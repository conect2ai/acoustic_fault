#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.34690583f, 1.11188269f, -0.67301309f, 0.09557804f, 0.31715390f, -0.69147044f, 0.16110517f, -0.04648632f, 
    0.54492003f, 1.07436311f, -1.19482398f, -0.04640434f, 1.03690135f, 0.44077688f, 0.64448255f, -0.22403212f, 
    0.57074344f, -0.48797426f, -0.66737610f, -1.05303788f, -1.14928865f, -0.38368469f, 0.85918504f, -0.63682735f, 
    0.40855306f, 0.11803549f, 0.14074433f, 0.22329171f, 0.69374293f, 1.06062806f, -1.54621053f, -0.46312416f, 
    -0.61017090f, -0.09049161f, 0.72440344f, -0.53953803f, -1.42673993f, 0.53001434f, 0.03704161f, -0.07866479f, 
    1.56442702f, -0.44164455f, -0.61951971f, 0.27489239f, 0.58249140f, 0.45692110f, -0.64238960f, -1.02602613f, 
    -0.98958606f, 0.58186197f, 1.07976091f, 0.06233624f, -0.32760841f, -0.00948794f, -1.37478983f, 0.66804999f, 
    0.36810359f, 0.84461337f, 0.95854074f, 0.94511473f, 0.29452074f, -0.30653629f, -0.66498899f, -1.05621421f, 
    -1.05061066f, 1.31682837f, 0.94496429f, 0.12280186f, 0.09434834f, 0.10024966f, 0.20007661f, 0.25000241f, 
    0.73261869f, -0.43911791f, -0.83745611f, 1.16319501f, 0.69494164f, -0.49342594f, -0.05681826f, -0.21550728f, 
    0.48979303f, 1.06801033f, 1.14021063f, 1.22091877f, 0.42163807f, -0.21759927f, 0.47753158f, 0.44895163f, 
    0.80983788f, -0.05708992f, -0.17420097f, -1.21612501f, 0.31971806f, -0.81088811f, -1.08909369f, -0.56294578f, 
    -0.20866075f, -0.45436737f, -0.31937811f, -0.82135153f, -0.58407891f, -0.78509784f, -0.48364875f, -0.28762698f, 
    0.75846994f, 0.02985141f, 0.55122322f, 0.57580042f, 1.34793127f, 0.75303638f, 0.25786531f, 0.03898006f, 
    0.66245806f, -0.46405461f, -0.22874050f, 0.19318511f, -0.59169865f, 0.56558090f, -0.75512391f, -0.64420545f, 
    -1.11834550f, -0.38517129f, 0.11842001f, 0.10716313f, 0.11594793f, 0.70887917f, -1.06539118f, -0.97216684f, 
    0.74193835f, -0.25914690f, -0.82740480f, 0.10956234f, 0.01089172f, 0.00402956f, -0.51796556f, -0.98779219f, 
    0.95368969f, 0.95677668f, 0.59815180f, -0.31480089f, 0.64662057f, -0.72308189f, -0.51346296f, -0.26002246f, 
    -0.43084168f, -1.32385361f, -0.74635398f, -0.25700742f, 1.00557137f, -0.05592106f, -0.54867327f, -0.42247647f, 
    -0.43481010f, 0.21771531f, 0.02957494f, -1.21030009f, 0.24225980f, -1.40125740f, 0.21883431f, 0.12490844f, 
    -0.31786022f, -0.24384537f, 0.93396944f, -0.50052750f, 1.15460122f, 1.05523694f, -0.01177584f, -0.32887778f, 
    -0.05710897f, -0.34420517f, 0.12197854f, -1.26714659f, 0.27583429f, -0.20351407f, -0.80726957f, 0.43476138f, 
    0.56569982f, -0.24564788f, 0.47903931f, 0.65362191f, 0.05614974f, -0.81154352f, -0.73350030f, -0.24601059f, 
    -0.90085083f, -1.22285426f, -0.17930804f, -0.08708577f, 0.25109717f, 0.94243944f, 0.43482184f, 0.77686524f, 
    -0.65709740f, -1.30274117f, -0.69140023f, 0.81332749f, 0.34634700f, -0.03959154f, 0.86708724f, -1.26678872f, 
    0.37870631f, 0.07252095f, -0.97990483f, -0.22948654f, -0.26790634f, 0.64296675f, -0.27589539f, -1.16800725f, 
    1.37179291f, -0.95408171f, 0.24936609f, 0.28261361f, -1.05818260f, -0.03269216f, -0.31888345f, -0.36963776f, 
    1.17639673f, 0.93274957f, 0.28849798f, -0.30346003f, -0.43461937f, -0.15633215f, -0.80082798f, -0.73669666f, 
    -0.13408710f, -0.85279071f, -1.47728777f, -0.53698623f, 0.28748253f, 0.90728176f, 0.76708204f, -0.14540362f, 
    -0.07429340f, -0.09300265f, 0.66299713f, 0.91666698f, 0.09815186f, 0.96500927f, 0.93591636f, 0.30084214f, 
    0.04984561f, -0.32473326f, -0.11776365f, -0.76342273f, -0.81126195f, -0.31278428f, -0.61138803f, -0.48636708f, 
    -0.18344499f, 0.97320539f, 0.55360579f, -0.57419914f, 1.18748641f, -0.54438394f, -0.46964365f, -0.82064766f, 
    -0.93774962f, 0.14219476f, 0.09278807f, -0.05505357f, -0.38275015f, 1.33118677f, -0.97762823f, 1.01370811f, 
    -0.23454636f, -0.06859344f, -0.25292650f, 0.24486874f, 0.41929963f, -0.26440483f, -0.85500205f, 0.66105735f, 
    0.98467463f, 1.16298985f, -0.40530545f, -0.93372673f, -0.55561620f, 0.08930008f, -0.18730539f, -0.68331754f, 
    1.38567829f, 0.99714547f, -0.40228906f, -0.48081863f, 0.62680709f, -0.26157507f, 0.04478522f, 0.26850986f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.21550272f, 0.06770143f, 0.36665028f, 0.30432373f, 0.00559799f, 0.01661026f, 0.10550015f, 0.21855755f, 
    0.41035119f, 0.27075726f, 0.43603817f, 0.03035850f, 0.43393835f, 0.25362307f, 0.53299260f, 0.07272468f, 
    0.10300867f, 0.23619603f, 0.25956330f, 0.44233537f, 0.20365201f, 0.20806462f, 0.17924838f, -0.21952336f, 
    0.02207563f, 0.38816383f, 0.21183465f, 0.07802543f, -0.04837594f, 0.26954627f, 0.00743077f, 0.10853442f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01393703f, 0.15937546f, 0.08662145f, -0.32839486f, 0.42672086f, -0.25990516f, 0.00235522f, 0.06185451f, 
    0.16499712f, 0.04950860f, -0.00395789f, -0.01279233f, 0.08204240f, -0.05269247f, -0.19178830f, 0.07053627f, 
    -0.08941963f, 0.07132614f, 0.01915077f, -0.09009605f, 0.22562179f, 0.18257254f, -0.11719208f, -0.14878857f, 
    -0.12641825f, 0.09951339f, 0.10075727f, -0.10022994f, 0.01129864f, -0.06734721f, -0.13779479f, 0.05828150f, 
    0.14817363f, -0.05474357f, 0.02914415f, 0.08722916f, 0.09201730f, 0.03770104f, -0.06971785f, 0.04852864f, 
    -0.06951221f, 0.02089234f, -0.14082392f, -0.02483076f, -0.22317946f, -0.02383351f, -0.14241599f, 0.05973372f, 
    0.06550699f, -0.03949386f, -0.01546039f, 0.12572163f, -0.08705414f, -0.05458389f, 0.12924804f, -0.01017360f, 
    -0.04052198f, 0.05869856f, -0.08530518f, -0.00895743f, 0.13279948f, -0.02049892f, -0.05086114f, 0.09302074f, 
    0.06742574f, -0.09295993f, -0.05127782f, -0.16744171f, 0.05698696f, 0.01653299f, -0.02418118f, 0.04945353f, 
    0.00886025f, -0.08797749f, 0.00596128f, -0.00174535f, 0.02973827f, -0.06156088f, 0.05448670f, -0.09626301f, 
    0.54795867f, 0.18294771f, 0.25547749f, -0.25985271f, -0.12467600f, -0.02490587f, 0.07864711f, -0.02150594f, 
    0.01838822f, -0.05505140f, 0.07486159f, 0.00300120f, -0.07549084f, -0.01734993f, -0.03949079f, -0.04681245f, 
    -0.03881234f, 0.08255140f, 0.12706961f, 0.04208003f, -0.45042631f, 0.40569285f, -0.14243379f, -0.04729808f, 
    -0.07130624f, -0.02978340f, 0.06473451f, -0.02606331f, -0.11366203f, 0.10086066f, 0.06194784f, -0.11472197f, 
    0.07468499f, 0.03037453f, -0.01654073f, -0.01630931f, -0.04308987f, -0.08933876f, -0.04227767f, 0.01221764f, 
    0.20748693f, 0.07258204f, 0.32335883f, -0.07028417f, 0.08293457f, 0.06297593f, 0.02873006f, 0.14099585f, 
    0.01280382f, 0.01534114f, -0.10319919f, -0.11510704f, 0.03627956f, -0.17566706f, 0.04342506f, 0.01311732f, 
    0.06126049f, -0.15067142f, 0.08422610f, -0.03098952f, -0.58484763f, -0.07457866f, 0.25797540f, 0.11865102f, 
    -0.26201707f, -0.02935466f, 0.04052038f, 0.00521815f, 0.02287018f, 0.03584614f, -0.07130123f, -0.00194669f, 
    0.10160729f, -0.13481963f, 0.09754679f, -0.05122837f, 0.08880804f, 0.03426721f, -0.02538658f, 0.01562587f, 
    -0.07074590f, 0.02965982f, -0.03036761f, -0.09864163f, 0.14963675f, -0.13513720f, 0.00340065f, 0.02420953f, 
    -0.04223762f, -0.10344964f, 0.00082555f, 0.10953977f, 0.00688206f, -0.01251010f, 0.00749066f, 0.05632035f, 
    0.06116967f, 0.00267387f, -0.08648259f, 0.05724730f, 0.05744341f, 0.10166960f, -0.04262428f, -0.15563357f, 
    0.10547116f, -0.03286934f, -0.14302546f, -0.03768791f, 0.02129417f, -0.03044841f, -0.01144134f, -0.02488733f, 
    0.03384697f, 0.07432908f, -0.05742219f, -0.04002723f, -0.05011182f, -0.09020437f, -0.05305408f, 0.05532553f, 
    0.10872720f, -0.52890313f, 0.01815305f, 0.19404642f, -0.14754516f, -0.01019196f, -0.03503448f, -0.04911287f, 
    0.07815342f, 0.00549496f, -0.08366803f, -0.02400201f, -0.16868104f, 0.03665851f, 0.00662107f, 0.04286138f, 
    -0.01271648f, 0.02794854f, 0.00038593f, -0.03813341f, -0.25213107f, -0.14911927f, -0.16328010f, -0.06699011f, 
    -0.18805936f, 0.00598783f, -0.11041822f, -0.08017053f, 0.06496847f, -0.13297883f, 0.07451990f, 0.00561434f, 
    0.02592972f, 0.04979911f, -0.02146397f, 0.00787365f, -0.08117588f, 0.06107973f, -0.02596754f, -0.14155546f, 
    0.18408825f, 0.08303139f, 0.05906843f, -0.16249061f, 0.23457193f, -0.14379451f, -0.16386120f, -0.05194589f, 
    0.05012852f, 0.10781768f, -0.01732376f, 0.08489733f, 0.00321402f, -0.04912050f, -0.01444543f, 0.03070518f, 
    -0.00941876f, 0.01159062f, 0.03113287f, 0.01819856f, -0.14569569f, -0.41737503f, 0.02406304f, 0.09934162f, 
    -0.24275540f, 0.10403486f, 0.01214930f, 0.10351268f, 0.04586297f, 0.00705803f, -0.04765300f, -0.00238621f, 
    0.02452916f, 0.01407970f, 0.00843648f, -0.07775068f, -0.14056519f, -0.06777924f, 0.02653078f, 0.01145828f, 
    -0.32572180f, -0.12375919f, -0.26112780f, 0.13084786f, -0.15787521f, 0.03115732f, 0.02631358f, -0.04335815f, 
    0.08709613f, 0.02222195f, 0.05781852f, -0.01752001f, -0.03202282f, -0.02876345f, -0.02267676f, -0.08234601f, 
    -0.09484539f, 0.01677694f, 0.00513885f, 0.07323634f, -0.12779400f, 0.19526495f, 0.18208466f, 0.22646184f, 
    0.13992774f, -0.10639951f, -0.02295041f, 0.05812496f, -0.02779098f, 0.06118253f, 0.06653961f, -0.06036348f, 
    -0.06698152f, -0.05754824f, 0.05689383f, 0.05429895f, -0.01675512f, -0.07486221f, 0.03961441f, 0.06814695f, 
    -0.14310579f, 0.03716350f, 0.00365854f, -0.12264462f, -0.55982482f, 0.00207494f, 0.10017201f, 0.08880518f, 
    -0.12818433f, -0.01877340f, 0.05927389f, 0.05892621f, 0.02563480f, 0.01778720f, 0.01117355f, -0.07232211f, 
    0.01690923f, 0.09018378f, -0.04159354f, 0.07036281f, 0.28793013f, -0.46808454f, 0.17167695f, 0.15098740f, 
    0.02088762f, -0.09442638f, 0.09386952f, -0.04112254f, 0.08199435f, -0.00558889f, 0.00018420f, -0.12684076f, 
    -0.03427331f, -0.07971684f, -0.03518018f, 0.03392944f, -0.08718083f, 0.14191048f, -0.14819440f, -0.05037360f, 
    0.15808094f, -0.12723036f, 0.11989386f, 0.07399779f, -0.11802837f, -0.08366617f, -0.21269473f, -0.01520440f, 
    0.00936265f, -0.08316623f, -0.11484308f, 0.02124441f, -0.15251639f, 0.09291352f, 0.00655173f, 0.01535510f, 
    0.00311775f, 0.10762497f, -0.07075071f, -0.01131767f, -0.10793621f, 0.12731977f, -0.10184382f, 0.00135242f, 
    -0.03294594f, 0.05454229f, -0.09728990f, -0.04588392f, 0.11324801f, -0.10129064f, 0.06371781f, -0.01390071f, 
    0.03482474f, 0.03998984f, 0.03394042f, -0.01982177f, -0.01665472f, 0.09444878f, -0.00250140f, -0.09322344f, 
    -0.19642119f, -0.64140773f, 0.29421699f, 0.17618927f, 0.01269950f, 0.07498609f, -0.00985143f, 0.01889029f, 
    -0.00633909f, 0.06544967f, 0.01366106f, -0.09465445f, -0.05348459f, 0.09982929f, -0.06698170f, 0.04159438f, 
    -0.00556275f, 0.04416740f, -0.06473974f, -0.13137923f, 0.20413710f, 0.00586276f, 0.02896740f, -0.00377461f, 
    0.02108573f, -0.11560581f, -0.03786380f, -0.00840801f, 0.04584169f, -0.07585902f, 0.04459377f, -0.05317489f, 
    -0.01376283f, -0.01490200f, -0.04042489f, 0.03506790f, -0.04996606f, 0.08227164f, 0.10373695f, -0.00041641f, 
    0.16756126f, -0.41186231f, 0.24375933f, -0.01109721f, -0.53401929f, 0.00240113f, 0.05658402f, 0.09683795f, 
    -0.03778781f, 0.03208107f, -0.19798687f, 0.09252059f, 0.00247184f, 0.05718173f, 0.01773948f, -0.00408815f, 
    -0.03990669f, 0.03964983f, 0.01550080f, -0.10589617f, 0.61625284f, 0.04208757f, 0.17804426f, -0.13205458f, 
    0.20654888f, -0.00323838f, -0.12862584f, 0.08234836f, -0.07671283f, 0.00255187f, 0.05148632f, 0.16803116f, 
    -0.08068267f, -0.04900919f, 0.06879186f, -0.01977588f, -0.03027241f, 0.19316584f, -0.11164929f, -0.14789960f, 
    0.28793439f, 0.09297839f, 0.03511865f, -0.03829709f, 0.26542887f, -0.04274518f, -0.26549900f, -0.10534096f, 
    0.07223623f, 0.05975402f, -0.05020669f, 0.02704400f, -0.00332416f, 0.01063892f, 0.04420043f, 0.20405863f, 
    0.10372867f, -0.09153346f, 0.07020474f, 0.05265937f, -0.09033567f, 0.17284892f, 0.04652958f, -0.26779127f, 
    -0.50737464f, 0.14454401f, 0.01738056f, -0.04761874f, 0.15264174f, -0.05661941f, 0.00300164f, -0.08712025f, 
    -0.03812052f, -0.03190496f, -0.02307274f, 0.04793248f, 0.04052439f, -0.01570017f, 0.00593948f, 0.06914110f, 
    0.02514040f, 0.00609460f, 0.09622500f, -0.15447012f, 0.25393218f, -0.27830428f, -0.08565835f, 0.14988552f, 
    0.04381892f, -0.10483041f, 0.03403225f, -0.02553603f, -0.13519715f, 0.04174365f, -0.01786670f, -0.04492684f, 
    -0.00193390f, 0.01367804f, -0.04335177f, 0.08907890f, -0.33659172f, -0.48685041f, -0.32773167f, 0.19758284f, 
    -0.06664500f, -0.09458697f, -0.08411240f, -0.00415812f, 0.02507175f, 0.03349074f, 0.04894876f, -0.04802138f, 
    -0.02913878f, -0.10461416f, -0.01496185f, 0.10284927f, 0.08747003f, -0.09753383f, 0.11447588f, -0.03853741f, 
    0.22652599f, -0.37211606f, 0.12113236f, 0.17985885f, 0.06705752f, -0.02278335f, -0.00314840f, -0.09494945f, 
    -0.03110866f, -0.02065986f, -0.15325750f, -0.09234741f, 0.06513780f, 0.05606481f, 0.03169874f, -0.09292863f, 
    -0.00425001f, -0.00800729f, 0.20691694f, 0.07723632f, 0.27903485f, -0.05537042f, 0.07244773f, -0.04069864f, 
    -0.45573720f, -0.11029755f, -0.14542140f, 0.03602652f, -0.00476095f, -0.07501893f, -0.13760379f, 0.18599606f, 
    -0.08658489f, 0.07739902f, -0.04234782f, -0.05118180f, -0.20291509f, 0.05855327f, 0.01914371f, 0.05126466f, 
    -0.32898015f, 0.04914934f, 0.24676724f, 0.12834723f, -0.04928981f, 0.04884398f, -0.28278515f, 0.07454895f, 
    -0.18627678f, 0.03385350f, -0.12746310f, 0.04493759f, -0.14312099f, 0.09246521f, -0.09434959f, 0.00663148f, 
    -0.11056499f, 0.01944765f, -0.16780724f, -0.12131169f, -0.49744475f, 0.31195900f, 0.05699645f, 0.08746327f, 
    0.34743378f, -0.00416191f, -0.17385998f, 0.04360874f, -0.07748134f, -0.01698644f, -0.00893235f, -0.07709099f, 
    0.00471429f, -0.01571809f, 0.01106393f, -0.03005429f, 0.01229602f, -0.05332031f, -0.01832655f, 0.05207090f, 
    0.46083823f, -0.20261499f, 0.30736774f, -0.18870582f, 0.03888081f, -0.05474515f, -0.26816791f, -0.04514783f, 
    0.01922070f, 0.00833084f, -0.09113299f, -0.00533442f, 0.05370057f, 0.01415670f, 0.17293423f, -0.19208640f, 
    -0.02188499f, -0.12554060f, -0.09002659f, 0.01708993f, 0.41896415f, -0.46172929f, 0.13982125f, -0.09975921f, 
    -0.07293887f, -0.02305160f, 0.14462443f, -0.08714291f, 0.03317269f, 0.06675065f, 0.15868253f, -0.09000995f, 
    -0.04743069f, 0.03360545f, -0.24253733f, 0.07150833f, 0.06528363f, -0.06811072f, 0.06806812f, 0.08089538f, 
    0.33043578f, -0.05553798f, -0.24045289f, 0.12559663f, -0.08188724f, 0.07481312f, 0.01835067f, 0.05119308f, 
    0.07127170f, 0.13681446f, 0.04985334f, -0.03744102f, 0.01955408f, 0.09190855f, 0.14088747f, 0.23161137f, 
    0.07841904f, -0.00572685f, -0.09386478f, 0.01472496f, -0.23247761f, 0.05623170f, -0.28755614f, 0.09633333f, 
    -0.04400234f, 0.10163669f, -0.01950911f, 0.03446602f, 0.04969506f, 0.05755798f, -0.02400523f, -0.08100025f, 
    0.00369117f, 0.05813735f, -0.06698767f, -0.01867851f, 0.07459042f, 0.00160426f, -0.14133941f, 0.06672383f, 
    -0.59854251f, 0.18900006f, -0.16363086f, -0.17308445f, 0.14586906f, -0.08755979f, 0.15192391f, -0.10877715f, 
    -0.02750134f, 0.06627923f, -0.02395538f, 0.00692725f, 0.14362493f, -0.08079596f, -0.09958812f, 0.01614115f, 
    -0.04159834f, 0.05583271f, -0.04592435f, -0.09527696f, 0.30825588f, -0.58917350f, 0.07002895f, -0.00644132f, 
    0.03551607f, -0.19658375f, -0.00365471f, -0.10266165f, 0.05189091f, -0.07619092f, -0.02784245f, -0.04407607f, 
    -0.08973419f, 0.07560907f, -0.01552168f, -0.03326783f, -0.13371681f, 0.07354882f, 0.02984777f, 0.00796603f, 
    -0.52026564f, 0.14710526f, -0.06845624f, 0.00277527f, 0.08058392f, -0.08664481f, 0.13048111f, -0.11297857f, 
    -0.05165811f, 0.04985280f, 0.17856495f, 0.11066134f, 0.02599648f, -0.02396259f, -0.00600235f, 0.02758843f, 
    -0.08516648f, 0.10007039f, -0.01945795f, 0.08910336f, -0.12324398f, 0.20192637f, 0.01039296f, 0.07515896f, 
    -0.36828485f, -0.10668427f, 0.03380277f, -0.01980465f, 0.04147505f, 0.08017069f, -0.01478491f, -0.01459122f, 
    -0.12313368f, 0.01978291f, 0.06033423f, 0.01600743f, 0.05135097f, -0.01773819f, 0.00248683f, 0.05579915f, 
    0.08596743f, -0.40753034f, 0.01521426f, -0.05562019f, -0.16049004f, 0.21006538f, -0.01733527f, -0.11609521f, 
    0.04905476f, 0.03959615f, -0.06941737f, 0.03938523f, -0.03338042f, -0.04136046f, -0.05097363f, 0.03996483f, 
    -0.00976356f, -0.15190144f, 0.06145267f, -0.06258623f, 0.07476895f, 0.21022016f, 0.19763273f, 0.17152591f, 
    0.26942217f, -0.16795237f, -0.09354592f, -0.00847212f, -0.03221666f, 0.10880097f, -0.05903143f, 0.00036674f, 
    0.05624035f, -0.02967198f, -0.06047971f, 0.01842179f, 0.09959876f, -0.00393572f, -0.02331105f, 0.04358198f, 
    -0.32449743f, 0.15922566f, -0.01872122f, -0.11599190f, -0.31669033f, -0.02096615f, 0.10051520f, 0.05107833f, 
    0.01796607f, -0.06400307f, -0.03365453f, -0.02557373f, 0.10947873f, 0.07848438f, 0.04626857f, -0.12129565f, 
    0.09290244f, -0.15178160f, -0.08990110f, -0.06121794f, 0.01369607f, 0.05086094f, 0.08173345f, -0.00165454f, 
    -0.06642859f, 0.02190787f, -0.08792135f, 0.04614807f, 0.09680980f, -0.06708130f, -0.05216111f, -0.15260252f, 
    0.13707906f, -0.05801409f, -0.08117159f, 0.11281336f, 0.04741753f, -0.10332265f, 0.07792533f, 0.03364104f, 
    0.32862991f, 0.11765884f, 0.20153084f, 0.03885207f, 0.27603790f, -0.06271108f, -0.15249659f, 0.01818506f, 
    -0.01363102f, 0.00949892f, -0.05587735f, -0.07328197f, -0.03911357f, 0.13518825f, -0.04202574f, -0.04347730f, 
    0.20047176f, -0.00196305f, 0.05003868f, 0.02605434f, -0.07614162f, -0.40810499f, -0.03674721f, -0.04078919f, 
    0.01174705f, 0.04556270f, 0.00486174f, -0.00621288f, 0.14179215f, 0.05617575f, -0.09133548f, 0.04354366f, 
    -0.06559771f, -0.03210186f, 0.11810171f, 0.00493298f, -0.13149604f, 0.10031242f, -0.04334415f, -0.21594483f, 
    -0.04234729f, 0.13544206f, -0.05358837f, 0.00727613f, -0.53958297f, 0.03999992f, 0.01958586f, -0.00114665f, 
    0.11583218f, -0.00946932f, -0.08718493f, 0.05109316f, -0.05662021f, 0.08012655f, -0.02709599f, 0.01210476f, 
    0.10017945f, -0.01162674f, -0.20810598f, -0.08570886f, 0.10981894f, 0.10549243f, -0.22367522f, -0.10055047f, 
    0.15088332f, 0.07680710f, 0.07851712f, 0.03846119f, -0.18559998f, -0.02511540f, -0.01428895f, 0.07803388f, 
    0.08845040f, 0.03615198f, 0.01319438f, 0.13567290f, -0.08548602f, 0.14975928f, 0.07003244f, -0.07214461f, 
    0.25396377f, -0.21601912f, -0.23451050f, -0.10161126f, -0.28149360f, -0.02003673f, -0.18192792f, -0.05824747f, 
    -0.00247826f, 0.09532983f, 0.06789752f, 0.05329712f, -0.16515343f, 0.00880037f, 0.06399260f, 0.03289006f, 
    0.02999813f, -0.07221069f, -0.09388353f, 0.09015177f, -0.34277490f, 0.07134706f, 0.00168034f, -0.31775117f, 
    0.16602109f, 0.02043120f, -0.06854583f, 0.02505229f, -0.03668950f, 0.02664837f, 0.18296048f, -0.05526344f, 
    -0.07232200f, -0.02906543f, -0.01887104f, -0.09545883f, -0.02134703f, -0.09508473f, 0.14978880f, -0.06065407f, 
    0.08721177f, -0.03101926f, 0.22634736f, -0.02578747f, -0.05723791f, -0.06528276f, 0.05140118f, 0.05829426f, 
    -0.06669703f, 0.14803153f, 0.08577985f, 0.01341397f, 0.16337009f, -0.11091740f, 0.11940115f, -0.07313280f, 
    0.05941348f, -0.09370921f, 0.08476075f, 0.14973898f, -0.14748374f, 0.20511478f, -0.07554471f, -0.15546195f, 
    -0.06011821f, 0.05290234f, 0.04762084f, -0.09520537f, -0.00303411f, -0.02385703f, -0.02262987f, -0.15462404f, 
    0.02266288f, -0.08277237f, 0.01976533f, -0.00024413f, -0.03620967f, -0.01037047f, 0.00442347f, 0.11439196f, 
    -0.07872778f, -0.02102761f, -0.04175024f, -0.14560428f, 0.03268628f, 0.06448130f, -0.01572207f, 0.16386324f, 
    -0.00637776f, -0.04822446f, -0.08626240f, -0.15196572f, 0.13267449f, 0.00691862f, 0.07921977f, -0.12811710f, 
    -0.00090001f, -0.29152167f, -0.12001829f, -0.02808606f, -0.06217174f, -0.06009589f, 0.08075627f, -0.04937961f, 
    -0.00355750f, 0.09942725f, 0.01343168f, 0.07651174f, -0.01995319f, -0.09851943f, -0.02208231f, 0.07456823f, 
    0.13641274f, 0.08786911f, -0.02879605f, 0.01876291f, -0.01260476f, -0.12067826f, -0.06062704f, -0.09075392f, 
    0.10819810f, 0.06525312f, 0.18543977f, -0.18417001f, -0.04987615f, -0.02089589f, 0.18915264f, 0.02586984f, 
    0.04464946f, -0.07747787f, 0.09113937f, -0.06771421f, 0.05525402f, -0.08839436f, 0.07404961f, -0.11517432f, 
    -0.00326783f, -0.11841267f, 0.02200514f, 0.18357332f, -0.71804982f, -0.24638420f, -0.59406775f, -0.43185160f, 
    0.22841826f, 0.09732019f, -0.10788484f, -0.09593064f, -0.04847170f, 0.11138158f, 0.07631543f, -0.06859489f, 
    0.01353655f, -0.17955649f, 0.14705518f, 0.00594277f, -0.06988247f, -0.18975198f, -0.05713017f, -0.12271928f, 
    0.32753375f, -0.13401948f, 0.13504036f, 0.03742874f, 0.14390533f, -0.11187327f, -0.14793153f, 0.13524880f, 
    0.06449471f, 0.02027110f, -0.02089878f, -0.21169096f, -0.14928997f, -0.08423809f, -0.18082722f, 0.06640361f, 
    -0.06006074f, -0.07931090f, 0.04689444f, -0.04855443f, 0.29635489f, 0.04479004f, -0.21814480f, 0.05255001f, 
    -0.33092314f, -0.06761901f, 0.03543681f, -0.01076356f, -0.08325163f, 0.03148878f, 0.05959016f, 0.05743075f, 
    -0.07423554f, 0.04618575f, 0.01867859f, 0.09007165f, 0.04935841f, 0.03769650f, -0.06748880f, -0.02497497f, 
    0.19532813f, 0.17274097f, 0.19022994f, 0.06277144f, 0.22604246f, -0.11880306f, 0.02828354f, -0.12738137f, 
    0.01524924f, -0.03426601f, -0.06708012f, 0.03827031f, 0.04257508f, 0.01518390f, -0.00539945f, 0.01726616f, 
    0.04075225f, -0.00508879f, 0.06713444f, 0.00146056f, 0.06455482f, 0.05487844f, -0.22313593f, 0.05035577f, 
    -0.20586349f, 0.08696709f, 0.04591819f, -0.10009047f, 0.13069950f, -0.02140792f, -0.10369562f, -0.18525152f, 
    0.00988500f, 0.07844809f, -0.18339622f, -0.01617131f, 0.10382362f, -0.01798501f, -0.12578008f, -0.09370837f, 
    0.10816052f, -0.15662274f, 0.05071452f, -0.05991111f, -0.02706365f, -0.03877686f, 0.00735160f, 0.07351438f, 
    0.08376007f, -0.06577414f, -0.02779001f, 0.10566309f, -0.07265304f, 0.12558587f, -0.16565947f, 0.06845576f, 
    -0.24036464f, -0.03881717f, -0.10073167f, -0.13977537f, 0.20011389f, -0.06570406f, 0.12941751f, -0.00431301f, 
    -0.04109612f, -0.08198423f, 0.03531596f, 0.01475097f, -0.03867436f, 0.07287975f, 0.12853284f, 0.00325678f, 
    0.02161739f, -0.05799530f, 0.02043102f, -0.02159725f, 0.03656007f, -0.10152812f, -0.03439492f, 0.07621174f, 
    0.03508433f, -0.09048905f, -0.08038682f, -0.02559857f, 0.20639588f, -0.09930972f, 0.04482552f, 0.00740817f, 
    -0.16350542f, 0.07467847f, -0.00072050f, 0.02553584f, 0.09466336f, -0.07910763f, -0.05163774f, 0.04864001f, 
    -0.06668262f, -0.05731614f, 0.08681126f, 0.13832133f, 0.22678913f, 0.06712722f, -0.30425420f, -0.20881598f, 
    0.12902182f, 0.06867278f, 0.11828736f, -0.04121486f, -0.14268892f, 0.00949688f, -0.10753962f, -0.04876911f, 
    0.08229755f, 0.09680840f, 0.13092174f, 0.01053652f, -0.01208196f, 0.05766764f, -0.01125920f, -0.00744498f, 
    0.19107880f, -0.01191731f, 0.04222023f, -0.30262989f, -0.08829326f, 0.13673003f, -0.15207875f, 0.12924011f, 
    -0.03821724f, -0.01349585f, -0.09538407f, 0.06243909f, 0.02129734f, -0.04604566f, 0.01116484f, 0.01548173f, 
    -0.08723142f, 0.13950974f, -0.00322069f, -0.04032882f, -0.15572113f, 0.08610649f, 0.20800626f, 0.02292463f, 
    0.06963500f, -0.04332516f, -0.08199271f, 0.04117324f, 0.12015637f, 0.05953184f, 0.04826693f, -0.04691489f, 
    0.05408652f, -0.02730525f, 0.04033943f, 0.00143886f, 0.02189857f, -0.09484865f, 0.00538467f, 0.00358494f, 
    0.35292840f, -0.24581325f, 0.22828713f, -0.08073214f, 0.00894556f, -0.14930709f, 0.03841837f, -0.12486481f, 
    0.00955056f, 0.04262873f, 0.02373629f, -0.04833043f, 0.00977456f, 0.00777643f, -0.00606595f, 0.05411624f, 
    0.00662494f, 0.08490769f, 0.06918444f, -0.01328302f, 0.14465104f, 0.22164141f, -0.07976774f, -0.08289641f, 
    -0.05222182f, 0.05511296f, 0.08961489f, -0.03810638f, -0.09320382f, -0.07589251f, -0.01525667f, -0.04070277f, 
    0.01639504f, -0.11352074f, -0.03347677f, 0.00701790f, 0.15451828f, -0.11184660f, -0.00531181f, -0.04731502f, 
    0.43432355f, -0.04438974f, -0.07258840f, -0.12059701f, 0.03307001f, 0.08131966f, -0.09607501f, -0.13758102f, 
    0.01385114f, 0.05815192f, 0.07658280f, 0.04340221f, 0.08427498f, 0.04705507f, -0.01412886f, 0.00218004f, 
    0.00484469f, -0.06564502f, -0.04942826f, -0.04831174f, 0.51890069f, 0.13120309f, -0.08681680f, 0.34331939f, 
    -0.30688602f, -0.01549369f, -0.17603557f, 0.11281932f, 0.09287878f, 0.17414190f, -0.01859793f, 0.05976486f, 
    0.07949460f, 0.06567653f, -0.01968637f, -0.00163590f, -0.08314470f, -0.09509184f, 0.05851060f, 0.01630699f, 
    0.38411403f, 0.08725159f, 0.03395650f, 0.01477313f, 0.19521728f, -0.05218498f, -0.09865127f, 0.02642270f, 
    0.08006223f, 0.06347431f, -0.07414707f, -0.08734403f, 0.01925227f, -0.05821805f, 0.04759725f, 0.03195945f, 
    -0.17164075f, -0.18792552f, -0.14358917f, -0.09679794f, 0.27940080f, -0.11426331f, 0.11145657f, -0.04143027f, 
    -0.00914325f, -0.33982903f, 0.02512519f, -0.01505385f, -0.00330084f, -0.05884850f, 0.03169887f, -0.02534744f, 
    0.02804624f, -0.14732410f, 0.08500598f, 0.03002777f, 0.01762191f, 0.02539911f, 0.00891002f, 0.04418518f, 
    -0.00021952f, -0.04432951f, 0.22186768f, 0.00994488f, 0.00011880f, -0.06763110f, -0.22124453f, -0.06565481f, 
    0.06309296f, 0.02055302f, -0.06644443f, -0.09045117f, 0.00436586f, 0.03715869f, -0.01379418f, 0.00119987f, 
    -0.12381374f, 0.00661523f, -0.00783797f, 0.03381723f, -0.11849477f, 0.07167567f, 0.03874381f, -0.17126602f, 
    0.03395433f, -0.00494136f, 0.03019483f, 0.09583835f, -0.00803266f, -0.13318218f, -0.00027932f, 0.00419649f, 
    0.02607002f, 0.02359654f, 0.00777483f, 0.01624134f, -0.14317533f, -0.10481462f, -0.08335889f, -0.03369457f, 
    -0.11762624f, -0.22463143f, -0.16137189f, -0.09861092f, -0.28881910f, -0.11445886f, 0.07110982f, -0.13611752f, 
    0.02507733f, -0.03336751f, 0.01294549f, 0.00768867f, 0.01097439f, -0.01312452f, -0.08581292f, 0.01458068f, 
    -0.11254858f, -0.00273600f, 0.00556776f, -0.05861638f, 0.45705858f, -0.03082335f, -0.00005994f, 0.16581763f, 
    -0.12991908f, -0.03693045f, -0.12562573f, -0.06226068f, 0.00302174f, -0.05076661f, -0.02045090f, -0.04924347f, 
    0.02050330f, -0.12357334f, -0.04722138f, 0.07791661f, 0.03930426f, 0.10333540f, 0.08918952f, -0.04402573f, 
    0.02180715f, -0.11118729f, 0.08159558f, -0.19162871f, 0.04878896f, 0.18356736f, -0.02972323f, 0.04367518f, 
    0.04036800f, -0.02473096f, -0.01452273f, 0.01388885f, 0.05980874f, -0.05109302f, -0.03889019f, 0.02693116f, 
    -0.02206233f, -0.00553442f, -0.04499108f, -0.07562715f, 0.45317766f, 0.06971310f, -0.11189411f, 0.03157518f, 
    -0.48856747f, -0.04749525f, 0.09051477f, 0.06998742f, -0.09053754f, 0.08209923f, -0.02590361f, -0.07595197f, 
    -0.00956703f, -0.09711307f, -0.10627365f, -0.06174191f, 0.06837263f, 0.02271328f, 0.03687925f, 0.03261207f, 
    0.12006501f, -0.27073628f, -0.19900939f, -0.00556723f, -0.15752184f, -0.21699080f, -0.04731173f, 0.04364460f, 
    -0.03306955f, -0.02051869f, 0.04909771f, -0.04628249f, -0.02243829f, -0.00293529f, -0.00315621f, 0.05646586f, 
    -0.00400997f, -0.04822795f, 0.04013697f, 0.01364467f, 0.17400037f, 0.06191127f, -0.12159447f, -0.01706199f, 
    0.02521026f, -0.01656950f, 0.02901505f, 0.04917952f, 0.04415483f, 0.06961019f, -0.03281584f, 0.11112167f, 
    -0.00614990f, 0.05339501f, 0.01589274f, -0.08065804f, 0.07498139f, -0.17444433f, -0.05202221f, 0.01666937f, 
    0.28316274f, -0.19732505f, -0.03485320f, 0.12989527f, 0.18642947f, -0.16950800f, 0.01456373f, -0.11512169f, 
    0.01778104f, 0.07130555f, 0.03122285f, 0.03015054f, 0.01545091f, 0.14279215f, 0.00898043f, -0.03438270f, 
    -0.07191570f, 0.07585568f, -0.01870096f, -0.14771162f, -0.18786432f, -0.18500081f, -0.08697596f, 0.10252701f, 
    -0.30913204f, 0.03536135f, -0.15614752f, -0.05816371f, 0.04551354f, 0.02477694f, -0.03552860f, 0.00526364f, 
    -0.00424121f, -0.00536575f, -0.01829822f, 0.08440560f, -0.03660138f, 0.02299569f, -0.14419778f, -0.10270493f, 
    -0.15598974f, -0.15793198f, 0.05946417f, 0.03081667f, -0.00979683f, 0.07135563f, 0.10003228f, 0.01171897f, 
    0.04821375f, -0.06278790f, -0.08327410f, -0.10007005f, -0.04710294f, -0.05408892f, -0.02553101f, 0.03361261f, 
    -0.06547545f, 0.04130001f, -0.12661278f, 0.01414720f, 0.15492630f, 0.06600812f, -0.18230762f, 0.01116926f, 
    0.01309735f, -0.07315399f, -0.00437707f, -0.05315950f, -0.09290446f, -0.03694293f, 0.00449985f, -0.04395888f, 
    -0.05395970f, -0.07008193f, -0.14748013f, -0.00265918f, 0.05762448f, -0.07656968f, 0.10256214f, -0.04609323f, 
    -0.28613791f, -0.40960473f, -0.11885820f, -0.36782011f, -0.53559345f, 0.09338120f, -0.00008362f, -0.08364662f, 
    0.00045901f, 0.01143847f, 0.05381019f, 0.07254658f, 0.04167186f, -0.00370184f, 0.00204303f, -0.03948698f, 
    -0.06080625f, 0.17894949f, -0.04040201f, -0.08262674f, -0.17094387f, 0.22153553f, -0.02397651f, -0.06417473f, 
    0.04207588f, 0.01810475f, 0.10577271f, -0.01243902f, -0.02966486f, -0.12481410f, -0.03606852f, 0.09170571f, 
    -0.05610230f, -0.10163902f, -0.05306276f, 0.04918211f, 0.04059091f, -0.00473132f, -0.04080269f, 0.01485519f, 
    -0.64320564f, -0.05480842f, 0.00338997f, -0.28690770f, -0.00406006f, 0.02996858f, 0.13262631f, -0.03451531f, 
    0.06271911f, 0.01996702f, -0.05951997f, 0.00995027f, -0.01618246f, -0.05062150f, 0.03784035f, 0.02391020f, 
    0.05801511f, -0.01609555f, 0.04986024f, -0.04848865f, 0.07035311f, -0.18339182f, -0.33789471f, -0.29843575f, 
    -0.22002967f, 0.01543431f, -0.02927355f, 0.15052742f, -0.15883069f, -0.03507122f, -0.10350934f, -0.03565366f, 
    -0.04526669f, 0.05080181f, -0.05631949f, -0.03024954f, -0.09099142f, 0.07953118f, -0.00834101f, -0.09692982f, 
    -0.03619882f, -0.15019761f, -0.12743855f, -0.20939802f, -0.00651260f, 0.13516718f, -0.00159193f, 0.06286147f, 
    0.02113072f, -0.06487318f, -0.07203352f, 0.04785163f, -0.01173321f, -0.03623740f, -0.11142913f, -0.14413553f, 
    0.07237270f, 0.13571259f, -0.11434359f, -0.03129216f, 0.22097884f, 0.04162936f, 0.12403785f, 0.15729061f, 
    0.35112834f, -0.29913819f, -0.09391653f, -0.06921874f, 0.07019611f, 0.00690079f, 0.14475128f, -0.03525788f, 
    -0.10201579f, 0.00078887f, 0.00991318f, -0.06172533f, -0.07432419f, -0.04132027f, -0.00029611f, -0.01499623f, 
    0.21948762f, -0.18184376f, 0.19221050f, -0.15716113f, -0.02308470f, 0.12599695f, -0.16130896f, 0.08206766f, 
    0.03598579f, 0.03363951f, -0.03564822f, 0.01531122f, 0.07379542f, 0.04138102f, -0.09217522f, -0.05049200f, 
    -0.16776919f, 0.01315200f, -0.13548519f, -0.12212129f, 0.26931688f, -0.36502656f, 0.15000695f, 0.06497180f, 
    -0.17932524f, -0.12602106f, 0.10032669f, -0.10452384f, 0.02655187f, 0.02706328f, -0.02056282f, -0.01308455f, 
    0.01648911f, -0.03863134f, -0.01873932f, 0.13320890f, 0.00465051f, -0.08950555f, 0.06632777f, -0.03141835f, 
    -0.12812558f, 0.07719691f, -0.07076913f, -0.14074244f, -0.10563986f, 0.01919600f, 0.01820581f, 0.12244984f, 
    0.12512898f, 0.04103168f, 0.03065850f, 0.03726899f, 0.03009396f, -0.01077862f, -0.06230516f, 0.00498149f, 
    -0.02717226f, 0.05722858f, 0.17072454f, 0.02391570f, -0.50959289f, 0.18114924f, 0.00720469f, -0.16734102f, 
    0.07149274f, 0.03876475f, 0.09623513f, 0.03518758f, 0.12122766f, -0.05679681f, 0.03559659f, -0.02584907f, 
    0.04875371f, -0.11967105f, 0.01586468f, 0.07253716f, -0.01774937f, -0.01166266f, 0.07987542f, -0.03183110f, 
    0.22643551f, -0.24732378f, -0.07604009f, 0.02378098f, -0.08037238f, 0.02210737f, 0.10689078f, -0.01598042f, 
    -0.04875936f, 0.05078800f, 0.00550590f, 0.01331462f, -0.09173094f, 0.04302012f, 0.00350380f, 0.01429008f, 
    0.01806117f, 0.01270576f, -0.06564191f, -0.03884612f, 0.16336691f, 0.21055213f, -0.30701602f, 0.02755255f, 
    -0.14184909f, -0.06968609f, 0.12908691f, 0.06640343f, 0.01656124f, -0.11900254f, -0.09869322f, 0.03257172f, 
    -0.01943256f, 0.04181135f, -0.04081521f, 0.01769524f, 0.04093036f, -0.08444829f, 0.05651541f, 0.14081781f, 
    0.04627186f, -0.44283161f, -0.21619378f, -0.09938379f, 0.08038920f, -0.11416446f, 0.00671413f, 0.04898501f, 
    0.04451462f, 0.03377165f, -0.03009963f, -0.01771549f, -0.05098163f, 0.02171163f, -0.03645389f, -0.04684914f, 
    -0.00842491f, -0.02879061f, -0.01551253f, 0.04454460f, -0.07164070f, 0.09596182f, -0.28492600f, 0.03248866f, 
    -0.24882561f, -0.07724853f, 0.08857781f, -0.05042882f, -0.00546352f, 0.00115277f, -0.10068586f, 0.00864607f, 
    0.06917915f, 0.02059317f, -0.03794976f, 0.04981298f, -0.07745335f, -0.01268888f, -0.10623188f, 0.00155112f, 
    -0.02854954f, 0.06623738f, -0.05567602f, -0.01595831f, 0.01747041f, -0.08572720f, -0.13636039f, 0.05460759f, 
    0.00967069f, -0.00911386f, -0.06297597f, 0.05206173f, -0.07567271f, 0.01862734f, 0.01132031f, -0.03095833f, 
    0.02107461f, 0.04334307f, 0.04877576f, -0.00372321f, -0.34482792f, 0.30138668f, -0.11620700f, 0.23474059f, 
    0.26198763f, 0.13101538f, 0.05879489f, 0.02247556f, -0.05463253f, 0.05328043f, 0.02599289f, -0.05684881f, 
    -0.01974331f, -0.10563961f, -0.04624179f, -0.02522708f, 0.00767779f, -0.02437502f, 0.06373718f, -0.08797269f, 
    -0.37846491f, 0.47248170f, 0.03166720f, 0.11813941f, -0.09489752f, -0.03763586f, -0.08219210f, -0.08863773f, 
    0.10148818f, -0.08992351f, -0.05853228f, -0.07557243f, -0.14210078f, 0.00353769f, -0.10008016f, 0.03797128f, 
    -0.03046392f, -0.15868594f, 0.21146815f, -0.03779759f, 0.01791082f, -0.39573237f, 0.03758275f, 0.00487012f, 
    0.01130391f, -0.09350780f, -0.01713731f, 0.06282523f, -0.03630050f, 0.05743118f, -0.12997331f, 0.12717681f, 
    -0.13947229f, 0.04248660f, 0.10449869f, 0.00389858f, 0.00576142f, 0.03326696f, -0.04912394f, 0.03035067f, 
    -0.52983886f, 0.20234694f, 0.17064804f, -0.24741341f, -0.23068687f, -0.08646783f, -0.16695820f, -0.03875899f, 
    0.04047016f, -0.11411647f, -0.00085685f, -0.07148466f, -0.09363047f, 0.00028902f, 0.02933894f, 0.01966353f, 
    0.07103889f, -0.07754955f, 0.02561421f, 0.11620279f, 0.12162346f, -0.23628597f, 0.13572581f, -0.13381892f, 
    -0.02364515f, 0.09398273f, -0.07250793f, -0.03679661f, 0.07094665f, -0.08651769f, 0.05966758f, 0.06490840f, 
    -0.02065173f, 0.01781798f, -0.06351341f, -0.07047147f, 0.02022945f, -0.08063892f, -0.00996831f, -0.01602813f, 
    0.03581066f, 0.07093824f, -0.11657868f, -0.08442789f, -0.09322464f, -0.00667576f, 0.06318001f, 0.08756588f, 
    0.06437589f, -0.06843857f, -0.10076214f, -0.06575119f, -0.01422829f, 0.05372090f, -0.00815209f, -0.03766032f, 
    -0.01327506f, -0.04340280f, -0.04746157f, -0.05373141f, -0.36374602f, -0.81386185f, -0.28018010f, 0.02631146f, 
    0.01175070f, -0.10269437f, -0.12757254f, 0.01320433f, 0.03541322f, -0.16596332f, -0.09092573f, 0.07098406f, 
    -0.01168302f, -0.11270536f, 0.11424073f, -0.05213019f, -0.09838217f, -0.03216829f, -0.06884776f, -0.04480148f, 
    0.09571369f, 0.17108738f, 0.17377482f, 0.17600727f, 0.02936349f, -0.02143589f, 0.03481793f, -0.03613807f, 
    -0.04712626f, 0.03977823f, -0.04735149f, 0.03640661f, -0.09290502f, -0.09576254f, -0.07327864f, -0.06780972f, 
    0.04009456f, 0.04684231f, 0.07858658f, 0.06422739f, 0.07043982f, -0.08071353f, -0.02326258f, 0.03410782f, 
    -0.09694110f, -0.12275956f, -0.11071346f, 0.00027009f, -0.16011271f, 0.04474369f, -0.08746873f, -0.02603802f, 
    0.09389488f, 0.11397139f, 0.08591299f, 0.05430127f, 0.06578643f, -0.05196609f, -0.00573069f, -0.03904310f, 
    -0.21310398f, -0.22408466f, -0.33155978f, -0.12187210f, -0.01520705f, -0.11090531f, -0.06987657f, -0.06004972f, 
    0.03937256f, 0.07794733f, -0.06747308f, 0.02009573f, 0.05259205f, 0.10127505f, 0.04652969f, -0.02969679f, 
    0.01023205f, -0.00606993f, -0.02407540f, 0.06924336f, 0.13401583f, 0.10786393f, 0.12498508f, 0.06508165f, 
    -0.03558755f, -0.05143592f, -0.04756161f, -0.04747205f, -0.10573350f, -0.02805413f, 0.07696270f, -0.01285189f, 
    0.06480837f, -0.10181461f, 0.03146529f, 0.00459199f, 0.00106482f, 0.00456386f, -0.01600515f, 0.09433180f, 
    0.10149098f, 0.03746367f, 0.15591747f, -0.05829002f, 0.00143082f, -0.13264138f, -0.05278006f, -0.05960645f, 
    -0.03365215f, 0.02304323f, -0.02658712f, -0.03118963f, 0.08062849f, 0.04122601f, -0.00425274f, -0.08367371f, 
    0.05649604f, 0.03741337f, 0.06793538f, -0.04337142f, -0.12925909f, -0.08174670f, -0.14017244f, 0.04744846f, 
    0.06985103f, -0.07557198f, -0.10233118f, -0.05251425f, 0.07220358f, -0.09560821f, 0.01147545f, -0.01882723f, 
    0.02143855f, 0.08964934f, -0.00595606f, -0.00771626f, 0.07038308f, 0.01067327f, 0.02955843f, -0.00171934f, 
    -0.09085169f, -0.02281240f, -0.04550053f, 0.05041079f, -0.16358805f, -0.14825960f, -0.22357960f, 0.12223490f, 
    -0.02581105f, 0.07689817f, -0.06441870f, 0.01523406f, -0.03091228f, 0.01361466f, 0.07490031f, 0.08279334f, 
    -0.00154792f, 0.08594383f, 0.17527865f, 0.03244599f, 0.24213725f, 0.11325318f, -0.11508487f, 0.14284392f, 
    -0.01303722f, -0.06827948f, 0.05732702f, 0.05947503f, -0.10820726f, -0.01830526f, 0.02617629f, -0.01310223f, 
    -0.10510363f, -0.09379609f, 0.13550553f, -0.04244578f, 0.15161534f, 0.05638037f, -0.00961132f, 0.00832957f, 
    -0.26806301f, -0.31777775f, -0.23485756f, 0.08761940f, -0.04149363f, 0.02196421f, 0.02845676f, -0.02922432f, 
    0.01100479f, -0.15849446f, -0.02826220f, 0.01056216f, -0.05671442f, 0.05058720f, -0.03283923f, -0.02868825f, 
    0.12650283f, 0.03109490f, -0.00477610f, -0.03728864f, -0.29253396f, 0.23161173f, 0.05335182f, 0.00384912f, 
    -0.04179048f, -0.00776109f, -0.00616002f, -0.04695727f, -0.05925407f, 0.00810489f, -0.01622608f, 0.03583861f, 
    -0.04380356f, 0.10114248f, 0.02534510f, 0.02321671f, 0.00678100f, -0.07097458f, 0.06033619f, -0.06670496f, 
    0.26835713f, 0.21702754f, 0.13190529f, 0.07870280f, -0.01333009f, -0.04965842f, 0.05089625f, -0.04944389f, 
    -0.14640455f, -0.04468313f, -0.04497138f, 0.05791575f, -0.00286622f, -0.10414899f, -0.05903731f, 0.05842176f, 
    -0.02229734f, 0.08579472f, 0.02189503f, 0.06149475f, 0.02260102f, -0.22872719f, -0.22156586f, 0.24476226f, 
    0.20784621f, 0.06179960f, 0.16947304f, 0.07247106f, 0.05859734f, 0.01596986f, -0.05029218f, 0.09798900f, 
    0.00298547f, -0.27072039f, -0.06430973f, -0.02172930f, -0.03092624f, 0.07223658f, 0.01776149f, -0.12492562f, 
    0.02611155f, 0.18267770f, 0.06693519f, 0.22484240f, 0.08851810f, 0.03605886f, 0.09191503f, -0.03812054f, 
    0.02788981f, 0.08577740f, 0.07803980f, -0.06092083f, -0.12182510f, 0.05127979f, -0.07537633f, 0.02896103f, 
    -0.09263750f, 0.10159763f, 0.04087552f, 0.05196065f, 0.76365507f, 0.45214456f, -0.11040313f, 0.02012686f, 
    0.01434727f, -0.03353990f, 0.01031255f, -0.03742253f, 0.12615852f, 0.06948616f, -0.12980606f, -0.09911653f, 
    0.00619325f, 0.09468171f, 0.01459906f, -0.03374402f, 0.09057194f, -0.01339045f, 0.21759365f, 0.06907174f, 
    -0.13789725f, -0.46082357f, -0.15938586f, -0.05103893f, 0.12576550f, 0.02224272f, 0.07443722f, 0.01043776f, 
    -0.05529099f, 0.07559413f, 0.07032467f, -0.03959718f, -0.00554813f, 0.15282775f, 0.03358642f, 0.08819740f, 
    0.03251999f, 0.03686828f, -0.04095098f, 0.08757162f, 0.12861514f, -0.16172068f, 0.00041689f, -0.07881173f, 
    -0.17104506f, -0.05828062f, -0.19639546f, 0.00582380f, -0.05439899f, 0.00217757f, -0.06818309f, 0.03597603f, 
    0.09467103f, -0.09044820f, 0.04689883f, -0.00569980f, -0.02231346f, 0.01813195f, 0.09736602f, 0.04601429f, 
    -0.47887358f, -0.32838631f, -0.19982828f, -0.06226373f, -0.28943866f, -0.06691646f, -0.14212362f, -0.06278714f, 
    0.04133024f, 0.03505481f, -0.19832270f, -0.11409359f, 0.10480315f, -0.03010502f, -0.03537539f, 0.02845382f, 
    -0.01512372f, -0.05439535f, 0.00590869f, 0.10088146f, -0.21007349f, 0.08476153f, 0.09191560f, 0.05558168f, 
    0.03606252f, 0.02797975f, -0.00270024f, -0.11028904f, -0.09715746f, 0.04610197f, -0.08491996f, 0.01764553f, 
    0.14218153f, -0.06069765f, 0.00981440f, -0.09368787f, 0.06007264f, 0.07144691f, 0.13059537f, -0.16020566f, 
    0.13972428f, 0.04085821f, 0.22559130f, 0.13219243f, 0.17979617f, 0.00026997f, 0.16302106f, -0.02668582f, 
    0.03154597f, 0.06378808f, 0.00293886f, 0.10357945f, -0.11336251f, -0.09079462f, -0.04836369f, -0.01026707f, 
    -0.01995389f, -0.02767588f, 0.00181911f, -0.00844815f, -0.20757890f, -0.04918936f, -0.26296276f, 0.14685659f, 
    0.04378522f, -0.01433652f, 0.04833467f, 0.05076938f, 0.10427877f, -0.02552502f, -0.01987951f, -0.02346794f, 
    -0.01862567f, -0.05307416f, -0.05997734f, -0.02040934f, -0.06937779f, 0.05291450f, 0.00612849f, -0.02310806f, 
    0.52917087f, -0.16030397f, -0.07882691f, 0.22385408f, 0.07166111f, 0.18882567f, -0.04520103f, -0.09630987f, 
    0.14604363f, -0.01464050f, 0.04270081f, 0.08361795f, -0.09086493f, 0.04527756f, -0.10988653f, -0.09202747f, 
    0.03680766f, -0.04203935f, 0.06197106f, -0.08334774f, -0.27138421f, -0.17961025f, -0.05143889f, 0.11888983f, 
    0.17678085f, 0.02183044f, 0.02818977f, 0.01863034f, 0.06432320f, 0.01612159f, 0.00529032f, 0.08276413f, 
    -0.06319741f, 0.01620355f, 0.00355397f, 0.01027531f, 0.05985797f, -0.12187482f, 0.10497084f, -0.04025703f, 
    0.09821559f, -0.40663573f, -0.04785603f, 0.05352443f, -0.22783339f, -0.18084790f, -0.02739790f, -0.02302238f, 
    0.04120373f, -0.09831070f, 0.02594310f, -0.03712021f, -0.01144604f, -0.01430628f, -0.02098062f, -0.21568665f, 
    0.16909626f, -0.14295577f, -0.02153841f, 0.00290380f, -0.46540174f, 0.21059054f, -0.07713899f, 0.04944900f, 
    -0.11048643f, -0.02815700f, -0.09253787f, 0.01676678f, -0.23535450f, -0.02200042f, 0.01383746f, 0.05367521f, 
    0.03383542f, -0.01525704f, 0.04985498f, 0.10450467f, -0.06422037f, -0.03217305f, -0.06873979f, -0.01399846f, 
    -0.29597944f, 0.08001768f, 0.02183800f, 0.01045729f, 0.05004939f, 0.05432501f, 0.06499422f, -0.01586696f, 
    0.17333509f, 0.03299706f, -0.02693539f, -0.02909836f, 0.04089135f, 0.01854087f, -0.07839846f, -0.06582287f, 
    -0.09290653f, 0.04999091f, 0.05197104f, -0.01942197f, -0.32976985f, -0.30171272f, 0.19790220f, 0.23931314f, 
    0.03246947f, -0.08619756f, -0.07082967f, 0.09743357f, -0.09530888f, -0.05943520f, 0.07731979f, 0.05877930f, 
    0.02478291f, -0.03153551f, 0.03841875f, 0.01747880f, -0.21239142f, 0.09449799f, 0.04449406f, 0.05115145f, 
    -0.57968873f, 0.12871030f, 0.02480623f, -0.19975497f, -0.08451665f, 0.11196657f, -0.11202319f, 0.12958513f, 
    0.00269539f, 0.06596704f, -0.02683257f, -0.03249248f, -0.16471040f, -0.01445076f, 0.11454941f, -0.03605036f, 
    0.11829259f, 0.00090626f, -0.03661753f, -0.07088906f, 0.05384323f, -0.00415290f, -0.00200760f, -0.09470655f, 
    -0.00682438f, 0.05121019f, -0.05415988f, -0.09678474f, -0.04000882f, 0.13748476f, 0.02437980f, -0.10746906f, 
    0.03001954f, -0.03383661f, 0.02063820f, -0.03586731f, -0.03872653f, 0.13859434f, 0.03683043f, -0.28553107f, 
    0.32690558f, 0.10095710f, -0.11342981f, 0.15538664f, 0.19795164f, -0.00145264f, 0.10146811f, 0.12120014f, 
    -0.00369287f, -0.10796332f, -0.04422084f, -0.04922471f, 0.07538783f, 0.07398235f, -0.07382707f, -0.02021358f, 
    0.05510987f, -0.10978220f, 0.00075578f, -0.05394061f, -0.05938873f, 0.30856335f, -0.29394087f, -0.58696622f, 
    0.02189863f, 0.08285300f, 0.00797367f, 0.00283303f, 0.08291823f, -0.13972694f, 0.00800187f, -0.04988597f, 
    -0.09927373f, 0.06649116f, -0.03573393f, 0.00452292f, -0.07917254f, -0.09131145f, -0.02430141f, -0.07190824f, 
    0.05690388f, 0.15478915f, -0.22094481f, 0.14003925f, -0.12647441f, 0.01123050f, -0.03310654f, 0.15637834f, 
    -0.13711479f, -0.14383350f, -0.09177195f, -0.05769301f, 0.05868839f, 0.07083504f, -0.01545417f, 0.00233522f, 
    -0.09707478f, 0.19530635f, 0.00624056f, 0.07204220f, -0.23290908f, -0.32079491f, -0.05217999f, -0.08251198f, 
    0.14200664f, -0.11934379f, 0.04975635f, -0.11427899f, 0.10460937f, 0.08845200f, 0.17314906f, 0.00945409f, 
    0.12160961f, 0.00390099f, -0.07847983f, 0.08913728f, -0.00413503f, -0.06289269f, 0.02828999f, 0.00207971f, 
    -0.00588759f, -0.16492094f, 0.04049276f, 0.16179335f, 0.04592320f, 0.07774778f, 0.04638180f, -0.03806729f, 
    -0.03867408f, 0.04661278f, 0.09992262f, 0.10141087f, -0.09747352f, 0.01309400f, 0.04809700f, 0.05006703f, 
    -0.03060833f, 0.06911957f, 0.07433494f, 0.06860504f, 0.00951950f, 0.07466471f, 0.05039785f, 0.04532001f, 
    0.24485520f, 0.09747035f, 0.13550779f, 0.00843265f, 0.07461481f, 0.11394794f, 0.02470011f, 0.10603458f, 
    -0.06130257f, -0.05488275f, -0.07874651f, -0.00898201f, -0.14083588f, -0.04084843f, 0.06831874f, -0.12022305f, 
    0.11376914f, 0.08753746f, 0.24825351f, -0.02882595f, -0.10495469f, 0.00222874f, -0.00425851f, -0.00542220f, 
    0.06787480f, 0.07473437f, 0.08188543f, 0.01016141f, -0.06011379f, -0.12036501f, 0.05720524f, 0.02151968f, 
    -0.00388703f, -0.10231296f, -0.07772872f, 0.06292677f, 0.00215010f, -0.04735601f, -0.26139244f, 0.10040642f, 
    -0.10367839f, 0.03960289f, -0.10898718f, -0.07416130f, -0.02514892f, -0.05384156f, 0.03866390f, 0.09704545f, 
    0.01292392f, -0.05095279f, 0.04384832f, -0.04242164f, -0.07550483f, -0.05852988f, -0.00203248f, -0.10022607f, 
    0.09044825f, 0.02112531f, 0.05857403f, -0.22760558f, 0.13205262f, -0.05131221f, 0.01954832f, -0.05612672f, 
    0.04131091f, -0.00979054f, 0.03081654f, -0.04681623f, -0.06345487f, 0.00212760f, -0.03194957f, -0.02840007f, 
    0.03722034f, -0.08362481f, 0.11201865f, -0.04583734f, 0.48354173f, 0.15833746f, -0.18760347f, -0.13559563f, 
    0.05175044f, 0.01754781f, -0.08897144f, 0.05104138f, 0.06106552f, 0.08594255f, -0.05671209f, 0.04455845f, 
    0.06680712f, 0.00426424f, -0.02023190f, -0.12814507f, 0.04715070f, -0.08105332f, 0.00879313f, 0.05261374f, 
    -0.61347425f, 0.08502460f, 0.16448955f, 0.14820214f, 0.14797144f, 0.06650111f, -0.04272832f, -0.09833418f, 
    0.16129234f, 0.07097064f, -0.04800221f, -0.07747995f, 0.03796054f, 0.10924725f, 0.05108634f, -0.05794183f, 
    0.13016988f, 0.08852427f, 0.16520390f, -0.02695704f, -0.06845318f, -0.04602265f, -0.30292141f, 0.24194886f, 
    -0.01956458f, -0.03690066f, -0.04624514f, 0.04201466f, 0.06700326f, -0.13153663f, -0.06195688f, -0.01056392f, 
    0.08595884f, -0.02138660f, 0.03416761f, -0.04349702f, 0.00023192f, 0.13882224f, -0.14363879f, 0.11004289f, 
    -0.24754924f, 0.34753206f, -0.04973131f, -0.30360109f, 0.00287385f, 0.15860777f, 0.03993039f, -0.07998874f, 
    0.05722435f, -0.06291796f, -0.03429528f, -0.09194863f, 0.00025278f, 0.04824778f, -0.05599596f, -0.12251771f, 
    -0.01397895f, 0.01851514f, -0.08552901f, -0.03265601f, 0.06515958f, 0.10234530f, 0.16079630f, -0.02704488f, 
    0.12139089f, -0.02062426f, -0.02722435f, -0.03747101f, -0.02501093f, 0.10216529f, -0.06466483f, -0.01712009f, 
    -0.07538882f, -0.03738525f, -0.07865786f, 0.01957302f, -0.00763304f, -0.10350297f, 0.02223874f, -0.13227424f, 
    -0.02868429f, -0.02009462f, 0.09526596f, 0.17213157f, -0.11172372f, -0.02799942f, 0.11429483f, -0.05110794f, 
    0.12671243f, -0.11450986f, 0.17862517f, -0.03407289f, -0.04940327f, -0.04910387f, 0.12192945f, 0.08542966f, 
    -0.06017864f, 0.00774242f, 0.09781870f, 0.20501669f, -0.30440336f, -0.48250711f, 0.17837135f, 0.28658763f, 
    0.08601140f, -0.17355880f, 0.04625851f, -0.14665268f, -0.17430751f, -0.00828318f, 0.06560199f, -0.04371149f, 
    -0.07769634f, -0.02832474f, 0.20230675f, -0.08380750f, -0.11240070f, 0.00589073f, 0.01096382f, 0.02860995f, 
    -0.04885178f, 0.01807432f, -0.00554829f, 0.15786649f, -0.20120057f, -0.04641865f, 0.01331449f, -0.19865960f, 
    -0.09454975f, -0.06855250f, 0.05561637f, 0.00859695f, 0.06732808f, 0.04991318f, -0.21169004f, -0.07111743f, 
    0.03445501f, -0.04878031f, -0.04909757f, -0.10384671f, 0.15792629f, -0.11831786f, 0.06973816f, -0.25441715f, 
    -0.35926309f, 0.01104543f, 0.11907610f, 0.16848035f, -0.10893001f, 0.07236516f, 0.01279784f, 0.04128006f, 
    0.10103548f, 0.05147191f, 0.05472476f, -0.06872719f, 0.07586544f, -0.04030468f, -0.03700091f, 0.11152081f, 
    0.09498390f, -0.10074862f, 0.15295996f, 0.12096144f, -0.08972068f, -0.06698142f, 0.02168831f, 0.04186538f, 
    0.05077798f, 0.01706722f, 0.11762320f, 0.13798167f, 0.03430717f, -0.02356934f, -0.02248196f, -0.05083339f, 
    0.11723382f, 0.06120207f, 0.02574150f, 0.08032994f, -0.93949205f, -0.04929824f, -0.06320845f, 0.12701212f, 
    0.31562060f, 0.05356698f, -0.03440811f, 0.03150234f, 0.12524259f, 0.17362575f, 0.07336999f, 0.00218046f, 
    0.03830811f, 0.04760566f, 0.00502120f, 0.02121441f, 0.11619499f, 0.08633191f, 0.08541465f, -0.04349799f, 
    -0.26521105f, -0.03011287f, -0.11874803f, 0.20567954f, 0.09171158f, 0.08960618f, -0.12888841f, -0.02626411f, 
    0.08301070f, 0.12162343f, 0.00581218f, -0.07909148f, 0.12332189f, -0.04890341f, 0.05046373f, 0.04037565f, 
    0.10472685f, 0.04526241f, -0.00964751f, -0.06891946f, -0.07194831f, 0.03857399f, -0.00932525f, -0.10082262f, 
    0.12052733f, 0.03031521f, 0.02260651f, 0.04652881f, 0.14216961f, -0.00649241f, 0.12558219f, 0.08175804f, 
    0.08289181f, -0.09079804f, -0.00146897f, -0.10956027f, -0.03986683f, 0.07688746f, -0.01433024f, -0.01031771f, 
    -0.16621657f, -0.13134626f, -0.10294560f, 0.00369387f, -0.23716262f, 0.00095382f, -0.11176909f, 0.02814044f, 
    -0.02776647f, 0.07790700f, -0.05251798f, -0.00135388f, 0.04813976f, -0.02563145f, 0.02264149f, 0.03353294f, 
    0.01101900f, 0.08387371f, -0.05914267f, 0.08956641f, -0.25139228f, -0.01698455f, 0.19363074f, -0.04301644f, 
    -0.10529891f, 0.05537890f, 0.05994594f, -0.07063329f, -0.06366957f, -0.01110795f, 0.06702480f, -0.03536574f, 
    0.02085702f, -0.12214918f, -0.03808899f, 0.01014538f, -0.02251589f, -0.00879354f, -0.05722395f, 0.02737025f, 
    0.21799411f, 0.45597398f, -0.23771231f, -0.31365362f, -0.19813758f, -0.06638952f, 0.03715574f, 0.00134979f, 
    0.04928230f, -0.08114792f, -0.08855703f, 0.00034800f, 0.06674892f, 0.11297105f, -0.04729591f, -0.03108037f, 
    0.18749240f, 0.07554802f, -0.05688918f, 0.11451117f, 0.23435049f, -0.04706889f, 0.05066028f, 0.01732886f, 
    0.07972479f, -0.11947563f, -0.06537309f, 0.10898318f, -0.00714645f, -0.04699834f, -0.04369595f, 0.01425980f, 
    -0.14877173f, -0.05998786f, -0.06880095f, -0.00182955f, -0.06900279f, -0.05437233f, -0.03358353f, -0.04161146f, 
    -0.05654790f, 0.11025413f, -0.01184243f, 0.19459836f, 0.27962986f, -0.07940213f, -0.13119088f, 0.11576070f, 
    -0.10947996f, 0.11866645f, 0.00180446f, -0.18838841f, -0.06453068f, 0.05476023f, 0.00005391f, 0.08527366f, 
    0.06172641f, -0.19210176f, 0.12679748f, 0.11101539f, -0.40571243f, 0.07595995f, 0.07500311f, 0.04133311f, 
    -0.05488990f, -0.10248365f, -0.02987030f, -0.01360697f, -0.06835564f, -0.14668152f, 0.10506412f, 0.01127088f, 
    -0.00177123f, -0.03670493f, 0.00577029f, 0.01411486f, 0.01174485f, 0.08589131f, 0.07315981f, -0.05672760f, 
    -0.68629396f, -0.20206837f, -0.12012217f, -0.13476762f, 0.09591569f, 0.04098739f, 0.05602527f, 0.00811394f, 
    0.00261924f, -0.08491304f, 0.01085747f, -0.01115454f, 0.06638168f, -0.00505477f, -0.06530973f, -0.11169706f, 
    0.01428713f, -0.17677686f, -0.07989188f, -0.00486040f, 0.18574055f, 0.13827482f, -0.07956804f, -0.12085792f, 
    0.09248175f, -0.21916437f, -0.03197548f, -0.00796588f, 0.08674416f, 0.07628432f, -0.12422539f, -0.07699425f, 
    -0.05466604f, 0.14826146f, 0.24394916f, -0.07667841f, -0.02655283f, -0.01123935f, -0.09626774f, -0.12634437f, 
    -0.72900307f, -0.31547904f, -0.18555148f, -0.04473877f, -0.16107899f, 0.02620758f, 0.02512475f, 0.05150429f, 
    0.03436870f, -0.16022527f, 0.09493819f, 0.01028795f, 0.12026736f, 0.03013915f, 0.04439988f, -0.01169453f, 
    -0.04095576f, -0.17684796f, 0.03646526f, 0.04046134f, -0.36863711f, -0.12981918f, -0.16366802f, -0.14518581f, 
    0.06245010f, 0.06607348f, 0.06426525f, -0.11633819f, 0.03527360f, -0.13939747f, -0.00414178f, 0.08571623f, 
    -0.18578145f, 0.00683187f, -0.10693730f, -0.04409629f, 0.00644687f, 0.10238757f, -0.05320642f, 0.07730622f, 
    -0.17216291f, 0.13660224f, 0.14813213f, -0.01861037f, -0.31705421f, 0.13745967f, -0.10107142f, 0.03781008f, 
    -0.04268921f, -0.01262984f, 0.15315868f, -0.04534019f, -0.12496456f, 0.04791230f, -0.15645610f, 0.01892041f, 
    -0.02406376f, 0.27737123f, 0.05825961f, -0.02298061f, -0.46267903f, -0.08321311f, 0.08510528f, 0.21136105f, 
    -0.17299499f, 0.06763367f, -0.02224356f, -0.05167508f, -0.04078823f, 0.02832333f, 0.01733754f, 0.04380819f, 
    0.14942066f, 0.00355788f, 0.00968419f, 0.13327685f, 0.07472742f, -0.00022864f, -0.04473228f, -0.07880994f, 
    -0.11457714f, 0.26753306f, -0.08941422f, -0.11631507f, 0.07595644f, -0.04256705f, 0.05276138f, -0.12042756f, 
    0.10698374f, -0.01498669f, 0.22810982f, 0.01523326f, 0.11991351f, -0.09346640f, 0.07443618f, -0.03249993f, 
    0.13446459f, -0.13607863f, 0.09495112f, -0.01093685f, 0.10265932f, 0.06299657f, 0.15904073f, 0.09123284f, 
    -0.16233543f, 0.03960929f, 0.12755455f, 0.04228973f, 0.04539828f, -0.00385535f, -0.10751235f, -0.06845196f, 
    -0.10457627f, 0.03735787f, 0.14466068f, -0.00466826f, 0.04022846f, 0.17057915f, -0.01959195f, 0.01846789f, 
    0.07867778f, 0.12259568f, -0.04128348f, 0.08104080f, 0.15655941f, 0.16294500f, -0.05558743f, -0.03492920f, 
    0.03142541f, 0.03974191f, 0.02124600f, 0.05116930f, 0.14389449f, 0.02839284f, 0.10539252f, 0.01556875f, 
    -0.03495716f, 0.05264468f, -0.20396610f, -0.09582479f, -0.56176060f, -0.33331713f, -0.19601180f, 0.01067474f, 
    -0.00510471f, 0.04827695f, 0.15964134f, 0.00935882f, 0.00165868f, -0.01536761f, 0.03157308f, 0.11992004f, 
    -0.05709602f, 0.06699940f, -0.09659586f, 0.00235939f, 0.04608169f, 0.03200398f, -0.13425170f, 0.14882571f, 
    -0.02894413f, -0.20183817f, -0.05660081f, 0.11645336f, 0.07073253f, 0.06064049f, 0.12634473f, -0.01491002f, 
    -0.05278751f, -0.09641603f, 0.03561250f, 0.01282907f, 0.08771202f, 0.02897690f, 0.03196084f, -0.08365554f, 
    0.02487285f, 0.03303649f, 0.00509546f, -0.03893543f, -0.12067454f, -0.09349038f, 0.01190745f, 0.00463722f, 
    0.14516521f, -0.11849514f, -0.01041331f, -0.04871436f, -0.08628334f, 0.00891542f, -0.00493731f, -0.26964679f, 
    -0.00825747f, 0.13469268f, -0.06487188f, 0.09170853f, 0.01476743f, -0.14600706f, -0.06248809f, 0.13684785f, 
    0.00132781f, 0.06959818f, -0.22508675f, 0.08734524f, 0.09793394f, 0.08211318f, 0.03584561f, 0.09843756f, 
    -0.08651252f, 0.08711249f, 0.07239297f, -0.02108669f, 0.04282051f, -0.00818603f, 0.01547290f, -0.07974420f, 
    0.01673260f, -0.03139895f, -0.08409377f, -0.08155799f, -0.26113570f, -0.06186369f, 0.34871125f, 0.03902607f, 
    -0.36598668f, 0.15095626f, 0.00821896f, -0.03942237f, -0.07613649f, -0.00213567f, 0.00519805f, -0.05447768f, 
    -0.03117596f, -0.13481823f, -0.03491075f, -0.04474738f, 0.02141376f, 0.11455277f, 0.08250235f, 0.04664794f, 
    -0.24964440f, 0.28651568f, -0.47282687f, -0.15389329f, 0.05387724f, 0.15008691f, 0.21384041f, 0.00788420f, 
    0.00651569f, -0.08485433f, 0.06602067f, -0.00412257f, -0.10960599f, -0.14246704f, -0.02325816f, -0.01625733f, 
    -0.01271435f, -0.04053542f, -0.00310675f, -0.04835434f, -0.04699671f, 0.02196706f, 0.02009602f, -0.07209461f, 
    -0.17977168f, 0.12598228f, 0.04010984f, -0.23845415f, 0.00505779f, 0.18692635f, 0.01724722f, 0.15431489f, 
    -0.09080181f, 0.05096139f, -0.10848329f, -0.01552914f, 0.01181500f, -0.00215231f, 0.06093212f, 0.04835662f, 
    0.15988868f, -0.00859612f, 0.11311210f, 0.27288419f, 0.12104370f, -0.07406627f, 0.14562453f, 0.07812348f, 
    0.05917092f, -0.01840580f, 0.05097916f, 0.04495927f, -0.13166828f, 0.04942323f, -0.00235598f, 0.10090225f, 
    0.04366151f, -0.00894318f, 0.04415187f, 0.08646486f, -0.17259222f, -0.27908856f, -0.27243221f, 0.04049989f, 
    0.01130406f, 0.06077644f, 0.04836822f, 0.01926127f, 0.07624204f, 0.03740733f, 0.07302514f, 0.07580661f, 
    0.01144815f, 0.05773810f, -0.00861090f, -0.06432503f, -0.06118432f, 0.02331580f, -0.05635394f, 0.03227388f, 
    0.05818246f, 0.06095038f, -0.08171783f, 0.11139692f, 0.11234303f, -0.10152641f, -0.07670853f, -0.00018149f, 
    -0.00546542f, 0.16337614f, -0.05556410f, 0.23192631f, 0.21795733f, 0.18499281f, -0.10816023f, -0.06551657f, 
    0.07383734f, -0.12514518f, -0.02211707f, -0.12247184f, 0.10301988f, 0.07996294f, 0.00067069f, 0.15825680f, 
    0.12476286f, -0.14638664f, -0.00858637f, -0.05890052f, 0.05283133f, 0.12427944f, 0.02092898f, -0.18874356f, 
    -0.00028354f, 0.23580003f, 0.12843861f, -0.01228860f, 0.18190250f, -0.11928448f, -0.06820929f, 0.06127913f, 
    -0.09101745f, -0.11664180f, -0.18387818f, 0.26828703f, 0.12564853f, -0.02235728f, -0.30792880f, 0.01342633f, 
    0.05716277f, 0.12582929f, 0.00882691f, 0.00195356f, 0.05756659f, 0.05129941f, 0.08170149f, -0.04531935f, 
    -0.03282991f, -0.03316906f, -0.13209563f, -0.23466977f, -0.05603363f, 0.03979905f, 0.34389925f, 0.10104759f, 
    -0.34470981f, -0.08932503f, -0.06718360f, 0.07820058f, 0.05495468f, 0.06356348f, -0.05038757f, 0.07174817f, 
    -0.01023833f, 0.00994078f, -0.27175620f, -0.11341385f, -0.11229183f, -0.18073122f, -0.08716752f, 0.12448521f, 
    0.14963368f, 0.02428046f, 0.11667233f, -0.06912687f, 0.14727193f, -0.03853529f, -0.02439051f, 0.00290080f, 
    -0.10619873f, 0.02938874f, -0.06125462f, 0.05047583f, 0.14160347f, 0.09243500f, 0.07600040f, -0.01458414f, 
    -0.25678617f, 0.02890206f, 0.01074376f, -0.02439381f, -0.43545264f, 0.13222940f, -0.39719021f, -0.20634949f, 
    -0.08562589f, 0.17430677f, 0.10904227f, 0.14998014f, -0.08325400f, -0.17195719f, -0.02495736f, 0.04630988f, 
    -0.05281898f, -0.17435117f, -0.03876464f, 0.10194810f, -0.10681985f, 0.02200757f, 0.05966994f, -0.01237504f, 
    0.30299559f, 0.18932430f, 0.07385309f, 0.03073213f, -0.10031950f, -0.02669801f, -0.07371399f, -0.01459156f, 
    -0.06336850f, -0.04538853f, 0.08556891f, 0.03924735f, -0.02407122f, 0.04452331f, -0.01694213f, 0.11068905f, 
    -0.07320214f, 0.00800556f, 0.15235582f, 0.05154337f, -0.05429226f, -0.20296422f, 0.00015194f, -0.07786737f, 
    0.25446138f, -0.04923166f, -0.10515191f, 0.02849182f, 0.07968986f, 0.05609338f, 0.06396262f, 0.13723333f, 
    -0.10189468f, 0.17203891f, 0.16184013f, 0.11381304f, 0.00601139f, 0.02141816f, -0.44590756f, 0.11434717f, 
    0.00562098f, -0.09233089f, -0.03368755f, -0.00559410f, 0.04878777f, -0.06327073f, -0.10670880f, -0.13682356f, 
    -0.01043343f, 0.04311925f, 0.04278320f, -0.09368861f, 0.02948397f, -0.00504236f, 0.11564090f, 0.00985711f, 
    -0.01091061f, 0.00766405f, -0.20661964f, -0.11273216f, -0.17036885f, -0.01476107f, 0.09053814f, 0.21855618f, 
    0.14989854f, -0.04134388f, 0.00322202f, 0.06841678f, 0.06915531f, 0.06903096f, 0.03898613f, -0.12444857f, 
    0.02758451f, -0.01992693f, 0.08961442f, -0.02486105f, 0.03764647f, -0.08047255f, -0.08563275f, -0.21571910f, 
    -0.20557643f, -0.12295515f, 0.36876729f, 0.15257205f, -0.14598320f, 0.06670488f, -0.07595936f, 0.01128505f, 
    -0.04129924f, -0.08721753f, -0.03487748f, 0.00286611f, -0.05113905f, -0.11828719f, 0.26145300f, -0.12948245f, 
    0.05347295f, -0.06507459f, 0.13792998f, -0.12410308f, -0.18541805f, -0.16981125f, 0.03048499f, 0.16955361f, 
    -0.45416358f, -0.05088841f, -0.04583360f, -0.03664646f, 0.10714903f, 0.00435864f, 0.01881740f, 0.06496101f, 
    0.02300431f, -0.03046712f, -0.00101791f, -0.02200372f, 0.00816089f, 0.09983583f, 0.02394406f, -0.03512876f, 
    -0.23536772f, 0.35951394f, -0.11872853f, 0.32385099f, -0.45872033f, 0.16222501f, 0.22450161f, -0.07002337f, 
    0.14757250f, 0.01614837f, -0.06209693f, 0.17989780f, 0.03770600f, -0.01622901f, -0.22196190f, 0.10180309f, 
    -0.07994621f, 0.12913500f, -0.04856129f, -0.05825954f, 0.13882829f, -0.47643575f, 0.00180719f, -0.17828172f, 
    0.41855291f, 0.02757363f, 0.00949489f, 0.00073211f, 0.13431615f, 0.03731817f, -0.15125680f, -0.06969343f, 
    -0.07966666f, 0.09046362f, 0.14580522f, -0.07513246f, -0.00809658f, -0.00549178f, -0.16396786f, -0.05777202f, 
    -0.09392453f, 0.13980177f, -0.03622242f, -0.24403311f, 0.11089088f, -0.01736471f, 0.04461738f, 0.07684854f, 
    -0.12045611f, -0.16649137f, 0.04742585f, -0.08124493f, 0.02216338f, 0.01093300f, 0.07256112f, 0.00662221f, 
    0.00235281f, 0.04685192f, 0.10811124f, 0.10653923f, -0.03161320f, 0.18842159f, 0.08598099f, -0.10611290f, 
    -0.35656315f, 0.12968764f, 0.06460949f, 0.05313437f, -0.00992614f, 0.06185984f, -0.03163894f, 0.05302779f, 
    -0.05461208f, -0.02011091f, -0.16737689f, 0.06070646f, 0.00756430f, -0.03244434f, 0.01936787f, 0.08354466f, 
    0.23941383f, -0.42909572f, -0.01061709f, 0.20170261f, 0.01509538f, 0.10629368f, 0.06333099f, 0.12488697f, 
    -0.13203508f, -0.11399732f, -0.03623737f, -0.01965868f, -0.17449205f, 0.04973911f, -0.03880952f, -0.06263366f, 
    0.05908988f, 0.23760344f, 0.05394393f, -0.00077654f, -0.16052729f, -0.25158814f, -0.02333972f, -0.07884103f, 
    0.26917735f, 0.15638503f, -0.15119249f, 0.14876011f, -0.01015258f, -0.02817536f, -0.03957973f, -0.07119647f, 
    0.15203542f, 0.03837896f, -0.10845688f, 0.15408175f, 0.03754846f, -0.25379732f, 0.03127326f, 0.10791644f, 
    0.29522741f, -0.59017324f, -0.07339609f, 0.22543144f, -0.27772933f, -0.12057187f, 0.03822467f, -0.00771786f, 
    -0.04637615f, 0.05466010f, -0.12346312f, -0.02941981f, 0.06499942f, -0.00167730f, 0.14617619f, 0.00710351f, 
    -0.10636009f, 0.02632420f, -0.05686598f, -0.15429935f, 0.17902300f, -0.65960562f, -0.05861935f, 0.23207794f, 
    0.07713784f, 0.05631184f, 0.00415503f, 0.00124303f, -0.09342849f, -0.04099615f, 0.03746130f, 0.03312173f, 
    -0.08938616f, -0.01545055f, 0.05184240f, -0.06390979f, -0.07376076f, 0.05770491f, -0.02716669f, 0.10595633f, 
    0.10788924f, -0.40140912f, -0.14851025f, -0.13330846f, 0.26345271f, -0.17502372f, 0.08095688f, -0.03661106f, 
    -0.07050972f, -0.00386538f, -0.02902875f, 0.02297717f, -0.09097375f, 0.07816835f, -0.12780178f, 0.01856438f, 
    0.00718872f, 0.10343519f, -0.14014967f, 0.04316790f, -0.35088491f, 0.45049888f, -0.06071021f, 0.31864399f, 
    -0.21311416f, -0.08860391f, -0.12970029f, -0.03571723f, 0.10196725f, 0.02628630f, 0.01350650f, 0.05815190f, 
    0.04917502f, -0.06659980f, -0.07650407f, -0.00931983f, -0.00834779f, -0.07268266f, -0.01022985f, -0.18414086f, 
    -0.09262659f, 0.13382472f, -0.18020286f, -0.36067873f, -0.08446983f, -0.10530577f, 0.03279971f, 0.05139101f, 
    0.00720754f, 0.10439002f, -0.06449402f, -0.11637428f, -0.15924037f, -0.04089803f, -0.01360475f, -0.01562365f, 
    -0.19592416f, 0.01362847f, 0.17198816f, 0.06205322f, -0.09374219f, 0.01761114f, -0.04282084f, -0.20166405f, 
    0.09816315f, -0.09477223f, -0.04580248f, 0.06082472f, -0.04053187f, -0.01596433f, 0.01476123f, -0.11205641f, 
    0.06835034f, 0.06749611f, 0.02750907f, -0.12989962f, -0.03000246f, 0.03334214f, 0.05198862f, -0.09165626f, 
    -0.37312007f, 0.17500612f, 0.09085505f, 0.14114188f, -0.33869264f, 0.03598140f, -0.00582745f, 0.03360170f, 
    0.09713370f, 0.12328243f, -0.01798608f, -0.05732593f, 0.03187046f, 0.06458121f, 0.02428996f, 0.00705789f, 
    -0.11342160f, -0.06749552f, -0.08056209f, 0.01495146f, 0.01672645f, -0.04728358f, 0.06630540f, -0.19379453f, 
    0.14101303f, -0.00393444f, 0.06335597f, 0.01299041f, -0.09716296f, 0.12851626f, 0.05120083f, 0.05673170f, 
    0.03850184f, -0.10072315f, -0.04439370f, -0.07296593f, 0.09365056f, 0.01342044f, 0.03777316f, 0.02155101f, 
    -0.12172300f, -0.07036245f, -0.07938512f, -0.29799485f, -0.04881505f, 0.07185601f, -0.04914321f, -0.00937567f, 
    -0.10864976f, -0.17435618f, -0.07132540f, 0.02295387f, -0.03094344f, 0.02548132f, -0.01001884f, 0.11062015f, 
    -0.00975542f, 0.00935544f, 0.12660895f, 0.05584612f, 0.19758245f, 0.00568376f, -0.08830900f, -0.04789103f, 
    -0.18778996f, -0.06810595f, 0.00666519f, 0.04951052f, 0.07555258f, 0.11334640f, 0.04480070f, -0.05605011f, 
    -0.09957027f, -0.01334721f, 0.12366588f, 0.12262265f, -0.04555764f, -0.15117717f, -0.00058725f, -0.04129686f, 
    0.19200540f, -0.36242488f, -0.04988315f, -0.50286055f, 0.17429332f, -0.05047920f, 0.07794283f, -0.07167283f, 
    0.07974727f, -0.13599131f, -0.03451059f, -0.03734332f, 0.09562601f, 0.02387712f, -0.05983229f, 0.16493709f, 
    -0.06811859f, -0.03845767f, -0.01816035f, 0.17909300f, 0.06770542f, -0.25226113f, -0.13212129f, 0.03620046f, 
    0.05034629f, 0.05154465f, 0.01312077f, 0.04670760f, -0.09437387f, -0.03665283f, -0.05276778f, -0.12648444f, 
    0.03418982f, -0.05358662f, -0.01779699f, -0.00975265f, 0.01822575f, -0.01767669f, 0.11733981f, 0.01591876f, 
    -0.16480784f, 0.05655899f, -0.05932558f, 0.03015889f, 0.29939267f, -0.19263655f, -0.07107604f, 0.04151515f, 
    0.00185168f, 0.05863472f, -0.09635486f, 0.11630102f, 0.15269761f, -0.03728710f, 0.18038969f, 0.04609736f, 
    0.02144547f, 0.03621315f, -0.03430807f, 0.04034028f, -0.25247300f, -0.15315717f, -0.00141999f, -0.08209485f, 
    -0.00561447f, -0.03538150f, -0.01946762f, 0.18011571f, -0.12138635f, 0.00696235f, -0.08983907f, -0.01097724f, 
    0.03061983f, 0.04923983f, -0.02851005f, 0.02666967f, 0.00492727f, 0.04480705f, 0.03909465f, -0.10461754f, 
    -0.23290579f, 0.02383617f, -0.35635036f, -0.32312271f, 0.08051210f, 0.03063586f, 0.01708045f, -0.04057026f, 
    -0.08758716f, 0.00677913f, -0.03088707f, -0.06472926f, -0.09323994f, -0.03976325f, -0.01673087f, 0.01642194f, 
    -0.01537594f, 0.24054302f, 0.09351784f, 0.01719723f, -0.22692180f, 0.27264562f, -0.02367116f, -0.03734472f, 
    -0.22591069f, 0.01599289f, 0.08508593f, 0.11555863f, 0.05335490f, 0.08129331f, -0.00660203f, 0.10535173f, 
    -0.11117435f, -0.00498396f, -0.10263766f, 0.09850516f, -0.08522896f, 0.07601867f, 0.07891366f, -0.00224683f, 
    0.13295382f, 0.03810516f, 0.11289981f, -0.13058464f, 0.21587454f, 0.03685283f, -0.01398012f, 0.07874150f, 
    -0.03022573f, -0.16690718f, 0.00113134f, -0.04176261f, -0.12024634f, -0.08696236f, -0.01537628f, 0.02320752f, 
    -0.07811123f, 0.17072716f, 0.04019135f, 0.06007751f, -0.19727589f, 0.07238549f, 0.08962419f, 0.25882232f, 
    0.34788248f, 0.08291478f, 0.12139761f, -0.04818036f, 0.04139338f, -0.05132186f, -0.05378640f, 0.00514024f, 
    0.01014368f, 0.13103992f, 0.12477910f, 0.10422929f, -0.05575155f, 0.20042117f, 0.10709590f, -0.00027291f, 
    -0.49529755f, 0.26513210f, -0.09317425f, 0.09428439f, -0.28271067f, 0.14627013f, 0.04861186f, 0.04046858f, 
    0.05885812f, 0.05318338f, 0.00643439f, -0.02575573f, -0.00213283f, 0.00408076f, 0.05340816f, -0.03252229f, 
    -0.02926453f, 0.04605734f, -0.03626990f, 0.07438673f, 0.15735902f, -0.54311186f, -0.05407527f, -0.39550161f, 
    0.07709714f, -0.07470459f, -0.05910185f, -0.00795944f, -0.06738613f, 0.04764612f, 0.00264698f, 0.01676562f, 
    0.03441546f, 0.11311918f, 0.04640201f, -0.05526712f, 0.02873883f, -0.12574352f, -0.08548763f, 0.02173417f, 
    -0.16136684f, -0.04118090f, -0.17522033f, 0.17355971f, -0.19305845f, 0.02582244f, 0.15642059f, 0.01066910f, 
    0.10768518f, 0.07651407f, -0.06682706f, -0.07314268f, 0.06295067f, 0.01309384f, 0.02857032f, -0.02188625f, 
    -0.04428136f, -0.07010792f, -0.25556505f, -0.13765131f, 0.06307428f, 0.10231823f, -0.08934074f, -0.11213859f, 
    -0.02371438f, 0.08041237f, 0.00059901f, 0.01086717f, -0.18600488f, -0.08696630f, -0.03138566f, 0.01071666f, 
    0.05909840f, -0.07411605f, 0.08379456f, -0.13792320f, 0.02489209f, 0.11414786f, -0.01363929f, 0.03280238f, 
    0.14188582f, 0.01742858f, -0.03973058f, -0.11899766f, 0.09681707f, 0.05708953f, 0.14336619f, 0.01236169f, 
    -0.10139702f, -0.05735540f, -0.03423717f, -0.09082073f, -0.00633721f, -0.05667003f, -0.04154220f, -0.02275511f, 
    0.15405037f, -0.00416048f, 0.16027996f, 0.07728407f, 0.26081228f, 0.12827878f, 0.07180635f, 0.02897058f, 
    0.22963177f, -0.11892232f, -0.03481389f, -0.05259797f, -0.07925186f, -0.07062700f, -0.07811753f, 0.00996925f, 
    0.00797422f, -0.02713328f, 0.01052261f, 0.07057441f, -0.08271994f, 0.01749802f, 0.01786045f, 0.02669357f, 
    0.18694822f, 0.07511391f, -0.04936932f, 0.02413791f, 0.06928560f, -0.04773265f, 0.18920155f, 0.13139366f, 
    0.13349098f, -0.11648006f, 0.03021288f, -0.03664975f, -0.00401376f, 0.06454758f, -0.18934703f, 0.07597946f, 
    0.01187218f, 0.14754474f, -0.08553536f, 0.16765262f, 0.04332422f, 0.27428547f, 0.14014794f, -0.17972754f, 
    -0.03168448f, -0.03339405f, -0.19807994f, 0.11368655f, -0.03727804f, 0.08517787f, -0.06558886f, 0.07146595f, 
    -0.11459494f, -0.08644086f, -0.11145535f, -0.08221685f, -0.07338426f, -0.13882241f, 0.08245209f, -0.10015327f, 
    -0.54630589f, 0.25498497f, -0.08710034f, -0.12161969f, -0.18731427f, 0.01691936f, 0.02455526f, -0.15886465f, 
    0.03552714f, -0.10273951f, -0.07243361f, 0.03793561f, -0.02260609f, -0.08079188f, -0.11839789f, 0.01145322f, 
    -0.01251328f, 0.01854383f, -0.01143896f, -0.04332272f, -0.18721129f, -0.12835988f, 0.08963127f, -0.06016426f, 
    0.02563181f, -0.15530330f, 0.00123290f, -0.12725361f, 0.03997327f, 0.00674659f, -0.01712134f, 0.09603242f, 
    -0.10621972f, 0.02226150f, 0.00059231f, -0.02680564f, -0.01190461f, 0.08183893f, -0.07469117f, -0.05804611f, 
    0.04639524f, 0.14048149f, 0.25950131f, 0.01377609f, 0.12172955f, -0.00657291f, 0.03479394f, -0.02975398f, 
    -0.03714960f, -0.00877629f, -0.06715880f, -0.00583565f, -0.03455009f, -0.01414950f, -0.09428703f, -0.02464368f, 
    -0.04121288f, 0.03576541f, 0.04035069f, -0.09174144f, -0.00846892f, -0.33107993f, -0.06419885f, -0.04546452f, 
    -0.01637285f, 0.00805494f, -0.13817701f, -0.05400400f, -0.02009864f, -0.05506728f, -0.06730268f, 0.04132667f, 
    -0.02006415f, -0.05688643f, -0.05165385f, -0.06657384f, 0.06559823f, -0.03162076f, -0.00659461f, -0.02877368f, 
    0.16028614f, -0.18847325f, 0.19376153f, 0.08155645f, -0.11083321f, 0.09311983f, -0.00048952f, -0.01896192f, 
    -0.06645953f, -0.09177338f, -0.04933247f, 0.13200472f, -0.00304033f, -0.01099097f, -0.08925732f, -0.04157770f, 
    0.10842060f, 0.07371525f, -0.03573541f, -0.00703361f, 0.19331595f, 0.24768610f, 0.21863213f, -0.24845919f, 
    0.19831160f, -0.09356555f, 0.15836971f, 0.05318981f, -0.04486510f, 0.04296385f, -0.00844282f, 0.17167857f, 
    -0.00607084f, -0.07118955f, -0.03040201f, 0.03201113f, 0.08019817f, -0.02920189f, 0.07256468f, -0.07157879f, 
    0.10870042f, 0.04982100f, 0.03133134f, 0.01321946f, -0.19278058f, 0.06712162f, 0.03089123f, -0.01170527f, 
    -0.08442375f, -0.01903808f, 0.01613702f, -0.00511316f, 0.07450107f, -0.02668724f, -0.08945706f, 0.04868352f, 
    -0.00678738f, 0.00068420f, 0.00733171f, -0.09051534f, 0.05179135f, -0.16857769f, -0.08043592f, 0.04513643f, 
    0.29091340f, 0.09443269f, 0.08469865f, -0.11162253f, 0.04745903f, -0.05310529f, 0.00008926f, -0.12583776f, 
    -0.04438222f, -0.04876400f, -0.00454900f, 0.02052791f, -0.07700647f, 0.01512777f, 0.01917181f, -0.02208443f, 
    -0.09909500f, 0.03163685f, 0.03486685f, -0.07678468f, 0.04570173f, -0.08559386f, -0.00328866f, -0.10089406f, 
    -0.06048561f, -0.03071331f, -0.04941075f, 0.06211204f, -0.11461621f, -0.04554637f, -0.02903151f, 0.00747401f, 
    0.00083946f, 0.05046264f, -0.01133330f, -0.01130623f, -0.20142895f, -0.02826775f, -0.14544989f, -0.28084019f, 
    -0.25839847f, 0.04898953f, -0.04747323f, 0.00434228f, 0.00802654f, -0.08489897f, -0.09238367f, -0.06360253f, 
    -0.05101746f, -0.03127110f, -0.07869200f, 0.02776572f, -0.02618346f, -0.01772459f, 0.01622470f, 0.04166791f, 
    0.16068360f, 0.08526415f, 0.00808436f, 0.11384287f, 0.31898129f, 0.01840796f, -0.00671772f, -0.02095889f, 
    -0.10850687f, -0.06672380f, -0.02785392f, 0.03408714f, -0.09274922f, -0.00210740f, -0.04549663f, -0.00815476f, 
    -0.05680685f, -0.04352444f, -0.00614928f, -0.05276891f, 0.23348887f, 0.01684303f, 0.20219980f, 0.10178320f, 
    0.09509279f, 0.01201666f, -0.01273697f, -0.04741242f, -0.00549532f, -0.01051160f, -0.00825833f, 0.12342804f, 
    -0.03423943f, 0.06667537f, 0.02404980f, -0.06540536f, 0.00957990f, 0.08515605f, 0.02579480f, -0.11249262f, 
    -0.31474552f, -0.16934329f, -0.28223208f, -0.06286210f, -0.17218500f, -0.12945184f, -0.01524418f, 0.03279560f, 
    -0.06377779f, -0.10604217f, -0.01982479f, -0.06351873f, -0.06253861f, -0.02219249f, -0.00907684f, 0.00066161f, 
    -0.02710509f, -0.05889116f, -0.01637186f, -0.05286808f, 0.22338365f, 0.21934243f, 0.13091440f, -0.15197690f, 
    0.15218289f, -0.09882727f, 0.11010268f, -0.13206521f, -0.01500029f, -0.01207738f, -0.03448267f, -0.04732849f, 
    -0.02058467f, 0.05712866f, -0.02652739f, -0.03112143f, 0.01946016f, 0.12813197f, 0.03271648f, -0.04351522f, 
    0.08091605f, -0.02884569f, 0.15965331f, 0.16976869f, 0.24566849f, 0.09761190f, 0.11989264f, -0.07053068f, 
    -0.04783888f, 0.00861595f, -0.05082341f, 0.01003017f, -0.07520622f, -0.07670958f, -0.01853838f, -0.06252483f, 
    -0.05103454f, -0.05524644f, -0.01485856f, 0.02172186f, 0.04668148f, -0.00053882f, -0.05931694f, 0.00928928f, 
    -0.21394250f, 0.05850674f, -0.03568636f, -0.02346064f, -0.06671649f, -0.02304430f, 0.01884536f, 0.05755641f, 
    -0.05549464f, 0.03224332f, 0.01382633f, 0.06505606f, -0.08183977f, -0.10720750f, -0.07079189f, 0.00293545f, 
    0.16213971f, 0.19081679f, 0.26165047f, 0.05120976f, 0.24815890f, 0.00488596f, 0.14445458f, 0.03347395f, 
    0.01761980f, 0.02699078f, -0.03982308f, 0.04133683f, -0.03168468f, -0.00607031f, -0.10956690f, -0.06433724f, 
    -0.00567889f, -0.00843898f, 0.01641307f, -0.00023713f, 0.10096004f, 0.19121453f, -0.00942846f, 0.05784097f, 
    0.14426023f, 0.06995985f, 0.05585329f, -0.07699170f, 0.05740666f, -0.04647696f, -0.02080499f, 0.01683514f, 
    -0.04155254f, 0.03164515f, -0.09558364f, 0.06720665f, -0.07133012f, 0.01889306f, 0.01574716f, -0.08609135f, 
    -0.11775510f, -0.03811502f, -0.27630150f, -0.12587701f, 0.05583813f, -0.10342707f, -0.10393807f, -0.11531802f, 
    -0.04260462f, -0.05750908f, -0.05444322f, 0.06986139f, -0.09150583f, -0.04715249f, -0.03578602f, 0.01852612f, 
    -0.10846087f, -0.02411157f, 0.00514028f, -0.05586716f, 0.17240228f, -0.33037940f, 0.18604289f, 0.05286603f, 
    -0.07837940f, -0.01129410f, -0.03490198f, -0.07449118f, -0.05765363f, 0.00193695f, -0.06127765f, 0.00617061f, 
    0.02296707f, 0.02366176f, -0.06712993f, -0.14397520f, -0.02708877f, -0.06739075f, 0.00597613f, -0.03199562f, 
    0.01754418f, 0.17650068f, -0.01184624f, 0.05198961f, 0.23347186f, -0.00588195f, -0.02796546f, -0.08296911f, 
    -0.07951273f, -0.01178271f, -0.00470297f, -0.02686263f, -0.07799520f, -0.05522821f, -0.11758164f, -0.04206079f, 
    0.00539902f, 0.09387753f, 0.01799136f, -0.05498501f, -0.34943208f, -0.00775884f, -0.35124069f, -0.06781144f, 
    0.13222139f, -0.05995542f, -0.10947304f, -0.09472150f, -0.03403810f, -0.00180665f, -0.02192972f, 0.09082729f, 
    0.03485660f, -0.08246560f, -0.05789866f, -0.06618400f, -0.00221101f, -0.04875815f, -0.00945496f, 0.05850827f, 
    -0.00477403f, 0.17582439f, -0.13792664f, 0.14220682f, 0.23012853f, -0.08561926f, 0.02645677f, -0.07372969f, 
    0.11016697f, -0.01777496f, -0.18792795f, -0.06683782f, -0.01588076f, -0.03541953f, -0.02099197f, -0.04857231f, 
    -0.06866659f, 0.01486400f, -0.04420948f, -0.11522564f, -0.41775167f, 0.14099389f, 0.10850767f, 0.16726099f, 
    0.14557262f, 0.13444629f, -0.10912608f, -0.03165821f, 0.17558269f, 0.08836224f, -0.06281378f, -0.00316092f, 
    0.05196781f, 0.02052192f, -0.22319165f, 0.10971973f, -0.00534827f, 0.10104922f, -0.01699242f, -0.00329405f, 
    -0.05910648f, -0.00597346f, -0.19828123f, -0.09263226f, -0.05017342f, -0.02078135f, -0.00100449f, -0.04274137f, 
    -0.01201874f, -0.08031949f, -0.08859297f, 0.05993176f, 0.06389952f, 0.06761355f, -0.02475463f, 0.04260594f, 
    -0.07908721f, -0.05052584f, 0.03798707f, -0.01225363f, 0.13843516f, 0.06195965f, 0.27487355f, 0.20081648f, 
    0.14083375f, 0.07639658f, 0.12410634f, -0.01719224f, -0.03734859f, -0.09294660f, -0.01791579f, 0.08102932f, 
    0.05237724f, -0.06312858f, -0.05110516f, -0.05268730f, 0.07422043f, 0.01257002f, 0.02386645f, -0.11178978f, 
    -0.03120004f, 0.07476445f, 0.01620993f, -0.15129934f, -0.12644614f, -0.11138173f, -0.04697767f, 0.01978397f, 
    -0.05354682f, -0.09095608f, 0.09732699f, 0.02109262f, -0.04455537f, -0.00022986f, -0.07315951f, 0.00342579f, 
    0.03550581f, -0.07778667f, -0.07039309f, -0.02936952f, 0.24384984f, 0.03302357f, 0.17963985f, 0.12021241f, 
    0.13216183f, -0.04309842f, 0.09512636f, -0.02483638f, -0.13445722f, 0.04688085f, -0.00624433f, 0.01835341f, 
    -0.03961087f, -0.03965227f, 0.02688502f, -0.06023855f, 0.01750642f, -0.02817516f, 0.18420959f, 0.00225391f, 
    0.01867938f, 0.31789216f, -0.16451707f, 0.06900324f, 0.15049569f, -0.09767336f, 0.05171880f, -0.13898508f, 
    0.00715227f, -0.00177041f, -0.07570651f, 0.05416149f, -0.01414871f, -0.07166976f, -0.08433817f, 0.03854220f, 
    -0.03542968f, 0.04971854f, -0.00553026f, 0.04231887f, -0.06806581f, 0.09330942f, -0.33946055f, 0.08605843f, 
    0.20312110f, -0.05309326f, -0.10244024f, -0.02398216f, 0.00702406f, -0.00390726f, -0.14814705f, -0.08672633f, 
    -0.07672895f, -0.02478643f, -0.05135633f, -0.05463501f, -0.10395160f, -0.02157358f, -0.07499957f, 0.00302991f, 
    -0.01739581f, 0.14855215f, -0.22153407f, 0.15688881f, 0.14679533f, 0.04084635f, -0.07824923f, -0.02490473f, 
    0.02823629f, -0.02011054f, -0.05744925f, 0.07989880f, 0.06483737f, -0.07332299f, -0.09051624f, 0.12620741f, 
    -0.00718377f, 0.03995943f, 0.03987675f, -0.04641408f, 0.09718084f, -0.30106282f, 0.05051457f, -0.00463398f, 
    -0.35022211f, 0.09325343f, -0.05613978f, -0.05688227f, -0.04602548f, -0.11625204f, -0.03181946f, 0.02334026f, 
    -0.13871607f, 0.00187764f, -0.07572030f, -0.01399682f, 0.13110831f, -0.04627444f, -0.01577128f, -0.02311987f, 
    0.09171546f, 0.03074273f, -0.41785026f, 0.18138354f, 0.05626796f, 0.02950634f, 0.07625204f, -0.08749680f, 
    -0.14517094f, -0.04486677f, 0.02912991f, 0.04631742f, 0.00877401f, -0.03467515f, 0.08371654f, -0.00060981f, 
    -0.01810382f, -0.05232526f, 0.15727562f, -0.03116133f, 0.06783751f, 0.22076865f, 0.07212387f, 0.05975649f, 
    0.11322639f, -0.19556996f, -0.09972014f, -0.03785253f, -0.08789403f, -0.01380769f, 0.13859868f, 0.06370849f, 
    -0.02091712f, -0.01894907f, 0.01814259f, -0.08041438f, 0.07503122f, -0.02337947f, 0.12683234f, 0.00267743f, 
    -0.10641910f, 0.03125902f, 0.17647047f, 0.00682803f, -0.07502994f, -0.07256497f, 0.05727400f, -0.11764581f, 
    -0.05016265f, -0.04096083f, 0.06567998f, -0.00238004f, 0.02027574f, 0.06889284f, -0.01779187f, 0.01672375f, 
    -0.09445269f, -0.09550742f, -0.02715896f, 0.00625443f, -0.09771020f, -0.20169754f, -0.18763880f, -0.17154132f, 
    0.11103659f, 0.07076710f, -0.01369474f, -0.03589728f, -0.03650121f, -0.03296025f, 0.06866091f, 0.02400019f, 
    0.02448530f, 0.10965471f, -0.01380504f, 0.03927700f, 0.05362286f, 0.00576589f, -0.09007262f, -0.02832470f, 
    0.01513413f, -0.00947621f, -0.00366715f, 0.14753805f, 0.01064181f, -0.09022719f, 0.01378432f, -0.10299879f, 
    -0.12277868f, 0.19643386f, -0.06654102f, -0.05242509f, -0.05597181f, -0.00984380f, -0.03758407f, 0.07814486f, 
    -0.03756306f, -0.13241468f, 0.11293537f, 0.00448415f, -0.30297059f, 0.33921945f, 0.01516352f, -0.28189102f, 
    -0.04663093f, 0.03078660f, 0.01532161f, 0.08006207f, 0.03207650f, -0.07140476f, 0.02621553f, 0.01264202f, 
    -0.15734272f, 0.02678497f, 0.09630025f, -0.06915836f, -0.04808639f, 0.10322285f, 0.02179366f, 0.03050430f, 
    0.15836194f, 0.04821998f, -0.01612118f, 0.08371909f, 0.23805161f, -0.08208185f, -0.12336791f, -0.07555649f, 
    -0.10323029f, 0.03221362f, -0.09595814f, -0.02442677f, -0.00546364f, 0.05801797f, -0.00637873f, -0.00517209f, 
    0.07331503f, 0.08015487f, 0.11702563f, 0.03494101f, 0.06693492f, -0.13655828f, 0.16810457f, -0.11794607f, 
    0.07103812f, -0.05418482f, -0.04270396f, 0.01694313f, -0.10636917f, -0.07241897f, -0.04549376f, -0.00428773f, 
    0.01103757f, -0.00025867f, 0.00168275f, 0.02303378f, -0.07258888f, 0.02142483f, 0.07020354f, 0.09091749f, 
    0.01419231f, 0.06190049f, 0.09653494f, 0.01990085f, -0.07578155f, -0.17439610f, 0.00982604f, 0.01187622f, 
    0.02047746f, 0.07979878f, 0.04842957f, -0.02220454f, -0.02880072f, -0.03970410f, -0.01281573f, -0.00157695f, 
    -0.03883260f, -0.10176745f, 0.09334547f, -0.02795479f, 0.23349991f, 0.11499281f, -0.10024892f, 0.09468340f, 
    0.19474070f, 0.13795628f, 0.03222991f, -0.05797615f, -0.06948526f, -0.01169858f, -0.03827162f, 0.04710039f, 
    -0.08848907f, 0.13958126f, -0.08074170f, 0.03756778f, 0.05371181f, 0.11021972f, 0.09515312f, -0.03313038f, 
    -0.26526827f, -0.16112606f, 0.10319617f, -0.34787029f, -0.28834328f, -0.02397020f, -0.03352057f, -0.05653399f, 
    0.04170002f, 0.01382228f, -0.00448299f, 0.07378225f, 0.02520224f, -0.01677112f, -0.07154020f, -0.13386948f, 
    0.03306636f, -0.00503624f, -0.20584068f, -0.14183189f, -0.22636257f, -0.00402863f, 0.10554101f, 0.06910954f, 
    -0.04166900f, 0.00514314f, -0.01628528f, 0.02948260f, -0.11802288f, -0.03463629f, 0.03333681f, -0.03113808f, 
    -0.01147047f, 0.15811127f, 0.06775618f, 0.12880194f, 0.04745085f, -0.02218110f, -0.08275250f, 0.06420820f, 
    0.13539435f, 0.03486815f, -0.11512692f, 0.10710835f, 0.14502028f, 0.05868894f, 0.12293469f, -0.07363368f, 
    -0.08889986f, -0.11828382f, -0.01443775f, -0.01831901f, -0.00001140f, 0.04902324f, 0.00450994f, -0.04623212f, 
    -0.06649584f, 0.04400145f, 0.08459096f, -0.09134883f, -0.27344537f, 0.19204536f, 0.00805648f, -0.16343200f, 
    -0.19063325f, -0.01155346f, -0.02056231f, 0.01201501f, 0.08932836f, -0.17586245f, 0.07311493f, -0.07790852f, 
    0.10268790f, 0.08542076f, -0.01421535f, 0.01054181f, 0.06688038f, -0.04468136f, -0.01600741f, 0.09112507f, 
    -0.25449681f, -0.31702185f, 0.18039209f, -0.08587548f, -0.06677714f, -0.04859262f, 0.03784943f, 0.01977352f, 
    -0.07155599f, 0.00563008f, 0.05909384f, 0.03431928f, 0.02442626f, 0.03377536f, -0.05306121f, -0.05421982f, 
    0.02138411f, 0.04299042f, -0.21201222f, 0.02713232f, 0.03155004f, 0.01133461f, 0.05359247f, -0.14980604f, 
    0.15119310f, -0.00646521f, -0.05995772f, -0.15262617f, 0.05196345f, -0.09223735f, 0.00922479f, 0.04195124f, 
    0.03850783f, -0.14330548f, -0.01353582f, -0.05087015f, 0.01409895f, 0.08825465f, -0.01661592f, 0.06906261f, 
    -0.13055646f, 0.05958691f, 0.17427166f, -0.09649542f, -0.00428388f, 0.06825910f, -0.06184061f, 0.06309354f, 
    -0.07747623f, 0.03886681f, 0.04279551f, -0.03389429f, -0.07108951f, -0.03702386f, 0.05018734f, 0.02264772f, 
    -0.03180696f, -0.01575346f, 0.06318156f, -0.02815495f, -0.31302300f, 0.12588556f, 0.11012830f, -0.08164182f, 
    -0.25661415f, 0.01645023f, -0.04966735f, -0.04163284f, 0.15728122f, -0.05361020f, 0.02673163f, -0.00155111f, 
    -0.02256766f, -0.03810591f, 0.02607642f, -0.07481671f, 0.00448246f, -0.22751635f, 0.06549742f, -0.08492916f, 
    0.07743552f, 0.19410941f, 0.01203894f, 0.07796045f, 0.04621034f, 0.02075802f, 0.02024439f, -0.09271933f, 
    -0.08304004f, -0.06734084f, 0.03010826f, -0.01411566f, 0.02560216f, -0.01019338f, -0.04660659f, -0.05104194f, 
    -0.00286690f, -0.00332951f, 0.10262886f, -0.10776643f, -0.00167569f, -0.08324177f, 0.14441289f, 0.13300711f, 
    0.05251037f, -0.07994339f, 0.02441220f, 0.00625458f, -0.12530686f, 0.05104717f, 0.05713079f, -0.02353392f, 
    0.02596803f, 0.10399147f, 0.00670984f, 0.01356981f, 0.00588698f, -0.03942095f, 0.01308656f, 0.05398170f, 
    -0.18031624f, -0.06767385f, 0.02071750f, -0.29521799f, -0.24893959f, -0.18173148f, -0.02515420f, -0.05888768f, 
    0.08986229f, -0.04339893f, 0.04032057f, 0.06321470f, 0.08965965f, -0.06828699f, 0.07205453f, -0.07182883f, 
    0.02654651f, -0.19752064f, -0.06331024f, -0.01540353f, -0.10528304f, 0.00859190f, -0.26330027f, -0.20201257f, 
    -0.05194259f, 0.14378366f, 0.00189662f, -0.02660986f, 0.00000697f, -0.09567190f, -0.00651434f, 0.03126936f, 
    0.02177974f, 0.04851863f, -0.06988166f, 0.04389481f, 0.12950949f, 0.07878163f, -0.03250367f, -0.09634789f, 
    -0.17229486f, 0.01328136f, 0.05831163f, -0.35749987f, -0.05444562f, -0.10772627f, -0.04147649f, -0.01473970f, 
    -0.13776757f, -0.06940819f, 0.09191363f, 0.06014157f, 0.02534859f, 0.07117736f, -0.01830155f, -0.02914010f, 
    0.02708491f, -0.11736747f, -0.12857112f, 0.01684304f, -0.08876564f, 0.15315475f, -0.44127375f, 0.06074780f, 
    -0.28287771f, 0.10204668f, -0.11190721f, -0.38841367f, -0.01047951f, -0.02534669f, 0.13228069f, -0.03920976f, 
    0.09739912f, -0.03141920f, 0.02932345f, -0.03097840f, 0.00994322f, -0.25722143f, 0.07590365f, 0.01871981f, 
    -0.09832740f, -0.18170635f, -0.07891684f, 0.12500352f, 0.14780439f, 0.08776122f, 0.12217177f, -0.13738807f, 
    -0.07754967f, -0.06960970f, 0.11084024f, 0.00873787f, 0.02172603f, 0.02538191f, 0.10656706f, -0.18697144f, 
    -0.01638564f, 0.02446940f, 0.07314386f, -0.14372857f, -0.19798328f, -0.18216296f, 0.24508515f, 0.05090362f, 
    0.29094332f, -0.13455142f, -0.04339910f, 0.07699213f, -0.04925716f, 0.02096530f, 0.03238574f, -0.01868632f, 
    -0.05238154f, -0.16537155f, 0.08571356f, 0.02819443f, -0.01432831f, 0.03185167f, 0.06747234f, 0.06865279f, 
    0.28213212f, 0.19872688f, -0.13181850f, 0.06909534f, 0.16117515f, -0.02027856f, -0.01411570f, -0.12140942f, 
    -0.09892168f, -0.09765469f, -0.10614723f, -0.01398209f, -0.03392009f, -0.06848411f, -0.01306176f, -0.10029441f, 
    0.01167997f, 0.02523925f, 0.16546521f, -0.01320262f, -0.26181811f, -0.21617927f, 0.20609841f, -0.15653139f, 
    -0.12347038f, 0.04499505f, 0.04733262f, -0.04177261f, -0.06319942f, 0.04156158f, -0.02270837f, 0.07065082f, 
    0.00293388f, 0.16677153f, 0.03148390f, 0.04263888f, 0.05075519f, 0.00083960f, -0.41293937f, 0.06508564f, 
    -0.24491413f, 0.02339540f, -0.11256370f, -0.43611050f, -0.20996222f, -0.01153847f, 0.07314242f, -0.03550178f, 
    0.01080478f, -0.11592017f, 0.11042768f, -0.04863729f, -0.08442706f, 0.03697568f, 0.00046694f, -0.16273631f, 
    -0.00760384f, -0.04605841f, 0.04545670f, 0.00008092f, 0.03965059f, 0.07218613f, -0.01300670f, -0.04453254f, 
    0.02447382f, -0.00107497f, 0.01558094f, -0.04668163f, -0.12874198f, -0.04829093f, 0.04124462f, -0.02156694f, 
    0.07124697f, 0.05300338f, -0.15636988f, -0.02530486f, 0.08040701f, 0.00768560f, -0.03276402f, -0.05621774f, 
    -0.07262341f, -0.26615649f, -0.06473443f, -0.21129495f, -0.10566313f, 0.01138806f, -0.12879437f, -0.07314627f, 
    -0.03887347f, -0.07054566f, 0.12000937f, -0.03763470f, 0.05338575f, -0.08036105f, 0.24227710f, -0.06665745f, 
    -0.04077582f, 0.00159944f, -0.01785185f, -0.04130264f, 0.10852147f, -0.10063168f, 0.16960157f, -0.10664830f, 
    0.15739071f, 0.07755283f, 0.02985690f, -0.13747735f, 0.02452010f, -0.01401106f, -0.01151577f, 0.02552579f, 
    0.02121790f, -0.05202612f, 0.01647338f, 0.04074284f, -0.00046032f, 0.04758947f, -0.04656239f, 0.04096662f, 
    -0.54823792f, 0.14480436f, 0.29652327f, -0.12960796f, -0.14026684f, 0.03456601f, 0.11382161f, 0.04732296f, 
    -0.02319084f, -0.06931281f, 0.00347872f, -0.03864278f, -0.04714630f, -0.05088570f, 0.13398573f, 0.11077938f, 
    -0.02712975f, 0.22325997f, -0.22539756f, -0.00042269f, 0.13409872f, 0.19709264f, -0.21854216f, 0.26392850f, 
    -0.11380997f, 0.06320739f, 0.02500183f, 0.16590837f, 0.05347757f, -0.10700534f, -0.05020551f, 0.04879528f, 
    0.08160749f, 0.06931954f, 0.05107673f, -0.06362496f, -0.01751486f, 0.12288179f, -0.03082831f, -0.01787063f, 
    -0.19862156f, -0.28131285f, -0.04432536f, 0.25048271f, 0.07201956f, -0.01172966f, -0.00376008f, -0.10976886f, 
    -0.08549549f, 0.13427994f, -0.11080151f, 0.13352242f, -0.05582965f, -0.01857824f, -0.13355809f, -0.11396016f, 
    -0.04807587f, 0.05530696f, 0.02042765f, 0.02775828f, -0.05559932f, -0.25747821f, 0.31344232f, -0.40152392f, 
    -0.20649052f, -0.11990665f, 0.06257509f, -0.04780960f, -0.00480709f, 0.00955939f, -0.01705050f, 0.09117356f, 
    0.16511649f, -0.15214044f, -0.05704527f, -0.14139067f, 0.07440595f, 0.06322405f, 0.08626329f, -0.02052353f, 
    0.77449745f, -0.61704904f, 0.16153030f, 0.14212073f, 0.33562389f, -0.06513421f, -0.04873633f, -0.05710866f, 
    0.15128078f, 0.00758803f, 0.00502558f, 0.02607703f, 0.07413255f, 0.01392559f, -0.01575646f, -0.07482470f, 
    -0.07005322f, -0.01618395f, -0.13432936f, 0.13618338f, -0.16371469f, 0.18352972f, -0.18373543f, 0.28493667f, 
    -0.16891818f, 0.01020827f, 0.10249408f, -0.01690457f, -0.00037689f, -0.02713320f, -0.10014150f, 0.07174282f, 
    0.06808720f, -0.05070534f, 0.07207052f, 0.02816227f, -0.01989479f, 0.04509442f, -0.13889483f, -0.04360112f, 
    -0.22879511f, -0.25164181f, -0.15459506f, -0.04999798f, -0.05341066f, 0.02968373f, -0.02287742f, -0.01897766f, 
    0.01310708f, 0.06389426f, 0.01387996f, -0.06343571f, 0.02801556f, -0.06686726f, 0.07655175f, -0.05409106f, 
    0.13461785f, -0.19509462f, 0.01193164f, 0.08901147f, 0.38332081f, 0.14685667f, -0.18215629f, -0.13352865f, 
    0.19849244f, 0.16268760f, -0.08081732f, -0.01561065f, -0.07063233f, 0.12062854f, -0.02416129f, 0.02689973f, 
    0.10987028f, 0.14201874f, -0.09875301f, -0.01995720f, 0.05820686f, -0.09075647f, -0.00884627f, -0.12918018f, 
    -0.55130178f, 0.18348187f, 0.20467974f, 0.12218217f, -0.08317333f, 0.23149611f, 0.02951581f, -0.01829940f, 
    0.04571226f, 0.19435363f, -0.02795101f, -0.02012144f, -0.02721305f, -0.06771362f, 0.07291915f, -0.01642915f, 
    0.04274467f, 0.03326918f, -0.09687550f, -0.02436099f, 0.26306358f, -0.18406303f, 0.18489560f, -0.23428708f, 
    -0.29941791f, 0.09385891f, 0.06536453f, 0.12083583f, -0.15269223f, -0.10228563f, -0.20744874f, -0.01519391f, 
    0.01871195f, -0.11875417f, 0.09229590f, -0.15685217f, 0.06353320f, -0.17513707f, 0.06388050f, 0.02124487f, 
    0.16571012f, -0.11353876f, -0.12624232f, -0.12148129f, -0.03231561f, -0.12046882f, -0.03418220f, 0.01680108f, 
    0.03109949f, -0.10020670f, 0.00016273f, 0.03772774f, 0.07364296f, 0.02523060f, -0.09419832f, 0.16061749f, 
    0.11869200f, 0.01428373f, -0.01922211f, 0.07894388f, -0.05457928f, -0.26474047f, -0.21920204f, 0.18886952f, 
    -0.10151646f, 0.03533407f, 0.04667878f, -0.11786804f, 0.02691046f, -0.00967104f, -0.04395131f, 0.05810574f, 
    -0.04017972f, -0.10407896f, 0.14247549f, -0.12876515f, 0.03688492f, 0.07216920f, 0.01749851f, 0.11639219f, 
    -0.35597745f, 0.20219480f, -0.03746254f, 0.13839409f, -0.10223725f, 0.04964365f, 0.07437740f, -0.05547040f, 
    0.03111009f, -0.08334170f, -0.09530510f, 0.12740923f, -0.06355195f, -0.03147775f, -0.03155514f, 0.08387769f, 
    0.03339472f, 0.10291021f, 0.15343064f, 0.01287543f, -0.33227569f, -0.02587067f, -0.17273881f, 0.13433951f, 
    0.01496929f, 0.01635580f, 0.03412345f, -0.02990593f, 0.07324854f, 0.05341327f, -0.05825850f, -0.02271020f, 
    -0.10193648f, 0.06261178f, 0.02098664f, 0.06984784f, 0.02152179f, 0.00526893f, 0.04164805f, 0.03054733f, 
    0.28224948f, -0.13344304f, -0.09662178f, 0.10382329f, 0.16999269f, 0.05746004f, -0.00526291f, 0.11949349f, 
    0.02032816f, 0.05573242f, 0.01781558f, 0.04575532f, 0.07988615f, -0.02315951f, 0.00580521f, 0.12858175f, 
    -0.00482656f, 0.05442864f, 0.04600070f, 0.03609730f, -0.06225862f, -0.25708100f, 0.01007622f, 0.03606861f, 
    -0.10706204f, -0.08993042f, 0.00651530f, -0.00549017f, 0.00225144f, -0.06512269f, 0.00381371f, 0.03681520f, 
    0.00702071f, 0.18647555f, -0.09128825f, -0.00644011f, 0.04661882f, -0.20513503f, -0.07931633f, -0.15219201f, 
    -0.12394562f, -0.14685127f, -0.03798403f, 0.08895377f, 0.01499180f, -0.02969905f, 0.01809424f, -0.02578682f, 
    -0.01605454f, 0.14548683f, -0.15003116f, -0.02266883f, 0.01096197f, 0.11046459f, -0.01434313f, 0.03245003f, 
    -0.10020109f, 0.00356260f, 0.03126176f, -0.09387577f, -0.05128462f, 0.01516472f, 0.29127976f, -0.31467465f, 
    -0.03898256f, -0.09893497f, 0.02747933f, 0.10599253f, 0.06639685f, 0.07517815f, -0.04088018f, -0.03406150f, 
    0.22863390f, 0.14518219f, 0.20553160f, 0.02064548f, 0.04411889f, -0.02684069f, -0.01550653f, -0.01786382f, 
    0.40975252f, 0.02198125f, -0.17616695f, -0.25155985f, -0.27567807f, 0.02071583f, 0.06185250f, -0.01458949f, 
    0.13029651f, -0.04314959f, 0.09046712f, -0.05636919f, 0.03433654f, 0.02705522f, -0.15088940f, 0.04035825f, 
    0.01438117f, -0.00934447f, -0.19823173f, -0.05086017f, 0.41987398f, -0.47547919f, 0.01637555f, 0.10985167f, 
    -0.01701911f, -0.04539520f, 0.02103230f, 0.05311242f, 0.10694362f, 0.01066682f, -0.00779927f, 0.05685665f, 
    0.01415555f, -0.12872556f, 0.13985184f, -0.04341786f, -0.04825940f, -0.04918498f, 0.07734063f, 0.18140946f, 
    -0.05568780f, -0.03748718f, 0.03896154f, -0.03552439f, -0.01065815f, 0.12326965f, 0.03162539f, -0.01508784f, 
    -0.02287407f, -0.02378709f, -0.06343001f, -0.00140450f, -0.15673926f, -0.04785420f, 0.14836523f, 0.04002383f, 
    0.10282569f, 0.06751505f, -0.01796033f, 0.03925981f, 0.10390762f, 0.10440493f, 0.08675296f, -0.46321142f, 
    -0.39635462f, -0.03518851f, -0.16048811f, 0.06861575f, -0.04446629f, 0.15538445f, -0.03176600f, -0.10118032f, 
    0.04204665f, -0.19179708f, -0.10615139f, -0.06390653f, -0.02757011f, 0.01686179f, 0.01073869f, 0.03949133f, 
    0.24983241f, 0.07687607f, -0.33242092f, -0.27946219f, -0.15530384f, -0.07019892f, 0.04671004f, 0.04826127f, 
    0.06161017f, -0.00257729f, -0.02942977f, -0.04381318f, -0.07086807f, 0.01392555f, 0.04558831f, 0.04549977f, 
    0.13996835f, -0.02270774f, 0.17588903f, 0.13203743f, -0.13239129f, -0.49273291f, 0.17326243f, -0.06701878f, 
    0.27509594f, -0.19417411f, 0.03054483f, 0.03228058f, 0.02194383f, -0.11480871f, -0.05087763f, -0.11835153f, 
    -0.11313510f, 0.03854867f, -0.05896084f, 0.14499260f, 0.12575611f, -0.00468544f, -0.03282142f, 0.10983851f, 
    -0.28760713f, 0.02876333f, 0.00554230f, 0.08790748f, -0.04659776f, 0.01160749f, 0.19491771f, -0.07338201f, 
    -0.05768689f, -0.09265370f, 0.05456160f, -0.05833273f, -0.05123571f, -0.13364281f, -0.05739139f, -0.01568630f, 
    0.05983746f, 0.01144271f, -0.11023388f, -0.02007869f, 0.27416140f, -0.14606529f, -0.11626527f, 0.12804675f, 
    0.01286799f, 0.09999925f, 0.02361424f, -0.05244704f, -0.04313528f, 0.16879779f, -0.01592090f, -0.06937081f, 
    0.08179117f, -0.01964893f, 0.04642546f, -0.07407809f, -0.09868006f, 0.07805850f, 0.00804798f, -0.00947263f, 
    -0.32128879f, 0.09481583f, 0.10384431f, -0.03887746f, 0.00916754f, 0.12251505f, 0.02324930f, 0.04216224f, 
    -0.15589905f, -0.24087106f, 0.13354430f, 0.09666199f, -0.13704517f, 0.05489034f, 0.02498465f, 0.08319943f, 
    0.02437215f, -0.06544039f, -0.14375803f, 0.07670967f, 0.06979863f, -0.18529038f, -0.05024695f, 0.17284516f, 
    0.02692149f, -0.02750901f, 0.09691950f, -0.00547119f, -0.09319727f, -0.00504387f, 0.11060016f, 0.07229712f, 
    -0.05781972f, -0.15676922f, -0.05019562f, -0.05994289f, -0.11964699f, -0.17365162f, 0.26076588f, 0.05530092f, 
    -0.01948719f, 0.02206960f, -0.05933575f, 0.19240721f, -0.35590240f, -0.06374957f, -0.03188434f, 0.05717748f, 
    -0.12072172f, 0.11795326f, 0.02112498f, 0.11114277f, 0.00548281f, -0.03150503f, 0.09484516f, -0.03040259f, 
    0.00947454f, -0.01719199f, 0.05441112f, -0.00114673f, 0.16160096f, -0.07928967f, -0.25961289f, -0.23617567f, 
    -0.41274384f, 0.06735988f, 0.05580305f, 0.09077162f, 0.04497901f, -0.11311349f, -0.15632033f, -0.02583092f, 
    -0.05448358f, 0.17432673f, -0.00112420f, -0.05593557f, 0.10723273f, 0.02927488f, 0.17626159f, 0.05793745f, 
    -0.38254946f, -0.04584320f, -0.02737147f, -0.38314131f, 0.00435134f, -0.04996288f, -0.13696122f, -0.23245920f, 
    0.08569868f, 0.20506576f, 0.02939945f, -0.03539716f, 0.03618820f, 0.03170528f, 0.05362707f, 0.10647193f, 
    -0.07071760f, -0.07983407f, -0.03555122f, -0.21957946f, 0.12808184f, -0.55116761f, 0.20790252f, -0.02012760f, 
    -0.23792407f, -0.03537748f, 0.11698498f, -0.00782860f, 0.06624120f, -0.06929921f, -0.00881665f, -0.05061194f, 
    0.14496092f, 0.00877708f, -0.03755713f, 0.10238965f, -0.02931224f, -0.09979969f, -0.10511954f, -0.05573830f, 
    -0.73515528f, -0.56044066f, -0.08460661f, -0.05566350f, -0.01943905f, 0.08845738f, -0.01833550f, -0.02348349f, 
    0.05047594f, -0.09423939f, 0.18839940f, 0.02858512f, 0.01355506f, 0.05339525f, 0.12774000f, 0.09557310f, 
    -0.01245414f, 0.02910080f, 0.08584875f, -0.00479304f, -0.04436926f, 0.04075314f, 0.04896963f, -0.02987377f, 
    0.02036866f, -0.13035904f, -0.00157959f, -0.01075275f, 0.05300399f, 0.03118910f, 0.00566089f, -0.04941042f, 
    0.02032625f, -0.09678313f, -0.01733872f, -0.00160750f, -0.00612133f, 0.07949959f, 0.13483660f, 0.06165038f, 
    0.17563854f, 0.04140949f, -0.06786547f, 0.08400850f, -0.14679213f, -0.02881939f, 0.05431908f, -0.00388288f, 
    0.04771173f, 0.00982955f, 0.06658001f, -0.00088450f, -0.03378997f, -0.02567516f, -0.00213236f, 0.03043081f, 
    0.08846933f, -0.07219750f, -0.04480263f, -0.00227606f, 0.10797413f, 0.08663213f, 0.11797090f, -0.05578944f, 
    -0.01650945f, 0.11126958f, -0.10321336f, -0.00603742f, 0.04636585f, 0.09529155f, -0.07847057f, 0.00307062f, 
    -0.01579656f, 0.12953191f, -0.00380946f, 0.06277915f, 0.05760832f, -0.06431875f, -0.11883334f, -0.02129501f, 
    -0.01061017f, 0.06683358f, -0.36052045f, 0.08680708f, 0.01230272f, -0.16534904f, -0.02921884f, -0.09927074f, 
    -0.03156792f, 0.06333451f, -0.00477691f, 0.00701928f, 0.05700492f, -0.15515882f, 0.06300646f, -0.00706986f, 
    0.05428648f, 0.08143870f, -0.04883443f, -0.05183656f, 0.08733477f, -0.21734218f, -0.01708528f, -0.00456535f, 
    0.18680118f, -0.08636906f, 0.07098005f, 0.00729223f, -0.02407997f, -0.24029547f, -0.02032641f, 0.04647180f, 
    0.02723306f, -0.03383620f, 0.00843957f, -0.16329600f, 0.04314055f, 0.01865183f, -0.03143920f, 0.14815843f, 
    0.01004018f, -0.06535022f, -0.26985881f, -0.13595982f, 0.03685757f, 0.00114036f, 0.04508275f, -0.17260933f, 
    0.04006836f, -0.01239195f, -0.00473820f, 0.10044411f, -0.10459896f, 0.00544920f, 0.04468712f, -0.08695403f, 
    0.03810915f, 0.12405305f, 0.07001437f, 0.02301999f, -0.06832943f, 0.24071169f, -0.06475153f, 0.16790973f, 
    0.02184287f, -0.04037546f, -0.04296007f, 0.00657084f, 0.02598605f, 0.08726804f, 0.03025879f, -0.03145014f, 
    0.05013479f, -0.05494219f, 0.04003585f, -0.05330437f, 0.00807906f, 0.08419345f, 0.10589737f, 0.05803541f, 
    0.05996118f, 0.09958328f, -0.07395089f, 0.11151578f, -0.02728814f, -0.00255366f, -0.06110213f, 0.14614077f, 
    0.05938903f, -0.00213661f, 0.13827403f, -0.05116985f, 0.10394646f, -0.04388051f, 0.07273667f, 0.11677118f, 
    0.00743385f, 0.00802603f, 0.13137083f, 0.02410746f, -0.69185996f, -0.54830182f, -0.25922617f, -0.20205134f, 
    -0.18907125f, 0.08199375f, -0.02021402f, -0.15734376f, -0.07538349f, 0.05264700f, 0.00285430f, 0.02296723f, 
    -0.05411931f, 0.21681054f, 0.02245424f, 0.09829955f, 0.16393897f, 0.11933593f, 0.07603533f, 0.08830249f, 
    0.23664621f, 0.21160585f, 0.06111940f, 0.00896261f, -0.10637263f, -0.01015104f, 0.03572609f, 0.08805648f, 
    -0.05866423f, 0.00567256f, -0.04636205f, -0.02117249f, 0.11510177f, -0.02394057f, -0.06163245f, 0.04850235f, 
    -0.02261132f, -0.21217324f, -0.07306308f, 0.02508219f, 0.10916873f, 0.04554397f, -0.03276486f, -0.18633434f, 
    -0.13682351f, 0.05959377f, 0.02732557f, 0.12336154f, 0.04508937f, 0.03781817f, -0.03316922f, -0.01179939f, 
    -0.08306296f, -0.03295428f, 0.02817408f, 0.00972881f, 0.10169503f, -0.03330209f, 0.03309315f, 0.10668689f, 
    -0.63118899f, -0.41591594f, -0.11750840f, -0.01957426f, -0.25879511f, 0.02080472f, 0.08653794f, -0.02177164f, 
    -0.10554522f, 0.01227611f, 0.08304886f, -0.00356463f, 0.01446641f, -0.04597187f, -0.03290012f, 0.05588970f, 
    0.04100389f, 0.02619858f, 0.03729102f, -0.01412611f, -0.04057529f, 0.02117229f, -0.01523624f, -0.04342974f, 
    0.05226155f, 0.00267596f, 0.13862136f, 0.03199811f, 0.08992624f, 0.03087833f, 0.00613065f, 0.03597900f, 
    0.00748846f, 0.05563667f, -0.01624355f, 0.12926580f, 0.03632743f, -0.07297294f, -0.09841049f, -0.01361081f, 
    0.03894402f, 0.18183228f, 0.05446720f, 0.08043529f, 0.01563887f, -0.02709078f, 0.02093548f, 0.06831443f, 
    0.05927754f, -0.01119962f, -0.04513926f, 0.09317655f, 0.03427968f, 0.01908078f, -0.00080694f, 0.08601458f, 
    -0.00163912f, -0.06382684f, -0.11055236f, 0.02194350f, -0.51634926f, 0.01322438f, -0.13326287f, -0.05570175f, 
    0.03000442f, 0.10269216f, -0.01601463f, 0.01222441f, -0.00447372f, -0.01023405f, 0.07712599f, -0.05220991f, 
    -0.06241792f, -0.14455737f, 0.02421457f, -0.04378986f, -0.08031034f, 0.12897061f, -0.01218210f, 0.14069270f, 
    0.36757550f, -0.15346377f, -0.20112187f, 0.09559985f, -0.07385647f, -0.13463300f, -0.02736484f, -0.04944604f, 
    0.03179750f, -0.06984596f, -0.01893859f, 0.07204184f, -0.07836349f, -0.16603613f, -0.09468095f, -0.14501058f, 
    0.00606699f, -0.10532701f, -0.18816431f, -0.11700924f, -0.07298896f, -0.24608059f, 0.05475948f, -0.04074289f, 
    0.15990093f, 0.05803580f, 0.06185987f, 0.15457256f, -0.02842112f, -0.06496766f, 0.03664142f, 0.02749436f, 
    -0.13199225f, 0.02685523f, -0.06670434f, 0.05142521f, 0.02832732f, -0.06086697f, -0.00120343f, 0.16235141f, 
    -0.55195594f, -0.23783395f, -0.00976823f, -0.02979564f, -0.16330552f, 0.06672679f, 0.01312643f, 0.01289978f, 
    -0.08587775f, 0.13113880f, 0.13037795f, -0.01201964f, 0.05037238f, 0.02723636f, 0.03123152f, -0.03607931f, 
    -0.07285629f, 0.04039376f, 0.04675994f, 0.06330710f, 0.00791675f, 0.06210585f, 0.00712877f, -0.00292966f, 
    0.02566916f, 0.00665354f, 0.01143028f, 0.03260747f, 0.08574763f, 0.00884695f, 0.01600954f, 0.14531752f, 
    0.02028291f, -0.00605423f, 0.04000943f, 0.09063496f, 0.08605170f, 0.09092869f, -0.06239012f, 0.12907284f, 
    0.27613789f, 0.16585676f, 0.04511692f, 0.04317024f, -0.12083948f, 0.12112716f, 0.04561773f, 0.12912834f, 
    -0.01433738f, 0.07611412f, -0.01708623f, -0.01291000f, 0.03468841f, -0.06223628f, -0.08402575f, -0.04148273f, 
    0.04764992f, -0.35691568f, -0.01271879f, -0.06336550f, -0.00686808f, 0.17495857f, 0.23772663f, -0.08498517f, 
    -0.13511842f, 0.15088810f, -0.01866370f, 0.06459080f, 0.06470470f, 0.02183149f, -0.04067612f, 0.02950988f, 
    0.04835591f, 0.16140744f, 0.04823503f, 0.01746447f, 0.08552215f, -0.02670221f, -0.08867097f, -0.08352793f, 
    -0.03833694f, -0.05275810f, 0.08290433f, 0.00087354f, 0.06276233f, 0.14534891f, -0.01779320f, 0.12240463f, 
    -0.11478622f, 0.16713756f, 0.11006082f, 0.07868776f, 0.07331119f, 0.00343776f, 0.00080434f, 0.03412863f, 
    -0.00555552f, -0.10454850f, 0.00827816f, 0.04860446f, -0.45296946f, -0.14805555f, -0.24466532f, 0.25224811f, 
    0.09396018f, 0.02463266f, -0.05901101f, -0.09023357f, 0.05113251f, 0.02486588f, 0.08424170f, 0.03018645f, 
    0.01264817f, -0.24710324f, 0.21688709f, 0.00862696f, -0.15999907f, -0.22920398f, -0.07609620f, -0.19903025f, 
    -0.72187489f, -0.25017259f, 0.15709744f, -0.09649576f, -0.26847562f, 0.07704338f, -0.07282607f, -0.07094944f, 
    -0.09147689f, -0.08505739f, 0.09656969f, -0.06807384f, -0.11259215f, 0.04309136f, -0.04966571f, -0.04624146f, 
    -0.14906374f, -0.10320002f, -0.10109122f, -0.11374495f, 0.33644062f, 0.10253452f, -0.01389055f, -0.01275777f, 
    -0.03488686f, -0.26368278f, -0.11358324f, 0.00527250f, -0.00188433f, -0.10452686f, -0.01856421f, 0.03203587f, 
    -0.01081032f, -0.03882294f, -0.10295616f, -0.04970967f, 0.00059139f, 0.00836544f, -0.15209040f, -0.01613082f, 
    -0.28387335f, -0.28327385f, -0.35997248f, -0.17774509f, -0.16865380f, 0.00724708f, 0.07877249f, -0.06771546f, 
    -0.06413220f, -0.07950066f, 0.07673697f, 0.00164069f, -0.01775367f, -0.07443345f, 0.02026969f, -0.08314808f, 
    -0.03622078f, 0.10753457f, 0.10035399f, 0.00384914f, 0.32740593f, 0.15618256f, 0.09444648f, -0.20230944f, 
    -0.09090716f, 0.10830061f, -0.03436992f, 0.05525271f, 0.04799126f, -0.08908754f, -0.03874386f, -0.07037927f, 
    -0.01222604f, 0.10892614f, -0.04928598f, 0.04328429f, 0.03005624f, 0.12276638f, -0.05055466f, 0.07737462f, 
    -0.28695360f, -0.10329477f, 0.01911564f, 0.07653975f, 0.01186445f, 0.09570583f, -0.06227083f, -0.08475418f, 
    -0.10166198f, -0.00770646f, 0.06622491f, -0.03071224f, -0.03296611f, 0.08944138f, 0.01223402f, 0.04240688f, 
    -0.02739157f, -0.11954246f, -0.08670203f, -0.05391524f, -0.37968099f, -0.21194790f, 0.09532835f, -0.05850986f, 
    -0.21218361f, 0.09283269f, 0.00755079f, -0.04999131f, -0.05459233f, 0.10568678f, 0.07517365f, 0.03657123f, 
    0.12607835f, -0.00860780f, 0.11406662f, 0.07004950f, 0.08687857f, -0.00397277f, 0.00521513f, 0.05499196f, 
    -0.40148070f, 0.05820523f, -0.10054180f, 0.03563138f, 0.06653930f, 0.04968445f, 0.00904241f, -0.01798676f, 
    -0.16230975f, 0.10855064f, -0.04750274f, -0.07861352f, 0.09396271f, -0.03584886f, -0.03234620f, -0.05251224f, 
    -0.04853028f, 0.06467325f, 0.03208301f, 0.05805670f, -0.55893797f, 0.14430703f, -0.23115629f, -0.12959810f, 
    0.00496064f, 0.15519537f, 0.00220995f, -0.10364485f, -0.01052425f, 0.02605071f, 0.10722918f, 0.00977052f, 
    -0.04372593f, 0.03744829f, 0.09617753f, 0.02711824f, 0.01894644f, 0.15938650f, -0.08650786f, 0.12987754f, 
    0.37788591f, 0.21439873f, -0.16773959f, 0.12976395f, -0.09792396f, 0.16737904f, 0.02279928f, -0.11071277f, 
    0.00700111f, 0.02427902f, -0.04264848f, 0.12765238f, 0.06353323f, 0.10355098f, 0.14451209f, -0.03309597f, 
    0.06507487f, 0.04029331f, -0.12154263f, 0.05716193f, -0.38892594f, -0.41829103f, -0.04655080f, -0.09301704f, 
    -0.07733547f, 0.06402068f, -0.00585598f, 0.02391174f, -0.01494515f, 0.15641758f, -0.10145890f, -0.00013483f, 
    -0.08295742f, -0.05427904f, -0.07160431f, -0.07797834f, -0.01067607f, -0.02758448f, -0.12619123f, -0.05873986f, 
    0.24202959f, 0.09970579f, 0.06185402f, -0.19285989f, -0.07189117f, -0.05986024f, -0.03675676f, 0.11129436f, 
    -0.12489822f, -0.19142963f, -0.01296328f, -0.12275898f, 0.09217249f, -0.13000940f, -0.14143084f, 0.06446346f, 
    0.01999907f, 0.05166460f, 0.05227018f, -0.03098964f, 0.50534791f, -0.01082173f, -0.13406810f, 0.01516980f, 
    0.07654828f, -0.06411806f, 0.01183051f, 0.00207837f, 0.09801871f, -0.12993897f, 0.14987583f, -0.04069298f, 
    0.04273759f, 0.04408092f, 0.06996924f, 0.10912676f, -0.11022507f, -0.05775437f, 0.06339119f, 0.08040489f, 
    -0.16034377f, 0.17001382f, 0.03882518f, 0.00480533f, -0.19060822f, -0.03269760f, 0.09023064f, -0.10279932f, 
    -0.00104154f, 0.07986982f, -0.24560851f, -0.07356305f, 0.10774485f, 0.10418882f, 0.05008883f, 0.02745628f, 
    0.01240066f, -0.06063799f, -0.06591471f, -0.05122417f, -0.49188977f, 0.37918022f, 0.07307930f, 0.10596830f, 
    -0.17612426f, 0.17884374f, -0.05752037f, 0.12411755f, -0.02864350f, 0.02079120f, 0.02670584f, 0.05357828f, 
    0.04946767f, -0.13733232f, -0.09131368f, -0.02246347f, 0.07155914f, -0.13686340f, 0.08704633f, 0.01186773f, 
    -0.62470031f, -0.13501194f, -0.15550426f, -0.17949776f, -0.02215025f, 0.00382689f, 0.07317982f, -0.02926941f, 
    0.12624969f, 0.02829089f, -0.21904770f, 0.21092933f, 0.08577465f, 0.07202468f, 0.02929238f, -0.02499598f, 
    -0.00588017f, -0.00665036f, -0.25130463f, 0.01195281f, -0.25462335f, 0.05007071f, 0.04901701f, 0.04925535f, 
    0.19709168f, -0.10396029f, 0.12741092f, 0.10147589f, 0.06490373f, -0.00657099f, -0.01196207f, -0.06951485f, 
    -0.02510531f, 0.11633609f, -0.04184865f, -0.00612437f, -0.03030540f, -0.03685460f, -0.03147539f, -0.01317850f, 
    0.20194946f, -0.36835423f, 0.17112669f, 0.01648701f, -0.07607188f, 0.08647825f, 0.09182348f, -0.01030676f, 
    -0.01327903f, 0.08918730f, -0.00825692f, -0.08029895f, -0.09055103f, 0.06500758f, -0.14006893f, -0.10741556f, 
    -0.04446407f, -0.05490940f, -0.18843690f, -0.09775190f, 0.55464321f, -0.17276172f, -0.21183652f, -0.17480850f, 
    -0.22529812f, 0.10183902f, 0.02997915f, -0.09126531f, -0.03248048f, 0.06170949f, 0.19158906f, -0.01489055f, 
    0.00294255f, 0.02882892f, 0.02106776f, -0.00380692f, -0.07699218f, -0.04449750f, -0.01775144f, 0.04574486f, 
    -0.03822162f, -0.07082668f, -0.08286173f, -0.14911273f, 0.32421416f, 0.06805573f, -0.07303359f, 0.06941041f, 
    0.00849764f, -0.06053994f, 0.03112255f, -0.13855600f, 0.02215830f, 0.03982371f, 0.05907115f, -0.07131365f, 
    0.07818089f, -0.03205917f, 0.08840146f, 0.09595435f, -0.10764833f, 0.28619030f, -0.11934049f, -0.09964161f, 
    0.03616887f, -0.08311290f, -0.07856957f, 0.03895535f, -0.16512954f, -0.05146300f, -0.05065863f, 0.05584440f, 
    0.03987158f, -0.08240672f, -0.08889251f, -0.00106932f, 0.01403860f, 0.00105102f, -0.10188366f, -0.19844016f, 
    0.29966393f, -0.01892061f, -0.17608543f, -0.11674411f, -0.20745654f, 0.01807319f, -0.05833711f, 0.12778839f, 
    -0.01338064f, 0.04973866f, 0.06541373f, 0.01139798f, 0.04007765f, -0.03339063f, -0.07419588f, -0.09482009f, 
    0.03918396f, 0.00658860f, -0.10961542f, -0.03560721f, -0.28403810f, 0.29467061f, -0.14913221f, -0.08273844f, 
    0.13855428f, 0.16322675f, -0.13279067f, 0.00563869f, -0.04201395f, -0.15033770f, 0.10962451f, 0.14729983f, 
    0.09597819f, -0.05466111f, -0.04689109f, -0.07348605f, 0.11387039f, 0.05966514f, -0.03421474f, -0.02438494f, 
    -0.21844949f, 0.15387669f, -0.06192121f, 0.01442586f, 0.22787751f, -0.13168977f, -0.01473382f, 0.00153675f, 
    0.00970890f, -0.00674415f, 0.05356246f, -0.09498589f, 0.01184867f, 0.05977661f, 0.12778234f, -0.01036707f, 
    -0.02856687f, -0.00239283f, 0.02122404f, -0.02580475f, -0.45103005f, -0.26583025f, 0.09935526f, -0.08391742f, 
    -0.02007043f, -0.12549146f, 0.11457942f, -0.00732677f, 0.02021889f, -0.08927915f, -0.04171556f, -0.01557246f, 
    -0.00234586f, 0.08047868f, -0.03269606f, -0.09754255f, -0.01992718f, -0.09515563f, -0.05440528f, 0.06818088f, 
    -0.02457971f, 0.02930588f, 0.07974841f, 0.08002722f, -0.08202311f, -0.04267674f, -0.11969556f, 0.11921597f, 
    -0.14272657f, -0.20827217f, -0.06166422f, -0.02829575f, 0.07628656f, -0.11576044f, 0.01802379f, -0.02837831f, 
    0.05023139f, -0.07300477f, 0.03988541f, -0.02077076f, 0.15778671f, 0.10708599f, -0.06389438f, 0.08054252f, 
    0.16965511f, 0.01363837f, -0.03370035f, -0.04967622f, -0.08651251f, -0.11512816f, -0.05399687f, 0.07678393f, 
    0.00854446f, 0.08868177f, -0.12488195f, -0.04715952f, 0.03045938f, -0.04006518f, 0.11781342f, 0.08965737f, 
    0.28267351f, -0.28391010f, -0.08495076f, -0.03402429f, -0.04219057f, 0.02978640f, -0.05598143f, 0.10372747f, 
    0.02689543f, 0.12044248f, 0.03480576f, 0.09663668f, -0.09003571f, 0.08460928f, -0.03080063f, 0.08199342f, 
    0.05917021f, -0.09250147f, 0.08465149f, -0.13687973f, -0.19845511f, 0.21750948f, -0.04527692f, -0.06496086f, 
    -0.00134970f, -0.05677088f, -0.05500842f, 0.00859508f, -0.06352579f, -0.02076871f, -0.02928297f, -0.01857181f, 
    -0.02310153f, -0.08111418f, -0.05491087f, 0.01677154f, 0.00007829f, -0.01218819f, -0.03409925f, -0.08332691f, 
    0.13524032f, -0.06213620f, -0.22613606f, -0.10733572f, 0.06166234f, -0.12264854f, -0.05442426f, -0.07052571f, 
    0.06331257f, -0.03139886f, 0.11474441f, 0.01898407f, -0.05409537f, 0.05233409f, -0.05590836f, -0.05147506f, 
    -0.03649965f, -0.04226849f, 0.11768074f, 0.06001340f, 0.49194551f, 0.09856077f, -0.15171456f, -0.12429257f, 
    0.18691207f, 0.03392626f, 0.01402429f, -0.07242488f, 0.13681020f, 0.01978770f, 0.09813250f, -0.00270821f, 
    0.01795570f, -0.02888300f, 0.00327370f, 0.04900940f, 0.00845061f, 0.01450829f, -0.04454618f, 0.10657187f, 
    -0.04433531f, -0.07135727f, -0.07557991f, -0.08483109f, 0.29287460f, 0.09673510f, -0.18413721f, -0.08634939f, 
    0.12757482f, 0.09841331f, -0.07615410f, -0.01939413f, -0.02406042f, -0.00325750f, 0.13192026f, 0.16831583f, 
    0.05174453f, 0.15977719f, -0.06672665f, -0.05633065f, -0.10982920f, -0.12366302f, -0.26681617f, 0.19507697f, 
    -0.26183975f, -0.15442626f, 0.10409848f, -0.08677357f, 0.01562299f, -0.13900743f, 0.03106146f, -0.10349681f, 
    0.10719016f, 0.11183058f, -0.11464816f, 0.03865483f, 0.09686311f, 0.05903779f, -0.07254355f, -0.27437305f, 
    0.21118155f, 0.36886981f, -0.30221161f, -0.17192814f, -0.29756838f, 0.07413632f, -0.00129273f, -0.06717952f, 
    -0.01982258f, 0.03587144f, 0.10227823f, 0.01134120f, -0.07586171f, -0.04050999f, 0.03709764f, -0.10060083f, 
    0.02687964f, 0.08528504f, -0.04633206f, 0.10067081f, -0.17311528f, 0.07547344f, 0.05792963f, -0.01609246f, 
    0.01648442f, -0.03001479f, 0.01223729f, -0.02094476f, -0.04088859f, -0.14029717f, -0.03586359f, -0.04806534f, 
    0.09292641f, 0.04062908f, -0.06715016f, -0.10041037f, -0.09615701f, -0.07587462f, -0.10263649f, 0.02401519f, 
    -0.25859204f, -0.51622295f, -0.21202770f, -0.16883047f, -0.33525828f, 0.05904669f, 0.11757796f, 0.10052311f, 
    0.02649088f, 0.12627335f, -0.02635018f, 0.00804106f, 0.02532122f, -0.02473754f, -0.01769533f, -0.04680202f, 
    -0.01866846f, -0.09750377f, -0.10980657f, -0.02704222f, -0.12879452f, 0.25423574f, -0.13323265f, -0.25156108f, 
    -0.01647910f, -0.12805532f, -0.10939763f, 0.10435343f, -0.09386880f, -0.15728022f, -0.08107944f, -0.09084903f, 
    -0.13462856f, -0.16887929f, 0.17619336f, 0.06221715f, -0.16846621f, -0.03251587f, 0.16759698f, -0.09966905f, 
    -0.10304426f, 0.36507916f, -0.12856266f, -0.16765164f, 0.18256724f, 0.20330615f, -0.09683891f, 0.01562918f, 
    0.08392436f, 0.00566464f, 0.09319203f, 0.04647594f, -0.03262607f, -0.01955866f, 0.05439362f, -0.01454130f, 
    0.07668236f, 0.12473483f, 0.05881566f, 0.08324926f, 0.05998899f, 0.11137730f, -0.10304002f, -0.04739375f, 
    0.39216593f, 0.09994651f, -0.05363036f, -0.04214530f, 0.02915912f, 0.06000454f, 0.08451676f, -0.02696617f, 
    -0.02993101f, 0.06484195f, 0.04417153f, 0.09203210f, 0.07889511f, 0.06687650f, -0.04148168f, -0.09087632f, 
    0.06001990f, -0.28057140f, -0.10989661f, 0.22184256f, 0.01708267f, -0.21513836f, 0.16248515f, 0.13537158f, 
    0.00648356f, -0.01251331f, 0.12368630f, -0.05955305f, -0.11596823f, -0.02285024f, 0.02203691f, 0.06875546f, 
    0.09697364f, -0.16060406f, 0.16916418f, 0.08206084f, -0.05354946f, -0.05300433f, 0.01962021f, 0.06175496f, 
    0.02536352f, -0.16302730f, 0.17236440f, -0.08607469f, 0.06275489f, -0.04382627f, 0.09148449f, -0.04101723f, 
    0.03977698f, 0.06955893f, -0.00192326f, -0.05513911f, -0.00975679f, -0.08092947f, 0.03344979f, 0.05005366f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06137370f, 0.07120083f, -0.02380246f, -0.03589081f, 0.02014666f, 0.01546812f, -0.02722092f, -0.10555955f, 
    -0.01824623f, 0.00727492f, 0.05719795f, 0.04629407f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
