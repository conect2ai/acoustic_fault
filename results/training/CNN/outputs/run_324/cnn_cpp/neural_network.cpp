#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.09769605f, -0.27548069f, 0.91680014f, -1.79015172f, -1.27020192f, -0.44248813f, 0.57685071f, 0.34177700f, 
    -0.86023408f, -0.15552704f, -1.41038537f, -1.07994866f, 0.19830512f, -1.06453502f, -0.95592767f, 0.03693786f, 
    0.25058618f, 0.26664206f, -1.43952584f, 1.22001612f, 0.72102839f, -0.90695882f, 1.41033959f, -0.03821098f, 
    -0.02827646f, -0.30116096f, 0.36273634f, -0.82533175f, -0.58742094f, -0.84241682f, 0.44951156f, 1.12727249f, 
    -0.68173540f, -0.32335258f, -0.77435291f, 0.06764509f, -0.81910974f, -0.87525284f, -0.63945127f, 0.67738807f, 
    1.43931556f, -0.00703414f, -0.20329268f, 0.38232601f, 0.15066354f, -1.50720727f, 1.04361808f, 1.55144286f, 
    0.47273391f, 0.09457743f, 0.59099054f, -0.30888534f, 0.14295439f, -0.07747962f, 0.99847662f, 1.41888094f, 
    -0.07369551f, 0.87779713f, 1.09069037f, 1.21899796f, 0.49131954f, -0.62863654f, 0.06568009f, 0.83483350f, 
    1.03904760f, 1.58582234f, -0.79438573f, 0.87216163f, -0.56734800f, 0.07013448f, -0.32106349f, -0.10911916f, 
    -0.71553880f, -1.56325293f, -0.96762478f, -0.66687047f, 1.05894852f, 0.83885950f, -0.61002600f, -0.10330779f, 
    -0.49735484f, 1.71939850f, 1.34614766f, 0.97285134f, -0.57179457f, -1.11517549f, -0.49790174f, 0.21675354f, 
    0.63026589f, 0.15744776f, 1.50046456f, -0.84017670f, -1.02375305f, -1.07252526f, 0.17778249f, -0.62684423f, 
    0.07463674f, 0.19518341f, -0.16589375f, -0.77768850f, -1.75012445f, 1.19207454f, 0.64918053f, -0.50753719f, 
    0.86520845f, -0.14653070f, -0.16723591f, -0.10665668f, -1.11545789f, -1.42475343f, -0.26311743f, -1.17961764f, 
    -0.30388120f, 0.67572725f, 0.59810859f, 0.03599784f, 0.16858764f, -1.61987805f, -0.15219249f, -0.00758928f, 
    1.32040107f, 0.45843303f, 0.64871603f, 0.12755410f, -0.81655437f, 0.58633417f, -1.66078556f, 1.37662768f, 
    -0.80433720f, 0.64802414f, -0.49119154f, -0.48376462f, -0.07575187f, 0.25649992f, -0.28923514f, 1.59083235f, 
    -0.91282821f, -1.22780931f, 0.98905700f, -0.73984301f, -0.09888504f, -0.12236804f, -0.35971990f, 0.13474469f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13937746f, 0.49365681f, 0.03445714f, -0.00296126f, 0.17783594f, 0.05195145f, 0.39037359f, 0.20492974f, 
    0.07102692f, 0.30348268f, 0.39562768f, 0.21791042f, 0.44685376f, 0.12811695f, -0.17598653f, 0.32524270f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01736214f, -0.32823762f, -0.17371750f, 0.28309977f, -0.17422190f, -0.05824991f, -0.13388525f, -0.00205637f, 
    0.02382377f, -0.06105141f, 0.05972722f, -0.10483858f, 0.11663719f, -0.14051694f, 0.07186800f, 0.06022684f, 
    -0.02365749f, -0.03426797f, -0.02402189f, -0.05354442f, -0.29616508f, -0.94224304f, 0.15418027f, 0.07357259f, 
    -0.15701313f, 0.05085160f, -0.14074671f, 0.25714561f, 0.06991083f, 0.05838538f, -0.20729473f, -0.08199153f, 
    -0.16665140f, 0.03918920f, 0.02638678f, 0.14198361f, 0.08533023f, 0.10001575f, -0.09213842f, -0.12035260f, 
    0.22184075f, 0.07060019f, 0.32347339f, -0.22152610f, 0.15721966f, -0.08648885f, -0.10025329f, 0.01687884f, 
    -0.10748022f, 0.01844234f, -0.06507959f, -0.00479075f, 0.26645678f, 0.01942793f, 0.02262852f, -0.00506565f, 
    -0.02123298f, -0.03864043f, 0.09084055f, -0.06440309f, 0.51144505f, 0.25636005f, 0.24940184f, -0.08783872f, 
    -0.27537638f, 0.03438970f, 0.09698305f, -0.06152312f, 0.01229545f, -0.13365945f, 0.02422498f, 0.05617632f, 
    -0.04513956f, 0.10296924f, 0.04617330f, 0.03897281f, -0.02187883f, 0.03356000f, -0.09679598f, 0.00162050f, 
    0.10951131f, 0.39384392f, 0.15262440f, -0.37977886f, -0.38290739f, 0.06642511f, 0.11136117f, 0.02320527f, 
    0.03757621f, 0.00504422f, 0.10588311f, 0.01320069f, -0.07580572f, -0.01248073f, 0.05605565f, -0.01238635f, 
    0.02347856f, 0.10252336f, 0.03515754f, -0.02001008f, -0.62091708f, 0.19308637f, 0.37704495f, 0.26008135f, 
    0.35477582f, 0.01960928f, -0.15785319f, 0.05542637f, 0.01375237f, -0.03644928f, 0.12354738f, -0.09776305f, 
    0.11570189f, 0.09313206f, -0.09424002f, 0.05170313f, -0.14091417f, 0.03131700f, 0.03152208f, 0.07297899f, 
    -0.10357009f, -0.08688518f, 0.01539858f, -0.26617226f, 0.37053692f, -0.42252374f, -0.06880977f, 0.07849062f, 
    -0.05440355f, -0.16105929f, -0.13471963f, 0.03357715f, -0.08333413f, -0.00960320f, 0.05430002f, -0.10939272f, 
    0.09258553f, -0.08438706f, -0.06172545f, -0.04370097f, 0.23195747f, 0.26510125f, -0.04167385f, -0.03021908f, 
    0.13216276f, -0.38810086f, -0.21022578f, -0.15632580f, 0.04509480f, 0.03464607f, -0.03264021f, -0.00383425f, 
    0.03024438f, -0.08947196f, 0.02569654f, -0.12336351f, 0.00580164f, -0.05539688f, -0.00421345f, 0.02746985f, 
    -0.43050098f, 0.24980137f, -0.27656618f, -0.08316863f, -0.48357078f, 0.06370858f, 0.18925853f, 0.04305489f, 
    0.01563501f, -0.02886388f, 0.01295332f, 0.08894038f, 0.11407150f, 0.04580853f, -0.09482825f, -0.08316812f, 
    -0.11129820f, -0.00665758f, -0.15872069f, -0.07161821f, 0.15014352f, 0.12974855f, 0.15695806f, -0.31211844f, 
    0.27180207f, -0.25867531f, -0.24784620f, -0.10550142f, 0.14763683f, -0.05877783f, -0.04013066f, -0.08191055f, 
    -0.03651055f, 0.02920910f, -0.02414941f, 0.01734844f, -0.01226510f, 0.06334962f, 0.09459361f, -0.01885878f, 
    -0.10001812f, -0.33405691f, 0.19810788f, 0.25384834f, 0.11869580f, -0.21164168f, -0.10238820f, -0.09231027f, 
    -0.02739427f, 0.10371774f, 0.01253512f, 0.03617200f, 0.16176583f, -0.05631825f, 0.01753645f, -0.01123858f, 
    -0.15243906f, -0.17364599f, 0.17924592f, -0.08160193f, -0.28102264f, -0.17414895f, 0.18926843f, 0.00767445f, 
    -0.51917273f, -0.04942607f, 0.21860147f, 0.04501445f, 0.12911099f, 0.02676611f, 0.04132876f, 0.00670910f, 
    -0.18598208f, -0.11168577f, -0.12484102f, 0.00644787f, -0.00647238f, 0.05477650f, 0.05287166f, 0.01790746f, 
    -0.38999927f, -0.16290970f, -0.24634460f, 0.13645561f, -0.24074924f, -0.13818762f, -0.01008428f, -0.09545262f, 
    0.10868795f, -0.11049061f, 0.03279538f, 0.03540926f, -0.13390075f, -0.02019437f, 0.05449815f, -0.20961270f, 
    -0.07148635f, -0.02561945f, 0.02665857f, -0.01392239f, 0.73597628f, -0.17602277f, 0.17200980f, -0.08631726f, 
    -0.27449921f, 0.02888809f, 0.13042265f, -0.18422720f, 0.04295068f, -0.05763857f, -0.05567453f, -0.04934885f, 
    -0.07776723f, -0.15740760f, 0.11067184f, 0.04527723f, 0.05482697f, 0.06034243f, 0.06907341f, 0.00333640f, 
    0.47993299f, 0.08313571f, 0.07335603f, -0.10785636f, -0.08778181f, 0.04780593f, -0.31666580f, 0.17011234f, 
    -0.07656249f, 0.08781131f, 0.03909105f, 0.00936608f, -0.14230452f, 0.06089709f, 0.07657300f, -0.24631260f, 
    0.00130777f, 0.08847908f, -0.08448706f, -0.17656863f, 0.32637820f, -0.73537976f, 0.30172065f, 0.16766976f, 
    0.19227281f, 0.02255605f, 0.15292588f, 0.11092068f, 0.14268000f, -0.14888266f, -0.39723995f, 0.21253690f, 
    0.08590508f, 0.04587821f, -0.04305305f, 0.21147344f, -0.06965751f, 0.13941902f, -0.08361671f, 0.04108460f, 
    -0.74957019f, -0.18903182f, -0.19756474f, -0.06869409f, -0.29822901f, -0.02232581f, 0.01840808f, -0.08228427f, 
    0.08876377f, -0.04608971f, -0.09372094f, 0.07879063f, -0.12597159f, 0.26273060f, -0.24048503f, -0.14004309f, 
    -0.18472655f, -0.06873377f, -0.10211842f, -0.10771400f, -0.13065013f, 0.14902675f, 0.03771742f, 0.00389957f, 
    -0.00219389f, 0.10408393f, 0.13112830f, 0.22453922f, -0.01065989f, 0.09807561f, -0.00680835f, -0.19116729f, 
    0.25695896f, 0.20291276f, -0.14967845f, 0.04996056f, 0.13655983f, -0.44531208f, -0.03855256f, -0.06800546f, 
    -0.34137481f, 0.19211873f, -0.22058736f, -0.33856529f, 0.21089934f, -0.21402450f, 0.27393845f, -0.03661496f, 
    0.00948627f, -0.06751740f, -0.02054058f, -0.16704553f, 0.08380883f, -0.03656928f, -0.15444303f, 0.01056678f, 
    -0.10001987f, 0.10170174f, -0.04815830f, 0.02229140f, -0.02093033f, -0.12324408f, -0.24880207f, -0.07739148f, 
    -0.18829665f, -0.04174954f, -0.04731318f, 0.07853503f, 0.17077437f, 0.08758481f, 0.00197551f, 0.07913099f, 
    -0.10357563f, -0.21165565f, 0.18280740f, -0.05821073f, 0.07514930f, -0.11611768f, 0.03158433f, -0.21289374f, 
    0.27383989f, -0.08407947f, -0.23132566f, -0.01627742f, -0.23344588f, 0.07396410f, 0.06114367f, -0.04593706f, 
    -0.01471750f, 0.11042381f, -0.01346031f, 0.11482769f, -0.06036381f, 0.13048527f, -0.03039541f, 0.21049622f, 
    0.06506678f, 0.08344876f, -0.11950142f, 0.14680390f, -0.08797339f, 0.02199703f, -0.28942034f, -0.17134713f, 
    -0.06984928f, -0.07598595f, 0.09964878f, 0.03002454f, -0.14325519f, 0.00886544f, -0.04924899f, 0.06690563f, 
    0.18612064f, -0.06888447f, -0.08170339f, 0.00015305f, -0.22545196f, 0.18304513f, 0.06041819f, 0.10799369f, 
    0.32470959f, 0.22763015f, 0.26133031f, 0.22935264f, 0.33645728f, -0.16800530f, -0.00522329f, -0.10266654f, 
    0.03700253f, 0.00351623f, -0.01660935f, 0.04485271f, -0.04756329f, 0.12061982f, -0.00959383f, 0.01634141f, 
    0.04337671f, 0.07998689f, 0.03885770f, 0.13050467f, 0.24120910f, 0.31209135f, 0.05145128f, 0.16543594f, 
    0.47046861f, -0.14824228f, -0.12078022f, 0.07569988f, 0.07911012f, -0.03069539f, 0.15856446f, -0.14458399f, 
    -0.09867368f, 0.12185168f, -0.16353488f, 0.10041541f, 0.14619108f, 0.03613229f, -0.11680602f, -0.07050742f, 
    0.33582723f, -0.44217086f, -0.07437699f, -0.02450323f, -0.23644152f, -0.05836787f, -0.05928308f, -0.06811028f, 
    -0.02395955f, 0.03843563f, 0.04101352f, -0.02924971f, 0.01092298f, -0.00342489f, -0.01302186f, 0.15709034f, 
    0.01729528f, -0.02041263f, -0.18733814f, 0.08008081f, 0.27785021f, 0.01622769f, 0.07555056f, 0.09469124f, 
    0.18512790f, -0.04330529f, -0.21614617f, 0.05338939f, 0.01907039f, -0.01732995f, -0.04837580f, 0.05037202f, 
    0.11281081f, 0.11204188f, 0.02554078f, 0.01031350f, 0.12482128f, -0.20650065f, -0.17111537f, -0.04831792f, 
    0.66813248f, -0.74283749f, -0.00226094f, -0.15628608f, -0.02463905f, 0.02383790f, -0.08886251f, -0.05290234f, 
    0.06123535f, -0.05965225f, -0.23265623f, 0.11237109f, -0.07389788f, 0.11336677f, -0.01110527f, 0.07181297f, 
    -0.13500737f, -0.02760985f, -0.15328328f, 0.02081538f, -0.03402217f, 0.37483078f, -0.08641858f, 0.16149977f, 
    -0.65919757f, 0.05812988f, 0.00795917f, -0.00315936f, 0.08143707f, 0.16711326f, 0.13574463f, 0.02365320f, 
    -0.10147484f, -0.01732585f, 0.06487904f, -0.05015040f, 0.08251686f, -0.00234268f, 0.03069494f, 0.17549683f, 
    0.11439713f, 0.02395309f, -0.05450693f, 0.11232343f, -0.21227936f, 0.00513735f, 0.01621903f, 0.00769884f, 
    0.13603874f, 0.07192870f, -0.06604879f, -0.21607074f, 0.01681186f, 0.20897849f, -0.15682393f, 0.01761518f, 
    0.00193401f, -0.01882440f, -0.13404982f, -0.06766295f, -0.48295236f, 0.44978410f, 0.00312407f, 0.03268638f, 
    -0.03287354f, 0.11793657f, 0.02639005f, 0.04863374f, -0.20092502f, -0.04707598f, 0.00782760f, 0.12755077f, 
    0.00428804f, 0.01837337f, 0.04022799f, 0.15460697f, 0.01828424f, -0.04582422f, 0.15337996f, 0.06038936f, 
    -0.85494530f, -0.32623696f, -0.55187702f, -0.28029504f, 0.45198259f, 0.15048455f, -0.01659550f, -0.15524186f, 
    -0.01367938f, 0.04771227f, 0.21776290f, 0.12831047f, -0.05564727f, -0.22241989f, 0.01214863f, -0.01734613f, 
    -0.03333134f, -0.15584844f, -0.04747483f, -0.06603373f, 0.10695396f, -0.46903279f, 0.13168183f, -0.37117144f, 
    -0.11021698f, 0.01963807f, -0.01674308f, -0.04928867f, -0.10863487f, 0.04219867f, 0.08638242f, -0.02779779f, 
    -0.11705235f, -0.02853102f, -0.11774784f, -0.02865164f, -0.02768442f, -0.22239876f, 0.08769055f, -0.15729594f, 
    0.03440607f, 0.10009926f, -0.06810286f, -0.08735261f, -0.34386626f, -0.07383309f, 0.21582407f, 0.00434521f, 
    0.05692348f, -0.11803301f, 0.07185583f, -0.05859300f, 0.01708312f, 0.04213819f, -0.07374626f, 0.10073434f, 
    0.03093659f, -0.16024213f, -0.06125287f, -0.24044511f, -0.57109165f, -0.79133147f, 0.00005672f, -0.31572169f, 
    -0.51293677f, 0.00776282f, -0.17098568f, -0.36090478f, -0.08501642f, 0.06582899f, -0.06869026f, -0.06291467f, 
    -0.05754398f, -0.06158807f, 0.01053266f, -0.06608852f, 0.01049866f, 0.21842588f, -0.10044581f, 0.01191918f, 
    0.17563555f, 0.18633859f, -0.29696369f, -0.03689312f, -0.21693037f, 0.12221649f, 0.09428314f, -0.03832310f, 
    -0.00154380f, -0.05548012f, 0.07556653f, -0.00958900f, 0.14153530f, -0.06463248f, 0.08447612f, 0.13170844f, 
    -0.15847044f, -0.23604573f, 0.09576093f, -0.06841487f, 0.36788872f, -0.27529877f, 0.21774124f, 0.00464583f, 
    0.24741672f, 0.04462631f, -0.01395238f, -0.20449866f, 0.08500469f, 0.07381188f, 0.15637939f, -0.04066311f, 
    -0.01755253f, 0.09750343f, 0.02649090f, 0.06737900f, -0.14808890f, -0.00758579f, -0.03985073f, -0.08662160f, 
    0.58470577f, -0.23636189f, 0.44169453f, -0.08297782f, 0.44385058f, -0.06137152f, -0.07622007f, -0.21493651f, 
    0.11688477f, 0.05568260f, 0.22274923f, -0.07702555f, -0.07869188f, -0.01802000f, 0.02787201f, -0.09207334f, 
    -0.14385608f, 0.06803921f, 0.03386169f, -0.04243544f, 0.61808515f, 0.05296233f, -0.49918389f, 0.06595530f, 
    -0.05628835f, -0.25322366f, 0.05603221f, 0.10767969f, 0.04739758f, -0.00886863f, -0.02506220f, 0.09179746f, 
    0.01507735f, -0.01864085f, 0.05673910f, -0.14247026f, -0.04252463f, -0.14237151f, -0.03084540f, -0.06195461f, 
    0.28223580f, -0.01166557f, 0.11833099f, -0.25908640f, 0.06195360f, 0.20173445f, -0.10953294f, 0.19883120f, 
    0.14108129f, 0.06809048f, -0.00962732f, -0.01273319f, 0.08418591f, 0.11173913f, -0.09288573f, -0.10611043f, 
    -0.11527532f, -0.04368173f, -0.22514066f, -0.07771209f, -0.10997812f, 0.12418915f, -0.23660865f, -0.20121495f, 
    0.05631330f, 0.16470557f, 0.17683646f, 0.11516591f, -0.05143210f, -0.19616057f, -0.00585900f, -0.00374628f, 
    -0.12119280f, -0.15991496f, -0.02015066f, -0.12197625f, -0.09033161f, 0.04967893f, -0.07063158f, -0.04972684f, 
    0.57326931f, 0.05066583f, -0.32153857f, 0.40217453f, 0.10364555f, -0.36712003f, -0.06884526f, -0.04054172f, 
    0.11124204f, 0.14041567f, 0.12361760f, 0.05804043f, -0.03553083f, 0.22254282f, -0.10382337f, -0.07898096f, 
    -0.06463603f, -0.01000739f, -0.10670069f, -0.13912497f, -0.34714624f, 0.21826315f, -0.04611378f, -0.26133254f, 
    -0.04001453f, 0.18660864f, 0.11933897f, 0.31718659f, -0.10328814f, -0.14805667f, -0.18579926f, 0.13041985f, 
    -0.03086508f, -0.18289106f, -0.05401348f, -0.07018737f, -0.02522026f, 0.09248089f, -0.14018564f, 0.10251621f, 
    0.15410541f, -0.14531344f, -0.09779812f, -0.44457334f, -0.37422723f, -0.11800648f, 0.08452818f, 0.10510201f, 
    0.03140458f, -0.01074911f, 0.03866318f, -0.10150895f, -0.13138588f, -0.21404515f, -0.00697880f, 0.16333185f, 
    -0.01299546f, 0.05732346f, 0.12073850f, 0.03080821f, -0.19685505f, 0.06074020f, -0.12487084f, -0.00635960f, 
    -0.00476408f, -0.37365261f, -0.08420495f, -0.08141366f, -0.09802185f, -0.19228670f, 0.07019516f, 0.05148394f, 
    0.11438269f, -0.16515823f, 0.07620753f, -0.05964852f, 0.00596563f, -0.08928352f, -0.08142318f, 0.05028249f, 
    0.79791439f, -0.25451645f, -0.21790384f, 0.03982734f, -0.32569051f, -0.28545329f, 0.21300469f, -0.09347373f, 
    0.01732499f, -0.02743247f, 0.01568720f, -0.04368971f, 0.07414480f, -0.04598422f, -0.11067790f, 0.16160427f, 
    -0.10069607f, -0.00101902f, 0.21642214f, -0.09295072f, 0.37446603f, 0.14727953f, 0.25667036f, 0.10895730f, 
    0.41769552f, -0.12014778f, -0.06992934f, -0.45959809f, 0.16025116f, -0.04321029f, 0.08759702f, -0.02113694f, 
    -0.05827672f, -0.06336043f, 0.01863136f, -0.00261215f, 0.01212809f, -0.08035255f, 0.01693328f, 0.01991677f, 
    0.23217696f, 0.03844863f, 0.05325294f, -0.32612965f, -0.00800722f, -0.00378322f, -0.16579881f, 0.08142386f, 
    -0.08416045f, 0.00805162f, -0.30140215f, 0.13687682f, -0.01515879f, 0.05896078f, -0.20152785f, -0.06814065f, 
    0.03057464f, 0.20762947f, 0.10865469f, 0.00372682f, -0.34644660f, -0.27600268f, -0.05906372f, -0.02463286f, 
    -0.24789211f, 0.01841523f, -0.11447081f, -0.01793662f, 0.04516562f, 0.25584829f, -0.18320985f, -0.03173641f, 
    -0.01676252f, 0.02985439f, -0.08216091f, 0.00334980f, -0.00581860f, -0.07168321f, 0.04734278f, 0.00678764f, 
    -0.26898870f, 0.52314109f, 0.12110676f, 0.50276554f, 0.26744032f, 0.19314671f, 0.17754227f, 0.03475907f, 
    -0.18998426f, 0.06024381f, -0.10312308f, -0.06951505f, -0.09349139f, -0.10557295f, -0.12065534f, -0.03921751f, 
    0.01601609f, 0.00321918f, 0.32357749f, -0.18180180f, 0.35370636f, 0.36165524f, -0.28821951f, 0.08116622f, 
    -0.24478091f, -0.06175856f, 0.05639200f, -0.16273914f, 0.01165397f, 0.04538213f, -0.06597577f, -0.05904115f, 
    -0.02957773f, -0.14274496f, 0.07383739f, -0.01356921f, 0.01124710f, 0.16534725f, -0.06669892f, 0.07159688f, 
    -0.59834826f, 0.45881253f, 0.19469345f, -0.01744314f, -0.15139778f, 0.04646364f, -0.05304397f, -0.05776420f, 
    0.12676080f, -0.09013421f, 0.06446206f, -0.10150474f, -0.10414902f, 0.03212966f, -0.07849969f, -0.09053414f, 
    0.00117717f, -0.33923942f, 0.15466522f, -0.07046420f, -0.18493633f, 0.11988406f, -0.15696527f, 0.15871014f, 
    -0.03222938f, -0.00039491f, -0.23396014f, 0.12712802f, 0.06241699f, 0.04240923f, -0.08081868f, -0.05910607f, 
    -0.08165200f, 0.00991657f, -0.05353764f, 0.00474719f, -0.03729144f, 0.07365029f, 0.14198793f, -0.02672762f, 
    -0.36024883f, 0.23158535f, -0.18118736f, -0.10003716f, -0.18497500f, -0.12063694f, -0.19279140f, -0.01610271f, 
    0.06211370f, 0.05693901f, -0.26288661f, 0.06055344f, 0.08040113f, 0.03867257f, 0.05728586f, 0.02301358f, 
    -0.01853325f, -0.07979216f, 0.19340938f, 0.05335200f, -0.38552082f, -0.24575943f, 0.10737840f, -0.21053052f, 
    0.05327819f, -0.04648431f, -0.18446739f, 0.09740625f, 0.08236518f, -0.17654218f, 0.12270728f, 0.04729823f, 
    -0.07520609f, -0.00211056f, -0.09040112f, -0.06836100f, 0.01033877f, -0.13340446f, 0.05857320f, 0.02425285f, 
    -0.63599461f, -0.80896819f, -0.09429274f, -0.34106049f, -0.35888442f, -0.22689301f, -0.08196148f, -0.20736718f, 
    0.07946776f, 0.02992739f, -0.17208129f, -0.04693638f, 0.12065323f, 0.03107278f, 0.02337180f, 0.04861608f, 
    -0.04868862f, -0.12503420f, 0.02580253f, 0.15775770f, -0.76923352f, -0.17480892f, -0.31926927f, 0.20139782f, 
    0.20094876f, -0.08319312f, 0.04066841f, 0.11732265f, -0.08257040f, -0.02517255f, -0.05347279f, -0.12829766f, 
    0.12293638f, -0.05026411f, 0.04536599f, -0.03754427f, -0.05010591f, -0.04919608f, 0.00277778f, 0.17983603f, 
    0.00090785f, -0.07907255f, 0.01361166f, 0.11475947f, -0.30736849f, -0.01665447f, -0.22617604f, 0.11401926f, 
    -0.04355810f, 0.07352510f, -0.03108297f, 0.18347435f, 0.03696378f, -0.04355455f, 0.08306396f, 0.07578725f, 
    0.03444364f, 0.19125339f, 0.08103655f, 0.04690045f, -0.17066956f, -0.97650337f, -0.50516748f, 0.15779351f, 
    0.43866470f, 0.05678015f, 0.10106245f, 0.09560693f, 0.04303774f, -0.19174764f, -0.00125584f, -0.00601544f, 
    -0.15869282f, -0.16935323f, -0.05214178f, -0.03581374f, -0.03304603f, 0.08068916f, -0.00643110f, -0.06631967f, 
    -0.07782428f, 0.22542755f, 0.32195604f, 0.10439979f, 0.18258005f, -0.05404257f, 0.09012081f, -0.01985287f, 
    -0.02237490f, 0.11376183f, 0.27523831f, 0.09693977f, 0.02375471f, -0.02535659f, -0.08243138f, 0.02279671f, 
    0.07676857f, 0.05676033f, 0.12680025f, 0.13481507f, 0.34411132f, -0.16388793f, 0.17537062f, -0.13363574f, 
    0.04500461f, -0.06197773f, 0.05476395f, -0.07243335f, -0.02023680f, -0.10189450f, 0.10218222f, 0.02521575f, 
    0.14817594f, -0.04232692f, 0.06281351f, -0.17656048f, 0.01308473f, -0.02253457f, 0.07092261f, -0.04929698f, 
    -0.03038786f, 0.02504415f, 0.33233792f, 0.14861587f, -0.04544077f, -0.08466534f, -0.15673378f, -0.13346945f, 
    -0.14704010f, -0.05466233f, -0.02875390f, -0.07347899f, -0.01430113f, -0.09968329f, 0.14283611f, 0.03318558f, 
    0.09531181f, 0.07537542f, 0.00058989f, -0.04819147f, -0.15633217f, 0.11889959f, -0.17694224f, -0.22874215f, 
    -0.21560521f, -0.17271703f, -0.21036752f, -0.03007730f, 0.19033732f, -0.19010597f, 0.06297996f, -0.12356450f, 
    0.04902162f, -0.04977722f, -0.11562341f, -0.03336286f, 0.02749073f, 0.12267804f, -0.20070112f, -0.06882863f, 
    0.86065364f, 0.52349550f, -0.05144811f, -0.03954398f, 0.06407163f, -0.10026151f, 0.02891640f, -0.03525684f, 
    0.21421574f, 0.11260409f, -0.25376844f, 0.02617956f, -0.07806307f, 0.07202556f, 0.03946781f, -0.17502940f, 
    -0.19262713f, 0.08119712f, 0.12122685f, 0.05214835f, 0.09681818f, 0.23620398f, 0.05957559f, 0.15622406f, 
    -0.17846011f, -0.03907768f, 0.17814161f, -0.02010707f, 0.10703003f, 0.03630577f, 0.12346499f, -0.01481770f, 
    -0.13167726f, -0.17850915f, -0.07256182f, -0.00935000f, 0.10176950f, -0.14172305f, -0.03092525f, -0.01225580f, 
    -0.08850413f, -0.48327279f, 0.11319330f, 0.21071108f, 0.08856346f, -0.00330374f, -0.04917483f, 0.11015671f, 
    -0.14970811f, 0.03880166f, 0.10157916f, 0.02800817f, -0.08032302f, -0.10340971f, 0.10902145f, -0.01901270f, 
    -0.15110984f, 0.10883382f, -0.03596463f, 0.06670935f, -0.12217871f, 0.13860734f, 0.06834656f, 0.12063761f, 
    0.00489977f, 0.07647833f, 0.02106540f, -0.01768837f, 0.03237636f, -0.06329393f, 0.18313006f, -0.03773322f, 
    -0.00759094f, 0.03409570f, 0.04665963f, 0.03053455f, -0.04361982f, 0.03108848f, 0.06348725f, 0.16536470f, 
    -0.62870634f, 0.21480834f, -0.03382143f, 0.12842909f, -0.08487225f, 0.16198410f, -0.15831368f, 0.15197718f, 
    -0.11698189f, -0.00256983f, 0.12409615f, -0.00493632f, -0.19272286f, 0.08605813f, -0.01471257f, -0.03027111f, 
    0.03445194f, -0.19005844f, -0.28496194f, -0.11380482f, -0.87395924f, -0.12008935f, 0.04003051f, -0.06207163f, 
    0.01219748f, -0.01291541f, 0.07484702f, 0.07310336f, 0.08981700f, -0.00345822f, 0.01492552f, -0.13087186f, 
    0.09366205f, 0.19171377f, 0.02481327f, 0.03510633f, 0.03186054f, 0.21909657f, 0.09060480f, 0.10398206f, 
    -1.04872668f, 0.08727604f, 0.21325134f, -0.00757662f, 0.17079544f, 0.00774121f, -0.03524651f, 0.11628412f, 
    0.05378856f, 0.01953051f, 0.01522761f, 0.18971948f, -0.00540430f, 0.01693388f, 0.05891332f, 0.06514082f, 
    -0.01076530f, 0.12525487f, 0.03455821f, -0.10308884f, 0.70773089f, 0.44483134f, -0.40003493f, -0.22046599f, 
    -0.01377490f, -0.12139676f, 0.01184085f, 0.07631715f, 0.11011175f, -0.02288267f, -0.13978833f, -0.05360303f, 
    -0.10947691f, -0.11352558f, -0.06252117f, 0.00052058f, -0.02274654f, -0.03157945f, -0.13543499f, -0.07847502f, 
    0.15477997f, -0.15508869f, -0.12576865f, 0.17097129f, 0.03546324f, -0.02373204f, 0.04381263f, -0.08437901f, 
    0.06759974f, 0.06717886f, 0.03594110f, -0.02554964f, 0.13493754f, 0.02339408f, -0.00994542f, 0.07466975f, 
    0.00122756f, -0.25774512f, 0.03190035f, -0.08018258f, -0.57644874f, 0.16588518f, 0.12295705f, 0.13433205f, 
    -0.21977614f, -0.00891860f, -0.14832170f, 0.01905522f, -0.00061068f, 0.01258515f, 0.08011620f, -0.00135850f, 
    -0.03304550f, -0.08432790f, -0.00965328f, 0.04638750f, 0.08485912f, -0.19981018f, 0.13083060f, 0.12257731f, 
    -0.83548111f, 0.18921031f, 0.10576985f, 0.21852455f, 0.29152679f, 0.17763440f, -0.05805906f, -0.06734017f, 
    0.16173506f, 0.23980734f, -0.05754579f, -0.08029737f, 0.11036249f, 0.15557194f, 0.09089560f, -0.01023454f, 
    0.16018294f, 0.10735034f, 0.12730697f, -0.25486928f, -0.23334128f, -0.60413516f, 0.32543182f, 0.20960425f, 
    -0.08621538f, -0.36302325f, 0.05695408f, -0.06424172f, -0.07097663f, -0.06368599f, 0.14564435f, -0.04696669f, 
    0.04036851f, -0.09269097f, 0.00706515f, -0.19670048f, -0.07419139f, -0.02319801f, 0.00792114f, 0.06544802f, 
    -0.18769096f, 0.21337199f, -0.10366552f, 0.04162153f, -0.27778369f, 0.07266068f, 0.04844498f, 0.13812873f, 
    -0.05637360f, -0.15426125f, -0.13845050f, 0.04341127f, 0.02651299f, -0.10811724f, -0.03640881f, -0.04953678f, 
    0.00028406f, 0.09743247f, 0.10854698f, -0.01696709f, -0.31310707f, 0.01281126f, -0.01696596f, -0.41434729f, 
    0.15677801f, 0.15006834f, -0.06740404f, -0.11138727f, 0.04672192f, -0.24406557f, -0.07018318f, -0.04434529f, 
    -0.06657771f, 0.17581205f, -0.11830702f, 0.00824691f, -0.14633518f, -0.27662572f, 0.00842594f, 0.02072448f, 
    -0.10206145f, 0.09971158f, -0.16547091f, 0.02519089f, 0.18334658f, 0.19172113f, 0.02067575f, 0.09796213f, 
    0.20850861f, 0.06995963f, 0.03851277f, 0.10146686f, 0.07435891f, -0.02966895f, -0.05680132f, -0.07337416f, 
    0.05371159f, -0.03527291f, 0.08406559f, -0.13650776f, -0.23902184f, 0.19307861f, -0.39292058f, -0.00736358f, 
    0.13391687f, 0.12164936f, -0.02375682f, 0.16133668f, 0.09756485f, -0.08527625f, -0.05033480f, 0.02981347f, 
    0.03948288f, -0.08743026f, -0.09405141f, 0.00923739f, 0.06838764f, -0.21048371f, 0.16542578f, 0.09062625f, 
    0.69139785f, -0.17810391f, 0.14649232f, -0.61452585f, -0.25181782f, 0.05118233f, 0.06612246f, 0.06659273f, 
    0.12502779f, -0.02295929f, 0.05870281f, -0.12926473f, 0.06683574f, 0.02375013f, 0.06142240f, -0.02956864f, 
    0.02428741f, 0.03442047f, -0.00260525f, -0.01026431f, -0.07657555f, 0.37848562f, -0.39837527f, 0.19455250f, 
    -0.50855517f, -0.07536260f, -0.14000295f, -0.06127654f, -0.12678228f, -0.11405150f, -0.04157291f, -0.02438700f, 
    0.00764445f, 0.07801434f, 0.07008629f, -0.08862905f, 0.02339960f, 0.13429168f, -0.11070417f, 0.06373241f, 
    0.30324271f, 0.06738076f, 0.09551100f, 0.04086090f, 0.34508854f, -0.20435455f, -0.09751652f, -0.12467705f, 
    0.30641043f, 0.11779571f, 0.01415273f, -0.06835595f, -0.01127475f, 0.01104517f, 0.28919122f, -0.05562369f, 
    0.08374539f, 0.07284477f, -0.33440888f, -0.13756360f, -0.32589966f, -0.31834769f, -0.33218589f, 0.21103732f, 
    0.09357147f, 0.04425335f, 0.09800456f, -0.08042104f, 0.11724170f, 0.23195821f, -0.07084648f, 0.29638901f, 
    0.14997834f, 0.10492833f, 0.03063426f, -0.16381268f, 0.05159587f, -0.06919792f, 0.16016828f, -0.12948048f, 
    -0.28140503f, -0.08160286f, 0.05490330f, 0.25755009f, -0.41684669f, -0.08273163f, -0.15184160f, 0.00377442f, 
    0.03032366f, -0.00395533f, 0.16407466f, 0.02268393f, -0.05345396f, 0.05186703f, 0.01480118f, -0.06702221f, 
    -0.09720597f, 0.05680043f, -0.06993561f, -0.06560867f, -0.48209509f, 0.23824377f, -0.21760748f, -0.24748741f, 
    -0.08207676f, -0.02504736f, 0.19613008f, 0.04874045f, -0.03040300f, -0.00920123f, 0.10348409f, 0.04686036f, 
    -0.00472158f, -0.00267362f, 0.00371952f, -0.05865229f, 0.01488396f, -0.20372088f, -0.03213968f, 0.08902028f, 
    -0.77073902f, -0.12374815f, -0.44563654f, -0.35356164f, -0.00104613f, 0.06556717f, 0.10144424f, 0.12007450f, 
    0.01965071f, -0.26909891f, 0.12361261f, 0.00298482f, 0.03016822f, -0.10541303f, 0.19217180f, 0.01118486f, 
    0.04900791f, -0.20262152f, 0.10019917f, 0.01587418f, -0.60131437f, -0.28428349f, 0.27792686f, 0.28823987f, 
    -0.35152948f, 0.07883670f, -0.04434966f, -0.09986761f, -0.02714076f, -0.06306626f, 0.04445747f, -0.10438813f, 
    -0.19608352f, -0.01455908f, 0.09570177f, -0.08548515f, 0.12736163f, 0.13379076f, 0.23401636f, -0.03887588f, 
    0.41531530f, 0.47488734f, 0.14559086f, -0.04667095f, -0.12506486f, 0.04384371f, -0.04254021f, 0.01534401f, 
    -0.11477773f, 0.11506215f, 0.09871937f, -0.00975425f, -0.09995061f, 0.02065550f, -0.07064792f, 0.20752403f, 
    -0.05193664f, 0.22541720f, 0.20313084f, 0.14072244f, 0.05160915f, -0.10547201f, 0.11877566f, 0.10233985f, 
    -0.27727011f, -0.24572897f, 0.19519201f, 0.09166868f, -0.04815998f, 0.08224630f, -0.16890921f, 0.13220929f, 
    0.14684945f, -0.05510127f, 0.20109630f, -0.14676392f, -0.17947514f, -0.01996846f, 0.09797195f, 0.06134482f, 
    -0.21760051f, 0.29710668f, -0.56365150f, -0.19435874f, -0.04721476f, 0.25531745f, 0.21343327f, 0.09455625f, 
    -0.04718953f, -0.26014927f, -0.06706101f, 0.08602755f, -0.35176989f, -0.13088474f, -0.07933599f, -0.05324866f, 
    -0.09502261f, 0.15512370f, 0.05490087f, 0.06263680f, 0.23592106f, 0.13026527f, -0.03530214f, 0.35089919f, 
    0.17177606f, -0.14821209f, -0.06593440f, 0.07965528f, 0.04625899f, 0.12336960f, -0.19352333f, -0.20388113f, 
    0.08012361f, 0.15089951f, 0.12675612f, 0.06474356f, 0.03989628f, -0.01346052f, 0.07497937f, -0.06779905f, 
    -0.27597097f, -0.27598524f, 0.09935030f, 0.23620927f, 0.24610032f, -0.01120081f, -0.24463245f, 0.11983054f, 
    -0.01631289f, 0.02833030f, 0.07810276f, -0.20108253f, 0.00725517f, -0.00317928f, 0.06983364f, -0.18462041f, 
    -0.00411045f, -0.19859664f, -0.15147755f, -0.09561267f, -0.38984606f, 0.08733416f, -0.16922307f, 0.35757345f, 
    -0.04765068f, 0.17265590f, -0.02671182f, 0.06660390f, -0.17791808f, 0.20235325f, 0.05149534f, -0.01336721f, 
    -0.00564393f, -0.05687632f, -0.06021089f, 0.11272652f, 0.03533484f, 0.13170677f, -0.05797658f, -0.16547449f, 
    -0.33511174f, -0.35673323f, -0.19445425f, -0.21473426f, -0.10372434f, 0.29109967f, -0.04696793f, 0.12449748f, 
    -0.05757455f, -0.13219300f, -0.06502964f, 0.19666947f, -0.05923419f, 0.04559056f, -0.05971268f, 0.02091879f, 
    -0.02240696f, 0.09814811f, -0.29490075f, 0.12582961f, -0.64450413f, -0.25967821f, 0.16298608f, -0.00255810f, 
    -0.26887697f, 0.05545893f, 0.11208624f, 0.10285180f, -0.01841704f, -0.10729182f, 0.16377389f, -0.23344015f, 
    -0.03462115f, -0.23030899f, -0.00175274f, 0.22489029f, 0.01716098f, 0.11564046f, -0.21154742f, -0.00595362f, 
    -0.38207507f, 0.07165498f, 0.51148164f, 0.37576029f, -0.09251566f, 0.05190966f, 0.25855055f, 0.01079302f, 
    -0.12263163f, 0.03733201f, -0.15557846f, -0.06202060f, 0.00153058f, -0.02373175f, -0.17134860f, -0.06760132f, 
    0.11686818f, -0.09877369f, 0.08164041f, 0.10791282f, 0.00284523f, -0.13720311f, -0.24725263f, -0.01750686f, 
    0.10290994f, -0.05812382f, -0.05922837f, -0.05170880f, 0.03968475f, 0.06946598f, 0.21074624f, 0.08213944f, 
    0.08821516f, -0.09831039f, -0.02702142f, 0.01576063f, -0.19076641f, -0.29177737f, 0.01050847f, 0.00567334f, 
    -0.10040218f, 0.31736454f, -0.17263021f, -0.12792860f, -0.13281773f, 0.10988110f, 0.14235838f, 0.07803163f, 
    -0.25094041f, 0.02815815f, -0.12628613f, -0.16920480f, -0.12496708f, -0.07715172f, -0.17102432f, 0.02680665f, 
    0.01077025f, 0.04094958f, 0.17252032f, 0.16317046f, -0.06334095f, -0.10992353f, -0.30017757f, -0.64851278f, 
    0.25097936f, -0.06684047f, -0.01965446f, -0.01691577f, -0.20627284f, -0.10397825f, -0.11674770f, -0.11412676f, 
    -0.27982324f, -0.05093441f, 0.07736913f, -0.12671742f, -0.07222071f, 0.21202515f, 0.07141662f, 0.10408065f, 
    0.35044524f, -0.40595874f, 0.17646281f, 0.13034482f, 0.18652938f, 0.09400152f, -0.10111271f, 0.15845656f, 
    0.08803277f, -0.11632469f, -0.07827823f, 0.10018741f, -0.13213845f, -0.17427060f, 0.07940459f, -0.24624240f, 
    0.20810206f, 0.18289469f, 0.12528919f, 0.03992403f, 0.30215564f, -0.20784950f, -0.16260266f, -0.12847562f, 
    0.20526080f, -0.09746923f, 0.05608913f, -0.10113598f, -0.07364704f, -0.16827703f, -0.04290983f, 0.06066123f, 
    0.15680011f, 0.03570547f, 0.14648744f, 0.07273459f, -0.02518682f, 0.06869976f, -0.05226995f, 0.08934197f, 
    0.10730574f, -0.66051000f, -0.11015946f, -0.09641645f, 0.11069084f, -0.01981157f, 0.11474858f, -0.02818185f, 
    -0.15496878f, -0.12821200f, 0.05371272f, -0.03007425f, -0.03734137f, 0.09952787f, 0.08433256f, -0.12613572f, 
    -0.00657650f, 0.06113128f, -0.10921798f, -0.01046001f, 0.33250087f, -0.16252938f, 0.01715102f, 0.11102998f, 
    0.13997732f, -0.08081041f, -0.11958975f, 0.13782904f, 0.07815004f, 0.12944755f, -0.03883072f, 0.05424919f, 
    -0.07133535f, 0.02897067f, -0.01278378f, 0.08123730f, -0.13942772f, -0.14133888f, -0.15052231f, -0.13541359f, 
    -0.54849803f, -0.02647861f, -0.27440482f, 0.29848841f, -0.18701997f, -0.12594073f, 0.01586668f, 0.02329670f, 
    0.17236370f, 0.08098292f, 0.02280413f, -0.16716506f, 0.16233581f, -0.01522043f, 0.02828418f, -0.07772572f, 
    0.10231009f, -0.25982091f, -0.05654380f, -0.19688669f, -0.03663094f, 0.44467214f, 0.35587659f, 0.01243250f, 
    -0.33127263f, 0.17486039f, -0.13682836f, 0.11044770f, 0.10086064f, 0.03354245f, -0.01978270f, 0.04850014f, 
    0.06665474f, 0.16418687f, 0.01107042f, 0.09749401f, -0.11375311f, -0.03905170f, 0.01308704f, -0.09245104f, 
    0.04803271f, -0.49096876f, -0.00316032f, -0.79720771f, 0.35383043f, 0.01226520f, -0.09360585f, -0.08022092f, 
    -0.14247230f, -0.20331533f, -0.06334897f, -0.18070640f, 0.18546431f, 0.01825710f, -0.07738765f, 0.15785061f, 
    0.04508168f, -0.14145134f, 0.01243683f, 0.23896341f, -0.46298084f, 0.54418063f, 0.07309828f, 0.09229319f, 
    -0.47391590f, 0.05862576f, -0.04941798f, 0.02985106f, 0.11931894f, 0.16376379f, 0.06268646f, 0.11582473f, 
    -0.01481100f, -0.05683919f, -0.18699212f, 0.01353327f, -0.04146830f, -0.02113836f, -0.02369195f, 0.00708620f, 
    0.07639141f, 0.10477480f, -0.31887069f, -0.07420085f, 0.02354556f, 0.15205094f, 0.12516360f, -0.03907756f, 
    -0.08883644f, 0.00918488f, -0.03539907f, -0.05909522f, 0.02730064f, 0.05509828f, -0.17600140f, 0.14515215f, 
    0.07624191f, 0.13833749f, 0.11623069f, 0.19599295f, -0.21755356f, -0.68187076f, 0.06556250f, 0.10519204f, 
    0.00558567f, 0.01129577f, 0.07034353f, -0.03916376f, -0.02859353f, -0.03945766f, -0.13580485f, 0.01640038f, 
    -0.04931705f, -0.01818649f, 0.17637771f, -0.05072743f, -0.03117058f, -0.04471336f, 0.11805776f, 0.01739600f, 
    -0.10872283f, 0.30845195f, -0.05563202f, -0.33126563f, -0.03227435f, -0.02187338f, -0.01177970f, 0.07724278f, 
    -0.09677262f, 0.00671984f, 0.13541147f, -0.21029449f, 0.11547516f, -0.03621170f, 0.15375438f, -0.06905367f, 
    0.02688727f, -0.09530776f, 0.12862600f, -0.08583134f, 0.46082708f, -0.65239227f, -0.19522537f, -0.13222833f, 
    -0.00192252f, -0.17922810f, 0.07287364f, 0.00644527f, -0.11157084f, 0.17570241f, -0.18822797f, 0.11479180f, 
    -0.08090686f, 0.23032999f, 0.06835190f, -0.13606228f, -0.00111675f, -0.16531579f, -0.06093978f, -0.16613765f, 
    0.09121791f, 0.09687520f, 0.20940897f, 0.30455372f, 0.39683083f, -0.30287895f, -0.03386915f, -0.05573333f, 
    0.18479988f, -0.12774467f, 0.02370419f, 0.02259075f, 0.15092391f, 0.15699667f, -0.12145963f, 0.12914808f, 
    -0.10238644f, 0.21775867f, -0.04775901f, -0.13767883f, -0.02675356f, -0.46455312f, -0.20634645f, -0.24422219f, 
    0.41751146f, -0.00729690f, 0.19124958f, 0.07737389f, 0.04811694f, 0.11256748f, -0.08360538f, 0.01781987f, 
    0.01289310f, 0.06987471f, -0.11952691f, 0.06992598f, 0.08019453f, 0.24998307f, 0.08946033f, -0.02035291f, 
    0.28711471f, -0.01464366f, -0.14541192f, 0.01969373f, 0.35065907f, -0.05047323f, -0.15793812f, -0.10718515f, 
    -0.17858782f, 0.06924020f, -0.12569471f, 0.13189927f, -0.08427280f, -0.02526906f, -0.13148999f, -0.12819538f, 
    0.03325929f, 0.00884043f, 0.09633653f, 0.07737525f, -0.06643186f, 0.31477937f, 0.18777853f, 0.17329107f, 
    0.17786622f, -0.08378609f, 0.14944057f, -0.17886053f, -0.01494451f, -0.06103569f, -0.10776296f, -0.05197541f, 
    -0.23609132f, -0.21737415f, -0.07198242f, -0.00701575f, -0.09017655f, 0.23928617f, -0.03309548f, -0.14329521f, 
    0.42514363f, -0.35936850f, 0.08309465f, 0.11619353f, -0.31818256f, 0.15708232f, -0.08809804f, -0.15446959f, 
    0.00077516f, 0.06082436f, -0.09309605f, 0.05837572f, 0.03839034f, 0.04372911f, -0.06064850f, 0.01854906f, 
    -0.01001396f, -0.06815568f, -0.02991627f, 0.04518422f, -0.30296052f, 0.24111521f, 0.27340060f, 0.08161177f, 
    0.25153688f, 0.20770946f, 0.16854280f, 0.02837893f, 0.16984196f, -0.04474431f, -0.17941855f, -0.04563268f, 
    0.06920432f, 0.03507490f, -0.14688823f, 0.00090544f, 0.03692606f, 0.06626978f, 0.08069553f, 0.01002036f, 
    -0.10119770f, 0.05845204f, 0.41576776f, 0.06927444f, 0.13580312f, 0.11112367f, 0.10494291f, 0.09824587f, 
    0.15630367f, -0.13581316f, -0.04091558f, 0.00519925f, -0.02197303f, 0.00427013f, -0.18832031f, -0.11730845f, 
    0.05541587f, 0.12434354f, 0.03999576f, -0.09359918f, 0.26056102f, -0.49884117f, 0.09165545f, -0.09237720f, 
    -0.10502837f, 0.30597746f, -0.11557006f, -0.00526026f, -0.17172669f, -0.02885244f, 0.03607261f, -0.03125545f, 
    -0.18321706f, -0.14247099f, -0.06096803f, 0.07204589f, 0.14925626f, -0.10410079f, 0.04900012f, -0.01213308f, 
    -0.43232930f, 0.01648425f, 0.12566254f, -0.27508879f, -0.32297072f, -0.11018966f, -0.20052378f, -0.08652777f, 
    -0.11436310f, -0.17862782f, 0.13067873f, -0.07142769f, -0.19343859f, -0.04626308f, -0.01660399f, -0.06492140f, 
    -0.12014579f, -0.12037561f, -0.04074260f, -0.05371932f, 0.03592429f, -0.96097857f, -0.21714048f, -0.27933186f, 
    -0.19825219f, -0.07206799f, -0.05016855f, -0.03269837f, -0.02289815f, -0.17234649f, -0.06992836f, -0.02052043f, 
    -0.24298760f, -0.08757894f, -0.01150379f, -0.01718355f, 0.14400725f, -0.08451329f, -0.01210789f, -0.05826400f, 
    0.41128874f, -0.05794593f, 0.49508962f, -0.00027284f, 0.29746380f, 0.00884182f, 0.27435833f, -0.01919253f, 
    0.01645683f, 0.08605943f, 0.03692503f, 0.06883263f, -0.07201923f, -0.02797532f, -0.03329435f, -0.09363431f, 
    0.02323982f, 0.02766336f, 0.12928472f, -0.17107853f, -0.67267209f, -0.14735688f, -0.51691675f, -0.08018005f, 
    -0.07718639f, -0.00670949f, -0.12278914f, -0.10667378f, -0.01553147f, -0.17811738f, -0.21731982f, 0.00985349f, 
    0.03526360f, -0.15481275f, -0.13311045f, -0.03605284f, 0.05819229f, -0.02165511f, -0.03570824f, 0.08600258f, 
    0.00286151f, 0.30693188f, 0.03243471f, -0.13897693f, 0.29112512f, -0.14016797f, -0.00796059f, -0.10060291f, 
    -0.05376524f, -0.01006105f, 0.02014225f, 0.02881963f, -0.12738219f, -0.11847175f, -0.04738796f, 0.04799106f, 
    -0.03127843f, 0.02666485f, -0.09837921f, 0.00858695f, 0.01034615f, -0.22950990f, 0.00674400f, 0.25210893f, 
    0.44407782f, 0.06186460f, 0.05032735f, -0.17530787f, 0.09124817f, 0.01746657f, -0.09935979f, -0.10471671f, 
    -0.04422982f, -0.14913681f, -0.07659939f, -0.07213414f, -0.04356158f, -0.05925472f, 0.04864345f, -0.07171794f, 
    0.23108797f, -0.22171293f, 0.26046374f, 0.07447773f, 0.26692361f, 0.03991326f, 0.07718658f, -0.20912154f, 
    -0.18605441f, 0.10929006f, -0.02436988f, 0.16324049f, -0.09819207f, -0.09902135f, -0.07962589f, -0.01638594f, 
    -0.01851941f, -0.03693166f, 0.20617494f, -0.15235285f, -0.16385521f, -0.01329324f, 0.11577037f, 0.15608320f, 
    -0.01204235f, 0.18537891f, -0.06673390f, -0.00172050f, 0.11900668f, 0.04451226f, -0.05880622f, 0.07594367f, 
    0.08382874f, -0.10402509f, -0.02591433f, -0.04324307f, -0.06642091f, -0.04222573f, 0.05589091f, 0.05930370f, 
    -0.10557554f, 0.28511670f, -0.01805274f, 0.13195519f, -0.12819673f, 0.14821261f, -0.21577485f, -0.00424584f, 
    0.00246533f, 0.04356603f, -0.05249706f, 0.11408754f, 0.14581399f, -0.19761437f, -0.02805175f, -0.00044647f, 
    0.05063614f, 0.06213848f, -0.08595587f, -0.09633669f, -0.01747061f, 0.18543316f, -0.01850041f, 0.01061291f, 
    0.05062019f, -0.19571337f, 0.09494966f, -0.17603318f, -0.06958155f, -0.04215927f, -0.33866242f, 0.00054455f, 
    -0.12070434f, 0.00252747f, -0.02952824f, 0.02533222f, -0.03556685f, 0.10031530f, -0.04830626f, -0.05256197f, 
    -0.38317382f, -0.35453695f, -0.18540834f, -0.48239243f, -0.18379785f, 0.10239693f, -0.11227047f, -0.03527205f, 
    0.05515986f, -0.20886306f, 0.06642380f, 0.11286421f, -0.06071580f, 0.02606336f, -0.17066497f, 0.05928143f, 
    0.07537453f, 0.00096613f, -0.40662134f, -0.07282264f, -0.33149257f, 0.16250794f, 0.31922224f, -0.17985731f, 
    -0.25502741f, -0.20030117f, 0.02468918f, -0.03984173f, 0.14225945f, -0.17755170f, 0.06957639f, 0.11114616f, 
    0.10245290f, -0.05615983f, 0.10936978f, -0.12858608f, 0.04471429f, -0.40751919f, -0.21503566f, -0.04245742f, 
    0.13157544f, 0.00540443f, -0.12256005f, 0.09282253f, 0.14716046f, -0.03391603f, 0.01908378f, -0.08592232f, 
    -0.15534520f, 0.11474545f, -0.01674466f, 0.09698360f, -0.10740537f, -0.10020487f, -0.00296197f, 0.10503107f, 
    0.03559546f, -0.03548739f, 0.19328810f, -0.00479559f, -0.01686082f, -0.25036854f, 0.17653227f, -0.07082324f, 
    -0.05226440f, 0.02339863f, -0.17342158f, 0.07011983f, -0.17516822f, 0.24332128f, -0.02624289f, -0.08900924f, 
    -0.09059913f, 0.01122677f, 0.07274956f, -0.01576012f, -0.06183752f, -0.03061840f, 0.00589956f, -0.14551201f, 
    0.09360365f, -0.10653447f, 0.13121730f, 0.18258663f, 0.14385252f, -0.19391444f, -0.06827754f, -0.05662162f, 
    -0.02647893f, -0.01442340f, 0.04031948f, -0.17924060f, -0.04252108f, -0.07292528f, 0.06080604f, 0.13981821f, 
    -0.02890926f, -0.12457462f, 0.15709397f, -0.02293152f, 0.23142909f, 0.18779753f, 0.23942180f, 0.02517641f, 
    0.13601623f, -0.16892019f, -0.04787147f, -0.12835220f, -0.10982963f, -0.02769309f, -0.07002372f, 0.01847248f, 
    -0.17904584f, -0.08999766f, 0.11295792f, 0.00348030f, 0.03931669f, 0.01886698f, -0.04685717f, 0.20774822f, 
    0.35858953f, 0.39382449f, -0.18751764f, 0.16885373f, 0.25534987f, 0.05618857f, 0.03516396f, -0.20199707f, 
    -0.09742863f, -0.11498031f, -0.10641581f, 0.06874544f, -0.05748535f, -0.22513218f, -0.07770789f, -0.00551167f, 
    0.00669331f, 0.07984810f, 0.11240447f, -0.05454230f, 0.02611299f, -0.33687732f, -0.35202715f, 0.22635275f, 
    0.25032604f, 0.18930884f, 0.10316835f, -0.11913591f, -0.09137719f, -0.10479075f, 0.00798948f, 0.01829001f, 
    0.18232957f, 0.05640939f, 0.06828508f, -0.04271675f, 0.09703954f, 0.07774415f, 0.11028063f, -0.15578473f, 
    -0.32116726f, 0.21801643f, 0.18501830f, -0.01473567f, 0.09111140f, 0.02736156f, -0.10315847f, 0.25519928f, 
    0.01987111f, 0.04199595f, 0.07600980f, -0.04981704f, -0.40939760f, 0.05432728f, 0.02945401f, -0.11161201f, 
    0.05877326f, 0.04221595f, 0.02477908f, -0.06251188f, 0.19193356f, 0.04266491f, -0.33806419f, 0.05616935f, 
    0.14555715f, 0.12645689f, 0.01313086f, -0.08827104f, -0.01376002f, -0.07699536f, -0.03503153f, -0.00917195f, 
    0.02398492f, 0.14452638f, 0.11596798f, -0.05474683f, 0.04171645f, 0.14202799f, 0.16023739f, -0.01350717f, 
    -0.06163450f, 0.42632958f, -0.35254049f, -0.24682494f, -0.28420463f, -0.13758466f, -0.14613059f, -0.07054114f, 
    -0.04321325f, -0.10000353f, 0.20221186f, 0.02364263f, -0.01122737f, -0.02458510f, 0.04089364f, -0.19342990f, 
    -0.15711404f, -0.19940862f, -0.04494991f, 0.12723403f, -0.08252981f, -0.07422753f, 0.16014723f, -0.01131953f, 
    0.22153589f, -0.09072334f, -0.11634552f, -0.07711484f, -0.06914472f, -0.14501867f, 0.00396403f, -0.04389646f, 
    0.10240545f, 0.03789171f, -0.01733472f, 0.02136932f, -0.01083127f, 0.19935814f, -0.19575483f, 0.01479260f, 
    -0.31486022f, -0.26819938f, 0.28093174f, -0.18042468f, -0.04616163f, 0.04751390f, 0.04906958f, 0.06312465f, 
    -0.01635619f, -0.11822649f, -0.01094940f, -0.03725580f, 0.13267432f, 0.21894121f, 0.07254563f, -0.04477922f, 
    0.00394103f, 0.09125765f, -0.49677628f, 0.02804806f, 0.02396596f, -0.04469386f, 0.15868092f, -0.05015885f, 
    0.24053933f, -0.19553842f, -0.19981042f, -0.05052725f, -0.18405494f, 0.14253518f, -0.03853785f, -0.11296643f, 
    0.07126333f, -0.24193858f, -0.20251764f, -0.03488468f, 0.07619498f, 0.09022041f, 0.03598517f, 0.09405073f, 
    -0.44896367f, -0.04751891f, -0.43853956f, -0.01158853f, -0.32945377f, 0.16030747f, 0.00227781f, -0.31459925f, 
    -0.12599678f, -0.08544765f, 0.18550777f, -0.06876954f, -0.24361292f, 0.02116039f, 0.17776805f, 0.03641069f, 
    -0.00166473f, -0.08074994f, -0.05564246f, 0.19821024f, -0.20374119f, 0.23550242f, 0.30594581f, -0.16154674f, 
    -0.28884351f, -0.11018817f, 0.03731081f, 0.00556528f, 0.02928399f, -0.23041396f, 0.11812780f, 0.02832955f, 
    0.01048982f, 0.01556478f, 0.05944481f, -0.24706291f, 0.05429598f, -0.08443408f, 0.17132680f, 0.03176615f, 
    0.15048850f, -0.27527511f, 0.12139652f, -0.21307023f, -0.42021716f, -0.16712876f, -0.04158879f, 0.17951474f, 
    -0.10082489f, 0.07816444f, 0.21992524f, 0.19118986f, 0.25122312f, -0.23322417f, -0.07154131f, 0.06696291f, 
    0.05161358f, -0.05035411f, 0.20600270f, 0.05319627f, -0.20886004f, -0.15220252f, 0.00202229f, 0.20094450f, 
    0.02898690f, 0.03246686f, 0.02360234f, -0.01182656f, -0.03692402f, -0.17469834f, 0.00375027f, 0.05870096f, 
    -0.11253163f, -0.10022705f, -0.03153364f, 0.03843014f, -0.16324486f, -0.00432591f, -0.09282802f, -0.03320884f, 
    0.67503124f, -0.77509171f, 0.05988181f, -0.04302965f, 0.17722382f, -0.02860280f, -0.12299902f, 0.01071881f, 
    0.03911083f, -0.01837695f, 0.19302242f, -0.01467955f, 0.00838637f, -0.18573360f, 0.02176750f, 0.05165360f, 
    -0.04827267f, -0.11991933f, 0.10853465f, 0.20732799f, -0.08796354f, -0.28978422f, -0.10679783f, 0.23839672f, 
    0.27520856f, 0.10747387f, -0.10706287f, -0.11979665f, -0.05282305f, 0.15965495f, -0.10960489f, 0.03934578f, 
    -0.14887542f, 0.10239586f, -0.13294894f, 0.02543644f, -0.01695038f, 0.10196363f, 0.06805050f, 0.05671329f, 
    -0.09460480f, -0.20496565f, -0.00158099f, 0.37448981f, 0.15691364f, 0.18185160f, -0.11561749f, -0.09383956f, 
    0.05433501f, 0.11490931f, -0.05364749f, -0.00487550f, 0.04635467f, -0.11338585f, -0.27906585f, -0.27401567f, 
    -0.22062880f, -0.00950219f, -0.03879964f, 0.02310155f, 0.02021629f, -0.28292075f, 0.26075852f, 0.04598922f, 
    -0.18938403f, 0.24939194f, -0.01552503f, -0.11299066f, 0.05837445f, -0.07562246f, -0.01582355f, -0.09171530f, 
    0.02384289f, 0.19572872f, 0.10397253f, -0.01359705f, 0.05238268f, -0.28029275f, -0.15915696f, -0.17098716f, 
    -0.12019655f, -0.03114239f, 0.06107690f, -0.07495097f, -0.04605592f, 0.08601280f, 0.15946844f, 0.02392327f, 
    -0.07577218f, -0.18725646f, 0.11259803f, 0.09671454f, -0.05476229f, -0.05938234f, 0.11144948f, 0.07798675f, 
    -0.04142419f, 0.01014910f, -0.27718383f, 0.03999313f, -0.09428392f, -0.42712995f, 0.21425606f, -0.43327919f, 
    -0.27201140f, 0.04484694f, 0.19694315f, -0.28116503f, 0.05178887f, -0.07646588f, -0.11615173f, 0.03310473f, 
    0.02863595f, -0.06057803f, -0.16533351f, -0.02658845f, -0.03316508f, 0.03415591f, -0.10135040f, -0.00600584f, 
    -0.13701087f, -0.05346576f, -0.01009949f, 0.14163496f, -0.22532006f, -0.12972693f, 0.15807167f, -0.11123314f, 
    -0.08494294f, 0.22642308f, -0.11010230f, 0.07560315f, 0.00881874f, 0.00498407f, 0.22010060f, -0.07157187f, 
    -0.04901516f, -0.17350961f, 0.09062707f, -0.01100111f, -0.04650331f, 0.03393798f, 0.42120072f, -0.46409804f, 
    -0.47931173f, 0.11230160f, 0.13912031f, -0.03226259f, -0.10626220f, 0.06717103f, -0.13353308f, -0.04999266f, 
    -0.13689956f, -0.10851801f, 0.03166759f, -0.07615508f, -0.06323164f, -0.00564392f, 0.01004349f, -0.03984157f, 
    -0.51341403f, 0.14720815f, -0.07727654f, 0.05343623f, -0.44567415f, 0.01207158f, 0.11760761f, -0.12198177f, 
    0.02827647f, 0.12192483f, -0.02457669f, 0.03029127f, 0.01539180f, 0.20979948f, 0.14903098f, -0.03804364f, 
    0.05894585f, 0.10593440f, -0.05868322f, -0.05388042f, 1.16152203f, 0.04684052f, -0.41034293f, -0.25744051f, 
    0.11081585f, 0.09637339f, -0.06501425f, 0.11871435f, -0.05858805f, -0.09774841f, -0.15634529f, 0.06275272f, 
    0.11224833f, 0.12772876f, -0.07391011f, 0.08760462f, 0.12050343f, -0.10785709f, 0.04819063f, -0.02224136f, 
    0.28180411f, -0.33187392f, -0.16502869f, 0.21300238f, 0.10150630f, -0.15883166f, 0.10413831f, -0.05622213f, 
    0.00367035f, 0.15315007f, -0.00145703f, 0.06498902f, 0.02700227f, -0.21181394f, 0.11910284f, 0.05597005f, 
    -0.06033737f, -0.03878730f, 0.24739864f, 0.21888036f, -0.04092564f, 0.02260238f, -0.24198991f, 0.03857713f, 
    -0.18118735f, -0.03388868f, -0.07970613f, 0.06465258f, 0.11553515f, 0.20059402f, -0.00016149f, 0.11561796f, 
    0.04333024f, 0.26161608f, 0.05376670f, -0.12745838f, -0.15717615f, 0.03251887f, -0.01327163f, -0.24925651f, 
    -0.50159228f, -0.84888679f, -0.18778296f, 0.17477788f, -0.07053030f, -0.12252002f, -0.03232310f, 0.12014338f, 
    0.00005603f, -0.01763681f, -0.26541239f, -0.13452323f, -0.01591203f, 0.02200935f, -0.01476496f, 0.14801484f, 
    0.08481508f, -0.10093382f, 0.13757662f, 0.07616244f, -0.12756364f, 0.43308869f, 0.20900884f, 0.24364190f, 
    0.07011713f, -0.05508286f, -0.03146694f, 0.07640304f, 0.07836232f, -0.05928882f, -0.05347349f, -0.15016767f, 
    0.02923058f, 0.05589193f, 0.24689494f, 0.14789633f, 0.10769068f, 0.07253101f, -0.18558802f, 0.06893493f, 
    0.50238699f, 0.52331096f, 0.37888026f, -0.05596056f, -0.17405866f, 0.18902148f, -0.11601634f, 0.03909479f, 
    0.21955973f, -0.12543803f, -0.10183550f, 0.07020421f, 0.00279693f, 0.01181639f, 0.05631445f, 0.09408177f, 
    0.05355617f, -0.04980162f, -0.20673239f, -0.01649614f, 0.29657432f, 0.12465281f, -0.00752213f, -0.09199755f, 
    0.00118889f, 0.04212217f, -0.08881429f, 0.11608469f, -0.07136451f, -0.03516530f, -0.06737224f, -0.02430392f, 
    0.04798974f, 0.06100671f, -0.00779493f, 0.01576694f, 0.10660162f, -0.27101910f, -0.08774605f, -0.03546188f, 
    -0.52249938f, -0.17813623f, -0.54026842f, -0.07928547f, 0.12325137f, -0.00911965f, 0.05955714f, -0.12636939f, 
    -0.01418716f, 0.21597721f, 0.03315496f, 0.02961516f, -0.02369172f, -0.00357563f, 0.05892010f, 0.05417603f, 
    0.00355704f, 0.15240237f, -0.10697049f, 0.17605525f, 0.44169384f, 0.12854096f, -0.14554994f, 0.14295204f, 
    -0.12184651f, -0.20925462f, -0.10737351f, 0.08304206f, -0.00612938f, -0.02014962f, 0.06773227f, 0.08033396f, 
    0.00154289f, -0.16798058f, -0.19008394f, -0.15865985f, -0.01318078f, -0.01785554f, -0.00346088f, -0.11060614f, 
    0.47700465f, 0.20604771f, -0.32049796f, 0.11432242f, -0.15048306f, -0.33499628f, -0.23449473f, 0.12437533f, 
    0.12140394f, -0.04794054f, -0.06932537f, -0.03022638f, 0.02223051f, -0.24765360f, -0.09203633f, -0.07004353f, 
    0.09489145f, -0.01614372f, -0.04760823f, 0.05369334f, -0.90474576f, 0.16388647f, -0.26087630f, -0.21712564f, 
    -0.05771949f, 0.11172009f, 0.14057079f, -0.19094163f, -0.01736165f, -0.03932725f, 0.08823959f, 0.10915130f, 
    0.14704654f, -0.06744071f, 0.12489982f, -0.06506054f, 0.03842130f, 0.19029017f, 0.07422418f, 0.08559830f, 
    -0.43486845f, -0.44994140f, -0.40756568f, -0.26077589f, -0.14190739f, 0.16434579f, 0.07703061f, -0.06642230f, 
    -0.04917212f, -0.18646257f, -0.07187422f, -0.01813887f, -0.19309497f, -0.08049767f, 0.14297976f, -0.04449069f, 
    0.17868733f, 0.24039820f, 0.18993564f, 0.14732908f, -1.05810738f, -0.61783451f, -0.16741897f, -0.36953807f, 
    -0.29839996f, 0.09222931f, 0.02539703f, -0.05827788f, 0.03115604f, 0.14156356f, 0.00249180f, -0.05636721f, 
    -0.10160872f, 0.21604770f, 0.07365539f, 0.05381382f, -0.16997404f, 0.09899638f, -0.07844304f, 0.02160709f, 
    0.41627961f, -0.23069069f, -0.00965302f, -0.02928428f, 0.11913607f, -0.12315951f, -0.06782441f, -0.14596495f, 
    0.08668772f, -0.16874707f, 0.05379729f, 0.11245704f, -0.12370169f, -0.10172648f, -0.12839320f, -0.27321315f, 
    -0.06343590f, -0.19614737f, -0.18133536f, 0.07282263f, -0.74354559f, -0.36661261f, 0.19250841f, -0.23749235f, 
    -0.15158656f, 0.19097531f, -0.05234575f, -0.08904547f, -0.03344229f, 0.07960018f, 0.12677671f, 0.11021374f, 
    0.09642975f, 0.33958834f, 0.01072986f, 0.19233032f, 0.04072849f, -0.01492541f, -0.17067622f, 0.05117035f, 
    -0.27984232f, -0.49116495f, 0.24248539f, 0.07623681f, -0.02860454f, 0.04104121f, 0.12819317f, 0.01321874f, 
    0.15272804f, 0.04366375f, 0.13593791f, -0.04955557f, 0.09431521f, -0.10679737f, 0.03965582f, -0.13489503f, 
    0.07396384f, -0.16043887f, -0.02271373f, -0.08172572f, -0.15937796f, 0.20853867f, 0.03681613f, 0.03864146f, 
    -0.02718895f, -0.12204929f, 0.01549153f, 0.03382307f, -0.00518653f, 0.17708510f, 0.02233602f, 0.04068488f, 
    0.01062957f, -0.03336413f, 0.04378024f, -0.03068511f, 0.10741751f, 0.11874652f, -0.04723746f, 0.00475754f, 
    0.15350080f, 0.23699985f, 0.03710292f, -0.21384126f, -0.10607447f, 0.09301969f, 0.13873520f, 0.02231303f, 
    -0.04892649f, 0.04843613f, -0.06651627f, 0.06003884f, -0.03140394f, 0.15891658f, -0.08471512f, 0.09273653f, 
    0.03653834f, 0.07274948f, -0.24246965f, 0.12973197f, 0.22144359f, 0.08617947f, -0.21197407f, 0.08679945f, 
    0.03283853f, -0.02130297f, -0.15353550f, 0.03468924f, 0.00887848f, 0.01951218f, 0.00924105f, -0.12226330f, 
    -0.02521288f, -0.05570390f, 0.07961486f, 0.04975156f, -0.00858498f, 0.31087989f, 0.09288616f, 0.04493979f, 
    -0.34986103f, -0.00752155f, 0.02252000f, 0.07673947f, -0.01144948f, 0.09855009f, 0.04767327f, -0.00681894f, 
    0.06684365f, -0.03271610f, 0.06018586f, 0.25854927f, -0.03685394f, -0.22479010f, 0.20748335f, 0.12751146f, 
    0.00330759f, -0.14421067f, -0.10971267f, 0.01032881f, -0.52989447f, -0.15601286f, -0.02425995f, 0.09191858f, 
    0.24911124f, 0.12719597f, -0.00770243f, 0.04686658f, -0.01380239f, 0.02943883f, 0.12669989f, 0.01015887f, 
    -0.04175316f, 0.00681350f, 0.11148183f, -0.02087823f, -0.24458344f, -0.15396312f, 0.18203267f, -0.00663551f, 
    0.09958872f, -0.01276094f, -0.20599306f, -0.36722285f, 0.47408777f, 0.06952019f, -0.07713760f, -0.00043100f, 
    0.29376444f, -0.16797158f, 0.06678212f, -0.07001278f, 0.00495469f, 0.10926730f, 0.19983660f, 0.06330658f, 
    -0.13517116f, 0.06617616f, 0.13860910f, 0.03734595f, 0.52478290f, -0.15914792f, -0.03454478f, -0.01664103f, 
    0.01663731f, -0.11267496f, -0.18393631f, -0.08258992f, -0.03008392f, -0.07748300f, 0.07318690f, -0.06000593f, 
    -0.07634757f, 0.06728571f, -0.12372893f, 0.07650935f, -0.06905701f, 0.06380947f, 0.07348527f, 0.08026641f, 
    -0.28482416f, 0.27704272f, -0.15706089f, 0.03737343f, -0.25372398f, -0.05936852f, 0.13376321f, -0.10159495f, 
    0.06370719f, 0.12065776f, -0.19410957f, 0.13267353f, 0.07079618f, 0.19917765f, 0.05716807f, 0.13286623f, 
    0.02322415f, 0.00382437f, -0.05015782f, -0.04354879f, 0.16915414f, -0.16970873f, 0.16723333f, 0.03849478f, 
    -0.09319122f, -0.09923258f, 0.01037198f, 0.00899224f, -0.08966469f, -0.10729539f, -0.13468730f, -0.08596984f, 
    0.09911753f, -0.03916484f, -0.09363119f, -0.09224773f, -0.03066738f, -0.11101303f, -0.08061717f, -0.03053829f, 
    0.09073912f, -0.15978183f, 0.00510967f, 0.01290837f, -0.06751227f, 0.04130193f, 0.06756530f, 0.08577941f, 
    -0.07164237f, -0.03500101f, -0.36810413f, -0.20792592f, 0.10930893f, 0.01018499f, -0.01177929f, 0.03576779f, 
    0.08810180f, 0.10715216f, -0.21547025f, -0.01632722f, -0.62948316f, -0.05345347f, 0.13921969f, -0.12037808f, 
    0.09121737f, 0.02924083f, 0.27277550f, 0.00855086f, 0.03229614f, 0.01149071f, -0.08365656f, -0.04821238f, 
    0.00105634f, 0.13511980f, 0.00574771f, -0.01735480f, 0.06871657f, -0.20699315f, 0.00135533f, 0.04454103f, 
    -0.39950368f, -0.80974078f, -0.19846195f, -0.18087873f, -0.54527754f, 0.18418406f, 0.18907355f, 0.12101942f, 
    0.10530752f, 0.24049741f, 0.09783804f, -0.00169696f, 0.08662242f, -0.03917561f, 0.00462993f, -0.08228894f, 
    -0.13391595f, -0.09904273f, -0.23934437f, -0.10551013f, 1.00180876f, 0.11392090f, -0.41527304f, -0.12376460f, 
    0.05056726f, -0.02445751f, -0.07516486f, -0.03264631f, 0.07304519f, 0.00976214f, 0.14204744f, 0.03398712f, 
    -0.06657641f, 0.03633556f, -0.04102528f, 0.02890526f, -0.10779651f, -0.09388196f, -0.05548327f, 0.05400590f, 
    -0.39993241f, 0.30340478f, 0.01899670f, 0.07971087f, -0.22095323f, -0.10814326f, -0.35643104f, 0.05683062f, 
    0.02890211f, -0.14287302f, 0.05801064f, 0.01603925f, 0.07064657f, -0.11209707f, -0.02414646f, 0.03343652f, 
    0.04777877f, -0.16162725f, 0.06971185f, -0.01683901f, 0.73658240f, 0.26483637f, -0.46944010f, -0.00857469f, 
    -0.08590528f, 0.10702361f, 0.05702954f, -0.10703656f, -0.05055531f, 0.02050891f, 0.31971714f, 0.06622639f, 
    0.03565194f, 0.02041857f, 0.06072658f, 0.07107443f, -0.07609910f, 0.03291498f, -0.04644968f, 0.18056828f, 
    -0.15778175f, 0.31470975f, -0.12570491f, -0.21626969f, 0.40991578f, 0.33661687f, 0.05767723f, -0.02301878f, 
    -0.00989508f, -0.05129291f, 0.12137824f, 0.19064061f, -0.10356981f, 0.01154153f, 0.09773098f, -0.06138961f, 
    0.10918497f, 0.03063847f, 0.02697545f, -0.04766888f, -0.42762691f, 0.05394371f, 0.07979424f, -0.27504063f, 
    0.21621630f, -0.27613932f, 0.00915627f, -0.09195125f, 0.13613079f, 0.02027690f, 0.03621342f, -0.10424838f, 
    0.02443892f, -0.01044919f, -0.03941028f, -0.02413683f, -0.10094068f, 0.02756862f, -0.23665659f, -0.12070548f, 
    -0.63739884f, 0.50620461f, -0.02579239f, -0.16768247f, 0.16123539f, -0.26414850f, 0.01087131f, -0.05368737f, 
    -0.24023001f, 0.01630767f, 0.00119765f, 0.00339170f, 0.07091952f, -0.13292436f, 0.07837734f, 0.18558565f, 
    -0.07187250f, -0.09160514f, 0.03233645f, -0.09282608f, -0.13472567f, -0.58387822f, 0.13493334f, -0.00575201f, 
    0.20956500f, -0.10798779f, 0.05305971f, 0.07171223f, 0.13814650f, -0.15411568f, -0.06239009f, 0.02626347f, 
    -0.01996122f, 0.18681347f, -0.14146766f, -0.22054969f, -0.15261921f, -0.03506316f, -0.21895950f, -0.02551867f, 
    -0.37086669f, 0.04314480f, -0.12307511f, 0.13550128f, -0.21132484f, -0.03268248f, 0.04192641f, -0.00079389f, 
    -0.03480758f, -0.16605754f, -0.03063127f, -0.07578293f, 0.10587040f, -0.02618118f, -0.01670102f, -0.06361523f, 
    0.09965183f, 0.03787576f, -0.04891489f, -0.15666458f, 0.19024067f, 0.06581719f, -0.03707009f, 0.16691932f, 
    0.08658765f, 0.19807908f, -0.24173218f, 0.00537618f, -0.03090870f, 0.02067264f, 0.05207087f, 0.13265002f, 
    0.02771758f, -0.07484578f, -0.04401362f, -0.03827000f, 0.22249389f, 0.06978433f, -0.13178584f, -0.00297343f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13736178f, 0.08284607f, -0.08677057f, -0.01988905f, -0.02366880f, 0.06906037f, -0.01054569f, -0.09310181f, 
    0.00150091f, 0.04493651f, 0.06518456f, 0.07087614f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
