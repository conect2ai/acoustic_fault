#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.93785357f, 0.42814299f, 0.54795915f, -0.45657718f, -0.30971518f, 0.55664587f, -0.36499411f, 0.43023947f, 
    0.35389635f, 0.06140801f, 0.17863093f, 0.01813232f, -0.17866668f, -0.35176924f, 0.15409577f, -0.15198289f, 
    -0.18298458f, -0.30131340f, -0.16994920f, 0.18894146f, -0.04890867f, 0.01566445f, 0.01992786f, -0.22297078f, 
    -0.34814355f, -0.79413617f, -0.45991778f, -0.60710287f, -0.39023805f, -0.40247968f, -0.35337096f, -0.43509540f, 
    0.01010277f, 0.43848541f, 0.22121359f, 0.13226743f, 0.21630470f, -0.07470707f, 0.05370146f, -0.09367657f, 
    0.05592419f, 0.15478393f, 0.05744718f, 0.43381906f, 0.03925746f, 0.11950071f, -0.21997574f, 0.36597040f, 
    -0.05922642f, 0.04299138f, 0.27345407f, 0.46230754f, 0.55302227f, -0.34914297f, -0.62032950f, -0.81910008f, 
    -0.15570129f, -0.58276474f, -0.44056311f, -0.59222931f, -0.12044297f, 0.06580076f, -0.10062108f, 0.14426009f, 
    -0.07691476f, -0.27251285f, -0.02978477f, -0.05134346f, 0.03693096f, -0.09466806f, 0.03990603f, 0.17380561f, 
    -0.02176331f, -0.13566285f, -0.02480692f, 0.47886908f, -0.38274270f, -0.98210388f, -0.55290377f, -0.18045412f, 
    -0.25885323f, 0.65205091f, 0.05333491f, 0.01018339f, 0.20894408f, 0.21276802f, -0.28301078f, 0.18903148f, 
    0.12916356f, 0.29377499f, -0.17013156f, 0.24407439f, 0.10510805f, -0.07082756f, 0.09191967f, 0.09475812f, 
    0.01810145f, -0.01553174f, -0.02038115f, 0.12988782f, -0.48471868f, 0.27173552f, -0.62342316f, -0.46643433f, 
    0.17889738f, -0.42137235f, 0.30922753f, 0.56603783f, -0.09424229f, -0.11366579f, 0.17046417f, -0.23735118f, 
    0.08563054f, -0.51521063f, 0.32026625f, -0.11574715f, 0.03346844f, -0.10568833f, 0.01809042f, -0.15961431f, 
    -0.23014022f, -0.05881683f, -0.10622411f, -0.25493041f, -0.16978541f, -0.48810220f, -0.39918676f, -0.38398057f, 
    0.20385548f, -0.26003307f, 0.54601049f, 0.29479158f, 0.38103610f, 0.27557564f, 0.10264878f, 0.29063788f, 
    -0.03849928f, 0.04360024f, 0.44183671f, 0.51027095f, -0.08143243f, 0.09206602f, -0.31729499f, 0.11501586f, 
    0.35747612f, -0.09672481f, 0.16477585f, -0.07337128f, 0.39655277f, -0.00882922f, -0.37967378f, -0.30268052f, 
    0.59702343f, 0.71461695f, -0.06768698f, -0.57158786f, -0.26820996f, -0.20778707f, -0.24187058f, -0.09053885f, 
    -0.04647543f, 0.48843542f, 0.24589765f, 0.00557849f, -0.29206678f, 0.26641724f, 0.10919961f, 0.18205898f, 
    0.13430911f, -0.15923944f, -0.27030072f, -0.08650758f, -0.05509988f, -0.06506228f, -0.28783518f, 0.60499513f, 
    0.12384531f, 0.49087074f, 0.69479454f, 0.46720961f, 0.71596533f, -0.19384155f, -0.31255275f, 0.30385622f, 
    -0.37353367f, 0.22678559f, 0.26523358f, 0.02756680f, -0.18838811f, -0.11065353f, 0.39139569f, -0.03034081f, 
    -0.09168042f, -0.11273456f, -0.18819447f, -0.06131607f, -0.06708401f, 0.27161723f, -0.03272041f, 0.14449860f, 
    0.71855712f, 0.29373094f, 0.35596403f, 0.93217623f, 0.48570716f, 0.18800937f, 0.25612479f, -0.23283210f, 
    -0.29556149f, 0.23895136f, -0.29106709f, -0.24450804f, -0.45763150f, -0.25024486f, -0.22596885f, -0.38327548f, 
    0.02294839f, -0.09426970f, -0.11159599f, -0.22617745f, 0.19130933f, 0.39118260f, -0.12366318f, -0.01152112f, 
    0.14299984f, -0.49082264f, 0.10563540f, -0.32086188f, -0.47367844f, 0.34359580f, 0.85581726f, -0.36338040f, 
    -0.73267066f, 0.26753539f, -0.55016130f, 0.27472177f, 0.01712651f, -0.16696212f, 0.02520890f, 0.15120913f, 
    -0.27911362f, -0.19860600f, -0.14636539f, -0.17008246f, 0.12554476f, 0.30389383f, -0.01814689f, -0.14111067f, 
    0.22539720f, -0.42068431f, 0.20986417f, -1.30150628f, 0.18129984f, 0.76662707f, -0.30241022f, -0.64637190f, 
    0.72112668f, 0.30978718f, -0.42422521f, 0.13882658f, 0.04689594f, 0.05321313f, -0.21403904f, -0.02525066f, 
    0.23671526f, -0.09058616f, 0.03573209f, -0.02834129f, 0.07617308f, -0.11003015f, 0.14123678f, 0.01437593f, 
    0.01159430f, 0.03037926f, 0.05262141f, -0.43616056f, -0.43588826f, -0.59201115f, -0.25474325f, -0.30459976f, 
    0.52243859f, 0.95960259f, 0.00767313f, 0.44128487f, 0.64574122f, -0.12366882f, -0.37820995f, -0.08456103f, 
    -0.34536636f, -0.12683024f, -0.26651040f, -0.15292941f, -0.05114143f, 0.04572048f, -0.29081932f, -0.20071557f, 
    -0.07451058f, 0.01585632f, -0.12650354f, -0.00073204f, 0.43305635f, 0.74340421f, 0.66135436f, 0.19208992f, 
    -0.11168671f, 0.02799977f, 0.10225393f, 0.17367952f, -0.49174336f, 0.31658122f, 0.26349553f, 0.10249603f, 
    0.04419030f, 0.17476401f, 0.05465451f, -0.13537699f, 0.03805833f, 0.35346833f, 0.05815356f, -0.03784809f, 
    0.25872201f, -0.16782282f, -0.29360166f, 0.17101173f, 0.24578755f, 0.79943132f, 0.16772783f, -0.13208464f, 
    0.99965197f, 0.23933919f, 0.19651937f, 0.18458793f, 0.24567385f, 0.36354080f, 0.23516431f, -0.56004596f, 
    -0.08803846f, 0.04023752f, 0.05633950f, 0.17781720f, 0.13186005f, 0.01392270f, 0.18724850f, 0.14388439f, 
    0.38008192f, 0.03791774f, 0.00511962f, 0.05659190f, -0.18902797f, -0.12192800f, 0.25795853f, 0.77499115f, 
    0.20748320f, -0.13030043f, -0.28190917f, -0.34153637f, 0.49811718f, -0.24330513f, -0.50666189f, 0.50801837f, 
    0.24798711f, 0.34424999f, -0.32796752f, -0.06897344f, 0.36486378f, 0.25328302f, -0.17282766f, 0.10352597f, 
    -0.19722590f, -0.18720303f, 0.06499336f, 0.35978663f, 0.02509155f, -0.02005480f, 0.08581135f, 0.80696672f, 
    0.54361141f, 0.60430765f, 0.34405050f, 0.18892257f, -0.58273977f, -0.64178908f, -0.40097287f, -0.02694734f, 
    0.23821895f, 0.19002528f, 0.27528885f, -0.14868468f, 0.20442578f, -0.19431722f, 0.09689192f, -0.18829550f, 
    0.15442435f, 0.07652176f, 0.02259714f, -0.05386565f, 0.08541097f, 0.16711928f, -0.07207489f, 0.16824277f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.23892786f, 0.27008992f, 0.11946680f, 0.13600291f, -0.00325053f, 0.18679014f, 0.19493926f, 0.07418713f, 
    0.08289123f, 0.09226748f, 0.00353458f, 0.07856899f, 0.07322271f, 0.27854565f, -0.05479414f, -0.08822066f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05702827f, 0.05554294f, -0.06805509f, 0.08543713f, 0.01758292f, 0.09952030f, 0.06498823f, 0.04145592f, 
    0.06492449f, 0.02042011f, 0.14670947f, 0.10155619f, -0.09777011f, -0.00098001f, 0.09433851f, -0.15352996f, 
    -0.19125691f, -0.03748999f, 0.02687889f, 0.12539236f, 0.06495218f, -0.06924893f, -0.00177757f, -0.03210022f, 
    -0.05652433f, 0.06426930f, -0.08858448f, -0.30422658f, 0.00400568f, 0.04106013f, -0.09157349f, -0.05330786f, 
    0.05023560f, -0.03556658f, 0.05575158f, 0.06799822f, -0.05011702f, 0.15251991f, 0.04187789f, -0.01431000f, 
    0.06874426f, 0.03850421f, -0.03576924f, -0.05616471f, -0.02598683f, -0.03884188f, -0.10453041f, 0.02425355f, 
    -0.11804260f, -0.01363354f, 0.01676361f, -0.30003974f, -0.05369934f, 0.11536563f, 0.06779931f, 0.10239332f, 
    0.09158317f, -0.02189290f, 0.08690935f, -0.03629578f, 0.11971869f, -0.07477501f, 0.11180446f, 0.02900541f, 
    -0.02095183f, 0.01791253f, -0.03501404f, -0.08875196f, -0.05063724f, -0.05316747f, 0.06211525f, 0.02751998f, 
    -0.27312839f, -0.05313086f, 0.05669037f, 0.03985361f, 0.01439021f, 0.04997138f, 0.07726808f, 0.02273009f, 
    0.00748709f, -0.02397551f, -0.06780709f, -0.11001683f, 0.21706329f, -0.11977024f, 0.01861815f, 0.17079800f, 
    0.01909602f, 0.01316996f, -0.13359576f, 0.05811548f, 0.09927797f, 0.03522035f, -0.03704330f, -0.03619584f, 
    0.10298918f, 0.07282238f, -0.09876584f, 0.32943034f, 0.17540176f, -0.04165760f, -0.01320755f, -0.02752771f, 
    -0.00743478f, 0.12554456f, 0.10663743f, 0.01929760f, 0.24410278f, 0.04190430f, 0.13003720f, -0.02509158f, 
    -0.05044537f, -0.00480130f, 0.01734271f, -0.13539648f, -0.02777524f, -0.03350516f, 0.06017652f, 0.06959817f, 
    0.07974304f, -0.17677286f, 0.00455005f, 0.06000594f, 0.02402708f, 0.07529476f, 0.04561599f, -0.01503417f, 
    0.05336055f, 0.15162425f, -0.00404752f, 0.00378794f, 0.21071324f, -0.14738891f, 0.17101668f, 0.02537332f, 
    0.01055102f, 0.03988175f, -0.06338068f, 0.02552913f, 0.08677619f, -0.00218572f, 0.13240595f, 0.11916146f, 
    0.11838152f, 0.03096065f, 0.03754999f, 0.01410244f, -0.01742179f, -0.10007107f, -0.08443477f, -0.02170086f, 
    0.04030244f, -0.04151500f, 0.06319687f, -0.03034153f, 0.18120037f, -0.24068989f, -0.04880723f, 0.35530776f, 
    0.06317756f, -0.06377333f, -0.00039827f, 0.02428222f, 0.09878644f, -0.00589727f, 0.00824442f, 0.02472237f, 
    0.01201413f, 0.29319710f, -0.10807541f, 0.14021316f, -0.00444460f, -0.04981969f, 0.01725878f, -0.10039967f, 
    0.06980696f, 0.06108014f, 0.02364245f, -0.02472079f, 0.15463814f, -0.05541319f, 0.07872907f, 0.08876558f, 
    0.10405914f, 0.03595918f, -0.03428417f, 0.07721625f, 0.14994186f, 0.04315936f, 0.00908299f, -0.12949954f, 
    0.03768679f, -0.03926769f, -0.01410585f, -0.02985259f, -0.01179458f, 0.03092226f, -0.02077334f, 0.01124640f, 
    -0.00835139f, 0.04814968f, -0.00515596f, -0.01319166f, -0.03249140f, -0.05651160f, -0.06571138f, -0.04680442f, 
    -0.07940277f, 0.01108888f, 0.05276262f, 0.04473029f, -0.00527130f, 0.03718472f, 0.00501089f, 0.04330838f, 
    -0.06887829f, 0.05946651f, -0.00336954f, 0.00650775f, -0.01090353f, -0.01371468f, -0.01115277f, -0.07354212f, 
    0.05445011f, 0.05507451f, 0.04583802f, -0.06888384f, 0.02173571f, 0.00092417f, -0.05652373f, 0.06421405f, 
    0.00936349f, -0.01193219f, -0.03157628f, -0.04751081f, -0.05290028f, 0.00822005f, -0.06525853f, -0.04115847f, 
    0.02460406f, -0.03509479f, 0.02676765f, -0.05744680f, -0.02240817f, -0.04561284f, -0.01052709f, -0.06587487f, 
    -0.03966798f, -0.06409656f, -0.02271026f, 0.00535023f, 0.00092082f, 0.05031032f, -0.05175123f, -0.02486570f, 
    0.01978751f, 0.02663596f, -0.01841348f, 0.03284482f, 0.05584487f, -0.07584997f, -0.05120003f, 0.06057435f, 
    -0.04524570f, -0.05076725f, 0.05180149f, 0.02100863f, 0.01415372f, 0.01975654f, -0.05590212f, 0.04880354f, 
    0.04667903f, 0.01759472f, 0.01243473f, -0.07498916f, -0.03035902f, 0.00784781f, 0.05554463f, 0.00745758f, 
    -0.03510306f, -0.07561518f, -0.02911817f, -0.00826038f, -0.01216319f, -0.00451521f, 0.03411434f, -0.01571357f, 
    -0.08292995f, 0.04969353f, 0.03818173f, -0.04772640f, -0.03390505f, -0.00446101f, -0.02678872f, -0.02229005f, 
    0.03800386f, 0.04410883f, 0.03639097f, 0.01475994f, -0.05453635f, 0.04944171f, -0.02405341f, -0.03202701f, 
    -0.01436212f, -0.05012511f, -0.06928743f, -0.03539002f, -0.06484088f, -0.00497250f, -0.04233246f, -0.07513186f, 
    0.05961067f, -0.03584450f, -0.03608730f, 0.01431491f, 0.02026168f, -0.04141930f, -0.01784695f, -0.07472634f, 
    -0.03895761f, -0.03101900f, 0.05179986f, -0.06988073f, 0.01000581f, 0.05962731f, -0.03077940f, -0.02142237f, 
    -0.04615696f, 0.01532383f, 0.00084717f, 0.02089116f, 0.01876108f, 0.01977210f, -0.03020281f, -0.05891229f, 
    -0.05658660f, -0.07595236f, 0.01357716f, 0.01875185f, -0.00950563f, 0.00300675f, -0.06224891f, -0.02987879f, 
    -0.03485731f, -0.03254135f, -0.01780984f, -0.05122523f, 0.02052998f, -0.05494934f, 0.06949303f, 0.00231472f, 
    -0.06304630f, -0.06112586f, 0.00293512f, -0.01749577f, -0.02501848f, -0.04195015f, 0.03657085f, 0.04215158f, 
    -0.06187063f, -0.05728628f, -0.01547026f, 0.03096546f, -0.05732210f, 0.01803105f, -0.01453319f, -0.00057026f, 
    -0.03798022f, 0.02226494f, -0.06854249f, 0.04276526f, -0.08483315f, -0.05123017f, 0.02162327f, 0.00525714f, 
    -0.07913996f, -0.06599040f, -0.01455997f, 0.00191645f, -0.02539573f, 0.04264041f, 0.02521557f, -0.01168349f, 
    -0.14126706f, -0.03846608f, 0.01901483f, 0.14755535f, 0.00501437f, -0.08424360f, 0.08411031f, -0.19275363f, 
    0.13516983f, 0.00955074f, -0.08954718f, -0.04645972f, 0.04155069f, -0.13567835f, -0.03590075f, 0.16653682f, 
    0.37450486f, 0.03642641f, 0.02987347f, 0.01197500f, 0.00821371f, 0.06982370f, -0.02464987f, 0.12526403f, 
    -0.02116409f, -0.06786586f, 0.09971987f, 0.01112125f, 0.03781796f, -0.04567318f, 0.03472022f, 0.00008632f, 
    -0.17262730f, 0.07998916f, -0.02919328f, -0.05279711f, -0.00566631f, -0.14672945f, -0.00248967f, 0.03068018f, 
    0.06064091f, 0.04431413f, -0.05426754f, 0.11803887f, -0.01388066f, -0.06273737f, 0.13894556f, -0.04295469f, 
    0.15347306f, -0.08151381f, -0.06443570f, 0.23584762f, -0.03178871f, -0.09081992f, -0.06883589f, -0.05698441f, 
    0.07842412f, -0.07456010f, -0.08222806f, 0.17221460f, -0.09095702f, 0.02303468f, -0.12452020f, 0.09662560f, 
    -0.02787949f, 0.07486363f, 0.11620605f, 0.04139902f, 0.06904648f, 0.11956221f, -0.19339602f, 0.02512142f, 
    0.27079096f, -0.01046712f, 0.06530371f, 0.05173440f, -0.15779935f, 0.10237010f, -0.07135398f, 0.04821093f, 
    -0.10654628f, 0.11079838f, 0.08517959f, 0.11100769f, -0.19583987f, 0.28480017f, 0.13027231f, -0.09717999f, 
    -0.05359605f, -0.01833066f, 0.15784565f, -0.05882301f, 0.11141970f, -0.05549291f, -0.01971297f, 0.11467455f, 
    -0.05471816f, 0.25006679f, 0.25473300f, -0.19911733f, -0.04053468f, 0.09961293f, -0.07424129f, 0.15212020f, 
    0.09449136f, -0.06209289f, 0.16483915f, 0.14175645f, -0.28011999f, 0.14616083f, -0.04685259f, -0.14722560f, 
    0.15042834f, -0.04471834f, -0.00952856f, 0.19975328f, 0.05769324f, 0.02282478f, -0.05639672f, 0.01430443f, 
    -0.06239530f, 0.16073677f, -0.06642009f, -0.00647777f, -0.11948650f, 0.02636384f, -0.04775795f, 0.02625998f, 
    0.07343050f, 0.01487085f, -0.06714572f, -0.01907469f, -0.05565783f, 0.12449761f, -0.05764044f, 0.13648431f, 
    -0.05981777f, -0.02538359f, -0.02650161f, 0.00767340f, -0.02938689f, -0.03592672f, 0.04147667f, -0.01306236f, 
    -0.19040883f, 0.14247967f, -0.10305532f, -0.07555959f, 0.03119353f, 0.06754616f, -0.09134336f, 0.02355975f, 
    -0.09109131f, 0.06147132f, -0.02082950f, 0.08324086f, -0.04417780f, 0.15217218f, 0.10150664f, -0.15708569f, 
    0.01741138f, 0.00630279f, -0.00710201f, -0.09427601f, -0.05524725f, 0.09572693f, 0.11610386f, 0.04057234f, 
    -0.22511426f, -0.16572027f, 0.04697999f, -0.02800476f, -0.07982889f, -0.04794117f, 0.04242258f, -0.01738344f, 
    0.02488809f, 0.04448399f, -0.07507145f, 0.02056769f, -0.33661816f, 0.00490385f, 0.19392787f, 0.02334544f, 
    -0.07911839f, 0.03545050f, 0.01060109f, -0.10816579f, 0.09795900f, 0.04611994f, 0.11513419f, 0.01755691f, 
    -0.06854022f, -0.04215038f, 0.02307033f, 0.01845846f, -0.05795993f, -0.06919073f, -0.09314109f, -0.05809747f, 
    -0.00968454f, -0.04386255f, 0.04488602f, 0.06333725f, 0.00689305f, -0.05933369f, 0.01976957f, -0.07070275f, 
    -0.06691874f, 0.02695171f, -0.03750623f, 0.04982458f, 0.05366277f, 0.01947174f, 0.05968721f, -0.02894214f, 
    -0.01444392f, -0.05576212f, -0.00707436f, -0.07844087f, -0.03399775f, 0.01637612f, -0.07137908f, 0.03634791f, 
    -0.06972782f, 0.03573922f, -0.03967255f, -0.08254990f, -0.02510162f, -0.02715225f, -0.04119169f, 0.04980377f, 
    0.06136975f, 0.02986338f, 0.03524110f, -0.06636072f, 0.03837950f, -0.05863424f, -0.01319746f, -0.07692575f, 
    -0.03520632f, 0.02655926f, 0.01050292f, -0.06826009f, -0.01959933f, -0.04225186f, -0.08790193f, 0.02686414f, 
    -0.00140036f, 0.03399448f, -0.06232185f, 0.04440894f, -0.07065796f, -0.04935176f, 0.01427343f, 0.03271459f, 
    -0.04760336f, 0.05959165f, -0.07525565f, 0.03204766f, -0.00997510f, -0.02563960f, -0.06885491f, -0.05581341f, 
    -0.02302564f, 0.01250479f, 0.00578762f, -0.02511526f, 0.02706178f, 0.01243173f, 0.01656281f, 0.02569818f, 
    -0.04444804f, -0.01100723f, 0.06188831f, 0.03447277f, 0.01329252f, 0.01816669f, -0.03377124f, -0.01479494f, 
    -0.01238819f, 0.01737557f, -0.07508067f, -0.03020488f, -0.00600064f, 0.03063575f, 0.02902332f, -0.03783187f, 
    -0.02264700f, -0.05035909f, -0.07145995f, 0.04909638f, -0.07393405f, 0.03997466f, -0.00592025f, 0.00104168f, 
    0.05062043f, 0.05869515f, -0.02419630f, -0.04490615f, 0.03525079f, 0.06669077f, 0.02334994f, -0.06891862f, 
    -0.00198519f, -0.02299484f, -0.00375969f, -0.03212951f, 0.03223486f, -0.06107627f, 0.05642641f, 0.02592572f, 
    0.07103229f, -0.09121244f, -0.05681311f, -0.01994352f, -0.06355336f, -0.00610021f, -0.05977781f, -0.03172303f, 
    -0.01752926f, 0.06024758f, 0.04326934f, -0.04522733f, -0.07679634f, -0.04788960f, 0.02178948f, -0.04310516f, 
    -0.03996255f, -0.05203750f, -0.01890195f, -0.03412534f, 0.01950507f, -0.01519278f, 0.01139719f, -0.04270595f, 
    0.03677901f, 0.05146759f, -0.04640082f, -0.03196378f, 0.02949975f, -0.00961936f, 0.02293914f, 0.00405225f, 
    0.00857588f, 0.02345662f, -0.07094110f, 0.02390748f, 0.04753061f, -0.07970804f, 0.01537825f, -0.06410078f, 
    -0.01381259f, -0.00963494f, 0.02519099f, -0.06837842f, -0.03338149f, -0.02979738f, -0.05611517f, -0.01172371f, 
    -0.03848134f, -0.07086986f, -0.05175788f, 0.04289636f, -0.04209629f, 0.03962028f, -0.05764804f, -0.00542941f, 
    -0.03448407f, 0.05226093f, 0.03363311f, 0.01647632f, 0.00924448f, -0.03146952f, 0.05750657f, -0.00095467f, 
    -0.01521870f, 0.05522591f, 0.04535506f, 0.02734333f, 0.00577545f, -0.05704505f, 0.00383636f, 0.03030721f, 
    0.39849949f, 0.08046590f, 0.02645976f, -0.12779965f, -0.02100313f, -0.02510737f, -0.01149831f, -0.08997320f, 
    -0.06530774f, -0.05220300f, -0.01861646f, -0.13335682f, 0.08702128f, -0.10450976f, 0.06100509f, 0.37130877f, 
    0.13039373f, 0.05361428f, 0.04990966f, 0.07260254f, 0.08000833f, -0.09952150f, -0.01974986f, 0.02517409f, 
    0.01719796f, -0.17694111f, -0.09723130f, 0.04105657f, -0.06663211f, -0.03918756f, 0.04251136f, -0.17642386f, 
    -0.04601189f, -0.00132042f, 0.05895739f, -0.01036556f, -0.11364253f, 0.21461947f, 0.10772970f, -0.01827115f, 
    -0.06804907f, -0.02704715f, -0.05470696f, 0.12881613f, 0.07851917f, -0.00632599f, -0.02864647f, 0.12930362f, 
    0.15703104f, -0.04142515f, -0.02949174f, 0.06792751f, 0.11934219f, 0.00223896f, 0.02001646f, -0.02397208f, 
    0.06169012f, 0.00337340f, 0.05044632f, 0.02420037f, -0.12447451f, 0.20027989f, 0.00541874f, 0.05370920f, 
    0.01550321f, -0.03667309f, 0.08390706f, -0.05775830f, -0.03242702f, -0.06318585f, 0.06924076f, -0.01369061f, 
    0.25362295f, -0.19933945f, -0.05613798f, 0.00138650f, 0.01357715f, 0.05301315f, -0.09936807f, -0.08210728f, 
    -0.01072805f, 0.01063991f, -0.07075889f, 0.12119550f, 0.02181228f, 0.16709550f, 0.10017203f, 0.23450524f, 
    0.03162653f, 0.11767910f, -0.01923172f, -0.10852376f, -0.01661374f, -0.17931789f, -0.10168522f, -0.03723549f, 
    -0.06287517f, 0.09449770f, 0.02362632f, 0.13415043f, -0.01763838f, 0.08942703f, 0.00463920f, 0.02418932f, 
    -0.03059945f, 0.06553786f, -0.11040078f, 0.04027816f, -0.29678804f, 0.13468455f, 0.10058219f, 0.02614959f, 
    0.02457106f, -0.01341269f, 0.03720237f, 0.04650503f, -0.07933060f, -0.06504364f, -0.04071303f, 0.05826312f, 
    0.10047881f, 0.18452328f, -0.06909890f, -0.24031030f, -0.09914431f, -0.03527728f, -0.05806910f, 0.15529332f, 
    0.07381655f, -0.07816140f, -0.10247932f, -0.04511263f, -0.11230448f, 0.25256902f, 0.13001771f, 0.22953352f, 
    0.02515959f, -0.05696745f, -0.04715188f, 0.10996159f, -0.07341547f, -0.06031311f, -0.00682184f, -0.13326125f, 
    0.01046123f, -0.03547505f, -0.11144682f, -0.05158492f, 0.06591706f, 0.13987786f, 0.01126600f, -0.07080609f, 
    -0.08741258f, 0.01189841f, 0.08993975f, -0.01161757f, 0.34158611f, 0.24635008f, 0.02767051f, 0.00530046f, 
    -0.01853500f, 0.09633464f, 0.08485910f, -0.03552677f, -0.12511468f, 0.11769684f, 0.08599430f, -0.02378088f, 
    0.17884463f, -0.05306854f, 0.12973106f, -0.26460463f, -0.03894252f, -0.13238171f, -0.02977122f, 0.02718600f, 
    0.06338091f, 0.00574519f, -0.00857625f, 0.13365373f, -0.18953776f, -0.03592923f, 0.00440971f, 0.03881231f, 
    -0.09663198f, 0.07490188f, -0.01439430f, -0.04241708f, -0.04144629f, -0.02107579f, 0.18417613f, -0.14565100f, 
    -0.05523468f, -0.14206669f, 0.15211833f, -0.09997724f, 0.07225861f, -0.12689207f, 0.14789684f, -0.02506379f, 
    0.00392244f, 0.07349740f, -0.14621192f, -0.07289506f, 0.05528983f, -0.04784405f, 0.08387616f, -0.13080545f, 
    0.09567600f, -0.11809146f, -0.04790930f, -0.03375271f, -0.08483609f, -0.00132018f, -0.00398929f, 0.09763066f, 
    -0.26480630f, 0.29808670f, -0.04526867f, -0.06243973f, 0.10919362f, 0.05956794f, 0.04950367f, 0.05041954f, 
    -0.08784682f, 0.01560413f, -0.05078130f, 0.00228085f, 0.21011461f, -0.13532989f, -0.03490268f, -0.07008535f, 
    0.00572791f, 0.12910391f, 0.08350796f, 0.06075797f, -0.04169070f, 0.07212423f, 0.14112365f, 0.05510698f, 
    0.20608136f, 0.01957389f, -0.02568779f, -0.03731114f, 0.00406513f, 0.07030039f, -0.07955075f, 0.11686783f, 
    -0.11216950f, 0.00057398f, -0.12089941f, -0.10769486f, 0.14136149f, 0.04393495f, 0.08852852f, 0.06136416f, 
    -0.11997220f, 0.01039231f, 0.11290664f, 0.09449067f, 0.02090162f, 0.19219364f, -0.02247253f, 0.16589963f, 
    0.16078156f, 0.13941613f, -0.17148258f, 0.05403317f, -0.00740836f, -0.04838625f, 0.06106886f, -0.06800079f, 
    0.04580482f, -0.00722766f, 0.12741867f, 0.07931103f, -0.13821268f, -0.25603801f, 0.00911055f, 0.17519613f, 
    0.17464389f, -0.07571533f, -0.01450862f, -0.04300309f, 0.12300634f, 0.01658541f, 0.06644819f, 0.04809130f, 
    -0.05828195f, -0.18924521f, -0.04736787f, -0.02504103f, 0.08449975f, 0.03241576f, -0.00309242f, 0.06082943f, 
    0.07275604f, 0.03877885f, 0.01651190f, -0.02695160f, 0.08173048f, -0.15485044f, 0.06563791f, 0.03269112f, 
    0.02764873f, -0.16298190f, 0.02241437f, 0.13674088f, 0.05204011f, 0.06624333f, -0.04663989f, 0.04259186f, 
    0.32304013f, -0.20126663f, -0.11190329f, 0.24498934f, -0.10033632f, 0.07929344f, -0.07980340f, 0.05297060f, 
    0.15166484f, 0.04746538f, 0.05343753f, 0.01763374f, 0.55745214f, 0.07557034f, -0.09190033f, -0.06441318f, 
    0.03989280f, -0.07007422f, -0.06936656f, 0.03996493f, 0.06189341f, -0.09046622f, -0.06205308f, -0.17815228f, 
    -0.08062097f, 0.13586749f, 0.02625767f, 0.08156565f, 0.06866062f, 0.11246562f, 0.04972227f, 0.03712643f, 
    0.03167969f, 0.05543147f, 0.05311839f, 0.13834733f, -0.07333341f, -0.30963352f, -0.07552165f, -0.11120079f, 
    0.07100184f, 0.01803144f, -0.19185297f, 0.09976260f, 0.07180267f, 0.04016344f, -0.01108114f, 0.11053583f, 
    -0.03179450f, -0.05410585f, 0.00922623f, -0.21435824f, 0.18668345f, 0.06286630f, -0.00758456f, -0.01967233f, 
    0.03455187f, -0.05430888f, 0.03088472f, 0.01555539f, -0.08389244f, 0.02399501f, 0.07448213f, 0.07196881f, 
    0.02791008f, 0.06002842f, -0.01389427f, 0.05134917f, 0.03366214f, -0.07382752f, 0.03407060f, -0.00888652f, 
    0.03987541f, 0.06118033f, 0.01866287f, -0.00319955f, 0.05606115f, 0.02644664f, 0.06252237f, -0.04227970f, 
    0.05805724f, 0.03041804f, 0.05161754f, -0.03725670f, 0.02165084f, 0.00173664f, -0.04037875f, -0.05078839f, 
    -0.07015018f, 0.02796013f, -0.03032793f, 0.02490467f, -0.01771695f, 0.03049737f, -0.02636820f, 0.03026642f, 
    0.02390567f, 0.00966256f, -0.06016152f, -0.00907923f, 0.02820448f, -0.04190119f, -0.06939337f, 0.01050021f, 
    0.00763395f, 0.01591478f, -0.02112973f, -0.04536921f, 0.04246349f, 0.05878381f, 0.04907878f, -0.00002100f, 
    0.00707660f, 0.01809767f, -0.03900407f, 0.01253585f, 0.02667456f, 0.01029643f, -0.05292638f, 0.05585276f, 
    -0.01797481f, 0.01560337f, 0.01853720f, 0.05765249f, -0.07522294f, 0.00004802f, -0.07141092f, 0.04743371f, 
    0.03204893f, -0.01506936f, 0.01403156f, 0.02822288f, -0.07506546f, -0.06322020f, -0.05107975f, -0.07237991f, 
    0.00047877f, 0.04797671f, -0.06568573f, -0.00444175f, -0.01129242f, -0.06687553f, 0.02762714f, 0.04243046f, 
    -0.07245979f, 0.01010002f, 0.00419271f, -0.06397860f, -0.06489810f, -0.01051514f, -0.00104955f, 0.03607778f, 
    -0.06778986f, -0.05179017f, -0.02038570f, -0.06189214f, 0.00412425f, -0.00646964f, -0.01672447f, -0.06151961f, 
    -0.00664428f, -0.05249026f, -0.02418769f, -0.01650588f, 0.05701128f, -0.07269336f, -0.03586112f, 0.02323858f, 
    0.01435481f, -0.03547991f, -0.08177736f, -0.04617770f, 0.01574369f, -0.04012559f, -0.04543856f, -0.03421544f, 
    -0.00727903f, 0.01777847f, -0.07894114f, 0.05042639f, 0.03019191f, -0.01127335f, -0.07436320f, 0.02955860f, 
    -0.08093467f, 0.05802409f, -0.01827290f, -0.03238562f, -0.02739035f, 0.01037245f, 0.05548567f, 0.00344236f, 
    0.05163210f, -0.02762944f, -0.07706026f, 0.01511514f, -0.01346767f, -0.07195950f, -0.01038427f, -0.04482050f, 
    0.02498129f, -0.01146190f, 0.03060867f, 0.00706739f, 0.01807122f, -0.03779684f, -0.05293129f, -0.00492628f, 
    -0.04179216f, 0.03691588f, -0.03675082f, 0.00421055f, -0.06612694f, -0.03892618f, 0.00001731f, -0.07844427f, 
    -0.00267061f, 0.00795102f, -0.06725097f, 0.00715284f, 0.04270407f, -0.05208759f, -0.02812881f, -0.07241606f, 
    -0.03864306f, -0.04747437f, -0.00963560f, -0.05820930f, 0.04175554f, 0.03870635f, -0.01601493f, -0.06901676f, 
    -0.00146169f, -0.05883905f, 0.03509125f, -0.01126073f, -0.01356245f, -0.05101553f, 0.06100046f, 0.05013092f, 
    0.06008188f, -0.07133743f, -0.04116810f, 0.04044851f, -0.04541250f, 0.02127922f, -0.05460569f, 0.04233908f, 
    -0.01514619f, -0.00529115f, 0.04246512f, -0.06706174f, -0.02105531f, 0.01276166f, 0.00269528f, -0.04962612f, 
    -0.05144930f, -0.03300966f, 0.01059251f, -0.04302275f, 0.02059210f, 0.04647058f, -0.01240118f, -0.07336540f, 
    -0.04688987f, -0.00444103f, -0.01189666f, -0.06906548f, 0.04795979f, -0.06824774f, -0.04427495f, -0.03255960f, 
    0.02513542f, -0.04919054f, -0.02090522f, 0.05259385f, -0.01375765f, -0.04470894f, -0.05044309f, 0.04275160f, 
    -0.00418039f, 0.01204071f, 0.02130252f, -0.09056956f, -0.04291993f, -0.03520189f, 0.01053128f, -0.01323960f, 
    -0.08272775f, 0.02298562f, 0.00962718f, -0.04499374f, -0.03637382f, -0.00594546f, -0.00169002f, -0.07039353f, 
    0.05573233f, 0.03238625f, -0.02602491f, -0.01202489f, -0.04834107f, -0.03733141f, 0.02259930f, -0.08142046f, 
    -0.03778387f, -0.00961541f, 0.01202309f, 0.05131684f, 0.03694701f, 0.00124991f, 0.01598242f, 0.01733649f, 
    0.02540089f, 0.02843830f, -0.06709562f, 0.01012610f, -0.08417784f, 0.03731929f, -0.00248436f, -0.00778970f, 
    0.02611539f, 0.03431318f, -0.06231733f, 0.02048594f, 0.04797252f, 0.06357124f, -0.05623314f, -0.02600263f, 
    -0.04414581f, 0.03560403f, -0.05666556f, 0.04495223f, -0.05826734f, -0.00733332f, 0.01794377f, 0.05995495f, 
    0.03091023f, 0.02347712f, -0.05422994f, -0.03431626f, -0.06514706f, -0.04977814f, -0.07224944f, -0.06790687f, 
    0.03173310f, 0.03209067f, 0.02735543f, -0.04581679f, 0.04820221f, 0.03889453f, 0.03341701f, -0.06185488f, 
    0.03892211f, -0.02623126f, 0.00269035f, -0.02830407f, -0.00708453f, -0.00990785f, -0.08853516f, -0.04274194f, 
    0.04095079f, 0.02651228f, -0.05475244f, -0.07979736f, 0.02317940f, -0.01518551f, -0.01209020f, 0.03494928f, 
    0.04662849f, -0.01539055f, 0.04294275f, 0.03896092f, 0.01482698f, 0.04914347f, -0.06452020f, -0.05366253f, 
    -0.07707172f, 0.02835085f, -0.07167523f, -0.04630552f, -0.00566586f, -0.05177815f, 0.03270403f, -0.07024183f, 
    -0.07951848f, 0.04208729f, 0.01572639f, 0.04127832f, -0.04577501f, -0.02898697f, 0.04612530f, -0.04970929f, 
    -0.07091051f, 0.02438744f, 0.04640797f, 0.03994462f, -0.04627668f, -0.03344906f, 0.02476051f, -0.08624884f, 
    0.00447289f, -0.07217833f, -0.01306418f, -0.01721360f, 0.02216328f, -0.01847346f, 0.00935400f, 0.04683046f, 
    -0.05020850f, 0.05932048f, -0.05294381f, 0.05737482f, 0.02663088f, -0.00817191f, -0.01392409f, 0.01036935f, 
    0.03056794f, -0.07841869f, 0.04544703f, 0.04450995f, -0.03844485f, 0.02142183f, 0.05119287f, -0.00785951f, 
    0.01627762f, -0.06438067f, -0.07026195f, 0.00342260f, -0.06347486f, 0.00711830f, -0.00633244f, 0.03690799f, 
    0.02264434f, -0.06959862f, 0.05740200f, 0.01076261f, 0.02400805f, 0.00031097f, 0.00699870f, -0.06964032f, 
    0.04478014f, 0.03442575f, -0.04318954f, -0.04944086f, -0.04875047f, 0.05054514f, -0.05100168f, 0.02986700f, 
    -0.00262281f, -0.07610422f, -0.01430827f, 0.02944320f, -0.02612782f, 0.01985288f, -0.03932919f, -0.02990620f, 
    0.00830234f, -0.08077607f, -0.03868194f, -0.05854715f, -0.01559934f, -0.02247629f, 0.00421067f, -0.00150007f, 
    0.06209411f, -0.02471095f, 0.02387971f, 0.05958881f, 0.01610403f, -0.03582564f, 0.04273251f, -0.02359786f, 
    -0.03712213f, 0.00801154f, -0.07468598f, -0.06500391f, -0.00739509f, 0.02584318f, 0.00190522f, 0.00616507f, 
    -0.07518724f, -0.07071785f, 0.02460232f, 0.07271101f, -0.00886582f, -0.03826851f, 0.03227153f, 0.05983879f, 
    -0.00734319f, 0.06063987f, 0.03140175f, -0.04245547f, -0.01971071f, -0.04772437f, 0.05594234f, 0.06675752f, 
    -0.06873298f, 0.02705773f, -0.04045188f, -0.03068219f, 0.03769618f, 0.00742622f, 0.06329614f, 0.00296378f, 
    -0.00423028f, -0.02871200f, -0.04699038f, 0.04415770f, 0.05390043f, 0.04117245f, -0.03615857f, 0.00666075f, 
    0.06319975f, 0.00184289f, -0.05367331f, -0.04856220f, 0.01150264f, -0.03585321f, 0.03146378f, -0.04078409f, 
    -0.04831807f, -0.05280191f, 0.00202024f, -0.07179989f, -0.07478614f, -0.06510825f, 0.02660575f, 0.03138199f, 
    -0.05540335f, -0.04612334f, -0.02298784f, -0.07019448f, -0.01601326f, -0.03825529f, -0.03231280f, -0.05015832f, 
    0.05079234f, -0.01041195f, -0.05443317f, -0.07726655f, 0.04504694f, 0.01213906f, 0.03074551f, 0.02566997f, 
    -0.02617892f, 0.06075817f, -0.03682017f, -0.04687245f, -0.00366105f, -0.03921858f, -0.02328996f, -0.02702213f, 
    0.05189721f, -0.07422824f, 0.00426113f, 0.02277140f, -0.04399896f, -0.05687312f, -0.06543460f, -0.07308383f, 
    -0.05380203f, 0.00020756f, 0.05124004f, 0.03582128f, 0.06024304f, -0.05099808f, 0.02924545f, 0.03034882f, 
    -0.01795984f, -0.03534370f, 0.05619684f, 0.01363442f, 0.00390336f, 0.02517397f, -0.03717789f, -0.04611352f, 
    0.04767622f, 0.01437368f, 0.03914243f, -0.01494036f, -0.04386231f, 0.07113667f, -0.03509249f, 0.00897662f, 
    -0.05267550f, -0.07589501f, -0.04711743f, -0.08808130f, -0.05780343f, -0.01274906f, 0.05630926f, -0.02025173f, 
    -0.06409425f, 0.04990992f, 0.06028153f, -0.00363265f, -0.00980659f, -0.07544587f, 0.05077682f, 0.01316879f, 
    0.00721986f, -0.01004702f, -0.02422427f, -0.04939933f, 0.05674587f, -0.05683691f, 0.03450796f, -0.06716701f, 
    -0.01295670f, -0.05212366f, -0.04319238f, 0.01638620f, 0.02855650f, 0.05136115f, -0.05263622f, -0.00164177f, 
    -0.04448555f, -0.02633430f, -0.03430118f, -0.04738825f, -0.00182022f, 0.00196765f, 0.00334720f, -0.05044319f, 
    -0.00341624f, -0.00379847f, 0.03404987f, -0.00851278f, -0.00748075f, 0.03409735f, 0.03252128f, -0.02186656f, 
    -0.05621057f, 0.03812847f, 0.00798251f, 0.01093446f, -0.00815903f, -0.07551240f, 0.01604961f, -0.06010189f, 
    -0.03323152f, -0.03576948f, -0.01423479f, -0.07117566f, -0.01267345f, -0.00239584f, 0.06436810f, 0.06534961f, 
    0.36973023f, -0.14231285f, -0.10063438f, 0.03109010f, -0.10114023f, -0.09615757f, -0.05853183f, -0.14020522f, 
    -0.06935337f, -0.06810888f, -0.04133135f, -0.21700777f, 0.24169566f, 0.10467973f, 0.13125642f, -0.20120114f, 
    0.22538751f, 0.21576555f, 0.04479756f, -0.13219884f, 0.15953150f, 0.00967729f, -0.09545200f, 0.12440222f, 
    0.23541220f, 0.61318910f, 0.14726612f, 0.06173496f, -0.19645067f, 0.07371914f, 0.02375006f, 0.01504119f, 
    -0.06740864f, 0.14022191f, 0.00909402f, 0.12495419f, -0.03660005f, 0.09299548f, -0.10069108f, -0.14059678f, 
    0.04447487f, 0.20125139f, 0.01283084f, -0.16959900f, 0.05225470f, 0.02672290f, -0.03731173f, 0.11318430f, 
    0.05111067f, 0.09352523f, 0.00291597f, -0.28663257f, 0.09597335f, 0.09444510f, 0.10359379f, -0.00870488f, 
    -0.24216306f, 0.05477431f, 0.08258867f, -0.01744552f, -0.31967512f, -0.21574940f, -0.11071570f, -0.22890973f, 
    0.17307876f, 0.07526512f, 0.16582300f, -0.25233373f, 0.08365700f, 0.09148097f, 0.04008266f, -0.01962193f, 
    0.15672605f, 0.47775316f, 0.12423031f, 0.12991181f, 0.08980308f, -0.02169524f, -0.04267033f, 0.10661548f, 
    -0.14363763f, -0.04177364f, -0.07213067f, 0.00538096f, -0.16981734f, -0.14640878f, 0.05327961f, 0.37892154f, 
    0.04317428f, 0.04708205f, -0.13927171f, 0.03504607f, -0.04385844f, 0.08431097f, -0.07374313f, -0.08437913f, 
    -0.22966260f, -0.04790504f, 0.10846180f, 0.29500979f, -0.18706235f, -0.08732027f, -0.09588207f, -0.11952309f, 
    0.07158831f, 0.01087539f, 0.04854614f, -0.17310186f, 0.00839083f, 0.09593282f, 0.01710376f, -0.14709014f, 
    0.08134364f, 0.10706432f, 0.21786740f, -0.17098746f, -0.10069710f, 0.15208358f, 0.13527398f, -0.12180232f, 
    -0.28561074f, 0.29713169f, 0.19172864f, 0.22448801f, 0.04454198f, -0.05117040f, 0.07377174f, -0.06500852f, 
    -0.04321626f, 0.03610888f, -0.19621858f, -0.09644998f, 0.55920118f, 0.40415877f, -0.18005455f, -0.23133917f, 
    0.23037374f, 0.08022230f, 0.19711167f, -0.20605513f, -0.01778639f, -0.08072311f, 0.01929687f, -0.12989441f, 
    -0.07898816f, -0.22582485f, -0.12911224f, 0.24875033f, -0.14331234f, -0.04909316f, -0.05125119f, -0.11203473f, 
    -0.20343475f, -0.01614794f, -0.01054664f, -0.01047929f, -0.14419410f, -0.18891315f, 0.16895643f, 0.20620924f, 
    -0.06691907f, -0.08782446f, -0.04480578f, -0.22419100f, 0.01039091f, -0.16435914f, -0.11007392f, -0.11256321f, 
    -0.09267272f, 0.01997775f, 0.03650006f, -0.04542561f, -0.17961264f, 0.08387440f, -0.15010975f, -0.08105265f, 
    -0.23556094f, 0.01189676f, 0.02788768f, -0.00487359f, 0.12071969f, 0.05639411f, 0.27629581f, 0.16777126f, 
    -0.08768769f, -0.24990466f, -0.21722625f, 0.07586198f, -0.26829872f, -0.13310473f, 0.05061934f, 0.00317251f, 
    -0.23338948f, -0.24189553f, -0.24206375f, 0.14785060f, 0.03584315f, 0.00242464f, -0.05459714f, -0.00432494f, 
    0.00788379f, 0.08285605f, 0.15113050f, -0.06261473f, -0.05445130f, 0.29197657f, -0.06877775f, -0.05615156f, 
    -0.10062063f, 0.05877806f, 0.01200073f, -0.01312902f, 0.00224242f, 0.09723761f, 0.02145763f, -0.02278828f, 
    0.22510757f, 0.10323309f, 0.02692725f, 0.20122814f, -0.00607290f, -0.00326626f, -0.03467280f, -0.02119502f, 
    0.01010530f, -0.01499371f, 0.00268947f, -0.04162278f, 0.01110101f, 0.09750573f, -0.19894864f, 0.00957735f, 
    -0.06764192f, -0.03648865f, 0.02751287f, -0.08641085f, 0.05493531f, -0.02099660f, -0.06284522f, 0.02594150f, 
    -0.36879387f, 0.25640982f, 0.24918498f, 0.01284017f, 0.12572533f, 0.02347064f, 0.03646877f, -0.03544635f, 
    0.12578298f, 0.04971953f, -0.00715580f, 0.01806811f, -0.10459331f, -0.11041414f, 0.00918399f, -0.10270397f, 
    -0.01192459f, 0.05530940f, 0.00806895f, 0.00198851f, 0.06031832f, -0.03927042f, 0.08928518f, -0.03995650f, 
    -0.15671024f, 0.09322318f, -0.01823511f, 0.03789339f, -0.03747399f, 0.07002205f, 0.17113844f, -0.03820998f, 
    0.08212619f, 0.04721195f, 0.07268780f, 0.01549809f, 0.06950422f, -0.29440832f, 0.08266655f, 0.18477453f, 
    -0.05543076f, -0.00144832f, -0.00629725f, 0.13208489f, 0.04395683f, 0.15215552f, 0.00030501f, 0.06874431f, 
    0.17551240f, -0.20365347f, -0.13487840f, 0.01646347f, -0.16745189f, -0.03969162f, 0.00266619f, 0.07289971f, 
    -0.03228527f, 0.12075215f, -0.02554013f, 0.07521191f, 0.41190580f, 0.04480296f, 0.09936603f, 0.10981488f, 
    -0.00055262f, 0.05229539f, 0.00133382f, -0.08850534f, -0.00647609f, 0.08233646f, -0.03265685f, -0.04377725f, 
    0.12649177f, 0.04419109f, 0.23297003f, 0.09868016f, 0.02728108f, 0.02925086f, 0.08061810f, 0.07473975f, 
    -0.04487110f, 0.08814091f, 0.02719315f, 0.07585683f, -0.15799215f, 0.08230049f, -0.08672275f, -0.13755450f, 
    -0.15946551f, 0.01522782f, 0.10325022f, -0.01750695f, 0.01342413f, -0.00854423f, 0.07268661f, -0.04772335f, 
    0.24127330f, -0.02690782f, 0.07469669f, 0.01264138f, 0.04219230f, -0.09193572f, 0.07229998f, 0.04655517f, 
    0.03577343f, -0.06801805f, 0.09696855f, 0.03244755f, 0.05639515f, -0.14556436f, 0.15980402f, -0.10930392f, 
    -0.05548554f, 0.01205131f, 0.01054063f, -0.04063192f, -0.05939807f, -0.13057302f, -0.06113001f, -0.07601897f, 
    -0.07552882f, 0.19119334f, -0.03103562f, 0.05830005f, -0.05242434f, 0.00470223f, 0.00729448f, 0.06723763f, 
    -0.07600121f, 0.00984623f, 0.11872627f, -0.02330573f, 0.31925014f, 0.15694684f, -0.31829369f, 0.16984357f, 
    0.08470090f, -0.08184329f, -0.01384629f, 0.16066809f, -0.02838254f, -0.07707212f, -0.05980616f, 0.05235385f, 
    -0.28497303f, 0.00187530f, 0.00838596f, 0.09899096f, 0.07588108f, -0.02739933f, -0.11473285f, -0.02230564f, 
    -0.01364183f, 0.01652800f, 0.08590733f, 0.03256716f, -0.10591196f, 0.29681823f, 0.22631145f, -0.15706709f, 
    -0.09688897f, 0.07137334f, -0.02003142f, 0.04918403f, 0.07019216f, 0.06605586f, 0.03482615f, 0.02121697f, 
    0.11218142f, 0.00946733f, -0.08907486f, -0.11985396f, 0.01593252f, -0.03364506f, 0.02297887f, 0.14363858f, 
    0.10407951f, -0.00766294f, -0.02877516f, 0.02242826f, 0.40731436f, -0.07275112f, -0.15836298f, -0.09389532f, 
    0.14342242f, 0.03437760f, -0.08130888f, -0.02860377f, 0.05709301f, -0.01943421f, 0.06420725f, -0.12168323f, 
    0.11779954f, 0.10980827f, 0.18505663f, -0.21270765f, -0.03343396f, 0.25071064f, -0.06698549f, 0.00734447f, 
    0.01143570f, -0.06726778f, 0.04744290f, -0.04797185f, 0.10779873f, -0.09730508f, 0.12777057f, 0.06973778f, 
    -0.02313459f, -0.05532959f, 0.10903168f, -0.11615256f, -0.10211308f, 0.12710205f, -0.04541555f, 0.01557342f, 
    -0.27158448f, 0.05700250f, -0.06789370f, -0.13728870f, 0.05317620f, -0.06997164f, -0.02007033f, -0.10950928f, 
    0.07439516f, -0.03254293f, 0.12026142f, -0.04321490f, -0.06203348f, -0.09737197f, 0.04800886f, 0.01455691f, 
    -0.07251959f, -0.06815551f, 0.04276532f, 0.00505385f, 0.00165808f, 0.04097432f, 0.11525819f, 0.05293691f, 
    0.26263061f, -0.03445707f, -0.00276176f, 0.00161835f, 0.08663763f, -0.01289718f, -0.00393219f, 0.02926564f, 
    0.03825724f, -0.03504802f, 0.13507544f, -0.11538350f, 0.12815091f, -0.02562087f, -0.07266445f, 0.07373332f, 
    0.06158657f, -0.04726164f, 0.04068748f, -0.09994624f, 0.07631745f, 0.02021473f, 0.01523013f, -0.02118610f, 
    0.09477164f, -0.19158082f, 0.08619218f, 0.10971114f, -0.11424707f, -0.03747446f, 0.14221352f, -0.04225695f, 
    -0.00985223f, 0.12068789f, 0.03118031f, 0.16885068f, 0.06642878f, -0.23856208f, -0.09020715f, -0.02508295f, 
    0.01788620f, -0.06607175f, -0.03693633f, -0.03427743f, 0.13873965f, -0.04718576f, 0.03729844f, -0.03286682f, 
    0.15738577f, 0.05497103f, 0.03556783f, 0.07117089f, 0.05378088f, -0.07847454f, 0.00895007f, 0.04417159f, 
    0.08629117f, -0.03552834f, 0.02279686f, 0.07723314f, 0.03800202f, -0.13225827f, 0.08633454f, 0.11100992f, 
    -0.07911263f, -0.04723768f, -0.09178323f, 0.01576587f, 0.05104663f, 0.04141339f, -0.06412587f, -0.05361909f, 
    0.05397776f, 0.17699052f, -0.28977427f, 0.11685654f, 0.00004431f, 0.02616260f, 0.08400818f, 0.06951474f, 
    0.06208102f, 0.03262571f, -0.06157751f, -0.01105674f, 0.18889004f, 0.18880780f, 0.03527239f, 0.03127860f, 
    0.21126941f, -0.15012331f, 0.01217594f, -0.04074967f, 0.11172556f, 0.03255128f, 0.00869180f, 0.07600462f, 
    -0.05727439f, 0.05692029f, -0.02053124f, 0.01591743f, -0.05442591f, 0.04075041f, -0.03588977f, -0.07367430f, 
    -0.06427895f, -0.00407623f, -0.06041282f, 0.03516310f, -0.06052155f, 0.04788972f, -0.06710353f, -0.05046918f, 
    -0.00981718f, -0.06334931f, 0.00797001f, -0.06250118f, 0.04542301f, 0.04895294f, 0.05245630f, -0.02539840f, 
    -0.00514713f, 0.06496433f, 0.03249995f, 0.03906158f, -0.02321488f, -0.02895785f, 0.01983346f, 0.03173582f, 
    0.01679450f, -0.07287467f, -0.00592185f, -0.04197561f, 0.01847519f, 0.01552284f, 0.00326541f, 0.05555470f, 
    0.02464551f, -0.06011641f, -0.03666105f, -0.07462772f, 0.02453722f, -0.05479441f, 0.00483457f, -0.00649550f, 
    -0.02787786f, 0.03877021f, 0.02266724f, 0.02737672f, 0.00308539f, 0.01756842f, -0.08126569f, 0.04363809f, 
    -0.06227989f, 0.01269460f, 0.05624002f, 0.03556811f, 0.02772212f, -0.03216070f, -0.06442444f, -0.08008655f, 
    -0.05805448f, -0.02969455f, -0.02919914f, -0.05470381f, 0.04448892f, -0.07380769f, -0.00704855f, 0.03865905f, 
    -0.06230974f, 0.03150077f, -0.07007106f, 0.02455366f, -0.00388739f, -0.04858952f, 0.03523150f, -0.07576646f, 
    -0.02174880f, -0.03388022f, -0.01523541f, -0.07860059f, -0.02019178f, -0.03871368f, 0.05528136f, 0.04627250f, 
    -0.05829552f, -0.01845586f, 0.02748190f, 0.04219471f, -0.03860688f, 0.04073432f, 0.00735419f, 0.01184665f, 
    0.03123086f, -0.02284025f, 0.01750580f, 0.04032270f, 0.05324212f, -0.04526386f, 0.03359933f, -0.00215732f, 
    0.02725900f, 0.01135210f, 0.02197887f, -0.05129603f, 0.01631671f, 0.01678668f, -0.07048474f, 0.02567220f, 
    0.03575002f, -0.07741978f, 0.01963123f, -0.02973994f, -0.05145526f, -0.04287488f, 0.01645296f, 0.03326636f, 
    -0.00132083f, 0.04070644f, -0.03512447f, -0.04099244f, -0.07505602f, 0.04170778f, -0.01961344f, 0.00964545f, 
    -0.03555002f, -0.07106401f, -0.07077040f, -0.05706640f, 0.01697561f, -0.02937808f, -0.05618497f, 0.01739448f, 
    -0.02319289f, 0.03330997f, 0.00696751f, 0.04743914f, 0.03119441f, -0.06087209f, 0.00616565f, 0.05748470f, 
    -0.02910306f, 0.02303098f, -0.04161293f, -0.06986089f, -0.00788998f, -0.04153645f, 0.04280860f, 0.04513162f, 
    -0.00621404f, 0.04892770f, -0.01243755f, -0.04975104f, 0.03960489f, -0.06125072f, 0.01430671f, -0.03857373f, 
    0.06596423f, 0.01522386f, -0.06978997f, 0.02904527f, 0.03085660f, -0.01244344f, -0.01440836f, 0.04217006f, 
    -0.08148981f, -0.02424791f, -0.06791955f, -0.03702994f, -0.03254876f, -0.06693491f, 0.00484052f, 0.02431512f, 
    -0.06384487f, 0.04581941f, 0.01825776f, -0.05659648f, 0.02771218f, 0.01941082f, 0.00261905f, -0.02294814f, 
    -0.01997164f, 0.01991902f, 0.05552522f, 0.04946631f, -0.00066087f, -0.06460736f, 0.02640373f, -0.02953476f, 
    -0.12019385f, -0.05999336f, 0.20850469f, 0.06091103f, 0.01110291f, -0.00473895f, -0.05194801f, 0.00403000f, 
    0.19436257f, -0.05520503f, 0.19468215f, 0.10350738f, -0.05579459f, -0.25197440f, -0.12855273f, -0.19000499f, 
    0.05136300f, -0.01408919f, 0.11508614f, 0.27197647f, -0.04952335f, 0.10250024f, -0.01224036f, -0.06623241f, 
    0.10493583f, -0.12257911f, 0.08457255f, 0.15009242f, -0.16297534f, -0.02680752f, -0.09651050f, 0.05460086f, 
    0.19192557f, -0.10412487f, 0.04459247f, 0.11852512f, 0.08198635f, -0.35828441f, -0.19525474f, -0.15623498f, 
    0.12669629f, -0.04577172f, 0.07252579f, 0.01266700f, 0.11613311f, -0.12637603f, 0.05376353f, -0.05537663f, 
    -0.05129496f, -0.05777879f, -0.21073441f, -0.20222864f, -0.01225224f, -0.07626143f, -0.04242423f, 0.11007375f, 
    0.12345371f, -0.01793599f, 0.00073670f, -0.16679499f, -0.08751433f, -0.11047725f, -0.17856386f, -0.07456512f, 
    0.15804468f, 0.19700618f, 0.04367537f, 0.09164249f, -0.00197719f, -0.05707753f, 0.01007175f, 0.00124439f, 
    -0.16758363f, 0.16500141f, 0.24459837f, -0.02406615f, 0.08570949f, 0.05444202f, -0.24185109f, 0.02754769f, 
    -0.04891261f, 0.08229458f, 0.09513385f, 0.04774494f, 0.02182211f, 0.20365980f, 0.07694472f, -0.05356115f, 
    -0.06144648f, -0.06042838f, -0.00760434f, 0.02528867f, -0.00025825f, -0.09096632f, -0.01559873f, 0.11529667f, 
    0.17209680f, 0.07683616f, 0.09452128f, -0.14609215f, 0.04546772f, 0.16867411f, -0.05387259f, 0.00846862f, 
    -0.01371757f, -0.08034523f, 0.10041811f, 0.21872419f, -0.02446532f, -0.09907988f, -0.06170215f, -0.26022834f, 
    0.09709959f, 0.07409998f, -0.08037620f, -0.00243700f, 0.01369427f, -0.05265892f, 0.03511602f, -0.17248872f, 
    -0.35939780f, 0.02472148f, -0.00101017f, 0.13965672f, 0.03497624f, 0.04520694f, 0.10443957f, -0.03341516f, 
    -0.00535271f, -0.07679266f, 0.00899932f, -0.01026066f, -0.35569829f, -0.26605415f, -0.16165669f, -0.09380765f, 
    0.16577744f, 0.06090004f, 0.07122552f, 0.06063795f, 0.00582569f, 0.13336994f, -0.12708117f, 0.10884243f, 
    0.07103562f, 0.17083561f, 0.15576357f, 0.14516793f, -0.17693989f, -0.04869056f, 0.03620197f, 0.12503678f, 
    0.08875823f, 0.05252363f, -0.05786648f, 0.05209897f, 0.10546132f, 0.10580074f, 0.14885527f, 0.10232722f, 
    0.03419990f, 0.01999985f, 0.16593398f, 0.03959579f, 0.00200280f, -0.08206079f, -0.04202357f, 0.13767089f, 
    -0.29765055f, -0.04970079f, 0.01106599f, 0.11579494f, -0.05380225f, 0.07506232f, 0.07367966f, -0.03960498f, 
    -0.05934050f, 0.05674256f, -0.00305449f, -0.03288150f, -0.04038017f, 0.15800139f, 0.41117957f, 0.18232119f, 
    0.03480664f, -0.21149382f, 0.02290937f, -0.01278647f, 0.12822710f, 0.10738613f, 0.04912723f, 0.04550688f, 
    0.33200815f, 0.03430389f, 0.09800943f, -0.16539358f, 0.03430579f, 0.05921863f, 0.13045201f, 0.08444493f, 
    0.09594709f, -0.08771401f, -0.10478833f, 0.16610549f, 0.19844975f, -0.26732090f, -0.18389305f, 0.07601493f, 
    0.10361316f, -0.00162582f, -0.04499174f, -0.01289323f, 0.01166616f, -0.02769785f, -0.03060457f, -0.00923850f, 
    -0.15163691f, 0.12112242f, 0.21187705f, 0.02101504f, 0.02748097f, 0.08654264f, -0.02006660f, 0.06197158f, 
    -0.10696629f, 0.04403898f, 0.08477714f, 0.11339559f, -0.28152376f, -0.06322458f, 0.25132671f, -0.12396872f, 
    -0.02099357f, 0.08853268f, 0.10569306f, 0.02899012f, 0.08708071f, 0.00299696f, -0.05721755f, 0.13181275f, 
    0.09648202f, -0.08527545f, -0.13494356f, 0.02797960f, -0.05911915f, -0.19129522f, -0.07602450f, -0.01389661f, 
    0.00291019f, 0.04142082f, -0.00201083f, 0.03437749f, 0.04795290f, 0.11004022f, -0.09155142f, -0.09768263f, 
    0.01178554f, 0.00689897f, -0.02436894f, 0.10727151f, 0.09637604f, 0.04441316f, 0.04045924f, 0.11959665f, 
    0.05204245f, -0.00489733f, 0.01060912f, 0.13973145f, 0.11381503f, -0.05705898f, 0.01174039f, 0.06474939f, 
    -0.09360091f, 0.07413788f, 0.09622382f, 0.13011506f, -0.04089366f, 0.13831696f, -0.21940832f, -0.15427302f, 
    0.14468615f, -0.08831343f, 0.00565661f, 0.05909201f, -0.07074382f, -0.03226382f, -0.05234552f, -0.06645954f, 
    -0.00816901f, 0.03627574f, -0.07343196f, -0.11311527f, -0.03774380f, -0.10086779f, 0.00746305f, -0.07999898f, 
    -0.04908442f, -0.11565547f, -0.02396745f, 0.10697853f, -0.32465655f, -0.19395672f, 0.23521967f, 0.05115484f, 
    0.08806626f, -0.08111177f, 0.12863238f, 0.05098393f, -0.00351483f, 0.03065019f, 0.06874088f, 0.11777940f, 
    -0.35902548f, 0.10746350f, -0.27259174f, 0.24876145f, 0.12541838f, 0.00237162f, -0.13686155f, -0.01307555f, 
    -0.04832353f, 0.11113594f, 0.03745194f, 0.05946416f, 0.27486023f, 0.23907602f, -0.04929189f, -0.02124288f, 
    0.12783423f, 0.05383429f, 0.00531396f, -0.08344604f, 0.03945024f, 0.12474721f, -0.09399725f, 0.10668540f, 
    -0.13964355f, 0.10382677f, -0.06556901f, -0.17365965f, -0.08353771f, 0.07157236f, -0.00700870f, -0.12315888f, 
    -0.05982308f, 0.03803996f, -0.00616869f, -0.04275372f, -0.06683362f, 0.04199894f, -0.21109521f, 0.06200410f, 
    -0.03353548f, 0.01088418f, -0.03991291f, -0.10577887f, 0.14581181f, 0.08711662f, 0.13453740f, 0.16614045f, 
    -0.06132646f, -0.09759448f, 0.08080271f, 0.01843446f, 0.12023100f, 0.07891362f, 0.02995856f, -0.05190658f, 
    -0.08831953f, 0.01008075f, 0.05619728f, 0.07574337f, 0.08248855f, -0.17045210f, 0.08493798f, -0.05712464f, 
    -0.05209899f, -0.10737495f, -0.11937042f, -0.01923501f, -0.14207466f, 0.03122006f, 0.02042491f, 0.01811221f, 
    0.04376478f, -0.03659489f, -0.00858410f, -0.01715537f, -0.00009692f, 0.03530613f, -0.03863544f, -0.06524969f, 
    -0.07921974f, 0.06522750f, 0.02996009f, -0.02758855f, 0.05622628f, -0.01002844f, 0.02664424f, 0.06042655f, 
    0.02748785f, -0.06569294f, 0.05411962f, -0.05769887f, -0.07045706f, -0.03306573f, -0.06357471f, -0.06833502f, 
    0.03515325f, -0.01161489f, -0.06206260f, -0.01170381f, 0.00579633f, 0.01036553f, -0.02962414f, 0.03508626f, 
    0.02385196f, 0.05399661f, 0.02130329f, -0.00101534f, 0.02881183f, -0.06669996f, -0.01861406f, 0.05891613f, 
    -0.04896061f, -0.06473033f, 0.03300888f, -0.03988522f, 0.00128269f, -0.01559199f, -0.03560007f, -0.05501212f, 
    -0.06867547f, 0.04628643f, 0.00705918f, -0.06956200f, -0.00947153f, -0.05304045f, -0.06298316f, 0.03817411f, 
    -0.01260936f, -0.00315758f, 0.04523053f, -0.04005069f, -0.05078246f, -0.04113368f, -0.05482841f, -0.06099964f, 
    -0.03809261f, 0.05427134f, -0.02476926f, -0.07170670f, -0.05751785f, 0.06515066f, -0.00708793f, 0.01418898f, 
    0.03691114f, -0.04747900f, -0.02271390f, -0.06402969f, 0.01567174f, -0.03995647f, 0.05653127f, -0.00555144f, 
    -0.04337174f, -0.05880743f, -0.05287694f, -0.01112955f, 0.04454357f, -0.02503354f, -0.00903672f, -0.01569522f, 
    0.04992644f, -0.06842551f, 0.00699224f, 0.06406645f, -0.03892582f, -0.05050845f, 0.04103196f, 0.03069780f, 
    0.04288427f, -0.06621959f, 0.00930538f, -0.03106166f, -0.01603061f, 0.03248819f, -0.02858112f, -0.00173257f, 
    -0.02964369f, 0.05112462f, -0.03150899f, 0.01760788f, -0.03982583f, 0.00129382f, 0.00855951f, -0.03207778f, 
    0.02534489f, -0.02208469f, 0.03100392f, 0.04176997f, 0.04893664f, -0.04997504f, -0.05766961f, -0.03048110f, 
    -0.01324744f, -0.06179106f, -0.04435327f, 0.04399838f, -0.04561616f, -0.06807993f, 0.03429005f, 0.03054923f, 
    -0.00799268f, 0.04578520f, 0.06341425f, -0.03001091f, 0.06779772f, -0.04294671f, 0.05557476f, -0.07091765f, 
    0.01756591f, 0.04018640f, 0.05558331f, -0.02131294f, -0.06174490f, -0.04942152f, -0.02051368f, -0.04591395f, 
    -0.01923863f, -0.00203313f, -0.04840325f, -0.03977657f, 0.01715295f, 0.05569638f, 0.01200761f, 0.05821137f, 
    0.00353302f, 0.00749076f, -0.01775032f, -0.00415342f, -0.05695506f, -0.03669047f, -0.02363475f, -0.00224767f, 
    0.00536477f, -0.01008220f, -0.03534358f, 0.02365259f, -0.06216124f, 0.01223329f, -0.02280026f, -0.05829798f, 
    -0.07050826f, 0.00329939f, 0.06303830f, -0.02124900f, -0.00853462f, 0.00677432f, -0.02330709f, -0.02747140f, 
    0.03551584f, -0.02460032f, 0.06792583f, -0.01277778f, 0.05602494f, -0.02330134f, 0.05196870f, 0.05834224f, 
    -0.06763074f, -0.03823143f, -0.03588273f, -0.02977213f, -0.00255848f, 0.01672598f, -0.03993306f, 0.00724183f, 
    0.11910424f, 0.06474363f, -0.18494834f, 0.06561118f, -0.05262822f, 0.29723576f, 0.04334714f, 0.11088283f, 
    0.07345658f, -0.06539216f, 0.00638351f, 0.13964756f, 0.05045315f, 0.16327415f, -0.13163029f, 0.17984702f, 
    0.18600613f, 0.04020705f, 0.05770662f, 0.09931163f, -0.14120267f, 0.01043699f, 0.05511593f, -0.17744023f, 
    0.19375248f, -0.12858139f, 0.19522697f, 0.02509180f, 0.02354647f, 0.14766204f, 0.02306434f, -0.06260997f, 
    -0.00806908f, 0.06047865f, 0.03879407f, 0.01183537f, -0.45857465f, 0.40538505f, 0.17511730f, 0.02905773f, 
    -0.13351554f, 0.06372788f, -0.01152079f, 0.06041589f, -0.01903837f, -0.09583865f, -0.09014775f, 0.01876710f, 
    -0.21764712f, -0.07636283f, 0.09320001f, 0.20269220f, -0.02883748f, -0.04454741f, 0.17074758f, 0.06590836f, 
    0.06712379f, 0.13819240f, 0.16302277f, 0.28251249f, 0.00887172f, -0.10057690f, -0.03939645f, -0.28266829f, 
    0.06149690f, -0.04703728f, 0.06452218f, 0.02654961f, 0.19047455f, -0.21174359f, 0.04068386f, -0.08056799f, 
    0.17474152f, -0.09062040f, 0.15106191f, -0.05931415f, 0.22672546f, -0.09562405f, 0.07132872f, 0.09453054f, 
    -0.04105960f, 0.09912665f, -0.03243593f, -0.02510605f, 0.04728675f, 0.20923637f, -0.19198097f, -0.10879572f, 
    0.02828087f, -0.03453616f, -0.06043208f, -0.08840790f, -0.06560764f, -0.05936999f, 0.02628637f, -0.11720438f, 
    0.01829315f, 0.14077257f, -0.01382986f, 0.07063146f, 0.05836980f, -0.17472178f, 0.00962142f, -0.24771130f, 
    -0.10971832f, 0.03495070f, 0.02590483f, 0.15198696f, -0.05199700f, 0.18843243f, 0.08823013f, 0.02003541f, 
    0.07697801f, 0.02932991f, 0.13839070f, -0.03249622f, 0.06325880f, -0.05561423f, 0.13311644f, 0.09708303f, 
    0.13509955f, 0.11560046f, 0.13145521f, -0.17697905f, 0.04833856f, -0.09335459f, 0.03250495f, 0.04453367f, 
    0.02678938f, 0.11532754f, 0.01309372f, -0.02809390f, -0.16459145f, 0.14020927f, 0.01251507f, -0.22336677f, 
    0.12149569f, 0.23518181f, 0.09027315f, 0.00117438f, -0.05748797f, -0.03182887f, 0.01647829f, 0.28479800f, 
    -0.01636595f, -0.06754504f, -0.00309781f, -0.13394202f, 0.15178606f, -0.02035836f, 0.01083204f, -0.19329092f, 
    0.07345600f, -0.05179032f, -0.18970217f, -0.13252555f, -0.00197895f, 0.27568471f, -0.06198884f, 0.01981317f, 
    0.00284908f, -0.00084385f, 0.16472363f, -0.18824892f, 0.08482880f, -0.08232469f, -0.06352895f, -0.04597558f, 
    -0.07649971f, -0.07658073f, -0.06285497f, 0.27734432f, -0.01033575f, -0.02636911f, -0.06143406f, -0.11477411f, 
    0.02061414f, 0.01992259f, 0.01737031f, -0.11424500f, 0.07218692f, -0.13642076f, -0.02587984f, -0.06951842f, 
    -0.07165897f, 0.05956977f, -0.18477426f, 0.00417295f, 0.07293305f, 0.05593351f, 0.02335204f, 0.07256028f, 
    -0.08200347f, 0.15575828f, 0.05079784f, -0.06197936f, -0.07897491f, -0.00462718f, 0.12255563f, 0.02441342f, 
    -0.02745027f, 0.05158821f, 0.00693536f, 0.08099440f, -0.09310535f, -0.11672642f, 0.07384598f, 0.05596353f, 
    0.01506106f, 0.10019126f, -0.02830954f, -0.06396470f, 0.04612104f, -0.04894287f, 0.06641090f, -0.05654481f, 
    0.01116884f, -0.08826751f, -0.06741939f, 0.03923912f, 0.06375811f, 0.05627191f, 0.08024754f, -0.04126776f, 
    -0.00573776f, 0.06994212f, -0.19006102f, -0.08666598f, -0.10374878f, 0.04127865f, 0.07357155f, 0.15221229f, 
    -0.08040506f, -0.06586604f, 0.10247550f, 0.11434884f, -0.00937755f, -0.14242290f, -0.01346714f, 0.00670864f, 
    0.14731376f, -0.17283292f, -0.05394226f, 0.16281852f, 0.08886332f, 0.08357400f, 0.08502415f, 0.05520912f, 
    0.07390110f, 0.04740345f, 0.03591384f, -0.05302217f, 0.15745240f, 0.10761997f, 0.14247634f, 0.04504127f, 
    -0.00873453f, -0.06230945f, -0.08567157f, 0.14890432f, 0.06417128f, -0.00678320f, 0.02690889f, -0.02712539f, 
    0.32703891f, 0.06519803f, 0.09971238f, -0.07275748f, 0.04731664f, 0.03915838f, -0.00542466f, 0.06232874f, 
    -0.04293379f, 0.05604203f, -0.05690359f, -0.06492253f, -0.03722014f, 0.06771165f, -0.12282480f, -0.23457642f, 
    0.08095902f, -0.05583673f, 0.04922803f, -0.05606634f, -0.07096621f, 0.09700485f, 0.07299896f, -0.09110533f, 
    -0.29640374f, 0.10173887f, 0.00535474f, -0.38380212f, 0.13015237f, -0.06654508f, -0.08623316f, -0.15310995f, 
    0.07915615f, 0.11699335f, -0.04747344f, 0.05474259f, -0.08915824f, -0.04232812f, 0.00116727f, 0.05055878f, 
    -0.01582040f, 0.00296664f, -0.09899133f, 0.11088636f, 0.05568287f, 0.05138128f, 0.02714585f, -0.09975592f, 
    0.65720522f, -0.17524141f, -0.01655067f, -0.28019786f, 0.00839837f, 0.07663158f, 0.08346862f, 0.06392204f, 
    -0.05197154f, 0.02780772f, 0.09482513f, 0.00616157f, 0.17182063f, 0.03981737f, 0.13311540f, 0.07267866f, 
    -0.04929607f, -0.04638263f, 0.06974013f, 0.05049279f, -0.08811324f, 0.10899824f, 0.05223972f, -0.00443044f, 
    -0.02362795f, 0.11371689f, 0.09614713f, 0.12725377f, 0.06949926f, 0.16469458f, 0.05982748f, -0.02653833f, 
    -0.05155321f, 0.14621334f, -0.03923870f, -0.04314558f, -0.46482375f, 0.15508981f, 0.05765026f, -0.25714192f, 
    0.00884016f, 0.12089453f, 0.04159013f, 0.04361603f, 0.12811834f, -0.02130100f, -0.07443694f, 0.05919390f, 
    0.30331805f, -0.25144431f, 0.09944350f, -0.05307825f, 0.09806331f, -0.00988248f, 0.01785332f, 0.01228016f, 
    -0.14262506f, -0.01215255f, 0.04011417f, -0.12577008f, -0.21898820f, 0.19246155f, -0.01307867f, -0.23268431f, 
    0.00454814f, 0.13324255f, -0.02690094f, -0.10301941f, -0.01592047f, 0.16930532f, 0.01939842f, 0.04075845f, 
    0.06147135f, 0.03819689f, -0.07418838f, -0.02598428f, -0.04254112f, -0.07148404f, 0.05130928f, 0.01916564f, 
    0.03037670f, -0.07387155f, -0.03426315f, -0.00510165f, 0.00077483f, -0.06070329f, -0.03333621f, -0.01642756f, 
    -0.02945889f, 0.06128557f, -0.00920215f, -0.02965652f, 0.04020158f, -0.03488356f, 0.04701602f, -0.00880316f, 
    -0.03516561f, 0.02724296f, 0.03998500f, 0.00922389f, -0.05668224f, -0.01708024f, -0.01123360f, 0.03189352f, 
    0.01502258f, 0.00527340f, 0.04619838f, -0.03443287f, 0.05430739f, -0.07689832f, -0.06583390f, -0.01980457f, 
    0.03190494f, -0.02623493f, 0.02673063f, 0.00600084f, -0.01579459f, 0.02326050f, -0.01545487f, -0.00013776f, 
    -0.01607785f, -0.04102891f, -0.02623777f, 0.03639465f, -0.02003717f, 0.04869204f, -0.06388816f, -0.03894866f, 
    -0.05322823f, 0.00988130f, -0.06577415f, -0.05597260f, -0.04678050f, -0.03535325f, -0.07759351f, 0.03502588f, 
    0.00584364f, -0.02730836f, -0.05669071f, 0.02245491f, 0.02051846f, 0.04733800f, -0.03758376f, -0.00800816f, 
    0.01292482f, 0.02619369f, -0.07601859f, -0.06037314f, -0.05241587f, 0.05866279f, 0.02484552f, -0.02879007f, 
    -0.07573216f, -0.07689073f, 0.02138124f, -0.07451701f, -0.07282045f, 0.05618856f, -0.01153408f, -0.01877888f, 
    -0.07479193f, -0.02354831f, -0.06622016f, 0.06149408f, -0.02354042f, -0.05064065f, -0.01866600f, 0.04683035f, 
    -0.00888947f, -0.04119946f, 0.04532389f, 0.06240855f, -0.05376277f, 0.05129814f, 0.05077486f, 0.04388274f, 
    0.02440192f, -0.07649636f, -0.00179540f, -0.02778463f, -0.02082436f, 0.03726915f, -0.06308389f, -0.01849010f, 
    -0.01774923f, -0.03392677f, -0.05237437f, 0.01470648f, 0.06598409f, -0.03745948f, 0.02782984f, -0.03985934f, 
    0.05713684f, -0.06948513f, 0.00043667f, -0.01890855f, -0.07084571f, -0.01489363f, 0.01192665f, -0.04032915f, 
    0.02429365f, -0.02815217f, 0.02885303f, 0.04197041f, -0.05696008f, -0.01708941f, -0.05353744f, 0.06578527f, 
    -0.05669490f, 0.06583558f, -0.00258689f, -0.01447882f, -0.03407708f, -0.03453417f, -0.03167567f, -0.03370427f, 
    -0.00841294f, 0.00843916f, -0.01030451f, -0.01658499f, -0.00378724f, -0.02855225f, 0.03749694f, 0.00125557f, 
    -0.01499612f, -0.05600441f, 0.00593777f, -0.03997514f, -0.06578001f, 0.05252962f, 0.03784651f, 0.06383825f, 
    0.04013481f, -0.00989816f, 0.06111258f, -0.03361958f, -0.07451837f, -0.06943111f, 0.05969555f, -0.06314230f, 
    -0.06623571f, 0.04186433f, 0.02643512f, 0.03795591f, 0.01169351f, 0.01464388f, -0.05696153f, 0.00865070f, 
    0.01776900f, 0.04112782f, -0.05492070f, -0.02914073f, 0.01366925f, -0.03323669f, 0.01700147f, -0.04259212f, 
    -0.00429569f, 0.06032248f, 0.02147765f, -0.02776088f, -0.07191634f, -0.01320910f, 0.01549834f, 0.04663007f, 
    -0.07651098f, 0.16308039f, 0.08152609f, 0.16750620f, -0.08362415f, 0.02456694f, 0.08262051f, -0.04295298f, 
    -0.01538849f, -0.02294411f, 0.06237855f, -0.00146618f, -0.19741563f, 0.00323806f, 0.03587330f, 0.00727083f, 
    -0.05959143f, 0.03096257f, -0.11484438f, 0.07155472f, 0.03180982f, 0.06697479f, 0.06132609f, -0.07327881f, 
    -0.07661148f, -0.18365730f, -0.15993248f, -0.25729349f, 0.01698763f, -0.01322182f, 0.01495760f, 0.12698968f, 
    -0.05009926f, -0.06070988f, 0.01239004f, 0.06555312f, 0.12283728f, 0.06406164f, -0.02005634f, -0.13443033f, 
    0.06572592f, -0.01122213f, -0.00896945f, -0.08418800f, 0.06227436f, -0.02932674f, 0.11835463f, -0.02635898f, 
    0.18761896f, 0.16086330f, 0.06497142f, -0.09846451f, 0.03100297f, 0.00911538f, -0.10222484f, 0.09572420f, 
    0.07538342f, -0.10579176f, 0.11878884f, -0.01964775f, 0.10804741f, -0.06657764f, 0.00723925f, 0.11251387f, 
    -0.03433304f, 0.11729597f, -0.09559906f, -0.13226841f, -0.04162904f, 0.01271204f, -0.00803955f, -0.11780901f, 
    -0.24244951f, -0.12412701f, -0.11343161f, -0.02865623f, 0.03820673f, -0.01904217f, 0.02647175f, -0.14643309f, 
    0.02729784f, -0.00046614f, -0.11616358f, -0.15008239f, 0.16567972f, 0.14186187f, 0.05970884f, -0.00689861f, 
    -0.12676555f, -0.01027325f, -0.01934818f, 0.00286792f, -0.03027324f, 0.02886478f, 0.10832103f, -0.07342540f, 
    0.30775514f, 0.31334397f, 0.15414186f, 0.29407758f, 0.04667813f, 0.09554042f, -0.01076653f, 0.07336367f, 
    -0.03935886f, 0.05047555f, 0.07581805f, -0.04822328f, -0.24098854f, 0.07280323f, -0.03690163f, -0.21299462f, 
    0.05876143f, -0.00083071f, -0.05781471f, 0.02403465f, 0.03086027f, -0.06764812f, -0.01370684f, 0.03657441f, 
    0.20564425f, -0.13868970f, -0.06170167f, 0.08096078f, -0.18392235f, 0.06401974f, 0.01530462f, -0.10407744f, 
    0.02652144f, -0.00353735f, 0.09158124f, 0.03179936f, 0.06019470f, -0.02580420f, 0.16830640f, -0.02343543f, 
    0.12358283f, 0.03379431f, -0.06431801f, -0.00019744f, 0.04526284f, 0.16186911f, 0.03846347f, 0.20070595f, 
    0.21000445f, 0.16523026f, 0.02255732f, 0.01912899f, 0.01907961f, -0.09743619f, 0.02583681f, 0.00758354f, 
    0.03542307f, -0.03213422f, -0.02791538f, -0.07827549f, 0.33857867f, 0.00457193f, 0.03273717f, 0.28076389f, 
    -0.08443540f, 0.11217307f, 0.06879679f, 0.01654363f, 0.09905159f, 0.01173378f, -0.09133043f, -0.04380674f, 
    -0.09335181f, 0.03197874f, -0.06568097f, -0.08956331f, -0.06172997f, 0.14901929f, 0.10273730f, 0.01038224f, 
    -0.10229670f, -0.03283763f, -0.00392625f, -0.06624646f, 0.01056479f, 0.12335797f, 0.31657436f, 0.04095588f, 
    0.02226410f, -0.10037490f, -0.02125569f, 0.02706957f, 0.10939500f, 0.05865408f, -0.07630338f, 0.01500178f, 
    0.14405897f, 0.09493426f, -0.00088827f, 0.09389815f, 0.08569761f, -0.00220377f, -0.04097483f, 0.03475767f, 
    0.15743089f, 0.09639936f, -0.00013304f, 0.09337632f, -0.08273697f, -0.12980935f, -0.06718728f, -0.09552345f, 
    0.12376507f, -0.08906110f, 0.10471907f, 0.00424462f, 0.05107111f, 0.11942656f, 0.02846977f, 0.10424817f, 
    -0.07864490f, -0.09357204f, 0.13495170f, 0.02643226f, 0.04613814f, 0.05773723f, 0.00510912f, -0.00659727f, 
    -0.08634818f, 0.02918223f, 0.10154057f, 0.02557101f, -0.26574284f, 0.11106089f, -0.05138240f, -0.05323527f, 
    -0.05886309f, 0.08401241f, -0.03622623f, 0.01495452f, 0.14055549f, 0.07569894f, -0.13123015f, 0.13136610f, 
    -0.23478468f, -0.10655328f, -0.08250492f, 0.20133331f, -0.07232521f, -0.17352180f, 0.00542735f, -0.06548917f, 
    0.09228046f, 0.09104063f, -0.00245936f, 0.13594228f, -0.19996211f, -0.08191982f, -0.04917288f, -0.10903662f, 
    0.13082735f, 0.02871731f, 0.09415290f, 0.08359974f, -0.00965266f, 0.04585586f, 0.01462174f, 0.00377146f, 
    0.09370080f, 0.02344924f, 0.20087090f, -0.04178123f, 0.10228281f, 0.04567400f, 0.09328586f, 0.05877688f, 
    0.02675583f, 0.13266775f, 0.04480263f, 0.16829701f, 0.02078947f, 0.23480214f, -0.00861244f, -0.05548910f, 
    0.08261144f, -0.02428765f, 0.01633910f, -0.00057089f, 0.11125699f, -0.01068585f, 0.09284515f, 0.14438894f, 
    -0.20216750f, 0.01008580f, 0.06048054f, -0.03909084f, 0.04703865f, 0.00406544f, 0.00926362f, 0.06700869f, 
    0.03808794f, -0.06327441f, -0.02504826f, 0.01350248f, 0.01309197f, -0.04096157f, -0.02739787f, -0.01506927f, 
    0.03918308f, -0.04498463f, -0.02920344f, 0.06461874f, 0.09325949f, 0.08589455f, 0.13739431f, 0.10681262f, 
    -0.60335714f, 0.27246115f, 0.04451747f, -0.03203577f, 0.18963642f, 0.00169192f, -0.08951574f, 0.07664730f, 
    -0.05936521f, -0.09934951f, -0.04663763f, 0.06573203f, -0.31389651f, 0.03102545f, -0.15721497f, -0.01141719f, 
    -0.08589278f, 0.06996108f, 0.02896160f, -0.03448995f, -0.04370806f, -0.09182243f, 0.06206910f, -0.00316030f, 
    -0.07896841f, -0.11722225f, -0.00683161f, 0.02898956f, -0.01184608f, 0.14120068f, -0.09217504f, 0.10785141f, 
    0.02063109f, -0.03264749f, 0.15072353f, 0.12323900f, 0.01443029f, 0.09154308f, -0.07011541f, 0.01551290f, 
    0.09000322f, -0.01248362f, -0.04562713f, -0.02263379f, 0.01449454f, 0.07130865f, 0.11602397f, 0.00918946f, 
    -0.22327808f, 0.02567941f, 0.06108819f, 0.21920836f, 0.10645800f, -0.05919402f, -0.08376694f, 0.02764781f, 
    -0.01238542f, 0.11269706f, -0.02166584f, 0.10590646f, -0.17968567f, -0.17650861f, 0.12781738f, 0.02693790f, 
    -0.03961478f, 0.09319447f, -0.05828472f, -0.09507069f, -0.03047034f, -0.09905469f, 0.08735009f, 0.03367113f, 
    -0.25087273f, -0.10117605f, -0.15723202f, 0.13414763f, -0.06723507f, 0.02040960f, 0.01304472f, 0.11537994f, 
    0.10200607f, 0.06332090f, 0.04572206f, 0.06705029f, -0.00855944f, 0.05985136f, 0.02873979f, 0.11165883f, 
    0.12235033f, 0.14706738f, 0.08021086f, 0.03383409f, 0.03824269f, 0.06004094f, 0.03189194f, -0.01254233f, 
    0.14014134f, -0.13741329f, 0.16284671f, 0.23914367f, 0.07974527f, 0.02803889f, -0.00382398f, -0.03561049f, 
    -0.04482104f, -0.05995635f, -0.02681245f, -0.02142533f, -0.04928979f, -0.02348383f, -0.02235089f, 0.17355460f, 
    -0.07128216f, -0.03211173f, -0.03870085f, 0.15407005f, -0.01338619f, -0.03039973f, 0.03847019f, 0.02029395f, 
    -0.02531654f, 0.07585789f, 0.06502555f, 0.23398754f, 0.15776022f, -0.02921349f, 0.04941372f, -0.02480223f, 
    0.17361681f, 0.10317193f, 0.06611636f, 0.13025233f, 0.00875657f, 0.04662530f, -0.04803925f, -0.01166998f, 
    0.00263433f, 0.04071311f, -0.08501317f, 0.01602281f, -0.07150827f, -0.09903131f, 0.00480431f, -0.11112852f, 
    0.19710591f, 0.04378229f, 0.25381690f, 0.04966961f, 0.12912169f, 0.08013605f, -0.06095557f, 0.08139344f, 
    -0.02326554f, 0.12154052f, 0.02227357f, -0.01378141f, -0.09202217f, 0.12404134f, 0.01878431f, -0.13406228f, 
    -0.11943116f, -0.03591400f, 0.10547715f, -0.02753848f, 0.03129006f, 0.02522810f, -0.04905127f, 0.03547466f, 
    -0.10742661f, 0.07337270f, 0.07366490f, -0.23505706f, 0.01405908f, 0.04318207f, -0.04486110f, -0.02022173f, 
    0.03061180f, 0.08079397f, 0.04722811f, 0.17723055f, 0.34288794f, 0.18345843f, -0.10433584f, -0.02488998f, 
    0.09686835f, 0.09296685f, -0.02260259f, -0.01043347f, -0.18706934f, -0.05672438f, -0.04480977f, -0.09618396f, 
    0.21486874f, 0.27056658f, 0.13025415f, -0.21341294f, 0.01102893f, 0.09263478f, 0.01131193f, 0.13894288f, 
    -0.07672789f, 0.00108358f, -0.05552374f, -0.02598236f, -0.32168525f, 0.16200115f, -0.01392815f, -0.04167847f, 
    -0.03662706f, 0.01051311f, 0.13575783f, 0.08605926f, -0.07504138f, 0.06453796f, 0.10141689f, 0.07736826f, 
    -0.18488215f, -0.10281322f, 0.03237427f, 0.08584962f, 0.05408378f, 0.02098629f, 0.00639819f, 0.01367545f, 
    0.15199876f, -0.03129643f, -0.01899143f, -0.01378819f, -0.17820628f, 0.21718356f, 0.11929777f, -0.33308819f, 
    0.01555294f, 0.04368870f, 0.23355931f, 0.01281835f, -0.08779860f, -0.12584756f, -0.03928598f, -0.02588623f, 
    -0.23809372f, -0.08611381f, 0.06414870f, 0.01639511f, -0.07541399f, -0.12441726f, -0.08120225f, -0.03376775f, 
    -0.13312531f, -0.00757072f, -0.04188557f, -0.04416384f, -0.21221341f, 0.16932349f, -0.16497351f, 0.10411280f, 
    -0.04105639f, 0.15794611f, -0.02439124f, -0.07818591f, 0.02224484f, -0.00412016f, 0.03860718f, 0.02027889f, 
    -0.05539893f, -0.03476124f, -0.00049746f, 0.00789686f, -0.06452306f, -0.02909666f, -0.03943683f, -0.04174574f, 
    -0.03769603f, 0.03071395f, -0.02141420f, 0.00181960f, -0.05113418f, -0.05728847f, 0.04177338f, -0.04779653f, 
    -0.03173944f, 0.05672695f, 0.00136995f, 0.01528963f, 0.02363456f, -0.04791354f, -0.05719890f, -0.05862332f, 
    0.03296471f, 0.05010730f, -0.05665122f, -0.03370830f, 0.01931381f, 0.00392269f, 0.04174370f, -0.05594492f, 
    0.03930494f, 0.00351872f, -0.07561763f, 0.05786830f, 0.05472877f, -0.02703241f, -0.00580812f, 0.01637230f, 
    -0.03309126f, 0.02832619f, 0.02429467f, -0.05680789f, 0.02582580f, 0.01512029f, -0.03918308f, -0.06266560f, 
    -0.02592365f, -0.04409680f, -0.02283306f, -0.04370831f, -0.04616298f, 0.06123487f, -0.04444643f, -0.01480252f, 
    -0.08088977f, 0.04695218f, 0.01074536f, 0.00072317f, 0.04883813f, 0.04982291f, -0.01644632f, 0.05364241f, 
    0.04528288f, 0.02794620f, 0.05394317f, 0.00973117f, -0.03710533f, 0.00848719f, 0.02925958f, 0.05429038f, 
    -0.06510774f, -0.02969540f, 0.05896067f, 0.06240636f, -0.02268901f, 0.01951062f, -0.04862582f, -0.03158437f, 
    0.01041751f, -0.01077385f, 0.02599776f, -0.00311584f, 0.05142186f, -0.06868809f, -0.07692968f, 0.04160031f, 
    -0.06327992f, 0.01397448f, -0.07293331f, -0.01248114f, 0.02508040f, 0.02831712f, 0.03102873f, -0.02923985f, 
    -0.02401053f, 0.01722061f, -0.05887336f, -0.04063518f, -0.05961498f, -0.03238849f, -0.00022163f, 0.04047691f, 
    -0.03452870f, 0.05888428f, 0.05267986f, -0.04149116f, -0.05121034f, -0.02395628f, -0.07308303f, -0.07165904f, 
    -0.02887583f, -0.08518733f, 0.00460421f, -0.02414894f, -0.02453586f, -0.05244491f, -0.00385118f, 0.04820990f, 
    0.03476090f, 0.00344252f, -0.01621274f, -0.04997850f, 0.05263804f, -0.05006948f, 0.03354608f, 0.01202867f, 
    0.01353125f, -0.01956322f, 0.01066306f, -0.00201064f, 0.03086502f, -0.00752447f, 0.02061612f, 0.05804939f, 
    -0.05316854f, 0.05005923f, -0.07710282f, -0.04492863f, -0.06299578f, 0.03273189f, -0.02714999f, -0.03678194f, 
    -0.00401271f, -0.05078545f, -0.04171696f, -0.01559318f, -0.06673016f, 0.02444778f, 0.02174671f, -0.04165791f, 
    -0.00370040f, -0.00236192f, 0.02449979f, 0.05602459f, -0.01059834f, 0.00492716f, 0.03836057f, -0.05439811f, 
    -0.03220352f, 0.01111369f, 0.02225509f, 0.00223213f, 0.05796521f, -0.04628576f, -0.00081036f, -0.03786879f, 
    -0.00186141f, 0.05613410f, -0.01266585f, 0.03496642f, -0.00222760f, -0.01925182f, 0.03805711f, -0.03965190f, 
    -0.01511246f, -0.01813169f, 0.04013870f, 0.03361170f, -0.04449276f, 0.02862726f, -0.05828900f, 0.00501499f, 
    0.02823216f, -0.00701671f, -0.05470482f, -0.06165140f, 0.02628568f, -0.04238517f, 0.00832076f, -0.02733744f, 
    0.10752574f, 0.26884678f, -0.08595404f, -0.17645714f, -0.16452095f, 0.04543130f, -0.07843706f, 0.02853317f, 
    -0.01666641f, 0.07984669f, 0.04962599f, 0.06978216f, -0.00314326f, -0.00544177f, 0.12549882f, -0.03539633f, 
    0.09516492f, 0.07512888f, -0.12216122f, -0.04450567f, 0.00079879f, 0.08534335f, -0.05341922f, 0.04970797f, 
    0.20047064f, -0.07587114f, -0.13841669f, -0.00974846f, 0.16050859f, -0.10530397f, 0.11961184f, 0.09043027f, 
    0.07715695f, 0.11727304f, 0.07420621f, 0.05942439f, 0.17901547f, 0.05827469f, 0.14835411f, 0.19055550f, 
    0.08843146f, 0.13336572f, 0.03974923f, 0.10023721f, -0.09541167f, 0.03763232f, 0.05265060f, 0.05652654f, 
    0.36744872f, -0.23208618f, -0.08676716f, 0.13877583f, 0.08607429f, 0.18078414f, 0.07248711f, 0.06957667f, 
    -0.00040243f, 0.03894358f, 0.03289676f, -0.06316034f, 0.17829303f, 0.19351417f, 0.11352905f, 0.10492027f, 
    0.09187860f, -0.10306551f, 0.02271816f, 0.07564048f, 0.02034323f, 0.00651215f, 0.07177173f, -0.05644051f, 
    0.03556076f, -0.07637669f, 0.09619869f, -0.06775799f, 0.10901835f, -0.06574941f, 0.02257480f, 0.05018926f, 
    -0.01332847f, -0.04558394f, -0.02770264f, -0.07799894f, 0.06398235f, 0.08308399f, -0.20261008f, -0.25796312f, 
    0.10273342f, -0.08969371f, -0.00938475f, -0.10992949f, -0.04107304f, 0.15371799f, 0.14081219f, 0.10128923f, 
    -0.36603025f, -0.00078663f, -0.19764325f, -0.25115550f, 0.14892147f, -0.01663066f, -0.02916429f, -0.21399474f, 
    0.05665654f, -0.00175491f, 0.01318782f, -0.07805846f, -0.07158159f, 0.19587685f, -0.06545871f, 0.14793719f, 
    -0.01879449f, -0.01289919f, -0.04891004f, 0.14032717f, 0.07618159f, 0.00209898f, 0.12784949f, -0.01603260f, 
    0.27107039f, -0.01500922f, 0.07195342f, -0.22172372f, 0.09028678f, 0.03767211f, 0.11397596f, 0.00420977f, 
    -0.10543054f, -0.10910049f, 0.01862130f, 0.00676443f, -0.23418245f, 0.01348619f, -0.04151470f, 0.07279334f, 
    0.04747566f, -0.06435697f, -0.07014815f, -0.08796553f, 0.10389378f, 0.03532800f, 0.14602843f, -0.00744301f, 
    0.13657115f, -0.19420598f, -0.03501686f, 0.06863187f, -0.01823696f, 0.04012302f, -0.00268428f, 0.00231483f, 
    -0.07066584f, 0.05408228f, -0.00575930f, -0.04146066f, -0.36857742f, 0.09717412f, -0.02385068f, -0.27418956f, 
    -0.03129229f, 0.03062354f, 0.12829202f, -0.02851892f, -0.02203769f, 0.01942211f, -0.03213529f, 0.11862043f, 
    0.38301331f, -0.01462757f, -0.05673715f, 0.01768613f, 0.10992992f, 0.07030956f, -0.03795639f, 0.03311170f, 
    -0.05038156f, 0.00387312f, 0.00069560f, 0.05335784f, -0.06641863f, 0.07400581f, -0.07936473f, -0.25146228f, 
    0.05419384f, 0.13605146f, -0.00627130f, -0.15352744f, -0.05814643f, 0.15201187f, -0.03196752f, 0.09271945f, 
    0.19507323f, 0.00944322f, 0.13904017f, -0.08290668f, 0.03360379f, -0.13357139f, 0.00342955f, -0.12075906f, 
    0.00507478f, -0.09970549f, -0.10279611f, -0.11926015f, 0.16345944f, 0.00980969f, 0.00033034f, 0.05118904f, 
    0.26777115f, -0.10676979f, 0.05742520f, -0.03683931f, -0.02956954f, -0.02186912f, -0.09071334f, 0.05079741f, 
    -0.04438597f, 0.19871837f, -0.00898602f, 0.07190858f, -0.03984473f, -0.20112196f, -0.05104606f, 0.12607493f, 
    -0.12427465f, 0.00532094f, 0.10942570f, 0.12892604f, 0.12926041f, -0.04418931f, 0.11629318f, -0.10580972f, 
    0.02579400f, 0.14437358f, 0.00776424f, 0.09331132f, -0.01319097f, 0.08331200f, 0.06965073f, -0.00100823f, 
    0.31338537f, 0.17403187f, 0.09246445f, -0.05869405f, 0.02078209f, -0.07883143f, -0.10229705f, 0.00983683f, 
    -0.00194621f, -0.07062215f, -0.18097006f, -0.13269034f, -0.01544640f, -0.03460754f, -0.11033230f, 0.03652186f, 
    -0.01708229f, 0.09938576f, 0.14530668f, -0.01373182f, 0.08520808f, 0.14268123f, -0.10012297f, 0.10786308f, 
    0.06358984f, 0.02382826f, -0.11265331f, -0.02788203f, 0.06130707f, -0.13871257f, -0.02921190f, -0.01750457f, 
    -0.06057003f, 0.00188505f, 0.07847441f, 0.15389293f, -0.10550828f, 0.13672476f, -0.08071662f, 0.13315734f, 
    0.08701996f, -0.04723028f, 0.03526041f, 0.04896412f, 0.05824890f, -0.00191816f, 0.04131871f, 0.01473843f, 
    0.03366990f, 0.03386744f, 0.07795633f, 0.18145196f, -0.17450069f, 0.05398868f, 0.02218759f, 0.08649520f, 
    0.01750272f, -0.14898857f, -0.02756211f, -0.03383803f, -0.37680349f, 0.10516012f, 0.07692984f, -0.02924938f, 
    0.07960591f, -0.06737045f, 0.11328796f, 0.09734311f, 0.02906451f, 0.02272007f, 0.07550514f, -0.02343992f, 
    -0.34431705f, 0.01400854f, -0.12320690f, 0.27984765f, -0.16586372f, -0.00270443f, 0.02972561f, -0.04543604f, 
    -0.04564964f, 0.04248743f, -0.08251756f, -0.00780134f, 0.15230651f, 0.22146417f, 0.00369898f, -0.10584775f, 
    0.10699468f, -0.04259348f, -0.03343147f, -0.16439719f, 0.04899596f, -0.06270196f, -0.11513847f, -0.01517949f, 
    -0.04310477f, -0.00562816f, -0.06081452f, -0.20039374f, -0.01655826f, 0.03334774f, 0.02178266f, 0.02919883f, 
    -0.07884976f, 0.09003664f, 0.04483088f, 0.06990007f, 0.22211285f, 0.06830438f, -0.02657895f, 0.13575459f, 
    0.03684650f, -0.03868437f, -0.08452430f, 0.03246896f, -0.00395575f, 0.11488912f, 0.11375341f, 0.04027553f, 
    -0.16505815f, -0.01980515f, -0.05972135f, -0.02928979f, 0.05825747f, 0.10290016f, 0.07204045f, -0.01597458f, 
    0.04237504f, 0.09424745f, -0.14524683f, 0.12117571f, 0.14648636f, -0.20688047f, 0.11240639f, 0.05597186f, 
    0.05356057f, -0.10308411f, 0.01456302f, 0.03004140f, -0.05096041f, -0.05116675f, 0.04660251f, 0.00337678f, 
    0.09497381f, 0.31414580f, 0.04694801f, 0.04931528f, 0.06780129f, -0.07071667f, 0.02373332f, -0.06253564f, 
    -0.04904137f, -0.05899804f, 0.02325239f, -0.10413814f, -0.23689824f, -0.01961881f, 0.21398216f, 0.04486600f, 
    0.09335174f, -0.03548236f, -0.05477817f, 0.01495660f, -0.02169040f, -0.08519260f, 0.00464328f, 0.16327038f, 
    -0.05456547f, -0.17660430f, -0.30611646f, -0.24631229f, 0.05254260f, -0.05335219f, 0.12726535f, 0.07139631f, 
    0.02356450f, 0.09340171f, -0.07327541f, 0.01748163f, 0.11835335f, 0.03541844f, -0.09277721f, -0.12842609f, 
    0.03900843f, 0.09189764f, -0.00153949f, -0.04039066f, -0.06689376f, 0.02397494f, 0.02603333f, -0.07649732f, 
    0.07748833f, 0.09870965f, -0.04964280f, -0.04983922f, 0.10879339f, 0.11077406f, -0.12710971f, 0.09136476f, 
    0.02098103f, -0.11626518f, 0.01964344f, -0.03300307f, 0.02257561f, 0.11793753f, 0.09470686f, 0.14396799f, 
    -0.08501047f, -0.03416147f, 0.12378263f, -0.05674040f, -0.10030390f, 0.08703387f, -0.05227239f, -0.11089502f, 
    -0.04463119f, -0.12409031f, -0.19506384f, -0.12175538f, 0.00816114f, 0.03327732f, -0.06478338f, -0.06717431f, 
    0.00088948f, -0.12987952f, 0.03155755f, -0.01742506f, -0.00217361f, 0.10535154f, 0.15664236f, 0.14206852f, 
    0.00926772f, 0.09859131f, 0.07229277f, -0.16262423f, 0.06463730f, -0.03756791f, -0.02677109f, 0.01531030f, 
    0.00463234f, 0.06131256f, 0.20836584f, 0.15528783f, 0.00877058f, 0.05101709f, 0.05486260f, 0.01977487f, 
    0.01585556f, 0.05810105f, -0.04631112f, -0.06644668f, -0.34382328f, 0.01036357f, -0.01299112f, -0.04265063f, 
    0.05053297f, -0.13535771f, -0.00408694f, 0.08140025f, 0.03657344f, 0.03300634f, -0.05937942f, -0.00955583f, 
    0.28814539f, -0.16330443f, -0.00490191f, 0.02479775f, -0.16798492f, -0.06349498f, 0.09234749f, 0.11740465f, 
    0.11320646f, -0.04550755f, 0.02785735f, -0.00316795f, 0.05805388f, 0.03568932f, 0.13513328f, 0.12582026f, 
    -0.06441624f, -0.06699640f, -0.15751334f, 0.03099666f, -0.06505545f, 0.09426281f, 0.07190762f, -0.03851451f, 
    0.29155338f, 0.11809348f, 0.00408268f, 0.07686865f, 0.04208901f, 0.05764075f, 0.06850743f, -0.00460316f, 
    -0.09037758f, 0.04962464f, 0.08076257f, 0.12006532f, 0.24906847f, 0.09358893f, 0.20076090f, 0.09648830f, 
    0.01850708f, 0.07242166f, -0.05235868f, 0.01622973f, 0.05724870f, 0.08572701f, 0.03283080f, 0.00830935f, 
    0.31777799f, -0.09610770f, -0.09655388f, -0.21413139f, 0.05139617f, 0.05638779f, 0.15177234f, 0.02854813f, 
    -0.04237882f, 0.05662671f, -0.13232040f, 0.02328874f, -0.08587015f, 0.07911939f, 0.17543016f, -0.05666097f, 
    -0.03635193f, 0.07574272f, -0.01357833f, -0.00114675f, 0.01142331f, -0.01747627f, 0.06713115f, 0.03323494f, 
    -0.04518683f, 0.03607667f, -0.30666628f, 0.33578143f, -0.00526766f, -0.21225546f, 0.09561640f, 0.05090028f, 
    -0.06144660f, 0.05069290f, -0.01643855f, -0.17769270f, -0.20934437f, 0.04551237f, -0.00664943f, 0.07795732f, 
    0.14068174f, 0.01934873f, 0.06505185f, 0.08525304f, 0.02534882f, 0.05308776f, 0.01441611f, 0.03079287f, 
    0.01273928f, 0.07380783f, -0.07351954f, 0.12082799f, 0.05067653f, -0.01571624f, 0.06087964f, 0.08855366f, 
    -0.13246024f, -0.03680509f, -0.07928649f, -0.12033111f, -0.06278496f, -0.03495119f, -0.18050680f, -0.02730710f, 
    0.04300227f, -0.01495851f, -0.09792833f, 0.04839542f, -0.04995369f, 0.04640398f, 0.02227909f, 0.06051526f, 
    -0.26329643f, 0.16697574f, 0.13614331f, 0.13098860f, 0.16669033f, -0.08096413f, 0.03419873f, -0.03614547f, 
    0.18608339f, -0.05196248f, -0.09629788f, 0.09235953f, -0.17425354f, 0.02488732f, -0.08168455f, -0.11347961f, 
    0.00192620f, 0.05558225f, 0.01304270f, -0.14877529f, 0.11311170f, 0.08925780f, -0.00546834f, -0.03784115f, 
    0.19573858f, 0.00901206f, -0.03373736f, -0.05209840f, 0.02715094f, 0.09460476f, 0.05297114f, -0.11570796f, 
    -0.01691622f, 0.10936292f, 0.13006464f, -0.04112060f, 0.03613430f, 0.07013765f, -0.01458200f, 0.07168872f, 
    -0.13115159f, 0.02247805f, 0.10255153f, 0.02262156f, -0.01694429f, -0.03437467f, -0.03691572f, 0.07047538f, 
    -0.04614240f, 0.06727684f, 0.12942268f, -0.02209413f, -0.19510505f, 0.00484339f, -0.01455066f, -0.00339417f, 
    0.00935531f, 0.01860278f, 0.02538198f, 0.08325873f, 0.06430651f, 0.00800669f, -0.02466710f, 0.03477473f, 
    0.02872139f, -0.04524924f, -0.06732121f, -0.00797818f, 0.06182947f, 0.01584975f, 0.03528545f, 0.01270227f, 
    0.51052874f, 0.03378164f, 0.13772440f, 0.01209593f, -0.05119519f, -0.01748591f, 0.15747561f, 0.00395629f, 
    0.02331213f, -0.09005439f, 0.03491837f, -0.11683997f, -0.02798891f, 0.14792205f, -0.03607247f, -0.18531597f, 
    -0.00579388f, 0.14310212f, -0.07990613f, -0.14453684f, 0.02466566f, 0.01423008f, 0.04842820f, 0.12902217f, 
    0.08693219f, 0.08660500f, 0.10897528f, 0.04427113f, -0.04887838f, -0.04701942f, 0.08246252f, 0.09087976f, 
    0.02362024f, -0.01153151f, 0.01270500f, 0.05661041f, 0.17225634f, 0.13822871f, 0.25146475f, -0.08244623f, 
    -0.15208040f, 0.04027234f, -0.00714558f, 0.02063205f, -0.14288461f, -0.04855926f, -0.01045549f, 0.01336036f, 
    -0.21483894f, 0.05091514f, -0.10379585f, -0.10820407f, 0.07601628f, 0.06873717f, -0.03563391f, 0.03949118f, 
    -0.06968995f, 0.07229652f, -0.01410798f, 0.09542800f, -0.00418958f, 0.24118957f, -0.16285183f, 0.08717826f, 
    -0.07995783f, 0.17106326f, 0.03901056f, 0.02754442f, -0.10024571f, -0.16429040f, -0.10411683f, 0.02863279f, 
    0.01002265f, -0.02735663f, -0.04306391f, 0.03135364f, 0.02951458f, 0.00186780f, -0.07381203f, -0.01671060f, 
    -0.04728977f, -0.10196697f, 0.02293611f, 0.06060459f, -0.01456166f, -0.09043998f, 0.00980902f, -0.07725372f, 
    -0.03509182f, -0.03811680f, -0.05857760f, -0.06458670f, -0.04086966f, -0.05214524f, 0.04967922f, 0.03666075f, 
    0.01091288f, -0.09423950f, -0.09977815f, -0.06894063f, -0.03170837f, -0.09749835f, -0.04512467f, 0.02866324f, 
    -0.02037692f, -0.06591560f, -0.00061132f, -0.03565609f, 0.01186899f, 0.00565468f, -0.07520968f, -0.06099464f, 
    -0.00537074f, -0.05008676f, 0.05304945f, -0.03329467f, -0.00131324f, 0.07012656f, -0.00721855f, 0.06757022f, 
    0.09470032f, -0.07141307f, -0.02908069f, -0.08150303f, -0.03810301f, -0.11598235f, -0.00638319f, -0.07220456f, 
    0.02047215f, -0.05488965f, 0.00571557f, -0.06988060f, 0.00637014f, 0.09232084f, 0.03786987f, -0.01795590f, 
    0.03239523f, -0.07017706f, -0.04951173f, -0.03950927f, -0.02197004f, 0.07008348f, -0.04803041f, 0.06524792f, 
    0.03560778f, -0.04962768f, -0.00907205f, -0.05911229f, 0.03078131f, -0.06149314f, 0.04428449f, -0.02295173f, 
    -0.03520080f, -0.08549849f, 0.04983012f, -0.09110431f, 0.06039579f, -0.05684211f, 0.02270319f, -0.07147159f, 
    0.03697330f, -0.02006586f, -0.07800921f, 0.00160869f, -0.01354692f, -0.04654393f, -0.00530544f, -0.07694580f, 
    -0.00118587f, -0.00296318f, -0.06416899f, 0.04336041f, -0.01769397f, -0.02429973f, 0.01034421f, 0.01074913f, 
    -0.03690556f, -0.03586761f, 0.04748737f, -0.02069122f, -0.07790575f, -0.08059613f, -0.03194836f, -0.00561384f, 
    0.01399474f, -0.08163605f, -0.02512377f, 0.01393672f, -0.10769811f, -0.05207145f, -0.08806461f, 0.02533779f, 
    -0.01685566f, -0.03117978f, -0.02880823f, -0.09260811f, -0.02496230f, -0.05852488f, 0.03243678f, -0.03224386f, 
    -0.07649386f, -0.05933230f, -0.02653380f, -0.11680043f, -0.06684739f, -0.06025263f, 0.02572101f, 0.04358724f, 
    0.04397886f, 0.01033229f, -0.04660115f, -0.07780416f, 0.01122639f, 0.02602039f, 0.06199849f, -0.08388948f, 
    -0.04540012f, 0.00657591f, -0.05452987f, -0.07293639f, 0.03326159f, -0.03994652f, 0.01241400f, 0.05113240f, 
    0.00602027f, -0.04040071f, 0.05770758f, -0.04047398f, -0.05695359f, 0.03441957f, 0.01533350f, 0.00058057f, 
    0.04476586f, 0.06660850f, 0.06384282f, -0.02896508f, -0.06842918f, 0.03557809f, -0.03877112f, -0.00508379f, 
    0.01827135f, -0.09659843f, 0.00843555f, 0.01876211f, 0.00930024f, 0.03812687f, 0.01128384f, 0.01062944f, 
    0.00341712f, 0.04748714f, -0.02899627f, -0.03637043f, -0.02788852f, 0.01642205f, -0.03312506f, -0.05249353f, 
    -0.07427036f, -0.04036746f, 0.06608386f, 0.06573494f, -0.02263997f, -0.10503677f, 0.02608982f, -0.07268926f, 
    0.03600539f, 0.21705268f, 0.14803812f, 0.09030544f, 0.04438240f, -0.14262581f, 0.08956674f, 0.05659015f, 
    0.07518643f, -0.12105463f, 0.11802180f, 0.07032184f, -0.07532808f, -0.09169873f, -0.03400884f, 0.13217559f, 
    0.15569578f, -0.03104374f, -0.16340339f, 0.02939125f, -0.07639145f, 0.15352827f, 0.03692500f, 0.14943990f, 
    0.11384817f, -0.13379908f, -0.08632229f, -0.00569470f, 0.05650661f, -0.04471649f, 0.10421143f, 0.07454186f, 
    0.01730496f, 0.03081794f, 0.09730287f, 0.08563038f, 0.27981672f, -0.07754915f, -0.01600319f, 0.02960572f, 
    0.16074705f, -0.04129347f, -0.01686000f, 0.05952499f, -0.04382675f, -0.01173965f, 0.04416196f, -0.04038934f, 
    0.16166000f, 0.06676695f, -0.08779845f, 0.09075563f, -0.00237971f, 0.08857618f, -0.01530037f, 0.10531788f, 
    0.01944748f, -0.10887595f, 0.06913813f, 0.09773782f, -0.20257188f, 0.04120311f, 0.05719079f, 0.10523179f, 
    0.02076251f, 0.01178157f, -0.07361309f, 0.05796611f, -0.11516023f, 0.04475391f, -0.10363887f, -0.11973269f, 
    0.00576393f, -0.07871455f, -0.08066033f, -0.06007026f, 0.03694571f, 0.00192209f, -0.13637240f, -0.04678617f, 
    0.07087836f, -0.00866529f, 0.16086534f, 0.00435462f, 0.00908972f, 0.26372629f, 0.16475467f, -0.04697815f, 
    0.03149183f, 0.00731454f, 0.01872879f, 0.05652861f, -0.08535900f, -0.07164231f, 0.10897627f, -0.00367991f, 
    0.12617305f, 0.18221785f, 0.23870909f, -0.18635304f, -0.02766765f, 0.11829324f, -0.00017025f, 0.04476897f, 
    -0.00386964f, -0.05514397f, -0.02940982f, -0.02364731f, -0.29240644f, -0.10759381f, -0.01028666f, -0.07242276f, 
    -0.03410681f, -0.02363855f, -0.07020333f, 0.11824458f, 0.07082510f, 0.16446635f, -0.06174793f, 0.08682141f, 
    -0.25841939f, 0.08680031f, -0.16542003f, 0.02723720f, -0.16833058f, -0.05662971f, 0.00092366f, 0.01105310f, 
    -0.03612179f, -0.03623636f, 0.01239538f, -0.02138013f, -0.24836570f, -0.13349234f, -0.02436176f, -0.03662226f, 
    0.09759872f, 0.08006246f, -0.04267880f, -0.05262109f, 0.07820142f, 0.10286438f, 0.07612356f, -0.03917120f, 
    0.17605586f, 0.17335272f, 0.14208539f, 0.05763279f, -0.13971195f, 0.01425856f, -0.02804472f, 0.09306055f, 
    0.00671645f, 0.01934934f, -0.01748291f, -0.02039593f, 0.20624880f, 0.06602192f, 0.21968307f, -0.17208858f, 
    0.01052564f, -0.02647130f, 0.00882685f, -0.01317557f, -0.06594919f, -0.04061686f, -0.12150470f, 0.03487497f, 
    0.07168123f, -0.06253260f, 0.03128072f, -0.16363485f, -0.03638427f, 0.09063222f, 0.03022366f, 0.07144712f, 
    -0.05360456f, -0.03476107f, -0.17312901f, 0.01020346f, 0.11659972f, 0.22047390f, 0.20548204f, -0.11312157f, 
    -0.01795319f, 0.03958112f, -0.02490825f, 0.02154976f, -0.05914268f, -0.07081871f, -0.03991383f, 0.05516843f, 
    -0.27458876f, 0.03315612f, 0.08490057f, 0.16359493f, -0.18550226f, 0.09413622f, 0.04550613f, 0.03428303f, 
    0.00842781f, 0.03137236f, -0.03081796f, 0.13237701f, -0.11627975f, -0.10185558f, 0.07135085f, 0.11999948f, 
    -0.06399048f, 0.13439611f, -0.06516340f, 0.13740309f, 0.00677059f, -0.01350756f, 0.06931213f, -0.13675728f, 
    -0.12607059f, -0.01122791f, -0.07182645f, -0.24959353f, 0.05055125f, -0.10022295f, 0.11050133f, 0.08163555f, 
    0.01580833f, -0.00588497f, -0.04099655f, 0.10558020f, 0.15263692f, -0.12267303f, 0.11495101f, 0.02917215f, 
    0.06621519f, 0.03744887f, 0.01823625f, 0.00383313f, -0.07730537f, -0.12008432f, 0.15885262f, -0.12618144f, 
    0.49741140f, -0.07324616f, -0.00836199f, 0.00469549f, -0.00656521f, 0.07987872f, 0.10809559f, 0.19806810f, 
    0.06203790f, -0.09698270f, 0.02192026f, -0.10412890f, 0.27275348f, 0.01788823f, -0.00465064f, 0.14742772f, 
    -0.04397104f, -0.03190386f, -0.12137786f, -0.12119212f, 0.09804409f, -0.04084386f, -0.02136277f, -0.01377286f, 
    -0.10646629f, 0.04628267f, 0.04128609f, 0.00943212f, 0.09073087f, -0.04417887f, -0.00737517f, -0.04982126f, 
    -0.02916581f, -0.07407477f, -0.09240584f, -0.23278596f, 0.01105435f, 0.26171896f, -0.16670258f, -0.11726505f, 
    -0.08571249f, 0.13269100f, 0.01048349f, 0.03301601f, -0.05927818f, -0.01187856f, 0.03676304f, -0.11052179f, 
    -0.05963773f, 0.14662056f, -0.04714168f, 0.11160734f, 0.03284878f, 0.17796221f, -0.06830768f, -0.01429774f, 
    -0.12463863f, -0.01310348f, 0.05625877f, 0.10905761f, -0.18688992f, 0.20506330f, -0.12561800f, -0.06282637f, 
    0.13236494f, 0.06338642f, -0.11404165f, -0.09606457f, -0.03167851f, -0.20685446f, 0.07720882f, -0.15267824f, 
    0.71532732f, -0.38570631f, 0.12128578f, 0.11442848f, -0.25430608f, -0.00036619f, 0.13385804f, -0.17917508f, 
    -0.07819603f, 0.03514693f, 0.01963696f, 0.05933474f, 0.13048987f, -0.10713042f, 0.13512404f, -0.02285236f, 
    0.08676069f, 0.08122507f, -0.00070794f, -0.01964708f, 0.09151120f, 0.16968355f, 0.07153508f, 0.25566226f, 
    -0.15839419f, 0.03861907f, 0.17275900f, 0.05275011f, 0.03841851f, -0.07332058f, 0.02797174f, -0.12150186f, 
    0.10597616f, 0.12202376f, -0.13798203f, -0.07472564f, 0.06061786f, 0.06188256f, 0.00450204f, 0.15190448f, 
    -0.02409901f, 0.08417024f, 0.16205357f, 0.02821339f, 0.15933011f, -0.04437528f, -0.08315086f, -0.07523374f, 
    -0.19878083f, -0.00557226f, -0.00968172f, 0.08156506f, 0.03776859f, 0.08910073f, 0.03152533f, -0.00968679f, 
    -0.08533385f, -0.01719061f, -0.10916387f, -0.15688150f, 0.03072202f, 0.14613199f, 0.18774447f, -0.15771692f, 
    0.03063041f, -0.02691434f, -0.04485524f, 0.03594352f, 0.01077642f, 0.09864512f, -0.10297599f, -0.11708871f, 
    0.09849413f, 0.00738590f, 0.04774396f, -0.05679468f, -0.03409180f, 0.16292788f, 0.06945344f, 0.07106012f, 
    0.06107299f, 0.12441602f, 0.00368299f, 0.09197182f, -0.03936976f, -0.10755220f, 0.00434518f, -0.15163022f, 
    -0.13872321f, -0.03604335f, 0.09779558f, 0.06782621f, 0.11365816f, -0.04311349f, 0.04476558f, 0.00785216f, 
    -0.14893037f, 0.23214214f, 0.05819030f, -0.27503800f, 0.10002430f, 0.12957840f, -0.00366734f, -0.00934645f, 
    0.05061610f, -0.01328086f, -0.02719176f, 0.05206876f, -0.16279760f, 0.03035119f, 0.07223145f, -0.09977782f, 
    -0.02892631f, -0.01028011f, 0.06391568f, -0.07177196f, 0.04356279f, -0.01190946f, 0.04131423f, 0.02959243f, 
    0.02369971f, -0.08825954f, -0.05125691f, -0.17892259f, -0.19557904f, -0.07252963f, 0.04501282f, 0.15473102f, 
    -0.08908054f, 0.09110142f, 0.03650854f, 0.03511384f, 0.24766120f, -0.03448256f, 0.02214931f, -0.02141823f, 
    -0.04936140f, -0.07495497f, 0.05563078f, -0.01041633f, 0.04132759f, -0.05196595f, 0.09851874f, 0.12666801f, 
    -0.11912590f, 0.06465179f, 0.04759945f, 0.13280547f, 0.04386612f, -0.09704523f, 0.16354114f, -0.03059741f, 
    0.02241975f, 0.06579802f, -0.12795989f, 0.03628919f, 0.08511382f, -0.17513885f, -0.11726118f, 0.06281070f, 
    0.14775777f, -0.06407768f, -0.05040789f, 0.02046481f, -0.01241329f, 0.05031368f, 0.03511759f, -0.05156570f, 
    -0.07970887f, 0.06039554f, -0.16516195f, 0.19150966f, 0.13105625f, -0.00646307f, -0.06217007f, 0.03750160f, 
    -0.06353585f, 0.01104104f, -0.03718319f, 0.05909463f, 0.11689021f, -0.01709501f, 0.11253688f, -0.11185914f, 
    0.04612148f, 0.03557473f, 0.00881982f, -0.04565722f, 0.03042661f, -0.04488461f, 0.04049096f, 0.09207047f, 
    -0.15007758f, -0.13227384f, -0.08120399f, 0.07499417f, 0.06991870f, -0.03185461f, 0.02362748f, -0.03332451f, 
    -0.00002728f, 0.12690085f, 0.06263331f, -0.00657037f, 0.28169072f, -0.04704696f, 0.11590160f, -0.04047811f, 
    0.03864788f, -0.03816045f, 0.09432469f, 0.00584518f, 0.08105367f, -0.00453352f, 0.08959059f, 0.08369283f, 
    -0.15906283f, -0.04356895f, -0.07653746f, 0.01169076f, 0.07284923f, -0.06415705f, -0.03221742f, -0.10296577f, 
    -0.07473208f, 0.06351127f, -0.01254164f, 0.00759983f, -0.03084635f, -0.14188989f, -0.20549622f, 0.35821670f, 
    0.02529446f, -0.02695714f, -0.13254671f, 0.06327322f, 0.06602597f, -0.02657517f, 0.05638738f, -0.01792202f, 
    -0.10915246f, 0.13471246f, -0.00840425f, 0.27609932f, 0.03376122f, -0.01142324f, 0.04294578f, -0.07300915f, 
    0.10415458f, 0.04103299f, 0.18173364f, 0.02078216f, -0.01093672f, -0.14638717f, 0.10521132f, -0.06557734f, 
    0.07338969f, 0.03714317f, 0.01589835f, -0.00509143f, 0.00793076f, 0.14820182f, -0.08770927f, -0.09578990f, 
    -0.16370967f, 0.14230880f, -0.06797484f, 0.14815900f, 0.02939104f, 0.10844070f, -0.04708736f, -0.04530362f, 
    0.13030079f, 0.12901807f, -0.02085194f, 0.04551488f, -0.24713831f, -0.06275660f, -0.00394673f, -0.10148185f, 
    0.16811438f, 0.10418880f, -0.02780454f, -0.04065179f, 0.04817117f, 0.08774467f, 0.00969729f, 0.03146493f, 
    -0.05681126f, -0.33664972f, 0.07442673f, -0.05673612f, 0.12290043f, -0.05327883f, 0.01278851f, 0.06169239f, 
    0.01853064f, 0.06975538f, -0.06887032f, 0.03498306f, -0.09234934f, 0.18225507f, -0.08856994f, -0.00524174f, 
    0.09145837f, 0.14832826f, 0.03695397f, -0.00804850f, 0.03034355f, -0.03478699f, 0.06976346f, 0.01148855f, 
    0.05901264f, -0.23053594f, -0.17610341f, 0.16192347f, -0.13345569f, 0.05950247f, -0.01282638f, -0.06323850f, 
    0.02047304f, 0.06635723f, 0.08490214f, 0.08757694f, 0.07483055f, -0.10069589f, 0.16835476f, 0.04640555f, 
    -0.01086690f, -0.02617727f, 0.10524738f, 0.12289833f, -0.02983779f, 0.18632047f, -0.08727435f, -0.06867511f, 
    0.14420897f, -0.12988791f, 0.23668617f, -0.25592506f, 0.06589009f, -0.11248606f, 0.00051433f, 0.03453517f, 
    -0.05597017f, 0.04465100f, 0.05300786f, -0.01906737f, -0.19621569f, 0.27323276f, 0.10593632f, -0.34797189f, 
    0.09853280f, -0.02805499f, 0.03292452f, -0.12533654f, 0.10050449f, 0.07018595f, 0.08976244f, 0.08014986f, 
    -0.15218468f, 0.24440430f, 0.01705223f, -0.25271922f, 0.18535899f, 0.01478968f, 0.05073585f, 0.01631070f, 
    -0.00499471f, 0.00557992f, 0.09778516f, 0.03170783f, -0.12596788f, 0.10523891f, -0.07612717f, -0.10660715f, 
    -0.01226625f, -0.00233658f, 0.00677134f, 0.04588430f, 0.09930617f, 0.16898721f, -0.02400249f, 0.08985431f, 
    0.06987463f, -0.16436887f, -0.03062789f, -0.16179720f, 0.12387410f, 0.04157946f, 0.07140736f, 0.04609670f, 
    -0.01776818f, -0.04331997f, 0.09859104f, 0.09911323f, -0.03018098f, -0.16196829f, -0.02975336f, 0.17485657f, 
    0.01714838f, -0.12154661f, -0.02783019f, -0.05561784f, 0.03592151f, -0.00834208f, 0.10332481f, 0.00862183f, 
    -0.13448603f, 0.09742703f, -0.09335060f, 0.10311258f, 0.15657559f, 0.02840283f, -0.13914146f, 0.08330455f, 
    0.00039849f, 0.12841393f, 0.00027728f, 0.08921590f, -0.23162201f, 0.07642451f, 0.18175676f, -0.14175405f, 
    0.10864685f, 0.00446878f, -0.01601444f, 0.07322062f, 0.02630035f, 0.15046303f, 0.05362481f, 0.05055098f, 
    0.03099068f, 0.06249135f, -0.09674986f, 0.12750939f, 0.16683358f, 0.01908408f, 0.11399525f, 0.02839859f, 
    -0.08642116f, -0.02617674f, 0.07283654f, -0.02894574f, -0.29455122f, 0.09466694f, 0.21435408f, -0.18387318f, 
    0.03652695f, 0.07120422f, -0.05719649f, -0.14229436f, 0.09538314f, 0.09384020f, 0.01629245f, 0.04669892f, 
    0.38539743f, -0.06049807f, 0.09457335f, -0.17539510f, -0.06050594f, -0.05308978f, 0.03265687f, -0.03457672f, 
    0.03555337f, 0.00832928f, 0.04221497f, 0.04232991f, 0.05973681f, -0.10536767f, -0.10694385f, 0.16735391f, 
    0.07902185f, -0.07342718f, 0.13286364f, 0.11350655f, -0.01110312f, -0.10648866f, 0.03362247f, 0.17649375f, 
    -0.06981106f, 0.11335889f, 0.07715164f, 0.13628691f, -0.15615059f, -0.05817655f, 0.04758022f, -0.06866144f, 
    0.03837204f, 0.05513575f, 0.11119401f, 0.04234906f, 0.02649182f, -0.21841797f, 0.11851119f, 0.09634732f, 
    0.01508190f, 0.00437405f, 0.02715738f, 0.10065795f, -0.04327153f, 0.00335106f, -0.05307672f, 0.11889344f, 
    0.19528893f, 0.08430597f, -0.10161630f, 0.00059262f, 0.02728738f, -0.14959890f, -0.01173009f, 0.05886959f, 
    0.10441794f, 0.03517449f, 0.06088457f, 0.12244880f, -0.15800394f, 0.15738022f, -0.21325697f, -0.07972220f, 
    0.07079955f, 0.00644910f, 0.01150942f, -0.05517543f, 0.16532941f, -0.07378086f, 0.04457510f, 0.05708172f, 
    -0.11281713f, -0.02091575f, -0.04347175f, 0.21688670f, 0.05804991f, 0.05766015f, 0.01039178f, 0.04323059f, 
    -0.00507582f, -0.01051513f, -0.14578505f, 0.06775608f, 0.12156568f, 0.18944809f, -0.03075484f, 0.27019286f, 
    -0.00488807f, -0.03694685f, -0.08293521f, 0.14137273f, -0.05811014f, -0.13590072f, 0.07843662f, 0.00196502f, 
    -0.02040728f, 0.01270691f, 0.13835096f, 0.27500957f, -0.17219937f, 0.08730000f, 0.00622692f, 0.01752036f, 
    -0.03911559f, -0.02363067f, -0.07480382f, -0.01778093f, 0.02430079f, 0.10053438f, 0.01029731f, 0.03920937f, 
    0.00502217f, 0.04496517f, 0.11123023f, 0.08952443f, -0.08136998f, -0.08834409f, 0.17461938f, 0.12412202f, 
    -0.67703724f, 0.37362874f, -0.10573708f, 0.09849422f, 0.03264342f, 0.06174570f, -0.09030018f, 0.07243940f, 
    -0.00754635f, -0.08036189f, -0.05939348f, -0.03356638f, -0.20474996f, 0.17867194f, -0.00402138f, -0.04083391f, 
    0.07566354f, -0.01110404f, 0.01593043f, 0.02472766f, -0.08007453f, -0.00447043f, -0.10766813f, 0.05643953f, 
    -0.22555032f, -0.16038138f, -0.04194747f, -0.01281293f, -0.13358328f, 0.00400452f, 0.00635455f, 0.05243700f, 
    -0.11069470f, 0.01076972f, -0.00470456f, -0.09771754f, 0.34583175f, 0.07620659f, -0.14152737f, 0.01319738f, 
    0.09596839f, -0.00647461f, 0.14359723f, -0.10204746f, 0.00128598f, 0.05319699f, 0.02762855f, 0.00366012f, 
    -0.35439527f, -0.16522703f, 0.20351711f, -0.13828979f, -0.04860270f, -0.00069581f, -0.08590513f, -0.00794159f, 
    0.12668213f, -0.03098900f, -0.02838283f, 0.08150040f, 0.03393725f, -0.17346442f, 0.08118407f, 0.17976718f, 
    -0.15906394f, 0.01509380f, 0.06002937f, -0.00111365f, -0.09491788f, -0.07194579f, 0.04099068f, -0.07214474f, 
    0.02361177f, 0.01852430f, -0.07093805f, -0.05365789f, 0.05262437f, 0.01047901f, -0.05130746f, 0.05310503f, 
    -0.02694098f, -0.06249279f, -0.06087228f, 0.03311866f, -0.02139667f, -0.05535638f, -0.07838758f, 0.05487065f, 
    0.06151847f, -0.05141510f, 0.06000333f, -0.01610810f, -0.04694551f, 0.05284627f, -0.03741783f, -0.02730793f, 
    0.02204013f, -0.06026873f, 0.06465940f, 0.04948604f, -0.06173495f, 0.05807354f, -0.06486088f, 0.01680269f, 
    0.01541751f, 0.00574868f, 0.05309835f, -0.08010446f, -0.06522370f, 0.04402965f, 0.03923338f, 0.00338758f, 
    -0.01189409f, 0.02869209f, -0.07798698f, -0.07146905f, -0.00909635f, -0.01117662f, 0.00421884f, -0.07164911f, 
    -0.02397008f, 0.03330035f, 0.01388377f, 0.02058756f, -0.02323616f, 0.00924188f, -0.05439072f, -0.06583529f, 
    -0.06098645f, -0.00644999f, -0.02920140f, -0.05347735f, -0.05261937f, -0.05947348f, 0.00118101f, 0.03421281f, 
    -0.00296091f, -0.01199807f, -0.03053255f, 0.03705787f, 0.02143021f, -0.03151756f, -0.05336518f, -0.07215121f, 
    0.03982730f, 0.00249059f, 0.06681059f, -0.05105111f, 0.01986832f, -0.06197387f, -0.04491289f, -0.00476025f, 
    0.06944259f, -0.05499686f, -0.00434549f, 0.03824859f, -0.02649367f, 0.03916378f, -0.01901392f, -0.05804460f, 
    0.02174170f, -0.03649611f, -0.05342047f, 0.01735163f, -0.06706114f, -0.03476267f, -0.03917955f, 0.04608829f, 
    -0.06930259f, -0.05306131f, -0.06910596f, 0.01842226f, -0.04820992f, 0.03658128f, 0.02270349f, -0.06221391f, 
    0.03291224f, -0.00004843f, -0.04030313f, 0.05353550f, 0.02441528f, -0.00514789f, -0.05902438f, -0.02172795f, 
    -0.00409002f, -0.05990881f, -0.05978895f, 0.02507594f, 0.05424717f, 0.05585172f, 0.02388165f, 0.03630196f, 
    0.01146478f, -0.01022675f, -0.07727704f, 0.02874827f, -0.00830987f, 0.03670017f, -0.05630809f, -0.04751575f, 
    0.04267576f, 0.02592213f, -0.06692731f, -0.01762328f, 0.05956001f, 0.01075040f, -0.05070410f, -0.06752783f, 
    -0.04126388f, 0.00287273f, 0.02468236f, -0.01549469f, 0.06425279f, -0.04204839f, -0.01206049f, 0.00086774f, 
    0.03443675f, -0.03824869f, -0.07406454f, -0.01762922f, 0.00229126f, -0.04744421f, -0.07844903f, -0.02025410f, 
    0.03823720f, 0.02553703f, -0.07054812f, -0.06120347f, 0.00706773f, -0.07156326f, -0.03493269f, -0.06850770f, 
    0.02302232f, -0.07788563f, -0.03032005f, 0.02207095f, 0.04349639f, 0.04380505f, 0.00869340f, 0.00102146f, 
    -0.03176301f, 0.01860671f, -0.01359624f, 0.03460899f, -0.04554663f, 0.03029352f, -0.02015813f, 0.02863390f, 
    0.02554493f, 0.03682581f, -0.02829186f, 0.04247024f, 0.00478269f, 0.03562786f, -0.00004954f, -0.07348290f, 
    0.04756625f, -0.01856749f, 0.00899957f, -0.07369430f, 0.01354263f, 0.02480337f, 0.00053844f, -0.02132955f, 
    -0.14298637f, -0.21954153f, -0.14181487f, -0.01916705f, 0.07253625f, 0.04200556f, 0.04376884f, 0.01768535f, 
    0.04769173f, 0.05537266f, -0.10051106f, 0.00420549f, 0.14642943f, 0.14892861f, -0.23373635f, 0.02399999f, 
    0.17653255f, -0.07835689f, 0.07332482f, -0.05751791f, -0.08063732f, 0.13178881f, -0.00456458f, 0.01512844f, 
    -0.14673983f, 0.19691145f, 0.30764097f, 0.28388432f, 0.07134040f, 0.05205911f, -0.05790929f, 0.02577364f, 
    -0.15841524f, 0.04295098f, 0.02207034f, -0.05853866f, -0.18744247f, 0.01877633f, 0.04298915f, -0.02442645f, 
    -0.13232960f, 0.01182597f, -0.02420325f, 0.03818075f, 0.07588994f, -0.00861563f, 0.07934958f, 0.09139599f, 
    -0.09447092f, 0.14300880f, 0.20122354f, 0.24306993f, -0.09187187f, -0.13848443f, -0.01034220f, -0.12744105f, 
    0.08483682f, 0.04140260f, -0.16994664f, 0.11847150f, -0.05766661f, -0.03999270f, -0.19300735f, -0.07537903f, 
    -0.11359780f, 0.20240030f, 0.11455476f, 0.03369049f, 0.15121284f, 0.13919826f, -0.02764752f, 0.11199436f, 
    0.22198240f, 0.04955672f, 0.14691114f, 0.13852355f, 0.05205167f, 0.03162872f, 0.09995162f, -0.00359879f, 
    -0.09800386f, 0.06927413f, 0.10550494f, 0.08225077f, -0.14908639f, 0.04109510f, -0.10428733f, 0.02270365f, 
    0.00087109f, 0.06724112f, 0.10599717f, 0.05958520f, 0.13656943f, -0.06487038f, -0.00370974f, 0.07412331f, 
    0.00772938f, -0.02373537f, 0.05380683f, 0.04966818f, -0.17460512f, 0.04111362f, 0.06293775f, 0.05541881f, 
    0.01047813f, -0.01198482f, -0.00780478f, 0.11072177f, 0.13197707f, 0.06548045f, 0.09548742f, -0.08882242f, 
    0.01242006f, 0.03094275f, 0.06826220f, 0.06189378f, -0.04171987f, -0.01947405f, -0.00318419f, 0.10000329f, 
    -0.38770449f, 0.32758084f, 0.14798255f, 0.04988438f, 0.12721083f, 0.03821864f, -0.11346547f, 0.00232598f, 
    0.08352013f, 0.02348124f, -0.05159842f, -0.00642356f, 0.05098119f, 0.35504448f, -0.12358122f, -0.04691866f, 
    0.02383035f, 0.06671143f, 0.15818039f, 0.01137641f, -0.07561812f, -0.04960458f, 0.01972127f, -0.03393193f, 
    -0.37609321f, 0.04933975f, -0.05407625f, -0.17485870f, 0.05098957f, 0.09464975f, 0.10833390f, 0.09653849f, 
    0.07653783f, -0.03436689f, 0.03187688f, 0.02401354f, 0.02050417f, -0.03167505f, -0.11328540f, 0.03993047f, 
    0.06946782f, -0.04034765f, 0.01608876f, -0.01204123f, -0.08079937f, 0.04161881f, 0.05201453f, -0.00043181f, 
    -0.47038987f, -0.05047895f, 0.06971212f, 0.17368630f, 0.05729266f, -0.01547704f, -0.07754478f, -0.01669120f, 
    0.03815310f, 0.06347214f, 0.08925548f, 0.09612671f, -0.12302272f, -0.12629260f, -0.01069326f, 0.17754737f, 
    0.03313439f, -0.04453785f, 0.00104179f, 0.05145390f, 0.09469780f, 0.02704173f, 0.11627502f, 0.01414076f, 
    0.45109105f, 0.00204799f, 0.27128497f, -0.18375345f, 0.00286233f, 0.11677524f, -0.03777951f, 0.09037677f, 
    -0.01787429f, 0.00801892f, 0.02976157f, 0.11977712f, 0.28865051f, -0.21674864f, -0.24154834f, 0.07406011f, 
    -0.01431753f, -0.03958613f, 0.07095560f, -0.01201711f, -0.00859878f, -0.05411477f, 0.00240527f, -0.02548175f, 
    0.16575527f, -0.12905101f, 0.13753438f, 0.01483694f, -0.08541164f, 0.01381159f, 0.02874925f, -0.06741729f, 
    0.05204402f, -0.00526561f, 0.06059088f, 0.03063695f, -0.23577556f, 0.05876616f, 0.17772508f, 0.09480058f, 
    -0.04628588f, -0.01413488f, 0.09719004f, 0.11794928f, 0.09950551f, 0.03789254f, -0.10358086f, 0.02830675f, 
    0.00740509f, -0.16930194f, -0.20958011f, 0.06003759f, -0.09951706f, -0.06510569f, -0.05572001f, -0.02439190f, 
    -0.07362362f, 0.09053071f, 0.09803769f, -0.03568298f, -0.10118769f, 0.04443369f, 0.00236208f, -0.06333941f, 
    0.17209405f, 0.02181638f, -0.06300908f, 0.19493945f, 0.02960367f, -0.01659768f, 0.05784820f, 0.17142907f, 
    0.05962413f, 0.02433878f, 0.13117312f, -0.02755064f, 0.08054547f, -0.07220218f, -0.07123239f, 0.09335761f, 
    0.07864828f, 0.00581550f, -0.01136467f, 0.14613190f, 0.09694521f, 0.04061094f, -0.06033031f, -0.10483982f, 
    0.10622489f, -0.03469973f, -0.05188751f, 0.11609822f, -0.20047732f, -0.07798130f, 0.08618231f, 0.04479462f, 
    -0.03858691f, 0.10812411f, -0.09236380f, -0.03557764f, 0.04729407f, 0.01500027f, 0.06139626f, -0.04732127f, 
    -0.03783688f, 0.00112704f, -0.01663429f, 0.09055535f, -0.24173293f, -0.10943333f, 0.11836774f, 0.15264468f, 
    -0.07882817f, -0.02111993f, 0.14792503f, -0.02201917f, 0.00116330f, 0.03566061f, 0.08371568f, 0.11437171f, 
    -0.81135899f, 0.18564521f, -0.14965715f, 0.04487588f, 0.08233008f, -0.04555699f, -0.20390953f, 0.04171089f, 
    0.03636630f, -0.01697121f, -0.02921320f, 0.01390773f, -0.26046392f, 0.07153758f, 0.05664060f, 0.03746574f, 
    0.10986631f, 0.00650030f, 0.04160864f, 0.04559306f, 0.03092100f, 0.05518938f, -0.10183346f, 0.09389219f, 
    0.00619870f, -0.06431946f, -0.02828609f, -0.13673906f, 0.03756041f, 0.08257432f, 0.00287105f, -0.00132496f, 
    -0.06385444f, 0.02767921f, -0.08886423f, -0.05807564f, -0.09491011f, 0.10551433f, -0.18832736f, 0.05091830f, 
    0.01881765f, 0.03300884f, 0.06115061f, -0.04650962f, 0.11166281f, 0.00565490f, 0.04352764f, 0.13224152f, 
    0.21176353f, -0.08870163f, 0.20265754f, 0.13634373f, 0.00013445f, -0.04572700f, 0.00490324f, 0.06864763f, 
    0.09553700f, 0.12079476f, -0.00903611f, 0.04945781f, 0.03432931f, -0.11319496f, 0.13205627f, -0.19009951f, 
    -0.08226976f, -0.04012239f, 0.05718702f, -0.03673812f, -0.05958001f, 0.03816935f, -0.01348856f, 0.08100639f, 
    0.04454111f, 0.23907769f, 0.01832383f, -0.01459807f, 0.05416260f, -0.05931624f, 0.00443818f, -0.13583368f, 
    -0.08156851f, -0.02516014f, 0.04966987f, -0.11138171f, -0.10932407f, 0.20014039f, 0.26765344f, 0.21102774f, 
    0.01093382f, -0.12378361f, -0.08554353f, 0.06514006f, 0.03623401f, -0.08472677f, 0.04819104f, 0.00233887f, 
    -0.22938435f, -0.11321954f, -0.38072658f, -0.36346996f, 0.07891992f, -0.03198384f, 0.05086422f, -0.04942620f, 
    0.07406460f, -0.04766565f, 0.00425360f, 0.06145030f, 0.26257420f, 0.00804968f, -0.14327708f, -0.18131392f, 
    0.04422169f, 0.02905488f, -0.12571581f, -0.07391093f, 0.00560959f, 0.04798789f, 0.01012101f, -0.09473238f, 
    0.17236598f, 0.22078761f, 0.12425517f, -0.21195298f, 0.06329866f, 0.07888628f, -0.14082138f, 0.08043975f, 
    0.04737108f, -0.11681399f, -0.04181557f, -0.16123116f, 0.09278563f, 0.03952751f, 0.01701845f, 0.19828957f, 
    -0.12753361f, 0.00622901f, 0.09787647f, -0.08592964f, -0.07903942f, 0.09884673f, -0.02042440f, -0.10613918f, 
    -0.09776944f, -0.21109004f, -0.34273088f, -0.03524335f, -0.06763706f, 0.01718716f, -0.02511741f, -0.17057079f, 
    0.01689034f, -0.08472130f, 0.00118966f, 0.00469111f, 0.06548517f, 0.00783745f, 0.26895085f, 0.22015379f, 
    -0.04873352f, -0.02700309f, 0.03554434f, 0.00141579f, -0.03115614f, -0.02660761f, -0.02954956f, -0.01484261f, 
    0.30559507f, 0.00409110f, 0.11897847f, 0.31659535f, -0.08436906f, 0.08989461f, -0.00842809f, 0.10141304f, 
    0.02030006f, 0.06448567f, 0.09931042f, -0.09642958f, -0.18983878f, 0.09234893f, 0.11578444f, -0.21693662f, 
    0.00189139f, -0.08270937f, -0.07765110f, -0.04429834f, -0.03122333f, 0.07105632f, -0.21774662f, 0.05262630f, 
    0.28650174f, -0.18594259f, -0.03964859f, 0.11902965f, -0.16876394f, 0.06135507f, 0.15282476f, 0.11686195f, 
    0.07690544f, 0.05216411f, 0.01373876f, 0.13709964f, 0.20897831f, 0.06906679f, 0.19760674f, 0.11440729f, 
    -0.00102668f, -0.07591225f, -0.09239221f, 0.01675822f, 0.04832659f, 0.01173639f, -0.01944228f, -0.14472675f, 
    0.30083117f, 0.15258183f, -0.01376073f, -0.02503365f, 0.09009842f, -0.04758907f, 0.02438137f, -0.01167936f, 
    -0.06665656f, -0.00099423f, 0.01322911f, -0.01978711f, 0.40264398f, 0.05433206f, 0.20218627f, 0.24503630f, 
    -0.02047086f, -0.00077074f, -0.12666847f, -0.00278718f, -0.06185196f, 0.15307452f, -0.04590985f, -0.00419454f, 
    0.05983403f, 0.13056940f, -0.11094451f, -0.30755818f, -0.08019127f, -0.00004054f, 0.13391989f, 0.03840483f, 
    0.04610932f, -0.05551646f, -0.08644756f, 0.04164358f, -0.07294740f, 0.05989531f, -0.03485775f, 0.13306864f, 
    0.03164756f, -0.06907374f, -0.02486326f, -0.01440725f, 0.06721969f, 0.02761433f, 0.10903558f, -0.00264626f, 
    0.10120486f, 0.10678186f, 0.05472327f, -0.05148391f, -0.03297704f, 0.07651204f, -0.04952551f, 0.04842126f, 
    0.02373953f, -0.01123491f, 0.20300333f, 0.07725871f, 0.01317108f, -0.11860333f, 0.06267238f, 0.05823683f, 
    -0.11072557f, 0.14086951f, -0.07359199f, 0.15883540f, 0.15120833f, -0.03097104f, -0.03551630f, 0.04198201f, 
    0.26269192f, -0.17280906f, -0.12168971f, -0.09918067f, -0.08335807f, 0.10455110f, 0.06036820f, -0.07821623f, 
    0.25143242f, -0.05407106f, 0.11200126f, 0.04647560f, 0.20174637f, 0.06141307f, -0.03659470f, 0.14744386f, 
    0.12293553f, -0.03663696f, -0.03010709f, 0.00948482f, -0.09179299f, -0.10083540f, 0.04116310f, -0.04303722f, 
    0.06531161f, -0.16064094f, -0.15624440f, -0.09505109f, 0.03071423f, 0.17192346f, 0.14660652f, 0.07127175f, 
    -0.03686123f, -0.02280488f, 0.21486858f, 0.07284249f, -0.04180644f, 0.00014958f, 0.10938872f, -0.01557967f, 
    0.18437396f, -0.13306786f, -0.05927762f, -0.04980509f, -0.11645114f, -0.17291927f, 0.04428362f, -0.02772479f, 
    -0.27937555f, -0.09499219f, 0.05679855f, 0.01041301f, 0.02320422f, 0.03144523f, -0.05938125f, 0.07601141f, 
    0.12229799f, 0.09860145f, -0.13324288f, -0.00977730f, 0.24942037f, 0.05024997f, 0.12610500f, 0.04318372f, 
    0.02951688f, 0.02886699f, -0.06021319f, -0.00812015f, -0.01520671f, 0.01229479f, 0.01385410f, 0.08896635f, 
    -0.01380230f, -0.00022609f, -0.04694537f, 0.05254292f, 0.25141877f, -0.00555460f, 0.08023465f, 0.01937980f, 
    0.00423462f, 0.07320023f, 0.15555206f, -0.00905641f, 0.20821409f, 0.09924743f, -0.10085027f, -0.01924000f, 
    -0.08982059f, -0.01313595f, 0.05491449f, -0.04669473f, -0.00902236f, -0.05623081f, 0.03458255f, 0.03817722f, 
    -0.31994253f, 0.16967957f, -0.09696274f, -0.14282893f, 0.12326131f, 0.03915603f, 0.01345018f, -0.03015108f, 
    -0.08422644f, 0.03455444f, 0.01066623f, 0.05463067f, -0.46577445f, -0.31592923f, -0.00107163f, 0.21960200f, 
    0.02589732f, -0.04458641f, 0.00289711f, 0.08188353f, 0.00232061f, 0.03325240f, 0.07009409f, 0.00376940f, 
    0.19504599f, -0.16092323f, 0.10439769f, 0.16397427f, -0.06600174f, -0.04027854f, -0.08896458f, 0.10882904f, 
    0.00767294f, -0.05132544f, -0.00696044f, -0.14952211f, 0.08487455f, 0.08149692f, 0.06248959f, 0.03153509f, 
    0.02920380f, 0.00779042f, 0.18119138f, -0.01102294f, 0.03345573f, 0.05206166f, 0.05702050f, -0.10592968f, 
    0.30853090f, 0.00557031f, 0.00525418f, -0.00519444f, -0.00922984f, 0.00384224f, -0.06925936f, -0.08059262f, 
    0.11433400f, -0.02031001f, -0.11450712f, -0.07210192f, -0.00134677f, -0.01766009f, -0.00289579f, 0.07208988f, 
    0.03525089f, 0.16376522f, 0.11893628f, -0.11322233f, 0.01955944f, -0.00765810f, -0.04233577f, -0.06621098f, 
    -0.07947863f, 0.01834340f, 0.04395667f, -0.01744338f, -0.06795771f, -0.06599334f, -0.04909106f, -0.07926907f, 
    0.01749342f, -0.01656318f, -0.05486287f, -0.03952553f, 0.03284381f, 0.01444594f, -0.01543618f, 0.01522078f, 
    -0.06988850f, -0.03638612f, -0.06024553f, 0.00071971f, 0.00262783f, 0.01861409f, 0.05839119f, 0.05087785f, 
    -0.00642451f, -0.04954768f, -0.06639548f, -0.07242699f, 0.01351733f, -0.02508247f, -0.02879580f, 0.02506400f, 
    0.05403179f, 0.00622752f, 0.06061724f, -0.06912828f, 0.04810678f, 0.04215417f, -0.02534527f, 0.00500908f, 
    -0.05310942f, 0.01207701f, -0.06951861f, -0.04826962f, 0.04999813f, -0.00456537f, -0.01930736f, -0.01703817f, 
    -0.07523492f, 0.03460041f, -0.07335716f, 0.05938683f, -0.00293356f, -0.05925342f, -0.02157073f, -0.01585735f, 
    0.02426345f, 0.03707591f, 0.05561193f, -0.06762131f, 0.04030694f, 0.02021280f, -0.01314131f, 0.02929038f, 
    -0.06858960f, 0.02698111f, -0.07476424f, -0.01407429f, -0.06097325f, -0.03135409f, 0.02745125f, 0.06362109f, 
    0.05953210f, -0.00031667f, 0.05361933f, -0.01579427f, 0.04036615f, 0.00576642f, -0.05535592f, 0.01092322f, 
    -0.04906432f, 0.04545876f, -0.02098632f, 0.01770171f, 0.04770712f, -0.06983911f, -0.06171023f, -0.06878685f, 
    -0.07623582f, 0.02270291f, -0.00404334f, 0.04872468f, -0.03961515f, 0.05417138f, -0.00629534f, -0.00685840f, 
    -0.05080529f, -0.00163456f, -0.05580328f, -0.07246038f, -0.03572234f, -0.03832529f, 0.01527037f, -0.06111052f, 
    -0.02296538f, 0.05287900f, -0.02077990f, -0.01536961f, -0.04339380f, -0.04199691f, -0.01610357f, -0.00834847f, 
    0.05603943f, 0.01149610f, -0.06426912f, -0.05447914f, 0.02865933f, 0.01315999f, -0.03804104f, -0.02093930f, 
    0.01743184f, 0.06153450f, 0.03066840f, 0.04026038f, -0.06502046f, -0.03062919f, 0.01947341f, -0.04468988f, 
    0.01260190f, -0.02203153f, -0.06972888f, 0.06193755f, -0.05790794f, -0.01712873f, 0.01010121f, 0.04086354f, 
    -0.07808311f, -0.04079428f, 0.04949028f, 0.04067279f, 0.06076057f, 0.03719024f, -0.06807122f, -0.03321391f, 
    -0.01278512f, -0.02264892f, 0.00392960f, 0.00015106f, -0.00625274f, -0.05960044f, -0.04370078f, 0.03225698f, 
    -0.02905371f, 0.04607012f, 0.04932225f, 0.02031444f, 0.01202947f, -0.07438627f, -0.05266992f, -0.04596533f, 
    0.05628986f, -0.00017553f, -0.02046260f, -0.02798244f, 0.03933906f, -0.06471369f, 0.02606910f, 0.02588729f, 
    -0.03789402f, -0.04443196f, -0.06558054f, 0.01317572f, -0.00436611f, 0.04256725f, 0.02416467f, -0.05234357f, 
    0.04607921f, -0.05240621f, -0.04498234f, -0.03837779f, 0.02890548f, -0.03085654f, -0.02960119f, 0.01990032f, 
    0.06244005f, -0.07611161f, -0.02614236f, 0.03420303f, -0.04748709f, -0.00609267f, 0.04335227f, -0.05540215f, 
    0.14426489f, -0.03665200f, -0.06191722f, 0.13717838f, 0.14676636f, -0.23462814f, 0.00499470f, -0.06653148f, 
    0.04884080f, 0.00176853f, -0.03662159f, -0.07430346f, -0.13341576f, 0.16702656f, 0.05784605f, -0.00604861f, 
    0.09009507f, -0.04207292f, 0.05723586f, -0.10570894f, 0.08274382f, 0.03155075f, -0.00286987f, 0.07339645f, 
    0.00397922f, 0.16486186f, -0.09685173f, 0.11581164f, -0.06842223f, -0.05461508f, -0.03965688f, 0.02216709f, 
    0.01287227f, -0.05438321f, -0.05627396f, 0.04855492f, 0.04377746f, 0.14936021f, -0.21896592f, -0.13770698f, 
    0.03291435f, 0.08745921f, -0.09206008f, -0.00214886f, 0.03882410f, 0.13639158f, -0.05387589f, 0.08180651f, 
    -0.26103517f, 0.25105610f, 0.18309259f, -0.09224334f, 0.10206212f, 0.10560204f, -0.08073773f, -0.14515567f, 
    -0.01336641f, 0.01356714f, -0.02246780f, 0.04375627f, -0.20135804f, -0.03991149f, 0.04435522f, -0.09287286f, 
    -0.04433873f, 0.04400276f, 0.16309735f, -0.03078582f, -0.01564071f, 0.10425698f, -0.02186001f, -0.01453171f, 
    0.03618375f, -0.00436539f, -0.21189719f, -0.03706284f, -0.00404789f, -0.04642309f, 0.02046598f, -0.04849346f, 
    0.06276550f, -0.00793761f, 0.18346566f, 0.14618652f, 0.00903287f, -0.26978543f, 0.22485392f, 0.33467165f, 
    0.01422693f, 0.04326634f, 0.07390533f, -0.05767332f, 0.08754321f, -0.00166234f, -0.06471591f, 0.15929006f, 
    0.20943579f, -0.16619451f, 0.16303641f, 0.22918651f, -0.11444895f, -0.02273559f, -0.01959462f, 0.07798404f, 
    0.04667985f, 0.04139880f, -0.09381808f, -0.09004800f, 0.08376557f, -0.16377631f, 0.09357584f, 0.08058588f, 
    -0.02905334f, -0.11368167f, -0.03408454f, 0.09552947f, 0.03986384f, 0.15691856f, -0.13018620f, -0.02016695f, 
    -0.12540960f, 0.09475143f, -0.03718325f, 0.04360666f, 0.02890275f, -0.01493794f, -0.04228846f, 0.00799386f, 
    0.13469651f, 0.02148043f, -0.01215985f, -0.03128941f, 0.13774374f, 0.13936235f, -0.05312268f, -0.07961519f, 
    -0.00298013f, 0.04681177f, -0.01600496f, -0.01353048f, -0.01195479f, -0.24762143f, 0.00386257f, -0.19707431f, 
    0.33576626f, 0.03090478f, 0.01950986f, 0.03336474f, -0.03289355f, 0.08386078f, 0.06259790f, 0.09654271f, 
    -0.03408223f, -0.11405218f, 0.13855775f, 0.10839269f, 0.29210997f, -0.04248310f, 0.19978568f, -0.11902376f, 
    -0.06451760f, -0.04534724f, -0.16660243f, 0.03534276f, -0.10798778f, 0.11692088f, 0.04609576f, -0.02558367f, 
    0.02841093f, 0.05459372f, -0.17549223f, -0.18729343f, -0.01427600f, 0.01903039f, -0.04026636f, 0.07432812f, 
    -0.02726644f, 0.08168710f, -0.00653918f, 0.08968157f, 0.19497968f, 0.09386351f, -0.14667793f, 0.22247663f, 
    0.04426477f, 0.03634618f, 0.03194164f, 0.10815563f, -0.07117431f, -0.18596892f, 0.06571369f, 0.03896345f, 
    0.01335365f, 0.01504677f, 0.02965911f, -0.11096366f, -0.00315506f, 0.05529446f, -0.15452228f, 0.07745162f, 
    0.07084230f, -0.07150672f, 0.21227801f, 0.15727367f, 0.12565988f, 0.08108608f, 0.05539024f, 0.01351886f, 
    -0.15768367f, 0.11040235f, -0.03218405f, 0.18250149f, 0.09017530f, 0.03119437f, 0.01946046f, -0.01859135f, 
    0.18427116f, -0.11604401f, -0.01045024f, 0.06668659f, -0.11594430f, 0.07273119f, 0.07585167f, -0.08855377f, 
    0.27093491f, -0.02516149f, 0.10239729f, 0.12286142f, 0.41043210f, -0.10944975f, -0.05228190f, 0.19421035f, 
    0.10975507f, -0.08166368f, -0.00331724f, 0.07640830f, -0.10577364f, -0.14746185f, -0.02579678f, -0.03510965f, 
    -0.01036739f, -0.02205331f, 0.03686306f, 0.02887963f, 0.01543909f, 0.05049425f, 0.15476546f, 0.02440548f, 
    0.10242250f, 0.00291766f, 0.22549669f, 0.07941158f, -0.14483769f, 0.09841208f, -0.05066226f, -0.01546576f, 
    0.04556619f, 0.05332057f, -0.11886632f, 0.01970371f, -0.10121020f, -0.21172430f, 0.06198759f, -0.11364429f, 
    -0.21611963f, -0.03945815f, 0.17104359f, 0.01557934f, 0.08196680f, 0.04189398f, -0.03854381f, 0.02047803f, 
    0.04748351f, 0.05666705f, -0.06503621f, -0.08377905f, 0.24328458f, 0.06405929f, 0.05716129f, 0.02649382f, 
    -0.06883064f, -0.04608432f, -0.02155738f, 0.00363684f, -0.09808946f, -0.07148610f, 0.02538256f, -0.05841422f, 
    0.13643254f, 0.02482674f, -0.12976055f, -0.03827352f, 0.12779658f, -0.03170212f, -0.04132076f, -0.07194442f, 
    0.03124033f, -0.05195349f, 0.16916019f, 0.05755820f, 0.29594365f, 0.27140507f, -0.12160607f, 0.04164251f, 
    0.02127881f, 0.08799911f, -0.05988626f, -0.00173865f, -0.16600779f, -0.07312369f, 0.00338682f, 0.06893256f, 
    -0.41012257f, 0.29906574f, 0.02843249f, -0.11899579f, 0.03200683f, -0.01517120f, 0.08778669f, -0.05944537f, 
    -0.15977867f, -0.08364868f, -0.02349236f, -0.04949124f, -0.57323277f, -0.13536654f, -0.07438590f, 0.23688500f, 
    0.00096525f, -0.06811722f, 0.01613811f, 0.23216960f, 0.08133715f, 0.09802366f, 0.15373984f, -0.01850923f, 
    0.03951167f, -0.27633819f, 0.07897337f, 0.06335101f, -0.03808718f, -0.03608008f, -0.00230073f, 0.04427922f, 
    0.09721676f, -0.07130546f, -0.03270110f, -0.10100099f, 0.07887903f, 0.09903935f, -0.06504643f, -0.02953990f, 
    0.09094287f, 0.09131521f, 0.14311618f, -0.06179593f, 0.07227201f, -0.11721566f, -0.08927242f, -0.09153452f, 
    0.09802367f, -0.02167136f, 0.05013357f, 0.03358222f, -0.11540949f, -0.00065373f, -0.10472710f, -0.03613471f, 
    -0.01063061f, -0.07325076f, -0.08203889f, -0.04248343f, 0.05290691f, -0.06868902f, -0.04230309f, 0.09806640f, 
    0.03231502f, 0.16481386f, -0.03017868f, -0.03371012f, 0.08966226f, -0.00119559f, 0.00912877f, -0.05141816f, 
    -0.05491768f, 0.03164620f, 0.12536448f, -0.10999985f, 0.03181317f, 0.02623403f, 0.04781657f, -0.11805359f, 
    0.06687705f, -0.02988317f, 0.20137256f, -0.05027771f, -0.12702703f, -0.05832899f, 0.00017577f, -0.00463757f, 
    0.08027846f, 0.01396287f, 0.02023679f, -0.01182309f, -0.01359781f, -0.02063425f, -0.12593007f, -0.02357396f, 
    -0.09053475f, 0.10328174f, -0.01317556f, 0.11340256f, -0.15393244f, -0.04500298f, -0.07719618f, -0.14811751f, 
    0.09358907f, -0.09164394f, 0.03581864f, 0.09921879f, 0.01288801f, -0.25618958f, -0.21653374f, -0.22091676f, 
    0.09746771f, -0.00659327f, 0.08877107f, -0.06487796f, 0.07734568f, -0.01130102f, 0.00999406f, -0.05403119f, 
    -0.25382930f, 0.17936811f, -0.14478163f, -0.20503461f, 0.03274542f, 0.03634896f, -0.07525291f, -0.00101101f, 
    -0.03456575f, -0.04895319f, 0.08011997f, -0.13967073f, -0.08189060f, 0.06630605f, -0.04682710f, -0.05703490f, 
    0.09713225f, 0.19218710f, 0.03630317f, -0.01716230f, -0.21176015f, 0.01608159f, -0.06367800f, -0.07689870f, 
    0.03424988f, 0.00564540f, -0.00104626f, 0.12771282f, -0.08909839f, 0.11396433f, -0.23762864f, -0.09232987f, 
    0.06145484f, 0.00641968f, 0.00643941f, 0.01063565f, 0.14012066f, -0.11501893f, 0.26258442f, 0.13108560f, 
    -0.19206944f, 0.03947764f, 0.06794816f, 0.05034730f, -0.04539263f, -0.01006964f, 0.02996061f, 0.09849402f, 
    0.53397220f, 0.17573310f, 0.21341196f, 0.13666724f, -0.06860201f, 0.10252419f, 0.09569550f, -0.01718566f, 
    0.00224025f, 0.15160738f, 0.01268805f, -0.01089529f, -0.17890748f, -0.23238321f, 0.09508076f, -0.24938832f, 
    0.04007965f, 0.07895543f, -0.04582348f, -0.00822524f, -0.02057635f, 0.02433085f, -0.16582946f, 0.09008147f, 
    -0.16908045f, 0.02370041f, -0.10192487f, 0.15654594f, -0.03971040f, 0.09104963f, -0.04239430f, 0.01989608f, 
    0.12180628f, 0.01504670f, -0.04744388f, -0.07993761f, 0.08155924f, -0.06764480f, 0.07731077f, 0.05140969f, 
    0.03760789f, 0.06880413f, -0.01053027f, 0.19226393f, -0.06539541f, 0.11840644f, -0.07052130f, 0.00880595f, 
    0.23444709f, 0.25572115f, 0.11126348f, 0.09442052f, -0.05338811f, -0.10410684f, 0.02764019f, 0.01803390f, 
    -0.02744655f, 0.07885974f, 0.12762840f, 0.03695141f, 0.53647512f, -0.08768095f, 0.10730599f, 0.24568135f, 
    0.12168474f, 0.12437509f, -0.00349228f, 0.01823691f, -0.06215205f, -0.02734968f, -0.04298618f, -0.04188554f, 
    -0.07027812f, 0.03008776f, 0.05676924f, -0.19965248f, -0.03884730f, -0.03855439f, 0.17649122f, 0.08817834f, 
    -0.02770393f, 0.00458961f, -0.00144720f, 0.07351574f, 0.13639897f, 0.15546690f, 0.14611202f, 0.26090324f, 
    -0.11853181f, -0.17529108f, -0.09029193f, -0.02448087f, 0.13660139f, -0.08163724f, 0.02439536f, 0.00753863f, 
    0.05139121f, -0.04373607f, -0.00579836f, -0.04831471f, -0.07737121f, -0.05450016f, 0.02174962f, 0.00048420f, 
    -0.05051022f, 0.06577405f, -0.05120609f, 0.02055209f, -0.07214387f, -0.03428420f, 0.03743432f, -0.03765312f, 
    -0.04640341f, -0.00967513f, 0.04487492f, -0.03616418f, 0.00251026f, 0.04460520f, 0.02395055f, -0.05305818f, 
    -0.04512218f, 0.00044154f, -0.04324386f, -0.07000486f, -0.05552188f, -0.01276915f, 0.03166558f, -0.01912969f, 
    0.03563723f, -0.07297320f, 0.05409032f, 0.01864821f, 0.01192429f, -0.02520843f, -0.06145847f, -0.04351595f, 
    -0.00129707f, -0.05348169f, -0.00280651f, 0.01023889f, -0.03856421f, 0.05957574f, -0.03888004f, -0.01758674f, 
    0.00759283f, -0.07076796f, -0.02463722f, -0.06956964f, 0.02995871f, -0.07114913f, -0.03065969f, -0.00232520f, 
    -0.05633833f, 0.02786647f, 0.04784551f, 0.02353491f, 0.00838589f, -0.04042463f, -0.03399954f, 0.04101607f, 
    0.01750247f, -0.04761305f, -0.05726970f, -0.06469785f, -0.00915987f, 0.01110023f, 0.04757062f, 0.01877007f, 
    -0.00400850f, 0.02494103f, 0.06069970f, 0.05941104f, 0.05676873f, 0.00227311f, 0.00093546f, -0.00920736f, 
    -0.00035688f, -0.05233076f, -0.04553806f, -0.04213386f, 0.04396188f, -0.05561072f, 0.01055359f, 0.02316242f, 
    -0.03790078f, -0.05598830f, -0.03454111f, -0.05198521f, -0.06217297f, -0.00230972f, 0.01715292f, 0.00790024f, 
    -0.07352418f, -0.06544937f, -0.07525113f, -0.04595631f, -0.04213447f, 0.00544431f, -0.01222966f, -0.02539562f, 
    -0.02628343f, -0.00941411f, -0.01283866f, 0.01966376f, -0.01598270f, 0.03622625f, 0.02880733f, -0.04980880f, 
    0.06032673f, -0.06298685f, -0.03830454f, -0.01619800f, -0.07460418f, -0.01963081f, 0.05451858f, 0.01281604f, 
    -0.01741047f, -0.00183656f, -0.03206043f, 0.03834514f, 0.05087373f, 0.03050812f, -0.00460695f, -0.06573243f, 
    -0.03689784f, -0.07523043f, -0.02741706f, -0.05934075f, -0.02164854f, -0.00723253f, 0.05614828f, -0.02701767f, 
    0.02342647f, -0.01904966f, -0.04276323f, 0.05364332f, 0.04038129f, 0.00663567f, 0.04941343f, -0.03233140f, 
    0.01420147f, 0.01265857f, -0.04832170f, 0.03346514f, 0.02943023f, 0.04784832f, 0.04232144f, 0.04579889f, 
    -0.07418168f, -0.01504957f, 0.06550548f, -0.05798278f, 0.04636437f, -0.06369946f, -0.05952059f, -0.06502812f, 
    -0.04912154f, -0.07310583f, -0.01121018f, -0.00576441f, -0.06244705f, 0.01865096f, 0.06253914f, 0.02203250f, 
    -0.06496063f, -0.01810043f, 0.04172686f, -0.06592988f, 0.01348567f, 0.06232229f, 0.06031328f, 0.04665066f, 
    -0.01825878f, -0.06806212f, -0.06112388f, -0.04340794f, -0.06159749f, -0.05687419f, 0.04773190f, 0.01970517f, 
    0.03417683f, 0.04186189f, -0.04873816f, -0.06461158f, 0.00165208f, -0.05273211f, -0.06976388f, 0.05754022f, 
    0.31796888f, 0.09111264f, -0.09149266f, -0.06233695f, -0.05275873f, 0.07020585f, -0.04835851f, 0.06485877f, 
    -0.08096706f, 0.04248969f, 0.12372916f, -0.02840273f, 0.12534088f, 0.15999697f, -0.11007679f, 0.10812961f, 
    0.06361523f, -0.07306082f, 0.00542865f, 0.07834476f, -0.08157370f, 0.05756083f, -0.09702532f, -0.05361909f, 
    0.29681298f, -0.17729144f, -0.02968281f, 0.26920506f, -0.03418028f, -0.01131868f, -0.03024120f, 0.11054803f, 
    0.08263578f, 0.07982071f, 0.04191292f, -0.07329178f, 0.05901258f, 0.14055249f, -0.02080785f, 0.12981378f, 
    0.17781113f, 0.00585857f, 0.11191384f, 0.03639290f, 0.04384678f, 0.04863345f, 0.00262063f, 0.03258250f, 
    -0.05151596f, -0.03561824f, 0.15443666f, -0.02209623f, 0.06416146f, -0.05304015f, 0.14571510f, -0.04503673f, 
    0.00887096f, 0.05684884f, 0.00544410f, -0.05114687f, -0.18320967f, -0.05974269f, 0.04484287f, 0.04367504f, 
    0.13236745f, 0.02891809f, 0.05132332f, 0.03599200f, 0.11517893f, -0.04861702f, 0.11361066f, -0.07561652f, 
    -0.02422173f, -0.01715187f, -0.03286926f, -0.03809055f, 0.15151490f, -0.10461545f, -0.01905769f, 0.10019623f, 
    0.03516747f, 0.11916173f, 0.12371823f, -0.01946987f, 0.01092606f, 0.09324799f, -0.08458786f, -0.07731703f, 
    0.01643689f, 0.08055770f, -0.03717837f, -0.00903036f, -0.09441504f, 0.11693934f, 0.04773449f, 0.02773356f, 
    -0.11184406f, -0.08211202f, -0.17648157f, -0.12476955f, -0.04636814f, -0.03328109f, 0.03376110f, -0.09813446f, 
    -0.08196459f, 0.02399647f, 0.01512248f, 0.03234421f, -0.06723770f, 0.16896060f, -0.00584936f, 0.18328926f, 
    -0.00270989f, 0.10511199f, 0.07987753f, -0.01967376f, 0.04542900f, -0.03708027f, 0.11496966f, -0.02145148f, 
    -0.12418720f, 0.20311773f, 0.08898162f, -0.02062124f, 0.05559845f, -0.15364720f, 0.01499220f, 0.03038887f, 
    -0.07586001f, -0.01135757f, -0.03170516f, -0.02527553f, -0.42857945f, -0.00798496f, -0.04309253f, -0.06707496f, 
    0.05984245f, 0.10122414f, -0.04242638f, -0.10997013f, 0.01851021f, -0.02093780f, 0.00831202f, -0.04624524f, 
    0.22027172f, -0.17893077f, -0.06891615f, -0.07667581f, -0.00953995f, -0.07005525f, 0.07042708f, 0.06616477f, 
    -0.03031913f, 0.05091821f, -0.02444427f, -0.04086322f, -0.16717266f, 0.20189139f, 0.11130057f, -0.10070273f, 
    0.06959295f, -0.04631576f, 0.15558597f, -0.09972329f, 0.02459564f, -0.03475687f, -0.03658937f, 0.01143656f, 
    0.23286343f, 0.06971025f, -0.02635664f, 0.10085385f, -0.07859840f, -0.04134972f, 0.00188249f, 0.05568253f, 
    -0.04800851f, 0.10920211f, -0.10586940f, 0.12650114f, 0.18737094f, 0.06241284f, -0.12055935f, -0.11331829f, 
    -0.00246111f, -0.04288126f, 0.02797693f, -0.04423668f, -0.10706630f, 0.02427670f, 0.00032680f, 0.06803484f, 
    0.25284818f, 0.15074226f, 0.01089088f, 0.02274725f, 0.00631496f, 0.05224584f, -0.00403912f, 0.00328808f, 
    -0.06349313f, -0.03005457f, -0.12237083f, 0.01481595f, -0.13827680f, -0.09128603f, -0.00938827f, 0.03347313f, 
    0.17144132f, 0.05870509f, 0.00197542f, 0.00163163f, -0.01096505f, 0.00617410f, 0.05145555f, 0.17962611f, 
    0.13752340f, -0.05961168f, 0.08396958f, 0.08958318f, 0.01345034f, 0.02027297f, 0.08406399f, 0.05091873f, 
    0.01212535f, 0.06671689f, -0.02556003f, 0.00985474f, -0.39591119f, 0.35057884f, -0.02585860f, 0.05123406f, 
    0.01736558f, 0.10550831f, 0.06725020f, 0.04779489f, 0.09059315f, 0.08127729f, -0.10182288f, 0.08903009f, 
    0.05559918f, -0.21485746f, -0.01507068f, 0.28057751f, -0.03487998f, -0.00390831f, -0.02796001f, 0.00999880f, 
    -0.10066888f, -0.01028887f, 0.13151683f, -0.03694564f, -0.05723387f, -0.07459373f, 0.14038305f, 0.02934391f, 
    -0.08856864f, -0.04414239f, 0.01553880f, -0.03905438f, -0.02892908f, 0.20798151f, 0.05229337f, 0.09082688f, 
    0.29033923f, 0.03776454f, 0.10171415f, -0.15786691f, 0.00338719f, -0.00556042f, -0.00456394f, -0.03582359f, 
    -0.09517542f, 0.06213985f, 0.07992708f, 0.08127864f, -0.21014446f, 0.17218378f, 0.04639984f, -0.02557331f, 
    0.28381565f, -0.04415410f, 0.01887905f, -0.18082514f, -0.06362015f, -0.02309650f, 0.09580072f, 0.00326023f, 
    -0.22701718f, 0.11116288f, 0.03973695f, -0.01964125f, 0.05335009f, -0.03883129f, -0.04487672f, -0.10059328f, 
    0.00667586f, -0.08236647f, -0.23367248f, -0.17214325f, -0.17103340f, 0.06992185f, 0.06419611f, 0.11065374f, 
    -0.04833857f, -0.02264669f, -0.02375565f, -0.00054022f, 0.19773419f, 0.17999317f, 0.09847217f, 0.05899281f, 
    0.18052201f, -0.04014076f, 0.05113912f, -0.20234978f, 0.05013882f, -0.09357346f, 0.02660675f, 0.07368331f, 
    -0.03387577f, 0.03906939f, 0.05553139f, 0.00619742f, 0.21342134f, 0.13991106f, 0.05475538f, -0.06562933f, 
    0.09732716f, -0.06395660f, -0.07220962f, -0.18014346f, -0.02963685f, -0.05391326f, 0.08175891f, 0.06691466f, 
    0.02495430f, -0.10153614f, -0.15710863f, -0.00748316f, 0.16969374f, 0.07623180f, -0.06791402f, -0.12113147f, 
    -0.18985397f, -0.00055674f, 0.03838938f, 0.01302327f, -0.37386248f, 0.14018537f, 0.13245410f, 0.02754814f, 
    -0.00900717f, -0.07440224f, -0.14058048f, -0.10104574f, 0.04601900f, 0.05498099f, -0.10887415f, -0.00480410f, 
    0.24345475f, -0.16957946f, -0.03842445f, 0.15266246f, 0.21103925f, -0.10043179f, -0.10099336f, -0.00131814f, 
    0.05919155f, -0.05881834f, 0.08849718f, 0.03538499f, -0.05167342f, 0.11227793f, -0.00884754f, -0.08778919f, 
    -0.11096141f, 0.03574530f, -0.04182082f, -0.10245285f, -0.05096347f, 0.01276382f, -0.04383037f, 0.06839857f, 
    -0.22315527f, 0.02082524f, -0.23254636f, 0.02677302f, -0.02420080f, 0.21789321f, -0.00762745f, 0.04183165f, 
    -0.01975821f, 0.11018822f, 0.07926679f, 0.05502891f, 0.10947375f, 0.16020116f, 0.09044298f, 0.20186725f, 
    -0.13152198f, 0.04842968f, 0.05884904f, 0.13009836f, 0.10171647f, -0.04749044f, 0.07835506f, 0.03369751f, 
    -0.00123948f, -0.18018655f, 0.11771624f, 0.00084387f, 0.02600510f, 0.12045027f, 0.12289312f, -0.09257352f, 
    0.01468993f, 0.06966988f, 0.16360694f, 0.07375829f, -0.02178230f, 0.19109724f, 0.06261954f, 0.06067741f, 
    -0.09897405f, -0.08367175f, -0.16437252f, -0.06084611f, 0.04473694f, -0.08964370f, -0.03601953f, 0.03952213f, 
    0.04733499f, 0.03991390f, 0.05828618f, 0.08872688f, 0.00040575f, 0.00769908f, 0.21412653f, 0.12786567f, 
    0.08069255f, 0.11007191f, -0.02527297f, 0.20044488f, 0.00604642f, -0.00175319f, -0.13767083f, 0.01147930f, 
    -0.02198460f, -0.06640673f, -0.03655821f, -0.10278367f, 0.11109504f, -0.14970884f, 0.09849615f, 0.07094214f, 
    -0.17310132f, -0.21863991f, 0.17834030f, 0.11138857f, 0.08634055f, 0.13408244f, -0.01221311f, 0.01568807f, 
    -0.06077151f, 0.15846379f, -0.07499161f, -0.08710561f, 0.07275800f, 0.22206643f, -0.10379589f, 0.04219039f, 
    -0.11419473f, 0.13854744f, -0.03939738f, -0.05265822f, 0.06798770f, -0.02216306f, -0.02054329f, 0.03595237f, 
    -0.00884760f, 0.06734747f, -0.03182372f, 0.14535624f, -0.06221283f, 0.04812621f, -0.10626525f, 0.05596228f, 
    -0.02722081f, 0.04801793f, 0.15237601f, 0.14476873f, 0.13037300f, 0.34537071f, -0.03541278f, -0.07640515f, 
    0.05682884f, 0.00621112f, 0.03354384f, -0.08608219f, -0.06825058f, -0.22918399f, 0.04738121f, -0.04800319f, 
    0.09949454f, 0.13269547f, 0.26144230f, -0.24247965f, -0.00294238f, 0.04006929f, 0.14784852f, 0.04643429f, 
    0.03094140f, 0.04824585f, -0.05698134f, -0.06248183f, -0.44497037f, 0.15476139f, -0.01711393f, 0.10949505f, 
    -0.03689416f, 0.05490352f, 0.02045487f, 0.04260319f, 0.00404428f, -0.01792554f, 0.12337043f, 0.08643541f, 
    -0.24589451f, -0.28084481f, -0.08357101f, -0.04626024f, 0.08790503f, -0.17127593f, 0.03712331f, -0.01214887f, 
    0.05149209f, -0.07542807f, -0.07764992f, -0.06323758f, 0.19838376f, 0.04850016f, -0.22079989f, 0.12131074f, 
    0.00410090f, -0.02038346f, 0.23882975f, -0.04508857f, -0.01218792f, -0.12397194f, -0.01491650f, -0.13466702f, 
    -0.49455628f, 0.10061594f, -0.02099677f, 0.21286337f, -0.08088395f, -0.02834873f, -0.06544268f, -0.06597580f, 
    0.06568966f, -0.10075273f, 0.01561448f, -0.06868509f, -0.29695973f, -0.31456637f, -0.08240288f, 0.21959560f, 
    0.07029396f, 0.10467023f, -0.03957850f, 0.03253067f, 0.06637325f, 0.16623259f, -0.02098669f, -0.06234375f, 
    0.00041022f, 0.02397778f, 0.02754021f, 0.05137001f, -0.05177349f, -0.04439250f, 0.01909610f, 0.00325152f, 
    0.03196663f, 0.03241212f, 0.00552575f, -0.07665765f, -0.06127736f, 0.04839440f, -0.03658544f, -0.07708482f, 
    0.01310855f, -0.03265290f, 0.04052474f, -0.04372473f, -0.07175840f, -0.02474324f, 0.01713041f, 0.05696793f, 
    -0.06451327f, -0.06078602f, 0.01821430f, -0.05530633f, 0.06573720f, 0.06355947f, 0.05470213f, -0.05280483f, 
    -0.06017355f, -0.00150917f, -0.02167699f, -0.07386410f, -0.03466777f, 0.02432332f, 0.05443210f, 0.04537091f, 
    -0.02798228f, -0.03872423f, 0.01219815f, 0.03533994f, 0.04729446f, -0.01270555f, -0.06188858f, 0.00754548f, 
    0.04506037f, 0.00074995f, -0.02753694f, 0.04076335f, 0.07137574f, -0.03960560f, -0.00255014f, -0.05649120f, 
    0.06498026f, 0.00484911f, -0.00035614f, -0.02158333f, -0.07097427f, 0.05983371f, -0.05680925f, -0.02865697f, 
    -0.06713749f, -0.05682886f, -0.03495291f, -0.04462783f, 0.05457688f, 0.00927220f, 0.05620522f, -0.06437217f, 
    0.06599686f, 0.01096143f, -0.04959951f, 0.02899852f, 0.03754559f, -0.07724197f, -0.05735571f, 0.05971615f, 
    -0.04871402f, 0.01058307f, -0.04613553f, 0.04847409f, -0.04175543f, 0.03381997f, 0.00982667f, -0.05792883f, 
    -0.06560411f, 0.05568321f, -0.06036713f, 0.05279394f, -0.03927103f, -0.07125132f, 0.05548144f, 0.01424255f, 
    -0.00241782f, -0.06203304f, -0.04373915f, 0.06177558f, 0.04393007f, -0.07450928f, -0.01737838f, 0.06236002f, 
    -0.02762261f, 0.04459872f, -0.02151708f, -0.03626793f, -0.01207026f, 0.04361256f, -0.06008737f, -0.06405610f, 
    -0.03664828f, -0.02587542f, -0.03599258f, -0.03535372f, 0.01508907f, -0.02964498f, -0.00449189f, -0.01914486f, 
    -0.01238898f, -0.07466009f, -0.03707232f, -0.02931529f, 0.03704213f, -0.00874749f, -0.02660420f, 0.05760787f, 
    -0.03836412f, -0.00075042f, -0.00352559f, 0.05403730f, -0.07762542f, -0.00005068f, -0.05451946f, -0.03441128f, 
    -0.00101407f, 0.02507059f, -0.03167275f, 0.00784984f, -0.06448385f, -0.04699065f, -0.02266981f, -0.02435781f, 
    0.05475440f, -0.01540274f, 0.00567214f, 0.00487622f, 0.00704552f, 0.06361558f, 0.05403612f, -0.03598372f, 
    0.04779186f, 0.00159087f, -0.07178587f, 0.05111682f, -0.06609882f, 0.06512181f, -0.05613091f, -0.03983815f, 
    -0.07154792f, 0.04735367f, 0.05591783f, -0.04230149f, 0.01454465f, -0.06310093f, 0.01411241f, 0.01862479f, 
    -0.04972944f, 0.02310926f, -0.04724880f, -0.02224072f, 0.04427456f, 0.06356277f, -0.06887323f, -0.03942306f, 
    0.00938383f, -0.03417722f, 0.03645116f, -0.07232325f, 0.00933997f, 0.06582582f, -0.05526653f, -0.06235785f, 
    0.00600193f, -0.01557859f, -0.07119598f, -0.01613300f, -0.04753949f, 0.02111297f, -0.06313326f, 0.04049218f, 
    -0.19848903f, -0.27986482f, -0.00409770f, -0.12459721f, -0.04294877f, 0.26243454f, 0.03452255f, 0.04392252f, 
    0.06880841f, 0.02685381f, 0.00176310f, 0.11737258f, 0.26301956f, 0.15784918f, -0.06650342f, 0.06269854f, 
    -0.12828907f, 0.10657454f, 0.12402290f, 0.04122967f, 0.01473350f, 0.04294153f, 0.09180445f, -0.12425972f, 
    0.07197900f, 0.06717120f, 0.25033709f, 0.11913036f, -0.05077360f, 0.12822384f, -0.06351737f, -0.14991650f, 
    0.02069408f, -0.01839732f, 0.00197940f, -0.00068234f, -0.07889124f, -0.00820777f, 0.09271489f, 0.01059587f, 
    -0.08440057f, -0.03817903f, 0.10101404f, -0.03848063f, 0.05085358f, -0.02632222f, -0.02314313f, -0.05282697f, 
    -0.03823067f, 0.05497176f, 0.11581646f, 0.09946323f, -0.08718692f, -0.04930440f, 0.10569550f, 0.01609176f, 
    0.03921346f, 0.05182404f, 0.04114472f, -0.00388529f, 0.02074199f, -0.01372553f, -0.01601987f, -0.08660249f, 
    0.03626420f, 0.14060161f, -0.09297339f, 0.06545036f, 0.11624794f, -0.15238269f, 0.05044345f, 0.05589072f, 
    -0.08912860f, 0.00994032f, 0.14579630f, 0.08351010f, 0.01739918f, -0.03915864f, 0.04808382f, 0.09916323f, 
    0.06682133f, 0.11933738f, -0.12735131f, -0.06085770f, -0.04915244f, 0.03335553f, -0.12759501f, -0.08255788f, 
    -0.13933291f, -0.03422577f, 0.01555626f, 0.05788504f, 0.00241185f, -0.00129885f, 0.01115975f, -0.09675710f, 
    0.10254516f, 0.10447600f, -0.10478792f, -0.00305055f, 0.03065870f, -0.01528778f, -0.02342722f, 0.06897680f, 
    -0.12135550f, 0.00080160f, 0.06524762f, 0.13655570f, 0.20546958f, 0.14765275f, 0.07858694f, 0.04019322f, 
    0.03479584f, 0.13554004f, 0.15001512f, -0.11033802f, -0.08626543f, -0.06938619f, 0.04851969f, 0.04152932f, 
    -0.17538176f, 0.11637663f, 0.16713299f, 0.03495999f, 0.03635698f, 0.09842401f, 0.00675743f, -0.03438872f, 
    0.05269819f, 0.10075115f, 0.01446392f, 0.08817463f, -0.02776104f, 0.09568329f, -0.02143790f, -0.02093781f, 
    0.06098005f, 0.10477839f, 0.07846625f, 0.13553567f, 0.05817107f, 0.18894498f, 0.00489251f, 0.08613898f, 
    -0.22626498f, 0.00280288f, -0.05059203f, -0.17792432f, 0.06880311f, -0.17090073f, -0.00995041f, 0.00732263f, 
    0.12519448f, -0.03940492f, -0.04779917f, -0.03551325f, -0.18063186f, -0.05176923f, -0.20232370f, 0.07394207f, 
    0.03578687f, 0.14618549f, 0.09586401f, 0.03454978f, 0.11164647f, -0.09924422f, -0.08697193f, 0.02642391f, 
    -0.24695492f, 0.04762000f, 0.03692584f, 0.30063590f, -0.05621718f, -0.01661083f, -0.04703674f, -0.06679710f, 
    0.01431129f, 0.04742083f, 0.07969151f, -0.00055594f, -0.01277928f, -0.17306453f, -0.00791539f, 0.07415564f, 
    -0.04691915f, 0.01294808f, -0.01280129f, 0.06642568f, 0.04833216f, 0.20309921f, -0.01336668f, -0.03771026f, 
    0.52248007f, 0.26985994f, 0.04178731f, 0.02756801f, 0.04173985f, -0.00294896f, 0.10161324f, 0.02343266f, 
    -0.02896743f, -0.01641850f, 0.00924323f, -0.06748543f, -0.39138308f, -0.31155199f, 0.09225717f, -0.09716319f, 
    -0.06030551f, -0.21669385f, -0.08668926f, -0.02491362f, 0.06036951f, -0.00704827f, -0.12488856f, 0.18372814f, 
    -0.08229497f, 0.03176693f, -0.11142438f, -0.20091334f, 0.02531796f, -0.00460747f, -0.05389801f, 0.10856817f, 
    0.09606484f, 0.11720258f, 0.05529285f, 0.04912949f, -0.12185380f, 0.05312794f, 0.01443132f, 0.02399305f, 
    0.08793307f, 0.04889206f, 0.08652813f, 0.09538734f, -0.01692660f, 0.10139744f, -0.05031847f, 0.08879838f, 
    0.13094606f, -0.13767876f, -0.33443323f, -0.10347258f, 0.11926835f, 0.05580521f, -0.12152570f, 0.15849964f, 
    0.08965641f, 0.10693285f, -0.00043978f, -0.11299310f, 0.02440455f, 0.03103612f, -0.04509022f, -0.04508057f, 
    0.08357889f, -0.03678540f, 0.15658134f, 0.04120404f, -0.09908202f, 0.00262698f, 0.03630245f, 0.06709129f, 
    -0.01483760f, 0.12490276f, -0.12215611f, 0.03985946f, 0.01333916f, -0.14422411f, 0.11292158f, -0.03166688f, 
    0.09945226f, 0.03758851f, 0.08210236f, 0.13081810f, 0.26986548f, -0.01246767f, -0.06632313f, 0.10230439f, 
    0.19832906f, -0.01854152f, -0.10686705f, 0.00373937f, -0.02356976f, 0.12371407f, 0.08937653f, 0.06902615f, 
    -0.23003930f, -0.01578738f, -0.10631920f, 0.08844209f, 0.12001376f, 0.03275545f, 0.03123219f, -0.22939660f, 
    0.01190745f, 0.11623152f, -0.07410601f, -0.06671211f, -0.58506989f, -0.17686361f, 0.14536643f, 0.14740916f, 
    -0.03194644f, -0.10765606f, 0.11231615f, 0.18905292f, 0.25390941f, 0.10004928f, -0.01302047f, -0.01172627f, 
    0.33538371f, -0.32988703f, -0.29905105f, 0.10006502f, 0.03614630f, -0.13171680f, -0.01874704f, 0.02715568f, 
    0.01345194f, 0.04257289f, 0.03331977f, -0.02715945f, 0.08323926f, -0.21967024f, -0.00574458f, -0.25442156f, 
    -0.00184564f, -0.09698591f, -0.09852172f, 0.00000423f, 0.01283710f, -0.03201666f, 0.03208556f, -0.05984159f, 
    0.50787491f, 0.09671713f, 0.12142196f, -0.08387769f, 0.09659825f, 0.04027793f, 0.11162105f, -0.01067246f, 
    -0.06762156f, 0.08763851f, 0.09685273f, -0.01515070f, -0.07023109f, 0.11464590f, -0.14914386f, 0.01132883f, 
    -0.00326655f, -0.06007003f, -0.00018191f, -0.13882920f, 0.09967896f, 0.13285106f, 0.11340240f, 0.08859295f, 
    0.59535915f, 0.04838833f, 0.02208443f, -0.27764031f, 0.07198755f, -0.03054793f, 0.11706860f, 0.02960054f, 
    0.02926777f, -0.04687417f, -0.02192236f, 0.13626042f, 0.18543774f, 0.10875005f, 0.11690790f, -0.08003342f, 
    0.03457652f, -0.00711693f, 0.02151992f, -0.09106220f, -0.14197041f, 0.01830542f, 0.07540587f, -0.09522969f, 
    0.04108845f, 0.03079537f, 0.02444939f, -0.06834191f, -0.03388587f, 0.02851250f, 0.05501445f, 0.01146629f, 
    0.04895088f, 0.05680196f, -0.05371213f, 0.02333394f, 0.00137115f, -0.00611242f, -0.03946882f, -0.03298423f, 
    0.04676874f, -0.05477751f, -0.03081933f, -0.03230543f, -0.03674809f, -0.03926095f, -0.07168302f, 0.04588909f, 
    0.01051850f, -0.04137449f, 0.06814538f, -0.01369825f, 0.05817676f, -0.01459737f, 0.00073265f, -0.06046914f, 
    -0.06226908f, 0.04253813f, -0.04244564f, -0.06184928f, 0.03163058f, -0.02388022f, 0.03760697f, -0.07283613f, 
    -0.06357415f, -0.00296313f, -0.06642593f, -0.01785737f, 0.03662351f, -0.05993899f, -0.01390750f, -0.00585750f, 
    -0.02460070f, 0.03929545f, -0.04895893f, 0.04522165f, 0.00148604f, -0.01107061f, 0.00006036f, -0.05260023f, 
    -0.01842429f, -0.06887966f, -0.00630663f, -0.00843787f, 0.04289952f, 0.02044419f, -0.07519251f, -0.02245382f, 
    0.04778537f, 0.01451103f, -0.05865005f, -0.03755602f, -0.05471620f, -0.05111638f, -0.06640426f, 0.02659266f, 
    0.02970555f, -0.02022181f, 0.02810139f, 0.00362962f, -0.06309415f, 0.01339745f, 0.04074856f, -0.05112155f, 
    0.05818626f, 0.05013189f, -0.01780538f, -0.01241085f, -0.05362732f, 0.04194726f, -0.02215266f, 0.01704983f, 
    0.00281390f, 0.00478948f, 0.05953756f, -0.02915784f, 0.02851254f, 0.01404725f, -0.02492316f, -0.06043194f, 
    0.04011010f, -0.02701386f, 0.00346025f, -0.08522977f, 0.03793518f, -0.07997809f, -0.00024176f, 0.05062732f, 
    -0.00456994f, -0.06918877f, 0.01168967f, 0.02669073f, 0.04830950f, 0.02842031f, -0.03384516f, -0.04963842f, 
    0.04369301f, 0.00321757f, -0.00495179f, -0.03104010f, 0.04660190f, -0.01756912f, -0.03851979f, 0.01984763f, 
    -0.03913897f, -0.04069531f, -0.06225571f, -0.03919771f, -0.03992100f, -0.00142273f, -0.02216725f, 0.00344716f, 
    -0.02249552f, 0.06224844f, -0.03728026f, 0.02571890f, -0.05797338f, -0.02724958f, -0.05212523f, -0.05833983f, 
    -0.00014770f, -0.06956770f, -0.01188777f, -0.07280918f, 0.03793838f, 0.06934659f, 0.02600402f, 0.06051149f, 
    -0.00789916f, -0.04395422f, 0.02223724f, -0.03449228f, -0.07121944f, -0.01885688f, 0.05886294f, 0.02437657f, 
    0.00103726f, 0.02889992f, -0.00773198f, 0.02427712f, 0.00331738f, 0.03366128f, 0.00085951f, 0.02735005f, 
    -0.07580957f, -0.02662488f, 0.00883985f, -0.03883103f, 0.06163297f, -0.06003141f, 0.06849896f, -0.02810510f, 
    0.03719680f, 0.05232240f, -0.03666778f, -0.08799516f, 0.05996924f, 0.04113783f, 0.01098020f, -0.02366330f, 
    0.04718644f, -0.03626324f, -0.07160710f, -0.01358293f, -0.04409169f, 0.03348305f, 0.03942746f, -0.07748071f, 
    -0.06567327f, -0.03235861f, 0.00626732f, -0.05289416f, 0.00908696f, -0.01439175f, 0.00789295f, -0.05054879f, 
    -0.21599203f, 0.04519768f, -0.28247863f, 0.08936852f, -0.12123746f, 0.16545591f, 0.02076016f, 0.10883679f, 
    -0.05657785f, 0.03606669f, 0.00223875f, 0.01186591f, -0.08254788f, 0.19205643f, -0.08696097f, 0.02037888f, 
    0.03458907f, 0.02536213f, 0.11385335f, 0.00170604f, -0.01032831f, 0.01970945f, 0.07182015f, -0.06457192f, 
    0.16874579f, -0.18987313f, 0.15837015f, 0.23188014f, 0.08904060f, 0.11362015f, 0.02744078f, -0.08064417f, 
    0.03562560f, 0.04278817f, -0.02671698f, -0.10500699f, -0.34778813f, 0.31379610f, 0.03565300f, 0.05318119f, 
    -0.04838849f, -0.00263032f, -0.01928126f, -0.04633513f, 0.00446970f, 0.00785406f, 0.04550752f, 0.00081182f, 
    -0.28334525f, 0.04892692f, 0.12698349f, 0.17029026f, 0.03309764f, -0.03410748f, 0.09921223f, -0.14114302f, 
    0.02889440f, 0.09676406f, 0.06331865f, 0.10758571f, 0.10969289f, -0.02574921f, 0.10481060f, -0.10896836f, 
    -0.09068853f, 0.06351808f, 0.07068788f, -0.00078640f, 0.06751809f, -0.03841741f, 0.09260390f, -0.11072239f, 
    0.10055695f, -0.05857800f, 0.26124287f, 0.01874650f, 0.10130379f, 0.08827081f, 0.11951905f, 0.00332629f, 
    -0.06514178f, 0.17034273f, 0.04072694f, -0.06407475f, 0.06216706f, 0.04146493f, -0.01692308f, -0.13066831f, 
    0.02704711f, 0.05914253f, -0.01804559f, 0.02258555f, -0.01387787f, 0.14022383f, -0.07025972f, 0.00583202f, 
    -0.08884236f, -0.00420919f, -0.07702448f, -0.20789437f, 0.08687886f, -0.07929541f, -0.05297711f, 0.01411198f, 
    0.02961191f, 0.15081574f, -0.04008199f, 0.15992795f, 0.28133622f, 0.11169648f, 0.00754905f, 0.05770439f, 
    -0.03521270f, 0.08701308f, -0.04151717f, -0.05547782f, -0.05219999f, 0.01716154f, 0.04308766f, 0.00110482f, 
    0.50209081f, 0.05824120f, 0.19677033f, -0.31976387f, 0.19054583f, 0.03019352f, 0.09372091f, 0.05891434f, 
    0.02623499f, 0.10387491f, 0.00006668f, -0.07598372f, -0.15611883f, 0.13022445f, 0.01047444f, 0.00588459f, 
    -0.09524511f, 0.01914051f, 0.19090965f, -0.02269918f, 0.04863336f, -0.05617134f, 0.08290410f, 0.07980185f, 
    0.01500111f, -0.08070096f, 0.06130413f, 0.03370668f, 0.14366931f, -0.08052580f, 0.03112308f, -0.06211438f, 
    0.02659442f, 0.01732609f, -0.03640892f, 0.02249757f, -0.26640952f, 0.04304584f, 0.13673554f, -0.09432304f, 
    -0.04904875f, 0.10715742f, 0.09430756f, 0.01609586f, -0.00715343f, -0.06812413f, -0.06988842f, -0.07591601f, 
    -0.09361956f, 0.09818097f, 0.05535503f, 0.19648497f, 0.06482048f, -0.04151659f, -0.07561064f, 0.05230404f, 
    -0.06645391f, 0.07984874f, 0.14193358f, -0.12801704f, -0.10584245f, 0.15517376f, -0.16122274f, 0.06424545f, 
    0.00125865f, 0.14715774f, -0.00549549f, 0.01599877f, 0.11480274f, 0.05220943f, -0.05625947f, 0.03754050f, 
    0.13589634f, 0.17202185f, 0.02835445f, -0.16772799f, -0.05292827f, 0.12770686f, 0.02772449f, 0.11691947f, 
    -0.06859547f, -0.00632833f, 0.10587846f, -0.00851571f, 0.01679357f, -0.02822005f, 0.09164494f, -0.09670524f, 
    -0.23290718f, 0.05025018f, 0.00544397f, 0.04211449f, 0.01720422f, -0.11525679f, -0.02753805f, -0.01321599f, 
    0.14898977f, 0.19697723f, -0.14413340f, -0.13171265f, -0.02683583f, 0.12259021f, 0.08826404f, -0.03762414f, 
    0.09529775f, 0.06326203f, -0.00367456f, -0.06559554f, 0.08960041f, 0.00913505f, 0.02182745f, 0.22547531f, 
    0.08205152f, -0.10273193f, -0.00357748f, 0.02114585f, -0.08630078f, 0.00127315f, -0.00916647f, 0.00058237f, 
    -0.02097967f, -0.20101625f, -0.22633401f, -0.10838865f, -0.02270115f, -0.00648522f, 0.06447612f, 0.05265119f, 
    -0.11538571f, 0.13227694f, 0.14986761f, 0.00537133f, 0.18404016f, 0.15642945f, 0.10392088f, -0.01826276f, 
    0.08647515f, -0.20088263f, 0.03434812f, 0.14082320f, -0.04355844f, -0.15131815f, 0.07523014f, -0.04011006f, 
    -0.01213191f, 0.19073729f, 0.03444301f, 0.10758124f, -0.10148574f, 0.06107271f, 0.09104797f, 0.07793481f, 
    -0.02224065f, 0.02876532f, -0.02069831f, 0.04428383f, 0.24143365f, -0.18020663f, -0.11521543f, 0.03944334f, 
    0.12448087f, -0.01680242f, -0.06290784f, -0.04647369f, -0.03727141f, 0.10018001f, 0.05089418f, 0.06405503f, 
    -0.30427501f, -0.20810363f, -0.20364155f, -0.03971983f, 0.21647045f, -0.09391993f, -0.01751741f, -0.19337419f, 
    0.01466430f, 0.15834905f, -0.03786073f, 0.05954139f, 0.23809224f, -0.06474274f, 0.00888628f, 0.20829478f, 
    -0.11006665f, -0.01230516f, -0.07038601f, 0.05762482f, -0.00519281f, 0.01068898f, 0.01690068f, -0.00312613f, 
    0.22900765f, -0.06983075f, -0.08031961f, -0.16588886f, 0.11632351f, -0.03138828f, 0.05373824f, 0.04223055f, 
    0.01293731f, 0.08008642f, -0.02300889f, 0.01592805f, 0.09551092f, -0.11738104f, 0.03853524f, 0.11432450f, 
    -0.01337234f, -0.03253412f, 0.05570293f, 0.13897303f, -0.02219020f, -0.07677830f, 0.09922351f, -0.03409006f, 
    0.03781983f, -0.11925239f, 0.11359690f, 0.14161190f, 0.02807762f, 0.09714831f, 0.06967463f, 0.02246566f, 
    -0.04095489f, 0.04548787f, 0.11026331f, -0.09212544f, -0.32366937f, -0.03979992f, -0.06252117f, -0.03065061f, 
    0.00070076f, 0.02569844f, -0.01081548f, -0.09465962f, 0.09124620f, -0.03543358f, -0.01190029f, 0.07158962f, 
    0.34841493f, -0.06156218f, 0.16696845f, 0.00787765f, 0.07446180f, -0.03520744f, -0.02435330f, 0.02296005f, 
    0.09860109f, 0.04957676f, 0.15819843f, -0.01672836f, 0.06839665f, 0.08967760f, -0.06684339f, -0.02724284f, 
    0.09646434f, 0.15617119f, 0.13917458f, -0.05148605f, 0.01230842f, -0.02771468f, -0.01182841f, 0.00760021f, 
    -0.17835343f, -0.07867657f, 0.12681794f, 0.11153354f, -0.05791861f, 0.10299733f, 0.09760273f, 0.09639674f, 
    0.02878095f, -0.02124928f, 0.05314614f, 0.15776686f, 0.07573912f, 0.07446450f, -0.13311808f, -0.17804481f, 
    -0.18250373f, 0.00634030f, -0.03583726f, -0.02421363f, -0.13717610f, -0.01035363f, 0.06924612f, -0.10234112f, 
    0.09261212f, 0.12503427f, 0.08962713f, -0.06967810f, 0.04684560f, 0.00706151f, -0.03433932f, 0.16982618f, 
    0.00263532f, -0.06612580f, -0.04293999f, 0.00849190f, -0.02897318f, -0.13889638f, 0.06555421f, 0.04224926f, 
    -0.01571684f, 0.04422826f, 0.11674459f, 0.00191243f, -0.08099744f, -0.00204161f, 0.06167307f, -0.03435701f, 
    -0.03656618f, -0.02446035f, 0.01402732f, 0.07729670f, -0.01637784f, 0.08922914f, 0.04671067f, 0.06761273f, 
    0.05491582f, 0.06817788f, 0.06623009f, -0.13065214f, 0.19467376f, -0.13492817f, 0.03810868f, 0.11881780f, 
    0.02642186f, 0.05840366f, -0.02866869f, 0.10218156f, 0.04516196f, -0.04586636f, -0.00147035f, -0.01194062f, 
    -0.04971682f, 0.27248073f, -0.05983948f, -0.06914574f, 0.05807853f, -0.01156758f, 0.03888628f, -0.03845138f, 
    0.07907945f, 0.01993846f, 0.05105671f, -0.07310395f, 0.02147697f, 0.03441465f, -0.21129014f, -0.28921431f, 
    -0.02238169f, -0.00477259f, -0.03804499f, 0.12773976f, -0.07087211f, 0.10043831f, 0.10085311f, 0.00192253f, 
    -0.03743739f, 0.03568060f, -0.08197635f, -0.28613174f, 0.13483296f, -0.00143418f, -0.04885826f, -0.02554356f, 
    -0.09893307f, 0.03890979f, 0.06314229f, 0.07506432f, 0.04941741f, -0.27251178f, 0.00156856f, 0.25428936f, 
    -0.04875984f, 0.10647961f, -0.04664537f, -0.08931101f, 0.09635355f, 0.00599219f, 0.08146219f, -0.02785324f, 
    0.43509588f, -0.30658719f, -0.01664656f, 0.23002066f, 0.04041023f, -0.00867982f, 0.04570338f, -0.16150449f, 
    -0.05807025f, 0.06412943f, 0.06483159f, 0.03953534f, 0.33384228f, -0.18859532f, 0.01462032f, -0.14383850f, 
    0.09549733f, 0.04728947f, 0.01709924f, 0.05966149f, 0.04279350f, 0.15334672f, 0.04943082f, 0.07233324f, 
    0.01765907f, 0.18966316f, 0.09443486f, -0.01609432f, 0.07595281f, -0.02534769f, 0.04598489f, -0.02571584f, 
    0.12863685f, 0.12001075f, -0.06122026f, 0.00612632f, -0.49275255f, -0.04608433f, 0.03680588f, 0.05224593f, 
    -0.00142273f, -0.02306536f, 0.04485290f, 0.12448993f, 0.14749406f, -0.07105104f, -0.10919792f, 0.07217340f, 
    0.12014177f, 0.03206566f, 0.08929096f, 0.15505087f, 0.09672610f, 0.21621098f, 0.03621679f, 0.12857242f, 
    -0.02136211f, -0.05265590f, 0.03731893f, -0.11796659f, 0.28240311f, 0.31311068f, 0.03133278f, -0.13920972f, 
    0.06622723f, -0.17691657f, -0.08956509f, 0.13811857f, 0.00248774f, 0.09037760f, -0.17850642f, 0.04191593f, 
    0.32054648f, -0.01224949f, 0.25802931f, -0.18807437f, 0.03777364f, 0.00015363f, 0.00753255f, 0.00475026f, 
    0.01489733f, -0.02652649f, 0.13758500f, 0.11129747f, 0.22205445f, -0.13131811f, -0.03084037f, 0.02878276f, 
    -0.04714071f, 0.02420405f, -0.00519506f, 0.07283679f, 0.03236366f, 0.03700351f, -0.05285944f, 0.10701742f, 
    0.18940218f, 0.02351629f, 0.07286140f, -0.00025635f, -0.10407760f, -0.00110349f, 0.01249036f, -0.03303052f, 
    0.23199454f, -0.05676983f, 0.15398957f, -0.01509554f, 0.37249792f, -0.14137174f, -0.04902100f, 0.12736864f, 
    0.03777092f, -0.09206080f, -0.04415305f, 0.05973323f, -0.04658240f, 0.03027680f, -0.05459638f, 0.06822306f, 
    0.08413015f, -0.02858801f, -0.11914562f, -0.01421196f, 0.04467560f, -0.00734631f, -0.03593803f, -0.02282927f, 
    -0.03479240f, 0.12434851f, 0.08022594f, 0.06049042f, -0.18311328f, 0.13292742f, -0.05691524f, -0.04586857f, 
    0.09979618f, 0.05980711f, -0.08977957f, 0.00354768f, -0.09637534f, -0.11579189f, 0.04517451f, 0.05783015f, 
    -0.18015680f, -0.03178278f, -0.08702709f, 0.14041859f, 0.01247717f, 0.02932199f, -0.17587768f, 0.09965552f, 
    0.14256579f, -0.04953252f, -0.07253249f, 0.10018341f, 0.14168458f, 0.02048737f, 0.04849445f, 0.19319415f, 
    -0.01606551f, 0.00461581f, 0.02122631f, 0.04180034f, -0.00178548f, -0.04444706f, -0.00179562f, 0.00159234f, 
    0.16218951f, -0.00083489f, -0.02538927f, 0.06062135f, 0.01756095f, 0.12778284f, 0.01756977f, 0.04796521f, 
    0.05837571f, 0.08389252f, 0.04073259f, 0.01796159f, 0.08643344f, -0.10179406f, -0.02822688f, 0.07581643f, 
    0.00678260f, 0.09234010f, 0.10396002f, -0.05706201f, -0.04080053f, -0.03914811f, 0.01648164f, 0.05694297f, 
    -0.67704123f, 0.32576180f, -0.16187187f, 0.02571694f, -0.03106852f, -0.02413416f, -0.08808588f, -0.00162205f, 
    0.00236209f, -0.00625500f, -0.02508727f, 0.00768659f, -0.45699638f, -0.05203742f, 0.00014001f, 0.08861364f, 
    -0.06027175f, -0.04667002f, -0.05478219f, 0.16833736f, -0.02399219f, 0.07355934f, 0.03647222f, -0.12678258f, 
    0.16552015f, -0.15781440f, 0.05291149f, -0.02416229f, -0.05840170f, 0.10166005f, 0.05231321f, 0.04337390f, 
    0.00302045f, -0.01694655f, 0.04765615f, -0.11693761f, 0.38406226f, 0.04328150f, -0.06241700f, -0.01023628f, 
    0.05475951f, 0.07871278f, 0.03039200f, -0.02821771f, 0.02043218f, 0.05836576f, 0.04154190f, 0.04816561f, 
    0.11721022f, -0.04952625f, 0.11291160f, -0.19768836f, -0.11611810f, -0.05486357f, -0.08856508f, -0.04387487f, 
    0.14639197f, 0.00198084f, -0.08945107f, 0.02931369f, 0.10597313f, -0.20088395f, 0.06301174f, 0.13693760f, 
    -0.02041534f, 0.00452539f, 0.10058090f, -0.09920981f, -0.00767880f, -0.10443367f, -0.00450074f, -0.00947207f, 
    -0.22078899f, -0.18522348f, 0.00109577f, 0.12622456f, 0.07724760f, -0.10025097f, 0.03143690f, -0.11772738f, 
    0.13116235f, -0.02166621f, 0.05228082f, 0.00615084f, 0.08068620f, 0.28823382f, -0.02849466f, -0.17065148f, 
    -0.02618956f, 0.02606546f, -0.01563489f, -0.03914108f, -0.02786158f, 0.11129590f, 0.00758525f, 0.04433739f, 
    -0.13971962f, 0.22266161f, -0.03287616f, 0.12707028f, 0.02545163f, -0.01054199f, 0.04103811f, -0.01954122f, 
    0.05920598f, -0.06938450f, 0.01651469f, 0.04748711f, 0.16677272f, -0.25198361f, -0.13357621f, -0.07051873f, 
    0.00845690f, -0.00727788f, 0.01994429f, -0.07491695f, 0.10123995f, 0.13158666f, 0.01318673f, -0.03221682f, 
    -0.10338946f, 0.28869483f, 0.28406206f, -0.10771748f, 0.03666198f, 0.00693487f, -0.09652632f, -0.03146526f, 
    0.05494635f, 0.00042360f, -0.06918614f, 0.03123279f, 0.03206740f, -0.04675174f, -0.07769752f, -0.01116690f, 
    -0.12344294f, -0.00131916f, 0.02211418f, -0.12880021f, 0.04266253f, 0.13605611f, -0.00898277f, 0.10423805f, 
    -0.09110738f, 0.07638232f, -0.15105946f, 0.12005258f, -0.04672239f, 0.01790025f, -0.02804532f, -0.14287905f, 
    0.11475439f, -0.05944506f, 0.13294561f, 0.00474864f, -0.03086982f, -0.22589765f, 0.14091016f, 0.29003385f, 
    -0.12197611f, 0.03800036f, 0.11093979f, 0.11733685f, 0.08793254f, -0.02158249f, 0.01326440f, 0.04742087f, 
    0.35782060f, -0.17452382f, 0.10292058f, 0.27308261f, -0.19457145f, 0.06155268f, 0.02096481f, 0.07750487f, 
    0.07149442f, -0.02070057f, -0.03519868f, -0.04544516f, 0.26544794f, -0.10512582f, 0.07096003f, -0.03502889f, 
    0.10176326f, -0.02992080f, 0.06348959f, -0.04016658f, 0.03406731f, 0.03772325f, 0.01278628f, -0.03438495f, 
    -0.14877036f, 0.04253991f, -0.05863750f, 0.23431826f, -0.13938135f, 0.06415388f, -0.04168637f, 0.01845395f, 
    0.07652450f, -0.01926893f, 0.04545912f, -0.02132740f, 0.21541385f, 0.01035776f, -0.06179576f, -0.06769188f, 
    -0.08695056f, 0.06432276f, 0.00406403f, -0.05822356f, 0.06248975f, -0.04392123f, 0.04335638f, -0.07654621f, 
    0.02893492f, 0.14590205f, -0.01222906f, -0.03506172f, -0.06562112f, -0.11052188f, -0.03555892f, 0.08223081f, 
    0.08893408f, -0.03939094f, 0.08432575f, 0.04107374f, 0.33227509f, -0.18053265f, 0.04085350f, 0.07544006f, 
    -0.02137107f, -0.06293801f, -0.06494240f, 0.14201546f, -0.03534594f, 0.04818045f, -0.04362277f, -0.03415242f, 
    -0.28727481f, 0.07205215f, -0.15000874f, -0.01515795f, -0.03468849f, 0.06239983f, 0.04661788f, -0.01170904f, 
    0.00635413f, 0.05175333f, -0.02654807f, 0.12524451f, 0.23566583f, 0.08294595f, -0.02148017f, 0.18696597f, 
    0.06338334f, -0.12467464f, 0.03156513f, 0.15649317f, 0.00122317f, -0.02423944f, 0.01668198f, -0.01094191f, 
    0.11718030f, -0.09719475f, 0.00517546f, -0.10712364f, 0.11046503f, -0.04949876f, -0.01889657f, 0.00914608f, 
    0.10326840f, -0.02880416f, -0.04556638f, -0.00565144f, -0.03490750f, -0.13766904f, -0.02302015f, -0.14838697f, 
    0.13320486f, 0.00510043f, 0.01493393f, 0.05105335f, 0.06705730f, -0.02497172f, 0.01728699f, 0.22981669f, 
    -0.04690547f, 0.22882906f, -0.04854940f, 0.16001983f, 0.05299343f, -0.05874299f, 0.07380211f, 0.14845738f, 
    -0.00677388f, 0.08576528f, -0.01627105f, -0.01453043f, 0.29462209f, -0.27486682f, -0.04254031f, 0.12525102f, 
    0.08714695f, -0.04655969f, -0.05388927f, 0.12016821f, -0.09088434f, 0.11067743f, 0.03128435f, 0.01408683f, 
    0.13612710f, -0.06966656f, 0.14424439f, 0.03102657f, 0.16412596f, 0.02043670f, -0.01775678f, -0.04140984f, 
    -0.04648535f, 0.06336147f, -0.13035031f, 0.01160346f, -0.09610862f, 0.07577886f, -0.03641283f, -0.10042736f, 
    0.11229872f, -0.12088937f, 0.08032917f, 0.02602766f, 0.12794575f, 0.08132934f, 0.05149624f, 0.14208068f, 
    -0.10337725f, 0.21367790f, -0.04112739f, -0.02319655f, 0.03794450f, -0.08728632f, 0.06859925f, 0.09561223f, 
    0.00618612f, -0.03365550f, 0.19510598f, 0.16543536f, -0.02540406f, 0.00075070f, -0.05667683f, 0.11426647f, 
    0.18933630f, -0.06108650f, 0.11738568f, 0.00921043f, 0.01995117f, 0.09109282f, 0.10139638f, 0.20895101f, 
    -0.30684838f, -0.17251788f, -0.01096215f, 0.10485488f, -0.10740275f, 0.05728827f, 0.03632871f, 0.06399189f, 
    0.02617099f, -0.07289326f, 0.07327133f, -0.10749140f, 0.18213509f, 0.05064114f, -0.18389636f, 0.14961283f, 
    0.06576785f, -0.03843794f, 0.07338169f, 0.13143039f, 0.03122959f, 0.06592799f, 0.08162948f, -0.03783291f, 
    -0.30863327f, 0.08743761f, 0.03885747f, 0.16067864f, -0.02096400f, 0.01794132f, 0.00161342f, -0.06087098f, 
    0.00260322f, -0.03557174f, 0.04928983f, 0.01919701f, -0.21343368f, -0.07953501f, -0.12064202f, -0.20952439f, 
    0.03965451f, -0.08605203f, -0.07870522f, -0.16733162f, 0.02638998f, -0.09538634f, -0.03400426f, -0.09282932f, 
    0.02008666f, -0.14769559f, 0.01141849f, 0.06763296f, -0.09995070f, 0.10769338f, -0.01027635f, 0.09071313f, 
    0.07120360f, -0.01847254f, 0.03509094f, 0.10546160f, -0.05946460f, -0.02006440f, 0.06719495f, -0.13809806f, 
    0.03987743f, -0.11549705f, -0.02144358f, -0.04563950f, 0.02189952f, 0.03335709f, 0.13464721f, 0.07803085f, 
    -0.15728518f, -0.09091365f, 0.01896642f, 0.00311226f, 0.09875035f, 0.00623267f, -0.01547884f, -0.00777242f, 
    0.10057624f, 0.02085769f, -0.15835074f, 0.19628918f, 0.10391252f, 0.00384530f, -0.11992316f, 0.04363210f, 
    0.06413362f, -0.02614860f, 0.14907350f, -0.10238326f, -0.09736305f, -0.10937782f, 0.13290732f, 0.06299868f, 
    -0.03055873f, 0.08350837f, -0.05510107f, 0.00103749f, 0.06588349f, 0.19928423f, 0.00373444f, 0.07216263f, 
    -0.08824018f, 0.08288658f, 0.00959028f, 0.07297541f, 0.00056026f, 0.03966468f, 0.01679084f, -0.00258746f, 
    -0.01701931f, 0.07121539f, 0.03324476f, -0.11589193f, -0.07236160f, 0.00601417f, -0.01674700f, -0.14563043f, 
    0.12288029f, -0.29349166f, 0.02854994f, -0.02879406f, 0.05657459f, 0.03765824f, -0.05923751f, 0.11239487f, 
    0.04133416f, 0.02104940f, 0.00798364f, -0.06048070f, -0.15326531f, 0.29661188f, 0.01756346f, 0.06296346f, 
    0.02140892f, 0.15844245f, 0.11540062f, -0.04391532f, 0.10165573f, -0.03384745f, 0.03238353f, 0.02609763f, 
    -0.00621082f, -0.20738100f, -0.07131784f, 0.09650949f, -0.06959166f, 0.10722560f, 0.01285258f, -0.03142707f, 
    -0.10407356f, 0.09488780f, 0.11072191f, -0.00963476f, 0.09850903f, -0.18422706f, 0.15779525f, 0.10149192f, 
    0.02512982f, -0.08957177f, 0.08032846f, 0.06241534f, -0.02030968f, 0.07303735f, -0.02334392f, 0.01106179f, 
    0.10778061f, -0.07650760f, 0.12310144f, -0.20897900f, 0.13206403f, -0.08364773f, 0.00952761f, 0.09256202f, 
    0.01050187f, 0.12823418f, 0.08283705f, 0.00090311f, -0.03338268f, 0.02363198f, -0.03866531f, -0.30940744f, 
    0.13839479f, -0.04394655f, 0.05950723f, -0.05576004f, -0.02141909f, 0.08586048f, 0.07532603f, 0.03420621f, 
    -0.03129755f, 0.14024201f, -0.19239973f, -0.24792795f, 0.15175474f, -0.19461095f, 0.01236513f, -0.01721544f, 
    0.03590731f, 0.02045136f, -0.00746347f, -0.02029483f, 0.00780716f, 0.02122292f, 0.05166414f, 0.14459503f, 
    0.04170817f, 0.04267163f, -0.04699904f, -0.01563670f, 0.08127662f, 0.04840785f, 0.10475622f, 0.01921669f, 
    0.39609152f, -0.17260408f, 0.05285900f, -0.23406880f, 0.12200250f, -0.13396977f, 0.10784750f, 0.05658308f, 
    0.03176184f, 0.02757949f, 0.06426977f, 0.15492740f, 0.03518978f, -0.02931262f, 0.07235914f, -0.01267669f, 
    -0.00429706f, -0.04687935f, 0.08903566f, -0.05076216f, 0.02775332f, 0.05546334f, 0.06423833f, 0.03597674f, 
    0.05345570f, 0.06337216f, -0.07970911f, 0.01277434f, 0.06550209f, 0.06011390f, -0.10038191f, -0.01832891f, 
    0.02657684f, 0.06383751f, -0.02144636f, 0.01590722f, -0.52474546f, 0.00094923f, 0.13233477f, -0.05242760f, 
    -0.00587387f, 0.00052005f, 0.07739273f, -0.00429716f, 0.15962771f, -0.02214728f, -0.06084603f, 0.06487375f, 
    0.32190043f, 0.11608458f, -0.08489016f, 0.22285740f, 0.07550996f, 0.01940654f, 0.05593517f, 0.09986389f, 
    -0.07015547f, 0.01258704f, 0.10778970f, -0.07523861f, 0.02189134f, 0.13478923f, 0.03540768f, -0.19101281f, 
    0.09829400f, -0.06455652f, 0.00367737f, -0.08500547f, -0.05938493f, 0.13741453f, -0.08714005f, 0.07251031f, 
    -0.05786859f, -0.02882538f, -0.07038661f, -0.06217954f, -0.02636502f, -0.07555883f, 0.01904569f, 0.02425246f, 
    -0.05713150f, -0.01642533f, -0.00954311f, 0.05336049f, -0.03694648f, 0.01140350f, -0.01269807f, 0.00981839f, 
    0.03499408f, -0.01577071f, -0.06283786f, 0.00084545f, 0.04028873f, 0.00872118f, -0.07762512f, -0.06513413f, 
    0.04426294f, -0.04051367f, 0.02245966f, 0.04769870f, -0.01392804f, 0.00369222f, -0.01334061f, -0.00917590f, 
    -0.03812293f, 0.01371664f, -0.04332316f, 0.04110407f, -0.05901996f, -0.07576364f, 0.03606480f, -0.03213406f, 
    0.02109025f, -0.06727930f, 0.00842635f, 0.05900105f, 0.05006374f, 0.05633684f, 0.03432274f, 0.05447289f, 
    -0.06737405f, 0.05114680f, 0.06456403f, -0.02812192f, -0.01680335f, -0.02472431f, -0.04501499f, -0.00134924f, 
    0.04080571f, -0.00146370f, 0.01949772f, -0.07230019f, -0.01178504f, 0.01132992f, 0.04526067f, 0.03477395f, 
    -0.01215948f, -0.03731821f, 0.03918251f, -0.05615356f, -0.06733283f, 0.00954253f, 0.04574178f, 0.00615157f, 
    0.05702356f, -0.02005359f, 0.02790355f, -0.01573542f, -0.07350230f, -0.02260197f, -0.02545143f, -0.02291716f, 
    0.07010394f, 0.05762312f, -0.01600284f, -0.03687226f, -0.05985913f, -0.02195780f, -0.06526508f, -0.07414402f, 
    0.00908333f, -0.03923887f, -0.01450695f, 0.00674788f, -0.03309287f, -0.06777994f, -0.02799125f, 0.02541505f, 
    -0.04446175f, -0.05963214f, 0.00326433f, -0.04092658f, -0.06214959f, 0.01441424f, -0.01966333f, -0.03131095f, 
    0.00118459f, -0.04211016f, -0.03633547f, -0.03346396f, 0.04485751f, 0.01917024f, -0.03349540f, -0.00914777f, 
    0.05600245f, -0.05395339f, 0.05285298f, 0.06046521f, -0.03793581f, -0.06226235f, 0.02596919f, -0.02961266f, 
    -0.03818540f, 0.01037928f, -0.07049956f, -0.08107881f, 0.04006708f, 0.01462089f, 0.06363758f, 0.00636432f, 
    -0.03200971f, -0.04274262f, -0.01309989f, -0.07107250f, -0.06147511f, 0.05227366f, 0.06148610f, 0.01929391f, 
    -0.04508938f, 0.05620629f, -0.03165005f, 0.04836806f, -0.05374322f, -0.00676724f, 0.00522456f, 0.03127031f, 
    -0.01475350f, 0.02386796f, -0.05102083f, 0.06701244f, 0.01984256f, -0.03740425f, -0.02893631f, -0.00838892f, 
    -0.06702058f, 0.02674002f, 0.06027591f, 0.02051280f, -0.06674028f, 0.03680031f, -0.03585511f, 0.06178371f, 
    0.04085315f, -0.02731876f, 0.02258847f, -0.06751625f, -0.05673811f, -0.02298145f, 0.00950661f, -0.02443543f, 
    -0.05049400f, 0.04609272f, -0.07140683f, -0.01439813f, 0.01302842f, -0.06313159f, -0.03360430f, -0.01047038f, 
    -0.03240811f, -0.04121470f, 0.05578694f, -0.04359456f, -0.03615752f, 0.04723288f, 0.06164949f, -0.01147055f, 
    -0.06836315f, -0.03007605f, 0.02512363f, -0.01097439f, 0.05940054f, 0.02956288f, -0.00654453f, -0.01139651f, 
    0.19964366f, -0.04681120f, -0.10936949f, -0.09972196f, 0.08895271f, -0.02332021f, 0.03444200f, -0.02335475f, 
    -0.09136571f, 0.00572776f, -0.13054061f, -0.10058263f, 0.10509447f, 0.19324575f, -0.09611475f, -0.06844755f, 
    0.09739757f, -0.16804066f, 0.13453324f, -0.09014596f, 0.07711262f, 0.02569129f, 0.03389768f, -0.00231921f, 
    0.04317170f, 0.09692623f, 0.15604569f, 0.00731867f, 0.01234922f, -0.08505686f, -0.02856878f, -0.12297730f, 
    -0.05263954f, 0.05086010f, 0.06097134f, -0.00918325f, -0.27081022f, 0.34923944f, 0.15932071f, -0.12317090f, 
    -0.07781904f, 0.14416105f, -0.02760544f, -0.04190186f, 0.16573612f, 0.02492271f, -0.04490270f, 0.05890774f, 
    -0.04048660f, 0.02180804f, 0.09911767f, -0.01666282f, 0.06100704f, -0.09633963f, -0.03626492f, -0.07657243f, 
    -0.08446801f, 0.13653669f, -0.19261408f, 0.05051481f, 0.03651205f, -0.05955042f, -0.01049624f, 0.02821914f, 
    -0.01321190f, 0.03542635f, 0.18385738f, -0.06265822f, 0.12402545f, 0.07679814f, 0.06993628f, 0.16690405f, 
    0.13090172f, -0.07440589f, -0.00821943f, -0.01559744f, 0.01512717f, -0.14692210f, 0.08813529f, -0.00037779f, 
    0.04149033f, 0.05325044f, 0.07815176f, 0.05833771f, -0.21204150f, -0.15110181f, -0.04889529f, 0.11170741f, 
    0.08110358f, -0.04722400f, -0.01182978f, 0.00491662f, 0.02126900f, 0.01492060f, -0.04402711f, -0.11870441f, 
    0.02881137f, 0.01306583f, -0.04607959f, 0.13684161f, -0.17054035f, -0.06854616f, 0.03912165f, 0.01477587f, 
    0.10513660f, -0.06123858f, -0.15618597f, -0.00463465f, -0.20886667f, 0.15836684f, 0.07439288f, -0.05502886f, 
    0.03514513f, 0.01060075f, 0.19970858f, -0.04189573f, 0.13231771f, 0.08255838f, -0.00632832f, 0.03446528f, 
    -0.12460720f, 0.09540335f, 0.05230952f, -0.01721255f, 0.09828862f, -0.05396656f, -0.01539240f, -0.04640587f, 
    0.14054891f, 0.04492367f, -0.02007392f, 0.08558030f, 0.25766000f, 0.30600291f, 0.07859784f, -0.00034736f, 
    0.08274494f, -0.02353218f, 0.05122084f, -0.22018050f, 0.02635622f, -0.14523660f, -0.02689088f, -0.05570130f, 
    -0.17601439f, -0.10341895f, -0.14725669f, -0.03853087f, 0.10623465f, -0.04632961f, 0.03766217f, -0.02603138f, 
    -0.02884293f, 0.06699355f, 0.12275171f, 0.00630823f, -0.03404941f, 0.00916744f, -0.09023032f, 0.10940615f, 
    -0.03696730f, 0.01756807f, -0.07467199f, -0.00383081f, -0.06729108f, 0.07801657f, 0.01622939f, -0.09394282f, 
    -0.06024392f, 0.05673026f, -0.10079981f, 0.19155589f, 0.08010527f, 0.00302969f, 0.04233539f, 0.02103676f, 
    0.14168642f, 0.05435612f, 0.13061292f, 0.12520520f, 0.06270213f, -0.22969730f, -0.05227884f, 0.06802071f, 
    -0.03711599f, -0.13434595f, -0.06292620f, 0.03961933f, -0.02249885f, 0.08338708f, 0.04661690f, 0.02523735f, 
    -0.06771734f, 0.03899220f, -0.05966191f, 0.04390565f, 0.04882079f, 0.03282129f, -0.00880181f, -0.03503833f, 
    -0.03591973f, 0.02063834f, -0.05971354f, 0.03222195f, 0.00432108f, -0.00151608f, -0.04250070f, 0.02250660f, 
    -0.05597884f, -0.01094481f, -0.05957502f, 0.02968066f, -0.02121290f, 0.05716471f, -0.02373770f, -0.04842095f, 
    0.03601453f, 0.00568257f, -0.04846294f, -0.02635652f, 0.02965489f, 0.04437348f, -0.03933646f, -0.06642210f, 
    0.03144185f, 0.01883534f, -0.05337973f, 0.00063706f, 0.04758571f, -0.06640809f, -0.02264489f, -0.05441258f, 
    0.00965876f, 0.02687301f, -0.02005954f, 0.03737510f, -0.05297219f, 0.04693314f, -0.06691939f, 0.02561057f, 
    0.02711974f, -0.05212217f, -0.06578621f, -0.03203744f, 0.05728734f, 0.00658811f, -0.00047549f, -0.00344928f, 
    -0.04050034f, 0.04492386f, -0.07513770f, -0.00170842f, -0.02107734f, 0.04983678f, 0.01935577f, 0.04543862f, 
    0.03661518f, 0.00078837f, 0.03229167f, -0.05359479f, -0.07834789f, -0.07741423f, -0.07040225f, -0.05532743f, 
    0.02112010f, 0.01849233f, 0.04338809f, 0.06199673f, -0.02204892f, 0.02206222f, -0.04511257f, -0.07135033f, 
    -0.07693342f, -0.07349538f, 0.00533524f, 0.02209136f, -0.00690383f, -0.01830660f, -0.02652776f, -0.03292097f, 
    0.02405090f, 0.04239273f, -0.00522364f, 0.01080143f, -0.06052360f, 0.04797487f, 0.02649374f, -0.06146223f, 
    0.02261341f, 0.01901229f, 0.00012864f, 0.03072779f, -0.04170532f, -0.01266803f, 0.03143160f, -0.00828608f, 
    0.01467893f, -0.00512204f, 0.00957291f, 0.04357605f, -0.06165196f, 0.04482735f, 0.05384784f, -0.02128453f, 
    -0.06837238f, 0.03454681f, -0.02465449f, -0.07198402f, -0.02228937f, 0.00982377f, -0.01172590f, -0.01928426f, 
    0.03271937f, -0.01445593f, -0.01639679f, -0.06299020f, 0.02867838f, 0.06050493f, -0.03741474f, -0.01721079f, 
    -0.06354233f, 0.05037383f, 0.00869162f, 0.01834939f, -0.04421761f, -0.02684753f, 0.04466202f, 0.06476820f, 
    -0.06283309f, 0.02581364f, 0.06518165f, -0.02201692f, -0.00304947f, 0.01533876f, 0.05900842f, -0.00106614f, 
    -0.06263451f, 0.04935845f, -0.06379800f, -0.04076878f, -0.02929296f, 0.05546725f, -0.07062377f, -0.03375451f, 
    0.04467247f, -0.04866348f, -0.06961913f, 0.03901396f, -0.00336414f, -0.01054976f, -0.06688306f, -0.03487072f, 
    -0.02254361f, -0.01697060f, -0.02820008f, -0.00079630f, -0.00980983f, 0.00611742f, 0.06255843f, -0.06077154f, 
    -0.05568875f, 0.06278449f, -0.01694568f, -0.01399127f, -0.00780585f, -0.01057131f, 0.02258395f, -0.00590672f, 
    -0.06812377f, 0.03167077f, 0.01271583f, 0.05350882f, -0.03208240f, -0.02009352f, -0.06530619f, 0.06119922f, 
    -0.02244115f, -0.04391596f, -0.03467433f, 0.04098142f, -0.00370741f, -0.01497751f, 0.01519144f, -0.03620723f, 
    0.24268767f, 0.01454546f, 0.12183939f, -0.04160164f, 0.07148468f, 0.02119860f, -0.14497684f, -0.02393903f, 
    0.05289494f, 0.00475582f, 0.07164948f, -0.02152401f, -0.01853389f, 0.25153911f, 0.08475852f, -0.01485556f, 
    -0.05985741f, 0.01731452f, -0.12725347f, -0.06467809f, -0.00954925f, -0.03386434f, -0.04243318f, 0.06289402f, 
    0.18899220f, -0.10081547f, -0.24389264f, -0.01982170f, -0.04137486f, -0.00273411f, -0.01855645f, -0.09020746f, 
    0.22467838f, 0.00186872f, 0.05774906f, 0.06061140f, 0.20305972f, 0.24431641f, -0.10743560f, 0.07597434f, 
    0.08662023f, 0.13187586f, -0.03672735f, -0.03789011f, 0.04137713f, 0.16229656f, -0.00612701f, -0.03920221f, 
    -0.19386460f, -0.00117131f, 0.05687247f, -0.10192576f, -0.05222722f, 0.08001000f, -0.09812114f, -0.18956262f, 
    -0.18471897f, 0.03046649f, 0.00022805f, -0.09487975f, -0.08909962f, -0.01974231f, 0.21250215f, 0.12943445f, 
    0.08282259f, -0.04537675f, 0.09418413f, 0.05833519f, -0.10251585f, 0.09958591f, 0.05733661f, -0.03358501f, 
    -0.06497510f, -0.12988229f, -0.11433437f, -0.14729856f, -0.06826572f, -0.15117048f, -0.03044855f, -0.08026017f, 
    0.14962216f, -0.02451196f, 0.18249008f, 0.14942048f, -0.07424330f, -0.31322563f, 0.19298786f, 0.02226410f, 
    0.01222473f, -0.09282955f, 0.05929700f, -0.02428936f, 0.05820962f, 0.06851612f, 0.06156065f, 0.12454952f, 
    0.21366894f, -0.19190815f, -0.06994006f, 0.00617740f, 0.04075664f, -0.09013277f, 0.07388578f, -0.03323075f, 
    0.05444765f, 0.04416276f, -0.08655375f, -0.18679126f, 0.07684507f, -0.07861235f, 0.11220469f, 0.08014379f, 
    -0.05616419f, -0.06832159f, 0.02577764f, -0.00556343f, 0.13570918f, 0.16458000f, -0.17238243f, 0.04547977f, 
    -0.22472124f, -0.05202727f, -0.06664638f, 0.07998914f, 0.05803196f, -0.06321257f, 0.02706390f, 0.05171860f, 
    0.11217040f, -0.01533397f, -0.00516614f, 0.04813772f, -0.12873176f, -0.07591702f, -0.04359029f, 0.13770324f, 
    -0.09217238f, -0.07621252f, 0.08880647f, 0.06555318f, -0.00959930f, -0.04693113f, -0.07597230f, -0.16607589f, 
    0.37815076f, -0.01785572f, -0.05795054f, 0.01203000f, -0.05008857f, 0.06743944f, -0.08260871f, 0.08716599f, 
    -0.03968898f, -0.10896678f, 0.20890370f, 0.02461781f, 0.03507018f, -0.06534462f, 0.09366910f, -0.00961924f, 
    0.11988667f, -0.07508998f, -0.13145855f, 0.05814240f, 0.01178910f, 0.11360113f, 0.00733352f, 0.01776011f, 
    0.37135825f, 0.10626422f, -0.14735372f, -0.13730964f, -0.06090687f, 0.01954212f, 0.01808730f, 0.04422481f, 
    0.09747044f, 0.03083093f, -0.05694113f, 0.18258204f, 0.11753920f, 0.06275780f, -0.16533369f, 0.02368815f, 
    0.15972382f, -0.12602998f, -0.02099128f, -0.06485970f, 0.01710130f, -0.07359319f, -0.02154351f, 0.11200830f, 
    0.07674902f, 0.03308778f, 0.14462917f, -0.15401308f, 0.01371969f, 0.10829611f, 0.03627520f, 0.02860407f, 
    -0.04077223f, -0.08820979f, 0.07674251f, -0.00320748f, 0.29381999f, 0.19480896f, 0.10241412f, 0.26495159f, 
    -0.05573159f, 0.13419487f, -0.05022048f, 0.03968941f, 0.14078839f, 0.10330892f, -0.06642402f, 0.01682820f, 
    0.16577238f, -0.20958436f, -0.07670975f, 0.00045690f, -0.05007612f, 0.02204938f, 0.09698394f, -0.15270653f, 
    0.12646699f, 0.06003119f, 0.02780606f, 0.02753220f, 0.39967492f, 0.02120084f, 0.13343275f, 0.02136264f, 
    -0.01751318f, -0.16815837f, 0.05981005f, -0.04442277f, 0.09282145f, -0.00089823f, 0.03171035f, -0.03999559f, 
    0.19116165f, 0.11940575f, 0.06671844f, 0.08723084f, -0.04768813f, 0.02837406f, 0.01344437f, 0.03772383f, 
    0.00534404f, 0.07027110f, 0.15638804f, 0.13697292f, -0.09172498f, 0.17304501f, -0.02603624f, 0.12349322f, 
    0.12849763f, -0.13379550f, -0.20683457f, -0.06262034f, 0.02308422f, -0.03224190f, -0.02466299f, -0.02296323f, 
    -0.24621050f, -0.13526557f, -0.08254145f, 0.00691822f, -0.11240976f, 0.07170408f, -0.09804616f, 0.00057548f, 
    0.05994422f, 0.00245303f, -0.17897274f, 0.02948920f, 0.06785102f, 0.09072329f, 0.08217768f, -0.06613316f, 
    -0.20793715f, -0.04042318f, -0.03780542f, 0.00566166f, -0.13107507f, -0.21296565f, 0.00568312f, -0.03859888f, 
    0.20713879f, 0.09368216f, -0.00928746f, 0.13360332f, 0.08419047f, 0.08802062f, 0.16300894f, 0.06371434f, 
    -0.08351854f, -0.05165269f, -0.02665473f, -0.01712435f, 0.13290423f, 0.14476256f, -0.03941611f, -0.03396820f, 
    -0.01833875f, 0.05008752f, 0.15841196f, -0.11107632f, -0.13387957f, -0.01333816f, 0.11596555f, 0.04018360f, 
    -0.27571043f, 0.15212515f, 0.04178862f, -0.09119213f, -0.01431777f, 0.02735553f, -0.02285404f, 0.09381586f, 
    -0.01202372f, 0.09746443f, -0.04896533f, 0.06982574f, -0.38935143f, -0.12037794f, 0.11494998f, 0.23312068f, 
    0.01073139f, -0.00964596f, -0.00188643f, 0.16288772f, -0.02833349f, 0.13819796f, 0.02139178f, -0.00881545f, 
    0.12336682f, -0.14799309f, 0.03351006f, -0.00046080f, -0.07387584f, -0.12187952f, 0.00224695f, 0.09392331f, 
    -0.04284104f, -0.14438762f, -0.09226953f, -0.16666807f, 0.31805739f, 0.07091464f, -0.06424876f, 0.04048636f, 
    0.11371834f, 0.10723496f, 0.11405423f, -0.07794245f, -0.03277443f, -0.12382194f, -0.05751265f, -0.18156509f, 
    0.10352921f, -0.02913867f, -0.00511039f, -0.10965634f, -0.22524811f, -0.09868384f, 0.05818343f, -0.10830503f, 
    -0.03354737f, -0.07278418f, -0.05583903f, -0.10473864f, 0.04189302f, -0.13781168f, 0.00588766f, 0.12864776f, 
    0.07374118f, -0.08169126f, 0.06934579f, -0.04503961f, -0.03107608f, -0.08261706f, -0.04501017f, -0.14824782f, 
    0.26593134f, 0.12645163f, 0.06286848f, -0.10164686f, 0.08316977f, 0.06138555f, -0.01569378f, -0.06299805f, 
    -0.05450346f, -0.00891219f, -0.04408089f, -0.03615971f, 0.04716748f, 0.04096725f, 0.11653432f, 0.16766962f, 
    0.14451611f, 0.01848677f, -0.04311364f, 0.01855468f, -0.08030006f, -0.07076937f, -0.05512767f, 0.06678633f, 
    0.03045614f, -0.11612490f, -0.19155195f, 0.01547793f, -0.06451856f, -0.13307364f, 0.09185667f, 0.06243156f, 
    0.02369641f, 0.09450078f, -0.11136122f, 0.04775523f, 0.31865957f, 0.15140128f, 0.16094978f, 0.13179383f, 
    0.10182935f, 0.09285510f, -0.01095065f, 0.14551429f, -0.07265838f, 0.00585956f, -0.05687135f, -0.01003211f, 
    0.27794763f, -0.08955244f, -0.04066965f, 0.15340599f, 0.12323989f, 0.01283076f, 0.01194738f, -0.03400787f, 
    -0.01899422f, 0.00226329f, 0.03991294f, -0.00584695f, 0.10537730f, 0.14258480f, 0.09411358f, 0.15489794f, 
    0.01202610f, -0.08080565f, 0.04437452f, 0.07822494f, -0.01845691f, 0.00658714f, -0.00733230f, -0.05525447f, 
    0.14819638f, -0.04233116f, -0.01178941f, -0.13988197f, 0.01833656f, -0.04047037f, -0.06257165f, 0.10705100f, 
    -0.04088035f, -0.13158531f, 0.05993888f, 0.05969815f, 0.04219374f, 0.11317654f, -0.01060335f, 0.01872521f, 
    0.13678530f, 0.02585093f, -0.05875895f, -0.04664112f, -0.09567202f, -0.07395594f, 0.04073276f, 0.05308362f, 
    -0.22662345f, -0.00237483f, 0.04729711f, -0.09378217f, 0.07643231f, -0.05211688f, -0.08604824f, -0.06284744f, 
    0.03292624f, -0.00917905f, -0.11049096f, -0.11548855f, -0.33941504f, 0.15969196f, 0.00379715f, 0.18158941f, 
    -0.12229716f, -0.10448041f, 0.01681912f, 0.05493280f, 0.04181136f, -0.00921034f, -0.07399943f, -0.06629825f, 
    0.25526801f, 0.01114024f, -0.08728033f, -0.04482824f, -0.01793751f, -0.07755156f, -0.02688286f, -0.01367414f, 
    0.03223804f, -0.06761712f, -0.08911517f, 0.06032073f, -0.11240923f, 0.14586036f, 0.14656338f, 0.10399404f, 
    0.13062273f, 0.03973242f, -0.01149347f, 0.08409043f, -0.09479514f, -0.07157625f, 0.01749854f, -0.09018669f, 
    0.21968995f, -0.00894589f, -0.10271209f, -0.02428949f, -0.00187844f, 0.15329476f, 0.12151325f, -0.05726389f, 
    -0.08632264f, -0.00270972f, 0.02613359f, 0.07058186f, -0.00564146f, 0.10619824f, 0.07997494f, -0.21919192f, 
    -0.00760037f, 0.07816992f, 0.00188005f, -0.14094891f, 0.01775877f, 0.05841725f, -0.00297956f, 0.03842150f, 
    0.60646820f, -0.13018847f, -0.16444264f, -0.14171672f, -0.03857963f, -0.02663100f, -0.08690337f, 0.06930935f, 
    -0.00554468f, -0.06311604f, -0.11311423f, 0.14941449f, 0.02198236f, 0.06848317f, -0.05494091f, -0.12272355f, 
    -0.11173529f, -0.03243260f, -0.05280557f, -0.04878149f, -0.13641644f, -0.08570406f, 0.04207505f, 0.00309140f, 
    0.28049594f, 0.09239371f, 0.13459823f, -0.01143296f, -0.04923931f, 0.00347200f, 0.10540339f, 0.03823216f, 
    0.05303487f, -0.03568260f, 0.08583932f, 0.11513838f, 0.03182662f, -0.17730486f, -0.15828761f, 0.15352117f, 
    0.10507260f, 0.04370605f, 0.06583797f, 0.01196724f, 0.02058860f, 0.01857435f, -0.05054016f, -0.18943477f, 
    -0.03203044f, -0.11906144f, 0.01678183f, -0.14218402f, -0.05027093f, 0.05744077f, -0.02674630f, 0.08006951f, 
    -0.12164967f, 0.06343243f, -0.02477539f, 0.02518876f, -0.34494874f, 0.19225463f, 0.21536683f, 0.01589257f, 
    0.03726365f, 0.01785114f, 0.13121909f, -0.00447148f, -0.01098278f, -0.03622729f, 0.02318875f, 0.03452782f, 
    0.13482349f, -0.02995664f, -0.13910753f, 0.08850951f, -0.08525607f, -0.04914331f, -0.07578833f, 0.04512540f, 
    0.01346062f, 0.03524003f, 0.12838024f, -0.06335875f, 0.02422544f, -0.03176163f, -0.04212898f, 0.01978794f, 
    0.01618142f, 0.04947334f, 0.01486020f, 0.07435510f, 0.09398746f, -0.13392134f, 0.00653206f, 0.05275530f, 
    0.14647812f, -0.02011519f, 0.13701926f, 0.02314935f, 0.07510657f, 0.03053594f, -0.02225332f, -0.01927012f, 
    -0.00037248f, -0.04721478f, -0.15541691f, -0.11215036f, 0.09567050f, 0.29881909f, -0.17457691f, -0.15287714f, 
    -0.04077360f, 0.09221565f, -0.03988202f, 0.05228752f, -0.14282745f, 0.05902718f, -0.00419074f, -0.20112155f, 
    0.03612381f, 0.31792995f, 0.08939021f, -0.08214278f, 0.07883670f, -0.00885242f, 0.00109937f, 0.05593078f, 
    -0.10484434f, 0.08641971f, -0.05609544f, 0.04046263f, -0.43451738f, -0.12845255f, 0.13461009f, -0.04876266f, 
    -0.02284697f, 0.03918748f, 0.06618179f, -0.04812638f, 0.03223626f, 0.00485001f, 0.10055985f, 0.03301056f, 
    -0.10476526f, -0.11440012f, -0.06872607f, 0.08161484f, 0.00273229f, -0.00119754f, 0.00479072f, -0.10099148f, 
    -0.00738043f, 0.04714444f, 0.05014870f, -0.00208913f, 0.16173658f, 0.10083153f, 0.24636310f, 0.03640838f, 
    0.24430400f, 0.13552497f, 0.05156622f, -0.01267404f, -0.01085440f, 0.10219479f, 0.05224869f, 0.15536587f, 
    -0.05291425f, 0.17072859f, 0.03889168f, -0.09850901f, 0.03247821f, 0.02887969f, 0.04176826f, -0.02826329f, 
    0.01600006f, 0.02145939f, -0.19629499f, -0.01796334f, 0.00523883f, 0.16494933f, -0.08220971f, 0.24848501f, 
    0.07878762f, 0.13583791f, 0.05510463f, -0.01908417f, 0.16062158f, -0.00549498f, -0.01742689f, 0.02946108f, 
    0.12842995f, -0.02536309f, 0.10807290f, 0.03644207f, -0.06530997f, 0.17358008f, 0.03579292f, -0.08753273f, 
    -0.05461768f, 0.08311130f, 0.11216596f, -0.06204979f, 0.01763821f, -0.02355435f, 0.29055592f, -0.22204684f, 
    -0.15029266f, -0.10139275f, -0.03344715f, 0.08414435f, -0.07503280f, 0.09959941f, -0.08683361f, -0.06121066f, 
    -0.06304748f, 0.03743432f, 0.08293531f, 0.23827690f, -0.15586795f, -0.05547441f, 0.12429009f, 0.18487538f, 
    0.00125083f, 0.11166012f, 0.13584533f, 0.05950568f, -0.02913464f, -0.01615670f, -0.06723115f, -0.08693084f, 
    -0.12304276f, 0.06966714f, -0.02260265f, 0.19862074f, -0.04021954f, 0.11364099f, 0.13015719f, -0.08177410f, 
    -0.06177580f, 0.13757303f, 0.00128805f, -0.05145924f, 0.00237153f, 0.12814613f, -0.01132538f, 0.09591808f, 
    0.02628666f, -0.05175783f, 0.01001873f, 0.06557927f, -0.04017386f, -0.25286195f, 0.03568152f, 0.06859884f, 
    0.00702849f, -0.06460076f, -0.00412434f, -0.01772183f, 0.00169202f, -0.08834726f, 0.03162313f, 0.06389596f, 
    -0.00113093f, 0.11229382f, -0.01174191f, -0.05570726f, -0.02809085f, 0.00679177f, 0.15121165f, 0.15952560f, 
    0.20539686f, 0.01155195f, 0.15987793f, 0.04639209f, 0.06452649f, -0.04368545f, -0.11338354f, -0.06953455f, 
    0.06758701f, 0.07520048f, -0.18592899f, -0.07706459f, 0.13375244f, -0.17222771f, -0.02058437f, -0.03077698f, 
    -0.10514575f, 0.07093598f, 0.04717825f, 0.12038261f, 0.03767785f, 0.13228355f, 0.00890613f, 0.07046671f, 
    -0.02683542f, 0.00790918f, -0.13846974f, -0.15749717f, 0.29179516f, 0.21606275f, -0.23591408f, -0.03020304f, 
    -0.15595868f, 0.00539674f, 0.01845410f, 0.16831502f, -0.09807864f, 0.00691870f, 0.04627727f, -0.05993228f, 
    0.10534731f, 0.06660919f, 0.07608363f, 0.03486971f, -0.05102288f, 0.13541542f, 0.04689996f, 0.03171368f, 
    -0.18279950f, 0.10484238f, 0.10330912f, 0.14094076f, 0.04124253f, -0.11616503f, -0.07407499f, 0.01765349f, 
    -0.01840681f, 0.03738343f, -0.05209743f, -0.04674536f, -0.09238789f, -0.11521050f, 0.13065395f, -0.06102758f, 
    -0.05750478f, -0.05700869f, -0.03230336f, 0.20672075f, -0.00305344f, -0.01004121f, 0.05926126f, -0.07292214f, 
    -0.01656675f, 0.05309651f, 0.09545922f, -0.09201206f, -0.07491644f, -0.17272477f, 0.02905607f, -0.12692453f, 
    0.04646978f, 0.10395689f, -0.06599172f, -0.01690970f, 0.04910094f, 0.21282598f, 0.12658253f, 0.30992696f, 
    -0.02896630f, 0.04077153f, 0.15876865f, -0.06567595f, -0.07778309f, -0.09153854f, 0.09867748f, 0.07280570f, 
    0.08523659f, -0.00473371f, -0.10774090f, -0.05120059f, 0.08316744f, 0.08758368f, -0.01060108f, 0.15590669f, 
    -0.03436953f, 0.02007344f, 0.14283586f, 0.01204764f, 0.10956439f, -0.17785902f, 0.00293859f, 0.08085163f, 
    -0.26411381f, 0.08312802f, 0.12965095f, 0.06723420f, -0.04113179f, 0.11601992f, -0.02317910f, -0.02359861f, 
    -0.13242963f, -0.00009692f, -0.08686169f, -0.16392608f, 0.05742553f, 0.13016817f, 0.17869715f, -0.00783496f, 
    -0.04785204f, 0.13804561f, 0.03380391f, 0.05565846f, -0.00231538f, 0.08542604f, -0.18336180f, -0.02105455f, 
    -0.02430899f, 0.01225863f, 0.04385200f, -0.00777328f, -0.06914520f, -0.06439607f, -0.04772982f, -0.07505866f, 
    0.03706141f, -0.05503684f, 0.00499093f, -0.00164980f, 0.02369677f, -0.06063083f, 0.04849963f, 0.04316621f, 
    0.00015945f, -0.01434649f, -0.04821995f, -0.05916826f, -0.00565984f, -0.05076886f, 0.02884619f, 0.03973888f, 
    -0.07931747f, -0.00326397f, -0.00735270f, -0.05402642f, -0.00110728f, 0.00765915f, -0.02871739f, 0.05889634f, 
    -0.04130628f, 0.02236161f, 0.01892667f, 0.05626621f, 0.00802899f, 0.02041860f, -0.00345436f, 0.04958427f, 
    -0.04093511f, -0.04583532f, -0.05466181f, 0.04615235f, 0.03448810f, -0.06947391f, 0.01361358f, 0.04643679f, 
    -0.03267948f, 0.03806213f, -0.03314137f, 0.04134575f, 0.05267722f, 0.01177476f, -0.04554715f, 0.04165462f, 
    -0.03277908f, 0.03395373f, -0.04376339f, 0.01242835f, 0.04283648f, -0.02591110f, 0.02180742f, -0.06292782f, 
    -0.07786816f, -0.02051387f, 0.04497668f, 0.00399995f, 0.05349387f, -0.06951545f, 0.02092664f, -0.03601928f, 
    -0.02607485f, -0.06013977f, 0.05308307f, -0.07431238f, 0.05998971f, 0.03876866f, 0.06306601f, -0.03323042f, 
    -0.04393549f, -0.03749100f, 0.05350731f, -0.07341988f, -0.05499383f, -0.03087250f, 0.01076963f, -0.05472327f, 
    0.00323475f, -0.05492497f, -0.01477134f, -0.05857410f, 0.04318096f, -0.04771360f, -0.00697158f, 0.03699206f, 
    -0.02584678f, 0.06406139f, 0.02763211f, -0.03380113f, -0.05712182f, -0.04646754f, 0.01609075f, -0.05608517f, 
    -0.06005516f, -0.07853448f, -0.01455868f, 0.00813299f, -0.02513050f, -0.02533353f, 0.00868673f, -0.07502453f, 
    -0.03832569f, 0.02347282f, -0.05482424f, -0.02375101f, -0.04318770f, -0.06864021f, 0.01331606f, -0.00617344f, 
    0.04781324f, 0.04929996f, -0.05751610f, -0.04426672f, 0.02220326f, -0.02262167f, -0.03402293f, -0.03907391f, 
    -0.04389610f, -0.02236330f, -0.00904875f, -0.06378512f, -0.04827094f, 0.02638015f, -0.07526557f, -0.06577017f, 
    -0.06281501f, 0.01587831f, 0.05612085f, -0.01255216f, 0.02270429f, -0.00756871f, 0.04402443f, 0.06264902f, 
    0.01199979f, -0.00417735f, -0.01642715f, 0.04328168f, 0.04203796f, -0.00321861f, -0.01002921f, 0.02595371f, 
    -0.00568936f, 0.04105680f, 0.03242599f, 0.04563341f, -0.00303433f, 0.05796886f, -0.06785294f, -0.06383479f, 
    -0.06961840f, -0.01785679f, -0.01702792f, 0.04284195f, -0.01201548f, 0.06066469f, 0.05458991f, -0.07565622f, 
    0.01455201f, -0.05162095f, -0.04579791f, 0.01497321f, -0.02072373f, 0.04263870f, 0.02131601f, -0.01147145f, 
    -0.04038167f, -0.03735740f, 0.01599380f, 0.03723770f, -0.00019491f, -0.05895375f, -0.02977897f, -0.06199255f, 
    0.01040593f, -0.06884708f, 0.06008134f, -0.07662130f, -0.06844018f, -0.06631416f, -0.06474462f, -0.01538351f, 
    -0.12644729f, -0.01561427f, -0.02058731f, 0.05550250f, 0.00261461f, -0.05605696f, 0.09581301f, 0.06280153f, 
    -0.06826563f, 0.10912865f, 0.01677212f, -0.09957145f, -0.03857516f, -0.01475776f, -0.08495217f, -0.06255168f, 
    0.10385633f, 0.03348133f, -0.01294677f, -0.01688283f, -0.08208347f, 0.05031810f, 0.00480824f, 0.01103884f, 
    0.06135090f, -0.05133769f, 0.13225988f, 0.24585131f, 0.06370361f, 0.11356387f, 0.03600694f, 0.04861337f, 
    -0.15903808f, -0.01973232f, -0.19777091f, -0.14908724f, -0.08957909f, -0.12588857f, -0.02443308f, 0.13239585f, 
    -0.10372891f, 0.01498304f, 0.13150354f, 0.12755752f, -0.04659434f, -0.03888690f, 0.00795185f, 0.06185435f, 
    -0.15821636f, -0.11710649f, -0.00679757f, 0.23775536f, 0.04533731f, 0.03499850f, 0.04812886f, -0.07573802f, 
    -0.01438149f, 0.01240270f, 0.02230609f, 0.02946015f, -0.02475587f, -0.02914673f, 0.03053874f, -0.08698515f, 
    -0.03077950f, 0.08721234f, -0.03434447f, 0.18806352f, 0.03443703f, 0.05892242f, -0.01551278f, -0.10364019f, 
    0.31193683f, 0.25921649f, 0.15018786f, -0.01271735f, 0.04660014f, 0.19154789f, 0.02859043f, 0.00288130f, 
    -0.00888279f, 0.06318995f, 0.14553143f, -0.05272864f, -0.10580976f, -0.00970658f, -0.01809143f, -0.15611172f, 
    0.05105799f, 0.04123810f, 0.15609759f, -0.06901611f, 0.06021504f, 0.12688217f, -0.08238840f, 0.10861655f, 
    -0.13543870f, -0.07968608f, 0.14972293f, -0.51456153f, 0.11665171f, -0.06533046f, 0.05306498f, 0.05722240f, 
    0.05686442f, 0.13766724f, 0.04103857f, 0.15835965f, 0.19828708f, -0.09170555f, 0.03994701f, 0.05219473f, 
    0.02946429f, -0.01595755f, -0.15905775f, 0.09777992f, 0.08429438f, 0.12994997f, 0.01836549f, -0.00179274f, 
    0.48005253f, -0.00486686f, 0.11839943f, -0.08715170f, 0.01554108f, 0.03171257f, 0.02153904f, 0.00214161f, 
    -0.02461897f, -0.00720764f, 0.02180959f, -0.08063621f, 0.07497554f, -0.01567327f, -0.00088563f, -0.09096531f, 
    -0.08039477f, -0.07570452f, 0.06544639f, 0.04796083f, 0.08286720f, -0.00200607f, 0.03006739f, 0.03901821f, 
    -0.02776738f, 0.11154523f, 0.07432036f, 0.00402705f, 0.11930888f, 0.10548300f, 0.10814784f, -0.01863322f, 
    0.08326047f, 0.03578230f, -0.09788287f, 0.08294766f, -0.36276776f, 0.06765927f, 0.23685141f, -0.37410596f, 
    -0.00529260f, -0.02324721f, -0.02509511f, 0.07743064f, -0.02476299f, -0.07761913f, -0.13047083f, 0.05015318f, 
    0.08183828f, -0.13077734f, 0.14986993f, -0.09453756f, 0.06933217f, 0.07740037f, -0.10992821f, 0.15862077f, 
    -0.16371372f, -0.01181096f, 0.07015529f, -0.07094639f, -0.07481430f, 0.32179880f, -0.12106233f, -0.10681333f, 
    0.01541325f, 0.12384384f, -0.02341311f, 0.00750577f, -0.07507764f, 0.03865889f, -0.04432136f, 0.15613027f, 
    0.35860324f, 0.14982930f, -0.04518793f, 0.06256224f, -0.02612974f, 0.04855301f, -0.03720464f, 0.14074925f, 
    0.02586227f, -0.04595121f, 0.12452198f, 0.00077514f, -0.06443429f, -0.06838642f, -0.09225053f, 0.08374641f, 
    -0.10850686f, 0.08930535f, 0.02086268f, -0.03744043f, 0.10318743f, -0.02394802f, -0.04329739f, 0.02439393f, 
    0.26216641f, -0.01616926f, -0.02873584f, 0.11100011f, -0.08763604f, 0.18052039f, -0.08237743f, -0.11493874f, 
    0.05920323f, 0.01302685f, 0.12181289f, -0.03206880f, -0.30724519f, 0.27547887f, 0.09372652f, 0.16102192f, 
    0.03985594f, -0.09705210f, 0.04750715f, 0.06818604f, -0.01520836f, 0.04579607f, -0.07526992f, 0.01985881f, 
    -0.38920483f, 0.03906106f, -0.07874990f, 0.17591284f, -0.01549285f, -0.11071952f, 0.06435741f, -0.19199987f, 
    0.05617287f, 0.21575761f, 0.14293058f, 0.20288523f, -0.10219351f, -0.00483978f, 0.05442724f, -0.12503430f, 
    0.04864792f, -0.07104191f, 0.01008767f, 0.09395183f, 0.03490819f, -0.04475871f, 0.13906848f, -0.11183051f, 
    0.04055609f, -0.07103712f, 0.12354873f, 0.00194482f, -0.03706301f, 0.05088274f, 0.05761884f, 0.09847350f, 
    0.09499019f, 0.03305076f, -0.13739860f, 0.02082371f, 0.24280521f, 0.00706467f, -0.06117226f, -0.00241573f, 
    0.00672780f, 0.01962397f, -0.03963310f, 0.05315628f, -0.07836432f, 0.00081834f, 0.02716925f, -0.03026420f, 
    -0.04128996f, 0.02908254f, -0.05734226f, -0.06574341f, 0.03121153f, -0.05666835f, 0.03421207f, 0.02622510f, 
    -0.03562352f, 0.10376583f, -0.01771473f, 0.05092907f, 0.15970162f, 0.01350702f, 0.13015415f, 0.03525467f, 
    -0.11669844f, 0.05999673f, -0.02280574f, 0.03883755f, -0.10810602f, 0.05125888f, 0.04205915f, 0.10896038f, 
    -0.41227290f, 0.31994864f, 0.00005367f, -0.17001158f, 0.23808570f, -0.06395666f, -0.03268606f, 0.04503330f, 
    -0.07196566f, -0.03534229f, 0.04280981f, -0.04212033f, -0.26630896f, -0.06675705f, 0.00090685f, 0.04524105f, 
    -0.01018924f, 0.02212440f, 0.02306633f, 0.08060923f, -0.02956118f, -0.11518681f, 0.07971350f, 0.02413208f, 
    0.20487934f, -0.14598405f, 0.08943063f, 0.00777480f, -0.00186074f, -0.00581140f, 0.04595513f, 0.05479856f, 
    -0.00431411f, 0.00051133f, 0.07808428f, 0.03410243f, 0.02453218f, 0.13707088f, -0.04316255f, -0.00613238f, 
    0.12110034f, 0.01020997f, 0.08787222f, -0.07259943f, -0.07458101f, -0.07935559f, 0.05249124f, -0.03893193f, 
    0.24494165f, 0.00711896f, 0.14909175f, 0.05039208f, -0.06022253f, -0.12724879f, -0.03382470f, 0.04653946f, 
    0.05119222f, 0.06563465f, 0.10207033f, -0.03594248f, 0.07015037f, -0.01286303f, -0.17537293f, 0.01742011f, 
    -0.00819685f, 0.19386494f, 0.02979476f, -0.00590057f, 0.06183215f, -0.13822150f, 0.01617107f, 0.02727875f, 
    0.02912997f, 0.03796564f, 0.06088634f, -0.03793676f, -0.01758628f, -0.04357116f, 0.00324074f, -0.03741268f, 
    -0.03780278f, 0.02727019f, -0.02574631f, -0.02226502f, 0.05437330f, -0.01174118f, -0.01772156f, -0.02046621f, 
    0.00368612f, -0.07862622f, 0.04323655f, 0.03083687f, 0.06007288f, -0.06528006f, 0.01514650f, -0.08158360f, 
    0.02390028f, 0.04963221f, -0.05262769f, -0.04399773f, 0.00583479f, -0.05132518f, -0.01921027f, -0.05828458f, 
    -0.00811856f, -0.02752871f, 0.02258044f, -0.02686205f, 0.05136747f, 0.02138202f, -0.01038503f, -0.01898047f, 
    -0.06450373f, 0.04052735f, 0.01916872f, -0.05500580f, -0.00388353f, -0.00352046f, -0.03852750f, -0.07987940f, 
    -0.06684713f, -0.06531216f, 0.00891832f, 0.06277443f, -0.01714959f, -0.06008710f, 0.02972260f, 0.04039792f, 
    -0.07722683f, -0.06867031f, -0.02824080f, 0.05196029f, -0.05667911f, 0.00557270f, -0.03199401f, -0.02793203f, 
    -0.02984180f, 0.03041897f, 0.04547257f, 0.04457803f, -0.06849008f, 0.04524542f, 0.01877583f, 0.05567152f, 
    0.00518056f, -0.00335075f, 0.01070110f, -0.05858291f, 0.01832009f, -0.03515682f, -0.07221515f, 0.02251459f, 
    0.00882277f, 0.02509147f, 0.03729720f, -0.07822444f, 0.02733899f, -0.03682997f, -0.02411441f, -0.01835632f, 
    0.00054169f, 0.01253117f, -0.06950384f, 0.01309269f, -0.04184315f, -0.01508638f, 0.00406586f, -0.03280274f, 
    0.04285179f, -0.06739325f, -0.02630735f, -0.01311207f, -0.05434617f, 0.00898312f, 0.02775757f, 0.05413995f, 
    0.00704383f, -0.00259264f, -0.05210898f, 0.03418921f, -0.07206687f, -0.03972270f, -0.04693108f, 0.04790405f, 
    0.02303455f, -0.07918774f, 0.02307352f, 0.03430816f, -0.07023830f, 0.03792702f, -0.00638147f, -0.03775630f, 
    -0.01064810f, 0.05207996f, 0.05007584f, -0.06170280f, -0.06685772f, -0.06968450f, -0.04216833f, -0.06944910f, 
    0.04018601f, -0.04173488f, -0.04241481f, 0.02002940f, -0.03070386f, -0.04959107f, -0.06445317f, -0.02743160f, 
    -0.00332746f, -0.04107575f, 0.05558561f, -0.07010977f, -0.03687467f, -0.05358868f, -0.04974261f, -0.01317408f, 
    0.03468462f, 0.03430410f, 0.01204004f, 0.02554491f, -0.04570147f, 0.03018225f, -0.07794961f, -0.02993467f, 
    -0.03653487f, -0.04728593f, -0.06629721f, -0.01947663f, -0.02169264f, 0.02380637f, 0.04957799f, 0.01577223f, 
    -0.04016552f, 0.03209431f, -0.04984772f, 0.04506443f, 0.04777550f, 0.02156237f, 0.05382688f, 0.00874225f, 
    0.02125826f, -0.04985146f, 0.05836180f, -0.00738556f, 0.02183115f, 0.01922503f, 0.00797948f, 0.00820071f, 
    -0.02517595f, -0.04139329f, -0.02768211f, 0.05567954f, -0.04543740f, -0.03559814f, 0.01857423f, 0.02315573f, 
    0.00509341f, -0.04935577f, -0.06193365f, -0.03201121f, 0.06171959f, 0.04704177f, -0.01813812f, 0.05959696f, 
    -0.36257738f, 0.02008134f, 0.04132506f, 0.05917095f, 0.08449989f, 0.08868786f, -0.00716785f, -0.21651378f, 
    0.05861746f, 0.09148223f, -0.06502088f, 0.06777470f, -0.04070150f, -0.05654502f, 0.03587835f, 0.03967782f, 
    0.28865662f, 0.08449046f, 0.06453242f, -0.07071789f, -0.04627956f, 0.08209279f, 0.07416819f, 0.15060532f, 
    -0.03979556f, -0.19574371f, 0.06986613f, -0.03526922f, 0.00298617f, -0.07343034f, 0.02934790f, 0.03540822f, 
    -0.01169163f, -0.04128934f, 0.00533603f, -0.00015692f, 0.03513207f, -0.01749417f, -0.03843268f, 0.00047307f, 
    -0.00671050f, 0.09738331f, -0.07580879f, -0.00417778f, 0.06150444f, -0.03987223f, 0.07001907f, -0.07767867f, 
    0.18815927f, -0.10452008f, -0.09218637f, 0.12908012f, -0.09178221f, -0.01138169f, -0.12331238f, -0.08570492f, 
    -0.04034298f, -0.14267901f, -0.07603427f, 0.10034405f, 0.03368894f, -0.07727246f, 0.10371988f, 0.11587354f, 
    -0.05164276f, 0.08412278f, 0.13177985f, 0.15692002f, -0.01428332f, 0.15143129f, -0.08724651f, 0.03510001f, 
    0.20968279f, -0.20036015f, 0.02897081f, -0.12277442f, -0.11678836f, -0.00686217f, -0.08973537f, 0.04554168f, 
    -0.14165179f, 0.05789837f, 0.03971071f, 0.07893836f, -0.33828139f, 0.19030990f, 0.19590719f, -0.24791333f, 
    0.06179841f, -0.06728129f, 0.07498645f, -0.09603096f, 0.13867924f, -0.04759160f, 0.05979605f, -0.01656531f, 
    0.09160093f, 0.26083112f, 0.14315113f, -0.16992635f, 0.10654732f, 0.02056915f, 0.02126215f, 0.14575127f, 
    0.06638451f, -0.03515489f, 0.07760216f, 0.06408509f, -0.13687874f, 0.16004080f, -0.19241200f, -0.28054968f, 
    0.17082046f, -0.00996021f, -0.00204438f, 0.05663480f, 0.02957061f, 0.12595308f, -0.09458390f, 0.05908298f, 
    0.06505346f, -0.07740828f, -0.02655012f, -0.12899539f, -0.04435387f, 0.10743596f, -0.03694873f, 0.13144810f, 
    0.05665960f, 0.03386096f, -0.00153597f, 0.11673184f, 0.08142705f, 0.01648645f, -0.12152573f, 0.20424940f, 
    -0.03420737f, -0.04888805f, 0.05999636f, 0.04941830f, -0.00695038f, -0.06399637f, 0.07734005f, -0.00197672f, 
    -0.13431214f, 0.14212537f, -0.16376132f, -0.00854710f, 0.07695814f, 0.05161771f, -0.22436902f, 0.03869584f, 
    0.03531927f, 0.11423180f, 0.09822410f, 0.09614136f, -0.07799331f, 0.00039909f, 0.12592630f, -0.00296180f, 
    0.01449017f, 0.06456359f, -0.04034907f, 0.05650647f, 0.08177202f, 0.25102693f, 0.09324775f, 0.01019054f, 
    -0.01854504f, -0.09172906f, -0.17347819f, 0.09670099f, 0.00297647f, -0.11836977f, 0.07246999f, -0.10991508f, 
    -0.00514223f, -0.02783157f, -0.02942135f, 0.03814327f, -0.46818477f, 0.12185384f, 0.21301110f, -0.04008198f, 
    0.00378133f, -0.02826640f, -0.09253701f, -0.04414454f, 0.04897051f, 0.05331516f, 0.14104611f, 0.01033812f, 
    0.05382243f, 0.22415811f, -0.04305229f, 0.07985335f, 0.06829029f, 0.06027424f, 0.01457961f, -0.04156721f, 
    0.02709927f, 0.02432145f, -0.11409707f, -0.03436636f, -0.08643183f, -0.08246140f, 0.14025180f, -0.12902953f, 
    0.00321100f, -0.03498299f, -0.00797379f, -0.00452478f, 0.13032833f, -0.04068682f, 0.07365669f, 0.22038837f, 
    -0.18135639f, 0.02896834f, -0.05373686f, -0.26828998f, 0.10625830f, 0.05382890f, 0.08530670f, 0.02398233f, 
    0.06995337f, -0.02361964f, 0.07737387f, 0.13171208f, 0.08275463f, 0.05281518f, 0.01091277f, -0.04344932f, 
    -0.03933194f, 0.08037113f, -0.21583197f, 0.04251475f, -0.04114797f, 0.08055740f, -0.00513463f, 0.03964029f, 
    0.15581122f, -0.05649142f, -0.05957401f, -0.05714818f, 0.02859392f, 0.07931186f, -0.03128150f, 0.04145883f, 
    -0.08556092f, 0.00213956f, -0.01628794f, 0.09227553f, 0.12244280f, 0.02896427f, 0.03682886f, -0.00834522f, 
    0.06309266f, -0.07310968f, 0.02528207f, -0.05490545f, 0.02554978f, 0.09731221f, -0.00195696f, 0.11860298f, 
    0.04175815f, -0.00298637f, 0.02132768f, -0.02702455f, -0.07415583f, 0.00836261f, 0.09281200f, 0.05539098f, 
    -0.04844299f, 0.06373419f, 0.07240744f, 0.14221372f, -0.01441251f, -0.06673093f, 0.14569667f, 0.04958742f, 
    0.17411190f, 0.03449615f, -0.01723090f, -0.00873812f, 0.09955982f, -0.09439435f, 0.06647977f, 0.04199737f, 
    -0.18106857f, -0.01679055f, -0.04245630f, 0.19999471f, 0.07632784f, 0.00814119f, 0.00576164f, 0.10150473f, 
    0.01273468f, -0.08591951f, 0.15672414f, -0.04273378f, 0.15734370f, 0.07204345f, -0.08577043f, -0.15898381f, 
    0.05080518f, -0.07861542f, 0.03110665f, 0.16951509f, 0.10245209f, 0.06238729f, 0.04096901f, 0.06370007f, 
    -0.11146607f, -0.17156418f, 0.00174219f, 0.01130171f, -0.06343346f, 0.10236625f, 0.00980166f, -0.05282494f, 
    -0.02118124f, -0.01469510f, 0.03034925f, 0.06669081f, 0.03607276f, -0.10563921f, -0.01422531f, 0.06947960f, 
    -0.00980454f, 0.00771891f, -0.11851466f, -0.02126199f, 0.07549971f, -0.12748866f, 0.01984330f, -0.07855517f, 
    -0.13006516f, 0.00929788f, -0.07517570f, 0.11249061f, 0.08382068f, 0.03595326f, -0.17810850f, 0.00430023f, 
    0.02485105f, 0.09754457f, 0.12921254f, -0.04744477f, 0.13395393f, -0.18273562f, 0.02871282f, 0.17183544f, 
    0.01423142f, -0.11655967f, -0.11190553f, -0.06353024f, -0.08237433f, 0.14785706f, 0.13199654f, 0.03529603f, 
    -0.20913388f, 0.02705043f, -0.16240500f, 0.03422720f, 0.13944595f, -0.04288207f, -0.00297695f, -0.06764838f, 
    0.14851928f, -0.01088468f, -0.14406475f, 0.13958912f, -0.22819346f, -0.15771940f, 0.21667726f, 0.06974658f, 
    0.13182706f, 0.14700854f, 0.01787767f, -0.02407515f, 0.00373334f, -0.10910293f, 0.02616574f, -0.08799817f, 
    -0.00958086f, -0.04042131f, -0.02062470f, -0.02091580f, 0.04926326f, 0.01440383f, 0.04369731f, -0.05888050f, 
    -0.03379063f, 0.01547831f, -0.06129885f, -0.03478928f, -0.06456937f, -0.03454291f, -0.02997356f, 0.05471279f, 
    -0.03537570f, -0.04857747f, -0.01984977f, 0.00528307f, 0.00500789f, 0.01439438f, -0.06232030f, 0.01177640f, 
    0.00202537f, -0.00389881f, 0.03082547f, 0.00658461f, -0.03302292f, -0.02045699f, 0.04204831f, -0.06337969f, 
    0.01396172f, -0.05708392f, -0.04389493f, -0.00265540f, -0.06781151f, 0.00344678f, 0.04140055f, -0.04487138f, 
    -0.06233215f, 0.01464185f, -0.02496911f, -0.05645610f, -0.03401408f, -0.02428656f, 0.05088209f, 0.05191644f, 
    0.04283217f, -0.00377275f, -0.06537963f, 0.05752642f, -0.04320170f, 0.00126165f, 0.01717289f, -0.06050356f, 
    0.04792425f, 0.02560899f, 0.02915035f, -0.04919337f, 0.01023791f, -0.07683971f, -0.00277689f, 0.01034288f, 
    0.05430694f, -0.01378310f, -0.00709585f, -0.00809473f, -0.03607777f, -0.06428856f, -0.03005517f, 0.05640313f, 
    0.03035920f, -0.07635394f, -0.06012908f, 0.03002438f, 0.05737906f, -0.03748753f, -0.00129957f, -0.00981505f, 
    0.01132802f, 0.03522142f, -0.02305565f, -0.03566525f, -0.01146733f, 0.02047686f, -0.02045874f, -0.01949784f, 
    -0.04315519f, 0.02723186f, -0.04890973f, -0.01541516f, 0.00465601f, 0.03152331f, 0.06211307f, -0.07882524f, 
    -0.03977107f, -0.06240977f, -0.01600337f, -0.06262141f, 0.03427505f, -0.05573800f, -0.04205467f, -0.05710833f, 
    -0.00590133f, -0.00163589f, -0.02947202f, 0.02167977f, 0.04052180f, 0.03873076f, 0.06024458f, -0.07847602f, 
    -0.00327429f, 0.03601521f, -0.02074542f, -0.00849010f, -0.02501816f, -0.00814423f, -0.04279947f, -0.02728523f, 
    -0.07647844f, 0.03130774f, 0.02410913f, -0.00470520f, 0.04082147f, -0.06195074f, 0.03566559f, -0.01154743f, 
    0.00135522f, -0.00847925f, -0.05153408f, -0.02629364f, 0.02131220f, 0.00981354f, -0.07395817f, 0.05030355f, 
    0.00591251f, -0.06117122f, -0.02655162f, -0.07367320f, -0.02282033f, 0.05330658f, 0.02602914f, 0.05016498f, 
    -0.04469607f, -0.03054857f, -0.02955239f, -0.07542396f, -0.00323779f, -0.01835853f, -0.05658250f, -0.05119186f, 
    -0.03976443f, -0.04739409f, 0.00499349f, -0.00666639f, -0.00158436f, 0.05899141f, -0.01129809f, -0.01168764f, 
    0.03978647f, -0.00055658f, 0.04349448f, -0.02222397f, 0.03710368f, -0.03248383f, -0.02186368f, -0.00730721f, 
    -0.00468171f, -0.02197080f, -0.02063132f, -0.03960051f, 0.03945285f, -0.00713675f, 0.00642561f, 0.00009478f, 
    0.01796875f, -0.01399031f, 0.00147961f, -0.00787495f, 0.01662805f, 0.01386692f, -0.04118342f, 0.01747143f, 
    -0.00004724f, -0.05103372f, -0.06573185f, 0.00081105f, -0.07723533f, -0.02605070f, -0.00035339f, -0.02547547f, 
    0.11171038f, 0.15013677f, 0.05422574f, -0.22253221f, 0.13071355f, 0.02482113f, -0.14878932f, -0.08554310f, 
    0.05903659f, -0.01056409f, -0.03213179f, 0.07404783f, 0.15676780f, -0.00625477f, 0.38581720f, 0.22537600f, 
    0.29601806f, 0.06373445f, 0.10031272f, 0.04499609f, 0.02652009f, -0.04159618f, -0.10079959f, 0.14381886f, 
    0.26130292f, -0.12463554f, 0.22046036f, -0.04119989f, -0.01132743f, -0.11336701f, 0.02539879f, 0.00291583f, 
    -0.01438519f, -0.02887175f, 0.05774660f, 0.05324776f, 0.23648509f, 0.20992787f, 0.15187047f, 0.40524423f, 
    -0.02891320f, 0.14772481f, -0.07465127f, 0.02195598f, 0.02881064f, 0.01159885f, -0.02318589f, -0.02158708f, 
    0.39249876f, -0.04795239f, 0.02939815f, 0.23140927f, 0.11350428f, 0.17221132f, 0.06910045f, 0.05731529f, 
    -0.01264970f, 0.05234715f, 0.02016958f, 0.01575145f, 0.04209444f, -0.01205214f, 0.15157744f, 0.15798742f, 
    0.09575912f, -0.02094888f, 0.04390711f, 0.13609013f, 0.07495760f, 0.05049932f, 0.00801748f, 0.09493801f, 
    -0.07193361f, -0.20141332f, 0.22397423f, -0.07409579f, 0.12581061f, -0.15672961f, -0.02428096f, 0.10309146f, 
    -0.08613610f, -0.01466239f, -0.04211912f, 0.11811826f, -0.15752342f, 0.07194369f, -0.08316748f, -0.27813977f, 
    -0.10599259f, -0.09066223f, -0.13510974f, -0.17481795f, -0.04878820f, -0.12962326f, -0.01581882f, -0.01245068f, 
    -0.13134862f, 0.11033597f, -0.12356516f, -0.07759051f, 0.01173435f, -0.06215497f, -0.05027253f, -0.10141540f, 
    0.01424212f, -0.21310654f, 0.03115428f, 0.03390023f, 0.01975024f, 0.50732422f, -0.10309222f, 0.04225115f, 
    0.07858898f, -0.04736387f, 0.14038773f, 0.08456609f, 0.08432649f, -0.11417846f, 0.00760874f, -0.01438895f, 
    -0.27165473f, -0.02979696f, -0.01386357f, -0.05593491f, 0.09909002f, -0.06648702f, 0.04179120f, -0.02813759f, 
    -0.09687632f, 0.12248917f, -0.09698187f, 0.02424475f, -0.22044143f, 0.03730100f, 0.16913986f, 0.27567488f, 
    0.09151603f, -0.04024546f, 0.01280549f, 0.01893804f, -0.00280325f, 0.06058158f, -0.05912062f, 0.01730282f, 
    -0.09779412f, -0.25454783f, -0.08876622f, -0.04302290f, -0.11401445f, 0.03084060f, -0.14228217f, -0.04803688f, 
    0.05391638f, -0.00299121f, -0.03975615f, -0.03080782f, -0.05011772f, 0.01925068f, -0.21346189f, -0.04740180f, 
    -0.00266398f, -0.00740484f, 0.09991843f, -0.10075954f, 0.00724131f, 0.12947638f, 0.14525868f, -0.06381341f, 
    -0.02545280f, 0.03144319f, -0.26140326f, 0.10453189f, -0.03033754f, -0.00971913f, -0.14778651f, -0.12486686f, 
    0.09490961f, 0.03125570f, 0.00102037f, 0.10907926f, -0.30384567f, -0.10540423f, 0.13715135f, -0.18355131f, 
    0.01063500f, -0.08797730f, -0.07484678f, -0.12823647f, 0.09450997f, 0.03810155f, -0.10697632f, -0.03862684f, 
    0.32389849f, 0.19707492f, -0.01988593f, 0.00307008f, 0.10351515f, -0.01114507f, -0.08424735f, -0.01692131f, 
    -0.03234953f, 0.02972082f, 0.03361885f, -0.04909402f, -0.20170209f, -0.09635922f, 0.04108880f, 0.04831867f, 
    0.00965722f, -0.02417492f, -0.05153511f, -0.01833968f, 0.04190154f, 0.02585902f, -0.12628458f, 0.21978661f, 
    0.23989353f, -0.11314052f, -0.11853799f, 0.07700770f, 0.02487953f, 0.06538257f, -0.05745480f, -0.01450952f, 
    0.09898762f, 0.03185444f, 0.04472807f, -0.00121523f, -0.12275457f, 0.24120682f, -0.10149071f, 0.16447982f, 
    -0.01634144f, 0.05697025f, -0.03469142f, 0.04361438f, -0.01564664f, 0.09282518f, -0.04260336f, 0.13135102f, 
    -0.21460524f, -0.09546479f, -0.13788277f, -0.02012227f, 0.02714233f, -0.00100068f, -0.01362343f, -0.17784476f, 
    -0.10851279f, 0.06251532f, 0.08797628f, 0.07543746f, -0.14953505f, 0.09924209f, 0.15207347f, -0.00796862f, 
    0.12853721f, -0.10572191f, 0.03940117f, 0.03592695f, 0.00037999f, 0.09986298f, 0.07651991f, -0.05766480f, 
    0.09889849f, -0.04153297f, 0.11132944f, -0.07937219f, -0.01520832f, 0.01937380f, 0.07080448f, 0.16063535f, 
    -0.02545721f, 0.02377039f, 0.05603090f, 0.17803985f, 0.10958379f, -0.09563182f, 0.07374519f, 0.05384398f, 
    0.09291416f, -0.01089391f, 0.05880035f, -0.05469208f, 0.08802477f, 0.04510693f, -0.01391218f, 0.06600942f, 
    -0.22789297f, -0.10949782f, -0.00495384f, 0.06861679f, 0.11348668f, -0.03186833f, -0.00066411f, -0.03794435f, 
    0.11312856f, -0.02385678f, 0.01909515f, -0.01628434f, 0.01378773f, -0.02883480f, 0.06968004f, 0.10997786f, 
    -0.09655052f, -0.00901098f, 0.04416159f, 0.07030252f, 0.01958907f, 0.18223898f, -0.06204528f, 0.05729254f, 
    -0.29211158f, 0.14418884f, 0.00298846f, -0.22863810f, 0.21518455f, -0.03068804f, 0.00537890f, 0.15316521f, 
    0.04482625f, -0.06473966f, 0.06799141f, -0.03053696f, -0.18515973f, -0.09993582f, -0.06908078f, 0.08403387f, 
    -0.04820638f, -0.05107178f, -0.02691211f, -0.03674297f, -0.00699489f, -0.17085324f, -0.00952795f, -0.16549021f, 
    0.28448728f, -0.14586169f, -0.04720634f, 0.17346652f, -0.02421924f, 0.09674956f, -0.12353287f, 0.00585786f, 
    -0.02399972f, -0.03571318f, 0.14819875f, -0.01852827f, -0.06044073f, 0.03415228f, 0.18698758f, -0.14923060f, 
    0.08618575f, -0.12823349f, -0.01505494f, -0.06030017f, -0.05531824f, 0.08503652f, 0.09835275f, 0.05666441f, 
    0.42192495f, -0.00085951f, -0.00959544f, -0.00603449f, 0.00807779f, -0.11753357f, -0.00600064f, 0.01395274f, 
    0.04821052f, 0.06139250f, 0.05834181f, 0.06986860f, -0.06447102f, 0.03425917f, -0.17725162f, -0.01018633f, 
    0.03499093f, 0.14548142f, 0.04231312f, -0.05942205f, 0.00011861f, -0.05135487f, 0.04571812f, 0.05815524f, 
    0.27981135f, -0.06538748f, 0.07870987f, -0.18168037f, 0.01541242f, 0.14349006f, -0.02145247f, 0.14521432f, 
    0.01814354f, -0.05526083f, 0.14883944f, 0.15786541f, 0.31913185f, 0.07082635f, 0.11720652f, 0.21464100f, 
    0.03449297f, 0.08271781f, 0.10092389f, 0.08045963f, -0.09519849f, -0.02186197f, -0.05611873f, -0.05278416f, 
    0.33678639f, -0.10902026f, 0.15967044f, 0.16337357f, -0.07298457f, 0.00379535f, -0.00351193f, 0.00520139f, 
    0.14984950f, 0.02724207f, 0.03548128f, -0.02125969f, 0.19455059f, 0.11818052f, 0.11326241f, 0.24769725f, 
    0.02538250f, 0.01636791f, 0.08896310f, 0.11111743f, -0.03245107f, -0.12302744f, -0.07538299f, 0.01140281f, 
    0.04553901f, 0.03811695f, -0.00215868f, 0.13846610f, 0.01357512f, 0.07004894f, 0.03781068f, 0.09422147f, 
    0.02413121f, 0.06367110f, 0.07362822f, 0.10498355f, -0.12298872f, 0.14688754f, 0.06349613f, -0.04044725f, 
    0.14120528f, -0.03704615f, -0.12294752f, 0.10745141f, 0.03508423f, -0.21441865f, 0.08116762f, 0.04268815f, 
    -0.09469198f, -0.05760549f, 0.04026347f, -0.00160210f, 0.03134338f, 0.02825485f, -0.00194269f, 0.14148955f, 
    -0.04227864f, -0.01671670f, -0.09211698f, 0.00097422f, 0.03846058f, 0.10116185f, -0.18340583f, -0.17209417f, 
    -0.08682693f, -0.11178324f, -0.09943571f, 0.07427239f, -0.08869071f, -0.10155971f, 0.10758945f, -0.04561993f, 
    -0.03690048f, 0.04802612f, -0.20382547f, 0.05388927f, -0.05249158f, -0.01077373f, 0.05843462f, -0.12867652f, 
    0.03638622f, -0.07939333f, 0.06786159f, 0.11952188f, -0.06987865f, 0.21782325f, -0.04794494f, 0.09130113f, 
    -0.07772957f, 0.10644291f, 0.12942770f, -0.02144331f, -0.15861505f, -0.19300219f, 0.09926187f, -0.06539292f, 
    -0.36833555f, 0.14349762f, -0.00037650f, 0.08916802f, 0.02464428f, -0.15137143f, -0.06711426f, -0.11082812f, 
    -0.07215862f, -0.09967486f, -0.05490087f, 0.04233934f, -0.44048336f, 0.06218984f, 0.08932833f, 0.04497074f, 
    0.13538986f, -0.04429105f, -0.06986009f, 0.12951060f, 0.02803599f, 0.20780134f, -0.12656881f, 0.04951302f, 
    0.06729852f, -0.20357017f, -0.06509900f, -0.18775412f, -0.03486695f, -0.09931922f, 0.03992540f, -0.06164878f, 
    0.02838146f, 0.02046083f, -0.09886118f, -0.15438931f, 0.00505114f, 0.12291510f, -0.09757676f, 0.04399112f, 
    -0.00082207f, 0.10699779f, 0.09271280f, -0.05070271f, 0.14649580f, -0.11348373f, -0.06880667f, -0.03786247f, 
    0.13515021f, -0.12634358f, -0.03406811f, -0.00283062f, -0.09382240f, 0.00635048f, 0.01828614f, -0.00822032f, 
    0.03819306f, 0.08211278f, 0.02065196f, 0.02409446f, 0.19217038f, -0.05569774f, -0.07312734f, -0.09436242f, 
    -0.07230249f, -0.04619912f, 0.00000858f, -0.01097216f, -0.05336823f, 0.02177726f, -0.14425808f, 0.04239823f, 
    -0.04465862f, -0.16383506f, 0.19172932f, -0.10719477f, 0.07370134f, 0.09967340f, 0.00036505f, 0.01408966f, 
    0.08649019f, -0.01959926f, 0.10305275f, 0.05656595f, 0.26042715f, 0.03765991f, -0.15284285f, 0.08294904f, 
    0.21425252f, 0.07879394f, 0.06597284f, 0.01211341f, -0.09079964f, 0.09107216f, 0.01225346f, -0.01065266f, 
    0.14251272f, -0.25707579f, 0.21889716f, 0.26501903f, -0.04724050f, 0.03885380f, 0.01454052f, 0.04096441f, 
    -0.01185884f, -0.03658864f, 0.04680593f, 0.05347202f, 0.08836868f, -0.15402980f, 0.03739661f, 0.06585614f, 
    0.00250697f, -0.01912264f, 0.05718318f, 0.04062246f, 0.07288589f, 0.04372022f, 0.07540782f, -0.00702725f, 
    0.10055349f, -0.04033927f, -0.02811169f, 0.17809083f, 0.03708572f, 0.02538430f, -0.05013243f, -0.06488799f, 
    -0.14339633f, 0.02525582f, -0.01538718f, 0.06515563f, -0.13681547f, -0.05079145f, -0.02946336f, 0.04656059f, 
    0.18638033f, -0.00270750f, 0.02990533f, 0.15209626f, 0.01698770f, 0.08665634f, -0.11631095f, 0.04381262f, 
    0.02029373f, -0.12956235f, 0.09203613f, -0.17601129f, 0.02485641f, -0.01035025f, -0.11783472f, 0.06451471f, 
    0.05760850f, -0.01155416f, 0.15933900f, 0.11330296f, -0.11455301f, 0.23093498f, 0.10506703f, -0.30784127f, 
    0.10414662f, -0.11265124f, 0.08844010f, -0.03773868f, 0.02752128f, -0.06209143f, 0.05883342f, 0.08272624f, 
    0.12386961f, 0.11958486f, 0.04157808f, -0.19138925f, 0.00439424f, -0.03085945f, 0.07000475f, 0.03205417f, 
    0.02169221f, -0.16408227f, 0.05363207f, 0.10291809f, -0.05871688f, 0.02289865f, -0.09322426f, 0.02908253f, 
    0.04227772f, 0.03882992f, 0.02422733f, 0.08698729f, 0.06380107f, 0.10383093f, 0.03953827f, -0.01422374f, 
    -0.53706419f, 0.23808640f, -0.10988650f, 0.05526941f, 0.12153812f, -0.10297892f, -0.04545588f, 0.01133581f, 
    -0.08457497f, 0.00852594f, -0.01765618f, 0.04391925f, -0.31775180f, 0.00541028f, -0.07277193f, 0.05365411f, 
    -0.08378533f, -0.06378573f, 0.03112232f, 0.00602458f, 0.07699765f, 0.01817473f, -0.10429924f, -0.05352943f, 
    -0.11577691f, -0.07641210f, -0.06278413f, 0.02933862f, -0.04590271f, 0.10038558f, -0.14963955f, 0.17247964f, 
    0.11430889f, 0.05790310f, 0.02672321f, 0.01348176f, -0.15272132f, 0.09572769f, 0.00096061f, -0.19570342f, 
    0.02957884f, -0.00579046f, 0.11983526f, -0.07312270f, 0.04277990f, 0.06090620f, 0.00518592f, 0.09640207f, 
    0.11946408f, -0.14921929f, -0.02200833f, -0.02222996f, 0.03834480f, 0.00732370f, 0.06239073f, 0.03364408f, 
    0.01352972f, -0.01543495f, -0.03820413f, 0.05462216f, -0.02708971f, -0.01831947f, 0.15371095f, -0.11130641f, 
    0.07986039f, -0.14645863f, -0.07901327f, 0.00299493f, 0.06331044f, 0.11752288f, 0.01476399f, 0.08607741f, 
    0.06632983f, 0.17795524f, -0.18203250f, 0.21592213f, -0.10611691f, -0.04365815f, 0.04413684f, 0.09887060f, 
    0.01260910f, 0.04690902f, 0.09700794f, -0.07421335f, -0.10062598f, -0.17930436f, -0.03852423f, 0.18282360f, 
    0.09454831f, 0.05883339f, 0.02104881f, 0.05685386f, 0.00703914f, -0.02484399f, 0.00406207f, -0.02628557f, 
    -0.14235498f, -0.04788940f, 0.07070611f, 0.02378809f, 0.04378709f, 0.05655974f, -0.05600239f, -0.07657462f, 
    0.00071646f, -0.02585512f, 0.05629238f, -0.07175482f, -0.35943189f, 0.21429296f, 0.10820456f, -0.02519133f, 
    -0.05699790f, -0.04452742f, -0.09639563f, -0.05753504f, 0.10273581f, -0.04233921f, -0.07098195f, 0.13014089f, 
    -0.27930415f, 0.02673261f, -0.08745634f, 0.19283038f, -0.12699987f, -0.10677546f, 0.07597262f, 0.06419094f, 
    0.22689185f, 0.06557055f, 0.02849073f, 0.20874743f, -0.13337860f, 0.02048388f, -0.05880943f, -0.03731680f, 
    0.02324540f, 0.14631847f, -0.03974113f, -0.02358975f, -0.01910528f, -0.08551614f, 0.05795049f, -0.06645678f, 
    0.04565295f, -0.15512694f, 0.23272017f, 0.06589984f, 0.00377013f, 0.09414565f, 0.02745356f, 0.06991876f, 
    0.02316774f, 0.05817611f, -0.06517792f, -0.10675126f, 0.10987387f, 0.25174239f, -0.05492447f, 0.03324841f, 
    -0.12757467f, 0.11317579f, 0.09151114f, 0.02968698f, 0.02522346f, 0.07374369f, -0.00107766f, -0.10920416f, 
    -0.01089848f, 0.23332325f, 0.08472549f, 0.04870191f, 0.01021269f, -0.03134041f, -0.05454960f, 0.09598529f, 
    0.02807263f, 0.09521342f, 0.03977116f, 0.10458761f, -0.04088692f, 0.11683544f, 0.06762401f, -0.09094564f, 
    0.01581937f, 0.06798033f, -0.04698007f, -0.00333802f, -0.03505041f, -0.01687321f, 0.10074955f, 0.05957402f, 
    0.07736162f, 0.09589680f, 0.06723675f, -0.15710364f, 0.04492614f, 0.06143364f, -0.01974651f, -0.02129233f, 
    0.02587475f, 0.00433479f, 0.06331878f, -0.12835279f, -0.07279675f, 0.04844155f, 0.13584504f, 0.14162992f, 
    -0.02891990f, 0.07363161f, 0.06829116f, -0.03427523f, -0.01326223f, -0.01944487f, 0.08184541f, 0.23017968f, 
    0.00169842f, 0.03404063f, 0.08986767f, 0.04220763f, 0.03263355f, -0.05758259f, 0.04963575f, 0.06734110f, 
    -0.05453106f, -0.02162031f, -0.04123899f, -0.07316654f, 0.20286825f, 0.21185289f, 0.07682719f, 0.08025692f, 
    0.05158900f, 0.08519287f, 0.14965621f, 0.06355595f, -0.05215487f, 0.03082093f, 0.08580924f, -0.12688671f, 
    -0.28850541f, -0.01552532f, 0.10420506f, 0.02196617f, -0.07179202f, 0.04237538f, 0.03659710f, -0.02409553f, 
    -0.03172422f, 0.10243806f, -0.00834803f, 0.00837607f, -0.17722048f, -0.02095132f, 0.12770246f, 0.03543597f, 
    -0.16514784f, 0.18877535f, -0.02927765f, 0.03964632f, 0.03093352f, -0.01127519f, -0.01603064f, -0.10659699f, 
    -0.05304267f, -0.05154338f, -0.03378082f, 0.06001456f, -0.07556271f, -0.06659135f, 0.02077227f, -0.02031669f, 
    -0.03154765f, -0.05612697f, 0.06609783f, -0.00971405f, -0.02602111f, -0.01416764f, 0.03218380f, -0.02391773f, 
    0.05384898f, 0.03602877f, -0.07245059f, 0.00330491f, 0.06167363f, -0.05535414f, 0.02638011f, -0.03583598f, 
    -0.06230292f, 0.04716917f, 0.00062364f, -0.06728638f, 0.04799862f, -0.07149462f, -0.06420863f, 0.01439176f, 
    0.01679081f, -0.05401314f, 0.00686648f, 0.03230581f, -0.00467613f, 0.02508900f, -0.04032078f, -0.01731664f, 
    0.03577520f, -0.04531880f, -0.02058634f, -0.03085913f, 0.00139806f, -0.06366756f, 0.06974154f, -0.02185043f, 
    0.00361098f, -0.03739991f, 0.07119401f, 0.01164828f, -0.06497627f, -0.01628748f, -0.07401868f, -0.02747578f, 
    0.04928340f, 0.05286056f, -0.01586316f, -0.06223546f, 0.01037349f, 0.04986267f, 0.04849307f, -0.02177083f, 
    -0.03994247f, 0.00111315f, -0.01186458f, -0.03567322f, 0.05499239f, 0.03722423f, 0.04040357f, -0.01543735f, 
    -0.02564424f, -0.07671116f, 0.05723988f, 0.01043362f, -0.06733554f, -0.03305729f, 0.03777242f, -0.01622483f, 
    -0.07149024f, -0.03966846f, -0.06574103f, -0.03008441f, 0.06246796f, -0.06421985f, 0.06557459f, 0.03707776f, 
    -0.06392127f, -0.07004440f, 0.06159047f, -0.05195063f, 0.05247026f, -0.07328682f, -0.07218812f, -0.02706136f, 
    -0.06447871f, -0.05486901f, 0.02272004f, -0.03302851f, -0.04596179f, -0.05670502f, -0.02306269f, 0.05848913f, 
    -0.02233854f, 0.02655333f, -0.04752727f, 0.03367664f, 0.03796856f, -0.00244518f, -0.02846288f, -0.01238692f, 
    -0.07689260f, -0.04876908f, -0.04479588f, -0.06233985f, -0.07572876f, 0.04897212f, -0.01832851f, -0.04942600f, 
    -0.02977810f, 0.05608170f, -0.02347023f, -0.04416499f, -0.00553470f, 0.01966325f, -0.01023886f, 0.00886676f, 
    -0.02241819f, 0.01242370f, 0.04576100f, -0.02674339f, 0.04590745f, -0.03736005f, -0.05097156f, 0.00106680f, 
    0.04805351f, -0.01108160f, -0.06098843f, -0.00288513f, -0.02882046f, -0.01492494f, 0.05769205f, 0.06092149f, 
    -0.07453208f, 0.02762680f, 0.05786730f, 0.05576649f, -0.05836378f, -0.00129270f, 0.01337393f, 0.02124857f, 
    -0.05924292f, -0.05817813f, -0.06908809f, -0.02118303f, -0.04819484f, -0.00236585f, -0.02300901f, 0.01098058f, 
    0.05026706f, -0.04779165f, -0.00011389f, 0.05773425f, -0.02204348f, 0.03587921f, 0.00180956f, -0.03102219f, 
    0.02227102f, -0.04041089f, 0.03136024f, -0.02476324f, 0.01853895f, 0.02236919f, -0.00024809f, 0.01920578f, 
    0.04465222f, -0.04418268f, 0.00057921f, -0.06047084f, -0.01558185f, -0.05305792f, 0.01503723f, 0.04104802f, 
    0.03401972f, -0.04583588f, -0.02158935f, -0.05353434f, -0.01264755f, -0.03886842f, 0.03695798f, 0.03776648f, 
    -0.10929149f, 0.03358625f, -0.18182786f, 0.32377386f, -0.09245682f, 0.04768433f, 0.05638157f, 0.16514222f, 
    0.09314930f, -0.01205427f, 0.22081548f, 0.02740582f, -0.12187894f, -0.12104412f, -0.10566266f, -0.04358505f, 
    -0.11465245f, 0.02442080f, -0.00233267f, 0.04446601f, -0.06276248f, 0.03148362f, -0.02624276f, 0.01442199f, 
    -0.01409253f, 0.18984403f, 0.00402583f, 0.10035878f, 0.07434886f, 0.09763250f, -0.10806841f, -0.00275115f, 
    0.08094244f, 0.08272702f, -0.04377353f, -0.08060890f, -0.11409751f, -0.14096387f, -0.16983517f, 0.08694189f, 
    -0.04597660f, -0.23697616f, 0.06072498f, -0.00941998f, -0.02923677f, -0.09838644f, -0.06397617f, 0.03318844f, 
    -0.51043624f, 0.12973972f, 0.01094002f, 0.16408664f, 0.06384280f, -0.06058887f, 0.02782284f, 0.02440257f, 
    0.20860164f, 0.02625067f, 0.17337768f, 0.07536232f, -0.15673216f, 0.02997331f, -0.12825984f, -0.22063656f, 
    -0.06446271f, -0.01317848f, -0.06875446f, -0.07759830f, 0.02722768f, -0.09956596f, -0.02116078f, -0.04150159f, 
    0.02429155f, 0.18982656f, 0.04890018f, 0.07500882f, -0.02773433f, 0.28130522f, -0.00864479f, 0.09493669f, 
    0.08038691f, 0.04777687f, -0.02322662f, 0.00145630f, 0.17428119f, -0.03907537f, -0.00731006f, 0.08216421f, 
    -0.04885656f, -0.03512873f, 0.09313565f, 0.02332158f, 0.04290607f, -0.00583433f, -0.09521604f, 0.10043443f, 
    0.01391206f, 0.00452654f, 0.08983875f, -0.10256328f, 0.07540854f, -0.01778195f, 0.01099628f, 0.09684014f, 
    -0.00749172f, 0.10061904f, 0.04848792f, 0.11642674f, 0.28100866f, -0.11772700f, 0.00160012f, 0.05349848f, 
    -0.05403939f, 0.02015332f, -0.16859785f, -0.04279375f, -0.01964547f, 0.08754764f, 0.08128649f, -0.01233043f, 
    0.14598237f, 0.15517043f, 0.14172585f, -0.09512426f, 0.11498309f, 0.07728534f, -0.02157392f, 0.07797663f, 
    -0.04437917f, 0.04403691f, 0.14455917f, -0.18490177f, -0.11553866f, -0.05850552f, 0.00785509f, -0.09456761f, 
    -0.04327008f, 0.02104609f, -0.00136677f, 0.15401258f, -0.00984706f, 0.03466641f, 0.13488777f, 0.03130417f, 
    0.19002499f, 0.07423705f, 0.26989603f, 0.11128344f, 0.04650200f, -0.07589692f, 0.00804763f, 0.02177575f, 
    0.05726174f, -0.01320546f, -0.07448354f, 0.04643358f, 0.03015513f, 0.02664872f, 0.17490275f, -0.18373422f, 
    -0.06643798f, 0.05149546f, 0.02790730f, -0.03456306f, -0.14625645f, -0.16771527f, 0.03028726f, 0.02056831f, 
    -0.14384848f, -0.05879888f, 0.21396866f, -0.01569117f, -0.01874022f, -0.08358316f, -0.08428072f, 0.03791329f, 
    -0.09401863f, 0.04254552f, 0.01422308f, -0.12749477f, 0.07529939f, 0.26110277f, -0.14769475f, 0.18040660f, 
    -0.04850229f, 0.25208819f, 0.01569539f, 0.08485820f, 0.09416445f, -0.09705196f, -0.12579767f, 0.01967855f, 
    0.07372415f, 0.04875799f, -0.21792375f, 0.15537262f, -0.02290846f, 0.04376774f, -0.01838463f, 0.14921093f, 
    0.07781659f, 0.10158893f, 0.03609724f, -0.01456403f, -0.13817962f, -0.14471012f, -0.00296402f, 0.00559380f, 
    -0.03790013f, -0.07724399f, 0.09165441f, 0.07574755f, 0.01172071f, -0.01886616f, -0.00238163f, 0.06234464f, 
    -0.09789706f, 0.08624785f, 0.01493323f, 0.08501223f, -0.02063982f, 0.08566850f, -0.08903272f, 0.04482367f, 
    -0.01513922f, 0.10716709f, 0.02747050f, -0.05736500f, -0.28166145f, 0.09796232f, 0.00015805f, 0.11913349f, 
    -0.07892813f, -0.02022126f, -0.09187564f, 0.08052065f, 0.07152487f, 0.07480812f, -0.09389725f, 0.09605914f, 
    -0.31370538f, 0.03930008f, -0.07774396f, 0.08669486f, 0.00254650f, -0.09646634f, 0.16512999f, -0.13884763f, 
    0.03800364f, 0.07140092f, -0.06234563f, 0.17852511f, -0.09021543f, -0.02034578f, -0.00269324f, -0.22529207f, 
    0.02592379f, -0.07894089f, 0.05570119f, -0.06892655f, 0.09114341f, -0.02967571f, 0.12471877f, 0.07771233f, 
    0.00007950f, 0.08746713f, 0.21833970f, 0.19260775f, -0.03136473f, 0.11959657f, 0.17468879f, 0.13803814f, 
    -0.01833432f, 0.15198238f, -0.03871753f, 0.00162147f, 0.24529183f, 0.06038216f, -0.06762975f, 0.27613506f, 
    0.06761351f, 0.10069153f, 0.09407634f, 0.03639930f, 0.13363154f, 0.02186766f, -0.04822503f, 0.01929820f, 
    -0.36436203f, -0.23112917f, -0.03083234f, 0.03975947f, 0.02241849f, -0.00735394f, -0.08827160f, -0.04849876f, 
    -0.04264931f, 0.04042712f, 0.01729543f, 0.14363445f, 0.30863696f, 0.10941001f, 0.06376752f, 0.04307624f, 
    0.06663024f, -0.02920442f, -0.02824466f, 0.03105943f, -0.03480165f, -0.04098873f, 0.15707339f, 0.11282758f, 
    -0.08875632f, 0.22891447f, 0.15680099f, -0.13923441f, 0.12458999f, 0.00672739f, -0.03393709f, 0.03845803f, 
    -0.02028251f, -0.02663913f, 0.05758867f, -0.07497092f, -0.14955302f, -0.03130989f, 0.03457877f, -0.08739290f, 
    -0.09225880f, 0.03384729f, 0.06539243f, -0.01001121f, -0.04239530f, -0.10098741f, 0.03633261f, 0.07107925f, 
    -0.11538086f, -0.25279042f, 0.14438932f, 0.04509057f, 0.10181675f, 0.08026316f, 0.00459127f, 0.12609361f, 
    0.06621458f, 0.00702433f, 0.10156968f, 0.04204383f, 0.06129410f, 0.05901257f, 0.01173515f, 0.05352082f, 
    -0.00062636f, -0.07793715f, 0.06583583f, -0.07264424f, -0.08912502f, -0.02035105f, 0.17011757f, 0.01623778f, 
    -0.21420206f, 0.10730725f, 0.08678332f, 0.10619512f, -0.01916710f, -0.04477927f, -0.12008980f, -0.01960462f, 
    0.04518156f, 0.02260661f, 0.10704263f, -0.08443220f, -0.20506111f, -0.19857188f, -0.22901073f, 0.19560325f, 
    -0.01432047f, 0.20100598f, 0.09317506f, 0.03894127f, -0.03909460f, -0.08483059f, -0.01226974f, -0.06341309f, 
    -0.18297774f, -0.08423501f, 0.01788652f, 0.12277190f, 0.06715692f, 0.07130111f, -0.00082106f, 0.13927491f, 
    0.11232606f, 0.08305220f, -0.10719142f, 0.01509292f, -0.05459978f, -0.12194262f, -0.11992321f, -0.07905567f, 
    0.22917454f, -0.01473743f, 0.05235908f, 0.08027332f, 0.00865217f, 0.09635387f, 0.01345995f, 0.11909394f, 
    -0.10612392f, 0.13154365f, 0.25342223f, 0.15591507f, 0.20681545f, 0.14144218f, 0.09193368f, 0.21285002f, 
    -0.10701711f, 0.08338909f, -0.01347485f, -0.03243711f, 0.06533698f, -0.30991533f, -0.05804693f, 0.14401197f, 
    0.00939651f, -0.07984152f, 0.02490035f, 0.18293519f, -0.01297838f, -0.01478047f, -0.00144612f, 0.10145357f, 
    0.00964851f, -0.05828822f, 0.09961366f, 0.19612952f, 0.12222400f, -0.13500325f, 0.03193662f, 0.06411195f, 
    0.10132621f, -0.00299750f, -0.18503298f, 0.10743894f, -0.06447069f, 0.01239362f, -0.13831834f, -0.10735410f, 
    -0.00019402f, 0.07474824f, -0.00307481f, 0.02572829f, 0.21394600f, 0.03268855f, 0.00420029f, 0.02048763f, 
    0.03239811f, 0.17359065f, 0.22446659f, 0.06918005f, 0.20685016f, 0.11284085f, -0.02232729f, 0.20710926f, 
    -0.07122590f, 0.10847127f, 0.05106330f, 0.11616042f, -0.16491899f, 0.28173551f, -0.19422226f, -0.10167324f, 
    0.16792300f, -0.07146746f, 0.16064593f, 0.03534699f, 0.04001407f, 0.08649641f, 0.01041439f, 0.11192720f, 
    -0.43352896f, -0.04521354f, -0.05531762f, -0.21535523f, -0.03642717f, 0.14615251f, -0.04040719f, 0.06054053f, 
    0.06978659f, -0.05947207f, 0.06902178f, 0.15536240f, 0.31454369f, 0.14505874f, -0.19871658f, 0.09531356f, 
    0.09354467f, 0.04141903f, 0.00185787f, 0.05590950f, 0.08618177f, 0.07577658f, 0.15932108f, -0.12008619f, 
    -0.18687305f, 0.13581286f, 0.10032130f, 0.13156421f, 0.02606180f, -0.06854679f, 0.07776149f, 0.02727204f, 
    -0.09892941f, -0.10120687f, 0.05637794f, -0.06199127f, -0.21106143f, 0.01444382f, -0.11938142f, -0.23032100f, 
    0.00298238f, 0.03954359f, 0.00273917f, -0.08077244f, 0.12389819f, -0.02139096f, -0.02971114f, 0.02309894f, 
    -0.28420842f, -0.11703163f, 0.08732466f, -0.00219023f, 0.01075137f, 0.14154695f, 0.10985757f, 0.04002893f, 
    0.12310731f, 0.04832881f, 0.02735098f, 0.07381935f, -0.27738243f, 0.16174060f, 0.05933742f, -0.29775187f, 
    -0.02304114f, -0.10961623f, 0.07697231f, 0.02544761f, 0.06250107f, -0.05029761f, 0.05385784f, 0.13012469f, 
    -0.32385346f, -0.15741901f, 0.09764033f, 0.03451777f, 0.05464886f, 0.14261159f, -0.06671694f, 0.07238431f, 
    -0.08531644f, 0.08021653f, -0.07861189f, -0.01173099f, -0.15734981f, 0.04485028f, 0.02433921f, 0.07160206f, 
    -0.00209771f, 0.17298715f, 0.02475443f, 0.01704281f, -0.01523050f, -0.02063145f, 0.00966052f, 0.17482302f, 
    0.05820652f, -0.02726396f, 0.05470993f, -0.01841614f, -0.05106301f, 0.00724998f, 0.02076818f, -0.05378103f, 
    0.02548471f, -0.03149094f, -0.08248472f, 0.01305480f, -0.05797511f, -0.01758996f, -0.00885664f, 0.01768541f, 
    -0.07004021f, 0.03207190f, -0.02612625f, -0.03269915f, -0.07969430f, -0.04284300f, 0.00591620f, 0.01967815f, 
    -0.03886099f, 0.04878978f, -0.01820913f, -0.04966536f, -0.05950832f, -0.05486047f, -0.06697472f, -0.05858648f, 
    0.01906181f, 0.00733713f, -0.01304353f, 0.05606592f, -0.07163066f, -0.00492357f, -0.05624407f, -0.05489626f, 
    0.04209448f, -0.06445367f, -0.04947371f, -0.04787054f, 0.01209966f, -0.04704147f, 0.03581768f, 0.05105028f, 
    0.00620732f, 0.01169679f, -0.02432370f, 0.04520638f, -0.02961142f, 0.01200812f, 0.01120497f, 0.00860286f, 
    0.01958494f, -0.05477848f, -0.02319516f, -0.02989127f, -0.01777369f, -0.01798866f, 0.04267177f, 0.04542251f, 
    -0.03057753f, 0.05999468f, -0.07064022f, -0.05588467f, 0.00475420f, -0.07272168f, 0.05420773f, 0.00186314f, 
    0.03910368f, 0.05379171f, -0.03666483f, -0.01902282f, 0.01223156f, 0.02039674f, 0.01993430f, 0.04440490f, 
    0.03910542f, -0.03280013f, -0.07437690f, -0.00516657f, 0.03889079f, -0.03855054f, 0.01946735f, 0.06204752f, 
    -0.07396076f, 0.04722909f, -0.04926306f, -0.03722646f, -0.07066061f, -0.02266384f, -0.06024174f, 0.02592793f, 
    -0.01047191f, -0.04654491f, 0.05754833f, 0.05553974f, 0.05676092f, 0.01675137f, -0.03202773f, -0.04905100f, 
    0.04323794f, 0.02522015f, -0.01406363f, 0.04871463f, -0.07650717f, -0.04098205f, -0.01086882f, -0.06225812f, 
    0.01965206f, 0.03444820f, -0.02029543f, -0.02794551f, -0.06372197f, -0.04561505f, -0.00091535f, -0.06720171f, 
    -0.02458692f, 0.05209298f, -0.05112178f, -0.07884969f, 0.04579056f, 0.05032646f, 0.01610203f, -0.06536163f, 
    -0.01575940f, -0.03118050f, 0.00840896f, 0.01633587f, 0.03794471f, -0.03105394f, -0.04742953f, 0.00917357f, 
    0.02472638f, 0.04811309f, -0.02306095f, -0.04248443f, 0.03783441f, -0.03446271f, -0.06403261f, -0.00039582f, 
    -0.01010910f, -0.03282357f, -0.02857696f, 0.02137754f, 0.02367264f, 0.01295859f, 0.04671190f, 0.00061804f, 
    0.02874141f, -0.00080765f, -0.02180039f, -0.02003841f, -0.02134128f, -0.05831270f, -0.01937732f, -0.07815596f, 
    0.02390715f, -0.06432227f, 0.02801720f, -0.03283625f, 0.03416007f, -0.04500606f, -0.04205964f, 0.04460558f, 
    0.04630367f, 0.03939427f, 0.01112133f, -0.04613310f, 0.02684701f, 0.01325652f, 0.00229026f, -0.02847825f, 
    -0.06224861f, 0.00069357f, -0.06071932f, -0.03661582f, -0.03526952f, 0.02379813f, 0.00196358f, -0.00904399f, 
    -0.01555957f, -0.00674062f, -0.05542283f, 0.01498993f, -0.06898612f, -0.05335369f, 0.02019837f, 0.03741373f, 
    0.12169214f, 0.00633462f, 0.09607059f, -0.01200321f, 0.04937510f, -0.20329207f, 0.13474980f, -0.00368749f, 
    -0.05202616f, -0.00248061f, 0.07051736f, -0.06781032f, -0.01401936f, 0.13977908f, 0.12323318f, -0.03755163f, 
    -0.11549528f, -0.04951730f, -0.04814079f, 0.07234938f, 0.05962365f, -0.05495511f, 0.03997121f, 0.08983751f, 
    -0.03295452f, 0.38196552f, -0.24222048f, -0.00656954f, 0.03071290f, 0.05381275f, -0.00960300f, -0.05410872f, 
    0.09863760f, -0.04734521f, -0.02648209f, -0.02575758f, 0.29756230f, -0.14778449f, -0.03810206f, -0.11920124f, 
    0.04303814f, -0.10724018f, 0.00035385f, -0.01531657f, 0.00719618f, 0.18189491f, -0.00257273f, 0.09324231f, 
    -0.07872690f, 0.16244361f, -0.02792134f, -0.21366568f, 0.05745317f, 0.03336344f, 0.01043339f, 0.03707602f, 
    -0.00793356f, -0.02915973f, -0.06300627f, -0.09274860f, 0.01321161f, 0.10852105f, 0.10181035f, 0.01689179f, 
    -0.06831182f, 0.02837159f, 0.02963199f, -0.03551027f, 0.01490016f, 0.09474652f, -0.03059015f, 0.06642613f, 
    -0.01683614f, 0.18725586f, -0.33956301f, 0.10217101f, -0.04218822f, 0.08294370f, -0.01040631f, -0.05320452f, 
    0.14617771f, -0.16030052f, 0.06469284f, 0.01429181f, 0.14800249f, -0.36996314f, 0.17034873f, 0.40151772f, 
    -0.04434791f, 0.08616569f, 0.00591917f, 0.07298793f, 0.12021770f, -0.00201978f, 0.02966618f, 0.05941521f, 
    0.24698365f, -0.23270062f, 0.10664289f, 0.19157849f, -0.06607573f, 0.01207570f, 0.08485694f, 0.07607780f, 
    0.06260312f, 0.12102922f, -0.05577235f, 0.00933261f, 0.03752537f, -0.22952281f, 0.09338036f, 0.03282816f, 
    0.03158723f, -0.06354211f, -0.00398941f, -0.07596047f, 0.04622979f, 0.02722351f, -0.09994319f, 0.03655778f, 
    0.17048416f, -0.01836740f, -0.04730933f, 0.16655520f, -0.12413346f, 0.10985620f, 0.01432695f, -0.02257021f, 
    0.04105821f, -0.00939215f, 0.06080910f, -0.09175736f, 0.29857412f, 0.07057602f, 0.09093449f, -0.07490057f, 
    -0.08000867f, -0.05968719f, 0.00202945f, 0.08457227f, 0.05097202f, -0.03813057f, -0.08720092f, -0.09463382f, 
    0.23184271f, 0.11406286f, -0.01358153f, 0.13549778f, -0.00598773f, -0.04304316f, 0.10373662f, -0.02804756f, 
    -0.10659214f, -0.06086639f, 0.05854565f, 0.03921171f, 0.21171959f, -0.15271747f, 0.06235445f, -0.00278050f, 
    0.03142962f, -0.04743051f, -0.10260686f, 0.07438380f, -0.08146100f, 0.02664435f, -0.03832562f, 0.08911969f, 
    0.14104912f, -0.03617201f, 0.00423539f, -0.28943041f, 0.02713139f, -0.00922930f, 0.01644261f, 0.07495902f, 
    0.00243353f, -0.01047097f, -0.00812545f, 0.04936299f, 0.28170252f, 0.08870224f, -0.15194960f, 0.17752388f, 
    -0.04960700f, 0.03030135f, 0.07168384f, 0.09187336f, 0.01623034f, -0.15853174f, 0.09792164f, 0.07266703f, 
    -0.04370866f, -0.06365401f, -0.06261595f, -0.04094788f, -0.05225842f, 0.01577882f, 0.04208769f, -0.06338849f, 
    -0.06354515f, 0.02508129f, -0.06728816f, 0.00323926f, -0.06908639f, 0.03018754f, 0.05457556f, 0.03591246f, 
    0.05457244f, -0.03885724f, 0.04795647f, -0.05017883f, -0.03773560f, -0.06205640f, -0.06327073f, -0.06370544f, 
    -0.00828607f, 0.04781161f, -0.01506171f, -0.02527682f, 0.04759710f, 0.05653000f, -0.04753247f, 0.00719209f, 
    0.03573602f, 0.04691752f, -0.06981901f, -0.03607690f, 0.02980052f, -0.03477560f, 0.02469571f, -0.04033552f, 
    0.02877307f, 0.06408383f, -0.01047195f, 0.04137981f, -0.03802530f, 0.04517931f, 0.01987829f, -0.03666081f, 
    0.06570452f, -0.00290980f, 0.05529160f, 0.00737871f, -0.06867737f, -0.04217521f, 0.06286953f, -0.06122886f, 
    -0.03977668f, 0.03823657f, 0.02484438f, -0.04787423f, -0.01057618f, 0.01885917f, 0.03933478f, -0.02433618f, 
    -0.05297618f, 0.03137565f, -0.00172779f, 0.00380206f, -0.05602684f, 0.05114562f, -0.06677784f, -0.07019540f, 
    -0.01689808f, 0.02147810f, 0.01867977f, 0.05211289f, 0.04728187f, -0.00094465f, -0.03532997f, -0.05673948f, 
    -0.04506649f, -0.05110670f, 0.06212096f, 0.01243206f, -0.05093911f, -0.00582233f, 0.02633834f, -0.00307785f, 
    -0.05463280f, 0.01624902f, -0.06319629f, 0.01539105f, -0.03633393f, -0.04675954f, -0.02293678f, 0.07056762f, 
    0.04518221f, -0.01450567f, -0.06025066f, -0.06801358f, -0.06321466f, -0.00739572f, -0.01022006f, -0.04868976f, 
    0.02638050f, -0.06996051f, -0.07173473f, -0.04443287f, 0.05234992f, -0.06968609f, 0.02127648f, 0.07018416f, 
    0.01684694f, 0.01478735f, 0.00940251f, -0.03920098f, -0.03027367f, -0.02449489f, 0.00642107f, 0.02830163f, 
    0.06900753f, -0.06933144f, -0.05617414f, 0.06142827f, 0.04254372f, 0.01094240f, -0.05448572f, -0.05547781f, 
    -0.06158930f, -0.06706315f, -0.06045057f, -0.04204093f, -0.02176843f, 0.02239353f, 0.00019251f, -0.05296093f, 
    0.03687545f, -0.00008906f, -0.00292110f, 0.01838810f, -0.01012219f, 0.00676634f, 0.05351311f, -0.05883368f, 
    0.00223596f, -0.05891728f, -0.00738548f, 0.03173790f, -0.03469249f, 0.02029549f, -0.05395983f, -0.01360119f, 
    -0.07130579f, 0.02225538f, -0.06856814f, -0.04933871f, 0.03219534f, -0.04102484f, -0.01877771f, 0.05086301f, 
    0.06047429f, -0.00511091f, -0.02437307f, 0.06211429f, -0.05142680f, -0.01537216f, 0.07164460f, -0.04755676f, 
    -0.01780510f, -0.03941827f, -0.05882069f, -0.05992295f, 0.02370251f, 0.03727314f, 0.01144079f, -0.02895861f, 
    -0.06780285f, 0.06076108f, 0.00706480f, 0.04235188f, 0.04925760f, -0.00454807f, -0.01427194f, 0.02140812f, 
    -0.00293743f, -0.04303179f, -0.05525371f, 0.02138183f, -0.01385348f, 0.00913356f, -0.05305451f, 0.03774149f, 
    0.02733635f, -0.00844077f, -0.06563951f, 0.02222299f, -0.02466236f, 0.02937973f, 0.04991687f, -0.06987222f, 
    -0.00105310f, -0.04160041f, 0.06239180f, -0.03193051f, -0.05126430f, 0.02091021f, -0.08033089f, 0.01607998f, 
    -0.01596255f, 0.00955099f, -0.03455535f, -0.03853298f, -0.07260005f, -0.00383066f, -0.07123562f, -0.01948447f, 
    0.02144371f, -0.00235778f, 0.00359699f, -0.07326274f, -0.05241477f, -0.01436910f, -0.00172737f, 0.05551816f, 
    0.03258670f, 0.01034440f, -0.02012410f, 0.02309318f, -0.05448809f, 0.05871730f, 0.01517180f, 0.03079458f, 
    0.02502793f, 0.04918286f, -0.07090185f, -0.00304058f, -0.03137045f, -0.05529404f, 0.00573982f, -0.05233448f, 
    0.05717066f, 0.03340556f, 0.04656759f, 0.05900063f, -0.08019239f, -0.03165814f, 0.00763217f, 0.04457344f, 
    -0.05796142f, 0.04669424f, 0.04544626f, 0.00824560f, -0.03130712f, -0.06144238f, 0.01336824f, -0.02353577f, 
    0.03669032f, -0.03343004f, -0.00183809f, -0.00335920f, -0.00137561f, -0.07763379f, 0.01722202f, -0.07260866f, 
    -0.01245008f, -0.02073237f, 0.05905681f, -0.01434470f, -0.07360663f, 0.00951159f, -0.00247294f, -0.04212954f, 
    0.04715487f, 0.01960411f, -0.00738674f, 0.04196065f, -0.01809671f, 0.03999128f, 0.04454682f, -0.00447152f, 
    -0.05550368f, 0.00175126f, -0.07725642f, 0.06512498f, -0.05485773f, -0.06210495f, -0.03795985f, -0.04143895f, 
    -0.00440765f, -0.02865734f, -0.06047666f, 0.03035639f, -0.07691655f, 0.02016905f, -0.07224466f, 0.01863131f, 
    -0.00866230f, -0.07088373f, -0.03076145f, -0.06950660f, -0.04357314f, -0.02458570f, 0.03085702f, -0.05357714f, 
    -0.07623689f, 0.00144980f, -0.02975665f, 0.04767872f, 0.04293808f, 0.03407583f, -0.05555731f, -0.02483232f, 
    0.00816789f, 0.04258318f, 0.00241225f, -0.07485625f, -0.01075522f, 0.03570446f, 0.05725394f, 0.02371647f, 
    -0.07259010f, -0.02006910f, -0.05315686f, -0.01361288f, -0.04362407f, 0.01399733f, -0.06218806f, -0.03912714f, 
    -0.00161192f, -0.00597782f, -0.08071698f, -0.06715189f, -0.05827207f, -0.04507270f, -0.04579869f, -0.01229140f, 
    0.00862425f, -0.07621565f, -0.01161142f, 0.01175191f, -0.01851144f, -0.05566338f, -0.00548300f, 0.03184193f, 
    -0.03328664f, 0.03973659f, -0.06657361f, 0.05771702f, 0.05404010f, -0.00941738f, 0.06468824f, -0.01802583f, 
    0.05204372f, -0.05229456f, 0.03931756f, -0.04600094f, 0.06218627f, -0.01040270f, -0.05671190f, 0.05571200f, 
    0.02651717f, 0.03516906f, -0.04863608f, 0.06568880f, -0.02812612f, -0.01514134f, -0.06118695f, -0.05013855f, 
    -0.05621730f, -0.00680670f, -0.01441062f, 0.02392044f, 0.00470347f, -0.04179040f, 0.00007336f, 0.01796524f, 
    -0.03851037f, 0.05105037f, 0.05294467f, -0.02244392f, -0.01212815f, -0.05921565f, 0.05200547f, 0.05765871f, 
    -0.01565557f, -0.10585890f, 0.07910371f, 0.08305224f, 0.19110323f, -0.04201382f, -0.07736961f, -0.11913693f, 
    0.05381927f, -0.09587254f, 0.09175462f, 0.00858065f, 0.16039047f, 0.26676130f, 0.11765476f, -0.01816564f, 
    0.08503351f, -0.01453530f, 0.01790393f, -0.00602799f, -0.05473900f, -0.01851425f, -0.09230731f, 0.15329872f, 
    0.12228137f, -0.00899007f, -0.13217168f, 0.07003590f, 0.02785064f, -0.03874528f, 0.04716664f, 0.04857405f, 
    0.05627825f, -0.03551108f, 0.03815681f, 0.01448563f, 0.30834624f, -0.03951127f, -0.24126522f, -0.05971290f, 
    0.07438777f, 0.02604330f, -0.04918956f, 0.01175335f, 0.07964899f, 0.14392057f, 0.07763917f, -0.00963379f, 
    -0.13911830f, 0.15494494f, 0.12847775f, -0.14444594f, 0.03936288f, 0.16387615f, -0.07767971f, -0.07877966f, 
    -0.07337093f, -0.11157805f, -0.08266471f, -0.01876486f, -0.08289010f, -0.09429362f, -0.05233001f, 0.11950840f, 
    -0.00719065f, 0.07701906f, 0.02926418f, -0.06822632f, -0.11455282f, 0.12843080f, -0.08339016f, 0.06007608f, 
    -0.12087127f, -0.04123677f, -0.14677449f, -0.01977561f, -0.01457675f, -0.07178976f, -0.00915661f, -0.14905466f, 
    0.15406750f, -0.11171516f, 0.17624395f, 0.09783506f, -0.12780502f, -0.26327518f, 0.22617817f, 0.20771191f, 
    -0.01109578f, -0.01402934f, 0.07670350f, -0.03614141f, 0.09180976f, -0.05906638f, -0.04244466f, 0.14893675f, 
    0.37702295f, -0.06066035f, 0.05260681f, 0.21834978f, -0.12929466f, 0.05691281f, 0.05992941f, 0.08477318f, 
    0.00395635f, 0.03442179f, 0.00579894f, -0.10178493f, -0.01747672f, -0.14458324f, 0.06723360f, -0.00444225f, 
    0.04648930f, -0.10017635f, -0.00237210f, 0.03319161f, 0.10612967f, 0.14572172f, -0.13089141f, -0.00197934f, 
    -0.27014688f, -0.01821776f, -0.04653831f, 0.22048584f, -0.02312486f, -0.01777557f, -0.07993490f, 0.02587020f, 
    0.12634318f, -0.02438506f, 0.06776321f, 0.01642238f, 0.15233772f, -0.02818383f, -0.12953490f, 0.05362799f, 
    -0.11291358f, -0.04692130f, -0.00963859f, 0.00250032f, -0.00477483f, -0.00705943f, -0.02829339f, -0.07611665f, 
    0.23595038f, 0.15712312f, 0.01650023f, -0.05166786f, -0.04195835f, 0.05026768f, -0.08688779f, 0.10068025f, 
    0.01889719f, 0.00134719f, 0.16021675f, 0.01593491f, 0.21910602f, -0.06645221f, 0.11565192f, 0.02974824f, 
    -0.01493069f, -0.00361630f, -0.20954816f, 0.03388502f, -0.10601936f, 0.13876294f, 0.00905851f, -0.05647937f, 
    0.08024886f, 0.11446126f, -0.16168906f, -0.11691494f, 0.00255838f, -0.02432569f, 0.12562589f, 0.01734909f, 
    0.07920057f, -0.00312185f, -0.09286552f, 0.09077091f, 0.21446520f, 0.07203939f, -0.10005182f, 0.06228900f, 
    0.14059193f, -0.15428194f, -0.04433029f, 0.04355659f, 0.00974568f, -0.18510458f, 0.07224707f, 0.06643286f, 
    -0.04083580f, -0.02502694f, 0.04791579f, 0.06093193f, -0.03720339f, 0.01306748f, 0.01957533f, 0.01257039f, 
    0.02520677f, -0.00880858f, -0.05970562f, 0.02982231f, -0.04092931f, -0.01481390f, -0.06586535f, -0.04410862f, 
    0.01602806f, -0.07585593f, 0.06247269f, 0.04436064f, 0.04837339f, 0.00807531f, -0.00396409f, -0.00443746f, 
    -0.05860314f, -0.01407622f, 0.03003564f, 0.03039151f, 0.03280660f, -0.02414726f, -0.04717956f, -0.05902950f, 
    0.01964959f, -0.05658802f, -0.07901132f, 0.02907057f, -0.02180530f, 0.00720967f, 0.01611658f, -0.05401018f, 
    0.01923776f, -0.06140240f, 0.03527828f, -0.03786489f, -0.01648351f, 0.06407520f, -0.02379191f, 0.01135954f, 
    -0.06637035f, 0.00543376f, -0.05808761f, 0.05158436f, -0.03194628f, -0.00333812f, -0.04965198f, -0.02255146f, 
    0.00658347f, -0.01661351f, 0.04076191f, 0.04076831f, -0.03951473f, -0.08107879f, 0.01930253f, -0.05805780f, 
    -0.07760782f, 0.00162067f, 0.05053173f, 0.05144267f, -0.02784552f, 0.00164389f, -0.06180139f, -0.05740824f, 
    -0.05491421f, -0.07171820f, -0.02888257f, 0.01734551f, -0.05812399f, -0.06822590f, 0.03966053f, -0.01837061f, 
    0.00391109f, 0.03486957f, 0.05106905f, 0.00488665f, 0.06682897f, -0.04375306f, 0.00485752f, -0.00771236f, 
    0.00303685f, -0.07318158f, 0.02681201f, -0.02622758f, -0.01885022f, -0.08883561f, 0.02851542f, -0.07269168f, 
    -0.01738120f, 0.05379631f, -0.05305437f, -0.03099625f, 0.00970199f, 0.03821391f, -0.08175718f, 0.01920034f, 
    -0.01421697f, 0.05100146f, -0.00585994f, -0.06121724f, -0.08862320f, 0.01647602f, -0.01078003f, -0.03060196f, 
    0.03718704f, -0.07252087f, 0.06238469f, 0.03890790f, 0.01157660f, 0.06504649f, -0.01406128f, -0.03864131f, 
    0.00864153f, -0.08301139f, 0.04929973f, -0.08605889f, -0.08100115f, -0.01591017f, 0.03421581f, 0.02089958f, 
    -0.02417818f, -0.00752080f, -0.06954621f, 0.06788783f, -0.04729868f, 0.01169762f, 0.01624292f, 0.02951044f, 
    0.06846150f, 0.00830020f, 0.00290904f, -0.08641992f, 0.00975691f, -0.08265623f, 0.02848743f, 0.03472965f, 
    0.08377890f, 0.02030803f, -0.07288217f, -0.03046031f, 0.05432575f, -0.00632967f, -0.05266250f, -0.00578566f, 
    -0.05438083f, 0.02438662f, 0.03479151f, 0.01994677f, -0.01134228f, 0.01574246f, 0.04794810f, -0.09387191f, 
    -0.08112203f, -0.01674889f, -0.09589524f, -0.04320865f, 0.01924484f, -0.06313933f, -0.01369038f, -0.03612788f, 
    -0.03766492f, 0.02670610f, -0.09048645f, -0.03861452f, -0.02062279f, -0.00268757f, -0.08539971f, -0.04986534f, 
    0.03459305f, -0.01810202f, -0.02251578f, -0.06070110f, 0.05055056f, -0.06611153f, -0.03976901f, -0.02760234f, 
    -0.07989960f, 0.02631315f, -0.01728970f, 0.01352973f, 0.00397149f, 0.00941212f, 0.03268977f, -0.01026571f, 
    0.01869546f, -0.01673568f, -0.00706236f, -0.09453120f, 0.10839067f, 0.07346358f, -0.18235160f, 0.01067129f, 
    0.03203605f, 0.03362941f, 0.10773717f, 0.07049499f, 0.15164699f, 0.12627599f, 0.16945644f, -0.00008138f, 
    -0.05571445f, 0.10581097f, -0.04881469f, 0.06752281f, 0.05515875f, -0.00602332f, -0.12551783f, 0.20539619f, 
    0.19452393f, 0.01551691f, -0.03737052f, 0.07550164f, -0.11752398f, 0.04091638f, 0.05419262f, 0.00057355f, 
    0.23377761f, -0.05057344f, 0.07419764f, 0.00959131f, 0.46986786f, -0.04747721f, -0.12808038f, 0.13143325f, 
    0.04969355f, -0.05018413f, -0.04511252f, -0.01271506f, -0.09530353f, 0.15043291f, 0.02597031f, 0.01870536f, 
    -0.08271920f, 0.05307534f, 0.10696022f, -0.17222412f, -0.03366394f, 0.12427356f, 0.05444932f, -0.05346941f, 
    0.01917036f, 0.04182534f, 0.04949101f, 0.08932607f, -0.15887506f, 0.05992523f, -0.02343816f, -0.01320292f, 
    0.07224483f, -0.09344662f, -0.03895578f, -0.01134467f, -0.07150456f, 0.04554145f, 0.06071230f, -0.04032532f, 
    -0.22453800f, -0.04244392f, -0.09296718f, 0.02354522f, -0.00391437f, 0.06325336f, -0.08599619f, 0.06371333f, 
    0.06118619f, -0.00626804f, 0.12342009f, 0.08797659f, 0.08783983f, -0.14109044f, 0.24541768f, 0.28204241f, 
    0.11677758f, 0.00545092f, -0.08633389f, 0.03658061f, 0.01421569f, -0.07087541f, -0.07424564f, 0.18022309f, 
    0.10465244f, -0.33307889f, -0.03300729f, 0.14742035f, 0.01034152f, -0.03147576f, -0.04539039f, -0.04881831f, 
    0.06982896f, 0.03393358f, 0.12216447f, -0.04730950f, 0.36014554f, 0.02805089f, -0.01911010f, 0.06221482f, 
    0.05464808f, 0.02434122f, -0.04002099f, 0.05901208f, -0.06092530f, -0.02512683f, -0.06538653f, -0.00725668f, 
    -0.45132828f, 0.22086550f, -0.03829444f, 0.03094230f, 0.06902543f, 0.05250949f, 0.00622118f, 0.13144045f, 
    0.04846355f, 0.03044028f, -0.06457018f, 0.02707901f, -0.28427622f, -0.09841219f, -0.14944108f, 0.07061174f, 
    -0.01848778f, -0.10983481f, -0.02764559f, 0.13850126f, -0.05680678f, -0.06490490f, -0.04275287f, -0.22338369f, 
    0.18587314f, -0.23180450f, 0.00925214f, 0.06599917f, -0.10869728f, -0.04467235f, 0.01075166f, 0.06971942f, 
    0.02352470f, -0.13371329f, 0.18874112f, -0.12020672f, 0.17875078f, -0.08564322f, 0.04167174f, -0.14390919f, 
    0.10237245f, -0.01242325f, 0.00493126f, -0.04906808f, -0.05080482f, 0.10976125f, 0.06689501f, 0.04865485f, 
    0.18214218f, 0.10231986f, -0.03792621f, -0.17362660f, -0.06317712f, 0.02281057f, -0.01153614f, 0.10123778f, 
    0.05644890f, -0.00203697f, -0.13582425f, 0.17143118f, 0.10771968f, -0.11524027f, -0.22737035f, 0.22645940f, 
    0.14615518f, -0.04571293f, 0.03550437f, -0.13148755f, -0.00723689f, -0.09446575f, 0.09285145f, 0.00450704f, 
    0.08008071f, 0.23943353f, 0.13561876f, 0.15492246f, -0.07614294f, -0.00573949f, 0.07945722f, 0.04788861f, 
    -0.05116380f, 0.05370234f, 0.01645796f, 0.10975277f, -0.21556889f, -0.10923412f, 0.05825373f, -0.13471602f, 
    -0.12710787f, 0.02107058f, -0.14994869f, -0.02037131f, 0.05323103f, -0.03056836f, 0.00767626f, 0.06430217f, 
    -0.10796922f, 0.14606802f, -0.20179757f, -0.30378988f, 0.13042037f, 0.03728220f, 0.03586672f, 0.08565710f, 
    0.03680185f, 0.09191616f, -0.05671282f, 0.16656038f, 0.09530994f, -0.04800464f, -0.03221529f, -0.03894478f, 
    0.08623260f, 0.00713982f, 0.06645405f, -0.05532309f, -0.03753804f, -0.06189543f, 0.06359931f, 0.03146498f, 
    0.19209500f, 0.02897886f, -0.08842096f, -0.16085789f, -0.02321431f, 0.17451018f, -0.01188177f, 0.16930911f, 
    0.04279235f, -0.06498776f, 0.08726908f, -0.07655546f, 0.13496314f, -0.06292429f, 0.16585867f, 0.09745636f, 
    -0.03677710f, -0.10001030f, -0.04307846f, -0.10709582f, -0.04490801f, -0.02513254f, -0.02089975f, 0.00679298f, 
    -0.09041613f, 0.10030396f, -0.09430939f, -0.04457641f, -0.00521479f, 0.03389490f, -0.03007044f, 0.02182512f, 
    0.08181217f, -0.03485624f, -0.04875571f, -0.09850609f, 0.12707883f, 0.06447282f, -0.00493437f, 0.01930766f, 
    0.08808319f, 0.00757849f, -0.04996648f, 0.09292614f, -0.05519370f, 0.03206830f, 0.01400148f, -0.02765487f, 
    0.11129110f, 0.07871660f, 0.01386643f, -0.01591958f, 0.09709359f, -0.00631576f, 0.02930875f, 0.07309834f, 
    -0.06495873f, 0.04654382f, 0.06377184f, -0.04148994f, -0.11937357f, -0.09070184f, 0.04166499f, 0.02644379f, 
    -0.04690897f, -0.08430760f, -0.07065806f, 0.00483367f, 0.18379214f, -0.05443819f, 0.08761380f, -0.01775048f, 
    0.43655479f, -0.41420558f, -0.11133319f, 0.19120032f, -0.04775514f, 0.03378792f, 0.02581618f, -0.11172355f, 
    0.01823636f, 0.05784860f, 0.02777895f, 0.03869389f, 0.27728999f, -0.25066510f, 0.10850161f, -0.08773265f, 
    0.13460511f, 0.09984373f, -0.02148897f, -0.02335326f, 0.14121167f, 0.10935686f, 0.10566431f, 0.15474311f, 
    0.25026011f, 0.17998669f, 0.13146703f, 0.13697535f, -0.03273327f, -0.06564017f, 0.07948268f, -0.02386331f, 
    0.03485593f, 0.02744854f, -0.06333622f, -0.04232187f, -0.04419584f, -0.05225207f, 0.05823602f, 0.21237920f, 
    0.01746468f, -0.00772242f, -0.13936965f, 0.08238418f, 0.17393059f, 0.02038795f, -0.01352581f, 0.00479221f, 
    0.24819133f, 0.09466740f, -0.04591795f, 0.01662389f, 0.10615367f, 0.10915951f, 0.13107194f, 0.07636971f, 
    -0.02225194f, 0.01729787f, 0.01112273f, -0.01969811f, 0.11764684f, 0.27387965f, 0.23336717f, -0.06087823f, 
    0.05746599f, -0.02631743f, -0.02963119f, 0.08598283f, -0.06666557f, 0.04913953f, -0.12913884f, 0.01671575f, 
    0.03534389f, 0.01340391f, -0.05421389f, 0.00019774f, 0.00594982f, -0.06729236f, -0.04525293f, 0.06504668f, 
    -0.05387695f, -0.02723132f, 0.04723770f, -0.01353232f, -0.05246671f, -0.01780873f, 0.00232094f, 0.03254518f, 
    0.05309231f, 0.02262203f, -0.01039159f, -0.01641260f, 0.01868512f, 0.05060852f, 0.04533062f, 0.01104609f, 
    -0.04094538f, -0.01017363f, -0.02782657f, -0.01741134f, 0.03508196f, -0.04961017f, -0.04250282f, -0.00127098f, 
    -0.05107091f, 0.02286185f, 0.04522026f, -0.07840589f, 0.00356762f, -0.06097064f, 0.00324690f, -0.08074174f, 
    -0.01253615f, 0.04652528f, 0.04764994f, 0.02838443f, -0.04786851f, 0.02502282f, 0.01277221f, -0.01220364f, 
    0.04097309f, 0.00174652f, 0.03483412f, 0.05225291f, 0.06291152f, -0.03447570f, -0.05934110f, -0.07366109f, 
    0.01622329f, 0.02921515f, -0.00314755f, -0.00775095f, -0.06450234f, -0.05677424f, -0.02883899f, -0.04549736f, 
    0.04766579f, -0.07217637f, -0.06399405f, -0.01663904f, 0.04773664f, -0.04590949f, 0.02020003f, 0.06097270f, 
    0.01088263f, -0.00550696f, 0.04767229f, 0.03987550f, -0.03231306f, -0.04996625f, -0.00297884f, -0.07879663f, 
    0.05519700f, 0.01406672f, -0.02705623f, -0.05301310f, 0.01744806f, -0.01706001f, 0.05332367f, -0.05774576f, 
    0.02003074f, -0.02555198f, -0.07184205f, -0.05798924f, 0.02230252f, -0.02932671f, -0.07425015f, 0.01655313f, 
    -0.02723102f, -0.02921824f, 0.00917825f, 0.00513737f, -0.01767322f, 0.01433169f, -0.01451612f, 0.03768212f, 
    0.01828984f, 0.03643198f, -0.06423069f, -0.06901912f, 0.01204650f, 0.02268479f, -0.08477762f, -0.05908655f, 
    -0.04138259f, 0.03355973f, -0.02999454f, -0.06564496f, -0.03597602f, 0.02547685f, -0.06463619f, -0.06523507f, 
    0.00913887f, -0.03344618f, -0.06055633f, -0.02717966f, -0.04756960f, -0.01354235f, -0.01334668f, 0.01674161f, 
    0.01107348f, 0.04849638f, -0.02923949f, 0.02335000f, 0.01304290f, 0.00551641f, -0.04134337f, 0.03228150f, 
    0.04922881f, 0.02442610f, 0.00845190f, 0.01048245f, -0.05455670f, -0.01895255f, 0.01354638f, -0.00611732f, 
    -0.07054330f, 0.04463347f, -0.02144013f, 0.00756245f, 0.00812949f, -0.05426348f, 0.02765832f, -0.05516826f, 
    0.01539880f, -0.00574480f, -0.01984853f, 0.02160221f, -0.06841216f, 0.01323997f, -0.02512081f, 0.07289683f, 
    0.02200008f, -0.07218150f, -0.07812864f, -0.05766590f, 0.05734899f, 0.06404423f, 0.04502921f, 0.00714445f, 
    0.07058892f, 0.04192600f, -0.04881250f, 0.02109807f, 0.01084591f, 0.04668163f, -0.00169212f, -0.06568448f, 
    0.01658751f, -0.05992154f, 0.01703113f, 0.01558907f, -0.05820100f, -0.01548823f, -0.03413531f, -0.04540233f, 
    0.04742996f, -0.01290148f, 0.02091158f, -0.03780583f, 0.03195208f, -0.05514760f, -0.03981168f, 0.01360595f, 
    0.03313336f, 0.01559152f, -0.05585369f, -0.05478721f, -0.01488019f, 0.04798382f, 0.05848506f, 0.00075300f, 
    0.05691103f, -0.06473141f, 0.03774780f, -0.05059472f, 0.00043815f, -0.03882011f, -0.08212502f, -0.05659056f, 
    -0.05284676f, -0.01879007f, -0.06264150f, -0.02214478f, 0.03147262f, 0.00772599f, -0.05529238f, -0.01116042f, 
    0.05117081f, -0.05552792f, 0.01074752f, -0.02658262f, 0.05997192f, 0.01682987f, -0.04160452f, 0.01542398f, 
    -0.07903396f, -0.01396119f, 0.06837075f, -0.06459787f, 0.03261801f, 0.06116207f, 0.00247617f, 0.05435055f, 
    -0.06204661f, 0.02011270f, -0.05092095f, 0.01864379f, -0.07955422f, 0.04442843f, 0.06295617f, -0.04960054f, 
    -0.04653712f, 0.05324914f, -0.01960107f, 0.05059321f, 0.06022897f, 0.05491139f, -0.04740081f, -0.07036954f, 
    -0.05248297f, 0.02888318f, -0.05571396f, -0.07739902f, -0.01395361f, -0.01473508f, 0.04843653f, -0.07346678f, 
    0.03198446f, 0.00662049f, 0.00597812f, -0.05850213f, -0.04940542f, 0.00985534f, -0.05080359f, -0.00331329f, 
    -0.03317210f, 0.05310234f, -0.05514021f, 0.03590866f, 0.02083461f, -0.04877569f, -0.02372179f, -0.07020018f, 
    0.04275122f, -0.01675987f, 0.04226980f, -0.02611763f, 0.00061872f, -0.04923923f, -0.02974339f, 0.03464451f, 
    0.04564830f, -0.00087180f, 0.03709449f, -0.01882194f, 0.02568531f, -0.00730556f, -0.05471759f, -0.03572081f, 
    0.05495801f, 0.02781598f, 0.04805864f, 0.03545166f, -0.01140174f, -0.01791447f, 0.03813129f, -0.05003421f, 
    0.01030669f, -0.02884465f, 0.04156596f, -0.04561803f, -0.01743818f, 0.06244344f, 0.05472170f, 0.05190772f, 
    0.01547323f, 0.00164655f, -0.02973911f, -0.04175440f, 0.01866619f, -0.06270192f, -0.06731152f, -0.01515382f, 
    0.00142452f, -0.05409162f, 0.03216692f, -0.04565668f, 0.05663753f, -0.02486258f, 0.02267134f, 0.05779196f, 
    -0.02145341f, -0.01585302f, -0.05827421f, -0.05763627f, -0.00618753f, -0.07036897f, 0.01973497f, -0.03990000f, 
    0.01988577f, -0.08066104f, 0.05047486f, -0.07752093f, 0.06461700f, 0.00270117f, 0.01259105f, 0.00449873f, 
    0.01529461f, 0.00612088f, 0.00855873f, 0.02139346f, 0.06184438f, -0.03545550f, -0.05624508f, 0.02033537f, 
    -0.00731569f, -0.05295991f, -0.01899859f, 0.03704153f, -0.02713639f, 0.04743425f, 0.02373644f, -0.05034186f, 
    -0.01883546f, -0.05238615f, -0.06231622f, -0.06338421f, -0.07755110f, -0.04460119f, -0.03844279f, -0.05187726f, 
    0.02909584f, -0.00625156f, 0.05797152f, 0.04730114f, 0.00596270f, -0.03380019f, 0.00362866f, -0.01591721f, 
    -0.05368579f, 0.04509024f, 0.04172077f, -0.03061607f, -0.03537422f, -0.00354400f, 0.04697094f, 0.05932887f, 
    0.04098346f, -0.00321400f, -0.00263205f, 0.02851963f, 0.00249139f, -0.00661821f, 0.05548647f, -0.02572984f, 
    -0.48143685f, -0.33898729f, 0.02204175f, -0.07603221f, 0.05004639f, 0.20206879f, 0.09977797f, -0.03951767f, 
    0.02863939f, 0.00849186f, 0.11861682f, 0.11986907f, 0.36178848f, 0.14413317f, -0.10911660f, -0.09010653f, 
    -0.12482143f, 0.02006377f, 0.16898084f, 0.17516778f, 0.03913403f, 0.08780798f, 0.08029501f, -0.06906026f, 
    -0.04361100f, 0.03557077f, 0.26476979f, 0.08576354f, 0.05946986f, 0.10056852f, 0.04256639f, -0.11719147f, 
    -0.03964214f, -0.00010177f, -0.01618514f, -0.01629937f, 0.05599210f, -0.14862375f, -0.01097043f, -0.08665127f, 
    -0.14455998f, -0.03539684f, 0.13678247f, -0.01358208f, -0.00514831f, -0.01042452f, 0.12047895f, 0.01740013f, 
    -0.07838809f, 0.15781392f, 0.20917203f, -0.02792307f, -0.10609905f, 0.00348104f, 0.08665887f, -0.00692731f, 
    0.00471629f, 0.03649937f, 0.02757489f, 0.14505492f, 0.14818975f, 0.00567970f, -0.13774601f, -0.08737108f, 
    0.00990963f, 0.11809407f, -0.09756417f, 0.16564696f, 0.07698117f, 0.05203097f, 0.06724079f, 0.08023348f, 
    -0.11833599f, 0.07831424f, 0.03929327f, 0.07007712f, -0.05462772f, 0.06699018f, -0.01434410f, -0.02778264f, 
    0.02127893f, -0.02446966f, 0.00735435f, -0.01340590f, -0.04500990f, -0.15907633f, 0.02072076f, -0.13378190f, 
    -0.09767699f, -0.06685246f, 0.02415445f, 0.03629714f, 0.03982439f, -0.06593458f, -0.03376511f, -0.04489987f, 
    0.27934012f, -0.09697767f, -0.11911210f, 0.01315387f, -0.03234417f, 0.13188036f, 0.11870073f, 0.01100988f, 
    0.02451048f, -0.02026423f, 0.07527200f, 0.08576122f, 0.34981281f, 0.02392993f, -0.12342937f, -0.14627157f, 
    -0.03781165f, 0.09626857f, 0.05289514f, -0.11917605f, -0.11460345f, -0.04055248f, 0.04913690f, 0.02017011f, 
    -0.28488594f, 0.15215659f, 0.03496434f, 0.06542730f, 0.10225368f, 0.15941736f, -0.05546387f, 0.07958240f, 
    0.09290430f, 0.01915639f, -0.02148757f, 0.02755660f, -0.00773415f, 0.16807546f, -0.15519981f, -0.01175166f, 
    -0.08572622f, -0.11200601f, 0.17693239f, 0.19325909f, 0.13936903f, -0.02869943f, -0.06273985f, 0.05264011f, 
    -0.24581516f, 0.01117266f, -0.07148692f, -0.06570358f, 0.01121555f, -0.03203539f, -0.05163584f, 0.04319679f, 
    0.04122340f, -0.08767127f, -0.06086097f, 0.02413951f, -0.02552391f, -0.18794671f, -0.04789665f, 0.07658742f, 
    0.04079469f, 0.07225564f, 0.05832321f, 0.09112942f, 0.09933147f, -0.05374082f, 0.00077528f, -0.04824406f, 
    -0.45356295f, -0.05832098f, 0.01257534f, 0.14304891f, -0.01937715f, 0.09669710f, 0.04077371f, 0.01842502f, 
    0.09946977f, -0.03727314f, 0.00813786f, -0.01849171f, -0.03863402f, -0.11081444f, -0.07550129f, 0.19172959f, 
    0.11273822f, -0.05755552f, 0.00104599f, -0.04054416f, 0.16354787f, 0.01977858f, 0.05816916f, 0.09270900f, 
    0.05032738f, 0.03246802f, 0.03804775f, -0.07799553f, -0.03649957f, 0.03590360f, -0.03232009f, -0.08784414f, 
    0.03946225f, -0.01309876f, 0.03743837f, 0.05345207f, 0.04477725f, 0.05067121f, -0.05079447f, -0.06521312f, 
    -0.00601656f, -0.00376131f, -0.00413021f, 0.03098917f, -0.00052524f, -0.05183521f, 0.03822850f, -0.04897770f, 
    -0.06596713f, 0.05112634f, -0.02457787f, -0.03485616f, -0.02220534f, -0.06931910f, 0.06310241f, -0.02321971f, 
    0.04335262f, 0.00571995f, 0.01002505f, -0.03907062f, -0.04231139f, 0.02601834f, 0.03573566f, -0.06199940f, 
    -0.07395039f, -0.03723043f, -0.02465118f, -0.01448122f, -0.01503738f, -0.07086341f, -0.05732533f, 0.02377576f, 
    -0.03910387f, 0.02237345f, -0.03291639f, 0.06810643f, -0.03120598f, -0.04832538f, -0.06729729f, 0.00471394f, 
    0.01326116f, -0.00552952f, 0.02628553f, -0.03096118f, 0.03688432f, 0.00699865f, -0.07718889f, -0.00831943f, 
    0.01398397f, -0.07081866f, 0.06246871f, 0.04050789f, -0.00874039f, 0.02004543f, 0.06278154f, 0.03077034f, 
    0.05890467f, -0.04972360f, -0.03794499f, -0.00461055f, -0.07508587f, -0.03324430f, -0.07877436f, 0.06030492f, 
    0.02382288f, 0.03525042f, 0.04608249f, -0.08022837f, -0.04150548f, 0.04354161f, 0.02112257f, -0.00007972f, 
    -0.07878869f, -0.04551122f, -0.06231048f, 0.02167613f, -0.06704776f, -0.07543394f, -0.02211272f, -0.01242319f, 
    -0.06649621f, -0.01176827f, -0.01088423f, -0.09373792f, -0.01401406f, -0.02356843f, 0.03258471f, 0.05532434f, 
    0.02613149f, -0.01634856f, -0.04313335f, -0.06082034f, -0.02150615f, 0.05355510f, 0.01478170f, -0.03509660f, 
    -0.05971387f, 0.03199175f, -0.06605349f, 0.03137971f, -0.06405770f, -0.03277983f, 0.01538020f, 0.05639653f, 
    -0.05368989f, -0.06924425f, 0.01457283f, -0.06971382f, -0.02089576f, 0.04022713f, -0.08039692f, 0.02775210f, 
    -0.01771772f, -0.00435683f, -0.05582673f, -0.00645472f, -0.05983973f, 0.04605802f, 0.00563902f, 0.05834560f, 
    0.05344730f, 0.04374019f, -0.01089642f, -0.05054920f, 0.03580595f, 0.05713229f, -0.03007696f, -0.03187339f, 
    0.03420837f, 0.05738359f, -0.05416709f, -0.02608748f, -0.05274485f, -0.03419533f, -0.07367384f, -0.00109564f, 
    0.05815172f, 0.02058150f, -0.05663397f, -0.04232341f, -0.05284535f, -0.00263841f, -0.02856916f, 0.02189688f, 
    -0.07545964f, -0.04601910f, 0.07043535f, -0.01703619f, 0.00993433f, 0.01658698f, 0.04234531f, -0.07231557f, 
    0.01447657f, 0.04947402f, 0.01552891f, -0.00665735f, -0.05474338f, -0.01273296f, 0.02924727f, -0.02849438f, 
    -0.05121987f, 0.03770972f, -0.00399038f, -0.02615390f, -0.00105854f, 0.04893756f, 0.00469408f, 0.00494490f, 
    -0.07162815f, -0.05780244f, -0.00383367f, 0.01028778f, 0.06228321f, -0.02503198f, -0.06938174f, -0.02352987f, 
    0.09906200f, -0.08090110f, 0.20841189f, -0.21169968f, -0.03564245f, -0.02937542f, 0.16188936f, 0.10072562f, 
    0.04673313f, 0.04134072f, -0.05758570f, 0.09952669f, 0.09756119f, -0.18348782f, -0.00445372f, -0.01724678f, 
    -0.04537914f, 0.00970120f, -0.00336227f, 0.08505177f, 0.03338398f, -0.04671083f, 0.09168402f, 0.13755517f, 
    -0.25666478f, 0.40114141f, 0.09882322f, -0.15309858f, -0.01359836f, 0.06672090f, 0.01063659f, -0.09400953f, 
    0.04945666f, 0.03303363f, 0.06761733f, 0.08572151f, 0.03662181f, -0.26725683f, 0.08160818f, 0.04249324f, 
    -0.10769624f, -0.09974682f, 0.08047511f, 0.07169048f, 0.05600809f, 0.06492457f, -0.09798559f, 0.05092793f, 
    0.07171115f, 0.01714419f, -0.16031301f, -0.11156601f, 0.02100420f, -0.05548632f, 0.12155056f, 0.06978580f, 
    0.05800217f, 0.03487433f, 0.03979385f, 0.04667067f, 0.12383287f, 0.18495309f, -0.13060567f, -0.09506684f, 
    0.02230057f, -0.05764569f, 0.00874824f, -0.00150097f, 0.11685771f, -0.00342444f, 0.00484835f, 0.07776797f, 
    0.02939511f, 0.17116834f, -0.00588491f, 0.33719325f, -0.03445523f, 0.01580734f, 0.03395944f, 0.06269092f, 
    -0.01839386f, -0.03626548f, -0.05866160f, 0.14767671f, 0.23508716f, -0.05831012f, -0.05509150f, 0.28327736f, 
    0.07095490f, -0.07360000f, -0.10478859f, 0.08204321f, 0.05931657f, -0.02314668f, -0.05351328f, 0.00735074f, 
    -0.12303314f, -0.13318972f, -0.03059954f, 0.25102347f, -0.02749993f, 0.13850066f, -0.02148628f, -0.06783168f, 
    0.03454621f, -0.03105552f, 0.06050656f, 0.08822655f, 0.21869555f, -0.08153993f, -0.03400785f, -0.03193423f, 
    0.00500361f, -0.01724317f, 0.10887830f, 0.10292123f, -0.05391090f, -0.01447836f, 0.03579416f, -0.02635418f, 
    -0.20802471f, 0.14469089f, -0.16482958f, 0.11997965f, -0.00164392f, 0.14104873f, -0.08491012f, -0.04837134f, 
    0.01759944f, -0.07464112f, 0.01506522f, 0.03130529f, 0.19252935f, 0.05874559f, -0.01298393f, -0.03034996f, 
    -0.00074561f, -0.03956123f, 0.08605997f, 0.08786295f, -0.01655277f, -0.01518320f, -0.07610360f, -0.06885333f, 
    -0.21815644f, 0.02787916f, 0.09775573f, -0.01547802f, -0.07607462f, 0.08066601f, 0.04229789f, 0.07415099f, 
    -0.14329733f, -0.07841966f, 0.00625014f, -0.02685015f, 0.22634540f, -0.06825104f, -0.19839749f, 0.04002636f, 
    0.05540146f, -0.03840255f, -0.07422204f, -0.06922503f, -0.08249823f, -0.03652322f, 0.16116986f, 0.11781999f, 
    -0.20669974f, -0.04754027f, 0.29425809f, -0.09590489f, -0.02132959f, -0.04154781f, -0.10724284f, -0.06788629f, 
    0.16411054f, -0.03231067f, -0.03243462f, 0.01958343f, -0.19014604f, -0.23088820f, 0.17432539f, 0.09519702f, 
    -0.07430059f, 0.12975261f, 0.01746413f, -0.00263565f, 0.00109573f, -0.11521326f, 0.04973909f, -0.03480854f, 
    -0.12539288f, -0.06744046f, 0.01936875f, 0.07011669f, 0.07242470f, 0.00647289f, -0.03808922f, -0.04930054f, 
    -0.00604752f, 0.06950551f, -0.03745015f, 0.01678527f, -0.08839653f, 0.01820798f, 0.00782505f, -0.04722748f, 
    0.14669926f, -0.02503235f, -0.03393516f, -0.15614149f, 0.02142221f, 0.02771287f, -0.07103277f, 0.14879315f, 
    0.13151924f, -0.16922183f, -0.03701428f, 0.06959531f, -0.00969426f, 0.00187892f, 0.06471547f, -0.06368925f, 
    0.02517342f, 0.05886715f, -0.05691895f, -0.02271121f, -0.08180081f, 0.12968926f, -0.11415693f, -0.07155923f, 
    0.04316648f, 0.07241804f, 0.04206268f, -0.06035327f, 0.01613246f, 0.03130724f, 0.03355443f, -0.03199257f, 
    -0.35230795f, -0.12977561f, -0.03094359f, 0.03739205f, -0.01980142f, 0.15837252f, 0.03766944f, -0.16294315f, 
    -0.03021006f, -0.01767959f, 0.03693986f, 0.12655050f, -0.01257257f, -0.00973284f, 0.12551978f, -0.06349758f, 
    -0.07067228f, -0.06977136f, 0.11078727f, 0.12561724f, -0.10673466f, 0.13274921f, -0.01816455f, -0.03827013f, 
    0.03990759f, -0.03101193f, 0.11411946f, -0.18219583f, -0.00117183f, -0.04013144f, -0.05159410f, -0.01061528f, 
    -0.04227518f, 0.05711346f, 0.12559061f, 0.14885858f, -0.18182249f, -0.05277077f, 0.27052417f, -0.11187460f, 
    0.08164562f, -0.03055035f, 0.09835938f, -0.14150107f, 0.06576197f, 0.10851186f, -0.01499184f, 0.06024064f, 
    0.04519389f, 0.05082983f, 0.12125680f, -0.18439828f, 0.05191684f, 0.01812880f, -0.01543318f, 0.12550360f, 
    0.07948671f, 0.07214991f, 0.08142252f, 0.02988411f, 0.21017855f, -0.12836771f, -0.00731036f, 0.02945188f, 
    -0.00155431f, -0.09318608f, -0.07772262f, 0.09158865f, 0.06688495f, 0.12617366f, -0.13092896f, 0.05595234f, 
    -0.21689983f, -0.00013622f, -0.01911899f, -0.21814354f, 0.14109500f, -0.03680246f, -0.03896665f, 0.07729919f, 
    0.02213669f, -0.01619921f, 0.03352952f, 0.09326915f, 0.04574466f, -0.12608154f, -0.14190091f, 0.08603441f, 
    -0.14689536f, -0.11010700f, 0.06489102f, 0.05996794f, 0.05026310f, -0.09612603f, 0.00970499f, -0.07024296f, 
    -0.02717862f, 0.03256873f, -0.07259645f, 0.19459789f, 0.11952373f, 0.14894532f, -0.11053242f, 0.06924047f, 
    -0.01814707f, 0.00570500f, 0.17880292f, 0.02287390f, -0.08438469f, 0.02474681f, 0.21957223f, -0.20094134f, 
    0.01761785f, -0.10624189f, -0.07720502f, 0.07000330f, -0.02371419f, 0.04966348f, 0.09662066f, -0.00013238f, 
    0.17244266f, 0.03516290f, -0.12226520f, 0.15941127f, 0.09437338f, -0.07961933f, -0.02639807f, -0.00790190f, 
    0.06495904f, 0.01360526f, 0.09467209f, 0.08005901f, -0.05539049f, 0.02679580f, -0.01266028f, -0.05311861f, 
    0.18270978f, 0.04868739f, 0.01891136f, 0.00673040f, 0.12416483f, -0.00989428f, 0.12651494f, 0.19103657f, 
    0.03415455f, 0.21933179f, 0.14176649f, 0.09848098f, -0.02143751f, -0.01311263f, 0.06295704f, 0.04010425f, 
    -0.05391950f, -0.04034767f, -0.14686146f, -0.04218479f, -0.14587232f, -0.13948077f, 0.10325749f, -0.09426491f, 
    0.11235125f, -0.03870950f, -0.03723994f, -0.06857357f, -0.05889172f, 0.04864809f, 0.00977609f, 0.01854419f, 
    -0.23688003f, 0.05526632f, -0.14152640f, -0.28774592f, 0.14020792f, -0.01337871f, 0.09808215f, 0.15922110f, 
    -0.10234817f, 0.07323520f, -0.14173166f, 0.14655294f, -0.01543242f, -0.17383462f, 0.00200850f, -0.04502384f, 
    0.08514454f, -0.01188932f, 0.09990499f, -0.02959396f, 0.04307133f, -0.00691153f, 0.01421429f, 0.05410210f, 
    0.27250853f, -0.03598629f, -0.19742960f, -0.14286789f, 0.05929210f, 0.05602651f, -0.08115722f, 0.14059086f, 
    -0.06840448f, -0.03075931f, -0.00367052f, -0.11674668f, 0.23040648f, 0.02113836f, 0.04823370f, 0.06265444f, 
    -0.02950954f, -0.00821589f, 0.04422294f, -0.06531871f, -0.03130579f, 0.15287468f, -0.03245613f, -0.03489464f, 
    0.02211579f, 0.14427172f, -0.07747674f, -0.01660467f, 0.03943325f, 0.03266576f, -0.00654922f, 0.01217910f, 
    0.01855363f, -0.04135260f, 0.10702080f, -0.02265414f, -0.04133723f, 0.12938794f, -0.12548397f, -0.11262514f, 
    0.09081278f, -0.01677684f, 0.03485650f, -0.05063443f, 0.07988253f, 0.01451617f, -0.00238317f, -0.10690182f, 
    -0.12171965f, 0.09793659f, -0.00170633f, 0.02136336f, 0.14120728f, 0.05184716f, 0.06143285f, -0.05235174f, 
    0.04089776f, -0.05269549f, -0.01851875f, -0.06834733f, -0.24176326f, -0.21134347f, 0.07047228f, -0.07938943f, 
    0.04732726f, -0.05677855f, -0.03492797f, 0.11805125f, 0.14952958f, 0.06072331f, 0.06882051f, 0.00434436f, 
    0.39315975f, -0.30402708f, -0.12271348f, 0.15817428f, -0.14663717f, 0.08208249f, 0.05333235f, -0.06632985f, 
    -0.02566061f, -0.02775997f, 0.00396227f, 0.08514495f, 0.47423735f, -0.06747354f, 0.15651007f, -0.01727903f, 
    0.12156162f, 0.01362469f, -0.03891937f, -0.01699463f, 0.08801620f, 0.07146850f, 0.06394623f, 0.07016356f, 
    0.00692565f, 0.20848404f, 0.05410524f, -0.04448196f, 0.07293154f, 0.14453895f, -0.04765815f, -0.02030690f, 
    0.00186240f, 0.15098488f, 0.00238250f, -0.01789805f, -0.05440532f, -0.06385983f, 0.01194972f, 0.17311656f, 
    0.02011218f, 0.04580123f, -0.07568070f, 0.00114666f, 0.03365739f, 0.00847987f, 0.03733366f, 0.11818278f, 
    0.15482584f, -0.04787586f, -0.02345524f, 0.00798502f, 0.06802914f, 0.12680726f, 0.16076522f, -0.01243392f, 
    -0.05878246f, -0.05070205f, -0.01430926f, -0.00553966f, -0.06793804f, 0.15599070f, 0.32466522f, -0.19878645f, 
    0.04987647f, -0.00415641f, 0.01879818f, -0.05680068f, -0.03751884f, 0.08729699f, -0.05870363f, -0.06714720f, 
    0.25566012f, 0.18847156f, 0.13047127f, 0.02488220f, 0.03259091f, -0.02002356f, 0.18874997f, -0.00149017f, 
    -0.05539019f, -0.05365779f, 0.13617361f, -0.01408905f, -0.17695348f, -0.13934681f, -0.17982721f, -0.06463728f, 
    0.01480857f, -0.06088111f, -0.08267368f, -0.13640150f, -0.14597374f, -0.01657521f, -0.15054211f, -0.05487206f, 
    0.14010973f, -0.05352904f, -0.01530110f, 0.08172718f, -0.16162747f, -0.03733385f, -0.14183086f, 0.04490150f, 
    -0.08019486f, 0.03601682f, 0.03429252f, -0.05540081f, -0.30057925f, 0.11352508f, -0.06721023f, -0.18042512f, 
    0.13384958f, -0.04263835f, 0.21656680f, -0.07847866f, -0.07570848f, -0.00802561f, 0.01122919f, -0.01221963f, 
    -0.31176040f, 0.01711101f, -0.16362609f, -0.02509654f, -0.02602422f, -0.05395121f, -0.16509701f, 0.08160579f, 
    -0.09687772f, 0.06096893f, 0.15866324f, -0.08862906f, -0.14782205f, -0.07506363f, 0.06807904f, 0.13077255f, 
    0.10493924f, 0.06983396f, 0.05277905f, 0.12122684f, -0.06868049f, 0.08813734f, 0.05058838f, -0.04629814f, 
    0.14884023f, 0.10542939f, 0.08421177f, -0.02430851f, -0.01069659f, -0.09582430f, -0.11350165f, -0.09172703f, 
    0.12023851f, -0.04786555f, 0.04195505f, -0.01679716f, 0.09768040f, -0.01534758f, 0.08780473f, -0.08978037f, 
    -0.05079062f, -0.02541951f, 0.06106107f, 0.06823722f, -0.10370354f, 0.14565529f, 0.05625571f, -0.11890652f, 
    0.28553668f, 0.28626370f, 0.13777664f, -0.06187261f, 0.11132026f, -0.03032638f, 0.09597725f, -0.03553297f, 
    0.01526493f, 0.15035172f, -0.14111125f, -0.07719734f, -0.33715820f, -0.41995305f, 0.17854048f, 0.08782455f, 
    -0.10986167f, 0.06527174f, 0.03747032f, 0.05981948f, 0.05906735f, 0.15535863f, -0.03834773f, 0.09906031f, 
    -0.04752874f, -0.00250889f, -0.18347588f, 0.13082966f, 0.02458419f, -0.02758666f, -0.07639737f, -0.04986067f, 
    0.11763950f, 0.07789259f, 0.03870025f, 0.06953874f, 0.18262590f, -0.10876679f, 0.18860261f, -0.02302337f, 
    0.15427363f, 0.03786369f, 0.09355478f, 0.05539372f, -0.05843059f, 0.09769164f, 0.01311183f, 0.03805713f, 
    0.37220082f, 0.26826647f, 0.03339716f, 0.07190039f, 0.07108272f, 0.09906886f, 0.00499757f, -0.09650278f, 
    -0.02039826f, 0.15272571f, 0.05108193f, 0.09104559f, -0.04407661f, 0.08193344f, 0.10915706f, 0.09429617f, 
    0.10351680f, 0.08641382f, -0.12683685f, 0.15957473f, 0.15050794f, 0.00178484f, -0.08328495f, 0.09742046f, 
    0.50160283f, 0.04292925f, 0.09917207f, -0.08267931f, 0.05196233f, 0.01575107f, 0.25051659f, 0.05111282f, 
    -0.00095731f, 0.09265206f, 0.11658405f, -0.04146140f, 0.32726333f, 0.26882839f, 0.16209921f, -0.07722458f, 
    -0.13608257f, -0.20976722f, -0.12038592f, 0.13711348f, 0.01209543f, 0.02664602f, -0.05728414f, 0.02157305f, 
    0.30012956f, 0.05116155f, -0.08903325f, 0.13547435f, -0.00748659f, -0.06385698f, -0.00579582f, 0.07036727f, 
    0.05241290f, -0.02502479f, 0.13936982f, -0.09388714f, -0.05990823f, 0.08084697f, -0.28011876f, -0.10641202f, 
    0.00857043f, -0.00289910f, -0.01562572f, 0.00614505f, -0.04989083f, 0.07552832f, -0.05760685f, -0.09169733f, 
    0.19539157f, -0.04796148f, -0.02938137f, 0.28530547f, -0.09136907f, 0.06751891f, -0.09174061f, -0.00804967f, 
    0.01989182f, -0.03680834f, 0.08930317f, -0.05004819f, -0.31838647f, 0.26555532f, -0.12582988f, -0.10002049f, 
    0.09823831f, 0.00832241f, 0.01678772f, 0.01133481f, 0.06680673f, 0.08428625f, -0.07850704f, 0.00594783f, 
    -0.53363812f, 0.06301086f, -0.00555477f, 0.14040916f, -0.00254594f, -0.06234630f, -0.02325015f, -0.06117022f, 
    0.01607798f, 0.09313440f, 0.03767696f, 0.01050979f, -0.29377085f, -0.04917791f, 0.00955311f, -0.09136090f, 
    0.02065140f, 0.11855412f, 0.04577398f, 0.09020422f, -0.08375012f, 0.01840059f, 0.00892428f, -0.08513870f, 
    0.07491213f, 0.01258716f, 0.12254030f, -0.14161742f, 0.07413227f, 0.05363235f, -0.02289283f, 0.07180499f, 
    0.10859630f, 0.09611323f, 0.05382943f, 0.04680406f, 0.05638375f, -0.05423323f, 0.11173952f, -0.02951217f, 
    0.01583892f, 0.07976107f, 0.06710608f, -0.03085649f, 0.03413075f, 0.13696665f, 0.02197978f, 0.11713234f, 
    0.17247030f, 0.01019769f, -0.02165730f, -0.11159395f, 0.03338868f, -0.11842575f, 0.11671319f, 0.03910587f, 
    -0.04568332f, 0.10708862f, -0.04458774f, 0.01695733f, -0.15573709f, -0.26529518f, 0.11914498f, 0.09075712f, 
    -0.02361401f, -0.01813096f, 0.01528302f, -0.06631312f, 0.07640038f, 0.14155164f, 0.00683870f, 0.07937288f, 
    -0.44230008f, 0.18941645f, 0.05652190f, 0.00217630f, 0.08409688f, -0.11572149f, -0.05981570f, 0.08976553f, 
    0.11750899f, 0.05424071f, 0.05122056f, 0.02321069f, -0.13537885f, -0.05572445f, -0.02311114f, -0.08079453f, 
    -0.03431537f, 0.07250604f, -0.01571564f, -0.03949265f, -0.01617212f, -0.01120850f, -0.00584317f, 0.02589241f, 
    0.37643355f, 0.05881241f, -0.03282700f, -0.02123993f, 0.01265466f, 0.10866439f, -0.00423572f, 0.08932117f, 
    -0.00638874f, -0.04539378f, 0.08574336f, 0.11964560f, 0.06807344f, 0.13894287f, 0.20157827f, -0.00186089f, 
    0.12756975f, 0.00672587f, -0.05071449f, 0.06718300f, -0.11760592f, -0.01477018f, -0.04505398f, -0.05801042f, 
    0.27215156f, 0.05429707f, -0.04392700f, 0.08950844f, 0.01399834f, 0.03488635f, 0.02152077f, 0.01040449f, 
    -0.02294127f, 0.12308940f, 0.06350487f, 0.03810116f, 0.24761182f, 0.19927996f, -0.05651997f, -0.02398680f, 
    -0.05380681f, -0.08042948f, -0.01215498f, 0.01036538f, -0.01749732f, -0.05086449f, 0.04542753f, 0.07954390f, 
    -0.02716948f, 0.01616591f, -0.07777470f, 0.04146614f, -0.02541637f, 0.03516072f, -0.04764067f, -0.00973998f, 
    0.03857230f, -0.02691314f, -0.00845867f, 0.05794205f, -0.05319738f, -0.01450084f, 0.03547347f, -0.06220859f, 
    -0.07671481f, -0.03473395f, -0.07711851f, -0.00193034f, 0.05217113f, 0.00272666f, 0.00218771f, -0.01487686f, 
    -0.02383148f, 0.02349766f, -0.06379572f, 0.02839921f, 0.01058361f, 0.03108344f, -0.07008457f, -0.03233956f, 
    0.02262806f, 0.04730291f, -0.02175456f, -0.07198608f, -0.05648122f, 0.01146511f, -0.06208333f, -0.04372161f, 
    -0.07464068f, 0.01916393f, 0.05564787f, 0.03120684f, -0.03824282f, -0.03319534f, -0.07895240f, -0.05916333f, 
    0.01410821f, -0.01574595f, -0.02241251f, -0.05654738f, 0.05034968f, -0.06556080f, -0.05360070f, 0.00451016f, 
    -0.07200874f, -0.02365445f, -0.01140782f, 0.02860169f, -0.01596726f, 0.04071206f, -0.01539329f, 0.04310229f, 
    -0.03017942f, -0.05698531f, -0.01174201f, -0.01002188f, -0.03944382f, 0.02160610f, 0.01953151f, -0.06630555f, 
    -0.07773980f, -0.00719194f, 0.02660097f, 0.00038120f, 0.01039912f, 0.00265120f, 0.01939121f, -0.02950204f, 
    -0.00027233f, 0.05412739f, 0.04998698f, -0.00986093f, 0.04581912f, 0.06880628f, 0.04218323f, -0.07403459f, 
    0.03610359f, -0.00091305f, 0.01515392f, 0.04467644f, -0.05834974f, -0.02633841f, -0.06732537f, 0.02051253f, 
    -0.01468812f, 0.00329060f, -0.06706933f, -0.07610955f, -0.05249953f, 0.06136333f, -0.08311798f, 0.05681271f, 
    -0.03146864f, -0.05377124f, 0.06096796f, 0.05577385f, -0.04126812f, -0.00764680f, -0.03830493f, 0.02653368f, 
    0.02615017f, -0.01293226f, 0.02290389f, 0.04608614f, -0.05889433f, -0.01305186f, 0.01774023f, -0.04432498f, 
    -0.02345830f, -0.03248964f, -0.01361277f, 0.06089760f, 0.01673947f, -0.04804448f, 0.00235466f, -0.00889855f, 
    -0.04397087f, 0.05797608f, 0.01413315f, 0.05350089f, 0.03979303f, 0.03957187f, -0.05097410f, 0.00457366f, 
    -0.02604042f, 0.00543457f, -0.00590236f, -0.01775605f, 0.04169308f, 0.00309147f, 0.01687267f, -0.04004570f, 
    -0.04062429f, -0.00645686f, -0.01167908f, -0.02994885f, -0.07711448f, -0.05516594f, -0.05198646f, -0.07366599f, 
    0.02466988f, 0.00026911f, 0.00708850f, -0.05010374f, -0.06507224f, 0.00491798f, -0.06100881f, 0.02587490f, 
    0.02724001f, -0.05640370f, 0.04983803f, -0.05912511f, -0.00368801f, -0.02006762f, -0.06799098f, 0.00633486f, 
    -0.03741955f, 0.05187719f, 0.05209231f, -0.00426907f, -0.07242602f, 0.05272163f, 0.05063788f, -0.01047093f, 
    0.02817300f, 0.04515226f, -0.06133886f, 0.02857422f, -0.03980643f, 0.06551500f, 0.00808065f, 0.04785114f, 
    -0.06364457f, -0.02965889f, 0.04507310f, 0.04414462f, -0.00054789f, 0.02139024f, 0.03016474f, -0.07446098f, 
    -0.01757151f, -0.07418922f, -0.00399592f, 0.01702544f, -0.02696456f, -0.00598021f, -0.06233149f, -0.00334741f, 
    -0.00008091f, -0.07615516f, -0.00873508f, 0.03985941f, -0.01629570f, -0.00924130f, 0.02985604f, -0.04215332f, 
    -0.01016503f, -0.00228768f, -0.00910884f, -0.04258094f, -0.05740424f, -0.02891070f, 0.06695672f, -0.01440712f, 
    0.06035263f, -0.07489567f, 0.00425265f, -0.05832043f, 0.04499070f, 0.03317325f, -0.06924039f, -0.05402334f, 
    -0.00292409f, 0.01838293f, 0.00672776f, 0.03764258f, 0.05439600f, -0.01639184f, -0.01094034f, -0.02674337f, 
    -0.00704449f, -0.03861585f, -0.04354809f, 0.05164677f, -0.04759114f, 0.00745990f, -0.02276517f, -0.03104188f, 
    -0.07075340f, -0.01917078f, -0.01499203f, -0.07646202f, -0.07807969f, 0.02467319f, -0.01180587f, -0.00102417f, 
    -0.04544523f, 0.06417709f, -0.06066323f, -0.03747071f, 0.01179278f, 0.00028422f, 0.01622781f, 0.00228954f, 
    -0.02726249f, 0.04429951f, 0.03523626f, -0.02773830f, -0.03842795f, -0.00736226f, -0.02818075f, -0.07180240f, 
    -0.04349501f, -0.03125120f, -0.02546101f, 0.05205785f, -0.05513040f, 0.03372072f, 0.00146278f, -0.08006829f, 
    -0.03363258f, 0.05641494f, 0.00397801f, 0.04354844f, -0.03266978f, 0.05561544f, 0.00735765f, 0.04028841f, 
    -0.07536289f, 0.04809109f, -0.07022681f, 0.01483552f, -0.01944087f, -0.05672875f, -0.05938492f, 0.04656597f, 
    0.01681602f, -0.03723678f, 0.05320038f, 0.05107243f, -0.03049617f, 0.00909233f, 0.00437934f, -0.03801772f, 
    -0.03153855f, 0.04476052f, -0.03039934f, 0.04577003f, 0.06577934f, 0.00027210f, -0.01772508f, -0.01019114f, 
    -0.02757781f, 0.05203867f, 0.03290495f, 0.04040470f, 0.05399333f, 0.00489035f, 0.06773964f, 0.05661777f, 
    -0.04734452f, -0.03186481f, -0.06815883f, 0.04462627f, -0.04163038f, -0.06227023f, 0.03821411f, -0.03760670f, 
    -0.05491339f, -0.01104995f, -0.07412808f, -0.03485511f, 0.00706294f, 0.01807674f, 0.05940834f, 0.06536704f, 
    0.04925637f, -0.01808186f, 0.01192497f, -0.05211104f, -0.03603217f, 0.05276888f, -0.00789172f, 0.00020013f, 
    0.04853858f, -0.06094177f, 0.04088888f, -0.03693553f, 0.05184623f, -0.01014056f, -0.05304601f, 0.01594449f, 
    -0.06231882f, -0.04302160f, 0.05504134f, -0.01800534f, -0.07465436f, 0.03033792f, -0.06225310f, -0.08476805f, 
    -0.02300004f, 0.02805797f, -0.00959271f, -0.04933933f, -0.07567460f, -0.02563150f, 0.02374148f, -0.03499835f, 
    -0.05350421f, 0.06383409f, 0.01351848f, -0.06527453f, -0.05475157f, 0.04929261f, -0.04390628f, 0.06562436f, 
    -0.03451665f, -0.02229634f, -0.02638914f, -0.03981303f, 0.01000169f, 0.04244226f, 0.02518171f, 0.05312619f, 
    0.00438600f, -0.06044347f, -0.02346969f, 0.02244788f, 0.00200303f, -0.04737756f, -0.04874049f, -0.04213215f, 
    0.18997841f, -0.01948412f, 0.06816138f, -0.23584348f, 0.05673605f, 0.07813656f, 0.09407491f, -0.01503828f, 
    -0.06605760f, -0.05370794f, 0.03296293f, 0.08513617f, 0.36004084f, 0.00882546f, 0.00236574f, 0.08808835f, 
    0.12512261f, 0.09505475f, 0.09368075f, -0.10003729f, -0.06711800f, -0.11331132f, -0.11201195f, -0.22702332f, 
    0.06250447f, 0.14986984f, 0.10227301f, 0.10586737f, 0.06954627f, 0.04004579f, -0.05945311f, -0.11390853f, 
    -0.18379799f, 0.00951137f, -0.08616333f, 0.03960750f, -0.21683495f, 0.11394104f, 0.10461342f, -0.05356003f, 
    0.04028252f, 0.10284871f, 0.15754192f, -0.08308268f, -0.03917625f, -0.00332147f, -0.05217553f, 0.05125703f, 
    0.03603991f, -0.08098829f, -0.07220960f, 0.23348163f, -0.00511279f, -0.10570261f, 0.05426268f, 0.02645108f, 
    -0.17366992f, -0.02304588f, 0.06890577f, 0.00763663f, 0.16425164f, -0.00453306f, 0.04795794f, -0.01007419f, 
    -0.06222051f, -0.08035419f, 0.08884758f, 0.07824707f, -0.00311192f, -0.12420859f, 0.02617798f, 0.05923981f, 
    0.31169584f, 0.15265287f, -0.20955986f, 0.00643518f, 0.07185989f, -0.01272966f, -0.02186205f, 0.03301093f, 
    0.04815040f, 0.00713223f, -0.01195941f, -0.00041418f, 0.01157430f, -0.27188271f, 0.04230708f, -0.18997091f, 
    0.19728284f, -0.06459536f, -0.04522850f, -0.04637911f, -0.09995735f, 0.04368967f, -0.00284284f, -0.11578092f, 
    0.20755911f, 0.08987790f, -0.10215179f, -0.05043282f, 0.02022566f, -0.24148595f, 0.00795992f, -0.26884896f, 
    0.00386029f, 0.05738206f, -0.08812261f, 0.12300380f, -0.07125754f, -0.10185417f, 0.15506656f, 0.11106116f, 
    -0.02135144f, -0.05632084f, 0.23805891f, -0.18406783f, -0.03514080f, -0.02896818f, 0.03981265f, 0.12812968f, 
    0.21480356f, -0.01594662f, -0.15209939f, 0.09057174f, 0.05155540f, -0.04275844f, -0.13467367f, 0.07230535f, 
    0.09394272f, 0.16375937f, -0.01533269f, 0.10987061f, 0.34203368f, 0.15550657f, 0.08424616f, -0.02836500f, 
    0.05424911f, 0.05174147f, 0.23334716f, 0.07069909f, -0.05651840f, 0.07585873f, -0.04168781f, 0.04476140f, 
    0.05596056f, 0.08387405f, -0.15077645f, -0.11284293f, 0.15289959f, 0.04632376f, -0.05493752f, -0.12043979f, 
    -0.06001335f, 0.01090710f, 0.00810205f, -0.07209796f, -0.17467052f, 0.06040880f, -0.11335309f, 0.07366130f, 
    0.06705032f, -0.07883964f, -0.06710150f, -0.08224205f, 0.03310568f, -0.01904853f, -0.07283927f, -0.03675855f, 
    0.31782204f, -0.00839462f, 0.04170249f, -0.10526837f, 0.04067193f, -0.00354599f, 0.06542405f, -0.03714835f, 
    0.04500904f, 0.03533669f, 0.14022659f, -0.05400810f, 0.32981449f, 0.00354790f, -0.10250453f, -0.01148563f, 
    -0.04849730f, -0.02499000f, -0.14090556f, -0.07230636f, -0.14582703f, -0.01660767f, 0.05919725f, -0.00361146f, 
    -0.07112743f, -0.11740524f, -0.03426662f, -0.00180194f, -0.10184467f, 0.02538634f, 0.11795577f, 0.12941903f, 
    0.08838869f, 0.06396654f, 0.10774828f, 0.06159059f, 0.13976187f, 0.04177127f, -0.11871737f, 0.04425503f, 
    0.02504738f, 0.00090734f, 0.15790452f, 0.14868470f, -0.02621142f, 0.08362299f, 0.05582184f, -0.14217742f, 
    0.00257759f, 0.10463138f, 0.19107632f, 0.16565348f, 0.03202362f, 0.04589330f, -0.01006125f, -0.03375268f, 
    0.00714808f, -0.00314930f, 0.08244640f, -0.05594040f, -0.02618793f, -0.08305937f, 0.09356362f, 0.07133932f, 
    -0.04019454f, -0.06009201f, 0.04773114f, 0.08895873f, -0.01319979f, -0.04468868f, 0.02672469f, 0.04886733f, 
    -0.14072907f, 0.10766691f, 0.01797858f, 0.09457070f, 0.09044857f, -0.13179313f, 0.15859212f, 0.12065887f, 
    0.22544521f, -0.01395989f, 0.04632036f, 0.10525677f, -0.14500245f, 0.12379113f, -0.20328456f, -0.09960488f, 
    0.00953634f, 0.11107522f, -0.20022739f, 0.05176227f, 0.06956561f, -0.11024608f, 0.09400326f, -0.00134573f, 
    -0.09796092f, 0.04380291f, 0.14558896f, 0.24642728f, 0.04596160f, 0.12688181f, -0.04672327f, 0.11345097f, 
    0.05458260f, 0.13478971f, -0.07349399f, -0.07372636f, 0.12563255f, 0.07055642f, -0.05651623f, 0.00250849f, 
    -0.15292411f, 0.08412773f, -0.00453918f, 0.13222259f, -0.01226678f, -0.03943184f, -0.08476549f, 0.06252377f, 
    0.14642844f, 0.08571084f, -0.04707344f, 0.00168376f, -0.07472129f, 0.07141213f, 0.03517033f, 0.07633734f, 
    -0.00213161f, 0.01681585f, 0.11243690f, 0.24748300f, 0.12612775f, 0.07012613f, -0.02586971f, -0.02668514f, 
    0.03649481f, 0.12839450f, 0.03959735f, -0.04524384f, -0.15800261f, -0.05011125f, 0.11151122f, -0.00517894f, 
    -0.26611939f, 0.26213777f, 0.08113740f, -0.02979113f, 0.03627346f, 0.09420671f, -0.04493225f, 0.06419255f, 
    -0.01983575f, 0.00925129f, -0.06713271f, -0.12081547f, -0.33190820f, 0.02431737f, -0.08432996f, -0.09201541f, 
    0.00077859f, 0.16450837f, 0.12363301f, 0.13413875f, -0.05168557f, 0.12768054f, 0.04348125f, 0.14932579f, 
    -0.15676498f, -0.09019091f, 0.14755543f, -0.10334640f, -0.10832220f, -0.09050171f, 0.04685145f, 0.09518620f, 
    -0.01335685f, -0.03091617f, -0.11554853f, -0.05295388f, 0.11664893f, 0.15897292f, -0.00297106f, -0.01928129f, 
    -0.04373855f, 0.15033670f, 0.25753751f, 0.04014103f, 0.04318904f, -0.18295614f, -0.05310274f, -0.01745494f, 
    -0.39368755f, -0.05802014f, 0.22742203f, 0.00046201f, -0.14735490f, 0.03212103f, -0.08827918f, -0.04477094f, 
    -0.05111377f, 0.01185347f, 0.03690854f, -0.16518359f, 0.11466467f, -0.01938335f, -0.07114283f, 0.14416090f, 
    -0.17431168f, 0.13515992f, -0.01094898f, 0.00221678f, 0.03332505f, -0.03291660f, -0.09282227f, 0.03562416f, 
    -0.13084397f, -0.01026338f, 0.09936152f, -0.05574258f, 0.02719026f, -0.12292559f, 0.05169854f, -0.10834739f, 
    0.09153338f, -0.03484613f, 0.00401800f, -0.04283907f, 0.01498052f, -0.02574807f, -0.02263476f, 0.13289768f, 
    0.18553160f, 0.05353063f, -0.01661618f, 0.02679196f, -0.07258188f, 0.06711565f, -0.03073977f, 0.03702748f, 
    -0.15916379f, 0.09956156f, 0.10612994f, -0.00475931f, -0.01316749f, -0.03944723f, 0.03503275f, 0.03135604f, 
    0.00120830f, -0.00357801f, 0.13448535f, 0.07675374f, -0.02721580f, -0.13752286f, -0.05918204f, -0.12826064f, 
    0.06127977f, 0.01222230f, 0.00172273f, 0.00701964f, 0.07375515f, 0.07068932f, 0.05210327f, 0.02625663f, 
    -0.00946332f, 0.14264971f, -0.00836109f, 0.01720910f, 0.05239647f, -0.01616438f, -0.03601121f, 0.00067258f, 
    -0.05692872f, -0.00558545f, -0.19011587f, -0.00917286f, -0.13177425f, 0.06350733f, -0.05805016f, 0.03583866f, 
    0.00395110f, 0.12205824f, 0.11776433f, -0.03058193f, -0.00794247f, 0.19165275f, -0.01475459f, -0.00381044f, 
    0.06761056f, -0.11112429f, -0.12558211f, 0.02828700f, -0.00734892f, 0.02841175f, -0.14545520f, 0.00863947f, 
    0.09264935f, 0.01374495f, 0.07775803f, 0.10841291f, -0.09901147f, 0.05264551f, 0.13525486f, -0.04499150f, 
    -0.00342224f, -0.05371435f, 0.07361388f, 0.03945650f, 0.06089176f, -0.04671379f, 0.07093411f, -0.04418370f, 
    0.28112793f, 0.03535827f, 0.24485081f, 0.10399981f, -0.10519513f, 0.13453551f, 0.02734829f, 0.15946926f, 
    0.04153622f, -0.05694933f, 0.07337244f, -0.01329601f, -0.20281826f, -0.11608012f, -0.00682765f, -0.12926662f, 
    0.04613089f, -0.09208904f, 0.07790579f, 0.04373593f, 0.03551283f, 0.08535752f, -0.12069342f, 0.00959258f, 
    -0.37710533f, 0.12787591f, -0.19974029f, 0.17739479f, -0.17947097f, 0.10443071f, -0.07805418f, 0.04828348f, 
    0.01799666f, 0.00257384f, -0.05009439f, -0.02965621f, 0.01652965f, 0.17491534f, -0.12445702f, 0.00006052f, 
    -0.02654449f, -0.00010643f, -0.01950668f, 0.01302559f, 0.01212439f, 0.01280822f, -0.01024274f, -0.13537309f, 
    -0.13609312f, 0.22465572f, -0.05551885f, -0.06783540f, -0.04842735f, 0.02998028f, -0.07315093f, 0.09493925f, 
    -0.05171759f, 0.09528494f, 0.05318602f, -0.02582889f, 0.32481727f, -0.06469317f, -0.06596369f, 0.03000619f, 
    0.01999250f, 0.01842584f, -0.08677796f, 0.01478970f, -0.01576718f, 0.20411608f, 0.08423286f, 0.05091697f, 
    -0.35336852f, -0.04720454f, -0.06797110f, -0.15196641f, -0.00912576f, -0.02205671f, 0.04746718f, -0.03049370f, 
    0.08472874f, -0.02334607f, -0.04737720f, 0.04067865f, -0.16420281f, -0.02679522f, 0.19981141f, 0.12382660f, 
    -0.09707666f, -0.07383482f, -0.00449060f, -0.05531948f, 0.09657443f, -0.03224129f, 0.13312040f, 0.00516235f, 
    0.00114104f, -0.02226619f, -0.01188968f, 0.02727128f, 0.00537478f, -0.05460748f, -0.05400560f, 0.04522321f, 
    -0.00566115f, 0.04076037f, 0.04847880f, -0.04149288f, -0.03253102f, -0.02949638f, -0.02753898f, -0.03911195f, 
    0.01913328f, -0.03655919f, -0.04042595f, -0.02515582f, -0.03772981f, -0.06280825f, 0.04452048f, -0.04398377f, 
    -0.06318481f, 0.00956513f, -0.03056221f, 0.05302556f, 0.02944608f, -0.06637797f, 0.01719486f, -0.02129137f, 
    0.04217954f, 0.01932238f, 0.03244910f, 0.00837078f, -0.05432937f, 0.03361828f, 0.06632555f, -0.00499457f, 
    0.05123735f, 0.00018791f, -0.04269806f, 0.00369774f, 0.03829179f, -0.04219216f, 0.00436376f, 0.04281914f, 
    0.01139750f, -0.03352630f, 0.04205422f, -0.05697963f, -0.03715472f, -0.05269143f, 0.01817645f, -0.07753595f, 
    -0.00285706f, -0.05504712f, -0.05553495f, 0.05498730f, 0.04757792f, -0.06613899f, 0.03832657f, 0.03241730f, 
    -0.02530975f, 0.00157163f, -0.05274810f, -0.01910689f, 0.03589750f, -0.02351911f, -0.02472112f, -0.05418322f, 
    -0.02829220f, -0.03923083f, -0.03180392f, 0.04679975f, 0.00514723f, 0.02869008f, -0.04169900f, -0.07604627f, 
    0.00580590f, -0.02264804f, -0.03962888f, 0.01616783f, -0.03801230f, 0.03892029f, 0.03355026f, -0.03469761f, 
    -0.01660760f, -0.01427334f, 0.03258998f, 0.00121004f, 0.00566910f, -0.02678337f, -0.07951108f, 0.02644476f, 
    -0.02503180f, 0.05812814f, -0.02309517f, 0.02198364f, 0.04280859f, -0.01118257f, 0.02419226f, -0.06622686f, 
    0.01604356f, -0.02904566f, 0.01542505f, 0.04670132f, -0.01993194f, 0.01190555f, -0.02884727f, -0.04635572f, 
    -0.04635122f, -0.03336473f, -0.04173725f, -0.06961190f, -0.04895316f, 0.00168044f, 0.06129831f, 0.02887863f, 
    -0.05804061f, -0.06584281f, 0.02936144f, 0.06174180f, 0.03424560f, -0.04199302f, -0.07884815f, 0.00035077f, 
    -0.05897851f, 0.01621307f, -0.02468706f, 0.02299134f, -0.03219126f, 0.04869169f, 0.01463826f, -0.03453296f, 
    -0.01376865f, -0.01206774f, -0.00255101f, -0.07146235f, -0.00929143f, 0.05681648f, 0.01609442f, -0.04208302f, 
    -0.00339457f, 0.01377229f, 0.02225479f, 0.04347096f, -0.02785055f, 0.05449959f, 0.03082849f, -0.00916000f, 
    0.00250648f, 0.05354700f, -0.04252677f, -0.04990670f, -0.07172465f, -0.07955801f, -0.01027518f, -0.06920390f, 
    0.01504874f, -0.04722332f, 0.05690566f, -0.01737419f, -0.08007429f, -0.06839896f, -0.06742474f, -0.02455606f, 
    0.00810286f, 0.06466080f, 0.02605441f, -0.01300247f, 0.02325599f, -0.06468096f, 0.02533861f, -0.00400719f, 
    0.05095176f, -0.06514364f, 0.01219468f, -0.04133593f, -0.07417630f, -0.03968648f, -0.05163338f, -0.03519281f, 
    0.00879220f, 0.05951353f, 0.01137434f, 0.02653928f, 0.02248503f, -0.04891621f, -0.06870666f, 0.00605742f, 
    0.12953335f, 0.08014026f, 0.05459429f, 0.03583894f, -0.05113022f, 0.06868542f, 0.07916687f, 0.12178139f, 
    -0.06510129f, -0.02451810f, 0.05221158f, 0.11162009f, -0.08945175f, -0.33615068f, -0.06173148f, 0.02318960f, 
    0.00220172f, 0.02931729f, -0.06228912f, -0.05461088f, -0.09061088f, 0.03435698f, -0.01592526f, 0.01558331f, 
    -0.04978124f, -0.00815747f, 0.03373723f, -0.06369855f, 0.01792399f, 0.07192943f, 0.01888879f, 0.08048966f, 
    -0.03113958f, -0.00639205f, 0.01510914f, -0.06423353f, -0.26571742f, -0.00709790f, 0.22091849f, 0.13524428f, 
    -0.03834243f, -0.09971543f, 0.09067694f, -0.00181967f, -0.10433585f, 0.04211225f, 0.02117291f, 0.04514504f, 
    -0.00808159f, -0.19199416f, -0.14951010f, 0.21479365f, -0.04215236f, -0.01274957f, 0.00377718f, 0.12234567f, 
    0.02294774f, 0.11267201f, 0.06423437f, -0.04223628f, 0.08791488f, 0.05225703f, 0.01405121f, 0.05735525f, 
    0.03825868f, -0.00380451f, 0.02420855f, 0.15622941f, 0.05024669f, -0.01621522f, 0.03072014f, -0.04450696f, 
    0.04229339f, 0.17836304f, 0.13368858f, -0.02541165f, 0.11841311f, 0.08489357f, 0.08708546f, 0.15124458f, 
    -0.01270309f, -0.02523146f, -0.04849752f, -0.05058017f, 0.11244600f, 0.19566590f, -0.19306166f, -0.23569782f, 
    0.16377704f, -0.00301213f, -0.01248594f, 0.09349184f, -0.05085746f, 0.11992525f, 0.01521163f, -0.04011749f, 
    -0.27603984f, 0.13105300f, -0.12749776f, -0.29008999f, 0.15040877f, 0.01623269f, 0.01000719f, -0.01495901f, 
    0.03867053f, 0.06136591f, -0.06155254f, 0.04985863f, -0.08914629f, -0.16394150f, -0.02306791f, 0.17444220f, 
    -0.00900379f, 0.03055326f, 0.01971641f, 0.09266390f, 0.00332988f, 0.09196956f, 0.16945584f, 0.02742375f, 
    -0.04119330f, -0.09837410f, -0.09142728f, -0.05556600f, 0.05092440f, -0.02115962f, 0.00794026f, -0.00659481f, 
    -0.01119253f, -0.02845106f, 0.03269885f, 0.00810202f, 0.02272092f, -0.14083903f, 0.02510118f, 0.09015678f, 
    0.15165368f, -0.01989703f, -0.02169698f, 0.04115592f, -0.06108718f, 0.09586927f, 0.05643358f, 0.05473767f, 
    -0.09781449f, -0.05946961f, 0.09461870f, 0.02759093f, 0.07155547f, 0.11661467f, 0.06133151f, 0.04225964f, 
    0.04758508f, -0.01532735f, -0.11496095f, 0.05333681f, -0.30414441f, 0.12454654f, -0.07411907f, -0.09612561f, 
    0.06618482f, 0.05804531f, 0.11092321f, 0.01250687f, 0.02800618f, -0.05226644f, -0.08342354f, 0.12128401f, 
    0.24163075f, -0.11684315f, 0.21113813f, 0.05462760f, -0.01055953f, 0.14308769f, 0.03952154f, 0.10447688f, 
    -0.04696599f, 0.00045739f, -0.02805726f, -0.06929164f, -0.05227377f, 0.11018635f, 0.10908257f, -0.19937342f, 
    -0.12209331f, 0.06383231f, -0.03930269f, -0.05346467f, -0.05345828f, 0.03826856f, -0.12709153f, -0.03388725f, 
    0.32440946f, 0.02640459f, 0.13332179f, -0.10876567f, 0.05727741f, -0.08143105f, -0.04619757f, -0.00141874f, 
    0.04661755f, -0.03382188f, 0.02922708f, -0.10256168f, -0.23757908f, -0.43648073f, -0.04429841f, -0.00604708f, 
    0.14666335f, -0.09000607f, 0.02791697f, 0.02218422f, 0.10366925f, -0.04912150f, -0.15291077f, 0.20574589f, 
    0.03728080f, 0.05241184f, 0.07321278f, 0.09710901f, -0.11157175f, -0.13491778f, 0.03172801f, 0.01233317f, 
    0.12227718f, 0.09319307f, 0.19182669f, 0.04359564f, -0.00746028f, -0.20005563f, -0.08324133f, -0.15678081f, 
    0.05341046f, 0.07176173f, -0.05594629f, 0.11060135f, 0.01478200f, 0.11966038f, 0.03689354f, 0.02174744f, 
    0.05659473f, -0.08838642f, -0.08978260f, -0.10081970f, 0.05217844f, -0.01903698f, 0.00460777f, 0.08216133f, 
    0.00195617f, 0.09316173f, -0.03786212f, 0.02862416f, -0.17042741f, 0.11067148f, -0.22977547f, -0.13099749f, 
    0.13959286f, 0.08329923f, 0.00720990f, -0.08614248f, -0.02139272f, 0.13605234f, -0.03270056f, 0.05401425f, 
    0.10435087f, 0.04783533f, -0.06523617f, 0.12048338f, 0.04150354f, -0.08529008f, -0.08814494f, -0.08441941f, 
    0.03912519f, 0.06201307f, 0.14973904f, 0.20551884f, 0.03396342f, 0.10816473f, 0.16627535f, 0.35343406f, 
    0.05814075f, -0.02118139f, -0.03315057f, -0.06640574f, 0.02092714f, -0.00467223f, 0.03112097f, 0.09592113f, 
    0.03771741f, 0.03147106f, 0.14476922f, 0.28614518f, -0.13179946f, 0.10042135f, -0.06666406f, -0.11219741f, 
    0.09273815f, 0.00890701f, -0.02084219f, -0.12192973f, -0.40733430f, -0.11599141f, 0.10185734f, -0.03563409f, 
    -0.05157707f, -0.03405678f, 0.08862806f, 0.10043254f, 0.05103515f, 0.08372150f, 0.02772148f, 0.12626377f, 
    -0.70141006f, 0.10189176f, -0.28962395f, 0.14516343f, -0.00719291f, -0.04093228f, -0.06011033f, 0.03464901f, 
    0.10303573f, -0.04045198f, 0.02780154f, -0.11887122f, -0.18296748f, 0.07118686f, -0.13153738f, -0.18175599f, 
    0.10544022f, -0.00137597f, 0.01298377f, 0.05072333f, 0.03100664f, 0.00272494f, -0.03420266f, -0.07824837f, 
    0.19643800f, -0.01623698f, 0.01027604f, 0.07450564f, 0.02648797f, 0.05980864f, -0.00218425f, 0.06963199f, 
    -0.07971917f, 0.03211089f, 0.17592688f, 0.09950008f, 0.36013770f, 0.06347248f, -0.03521051f, -0.04137542f, 
    0.02922335f, -0.05967627f, -0.11337052f, -0.17847770f, -0.10800642f, 0.18281960f, 0.12163578f, 0.07099995f, 
    -0.00574552f, -0.04115556f, 0.11950349f, -0.20795320f, 0.05070435f, -0.07348351f, -0.05305011f, 0.06124898f, 
    0.08985732f, -0.00637784f, -0.04176705f, 0.19497947f, 0.07564971f, -0.09582146f, 0.16788085f, 0.16570491f, 
    -0.02394312f, 0.05700265f, 0.04864318f, -0.16644716f, -0.06964454f, -0.09633284f, 0.12566629f, 0.04900319f, 
    0.05646668f, 0.07200509f, 0.09672069f, -0.14456733f, 0.03218186f, -0.07273328f, 0.02746459f, -0.10031310f, 
    0.04350526f, -0.02174460f, -0.12869850f, -0.04552265f, 0.02948954f, -0.15262558f, 0.09614906f, 0.24176535f, 
    0.28695661f, -0.03541259f, 0.05327941f, 0.08394141f, 0.06467806f, 0.03094276f, -0.01162501f, 0.11015736f, 
    -0.30909672f, 0.10565424f, 0.06627920f, -0.13391204f, 0.04431628f, -0.08150966f, 0.08106697f, 0.05846870f, 
    -0.07966888f, 0.07272645f, 0.06651827f, 0.12486432f, -0.01281564f, -0.16216968f, 0.18996046f, -0.08626752f, 
    -0.04214128f, -0.03760346f, -0.07706375f, 0.07120001f, 0.02431677f, 0.06736776f, 0.14926220f, -0.01895262f, 
    0.40262663f, -0.01080930f, -0.05851090f, 0.02050625f, 0.01865763f, -0.11559606f, -0.06923082f, 0.06534307f, 
    -0.02625738f, -0.10387520f, -0.03425633f, 0.05068391f, 0.02522781f, 0.06701913f, -0.05153221f, -0.00592795f, 
    -0.00829465f, 0.06526797f, -0.04275327f, 0.00030522f, -0.01532350f, 0.09291229f, -0.10517758f, 0.12538713f, 
    0.14876707f, -0.13498722f, -0.08060543f, 0.07496682f, 0.04824178f, -0.02870531f, -0.15130560f, 0.08536296f, 
    -0.03337157f, 0.02975165f, 0.00244885f, 0.03946256f, 0.03658844f, 0.26683271f, -0.05659756f, 0.04294847f, 
    0.01743956f, 0.01527664f, 0.06144528f, -0.00337771f, -0.00658110f, -0.18978448f, 0.01500660f, 0.02177998f, 
    -0.01337803f, 0.06279075f, 0.05180226f, 0.24755180f, -0.04536173f, 0.12030682f, -0.03554961f, 0.08548265f, 
    0.11052815f, -0.12058878f, 0.04757410f, 0.09464391f, -0.32000768f, 0.03312273f, -0.06183111f, -0.23110127f, 
    0.06593215f, -0.03969039f, 0.08854669f, 0.11206643f, -0.08829887f, -0.04705651f, 0.09085362f, 0.07521391f, 
    -0.00849739f, -0.06458864f, -0.13461879f, 0.18479927f, -0.07564600f, 0.16861868f, -0.04910737f, 0.07686312f, 
    0.13194196f, -0.07637706f, -0.07286584f, 0.02579007f, 0.16420789f, 0.10133054f, 0.01486001f, 0.11560788f, 
    0.06181289f, 0.03489615f, -0.08644356f, 0.10952442f, -0.01688108f, 0.08684930f, -0.04591122f, -0.05976559f, 
    -0.18653506f, 0.11123984f, -0.06419624f, -0.13226520f, -0.11962001f, 0.16043776f, 0.06965344f, 0.03752129f, 
    -0.09705365f, 0.08103943f, -0.02073763f, -0.04344081f, 0.35999718f, 0.02976456f, -0.15304956f, 0.06007203f, 
    0.06062515f, 0.05309321f, -0.04173235f, 0.05206307f, -0.01671664f, 0.16439727f, 0.11454210f, 0.11813919f, 
    -0.26679766f, -0.05245301f, 0.10996354f, -0.15955007f, 0.06398556f, -0.00526188f, 0.10012231f, -0.06190865f, 
    -0.03129782f, 0.00857934f, -0.07665130f, 0.08549983f, -0.28691876f, -0.17149945f, 0.24008995f, -0.06340478f, 
    -0.04115620f, 0.08100258f, 0.05160107f, -0.08246636f, 0.04111204f, 0.06786339f, 0.07298182f, -0.08705700f, 
    0.27498004f, 0.04004372f, -0.13943422f, -0.14590372f, -0.08704453f, 0.07161763f, 0.14546312f, 0.03038234f, 
    0.03516917f, 0.05239754f, 0.11570173f, 0.14307751f, 0.15183721f, -0.11716032f, -0.00201944f, 0.16432832f, 
    0.01117685f, 0.08972045f, 0.02594081f, -0.05600583f, -0.12502785f, -0.13012053f, 0.02868962f, -0.23177807f, 
    -0.05044596f, 0.18285660f, 0.12062735f, -0.03983389f, -0.08302208f, 0.13677543f, -0.05724648f, -0.03252928f, 
    -0.18787117f, 0.03417738f, 0.01047302f, 0.07654273f, -0.27475873f, 0.10123308f, 0.17109326f, 0.00674215f, 
    -0.13193110f, -0.02683998f, 0.05341952f, -0.01265734f, -0.05214834f, 0.01619210f, -0.14277381f, 0.04273194f, 
    0.12203072f, -0.12272951f, -0.13461430f, 0.08167870f, -0.09355115f, -0.11809199f, 0.09870750f, 0.23257196f, 
    0.01939571f, 0.09728027f, 0.20044544f, 0.10225584f, 0.17520219f, 0.09185556f, -0.05459774f, -0.19881991f, 
    -0.05556634f, -0.06373288f, 0.04308664f, 0.05528631f, 0.04196570f, -0.20080309f, -0.01274274f, -0.00518440f, 
    0.05347346f, 0.11489071f, -0.14590184f, 0.27203041f, 0.10007118f, 0.03721716f, 0.00508745f, 0.10399708f, 
    -0.08327033f, 0.02191744f, -0.19532129f, -0.16777858f, 0.12140416f, -0.06176195f, -0.10864675f, -0.05462625f, 
    0.03981787f, -0.03719427f, -0.18661314f, 0.01405230f, -0.06287610f, 0.09847043f, -0.01617899f, -0.09880235f, 
    -0.01664585f, -0.02604585f, -0.09968024f, 0.02351209f, -0.00025818f, -0.15932448f, -0.08551552f, -0.19600013f, 
    -0.07724478f, 0.21524626f, 0.12653150f, 0.19472836f, -0.01673831f, -0.08268203f, 0.29300830f, 0.04837308f, 
    -0.02507401f, -0.02148431f, 0.01183370f, -0.10880422f, 0.04814140f, -0.06470140f, 0.18653952f, 0.07993229f, 
    0.56927657f, -0.02071414f, -0.11140315f, 0.10908975f, 0.07045450f, -0.00372765f, -0.14448273f, 0.00506554f, 
    0.04063962f, 0.02840120f, 0.10088228f, -0.06694993f, 0.37509021f, 0.16141118f, 0.03339790f, -0.31646842f, 
    0.10128500f, 0.09982324f, 0.08233444f, 0.18050362f, -0.04111260f, 0.05245093f, 0.01335370f, 0.14335282f, 
    0.02241720f, 0.01381530f, 0.03990024f, -0.12185892f, 0.10024964f, -0.09011245f, 0.13031374f, -0.29440957f, 
    -0.15841898f, -0.03240222f, -0.09443602f, -0.12293053f, 0.02263540f, 0.02642566f, -0.21258804f, 0.04765349f, 
    -0.01202854f, -0.03869928f, 0.12250210f, -0.13668652f, 0.09670115f, -0.07864249f, 0.00790587f, -0.03698491f, 
    0.17587146f, -0.13187654f, 0.14858536f, 0.08404335f, 0.10846514f, 0.16710110f, 0.03595711f, 0.02291206f, 
    0.06820612f, -0.14489077f, 0.05177491f, -0.13702758f, 0.24500099f, -0.04115237f, 0.00345266f, 0.07282455f, 
    -0.03988330f, 0.09001575f, -0.23303653f, -0.05724662f, -0.01309708f, 0.12978292f, 0.03479930f, 0.04332071f, 
    -0.13020861f, -0.22375055f, 0.03718692f, -0.25845304f, 0.10268363f, 0.07938240f, 0.03461951f, -0.09823855f, 
    0.12186439f, 0.02600751f, 0.05377942f, 0.18422408f, 0.19778796f, 0.16184275f, 0.05789677f, -0.08275768f, 
    -0.07271449f, -0.09151984f, 0.07427376f, -0.04096923f, -0.13054241f, 0.01966812f, 0.03903462f, 0.04431520f, 
    0.07041820f, 0.14129616f, 0.10711899f, 0.08868735f, 0.03140064f, 0.08904018f, 0.07505003f, -0.13284993f, 
    0.06225001f, -0.02883477f, -0.02644235f, 0.04266061f, 0.36598542f, -0.05884325f, 0.05207659f, 0.16009736f, 
    -0.00900395f, 0.00273897f, 0.13102353f, 0.02862892f, -0.08681560f, 0.14314923f, 0.07550868f, -0.00582727f, 
    0.05159258f, -0.05589006f, 0.04231081f, 0.02232202f, 0.01442183f, 0.04596531f, -0.04506781f, 0.00230196f, 
    -0.30032876f, -0.00914781f, -0.13724554f, -0.20294121f, 0.20770822f, 0.05351496f, 0.13862434f, 0.14162044f, 
    0.00611726f, -0.16667195f, 0.00470646f, 0.06639242f, 0.06738677f, 0.12476999f, -0.04807172f, 0.02227369f, 
    0.08538324f, 0.04401145f, -0.15102558f, -0.00487053f, 0.00904175f, -0.11978848f, -0.02183780f, 0.09941077f, 
    0.02319614f, -0.05967124f, 0.06308247f, 0.07958166f, -0.16949481f, -0.37962517f, -0.14688654f, -0.14760254f, 
    0.17571694f, -0.13467796f, -0.04932497f, 0.05122175f, -0.04022294f, 0.01396251f, 0.09727668f, 0.00249091f, 
    -0.07842357f, -0.24722326f, -0.27047950f, -0.24643423f, 0.06720319f, -0.10304143f, 0.08653799f, 0.04630970f, 
    0.14535187f, 0.02327060f, -0.04898812f, -0.03666267f, 0.24549145f, -0.01763829f, 0.06630635f, 0.15448451f, 
    0.02282091f, 0.04289237f, 0.06632860f, 0.06662892f, 0.09714871f, -0.03869365f, -0.00715229f, -0.07844730f, 
    0.24575318f, -0.12637112f, -0.03775691f, 0.03421281f, 0.07755905f, -0.01764691f, 0.02250285f, -0.03747255f, 
    0.01388541f, -0.03530384f, -0.05801634f, 0.06151751f, 0.30724642f, 0.00219864f, 0.01132030f, -0.02008946f, 
    0.02615180f, -0.13186905f, 0.13400199f, 0.09368344f, 0.02872108f, -0.11535776f, -0.02646689f, -0.18823972f, 
    -0.09353756f, -0.06770851f, -0.08012807f, 0.02899453f, 0.08640024f, 0.17433137f, 0.01467234f, 0.08702703f, 
    -0.02823213f, 0.09801992f, 0.03270241f, 0.04330258f, -0.44122118f, -0.29638457f, -0.12146703f, -0.10418927f, 
    0.05985690f, -0.06163871f, 0.01822570f, 0.05858436f, 0.10837936f, 0.03866951f, 0.03852190f, 0.17431960f, 
    0.23412363f, -0.01828213f, -0.06670713f, -0.02093941f, 0.08697917f, 0.12085063f, -0.01623406f, -0.03431968f, 
    0.09053612f, 0.04546589f, 0.11113723f, 0.04543767f, 0.15021783f, -0.02169557f, -0.20854068f, -0.04169101f, 
    0.14770849f, -0.10296898f, 0.03304383f, -0.01524539f, 0.00746499f, 0.07005194f, -0.03257034f, 0.07946575f, 
    0.10504697f, -0.07741444f, 0.17409076f, -0.10224730f, 0.09126559f, 0.03437587f, -0.13337708f, -0.07028619f, 
    0.10605810f, -0.03198331f, 0.15763788f, 0.02229312f, 0.25522038f, 0.07039390f, 0.03433600f, 0.16280936f, 
    0.08608969f, 0.12858954f, 0.03414313f, -0.00457875f, -0.00540347f, 0.11329541f, -0.06315748f, 0.10140774f, 
    0.22240776f, -0.07735156f, 0.03250374f, 0.26991850f, -0.01115224f, 0.04198977f, 0.06811775f, -0.16317821f, 
    0.08167450f, 0.05938595f, 0.09485555f, -0.03024815f, 0.41782323f, -0.08310094f, -0.03789474f, 0.12727386f, 
    -0.05645672f, -0.04909819f, 0.05751497f, 0.02586371f, -0.05940433f, 0.04286231f, 0.13255584f, 0.01332906f, 
    0.04099584f, 0.11074512f, -0.01693654f, 0.08514077f, 0.11781202f, 0.05951960f, -0.08423398f, -0.17350131f, 
    -0.11938161f, -0.03585451f, -0.03680107f, 0.04614773f, -0.26602834f, 0.09195729f, 0.02769869f, 0.06299855f, 
    0.08534317f, -0.02119037f, -0.10976709f, 0.02193072f, -0.06287625f, -0.00016683f, -0.10483795f, -0.08718105f, 
    -0.12673093f, -0.05193913f, -0.08094132f, -0.05295227f, -0.04168811f, -0.04638943f, -0.15082221f, -0.04304663f, 
    0.08697028f, 0.07430278f, 0.01055355f, 0.07375600f, -0.05045826f, -0.03868707f, 0.10988368f, -0.07477058f, 
    -0.00910454f, -0.06976568f, 0.00827127f, 0.02951803f, -0.04970276f, -0.15774532f, -0.07300744f, 0.08503798f, 
    0.25153905f, 0.04459927f, 0.01814578f, -0.15042052f, 0.05880978f, 0.06221173f, 0.12998395f, 0.07682549f, 
    0.01572201f, -0.02650787f, -0.12851515f, -0.08894915f, 0.04065694f, -0.09477475f, -0.02421814f, -0.02987874f, 
    -0.00573128f, 0.07902803f, 0.06549638f, -0.04659895f, -0.03173737f, 0.07905044f, -0.06479833f, 0.06192096f, 
    -0.50645924f, 0.31781650f, -0.03150949f, -0.12820144f, 0.01651387f, 0.05877540f, 0.01946619f, 0.11980319f, 
    -0.00745449f, -0.11616439f, 0.05289173f, 0.08356040f, -0.43640935f, 0.02922464f, -0.18295337f, 0.12217823f, 
    0.01201792f, -0.12325751f, 0.11800038f, 0.11584493f, 0.07739210f, -0.00083060f, -0.06929576f, -0.15690523f, 
    0.19908310f, -0.04748358f, -0.00467186f, 0.00577551f, -0.10768326f, 0.05851206f, -0.01461065f, 0.03983765f, 
    0.01132974f, -0.05775445f, -0.04865688f, -0.10204843f, 0.06359179f, 0.12923388f, 0.06378603f, -0.10449763f, 
    0.03402410f, 0.00922683f, 0.10301140f, -0.02027338f, -0.05385009f, -0.05525680f, -0.07859156f, -0.10780285f, 
    0.22072911f, -0.08206610f, 0.07702824f, -0.18375957f, -0.13211605f, -0.02435200f, 0.04180768f, -0.01949446f, 
    -0.03654269f, -0.09568768f, -0.00984234f, 0.02691106f, 0.07214715f, 0.07254849f, -0.02776265f, -0.02768480f, 
    0.04980519f, -0.05330322f, 0.03224956f, 0.00791445f, -0.00527140f, 0.03763915f, 0.02091399f, 0.02687123f, 
    -0.23470746f, -0.01556089f, -0.05272044f, -0.14446050f, -0.08530073f, 0.24848081f, -0.07064423f, 0.07096399f, 
    0.06005871f, 0.03440483f, 0.04826395f, 0.13314685f, 0.25197396f, 0.15102994f, 0.12721996f, 0.10551369f, 
    -0.04637295f, 0.15974823f, 0.02658040f, 0.03594854f, 0.05191039f, -0.10448921f, 0.07107556f, -0.10578374f, 
    0.14799197f, -0.13442281f, 0.15808646f, -0.01926046f, -0.02966655f, 0.01898250f, -0.04937758f, -0.07641178f, 
    0.12053087f, -0.04537237f, -0.01812332f, 0.04369521f, 0.00041244f, 0.13678782f, 0.06382071f, 0.08092753f, 
    -0.07450690f, -0.02165727f, 0.08240528f, -0.02109092f, 0.00436763f, -0.18531507f, -0.00171813f, -0.06600304f, 
    0.09059515f, 0.02619395f, -0.04361791f, -0.02155432f, -0.00538099f, 0.01450605f, 0.09554088f, 0.05667797f, 
    0.03165796f, -0.00319624f, 0.12535867f, -0.01911516f, 0.24413064f, -0.06014695f, 0.09241780f, -0.05188407f, 
    -0.03185659f, -0.03259925f, -0.08840413f, 0.05740045f, -0.00466132f, -0.10242760f, 0.01865518f, -0.01299194f, 
    0.05708871f, -0.16226470f, 0.07976668f, 0.13515219f, -0.08851565f, 0.04915384f, 0.07503060f, 0.07829797f, 
    -0.01404570f, 0.04601394f, -0.16321805f, -0.11876896f, 0.01145056f, 0.01093525f, -0.00519090f, -0.10790164f, 
    -0.05581310f, -0.01224790f, -0.12168033f, -0.01172742f, 0.00627557f, -0.08081402f, 0.01556691f, -0.14181402f, 
    0.09004608f, 0.02281888f, -0.05149997f, 0.08783311f, 0.06212548f, -0.04923915f, 0.02305463f, 0.00776683f, 
    -0.09866536f, 0.04068143f, 0.11557869f, 0.08990011f, 0.14266437f, 0.24353462f, 0.04084040f, 0.01359874f, 
    0.00823524f, 0.06870991f, 0.07327618f, -0.07148518f, -0.09721231f, -0.08701366f, -0.00824304f, -0.02661392f, 
    0.25252038f, 0.03064340f, 0.08674194f, -0.11890524f, 0.08548395f, 0.11497677f, 0.02544599f, 0.05921442f, 
    0.00459504f, 0.13070495f, -0.02487682f, -0.02439060f, -0.05604715f, 0.06289733f, 0.15181483f, 0.14552630f, 
    0.01205986f, -0.02941817f, 0.04473563f, 0.12752733f, 0.03557982f, 0.15773205f, 0.01143078f, 0.10181043f, 
    -0.12956947f, -0.13985771f, -0.02382321f, -0.04464309f, 0.05297661f, -0.15435614f, -0.04464111f, -0.09503154f, 
    -0.00166537f, 0.04374187f, -0.01046198f, -0.01482477f, -0.06038176f, 0.04499506f, -0.16159268f, 0.10615695f, 
    -0.03693059f, 0.12889141f, 0.11860469f, 0.07978185f, 0.15738462f, -0.01803125f, 0.00903462f, -0.01012772f, 
    -0.04496719f, 0.02639613f, 0.05196526f, 0.26234725f, -0.01946725f, -0.03652292f, -0.00367038f, -0.07583912f, 
    0.09296800f, 0.04807797f, 0.06008499f, -0.09123962f, -0.10136361f, -0.10266112f, -0.04151686f, -0.01782659f, 
    0.04004138f, 0.04633534f, -0.04099576f, -0.06478228f, 0.12787266f, 0.09514380f, -0.02079366f, -0.10643821f, 
    -0.06947241f, -0.06174111f, -0.06765092f, 0.00328983f, 0.02483621f, 0.06286790f, -0.01811588f, -0.03970113f, 
    -0.07327834f, 0.01997575f, 0.00842746f, -0.05421406f, 0.04458898f, -0.04416917f, 0.04487307f, -0.03059854f, 
    0.00184686f, -0.07911109f, -0.01517280f, -0.03598417f, 0.04749927f, 0.04622731f, 0.04456150f, 0.01107123f, 
    -0.04575507f, -0.03982456f, -0.02245500f, -0.06784999f, -0.03321811f, -0.01902759f, 0.00835828f, 0.01781545f, 
    -0.03779610f, 0.02900785f, -0.02819628f, -0.07356595f, 0.01365037f, -0.02404223f, -0.02184946f, 0.01070799f, 
    -0.05300227f, 0.04585785f, -0.05275184f, 0.04799221f, -0.02118609f, -0.01941744f, -0.07048012f, -0.02583946f, 
    0.00358848f, -0.03067676f, -0.05079962f, 0.00947954f, 0.01213384f, -0.07577652f, -0.02043368f, -0.02123608f, 
    -0.04598550f, 0.04909011f, -0.06122209f, 0.06337775f, -0.01980317f, 0.05537141f, 0.02566522f, -0.03423475f, 
    0.06142289f, 0.05821863f, -0.01978981f, -0.05817401f, -0.06817032f, -0.03684356f, -0.04978112f, 0.05599269f, 
    -0.07366045f, 0.06322733f, -0.03413227f, -0.06934863f, 0.02648626f, 0.00707730f, -0.03126021f, 0.01688513f, 
    -0.06287543f, 0.02943184f, -0.02261157f, 0.05932427f, -0.06938758f, -0.05592786f, -0.04201323f, 0.02462498f, 
    0.05869495f, 0.01988610f, -0.05876155f, -0.02789495f, -0.00174227f, -0.02352369f, -0.07947914f, -0.03516731f, 
    -0.02909755f, 0.02203749f, 0.04496621f, -0.05316257f, -0.02582004f, 0.05125322f, 0.03427792f, -0.05469085f, 
    -0.00077182f, 0.01545962f, -0.01836997f, 0.06305036f, -0.06466607f, 0.01453703f, -0.06608640f, -0.07436799f, 
    0.04560513f, 0.05769027f, -0.07609955f, -0.05282769f, -0.07053969f, -0.07165091f, 0.06159248f, -0.02891287f, 
    0.00861475f, 0.02583110f, -0.01593945f, -0.05845912f, 0.00745939f, -0.07603575f, 0.00941015f, 0.02634408f, 
    0.01845569f, 0.03217041f, -0.07867344f, -0.05500642f, 0.02164829f, 0.06159171f, 0.00996998f, -0.02657109f, 
    -0.01562679f, 0.03912227f, 0.03327429f, -0.01801158f, -0.00766623f, -0.03458544f, -0.05410039f, 0.04555693f, 
    -0.04848210f, 0.01926688f, 0.02221780f, -0.01378210f, 0.00188526f, 0.01263674f, -0.06555403f, -0.07437948f, 
    -0.02995756f, 0.01996023f, 0.03430337f, 0.01922020f, 0.05611611f, -0.01996863f, -0.02022576f, -0.07536737f, 
    -0.07433162f, -0.04062995f, -0.04436367f, 0.03817682f, -0.00259108f, -0.04516727f, 0.01070269f, -0.05866620f, 
    -0.04600308f, -0.00132291f, 0.00717789f, 0.02758450f, -0.07671835f, 0.04928269f, 0.01044346f, -0.04309388f, 
    -0.07192753f, -0.05415481f, -0.03926390f, -0.04977660f, -0.02794823f, -0.06681282f, -0.05023806f, 0.04062507f, 
    -0.03342637f, 0.06324210f, -0.01792645f, 0.01685998f, 0.02109701f, -0.03166829f, -0.06931172f, -0.06292526f, 
    -0.19656615f, -0.06405706f, -0.05854292f, -0.02096668f, 0.12335415f, -0.07729484f, -0.13383499f, 0.06014036f, 
    -0.03916447f, 0.02629349f, -0.02903490f, -0.01979456f, 0.21507563f, 0.22416081f, 0.12296040f, 0.06106582f, 
    0.19076617f, 0.20605025f, -0.04507595f, 0.01168220f, 0.07815821f, 0.05587420f, -0.01375904f, 0.06898586f, 
    0.21594220f, -0.12945636f, 0.17855759f, 0.26614451f, 0.14621866f, -0.00255775f, 0.04671919f, 0.06206492f, 
    -0.03117617f, 0.03133707f, 0.00014354f, 0.02629788f, 0.28837952f, -0.05350050f, -0.03994537f, 0.27744678f, 
    0.06043297f, 0.02746354f, -0.00493108f, 0.04244559f, -0.07579324f, 0.01893736f, 0.08766868f, -0.04295678f, 
    0.09214053f, 0.04080804f, 0.25556123f, 0.19194943f, 0.08391243f, 0.01305552f, 0.06663723f, -0.01653243f, 
    0.05704367f, -0.02178691f, 0.03636219f, 0.10373899f, -0.05800781f, 0.01294666f, 0.03697218f, 0.09893641f, 
    -0.01366446f, 0.01472722f, 0.04528657f, 0.04414515f, 0.02791596f, -0.01557020f, -0.04750406f, -0.01217279f, 
    -0.01400919f, 0.00357972f, 0.16906881f, -0.07395578f, 0.07806227f, 0.07779665f, -0.00618337f, 0.06063266f, 
    0.00061463f, -0.03669040f, 0.10506576f, 0.02891619f, -0.12437335f, 0.03884128f, -0.01884775f, -0.19873638f, 
    -0.09599065f, -0.09957889f, 0.07664140f, -0.08282728f, 0.04920715f, -0.02652574f, -0.04863781f, 0.03419684f, 
    -0.10690969f, -0.11786459f, -0.01869503f, -0.20536228f, -0.09918895f, -0.01888384f, -0.05869556f, 0.05323796f, 
    -0.01157167f, -0.04601710f, 0.01550214f, -0.06258162f, 0.19562821f, 0.27782762f, -0.12648071f, 0.03255701f, 
    0.08849747f, 0.06116134f, -0.05338824f, 0.04487035f, 0.02406922f, 0.06629007f, 0.01730699f, 0.02982946f, 
    -0.17994882f, 0.27369601f, 0.03111597f, 0.02578981f, -0.01597422f, -0.08989515f, -0.00530300f, 0.09489557f, 
    -0.08948644f, -0.03934386f, 0.04973724f, 0.08013824f, -0.18425772f, 0.02807982f, -0.15513183f, -0.00809186f, 
    -0.01704788f, -0.13510142f, 0.03101096f, -0.03927609f, -0.01293970f, -0.00914698f, 0.05302965f, 0.02389232f, 
    -0.00845110f, -0.20067494f, -0.06761232f, 0.08896296f, -0.11222180f, 0.05220339f, -0.08370731f, 0.07788548f, 
    0.06485958f, -0.02034966f, 0.00625134f, 0.03568003f, -0.18192627f, -0.00504376f, 0.17778020f, -0.16613087f, 
    -0.09889179f, -0.06535067f, 0.18183717f, -0.02985568f, -0.06090941f, 0.00184473f, -0.01353502f, 0.02707014f, 
    -0.01587055f, -0.12144316f, -0.13124907f, -0.00063210f, -0.05116610f, -0.06275014f, -0.07586650f, 0.13664781f, 
    -0.06314965f, -0.02847632f, -0.21706587f, 0.12350918f, -0.02998048f, 0.07286895f, 0.01321892f, -0.02775834f, 
    0.09274757f, 0.05026820f, 0.06286631f, -0.06796384f, -0.09334963f, -0.04424959f, 0.01507260f, 0.09021360f, 
    -0.44265711f, 0.02325977f, 0.05856138f, -0.03168018f, -0.00378226f, 0.08536740f, -0.00865423f, -0.03341591f, 
    -0.00322309f, -0.04943433f, -0.06165722f, 0.08968227f, -0.09820580f, 0.14080602f, 0.24668436f, -0.07508817f, 
    -0.11614036f, 0.00029217f, -0.01697472f, -0.02551398f, -0.01571172f, 0.07083617f, 0.05543092f, 0.11481208f, 
    -0.25155726f, 0.06256020f, -0.15413214f, -0.30146682f, 0.11397963f, -0.00729502f, 0.15277563f, 0.04928490f, 
    -0.06510569f, -0.01930856f, -0.01308282f, 0.17040135f, 0.40605268f, -0.29015845f, -0.07369766f, -0.05374910f, 
    0.01211597f, -0.05180560f, -0.01555388f, -0.13428123f, 0.01381849f, -0.03000202f, 0.20610510f, -0.02204090f, 
    0.36013293f, 0.06510157f, -0.01898836f, -0.17821744f, -0.06017607f, 0.07681078f, -0.01118759f, 0.11654372f, 
    0.06547666f, -0.06017017f, 0.04176683f, 0.05656875f, 0.36465770f, 0.08912541f, 0.11746272f, 0.14963461f, 
    -0.11255977f, -0.12862454f, -0.17304038f, -0.07106119f, 0.05524139f, -0.07523835f, 0.04306661f, 0.00658440f, 
    -0.12677607f, 0.01007725f, -0.05413106f, 0.04606952f, -0.03412925f, 0.11098587f, -0.07698421f, 0.00128422f, 
    -0.01384978f, -0.01113675f, 0.01783081f, -0.12308535f, -0.01169780f, -0.15709026f, 0.08233974f, 0.02575761f, 
    -0.02008769f, 0.04278037f, -0.01092886f, 0.03880626f, -0.00228409f, -0.01880166f, 0.01439475f, -0.01945755f, 
    -0.02324736f, -0.08302372f, 0.04140681f, 0.15958422f, 0.13440275f, 0.03281289f, -0.05844018f, 0.02555647f, 
    -0.06916533f, -0.10160863f, 0.13642432f, -0.00014037f, 0.29446232f, 0.19954750f, -0.20734307f, -0.22639790f, 
    0.06245816f, -0.01467186f, 0.01544027f, -0.08269956f, 0.11762388f, -0.01257278f, -0.04818394f, 0.00444343f, 
    0.65124798f, -0.24264085f, 0.13281970f, 0.02886746f, -0.13348883f, 0.19186589f, 0.03899790f, 0.11154824f, 
    0.09978266f, 0.05612798f, 0.07207514f, 0.12614807f, 0.18481933f, -0.10225648f, -0.04264100f, 0.15741807f, 
    -0.10661355f, -0.01914510f, -0.14645809f, 0.17353062f, 0.10883719f, -0.03968820f, 0.09870709f, 0.01132885f, 
    -0.15293646f, -0.02536140f, -0.02989230f, 0.16964479f, 0.06095450f, -0.10215893f, 0.02705591f, 0.03882657f, 
    -0.00254480f, -0.06731267f, 0.01699724f, 0.00981912f, 0.09517254f, -0.22121605f, 0.05134914f, 0.09317768f, 
    -0.07548308f, 0.00065939f, -0.00090785f, 0.02392840f, 0.05278003f, -0.06731516f, -0.01109687f, -0.09979724f, 
    -0.14058721f, 0.03940299f, -0.02158600f, -0.01864787f, 0.03895466f, 0.01729794f, 0.00942987f, 0.01034989f, 
    0.04470845f, -0.08315555f, -0.12846848f, -0.00785527f, -0.13033871f, 0.02889463f, 0.05868090f, 0.09327770f, 
    0.11231282f, 0.16310970f, -0.03991304f, -0.00466663f, -0.02362250f, -0.00333516f, -0.03690238f, 0.03860989f, 
    -0.09890968f, -0.14652234f, -0.04446309f, -0.16866003f, -0.03247353f, -0.02311156f, -0.04299837f, -0.09456120f, 
    0.03845574f, -0.05440593f, -0.10121712f, 0.04207533f, 0.12801735f, 0.02247954f, 0.08684117f, 0.04040209f, 
    0.02935692f, -0.07399434f, 0.13961139f, 0.13619484f, 0.05120650f, -0.16161087f, -0.00004616f, 0.01206154f, 
    -0.22871514f, 0.25403622f, 0.00583327f, -0.02626774f, -0.00111911f, 0.01460476f, 0.03533250f, -0.12284918f, 
    -0.01527260f, -0.08621329f, 0.06270198f, 0.10930201f, 0.15917650f, -0.17933226f, 0.11849097f, -0.13455096f, 
    -0.09395837f, -0.00373606f, -0.01841944f, 0.03197590f, -0.04705988f, 0.13864502f, -0.02241777f, 0.05442260f, 
    0.20942858f, 0.20068127f, 0.12367961f, -0.12903929f, 0.03543210f, -0.00612461f, 0.01436600f, -0.02814545f, 
    0.01666062f, -0.13043110f, -0.14982148f, -0.00630752f, 0.16212896f, 0.19108322f, -0.13631357f, 0.02616747f, 
    -0.04427971f, 0.00650525f, -0.06109942f, -0.01655680f, 0.04307821f, 0.03807496f, -0.03678585f, 0.15952469f, 
    -0.04784895f, 0.02790792f, -0.21124232f, 0.26392934f, -0.12418076f, 0.06754232f, -0.01775361f, -0.04493289f, 
    0.05151750f, -0.03830557f, -0.08851022f, 0.03387506f, 0.03217257f, -0.13438140f, 0.14430055f, 0.30463320f, 
    -0.07102130f, 0.09414245f, -0.13399342f, 0.07304425f, 0.00739959f, -0.03928516f, 0.03732307f, 0.02120234f, 
    0.07455116f, -0.10221972f, 0.08134191f, 0.43689203f, -0.10154242f, 0.02147716f, -0.03657630f, 0.03130376f, 
    0.09458789f, 0.09499074f, 0.09122907f, 0.12033780f, 0.03449868f, 0.18854879f, -0.01690636f, -0.16279875f, 
    0.06629814f, -0.00828261f, 0.06045591f, 0.00065509f, -0.10232208f, -0.10903914f, -0.09222942f, 0.06948014f, 
    0.09324758f, 0.09896027f, -0.00507873f, 0.05809665f, -0.06831831f, 0.12640695f, -0.04327665f, 0.08981985f, 
    0.15602145f, -0.02294717f, 0.00925862f, -0.05963809f, 0.31303316f, 0.33008257f, 0.11823711f, 0.07713231f, 
    0.03068970f, -0.05294142f, 0.02201745f, 0.02514389f, 0.02538145f, -0.01981232f, -0.08738557f, -0.08450124f, 
    -0.21434097f, -0.00886768f, 0.01050517f, -0.02137652f, 0.03913227f, -0.01176206f, -0.01239256f, -0.01171873f, 
    -0.09880831f, -0.06135485f, 0.06524652f, 0.07547206f, 0.44257230f, -0.06119229f, -0.19942811f, 0.26874152f, 
    0.02497695f, 0.06210741f, -0.07387936f, -0.05314283f, 0.04194677f, 0.10861079f, 0.03283382f, -0.00247650f, 
    -0.35806122f, 0.04920349f, 0.05458773f, -0.14709626f, 0.04987588f, -0.00639146f, -0.05270897f, -0.01198722f, 
    0.15186369f, -0.03410707f, -0.04359508f, 0.02292068f, -0.13110550f, -0.20538381f, 0.01736402f, 0.22071248f, 
    -0.02676786f, -0.02625028f, -0.01557849f, 0.08711281f, 0.04454432f, -0.06744513f, 0.05018472f, 0.03380240f, 
    0.15669218f, 0.26762915f, 0.15842652f, 0.15036643f, -0.09615908f, -0.06098618f, 0.01748583f, 0.07204433f, 
    -0.00119476f, 0.00596705f, -0.01450733f, 0.01728182f, -0.36366722f, -0.46276659f, -0.17620251f, 0.02348628f, 
    0.10425739f, -0.01846190f, 0.00759411f, 0.09334452f, 0.01467732f, 0.10842357f, -0.13003629f, -0.01785376f, 
    0.04592794f, -0.06636575f, 0.05491417f, -0.03467673f, -0.09557363f, -0.07053116f, -0.02935136f, 0.11392401f, 
    0.05187479f, 0.06068183f, -0.01766325f, 0.02972125f, -0.13776450f, -0.21738543f, -0.12314615f, 0.11270122f, 
    0.15884219f, -0.01560356f, 0.05422111f, 0.14141019f, -0.03914496f, -0.02326149f, 0.03550399f, -0.19111310f, 
    0.19356477f, -0.47800499f, -0.21337254f, 0.07396883f, -0.03718131f, 0.01611732f, 0.04596987f, 0.24913318f, 
    0.13628601f, 0.04143454f, 0.06689531f, -0.03395168f, 0.08172264f, -0.04171140f, -0.09274415f, -0.00977371f, 
    0.12816465f, -0.08812739f, 0.03825211f, 0.06660452f, 0.05562443f, -0.08636408f, -0.04339021f, 0.03437374f, 
    0.01222468f, 0.08015962f, 0.14618900f, -0.11464290f, 0.00468204f, -0.09448221f, -0.04707109f, 0.05929638f, 
    -0.04680208f, 0.10271205f, 0.08397986f, 0.09504479f, 0.11302122f, 0.36929253f, -0.05480989f, -0.17219733f, 
    0.09720026f, -0.00748409f, -0.01385449f, -0.02257936f, 0.09463966f, 0.05629047f, 0.13379627f, 0.09175341f, 
    -0.17504573f, 0.12785046f, 0.02490546f, -0.11500823f, 0.08320723f, 0.14794208f, 0.03653410f, -0.05517459f, 
    0.05246021f, 0.02833259f, 0.02096120f, 0.06238022f, -0.38237491f, -0.05625855f, -0.06760142f, 0.09731621f, 
    0.00208790f, 0.00777836f, -0.02797685f, 0.12958749f, 0.18452753f, 0.05254204f, 0.11489841f, -0.06494512f, 
    -0.02957705f, -0.20561610f, -0.04030890f, 0.01474490f, 0.01058285f, -0.06404640f, 0.10254238f, -0.10135838f, 
    -0.07465637f, 0.04151489f, -0.03395793f, -0.01243610f, -0.30479002f, -0.27201530f, -0.09356442f, -0.22468054f, 
    0.09413416f, -0.00090925f, -0.07906779f, 0.01852280f, -0.00748580f, 0.08511692f, 0.07621941f, 0.03456498f, 
    0.09135104f, 0.09338280f, 0.13165881f, 0.18031028f, -0.05750174f, 0.13537358f, 0.07272722f, 0.06540215f, 
    -0.03231878f, 0.03755961f, -0.01336343f, 0.03040271f, -0.02420243f, 0.16038571f, 0.09772092f, -0.12665159f, 
    0.04267421f, -0.03563699f, 0.07709871f, 0.00339410f, 0.08387205f, 0.02761083f, -0.07454620f, 0.13856193f, 
    0.01622268f, -0.00661595f, 0.01374698f, 0.14987862f, 0.08929427f, 0.11217303f, 0.04661224f, 0.04381987f, 
    0.01992129f, 0.02864423f, -0.11256813f, 0.01711918f, 0.09861645f, 0.14262407f, 0.27682656f, -0.17956138f, 
    -0.01955911f, -0.11856853f, -0.01377927f, -0.07305259f, -0.05139260f, 0.10839845f, -0.04272506f, 0.00936289f, 
    -0.02888686f, -0.02476650f, -0.01809002f, -0.00611689f, -0.05275412f, 0.02929659f, -0.05007247f, -0.02189294f, 
    0.00256493f, -0.05748352f, 0.04138610f, 0.04029359f, -0.04620411f, 0.04618004f, 0.05275692f, -0.01114603f, 
    -0.04813500f, 0.01297337f, -0.06414434f, 0.04601502f, 0.05723377f, 0.00312361f, -0.06728906f, -0.01998440f, 
    -0.01743012f, 0.05257358f, 0.01726551f, -0.05828461f, 0.05416579f, -0.02143033f, -0.00910883f, -0.04630832f, 
    0.00431053f, -0.00472923f, -0.07800116f, 0.04400357f, -0.03142329f, -0.07287967f, -0.03976263f, 0.04347182f, 
    0.01445921f, 0.05908268f, -0.05753218f, 0.05291820f, -0.06694892f, 0.06440382f, 0.01156336f, -0.01713298f, 
    -0.06378410f, -0.03557771f, -0.03679781f, -0.03782013f, -0.03738028f, -0.00058337f, -0.01467089f, -0.00260868f, 
    0.02935003f, -0.01005293f, -0.02664435f, -0.03037754f, -0.02912897f, -0.05482064f, 0.00898215f, -0.01788154f, 
    -0.05899263f, 0.04001528f, 0.02973270f, -0.02350688f, 0.01771854f, -0.06774308f, 0.02104816f, 0.05990041f, 
    0.06361606f, -0.00626141f, -0.07017156f, 0.02974750f, 0.01762362f, 0.03875649f, -0.05563308f, -0.06105353f, 
    0.04194058f, -0.01338600f, 0.00850899f, -0.01542015f, 0.05721635f, 0.01928419f, -0.01650108f, 0.01735125f, 
    0.05520005f, 0.02746430f, -0.07091597f, 0.00278602f, -0.05264533f, -0.04468573f, -0.06505431f, 0.05285997f, 
    -0.01988833f, 0.00196914f, -0.07069684f, 0.05740499f, 0.03651999f, 0.04229543f, 0.00158143f, 0.01874205f, 
    -0.06688926f, -0.00094496f, -0.00375203f, 0.02282959f, -0.06315838f, 0.05454930f, 0.04985862f, -0.05365793f, 
    -0.01452484f, -0.02702527f, 0.00897322f, 0.01378618f, -0.06532605f, -0.00824573f, 0.05839116f, -0.06921719f, 
    -0.05397260f, -0.05427066f, 0.01292460f, -0.06280896f, -0.04058551f, 0.03750169f, 0.02754295f, 0.02014902f, 
    -0.02672504f, 0.02980747f, -0.07820572f, -0.03298325f, 0.00114903f, -0.07684415f, -0.06599905f, 0.05112864f, 
    -0.00470648f, -0.05554181f, -0.01674746f, 0.03116975f, 0.02017216f, -0.05613582f, 0.03127093f, -0.00015079f, 
    0.02994242f, 0.05748363f, -0.01153499f, -0.00244686f, -0.07746223f, -0.00042237f, -0.07055480f, -0.01140587f, 
    -0.07543170f, -0.03150058f, -0.02731764f, -0.01135962f, 0.02512557f, -0.03986189f, 0.02512622f, 0.01032019f, 
    -0.01080836f, 0.06048070f, -0.07625648f, 0.03986792f, -0.04088774f, -0.06671552f, 0.00047479f, -0.02920054f, 
    0.02294141f, 0.04576108f, -0.05919304f, -0.06121537f, -0.02751298f, -0.07720853f, -0.06310258f, -0.03188591f, 
    0.06128497f, 0.04227690f, 0.00137853f, 0.04230258f, 0.03634764f, -0.07278888f, 0.04386275f, -0.06487973f, 
    -0.04789189f, -0.07100167f, 0.05703713f, -0.07654241f, 0.03512086f, -0.05694617f, -0.00594881f, -0.03799851f, 
    0.01895004f, -0.10420194f, 0.16829325f, -0.34171009f, -0.10567924f, 0.10054475f, 0.02487882f, -0.00112929f, 
    0.01563630f, -0.03826394f, 0.04627613f, 0.12278470f, 0.16308999f, -0.18462162f, 0.15844502f, 0.13397071f, 
    -0.07152485f, 0.02107211f, 0.11679701f, 0.16829224f, -0.05045134f, -0.11924519f, -0.02409691f, 0.03563426f, 
    -0.23663636f, 0.19806395f, 0.02281280f, -0.06130980f, -0.05493697f, -0.01531947f, 0.08465684f, -0.02351316f, 
    -0.02407600f, 0.13431357f, 0.11159967f, 0.20823440f, 0.29551575f, -0.22334552f, 0.24651858f, 0.07040618f, 
    -0.05029991f, -0.04477372f, 0.12312787f, 0.00802178f, -0.02153884f, -0.02045798f, 0.06609500f, 0.11986861f, 
    0.53271943f, -0.13639162f, -0.09393875f, 0.00408592f, -0.07080568f, 0.03974750f, -0.00348680f, 0.23225597f, 
    0.07353407f, 0.01360195f, 0.04234593f, 0.01737292f, 0.27127790f, 0.25329846f, -0.12892364f, -0.05942981f, 
    0.04684095f, 0.00067243f, -0.00588362f, 0.15382925f, 0.11832216f, -0.15221450f, 0.02988767f, 0.23271090f, 
    -0.15621319f, 0.06744313f, 0.05360382f, 0.17798342f, -0.00265568f, 0.20505475f, 0.04698718f, 0.07011285f, 
    -0.10520749f, -0.02711119f, -0.12355202f, -0.03487109f, -0.00559433f, 0.10370333f, -0.02634491f, 0.01181849f, 
    0.04028091f, -0.04294843f, -0.14206268f, -0.05295714f, -0.05625813f, 0.01593670f, 0.08523045f, -0.02621145f, 
    -0.22106619f, 0.00124581f, -0.10973779f, 0.11215258f, -0.00507383f, 0.06630137f, -0.16343245f, -0.06211874f, 
    0.10601708f, -0.08239259f, 0.05412580f, 0.02217236f, 0.11048113f, 0.29943329f, -0.04701804f, -0.10073646f, 
    0.16803974f, 0.01642640f, 0.10699207f, 0.19550131f, -0.03662964f, -0.24971856f, 0.08513214f, -0.08131887f, 
    0.17817202f, 0.02776090f, -0.06835811f, -0.10828324f, -0.08812955f, 0.18141867f, -0.11718630f, -0.06226358f, 
    -0.03376875f, -0.03467065f, -0.00015296f, -0.02744482f, 0.03625173f, 0.09392314f, -0.01586778f, 0.16117691f, 
    0.02058736f, -0.04590066f, 0.11131147f, 0.11392131f, -0.05511226f, 0.10598277f, -0.03323198f, 0.07482895f, 
    -0.35279372f, -0.22878258f, 0.06934446f, -0.11278462f, -0.20219150f, 0.05586267f, -0.00752552f, -0.07350563f, 
    0.06786705f, 0.09468284f, 0.01751084f, 0.04228378f, -0.06553691f, 0.00280595f, -0.32040578f, 0.02211457f, 
    -0.07218847f, -0.04531566f, -0.02804846f, -0.11445353f, 0.09678128f, -0.02462124f, 0.10220035f, 0.07661289f, 
    -0.25607696f, -0.22873822f, 0.15113990f, -0.01815136f, -0.01339377f, 0.03364695f, -0.12465239f, -0.07431822f, 
    0.14747381f, -0.04582260f, 0.07720120f, -0.12657860f, -0.17635255f, -0.26494056f, 0.14139931f, 0.07384720f, 
    -0.18475668f, 0.09599749f, 0.00978402f, -0.03183281f, -0.03790923f, 0.17498177f, 0.12563835f, -0.01240532f, 
    -0.05303290f, -0.13911359f, -0.01098960f, -0.39561382f, -0.06491765f, 0.05704183f, 0.05917188f, 0.00477232f, 
    0.04826523f, -0.02184391f, -0.00995393f, 0.11902343f, 0.22082020f, 0.10447586f, 0.12637086f, 0.06942048f, 
    0.01288285f, 0.09418853f, 0.12775239f, -0.03475196f, 0.05240187f, 0.07179254f, 0.07293589f, 0.07938621f, 
    0.29993042f, 0.12571980f, 0.06434233f, 0.02754434f, 0.06516204f, -0.01782580f, -0.02073484f, -0.00790924f, 
    -0.04681802f, 0.05843249f, -0.00186639f, 0.04827297f, 0.27872115f, -0.06945038f, 0.16148373f, 0.20832792f, 
    0.03684667f, -0.02856475f, -0.00708540f, 0.09925402f, -0.04956819f, -0.07881816f, 0.05347555f, 0.06324194f, 
    0.38123178f, -0.08240356f, 0.01183435f, 0.02182183f, 0.00457378f, 0.21945880f, 0.07610177f, -0.00640474f, 
    -0.16119096f, 0.11216338f, -0.07543308f, -0.08372724f, 0.13817540f, 0.06528696f, 0.10941125f, 0.10241199f, 
    0.10594761f, -0.12263659f, 0.02601968f, 0.19870658f, 0.10335808f, 0.01087159f, -0.00898001f, 0.05605544f, 
    0.01808287f, 0.14570381f, 0.02799305f, 0.04494067f, -0.00128590f, -0.01803204f, -0.01750172f, 0.06824998f, 
    -0.09754227f, -0.01905303f, 0.03640947f, 0.00219454f, -0.09419671f, -0.16895114f, -0.26260939f, -0.27082574f, 
    0.18195687f, -0.12712459f, -0.03734206f, 0.02277853f, -0.14785835f, -0.04854540f, 0.04749463f, 0.10094830f, 
    -0.27745548f, -0.20534858f, -0.28013659f, -0.41515213f, 0.11853149f, 0.00088182f, 0.00022234f, 0.00645748f, 
    0.06796607f, -0.04929367f, -0.03117842f, -0.01485494f, 0.15827093f, 0.07623649f, 0.06703574f, 0.13717690f, 
    0.20737174f, 0.09674187f, 0.08661045f, 0.10227875f, 0.02898008f, -0.09989317f, -0.01773242f, -0.10666081f, 
    0.19613750f, 0.03103431f, 0.10682321f, 0.00813031f, 0.10041937f, -0.02233526f, 0.05749436f, 0.08638024f, 
    0.01036859f, -0.07016090f, -0.05430792f, 0.08706246f, 0.09935953f, 0.00705909f, -0.10185053f, -0.02035247f, 
    0.09989586f, -0.08994886f, -0.00638777f, 0.17908856f, -0.03536801f, -0.06296629f, 0.03062010f, -0.04007676f, 
    -0.17194775f, -0.22582957f, -0.04871969f, -0.04556753f, 0.05973800f, 0.15558212f, 0.04612450f, 0.04057574f, 
    0.03593628f, 0.11037236f, -0.03165807f, 0.05599682f, -0.40739322f, -0.10491943f, -0.15300269f, -0.27142417f, 
    0.05187729f, -0.07750188f, 0.07623117f, 0.07326286f, 0.04795755f, -0.02960389f, 0.05330973f, 0.06146723f, 
    0.20577212f, -0.10669189f, 0.00853562f, -0.08582514f, 0.07050585f, 0.09312325f, -0.12998575f, -0.03059070f, 
    0.04092598f, -0.07863555f, 0.01911994f, -0.03741306f, -0.07894967f, 0.07143711f, -0.09960861f, -0.23948607f, 
    0.07003361f, 0.04664991f, 0.03024943f, -0.08999140f, 0.01387381f, 0.08460962f, 0.01239710f, 0.08888187f, 
    0.00001251f, -0.06285082f, -0.07072092f, 0.04212623f, 0.05316257f, 0.02723677f, -0.07466464f, -0.00780260f, 
    0.05694110f, -0.06227630f, -0.01909737f, -0.04907597f, 0.03449988f, -0.02173453f, -0.00648668f, -0.00628588f, 
    -0.03812538f, 0.02568931f, 0.02814336f, -0.03487148f, -0.05699756f, -0.01954221f, 0.04768432f, 0.01630522f, 
    -0.06492129f, 0.01244987f, 0.05150339f, -0.06957274f, 0.03779835f, -0.05595400f, -0.06121398f, -0.02329388f, 
    0.02457837f, 0.03410268f, 0.06061460f, -0.06647839f, -0.01635049f, 0.00972170f, -0.04584682f, 0.05417609f, 
    0.00676144f, -0.06804056f, -0.02274254f, 0.01181501f, -0.04304107f, -0.04684390f, 0.03154277f, -0.06881647f, 
    -0.00598865f, -0.03191046f, 0.05097242f, -0.06802519f, -0.05018434f, -0.07580439f, -0.06109791f, 0.02102826f, 
    -0.07366325f, -0.01281037f, 0.03723576f, 0.03875962f, 0.03046117f, -0.05033299f, 0.03854666f, -0.05849106f, 
    -0.07487366f, 0.03059889f, -0.06421124f, -0.00645306f, 0.03826675f, -0.01160679f, 0.05602425f, -0.01722220f, 
    0.02506773f, -0.04482128f, 0.03301159f, -0.01567344f, 0.03655441f, -0.02839036f, -0.06559854f, 0.03304155f, 
    -0.03875314f, 0.01304953f, 0.03315303f, 0.02002987f, 0.02702114f, 0.00347675f, -0.02625933f, 0.02720756f, 
    -0.03491559f, 0.02863333f, -0.05121519f, -0.06321625f, -0.03002590f, -0.05648429f, -0.05421073f, -0.06778064f, 
    0.03144633f, 0.00842997f, -0.00196689f, 0.02093105f, -0.04137199f, -0.06668663f, -0.07482304f, 0.02122212f, 
    0.02945410f, -0.07642900f, 0.03202054f, -0.04222614f, -0.01960352f, -0.02754579f, -0.07035086f, 0.05354302f, 
    -0.06774765f, 0.05065319f, 0.05785341f, -0.04786607f, -0.07551749f, -0.05594885f, 0.01994388f, 0.05873494f, 
    -0.01234562f, 0.03238251f, -0.07097484f, -0.04271565f, 0.01506456f, 0.03875592f, -0.03289647f, 0.06235682f, 
    0.03741730f, 0.05597799f, 0.04892677f, 0.05970507f, -0.02822492f, -0.06468549f, 0.05265284f, -0.04056309f, 
    0.00516351f, -0.04044861f, -0.00161074f, 0.02087967f, 0.02362759f, -0.00340269f, -0.02850180f, 0.04304533f, 
    -0.06207469f, -0.04668659f, -0.03427899f, 0.03814097f, -0.03587987f, 0.02497119f, -0.06096556f, -0.03915366f, 
    0.01182142f, 0.01111459f, -0.04285347f, 0.05710160f, -0.03803451f, -0.04657224f, 0.04002092f, 0.03224294f, 
    -0.01434523f, 0.03058096f, -0.04121419f, 0.01413632f, 0.03579257f, -0.05346031f, -0.03582476f, -0.00392191f, 
    -0.04756477f, 0.04540612f, -0.04241357f, 0.04253478f, 0.04277699f, 0.02682300f, 0.02151735f, 0.06610782f, 
    -0.07805344f, 0.00290489f, -0.06601793f, -0.07651968f, -0.00668772f, -0.07126702f, -0.03376210f, -0.02758448f, 
    -0.05591651f, -0.07086581f, -0.03222762f, -0.00886485f, 0.05573539f, -0.03924633f, -0.04901550f, -0.02015018f, 
    -0.47963968f, -0.15440141f, 0.17954847f, -0.11039366f, 0.06373230f, 0.09289033f, 0.05538746f, -0.18290624f, 
    0.04443065f, -0.04720079f, -0.00040430f, 0.00837387f, 0.10911861f, 0.15347600f, 0.07483307f, -0.07987642f, 
    -0.03474808f, 0.09160405f, 0.10772263f, 0.13659810f, 0.11695567f, 0.11979837f, -0.01769881f, 0.16827489f, 
    -0.14818332f, 0.06153873f, 0.14076254f, 0.06252292f, -0.01531206f, 0.01731043f, 0.15295981f, 0.01184648f, 
    0.03106263f, -0.12165791f, 0.03258887f, 0.00301424f, 0.41257924f, -0.24562037f, -0.23139532f, -0.12649184f, 
    -0.01054101f, 0.06922682f, 0.01206936f, -0.00376396f, 0.03349461f, -0.04528632f, 0.19262162f, 0.01599955f, 
    0.07645701f, 0.15828604f, 0.11078139f, -0.26162678f, 0.00341339f, 0.00749160f, -0.00366296f, -0.08082923f, 
    -0.05693978f, -0.20517448f, -0.01213189f, 0.00200473f, -0.02142294f, 0.03474179f, -0.17961621f, -0.02872525f, 
    0.00167237f, 0.03974144f, 0.06940635f, -0.03160669f, -0.08077698f, 0.13216564f, -0.09573886f, 0.09310230f, 
    -0.00184467f, -0.04068119f, -0.10930029f, 0.04410551f, -0.09360536f, 0.05051459f, -0.12744293f, -0.12459283f, 
    0.02065539f, -0.01626464f, 0.08271727f, 0.02787694f, -0.12514263f, -0.19538997f, 0.28585014f, 0.17422189f, 
    -0.04639447f, -0.00104868f, 0.02572441f, -0.10890908f, 0.09011608f, -0.11119368f, -0.04841504f, 0.14654757f, 
    0.25035444f, -0.02910795f, 0.20397635f, 0.16370921f, 0.06422124f, 0.19276935f, -0.04559908f, 0.04030062f, 
    0.14552021f, 0.04656409f, 0.13302629f, -0.00040450f, 0.14711753f, -0.01760412f, -0.08890283f, -0.26986539f, 
    0.10946856f, 0.09771822f, -0.01810244f, 0.08947585f, -0.05675621f, 0.05137094f, -0.15963735f, 0.05947958f, 
    -0.19055533f, 0.00584983f, -0.09801899f, 0.01027897f, 0.05707990f, 0.21532853f, -0.04314511f, 0.03258241f, 
    0.14770982f, -0.02897636f, 0.05085160f, -0.00343549f, 0.11838316f, 0.04670882f, -0.19611192f, 0.01550089f, 
    -0.17282794f, 0.04262728f, 0.09518496f, 0.09120616f, -0.02489496f, 0.04348286f, -0.03293622f, 0.00309448f, 
    -0.09372202f, 0.11458571f, 0.01792425f, 0.11413985f, 0.01409128f, 0.04728603f, -0.09460224f, -0.00121249f, 
    0.01460503f, -0.01846547f, 0.19135782f, -0.00858389f, 0.27237716f, -0.15659331f, -0.01219957f, -0.05867576f, 
    0.05907073f, 0.02129318f, -0.14635497f, -0.03625885f, -0.00892970f, 0.07926504f, 0.04402811f, -0.07274792f, 
    -0.35312021f, 0.07745294f, -0.20349039f, -0.15279119f, -0.01101310f, -0.00826168f, -0.04909907f, -0.01584947f, 
    0.04555726f, 0.02425609f, -0.01460724f, -0.03071467f, -0.08727185f, -0.09668665f, 0.01886901f, 0.29484111f, 
    0.08126546f, 0.06043684f, 0.02569167f, 0.00631799f, 0.08892700f, -0.01581442f, 0.12751858f, 0.16302507f, 
    -0.15472899f, -0.19662593f, 0.26666293f, -0.06304319f, 0.10134703f, 0.04615092f, 0.20900561f, -0.05779705f, 
    0.05411430f, 0.00051300f, 0.07725976f, 0.13471247f, 0.14328901f, 0.06945065f, -0.07779122f, -0.00232684f, 
    -0.01762185f, 0.03585251f, -0.06537504f, 0.04823734f, -0.02094012f, 0.00016051f, -0.01545209f, -0.11931410f, 
    -0.14763989f, 0.15512140f, 0.02522065f, -0.07045221f, 0.04854685f, 0.00949442f, 0.02554490f, -0.13811073f, 
    -0.01640186f, -0.05152229f, -0.08366843f, -0.00179075f, 0.12645544f, -0.17365326f, -0.01132563f, -0.01327079f, 
    -0.00096913f, -0.07520101f, 0.20348410f, -0.15517381f, -0.02958955f, 0.00990321f, 0.05247654f, -0.01802045f, 
    -0.05173222f, 0.02951065f, -0.13269190f, -0.08208642f, -0.04949996f, 0.03699829f, -0.00573837f, -0.03541572f, 
    -0.12070344f, -0.05132482f, 0.10446016f, -0.10778330f, 0.10457527f, 0.01973773f, 0.02657944f, -0.03026283f, 
    -0.07773613f, 0.10116138f, -0.08418787f, 0.08461891f, -0.09205669f, 0.05688869f, 0.00286436f, 0.07264125f, 
    0.02625453f, 0.11620472f, -0.05414356f, 0.07462867f, -0.13272151f, 0.03629205f, -0.04178103f, -0.00219859f, 
    0.04185995f, -0.03935016f, -0.08378094f, -0.06153882f, -0.05877334f, -0.30078730f, 0.07792225f, -0.00226702f, 
    -0.04946829f, -0.06712036f, 0.02889054f, 0.07713011f, -0.03191211f, 0.01846365f, -0.07496960f, -0.03532009f, 
    0.34236816f, 0.05049798f, 0.01012025f, -0.02753143f, 0.06373736f, 0.07223285f, 0.00871963f, 0.04155381f, 
    0.01166411f, 0.12387717f, 0.03490705f, 0.04839554f, 0.05021311f, -0.33841151f, 0.06538180f, -0.10598613f, 
    0.01048936f, 0.09652974f, -0.00116051f, -0.09192907f, 0.07912645f, 0.10586607f, -0.06103009f, 0.11851377f, 
    -0.09174941f, -0.06856319f, -0.11519153f, 0.19949444f, -0.03472929f, 0.12302610f, -0.07979754f, 0.09841137f, 
    0.17033504f, 0.01829219f, 0.04267399f, 0.05889959f, 0.43050817f, 0.04161729f, 0.06965746f, 0.08967546f, 
    0.03012509f, -0.07785732f, 0.14405020f, 0.10755821f, -0.02948079f, 0.12355492f, -0.01453495f, -0.01086613f, 
    -0.05924630f, 0.24234679f, -0.02509676f, -0.09187842f, 0.04170863f, -0.04061896f, 0.02205992f, -0.04682177f, 
    0.00368046f, 0.06254717f, -0.11150756f, -0.03260910f, 0.05845273f, -0.29978275f, -0.10196123f, 0.11881503f, 
    0.04229301f, 0.08001064f, -0.14899921f, 0.12333443f, 0.13810326f, -0.00997570f, -0.04224133f, 0.08719535f, 
    0.09014782f, 0.01739973f, 0.09118281f, 0.02992922f, -0.06718686f, -0.00878592f, 0.12768665f, -0.05034351f, 
    0.00422149f, -0.02982127f, 0.00486466f, -0.11043602f, 0.14259318f, 0.03457550f, 0.17227755f, -0.02212236f, 
    -0.07639293f, -0.09279791f, -0.06784036f, 0.06756252f, 0.13086274f, 0.02421075f, -0.05385035f, -0.01815977f, 
    -0.14249118f, 0.01085418f, -0.18200612f, 0.16355476f, 0.05351753f, 0.05665615f, -0.05637108f, -0.06749427f, 
    0.00406914f, 0.08588263f, -0.01890179f, -0.03032880f, -0.19265206f, 0.11764755f, -0.04072367f, -0.20112975f, 
    -0.00575192f, -0.04692247f, -0.08398238f, -0.20155293f, -0.01438466f, 0.08275222f, -0.01825574f, 0.08737853f, 
    0.09332661f, -0.09250274f, -0.03302376f, 0.14837690f, 0.10632973f, -0.02522293f, 0.03236156f, 0.03698343f, 
    -0.01049010f, -0.00225568f, -0.02343455f, -0.05398565f, -0.07713424f, 0.20457613f, -0.11649702f, -0.03471120f, 
    0.00943160f, 0.11870130f, 0.02208630f, 0.01177908f, 0.07459106f, 0.10563628f, -0.02836348f, 0.02258030f, 
    -0.30714586f, -0.10827987f, 0.16232118f, 0.01643017f, 0.02787940f, 0.13152181f, 0.04305742f, -0.12198823f, 
    -0.11198868f, 0.04839314f, -0.07955671f, 0.04984562f, 0.01815129f, -0.17037427f, 0.21257713f, 0.05466957f, 
    -0.02958649f, -0.08427545f, 0.04960438f, 0.08063959f, -0.00040796f, 0.21854864f, -0.06813877f, -0.09146834f, 
    0.17504074f, 0.08430173f, 0.12655558f, -0.23624061f, 0.09337317f, 0.05455330f, 0.04334501f, 0.06432997f, 
    0.06640428f, 0.05766238f, 0.17404409f, -0.01303952f, -0.15351775f, -0.08999484f, 0.13045588f, -0.19148381f, 
    0.07060246f, 0.04202165f, 0.16577141f, -0.14339231f, 0.09631927f, 0.13880451f, -0.02741687f, 0.02809611f, 
    -0.04406906f, -0.09593348f, 0.03334023f, -0.28008580f, 0.04479056f, -0.11602650f, 0.07385024f, -0.06150111f, 
    0.12307730f, 0.07236852f, -0.06325354f, -0.07486235f, 0.17277148f, -0.11520113f, 0.05707903f, 0.11186121f, 
    0.03735056f, -0.06900758f, -0.01973394f, -0.01644867f, 0.18924113f, 0.14339472f, -0.06999537f, 0.08759261f, 
    0.33978805f, -0.09867828f, 0.16255781f, -0.10417552f, 0.10640255f, 0.02352041f, 0.05060481f, 0.07562528f, 
    0.06788775f, 0.06523449f, 0.06657426f, 0.03944807f, 0.23267247f, -0.03603846f, -0.01637790f, -0.07401574f, 
    -0.01951101f, -0.10110950f, 0.03363236f, -0.04918064f, 0.13104734f, -0.09626292f, 0.05865810f, -0.02711201f, 
    0.04155894f, 0.00989140f, 0.02463617f, 0.16430497f, 0.10506418f, 0.02979829f, -0.02474188f, 0.08147035f, 
    0.02971842f, 0.09380548f, 0.06969764f, 0.14827360f, -0.36031616f, -0.10989651f, 0.22648187f, -0.11315006f, 
    0.02483429f, -0.05471167f, -0.08038533f, 0.12666242f, -0.03038594f, 0.07572652f, 0.00177892f, 0.03537708f, 
    0.21905304f, 0.05317144f, -0.15513769f, 0.17528436f, 0.12610205f, -0.02177542f, 0.02640657f, 0.05250976f, 
    -0.01368971f, 0.00308304f, 0.08646233f, 0.04807998f, -0.06081987f, 0.24281292f, -0.15008645f, 0.00112770f, 
    0.13939559f, 0.01573150f, -0.04639636f, -0.02675225f, 0.06116679f, 0.04008611f, 0.06495000f, 0.05240260f, 
    -0.06699440f, -0.25898162f, -0.23636664f, 0.13822758f, 0.08415610f, 0.07647226f, 0.04995032f, -0.04906442f, 
    -0.00194958f, 0.00134570f, 0.03935803f, -0.06143552f, 0.12362581f, 0.32192653f, -0.16637503f, -0.15122314f, 
    0.02776630f, 0.02253663f, 0.04886969f, -0.05936258f, -0.05808843f, 0.11077316f, 0.06688263f, -0.08001097f, 
    0.09100442f, 0.08072861f, 0.14001518f, 0.36276868f, 0.05277997f, 0.08289065f, -0.02145161f, 0.02091398f, 
    -0.10490000f, -0.04314577f, -0.02898061f, -0.14609064f, -0.04206533f, 0.08694168f, -0.13685977f, -0.09908099f, 
    -0.09329233f, -0.00942260f, 0.08020949f, -0.04760346f, -0.02196785f, 0.05055717f, 0.00598155f, 0.05224914f, 
    -0.48380184f, 0.12641421f, 0.32753116f, 0.04612017f, 0.03689431f, -0.04229440f, 0.00231328f, 0.00028090f, 
    0.03473258f, 0.05320919f, -0.14698657f, -0.01973799f, -0.02560046f, -0.02387914f, -0.04357230f, -0.16560322f, 
    -0.00338553f, 0.05135198f, 0.03665530f, -0.03405420f, 0.07283984f, 0.07543521f, 0.00262241f, 0.07621980f, 
    -0.02858812f, 0.23373580f, 0.04463660f, 0.07274234f, 0.11632064f, 0.02916043f, 0.03873433f, -0.03213244f, 
    0.04723905f, 0.05044805f, 0.17798461f, 0.05613269f, -0.03975713f, -0.28187066f, -0.05780767f, 0.06724093f, 
    -0.04374635f, -0.07425459f, 0.05773316f, 0.02956443f, 0.02474245f, 0.16414438f, 0.04080381f, 0.05975140f, 
    0.14820690f, -0.24469355f, 0.02801873f, -0.08700492f, -0.17260355f, -0.14096102f, 0.04539260f, 0.01926965f, 
    -0.03174752f, -0.02234796f, -0.07566351f, 0.04366012f, 0.26518670f, -0.15275702f, 0.04451711f, 0.24799149f, 
    -0.03020264f, 0.09032632f, 0.09855546f, -0.13820882f, 0.00533521f, 0.05516418f, 0.06000131f, 0.01891882f, 
    0.10215460f, 0.17907272f, 0.21856339f, 0.14962693f, 0.13567577f, 0.01232955f, -0.03423926f, 0.05627353f, 
    0.07902057f, 0.05267343f, 0.00474951f, 0.02145369f, 0.13295317f, 0.26400888f, -0.13348731f, -0.23104900f, 
    -0.08701869f, 0.04638398f, 0.13085531f, -0.05394837f, 0.13829140f, -0.10672276f, -0.04399906f, 0.01310667f, 
    0.05902388f, 0.00398934f, 0.04324928f, -0.07946322f, 0.04128554f, -0.00104577f, 0.00784109f, 0.09490161f, 
    0.04702595f, -0.09413705f, 0.08265169f, 0.00486399f, -0.20891556f, -0.09668742f, 0.04574478f, -0.10975946f, 
    -0.02999502f, -0.06940399f, 0.04901129f, -0.01287298f, -0.08325391f, -0.06764279f, -0.06316067f, 0.06283692f, 
    -0.09725583f, 0.07713661f, -0.05261317f, 0.07605050f, 0.06813384f, 0.07617871f, -0.02608158f, 0.04399098f, 
    -0.04382135f, -0.01779105f, 0.05201395f, 0.04648464f, 0.36712858f, 0.09930778f, -0.33693695f, 0.14331245f, 
    0.01505089f, -0.13461569f, 0.03201120f, 0.20320417f, -0.05349689f, 0.04003274f, 0.08628096f, 0.08147650f, 
    -0.42863116f, 0.10993320f, 0.04764684f, 0.32179308f, -0.05096607f, -0.15196127f, 0.05889244f, -0.04835355f, 
    0.00238555f, 0.08208649f, 0.02184729f, -0.18042730f, -0.50805199f, -0.38760138f, -0.47514045f, -0.03776616f, 
    0.09121950f, 0.01721771f, 0.04799600f, -0.02601198f, -0.04270878f, 0.02102050f, -0.01876383f, -0.01870855f, 
    -0.03117440f, 0.01416505f, -0.10849265f, 0.27348593f, 0.04875916f, 0.01497092f, 0.03212915f, 0.05763327f, 
    0.04348464f, -0.07849998f, -0.04929920f, -0.19898264f, -0.32099593f, -0.39519346f, -0.29459858f, -0.30194959f, 
    0.11184063f, -0.10437905f, -0.00254771f, 0.16879356f, -0.00875235f, 0.14765093f, 0.04756250f, 0.04552785f, 
    -0.11349031f, -0.20535162f, -0.08379596f, -0.05457427f, 0.07711817f, -0.00316164f, -0.13567019f, 0.03590053f, 
    0.04482200f, 0.07560313f, -0.07180408f, 0.04597431f, -0.27043700f, -0.13923666f, -0.15965986f, 0.03548532f, 
    -0.05960382f, 0.00225528f, -0.00170113f, -0.01047887f, -0.00002358f, 0.17136480f, -0.02534601f, -0.00418249f, 
    0.17003466f, 0.18177263f, -0.11489832f, -0.25054243f, -0.05162735f, 0.01983985f, 0.04349353f, -0.13346004f, 
    0.00485716f, 0.07103357f, 0.19751489f, 0.05540469f, 0.01455226f, 0.29687151f, 0.25943252f, 0.06042891f, 
    0.03063274f, 0.04806163f, 0.17730126f, -0.07536667f, 0.10745292f, 0.09640346f, -0.06426058f, 0.23904595f, 
    0.19068784f, 0.17319955f, 0.24564280f, -0.20238458f, -0.01168767f, 0.06539842f, 0.01911593f, 0.07721032f, 
    0.11935323f, -0.09071577f, -0.17485483f, 0.03200608f, -0.07931504f, -0.48243189f, -0.10460401f, 0.17179938f, 
    0.02161177f, 0.07608444f, -0.14754736f, 0.07589148f, 0.19489400f, 0.26064810f, -0.07695410f, -0.07789382f, 
    0.17082305f, -0.23101898f, 0.00600017f, -0.17998336f, -0.02837146f, 0.17630385f, 0.10903025f, 0.06856602f, 
    0.06636530f, -0.05621491f, -0.01162528f, 0.07260524f, -0.08314151f, -0.23776013f, -0.33774155f, -0.39446014f, 
    -0.03740343f, -0.15109564f, -0.08409645f, -0.09655125f, 0.02807337f, -0.09556083f, 0.05105834f, -0.07780673f, 
    0.27770382f, 0.34012267f, 0.22843698f, 0.34986663f, -0.05822929f, 0.05160544f, 0.15079726f, 0.06247481f, 
    0.04511762f, -0.05368179f, 0.11192070f, 0.09819259f, -0.02739119f, 0.12206006f, 0.35475874f, -0.32527453f, 
    0.11542396f, 0.01686579f, -0.10189295f, 0.05655912f, -0.02830042f, 0.08613398f, -0.08148991f, -0.07619180f, 
    0.01172459f, 0.08507951f, -0.00093933f, -0.01631913f, -0.06012621f, 0.04833362f, -0.04222934f, 0.05719140f, 
    0.10633819f, -0.07889704f, -0.07066969f, 0.09556637f, 0.09670057f, 0.42965654f, 0.07326770f, -0.02826853f, 
    -0.00716781f, 0.00770909f, 0.06310438f, 0.08779620f, -0.10086892f, -0.08758233f, -0.00604032f, 0.22457229f, 
    0.07864824f, -0.10820910f, 0.09495638f, -0.05359722f, 0.12998047f, -0.02679012f, -0.10940725f, -0.03312750f, 
    -0.00328341f, -0.06092499f, -0.09754319f, -0.07262985f, 0.06128740f, 0.09557571f, 0.00535758f, -0.13125561f, 
    0.05850899f, -0.06311401f, 0.07419424f, -0.04431489f, 0.06221487f, 0.07049853f, 0.04254285f, 0.23399332f, 
    -0.07654722f, 0.15126619f, 0.02875335f, 0.10753304f, -0.03979912f, -0.08730756f, -0.01829765f, 0.11310700f, 
    -0.06402658f, 0.02794932f, 0.02112053f, 0.12495263f, 0.24095254f, -0.09572528f, -0.16875975f, -0.11912610f, 
    0.00883627f, 0.17370652f, 0.01779213f, 0.05287339f, 0.06145241f, 0.19436951f, 0.04253297f, 0.06370702f, 
    0.08661851f, 0.01290826f, 0.16182862f, -0.11543821f, 0.11007848f, 0.03615497f, -0.12462164f, -0.09877292f, 
    -0.13936979f, 0.02188456f, -0.17807575f, -0.05420165f, -0.11099919f, 0.02597510f, -0.05807699f, 0.08755129f, 
    0.01651371f, -0.07599259f, 0.11481959f, -0.06037749f, 0.01902349f, 0.23911776f, -0.03325908f, 0.06222975f, 
    -0.12046236f, 0.01839835f, -0.18346789f, -0.04977429f, 0.04699202f, -0.11202880f, 0.02403116f, -0.10400955f, 
    -0.01707926f, -0.02818763f, 0.12647809f, 0.24225952f, -0.14679277f, -0.10950288f, 0.06164014f, 0.12419619f, 
    0.05946106f, -0.00472256f, 0.07149197f, -0.07900444f, 0.14563061f, -0.01484442f, 0.04078440f, 0.18853323f, 
    0.11786307f, -0.18845440f, 0.10382968f, 0.15889855f, -0.12309395f, 0.06426912f, 0.08205447f, 0.00432026f, 
    0.10070268f, -0.09821790f, -0.01470893f, -0.10030143f, 0.02603276f, -0.05871649f, -0.02235318f, 0.03808214f, 
    0.05718284f, -0.03949366f, 0.11813430f, 0.08221644f, 0.11481318f, 0.18959281f, 0.01524118f, 0.03905221f, 
    -0.49907580f, -0.03807845f, -0.12927593f, 0.32689458f, 0.02808275f, -0.00913482f, 0.04478868f, -0.03927829f, 
    -0.00181357f, -0.03799409f, 0.05601817f, 0.11367433f, 0.12211665f, 0.01430656f, -0.09673577f, -0.04942316f, 
    0.02629106f, -0.11332475f, -0.06501032f, -0.16063900f, 0.08152130f, -0.19188584f, -0.01740022f, -0.24065650f, 
    0.09498343f, -0.05270074f, -0.04511559f, 0.07549910f, -0.04116054f, 0.07377037f, -0.08788313f, 0.11838669f, 
    -0.05510313f, -0.01560919f, 0.23896971f, 0.11292794f, 0.12751704f, -0.11679848f, -0.01285930f, 0.12094125f, 
    -0.02988184f, -0.09960085f, -0.14927126f, -0.07724109f, 0.02864558f, 0.17601864f, 0.16492033f, 0.06894460f, 
    0.01707386f, 0.16427375f, -0.18734956f, -0.05690998f, 0.06163419f, 0.00266527f, 0.03522056f, -0.00615306f, 
    0.12159908f, 0.04953258f, -0.10846958f, 0.25300997f, 0.10275996f, -0.10738784f, 0.06772581f, 0.11295242f, 
    0.12442753f, -0.09578003f, 0.04392470f, -0.04960550f, 0.02918829f, -0.03330971f, 0.10211208f, 0.03811051f, 
    0.01638272f, 0.24175450f, -0.02664893f, -0.15527956f, 0.07264744f, 0.08411396f, -0.13733597f, -0.02063386f, 
    -0.02107539f, 0.04766223f, -0.24870713f, -0.07817161f, -0.01687641f, -0.00238515f, 0.06386035f, 0.19830820f, 
    0.03542018f, -0.06529130f, -0.16830654f, -0.13253547f, -0.08814797f, 0.01077328f, -0.07062738f, -0.02421496f, 
    -0.37827370f, -0.27242148f, -0.32230026f, 0.02457307f, 0.07044095f, 0.01556547f, -0.00277843f, -0.20703571f, 
    0.07531963f, -0.05914624f, -0.06141035f, -0.10162596f, -0.13656469f, 0.16669996f, 0.22587693f, -0.01356519f, 
    -0.21280366f, 0.01977498f, -0.06616079f, 0.07102235f, -0.07839422f, -0.01634572f, -0.14424604f, -0.10305471f, 
    0.07506729f, 0.05035765f, -0.04561517f, 0.22583669f, -0.12313280f, -0.08771212f, -0.04757879f, -0.24319176f, 
    -0.04232458f, -0.01412093f, -0.17502277f, 0.04753226f, 0.03784594f, 0.20303257f, 0.19096465f, 0.07955027f, 
    -0.13169479f, 0.02008195f, 0.20389034f, 0.15411365f, -0.13086459f, 0.05174346f, 0.01735186f, -0.02529245f, 
    0.15996490f, -0.18410225f, -0.20678091f, 0.07706712f, -0.00001414f, 0.09317482f, 0.07133754f, -0.01370021f, 
    0.03222287f, -0.03904489f, 0.08995052f, 0.09834819f, 0.14458209f, 0.14555202f, 0.25722080f, 0.12799430f, 
    0.17508633f, 0.02965775f, -0.00202496f, -0.12049565f, 0.06097501f, 0.02926410f, -0.14116378f, 0.12857719f, 
    -0.09935243f, -0.24570438f, -0.06063463f, -0.02423928f, -0.03992625f, -0.04755940f, -0.03662669f, -0.02078004f, 
    0.12420603f, 0.06463232f, 0.00035302f, 0.17553087f, -0.01391675f, 0.08858399f, 0.01618940f, -0.07706914f, 
    0.01966766f, -0.26267922f, -0.10327933f, 0.24338520f, 0.10674318f, 0.00019304f, -0.23515026f, -0.00683581f, 
    0.36157507f, 0.10027817f, 0.02920383f, -0.24077298f, 0.05371065f, 0.10843391f, -0.00539669f, 0.16793273f, 
    0.09826114f, 0.05798655f, -0.07452219f, -0.11893816f, 0.14118238f, 0.15366624f, 0.22007646f, 0.22588539f, 
    -0.16014500f, -0.11832021f, 0.08806034f, 0.09919528f, -0.07660154f, -0.24223995f, -0.00967211f, -0.18259843f, 
    0.06067772f, 0.03704891f, 0.05138766f, 0.04377462f, 0.15679851f, 0.25771204f, 0.09120231f, 0.06984599f, 
    0.01991886f, -0.08006522f, 0.12024943f, 0.09031148f, 0.18505666f, 0.11242621f, 0.04721308f, 0.03177503f, 
    0.06140643f, -0.03317809f, 0.05389871f, 0.04635622f, -0.12699443f, 0.17885774f, 0.17208213f, 0.02579307f, 
    0.10226914f, -0.08038067f, 0.02956709f, -0.09575455f, 0.04090456f, -0.04361335f, -0.09628083f, 0.12819050f, 
    0.10780355f, -0.02633386f, 0.03078274f, 0.13769230f, -0.39098176f, -0.23233844f, -0.15029451f, 0.07165457f, 
    -0.00804827f, 0.22680449f, 0.11691330f, -0.01473481f, 0.02106005f, -0.06358437f, 0.16463436f, -0.00914663f, 
    -0.24682863f, -0.26601326f, 0.07011230f, -0.08949194f, -0.02624884f, 0.16464376f, -0.01110910f, -0.07237799f, 
    0.09873189f, -0.03862422f, 0.01693652f, 0.14030287f, 0.35493308f, 0.33178818f, 0.08352837f, -0.01746033f, 
    -0.02376333f, -0.07583419f, 0.14206375f, 0.02146821f, 0.00071659f, 0.04531368f, 0.10261854f, -0.13010848f, 
    -0.01543797f, 0.03158190f, 0.23877764f, 0.10793369f, 0.04425703f, -0.06877400f, 0.00655283f, 0.01236892f, 
    0.00159536f, -0.00876392f, -0.01664990f, 0.06371291f, 0.03367949f, -0.07302858f, 0.07628992f, -0.16314086f, 
    0.05078625f, 0.09657838f, 0.09871048f, -0.07047272f, 0.13416210f, 0.08335525f, 0.04003731f, -0.08184597f, 
    0.16475776f, 0.17035016f, 0.27985945f, -0.13929200f, -0.03662682f, 0.01467266f, -0.07236508f, 0.08605003f, 
    -0.05891411f, -0.01125758f, -0.12139446f, -0.12825930f, 0.14142123f, -0.13486277f, 0.02980001f, -0.00145160f, 
    -0.07097078f, 0.07125086f, -0.02186376f, -0.01878890f, 0.06287642f, 0.04188126f, -0.01318614f, 0.20124075f, 
    -0.17770427f, -0.02054972f, -0.10994715f, 0.10226874f, 0.03214059f, -0.09641445f, 0.06286266f, -0.12523030f, 
    0.01217636f, -0.03240792f, 0.00155258f, -0.04824638f, -0.08868242f, -0.11799368f, -0.09364934f, 0.01520651f, 
    -0.13375086f, -0.00160781f, 0.00043422f, 0.12057356f, -0.01745473f, -0.08796101f, 0.13486357f, -0.06171960f, 
    0.29086232f, 0.09864446f, -0.14196452f, 0.20554624f, -0.10514170f, -0.03533586f, 0.04051656f, 0.01851959f, 
    -0.05778220f, -0.02531262f, 0.07993685f, 0.01611868f, 0.00691678f, 0.03254627f, 0.00561942f, -0.03725442f, 
    -0.03009430f, -0.00106805f, 0.11023983f, -0.07034677f, -0.02855912f, -0.10808860f, 0.01583085f, -0.09098432f, 
    -0.06306671f, -0.04065016f, 0.00891342f, 0.31010008f, 0.00309790f, 0.08057742f, -0.03783851f, -0.07870187f, 
    0.02983452f, 0.08491699f, -0.05580876f, 0.08152325f, 0.10473058f, 0.13404047f, -0.06147668f, -0.11989461f, 
    0.05018875f, 0.07775842f, 0.09403519f, -0.05037701f, 0.06319438f, 0.12600487f, -0.03799434f, 0.05451954f, 
    -0.17765474f, 0.08601825f, -0.06025658f, -0.16828892f, -0.00828519f, -0.09041613f, 0.07935240f, -0.04727964f, 
    0.05605295f, 0.05363875f, -0.05080321f, -0.04144427f, 0.12456150f, -0.04748102f, -0.20496866f, 0.23948748f, 
    -0.02006006f, 0.01246744f, 0.07733479f, 0.04552402f, 0.11919136f, -0.03133380f, -0.00044019f, 0.07484057f, 
    -0.26720995f, 0.10807152f, -0.04476380f, 0.23994449f, 0.07877733f, 0.14220388f, 0.05923687f, -0.05619049f, 
    0.04895813f, 0.07295895f, 0.00874674f, -0.00305989f, 0.16132264f, -0.22896376f, 0.03255826f, 0.03824870f, 
    0.06951021f, -0.24316204f, -0.02500156f, 0.12109046f, 0.07684391f, 0.16853501f, 0.02392400f, 0.00148347f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07494520f, -0.00792309f, 0.07570016f, -0.00497279f, -0.13044365f, 0.08518110f, -0.00932360f, -0.04979927f, 
    -0.05645893f, -0.05682110f, -0.00980867f, 0.10894267f, -0.04728433f, 0.10832236f, 0.08354948f, 0.04222709f, 
    -0.02459355f, 0.04628861f, -0.03647151f, -0.08382767f, 0.02611663f, 0.02617146f, 0.00007273f, 0.01767908f, 
    0.03728596f, 0.02371895f, -0.02755141f, 0.04354391f, -0.01896170f, 0.02878308f, 0.06353693f, 0.09226289f, 
    0.06306497f, 0.02224032f, -0.00423877f, 0.03397830f, -0.06099982f, 0.08338558f, -0.02586554f, 0.01470037f, 
    0.12797965f, 0.02337489f, 0.02463382f, 0.06216332f, -0.00323767f, 0.05462437f, -0.00941330f, -0.04232809f, 
    -0.06736055f, -0.05913191f, -0.02931171f, -0.00654933f, 0.03788273f, 0.01515028f, 0.07636443f, 0.02816767f, 
    0.03612371f, -0.00017249f, 0.00239726f, -0.04305870f, -0.02618651f, 0.00171215f, -0.11397230f, 0.00297916f, 
    0.09309471f, -0.06957126f, 0.10196993f, 0.00205223f, -0.02764228f, 0.03534998f, 0.06131849f, -0.05152360f, 
    0.06366722f, 0.06373437f, -0.04334291f, 0.12241279f, -0.05577486f, 0.04452815f, -0.00048398f, -0.01653959f, 
    0.19542059f, 0.02799344f, 0.02335001f, -0.06377180f, -0.02239929f, 0.10263710f, 0.02403790f, 0.06086073f, 
    0.02981753f, -0.01206040f, -0.05852804f, 0.17606150f, 0.00300659f, 0.03393605f, 0.14926732f, 0.09303739f, 
    -0.04297351f, -0.00606231f, 0.00490792f, -0.04644679f, -0.07425214f, 0.03031904f, 0.05028858f, -0.06312169f, 
    0.08370345f, 0.05387512f, 0.05385849f, -0.00849378f, 0.11621434f, 0.03754577f, -0.00138309f, 0.02992572f, 
    0.04860362f, 0.00524256f, 0.02898111f, 0.05707642f, 0.02669494f, 0.09344102f, 0.09407409f, -0.05666103f, 
    0.12890761f, 0.10287635f, 0.04913167f, 0.05299003f, 0.06956223f, 0.00706793f, -0.08891398f, 0.08320761f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13575199f, -0.06636676f, -0.12595682f, -0.07099230f, 0.00028945f, 0.04101036f, -0.09573112f, 0.04760948f, 
    0.04960686f, 0.18362018f, 0.04693267f, -0.15834497f, -0.00851892f, -0.06868646f, 0.31114474f, -0.09582355f, 
    0.16116801f, -0.30051458f, 0.08228889f, 0.11755013f, -0.02917382f, -0.31006125f, 0.01633220f, -0.73312193f, 
    0.22275715f, -0.10220281f, -0.01249623f, -0.06480465f, -0.17395686f, -0.00455478f, 0.22217621f, -0.30877608f, 
    0.15404142f, -0.07500620f, 0.17056420f, 0.13894907f, -0.00934495f, -0.30468765f, -0.09088690f, 0.02992270f, 
    -0.41216287f, 0.13328104f, 0.05503883f, -0.17765273f, -0.11149294f, -0.06909207f, -0.05043435f, 0.17066051f, 
    0.03632424f, 0.08511946f, -0.12888293f, -0.18964575f, 0.09601783f, -0.13354982f, 0.19913253f, -0.19949809f, 
    -0.18533877f, 0.02555084f, 0.28088012f, 0.07825015f, -0.13800126f, -0.13746956f, -0.33713838f, 0.23123424f, 
    0.10550775f, 0.04252412f, -0.24037750f, -0.00461817f, -0.04442150f, -0.29383239f, -0.09745498f, -0.04315667f, 
    -0.53602570f, -0.29520407f, -0.05281132f, -0.25125051f, 0.10151522f, 0.01088209f, -0.04755761f, -0.03026799f, 
    -0.13156667f, -0.08350664f, 0.13724308f, -0.06921086f, 0.07166155f, 0.06729332f, 0.00785835f, -0.27874777f, 
    0.03567162f, 0.07435847f, 0.04227304f, 0.10226065f, 0.01403515f, 0.13656561f, -0.30580971f, 0.07082306f, 
    0.16542947f, 0.05326254f, 0.08058424f, -0.06394432f, 0.35950169f, 0.08057681f, 0.10572083f, -0.02619556f, 
    -0.06035371f, 0.06027560f, 0.09560773f, 0.37087002f, -0.17297021f, -0.33102420f, 0.00249181f, 0.01305797f, 
    -0.50164330f, -0.17294407f, 0.23941833f, -0.28713387f, -0.03896696f, -0.04156879f, -0.54232734f, -0.05159626f, 
    -0.03365724f, 0.21020143f, -0.20752233f, 0.15746488f, -0.48296654f, 0.03823287f, -0.19276689f, 0.28378668f, 
    0.02651156f, 0.00081797f, 0.01117269f, 0.04498043f, -0.02366047f, 0.04450498f, -0.02929679f, 0.08251565f, 
    -0.02214273f, -0.33284110f, -0.03436217f, 0.26248682f, 0.03192316f, 0.23133482f, -0.19330347f, -0.06161519f, 
    -0.63067251f, -0.30702296f, 0.01692146f, 0.23013444f, -0.14191179f, -0.25223976f, -0.04689572f, -0.09849578f, 
    0.19228622f, 0.14201222f, 0.03098708f, 0.02426212f, 0.18374421f, 0.15539336f, -0.09200344f, -0.11108258f, 
    0.05960382f, -0.02790922f, -0.21275312f, -0.19678156f, 0.19604288f, 0.03696984f, 0.03596252f, 0.06043779f, 
    0.06727441f, 0.20933563f, -0.06968859f, -0.05667680f, -0.41434065f, -0.10861716f, -0.02470890f, -0.16447303f, 
    0.11631715f, 0.04089542f, -0.41076076f, -0.15263963f, -0.03403145f, 0.05670787f, 0.19559023f, 0.12082589f, 
    -0.25506464f, -0.10081149f, -0.19284219f, -0.03006175f, 0.06561627f, 0.12826423f, 0.04554414f, -0.10041266f, 
    0.03347934f, -0.05071395f, -0.28043801f, -0.23790991f, -0.06881680f, -0.00403842f, 0.05589832f, 0.04861981f, 
    0.19383645f, -0.15346649f, 0.11190297f, -0.06966934f, -0.13341901f, 0.06400732f, -0.13969819f, -0.33692834f, 
    -0.07625920f, -0.04986933f, 0.15349057f, -0.02220257f, -0.05946708f, 0.26310953f, -0.08998444f, 0.12298952f, 
    0.14442098f, 0.08904130f, -0.04940603f, -0.07564278f, -0.07279753f, 0.02830861f, -0.13512753f, 0.12559529f, 
    -0.00424564f, -0.11117113f, -0.02793808f, -0.05275854f, -0.35869971f, -0.05959623f, 0.18960100f, -0.06403698f, 
    -0.22564021f, 0.25625536f, 0.14584810f, -0.36959717f, 0.05981550f, 0.06680964f, -0.12343672f, 0.07994059f, 
    0.06185780f, 0.21387884f, 0.14521374f, 0.16932912f, -0.04964715f, 0.11189369f, -0.04175976f, 0.00930921f, 
    0.26943567f, 0.03408691f, -0.19748527f, -0.17672379f, 0.37091953f, 0.20907383f, -0.15746064f, 0.06910859f, 
    0.03589126f, 0.02618749f, 0.07760248f, -0.00280392f, 0.18398218f, 0.22134078f, 0.02316147f, -0.03980612f, 
    0.06193011f, -0.21034664f, -0.25934213f, -0.21394175f, -0.00780851f, -0.41436768f, -0.12954615f, 0.06204193f, 
    -0.31716993f, 0.38706210f, -0.01966474f, 0.02907614f, -0.34766597f, 0.02027170f, 0.01738507f, 0.04215330f, 
    -0.34415698f, 0.13177605f, -0.01531814f, -0.00721697f, -0.03886754f, 0.17094973f, 0.01820227f, -0.00078525f, 
    -0.22405791f, -0.06976233f, -0.33485270f, -0.31282315f, 0.07265825f, -0.00462188f, 0.03002451f, -0.10861313f, 
    -0.16456403f, 0.05217102f, -0.07332753f, -0.57998121f, 0.02716171f, -0.20378968f, -0.08159950f, -0.18213566f, 
    0.15916234f, 0.03873883f, 0.00842430f, 0.26946327f, 0.06988059f, -0.18731026f, -0.14154018f, -0.30627093f, 
    -0.01928557f, -0.09987116f, -0.32938075f, -0.03916574f, -0.13180153f, -0.10304946f, 0.10557773f, 0.04275888f, 
    -0.01803526f, -0.00806697f, 0.27012414f, -0.05262191f, 0.02587273f, 0.04247043f, 0.02843518f, -0.05126548f, 
    -0.35650387f, -0.04249621f, -0.45655739f, -0.44254985f, 0.04728078f, 0.03610985f, 0.17000900f, -0.08181737f, 
    -0.13785306f, -0.00310067f, 0.21528399f, 0.03766825f, -0.04707003f, -0.18712108f, 0.04765145f, -0.15001135f, 
    0.17262025f, -0.02487259f, 0.01672348f, -0.14235581f, -0.07700998f, 0.20234713f, -0.08411288f, 0.22976515f, 
    0.06992757f, -0.31427443f, 0.07801607f, 0.00141052f, 0.22658226f, -0.08864155f, -0.10951839f, -0.06933016f, 
    0.11667135f, -0.22548339f, 0.15433824f, 0.30142576f, 0.10861759f, -0.18725929f, 0.09572390f, 0.00413080f, 
    -0.41809621f, 0.22170946f, 0.18703084f, -0.14245935f, 0.01973766f, 0.18754745f, 0.09912530f, -0.05754380f, 
    0.04220798f, 0.22338301f, -0.02084708f, -0.38325262f, -0.17528071f, -0.37714297f, 0.22648975f, -0.36932093f, 
    0.11881823f, -0.00510195f, -0.23216514f, -0.00494733f, -0.17100504f, -0.04726635f, -0.04399044f, 0.00811274f, 
    -0.07195185f, -0.02068815f, 0.26990759f, -0.05204023f, -0.03624128f, -0.08015729f, -0.22827472f, -0.03998937f, 
    0.01169350f, -0.23983616f, 0.02500293f, -0.41467121f, 0.07707643f, 0.11098611f, 0.02250057f, -0.02940933f, 
    -0.16723278f, -0.42359602f, 0.07146422f, -0.08591682f, -0.52465457f, -0.04060950f, 0.12789789f, -0.30986300f, 
    0.28559434f, -0.07536972f, 0.11303218f, -0.21171153f, -0.34091195f, 0.14232367f, -0.06715584f, -0.02817852f, 
    0.21878475f, -0.53990793f, -0.07755554f, -0.00764362f, -0.42917949f, 0.26224551f, 0.06975606f, 0.14357747f, 
    -0.37130317f, -0.07243973f, 0.11718997f, 0.19192308f, -0.08388718f, 0.04912942f, 0.13968696f, 0.30210483f, 
    -0.22060698f, 0.01183002f, -0.06374770f, 0.01082165f, -0.16930047f, -0.08817828f, -0.28531566f, -0.51396924f, 
    0.12380429f, 0.00941427f, -0.07494077f, 0.12163648f, 0.06512875f, -0.47810775f, 0.11685394f, 0.02440673f, 
    -0.03212270f, 0.00568231f, -0.02344860f, -0.21975286f, -0.01381910f, 0.02190534f, 0.25561842f, 0.42522880f, 
    0.24249949f, -0.07942902f, 0.05244141f, 0.01701925f, 0.05294652f, -0.15138258f, 0.07663706f, 0.24430901f, 
    -0.17734486f, -0.08148470f, 0.05245851f, 0.20495047f, -0.06999724f, 0.30674517f, -0.16630214f, -0.33482274f, 
    -0.73097855f, -0.30914736f, 0.01402913f, 0.03683033f, -0.23688516f, 0.20251733f, -0.31217280f, -0.05077289f, 
    -0.16386901f, -0.35734427f, -0.09656110f, 0.11778202f, 0.02244818f, -0.18797344f, 0.08641876f, -0.02302703f, 
    0.08892702f, 0.12583528f, 0.21898378f, -0.50121510f, -0.00906040f, 0.23091775f, 0.01448756f, 0.02149034f, 
    0.12789652f, -0.19160026f, -0.12501766f, 0.15799074f, -0.17379287f, 0.04089239f, 0.00557896f, 0.03079546f, 
    -0.08210678f, -0.02031678f, 0.17614722f, -0.05333473f, 0.18594705f, -0.37668014f, -0.01118793f, -0.08181711f, 
    0.06842561f, -0.58239126f, -0.17514858f, -0.27020672f, -0.04600825f, 0.20212641f, 0.06552829f, -0.07165356f, 
    0.13208418f, -0.22572324f, -0.02861159f, 0.04739505f, 0.15902458f, 0.11486080f, -0.04751179f, -0.15008074f, 
    -0.03258603f, -0.11498705f, -0.14962505f, -0.01843929f, 0.09774375f, -0.09907439f, -0.09763584f, 0.04304880f, 
    0.31237781f, 0.06809923f, 0.07817367f, 0.21722183f, -0.05732539f, 0.19987765f, -0.07419918f, -0.24234250f, 
    0.31425235f, 0.15857901f, 0.00398656f, 0.01472894f, -0.24810264f, 0.19147140f, 0.01020431f, 0.15744205f, 
    -0.55879521f, -0.04324613f, -0.04991166f, -0.20831518f, -0.26000977f, 0.22405553f, -0.07529347f, -0.11658718f, 
    -0.15581091f, 0.01497888f, -0.12852000f, 0.07814661f, -0.18056169f, 0.35031942f, -0.17515217f, 0.08084472f, 
    0.07018235f, 0.03272454f, -0.16390811f, 0.17575954f, -0.05532101f, 0.14162084f, -0.03725964f, 0.03291775f, 
    0.20796426f, -0.04975672f, 0.20604269f, 0.19863234f, 0.18351367f, 0.04058427f, 0.00626665f, -0.02423895f, 
    0.02976654f, -0.02187564f, -0.23817934f, -0.04881386f, 0.02380883f, -0.08195827f, -0.06670762f, 0.05675233f, 
    -0.22655715f, -0.04835820f, -0.03233813f, 0.20794460f, -0.06278764f, 0.06859024f, 0.01642941f, -0.23280613f, 
    -0.06409066f, 0.00708590f, -0.05393659f, -0.06946273f, -0.12397850f, 0.21453810f, 0.19995672f, -0.04113152f, 
    -0.04586358f, 0.09416463f, 0.16935967f, -0.17935231f, -0.38177353f, 0.26838598f, 0.13474216f, 0.01201274f, 
    0.11851797f, -0.12703048f, 0.07138350f, -0.09699592f, 0.04835769f, 0.11493880f, -0.12373257f, -0.01406772f, 
    0.17444006f, 0.01853810f, -0.35904491f, -0.19558337f, -0.60491341f, -0.13096681f, 0.09297768f, -0.00605807f, 
    -0.25707284f, -0.08049793f, 0.16688401f, -0.07698189f, 0.13449810f, 0.00515057f, 0.00137616f, -0.02278440f, 
    0.04534683f, 0.81575525f, 0.03374051f, -0.24143031f, -0.01047381f, -0.01930851f, 0.07581206f, 0.04099169f, 
    -0.09607898f, -0.06714947f, 0.00019664f, -0.20293701f, 0.18045123f, 0.01387767f, 0.00934823f, -0.08021230f, 
    0.12015828f, 0.02196861f, 0.19457561f, -0.01042990f, 0.13336231f, -0.49759918f, -0.29247156f, 0.00145594f, 
    0.15248205f, 0.06594609f, 0.09445109f, 0.03451944f, -0.15772650f, -0.11317153f, 0.08395810f, 0.22351576f, 
    -0.17960663f, -0.01183568f, 0.03554406f, 0.09849229f, 0.18245190f, -0.41241074f, 0.02698153f, -0.24356520f, 
    0.09785877f, -0.05351474f, -0.07882304f, -0.08413126f, -0.15442239f, -0.00101221f, 0.03625028f, 0.23830044f, 
    -0.14247753f, 0.03888478f, 0.04802583f, 0.01738302f, 0.07051774f, -0.32677311f, 0.13626604f, -0.10115727f, 
    -0.11307504f, -0.04950221f, 0.18247387f, 0.15303101f, -0.06832752f, -0.01057603f, -0.05174747f, 0.02975192f, 
    -0.36568829f, 0.19551857f, -0.16238174f, 0.07512393f, 0.04174947f, -0.00589056f, 0.11198986f, 0.07578877f, 
    0.16120115f, 0.01386901f, 0.05726822f, 0.04849154f, -0.00924474f, 0.12019582f, 0.05352839f, 0.06266738f, 
    -0.15462293f, -0.03258415f, -0.07364215f, -0.22119646f, 0.06454937f, 0.03855399f, 0.14146598f, -0.07254582f, 
    0.06740963f, 0.17821246f, -0.00087468f, -0.05374220f, -0.07501875f, -0.00051681f, 0.15652315f, -0.01784307f, 
    0.00064103f, 0.27603614f, 0.01706826f, -0.19565251f, -0.07119743f, 0.11733054f, -0.37271762f, 0.03819257f, 
    0.11828531f, -0.48433399f, -0.11231337f, 0.08080101f, -0.07957078f, -0.34737095f, -0.24630716f, 0.04885112f, 
    -0.04960682f, -0.11700868f, 0.07317393f, 0.14875084f, 0.33472455f, 0.17195709f, 0.32357737f, -0.30781272f, 
    0.04338674f, 0.03733109f, 0.03871360f, 0.08076674f, -0.28689617f, -0.16117580f, 0.07098219f, 0.00857898f, 
    -0.02116381f, -0.67031777f, 0.20823535f, 0.19727843f, -0.07081203f, 0.12074292f, -0.34224814f, 0.06796536f, 
    0.16387971f, 0.13561125f, -0.00905449f, 0.18912518f, -0.02370382f, 0.18008353f, 0.00863896f, -0.05830189f, 
    -0.35849896f, -0.02310531f, 0.29505873f, -0.05736152f, 0.03635901f, 0.23418115f, -0.06591845f, 0.22345516f, 
    -0.53916824f, 0.00460579f, -0.06433789f, -0.40426624f, -0.10307208f, -0.07161171f, 0.02990719f, -0.10293180f, 
    -0.08661814f, -0.02341262f, 0.05735597f, 0.00344766f, -0.00362899f, 0.07218696f, -0.07713377f, 0.03348774f, 
    -0.20872051f, 0.05164476f, 0.30118257f, -0.12667958f, 0.22575119f, -0.46915475f, 0.04105388f, -0.19926606f, 
    0.22655658f, -0.07021797f, -0.24716915f, 0.03341763f, -0.17884018f, -0.38667846f, -0.32785755f, 0.01166384f, 
    0.18526877f, -0.04141220f, 0.28209478f, 0.00392435f, -0.04629874f, 0.08535007f, -0.09262393f, -0.01958528f, 
    -0.33466151f, -0.13122767f, -0.23872250f, -0.11490103f, 0.19494055f, -0.02483207f, 0.26811403f, -0.00240793f, 
    0.11166957f, -0.05527526f, -0.14891528f, 0.04200675f, 0.05323035f, -0.09690572f, 0.05447370f, -0.36214155f, 
    0.15101783f, 0.04769085f, -0.02844441f, 0.01461801f, -0.02939613f, -0.34534085f, 0.11283769f, 0.06256776f, 
    0.06047384f, 0.06816600f, 0.05255506f, -0.09046578f, -0.20487694f, 0.06590378f, -0.10146281f, -0.08479176f, 
    0.01768170f, -0.43699527f, -0.21226135f, -0.03018254f, -0.25022078f, -0.27984524f, 0.02528266f, -0.08806673f, 
    0.08114655f, 0.08341322f, -0.33263811f, 0.09332543f, -0.05737298f, -0.52101654f, -0.23770455f, -0.03399165f, 
    -0.05724476f, -0.02788347f, 0.26602635f, 0.14234892f, 0.29389545f, -0.26629537f, -0.35449392f, -0.06922311f, 
    -0.24718639f, -0.08658027f, 0.05445005f, 0.01919750f, 0.28057876f, -0.15079686f, -0.03930379f, -0.06909283f, 
    -0.08131809f, -0.08722614f, 0.05499978f, -0.11946251f, 0.07804861f, -0.31228331f, -0.24402840f, 0.08477007f, 
    0.34079552f, 0.22444659f, 0.03197167f, -0.00939325f, -0.37152186f, 0.17555921f, -0.05298022f, 0.19818269f, 
    0.05904812f, 0.12272646f, 0.16173141f, 0.09253890f, -0.18664111f, 0.17140615f, -0.35287425f, -0.05244606f, 
    -0.10732423f, -0.01871214f, 0.02162345f, -0.15023938f, 0.11389274f, -0.17339775f, 0.06699359f, -0.12790018f, 
    -0.06989084f, -0.30387688f, 0.05141181f, 0.23323885f, 0.34944138f, 0.16398191f, 0.03344912f, 0.10499597f, 
    -0.10112040f, 0.08189585f, 0.18658473f, -0.07273619f, -0.07161424f, -0.30432236f, -0.16365570f, -0.08847114f, 
    0.18182750f, -0.06905939f, 0.17689724f, -0.07659828f, -0.09140842f, 0.04794692f, 0.27376091f, -0.04935250f, 
    -0.26678076f, -0.04146133f, 0.09510065f, -0.14672305f, -0.00739754f, 0.01244447f, -0.27453697f, 0.06535917f, 
    0.12830172f, -0.13805613f, 0.15030168f, -0.02373543f, -0.04689574f, -0.00800268f, -0.34296888f, -0.20129851f, 
    -0.02755411f, 0.04632670f, -0.15420613f, 0.05197889f, -0.04857732f, -0.12872095f, 0.02597377f, -0.11326021f, 
    -0.25372821f, -0.06919950f, -0.01093766f, -0.02020544f, 0.08384974f, -0.39365432f, -0.24129243f, -0.11194538f, 
    -0.25032854f, -0.22082001f, 0.08217183f, -0.05914595f, 0.27083215f, 0.02520156f, -0.19951443f, -0.07215114f, 
    -0.20421214f, -0.10882955f, 0.02806070f, 0.22358119f, 0.08291540f, -0.04289291f, 0.17380652f, 0.07820418f, 
    0.12326116f, -0.03928955f, 0.07799789f, -0.10072748f, 0.02302373f, 0.06337342f, 0.10079169f, -0.02397883f, 
    -0.15345179f, -0.32027683f, -0.00679910f, 0.10140458f, -0.19142550f, -0.23498675f, 0.22679578f, 0.10188365f, 
    0.20320292f, -0.06729316f, -0.06603498f, -0.10146476f, 0.22387406f, -0.06457469f, 0.07167067f, 0.02135743f, 
    -0.06289697f, -0.27713928f, -0.04970660f, 0.12601273f, -0.05493343f, -0.52665997f, -0.40360683f, -0.02592025f, 
    0.09674373f, -0.17814051f, -0.07409871f, 0.06177973f, 0.13272664f, -0.31925490f, 0.01836622f, -0.03762282f, 
    -0.03586235f, 0.17834322f, -0.18787394f, 0.00875017f, -0.14489388f, -0.25393569f, 0.16786686f, 0.23919846f, 
    -0.22906719f, -0.04382020f, -0.18808249f, -0.10406713f, 0.19339658f, 0.14013790f, 0.00387534f, 0.16505367f, 
    -0.14761329f, -0.06053395f, 0.03283088f, -0.03796374f, 0.37585542f, 0.04646338f, 0.06410894f, -0.22224046f, 
    0.18202300f, -0.07605815f, 0.03951855f, 0.05273190f, -0.40828496f, -0.16410348f, -0.02335174f, -0.10822626f, 
    0.16614115f, -0.08513865f, 0.25249857f, -0.03322737f, 0.25684878f, -0.06691994f, 0.03392636f, -0.12720166f, 
    -0.43472070f, -0.06241849f, -0.43801481f, 0.16622055f, -0.06639969f, 0.22524691f, 0.25583810f, -0.04322915f, 
    0.19771990f, 0.30074593f, -0.35558325f, -0.22278914f, 0.05903613f, -0.07907753f, -0.32910705f, 0.08841808f, 
    -0.38506332f, -0.03083329f, 0.01808805f, 0.08308890f, 0.03774236f, 0.17863970f, 0.05752692f, 0.10487776f, 
    0.02142133f, -0.03348522f, 0.07088840f, -0.33267227f, -0.07956818f, -0.14041559f, 0.30086830f, 0.04386487f, 
    -0.00060661f, 0.07029418f, -0.06775036f, 0.02897283f, -0.10626896f, -0.44470972f, 0.00088218f, -0.07005283f, 
    -0.27050048f, 0.09224013f, 0.00076553f, -0.42691243f, -0.07486155f, -0.17503305f, 0.04135442f, -0.04736269f, 
    -0.19746211f, -0.02256447f, 0.04681104f, -0.24053875f, -0.07624626f, -0.28026241f, -0.23725104f, -0.08830725f, 
    0.02010592f, -0.15493943f, 0.19823577f, -0.26652408f, -0.29200846f, 0.18423742f, 0.28469789f, -0.15947659f, 
    -0.01534432f, 0.01102154f, -0.00553824f, -0.01541192f, 0.00406399f, -0.16151167f, -0.05895931f, -0.00499430f, 
    -0.07364598f, 0.12536331f, -0.43856257f, -0.21456861f, 0.06573944f, 0.07030372f, 0.23933330f, 0.05733164f, 
    0.15206763f, 0.16193256f, -0.03596633f, 0.01810291f, 0.11352161f, -0.10103774f, -0.00539877f, 0.27292675f, 
    0.03372185f, -0.01315315f, -0.16324832f, 0.07121699f, 0.06844480f, 0.19541270f, 0.11608092f, 0.14752071f, 
    0.08521308f, -0.05590718f, -0.22162680f, 0.24344544f, -0.39231786f, 0.12426496f, -0.02824818f, -0.45793378f, 
    -0.00598430f, -0.25600120f, -0.09723888f, 0.14566919f, 0.20488493f, -0.15449443f, -0.03149719f, -0.04565750f, 
    0.33054850f, 0.05274349f, -0.10287859f, 0.14313233f, 0.14105418f, -0.06475904f, -0.43595865f, 0.09579597f, 
    0.19789089f, 0.02325533f, -0.05761391f, -0.08697163f, -0.15628362f, -0.15990478f, 0.14591773f, 0.24823841f, 
    0.10902455f, 0.00298317f, -0.03033200f, 0.10730013f, 0.06973366f, -0.09695867f, 0.02899441f, 0.03186365f, 
    0.25922400f, 0.04857164f, 0.15607448f, 0.02795464f, 0.06523779f, -0.05356567f, -0.12765509f, -0.02817348f, 
    0.13620885f, -0.02903456f, -0.30628136f, -0.07015318f, 0.07407230f, -0.41936335f, 0.05437271f, -0.29053003f, 
    0.14588813f, 0.00623108f, 0.05752765f, -0.38480017f, 0.04312579f, 0.02247569f, -0.13670067f, 0.18816109f, 
    0.07804231f, -0.05149364f, -0.00380957f, 0.00627979f, -0.01012069f, -0.02550614f, -0.19134957f, 0.04193496f, 
    0.28029245f, 0.02305830f, 0.06866607f, 0.15505533f, -0.01882531f, -0.17671952f, -0.04747628f, 0.02894732f, 
    -0.01428130f, -0.19600929f, -0.33118406f, 0.33848861f, 0.06028866f, 0.16162273f, 0.12179097f, 0.06575587f, 
    -0.59269059f, -0.17126817f, -0.12724097f, -0.37107897f, -0.29153103f, -0.13483560f, -0.33244142f, -0.17224146f, 
    -0.15254061f, -0.04378678f, 0.19614857f, 0.06108876f, -0.36870751f, 0.26541370f, -0.01452762f, -0.03246755f, 
    0.01491261f, -0.19708005f, -0.14955790f, 0.09718347f, 0.02549893f, -0.26551381f, 0.24118015f, -0.07286741f, 
    -0.27565935f, 0.09236021f, -0.07929664f, -0.26965263f, 0.03121823f, -0.02137762f, 0.01686709f, -0.00922509f, 
    0.10775754f, -0.23038051f, -0.37498012f, 0.00572985f, -0.19012187f, -0.03059121f, 0.10470341f, 0.25300333f, 
    -0.22340846f, -0.03282845f, 0.20603059f, -0.02333175f, -0.33989412f, -0.25707310f, 0.02021614f, -0.19917302f, 
    -0.27561653f, -0.38834769f, 0.01201455f, -0.23144904f, 0.14436458f, -0.16422713f, -0.03244933f, 0.10923925f, 
    -0.53420293f, -0.03703270f, -0.07668299f, -0.04610042f, 0.16351281f, -0.34137452f, 0.09907895f, 0.15665850f, 
    0.16794699f, -0.07028665f, 0.12172400f, 0.02107838f, -0.09137929f, -0.34615085f, -0.18509139f, -0.17543842f, 
    -0.22333334f, -0.07751525f, 0.18344742f, -0.39399832f, 0.06427737f, 0.38622084f, 0.10168609f, -0.00015804f, 
    0.16226900f, -0.17166258f, -0.21229710f, 0.20109589f, -0.32214716f, 0.03491669f, -0.39657012f, -0.20499791f, 
    0.22156061f, -0.08053201f, -0.13084918f, 0.04789088f, -0.04851935f, 0.06625184f, -0.02925309f, -0.11215223f, 
    -0.06810271f, 0.02690563f, 0.04099824f, 0.28524962f, -0.05514564f, 0.06739021f, 0.23944068f, 0.17151864f, 
    -0.19842750f, -0.35517755f, 0.04566955f, -0.06010302f, 0.10845868f, -0.12461933f, 0.17066376f, 0.01886038f, 
    -0.02077061f, -0.43963370f, 0.14732037f, -0.21591045f, 0.31490269f, -0.05512032f, 0.03101585f, -0.00830293f, 
    0.14024527f, 0.11419177f, 0.06079323f, -0.58814114f, -0.03400436f, 0.12793563f, 0.19082665f, -0.09003914f, 
    0.27115393f, 0.18759078f, 0.22649530f, 0.07573038f, -0.16449755f, 0.21363860f, -0.02494960f, 0.17837808f, 
    0.04595871f, 0.03572524f, -0.51451749f, -0.04630509f, -0.23419504f, -0.15740255f, 0.00518552f, 0.00752016f, 
    -0.05529665f, -0.27769428f, 0.24071959f, 0.17398782f, 0.05945993f, 0.01744761f, -0.15420972f, -0.04668727f, 
    -0.12999791f, -0.02314080f, -0.04511995f, -0.20896724f, -0.13357566f, -0.10232333f, -0.05043433f, 0.02854979f, 
    -0.35685754f, -0.20264323f, -0.30980033f, -0.06164178f, 0.01546086f, -0.36160788f, -0.07543020f, -0.11630593f, 
    -0.22522311f, 0.07000506f, -0.26015976f, 0.20207365f, -0.27695552f, 0.23287071f, -0.06723793f, 0.00320552f, 
    0.22869803f, 0.05939782f, -0.04467702f, 0.20293075f, -0.15941721f, -0.28432086f, -0.07213765f, 0.08234684f, 
    -0.00405003f, 0.00739179f, 0.00819859f, 0.24355526f, 0.22024578f, 0.14571805f, 0.01808324f, -0.06324560f, 
    0.22688468f, -0.08777815f, -0.11829531f, 0.06669541f, 0.31527326f, 0.15384452f, -0.04367316f, -0.10872169f, 
    -0.06650542f, 0.05050509f, 0.05266495f, 0.22982933f, 0.07361148f, -0.39854929f, -0.26877496f, -0.00129816f, 
    -0.15719534f, 0.12989511f, 0.16641663f, 0.11148500f, -0.25950137f, 0.03660971f, 0.05293708f, -0.22588407f, 
    -0.16910146f, -0.02720052f, 0.11140253f, -0.07338084f, -0.01802117f, 0.19659948f, 0.01848132f, 0.22835548f, 
    0.01750991f, -0.01091400f, 0.01474307f, 0.11464569f, 0.00270054f, -0.18118957f, 0.15192989f, -0.20892981f, 
    0.22535360f, 0.21635693f, 0.06882641f, -0.01777832f, 0.30603868f, 0.00252246f, -0.35580409f, 0.02176965f, 
    0.01287430f, -0.20138666f, -0.55500066f, -0.03603403f, 0.24588263f, 0.32078078f, 0.04739000f, 0.05633597f, 
    0.05516044f, -0.20530915f, -0.30635345f, -0.22865695f, -0.00834191f, -0.26941308f, 0.07136300f, -0.07583726f, 
    -0.09246861f, 0.16386582f, 0.12444171f, 0.18847416f, -0.04529267f, -0.00290552f, -0.33367059f, -0.00853014f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.08226929f, 0.04077759f, -0.04256724f, -0.02288819f, 0.09730517f, -0.05463248f, 0.07912232f, -0.03815146f, 
    0.02331530f, 0.03083770f, 0.00263026f, -0.02955351f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
