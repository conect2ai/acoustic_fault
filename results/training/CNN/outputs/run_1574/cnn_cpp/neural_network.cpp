#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.24227373f, 0.17816043f, 0.16810979f, 0.39000747f, 0.31487617f, 0.18859808f, -0.29630846f, -0.40662900f, 
    -0.45452392f, -0.23776658f, 0.17869566f, 0.22909045f, -0.03343966f, -0.03498453f, 0.42827904f, -0.01081432f, 
    -0.01756859f, -0.14076686f, 0.03266887f, 0.07685283f, -0.01898900f, -0.04266760f, 0.00518545f, -0.05192350f, 
    0.16018265f, 0.98733348f, -0.41699067f, 0.06231910f, -0.16796672f, -0.71114421f, 0.39100039f, -0.23067214f, 
    -0.22265463f, 0.17447932f, 0.22015065f, -0.01958292f, 0.02970173f, -0.02873883f, 0.10397764f, -0.06350997f, 
    -0.23880097f, 0.37416089f, 0.29288176f, 0.07134757f, -0.43144107f, 0.23779991f, -0.08217710f, -0.00775354f, 
    -0.08112342f, 0.08490542f, -0.47588038f, 0.13187122f, 0.42648029f, 0.07127037f, -0.28608233f, -0.05048646f, 
    0.46570775f, -0.09211658f, 0.21232311f, -0.19980265f, -0.22006705f, 0.29346591f, 0.39164686f, -0.35089937f, 
    -0.21446893f, -0.21222629f, -0.10372134f, -0.18308905f, 0.09686624f, 0.14598100f, 0.10547647f, -0.07764795f, 
    0.00162362f, -0.06061705f, 0.41656038f, -0.47351795f, -0.09847595f, -0.13692980f, 0.21041413f, 0.46016359f, 
    -0.41803697f, 0.31825548f, -0.39099252f, -0.27754310f, 0.47672924f, -0.13487956f, -0.20651762f, 0.17002282f, 
    0.17174509f, 0.11565156f, -0.06415791f, -0.18860307f, 0.11096683f, -0.12109014f, -0.04984515f, 0.15652421f, 
    -0.04401730f, 0.04352913f, 0.18610325f, 0.16001074f, -0.85341799f, -0.65075272f, -0.58135730f, 0.10572167f, 
    -0.26401758f, 0.53369862f, 0.20485610f, 0.13459353f, 0.24991582f, 0.43103483f, 0.12953854f, -0.04083135f, 
    -0.09320846f, 0.31169873f, 0.15878773f, -0.16820265f, -0.04177905f, -0.01388453f, -0.20496103f, -0.20558575f, 
    -0.09643196f, -0.03991020f, 0.14460653f, 0.24639714f, -0.13229357f, 0.46801057f, -0.98550010f, -0.47331795f, 
    -0.53193915f, -0.00994115f, 0.31886604f, 0.24449931f, 0.04003584f, -0.23373444f, -0.06037436f, -0.25925457f, 
    -0.22901487f, 0.24403350f, -0.17147657f, 0.43551999f, 0.06205434f, -0.11363703f, -0.17305341f, -0.21095034f, 
    0.03204112f, -0.07856293f, -0.24788105f, -0.31291923f, -0.04022457f, -0.01035921f, -0.18752225f, 0.59035754f, 
    0.17744567f, -0.64220965f, -0.29972884f, 0.27410555f, 0.19714718f, 0.16945443f, -0.05552636f, -0.49152678f, 
    0.36365610f, 0.13329789f, -0.21014428f, 0.58791280f, -0.59283912f, -0.17385660f, -0.14615250f, -0.26599950f, 
    0.05168562f, 0.14832462f, 0.01265702f, 0.26784962f, 0.27200496f, -0.26037124f, 0.14733265f, 0.38347408f, 
    0.49632701f, 0.35911319f, 0.30372065f, -0.36518934f, -0.12518191f, -0.34279263f, -0.07956620f, 0.03103802f, 
    -0.12435810f, 0.30929059f, -0.13363925f, -0.24344152f, 0.00606365f, 0.04999314f, -0.09734440f, 0.07416098f, 
    0.11834154f, -0.13163699f, 0.06798812f, -0.08862247f, 0.14354338f, -0.01847265f, -0.13953914f, -0.20482776f, 
    -0.26455083f, 0.42456657f, -0.65095532f, 0.63240552f, -0.64854378f, -0.22356281f, -0.60725868f, 0.09956084f, 
    0.77291483f, 0.50251579f, 0.05704182f, -0.16568944f, -0.03122933f, 0.30812752f, -0.23114964f, -0.01202684f, 
    -0.08039705f, 0.12930903f, -0.15146229f, -0.16527431f, -0.04631381f, 0.09178001f, 0.00109966f, -0.01167386f, 
    -0.05533914f, 0.98370200f, -0.91015238f, -0.69994009f, -0.03810671f, -0.65526640f, 0.49571532f, 0.47637931f, 
    0.60683167f, -0.17786309f, -0.33615127f, 0.00938372f, 0.13717112f, 0.08126310f, -0.54523176f, 0.27750552f, 
    0.02292036f, -0.07194930f, 0.03563606f, -0.06323792f, -0.13640435f, -0.06987122f, -0.05271416f, -0.02689116f, 
    0.19812289f, 0.26918256f, -0.53076297f, -0.55031794f, 0.51042956f, 0.03977987f, 0.30585095f, -0.58135575f, 
    -0.32618198f, -0.35331842f, 0.42541346f, -0.03372500f, -0.25033408f, 0.45006183f, -0.16561855f, -0.12518741f, 
    0.02951217f, -0.06085377f, -0.12605534f, -0.27053800f, -0.31941617f, -0.31913555f, 0.12409173f, -0.15317246f, 
    -0.13550462f, -0.45934924f, -0.12832828f, -0.48488507f, -0.53514683f, -0.29656881f, 0.62164497f, 0.56265503f, 
    -0.33151770f, 0.13509326f, -0.08036750f, 0.13310222f, -0.31148425f, 0.11286254f, -0.01175948f, 0.07232179f, 
    0.11505737f, -0.08550315f, -0.13826957f, -0.11761328f, -0.06093590f, -0.08408544f, 0.21176533f, -0.22706755f, 
    0.05162516f, 0.23073003f, 0.32362321f, 0.11567168f, 0.38160899f, 0.52547097f, -0.01897135f, -0.62498450f, 
    -0.42769197f, -0.16622940f, 0.07865608f, 0.16359526f, -0.04438666f, -0.00521588f, 0.16935697f, -0.37068486f, 
    0.55969894f, -0.41062334f, 0.15484819f, 0.22845258f, -0.13133220f, -0.51929295f, -0.09498995f, 0.33951113f, 
    0.03721812f, 0.12630710f, -0.12362596f, -0.10786085f, 0.32427445f, -0.91835392f, -0.32960254f, -0.64551729f, 
    -0.75262290f, -0.52968657f, 0.48886016f, 0.23471984f, 0.03154295f, 0.09512199f, 0.33451843f, 0.01604016f, 
    0.38685313f, -0.03003661f, 0.14138402f, -0.25436524f, -0.06810281f, -0.02875957f, -0.13502227f, 0.22497702f, 
    0.12358232f, -0.02625613f, 0.03529152f, -0.26985335f, -0.05576364f, -0.25376865f, 0.01789970f, 0.52253795f, 
    -0.20684573f, -0.08844766f, 0.51316869f, 0.10254970f, -0.15982676f, -0.23547715f, 0.20589881f, -0.33773428f, 
    0.52249604f, -0.24614701f, -0.07914831f, -0.18072732f, -0.11244778f, -0.19560121f, 0.00355128f, 0.01712086f, 
    0.21970683f, -0.16556588f, 0.15226428f, -0.01850559f, -0.16787910f, 0.09390249f, -0.14041658f, 0.58026826f, 
    0.68732172f, 0.08403125f, -0.13439828f, -0.31212601f, 0.10958546f, 0.32395437f, -0.10037228f, -0.28885919f, 
    -0.17710589f, -0.17847896f, 0.24330829f, -0.02769938f, -0.01994901f, -0.27496210f, 0.21440874f, -0.13531561f, 
    -0.02434782f, -0.23368883f, 0.01695308f, -0.00024950f, -0.09918008f, -0.29747009f, -0.12192106f, -0.09064284f, 
    -0.50753146f, -0.38531122f, -0.31670758f, -0.34831336f, -0.12065082f, -0.26674888f, -0.59426600f, -0.44474190f, 
    -0.48888496f, -0.24350287f, 0.00173167f, 0.02469736f, 0.03167290f, -0.43748567f, -0.26446953f, 0.11247227f, 
    -0.10265125f, -0.18458243f, 0.12534012f, -0.08038398f, -0.14886357f, 0.27193061f, 0.09467756f, -0.26914668f, 
    0.32341376f, 0.08266406f, -0.95062524f, -0.78824806f, -0.28468603f, 0.64394152f, 0.40381086f, 0.53078866f, 
    0.37160617f, -0.00641688f, -0.06562484f, -0.05828907f, -0.03408647f, -0.23681815f, -0.11053832f, 0.19410269f, 
    0.19764304f, -0.14071874f, 0.05140477f, 0.09308089f, -0.18257087f, 0.17669468f, -0.05746051f, -0.09572184f, 
    0.06999356f, -0.09466610f, -0.05102387f, -0.21808191f, -0.17726704f, 0.19908914f, 0.00083108f, -0.60385919f, 
    -0.45858100f, 0.20197755f, 0.03679721f, 0.16192742f, -0.10952605f, 0.09099509f, -0.12786564f, -0.20205709f, 
    0.09983228f, -0.01287571f, -0.28148597f, -0.34694967f, 0.36491814f, -0.29241046f, 0.14572142f, -0.27996245f, 
    -0.23090947f, 0.18754666f, 0.43119478f, 0.26870403f, -0.31564146f, 0.09151730f, 0.75716561f, 0.26196450f, 
    -0.44374666f, -0.43885443f, -0.02240002f, -0.48819429f, -0.49264762f, -0.23812304f, -0.05822963f, -0.14225002f, 
    0.41212025f, -0.19946748f, -0.04749179f, 0.10060740f, 0.32377192f, 0.07507871f, 0.16687515f, -0.03977390f, 
    -0.24626338f, 0.02965585f, -0.16433874f, 0.06147882f, 0.33016562f, -0.20333147f, -0.98896599f, -0.10523845f, 
    0.04330600f, 0.23332658f, 0.74326736f, 0.55746979f, -0.52748466f, -0.29071927f, -0.48906982f, -0.58756071f, 
    -0.29377428f, -0.02225778f, -0.21277766f, -0.04482847f, -0.07905081f, 0.32922801f, 0.12355410f, -0.03509172f, 
    0.09426621f, -0.21825305f, -0.31760168f, 0.00316929f, -0.37113160f, 0.57616401f, 0.73743170f, 0.16360642f, 
    -0.49652943f, -0.38703603f, -0.36517483f, -0.08481622f, -0.08284090f, -0.37832570f, -0.19981866f, 0.08889556f, 
    0.06410408f, -0.05986277f, 0.05754600f, 0.05125658f, -0.04763503f, 0.22122470f, -0.00900897f, 0.16787712f, 
    -0.24129157f, -0.00112463f, -0.30565575f, -0.28460807f, -0.56198436f, -0.45840809f, -0.28548262f, -0.59004897f, 
    -0.03380210f, 0.19058533f, -0.44095123f, 0.12370999f, 0.04730329f, -0.01259114f, 0.02821925f, -0.02509307f, 
    0.34959948f, 0.59921467f, -0.10882208f, -0.08656557f, -0.23936747f, -0.42169502f, 0.11880132f, 0.24202180f, 
    -0.18674278f, -0.18581973f, 0.05853947f, 0.25449896f, -0.35210910f, 0.31924021f, 0.04078452f, 0.30011263f, 
    -0.67132080f, -0.37273979f, -0.06914773f, 0.15193714f, 0.40215006f, 0.39018258f, 0.35805002f, 0.16650069f, 
    0.27006483f, 0.05814565f, 0.11851993f, -0.04204736f, -0.02201386f, -0.14985824f, 0.08256384f, -0.12881853f, 
    -0.10680767f, 0.02448200f, -0.19830023f, -0.14051239f, 0.09032567f, 0.22021672f, -0.08707317f, -0.15876709f, 
    0.45861465f, -0.32311994f, -0.05423867f, -0.32198814f, -0.24925768f, 0.53739810f, -0.43513495f, 0.35566327f, 
    -0.12987815f, -0.11840534f, -0.14574312f, 0.17665076f, 0.05532557f, -0.02025182f, -0.14708304f, 0.18345359f, 
    0.04288391f, 0.18883914f, 0.11109211f, -0.19185062f, 0.21710035f, 0.14334579f, 0.25976062f, -0.35025790f, 
    -0.22767793f, -0.50844204f, -0.42712799f, 0.10787213f, -0.54697275f, -0.29696915f, 0.09330804f, -0.36292753f, 
    -0.41466317f, -0.44184500f, -0.08233115f, -0.07135443f, 0.14422674f, 0.24822013f, 0.53396755f, 0.29427841f, 
    0.18831082f, -0.06645407f, -0.13484074f, -0.21333599f, 0.10372845f, -0.09996334f, 0.22214679f, 0.16940990f, 
    -0.14552024f, -0.06117644f, 0.14084758f, 0.20069490f, 0.03649866f, -0.18665640f, 0.02625836f, 0.38858685f, 
    -0.00747467f, 0.06002156f, 0.28063244f, 0.26087600f, 0.28687811f, -0.59066266f, -0.14638287f, -0.24692354f, 
    -0.22977930f, 0.25664198f, -0.00564582f, -0.09478622f, -0.10718188f, -0.19999427f, -0.33427453f, -0.14524423f, 
    0.25707552f, 0.19500408f, -0.13218263f, 0.38694248f, -0.67265224f, -0.68223256f, 0.06858446f, 0.53555810f, 
    0.38056517f, 0.82887810f, -0.83152074f, -1.08354986f, -0.49746189f, 0.15602678f, -0.25055194f, -0.10999919f, 
    -0.20091812f, -0.11698192f, -0.02883792f, -0.46777159f, -0.01345840f, -0.07707158f, -0.09457514f, -0.01665920f, 
    -0.12672000f, -0.06590785f, -0.01004026f, -0.13158020f, 0.15838322f, -0.17537442f, -0.61601269f, -0.58215910f, 
    0.00954595f, -0.45733777f, -0.33820295f, -0.58441389f, -0.27246493f, -0.64625728f, 0.58731788f, 0.41070539f, 
    0.29431576f, 0.13923600f, 0.04595220f, -0.26320502f, 0.12051515f, -0.29379681f, -0.36884791f, -0.22964640f, 
    -0.00860242f, -0.10702308f, -0.05614571f, -0.17263749f, 0.03779390f, -1.28404331f, 0.62801564f, 0.04163305f, 
    -0.29694253f, 0.24870609f, -0.10705668f, 0.06775170f, -0.16648203f, 0.16103761f, -0.13543010f, 0.01650614f, 
    -0.44250569f, -0.20649174f, -0.20313822f, -0.10449655f, 0.52868974f, -0.23335627f, -0.20576297f, -0.02114741f, 
    -0.26657721f, -0.14184165f, 0.02924886f, -0.33404422f, -0.18479168f, -0.52380013f, -0.17674056f, 0.51458025f, 
    -0.18219179f, -0.09630262f, 0.09186470f, 0.00797845f, -0.06645656f, -0.21198843f, -0.07665475f, -0.34163094f, 
    0.19983374f, -0.11249602f, -0.11355098f, 0.19677028f, 0.00225405f, 0.09960228f, -0.01127171f, -0.03195490f, 
    0.10580041f, -0.25395933f, -0.24039502f, 0.01322747f, 0.14845607f, 0.10058995f, 0.43190622f, 0.20664987f, 
    0.30751270f, -0.02889925f, -0.45419961f, -0.32461539f, 0.08042704f, 0.13064532f, 0.33806738f, -0.23068340f, 
    -0.09063226f, 0.22731659f, -0.29263902f, -0.24803430f, 0.47318190f, -0.42546105f, -0.08332549f, -0.20123875f, 
    -0.07629671f, 0.04526544f, -0.18487185f, 0.31303132f, -0.01162005f, 0.24036546f, 0.08655744f, 0.28526500f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03355804f, 0.17728639f, 0.12601173f, 0.10637128f, 0.11456470f, 0.05984128f, 0.08402671f, 0.14973602f, 
    0.21608000f, 0.14399056f, -0.00665321f, 0.19154963f, 0.26621535f, 0.18427595f, 0.07052215f, 0.15341347f, 
    -0.22675835f, 0.20408329f, 0.20507869f, -0.01040843f, -0.13947736f, 0.07710222f, 0.25721306f, 0.04003630f, 
    0.06257901f, -0.09758508f, 0.18303797f, 0.31848726f, -0.14222676f, 0.10221421f, 0.26497239f, 0.01299356f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03533357f, 0.03585932f, 0.04161422f, -0.04183682f, -0.01157271f, -0.01350255f, -0.01717909f, -0.01385626f, 
    0.02105802f, -0.02652084f, -0.02603551f, -0.02359433f, -0.04679100f, 0.03421714f, 0.01355471f, 0.04108756f, 
    -0.00534116f, 0.02215163f, -0.04800526f, -0.03937924f, 0.01012340f, -0.05156384f, -0.00579614f, -0.04488837f, 
    -0.01560555f, -0.02482486f, 0.03217383f, -0.00462036f, -0.03792816f, -0.00015430f, -0.03900876f, 0.02069999f, 
    -0.04961379f, 0.03191542f, -0.01351570f, -0.03612852f, 0.01720074f, -0.02693393f, -0.04641087f, 0.02953028f, 
    0.03219065f, 0.01048852f, -0.01195038f, 0.03007268f, -0.03343030f, 0.02226635f, -0.02446404f, -0.02358661f, 
    -0.05540740f, 0.03489543f, -0.04383470f, -0.04971831f, -0.03358926f, -0.04224429f, -0.01750302f, 0.01054941f, 
    0.01515974f, 0.01975300f, -0.00116017f, -0.05042170f, -0.00146105f, 0.00732346f, -0.05408234f, -0.04811312f, 
    0.00655045f, 0.03681662f, 0.02657697f, 0.01186563f, -0.04904667f, 0.04244483f, -0.00606942f, -0.04494219f, 
    0.02925875f, -0.00137390f, 0.02549692f, -0.00615375f, 0.03261779f, 0.01535256f, -0.04155286f, 0.01493306f, 
    -0.03219809f, -0.02575634f, -0.05814384f, -0.01203381f, -0.03556409f, -0.04599032f, -0.02900513f, 0.00210707f, 
    -0.03540052f, -0.02065108f, -0.02032846f, -0.01030541f, 0.00807224f, -0.00731278f, -0.04992624f, 0.03190531f, 
    -0.05483280f, -0.04336460f, 0.04317433f, 0.00266360f, -0.05410239f, 0.01122418f, 0.01812336f, -0.00363995f, 
    0.01195456f, 0.00362333f, 0.02763729f, 0.02438867f, -0.03676101f, -0.01576703f, -0.04635673f, 0.01309615f, 
    -0.05641604f, 0.02982347f, 0.03918505f, -0.03097706f, -0.04884972f, 0.00819883f, -0.05664164f, -0.04584333f, 
    -0.04006341f, -0.01128590f, 0.03273544f, -0.02074213f, -0.04532503f, 0.03458491f, -0.05112962f, -0.02405734f, 
    0.00273217f, -0.03475079f, 0.01995825f, -0.00980070f, 0.01548371f, 0.02238774f, -0.03462342f, -0.01913919f, 
    0.00428834f, 0.02855806f, -0.04116752f, -0.01403589f, -0.04823021f, 0.00800055f, -0.03873614f, -0.03643719f, 
    -0.02282234f, -0.05458458f, -0.02762565f, -0.02304381f, -0.00656665f, -0.00016101f, -0.03262113f, -0.00292000f, 
    0.00075527f, -0.02844873f, -0.02104957f, -0.05085701f, 0.00023991f, 0.03098666f, -0.02190761f, -0.01303261f, 
    -0.00740830f, -0.04942876f, -0.01226131f, 0.02338142f, 0.02776845f, -0.02675257f, -0.00206072f, 0.03888285f, 
    -0.03898011f, -0.01869977f, -0.02393825f, -0.00268964f, 0.00907537f, 0.00475553f, -0.04669803f, 0.01703629f, 
    -0.03779384f, -0.03781906f, 0.03397213f, 0.00831171f, 0.01166597f, -0.02509521f, 0.01652692f, -0.03053956f, 
    -0.02564773f, -0.02388068f, -0.02600629f, 0.01691533f, -0.03626451f, -0.03086472f, -0.02973708f, 0.02507420f, 
    0.02581537f, 0.02236336f, 0.03814087f, 0.01027690f, -0.05420233f, 0.03487264f, 0.03995081f, 0.02638796f, 
    -0.05893026f, -0.01856434f, 0.00207461f, -0.04019837f, -0.04280256f, -0.00709434f, -0.00107857f, 0.03749912f, 
    0.00178944f, 0.04269192f, -0.04906032f, -0.03669333f, -0.02843856f, -0.02278621f, -0.02887859f, 0.03322103f, 
    0.00914880f, 0.02381005f, -0.00654175f, 0.00559593f, 0.02672552f, -0.04607794f, 0.02593733f, 0.03556436f, 
    0.00954935f, 0.02377310f, 0.00738764f, -0.00145859f, 0.03083121f, 0.03974685f, 0.03469073f, -0.05649092f, 
    0.03282170f, 0.00674539f, -0.03838263f, 0.03023756f, 0.01680332f, 0.00701852f, -0.05137041f, 0.02224356f, 
    -0.05830380f, -0.01674651f, -0.00960520f, -0.04859948f, -0.01976145f, -0.02761669f, -0.04856693f, -0.03728508f, 
    0.02074083f, -0.04836353f, 0.03826914f, -0.00735073f, -0.04930124f, 0.02688738f, -0.00261906f, -0.03475378f, 
    -0.02453924f, -0.01119202f, -0.04515083f, -0.00023893f, -0.02048638f, -0.00497095f, 0.00664654f, -0.03054928f, 
    -0.02555494f, -0.00624058f, 0.02327413f, -0.02547046f, -0.05344177f, -0.04457027f, 0.00845607f, -0.01181396f, 
    -0.02278384f, -0.01579434f, -0.01765885f, -0.00895293f, -0.02547408f, 0.04378902f, 0.01338610f, -0.01747492f, 
    0.00617863f, 0.00621321f, 0.01574852f, -0.01776920f, -0.03253928f, -0.02699058f, 0.00622680f, -0.01486406f, 
    0.03539992f, -0.03495555f, -0.00371622f, 0.04007734f, 0.01920306f, -0.02723836f, -0.04416529f, 0.02611214f, 
    -0.03489098f, -0.02161354f, 0.03402811f, -0.03534477f, 0.00830146f, 0.02549659f, -0.02980441f, 0.03022634f, 
    0.01908087f, -0.03179464f, 0.03220779f, -0.01120528f, 0.02984953f, 0.02677669f, -0.02587788f, -0.00631643f, 
    0.03891724f, 0.04027897f, -0.00765576f, -0.04655378f, 0.01809120f, -0.03506257f, -0.00865319f, -0.00189971f, 
    0.00551346f, 0.00532628f, -0.02131387f, 0.00579000f, -0.02384328f, 0.03215589f, 0.00601990f, -0.04348026f, 
    -0.05007481f, -0.00223436f, 0.03946047f, -0.05682477f, -0.03484873f, -0.04161135f, 0.03144543f, -0.03104073f, 
    -0.04113016f, -0.02271986f, 0.00835945f, -0.04145468f, -0.03820224f, -0.01460928f, 0.00989828f, -0.05404907f, 
    -0.02673731f, -0.01389466f, -0.02588297f, -0.00069448f, 0.03534240f, 0.03322916f, -0.03793228f, 0.00536231f, 
    -0.02168962f, -0.04778949f, -0.00050937f, -0.00309798f, -0.04657618f, 0.01146701f, 0.02069213f, -0.05780174f, 
    0.00286967f, 0.01118803f, 0.02279757f, -0.05306054f, -0.03296316f, -0.03564629f, -0.04105223f, -0.03127060f, 
    -0.01240342f, 0.02495580f, 0.02982113f, -0.03644471f, 0.03449246f, 0.04126887f, 0.02675226f, -0.00756470f, 
    -0.03779767f, 0.03507325f, -0.04773440f, -0.01436184f, -0.01584175f, -0.04055125f, 0.02495706f, -0.04800459f, 
    -0.09368151f, 0.13803995f, -0.02633731f, 0.01258437f, -0.06675480f, -0.10499118f, -0.12504013f, -0.04907345f, 
    0.02570438f, -0.02593167f, 0.01574325f, 0.00165847f, -0.45395055f, 0.17313841f, 0.09034488f, 0.28829780f, 
    0.13842006f, -0.11935619f, -0.01871926f, 0.04327036f, -0.12898178f, 0.05488762f, 0.00076013f, 0.22290337f, 
    0.20213026f, 0.18518704f, 0.04080454f, -0.17453313f, -0.08176073f, 0.04624840f, -0.04143209f, 0.13169608f, 
    0.03774416f, 0.12339710f, 0.08994190f, -0.01349035f, 0.06220437f, 0.00870255f, -0.19213371f, -0.17143555f, 
    0.08644304f, 0.10116614f, 0.10165592f, -0.04850174f, 0.09439591f, 0.06796677f, 0.15344483f, 0.03843286f, 
    0.01631464f, -0.04752089f, 0.14163862f, -0.02865725f, 0.05623597f, 0.03864918f, 0.03429716f, -0.10234740f, 
    -0.12416301f, -0.07740798f, 0.04564674f, -0.02845812f, 0.04133033f, 0.11040375f, -0.01534684f, 0.23917083f, 
    0.07144951f, 0.00026767f, 0.00435647f, 0.00884706f, 0.02478388f, -0.03182245f, -0.04084028f, -0.19828711f, 
    0.03806557f, -0.13927098f, 0.09170746f, 0.05200920f, -0.04124850f, -0.04392751f, 0.02963610f, 0.15574601f, 
    0.04931350f, 0.12574077f, 0.12181401f, 0.09557637f, -0.12730101f, 0.11134896f, 0.28329757f, -0.05953975f, 
    -0.13974001f, -0.02306639f, -0.14483790f, 0.04934734f, -0.04982020f, 0.06141366f, -0.02585833f, 0.03663367f, 
    -0.11143077f, 0.13544585f, -0.07296164f, -0.10363234f, 0.17166440f, 0.02217432f, -0.11077348f, -0.29623950f, 
    -0.02835000f, -0.08058940f, 0.13791497f, 0.05714515f, -0.12453495f, 0.26037017f, 0.18769346f, 0.21980307f, 
    -0.01264013f, 0.01988872f, 0.10496352f, 0.04352767f, 0.12104214f, 0.03549832f, -0.04441702f, -0.03355481f, 
    0.07044758f, 0.02627845f, -0.20882030f, -0.17605415f, 0.06846483f, 0.04097892f, -0.06493055f, 0.06776050f, 
    -0.06154487f, 0.06774472f, -0.25938389f, -0.01616363f, 0.02152107f, 0.27020872f, -0.34873000f, -0.06245059f, 
    0.21041696f, 0.06838790f, 0.14481705f, 0.03168864f, -0.00173991f, 0.07671046f, 0.17688452f, 0.01374693f, 
    -0.04851770f, -0.06261306f, 0.12697254f, 0.04560804f, -0.05953498f, 0.08910543f, 0.00992233f, -0.00345955f, 
    -0.07874987f, 0.07544510f, 0.03331997f, 0.02132074f, 0.29156986f, -0.06312612f, -0.00616355f, 0.15491350f, 
    0.01243100f, 0.07501128f, 0.05068588f, 0.07688197f, -0.06347404f, -0.04386942f, -0.04089416f, -0.06647845f, 
    0.27884746f, 0.12863973f, 0.35403484f, 0.17601439f, -0.27356318f, -0.01465435f, -0.01574525f, -0.10086384f, 
    0.03763554f, 0.07018751f, 0.03594159f, 0.05931630f, -0.24822845f, 0.23222268f, 0.72277921f, -0.14660454f, 
    -0.19284248f, -0.15265410f, -0.20800506f, 0.06519327f, -0.03761364f, -0.17532265f, -0.12707761f, 0.14434227f, 
    0.01979275f, -0.11113404f, -0.29241323f, -0.03427470f, 0.00530180f, 0.04366818f, -0.08870313f, 0.01274548f, 
    -0.09922352f, -0.00462358f, -0.09056324f, -0.06454659f, 0.47252265f, 0.39991039f, 0.18319422f, 0.06160342f, 
    0.01799074f, -0.04390993f, 0.03560320f, -0.09240414f, -0.11556175f, 0.04160779f, 0.12052301f, 0.02298037f, 
    -0.01796250f, 0.14933522f, -0.06390072f, 0.07351886f, 0.01987332f, 0.07722799f, 0.12309930f, 0.05491693f, 
    0.04022673f, -0.02512793f, 0.21748762f, 0.08403487f, 0.00456505f, 0.28541169f, -0.21873479f, 0.06208624f, 
    -0.03771579f, -0.03061158f, -0.00894900f, -0.02889122f, -0.05588159f, -0.05124276f, -0.06795704f, -0.04815698f, 
    0.45490813f, 0.03553218f, 0.12020093f, 0.29244858f, -0.01369862f, 0.00663385f, 0.12479170f, 0.10079762f, 
    0.08053884f, 0.00619444f, 0.02857557f, -0.09763402f, -0.28767833f, -0.18533543f, 0.23243301f, -0.02698154f, 
    -0.08042065f, 0.20196760f, -0.08941208f, 0.05146044f, 0.01501951f, 0.07247990f, -0.10722363f, 0.09218166f, 
    -0.05001056f, -0.01170514f, -0.13551387f, 0.04927045f, 0.00634003f, -0.13944608f, 0.06020031f, 0.18173838f, 
    -0.04208744f, 0.14717555f, 0.01127360f, 0.26950958f, 0.09167881f, 0.08675390f, -0.00253328f, -0.08604088f, 
    -0.08190330f, 0.03501791f, 0.01820814f, -0.10353019f, -0.14182884f, 0.01956291f, -0.00713295f, 0.06447446f, 
    -0.03343896f, 0.00311421f, -0.18782482f, 0.02301808f, 0.02334880f, 0.10327952f, 0.01929835f, 0.09714256f, 
    -0.08422833f, 0.03121549f, 0.08736079f, 0.00601212f, -0.01304211f, -0.22737962f, -0.15787148f, 0.07680953f, 
    0.05333771f, 0.10036553f, -0.12673396f, 0.04099935f, -0.17123808f, 0.07569654f, -0.05084943f, -0.09888708f, 
    -0.03428277f, 0.23338540f, 0.24132593f, -0.03019433f, -0.09431972f, -0.07929657f, -0.04673503f, -0.07384016f, 
    -0.02959560f, 0.15873918f, 0.09872557f, 0.08125825f, 0.11057948f, -0.00387297f, -0.20565945f, 0.14750040f, 
    -0.06853803f, 0.03082271f, 0.12857667f, 0.01996384f, 0.03015472f, -0.05039521f, -0.01593120f, 0.01505797f, 
    -0.15593940f, -0.15149537f, -0.25453323f, 0.02236200f, 0.09436031f, 0.14252909f, 0.13141280f, 0.11760167f, 
    -0.00686147f, 0.03359509f, -0.18819241f, 0.00450018f, 0.22986710f, -0.00851953f, -0.00955884f, 0.04917539f, 
    0.09123645f, 0.12916143f, 0.00125522f, 0.01686447f, -0.02478196f, 0.10599895f, -0.00616903f, 0.09353097f, 
    0.07545966f, -0.13510904f, -0.03600652f, -0.07047497f, 0.03976399f, 0.02694486f, 0.05116344f, -0.18828903f, 
    0.06316987f, 0.12002578f, 0.25627291f, 0.01250927f, -0.07173265f, -0.12832677f, 0.18888034f, 0.16680148f, 
    -0.04503383f, -0.03022861f, 0.14852269f, -0.01099752f, -0.00821025f, 0.04338669f, 0.14353587f, -0.02588519f, 
    0.02865687f, -0.00761907f, 0.03275336f, -0.04241667f, -0.03343554f, -0.00154613f, -0.03350836f, 0.04037715f, 
    -0.03539894f, 0.00912424f, -0.04661388f, -0.02257407f, -0.00779066f, -0.01787467f, 0.01898795f, -0.02890521f, 
    0.01438832f, -0.02295106f, -0.00438803f, -0.02907462f, -0.04643042f, -0.04045561f, -0.05187710f, -0.05579953f, 
    -0.05311508f, 0.01845279f, 0.04687036f, -0.06111022f, -0.02472538f, 0.02996180f, 0.02886166f, -0.05358151f, 
    -0.02545861f, 0.01244693f, -0.03253251f, -0.04073356f, -0.02984315f, 0.02933834f, 0.02537641f, -0.00373425f, 
    0.01901361f, -0.03282167f, 0.03242065f, 0.03631857f, 0.00910898f, -0.04611133f, -0.04900577f, 0.03786555f, 
    -0.05622921f, 0.01679347f, -0.03945196f, -0.03023206f, -0.06060920f, 0.01328462f, -0.00137136f, -0.02135873f, 
    -0.00633163f, -0.02182650f, -0.03216602f, 0.03594530f, 0.03387507f, -0.02360439f, -0.03267100f, 0.01802571f, 
    0.01960401f, -0.00041468f, -0.03243065f, -0.01412713f, 0.01897241f, -0.04770409f, -0.03058786f, -0.05969660f, 
    -0.02471177f, -0.00759605f, -0.01516246f, -0.04957451f, -0.04888634f, 0.01599902f, -0.00540790f, -0.03344031f, 
    0.04467650f, 0.01314871f, -0.04649715f, -0.05223532f, -0.04962916f, -0.03996828f, 0.02425731f, 0.01286414f, 
    0.03825793f, -0.04263136f, -0.04557113f, -0.05967196f, 0.03824659f, -0.00015928f, -0.01637889f, -0.01631885f, 
    0.02300521f, -0.04336867f, -0.01255302f, -0.00472173f, -0.00170579f, 0.02340783f, -0.01292333f, -0.03600929f, 
    -0.01162461f, 0.01174165f, -0.03131135f, -0.00884992f, -0.02247771f, -0.05429688f, 0.03767192f, 0.03489588f, 
    -0.05346209f, -0.03981093f, -0.03874928f, -0.03180423f, 0.02613280f, 0.02212710f, -0.01918993f, 0.03679520f, 
    -0.03791723f, 0.00732422f, 0.01116264f, -0.03390832f, -0.03044366f, -0.05630704f, -0.04592680f, 0.03791875f, 
    -0.05316981f, 0.01339040f, -0.02159684f, 0.02588598f, 0.02202068f, 0.02931547f, 0.01793291f, 0.03407603f, 
    -0.02207790f, -0.02508164f, -0.01521389f, -0.05326969f, 0.03635962f, 0.02709415f, -0.03692760f, 0.00203219f, 
    0.03439443f, 0.01025749f, -0.02940828f, -0.01473379f, 0.00022140f, -0.05495863f, -0.04582047f, 0.00886574f, 
    -0.01773730f, 0.02608022f, 0.03457392f, 0.02553960f, 0.01682808f, 0.01393635f, 0.01565329f, -0.01878067f, 
    0.03346131f, -0.00729538f, 0.00493416f, -0.04484755f, 0.01053134f, -0.01260984f, -0.02753085f, 0.00875902f, 
    0.01834552f, 0.04555852f, 0.03652968f, 0.00227346f, -0.00088088f, 0.01117885f, -0.05901153f, -0.02279318f, 
    -0.00996858f, 0.04374110f, -0.02877475f, -0.01081122f, -0.05476810f, -0.01852402f, 0.03157295f, 0.03497008f, 
    -0.04614187f, -0.02085348f, -0.01357123f, -0.05053557f, -0.04136807f, -0.03060082f, -0.04753321f, -0.00267050f, 
    -0.00755163f, 0.02492420f, -0.05763133f, -0.02286392f, 0.00978349f, -0.03067419f, -0.01228806f, -0.04529682f, 
    -0.01083567f, -0.05684999f, -0.05338052f, 0.00003537f, 0.02566103f, -0.01514045f, 0.01096913f, -0.01670945f, 
    0.01043622f, 0.00595057f, -0.00168139f, 0.00478116f, 0.01307110f, -0.02822293f, -0.04471197f, 0.02938062f, 
    0.01961405f, -0.03755438f, 0.02122458f, -0.01150273f, -0.04905404f, -0.02363855f, -0.02019870f, 0.01281545f, 
    -0.02524275f, 0.00329786f, -0.04579237f, -0.00611839f, -0.00105987f, -0.01511299f, -0.04741294f, 0.00883186f, 
    -0.05394955f, -0.04092859f, -0.01252365f, 0.03950819f, 0.01129467f, 0.02179279f, -0.04754555f, 0.02886926f, 
    0.01240769f, -0.02327401f, 0.04073356f, -0.00000274f, 0.00223137f, 0.02886747f, -0.01051787f, -0.02827441f, 
    -0.04411537f, 0.00710243f, 0.02937500f, 0.03534008f, 0.01222523f, -0.05608777f, -0.05851639f, -0.01457433f, 
    0.02399542f, -0.01110833f, 0.00216252f, 0.03793378f, -0.04304421f, -0.05889796f, 0.03539119f, -0.02070361f, 
    -0.03538010f, 0.02102889f, 0.00314728f, 0.01594542f, 0.00755857f, -0.01869668f, -0.03877165f, -0.02441252f, 
    -0.01062209f, 0.00228171f, -0.00410851f, -0.05379606f, 0.03537883f, -0.02299585f, -0.01729373f, -0.00935072f, 
    -0.03486864f, -0.05514145f, 0.01285133f, -0.00066405f, 0.03910541f, 0.00919012f, 0.00999564f, 0.03445326f, 
    -0.06081930f, 0.04230780f, 0.02592273f, -0.04104400f, -0.04359736f, -0.01806223f, -0.04914278f, -0.03152684f, 
    -0.00406536f, 0.02834018f, 0.04258921f, -0.01224600f, -0.01769663f, 0.01688671f, -0.05175285f, -0.03428911f, 
    0.01923393f, -0.02753195f, 0.04069066f, -0.01518549f, -0.01257143f, -0.03883872f, 0.00310171f, 0.01384034f, 
    -0.03618377f, -0.01242362f, 0.02140714f, 0.04991863f, -0.02650925f, 0.02429725f, 0.00227628f, 0.02556335f, 
    0.03197308f, -0.02221519f, 0.03772318f, -0.03650839f, 0.01485392f, -0.05033934f, -0.02103026f, 0.01160390f, 
    -0.06221621f, -0.01103935f, 0.02228462f, 0.00894750f, 0.03497957f, -0.00128793f, 0.01591647f, 0.03088744f, 
    0.00077882f, 0.03978045f, -0.02063178f, -0.04233687f, -0.04647063f, 0.00762966f, -0.00794732f, 0.01577509f, 
    -0.03934559f, -0.04853501f, -0.03196036f, 0.03350925f, -0.00181570f, -0.02332279f, -0.04599232f, -0.03689383f, 
    -0.03850433f, -0.03821526f, 0.00578103f, 0.02080299f, 0.01519154f, 0.00477880f, 0.03106631f, -0.03659097f, 
    -0.02729212f, -0.03561191f, 0.00174356f, -0.03179779f, -0.03751493f, 0.02449583f, -0.05827221f, -0.00334990f, 
    0.00630492f, -0.03330331f, -0.05102495f, 0.01632108f, 0.02461630f, -0.05810287f, 0.01374696f, 0.02280185f, 
    -0.05696465f, -0.05883327f, -0.05095059f, 0.01048937f, -0.03027993f, -0.04690807f, 0.02823189f, 0.03710455f, 
    -0.05015918f, -0.06727682f, -0.03478986f, 0.03036420f, 0.01189570f, 0.01961474f, -0.11706607f, -0.09584702f, 
    0.05191756f, -0.07419223f, -0.03924757f, -0.00593464f, -0.23303138f, 0.17842053f, -0.07086873f, 0.22932233f, 
    0.11786377f, -0.00729903f, 0.05403399f, -0.05985695f, -0.15706831f, 0.15519428f, -0.13934842f, 0.15249486f, 
    0.04668905f, -0.10644151f, 0.10391259f, -0.08233658f, -0.03454081f, -0.01365070f, -0.06265295f, 0.00054698f, 
    0.01390878f, 0.07136034f, 0.05691955f, 0.05139216f, -0.02235157f, -0.12093070f, -0.28578836f, -0.14378023f, 
    -0.02712956f, 0.10664874f, 0.09572873f, 0.01081073f, 0.09758818f, -0.01975403f, 0.05119466f, -0.03157518f, 
    -0.28144431f, 0.06484690f, 0.21724440f, 0.06450279f, -0.05080549f, -0.00502845f, 0.00291227f, -0.01636333f, 
    -0.11445586f, -0.04717232f, 0.12122384f, 0.03739071f, -0.16201720f, 0.20955685f, -0.04777381f, 0.25649491f, 
    -0.00074754f, 0.11009697f, 0.07410966f, 0.09461147f, 0.08181190f, -0.01746720f, 0.04748444f, -0.05794862f, 
    0.00984034f, -0.15049689f, 0.35120973f, -0.09446579f, -0.01089658f, -0.00644622f, -0.08715769f, 0.02104694f, 
    -0.07521674f, 0.09217840f, 0.17127444f, 0.00011060f, 0.02030002f, 0.07866302f, 0.02299824f, 0.08087169f, 
    -0.04430689f, -0.04221149f, 0.01762868f, -0.01867033f, 0.00644939f, -0.00444206f, -0.10570685f, -0.06824838f, 
    -0.19103217f, 0.08789164f, -0.18821418f, 0.03524711f, 0.08774947f, -0.13919340f, 0.04764804f, -0.13535678f, 
    0.02875833f, 0.07315694f, 0.02509401f, 0.16173829f, -0.25798261f, 0.35717791f, 0.40079442f, 0.21323496f, 
    0.03614219f, 0.05109201f, -0.03105629f, 0.09268116f, 0.17698127f, -0.00581333f, 0.05830554f, 0.00870089f, 
    -0.02767987f, -0.06923054f, -0.29063010f, -0.13651495f, 0.19163780f, 0.11249499f, -0.01896079f, 0.07276711f, 
    0.01827195f, 0.14927158f, -0.06602788f, -0.05653268f, -0.16187541f, 0.03293161f, -0.27815723f, -0.05492593f, 
    -0.01109455f, -0.03538216f, -0.13930947f, 0.05821054f, -0.01924449f, -0.00168298f, 0.10147751f, 0.08717375f, 
    0.21136057f, -0.04649483f, 0.11920540f, 0.04937564f, -0.06296814f, 0.04345367f, -0.07867520f, 0.04075744f, 
    -0.12200249f, 0.01090655f, 0.02878032f, -0.02713528f, 0.00127448f, -0.02607815f, 0.22280531f, 0.28840759f, 
    0.00245551f, -0.03247446f, 0.05101626f, -0.00207818f, -0.09910202f, -0.04461269f, -0.00210118f, -0.00074819f, 
    0.14595681f, -0.08112938f, -0.02249939f, 0.03568923f, -0.04440202f, -0.02648496f, -0.04883089f, -0.10176808f, 
    -0.02413700f, -0.04269758f, -0.01297306f, 0.01231609f, -0.00957062f, 0.02463158f, 0.48866698f, -0.08610833f, 
    -0.09637038f, 0.00909927f, -0.12540829f, -0.02748117f, -0.06212534f, -0.06871893f, -0.05345841f, 0.08384877f, 
    -0.26285961f, -0.29056937f, -0.24330077f, 0.00147457f, -0.06565993f, -0.14753509f, -0.07610343f, -0.06507595f, 
    -0.06585529f, 0.09906751f, 0.02128377f, 0.02550189f, 0.06648446f, 0.51988584f, 0.15978123f, 0.04835325f, 
    0.04043802f, 0.06209604f, -0.00897877f, 0.01593374f, -0.10393116f, 0.01833276f, 0.14415449f, 0.00878779f, 
    0.10784747f, -0.03216020f, -0.15163171f, -0.02921837f, -0.09746891f, 0.00880007f, 0.14886098f, 0.09577091f, 
    0.12865257f, 0.06684339f, 0.26677802f, -0.00637539f, -0.05793534f, 0.14893043f, -0.20758586f, 0.30152094f, 
    0.01377941f, 0.03464728f, -0.09341698f, -0.05591379f, -0.01491301f, -0.05183647f, -0.06374494f, -0.01137951f, 
    0.13466747f, -0.00411758f, 0.05603057f, 0.12039664f, 0.07782369f, 0.09141026f, 0.05512602f, -0.01811419f, 
    0.14364381f, 0.08319768f, 0.10014185f, -0.01299445f, -0.01164673f, -0.12657391f, 0.22772443f, -0.04194776f, 
    0.01477737f, 0.23633061f, -0.01937767f, 0.01930641f, -0.00126822f, -0.02146240f, -0.19216874f, 0.02089052f, 
    -0.08387123f, 0.02146744f, 0.09642930f, 0.33065456f, 0.02864230f, -0.23149303f, 0.01281158f, 0.04187806f, 
    -0.06665064f, 0.20526171f, -0.06708093f, 0.23673700f, -0.19346751f, 0.09787784f, 0.00261299f, -0.10410888f, 
    -0.01938577f, 0.04067484f, -0.07763354f, -0.03196953f, -0.03467515f, 0.08750608f, 0.11836062f, 0.15942720f, 
    -0.10062504f, 0.04882579f, -0.04470577f, 0.03171722f, 0.10552612f, 0.12695825f, 0.02317143f, 0.09585552f, 
    -0.00128627f, 0.01003922f, -0.08615337f, -0.00605547f, -0.28064802f, -0.23469321f, -0.03842000f, 0.16075532f, 
    0.02364968f, -0.01088138f, -0.01515890f, 0.08042958f, -0.14601707f, -0.06172377f, 0.03419410f, 0.00681935f, 
    0.06963629f, 0.04155676f, 0.06086088f, -0.09276614f, 0.01288470f, -0.10275593f, -0.10027040f, -0.00500773f, 
    0.03530056f, 0.15492822f, 0.16311236f, 0.07250518f, -0.18117639f, -0.02209050f, -0.20879501f, 0.35253730f, 
    -0.03148420f, 0.09890777f, -0.10497746f, -0.11670260f, 0.10791446f, 0.05155391f, 0.06717664f, 0.04369482f, 
    -0.30480009f, -0.21700798f, -0.06375534f, 0.04475131f, -0.03127855f, 0.07493716f, 0.02653356f, 0.06858422f, 
    -0.03464814f, 0.05118595f, -0.04211483f, 0.13137794f, 0.27713212f, -0.13765837f, -0.01907178f, -0.08177932f, 
    0.20240808f, 0.14256749f, 0.04842738f, -0.05298470f, 0.06629761f, 0.21505600f, 0.19738877f, 0.06114081f, 
    0.06292477f, -0.16309339f, -0.03823797f, -0.08426408f, 0.11755363f, 0.00324511f, 0.01720257f, 0.00914743f, 
    0.10124937f, 0.06044081f, 0.08017585f, 0.00157655f, -0.10435039f, -0.14730883f, 0.17791669f, -0.04999146f, 
    0.06447981f, -0.07764985f, 0.08715086f, 0.02651262f, -0.05518930f, -0.00692600f, 0.17703521f, 0.01133585f, 
    -0.33818844f, -0.02588690f, -0.09226183f, 0.14937030f, -0.02629522f, -0.11952642f, -0.02281195f, -0.05473268f, 
    -0.04396074f, 0.03804638f, -0.07616879f, -0.13224758f, -0.24806246f, 0.15021795f, -0.24760483f, -0.07122665f, 
    0.05272596f, -0.11501618f, -0.05880121f, -0.02083689f, -0.21888381f, 0.03982452f, 0.04036592f, 0.06512029f, 
    0.32778099f, 0.11602593f, 0.38666606f, -0.41802830f, -0.03734440f, -0.14071184f, 0.10979742f, 0.05908489f, 
    -0.07195284f, -0.10912497f, -0.11058683f, -0.18472667f, -0.20810576f, 0.10765662f, -0.10933127f, 0.02798023f, 
    -0.00241278f, 0.07433655f, 0.08217485f, -0.05006740f, -0.02450250f, 0.05966160f, -0.00191560f, -0.02582130f, 
    0.00655018f, 0.35238406f, 0.11709426f, 0.02787843f, 0.04169089f, 0.01738300f, 0.07689539f, 0.03730041f, 
    -0.05045604f, 0.04369297f, 0.03635667f, 0.02635335f, 0.09241610f, 0.27643177f, 0.01025788f, 0.21174631f, 
    0.13430117f, 0.12509347f, -0.09961195f, 0.03712365f, 0.10433860f, 0.01912409f, 0.08977172f, -0.09650052f, 
    0.34261060f, 0.02799731f, 0.05585801f, 0.00093854f, -0.12801023f, -0.07233763f, 0.04374366f, -0.00296751f, 
    -0.07091907f, -0.08238941f, -0.13444646f, -0.00876404f, -0.12000977f, -0.08953385f, 0.08149826f, -0.12970358f, 
    -0.16928154f, -0.20637891f, -0.10979696f, -0.12454078f, -0.08341131f, 0.07521051f, -0.05874766f, -0.04667398f, 
    -0.68057913f, 0.37514043f, -0.13006331f, -0.04131145f, -0.04580526f, 0.17950417f, 0.18996808f, -0.01420718f, 
    0.08603495f, -0.07918035f, -0.07641613f, 0.03870001f, 0.17099637f, 0.45712280f, 0.09381962f, 0.43631920f, 
    0.00213008f, -0.02626834f, 0.03328164f, -0.03558091f, 0.09549560f, 0.02733638f, -0.03566036f, -0.02694001f, 
    0.03287154f, 0.23335326f, -0.08037896f, -0.14226705f, -0.06347775f, 0.05756462f, 0.07699578f, 0.05050472f, 
    -0.19054225f, -0.09322128f, -0.01373734f, 0.18932892f, -0.12858620f, 0.10729252f, -0.13032712f, -0.14283316f, 
    -0.03110715f, 0.09399556f, -0.06085380f, -0.03665994f, -0.21009594f, -0.04309097f, 0.01718215f, -0.02475998f, 
    0.24838418f, -0.30425355f, 0.19160926f, 0.21019915f, -0.14173180f, 0.07198966f, -0.00911049f, -0.12809984f, 
    -0.12921226f, -0.15960415f, -0.11053576f, -0.17841303f, 0.31023970f, 0.13223456f, 0.09055547f, 0.25827524f, 
    0.00408584f, -0.00363206f, 0.01851702f, 0.01866636f, -0.00645837f, 0.14816353f, -0.02657306f, -0.06160028f, 
    -0.20157348f, 0.17013623f, 0.06792955f, 0.47620884f, -0.13353655f, -0.05547078f, 0.11475115f, -0.12656716f, 
    0.01297791f, 0.08348491f, -0.09657662f, 0.06467538f, 0.11343171f, 0.01315277f, 0.11900578f, -0.14797461f, 
    -0.07036895f, -0.17220552f, -0.18019074f, -0.00543018f, -0.13646281f, -0.04389105f, -0.06096596f, 0.15865694f, 
    0.12038359f, 0.00442234f, -0.14168607f, 0.04023791f, 0.06015138f, 0.03600294f, 0.03977283f, 0.09244417f, 
    -0.05978577f, 0.06711533f, 0.13941231f, 0.06543402f, 0.01161664f, 0.24435155f, -0.04308529f, 0.07127830f, 
    -0.05940399f, 0.18602899f, -0.07386821f, -0.02104529f, 0.05239788f, 0.12672794f, -0.03475601f, -0.04932800f, 
    -0.11264341f, 0.00942124f, -0.05898941f, -0.06271362f, -0.15299293f, 0.10196511f, -0.12354652f, 0.02874675f, 
    -0.02818185f, -0.08868847f, -0.06222870f, -0.11111441f, -0.12892619f, 0.11963348f, -0.01121782f, 0.00352906f, 
    -0.12837279f, 0.16855738f, -0.09494432f, 0.13294515f, -0.08464400f, -0.02568062f, -0.01267614f, -0.01613696f, 
    0.09980947f, -0.11944735f, 0.30939078f, 0.02550474f, 0.00334936f, 0.03305457f, -0.01905294f, -0.15788305f, 
    0.20382287f, 0.02245987f, -0.05250368f, 0.09341170f, 0.10568266f, -0.13591266f, 0.05934764f, -0.04209821f, 
    0.13720764f, -0.11265670f, 0.01189432f, -0.04923173f, 0.03128702f, -0.05954725f, 0.00697191f, 0.13546647f, 
    0.05719895f, 0.15800823f, 0.13126916f, -0.06186767f, 0.04204965f, -0.04192908f, -0.06788067f, 0.03880308f, 
    -0.11048066f, -0.00627374f, -0.05702578f, -0.11480581f, 0.10059540f, 0.09424606f, -0.06762503f, 0.13880847f, 
    -0.13764079f, -0.09676704f, 0.00974101f, 0.03550170f, 0.14110926f, 0.09027746f, -0.09848930f, 0.04790661f, 
    -0.03287413f, -0.13173816f, 0.02824873f, 0.17335072f, -0.15770741f, -0.15802242f, 0.00146192f, -0.01450432f, 
    -0.10216544f, -0.03674849f, -0.05358739f, -0.03455888f, 0.17153510f, 0.08820242f, -0.07439168f, 0.08475905f, 
    0.08688587f, -0.02773700f, -0.05729235f, 0.14920525f, -0.04833852f, 0.18239988f, 0.13358758f, 0.00584312f, 
    -0.02357069f, -0.02897318f, 0.08962312f, 0.24262021f, -0.01657297f, -0.05046985f, -0.02379464f, -0.03216401f, 
    0.02211151f, 0.05129847f, -0.06055817f, 0.18192525f, 0.05310144f, -0.08767515f, -0.22816589f, 0.29915607f, 
    0.17546222f, -0.09391331f, -0.08058289f, -0.00974933f, -0.00743692f, -0.08597076f, -0.06934032f, 0.09693336f, 
    0.09018961f, 0.06862050f, -0.09733237f, 0.12883227f, 0.02858648f, 0.10072302f, 0.14437361f, 0.12170827f, 
    0.10171553f, -0.01406380f, 0.06559726f, 0.11437695f, 0.41327217f, -0.10953899f, -0.01873559f, -0.09583469f, 
    -0.02933285f, 0.05585437f, 0.01214025f, -0.01168343f, -0.08980235f, 0.15002669f, 0.01122001f, 0.19851941f, 
    0.14215715f, -0.13353083f, -0.11884592f, 0.08243482f, 0.01856889f, 0.00391324f, 0.02478239f, -0.00988925f, 
    -0.02111689f, 0.13979824f, -0.12393297f, -0.05279418f, 0.02135509f, -0.08908056f, -0.00147688f, 0.06186634f, 
    0.07419859f, -0.03393153f, 0.12317543f, 0.20516306f, -0.04588191f, -0.09855308f, -0.11982190f, -0.06606948f, 
    0.03260166f, -0.30769458f, -0.03457265f, 0.01854272f, 0.05956846f, 0.07765461f, 0.00720257f, 0.00910899f, 
    -0.12590958f, 0.07960102f, -0.08845676f, -0.04157263f, 0.40414575f, 0.18085545f, -0.03865596f, -0.39032167f, 
    0.04906701f, 0.02216934f, -0.04821035f, -0.06306932f, -0.08030321f, 0.02185947f, -0.03330968f, 0.01408236f, 
    -0.05751047f, 0.11514258f, 0.05784241f, 0.00101151f, 0.02164896f, 0.02527164f, 0.10717139f, -0.00316801f, 
    0.00043186f, -0.07385884f, -0.16121480f, -0.05971051f, -0.11415374f, -0.03026244f, -0.07395309f, -0.00065804f, 
    0.02245232f, 0.07388666f, 0.03586583f, -0.02534982f, -0.10720452f, -0.01631798f, -0.01998292f, -0.12055153f, 
    0.29917228f, 0.31813386f, 0.25733975f, 0.25344235f, -0.14946929f, -0.15022023f, 0.00793217f, -0.02556685f, 
    0.01477947f, -0.02126586f, -0.02461736f, 0.04679654f, 0.13125284f, -0.11175464f, 0.20045199f, -0.06375188f, 
    -0.05798588f, 0.08390772f, -0.05871211f, -0.12505257f, 0.10038993f, 0.05862808f, 0.07435916f, 0.07629880f, 
    -0.01497983f, 0.03012789f, -0.05997186f, -0.14141269f, 0.05056318f, -0.07891832f, 0.02985976f, 0.02294515f, 
    0.00783979f, -0.20701674f, 0.03431333f, 0.05436546f, 0.00322776f, -0.01935528f, -0.27693167f, -0.07497025f, 
    0.00037824f, -0.01975614f, -0.02072703f, 0.04642548f, -0.04811684f, 0.05897936f, 0.06524903f, 0.05525820f, 
    -0.58160043f, 0.36213553f, -0.03732761f, -0.05239115f, -0.02458770f, -0.05399406f, 0.05303121f, 0.04167433f, 
    0.17362180f, -0.02338457f, -0.02740589f, 0.11015700f, 0.57040775f, -0.09403446f, 0.01361646f, -0.01023669f, 
    -0.06717319f, -0.08214745f, -0.07629880f, -0.13762373f, -0.01933822f, -0.02230426f, -0.06854045f, 0.03246537f, 
    -0.06525340f, 0.16807358f, -0.01226753f, -0.03954269f, -0.08330388f, 0.05265987f, -0.02653433f, -0.04530192f, 
    0.01855707f, 0.08610637f, 0.19874176f, 0.14587426f, 0.04679877f, -0.10206307f, 0.17955242f, 0.04821840f, 
    0.08338238f, -0.09308209f, -0.06846950f, 0.00788296f, -0.10046539f, -0.09939925f, -0.02721331f, 0.00010676f, 
    0.12113432f, 0.00195617f, -0.13184287f, -0.03848224f, 0.00111269f, 0.02434344f, 0.18617232f, 0.00799760f, 
    -0.20211393f, -0.03278271f, -0.05042388f, -0.27386197f, 0.12768288f, 0.23224643f, 0.19394419f, 0.01380207f, 
    -0.15095353f, -0.04200395f, -0.06511567f, -0.01538229f, 0.03676602f, 0.02902029f, -0.04546089f, 0.13083223f, 
    -0.08309935f, -0.25118181f, -0.03573466f, 0.22039549f, 0.15474258f, -0.29491013f, 0.23163338f, -0.16787390f, 
    -0.05581624f, -0.04975616f, 0.00267718f, 0.11013167f, 0.02960531f, -0.00346668f, -0.08354157f, -0.23817882f, 
    -0.08248531f, -0.08851916f, -0.00076876f, 0.03117383f, -0.06408064f, 0.15934420f, -0.08511934f, 0.07319133f, 
    0.13622481f, 0.13338466f, 0.06507484f, 0.00821486f, -0.11461882f, -0.05433438f, 0.05419284f, -0.06216306f, 
    -0.00990685f, 0.06242077f, 0.06022482f, -0.00323067f, 0.14996612f, -0.24800988f, 0.27968615f, 0.21385348f, 
    -0.04394095f, 0.09422830f, -0.11820828f, -0.05821121f, 0.13502480f, 0.03168942f, 0.00496414f, -0.02800457f, 
    0.02694741f, 0.06461252f, -0.03927013f, -0.11909600f, -0.11633917f, -0.01134465f, 0.11279097f, -0.04871414f, 
    -0.08688565f, -0.06073126f, 0.00558134f, -0.08969502f, -0.12741210f, -0.22339232f, -0.15407549f, -0.17299640f, 
    0.08485535f, 0.08115486f, 0.11198156f, 0.03345234f, -0.04869027f, -0.07770833f, -0.07849844f, 0.04471242f, 
    -0.08930441f, -0.24771324f, 0.21489653f, -0.18612923f, 0.03268335f, 0.06987819f, -0.07769180f, 0.01256378f, 
    0.14909685f, 0.07443772f, 0.08389185f, 0.09363369f, 0.02657360f, 0.25535992f, -0.11182323f, -0.14687435f, 
    0.18082660f, -0.07330523f, 0.03620845f, -0.08038811f, 0.08846258f, 0.02291614f, 0.10966602f, 0.14093520f, 
    0.07009747f, 0.18467471f, 0.15315865f, 0.01258476f, 0.01324736f, -0.12103982f, -0.10933074f, -0.06029091f, 
    -0.03009196f, 0.02971145f, -0.06774805f, 0.02410167f, 0.28859630f, 0.07882605f, 0.28125960f, 0.19568095f, 
    -0.11852086f, -0.23359144f, -0.07982294f, 0.13872235f, 0.15601751f, 0.02901105f, 0.02088282f, 0.11149662f, 
    0.21447697f, 0.00732288f, 0.05888470f, -0.01009403f, -0.07043288f, -0.14095452f, -0.08155264f, -0.11126336f, 
    0.17847279f, -0.02918328f, -0.17277884f, 0.00524473f, 0.06910314f, 0.08663184f, 0.12895650f, 0.05359566f, 
    -0.07844143f, -0.00331340f, -0.00454930f, 0.19705224f, 0.07260854f, 0.00369298f, 0.06231557f, -0.01031102f, 
    0.08860406f, -0.02404237f, -0.02828855f, 0.09006564f, -0.09587801f, -0.17902254f, 0.07747645f, -0.13437463f, 
    0.04211171f, 0.14154480f, -0.00638332f, 0.01953380f, 0.08505579f, -0.41991615f, 0.15481442f, -0.18340948f, 
    0.04428931f, 0.03350866f, -0.09417718f, -0.04362484f, -0.04789311f, 0.06327131f, 0.05263938f, 0.07580947f, 
    0.13276550f, 0.17126316f, 0.08285715f, -0.07062400f, -0.08660774f, -0.06494809f, 0.05224807f, 0.10257894f, 
    0.11247890f, -0.02910825f, 0.05890824f, -0.08019143f, -0.03589451f, -0.09356753f, -0.06300320f, 0.08648602f, 
    0.08586017f, 0.00472950f, -0.03133552f, 0.01533633f, 0.10063604f, 0.16275559f, 0.07848587f, 0.12134298f, 
    0.06189841f, 0.00671123f, -0.10099954f, 0.04466584f, 0.13156393f, -0.15222444f, 0.06172806f, 0.04192154f, 
    -0.15629531f, 0.05164741f, -0.25829348f, -0.17232084f, -0.01798401f, -0.17600623f, 0.10035699f, -0.03469436f, 
    0.08566830f, 0.11469317f, 0.13867000f, 0.20535134f, -0.16581404f, -0.25614256f, -0.03313645f, -0.17149006f, 
    0.07197134f, -0.05128174f, 0.06274208f, 0.20166968f, 0.04208790f, -0.02918566f, -0.01480998f, 0.05871004f, 
    0.01641983f, -0.02684097f, 0.06384499f, 0.06366906f, 0.24252443f, 0.17133620f, -0.16373102f, -0.07591684f, 
    0.21728410f, 0.10852376f, 0.00077741f, -0.00521196f, 0.05215756f, 0.08466670f, -0.08544803f, 0.06353063f, 
    -0.07131683f, 0.00059411f, -0.09497827f, 0.08018973f, -0.03277396f, -0.06113550f, -0.01529622f, -0.08925530f, 
    0.15706596f, -0.11166220f, 0.08618119f, 0.07842964f, -0.10362600f, -0.04959097f, 0.10695101f, 0.06970336f, 
    -0.03654544f, -0.14630677f, -0.06500986f, 0.07695901f, -0.04812950f, 0.01780348f, -0.00550794f, 0.05850635f, 
    -0.12569763f, -0.07496826f, 0.10017779f, -0.15089121f, -0.03447917f, 0.14413492f, 0.03952907f, 0.09653580f, 
    0.09184412f, 0.07991255f, 0.01261935f, -0.01436995f, 0.15726554f, 0.13831885f, 0.07917419f, -0.03746751f, 
    0.00955809f, 0.04992599f, 0.13979457f, -0.06900565f, 0.12399684f, -0.00508468f, -0.08836875f, -0.03678616f, 
    0.18196158f, -0.07155106f, -0.12270013f, -0.22586130f, 0.05128589f, -0.09840341f, -0.29649666f, -0.01964363f, 
    0.09147336f, -0.03921979f, 0.04957942f, -0.13273679f, -0.03046721f, 0.07365690f, 0.10733238f, 0.06814623f, 
    0.12851474f, 0.06255338f, 0.00842477f, -0.01339496f, -0.02380159f, 0.05829479f, -0.01145863f, 0.03446432f, 
    -0.17104398f, 0.13868448f, 0.01664692f, 0.09015445f, -0.05192939f, 0.09635315f, 0.09261037f, 0.19294569f, 
    -0.00881284f, 0.09491127f, 0.04474458f, 0.00278840f, 0.22647424f, 0.26060075f, -0.09181501f, -0.25035155f, 
    -0.00048514f, -0.03551286f, -0.01752050f, -0.16416380f, 0.23562925f, 0.03137663f, 0.03744804f, -0.01553277f, 
    0.20581876f, 0.08270342f, -0.23227106f, -0.08550689f, -0.12523155f, 0.02399889f, 0.06505606f, 0.09956393f, 
    -0.23925309f, -0.10417838f, -0.00134174f, 0.17970064f, -0.00003346f, -0.07666899f, 0.08536588f, 0.04601581f, 
    -0.17024866f, -0.23887517f, -0.04594202f, 0.04431492f, -0.10700497f, 0.01678401f, 0.01464616f, -0.07311857f, 
    0.19001800f, 0.02004252f, -0.04298434f, 0.11373842f, 0.13999498f, -0.14579584f, 0.02290760f, -0.09743906f, 
    0.19991525f, -0.01454305f, -0.09864332f, -0.08776750f, -0.09109784f, 0.06482045f, 0.26286364f, 0.40232778f, 
    0.00419444f, 0.09919444f, 0.00514725f, 0.16155241f, -0.02702359f, 0.07727575f, -0.00943661f, 0.02451802f, 
    0.03052643f, 0.01307331f, 0.15503874f, -0.03246569f, 0.24207124f, 0.00259404f, 0.06301685f, -0.01257050f, 
    -0.00376828f, -0.07232481f, 0.01952296f, 0.06221690f, 0.04069934f, -0.01333250f, -0.00900946f, 0.08002713f, 
    0.06436794f, 0.08731662f, 0.06652629f, -0.06892755f, 0.10480540f, 0.03642541f, -0.07521205f, -0.07535883f, 
    -0.22486885f, -0.00454407f, -0.17297134f, 0.04178817f, 0.13798624f, 0.08566760f, -0.09460071f, -0.08791966f, 
    -0.02442909f, -0.01277389f, 0.00373604f, 0.07463992f, 0.16653405f, 0.02808401f, 0.12668370f, -0.15886597f, 
    -0.12792687f, 0.08260259f, 0.10919631f, -0.04215044f, 0.12555268f, -0.06633905f, 0.03968335f, -0.16012144f, 
    -0.08587380f, -0.05153887f, -0.29025945f, -0.04354491f, -0.07742223f, 0.03328358f, 0.04181685f, -0.07813485f, 
    -0.08797471f, -0.05436448f, 0.00868901f, 0.02796821f, -0.21404926f, 0.16350530f, -0.23029792f, 0.08686598f, 
    -0.02589780f, -0.02373911f, 0.02284471f, -0.01539444f, 0.00178529f, -0.00066289f, 0.01632690f, 0.05022332f, 
    -0.03825128f, -0.17793077f, 0.07643483f, -0.37380609f, -0.09745435f, -0.00961229f, 0.09155726f, -0.22170205f, 
    0.04581170f, 0.00464918f, 0.02466287f, -0.11898395f, 0.04743560f, -0.02684998f, 0.02584084f, -0.01649070f, 
    -0.04199675f, 0.06528861f, -0.01111225f, -0.06925835f, 0.16241150f, 0.03826839f, -0.10393864f, -0.08360597f, 
    -0.10644289f, -0.05042981f, 0.10364631f, -0.18111257f, 0.19452785f, 0.14567783f, 0.04795463f, -0.17306820f, 
    -0.17282112f, 0.17220317f, -0.14069562f, 0.02248140f, 0.07668399f, -0.01948285f, 0.09278898f, 0.11481017f, 
    0.00109022f, 0.08701728f, 0.01971104f, 0.07629334f, 0.00639427f, -0.08839749f, -0.04516470f, -0.01247391f, 
    0.17756791f, 0.14219700f, 0.00182211f, -0.12669247f, 0.06118955f, -0.06415139f, -0.01407720f, 0.03185735f, 
    0.02344104f, -0.04322468f, 0.00521927f, 0.06414497f, -0.08346527f, -0.26342395f, -0.08807294f, 0.03816878f, 
    -0.02090192f, -0.12804052f, -0.16607331f, 0.08543868f, -0.00295321f, -0.12769280f, 0.03964343f, -0.03987189f, 
    0.20847285f, 0.01375521f, 0.11355294f, 0.08044100f, -0.03086394f, 0.08475582f, 0.03406453f, 0.09310744f, 
    -0.03158767f, 0.08061712f, -0.12022666f, -0.12644035f, -0.16900179f, -0.21993902f, -0.10553598f, 0.02395993f, 
    0.03178074f, -0.21994680f, 0.02343844f, -0.04598630f, 0.03646772f, 0.06874666f, -0.07446323f, 0.00090242f, 
    -0.06179439f, 0.04392811f, 0.06762178f, -0.12824388f, 0.06940556f, -0.00870704f, -0.00552105f, -0.05495532f, 
    -0.10499994f, -0.05876948f, -0.02487044f, 0.00738358f, 0.13588965f, -0.05196546f, 0.07581118f, -0.11552856f, 
    -0.11967682f, -0.04348390f, -0.04294929f, -0.00670082f, -0.27456582f, -0.16518082f, -0.07561002f, -0.04932349f, 
    -0.03527037f, -0.04082434f, 0.08959664f, 0.00034959f, -0.00036265f, -0.15448540f, -0.07888819f, -0.07318160f, 
    0.04109470f, -0.01824328f, 0.07570435f, -0.06327687f, 0.05636645f, 0.10627992f, -0.06356084f, -0.12863502f, 
    0.07847035f, -0.12415701f, -0.08224502f, -0.07150684f, 0.03801077f, -0.01069965f, 0.07861809f, 0.00455454f, 
    -0.21531378f, -0.54764956f, 0.09478781f, 0.35439032f, 0.16602391f, 0.15121546f, 0.10112768f, 0.02629815f, 
    -0.16854267f, -0.18013757f, -0.05216403f, 0.03732125f, 0.06512568f, 0.07716572f, -0.03070403f, 0.01010117f, 
    0.22917581f, 0.06958457f, 0.10284314f, 0.01596794f, 0.04104214f, 0.02068466f, -0.10975911f, 0.17898551f, 
    0.01228659f, -0.04476204f, 0.13154499f, 0.13311327f, 0.07223321f, -0.05753689f, -0.01856077f, -0.36750868f, 
    -0.18217361f, -0.25790587f, -0.06850830f, -0.19928589f, 0.10236382f, -0.21706590f, -0.16275875f, -0.02330737f, 
    -0.01801375f, -0.06466379f, -0.04713615f, 0.01621789f, -0.16151756f, -0.08465011f, -0.16159365f, -0.17476773f, 
    0.04962024f, 0.32447469f, 0.22105137f, 0.19183880f, -0.19683033f, -0.01466257f, 0.10105064f, 0.14718370f, 
    0.01349111f, 0.09100565f, 0.01318349f, 0.17277437f, -0.14917260f, 0.17684221f, -0.06836025f, 0.02948743f, 
    -0.08294372f, 0.10830697f, 0.10839591f, 0.04975615f, 0.16723301f, -0.02187931f, 0.02748801f, 0.22385652f, 
    -0.03700906f, 0.14662790f, 0.06002752f, -0.04647954f, 0.07446177f, 0.03753723f, -0.22244778f, -0.10609160f, 
    -0.08373163f, -0.17364199f, -0.03613980f, -0.28072205f, -0.07290745f, -0.24533801f, -0.20056203f, 0.00413877f, 
    0.12469755f, 0.03753826f, 0.08800460f, -0.03505163f, -0.03794214f, 0.02617712f, -0.03051642f, 0.01468810f, 
    0.41971210f, 0.17107370f, -0.13342139f, 0.29635996f, -0.18273267f, -0.01916823f, 0.02122699f, 0.25996321f, 
    0.04578495f, 0.13560995f, -0.02089561f, 0.05313800f, -0.34824884f, 0.27539083f, 0.18862763f, 0.35420188f, 
    -0.04284740f, -0.15269390f, 0.17172360f, -0.19974796f, 0.00531919f, 0.06472522f, 0.03937952f, 0.06556188f, 
    0.14375515f, 0.05420936f, -0.06934382f, 0.04197113f, -0.00111167f, -0.06655847f, -0.11010753f, -0.10517224f, 
    0.06517115f, 0.11898451f, 0.24359724f, 0.30738851f, -0.01937107f, -0.09271415f, -0.02913160f, -0.18498416f, 
    -0.06222821f, -0.09919515f, -0.22871469f, 0.03231484f, -0.24249099f, -0.03699964f, -0.08320368f, -0.21591271f, 
    0.11978213f, 0.20122904f, -0.27901775f, 0.42170891f, 0.05470885f, -0.03444828f, -0.03030207f, 0.00126515f, 
    -0.06740662f, -0.11600003f, 0.01955654f, -0.46784362f, -0.06185934f, 0.07750396f, 0.35631481f, 0.44173226f, 
    0.05680707f, -0.00689443f, -0.04354059f, -0.01828175f, -0.03428876f, 0.02631846f, -0.01686520f, 0.16567402f, 
    -0.18388402f, -0.30063689f, 0.05385822f, -0.22342147f, 0.22370026f, -0.17173512f, 0.14114229f, -0.15635017f, 
    -0.04226760f, -0.04755304f, -0.05220381f, -0.10746640f, -0.16356541f, -0.18238835f, 0.04745089f, 0.04534439f, 
    0.06990731f, -0.11787114f, 0.01378209f, -0.01905223f, -0.01331118f, 0.16593356f, 0.15771820f, -0.01379841f, 
    -0.06430074f, -0.11470920f, -0.12361509f, 0.01822500f, 0.04612400f, -0.23721725f, -0.07731116f, 0.05782992f, 
    -0.10139348f, -0.12538798f, -0.04479440f, -0.02060526f, 0.01826957f, 0.25376946f, 0.04894226f, -0.04392745f, 
    -0.05506831f, 0.05165112f, 0.01813602f, 0.11423406f, 0.05580688f, 0.03649218f, 0.12746133f, 0.02884910f, 
    0.04712268f, -0.01188112f, -0.12256882f, -0.05068102f, -0.21275534f, -0.09958006f, 0.07560704f, 0.02639141f, 
    -0.08378516f, 0.08853327f, -0.02620075f, -0.16025141f, -0.15491883f, -0.19587313f, 0.07852449f, 0.30181965f, 
    0.02862146f, 0.21195567f, 0.09838942f, 0.04331972f, 0.07948723f, -0.10302477f, -0.09552789f, 0.17778434f, 
    -0.26369816f, 0.02766609f, -0.17358708f, -0.17240760f, -0.00251711f, 0.12422225f, 0.01967148f, 0.03712417f, 
    0.10020134f, 0.08472576f, 0.09053993f, 0.13282870f, 0.18270656f, 0.07720556f, -0.07804572f, 0.25745079f, 
    0.08764949f, 0.15684202f, 0.14830841f, 0.02080893f, 0.31965074f, 0.13835022f, 0.20684582f, 0.20784327f, 
    0.18184997f, 0.09651519f, 0.46936330f, 0.30028608f, 0.04564882f, -0.21046758f, 0.09286302f, -0.13538441f, 
    -0.18136238f, 0.16941172f, -0.03658066f, -0.06274839f, 0.02432693f, 0.21681596f, 0.09299502f, -0.13898453f, 
    -0.14098144f, -0.02962366f, -0.09581925f, 0.14476572f, 0.12436786f, -0.10457432f, 0.00827991f, 0.15093948f, 
    -0.21266380f, -0.01178425f, 0.20204730f, -0.04120449f, 0.18344790f, -0.07129440f, 0.06089238f, -0.12568963f, 
    0.14952989f, -0.18051827f, -0.06457809f, 0.01046807f, -0.03034463f, -0.11379012f, -0.15103479f, -0.12786393f, 
    -0.07575648f, 0.03428800f, -0.00498910f, 0.15093204f, 0.07698965f, -0.10348604f, -0.10220344f, 0.01724697f, 
    0.17955208f, -0.08489725f, -0.01237695f, -0.07224253f, 0.00469528f, 0.04781549f, -0.10089352f, 0.08677198f, 
    -0.01478561f, -0.00948927f, 0.17484175f, 0.04576003f, -0.19256988f, -0.14281127f, -0.05525074f, 0.26426363f, 
    0.25291494f, -0.01802922f, -0.04056620f, -0.03077180f, 0.03253262f, -0.10461953f, 0.08875746f, 0.02366903f, 
    0.06066179f, 0.01305172f, 0.10081418f, 0.08993623f, 0.04540337f, -0.00335072f, 0.08383443f, 0.11410723f, 
    0.11544114f, -0.09467977f, 0.12070150f, -0.06185475f, 0.36035141f, -0.15300402f, -0.04740533f, -0.07319204f, 
    -0.01706321f, -0.01752992f, 0.08652652f, 0.06447178f, 0.14177550f, 0.11767250f, 0.28236702f, 0.26145175f, 
    -0.18106516f, 0.04536359f, -0.04068062f, 0.07196176f, -0.02555934f, -0.09351603f, -0.04865295f, 0.08837883f, 
    -0.26591107f, -0.28230792f, -0.21229587f, -0.52856457f, -0.30909827f, 0.05791188f, -0.22885311f, 0.11516855f, 
    0.13988616f, 0.03661513f, -0.18059880f, -0.17070045f, -0.35000107f, -0.27672443f, 0.06665611f, -0.27731785f, 
    0.65218854f, -0.13937162f, 0.17557688f, -0.06519303f, 0.09440000f, 0.13851988f, 0.05907570f, 0.05681260f, 
    -0.14909503f, -0.01809709f, -0.07170220f, -0.29907289f, -0.09898157f, -0.34320998f, -0.09724183f, 0.04962417f, 
    0.05278997f, -0.09848817f, 0.09804607f, 0.03333455f, 0.19790651f, 0.04935731f, -0.17248440f, 0.07010271f, 
    -0.23854962f, 0.03088879f, -0.03846937f, 0.08813492f, 0.04587651f, -0.02503595f, -0.18287764f, -0.02736831f, 
    0.02557550f, -0.08721207f, -0.18639079f, -0.20068574f, 0.02847193f, 0.10715915f, 0.02170487f, -0.09034389f, 
    0.13409521f, -0.04608271f, -0.08901742f, -0.20291606f, -0.28437465f, -0.21503900f, -0.40521577f, -0.35146654f, 
    0.44913650f, 0.10817170f, -0.10971506f, 0.15527442f, -0.10764018f, -0.07213277f, -0.11190149f, -0.10935568f, 
    0.10181879f, 0.04441942f, -0.12010964f, 0.13032144f, 0.05491693f, -0.09804904f, 0.02747849f, -0.19571704f, 
    -0.03696989f, 0.03338399f, -0.00795234f, 0.05009579f, 0.07749680f, 0.07906780f, -0.01051953f, 0.13369800f, 
    -0.13607651f, 0.05916843f, -0.23319073f, 0.07140937f, -0.04907774f, 0.15033069f, 0.05469967f, 0.02896363f, 
    0.03462211f, -0.18295743f, -0.12032752f, -0.17508559f, 0.25466201f, -0.12441503f, -0.17930560f, 0.21536809f, 
    0.02232145f, 0.18197371f, 0.15675251f, -0.03327759f, -0.00441294f, -0.10343748f, 0.01129229f, -0.03815075f, 
    0.47233263f, -0.28117850f, 0.25773194f, -0.00387261f, 0.02520124f, -0.03856441f, -0.18896829f, -0.08142376f, 
    0.05541563f, 0.17409562f, 0.00327541f, 0.13552798f, -0.06118595f, -0.37093350f, -0.06385526f, -0.12027445f, 
    0.14814782f, -0.10554453f, -0.00118160f, 0.24264517f, -0.12609097f, -0.10798553f, -0.14068922f, -0.12796746f, 
    0.04651651f, 0.13229932f, 0.21924154f, 0.10490591f, 0.11164610f, 0.00979245f, 0.01423967f, -0.15149465f, 
    0.05620748f, 0.03327050f, 0.17152695f, 0.24291082f, 0.21760996f, -0.14653152f, 0.32242042f, -0.19242215f, 
    0.12865274f, 0.05283518f, -0.22726591f, 0.01616331f, -0.06509702f, -0.20637493f, -0.29249001f, -0.34049726f, 
    -0.29456654f, 0.16310957f, -0.16648908f, -0.42164442f, 0.03864683f, -0.01079986f, 0.05743212f, 0.06088335f, 
    0.00616963f, -0.18988243f, -0.00848647f, -0.30999294f, 0.00021309f, 0.06314935f, 0.02148934f, -0.15688747f, 
    0.06419327f, 0.00156396f, -0.06600703f, -0.03937845f, 0.15440600f, 0.07902594f, 0.00609562f, 0.12494817f, 
    0.07228724f, -0.17553979f, -0.00612920f, 0.02839383f, 0.05115325f, 0.14029950f, -0.07393418f, -0.05462201f, 
    0.02260809f, -0.01064884f, -0.09488364f, -0.19065161f, -0.31904608f, 0.01580765f, -0.20456696f, 0.25171971f, 
    -0.03052300f, 0.00567007f, 0.14410006f, -0.02638310f, 0.15856187f, 0.14756230f, 0.19171537f, 0.02866162f, 
    0.23490825f, 0.23255062f, 0.19443142f, -0.02806632f, 0.02999777f, -0.04256345f, 0.08861294f, 0.11651660f, 
    0.07292941f, 0.01283973f, 0.11909746f, -0.00604763f, -0.04785352f, -0.21281140f, -0.19055845f, 0.13408075f, 
    0.09448382f, -0.00931386f, -0.14797649f, -0.13572834f, -0.02810788f, -0.03892645f, 0.01122861f, 0.08439539f, 
    0.07313354f, 0.05375123f, 0.10421912f, -0.00777260f, 0.06813894f, -0.09244360f, 0.01687466f, 0.06921516f, 
    -0.10953293f, 0.05407241f, -0.11541001f, -0.12143211f, 0.39698032f, -0.21756457f, 0.41066590f, 0.00325897f, 
    0.14058788f, 0.03571539f, 0.07850055f, 0.14959389f, -0.08699131f, -0.09818643f, -0.22330447f, -0.04373892f, 
    -0.11340196f, 0.09335940f, -0.20461722f, 0.09997529f, 0.09126451f, 0.04505817f, 0.02393182f, 0.22669744f, 
    0.07092246f, -0.04564875f, 0.08198861f, 0.25943193f, 0.00285470f, 0.29870763f, -0.13974239f, 0.29660469f, 
    -0.04360870f, -0.06786831f, 0.09171104f, 0.00900466f, 0.14030893f, 0.14312735f, 0.22238025f, 0.10869841f, 
    0.20793885f, 0.04337838f, 0.25544548f, 0.07276807f, 0.00587406f, 0.07973920f, 0.05727487f, -0.08655154f, 
    0.04746057f, 0.13639967f, 0.01205183f, -0.04781695f, -0.03580460f, -0.03719097f, -0.09921562f, 0.18271439f, 
    0.07100768f, -0.03713243f, -0.13361189f, -0.05729169f, 0.07442050f, 0.09748998f, 0.10214001f, 0.07281957f, 
    -0.08511288f, -0.18614368f, 0.09958144f, 0.13524169f, 0.11358232f, 0.01465600f, 0.02180716f, -0.10100071f, 
    0.12513451f, -0.00325378f, -0.11396814f, -0.01675300f, 0.35713264f, 0.25650021f, 0.02700596f, -0.15534586f, 
    -0.08219621f, 0.08596759f, 0.14972442f, 0.01870608f, 0.15503159f, -0.10893627f, -0.14470983f, 0.07770317f, 
    -0.12671863f, -0.17549972f, -0.16761222f, 0.17834900f, -0.18238604f, 0.01249948f, 0.10403467f, -0.05045687f, 
    -0.09283163f, 0.04435908f, 0.07713063f, 0.17739962f, 0.11442083f, 0.02068456f, 0.05939044f, 0.08115283f, 
    0.01360782f, 0.10383502f, -0.02330116f, 0.02558826f, -0.12322050f, -0.01873561f, 0.08218893f, 0.01706924f, 
    0.39705902f, 0.21766813f, 0.18066278f, 0.08561172f, 0.02790553f, -0.03073678f, 0.06883592f, 0.07091781f, 
    0.08640304f, 0.12279151f, 0.21689057f, -0.13842595f, -0.11168120f, 0.07156713f, 0.01173022f, 0.16384393f, 
    -0.04348678f, 0.14747946f, -0.00835781f, 0.05540878f, 0.10868268f, 0.08182143f, 0.17538004f, 0.15865025f, 
    -0.04065649f, 0.15578368f, -0.20424968f, 0.15913945f, 0.10379515f, 0.04323073f, -0.10048960f, 0.07717114f, 
    -0.28939572f, -0.17476062f, -0.20895700f, -0.56143576f, -0.06617266f, 0.10962368f, -0.15015897f, 0.24246167f, 
    0.06776653f, 0.12790439f, -0.10046580f, -0.26221830f, -0.26909691f, -0.25852057f, -0.33553371f, -0.29002070f, 
    -0.12056450f, -0.07707535f, 0.04266422f, -0.09167261f, -0.04234659f, 0.07543098f, 0.00554283f, 0.03423421f, 
    0.02401385f, -0.04134861f, 0.02930834f, -0.08913460f, -0.20519409f, 0.22656187f, -0.06630903f, 0.17329076f, 
    0.23661691f, -0.09460271f, 0.12694548f, 0.04661130f, -0.06719566f, 0.05355094f, -0.23253921f, 0.19083697f, 
    0.07714918f, 0.00751172f, 0.17888175f, -0.10641125f, -0.11261223f, 0.04042138f, -0.00474101f, 0.06404240f, 
    -0.02762848f, -0.01584185f, 0.08472294f, -0.12339354f, 0.04222656f, -0.01565310f, -0.02903491f, -0.07153136f, 
    0.02151493f, 0.13626201f, -0.01099056f, 0.01613854f, 0.00102601f, -0.03021225f, 0.04574771f, -0.02719370f, 
    0.25179809f, 0.23686941f, 0.33367988f, 0.22289339f, -0.02582511f, 0.02777305f, -0.01409619f, -0.00596772f, 
    -0.03056363f, 0.08219629f, 0.10490419f, 0.18609047f, 0.00054344f, 0.15139440f, 0.04427645f, 0.00611139f, 
    -0.08544149f, -0.04321209f, 0.01417477f, 0.11695769f, -0.06478038f, -0.03624947f, 0.03950156f, 0.00400607f, 
    -0.08168139f, 0.10972577f, 0.16340975f, -0.21087945f, -0.07981163f, -0.02390108f, 0.10674705f, 0.06733885f, 
    -0.13868168f, -0.04114804f, 0.13436578f, 0.00804818f, -0.12108556f, 0.01498623f, -0.09857515f, -0.09139009f, 
    -0.06955205f, 0.11255205f, 0.05466988f, 0.04149273f, -0.06657811f, -0.01854549f, -0.05826198f, -0.05587291f, 
    0.18395282f, 0.43702924f, -0.17695154f, -0.03674851f, 0.11851919f, 0.01384753f, 0.06246717f, -0.16172722f, 
    0.13221258f, -0.04150647f, -0.08484157f, 0.09399457f, -0.26338375f, 0.15225369f, 0.30395734f, 0.13651468f, 
    0.04068866f, 0.00003507f, 0.00261600f, 0.08660995f, 0.05323469f, 0.03962254f, 0.02954722f, 0.14713839f, 
    0.12108415f, 0.06419543f, -0.20758478f, -0.10454538f, 0.01607068f, -0.01870533f, -0.00222817f, -0.10930711f, 
    -0.14697126f, -0.08612529f, -0.03139356f, 0.03283058f, 0.05411594f, 0.02361406f, -0.18627711f, -0.00975174f, 
    0.14130335f, -0.04533404f, -0.15414152f, 0.19373858f, -0.03518394f, 0.01525347f, 0.03238042f, 0.04024420f, 
    -0.11661614f, 0.05925046f, 0.07134690f, 0.00454065f, -0.09349695f, -0.08434103f, 0.18164371f, 0.07504064f, 
    -0.13910918f, -0.04006454f, 0.00688795f, 0.00461557f, 0.18611287f, 0.05550671f, 0.16663305f, 0.10735084f, 
    -0.03413097f, -0.00548888f, 0.02029482f, 0.15007758f, -0.04857022f, 0.01666160f, -0.00539785f, -0.05715083f, 
    -0.09452407f, -0.18324356f, -0.06721383f, 0.07993392f, -0.11097105f, 0.01553516f, 0.15287568f, -0.00874953f, 
    0.06647836f, 0.00906154f, -0.00027160f, -0.09578346f, -0.46661505f, -0.04351795f, 0.31613559f, -0.18917038f, 
    -0.07830303f, -0.10506242f, -0.07234458f, 0.01729047f, -0.12644665f, -0.02999611f, -0.16289556f, 0.03079692f, 
    -0.16711895f, -0.34081289f, -0.38607267f, -0.35715175f, -0.04080935f, -0.20870860f, -0.11587586f, 0.08999662f, 
    -0.06832890f, -0.04636149f, -0.00043726f, -0.11727396f, 0.19654800f, 0.17429462f, 0.32746458f, 0.14969252f, 
    -0.00102395f, 0.02009830f, 0.03643738f, 0.03988456f, -0.08751146f, 0.18845601f, 0.09652922f, -0.06159462f, 
    0.01607290f, -0.03328168f, -0.24142003f, 0.03826502f, -0.00187463f, -0.14173672f, 0.09651241f, 0.13933443f, 
    0.00454788f, -0.03137661f, 0.13567021f, -0.10431320f, -0.29972485f, -0.02514618f, -0.38112307f, -0.01844138f, 
    0.05113458f, -0.00746275f, -0.05876374f, -0.16995271f, -0.03686856f, -0.02238247f, -0.08645033f, 0.05028164f, 
    0.10422350f, -0.34500495f, 0.24950361f, 0.16722837f, -0.11944099f, -0.05976558f, 0.09196229f, -0.07023479f, 
    0.05278802f, 0.04602067f, 0.04063667f, 0.15275136f, -0.13039215f, -0.01155279f, 0.05229476f, -0.12177986f, 
    0.02193603f, -0.10838751f, 0.10720534f, -0.03800102f, -0.10549345f, 0.17992817f, 0.01157963f, 0.05547027f, 
    0.04648798f, 0.18747538f, 0.06038324f, 0.13242882f, 0.05863212f, -0.10038185f, -0.00461935f, 0.04954539f, 
    -0.10389714f, 0.05855839f, -0.03784186f, 0.11681216f, -0.19346003f, 0.12461726f, 0.20231380f, 0.07326108f, 
    0.03083896f, -0.03611529f, 0.04859916f, -0.10157252f, 0.01947545f, 0.20283429f, 0.07881355f, 0.02523826f, 
    -0.09916477f, -0.05422513f, 0.06087531f, 0.09365967f, 0.01622253f, 0.02486572f, 0.09258925f, 0.03143543f, 
    0.02088355f, 0.01080506f, -0.03282134f, 0.00111422f, -0.18459168f, -0.28267881f, -0.18104188f, -0.12775266f, 
    -0.11616367f, 0.02054542f, -0.00614519f, 0.07366409f, -0.05024045f, -0.03339249f, -0.03513282f, -0.05859210f, 
    0.01768607f, 0.08268157f, 0.14481500f, 0.09828570f, -0.03511046f, -0.11305326f, -0.06233000f, -0.08686934f, 
    -0.06697021f, 0.27912575f, 0.21297111f, 0.07032660f, 0.15560979f, -0.30511934f, 0.04921703f, 0.23293841f, 
    0.07718625f, 0.01220218f, 0.09065830f, -0.01499404f, -0.06506409f, -0.01172867f, 0.10480843f, 0.02477345f, 
    -0.33927295f, -0.23535763f, -0.23470247f, -0.26415065f, 0.01576627f, 0.04035726f, 0.09277509f, 0.06961148f, 
    -0.09008031f, -0.02209594f, -0.04477204f, -0.06050182f, 0.22409020f, -0.12909222f, -0.11443426f, 0.06457318f, 
    -0.10029282f, 0.06326599f, 0.10053100f, 0.02238838f, -0.02459283f, 0.14514881f, 0.08607049f, 0.09999798f, 
    0.03304001f, -0.01937494f, -0.07625674f, -0.10855177f, -0.01535898f, -0.16139558f, 0.15123764f, 0.01960127f, 
    0.04657316f, 0.05712572f, 0.06238420f, -0.00367039f, -0.12432744f, -0.05738533f, 0.08717390f, -0.03860784f, 
    -0.06578230f, 0.03135041f, 0.07229456f, -0.02715622f, -0.04965388f, 0.01413548f, 0.02625508f, 0.02720362f, 
    -0.03501985f, 0.01858002f, -0.05225912f, -0.03892452f, 0.04374071f, 0.00250894f, 0.00512558f, -0.03287144f, 
    -0.05639663f, -0.01375670f, 0.00909445f, 0.02642014f, 0.00472070f, -0.03258665f, -0.02961045f, 0.01526555f, 
    0.02509728f, 0.01035098f, -0.02462716f, -0.04395782f, -0.02486754f, 0.04208731f, 0.04195988f, -0.01786622f, 
    -0.03820321f, 0.03545609f, -0.01472199f, -0.05351869f, 0.02562873f, 0.00166121f, -0.05018682f, -0.05264809f, 
    0.01289823f, 0.03545518f, 0.01596244f, 0.00697353f, 0.01046115f, -0.03093393f, -0.02882052f, -0.01915258f, 
    0.01267657f, -0.01200228f, 0.00759338f, 0.00599674f, -0.00246387f, -0.04073169f, -0.03814088f, 0.03109748f, 
    0.03945734f, -0.03089623f, -0.05551480f, -0.01795818f, -0.01538790f, 0.03165503f, -0.04465802f, -0.02207493f, 
    -0.03876974f, 0.00841211f, -0.05099291f, 0.01051171f, 0.02211229f, -0.05517308f, 0.00150857f, 0.01367831f, 
    0.02647518f, 0.00541508f, -0.01236035f, -0.02190560f, 0.03649294f, -0.03820822f, -0.00879876f, 0.03763540f, 
    0.04271566f, 0.02860525f, -0.03219289f, -0.03645992f, 0.04045194f, -0.05232524f, -0.02270105f, 0.01480010f, 
    0.03976768f, -0.01609159f, 0.02331267f, -0.04092979f, -0.00955394f, -0.03552174f, -0.01606546f, -0.04819465f, 
    -0.03026029f, 0.04434647f, -0.02693088f, -0.01401520f, 0.04030999f, -0.04909893f, 0.03498925f, -0.00994756f, 
    -0.02991754f, -0.03401168f, -0.05269229f, -0.04245992f, -0.05355846f, 0.03223393f, -0.04267555f, 0.00096031f, 
    -0.03684746f, -0.00536583f, -0.00712129f, -0.05139123f, -0.04726826f, -0.04052984f, -0.01444843f, 0.01970734f, 
    -0.05677064f, 0.01603865f, 0.00846454f, -0.05239678f, -0.03042238f, 0.01027286f, 0.02190390f, -0.01513659f, 
    0.03631653f, -0.01182417f, 0.00495790f, 0.01905743f, -0.00327512f, 0.01170199f, -0.01322936f, 0.04667522f, 
    0.02602929f, 0.00309114f, 0.02131574f, 0.01220186f, 0.01509137f, -0.00139464f, -0.03821758f, -0.03305504f, 
    0.02174643f, 0.04286214f, 0.02858259f, 0.03499633f, 0.01908086f, 0.00343035f, -0.04567428f, 0.04377892f, 
    0.04221350f, 0.02312918f, 0.00669774f, 0.02135340f, 0.00357701f, -0.03448155f, -0.05267854f, -0.02719320f, 
    -0.05239456f, -0.03958624f, -0.05166245f, -0.04662837f, -0.04975621f, -0.03739404f, -0.04609272f, 0.01690686f, 
    -0.03114572f, -0.05230137f, 0.03517837f, -0.04265438f, -0.04325332f, -0.03257833f, 0.00098620f, 0.00324012f, 
    0.01708035f, -0.04897081f, 0.00171882f, 0.01590696f, -0.05671209f, -0.03596924f, -0.03855938f, 0.00617359f, 
    0.01827165f, 0.00948276f, -0.05124490f, 0.04066054f, 0.01065324f, -0.00715179f, 0.00513108f, 0.00276925f, 
    0.01383489f, 0.03590656f, -0.00079863f, -0.00374601f, 0.01262435f, 0.04284232f, 0.03593755f, -0.02309718f, 
    0.01280908f, 0.02995042f, -0.04401389f, 0.00504892f, -0.03825466f, 0.03320618f, 0.00609869f, -0.03529198f, 
    -0.01530877f, 0.00160496f, -0.03585732f, -0.04580629f, -0.05045757f, 0.04370235f, 0.02793009f, -0.01634820f, 
    -0.03447160f, 0.00302497f, -0.02930447f, -0.02023435f, -0.04727007f, 0.01063282f, 0.02829736f, 0.03397484f, 
    -0.01181332f, 0.03110641f, 0.01930353f, -0.02239811f, 0.04166051f, 0.02062262f, -0.03716297f, -0.02765776f, 
    -0.01113494f, -0.04194895f, 0.04133916f, -0.00781124f, 0.04491052f, -0.01209946f, 0.01021560f, 0.02817075f, 
    -0.03872621f, -0.04171862f, -0.01137077f, -0.03567050f, -0.01117170f, -0.04130908f, -0.04093365f, 0.00707461f, 
    -0.04958822f, -0.02110346f, -0.01108458f, 0.01216169f, 0.02544633f, 0.03655565f, 0.02779051f, -0.04370822f, 
    -0.04941176f, 0.00327543f, 0.01644714f, 0.01039999f, -0.01336912f, 0.04077176f, -0.02493467f, -0.02165165f, 
    0.04091186f, -0.04667938f, 0.02932160f, 0.00998472f, -0.00364846f, -0.02904287f, 0.00990865f, -0.05067910f, 
    -0.04678810f, 0.03994323f, -0.04996579f, 0.00872259f, 0.03770779f, -0.05541324f, -0.04990542f, -0.00843967f, 
    -0.05665554f, -0.04320886f, -0.02124507f, -0.01149070f, 0.00125715f, -0.03642275f, 0.03783373f, 0.00802228f, 
    -0.03284139f, 0.04221141f, -0.04400635f, 0.00696664f, 0.01272585f, -0.02891207f, -0.02789422f, 0.01756752f, 
    0.04411799f, 0.00917710f, 0.03634283f, -0.04715621f, 0.02279745f, -0.00875525f, -0.05696204f, -0.01302701f, 
    -0.01717675f, 0.02683313f, -0.00540867f, -0.04213354f, -0.00328288f, -0.05155858f, -0.03338119f, -0.05233590f, 
    -0.04065231f, 0.00571933f, 0.00263648f, -0.00191906f, 0.03205572f, 0.01905821f, 0.02166035f, -0.04302339f, 
    -0.00582199f, 0.03540869f, -0.00190776f, 0.00747791f, 0.00737108f, -0.05306514f, 0.02153716f, 0.05305090f, 
    0.04838869f, -0.04106914f, -0.04293525f, -0.00434784f, -0.05508521f, -0.05362237f, -0.03632195f, 0.03941240f, 
    -0.03060173f, -0.05353365f, -0.00454420f, -0.01388746f, -0.03856983f, -0.00199431f, -0.04785062f, -0.00479797f, 
    0.00932573f, 0.01000159f, 0.01141633f, -0.00983321f, 0.04371651f, -0.04150371f, -0.04226264f, 0.01072018f, 
    -0.03634637f, -0.05106661f, -0.01044292f, -0.05229834f, 0.02928746f, 0.03201057f, 0.00239637f, 0.02347433f, 
    -0.04802163f, -0.04264836f, 0.01779698f, -0.00026845f, 0.04084531f, -0.01126550f, -0.02032453f, 0.03268287f, 
    -0.03484599f, -0.02851707f, -0.01388477f, 0.04501132f, 0.01481373f, 0.03569004f, -0.05531118f, -0.03446309f, 
    0.03959834f, 0.03340902f, -0.01098554f, -0.01878231f, -0.00468766f, -0.00729372f, 0.03497779f, 0.02590950f, 
    0.03035052f, -0.04937391f, 0.03734684f, -0.04674809f, -0.03203983f, 0.02964941f, -0.01535252f, -0.03693317f, 
    -0.03395678f, -0.10392462f, -0.01859585f, 0.04070201f, 0.05145200f, -0.03346235f, -0.00387238f, 0.03446465f, 
    -0.00546979f, 0.05800368f, 0.04636145f, -0.04978826f, 0.26872575f, 0.16092595f, 0.00549588f, -0.26809561f, 
    0.13992915f, 0.09998823f, -0.04971949f, 0.09896009f, -0.17831597f, 0.07439719f, 0.07872347f, -0.04567033f, 
    0.09666438f, 0.11544095f, 0.14431268f, -0.03658868f, -0.06512045f, 0.09689351f, -0.01257662f, 0.07112651f, 
    0.03183928f, -0.05846673f, 0.03140629f, -0.11186021f, -0.11241250f, -0.01540555f, 0.08174948f, 0.07193998f, 
    -0.07514465f, 0.06037793f, 0.11740363f, 0.01968131f, -0.07975765f, -0.02515308f, 0.04307650f, -0.05950853f, 
    0.17654935f, 0.20357920f, 0.15073302f, -0.02713179f, -0.08757814f, 0.01591200f, -0.00708753f, 0.03567591f, 
    -0.03352928f, -0.00390911f, 0.01827676f, -0.02664874f, 0.19524248f, 0.10165745f, 0.18595591f, 0.00828564f, 
    -0.07414392f, 0.01116937f, -0.08578282f, -0.06159281f, 0.14866672f, 0.02313963f, 0.01492642f, -0.04379663f, 
    0.25680751f, 0.06321162f, -0.04954212f, -0.07162273f, -0.01595545f, -0.21870521f, 0.09007353f, 0.02104218f, 
    -0.03970310f, -0.13381796f, 0.01693898f, -0.00403773f, 0.02035396f, -0.05244119f, -0.01606870f, -0.04720331f, 
    -0.08365811f, -0.04844052f, -0.06916454f, -0.01218369f, -0.06609432f, 0.00553790f, 0.00334692f, 0.05951596f, 
    -0.68322182f, 0.44910121f, 0.04642197f, -0.12955755f, -0.07608085f, 0.16108574f, 0.10157681f, 0.05583039f, 
    0.18320936f, 0.00334362f, 0.05446392f, 0.04395382f, 0.52590901f, 0.29394853f, -0.07761042f, 0.01158328f, 
    -0.07677922f, -0.02089650f, 0.05328073f, -0.10330627f, 0.09525261f, 0.03632815f, -0.10335466f, -0.06481650f, 
    -0.03836616f, 0.17394947f, -0.06694514f, -0.04087182f, -0.14040144f, 0.08756879f, 0.04554012f, 0.04284330f, 
    -0.07640826f, -0.09014560f, 0.05030707f, 0.09533663f, -0.09796648f, -0.00096939f, 0.10216276f, 0.10470996f, 
    0.08828460f, -0.07466073f, 0.01478777f, -0.01183550f, -0.11406219f, 0.09910717f, 0.02396150f, -0.04394157f, 
    0.19504902f, -0.03463283f, 0.07986836f, 0.08024456f, -0.07481046f, -0.03570335f, 0.22396539f, -0.00134888f, 
    -0.00914201f, -0.01745388f, -0.03392453f, -0.08758792f, 0.07056266f, 0.10349979f, 0.10208672f, 0.06021263f, 
    -0.08645345f, -0.05907797f, -0.10973271f, -0.05345217f, -0.02566268f, -0.05142982f, -0.08768896f, -0.01097239f, 
    0.04565554f, 0.05016438f, 0.07439340f, 0.24179950f, -0.00368339f, -0.06416498f, 0.14043984f, -0.09059808f, 
    -0.03120703f, -0.06462047f, 0.03016474f, 0.07007292f, 0.22096987f, -0.13522168f, 0.01441211f, -0.10107621f, 
    -0.03760173f, -0.06267346f, -0.01546699f, 0.00463519f, 0.00232609f, 0.02327132f, -0.14340194f, 0.03922702f, 
    0.13943738f, 0.13729028f, -0.02604088f, 0.06922948f, -0.03541707f, 0.07737919f, 0.07752250f, 0.02779262f, 
    -0.08216566f, -0.02124735f, -0.05745129f, -0.01087531f, 0.17076842f, -0.04371044f, 0.20043358f, 0.05322467f, 
    -0.09746523f, 0.10769843f, -0.05687263f, 0.07238293f, 0.12495784f, 0.05447656f, -0.02581668f, -0.02994482f, 
    -0.12592641f, 0.08147358f, -0.03464082f, -0.09195293f, 0.02615364f, 0.15752527f, 0.06927539f, -0.02517005f, 
    -0.07787780f, -0.12946028f, -0.01441805f, -0.06794348f, -0.30702004f, 0.01681806f, -0.18608175f, -0.28590974f, 
    -0.09908368f, -0.00000730f, -0.10480210f, -0.05184362f, -0.07992683f, -0.02226382f, -0.06357773f, 0.02018498f, 
    -0.02052034f, -0.27250120f, 0.26531219f, -0.10542488f, -0.01923778f, -0.05235758f, -0.06723892f, -0.17001855f, 
    0.06582116f, -0.08693591f, -0.02486459f, -0.06297389f, 0.03980451f, -0.04947982f, -0.13659994f, -0.13537991f, 
    0.04893878f, -0.09709881f, -0.06873852f, -0.08656549f, 0.07871566f, -0.08294270f, 0.00935286f, 0.12302459f, 
    -0.06752431f, 0.11667170f, 0.10929173f, -0.15344930f, 0.05487271f, 0.05926807f, -0.05779921f, -0.05217420f, 
    -0.11108733f, 0.05024470f, -0.10468991f, 0.00041217f, 0.23195310f, 0.10396900f, 0.08591781f, 0.11527539f, 
    -0.09677967f, -0.06929043f, -0.01726802f, 0.03147382f, 0.02947248f, 0.02122533f, -0.06471720f, -0.03763841f, 
    0.13246457f, 0.03918463f, 0.04219304f, 0.04889649f, -0.13195676f, -0.13502260f, -0.02108886f, -0.02658375f, 
    -0.02434745f, -0.04084528f, 0.00361064f, 0.05025975f, -0.00261236f, 0.05627381f, 0.02098857f, 0.04016587f, 
    0.04386614f, 0.02978104f, -0.04374710f, 0.14015965f, -0.10695291f, -0.05847218f, 0.04128002f, -0.05329205f, 
    0.12373609f, 0.07782008f, 0.18950948f, 0.14413613f, -0.05957272f, -0.08273858f, 0.06271201f, 0.02172750f, 
    0.01363727f, 0.12646759f, -0.13187689f, 0.08039859f, 0.17471072f, -0.23706800f, 0.14893578f, -0.00355926f, 
    0.05519024f, -0.00273191f, 0.03628757f, 0.08235711f, -0.05989093f, -0.04285304f, -0.08939689f, -0.04951346f, 
    0.00969967f, 0.08066760f, -0.03157445f, 0.00316854f, 0.04622971f, -0.05766104f, 0.07342888f, 0.03287162f, 
    -0.01743619f, -0.12733524f, -0.04157300f, 0.07240913f, 0.07922535f, -0.07301753f, 0.01071023f, 0.11555515f, 
    0.00298372f, 0.03033656f, -0.00307447f, -0.00226619f, -0.01912476f, 0.07136379f, -0.11799362f, 0.05356586f, 
    0.00733207f, 0.00700917f, -0.06060633f, 0.05650952f, 0.01990017f, -0.05933206f, 0.16546491f, 0.00210752f, 
    -0.10614139f, 0.01804342f, -0.05182945f, 0.01889224f, 0.13847266f, -0.00597018f, 0.00375772f, -0.06465957f, 
    -0.00601125f, -0.00322682f, 0.15280341f, 0.03422503f, -0.02168574f, -0.05728451f, -0.04943070f, -0.04581225f, 
    0.20517190f, 0.14980248f, 0.01868837f, 0.12480419f, 0.08639354f, 0.12966955f, 0.00843302f, -0.01669858f, 
    -0.02701733f, -0.11095057f, -0.03749244f, -0.00545168f, 0.25865886f, -0.04284306f, 0.01057283f, 0.18657291f, 
    0.27500156f, 0.07732125f, 0.30173647f, 0.10467918f, -0.02245473f, 0.21321800f, 0.06782411f, 0.07228322f, 
    -0.08942635f, 0.04349368f, 0.03542383f, 0.24458121f, 0.00568006f, 0.02497344f, 0.12131188f, -0.15045275f, 
    0.15105475f, 0.01996376f, -0.06215198f, 0.14093606f, -0.02920218f, -0.01770774f, -0.07830883f, 0.07563602f, 
    0.07900748f, -0.08652758f, 0.15083840f, -0.01594135f, -0.09004165f, -0.04942842f, -0.07677604f, -0.01696524f, 
    -0.45552838f, -0.19459535f, -0.32800639f, -0.20938851f, -0.15153864f, -0.05381358f, 0.02228667f, 0.05456623f, 
    0.08898224f, 0.03848189f, 0.10864957f, 0.04266898f, -0.19045293f, -0.07839200f, -0.36128366f, -0.21391310f, 
    -0.00201936f, 0.01594402f, 0.13559641f, -0.05212385f, 0.02410424f, 0.05992909f, 0.09876388f, 0.11058097f, 
    -0.02941289f, -0.20082758f, 0.24163963f, -0.08136605f, 0.05169628f, 0.13467351f, -0.13147004f, -0.00172526f, 
    0.04049861f, 0.10422347f, -0.00975713f, 0.01870826f, 0.33161628f, 0.13440830f, 0.21861844f, 0.23259014f, 
    -0.05681735f, -0.00320651f, 0.14228939f, 0.07652426f, -0.01216857f, -0.02365127f, 0.02114417f, -0.07696054f, 
    -0.20333597f, -0.05766717f, 0.21823260f, 0.03772418f, 0.04872638f, -0.03217349f, 0.19117059f, 0.25113210f, 
    0.18941201f, 0.17712885f, 0.07112870f, -0.07364078f, 0.24648961f, -0.17500952f, -0.33966431f, 0.13166378f, 
    -0.12947506f, -0.13954504f, 0.12586972f, 0.09430824f, 0.20577770f, -0.03496229f, 0.00510347f, -0.13499530f, 
    -0.40643930f, -0.17316832f, -0.30132982f, -0.44605061f, 0.15450162f, 0.02815144f, 0.05339826f, 0.01229964f, 
    0.05523788f, 0.06818076f, 0.42217922f, -0.03616313f, -0.14564154f, -0.05648210f, 0.08765730f, 0.01469790f, 
    0.13410637f, 0.14239331f, -0.04314972f, 0.11961540f, -0.02399996f, -0.02055346f, 0.01295133f, 0.01456098f, 
    0.43961126f, 0.06009268f, 0.16134170f, -0.01701722f, -0.01038552f, 0.06902973f, 0.02151131f, 0.09959313f, 
    0.09834083f, -0.02058181f, -0.06556284f, -0.15187818f, -0.46798217f, -0.21656986f, -0.16577902f, -0.20303613f, 
    -0.11680741f, 0.05774022f, 0.06504776f, -0.16770220f, 0.04625988f, 0.12447635f, -0.00322419f, -0.09211212f, 
    0.29937711f, 0.18239632f, 0.10075151f, 0.16346008f, 0.11765186f, 0.01071157f, -0.05963565f, -0.03385214f, 
    -0.05928492f, -0.04127818f, 0.04171273f, -0.04249422f, 0.18870024f, 0.00719872f, 0.21168031f, 0.36767465f, 
    -0.04726452f, 0.02973113f, 0.13757446f, 0.04403663f, 0.02531168f, 0.16279849f, 0.03993656f, 0.20410725f, 
    0.06416710f, -0.22696759f, -0.11685359f, -0.33145687f, -0.07709222f, -0.15999736f, -0.18700108f, -0.26186875f, 
    -0.18445867f, -0.06325672f, -0.03118873f, -0.12852913f, -0.11614564f, -0.01903963f, -0.34432459f, -0.11074614f, 
    -0.01985888f, 0.03930462f, -0.01837079f, -0.01176659f, 0.02593737f, -0.00554797f, 0.12324221f, 0.06662849f, 
    0.14851055f, -0.20238650f, -0.10096862f, -0.24027666f, 0.17642812f, -0.04280921f, 0.17360790f, 0.08887619f, 
    0.02515751f, -0.11584251f, 0.12622087f, 0.11226224f, 0.21734475f, 0.25636739f, 0.34542146f, 0.02591117f, 
    0.13304505f, 0.07269870f, 0.07122662f, 0.07774315f, 0.00122597f, -0.01244495f, -0.04232545f, 0.01226369f, 
    -0.18692164f, -0.05065266f, -0.13194971f, -0.07176910f, -0.04587812f, 0.16965966f, 0.03384986f, -0.05880833f, 
    -0.03091376f, 0.14563659f, 0.11177327f, 0.15032201f, 0.12886529f, -0.20277329f, 0.01188678f, -0.06928300f, 
    0.03224912f, 0.17438482f, 0.06050273f, 0.12136842f, 0.08238814f, 0.03511946f, 0.07964308f, 0.10819875f, 
    -0.38337392f, -0.05729631f, 0.04857466f, 0.25079992f, -0.04247756f, -0.00478023f, 0.25950813f, -0.11023670f, 
    0.05248940f, 0.31835067f, 0.16279323f, -0.00532005f, 0.05269666f, 0.12005799f, -0.03209488f, 0.05694534f, 
    -0.05500729f, -0.01393455f, -0.10676237f, 0.03132665f, -0.04227769f, 0.13243918f, 0.12215028f, 0.04015294f, 
    0.11710817f, 0.00463343f, 0.04012669f, -0.01938698f, 0.09390300f, 0.12421265f, -0.03433636f, -0.04843903f, 
    -0.16787651f, -0.05467826f, -0.15531188f, -0.11952118f, -0.35787159f, 0.03492843f, -0.06629492f, -0.45512158f, 
    0.01994173f, -0.17053783f, -0.15198682f, -0.21252735f, -0.06698065f, -0.25380725f, -0.10071087f, -0.08421504f, 
    0.26000369f, 0.04433588f, 0.20452315f, 0.10482793f, -0.06851909f, -0.05883903f, -0.03504048f, 0.03134370f, 
    0.06335213f, 0.26890442f, 0.18313742f, 0.07217413f, -0.40141609f, -0.11371220f, -0.44833431f, 0.24928418f, 
    -0.00109172f, 0.07528343f, 0.00148601f, 0.06402580f, 0.00036652f, 0.04881281f, 0.19259539f, 0.07843788f, 
    -0.29582056f, -0.16967449f, -0.19179749f, -0.28034505f, -0.16514122f, -0.05904556f, -0.13356489f, -0.02757038f, 
    0.09149987f, -0.03982108f, -0.01784831f, 0.00141087f, -0.23337398f, -0.24298774f, -0.12241669f, -0.23374923f, 
    0.12104837f, 0.18503413f, 0.15389694f, 0.08434655f, 0.12468620f, 0.26544544f, 0.36580265f, 0.04592728f, 
    0.01204796f, -0.05494162f, 0.03238099f, 0.09889475f, -0.00399614f, -0.06041651f, -0.06928755f, 0.10958551f, 
    -0.03323742f, 0.02130866f, -0.09891185f, -0.10699803f, 0.12800206f, 0.03056412f, 0.15863954f, -0.02521232f, 
    0.22008912f, -0.10846289f, 0.00698616f, -0.14218824f, -0.16482215f, -0.09460553f, -0.09356868f, -0.12452452f, 
    0.01207007f, 0.01068565f, 0.03038507f, 0.04257964f, 0.02104134f, -0.02296929f, 0.02138687f, -0.03129097f, 
    0.04423971f, -0.05246371f, 0.01866867f, -0.02100546f, -0.03087758f, 0.01436193f, 0.00566163f, -0.02349766f, 
    0.01578898f, -0.01685832f, 0.02602514f, -0.01397762f, -0.02688035f, 0.02398963f, -0.01983060f, 0.03807530f, 
    -0.03326654f, -0.03833519f, 0.03910834f, 0.02904889f, -0.04597114f, 0.00736908f, 0.00361430f, 0.00727761f, 
    -0.03283863f, 0.03097192f, 0.00017716f, -0.00815593f, -0.02264936f, 0.03168925f, -0.05162808f, -0.03852316f, 
    0.01173706f, -0.02459322f, -0.05379537f, 0.00906295f, -0.03830797f, -0.00452387f, 0.01840773f, -0.00300259f, 
    -0.04458845f, 0.03605971f, -0.03749889f, 0.01263737f, -0.00213536f, -0.02148769f, 0.01372150f, 0.01712201f, 
    0.03425824f, 0.04514511f, -0.04531859f, -0.00159839f, 0.05138595f, -0.00577504f, 0.05188515f, 0.01351342f, 
    -0.03136657f, 0.01198917f, 0.03517201f, -0.00838780f, -0.01234973f, 0.04866730f, 0.03181929f, -0.02811875f, 
    0.04342653f, -0.01378787f, 0.00181432f, -0.00884615f, 0.03898149f, -0.05486042f, -0.01017971f, 0.01857299f, 
    0.01481511f, -0.01807812f, -0.02002592f, -0.01930015f, 0.04255348f, 0.01445847f, -0.05096434f, 0.03149869f, 
    -0.04749719f, 0.04358266f, 0.03891790f, 0.01813988f, -0.04765269f, -0.05303085f, -0.05602426f, 0.04065201f, 
    -0.00054936f, 0.03036160f, -0.04636315f, 0.00220808f, -0.02797988f, -0.00858467f, 0.03734565f, -0.03184334f, 
    0.02849317f, 0.04322855f, -0.02812677f, 0.02306611f, -0.00004483f, -0.04545549f, 0.01140146f, -0.01277284f, 
    -0.04332944f, -0.01176429f, 0.02883181f, -0.01675183f, -0.01797993f, 0.03769184f, -0.05017120f, 0.02685649f, 
    -0.03510661f, 0.00340082f, -0.04439677f, 0.02727584f, 0.03453985f, 0.00021590f, 0.00085631f, -0.01565854f, 
    0.02630315f, 0.03735527f, 0.01757473f, -0.03903776f, 0.04289065f, -0.02702558f, -0.02702990f, 0.03255715f, 
    0.00586748f, 0.02498886f, 0.01896086f, 0.03504687f, -0.04122087f, 0.00726477f, 0.01788492f, -0.05199733f, 
    -0.05209047f, -0.04371715f, 0.01030614f, -0.04743368f, 0.04088173f, 0.02396956f, -0.04951717f, -0.02555558f, 
    0.01302077f, 0.00710502f, -0.02323317f, -0.04691370f, 0.02686424f, -0.03717522f, 0.00464543f, -0.02357607f, 
    -0.00667179f, -0.04007162f, -0.02319757f, -0.02614378f, 0.00917014f, -0.05301397f, 0.00046701f, 0.01552464f, 
    -0.03639165f, -0.03981244f, 0.00076826f, -0.00946132f, -0.05413428f, 0.01463874f, -0.00103355f, 0.02181254f, 
    -0.02366943f, -0.04589699f, -0.01984153f, -0.04753357f, 0.01737541f, 0.01550485f, -0.04523416f, 0.00960082f, 
    -0.04707043f, 0.00819444f, -0.01174543f, 0.01187849f, -0.03298692f, 0.00147125f, -0.02450995f, -0.05367480f, 
    0.01972299f, 0.02881723f, -0.01814594f, 0.02487288f, 0.03600572f, -0.00106110f, 0.00753472f, 0.01413149f, 
    0.03285291f, 0.02531914f, 0.04856796f, 0.05037974f, -0.01961362f, -0.04115110f, 0.01221688f, 0.03937778f, 
    -0.05528896f, 0.03665435f, -0.02895004f, 0.04534103f, -0.02857617f, -0.01008653f, -0.03794097f, 0.02513701f, 
    -0.00731626f, 0.04538127f, -0.00426901f, -0.00034755f, -0.03906438f, 0.04066291f, -0.04566002f, -0.03778920f, 
    -0.05051881f, 0.01246686f, -0.01151108f, 0.01047876f, 0.00731523f, 0.03034495f, 0.02969264f, 0.00715424f, 
    -0.05172773f, -0.03284405f, -0.03721097f, -0.00893444f, -0.02072924f, 0.03772693f, 0.01930609f, 0.04272011f, 
    0.02436371f, -0.02181901f, -0.03939193f, 0.00013536f, -0.00859463f, -0.04100979f, -0.00240565f, -0.00924016f, 
    0.00660807f, -0.01872689f, -0.01045027f, 0.01069384f, -0.02822436f, -0.04143491f, -0.03751829f, -0.02737443f, 
    0.01997067f, -0.03509999f, -0.05218282f, 0.00277365f, -0.02405543f, 0.01667196f, 0.02318977f, -0.03471270f, 
    -0.00910661f, 0.00557487f, 0.00151037f, 0.00772549f, 0.02152321f, -0.01909009f, -0.05250721f, 0.00247442f, 
    -0.05005849f, -0.01874554f, 0.04417416f, -0.03015673f, 0.01025196f, -0.03471465f, 0.04287340f, 0.02045097f, 
    0.00368733f, 0.04211678f, 0.01095170f, 0.03315159f, -0.02494370f, 0.00446431f, 0.01116226f, -0.02665045f, 
    -0.02331871f, 0.02419518f, -0.00336779f, -0.04692833f, -0.04296193f, -0.00553383f, 0.00791860f, 0.01565889f, 
    -0.04397364f, 0.02763780f, -0.05103324f, 0.03557037f, -0.00737682f, 0.04157173f, -0.05420439f, -0.03118279f, 
    -0.00717620f, 0.01181464f, 0.01773078f, -0.04252393f, 0.03781368f, -0.05330925f, -0.04570777f, 0.00387424f, 
    -0.03941016f, -0.02105698f, 0.02686646f, -0.01978370f, 0.01674865f, -0.02681247f, -0.02858387f, 0.03053056f, 
    -0.01593648f, -0.04062283f, 0.00816901f, 0.00738464f, -0.04348028f, 0.04458594f, 0.03303629f, 0.04192668f, 
    0.03663455f, -0.04395121f, -0.03407130f, -0.01535633f, 0.02430474f, -0.04395511f, -0.03833368f, 0.00553695f, 
    0.04197119f, 0.01206283f, 0.00303666f, 0.04592223f, 0.00517194f, -0.03035340f, 0.00095928f, -0.03698714f, 
    -0.03218286f, -0.04383952f, 0.02667153f, -0.02742626f, -0.03285743f, -0.04295210f, -0.00798659f, -0.01540672f, 
    0.01164149f, 0.01924708f, -0.04025066f, -0.00426617f, -0.03662240f, -0.04504464f, -0.02516968f, 0.02263891f, 
    -0.02015907f, -0.03342162f, 0.02045331f, 0.01929239f, -0.02041685f, -0.00387621f, 0.02655512f, 0.00399348f, 
    -0.03268686f, 0.00967670f, 0.03641979f, 0.02029098f, -0.01532742f, 0.03452959f, -0.03094463f, -0.01672425f, 
    -0.05563987f, 0.03197187f, -0.04190555f, -0.02157489f, -0.05513695f, 0.02431746f, 0.00543087f, -0.00829426f, 
    -0.02208302f, 0.18172760f, 0.02749182f, 0.04546976f, -0.00101973f, 0.04458452f, -0.05499863f, -0.06140313f, 
    -0.10088491f, -0.05587642f, -0.04712180f, -0.00389082f, -0.15263577f, -0.13688695f, -0.13207398f, 0.38622326f, 
    -0.02810956f, -0.02572727f, -0.00862710f, 0.08796693f, -0.04617101f, -0.10809016f, 0.00416586f, -0.00419558f, 
    -0.06349762f, -0.09910774f, 0.18543507f, -0.01643364f, 0.03135268f, -0.14700903f, 0.11399049f, -0.10682383f, 
    0.00340226f, -0.05037827f, -0.00349669f, 0.04184309f, -0.01823602f, 0.00833315f, -0.07561119f, 0.08835596f, 
    0.01783208f, -0.07516955f, -0.00316259f, 0.06286146f, 0.00038604f, 0.09525813f, -0.06369310f, 0.01494153f, 
    -0.50687468f, 0.11549699f, -0.15685321f, 0.05541383f, 0.09945902f, 0.06240768f, 0.06409647f, 0.00993008f, 
    0.03585546f, -0.00841191f, -0.03132332f, -0.05177229f, -0.00996248f, 0.15902741f, 0.08287407f, 0.06225170f, 
    0.12534882f, 0.12145011f, 0.01663351f, 0.17475966f, 0.00966255f, 0.04021297f, -0.09026058f, 0.04312610f, 
    0.13042167f, -0.10355781f, 0.27680150f, -0.07893607f, -0.15588088f, 0.17135818f, -0.10694499f, 0.06313691f, 
    -0.08187397f, 0.02416569f, -0.15548280f, -0.16818483f, -0.04419557f, -0.00748541f, 0.00613353f, 0.05273097f, 
    0.04972766f, -0.02481433f, 0.15584444f, -0.02541649f, -0.04187278f, -0.03952713f, -0.02504333f, -0.00259548f, 
    0.26563939f, -0.07727113f, -0.08665868f, 0.21202376f, 0.08070333f, -0.02969669f, 0.18855883f, 0.08560410f, 
    -0.05930540f, 0.06831730f, -0.01687420f, 0.07281967f, -0.28573760f, -0.07573776f, 0.13776951f, 0.31622371f, 
    0.03692932f, 0.15155213f, -0.05652755f, 0.19179252f, -0.00550394f, -0.06701974f, 0.04741780f, -0.01981252f, 
    0.20925981f, -0.09429242f, 0.23832831f, 0.10375611f, 0.17051628f, 0.02701938f, 0.10659162f, -0.02845978f, 
    0.03197953f, 0.07027753f, 0.06488600f, 0.05246034f, 0.01967932f, 0.07820868f, -0.06220528f, 0.00338894f, 
    -0.11075404f, 0.10812233f, 0.04170244f, -0.00331330f, 0.16133268f, -0.01413773f, 0.01089231f, 0.03915763f, 
    0.06833417f, -0.21475331f, 0.29008535f, 0.07298682f, 0.01786779f, 0.04930940f, -0.15515120f, 0.08317588f, 
    0.04716431f, -0.05007332f, -0.01799980f, 0.12298677f, -0.05376302f, 0.07314150f, 0.03894111f, 0.10928688f, 
    0.11890882f, 0.09141185f, 0.17390257f, 0.04799445f, -0.11965105f, 0.09167477f, -0.12471811f, -0.14431921f, 
    0.01013795f, 0.12122044f, -0.20680030f, 0.05189723f, 0.01088089f, 0.08378045f, -0.07642268f, 0.12517209f, 
    -0.04998622f, -0.01424544f, 0.00280294f, 0.02593396f, 0.02255302f, -0.15698133f, -0.00480084f, 0.13384241f, 
    -0.06827343f, 0.05983360f, -0.05701159f, -0.08091594f, -0.09705878f, -0.01124888f, 0.06363013f, -0.05937188f, 
    -0.00707231f, -0.08632720f, 0.10696269f, 0.08455204f, 0.11466279f, 0.11249956f, 0.05355161f, -0.02618052f, 
    -0.03365600f, -0.02679188f, 0.06700115f, 0.01856962f, -0.33860534f, 0.13306440f, -0.29495549f, -0.10628050f, 
    0.05982817f, -0.00170412f, -0.00532640f, 0.05552632f, 0.01248795f, 0.03897193f, 0.01805129f, 0.01595700f, 
    0.21307817f, -0.11199621f, 0.29695195f, 0.05074188f, 0.07441849f, -0.10324552f, 0.04187576f, 0.18149100f, 
    0.10288966f, 0.04717112f, 0.05393192f, 0.07170904f, 0.21485288f, 0.26199657f, 0.52831453f, 0.22842628f, 
    -0.00592221f, 0.03311114f, -0.02941675f, -0.01392280f, -0.00331734f, 0.00686847f, -0.06499565f, -0.04711602f, 
    -0.16125372f, 0.14496584f, -0.04830207f, 0.05002947f, -0.05766379f, 0.15705805f, -0.00661421f, -0.01388413f, 
    -0.08203766f, 0.09948742f, -0.00598166f, 0.00796911f, 0.06893393f, -0.07989870f, -0.04763893f, 0.00684842f, 
    0.01670302f, -0.02096609f, -0.03314784f, 0.02442880f, -0.08153535f, -0.01803916f, 0.02482754f, -0.16524574f, 
    0.09258862f, 0.10464834f, 0.04703033f, 0.30812463f, -0.10777054f, 0.03270163f, 0.20208177f, 0.07099363f, 
    0.02199583f, -0.20942765f, 0.09050579f, -0.21781620f, -0.31190434f, -0.04593528f, -0.27053630f, 0.00098477f, 
    0.00370109f, 0.01709508f, -0.04684533f, 0.03032758f, 0.05734598f, -0.01355510f, 0.05300355f, 0.02698380f, 
    -0.18966404f, -0.14203098f, 0.07956499f, 0.19211535f, 0.13291399f, 0.04277940f, 0.02392842f, 0.00013005f, 
    -0.09072306f, 0.04314040f, -0.00405567f, -0.08606337f, 0.09571431f, 0.14859244f, 0.05304617f, 0.01368188f, 
    0.09984424f, -0.14831170f, 0.07243676f, -0.04576949f, 0.00936425f, -0.06001136f, -0.04726537f, -0.04563618f, 
    0.02556132f, -0.09297226f, -0.14294679f, 0.07694847f, -0.02730023f, 0.00340081f, -0.16229995f, -0.06010776f, 
    -0.01742955f, -0.13371286f, 0.00709191f, 0.20508111f, -0.16678773f, 0.39555672f, -0.31721061f, 0.31146976f, 
    0.02397909f, 0.17226444f, -0.01839076f, -0.08062097f, 0.10840501f, 0.10966724f, 0.03356181f, 0.13088724f, 
    0.14290899f, -0.04443960f, 0.08496677f, 0.10039097f, -0.00391501f, 0.14492692f, -0.21099517f, -0.14590180f, 
    -0.01386013f, 0.08623960f, 0.01245194f, 0.03067240f, -0.01663018f, -0.06235600f, 0.12594944f, -0.28463745f, 
    0.02204818f, 0.01269132f, 0.09146979f, 0.19605926f, 0.02934517f, 0.09368034f, 0.13498631f, 0.08371631f, 
    0.04736740f, 0.02831808f, 0.00788370f, -0.06636402f, 0.08623220f, 0.10145771f, 0.00596853f, 0.21006650f, 
    0.07054128f, 0.09158190f, 0.04580756f, -0.07692247f, -0.16039342f, -0.08766457f, 0.04011271f, -0.03188124f, 
    0.07298476f, -0.13909234f, -0.26219362f, -0.05215450f, -0.02031831f, 0.03618808f, -0.02909704f, 0.12245828f, 
    0.05073961f, 0.15310709f, 0.08144069f, -0.07991286f, -0.13499819f, -0.18452387f, -0.01319569f, 0.05648559f, 
    0.00588752f, 0.03048523f, -0.00452666f, -0.00468724f, 0.06857119f, -0.10912096f, 0.13393904f, -0.12328243f, 
    0.02609597f, 0.10404736f, -0.05679036f, 0.14411728f, 0.02818330f, -0.19032197f, 0.15237427f, 0.11474987f, 
    -0.00071915f, 0.20103230f, -0.24342442f, 0.09789401f, -0.01144331f, -0.02591400f, 0.10162351f, -0.03404508f, 
    -0.01226311f, 0.11425342f, 0.13331729f, 0.01127971f, 0.03569731f, 0.02357375f, 0.05617149f, 0.02617549f, 
    0.00335320f, -0.10859566f, -0.01163954f, 0.02296437f, 0.01310633f, -0.02323049f, 0.03521130f, -0.04765879f, 
    -0.08961350f, -0.42447770f, -0.09626877f, -0.17510396f, -0.01802029f, 0.03591574f, 0.08797093f, 0.03477244f, 
    0.15329836f, -0.01610601f, -0.01678615f, -0.08131453f, 0.33529505f, -0.31553558f, 0.06304303f, 0.05426909f, 
    0.09902963f, 0.03509712f, 0.02328308f, -0.03380833f, 0.02586424f, 0.03863735f, -0.02967404f, -0.08962830f, 
    -0.08868059f, -0.15584716f, -0.25089425f, 0.16554327f, -0.09103211f, 0.08587815f, 0.13986117f, 0.06961057f, 
    -0.09346852f, 0.11485974f, -0.04193943f, 0.09463105f, -0.12670328f, 0.13915148f, 0.19699645f, -0.02230719f, 
    0.11320347f, 0.01641705f, -0.10315707f, 0.08904051f, -0.00345414f, -0.03188899f, 0.07697167f, 0.05748707f, 
    0.19916584f, -0.23498595f, 0.26169935f, -0.05917101f, 0.15215713f, -0.05004196f, -0.11799767f, 0.06347620f, 
    -0.04502675f, -0.08395043f, 0.18852437f, -0.00802373f, 0.46599275f, -0.29609993f, -0.17443150f, 0.01794782f, 
    -0.01772915f, 0.19343132f, 0.28585541f, -0.08810994f, 0.00511315f, -0.02187295f, -0.14433578f, -0.05085975f, 
    0.21157007f, 0.03604616f, 0.17620404f, -0.01881649f, -0.01218446f, -0.02650979f, 0.00372823f, 0.07350387f, 
    0.11376333f, 0.11205056f, 0.08127644f, -0.09250312f, 0.11463534f, 0.09226371f, -0.02167452f, -0.02904372f, 
    0.06569009f, 0.01689518f, 0.48736212f, -0.21329461f, 0.08881555f, 0.07049304f, -0.01336309f, -0.03708571f, 
    -0.13996890f, 0.04391728f, -0.01672727f, 0.00369211f, 0.12271775f, 0.07808803f, -0.03780226f, -0.09371065f, 
    -0.00405340f, 0.03576352f, -0.02944450f, 0.04805269f, 0.06705546f, -0.05207434f, -0.27148399f, -0.08665033f, 
    0.05340005f, 0.19412985f, 0.06042282f, 0.03146733f, 0.01419027f, -0.10000178f, 0.02720612f, -0.11357871f, 
    0.10956939f, 0.17368372f, 0.12177718f, -0.11200256f, -0.04534490f, -0.02019016f, -0.08250926f, 0.08554597f, 
    -0.04101311f, -0.06704678f, 0.04776040f, 0.07672688f, -0.03696493f, 0.08848689f, -0.10606743f, 0.13701113f, 
    0.00507706f, 0.01177859f, -0.08572156f, 0.00446490f, -0.02147583f, -0.06643664f, 0.09007870f, 0.03701597f, 
    0.28522342f, 0.31890866f, 0.03035135f, -0.04192618f, 0.13772917f, 0.23285133f, 0.15736130f, -0.01252534f, 
    0.02545488f, 0.01789755f, -0.04283901f, 0.04957727f, 0.25251499f, -0.34315512f, -0.17492642f, -0.03817198f, 
    0.05492728f, -0.06441492f, 0.09357900f, -0.07985253f, 0.08642702f, -0.09198296f, 0.02163203f, 0.04699773f, 
    0.21759477f, 0.14049670f, 0.21201767f, 0.19082856f, 0.26582286f, 0.10895149f, -0.07939597f, -0.04234514f, 
    0.02262522f, -0.02336191f, 0.02193061f, 0.09777992f, 0.22342438f, 0.25691769f, 0.12685020f, -0.41091600f, 
    0.05530419f, -0.14706668f, 0.16076826f, -0.06660920f, 0.07950477f, 0.04133808f, -0.00871381f, -0.08576490f, 
    0.35139501f, 0.09629624f, 0.05169274f, 0.16778499f, -0.07489517f, -0.00494170f, 0.10438278f, 0.14190952f, 
    0.01312078f, -0.02030093f, 0.08109172f, -0.13425639f, -0.23002978f, -0.13458171f, -0.06248225f, -0.06844915f, 
    -0.01228238f, 0.14307408f, 0.00388938f, 0.09125148f, -0.04253285f, 0.10367868f, 0.21403594f, -0.02708674f, 
    -0.00249672f, -0.15211964f, -0.25634593f, -0.20273568f, 0.02865502f, -0.02006537f, 0.22435240f, 0.17451376f, 
    0.06417920f, -0.04462616f, 0.21742924f, 0.00648740f, 0.15884392f, -0.17897904f, -0.07240001f, 0.05986587f, 
    -0.01029743f, -0.03342704f, 0.06429449f, -0.06483877f, -0.00891153f, 0.03877547f, 0.03259953f, -0.06820399f, 
    0.10616599f, -0.04253783f, -0.05359092f, -0.13971493f, -0.00156055f, 0.11956957f, 0.04854471f, 0.16009961f, 
    -0.17193320f, -0.08461410f, 0.05556689f, -0.07151764f, 0.11838130f, 0.02808534f, 0.06406763f, -0.05446943f, 
    0.08831041f, 0.14809331f, 0.00474161f, -0.15467522f, 0.05964573f, -0.01991313f, -0.02387979f, -0.04615536f, 
    -0.02224643f, 0.14114381f, 0.09029822f, -0.01321693f, -0.00588612f, 0.00402485f, 0.02034369f, 0.03400101f, 
    0.15022208f, 0.09236422f, 0.04047459f, 0.09008165f, 0.25555477f, 0.22522400f, -0.01889817f, -0.22554146f, 
    -0.18977627f, -0.01502263f, 0.30631986f, 0.10476011f, -0.00170738f, 0.06669892f, -0.07502962f, 0.09928962f, 
    0.17124140f, 0.03952180f, -0.22379816f, -0.20235747f, -0.07234583f, -0.00382140f, -0.01579108f, -0.06127239f, 
    -0.03622225f, -0.00478535f, -0.05777298f, -0.00550617f, -0.22240649f, 0.24304841f, 0.13493995f, -0.07839851f, 
    0.06172611f, -0.13537057f, -0.04149861f, 0.13393705f, 0.02211525f, 0.09697325f, -0.09704868f, -0.07955302f, 
    0.01932210f, 0.10155799f, 0.05796222f, -0.04091781f, -0.00099279f, 0.15272088f, -0.08844782f, -0.10347106f, 
    0.04259264f, 0.09102485f, 0.07717147f, 0.06859476f, -0.07538531f, -0.05720329f, 0.08312368f, 0.14777748f, 
    -0.00421935f, -0.01316725f, 0.00673211f, -0.02281338f, -0.04655753f, -0.06701010f, 0.01765903f, -0.08119527f, 
    -0.00785755f, 0.00617136f, -0.05887694f, 0.00936938f, 0.08833867f, 0.08336293f, -0.02632096f, -0.02991141f, 
    -0.04265879f, -0.14916033f, -0.07311471f, -0.06017934f, 0.07252742f, 0.08108286f, -0.04684873f, -0.14073214f, 
    0.00947789f, 0.08506988f, -0.01301482f, -0.06145665f, 0.11157203f, -0.00035052f, 0.03383780f, 0.00656681f, 
    -0.14773038f, -0.17915389f, -0.25767446f, 0.11860542f, 0.10411299f, -0.10871777f, -0.06410781f, -0.17025581f, 
    -0.04018601f, -0.04962028f, -0.15120366f, 0.02415960f, -0.03879721f, -0.06911387f, -0.02560512f, 0.05521876f, 
    0.00326534f, -0.14188379f, -0.10283908f, 0.14028922f, -0.09129310f, -0.11656651f, -0.14939119f, -0.08917897f, 
    -0.37377930f, -0.10941444f, 0.19358285f, 0.14881933f, -0.00005336f, -0.14221048f, -0.01124131f, -0.06341975f, 
    -0.05726015f, 0.01639770f, -0.00309796f, 0.00235661f, -0.08609859f, 0.05172483f, 0.12119357f, -0.01118003f, 
    -0.08026408f, -0.02867610f, 0.01456945f, 0.03416193f, -0.01503506f, 0.06351696f, -0.11849374f, 0.13709523f, 
    -0.02143605f, -0.07585037f, -0.01462098f, -0.16901207f, 0.05131196f, 0.06949665f, -0.17878471f, -0.06733148f, 
    0.02022872f, -0.13226332f, -0.02538276f, -0.17692989f, -0.02614043f, -0.09998207f, -0.13605611f, 0.09154110f, 
    0.07177833f, -0.03951981f, -0.09608040f, -0.08015128f, -0.02038163f, -0.11400243f, -0.02597122f, -0.05906993f, 
    0.45382592f, -0.17566720f, -0.05239384f, 0.24068770f, -0.14563881f, -0.11124811f, -0.11393490f, 0.04326198f, 
    0.00072392f, 0.11920459f, 0.10870275f, -0.04822892f, -0.24239720f, -0.08244608f, 0.11692769f, -0.15261410f, 
    -0.11113930f, -0.04946183f, -0.15541980f, -0.13660595f, -0.14407387f, -0.11491758f, -0.00221613f, -0.08624860f, 
    -0.02834290f, -0.18166238f, 0.11876819f, 0.27175450f, -0.02292842f, -0.07254766f, -0.11159287f, -0.06614534f, 
    0.05438720f, 0.03585557f, 0.09987409f, 0.28190696f, -0.04306087f, -0.09659696f, 0.07372617f, -0.04593344f, 
    -0.08453605f, -0.08986293f, 0.03542225f, 0.06865858f, -0.04736529f, -0.09699629f, -0.10572790f, -0.15114185f, 
    0.08283895f, 0.04076044f, -0.11586577f, -0.14997712f, 0.06128057f, 0.02382319f, -0.18177804f, -0.03791000f, 
    0.07093036f, 0.02174309f, -0.11077658f, 0.03506447f, -0.22969633f, 0.10838233f, 0.15515567f, 0.11773553f, 
    -0.05928715f, -0.03610840f, -0.01039978f, -0.02302250f, -0.00528221f, -0.00920521f, -0.02377557f, 0.03060429f, 
    -0.06459028f, -0.17193386f, -0.03879932f, -0.35103929f, 0.14708750f, -0.02422368f, -0.16964087f, 0.15486521f, 
    -0.09550240f, -0.12152639f, -0.04789243f, -0.02425269f, 0.15273890f, -0.19064428f, -0.21475035f, -0.09947186f, 
    0.03143325f, 0.03227372f, -0.03709609f, -0.09079018f, 0.01550159f, -0.02121441f, 0.09576225f, -0.04398101f, 
    -0.18875995f, 0.07748942f, 0.17297825f, 0.06207936f, 0.04052930f, 0.02870481f, -0.00371878f, 0.01154239f, 
    0.00958446f, -0.03935491f, -0.01425324f, 0.00949341f, -0.29418683f, 0.05037135f, 0.18691070f, 0.02439212f, 
    0.01801768f, -0.07020817f, 0.04594984f, -0.03202184f, -0.05902740f, -0.11353578f, 0.03922106f, 0.10240871f, 
    0.06714076f, -0.01871552f, 0.03765630f, 0.05844651f, 0.04823413f, -0.05267071f, 0.03323026f, 0.01513238f, 
    -0.04361133f, 0.03054796f, -0.13077790f, 0.01144433f, -0.02482807f, -0.12568365f, 0.17973450f, 0.27312952f, 
    -0.17028080f, -0.11873563f, 0.06576164f, 0.05223462f, -0.01810275f, -0.07358256f, -0.02825521f, -0.03278774f, 
    -0.22401147f, 0.28367913f, -0.14128408f, -0.19183412f, -0.05054389f, -0.03193590f, -0.16062294f, -0.04269565f, 
    -0.17714125f, -0.00922275f, 0.05802240f, -0.03344374f, 0.13302737f, 0.10351278f, -0.06899536f, -0.10816657f, 
    -0.03202173f, 0.03581417f, -0.11721766f, -0.05503606f, 0.20112066f, -0.02170967f, 0.11310276f, 0.10119361f, 
    0.07040188f, 0.02080530f, 0.06985130f, 0.03206259f, -0.00192521f, -0.07950755f, 0.04490533f, 0.04379631f, 
    -0.07169514f, -0.08894578f, 0.00645815f, -0.06270631f, -0.07185495f, 0.00924326f, 0.00442646f, 0.00565740f, 
    -0.03608258f, 0.03804963f, -0.09829373f, -0.02979928f, -0.00850641f, -0.06564403f, 0.04973958f, -0.00521520f, 
    -0.04289829f, -0.03956719f, -0.04989102f, -0.11213740f, 0.14331841f, 0.17444886f, 0.04834136f, -0.02059530f, 
    0.01906906f, -0.04327236f, 0.03975385f, -0.07917092f, 0.00107578f, -0.11872844f, 0.05794615f, 0.00563017f, 
    0.04659613f, -0.03989956f, 0.04676016f, -0.07675584f, 0.02972836f, -0.10562564f, -0.04067146f, 0.02169207f, 
    0.03347419f, -0.28881535f, -0.14496532f, -0.14922050f, 0.03218566f, 0.02746492f, -0.02033801f, -0.02459455f, 
    -0.04275850f, -0.03503492f, 0.12937909f, 0.01080900f, -0.19144544f, 0.24585657f, -0.03173317f, -0.16979662f, 
    0.11314176f, 0.00436934f, 0.02346874f, 0.08925273f, -0.02817008f, 0.10494193f, -0.04629781f, -0.05462191f, 
    -0.01493893f, 0.02524750f, 0.15315703f, -0.15115045f, -0.00904820f, -0.02047771f, -0.11699001f, -0.03163143f, 
    -0.08091152f, -0.07813428f, -0.09989861f, -0.02850683f, -0.22821660f, 0.06132603f, 0.04108801f, 0.04098477f, 
    0.00795472f, -0.03229990f, -0.03402902f, 0.02147574f, -0.00484105f, -0.11838058f, 0.19418350f, 0.11914501f, 
    -0.08485321f, -0.09628199f, -0.00009600f, -0.13097738f, 0.09326512f, 0.13075456f, -0.12602057f, -0.02464269f, 
    -0.06841999f, -0.18731046f, -0.13359571f, -0.17292504f, -0.03635412f, -0.10777130f, -0.15435134f, -0.14271975f, 
    0.08703908f, -0.16286480f, -0.19433783f, -0.07007638f, -0.07062223f, -0.09020984f, -0.01794451f, -0.13511966f, 
    -0.14012395f, -0.23940207f, -0.12699492f, -0.11238174f, 0.10620539f, 0.08434419f, 0.00671863f, -0.06129558f, 
    0.12612103f, -0.00790848f, 0.01771919f, 0.06521305f, -0.22522360f, -0.14868681f, -0.05660808f, 0.19941495f, 
    -0.12658074f, 0.02218070f, -0.16719131f, 0.06472590f, 0.05652902f, 0.06669594f, 0.08373309f, 0.01222707f, 
    -0.17505831f, -0.25031289f, -0.03026470f, 0.11019512f, -0.03004166f, -0.05563603f, -0.09479838f, 0.01484482f, 
    0.16513902f, -0.03756339f, 0.21317348f, 0.20279181f, 0.03409808f, -0.02389594f, 0.08202288f, -0.15449822f, 
    -0.15395580f, 0.09615304f, 0.08269688f, 0.14819843f, 0.13552880f, 0.05236227f, 0.06973919f, 0.06244017f, 
    -0.19001415f, -0.16585310f, -0.10716874f, -0.20027825f, 0.00752614f, 0.00571539f, -0.15743065f, -0.11631536f, 
    0.05529371f, 0.06883103f, 0.03811642f, -0.05870897f, 0.09411579f, 0.16966979f, -0.04332913f, 0.11969773f, 
    0.06521360f, -0.05464253f, -0.08936904f, 0.13338111f, 0.02096257f, -0.05268150f, -0.07354306f, -0.07973598f, 
    0.08938743f, 0.11617415f, -0.03938386f, 0.20306855f, 0.07592133f, 0.00662023f, 0.05186061f, 0.07972424f, 
    0.13416724f, 0.39261517f, 0.11592417f, 0.04827798f, -0.22802062f, -0.26003277f, -0.16468956f, -0.00222627f, 
    -0.02031454f, 0.09282019f, -0.04266774f, -0.04182879f, -0.06782813f, -0.02203102f, -0.09460749f, -0.01979182f, 
    0.19425981f, -0.16821608f, -0.28482357f, -0.11988282f, -0.11105232f, 0.06051360f, -0.12452640f, -0.21952359f, 
    -0.21676598f, -0.01760372f, 0.09331711f, 0.00244774f, -0.08613589f, 0.06007309f, 0.11331568f, 0.10697307f, 
    0.17757018f, 0.04296343f, 0.04954111f, 0.00926705f, 0.18919314f, 0.10035232f, 0.15855780f, 0.08132533f, 
    0.08388490f, 0.04608040f, 0.12451475f, 0.09579149f, -0.00860379f, -0.10128222f, -0.01695067f, 0.11131214f, 
    -0.08813518f, -0.04360179f, -0.27076727f, -0.17920862f, -0.13396379f, 0.21323252f, -0.14406641f, -0.05504794f, 
    0.02242132f, 0.02663266f, 0.07684076f, 0.01409991f, 0.01454076f, -0.02463454f, 0.17024641f, 0.14499819f, 
    -0.10339671f, 0.03223073f, -0.07314200f, 0.17840604f, 0.04176088f, -0.07863417f, -0.04037324f, 0.03066220f, 
    0.18540379f, 0.07273791f, 0.23201349f, 0.19822000f, -0.14319386f, -0.18648753f, -0.05035112f, 0.00275454f, 
    0.07902760f, 0.09061424f, 0.06712903f, 0.09561873f, -0.02551331f, 0.07037824f, 0.00943522f, -0.10431574f, 
    -0.32708025f, -0.03076461f, 0.00945471f, -0.05115542f, -0.20239145f, 0.06417439f, -0.02690130f, -0.22566347f, 
    -0.03016557f, -0.01586400f, -0.00674064f, -0.05789895f, -0.10618377f, -0.01703879f, 0.17713794f, 0.08692394f, 
    -0.13813739f, -0.02892954f, -0.04293479f, -0.09980802f, 0.10295066f, -0.21623996f, -0.05788736f, -0.11371655f, 
    0.02518504f, -0.03038357f, 0.05966063f, 0.16171661f, 0.19273049f, 0.14313655f, 0.07873099f, 0.08551983f, 
    -0.00833752f, -0.04639496f, -0.07733307f, 0.09612685f, 0.17647487f, 0.33837450f, -0.08350271f, -0.19101666f, 
    0.04293868f, -0.08959074f, 0.04589231f, -0.12161411f, -0.12527511f, -0.04525870f, 0.04240143f, 0.04280728f, 
    0.02932742f, 0.04639210f, 0.16888882f, 0.17073302f, -0.00163664f, 0.13188514f, -0.04990588f, 0.02222911f, 
    0.04220992f, 0.06571606f, -0.02604576f, 0.07103088f, 0.05166637f, 0.14704509f, -0.04015750f, 0.30207348f, 
    -0.13656728f, 0.13072032f, -0.07493890f, -0.01404560f, -0.06091524f, 0.02295933f, 0.00463599f, -0.12404500f, 
    0.21652761f, 0.19842140f, -0.24406481f, 0.09698320f, 0.04297318f, 0.00786291f, 0.07719313f, 0.11654369f, 
    -0.01686285f, -0.00754114f, -0.00810011f, -0.21678767f, -0.11177053f, -0.11154854f, 0.10751623f, 0.16465375f, 
    -0.14336784f, 0.11482295f, 0.14111172f, 0.14939597f, -0.03579944f, -0.08600873f, -0.26126677f, -0.15716644f, 
    -0.02441768f, -0.10777029f, 0.02239852f, 0.08620543f, 0.00545485f, 0.01418770f, 0.04342502f, 0.02444608f, 
    0.08009639f, 0.04552077f, 0.18340899f, 0.13783714f, 0.03922236f, -0.16762455f, -0.15018302f, -0.21478835f, 
    0.07109620f, -0.08133052f, -0.01388252f, -0.20053695f, -0.04878590f, -0.02624475f, -0.01710485f, 0.07726529f, 
    -0.06765066f, -0.10992495f, -0.20487884f, -0.02889891f, 0.19821607f, 0.18239371f, -0.02684955f, 0.15101349f, 
    0.01000656f, 0.17016923f, 0.11068743f, 0.01308823f, 0.01720390f, 0.01136955f, -0.01086225f, 0.11118089f, 
    0.08105813f, 0.02138559f, 0.09724775f, 0.12715954f, -0.14869586f, 0.02967763f, -0.02154122f, -0.06931582f, 
    -0.08097310f, -0.00606075f, -0.20895976f, -0.03017604f, 0.00561546f, -0.00352616f, -0.04433918f, -0.15353356f, 
    0.00300155f, 0.00781138f, -0.13242911f, -0.04387474f, 0.07687413f, 0.35696107f, -0.04620245f, 0.00584175f, 
    -0.05132847f, 0.02355833f, 0.00735941f, 0.03703275f, 0.10200401f, -0.08130775f, -0.07497738f, -0.00367186f, 
    0.09978093f, 0.03207159f, 0.14719087f, 0.18482710f, 0.17853011f, 0.10696310f, 0.11486406f, 0.02675634f, 
    -0.09916700f, -0.02799695f, -0.08722795f, 0.03125762f, 0.08293733f, 0.15514444f, 0.23188497f, -0.00186931f, 
    0.00963510f, 0.06968185f, 0.05504533f, 0.07013094f, -0.15726130f, -0.18602270f, -0.19950204f, -0.22694765f, 
    -0.08723374f, -0.02829027f, -0.06202367f, -0.17149146f, 0.04473609f, 0.25160423f, 0.24981804f, -0.07239139f, 
    0.23217577f, 0.08738774f, 0.28896439f, 0.14852421f, 0.02606623f, 0.01578368f, -0.19776194f, 0.20260197f, 
    -0.05244517f, -0.02213189f, -0.08903904f, -0.08353157f, 0.21059860f, 0.25672874f, 0.16858064f, 0.13239388f, 
    -0.03585440f, 0.08881827f, -0.05998310f, -0.00975924f, -0.09005871f, -0.14909138f, -0.07709534f, -0.18197291f, 
    0.01854973f, -0.04749365f, -0.00216528f, 0.07409798f, -0.04211997f, 0.00810742f, 0.06738022f, 0.06479725f, 
    -0.00346931f, 0.00064024f, 0.18925887f, 0.06997106f, -0.04912410f, 0.01119420f, 0.08033126f, -0.00473451f, 
    0.00227913f, 0.11521696f, 0.04210711f, -0.06581663f, -0.06309409f, 0.00777514f, -0.01110469f, -0.06364178f, 
    0.02796338f, 0.09868721f, 0.04505125f, 0.12817778f, 0.00436868f, -0.03385672f, -0.07657093f, 0.02789221f, 
    -0.00931576f, -0.09873348f, 0.14942425f, 0.01895207f, 0.07867154f, 0.02460061f, 0.05895890f, 0.03365001f, 
    -0.19991000f, -0.11518575f, -0.05301092f, -0.24839143f, 0.03595046f, 0.01663225f, -0.04835217f, -0.06802896f, 
    -0.01166773f, 0.08292652f, 0.15365878f, 0.00870404f, 0.02034895f, 0.16283929f, -0.07550138f, 0.16627945f, 
    0.17737545f, -0.02091153f, 0.14844546f, -0.02052064f, -0.00384135f, -0.01511318f, 0.03683839f, -0.11228283f, 
    -0.04269192f, -0.20091762f, 0.19946133f, 0.06790831f, -0.03466256f, 0.01501343f, -0.01331469f, 0.11000683f, 
    -0.00338885f, 0.13701563f, 0.03595604f, 0.08905336f, 0.03062597f, 0.08844841f, 0.25484970f, 0.03716283f, 
    -0.14536290f, -0.04534647f, -0.07346815f, -0.02776157f, -0.03563192f, -0.01881302f, -0.06582298f, -0.03995594f, 
    -0.16788802f, -0.15558949f, 0.20737347f, -0.09654704f, 0.01242989f, 0.00693806f, -0.08948133f, -0.01350859f, 
    -0.01858337f, 0.00613722f, 0.02714340f, -0.06526709f, 0.10999770f, 0.29661587f, -0.12913167f, 0.13541080f, 
    -0.12654589f, 0.02615605f, 0.19996691f, -0.04095432f, 0.07769897f, 0.08236485f, -0.00439718f, -0.16418542f, 
    0.00042111f, 0.00909136f, -0.08928031f, -0.21201892f, -0.11650270f, -0.02724469f, 0.01392620f, 0.16749005f, 
    0.05814521f, 0.07430987f, -0.03236320f, -0.13004188f, -0.11345679f, 0.16806702f, -0.17194369f, -0.00854342f, 
    0.06572701f, 0.08920103f, 0.21390750f, 0.02956803f, 0.04365860f, 0.09389929f, 0.09647705f, -0.01327543f, 
    0.28116781f, -0.06272562f, 0.18569663f, 0.08172367f, 0.01325198f, 0.02033386f, -0.05289036f, 0.03771175f, 
    -0.02661764f, 0.00929165f, 0.02838500f, 0.02945560f, 0.07639688f, -0.15737318f, -0.12911269f, -0.00116548f, 
    0.03726798f, 0.11052743f, 0.03088892f, -0.02881920f, -0.01415809f, 0.01577902f, 0.04442593f, -0.01576927f, 
    0.16502543f, 0.11516400f, 0.26037425f, 0.03904696f, -0.06737051f, -0.00144450f, -0.16566408f, 0.03766395f, 
    -0.00952116f, 0.00875932f, 0.04712901f, -0.00631204f, 0.21929750f, 0.09968492f, 0.37549794f, 0.14045560f, 
    -0.09717803f, -0.05663312f, -0.03507727f, 0.02922029f, -0.02044242f, -0.04392341f, 0.07364086f, 0.04930028f, 
    0.00870474f, 0.02040791f, -0.17009968f, -0.00822149f, 0.10490320f, 0.04571159f, -0.10277303f, -0.08945388f, 
    -0.05724350f, -0.05283935f, -0.10258066f, -0.05767075f, 0.25051492f, 0.41998395f, -0.12419938f, -0.00467081f, 
    -0.01808152f, -0.01922029f, 0.06690040f, -0.14640820f, -0.01532144f, 0.00686900f, 0.14185931f, -0.08742479f, 
    -0.00819702f, 0.04492243f, -0.01695697f, -0.08378180f, 0.15892750f, 0.08091482f, 0.15745117f, -0.04034535f, 
    -0.00674947f, 0.02539713f, 0.09026984f, 0.10474904f, 0.04327268f, 0.26799417f, -0.07046913f, -0.17963652f, 
    0.05482641f, 0.03146491f, -0.01840012f, -0.09257431f, -0.02232044f, 0.00693775f, 0.00755118f, 0.01649307f, 
    0.44824016f, 0.16127139f, 0.08536283f, 0.35047102f, -0.02773943f, 0.02049268f, 0.13812001f, -0.02940810f, 
    -0.05037977f, 0.09495376f, 0.01251196f, -0.04875673f, 0.06140126f, -0.22509545f, 0.02825698f, -0.04204248f, 
    -0.16918451f, 0.14555453f, 0.01701257f, 0.17825346f, 0.00115153f, 0.08257543f, 0.01911348f, 0.03476883f, 
    -0.19215903f, -0.09275560f, -0.09684739f, -0.01327135f, -0.07643322f, -0.07060525f, 0.06291877f, 0.11601292f, 
    0.08731486f, 0.16460368f, 0.03571742f, 0.22644736f, 0.00086806f, 0.03412737f, -0.16142382f, -0.05354165f, 
    -0.06867247f, 0.04131609f, 0.00707994f, -0.00255801f, -0.15128241f, 0.04766094f, 0.04085333f, -0.04420102f, 
    0.02630224f, 0.08378468f, -0.16678829f, -0.03052793f, -0.11071082f, 0.16498004f, -0.01703588f, 0.10285696f, 
    -0.15462926f, -0.02922616f, 0.01996198f, -0.01906881f, -0.15295927f, -0.20576440f, -0.00612485f, 0.05096437f, 
    0.15959884f, 0.07068223f, -0.11543857f, -0.04735100f, -0.15069440f, 0.03985687f, 0.00918537f, -0.01680112f, 
    0.13703646f, 0.18585022f, 0.28063250f, 0.05560439f, -0.06596703f, -0.01848207f, -0.03136500f, -0.04703431f, 
    0.02620643f, 0.11517553f, 0.05438798f, 0.02289073f, 0.01931375f, 0.15837017f, -0.12294497f, 0.27545667f, 
    -0.01661468f, -0.03371460f, 0.20981130f, -0.03621341f, -0.03856451f, 0.02043226f, 0.08541828f, 0.01460829f, 
    -0.13228609f, -0.16992536f, -0.21405105f, 0.08806780f, 0.03467764f, 0.18001583f, -0.00133993f, 0.02242633f, 
    -0.02312039f, 0.01240894f, -0.03384423f, 0.11074241f, 0.10031558f, 0.02811464f, 0.09248298f, -0.03323023f, 
    0.01342666f, 0.08910932f, 0.05375070f, 0.04720678f, -0.14344655f, 0.09449412f, 0.04882663f, 0.03022917f, 
    0.07715847f, -0.11792336f, 0.05839767f, -0.09774442f, -0.04345622f, 0.03389155f, 0.01178186f, -0.11793825f, 
    0.09443980f, 0.06958766f, 0.06600360f, 0.06318929f, 0.03650633f, -0.04230861f, 0.09310722f, -0.00363909f, 
    0.03308156f, -0.11507840f, 0.11867342f, -0.01528138f, -0.06252764f, 0.03063191f, 0.09659334f, -0.04676251f, 
    0.00722835f, 0.00179999f, -0.05226595f, -0.00330772f, -0.04253895f, 0.02759860f, -0.00442177f, -0.02584375f, 
    -0.03204069f, 0.03585982f, -0.04136017f, -0.01348503f, -0.02550558f, 0.01827822f, 0.01396160f, 0.03981897f, 
    -0.01763504f, -0.02038988f, 0.02010552f, -0.03170253f, -0.00883706f, 0.00683259f, 0.04011999f, -0.00421242f, 
    -0.00548764f, -0.02826590f, 0.03876694f, 0.04087574f, -0.05302024f, 0.02921076f, 0.03948073f, -0.00861079f, 
    0.01209568f, -0.05477739f, 0.04365962f, -0.02298550f, 0.00330132f, -0.05554156f, -0.04530299f, -0.03222124f, 
    -0.01437673f, -0.04874163f, -0.03926573f, -0.00522784f, -0.01872220f, -0.02769050f, -0.03047941f, -0.03230362f, 
    0.02271480f, -0.02404735f, 0.01977733f, -0.02704241f, 0.00189737f, -0.04419363f, -0.00972389f, -0.05205751f, 
    0.03173161f, 0.00311121f, -0.01854644f, 0.01206334f, -0.01996230f, -0.03139375f, -0.00518560f, -0.05240863f, 
    0.04098924f, -0.01965547f, 0.02488032f, -0.02692875f, -0.03254050f, -0.02348825f, -0.02078492f, 0.00105284f, 
    0.02221072f, -0.05232112f, -0.04759452f, -0.05287717f, 0.00608673f, -0.03824957f, -0.03832670f, -0.00516453f, 
    0.02208201f, 0.02353085f, 0.02527279f, -0.05550551f, 0.00728177f, -0.01778718f, -0.02200201f, 0.03526421f, 
    -0.03826588f, 0.01245738f, -0.04686950f, -0.03198995f, 0.04023404f, -0.01470206f, -0.03566546f, 0.02250661f, 
    0.03476612f, -0.01303996f, -0.00845846f, -0.03125877f, -0.03588592f, -0.02429518f, -0.05260831f, -0.01629447f, 
    -0.04426923f, -0.01997291f, 0.00446503f, -0.00431197f, -0.05680830f, 0.03093314f, -0.03582022f, 0.04280733f, 
    0.01133770f, -0.01672522f, 0.02804798f, -0.03242405f, -0.05277405f, -0.03739676f, 0.01989008f, 0.01039839f, 
    -0.03727128f, 0.01351594f, 0.04208848f, 0.01410189f, -0.03658516f, -0.02359818f, 0.02795246f, 0.03938080f, 
    0.01759450f, -0.03197139f, -0.05109406f, -0.03731886f, -0.03091909f, -0.02017327f, 0.00178083f, -0.00476492f, 
    0.00849081f, -0.01695363f, 0.01813509f, -0.05528848f, -0.00990947f, -0.04352582f, 0.03546322f, 0.04272139f, 
    0.02684108f, 0.04144138f, 0.01584479f, -0.04073087f, 0.03922820f, 0.00033504f, -0.05120681f, -0.02825764f, 
    -0.00806725f, 0.01623622f, -0.02006831f, 0.02405117f, -0.04672192f, -0.04895115f, 0.02543936f, 0.02489698f, 
    -0.05651301f, 0.01836008f, -0.02082444f, -0.04844870f, -0.01956067f, 0.00765185f, 0.03384714f, -0.00741125f, 
    0.02249493f, -0.02529978f, -0.01218426f, 0.00153272f, -0.04349906f, -0.01526359f, -0.01196053f, 0.00260024f, 
    -0.04625674f, -0.04066778f, 0.03057382f, -0.04126235f, 0.00469942f, -0.00688960f, -0.00449909f, 0.03101489f, 
    0.02470416f, 0.01091033f, -0.03370729f, 0.02126965f, 0.01095147f, 0.01070968f, 0.01429485f, -0.05156845f, 
    -0.03456338f, -0.00288554f, 0.00311480f, -0.01415094f, 0.03307818f, 0.01205967f, -0.00465119f, -0.02872537f, 
    0.01547400f, -0.00840458f, -0.01122402f, -0.04084673f, -0.01602257f, 0.00776386f, -0.05363676f, 0.03104838f, 
    0.00752673f, 0.03505887f, -0.02481398f, -0.01970514f, -0.05021412f, -0.00762579f, -0.01330762f, -0.04051378f, 
    -0.00122338f, -0.03254635f, -0.02200106f, 0.00517580f, -0.00884972f, 0.00652499f, 0.03882005f, 0.01607513f, 
    0.03209522f, -0.03683596f, -0.04658607f, -0.05144054f, 0.02930612f, -0.05034865f, -0.04043774f, -0.04891262f, 
    0.00932414f, -0.03096587f, -0.01793393f, -0.00838151f, 0.02961984f, -0.05489573f, -0.04441230f, -0.05455216f, 
    -0.02445458f, -0.02342118f, -0.03307768f, -0.00566118f, -0.05150457f, -0.02866564f, 0.01853992f, 0.00263013f, 
    0.03244220f, -0.05527348f, -0.03731463f, -0.03083231f, -0.04811589f, -0.01354303f, 0.00985636f, 0.01637042f, 
    -0.04858302f, -0.05815767f, -0.02157512f, -0.01029684f, 0.02772809f, -0.00645063f, -0.05568226f, -0.02643373f, 
    -0.01912101f, -0.00356366f, -0.02860750f, -0.03929639f, 0.02595143f, 0.01614346f, 0.01836457f, 0.01254538f, 
    0.01346581f, 0.04362813f, 0.04440608f, 0.03481325f, 0.01863568f, -0.04513402f, 0.01943111f, 0.00699942f, 
    -0.04799559f, -0.00445740f, -0.03047855f, -0.05333532f, -0.00873885f, -0.04090865f, 0.00318565f, -0.03106710f, 
    0.00399329f, -0.02611855f, 0.04135512f, -0.02725295f, -0.03402894f, 0.01495811f, -0.05503952f, -0.04777754f, 
    -0.01488354f, -0.00585424f, 0.01613318f, -0.01399151f, 0.01815776f, -0.04974722f, 0.02154913f, 0.03589078f, 
    -0.02617248f, -0.04556416f, 0.01248392f, 0.03124508f, -0.03105219f, -0.05798991f, 0.01962823f, -0.01468157f, 
    -0.01281375f, 0.04405444f, -0.04415039f, -0.00874326f, -0.02627338f, 0.00244136f, 0.00380997f, 0.00592138f, 
    -0.01470480f, 0.02915096f, 0.03727530f, 0.03667751f, -0.00169781f, 0.01087250f, 0.00931472f, -0.02318684f, 
    -0.03926151f, -0.00179071f, -0.02766783f, -0.00563991f, 0.00580279f, 0.01338926f, 0.03678248f, -0.03403315f, 
    -0.00767286f, -0.04974143f, -0.05389556f, 0.03313091f, -0.01344718f, -0.05209283f, -0.05233655f, -0.02751593f, 
    0.03759097f, 0.02125967f, 0.03266668f, 0.03042009f, 0.01545373f, -0.05308438f, 0.03853210f, -0.00400913f, 
    0.04265650f, -0.01766448f, -0.03345068f, -0.04175232f, 0.03605870f, 0.01704978f, 0.00832103f, 0.01750997f, 
    0.02742559f, 0.02100107f, -0.02438852f, 0.00053659f, 0.01157208f, 0.02017757f, -0.05832670f, -0.02817028f, 
    0.00908543f, 0.01392811f, -0.05247305f, 0.01294522f, -0.01592506f, -0.01517478f, 0.02036744f, 0.01764759f, 
    -0.01356966f, -0.02047415f, 0.02066334f, -0.01822234f, -0.04302197f, 0.01563907f, 0.02118548f, -0.02353807f, 
    0.32389748f, -0.02303206f, 0.02516293f, -0.19111024f, -0.07304255f, 0.01058551f, 0.01161564f, 0.05802040f, 
    -0.10459053f, -0.09069517f, -0.23287977f, -0.18201143f, -0.40547639f, -0.28904122f, 0.39319840f, 0.14735168f, 
    -0.17950867f, 0.01829974f, 0.02329956f, -0.12070043f, -0.05106867f, -0.01706254f, 0.01476516f, 0.13904063f, 
    -0.09578114f, -0.02633092f, -0.01844449f, -0.23141704f, -0.08136471f, 0.08005841f, -0.26233932f, 0.16524771f, 
    -0.05974256f, -0.10701717f, 0.06434586f, -0.15677629f, -0.03141734f, 0.08830234f, -0.17612503f, -0.19588649f, 
    0.18907280f, 0.02736730f, -0.13821419f, -0.32184118f, -0.00149271f, -0.25276050f, -0.25570226f, -0.23807067f, 
    0.43268657f, 0.01106890f, -0.07293524f, 0.14982192f, 0.06607249f, -0.02807749f, -0.10159831f, -0.16113105f, 
    -0.03550068f, -0.00112633f, -0.04268577f, 0.07169086f, -0.23240219f, -0.03475381f, -0.06227445f, -0.10735326f, 
    0.01632101f, 0.03571396f, 0.11371946f, 0.02831174f, 0.03165990f, -0.01179321f, -0.02429437f, 0.02197164f, 
    -0.24213389f, 0.20936848f, -0.03771391f, 0.23048329f, -0.02515920f, 0.01455694f, 0.05037527f, 0.02464482f, 
    -0.02529923f, -0.06928611f, -0.01212154f, -0.08269152f, 0.12229154f, -0.14276911f, 0.05089531f, 0.04085229f, 
    -0.21618895f, 0.11794219f, 0.04935438f, -0.00740121f, 0.04619856f, -0.01678343f, -0.07862271f, -0.10521246f, 
    0.15639751f, -0.23596722f, 0.30109805f, 0.00885904f, 0.09561900f, -0.09272428f, -0.30625498f, -0.31334057f, 
    0.03600561f, 0.09710664f, 0.05465512f, 0.08221097f, -0.33942670f, -0.02160662f, 0.08463836f, -0.09369838f, 
    0.06289217f, -0.06062583f, -0.07617620f, 0.10801852f, -0.12768325f, 0.04057098f, -0.06401829f, -0.07707275f, 
    -0.10188356f, 0.02495876f, 0.07245726f, 0.11541037f, 0.13049656f, 0.04059168f, 0.05188555f, -0.10055660f, 
    0.11668053f, 0.09207310f, -0.08644242f, 0.12165842f, -0.00178028f, 0.04649314f, -0.11906003f, -0.12974957f, 
    0.18534917f, 0.02773187f, -0.23480003f, 0.10824625f, -0.10428961f, -0.08662355f, -0.06544290f, -0.28835198f, 
    -0.18444607f, 0.10653006f, -0.10736875f, -0.23047803f, -0.01025508f, -0.00436506f, -0.09009193f, 0.01611371f, 
    -0.01742536f, -0.00669329f, -0.01304333f, -0.25701812f, 0.16788697f, -0.15875775f, -0.11776188f, -0.16831368f, 
    0.09220151f, -0.06006490f, -0.00782495f, -0.03461931f, 0.15740417f, 0.00209590f, -0.03827253f, 0.16394591f, 
    0.14708312f, -0.09078678f, 0.03937686f, 0.15660776f, -0.21045557f, 0.14355360f, -0.10172778f, -0.13803133f, 
    0.14460741f, -0.05114741f, -0.14724377f, -0.06962244f, -0.16837440f, 0.09635472f, 0.16896726f, 0.12367692f, 
    0.00490566f, -0.07577325f, 0.14524661f, 0.11137740f, 0.13971290f, 0.06115659f, 0.05607013f, -0.01755823f, 
    0.01083419f, -0.08332638f, -0.07889128f, 0.00402319f, -0.05724538f, -0.10714091f, -0.00631836f, 0.15213680f, 
    0.03131103f, -0.02224932f, 0.07653104f, -0.10594702f, 0.06426271f, 0.12448175f, 0.00298927f, 0.22938885f, 
    0.13670218f, 0.00796360f, -0.05381726f, -0.26408222f, -0.01185434f, 0.06209279f, 0.08214037f, 0.08289030f, 
    -0.08747655f, -0.04561923f, -0.03092960f, -0.04994677f, -0.03651525f, -0.14803731f, 0.02165931f, 0.01809666f, 
    0.03588042f, 0.06903434f, -0.03825341f, -0.09224560f, 0.26272503f, -0.04808484f, 0.06509555f, 0.06280090f, 
    0.26171941f, 0.09211982f, 0.17296915f, 0.18098684f, 0.04251318f, 0.06189210f, -0.11672755f, 0.00614045f, 
    0.12912697f, 0.07443393f, -0.19326422f, 0.31291974f, 0.04580694f, 0.02926579f, 0.07159644f, 0.15637733f, 
    0.09262946f, 0.06226543f, 0.11009913f, 0.25519916f, -0.16748190f, 0.21617596f, 0.18709138f, 0.09125652f, 
    0.00312679f, -0.00652354f, 0.13316929f, 0.11276428f, 0.07268917f, 0.13414986f, 0.10438661f, 0.07917587f, 
    0.02288514f, -0.05320345f, 0.05884455f, 0.08141074f, 0.00561443f, -0.01231782f, -0.08943442f, 0.06638105f, 
    0.04542998f, 0.21635309f, -0.11433957f, 0.02471238f, 0.05515204f, -0.05422110f, -0.03502984f, -0.00683797f, 
    0.04605679f, -0.06880455f, -0.13543335f, -0.39306548f, -0.06540909f, -0.00224508f, 0.09591907f, 0.05887042f, 
    -0.23545009f, 0.00899176f, 0.04780964f, 0.06479678f, -0.07727411f, 0.05181860f, 0.11988396f, -0.07452352f, 
    0.00676718f, 0.04169343f, -0.00214394f, -0.04326715f, 0.07935621f, 0.17662507f, -0.12153478f, -0.08273695f, 
    -0.02756078f, 0.20364629f, 0.01449236f, 0.04510833f, 0.13067676f, -0.00424640f, -0.16792487f, 0.07888917f, 
    -0.08537610f, 0.02924482f, 0.05913527f, 0.08275159f, -0.12395878f, 0.01652468f, 0.00297600f, -0.29758608f, 
    -0.06176006f, 0.09484750f, 0.13554607f, 0.01916115f, 0.07821278f, 0.11518281f, 0.14198044f, 0.12727930f, 
    -0.05425327f, 0.13621187f, 0.07767390f, 0.07675093f, 0.03211848f, 0.00721631f, 0.15120636f, 0.01230205f, 
    0.02004747f, 0.01540408f, 0.14202802f, 0.20108601f, 0.04965147f, 0.04579172f, 0.15793616f, 0.22648694f, 
    0.03636918f, 0.07427104f, 0.06748435f, -0.21706161f, 0.19526610f, -0.03822124f, -0.06702112f, 0.28943172f, 
    0.00525514f, 0.15653646f, 0.06433617f, -0.07113658f, 0.07209154f, -0.02947976f, 0.13862203f, 0.16228540f, 
    0.06404748f, -0.01509821f, -0.11568061f, 0.15220174f, -0.04749380f, 0.10477045f, -0.11207301f, -0.06852975f, 
    -0.24260810f, -0.10408264f, -0.12665936f, -0.36277276f, -0.04510384f, 0.13754660f, 0.00231602f, 0.20211716f, 
    -0.13086873f, 0.03227209f, 0.12422961f, -0.13025469f, -0.19581789f, 0.04627652f, 0.03345058f, -0.07216679f, 
    0.01077219f, -0.02440666f, -0.08072135f, 0.13052636f, 0.08824407f, 0.00118804f, -0.02971736f, 0.12292280f, 
    0.01572430f, -0.03217117f, 0.01547631f, 0.02997245f, -0.10940657f, 0.33865687f, -0.12943017f, 0.11767690f, 
    0.16665524f, 0.00336015f, 0.01843305f, -0.00414091f, -0.06870158f, 0.23937893f, 0.01913836f, -0.01188292f, 
    0.07028815f, -0.06163352f, 0.15970956f, -0.23132180f, 0.07745088f, 0.02319669f, -0.05685704f, 0.09435529f, 
    -0.03701074f, -0.03137826f, -0.00822632f, -0.07473990f, -0.13478607f, 0.04556268f, 0.00070743f, 0.05339574f, 
    0.05405588f, 0.08561179f, 0.00719321f, -0.01088674f, -0.07135190f, -0.03471608f, -0.05494206f, -0.02656973f, 
    -0.04068811f, 0.41248432f, 0.33153781f, 0.26752049f, 0.01120678f, -0.01876535f, 0.04499314f, 0.03638985f, 
    -0.14174084f, -0.08155861f, -0.01240829f, 0.08711918f, -0.18504269f, 0.27678850f, 0.09703403f, 0.05399172f, 
    -0.08872551f, -0.04401038f, -0.09010512f, 0.04021991f, -0.05499671f, 0.01295843f, 0.13329302f, -0.05020630f, 
    0.25822848f, -0.00423016f, 0.21545725f, -0.35630867f, 0.05412822f, -0.07990601f, -0.16351812f, -0.04713213f, 
    0.06675591f, -0.02233006f, 0.00517195f, -0.05040428f, -0.01919834f, -0.07815260f, -0.00617167f, 0.01140564f, 
    0.04043273f, 0.03790208f, 0.12252010f, -0.01074679f, 0.09135752f, 0.04824535f, -0.00984493f, -0.00174676f, 
    -0.27709949f, 0.42584905f, -0.02560385f, 0.20821314f, -0.03994726f, 0.08387860f, 0.11970767f, 0.01400998f, 
    0.17679578f, 0.05030543f, 0.06203609f, 0.10819132f, -0.21374242f, 0.40708151f, 0.29994145f, 0.05744930f, 
    -0.00546130f, -0.06618463f, -0.22266479f, 0.00350297f, -0.10281193f, -0.02120691f, 0.04286049f, -0.09902579f, 
    -0.17244256f, 0.05255185f, -0.20351551f, -0.04137562f, -0.06062856f, 0.08136116f, -0.03478909f, -0.03681391f, 
    -0.12265972f, -0.21230315f, -0.01426812f, 0.25940228f, -0.09191799f, -0.08910190f, 0.04967569f, 0.11401668f, 
    0.13053730f, 0.05279805f, -0.28536916f, 0.15965655f, -0.12487136f, -0.03705346f, 0.01243675f, -0.11567973f, 
    0.32140672f, -0.13190547f, 0.11382291f, -0.00934646f, -0.07842951f, 0.04600797f, -0.02833528f, 0.09880099f, 
    0.01920711f, -0.00465650f, -0.08876757f, -0.10113167f, 0.11178578f, 0.24140863f, 0.30096531f, 0.24823271f, 
    0.01432800f, -0.15016074f, -0.09569792f, 0.03613783f, 0.06434003f, 0.09015152f, 0.00938739f, 0.12061117f, 
    0.01876802f, -0.12520222f, -0.02525832f, 0.22828096f, 0.01370567f, 0.04355972f, 0.09483936f, 0.01131597f, 
    0.04515561f, 0.03227537f, 0.05292254f, 0.05614470f, 0.11344609f, -0.12934180f, 0.10991781f, -0.24241334f, 
    0.00735367f, -0.03180706f, 0.03530432f, 0.04301329f, -0.04653003f, 0.14525983f, -0.11374904f, 0.07138433f, 
    -0.13731611f, -0.23895915f, -0.14712322f, -0.02126266f, -0.14112008f, -0.07122149f, -0.09053254f, 0.03194920f, 
    -0.00414423f, -0.01815469f, -0.05662670f, -0.00946315f, -0.16755010f, 0.29403502f, 0.33552501f, 0.14402229f, 
    -0.03602153f, 0.14348997f, -0.02336326f, 0.17834491f, -0.02427547f, 0.07009771f, 0.08466032f, -0.00153727f, 
    -0.16110454f, -0.06993198f, -0.12220262f, -0.20179357f, -0.11485398f, 0.05489212f, 0.08681115f, 0.06706457f, 
    -0.04863384f, -0.04137551f, -0.03368210f, -0.08115764f, -0.24392006f, -0.04730603f, -0.04995940f, 0.18550415f, 
    -0.06769254f, -0.06586680f, -0.08922439f, 0.15921965f, -0.01174863f, 0.00849873f, 0.07225273f, 0.04317907f, 
    -0.22004589f, -0.18580307f, 0.25761387f, -0.15863544f, 0.07744180f, 0.03942238f, -0.05923074f, -0.18575260f, 
    0.04690554f, 0.11927362f, 0.13609207f, 0.15883192f, 0.16481079f, 0.02881120f, 0.11123352f, -0.03926920f, 
    0.05498078f, -0.10969001f, -0.19984719f, -0.19091807f, 0.13649575f, 0.08186793f, 0.00326827f, 0.15656990f, 
    0.04090735f, 0.23925255f, 0.16754590f, 0.00936039f, 0.12351974f, 0.04839270f, -0.12688099f, -0.02351225f, 
    -0.04916607f, 0.07067546f, -0.20053799f, 0.01658542f, -0.07061826f, 0.21176273f, 0.12702917f, 0.12674342f, 
    0.03529932f, 0.05169575f, 0.03126966f, 0.10774940f, 0.01326476f, 0.03486292f, 0.05759189f, 0.00329343f, 
    0.02638105f, 0.07433164f, 0.05840805f, 0.06203550f, -0.03005202f, 0.02523566f, 0.03358413f, -0.15678275f, 
    0.03265293f, 0.03595009f, 0.02732655f, 0.02106726f, 0.04547762f, -0.04695357f, 0.02980034f, 0.14073400f, 
    0.05655935f, -0.02792740f, -0.02929961f, 0.06964813f, 0.03840427f, 0.02338476f, -0.00113937f, 0.04891365f, 
    -0.03297971f, -0.15972155f, 0.00160323f, 0.05803167f, -0.02158042f, -0.01970251f, 0.08261646f, 0.00098248f, 
    -0.08434862f, 0.10019103f, 0.03748695f, 0.04827451f, -0.12384287f, -0.20539202f, -0.11678150f, 0.16988987f, 
    0.24737495f, -0.02093101f, -0.08926339f, -0.00393544f, -0.01650684f, 0.00159395f, 0.02342336f, 0.01175850f, 
    -0.21161534f, -0.03373362f, -0.07464953f, -0.02706409f, -0.03646723f, 0.09190223f, -0.02443517f, 0.04049409f, 
    -0.05624770f, -0.01193834f, -0.01081327f, -0.00826456f, 0.27614754f, -0.27108511f, -0.16233175f, -0.01945176f, 
    -0.07416910f, 0.07254332f, 0.02981269f, -0.01579414f, -0.04386200f, -0.00092917f, 0.20170650f, 0.23676516f, 
    0.05232023f, -0.12817045f, 0.04654287f, 0.06342357f, 0.05763259f, -0.09361655f, 0.05719768f, -0.03224081f, 
    -0.04542601f, 0.00491093f, -0.03530291f, 0.02279879f, 0.11770016f, -0.11687845f, 0.05003241f, -0.14925879f, 
    0.14132500f, 0.02960199f, 0.02466624f, 0.06515273f, 0.03764426f, -0.02256761f, 0.00668224f, -0.03748234f, 
    -0.00613923f, 0.01564652f, -0.04509002f, -0.05155307f, -0.04124400f, 0.05078346f, 0.02540186f, -0.05518776f, 
    0.02001249f, -0.04182701f, 0.04126873f, 0.03276930f, 0.00421830f, 0.01431384f, 0.01660295f, 0.04239968f, 
    0.03041886f, 0.01439201f, -0.04742767f, 0.00660230f, 0.01450785f, -0.04888200f, 0.02421054f, -0.04548444f, 
    0.02941414f, 0.03502470f, 0.02050359f, -0.02762162f, 0.01846650f, -0.04466149f, -0.04782670f, -0.03433336f, 
    0.01711619f, -0.02185595f, 0.04721983f, -0.00174035f, 0.03489681f, 0.02082656f, -0.05597294f, -0.05406281f, 
    -0.02858574f, 0.00488529f, -0.00632019f, -0.01557297f, 0.04788066f, -0.03419460f, 0.00739750f, 0.00400101f, 
    -0.03320419f, -0.02760249f, -0.03620273f, -0.04939367f, -0.02138176f, -0.01825707f, -0.00481880f, -0.01230382f, 
    0.03048155f, -0.04661712f, -0.01681994f, 0.03119244f, -0.01258617f, -0.03982370f, 0.00597082f, -0.00154998f, 
    -0.01934482f, -0.04321689f, 0.04555501f, 0.04871656f, -0.02501893f, -0.00614167f, 0.03790784f, 0.03247822f, 
    -0.03307603f, -0.00463939f, -0.03585178f, 0.02822368f, -0.03118474f, -0.04247564f, -0.03535954f, -0.00553784f, 
    0.04569803f, -0.03931728f, -0.03358531f, -0.00096241f, -0.01220835f, -0.04738482f, -0.04613376f, 0.01554601f, 
    -0.00458833f, -0.00046337f, 0.03166911f, -0.01680704f, -0.02291154f, -0.02069198f, 0.03236093f, -0.02643260f, 
    -0.04380198f, -0.02287244f, -0.02529277f, 0.03054126f, 0.02358837f, 0.04014461f, -0.01833408f, -0.03124226f, 
    0.02837239f, 0.03216345f, 0.03879319f, -0.03804223f, 0.01421901f, -0.01932974f, 0.00342499f, -0.03813974f, 
    -0.02702751f, 0.02995717f, -0.00353800f, 0.02804249f, 0.02625849f, 0.04016814f, -0.04826634f, 0.03086872f, 
    -0.02426063f, 0.00739318f, -0.04559120f, 0.00905567f, -0.00783824f, -0.00330510f, 0.03412097f, -0.02940064f, 
    0.03492358f, 0.01628926f, 0.01681043f, 0.00791815f, -0.00864572f, 0.04327841f, -0.00822940f, 0.01190720f, 
    0.02908048f, -0.01402316f, -0.02826948f, -0.00839582f, 0.04022468f, -0.03519434f, 0.01873157f, 0.02524575f, 
    -0.02923999f, 0.02246897f, 0.03716824f, -0.04301270f, -0.04868997f, 0.01694491f, 0.04649347f, -0.00461339f, 
    0.02741729f, -0.03469710f, -0.01198288f, 0.04003634f, 0.01505658f, -0.05060446f, -0.05268503f, 0.04255416f, 
    -0.03113479f, 0.00298689f, -0.00426263f, 0.01513245f, -0.02933674f, -0.02792666f, 0.04092293f, 0.00384189f, 
    -0.02354985f, -0.03327695f, -0.02006939f, 0.02825960f, -0.00883960f, -0.00227509f, 0.03632268f, 0.03466941f, 
    0.02142269f, 0.00800685f, 0.01788284f, 0.01616399f, -0.01123381f, -0.01349615f, 0.04519046f, 0.02043043f, 
    -0.00451838f, -0.00750832f, -0.02581415f, -0.04434495f, 0.01619007f, 0.02125056f, -0.00994853f, 0.03897424f, 
    0.01691926f, -0.04980933f, 0.01007363f, -0.02063777f, -0.05514859f, 0.00142684f, 0.01540183f, 0.01719351f, 
    0.03059578f, 0.02450421f, -0.02114801f, -0.01064934f, 0.04067482f, 0.04241812f, -0.00930861f, -0.04685218f, 
    -0.02289782f, 0.03065149f, 0.00185923f, -0.00558066f, 0.03925296f, 0.03076740f, -0.05427990f, 0.03294084f, 
    -0.00053409f, -0.01791475f, -0.00969538f, -0.02935256f, -0.01928850f, 0.00047148f, 0.00874695f, 0.04160045f, 
    0.02099313f, -0.05109882f, -0.01389884f, 0.04093770f, 0.01067355f, -0.04699634f, 0.00075973f, -0.04926917f, 
    -0.01795053f, 0.04795432f, -0.01603650f, 0.03456148f, -0.02500274f, 0.04616067f, 0.02019708f, -0.00525603f, 
    -0.01084641f, 0.02796921f, -0.04070193f, 0.02544487f, 0.01277713f, -0.00857937f, 0.03073880f, -0.00870885f, 
    -0.03427594f, 0.00155653f, 0.04012583f, -0.05245560f, -0.02578843f, -0.04102783f, 0.04683073f, -0.04818258f, 
    -0.00219262f, -0.01835618f, -0.01509511f, 0.00279093f, -0.04191823f, -0.03609032f, 0.00963157f, -0.00555291f, 
    -0.01063532f, -0.00344617f, -0.03686144f, 0.00717898f, -0.03076647f, -0.02493603f, -0.03435617f, -0.02083144f, 
    -0.02111968f, -0.04049755f, -0.01636943f, 0.01942831f, -0.00289375f, -0.02934828f, 0.03562608f, 0.02124305f, 
    0.02035447f, 0.03225626f, -0.02849009f, 0.02904048f, 0.03670412f, -0.02021024f, -0.05605032f, -0.05014754f, 
    -0.04049903f, -0.04474491f, 0.02821340f, -0.02060845f, -0.05246524f, -0.02264479f, -0.00886572f, 0.03010148f, 
    0.00014158f, 0.03711327f, -0.03110659f, 0.03897352f, -0.03079838f, -0.00655407f, 0.03827181f, 0.00042842f, 
    -0.05516929f, 0.02174532f, -0.03024635f, 0.02914339f, -0.03076748f, -0.05161063f, -0.00487649f, -0.01462941f, 
    -0.03062466f, -0.05686263f, -0.02451636f, -0.04050913f, -0.01141500f, 0.00157344f, -0.01423049f, -0.05241089f, 
    -0.05420364f, 0.01263937f, 0.04298512f, 0.02994011f, -0.04870471f, -0.00648209f, -0.05214413f, -0.01140885f, 
    -0.03904458f, -0.02694826f, -0.05806422f, 0.00979007f, -0.01986521f, -0.03150371f, 0.01820568f, -0.03097145f, 
    -0.02176463f, -0.05251767f, -0.03136129f, 0.03837769f, 0.00500948f, 0.00630677f, 0.02078230f, 0.00024020f, 
    -0.00323726f, 0.02158756f, -0.01393516f, 0.02224129f, 0.01514828f, -0.00881973f, 0.02876037f, 0.00716853f, 
    -0.04714455f, 0.04781771f, -0.05112596f, 0.00923610f, 0.04455986f, 0.01989668f, 0.02898452f, 0.02773870f, 
    -0.01831522f, -0.05095970f, 0.01134834f, -0.01296407f, -0.04918632f, 0.00450457f, -0.05277578f, -0.04110536f, 
    -0.01961151f, -0.01315362f, -0.03165264f, -0.04141704f, -0.05304773f, -0.02419603f, 0.00248070f, 0.01128528f, 
    -0.01406731f, -0.00125931f, -0.00276637f, -0.00579196f, -0.02379591f, 0.00360744f, -0.01216042f, -0.01002559f, 
    0.00136459f, -0.04402724f, -0.02842845f, -0.03793112f, -0.01697460f, -0.01698581f, -0.03860611f, -0.01250939f, 
    0.01829717f, 0.04301780f, 0.02500512f, 0.01962318f, -0.02198239f, 0.00998772f, -0.05239975f, 0.02855684f, 
    0.00393193f, -0.00488831f, 0.01363600f, 0.02911402f, 0.00235665f, -0.01257350f, -0.04892218f, 0.02673738f, 
    -0.01204746f, 0.01071162f, -0.03465141f, -0.05619632f, -0.01597901f, 0.03513345f, 0.01636630f, -0.00824971f, 
    -0.01458248f, 0.02244946f, 0.04419709f, 0.01597946f, 0.00738759f, -0.03670005f, -0.00350036f, 0.03171175f, 
    -0.03867519f, -0.03453415f, 0.01514249f, 0.03684877f, -0.02393623f, 0.04354535f, -0.04681270f, 0.03086590f, 
    -0.03735986f, -0.01222445f, 0.00254959f, -0.05144912f, 0.04328451f, -0.01359683f, -0.02557503f, -0.05193073f, 
    -0.04133715f, -0.00320361f, -0.03286669f, -0.04693512f, -0.04580858f, 0.00882208f, 0.00244530f, -0.03637717f, 
    0.03252127f, 0.01864107f, 0.01581874f, 0.01589449f, 0.03638287f, 0.02433798f, 0.03605571f, -0.04680828f, 
    0.02635270f, -0.03284674f, -0.02263934f, -0.05601164f, 0.02162158f, -0.01090365f, -0.01417449f, 0.04575045f, 
    -0.00214297f, 0.01431322f, 0.00026066f, -0.01093768f, -0.01658585f, -0.02380662f, 0.00340186f, -0.04179933f, 
    -0.03295673f, 0.02574032f, -0.04586326f, -0.01080346f, -0.00916844f, -0.00875634f, -0.00302809f, -0.04940782f, 
    0.00666092f, 0.03310432f, -0.04923265f, 0.03577172f, 0.03214367f, -0.00759679f, -0.01451211f, 0.03091098f, 
    -0.00758306f, 0.01618747f, 0.04016993f, 0.01629019f, 0.03473734f, -0.04275693f, -0.02181816f, -0.00704155f, 
    0.00360526f, 0.00778239f, 0.02957704f, 0.00390268f, -0.00346557f, 0.03955508f, -0.01718429f, -0.04862302f, 
    -0.04301187f, 0.02588029f, -0.02309377f, 0.03783781f, -0.05528119f, 0.04531487f, 0.02579938f, -0.00255475f, 
    -0.04115470f, -0.00914988f, 0.03772806f, -0.03597440f, -0.04396548f, -0.04953285f, -0.03799103f, -0.04896463f, 
    0.00150157f, 0.00230023f, -0.00302964f, -0.04636048f, 0.00316247f, 0.01666188f, -0.04816552f, -0.02773561f, 
    -0.01855103f, -0.00601702f, -0.00378826f, 0.03773808f, -0.04648146f, 0.02140596f, -0.04500404f, 0.02782409f, 
    0.04136501f, 0.03189243f, -0.03892624f, 0.02773527f, 0.00906908f, -0.04174833f, 0.00296798f, -0.04038893f, 
    0.01060628f, -0.01372920f, 0.01511041f, 0.02817472f, 0.00425446f, -0.02543274f, 0.02144489f, -0.00014718f, 
    0.01738980f, -0.00993997f, 0.04173157f, -0.01801595f, -0.01577166f, -0.01504836f, -0.01929466f, -0.01546494f, 
    0.03711982f, -0.02797845f, -0.02676379f, -0.04376198f, 0.00260683f, -0.04576104f, 0.03056843f, 0.02639858f, 
    0.00049149f, 0.00836421f, -0.03976949f, 0.00727991f, 0.05139200f, -0.05277566f, 0.03851747f, -0.03018746f, 
    -0.04592127f, -0.00325595f, 0.04961341f, -0.00563012f, 0.04912086f, 0.02403800f, -0.03918695f, 0.02755287f, 
    0.01484859f, 0.00693837f, 0.02231824f, -0.03027656f, -0.05032331f, 0.03817242f, 0.00354844f, -0.00483534f, 
    -0.01684010f, 0.03194407f, -0.03472608f, -0.01437926f, -0.03040011f, -0.04274419f, 0.01249272f, 0.01454374f, 
    -0.02046170f, -0.02578090f, -0.00424186f, 0.01951092f, -0.03457746f, -0.03028898f, -0.01865423f, 0.00852510f, 
    -0.04860264f, 0.00119092f, 0.00144203f, 0.04972143f, 0.02827228f, -0.01626646f, -0.02682119f, 0.03869626f, 
    -0.02879239f, -0.04899820f, -0.04880840f, -0.02521106f, 0.01590717f, 0.00288340f, -0.03772379f, -0.01200009f, 
    -0.04659671f, -0.02391958f, 0.01108068f, -0.02669024f, -0.00195517f, 0.00557718f, 0.00393541f, 0.00485042f, 
    -0.01188858f, -0.02814092f, 0.04563752f, -0.02446000f, -0.02664272f, -0.03016544f, 0.01278382f, -0.02480681f, 
    -0.03643128f, -0.03224574f, -0.05589668f, 0.03041227f, -0.00596529f, -0.01040100f, -0.00446983f, -0.00760354f, 
    -0.05395066f, -0.02960223f, -0.02781175f, -0.03448085f, -0.00749077f, 0.03724525f, -0.05397160f, 0.03655342f, 
    0.01309546f, -0.03510405f, 0.03937550f, -0.04292097f, 0.03477655f, -0.05414290f, 0.02202363f, 0.02288065f, 
    -0.04226695f, -0.03231876f, -0.00447459f, 0.02511408f, 0.03666209f, 0.01174296f, -0.04839083f, 0.02947579f, 
    0.02232989f, -0.02628489f, 0.02401307f, -0.04730816f, 0.00803085f, -0.03944137f, -0.03237604f, -0.01635590f, 
    0.03874262f, 0.00567603f, 0.00822008f, -0.04531142f, -0.03956606f, -0.02631419f, 0.01861875f, -0.03868654f, 
    0.00502187f, -0.00043557f, 0.01945442f, -0.05488897f, 0.02192564f, -0.03469256f, -0.01068406f, -0.03126727f, 
    -0.03134906f, 0.01474611f, 0.00570064f, -0.00694351f, 0.03623952f, -0.01561034f, 0.00692317f, -0.01426589f, 
    0.03581874f, -0.03744821f, -0.03150857f, 0.00401650f, 0.02541913f, 0.01880791f, -0.00815631f, 0.03972738f, 
    0.03893090f, 0.04599419f, 0.00606439f, -0.00620062f, 0.01960477f, -0.02250540f, 0.01061180f, 0.01107269f, 
    -0.00821338f, 0.02462634f, 0.04988210f, -0.04388128f, -0.01269763f, -0.03270737f, 0.02695187f, 0.02701610f, 
    -0.03344089f, -0.04367708f, 0.03538544f, 0.04246727f, -0.01339600f, 0.03809262f, 0.01392970f, -0.02627839f, 
    -0.03280357f, -0.01860030f, -0.01925777f, -0.02041988f, -0.01284694f, 0.04529596f, 0.02352616f, 0.00176909f, 
    -0.04701239f, -0.02851770f, 0.04194460f, -0.00849838f, 0.04603080f, 0.01536427f, -0.00175580f, -0.02850829f, 
    0.03018632f, 0.03035888f, 0.03379517f, -0.02994686f, -0.00500215f, 0.03265249f, -0.03432605f, 0.00043012f, 
    0.03470463f, -0.01443698f, 0.01058376f, -0.01678292f, 0.01415253f, -0.04246019f, -0.05943516f, 0.00847516f, 
    0.04023330f, -0.05520258f, 0.00430429f, -0.04184433f, -0.03065801f, -0.04476346f, 0.02173006f, -0.01062662f, 
    -0.02394893f, 0.01430663f, -0.02033080f, -0.02410564f, 0.01262213f, -0.00501720f, -0.00782253f, 0.01690023f, 
    -0.00234337f, -0.03994296f, 0.03566992f, 0.02925185f, 0.00734896f, -0.05537946f, 0.04167638f, 0.00960767f, 
    0.00239092f, 0.03232707f, -0.02966137f, -0.01318431f, 0.01871476f, -0.00993865f, 0.01634917f, 0.01069697f, 
    -0.00688340f, 0.00405751f, -0.04168677f, 0.02233228f, -0.02054382f, 0.02346918f, -0.03722228f, -0.03078875f, 
    0.03345228f, 0.02144148f, -0.02591501f, 0.00882746f, -0.02245955f, 0.04209097f, -0.02386615f, -0.03700893f, 
    -0.05350882f, -0.00650540f, 0.03067300f, -0.00335535f, -0.05145446f, 0.03672823f, -0.05006892f, 0.00797253f, 
    0.00537626f, -0.03798776f, 0.04502299f, -0.03958629f, -0.03582118f, -0.05517178f, 0.00597570f, 0.00410058f, 
    0.04469503f, 0.01352026f, -0.02604383f, -0.02627562f, 0.04875082f, 0.00318290f, 0.03838060f, -0.03659751f, 
    0.00627363f, 0.03319816f, -0.04890845f, -0.01924923f, -0.04321392f, 0.02100133f, -0.02162637f, 0.00053198f, 
    0.00194735f, -0.02482009f, 0.01413025f, -0.01806635f, -0.02385346f, 0.03785264f, 0.01769112f, 0.00902063f, 
    0.03576504f, -0.00306820f, -0.03397162f, 0.04220905f, -0.00863603f, -0.04214124f, 0.04411814f, -0.02230189f, 
    0.03528167f, 0.00515411f, -0.05644767f, -0.04953441f, -0.03874086f, -0.00334307f, 0.01552712f, -0.03383735f, 
    -0.03253791f, 0.00667328f, 0.02698137f, -0.02135280f, 0.05041856f, -0.02835294f, -0.01929351f, -0.00172142f, 
    -0.00088719f, -0.03838343f, 0.03038004f, -0.00470731f, -0.00995893f, 0.01409144f, 0.01085027f, 0.03381367f, 
    0.03528626f, -0.01023593f, 0.02319035f, -0.04175840f, -0.00434868f, -0.00221723f, -0.05489024f, -0.01575505f, 
    -0.02795008f, -0.01900079f, -0.01497207f, 0.02532695f, 0.01131202f, 0.01048216f, 0.00633628f, -0.02409494f, 
    -0.04866930f, -0.03703700f, 0.04408429f, -0.01561163f, 0.04355877f, -0.02752351f, 0.00261983f, -0.00844961f, 
    -0.04482524f, -0.04712243f, 0.00041692f, -0.01535756f, 0.01381840f, -0.02412374f, 0.00904842f, 0.04245522f, 
    0.04131253f, -0.03979919f, 0.02132534f, -0.00137462f, -0.00134257f, -0.03376398f, -0.02257501f, -0.05267530f, 
    -0.00690714f, -0.05228906f, 0.00549219f, -0.03682158f, 0.00840717f, -0.01719165f, -0.04876803f, -0.01245328f, 
    -0.00559845f, 0.03660646f, -0.04397296f, 0.01328678f, 0.01705030f, 0.00010562f, -0.02192278f, -0.00515491f, 
    0.03647716f, -0.00442519f, 0.02725303f, -0.05407617f, -0.05370633f, -0.04166025f, -0.04492991f, -0.04789716f, 
    0.04271567f, -0.03789816f, 0.02453106f, 0.01687412f, -0.05437246f, -0.01894937f, -0.05249270f, -0.01513002f, 
    0.03694183f, -0.01671253f, 0.00051761f, -0.01585313f, -0.04512940f, -0.03320869f, -0.04949637f, -0.03090662f, 
    -0.04506244f, 0.01432169f, 0.01480692f, 0.01079464f, -0.01395124f, 0.01842026f, -0.03103814f, -0.01071968f, 
    -0.02667106f, -0.01266828f, -0.03079421f, -0.03626517f, 0.01787588f, -0.01515395f, -0.03812086f, 0.00052351f, 
    0.03824956f, -0.04914930f, 0.00330761f, 0.01881814f, -0.03853856f, -0.00847867f, 0.00038162f, -0.05690230f, 
    -0.01579408f, 0.02663083f, -0.00358781f, -0.01129109f, -0.02804906f, 0.01645036f, 0.01759456f, -0.00281604f, 
    -0.00630717f, 0.00792367f, -0.01519043f, 0.01171596f, -0.04068812f, 0.02330821f, -0.03339266f, -0.04836223f, 
    -0.03039018f, 0.01136175f, 0.00379024f, 0.04008280f, -0.05468202f, -0.02491591f, 0.03388673f, -0.02679238f, 
    0.00931426f, 0.02916339f, -0.04679935f, 0.03539149f, -0.00584144f, 0.03274357f, -0.00999868f, 0.03834847f, 
    -0.04185491f, -0.01571996f, 0.01021279f, -0.02366083f, -0.02274005f, -0.02398122f, 0.00055854f, 0.01707990f, 
    -0.04975051f, -0.03753406f, 0.01198789f, -0.00818076f, -0.02901701f, -0.03016195f, -0.05665998f, 0.00915997f, 
    0.00836461f, -0.02953056f, -0.05271627f, 0.03027057f, 0.00736523f, -0.00176099f, -0.00774752f, 0.02170847f, 
    -0.00284373f, 0.01786443f, 0.02984288f, 0.04323491f, 0.01350053f, 0.01964531f, -0.03805520f, -0.02377730f, 
    -0.00649389f, -0.04580245f, 0.04004890f, 0.01636477f, -0.01733513f, -0.00071696f, -0.00280875f, -0.01213495f, 
    -0.01746083f, 0.02820598f, -0.03278892f, -0.01991720f, -0.05438277f, 0.00637974f, -0.04666350f, -0.05036061f, 
    0.03734681f, -0.00773308f, -0.04471675f, -0.01881178f, -0.02105599f, 0.01910511f, -0.04820314f, 0.02236266f, 
    -0.03058351f, 0.00894349f, -0.05166508f, 0.04220567f, -0.00023170f, -0.01820534f, 0.03841745f, 0.00796315f, 
    0.02578153f, 0.03873360f, 0.01159440f, -0.02793877f, -0.05425616f, 0.01501237f, -0.01452979f, -0.05398653f, 
    -0.05693465f, 0.00145733f, -0.02368037f, -0.04107928f, -0.02501534f, -0.03328409f, 0.00156468f, -0.02432579f, 
    0.00181599f, -0.01354290f, -0.03883232f, 0.03652614f, 0.04169420f, -0.01882526f, -0.03809280f, -0.00646093f, 
    -0.04944452f, -0.02441046f, 0.00344004f, 0.01016530f, 0.00925059f, 0.02032145f, 0.02046208f, 0.02637396f, 
    -0.02764047f, 0.04160222f, 0.04387770f, -0.04741934f, 0.03471078f, -0.04532631f, -0.00165476f, 0.04295276f, 
    -0.03286802f, -0.02566585f, 0.03712015f, 0.01436233f, 0.03506297f, -0.04584014f, 0.00845540f, -0.01549543f, 
    -0.01163380f, -0.01650243f, 0.02058965f, 0.02936588f, -0.00962801f, 0.03602455f, -0.00424329f, -0.00738332f, 
    0.01059545f, -0.02975696f, 0.03665870f, -0.05543026f, -0.02606347f, 0.00321308f, -0.02592233f, 0.03196977f, 
    0.00475196f, -0.04541184f, 0.00567099f, -0.01843558f, 0.03872884f, 0.00282718f, -0.05231788f, 0.03891386f, 
    0.00026877f, 0.01191952f, -0.03442072f, -0.02536755f, -0.03669082f, -0.02974581f, -0.02946227f, 0.02687319f, 
    0.01707480f, 0.03693477f, 0.00071438f, 0.00703524f, -0.01671318f, 0.04480584f, -0.05242344f, -0.04385649f, 
    -0.03872285f, -0.02811454f, -0.00390924f, -0.00310905f, 0.01504761f, -0.03682777f, -0.02820961f, 0.03566346f, 
    0.03228362f, 0.01125694f, 0.03549599f, 0.02081992f, -0.00500975f, 0.00138032f, -0.05622503f, -0.00147778f, 
    0.02107613f, 0.03091183f, -0.00865296f, -0.03377467f, -0.04529249f, 0.01308837f, -0.02507338f, -0.05081287f, 
    0.04012461f, -0.02674740f, 0.03275075f, 0.00214459f, 0.02068523f, 0.02906268f, 0.02375262f, -0.04003182f, 
    0.03310277f, 0.01786061f, -0.04380680f, 0.02588440f, 0.00680696f, -0.04739376f, -0.01321791f, -0.02034967f, 
    -0.02547430f, 0.02348653f, -0.00178109f, -0.04957269f, 0.01453966f, -0.02184871f, 0.05100330f, 0.03333616f, 
    -0.02450086f, -0.00450825f, -0.01764035f, -0.03638666f, 0.01837724f, -0.01682620f, -0.04992420f, 0.02968026f, 
    0.03933672f, -0.01964316f, -0.00574454f, -0.03312891f, -0.00961220f, 0.01455008f, -0.03772642f, -0.03538680f, 
    -0.05000240f, -0.00599606f, 0.04007189f, 0.03484280f, -0.04102911f, 0.01453282f, 0.02513398f, 0.03193942f, 
    0.05051474f, -0.06004719f, -0.05334470f, -0.02278030f, 0.01538464f, 0.02002787f, 0.00213175f, -0.01350555f, 
    -0.05012759f, -0.03084934f, -0.04862527f, -0.05284402f, -0.05229554f, -0.01550037f, -0.02575911f, 0.03510011f, 
    0.03719454f, 0.00455862f, 0.02299117f, -0.04501617f, -0.03565414f, -0.00871935f, -0.01545042f, -0.03809693f, 
    -0.03657591f, 0.02508005f, -0.03836799f, 0.01204062f, 0.00026804f, 0.01030425f, 0.03269112f, 0.00483030f, 
    -0.04560944f, 0.03023152f, -0.03150990f, 0.00918782f, -0.02418828f, 0.02144514f, -0.00965461f, 0.03365016f, 
    0.03879076f, -0.05562185f, 0.04093787f, 0.02800008f, 0.02005137f, -0.03530825f, 0.03684570f, -0.04394370f, 
    -0.00516260f, 0.03587616f, 0.01683194f, -0.02107064f, 0.03565043f, -0.02832912f, 0.02449017f, 0.03157679f, 
    -0.00569796f, -0.00167964f, -0.00336496f, 0.03821130f, -0.02379409f, 0.01126900f, -0.05569877f, -0.00211277f, 
    0.00615997f, -0.05637930f, 0.02457519f, 0.02893026f, 0.03318799f, -0.03876476f, 0.02665230f, 0.02670977f, 
    0.01426105f, -0.02186131f, 0.01996485f, 0.01189953f, 0.01113092f, -0.00829305f, -0.00346710f, 0.02690061f, 
    -0.02273425f, -0.05628408f, -0.04131204f, 0.02269977f, -0.04253029f, 0.04265254f, 0.04330625f, 0.03381226f, 
    0.01761670f, 0.01395484f, -0.01814413f, -0.05356251f, -0.04418433f, 0.03945553f, 0.04231158f, -0.01045589f, 
    -0.00351126f, 0.01086691f, -0.05027866f, 0.01811405f, 0.01064207f, -0.00651412f, -0.00114960f, 0.02027744f, 
    -0.03676980f, 0.01533294f, -0.02578986f, 0.00885557f, -0.04278013f, -0.00665109f, 0.01888292f, -0.01583717f, 
    -0.04779190f, 0.01972662f, -0.03606024f, -0.05608331f, -0.03327879f, 0.02009004f, -0.01092349f, -0.04066714f, 
    -0.00336540f, -0.01584235f, -0.03675496f, 0.00906928f, 0.03863061f, -0.02107121f, -0.00736842f, 0.02240972f, 
    0.00809058f, 0.03819102f, -0.03799282f, 0.04036411f, 0.00368577f, 0.00110201f, -0.04535432f, 0.05685079f, 
    0.04436261f, 0.03350299f, -0.03751068f, 0.04124998f, 0.00681680f, -0.02069673f, 0.03906352f, 0.02001007f, 
    0.00843318f, 0.03157470f, 0.03706111f, -0.02499596f, -0.03854248f, -0.02501565f, -0.03628251f, 0.01820211f, 
    0.01745266f, 0.00133042f, 0.00061497f, -0.03371386f, -0.01065832f, -0.05662344f, 0.03839949f, -0.05116424f, 
    -0.03339180f, 0.02487149f, -0.02409815f, -0.01152591f, 0.04630876f, -0.00553639f, -0.04412496f, 0.01996980f, 
    -0.03455444f, -0.00923832f, 0.01185214f, -0.03948132f, 0.01419305f, -0.02479690f, -0.01315911f, 0.03190965f, 
    -0.04919485f, -0.00474969f, 0.03172619f, 0.00093483f, -0.03435576f, 0.01239797f, -0.03923147f, 0.01782254f, 
    -0.03421598f, 0.00243732f, -0.01077746f, -0.01430755f, -0.01867362f, 0.02100875f, -0.00578597f, -0.01601803f, 
    0.03810968f, -0.03514209f, -0.04157625f, 0.02155337f, -0.04674339f, -0.04278665f, 0.01154290f, 0.02937908f, 
    0.00916551f, 0.01984593f, -0.05429829f, 0.03342140f, 0.00491263f, -0.04014410f, 0.01334020f, -0.05160192f, 
    -0.03804747f, -0.05223368f, 0.00781231f, -0.02035224f, 0.01931011f, 0.03475515f, -0.00853268f, -0.00174115f, 
    -0.01564689f, -0.00000575f, 0.04282720f, -0.02835244f, 0.02726197f, 0.00301429f, -0.05397501f, 0.02451665f, 
    -0.05929973f, 0.00105125f, 0.03501435f, -0.01611633f, 0.01084543f, -0.03011327f, -0.04185898f, -0.00041897f, 
    0.01043118f, -0.04928830f, -0.02535211f, 0.00457802f, 0.00922661f, -0.03075637f, -0.05741503f, -0.03504814f, 
    -0.02073956f, -0.04315402f, -0.00185664f, -0.02839907f, 0.04508146f, 0.02420550f, 0.04109942f, -0.01222463f, 
    -0.02718526f, -0.03597695f, 0.01045858f, 0.01129966f, -0.05546573f, -0.04629191f, -0.01962653f, -0.05286958f, 
    -0.04075539f, 0.03586673f, 0.04122620f, 0.03159165f, -0.00410096f, -0.05756935f, 0.02915820f, -0.02469240f, 
    -0.03345076f, -0.00762016f, -0.05058412f, 0.02078705f, -0.01348470f, 0.02697995f, -0.01676397f, 0.00241004f, 
    -0.03389910f, -0.01634440f, 0.03792951f, 0.00285578f, -0.00033377f, 0.04520505f, -0.04737528f, -0.02685422f, 
    0.02393290f, 0.04588447f, 0.01567764f, -0.03103509f, -0.00166402f, -0.00135554f, 0.04015768f, 0.01244146f, 
    0.03611927f, 0.05576135f, 0.15784717f, -0.11592515f, 0.27175075f, 0.07397645f, 0.02973788f, 0.09345835f, 
    -0.00834118f, 0.09578600f, -0.03697008f, 0.01636125f, 0.08849518f, 0.13896309f, 0.14276856f, -0.12252108f, 
    0.04323819f, 0.18973725f, -0.00811015f, 0.06458016f, 0.09210338f, 0.07283180f, -0.07143869f, -0.08823989f, 
    0.26459289f, 0.16109851f, -0.06656937f, 0.17217585f, -0.01144739f, 0.02035766f, -0.01398792f, 0.05203434f, 
    0.01289901f, -0.05102277f, -0.10760963f, -0.07997763f, 0.13935320f, -0.15245903f, -0.05396803f, 0.00186313f, 
    -0.03547911f, 0.17834018f, -0.03679715f, 0.00707178f, 0.01181787f, 0.09106264f, 0.05971943f, -0.02092380f, 
    0.24011882f, 0.06815011f, 0.02256819f, -0.03916557f, -0.08227331f, -0.12146150f, -0.01325425f, 0.00640987f, 
    0.13362734f, 0.01126547f, -0.01321103f, 0.04088988f, -0.03984893f, -0.17749746f, 0.16848412f, -0.12299817f, 
    -0.19478036f, -0.03909633f, 0.08312903f, 0.22214887f, 0.01300932f, 0.08875351f, 0.02093729f, 0.08444497f, 
    0.00018323f, 0.34991029f, -0.02005017f, -0.12913883f, 0.05568363f, -0.03751737f, 0.34554318f, -0.05432477f, 
    0.04244657f, -0.08579084f, 0.02296576f, -0.01572533f, 0.18362537f, 0.16052505f, -0.05259649f, 0.03274396f, 
    0.00812497f, -0.04812640f, 0.09879027f, -0.02990802f, 0.08150422f, 0.01518737f, 0.04642409f, 0.00052244f, 
    0.14655839f, 0.03261748f, -0.27169144f, -0.14980245f, -0.07208566f, -0.00891167f, 0.02936707f, -0.02859199f, 
    0.01882502f, 0.10254002f, -0.01167400f, 0.07872534f, -0.06693464f, -0.23342147f, 0.20782053f, -0.19826062f, 
    -0.18582770f, 0.09235679f, -0.06308936f, 0.14609678f, -0.02640542f, 0.15656114f, 0.01915412f, 0.13592616f, 
    -0.01612227f, -0.03668454f, 0.06746793f, 0.17556743f, 0.11104535f, 0.01607030f, -0.03351899f, -0.08574071f, 
    0.12908004f, 0.10274632f, 0.06677836f, -0.00625070f, 0.23786193f, -0.25210834f, 0.06473009f, 0.04637640f, 
    -0.26225886f, 0.01769714f, -0.06455547f, -0.05142061f, 0.05665581f, 0.05685549f, -0.03889009f, 0.14893985f, 
    -0.26993006f, 0.19107911f, -0.14618535f, -0.05122203f, 0.05454151f, 0.16129111f, 0.15706243f, 0.12638204f, 
    0.19485921f, 0.11349563f, 0.12964348f, 0.11195047f, -0.13153781f, -0.04652309f, 0.01297009f, -0.15326038f, 
    -0.11500007f, -0.19899853f, 0.05448721f, 0.23167269f, 0.09637355f, -0.02206323f, -0.05875871f, -0.00260210f, 
    0.25369221f, 0.20754668f, -0.02241295f, -0.01195117f, 0.01652815f, -0.07964319f, 0.15817891f, -0.01059334f, 
    0.03956424f, 0.05256464f, -0.05006013f, -0.08164002f, 0.30760270f, 0.37082705f, -0.10378164f, 0.12181154f, 
    -0.00437178f, 0.04033519f, 0.02847462f, -0.01044878f, -0.00112573f, 0.04411808f, 0.05182675f, 0.01106404f, 
    -0.16553283f, -0.03553632f, 0.26229754f, 0.09648257f, -0.15044613f, -0.02803135f, 0.06976742f, 0.07308310f, 
    0.02005962f, 0.01695781f, 0.08600745f, -0.01268586f, -0.19002014f, -0.42991117f, 0.24297039f, -0.06209876f, 
    -0.14157517f, -0.04906677f, -0.06040910f, 0.15751992f, 0.03922344f, 0.02220918f, -0.02463977f, 0.01102416f, 
    -0.04433444f, -0.07686014f, 0.06835946f, 0.18849577f, -0.06942564f, 0.09810773f, 0.00334324f, 0.08495027f, 
    0.00716025f, 0.04502229f, -0.03746420f, 0.01612255f, -0.01880931f, -0.04528267f, 0.03436590f, 0.07848398f, 
    0.04954328f, 0.07946821f, 0.00513118f, -0.04222349f, -0.00046904f, -0.03249810f, 0.05858029f, -0.05397473f, 
    -0.39213917f, -0.01302241f, 0.04018204f, -0.07638815f, 0.03338110f, -0.09530567f, 0.01840214f, 0.03015479f, 
    -0.05535084f, -0.03167375f, -0.06289681f, -0.03150362f, 0.00650889f, 0.16587657f, -0.08224020f, -0.04649698f, 
    0.03506492f, -0.02612838f, 0.11062432f, -0.00937164f, -0.03592581f, -0.13573703f, -0.00294159f, -0.01113035f, 
    0.22342704f, 0.07822347f, 0.02649607f, 0.12317047f, -0.04037037f, 0.09261378f, -0.09368394f, 0.07534561f, 
    0.17201178f, -0.16373546f, 0.08620407f, -0.03739332f, 0.10331498f, 0.04461099f, 0.20205371f, -0.10398361f, 
    -0.04138201f, -0.07316076f, -0.03174850f, -0.05150241f, 0.07715069f, -0.05109324f, -0.05762308f, 0.05221971f, 
    -0.03869440f, 0.09152605f, 0.04129240f, -0.02190691f, 0.12024239f, -0.21391760f, 0.06626104f, -0.00909782f, 
    0.10106406f, -0.01021737f, -0.00990534f, 0.00344090f, -0.12451313f, 0.11115736f, 0.18179809f, 0.06905270f, 
    -0.02256682f, -0.07371920f, 0.11350581f, 0.14046478f, 0.07031798f, -0.01666313f, -0.02534697f, -0.07821684f, 
    -0.00002517f, 0.14296316f, -0.09495091f, -0.12678513f, -0.00149911f, -0.04493485f, 0.01403604f, -0.08498114f, 
    0.13423680f, -0.21555240f, -0.16350931f, -0.02552038f, -0.11416359f, -0.12059238f, 0.51035511f, -0.18533763f, 
    0.06695145f, 0.17502598f, -0.00751752f, 0.10027094f, 0.04038044f, -0.04067925f, -0.01849710f, 0.01374112f, 
    -0.00836226f, -0.02032860f, 0.34847280f, 0.14031716f, 0.04447402f, 0.01765527f, 0.05028174f, 0.03660493f, 
    0.07365747f, 0.02998828f, -0.01338556f, 0.00028147f, -0.16860647f, -0.04877103f, -0.12727621f, 0.19885740f, 
    0.04844556f, 0.00641743f, 0.06091871f, -0.03755314f, 0.13911989f, 0.04051347f, -0.09170838f, 0.02548484f, 
    -0.01880088f, 0.10438807f, 0.00480081f, -0.00421701f, -0.00833218f, -0.12283755f, 0.06794623f, 0.25244018f, 
    0.00689328f, 0.00122288f, -0.00035789f, 0.04966461f, 0.07259882f, 0.10812536f, 0.02165467f, -0.04572341f, 
    -0.17188655f, 0.13254438f, 0.04576443f, 0.08548301f, -0.03223430f, 0.00732268f, -0.05704653f, 0.04737623f, 
    0.16898602f, -0.16912398f, 0.09832515f, 0.01605012f, 0.04067271f, 0.11785092f, 0.12074962f, -0.07168414f, 
    0.00390100f, -0.00920668f, 0.02612109f, -0.05362849f, 0.43659824f, -0.06717485f, -0.18784706f, 0.01153670f, 
    0.13922644f, -0.10865830f, 0.18693824f, 0.00099521f, -0.01819177f, 0.14179151f, -0.01968925f, 0.01604447f, 
    -0.28665784f, -0.09108345f, 0.20317434f, 0.22058123f, -0.06006998f, 0.04058995f, 0.11325141f, 0.02646710f, 
    0.21374372f, -0.00962983f, 0.13861680f, 0.14072874f, -0.11905108f, -0.11388392f, 0.11213183f, -0.05568580f, 
    -0.06392042f, 0.18920062f, 0.04932936f, 0.04748672f, -0.09388981f, -0.02896637f, 0.03398734f, 0.15582930f, 
    0.02719750f, 0.20775244f, 0.06990877f, 0.06685034f, -0.07451795f, -0.00795916f, -0.06873718f, -0.01437614f, 
    0.08639372f, 0.03552775f, 0.02515443f, 0.02385810f, 0.27386829f, -0.01297251f, -0.02187125f, -0.22830960f, 
    0.04139956f, -0.04352182f, 0.01882557f, 0.04331715f, 0.01291369f, 0.01049897f, 0.09315826f, 0.13941596f, 
    -0.12197507f, 0.10115258f, 0.03775576f, -0.12965259f, 0.03442053f, 0.08907443f, 0.16968340f, 0.08199861f, 
    -0.04250978f, 0.14660224f, 0.13499434f, 0.10206603f, 0.05925420f, 0.03678839f, -0.21461529f, -0.02056027f, 
    0.11155321f, 0.15450536f, 0.17142715f, 0.03021359f, -0.14384995f, 0.01658343f, 0.06831064f, -0.08436763f, 
    -0.20728733f, 0.22411025f, -0.14486535f, -0.16594824f, 0.12745903f, 0.03975581f, 0.09204648f, -0.04515191f, 
    0.13264519f, 0.08439070f, -0.12000691f, -0.03579871f, 0.49420655f, -0.37342316f, -0.11232214f, -0.09607387f, 
    0.11545958f, -0.07111614f, 0.01119830f, 0.19447862f, 0.14413150f, 0.06455331f, 0.03438594f, 0.11693944f, 
    0.00350139f, 0.04867502f, 0.13663451f, -0.05258033f, 0.06837766f, 0.03388715f, 0.15494704f, 0.09913129f, 
    0.02671482f, 0.04958050f, 0.16666603f, -0.21958582f, -0.09625601f, -0.04977173f, 0.11174195f, 0.03977064f, 
    0.14978321f, -0.02844361f, -0.00970777f, 0.13517588f, 0.16045845f, -0.08637834f, 0.11087394f, 0.16423123f, 
    -0.02027827f, 0.16026668f, 0.00988386f, -0.02913832f, 0.09237139f, -0.18634830f, 0.38766560f, -0.01494151f, 
    -0.06675901f, 0.02431329f, 0.18633822f, -0.04240340f, -0.21686010f, -0.00678301f, -0.00078669f, -0.32228255f, 
    0.00341285f, 0.21021092f, 0.04651929f, -0.08586096f, -0.09776266f, -0.05777796f, 0.03916292f, -0.08637652f, 
    -0.21566133f, -0.10774753f, -0.17986193f, 0.19490802f, 0.10894509f, -0.16076121f, 0.22844586f, -0.23137274f, 
    0.01835584f, -0.02613892f, -0.01447828f, -0.01547479f, -0.10250871f, -0.08428642f, 0.00228170f, 0.10550196f, 
    -0.01308269f, 0.03790848f, 0.09530737f, -0.06238802f, -0.05753435f, -0.04400448f, -0.19614564f, 0.10370450f, 
    0.15966247f, -0.01249772f, 0.02527649f, -0.17077345f, -0.04984212f, -0.02462013f, 0.02311795f, -0.03294092f, 
    -0.04026587f, 0.03892329f, 0.04253704f, 0.02448393f, 0.14713036f, -0.12038209f, 0.00312537f, 0.09134184f, 
    0.01018794f, 0.01331397f, -0.00690500f, -0.00566809f, -0.01375727f, 0.04186970f, 0.06357028f, 0.00794230f, 
    0.13952264f, -0.04288715f, -0.06379464f, -0.08710806f, 0.21192841f, -0.09090444f, 0.07056307f, 0.08993363f, 
    0.05540788f, -0.05389766f, 0.18804295f, 0.00013036f, -0.11220682f, -0.12215035f, -0.31492162f, -0.14669734f, 
    0.14385249f, 0.08997519f, 0.09164771f, -0.11218220f, -0.02799683f, 0.04950559f, -0.05541217f, 0.01526602f, 
    0.08878113f, -0.36080584f, 0.09156181f, -0.10675392f, 0.03834875f, 0.08142801f, -0.05628011f, 0.07058477f, 
    0.13486725f, -0.00026909f, -0.07905065f, -0.00589663f, -0.07768708f, 0.02760692f, -0.15068613f, -0.03739526f, 
    -0.02175811f, -0.04208463f, 0.20090136f, 0.15203148f, -0.18415523f, -0.01324270f, -0.04071783f, -0.12876154f, 
    0.02114783f, 0.08401165f, 0.15886383f, 0.13138434f, 0.02476479f, 0.01747822f, 0.00102437f, -0.06021696f, 
    0.01353011f, -0.03799938f, 0.11188307f, 0.04163226f, 0.06662314f, 0.06033523f, 0.11589563f, 0.11952858f, 
    -0.01863507f, -0.08272702f, -0.01531690f, 0.01659258f, 0.05947664f, 0.23879199f, 0.05678229f, 0.02784852f, 
    0.12640285f, -0.12514573f, -0.09939072f, 0.03771697f, 0.08013508f, 0.03845154f, -0.05154417f, 0.14646624f, 
    0.00951478f, 0.04301216f, -0.14042200f, 0.05512372f, -0.05826137f, 0.22782701f, -0.11071715f, -0.19405849f, 
    -0.09148543f, 0.03150185f, 0.06175120f, 0.04027733f, -0.14130436f, -0.16140297f, -0.00423873f, -0.01912713f, 
    0.18454647f, 0.09279916f, 0.00845110f, 0.26936245f, -0.13201548f, -0.09237061f, -0.04566081f, 0.02731709f, 
    0.07030299f, 0.19608717f, -0.02486850f, -0.02345226f, 0.27469558f, -0.43545988f, 0.11075246f, -0.10914619f, 
    0.04840389f, 0.16294430f, 0.03479308f, 0.05069465f, 0.01946713f, 0.05205127f, 0.03190333f, 0.03952994f, 
    0.12615810f, 0.13960476f, -0.00254024f, -0.22240822f, -0.01491443f, -0.20083252f, 0.07712390f, -0.07874326f, 
    -0.05005047f, -0.03685945f, 0.00932700f, -0.01654798f, -0.25242454f, 0.18043286f, 0.09395891f, 0.02196009f, 
    -0.03443566f, 0.15028131f, 0.06947119f, 0.11286982f, 0.16426083f, 0.10813671f, -0.02415026f, -0.21456419f, 
    -0.00920611f, -0.02154542f, 0.00409007f, -0.10576461f, 0.00443870f, -0.14613056f, 0.16198955f, 0.05072741f, 
    0.19510010f, 0.20056228f, 0.07368056f, 0.10269515f, -0.08462976f, -0.11106508f, -0.04804471f, -0.02106970f, 
    -0.07027251f, -0.01950064f, -0.03381259f, 0.05180054f, 0.08073386f, 0.06435836f, -0.03540248f, 0.08152657f, 
    0.12789083f, 0.10907438f, -0.11526707f, 0.04456396f, 0.21209507f, 0.21986546f, 0.08371640f, 0.04824734f, 
    -0.07545299f, -0.01991161f, -0.10017692f, 0.01068013f, -0.08094226f, -0.06993931f, -0.06538727f, 0.06680270f, 
    -0.00268359f, 0.03299716f, 0.07267914f, 0.10971160f, -0.06781017f, -0.06514458f, 0.23106194f, -0.06284599f, 
    -0.08648337f, -0.24359477f, 0.19584411f, 0.04269376f, 0.16300647f, -0.06293022f, -0.00743184f, -0.05559341f, 
    -0.00440088f, -0.11380211f, -0.17646454f, 0.05703846f, -0.20700772f, 0.08502979f, -0.09689378f, 0.05495087f, 
    0.13688868f, 0.12256165f, 0.09532348f, 0.08739581f, 0.00627446f, -0.06949671f, -0.16658655f, -0.13912475f, 
    -0.33998844f, 0.31083009f, -0.06825969f, 0.25114086f, 0.01733823f, -0.16164097f, -0.06387556f, -0.03922484f, 
    -0.01758482f, -0.01812883f, -0.03559221f, -0.01356490f, -0.05117438f, 0.12058864f, 0.05723242f, -0.02880457f, 
    0.05164058f, -0.05778798f, -0.16122016f, 0.14268737f, 0.07210501f, 0.00640798f, -0.04626543f, 0.17031747f, 
    0.08560951f, 0.00433955f, 0.16958404f, -0.04303003f, 0.00963095f, 0.05143636f, -0.02323161f, -0.04813498f, 
    0.02014761f, -0.11888097f, -0.05234642f, -0.05952114f, 0.19224659f, -0.16405156f, -0.24799299f, 0.17954865f, 
    -0.05704259f, -0.08000723f, 0.11575067f, -0.08024967f, 0.08592313f, -0.07044228f, -0.09047450f, -0.04876680f, 
    -0.00221664f, 0.09349997f, 0.05813286f, 0.27366871f, -0.01042173f, -0.07047783f, 0.14691825f, 0.14180389f, 
    0.13334276f, 0.07466207f, 0.00595917f, 0.02159722f, -0.13050817f, 0.00090910f, 0.03714152f, 0.06343869f, 
    0.04207621f, 0.05904616f, -0.18284716f, 0.15482065f, -0.17531806f, -0.15454869f, -0.01846684f, -0.09887847f, 
    -0.20940298f, 0.01388891f, 0.28134000f, 0.21858272f, 0.17189868f, -0.04004285f, 0.09971767f, -0.12197562f, 
    0.08382316f, -0.07571913f, 0.15771045f, 0.25092345f, -0.12834162f, -0.01988411f, 0.21718469f, 0.14497985f, 
    0.10577155f, 0.14097278f, -0.10475677f, 0.01410178f, 0.06809825f, -0.13681257f, -0.07969911f, -0.20459844f, 
    0.22821632f, -0.23842646f, 0.20147714f, -0.23109739f, -0.08921690f, 0.22339554f, -0.06524383f, 0.04619582f, 
    0.14785020f, 0.01528693f, -0.00446220f, 0.00439822f, -0.12141445f, 0.21711212f, 0.18816252f, -0.05816679f, 
    0.05411648f, -0.15648630f, 0.05104395f, -0.11366533f, 0.03859628f, 0.05621269f, -0.04138988f, -0.01164342f, 
    -0.11713219f, -0.07272870f, -0.24656703f, 0.35045928f, 0.02016873f, 0.21428770f, -0.05984830f, 0.10923706f, 
    0.02752554f, -0.09152991f, -0.06543799f, 0.03659441f, 0.23888727f, -0.24622346f, -0.18931137f, -0.08756124f, 
    -0.03955379f, 0.03892615f, 0.05182432f, -0.05367172f, 0.00162529f, 0.11660311f, 0.12148944f, -0.04382528f, 
    0.04502225f, 0.13197902f, 0.21021649f, 0.02937863f, 0.05694351f, 0.10100161f, 0.17560345f, 0.07735398f, 
    -0.00351229f, -0.10046972f, 0.04051134f, 0.01847342f, -0.42299363f, 0.19158712f, 0.07974923f, 0.10809638f, 
    0.06924018f, 0.05011487f, -0.12144212f, 0.07249653f, -0.00127728f, 0.04621563f, -0.04402199f, 0.17415318f, 
    0.06658420f, -0.13311186f, 0.24338721f, -0.07173907f, -0.01213800f, 0.00046676f, 0.07039868f, 0.18033859f, 
    -0.01665590f, 0.03692703f, -0.24086864f, -0.06582477f, 0.15818457f, -0.07856096f, 0.42243099f, 0.22597151f, 
    -0.03706455f, -0.03479954f, -0.00583699f, 0.27687135f, -0.04100809f, -0.02989688f, -0.06445241f, -0.08108354f, 
    -0.25933021f, 0.13322811f, -0.04285459f, -0.18828282f, -0.01233631f, 0.13900767f, -0.14029275f, 0.01633912f, 
    -0.04346317f, 0.10719704f, 0.05200958f, 0.15478987f, 0.17680410f, 0.08292354f, -0.11166947f, -0.09279005f, 
    0.03197210f, -0.06897605f, 0.00386353f, -0.05498061f, 0.07340311f, 0.03750470f, 0.06455289f, 0.08877661f, 
    0.12937218f, 0.15898651f, 0.21382681f, 0.10991455f, -0.01849305f, 0.12931332f, 0.09559476f, 0.06207767f, 
    0.04095449f, 0.00472733f, 0.04305452f, -0.12450021f, -0.13027987f, 0.03619795f, -0.13299619f, 0.02385049f, 
    0.04339649f, -0.04097666f, -0.04723560f, 0.11218511f, 0.02662280f, -0.01842079f, 0.07607164f, 0.03384027f, 
    -0.10367948f, -0.08249567f, 0.17763513f, 0.14260584f, 0.06234357f, 0.07131187f, 0.10439329f, -0.02134291f, 
    0.01453886f, 0.03240971f, 0.05394268f, -0.02710985f, 0.13791533f, 0.38864085f, 0.06905404f, -0.02370083f, 
    0.06799900f, -0.04444500f, 0.02708977f, -0.03945775f, 0.04653964f, -0.03650108f, -0.04669883f, 0.02837091f, 
    -0.07803664f, -0.25862473f, -0.17184006f, 0.13316883f, -0.02131252f, -0.01448040f, -0.03478142f, 0.01146535f, 
    -0.07125696f, -0.03253688f, 0.02007456f, 0.15443490f, -0.20814884f, 0.20687504f, -0.15675393f, 0.10407644f, 
    0.08780231f, 0.21729109f, -0.18356478f, 0.16479447f, 0.06834473f, 0.04705964f, -0.09348220f, 0.14220908f, 
    0.20029409f, 0.13540365f, 0.29557908f, 0.12715480f, -0.01124256f, 0.04296733f, -0.13188265f, 0.01266691f, 
    -0.02883664f, -0.11251456f, 0.07171618f, 0.00428552f, -0.20016019f, -0.04554972f, 0.04891434f, -0.01414001f, 
    0.04332634f, 0.10995058f, 0.19508551f, 0.13645378f, 0.10182542f, 0.03919976f, 0.19785884f, 0.17672573f, 
    0.06036914f, 0.01350572f, -0.02410570f, 0.07583508f, 0.17709909f, 0.16768332f, 0.10354369f, 0.21388529f, 
    -0.11847060f, -0.03341068f, -0.28020629f, -0.09319219f, 0.17618279f, -0.08474904f, -0.03528684f, 0.04460310f, 
    0.05443422f, -0.07281318f, -0.15485169f, 0.02258407f, 0.05241456f, 0.00686944f, -0.22868277f, -0.05751720f, 
    0.03847567f, -0.01219241f, -0.01211182f, -0.02293463f, 0.00280550f, 0.21742897f, 0.03708052f, -0.04711764f, 
    0.02866134f, -0.00111612f, -0.05050944f, 0.00682519f, -0.25266507f, -0.08394387f, -0.05632515f, 0.23281729f, 
    -0.19927000f, -0.00035856f, 0.11404666f, -0.13188402f, 0.11880663f, -0.04356006f, -0.04107516f, -0.01388458f, 
    -0.01946045f, -0.24101883f, 0.09175473f, -0.02988608f, 0.13995492f, -0.03709139f, -0.07905015f, 0.01158594f, 
    -0.06582267f, -0.06070857f, -0.15570885f, 0.09390033f, 0.09465633f, -0.01516104f, -0.11722932f, -0.04223757f, 
    0.02772200f, -0.10848684f, -0.02157044f, -0.05274135f, 0.10635772f, 0.03380804f, -0.08463593f, -0.01096458f, 
    -0.14666705f, 0.16054863f, -0.05421497f, 0.05336258f, 0.12134345f, -0.08290529f, -0.07009563f, -0.03943824f, 
    -0.09042201f, -0.00084504f, -0.00346656f, 0.08259925f, -0.30355853f, 0.27206153f, -0.11095460f, -0.01023919f, 
    0.02083574f, -0.01202401f, -0.00260078f, 0.05558368f, -0.08587436f, 0.00212365f, 0.01956780f, -0.00630047f, 
    -0.08780047f, 0.02763809f, 0.20403720f, 0.12672059f, -0.05714306f, 0.13938160f, -0.09020483f, -0.03233027f, 
    0.02911127f, 0.03100472f, 0.01553003f, -0.05104706f, 0.06547259f, -0.05527222f, -0.01851311f, 0.10550322f, 
    -0.07342801f, 0.04437399f, 0.05992136f, -0.07298227f, 0.07551730f, 0.02841491f, -0.02690938f, -0.05977933f, 
    0.53026956f, -0.34600991f, -0.06518207f, 0.24288180f, -0.06620052f, -0.11680572f, -0.02087818f, -0.03465097f, 
    -0.08502202f, 0.02835967f, -0.01521565f, -0.03378616f, -0.54843390f, 0.01891925f, 0.06367006f, 0.11835414f, 
    0.06347772f, -0.04041891f, -0.11457052f, 0.07193464f, -0.09757242f, 0.03568309f, 0.14726444f, 0.05488935f, 
    -0.06691741f, -0.06958358f, 0.06509916f, 0.12270837f, 0.11989369f, -0.06274520f, -0.00054924f, -0.10415388f, 
    0.05251515f, -0.01892226f, -0.00928057f, 0.07212324f, -0.06251324f, 0.06636551f, 0.00994558f, -0.02801262f, 
    -0.00848964f, 0.12581033f, -0.20544051f, 0.05966742f, 0.01462309f, -0.13622659f, 0.04130735f, -0.04360578f, 
    0.03179818f, 0.00639862f, 0.04049614f, -0.03124657f, -0.07373480f, 0.02201088f, -0.21652219f, 0.04669133f, 
    0.02405772f, 0.05572534f, 0.08599649f, 0.12028827f, -0.06771451f, -0.04490241f, 0.06543995f, -0.00462837f, 
    0.09511144f, -0.01511730f, 0.04815429f, -0.06569219f, 0.03112037f, 0.09651937f, 0.05917127f, 0.10521570f, 
    -0.12407376f, -0.01569270f, 0.01699303f, -0.01340141f, -0.01222447f, 0.11956534f, -0.12546308f, 0.03356863f, 
    0.06128262f, 0.06751484f, -0.07982853f, -0.08963669f, 0.05145216f, 0.14742722f, 0.18442881f, 0.13309881f, 
    0.05443563f, 0.02452259f, 0.09288837f, -0.07098477f, 0.00089787f, 0.03838492f, 0.11176977f, 0.02972456f, 
    -0.10008362f, -0.12864527f, 0.06684511f, 0.05659261f, 0.03417967f, -0.03641164f, -0.03975441f, 0.00828891f, 
    0.07194819f, 0.01433457f, 0.08337242f, -0.04185947f, -0.21431227f, 0.47514531f, -0.15174848f, 0.00097313f, 
    0.14039454f, -0.07474310f, -0.04865997f, 0.05898416f, -0.14088184f, 0.01929388f, 0.00660213f, 0.11184984f, 
    0.01942030f, -0.04434877f, 0.12542860f, 0.01281027f, -0.08835512f, -0.13272718f, -0.04896442f, 0.02220672f, 
    -0.03347468f, 0.06549529f, -0.09842117f, 0.00713571f, 0.12629311f, -0.06202995f, 0.24458610f, 0.38283622f, 
    0.09027047f, 0.02792780f, 0.02421407f, 0.09465912f, 0.09528952f, -0.00269023f, -0.01652019f, -0.03935944f, 
    -0.02967405f, 0.23883189f, -0.25995684f, 0.08005223f, 0.02804475f, 0.14126448f, 0.00795092f, 0.20673577f, 
    -0.15406069f, 0.07491300f, 0.03785425f, 0.15920602f, 0.07154242f, 0.10742569f, 0.06048181f, 0.16874079f, 
    -0.12047889f, 0.10422155f, 0.10433353f, 0.06494743f, 0.04936385f, 0.01108908f, -0.01226212f, 0.04882610f, 
    0.02596293f, 0.05685043f, 0.16145580f, 0.22193141f, -0.03665973f, -0.01875276f, -0.02776644f, 0.03743305f, 
    0.05017507f, 0.07418302f, 0.03915621f, 0.08717118f, -0.19425544f, 0.02359035f, -0.15139860f, -0.14342645f, 
    0.04802420f, 0.03341776f, -0.02201870f, 0.06950568f, -0.07476356f, -0.06461296f, 0.05917366f, -0.01229182f, 
    -0.23219499f, -0.00920572f, 0.01734618f, 0.02990438f, 0.11467060f, 0.13452466f, 0.06666782f, 0.00107358f, 
    0.10867078f, 0.16857593f, 0.04974064f, -0.00071580f, -0.02290071f, 0.08058194f, -0.09502393f, -0.07142805f, 
    0.08179069f, 0.09218926f, 0.06502896f, 0.00060611f, 0.02433251f, 0.03580460f, 0.00453139f, 0.04974487f, 
    -0.08810303f, -0.19208634f, -0.10191582f, -0.03597542f, -0.00342750f, 0.09305085f, -0.05667559f, -0.07345563f, 
    -0.08346966f, -0.15873022f, 0.15930468f, -0.03904516f, -0.15492150f, 0.30992121f, -0.19932730f, 0.29694605f, 
    0.04142644f, 0.03546238f, -0.05487584f, 0.00043464f, 0.01128041f, -0.02710457f, 0.10075291f, 0.00156538f, 
    -0.01831368f, 0.04899588f, 0.23220529f, 0.23263031f, 0.09252135f, 0.06887276f, -0.12072759f, 0.08682960f, 
    -0.00098799f, 0.13510989f, 0.02508386f, -0.06542538f, 0.12307621f, -0.00347883f, -0.02305189f, -0.03818889f, 
    0.02647354f, -0.00839835f, 0.02060513f, 0.05141178f, -0.02280101f, -0.04585842f, 0.20590922f, 0.09977343f, 
    0.01129476f, -0.05930514f, 0.01373045f, 0.01801594f, -0.02446003f, 0.15490511f, -0.05645900f, -0.01019211f, 
    -0.04733173f, -0.11487597f, -0.07755676f, -0.05761985f, -0.08126537f, -0.00480791f, 0.04605846f, 0.03669540f, 
    0.05039427f, 0.00552462f, -0.08731995f, -0.01040945f, 0.02449414f, 0.11477285f, -0.00015818f, 0.08182418f, 
    0.04014983f, 0.10395546f, 0.01018040f, -0.17091791f, 0.03689213f, 0.03154729f, 0.05610720f, 0.11885516f, 
    0.02373441f, 0.10780615f, -0.02551527f, 0.00357184f, -0.02448317f, 0.16995727f, 0.20340058f, -0.00112423f, 
    0.12010069f, 0.06275574f, -0.17522930f, 0.09160121f, 0.19215260f, -0.03558858f, -0.01765465f, 0.03790399f, 
    0.06449263f, -0.03537996f, -0.19667417f, 0.14272758f, 0.07413170f, 0.04894435f, 0.02147013f, 0.04697732f, 
    -0.01552635f, -0.03508674f, 0.05147083f, -0.03958704f, 0.06986269f, -0.08324893f, 0.03546517f, 0.05127789f, 
    0.04754467f, 0.06237055f, -0.03618557f, 0.14475757f, -0.03301393f, 0.00570236f, -0.10707904f, 0.00659524f, 
    0.11763246f, -0.04275772f, 0.03289439f, 0.20817035f, -0.08464415f, -0.09030095f, -0.04548107f, -0.04296058f, 
    0.12541559f, 0.07016286f, -0.01749335f, 0.12400156f, -0.04281132f, -0.30714437f, 0.19807969f, -0.10298070f, 
    -0.19379754f, 0.00494625f, -0.07850073f, 0.21647288f, 0.01931592f, 0.06930387f, -0.06406450f, 0.18226624f, 
    -0.03796436f, 0.19892912f, -0.03272026f, -0.05593197f, 0.03422644f, 0.03789590f, 0.11438196f, 0.00011157f, 
    0.08362911f, -0.02905541f, -0.02553312f, -0.07343734f, -0.08026875f, 0.14493027f, -0.12895903f, -0.02093035f, 
    0.07011116f, -0.01161540f, 0.10448208f, -0.02396264f, 0.02068767f, -0.05045632f, 0.03281951f, -0.00180320f, 
    0.66160971f, -0.02176916f, -0.19520923f, 0.11917553f, -0.03821434f, -0.11212237f, 0.00360498f, -0.02280984f, 
    -0.00374170f, 0.10148112f, 0.12443749f, 0.19943227f, -0.24244799f, -0.33828127f, 0.26793051f, -0.32788879f, 
    -0.04712696f, 0.11984986f, -0.07156255f, 0.13161361f, -0.08236919f, -0.02177390f, -0.02058962f, -0.02039654f, 
    0.13354775f, -0.07659404f, 0.16286871f, 0.28084463f, 0.12188893f, -0.01514214f, 0.01761768f, -0.19603807f, 
    0.12852983f, 0.03441720f, 0.05143595f, 0.14097573f, 0.18513647f, -0.12571970f, 0.07199173f, 0.09472144f, 
    -0.11839496f, 0.03268565f, 0.01385571f, -0.01348563f, 0.12120280f, -0.00806232f, -0.09052251f, 0.04113499f, 
    -0.35460627f, 0.19363625f, -0.15070257f, -0.18585561f, 0.04195263f, 0.17705101f, -0.02726656f, 0.04520931f, 
    0.12307419f, 0.10226388f, -0.00328961f, 0.14784658f, -0.15040438f, 0.08254081f, 0.00631023f, 0.04096437f, 
    -0.08083852f, -0.11150029f, 0.04966205f, 0.23508716f, 0.11625537f, -0.06884183f, 0.02199133f, -0.02026971f, 
    0.15827700f, 0.00612880f, -0.09672655f, -0.25638810f, 0.02970195f, -0.06187588f, -0.00615016f, 0.09233239f, 
    -0.07509910f, -0.05275778f, -0.03006005f, 0.00422864f, 0.01800973f, 0.15010493f, -0.24506348f, -0.07337229f, 
    0.01509585f, -0.01063132f, -0.03373845f, -0.03457896f, -0.02390018f, -0.08791576f, -0.07866368f, -0.10295809f, 
    -0.17978789f, -0.06238796f, 0.23694183f, 0.06040961f, -0.09699489f, 0.03662039f, 0.13398218f, 0.10856330f, 
    0.02779267f, -0.04521488f, 0.04155767f, 0.00831749f, -0.24189217f, -0.36073023f, 0.30871156f, -0.05668284f, 
    -0.06109754f, -0.02699195f, -0.07492732f, 0.05633642f, 0.05422409f, 0.02623781f, -0.04015484f, 0.10335707f, 
    0.05856176f, -0.01425357f, 0.07110057f, 0.21259215f, 0.06589920f, 0.04435106f, -0.04025445f, 0.18174376f, 
    0.01890229f, 0.03035185f, 0.00290392f, -0.03327179f, 0.08898024f, -0.02533394f, 0.19319451f, 0.20980789f, 
    0.07144110f, -0.03459106f, 0.03553649f, 0.07239887f, -0.00381854f, -0.10188145f, -0.02055691f, -0.06937202f, 
    -0.35972318f, 0.03262700f, 0.01371401f, -0.17235959f, 0.00506907f, -0.07973759f, 0.04201737f, 0.13007066f, 
    -0.04845089f, -0.06823095f, 0.06744786f, -0.03282192f, -0.04630957f, 0.26936457f, -0.04140704f, -0.02510609f, 
    0.12824428f, -0.02430330f, -0.05030539f, -0.01191864f, 0.01091126f, -0.05116338f, 0.07275606f, -0.07024940f, 
    0.19641641f, 0.10318044f, -0.05407237f, 0.04767329f, 0.03015863f, 0.02563850f, 0.02433993f, 0.05848273f, 
    0.11793952f, -0.15880173f, 0.12444850f, -0.16773613f, -0.09701808f, -0.08813610f, 0.09253696f, -0.03900907f, 
    -0.08150782f, -0.05786152f, -0.07061461f, -0.05133078f, 0.14124423f, -0.07460436f, 0.00223449f, 0.00647758f, 
    -0.11951117f, -0.06795036f, 0.09635644f, 0.00913719f, 0.23574892f, -0.03796233f, 0.08732689f, -0.07032852f, 
    0.15995727f, 0.09576333f, 0.08606930f, -0.01524937f, 0.06973024f, 0.02406579f, 0.09314059f, -0.00157239f, 
    -0.02151670f, -0.03805485f, 0.14453927f, 0.01287970f, 0.12226301f, -0.12746696f, -0.09875478f, -0.02937065f, 
    -0.06967826f, -0.01904853f, -0.14090270f, -0.11847027f, -0.02481673f, -0.01086616f, -0.05868230f, -0.14415930f, 
    0.01575526f, -0.04577546f, -0.03947334f, 0.10530896f, -0.16334531f, 0.00090235f, 0.30726603f, -0.32408395f, 
    0.02427658f, 0.10806473f, 0.06335036f, 0.19464260f, 0.01864373f, 0.12054882f, -0.03177767f, -0.02249450f, 
    -0.00091684f, -0.03985937f, 0.22255825f, -0.03316905f, 0.00349255f, 0.03861119f, -0.08205016f, 0.03196754f, 
    -0.10391475f, 0.00896814f, 0.02986910f, -0.11654174f, -0.17159630f, -0.01193900f, -0.07600310f, 0.16319212f, 
    0.01729853f, 0.00970466f, 0.05688663f, -0.04463939f, 0.13631600f, -0.09398916f, -0.06330185f, 0.06006387f, 
    -0.02658582f, 0.14157341f, 0.04452433f, 0.06452660f, 0.13047162f, 0.05703006f, 0.08555854f, 0.21276444f, 
    0.03552929f, -0.06633662f, -0.00015499f, 0.06380109f, -0.13225645f, 0.09551461f, 0.01228368f, -0.10546274f, 
    -0.10884044f, 0.07635910f, -0.14267099f, -0.03573396f, -0.03006434f, 0.00933994f, -0.04583700f, 0.00699952f, 
    -0.11486908f, 0.07657669f, 0.04040851f, -0.06600827f, -0.20056777f, -0.13671789f, -0.06904852f, 0.03637534f, 
    -0.00081501f, 0.07552446f, 0.05587300f, -0.04914941f, -0.27034739f, -0.06178427f, -0.01428956f, 0.08028557f, 
    0.06921820f, 0.02653974f, -0.24154298f, 0.00491174f, 0.08232310f, -0.10029680f, 0.08076511f, 0.13860640f, 
    -0.01780233f, 0.01801248f, -0.18078624f, -0.04817019f, -0.10648551f, -0.05628877f, 0.01173938f, 0.00146953f, 
    0.06759004f, -0.04518749f, 0.10868300f, -0.10001749f, 0.11849813f, -0.00917000f, 0.06413339f, -0.05580452f, 
    0.07671930f, -0.03850094f, -0.10944646f, 0.00513300f, 0.00737044f, -0.02080207f, 0.00166808f, 0.02368653f, 
    -0.04045048f, -0.26515949f, 0.09295643f, 0.04494809f, 0.03195787f, 0.04540385f, 0.06627047f, -0.06166109f, 
    0.17897704f, 0.00121573f, 0.02570974f, 0.06290506f, 0.40397438f, -0.25579578f, -0.02431625f, 0.11508211f, 
    0.08748876f, 0.16558291f, -0.01194022f, 0.05835961f, -0.03986483f, 0.04324161f, 0.02229766f, -0.04068558f, 
    -0.11376043f, -0.08349042f, -0.33452621f, 0.15245540f, 0.02278073f, 0.15372352f, 0.03289187f, 0.02236426f, 
    0.04040433f, 0.11867596f, -0.08848530f, -0.01697415f, -0.35807908f, 0.07480543f, 0.03889038f, -0.07638216f, 
    0.08295522f, -0.03586075f, -0.05177338f, 0.00796623f, -0.07585750f, 0.05702428f, 0.00646688f, 0.01728064f, 
    0.21686915f, -0.07893566f, -0.01269891f, -0.03425645f, 0.16895820f, -0.08373417f, -0.04176950f, -0.09931388f, 
    -0.04987409f, -0.02162060f, 0.11774787f, 0.12932736f, -0.11192953f, -0.47902393f, -0.06206553f, 0.02921671f, 
    0.13205630f, 0.13576815f, -0.03990064f, -0.07266235f, 0.16659907f, -0.08214525f, -0.08816262f, 0.09903598f, 
    0.35295999f, 0.14213131f, 0.23758125f, -0.09030708f, 0.06354157f, -0.01995278f, -0.06208988f, -0.02593341f, 
    0.09465771f, -0.00575659f, -0.08702026f, 0.04817187f, 0.25277257f, 0.10882047f, -0.14516482f, -0.13041542f, 
    0.03486050f, -0.00865797f, 0.22011180f, -0.13314994f, 0.13034497f, 0.01748863f, -0.00689636f, 0.10640956f, 
    -0.34060505f, -0.00921471f, -0.06507273f, 0.05451328f, 0.07943963f, -0.01418707f, -0.16429073f, 0.02916067f, 
    -0.08899286f, 0.04780567f, 0.04135283f, 0.04612125f, 0.17167126f, -0.03861545f, -0.19684820f, 0.20458411f, 
    0.11358266f, 0.23557217f, 0.16101904f, 0.16717009f, -0.01429712f, -0.04335247f, 0.05086852f, -0.00840397f, 
    -0.08820112f, -0.03530557f, 0.09067453f, -0.15457347f, -0.09426480f, -0.02951559f, 0.01154346f, 0.00367773f, 
    -0.07710966f, 0.00230173f, 0.06130841f, -0.01316449f, -0.50850886f, -0.05952430f, 0.02757601f, 0.05568189f, 
    -0.02167854f, 0.02353461f, -0.15328926f, -0.03941701f, -0.09016140f, -0.10725777f, 0.05536402f, -0.07825404f, 
    0.19140585f, 0.15523972f, -0.16861524f, -0.15782408f, 0.17051663f, 0.16367750f, 0.08611910f, 0.11188448f, 
    0.01658600f, -0.02556497f, -0.02716693f, 0.06091553f, 0.23481490f, -0.21618506f, -0.06588382f, -0.02193379f, 
    -0.00134054f, 0.00127806f, 0.10045175f, -0.03650799f, 0.06607106f, 0.01559746f, 0.03597943f, 0.04494433f, 
    0.24003725f, 0.13489898f, 0.13873769f, 0.23201197f, 0.19558939f, 0.06873392f, -0.08004283f, 0.01591756f, 
    0.03809108f, -0.01559659f, 0.11829411f, 0.12059867f, 0.13641348f, 0.12685604f, 0.10368156f, -0.11271828f, 
    0.03099935f, -0.13310497f, 0.17588438f, -0.05211153f, 0.05141477f, -0.01569840f, -0.04483894f, -0.05080483f, 
    0.39691913f, 0.01522581f, 0.06594278f, 0.05137695f, -0.02865273f, 0.02018353f, 0.07306674f, 0.13389018f, 
    0.10324987f, -0.04582302f, 0.13488476f, -0.06199710f, -0.31008092f, -0.09985323f, 0.06192147f, 0.06319709f, 
    0.01107351f, 0.10813374f, -0.07321826f, 0.01262211f, -0.07129695f, 0.12476580f, 0.09944636f, -0.05033701f, 
    0.14576361f, -0.04262075f, -0.24196598f, -0.11547886f, 0.07826392f, 0.00200800f, 0.12038200f, 0.13039744f, 
    0.15987159f, -0.12618876f, 0.11730188f, 0.05356894f, -0.02857427f, -0.14315587f, -0.07092733f, -0.01176222f, 
    0.01749346f, -0.02609590f, 0.02538250f, -0.16266535f, -0.00778104f, 0.02455059f, -0.01834430f, 0.08548144f, 
    -0.01231072f, -0.13469644f, -0.16108754f, -0.07266096f, 0.11432342f, 0.07197808f, 0.09639092f, 0.15360677f, 
    -0.04381841f, 0.04300404f, 0.03891902f, -0.02506176f, 0.27199724f, -0.07453146f, 0.02399680f, -0.02222252f, 
    0.00203889f, 0.06967582f, 0.05965911f, 0.00793137f, 0.05733151f, 0.02604004f, -0.06702608f, -0.06391217f, 
    -0.06629422f, 0.02040277f, -0.03387021f, -0.05240734f, -0.07305719f, -0.03714134f, -0.00466802f, 0.03154014f, 
    0.10875403f, 0.09369944f, 0.08475544f, 0.18376327f, 0.30761909f, 0.11159791f, -0.25983372f, -0.17936639f, 
    0.01437158f, 0.01082687f, 0.26197696f, 0.01956026f, -0.04837216f, -0.01326399f, -0.03741964f, 0.03151440f, 
    0.19756128f, 0.10878032f, -0.28411016f, -0.25458580f, 0.08012564f, 0.04383834f, 0.15981054f, -0.06523206f, 
    -0.06209565f, 0.06654903f, -0.03269349f, -0.00276716f, 0.04756076f, 0.22635151f, 0.13366935f, -0.09298418f, 
    0.06341049f, -0.02317349f, -0.00438769f, 0.14637525f, 0.01188644f, 0.01623712f, -0.08638103f, -0.09509516f, 
    -0.04179757f, 0.01111566f, -0.09170781f, -0.08110939f, 0.10521058f, 0.08849350f, -0.07334013f, -0.10579851f, 
    0.11950368f, 0.09093124f, 0.05407309f, 0.06416029f, -0.25535896f, -0.11079685f, -0.13529423f, 0.09274330f, 
    0.00740283f, 0.08169225f, -0.16146390f, -0.12044320f, 0.01442728f, 0.01598763f, 0.09135878f, -0.02101938f, 
    -0.03399866f, -0.11716893f, 0.03986760f, -0.09699601f, 0.17533815f, 0.25312841f, 0.04166102f, -0.01055379f, 
    0.01615879f, -0.11602871f, -0.00378139f, -0.04668434f, -0.01388118f, 0.05049246f, 0.21981229f, 0.01491297f, 
    -0.06956245f, 0.02465713f, 0.12006531f, -0.02285177f, 0.12570135f, 0.05251736f, -0.05072459f, 0.02304344f, 
    -0.06932055f, -0.03415948f, 0.03108874f, 0.12008556f, 0.07095749f, 0.11227114f, -0.02821002f, 0.05689571f, 
    -0.00100868f, 0.00651862f, -0.06457447f, 0.12982093f, 0.04285846f, -0.09529530f, -0.05187611f, -0.08010718f, 
    -0.03981998f, 0.05306828f, 0.09187721f, 0.04754309f, 0.00885593f, 0.02889304f, 0.05721790f, 0.01382787f, 
    -0.03088147f, 0.09111707f, 0.11144220f, 0.07403018f, -0.02914984f, -0.09850162f, -0.09535465f, -0.09114885f, 
    0.01342723f, 0.11171576f, 0.12409383f, 0.05938046f, -0.22198819f, 0.11008193f, 0.01176895f, -0.10223079f, 
    -0.10085682f, -0.16422679f, 0.09040246f, 0.26253584f, 0.07525545f, 0.14276068f, -0.03422090f, 0.13560724f, 
    -0.22172232f, 0.29131004f, 0.19802901f, 0.08238650f, -0.02173904f, -0.03006343f, 0.15029350f, 0.02164198f, 
    0.11204686f, -0.02756802f, 0.09066629f, -0.02345323f, 0.13169686f, -0.00081582f, -0.07197785f, 0.02395081f, 
    -0.01251065f, 0.08488503f, 0.06413680f, -0.02055229f, 0.00840536f, -0.06086499f, -0.03729734f, 0.01850221f, 
    0.64182699f, -0.08533914f, -0.12490518f, 0.07271809f, -0.05402330f, -0.02681177f, -0.19231568f, -0.12898839f, 
    -0.05558004f, 0.14984287f, 0.08064666f, 0.01732722f, -0.31853449f, 0.08395207f, 0.32259852f, -0.09900661f, 
    -0.02811293f, 0.00993960f, 0.06946354f, 0.13331604f, 0.02210587f, 0.07921647f, 0.12053192f, 0.06989605f, 
    -0.08717678f, -0.20153423f, 0.05325375f, 0.26395202f, 0.04760686f, -0.10996418f, 0.00246382f, -0.01873801f, 
    0.10204384f, 0.14396130f, 0.03021298f, 0.07756400f, -0.11085308f, -0.03267941f, -0.04956634f, 0.09643581f, 
    -0.00473150f, 0.04946916f, 0.01051417f, 0.11583741f, -0.00564479f, 0.07979301f, 0.04909116f, 0.01945713f, 
    0.06405500f, 0.12314570f, -0.00066738f, -0.02551771f, 0.05479952f, 0.00345294f, 0.15631460f, 0.02519714f, 
    0.08378615f, 0.02772473f, 0.03797306f, 0.15713269f, -0.31420541f, -0.06776082f, 0.00894745f, -0.15305860f, 
    -0.08467540f, -0.17486167f, -0.05845378f, 0.02866135f, 0.13667539f, 0.07605630f, 0.04701208f, 0.05351063f, 
    0.03513226f, 0.00503754f, 0.00600445f, -0.16969179f, -0.08002555f, 0.10351109f, -0.00197655f, -0.02117418f, 
    0.05144861f, -0.02644277f, -0.10052692f, -0.12003043f, 0.29831314f, 0.19851923f, 0.19210373f, 0.03682735f, 
    0.03583671f, -0.03885622f, 0.02155768f, -0.01938655f, 0.08477946f, -0.04864769f, -0.01836093f, 0.02393701f, 
    -0.34137690f, -0.24637395f, 0.06785403f, 0.02530312f, -0.03796302f, -0.11537393f, -0.01110992f, 0.05159398f, 
    -0.01006321f, -0.03774377f, 0.01155953f, -0.06023748f, 0.00512678f, 0.32467413f, 0.25360265f, 0.04635086f, 
    0.02345636f, -0.11663239f, -0.02006071f, 0.04666592f, -0.00892805f, 0.16169998f, 0.07115797f, 0.11896279f, 
    -0.12109444f, -0.08959340f, -0.01527591f, 0.05402344f, 0.06953502f, 0.02837449f, 0.11097706f, 0.03857710f, 
    0.08484542f, 0.12885480f, 0.03298563f, 0.06133923f, -0.17414442f, -0.10341251f, -0.08979882f, 0.34714648f, 
    0.08859090f, 0.12803656f, 0.00457448f, -0.00081241f, -0.00711064f, 0.01774886f, 0.02516012f, -0.00635891f, 
    -0.08255229f, 0.16209622f, -0.20364583f, -0.02413913f, -0.06031875f, 0.01453773f, 0.01936734f, 0.21824552f, 
    -0.10413052f, 0.00045350f, 0.07201214f, 0.04494069f, 0.11830357f, 0.07960118f, 0.01851497f, -0.11940029f, 
    -0.07488184f, 0.08623300f, 0.22775976f, 0.06914455f, 0.05337422f, 0.00673491f, -0.00166362f, 0.11328702f, 
    0.04160842f, 0.03868726f, 0.19051583f, 0.29041165f, -0.04585700f, -0.17580783f, -0.08556081f, 0.09829718f, 
    0.08697566f, 0.06479084f, 0.16084044f, 0.17656492f, 0.00709906f, 0.15460643f, 0.13993339f, -0.12139374f, 
    0.05343435f, -0.06571066f, -0.06530773f, -0.05628880f, -0.03931874f, -0.00305163f, 0.12242513f, 0.01083250f, 
    -0.08956237f, 0.09398883f, -0.04175168f, -0.06561658f, 0.17341377f, 0.04878038f, -0.02598642f, 0.11650946f, 
    0.10786452f, 0.02437879f, 0.01499935f, 0.00207313f, -0.25672477f, -0.11694441f, -0.04119885f, -0.11087795f, 
    0.03182083f, -0.01104447f, 0.04884060f, 0.07673033f, 0.04759657f, 0.00271538f, -0.01405074f, -0.03873101f, 
    0.10693703f, 0.09793579f, 0.14405544f, 0.02439715f, -0.02930276f, -0.00481771f, -0.05035101f, -0.12323935f, 
    0.09596550f, 0.04703081f, 0.09353662f, -0.05806049f, -0.23410451f, 0.10557438f, 0.30980539f, -0.09482975f, 
    0.08806815f, 0.24248853f, 0.03963214f, 0.17888401f, 0.13799307f, 0.07299963f, 0.08144281f, -0.05116438f, 
    -0.30202115f, -0.12213145f, 0.16491799f, 0.05388721f, -0.00321407f, -0.07776663f, -0.05183178f, 0.02180710f, 
    0.01330233f, -0.00174289f, -0.06064250f, -0.03445185f, -0.12850434f, 0.01722104f, 0.09173567f, 0.10943706f, 
    0.07453349f, 0.06226207f, 0.07821502f, 0.03263051f, 0.18056713f, -0.02209568f, 0.18733796f, 0.05263354f, 
    -0.00549690f, -0.02392638f, -0.00383621f, -0.11851802f, 0.01653226f, 0.12575302f, 0.00550122f, 0.09454850f, 
    0.03480494f, -0.10126282f, -0.00328033f, -0.00306584f, -0.05689195f, 0.08568556f, -0.00043932f, -0.07708829f, 
    -0.12595981f, -0.03490128f, -0.00924893f, 0.01571081f, 0.02248026f, 0.07161376f, 0.00780734f, 0.05470406f, 
    -0.08458885f, -0.13739327f, -0.06923506f, -0.12596165f, -0.00568281f, -0.04581973f, -0.02626136f, 0.13856634f, 
    -0.09994499f, 0.06526027f, 0.02198134f, -0.06176100f, 0.17502154f, 0.12148837f, 0.05430353f, -0.38142371f, 
    -0.10125746f, 0.01214103f, -0.17431650f, 0.00436467f, 0.12250908f, 0.04483179f, 0.18608060f, 0.01003789f, 
    -0.13295683f, -0.14974988f, -0.04731466f, 0.12601765f, 0.04325176f, -0.02656500f, 0.03512862f, 0.16051054f, 
    0.01705359f, -0.03629365f, 0.03706340f, 0.02870016f, -0.19074211f, 0.03644385f, 0.24873357f, -0.03903668f, 
    0.10584717f, 0.14986390f, 0.03407538f, 0.10562817f, -0.04768069f, -0.02470458f, -0.03450325f, -0.00284556f, 
    0.18662852f, 0.05763965f, 0.16521400f, 0.18040633f, -0.16418886f, -0.08370271f, -0.06688484f, -0.02612770f, 
    0.05316458f, 0.01811797f, 0.00103925f, 0.00059553f, 0.39991704f, -0.12371485f, 0.21167302f, -0.07069731f, 
    0.02149644f, -0.04359733f, -0.17614891f, 0.01479758f, 0.02949349f, -0.00476045f, 0.09833305f, -0.00440600f, 
    0.06104780f, 0.12807229f, -0.24786638f, -0.15821114f, -0.00854584f, 0.01245709f, 0.19810782f, 0.07203589f, 
    0.06662783f, -0.03170005f, -0.07473405f, 0.03811686f, -0.23869209f, -0.04000527f, -0.23342746f, -0.01382174f, 
    0.03477892f, 0.02318168f, -0.05405374f, 0.00828962f, -0.02427128f, -0.05268588f, 0.05985531f, 0.09038040f, 
    -0.22452173f, 0.18735805f, 0.00586278f, -0.10371988f, -0.11610906f, -0.01383191f, -0.08203171f, 0.01187747f, 
    0.10402047f, -0.00365075f, 0.14651114f, 0.11375918f, 0.55050462f, -0.29247090f, -0.02570413f, -0.27152079f, 
    -0.00631351f, 0.04522089f, -0.04180014f, 0.00648627f, -0.01831929f, -0.09843410f, -0.09276115f, 0.03002621f, 
    0.05060755f, 0.14256541f, 0.28524521f, 0.21518449f, 0.05793471f, 0.03200341f, -0.02284473f, 0.02034363f, 
    0.01803346f, -0.05402449f, -0.07460430f, 0.06174057f, 0.05547719f, 0.02430544f, 0.20697132f, 0.04057455f, 
    0.23773597f, -0.04042887f, 0.27068126f, 0.03133796f, 0.13458128f, -0.15719149f, -0.11987238f, -0.05647995f, 
    -0.16318640f, -0.04536290f, -0.18776795f, -0.24422330f, 0.01749907f, 0.03546940f, 0.21552287f, -0.04733108f, 
    0.01142291f, 0.03721348f, -0.00458462f, 0.14492503f, 0.01037551f, 0.17048374f, 0.02371852f, -0.19296335f, 
    -0.04409909f, -0.05775228f, -0.07483709f, 0.03341726f, 0.11466660f, -0.00288793f, 0.10667982f, 0.06926980f, 
    -0.19438937f, -0.13093843f, -0.10532659f, 0.10338822f, 0.00711249f, -0.10052807f, 0.13040814f, -0.06007780f, 
    -0.02406495f, -0.08096559f, -0.03751740f, 0.08050520f, 0.03411953f, -0.13822450f, -0.33856735f, -0.12706228f, 
    -0.02175558f, -0.06520094f, -0.01117617f, 0.05223057f, 0.00761694f, 0.00015479f, -0.13542774f, 0.00096329f, 
    0.07448475f, 0.29063666f, 0.24825354f, 0.02561666f, 0.06244469f, 0.18262853f, 0.15284789f, 0.10684635f, 
    0.12597865f, 0.02672661f, 0.05695792f, 0.06515739f, 0.03736431f, -0.30084339f, 0.31758627f, 0.14562385f, 
    -0.04660904f, -0.05195282f, -0.03223534f, -0.00290495f, 0.05942555f, 0.05908506f, -0.14052048f, -0.03107678f, 
    -0.01819540f, 0.13542731f, 0.09484756f, 0.12846845f, 0.22325093f, 0.14887905f, -0.00997901f, -0.02205539f, 
    -0.01928506f, -0.03982890f, -0.09384173f, 0.00493114f, -0.09572881f, -0.25681734f, -0.09453854f, -0.23138922f, 
    -0.04043294f, -0.18342866f, 0.06735004f, 0.00221512f, -0.02625628f, -0.00834695f, 0.00334608f, -0.12060412f, 
    0.04129444f, -0.09657450f, 0.18401569f, -0.24420035f, 0.14407137f, -0.12274137f, -0.06661291f, 0.03348319f, 
    0.05552566f, -0.02903698f, -0.02533733f, 0.01108274f, -0.10240421f, 0.11844388f, -0.15909877f, -0.16509381f, 
    0.12332629f, -0.04732846f, 0.03046518f, -0.01804176f, 0.00662348f, 0.00904072f, 0.10250677f, -0.00337733f, 
    0.09180216f, 0.11964004f, -0.05138207f, -0.21370082f, 0.04199113f, 0.24146825f, -0.05728946f, 0.13210888f, 
    0.07686822f, -0.17733730f, 0.16528927f, -0.02140085f, 0.17768799f, -0.17488235f, 0.08806020f, 0.07696122f, 
    -0.14617707f, -0.24446081f, -0.14408568f, -0.16412295f, 0.04519714f, 0.06616979f, 0.06959378f, -0.00851968f, 
    0.14394374f, -0.13300535f, -0.04129956f, -0.17151693f, -0.01361255f, -0.03471059f, 0.04974227f, 0.08715558f, 
    0.09513528f, 0.11207847f, 0.09685089f, 0.02078485f, 0.18257977f, 0.17603110f, 0.04174039f, 0.00071542f, 
    -0.07061436f, 0.05667464f, 0.09684090f, 0.01921084f, 0.16784428f, -0.00207316f, 0.10840750f, 0.02739605f, 
    -0.07075165f, -0.07715285f, -0.16848570f, 0.08807264f, -0.07371426f, -0.08403196f, 0.05028303f, -0.07729107f, 
    0.14141637f, 0.01830776f, -0.15711755f, 0.09341658f, 0.27082229f, -0.04628726f, 0.19713932f, -0.42190063f, 
    0.00356804f, 0.00334760f, 0.02677114f, 0.16313006f, -0.03603001f, 0.03285063f, -0.11051575f, -0.03926487f, 
    0.28445929f, 0.27931803f, 0.06437313f, -0.16273913f, 0.05042105f, -0.04900739f, 0.10393628f, -0.02548350f, 
    -0.03785199f, -0.04738220f, 0.03804195f, 0.04662061f, -0.26901093f, 0.18872628f, 0.13262352f, 0.18226843f, 
    0.04562166f, 0.01835446f, -0.03662569f, 0.11074281f, 0.10606984f, -0.10899674f, -0.23512946f, -0.02988852f, 
    -0.04149041f, 0.03141961f, -0.07508367f, -0.03198490f, 0.15234715f, 0.01580496f, 0.18884945f, 0.10923368f, 
    0.01346936f, 0.04627332f, -0.08236499f, 0.15831824f, 0.11224856f, -0.09751376f, -0.16418214f, -0.06563739f, 
    -0.04238132f, 0.09099621f, 0.05468278f, 0.04285314f, 0.01405499f, -0.08500103f, -0.20226958f, -0.12947387f, 
    0.03282094f, 0.00063294f, -0.00219228f, 0.01837007f, 0.00089105f, 0.00700649f, -0.04679883f, 0.03386208f, 
    -0.03687760f, -0.02543428f, -0.05263278f, 0.03755858f, 0.00270055f, 0.03095814f, -0.04932170f, -0.00476874f, 
    -0.00869932f, -0.05528139f, 0.00718784f, -0.05580723f, -0.00858293f, -0.05111337f, -0.04049682f, -0.02823555f, 
    -0.00225922f, 0.00655008f, -0.01921414f, -0.01074265f, -0.04781406f, -0.00875592f, 0.01371713f, -0.03455250f, 
    -0.00795334f, -0.00985951f, 0.01195396f, 0.00027806f, -0.01736557f, 0.04396176f, -0.01709279f, -0.04606837f, 
    -0.04330529f, -0.02189468f, 0.01169120f, -0.00576033f, -0.04260009f, -0.04305549f, 0.03199502f, -0.05130297f, 
    -0.03271656f, -0.00750872f, -0.05342507f, -0.02533924f, 0.03361899f, 0.00250819f, -0.03289439f, -0.04105263f, 
    -0.04704482f, 0.03134822f, -0.03507656f, -0.00966437f, -0.02622360f, -0.04838663f, -0.02567588f, 0.03044472f, 
    0.01066156f, 0.01552687f, -0.05519900f, 0.01604189f, 0.04168051f, -0.01961065f, -0.03098813f, -0.01982971f, 
    -0.01673909f, -0.04672522f, 0.00990259f, 0.01034328f, -0.01051589f, -0.02280072f, -0.01078067f, -0.02726801f, 
    -0.03664495f, -0.05589995f, 0.01521557f, 0.02434316f, -0.00424413f, 0.00904164f, -0.02077824f, -0.02038739f, 
    -0.02805015f, 0.00601021f, -0.02153056f, -0.02112190f, -0.00174037f, 0.02531022f, -0.00231006f, -0.02202604f, 
    -0.03152277f, 0.02662890f, -0.04993780f, 0.00367746f, -0.04563665f, 0.04450199f, -0.01080548f, 0.00022855f, 
    -0.02134727f, 0.01996307f, -0.03162400f, -0.03401354f, -0.03648395f, 0.03579728f, -0.05093396f, 0.02971344f, 
    0.01497551f, 0.01302311f, -0.01429728f, 0.04002463f, -0.00262592f, 0.03071564f, 0.01335527f, 0.00014213f, 
    0.03872016f, 0.03583489f, 0.02078903f, 0.01063292f, -0.02268212f, 0.01609882f, -0.04677678f, 0.00085177f, 
    -0.01488737f, 0.02065764f, -0.03867620f, 0.03118458f, 0.00090941f, 0.02000283f, 0.00245493f, -0.02085896f, 
    0.01430040f, 0.02397279f, -0.04634655f, -0.04194598f, -0.04789134f, -0.02099795f, -0.03027563f, -0.02570884f, 
    0.03982926f, -0.01540793f, -0.00516552f, -0.02303857f, -0.04964386f, 0.02918775f, -0.03532338f, 0.03556466f, 
    -0.00452073f, -0.03126422f, 0.00192539f, -0.00564789f, 0.02620787f, 0.03175975f, -0.01718305f, 0.02059998f, 
    -0.02776336f, -0.03408085f, 0.01137492f, -0.03677013f, 0.04114203f, 0.04402066f, -0.02442175f, -0.00668720f, 
    -0.03754649f, 0.03795721f, -0.01163650f, -0.05247626f, 0.00924523f, -0.01286743f, 0.00318360f, -0.04246522f, 
    -0.04791305f, 0.03480984f, -0.00338794f, -0.01224512f, -0.05534928f, -0.03120490f, 0.01441803f, -0.01310769f, 
    -0.03141512f, 0.03994877f, 0.00071913f, -0.04056137f, -0.04448932f, -0.00645287f, -0.05609129f, 0.00749919f, 
    -0.01148355f, -0.05649601f, 0.03672501f, 0.01758792f, 0.03427985f, 0.03488239f, 0.03606452f, 0.03586488f, 
    -0.00184255f, -0.00084438f, -0.05046507f, 0.03666794f, 0.03874689f, -0.00935772f, 0.02744137f, -0.05595716f, 
    0.01063333f, -0.05517511f, 0.00103939f, -0.01691244f, -0.04511954f, 0.01087475f, -0.00826760f, -0.01325612f, 
    0.00895618f, -0.00752883f, -0.00451533f, -0.02861418f, 0.00456577f, 0.04350660f, 0.00550393f, -0.00212502f, 
    -0.03384025f, -0.05348419f, -0.02510615f, 0.00110825f, 0.03143239f, 0.02705873f, 0.02497216f, 0.04443659f, 
    0.02103290f, -0.03565127f, -0.01490482f, -0.03108110f, -0.04099108f, -0.02039435f, 0.04176721f, -0.00477432f, 
    -0.02472484f, 0.00638868f, -0.04519364f, 0.03106687f, -0.02523495f, -0.05523227f, -0.05399054f, -0.03137323f, 
    0.00680586f, -0.05302183f, -0.03111365f, 0.00631223f, -0.04306216f, 0.03423365f, -0.00477939f, -0.05663209f, 
    0.04271154f, -0.02453128f, 0.03535003f, -0.00757048f, -0.01325058f, -0.04380789f, -0.00607655f, -0.03287721f, 
    -0.05179295f, -0.05170733f, -0.00805091f, -0.01591130f, -0.02979963f, 0.04421789f, 0.03158158f, 0.04413790f, 
    0.02228630f, -0.03351807f, -0.03656091f, 0.01229137f, -0.00239911f, -0.01031313f, 0.04044136f, 0.00177662f, 
    -0.01146794f, 0.01401108f, 0.03392919f, -0.03364884f, -0.01567076f, -0.01484135f, 0.01011179f, 0.00982385f, 
    0.01594103f, -0.01294002f, 0.00978094f, -0.02536071f, -0.02312670f, 0.03296934f, -0.00728180f, 0.00593427f, 
    0.02338505f, 0.01134448f, -0.01758335f, 0.02868872f, 0.03290840f, -0.05460531f, -0.03769141f, -0.02094617f, 
    -0.04649294f, -0.00172830f, -0.02075643f, -0.05075028f, 0.00019139f, -0.00857270f, -0.01368372f, -0.02115517f, 
    -0.01309543f, -0.02601320f, -0.04580107f, 0.02613181f, 0.00335836f, 0.03060382f, -0.05383922f, 0.04348023f, 
    0.02984433f, 0.02750329f, -0.01590595f, 0.03276571f, -0.05008718f, 0.02441170f, 0.00719426f, -0.00681840f, 
    -0.04096366f, 0.01792272f, 0.00841080f, 0.00159028f, -0.05484942f, -0.00756862f, -0.04569677f, 0.02562329f, 
    0.03234247f, -0.00910466f, 0.02358964f, 0.01919253f, -0.04646787f, -0.04347814f, 0.00295608f, -0.01107940f, 
    -0.00683862f, -0.05017351f, 0.02335868f, -0.00619994f, -0.02285959f, -0.04742621f, -0.01849218f, -0.04846747f, 
    -0.04101698f, -0.01604350f, 0.04232034f, 0.01905417f, -0.01506034f, -0.01324900f, 0.02105453f, 0.00471963f, 
    -0.00075302f, 0.04493374f, -0.05677977f, -0.03821822f, 0.02654815f, -0.03016414f, 0.02215983f, 0.04358473f, 
    -0.04330019f, 0.02713631f, -0.01672760f, -0.00790055f, 0.02018584f, 0.03641870f, 0.04241785f, -0.01387914f, 
    0.03932124f, 0.03752441f, -0.02417709f, -0.04320793f, 0.04482744f, -0.04087492f, -0.05100875f, 0.00071283f, 
    -0.37845305f, -0.20900312f, 0.02453233f, 0.04401106f, -0.08195390f, -0.10275002f, -0.03381742f, -0.04177529f, 
    -0.19807196f, -0.25164649f, -0.20835106f, -0.16935065f, -0.12055025f, -0.00001469f, 0.17930761f, -0.17972317f, 
    0.08762347f, 0.17482454f, 0.06537349f, -0.08837605f, 0.02132883f, 0.01288758f, -0.12083315f, 0.07336392f, 
    0.18401684f, 0.26711941f, -0.03765824f, -0.33149087f, 0.11142042f, -0.05316737f, -0.02991324f, -0.06925118f, 
    -0.22836246f, -0.07314153f, -0.16329886f, -0.38535643f, 0.12257770f, -0.18412976f, -0.26458672f, -0.09128571f, 
    0.08845622f, -0.08457074f, -0.06225001f, -0.03569975f, -0.12619923f, -0.09133379f, -0.09853973f, -0.29182249f, 
    0.45967859f, 0.02266552f, 0.23934133f, 0.08327828f, -0.17734566f, -0.03353406f, 0.17165746f, 0.16665255f, 
    0.04566460f, -0.03146271f, 0.00925987f, 0.10471309f, -0.16133124f, 0.02070199f, 0.03348293f, 0.16997901f, 
    -0.00724032f, 0.13889642f, 0.28655371f, 0.03009925f, 0.08750561f, 0.08378535f, 0.10638545f, 0.16502894f, 
    -0.06348954f, 0.07660268f, -0.14832778f, 0.11904221f, 0.07563698f, -0.08150406f, -0.10065954f, 0.02846770f, 
    -0.04800838f, -0.24087556f, -0.10725934f, -0.04552950f, -0.14807056f, -0.05645137f, 0.22744492f, -0.16833502f, 
    -0.13494955f, -0.09670356f, -0.17740925f, 0.01100748f, 0.02312895f, -0.14010568f, -0.15380351f, 0.10563140f, 
    0.11701924f, 0.01298855f, 0.18830018f, -0.02409758f, -0.22744414f, 0.13118707f, -0.10629201f, -0.04844443f, 
    0.08863761f, -0.01372345f, 0.10915833f, 0.13265951f, -0.19740324f, 0.38667583f, 0.09857013f, 0.01260850f, 
    -0.11720695f, -0.07979607f, 0.23980795f, -0.12955397f, -0.00808312f, -0.08298607f, -0.09440028f, 0.00294662f, 
    0.13249925f, 0.12646765f, -0.07419379f, 0.08207143f, -0.07083625f, 0.04133466f, -0.01537575f, 0.00952028f, 
    -0.00003049f, 0.10500644f, 0.12433857f, 0.32102600f, 0.17990719f, -0.08905203f, -0.20416643f, -0.17435627f, 
    -0.00435877f, -0.13975558f, 0.00213861f, -0.00105851f, -0.25827396f, 0.06867394f, 0.02881768f, -0.28982913f, 
    -0.04468486f, 0.13138813f, -0.26786780f, 0.21140650f, 0.00183099f, 0.04193647f, 0.06748573f, -0.00155422f, 
    -0.07197402f, -0.06811928f, -0.19701442f, -0.12226117f, 0.33314523f, 0.00311539f, 0.16972883f, 0.29848483f, 
    -0.03663278f, -0.01968251f, -0.02990256f, 0.13228492f, 0.03652775f, -0.04234470f, -0.07442521f, 0.24167240f, 
    0.12739144f, -0.03813188f, 0.38905039f, -0.11627600f, 0.10854490f, -0.23885527f, 0.00204525f, 0.05343209f, 
    -0.12022259f, -0.18933924f, -0.02598370f, -0.18859693f, 0.02688489f, 0.11057604f, 0.17454301f, 0.11532113f, 
    0.06771781f, -0.23997514f, -0.16633397f, 0.07885854f, -0.12653695f, 0.07076497f, 0.08409020f, 0.12725498f, 
    -0.02040317f, -0.05503527f, -0.15479222f, -0.06841987f, -0.01857157f, -0.03019542f, -0.04489181f, 0.15046398f, 
    -0.05310096f, -0.05507675f, -0.00849822f, -0.05079699f, 0.24622086f, -0.02750636f, 0.03327422f, 0.00696264f, 
    -0.16688511f, -0.06889447f, 0.10650196f, 0.03406061f, 0.11098498f, 0.07059680f, 0.06691760f, -0.01645922f, 
    -0.11878670f, 0.10675327f, -0.11859921f, 0.00527370f, -0.08749387f, -0.00734655f, 0.07878872f, -0.07315605f, 
    -0.13510709f, 0.00107854f, -0.03201639f, -0.09804832f, -0.21294722f, 0.09633003f, 0.05232968f, 0.02886849f, 
    0.09037831f, 0.16000985f, 0.08627900f, 0.08984341f, -0.01596900f, -0.06547990f, -0.09119584f, 0.07567588f, 
    -0.10320024f, -0.01020279f, 0.03219831f, 0.16472256f, 0.01555421f, -0.04299857f, 0.16385520f, 0.05416214f, 
    0.14255926f, 0.14517605f, 0.18288016f, 0.12952060f, -0.08003961f, -0.08192425f, 0.02792970f, 0.20583449f, 
    0.23326114f, 0.02310020f, 0.07957753f, -0.05893437f, 0.30715862f, 0.17299493f, 0.22225325f, 0.33844694f, 
    0.07533881f, 0.11252641f, 0.15687227f, -0.02861715f, 0.04472697f, -0.19178815f, -0.02069340f, 0.06967298f, 
    -0.04705000f, 0.14280632f, -0.22851144f, -0.09336506f, 0.20821166f, 0.12876740f, 0.11728699f, -0.12659740f, 
    -0.24868435f, -0.11335216f, 0.07311852f, -0.05665873f, 0.13388255f, -0.01044001f, 0.04915705f, 0.07328859f, 
    -0.09641355f, 0.15068536f, -0.02396388f, -0.24823238f, 0.04393585f, -0.03417434f, 0.13326004f, -0.13158947f, 
    0.00203434f, -0.11618584f, -0.05409284f, -0.02817693f, 0.14835297f, -0.22544858f, -0.01427049f, 0.04518728f, 
    -0.01838763f, 0.07998859f, -0.01238113f, 0.09781830f, 0.13416561f, 0.10020537f, 0.04023871f, 0.12484451f, 
    0.09600423f, 0.03828225f, 0.23828226f, -0.14635952f, -0.12747660f, -0.03226724f, -0.01646430f, -0.07003618f, 
    0.09140351f, 0.14261302f, 0.13204083f, -0.06385062f, 0.04030994f, -0.11666692f, 0.18264152f, 0.13513289f, 
    0.09173544f, -0.06574126f, 0.20930041f, 0.05995765f, -0.03302936f, -0.02473849f, 0.07613718f, 0.00631022f, 
    -0.01906881f, 0.01285892f, -0.01972235f, -0.00829676f, 0.06796428f, 0.01910274f, 0.10916861f, 0.18499649f, 
    0.13340577f, 0.00484953f, 0.05016368f, -0.11069255f, 0.44025785f, -0.09538483f, -0.02830549f, 0.08647147f, 
    -0.05224341f, -0.03954777f, 0.05720024f, -0.01768700f, 0.06316930f, 0.09409048f, 0.15879086f, 0.22518942f, 
    -0.12147138f, -0.10703286f, -0.10142035f, 0.01601129f, -0.02642965f, -0.06932303f, -0.07955766f, -0.03898483f, 
    -0.33744052f, -0.22175063f, -0.24112390f, -0.36379296f, -0.19983652f, 0.12677063f, -0.04061614f, 0.03903564f, 
    0.08984048f, 0.04319285f, 0.04854662f, -0.05797353f, -0.27501851f, -0.20589449f, 0.07377034f, -0.24104965f, 
    0.11297261f, 0.04920116f, 0.03024534f, -0.03146619f, 0.08557957f, -0.11976520f, 0.06847689f, -0.02725106f, 
    0.02122706f, 0.06795832f, 0.00110209f, -0.00647555f, 0.17451450f, -0.21071060f, 0.18098366f, -0.17595246f, 
    -0.01748157f, 0.08518200f, 0.00681106f, 0.09919661f, -0.06111717f, 0.04842560f, 0.01994138f, 0.02974983f, 
    0.14116542f, 0.18764210f, -0.14163248f, 0.16046692f, -0.06973475f, 0.05515528f, 0.04241920f, -0.03389075f, 
    0.01989779f, 0.05491269f, 0.00820861f, -0.05288855f, 0.09332571f, 0.07555605f, 0.07371192f, 0.00166667f, 
    0.03674792f, 0.02217950f, 0.05335153f, 0.00032683f, -0.03390386f, -0.03127892f, 0.09270437f, 0.00311653f, 
    0.47255963f, -0.21242058f, -0.24112576f, -0.20453352f, -0.04962488f, 0.03462989f, -0.04527684f, -0.00815119f, 
    0.02952491f, -0.04963236f, 0.03850515f, -0.08862270f, 0.14098406f, -0.26427609f, -0.06108015f, 0.07519038f, 
    0.04606026f, -0.02422692f, -0.01279962f, -0.14005479f, 0.17285191f, -0.01126231f, -0.03163771f, -0.04041786f, 
    -0.00928512f, 0.03640307f, -0.16942698f, 0.22937857f, 0.15188290f, -0.03640894f, 0.31358680f, -0.08467007f, 
    -0.00997393f, 0.03941474f, 0.04440800f, 0.18772903f, 0.08581147f, 0.07475834f, 0.07685307f, 0.01159495f, 
    -0.01517419f, -0.02088680f, -0.10053495f, 0.00201027f, 0.07385030f, 0.03706567f, 0.06224246f, 0.00507486f, 
    -0.31838217f, -0.14082251f, 0.02811512f, -0.31996968f, 0.01714009f, 0.05518343f, -0.07938400f, 0.04371348f, 
    -0.06772865f, -0.03134419f, 0.02754856f, -0.03688275f, 0.57730943f, -0.10647574f, -0.29859880f, -0.01350924f, 
    0.05971769f, 0.01255676f, 0.20243078f, -0.05791993f, 0.08169609f, 0.04086846f, -0.07152306f, -0.05644869f, 
    -0.20586930f, 0.05924468f, -0.05359004f, -0.07741310f, -0.00753515f, 0.01255539f, -0.01269510f, -0.03554437f, 
    0.03073228f, 0.11287030f, -0.07963850f, -0.08805555f, 0.05725187f, 0.12959096f, 0.00786830f, 0.01107539f, 
    0.07840019f, -0.11938263f, 0.09464726f, -0.11270341f, -0.01647991f, 0.02838434f, -0.05009545f, 0.05057487f, 
    -0.11322757f, 0.10425281f, -0.05538986f, 0.07899291f, -0.01652288f, -0.01946233f, 0.03665817f, -0.08636805f, 
    0.05185166f, 0.02241618f, 0.08682202f, -0.06630147f, 0.05288604f, -0.14146927f, -0.28505990f, -0.08138209f, 
    -0.01271019f, 0.06030134f, -0.07926528f, 0.06623969f, -0.15442683f, -0.11895590f, -0.05696467f, 0.02259752f, 
    0.07933322f, 0.04716073f, 0.09760843f, 0.14198457f, -0.05896810f, -0.03978574f, 0.00437005f, -0.04091509f, 
    0.00484547f, 0.03625168f, 0.09354085f, 0.03310517f, 0.02721126f, 0.18719804f, 0.09161245f, 0.10903396f, 
    0.04847673f, -0.04840033f, 0.02106110f, -0.03873383f, 0.11554426f, 0.04306623f, 0.05137020f, 0.13501550f, 
    0.21909498f, 0.27756390f, 0.17589106f, 0.28491336f, -0.10318471f, 0.03868479f, 0.05170250f, 0.03554379f, 
    -0.02720493f, -0.01756657f, -0.03463472f, 0.06279014f, 0.39196941f, -0.25080624f, -0.08012127f, -0.05633542f, 
    -0.07646101f, -0.02729158f, -0.00601294f, -0.06937209f, -0.01994187f, -0.15680443f, -0.03645362f, 0.00334804f, 
    -0.07624262f, 0.20790195f, -0.03510077f, 0.01718694f, -0.10400146f, 0.14025652f, -0.01019910f, -0.05857407f, 
    -0.03740343f, 0.00055850f, -0.01176455f, -0.03305667f, 0.30291730f, 0.02957446f, -0.02844109f, -0.10084257f, 
    0.04089268f, 0.05854750f, 0.01835650f, 0.04528077f, 0.00352729f, 0.07644552f, -0.02691069f, -0.01547518f, 
    0.24731153f, -0.00218912f, 0.05090895f, 0.10653477f, 0.07797126f, -0.08736944f, 0.06040002f, 0.10084583f, 
    0.05873973f, -0.16850477f, -0.03420645f, -0.04037562f, -0.16148639f, 0.03004726f, -0.02324236f, 0.00642424f, 
    0.03938819f, 0.11920172f, 0.09782343f, 0.10693744f, 0.02853850f, -0.11083400f, 0.07950950f, 0.08506081f, 
    -0.07202002f, -0.18235984f, -0.19583042f, -0.24277812f, -0.00856166f, 0.02785492f, 0.02196844f, 0.02226491f, 
    -0.03491735f, 0.20213956f, -0.02050748f, 0.04446042f, 0.34526193f, -0.00298472f, -0.00486711f, -0.07383391f, 
    -0.01162480f, -0.02749386f, 0.02913775f, -0.05082747f, -0.09845930f, 0.00528672f, -0.09624474f, 0.01621865f, 
    0.08169202f, -0.06300709f, -0.06275356f, -0.05832384f, -0.13091446f, -0.02168293f, -0.05846323f, 0.04166150f, 
    -0.08378038f, -0.05268028f, -0.03648920f, -0.00691044f, 0.02554020f, 0.18132357f, 0.15032864f, 0.10481865f, 
    -0.01224149f, 0.06921409f, -0.07444406f, 0.20780586f, -0.09711956f, -0.03226042f, 0.04379678f, -0.01806933f, 
    0.13493647f, 0.22702171f, 0.13176544f, -0.09083457f, 0.02302974f, -0.00443265f, 0.06716993f, 0.00112577f, 
    0.13009518f, 0.14703691f, -0.21215649f, -0.14669266f, 0.26358777f, -0.14641248f, 0.24733441f, -0.22302200f, 
    -0.10413518f, -0.09719247f, 0.06087600f, 0.06810702f, -0.04333229f, -0.09994753f, -0.06840002f, 0.04961054f, 
    0.22911501f, 0.23390074f, 0.12728852f, 0.24760164f, 0.09489905f, -0.00964196f, 0.29600987f, 0.24296741f, 
    0.06538339f, 0.01095585f, -0.01414652f, 0.06335294f, -0.03097653f, 0.11160659f, -0.03448022f, 0.25964141f, 
    0.07846150f, 0.03927247f, -0.00840554f, -0.04939186f, 0.12193923f, 0.11355717f, -0.17772725f, -0.11739027f, 
    0.06528360f, 0.11737932f, 0.01252288f, 0.08334974f, -0.04224637f, 0.01839682f, 0.07939716f, -0.08381081f, 
    -0.01386197f, -0.01994704f, 0.06004905f, 0.05312157f, 0.16900498f, 0.08623955f, 0.09547567f, 0.17567484f, 
    -0.03768457f, 0.03375967f, 0.08237093f, -0.07107562f, -0.03443899f, -0.00966982f, 0.05751530f, -0.01425683f, 
    -0.06088839f, 0.01556764f, -0.00038876f, -0.10023915f, -0.03216241f, 0.03571012f, 0.09936707f, -0.06063349f, 
    0.04602792f, -0.08501007f, 0.01116619f, -0.03650944f, -0.16847256f, -0.09338061f, 0.04773723f, 0.32750708f, 
    -0.01767792f, -0.07679173f, 0.18729280f, 0.12626715f, 0.11191934f, -0.03963368f, -0.04555496f, 0.01342124f, 
    0.07457551f, 0.05001533f, 0.16771702f, -0.04924146f, 0.13202047f, -0.03858589f, 0.05570634f, 0.05902781f, 
    -0.07544463f, 0.10654239f, 0.04534620f, -0.01398092f, 0.10053018f, -0.10453153f, -0.10447858f, -0.07615897f, 
    0.02248977f, -0.02719899f, 0.05165323f, -0.00577219f, 0.05265862f, 0.10323223f, 0.02182384f, 0.02783570f, 
    -0.05149551f, -0.11682420f, -0.15804338f, -0.18200348f, -0.01212800f, -0.02517222f, 0.01895393f, -0.05023297f, 
    0.14889242f, 0.16860700f, 0.20940407f, 0.13149169f, -0.18933888f, 0.20357871f, -0.06969097f, 0.01184418f, 
    -0.03134380f, -0.02566529f, 0.12016132f, 0.12599993f, -0.07369444f, 0.12672891f, 0.01324403f, 0.11164691f, 
    -0.18996738f, -0.00447241f, 0.26971415f, 0.10958934f, -0.14647168f, 0.08678844f, 0.10776633f, 0.23637521f, 
    -0.08654897f, 0.06304675f, 0.02686555f, 0.04632144f, -0.01477004f, 0.06784469f, 0.01569076f, -0.05494731f, 
    0.01607075f, -0.02664236f, 0.03624226f, 0.03950937f, -0.07798481f, -0.02017976f, -0.08221655f, -0.04299175f, 
    0.54305351f, -0.12324167f, -0.03500511f, 0.12199397f, 0.07548896f, -0.03076836f, -0.03039850f, -0.04367719f, 
    0.09980371f, 0.04728198f, 0.03325000f, 0.02850827f, -0.59659195f, 0.17708355f, 0.12148401f, 0.36681199f, 
    -0.10662735f, 0.05170043f, 0.19300488f, 0.27002051f, 0.00780774f, 0.10991722f, 0.07377990f, 0.07906424f, 
    0.24883240f, -0.17266080f, -0.13922943f, -0.05468706f, 0.01414570f, -0.09060067f, 0.03744771f, -0.02920029f, 
    -0.04714116f, 0.07376196f, 0.07732493f, -0.00767665f, 0.02238792f, 0.11097687f, -0.19696592f, -0.09789577f, 
    -0.04920579f, 0.16030194f, 0.07900541f, 0.08242201f, 0.15731801f, 0.16102111f, 0.09231030f, 0.02556990f, 
    -0.04493608f, -0.00995591f, 0.08313558f, 0.16516759f, 0.03169327f, 0.04954737f, 0.15589805f, 0.10594255f, 
    -0.07696401f, 0.00444024f, -0.01968384f, 0.22933127f, 0.05066725f, -0.24059249f, -0.12565160f, 0.03767737f, 
    0.00599295f, -0.03300063f, 0.11610524f, 0.12364522f, 0.05622165f, 0.20407242f, -0.03603781f, 0.02524278f, 
    -0.03490766f, -0.03545768f, 0.05263431f, -0.20431453f, -0.03794045f, 0.01422886f, -0.09657642f, 0.10897432f, 
    0.00813229f, -0.02094174f, -0.00345181f, -0.08049518f, -0.03516625f, 0.14020516f, 0.20698890f, 0.11777471f, 
    -0.00922039f, -0.02161366f, -0.02168864f, 0.03467037f, -0.15124989f, -0.10134422f, 0.01944108f, -0.07953107f, 
    -0.24739753f, -0.42096728f, -0.33807361f, -0.23752594f, 0.03994760f, -0.08439609f, -0.14161786f, -0.08320107f, 
    -0.00481386f, 0.04892651f, 0.01339879f, -0.15852597f, 0.00969251f, 0.15310229f, -0.17976831f, -0.00312947f, 
    0.01988438f, -0.03338568f, 0.00597952f, 0.07982126f, 0.04443615f, 0.17757025f, 0.09813336f, 0.03186062f, 
    0.16705336f, -0.08429185f, -0.03455115f, -0.04751137f, 0.09578302f, -0.07346193f, 0.05362322f, 0.07321671f, 
    0.09070534f, 0.12088946f, 0.02604108f, -0.03080265f, -0.02291215f, 0.04532859f, 0.02430593f, -0.17838232f, 
    0.11937702f, 0.19837096f, 0.03852255f, -0.13155414f, 0.04724371f, -0.01469783f, 0.00032783f, 0.00830306f, 
    0.03504617f, 0.10575532f, -0.07793570f, 0.22254257f, -0.06006843f, 0.04479948f, 0.13446304f, 0.13958944f, 
    -0.10215225f, 0.05050897f, 0.01059619f, 0.12993176f, -0.00843351f, -0.04303846f, 0.02689726f, -0.01051934f, 
    -0.06108934f, 0.02328002f, 0.09688839f, 0.07920974f, -0.09517789f, -0.00407933f, 0.05306288f, 0.03010389f, 
    0.01186939f, -0.05640275f, 0.05770704f, 0.34958658f, -0.02146160f, -0.23552841f, 0.08835346f, 0.09577968f, 
    -0.02775792f, 0.01196902f, 0.12109750f, 0.03298257f, -0.20494100f, 0.10860025f, -0.01225480f, -0.07207150f, 
    -0.04123066f, 0.00974904f, -0.02159934f, -0.01655527f, 0.10022203f, 0.07690150f, 0.09239046f, 0.08756944f, 
    -0.17027271f, -0.06620077f, -0.01008588f, 0.06558121f, -0.02388074f, 0.01785248f, -0.03286389f, 0.10671867f, 
    0.03080783f, 0.05083016f, -0.02800734f, 0.02159289f, -0.33762977f, -0.42339918f, -0.24730255f, -0.19571595f, 
    0.06464671f, 0.06693197f, 0.06163917f, -0.11015672f, 0.08025803f, 0.03873145f, 0.00269405f, 0.02412022f, 
    -0.08588705f, 0.09151573f, 0.19421698f, 0.08593590f, 0.01323190f, -0.03876618f, -0.11178859f, -0.07552945f, 
    -0.04598293f, -0.09597746f, 0.37847993f, 0.10211717f, -0.18601769f, 0.15789664f, -0.12035187f, 0.29455358f, 
    0.20979640f, 0.08333041f, 0.05026694f, -0.05626007f, 0.02446507f, 0.02727882f, 0.09293052f, -0.02766597f, 
    -0.29636636f, -0.38856795f, -0.27712947f, -0.07705390f, 0.02661972f, 0.11855970f, -0.15548059f, -0.06176532f, 
    -0.04275957f, 0.05112402f, 0.05395563f, 0.01145883f, 0.24113993f, -0.06850083f, -0.06387254f, -0.24349019f, 
    -0.05026094f, -0.01886412f, 0.03242645f, 0.01413799f, -0.10645181f, -0.03043715f, 0.20816381f, 0.03444381f, 
    -0.04232192f, -0.02437113f, 0.06922582f, -0.05276389f, 0.02426607f, 0.04816149f, 0.01579862f, 0.17282994f, 
    0.09657340f, 0.04281936f, 0.11325539f, -0.07648437f, -0.20387541f, 0.06011351f, 0.05343706f, 0.08596904f, 
    0.00754533f, 0.06942844f, 0.01670492f, 0.01250447f, 0.03428712f, 0.08030213f, -0.01844370f, 0.06360468f, 
    -0.24354962f, -0.23846717f, -0.08393496f, 0.01463945f, 0.05677351f, -0.00026146f, 0.16524196f, -0.04720326f, 
    0.03414690f, -0.02594084f, 0.01720055f, 0.00178605f, -0.11712682f, -0.48198408f, -0.23978403f, 0.08934449f, 
    -0.27538696f, -0.05937682f, -0.01339702f, 0.02059475f, -0.03924722f, -0.10570880f, 0.17328320f, -0.18924077f, 
    -0.02399509f, -0.00613457f, 0.35969284f, -0.04941689f, -0.01992439f, -0.18571928f, -0.02417615f, -0.05000175f, 
    -0.01678369f, -0.09357933f, -0.01462930f, 0.05437690f, -0.13989732f, 0.15168294f, 0.11156905f, -0.09117755f, 
    -0.18911330f, -0.01339492f, 0.02745757f, 0.07272288f, 0.02361252f, -0.01301087f, 0.03610343f, -0.03834459f, 
    0.04238520f, 0.19853848f, -0.27464765f, -0.11949939f, 0.02468916f, 0.07197227f, -0.01575904f, 0.10206766f, 
    -0.03140218f, 0.12274673f, 0.05034132f, 0.01500511f, 0.06196583f, 0.29572448f, -0.16519178f, 0.10674379f, 
    0.12138177f, 0.12108416f, -0.10493897f, 0.12114779f, 0.22798930f, -0.04468315f, -0.05024341f, 0.00770264f, 
    0.21210165f, 0.28871104f, 0.07191005f, 0.41002354f, -0.00964238f, 0.12360370f, 0.03308588f, -0.13434473f, 
    0.01836342f, 0.12361053f, -0.08066420f, -0.04644134f, -0.13522218f, -0.30412725f, -0.16762759f, -0.12060213f, 
    -0.04810194f, -0.02282423f, -0.05574731f, -0.10573361f, 0.04658972f, 0.04086110f, 0.04254003f, -0.05125254f, 
    -0.14935736f, -0.03083515f, -0.21007554f, -0.10698897f, -0.14893727f, 0.16874962f, 0.14419664f, 0.20353116f, 
    -0.17256275f, -0.07616349f, -0.17160538f, -0.13163616f, 0.07518927f, 0.15331827f, -0.18374078f, 0.39939266f, 
    0.20647906f, 0.03655347f, 0.03074679f, -0.04036244f, 0.01435858f, 0.05272755f, 0.08969143f, 0.06842046f, 
    0.08497883f, 0.16481876f, 0.28227669f, 0.18279226f, -0.00177608f, -0.02132945f, 0.11784850f, 0.07978915f, 
    -0.06879182f, -0.09635723f, -0.04446165f, -0.12238504f, -0.09542011f, 0.14362247f, 0.03471496f, 0.00250599f, 
    -0.15511222f, 0.13986322f, -0.10644516f, 0.05540930f, -0.04590255f, -0.08233853f, 0.04075046f, 0.00541188f, 
    -0.12609798f, -0.19762506f, 0.04647819f, 0.23069669f, -0.00469543f, 0.01721677f, 0.03033905f, -0.05968960f, 
    0.07213333f, -0.07024322f, 0.07941811f, 0.04825235f, 0.01962946f, -0.05328466f, 0.01542296f, 0.02173842f, 
    0.18793154f, 0.13401930f, 0.02094673f, 0.12502547f, -0.05533868f, 0.09032862f, -0.13655826f, -0.09618445f, 
    -0.62400973f, 0.10644741f, -0.21644139f, 0.28887561f, -0.10350041f, 0.11409090f, 0.06375869f, -0.18901901f, 
    0.04984976f, 0.01427874f, -0.11573809f, -0.03047002f, -0.07674870f, -0.20307583f, -0.11814665f, 0.29564875f, 
    -0.03854840f, -0.06398217f, -0.00297163f, -0.12943134f, 0.02558350f, -0.07256355f, 0.02857152f, -0.07434501f, 
    0.24691895f, 0.20974764f, 0.21259074f, 0.13242494f, 0.19738229f, 0.21348576f, 0.14456680f, 0.22816753f, 
    0.00849820f, -0.03985934f, 0.02599198f, 0.09215727f, -0.10568222f, 0.22412324f, -0.44647723f, -0.13768509f, 
    0.04578528f, 0.09750237f, -0.06701330f, 0.03212392f, 0.06294000f, 0.05198589f, -0.01465980f, 0.02173570f, 
    -0.17775452f, 0.00092077f, 0.29174435f, 0.06150034f, -0.15356795f, -0.01633267f, -0.19962315f, 0.02075460f, 
    -0.07127612f, -0.01141923f, -0.15562034f, -0.03873263f, 0.08335892f, 0.03717062f, 0.30354998f, 0.29988214f, 
    -0.08374653f, 0.32957008f, -0.05572117f, 0.23132655f, -0.07582168f, 0.07147271f, 0.00976843f, -0.02630485f, 
    -0.00081726f, 0.26905087f, -0.18699250f, 0.08976014f, 0.01934344f, 0.09974744f, 0.08389318f, -0.02806442f, 
    -0.03086038f, 0.01285619f, -0.11843339f, 0.03531158f, 0.03895360f, -0.04415733f, -0.06183212f, 0.23302566f, 
    -0.03709476f, -0.10455205f, 0.25566185f, 0.06769939f, -0.05573769f, -0.01127512f, -0.18266137f, -0.12439015f, 
    0.08476771f, 0.01329299f, 0.15791155f, -0.09068133f, 0.00611594f, 0.20728546f, 0.09082725f, 0.06336597f, 
    0.06007132f, -0.00864782f, 0.05613698f, -0.18452325f, 0.00953459f, -0.04993994f, -0.24905172f, -0.12213726f, 
    -0.00630086f, -0.00702163f, -0.01139795f, 0.01521984f, 0.09332935f, -0.04816942f, -0.18256593f, 0.01778438f, 
    -0.13271344f, -0.06842005f, 0.02966779f, 0.18516654f, -0.01688146f, -0.07294340f, -0.06792222f, 0.08638534f, 
    -0.07810288f, 0.08355467f, -0.06593445f, -0.01072933f, 0.27998826f, 0.33391720f, -0.02486653f, 0.10536340f, 
    0.20736006f, -0.00517849f, 0.17062950f, 0.23975594f, -0.12241352f, 0.00243582f, -0.04573473f, 0.02498754f, 
    0.00485489f, -0.06963307f, -0.14219691f, 0.08580066f, -0.03790232f, 0.05443225f, -0.08340795f, -0.01109686f, 
    -0.01177868f, -0.16523705f, -0.28406191f, -0.01906104f, 0.07958893f, 0.48414069f, -0.15206081f, 0.06867853f, 
    0.15184036f, -0.05613335f, -0.08041357f, 0.06088785f, 0.05192420f, -0.12747924f, -0.10519004f, -0.01018317f, 
    0.38918832f, 0.35555640f, 0.31937960f, 0.47208992f, 0.22952029f, 0.16267055f, 0.13860770f, 0.19565380f, 
    0.07761226f, -0.08132081f, 0.04965380f, -0.06812420f, 0.21336341f, 0.13545206f, 0.23576427f, -0.04059097f, 
    -0.08608713f, 0.03642592f, 0.10840204f, 0.12202060f, -0.15905498f, -0.09359878f, -0.20431513f, -0.14252552f, 
    0.00041571f, 0.08633158f, -0.00796380f, 0.04111162f, -0.03969524f, 0.09957299f, 0.12898110f, 0.12781197f, 
    -0.04968315f, 0.11658733f, 0.03137582f, 0.03343072f, 0.16916080f, 0.06144107f, -0.08229454f, 0.23844019f, 
    -0.03593061f, -0.11541604f, -0.15563916f, -0.08401123f, 0.16498153f, 0.12695427f, -0.04528293f, 0.16908720f, 
    -0.03556560f, 0.00031238f, 0.00235251f, 0.00017143f, -0.03283074f, -0.05066264f, -0.05482010f, 0.04336045f, 
    0.02637172f, 0.02012923f, -0.01249582f, 0.02221530f, -0.03805904f, 0.04809224f, -0.01225857f, 0.03982913f, 
    -0.00612274f, 0.01989720f, -0.00454983f, -0.05529555f, 0.00237525f, 0.00657048f, -0.01487519f, 0.03217055f, 
    0.00910260f, -0.04181108f, -0.04416902f, -0.02442926f, 0.01159812f, 0.02513766f, -0.01240215f, 0.02506670f, 
    0.03976766f, -0.02368443f, -0.02115173f, -0.02670805f, -0.00396726f, -0.03960972f, 0.01319462f, -0.03180160f, 
    -0.00547822f, -0.05592253f, -0.01854169f, 0.04277255f, 0.01120951f, -0.05284721f, -0.00526379f, -0.00108912f, 
    0.00366710f, 0.00765811f, 0.04593049f, 0.04085974f, 0.04453181f, 0.02728362f, 0.01008665f, 0.00254225f, 
    -0.04125983f, -0.04405686f, -0.03531013f, -0.01787360f, 0.03785424f, 0.02502978f, 0.03825435f, -0.04570737f, 
    -0.00575113f, 0.02674546f, 0.02519734f, -0.03955675f, -0.00148017f, -0.03421109f, 0.00475795f, 0.03754232f, 
    -0.01676132f, -0.02167755f, 0.01695474f, -0.00527744f, -0.02591312f, 0.01456670f, -0.01030428f, -0.00841263f, 
    0.00561719f, 0.02303776f, -0.02569432f, 0.01859437f, 0.02711251f, 0.03281684f, -0.02219225f, 0.00444309f, 
    -0.03640421f, 0.00644464f, 0.00720697f, -0.01730809f, -0.02728498f, 0.02685102f, 0.03798523f, -0.02128024f, 
    -0.00546095f, 0.03543630f, -0.03829363f, 0.03469535f, -0.04106223f, -0.01226279f, 0.00744081f, 0.03612082f, 
    -0.01273157f, 0.02770017f, 0.03402608f, -0.03327046f, 0.03956206f, -0.00004502f, -0.01492103f, 0.03726137f, 
    -0.02191065f, 0.03894980f, 0.02479086f, -0.02075214f, -0.01052101f, -0.02986064f, -0.00565162f, -0.05377922f, 
    0.02004117f, -0.03551039f, -0.01873694f, -0.02310165f, -0.01780732f, -0.03715716f, -0.04452979f, -0.02993371f, 
    0.01017950f, -0.03771587f, 0.04389087f, -0.01102089f, -0.05554589f, 0.03875841f, 0.04396662f, 0.01434950f, 
    0.02098789f, 0.03005019f, 0.03997655f, 0.02204545f, -0.05660350f, 0.02705665f, -0.00369561f, -0.05804951f, 
    0.02553332f, -0.01361082f, 0.02011932f, -0.00890814f, 0.01543444f, -0.02518999f, -0.00054356f, 0.03133597f, 
    0.01589051f, 0.01049938f, -0.04437922f, -0.01749673f, -0.01613598f, -0.04937965f, -0.02742102f, 0.01765182f, 
    0.01442761f, -0.01134153f, -0.04436032f, 0.02502535f, 0.04011537f, -0.03555287f, -0.01777767f, 0.00090950f, 
    0.01243072f, 0.01664875f, 0.00911758f, 0.04015405f, -0.04778594f, -0.00650751f, -0.04729678f, 0.02345204f, 
    0.00750911f, -0.02483696f, 0.00250730f, 0.04188082f, 0.04257058f, -0.02500196f, -0.03598271f, -0.03462048f, 
    -0.00157327f, -0.00840544f, -0.01943362f, 0.02635620f, -0.01115584f, 0.04530346f, 0.01552263f, -0.02761976f, 
    -0.03093711f, -0.02227286f, -0.01257171f, -0.04562292f, -0.00725508f, 0.04458503f, 0.04191190f, -0.02984187f, 
    0.02160991f, -0.02933683f, 0.04499548f, 0.01587511f, -0.03973504f, -0.04286420f, 0.01664591f, -0.01125352f, 
    -0.04448014f, -0.01833642f, 0.00670763f, -0.03691085f, -0.04065635f, -0.02185832f, 0.00261532f, 0.02530431f, 
    0.02059965f, -0.03347110f, 0.00479970f, -0.03856738f, 0.04014179f, -0.03106972f, -0.02788497f, -0.05502482f, 
    -0.00558091f, -0.00486883f, 0.04226044f, -0.05670561f, -0.05048077f, -0.05974138f, -0.00057353f, 0.01353043f, 
    0.01244314f, -0.02441020f, -0.02571259f, 0.01076782f, 0.00603657f, -0.04756211f, -0.02843712f, -0.01848247f, 
    -0.02984014f, -0.02123637f, -0.01600303f, -0.05420103f, -0.04392262f, -0.04459800f, -0.02599785f, 0.03746696f, 
    0.00977575f, -0.02603586f, -0.00318304f, -0.01483511f, -0.03251688f, -0.01468578f, 0.03160409f, 0.03095599f, 
    -0.01791560f, -0.02054722f, -0.00131294f, 0.01072026f, -0.05264080f, -0.02715872f, 0.01338193f, -0.02235072f, 
    -0.02891499f, -0.00029308f, -0.01254879f, -0.04016535f, -0.03197039f, 0.02139527f, -0.03306689f, 0.03539290f, 
    -0.02034595f, -0.01585391f, -0.02321813f, -0.04802607f, -0.02347898f, 0.00426740f, 0.03440570f, -0.01931509f, 
    0.02670442f, 0.00858241f, 0.01185014f, -0.04695139f, -0.03605261f, -0.02918722f, 0.04116494f, -0.01403480f, 
    0.03465392f, 0.04291969f, 0.00306321f, -0.05884696f, 0.03986809f, 0.00665164f, 0.02653977f, 0.00713484f, 
    -0.00662665f, 0.01929900f, -0.01167868f, -0.04053384f, -0.00766274f, -0.05739991f, -0.04888362f, -0.02244412f, 
    0.03462758f, -0.01157671f, -0.02545195f, 0.02429336f, -0.00052520f, 0.03884137f, 0.03875328f, -0.02091925f, 
    0.02396444f, 0.02720744f, 0.00501690f, -0.03082883f, -0.01915650f, -0.05694778f, 0.00136476f, -0.04134092f, 
    0.03647667f, -0.02230241f, 0.02886866f, 0.00639481f, -0.04718873f, -0.01018281f, -0.04014394f, -0.01590390f, 
    -0.01980139f, -0.00937023f, 0.02261402f, -0.02391380f, 0.04249156f, 0.02675644f, -0.03807988f, 0.02799079f, 
    -0.02882276f, -0.05648051f, -0.00291437f, -0.00145053f, 0.04465766f, 0.01180694f, 0.00885093f, 0.03830337f, 
    -0.01802361f, -0.01997662f, -0.01136983f, 0.02945563f, -0.02209137f, -0.04683952f, -0.05202031f, 0.01399681f, 
    0.04375517f, 0.00835319f, 0.04325139f, 0.04464255f, -0.01405839f, 0.02924340f, -0.03010584f, -0.02899038f, 
    0.00841253f, -0.00335506f, -0.03189750f, -0.05263067f, 0.02577839f, 0.01215329f, -0.02478465f, -0.02845245f, 
    0.01803757f, -0.01908643f, 0.03859887f, -0.04608792f, -0.00745908f, -0.01728558f, -0.01674406f, -0.04143598f, 
    0.03679241f, -0.01053068f, -0.02868959f, 0.03226860f, 0.01957008f, 0.00681232f, -0.02542618f, -0.06167251f, 
    -0.19918132f, 0.38507119f, -0.04008940f, -0.05028042f, -0.03157068f, -0.10228679f, -0.06406194f, -0.02902240f, 
    -0.03301708f, -0.00026275f, -0.04346225f, 0.01971469f, -0.02145268f, 0.20850508f, 0.02225478f, 0.09680896f, 
    0.09848625f, 0.09537238f, 0.03149303f, 0.15213816f, -0.05371016f, -0.00178801f, 0.09577796f, 0.01341573f, 
    0.31630078f, 0.15655226f, 0.01705871f, 0.01961190f, 0.01118049f, 0.02607242f, 0.09139030f, -0.03603940f, 
    -0.10906356f, 0.09454168f, -0.16837154f, -0.09523372f, 0.05454067f, 0.00601525f, -0.20751575f, 0.13188320f, 
    0.05114431f, 0.08467156f, 0.02964123f, 0.09497289f, 0.05530310f, 0.15468776f, -0.02877055f, -0.03785771f, 
    -0.26281253f, 0.07107520f, -0.02818950f, -0.12302487f, -0.10263994f, -0.06946079f, 0.17021610f, 0.09103514f, 
    0.04471905f, 0.04831681f, 0.04247120f, -0.02789585f, -0.02370399f, 0.01207088f, 0.21900052f, 0.11901794f, 
    0.00528311f, 0.06265943f, -0.04802643f, 0.11033069f, 0.13009752f, 0.09067140f, -0.01753862f, -0.09569671f, 
    0.21881245f, -0.13519795f, 0.27877250f, -0.14145580f, 0.08745038f, -0.03143615f, 0.02438364f, -0.04160608f, 
    -0.08637805f, -0.12081723f, 0.03396039f, 0.01593188f, 0.05701114f, 0.29753780f, 0.31631702f, -0.06036363f, 
    0.02289250f, -0.26686871f, -0.06811245f, -0.06932989f, 0.06920411f, 0.04991752f, 0.06285758f, -0.08100189f, 
    -0.30819654f, 0.20070533f, -0.07947409f, -0.00185257f, 0.00106286f, -0.03666807f, 0.22165152f, 0.07284728f, 
    0.10818553f, 0.04733507f, 0.06833065f, 0.18370686f, 0.11457622f, 0.23821715f, 0.24021415f, 0.24639383f, 
    -0.26268747f, 0.17718320f, 0.19018853f, -0.02710048f, 0.06177709f, 0.03903518f, -0.00102965f, -0.00322678f, 
    0.01775249f, -0.05630240f, -0.13293241f, 0.05859114f, 0.02210465f, 0.04839398f, -0.03133238f, 0.01590757f, 
    -0.01916673f, 0.05602350f, 0.06447060f, 0.04511675f, 0.07637531f, -0.06530762f, -0.15208729f, 0.08515195f, 
    -0.20444962f, 0.16794638f, 0.11326782f, 0.01882370f, 0.00201346f, 0.18065675f, -0.02662777f, 0.09951681f, 
    0.07803041f, -0.25604185f, 0.29225203f, 0.06605759f, -0.02258488f, 0.24931933f, -0.04029803f, 0.01044470f, 
    0.01517080f, 0.07034697f, -0.16613898f, 0.12567438f, 0.08578905f, 0.04799557f, 0.07243842f, 0.13688713f, 
    -0.08029281f, -0.15307169f, 0.10878763f, 0.16918495f, -0.06210854f, -0.01485760f, -0.08894968f, -0.11089049f, 
    0.45697156f, 0.39829016f, 0.01829765f, -0.03252742f, -0.01668369f, -0.10636991f, -0.09080381f, 0.15848143f, 
    -0.09302846f, -0.04140426f, 0.04890925f, 0.10690310f, 0.41104156f, 0.01634046f, 0.12242565f, -0.08271290f, 
    -0.09568775f, -0.00770774f, -0.20261638f, -0.05661003f, -0.09622078f, 0.07655162f, 0.07903791f, 0.01445933f, 
    -0.13589029f, -0.13146372f, 0.07600241f, 0.24533337f, -0.11490063f, 0.10191657f, 0.02910540f, -0.03162238f, 
    -0.05805743f, 0.01933820f, -0.08757050f, 0.03555362f, -0.28297314f, -0.10762181f, 0.12671198f, -0.07758077f, 
    -0.19582570f, 0.05390123f, -0.08203240f, 0.17158334f, 0.15034181f, 0.03112265f, -0.00125368f, -0.05205332f, 
    0.11057341f, -0.05351972f, 0.09784445f, 0.10518918f, -0.07623753f, 0.10815325f, -0.05074940f, 0.16229779f, 
    -0.00684065f, -0.03213222f, 0.04340741f, 0.01984052f, -0.06524431f, 0.33372864f, 0.21557866f, -0.13436198f, 
    -0.06806737f, 0.04028608f, -0.11960369f, -0.01688276f, -0.03740612f, -0.07215478f, 0.06454747f, -0.10376128f, 
    -0.25286159f, 0.01071275f, 0.33541703f, 0.00714934f, -0.08427366f, 0.04038242f, 0.06590404f, -0.14682280f, 
    -0.01585671f, 0.04901921f, 0.04478624f, -0.08721208f, 0.07630323f, -0.15365639f, 0.06138674f, -0.17007773f, 
    0.16082941f, -0.04926019f, -0.17452547f, -0.10417650f, 0.05875109f, -0.10372493f, -0.01123619f, 0.01065557f, 
    0.01064109f, 0.10869233f, -0.09107120f, 0.05809860f, -0.04091939f, -0.01202355f, 0.13825150f, 0.03695313f, 
    0.00295569f, -0.07719557f, 0.04882378f, -0.10061103f, -0.24554031f, -0.05129337f, -0.12578623f, -0.12854564f, 
    -0.15085043f, 0.02442984f, -0.03742148f, 0.06854302f, 0.12753910f, -0.03768343f, -0.00029106f, 0.02775170f, 
    -0.02348436f, 0.06121262f, 0.17574827f, 0.10800614f, -0.04225599f, -0.07810374f, 0.05135902f, -0.04334193f, 
    -0.12872115f, -0.11616933f, -0.06399623f, -0.12152219f, -0.11329589f, -0.17299730f, 0.20310549f, 0.26805067f, 
    0.07048613f, -0.14383267f, -0.01269956f, 0.04021768f, -0.01327068f, 0.03760940f, -0.08524083f, -0.05390825f, 
    0.06640480f, 0.03662905f, 0.07199173f, -0.03773936f, 0.01709532f, -0.15299529f, -0.04476734f, -0.04285526f, 
    0.09983335f, -0.02271631f, -0.02746377f, 0.13293380f, -0.18447734f, 0.01702952f, 0.19672433f, 0.17650251f, 
    0.05667055f, 0.03982854f, 0.05101277f, 0.01350010f, 0.03475598f, 0.05068928f, 0.04762800f, 0.01072538f, 
    -0.16817971f, -0.30976263f, 0.13951637f, 0.18801433f, -0.07460370f, 0.17870326f, -0.09621295f, -0.13092577f, 
    0.02282691f, 0.05379546f, 0.01117238f, 0.08297656f, 0.05780166f, -0.24215041f, -0.02011298f, -0.08074924f, 
    0.13209122f, -0.11797156f, 0.04639699f, -0.06931448f, 0.01085600f, 0.14288048f, 0.01320144f, 0.12959930f, 
    0.11381346f, -0.04514110f, 0.01892822f, 0.08053728f, 0.09407854f, 0.02291177f, 0.03087795f, 0.26425785f, 
    -0.06796014f, 0.08711341f, -0.03697070f, -0.02517325f, 0.06412403f, -0.06687658f, 0.23384628f, -0.13660409f, 
    0.04176560f, -0.06035612f, 0.01573549f, 0.07325956f, -0.12198184f, -0.18297550f, -0.01131919f, -0.01139092f, 
    -0.01767013f, -0.03383642f, 0.01380922f, -0.03234453f, -0.01221155f, 0.01708374f, -0.03816003f, -0.05046785f, 
    0.02169309f, -0.02554982f, -0.01908695f, -0.04081666f, -0.02344559f, -0.04206086f, -0.05773961f, 0.04015267f, 
    -0.03212024f, 0.00729113f, 0.03899584f, 0.04709901f, -0.03670230f, -0.02388464f, -0.02333206f, 0.02638414f, 
    -0.04074934f, -0.03810565f, 0.01567408f, -0.03015072f, -0.01391436f, -0.00602000f, -0.00193995f, 0.03806991f, 
    -0.00262695f, -0.04352589f, -0.04116741f, 0.03080451f, -0.04876791f, 0.00673905f, -0.02075133f, -0.01244420f, 
    0.03664902f, -0.00413970f, 0.05113628f, 0.03071185f, -0.00222888f, -0.00461126f, 0.04243652f, 0.03994239f, 
    -0.04294546f, -0.01540191f, -0.04590086f, -0.03953647f, 0.01580726f, -0.01767134f, 0.02683846f, -0.02947387f, 
    -0.02473439f, -0.00578962f, 0.03449908f, -0.00860838f, 0.00692498f, -0.03003034f, 0.01819642f, -0.00726744f, 
    -0.04590525f, -0.01652809f, 0.03438812f, 0.00103639f, 0.02374262f, 0.02399697f, 0.00066661f, 0.02922658f, 
    -0.02235302f, 0.01076145f, 0.02593239f, -0.05556526f, 0.03787338f, -0.00989498f, -0.01945315f, -0.05804988f, 
    0.01977768f, 0.00196349f, 0.01858079f, 0.02196388f, 0.02005623f, 0.01931695f, 0.03228325f, -0.00496845f, 
    0.03724709f, -0.04082876f, -0.04476291f, -0.03512642f, 0.01401024f, -0.03275338f, -0.01332178f, 0.00343585f, 
    -0.05290974f, -0.02706528f, -0.05016956f, -0.03389582f, -0.03650638f, 0.01870549f, -0.03465506f, -0.04922209f, 
    0.03352448f, -0.01363103f, 0.01915989f, -0.04399475f, -0.03182152f, -0.04671070f, -0.02014495f, 0.01545207f, 
    -0.03857284f, 0.01727872f, 0.04266089f, 0.01542551f, -0.02295284f, -0.04380922f, -0.03174332f, 0.04391377f, 
    0.03637901f, 0.03509403f, -0.04083249f, -0.00817676f, -0.01710517f, 0.01316470f, 0.02395104f, 0.04481972f, 
    -0.01172626f, -0.02863379f, -0.00699261f, -0.01799131f, 0.04304515f, -0.04530720f, -0.05425649f, 0.00575444f, 
    0.03473711f, 0.01938471f, 0.01269302f, -0.04465680f, 0.02562184f, -0.02657763f, -0.04271738f, -0.04082457f, 
    0.03754784f, -0.00896621f, -0.02478683f, -0.01571199f, -0.04824297f, 0.01454211f, -0.02597918f, 0.00283956f, 
    0.03598708f, -0.01767889f, 0.02486318f, 0.00068853f, -0.04548651f, -0.00141154f, -0.03698806f, -0.03062061f, 
    -0.01979442f, 0.04089151f, -0.03404428f, -0.03827456f, 0.02111584f, -0.00176579f, -0.00309003f, 0.01873953f, 
    0.03400764f, 0.01233285f, -0.05938715f, 0.00042842f, 0.03319135f, -0.01569970f, 0.01577787f, -0.02604051f, 
    -0.05947211f, -0.00479160f, 0.01048779f, -0.03828621f, -0.04034720f, -0.04324669f, 0.01030635f, -0.01658305f, 
    -0.00986670f, -0.01289906f, 0.01133561f, 0.00588639f, 0.01417671f, 0.00332577f, -0.05681912f, 0.00999927f, 
    -0.03464900f, 0.03957765f, -0.00930763f, 0.02428470f, -0.02330795f, 0.03777494f, -0.00143909f, -0.00461848f, 
    -0.05239102f, 0.01688738f, 0.03294844f, -0.03801407f, -0.03407405f, 0.00506042f, 0.02090933f, -0.03019854f, 
    -0.03213868f, 0.00417624f, 0.02636327f, -0.03403112f, 0.03623338f, -0.04609217f, 0.02499826f, -0.01898234f, 
    -0.00868271f, 0.03839960f, 0.02560730f, -0.00521225f, 0.03094727f, -0.01758439f, -0.04627651f, -0.04623452f, 
    0.03568199f, -0.01655221f, -0.04735791f, 0.00064037f, -0.01284424f, 0.01060127f, 0.02382912f, 0.03537282f, 
    0.01454385f, 0.03381158f, 0.01086342f, -0.04534985f, -0.03819454f, -0.00610590f, -0.02031432f, -0.00422329f, 
    0.00191447f, -0.04779430f, 0.00855248f, -0.04952859f, 0.00877740f, 0.01605751f, 0.00142174f, -0.01540594f, 
    0.04016177f, 0.00548399f, 0.01572663f, 0.03496394f, 0.02997240f, -0.05029744f, -0.03796815f, 0.03908086f, 
    -0.02227193f, 0.02165804f, -0.01460607f, 0.02348275f, 0.01053884f, -0.04656976f, 0.03393418f, -0.00067341f, 
    0.00740562f, 0.04084018f, 0.01623621f, -0.01262808f, -0.03390739f, -0.02149709f, -0.04702378f, -0.00770906f, 
    -0.03301229f, 0.00019423f, -0.04101364f, 0.01849047f, -0.02162590f, 0.00444966f, -0.03476199f, -0.03947820f, 
    0.03280027f, -0.01565288f, -0.03447638f, -0.00540715f, -0.04276716f, -0.01857844f, -0.03142921f, -0.05660053f, 
    0.00279534f, 0.02725260f, -0.02201131f, -0.05055372f, 0.03183931f, -0.02410555f, 0.03187871f, -0.02495572f, 
    -0.02566375f, -0.02707701f, 0.02298823f, 0.03239641f, -0.03707871f, -0.04699736f, -0.01929097f, 0.00219020f, 
    -0.03331434f, -0.03733120f, -0.00285355f, 0.03215204f, 0.02348061f, 0.01024513f, 0.00047854f, 0.03817003f, 
    0.00738056f, -0.03755586f, 0.01775226f, -0.02950724f, 0.00479911f, 0.01261631f, -0.03971546f, -0.02624050f, 
    0.02823608f, 0.02147303f, 0.03317380f, -0.04918179f, -0.01401259f, 0.00218325f, 0.02483886f, 0.00921099f, 
    0.01271454f, 0.01974813f, 0.01219599f, 0.00343873f, -0.03555507f, 0.04560268f, -0.02771505f, 0.03327147f, 
    -0.04416502f, 0.04373917f, -0.00546916f, -0.03112521f, -0.05057443f, 0.03790516f, 0.00761029f, 0.00250696f, 
    -0.03661618f, 0.00826272f, -0.03295006f, -0.00235249f, -0.04454596f, -0.04412893f, 0.02296617f, -0.02122103f, 
    0.01650980f, 0.01896948f, -0.02010033f, 0.01273461f, -0.04147446f, -0.05112243f, -0.04760247f, 0.00853340f, 
    -0.00251771f, -0.01892539f, -0.03106794f, -0.01552799f, -0.05267754f, 0.01284123f, -0.02523218f, -0.00183754f, 
    -0.01135660f, 0.02922924f, -0.04523452f, -0.01646351f, -0.04266134f, 0.00009152f, 0.00304205f, -0.01970480f, 
    -0.01243483f, -0.03189615f, 0.00310779f, -0.02447885f, -0.05829192f, -0.03798173f, -0.05336973f, -0.01905982f, 
    -0.19736527f, 0.09308644f, 0.10261108f, -0.11570746f, -0.06834791f, 0.03530791f, 0.02618176f, 0.04596291f, 
    -0.06924197f, -0.10478659f, -0.03740544f, 0.09326285f, -0.41977072f, -0.17998075f, 0.21429366f, 0.22265057f, 
    -0.05892848f, 0.17498364f, -0.09160767f, 0.00563580f, 0.19484225f, -0.04706715f, -0.13043950f, 0.21519971f, 
    -0.01550745f, 0.02801720f, -0.27821371f, 0.03146777f, 0.04814117f, -0.00908554f, -0.14510049f, -0.00513926f, 
    -0.09427000f, 0.01615491f, 0.07291935f, 0.01089224f, 0.26266742f, 0.04277787f, 0.02898169f, -0.14054769f, 
    0.09686908f, -0.07613879f, -0.00687952f, -0.05225743f, 0.04121986f, -0.05136658f, -0.08829077f, -0.09494836f, 
    0.15264298f, -0.21999501f, 0.09522588f, 0.08115212f, 0.08306658f, 0.08426023f, -0.04328618f, -0.08372100f, 
    0.03057663f, 0.01821853f, 0.01570993f, 0.14395182f, -0.23068357f, -0.12205612f, -0.01447062f, 0.09272116f, 
    -0.00779071f, 0.03148130f, 0.06845223f, 0.08103623f, -0.11661293f, 0.09278619f, -0.07461897f, 0.06508191f, 
    -0.17718978f, 0.08628251f, -0.12891284f, 0.17660147f, 0.03536008f, 0.06753463f, -0.16934168f, 0.09199726f, 
    0.02533198f, 0.04348430f, -0.01955194f, -0.04475236f, -0.19296035f, -0.07236795f, 0.07410487f, 0.01729245f, 
    0.04523218f, 0.07249083f, 0.02871316f, 0.10201405f, 0.07417287f, -0.05628397f, -0.11082529f, 0.08961362f, 
    1.08011603f, -0.32784855f, 0.10242982f, 0.29313195f, -0.01690723f, -0.04492731f, -0.22175682f, -0.08450284f, 
    -0.12222325f, 0.04720657f, 0.12741384f, 0.05580686f, -0.61150652f, 0.01887877f, 0.12731266f, 0.00447295f, 
    0.16575617f, -0.01179903f, 0.02267310f, 0.07195904f, -0.13140757f, -0.10518520f, 0.01117672f, -0.00310842f, 
    0.19418092f, -0.10168260f, 0.04041682f, 0.16279571f, 0.01425459f, -0.02047670f, -0.11553683f, -0.10314793f, 
    0.16136976f, 0.03085325f, -0.08023001f, 0.14151888f, 0.25248703f, 0.12532575f, -0.13981962f, -0.03059424f, 
    -0.02544047f, -0.00613925f, 0.07991547f, -0.06414341f, 0.08364657f, -0.01947917f, -0.00816141f, -0.21499148f, 
    -0.30599377f, 0.17460683f, -0.12943700f, -0.02823931f, 0.07665984f, 0.05899959f, -0.28027287f, 0.11470196f, 
    0.07222470f, 0.05527876f, -0.02167490f, 0.12478086f, 0.00835602f, -0.10437420f, -0.04304644f, 0.13867886f, 
    0.16416065f, -0.00646076f, 0.04554630f, 0.14021546f, 0.05050674f, -0.00222636f, 0.04460473f, 0.13508852f, 
    0.03691643f, -0.13134706f, 0.21253371f, -0.40325236f, -0.05439512f, 0.25249717f, -0.11194593f, 0.18546447f, 
    -0.09483384f, -0.07021111f, 0.03640037f, 0.01906112f, -0.22625393f, 0.07386424f, 0.09283525f, 0.18184602f, 
    0.05980709f, 0.00159258f, -0.08605654f, 0.15663801f, 0.09134207f, 0.02282570f, 0.08280056f, -0.05274504f, 
    -0.06072441f, -0.12927844f, -0.03666363f, -0.06403351f, 0.05768010f, 0.00952815f, -0.09332649f, 0.05477304f, 
    0.03975001f, -0.10856598f, -0.04304324f, -0.09309942f, 0.09282543f, 0.13161643f, -0.06793334f, -0.02927897f, 
    0.13590221f, -0.09272707f, 0.14644726f, -0.05010413f, -0.06814519f, -0.04749667f, 0.11182415f, 0.11111353f, 
    0.04425248f, 0.00179902f, 0.06563932f, 0.17449321f, 0.03542160f, -0.02530105f, 0.01927251f, -0.00047005f, 
    0.02605211f, 0.06650922f, -0.00485814f, -0.05704697f, 0.18936761f, 0.07451659f, 0.23491429f, 0.23803918f, 
    0.07581098f, -0.05655595f, 0.16399862f, 0.04712665f, 0.05889993f, 0.08777445f, 0.07788090f, 0.01779169f, 
    0.06132852f, 0.25389633f, -0.30144694f, 0.14379053f, 0.04807759f, -0.03970499f, 0.08526205f, 0.24938926f, 
    -0.04608484f, 0.05644981f, 0.16740002f, 0.01917074f, -0.22616714f, 0.01362514f, 0.07993691f, 0.16289313f, 
    -0.06098703f, 0.16533898f, -0.00421343f, 0.03811100f, 0.10421908f, 0.14870271f, 0.08716393f, 0.05545148f, 
    0.11731157f, 0.01865170f, 0.00963572f, 0.14561358f, 0.06592117f, -0.05201544f, 0.01641419f, 0.14999416f, 
    0.08468405f, 0.04704558f, 0.05283283f, 0.04915907f, -0.05524805f, -0.04292256f, -0.06347253f, -0.13329203f, 
    0.12251634f, 0.12022743f, 0.09563745f, -0.06307706f, 0.01459739f, -0.07430782f, 0.11999827f, 0.02655877f, 
    -0.25088441f, 0.03300077f, 0.04781198f, -0.08425091f, 0.19266397f, 0.18872468f, 0.12035198f, -0.02818221f, 
    0.08574463f, 0.06744067f, 0.16486719f, -0.06668065f, 0.15302832f, -0.09012349f, -0.08176408f, -0.03893637f, 
    0.00010919f, 0.06411926f, 0.07900052f, -0.04197498f, 0.17060129f, -0.01386168f, -0.20106086f, 0.05910025f, 
    -0.09367374f, -0.03556820f, -0.01926913f, -0.12872383f, 0.01050600f, 0.09868854f, -0.00277202f, 0.07684554f, 
    0.09723845f, -0.02372804f, 0.21583839f, -0.01341565f, -0.09866961f, 0.35780114f, -0.05745607f, 0.02371267f, 
    -0.02436069f, 0.03701052f, 0.07106493f, 0.05538209f, 0.04007586f, 0.11209337f, 0.04560404f, -0.10535772f, 
    -0.05228135f, -0.08056260f, 0.05999308f, 0.06615259f, 0.12761879f, 0.02688499f, -0.08654026f, 0.02396837f, 
    -0.04809566f, 0.03335651f, -0.07597380f, -0.07541593f, 0.09234276f, 0.09938941f, -0.00615125f, 0.01944274f, 
    -0.07690737f, -0.04490747f, 0.00412807f, -0.02699957f, 0.01117876f, -0.11558676f, 0.07701397f, 0.11540020f, 
    -0.07581925f, 0.08645549f, 0.06098645f, 0.00196130f, 0.00625344f, 0.16953355f, -0.08661712f, -0.05948756f, 
    -0.02175980f, -0.21253955f, 0.15191273f, -0.12785831f, -0.20180246f, 0.15491846f, -0.13319913f, 0.10300645f, 
    0.02638791f, 0.01820074f, -0.26855761f, -0.26710603f, 0.00370353f, 0.15745027f, 0.13447766f, 0.07839168f, 
    -0.03952148f, -0.03897315f, 0.01591240f, -0.02326872f, -0.04492772f, 0.03734122f, -0.02149314f, -0.02965690f, 
    0.00223601f, 0.00162668f, -0.00432055f, -0.02207925f, 0.02737800f, -0.04442449f, -0.03480749f, -0.02464498f, 
    -0.02174803f, 0.05066768f, 0.02659893f, -0.03325929f, 0.00825936f, -0.02600692f, 0.02317517f, -0.04136283f, 
    -0.00358074f, 0.03192320f, -0.02836822f, -0.01912750f, 0.00126691f, -0.03808659f, 0.03213896f, -0.00340169f, 
    0.04148135f, -0.03375383f, -0.02509539f, 0.05065970f, 0.04454352f, -0.00108332f, 0.00374856f, -0.00131673f, 
    -0.00311416f, 0.03389652f, -0.03729791f, -0.03875013f, 0.01390879f, 0.03930108f, -0.01179639f, 0.01105411f, 
    0.03462690f, -0.04730655f, -0.03855712f, 0.04321449f, 0.03548349f, -0.01464310f, 0.04971980f, 0.02200561f, 
    -0.02923997f, -0.01326647f, -0.02895172f, 0.01629852f, 0.00428866f, -0.02790027f, -0.02470411f, -0.05094711f, 
    0.01764785f, 0.03849697f, 0.02149031f, 0.01872555f, -0.01740270f, -0.03676274f, -0.04760578f, 0.00973590f, 
    0.00088845f, 0.04850328f, 0.00209740f, 0.04483521f, -0.01036025f, -0.02532482f, -0.03126048f, -0.04312826f, 
    -0.04028345f, 0.01152745f, -0.03884245f, 0.03683856f, 0.04544926f, -0.01123662f, -0.04347007f, 0.04029106f, 
    -0.03923098f, -0.01262461f, -0.03456152f, -0.00483395f, 0.04597910f, -0.01629227f, -0.00632404f, -0.00844501f, 
    -0.00860733f, -0.04743166f, -0.01854951f, 0.00227747f, -0.00646349f, -0.03538920f, -0.00130448f, -0.03238383f, 
    0.00547774f, -0.04779618f, -0.05071961f, -0.03815839f, -0.04943569f, 0.02799270f, -0.00780857f, 0.01571183f, 
    -0.02143622f, 0.01584827f, -0.02900840f, -0.04951978f, -0.02498726f, -0.03991006f, 0.02399541f, 0.01101813f, 
    0.02680414f, -0.01749492f, -0.03166514f, -0.01400296f, -0.01596856f, -0.01541012f, -0.04092983f, 0.04949588f, 
    -0.00045770f, 0.02983136f, -0.01608579f, 0.03814919f, 0.00800845f, -0.00586943f, -0.02186795f, -0.01361122f, 
    0.03001622f, 0.02287218f, 0.01576611f, 0.02348317f, -0.03507926f, -0.01558155f, 0.02436899f, -0.02789706f, 
    0.01476834f, -0.00896453f, 0.03368808f, -0.04598970f, 0.00423225f, 0.02451855f, 0.04977525f, -0.02332869f, 
    -0.04286725f, 0.03847292f, -0.03867814f, -0.03534804f, -0.03892441f, 0.03377481f, 0.04575136f, -0.00116557f, 
    -0.02997402f, -0.01772362f, -0.00234516f, 0.03496436f, -0.00267471f, -0.01603203f, -0.00684134f, 0.04131228f, 
    -0.02652832f, -0.04044392f, 0.00296661f, 0.00313246f, 0.02466817f, 0.04163663f, 0.01788180f, 0.01985811f, 
    -0.01187113f, -0.00950029f, 0.05024874f, -0.03508162f, 0.01338699f, 0.01172207f, -0.00033855f, 0.00573870f, 
    -0.02318845f, -0.00105952f, 0.03033803f, -0.04791902f, 0.04993281f, 0.03367927f, -0.02238531f, 0.00743189f, 
    -0.01011567f, -0.00170760f, 0.02293446f, 0.01538896f, -0.01067904f, -0.03293439f, -0.03836594f, -0.00430730f, 
    -0.01453520f, -0.05081955f, 0.02166960f, -0.01870269f, 0.00814814f, 0.02473726f, -0.02818891f, -0.04810857f, 
    -0.04235453f, 0.00640139f, 0.04008358f, -0.00819653f, 0.02649269f, 0.03645483f, 0.02526964f, -0.01133318f, 
    -0.04081570f, -0.02235076f, -0.03096865f, 0.04513083f, -0.02517121f, 0.04630525f, -0.03646447f, 0.03160155f, 
    0.03911638f, -0.00923752f, 0.03760804f, -0.04539852f, -0.01669011f, 0.03465712f, -0.00098916f, -0.01046587f, 
    -0.00764519f, 0.05020456f, -0.04350476f, -0.02459628f, -0.05050336f, 0.00346948f, -0.04106693f, 0.01557900f, 
    -0.02137724f, 0.02687389f, -0.01453804f, 0.01581763f, 0.00325031f, 0.04291674f, 0.04161356f, 0.00083663f, 
    -0.02107530f, -0.00826373f, 0.00016750f, -0.04950949f, -0.00620718f, -0.03480895f, 0.03354691f, 0.02169208f, 
    0.04304741f, -0.01273786f, 0.02440323f, 0.03010892f, 0.04471959f, -0.01667596f, 0.02053998f, -0.02233398f, 
    0.04158139f, 0.00185753f, -0.04814774f, -0.00584629f, -0.04047322f, 0.05071115f, -0.01009214f, 0.01799995f, 
    0.02356124f, -0.02068649f, -0.00261409f, 0.00461847f, -0.02754583f, -0.02467356f, -0.01101636f, -0.01136380f, 
    -0.04999802f, -0.04582502f, 0.04709581f, -0.01327573f, 0.02404113f, -0.00496624f, 0.02480721f, 0.01861165f, 
    0.05050717f, 0.00231834f, 0.00693976f, -0.04541082f, -0.05082879f, 0.00391801f, -0.03301698f, 0.00004247f, 
    0.02309559f, -0.01248991f, 0.02501631f, 0.04580339f, 0.00166234f, -0.03415129f, 0.01894271f, 0.02576354f, 
    -0.03673622f, 0.00266205f, 0.00634037f, -0.04347437f, 0.02402532f, -0.00032326f, -0.02039214f, -0.04845983f, 
    -0.04114874f, -0.01210500f, -0.03398821f, -0.00067766f, -0.02610186f, 0.04194028f, 0.04621546f, -0.04532422f, 
    -0.04242902f, -0.02860163f, -0.01263534f, -0.03739120f, -0.02064923f, -0.00697231f, -0.04007327f, 0.03025814f, 
    0.00757819f, -0.04110657f, -0.01392339f, -0.04352378f, 0.03176441f, -0.02606437f, -0.05010642f, -0.04183766f, 
    0.00430826f, -0.02103441f, -0.04958910f, 0.04697385f, -0.02936841f, 0.01042968f, 0.00066923f, 0.02305488f, 
    -0.03406911f, 0.00879354f, 0.04119063f, 0.04332774f, -0.03270183f, 0.04733778f, 0.04416177f, -0.02294038f, 
    -0.03615933f, -0.04364116f, -0.05047488f, 0.02634971f, 0.03201949f, -0.03585188f, -0.01195013f, -0.04928315f, 
    -0.02099161f, -0.01995786f, 0.00556228f, 0.01321382f, 0.04429738f, -0.02034957f, 0.04758434f, -0.01347501f, 
    -0.01526363f, 0.01557454f, -0.05031006f, 0.03683509f, -0.00489271f, -0.04312208f, 0.03575451f, -0.02541720f, 
    0.02962519f, -0.02280445f, -0.02061062f, -0.02403432f, -0.01575313f, 0.01264284f, 0.01644733f, -0.02236816f, 
    -0.02356143f, 0.00579184f, 0.00257137f, 0.04342297f, 0.02078611f, -0.02670567f, 0.02897156f, -0.04082993f, 
    -0.05745763f, -0.05733015f, -0.04717306f, 0.04561678f, -0.01183737f, 0.02416495f, -0.03187839f, -0.03811049f, 
    -0.03846790f, -0.01454007f, -0.01747766f, -0.01908029f, -0.00060653f, -0.03721156f, -0.01483300f, -0.00682336f, 
    0.00389127f, 0.01580814f, -0.03176173f, -0.01136710f, 0.03394771f, -0.03550451f, 0.02111367f, -0.00052505f, 
    -0.01518794f, 0.01255745f, -0.01675289f, 0.00776135f, 0.01640754f, 0.01028671f, -0.01208352f, 0.00380344f, 
    0.03620434f, -0.05057432f, -0.05075955f, -0.05312938f, 0.01280883f, 0.03071208f, 0.03447291f, 0.04501614f, 
    -0.03344757f, -0.03157252f, 0.00227766f, -0.05182428f, -0.00886864f, 0.00024933f, 0.03460872f, 0.03453505f, 
    -0.02498159f, -0.00091607f, 0.02225959f, 0.02255711f, 0.00560505f, -0.00169823f, 0.02905014f, 0.00816161f, 
    -0.00492092f, -0.02000402f, 0.02800176f, 0.03257692f, -0.00904702f, 0.02731508f, 0.00650355f, -0.00727633f, 
    -0.02961923f, 0.04263969f, -0.04118161f, 0.04195092f, 0.00958775f, -0.01182568f, -0.01056021f, 0.02872326f, 
    -0.03888502f, 0.01255985f, -0.00291460f, -0.03349371f, -0.03634869f, 0.03808860f, -0.03506673f, -0.02907339f, 
    0.03373400f, 0.00849188f, -0.02090393f, -0.00833783f, -0.00009967f, -0.02058747f, -0.03579893f, 0.00006228f, 
    -0.05293315f, -0.04120861f, 0.03387132f, 0.02112377f, -0.04704705f, -0.01846538f, -0.03616037f, -0.04956445f, 
    -0.02188327f, -0.01957987f, 0.00858843f, -0.00620753f, -0.00962146f, -0.04180406f, -0.04442640f, -0.05220287f, 
    0.03604033f, -0.04194812f, -0.05516979f, 0.02680779f, 0.00224213f, 0.03319579f, 0.04740283f, 0.01524871f, 
    -0.04199260f, 0.04159278f, -0.02851380f, -0.05321717f, 0.04098229f, -0.04628323f, -0.04762291f, -0.03239252f, 
    -0.03367678f, 0.03094430f, 0.02866311f, 0.01070597f, -0.01815645f, -0.00953381f, -0.00305002f, -0.05695256f, 
    -0.05820143f, 0.01298913f, -0.02606658f, -0.02060235f, 0.03553677f, 0.02642762f, -0.04124933f, -0.01846331f, 
    0.03636309f, -0.02243039f, -0.05066722f, -0.00432272f, -0.01067722f, -0.02663771f, -0.01077364f, -0.00873066f, 
    -0.00830482f, 0.03290416f, -0.00143864f, 0.02652915f, 0.02215158f, -0.04101811f, 0.02091323f, 0.03973692f, 
    -0.04609527f, -0.03107296f, -0.03877961f, 0.04338385f, -0.01924986f, -0.02062467f, 0.01952050f, 0.02556055f, 
    -0.00961784f, 0.02889287f, -0.01709558f, -0.04304022f, 0.00771042f, -0.05497107f, -0.01604134f, 0.00603784f, 
    0.00812773f, 0.00063136f, 0.00981501f, -0.01129095f, 0.01975119f, -0.02563244f, 0.00837379f, -0.01188728f, 
    0.03833206f, 0.00284932f, -0.02502644f, 0.01543653f, -0.01595744f, 0.01202470f, 0.00740138f, -0.01486700f, 
    -0.02644085f, -0.00390023f, -0.03702784f, -0.01040033f, -0.05431620f, -0.05586917f, 0.02872303f, 0.01406836f, 
    -0.03007979f, -0.00590844f, -0.02177718f, -0.04369506f, 0.02149303f, -0.02560791f, 0.00918737f, -0.02921808f, 
    0.01730345f, -0.05257406f, 0.00414234f, -0.01289413f, -0.02645023f, 0.03011888f, -0.01684322f, -0.04177647f, 
    -0.01985296f, 0.04597636f, 0.01891484f, -0.00318254f, -0.01200707f, -0.02229882f, -0.01092319f, -0.03871829f, 
    -0.03138612f, 0.00309937f, -0.04810125f, -0.04163532f, -0.05501485f, 0.03468671f, -0.03852613f, 0.03931427f, 
    0.00361858f, 0.00708194f, 0.01276013f, -0.03290250f, 0.00678867f, -0.01373284f, -0.04278647f, 0.01507034f, 
    0.02527615f, 0.00576998f, -0.03138806f, 0.00566861f, -0.03755749f, -0.04290372f, -0.02805313f, -0.01822001f, 
    -0.03163224f, 0.00222410f, -0.04621282f, -0.00103219f, -0.00068862f, -0.05177553f, 0.02277957f, -0.03592817f, 
    -0.02920657f, 0.02303967f, 0.00648005f, -0.00704948f, 0.01835100f, -0.03219225f, 0.00340729f, -0.03806818f, 
    -0.05566854f, 0.03552407f, 0.03284018f, -0.00045902f, -0.00621698f, 0.01593335f, -0.05594611f, -0.01002032f, 
    -0.01909900f, 0.01271967f, 0.01294175f, -0.01469256f, -0.01834702f, 0.02801272f, 0.04143260f, 0.03399305f, 
    -0.01313788f, 0.04462903f, -0.04805306f, 0.02156959f, -0.02114862f, -0.02734689f, -0.05596159f, -0.05086302f, 
    -0.01060712f, 0.02562080f, 0.00966134f, -0.01253361f, -0.03097253f, 0.01064495f, -0.03763011f, 0.02788113f, 
    -0.00281020f, -0.05602745f, 0.00112415f, -0.04349431f, -0.00212626f, -0.00016119f, -0.02406565f, 0.04510494f, 
    0.04226860f, -0.01059832f, 0.03127803f, 0.03765882f, 0.02816752f, -0.04577745f, 0.01380689f, 0.01643283f, 
    0.03517028f, -0.04479127f, -0.01673127f, -0.02271738f, -0.05714815f, -0.02612241f, -0.04341923f, -0.00208492f, 
    -0.04203163f, -0.03452151f, 0.00669387f, 0.01303713f, 0.00951061f, 0.00904678f, -0.03942355f, 0.00785721f, 
    0.02053525f, 0.03105553f, -0.00938376f, 0.03978494f, -0.01207513f, 0.04283759f, 0.02561609f, 0.01865354f, 
    -0.04735443f, 0.00065711f, -0.02549795f, 0.02854188f, -0.04348103f, -0.05099432f, -0.02954094f, 0.00602501f, 
    -0.02871623f, -0.01461113f, 0.01608012f, 0.01916214f, 0.01502340f, 0.01372524f, -0.03064649f, -0.00851126f, 
    0.01393232f, -0.04813712f, -0.03512505f, -0.00441238f, 0.02340272f, -0.02674182f, -0.02473224f, 0.03516648f, 
    0.00267938f, 0.03240692f, -0.04748827f, -0.03352051f, -0.04511742f, 0.01208088f, 0.01678907f, -0.02492701f, 
    -0.02112608f, -0.02428393f, -0.02192807f, 0.00936027f, 0.04779545f, -0.01118325f, -0.02914891f, 0.02942177f, 
    0.03878390f, -0.03872456f, 0.01785843f, -0.04186476f, 0.03734570f, -0.00280747f, -0.04475237f, -0.05561484f, 
    0.02675105f, -0.00550625f, 0.03056266f, 0.01951812f, -0.02630478f, 0.04447608f, 0.04687225f, -0.03635333f, 
    0.03939720f, -0.04932513f, -0.05547246f, -0.05501967f, -0.02007696f, -0.01062154f, 0.02096101f, -0.00439786f, 
    -0.04548996f, -0.03451867f, 0.03705820f, -0.00846984f, 0.01684030f, 0.03110635f, 0.01890059f, -0.02286819f, 
    -0.03903214f, -0.00196207f, -0.05124698f, 0.00009029f, -0.04890669f, 0.00354060f, -0.03203047f, -0.04674415f, 
    0.00082688f, 0.01152121f, -0.00688115f, -0.01783805f, 0.02720031f, 0.04411722f, -0.01203082f, -0.04266708f, 
    0.00516912f, 0.04662491f, 0.02182127f, -0.00451262f, 0.03619302f, -0.01050035f, 0.04209509f, -0.02813717f, 
    -0.05441549f, 0.03981333f, -0.00485461f, 0.00608770f, 0.00387888f, -0.01943122f, -0.03302244f, -0.03303083f, 
    0.04172869f, 0.03382596f, 0.03275046f, -0.04568321f, -0.00284000f, -0.02079620f, 0.02644978f, 0.01728085f, 
    -0.04881360f, -0.01744373f, -0.05276404f, 0.02472767f, 0.03157687f, 0.01577193f, 0.00981972f, -0.03092981f, 
    -0.04976312f, -0.03712607f, 0.01798734f, -0.01887386f, 0.02458828f, -0.05184889f, 0.01733777f, -0.04037109f, 
    0.02192176f, -0.00819773f, 0.02069577f, 0.01698145f, -0.04030963f, -0.01111577f, -0.02890672f, -0.00639103f, 
    0.04281956f, 0.03467688f, -0.05414046f, 0.01099704f, -0.05628484f, -0.01932428f, -0.04801114f, 0.02832135f, 
    0.02004201f, 0.00966892f, -0.00577373f, 0.01162129f, 0.00158036f, 0.02838134f, 0.02222892f, -0.04354750f, 
    -0.02984734f, -0.03522377f, 0.01115483f, -0.00209072f, 0.04413463f, -0.00405537f, -0.01577784f, -0.03180308f, 
    -0.01492065f, 0.01652025f, -0.04408098f, -0.03964005f, -0.04919640f, 0.02675503f, -0.04265672f, -0.05329361f, 
    0.00925507f, 0.02061243f, 0.04749744f, -0.03751104f, -0.01128075f, -0.04341912f, 0.00565041f, -0.00408609f, 
    0.01642774f, -0.00798576f, -0.05030309f, 0.00051147f, -0.00542236f, -0.01424686f, 0.00988814f, 0.00183815f, 
    -0.04904468f, 0.03585150f, 0.02655897f, -0.02884648f, -0.03569136f, 0.03696863f, 0.01073258f, 0.01114065f, 
    -0.03946817f, 0.03590375f, 0.01450426f, -0.05162680f, 0.02359062f, -0.04440172f, 0.02969430f, -0.04856737f, 
    0.01265687f, -0.01616623f, -0.05473634f, 0.03892050f, -0.00112288f, -0.01907176f, -0.02194201f, -0.01582290f, 
    -0.00552476f, 0.01826398f, -0.00857823f, -0.02785970f, -0.03608096f, 0.00604754f, -0.00027224f, -0.01013529f, 
    -0.02559461f, 0.01007356f, 0.03173663f, 0.04045722f, -0.00092840f, -0.02051266f, -0.04526616f, -0.05146099f, 
    0.03900960f, -0.02081124f, -0.05721936f, -0.01526218f, 0.00510453f, 0.01803196f, 0.00358023f, -0.04286092f, 
    -0.01050951f, -0.01055938f, -0.02912428f, 0.03884751f, 0.02414045f, 0.03020640f, -0.00737231f, -0.01455857f, 
    -0.04573225f, 0.01722843f, 0.00772276f, 0.01793856f, -0.03991734f, 0.04432979f, 0.03042060f, -0.02078961f, 
    -0.04493558f, -0.04161578f, 0.04118762f, -0.00932561f, -0.03798526f, 0.01358783f, -0.05010255f, -0.04493161f, 
    -0.01644081f, 0.04468244f, -0.02475786f, -0.01386555f, -0.00195895f, -0.02026715f, -0.00882588f, 0.01512314f, 
    -0.02735497f, 0.02810519f, 0.01737955f, -0.02077547f, -0.00905638f, -0.01675219f, -0.01472700f, 0.04126038f, 
    0.00046612f, 0.00306251f, -0.03165853f, 0.02090379f, 0.02371396f, -0.04237542f, 0.03377991f, -0.03677261f, 
    -0.00667088f, 0.02730429f, 0.00870152f, 0.04968401f, -0.05387053f, 0.00356824f, 0.03827777f, 0.00683428f, 
    -0.03452451f, -0.04148952f, 0.01174982f, -0.05158955f, -0.04329747f, 0.01946326f, -0.01581562f, 0.01319924f, 
    -0.03536375f, -0.05004294f, -0.04511897f, 0.01334581f, -0.03308506f, -0.02546888f, 0.02565230f, -0.00768103f, 
    -0.01758708f, -0.01725602f, -0.01779193f, 0.01276854f, 0.03582459f, 0.02762257f, -0.01625803f, -0.00397123f, 
    -0.00575134f, -0.04656798f, 0.00447470f, 0.04514663f, -0.00484797f, -0.00184163f, -0.04945389f, 0.02651324f, 
    0.04587894f, 0.03974497f, 0.03454096f, 0.02584301f, -0.03240557f, 0.05115625f, 0.02725470f, -0.01306389f, 
    -0.06053283f, -0.03670466f, 0.03388003f, 0.01322678f, 0.01254595f, -0.00293011f, -0.04185123f, -0.01546609f, 
    0.00646725f, 0.02981054f, -0.00294863f, 0.03366483f, 0.00046415f, 0.02198799f, -0.02350042f, -0.00688329f, 
    -0.04391472f, 0.04139234f, -0.03812799f, 0.01309967f, -0.04450122f, 0.00036392f, -0.01998691f, 0.01188375f, 
    -0.00682343f, 0.01917777f, -0.04602280f, 0.04518389f, -0.01055057f, -0.03825927f, 0.03296768f, -0.02702007f, 
    -0.01705832f, -0.01156082f, -0.04122385f, 0.03509532f, 0.02636667f, -0.00011526f, 0.02120090f, 0.01923998f, 
    -0.04780550f, 0.02334749f, 0.02672970f, 0.00225098f, -0.04081870f, 0.03311849f, 0.01095070f, -0.03490643f, 
    0.04317050f, 0.00790061f, 0.01919395f, -0.04793576f, 0.00012681f, -0.03581073f, -0.01510162f, 0.00984224f, 
    0.03870183f, -0.02877129f, 0.00981091f, -0.04076109f, 0.01460631f, -0.02390523f, 0.04388104f, -0.03828741f, 
    -0.01715653f, -0.03990185f, -0.05166340f, 0.00079371f, -0.03640603f, -0.02506255f, 0.03754868f, -0.00071265f, 
    -0.00113465f, 0.01746178f, -0.01144027f, 0.02788406f, 0.03649895f, 0.00355291f, 0.01789186f, -0.04286183f, 
    -0.03409115f, -0.00988387f, -0.01604399f, -0.03725547f, -0.02472182f, 0.04167182f, 0.01326431f, -0.03118472f, 
    -0.03741414f, 0.03287611f, 0.00885059f, 0.03840155f, -0.00495699f, 0.03538274f, -0.04334728f, -0.00528887f, 
    0.03756074f, 0.00682575f, -0.03901323f, -0.00536891f, 0.03229235f, 0.01810548f, -0.02335901f, -0.02891272f, 
    0.21625894f, 0.00405315f, -0.10198826f, 0.08425016f, 0.11597310f, 0.09832466f, 0.01878395f, 0.03043750f, 
    -0.02164662f, -0.06125148f, -0.06517667f, 0.02750290f, 0.10620870f, 0.20412794f, 0.06744612f, -0.13156445f, 
    0.00534071f, 0.02341571f, 0.12329069f, -0.13925257f, -0.04905265f, 0.20782186f, -0.00317829f, -0.05243075f, 
    -0.01215473f, -0.10618762f, 0.10692625f, -0.06259092f, 0.17497554f, 0.12642887f, -0.05083344f, -0.05671540f, 
    -0.10067409f, 0.03418770f, -0.20837869f, 0.00142532f, -0.05361424f, -0.01386548f, -0.18320832f, 0.05518357f, 
    0.13430871f, 0.15434924f, 0.10254100f, -0.01679855f, 0.04902951f, -0.04068661f, -0.07558980f, -0.10391533f, 
    0.05412665f, 0.31347454f, 0.07670959f, 0.22605398f, -0.00108594f, -0.12536232f, -0.04248430f, -0.05746863f, 
    -0.08392611f, -0.03980020f, 0.04667062f, 0.02569001f, -0.22488637f, 0.10391115f, 0.08453706f, 0.01453069f, 
    -0.09224361f, 0.00826309f, -0.10391869f, -0.08576455f, 0.03906094f, 0.02858274f, 0.05330966f, 0.05164744f, 
    0.05492698f, -0.14612994f, 0.34464562f, -0.12266680f, 0.13237222f, -0.03957092f, 0.01063318f, -0.03212959f, 
    0.01736556f, -0.17560394f, 0.09880974f, -0.00030417f, 0.21122293f, -0.02594072f, -0.10644972f, 0.02241057f, 
    -0.13321255f, -0.09367156f, 0.03952565f, 0.00672616f, 0.15454121f, 0.05649267f, -0.02594210f, -0.00501062f, 
    -0.55015528f, 0.22963512f, 0.01621367f, 0.05850391f, -0.08083230f, -0.10258928f, 0.11702417f, 0.10051643f, 
    0.18993628f, 0.09876203f, 0.02609531f, 0.00963701f, 0.25297692f, 0.28439537f, 0.12729813f, 0.12979563f, 
    0.01669482f, -0.10927868f, -0.02808209f, -0.00505537f, -0.09179888f, -0.03722855f, 0.04163096f, -0.10433644f, 
    -0.38003495f, -0.01371917f, -0.17155515f, -0.06181977f, -0.01300579f, 0.07184894f, 0.06719420f, -0.02376710f, 
    -0.01441958f, 0.00316293f, 0.13567269f, 0.13887201f, -0.19263081f, -0.08338447f, 0.08463047f, 0.13674714f, 
    0.15680395f, 0.03266646f, -0.27236021f, 0.21010901f, -0.12644008f, -0.02023221f, -0.01636479f, -0.09211844f, 
    0.37654978f, -0.00535568f, 0.10665237f, -0.15159631f, -0.06733202f, 0.10408454f, -0.00247442f, 0.02486952f, 
    0.03411579f, 0.01046552f, -0.03316095f, -0.19209948f, 0.05933175f, 0.16901436f, 0.22934218f, 0.10392179f, 
    -0.09807608f, -0.17883147f, -0.08849721f, -0.17330922f, 0.03294197f, -0.06757124f, 0.03337703f, 0.12911175f, 
    -0.02951639f, -0.11118302f, 0.00416344f, 0.34317213f, -0.01430879f, -0.01120044f, -0.07852595f, -0.03057723f, 
    0.01432731f, 0.00016996f, 0.00039467f, -0.05362593f, 0.29595891f, -0.00196593f, 0.07456117f, -0.15104860f, 
    0.03344570f, -0.01906559f, 0.03853097f, -0.01969093f, -0.01462619f, 0.12935337f, 0.03353356f, 0.10138623f, 
    -0.05878126f, 0.00782567f, 0.13029259f, 0.16410248f, -0.23168206f, -0.11160164f, -0.01904500f, -0.06970230f, 
    -0.02146175f, -0.03680961f, -0.06573208f, -0.10526907f, -0.10041930f, 0.22790958f, 0.19631752f, 0.18915324f, 
    0.03361998f, 0.07216622f, -0.18098488f, 0.06826068f, -0.02471261f, 0.03113476f, 0.07057409f, 0.02562118f, 
    -0.09239028f, -0.07036762f, -0.12459350f, -0.21541558f, -0.21047328f, -0.05492651f, 0.15372628f, 0.05031019f, 
    -0.07706639f, -0.03344847f, -0.01120599f, -0.01619389f, -0.00523175f, -0.06703144f, 0.01043329f, 0.06044838f, 
    0.00346131f, 0.03765889f, -0.01866387f, 0.18173742f, -0.04068480f, -0.08695459f, -0.07265637f, 0.01047431f, 
    -0.19726376f, -0.05875950f, 0.11316229f, -0.09905610f, 0.05307969f, 0.10646649f, -0.02039400f, -0.06644978f, 
    0.05017514f, 0.04138875f, 0.04420790f, 0.17214441f, 0.15133163f, 0.09910392f, 0.12187399f, -0.06872950f, 
    0.03563615f, -0.09456199f, -0.03122915f, -0.12328105f, 0.17458607f, 0.06967915f, 0.03054344f, 0.20404398f, 
    -0.07078577f, 0.04814402f, 0.12236344f, 0.09814805f, 0.06013045f, 0.00182465f, -0.01580904f, 0.00294368f, 
    -0.13587476f, 0.27621129f, -0.20019662f, 0.02039334f, 0.04103274f, 0.17209962f, 0.06361867f, -0.00538890f, 
    -0.01227263f, 0.05846258f, -0.08068433f, 0.15201308f, 0.01339026f, 0.04417896f, 0.08291817f, 0.14801633f, 
    0.08563684f, 0.12913898f, 0.18035375f, 0.01646533f, -0.07105061f, 0.06465387f, 0.02667446f, -0.09079694f, 
    0.03091638f, -0.08764732f, -0.06181548f, -0.06311310f, -0.07895794f, 0.14975010f, 0.14529563f, 0.11808065f, 
    0.00742078f, 0.01013843f, -0.09100949f, 0.03737356f, -0.01816458f, -0.08384072f, -0.00525277f, 0.01230007f, 
    0.02373775f, -0.05251396f, 0.00579513f, -0.06543177f, -0.02379531f, -0.06304754f, -0.00658207f, 0.00838344f, 
    -0.01024213f, 0.11743584f, 0.07354144f, 0.01241104f, -0.13010930f, -0.24975525f, 0.05356364f, 0.23077834f, 
    0.05561881f, 0.02831428f, -0.17877209f, -0.03089696f, -0.02450629f, -0.03415592f, 0.05434034f, 0.05847847f, 
    -0.08316459f, -0.00418171f, 0.16942807f, 0.16652441f, -0.05985643f, -0.06100262f, 0.00709287f, 0.13013478f, 
    0.08812463f, -0.00515464f, -0.01162949f, -0.05379479f, 0.05912444f, -0.20695592f, -0.14046513f, 0.09404428f, 
    0.15483485f, -0.00326641f, 0.01448518f, -0.12218370f, 0.14629160f, 0.14903164f, 0.16262490f, 0.29441705f, 
    0.11571378f, -0.09802347f, -0.01611143f, 0.17292328f, 0.12366169f, 0.02161374f, -0.01856258f, 0.05727135f, 
    -0.11893223f, -0.08994147f, -0.19798346f, -0.04893163f, 0.12804613f, -0.13393195f, 0.17278613f, -0.01292546f, 
    0.11253913f, 0.05168292f, 0.14902820f, 0.02201445f, -0.08053093f, -0.08970529f, -0.05173578f, -0.04619314f, 
    -0.03039555f, 0.02618448f, -0.00938027f, 0.00966484f, -0.01866142f, -0.00770020f, -0.02551657f, -0.03727920f, 
    -0.01030778f, -0.03540315f, 0.00345989f, 0.03653976f, -0.03683027f, -0.05840884f, -0.00744797f, -0.05216519f, 
    -0.03214891f, 0.04548480f, 0.01556550f, -0.04005871f, -0.01735330f, 0.04157918f, -0.03319586f, 0.03546110f, 
    -0.03306082f, 0.01204262f, -0.03655186f, 0.00815909f, 0.01090509f, 0.01726101f, -0.00510260f, 0.03521045f, 
    -0.05149724f, 0.02003951f, 0.03614869f, -0.01266245f, -0.01864373f, -0.02911420f, 0.02991994f, -0.02221940f, 
    -0.01478776f, 0.02155648f, 0.00127374f, 0.02230301f, -0.02452024f, -0.01290211f, 0.03268450f, -0.01817894f, 
    0.04283406f, -0.03031113f, 0.02992113f, -0.04943429f, -0.02246235f, -0.02970743f, 0.04207219f, 0.00284715f, 
    0.00149277f, 0.03049049f, -0.00622537f, -0.03602577f, -0.04510001f, -0.03467177f, 0.03670412f, -0.01695524f, 
    0.03460952f, 0.02172861f, -0.00295090f, -0.01076774f, 0.04233789f, -0.04080881f, 0.02853930f, -0.03113611f, 
    0.01761623f, -0.05526611f, -0.03180081f, -0.01492043f, 0.03928306f, -0.02993565f, -0.03624949f, -0.01115743f, 
    -0.03947893f, -0.00566811f, 0.02178290f, 0.03408642f, 0.02625138f, -0.02051403f, -0.01921138f, -0.02337239f, 
    -0.00420346f, -0.05497987f, -0.03154017f, 0.04510763f, 0.04404232f, -0.01358777f, -0.02825168f, 0.02036832f, 
    0.01097743f, -0.04355733f, -0.03667678f, 0.00780585f, 0.00388362f, -0.05515159f, -0.02985277f, 0.00715944f, 
    0.03081277f, 0.01491776f, 0.03614093f, 0.00311659f, 0.01770031f, -0.00677849f, -0.02349565f, 0.02014682f, 
    0.04768925f, -0.02021950f, -0.03661520f, 0.01757158f, -0.02334529f, -0.02984574f, 0.03923301f, 0.02583319f, 
    -0.04772732f, 0.01409814f, -0.02304198f, 0.02988688f, 0.00993020f, -0.03020074f, -0.00842842f, -0.03916929f, 
    0.00315889f, -0.03109340f, -0.05183783f, -0.01942337f, -0.02613777f, -0.02308391f, -0.01568302f, -0.02514499f, 
    -0.01060734f, 0.02589002f, 0.01120329f, 0.00633399f, -0.03923187f, -0.00879847f, 0.03487328f, 0.00612907f, 
    0.04037117f, -0.04690641f, 0.02058274f, -0.00836403f, -0.02403985f, -0.03031212f, -0.02938435f, 0.01053974f, 
    -0.01758679f, 0.04021205f, -0.03630117f, -0.04136944f, -0.02023459f, 0.00909341f, 0.02499235f, 0.01207166f, 
    0.03825086f, 0.01641229f, -0.04216897f, -0.00879130f, -0.01886184f, -0.02870810f, 0.01248556f, 0.03715814f, 
    -0.04709113f, 0.03367365f, -0.05274564f, 0.04008172f, 0.01791574f, -0.04113686f, -0.05642117f, 0.01329867f, 
    -0.04366798f, -0.01728575f, 0.02310394f, -0.03451302f, 0.01903914f, -0.02617472f, 0.03619033f, 0.00475813f, 
    0.03320804f, -0.04020220f, -0.05378148f, -0.05641937f, -0.04683503f, -0.00754147f, -0.05214967f, -0.00388239f, 
    -0.03472566f, -0.04944758f, -0.01034075f, 0.00749946f, -0.04731742f, -0.02001468f, -0.00740822f, -0.05025436f, 
    0.01382011f, -0.02024361f, -0.00623029f, -0.05099683f, -0.03765937f, -0.05049804f, 0.03171795f, 0.04312409f, 
    0.02129936f, 0.00382833f, -0.04713348f, -0.02577289f, -0.04289701f, 0.03863511f, -0.02134991f, 0.02943510f, 
    -0.01908648f, -0.03783055f, -0.04467640f, 0.03870126f, -0.02210074f, -0.00196497f, 0.04328579f, 0.01841209f, 
    -0.00711024f, 0.01440040f, 0.02791368f, -0.00965205f, -0.03344566f, -0.02164069f, -0.05647383f, -0.02541864f, 
    0.01908644f, 0.01122836f, 0.03098950f, 0.02483764f, 0.04405566f, -0.03974686f, -0.01687874f, -0.05046104f, 
    -0.01461498f, 0.00271423f, -0.05428945f, 0.03474780f, -0.02548319f, -0.02086186f, -0.02911458f, -0.01087439f, 
    -0.02226343f, -0.04488563f, -0.00532301f, -0.02559895f, -0.01769999f, 0.01125325f, 0.03039232f, -0.04197099f, 
    0.03617617f, -0.01413383f, -0.02166253f, 0.01551980f, -0.03628144f, -0.01610869f, -0.01763679f, 0.00537987f, 
    0.03845402f, 0.03115942f, -0.01699071f, 0.03013641f, -0.03032313f, 0.00005290f, 0.02983546f, 0.02311742f, 
    -0.01763141f, 0.03585526f, -0.04913353f, -0.03608153f, 0.03443926f, 0.03505987f, -0.00713044f, 0.01210372f, 
    -0.02383756f, -0.04579373f, -0.04157833f, -0.02989062f, 0.03264441f, 0.00647855f, -0.02107851f, 0.03201031f, 
    -0.04516763f, 0.03195480f, 0.01701991f, -0.01988175f, 0.04739211f, -0.01905219f, -0.02451587f, -0.03253119f, 
    0.00987078f, 0.00600685f, -0.03209060f, 0.03255914f, 0.00302830f, -0.01301530f, 0.02557317f, -0.01744120f, 
    0.00494365f, -0.00605112f, 0.01144966f, 0.01621108f, 0.03000163f, -0.05080679f, 0.02731517f, 0.01688352f, 
    -0.03075667f, 0.03063920f, 0.01698321f, -0.02731119f, 0.04235145f, -0.04116428f, 0.02252970f, -0.00563141f, 
    -0.04935574f, -0.05122141f, 0.03884614f, -0.01373010f, -0.00590359f, 0.04105033f, -0.04247009f, 0.02843217f, 
    0.00050353f, -0.04359559f, -0.00758207f, -0.05790440f, 0.00839354f, -0.05100824f, -0.01890865f, 0.04424956f, 
    -0.02070175f, -0.05171499f, -0.03834949f, -0.02392053f, -0.03469501f, 0.02342106f, -0.03740450f, -0.05206058f, 
    0.00365223f, 0.03270947f, -0.00165971f, -0.04760526f, -0.01344672f, -0.00442799f, 0.01977706f, 0.00570311f, 
    -0.04673018f, -0.02397665f, 0.03211311f, -0.00111850f, -0.05245404f, 0.00548126f, -0.03997341f, 0.00055412f, 
    0.02430178f, -0.02928501f, -0.04522366f, 0.00093086f, -0.03080337f, 0.03003607f, 0.02618621f, 0.01585929f, 
    -0.01138772f, -0.02728700f, -0.03989112f, 0.02228514f, 0.00803729f, 0.02814478f, 0.03079930f, -0.00613895f, 
    -0.04893890f, 0.01820733f, 0.04383828f, 0.03651103f, 0.00931735f, 0.04155996f, 0.02864981f, -0.04763033f, 
    0.14630978f, -0.19566989f, -0.10681381f, -0.12066588f, 0.05586592f, 0.08315143f, -0.05467388f, 0.02924723f, 
    -0.01599163f, -0.00217071f, -0.06949116f, -0.06973500f, -0.11537672f, -0.12850979f, 0.04270919f, -0.16359150f, 
    -0.09529508f, -0.09091679f, 0.01484826f, -0.24013422f, -0.09719346f, 0.06706469f, 0.05634291f, 0.13939655f, 
    -0.05295528f, -0.09792563f, -0.04092567f, -0.25400773f, -0.01483263f, -0.01376261f, -0.08138715f, 0.18158433f, 
    -0.03726339f, -0.04638396f, -0.04473881f, -0.06901442f, -0.16290459f, 0.09512324f, -0.09255330f, -0.11802285f, 
    0.03407864f, 0.20409419f, -0.05798247f, -0.22358145f, 0.03082546f, -0.11595304f, -0.02368722f, -0.17528591f, 
    0.31997067f, 0.09880724f, 0.08344981f, 0.12085076f, -0.00044802f, -0.03234199f, 0.02564514f, -0.13037463f, 
    -0.09331389f, -0.04372980f, 0.05770795f, 0.02844902f, 0.01473829f, 0.03574215f, -0.03097072f, 0.12433159f, 
    0.09140193f, 0.04724456f, -0.09562970f, -0.11910804f, -0.06354770f, -0.07177788f, 0.03915263f, -0.07751677f, 
    0.05619499f, -0.03701006f, -0.00768845f, 0.06764151f, -0.07165982f, -0.05002275f, 0.04150267f, 0.06428166f, 
    -0.05370278f, -0.17531836f, -0.02238576f, 0.05747939f, -0.14499728f, -0.37562758f, -0.19390489f, -0.09853659f, 
    -0.21796897f, 0.16630714f, -0.12823926f, 0.01158394f, 0.06039525f, 0.07063067f, -0.04113080f, 0.04461693f, 
    -0.50282234f, -0.01488471f, 0.19339162f, -0.15328287f, -0.03066309f, -0.01859232f, -0.21935913f, -0.35832778f, 
    -0.00989507f, -0.02897933f, 0.02019172f, 0.17411955f, 0.33673361f, 0.18416111f, 0.04971324f, 0.09440280f, 
    0.13823740f, -0.12771490f, -0.05415124f, 0.07494260f, -0.03067952f, 0.03030805f, -0.03655675f, -0.01954057f, 
    -0.23840912f, 0.16815275f, -0.06949608f, -0.03162642f, -0.05657561f, 0.01661406f, -0.05874453f, 0.01751382f, 
    -0.05898912f, -0.00420655f, -0.15262663f, 0.01158637f, -0.11921941f, 0.04978202f, -0.08948506f, -0.13113160f, 
    0.16621462f, -0.07632136f, -0.13130978f, 0.04046119f, -0.23421155f, -0.10626557f, 0.04964356f, -0.10995906f, 
    -0.04025730f, -0.03942206f, -0.18301907f, -0.24701460f, -0.08349328f, -0.05731250f, -0.00241244f, -0.15769458f, 
    -0.16745049f, -0.14994159f, -0.00273066f, -0.15761252f, 0.20917751f, 0.01970988f, 0.03015940f, 0.12767087f, 
    0.07440934f, -0.01645051f, -0.04777841f, -0.02488696f, 0.03152759f, 0.00539240f, -0.01554067f, 0.07103235f, 
    -0.27748469f, -0.26385772f, -0.03745719f, 0.24731244f, -0.13659327f, 0.00468181f, 0.06380393f, -0.07387467f, 
    0.02915350f, 0.04243380f, -0.04037967f, -0.00309147f, -0.21690813f, 0.07208372f, 0.04784482f, -0.18428905f, 
    0.04622111f, -0.12417663f, -0.03546826f, 0.06365859f, 0.02491654f, -0.03209958f, 0.01477972f, 0.08974965f, 
    0.17459995f, 0.16954471f, 0.07413884f, 0.15494335f, -0.06038061f, -0.04004541f, -0.01055835f, 0.05783402f, 
    0.00336717f, -0.00242427f, -0.03018041f, -0.01050616f, 0.31588787f, 0.27358559f, 0.06033620f, 0.31787035f, 
    0.08585881f, -0.02155799f, -0.05847700f, -0.20389751f, -0.02800836f, 0.02021344f, 0.06523576f, 0.09454930f, 
    0.00191620f, 0.15856507f, 0.01270175f, -0.06434695f, -0.12874813f, -0.12170312f, -0.02333355f, -0.12250093f, 
    -0.07857712f, -0.01389283f, 0.02760435f, -0.08599816f, 0.11478392f, -0.08270256f, -0.16110481f, 0.11501195f, 
    0.13551743f, 0.07622025f, 0.07208212f, 0.05397797f, -0.02888712f, 0.05502594f, 0.02464891f, -0.00769664f, 
    0.39529520f, 0.04617861f, 0.06077230f, 0.20518339f, 0.18805255f, -0.01590352f, 0.04453423f, 0.10219751f, 
    0.07663240f, -0.02176312f, 0.00501248f, 0.14443196f, -0.03028433f, 0.14243035f, 0.18903466f, 0.07991637f, 
    0.04344890f, 0.08798946f, -0.01916530f, 0.08957738f, 0.07011820f, -0.02898450f, 0.01385844f, 0.25845191f, 
    -0.09245484f, 0.00279380f, 0.01369157f, -0.02167775f, 0.03085822f, -0.02875839f, -0.13274509f, 0.04799196f, 
    -0.04312570f, 0.16791350f, -0.06478738f, 0.13247825f, 0.12092455f, -0.10872608f, -0.14803512f, 0.12024295f, 
    0.06017313f, -0.01245437f, 0.00581118f, -0.08775040f, 0.01022803f, 0.03147363f, -0.02857353f, 0.12423480f, 
    0.02784231f, -0.06199990f, -0.15399383f, -0.03025930f, -0.02404661f, 0.05271113f, -0.06831364f, 0.02113369f, 
    0.05092394f, 0.05901398f, -0.07670685f, 0.12416074f, 0.11758086f, 0.24331562f, 0.05170494f, 0.22251464f, 
    -0.00468929f, 0.08244672f, -0.04379012f, 0.17351931f, -0.07067134f, 0.06880689f, -0.00405808f, -0.05624671f, 
    -0.09995492f, -0.05873918f, -0.00085965f, 0.01738723f, 0.01968579f, 0.06515303f, 0.00223918f, -0.15117963f, 
    -0.07339504f, 0.13903941f, 0.02248015f, -0.01559494f, 0.16281669f, -0.01813991f, 0.07722436f, 0.05531784f, 
    -0.06668932f, 0.06385750f, -0.06811643f, 0.01842751f, -0.00886730f, -0.09966146f, -0.02082614f, 0.10384350f, 
    0.12902057f, 0.23783235f, 0.06359106f, 0.19757572f, 0.04203321f, 0.11490517f, 0.15683950f, 0.25900510f, 
    0.04803317f, 0.04888274f, 0.04462208f, 0.03845101f, 0.19722602f, 0.06636795f, -0.01280941f, 0.20207882f, 
    0.06458581f, 0.10250755f, -0.01410254f, -0.09751636f, -0.04397336f, 0.01865554f, 0.05165002f, 0.12241905f, 
    0.02919981f, -0.03449893f, -0.10950376f, 0.08911886f, 0.05654018f, 0.01469297f, -0.01005718f, -0.13243033f, 
    -0.08768617f, -0.11147977f, -0.06740144f, -0.10386044f, 0.10799125f, -0.12843551f, 0.04986597f, 0.14199817f, 
    0.04537757f, 0.11895281f, 0.17954922f, 0.05934365f, -0.05843014f, -0.02463477f, 0.01723053f, -0.12109745f, 
    0.01675466f, 0.00243274f, 0.01599320f, 0.02583529f, 0.03722749f, -0.04902022f, 0.03662075f, -0.02155690f, 
    0.02947303f, 0.02179285f, 0.00234053f, -0.02789981f, -0.00789170f, -0.04671823f, 0.01715880f, 0.00684126f, 
    -0.00577068f, -0.05846702f, 0.03690355f, -0.03729398f, 0.02057379f, -0.04588521f, 0.00109993f, -0.00607520f, 
    -0.01242862f, 0.01292784f, 0.01900875f, 0.04643686f, -0.02200405f, 0.03976381f, -0.02761191f, 0.01340583f, 
    0.00203281f, -0.00904989f, 0.01520564f, -0.01685521f, -0.00854258f, 0.00860160f, -0.00426875f, -0.00082016f, 
    0.01296664f, 0.00640222f, -0.02215613f, 0.01884263f, 0.00038522f, -0.05171040f, 0.02293927f, -0.05229625f, 
    0.02178073f, 0.01524351f, -0.03742957f, 0.03525458f, -0.05126934f, 0.01752894f, 0.01847680f, 0.04153140f, 
    -0.05702983f, -0.05350372f, 0.01357364f, 0.03522455f, -0.00480356f, 0.00820190f, -0.03263715f, 0.03302028f, 
    0.02681261f, 0.00180587f, -0.03864183f, 0.02139122f, -0.03810814f, -0.02578047f, 0.01467465f, -0.04496228f, 
    0.00310242f, 0.00122876f, 0.02981273f, 0.03652819f, 0.04378878f, 0.00713649f, -0.04993850f, 0.00627797f, 
    -0.04592533f, 0.01651960f, -0.04460952f, 0.00522287f, -0.03559861f, -0.01723876f, -0.02544775f, -0.02282593f, 
    -0.01719450f, -0.04557518f, 0.03150362f, 0.03411245f, 0.03051383f, 0.01510214f, 0.00673313f, 0.03275773f, 
    0.01311992f, -0.00228687f, 0.01056860f, -0.03808997f, 0.02885466f, 0.01073137f, 0.02349761f, 0.01970425f, 
    -0.05568390f, 0.00732560f, -0.02252946f, 0.03765649f, 0.00543134f, -0.02417935f, -0.02911653f, 0.00613970f, 
    0.00827182f, -0.00670200f, -0.04797269f, -0.03039500f, 0.04760305f, -0.03692733f, -0.01153915f, 0.03774423f, 
    0.01812723f, -0.03209985f, -0.04921396f, -0.05490957f, -0.01861878f, 0.00943444f, 0.00335421f, 0.01185038f, 
    -0.03593377f, -0.04514095f, 0.03120193f, -0.03399124f, 0.02030728f, -0.04524667f, -0.00995368f, -0.01525775f, 
    -0.01563834f, -0.05515278f, 0.00706298f, -0.02063098f, 0.03603848f, 0.04130151f, -0.06012939f, -0.02126524f, 
    -0.01755859f, -0.05751452f, 0.00617003f, -0.02881687f, 0.00845727f, -0.02886273f, 0.02655186f, -0.01648646f, 
    -0.04563569f, -0.03927736f, -0.03991285f, -0.02529669f, -0.03024718f, -0.04828782f, -0.02041371f, -0.05254849f, 
    -0.01368443f, -0.04292419f, -0.03467259f, -0.02751293f, -0.05303682f, 0.02102534f, -0.05181627f, 0.03127598f, 
    0.04734182f, -0.01406840f, 0.01954348f, -0.05599611f, 0.00513911f, 0.02610765f, 0.01233580f, 0.02169877f, 
    0.01722212f, 0.03282161f, 0.01547831f, 0.01679484f, -0.04599462f, 0.00189709f, -0.00922554f, 0.04172577f, 
    -0.03778623f, 0.02317427f, 0.02509883f, -0.00106950f, 0.02606442f, 0.02122861f, -0.04484879f, -0.05541021f, 
    0.01715573f, 0.04332846f, 0.01622135f, -0.05093135f, -0.04350163f, -0.02546529f, -0.02970656f, 0.01780771f, 
    0.00605854f, 0.01701422f, -0.03258323f, -0.00360694f, -0.04135672f, -0.05137094f, 0.00731462f, -0.00283898f, 
    0.04152697f, -0.02477809f, 0.01642354f, 0.03421303f, -0.01126997f, -0.04320081f, 0.01105806f, -0.01429543f, 
    -0.02285267f, 0.01143797f, -0.00173916f, -0.00499576f, 0.00730613f, -0.02914011f, -0.01031192f, -0.00699346f, 
    -0.00820823f, -0.02073839f, 0.01868826f, -0.03356022f, 0.00409316f, -0.02333064f, 0.02507713f, 0.01971475f, 
    -0.00590272f, -0.02780086f, -0.02672273f, 0.02953234f, 0.01928364f, 0.03045895f, 0.00042300f, -0.05824728f, 
    -0.01539895f, -0.01883376f, 0.02021243f, 0.01704374f, -0.05123988f, 0.04120464f, 0.00860923f, 0.00322438f, 
    0.01424727f, 0.02086788f, 0.03624870f, 0.02402250f, -0.00026068f, -0.01795794f, 0.02690622f, -0.05071476f, 
    -0.03071593f, -0.00047977f, -0.02376965f, 0.02001676f, 0.03510650f, -0.01393244f, -0.03471723f, 0.01585709f, 
    0.04153113f, 0.02193151f, -0.03073030f, -0.02507973f, -0.00728570f, -0.05420592f, -0.02024776f, 0.00813085f, 
    0.02321690f, 0.00269020f, -0.05937899f, 0.01376473f, 0.00182409f, 0.03988639f, 0.01456861f, -0.03090061f, 
    -0.02195556f, -0.00202437f, -0.04729555f, 0.00565629f, -0.01975986f, -0.03155663f, -0.02568938f, -0.02947898f, 
    -0.03618032f, 0.00903532f, 0.03106132f, -0.03136013f, 0.01767419f, -0.05381823f, 0.02862407f, -0.00593353f, 
    -0.04914111f, 0.02197691f, 0.02680515f, -0.05095185f, -0.00919996f, -0.00416127f, -0.02555998f, -0.02934642f, 
    0.02977397f, -0.01074670f, -0.04245771f, -0.02674660f, 0.03794976f, -0.02785014f, -0.03260927f, -0.02981601f, 
    -0.02040023f, 0.00914287f, -0.03165840f, -0.00511881f, 0.03133735f, -0.03270129f, 0.03031397f, -0.02123846f, 
    -0.05179857f, -0.02628627f, 0.02207202f, 0.03707809f, 0.00871362f, 0.03084562f, -0.01498729f, -0.02959830f, 
    -0.01441545f, -0.02743626f, -0.02435090f, -0.02565713f, 0.01573039f, -0.00306870f, -0.03488320f, -0.04493092f, 
    -0.01721626f, 0.03689365f, -0.02507205f, -0.02664481f, 0.00437129f, -0.05570444f, 0.03750533f, -0.01351605f, 
    0.00358827f, 0.04052882f, 0.03536348f, 0.03041697f, 0.00155164f, -0.05312883f, -0.02252589f, -0.00548226f, 
    -0.04257156f, 0.03377398f, -0.00236439f, 0.02536809f, 0.00606952f, -0.05084226f, 0.02926796f, -0.00099624f, 
    -0.04851767f, -0.01377501f, -0.05197825f, -0.05845224f, -0.03473811f, -0.04608940f, -0.00162225f, 0.02172238f, 
    0.03413974f, -0.05754223f, -0.00573147f, -0.02610806f, -0.00910933f, -0.04673356f, 0.02087025f, -0.04236673f, 
    0.01499533f, -0.02525675f, 0.03441610f, -0.03559865f, -0.00925649f, 0.00482071f, 0.00771680f, 0.03131841f, 
    0.04406659f, -0.00099107f, -0.00213715f, -0.03583654f, 0.01317896f, 0.01709647f, 0.02007520f, -0.00371454f, 
    0.00683324f, -0.01901705f, 0.04263159f, -0.01218789f, 0.02152732f, 0.04193348f, -0.05626853f, -0.00742882f, 
    0.00756406f, 0.03000728f, 0.03769840f, 0.01530060f, -0.05216892f, -0.04690395f, 0.01639816f, -0.01644216f, 
    -0.00167433f, -0.05040362f, 0.00719538f, -0.04638791f, 0.02366671f, -0.04443678f, -0.02788656f, 0.01380430f, 
    -0.03455901f, 0.03390955f, 0.02299201f, 0.00936991f, 0.01916346f, -0.00641013f, -0.01054714f, -0.02251073f, 
    0.00237808f, -0.01874048f, 0.02440731f, 0.03260259f, 0.04464609f, -0.03364980f, 0.00051493f, -0.01316777f, 
    -0.03063247f, 0.01712461f, -0.00873131f, -0.02097780f, 0.00535182f, -0.00970842f, -0.05626084f, -0.03680545f, 
    0.01101614f, -0.00297151f, -0.02097698f, 0.02392258f, -0.02396507f, -0.02037055f, 0.02935821f, 0.02402320f, 
    0.02638784f, -0.01064111f, 0.03889888f, 0.02671901f, 0.04413948f, 0.01614525f, -0.04862676f, -0.02342647f, 
    -0.04799067f, -0.01536182f, -0.04860515f, 0.03741233f, 0.04074033f, -0.04540712f, -0.05111510f, 0.00280128f, 
    -0.00228890f, 0.00724440f, -0.03468519f, -0.02720935f, -0.02263780f, -0.00522274f, 0.03724102f, -0.04694578f, 
    0.00586192f, 0.01959314f, -0.00456216f, 0.03701203f, -0.01829034f, -0.05406548f, 0.02255175f, -0.03801353f, 
    -0.03180075f, 0.01308512f, 0.01585671f, -0.04777480f, -0.03938737f, -0.01333939f, 0.00353498f, -0.00722603f, 
    0.00261555f, -0.03247527f, 0.02473470f, -0.01793507f, 0.03965600f, -0.02199961f, 0.02874745f, -0.03206629f, 
    -0.01884706f, 0.03469811f, -0.00144152f, -0.00523308f, -0.01410505f, -0.02642609f, -0.02274425f, 0.01991650f, 
    0.03037447f, -0.04343081f, 0.01113941f, -0.04239923f, -0.04322214f, -0.04635601f, -0.00244860f, -0.02854318f, 
    -0.00632915f, 0.01605041f, -0.03288322f, -0.00525009f, 0.03019563f, 0.03655750f, 0.01151519f, 0.00318904f, 
    -0.05209750f, -0.04251263f, 0.01737423f, -0.03666476f, 0.04010422f, -0.02299660f, -0.03517953f, -0.01613813f, 
    -0.03652514f, -0.04593863f, 0.02162726f, -0.01629487f, -0.03732054f, 0.00468181f, 0.01970565f, -0.00738232f, 
    0.01511840f, -0.00499989f, 0.01180478f, -0.01420341f, -0.03628189f, 0.04155672f, 0.03386412f, 0.01443101f, 
    -0.03659128f, 0.03779265f, 0.01471121f, -0.04183275f, -0.03043674f, 0.03201407f, -0.03548398f, -0.00758007f, 
    -0.02203394f, 0.02068837f, -0.02786316f, -0.04230200f, -0.02289197f, 0.01981540f, 0.03659638f, -0.03172518f, 
    -0.02119561f, 0.03381524f, 0.03426328f, 0.00604107f, 0.02611216f, -0.05187254f, 0.03851402f, 0.00344190f, 
    0.01983536f, 0.02512479f, 0.02864244f, 0.03144499f, 0.05016553f, -0.02201631f, 0.00257831f, 0.01015379f, 
    -0.02835114f, -0.03495129f, -0.00013207f, 0.03972727f, -0.02624891f, -0.00826895f, 0.00317178f, 0.03580549f, 
    -0.01798478f, 0.00646431f, -0.02408606f, 0.03994792f, 0.04322419f, -0.04929331f, -0.05466465f, -0.03246601f, 
    -0.03364492f, 0.01106434f, -0.03510707f, -0.01207046f, -0.01549581f, -0.02697043f, -0.03542603f, -0.00630624f, 
    -0.03315388f, -0.03884832f, -0.01199819f, 0.01266456f, -0.02388069f, 0.00708612f, 0.01080262f, -0.02113682f, 
    -0.01502788f, -0.01233346f, 0.01600246f, 0.01126052f, -0.05450255f, 0.02097660f, 0.01656192f, 0.02685959f, 
    -0.03377289f, 0.00432352f, -0.05400613f, -0.00511069f, 0.01170295f, 0.01112778f, -0.01752347f, -0.05526004f, 
    -0.04745993f, -0.04596860f, -0.00103863f, 0.00003367f, -0.00208461f, -0.00038051f, -0.05080680f, 0.01640974f, 
    0.01704312f, -0.04606082f, -0.01687842f, -0.01625778f, -0.02718252f, 0.00643169f, -0.05504938f, -0.00233025f, 
    0.03678396f, 0.01621951f, 0.03282296f, -0.03695690f, -0.05550035f, 0.00847194f, -0.04627695f, -0.02154741f, 
    -0.04927097f, 0.01205141f, -0.00547770f, 0.01744896f, 0.02099325f, -0.04391608f, 0.03219877f, -0.00680610f, 
    -0.01545223f, -0.05373131f, 0.03097574f, -0.00838441f, -0.04864229f, 0.03202883f, -0.02799331f, -0.01899115f, 
    -0.04866518f, 0.03338256f, -0.00438480f, -0.05664630f, 0.03342224f, 0.02963625f, -0.04503696f, 0.00617146f, 
    0.01709290f, -0.02714429f, 0.03818136f, 0.00838938f, 0.00877194f, -0.04590155f, 0.01128229f, 0.01679560f, 
    0.01419402f, -0.05149031f, -0.04406213f, 0.00856591f, -0.01862987f, 0.04198327f, -0.01870781f, 0.01285597f, 
    0.04426769f, -0.00820773f, 0.01653535f, -0.03723037f, -0.04107213f, -0.00519982f, -0.03862179f, 0.03992003f, 
    -0.05033014f, -0.03581291f, 0.03916266f, -0.03600490f, -0.03206072f, -0.00941043f, -0.01681430f, -0.03555619f, 
    -0.00742820f, -0.05449652f, -0.02580401f, 0.03678184f, -0.02671322f, -0.00328968f, -0.03843766f, -0.01707054f, 
    0.01681381f, -0.03663760f, -0.05572817f, -0.04982009f, -0.01935619f, 0.03393423f, 0.00268108f, -0.04053711f, 
    -0.03029389f, 0.03478510f, -0.03097297f, 0.04385520f, 0.03563703f, 0.02718635f, -0.03389028f, 0.01037857f, 
    -0.03558955f, 0.02708689f, 0.03660315f, -0.00766339f, -0.04832186f, -0.04414939f, 0.02395879f, -0.01352264f, 
    0.02381883f, -0.02482139f, -0.04920461f, -0.00683627f, 0.02955456f, -0.01697527f, -0.03956398f, -0.03597801f, 
    -0.00687462f, -0.00420715f, -0.00872222f, -0.01822568f, -0.03237244f, -0.01158388f, -0.01186975f, 0.02014594f, 
    -0.02956330f, 0.00313819f, 0.00603996f, -0.03403554f, -0.02561930f, -0.03951047f, -0.00156307f, -0.03542697f, 
    -0.01262122f, -0.02445679f, -0.00503404f, -0.01165106f, 0.02495584f, -0.01798277f, -0.03458480f, -0.04027536f, 
    0.03051897f, 0.03276420f, 0.04377735f, 0.03577981f, -0.00166872f, -0.00312691f, 0.01526665f, 0.01475828f, 
    -0.00818416f, -0.04715465f, 0.01327534f, -0.05984424f, -0.04904381f, -0.05357073f, 0.01911864f, -0.03896411f, 
    0.01397972f, -0.02204405f, 0.01977656f, 0.02633679f, 0.03949500f, -0.05777305f, -0.02030538f, 0.01677877f, 
    0.01592829f, -0.04435942f, -0.01498943f, 0.03391447f, -0.03304421f, 0.02412621f, -0.01700425f, 0.03221019f, 
    0.03324849f, -0.03070556f, 0.03332007f, -0.03872753f, 0.00093497f, -0.00776842f, -0.01905232f, -0.03476418f, 
    0.01314780f, 0.00794807f, -0.03224365f, -0.02443233f, -0.05235383f, -0.05674028f, 0.02216309f, -0.01928922f, 
    -0.02952038f, 0.02536786f, -0.05793312f, 0.00075962f, -0.02969456f, -0.01086581f, -0.03969553f, 0.02343899f, 
    -0.00253141f, 0.01952340f, -0.05055817f, -0.05605837f, -0.01094163f, 0.04428454f, -0.02837345f, -0.01804692f, 
    -0.03479257f, 0.01670848f, -0.05432456f, 0.01788134f, 0.03260445f, -0.03504989f, 0.00231104f, -0.05552761f, 
    0.00066364f, -0.05050011f, -0.01312439f, 0.03262540f, 0.01946699f, -0.02343464f, -0.00676820f, -0.01250931f, 
    -0.00840728f, -0.01697407f, 0.01194831f, 0.02509088f, 0.04247314f, -0.01876108f, 0.03368573f, -0.05320388f, 
    -0.02709416f, 0.00569940f, -0.03549818f, -0.05530500f, -0.03410844f, 0.01378107f, 0.02814376f, -0.02153424f, 
    -0.02534184f, 0.03681400f, 0.03627108f, -0.05725996f, 0.02435819f, -0.01239211f, -0.00571663f, 0.01276682f, 
    -0.03532312f, -0.00043557f, -0.00070735f, -0.03131932f, -0.00416757f, -0.03346894f, -0.04111169f, -0.01818349f, 
    0.03013610f, 0.00958932f, -0.02020175f, 0.00818160f, -0.04306737f, 0.01644824f, -0.03989007f, -0.04668445f, 
    0.00789448f, -0.01092951f, 0.01502791f, 0.00613720f, 0.03216381f, -0.00313192f, 0.04280098f, -0.03318047f, 
    -0.03810180f, -0.01328264f, 0.04166913f, 0.00344944f, 0.00039335f, -0.02667165f, 0.02256867f, -0.05511416f, 
    0.04143547f, -0.05476977f, -0.00391032f, 0.01351093f, 0.03368067f, -0.02693421f, 0.00212868f, -0.04776067f, 
    0.03466396f, -0.00745302f, 0.01556589f, -0.05113909f, -0.00184461f, -0.00454792f, 0.01513871f, 0.00111168f, 
    0.00853536f, 0.00313877f, -0.01685664f, -0.01186886f, -0.03709677f, -0.01917153f, 0.03782537f, -0.03195772f, 
    -0.04687670f, -0.01410057f, -0.05028972f, 0.03519622f, 0.03462429f, 0.02602313f, -0.01002810f, -0.00708763f, 
    0.04454583f, -0.01583026f, 0.03307897f, 0.02408099f, 0.02660847f, 0.01954301f, -0.01390873f, -0.04175380f, 
    0.00717381f, 0.04241202f, -0.03985923f, -0.01672448f, -0.03863017f, 0.01397674f, 0.02836701f, -0.03863391f, 
    0.02437342f, 0.04782549f, -0.01010962f, 0.03686445f, -0.03706994f, -0.00436874f, 0.00571175f, -0.05360723f, 
    -0.01894121f, -0.02179107f, -0.02060543f, -0.01618452f, -0.04174864f, -0.04267851f, 0.03833853f, 0.03124144f, 
    0.00677286f, -0.04148254f, -0.01630522f, -0.03455849f, -0.04190927f, -0.03470397f, -0.00247025f, 0.02588449f, 
    0.01621887f, -0.04368827f, -0.01236239f, -0.00416182f, -0.00248926f, 0.01676333f, 0.00364207f, 0.03118371f, 
    -0.03367806f, -0.04733513f, -0.04715232f, -0.01907260f, -0.00464153f, 0.00564458f, 0.01719313f, 0.03126099f, 
    -0.05748548f, 0.04382842f, 0.04063130f, -0.03281302f, -0.04791911f, 0.01746692f, -0.03254247f, 0.01274856f, 
    -0.00819051f, 0.00333751f, -0.00788542f, -0.05454511f, 0.04236051f, -0.01704801f, 0.00352629f, -0.02145991f, 
    -0.01546281f, 0.00456303f, 0.00041663f, 0.03310244f, -0.02088956f, 0.00823290f, -0.04229838f, -0.05069670f, 
    0.04011178f, -0.00483927f, -0.05433490f, 0.01162313f, 0.03219213f, 0.01936213f, 0.00920669f, -0.03073637f, 
    0.00109325f, -0.00428236f, -0.04058914f, -0.00697229f, -0.05546977f, 0.00415607f, -0.03311362f, -0.01596202f, 
    0.04118024f, 0.00256533f, 0.00229701f, 0.02456349f, -0.02574235f, 0.02832182f, 0.02668177f, -0.02913885f, 
    0.03378591f, 0.04458331f, -0.01568327f, -0.01434555f, 0.01998521f, 0.02492291f, -0.01455564f, 0.01091588f, 
    0.00281995f, 0.02996101f, 0.00100014f, 0.00043743f, 0.02990476f, -0.00601708f, -0.05225402f, -0.03363241f, 
    -0.03068860f, 0.00540754f, -0.05008283f, -0.00974704f, 0.04471056f, -0.04639370f, 0.03598182f, 0.03675081f, 
    0.00623381f, -0.05007735f, -0.04522923f, -0.00106144f, -0.03007065f, 0.01933665f, 0.04320862f, -0.03995341f, 
    0.04254263f, -0.00902642f, -0.00445511f, -0.03871577f, 0.00950997f, 0.01639773f, -0.02650878f, -0.03923568f, 
    -0.01835045f, 0.01687961f, -0.04568669f, -0.00934174f, -0.00225655f, 0.00298374f, 0.01701136f, 0.03037908f, 
    -0.01221511f, -0.04306215f, 0.02217570f, -0.00714792f, -0.03063540f, 0.05168309f, 0.03426040f, -0.02894764f, 
    -0.01502537f, -0.00401447f, -0.04019998f, -0.04669677f, -0.01465709f, -0.01727200f, 0.01287719f, -0.00190461f, 
    0.02213693f, 0.02897462f, -0.00078067f, -0.03706247f, -0.02024466f, 0.01310865f, 0.01476665f, 0.01292452f, 
    -0.04515081f, -0.02291781f, -0.01857474f, -0.00704305f, 0.03852768f, 0.03105341f, 0.03727974f, 0.03875721f, 
    -0.01963710f, 0.00878562f, -0.04060405f, 0.01014570f, 0.03335312f, -0.01306643f, 0.03688081f, 0.00172681f, 
    0.02904671f, 0.00098388f, -0.01500698f, -0.02961314f, -0.03165199f, -0.02552592f, 0.02072612f, -0.05488414f, 
    0.00459349f, 0.03219251f, -0.02000376f, -0.00131020f, 0.02098787f, -0.04601482f, 0.01097175f, -0.04143433f, 
    -0.02085264f, -0.02961862f, 0.01983846f, -0.02972838f, -0.02373852f, 0.04580831f, -0.04431203f, 0.03909783f, 
    0.13222107f, -0.04895983f, 0.04961834f, 0.18074088f, 0.05305595f, 0.03250341f, 0.10602745f, 0.04082798f, 
    -0.00000854f, 0.03994303f, 0.00613833f, 0.01400236f, 0.22177756f, -0.00378642f, -0.03175241f, -0.16033612f, 
    0.08833162f, -0.03771899f, 0.19738990f, -0.02734110f, 0.05306336f, 0.18612099f, 0.13125059f, -0.12186444f, 
    -0.04810377f, -0.02095045f, 0.01551138f, 0.26491603f, -0.08793467f, -0.00024614f, 0.04116258f, -0.14066485f, 
    -0.00461403f, 0.03072970f, 0.03572465f, 0.00485344f, -0.05019075f, 0.01228706f, 0.08549851f, 0.02276930f, 
    -0.07013970f, -0.10521645f, 0.04499936f, 0.15566371f, -0.01744749f, -0.07360231f, 0.00719413f, 0.02549762f, 
    0.22501466f, -0.05966051f, -0.10142823f, -0.10721145f, -0.01373067f, 0.00726889f, -0.00404851f, 0.02592769f, 
    0.09055402f, 0.11436069f, 0.00881870f, -0.06074026f, -0.08797679f, -0.11623377f, -0.24989505f, -0.34469619f, 
    -0.00641349f, -0.02800873f, -0.01733705f, -0.05116451f, 0.14119805f, -0.01684443f, -0.00587737f, 0.21615957f, 
    -0.02618668f, 0.06042511f, -0.05554948f, 0.12148438f, 0.22768897f, -0.03987325f, -0.02404919f, -0.20136209f, 
    0.03576578f, 0.09013095f, 0.05541800f, 0.07480361f, 0.11514145f, 0.06697652f, -0.03772455f, 0.10136107f, 
    0.02887057f, 0.03128834f, 0.08402965f, 0.03860143f, 0.00890981f, 0.05322455f, 0.07698824f, -0.01058303f, 
    -0.05855724f, 0.02444956f, 0.01569827f, -0.18506807f, -0.06750131f, -0.03321689f, 0.06598738f, 0.26671812f, 
    0.06314198f, 0.18742034f, -0.02284679f, -0.25176096f, 0.27174300f, -0.19086488f, -0.32610682f, -0.15486346f, 
    0.01048626f, -0.16081390f, 0.09805139f, 0.01569804f, 0.03778289f, 0.08855321f, 0.07736751f, -0.00153867f, 
    -0.22863927f, 0.00142167f, -0.27606115f, -0.27291498f, -0.06693315f, -0.04962493f, 0.02892133f, -0.04181245f, 
    0.02525636f, 0.00239006f, 0.13957722f, -0.07355446f, -0.00854482f, -0.05973894f, 0.08705268f, 0.08545881f, 
    0.04645116f, -0.06851701f, -0.11169022f, 0.12263164f, -0.02133307f, 0.01879584f, -0.03776616f, 0.04099439f, 
    0.10980263f, 0.19499084f, -0.07723721f, 0.10081459f, 0.05738468f, -0.02716986f, 0.02743319f, -0.09449448f, 
    0.02538524f, 0.06466769f, 0.05006430f, -0.17283726f, -0.25569329f, -0.11976891f, 0.04995655f, -0.18806723f, 
    -0.07003349f, 0.00770774f, -0.13242221f, -0.02256114f, -0.09080033f, -0.12054407f, -0.03410130f, 0.10000972f, 
    0.02992700f, 0.05639384f, 0.16576160f, 0.14776127f, 0.03102115f, -0.02828740f, -0.01121896f, -0.06734671f, 
    -0.04525674f, 0.01887901f, 0.02184396f, -0.05034317f, 0.11376832f, 0.10500118f, 0.01507424f, 0.27316177f, 
    0.02043918f, 0.01800755f, 0.06197367f, -0.05590434f, 0.09894826f, 0.07509643f, -0.04571311f, -0.03082021f, 
    -0.14589028f, -0.11835083f, -0.02357998f, -0.23682432f, 0.10254344f, -0.04192588f, -0.06069840f, -0.15081544f, 
    -0.05538779f, -0.02349712f, -0.04193062f, 0.00042897f, 0.18766241f, 0.00707606f, -0.03743743f, -0.04193676f, 
    -0.07217633f, -0.02948847f, -0.02204630f, -0.07392927f, -0.01345472f, -0.01723916f, 0.06414406f, -0.02472836f, 
    -0.24147293f, -0.21197553f, -0.32545349f, -0.19209477f, -0.00473462f, 0.01441558f, 0.05937218f, -0.12596056f, 
    -0.05283289f, -0.02126994f, -0.03142946f, -0.13992001f, -0.10941600f, -0.15023597f, -0.26921690f, 0.13268581f, 
    0.08845068f, 0.13677320f, 0.15787929f, 0.14499369f, -0.02311969f, -0.03774787f, -0.02279793f, 0.01254349f, 
    -0.24967232f, -0.24117579f, -0.29613194f, -0.21733344f, -0.05688509f, -0.04443490f, -0.13578618f, -0.09931638f, 
    -0.02093055f, -0.04910308f, -0.00139506f, 0.08205266f, 0.07857527f, -0.04999869f, -0.01997785f, 0.03439824f, 
    0.01880557f, 0.02976503f, 0.01723086f, 0.15271857f, 0.12691867f, 0.01547733f, -0.04204878f, 0.01175557f, 
    -0.16478974f, -0.18612100f, 0.10046975f, -0.02993627f, 0.01674406f, 0.15779601f, 0.05941589f, -0.18759090f, 
    -0.06155093f, 0.17768912f, -0.04878202f, 0.00314256f, 0.31486994f, 0.11234105f, 0.17523491f, 0.00693105f, 
    0.01616340f, -0.05457078f, -0.00305115f, 0.02524255f, -0.03461741f, 0.02772728f, -0.01715035f, -0.02894414f, 
    0.08116692f, 0.04410423f, -0.03789034f, -0.09050179f, -0.00058247f, -0.04366399f, -0.07233127f, -0.01164408f, 
    -0.02229349f, -0.07273082f, -0.02423202f, 0.02056609f, -0.25765550f, 0.03937805f, -0.23734049f, -0.32664812f, 
    0.03166768f, 0.03188856f, -0.07254727f, 0.02997673f, -0.05966930f, -0.02997261f, 0.02561538f, -0.00506473f, 
    0.34038162f, 0.23624514f, 0.16273159f, 0.03676401f, 0.01527632f, 0.03716085f, 0.02384917f, 0.08530293f, 
    -0.02108653f, 0.11344921f, -0.12650807f, -0.13583744f, -0.13752145f, -0.48920244f, -0.01520806f, -0.10182165f, 
    -0.02381928f, 0.03486254f, -0.09798514f, 0.13266353f, -0.05266491f, -0.04577582f, -0.05312314f, -0.08050089f, 
    -0.14207710f, 0.18073845f, 0.09923048f, -0.14861511f, 0.10266611f, -0.09154055f, 0.06795987f, 0.12577799f, 
    -0.02519993f, -0.14156656f, 0.01900740f, 0.04123707f, -0.23262972f, -0.11341976f, -0.18797293f, -0.02010838f, 
    -0.10811410f, -0.03322024f, 0.01861752f, -0.06917642f, 0.05683206f, 0.00057693f, 0.08392054f, -0.04608424f, 
    -0.05057168f, 0.07469647f, 0.06809272f, 0.04555868f, -0.08597512f, -0.11719218f, 0.12478726f, -0.00916314f, 
    -0.02548803f, 0.02010901f, 0.01171457f, -0.00655242f, 0.17925216f, 0.10322125f, -0.03530216f, 0.00362723f, 
    0.06729715f, -0.02109511f, 0.03017244f, -0.07358335f, -0.00521088f, -0.00081828f, 0.03491520f, -0.04818922f, 
    -0.03389786f, 0.03493640f, -0.02352834f, 0.02558109f, -0.01300605f, -0.02175112f, -0.00772909f, -0.03497471f, 
    -0.02989765f, -0.05005443f, -0.04801865f, -0.04203462f, -0.00508885f, -0.00693748f, 0.03434803f, 0.03066654f, 
    -0.03062582f, -0.03539390f, -0.05368622f, -0.03318115f, -0.04245197f, -0.00872785f, -0.02355669f, 0.02609131f, 
    -0.03247156f, 0.03301871f, -0.04878030f, -0.02819189f, 0.04485317f, -0.01183724f, 0.00263995f, -0.04765585f, 
    0.00231794f, -0.02489806f, -0.04578913f, 0.01744114f, -0.03724568f, 0.02623450f, -0.03052645f, -0.04438616f, 
    0.00456802f, -0.04880338f, -0.00716632f, -0.01148453f, -0.02642420f, 0.01874509f, 0.04265467f, -0.00044506f, 
    -0.02046530f, 0.04067828f, 0.03605942f, 0.04101649f, -0.04619485f, -0.03637699f, 0.00896027f, -0.00517804f, 
    -0.01496375f, 0.04296216f, -0.02284619f, -0.02644188f, -0.04125363f, -0.03494404f, 0.00210801f, 0.04477144f, 
    -0.01981904f, -0.00870415f, -0.01244477f, -0.00977664f, -0.02307513f, -0.02716373f, 0.01496575f, 0.03774408f, 
    0.00981327f, -0.04878378f, -0.00562788f, -0.03723415f, -0.00526438f, 0.01115432f, 0.02820439f, 0.02512473f, 
    -0.03245261f, -0.02877606f, -0.03201736f, -0.03223174f, 0.00798628f, -0.03985510f, 0.02045402f, -0.01922849f, 
    0.01708455f, -0.00409289f, 0.04266168f, 0.01924453f, 0.03469624f, 0.02720303f, -0.03146980f, 0.01056643f, 
    -0.01491902f, -0.00337599f, -0.02970371f, 0.00482123f, -0.03424400f, 0.03108197f, -0.00015663f, -0.02633360f, 
    -0.03385698f, -0.03913539f, 0.03374684f, 0.02259073f, 0.00817293f, -0.02782314f, -0.02853375f, -0.02781423f, 
    0.02792164f, -0.03512264f, -0.02177459f, -0.03466647f, -0.00005592f, 0.03618840f, 0.02399000f, -0.01464649f, 
    0.00717673f, -0.00965192f, 0.02186802f, 0.03871909f, -0.05007828f, 0.02387628f, -0.04735440f, -0.04629809f, 
    -0.04014696f, 0.02459919f, 0.04489949f, -0.05086001f, -0.05632426f, -0.05412069f, -0.04162798f, 0.00114469f, 
    -0.03905346f, -0.04189170f, -0.05614046f, 0.02383493f, 0.03991031f, 0.02572764f, -0.00310130f, 0.01777645f, 
    0.02580106f, -0.00156869f, -0.04116256f, 0.00335186f, 0.00457092f, 0.03388662f, 0.00691188f, -0.01980735f, 
    0.02592048f, 0.00487779f, -0.02495876f, 0.02007843f, 0.02114522f, -0.05030634f, -0.05210176f, 0.00391289f, 
    -0.02646196f, -0.01111232f, 0.02757275f, 0.00926617f, 0.04290165f, -0.01493901f, 0.01111983f, -0.05608411f, 
    0.00731147f, -0.03457141f, 0.04355508f, -0.04254150f, 0.02546454f, -0.03593650f, 0.02399322f, 0.01600884f, 
    0.03254395f, -0.01194310f, 0.00938178f, -0.00471453f, 0.02559946f, -0.03134529f, -0.01288104f, 0.00089491f, 
    -0.02300997f, 0.00735418f, 0.02891459f, 0.04184164f, -0.04215312f, 0.01181785f, 0.01553281f, -0.03601392f, 
    0.03836133f, 0.03085224f, -0.03785812f, 0.04071768f, -0.02174946f, 0.04416762f, -0.03916316f, 0.01523215f, 
    -0.04818386f, -0.00174833f, -0.02197226f, 0.03106684f, -0.01858083f, 0.03870304f, 0.01237637f, -0.01823889f, 
    -0.05056205f, -0.05029816f, -0.01304821f, 0.02420514f, -0.02222149f, -0.02618570f, -0.00179673f, 0.00055835f, 
    -0.00501031f, 0.01136031f, -0.01126449f, 0.01843847f, -0.01416319f, -0.05229104f, 0.04087403f, -0.03028345f, 
    -0.03228026f, 0.03868535f, -0.03196639f, -0.04244765f, -0.05205166f, 0.01485201f, 0.00700777f, 0.04542412f, 
    0.03514251f, -0.00055347f, -0.04279383f, -0.05515125f, -0.02916021f, -0.03188442f, -0.01068834f, -0.05530159f, 
    0.02240299f, 0.03962908f, -0.02724012f, -0.04467556f, 0.01799174f, 0.01719758f, 0.02070122f, -0.04243594f, 
    0.01512660f, 0.02114581f, -0.01635833f, 0.01555953f, -0.00745268f, -0.02289859f, 0.04311492f, -0.00808249f, 
    0.00031727f, -0.05041301f, 0.03825194f, -0.03083913f, 0.04267420f, -0.04938653f, -0.05058052f, -0.04261188f, 
    -0.00792185f, -0.05053360f, 0.04143690f, -0.00373561f, 0.01236273f, -0.03439943f, -0.04608965f, 0.01726324f, 
    0.02567776f, -0.02037906f, 0.00759840f, 0.03553456f, -0.03887170f, 0.01606471f, -0.00215200f, -0.03812259f, 
    0.02653817f, 0.03255153f, -0.02630044f, -0.02648502f, -0.05551931f, 0.04316008f, -0.04717515f, -0.05270605f, 
    0.00379430f, 0.03682585f, 0.04314831f, 0.04067088f, -0.03624368f, -0.01367193f, -0.02131936f, 0.00371149f, 
    -0.04744612f, 0.01671894f, -0.01793833f, -0.00430943f, 0.04160155f, -0.00374195f, 0.00219747f, 0.02300387f, 
    0.03128866f, 0.04440876f, -0.01157568f, 0.03220819f, -0.03933315f, -0.03192718f, -0.03535337f, -0.03064998f, 
    -0.00688371f, 0.03346964f, -0.03371421f, 0.01561347f, 0.04519862f, 0.00057339f, -0.03567998f, 0.02926038f, 
    -0.04759748f, -0.05403142f, -0.03799784f, -0.04631292f, -0.04936533f, 0.02194402f, 0.03861128f, 0.01046314f, 
    0.02890931f, -0.00487907f, -0.04736065f, -0.03313142f, -0.05291158f, -0.03614693f, -0.03880978f, 0.00779402f, 
    0.03147515f, -0.00936450f, -0.01781721f, -0.01960065f, 0.04450246f, -0.04576762f, 0.00019906f, 0.04294175f, 
    -0.01135473f, 0.00330005f, -0.04553763f, 0.00039012f, 0.03832029f, -0.04996639f, -0.03155566f, 0.04149513f, 
    -0.00447526f, -0.02874508f, 0.00768850f, -0.01303420f, -0.03277221f, 0.00083431f, -0.00465242f, 0.02934711f, 
    -0.02887295f, -0.01295894f, -0.03828887f, -0.02643486f, -0.00744261f, -0.01135622f, -0.00469973f, -0.03190201f, 
    0.02705607f, -0.05646253f, -0.01657272f, -0.04787288f, -0.00882522f, -0.00377915f, -0.01992642f, -0.03227824f, 
    0.02783095f, -0.00519814f, 0.02835424f, -0.05546865f, -0.02040467f, 0.03996340f, -0.02485263f, -0.01365098f, 
    0.00514535f, -0.27752194f, -0.12656088f, -0.02554756f, 0.11890441f, 0.10179044f, 0.00320007f, -0.01383636f, 
    -0.02639505f, -0.12313012f, -0.04045895f, 0.00035196f, 0.55405533f, 0.08376188f, -0.11228076f, -0.40372685f, 
    -0.01224168f, 0.14508654f, -0.01747643f, -0.00451512f, 0.14178629f, -0.06709833f, 0.04820076f, -0.09045414f, 
    -0.38595477f, -0.24039555f, 0.01231806f, 0.24193896f, 0.00950277f, -0.00344080f, -0.03205430f, 0.02548172f, 
    0.12859596f, -0.05213960f, -0.00045572f, 0.28035882f, -0.27933168f, -0.23295762f, 0.11560510f, 0.11005717f, 
    -0.07517132f, 0.12690154f, 0.01009251f, 0.16998447f, -0.00969254f, -0.01560570f, 0.03052043f, 0.11839271f, 
    -0.21756922f, 0.19305827f, 0.20830892f, 0.15526411f, -0.06955792f, -0.07546335f, -0.09259035f, 0.07060028f, 
    0.10390159f, 0.06673126f, 0.03529809f, -0.09219327f, 0.08817144f, -0.01754406f, 0.14407092f, -0.30980954f, 
    0.06041741f, 0.03194859f, 0.08513267f, -0.02231367f, 0.06201644f, 0.04763015f, -0.01062583f, 0.15717730f, 
    -0.04233140f, 0.18688978f, 0.02889120f, -0.28703853f, 0.06167530f, -0.01771653f, -0.00907663f, -0.01732028f, 
    0.09872587f, -0.01838810f, 0.10406311f, -0.02680555f, 0.08178847f, -0.10815144f, -0.35398945f, -0.05078502f, 
    0.09884954f, 0.13392389f, 0.03878501f, -0.04802534f, -0.10481226f, -0.03838127f, 0.04079661f, 0.00846366f, 
    -0.04013244f, 0.05927376f, -0.07917568f, 0.14178355f, -0.11854666f, 0.02342384f, 0.01705865f, 0.13677166f, 
    0.16481552f, 0.11366487f, 0.02351136f, -0.02480280f, 0.45472321f, -0.15614410f, 0.10391112f, -0.38100597f, 
    0.04423821f, 0.11507273f, -0.12150676f, 0.04105115f, 0.10444343f, -0.03463086f, 0.04696497f, 0.03906639f, 
    -0.12135438f, -0.11360903f, 0.17376363f, 0.22106673f, 0.08001609f, -0.00999672f, 0.10609892f, 0.22327255f, 
    0.08283310f, 0.14443550f, 0.12774849f, 0.01628185f, -0.27734867f, -0.18870403f, 0.27665660f, 0.15090173f, 
    0.05744199f, -0.06627527f, 0.12393585f, 0.13043068f, 0.12560746f, -0.04760752f, -0.00555779f, 0.09805990f, 
    0.18171236f, 0.13010237f, -0.10467140f, -0.15137078f, 0.17147976f, -0.07967806f, 0.17756224f, -0.06240170f, 
    0.15161858f, 0.04689199f, 0.00044726f, 0.09754139f, -0.34466860f, 0.13934398f, 0.11668704f, -0.27769747f, 
    -0.03167098f, 0.03098992f, 0.04186931f, -0.03873743f, 0.04393271f, 0.03094800f, 0.00077148f, -0.01542037f, 
    -0.16299085f, -0.07916054f, -0.30251685f, -0.05517007f, 0.14916670f, -0.04012206f, 0.07750726f, -0.12115702f, 
    -0.03275869f, -0.02394150f, -0.02226410f, 0.08053914f, 0.50505918f, -0.11069626f, -0.29353297f, -0.09324213f, 
    0.04981858f, 0.09908730f, 0.08690908f, -0.10701121f, 0.03431896f, -0.04630500f, -0.04347111f, -0.00437709f, 
    -0.19587663f, 0.04606456f, 0.25254238f, 0.01423963f, 0.01832024f, 0.08454940f, 0.16117449f, -0.01233010f, 
    0.14108121f, 0.06572919f, 0.07191763f, 0.16519411f, -0.14464280f, -0.16937271f, 0.31056362f, 0.00966963f, 
    -0.00939998f, -0.03272448f, 0.02334370f, -0.00024682f, 0.07199544f, 0.05846129f, -0.02764722f, 0.02477507f, 
    -0.06131863f, -0.06226397f, 0.01585321f, 0.00168636f, 0.14589711f, 0.04489712f, 0.07607502f, 0.05355826f, 
    0.04968104f, 0.07461911f, 0.06054071f, 0.11668309f, -0.22860944f, -0.21328865f, -0.15444449f, -0.06264102f, 
    0.09246453f, 0.04747604f, 0.00840829f, 0.00981682f, -0.05654811f, 0.09254991f, -0.04044022f, 0.02991971f, 
    -0.28452888f, -0.17115514f, 0.00631314f, -0.40504247f, 0.07245264f, 0.08078871f, -0.01821519f, 0.00127036f, 
    0.03409325f, 0.04968514f, -0.17127651f, -0.04370845f, 0.20189327f, 0.14186980f, -0.13107048f, -0.21509817f, 
    0.00986107f, -0.02475012f, 0.20720604f, 0.06627117f, -0.05871209f, -0.03615421f, -0.01082907f, -0.09774611f, 
    0.00988941f, 0.16387704f, 0.17458116f, 0.09391692f, -0.02015023f, 0.19191809f, 0.00891295f, -0.07368378f, 
    0.11987921f, -0.01139017f, 0.08581240f, -0.02541229f, 0.08303408f, -0.06914565f, 0.17720710f, 0.06473157f, 
    -0.05080617f, -0.11564650f, -0.11666697f, -0.08291009f, 0.05377443f, 0.14446008f, 0.12152847f, -0.00506641f, 
    0.15913303f, -0.00327698f, -0.10904901f, -0.07565593f, 0.13289100f, 0.00645613f, -0.02730928f, 0.10958579f, 
    0.05672004f, 0.00892189f, -0.04314427f, 0.04531738f, -0.12850650f, 0.14839491f, 0.03728167f, -0.00815330f, 
    0.05654687f, -0.02197917f, 0.16214672f, -0.05958790f, 0.12306755f, -0.12166399f, 0.04612035f, -0.03099121f, 
    0.24360271f, 0.05054518f, -0.05325883f, 0.17118080f, -0.02680864f, -0.02650992f, -0.03640899f, 0.01291905f, 
    0.02417221f, 0.07798231f, -0.08861304f, 0.06059375f, 0.02209421f, -0.15191495f, 0.28797376f, -0.36122710f, 
    0.00359247f, 0.07525381f, -0.01323712f, 0.07997780f, 0.16848417f, 0.11532998f, -0.06754509f, 0.03608213f, 
    -0.03203055f, 0.18407904f, 0.19635205f, -0.17994717f, -0.08759921f, -0.23316692f, -0.02667842f, -0.17159747f, 
    0.01497357f, -0.03384734f, -0.00022184f, -0.01854761f, -0.48199081f, 0.03607935f, 0.07097722f, 0.11977930f, 
    0.12792014f, 0.04401389f, 0.00179787f, 0.07361656f, 0.12815000f, -0.03810400f, -0.08591224f, -0.06645834f, 
    -0.07764971f, 0.00462627f, 0.02284223f, -0.15475900f, 0.07749103f, -0.01118897f, 0.07304985f, 0.17211859f, 
    0.06782807f, -0.00792441f, -0.03994961f, 0.11473054f, 0.07682611f, -0.07373637f, -0.05739298f, -0.18168065f, 
    -0.06086868f, -0.15760359f, -0.07901784f, -0.00424494f, 0.06918646f, 0.00171563f, -0.14562802f, 0.08530280f, 
    0.10089165f, 0.08982862f, -0.03569656f, -0.07644144f, 0.07717143f, 0.07791799f, 0.01338455f, -0.03486317f, 
    0.02020980f, 0.04312726f, -0.03001494f, -0.02131491f, 0.20498307f, 0.06256700f, 0.30131659f, -0.24424157f, 
    -0.02381152f, 0.10477410f, 0.09535467f, 0.19169641f, -0.09311847f, 0.05990514f, 0.01455038f, -0.06273828f, 
    0.04400828f, 0.06603447f, 0.03334722f, 0.12400193f, 0.04468497f, 0.18903603f, -0.02852247f, 0.01952703f, 
    -0.01894917f, 0.05065419f, -0.04561997f, 0.04337462f, -0.07697994f, 0.02189647f, -0.01559302f, 0.01445496f, 
    0.01938150f, 0.09997468f, 0.16030900f, 0.01881361f, -0.02379366f, -0.02623048f, 0.01948259f, -0.12345488f, 
    0.15895760f, 0.09480704f, 0.06811846f, 0.03977477f, -0.12258868f, -0.08046351f, -0.04107621f, -0.09690555f, 
    -0.11926740f, 0.05204767f, 0.14516869f, -0.05350351f, -0.11939420f, -0.04428421f, 0.18309653f, -0.07267980f, 
    -0.15055524f, -0.14398488f, -0.00558218f, 0.08147010f, 0.10780647f, 0.07149354f, 0.05787911f, 0.05484109f, 
    0.00659165f, 0.07659440f, 0.21565650f, -0.00466233f, 0.08831753f, -0.21834929f, 0.20127176f, -0.03315680f, 
    0.02369281f, -0.15622561f, 0.09154351f, 0.18363982f, 0.18602929f, 0.06171613f, 0.00030847f, -0.04206124f, 
    -0.06572503f, -0.08874100f, 0.04334711f, 0.04897809f, 0.08339550f, 0.01810253f, 0.10383078f, 0.00587917f, 
    -0.17790847f, 0.17002860f, 0.12868229f, -0.03724427f, -0.05597151f, -0.03484271f, -0.05936668f, 0.02889923f, 
    0.15233557f, 0.10743307f, 0.21690787f, 0.05755087f, 0.46152908f, 0.17715859f, 0.24404094f, -0.15097748f, 
    -0.14442240f, -0.02636193f, 0.05242034f, 0.14683294f, -0.11280834f, 0.05281427f, -0.01641969f, -0.11169251f, 
    -0.38781750f, -0.14434709f, -0.03015845f, 0.25819311f, 0.03037652f, -0.01013688f, -0.04513772f, -0.09454993f, 
    0.12078792f, 0.19770437f, 0.10319587f, 0.02250393f, -0.15653484f, 0.00288912f, 0.08808107f, 0.18879560f, 
    0.06718931f, 0.09504029f, 0.16755444f, -0.02540511f, -0.09020450f, 0.05280092f, 0.00155624f, 0.00556853f, 
    0.16691911f, 0.01047055f, 0.06219495f, -0.12386547f, -0.04149028f, 0.15440081f, 0.13513196f, 0.00979897f, 
    0.13223489f, 0.12474448f, -0.10299388f, 0.00325535f, -0.08179721f, 0.10246161f, -0.02344047f, -0.24056432f, 
    -0.20372334f, -0.27068239f, -0.15382734f, -0.09641182f, 0.09871429f, -0.14733155f, -0.00918228f, 0.05698181f, 
    0.34209436f, 0.02267439f, -0.05086784f, 0.14603168f, -0.04188267f, 0.08157805f, -0.08447369f, 0.02235785f, 
    0.02821985f, -0.03806747f, 0.02419674f, 0.06445901f, 0.48730767f, 0.11045499f, 0.05666208f, -0.11661001f, 
    -0.03124054f, 0.01084596f, -0.00754487f, 0.12291826f, 0.12856770f, 0.01889795f, 0.02017324f, 0.19220723f, 
    -0.20280154f, -0.01664979f, 0.23843747f, 0.29895785f, -0.22606832f, 0.03430668f, 0.02913181f, 0.00532369f, 
    -0.00529436f, 0.01094966f, -0.02047920f, -0.05710813f, -0.07053551f, 0.00934852f, 0.35646391f, 0.17420886f, 
    0.01315796f, -0.09664275f, -0.05738707f, 0.01831082f, -0.00279248f, -0.00137654f, -0.01170337f, 0.11890399f, 
    -0.19265029f, -0.03911053f, 0.01526978f, 0.03524620f, -0.02028071f, 0.16525812f, 0.13148846f, -0.07551902f, 
    -0.00981532f, 0.01666990f, -0.04851690f, -0.05814173f, -0.06093635f, 0.02982413f, -0.02159140f, -0.14255854f, 
    0.06814868f, -0.01610304f, -0.04789391f, 0.05400830f, -0.09959841f, 0.06188091f, 0.12771033f, 0.06190398f, 
    -0.20545709f, 0.07095417f, 0.18713777f, -0.00816583f, -0.00308646f, -0.19959529f, -0.01472893f, -0.03458925f, 
    -0.02018611f, 0.00590647f, 0.05367497f, -0.01650967f, 0.05738879f, 0.04460551f, -0.00520587f, -0.22385113f, 
    0.10190904f, -0.02525531f, -0.07771029f, -0.02301244f, 0.19907056f, -0.04523155f, 0.16210659f, 0.20417674f, 
    -0.06444027f, 0.03284743f, -0.00851408f, 0.00936314f, -0.06580761f, -0.08117114f, -0.02259412f, 0.08515708f, 
    -0.06461937f, 0.12594013f, -0.00997342f, 0.15820692f, 0.09589556f, 0.06494441f, 0.06747933f, -0.04053383f, 
    0.00306291f, -0.03535744f, -0.03183493f, -0.03701811f, -0.06848783f, -0.02465325f, 0.01378573f, -0.09111320f, 
    0.09400042f, 0.07003848f, -0.00600130f, -0.00433329f, -0.09072650f, -0.10876711f, -0.06404970f, -0.02952796f, 
    -0.02271093f, -0.12297992f, -0.03279484f, -0.01349832f, -0.32794830f, 0.09058578f, 0.21901050f, 0.09471643f, 
    0.13708225f, -0.01514377f, -0.03131274f, 0.08425566f, -0.02768966f, -0.01060298f, 0.02793164f, -0.04286494f, 
    0.08534051f, 0.08346891f, 0.09644978f, 0.03541642f, 0.03229672f, -0.00090078f, 0.03733167f, -0.05539830f, 
    0.12160162f, 0.09227845f, -0.06753126f, -0.04064686f, -0.05237169f, -0.11261322f, 0.54245347f, -0.08755017f, 
    -0.07044425f, 0.12770034f, -0.00860617f, 0.28871506f, 0.09726889f, 0.01246297f, -0.01117886f, -0.12120798f, 
    -0.33137837f, -0.15995629f, 0.28464887f, 0.14190120f, -0.07791577f, -0.07784816f, -0.07132693f, 0.08909489f, 
    0.06552076f, -0.12310121f, -0.18120760f, 0.04477194f, -0.22552292f, -0.09470565f, -0.02687781f, 0.34693018f, 
    0.10645626f, 0.01737772f, 0.03010688f, -0.11342053f, 0.20536736f, 0.10655182f, 0.04625716f, 0.20679331f, 
    0.01203237f, -0.03321812f, -0.01043102f, 0.05182299f, 0.04980270f, -0.00014205f, 0.13028066f, 0.06446727f, 
    -0.08496562f, 0.00742692f, -0.01711076f, 0.03746147f, 0.14892311f, -0.04828807f, 0.12515393f, -0.03681926f, 
    -0.05347645f, -0.00887074f, 0.24387193f, 0.04219449f, -0.04298488f, -0.00883462f, -0.11511464f, -0.05778366f, 
    -0.06436624f, -0.14587754f, -0.02213395f, -0.14330937f, -0.07878407f, -0.02421879f, 0.05752758f, 0.11387166f, 
    0.00276882f, -0.00502116f, 0.05470792f, -0.07522446f, 0.16840646f, -0.31033850f, 0.00409326f, -0.43299675f, 
    -0.10481760f, -0.00636363f, -0.01393772f, 0.08175843f, 0.12731253f, 0.06647637f, 0.17171340f, 0.00321866f, 
    -0.07858881f, 0.13527595f, -0.17531829f, -0.07466785f, 0.06144940f, 0.02212133f, 0.07418043f, 0.00857537f, 
    0.14864500f, 0.03620775f, 0.03631601f, 0.01883448f, -0.09704563f, -0.03094512f, 0.31350958f, -0.18361163f, 
    0.06618782f, -0.02358359f, -0.04738633f, 0.00917286f, 0.01274968f, -0.08083517f, 0.02431642f, 0.00006966f, 
    0.39094040f, -0.20455748f, -0.07196055f, -0.16239598f, -0.08551555f, 0.00335437f, -0.09641150f, -0.10110609f, 
    0.12144691f, 0.04284808f, 0.03327769f, 0.00352138f, 0.27826399f, -0.09479795f, -0.02381923f, -0.02319169f, 
    0.05753578f, -0.06988636f, 0.04619722f, -0.02034748f, 0.07522061f, 0.08059443f, 0.12334260f, 0.01942928f, 
    -0.18959560f, 0.09640257f, -0.46849722f, 0.18809503f, 0.02694745f, -0.01562445f, 0.19782761f, 0.04552177f, 
    0.07500028f, 0.02923389f, -0.08298951f, 0.07466791f, -0.07702529f, -0.04833373f, -0.00222576f, -0.05689568f, 
    -0.11025199f, 0.03883486f, -0.06447218f, 0.09859914f, -0.07184740f, -0.07434511f, 0.04191684f, 0.03172209f, 
    -0.08982413f, -0.27195764f, 0.32984519f, -0.27466163f, -0.12362969f, 0.12681909f, -0.28584635f, -0.09295740f, 
    -0.04434667f, -0.07911848f, 0.06030449f, -0.03669761f, 0.41619000f, -0.24367470f, -0.42269054f, -0.21083450f, 
    0.00136818f, -0.07109731f, 0.11331750f, -0.06505445f, 0.09599727f, -0.01574396f, -0.10909864f, 0.02113731f, 
    0.03387387f, 0.11204538f, 0.13332604f, -0.02799273f, -0.12209032f, 0.08092899f, 0.02497738f, 0.08894394f, 
    0.06675425f, -0.03174638f, 0.02473766f, -0.04950022f, 0.08377841f, 0.03762881f, 0.14107497f, -0.22065476f, 
    0.13784373f, 0.01788961f, 0.21656860f, -0.05049548f, -0.02233600f, -0.03439426f, -0.09901146f, -0.10459840f, 
    -0.15158625f, 0.08593071f, -0.37144628f, 0.02662269f, 0.13607638f, -0.14346826f, 0.14332768f, -0.05221285f, 
    0.02531324f, 0.01215835f, -0.01665170f, 0.01324170f, 0.05088047f, -0.16972785f, -0.26272109f, -0.32645920f, 
    0.05443493f, 0.19991446f, -0.03507623f, 0.04356990f, 0.18576160f, 0.07590624f, 0.08249436f, 0.06071815f, 
    -0.07606376f, -0.04626508f, 0.18068582f, 0.00707104f, -0.03694018f, 0.01008120f, -0.00340217f, -0.04030981f, 
    -0.13307330f, -0.09508561f, 0.03100770f, -0.00674533f, 0.05085807f, 0.16870609f, -0.05974489f, 0.25772986f, 
    -0.03046560f, -0.13202983f, 0.14746624f, -0.01558621f, 0.01830903f, -0.11074418f, -0.06830712f, -0.04488502f, 
    0.29123887f, 0.39629236f, 0.09714494f, -0.00443913f, 0.15125759f, 0.07419248f, 0.03449573f, -0.01264943f, 
    0.01707649f, -0.03594404f, -0.01022348f, 0.09895753f, 0.33614522f, -0.27011254f, -0.10698639f, 0.00266491f, 
    -0.03074452f, -0.05235554f, 0.13199431f, -0.16235833f, 0.14358103f, 0.08621268f, -0.00933048f, 0.00113115f, 
    -0.06793338f, 0.15038741f, 0.07386416f, 0.07462496f, 0.18488047f, 0.08617523f, -0.06841358f, -0.13492936f, 
    -0.14362712f, -0.06804990f, -0.14730404f, 0.08103267f, 0.19514415f, 0.01307887f, -0.08479635f, -0.37081033f, 
    0.06608380f, 0.06090023f, 0.16033980f, 0.16318212f, 0.00788064f, 0.04784367f, -0.07346670f, -0.02229388f, 
    0.22834243f, -0.04236050f, -0.04875601f, 0.08860658f, 0.04901280f, -0.10249276f, 0.07495154f, 0.04533403f, 
    0.14745194f, -0.00871158f, 0.03524175f, 0.00763091f, -0.20179553f, -0.04733580f, -0.20605187f, 0.00483060f, 
    0.02468154f, -0.01900598f, 0.14341810f, 0.04397912f, 0.02986515f, 0.07799072f, 0.14382502f, 0.02496900f, 
    0.03723283f, -0.11461008f, -0.03374857f, -0.22899491f, 0.10429833f, 0.20713647f, 0.01025621f, 0.11511944f, 
    0.13576831f, 0.00174164f, 0.09314218f, 0.04677542f, 0.34551600f, -0.16977471f, -0.03950271f, 0.11953492f, 
    -0.07721275f, -0.11882300f, -0.03195844f, -0.21947479f, 0.08617579f, 0.03741241f, 0.04825201f, 0.04570260f, 
    0.18054074f, -0.02733731f, -0.21250552f, -0.32311189f, -0.07305761f, -0.00937779f, -0.03943779f, 0.16273604f, 
    -0.02557992f, 0.12690671f, 0.06777105f, 0.03341050f, 0.24019395f, 0.23529501f, 0.07810099f, -0.07073977f, 
    0.03488482f, 0.20693952f, 0.04992099f, -0.03830907f, 0.10256451f, 0.01731376f, 0.16648935f, -0.04537359f, 
    0.05585167f, 0.08205863f, 0.10308289f, 0.12313523f, -0.11790428f, -0.02013446f, 0.01237753f, -0.04408995f, 
    0.05345467f, 0.08868544f, -0.06159820f, 0.00601923f, 0.32800171f, -0.01998069f, 0.09662914f, -0.24217114f, 
    0.03874096f, -0.09775060f, 0.22196423f, 0.09886909f, 0.02881303f, 0.04724202f, 0.03679266f, 0.01847293f, 
    0.30009961f, 0.32250145f, -0.19222306f, -0.06632167f, 0.19718404f, -0.07454281f, 0.13194461f, 0.02514970f, 
    -0.01742633f, 0.01356408f, 0.05040644f, 0.00334659f, -0.17330810f, 0.19357924f, 0.10261856f, 0.08077960f, 
    -0.05086402f, 0.13051647f, 0.06997543f, 0.13789004f, -0.04792110f, -0.11755903f, -0.09930393f, -0.10142642f, 
    -0.13653113f, 0.01944384f, -0.06487702f, -0.07584348f, -0.11817027f, -0.00245511f, 0.01401425f, -0.18535525f, 
    0.01899041f, -0.01000981f, 0.01704017f, -0.01257332f, 0.06168465f, 0.16991228f, -0.36239293f, 0.07735837f, 
    -0.02078833f, 0.05168167f, 0.01819189f, 0.03974402f, 0.12271240f, -0.07090293f, -0.03968572f, -0.05844210f, 
    -0.03317809f, 0.09246217f, 0.04995451f, -0.04581291f, 0.07171872f, -0.07472461f, -0.09278426f, -0.10774292f, 
    -0.04509239f, 0.04270767f, 0.02349328f, 0.02205588f, 0.02601241f, 0.00579539f, -0.12721753f, 0.23277371f, 
    0.10261854f, -0.05948756f, -0.04061601f, 0.14697464f, 0.03457493f, 0.03789435f, -0.00380491f, 0.03744717f, 
    0.01196488f, -0.00857449f, 0.01829248f, 0.08048175f, -0.13785943f, -0.04176290f, 0.06558019f, -0.00035100f, 
    0.14668493f, 0.02031809f, 0.11271331f, 0.10608062f, -0.00067085f, -0.10916660f, -0.01333223f, -0.00098028f, 
    -0.03341059f, 0.08717539f, 0.03842496f, 0.00473859f, 0.02000888f, 0.03019237f, 0.11496036f, 0.10862230f, 
    -0.31322342f, -0.05578938f, -0.20558146f, -0.20030190f, -0.06498416f, 0.02560574f, -0.06910352f, 0.00015019f, 
    0.14636318f, 0.05028763f, 0.06611768f, -0.08767389f, 0.29549113f, -0.02438176f, 0.06526667f, 0.14304410f, 
    0.02470454f, 0.02989495f, -0.11936560f, 0.13513555f, 0.01101275f, -0.07359476f, -0.04070149f, -0.11012463f, 
    0.04524469f, -0.03847624f, 0.11534750f, -0.12516169f, -0.06048001f, 0.09960090f, 0.09817982f, 0.04517854f, 
    -0.01680597f, 0.15415946f, 0.06266592f, 0.03219291f, -0.06487003f, 0.19077085f, 0.12565215f, 0.06272577f, 
    0.06414358f, -0.04400720f, -0.02619899f, 0.01570653f, -0.13685840f, -0.03064309f, 0.04100914f, -0.04245515f, 
    -0.14645238f, 0.10330569f, -0.25763535f, -0.13255896f, 0.11825713f, -0.07619511f, 0.17239755f, -0.11076437f, 
    0.08453552f, -0.04010071f, 0.00612854f, 0.10623758f, 0.30009776f, -0.22520697f, 0.05722935f, 0.11154146f, 
    -0.01238297f, 0.10227477f, 0.07876674f, 0.22541770f, 0.09836023f, 0.03482705f, -0.01409054f, 0.00585448f, 
    0.17795078f, 0.06006211f, 0.05038587f, 0.02824767f, 0.10951150f, -0.03498087f, 0.01558113f, 0.10873876f, 
    -0.04631736f, 0.02860809f, -0.04309316f, -0.28035879f, -0.02236479f, -0.01474424f, -0.10827106f, -0.03651398f, 
    0.03394174f, 0.06170293f, 0.13675292f, -0.06121286f, 0.14112443f, -0.04904736f, 0.05263949f, 0.15692209f, 
    -0.10122683f, -0.09805343f, 0.14679670f, -0.03313264f, -0.04432920f, 0.02733181f, 0.13590263f, 0.06906919f, 
    0.02050383f, 0.02212316f, 0.01980623f, 0.08412969f, -0.05452621f, -0.06051932f, -0.23677450f, -0.04132036f, 
    0.01391481f, 0.01092733f, 0.01478317f, 0.15143676f, -0.14061601f, -0.02164373f, -0.03414572f, -0.19493167f, 
    0.14788252f, 0.21192196f, 0.01520786f, 0.25258568f, -0.08875560f, -0.06599151f, 0.03740049f, -0.10712714f, 
    0.00007938f, -0.00563920f, -0.03708161f, 0.03476643f, 0.08243544f, 0.06688438f, 0.11871154f, 0.16428483f, 
    -0.16039029f, 0.02348448f, -0.07548032f, -0.02436268f, -0.04291791f, -0.09267407f, -0.17616004f, 0.00198136f, 
    0.08610896f, -0.01200586f, 0.10303330f, 0.22022100f, 0.05438340f, 0.18262774f, 0.04408864f, -0.01205994f, 
    -0.06762919f, -0.02047452f, -0.01797652f, 0.01193133f, 0.05633878f, -0.08955289f, -0.02712319f, -0.11393800f, 
    -0.11900004f, -0.05376063f, -0.06977822f, -0.05722556f, -0.00065399f, 0.00081057f, 0.03132535f, -0.04638847f, 
    0.15562521f, -0.00963049f, 0.21587017f, 0.21844770f, 0.19786446f, 0.10531633f, 0.02458882f, 0.12548149f, 
    0.07005569f, -0.01781222f, 0.11075102f, 0.05240938f, 0.04363012f, 0.29801327f, 0.00299327f, -0.01896541f, 
    0.02490734f, 0.08667953f, -0.07915455f, -0.12766202f, -0.02547090f, -0.01678791f, -0.01965113f, -0.17862546f, 
    0.25070569f, 0.01751758f, 0.23021816f, 0.02273388f, -0.09996446f, 0.00584473f, -0.00215415f, -0.07559136f, 
    -0.02719987f, -0.02526328f, -0.10842965f, -0.24370389f, -0.14660385f, -0.21312767f, 0.06831852f, -0.03983004f, 
    -0.09288543f, 0.02759193f, -0.01515635f, 0.16084050f, -0.32439652f, -0.15287031f, -0.22477916f, -0.31318897f, 
    -0.04188880f, -0.09996972f, -0.22122036f, 0.13319013f, -0.03646014f, 0.05633419f, 0.10727978f, 0.05372447f, 
    0.18566595f, -0.14454825f, 0.15403438f, -0.00327380f, -0.00495383f, 0.00381598f, -0.09122527f, 0.00245433f, 
    -0.14247459f, -0.07787991f, -0.05676997f, -0.04040213f, 0.08784478f, 0.12143870f, -0.07374359f, 0.04076106f, 
    -0.00296290f, -0.12022270f, -0.08101702f, 0.05823385f, 0.14321084f, 0.01492377f, 0.02261521f, 0.20093995f, 
    -0.17219019f, -0.00836362f, 0.00798346f, -0.00039626f, -0.17671770f, 0.05287707f, 0.09305281f, 0.06108505f, 
    0.08273859f, -0.05157603f, 0.00360297f, 0.10727757f, -0.21374550f, -0.03057107f, 0.01905460f, -0.03477631f, 
    0.14243488f, 0.12935716f, 0.05258677f, 0.19081652f, -0.05204821f, -0.07793558f, -0.10750712f, -0.07856546f, 
    0.09981328f, 0.03802245f, -0.09774571f, 0.15465736f, 0.22252929f, 0.18958761f, 0.01356150f, 0.04801081f, 
    -0.11030168f, 0.13102385f, 0.02290449f, 0.03387252f, -0.00575700f, 0.06514872f, -0.02885961f, 0.06609330f, 
    0.03106643f, -0.14296433f, 0.01337388f, 0.09028111f, -0.05958056f, 0.14969514f, 0.05439539f, -0.10870843f, 
    -0.08827046f, -0.01935453f, -0.01177300f, 0.10638143f, -0.02192125f, 0.13104026f, 0.14822200f, -0.13440502f, 
    0.07831231f, 0.03946531f, -0.01642565f, 0.12864307f, -0.13214751f, -0.00525716f, -0.24292123f, -0.19076915f, 
    0.00154091f, -0.01115881f, -0.04837206f, -0.08142237f, 0.11229681f, 0.08595093f, 0.09868092f, 0.03132659f, 
    0.19874632f, 0.15206683f, 0.14120702f, 0.14474013f, -0.02653721f, -0.10724916f, 0.14651068f, 0.03014780f, 
    -0.09778875f, -0.03590937f, -0.02331894f, -0.05101296f, 0.05932180f, 0.06870802f, 0.01332316f, 0.12220739f, 
    -0.55828649f, -0.62787491f, -0.10811982f, 0.06026057f, 0.13712826f, 0.07123046f, 0.03484509f, -0.01838863f, 
    0.00054317f, -0.12262845f, 0.06224583f, 0.04600801f, 0.10835530f, 0.22458790f, -0.08400117f, -0.13167644f, 
    0.03742824f, 0.13112371f, 0.03202178f, 0.15487221f, 0.21593420f, 0.06383879f, 0.01090127f, 0.00383432f, 
    -0.13244466f, -0.07084588f, -0.03794294f, 0.32506520f, 0.03467000f, -0.08451831f, -0.13831529f, -0.06422403f, 
    -0.09367545f, 0.00164064f, 0.19185206f, 0.15951863f, 0.08566389f, -0.28604704f, 0.18717191f, -0.04383372f, 
    -0.00890119f, 0.04125003f, 0.03348164f, 0.31679225f, 0.01903683f, -0.02594015f, -0.07530186f, 0.00556843f, 
    -0.14935346f, -0.01590887f, 0.28083384f, 0.11451539f, -0.06716205f, -0.03247850f, -0.11972424f, 0.16122495f, 
    0.05882987f, 0.20961840f, 0.04688433f, 0.01517085f, 0.01502145f, 0.16582312f, 0.05341904f, -0.01561996f, 
    -0.01045614f, -0.08647257f, 0.02711396f, 0.20615265f, 0.06473257f, 0.05619726f, 0.04358183f, 0.14339842f, 
    -0.09331916f, 0.32579082f, -0.19665207f, -0.17838122f, 0.04583720f, 0.11064168f, -0.08866843f, -0.12616429f, 
    0.03894226f, 0.18886338f, -0.03420515f, -0.18548457f, -0.28428835f, -0.23567456f, -0.37050843f, -0.04033276f, 
    0.17320588f, 0.08049238f, 0.02841674f, -0.03778529f, 0.00510267f, 0.00890807f, -0.02360011f, -0.00878245f, 
    0.90412366f, 0.19852397f, -0.28551972f, 0.32537240f, -0.27374217f, 0.01278247f, -0.03781164f, 0.26404458f, 
    -0.00597386f, 0.03952188f, 0.08456163f, 0.00562163f, -0.23625079f, 0.10962351f, 0.16839316f, -0.22046997f, 
    -0.03154236f, 0.04238556f, 0.00093926f, -0.07788119f, 0.04019643f, -0.08933580f, 0.18614249f, -0.05850843f, 
    0.24122967f, -0.10373314f, 0.17874841f, 0.27339005f, -0.00329163f, -0.07959466f, -0.06921086f, 0.05308197f, 
    0.20934604f, -0.02013198f, 0.04919486f, 0.04053767f, -0.05057819f, -0.05685909f, 0.01457150f, 0.13026810f, 
    0.00441660f, -0.04221606f, 0.11292887f, 0.01922227f, 0.06876901f, -0.07187335f, -0.10896681f, -0.10213888f, 
    0.01887494f, 0.28449559f, -0.13115880f, 0.11670975f, 0.07533611f, 0.02295189f, -0.00248149f, 0.03162152f, 
    0.15857010f, 0.06725949f, 0.09646843f, 0.23562810f, -0.27711031f, 0.13019510f, 0.23074697f, 0.19992417f, 
    -0.02326095f, 0.02944968f, 0.04156367f, 0.06374062f, 0.00979386f, 0.02402619f, 0.00362097f, 0.01319319f, 
    -0.39142942f, -0.22580571f, -0.13575020f, -0.44450375f, 0.07745901f, -0.00820854f, 0.13399671f, -0.01893213f, 
    -0.09838238f, -0.11077370f, 0.01476973f, -0.02698785f, -0.00237615f, -0.22329681f, -0.19214436f, -0.06890496f, 
    0.01804144f, -0.04652269f, 0.02703488f, -0.09251851f, 0.04983213f, -0.03648033f, 0.01280181f, -0.08138476f, 
    -0.28787717f, -0.11253173f, 0.06359576f, -0.05788452f, 0.20430349f, 0.04254869f, 0.10116822f, 0.09174862f, 
    0.08541954f, -0.12673841f, 0.00238791f, 0.06903715f, -0.02622408f, 0.17967618f, 0.34141889f, -0.14391732f, 
    -0.02375181f, -0.13837670f, 0.09769361f, 0.14637913f, -0.00786161f, 0.05221419f, 0.08994599f, -0.03184234f, 
    -0.00161696f, 0.01044900f, -0.02023816f, 0.14778294f, 0.16255143f, 0.21961729f, -0.03192654f, 0.07617482f, 
    0.08131385f, 0.06259038f, -0.02636166f, 0.10208184f, -0.27187905f, -0.21672620f, -0.12630028f, 0.34631935f, 
    -0.21697517f, -0.05231114f, 0.07234544f, -0.02962106f, 0.05805211f, 0.02766045f, -0.02668936f, -0.04931276f, 
    -0.14780270f, 0.07773817f, -0.23160143f, -0.24662925f, -0.00841468f, -0.02558360f, -0.00572515f, -0.00004717f, 
    -0.10331485f, -0.02349445f, 0.19294691f, -0.08101993f, -0.06134737f, -0.05281548f, -0.27272657f, 0.00976708f, 
    -0.06588612f, 0.16516383f, 0.14429672f, 0.01737657f, 0.14071502f, 0.13192904f, -0.07759108f, -0.02042896f, 
    0.08383843f, 0.09314633f, 0.22821584f, 0.08433813f, 0.00906921f, 0.11445397f, 0.11760277f, 0.06015917f, 
    0.04009763f, -0.05237774f, 0.09012851f, 0.06695360f, 0.02839599f, 0.11045603f, 0.31567410f, -0.20734212f, 
    -0.11853980f, -0.23731264f, -0.11853602f, -0.14135833f, 0.06268949f, 0.07725737f, 0.07080462f, -0.00348240f, 
    -0.10596707f, 0.05103841f, -0.13721660f, -0.27586454f, 0.17753024f, 0.16215517f, 0.04823120f, 0.13207325f, 
    0.10296289f, -0.00141252f, 0.15718488f, -0.03948828f, -0.07117990f, -0.22619510f, -0.16307585f, -0.05211805f, 
    0.11046116f, 0.03615885f, 0.15982217f, -0.08541244f, 0.02212662f, -0.12216295f, -0.04651724f, -0.05648927f, 
    0.18950880f, -0.04218975f, -0.00232001f, -0.15939073f, 0.03121692f, 0.02289390f, -0.08033004f, 0.05144164f, 
    0.12445574f, 0.07192523f, 0.06078591f, 0.10724924f, -0.08470777f, 0.20743166f, 0.12423379f, -0.28053832f, 
    0.18746825f, -0.04287250f, 0.03253665f, 0.04208767f, 0.13714574f, 0.06851725f, -0.08361157f, -0.02172717f, 
    -0.15907031f, 0.04544741f, -0.00086923f, -0.26513734f, 0.14672765f, -0.02886386f, -0.03847488f, -0.17914438f, 
    -0.18996547f, -0.12901832f, -0.09756320f, 0.08125535f, -0.17094257f, 0.09962346f, 0.09906467f, -0.03144744f, 
    -0.03334038f, -0.00791270f, 0.14669588f, 0.18896887f, 0.12448405f, -0.05015971f, 0.05239179f, -0.03512293f, 
    -0.22037685f, 0.00937965f, 0.04924430f, -0.26338801f, -0.01258788f, 0.05465609f, 0.13476136f, -0.00514043f, 
    0.05154448f, -0.10312665f, 0.11202826f, 0.02855670f, -0.09165722f, 0.20458256f, -0.34973261f, -0.12290481f, 
    0.08346122f, -0.15053329f, -0.25348386f, -0.24775794f, 0.13036828f, 0.15311745f, 0.03073346f, -0.07848101f, 
    0.02942750f, -0.01652737f, 0.00318022f, -0.04323428f, -0.01795368f, 0.03632243f, -0.03794382f, 0.00737134f, 
    0.04228200f, -0.01819397f, -0.02836970f, -0.04302940f, 0.00793192f, 0.01783931f, -0.00602861f, 0.03940076f, 
    -0.03211508f, -0.01051346f, -0.01954407f, 0.04282822f, 0.00091868f, 0.02782281f, -0.03548832f, 0.01789219f, 
    -0.03485644f, 0.00364247f, 0.00999163f, 0.02977569f, -0.02481431f, 0.04101885f, -0.00673809f, -0.04193427f, 
    -0.05277905f, 0.00871160f, -0.01397306f, -0.04798761f, -0.04720235f, -0.04789691f, -0.02630587f, -0.04918470f, 
    -0.02707900f, -0.02645474f, -0.00754955f, 0.01579506f, -0.01013388f, -0.01105002f, 0.00595672f, -0.05000969f, 
    -0.03599511f, 0.04965716f, -0.04015532f, -0.02019797f, -0.04343017f, -0.05470809f, -0.04101595f, -0.03970034f, 
    0.00884772f, 0.03500910f, -0.04210124f, -0.03195490f, 0.03531981f, 0.05039650f, -0.04897588f, -0.04726876f, 
    0.00835693f, -0.01095811f, -0.00230604f, -0.03853750f, 0.04248773f, -0.02357521f, 0.04309096f, 0.04331033f, 
    0.03512683f, 0.03287799f, 0.00924013f, -0.05143645f, -0.04371617f, -0.01807132f, 0.02642709f, -0.00946869f, 
    -0.04683803f, 0.02557324f, -0.03966868f, -0.02069642f, -0.01204831f, -0.02946529f, 0.03679250f, -0.01793945f, 
    0.01664477f, 0.04209785f, 0.02488181f, 0.02958751f, 0.02463267f, -0.03039776f, -0.01534203f, 0.00601263f, 
    0.03885039f, -0.01099036f, -0.00957378f, -0.00903396f, -0.00614238f, -0.04562594f, 0.03020504f, 0.03239360f, 
    -0.02507555f, -0.03017517f, -0.05317791f, 0.03299365f, 0.03750535f, 0.04085546f, 0.02103954f, 0.03882322f, 
    0.01020537f, 0.01884959f, 0.01246015f, -0.01643319f, 0.00055784f, 0.03941660f, -0.04598963f, -0.03889010f, 
    0.04997778f, -0.01494938f, -0.01230123f, -0.02987972f, -0.00362247f, 0.03169290f, 0.04110275f, -0.04502202f, 
    -0.01185377f, -0.02104012f, 0.00986657f, -0.02695477f, -0.02291835f, 0.00786834f, -0.02836966f, -0.05078578f, 
    -0.02726517f, -0.00053402f, -0.01061495f, -0.03371987f, 0.02214840f, -0.02515145f, 0.01626872f, -0.01695015f, 
    -0.03897674f, -0.02252900f, -0.01913147f, -0.05511755f, -0.05086431f, -0.04501624f, -0.01937174f, 0.01123830f, 
    0.01298624f, 0.01158017f, 0.03902355f, 0.03792004f, 0.03817958f, 0.01098745f, -0.00956604f, 0.05007106f, 
    0.00784159f, 0.01192811f, -0.04490996f, -0.01825793f, -0.01581346f, -0.02327272f, -0.01675812f, -0.04337092f, 
    0.04454269f, -0.03098831f, -0.03223672f, -0.01379976f, -0.02188788f, -0.01051609f, 0.02758945f, -0.02299209f, 
    -0.01939441f, 0.04182124f, 0.04248307f, 0.02702804f, 0.01927272f, 0.01902518f, -0.03517883f, -0.01787225f, 
    0.00758042f, -0.00447259f, -0.04388459f, 0.04479187f, -0.02389831f, 0.02536737f, 0.02704815f, 0.01721431f, 
    -0.00605312f, 0.01234769f, -0.00735854f, -0.01129892f, 0.04180295f, -0.00862882f, -0.02747390f, 0.00881823f, 
    0.05091368f, -0.03885388f, 0.00529895f, 0.02198775f, 0.03051929f, -0.04053048f, -0.01566002f, 0.01146265f, 
    -0.00506319f, 0.03830989f, 0.00221032f, -0.03611721f, -0.00645557f, -0.04521839f, 0.02550139f, -0.02755463f, 
    0.02139841f, -0.01166673f, -0.04871558f, -0.01193605f, -0.02009225f, -0.04328012f, -0.04034581f, 0.00586551f, 
    0.02556782f, -0.04952421f, 0.03857250f, -0.01924164f, 0.02623977f, 0.03354831f, 0.04110926f, -0.03314728f, 
    -0.01898361f, -0.00408933f, 0.01446339f, -0.04656970f, 0.03706815f, -0.01929089f, -0.03546176f, -0.01909744f, 
    -0.02114009f, -0.03218280f, -0.03448211f, -0.00172548f, 0.01764893f, -0.01651827f, 0.01459204f, -0.02948229f, 
    -0.01135906f, -0.01664853f, 0.01517252f, -0.03780869f, 0.01305486f, -0.03882543f, -0.02377793f, -0.00130550f, 
    -0.01990288f, 0.03000828f, 0.04186372f, 0.00934437f, 0.00996670f, -0.03637579f, 0.04527171f, 0.00192199f, 
    -0.03883384f, -0.03649944f, -0.03786929f, -0.03038806f, -0.04132222f, 0.02391676f, -0.00280595f, 0.02723753f, 
    -0.03748110f, 0.03845982f, -0.02134867f, -0.04248418f, -0.03307119f, 0.00517993f, -0.05307179f, -0.00078400f, 
    -0.02078218f, 0.03038610f, 0.04004938f, 0.02047381f, -0.04989965f, -0.04860572f, -0.04990141f, -0.02535523f, 
    0.01534473f, 0.02454491f, 0.02037826f, 0.03222482f, -0.03264013f, 0.03301112f, 0.02645139f, 0.01335562f, 
    -0.05547673f, -0.04955311f, 0.00885321f, 0.03880803f, -0.01384747f, 0.00561979f, -0.03224950f, -0.01998591f, 
    -0.03974345f, 0.00081573f, 0.01272044f, 0.02060216f, -0.02990354f, 0.00946397f, -0.01559572f, -0.00558628f, 
    -0.04780374f, -0.01356713f, 0.00132945f, 0.02799601f, -0.01915461f, -0.00060545f, -0.02644477f, -0.04418278f, 
    0.05070462f, -0.01402758f, 0.00296486f, 0.02479723f, -0.03151450f, -0.04327159f, 0.04159756f, 0.00058312f, 
    0.01988988f, 0.01527432f, -0.01699700f, -0.02673372f, 0.04906573f, 0.01681821f, -0.02275547f, -0.03888806f, 
    -0.02168844f, -0.02425071f, -0.01526382f, -0.00916249f, -0.02856079f, -0.05100880f, 0.04710023f, -0.00789934f, 
    0.03942516f, 0.00813468f, -0.04711093f, -0.02086210f, 0.00077078f, 0.01220276f, 0.00410693f, -0.03624973f, 
    0.04221746f, -0.01924139f, -0.01763093f, 0.01955104f, -0.00131469f, -0.04741721f, 0.04454891f, -0.01174884f, 
    -0.05484166f, 0.00128214f, 0.04257422f, -0.00394092f, -0.04847067f, -0.03167112f, -0.04437486f, -0.01045441f, 
    -0.00891923f, -0.00375764f, -0.05179563f, -0.02739641f, -0.01350841f, 0.00723076f, 0.04001337f, 0.02261383f, 
    0.00751000f, 0.02475812f, 0.03502743f, 0.03833799f, -0.00394073f, 0.00076160f, -0.03778068f, 0.03858274f, 
    0.00509449f, 0.13288184f, -0.08567102f, -0.02680613f, -0.11131992f, -0.14592020f, 0.00891972f, -0.01857934f, 
    -0.02432948f, 0.03705539f, 0.04046774f, 0.03130628f, -0.12187047f, -0.21368513f, -0.00357954f, 0.07215796f, 
    -0.24380010f, 0.02346124f, -0.02427061f, 0.07241882f, -0.05101306f, -0.26316956f, 0.21274096f, -0.09580996f, 
    0.09551863f, -0.01881430f, 0.27794969f, 0.01837512f, -0.00095412f, -0.02275584f, -0.02341571f, 0.00311642f, 
    -0.08113844f, -0.03686653f, -0.02195450f, 0.02487358f, -0.06365304f, 0.21367240f, 0.14203040f, 0.02240893f, 
    -0.06325424f, -0.01400897f, -0.03572204f, -0.02413781f, -0.06027072f, -0.01738467f, 0.05216245f, -0.04980484f, 
    0.10464581f, 0.02369674f, -0.32971439f, -0.03315463f, 0.02121368f, 0.00547332f, -0.01845664f, -0.02037788f, 
    0.05098334f, 0.08389708f, -0.02347776f, -0.15411597f, 0.12725951f, -0.00084170f, -0.11607846f, -0.10540514f, 
    0.14199831f, 0.06069957f, -0.17839228f, 0.08438086f, 0.04366584f, -0.03503292f, -0.00476982f, -0.18602654f, 
    0.15418690f, 0.11712538f, -0.05058357f, 0.31770015f, -0.06882009f, 0.18219429f, 0.13702101f, -0.12331799f, 
    -0.05953021f, 0.08723643f, -0.19069491f, -0.04356440f, -0.01626197f, -0.03918305f, 0.09385699f, 0.00118653f, 
    0.03045012f, 0.00235837f, -0.05100281f, -0.04804071f, 0.01172439f, 0.09716471f, 0.05090069f, 0.04229557f, 
    -0.02869503f, -0.05074618f, 0.08700121f, -0.01128318f, -0.04961946f, 0.00214141f, 0.14198229f, 0.09373676f, 
    -0.03933855f, -0.21129967f, 0.09740773f, -0.04707852f, 0.16731064f, -0.11501349f, -0.15501283f, 0.25946137f, 
    0.13943648f, 0.10296401f, -0.04000730f, -0.03728995f, -0.07073191f, -0.04709654f, -0.01601257f, 0.02721255f, 
    0.06005505f, 0.12496844f, 0.29794732f, 0.09642211f, -0.08770187f, -0.06121204f, 0.08613006f, -0.04430614f, 
    0.04299368f, 0.07137936f, -0.02991441f, -0.02242349f, 0.00632086f, 0.20034656f, 0.06804709f, 0.11945971f, 
    0.02280396f, 0.18791206f, 0.09895039f, -0.14471276f, 0.00401959f, -0.06141138f, -0.02038833f, -0.00572013f, 
    -0.16888170f, -0.09619018f, 0.19223121f, -0.02164920f, -0.03768820f, 0.12774882f, -0.16460970f, 0.00634144f, 
    -0.09529806f, -0.04722179f, 0.01862182f, 0.07797901f, 0.13709334f, 0.02436875f, -0.22250623f, -0.23686999f, 
    0.10938016f, 0.09402912f, -0.01536521f, 0.03596807f, -0.10350060f, 0.04646739f, 0.01837227f, -0.07148292f, 
    -0.06680709f, 0.27951422f, -0.01659860f, 0.33449224f, -0.05259061f, 0.11635526f, -0.01091242f, 0.03736639f, 
    -0.00632819f, 0.11398771f, 0.01723230f, 0.07745288f, 0.13567626f, -0.00633122f, -0.03231798f, 0.17686440f, 
    0.05967977f, 0.03614970f, 0.03521696f, 0.02295702f, 0.05380668f, 0.04655818f, 0.23009588f, 0.14697520f, 
    0.30030009f, 0.27065045f, 0.12034374f, 0.00808990f, 0.22911547f, 0.24363287f, 0.17155851f, 0.20155232f, 
    0.04267020f, -0.01124221f, 0.07605065f, 0.05317132f, -0.09326303f, -0.05812000f, -0.35549322f, -0.04635561f, 
    0.09044373f, 0.07049913f, -0.00669064f, 0.01348257f, -0.07263350f, 0.03336570f, -0.08473588f, 0.00840335f, 
    -0.08597745f, 0.06675460f, 0.32803342f, 0.05540673f, 0.12247783f, -0.05779942f, -0.26172292f, -0.01443937f, 
    -0.09188350f, 0.00721551f, -0.10421512f, 0.05698205f, 0.14783460f, 0.08507588f, 0.33911696f, -0.14102487f, 
    -0.08976150f, 0.01082200f, -0.08435113f, 0.17132507f, -0.00800581f, 0.10249501f, 0.01877264f, -0.06338023f, 
    0.18200080f, 0.14729825f, -0.03229530f, 0.18115592f, -0.09142406f, 0.09104498f, 0.12720412f, 0.09529186f, 
    -0.01344218f, 0.00001236f, -0.06298298f, 0.09170098f, -0.00097814f, -0.05673562f, 0.02535156f, 0.10128022f, 
    0.01919993f, -0.01242425f, 0.14010127f, 0.01819924f, -0.14152476f, -0.06072888f, 0.03428644f, -0.02782353f, 
    0.03943779f, 0.01727889f, -0.05079677f, -0.16152029f, -0.10078668f, 0.15766646f, 0.09005935f, 0.12645313f, 
    0.23165722f, -0.14644429f, 0.24888402f, -0.16856849f, -0.00540725f, -0.11763526f, -0.15804392f, 0.06067695f, 
    -0.01835667f, -0.03402190f, -0.00214333f, 0.00673893f, -0.04688467f, -0.06569865f, -0.12809537f, -0.07045400f, 
    0.05511211f, -0.12921169f, 0.06509237f, 0.13579467f, -0.10578124f, -0.06168156f, -0.07406306f, 0.04088943f, 
    -0.12542792f, -0.06673473f, 0.06877803f, -0.07028104f, 0.30951744f, 0.30331293f, 0.00829842f, -0.06590820f, 
    0.14931872f, 0.03141192f, 0.15676142f, 0.03401113f, -0.06071743f, 0.13185558f, -0.02888845f, 0.01449207f, 
    -0.11475270f, 0.03777532f, -0.09712161f, 0.12877086f, 0.02873003f, 0.01629516f, 0.01396520f, -0.01601528f, 
    0.11609971f, -0.11134312f, -0.12842822f, 0.15824844f, 0.27105132f, 0.35058716f, -0.18485317f, 0.01885588f, 
    -0.09296022f, -0.03815213f, 0.01795802f, 0.17304729f, 0.06090127f, -0.05498552f, -0.06498748f, 0.12006558f, 
    0.22787285f, 0.19306062f, -0.02423643f, 0.13145214f, 0.05133935f, 0.07755011f, 0.03292175f, 0.03574754f, 
    0.10083240f, 0.07615923f, 0.07700936f, -0.05372829f, -0.07495803f, 0.15054959f, 0.20611881f, -0.02242732f, 
    -0.04905165f, -0.09772450f, 0.02792490f, 0.03700876f, -0.13204961f, -0.04967260f, -0.14611427f, -0.03484713f, 
    0.08713800f, 0.03689113f, -0.01590265f, 0.07763389f, -0.07153037f, 0.12305187f, -0.05989571f, -0.03224819f, 
    -0.11056904f, 0.05595254f, 0.01502013f, 0.04360859f, 0.16325404f, 0.09221996f, 0.03075195f, 0.25847423f, 
    -0.12735502f, -0.02783355f, -0.07543706f, 0.00388892f, -0.01246755f, -0.00176097f, -0.13504227f, 0.11767402f, 
    -0.00230633f, 0.06582561f, -0.13849756f, -0.10318142f, -0.07785638f, -0.22919731f, -0.04906441f, 0.08596947f, 
    0.10419602f, 0.04488204f, -0.02619554f, 0.15006576f, -0.02096500f, -0.03818952f, 0.15171248f, -0.30144456f, 
    -0.03701053f, 0.07532202f, -0.00182822f, -0.10148980f, -0.01016570f, 0.15185632f, 0.04037593f, 0.03096704f, 
    0.02632664f, -0.00928116f, -0.46386468f, -0.08240448f, 0.04527337f, 0.02912509f, -0.02997289f, -0.01997429f, 
    -0.05133648f, 0.18091148f, -0.04402297f, -0.05687333f, 0.09067509f, 0.13755593f, -0.08348326f, 0.04506797f, 
    0.16789404f, -0.02822052f, 0.00630225f, 0.03227076f, 0.12218980f, -0.00916606f, 0.01097994f, -0.07552773f, 
    -0.03348070f, -0.10068491f, 0.23464352f, 0.12528031f, 0.10774998f, 0.00390665f, 0.17609924f, -0.05303695f, 
    -0.05081831f, -0.09201419f, 0.03202606f, 0.01163516f, 0.22219101f, 0.00545422f, 0.16719788f, 0.35205707f, 
    0.11765364f, 0.08892599f, -0.05718972f, -0.17022957f, -0.03840765f, 0.00864830f, 0.05406127f, 0.06689829f, 
    0.08776680f, -0.29165751f, -0.12310367f, 0.06533906f, 0.12052084f, -0.03700578f, -0.03723840f, -0.11001561f, 
    0.07062586f, -0.13139845f, 0.05126829f, 0.14483178f, -0.22879781f, -0.04091883f, -0.00838866f, -0.17155066f, 
    -0.12786585f, -0.17553879f, -0.24189715f, -0.03215136f, 0.02890302f, 0.05138109f, 0.05542303f, 0.00640646f, 
    -0.44778261f, -0.18045972f, 0.26712543f, -0.14659326f, 0.11596762f, -0.10769672f, -0.18502219f, 0.01945627f, 
    0.12146001f, -0.01731519f, 0.07457665f, -0.02529710f, 0.32366279f, 0.17394519f, -0.00516424f, 0.05635604f, 
    0.03783157f, 0.04064241f, 0.13878411f, -0.13859858f, -0.01577467f, 0.02212024f, -0.05410524f, -0.17898482f, 
    -0.05933143f, 0.08150452f, -0.10277402f, -0.04586513f, -0.07166222f, 0.09857941f, -0.07236350f, 0.06037721f, 
    0.02104870f, 0.00417770f, -0.06948683f, 0.05579379f, 0.10135249f, -0.01892335f, 0.01072031f, 0.06696635f, 
    0.10756529f, -0.08928697f, -0.03208070f, -0.15044035f, -0.06533990f, -0.02326998f, -0.01158222f, -0.12120578f, 
    0.14094080f, -0.00419915f, -0.08742069f, -0.08736781f, 0.01590266f, 0.03785808f, -0.18727523f, -0.05776280f, 
    -0.01232459f, 0.01682585f, -0.11241323f, -0.15330911f, 0.32401419f, 0.21864611f, 0.05984845f, 0.35385919f, 
    0.01070282f, 0.09287266f, 0.13816306f, 0.08422066f, 0.05816410f, -0.10950003f, 0.08118808f, 0.06238048f, 
    -0.19761495f, -0.15941544f, 0.07316276f, -0.35649940f, -0.14228143f, -0.11217542f, -0.21323343f, 0.03171427f, 
    -0.01063900f, -0.06147890f, 0.21474692f, 0.03460336f, -0.25215098f, -0.25729236f, -0.18979582f, -0.36202359f, 
    -0.09563201f, -0.06822457f, -0.11408101f, 0.03974556f, -0.15014619f, 0.10010993f, 0.16492067f, 0.06466458f, 
    0.22862642f, 0.34241709f, 0.11849587f, 0.26915222f, -0.16552034f, 0.02264558f, -0.09464850f, -0.06592558f, 
    -0.07462963f, 0.01846074f, -0.06406610f, 0.04089339f, 0.10071967f, -0.00930065f, 0.18324561f, 0.16906270f, 
    0.03170803f, 0.02072604f, 0.09252476f, -0.04947456f, 0.01731795f, -0.09847400f, -0.01019329f, -0.00243908f, 
    0.17992502f, 0.24060942f, 0.05018860f, 0.05847776f, -0.04592198f, 0.08331208f, 0.02657300f, -0.02333804f, 
    -0.02549573f, -0.12096364f, 0.01157397f, 0.08777570f, 0.25541005f, 0.14168593f, 0.18022516f, -0.10376631f, 
    -0.06415815f, -0.17540728f, 0.06712233f, -0.04932950f, 0.03445337f, 0.01587748f, 0.07160492f, -0.03889918f, 
    0.36669418f, 0.23539664f, 0.30338451f, 0.27045929f, 0.09676640f, -0.03223920f, 0.15199326f, 0.03426043f, 
    0.01606667f, -0.07514487f, 0.21321008f, 0.08064567f, -0.01047262f, -0.05020554f, 0.16285671f, 0.06678566f, 
    0.00555518f, 0.02896867f, -0.25236756f, -0.03168241f, 0.11356276f, 0.01704721f, 0.18443230f, 0.20623331f, 
    -0.08539038f, -0.02280690f, -0.17261824f, -0.08612021f, 0.07746023f, -0.02411267f, 0.09748340f, 0.03352946f, 
    -0.01605914f, 0.20078452f, -0.02981908f, 0.06206991f, -0.15295427f, -0.26270318f, -0.31653923f, -0.03369768f, 
    -0.03248530f, 0.04489688f, 0.05067237f, 0.00878128f, 0.01079912f, 0.06017155f, 0.06120340f, 0.08865738f, 
    0.12767546f, 0.12727885f, -0.04671796f, -0.23610219f, -0.11796439f, 0.19939649f, 0.04603415f, -0.02611689f, 
    0.00320955f, 0.04014337f, 0.01980002f, -0.01795137f, 0.21342549f, 0.02553417f, 0.31114754f, 0.24434257f, 
    0.02585703f, 0.09460062f, -0.09420604f, 0.06070567f, -0.01178033f, 0.06397341f, -0.00793829f, -0.03164193f, 
    -0.23653400f, -0.27300116f, -0.16059636f, -0.45318893f, -0.01795390f, -0.04671120f, 0.07535070f, -0.02608998f, 
    -0.07791805f, 0.09185587f, 0.16117957f, 0.02869412f, 0.13314423f, -0.00317410f, 0.07166505f, 0.13809931f, 
    -0.10911774f, -0.10014272f, 0.07942796f, -0.02298358f, -0.12678036f, -0.00865200f, 0.01861838f, 0.05573696f, 
    0.19291437f, 0.13007531f, 0.00496105f, 0.13780114f, -0.14381176f, 0.13535234f, 0.07697479f, 0.25849241f, 
    -0.00155301f, 0.00557307f, 0.00397838f, 0.03592112f, 0.16771600f, 0.13027762f, 0.08185273f, 0.11180658f, 
    0.03196310f, -0.10012128f, -0.03819147f, 0.00468831f, 0.11114160f, 0.23048317f, 0.09078986f, 0.14420164f, 
    0.11165505f, 0.04090178f, 0.03388703f, 0.05783177f, 0.12136448f, 0.09932028f, -0.09567280f, -0.11836493f, 
    0.02239104f, -0.10094626f, 0.03100237f, -0.02806479f, -0.00284197f, -0.11051786f, 0.04305719f, -0.01434970f, 
    0.13322385f, 0.16763091f, 0.12314487f, 0.01191821f, -0.09443627f, -0.11281268f, 0.16760485f, -0.12671703f, 
    0.00461997f, -0.02625131f, -0.02464834f, 0.02334831f, -0.03183966f, -0.04786159f, -0.05210200f, -0.03421063f, 
    0.01922289f, 0.03311184f, 0.01662212f, -0.02098549f, 0.01460001f, 0.03284867f, 0.01590998f, 0.02604355f, 
    -0.03972407f, -0.03980752f, -0.00563633f, -0.04392308f, -0.05706780f, 0.00400544f, -0.01515261f, 0.01300162f, 
    -0.02383160f, -0.01479222f, 0.05737242f, 0.03067382f, -0.03963488f, -0.00724147f, -0.01388850f, -0.03946384f, 
    0.04903521f, 0.01904677f, 0.01101779f, -0.03351619f, 0.04949719f, -0.01387248f, -0.01703389f, -0.01122519f, 
    -0.03363740f, -0.03915215f, 0.02607856f, 0.03664853f, 0.00126218f, 0.02011516f, -0.03968225f, -0.04335016f, 
    -0.03697652f, 0.03949053f, 0.00220435f, -0.00843954f, 0.03163834f, 0.01231669f, 0.03290490f, 0.03353187f, 
    -0.01261038f, 0.02997063f, 0.00005174f, -0.03519151f, -0.02175366f, 0.04003062f, 0.03384640f, 0.01130849f, 
    0.00876454f, -0.01039912f, 0.01925454f, -0.04452843f, 0.03557937f, -0.02939714f, 0.03262785f, 0.00021443f, 
    0.01959171f, 0.01271913f, 0.01800793f, 0.04588353f, -0.02721030f, -0.02358814f, 0.01397828f, 0.01032668f, 
    -0.03774281f, 0.01161805f, 0.03287523f, -0.05583860f, 0.01825674f, -0.02543024f, 0.00301613f, 0.02837050f, 
    0.01216013f, -0.00702701f, -0.05399579f, -0.00475384f, 0.02908963f, -0.02550190f, 0.02039745f, 0.02805086f, 
    -0.01541003f, -0.03798557f, -0.01583625f, -0.03955377f, 0.03585479f, 0.02934006f, -0.00982756f, 0.00779360f, 
    0.00115860f, 0.04705949f, 0.01118877f, -0.03351228f, -0.04758476f, 0.02500339f, -0.03813118f, -0.02735473f, 
    0.04079829f, 0.03217644f, -0.01834360f, -0.00164577f, -0.01978126f, -0.04440914f, -0.04194534f, 0.00070827f, 
    0.02447778f, -0.00778285f, 0.03102870f, -0.05411800f, -0.03073267f, -0.04077501f, -0.04114098f, 0.02080821f, 
    -0.04892096f, -0.04096086f, -0.00889667f, -0.04493028f, -0.02415771f, 0.01543600f, -0.04636715f, -0.03269272f, 
    -0.00587217f, 0.00215421f, 0.04097289f, -0.04150947f, 0.01327171f, -0.02043938f, 0.00080428f, 0.03414706f, 
    0.00507264f, 0.02134137f, -0.00282055f, 0.00598561f, -0.01794275f, 0.00085499f, -0.01246568f, 0.03013591f, 
    0.02245811f, 0.04539071f, -0.05174177f, 0.01133688f, 0.00847460f, -0.05160309f, -0.02552488f, 0.00850180f, 
    -0.01067115f, 0.01125456f, 0.03814387f, 0.00547469f, -0.03218872f, -0.00085882f, 0.02627612f, -0.03594435f, 
    -0.03229438f, -0.03571732f, -0.04468760f, 0.01417613f, -0.00207071f, -0.01350981f, 0.00399550f, -0.00803329f, 
    0.03958825f, -0.04001842f, -0.00649782f, -0.00434980f, -0.03478672f, -0.00175066f, -0.00294267f, 0.01363336f, 
    -0.01554157f, 0.00823811f, 0.01885222f, 0.02567791f, -0.03177809f, 0.00838006f, 0.04310472f, -0.05141038f, 
    0.00006481f, -0.00574752f, 0.00313851f, -0.03237124f, -0.04172800f, 0.03055385f, 0.04287974f, 0.01538759f, 
    0.03237893f, -0.04741863f, -0.01518086f, -0.02220325f, -0.03247690f, 0.01443201f, 0.02010845f, -0.02857558f, 
    0.03052916f, -0.03360116f, 0.01847196f, -0.01639927f, 0.02029464f, 0.03448909f, -0.00682948f, -0.02931853f, 
    0.02225243f, -0.01480820f, -0.03771202f, 0.03234286f, -0.03903394f, -0.04421347f, 0.03180072f, -0.03424060f, 
    -0.03422738f, 0.03733701f, 0.03763743f, 0.03344094f, 0.03701392f, -0.00373271f, -0.02503035f, 0.01858559f, 
    -0.05093359f, 0.03924704f, -0.05407009f, -0.04157137f, -0.04108316f, -0.04783502f, -0.01041428f, -0.02951665f, 
    -0.00977961f, -0.01214044f, 0.00905034f, -0.02400248f, -0.02079806f, 0.03543599f, -0.02950066f, -0.04263268f, 
    0.00849016f, 0.00014678f, -0.02265935f, 0.01424034f, 0.02848385f, -0.01167858f, 0.04591303f, -0.04874228f, 
    0.02244014f, -0.05545517f, -0.06029496f, 0.01700574f, -0.04299689f, 0.01276078f, -0.01647093f, -0.05398490f, 
    -0.03909229f, -0.03408510f, 0.03134504f, -0.04380600f, -0.01679497f, 0.03387407f, 0.00446368f, -0.02639642f, 
    -0.01385489f, 0.01946452f, 0.03842262f, -0.04373165f, -0.02640671f, -0.03538806f, 0.01732013f, -0.02052176f, 
    -0.00454079f, 0.04071875f, -0.01151846f, -0.04280479f, -0.00414040f, -0.01193895f, -0.05541033f, -0.04084761f, 
    -0.02738871f, 0.01956944f, 0.03596505f, -0.02091022f, -0.02065302f, 0.02490912f, 0.01320514f, 0.00817945f, 
    0.01625458f, -0.02575342f, 0.03127111f, 0.02309008f, -0.01020611f, 0.00051169f, -0.04592035f, -0.05490343f, 
    -0.02220821f, -0.01930606f, -0.03552011f, 0.02848025f, 0.01130331f, -0.02062812f, 0.00353668f, 0.01006919f, 
    0.01528959f, -0.02174965f, 0.00697903f, 0.00372436f, 0.03979414f, -0.03328171f, -0.03054229f, -0.03047806f, 
    -0.03176776f, 0.03437429f, 0.02394056f, -0.05057419f, -0.00097829f, -0.04861073f, 0.03679052f, 0.01841294f, 
    0.02473642f, -0.03866443f, -0.04591137f, -0.02796993f, 0.02133764f, 0.01168255f, -0.03386114f, -0.04382712f, 
    -0.01918355f, 0.01052859f, -0.03695349f, 0.01299745f, 0.03792968f, 0.02481894f, 0.00541584f, 0.01305346f, 
    -0.04993857f, 0.00440603f, -0.04761931f, 0.03594262f, 0.00418144f, -0.05606561f, 0.02560468f, 0.00491548f, 
    0.02642984f, -0.01395007f, 0.03339105f, -0.00314551f, -0.00099911f, -0.00530739f, -0.01784888f, -0.04803266f, 
    -0.00783625f, -0.03826102f, 0.00929213f, -0.04917510f, -0.01130342f, 0.01320138f, -0.02075648f, -0.03096579f, 
    -0.04389089f, 0.02759673f, 0.00839075f, -0.01238288f, -0.05274875f, -0.03919630f, 0.03040217f, -0.02195118f, 
    -0.00765181f, -0.03219464f, 0.02270085f, -0.05718110f, 0.01830004f, -0.00318257f, -0.00041028f, -0.01412436f, 
    -0.03365309f, 0.00110920f, -0.04624254f, -0.03732517f, -0.00555031f, -0.11321530f, -0.22545716f, -0.17774442f, 
    0.05709668f, -0.06048975f, -0.10332846f, 0.05838981f, 0.18844777f, 0.21791770f, 0.02785045f, 0.04138890f, 
    0.14869839f, -0.04680945f, 0.07194608f, -0.01665836f, -0.04573356f, 0.20016360f, -0.00348590f, -0.00705852f, 
    0.10394324f, 0.03393331f, -0.14043538f, -0.09089310f, 0.03351776f, 0.09170146f, 0.02358816f, -0.14283909f, 
    0.03423473f, 0.08913459f, -0.05854687f, 0.11831004f, -0.04894685f, -0.22127156f, -0.18085444f, -0.03127892f, 
    -0.05997123f, -0.05721230f, 0.06088880f, -0.00378386f, 0.12989248f, 0.04752412f, -0.00518985f, -0.04108080f, 
    -0.20366195f, -0.17038633f, 0.08038445f, -0.13206838f, 0.02744411f, 0.01337303f, 0.02962521f, -0.03076417f, 
    0.01625917f, 0.01527127f, 0.14640394f, 0.02206355f, -0.04718628f, 0.02292102f, 0.04389100f, 0.27844208f, 
    0.07191657f, 0.13751899f, 0.16464391f, -0.04293160f, 0.09869503f, 0.00875390f, 0.04414771f, -0.05550101f, 
    0.01529593f, -0.25457025f, 0.23879930f, -0.02803224f, 0.19376959f, -0.08569808f, 0.00835674f, -0.03313252f, 
    -0.00098182f, 0.01214932f, 0.18456054f, 0.08063244f, 0.08909148f, 0.16750850f, 0.22665019f, -0.04776180f, 
    -0.04238944f, -0.07928395f, -0.14758949f, -0.06886031f, -0.04751273f, 0.03504971f, 0.01654674f, -0.16295731f, 
    -0.49234939f, 0.00657921f, -0.06628563f, -0.05291240f, 0.06520239f, -0.17179488f, -0.04805613f, -0.15283111f, 
    0.07565984f, 0.06902535f, 0.07307599f, 0.05629846f, 0.19894552f, 0.32413030f, 0.17922197f, 0.13359870f, 
    -0.06015451f, 0.07501763f, 0.19681668f, -0.01336860f, 0.20008099f, 0.16058794f, 0.01863414f, 0.05269599f, 
    -0.10110223f, -0.14688183f, -0.34524375f, -0.16963783f, -0.02307525f, 0.02430720f, -0.07642870f, 0.14379646f, 
    -0.01373873f, 0.10533908f, 0.04169171f, -0.13691470f, -0.08110562f, -0.07443754f, -0.28236330f, -0.02770884f, 
    -0.01494239f, 0.03259407f, 0.08695602f, -0.02440714f, -0.01457448f, 0.06138187f, 0.11377572f, 0.10125863f, 
    0.21180524f, 0.00283851f, -0.00769924f, 0.07232160f, 0.04734398f, 0.02092338f, 0.03104568f, -0.02941984f, 
    -0.00557767f, 0.06833322f, -0.02708078f, 0.03462283f, 0.00434862f, -0.14662653f, -0.01085854f, 0.21452186f, 
    -0.03088366f, 0.03599997f, 0.09118828f, 0.03337624f, -0.07176699f, -0.04001046f, -0.03218771f, -0.00795711f, 
    0.41204286f, 0.15097760f, 0.22710553f, -0.18323286f, -0.02308612f, -0.18774834f, -0.18133830f, -0.11347334f, 
    -0.05683134f, -0.03029560f, -0.01331648f, 0.00451108f, 0.29526085f, 0.26119509f, 0.48645142f, -0.03065273f, 
    -0.04915859f, -0.01488327f, -0.11184359f, -0.06503147f, -0.05779777f, -0.06129263f, 0.03746823f, 0.03296709f, 
    -0.07580598f, -0.15104730f, -0.05125762f, 0.20452532f, -0.11458703f, -0.09756432f, -0.13116422f, -0.18048555f, 
    -0.08103759f, -0.06424958f, -0.09625676f, -0.07123089f, 0.17016712f, 0.15983489f, 0.13392113f, 0.01566822f, 
    0.01997798f, 0.02154407f, -0.09468696f, 0.01554379f, 0.12930048f, -0.00315725f, 0.12188002f, -0.02925639f, 
    0.03245948f, 0.02707126f, -0.08230197f, 0.00802517f, -0.06802163f, 0.01124978f, 0.08529121f, 0.05330482f, 
    0.04967897f, 0.05080731f, 0.17440891f, 0.07708638f, -0.01836147f, 0.33554786f, -0.11621033f, -0.00504438f, 
    0.03509915f, 0.11268911f, -0.03463667f, -0.13519697f, -0.05248659f, -0.13974540f, -0.04396151f, 0.02278301f, 
    0.20454724f, 0.17429475f, 0.12876749f, 0.11855727f, -0.05385848f, 0.05340781f, 0.11787909f, -0.04532430f, 
    -0.01070527f, 0.05853733f, 0.10905426f, -0.14081715f, -0.00034907f, -0.11990650f, 0.19890922f, -0.10007067f, 
    0.00068846f, 0.07609695f, -0.07290731f, 0.00599379f, 0.08468647f, -0.08684096f, -0.10523616f, 0.09549946f, 
    -0.11694158f, -0.10398576f, -0.08383630f, 0.14548934f, 0.07539888f, -0.11386811f, -0.02516469f, 0.02446947f, 
    0.02860186f, 0.19868658f, 0.04779993f, 0.09843455f, -0.07632087f, 0.00549152f, -0.02095465f, -0.14165857f, 
    -0.07477459f, -0.03414193f, -0.06122693f, -0.07665510f, -0.01385981f, -0.01667442f, 0.04253437f, 0.09347475f, 
    0.08702984f, 0.13198598f, -0.04988682f, -0.10550976f, 0.02890932f, 0.01449250f, -0.04556341f, 0.03677892f, 
    -0.05976927f, -0.04555146f, -0.01458413f, -0.03062894f, -0.29843059f, -0.23333153f, 0.18490864f, 0.31374162f, 
    0.12928523f, 0.02920286f, -0.15648313f, 0.06715314f, -0.17424537f, -0.04071304f, -0.02730522f, -0.06868003f, 
    0.21216124f, 0.24290830f, 0.21156342f, -0.09497976f, -0.06129638f, -0.09115171f, -0.11091761f, -0.10070468f, 
    0.10884006f, 0.12994067f, 0.08389694f, -0.03103978f, -0.06609476f, -0.03975575f, 0.14362629f, 0.24864064f, 
    0.02357961f, -0.06122948f, 0.10116807f, -0.01734526f, 0.06011206f, -0.01524553f, 0.11072605f, 0.04667489f, 
    -0.33590513f, -0.20264207f, -0.02594346f, 0.14037667f, 0.03278954f, 0.16805100f, 0.05612276f, 0.02694462f, 
    -0.02821900f, -0.02025335f, -0.04748416f, 0.12333776f, 0.16858926f, -0.11604039f, 0.06674945f, 0.01531615f, 
    0.13476011f, -0.06745873f, 0.03126413f, 0.04160395f, -0.03975535f, 0.18120968f, 0.05769359f, 0.01990783f, 
    0.07252797f, -0.15598446f, 0.02091941f, -0.07681113f, -0.01539523f, -0.07131477f, -0.05570901f, -0.03590808f, 
    0.04552428f, -0.06227658f, 0.00992071f, 0.03802579f, 0.02604963f, -0.03256582f, 0.23345435f, -0.13518259f, 
    0.05203180f, -0.08794649f, 0.10628576f, 0.00772638f, -0.06960528f, -0.02595408f, 0.13330944f, -0.05291439f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02089406f, 0.12397939f, 0.00975059f, 0.15796986f, -0.00423220f, 0.01018976f, -0.01633877f, -0.01004067f, 
    -0.01657327f, 0.04555107f, 0.03859051f, 0.08227456f, 0.15584381f, -0.01375711f, 0.03935011f, -0.00084605f, 
    0.05094038f, 0.03710639f, 0.08502948f, 0.03503756f, -0.02087881f, -0.01556684f, -0.05148412f, -0.00682283f, 
    0.01665021f, -0.05266964f, 0.11535839f, 0.06997570f, 0.05906120f, -0.02603340f, 0.13353746f, 0.03443831f, 
    0.08953759f, 0.02835288f, -0.03361997f, -0.05933885f, -0.04245881f, 0.03585315f, -0.02458289f, 0.02702277f, 
    0.11825076f, 0.01380374f, 0.03680613f, -0.01221029f, -0.01611402f, -0.00396406f, 0.04660613f, -0.03831577f, 
    -0.03670545f, -0.03080777f, 0.00515067f, -0.00863040f, 0.05788708f, -0.02622883f, 0.10617814f, 0.16133186f, 
    -0.04403886f, 0.13857725f, 0.14542744f, 0.00872699f, -0.03377018f, -0.05344327f, 0.01505539f, 0.13120264f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.09621903f, -0.04429555f, -0.07461637f, -0.51578099f, 0.14130011f, 0.17956160f, 0.14915706f, -0.12038209f, 
    0.26842105f, 0.06299327f, 0.06166607f, 0.10930129f, -0.03123679f, 0.06844573f, -0.08792396f, 0.17271355f, 
    -0.08916729f, -0.11314223f, 0.03020046f, 0.03420956f, 0.06414788f, -0.00176913f, -0.12050391f, 0.11173344f, 
    0.09054484f, -0.12208203f, -0.40713254f, 0.05815538f, 0.03125952f, -0.13675515f, -0.36746544f, 0.21074614f, 
    -0.58061939f, 0.17102329f, 0.02462633f, 0.06818664f, 0.07815146f, -0.24100669f, 0.07855193f, -0.01116684f, 
    -0.34118393f, 0.03356151f, -0.07358429f, -0.10029095f, 0.00601597f, -0.03089258f, -0.17191412f, -0.08519705f, 
    0.13606387f, -0.08400529f, -0.09356076f, -0.05848689f, 0.07179354f, 0.04893834f, -0.26865837f, -0.46669701f, 
    0.39115492f, -0.09814057f, -0.25019276f, 0.01845610f, 0.20164971f, 0.18219897f, 0.02708833f, -0.51020432f, 
    0.09869727f, 0.04685004f, -0.06759306f, -0.03289417f, 0.04497394f, 0.33656988f, 0.10620128f, -0.84344327f, 
    -0.76523763f, -0.27135125f, -0.09598497f, 0.20358238f, 0.39159274f, 0.01616275f, -0.21868739f, 0.17161311f, 
    -0.04092748f, 0.02379809f, 0.21326146f, -0.11028594f, -0.43206710f, -0.11225060f, -0.06021553f, -0.04765101f, 
    0.04293472f, -0.11130498f, -0.02604380f, 0.04603425f, -0.08658321f, -0.33873606f, -0.23392391f, -0.02809422f, 
    -0.08395910f, 0.17780319f, 0.03238342f, -0.10923752f, 0.17929831f, -0.25496021f, -0.07720712f, 0.02573964f, 
    0.16457511f, 0.10146649f, -0.43329594f, 0.09862289f, 0.10756841f, 0.09738442f, 0.10899014f, -0.03474984f, 
    0.21106501f, -0.01116695f, -0.04699060f, -0.08788111f, 0.13959906f, 0.01718887f, 0.12091051f, 0.16660216f, 
    0.21015069f, 0.10982929f, -0.39049211f, 0.02384801f, 0.02439089f, 0.25037694f, 0.04530181f, 0.26822218f, 
    0.05439718f, 0.23778930f, 0.08627076f, 0.12896191f, 0.11329111f, 0.20278183f, 0.11894152f, 0.03166257f, 
    -0.58031255f, 0.17430371f, 0.07889038f, 0.13497941f, -0.70537919f, -0.07288279f, -0.13151461f, -0.05377383f, 
    0.14928591f, -0.27483648f, -0.06040301f, -0.09795635f, -0.25399855f, 0.25552171f, -0.07607080f, -0.02632720f, 
    -0.03739778f, 0.05378095f, 0.01752121f, -0.30878219f, -0.08191759f, -0.13839611f, 0.25261343f, 0.01859581f, 
    0.03057418f, 0.17132261f, -0.01324172f, 0.31729954f, -0.29796642f, -0.03505133f, -0.45054087f, 0.09834137f, 
    0.28995156f, -0.04850153f, 0.14828613f, -0.04476659f, 0.05244708f, 0.07376358f, 0.03681046f, 0.05262840f, 
    -0.15695018f, 0.04235573f, 0.09455183f, -0.03255736f, -0.22745597f, 0.04497286f, 0.01092950f, 0.04157781f, 
    -0.21135817f, -0.13401005f, 0.31990415f, -0.03930742f, -0.13921484f, 0.05004501f, -0.02024274f, 0.04003629f, 
    -0.08070061f, 0.32696784f, 0.04850938f, 0.24262546f, 0.03406430f, -0.26063403f, -0.10508440f, 0.11566669f, 
    -0.04882226f, -0.06312202f, -0.08582702f, -0.25811616f, -0.50634754f, 0.00951108f, -0.01067654f, -0.13141184f, 
    0.08168218f, 0.24887259f, 0.14708002f, -0.10544327f, 0.21111892f, 0.02300955f, 0.11513876f, 0.04094034f, 
    0.03641772f, 0.01385089f, -0.30976751f, -0.54887795f, 0.03221515f, 0.34010953f, -0.24712071f, -0.02740668f, 
    -0.00485458f, -0.24776526f, -0.05648293f, 0.12564127f, 0.00613016f, 0.11732057f, 0.09265652f, -0.00938047f, 
    -0.16677943f, 0.07708174f, 0.25590613f, -0.01997350f, -0.03830212f, -0.11851331f, 0.04465277f, 0.00734380f, 
    0.21488607f, 0.00194742f, -0.05513892f, -0.02020976f, -0.16985986f, -0.11210609f, -0.51509815f, -0.25272161f, 
    -0.11914710f, -0.14842007f, -0.02205600f, 0.03048953f, 0.04378458f, 0.14081065f, -0.07198643f, 0.00499541f, 
    0.06700040f, -0.67891836f, 0.07863577f, -0.18295151f, 0.03751712f, 0.31736800f, 0.12082826f, 0.19268087f, 
    0.27186677f, -0.31298250f, 0.01334076f, 0.03480178f, -0.06352516f, -0.01971890f, 0.07674730f, -0.15973923f, 
    0.16391014f, -0.20099770f, -0.38670897f, 0.01655632f, -0.03381230f, 0.10298163f, 0.07603870f, -0.04294056f, 
    0.01818288f, -0.11216327f, 0.26794276f, -0.26859561f, 0.27465004f, 0.11047869f, 0.26865056f, -0.13650821f, 
    -0.17084022f, 0.03624319f, -0.09831505f, 0.09542006f, 0.04007792f, -0.32119101f, 0.09207834f, 0.05451943f, 
    0.17872667f, 0.01289779f, -0.07438832f, 0.05819632f, 0.10571011f, -0.02088661f, 0.20447780f, 0.07393717f, 
    0.05485469f, 0.01098521f, 0.00983805f, -0.07005970f, 0.14347316f, -0.06788352f, -0.00344110f, -0.02422764f, 
    -0.16042037f, -0.15472165f, -0.14802943f, 0.07424328f, 0.06829631f, 0.08538712f, 0.11329798f, -0.23985322f, 
    -0.03622639f, -0.31571692f, -0.11686132f, -0.23527935f, -0.31843141f, -0.27325797f, 0.09272946f, -0.30694994f, 
    -0.05476295f, -0.34711528f, -0.02704112f, -0.13826126f, -0.19864634f, -0.06955176f, 0.11792235f, 0.17946330f, 
    0.19398627f, 0.25696993f, -0.07071652f, -0.10995313f, -0.45118392f, -0.30963081f, -0.07672724f, 0.08634339f, 
    -0.05531452f, -0.08659764f, 0.02950662f, 0.05134695f, 0.11280120f, -0.00122811f, 0.25344458f, 0.05530760f, 
    0.08889090f, 0.17890418f, 0.05380538f, -0.36959732f, -0.01241738f, -0.06313524f, 0.07478802f, -0.08166065f, 
    -0.05631655f, -0.10625108f, 0.13741820f, -0.07466611f, 0.08047619f, 0.00730498f, -0.32848221f, 0.11468928f, 
    -0.23536755f, -0.06533544f, 0.00558410f, 0.05209848f, -0.04904669f, -0.09500495f, 0.26696441f, -0.03884950f, 
    0.15959083f, 0.11811352f, 0.51981038f, 0.06066205f, 0.15470591f, -0.05239603f, -0.05550794f, -0.15763466f, 
    0.11311229f, -0.24027623f, -0.04414915f, 0.19205754f, -0.01441196f, 0.18820369f, 0.18081234f, 0.46478605f, 
    -0.24489819f, 0.16011643f, 0.07202892f, 0.03922830f, 0.18724687f, 0.07263489f, -0.06972789f, -0.34390330f, 
    0.10703436f, -0.37612101f, 0.10717680f, -0.10317578f, -0.42606217f, 0.15392448f, 0.07465197f, -0.10222466f, 
    -0.00631959f, -0.10143160f, -0.13779262f, 0.21186681f, 0.02971664f, 0.11089520f, -0.32494158f, -0.49461666f, 
    0.12265959f, -0.52880883f, -0.12323526f, 0.08958225f, -0.43779999f, 0.13652377f, -0.23801881f, 0.06266983f, 
    -0.07250677f, 0.08357576f, -0.20929776f, 0.08067332f, 0.06672309f, -0.00119596f, 0.18180181f, 0.02567907f, 
    -0.58594763f, 0.04236288f, 0.08706950f, -0.08303905f, 0.13130166f, -0.02867452f, 0.24252063f, -0.07804640f, 
    -0.29046869f, -0.27087536f, 0.30789530f, 0.07005534f, -0.28080487f, -0.59782767f, 0.02447931f, 0.06156002f, 
    0.05456770f, -0.07145377f, 0.00832639f, -0.33273670f, -0.50641847f, -0.29653662f, -0.11217461f, -0.12660889f, 
    0.20624678f, 0.04773381f, -0.02222769f, 0.02017654f, -0.24645448f, -0.03776586f, -0.32371163f, 0.13156003f, 
    -0.15297362f, -0.19469608f, 0.13756649f, 0.08803748f, 0.32804519f, -0.26189244f, -0.01579336f, -0.09342929f, 
    0.08811597f, 0.09817863f, 0.24208400f, -0.26248527f, -0.46874008f, -0.02882431f, 0.11309616f, -0.15443198f, 
    0.15562056f, -0.32540822f, 0.10020874f, 0.40807909f, 0.16302827f, 0.20474948f, -0.08348796f, -0.09346079f, 
    0.04114426f, -0.10115426f, 0.24565703f, 0.05384785f, -0.08371506f, -0.09944078f, -0.21686535f, -0.12072676f, 
    -0.33568823f, -0.02594470f, -0.01330939f, 0.03760871f, 0.05730716f, -0.08672157f, -0.26285839f, 0.18014221f, 
    0.35373363f, -0.19256836f, -0.16482671f, 0.01632685f, 0.08431975f, -0.41294563f, 0.10174250f, 0.01424138f, 
    -0.05042116f, 0.28486893f, -0.04325576f, 0.26150900f, -0.30643338f, -0.50403494f, -0.08957767f, -0.04981555f, 
    -0.31348935f, 0.29369947f, 0.01912674f, -0.47212440f, 0.04562530f, 0.02290596f, 0.10963523f, 0.17306852f, 
    -0.23184557f, 0.06276743f, 0.05006482f, -0.12067629f, -0.41394567f, -0.34130734f, 0.07416621f, -0.05450826f, 
    -0.05135041f, -0.04262684f, 0.10531076f, 0.25525525f, -0.72974277f, -0.14508818f, 0.20647004f, 0.33521372f, 
    -0.07308527f, -0.30289564f, -0.12288760f, -0.23388430f, -0.00422651f, 0.24859098f, -0.28649083f, 0.05864052f, 
    0.14239067f, -0.07579233f, 0.11306097f, -0.00469834f, 0.09002625f, -0.09997609f, -0.67237145f, 0.06669849f, 
    -0.40554196f, 0.03218157f, -0.03916182f, -0.11118705f, -0.07268610f, -0.02497014f, -0.28842965f, -0.27411696f, 
    -0.22823340f, 0.27559441f, -0.15492365f, -0.09208594f, -0.11462052f, -0.05047388f, 0.07462380f, 0.15790628f, 
    -0.10785962f, -0.11327556f, -0.08921176f, 0.01389208f, -0.47352296f, 0.36630774f, -0.19678263f, -0.04446981f, 
    0.42968732f, 0.19247913f, 0.00487937f, 0.03265157f, -0.18948178f, -0.00456460f, -0.44991219f, -0.27620250f, 
    0.00894438f, -0.11020193f, -0.32901245f, -0.03156298f, 0.42589232f, 0.02635846f, -0.01128717f, -0.07866303f, 
    -0.11888178f, -0.04980383f, 0.12136575f, 0.37445870f, 0.02858976f, -0.02784063f, 0.20214313f, -0.24909391f, 
    0.20461459f, 0.24071290f, 0.10755122f, -0.06438536f, 0.01070664f, -0.27060643f, -0.43799198f, 0.02770686f, 
    -0.54851127f, -0.10224954f, -0.04791899f, 0.07408175f, -0.07830969f, -0.02651851f, 0.22359912f, -0.01150486f, 
    0.28441641f, -0.06345682f, -0.03922350f, -0.10567787f, 0.10205004f, -0.03299601f, 0.34083432f, 0.15431638f, 
    0.07745890f, -0.25039279f, -0.00308773f, -0.12871720f, -0.24272788f, -0.08772453f, 0.06948470f, -0.21922638f, 
    0.03872254f, 0.12748452f, 0.08090997f, 0.19807401f, 0.40551966f, -0.18413828f, -0.31792989f, -0.26782486f, 
    -0.64884442f, 0.22262722f, 0.06859083f, 0.21882746f, -0.44612515f, -0.01189095f, 0.13744074f, -0.34866679f, 
    -0.34456295f, 0.13612211f, 0.02266799f, 0.05661998f, -0.18481115f, 0.19290955f, 0.03573866f, -0.02343701f, 
    -0.08680384f, -0.06703898f, 0.02062242f, 0.15026821f, 0.15012977f, 0.07421087f, -0.20207614f, -0.28779978f, 
    0.02328558f, -0.09808474f, -0.05394573f, -0.36176336f, -0.20054956f, 0.05664271f, 0.31535017f, -0.00632882f, 
    0.22407728f, 0.07622738f, -0.44413868f, 0.02060734f, 0.07060418f, -0.00794667f, 0.01212551f, -0.00184054f, 
    -0.02144015f, -0.11612199f, -0.11370238f, 0.05441483f, -0.27333286f, 0.04198394f, 0.02895030f, 0.03367956f, 
    -0.52159858f, 0.17312358f, -0.15965652f, 0.09644573f, 0.24072786f, -0.50932658f, 0.08792984f, -0.09350391f, 
    0.02353854f, -0.00509419f, 0.11542575f, 0.13228486f, -0.27914166f, -0.46555462f, -0.37754393f, -0.50851464f, 
    0.23516837f, -0.05181978f, -0.08864383f, -0.32116669f, 0.34733483f, 0.07679421f, 0.23054418f, 0.00177179f, 
    0.14714606f, -0.47944522f, 0.19594900f, 0.01320358f, 0.13557795f, 0.05810272f, 0.05963226f, 0.10204954f, 
    0.07051909f, -0.04996098f, -0.11675235f, -0.19894864f, 0.33731574f, 0.23324683f, 0.07610520f, -0.26705649f, 
    0.08648334f, -0.28345680f, 0.00970685f, -0.38300213f, -0.36059925f, 0.18307656f, -0.45452431f, 0.10002322f, 
    0.25288945f, -0.10427467f, 0.07615248f, -0.10762002f, 0.09480664f, 0.10942021f, 0.23472732f, 0.01506114f, 
    -0.12835260f, -0.00746560f, -0.04722995f, 0.06356283f, -0.17315082f, -0.02755644f, -0.14846045f, 0.13814434f, 
    -0.45788515f, -0.00665836f, -0.63588560f, 0.11557947f, 0.02721376f, 0.12768444f, 0.08694218f, 0.01654310f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.19749354f, 0.07912138f, -0.02424229f, -0.09459933f, 0.06844666f, 0.03149946f, -0.04638359f, 0.00007431f, 
    0.15848944f, -0.09953786f, -0.03465685f, -0.03609405f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
