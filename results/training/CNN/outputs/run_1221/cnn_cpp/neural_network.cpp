#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.44129273f, 0.52606279f, 0.12919185f, 0.50134510f, -0.47323486f, -0.31034788f, -0.00543721f, -0.09412784f, 
    0.19192399f, 0.04319919f, 0.33586425f, 0.05270213f, -0.26635149f, -0.09845109f, 0.12199489f, -0.07142677f, 
    0.35609794f, 0.06248555f, 0.04696548f, -0.19096354f, -0.18119822f, -0.16990171f, -0.19625698f, -0.07915899f, 
    -0.36848736f, -0.65678716f, -0.16243200f, -0.33852363f, -0.40881357f, -0.34578624f, 0.62898433f, 0.29208940f, 
    -0.33401382f, -0.30735001f, 0.63264430f, 0.28939781f, 0.08296118f, 0.20705980f, 0.15615451f, 0.08874521f, 
    -0.02620073f, -0.05668104f, -0.23437302f, 0.01910531f, -0.27463469f, -0.01337648f, 0.16172597f, 0.08701903f, 
    -0.02012987f, -0.22356437f, -0.44854617f, -0.98904192f, 0.10666985f, 0.82609916f, 0.52287519f, 0.57108730f, 
    0.58911514f, -0.71362633f, -0.58229625f, -0.55554605f, -0.13592798f, 0.07903958f, -0.28010094f, 0.07904831f, 
    -0.17045593f, -0.20659086f, -0.17598112f, 0.07967165f, 0.15605615f, 0.19015759f, 0.06636414f, -0.07295583f, 
    0.06499600f, 0.10464710f, -0.13226086f, -0.36876649f, -0.51623613f, -0.39136761f, -0.22916476f, -0.51058334f, 
    -0.30129269f, -0.20361038f, 0.43306559f, 0.38145652f, 0.10484256f, 0.02071438f, -0.15604423f, 0.13734715f, 
    0.00428378f, -0.26079684f, -0.02991608f, -0.21211320f, 0.18103997f, 0.08134566f, 0.18975843f, -0.01262977f, 
    0.00292377f, -0.33479881f, -0.42860660f, 0.07229186f, 0.45889115f, 0.33306432f, -0.10779076f, 0.30928278f, 
    -0.45664817f, -0.33981723f, 0.00585833f, 0.02195333f, 0.30020416f, 0.35316974f, 0.03679644f, -0.13349389f, 
    0.06656363f, 0.05841995f, 0.30638248f, -0.12298727f, -0.14621447f, -0.27850008f, 0.11307573f, 0.23681402f, 
    -0.04271004f, 0.11332095f, -0.17123730f, 0.11670813f, 0.14515644f, -0.73545146f, -0.16710594f, -0.65256864f, 
    0.03074084f, 0.47450465f, 0.13597184f, -0.02894094f, 0.52472639f, 0.61899549f, 0.30235589f, 0.23700196f, 
    0.13497473f, 0.06214461f, 0.14433609f, 0.03701689f, 0.16814989f, -0.21184960f, -0.17473257f, -0.04808013f, 
    0.33018589f, -0.14299999f, -0.26096570f, 0.12544343f, 0.11622372f, 0.01981006f, 0.96967059f, -0.16670954f, 
    0.28786227f, -0.24261478f, -0.05887434f, -0.08684196f, -0.26661542f, -0.20145184f, -0.55216879f, -0.67046487f, 
    0.11438510f, -0.10274448f, 0.03710220f, -0.21041606f, -0.18791467f, 0.23232372f, 0.09095126f, 0.08095262f, 
    -0.22596090f, -0.05931775f, -0.13356589f, 0.17196809f, 0.07141195f, -0.24765770f, -0.02018462f, 0.48288238f, 
    0.70449984f, -0.15241618f, -0.19183138f, -0.17438176f, -0.28302577f, -0.10291646f, 0.26478550f, -0.02273097f, 
    -0.06894319f, -0.08840245f, 0.13769943f, 0.49097908f, -0.43785682f, -0.24924000f, -0.14931650f, 0.06419151f, 
    0.05518245f, -0.05011528f, -0.20122695f, 0.10914898f, -0.08200934f, -0.23446985f, 0.29656538f, -0.29169968f, 
    -0.85250372f, -0.20287725f, -0.31570292f, -0.10397657f, -0.56084704f, 0.60810417f, -0.08370801f, 0.26454803f, 
    0.15672153f, 0.22698314f, 0.02264489f, -0.18631820f, 0.10754775f, 0.06509000f, -0.15903635f, 0.16458657f, 
    -0.02918324f, -0.06975492f, -0.11903322f, -0.12828889f, 0.01175434f, 0.12617181f, 0.32437670f, 0.06894980f, 
    0.02984193f, -0.04835011f, 0.73722625f, -0.19343577f, -0.56499112f, -0.09780326f, -0.06649718f, 0.31442979f, 
    0.17898265f, 0.07507922f, 0.35424569f, -0.37819025f, 0.14212765f, -0.03308806f, -0.22179437f, -0.18546405f, 
    0.27936134f, -0.50381976f, 0.15152106f, 0.01217993f, -0.09460888f, -0.20643410f, 0.06397492f, 0.24702469f, 
    0.05310631f, -0.04681007f, -0.71703452f, -0.14308296f, -0.18644486f, -0.40914726f, -0.19899365f, 0.09223621f, 
    -0.04074630f, -0.58069927f, -0.45679873f, -0.25501603f, -0.05317165f, 0.09727770f, -0.16548964f, -0.52570647f, 
    -0.29679900f, 0.02422350f, 0.01839153f, -0.21186620f, -0.21707110f, -0.14846203f, 0.02583174f, -0.06106826f, 
    -0.17526057f, -0.08668169f, 0.09698065f, -0.79245931f, -0.23271157f, -0.03480716f, 0.77974457f, 0.20969285f, 
    -0.67959267f, -0.45283732f, -0.22614269f, 0.36715874f, 0.44345713f, 0.53915215f, -0.07229314f, -0.00573815f, 
    -0.24867737f, 0.60284328f, -0.13411343f, -0.05273044f, 0.17407395f, -0.27570358f, -0.20450337f, -0.09212962f, 
    0.08172894f, 0.02943899f, 0.10707927f, 0.16820982f, 0.26456395f, 0.40139437f, 0.14050817f, -0.13853998f, 
    0.31251666f, 0.46841314f, 0.15796910f, 0.00274344f, 0.19323534f, -0.21176745f, 0.09063011f, 0.13190210f, 
    -0.10225136f, -0.31476671f, -0.01600326f, -0.01852500f, -0.08256060f, -0.03414343f, -0.23481742f, -0.11129609f, 
    0.25103265f, 0.04183266f, -0.13147728f, 0.38508701f, 0.37081075f, 0.12815057f, -0.48687741f, -0.07106403f, 
    0.25130290f, -0.38784212f, -0.08342318f, -0.64371097f, -0.50207692f, 0.34780449f, -0.05130739f, 0.11957479f, 
    -0.15972598f, 0.00152517f, 0.26884395f, 0.06680679f, -0.22027841f, 0.26995271f, -0.34603259f, -0.28731331f, 
    -0.32540101f, -0.42961091f, -0.01636059f, -0.19698390f, -0.12411842f, -0.43509558f, 0.46142724f, 0.26687267f, 
    -0.07544581f, -0.27939388f, 0.05172871f, 0.21305870f, 0.05410651f, 0.06751263f, -0.17726661f, -0.28527665f, 
    -0.22401211f, 0.64138782f, -0.01586111f, 0.02677947f, -0.23546901f, -0.37415200f, 0.09579130f, -0.29326192f, 
    0.28536537f, 0.23493062f, 0.20793527f, 0.26977998f, 0.06660630f, -0.21097007f, -0.18068054f, -0.61162138f, 
    0.44436073f, 0.26027095f, -0.55264801f, 0.13626777f, -0.18504219f, 0.13991278f, -0.03386801f, -0.12716602f, 
    -0.26069319f, 0.06795982f, 0.19532275f, -0.23889066f, 0.06165800f, -0.06109191f, 0.24799064f, -0.27225134f, 
    -0.17624435f, 0.20541835f, -0.32543105f, 0.14851597f, 0.10971089f, 0.15232202f, 0.12252465f, 0.43245336f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.09020362f, 0.01245774f, -0.03019967f, 0.02741687f, 0.07899837f, 0.00441228f, 0.15621330f, 0.07960346f, 
    0.21056342f, 0.22143373f, 0.01543938f, 0.13186789f, -0.15369894f, -0.15748630f, 0.10775164f, 0.16830769f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.05487281f, 0.06174950f, -0.07788069f, 0.05219054f, -0.02074974f, -0.03937211f, 0.00543638f, -0.04027515f, 
    0.02675678f, 0.06807697f, 0.03315388f, 0.00684418f, 0.05371954f, -0.04719793f, -0.01090069f, 0.05597760f, 
    -0.01853782f, 0.05289770f, 0.02397062f, 0.05648945f, 0.04709988f, 0.04614077f, -0.07397483f, -0.02897167f, 
    0.00484467f, 0.01280392f, 0.02004839f, -0.05966600f, 0.03956819f, 0.02156083f, -0.06611276f, -0.07970447f, 
    -0.02333185f, 0.00037800f, -0.07152740f, 0.00713651f, 0.03552639f, -0.01771099f, 0.06120461f, -0.05345894f, 
    -0.06283878f, 0.01041220f, -0.02184569f, 0.00134110f, 0.02737532f, -0.04303009f, 0.02498182f, -0.01962906f, 
    -0.04508620f, -0.04669990f, -0.05931632f, 0.01731488f, 0.03164578f, 0.01994079f, -0.06907079f, -0.00289876f, 
    -0.00958790f, 0.01406482f, -0.05087423f, 0.05415226f, -0.04926630f, 0.02010111f, -0.07420599f, -0.05596505f, 
    -0.07517274f, -0.05665512f, -0.02941323f, -0.02526631f, -0.00965063f, -0.02027236f, -0.07639398f, 0.06109064f, 
    0.05598319f, -0.00323641f, 0.00061737f, -0.03748345f, -0.04675368f, 0.00523358f, -0.06428924f, -0.07526571f, 
    -0.01379816f, -0.01522280f, -0.03257275f, 0.05504251f, -0.01732003f, -0.06866357f, -0.02736932f, 0.01300799f, 
    0.05459781f, -0.02169129f, 0.03803262f, 0.03041769f, 0.01175154f, -0.01810695f, -0.02641863f, -0.06008829f, 
    -0.03040686f, 0.05154197f, -0.03728914f, 0.04178835f, 0.03688116f, -0.07742887f, 0.03693495f, -0.01663439f, 
    -0.05270213f, -0.00575448f, 0.00270760f, 0.01727458f, 0.05694211f, -0.01678664f, 0.02135387f, 0.05853708f, 
    -0.02262587f, -0.02115452f, 0.02022353f, 0.04541379f, -0.00155574f, -0.04631196f, 0.00722950f, 0.02832561f, 
    0.00194466f, -0.01843032f, -0.00848622f, 0.05949750f, 0.00914694f, -0.03240423f, -0.05035515f, -0.05905520f, 
    0.03220315f, -0.01633989f, -0.02385593f, -0.04263730f, -0.01502694f, 0.05918368f, 0.01876232f, -0.06800921f, 
    -0.01578584f, -0.03605467f, 0.02615411f, -0.00975953f, 0.06759949f, -0.04350026f, -0.07562257f, 0.00136636f, 
    0.00764395f, -0.02513716f, 0.02305200f, -0.06441605f, -0.07055129f, 0.06138371f, -0.05722093f, 0.01104124f, 
    0.04331887f, 0.04141092f, -0.03751440f, -0.06407698f, 0.06224352f, -0.07349599f, -0.06395610f, -0.04492271f, 
    -0.00794321f, -0.05825318f, -0.00352621f, 0.01425195f, -0.05455305f, 0.00676894f, 0.06337022f, 0.00422625f, 
    -0.00663434f, -0.02255253f, 0.01256175f, 0.00013325f, 0.01263145f, 0.03033343f, -0.00205854f, 0.00244535f, 
    -0.01103363f, -0.07592049f, -0.00782976f, 0.00307406f, -0.05618624f, 0.03192291f, 0.06273047f, -0.03652627f, 
    -0.02848778f, 0.05453831f, -0.00271993f, -0.04066663f, -0.03199111f, -0.02060393f, -0.00196238f, 0.01988242f, 
    -0.26003188f, -0.09009386f, 0.07723872f, -0.26994976f, -0.25745821f, -0.03207451f, -0.02228059f, -0.03412845f, 
    0.11764062f, 0.01918523f, -0.00133475f, -0.00143623f, 0.12709479f, -0.31221130f, 0.27454510f, -0.16505066f, 
    -0.11354706f, -0.04168284f, -0.10860018f, -0.06481210f, -0.13208765f, -0.00688809f, 0.16477181f, -0.01143607f, 
    -0.13316658f, 0.12005728f, -0.27845204f, -0.14209099f, -0.06066061f, 0.00365394f, 0.05413695f, 0.14587882f, 
    -0.01403298f, -0.12233280f, 0.03420442f, -0.11242540f, -0.14629243f, 0.20623700f, -0.02974211f, 0.13483086f, 
    0.03332353f, 0.02078273f, -0.07279258f, -0.09756564f, -0.03594812f, 0.08857767f, 0.12827449f, 0.08468232f, 
    -0.09585551f, 0.16654076f, -0.09699930f, -0.13372529f, -0.01726687f, -0.04743911f, -0.22259979f, -0.13535950f, 
    0.09358892f, -0.10678872f, 0.04422491f, 0.00812101f, -0.13409410f, 0.03869999f, 0.07221863f, 0.09567451f, 
    0.05265357f, -0.10867679f, -0.02410866f, -0.10414064f, -0.09570868f, 0.05809384f, 0.06606544f, 0.12338512f, 
    -0.00300885f, -0.23205544f, -0.27640614f, -0.04058453f, 0.09159321f, -0.03800522f, -0.01607303f, -0.03809398f, 
    0.05568588f, 0.04254199f, -0.08806075f, 0.10314716f, -0.17884435f, 0.24349594f, 0.24969922f, 0.16791749f, 
    0.09965141f, -0.10992321f, 0.00119577f, -0.09831068f, -0.01401517f, 0.21406066f, 0.13787168f, 0.22142351f, 
    0.09652390f, 0.31270373f, 0.09083779f, -0.04052842f, 0.00192185f, 0.14228015f, 0.06157510f, 0.06293249f, 
    -0.03414148f, 0.12930940f, 0.06404264f, -0.07945656f, 0.12956196f, 0.19299059f, 0.43090361f, -0.12013668f, 
    -0.10999538f, -0.16330959f, -0.00993496f, -0.25081047f, 0.10763022f, 0.25089693f, 0.01973744f, -0.04959178f, 
    -0.18176542f, -0.10518569f, -0.01904920f, -0.25897899f, 0.04660920f, 0.14586747f, 0.09575149f, 0.24322313f, 
    -0.02087219f, 0.04816171f, -0.01332930f, -0.00035964f, -0.21851437f, -0.22846261f, -0.01507724f, 0.11505759f, 
    0.07901569f, -0.17421760f, -0.09128381f, 0.05497226f, 0.12023401f, -0.00111592f, 0.01539839f, -0.12487502f, 
    0.04029715f, -0.02149842f, 0.09593389f, 0.12183053f, -0.10530696f, -0.16558015f, 0.02314590f, -0.09393202f, 
    0.05277502f, 0.07824245f, -0.05549918f, -0.09416854f, -0.26996189f, 0.04167834f, -0.10015912f, -0.15526201f, 
    -0.10282777f, -0.01915285f, 0.14289652f, 0.08262121f, 0.06290703f, 0.01506235f, 0.07703418f, 0.00905217f, 
    0.13668901f, 0.15805696f, -0.02783151f, 0.01034375f, 0.17566337f, 0.06166526f, -0.16783844f, 0.06119648f, 
    0.00990168f, 0.03065372f, -0.12932488f, 0.29601192f, -0.00571848f, -0.10150730f, 0.21322033f, -0.11177082f, 
    0.00121317f, 0.05666114f, -0.02705254f, 0.14024325f, 0.01107822f, 0.12088915f, -0.00948587f, -0.00831605f, 
    -0.16988704f, -0.03446505f, -0.09783541f, -0.04819566f, -0.00486408f, 0.11221103f, -0.19794241f, -0.05722104f, 
    -0.13932490f, -0.07785438f, -0.01434952f, -0.22350186f, -0.12549488f, -0.22405955f, -0.01337937f, -0.26077628f, 
    -0.05162284f, 0.01431060f, -0.11429629f, -0.09780495f, -0.06326992f, 0.12055087f, -0.11232615f, -0.13192920f, 
    0.17052685f, -0.08240137f, 0.23956531f, -0.19904383f, -0.04117379f, -0.06009259f, -0.07898230f, 0.23619571f, 
    0.07064888f, -0.06941148f, -0.12937936f, -0.10262234f, 0.03178797f, -0.03563562f, 0.02385932f, -0.05496148f, 
    0.21365696f, 0.01023330f, -0.03021318f, 0.14383656f, 0.06761219f, -0.10908002f, -0.05402910f, -0.00734158f, 
    -0.15535758f, 0.06613872f, 0.00737903f, -0.22896625f, 0.05389159f, -0.14084421f, -0.01578536f, -0.13297093f, 
    0.13024001f, 0.06111978f, 0.08929003f, 0.06060809f, 0.06996293f, -0.35294437f, 0.05424276f, -0.00530160f, 
    -0.02591620f, -0.04409889f, -0.13122094f, -0.34928855f, 0.11606605f, 0.02840044f, 0.15407135f, 0.21654250f, 
    0.19627656f, -0.09619413f, -0.31859034f, 0.10931921f, 0.10937288f, -0.04642005f, 0.04216660f, 0.11902079f, 
    -0.04956187f, 0.02848537f, -0.10934712f, -0.16893969f, 0.01634073f, 0.16839445f, -0.05472137f, 0.37956911f, 
    0.05185333f, 0.07947763f, 0.02509135f, -0.03137995f, 0.06769071f, -0.21714492f, 0.05953348f, -0.07532915f, 
    -0.02537026f, -0.02060470f, -0.17992100f, -0.27944097f, -0.04652989f, 0.08874010f, 0.00694611f, 0.08373981f, 
    0.08266965f, 0.03452981f, 0.02240783f, 0.07324957f, -0.00430855f, 0.22989470f, 0.15650597f, 0.08531599f, 
    -0.12598693f, -0.18265702f, 0.07171079f, -0.12449716f, 0.06816714f, 0.05614736f, -0.14106713f, -0.01950794f, 
    -0.03591616f, 0.25705051f, 0.20120442f, -0.23538309f, -0.01322246f, 0.18093143f, 0.15730764f, 0.27922618f, 
    0.15672876f, -0.23875630f, 0.05313875f, -0.06838927f, 0.10563375f, -0.11366453f, 0.21234232f, 0.17616598f, 
    0.04387780f, 0.07034077f, -0.02708664f, 0.02435851f, 0.23907086f, 0.03869634f, 0.01521047f, 0.11876440f, 
    -0.17495750f, 0.05477426f, 0.14507456f, 0.13385712f, -0.22522445f, -0.09902428f, -0.10397007f, -0.17125042f, 
    0.36851931f, -0.04468109f, 0.03307464f, 0.14507034f, 0.17144610f, -0.01036013f, 0.04698267f, -0.14437546f, 
    0.11318042f, 0.01069724f, 0.14240561f, 0.10026971f, -0.13130124f, -0.14978983f, -0.04731648f, -0.38368124f, 
    0.03490009f, -0.06645382f, 0.00735060f, 0.15366805f, -0.08146454f, 0.03804470f, -0.03965684f, 0.05490520f, 
    -0.04571937f, 0.06611113f, 0.06544878f, 0.02150454f, -0.23527001f, 0.02638025f, 0.10011212f, -0.13333739f, 
    0.09222828f, 0.18778367f, 0.16617136f, 0.26086617f, 0.11431460f, 0.09678043f, 0.12170171f, 0.27796170f, 
    0.12195340f, -0.05373867f, -0.23283163f, -0.01501668f, -0.07564691f, -0.15379010f, 0.06926382f, -0.04489785f, 
    0.25769091f, 0.04661302f, -0.03401662f, 0.12599368f, -0.06146930f, -0.01072536f, 0.14652714f, 0.01387324f, 
    -0.09506502f, -0.09255300f, -0.02528612f, 0.08259333f, 0.11517780f, 0.08422635f, 0.16947153f, 0.11775012f, 
    -0.38618097f, 0.05188806f, -0.17262933f, 0.22184226f, 0.21373898f, 0.09563925f, -0.06583475f, -0.04469517f, 
    0.02061679f, -0.05951000f, -0.03756071f, -0.10519593f, -0.06576176f, -0.00262338f, -0.03314364f, 0.12618993f, 
    -0.05038214f, -0.10128364f, 0.00485301f, -0.05235711f, 0.07871374f, 0.12415855f, 0.07920173f, 0.14023189f, 
    0.27409318f, 0.12214799f, -0.13820124f, 0.06947794f, -0.13012895f, -0.16383354f, 0.02654744f, 0.10055131f, 
    -0.06893744f, -0.03914014f, -0.02901361f, 0.04314382f, -0.14616740f, 0.07643633f, 0.17392404f, 0.13216317f, 
    -0.03377989f, -0.13823034f, -0.15301406f, -0.00185056f, 0.04532931f, -0.00673914f, 0.08997264f, 0.12162984f, 
    -0.10307279f, 0.12069091f, 0.19710463f, -0.00306610f, 0.05962808f, 0.12937084f, 0.08008134f, -0.14594132f, 
    0.02763805f, -0.02760086f, 0.06762189f, 0.06189442f, 0.26774350f, 0.16642043f, 0.04931025f, -0.20135044f, 
    -0.03672259f, -0.05154143f, 0.01487649f, 0.00336811f, 0.12285741f, 0.16851684f, -0.00014827f, -0.10684358f, 
    -0.15005189f, -0.04263296f, 0.03314520f, 0.23684955f, 0.01317849f, -0.10616557f, 0.01405531f, 0.02274017f, 
    0.03577844f, 0.07368223f, 0.11914923f, -0.02705001f, 0.32376859f, -0.18935990f, 0.08709612f, 0.04824835f, 
    -0.00952379f, 0.00244520f, -0.17555355f, -0.01266710f, 0.10921703f, 0.28361851f, 0.18394929f, 0.16661388f, 
    -0.15471338f, -0.19160959f, 0.09543473f, 0.08143982f, 0.07585877f, -0.14084287f, -0.08518290f, -0.08534916f, 
    -0.04124209f, 0.18169345f, 0.00889793f, -0.04826674f, 0.14761542f, -0.22605783f, -0.16920716f, 0.21346207f, 
    0.16177344f, -0.06106759f, -0.00954205f, 0.06947575f, 0.06286637f, 0.01488219f, 0.05779790f, -0.05923190f, 
    -0.08616114f, -0.21931472f, 0.00120790f, -0.09277336f, 0.04017349f, 0.01359263f, 0.01585038f, 0.03628662f, 
    -0.10690141f, 0.07393655f, -0.18535684f, -0.09086067f, -0.10147228f, -0.17219000f, -0.03403889f, 0.14369269f, 
    0.00790814f, 0.05888621f, 0.02623552f, -0.01565305f, 0.01212122f, 0.10839330f, 0.08821858f, 0.15526910f, 
    0.00090439f, 0.10681784f, 0.18471049f, -0.05983100f, 0.06708639f, 0.09736220f, -0.12209210f, -0.01556890f, 
    0.21258546f, 0.00048591f, 0.04579219f, 0.23509374f, -0.12895209f, 0.01298077f, -0.06250780f, -0.05552716f, 
    0.11471827f, -0.02566394f, -0.01138016f, 0.07947857f, 0.02213996f, -0.06458430f, -0.10974233f, -0.03119936f, 
    -0.27871132f, -0.03217025f, -0.01507468f, 0.08828431f, 0.09336416f, 0.07376472f, -0.10605963f, -0.18494062f, 
    -0.07205363f, -0.03924152f, -0.02211978f, -0.18948768f, -0.10177609f, -0.02447680f, 0.10188186f, -0.14530975f, 
    0.01982119f, 0.00527861f, -0.01272943f, -0.01927624f, -0.05452102f, -0.06507891f, -0.04303031f, -0.04586274f, 
    0.47694799f, 0.08821654f, 0.12067691f, -0.11636537f, -0.00478656f, 0.00997849f, 0.28032303f, 0.15172066f, 
    0.08817574f, 0.07254393f, -0.03204834f, 0.04129416f, 0.06516918f, 0.15174821f, -0.01056135f, -0.08125855f, 
    0.06876992f, 0.06080794f, -0.01062389f, 0.07978974f, 0.02826995f, -0.03136718f, -0.01947987f, -0.11242454f, 
    -0.29094729f, 0.09032257f, 0.11006047f, -0.02900756f, -0.04005047f, 0.04783814f, -0.10673376f, -0.16521570f, 
    0.10189790f, 0.01280162f, 0.03020712f, 0.00366016f, -0.15604350f, -0.02239649f, -0.03192990f, 0.04376341f, 
    -0.19568592f, -0.05797694f, -0.10279077f, -0.21451579f, 0.00737638f, 0.09085266f, 0.06222567f, 0.08446966f, 
    0.11128689f, -0.25501552f, -0.27568510f, -0.03614651f, 0.11009506f, 0.07363365f, 0.00737957f, 0.02192749f, 
    0.00957141f, -0.07599407f, -0.01795328f, 0.04767433f, 0.08946183f, -0.08262305f, 0.03355458f, 0.30240533f, 
    0.00762946f, 0.24728963f, -0.03599658f, -0.05152568f, 0.02815411f, -0.21303000f, 0.03023676f, 0.12248097f, 
    -0.06533819f, 0.16478430f, -0.06068552f, -0.17521031f, 0.02438221f, 0.22677661f, 0.17904912f, 0.08723330f, 
    0.10162011f, -0.02280428f, -0.05550447f, 0.09646044f, -0.01309096f, 0.15314786f, 0.14365564f, 0.02415926f, 
    -0.17350365f, -0.09891894f, 0.00813148f, 0.03641994f, 0.10234757f, 0.06617415f, -0.07627784f, 0.06182005f, 
    0.14655037f, 0.23915103f, -0.06608503f, -0.25874993f, 0.03699047f, 0.09816292f, 0.06365516f, 0.06894348f, 
    -0.02553563f, -0.23453726f, -0.04922582f, -0.00774226f, -0.08835729f, 0.03868663f, 0.03641034f, 0.02188864f, 
    -0.03376673f, 0.09074935f, -0.14900111f, 0.09585315f, 0.04694894f, -0.01559103f, -0.05318680f, 0.13542299f, 
    -0.22186594f, -0.02786119f, 0.04718948f, 0.14436808f, -0.12305936f, -0.12892810f, -0.20294309f, -0.16438198f, 
    0.19755420f, -0.07416835f, 0.03150996f, 0.09037733f, -0.06505463f, 0.07386211f, -0.08354308f, -0.26125422f, 
    0.04020325f, -0.00933092f, 0.03424286f, 0.00689391f, -0.15111132f, -0.24092931f, -0.19799009f, -0.23121618f, 
    0.11656014f, -0.04750618f, -0.09629545f, 0.08450419f, 0.10366181f, -0.03453130f, 0.14222738f, 0.20866343f, 
    -0.13804826f, 0.15115678f, 0.15455505f, -0.03572052f, -0.16244288f, -0.07001714f, 0.09351666f, -0.02775364f, 
    0.06779391f, 0.12991095f, 0.18150228f, 0.25530571f, 0.06393649f, 0.18120362f, 0.07196431f, 0.21480544f, 
    0.16137151f, -0.16195235f, -0.13305505f, -0.14752118f, -0.08203558f, 0.02699656f, 0.10206959f, -0.08070206f, 
    0.11349015f, 0.13407150f, -0.04590283f, 0.00291741f, 0.31889662f, 0.03929811f, 0.31418741f, -0.20420089f, 
    -0.18824153f, -0.12207219f, -0.07851070f, -0.02574656f, 0.03808988f, 0.13644172f, 0.18177195f, 0.02143075f, 
    0.02809580f, -0.60215509f, 0.13620034f, 0.04240435f, 0.16826589f, 0.15233707f, -0.16510698f, -0.04268793f, 
    0.07329469f, 0.03591120f, -0.03211836f, -0.08743133f, -0.39352676f, 0.10982646f, 0.05880468f, 0.09490302f, 
    -0.06563140f, 0.05188104f, 0.16461362f, -0.12684333f, 0.04509186f, 0.09229695f, -0.07356679f, 0.20726342f, 
    0.28148121f, 0.09014441f, -0.14065909f, 0.00670320f, -0.11545779f, -0.01594654f, -0.00753523f, -0.10543641f, 
    -0.00954680f, -0.19621456f, 0.10992635f, 0.02813251f, -0.02372000f, 0.18129393f, 0.24871409f, -0.01802385f, 
    -0.02364970f, -0.16968459f, -0.15713169f, 0.06288148f, 0.07501546f, 0.00625880f, 0.16814765f, -0.04345876f, 
    0.39542183f, -0.31111541f, -0.15091676f, -0.07588540f, 0.22138052f, 0.00393549f, 0.12947424f, 0.03410367f, 
    0.11442573f, -0.06336144f, -0.12982497f, 0.08291820f, 0.07972836f, 0.21832313f, -0.31048116f, -0.08466788f, 
    -0.02566200f, -0.07022391f, 0.19257110f, 0.03867197f, 0.04110717f, 0.18105300f, 0.01119286f, 0.20972691f, 
    0.02687865f, 0.21674411f, 0.10798512f, 0.07366445f, -0.19698925f, -0.05581610f, 0.10694300f, 0.10269886f, 
    -0.03362849f, 0.02410278f, 0.00622910f, 0.00526793f, 0.07500972f, 0.10244031f, 0.01598774f, -0.00159486f, 
    -0.05391009f, -0.09299233f, -0.05968281f, -0.11559717f, 0.13793014f, 0.14036401f, 0.05868647f, 0.07691696f, 
    -0.12399174f, -0.09971366f, 0.06384242f, 0.03006451f, 0.07472387f, -0.01799159f, 0.17440724f, 0.10382767f, 
    -0.03237258f, 0.04509756f, 0.03915681f, -0.07088320f, -0.14012992f, -0.22850361f, 0.10514966f, 0.02879976f, 
    -0.00261195f, -0.08175062f, -0.04952987f, -0.03374406f, 0.02468556f, -0.03504454f, -0.16281550f, -0.02895550f, 
    0.16342774f, -0.07228196f, 0.06073918f, 0.09265837f, -0.07006919f, -0.08869974f, -0.04265283f, -0.13937674f, 
    0.11241485f, -0.00809574f, 0.02493237f, -0.02108962f, 0.06394256f, 0.06294253f, -0.20357265f, -0.17523544f, 
    -0.04759264f, 0.07650767f, 0.07283174f, 0.10184284f, 0.17954515f, 0.16856159f, 0.14713423f, 0.03681879f, 
    -0.00135259f, 0.08276399f, 0.08267132f, 0.08229915f, 0.16948165f, -0.01088789f, 0.02683018f, -0.12008502f, 
    0.04518667f, 0.07553253f, -0.00176012f, 0.07272087f, -0.08791371f, -0.18644592f, 0.09456801f, -0.00952040f, 
    0.01510056f, -0.20768312f, -0.00585883f, -0.06101437f, -0.11866046f, -0.15881598f, -0.01687153f, -0.27821547f, 
    -0.36286861f, -0.04587060f, 0.03518093f, -0.17485791f, 0.00057656f, 0.01698906f, -0.22863780f, 0.04269830f, 
    -0.14364688f, -0.06672049f, -0.02216818f, -0.14839423f, -0.08263323f, -0.25368160f, 0.14017774f, 0.03985885f, 
    0.07118372f, 0.19883738f, 0.04574715f, -0.02785156f, -0.10096883f, -0.05426538f, 0.04562864f, -0.02095274f, 
    0.04289678f, 0.47959426f, -0.28357252f, 0.00273654f, 0.08506151f, -0.07792126f, 0.13754678f, -0.05431981f, 
    -0.03854463f, 0.08400317f, 0.12655669f, 0.12520921f, 0.17073950f, 0.00221110f, -0.01490162f, 0.13673382f, 
    0.07695730f, 0.05831322f, -0.03014379f, 0.00605735f, 0.01017671f, 0.07252190f, -0.06712498f, -0.12468987f, 
    -0.27265775f, 0.03541415f, -0.08955835f, -0.03948317f, 0.00468705f, -0.07787688f, -0.04768261f, -0.03297543f, 
    0.12974504f, -0.06984476f, 0.15514059f, -0.00071410f, -0.05927927f, -0.18927817f, -0.14937393f, -0.18746546f, 
    -0.02047763f, -0.11843111f, 0.01051059f, -0.18322885f, -0.14551133f, 0.11640979f, 0.10243577f, 0.08562202f, 
    -0.22074416f, -0.10069428f, 0.01927139f, 0.17734206f, -0.02993960f, 0.07159336f, -0.06706793f, -0.22330800f, 
    -0.00711454f, 0.09637774f, 0.01931485f, 0.12455258f, -0.20121217f, -0.05427204f, -0.08500365f, 0.13423668f, 
    -0.00145645f, -0.00192638f, 0.01658593f, -0.19343229f, 0.02472556f, 0.06551147f, -0.08641428f, 0.09653004f, 
    0.08145422f, -0.01780166f, -0.03000234f, 0.05500690f, 0.08946759f, 0.22142811f, 0.00580735f, 0.14623143f, 
    0.07715958f, 0.21199009f, 0.01551477f, 0.11169270f, 0.12825488f, -0.02182362f, -0.00589401f, 0.05733105f, 
    -0.19304721f, -0.00094846f, 0.10019992f, 0.03209163f, -0.01495866f, 0.05631823f, 0.01378418f, -0.03819061f, 
    0.18150948f, 0.15528619f, -0.11071710f, -0.02470926f, 0.16167887f, 0.15448558f, 0.04152077f, 0.02065415f, 
    -0.03865872f, -0.04268931f, -0.09021132f, 0.01814856f, 0.20616359f, 0.13098128f, -0.07651280f, -0.35325339f, 
    0.07418434f, 0.03687539f, -0.08462315f, 0.12369253f, 0.11935149f, 0.07933623f, -0.04363568f, 0.09252638f, 
    -0.46775812f, 0.11003543f, 0.04653841f, -0.03548928f, -0.05931325f, -0.12893911f, -0.04032220f, -0.04513429f, 
    0.02656493f, 0.01825981f, -0.09632769f, -0.00920371f, 0.01139806f, -0.01287816f, 0.12322374f, -0.08593289f, 
    0.00963931f, -0.06548049f, -0.07228982f, 0.07563993f, -0.07169300f, -0.04015640f, -0.13755180f, -0.12501594f, 
    0.08753023f, -0.25631133f, -0.07590418f, 0.06532355f, -0.08551041f, -0.05462309f, -0.11198738f, 0.01088861f, 
    -0.12017813f, 0.05729435f, 0.05565729f, 0.04955483f, 0.05507576f, -0.06691182f, -0.03675940f, 0.02065861f, 
    0.01170076f, 0.10659863f, -0.04014505f, 0.07295571f, 0.09131789f, 0.13996695f, 0.18622193f, 0.19130212f, 
    0.04716965f, -0.10594916f, 0.03625584f, -0.05030996f, -0.10660617f, 0.07211460f, 0.11471646f, 0.07681495f, 
    -0.05535885f, 0.08670910f, 0.08645934f, -0.12290929f, -0.44935706f, 0.09242184f, -0.44308671f, -0.06761351f, 
    0.06297316f, -0.05320397f, -0.12778918f, 0.00562675f, 0.03047442f, 0.05565121f, -0.00890635f, -0.08159503f, 
    -0.13932706f, 0.33533913f, -0.17439324f, 0.27033493f, 0.10337380f, 0.23933826f, 0.18001086f, 0.03249845f, 
    -0.11765703f, 0.05780831f, -0.04242986f, 0.03669319f, 0.29815811f, -0.46804327f, 0.04111394f, -0.18238130f, 
    0.01543367f, -0.05567531f, 0.05485520f, 0.19307379f, -0.07553231f, 0.02429087f, -0.02815051f, -0.00344414f, 
    0.20608924f, 0.13848770f, 0.12367637f, -0.00935134f, -0.02759259f, 0.03547218f, 0.11017073f, 0.08122309f, 
    0.05673141f, 0.05904375f, 0.07339749f, 0.00482093f, 0.02827910f, -0.19799826f, -0.16464961f, -0.42889848f, 
    -0.10547985f, 0.06531450f, -0.06603247f, 0.04439345f, 0.10098435f, -0.04913316f, 0.10701688f, -0.09007055f, 
    0.09182717f, 0.25308338f, 0.22849219f, 0.18200353f, 0.05447830f, 0.04541789f, 0.04202104f, 0.11606814f, 
    -0.10278220f, 0.00509042f, -0.05268233f, -0.12834530f, 0.26760438f, -0.11174951f, 0.25485030f, 0.22373594f, 
    -0.08021999f, -0.16869555f, 0.09772713f, 0.08091156f, 0.03324911f, 0.16503397f, -0.06888022f, 0.01748792f, 
    -0.02126399f, -0.37619957f, -0.10203976f, -0.13845466f, 0.20551531f, 0.03687110f, -0.02216913f, -0.03981924f, 
    -0.06315063f, 0.06970029f, 0.07949205f, -0.05809925f, 0.07416642f, 0.02177282f, 0.14473182f, 0.14136200f, 
    -0.04242214f, -0.01131718f, 0.04038333f, 0.07625312f, 0.12031595f, 0.09816451f, 0.16035303f, 0.21132387f, 
    0.06836801f, -0.23289822f, -0.08321467f, 0.03935701f, 0.11546490f, -0.08740175f, -0.00465293f, -0.12849730f, 
    -0.09620896f, -0.05653610f, -0.00580026f, -0.11636176f, 0.20771514f, 0.38399181f, 0.13529159f, -0.16808794f, 
    0.00444658f, 0.21713698f, 0.21555218f, 0.05880353f, 0.02222266f, -0.04520785f, 0.27092326f, 0.03891535f, 
    0.02358973f, 0.14143743f, -0.01702466f, 0.00118695f, -0.04126219f, -0.06868454f, -0.03470134f, -0.15976384f, 
    -0.12936278f, -0.10568912f, 0.00959857f, -0.09336944f, -0.04101010f, -0.04662838f, -0.06156610f, 0.06392217f, 
    0.10277940f, 0.09387695f, 0.00152133f, 0.05483954f, -0.06460258f, 0.03773576f, -0.02054074f, -0.04628217f, 
    -0.09331866f, -0.09933116f, 0.36977109f, 0.08706464f, -0.06621080f, 0.06410452f, 0.12042791f, 0.01456338f, 
    -0.21907513f, 0.03743882f, 0.18833202f, -0.10042939f, -0.01607932f, -0.02020800f, -0.08231838f, 0.01430541f, 
    0.04158871f, -0.00785778f, 0.17944975f, -0.09921276f, 0.00356613f, 0.22686674f, 0.06150572f, -0.02299570f, 
    -0.13940197f, -0.19338480f, -0.16870864f, 0.05276007f, -0.13005024f, 0.02703168f, -0.08987823f, 0.09972412f, 
    -0.00389356f, 0.10426106f, -0.02981474f, 0.11300460f, 0.23465486f, 0.21884219f, -0.12511405f, 0.22280753f, 
    0.02336306f, 0.07599574f, -0.06786676f, -0.33057314f, 0.15955165f, 0.04717740f, 0.19522385f, 0.21962732f, 
    0.31353626f, -0.10573407f, -0.13308631f, 0.01837824f, 0.26832575f, 0.23708904f, 0.20396188f, -0.06886455f, 
    -0.12646858f, -0.06856841f, 0.03932282f, 0.15969227f, -0.02198012f, 0.00867624f, -0.01179429f, 0.01080188f, 
    0.02429517f, 0.02052130f, 0.17298056f, -0.10745010f, 0.06192797f, 0.17475253f, 0.12138070f, 0.09169032f, 
    -0.29555231f, -0.32679623f, -0.26244757f, -0.13757677f, -0.04258069f, 0.24270242f, -0.18362984f, -0.12931474f, 
    -0.18700248f, -0.28808361f, -0.05824414f, -0.31586808f, 0.07035389f, -0.13264278f, -0.19420621f, -0.22422135f, 
    -0.13937938f, -0.02820987f, -0.17803095f, -0.35406741f, 0.11825764f, 0.13500713f, 0.14296219f, -0.06355222f, 
    0.15502463f, 0.01331610f, 0.14753154f, 0.24833424f, 0.16315083f, 0.13600507f, 0.06733803f, 0.05694199f, 
    -0.08504182f, 0.05397291f, -0.06211305f, -0.04904402f, -0.22442453f, -0.06560740f, -0.07867414f, 0.17935021f, 
    0.05248142f, -0.12390622f, 0.04452272f, -0.05258660f, -0.01943024f, 0.09438179f, -0.04145220f, 0.12790896f, 
    0.14304815f, 0.06488150f, 0.13037932f, 0.04002179f, 0.09361740f, 0.00379600f, -0.04766757f, -0.01634361f, 
    0.00020577f, 0.00524706f, -0.02537361f, -0.08808272f, -0.32609984f, -0.26056927f, -0.13679475f, 0.19136764f, 
    0.14282398f, -0.11626366f, -0.12370531f, -0.14944111f, -0.07681073f, -0.11404529f, 0.03255240f, 0.05154921f, 
    0.22309703f, 0.07187713f, -0.21711746f, 0.09562765f, 0.02776773f, 0.15780067f, 0.15633455f, 0.17654589f, 
    -0.00345219f, 0.11950267f, 0.18535152f, 0.09198701f, 0.04614611f, 0.38915864f, 0.27617422f, -0.47662231f, 
    0.00087278f, -0.16766100f, -0.00353177f, -0.19468592f, -0.17911652f, -0.00953224f, -0.02998606f, -0.02655040f, 
    0.03333737f, -0.25918606f, -0.24917862f, 0.04849501f, 0.13907047f, 0.02804324f, -0.12455693f, -0.16477339f, 
    -0.41471994f, -0.11920412f, -0.19888075f, -0.34084284f, 0.29876345f, 0.13933493f, 0.15699370f, 0.06851707f, 
    -0.04075673f, -0.05692407f, -0.16612595f, 0.04118250f, 0.19028281f, 0.26041049f, 0.21185324f, 0.24243876f, 
    -0.16716354f, -0.02684878f, -0.20022583f, 0.00216194f, 0.03950997f, 0.09512868f, 0.10397767f, 0.08631933f, 
    -0.13594045f, -0.26656583f, -0.25484115f, -0.07997505f, -0.06003383f, 0.08724637f, -0.22290266f, 0.09112455f, 
    0.03519846f, -0.06220510f, 0.00092023f, -0.03096553f, -0.31208211f, -0.20693901f, -0.17632253f, -0.47878698f, 
    -0.19818407f, -0.09266273f, -0.08746802f, 0.08970151f, 0.17865841f, -0.16224280f, -0.09822648f, -0.09383852f, 
    0.08591334f, -0.02136753f, 0.09942853f, 0.01940478f, -0.19137697f, 0.20071211f, 0.03243138f, 0.11189372f, 
    0.09747799f, 0.08917993f, 0.16653530f, 0.03546257f, 0.17171729f, 0.08148845f, -0.06401519f, -0.06203279f, 
    -0.05945456f, 0.55324215f, -0.07329652f, 0.07335728f, 0.01835863f, -0.09561964f, 0.24348086f, -0.02107139f, 
    0.03070999f, 0.00175232f, -0.11929674f, -0.03114647f, 0.20881978f, -0.09814911f, 0.03538950f, 0.19434409f, 
    0.12977220f, 0.15534590f, -0.00760033f, 0.11398744f, -0.07716548f, 0.03608997f, 0.01133759f, -0.00694004f, 
    -0.11141237f, -0.15254425f, 0.17087701f, 0.14320120f, 0.01596730f, -0.00584267f, -0.04278429f, 0.07427886f, 
    -0.00391318f, 0.18300144f, -0.07237389f, 0.14385334f, -0.01831254f, -0.19964159f, -0.14492938f, 0.02665483f, 
    0.01239183f, 0.07460400f, -0.00531702f, -0.00530095f, -0.01148160f, 0.04542141f, -0.05067636f, 0.01301314f, 
    -0.11040909f, 0.27278754f, 0.18893550f, 0.12175933f, 0.06216330f, 0.18179646f, 0.05092289f, 0.07753991f, 
    -0.08904801f, 0.00536588f, 0.14168882f, -0.10934894f, 0.27272767f, -0.16799390f, 0.02381719f, 0.16955064f, 
    -0.02534797f, 0.10260838f, -0.19516897f, -0.01148566f, 0.12808542f, 0.00274015f, 0.00569657f, -0.12924379f, 
    -0.15781753f, -0.24921563f, -0.04714027f, 0.13423651f, 0.22622931f, 0.17533606f, -0.03737399f, -0.12139565f, 
    -0.00034580f, -0.11743461f, -0.07692438f, 0.13934615f, 0.30435032f, -0.17423584f, -0.21504226f, 0.18552278f, 
    -0.04117571f, 0.02617519f, -0.17918271f, -0.02692893f, 0.24237870f, -0.02383051f, 0.14468282f, 0.19723509f, 
    -0.13262472f, 0.15605427f, 0.01255954f, -0.01174035f, 0.06747012f, 0.05444830f, -0.01140367f, -0.12299272f, 
    -0.03270979f, -0.15257068f, -0.11292005f, 0.10519515f, 0.25883207f, 0.08267754f, 0.04966309f, 0.17984323f, 
    0.03003550f, 0.08187193f, 0.07057222f, -0.01388517f, 0.01061427f, -0.03446725f, 0.02453903f, -0.01795227f, 
    -0.20937376f, -0.00454860f, -0.02971695f, -0.12961343f, 0.07557846f, 0.06153417f, -0.07647570f, -0.05388143f, 
    -0.08101644f, -0.07618672f, 0.07468761f, 0.01138316f, 0.10629924f, -0.01105876f, 0.23085278f, 0.17856823f, 
    0.18426061f, -0.02626686f, -0.02445571f, -0.09221208f, 0.12192696f, -0.08625976f, 0.10810690f, 0.10938548f, 
    0.03298916f, -0.00622107f, -0.00813012f, -0.05697913f, -0.03640372f, 0.01376173f, 0.07635476f, 0.01625896f, 
    0.05378948f, -0.10520843f, 0.06642390f, -0.16551629f, -0.07168479f, 0.12281265f, -0.08698381f, -0.11285065f, 
    0.14011411f, 0.14033934f, 0.04639160f, -0.05159992f, 0.05549015f, -0.08710117f, 0.00573139f, 0.01368992f, 
    -0.17782845f, 0.25101307f, 0.08639526f, -0.08633961f, -0.02045136f, -0.24038453f, -0.08990543f, -0.03205990f, 
    -0.04721365f, -0.07218996f, 0.04037376f, -0.02668870f, -0.04862230f, 0.01852128f, 0.08745284f, 0.22284918f, 
    0.14099894f, -0.10389210f, 0.03194445f, 0.10537318f, 0.01668420f, -0.05733478f, -0.04415481f, 0.02541743f, 
    -0.44264433f, 0.41465175f, -0.12919860f, 0.18267061f, 0.10887255f, -0.03783594f, 0.11519980f, -0.04111621f, 
    0.01730308f, 0.05605847f, -0.01515380f, -0.12967567f, 0.04283159f, 0.21874312f, -0.00294438f, 0.24404833f, 
    -0.06876288f, -0.05053288f, -0.11758439f, 0.02330772f, 0.07987414f, -0.02646690f, 0.05471743f, -0.18884073f, 
    -0.08425727f, 0.01475025f, 0.31431174f, 0.12390018f, -0.08047071f, 0.03994597f, -0.03062927f, 0.20446046f, 
    -0.09698704f, 0.08991630f, -0.07689614f, -0.02177757f, -0.15720120f, -0.15044533f, -0.31415942f, -0.13930997f, 
    0.08713622f, -0.10460395f, 0.09254158f, -0.02596482f, -0.00565796f, 0.10797000f, -0.22000754f, 0.11441127f, 
    -0.22437376f, 0.32285851f, 0.23608796f, 0.00138650f, 0.00150024f, 0.01835239f, -0.06075060f, 0.08079462f, 
    0.04186820f, -0.02518661f, 0.07417835f, 0.02327894f, 0.18497802f, 0.02649914f, 0.43054706f, -0.11221012f, 
    0.02671868f, -0.00359886f, -0.26011693f, -0.11203549f, -0.00163888f, 0.02547391f, 0.07136591f, -0.14771447f, 
    0.03121373f, 0.11639217f, 0.22083157f, 0.27791277f, 0.13844839f, -0.06157690f, 0.10468881f, 0.01015857f, 
    -0.03042148f, 0.03075555f, -0.02286830f, 0.01936151f, 0.32844856f, 0.13479382f, 0.19905668f, -0.01187042f, 
    0.07234596f, 0.13940267f, -0.20909926f, 0.01148350f, 0.04884284f, 0.10900106f, 0.07147897f, 0.14348046f, 
    -0.09715024f, -0.23834778f, 0.14381188f, 0.35365620f, 0.03653580f, 0.05547996f, -0.07066368f, -0.00384242f, 
    -0.06327651f, 0.03058845f, -0.22491594f, 0.01887412f, -0.13626875f, -0.01484130f, -0.44946781f, 0.08368254f, 
    -0.02791516f, -0.04854096f, 0.14777499f, 0.06102398f, -0.15539391f, -0.02654628f, 0.17663661f, -0.01330512f, 
    0.07412437f, -0.08126149f, -0.11852156f, -0.09734926f, -0.08102516f, 0.07185183f, -0.12761821f, 0.02277901f, 
    -0.16158925f, -0.06727587f, -0.05183675f, -0.01016741f, -0.27373943f, 0.10538740f, 0.00966255f, 0.26087180f, 
    -0.16090886f, -0.10895601f, 0.13175151f, 0.05203633f, -0.15451336f, -0.00488646f, -0.10453797f, 0.07442936f, 
    0.24276961f, 0.05523754f, 0.09475363f, -0.12271226f, 0.11312830f, -0.05943220f, -0.16682582f, 0.10017888f, 
    0.09224366f, -0.14541152f, 0.01786279f, 0.04676914f, 0.40913349f, -0.12496242f, 0.10069942f, -0.09916198f, 
    -0.01208802f, 0.03960873f, -0.05685082f, 0.05657218f, 0.18401784f, 0.15453978f, 0.06284526f, 0.16943686f, 
    0.07997479f, -0.25624517f, -0.25859913f, 0.02829517f, 0.06204832f, 0.04391761f, -0.09104176f, -0.06930657f, 
    0.19118616f, 0.07430075f, 0.07495751f, -0.06870500f, -0.11683153f, -0.07558653f, 0.13002665f, -0.07384326f, 
    -0.03913761f, 0.02187300f, 0.11795316f, 0.19631892f, 0.19210221f, 0.09615196f, -0.03734349f, -0.01073574f, 
    -0.34952688f, 0.26259983f, 0.09480084f, 0.11167432f, 0.03571343f, 0.02543810f, 0.00267299f, -0.04500273f, 
    -0.04618863f, -0.03748619f, 0.04845957f, -0.03980478f, -0.02779423f, -0.19747782f, -0.09182351f, 0.20212014f, 
    0.10435824f, 0.05402322f, 0.07846316f, 0.09154342f, 0.02349474f, 0.13515340f, 0.00087791f, 0.26600996f, 
    0.07152560f, -0.12705067f, -0.04829590f, 0.12736975f, -0.17562102f, -0.24226439f, -0.08463623f, -0.05458877f, 
    0.04552368f, 0.08276466f, -0.00187886f, 0.02928317f, 0.08174366f, -0.05196233f, 0.16638297f, 0.06106421f, 
    0.00462563f, -0.01005243f, -0.07977675f, 0.00127285f, 0.04653274f, 0.02850145f, -0.02962654f, -0.08804237f, 
    -0.16330603f, 0.17751479f, 0.22288802f, 0.24181500f, 0.17270590f, 0.33668336f, 0.16556117f, 0.02472853f, 
    -0.01390982f, -0.07581589f, 0.18765746f, -0.03262294f, 0.22364306f, -0.01140039f, -0.30426717f, -0.06380218f, 
    -0.09291863f, 0.01551904f, -0.04401023f, 0.05380028f, 0.27703258f, -0.01572512f, 0.02592132f, -0.17466620f, 
    -0.10396612f, -0.20165357f, -0.04647151f, 0.05190593f, -0.01517203f, -0.00000451f, -0.09233949f, -0.04664191f, 
    0.01585137f, 0.02204225f, -0.06995625f, -0.00615491f, 0.39484265f, -0.17102015f, -0.36526075f, 0.03047579f, 
    0.07639261f, 0.00213073f, -0.06682891f, -0.13883771f, 0.11939684f, 0.14238684f, 0.22608836f, 0.17336145f, 
    -0.25049800f, -0.07918253f, 0.12366527f, -0.10695440f, 0.16656466f, -0.09825032f, 0.06994418f, 0.02614545f, 
    0.11015682f, 0.07466426f, 0.06637039f, 0.09876736f, 0.28423494f, -0.31094098f, -0.12320336f, 0.19943501f, 
    -0.02832460f, 0.06676606f, 0.14555626f, 0.08853662f, 0.07751486f, 0.03773868f, -0.12687115f, -0.06187700f, 
    -0.19311272f, 0.00020161f, -0.05314789f, -0.11906546f, -0.07494894f, -0.19043677f, -0.09571209f, -0.14687946f, 
    -0.02414806f, -0.07074134f, -0.10058394f, 0.08821336f, -0.03767507f, -0.18377613f, 0.18873456f, 0.27016211f, 
    0.07398926f, 0.12473782f, 0.08236655f, -0.00787426f, 0.15222698f, 0.01358085f, 0.03447245f, 0.07883887f, 
    -0.06613946f, -0.01938847f, 0.03233388f, -0.12761208f, -0.03874008f, -0.07262012f, -0.11494544f, -0.10319131f, 
    0.18848638f, -0.08398789f, 0.10771644f, 0.04092666f, -0.10919975f, 0.12280335f, -0.16809800f, 0.00792642f, 
    0.04749971f, 0.07764866f, 0.04562702f, -0.06805260f, 0.05114493f, -0.06528827f, -0.05156410f, 0.08240702f, 
    -0.10700502f, 0.09914346f, -0.26647609f, -0.06868826f, -0.02541587f, 0.18124151f, 0.05496027f, 0.00297369f, 
    0.08929463f, 0.19155781f, 0.09448061f, 0.06350188f, 0.22244781f, 0.40970597f, -0.00572668f, 0.10048737f, 
    -0.09788003f, -0.08136223f, -0.01899722f, -0.03351598f, -0.06359860f, 0.03373730f, 0.04043613f, 0.09994364f, 
    -0.19372182f, -0.31699124f, 0.26840651f, -0.01159143f, 0.06050142f, 0.13868912f, -0.47411749f, -0.04999688f, 
    -0.02758117f, -0.11327698f, -0.02665261f, 0.06395040f, -0.07836796f, -0.07162211f, 0.17245784f, -0.01646046f, 
    0.09153526f, -0.14253056f, 0.01203244f, -0.04285996f, 0.01758037f, 0.03110228f, 0.16991304f, -0.01362030f, 
    -0.07999400f, 0.09397583f, -0.08850684f, -0.16055772f, -0.08533306f, -0.06963223f, 0.13452338f, -0.02331179f, 
    0.13101591f, -0.07257587f, -0.09906285f, 0.01705011f, -0.14970632f, 0.28141552f, 0.32018000f, 0.18776268f, 
    0.01357235f, 0.05872316f, -0.11452895f, -0.03477886f, -0.01711746f, 0.00721436f, -0.04556666f, 0.11050547f, 
    0.04504335f, -0.18489039f, -0.04525585f, 0.11878101f, 0.18626541f, -0.05926735f, 0.11987773f, 0.28286231f, 
    -0.00351803f, 0.01964241f, 0.06454357f, -0.07912032f, -0.28827170f, 0.13055582f, -0.22599055f, -0.07106081f, 
    0.05376324f, 0.03006368f, -0.02656802f, 0.07566816f, 0.11082429f, -0.03101907f, -0.10037120f, -0.16424608f, 
    0.21586223f, 0.25284368f, 0.04350929f, 0.18346372f, -0.03298537f, -0.00949726f, -0.01465114f, -0.00526900f, 
    0.11734077f, -0.04832605f, 0.04562460f, 0.05521134f, 0.00287880f, -0.00122202f, -0.08610792f, -0.19391383f, 
    0.11230087f, -0.12082404f, 0.01288204f, 0.01588293f, 0.07641476f, 0.10283211f, -0.07714298f, 0.07486476f, 
    -0.01668166f, -0.15004830f, -0.06609098f, 0.09393052f, -0.09752698f, -0.05306704f, -0.01245948f, -0.09331346f, 
    0.03653155f, 0.01092854f, 0.19627792f, -0.00755367f, -0.07138635f, 0.07596593f, 0.25721589f, 0.03531853f, 
    0.09543278f, 0.15429592f, 0.00507525f, -0.16911772f, -0.06177156f, -0.18611282f, -0.01214223f, 0.11224572f, 
    -0.09037309f, -0.16968089f, -0.07203613f, -0.05688016f, -0.00485837f, 0.02282893f, -0.00948992f, -0.09346146f, 
    -0.01092312f, 0.08097167f, 0.01785305f, 0.03125341f, 0.35906741f, 0.08369979f, -0.16774671f, 0.14788802f, 
    0.00259163f, 0.09538007f, -0.01236645f, 0.05274405f, -0.05762541f, 0.10928386f, -0.01253620f, 0.04017307f, 
    -0.15657565f, 0.09471726f, 0.16667739f, -0.12915164f, 0.21149121f, -0.00372252f, 0.00039800f, -0.10577657f, 
    0.28331536f, -0.00757921f, -0.07111766f, -0.20453367f, 0.01378308f, 0.04212114f, 0.17555064f, -0.04131222f, 
    -0.02153076f, -0.10946172f, 0.16341999f, 0.09340703f, 0.12362036f, -0.06054479f, -0.07411774f, -0.01829609f, 
    0.10633525f, -0.15796040f, 0.14129394f, 0.06697904f, -0.04795174f, 0.00807826f, -0.05288386f, -0.10993043f, 
    0.27980232f, 0.17649488f, 0.00727466f, 0.04024021f, 0.21236756f, -0.17750452f, -0.08209362f, -0.84350485f, 
    0.03693842f, -0.03041738f, -0.04318086f, 0.12209320f, -0.02655757f, 0.00833660f, 0.03238945f, -0.06737174f, 
    0.15205126f, -0.23889010f, -0.02675548f, 0.02080363f, -0.02953906f, 0.24888253f, 0.00813968f, 0.12082952f, 
    -0.03841683f, 0.05517351f, 0.03217719f, -0.04254788f, -0.43690693f, -0.13491303f, -0.14118722f, -0.21435641f, 
    -0.24036554f, 0.23966248f, 0.01170331f, -0.21895841f, -0.18663286f, -0.12435590f, -0.13965099f, -0.04896103f, 
    0.19290318f, 0.03111726f, 0.04455255f, 0.04514312f, -0.12928981f, 0.01188776f, -0.05365752f, 0.02287841f, 
    -0.01925497f, 0.00071534f, 0.07437309f, -0.08077892f, -0.05630016f, 0.01230557f, 0.11081308f, -0.06682497f, 
    -0.08877380f, -0.05343670f, -0.05689215f, 0.03999682f, -0.09672605f, -0.08852696f, -0.02210515f, -0.00767406f, 
    0.52520263f, -0.13681327f, -0.00449485f, -0.05736488f, 0.18208355f, 0.00842323f, 0.19851680f, -0.13229206f, 
    -0.12320516f, -0.15087838f, -0.03407583f, -0.01468020f, 0.20288743f, 0.05028531f, -0.15863506f, 0.07093631f, 
    -0.07550871f, -0.11800244f, -0.02975474f, -0.26088440f, 0.12813510f, 0.13235952f, -0.06653854f, 0.21580702f, 
    0.04382837f, 0.02304854f, -0.16690445f, -0.49283177f, -0.02032890f, -0.08094003f, 0.10547777f, 0.08737380f, 
    -0.08468509f, 0.01547326f, 0.11362050f, 0.07866467f, 0.35898164f, 0.10482503f, -0.06657548f, -0.03060963f, 
    0.01038867f, -0.03925072f, 0.16705161f, 0.04329656f, 0.21342754f, 0.01858145f, 0.09463960f, -0.05641223f, 
    -0.36941525f, -0.58787620f, -0.29906964f, -0.21733591f, 0.25338995f, -0.03117059f, 0.05200294f, 0.21254164f, 
    -0.09411506f, -0.17675631f, -0.11151420f, -0.00750872f, -0.19175135f, -0.03662849f, 0.20761496f, -0.23016758f, 
    -0.03819233f, 0.28953099f, -0.05417429f, 0.11344287f, 0.02012319f, 0.02401952f, -0.17104468f, 0.13103721f, 
    0.38754821f, 0.11779585f, 0.17597046f, 0.30207017f, 0.08603188f, -0.08295204f, 0.01764674f, -0.06700958f, 
    0.11463654f, -0.10399435f, -0.14473790f, 0.05995764f, -0.19092561f, 0.22347303f, -0.14341205f, -0.11034741f, 
    0.01947761f, 0.18876877f, 0.01010434f, 0.00507770f, 0.07346582f, 0.05025924f, -0.06579247f, -0.14671348f, 
    0.23454647f, 0.18955421f, 0.04979449f, 0.05641546f, 0.22350919f, 0.03585932f, -0.01677579f, -0.13147011f, 
    0.01598099f, 0.08043683f, 0.14078015f, 0.05606407f, 0.06679529f, -0.06004187f, -0.00335239f, 0.10397355f, 
    0.02650966f, 0.04963347f, 0.17776652f, -0.13986437f, -0.02168602f, -0.07182942f, 0.06545097f, -0.00565212f, 
    -0.31318316f, 0.10004234f, 0.27098572f, -0.11893689f, -0.10391135f, -0.12920518f, -0.23502837f, -0.09125283f, 
    0.11101463f, -0.11894574f, -0.12255308f, 0.12465633f, 0.45394212f, -0.50794023f, 0.18756613f, 0.09047248f, 
    0.14448415f, 0.01251939f, 0.01314196f, -0.04918464f, 0.09031544f, -0.08586466f, 0.18895274f, 0.05987469f, 
    0.02155409f, 0.26831940f, -0.20483240f, -0.34696427f, -0.13784541f, -0.00965495f, 0.35276955f, 0.25361630f, 
    0.06232789f, 0.04955769f, 0.03548608f, -0.03930647f, -0.06994233f, 0.22537418f, -0.07748017f, 0.03369282f, 
    -0.01276224f, 0.10301606f, -0.08924621f, -0.06211345f, 0.08459018f, 0.04892677f, -0.04865964f, -0.01297398f, 
    -0.30798164f, -0.04700134f, -0.02555973f, -0.08319898f, -0.09492110f, 0.06213028f, -0.37798843f, 0.00435744f, 
    -0.06681184f, -0.00333019f, -0.09550197f, -0.10458848f, 0.27159265f, -0.24563828f, -0.34848866f, -0.09546985f, 
    0.07538842f, -0.17839985f, 0.10327276f, -0.17977713f, 0.02478317f, 0.03315777f, -0.08972207f, 0.14764649f, 
    -0.15385689f, 0.33957678f, -0.01681599f, -0.06131278f, -0.05392306f, -0.02191283f, -0.10866590f, -0.09788030f, 
    0.03401943f, 0.00856641f, -0.04766623f, 0.05247074f, -0.15223435f, 0.12189561f, 0.28911328f, 0.16775250f, 
    0.13716446f, -0.09072827f, -0.13804448f, -0.04494275f, 0.10786281f, 0.02346173f, 0.16979352f, 0.16234687f, 
    0.25425881f, 0.11999942f, -0.01918636f, -0.00786773f, 0.01516707f, 0.16081418f, 0.11470009f, 0.05847903f, 
    -0.07344850f, 0.03944034f, -0.03979513f, 0.17671004f, 0.08721513f, 0.25395799f, 0.24433164f, 0.08185797f, 
    0.08063359f, -0.04428261f, 0.10787244f, -0.20238197f, 0.00720786f, -0.03595411f, 0.05816655f, -0.09820366f, 
    0.15250616f, -0.02775153f, -0.06478365f, 0.10836491f, 0.03525225f, 0.19628687f, -0.01407040f, 0.22475615f, 
    0.06325550f, 0.03860094f, -0.22202617f, 0.04599442f, -0.06017471f, -0.21237801f, -0.35588822f, -0.05709206f, 
    0.23143578f, -0.07720890f, -0.05159061f, 0.01055184f, 0.00467938f, 0.14585939f, -0.12541880f, -0.03633870f, 
    0.34721136f, 0.20955487f, 0.18812349f, 0.08866659f, 0.01531356f, -0.04990125f, 0.07404113f, 0.05079634f, 
    -0.15030351f, 0.00513849f, -0.06389318f, -0.08202705f, -0.22197567f, 0.04721549f, 0.13670237f, -0.04753160f, 
    0.04069767f, 0.07630727f, 0.00824650f, -0.07396007f, 0.22190249f, 0.04497436f, 0.04872819f, 0.06814303f, 
    0.15233994f, 0.26173016f, -0.24672934f, -0.03356015f, 0.11563728f, -0.09933055f, -0.08553688f, 0.26930729f, 
    -0.09079048f, -0.06553714f, -0.07933363f, 0.24510139f, 0.17402934f, -0.03877021f, -0.02588218f, 0.06002339f, 
    0.08848065f, 0.11495295f, -0.02394452f, 0.00451123f, -0.02666564f, 0.02200866f, -0.04922926f, -0.14950047f, 
    -0.10970332f, -0.05990454f, -0.11778522f, -0.00539488f, -0.00004018f, 0.15272219f, -0.19840664f, 0.08644087f, 
    0.19402258f, 0.14491101f, 0.19186699f, 0.08808795f, -0.02983701f, -0.14165880f, -0.14313601f, -0.03233881f, 
    0.03707180f, 0.03766400f, 0.11247282f, -0.15388225f, 0.19096540f, 0.04707052f, -0.00831379f, 0.04853604f, 
    0.28360757f, 0.55005735f, -0.07114111f, -0.05890903f, 0.00776921f, 0.06895874f, 0.07074300f, 0.08612189f, 
    -0.09044282f, -0.10342082f, 0.00986606f, -0.11416255f, 0.31436551f, -0.21927446f, -0.04921105f, -0.11858752f, 
    0.23159716f, 0.03833806f, -0.05736493f, 0.18931462f, -0.04180212f, 0.05303062f, 0.16199309f, 0.02489087f, 
    -0.20389725f, -0.10675021f, 0.07073499f, -0.03178395f, -0.02677474f, -0.09686402f, -0.28967559f, -0.11737055f, 
    -0.00563454f, 0.12263825f, -0.17336406f, 0.00250429f, 0.45347750f, -0.30451497f, -0.16543424f, -0.08126064f, 
    -0.09019923f, -0.11671014f, -0.06365888f, -0.12845373f, 0.06012325f, 0.16761337f, 0.06834543f, -0.04247546f, 
    -0.21870631f, 0.07361623f, 0.05558341f, 0.23839875f, 0.04882729f, 0.07713331f, 0.12832370f, 0.12651080f, 
    -0.05838580f, 0.10704327f, 0.07738165f, -0.12750377f, -0.10684968f, -0.02044722f, -0.06725847f, 0.18309987f, 
    0.01094913f, -0.06089845f, 0.03211609f, 0.06220062f, 0.21584702f, 0.07619340f, 0.10791385f, -0.16014713f, 
    0.12155209f, -0.18728182f, -0.05647000f, -0.10852323f, 0.02113383f, 0.05667873f, -0.08045013f, -0.10621203f, 
    0.06525640f, -0.11971831f, -0.14322200f, -0.08287586f, 0.14405350f, -0.07214060f, -0.11588918f, 0.21724175f, 
    0.06470440f, -0.00996170f, 0.14218532f, -0.16984479f, -0.01167771f, 0.14223112f, 0.15711214f, 0.10042002f, 
    0.10056972f, 0.18997717f, -0.10762417f, -0.26222697f, 0.11051018f, 0.15899417f, -0.07524481f, 0.05565765f, 
    0.07695466f, -0.07252044f, 0.08233558f, -0.01800155f, 0.53254938f, -0.01453491f, 0.25988615f, -0.03730539f, 
    0.00003465f, 0.19422159f, 0.06077779f, -0.07779814f, 0.07157468f, -0.13069266f, 0.12122996f, -0.06424300f, 
    -0.08858982f, 0.19434242f, 0.02309816f, 0.08649736f, -0.05869945f, 0.01069762f, -0.31988806f, -0.01513111f, 
    -0.17716834f, -0.20120741f, -0.04058252f, -0.12263319f, 0.19478591f, -0.18348473f, 0.17216252f, 0.07841978f, 
    -0.00696322f, 0.05747325f, -0.09764400f, 0.04995880f, 0.13832711f, -0.01351250f, 0.08435991f, 0.23966309f, 
    -0.25248760f, 0.10570122f, -0.07682456f, -0.06750613f, -0.00046172f, -0.03152262f, 0.07271846f, 0.08581220f, 
    0.15446556f, -0.07626521f, 0.07044575f, -0.23643804f, -0.06697419f, 0.32985249f, -0.20068389f, 0.06520274f, 
    0.15658140f, 0.12247120f, 0.04718943f, -0.04776240f, -0.20857637f, -0.29153571f, -0.07353297f, -0.18525405f, 
    0.14341360f, -0.19023484f, -0.09638995f, -0.20419537f, -0.13060847f, 0.00852062f, 0.09747445f, -0.08391789f, 
    0.20138204f, 0.15644303f, 0.07337724f, 0.29103211f, 0.06069135f, 0.09114881f, 0.22805949f, 0.13895869f, 
    -0.01423701f, -0.13353549f, 0.00394705f, 0.26306885f, 0.14567500f, 0.06959379f, 0.08578976f, 0.12735505f, 
    -0.31296569f, 0.08265800f, 0.09867310f, 0.23255494f, 0.10112752f, 0.04892443f, 0.00773710f, -0.10338244f, 
    -0.07027046f, -0.11089794f, -0.14853089f, -0.10536040f, -0.01503374f, 0.05772163f, 0.00323393f, 0.28479591f, 
    -0.06836671f, 0.02965325f, 0.09870225f, 0.01591345f, 0.01302723f, 0.04382803f, 0.04113306f, 0.18581067f, 
    0.23588948f, -0.05801307f, -0.15159807f, 0.01981340f, -0.06300198f, -0.05943788f, 0.16870552f, -0.08629560f, 
    -0.15620279f, 0.05541231f, -0.11367468f, -0.08164111f, 0.07272717f, 0.15659288f, -0.04499956f, -0.04295684f, 
    -0.09280830f, 0.05353963f, -0.03765921f, 0.16606067f, 0.14499232f, 0.02888748f, -0.02735742f, -0.15555589f, 
    -0.17726158f, 0.22490293f, 0.28599891f, 0.15241803f, 0.17653154f, 0.11070239f, 0.10232503f, 0.07395954f, 
    -0.03971169f, -0.15217043f, 0.00656200f, -0.02482454f, 0.06559027f, 0.11119540f, -0.04692243f, -0.09340368f, 
    -0.04755013f, -0.10208313f, 0.05390218f, 0.02986407f, 0.03132796f, 0.19809411f, 0.02729217f, -0.10626493f, 
    0.05199100f, -0.04086338f, 0.14543653f, 0.27061504f, -0.00019798f, -0.18321143f, -0.10520591f, -0.07551486f, 
    0.01510832f, 0.00680844f, 0.03044613f, -0.02677013f, 0.19927493f, -0.10371560f, -0.13234723f, 0.07823955f, 
    -0.03530669f, 0.00797778f, -0.11173768f, -0.06437770f, 0.07214645f, 0.12299401f, 0.20704114f, 0.14852370f, 
    -0.20875661f, -0.24478300f, 0.10961069f, 0.28273660f, -0.00840518f, -0.17781489f, -0.02319538f, 0.01496092f, 
    0.02400742f, 0.17327663f, 0.00804127f, 0.07370842f, 0.19675358f, -0.30091164f, -0.19759257f, 0.13122395f, 
    -0.07401475f, 0.04398192f, 0.07339727f, -0.05262434f, -0.15016089f, -0.05325944f, 0.02435584f, -0.13413000f, 
    -0.09516995f, -0.12592830f, -0.00775604f, -0.27046719f, -0.07888220f, -0.12397757f, -0.06279995f, -0.17790219f, 
    -0.24394521f, -0.17866912f, -0.11402645f, -0.16594605f, -0.10661124f, -0.10020576f, 0.07047115f, 0.19376488f, 
    -0.07140625f, 0.12447150f, -0.03570423f, -0.07315034f, 0.25783318f, 0.15798758f, 0.12945001f, 0.21015564f, 
    -0.07415868f, 0.07758332f, 0.17218791f, -0.06761321f, 0.17824765f, -0.06931563f, 0.00078673f, -0.07466130f, 
    0.11649290f, -0.21266684f, -0.06229473f, 0.04338600f, 0.03681926f, 0.05278097f, -0.19533244f, 0.17945486f, 
    0.11120177f, -0.07382932f, -0.00116156f, -0.20596389f, -0.27222514f, -0.18344286f, -0.17085394f, -0.22018769f, 
    -0.03101986f, 0.06458277f, -0.02394662f, 0.03685195f, 0.03790749f, -0.03808425f, 0.05647010f, 0.00011948f, 
    -0.01630771f, 0.05096879f, -0.04883851f, 0.00141992f, 0.05467473f, -0.03175513f, -0.06134639f, 0.04541273f, 
    0.05416701f, -0.02730739f, -0.07739895f, -0.04607575f, -0.02466638f, -0.05409242f, -0.04424899f, -0.03627717f, 
    -0.01252496f, -0.06957915f, -0.04817752f, -0.08506208f, -0.05010882f, -0.05520355f, -0.06789712f, 0.04697784f, 
    -0.05632736f, 0.02454807f, -0.03062404f, -0.04755304f, 0.04707820f, 0.00749948f, 0.02197875f, -0.04714156f, 
    0.00252185f, -0.04840811f, -0.03680291f, -0.02555170f, -0.00053118f, 0.04709065f, -0.06729838f, -0.05794208f, 
    0.02159451f, 0.07681626f, -0.02696619f, -0.07234901f, -0.07097691f, -0.07840732f, 0.04766442f, -0.01029815f, 
    0.01904671f, -0.01140459f, 0.03986152f, -0.04440782f, 0.02382269f, 0.00030471f, 0.04307132f, -0.00297308f, 
    -0.01653642f, 0.01292650f, -0.04739618f, -0.00629626f, -0.06867133f, -0.08473616f, -0.01007844f, -0.07520238f, 
    -0.01557318f, -0.06104478f, -0.03816941f, 0.00048255f, -0.08555333f, 0.01008685f, -0.01840293f, -0.05778296f, 
    -0.05159751f, -0.07090131f, -0.06026208f, -0.04488053f, 0.01393147f, -0.05190757f, -0.06759311f, 0.01643690f, 
    0.04053262f, 0.01329977f, -0.05832647f, -0.02218713f, -0.03642598f, 0.05409340f, -0.00256311f, 0.02174204f, 
    -0.00259491f, -0.02539302f, -0.05260123f, 0.03334427f, 0.04882614f, -0.03511079f, -0.02405165f, 0.01912128f, 
    0.01576745f, -0.07604627f, -0.05565176f, -0.07588565f, -0.01041660f, 0.03650713f, -0.07141934f, 0.01681273f, 
    -0.02201576f, -0.04927612f, -0.08480940f, 0.01167541f, -0.04673687f, 0.03632135f, -0.02907163f, -0.07765975f, 
    -0.07119421f, 0.00555317f, 0.00930889f, -0.04883472f, 0.04465661f, 0.03080376f, 0.01404292f, -0.02562363f, 
    -0.05674163f, -0.01638577f, -0.02665826f, -0.00969621f, -0.00573539f, -0.05743846f, -0.02308366f, 0.05236159f, 
    -0.06640494f, 0.03685416f, -0.07459179f, -0.02737659f, 0.01279734f, -0.02250028f, -0.01866783f, -0.00611888f, 
    -0.06548258f, 0.00295051f, 0.02579738f, -0.01725488f, 0.04150837f, -0.00051584f, 0.03191268f, -0.05349899f, 
    -0.06849084f, -0.02070464f, -0.05344901f, -0.04679003f, -0.02545632f, 0.00134883f, 0.00038638f, 0.05903447f, 
    -0.01289533f, -0.03221118f, 0.05532707f, 0.02722883f, 0.04825405f, 0.01057709f, 0.05581601f, 0.03729454f, 
    0.02984685f, 0.01397941f, -0.02715988f, -0.08697624f, 0.04543483f, 0.04977274f, -0.07890570f, 0.04016734f, 
    0.05445576f, 0.05854532f, 0.01191996f, -0.05698326f, -0.07353687f, 0.03567931f, -0.06981589f, -0.04214598f, 
    -0.02295090f, -0.08033863f, 0.00382200f, 0.03777219f, -0.02758613f, -0.02316026f, -0.08303403f, 0.03681846f, 
    -0.10400575f, -0.04258030f, 0.11086276f, 0.12306808f, 0.13726893f, 0.09496075f, 0.01058518f, 0.11254024f, 
    -0.03590456f, 0.03030214f, 0.02450047f, -0.15307964f, 0.01377226f, -0.03365362f, -0.07976153f, -0.20775099f, 
    0.02678483f, 0.10677966f, -0.06734441f, 0.13381790f, 0.00017115f, 0.10948750f, -0.07150438f, -0.24718736f, 
    0.58993721f, -0.21582232f, 0.09997127f, -0.30235174f, -0.14944898f, -0.06853744f, 0.15842354f, 0.27459478f, 
    0.13505615f, 0.12970370f, 0.05224194f, -0.09581316f, 0.02464045f, 0.05845108f, 0.05549148f, -0.20727555f, 
    0.01921666f, 0.06636326f, 0.02308290f, 0.07467854f, 0.01857686f, -0.04469462f, -0.10737677f, 0.03067571f, 
    -0.23152554f, 0.08548170f, -0.01135595f, -0.05639210f, 0.00436276f, -0.04618846f, -0.13312653f, -0.12192730f, 
    -0.08971751f, 0.02131947f, 0.05272990f, 0.01832142f, 0.03799994f, -0.10521306f, 0.07286679f, 0.05524397f, 
    -0.01192040f, 0.02680270f, 0.08022363f, -0.08222777f, 0.11870984f, -0.09512606f, 0.00397374f, -0.07339241f, 
    0.17698660f, -0.15386842f, -0.21273656f, -0.14372951f, 0.03109030f, 0.09168394f, 0.11235554f, 0.16200195f, 
    -0.01041385f, 0.03730337f, -0.07390758f, 0.05893389f, 0.11038464f, -0.09001216f, -0.05004749f, 0.24064648f, 
    0.03399419f, 0.00118818f, -0.00237321f, -0.08961438f, 0.03089810f, -0.12992479f, 0.17771727f, 0.13937561f, 
    -0.17392300f, 0.00516125f, -0.17292432f, -0.30634400f, -0.08987344f, 0.12360238f, 0.08376391f, -0.03654334f, 
    0.01174966f, -0.10257974f, -0.01821442f, -0.17709300f, -0.17187355f, 0.17554453f, 0.08119321f, 0.08788706f, 
    -0.04835841f, -0.06989370f, 0.02708671f, -0.11454026f, 0.19118290f, -0.06703196f, -0.11326683f, -0.08104571f, 
    0.11340701f, 0.34913585f, 0.07186852f, -0.17232655f, 0.04878212f, 0.10588795f, 0.19020988f, 0.18738195f, 
    0.06648183f, 0.02060248f, -0.07631546f, -0.00341702f, -0.19758862f, 0.14199185f, 0.22776006f, 0.06342883f, 
    -0.16529144f, 0.02154846f, 0.05568695f, 0.02500048f, 0.20683688f, -0.05561435f, -0.30058494f, 0.06211782f, 
    0.02234553f, -0.00568337f, 0.01298125f, 0.26818004f, -0.18105860f, 0.04710203f, -0.02604692f, 0.05745246f, 
    0.17227867f, 0.05051011f, 0.03923167f, 0.21151230f, 0.06251125f, 0.02795125f, 0.06008101f, -0.15576476f, 
    0.01759540f, -0.05493947f, 0.14667864f, -0.02437430f, -0.03214538f, -0.10290687f, 0.07969467f, -0.19116771f, 
    0.13053691f, -0.10444974f, -0.38413510f, 0.08646511f, -0.02727934f, -0.13261572f, 0.09040007f, 0.06699058f, 
    -0.21635459f, 0.01801832f, 0.09084006f, -0.09182020f, -0.16710322f, 0.12529767f, -0.02487722f, 0.08960451f, 
    0.05685223f, 0.16342500f, 0.16831259f, 0.01826985f, -0.11983529f, 0.02714842f, -0.03391116f, 0.08320386f, 
    -0.34152278f, -0.12682271f, -0.06759621f, -0.10598130f, -0.01937952f, -0.03329496f, -0.15061025f, 0.00209010f, 
    0.09619285f, -0.01662155f, -0.02371384f, 0.11914288f, 0.21325850f, -0.37991291f, 0.05217951f, 0.08237981f, 
    0.10406718f, 0.18098935f, 0.08798467f, -0.10298467f, 0.11184283f, -0.02167174f, 0.02819505f, 0.01797619f, 
    -0.00667246f, 0.39841911f, -0.27354005f, -0.12791167f, 0.00797059f, 0.09110457f, 0.16084236f, -0.02289721f, 
    -0.12474204f, -0.07041657f, 0.06366201f, 0.09503008f, 0.15273343f, -0.04638570f, -0.14179304f, 0.05197294f, 
    0.13514891f, 0.02161916f, 0.04419404f, 0.11428700f, -0.02702089f, 0.02458314f, 0.04039482f, -0.07290323f, 
    -0.37623274f, -0.08412944f, -0.03806060f, 0.13154894f, -0.00812596f, -0.02089058f, -0.28392863f, -0.07985284f, 
    -0.00148081f, -0.04382315f, -0.01542722f, -0.01088566f, 0.40938771f, -0.21582925f, -0.15197654f, -0.14105734f, 
    -0.03401055f, -0.12638985f, 0.12846637f, 0.01718888f, -0.06195316f, 0.11119052f, -0.00124239f, 0.04113135f, 
    -0.38487053f, 0.27643362f, 0.11240406f, 0.17061011f, 0.08327944f, 0.31426883f, -0.07044978f, -0.13233344f, 
    0.02755928f, 0.10616085f, -0.01063729f, -0.07685932f, -0.23448193f, 0.07618774f, -0.02316277f, 0.17547122f, 
    0.07444229f, -0.07721970f, -0.11211192f, -0.04445414f, 0.16837357f, 0.09600787f, -0.10419621f, -0.07218699f, 
    0.17208421f, -0.11710076f, -0.05112017f, -0.01412222f, 0.06718557f, 0.25491986f, -0.04919782f, -0.13241033f, 
    -0.02224348f, 0.02375430f, -0.04574108f, 0.05219231f, 0.20824635f, -0.02476356f, -0.10840838f, 0.23501372f, 
    0.01496082f, -0.02480903f, 0.02136131f, -0.04603178f, -0.04593321f, -0.00248151f, 0.14607301f, 0.02882972f, 
    0.12096184f, 0.09659551f, -0.16664539f, -0.02737864f, 0.04292081f, 0.04147347f, -0.05386672f, -0.02658200f, 
    -0.02654556f, 0.00154467f, -0.07337644f, 0.05749439f, 0.50762022f, -0.19447652f, -0.07412338f, -0.30353346f, 
    0.10944498f, -0.08180927f, 0.06861298f, 0.05527362f, 0.01034427f, 0.05658606f, 0.04669037f, -0.03025444f, 
    -0.20373133f, 0.21501558f, 0.21262017f, 0.05294738f, 0.14950629f, -0.12437376f, -0.05649480f, 0.10473198f, 
    -0.26591590f, 0.04340953f, -0.01074537f, 0.04893878f, 0.04857383f, -0.08101210f, 0.22088359f, 0.08667742f, 
    0.02979656f, 0.03903140f, -0.02335134f, -0.06475355f, 0.14159818f, -0.03843425f, 0.05035374f, 0.04500846f, 
    -0.09610730f, 0.05699334f, -0.06272519f, -0.00879590f, 0.02397003f, -0.04092495f, -0.07015242f, -0.02611241f, 
    0.12519109f, -0.10329743f, -0.17039864f, 0.07796855f, 0.00305959f, 0.08006679f, -0.23061404f, 0.16022834f, 
    0.03939930f, 0.02019609f, -0.10441722f, -0.10504110f, -0.07145853f, -0.08525328f, 0.03243161f, -0.02938653f, 
    -0.31819668f, -0.04044349f, -0.42636743f, -0.14784355f, -0.06849184f, 0.23057386f, -0.20145509f, 0.01406539f, 
    0.14741479f, 0.08170645f, 0.08354839f, 0.03940574f, 0.29973483f, -0.06056023f, -0.05113864f, -0.17336467f, 
    -0.41020456f, -0.08546207f, -0.09153379f, -0.09443402f, -0.00324429f, 0.06165992f, -0.00111721f, -0.11421388f, 
    -0.23497714f, -0.23065452f, 0.15842044f, -0.21516892f, 0.00146674f, 0.13824147f, -0.42179909f, 0.14551271f, 
    -0.00162018f, -0.11307772f, -0.14858867f, -0.04164813f, -0.09540588f, 0.00448984f, 0.06976984f, -0.08290269f, 
    0.14868116f, -0.10140703f, -0.04934993f, 0.08329632f, 0.07774053f, 0.05080244f, -0.02570511f, 0.17164029f, 
    -0.26253575f, 0.06669042f, -0.19082864f, -0.26580882f, 0.01474131f, -0.01630084f, -0.00354826f, -0.25273916f, 
    0.14214358f, -0.06289862f, -0.04748241f, 0.02507857f, 0.12663870f, 0.04852865f, 0.39096418f, 0.19137144f, 
    -0.00654362f, -0.02381501f, -0.16617134f, -0.25084770f, 0.10279654f, 0.06417044f, 0.05974518f, 0.09115491f, 
    0.08215667f, -0.07232232f, -0.30564827f, 0.09883837f, 0.17235179f, -0.02581126f, 0.12294910f, 0.31050786f, 
    -0.08733540f, -0.03471318f, -0.04372921f, -0.10858119f, -0.46865761f, 0.30752063f, -0.15057960f, 0.08884124f, 
    0.04025732f, 0.02549203f, 0.00424479f, -0.05322212f, 0.10495472f, 0.05085992f, 0.11282648f, 0.09926462f, 
    0.16745357f, 0.29414478f, -0.05947988f, 0.09010269f, -0.11231732f, 0.00676497f, -0.13771634f, -0.07023434f, 
    0.02315613f, -0.10527867f, -0.01483335f, -0.00971388f, -0.09144420f, 0.06206711f, 0.17162080f, -0.12708020f, 
    0.04777319f, -0.20793204f, 0.04975592f, -0.31003359f, 0.13242523f, 0.12243605f, 0.00522350f, 0.11659527f, 
    -0.12599224f, 0.08273428f, 0.06286909f, -0.23519570f, 0.02259847f, 0.02582868f, 0.03677341f, 0.15279602f, 
    0.15496737f, 0.07204539f, 0.12022889f, -0.05139035f, 0.14020982f, -0.28799504f, 0.17912172f, 0.26333246f, 
    0.13073443f, -0.16372688f, -0.05658562f, -0.10404597f, 0.09648983f, 0.08557083f, 0.10853910f, 0.03115484f, 
    -0.05090080f, 0.03627833f, 0.12814686f, 0.18498896f, -0.13228016f, -0.07284669f, 0.00755874f, -0.13041006f, 
    0.13255984f, 0.05804041f, 0.07710480f, 0.07034950f, 0.29058880f, -0.01478589f, 0.07965285f, 0.00872577f, 
    -0.01136541f, 0.05545263f, 0.03962653f, 0.07649072f, 0.06431624f, 0.14622961f, 0.07954092f, -0.03787706f, 
    -0.17781542f, 0.12989400f, 0.00957041f, -0.10828678f, 0.08441682f, 0.05315178f, -0.03891977f, -0.01211436f, 
    0.32557982f, 0.06843712f, -0.19535263f, 0.00293790f, -0.10165320f, 0.28978595f, 0.25516167f, 0.00055427f, 
    -0.02059222f, 0.06123520f, 0.19489214f, 0.03904042f, -0.00786548f, -0.12824653f, -0.08528116f, -0.02965637f, 
    -0.10080282f, 0.10475776f, -0.26303518f, -0.16076626f, -0.04871126f, 0.22250414f, 0.01758448f, -0.00486610f, 
    0.13660492f, -0.00242548f, 0.24730986f, 0.23244132f, 0.33109942f, 0.22948879f, 0.02128853f, 0.03936173f, 
    -0.10093572f, -0.10289349f, 0.00517733f, -0.18709943f, -0.01913330f, -0.04288742f, 0.08785183f, 0.15668862f, 
    -0.21234654f, -0.35124493f, 0.38146350f, -0.02864809f, 0.00004718f, 0.22887404f, -0.31045625f, 0.02162376f, 
    0.00470612f, -0.04839800f, -0.06059061f, 0.01234599f, -0.09599718f, -0.03822512f, 0.13437450f, -0.06872449f, 
    0.08684728f, -0.01202079f, -0.05383579f, 0.00252970f, 0.08628970f, -0.11305039f, 0.05253905f, 0.00744719f, 
    -0.08701275f, 0.03502547f, -0.16637260f, -0.32288370f, -0.02809357f, 0.04358537f, -0.06882964f, -0.03105931f, 
    -0.00497978f, 0.03499634f, -0.14589682f, -0.09898808f, 0.06140196f, 0.08965067f, 0.17841406f, 0.13032767f, 
    0.15696774f, 0.05981066f, -0.08761217f, -0.14640281f, 0.08302549f, -0.00959983f, -0.07202113f, 0.24039274f, 
    0.29189381f, 0.09348679f, -0.03058266f, 0.15364583f, 0.11133189f, -0.08179792f, -0.00224206f, 0.22622576f, 
    -0.00987776f, -0.00671679f, 0.11021932f, 0.00194793f, -0.34763971f, 0.22867900f, -0.07278664f, -0.12428318f, 
    -0.04525447f, -0.00929205f, -0.02571221f, 0.03620550f, 0.09218064f, -0.06074517f, 0.10853988f, -0.01853690f, 
    0.26352072f, 0.30678886f, -0.06140386f, 0.08989044f, 0.00945454f, -0.11058360f, 0.03052712f, -0.05309032f, 
    0.01059382f, -0.02244820f, 0.12586673f, 0.03865023f, -0.13391046f, 0.14907658f, 0.14301059f, -0.24422194f, 
    0.20376807f, -0.13154219f, 0.10710175f, -0.22240150f, 0.03228583f, -0.02604620f, 0.04116501f, 0.02272652f, 
    0.06932969f, -0.05405307f, 0.15369074f, 0.26158497f, -0.01779284f, 0.07465409f, 0.08548155f, 0.09260365f, 
    0.07963794f, 0.02588062f, 0.09920529f, 0.09085241f, -0.10660880f, -0.04689804f, 0.09321226f, 0.11650582f, 
    0.16931161f, -0.06227429f, -0.03705633f, -0.30956322f, -0.02896814f, 0.04460101f, -0.13251679f, 0.05399888f, 
    0.13805500f, -0.19782813f, -0.05395093f, 0.02851536f, -0.03351226f, 0.18426821f, 0.20221971f, 0.02475168f, 
    -0.01037117f, -0.00162226f, 0.05022683f, -0.09006547f, 0.25795245f, 0.10911399f, -0.06812437f, 0.19912539f, 
    -0.01196185f, -0.06420209f, -0.02732419f, -0.04621572f, -0.10861225f, 0.10944333f, -0.01215808f, -0.00163788f, 
    -0.10411096f, 0.25753996f, 0.09390765f, -0.12243842f, 0.02529977f, 0.03418625f, -0.07165977f, 0.08298603f, 
    0.21045734f, 0.06653327f, -0.12414360f, -0.13549319f, 0.18544552f, 0.07967363f, 0.16765450f, 0.05222528f, 
    -0.12841149f, 0.05756482f, 0.14696556f, -0.07716417f, 0.06147302f, -0.19173285f, -0.16268367f, -0.07463865f, 
    -0.05969791f, 0.02026454f, -0.01180106f, -0.04142196f, 0.05273994f, -0.00226019f, 0.04125259f, 0.05857559f, 
    0.04396040f, -0.06139876f, 0.05152043f, 0.05974508f, -0.02871254f, -0.04494768f, -0.04673749f, -0.04668198f, 
    -0.01854711f, -0.02273388f, 0.04283468f, -0.06894430f, -0.00566263f, 0.01741682f, -0.05292254f, -0.01915291f, 
    -0.04894535f, -0.05775854f, -0.04690896f, -0.07897095f, -0.04981938f, -0.06271055f, -0.06515900f, -0.06605834f, 
    0.02656485f, 0.04996336f, -0.02880351f, -0.01280620f, 0.00249313f, -0.01523022f, -0.07232423f, 0.03230178f, 
    0.03114651f, 0.00681669f, 0.03541667f, -0.03165383f, 0.02196997f, 0.00716238f, 0.03879410f, -0.05165045f, 
    -0.05703862f, -0.02648265f, -0.00349465f, 0.06677218f, -0.02393945f, 0.00103742f, -0.04850461f, -0.08201069f, 
    -0.04660787f, -0.03431596f, -0.01839784f, 0.01868534f, -0.01725896f, -0.00656853f, -0.00486356f, -0.05182499f, 
    0.02389905f, -0.02958595f, 0.02321834f, -0.01402150f, 0.00620644f, 0.05284518f, -0.06358054f, 0.00000696f, 
    -0.00173884f, 0.00402375f, 0.03893599f, 0.04926866f, -0.00631626f, -0.02062554f, 0.00101491f, -0.03630452f, 
    0.01024437f, -0.00628727f, -0.05668312f, 0.03791859f, 0.01549473f, 0.01388510f, -0.01111412f, 0.03488667f, 
    -0.03677988f, -0.07783511f, -0.01699013f, -0.06660084f, 0.05236347f, 0.04748268f, 0.01215728f, -0.00874623f, 
    0.03030769f, 0.03117927f, 0.01630807f, 0.03659138f, 0.01573003f, 0.00045941f, 0.03444161f, -0.03329745f, 
    0.01222598f, -0.02437670f, -0.03393414f, 0.05881270f, 0.04974015f, -0.07673455f, -0.00381146f, 0.04499947f, 
    0.03758320f, 0.03000480f, -0.00482967f, 0.00364249f, 0.00901228f, -0.07576054f, -0.03428211f, 0.02407787f, 
    -0.06335267f, -0.07647380f, 0.02914751f, 0.03907274f, 0.03114712f, -0.06064552f, -0.07408369f, 0.03730638f, 
    0.05538774f, -0.04959653f, -0.06203317f, 0.01608350f, -0.01009243f, -0.05663953f, 0.00471967f, -0.00909508f, 
    -0.05356681f, 0.05142168f, -0.02548204f, -0.07832982f, 0.03094236f, 0.00668364f, -0.01472561f, 0.04257084f, 
    -0.04687022f, -0.01267737f, -0.03575636f, 0.05664117f, 0.01315727f, 0.01609889f, -0.01848225f, 0.04323964f, 
    0.05166530f, -0.07575979f, -0.08017387f, -0.01939814f, -0.01419883f, 0.04356841f, 0.06104062f, 0.01568691f, 
    0.06664889f, -0.06958669f, -0.06479548f, -0.06803203f, -0.05446416f, 0.00198769f, 0.04138549f, 0.05107354f, 
    -0.03367689f, -0.01262932f, -0.05804651f, -0.02500884f, 0.02590090f, 0.04589822f, 0.01465856f, -0.04769745f, 
    -0.06281352f, -0.03595749f, 0.01263828f, -0.00143791f, 0.02820774f, 0.06574711f, -0.07586204f, 0.02542626f, 
    -0.03481324f, -0.01383872f, 0.05075973f, 0.02949678f, -0.06017929f, -0.02251271f, 0.01656912f, 0.04650246f, 
    -0.05951646f, -0.06233167f, 0.16875848f, -0.16439445f, -0.31175360f, 0.01860553f, -0.10190186f, 0.14361314f, 
    0.01428512f, 0.00851092f, -0.02798294f, 0.03957886f, 0.15008053f, -0.32490766f, -0.08560639f, 0.27421078f, 
    0.14215338f, 0.06917495f, -0.00366266f, -0.04913791f, 0.13186975f, -0.06200992f, 0.00555957f, 0.00424999f, 
    -0.27442026f, 0.52885932f, -0.14987932f, 0.05078021f, 0.03467822f, -0.02615109f, 0.14105932f, 0.07393253f, 
    -0.14731294f, 0.10140318f, 0.08215477f, -0.02386917f, 0.09788219f, -0.10126739f, -0.08196478f, 0.04561034f, 
    0.02886955f, 0.03851617f, -0.00161600f, 0.11236481f, 0.04436437f, 0.07798374f, 0.01250989f, -0.07968909f, 
    -0.06959397f, -0.07048778f, 0.08735520f, 0.02747302f, -0.23760921f, -0.05520980f, -0.12210806f, 0.04549436f, 
    -0.11525317f, 0.05883681f, -0.05621014f, -0.07127332f, 0.30844694f, -0.10614115f, -0.30422473f, -0.35869259f, 
    0.01623891f, 0.06357192f, 0.06702665f, 0.08688113f, -0.04413251f, 0.03571190f, -0.19504628f, -0.01651791f, 
    -0.34610793f, 0.34961110f, 0.31209767f, 0.17102885f, 0.04126677f, 0.14281763f, -0.02957638f, 0.02003856f, 
    -0.03059725f, 0.05291559f, 0.01420518f, -0.12458045f, -0.05906432f, 0.05327166f, 0.21721648f, 0.04862485f, 
    -0.07154816f, -0.11999444f, -0.08400233f, 0.00833169f, 0.15952295f, 0.04591260f, 0.03322161f, -0.14319539f, 
    0.18392654f, -0.30520779f, 0.06955025f, 0.02981680f, 0.13451017f, 0.10433196f, -0.09583414f, 0.04998099f, 
    0.02330981f, 0.04303251f, -0.00190981f, 0.04677674f, 0.20763046f, 0.03892506f, -0.04411755f, 0.21585679f, 
    0.03593543f, 0.05929022f, -0.06751724f, -0.03077085f, 0.03850503f, 0.00721143f, 0.22328353f, 0.09205387f, 
    -0.03611543f, -0.24385548f, -0.01391211f, 0.15015575f, -0.00308537f, -0.04259875f, -0.07601684f, 0.02504232f, 
    -0.03733061f, -0.03220629f, -0.13016406f, -0.00370322f, 0.28304830f, 0.01453118f, -0.16160496f, -0.17340939f, 
    0.09800955f, 0.11274255f, 0.12431183f, -0.04239547f, -0.07518572f, -0.04218821f, 0.19473697f, -0.03009914f, 
    0.11394137f, 0.11711126f, -0.11130881f, -0.23735386f, -0.03555445f, -0.05193796f, 0.04651602f, 0.06200919f, 
    -0.26005328f, -0.05196397f, 0.00690440f, -0.03163166f, -0.20488848f, -0.15172368f, 0.04449717f, 0.23809852f, 
    -0.06406319f, 0.12633082f, -0.09900077f, -0.02611661f, 0.04061835f, 0.04238886f, 0.01852802f, 0.14122424f, 
    -0.18422472f, 0.03064533f, 0.27674484f, 0.13439681f, 0.02131731f, -0.12429313f, -0.04502606f, 0.02235808f, 
    -0.00947159f, -0.06546780f, 0.03138985f, -0.02399030f, 0.28347459f, 0.11417938f, -0.08043819f, 0.18562973f, 
    -0.06799060f, 0.05684548f, -0.05408037f, -0.06144452f, 0.04747508f, -0.00137279f, 0.26250714f, 0.00958475f, 
    0.01624565f, -0.00315388f, 0.04454457f, 0.00120399f, 0.02668360f, -0.04127437f, 0.00029393f, -0.06380238f, 
    -0.07695042f, -0.05789166f, -0.02438226f, -0.06134767f, 0.01750396f, -0.00348012f, 0.00604265f, -0.04753882f, 
    0.04985404f, -0.07239788f, -0.06728703f, -0.05721141f, 0.03911756f, 0.01733482f, -0.04529684f, 0.02902537f, 
    -0.00961000f, 0.03931214f, -0.02629999f, -0.05391581f, 0.01183818f, -0.05924022f, 0.02270996f, -0.07900081f, 
    -0.04321798f, -0.00499445f, -0.02548498f, 0.06637804f, 0.02900803f, 0.05822663f, -0.04921316f, 0.02340685f, 
    -0.00150436f, -0.02230774f, -0.04049814f, 0.05735151f, -0.01729913f, -0.04440039f, -0.05264350f, 0.05164586f, 
    -0.02385374f, -0.00065973f, -0.03360277f, 0.00799682f, -0.01521540f, 0.01369784f, 0.01164704f, -0.06612596f, 
    0.04173368f, 0.03856446f, 0.03188115f, 0.04665576f, -0.04893808f, -0.04201877f, -0.07729147f, 0.04904168f, 
    0.01824111f, 0.02327631f, -0.00799308f, 0.05240392f, -0.05262026f, -0.05485975f, 0.06028613f, 0.02528018f, 
    0.05455206f, -0.04699786f, -0.01089835f, -0.02812118f, 0.04397921f, 0.05001749f, -0.02213457f, -0.03788953f, 
    0.04967541f, -0.04810610f, -0.02531942f, -0.07478781f, -0.07332673f, 0.04493822f, -0.04353622f, -0.03821566f, 
    -0.03502956f, -0.00424532f, -0.00348711f, -0.06711648f, 0.00569254f, 0.01476367f, -0.01406097f, -0.02002525f, 
    0.02098826f, 0.05486913f, 0.04691221f, -0.01540264f, -0.06521900f, 0.01833309f, -0.05288939f, 0.02511576f, 
    0.05671979f, -0.07094993f, -0.02394348f, -0.06891089f, 0.02353159f, -0.07661012f, 0.02069407f, 0.04238630f, 
    0.05546191f, 0.02149241f, 0.04143839f, -0.07248574f, -0.06038097f, 0.05203423f, -0.06143207f, 0.00896828f, 
    -0.00893738f, -0.03651906f, -0.04585071f, -0.04589193f, 0.02409198f, -0.00127528f, -0.02476256f, -0.04176237f, 
    -0.02218510f, 0.05933674f, 0.02373877f, 0.02669323f, -0.03838215f, -0.02232116f, 0.03350832f, -0.03124823f, 
    -0.02273518f, -0.02769776f, 0.03699739f, -0.07332864f, -0.02159497f, 0.02235778f, -0.02141433f, -0.01162480f, 
    -0.04209772f, -0.01586060f, 0.05031931f, -0.06274658f, 0.04943211f, -0.03231858f, 0.03570323f, 0.00568775f, 
    -0.05992461f, -0.05515644f, -0.01154581f, -0.02763419f, -0.01160046f, 0.01096705f, -0.00281207f, 0.05966887f, 
    -0.03862841f, 0.01862999f, -0.01893489f, 0.05587855f, 0.02094799f, 0.00048079f, 0.00848363f, 0.05048399f, 
    0.00907670f, -0.03245803f, -0.06514733f, 0.03982810f, -0.06067757f, -0.07024006f, 0.04330200f, 0.03888182f, 
    -0.02956850f, -0.01049001f, 0.02869053f, 0.05122529f, -0.07223316f, -0.00748112f, -0.03655202f, -0.06467109f, 
    -0.02583484f, 0.02584104f, 0.03972305f, -0.06404348f, 0.03122575f, 0.05213409f, -0.06080876f, -0.02737374f, 
    0.15609141f, 0.15731643f, 0.18916942f, 0.03097046f, -0.09464604f, -0.01569448f, 0.18985148f, 0.05072492f, 
    0.02753246f, -0.02851410f, 0.06951150f, 0.04974514f, -0.32107642f, 0.39943004f, -0.43184850f, 0.27731240f, 
    0.07909444f, -0.16621713f, 0.16053365f, -0.12106475f, -0.11520569f, -0.10536140f, -0.04445590f, -0.04094047f, 
    -0.50229669f, 0.22680117f, -0.32318777f, 0.36900616f, 0.09367521f, -0.12083453f, -0.00205784f, -0.24164318f, 
    -0.24993324f, -0.05301682f, -0.08209602f, 0.16926821f, 0.25902590f, 0.02859329f, 0.10488828f, -0.10560317f, 
    0.07456454f, -0.08431043f, 0.02256468f, 0.03439470f, 0.03816841f, 0.13426445f, 0.24311948f, 0.01751186f, 
    0.26866868f, 0.06402656f, 0.18627752f, 0.09851717f, -0.02442014f, 0.03609119f, 0.12459562f, 0.19855596f, 
    -0.04062868f, -0.10141673f, -0.02895026f, 0.01783639f, -0.07191613f, 0.02304729f, -0.22169609f, -0.17098458f, 
    0.08971865f, 0.16494764f, 0.04898476f, 0.18340115f, 0.05243828f, -0.00014685f, -0.05369776f, -0.06877009f, 
    -0.03603700f, 0.11917105f, 0.43707010f, -0.00281224f, -0.23395549f, -0.18398233f, -0.12132206f, -0.08755970f, 
    -0.00465341f, 0.04951398f, -0.01262632f, -0.04674142f, 0.16533054f, -0.11005000f, 0.50435442f, 0.04291797f, 
    -0.07566022f, -0.04434082f, 0.04821645f, -0.00311998f, 0.03457742f, 0.20602374f, 0.05186784f, 0.02407981f, 
    -0.09407280f, -0.02662606f, 0.25277460f, 0.23316473f, 0.10421205f, -0.09330442f, 0.11269693f, 0.00371976f, 
    -0.07877187f, 0.04751206f, 0.07206354f, 0.01069300f, 0.01084424f, 0.01449812f, 0.20367555f, 0.10669792f, 
    0.02459368f, 0.00395772f, -0.21580128f, 0.14609142f, -0.05570233f, 0.09545659f, 0.08668449f, 0.05302472f, 
    0.07842867f, -0.32574329f, -0.07647730f, 0.34002113f, -0.03422579f, 0.01023753f, -0.11298935f, -0.21212669f, 
    -0.04223143f, 0.06078136f, 0.12860747f, -0.02842821f, -0.10118761f, 0.53943610f, -0.16804439f, -0.18734279f, 
    -0.06541964f, -0.06904049f, 0.01999947f, 0.10013884f, -0.02398331f, -0.12295036f, 0.14556855f, -0.17403665f, 
    0.01676486f, 0.08367732f, -0.04237154f, 0.04405938f, 0.04484186f, 0.12530997f, -0.12622313f, -0.04093371f, 
    -0.13925907f, -0.02420872f, -0.06075807f, -0.18964747f, -0.29733053f, -0.07797481f, -0.27903369f, 0.21193168f, 
    0.09769615f, -0.04101057f, -0.11052494f, 0.13011637f, -0.14402343f, 0.15942186f, 0.09311251f, 0.23310038f, 
    0.03250843f, 0.01068539f, 0.30047974f, -0.02216959f, -0.10387994f, 0.10641932f, 0.03430612f, -0.06099633f, 
    -0.17494357f, -0.07051430f, 0.01627659f, 0.02809785f, 0.32681167f, -0.14097805f, 0.05477413f, -0.07464309f, 
    -0.03988818f, 0.00059954f, -0.16354081f, -0.01253571f, -0.10614780f, 0.04874679f, -0.06832378f, -0.09537797f, 
    0.03530197f, -0.03583257f, -0.22417185f, -0.04896570f, 0.03040815f, -0.05902006f, 0.10071290f, -0.11885980f, 
    0.01145548f, 0.08366026f, 0.01582907f, -0.23837835f, -0.31948987f, 0.11054035f, 0.16644590f, -0.07203793f, 
    0.00066641f, -0.05439223f, -0.04022465f, 0.12347905f, -0.00823091f, 0.24448472f, -0.05759807f, -0.00301500f, 
    -0.29549173f, -0.00257958f, -0.09053148f, 0.19986461f, 0.24175340f, 0.13142249f, 0.00204458f, -0.05058552f, 
    0.10102226f, -0.03922782f, -0.03480916f, 0.07196043f, 0.01823639f, 0.02134588f, -0.03801749f, 0.19860695f, 
    -0.10556739f, -0.11578839f, -0.06306183f, -0.01947695f, 0.08872503f, 0.13199331f, -0.08222137f, -0.01074879f, 
    0.09785565f, 0.09867491f, -0.03535179f, 0.15296020f, -0.00352851f, -0.01311804f, 0.15456192f, -0.05164596f, 
    0.01759290f, 0.08844389f, 0.08204477f, 0.09360924f, -0.32132015f, 0.07800723f, -0.03722692f, -0.11946479f, 
    -0.07459102f, -0.08023798f, -0.06218148f, -0.01386801f, -0.03548069f, 0.16634808f, -0.01531395f, -0.08105458f, 
    -0.10081878f, -0.13847442f, 0.05588989f, 0.09790948f, 0.10998399f, 0.12897862f, 0.07797021f, 0.14675736f, 
    0.04133730f, -0.03021505f, -0.01543089f, -0.02018721f, 0.26943362f, 0.14748535f, -0.06958951f, -0.05137303f, 
    -0.10253214f, 0.05290287f, -0.05111679f, -0.00989313f, -0.00235834f, -0.08839924f, -0.00757240f, -0.20033632f, 
    -0.15794528f, 0.11226222f, 0.02533516f, 0.15188116f, 0.02360107f, -0.01447584f, 0.12335875f, 0.07504344f, 
    0.10126214f, 0.00643299f, 0.05773553f, 0.01917513f, 0.18976468f, -0.03120478f, 0.05148083f, -0.05232089f, 
    -0.18712243f, -0.02215668f, -0.18822540f, -0.01989895f, 0.10705278f, 0.21059203f, -0.03073450f, 0.17177036f, 
    -0.23015533f, -0.22039737f, 0.06936513f, 0.01620858f, 0.00261896f, -0.07465167f, -0.07070491f, -0.15184279f, 
    -0.02327494f, -0.03938707f, 0.19621688f, 0.14600247f, -0.13834831f, -0.15149736f, -0.21222754f, 0.08726747f, 
    -0.10749547f, -0.00724533f, 0.01767514f, 0.15041946f, -0.09494440f, 0.08331155f, 0.14047281f, 0.08978363f, 
    -0.32143810f, -0.19771893f, -0.17117684f, -0.21742615f, -0.08619445f, -0.11763148f, -0.04002287f, -0.05087766f, 
    0.16087286f, -0.01102355f, -0.01904642f, 0.10677154f, -0.10206313f, 0.04794105f, -0.18794918f, 0.07786160f, 
    0.05814539f, 0.02711586f, 0.15391669f, 0.27192315f, -0.06851945f, -0.04075525f, -0.02385985f, -0.06978334f, 
    0.05567131f, -0.26535481f, 0.27905771f, -0.09290083f, 0.15262911f, 0.08691769f, 0.04879762f, -0.10738857f, 
    0.08446338f, -0.00663212f, 0.15011185f, -0.06916849f, 0.03683064f, -0.20584986f, 0.02424124f, -0.24490044f, 
    0.05985974f, -0.11007027f, 0.10009298f, 0.08665952f, 0.16071072f, 0.08722492f, 0.15970552f, 0.20588882f, 
    -0.13947515f, -0.07782705f, -0.18405543f, -0.21594627f, -0.00317578f, 0.16812953f, -0.12112623f, 0.00704973f, 
    0.08781981f, 0.06708055f, 0.05841644f, 0.18190038f, 0.50518787f, 0.05529122f, 0.04619253f, 0.13604565f, 
    -0.07711627f, -0.06406043f, 0.03110800f, 0.03918807f, 0.06285410f, 0.02065022f, 0.05609981f, -0.00529202f, 
    -0.05255095f, -0.36146674f, 0.43592277f, -0.20202267f, 0.08387815f, 0.10522929f, -0.23373146f, 0.10476991f, 
    0.10556349f, 0.01378210f, -0.09441675f, 0.01786972f, -0.19563814f, 0.15150130f, 0.06817444f, 0.04508068f, 
    -0.05779151f, 0.05540286f, 0.03877670f, -0.09315939f, 0.19687273f, 0.01945515f, 0.02916465f, 0.09352585f, 
    -0.16484642f, -0.13909714f, -0.31855151f, -0.27267921f, -0.13775821f, -0.03592999f, -0.03609236f, -0.18871859f, 
    -0.11361749f, -0.17439263f, -0.10203064f, -0.11778647f, 0.22823147f, 0.23880303f, 0.11880730f, 0.20918778f, 
    -0.07300343f, -0.14205150f, 0.01406460f, -0.01833335f, 0.16676351f, 0.04952846f, -0.09044283f, -0.04869368f, 
    0.06056362f, 0.03681583f, -0.09413193f, 0.08020023f, 0.23353584f, -0.04240834f, 0.10974075f, 0.23244187f, 
    0.08611248f, -0.01630703f, 0.00661615f, 0.01323347f, -0.34706721f, 0.17659327f, -0.19112527f, -0.04758576f, 
    -0.05397500f, -0.08479621f, 0.04187877f, 0.00555031f, 0.06396459f, -0.06446071f, 0.14620639f, 0.13215925f, 
    0.38002086f, 0.30621192f, 0.12568711f, 0.17665325f, -0.08651007f, -0.03394713f, -0.02829321f, 0.13998757f, 
    -0.02921191f, -0.06219488f, -0.03672237f, 0.05561231f, -0.07393747f, 0.14612696f, -0.03026453f, 0.00899573f, 
    0.02216991f, -0.15247193f, 0.00152633f, -0.12565780f, 0.08287238f, -0.00869210f, 0.08976074f, 0.07474862f, 
    0.10175751f, -0.08535957f, 0.07488307f, 0.13814858f, -0.02347993f, -0.04866600f, -0.00922013f, 0.09958030f, 
    0.01538882f, 0.11207306f, 0.09106159f, 0.04870719f, -0.17152998f, -0.25573763f, 0.31097576f, 0.05089010f, 
    -0.02943603f, 0.03457908f, -0.02166850f, -0.15826978f, -0.02959394f, -0.03380164f, 0.07127193f, 0.03651895f, 
    0.18707554f, -0.15571517f, -0.01935310f, 0.06121646f, 0.02309920f, -0.06475021f, 0.10534822f, -0.07379664f, 
    -0.04516944f, -0.08050197f, 0.16344984f, -0.04666435f, 0.05599686f, 0.19034222f, 0.09179310f, 0.07765494f, 
    0.03580324f, 0.15024488f, 0.07087303f, 0.07190548f, 0.16906430f, 0.09073713f, 0.01360185f, 0.03820997f, 
    -0.14922054f, 0.09146093f, -0.10763953f, -0.04919862f, 0.19686565f, -0.03744937f, -0.00423349f, 0.11770690f, 
    0.09023523f, -0.15293650f, -0.21657932f, 0.00454235f, 0.04873002f, 0.19189163f, 0.11776870f, 0.16552520f, 
    0.00955050f, 0.02271380f, 0.19431843f, -0.01515649f, -0.06193201f, -0.06907329f, -0.12325316f, -0.13778576f, 
    -0.32917526f, 0.04851774f, -0.10004449f, -0.15118667f, 0.04439266f, -0.01404252f, -0.08617115f, -0.05925379f, 
    -0.07844410f, 0.01680333f, 0.08605910f, -0.01800565f, 0.25456461f, 0.03774797f, 0.07710095f, 0.09744444f, 
    -0.00875650f, 0.07988145f, 0.05743800f, 0.08039312f, -0.08543950f, -0.10463515f, -0.04965696f, -0.16304080f, 
    0.08081368f, 0.16084810f, 0.33038425f, -0.24057508f, 0.05337079f, 0.00307367f, -0.09566320f, 0.15390733f, 
    -0.02838853f, 0.05546847f, -0.12289030f, -0.05151955f, 0.12541790f, 0.19552165f, 0.07066116f, 0.07931263f, 
    0.15075368f, 0.19439615f, -0.00759620f, -0.02809759f, -0.08610382f, -0.09038743f, -0.14169009f, -0.10444021f, 
    -0.27831170f, -0.19259281f, -0.16269198f, -0.13609940f, 0.04951766f, 0.11651459f, 0.09061047f, -0.01614103f, 
    0.08976039f, 0.05638240f, 0.08910793f, 0.10528956f, -0.12462880f, -0.10462703f, -0.17378554f, -0.14301305f, 
    0.08264975f, 0.01326380f, 0.08749710f, -0.02653618f, -0.03184876f, 0.15815794f, 0.02427093f, 0.04276219f, 
    -0.00552649f, 0.06890865f, -0.06821871f, 0.12034246f, 0.03042329f, 0.08832102f, -0.01403379f, 0.08952885f, 
    -0.05893957f, -0.01945788f, -0.07917555f, -0.10696346f, -0.32612127f, -0.04672074f, -0.05410967f, -0.01603353f, 
    0.02102356f, 0.05688710f, -0.08310828f, -0.19926548f, -0.09757380f, -0.05579494f, -0.10301814f, 0.08128856f, 
    0.26235262f, 0.37852305f, 0.02815242f, 0.13057722f, 0.02908919f, 0.17285213f, 0.19755195f, 0.19117226f, 
    0.08704922f, 0.07098218f, 0.04044369f, 0.00658843f, -0.10122656f, 0.07748100f, -0.14738478f, -0.14006390f, 
    -0.02859934f, 0.00828028f, 0.10312948f, 0.00372519f, -0.04611875f, -0.13686292f, -0.09000179f, 0.02171952f, 
    0.28005788f, 0.19332457f, -0.01115590f, 0.19684157f, 0.05692921f, 0.11898110f, 0.05869374f, 0.20443757f, 
    -0.03749812f, -0.07543045f, -0.07037269f, 0.05651737f, -0.09567301f, -0.05472000f, 0.07347105f, -0.09387472f, 
    0.03954345f, 0.06100270f, -0.12651576f, 0.04976221f, 0.05855373f, 0.03971630f, 0.17493528f, 0.16221878f, 
    -0.05480865f, -0.06545884f, -0.02479880f, -0.04904430f, 0.01354849f, -0.03118320f, 0.11182624f, 0.01070260f, 
    0.06377493f, 0.12858586f, 0.26433209f, 0.12798175f, 0.12569810f, 0.31337684f, 0.02821844f, -0.08717986f, 
    -0.04595525f, -0.00795630f, -0.06545633f, 0.07362543f, 0.00579262f, -0.08373889f, -0.02914100f, -0.04644774f, 
    0.00476434f, -0.04658704f, -0.04015398f, 0.00062685f, 0.03843835f, -0.06717430f, -0.02990315f, 0.03555599f, 
    -0.09565666f, -0.08635589f, -0.16789073f, -0.02343846f, 0.18361090f, 0.14680099f, 0.19772188f, 0.05939421f, 
    -0.08500203f, -0.04038559f, 0.07206094f, 0.07415871f, 0.02907718f, 0.18130183f, 0.15035184f, 0.02833901f, 
    0.00696671f, 0.06070887f, -0.03029398f, 0.00669209f, -0.02511344f, -0.06505183f, 0.02344208f, -0.06738122f, 
    -0.07533172f, 0.06586976f, 0.00871700f, -0.00245904f, 0.03376148f, 0.03220637f, 0.02964813f, -0.04361762f, 
    -0.01221551f, -0.07572856f, 0.04598554f, 0.02960422f, 0.01966564f, -0.00267908f, -0.01517036f, -0.06345610f, 
    0.06262768f, -0.05617060f, -0.01089644f, 0.04186985f, -0.04786820f, -0.06721211f, -0.00727912f, -0.02470052f, 
    -0.04630668f, -0.02151624f, -0.03700438f, -0.03972043f, 0.00730047f, -0.05990463f, -0.04245244f, -0.05639325f, 
    -0.00034190f, -0.02484185f, -0.06095177f, 0.01135800f, -0.01594846f, 0.03283331f, 0.03333038f, -0.00783891f, 
    -0.00717651f, 0.02350825f, 0.05234315f, -0.00095170f, 0.05762837f, -0.06705573f, -0.01543139f, 0.06170551f, 
    -0.07447797f, -0.07109293f, -0.06672260f, -0.01270852f, 0.00507301f, -0.05838318f, 0.03225484f, -0.06792488f, 
    -0.07111002f, -0.05776752f, 0.05532529f, -0.04179026f, 0.01219836f, -0.04791743f, -0.05268776f, 0.06156161f, 
    -0.06176032f, -0.00894503f, -0.04713611f, 0.02961951f, 0.05967760f, -0.04554537f, -0.01347934f, 0.04102484f, 
    -0.04080142f, -0.04432665f, 0.05632071f, -0.02015568f, 0.00929028f, 0.00977057f, 0.00919692f, -0.00576883f, 
    -0.05750207f, -0.03261601f, -0.04163850f, 0.02027099f, -0.06807342f, -0.00982779f, -0.01878093f, -0.04019231f, 
    -0.07163265f, -0.03910612f, 0.03476860f, -0.02418771f, 0.04618853f, 0.02283486f, -0.00710626f, -0.02184276f, 
    -0.00235843f, 0.03805921f, 0.01632848f, -0.05150902f, -0.06528626f, -0.05991013f, -0.03343174f, 0.01993813f, 
    -0.07405484f, 0.03066992f, -0.04962732f, 0.00363993f, 0.05210259f, 0.04168024f, -0.07123916f, -0.01781003f, 
    -0.01528811f, 0.02205383f, 0.04112087f, -0.05657189f, 0.04151116f, -0.03320976f, 0.02892728f, -0.03497723f, 
    -0.00702054f, -0.03906258f, -0.04907155f, 0.05140701f, 0.03188112f, -0.04977095f, 0.01893774f, -0.03154965f, 
    0.05216362f, -0.02733493f, 0.03808397f, -0.02983567f, -0.05972720f, -0.05944698f, 0.01728564f, -0.04732861f, 
    0.00699132f, -0.04116193f, 0.02205650f, 0.01755903f, 0.02687215f, -0.01594083f, 0.00676646f, -0.01531936f, 
    0.06613160f, 0.06649933f, -0.02940550f, -0.04449553f, 0.02595224f, -0.05007639f, -0.00675384f, 0.04513032f, 
    -0.04417466f, 0.06670108f, -0.02404815f, 0.01090309f, -0.06107729f, 0.04862257f, 0.00821180f, 0.06189461f, 
    -0.05700169f, -0.03005983f, 0.04399009f, -0.03627619f, 0.06463489f, -0.07601964f, -0.05452418f, -0.06354899f, 
    -0.00308475f, -0.04104663f, -0.03506716f, -0.02381078f, 0.04743760f, 0.00513799f, -0.03603913f, 0.03556117f, 
    0.02097041f, -0.06057268f, -0.05205786f, -0.02015143f, 0.02639652f, 0.01632593f, -0.06093404f, -0.00095987f, 
    0.00633621f, -0.05238460f, 0.00710907f, 0.06073658f, 0.01139803f, 0.01872621f, -0.04299308f, 0.04379874f, 
    -0.06638022f, -0.07208748f, -0.04982926f, -0.07465567f, -0.08171170f, -0.03323121f, 0.04005387f, 0.02111657f, 
    -0.04795290f, 0.01568463f, 0.00747323f, -0.00599215f, -0.06958763f, -0.03905892f, 0.02803026f, 0.05169773f, 
    0.05767876f, 0.00272297f, -0.04446126f, -0.01767674f, 0.02053582f, -0.01319514f, 0.04449077f, -0.07998050f, 
    -0.01072684f, -0.04585613f, 0.03027861f, -0.04631396f, 0.00200559f, -0.02717702f, -0.05523507f, -0.08401007f, 
    -0.03068613f, -0.02938781f, -0.03733800f, -0.06958241f, -0.07981347f, 0.02993499f, 0.02399492f, 0.04794691f, 
    -0.06868953f, -0.05212769f, -0.05200238f, 0.02743233f, -0.05316279f, 0.04058997f, 0.04468350f, -0.01089950f, 
    0.02758325f, -0.06813117f, -0.07099737f, -0.00186503f, 0.04152204f, -0.07537764f, 0.00933638f, -0.05569361f, 
    -0.05849740f, -0.03414062f, -0.00798949f, -0.03034677f, 0.03538307f, 0.02979863f, 0.05222858f, 0.00928415f, 
    -0.06583697f, -0.05755044f, -0.08043268f, -0.04408156f, -0.06587366f, -0.05167662f, 0.01679466f, -0.07875577f, 
    0.00558187f, -0.01230895f, -0.06233125f, -0.06366304f, 0.03935783f, -0.01268044f, -0.02614585f, 0.00418281f, 
    -0.06862635f, 0.06284197f, 0.00345980f, -0.06279430f, -0.06788951f, -0.01067581f, -0.06151948f, 0.04444596f, 
    -0.04700988f, 0.04525288f, 0.03396971f, 0.01544182f, 0.05007715f, 0.00070238f, -0.04799077f, -0.02501053f, 
    -0.03950708f, -0.04592076f, -0.08749453f, -0.03837807f, -0.06868024f, -0.02045852f, 0.01993205f, 0.05767574f, 
    -0.01880050f, 0.06231566f, 0.00775700f, -0.02009643f, -0.04561483f, -0.05571761f, -0.08952651f, -0.01389452f, 
    -0.09130053f, 0.04843700f, 0.00344215f, -0.08570126f, 0.04884193f, -0.04062582f, -0.09172043f, -0.05564875f, 
    -0.04405435f, 0.02538610f, -0.00255088f, -0.00129836f, 0.01201257f, 0.05036925f, 0.02134318f, 0.05636438f, 
    -0.02321320f, 0.05006104f, -0.01951991f, -0.06404065f, -0.08382172f, 0.02848363f, 0.01328981f, 0.01732129f, 
    -0.07318409f, -0.05385751f, 0.03738919f, -0.06506089f, -0.04452739f, 0.04817510f, -0.02247166f, 0.00948959f, 
    0.03931409f, -0.05841485f, -0.04606439f, 0.02248873f, 0.01148442f, 0.01674524f, 0.04779628f, 0.00894583f, 
    0.04300948f, -0.00527294f, 0.04145173f, 0.00588149f, -0.03467429f, -0.09056489f, -0.03216110f, -0.06704775f, 
    -0.07522216f, 0.03990983f, 0.01433130f, -0.01935167f, -0.02410120f, -0.08968967f, 0.05262811f, -0.05577016f, 
    -0.01006838f, 0.03644128f, 0.03797070f, 0.01985424f, 0.01997659f, 0.00196680f, 0.00270535f, -0.06825988f, 
    -0.05427387f, -0.07846356f, -0.08442012f, 0.02095041f, 0.05694354f, 0.01305488f, -0.03298496f, -0.00131750f, 
    -0.00014420f, -0.02931011f, 0.05594936f, -0.03893343f, 0.01961053f, -0.04531801f, 0.03113963f, 0.02327927f, 
    -0.06615306f, -0.11496190f, -0.10682005f, 0.02601366f, 0.02730072f, -0.01795826f, -0.05528267f, 0.02163074f, 
    -0.02095139f, 0.02740187f, -0.10832017f, -0.02450441f, -0.06580784f, -0.10140725f, -0.08358707f, 0.01875604f, 
    -0.04817959f, -0.05455268f, 0.01993250f, 0.03491914f, -0.06188873f, 0.02488418f, -0.08820464f, 0.01398718f, 
    0.00508776f, 0.05975430f, -0.05124918f, -0.02951995f, -0.06687711f, 0.02764170f, 0.03257015f, -0.05972764f, 
    -0.09026644f, -0.09230128f, -0.01430410f, -0.09593367f, -0.00656227f, -0.02793807f, -0.01510850f, -0.03435633f, 
    -0.01390117f, -0.03977050f, 0.06067680f, -0.06386219f, -0.06038638f, 0.05338775f, -0.01859880f, -0.00776299f, 
    -0.07931569f, 0.03547030f, -0.01925890f, -0.06574003f, -0.02118658f, -0.04953635f, -0.01113809f, -0.00085837f, 
    0.02468577f, -0.00966836f, -0.04405108f, -0.00291795f, -0.13113050f, -0.08093315f, -0.03576810f, 0.00920761f, 
    0.04196889f, -0.10523558f, -0.05400297f, -0.02605515f, 0.05555381f, -0.01272156f, -0.04824058f, 0.01010069f, 
    0.01932243f, 0.00815106f, -0.01356861f, -0.04496935f, 0.06492250f, -0.01254206f, -0.00665047f, -0.04009537f, 
    -0.03374204f, -0.03176525f, -0.04304875f, 0.00544224f, 0.00298375f, -0.10598236f, -0.04015583f, -0.09643478f, 
    -0.00167333f, 0.04854093f, -0.03957046f, 0.00357111f, -0.04343563f, -0.04112918f, -0.02374336f, -0.06028240f, 
    -0.05280330f, -0.08122327f, -0.01349792f, 0.05888576f, -0.02683839f, -0.04590366f, 0.06590253f, -0.00613879f, 
    0.01161656f, -0.06933359f, 0.07773218f, -0.04045302f, -0.02500182f, -0.08053192f, 0.00370069f, -0.08249133f, 
    -0.04495731f, 0.01438462f, -0.08622517f, -0.04369661f, 0.00948621f, -0.01324169f, -0.05929104f, -0.04234318f, 
    0.09141853f, 0.03970677f, -0.00486492f, 0.01166165f, 0.03620620f, 0.04182066f, -0.04037613f, -0.06073751f, 
    -0.06841217f, -0.03217639f, 0.02695135f, -0.09113986f, -0.13763405f, -0.01218736f, 0.04095099f, 0.10519727f, 
    0.00060972f, -0.07727113f, 0.07049174f, 0.00530668f, 0.00304957f, -0.04042329f, -0.02428998f, 0.09453159f, 
    0.01827607f, 0.01516923f, -0.03478683f, -0.09399500f, -0.06526168f, 0.00950144f, -0.04583229f, -0.09482586f, 
    -0.03051740f, -0.01158142f, -0.03619655f, -0.07825593f, 0.01828816f, 0.00002590f, -0.01696711f, -0.05228391f, 
    -0.00978743f, -0.07659062f, -0.05617156f, -0.04637551f, -0.00936620f, -0.09167114f, 0.04837646f, 0.04194837f, 
    -0.03590580f, -0.05513661f, -0.01590119f, -0.04990037f, -0.07336683f, 0.06292993f, -0.02450439f, -0.09516397f, 
    0.03138422f, -0.02771160f, 0.03195931f, -0.05447924f, 0.07292600f, 0.05888545f, -0.00683334f, 0.05807413f, 
    -0.19975193f, 0.05740068f, -0.03676444f, -0.01593133f, 0.07266460f, -0.01674312f, -0.18537182f, -0.21417019f, 
    -0.17187242f, -0.07150165f, -0.06301841f, -0.23367062f, -0.04820307f, 0.14387259f, 0.14611071f, -0.02299752f, 
    -0.01433350f, -0.11413980f, -0.10151777f, 0.03915427f, -0.03955960f, 0.03768319f, -0.13983925f, -0.07758207f, 
    0.12213445f, 0.18993263f, 0.09006648f, 0.01460374f, 0.00266226f, 0.05629924f, 0.12261625f, 0.03942426f, 
    0.09360366f, 0.03876296f, -0.01792607f, 0.02573485f, -0.06077867f, 0.12175608f, -0.14845465f, 0.06051457f, 
    -0.07031916f, 0.06395510f, -0.13267571f, 0.02054056f, 0.06648416f, -0.05775145f, -0.00359206f, -0.15508425f, 
    -0.14280485f, 0.10122024f, 0.24846771f, -0.00251471f, 0.05103090f, 0.05589947f, -0.02889570f, -0.03886406f, 
    0.03144793f, 0.08118137f, 0.08361891f, -0.01719064f, -0.19272070f, 0.02371868f, -0.29507220f, -0.25155097f, 
    -0.24083492f, -0.14411446f, -0.09793577f, 0.06061421f, 0.10194337f, 0.11542817f, -0.04301005f, 0.19365023f, 
    0.02320557f, -0.18277913f, -0.05637224f, 0.02175920f, 0.06165087f, 0.08920752f, 0.06670707f, 0.14274780f, 
    0.10098551f, -0.09810964f, -0.09415373f, 0.02753010f, 0.17284164f, 0.00988709f, 0.05206483f, 0.28043514f, 
    -0.03766086f, 0.16477194f, -0.18489179f, -0.12800348f, -0.09391049f, -0.23778825f, -0.09288843f, 0.07266828f, 
    -0.12243745f, 0.14622480f, -0.01037630f, 0.08287805f, 0.00246220f, 0.07693644f, 0.23067088f, 0.07357035f, 
    0.06365694f, 0.07343525f, -0.04901636f, 0.08501365f, 0.08333470f, 0.25718322f, 0.16291101f, -0.08152980f, 
    -0.19056620f, 0.00219797f, -0.09845671f, 0.03644116f, 0.17188391f, -0.08708743f, -0.01258417f, 0.16259985f, 
    0.07904454f, -0.03375407f, -0.01882086f, 0.01936215f, 0.09378006f, 0.08148182f, 0.09871374f, -0.02607668f, 
    -0.00941729f, -0.12829943f, -0.11485504f, 0.00134780f, -0.24223740f, -0.02154396f, -0.18874595f, -0.16067719f, 
    -0.09725626f, 0.12296083f, 0.00721614f, -0.02101944f, -0.00313094f, 0.05221790f, 0.06843997f, 0.25651979f, 
    -0.06187180f, -0.06330559f, -0.03012537f, 0.11538693f, -0.18079278f, -0.14330788f, -0.08845644f, -0.20347296f, 
    0.12557186f, -0.18712470f, 0.05514596f, 0.10744499f, -0.19607188f, 0.26620311f, -0.17796952f, -0.23922054f, 
    0.01716674f, -0.00054932f, 0.11214141f, 0.10622358f, -0.09736849f, -0.13262534f, -0.16965638f, -0.15675560f, 
    0.20645896f, -0.12874129f, -0.00173183f, -0.01597632f, 0.09009886f, -0.10559102f, -0.02666399f, 0.07837491f, 
    -0.05928739f, 0.10075850f, 0.13496952f, -0.18503891f, 0.15671048f, -0.30423868f, 0.14586231f, -0.06979702f, 
    0.16592164f, 0.12388942f, 0.23782089f, 0.31869322f, 0.18806911f, 0.07146133f, 0.12618770f, 0.24381031f, 
    -0.07400548f, -0.01180406f, -0.05613362f, -0.06815393f, 0.01652347f, -0.00882361f, -0.07088673f, 0.05479463f, 
    -0.05594170f, -0.06613576f, 0.03239108f, -0.07044077f, -0.04071112f, -0.01229585f, -0.06869733f, -0.01863849f, 
    -0.01835618f, 0.00241114f, 0.02388878f, -0.01253254f, 0.06194779f, 0.02345686f, 0.00385136f, 0.00212001f, 
    -0.01635164f, 0.05057331f, -0.05788354f, -0.01404315f, -0.00396767f, 0.01770426f, -0.01037878f, -0.06742967f, 
    0.03811619f, 0.00464293f, 0.05131164f, -0.05553214f, -0.05873207f, -0.03089264f, -0.07804848f, 0.06143150f, 
    -0.02380706f, -0.06696942f, -0.05733749f, -0.00409754f, -0.04029464f, -0.03228343f, 0.00226605f, 0.02788350f, 
    0.00678518f, -0.01039406f, -0.02290935f, 0.02504087f, 0.01954426f, 0.03320709f, 0.05820913f, -0.01696248f, 
    0.05982837f, 0.04653467f, 0.00773884f, -0.00949487f, -0.05634603f, 0.03989719f, -0.05264548f, -0.01784587f, 
    0.00553207f, 0.01505784f, -0.07468762f, -0.02233357f, -0.06589601f, -0.04797772f, -0.02312109f, 0.02316906f, 
    -0.07174847f, 0.01038686f, 0.00131817f, 0.01525266f, 0.03404728f, -0.03359424f, -0.07770997f, 0.06031138f, 
    -0.05465252f, -0.03170362f, -0.04819068f, -0.04776717f, -0.03492015f, -0.07611518f, -0.01619185f, -0.07526667f, 
    0.05662292f, 0.03151942f, 0.00836534f, 0.05244656f, 0.03727496f, 0.05608479f, 0.02274200f, -0.01854470f, 
    -0.01090307f, 0.01329601f, -0.03592660f, 0.05748224f, -0.04040184f, -0.06659306f, -0.06424384f, -0.01537081f, 
    0.05626246f, 0.05480905f, 0.03098064f, -0.06397689f, 0.04766108f, 0.03743009f, 0.01816767f, 0.00694110f, 
    -0.01041287f, -0.06027847f, 0.06327045f, -0.05247938f, 0.03105290f, 0.01940112f, 0.01140368f, -0.02608543f, 
    -0.01365701f, 0.06294842f, -0.02174019f, -0.02213548f, 0.02156331f, 0.04015226f, -0.00642543f, -0.07539500f, 
    0.01897829f, 0.01598044f, 0.01150024f, -0.00598345f, 0.02538915f, 0.02825481f, -0.05905095f, 0.02523317f, 
    -0.06257629f, -0.03609962f, -0.05465378f, -0.07342092f, 0.04228495f, -0.06632277f, -0.00165367f, 0.06383625f, 
    -0.06598828f, -0.04220088f, 0.04877792f, -0.06018995f, -0.01506391f, 0.03635568f, -0.02479715f, 0.06568760f, 
    -0.05406207f, 0.01859584f, -0.04848861f, 0.00191914f, -0.05688637f, -0.06396530f, 0.01886948f, 0.03661432f, 
    -0.02930679f, 0.03662518f, -0.02896557f, -0.01594632f, 0.06031523f, -0.02679696f, 0.00693658f, -0.05675124f, 
    -0.05475439f, 0.02475793f, -0.06847163f, -0.03822670f, 0.05893788f, 0.01695536f, -0.05702405f, -0.05568990f, 
    -0.07418159f, -0.02959426f, 0.02932053f, -0.01645223f, -0.05386040f, -0.01664943f, -0.02309571f, -0.05914177f, 
    -0.01134287f, 0.00654982f, 0.03996702f, -0.00792035f, 0.01779284f, -0.05754536f, 0.04574398f, -0.06692959f, 
    -0.05810318f, -0.02111806f, 0.10069211f, 0.05925845f, -0.17505994f, 0.12749779f, 0.06191342f, -0.03033833f, 
    0.27151293f, 0.08372526f, 0.05042559f, 0.08375514f, -0.32412624f, -0.10025906f, -0.24005111f, -0.06989001f, 
    -0.11550049f, -0.10955805f, -0.10485357f, 0.13633402f, -0.02683395f, 0.01559613f, 0.04601757f, -0.21899439f, 
    -0.21795548f, -0.00180076f, -0.37178159f, -0.11402103f, 0.06520676f, 0.07816734f, 0.03890124f, 0.09562282f, 
    -0.10221473f, -0.00713098f, 0.01554933f, -0.04030667f, 0.16366275f, 0.04663733f, -0.04474448f, -0.14299268f, 
    -0.05629013f, -0.10794199f, 0.10529535f, 0.04407309f, -0.07525446f, 0.18925436f, 0.22563358f, 0.04299566f, 
    0.24799490f, 0.24102463f, 0.16764531f, 0.11837847f, 0.04875344f, 0.02526569f, 0.14030582f, 0.18414094f, 
    0.02506384f, -0.11526325f, 0.08154579f, 0.06866103f, 0.00852421f, -0.00888953f, 0.07390153f, -0.09009094f, 
    -0.02619974f, 0.04884725f, 0.08572221f, 0.01870469f, 0.12224205f, -0.05888047f, 0.17191537f, 0.04785170f, 
    0.29809725f, 0.16857372f, 0.23292117f, -0.17618518f, -0.15765150f, -0.20781079f, -0.00763945f, -0.21017247f, 
    -0.15706712f, 0.03551159f, -0.08120891f, -0.04798140f, 0.18965851f, -0.03076143f, 0.62092268f, 0.03830272f, 
    0.13610968f, -0.20048958f, 0.15302472f, 0.09349619f, -0.05767243f, 0.26079199f, 0.10613032f, 0.27617073f, 
    -0.23705909f, -0.13853657f, 0.02602588f, 0.02105002f, 0.00580826f, -0.02119388f, 0.07184817f, -0.03590943f, 
    -0.23643863f, -0.16728330f, -0.13930835f, -0.31337389f, 0.04547009f, 0.02435922f, 0.41971058f, 0.04321776f, 
    -0.01519573f, -0.09473646f, -0.10294402f, 0.09085278f, 0.14857079f, 0.44771197f, 0.09112213f, 0.03067145f, 
    -0.39229441f, -0.17025626f, -0.02493292f, -0.08612048f, -0.09497726f, 0.02833843f, 0.05161643f, 0.12812269f, 
    -0.03992374f, 0.10322826f, -0.08335008f, 0.01748887f, 0.04629675f, 0.36316797f, -0.04206474f, 0.11947178f, 
    -0.02549483f, 0.08453714f, -0.05380907f, 0.09562437f, -0.00753291f, 0.03843844f, 0.18232475f, -0.14480631f, 
    0.06927247f, 0.07832150f, 0.06012269f, 0.14742155f, -0.06601418f, -0.05801467f, -0.01918874f, 0.00096170f, 
    -0.14609492f, 0.03963110f, -0.10497649f, -0.04268751f, 0.03338846f, -0.18308713f, -0.04999226f, 0.23060900f, 
    0.12069345f, 0.06209278f, 0.09084937f, 0.17356752f, -0.04023492f, 0.06403366f, 0.21194544f, 0.19392598f, 
    0.19807458f, 0.19455716f, 0.18391873f, -0.07351706f, 0.15460347f, 0.05429127f, 0.07605968f, 0.12251241f, 
    -0.10379843f, -0.12761520f, -0.02821008f, 0.18456073f, -0.00746222f, -0.07392585f, -0.03904375f, 0.06943991f, 
    0.03407570f, -0.12099811f, -0.15920506f, -0.24280663f, -0.15167539f, -0.13420540f, -0.19211380f, -0.12214315f, 
    -0.11218516f, 0.05675643f, 0.03057618f, -0.05090353f, 0.10778070f, -0.09690043f, 0.02821732f, 0.00708054f, 
    -0.03707676f, 0.02809852f, 0.23890004f, 0.00966664f, 0.04967782f, 0.20264667f, -0.27335998f, 0.16269775f, 
    0.11850534f, 0.14260872f, 0.18297414f, 0.04098381f, -0.16185413f, -0.07800781f, -0.16629775f, -0.08491036f, 
    0.16489606f, -0.06904274f, 0.19519714f, 0.01493059f, -0.15760486f, -0.08684790f, -0.10095575f, -0.10782492f, 
    -0.06598654f, -0.10707647f, -0.07370511f, -0.00394489f, 0.22314943f, 0.10443836f, 0.14766107f, -0.15201166f, 
    0.06602397f, 0.13810070f, 0.10328367f, 0.00639716f, -0.13716702f, -0.27654126f, -0.04685340f, -0.26050222f, 
    -0.12062056f, -0.14731935f, 0.02758837f, -0.06420659f, 0.06770338f, 0.06622550f, -0.01406298f, 0.09374205f, 
    0.07224800f, 0.07884122f, 0.13245989f, 0.13076881f, -0.03995923f, -0.08454381f, -0.13316828f, -0.08450606f, 
    0.07751806f, 0.05987051f, 0.11565485f, 0.04330589f, -0.03369232f, -0.03435913f, -0.08676550f, 0.07493901f, 
    0.12736189f, 0.09979688f, -0.04658047f, 0.00009036f, -0.12645242f, -0.09651538f, -0.02143171f, -0.04080392f, 
    -0.10835197f, 0.12021627f, -0.03987840f, 0.04812772f, -0.33850327f, -0.12944500f, 0.02244030f, -0.05250039f, 
    -0.02126012f, 0.00935536f, -0.11871847f, -0.17714146f, -0.00206853f, -0.07329626f, 0.04177664f, 0.15938316f, 
    0.29331249f, 0.29759613f, 0.02494812f, -0.03385068f, 0.11499146f, 0.10363381f, 0.00913143f, -0.00409412f, 
    -0.06044085f, -0.03446386f, 0.01748079f, -0.04794598f, -0.09988531f, -0.01499049f, -0.01635155f, -0.28428307f, 
    0.07728259f, 0.02145861f, 0.01324517f, -0.05984880f, -0.06669120f, -0.13966769f, 0.01138828f, -0.09515471f, 
    0.36989748f, 0.33302146f, 0.03211089f, 0.21606793f, 0.02245497f, 0.12361583f, -0.05240089f, 0.07938413f, 
    -0.14846207f, -0.16696501f, -0.20045191f, -0.02390265f, -0.02933237f, 0.42899376f, 0.16451906f, -0.34002319f, 
    -0.00983106f, 0.05686456f, 0.07818296f, -0.02085465f, 0.16899562f, 0.13179135f, -0.28347081f, -0.04620416f, 
    0.08934741f, -0.02811280f, 0.00095876f, -0.02146578f, 0.06669222f, 0.16474496f, 0.03385535f, 0.03650181f, 
    0.05626429f, 0.14595194f, 0.16005588f, 0.09358381f, 0.05085548f, 0.00734974f, -0.05610057f, -0.05178351f, 
    -0.18875739f, -0.29511687f, -0.16103855f, -0.25738776f, -0.11400390f, 0.04660768f, -0.05377701f, 0.05541414f, 
    0.01220945f, 0.05059935f, 0.10652857f, 0.19696243f, -0.06746544f, 0.06793965f, -0.03458644f, 0.01466691f, 
    -0.32015693f, 0.14366390f, -0.02776105f, 0.01262808f, 0.18900457f, 0.02898244f, 0.14904171f, 0.16260351f, 
    -0.17172487f, 0.11919562f, -0.11458355f, -0.21976729f, -0.02009660f, 0.06526336f, 0.03381466f, 0.04428776f, 
    -0.33968079f, 0.01810750f, 0.09245507f, -0.26238030f, -0.11294110f, -0.06104753f, -0.01425500f, 0.01740020f, 
    -0.02550185f, -0.01012006f, -0.13267785f, -0.05162114f, 0.11587492f, -0.45184717f, 0.14445440f, -0.06880733f, 
    0.14483900f, 0.19414353f, -0.08591487f, -0.06066696f, -0.10210129f, -0.01607388f, 0.04052724f, -0.04489149f, 
    0.14716557f, 0.25681105f, -0.40255475f, 0.02528741f, -0.17588122f, -0.07087766f, 0.25427893f, 0.05829443f, 
    0.11013983f, -0.03468373f, 0.23079672f, 0.10678038f, 0.04566967f, 0.04746699f, -0.05100219f, 0.07994682f, 
    0.10291870f, 0.05576996f, 0.02782589f, 0.00430649f, 0.07145818f, 0.06349834f, -0.07252074f, -0.09314080f, 
    -0.38631511f, 0.26330087f, -0.19680940f, -0.20567849f, -0.02048008f, 0.01205054f, -0.20578608f, -0.14443709f, 
    0.02755870f, -0.00577512f, 0.01329587f, 0.07304692f, 0.20274790f, 0.03896103f, -0.18517709f, -0.25765684f, 
    0.04538414f, -0.07746803f, 0.01227621f, -0.19634451f, -0.08146702f, 0.11671542f, 0.01347824f, 0.09196077f, 
    -0.30178788f, -0.19776352f, -0.06134954f, 0.08286078f, -0.00472238f, 0.01308114f, -0.11323357f, -0.17710640f, 
    0.05119880f, 0.17719704f, -0.02042208f, 0.20556760f, -0.41763255f, -0.08637998f, 0.17305309f, 0.16035548f, 
    0.03098841f, -0.08252841f, 0.06779473f, -0.06315389f, -0.02146913f, 0.04758243f, -0.09571613f, 0.10277309f, 
    0.21914092f, 0.08030470f, 0.06994328f, -0.05907124f, 0.09212649f, 0.17762896f, 0.08263018f, 0.01256347f, 
    -0.04015474f, 0.23740508f, 0.12033415f, 0.16335155f, -0.09872867f, 0.14094436f, 0.31919026f, 0.12357930f, 
    -0.18996924f, -0.03370360f, 0.17192657f, -0.03850705f, -0.07031057f, 0.08878481f, -0.01161579f, -0.12011349f, 
    0.10326014f, 0.00526817f, -0.11814577f, -0.02693193f, 0.10216161f, 0.03489399f, 0.07905870f, -0.00883700f, 
    0.02991273f, 0.07593998f, -0.11448648f, 0.03643256f, 0.35961351f, 0.00429290f, -0.12899882f, -0.42096812f, 
    0.12687646f, -0.03856079f, -0.02920863f, -0.08166275f, 0.06134512f, 0.06875210f, -0.02895118f, 0.16654329f, 
    -0.33964160f, 0.02688687f, 0.13178951f, 0.03071400f, -0.07392202f, -0.08110505f, 0.15833077f, -0.05541833f, 
    -0.06968077f, 0.05209325f, 0.01548367f, -0.03511293f, -0.13260549f, -0.04175762f, 0.06802154f, -0.14908223f, 
    0.02844418f, -0.02028091f, 0.13477993f, 0.05056504f, -0.01334043f, -0.03730603f, 0.01425977f, -0.09878682f, 
    -0.00548785f, -0.13629699f, -0.00631074f, 0.13915691f, -0.08997767f, 0.03128991f, -0.18978004f, 0.04683151f, 
    -0.18753818f, 0.08597533f, -0.05536396f, 0.18731201f, 0.10444675f, -0.12566012f, -0.00201577f, 0.01840630f, 
    -0.14046897f, 0.07763696f, -0.11084707f, 0.07738432f, 0.15290733f, 0.06987156f, 0.19204578f, 0.13480678f, 
    0.04070016f, -0.04013655f, -0.30519667f, 0.06325062f, 0.15818690f, 0.00063313f, -0.00159816f, 0.06928495f, 
    0.09867927f, 0.11764915f, 0.14165162f, 0.09549700f, -0.22620153f, 0.32797894f, -0.00073907f, 0.21626061f, 
    -0.06379069f, -0.05824958f, 0.01522148f, -0.14599021f, -0.02611408f, 0.01368397f, -0.06007053f, 0.08730437f, 
    -0.45870253f, 0.15897009f, 0.00952430f, 0.34743837f, 0.15702063f, 0.05888978f, -0.13759348f, -0.07255816f, 
    -0.05723045f, 0.07265604f, -0.14784420f, -0.01879150f, 0.10890306f, -0.25054082f, 0.05560113f, 0.07951909f, 
    0.08815544f, -0.16861379f, -0.13115381f, 0.05668103f, -0.00793049f, 0.02202881f, 0.09890749f, 0.00070391f, 
    0.19173595f, -0.02925858f, 0.13953961f, 0.13554600f, -0.01770727f, -0.00170914f, 0.07689031f, 0.15617482f, 
    0.10562237f, 0.11025394f, -0.15167101f, -0.02367488f, -0.14409542f, -0.10263658f, 0.10722822f, 0.23021527f, 
    0.07981162f, 0.06634771f, -0.12401378f, -0.05578786f, -0.09216797f, -0.04066925f, 0.02904920f, -0.02946303f, 
    -0.08256131f, 0.24456929f, 0.25442997f, 0.13610199f, 0.08841281f, 0.18562163f, 0.10612669f, 0.19153747f, 
    -0.02738500f, -0.06673321f, 0.11009211f, -0.18615405f, 0.22722067f, 0.10714729f, 0.11401401f, -0.18727526f, 
    -0.04240621f, 0.10983302f, -0.01748245f, 0.00009456f, 0.08271408f, 0.02790676f, -0.10302932f, -0.34173745f, 
    -0.04485952f, -0.11237981f, 0.02054292f, 0.23721604f, 0.19392689f, -0.15182199f, -0.07460264f, -0.25456014f, 
    0.01992273f, -0.10316762f, -0.04096143f, 0.02100481f, 0.19836408f, -0.15572216f, -0.11083996f, -0.03755517f, 
    0.11175928f, -0.00626310f, -0.22827047f, -0.01117824f, 0.09426113f, 0.09855507f, 0.07810313f, 0.22914077f, 
    -0.23638430f, -0.03683201f, 0.05886579f, 0.06270784f, 0.05607725f, -0.04809117f, -0.11431657f, -0.05475531f, 
    0.03851968f, -0.03114549f, 0.05419855f, 0.06912804f, 0.06384635f, 0.17479964f, -0.02672547f, 0.14482999f, 
    0.08874382f, -0.06736638f, 0.14890923f, 0.00618150f, -0.03625549f, 0.00256857f, 0.12413455f, -0.01595885f, 
    -0.14594479f, -0.08354752f, -0.14332716f, -0.04234498f, -0.08586790f, 0.12828065f, -0.19424871f, -0.00213044f, 
    -0.03574765f, -0.01400273f, 0.02663553f, 0.01060472f, 0.17353715f, -0.10576144f, -0.00291927f, 0.34994909f, 
    -0.01344913f, -0.06554694f, -0.19598560f, -0.05855767f, -0.08732818f, 0.01536835f, 0.18775214f, 0.18653618f, 
    0.02990740f, -0.00089738f, 0.09981077f, -0.09807951f, 0.02520988f, 0.07634111f, -0.02129230f, -0.06598228f, 
    0.27508640f, -0.08722237f, -0.00834616f, -0.12825298f, -0.03560812f, 0.14254442f, -0.11730453f, -0.06882633f, 
    0.02506379f, 0.00139392f, -0.04998457f, -0.11074038f, 0.03441166f, -0.17515382f, -0.17665535f, 0.04600737f, 
    -0.04374832f, 0.01675348f, -0.06939080f, -0.01182309f, 0.11329023f, -0.10289519f, -0.15595397f, -0.18664014f, 
    0.03918274f, 0.00160793f, 0.07875032f, 0.14682485f, 0.24061105f, 0.29386505f, 0.16820779f, 0.11688551f, 
    -0.08143654f, -0.08558630f, -0.03306416f, 0.05843591f, -0.05880490f, 0.03641615f, 0.05914660f, -0.00007281f, 
    0.09797742f, -0.36221752f, 0.28647086f, -0.20896006f, 0.07239567f, -0.13450375f, 0.07497589f, 0.23716967f, 
    0.16011576f, 0.02723142f, -0.10487755f, -0.03447278f, -0.16658711f, 0.34594190f, 0.14786582f, -0.06765114f, 
    -0.09828073f, 0.02848098f, 0.03847412f, -0.09912339f, 0.20584734f, -0.05485145f, 0.00753657f, 0.07372423f, 
    -0.14210396f, -0.14098023f, -0.03586087f, 0.00255793f, 0.08113162f, 0.07612330f, 0.03826267f, -0.01576655f, 
    -0.07157424f, -0.01962547f, -0.17790066f, 0.00644335f, -0.23524700f, -0.06470410f, -0.04969374f, 0.28657088f, 
    -0.08913041f, -0.07130508f, 0.05968101f, 0.02387811f, 0.10375300f, 0.09319546f, -0.03986709f, 0.11312745f, 
    0.31691828f, -0.02167297f, -0.16238557f, -0.29065707f, -0.05372974f, -0.07178780f, -0.11095273f, 0.03789246f, 
    0.01556418f, -0.03070813f, 0.02603203f, -0.03391922f, 0.23616500f, 0.01021400f, 0.11369359f, -0.02897666f, 
    0.13709255f, 0.03084980f, -0.01865210f, 0.00061693f, -0.07701389f, -0.12656184f, 0.12245703f, 0.03785443f, 
    0.02582809f, 0.30948025f, 0.08512849f, 0.07767936f, -0.02882929f, -0.01713470f, 0.09419289f, 0.03698451f, 
    0.03140377f, -0.20748040f, 0.03176295f, -0.09870383f, -0.13926527f, 0.21569444f, 0.21252970f, -0.22243001f, 
    -0.01709295f, -0.01427177f, -0.08083566f, 0.03526252f, -0.00005462f, -0.03730421f, -0.07557259f, -0.06402054f, 
    0.11099765f, 0.14136931f, 0.19281888f, 0.05363217f, -0.00891556f, 0.06512260f, 0.04304998f, -0.01007995f, 
    0.04674014f, -0.04690030f, 0.00879542f, 0.08551131f, -0.48984447f, 0.02534284f, -0.25152531f, 0.30506229f, 
    0.01189791f, 0.03247382f, -0.12686004f, -0.04858702f, 0.05529439f, -0.08399935f, 0.06459923f, 0.06382257f, 
    0.03903877f, -0.10652582f, -0.13504343f, -0.06578764f, -0.14207515f, -0.05355338f, -0.03750571f, -0.08456260f, 
    -0.09338775f, -0.06052648f, -0.03793025f, -0.13868421f, 0.02486648f, 0.19332066f, -0.08542759f, -0.11627903f, 
    0.04176583f, -0.09466593f, 0.12500721f, -0.04254475f, 0.06185956f, -0.01448491f, 0.04934870f, 0.00463985f, 
    0.15075929f, 0.19300276f, -0.28016344f, -0.21569367f, 0.18760051f, -0.09219963f, 0.12393886f, 0.16393940f, 
    -0.01561240f, 0.07586271f, -0.12356793f, -0.11696013f, -0.12968293f, -0.09426269f, 0.06622429f, -0.12026956f, 
    0.03978612f, -0.02821316f, 0.13515745f, 0.03542919f, -0.11973349f, -0.14380991f, -0.20866962f, -0.07962986f, 
    -0.08631345f, 0.04088585f, -0.01976411f, -0.05283780f, -0.13087085f, 0.14923346f, 0.06175602f, -0.09529234f, 
    0.10900545f, 0.27937379f, -0.18058342f, -0.03575983f, 0.21489379f, -0.15429401f, 0.13489546f, -0.05958369f, 
    -0.14314619f, 0.08400097f, -0.21301197f, 0.05472504f, -0.09051143f, 0.19541126f, 0.02854688f, -0.13058092f, 
    0.09802093f, -0.01091215f, -0.17186876f, -0.03989589f, -0.00066283f, 0.21254157f, -0.05953482f, 0.26320645f, 
    -0.13432375f, -0.07122054f, 0.07303187f, 0.08284268f, -0.14567287f, 0.11806343f, -0.05064899f, -0.03167010f, 
    0.03263514f, -0.04345848f, 0.15028946f, -0.15619400f, -0.07265063f, 0.10823523f, -0.07447017f, 0.05326273f, 
    0.00448356f, 0.35229224f, 0.02122173f, 0.07592241f, -0.11971629f, -0.04904998f, 0.00984795f, -0.03335163f, 
    0.02688830f, -0.20622207f, 0.04256029f, -0.02005885f, -0.03570143f, 0.22205262f, 0.12795852f, -0.11500464f, 
    0.01552114f, 0.05448847f, -0.07267758f, -0.02166938f, -0.08312099f, 0.02593565f, -0.00120539f, -0.01495058f, 
    0.08770169f, -0.12935551f, 0.00703193f, 0.08629981f, 0.11324730f, -0.09437035f, 0.10649671f, 0.16961032f, 
    0.00971402f, -0.01621711f, -0.08954311f, 0.02114377f, -0.08860616f, 0.20880722f, 0.13641876f, 0.16809949f, 
    -0.04946348f, -0.13422327f, 0.09514690f, -0.02277483f, 0.02074172f, 0.16090752f, 0.01107488f, 0.39670405f, 
    0.05974991f, 0.11469952f, 0.06674461f, 0.02740422f, -0.04445175f, 0.03882037f, 0.12789242f, 0.00577420f, 
    -0.14359680f, 0.07263488f, -0.07221372f, 0.00968251f, 0.18541712f, 0.27670333f, 0.39564764f, -0.05091419f, 
    -0.15903598f, -0.07776298f, 0.02859050f, -0.01112847f, 0.16395004f, 0.26568440f, 0.09608885f, 0.13002516f, 
    0.02441431f, -0.45892784f, -0.31164473f, -0.28103551f, -0.02149289f, -0.09674850f, 0.06616684f, 0.05263188f, 
    -0.08911125f, 0.08028007f, 0.10460932f, -0.11709484f, -0.02895876f, 0.03784218f, -0.11766004f, -0.28763196f, 
    0.07511137f, 0.01318890f, -0.01594757f, -0.01048030f, -0.03530353f, -0.10134763f, 0.15955442f, 0.01434559f, 
    0.01092062f, 0.14374413f, 0.17488913f, 0.18200991f, -0.00630529f, -0.18639247f, 0.01398149f, -0.04712746f, 
    -0.01950737f, 0.00715232f, 0.05497674f, 0.03817332f, -0.22529273f, 0.27131549f, -0.27606913f, -0.22423446f, 
    0.01191492f, 0.26596448f, 0.18836330f, 0.08014756f, -0.00125205f, 0.12949249f, -0.02062086f, 0.02786642f, 
    0.03512251f, 0.17281573f, 0.18193316f, 0.04612203f, 0.22172880f, -0.03500615f, -0.01945428f, -0.05712098f, 
    -0.08450303f, 0.03269319f, -0.18466723f, 0.04279787f, 0.08561012f, -0.18475141f, 0.18748415f, 0.00008393f, 
    0.04679900f, 0.01545695f, -0.03733962f, -0.01802566f, -0.00304797f, 0.03960147f, 0.11389694f, -0.04987411f, 
    0.00358914f, -0.03450682f, -0.22338000f, -0.03441271f, -0.05405308f, -0.13239942f, -0.07743021f, -0.17228569f, 
    0.21031862f, 0.26856032f, 0.02070047f, 0.04423174f, -0.23168840f, -0.02052168f, 0.15010546f, 0.04871615f, 
    -0.06086132f, -0.08317232f, 0.05437312f, 0.19348274f, 0.11174315f, 0.09198653f, 0.08887396f, -0.00821670f, 
    -0.44689682f, 0.11435664f, -0.17022873f, 0.25972974f, 0.12428153f, 0.10355590f, -0.05782088f, -0.01946785f, 
    -0.02989517f, -0.02072268f, 0.00316323f, -0.05264492f, -0.07340795f, 0.00563444f, -0.05388841f, 0.25647029f, 
    -0.05551270f, -0.08372077f, -0.02185421f, -0.08470074f, -0.11646268f, 0.03047530f, -0.07436291f, 0.11809245f, 
    0.22562620f, 0.17596418f, -0.02416787f, 0.10041685f, 0.00239636f, -0.08531804f, 0.04085195f, 0.15253597f, 
    0.05201071f, 0.07572073f, 0.01328789f, 0.16969073f, -0.44244975f, 0.13866134f, 0.11734026f, -0.00422939f, 
    0.07463570f, -0.04725633f, -0.04059658f, 0.01236852f, -0.04812906f, 0.07993350f, 0.02445805f, -0.00707743f, 
    0.03428447f, 0.11259646f, 0.18845923f, 0.07025013f, 0.05512689f, 0.16895205f, 0.10254031f, -0.03955800f, 
    -0.02248726f, -0.06504324f, 0.00634591f, 0.05876531f, 0.33393228f, 0.12329658f, 0.10346078f, -0.23351218f, 
    -0.14453165f, 0.02145504f, 0.00659250f, -0.09943862f, -0.01897869f, 0.09984864f, -0.06285347f, -0.10476054f, 
    -0.15978402f, 0.02111685f, 0.01284257f, 0.14133027f, 0.13730215f, -0.14697665f, 0.14137034f, -0.02332917f, 
    -0.08189487f, 0.08885615f, 0.05005619f, 0.08281126f, 0.51104611f, -0.07809059f, 0.01091396f, -0.03563813f, 
    0.00273979f, -0.00492693f, -0.19922112f, 0.03410704f, 0.15590739f, 0.29422548f, 0.15447567f, 0.14832895f, 
    -0.14050962f, -0.20501186f, 0.11398509f, 0.05563569f, 0.01821839f, -0.01460862f, -0.11208712f, -0.04494528f, 
    0.02066853f, 0.09714496f, 0.05033221f, 0.10170416f, 0.13044494f, -0.18019044f, -0.32886362f, 0.00660624f, 
    0.10996679f, 0.01524247f, 0.11717971f, 0.23755008f, 0.02366383f, 0.16303353f, 0.06158994f, 0.10591392f, 
    -0.13216388f, -0.13355611f, 0.03846919f, -0.09204347f, 0.01306713f, -0.06696536f, -0.10312098f, -0.04895858f, 
    0.00800286f, -0.04431151f, -0.06996907f, 0.03074485f, -0.13867110f, -0.07493763f, -0.07345567f, 0.06967185f, 
    -0.00030965f, 0.03871741f, 0.03026003f, 0.04066866f, 0.09083896f, 0.06277035f, 0.09318230f, 0.04529414f, 
    0.24627426f, -0.02085155f, 0.21780516f, -0.22161524f, 0.05205023f, 0.12837955f, -0.16502611f, -0.14564447f, 
    0.08177384f, -0.03827476f, 0.02898248f, 0.16062397f, -0.01450342f, -0.07772151f, -0.00610920f, -0.16001846f, 
    0.10782178f, -0.00463222f, -0.04559942f, -0.01867799f, 0.16516729f, 0.04183163f, 0.05243709f, 0.12551747f, 
    0.15974434f, 0.00253690f, 0.15591739f, 0.03643548f, 0.06081147f, 0.03848868f, -0.05644973f, -0.02956696f, 
    -0.00735271f, -0.05502325f, -0.02565596f, 0.09612323f, 0.19212194f, -0.22639373f, 0.17642528f, -0.23614597f, 
    0.12738277f, -0.09702314f, 0.07362112f, -0.04536849f, -0.04367262f, -0.02872350f, 0.18541288f, 0.21888913f, 
    0.06813470f, -0.27787706f, 0.27186865f, 0.23012771f, -0.11267858f, 0.01898582f, -0.00639645f, -0.04085075f, 
    -0.03936247f, 0.00596956f, 0.18227497f, 0.07888783f, -0.21064325f, 0.10228856f, -0.22822416f, 0.06560271f, 
    -0.12534225f, 0.16362739f, 0.12731653f, -0.01387300f, -0.04921757f, -0.26592585f, -0.16660254f, 0.02111469f, 
    0.15172940f, -0.03435637f, 0.05738335f, 0.03722381f, 0.00452995f, -0.08837724f, -0.03225913f, -0.03646727f, 
    -0.03999487f, -0.03377399f, -0.07142271f, -0.12226681f, 0.10476792f, 0.15746197f, 0.05665787f, 0.03626457f, 
    0.02024298f, -0.07201480f, -0.02259559f, 0.13012147f, -0.10013077f, -0.24139838f, -0.07505023f, -0.05702018f, 
    -0.00784495f, -0.09367996f, -0.01838490f, -0.17510830f, 0.10533386f, 0.05652007f, 0.11610176f, -0.06627555f, 
    0.09601069f, 0.06998787f, -0.07666215f, 0.01714396f, 0.16972627f, 0.04524103f, -0.44360989f, -0.20114483f, 
    -0.06849522f, 0.06798005f, 0.11571799f, 0.00218526f, -0.00938316f, -0.08361255f, 0.00616338f, -0.10802807f, 
    0.19699584f, -0.01742582f, -0.15223284f, -0.18901192f, -0.08218896f, -0.10158095f, 0.13327542f, 0.17372240f, 
    0.00295456f, 0.19015467f, 0.14501734f, 0.19359015f, 0.20947523f, -0.02970373f, -0.23910813f, -0.04154289f, 
    0.03058223f, 0.08538705f, 0.04843551f, 0.10295547f, -0.00918522f, -0.30741194f, 0.10561370f, -0.20694019f, 
    -0.10979434f, 0.00693846f, -0.01892954f, 0.00938327f, 0.02421018f, -0.18182491f, 0.12455031f, 0.02584285f, 
    -0.14087532f, -0.15304302f, -0.04008932f, 0.06600797f, 0.00010297f, -0.14123264f, 0.14633690f, -0.11190823f, 
    0.07355075f, 0.21306378f, -0.05080879f, -0.00379906f, 0.04050240f, -0.04460148f, -0.34713593f, 0.21211644f, 
    0.18646228f, 0.06451578f, 0.10509827f, -0.02554231f, 0.21159154f, -0.03478573f, 0.09413475f, -0.04443393f, 
    0.03793935f, -0.02945373f, -0.02464247f, -0.03755590f, 0.04542127f, 0.09128911f, -0.09522191f, -0.05752215f, 
    -0.13390024f, 0.13768317f, -0.14699472f, -0.12762634f, 0.08716451f, -0.08139026f, -0.20820406f, -0.27133694f, 
    0.03690976f, 0.17380632f, 0.16478571f, 0.08559797f, -0.05091996f, 0.04752782f, 0.07178865f, -0.17304377f, 
    -0.08463308f, 0.09290776f, 0.13147001f, -0.13392894f, 0.03926917f, -0.18850778f, -0.00943195f, 0.09678429f, 
    -0.14815563f, 0.01860068f, 0.04882479f, 0.09633205f, 0.06122090f, -0.03638510f, 0.05393109f, -0.02061085f, 
    0.10116240f, -0.32664174f, -0.39463204f, 0.20902924f, 0.12289315f, -0.11300624f, -0.04706160f, -0.00806009f, 
    0.21225251f, 0.12587461f, 0.14000264f, 0.24048270f, -0.20091167f, 0.23089898f, -0.10838398f, 0.02939292f, 
    0.09244410f, 0.05850234f, 0.19261584f, 0.03217672f, 0.14787665f, -0.11390945f, 0.11807767f, 0.10250393f, 
    0.44514492f, -0.41091612f, 0.19985949f, 0.05027123f, -0.08084108f, -0.07763064f, 0.12076484f, 0.06546120f, 
    0.01450867f, 0.09412977f, -0.15703934f, 0.07700364f, 0.09619126f, -0.10591902f, 0.07743118f, -0.04266036f, 
    0.12088270f, 0.13278584f, 0.07567826f, 0.15065613f, 0.01144796f, -0.11775886f, -0.00563446f, 0.23447527f, 
    0.10148095f, -0.55208886f, -0.38845035f, -0.05122274f, 0.11252488f, -0.07659660f, -0.10825782f, -0.03423935f, 
    0.03353877f, 0.00392442f, -0.05194346f, 0.09460421f, -0.28452376f, -0.49798456f, -0.06003332f, -0.00712496f, 
    0.10014247f, 0.15637906f, -0.01619483f, 0.01820252f, 0.18685819f, -0.05549327f, 0.13370256f, 0.01127236f, 
    0.48378024f, 0.29891494f, 0.20604442f, 0.06573533f, -0.05962402f, 0.01838779f, 0.07309271f, -0.03500648f, 
    0.00161708f, 0.06707943f, 0.21249449f, -0.04981088f, 0.04712493f, -0.18154542f, -0.23826213f, -0.12338311f, 
    -0.07446298f, 0.00265779f, 0.04404157f, 0.01726715f, 0.01424815f, 0.01313486f, -0.02292649f, -0.02950129f, 
    -0.07285171f, -0.16004716f, -0.05331657f, -0.00312654f, 0.04871334f, -0.06274902f, 0.00671338f, -0.14415394f, 
    0.00549321f, -0.22633432f, 0.05903214f, 0.00847060f, -0.30434871f, -0.34819391f, -0.48699713f, -0.15521322f, 
    0.17623509f, 0.01492515f, -0.07466846f, 0.11697665f, 0.11356529f, -0.06234124f, 0.06671958f, -0.07055350f, 
    0.01937545f, 0.30122921f, 0.12866677f, 0.10195521f, -0.11536700f, 0.03235528f, -0.00751084f, -0.08811244f, 
    0.03238014f, 0.03680173f, 0.14081147f, 0.14499520f, 0.03400654f, 0.11019817f, 0.21399827f, 0.03110546f, 
    -0.00046471f, 0.01266290f, -0.04692697f, -0.09052441f, 0.16560964f, -0.07023706f, -0.10144066f, -0.10928815f, 
    -0.13772643f, -0.34125578f, -0.23403253f, -0.00944775f, 0.06695225f, 0.11000866f, -0.17926334f, -0.02252026f, 
    0.00469085f, -0.03754459f, -0.00115174f, 0.05641503f, 0.30241451f, -0.11771406f, 0.23618336f, 0.14750603f, 
    0.15025677f, 0.02139522f, -0.01862613f, 0.05696269f, 0.06119232f, -0.11943641f, 0.10492095f, 0.10785491f, 
    0.04308882f, 0.09957103f, -0.41415733f, -0.12420065f, -0.00490799f, 0.24155706f, 0.22351387f, -0.08934598f, 
    0.12713595f, -0.01431799f, -0.02317240f, -0.02789418f, -0.13356915f, 0.24110144f, -0.09596401f, 0.24403584f, 
    0.17000392f, -0.11395128f, 0.04638259f, -0.12815623f, -0.02193829f, -0.14484057f, -0.24232124f, -0.26169261f, 
    0.05257325f, -0.04600129f, 0.13112777f, -0.06121371f, -0.17763603f, 0.09339321f, 0.12281913f, 0.00164603f, 
    0.17311862f, 0.00537384f, 0.00577541f, 0.28558841f, 0.11307949f, -0.44852617f, 0.14697358f, -0.01058174f, 
    -0.08158822f, -0.14188018f, -0.08303614f, -0.08307318f, -0.01087682f, -0.02798206f, 0.22811177f, 0.18394089f, 
    -0.36355639f, -0.04391561f, -0.33678192f, -0.12255305f, 0.09293353f, 0.05852409f, -0.02118605f, 0.14933912f, 
    -0.17894809f, 0.00496358f, 0.09575924f, -0.14920989f, -0.04537867f, -0.00170510f, -0.11910961f, 0.04785824f, 
    0.03733984f, -0.15528207f, 0.06588500f, 0.00611101f, 0.00489606f, 0.17513418f, 0.05485354f, 0.18736790f, 
    0.38655442f, 0.15705860f, -0.01696494f, 0.08727540f, 0.04418467f, 0.04901390f, 0.05079051f, 0.09369744f, 
    0.11089829f, -0.02002607f, -0.07809947f, -0.08620320f, 0.16051896f, 0.06202225f, 0.15512869f, 0.06637306f, 
    0.01753628f, -0.06748891f, -0.04631765f, -0.16553921f, -0.04111611f, -0.08214713f, 0.00995474f, 0.18861884f, 
    -0.07400431f, 0.13046339f, 0.05036738f, -0.05993136f, -0.08696794f, -0.02446740f, -0.03460376f, -0.13998236f, 
    0.05206141f, -0.01946585f, -0.04804441f, 0.00759058f, -0.01815531f, 0.17806184f, 0.42083588f, -0.12278000f, 
    0.14531115f, -0.17757504f, 0.14185829f, 0.08648755f, 0.09136829f, 0.11824551f, 0.06161428f, 0.18246613f, 
    -0.02739422f, -0.15861803f, 0.00333444f, 0.03899992f, -0.09535865f, -0.04211165f, -0.03886023f, 0.10531778f, 
    -0.06885426f, 0.10959131f, 0.00377374f, -0.05535520f, -0.06655215f, 0.09710250f, 0.25044316f, 0.15566728f, 
    0.07295245f, -0.05035818f, 0.08857499f, -0.02089434f, -0.01678228f, 0.25325266f, 0.11367261f, -0.01089824f, 
    -0.27468309f, -0.14392509f, -0.03563663f, -0.13690472f, 0.09542723f, 0.04543406f, 0.00716088f, 0.15196054f, 
    -0.10104627f, 0.02526716f, -0.17020425f, -0.08022866f, 0.31143871f, -0.12349485f, -0.20698941f, 0.25593436f, 
    0.32846597f, 0.08792759f, -0.15711294f, 0.04460927f, -0.03651736f, 0.00654175f, 0.21296068f, -0.07250369f, 
    0.11516704f, 0.04773525f, 0.10408554f, 0.05935574f, -0.00719800f, 0.09357684f, 0.16084975f, 0.00873125f, 
    -0.02084953f, 0.01100809f, -0.22493151f, -0.13943270f, -0.09662786f, -0.22783044f, 0.14726193f, 0.11200482f, 
    -0.16800690f, -0.04755634f, -0.01153110f, -0.04351098f, 0.17652257f, 0.13951352f, 0.18286560f, 0.28346029f, 
    0.06228387f, 0.27965435f, 0.01276685f, -0.01342764f, 0.11656633f, -0.01113942f, 0.04302764f, 0.31218019f, 
    0.11946920f, -0.11241352f, -0.00013598f, 0.27473167f, -0.09097413f, -0.06395259f, -0.08905371f, -0.07894404f, 
    0.10731126f, -0.04818384f, -0.00989220f, 0.19543102f, 0.01626892f, -0.04531266f, -0.13768265f, 0.00399098f, 
    0.05542078f, -0.05943479f, -0.08058880f, 0.14535260f, 0.03494202f, 0.02000483f, 0.15160102f, 0.00313120f, 
    0.03034472f, 0.00334694f, 0.11447328f, 0.09086677f, -0.48499537f, 0.34180924f, -0.11221319f, 0.03733847f, 
    -0.13685207f, -0.07360061f, -0.05564514f, 0.08282277f, -0.05952410f, 0.03757733f, -0.05835494f, -0.02406440f, 
    -0.12222105f, 0.01335862f, -0.18058561f, 0.12923260f, 0.03635317f, -0.16184002f, 0.08169148f, -0.05845457f, 
    0.13174413f, 0.05325600f, -0.14930479f, -0.15509126f, 0.24792883f, -0.08578694f, 0.18237157f, -0.10387132f, 
    0.07662385f, -0.08151340f, 0.05042323f, 0.18042551f, 0.03629189f, 0.09170500f, 0.16698194f, 0.04868677f, 
    0.27869916f, 0.04694617f, 0.15263589f, 0.02100574f, 0.11117563f, -0.03627994f, 0.13142866f, 0.13147338f, 
    0.08990691f, -0.02982426f, 0.00880170f, 0.03270162f, -0.26692480f, -0.21123062f, 0.05650988f, 0.11087356f, 
    0.01462125f, -0.04851477f, -0.08765330f, 0.02913046f, 0.17400637f, -0.01236113f, 0.14949879f, 0.07262167f, 
    0.28813410f, 0.11774749f, 0.00545662f, -0.23293954f, -0.15924671f, -0.07324571f, 0.04176041f, 0.06975022f, 
    -0.18266104f, 0.11179468f, -0.00235173f, 0.03858052f, 0.37252381f, -0.16414961f, 0.34448567f, 0.07293290f, 
    0.08668300f, 0.01737619f, 0.01593631f, 0.10957425f, -0.08329663f, 0.13162893f, 0.04874170f, -0.16063344f, 
    -0.47010499f, -0.15390933f, 0.06856390f, 0.02362731f, 0.04894114f, -0.10314529f, 0.00317223f, -0.10238793f, 
    0.02019628f, -0.09045991f, -0.03504061f, -0.07895182f, 0.08189289f, -0.12314525f, 0.11290825f, 0.06135619f, 
    0.04093784f, -0.00411558f, -0.15401059f, -0.00086049f, 0.18439811f, 0.16567177f, -0.02522478f, 0.22551045f, 
    -0.28372228f, 0.26479483f, 0.09041447f, -0.05539329f, -0.05396895f, 0.07142217f, -0.03122813f, -0.16229944f, 
    0.06627597f, -0.06115084f, -0.02219461f, -0.02861558f, 0.08017570f, 0.30764425f, -0.13429469f, 0.35639808f, 
    -0.03223619f, 0.00672411f, -0.00826433f, 0.15023635f, 0.13421343f, 0.05904366f, 0.06439599f, -0.13718964f, 
    -0.21305270f, -0.07128382f, 0.01766677f, 0.03493953f, -0.16983823f, 0.04048084f, -0.19642293f, -0.03617031f, 
    -0.07167069f, 0.01504444f, -0.02764776f, -0.09531724f, 0.17562984f, -0.18550088f, -0.00161288f, 0.07073107f, 
    0.16800088f, -0.09635028f, 0.09546342f, 0.01500601f, -0.16362587f, -0.01384766f, 0.16159418f, 0.16629317f, 
    0.21822178f, -0.00979023f, 0.02533104f, -0.09141535f, -0.01130477f, 0.25435659f, -0.01324773f, 0.02868438f, 
    0.02955747f, -0.03896166f, 0.05747969f, 0.02484368f, -0.22700667f, 0.01861729f, -0.06397819f, -0.19803385f, 
    0.20383418f, 0.04282032f, -0.13715456f, -0.04048048f, 0.03444649f, 0.01583065f, -0.28154352f, 0.11931568f, 
    -0.00435608f, 0.07085297f, 0.10436460f, -0.11300386f, 0.05064712f, -0.06398695f, -0.03785728f, -0.15627338f, 
    -0.19390649f, -0.18311694f, 0.04610418f, -0.01425744f, 0.03909357f, 0.17011768f, 0.11524077f, -0.05003616f, 
    -0.03471373f, -0.09483729f, -0.07629987f, 0.25738269f, 0.02094894f, 0.01238973f, -0.05340182f, -0.07242973f, 
    0.05240706f, -0.24038830f, 0.47046646f, -0.16205733f, -0.04208041f, -0.06911843f, 0.00899420f, 0.23022804f, 
    0.27792093f, 0.04529288f, 0.01873174f, -0.04886327f, -0.18168974f, 0.27836385f, -0.03669540f, -0.01094086f, 
    -0.10237546f, 0.09958579f, -0.07298939f, 0.10543060f, 0.13130812f, -0.01346222f, -0.09607618f, -0.15163465f, 
    -0.17183825f, -0.17489131f, -0.05220528f, -0.22178300f, 0.07878821f, 0.07337017f, 0.14469610f, -0.07227656f, 
    0.01659661f, 0.18373385f, 0.01719629f, -0.06444382f, -0.49317843f, -0.06899002f, -0.36319625f, -0.00156922f, 
    -0.14947738f, -0.13671140f, -0.08531692f, 0.03171845f, 0.18506607f, 0.04045060f, -0.05522326f, 0.16870600f, 
    0.09763841f, -0.04703105f, -0.12858662f, -0.19079217f, -0.15006064f, -0.02838100f, -0.09667374f, 0.06679437f, 
    0.04480793f, -0.20239630f, -0.11526630f, 0.07344048f, 0.18098778f, 0.01015676f, 0.01985750f, 0.09163827f, 
    0.03279406f, 0.10989185f, -0.09538992f, 0.04675478f, -0.09284761f, -0.22178835f, 0.17358048f, 0.01557078f, 
    0.01786646f, 0.31092817f, 0.07138289f, 0.18931118f, -0.04727886f, 0.13503383f, 0.13455288f, 0.16906281f, 
    0.09165232f, 0.02814651f, -0.07590725f, -0.01225356f, -0.23985359f, 0.20910679f, 0.05211258f, -0.16509491f, 
    0.01934768f, -0.02936625f, 0.04459716f, -0.05479489f, 0.05021382f, -0.02541690f, -0.20235786f, -0.05571626f, 
    0.07948173f, 0.05169563f, 0.29941121f, 0.08067157f, -0.05270870f, 0.00966009f, 0.10095330f, 0.13871089f, 
    0.08779692f, -0.09301458f, -0.00533739f, 0.10552865f, -0.54194343f, -0.30076754f, -0.15932550f, 0.32500857f, 
    -0.12788738f, 0.15633081f, -0.14680442f, -0.02670323f, -0.05981264f, 0.10238858f, 0.11246724f, 0.14586703f, 
    -0.02216791f, -0.23977637f, -0.23563910f, -0.33474183f, -0.21700992f, -0.05943326f, -0.00506819f, -0.08096129f, 
    0.17469057f, -0.02483705f, 0.10427675f, 0.03134253f, -0.20340112f, 0.12339876f, -0.00656028f, -0.03188028f, 
    0.03381571f, -0.01892254f, 0.09817187f, 0.12151377f, -0.10670789f, -0.13338751f, -0.15763010f, -0.20447117f, 
    0.12791803f, 0.02024786f, -0.11035942f, -0.13715261f, 0.13441247f, -0.13017738f, 0.20219435f, 0.15771519f, 
    -0.00541326f, -0.01366995f, 0.09687286f, -0.03766333f, 0.05128099f, -0.09187049f, 0.26924852f, -0.01963301f, 
    0.02411331f, -0.00944762f, 0.32487643f, 0.22998224f, -0.03612812f, 0.08795788f, 0.03406439f, 0.29492885f, 
    0.03150590f, 0.02671169f, -0.01005916f, 0.04315631f, 0.05072478f, -0.07168732f, -0.05739671f, -0.03544210f, 
    0.04976436f, 0.04727606f, -0.00989602f, -0.01031218f, -0.05432005f, 0.00100833f, -0.02089036f, -0.05363602f, 
    -0.01299774f, -0.01924879f, 0.03112917f, -0.01396547f, -0.00192464f, -0.00718302f, 0.00568730f, -0.00915139f, 
    -0.04883799f, -0.04393356f, -0.01218535f, 0.03817271f, -0.07109696f, -0.00557136f, -0.01258707f, -0.00391180f, 
    -0.05774722f, -0.05637890f, -0.01666162f, -0.04585791f, 0.03273126f, -0.04937384f, -0.00993131f, 0.03627044f, 
    0.03373289f, 0.04207054f, -0.06843554f, 0.01100041f, 0.06514377f, -0.02664065f, -0.01158545f, -0.03046709f, 
    -0.00272965f, 0.05936351f, 0.05500754f, -0.05449718f, 0.01720526f, -0.03275236f, 0.04307498f, -0.00154709f, 
    0.04367506f, -0.04295395f, 0.04461139f, 0.01234667f, -0.07778633f, -0.03559253f, -0.03451559f, 0.05005640f, 
    -0.01962820f, -0.03814030f, -0.04125398f, -0.06191506f, -0.03343617f, 0.01030511f, -0.02156758f, 0.04528905f, 
    -0.05630441f, -0.00853850f, 0.02040261f, 0.05292961f, -0.07353904f, -0.00779554f, -0.02552596f, -0.01706501f, 
    0.05925763f, -0.04686903f, -0.05366048f, -0.01186824f, 0.01030846f, -0.07471715f, 0.04845722f, -0.02736278f, 
    -0.04211181f, 0.03769042f, 0.01470840f, -0.00981793f, 0.00561939f, -0.00400351f, -0.01158863f, -0.03854591f, 
    -0.01629091f, -0.00021940f, 0.02317226f, 0.03196192f, -0.06478757f, 0.04674533f, -0.04096922f, -0.01970112f, 
    0.00929355f, -0.07414319f, 0.03510938f, -0.02387962f, 0.01114146f, -0.04537271f, 0.03402210f, 0.03903625f, 
    -0.01000959f, 0.01640615f, -0.04479711f, 0.01200972f, 0.06003693f, -0.07439806f, -0.01125322f, -0.03929040f, 
    -0.05910849f, 0.05725243f, 0.05232937f, -0.04128927f, 0.06168138f, -0.02451819f, -0.05481943f, 0.01336005f, 
    0.01681528f, -0.01439290f, -0.05498524f, -0.05781989f, -0.03017363f, -0.00737106f, -0.07067818f, -0.03723692f, 
    -0.00940400f, 0.02733491f, -0.02053125f, 0.06171232f, -0.04984352f, -0.06925311f, -0.02058332f, 0.01383009f, 
    0.02772260f, -0.01254349f, -0.03772966f, 0.04037171f, -0.02210388f, 0.06522146f, 0.06223448f, 0.06580325f, 
    0.03318385f, -0.00223731f, -0.02750260f, -0.04957950f, 0.06510244f, 0.05453243f, -0.03360619f, 0.03149902f, 
    -0.01058528f, 0.02024844f, 0.06513679f, 0.02271713f, -0.05532370f, 0.03442340f, -0.01593676f, 0.05786093f, 
    -0.04171525f, -0.07761274f, -0.00289450f, 0.03746636f, -0.00311667f, -0.03459800f, -0.00135895f, 0.07135414f, 
    -0.00613878f, -0.01380594f, -0.07710761f, -0.06875101f, -0.03409807f, 0.03185467f, -0.01204047f, -0.03638619f, 
    -0.01362765f, -0.01643433f, -0.03935968f, -0.03351255f, -0.01444265f, -0.07711123f, -0.02828715f, -0.03923455f, 
    -0.05127228f, 0.01780706f, -0.05219610f, 0.00578666f, -0.00793603f, -0.01792430f, -0.04353360f, 0.00986899f, 
    0.01946724f, -0.03285149f, -0.01423846f, -0.00572497f, 0.01161508f, 0.05518662f, -0.05910675f, 0.03267422f, 
    0.02750906f, -0.00958793f, -0.01275676f, -0.04543765f, -0.01911501f, 0.00725272f, -0.02889649f, 0.00492261f, 
    -0.06620514f, -0.00824092f, -0.00941147f, 0.03675804f, -0.07179221f, 0.00565648f, -0.04392805f, -0.04034825f, 
    0.03702974f, 0.06277796f, 0.01988368f, -0.05773359f, -0.07143083f, 0.02629039f, -0.01449777f, -0.03223170f, 
    -0.01786293f, -0.00198799f, 0.02268191f, -0.03540143f, 0.00392927f, -0.01452941f, -0.06085730f, -0.00584488f, 
    -0.03824734f, -0.02954568f, 0.06058760f, 0.00575354f, -0.04469829f, -0.00010609f, -0.06745939f, -0.05439666f, 
    0.01725126f, -0.00626514f, 0.00036828f, 0.06851470f, -0.02437233f, -0.04639928f, -0.06705347f, -0.06191889f, 
    0.03147409f, -0.04817894f, -0.03766948f, -0.01596511f, -0.01005397f, 0.06383566f, 0.00432645f, 0.01789375f, 
    0.02032183f, -0.02613544f, 0.00131086f, 0.03801092f, 0.05911009f, -0.04006578f, -0.03764073f, 0.01717594f, 
    -0.04272454f, 0.04900816f, -0.01063150f, 0.04802076f, -0.02904034f, 0.04841005f, -0.05891069f, 0.00532875f, 
    -0.01256360f, 0.00354952f, 0.03631816f, -0.05785694f, -0.06464508f, -0.04961467f, -0.06089381f, 0.03722901f, 
    0.04846403f, 0.04453230f, -0.03668031f, -0.07420764f, 0.01589268f, 0.00343597f, -0.03504193f, 0.01470988f, 
    -0.02601614f, -0.06177733f, -0.06872695f, -0.05008902f, 0.01094662f, -0.07700616f, -0.04472621f, -0.00877540f, 
    -0.06448832f, -0.00241492f, 0.02340215f, 0.03748382f, -0.04711258f, 0.05484878f, -0.04289974f, 0.01233236f, 
    0.03008924f, -0.01020085f, 0.02101842f, -0.05982544f, 0.05537682f, 0.03243337f, 0.04717481f, -0.03264244f, 
    0.00537813f, 0.01659249f, -0.05142179f, 0.02075757f, -0.02835082f, -0.03003883f, -0.06729595f, -0.06912806f, 
    -0.01177439f, -0.03317958f, 0.01657809f, -0.07405218f, -0.06900118f, -0.01786499f, -0.00701597f, 0.06453083f, 
    -0.00617738f, -0.03014608f, 0.06460600f, -0.02763950f, -0.04321543f, 0.05993792f, -0.02200843f, 0.01348618f, 
    -0.00431355f, -0.07091063f, -0.01883937f, -0.05078635f, -0.06012525f, 0.04156704f, -0.00562536f, -0.01372530f, 
    0.01234228f, 0.02287994f, -0.00230865f, -0.03987991f, -0.02043680f, 0.02622644f, -0.03537000f, 0.04203828f, 
    0.02801511f, -0.01938350f, 0.02940506f, 0.04205021f, -0.03611613f, -0.04886134f, -0.02550879f, -0.05944898f, 
    -0.00271785f, -0.07193045f, -0.06082452f, -0.06427220f, -0.05637691f, 0.00388069f, -0.06284255f, 0.01251297f, 
    -0.00095576f, -0.02433515f, -0.04118097f, 0.04871113f, -0.05224678f, -0.06208364f, -0.04623796f, 0.00560579f, 
    -0.27787080f, 0.18610616f, 0.18160959f, -0.22385131f, -0.20565230f, 0.05517756f, 0.09789899f, -0.10034725f, 
    -0.17291665f, -0.02237447f, -0.24856922f, -0.14624076f, 0.06053953f, -0.07652581f, -0.03384621f, 0.16323870f, 
    0.08513171f, 0.00264480f, -0.02817814f, 0.00302670f, -0.10323724f, 0.03272241f, 0.02055586f, -0.07398024f, 
    -0.07180143f, 0.35621795f, -0.36475262f, -0.01821857f, -0.04987026f, 0.06429362f, 0.12841295f, 0.07165642f, 
    0.00271322f, -0.06953423f, 0.13737532f, 0.04552030f, 0.01305042f, 0.17447893f, -0.08068656f, 0.00351091f, 
    0.09694735f, -0.00771821f, -0.13142148f, -0.07912702f, 0.06926835f, 0.09581601f, -0.03010541f, -0.11804152f, 
    -0.25805357f, 0.28895241f, 0.13880107f, -0.20375353f, 0.00403399f, 0.06446466f, -0.02940080f, -0.00575961f, 
    0.04064786f, -0.04821045f, 0.01225455f, 0.05317742f, -0.13899873f, 0.02771196f, -0.38914251f, -0.36902872f, 
    -0.04023761f, 0.12069994f, 0.08018228f, -0.04495600f, 0.00516580f, 0.06770517f, -0.06955407f, 0.09172826f, 
    -0.13252902f, -0.02646232f, -0.07462626f, 0.00214216f, -0.19197361f, -0.11465620f, -0.11263957f, 0.10465137f, 
    -0.00488768f, 0.03345665f, -0.10413529f, 0.04557500f, -0.09816076f, 0.08546107f, 0.50945950f, 0.14002985f, 
    -0.05332617f, -0.05122479f, -0.00060633f, -0.02313609f, -0.13212454f, 0.05753813f, 0.00142264f, 0.13256225f, 
    0.09823554f, 0.26920238f, 0.06145908f, 0.19717920f, -0.02126297f, 0.22353774f, 0.17178255f, 0.06478096f, 
    -0.03566616f, 0.19507931f, 0.02963596f, 0.08048670f, -0.04678163f, 0.33461246f, 0.52364850f, 0.10977918f, 
    -0.28593934f, -0.02671598f, 0.04647637f, -0.06768315f, -0.00868602f, 0.17645586f, 0.06252213f, 0.11737536f, 
    0.04467529f, -0.26592749f, -0.06205915f, -0.04060423f, -0.10426962f, 0.03559181f, -0.09716656f, -0.04449475f, 
    0.05692892f, 0.10437115f, 0.02081056f, -0.00378181f, -0.20137155f, 0.07969839f, -0.36264634f, -0.25449881f, 
    0.10092428f, -0.07823740f, 0.12108202f, -0.06134056f, 0.05998961f, 0.01526997f, 0.13398603f, 0.19594473f, 
    -0.09101732f, -0.02990398f, 0.02126929f, -0.16435850f, -0.24635321f, -0.11651316f, 0.09933220f, 0.00105650f, 
    -0.00105155f, 0.05541641f, 0.00046803f, -0.13845870f, -0.35735756f, 0.24390189f, -0.28968078f, -0.02323625f, 
    -0.04595841f, 0.04362777f, 0.14953397f, 0.16123421f, -0.00020447f, 0.07983223f, -0.00037644f, 0.01348227f, 
    0.02566251f, 0.01433676f, 0.31046128f, 0.07076018f, -0.08591987f, -0.05718778f, -0.10677064f, 0.02515576f, 
    -0.17681320f, 0.04129590f, -0.07767013f, 0.05401125f, 0.32864806f, -0.24601313f, 0.18254788f, 0.00214175f, 
    -0.14049411f, 0.12615342f, 0.07261634f, 0.13312441f, 0.03256639f, 0.20533139f, 0.23626038f, 0.16943417f, 
    -0.07425389f, -0.02232365f, -0.02514300f, -0.03017000f, 0.09029880f, -0.25381353f, -0.08357956f, -0.08167791f, 
    0.21346678f, 0.00986764f, -0.08532390f, 0.20232423f, 0.14355463f, 0.21234006f, 0.26341614f, 0.31433702f, 
    0.16123825f, -0.01510924f, 0.07084673f, -0.04419659f, 0.04506622f, -0.05199239f, 0.00735278f, 0.17802121f, 
    -0.00690972f, -0.39096147f, 0.08750334f, 0.00829844f, 0.03960913f, -0.19863217f, 0.13943219f, -0.02172806f, 
    0.12887089f, 0.05773902f, -0.05433435f, -0.04722638f, -0.27401417f, 0.35388982f, 0.05107695f, 0.16427040f, 
    -0.13338117f, 0.15417250f, -0.01287979f, -0.20057614f, 0.13871792f, 0.03754104f, 0.07979088f, -0.08783458f, 
    -0.15056844f, -0.22638676f, -0.05143003f, 0.15651482f, 0.03854586f, -0.00801995f, -0.00979397f, -0.00772701f, 
    -0.04042985f, -0.04602282f, -0.13655689f, 0.02123609f, -0.18836094f, 0.06384474f, 0.12692679f, 0.42899486f, 
    -0.01410829f, 0.01527359f, 0.12199727f, 0.12608105f, 0.08858977f, 0.10659435f, 0.10830157f, 0.08511297f, 
    0.03019535f, 0.11866049f, 0.08105528f, -0.30587775f, -0.03292919f, 0.03256297f, -0.04536935f, -0.16341941f, 
    0.00833678f, -0.01223021f, -0.09734507f, 0.09005757f, 0.19276080f, -0.07750708f, 0.15155783f, -0.18879759f, 
    0.13828570f, 0.06592943f, 0.04025850f, -0.11811079f, -0.09163250f, -0.01785828f, -0.03327725f, 0.09171180f, 
    -0.03279832f, 0.28033110f, 0.09692227f, 0.29893526f, 0.13648912f, -0.00789415f, 0.03640883f, 0.06448505f, 
    0.08874089f, -0.11214947f, 0.02492198f, -0.04322568f, 0.12313616f, -0.04290876f, -0.06349254f, 0.05346934f, 
    0.04733527f, -0.00361460f, -0.13415998f, 0.09897352f, -0.04063879f, -0.11368094f, -0.06686040f, -0.19365112f, 
    -0.03315744f, 0.03729600f, 0.08157849f, 0.22793202f, -0.01867707f, 0.14085539f, -0.05146534f, -0.00506175f, 
    0.01577030f, 0.08253933f, -0.14934450f, -0.03387440f, -0.32793802f, -0.03146835f, -0.08344737f, 0.21233244f, 
    -0.11050631f, -0.01159412f, -0.01407177f, 0.22004634f, 0.09334049f, 0.13499261f, -0.20065480f, 0.12241537f, 
    -0.07699732f, -0.18221687f, -0.24537949f, -0.22145535f, 0.08663859f, 0.05962702f, 0.05703181f, 0.09327199f, 
    -0.09525530f, 0.07459377f, -0.00366482f, 0.01735599f, -0.22149730f, 0.06676500f, 0.05850032f, -0.08455770f, 
    -0.03088169f, -0.09400540f, 0.00168711f, -0.08329327f, 0.13186336f, -0.05668623f, 0.08698720f, 0.21156169f, 
    0.24781944f, -0.07565365f, -0.35620022f, -0.32443783f, 0.14384322f, -0.10422749f, 0.02353349f, 0.13029346f, 
    -0.09248372f, -0.01337768f, -0.12911059f, 0.14304000f, 0.00637232f, -0.03697419f, -0.01759761f, 0.00064401f, 
    0.03858075f, -0.06328516f, -0.08316102f, 0.01084563f, -0.01816708f, -0.07105201f, -0.13410094f, -0.19278212f, 
    -0.00437275f, 0.05911009f, -0.00912170f, -0.13168241f, -0.06266329f, 0.03070711f, -0.01346861f, -0.07532888f, 
    -0.19114840f, -0.13987570f, -0.09999043f, -0.26617244f, -0.17928331f, 0.06811476f, -0.14782509f, -0.22138953f, 
    0.05621840f, -0.04291158f, -0.11170750f, 0.00095499f, -0.08885357f, -0.00351768f, -0.00089926f, -0.16152591f, 
    0.00296286f, 0.06710331f, -0.00300985f, 0.00935747f, 0.00364506f, 0.14817616f, -0.10534718f, 0.16741340f, 
    0.09215800f, -0.03144667f, -0.05458194f, -0.01514189f, 0.04460753f, -0.03219238f, 0.00093972f, -0.19330788f, 
    0.14352350f, -0.02126013f, -0.06549980f, 0.06494909f, 0.01735483f, 0.03978638f, -0.02216210f, -0.08584195f, 
    -0.02047201f, 0.12234551f, 0.06207038f, -0.22182965f, 0.05356525f, -0.12865105f, -0.01633139f, -0.00149764f, 
    0.01627252f, -0.08610488f, 0.00955969f, -0.02700283f, -0.21948612f, -0.19836405f, -0.10338767f, -0.19472326f, 
    -0.10855658f, 0.01957719f, -0.16923684f, -0.21611592f, 0.04133793f, 0.00748518f, 0.04527637f, 0.05143129f, 
    0.24028015f, -0.10007431f, -0.14213882f, 0.09769405f, 0.01956052f, -0.16410734f, -0.03131894f, 0.26902452f, 
    -0.09713085f, -0.06833279f, -0.15260379f, 0.04080316f, 0.21105972f, -0.06518652f, 0.21880712f, 0.24537119f, 
    -0.01594053f, -0.10999135f, 0.04962450f, 0.03186456f, -0.12415905f, -0.14256577f, -0.04219500f, -0.01554653f, 
    -0.04488851f, 0.02591468f, -0.17179878f, -0.19659875f, 0.00956022f, 0.07087434f, 0.02468235f, 0.05727620f, 
    -0.04766617f, 0.13906057f, 0.16376263f, -0.01078143f, 0.04977967f, 0.13808934f, 0.29414064f, 0.00357669f, 
    -0.15061998f, -0.17768922f, 0.01749127f, -0.00264926f, 0.17083333f, 0.00750508f, -0.11083316f, 0.02483408f, 
    0.01267422f, 0.03261529f, 0.13924089f, 0.00462302f, 0.07529357f, 0.01276783f, 0.11625629f, 0.05306811f, 
    -0.03303887f, -0.05041096f, 0.03562377f, -0.16451037f, -0.25250727f, 0.11599310f, 0.20560972f, 0.05572517f, 
    -0.01276503f, 0.08516786f, 0.10297889f, -0.03185846f, 0.06787569f, 0.08712789f, 0.07422571f, 0.02164557f, 
    -0.07316699f, -0.05826737f, -0.07015513f, 0.12964742f, -0.15722954f, 0.03171585f, -0.11015712f, -0.11616156f, 
    0.25679922f, -0.03759107f, 0.04735450f, 0.04539800f, 0.00654328f, 0.11447392f, -0.09273405f, -0.15554392f, 
    0.03080583f, -0.05100967f, 0.03677964f, 0.03659461f, -0.19284235f, -0.03379407f, -0.09976330f, -0.24138585f, 
    0.09585677f, -0.05207808f, 0.17096345f, 0.11104695f, -0.05692395f, 0.06961529f, -0.03852796f, 0.05650330f, 
    -0.01984458f, 0.07594189f, 0.02237527f, -0.02408395f, -0.01456932f, -0.15039998f, 0.29148728f, -0.02621616f, 
    -0.04488087f, 0.20607047f, 0.12218334f, 0.17160103f, 0.06367607f, 0.25056925f, 0.11082727f, 0.17847230f, 
    0.13922258f, 0.00844123f, -0.13296093f, 0.04298398f, -0.08783378f, 0.05645028f, 0.02293671f, 0.03969659f, 
    -0.19279766f, 0.05474827f, -0.02972697f, -0.36150306f, -0.36531785f, 0.03164991f, -0.10529902f, -0.14939426f, 
    -0.00708114f, -0.01423744f, -0.06292084f, 0.13443540f, -0.11919534f, 0.17858858f, -0.00355793f, -0.23729259f, 
    -0.28178144f, 0.18343127f, -0.07519623f, 0.30122286f, 0.11640534f, 0.23455364f, -0.04048549f, -0.07006073f, 
    0.03706500f, 0.03205731f, -0.02014484f, 0.01950283f, 0.12332214f, -0.19952229f, -0.01809256f, 0.03863988f, 
    0.01156146f, -0.08666455f, 0.08194020f, 0.04482821f, -0.02760622f, 0.15159312f, -0.06032151f, 0.07899256f, 
    0.22782314f, 0.27817497f, 0.07921778f, 0.06157030f, -0.05373108f, -0.06984009f, 0.16612342f, -0.07307568f, 
    -0.08174793f, 0.06353161f, 0.05941154f, 0.07186484f, -0.24295530f, -0.05453483f, -0.10962640f, -0.27601808f, 
    -0.02260507f, 0.02133504f, -0.20755638f, -0.02762090f, -0.01584182f, -0.08853539f, 0.09372707f, -0.15637897f, 
    0.01816561f, -0.10322244f, 0.04159272f, 0.19505586f, 0.20395520f, 0.20753641f, 0.21291491f, 0.12347965f, 
    -0.07050209f, -0.03738212f, 0.04778322f, -0.01274433f, 0.38154477f, 0.00950754f, 0.01886945f, 0.14536577f, 
    -0.05263224f, 0.05966968f, 0.02046488f, 0.00108290f, -0.00608720f, 0.00714095f, -0.06991817f, -0.09264781f, 
    -0.08830041f, -0.17481424f, -0.08189340f, -0.03853745f, 0.10365774f, -0.02536236f, 0.03633371f, -0.00683602f, 
    0.02603850f, 0.11546091f, 0.09911063f, -0.00562044f, 0.20990764f, -0.07927357f, 0.03186937f, -0.00294459f, 
    -0.10103329f, 0.02424381f, -0.08288250f, 0.03430903f, 0.19419469f, 0.19137098f, 0.00365567f, 0.11085299f, 
    -0.07064556f, -0.20203982f, 0.02559906f, 0.01820737f, 0.08890519f, -0.02686440f, 0.03594760f, -0.10268603f, 
    -0.01022561f, -0.02410128f, 0.22902252f, 0.03970382f, 0.02705388f, 0.04061260f, -0.11271600f, -0.15900360f, 
    -0.08669883f, -0.00898876f, 0.03118448f, 0.06939898f, -0.02568130f, 0.02656112f, 0.09024973f, 0.11486683f, 
    -0.20195667f, -0.08659799f, 0.07617660f, 0.02885257f, -0.00854664f, -0.13803254f, -0.04809035f, -0.08454729f, 
    0.15975447f, -0.11978583f, 0.02340770f, 0.07875012f, -0.00262544f, -0.02656788f, -0.07100678f, -0.05061178f, 
    0.15623733f, 0.13688244f, 0.19606544f, 0.21381122f, -0.11179458f, 0.10570651f, -0.02970339f, -0.17405902f, 
    0.05438261f, -0.25969353f, 0.26453534f, 0.08389793f, 0.02357852f, 0.12255643f, 0.01653237f, -0.17159727f, 
    0.03556038f, 0.03264375f, 0.16801532f, -0.00657021f, -0.14451611f, -0.08085775f, 0.01809304f, -0.10078772f, 
    0.01638837f, 0.00401074f, 0.09984009f, 0.06910705f, 0.21554656f, 0.22542836f, 0.29786426f, 0.09697010f, 
    0.05184817f, -0.06671743f, -0.01045573f, 0.01347319f, -0.07540403f, -0.01828121f, 0.01738185f, -0.00235423f, 
    0.04523381f, -0.03239506f, -0.03613338f, -0.07770109f, -0.06071341f, -0.01463143f, -0.07688259f, 0.05459280f, 
    -0.01380309f, 0.00862887f, -0.06794555f, 0.01804148f, -0.05998984f, -0.01672596f, -0.03464008f, -0.01096092f, 
    -0.00919655f, -0.05149769f, -0.05283419f, 0.03104788f, 0.03178128f, 0.00245836f, -0.02856077f, -0.00885093f, 
    -0.07557374f, -0.04218904f, -0.02717170f, 0.01903971f, 0.06025988f, 0.04045695f, 0.02597109f, -0.00711339f, 
    0.03860812f, 0.03343121f, -0.05528034f, 0.04711333f, -0.02350054f, 0.04173089f, 0.00070551f, 0.06476638f, 
    0.05837717f, -0.07358781f, -0.01017855f, 0.00546417f, -0.01353179f, -0.01483657f, 0.03862917f, -0.04335295f, 
    -0.07244400f, -0.01917554f, 0.04057384f, -0.05410261f, -0.06713805f, -0.05942831f, 0.03621154f, 0.04203078f, 
    -0.03227778f, 0.06238548f, -0.01489689f, 0.00997124f, 0.04588109f, -0.05759095f, 0.04376682f, -0.04531650f, 
    -0.02286553f, -0.04687846f, 0.02688620f, 0.02950536f, -0.04887906f, 0.00724935f, -0.03851189f, -0.01727322f, 
    0.02042157f, 0.03472603f, -0.02324100f, -0.02153185f, -0.03708846f, 0.01229595f, -0.00748793f, -0.04477029f, 
    0.04781642f, -0.04586706f, -0.04231646f, 0.05850456f, 0.05834972f, -0.05668253f, 0.04128756f, -0.01606897f, 
    0.03754339f, -0.02799956f, 0.04362622f, 0.04576313f, 0.01262125f, 0.02260522f, 0.00943479f, 0.02368303f, 
    -0.05716161f, -0.05916988f, -0.06198621f, -0.02245723f, -0.05520536f, -0.07011526f, -0.00533068f, 0.03904947f, 
    0.01828039f, -0.03783675f, -0.03588474f, -0.06803261f, 0.00574864f, -0.02158351f, 0.01843186f, -0.04620684f, 
    0.02103055f, 0.01609596f, -0.03156814f, 0.03255346f, -0.00949531f, -0.05799486f, -0.05115085f, 0.01144716f, 
    -0.04703815f, -0.06107426f, -0.04736210f, 0.02617219f, -0.05669701f, -0.03242289f, -0.06845938f, 0.03612122f, 
    0.02227378f, -0.05651909f, 0.00352786f, 0.04026233f, -0.06239361f, -0.08006629f, 0.04797034f, -0.02001776f, 
    0.00041855f, -0.01053949f, -0.02001970f, -0.05833212f, 0.03096031f, 0.03148203f, 0.05485061f, -0.07311768f, 
    -0.04063307f, 0.05624247f, 0.06370149f, -0.05811062f, -0.04208985f, 0.03168543f, -0.00725710f, 0.04941108f, 
    -0.03588747f, -0.07082532f, -0.03941297f, -0.07525577f, 0.00765243f, -0.01426369f, -0.03390405f, -0.02115176f, 
    -0.07631771f, 0.00180955f, -0.02103263f, 0.00522229f, -0.01282559f, 0.03449511f, -0.03032382f, -0.00828637f, 
    -0.00110235f, -0.07093330f, -0.06264281f, 0.06019264f, 0.01484005f, -0.07094728f, -0.06594440f, -0.04863156f, 
    0.05085919f, 0.00513759f, -0.01275324f, -0.06681560f, 0.05635859f, 0.05111375f, 0.01560463f, -0.01065046f, 
    0.14148660f, -0.02841017f, -0.14300781f, -0.03956411f, -0.02495635f, 0.13971224f, 0.09054875f, 0.07229719f, 
    -0.13647914f, -0.04622467f, 0.08835340f, -0.13718109f, -0.08535668f, -0.24627420f, -0.15686847f, -0.32689616f, 
    -0.18279600f, 0.11724871f, 0.03989093f, -0.00355245f, 0.08362526f, 0.02162143f, 0.02180939f, 0.02921449f, 
    -0.07400017f, 0.12444985f, -0.01908152f, 0.00132710f, -0.05342139f, 0.13094388f, -0.04145577f, -0.00575636f, 
    0.03170446f, -0.06346187f, -0.01906928f, 0.06957850f, 0.08758014f, -0.41480953f, -0.08238126f, -0.05452340f, 
    0.20739903f, -0.09714525f, 0.07710177f, 0.10995208f, -0.09833033f, -0.04344967f, -0.01740815f, 0.17499058f, 
    0.10970741f, 0.02517660f, -0.12822364f, -0.07881516f, -0.00417707f, -0.05947970f, -0.00970480f, 0.02337196f, 
    -0.00889587f, 0.15750663f, 0.07673719f, 0.17906882f, 0.26859739f, -0.05089684f, -0.02708081f, -0.21807852f, 
    0.07699553f, -0.00680342f, -0.10062869f, -0.09920451f, 0.10300744f, 0.06891711f, 0.08072352f, -0.03657954f, 
    -0.01509361f, 0.22525227f, 0.03515995f, 0.20980313f, 0.13319896f, 0.09316299f, 0.06831279f, 0.05658281f, 
    0.01321180f, 0.01249890f, 0.09402088f, -0.02001688f, -0.08104334f, 0.29488906f, -0.31514820f, 0.07607669f, 
    0.04420510f, 0.12430381f, 0.02362202f, 0.05257854f, 0.10712867f, -0.06348478f, 0.04075929f, -0.07515936f, 
    0.02440753f, -0.44908935f, -0.16992863f, -0.18702735f, -0.06709287f, -0.10876524f, -0.17008775f, -0.01396543f, 
    0.07273185f, 0.18203902f, 0.02637784f, -0.00306867f, -0.07850086f, 0.01050621f, -0.06395558f, 0.11245848f, 
    -0.04228245f, -0.01021245f, 0.02443505f, -0.18014202f, -0.00055075f, 0.13111512f, 0.14152507f, 0.12987675f, 
    -0.20048380f, 0.11899739f, 0.04131563f, -0.19529794f, -0.00735370f, -0.02948353f, 0.05529834f, 0.00531937f, 
    0.08937041f, 0.03333719f, 0.15933645f, 0.03785337f, 0.73867500f, -0.37184107f, 0.02938874f, 0.15719268f, 
    0.27468368f, -0.02727632f, 0.07086371f, -0.15632774f, 0.07378662f, 0.12280934f, 0.07619531f, 0.13818190f, 
    -0.12608215f, 0.09589931f, 0.17427343f, 0.07259622f, 0.00821361f, 0.07342895f, -0.00926887f, -0.12076336f, 
    0.07367666f, -0.04247646f, 0.04006494f, -0.00059360f, 0.26056826f, -0.20263749f, 0.23548929f, 0.02926200f, 
    0.05872312f, 0.00303046f, 0.00887559f, 0.07765795f, 0.05745044f, 0.05817918f, -0.03431061f, -0.04194759f, 
    -0.36311868f, 0.11352903f, 0.18700603f, 0.12890366f, -0.15988494f, 0.34486988f, 0.10297983f, -0.05817591f, 
    0.08616949f, 0.03170954f, 0.05444764f, -0.02649648f, -0.24186876f, 0.17736427f, -0.16078253f, -0.06840301f, 
    -0.03144405f, 0.04995691f, -0.03783575f, -0.02821114f, 0.07976162f, 0.08823116f, 0.09792446f, 0.17808390f, 
    -0.03723323f, -0.00494073f, 0.02669727f, 0.04868064f, 0.10921095f, -0.10906450f, 0.00225253f, 0.06030639f, 
    0.09240772f, 0.08904041f, 0.02687558f, -0.02775315f, -0.06749171f, 0.37976664f, -0.13718556f, 0.08316685f, 
    0.11727437f, 0.11862355f, 0.05575628f, 0.07960039f, 0.05649865f, -0.07064314f, -0.05380447f, -0.18025486f, 
    0.41469494f, -0.01141637f, 0.00927444f, 0.14453651f, -0.03214122f, -0.11299235f, 0.32309222f, 0.02091020f, 
    0.11133607f, 0.01450996f, -0.16727227f, 0.06524666f, 0.16913146f, 0.15289512f, 0.15848590f, -0.06654984f, 
    -0.08823020f, 0.16763228f, 0.01704706f, -0.05262722f, 0.12993124f, 0.01787896f, 0.03491883f, 0.03812395f, 
    0.05486089f, -0.19968803f, 0.09815013f, 0.09404432f, 0.02346389f, -0.04528993f, 0.03633663f, 0.06646675f, 
    -0.13686694f, 0.01171078f, -0.05358730f, 0.09091683f, -0.24835242f, -0.18923035f, -0.14017355f, 0.04333889f, 
    -0.07880197f, -0.01508730f, 0.05198174f, 0.09284661f, 0.15492660f, 0.00484995f, 0.13914482f, -0.08460911f, 
    0.20375368f, 0.02601784f, 0.07738800f, -0.20988375f, -0.10875106f, -0.05986049f, -0.00058669f, -0.16522895f, 
    -0.04135077f, 0.11318338f, 0.01922809f, -0.04536471f, 0.41750926f, -0.34387356f, 0.24228333f, 0.12649596f, 
    0.02048309f, 0.07218112f, -0.14041691f, -0.12001216f, 0.01339795f, 0.12541066f, 0.06782447f, 0.16691160f, 
    -0.13087396f, 0.17737174f, 0.09202569f, -0.12845246f, 0.12460820f, 0.08559620f, 0.02703668f, -0.07810902f, 
    -0.08026527f, -0.07704088f, 0.06346399f, -0.12340121f, 0.02826105f, 0.00219791f, -0.07455347f, 0.10499682f, 
    0.11355629f, 0.12438942f, -0.17620808f, 0.20683345f, 0.16051005f, -0.00736858f, -0.01854308f, 0.00944857f, 
    0.08154023f, 0.13798106f, 0.02087759f, 0.00446639f, 0.06901615f, 0.05263450f, -0.08649230f, -0.02692834f, 
    0.05133753f, 0.03444524f, 0.06013296f, -0.01044087f, -0.36090723f, 0.59596252f, 0.03398573f, -0.12294898f, 
    -0.30291432f, -0.06500100f, 0.11857828f, 0.33957013f, -0.04053028f, 0.05561644f, -0.00315583f, -0.11444852f, 
    0.04506392f, 0.10901349f, -0.09462217f, 0.11346150f, -0.02367057f, 0.06004449f, -0.11077686f, -0.03132624f, 
    -0.09778723f, -0.07081424f, -0.00700544f, 0.04600170f, -0.19582428f, 0.04914753f, -0.04388940f, -0.21664117f, 
    0.14371705f, 0.07083963f, 0.06856090f, -0.02944035f, 0.00251183f, 0.02621472f, -0.01394100f, 0.12506403f, 
    0.31018385f, -0.11774164f, -0.36459383f, 0.14606708f, 0.13866831f, 0.02353430f, 0.10854961f, -0.06018039f, 
    -0.10064097f, -0.06358796f, 0.10075183f, 0.03696475f, -0.04649642f, 0.08277458f, -0.00174401f, 0.01330176f, 
    0.15451740f, 0.13304418f, -0.16115583f, -0.09585370f, -0.08663355f, 0.04613107f, -0.16735436f, -0.02837014f, 
    -0.17779979f, -0.23120794f, 0.30397367f, -0.15320487f, -0.19258757f, -0.03066503f, 0.03404977f, 0.17763634f, 
    0.00580931f, 0.06828433f, -0.02479958f, 0.18955931f, 0.10039257f, 0.07286977f, -0.00827461f, 0.09775715f, 
    0.11355030f, 0.13602443f, 0.08255838f, -0.25735492f, 0.06508655f, -0.15098256f, 0.14633366f, 0.10395484f, 
    0.29028547f, 0.03404572f, -0.29954076f, -0.07942051f, 0.18080883f, -0.00962536f, 0.24787298f, 0.00935627f, 
    -0.00211710f, 0.11517105f, 0.11345940f, 0.11624170f, 0.19574061f, -0.00067140f, 0.09528404f, -0.08797896f, 
    0.12098496f, 0.06792083f, 0.15208061f, -0.11820575f, -0.04655820f, 0.07288126f, 0.02568916f, -0.07971021f, 
    -0.24994975f, -0.39025444f, -0.15033831f, -0.34870714f, 0.10746285f, 0.11048533f, -0.12543963f, -0.16758640f, 
    0.04961929f, -0.27937254f, 0.09957146f, -0.11769516f, -0.00897436f, -0.31930751f, -0.37366039f, -0.15446153f, 
    0.03205522f, 0.01212771f, 0.15521175f, -0.03729615f, 0.06889772f, 0.09328084f, 0.04222042f, 0.03715521f, 
    0.13364911f, -0.11573235f, 0.03026452f, 0.08802987f, -0.13718438f, -0.10977988f, -0.04059530f, -0.10436612f, 
    0.00903559f, 0.23682714f, 0.03257830f, 0.07660536f, -0.40086183f, -0.35931972f, 0.00100913f, 0.08623952f, 
    -0.10305250f, -0.13466637f, -0.01893427f, -0.13595834f, 0.03037131f, 0.18309346f, 0.01295876f, 0.26052317f, 
    0.12533638f, 0.14126079f, 0.05031987f, -0.12375594f, 0.05671970f, 0.13008563f, 0.06282039f, 0.07596206f, 
    -0.06234407f, 0.07278852f, -0.02460134f, 0.06043513f, -0.36226508f, -0.17843446f, -0.09594387f, 0.16464812f, 
    0.06859714f, -0.12915117f, -0.04307643f, 0.06537901f, -0.00515311f, 0.01673241f, 0.08330039f, 0.01720729f, 
    0.28678027f, 0.19929914f, -0.06357219f, 0.03353942f, 0.11507624f, 0.16132344f, 0.08413152f, 0.07292038f, 
    -0.15382503f, -0.03963917f, -0.03799125f, -0.05209563f, -0.04542063f, 0.36865214f, 0.17719966f, -0.57985872f, 
    0.08888165f, -0.01586716f, -0.01168660f, 0.01036816f, 0.07015859f, -0.11437415f, -0.09933481f, -0.19512472f, 
    -0.07496068f, -0.10598153f, -0.26204276f, 0.12617947f, 0.14707065f, 0.10816585f, 0.12923044f, 0.04879270f, 
    -0.19658440f, 0.10174879f, 0.08102056f, -0.18332115f, 0.08303329f, 0.02925330f, 0.07223790f, -0.01833772f, 
    0.00593714f, -0.01297412f, -0.17278893f, 0.07423268f, 0.04497847f, 0.11023233f, -0.02063451f, 0.19192170f, 
    0.00806959f, -0.00079959f, -0.31471288f, 0.10201462f, -0.08779038f, 0.09596218f, 0.08308970f, 0.03438461f, 
    -0.13769080f, -0.11579137f, 0.00406896f, -0.03106066f, 0.11187138f, 0.11450098f, -0.09084101f, 0.18636566f, 
    0.02819688f, 0.03817102f, -0.08152585f, -0.04025535f, -0.04686699f, -0.00935278f, -0.03386897f, -0.28478202f, 
    -0.00324040f, 0.06120881f, -0.01592394f, 0.01880853f, -0.06502319f, 0.00391768f, 0.05460490f, -0.03202774f, 
    -0.01653956f, -0.01786974f, 0.02096311f, -0.04072586f, 0.02230048f, -0.07130440f, -0.00727637f, 0.04755478f, 
    0.06277946f, -0.07551691f, 0.01918621f, -0.03748144f, -0.04005806f, -0.03018942f, -0.07370517f, -0.00621541f, 
    -0.00409332f, 0.03757058f, -0.00366865f, -0.06375503f, -0.02319485f, -0.03326303f, -0.07389337f, -0.02644083f, 
    -0.06332073f, 0.01968491f, 0.00604890f, -0.01313740f, 0.03399143f, -0.04637649f, -0.02472478f, -0.07273360f, 
    -0.07427491f, 0.02192561f, 0.03358167f, -0.00007820f, -0.04816882f, -0.01936837f, -0.07681817f, -0.07344350f, 
    -0.02495246f, 0.00579896f, -0.03420090f, -0.01069992f, 0.05071206f, -0.04424627f, -0.06205473f, -0.02459668f, 
    0.01986237f, -0.01796846f, -0.05818417f, 0.06422605f, 0.04924102f, -0.00115209f, 0.01634633f, -0.05632165f, 
    0.00413486f, -0.06996104f, 0.01727876f, -0.04822342f, -0.00744810f, -0.00015941f, -0.05709985f, 0.06608234f, 
    0.02349480f, 0.01050083f, -0.03992832f, -0.03898276f, -0.02368835f, -0.05010551f, 0.06157823f, 0.05785757f, 
    0.03567493f, 0.03874032f, 0.04609318f, -0.05863380f, -0.02312100f, -0.02466976f, 0.03782341f, 0.06375659f, 
    -0.01783081f, -0.02912856f, 0.05225796f, -0.05064790f, 0.06558173f, 0.05386224f, 0.00778668f, 0.02419098f, 
    -0.06915600f, 0.01117349f, -0.07025696f, -0.07249099f, -0.02084641f, -0.00727225f, -0.05056415f, -0.06007235f, 
    0.00415586f, 0.02193081f, 0.05605317f, 0.05218684f, -0.02729625f, -0.06781701f, 0.05802941f, -0.00572977f, 
    0.05798856f, -0.03072508f, 0.04916096f, 0.02788357f, 0.01090898f, 0.03010872f, -0.02376566f, 0.00517363f, 
    0.07186238f, 0.04913978f, 0.02362590f, -0.06600974f, -0.04254611f, 0.00915868f, 0.03251936f, -0.05334329f, 
    -0.07195397f, -0.02032017f, -0.05786621f, 0.03549900f, -0.05318021f, -0.07427498f, -0.00858243f, -0.03080849f, 
    -0.03687441f, 0.03074705f, 0.01284222f, -0.05096740f, -0.04205178f, 0.01890038f, 0.04053630f, -0.07039979f, 
    -0.03631961f, -0.03502931f, 0.05000587f, 0.00477870f, -0.03474551f, 0.00115412f, -0.05643987f, -0.02992378f, 
    -0.03781542f, -0.00553143f, 0.00868872f, 0.03993271f, -0.07193770f, 0.00743169f, -0.06860299f, -0.01493975f, 
    0.02041177f, -0.04325929f, -0.03657106f, 0.00535796f, -0.06165555f, -0.02169679f, -0.03956035f, -0.04047410f, 
    -0.03513551f, -0.05626307f, -0.00296559f, -0.00306455f, -0.06605811f, 0.03438117f, 0.02036047f, 0.04816940f, 
    0.03305443f, 0.01476504f, 0.06258776f, 0.01886053f, -0.02787790f, 0.00161723f, -0.01025840f, 0.04033355f, 
    0.06221000f, 0.01807583f, -0.05364123f, 0.06265700f, -0.05370350f, 0.00403752f, -0.02627755f, -0.04546309f, 
    0.08979663f, 0.05120264f, 0.07882081f, 0.01564495f, 0.07212738f, 0.10320223f, 0.00910960f, 0.00038631f, 
    -0.09729379f, -0.11534364f, 0.16399540f, 0.04069087f, -0.01962225f, -0.15684764f, -0.48046866f, -0.21508445f, 
    -0.12416317f, 0.08588145f, 0.09186229f, 0.06277017f, 0.20603640f, 0.05783626f, 0.06306330f, -0.10681094f, 
    0.04882709f, -0.00899764f, -0.01172915f, -0.17621674f, -0.12818184f, 0.23663817f, 0.18886803f, 0.20721976f, 
    -0.02293738f, 0.10382639f, -0.01547153f, -0.10870168f, -0.14169765f, -0.58914763f, -0.08695547f, -0.34505576f, 
    0.01178564f, -0.04010235f, -0.04509655f, 0.05859023f, 0.03516491f, -0.13472185f, -0.15319206f, -0.05498884f, 
    0.05160663f, -0.00052841f, 0.05641101f, -0.00921616f, 0.10029458f, 0.01889665f, -0.03192611f, -0.08593754f, 
    -0.02410020f, 0.15603809f, 0.06370895f, -0.01086047f, 0.20908451f, -0.15031053f, -0.16627210f, -0.25397426f, 
    0.00410217f, 0.07943841f, -0.02608126f, -0.16992585f, 0.10346808f, 0.05304042f, 0.14050695f, -0.08409245f, 
    0.42957255f, 0.29880941f, -0.11442684f, 0.07243410f, 0.03379345f, 0.02884691f, 0.09676188f, 0.10935983f, 
    -0.03671334f, -0.08826578f, 0.03723113f, 0.04059614f, 0.23815402f, 0.06538574f, 0.07818632f, 0.11193170f, 
    0.11702798f, -0.08410559f, -0.01777963f, 0.04382214f, -0.07656802f, -0.09425744f, -0.03691422f, -0.03987641f, 
    -0.06383846f, -0.46099868f, -0.36025873f, -0.30868050f, -0.06637434f, -0.00303514f, -0.00536666f, 0.09027123f, 
    -0.06885830f, -0.02612779f, 0.07597254f, -0.14782707f, -0.13063093f, 0.06655131f, 0.09059217f, 0.15977241f, 
    0.05689741f, 0.07079471f, 0.11908802f, -0.14456797f, 0.14135282f, -0.09012540f, 0.09760457f, 0.02897888f, 
    -0.17544381f, -0.05742897f, 0.13254341f, -0.16355082f, -0.18002579f, -0.05039287f, -0.04862218f, 0.06790610f, 
    -0.01040104f, -0.01043623f, 0.04070961f, 0.00774886f, 0.33390546f, -0.03616769f, 0.07101890f, 0.19711910f, 
    0.05493596f, -0.12152139f, 0.04694651f, -0.11966171f, -0.00573409f, 0.21578051f, 0.05726332f, -0.04256454f, 
    0.12386118f, 0.21504566f, 0.14779316f, 0.18411028f, -0.04300467f, 0.06594433f, -0.02804612f, -0.00629948f, 
    0.09233340f, -0.04696858f, -0.06002426f, 0.05782293f, 0.19466175f, -0.13501413f, 0.23862219f, 0.18125696f, 
    0.05719516f, -0.01127364f, -0.02456950f, -0.00578922f, 0.10965560f, -0.07887421f, 0.11566234f, -0.18120351f, 
    -0.11161636f, 0.15909949f, 0.09569963f, 0.26915544f, -0.20343976f, 0.17932028f, 0.01692702f, 0.20413995f, 
    -0.09064894f, -0.00684428f, 0.12706776f, -0.01736037f, -0.15361324f, 0.11495609f, -0.03193616f, 0.19483681f, 
    0.18627481f, 0.07137639f, 0.14724466f, 0.06818340f, -0.02621362f, 0.08805094f, 0.07067316f, 0.11672961f, 
    0.04711263f, -0.21028793f, -0.13790448f, 0.02941340f, -0.01501479f, -0.07897478f, -0.02974689f, 0.00104530f, 
    -0.00829388f, -0.22586226f, -0.01775506f, -0.22379710f, -0.33215114f, -0.06549861f, 0.03990083f, -0.20962001f, 
    -0.06147924f, -0.02100113f, 0.00734976f, 0.02540028f, -0.01703761f, 0.01561484f, -0.05826360f, -0.04767942f, 
    0.41139269f, 0.01350663f, 0.17355432f, -0.07991686f, -0.01022081f, 0.15622206f, 0.02251543f, 0.10330887f, 
    0.05956070f, 0.08415902f, 0.15024608f, 0.08823373f, 0.22183268f, 0.02554573f, 0.02678322f, -0.00373792f, 
    0.13078259f, 0.03017103f, 0.11087845f, 0.10354274f, -0.19756015f, -0.20352317f, -0.09321816f, 0.09120011f, 
    -0.23689687f, 0.01675399f, -0.18837604f, -0.11197606f, 0.01997698f, -0.14655356f, 0.16279279f, -0.07762960f, 
    0.06302512f, 0.14945656f, 0.06233821f, 0.13061056f, -0.20553659f, -0.33500585f, -0.02667742f, -0.25821877f, 
    -0.05852611f, -0.00008640f, -0.14478931f, -0.20030855f, -0.00480511f, 0.02227424f, 0.11701391f, 0.10189734f, 
    0.18162462f, -0.05309137f, -0.04793888f, 0.04426865f, 0.02980710f, 0.14484186f, 0.11084899f, 0.08482289f, 
    -0.03856676f, 0.03132330f, -0.06949537f, 0.03939577f, 0.14309415f, -0.17802216f, -0.19385485f, 0.13525939f, 
    -0.10031485f, 0.06015931f, -0.00774946f, 0.16628282f, 0.06007426f, -0.10573488f, -0.12770142f, -0.04922178f, 
    -0.22052506f, -0.17838681f, -0.05940206f, -0.13595881f, 0.03267261f, 0.16620228f, -0.00929619f, -0.02025384f, 
    0.19611306f, -0.06036035f, 0.07337470f, 0.00606745f, -0.30218294f, -0.18142612f, -0.24087778f, -0.13635549f, 
    0.05823073f, -0.02474416f, 0.08243689f, 0.14089014f, 0.13877794f, 0.14470074f, -0.14460211f, 0.16281623f, 
    0.11387914f, 0.36659324f, 0.20832872f, -0.10143244f, 0.03152808f, 0.02450955f, 0.10801253f, 0.00715165f, 
    -0.01861370f, -0.20852084f, 0.07081162f, -0.06161777f, 0.17566857f, -0.07962270f, 0.16685203f, 0.11086645f, 
    -0.16120780f, 0.11004966f, 0.06506103f, 0.08911309f, 0.09346338f, 0.02783516f, 0.04883472f, -0.03674908f, 
    -0.50221992f, -0.32347381f, -0.15083466f, -0.01551250f, -0.16286673f, 0.07284168f, -0.24796304f, -0.10099936f, 
    0.28807148f, 0.01916204f, 0.12374592f, 0.14328988f, 0.19306245f, 0.07263195f, 0.07248131f, 0.03805411f, 
    0.03733549f, 0.04479571f, 0.03706514f, 0.05220336f, -0.09687354f, -0.29612583f, -0.04241484f, -0.38239273f, 
    -0.05993463f, -0.22272725f, 0.06753503f, 0.13127165f, -0.10081112f, 0.06685294f, 0.04030528f, 0.15474536f, 
    0.10345097f, -0.01368195f, 0.23982824f, -0.12840797f, -0.23891093f, 0.10807245f, -0.02244919f, 0.01878047f, 
    0.12471302f, 0.09234654f, 0.11240070f, 0.15268856f, 0.01483923f, 0.20609680f, 0.06490017f, 0.27300620f, 
    -0.14597437f, -0.01281601f, -0.00128982f, 0.06129187f, 0.11998165f, -0.15628552f, -0.01266288f, -0.12530276f, 
    -0.11349863f, 0.00775438f, -0.07325538f, -0.16630383f, -0.26642531f, -0.17007001f, 0.00218822f, -0.11935131f, 
    -0.01314816f, 0.19097687f, 0.04613158f, -0.01391308f, -0.03094417f, 0.09948782f, -0.00543730f, -0.07653674f, 
    0.45126048f, -0.08592972f, -0.27878436f, -0.11180778f, -0.13361411f, 0.00368539f, 0.29846519f, 0.05913801f, 
    0.12278192f, 0.00464259f, 0.08230143f, 0.02824576f, 0.10176749f, 0.16971052f, -0.03510312f, -0.12222023f, 
    0.04135028f, 0.00024556f, 0.13567878f, -0.00869396f, -0.05921752f, 0.03057571f, 0.03307298f, -0.02113677f, 
    -0.05213096f, 0.15893044f, -0.01037972f, -0.06281286f, 0.11139347f, 0.00247009f, -0.02095771f, 0.00362396f, 
    0.07930449f, -0.02718937f, 0.09295389f, -0.03920940f, -0.18908674f, -0.16492517f, -0.01235286f, 0.03298654f, 
    -0.05263177f, -0.06554480f, -0.07686257f, -0.11629497f, -0.03045193f, 0.05753966f, 0.12748398f, 0.09150380f, 
    0.31985399f, -0.11440501f, -0.21737391f, -0.29399711f, -0.03341071f, -0.02504137f, -0.01557330f, -0.19286886f, 
    0.09974713f, 0.12589900f, -0.00535774f, 0.06148992f, 0.24836726f, 0.01961403f, 0.27298364f, 0.19389609f, 
    0.09459928f, 0.04240587f, 0.00984718f, -0.08748876f, 0.01100679f, 0.08964156f, 0.04475057f, 0.21853934f, 
    -0.21061763f, 0.02295185f, -0.09954453f, -0.07535891f, 0.06594298f, 0.16349392f, 0.17761365f, 0.08132083f, 
    0.00463631f, 0.06421518f, 0.12476590f, 0.00769837f, -0.18235061f, 0.08572377f, 0.32512808f, 0.01623983f, 
    -0.11908925f, -0.10841708f, -0.06374824f, 0.04995954f, 0.06480782f, 0.10921719f, -0.08626832f, -0.09866315f, 
    0.05708547f, 0.29368693f, -0.07458819f, -0.29700229f, 0.04123434f, 0.18511333f, 0.04159686f, -0.05594312f, 
    0.00722470f, -0.00868856f, -0.02767472f, 0.07438706f, 0.11944619f, 0.14772293f, -0.13611721f, -0.13827214f, 
    0.00963047f, -0.08507980f, -0.12086199f, 0.11191473f, 0.16999711f, 0.06460641f, -0.04408677f, 0.05479869f, 
    -0.17453127f, 0.08246117f, 0.09205993f, 0.11272617f, -0.18097636f, -0.03262278f, -0.16987140f, -0.07973790f, 
    -0.01053112f, 0.03872744f, -0.07448386f, -0.04322311f, -0.04238614f, -0.02112600f, 0.02216643f, -0.28315791f, 
    0.10277712f, -0.14076839f, 0.14538673f, 0.09157140f, -0.05728724f, -0.12762152f, 0.03721803f, -0.09889384f, 
    0.27348337f, -0.01118220f, -0.16218787f, 0.00740504f, -0.04487250f, 0.11610195f, 0.04603684f, 0.17260882f, 
    -0.13934204f, 0.04102518f, 0.10446827f, 0.08650708f, -0.19731049f, -0.16149455f, 0.02975291f, -0.05986615f, 
    0.05693941f, 0.10495360f, -0.15972731f, 0.06320076f, 0.08364634f, 0.07151990f, 0.05765843f, 0.11309992f, 
    -0.03469636f, 0.03844394f, -0.04399503f, 0.06159822f, 0.00686254f, -0.05698801f, -0.02031167f, 0.04655563f, 
    0.00104433f, 0.06589517f, -0.01239753f, -0.05483990f, -0.04370315f, 0.05191382f, -0.03699340f, 0.00932666f, 
    -0.03508678f, 0.01038117f, 0.04682895f, -0.00705282f, 0.01834775f, 0.04111490f, -0.02031183f, -0.02280409f, 
    -0.08089432f, -0.00613894f, 0.00238023f, 0.02790929f, -0.02856975f, -0.06659915f, 0.05486598f, -0.07804116f, 
    0.04615285f, -0.02823782f, -0.06917852f, -0.05868095f, -0.07636747f, 0.00598262f, 0.00595962f, 0.01061746f, 
    0.02843974f, -0.07152711f, 0.04936837f, 0.00419089f, -0.03678594f, -0.00075372f, -0.03492934f, 0.01896526f, 
    0.03346381f, 0.02251773f, -0.06697612f, 0.04277655f, -0.05092555f, 0.04005668f, 0.04694017f, 0.03482756f, 
    -0.00821134f, 0.00702647f, -0.02808197f, 0.06182636f, -0.02599957f, -0.05093414f, -0.05632359f, -0.06582590f, 
    0.06143998f, -0.02276298f, -0.00025032f, -0.08216322f, 0.05582730f, 0.03739160f, -0.02996557f, 0.05080028f, 
    0.04988747f, -0.02258912f, -0.05045737f, 0.02506160f, -0.04309601f, -0.04469998f, -0.06938355f, 0.00239133f, 
    -0.03625758f, 0.01754089f, -0.01094494f, 0.04243305f, 0.01016245f, 0.00685378f, 0.06123962f, 0.00396206f, 
    0.05204341f, -0.03416358f, -0.04486677f, -0.00716379f, -0.04631176f, -0.05604582f, -0.05276208f, -0.00096795f, 
    0.02377006f, -0.07644932f, -0.01634125f, -0.00377723f, -0.04163337f, -0.02641995f, -0.01472676f, 0.05494243f, 
    0.01953038f, 0.02062394f, -0.02647004f, 0.06171279f, 0.05409512f, -0.00392791f, 0.00345507f, -0.01663699f, 
    -0.07654420f, -0.02903802f, 0.00188086f, 0.04955036f, -0.01779180f, -0.05199214f, 0.00232550f, -0.01999144f, 
    -0.00775805f, 0.01090077f, -0.02897999f, 0.04702469f, -0.04922432f, -0.07718926f, -0.04052474f, -0.06566244f, 
    0.04719907f, -0.08160407f, 0.00275246f, -0.05338941f, 0.05377728f, -0.03199050f, 0.04388263f, -0.04955767f, 
    0.06132022f, -0.00706918f, 0.03807021f, -0.00956727f, -0.01126903f, 0.02727472f, -0.06089688f, -0.05615077f, 
    -0.05208221f, 0.01273407f, 0.00560030f, -0.06838971f, -0.04648576f, 0.04430588f, 0.06323652f, -0.02979772f, 
    0.02529060f, -0.01991200f, -0.02544098f, -0.01583896f, -0.08432322f, 0.04032134f, -0.00232407f, 0.01695034f, 
    0.03602152f, -0.03321103f, 0.01510432f, -0.00736143f, -0.05168833f, 0.00443579f, -0.02017206f, -0.01302513f, 
    -0.01865430f, 0.04590983f, 0.00089638f, -0.04143218f, -0.06800514f, -0.04046720f, 0.05527290f, -0.05670569f, 
    0.00408311f, -0.03836076f, -0.04615014f, 0.02886423f, 0.03820181f, 0.01506663f, 0.05274255f, -0.02863111f, 
    -0.05964236f, -0.08381715f, -0.00164684f, 0.00180151f, -0.03065832f, -0.02558316f, -0.04028935f, -0.00311064f, 
    0.10563264f, -0.11708866f, -0.15212719f, 0.06600498f, 0.08333775f, 0.02077484f, 0.08949389f, 0.08457316f, 
    0.19538270f, 0.35415041f, -0.16808906f, -0.01669542f, -0.29898089f, -0.06044191f, 0.47858319f, -0.19077247f, 
    0.01244823f, -0.01693300f, -0.01830204f, 0.05038164f, 0.05747430f, 0.15429914f, 0.05145360f, -0.03085876f, 
    0.35556158f, -0.24151540f, 0.01164704f, 0.26523376f, 0.13335370f, -0.17995121f, 0.29610559f, -0.14601192f, 
    0.17869984f, -0.11392128f, 0.09072413f, 0.08374041f, -0.16657314f, 0.07235584f, -0.12457915f, 0.34239724f, 
    -0.14686404f, 0.13586639f, 0.14658168f, -0.00024491f, 0.00367370f, 0.15153390f, -0.15353498f, 0.15396704f, 
    0.20293146f, 0.09288902f, -0.04492677f, 0.18043593f, 0.07534765f, -0.01978015f, 0.34648713f, -0.07372864f, 
    -0.01656480f, -0.16063066f, 0.09058884f, 0.09264107f, -0.08379120f, 0.15538520f, 0.21430714f, 0.05694724f, 
    -0.13950166f, 0.05022973f, 0.05704619f, 0.22327809f, 0.13403974f, 0.17531018f, 0.30293003f, -0.07583404f, 
    -0.32242453f, -0.49307129f, 0.02554016f, -0.06928217f, 0.13008134f, 0.32538596f, 0.06902446f, -0.27042854f, 
    0.03636335f, 0.03248141f, -0.09978045f, -0.01288515f, 0.28527600f, 0.02960633f, -0.24087729f, -0.03373308f, 
    -0.09205739f, 0.06162151f, 0.17430119f, 0.17421380f, -0.11289716f, 0.15907978f, -0.05798348f, -0.11616171f, 
    -0.53804648f, -0.25920719f, 0.18522541f, 0.25791568f, 0.00047322f, -0.05790797f, 0.06468221f, 0.10630000f, 
    0.07618869f, 0.09396035f, -0.06976987f, -0.04085210f, 0.21954197f, 0.02793696f, -0.19117257f, 0.24224059f, 
    -0.11086598f, -0.07329657f, -0.07159995f, 0.12178928f, 0.09706385f, 0.13866527f, 0.07158176f, 0.10400486f, 
    -0.39389467f, -0.13270734f, -0.16654091f, -0.23568572f, -0.03689263f, -0.11818979f, 0.04997724f, -0.28747743f, 
    -0.16194330f, 0.03805187f, 0.11350643f, -0.02768992f, 0.09042925f, -0.25180846f, 0.06774411f, 0.11804312f, 
    -0.19277242f, -0.06051325f, -0.05535478f, 0.22423904f, -0.02036436f, -0.10802363f, -0.01874761f, 0.12153427f, 
    -0.14046976f, -0.09910752f, -0.01875488f, -0.13794735f, 0.13275388f, -0.19014111f, -0.02300782f, -0.02850652f, 
    -0.10053322f, -0.06977633f, 0.06330529f, 0.01225402f, -0.24385148f, -0.02285266f, -0.11524127f, -0.38808641f, 
    0.09604349f, 0.21016002f, 0.07131650f, 0.02293255f, 0.10944869f, -0.12851781f, 0.00622331f, -0.07032030f, 
    -0.04096344f, -0.09813788f, -0.06234175f, 0.09091669f, 0.17453423f, 0.18568240f, 0.18717404f, -0.12407155f, 
    0.01465815f, -0.14626548f, 0.06379914f, 0.20923343f, -0.13696109f, -0.24118084f, -0.20918316f, -0.13299562f, 
    -0.02131996f, -0.06977341f, 0.00564874f, 0.00256561f, 0.03483206f, -0.02844120f, 0.06490598f, 0.00910984f, 
    -0.18782727f, 0.00500768f, 0.07436670f, -0.02233985f, 0.03211795f, -0.07245665f, -0.06108731f, -0.15935893f, 
    0.00906972f, 0.00128592f, 0.02340021f, 0.08916793f, 0.27421391f, 0.32872978f, 0.15422159f, 0.05739998f, 
    0.13464314f, -0.12993777f, 0.04388242f, 0.11741757f, -0.06615386f, -0.00570420f, -0.02890014f, 0.10194961f, 
    0.17037027f, -0.24563660f, 0.24734125f, 0.12244543f, 0.15218423f, 0.03189778f, 0.07283349f, -0.02972974f, 
    0.02853863f, 0.05808004f, -0.15424821f, 0.05408699f, -0.06327656f, 0.35083479f, 0.04887557f, 0.01315926f, 
    -0.10826804f, 0.25273994f, -0.01667655f, -0.00775397f, 0.18726057f, 0.02895215f, 0.05850257f, -0.05782016f, 
    -0.06367838f, -0.18625413f, 0.12851211f, -0.00615570f, -0.03435178f, 0.11824863f, -0.01173687f, -0.13939850f, 
    -0.03206666f, -0.07159752f, -0.04540175f, -0.13509279f, -0.27852747f, 0.08373225f, -0.10791840f, 0.12761702f, 
    -0.02643815f, -0.08791193f, 0.09038008f, 0.14942853f, 0.13302292f, 0.14219162f, -0.03028058f, 0.06455701f, 
    0.16118845f, -0.12270952f, 0.05675264f, -0.09018077f, 0.01349282f, -0.10566697f, 0.02349545f, 0.12489322f, 
    0.09237905f, 0.01565694f, -0.02756282f, 0.02002382f, 0.13235989f, -0.10029457f, 0.04732984f, 0.01577963f, 
    -0.09932981f, 0.06002416f, -0.12413654f, 0.02164461f, -0.01894468f, -0.07501093f, 0.13692072f, 0.10377674f, 
    0.17020398f, 0.28031111f, 0.11092256f, 0.16041967f, -0.00188477f, 0.05607519f, 0.26749146f, 0.08959953f, 
    -0.10503016f, -0.12444731f, -0.02690692f, 0.02753542f, 0.10139276f, 0.12123445f, 0.04290270f, 0.00267679f, 
    -0.06133176f, 0.03157302f, -0.13386300f, 0.16179907f, 0.13445264f, -0.13345033f, -0.06924277f, 0.01109060f, 
    0.08788124f, -0.00394273f, -0.07676957f, 0.13159209f, 0.02597910f, 0.09772974f, 0.02138576f, 0.00336107f, 
    0.01105900f, -0.02005002f, -0.09248126f, 0.02829333f, -0.56001985f, 0.16262394f, 0.08445959f, -0.11990906f, 
    -0.00454339f, 0.00658143f, -0.11532326f, -0.08680772f, -0.16232565f, -0.13819605f, -0.03762739f, 0.10752442f, 
    0.15959023f, -0.12669490f, -0.07934505f, 0.00032974f, -0.07805036f, -0.06413434f, -0.01231940f, -0.07663799f, 
    -0.06053373f, -0.15444252f, 0.00096321f, -0.06414132f, -0.18463178f, 0.28363016f, -0.21466489f, -0.10778917f, 
    0.05417908f, 0.04976045f, 0.02503419f, -0.03127115f, 0.03935530f, 0.06781366f, -0.07441997f, 0.01223659f, 
    0.13115914f, 0.17205065f, -0.07334749f, -0.04317980f, 0.15029272f, 0.02444492f, 0.16185383f, 0.04595674f, 
    -0.01182258f, -0.02677511f, -0.07869495f, -0.19673732f, 0.22315720f, -0.07452041f, 0.12798925f, -0.05418025f, 
    0.01734675f, 0.12890726f, 0.17826074f, 0.17184928f, 0.03785165f, -0.02446290f, -0.15847827f, 0.02083921f, 
    -0.21774705f, -0.03013772f, -0.15897986f, -0.00447926f, -0.06011260f, -0.04993632f, -0.04632385f, 0.13415478f, 
    0.09902131f, -0.00781629f, -0.05478580f, -0.05372649f, -0.14522758f, -0.32262957f, 0.07652515f, -0.03891550f, 
    0.09315540f, 0.22606163f, 0.08340066f, 0.02600810f, 0.10371546f, -0.02887012f, -0.12562749f, -0.16926366f, 
    0.07000867f, 0.52144402f, -0.39433798f, -0.06277963f, -0.00370511f, -0.00547030f, 0.19765554f, -0.06527431f, 
    0.07184815f, -0.09383864f, -0.04735567f, 0.02812791f, 0.22500190f, -0.00911389f, -0.07964033f, 0.20454861f, 
    0.15568788f, 0.13928993f, -0.09309158f, 0.01194305f, -0.04529483f, 0.12499030f, -0.00712280f, -0.02812779f, 
    -0.19066317f, -0.03856782f, -0.02008841f, 0.07380792f, 0.06927592f, -0.00807756f, -0.00460540f, -0.05103453f, 
    0.07384385f, 0.02897402f, 0.13480049f, 0.18700480f, 0.11060400f, -0.12916055f, -0.10569548f, -0.05428335f, 
    0.09316698f, 0.03259689f, 0.10038998f, 0.02159470f, -0.01711624f, 0.10219070f, 0.04779567f, -0.08788968f, 
    -0.28934252f, -0.07446109f, 0.04924757f, 0.05131965f, -0.07116492f, 0.15710884f, -0.00950773f, -0.18466985f, 
    0.03364666f, 0.01342815f, 0.01255540f, 0.10976579f, -0.03154524f, -0.22921753f, -0.04220942f, 0.02240654f, 
    -0.06937210f, 0.01871423f, -0.12687425f, -0.14363267f, 0.07958196f, 0.10252690f, -0.01562056f, 0.11340755f, 
    -0.10761253f, -0.07984971f, 0.08388873f, -0.09207150f, 0.05677617f, 0.08935074f, -0.16239680f, -0.06793332f, 
    0.02446902f, 0.00708864f, -0.11814447f, -0.04870495f, 0.23790756f, -0.07352025f, -0.00403087f, 0.05910295f, 
    -0.13818885f, -0.03156210f, -0.11441413f, -0.03898121f, 0.00993679f, 0.03192783f, 0.13916500f, 0.07401233f, 
    0.11599094f, 0.19929750f, -0.07667332f, -0.02621879f, 0.19215056f, 0.04507047f, -0.05246017f, -0.08785114f, 
    0.06666365f, 0.03627160f, -0.12955686f, 0.15443477f, 0.30914125f, -0.02688739f, -0.07391757f, -0.24302328f, 
    0.08443640f, -0.02943812f, 0.19031602f, 0.20680034f, 0.16789380f, 0.19452038f, -0.02228147f, -0.13324849f, 
    -0.29877001f, 0.10164376f, 0.16561881f, 0.05119994f, 0.07182415f, -0.05440721f, -0.03194796f, 0.03475458f, 
    -0.03381937f, 0.05216855f, 0.11907934f, 0.03643004f, -0.08050923f, -0.12570795f, 0.13891660f, -0.09048501f, 
    0.04431948f, -0.03859117f, 0.05438570f, -0.01215942f, 0.13807377f, 0.01726029f, -0.08916833f, 0.05684594f, 
    0.02835456f, -0.15763836f, -0.15695380f, 0.24630739f, -0.01014970f, 0.04131193f, -0.07856981f, -0.05342069f, 
    -0.06563459f, -0.13126704f, 0.04628212f, 0.18052900f, -0.03423569f, 0.13207269f, -0.05121505f, -0.03655274f, 
    0.15392973f, 0.05430222f, -0.25285274f, -0.16191995f, 0.02746786f, 0.05259745f, 0.13693388f, -0.04401241f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02789954f, 0.22147410f, 0.07247404f, 0.11697280f, 0.21663857f, 0.04836788f, 0.04921078f, 0.02879450f, 
    -0.15256514f, 0.10619985f, 0.04861975f, 0.04486698f, 0.05522667f, 0.21564092f, -0.02846139f, -0.10749044f, 
    -0.00250295f, -0.07941113f, 0.08024854f, -0.12441897f, 0.12226471f, -0.06100792f, -0.01838611f, -0.12078925f, 
    0.06542579f, -0.02840956f, 0.21122958f, -0.01113085f, -0.08858619f, 0.02098735f, 0.03575793f, 0.02172226f, 
    0.21373424f, -0.04303838f, 0.21049505f, -0.27099478f, -0.02808471f, 0.08063356f, 0.09882550f, 0.33037600f, 
    0.28230041f, -0.11922226f, 0.02760868f, 0.20517273f, 0.13808639f, 0.11802711f, 0.02207971f, 0.05511284f, 
    0.14948449f, 0.12423739f, 0.05744144f, 0.15658328f, -0.02004135f, -0.00291364f, 0.10789140f, -0.26086572f, 
    -0.02240117f, 0.00444092f, 0.02132135f, 0.20316868f, -0.01283405f, 0.20646398f, 0.04781317f, -0.01908524f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.09430125f, 0.00575786f, -0.07911628f, -0.01178922f, 0.16709852f, -0.00165294f, -0.01872322f, -0.37974003f, 
    0.07792516f, 0.23517402f, 0.08132921f, 0.24073336f, 0.27486804f, -0.14943349f, -0.01259023f, 0.13557799f, 
    0.16009161f, 0.10969052f, -0.08493368f, 0.14407326f, 0.33916429f, 0.21809003f, -0.10300647f, -0.05181538f, 
    0.09789995f, -0.36188072f, 0.13620871f, 0.28186226f, 0.23908311f, 0.11729838f, 0.09283151f, 0.11457515f, 
    0.05106129f, -0.07489476f, -0.27758151f, 0.05032766f, -0.32494372f, 0.34117088f, 0.21562988f, -0.11039662f, 
    0.12112159f, -0.08545537f, 0.18745196f, -0.06675048f, -0.07901830f, 0.21847825f, -0.07416511f, -0.00436031f, 
    -0.35130772f, 0.17098676f, -0.03601518f, -0.00433009f, -0.05018721f, 0.08054493f, -0.02979654f, -0.15132882f, 
    -0.11140703f, -0.25881898f, 0.14421010f, -0.18570091f, -0.11006721f, 0.05972353f, 0.20176633f, 0.09311985f, 
    -0.11210605f, 0.04599040f, -0.15728179f, -0.05563563f, 0.19086248f, 0.16176789f, -0.18211864f, 0.22987616f, 
    -0.57342982f, 0.08392508f, -0.09913566f, 0.05446965f, -0.16297784f, 0.12782495f, -0.11539146f, -0.03121123f, 
    0.21450427f, 0.09017505f, 0.10892559f, 0.01484324f, -0.15901828f, -0.35105976f, 0.01655521f, 0.05574984f, 
    -0.09175223f, 0.00626401f, -0.01692930f, -0.00361284f, -0.16957325f, 0.08384314f, 0.09916827f, 0.07644776f, 
    0.23055871f, -0.02477938f, -0.12566879f, -0.21110989f, 0.06108534f, -0.01541667f, -0.18896878f, 0.11695519f, 
    -0.00136075f, 0.04215883f, 0.18165141f, 0.09903473f, 0.02487470f, -0.15155569f, -0.02915229f, 0.07315893f, 
    -0.03694926f, 0.03652944f, -0.02335295f, 0.02990719f, -0.10696198f, 0.09095865f, 0.24635018f, -0.15282513f, 
    0.03823158f, 0.12383780f, -0.15724753f, 0.01165808f, 0.03256973f, 0.35905236f, 0.16874297f, 0.12666678f, 
    0.12919627f, 0.20695542f, -0.21966954f, 0.27163208f, 0.02991233f, -0.02603026f, 0.07226805f, 0.24476524f, 
    -0.19192737f, -0.00175244f, 0.41994867f, -0.03824364f, 0.17267835f, -0.26906100f, -0.03145707f, -0.36044174f, 
    -0.11505945f, -0.00971790f, -0.34284341f, -0.19818261f, -0.02471889f, 0.11682586f, 0.08279933f, -0.02608883f, 
    0.11087821f, 0.32693207f, 0.26977065f, -0.15019950f, -0.04938909f, 0.11385182f, -0.13205989f, 0.16019540f, 
    0.20889843f, 0.11072036f, 0.19312254f, -0.00319061f, -0.05491526f, 0.21894233f, 0.04198857f, -0.00528246f, 
    0.26437491f, -0.28285503f, -0.07773744f, 0.04804601f, 0.26528066f, -0.00110073f, -0.07035708f, -0.07201906f, 
    0.22674823f, 0.24092595f, 0.22553143f, 0.26251078f, 0.10284589f, -0.01273613f, 0.25747046f, -0.00582099f, 
    0.07195021f, -0.07642230f, -0.16199875f, 0.19932868f, 0.06401461f, -0.09494958f, 0.02087505f, -0.02879990f, 
    0.10415956f, -0.23863058f, 0.04629288f, 0.20004906f, -0.01078717f, -0.05784236f, 0.05867004f, -0.06914914f, 
    -0.17409226f, 0.10208033f, 0.03613370f, 0.17519544f, -0.16021316f, 0.22222888f, 0.14155333f, 0.04408447f, 
    0.38152120f, 0.10867241f, -0.09581256f, 0.20811549f, -0.17814305f, 0.01207817f, -0.00390598f, 0.32305074f, 
    -0.07946444f, -0.20232180f, -0.02517189f, 0.04838389f, 0.08371686f, 0.11824880f, -0.12778333f, -0.04219822f, 
    0.05007145f, 0.11359698f, -0.23963410f, 0.04828649f, 0.15904398f, -0.06589094f, 0.06538785f, -0.11331403f, 
    0.18896578f, 0.07122733f, 0.11273719f, 0.13387077f, -0.16829214f, 0.07076229f, -0.06356164f, 0.10980003f, 
    -0.20251764f, 0.13738357f, -0.10536044f, 0.12789816f, -0.09910692f, 0.13701481f, -0.01532492f, -0.14164732f, 
    0.11555318f, 0.09241594f, 0.10424241f, -0.09212044f, 0.08970405f, 0.15221633f, -0.11323018f, 0.13237877f, 
    0.03221248f, 0.25457191f, 0.04674159f, 0.12429638f, 0.07366227f, 0.00389259f, -0.00739477f, -0.64716417f, 
    -0.42667413f, 0.05402606f, 0.43350300f, -0.03863840f, -0.21189965f, -0.44465682f, 0.37488991f, -0.36732841f, 
    0.27110696f, 0.11349108f, -0.10980067f, 0.06776172f, -0.09491141f, -0.02184317f, 0.11005524f, 0.02907992f, 
    0.09314015f, -0.25271589f, 0.08575668f, -0.01630766f, 0.05696748f, 0.06817025f, -0.00301745f, 0.03261082f, 
    0.07401332f, 0.09965303f, 0.12405568f, -0.06466795f, 0.24856026f, -0.06861092f, 0.22919257f, -0.13373855f, 
    0.03042753f, -0.52330649f, -0.02889283f, 0.21311626f, 0.11172624f, 0.33576271f, 0.00720536f, 0.09868898f, 
    0.29869732f, 0.31231433f, -0.14780727f, -0.31445634f, -0.04776116f, -0.38578254f, -0.01199480f, -0.12002310f, 
    -0.03837322f, -0.45652050f, -0.17052944f, 0.10923795f, -0.06602617f, -0.20516138f, 0.11393087f, 0.09194180f, 
    0.06315318f, 0.08294561f, 0.37646955f, 0.01427646f, 0.15415522f, 0.26044792f, -0.00496976f, -0.05539028f, 
    -0.13521963f, 0.03071994f, 0.09672792f, -0.04719853f, -0.18162981f, 0.08926278f, 0.13983043f, -0.13671720f, 
    -0.31486261f, 0.00037810f, 0.33306357f, -0.15891334f, 0.10204834f, 0.16062233f, 0.09900728f, -0.23201674f, 
    0.07866184f, -0.26453021f, 0.01618113f, 0.12954977f, -0.02016338f, 0.04104193f, -0.08376162f, -0.01945931f, 
    0.10584580f, -0.10280248f, 0.02624087f, 0.14789753f, -0.17375404f, -0.20307131f, 0.13759167f, -0.08028782f, 
    0.07546891f, -0.07067067f, 0.19037871f, -0.15124419f, 0.11476407f, 0.40012997f, 0.03240944f, 0.02435175f, 
    0.05271430f, 0.05076817f, 0.21022996f, 0.01222857f, 0.08114509f, -0.02145000f, 0.17589882f, 0.09990785f, 
    -0.02165476f, 0.17398392f, 0.19682230f, 0.14167719f, -0.02966780f, -0.26485288f, -0.04115298f, -0.21321993f, 
    -0.11769517f, 0.03324798f, 0.09563327f, 0.18195571f, -0.15354767f, 0.05763227f, -0.42155626f, 0.30066392f, 
    -0.23744538f, 0.01136208f, -0.11066759f, 0.13080731f, -0.20006827f, 0.31597880f, 0.04403318f, 0.01326768f, 
    0.07573570f, -0.07535088f, 0.12211675f, -0.15182920f, -0.19858950f, -0.12581287f, 0.04524754f, 0.15597485f, 
    0.06199163f, 0.17486756f, -0.08780845f, -0.10487140f, -0.47905695f, 0.04798701f, 0.09266711f, 0.11332942f, 
    -0.12366694f, 0.00470237f, 0.24465317f, -0.14083117f, -0.18012515f, -0.12034617f, -0.02501139f, 0.11183821f, 
    -0.00791707f, 0.05874345f, 0.30266735f, 0.21832024f, 0.08695808f, -0.18892919f, 0.04569453f, 0.06389032f, 
    -0.12719154f, -0.21509872f, 0.18585752f, 0.04117403f, -0.13107663f, 0.16586880f, 0.03948431f, 0.20293175f, 
    0.08982990f, 0.28662610f, -0.20990521f, 0.07610232f, -0.04452538f, -0.05551864f, 0.05483563f, -0.00853397f, 
    -0.07972603f, -0.02429719f, -0.02472070f, -0.08182788f, 0.38577896f, -0.05252768f, 0.20522492f, -0.07816774f, 
    0.13715294f, 0.15493642f, -0.05022849f, -0.11147815f, 0.12868260f, -0.07222746f, 0.23302151f, 0.08059002f, 
    -0.21557929f, -0.07759284f, 0.28068468f, 0.28724656f, 0.12877598f, 0.04349320f, 0.09910796f, -0.02050611f, 
    0.01843931f, -0.02016600f, -0.14094882f, 0.08477234f, 0.21320304f, 0.09407128f, 0.09531830f, -0.05144071f, 
    0.23196375f, -0.04669396f, 0.06401480f, 0.33175343f, 0.15220203f, -0.03984596f, 0.21733376f, 0.05119118f, 
    0.05835846f, -0.06660981f, 0.00982628f, -0.11944375f, -0.05995920f, 0.13011840f, -0.00067948f, -0.03156231f, 
    0.19163948f, 0.21727285f, -0.08505400f, -0.06343389f, 0.08140253f, -0.15752432f, 0.08820107f, 0.03245198f, 
    0.03743950f, -0.14096688f, -0.13213935f, 0.18950301f, -0.02872642f, -0.06297658f, 0.25614062f, 0.11656943f, 
    0.03525053f, 0.01976699f, 0.15268087f, 0.02728738f, 0.15305415f, -0.22991562f, 0.31436765f, 0.20897074f, 
    0.13647640f, 0.01996886f, 0.15222882f, -0.20028515f, -0.24095765f, 0.08370466f, 0.11955103f, -0.01418357f, 
    -0.48741364f, -0.11561947f, -0.16131335f, 0.10283633f, -0.12734088f, -0.10982321f, -0.10393710f, -0.15315887f, 
    0.07170521f, 0.17956188f, -0.06792839f, -0.24606140f, 0.07939851f, -0.08604386f, 0.09874506f, 0.04958166f, 
    0.22447082f, 0.04262798f, 0.31370887f, 0.04914994f, 0.36362636f, -0.09345089f, 0.04024342f, 0.19365391f, 
    0.14051583f, -0.19806479f, -0.04078506f, 0.08480094f, 0.13154508f, 0.05388868f, -0.10993300f, -0.08727363f, 
    0.31904039f, -0.06140940f, 0.17578219f, 0.16296962f, 0.00629061f, -0.02693218f, 0.16425182f, 0.41417679f, 
    -0.03204284f, -0.06444030f, 0.19146387f, 0.30532375f, -0.09332357f, -0.17845757f, -0.01862968f, 0.05073329f, 
    0.07747956f, 0.12469167f, 0.15667735f, 0.14997686f, 0.15794003f, 0.27434230f, -0.12771669f, -0.09091055f, 
    -0.00019286f, 0.07222285f, -0.13928831f, 0.13830861f, 0.20607802f, 0.05772046f, 0.15596588f, 0.17649509f, 
    0.02985812f, 0.01070125f, 0.31060791f, -0.03769609f, 0.27862927f, 0.19548233f, 0.02751885f, -0.37390515f, 
    -0.08606664f, -0.16331391f, -0.08048689f, 0.14857095f, 0.05019952f, 0.09485659f, -0.03672234f, -0.10708831f, 
    0.12967016f, 0.08779556f, -0.24333160f, -0.17569387f, -0.46993068f, 0.16622746f, 0.06869137f, 0.10947022f, 
    0.04317242f, 0.07914582f, 0.15668042f, -0.16753979f, 0.03371673f, 0.20539705f, -0.04779686f, -0.00234765f, 
    -0.51771981f, 0.05611583f, 0.12172521f, -0.00557673f, -0.00562877f, 0.11516888f, 0.15611245f, 0.04717082f, 
    0.10737181f, -0.11334766f, 0.31605464f, 0.06948603f, -0.01232558f, 0.13378279f, 0.12705247f, 0.00469231f, 
    0.08508151f, -0.01647339f, -0.07159491f, 0.03701038f, -0.09889899f, -0.34694767f, 0.07093977f, 0.31669018f, 
    0.14359620f, 0.18954879f, 0.08862685f, 0.05683102f, -0.07523519f, -0.39001805f, 0.16348822f, 0.64000618f, 
    0.07800818f, 0.03717931f, 0.04274669f, 0.25450078f, -0.06917490f, -0.12805372f, -0.10664614f, 0.33833835f, 
    -0.12021729f, -0.01801670f, -0.06533301f, -0.00955642f, 0.09153081f, 0.02798110f, 0.07601096f, -0.01096971f, 
    -0.13065597f, 0.03864500f, 0.06174758f, -0.08117387f, 0.01217239f, 0.21621467f, 0.02312855f, 0.03281593f, 
    0.03382621f, -0.13796943f, 0.10990830f, 0.07835923f, 0.09577227f, -0.32756463f, 0.08550295f, -0.07357457f, 
    0.01651913f, -0.06048729f, -0.12642905f, -0.14512523f, 0.12178240f, 0.00612965f, 0.15795863f, 0.15704925f, 
    0.10466456f, 0.12750994f, -0.10548251f, 0.04031545f, 0.00146624f, -0.14117272f, -0.02369438f, 0.20512404f, 
    0.12082285f, 0.01142406f, 0.06683277f, -0.15958525f, -0.05645218f, 0.07170381f, -0.02071932f, 0.25348774f, 
    -0.12613855f, 0.10194719f, -0.33600140f, -0.01442303f, -0.09151731f, 0.32724699f, 0.03105368f, -0.06684479f, 
    -0.30677843f, -0.04454754f, -0.00694811f, -0.00758755f, 0.18750739f, -0.30847842f, 0.10455744f, -0.17297979f, 
    0.07323079f, -0.06599590f, -0.08908657f, -0.16299723f, 0.18837395f, 0.06340837f, -0.12686217f, -0.09466567f, 
    -0.04592361f, -0.08270115f, 0.34270296f, 0.16531694f, -0.05390996f, -0.22276767f, -0.06218802f, 0.19099045f, 
    0.13641027f, -0.06498359f, 0.19609247f, 0.04062146f, 0.01561210f, -0.07925241f, -0.11398170f, -0.06818953f, 
    -0.09445678f, -0.24384136f, -0.22878081f, -0.19874358f, 0.10724731f, -0.11237273f, -0.09291792f, -0.20342010f, 
    0.00744027f, 0.09558164f, 0.01915199f, 0.11414756f, 0.08645780f, 0.07830055f, 0.02188637f, 0.03535574f, 
    -0.10228378f, 0.13533777f, -0.02120945f, 0.22335784f, 0.03350557f, 0.34826100f, -0.24664731f, 0.04207331f, 
    -0.03200576f, -0.02352565f, 0.03628621f, 0.23499912f, 0.30033308f, -0.30429775f, -0.12754251f, -0.07015365f, 
    0.25760785f, -0.05209846f, -0.11207676f, -0.16071773f, 0.20045422f, 0.31545338f, -0.02633320f, -0.09517404f, 
    0.07771868f, -0.06385346f, 0.08976344f, 0.28528169f, -0.01074749f, 0.10626025f, 0.11285608f, -0.02668096f, 
    -0.00360968f, -0.08137195f, -0.03863994f, -0.03390434f, -0.28154740f, 0.07960876f, 0.12351657f, 0.12316669f, 
    0.11553594f, 0.00910260f, 0.04202382f, 0.17914730f, 0.19878934f, 0.09636305f, -0.09975387f, 0.11395040f, 
    -0.26640183f, -0.03242404f, -0.07187968f, 0.06189927f, -0.05203468f, 0.25507903f, -0.10992339f, -0.33173823f, 
    0.05518495f, -0.03493933f, 0.25162721f, -0.02471701f, -0.00697097f, 0.04738201f, -0.06008064f, -0.22128126f, 
    -0.02584972f, -0.04797001f, -0.10712095f, 0.08778614f, -0.16611864f, -0.23803720f, 0.19896489f, 0.07857414f, 
    0.02144401f, 0.19865999f, -0.05026789f, -0.00270415f, 0.15008661f, -0.43324667f, -0.10194711f, 0.13631190f, 
    0.19498295f, 0.04202968f, -0.27980539f, 0.14654648f, 0.12159062f, 0.03519580f, 0.09735498f, 0.12852035f, 
    -0.07136450f, 0.23261136f, 0.15119769f, -0.08017956f, 0.11820086f, 0.08320588f, 0.07655851f, -0.10858673f, 
    -0.23479381f, -0.12478680f, 0.19453087f, 0.16455999f, -0.12367600f, 0.26109061f, -0.13605355f, 0.03194455f, 
    0.17754745f, -0.20382702f, 0.19453400f, -0.07652409f, 0.31691962f, -0.41647789f, -0.12329926f, -0.04415253f, 
    -0.04439599f, -0.03665128f, 0.07355864f, 0.03316252f, 0.01308384f, 0.21889351f, 0.00407245f, 0.14321262f, 
    -0.02040716f, 0.03519019f, 0.09190653f, 0.11119704f, -0.04782382f, 0.06482521f, -0.22660920f, 0.15354481f, 
    -0.01197986f, -0.09900507f, 0.53470421f, -0.08230049f, 0.18157022f, -0.09831130f, 0.17114080f, 0.26524803f, 
    -0.05602758f, 0.18985426f, -0.18430974f, 0.15762803f, -0.13109128f, -0.06324726f, 0.19744931f, 0.37090626f, 
    -0.13340482f, -0.03359590f, 0.15162197f, 0.23287420f, 0.20791736f, -0.05561925f, 0.08384749f, 0.21769412f, 
    0.09371867f, 0.01643953f, -0.05277361f, -0.16013256f, 0.02861216f, 0.03417718f, 0.07198715f, -0.00295982f, 
    -0.07918908f, 0.12061405f, 0.03804378f, 0.14305018f, 0.02826846f, -0.00730116f, 0.05589552f, -0.19145745f, 
    -0.11980568f, -0.09736925f, 0.13207823f, -0.01870464f, 0.09059151f, -0.13911872f, -0.08939527f, 0.06742752f, 
    -0.11267981f, -0.22309652f, 0.19813035f, 0.22744368f, -0.00707239f, 0.35891128f, 0.08032235f, 0.13455299f, 
    -0.02203826f, 0.16061372f, 0.37400174f, 0.01489671f, 0.05218127f, -0.21062748f, -0.14115395f, 0.03374359f, 
    -0.07626331f, -0.17854874f, -0.07836113f, -0.07682256f, 0.08015683f, -0.02673424f, 0.04582208f, 0.18416025f, 
    -0.00188390f, -0.16188920f, -0.08939405f, -0.32953891f, -0.22717585f, 0.27737528f, -0.05034921f, 0.08421187f, 
    -0.03269299f, -0.05317594f, -0.08397360f, -0.17685559f, -0.26574862f, -0.32108858f, -0.10418268f, -0.22210601f, 
    0.04156764f, -0.00906883f, -0.13613512f, -0.22508332f, -0.42151093f, -0.06607728f, -0.08246407f, 0.02273073f, 
    0.07744846f, 0.02540015f, 0.21003164f, 0.11594090f, 0.05598095f, -0.22290446f, -0.11712893f, 0.05757290f, 
    -0.02125859f, -0.04894584f, -0.15397570f, 0.14149851f, -0.09403192f, -0.06555022f, 0.11339509f, -0.06398727f, 
    -0.02283394f, -0.12696990f, 0.01464933f, 0.00233854f, 0.01064703f, -0.23349270f, -0.04900550f, -0.13565144f, 
    -0.10120177f, -0.06258480f, -0.13732423f, 0.06666820f, -0.07259074f, 0.06697436f, -0.24754927f, -0.00629164f, 
    0.10860328f, 0.16078869f, -0.32757774f, 0.11323705f, -0.02412535f, -0.38924837f, 0.26532108f, 0.13758811f, 
    -0.07136419f, 0.14430135f, 0.18075474f, 0.16360939f, -0.02027892f, -0.20105922f, -0.01915515f, 0.13865589f, 
    0.18839097f, -0.05553518f, -0.30326167f, 0.30991450f, -0.12476026f, -0.19783248f, 0.07004754f, 0.40689707f, 
    -0.01135606f, 0.16458386f, 0.13536268f, -0.20022157f, 0.01581800f, -0.04613811f, -0.10158448f, 0.08079207f, 
    0.01748822f, 0.05850727f, 0.03188763f, 0.13153389f, 0.35231894f, 0.07406846f, -0.22971916f, 0.03169896f, 
    0.04261032f, -0.06027132f, -0.21915433f, 0.13120644f, -0.08185720f, -0.47340891f, 0.00039562f, 0.05126226f, 
    0.49202567f, 0.00009702f, 0.02980359f, 0.05923100f, -0.04722931f, 0.16353482f, -0.11437471f, 0.02093668f, 
    0.12260830f, 0.02160806f, -0.22578196f, -0.04982171f, -0.04416339f, -0.07570355f, -0.14778957f, 0.28584617f, 
    0.04885234f, 0.08279097f, 0.15808165f, 0.03425550f, 0.16192839f, 0.23665783f, -0.01368182f, 0.10303500f, 
    -0.38898334f, -0.09420236f, 0.24001184f, -0.18327004f, 0.13926138f, 0.02308088f, 0.07502185f, -0.39648715f, 
    -0.27865824f, 0.04056009f, 0.12750655f, -0.24596100f, -0.16929989f, 0.03991129f, -0.07065350f, -0.21923999f, 
    -0.06855682f, -0.02993941f, 0.15949307f, -0.15186915f, 0.13355801f, 0.06284945f, -0.09091517f, -0.12887232f, 
    0.30255240f, 0.02116488f, 0.13256066f, 0.04347489f, -0.08123565f, -0.13519286f, 0.07371471f, 0.11638757f, 
    0.08530252f, -0.01585851f, -0.10740431f, -0.05882009f, 0.07265624f, 0.26942980f, -0.02074265f, 0.05968959f, 
    0.36335865f, 0.01481119f, 0.18700355f, -0.00639649f, -0.06091752f, -0.22425053f, 0.02091847f, -0.18529910f, 
    -0.06711677f, 0.01921960f, 0.12730114f, 0.02500955f, -0.08584474f, 0.07006871f, 0.09550839f, -0.16302599f, 
    0.05660316f, 0.02385078f, 0.26477268f, -0.20073493f, 0.30527055f, -0.05717742f, 0.19648390f, 0.31716242f, 
    -0.17369059f, 0.12174579f, -0.08607795f, 0.01138638f, 0.01950467f, -0.20598085f, 0.07216403f, 0.26578394f, 
    -0.19390121f, 0.05103307f, 0.20626786f, 0.05595950f, 0.15903060f, -0.14240274f, -0.00851504f, 0.19625284f, 
    -0.13301468f, -0.17857316f, 0.10108203f, 0.01516974f, -0.04416462f, -0.00957808f, 0.06268512f, 0.16409568f, 
    0.21919765f, 0.10650537f, -0.23885861f, -0.02723289f, 0.32664773f, -0.15380609f, -0.02288380f, 0.32084656f, 
    -0.03622875f, -0.15842688f, -0.17116170f, -0.21320836f, -0.20326388f, -0.03839061f, 0.02954913f, -0.07333314f, 
    0.38808498f, -0.30163422f, 0.24176374f, 0.19257632f, -0.07926914f, 0.10265561f, 0.01719096f, -0.08010959f, 
    -0.07782993f, 0.08143669f, 0.23657414f, 0.05805960f, -0.10345438f, 0.04180901f, 0.06672966f, 0.09299616f, 
    0.00980715f, 0.23206981f, 0.45865673f, 0.01460028f, 0.22952151f, 0.09690804f, 0.11048040f, -0.07418769f, 
    -0.30679339f, -0.07534247f, 0.11419391f, 0.04600941f, 0.03307027f, -0.07627124f, 0.26852065f, 0.00861095f, 
    -0.10668229f, 0.00885736f, -0.00404210f, 0.23927163f, 0.34059224f, 0.10826905f, 0.03531069f, 0.04688312f, 
    -0.11514919f, -0.32299176f, 0.12344668f, 0.09766180f, 0.03352682f, -0.10455871f, -0.05958763f, -0.01583863f, 
    0.02965536f, -0.07044230f, 0.02357743f, 0.00301895f, 0.44007179f, -0.13305843f, 0.05802499f, 0.21956727f, 
    -0.07906541f, -0.27840140f, -0.25345850f, 0.26877546f, -0.20595996f, 0.12766670f, 0.02799334f, 0.11702131f, 
    0.46684700f, 0.04381759f, 0.15804042f, 0.00621200f, -0.00433527f, 0.16820396f, -0.10462714f, -0.22503293f, 
    0.10737650f, -0.00389592f, -0.03193464f, 0.22419024f, 0.07326286f, -0.31561199f, -0.16615236f, -0.03280399f, 
    -0.04115777f, -0.00867668f, -0.07595076f, 0.01760133f, 0.08192495f, -0.02117695f, 0.02689513f, -0.12014671f, 
    0.08720276f, -0.10589400f, 0.04021742f, -0.03000719f, -0.01426353f, 0.05717954f, 0.03540199f, 0.04983630f, 
    0.07117743f, 0.01603234f, -0.03455985f, 0.00275359f, -0.09639405f, 0.04501007f, -0.11897518f, -0.11042334f, 
    0.05304815f, -0.10723530f, 0.04915585f, -0.09693649f, -0.00882076f, -0.09686291f, -0.10288735f, -0.11259651f, 
    -0.03065908f, -0.00642131f, 0.00147855f, -0.07998379f, -0.10795312f, 0.07429343f, -0.09378767f, -0.02770954f, 
    0.07708743f, -0.04897799f, -0.04177349f, -0.05169957f, -0.11031124f, 0.08212869f, 0.06220566f, 0.10728817f, 
    -0.08228482f, 0.06258246f, -0.05571234f, -0.03918492f, -0.10945132f, 0.00553627f, 0.00659239f, -0.08876793f, 
    -0.01031791f, -0.01503795f, -0.01891860f, -0.10022762f, -0.02088071f, -0.07748066f, -0.09606010f, 0.06020428f, 
    -0.02159762f, -0.01049409f, 0.25802276f, 0.05070277f, -0.03756531f, -0.03676179f, 0.10209088f, 0.17753656f, 
    0.55410898f, 0.24066193f, 0.02153202f, 0.05941952f, 0.23307736f, 0.08286226f, 0.09606665f, 0.07140536f, 
    -0.13345484f, 0.01367206f, -0.06644402f, -0.05682983f, 0.19633937f, 0.34557217f, 0.04619352f, -0.15679562f, 
    0.04559886f, -0.05406332f, -0.05517367f, 0.30292919f, 0.26247260f, 0.07880424f, 0.01930361f, -0.01251065f, 
    -0.02855858f, 0.05741242f, 0.02686949f, 0.12680937f, -0.17814009f, 0.17104201f, 0.09401066f, -0.18379013f, 
    -0.06930429f, -0.09186635f, 0.50064403f, -0.24839577f, -0.03102219f, 0.07379054f, -0.09319934f, 0.09527045f, 
    -0.31228852f, -0.00705312f, 0.19207790f, 0.08983684f, -0.03131191f, -0.06167559f, 0.25716490f, 0.56017280f, 
    0.03307597f, 0.03742259f, 0.45910260f, -0.21438085f, 0.06845566f, -0.37224641f, 0.05633054f, 0.07506175f, 
    0.07141569f, 0.05594207f, -0.04592000f, -0.08866935f, 0.07383054f, 0.03646147f, -0.12904638f, -0.01969913f, 
    0.00884361f, 0.02084243f, -0.15252709f, -0.14849675f, -0.03242456f, -0.11575504f, 0.07263548f, -0.08885700f, 
    -0.11422695f, 0.08897515f, -0.08680389f, -0.05290237f, -0.03029597f, -0.08834409f, 0.05923005f, -0.05775874f, 
    -0.13767000f, -0.11341247f, -0.04713265f, 0.01730914f, 0.01242943f, -0.01545471f, 0.04191978f, -0.02370761f, 
    -0.07318254f, 0.12382825f, -0.16888256f, -0.05941191f, -0.09230851f, -0.06254669f, -0.13020244f, 0.04932529f, 
    -0.09923210f, -0.12520868f, -0.08133220f, -0.11092317f, 0.04031294f, -0.11839704f, -0.05900738f, 0.08682552f, 
    -0.03763669f, 0.08099867f, -0.03495742f, -0.11122958f, -0.10466052f, -0.07298521f, 0.00044688f, -0.03270081f, 
    0.03795573f, 0.01915507f, -0.07119805f, -0.11574698f, 0.09718676f, -0.02543438f, 0.00204799f, -0.11937875f, 
    -0.07582194f, -0.11439800f, 0.10111889f, 0.09799927f, -0.08835399f, -0.06144942f, 0.00703887f, 0.05826172f, 
    -0.02621065f, -0.02520508f, -0.08994798f, -0.04859121f, -0.11434902f, -0.12477262f, 0.00820883f, -0.11314138f, 
    0.10267292f, -0.11669275f, -0.00810737f, -0.12566534f, 0.01479423f, -0.01969480f, -0.04386092f, -0.11697355f, 
    -0.06404482f, -0.21164110f, 0.07545740f, 0.12138541f, -0.02604889f, 0.09101154f, 0.03897070f, -0.03874647f, 
    0.06680665f, -0.00875428f, -0.01977991f, -0.03665803f, -0.17228433f, -0.07619005f, -0.07324956f, -0.09702838f, 
    -0.02528033f, 0.01003150f, -0.05144137f, -0.00385166f, -0.07730772f, -0.13649876f, -0.04502171f, 0.09043679f, 
    0.03420209f, -0.16139922f, -0.08233708f, -0.11479645f, 0.05212719f, -0.06555626f, 0.06635177f, -0.02687449f, 
    0.12113270f, -0.05476122f, 0.08954200f, -0.06563115f, 0.07823226f, 0.00195477f, -0.12598015f, -0.18506691f, 
    -0.02929020f, -0.11324372f, -0.08879108f, -0.08036895f, -0.10487141f, 0.10056675f, -0.03232386f, -0.09671590f, 
    0.01637341f, -0.00970044f, -0.01944292f, 0.03256735f, -0.04016288f, -0.04238599f, -0.02397406f, -0.06659202f, 
    0.08687534f, -0.11643247f, -0.12280276f, 0.02058304f, 0.07788964f, 0.05849978f, -0.10505020f, -0.04509066f, 
    -0.02072143f, -0.09750912f, -0.10581996f, -0.04512418f, -0.02770936f, 0.01338053f, 0.10864120f, 0.02034043f, 
    0.00640020f, 0.02423912f, 0.01754802f, -0.00254964f, 0.01763171f, 0.01076860f, 0.00025951f, -0.12254316f, 
    0.06474135f, -0.01217333f, -0.06285369f, -0.12120371f, 0.09670559f, -0.08023828f, 0.00381544f, -0.01179862f, 
    -0.08176004f, -0.09722169f, -0.01135042f, 0.05647930f, -0.03685272f, -0.04516101f, -0.10081670f, 0.04638807f, 
    0.11584194f, 0.03647319f, -0.05700681f, -0.13692264f, -0.05047512f, -0.12545122f, -0.04790244f, -0.10650483f, 
    -0.04940751f, -0.11626006f, -0.16551870f, -0.02570771f, -0.20398685f, -0.08602314f, -0.01555719f, -0.01295369f, 
    0.13068819f, 0.00736846f, 0.04959432f, 0.07741668f, 0.01717170f, -0.15025884f, -0.23508073f, -0.19453350f, 
    0.13556574f, 0.05428040f, -0.06318785f, -0.14028960f, -0.06931601f, -0.10391628f, 0.11834310f, 0.07561167f, 
    -0.06966795f, -0.02554446f, 0.06299578f, 0.05308773f, -0.14334634f, -0.05786209f, -0.01382844f, -0.03759606f, 
    -0.00376623f, 0.02829525f, 0.05078817f, -0.14709750f, -0.01646024f, 0.06133791f, -0.18575050f, -0.04888793f, 
    0.06633806f, -0.15338942f, -0.05756552f, -0.04717546f, -0.01775753f, -0.18239182f, 0.04003219f, 0.06465083f, 
    0.02351569f, -0.00210050f, 0.04294469f, 0.00173740f, 0.11379135f, 0.02167276f, -0.16244787f, 0.01485192f, 
    -0.10386235f, -0.07561585f, -0.14413330f, 0.02767696f, -0.05865799f, -0.05598721f, -0.05918235f, 0.05919704f, 
    0.05249263f, 0.13805248f, -0.11398917f, 0.26929405f, -0.20620672f, 0.01821131f, -0.26594281f, -0.18356000f, 
    -0.14249410f, 0.08373340f, 0.24635661f, 0.21698840f, -0.05495512f, -0.09018051f, 0.12969366f, -0.16974564f, 
    0.21708046f, -0.07389884f, -0.08060206f, -0.04475638f, 0.09039158f, 0.12796171f, 0.06117590f, -0.03477925f, 
    -0.09456951f, 0.05306157f, -0.00250445f, 0.00123828f, -0.07196512f, -0.01077663f, 0.10140429f, -0.07544340f, 
    -0.13451183f, -0.03292292f, 0.19587201f, -0.18139602f, -0.15990174f, 0.15598352f, 0.25393486f, -0.18778288f, 
    0.12829734f, -0.17043373f, 0.17866012f, 0.40004846f, 0.34887698f, 0.23830599f, -0.07361706f, -0.07502393f, 
    -0.14508846f, 0.25707603f, 0.01853404f, 0.02452167f, 0.08479789f, 0.06214592f, 0.07592967f, -0.21344508f, 
    -0.05964568f, 0.06952307f, -0.07247062f, 0.09931756f, -0.01819304f, -0.04019591f, -0.05177362f, -0.08082948f, 
    0.09868447f, -0.22763710f, -0.02907578f, 0.03738124f, -0.16887502f, -0.37049055f, 0.06511738f, 0.17842656f, 
    0.11833435f, 0.14171249f, 0.10207018f, 0.22400154f, -0.01079065f, -0.28179377f, -0.08194292f, 0.23089093f, 
    -0.02929483f, 0.02354013f, -0.12516232f, 0.07306961f, -0.07828649f, 0.10989910f, 0.09926524f, 0.09265696f, 
    -0.00877320f, -0.05661932f, 0.00424131f, -0.21860796f, 0.10053486f, 0.08527602f, -0.01010949f, -0.04415832f, 
    0.03212965f, -0.07430398f, 0.10763209f, 0.08539576f, -0.38485423f, 0.38685375f, -0.12128473f, -0.30421910f, 
    0.10175474f, -0.15474816f, 0.33998382f, -0.05803156f, 0.23176384f, -0.07110869f, 0.04202783f, -0.08729541f, 
    -0.23928671f, -0.05125453f, 0.00113330f, 0.15345731f, 0.06539707f, 0.02987479f, -0.04895028f, -0.08024629f, 
    0.11608610f, 0.27134058f, 0.12160914f, 0.03967736f, 0.03623226f, -0.09026445f, -0.09775757f, -0.04170283f, 
    0.06089013f, 0.25096080f, 0.08928116f, 0.11421926f, 0.06262224f, 0.35867178f, -0.12485959f, -0.18205495f, 
    0.24799669f, 0.00710600f, -0.12863693f, -0.03246661f, 0.26658127f, 0.20051438f, 0.03827883f, -0.09550937f, 
    -0.11960346f, -0.01921847f, 0.14355358f, -0.09425549f, 0.23243415f, 0.12217811f, 0.11739124f, -0.39893630f, 
    -0.05121667f, -0.19191216f, 0.05702688f, 0.18629378f, 0.11149170f, 0.05461592f, 0.02283322f, -0.01265951f, 
    0.12831859f, 0.04829989f, -0.01827759f, 0.17461945f, -0.09851632f, -0.06731367f, 0.20419580f, 0.17634778f, 
    0.12248702f, -0.00340443f, 0.24963602f, 0.06433738f, 0.02333358f, 0.21156129f, -0.00266714f, 0.00062052f, 
    -0.05231188f, 0.19790669f, 0.02843603f, -0.04348759f, 0.05848648f, -0.30609426f, 0.14282310f, 0.16183586f, 
    0.02381565f, -0.16032378f, -0.13043168f, 0.15071271f, 0.01970138f, -0.08413079f, 0.28746510f, 0.04673384f, 
    -0.01509212f, 0.02494507f, 0.23430012f, -0.03292878f, -0.28401932f, 0.00844440f, -0.18574944f, 0.07281677f, 
    0.03122845f, -0.12854004f, -0.22778647f, -0.01003932f, 0.15690687f, 0.20128423f, 0.18123691f, 0.24331793f, 
    0.14653151f, -0.00507065f, 0.10918439f, -0.02860153f, 0.24053961f, 0.33742768f, 0.08278750f, 0.27266267f, 
    0.06583355f, -0.11726427f, 0.03644043f, 0.07249236f, 0.11454736f, -0.10098489f, -0.01605322f, -0.07583118f, 
    -0.21809508f, -0.03682434f, 0.12955256f, 0.07628018f, -0.06164106f, -0.07015716f, -0.09809683f, 0.14950652f, 
    0.08129387f, 0.01821048f, 0.05043781f, 0.22942439f, -0.17743999f, -0.09933048f, -0.10710944f, 0.01363412f, 
    0.10644090f, -0.27671447f, 0.05514418f, 0.08152383f, 0.00788647f, 0.26078653f, -0.23496424f, -0.00072040f, 
    0.07278123f, 0.23532072f, -0.16453929f, -0.17275578f, 0.08361650f, -0.31312206f, -0.27328613f, -0.18005808f, 
    0.03507271f, 0.00689090f, 0.05599142f, -0.11570785f, 0.10338105f, 0.17517467f, 0.19350903f, -0.12222211f, 
    0.09086354f, -0.08496282f, 0.04227354f, 0.04775337f, 0.07083213f, 0.13020128f, -0.00970879f, -0.18065929f, 
    -0.23379855f, 0.05710953f, -0.02804333f, -0.08724334f, -0.02481872f, 0.09153651f, -0.01682737f, -0.02112521f, 
    -0.02523273f, -0.13607426f, -0.08544012f, 0.14811859f, 0.20393483f, -0.00024912f, 0.07939512f, 0.02684061f, 
    -0.02063478f, 0.02503317f, -0.21947496f, 0.19586590f, 0.32477391f, -0.02164962f, 0.03654995f, -0.24974327f, 
    0.02624070f, -0.15879047f, 0.05876959f, 0.05545822f, 0.07151649f, 0.14946195f, -0.09921262f, 0.11597704f, 
    0.06265617f, -0.03710505f, 0.07695447f, -0.07165866f, -0.04728251f, -0.08408129f, 0.11445769f, 0.39490417f, 
    -0.11633216f, -0.09031989f, 0.41113576f, 0.01880517f, 0.04437067f, -0.22363998f, 0.09435577f, 0.22788543f, 
    -0.11042491f, 0.16284685f, 0.23036765f, -0.10871682f, 0.21631542f, -0.24608779f, -0.06071302f, 0.16457750f, 
    -0.28932667f, 0.06845903f, 0.02772965f, -0.08119519f, -0.12608479f, -0.06566261f, -0.06691150f, -0.21375552f, 
    -0.37884316f, -0.09456125f, 0.15139709f, -0.21500604f, -0.18660492f, -0.11971319f, 0.10573135f, -0.09813868f, 
    0.11770118f, 0.03633423f, 0.11419048f, -0.26140988f, 0.07598355f, -0.07465474f, 0.03176261f, 0.00265968f, 
    0.34547582f, -0.04709268f, 0.30802751f, -0.05692387f, -0.05690309f, 0.15158747f, 0.18769492f, 0.14748839f, 
    0.04255961f, -0.14521551f, -0.17749460f, 0.12479431f, 0.20928878f, 0.14790794f, 0.06211713f, 0.04834682f, 
    0.39382702f, 0.07532160f, 0.20491393f, 0.05111394f, 0.00123448f, -0.13150164f, 0.12745123f, -0.19313318f, 
    -0.11471821f, 0.04631606f, 0.30860576f, 0.33667684f, -0.09343664f, 0.13343203f, 0.11326935f, 0.05169455f, 
    -0.04082284f, -0.00716851f, -0.41170758f, 0.11052219f, -0.18038766f, 0.26768029f, -0.17545153f, 0.07466434f, 
    -0.06985689f, 0.06401765f, 0.22606683f, 0.21577145f, 0.19388999f, 0.05671233f, 0.00971803f, -0.35400066f, 
    0.32924366f, -0.06700494f, -0.45985618f, -0.12407617f, 0.06604820f, 0.13802218f, 0.12202361f, 0.22957374f, 
    0.07367775f, 0.18225284f, 0.44573450f, 0.24200213f, 0.17719585f, 0.07367437f, 0.04814611f, 0.12097273f, 
    0.14420716f, 0.08279067f, -0.11646653f, -0.03994923f, -0.25009027f, 0.12617135f, -0.03746101f, 0.14210549f, 
    0.25629258f, -0.12181820f, -0.08854158f, -0.18828605f, -0.21389580f, 0.18079586f, -0.10909734f, 0.11356758f, 
    0.23209961f, 0.01784221f, -0.09052187f, 0.29761574f, -0.06024007f, -0.11992089f, 0.07309306f, -0.20180863f, 
    -0.02475181f, -0.37964714f, -0.31287232f, -0.36828306f, 0.08624298f, 0.23533282f, 0.22970188f, -0.22836600f, 
    -0.00160422f, -0.05465836f, 0.25827828f, -0.07523423f, 0.27167198f, -0.11851554f, 0.20040679f, -0.04163238f, 
    -0.04500803f, 0.10185523f, -0.03004245f, 0.02581448f, -0.08424199f, 0.04853290f, 0.21878365f, 0.17851783f, 
    -0.37141427f, 0.10280585f, 0.21987656f, 0.19208349f, -0.01410362f, -0.24686928f, 0.02301527f, -0.22859938f, 
    -0.09224701f, 0.03257717f, -0.15401521f, -0.11365098f, 0.01542921f, -0.10086003f, -0.07320047f, 0.04881815f, 
    0.11608313f, -0.05489358f, 0.14603069f, 0.17671403f, 0.15345678f, -0.20628545f, -0.04490787f, 0.08445742f, 
    -0.11254843f, -0.14736091f, 0.02990722f, -0.24820389f, 0.11431587f, 0.13181581f, -0.11785734f, 0.10102585f, 
    -0.14048447f, 0.14868473f, -0.04388094f, -0.08767542f, -0.09266898f, 0.14211564f, 0.16867667f, 0.24839911f, 
    0.02483364f, 0.03920647f, 0.37342107f, 0.42394346f, 0.05674789f, 0.14630315f, -0.03968460f, 0.34628573f, 
    0.01741699f, 0.15618323f, -0.08827990f, 0.14694366f, -0.17091323f, -0.05910259f, 0.09733254f, 0.10824553f, 
    -0.01445608f, 0.02610799f, 0.24067485f, 0.19584543f, 0.11090159f, -0.39077738f, 0.20739934f, 0.07422784f, 
    0.28320131f, 0.01829129f, -0.45923668f, 0.12454282f, 0.12975800f, -0.04872977f, -0.03979078f, 0.47160861f, 
    0.10278174f, 0.14948449f, -0.00717467f, 0.06165977f, 0.08992430f, -0.12465360f, 0.11893392f, -0.04209775f, 
    0.07078825f, -0.10339000f, 0.07444576f, -0.07372487f, 0.37657845f, 0.06340209f, -0.17668013f, 0.33919805f, 
    0.12131585f, -0.12100736f, -0.40436831f, 0.18530732f, -0.24604055f, -0.03908594f, 0.00674736f, -0.12290822f, 
    0.50997871f, -0.12919852f, -0.01020716f, 0.18954743f, 0.05119757f, 0.16238445f, -0.04942892f, -0.20169215f, 
    -0.01807658f, -0.17190704f, -0.14370464f, -0.19887048f, 0.00885394f, -0.20560120f, -0.01683793f, 0.10016815f, 
    -0.01644721f, -0.07329296f, -0.04742720f, 0.28349441f, -0.10014426f, -0.09311803f, 0.02165279f, 0.11392958f, 
    -0.21643823f, 0.25465116f, 0.11743849f, 0.28166705f, 0.07540544f, -0.35308197f, 0.14218301f, 0.20226507f, 
    0.50575316f, 0.07855201f, -0.31277254f, 0.18708080f, 0.05144002f, -0.06497723f, 0.01052353f, 0.14601994f, 
    0.01149532f, -0.09754430f, 0.16710146f, 0.01749776f, -0.16365553f, -0.05581602f, -0.00154428f, 0.05864662f, 
    -0.11264893f, -0.11387591f, 0.07728719f, -0.24225360f, -0.11179667f, 0.33447155f, 0.01899559f, -0.14758110f, 
    0.21631934f, -0.18836977f, 0.04581005f, 0.19116163f, 0.07087272f, -0.06506161f, 0.09493028f, -0.12492201f, 
    -0.22918913f, -0.04573251f, -0.13369420f, 0.13918094f, -0.09216499f, 0.15218185f, 0.07283653f, -0.28075814f, 
    0.08555845f, -0.14210959f, 0.13067585f, -0.13296399f, 0.08053830f, 0.30985484f, -0.11305420f, 0.16981198f, 
    -0.08410243f, 0.12111634f, 0.07160874f, 0.11147131f, -0.07206121f, 0.11914819f, 0.14608461f, 0.03456942f, 
    0.24812530f, -0.08815525f, -0.27058902f, 0.00760227f, 0.05906672f, 0.04559383f, -0.01998828f, 0.04746777f, 
    -0.10176531f, 0.07726907f, -0.04712139f, 0.17372739f, 0.17424504f, 0.09107979f, 0.09857085f, -0.20822339f, 
    0.05038023f, -0.27039528f, -0.12474950f, -0.01219301f, 0.08000381f, 0.10449099f, 0.08568452f, 0.00845277f, 
    -0.14557970f, 0.09361301f, -0.07382377f, 0.06739370f, 0.28224063f, 0.01034887f, -0.08360509f, 0.04766096f, 
    0.13865459f, -0.13990715f, 0.20308232f, 0.02685759f, 0.14310829f, -0.24689022f, -0.05545668f, 0.05773496f, 
    -0.25422910f, 0.00526803f, -0.15021744f, 0.02818993f, 0.11185260f, 0.22507688f, -0.09781329f, 0.11053213f, 
    -0.08414894f, 0.11095347f, 0.30357817f, 0.24475020f, 0.11042311f, -0.04996864f, -0.08089729f, 0.26513761f, 
    0.01494252f, -0.01130214f, -0.35391128f, 0.10203184f, -0.01390276f, -0.31224972f, 0.02881304f, -0.07843893f, 
    -0.01393042f, 0.17769425f, 0.37707058f, 0.17137028f, 0.07489098f, -0.11076075f, 0.27646393f, 0.03660578f, 
    0.09539590f, 0.05938637f, -0.32061452f, 0.04910410f, 0.03777947f, 0.20339459f, -0.04466942f, 0.39388251f, 
    -0.03521680f, 0.27150306f, -0.03646081f, 0.03248978f, 0.03891980f, 0.10766602f, 0.06200658f, 0.12101172f, 
    0.17617129f, 0.08788912f, 0.05947091f, -0.00060768f, -0.22312666f, 0.26536018f, 0.05157522f, 0.10679676f, 
    0.15650071f, 0.06834432f, -0.04457854f, 0.08676798f, 0.06425808f, 0.06532253f, -0.00011463f, 0.07093963f, 
    0.10281666f, -0.03715098f, 0.00994089f, 0.00182762f, -0.10852640f, -0.18600203f, 0.05430664f, -0.09785131f, 
    -0.08101760f, -0.23142159f, -0.43904537f, -0.23008515f, -0.04086551f, -0.20324178f, 0.23754229f, 0.05718646f, 
    0.05880011f, 0.07391054f, -0.44817775f, 0.22959383f, -0.07867754f, 0.18912925f, -0.46609485f, 0.18200897f, 
    -0.04217851f, 0.02370097f, 0.19967189f, -0.05680022f, 0.23705344f, 0.06253742f, -0.08864243f, -0.07887872f, 
    0.10353322f, -0.07631829f, -0.15507789f, -0.32127509f, -0.21674144f, -0.01518389f, -0.09915914f, -0.26116028f, 
    -0.10051731f, 0.21668567f, -0.01410151f, -0.23584701f, -0.39544752f, -0.07885990f, -0.11897098f, -0.03409437f, 
    -0.04981221f, -0.03054749f, 0.43722048f, -0.30633423f, -0.15390128f, 0.13458741f, 0.02799028f, 0.22074176f, 
    0.17587687f, -0.06105546f, 0.16965681f, 0.32237467f, 0.33856606f, -0.32308531f, -0.10844086f, -0.04072337f, 
    0.05986554f, 0.17772366f, -0.07298320f, 0.12821746f, -0.03850651f, -0.19581237f, 0.10566953f, -0.07585554f, 
    0.07717273f, -0.15099353f, -0.41895768f, 0.23466474f, -0.08237842f, 0.08956229f, 0.05513063f, -0.08078007f, 
    -0.03849707f, 0.35419628f, 0.14669918f, 0.16120923f, 0.07502685f, 0.12032317f, -0.05257305f, -0.19230554f, 
    -0.39200377f, 0.09398720f, -0.06711475f, 0.20890522f, -0.08961187f, -0.22407986f, 0.19787848f, 0.12523969f, 
    -0.03030644f, 0.08810893f, 0.39569101f, -0.04686609f, 0.20436382f, 0.01636481f, -0.06985484f, -0.25485727f, 
    0.12289199f, -0.22814985f, -0.11566436f, 0.16489565f, -0.04477917f, -0.09127471f, 0.04014004f, 0.01158892f, 
    -0.26847506f, 0.05935945f, 0.26501825f, -0.11895847f, 0.13511625f, 0.01854108f, 0.07548288f, -0.05692897f, 
    0.11426520f, -0.28421739f, -0.11489736f, 0.41287476f, 0.19697405f, 0.06061525f, -0.02034638f, 0.00911587f, 
    -0.32730871f, 0.07572447f, -0.01889944f, -0.26761499f, -0.01074358f, -0.06917574f, 0.03302437f, -0.33433759f, 
    0.01774067f, 0.04038176f, -0.18524681f, 0.12525932f, 0.06591588f, 0.18412626f, -0.03692213f, 0.10444500f, 
    0.05406904f, -0.06782937f, -0.19452840f, 0.04121618f, 0.01500597f, -0.21849993f, 0.07011878f, -0.13591631f, 
    0.01599331f, -0.07679479f, 0.01696807f, 0.02663503f, -0.08237942f, 0.02888265f, -0.06430272f, 0.00842233f, 
    -0.11673529f, -0.05407479f, -0.15663411f, 0.14705749f, -0.16852614f, -0.07304225f, 0.00926083f, 0.10538688f, 
    0.11204780f, -0.07175871f, -0.21100666f, -0.08138956f, 0.06432644f, -0.00101618f, -0.05338137f, 0.03954991f, 
    -0.20842794f, 0.07445014f, 0.00022281f, 0.07389261f, 0.15425237f, 0.04656490f, -0.08078814f, -0.02506734f, 
    0.05544200f, -0.10806783f, -0.02856318f, 0.03024187f, -0.22271149f, -0.22560532f, 0.02469513f, -0.10853790f, 
    0.04541987f, -0.05244306f, -0.23873529f, -0.16432098f, -0.00604512f, -0.18416287f, 0.07065244f, 0.13366987f, 
    -0.05498562f, -0.07266698f, 0.08266086f, 0.05858999f, 0.05244879f, -0.21762791f, -0.00403522f, 0.15713054f, 
    -0.09823604f, 0.08227265f, 0.21405084f, 0.12466546f, 0.19650529f, -0.02438824f, 0.14520036f, -0.02896544f, 
    -0.19755363f, -0.08455005f, 0.02560269f, -0.07270876f, 0.42098579f, -0.04416747f, -0.19185048f, -0.20870964f, 
    -0.06808320f, 0.05894586f, 0.00251492f, 0.04283468f, 0.30186531f, 0.14384750f, 0.06154088f, -0.23652549f, 
    0.05514250f, -0.07072088f, 0.35011411f, 0.07769422f, 0.17388518f, 0.08733470f, 0.00671782f, -0.10862181f, 
    0.20730369f, -0.02954402f, -0.10667949f, -0.25915587f, 0.27473485f, 0.13251632f, -0.06463448f, 0.38862213f, 
    0.14112923f, 0.12257890f, -0.39823973f, -0.04497277f, -0.20536955f, 0.07237948f, -0.01373231f, -0.07877937f, 
    0.33933270f, -0.04706009f, 0.08618020f, 0.20152499f, -0.05072664f, 0.04182202f, -0.14678091f, -0.32727110f, 
    -0.05541593f, -0.19895647f, 0.15085465f, 0.12463608f, 0.04564055f, 0.23656999f, -0.02794518f, 0.03841163f, 
    0.06632686f, 0.17304234f, -0.02474839f, 0.18385373f, -0.04842311f, 0.10985738f, 0.19354361f, 0.00639354f, 
    -0.08900584f, 0.04266233f, 0.12906814f, 0.19401731f, -0.10601642f, 0.03818269f, 0.12280390f, -0.35291201f, 
    0.08665475f, 0.08117038f, -0.35727999f, 0.04009775f, 0.02727514f, 0.08862826f, -0.01018352f, 0.04681210f, 
    0.03886222f, 0.00446833f, 0.21002828f, 0.00522322f, -0.03836139f, -0.02775637f, 0.09154025f, -0.12078115f, 
    -0.05520134f, 0.02803420f, 0.09666952f, 0.02142259f, 0.41842899f, 0.07218534f, -0.01265330f, 0.18795958f, 
    0.26307485f, -0.26196837f, -0.23048697f, 0.21786936f, -0.02509922f, 0.08469718f, 0.07213569f, 0.04183675f, 
    0.45318061f, 0.01103097f, 0.10611515f, 0.10221791f, 0.02833861f, -0.11597221f, -0.04586235f, -0.07998232f, 
    0.05977473f, -0.19336143f, -0.00679700f, 0.09514382f, 0.11651003f, -0.19379242f, 0.11906986f, 0.25651699f, 
    0.04005580f, -0.18314190f, -0.20283696f, 0.04868779f, 0.00765220f, -0.03520437f, 0.12935650f, 0.33327195f, 
    -0.36055258f, 0.19202413f, 0.14526205f, 0.24201985f, -0.03776661f, -0.12162502f, -0.05073467f, 0.06439903f, 
    0.14817876f, 0.06892528f, -0.12384497f, -0.11823320f, -0.24539995f, -0.27132222f, 0.11431847f, 0.05257207f, 
    -0.01920393f, 0.15210341f, 0.19208696f, -0.13278793f, 0.01489575f, -0.06622685f, 0.04340772f, -0.08170682f, 
    0.15581401f, -0.08895323f, 0.04336042f, -0.16711293f, -0.06893306f, 0.15797213f, -0.14843221f, -0.11947781f, 
    0.22497459f, -0.02384912f, -0.02012193f, -0.09875821f, 0.06600626f, 0.00086388f, 0.12242529f, -0.00622496f, 
    0.02330301f, 0.03617191f, -0.04141483f, 0.20702936f, 0.08957692f, 0.03731910f, 0.17611045f, -0.08375636f, 
    -0.06976241f, 0.07321994f, 0.27169710f, 0.01739147f, -0.11562032f, 0.20908141f, 0.01202658f, 0.19476710f, 
    -0.05986953f, 0.02720910f, 0.19514342f, 0.08423167f, 0.01511557f, 0.13310908f, -0.12869017f, -0.20558642f, 
    -0.15301567f, 0.12340065f, 0.02843807f, 0.32813737f, 0.11216510f, -0.20515622f, -0.15232344f, 0.23982300f, 
    0.46528873f, -0.05357801f, -0.04298866f, 0.00005797f, 0.23259364f, 0.04825827f, -0.07875276f, -0.19954211f, 
    -0.09634001f, -0.40207416f, 0.18062332f, -0.00712559f, -0.06038124f, 0.06924716f, -0.08799864f, -0.05225517f, 
    0.04736540f, -0.05658606f, -0.02337236f, -0.05459024f, -0.19348642f, 0.07001689f, 0.11619056f, -0.01712840f, 
    0.13612816f, -0.09090699f, 0.13747901f, -0.03142878f, 0.07445558f, 0.03738891f, 0.03907561f, -0.00402405f, 
    -0.43481603f, -0.02359034f, -0.24112421f, 0.03535854f, -0.00910667f, 0.23802781f, -0.06262490f, -0.30035394f, 
    -0.02736004f, -0.08730499f, 0.13899937f, -0.02294007f, 0.12638067f, 0.19051050f, 0.05325251f, -0.09881965f, 
    0.07622761f, 0.12311245f, 0.38854864f, 0.10541776f, 0.18448366f, -0.29245144f, -0.03815713f, -0.07678410f, 
    -0.41437444f, 0.12159342f, 0.20348074f, 0.08430672f, -0.06993464f, -0.15149823f, -0.03786448f, -0.13241161f, 
    -0.27799809f, -0.05127659f, 0.20405449f, -0.18011813f, 0.10263478f, -0.10236700f, 0.04146583f, -0.19378217f, 
    0.07052386f, 0.14097935f, 0.21903811f, -0.15728180f, 0.04158260f, 0.09633353f, 0.08383430f, 0.03338377f, 
    0.09193670f, 0.00836010f, -0.17722680f, -0.14453293f, -0.17328867f, 0.26058349f, 0.05963230f, -0.04196059f, 
    0.12420204f, -0.09946999f, 0.12371268f, -0.05772279f, 0.27772143f, 0.27459112f, 0.06332663f, -0.08209254f, 
    0.15929215f, -0.17413014f, 0.24920951f, 0.23659351f, -0.08580595f, 0.19754878f, -0.05745675f, -0.24895072f, 
    -0.03754342f, 0.07744312f, 0.30869201f, 0.07926581f, 0.00481073f, 0.00423779f, 0.03805100f, -0.05425282f, 
    0.04081306f, 0.01020296f, -0.05824988f, -0.08566596f, -0.09373398f, -0.13497895f, -0.00039841f, 0.05126300f, 
    -0.11419707f, -0.01402168f, -0.11855429f, 0.14845429f, -0.04529381f, -0.07486451f, -0.07823347f, -0.17000051f, 
    -0.17590249f, -0.12416619f, 0.08359323f, 0.04533621f, -0.04027468f, 0.09127852f, -0.08752538f, 0.18520118f, 
    -0.10324857f, -0.12763694f, -0.03210595f, 0.10330904f, -0.05899557f, -0.04822071f, 0.07746108f, -0.03258914f, 
    -0.16742186f, -0.01509394f, -0.10172898f, -0.02856413f, -0.12502621f, 0.02830538f, -0.16239853f, 0.08053678f, 
    -0.08164098f, 0.02145934f, 0.13232648f, -0.05180132f, -0.09774392f, 0.03449721f, -0.05973481f, -0.08774643f, 
    0.02656819f, -0.10117114f, -0.15343226f, -0.08360596f, -0.03372724f, 0.05091919f, 0.05130995f, 0.01006852f, 
    0.04215422f, -0.14729755f, -0.02932134f, -0.04323507f, 0.07601158f, -0.07023771f, 0.10085399f, 0.07519405f, 
    -0.04651712f, 0.21856736f, 0.12774380f, 0.00096517f, 0.42486650f, -0.09671074f, 0.21792851f, 0.04499789f, 
    -0.17391403f, 0.13570338f, -0.02189156f, 0.06010986f, -0.20810074f, 0.06349897f, 0.12440533f, 0.01564494f, 
    -0.36035439f, 0.07416739f, 0.14991754f, 0.01451927f, -0.09047247f, -0.15656774f, 0.05974679f, 0.00920819f, 
    0.09405714f, -0.15913133f, 0.14393540f, 0.07721706f, 0.13058153f, -0.01964277f, 0.00992576f, 0.01158661f, 
    0.38453764f, -0.11484968f, -0.20024168f, 0.04459714f, 0.28494814f, -0.13872568f, -0.05504080f, 0.16878581f, 
    0.02315121f, 0.06293244f, -0.15341765f, -0.14645648f, -0.18075900f, 0.34222174f, 0.10834569f, 0.07115011f, 
    0.23600952f, -0.14451084f, 0.06959451f, 0.17226461f, -0.03470287f, -0.17617755f, 0.09046741f, 0.16364576f, 
    -0.08731206f, 0.11750538f, 0.22638446f, 0.17270507f, 0.06143996f, -0.19680606f, 0.15091816f, 0.11498347f, 
    -0.11142693f, -0.04164409f, 0.01863376f, -0.14798681f, -0.02909746f, 0.00207901f, -0.07946531f, 0.10070699f, 
    -0.03207216f, 0.09494551f, -0.11671447f, -0.03749767f, 0.04535566f, -0.06230773f, -0.24774574f, -0.07214374f, 
    -0.03360496f, -0.12226693f, -0.03449428f, -0.03745396f, 0.10067457f, -0.00451408f, 0.03216179f, -0.05796605f, 
    -0.01193687f, -0.13675091f, 0.02405453f, 0.00930110f, 0.11359427f, 0.04254024f, -0.02986870f, 0.11816853f, 
    0.05117548f, 0.04111461f, -0.11891021f, 0.05010542f, -0.22362109f, 0.14471872f, -0.26125193f, 0.07293476f, 
    -0.06582472f, -0.11121209f, 0.02586386f, 0.01057141f, 0.03943028f, 0.05132413f, 0.08579098f, 0.07826455f, 
    0.08866452f, -0.22712873f, -0.01778772f, 0.11761644f, -0.10934252f, 0.05424271f, -0.21988398f, -0.15781821f, 
    0.09611335f, 0.10337968f, 0.15604348f, -0.16207498f, 0.08662700f, -0.09981123f, -0.06740280f, -0.09107846f, 
    -0.06956231f, 0.03913335f, 0.36160508f, 0.00470832f, 0.17021421f, -0.09631404f, -0.13582779f, 0.22303823f, 
    -0.35096365f, 0.15406764f, -0.00852948f, 0.11619718f, 0.18841569f, -0.23507021f, -0.14885229f, 0.26560771f, 
    -0.17133021f, 0.07695740f, 0.11029181f, -0.23082630f, 0.12820727f, 0.04472400f, -0.07077724f, -0.00982411f, 
    0.05800040f, -0.05086674f, 0.10463065f, -0.01646827f, 0.00463112f, -0.09110026f, 0.07723335f, 0.07439841f, 
    -0.03416619f, 0.09733763f, -0.17247236f, -0.02196844f, -0.13904041f, 0.12316488f, -0.04076125f, -0.06951383f, 
    -0.07490722f, -0.05885997f, -0.14193062f, -0.11525679f, 0.13983807f, 0.15035686f, 0.05692643f, 0.01740183f, 
    0.11454173f, -0.21000428f, 0.20614156f, 0.09465809f, -0.08281891f, -0.05116320f, -0.01615599f, -0.17332521f, 
    0.00502390f, 0.06085875f, 0.30904961f, -0.02630475f, 0.10148502f, -0.00420347f, -0.04990296f, -0.02383214f, 
    0.12438423f, 0.18405682f, 0.40611279f, -0.05080723f, 0.10872174f, -0.15922962f, -0.00591517f, 0.02102147f, 
    -0.09565054f, -0.05037995f, -0.04668664f, -0.07172655f, 0.21901807f, -0.21645346f, 0.07970988f, 0.16203949f, 
    -0.20633475f, 0.00186078f, 0.12271793f, -0.14938441f, 0.31478447f, 0.22566253f, -0.05770946f, -0.16332605f, 
    -0.03728008f, 0.06272694f, -0.11452816f, 0.10910347f, 0.03475567f, 0.04945018f, 0.01139120f, 0.10328228f, 
    0.06084773f, -0.10849282f, 0.20411450f, 0.15328613f, -0.18841018f, 0.01273321f, 0.05630114f, 0.15365756f, 
    0.06998675f, -0.40850091f, -0.11934623f, 0.08572415f, 0.09550316f, 0.04331423f, 0.10425341f, -0.07015184f, 
    0.16340955f, -0.04613075f, 0.10659079f, 0.02634933f, 0.12420207f, -0.07711521f, -0.00293709f, -0.29201165f, 
    0.07293976f, 0.02417201f, 0.16130972f, 0.24039920f, 0.10788117f, -0.39673844f, 0.14035675f, -0.33786106f, 
    -0.04952740f, -0.02524754f, -0.36557862f, -0.05864648f, 0.06506220f, -0.14648718f, 0.16239034f, 0.19015156f, 
    0.50152129f, 0.16559593f, 0.24341798f, 0.10152095f, 0.09042271f, 0.34632984f, 0.28526562f, 0.23606262f, 
    0.18418553f, -0.11417572f, -0.28018549f, 0.12858655f, 0.03155806f, 0.12629622f, 0.03537113f, 0.22532140f, 
    -0.04028745f, 0.11833908f, -0.17304763f, 0.23519973f, 0.07072547f, -0.01891474f, 0.03039363f, 0.03393084f, 
    0.12972425f, -0.03717867f, -0.08644040f, 0.17123616f, 0.27865234f, 0.01873397f, 0.10928100f, 0.09999255f, 
    -0.15584506f, 0.14820674f, 0.18329860f, -0.08950133f, -0.37492669f, -0.14549419f, -0.10267145f, -0.03949190f, 
    0.02521687f, 0.05631963f, -0.04742803f, -0.16923875f, -0.08583337f, -0.11334807f, 0.16955543f, 0.27428427f, 
    0.01871401f, -0.04493828f, -0.16171800f, -0.30451030f, 0.03652766f, -0.40556765f, 0.26109919f, -0.01155209f, 
    0.06547569f, -0.04846080f, 0.15083826f, -0.07006498f, 0.22847719f, -0.05284936f, -0.17656223f, 0.25666723f, 
    -0.20902993f, 0.09814734f, 0.11055315f, -0.07642128f, -0.10298968f, -0.05624448f, -0.06513444f, -0.26687711f, 
    -0.09247448f, 0.11410923f, -0.13771111f, -0.17263684f, -0.06765527f, -0.09075487f, -0.12581098f, 0.07450543f, 
    -0.07778290f, 0.20723543f, 0.24635835f, -0.15145554f, -0.01235844f, 0.07469364f, -0.08324418f, 0.01260570f, 
    0.32895014f, 0.12782021f, 0.05503359f, 0.11775916f, 0.00950289f, -0.12740821f, 0.14270052f, 0.08851915f, 
    0.01711392f, -0.16364196f, -0.25750870f, 0.01545860f, 0.09264354f, 0.38734633f, 0.11886819f, -0.01456019f, 
    0.57047749f, -0.12006846f, 0.24973588f, 0.12454094f, 0.10391857f, -0.07667789f, 0.06158982f, -0.12175646f, 
    0.05964334f, -0.01401756f, -0.09577490f, 0.00289379f, -0.08777616f, 0.00462687f, 0.12508348f, -0.13770533f, 
    0.08064337f, 0.23564193f, 0.22553010f, 0.05685001f, 0.16743083f, -0.24901734f, 0.13534324f, -0.16733538f, 
    -0.23023720f, 0.06967600f, 0.24808368f, 0.28334105f, -0.12929711f, 0.27405593f, 0.27678433f, -0.10244746f, 
    -0.10777332f, 0.06245154f, 0.17306490f, 0.21367887f, -0.02074366f, -0.13113849f, -0.05375726f, 0.26325256f, 
    0.13339162f, -0.23584026f, 0.10495336f, 0.08034428f, 0.09707717f, 0.03697690f, 0.00600706f, 0.04690495f, 
    0.29539993f, 0.09926036f, -0.18511507f, -0.01819415f, 0.22297025f, -0.04567377f, -0.04770431f, -0.07106797f, 
    0.23017028f, 0.00746524f, -0.14092675f, 0.02186037f, -0.10083393f, 0.34131014f, -0.01382945f, 0.07604128f, 
    0.16457473f, 0.14286824f, 0.07454426f, 0.19695163f, 0.11477634f, -0.09094027f, 0.01431733f, -0.17370169f, 
    -0.08844948f, 0.10842492f, 0.02838358f, -0.05163349f, 0.07581190f, -0.27689946f, -0.00255143f, 0.18681094f, 
    -0.00747295f, 0.16348943f, -0.04150075f, 0.15456900f, 0.19440678f, -0.04665782f, 0.09813316f, -0.06719722f, 
    -0.25899199f, 0.19779888f, 0.11411844f, 0.20407563f, -0.16550073f, -0.40674123f, 0.00779535f, 0.27643767f, 
    0.11287910f, -0.10897270f, -0.22655419f, 0.22283603f, 0.06123408f, -0.20679842f, 0.03022394f, -0.03752929f, 
    0.08687373f, -0.10948037f, 0.16672900f, -0.19447607f, -0.05154860f, -0.01291412f, 0.01051764f, -0.04895086f, 
    0.13589950f, -0.04886771f, 0.00992854f, -0.12613741f, 0.15023816f, -0.02776715f, -0.03833590f, 0.09338654f, 
    0.18948424f, -0.13212119f, 0.07168243f, -0.03478840f, 0.14082590f, -0.24775380f, 0.07520417f, -0.12712090f, 
    -0.04844048f, -0.10559288f, -0.11918514f, 0.01022357f, -0.11512987f, -0.03651484f, 0.15335177f, 0.04158335f, 
    -0.01726187f, -0.29307479f, 0.05956250f, 0.21091159f, -0.10760672f, 0.28382808f, -0.09277736f, 0.35233346f, 
    -0.08587823f, 0.23982610f, -0.00235180f, 0.13161518f, 0.01392308f, 0.38959113f, -0.35439500f, 0.12873895f, 
    0.12979275f, -0.06249511f, -0.45882627f, 0.21024749f, 0.07768197f, 0.14234047f, 0.02064504f, 0.18293209f, 
    0.19466791f, -0.01114226f, -0.01584488f, -0.04174630f, 0.29503450f, 0.18718605f, -0.05689992f, 0.01863146f, 
    -0.03705607f, -0.29508418f, -0.02011364f, 0.12714270f, -0.35470515f, 0.09503797f, -0.00528508f, -0.05180616f, 
    -0.14094140f, 0.09748744f, 0.12941787f, -0.30776343f, -0.00195891f, -0.12689848f, -0.07394089f, 0.17048910f, 
    0.09522460f, -0.05621364f, 0.09835564f, 0.17783280f, -0.15255924f, -0.36995584f, -0.12153010f, 0.11028773f, 
    -0.07499000f, -0.07029691f, 0.00162014f, 0.12428079f, -0.03786869f, -0.00826386f, -0.14717403f, 0.05633522f, 
    0.10890434f, 0.00520145f, 0.08198837f, 0.00303986f, 0.06678995f, -0.01580122f, -0.22037408f, -0.17089675f, 
    0.11062111f, -0.07285717f, 0.04072015f, -0.27033597f, 0.05622993f, -0.17666596f, 0.00426126f, 0.13637917f, 
    -0.17391460f, 0.15537401f, -0.24532874f, 0.07772061f, -0.08106033f, 0.22595868f, 0.00366293f, 0.02941719f, 
    -0.16317183f, -0.09523344f, 0.07666658f, 0.02574767f, -0.00080614f, -0.07076123f, -0.03476246f, 0.01881188f, 
    0.09632418f, 0.01129916f, -0.04877721f, -0.13399243f, -0.17301783f, 0.02904922f, -0.06493166f, -0.06054129f, 
    -0.16299604f, -0.01511009f, -0.21508844f, 0.21346115f, 0.07436308f, -0.06645434f, -0.21088316f, -0.05499035f, 
    -0.09094587f, 0.21372701f, 0.30553359f, -0.07262275f, -0.04284815f, -0.09974986f, 0.10479707f, -0.02962972f, 
    0.04726297f, 0.10733435f, -0.04643290f, -0.00919659f, 0.05500692f, 0.13753165f, -0.10808334f, -0.09842180f, 
    0.10997118f, 0.26150361f, 0.07113039f, 0.04172557f, -0.00009114f, 0.02727228f, -0.11053188f, -0.13491011f, 
    0.05483338f, -0.34367767f, -0.04298848f, 0.00251829f, -0.09713098f, 0.16477504f, -0.17460831f, 0.07333674f, 
    0.12572625f, -0.01586989f, -0.12913090f, -0.22530329f, -0.08898930f, -0.17241921f, -0.14256451f, 0.11002141f, 
    0.08408549f, 0.06858248f, 0.07387302f, -0.21323138f, 0.04514939f, 0.10024863f, -0.10246810f, -0.10886417f, 
    -0.00443686f, -0.01122621f, -0.17814766f, 0.12334222f, 0.25302938f, 0.06304584f, -0.00180325f, -0.09513045f, 
    -0.09138017f, 0.09692943f, 0.02782572f, 0.12423160f, -0.17183605f, 0.06974880f, 0.09473369f, -0.10992453f, 
    -0.22601070f, -0.15913005f, 0.04406169f, -0.30854103f, 0.12338348f, 0.14727964f, -0.09268241f, 0.10932620f, 
    -0.03975913f, -0.02724287f, 0.01094665f, -0.10794616f, -0.01372470f, -0.06054181f, 0.19872847f, -0.02398155f, 
    0.01620168f, 0.15183838f, 0.14966781f, -0.22269675f, -0.08515173f, 0.22300433f, -0.09000260f, 0.14266935f, 
    -0.02689879f, 0.17354424f, -0.04335517f, 0.04517729f, -0.21687061f, -0.05000306f, 0.02128804f, 0.13973144f, 
    0.17338645f, 0.00288907f, 0.10221279f, 0.16991201f, -0.15624785f, -0.06682102f, 0.08465822f, 0.38470671f, 
    0.11511014f, 0.01343781f, -0.07611274f, 0.33278099f, 0.14316258f, 0.14054221f, 0.12523086f, 0.34710163f, 
    0.09442475f, 0.00698469f, -0.17870235f, 0.08516693f, -0.06231747f, 0.03259431f, -0.09691679f, 0.05836524f, 
    -0.14044449f, -0.10658330f, -0.02529073f, 0.01027499f, 0.18484049f, 0.07456722f, -0.23683235f, 0.12020773f, 
    -0.03481526f, -0.13435966f, -0.10629658f, 0.22513431f, -0.14408408f, -0.47046602f, 0.05465616f, -0.01400668f, 
    0.14831227f, -0.23233241f, -0.09570685f, -0.00770481f, -0.05932152f, 0.29376280f, -0.08363176f, 0.09116571f, 
    -0.11635908f, 0.23797183f, -0.16766220f, -0.18585773f, 0.01184663f, -0.57165223f, -0.31307822f, 0.22233163f, 
    0.00295760f, 0.01974024f, -0.51712394f, 0.03442060f, 0.02105138f, -0.01264735f, -0.01577442f, 0.06132716f, 
    0.30304074f, 0.16817331f, 0.00600652f, 0.00773807f, -0.07985866f, -0.21795018f, 0.20417397f, 0.11149487f, 
    0.26093554f, -0.06918571f, -0.26972571f, 0.22310503f, -0.00612615f, 0.07545234f, 0.00259281f, 0.15428151f, 
    -0.06583211f, 0.08435235f, -0.06336554f, 0.25679091f, 0.06265114f, 0.04714800f, 0.05397696f, -0.03361183f, 
    -0.11144016f, -0.01265254f, -0.03559013f, 0.14103450f, 0.05311349f, -0.06238034f, 0.23299648f, 0.05050664f, 
    -0.02527161f, -0.11765284f, 0.16902442f, -0.04440086f, 0.06071328f, -0.04715047f, -0.10964525f, -0.03067211f, 
    0.13313855f, 0.04247577f, -0.24525610f, -0.27377108f, 0.05107003f, -0.30083251f, 0.09966093f, 0.25689933f, 
    0.08072543f, -0.40143630f, -0.27446398f, 0.06605487f, 0.01684798f, -0.12691957f, 0.23477165f, 0.08629132f, 
    0.03664181f, -0.09664922f, -0.13044770f, 0.06385104f, 0.09062790f, 0.00316419f, 0.00904675f, 0.02497802f, 
    -0.15797867f, -0.13731548f, 0.02575211f, -0.00371073f, 0.04649699f, -0.08113839f, 0.06988625f, -0.13463110f, 
    0.02883559f, -0.10618841f, -0.10286329f, -0.12462132f, -0.00489962f, -0.09817862f, 0.02805961f, 0.04151753f, 
    0.11021416f, -0.10756449f, -0.06996457f, 0.06824970f, -0.03099960f, -0.07610562f, -0.13095269f, 0.06623530f, 
    0.00812409f, 0.04382043f, -0.15403628f, -0.08952148f, 0.09135460f, -0.09129046f, 0.04174547f, 0.06071863f, 
    -0.09322445f, -0.13451578f, -0.16600420f, -0.04238137f, 0.04798409f, -0.11049298f, 0.02385133f, 0.05223168f, 
    -0.00108412f, 0.04594849f, -0.07413621f, -0.16848382f, -0.02913663f, -0.11701060f, -0.13679934f, 0.03911057f, 
    0.10278530f, -0.02716257f, -0.11047807f, -0.09866636f, 0.06664008f, -0.11278532f, 0.06405324f, 0.01899782f, 
    -0.05827688f, -0.05513996f, 0.09672792f, -0.06547881f, 0.02797395f, 0.03259962f, -0.09227751f, 0.05352324f, 
    -0.00330065f, -0.23510122f, -0.10019861f, -0.13923846f, 0.10529768f, -0.14677624f, -0.20200686f, 0.03607185f, 
    -0.11499766f, -0.00133759f, -0.02515515f, -0.14557908f, -0.12780772f, 0.14010967f, 0.01369678f, 0.03388876f, 
    -0.05613404f, 0.01222346f, -0.01027412f, -0.26470545f, -0.25301680f, 0.12137087f, -0.07138757f, 0.08257087f, 
    0.00894884f, 0.00887003f, 0.08728515f, 0.09613848f, -0.25642562f, 0.05757736f, -0.00551211f, 0.04689180f, 
    -0.14985676f, 0.10635477f, -0.38105959f, -0.04911625f, -0.12607068f, -0.06795145f, 0.04418154f, -0.02485955f, 
    -0.21525173f, 0.29452640f, 0.07693451f, -0.04143735f, 0.08825192f, -0.07317103f, -0.16595124f, -0.02964340f, 
    -0.02382240f, -0.12635908f, -0.00133394f, -0.11259016f, -0.00924836f, 0.00743225f, -0.15877235f, -0.08151207f, 
    -0.04533117f, -0.04176382f, -0.17195532f, -0.06253047f, -0.18704170f, -0.23445991f, -0.05117773f, 0.03957861f, 
    0.53689164f, 0.00069579f, 0.02330776f, -0.03511748f, 0.13609137f, -0.11497515f, -0.05625434f, 0.40544641f, 
    0.24477352f, 0.05060314f, -0.13378191f, 0.10310549f, 0.13464881f, 0.23130810f, -0.03962995f, 0.04327846f, 
    -0.04770919f, 0.33903763f, -0.17729308f, 0.18173546f, -0.08284482f, -0.02737738f, 0.05137382f, -0.10117942f, 
    -0.11905267f, -0.04986060f, -0.01834212f, 0.21275729f, -0.20420124f, 0.25316906f, -0.09867774f, -0.02354043f, 
    0.01906935f, -0.05347621f, 0.21211012f, 0.14327373f, 0.14771546f, -0.29773051f, 0.03885392f, 0.08511053f, 
    -0.18817241f, -0.06122428f, -0.06452402f, 0.06395460f, 0.04359220f, 0.09973677f, 0.09102236f, 0.25327936f, 
    0.09489379f, 0.00722191f, 0.00058091f, -0.29460660f, 0.10150618f, -0.26837590f, 0.16100901f, -0.07299877f, 
    0.09456179f, -0.01337939f, -0.08421403f, 0.19722864f, 0.10907344f, 0.37501502f, -0.25506797f, 0.15379238f, 
    0.09109890f, -0.06516138f, -0.36900267f, 0.12724732f, 0.00013235f, 0.20867881f, -0.24063435f, -0.11860775f, 
    0.12215962f, -0.09967321f, -0.16098464f, -0.30904749f, 0.13186599f, -0.02105803f, -0.09331704f, -0.16207671f, 
    0.02882509f, -0.17509416f, 0.17943998f, -0.08341294f, -0.44111493f, -0.01417075f, -0.06156195f, 0.11254465f, 
    -0.05289864f, 0.01803161f, 0.09828569f, -0.32179379f, -0.13040558f, 0.11961189f, -0.08761494f, 0.29526901f, 
    0.25531667f, -0.06962342f, 0.11391567f, -0.01862190f, 0.15978104f, -0.32506514f, 0.03475607f, 0.07426959f, 
    -0.16799782f, -0.11069819f, 0.16800861f, 0.28752199f, -0.04718262f, 0.16748644f, 0.08561356f, 0.11742775f, 
    -0.05411320f, 0.03291438f, -0.16635928f, 0.16858095f, 0.01765856f, 0.01221207f, -0.00510963f, -0.02918276f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.05931492f, 0.15603685f, 0.24349996f, 0.12450292f, 0.11217341f, 0.13041832f, 0.10049141f, 0.00170663f, 
    -0.01939744f, 0.14903551f, 0.03082485f, 0.03706723f, 0.06817866f, -0.07286628f, 0.08004081f, -0.03430154f, 
    0.08761636f, 0.19898537f, 0.13342524f, 0.16961390f, -0.09188575f, -0.10180101f, 0.09951805f, -0.04713115f, 
    0.05197413f, -0.09616413f, 0.18656087f, -0.02319675f, 0.16860953f, 0.04017749f, -0.08358027f, 0.14961228f, 
    0.24306144f, -0.02754013f, 0.12538740f, 0.13677643f, -0.15539351f, 0.08087692f, 0.30617005f, 0.09589798f, 
    -0.19977653f, 0.28970081f, 0.19211034f, 0.11977715f, 0.23784137f, 0.14680995f, -0.12369254f, 0.03442912f, 
    -0.12465943f, 0.01927155f, 0.11986537f, -0.02533362f, 0.23172303f, 0.01441233f, 0.10829308f, 0.15783542f, 
    -0.07458168f, -0.01535776f, -0.05685165f, 0.13110217f, -0.13911793f, -0.02136019f, -0.25211340f, 0.09727522f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.00623129f, -0.12282984f, -0.35602859f, -0.19240190f, -0.39701307f, 0.01694222f, -0.42010295f, 0.24457523f, 
    0.08771432f, 0.14072926f, 0.16218024f, -0.54159439f, -0.29776034f, -0.08567063f, 0.11398549f, -0.06834550f, 
    -0.21886940f, -0.11274294f, 0.09138035f, -0.17245534f, -0.04959801f, 0.20405705f, 0.07062598f, -0.01527694f, 
    -0.08652123f, -0.11774840f, -0.41677696f, -0.04609219f, 0.10752605f, -0.51973337f, 0.12679796f, 0.00920939f, 
    -0.45642254f, 0.17498340f, -0.47395521f, -0.42604309f, 0.13838646f, -0.08791501f, -0.11766934f, 0.17973839f, 
    0.11315538f, -0.23014152f, -0.46802586f, -0.34791678f, -0.30663201f, -0.47427610f, -0.00295680f, -0.01446627f, 
    -0.07134233f, -0.13754410f, 0.02852175f, 0.18187173f, -0.09782481f, -0.29339209f, -0.08141191f, 0.00471153f, 
    0.08036559f, 0.03537776f, 0.07304834f, 0.23689222f, -0.04501713f, 0.14985326f, 0.16449966f, -0.22062942f, 
    -0.11396804f, 0.03633513f, 0.03876293f, -0.00840795f, 0.45093927f, 0.29742941f, 0.23508969f, 0.13835877f, 
    0.22348504f, -0.01149144f, -0.24672268f, 0.08264320f, -0.34398291f, -0.44929138f, 0.01735454f, 0.09802038f, 
    -0.30102643f, 0.17852327f, -0.06162457f, 0.06193167f, -0.11840732f, 0.02605245f, -0.12661920f, 0.01400456f, 
    -0.09574225f, -0.05112879f, 0.04824896f, -0.25153565f, 0.17558464f, 0.09568029f, 0.21610393f, 0.12818956f, 
    -0.17556180f, 0.11947145f, -0.30160061f, -0.43651447f, -0.03570693f, -0.08281622f, 0.25833732f, -0.06592715f, 
    -0.03875956f, -0.08551002f, 0.12693259f, -0.06903332f, -0.45938903f, 0.01184944f, 0.01445444f, 0.11896227f, 
    -0.22947170f, -0.23315611f, 0.04513417f, -0.02018066f, 0.11319983f, 0.21081430f, -0.22581984f, 0.19769199f, 
    -0.10951518f, -0.08113698f, 0.05053407f, -0.02676483f, 0.04414187f, 0.08649327f, -0.27627805f, 0.23925497f, 
    0.06753978f, 0.01604716f, -0.15394685f, 0.14866595f, 0.63506925f, -0.31891343f, -0.40041557f, 0.17477193f, 
    -0.29450220f, 0.03576132f, 0.18877321f, -0.27466065f, -0.02561637f, -0.23297831f, -0.48787221f, -0.01537481f, 
    0.10855841f, 0.01969052f, -0.09712823f, 0.21560042f, -0.12496725f, -0.65113759f, -0.07054278f, 0.04068954f, 
    -0.11213356f, -0.14423561f, 0.09738049f, -0.32507461f, 0.03034644f, -0.09936795f, -0.59453464f, -0.01126519f, 
    0.00161625f, -0.02415719f, 0.19679926f, 0.19952661f, -0.11186157f, 0.20342480f, 0.06083119f, 0.23037116f, 
    -0.16287924f, 0.08915303f, 0.08028809f, -0.10339741f, 0.10905319f, -0.15949464f, -0.07788365f, -0.11723110f, 
    -0.29424593f, -0.21009754f, 0.00707363f, 0.00000423f, -0.11273246f, 0.16324699f, 0.34252796f, -0.16274199f, 
    0.12842631f, -0.21848071f, -0.06960121f, 0.24039824f, 0.01219253f, 0.14000815f, -0.02021066f, -0.52689010f, 
    0.02989775f, -0.35717836f, -0.04015343f, 0.08584945f, -0.06725771f, -0.30627620f, -0.32146239f, -0.04832681f, 
    0.03925488f, -0.13747482f, 0.12638614f, -0.05462074f, -0.24055958f, 0.11726303f, -0.01867571f, -0.23360801f, 
    0.39215070f, -0.41634387f, -0.15179004f, -0.19672483f, 0.09750326f, 0.10584907f, -0.13046598f, 0.07378533f, 
    0.02017204f, -0.03844720f, -0.13078681f, 0.16666828f, -0.10033698f, 0.15712549f, 0.01759014f, -0.24767736f, 
    0.03134114f, -0.11139937f, 0.17540032f, 0.03210574f, 0.07361364f, 0.16056822f, -0.56276065f, -0.48115879f, 
    0.11111888f, -0.10878514f, 0.18999308f, 0.11614253f, -0.18300943f, -0.32583269f, -0.01127498f, -0.04286118f, 
    0.05383554f, -0.31419802f, -0.13677801f, 0.18858586f, -0.23172189f, 0.12628455f, 0.10922426f, -0.06429053f, 
    -0.65686047f, -0.24870665f, 0.28614417f, 0.03349169f, 0.01908159f, -0.28710157f, 0.10425641f, -0.14703569f, 
    0.18524195f, 0.14777856f, -0.09753758f, 0.09332576f, -0.10191534f, -0.05074041f, 0.30777636f, 0.02599832f, 
    -0.16572571f, 0.18189205f, 0.05645886f, 0.13065428f, 0.04267440f, -0.01960850f, -0.08964687f, 0.21574028f, 
    -0.39945158f, -0.21455789f, -0.30860323f, -0.56745410f, -0.11277051f, 0.18581700f, 0.06190655f, -0.03840759f, 
    0.11595330f, -0.11686479f, 0.01323761f, 0.22011369f, 0.02993963f, -0.04257780f, -0.08514699f, -0.27053365f, 
    0.35167643f, -0.12314314f, -0.19408384f, 0.01162421f, -0.06414128f, 0.18526556f, -0.32303056f, -0.49114770f, 
    -0.05799126f, -0.12537646f, -0.24036330f, -0.06060080f, 0.11411607f, -0.21227482f, -0.14480124f, -0.18491310f, 
    0.00583554f, -0.26377141f, -0.07525561f, 0.14013121f, -0.12157927f, -0.11389972f, -0.26436970f, -0.22673139f, 
    0.04396788f, 0.02979167f, -0.40398869f, 0.17027311f, -0.11288400f, -0.12885746f, 0.10411140f, -0.49907544f, 
    0.15139645f, 0.18538402f, -0.10401511f, 0.10615968f, -0.11087523f, 0.12314744f, 0.00687133f, -0.04842097f, 
    -0.04397618f, 0.17548484f, -0.01898615f, -0.46474335f, -0.04038870f, -0.10870261f, 0.19421273f, -0.21237287f, 
    -0.14841837f, -0.08578906f, 0.14354134f, -0.18099213f, 0.00377468f, 0.07697492f, -0.03804773f, 0.01140831f, 
    -0.06145920f, -0.12168016f, -0.01515540f, 0.27311739f, -0.10381333f, -0.32893500f, 0.09148037f, 0.10803664f, 
    -0.25316507f, 0.13047953f, -0.25086764f, 0.04281297f, 0.02910799f, -0.14546095f, -0.29800072f, 0.16288751f, 
    -0.19623636f, -0.09177144f, -0.11196481f, 0.28041270f, 0.28269625f, 0.23165299f, -0.16341861f, 0.03428183f, 
    0.17980027f, 0.34472430f, 0.04755921f, -0.15240383f, -0.06523518f, 0.15879162f, 0.16697203f, -0.22839820f, 
    -0.07722070f, 0.12003226f, -0.36264420f, -0.31781226f, 0.08314350f, -0.13006203f, -0.14314453f, -0.04214741f, 
    -0.14522149f, 0.22410420f, 0.12263310f, 0.08432174f, -0.41499880f, -0.34005180f, 0.00637529f, -0.60510755f, 
    -0.41318861f, 0.06249709f, -0.37563726f, -0.24648479f, 0.16514751f, -0.03532559f, -0.63046402f, -0.31693050f, 
    -0.18135749f, 0.08739249f, -0.36999732f, -0.35219887f, 0.08756553f, -0.85608178f, -0.03248679f, 0.08666464f, 
    -0.09379592f, 0.14629582f, 0.13839239f, -0.49130937f, 0.03705046f, -0.23519605f, -0.12298775f, -0.01611841f, 
    0.36301091f, -0.36312896f, -0.06613661f, 0.22959659f, 0.10641300f, -0.25828525f, 0.29257044f, 0.05494832f, 
    -0.02595860f, 0.09751900f, 0.20919859f, 0.18471766f, 0.18854864f, -0.11793956f, -0.06831522f, -0.37680891f, 
    -0.12926275f, -0.11391399f, -0.62559241f, -0.57665634f, -0.04390593f, -0.50968665f, 0.14702547f, 0.18147354f, 
    -0.03270467f, -0.12675761f, -0.49281418f, -0.12484761f, 0.00699456f, 0.10240933f, -0.22862151f, 0.31654015f, 
    -0.27346829f, -0.06408618f, -0.45948443f, 0.17908400f, -0.31315139f, 0.12955126f, 0.13482352f, -0.30270305f, 
    -0.28563502f, -0.27785426f, 0.12796463f, -0.10189330f, -0.03742341f, -0.20344560f, 0.20854323f, -0.03130964f, 
    0.04008165f, -0.13070323f, 0.12213352f, 0.21017310f, -0.03888522f, -0.04626647f, 0.08854811f, 0.09595075f, 
    -0.06468481f, -0.02565228f, 0.05952357f, -0.27555972f, -0.33608654f, 0.30951118f, -0.00838784f, -0.33424929f, 
    -0.36526987f, -0.16097964f, 0.16351354f, 0.08906226f, 0.11118251f, -0.25353473f, -0.51782483f, 0.13225587f, 
    0.01725850f, -0.45098010f, -0.01307399f, -0.20575801f, 0.04233897f, -0.44909948f, 0.00371535f, -0.21758440f, 
    -0.10653102f, 0.02233190f, -0.27188385f, 0.15908396f, -0.14279523f, 0.03532026f, -0.29700792f, 0.23852475f, 
    -0.05586065f, -0.11816239f, 0.39713645f, -0.38840976f, -0.05080994f, -0.12015156f, -0.02371327f, -0.01818453f, 
    -0.50865126f, 0.04443683f, -0.04794210f, 0.08582325f, -0.38022780f, -0.09466910f, -0.28422356f, 0.10829177f, 
    0.17701584f, -0.57382703f, 0.11799359f, 0.11154309f, -0.36621448f, 0.08727828f, 0.19646315f, -0.15937155f, 
    0.27478957f, 0.04813691f, 0.35502145f, 0.19791208f, 0.05851610f, -0.48506099f, 0.04732606f, 0.06665647f, 
    0.06700373f, -0.02190385f, -0.28678083f, 0.03152698f, -0.62323684f, -0.03476107f, -0.38802776f, 0.15053201f, 
    -0.46636447f, 0.27731037f, 0.16840702f, 0.02428944f, 0.18158926f, -0.55256331f, -0.29281065f, -0.21911615f, 
    0.02767921f, 0.28462046f, 0.10627706f, 0.09692959f, 0.03904980f, -0.00983266f, -0.11497528f, -0.01259492f, 
    -0.04158651f, -0.00699219f, -0.01736245f, -0.46864980f, 0.05277551f, -0.04573731f, 0.19900593f, -0.22368637f, 
    -0.15600049f, 0.21902326f, -0.04160507f, -0.45400718f, -0.02483538f, -0.27596042f, -0.37659365f, -0.07613254f, 
    0.15869071f, -0.27236778f, -0.08160875f, -0.21741267f, -0.04832786f, -0.04049806f, -0.19381760f, -0.28824383f, 
    -0.28825110f, 0.20718579f, -0.19158989f, 0.04935459f, 0.27762833f, 0.06520889f, -0.07839795f, -0.22135569f, 
    -0.35784686f, -0.05114061f, -0.56595445f, 0.18390857f, -0.02007411f, 0.05146555f, -0.07545557f, -0.17649432f, 
    -0.06590386f, -0.07413808f, 0.17528579f, 0.06767560f, 0.17763174f, 0.27136162f, -0.16789450f, -0.30092615f, 
    -0.13175038f, -0.19540660f, 0.00680427f, 0.02024010f, 0.27100500f, -0.13256657f, -0.08031768f, 0.24418099f, 
    -0.09946676f, 0.18530357f, 0.08199389f, -0.57761800f, 0.17087658f, -0.03971593f, -0.22084506f, -0.59329885f, 
    0.08114678f, 0.06214296f, 0.27615914f, -0.30575839f, -0.42538345f, -0.43348593f, -0.13584703f, 0.18901996f, 
    -0.27929479f, -0.39821619f, -0.01772703f, -0.24595663f, -0.11014777f, 0.09460910f, 0.05587134f, 0.00745738f, 
    -0.09580262f, -0.20988297f, 0.12796782f, -0.42397243f, -0.12531953f, -0.03632662f, -0.43267959f, -0.01013897f, 
    -0.03822775f, -0.14308921f, -0.31381729f, -0.44347215f, 0.00963125f, -0.28333005f, -0.20929116f, -0.12606457f, 
    -0.03847039f, 0.26795185f, 0.33282521f, 0.22827356f, -0.12253162f, -0.14426401f, -0.00274046f, -0.00543180f, 
    -0.09107099f, 0.13358861f, -0.29602647f, -0.30294368f, -0.09776296f, -0.00040047f, -0.09529813f, 0.18370889f, 
    0.38142291f, -0.27614525f, 0.30819970f, -0.28533486f, -0.48154372f, 0.09502672f, -0.19876575f, -0.35286704f, 
    -0.05320659f, 0.35164219f, 0.16721773f, -0.05385693f, -0.22447105f, 0.15144277f, 0.21044709f, 0.04544597f, 
    0.09320884f, 0.39712310f, 0.27883327f, -0.05772603f, 0.31392545f, 0.08345630f, -0.24110790f, -0.24349861f, 
    -0.79778987f, 0.01476093f, -0.32368037f, -0.26385790f, 0.00324837f, -0.27126265f, -0.06821276f, -0.31927255f, 
    -0.33897412f, -0.07973186f, 0.33296686f, -0.18228491f, -0.13722898f, -0.12213416f, 0.04364425f, -0.26756784f, 
    0.09218435f, -0.42078298f, 0.21159571f, -0.34779748f, -0.04127797f, 0.20736060f, 0.04148079f, -0.48717690f, 
    0.18454240f, 0.02391750f, -0.22003068f, -0.21091709f, 0.04815875f, -0.00327858f, 0.08104793f, 0.05843438f, 
    0.08354439f, 0.11101613f, 0.25163653f, 0.22367729f, -0.29999104f, -0.16794416f, -0.26404428f, 0.22309855f, 
    -0.17994834f, -0.18013377f, -0.03421514f, 0.09731979f, -0.11036777f, 0.08163112f, 0.34071589f, -0.00444911f, 
    -0.07035374f, -0.34941754f, -0.00054052f, 0.20537478f, -0.19092618f, 0.13782956f, 0.04844881f, -0.39404595f, 
    0.04623980f, 0.08818820f, 0.23895890f, -0.10465140f, 0.12669699f, -0.39261687f, 0.00128435f, -0.27045923f, 
    -0.59536821f, 0.18250425f, -0.06144033f, 0.03367309f, 0.03561562f, -0.16961701f, 0.16607994f, -0.11370613f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.22857156f, 0.08107868f, 0.18780956f, -0.03472786f, -0.06695193f, -0.06295951f, 0.04436914f, -0.22948344f, 
    0.01303012f, -0.09405700f, -0.05699772f, 0.08757587f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
