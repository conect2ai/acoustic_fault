#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.59630233f, 0.48115000f, 0.35845143f, -0.24120529f, 0.04555599f, -0.44026887f, -0.00877453f, 0.05246378f, 
    0.73175186f, -0.76021868f, 0.50725496f, -0.16689062f, 0.28968647f, 0.41632605f, 0.72075266f, -0.39515558f, 
    -0.57553989f, -0.54182786f, -0.07561576f, 0.46434391f, 0.40186128f, 0.10465523f, 0.36602440f, 0.58967477f, 
    0.43476537f, -0.52573937f, -0.06696604f, 0.33927804f, -0.48611110f, -0.71554255f, 0.32626632f, 0.48926860f, 
    0.78506845f, -0.25920737f, 0.23792745f, -0.29677469f, 0.80910629f, -0.56406021f, -0.41899624f, -0.48008868f, 
    -0.47194853f, 0.04346103f, -0.57391769f, 0.64846456f, -0.47696298f, -0.80408329f, -0.75745362f, -0.50834751f, 
    0.36520445f, 0.32672045f, 0.16399898f, -0.17955741f, -0.41911295f, -0.26301095f, 0.16567361f, -0.87991625f, 
    0.94664383f, 0.29628676f, -0.43818879f, -0.27177784f, 0.42053086f, 0.28848705f, 0.19810714f, 0.41553450f, 
    0.57385808f, 0.26270220f, -0.06188656f, 0.14582850f, 0.11749311f, 0.20370778f, 0.40888855f, -0.34885007f, 
    1.03704298f, -0.83570355f, -0.21951480f, 0.44613302f, 0.10315369f, -0.32695270f, 0.04610907f, 0.33200306f, 
    -0.35750484f, 0.53292674f, 0.48824108f, 0.41944331f, -0.76545727f, -0.05316137f, -0.51340860f, 0.03349984f, 
    0.24878797f, 0.56448609f, -0.58267415f, 0.03978306f, -0.07287892f, -0.27851415f, -0.56593132f, -0.61190605f, 
    0.22162035f, 0.18456471f, 0.34409139f, -0.44121155f, -0.44675031f, -0.41748515f, 0.58014375f, 0.33597806f, 
    0.25074232f, 0.24307013f, 0.13668363f, 0.38166282f, -0.62208617f, -0.49639654f, -0.21312453f, -0.19283703f, 
    0.02395867f, -0.34882095f, 0.48184294f, -0.12755498f, -0.07447787f, -0.07964473f, 0.31032670f, -0.00381785f, 
    -0.25472188f, 0.10968544f, -0.08006664f, -0.27268785f, 0.78277612f, -0.58539081f, 0.49091241f, -0.10807415f, 
    0.03467945f, 0.09009182f, -0.21889082f, 0.56483078f, 0.21430041f, 0.22714028f, -0.08947577f, 0.66049850f, 
    0.07089038f, 0.31442532f, -0.19571243f, -0.07731155f, -0.06729692f, 0.83301407f, -0.66840005f, -0.14820588f, 
    -0.10881781f, -0.38430181f, -0.12040117f, -0.48292479f, -0.82722616f, -0.73696977f, -0.00143951f, 0.60595834f, 
    0.20682293f, -0.35639697f, 0.82187110f, -0.61994487f, -0.53753227f, -0.28129449f, -0.22273339f, 0.12783068f, 
    0.14872929f, 0.46692437f, -0.11714957f, 0.60873741f, -0.25425526f, -0.27714637f, -0.57815796f, -0.64576864f, 
    -0.07026827f, 0.12777045f, 0.22334532f, 0.07664306f, -0.33420295f, 0.23764083f, -0.27454826f, -0.03972854f, 
    0.55043268f, -0.43484178f, 0.40054286f, 0.06118117f, -0.88535947f, 0.30997661f, 0.88794464f, -0.78639209f, 
    -0.59794122f, 0.94046307f, 0.00996586f, -0.01257214f, 0.12401716f, -0.60426402f, -0.37608391f, -0.24849145f, 
    1.05893612f, -0.22979251f, -0.48119894f, -0.38882616f, -0.32193336f, -0.05014062f, -0.85698587f, -0.29045013f, 
    0.39731368f, 0.06403346f, -0.39216846f, -0.39626694f, -0.11993252f, 0.22928387f, -0.38706172f, 0.64583349f, 
    0.29019994f, -0.25946400f, -0.35856402f, 0.58729517f, -0.58652347f, -0.16333568f, 0.20788689f, 0.07497079f, 
    -0.53403127f, 0.47357211f, -0.07798140f, -0.06441022f, 0.26706180f, -0.42274079f, 0.47409093f, 0.45906180f, 
    -0.82510579f, -0.51116288f, 0.22528659f, 0.19853008f, -0.69050765f, 0.49334717f, -0.51035094f, 0.20939106f, 
    0.79699612f, -0.37552986f, -0.09382396f, -0.14965816f, -0.14236695f, -0.16783179f, -0.16526571f, -0.28600097f, 
    0.29148954f, 0.49300152f, 0.67739767f, 0.64393175f, -0.36368573f, 0.60668105f, -0.16718118f, -0.57361054f, 
    -0.50652778f, -0.57144332f, -0.27859667f, -0.28955954f, -0.13013892f, 0.35904241f, 0.23114456f, 0.46866456f, 
    0.17613749f, 0.54278046f, 0.30771959f, -0.15145339f, 0.17989258f, -0.53432989f, 0.98713815f, -0.18234409f, 
    0.29535022f, -0.30647480f, 0.00063414f, 0.43745729f, -0.52881509f, 0.42871821f, -0.41031191f, 0.27755767f, 
    0.69761205f, 0.63381821f, -0.45218816f, -0.13936032f, -0.30270687f, 0.03727477f, -0.16918153f, 0.31586915f, 
    -0.00480566f, 0.46139508f, -0.54276317f, 0.04306106f, 0.43496245f, -0.49572951f, -0.22203889f, -0.34272373f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.31190506f, -0.27737185f, 0.12991907f, 0.25676656f, -0.02365152f, -0.17821452f, -0.23735505f, -0.37626991f, 
    0.09337544f, 0.03117575f, -0.06597369f, 0.40462908f, -0.20824999f, 0.27194783f, 0.40738139f, -0.20454399f, 
    -0.08172593f, 0.13709414f, 0.18164180f, 0.31719849f, -0.03432214f, 0.02084149f, -0.41258854f, 0.07648679f, 
    0.09604917f, -0.05978057f, 0.17326735f, -0.20379706f, -0.27238882f, -0.16422397f, 0.03634137f, 0.00789963f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02614305f, -0.06480622f, -0.04269816f, -0.03819957f, -0.01386093f, 0.02123470f, 0.03084052f, 0.00521196f, 
    -0.00669389f, -0.06311590f, 0.03372122f, -0.00224698f, -0.06126850f, -0.03981512f, 0.04369954f, -0.03253243f, 
    -0.00403825f, -0.03514597f, 0.04982062f, 0.01221792f, -0.03601889f, 0.02675005f, -0.05642124f, 0.04941092f, 
    0.02224448f, -0.03329802f, -0.04189815f, -0.02154471f, 0.05035914f, 0.01153970f, -0.00510467f, -0.01584909f, 
    0.00917625f, 0.01916694f, -0.04799943f, 0.04808659f, -0.03399148f, 0.04201709f, -0.02813258f, -0.04713296f, 
    0.03845860f, 0.01313206f, -0.04295457f, 0.01117547f, -0.01371937f, -0.03635015f, 0.02308715f, -0.03911415f, 
    -0.05869311f, 0.01917878f, -0.01328908f, 0.01083403f, -0.01311796f, -0.00893016f, -0.03096851f, -0.03190970f, 
    0.01956604f, -0.03380836f, -0.00742295f, -0.04617850f, -0.01340306f, 0.01426390f, -0.03663560f, -0.04666310f, 
    0.02812255f, -0.00478862f, -0.01934234f, -0.05421907f, 0.01365087f, 0.05477514f, -0.05278105f, -0.00351604f, 
    0.00591874f, -0.04713030f, -0.05567982f, -0.05063156f, 0.01813336f, -0.06119185f, 0.02832111f, -0.03195211f, 
    -0.02990045f, -0.00193896f, -0.02387737f, 0.02071626f, -0.01320359f, -0.04539340f, 0.02132286f, -0.03922967f, 
    -0.05964521f, -0.05898694f, 0.01401104f, -0.04093432f, -0.02732795f, -0.03101665f, -0.04458843f, 0.01768197f, 
    -0.00635671f, 0.02068657f, -0.03996126f, 0.02576810f, -0.01435800f, -0.04076907f, 0.02767666f, -0.00139113f, 
    0.05137739f, -0.05350501f, -0.05040717f, 0.04589919f, -0.00505985f, -0.04220654f, -0.04650275f, 0.04495459f, 
    0.03604219f, 0.04857178f, 0.02867840f, -0.01755759f, 0.00792709f, -0.03393316f, -0.04896475f, 0.02560887f, 
    -0.02896538f, 0.04350067f, 0.02568919f, 0.04073527f, -0.02673481f, -0.04844236f, 0.03740267f, 0.03462953f, 
    0.00829318f, -0.01198400f, -0.04587200f, -0.03604458f, 0.03969369f, 0.01809781f, 0.03202444f, -0.05236119f, 
    0.03981471f, -0.02069359f, -0.05625749f, -0.02066060f, 0.01318118f, 0.02610157f, -0.04700956f, 0.00787547f, 
    0.01702451f, 0.01066928f, -0.01348364f, 0.01129985f, -0.00497908f, -0.01660013f, -0.00205873f, -0.03696484f, 
    -0.03007763f, -0.04670434f, 0.03978867f, -0.02611008f, 0.04442270f, -0.02616815f, 0.00564195f, -0.00628582f, 
    -0.02846590f, -0.00943571f, -0.02700581f, 0.02335179f, -0.00240781f, 0.01766279f, -0.03508672f, -0.05317566f, 
    0.04412509f, -0.03090521f, 0.01805863f, -0.00579900f, 0.01036869f, 0.00173369f, -0.04321735f, 0.02970257f, 
    0.02329372f, -0.03899084f, -0.01030707f, 0.02950570f, -0.05462385f, 0.04901592f, -0.02909933f, -0.04804021f, 
    0.02576074f, -0.03627159f, 0.01404172f, 0.00704873f, -0.00908114f, -0.04210639f, 0.04191153f, 0.01709241f, 
    0.00861671f, -0.05694290f, -0.01071865f, 0.05512258f, 0.05029821f, -0.01939174f, -0.01693037f, 0.00965972f, 
    -0.03703818f, -0.05810333f, -0.04166062f, -0.03024540f, -0.01553716f, -0.00247682f, -0.05007512f, -0.04425571f, 
    -0.04699051f, -0.05332325f, -0.04727011f, 0.04048083f, -0.00937284f, 0.03218723f, -0.03784646f, 0.02478107f, 
    0.01791731f, 0.03534605f, 0.00188533f, 0.04414513f, -0.05995823f, -0.01382529f, -0.01465220f, 0.00602931f, 
    -0.04159500f, 0.03589186f, -0.02031641f, -0.02550623f, -0.00500627f, -0.02921466f, 0.01762693f, 0.00223846f, 
    -0.03688186f, 0.00449427f, -0.05602419f, 0.01695267f, -0.00942268f, -0.04157530f, -0.05356377f, -0.03109134f, 
    -0.03507075f, 0.02012762f, -0.01087653f, 0.03058624f, 0.02861469f, -0.01175416f, -0.05103642f, 0.03246254f, 
    -0.06109496f, -0.00258213f, -0.03111787f, -0.02503963f, 0.03466576f, -0.04282747f, 0.00236985f, 0.03617248f, 
    0.00563347f, -0.02899795f, -0.02151374f, -0.01181151f, -0.06392894f, 0.02115233f, 0.00078800f, -0.01217794f, 
    0.03519258f, -0.00039437f, -0.00122617f, -0.00325347f, 0.00534642f, -0.03340853f, 0.04981173f, -0.04828119f, 
    0.02035489f, 0.04990029f, -0.03119462f, 0.03079153f, 0.02779518f, -0.02711018f, 0.04996339f, 0.02948319f, 
    -0.00170092f, 0.00025930f, 0.03653098f, 0.02448735f, -0.05158132f, -0.02458668f, -0.00196977f, 0.01682789f, 
    -0.21166116f, -0.39802033f, 0.07234358f, -0.00403534f, -0.16708305f, -0.12756810f, 0.00093178f, -0.23704992f, 
    -0.04777718f, -0.20447214f, -0.09796953f, 0.12854588f, -0.14824423f, -0.23128451f, 0.02307276f, 0.01360300f, 
    0.26075184f, -0.24057709f, 0.07356104f, 0.02620964f, -0.02326934f, 0.05171715f, -0.08625212f, -0.13247815f, 
    -0.00213160f, 0.03690643f, 0.05570888f, -0.02256309f, 0.06814732f, 0.34755298f, -0.15082033f, 0.02979616f, 
    0.20845070f, 0.16764544f, 0.02052526f, -0.00910678f, -0.22966991f, -0.35409442f, -0.30311784f, 0.10041545f, 
    0.03754444f, -0.27487159f, 0.02391709f, 0.11016905f, -0.07913723f, -0.19441910f, -0.00437981f, 0.40239963f, 
    -0.13067698f, -0.12141909f, 0.08248386f, -0.04199297f, -0.01850465f, 0.09487846f, 0.25674149f, -0.17569922f, 
    -0.30769607f, 0.10324126f, -0.26450080f, -0.15198611f, 0.08011249f, 0.16075356f, -0.07744071f, -0.09576014f, 
    -0.12668706f, -0.09112167f, -0.20539473f, -0.31856102f, -0.26676250f, -0.09951475f, -0.14769159f, -0.22573611f, 
    0.04805603f, 0.08653729f, 0.04309784f, -0.07882316f, -0.00888479f, -0.12071619f, 0.00554404f, -0.00308477f, 
    0.15727639f, -0.27695456f, -0.25604302f, 0.19798394f, 0.00027696f, -0.07312398f, -0.08012944f, 0.19356106f, 
    -0.07470921f, 0.03036167f, 0.00591001f, -0.50736088f, -0.26622397f, -0.04509158f, -0.01219836f, -0.09296045f, 
    0.13376531f, -0.00179707f, 0.04601374f, 0.03613061f, 0.05181611f, 0.22221786f, 0.00984646f, 0.01243572f, 
    0.17370151f, 0.14243533f, 0.08205055f, 0.17502823f, -0.46362451f, -0.12551439f, 0.27706876f, -0.10472427f, 
    0.03342772f, -0.08984403f, -0.06410301f, 0.06475830f, -0.04864491f, 0.13145475f, 0.02168007f, 0.24518433f, 
    0.12304597f, 0.10833467f, 0.11899203f, 0.13912790f, 0.07091932f, 0.19696958f, 0.01579774f, 0.22743736f, 
    -0.06965791f, 0.06479791f, 0.08626674f, 0.14794257f, 0.02603136f, 0.13923518f, 0.05239207f, -0.05140211f, 
    0.11073931f, -0.09057919f, -0.06418817f, 0.02580313f, -0.07555127f, 0.18686284f, 0.05332124f, -0.06100734f, 
    -0.36134434f, -0.37815344f, -0.33727977f, -0.05176266f, 0.05124662f, -0.11634661f, 0.05516855f, 0.05582898f, 
    -0.00665898f, 0.33140582f, -0.22700462f, -0.30497891f, -0.03920908f, -0.06656174f, 0.02423703f, 0.12233442f, 
    -0.02499451f, 0.14400020f, 0.13512318f, -0.26297301f, -0.05683752f, 0.10705192f, 0.00328251f, -0.02512651f, 
    0.15513340f, 0.08741166f, 0.07830376f, 0.05248512f, 0.02593906f, -0.10325827f, -0.11931072f, 0.13027562f, 
    0.06668657f, 0.15471476f, 0.14958178f, -0.02057361f, 0.31611052f, -0.32911834f, -0.40302837f, -0.09617847f, 
    0.02724277f, 0.03441327f, 0.01851345f, -0.00993499f, 0.20623675f, -0.18846920f, -0.10561644f, 0.14412783f, 
    -0.05993096f, -0.08515091f, 0.04186781f, 0.10061537f, -0.04621704f, 0.03774742f, -0.28486884f, -0.64473307f, 
    0.04187635f, -0.17248330f, 0.07229866f, -0.23127176f, -0.12152807f, -0.08771516f, 0.03531671f, -0.17394198f, 
    0.02980681f, 0.36650482f, 0.03243905f, 0.13511802f, 0.02700306f, -0.07292958f, 0.20364055f, 0.05896856f, 
    0.00015277f, 0.02894204f, 0.15685244f, 0.05939962f, 0.22451465f, 0.04340271f, -0.11927828f, -0.00544616f, 
    0.05352785f, -0.23588254f, -0.00318359f, 0.15786669f, -0.15408218f, 0.04747284f, -0.31217611f, 0.07933829f, 
    0.10519669f, 0.02722031f, 0.02461408f, -0.18307228f, -0.08345527f, 0.05599977f, -0.04466781f, -0.00942531f, 
    0.01650450f, 0.01243029f, 0.12269963f, -0.18743032f, -0.04506586f, 0.19975081f, -0.03132374f, 0.05112562f, 
    -0.09557512f, 0.15024199f, -0.09874585f, 0.14556545f, -0.17021456f, -0.09170704f, -0.04543660f, -0.16802868f, 
    -0.26390350f, -0.10787407f, 0.02979716f, -0.04267835f, 0.04764977f, 0.12752853f, -0.27914265f, -0.08565916f, 
    -0.09038150f, -0.28263664f, -0.21565172f, -0.02996878f, 0.03174645f, 0.07518680f, -0.00486943f, 0.09288841f, 
    -0.00154284f, 0.18813363f, -0.02645572f, -0.22779050f, 0.14693730f, 0.16429020f, -0.03713305f, -0.11792041f, 
    -0.02461520f, 0.00161704f, -0.02829906f, 0.02406938f, -0.05195219f, 0.12669849f, 0.04981005f, 0.27582505f, 
    -0.62661135f, -0.37603477f, 0.08569017f, -0.17905618f, 0.04075915f, -0.00969515f, 0.16110949f, 0.20427996f, 
    0.11640270f, 0.22803374f, -0.01255929f, -0.05220319f, 0.03617356f, 0.04726154f, 0.02379634f, 0.01562226f, 
    -0.13037536f, -0.19071434f, -0.04637156f, -0.26358417f, 0.05885882f, 0.03509138f, -0.07209034f, -0.08323524f, 
    0.12187963f, -0.18644865f, 0.21164860f, 0.29325023f, -0.12441859f, -0.06506751f, 0.10685311f, 0.00097440f, 
    -0.06555001f, -0.07001550f, -0.01713685f, 0.00686796f, 0.07993227f, -0.11025345f, 0.10897265f, -0.03885386f, 
    -0.02407024f, -0.09562292f, 0.05700536f, 0.07495445f, 0.14626347f, 0.07388560f, 0.00145192f, -0.26123405f, 
    -0.01669894f, 0.01764122f, -0.00952317f, -0.00523634f, -0.01780937f, -0.19991425f, -0.09383518f, -0.30862835f, 
    -0.29805192f, 0.23788148f, 0.10724829f, 0.00304492f, 0.04726616f, 0.11983462f, 0.01590214f, -0.20792493f, 
    -0.14039430f, 0.30249792f, -0.26992261f, -0.08286646f, -0.05468620f, 0.08326232f, -0.02291180f, -0.04730838f, 
    -0.20040636f, 0.02874273f, -0.13855071f, -0.09575778f, -0.14969364f, 0.01639161f, 0.02509485f, 0.09400663f, 
    0.21543765f, -0.53740644f, -0.21507734f, 0.24781440f, -0.23898421f, 0.01225983f, 0.15492536f, 0.14989451f, 
    0.14737849f, 0.19449565f, 0.24368000f, -0.03282962f, -0.11210892f, 0.01654728f, -0.09746789f, 0.09834387f, 
    0.04177910f, 0.01235882f, 0.11600988f, -0.17740011f, -0.21359491f, 0.00017150f, 0.11785223f, -0.02662897f, 
    0.04466532f, 0.05187073f, 0.15419202f, 0.21145357f, 0.15589434f, -0.15532267f, -0.21515660f, 0.09304231f, 
    0.08982465f, 0.02603669f, -0.00547035f, 0.09691592f, -0.05377590f, 0.16406178f, 0.06632830f, 0.26616693f, 
    -0.00315417f, -0.24699309f, -0.02064919f, 0.11144260f, 0.08498128f, 0.23615789f, -0.35896644f, -0.17366977f, 
    0.02193050f, 0.07556425f, -0.02700073f, 0.01377783f, 0.14163791f, 0.01914328f, 0.10076420f, -0.18290204f, 
    -0.22293131f, 0.03200385f, -0.12132662f, -0.26602390f, 0.00240146f, 0.01229374f, 0.20704092f, 0.23546070f, 
    0.02753958f, -0.16341962f, -0.30228192f, 0.08336510f, -0.08557861f, -0.06562623f, 0.14298351f, 0.09171853f, 
    0.22849950f, 0.00356715f, -0.08746348f, -0.00969116f, -0.04700462f, 0.05606603f, 0.19433872f, 0.09268885f, 
    -0.00164943f, -0.01314040f, -0.01909500f, -0.19995467f, 0.15575337f, -0.10311712f, 0.05259859f, 0.18120988f, 
    0.07439055f, -0.07433005f, 0.03436242f, -0.18500665f, -0.19242218f, 0.07249139f, -0.07578304f, 0.08294957f, 
    -0.01337250f, 0.14211248f, 0.07016381f, 0.03793291f, 0.49917251f, 0.20268479f, 0.20899825f, -0.20444560f, 
    -0.05265648f, -0.24141823f, -0.07154313f, -0.03875547f, -0.02683954f, 0.06983148f, 0.14939617f, -0.17396662f, 
    0.03708267f, 0.01379948f, 0.00784162f, -0.01109132f, 0.07451046f, -0.21653330f, 0.27682248f, 0.33101594f, 
    -0.39397299f, 0.17973781f, 0.06800018f, -0.04376397f, -0.03733655f, 0.05186705f, -0.00733314f, -0.64287156f, 
    -0.14061853f, 0.17586592f, -0.27321136f, -0.00276071f, 0.01327270f, 0.10583149f, -0.03777748f, 0.04120237f, 
    0.22269082f, 0.05780677f, 0.07817377f, -0.07121541f, -0.15462670f, -0.03123452f, 0.08399531f, -0.10910622f, 
    0.20929995f, 0.19610304f, 0.08470938f, 0.11573247f, 0.12222183f, -0.18630753f, -0.04298554f, -0.06676266f, 
    0.03558746f, 0.16213688f, -0.15530697f, -0.09055642f, -0.02293650f, 0.06408467f, -0.03021693f, 0.08542455f, 
    0.18006440f, 0.04538621f, 0.05470837f, -0.20508128f, -0.32313380f, 0.02714312f, -0.17648570f, -0.23946780f, 
    -0.00073256f, 0.05015638f, 0.03043360f, -0.04610567f, -0.16100296f, -0.12252721f, -0.02437842f, 0.00875824f, 
    0.02279572f, -0.04534363f, -0.05242532f, -0.00751519f, 0.13516413f, 0.07618263f, -0.41870791f, 0.21876833f, 
    -0.25382721f, 0.07963224f, 0.29347941f, -0.01829646f, 0.24965075f, 0.26352364f, -0.19799377f, 0.18163648f, 
    0.23341379f, -0.24168140f, 0.09086336f, 0.07702633f, 0.09106854f, -0.00003699f, 0.03381675f, -0.05399506f, 
    0.07773826f, 0.17786734f, -0.14665751f, -0.17909747f, -0.18359815f, -0.00950311f, 0.00815852f, -0.09149904f, 
    0.15927385f, -0.14372261f, -0.29989177f, 0.12744355f, -0.12074374f, 0.00714932f, -0.00453549f, 0.00191300f, 
    -0.01812497f, -0.07543556f, -0.03232103f, 0.09929761f, -0.17561604f, -0.05169069f, -0.05295943f, 0.09052056f, 
    -0.04654901f, 0.13308747f, -0.09591612f, 0.04628849f, 0.05004064f, -0.09032936f, 0.14386269f, -0.01396483f, 
    0.00007304f, 0.03396339f, 0.08276705f, 0.08920370f, 0.07999334f, 0.32059076f, -0.03707506f, -0.07702973f, 
    0.04894647f, 0.18839952f, 0.04782147f, 0.21733852f, -0.13587172f, -0.23082967f, 0.18541637f, -0.09417196f, 
    -0.25281715f, 0.01548574f, 0.04563527f, 0.06865292f, -0.02919959f, 0.04878506f, -0.04612438f, 0.21754888f, 
    -0.03689881f, 0.11591112f, -0.11256324f, 0.06816126f, 0.01225664f, 0.14865342f, 0.05152246f, -0.45792854f, 
    -0.03920359f, -0.09473638f, 0.02332412f, 0.07469105f, -0.01921719f, 0.02664540f, -0.28007773f, -0.03050587f, 
    -0.03522374f, -0.23545210f, -0.20309578f, -0.13000017f, -0.19528177f, 0.00844510f, 0.11149868f, -0.04294241f, 
    0.18500310f, -0.41878259f, 0.31508631f, 0.08570137f, 0.17355357f, 0.15732877f, -0.08514597f, -0.01726949f, 
    0.15061150f, 0.26264697f, -0.06591833f, -0.36111146f, 0.06140171f, 0.05192243f, 0.06761994f, -0.03713638f, 
    -0.03239482f, 0.00381576f, -0.20368786f, -0.06537370f, -0.13439459f, -0.19188192f, 0.01670567f, -0.09021464f, 
    0.02001668f, -0.10774557f, 0.03483344f, 0.02539461f, 0.01849392f, 0.20936304f, -0.00998606f, 0.01826132f, 
    -0.15808587f, -0.00294687f, 0.04394170f, 0.16218911f, -0.36240768f, -0.18547750f, 0.36449197f, 0.18663290f, 
    0.01202659f, -0.05296575f, 0.04745174f, 0.01003242f, 0.03305347f, 0.09357487f, 0.01003752f, 0.03895459f, 
    0.05671050f, 0.10314983f, 0.07967649f, 0.15171634f, 0.08495213f, 0.17101364f, 0.02269007f, 0.06035468f, 
    0.05866058f, 0.20550431f, 0.09919588f, 0.13190722f, 0.07840704f, 0.01307959f, 0.16056094f, 0.21879084f, 
    -0.19783062f, -0.35410973f, -0.16786389f, -0.03406687f, -0.09166894f, -0.00040348f, 0.06375334f, 0.09121145f, 
    -0.03392761f, -0.00428748f, 0.13093863f, -0.20232730f, -0.09281483f, 0.01328566f, -0.08714807f, -0.02202339f, 
    0.06839875f, -0.22930340f, 0.16762987f, -0.21214630f, 0.05517522f, 0.12597752f, 0.23592883f, 0.01637961f, 
    -0.04742084f, 0.03900946f, -0.05481856f, 0.12322386f, -0.36349842f, 0.02719606f, 0.00320712f, 0.05088651f, 
    0.12667930f, 0.08097500f, 0.14748375f, 0.02278854f, 0.22774845f, 0.04225131f, 0.16374303f, -0.03064879f, 
    0.02558038f, 0.06796862f, 0.07325336f, 0.02097289f, -0.06570363f, -0.14497507f, -0.75965506f, -0.26567802f, 
    0.03872470f, 0.04615794f, 0.05602285f, 0.00918857f, -0.01616014f, 0.11648370f, -0.20641755f, -0.14856757f, 
    -0.12061702f, 0.18385756f, -0.05891754f, 0.17563277f, 0.08904822f, 0.19688241f, -0.37920770f, -0.10477365f, 
    -0.40567487f, -0.11980294f, -0.16711539f, -0.11947890f, 0.11922737f, -0.03288262f, 0.09929041f, 0.31153205f, 
    -0.00933807f, 0.02140306f, 0.20468807f, 0.10529440f, 0.25500467f, 0.01787964f, 0.08197105f, -0.02768723f, 
    -0.15176284f, -0.26470575f, 0.03294021f, 0.07589362f, 0.19388889f, -0.09423453f, 0.08108800f, 0.30601278f, 
    0.26181540f, -0.27437398f, -0.37587589f, -0.03032107f, -0.05941517f, 0.16690938f, -0.12687519f, -0.00468124f, 
    -0.03229722f, -0.08481032f, -0.08409490f, -0.02447096f, 0.14574596f, -0.01838947f, 0.06482463f, -0.03927208f, 
    -0.00622764f, -0.04416339f, 0.00403747f, -0.18881844f, -0.66499102f, -0.33177224f, -0.03076326f, -0.04317452f, 
    0.09254133f, 0.11347743f, -0.07988666f, -0.00151656f, -0.11781788f, -0.03543733f, 0.04861579f, -0.06617873f, 
    -0.07569933f, -0.06993921f, 0.07379659f, 0.13280064f, 0.01538897f, -0.27723038f, -0.12803882f, -0.15506880f, 
    -0.10142500f, -0.03101818f, 0.02303724f, -0.00840525f, 0.18418914f, -0.23722206f, -0.39812216f, -0.04296778f, 
    -0.31610039f, -0.14364970f, 0.06454115f, 0.07995202f, 0.07716657f, -0.00178476f, -0.03076194f, -0.29796043f, 
    -0.06684103f, -0.42057332f, -0.08056114f, -0.11888494f, 0.13868201f, 0.11278993f, -0.00568729f, 0.14729445f, 
    0.19976820f, 0.28738314f, 0.38975507f, 0.04041605f, 0.04732923f, -0.02199379f, -0.08111366f, 0.11081998f, 
    -0.01177837f, -0.09210619f, 0.07140259f, 0.22773153f, 0.03652477f, -0.04777032f, -0.17610754f, -0.03021867f, 
    -0.07626130f, -0.15929292f, 0.03182616f, -0.11917493f, 0.28957087f, -0.11370628f, -0.10798942f, 0.03618508f, 
    0.00982746f, 0.02006515f, 0.13988815f, 0.03175645f, -0.01355833f, -0.02704393f, -0.12792952f, -0.04888205f, 
    -0.12966760f, -0.01827804f, 0.02714603f, -0.16153564f, -0.37699795f, -0.10616268f, -0.21567178f, -0.08916716f, 
    -0.23074289f, 0.06198978f, -0.02064472f, 0.00087275f, -0.15174380f, -0.18603981f, 0.11641089f, 0.13466622f, 
    0.06900651f, -0.09381422f, -0.23329881f, -0.02280696f, -0.06495483f, -0.18858089f, -0.03440018f, 0.06877145f, 
    -0.00384895f, -0.12998657f, -0.00828388f, 0.19094923f, -0.15478802f, -0.14474116f, -0.07796665f, 0.14619058f, 
    0.19173022f, 0.27602136f, -0.00184166f, 0.02694944f, -0.02078260f, 0.02071300f, 0.08951880f, -0.03886307f, 
    -0.22907260f, -0.08991589f, -0.16842137f, 0.02279454f, -0.19185112f, -0.02472232f, -0.07072593f, 0.02291320f, 
    0.13454002f, 0.22896168f, 0.30580986f, 0.32342231f, 0.00761754f, 0.03732394f, 0.03950104f, 0.00996487f, 
    0.10042249f, -0.00065468f, 0.01810587f, 0.10966435f, 0.06964877f, -0.25556061f, -0.09672525f, -0.06399683f, 
    -0.07234939f, -0.01137333f, 0.02159960f, -0.13189873f, -0.08343482f, 0.15522198f, 0.05571038f, 0.07412693f, 
    0.00302862f, 0.00434627f, 0.12317542f, -0.10190497f, -0.12541774f, -0.34086430f, 0.06101723f, 0.13758381f, 
    -0.02693988f, 0.01743234f, 0.06286690f, 0.10312095f, -0.04106920f, 0.06700495f, -0.00502714f, -0.13656773f, 
    -0.08236621f, 0.07484420f, -0.14536987f, -0.03343997f, 0.15190601f, -0.30443916f, 0.02146772f, 0.01341411f, 
    0.16741620f, -0.02465032f, 0.09678072f, 0.11296872f, -0.06927852f, 0.06576671f, -0.10851885f, 0.20363440f, 
    0.02691618f, 0.31043476f, -0.15563923f, -0.03845823f, 0.05313240f, 0.06274760f, -0.10703215f, 0.16147703f, 
    0.06594165f, -0.03116884f, 0.13036680f, -0.24209251f, -0.08174717f, -0.10535325f, 0.03963348f, 0.02939523f, 
    0.12495744f, 0.00229523f, 0.08700449f, 0.00337705f, -0.14038579f, -0.01501307f, -0.13819025f, -0.09853750f, 
    0.04991493f, 0.01108866f, -0.00271523f, -0.17652532f, -0.00056402f, -0.10310655f, -0.06550727f, -0.23261452f, 
    -0.01493423f, 0.01067854f, 0.03414411f, 0.11016512f, -0.00063178f, 0.22401814f, 0.05840562f, 0.10586384f, 
    0.13579915f, -0.05344321f, 0.18375079f, -0.30497304f, 0.01623883f, -0.06546357f, 0.53138423f, 0.14927180f, 
    -0.01580206f, 0.25120544f, -0.03690860f, 0.20186375f, -0.14442715f, -0.19288176f, 0.08487312f, -0.16259816f, 
    0.20454755f, -0.15296525f, -0.20011421f, 0.03170817f, -0.07323860f, 0.05594719f, -0.26927057f, -0.23254235f, 
    -0.17772488f, 0.13641000f, -0.00975059f, -0.10556149f, 0.06606945f, 0.05024303f, 0.07793807f, 0.19289897f, 
    0.00618473f, -0.11762564f, 0.08066822f, 0.07938520f, 0.02160280f, 0.06263414f, -0.04051493f, -0.14440116f, 
    -0.09501113f, -0.04308257f, -0.14755337f, -0.14244422f, -0.17132053f, -0.06563965f, 0.19900987f, -0.15428293f, 
    -0.16138038f, 0.15761170f, -0.07033619f, -0.50849056f, -0.14616972f, -0.20473474f, -0.13421337f, -0.02403359f, 
    0.05296608f, -0.11660486f, -0.08236109f, -0.07720768f, -0.02518936f, 0.02312575f, -0.06839903f, -0.04924903f, 
    -0.12499528f, -0.06113941f, 0.05967271f, 0.04483502f, -0.04312775f, 0.23166364f, 0.08581440f, 0.00912928f, 
    0.11799968f, 0.09900570f, 0.10691029f, -0.02099323f, 0.02638590f, -0.02151867f, 0.21795197f, -0.06872130f, 
    -0.03364411f, 0.10851797f, 0.10974180f, 0.16206178f, 0.15543446f, 0.11912951f, -0.02241558f, 0.23935899f, 
    0.13687409f, -0.05061520f, -0.08359959f, -0.05783275f, 0.07498682f, -0.03300291f, 0.01019468f, -0.05563707f, 
    0.28164849f, 0.01170437f, 0.07384274f, 0.01358761f, 0.07317501f, -0.07201742f, 0.06014571f, 0.21336235f, 
    -0.02418202f, 0.21834788f, 0.11112068f, -0.02968376f, 0.07490988f, 0.03804975f, 0.06102525f, -0.01178658f, 
    0.47287312f, -0.06956281f, -0.01475471f, -0.13542190f, -0.09342308f, 0.01020621f, -0.09989344f, 0.06326027f, 
    -0.16800307f, -0.42893836f, 0.04067582f, -0.18193579f, 0.01191558f, -0.07039384f, -0.03346368f, -0.02441194f, 
    0.09092741f, 0.13730440f, 0.07771524f, 0.16253509f, 0.09302340f, -0.02559775f, -0.05973050f, -0.09222033f, 
    -0.05555024f, -0.01836725f, 0.06956922f, 0.05804301f, -0.11906175f, -0.01189287f, -0.00954687f, -0.00355417f, 
    -0.07049980f, -0.06562111f, -0.03177460f, 0.11543234f, 0.21080326f, 0.03279802f, -0.93180180f, 0.07534814f, 
    0.08203109f, -0.03830502f, 0.09088374f, -0.11838621f, -0.04332386f, -0.07380852f, -0.33103243f, -0.39187300f, 
    -0.06322172f, -0.20614842f, -0.05018932f, -0.06970926f, 0.16034923f, 0.00072105f, 0.00333786f, -0.05939237f, 
    -0.05919650f, -0.01797265f, 0.03714683f, -0.05382361f, -0.01239400f, -0.24756603f, -0.02419522f, 0.31462803f, 
    -0.10047113f, 0.05846194f, -0.09661748f, -0.18107241f, -0.14692499f, -0.15709731f, 0.01857913f, -0.10928779f, 
    0.51998442f, 0.12891600f, -0.39051422f, 0.06970825f, 0.04474739f, 0.15630130f, 0.34264606f, -0.05122472f, 
    0.11362520f, 0.59764105f, -0.15191802f, -0.13768961f, -0.01101156f, 0.03206358f, 0.08493683f, -0.13401106f, 
    0.15920278f, -0.18933165f, -0.78473407f, -0.33487090f, -0.27935967f, 0.02599353f, 0.01576485f, -0.12308948f, 
    -0.07108598f, -0.01971676f, -0.01532959f, -0.23960765f, 0.00343249f, 0.06777240f, -0.02841129f, 0.04374240f, 
    0.14658546f, 0.00256643f, 0.00051038f, -0.07531826f, 0.04937726f, -0.32868803f, -0.01974243f, -0.14120467f, 
    -0.05577918f, -0.04009782f, 0.04830369f, 0.05311606f, -0.03282475f, 0.07963106f, 0.03589892f, 0.12297561f, 
    0.02790271f, -0.02431962f, -0.04617237f, 0.08623000f, 0.05558693f, 0.19050770f, 0.18591623f, 0.06140200f, 
    0.01104939f, 0.04983341f, 0.03373094f, -0.00006331f, 0.11080126f, 0.21577923f, 0.05599572f, 0.52319551f, 
    0.04488844f, 0.02145724f, 0.05534939f, -0.13849120f, -0.14701471f, -0.04766349f, 0.05784986f, 0.03952173f, 
    -0.51747102f, -0.08899657f, -0.82843935f, 0.05822076f, -0.02157167f, -0.25802371f, -0.04966599f, -0.08594633f, 
    0.02978192f, -0.24607641f, -0.14010449f, -0.28547513f, 0.01292205f, 0.15844496f, 0.07648349f, 0.03868547f, 
    -0.04971473f, 0.00306499f, -0.28587574f, -0.28436607f, -0.74553281f, -0.00815158f, 0.06355555f, 0.06539712f, 
    -0.03446415f, 0.01508429f, 0.00403935f, 0.10732925f, 0.08628013f, 0.17418492f, 0.10634234f, 0.00435199f, 
    0.13069147f, 0.05896624f, 0.00712413f, 0.01664314f, -0.27866626f, 0.09059022f, -0.07810993f, -0.05554898f, 
    -0.15066335f, 0.05502712f, 0.10669737f, 0.01604690f, -0.08852787f, 0.02179373f, -0.40262759f, -0.25049624f, 
    -0.02202963f, -0.21824515f, 0.04445954f, 0.11202366f, 0.23254256f, -0.05294827f, -0.31089959f, -0.50783181f, 
    -0.44386682f, -0.19391876f, -0.08703320f, -0.02401383f, -0.08542433f, 0.03355622f, 0.07614793f, 0.40108728f, 
    -0.15728667f, -0.06629305f, 0.05052587f, -0.02935200f, 0.01918336f, 0.00726535f, 0.07656118f, -0.09742636f, 
    -0.20389955f, 0.03399053f, 0.14137104f, -0.08708660f, 0.00217250f, 0.05809160f, 0.18684074f, -0.16699027f, 
    0.29460847f, -0.52484381f, -0.33269683f, 0.36407593f, -0.19149059f, 0.18997166f, -0.04235794f, 0.03886186f, 
    0.08454366f, 0.00705494f, -0.31234947f, -0.06651694f, 0.02242053f, 0.03589517f, 0.00195199f, -0.08989285f, 
    0.01687253f, -0.00877970f, -0.18438615f, 0.18010114f, -0.24692947f, -0.19195993f, -0.12654284f, 0.10226786f, 
    0.17688525f, 0.02582251f, -0.01547319f, -0.05754667f, -0.07551584f, -0.04262133f, 0.12396672f, -0.02137047f, 
    -0.04571489f, -0.04556064f, 0.05837266f, 0.00058786f, -0.01011470f, -0.15718096f, -0.08402840f, 0.09560952f, 
    -0.05181355f, -0.09495090f, 0.06897797f, 0.12007995f, -0.09840529f, -0.02908230f, -0.00184181f, 0.09351692f, 
    0.13050720f, -0.10059743f, 0.16633302f, 0.02622085f, 0.17709205f, -0.11553735f, 0.05101233f, -0.00724542f, 
    0.12717065f, 0.12676772f, -0.09063839f, -0.01307733f, 0.16340749f, 0.13933527f, 0.09720500f, -0.02136570f, 
    0.13109396f, 0.06402516f, -0.14298742f, -0.16410464f, -0.19123240f, -0.12035891f, -0.10770216f, -0.12089735f, 
    -0.18155302f, -0.08780728f, -0.37458056f, -0.50355071f, -0.04941056f, 0.01054435f, -0.00944614f, 0.07454796f, 
    0.09258831f, 0.24166521f, 0.14262512f, 0.19374247f, -0.04788516f, 0.13294345f, -0.02003565f, -0.04499340f, 
    -0.00688562f, 0.10645483f, 0.04860276f, -0.28994194f, -0.12209392f, -0.04595932f, 0.13632731f, 0.04180690f, 
    0.10542396f, -0.03760765f, 0.07735450f, 0.08247248f, -0.21433748f, 0.11501487f, 0.20384198f, 0.18084025f, 
    -0.04666486f, -0.00423901f, 0.10729998f, -0.06784961f, 0.23093846f, -0.19061832f, -0.18888000f, 0.05059769f, 
    -0.06524435f, -0.01930843f, 0.12436397f, 0.04395609f, 0.03724238f, 0.05744857f, -0.00534850f, -0.14474486f, 
    0.03304052f, -0.01460357f, -0.05153786f, -0.12892385f, 0.10829977f, -0.06937566f, -0.16488028f, 0.05613459f, 
    0.15846477f, -0.09237788f, -0.05732610f, -0.02548144f, -0.04270533f, -0.20170696f, 0.02463147f, -0.15358736f, 
    -0.26438111f, 0.23126076f, 0.21431519f, -0.06464614f, 0.09974720f, -0.14256881f, 0.07830347f, -0.01973541f, 
    0.14442246f, 0.10793566f, 0.24681672f, 0.02577174f, -0.08679708f, -0.10452373f, -0.08353703f, -0.10539628f, 
    -0.14513324f, -0.17910771f, 0.07348908f, -0.12431780f, 0.02624835f, 0.24888156f, -0.00567345f, 0.13766606f, 
    -0.03458888f, 0.01869687f, -0.14438307f, 0.01336067f, -0.15250635f, -0.03529573f, 0.00150483f, 0.03436600f, 
    0.02047098f, -0.12377685f, -0.03629418f, -0.19362925f, 0.04035484f, -0.09432446f, 0.16573732f, -0.00165050f, 
    -0.14694619f, -0.08415029f, -0.00986557f, -0.09867910f, 0.01946161f, 0.15139405f, 0.25736204f, 0.09798504f, 
    0.16182119f, 0.02434968f, 0.21418953f, 0.04193611f, 0.08829555f, 0.08356888f, 0.13688453f, 0.04107996f, 
    -0.09659018f, -0.05833364f, -0.05543728f, -0.05900840f, -0.01260325f, 0.09537443f, -0.18303478f, 0.14699849f, 
    0.21124122f, -0.18755460f, 0.07933768f, -0.19451611f, -0.16002795f, 0.02493106f, -0.05622817f, -0.03086011f, 
    -0.10351613f, 0.00156283f, 0.14332575f, 0.12590639f, 0.10256661f, 0.09254188f, 0.02289472f, -0.05245359f, 
    -0.07906665f, 0.04740004f, -0.03049593f, 0.02459366f, 0.17395063f, 0.01295318f, -0.03190295f, 0.03691433f, 
    0.00097472f, -0.08291716f, 0.14963196f, 0.21716192f, 0.18076995f, 0.26856673f, 0.03462448f, 0.00248406f, 
    -0.00777746f, 0.05496402f, 0.07220950f, 0.17119133f, -0.08423615f, -0.13441554f, 0.10781048f, 0.02494174f, 
    0.12346318f, -0.03410392f, -0.11312529f, -0.11951817f, 0.21342278f, 0.09607713f, -0.25048098f, 0.05079653f, 
    -0.11567982f, 0.16381387f, 0.00997487f, -0.12623322f, -0.01882970f, -0.15398099f, -0.12172343f, 0.09181801f, 
    0.00040946f, 0.06224727f, 0.02014837f, 0.07705127f, 0.08750646f, 0.06759287f, 0.11366138f, -0.05947378f, 
    0.18638252f, 0.11768517f, -0.11962342f, 0.10106602f, -0.13787922f, 0.04023905f, 0.13803120f, 0.18714984f, 
    0.30858514f, 0.13924554f, 0.06242505f, 0.00122224f, -0.09590103f, 0.05401180f, -0.03559577f, 0.02070325f, 
    0.14415099f, 0.26547834f, -0.10151967f, -0.02628696f, 0.21255420f, 0.10039775f, -0.02127822f, 0.05182461f, 
    0.29262024f, 0.23116848f, 0.07835958f, -0.19932093f, -0.00185296f, 0.06440023f, 0.03073414f, 0.00751776f, 
    -0.04023166f, 0.06994096f, -0.05774035f, -0.17294070f, -0.00116135f, 0.04243938f, -0.01864416f, -0.00190268f, 
    0.04719213f, 0.08060078f, -0.47870162f, 0.21171294f, 0.19980751f, 0.34692669f, 0.11856045f, -0.02786900f, 
    -0.20071864f, -0.10758117f, -0.06021509f, 0.10358345f, -0.04397634f, 0.10476848f, -0.19863334f, -0.03649372f, 
    0.05380832f, 0.04079297f, -0.01730956f, 0.00247843f, -0.03168297f, 0.11115281f, -0.14261279f, -0.36961165f, 
    0.09195620f, -0.02081081f, -0.07664155f, -0.00958304f, 0.00523554f, 0.01863957f, 0.23005278f, 0.14058210f, 
    0.02400893f, -0.10641317f, -0.22395791f, -0.04412965f, 0.03096288f, -0.04411211f, 0.18139236f, 0.01344684f, 
    0.02958033f, -0.01117557f, 0.06300957f, -0.20876673f, 0.07962433f, 0.06723347f, 0.13685180f, 0.08905044f, 
    -0.01510282f, -0.05874386f, -0.05836139f, -0.21213737f, -0.00271874f, 0.00004499f, -0.07763676f, -0.01954707f, 
    -0.05855137f, -0.42387339f, 0.12992254f, -0.31415239f, 0.11169047f, -0.13784961f, -0.14838037f, 0.05420785f, 
    0.01820937f, 0.14722304f, -0.39635125f, -0.20313087f, -0.08842541f, 0.10985947f, -0.09969939f, -0.11418197f, 
    -0.02659565f, 0.04965651f, 0.14373173f, -0.00955842f, -0.19212113f, 0.02639518f, -0.04499883f, -0.10930443f, 
    0.00484142f, 0.04921260f, 0.07427157f, 0.24270359f, 0.12963648f, 0.17274551f, 0.41993710f, -0.09738112f, 
    0.08404538f, -0.10202225f, 0.33092180f, -0.14868146f, 0.07352909f, -0.35909072f, 0.26159331f, 0.20740755f, 
    -0.07029058f, -0.00811587f, 0.14194809f, 0.18771854f, 0.17180067f, -0.01669426f, -0.19697803f, -0.04982566f, 
    0.01451220f, -0.28582087f, 0.08369603f, -0.06185122f, 0.01360239f, -0.04699083f, 0.13994575f, -0.09157399f, 
    -0.09323648f, 0.09790940f, -0.07213663f, 0.07386975f, -0.12749614f, 0.17399447f, 0.07246426f, -0.01481073f, 
    0.24961814f, -0.11072050f, 0.12836309f, -0.04024002f, 0.04707144f, 0.09105231f, 0.13449888f, 0.08652163f, 
    0.21197920f, -0.03434807f, -0.03065417f, -0.11198846f, -0.12070446f, -0.03777061f, 0.03115373f, -0.05608197f, 
    -0.01075802f, 0.01484215f, 0.06533543f, 0.02930787f, 0.48942265f, 0.04242281f, 0.02646662f, -0.20448670f, 
    0.02451182f, -0.31409007f, -0.06721505f, -0.13362774f, -0.10925373f, 0.16471949f, 0.04549849f, 0.10593449f, 
    0.15973088f, 0.07679905f, 0.07797972f, 0.17302771f, -0.04504389f, 0.03118372f, 0.38017538f, -0.10035670f, 
    -0.01831192f, 0.07045507f, 0.00471813f, -0.02707052f, -0.06474452f, 0.05647017f, -0.07475286f, 0.27961749f, 
    -0.12808695f, 0.11585060f, -0.12769333f, 0.04350984f, -0.06387953f, 0.17758028f, -0.09997289f, -0.20341177f, 
    -0.01949077f, 0.01043487f, -0.13309623f, -0.02601953f, -0.02604208f, 0.16033156f, 0.12728293f, -0.06975282f, 
    0.11387406f, 0.20268138f, -0.02059518f, -0.12592256f, 0.06574703f, 0.00000429f, -0.02860593f, 0.21883957f, 
    0.05742559f, 0.00422657f, 0.61113393f, -0.00371243f, 0.03381837f, -0.19006619f, 0.00585259f, -0.23094963f, 
    -0.01525399f, 0.08124757f, 0.11329846f, 0.08293796f, -0.12448965f, 0.10272386f, 0.00515602f, 0.14751615f, 
    -0.10811348f, -0.15430467f, 0.06755440f, 0.05651410f, 0.22804610f, 0.01701198f, 0.01923764f, 0.09192926f, 
    -0.05265074f, -0.24272940f, -0.03527807f, 0.15613814f, 0.03377112f, -0.17370334f, 0.04247760f, 0.00281226f, 
    0.26757684f, 0.18394582f, 0.04968463f, 0.09062887f, -0.09805080f, -0.39315933f, -0.40723792f, -0.22719151f, 
    -0.17055225f, -0.19077247f, 0.02651869f, 0.19214784f, -0.03720049f, -0.33622292f, 0.28738043f, 0.26061398f, 
    0.23668304f, 0.02659599f, -0.07945030f, 0.15611194f, 0.13348784f, 0.06607635f, -0.22107247f, -0.17679401f, 
    0.37016556f, -0.16841504f, -0.10105824f, -0.07135686f, -0.01162400f, 0.12298018f, 0.15392737f, 0.36586690f, 
    -0.06047936f, 0.03037168f, 0.02338416f, 0.03630202f, 0.02215818f, 0.06650900f, -0.10571370f, 0.09991609f, 
    0.10420699f, -0.09727886f, 0.08066426f, 0.06927972f, 0.07682473f, -0.04994495f, 0.12305789f, -0.02018400f, 
    0.09476879f, 0.12858282f, -0.35819975f, 0.11796214f, -0.13915341f, -0.06697856f, -0.04383764f, 0.02976033f, 
    -0.18344720f, 0.01552449f, 0.11761416f, 0.08988981f, 0.17343101f, 0.14747083f, 0.15656039f, 0.04069617f, 
    0.04155045f, -0.13816911f, -0.11551773f, 0.12995161f, -0.05035507f, 0.45237517f, -0.06645564f, 0.17399614f, 
    0.00139079f, -0.13003886f, 0.09283211f, -0.05393575f, -0.21060984f, -0.19935989f, -0.07695568f, 0.04935678f, 
    0.02348736f, -0.03051337f, 0.13516343f, 0.19053981f, 0.15952675f, -0.16856641f, -0.05840444f, -0.25682333f, 
    -0.03460984f, -0.06762410f, 0.01956716f, 0.00990253f, 0.09813942f, -0.00449871f, -0.21087548f, 0.02506721f, 
    0.28593346f, -0.01401442f, 0.07936917f, 0.00716326f, 0.03846169f, 0.10464261f, 0.05443369f, 0.19451332f, 
    -0.23728184f, 0.10343393f, 0.12002644f, -0.08290906f, -0.01942174f, 0.03764272f, -0.05689134f, 0.01036718f, 
    -0.04770403f, -0.03798074f, 0.01955203f, 0.06571580f, 0.01343672f, -0.08745172f, 0.02848576f, -0.06376576f, 
    0.13101426f, -0.52996719f, 0.17417106f, -0.02884727f, -0.10541842f, -0.06832701f, -0.02927776f, 0.02245065f, 
    -0.19198577f, 0.04585980f, -0.33664742f, -0.02194763f, -0.09870981f, -0.08379383f, -0.08373483f, -0.02167771f, 
    0.03594403f, -0.09001397f, 0.16841151f, -0.26457804f, 0.26896113f, 0.03330045f, 0.09160163f, -0.15036629f, 
    0.02642378f, 0.03029864f, -0.07928936f, -0.01622995f, 0.14429651f, 0.28992632f, -0.04006875f, 0.11651503f, 
    0.00168243f, -0.09835414f, -0.03539535f, 0.07780576f, -0.06098721f, -0.05482572f, 0.02392269f, 0.13029334f, 
    -0.07571357f, -0.06378289f, 0.05229116f, 0.03233395f, -0.15722401f, -0.13819063f, -0.04674412f, -0.15612131f, 
    -0.17245848f, -0.00017301f, 0.18457811f, 0.06032207f, 0.21363148f, 0.15838763f, 0.05396185f, -0.21874408f, 
    -0.08944402f, 0.01372605f, 0.12280857f, -0.09113543f, -0.07600129f, 0.11883504f, 0.01431435f, -0.05019014f, 
    -0.05462556f, -0.06631163f, -0.05208639f, 0.10830223f, -0.16105151f, 0.13833526f, 0.05199902f, 0.00290637f, 
    -0.18582310f, -0.25126290f, 0.01886898f, 0.04720100f, 0.05126122f, 0.05842612f, -0.08433709f, -0.05430439f, 
    0.01971403f, -0.00664707f, 0.17723022f, 0.07365479f, 0.28940141f, -0.02674115f, 0.10078228f, 0.06494923f, 
    0.04346051f, 0.07390408f, 0.09662167f, 0.14439926f, 0.02266417f, 0.01760004f, -0.02276892f, -0.09221141f, 
    -0.07209280f, 0.08656591f, 0.04493193f, 0.08506507f, 0.14731874f, -0.01912172f, 0.28013173f, -0.18298779f, 
    -0.11910958f, -0.07824727f, 0.04164004f, 0.04316588f, -0.01852267f, -0.01215930f, 0.21000518f, 0.16476940f, 
    0.08345598f, -0.01316453f, -0.01876348f, -0.12546428f, 0.19563214f, -0.21110691f, -0.16059497f, -0.02110928f, 
    0.02136331f, 0.00036547f, -0.11532082f, 0.01404888f, -0.07731663f, 0.10447268f, -0.10389731f, -0.10098238f, 
    -0.17100552f, 0.45317033f, -0.02421818f, -0.03113463f, 0.08766623f, -0.10852697f, -0.04809143f, -0.13676959f, 
    0.11990363f, 0.31814170f, 0.30562946f, -0.08364943f, -0.08463348f, 0.05133550f, 0.03987020f, 0.02078296f, 
    0.06574892f, -0.05884334f, -0.05722958f, 0.16483590f, 0.13726291f, 0.16172458f, 0.06495580f, -0.00084784f, 
    0.04795608f, 0.03775597f, 0.07454664f, 0.02561035f, 0.21879277f, -0.08702773f, 0.10747863f, -0.00965968f, 
    0.07083608f, 0.11550413f, -0.02515044f, -0.07090237f, 0.16686176f, -0.13429533f, -0.07603712f, -0.00543046f, 
    0.02155400f, -0.09150402f, -0.09053119f, 0.01903951f, -0.49624246f, 0.21178716f, -0.05697682f, 0.09886603f, 
    -0.01499842f, -0.18516012f, -0.03792731f, 0.02746500f, 0.28568336f, -0.04828316f, -0.07551533f, 0.23006029f, 
    -0.10970390f, 0.01676488f, -0.06925130f, 0.00620197f, -0.03806866f, -0.13273369f, -0.10170677f, 0.06441287f, 
    0.27059498f, -0.11894447f, 0.19931278f, -0.21434541f, -0.00445119f, 0.02935481f, 0.04353131f, -0.29958230f, 
    0.04893560f, -0.25541285f, 0.02102561f, -0.18685350f, -0.09127424f, 0.12228009f, 0.05154492f, 0.05709770f, 
    0.05176385f, 0.00397862f, 0.08823685f, 0.02695963f, 0.02420196f, -0.01599777f, -0.16194187f, 0.14692308f, 
    -0.16826062f, -0.04564734f, 0.18324350f, 0.14209026f, -0.07380076f, 0.06190353f, 0.06170214f, -0.01812568f, 
    0.41755709f, -0.01944603f, -0.03896715f, -0.00680148f, -0.13815966f, 0.08798607f, 0.02109007f, -0.03520888f, 
    0.09724429f, 0.09099587f, 0.21401185f, 0.14643396f, -0.44469622f, -0.10685254f, 0.20706134f, -0.00668023f, 
    0.08097031f, 0.09630008f, -0.15216722f, -0.02462345f, -0.12354092f, -0.00671969f, -0.04897728f, 0.06396291f, 
    -0.01671176f, 0.00989926f, 0.03492646f, -0.07865845f, 0.11155314f, 0.02095051f, -0.03768264f, 0.15505205f, 
    0.14614756f, 0.03111671f, -0.21900074f, -0.11570367f, -0.09704946f, 0.09886454f, -0.69001627f, -0.44369215f, 
    0.12652372f, -0.22455786f, -0.04879108f, -0.26684088f, -0.04592907f, 0.03679847f, 0.02500664f, 0.09941979f, 
    -0.30398121f, -0.17028518f, -0.03200302f, 0.03794244f, -0.06672834f, -0.02747753f, 0.07447314f, 0.00130237f, 
    -0.26242182f, -0.14254545f, 0.17052560f, -0.04079731f, 0.03767085f, 0.10604040f, -0.12556010f, -0.08137236f, 
    0.09895322f, 0.05242750f, 0.04617935f, 0.19538513f, -0.14770588f, 0.15175341f, 0.06229332f, 0.03983689f, 
    0.12233532f, 0.10417496f, 0.18216968f, 0.32005957f, 0.13024619f, -0.14035822f, -0.00985582f, 0.19477031f, 
    0.03176812f, 0.01326243f, -0.02767400f, 0.02476239f, 0.01485577f, 0.13724646f, -0.08910609f, 0.01816553f, 
    -0.07138512f, 0.03169667f, -0.04936153f, -0.13169156f, 0.05569471f, -0.11326882f, -0.38756084f, -0.04167566f, 
    0.10553578f, -0.13276219f, 0.06563076f, 0.03866206f, -0.00021391f, 0.39884263f, 0.03261489f, -0.18310168f, 
    -0.11933894f, -0.10690824f, -0.07522113f, 0.05925674f, 0.03367438f, -0.14719449f, -0.12587479f, 0.12815356f, 
    -0.09721678f, 0.04410088f, -0.05171606f, 0.11308913f, 0.02870755f, 0.08198444f, -0.03868366f, -0.05373270f, 
    0.11488798f, 0.15112282f, 0.06147615f, -0.09123959f, -0.03706661f, 0.04798711f, -0.23057660f, 0.15148832f, 
    -0.24903846f, 0.16454376f, 0.07027485f, -0.01912380f, -0.06420327f, -0.10119396f, 0.11540678f, 0.01909517f, 
    -0.16597480f, -0.17048332f, -0.29384011f, 0.07167780f, 0.01644467f, 0.06187458f, 0.03566272f, -0.03789353f, 
    0.02303809f, 0.06540148f, 0.22677554f, -0.08936929f, 0.10995186f, -0.12122258f, 0.01177362f, -0.11870144f, 
    0.00193163f, -0.06013445f, -0.02414074f, 0.28330129f, 0.17813979f, -0.07379167f, -0.17346852f, -0.00306071f, 
    0.07362346f, 0.13642600f, -0.03633933f, -0.00655477f, 0.56838095f, 0.19621022f, -0.36448818f, -0.03303888f, 
    -0.23011623f, 0.00784415f, -0.11437738f, 0.00167922f, -0.20435812f, -0.05121940f, -0.03028920f, 0.22013322f, 
    0.04152673f, -0.10343471f, -0.00229783f, -0.02780122f, -0.16558276f, -0.01918354f, -0.00258711f, 0.01840366f, 
    0.05718253f, 0.10361100f, -0.03798440f, 0.00260335f, -0.05346893f, -0.02186823f, 0.05872631f, -0.14238280f, 
    0.10545167f, 0.11786344f, 0.10791256f, 0.11790794f, -0.15091014f, -0.20333739f, -0.12375452f, -0.11274706f, 
    0.14377061f, -0.00823280f, 0.13301586f, -0.09129176f, -0.00275621f, -0.01832660f, 0.05493473f, -0.17768320f, 
    -0.00436607f, -0.09107001f, -0.47115839f, -0.05755871f, -0.13217466f, 0.07506932f, 0.11047439f, -0.08123407f, 
    -0.12722990f, -0.07489949f, -0.09183590f, -0.28676319f, -0.00035884f, -0.21356267f, 0.10340352f, -0.04077754f, 
    0.04625183f, -0.08845427f, -0.06719027f, 0.04403126f, 0.09460650f, -0.15254442f, 0.18806110f, 0.03211468f, 
    -0.03778316f, -0.00060871f, 0.01120869f, -0.07610554f, 0.25827494f, 0.12771031f, 0.22455209f, -0.03330940f, 
    -0.02374976f, 0.07642370f, 0.08908316f, -0.03017713f, 0.03862850f, 0.16053881f, -0.24623983f, -0.28085116f, 
    -0.09649016f, 0.02010461f, -0.17932983f, 0.18547916f, 0.02441302f, 0.01864060f, 0.57536566f, 0.27113086f, 
    0.26760077f, -0.05993226f, -0.30090502f, -0.12847131f, 0.15553421f, 0.05033930f, -0.17382777f, -0.26608521f, 
    -0.04680806f, 0.28874135f, -0.08242756f, -0.03286881f, 0.11949249f, 0.21906686f, -0.15863547f, 0.00004553f, 
    0.03530451f, -0.07639262f, 0.29080874f, 0.10478170f, -0.12075294f, 0.13346438f, 0.03337855f, -0.09068535f, 
    -0.16992593f, -0.11272877f, -0.09929069f, 0.19417307f, 0.15979971f, -0.14983524f, 0.09584246f, -0.10255727f, 
    -0.01147810f, 0.04349848f, 0.08250105f, 0.01518941f, -0.04910351f, 0.03028322f, 0.03093472f, 0.14300911f, 
    0.04186397f, -0.01797105f, 0.12955862f, -0.05657390f, 0.01462385f, -0.34459099f, 0.00986978f, -0.00363452f, 
    -0.09461915f, 0.14843203f, 0.20148514f, 0.05967701f, 0.13271730f, 0.25305441f, 0.13215917f, -0.26938298f, 
    -0.35996392f, -0.07128944f, 0.04186722f, -0.05757692f, 0.04728454f, 0.01903068f, 0.05787359f, 0.10574641f, 
    -0.48909855f, 0.01086242f, -0.15724802f, 0.03417711f, -0.00224142f, -0.05759868f, 0.14814319f, 0.20322162f, 
    0.06422921f, 0.06243811f, 0.12042307f, -0.09497366f, -0.06336644f, 0.17968105f, 0.16035612f, 0.09920461f, 
    0.12466348f, 0.00754318f, 0.10974538f, 0.01925305f, -0.01761660f, 0.11877682f, 0.15077613f, 0.12375484f, 
    0.12518713f, 0.08994704f, 0.05816771f, 0.02744253f, 0.06092299f, 0.10787287f, -0.03077835f, 0.08253638f, 
    -0.07493681f, 0.09770360f, -0.20259182f, 0.01106850f, -0.13475408f, -0.01385401f, 0.26929995f, -0.06562753f, 
    0.26550469f, 0.03282715f, 0.00966017f, -0.04682839f, 0.09656796f, 0.02892097f, -0.25547439f, -0.16691557f, 
    0.01420744f, 0.22627094f, -0.03698828f, 0.00066501f, -0.15269786f, -0.04511800f, -0.14579186f, -0.02406102f, 
    -0.06797640f, 0.05895714f, 0.09700433f, -0.03434468f, -0.20979811f, 0.34772798f, 0.31836647f, -0.08239400f, 
    0.12420584f, -0.01961640f, 0.02209623f, -0.23952523f, -0.14645877f, 0.23571955f, -0.19777015f, -0.06584403f, 
    -0.07784536f, 0.05960657f, 0.05848824f, 0.01015042f, 0.00662403f, 0.05492701f, 0.05613711f, 0.03689081f, 
    -0.13432425f, -0.20022649f, -0.05468694f, 0.10330609f, 0.12295928f, 0.22934985f, 0.05127225f, 0.06446548f, 
    0.07395894f, 0.02038295f, 0.09654973f, 0.00426991f, -0.05227645f, 0.14052448f, 0.14337294f, 0.03050207f, 
    -0.12266723f, 0.00738831f, -0.28869602f, -0.18390617f, 0.12325238f, -0.00350868f, -0.04884743f, 0.00414076f, 
    0.00547569f, -0.16845457f, -0.07257094f, 0.11822017f, -0.05682810f, 0.10038541f, 0.10405808f, -0.10150591f, 
    -0.08251572f, 0.01261881f, 0.22845921f, 0.34592855f, -0.00704455f, 0.02877823f, -0.05983900f, 0.04261418f, 
    -0.03821427f, -0.13764137f, 0.22473355f, -0.00812523f, -0.14043026f, -0.05554195f, 0.01757541f, -0.07608684f, 
    -0.03028058f, 0.01026690f, 0.07811189f, -0.02548616f, 0.42064786f, 0.23720078f, 0.12325829f, 0.01955441f, 
    -0.19084403f, -0.01021021f, -0.12807250f, -0.01143821f, 0.00766711f, -0.15565357f, -0.00633814f, 0.27827865f, 
    0.00316098f, 0.01138394f, 0.03511487f, 0.00598655f, -0.04508416f, 0.15625805f, -0.10401848f, 0.00190890f, 
    -0.04412633f, -0.17609887f, -0.13724652f, -0.43486893f, 0.13026452f, 0.07550989f, 0.11332275f, -0.12320044f, 
    -0.18750528f, 0.13815869f, 0.07214168f, 0.06070144f, -0.03118262f, -0.30712974f, -0.04363487f, -0.17476995f, 
    0.26068249f, 0.36917752f, 0.04800828f, 0.00389146f, 0.08932602f, -0.03373437f, 0.04244998f, -0.23510815f, 
    0.14018083f, 0.14245714f, 0.19401382f, -0.16094598f, -0.18891668f, 0.13649437f, -0.04266138f, -0.01851286f, 
    0.01925902f, -0.13394645f, 0.17735927f, 0.17811304f, -0.15681182f, -0.04966322f, 0.00168512f, -0.02554518f, 
    -0.00372118f, -0.15356919f, -0.17118208f, -0.29316127f, -0.14283788f, 0.16119620f, 0.05204109f, 0.00320806f, 
    0.09857883f, 0.12855667f, 0.09309120f, 0.07375123f, -0.39798921f, 0.09835232f, 0.22228293f, -0.14322771f, 
    -0.18383311f, -0.15425518f, 0.12423392f, -0.02963324f, -0.30898774f, 0.15044285f, 0.00351613f, -0.17234819f, 
    -0.03230964f, -0.00013918f, -0.11018027f, 0.00107515f, -0.04016037f, 0.16358615f, 0.37411830f, 0.30326959f, 
    -0.03094147f, -0.03226041f, -0.08751253f, -0.12176894f, 0.08604429f, -0.05497375f, 0.18441942f, -0.09977224f, 
    -0.08453739f, -0.05497615f, -0.09760865f, -0.02083531f, 0.00130218f, -0.19151351f, 0.19669373f, -0.07272784f, 
    0.07355148f, -0.04613985f, 0.01193200f, -0.12615615f, -0.08283445f, -0.08978067f, 0.05953015f, 0.16416468f, 
    0.08126282f, -0.03837961f, 0.03710008f, 0.25837794f, -0.07451233f, 0.04209037f, 0.00416632f, -0.03361913f, 
    0.14553416f, 0.08953981f, 0.16331334f, 0.14479415f, 0.04614018f, -0.12111185f, -0.03656900f, -0.03647269f, 
    0.02569059f, 0.09087502f, -0.00696218f, -0.18148650f, 0.00415775f, 0.17107938f, -0.03598611f, 0.06285453f, 
    0.03438868f, -0.07650328f, -0.18969038f, -0.24844657f, 0.09752637f, 0.06214342f, 0.06173094f, -0.36365202f, 
    -0.37723437f, -0.30861241f, 0.04917498f, 0.09338168f, -0.05092084f, 0.03177255f, 0.02509106f, -0.05952232f, 
    -0.10512067f, -0.05059081f, -0.02214975f, 0.02567874f, 0.28501153f, -0.07628661f, -0.04521792f, -0.07596981f, 
    0.01620511f, -0.09230953f, -0.04058776f, -0.00721484f, -0.14514750f, -0.00788912f, -0.05893943f, -0.12132885f, 
    -0.12739575f, 0.06361789f, 0.12591605f, -0.06121717f, -0.00936188f, 0.13969214f, -0.03118266f, -0.06987584f, 
    0.19226545f, 0.36470613f, -0.06540166f, -0.06846047f, -0.09303430f, -0.12043192f, 0.01988113f, 0.05203290f, 
    -0.02774324f, -0.10896215f, -0.22426687f, -0.27451327f, 0.10183463f, 0.05262676f, -0.11923809f, -0.00321472f, 
    -0.17282501f, 0.41844031f, 0.04538705f, 0.03006701f, 0.04466769f, 0.03668973f, -0.10928269f, -0.05440667f, 
    0.01877100f, -0.01431654f, 0.10210802f, -0.34019008f, -0.07712481f, -0.05160725f, -0.00240556f, 0.01989737f, 
    0.01460302f, 0.14162514f, 0.04583410f, 0.28260565f, -0.10973857f, -0.13788459f, 0.19548140f, -0.21890803f, 
    -0.22933058f, 0.17086346f, 0.04147336f, 0.00691461f, 0.18824376f, -0.12085593f, -0.39194125f, -0.39784288f, 
    0.20417307f, 0.13026482f, 0.06227406f, -0.02593696f, 0.02213594f, 0.13652909f, -0.16604713f, -0.28195450f, 
    0.20983212f, -0.12527764f, 0.15488142f, -0.25094649f, 0.19321670f, 0.12261931f, -0.19477995f, 0.12292336f, 
    0.20628637f, -0.03690899f, -0.03519714f, -0.07958114f, -0.09789380f, -0.11945657f, 0.05620659f, 0.07693242f, 
    -0.35206246f, -0.26507568f, 0.28338864f, -0.03723127f, 0.08180340f, 0.27649423f, 0.00140339f, -0.06881594f, 
    0.02134644f, 0.25460842f, 0.16271013f, -0.01958529f, 0.00376863f, 0.04853912f, -0.10738106f, 0.08923797f, 
    0.12872836f, 0.05500250f, -0.34803405f, -0.24047481f, -0.02689174f, -0.09489594f, -0.01036960f, -0.18059605f, 
    0.04958404f, 0.10579920f, -0.03815625f, -0.05855879f, -0.06730936f, -0.08011240f, 0.03444044f, 0.04716937f, 
    -0.02460445f, 0.13339166f, 0.00025039f, -0.13806826f, 0.15763980f, 0.03701048f, -0.19820933f, -0.16377519f, 
    0.09428164f, -0.14159876f, -0.01586703f, 0.01627374f, -0.08479655f, 0.07903711f, -0.06982686f, 0.17206983f, 
    0.04520508f, -0.07161942f, -0.14978744f, 0.04099071f, 0.02726842f, 0.19936289f, -0.11862651f, -0.01834039f, 
    -0.01326597f, 0.04778476f, 0.02212777f, 0.12639639f, -0.05425702f, -0.05007549f, 0.17146148f, -0.02431957f, 
    0.10355601f, 0.21410730f, -0.18201528f, -0.06560862f, -0.08986211f, 0.01277188f, 0.08360755f, 0.01860951f, 
    -0.19371746f, -0.23817943f, 0.27234271f, -0.03032038f, 0.08680093f, -0.17318022f, 0.23697558f, 0.05471332f, 
    0.08985000f, -0.21635887f, -0.19134912f, -0.31748375f, -0.13610986f, 0.03454857f, 0.03892919f, 0.06640200f, 
    0.01029728f, -0.10837779f, -0.11112905f, 0.08117045f, -0.00328659f, -0.01295799f, -0.09083993f, 0.09051006f, 
    0.15085217f, 0.06001172f, 0.01154547f, -0.02567475f, 0.09026928f, 0.08786381f, -0.05124535f, 0.15780036f, 
    0.00330277f, -0.02542815f, -0.02155875f, -0.08694635f, 0.18247001f, 0.18678659f, -0.18479376f, -0.01646142f, 
    0.02190425f, 0.06174855f, 0.09771919f, 0.11904702f, 0.07422300f, -0.00081948f, -0.37928760f, 0.26008597f, 
    -0.06463324f, 0.13512050f, -0.16527951f, 0.10693640f, 0.02544857f, 0.01620434f, 0.33787501f, -0.36851224f, 
    0.02658222f, -0.40381482f, -0.25222489f, -0.33318400f, -0.08025879f, 0.00203640f, 0.16580960f, 0.18181106f, 
    0.08865682f, 0.27527425f, -0.14686619f, -0.03669099f, 0.05000690f, 0.03215970f, 0.04515231f, 0.01712974f, 
    -0.21731719f, 0.02359173f, -0.09305106f, 0.02786780f, 0.16225529f, 0.04493720f, 0.35546389f, 0.06252153f, 
    -0.07008273f, -0.13786836f, -0.38294986f, -0.03166951f, 0.10920617f, 0.23788156f, -0.08164232f, 0.12986228f, 
    -0.04179141f, -0.05082171f, -0.05892247f, -0.10069294f, -0.00102001f, 0.06150560f, 0.05682015f, -0.12462893f, 
    0.17391455f, -0.03994811f, -0.16829197f, 0.22286767f, 0.14012659f, 0.10231720f, -0.16340302f, 0.00279179f, 
    -0.09872047f, 0.15635778f, 0.08173377f, -0.07715100f, 0.02005302f, 0.00670832f, -0.12443589f, -0.10866936f, 
    -0.06307359f, -0.04227295f, 0.19809742f, 0.07382451f, -0.06638553f, -0.06040911f, -0.01772020f, -0.25109044f, 
    0.06500273f, -0.08457479f, 0.15609315f, -0.03720405f, -0.03598282f, 0.00313258f, 0.11083411f, 0.05459621f, 
    -0.01223485f, -0.01725170f, -0.01598131f, -0.15739705f, 0.08326662f, 0.00536052f, 0.06483515f, 0.05332641f, 
    0.05005819f, 0.02467436f, -0.03022379f, -0.12495998f, -0.08174840f, 0.06335795f, 0.13173673f, 0.02302306f, 
    0.07879476f, 0.14315610f, -0.10445100f, -0.14216538f, -0.12339146f, -0.02337825f, 0.01934836f, 0.07027061f, 
    -0.04880061f, -0.13954113f, -0.17669660f, -0.13881247f, -0.04796087f, 0.02016886f, -0.08407764f, -0.16277751f, 
    0.04041229f, -0.00611747f, 0.18155608f, 0.35612258f, 0.04445278f, -0.02670852f, -0.04369185f, -0.03068073f, 
    0.05018751f, -0.05770731f, 0.15333185f, -0.04844861f, -0.25619507f, -0.13613510f, -0.05759139f, 0.18626903f, 
    -0.25895828f, -0.06508486f, -0.08177178f, -0.05977933f, -0.04351245f, -0.60968584f, -0.21884277f, -0.08484080f, 
    0.16026989f, 0.18995553f, 0.16578847f, 0.02658925f, 0.05912212f, -0.17961060f, -0.66636306f, -0.75873375f, 
    -0.19985576f, -0.17480280f, 0.07687698f, -0.04300285f, 0.00757328f, -0.04453780f, -0.12993386f, 0.04115540f, 
    -0.24699056f, 0.04692780f, 0.03132360f, -0.08655059f, 0.08182601f, 0.07157606f, -0.12039865f, 0.05583004f, 
    0.39425373f, 0.05799964f, -0.02435042f, -0.06252848f, -0.06279185f, 0.03032659f, 0.04071154f, -0.00926440f, 
    -0.01770647f, 0.21667726f, -0.32048097f, 0.01571625f, 0.27100402f, -0.03455061f, 0.05660049f, 0.20211101f, 
    -0.12678806f, 0.15186232f, 0.19525541f, 0.04840780f, -0.01594353f, -0.08169484f, -0.06756746f, 0.01393651f, 
    0.06631213f, 0.08423066f, -0.08967431f, -0.01639334f, -0.00439021f, 0.03355896f, -0.06713371f, 0.01979811f, 
    0.02831778f, -0.07530162f, -0.06655609f, -0.02644178f, -0.27178970f, -0.35450104f, 0.01617856f, 0.09758940f, 
    0.05270495f, -0.03756075f, -0.02945191f, -0.03354483f, -0.08933231f, -0.55353618f, -0.58355248f, -0.05716176f, 
    0.09076786f, 0.23764683f, -0.03740146f, -0.08538941f, -0.08887152f, 0.25785670f, 0.25097945f, 0.19455722f, 
    -0.11115371f, -0.03731377f, -0.22588463f, 0.03773012f, 0.11893346f, 0.14298882f, -0.00069740f, 0.16278435f, 
    -0.03570271f, 0.05852259f, 0.03569256f, -0.03909858f, 0.10880278f, -0.09161036f, 0.00055368f, -0.01568102f, 
    0.40976268f, 0.18030182f, -0.10480595f, -0.13097523f, -0.19955741f, 0.04087401f, 0.00506047f, 0.16160594f, 
    0.00491610f, 0.17210642f, 0.26214400f, 0.00733645f, -0.02356256f, -0.01123375f, 0.03297667f, 0.03258026f, 
    0.03478643f, -0.41406813f, -0.47958079f, -0.09407714f, 0.12769912f, 0.12967964f, -0.10354704f, -0.02585989f, 
    0.00647278f, -0.05381341f, -0.31253684f, 0.21701258f, 0.01379186f, 0.05376909f, 0.09710235f, 0.02667429f, 
    -0.00269899f, 0.09629805f, -0.05575421f, 0.15367548f, -0.21821478f, 0.09753140f, 0.02539241f, -0.01810718f, 
    -0.09067665f, 0.06568773f, -0.19754426f, 0.06927194f, 0.25930136f, -0.12624043f, 0.34169990f, 0.02403600f, 
    0.00372339f, -0.04008710f, -0.00068859f, -0.03714571f, 0.09658375f, -0.42054328f, -0.05789680f, -0.67885554f, 
    -0.04401870f, -0.09035262f, 0.24408118f, 0.06264706f, 0.05132127f, 0.02272312f, -0.24303633f, 0.10898699f, 
    -0.39097688f, 0.06024804f, -0.03960267f, 0.24126352f, 0.15666912f, -0.06588667f, -0.11588369f, -0.07438245f, 
    0.34691605f, -0.04062576f, -0.00963300f, -0.02810591f, -0.02474830f, 0.15373097f, 0.03350133f, 0.05934516f, 
    0.19074140f, 0.10908144f, 0.02258390f, 0.23465432f, 0.02776553f, -0.05205572f, -0.00426169f, 0.03574898f, 
    0.20403980f, -0.25920591f, -0.04135606f, 0.13019399f, -0.07734826f, 0.19248767f, -0.05541216f, 0.05458776f, 
    0.09751754f, 0.12550375f, -0.22960140f, -0.21330184f, -0.13503835f, 0.05607614f, 0.00337987f, 0.06580326f, 
    0.07065798f, 0.06429195f, 0.04386316f, 0.22313963f, 0.37905934f, -0.11960739f, -0.14138111f, -0.08363414f, 
    -0.13927579f, -0.05474031f, -0.01166192f, 0.06320968f, 0.21333200f, 0.13373064f, -0.06796607f, -0.05178263f, 
    -0.01858938f, -0.04328462f, -0.14933303f, -0.09783784f, -0.11780612f, 0.06378551f, 0.05232922f, -0.22176789f, 
    0.05607299f, 0.13820472f, -0.07133661f, -0.00877752f, 0.10813494f, -0.12804538f, 0.01448512f, 0.27296779f, 
    0.02396816f, -0.00417006f, -0.16023749f, -0.02266869f, 0.04018027f, 0.15977404f, 0.14473526f, 0.16172051f, 
    0.06941260f, 0.24382336f, -0.07579980f, 0.07859167f, -0.02623084f, -0.07397015f, 0.02648956f, 0.03785161f, 
    -0.11267789f, -0.25304273f, -0.01596954f, -0.11621002f, 0.03515166f, -0.10488524f, -0.10653118f, 0.09177767f, 
    0.04485829f, -0.13205883f, 0.05800081f, -0.02367503f, 0.09169036f, -0.15923738f, -0.10784286f, -0.15048720f, 
    -0.02604873f, -0.15731168f, 0.07839519f, 0.01613915f, -0.01832412f, -0.08330634f, -0.22401544f, -0.08476257f, 
    -0.14837188f, -0.12308729f, -0.06201521f, -0.05790653f, 0.07286508f, 0.04316939f, 0.11348495f, 0.04806365f, 
    -0.14763701f, -0.01590651f, -0.11840138f, -0.01701101f, -0.15344182f, -0.07380538f, -0.11080584f, 0.07740204f, 
    0.07912215f, -0.09512649f, 0.00485257f, 0.11955843f, 0.05347615f, -0.29313019f, -0.03324351f, -0.11077154f, 
    -0.06879909f, -0.00146800f, -0.04988191f, -0.06593141f, -0.03180921f, -0.06274176f, -0.05087025f, 0.04994385f, 
    -0.05049757f, -0.05201599f, -0.07832883f, -0.09497292f, -0.11933210f, 0.05765788f, 0.27463606f, -0.02085672f, 
    -0.06878952f, -0.03220437f, -0.24367253f, -0.14256929f, -0.14848034f, -0.28655124f, -0.05064853f, -0.03633606f, 
    0.08029097f, 0.00993195f, 0.12495768f, 0.03915386f, -0.00369544f, -0.02358320f, 0.02304744f, -0.20887090f, 
    0.18530630f, 0.03093185f, -0.13654737f, 0.21984412f, -0.09555721f, 0.07949221f, 0.04282846f, -0.03019394f, 
    0.14876972f, 0.08264694f, -0.29807198f, -0.00144008f, -0.21830325f, 0.04450303f, 0.05165734f, -0.02985363f, 
    0.08530485f, 0.07329384f, 0.10078885f, -0.11941367f, 0.00986198f, 0.01961226f, 0.05301345f, 0.02784068f, 
    -0.07488851f, -0.04089677f, 0.03059726f, 0.14583275f, -0.44510800f, -0.14443706f, 0.01011505f, -0.04533364f, 
    0.01158034f, -0.05078562f, -0.01655582f, 0.03589282f, 0.09350824f, 0.20041187f, -0.01456079f, 0.19643213f, 
    0.06452166f, 0.04626517f, 0.09513702f, 0.18596277f, -0.08240128f, 0.07450414f, 0.08511221f, 0.04838260f, 
    0.07066835f, -0.06406881f, -0.12451921f, 0.08708251f, -0.21393006f, -0.02487208f, 0.13908744f, 0.21626908f, 
    -0.06437185f, 0.03756585f, -0.07507794f, -0.04377164f, 0.02005244f, -0.17992280f, 0.11394436f, 0.08268869f, 
    -0.36670524f, -0.10816681f, -0.28134105f, 0.04458746f, 0.00137230f, 0.00892175f, 0.11097286f, 0.00718693f, 
    0.18982533f, -0.04749854f, -0.07253185f, -0.02679263f, -0.09883225f, 0.06553146f, 0.03673328f, 0.16979703f, 
    0.06526236f, 0.13530011f, -0.09640130f, -0.04278081f, 0.06902508f, 0.09173416f, 0.09849909f, 0.07221089f, 
    0.12168690f, 0.19925469f, 0.13614462f, 0.09912799f, 0.12189818f, 0.05024619f, -0.02325115f, -0.08612832f, 
    0.14949855f, -0.08532836f, 0.03297720f, 0.17070763f, 0.10580226f, -0.02699826f, 0.22051401f, 0.11281542f, 
    -0.05787159f, 0.06801068f, -0.16237524f, 0.11329210f, 0.12851259f, -0.23959088f, 0.05002202f, 0.14524706f, 
    -0.02070615f, -0.04635250f, 0.08259396f, -0.03521906f, -0.02429259f, -0.13724516f, -0.42401969f, -0.21994390f, 
    0.06845949f, -0.03039484f, 0.10596219f, 0.14206845f, -0.03644643f, -0.02292151f, -0.22337897f, -0.00800450f, 
    -0.22207572f, 0.31306264f, -0.04651977f, 0.06890737f, -0.05157551f, -0.00756886f, 0.27557015f, 0.03750352f, 
    0.11861764f, 0.09060417f, 0.22381847f, 0.00346230f, 0.08657449f, -0.05434373f, 0.01423558f, 0.10218587f, 
    -0.03476404f, -0.09426043f, 0.20783654f, 0.34555963f, 0.03058025f, 0.07064238f, -0.17072162f, 0.15816207f, 
    0.04477957f, 0.07659246f, -0.09114576f, -0.01284081f, -0.09649533f, 0.01460215f, 0.00662504f, -0.08871377f, 
    -0.01847762f, 0.03676296f, 0.16002364f, -0.06139312f, 0.05586275f, -0.13772491f, 0.06305663f, 0.04557967f, 
    0.00414401f, 0.08467329f, -0.09207244f, -0.07166085f, -0.08566293f, -0.06248764f, -0.05109807f, 0.10211767f, 
    -0.09979733f, -0.16539836f, -0.22753768f, -0.10280780f, 0.06611004f, 0.00558887f, -0.06827461f, 0.18492597f, 
    0.03728299f, 0.13496821f, 0.24837616f, -0.00005990f, -0.02691533f, 0.01520286f, -0.13196348f, 0.02304327f, 
    0.02435100f, 0.06119166f, 0.07587781f, 0.01481058f, 0.25845358f, 0.13216664f, 0.01810419f, -0.02087866f, 
    0.08541192f, -0.06820034f, 0.06231510f, 0.00690738f, 0.06108418f, -0.07866705f, 0.02221616f, -0.10769058f, 
    0.22172526f, 0.07381240f, 0.18264347f, 0.08345064f, -0.04135180f, -0.13323608f, 0.09602427f, -0.00213638f, 
    0.11557250f, -0.12187430f, -0.02914963f, -0.14327703f, 0.21688215f, 0.07855822f, 0.04413551f, -0.31304780f, 
    -0.22273855f, -0.29098353f, -0.05632407f, -0.01139485f, -0.04422951f, 0.04454359f, 0.09677657f, 0.04115191f, 
    0.02008514f, 0.02334660f, -0.18014352f, -0.02714778f, -0.12067293f, -0.11621698f, 0.14063761f, 0.14319162f, 
    0.09244058f, -0.05012758f, 0.03558325f, -0.26525438f, 0.32878345f, -0.09430689f, 0.01674846f, 0.15837584f, 
    0.17274188f, -0.08224369f, -0.12772655f, -0.00238494f, 0.10499164f, -0.16931859f, -0.26308337f, -0.16716796f, 
    -0.04366644f, -0.06758984f, -0.21679524f, -0.22910500f, -0.27398124f, -0.08856813f, -0.11940736f, -0.01903703f, 
    -0.04724753f, 0.05409414f, 0.06828346f, 0.12616093f, 0.09359690f, 0.07257744f, 0.16833313f, -0.06009662f, 
    0.10741782f, -0.03900013f, 0.03067365f, 0.10136447f, -0.11553575f, -0.00759503f, 0.01441574f, -0.15519148f, 
    -0.07592755f, -0.04198322f, 0.28598249f, 0.02872131f, 0.17006861f, -0.08974269f, -0.07038064f, 0.13271266f, 
    -0.07195193f, 0.27438480f, 0.08556917f, 0.16450191f, 0.09477308f, 0.02877823f, -0.08653731f, 0.14378500f, 
    0.11494823f, 0.08493584f, -0.02877508f, 0.07244108f, -0.14141268f, -0.17825095f, -0.09422992f, -0.14466764f, 
    0.07943837f, 0.08978500f, 0.07242894f, -0.06103316f, 0.00090873f, 0.00209432f, -0.05039971f, -0.08606579f, 
    -0.00327537f, 0.04632564f, 0.22497296f, 0.12465887f, -0.19021121f, -0.00380856f, 0.13221039f, -0.14001808f, 
    -0.20660229f, -0.25656876f, -0.04532383f, 0.00892667f, 0.02886166f, 0.12627226f, 0.15870543f, 0.22663414f, 
    0.04966189f, 0.13568130f, 0.06748097f, 0.06604840f, -0.06237732f, -0.10146041f, -0.02442050f, -0.06146722f, 
    0.05818549f, 0.12489253f, 0.08545804f, 0.06464347f, -0.07571790f, 0.08196539f, 0.11247522f, -0.14179255f, 
    0.06045339f, 0.13805075f, -0.13752474f, -0.03905226f, 0.00907938f, -0.24083513f, 0.12835768f, -0.16776302f, 
    0.08141273f, -0.03459109f, -0.19947554f, -0.10822042f, 0.04653152f, -0.13987035f, 0.00021540f, 0.01585532f, 
    0.11791530f, -0.09855162f, 0.23006082f, -0.05313563f, -0.01566568f, -0.05159491f, -0.03480694f, 0.12866189f, 
    0.24897914f, 0.07370567f, 0.02253610f, 0.23398776f, 0.03699139f, 0.00013386f, 0.03025097f, 0.05341584f, 
    0.15407602f, 0.25825676f, 0.03109968f, 0.06849442f, 0.03877555f, 0.08423648f, 0.16556162f, 0.02289165f, 
    0.09531548f, 0.15458107f, -0.02044002f, -0.01605726f, 0.34086126f, 0.05262007f, 0.28686965f, 0.05123614f, 
    -0.21528962f, 0.20030032f, 0.16892862f, -0.06940120f, -0.11465913f, -0.12613922f, -0.08146178f, -0.19384569f, 
    0.02469196f, -0.06733789f, 0.08207367f, -0.24177772f, -0.25734615f, -0.00916063f, -0.37934381f, -0.13765639f, 
    0.14021024f, -0.14459154f, -0.02258203f, -0.11035252f, 0.00410205f, 0.03118380f, 0.01655469f, 0.18665014f, 
    0.00487584f, 0.22361739f, 0.06044235f, 0.03579107f, -0.17661157f, 0.10872684f, 0.04290352f, 0.00324114f, 
    -0.11226976f, 0.28643882f, 0.12614252f, 0.30696520f, 0.15977100f, -0.17527018f, -0.10533974f, 0.09895910f, 
    0.03943368f, -0.10780761f, 0.14172055f, 0.28312361f, 0.22745018f, 0.29298794f, 0.15113394f, 0.12944600f, 
    0.03636708f, 0.15598482f, -0.06164356f, 0.05851800f, -0.07012914f, -0.09126590f, 0.04213409f, -0.12141338f, 
    0.20511110f, 0.08809445f, 0.15974043f, 0.13599758f, 0.12281053f, -0.04076464f, 0.07203248f, -0.00015167f, 
    0.07572739f, -0.11274223f, -0.14420947f, -0.19312017f, -0.09324610f, 0.00848455f, -0.12865832f, 0.15623124f, 
    0.01984982f, -0.04820947f, 0.06725307f, -0.10589378f, -0.04489277f, -0.01739802f, 0.16172412f, 0.12255647f, 
    0.15294605f, -0.05110548f, 0.13611038f, -0.02513465f, 0.06020930f, -0.13589194f, -0.16401593f, 0.00374460f, 
    -0.09905973f, 0.00419922f, -0.12245508f, -0.00961243f, -0.07828574f, -0.13142149f, -0.23822044f, -0.07035474f, 
    -0.17018117f, -0.18032824f, -0.04877434f, -0.16865520f, 0.02572077f, -0.10613321f, -0.22370382f, -0.02923561f, 
    0.05289385f, 0.15603766f, -0.13265599f, 0.04813335f, -0.09005368f, -0.06371497f, 0.08166974f, -0.00221683f, 
    0.09849707f, -0.46735123f, 0.03381140f, -0.18179794f, 0.09600668f, 0.03954698f, -0.19005847f, -0.15268858f, 
    -0.12466881f, 0.07650701f, -0.12025271f, -0.07535819f, 0.17554069f, -0.02762352f, -0.22388229f, -0.13347934f, 
    0.02903420f, 0.05388415f, -0.02447522f, 0.00844494f, -0.03307286f, -0.07313698f, -0.01192450f, -0.13313812f, 
    -0.04572193f, -0.00880228f, -0.00346392f, 0.08575571f, 0.13040608f, 0.07047822f, 0.36098623f, -0.07860920f, 
    -0.13642827f, 0.16116521f, 0.04690333f, 0.18817817f, 0.05991353f, -0.35554421f, -0.17039602f, -0.12800132f, 
    0.05691245f, 0.04087189f, -0.16848052f, -0.13094559f, 0.02572317f, 0.10271916f, -0.09297896f, 0.09094909f, 
    0.17683139f, -0.09755573f, 0.32759210f, 0.02047855f, -0.03939085f, -0.10857034f, 0.01540336f, 0.05541011f, 
    -0.03657731f, 0.14168386f, -0.00873755f, -0.18582740f, -0.06133305f, 0.02221609f, 0.09464558f, 0.03784118f, 
    0.41126359f, -0.43514693f, 0.31515357f, -0.04701973f, 0.05257466f, 0.25162604f, -0.09297546f, 0.05744481f, 
    -0.04023966f, -0.09046984f, 0.14566293f, 0.02967660f, 0.06265911f, -0.07055216f, -0.11132727f, 0.10115328f, 
    0.11791624f, 0.04406039f, -0.22042610f, 0.04053735f, 0.02904985f, 0.03450562f, -0.13224822f, -0.13929956f, 
    -0.03106525f, 0.08960055f, -0.05871876f, -0.06806416f, -0.15105756f, -0.01185355f, 0.04219876f, 0.12098740f, 
    -0.13983947f, -0.10714865f, 0.11563151f, -0.05115405f, -0.14404091f, -0.02505901f, 0.03706949f, -0.04726545f, 
    -0.03216875f, -0.08500662f, 0.00117920f, 0.06042037f, -0.03173918f, 0.02791725f, 0.02570080f, 0.35463098f, 
    0.16023767f, -0.11276838f, -0.15883492f, -0.05789492f, 0.09544791f, 0.14838016f, 0.02749486f, -0.06279740f, 
    0.15895686f, 0.08267099f, 0.02803479f, 0.02821826f, 0.11315761f, 0.01984193f, 0.03672151f, -0.18344012f, 
    0.13874455f, 0.48148948f, -0.15725246f, -0.22312850f, -0.12781803f, -0.00412047f, 0.07930224f, -0.04407860f, 
    -0.19473332f, -0.00638525f, -0.00752742f, 0.02251660f, -0.01261911f, -0.21577054f, 0.11177821f, 0.04244722f, 
    0.01749850f, -0.14167775f, 0.10437846f, -0.19921646f, 0.04708054f, 0.01925252f, 0.08536813f, 0.20690055f, 
    0.07171104f, -0.03730305f, -0.19019341f, 0.06376744f, 0.04139057f, -0.15452470f, -0.07132009f, 0.08416724f, 
    0.03546988f, 0.05177626f, 0.00971718f, -0.03748259f, 0.23377860f, 0.20488942f, -0.01398083f, -0.01055903f, 
    0.12246875f, 0.08172558f, 0.06458144f, 0.08250926f, -0.67289394f, 0.42132077f, 0.10459194f, 0.12959503f, 
    -0.13365132f, -0.11586454f, -0.06791604f, -0.01046786f, 0.12529491f, -0.13814978f, -0.06187793f, 0.36560211f, 
    -0.07575770f, 0.09704012f, -0.01406566f, -0.03503960f, -0.01148339f, -0.12402863f, -0.50813836f, -0.24548277f, 
    0.25208545f, -0.06639358f, 0.07333842f, -0.27700809f, -0.20404851f, -0.01124823f, 0.14179346f, 0.23180717f, 
    -0.25608271f, 0.20406839f, -0.03566844f, -0.14386678f, 0.01548257f, 0.11749647f, 0.04339712f, 0.11983700f, 
    -0.03756855f, 0.08813871f, 0.00335182f, -0.05483193f, 0.10609028f, 0.09148177f, -0.08322186f, 0.11195025f, 
    -0.09018631f, -0.17502296f, -0.18899882f, 0.19948800f, 0.14736399f, 0.04567357f, 0.01763673f, 0.02151413f, 
    0.11201674f, -0.07193967f, 0.02373590f, -0.12806641f, -0.09239212f, 0.19386560f, 0.08195786f, -0.06903920f, 
    -0.02185815f, 0.02876513f, -0.06507806f, -0.01308908f, 0.11628921f, 0.26826340f, -0.16357858f, 0.09263432f, 
    -0.14930125f, 0.11580880f, -0.05277164f, -0.09636728f, -0.15623842f, -0.02576832f, 0.01912825f, 0.03107873f, 
    -0.06299178f, -0.03598458f, -0.02061831f, -0.02758530f, 0.00279312f, -0.15009286f, 0.30765873f, -0.02610199f, 
    0.03655705f, -0.06924784f, 0.23219959f, -0.06011146f, 0.02731382f, 0.16922994f, -0.18167083f, 0.06517150f, 
    0.29233494f, -0.00831805f, 0.02624775f, -0.17059503f, 0.06862539f, 0.15536796f, 0.07309981f, -0.01927434f, 
    -0.12187762f, 0.26221484f, -0.14015234f, -0.03852989f, -0.15220967f, 0.04738748f, 0.00087620f, -0.00954873f, 
    -0.17048557f, -0.00408911f, -0.09031906f, -0.16126180f, -0.04895638f, 0.02221500f, 0.08891689f, 0.07269447f, 
    -0.04207390f, 0.03911079f, -0.04987388f, -0.15618603f, -0.01667172f, -0.00740970f, 0.09416538f, -0.18009664f, 
    -0.24619299f, -0.23896761f, -0.04703284f, -0.11207900f, -0.02311007f, 0.03680240f, -0.09900914f, -0.38306648f, 
    -0.12963942f, -0.09337346f, -0.06867570f, -0.06993898f, -0.16550931f, -0.31087902f, 0.05441602f, 0.19457781f, 
    0.01919485f, -0.08147851f, -0.03882584f, 0.10861166f, 0.06972401f, -0.10524391f, 0.10633688f, 0.09609497f, 
    0.04548066f, 0.02511102f, 0.25151521f, -0.05494230f, -0.24622378f, -0.34554121f, 0.00464824f, -0.06095157f, 
    -0.09069067f, -0.20348902f, 0.23875262f, -0.09065216f, -0.03366541f, 0.00475255f, 0.24059023f, -0.09676464f, 
    -0.22572024f, -0.01917461f, -0.03899370f, 0.02086139f, 0.13931170f, 0.02282063f, 0.17881830f, -0.12083893f, 
    0.20473316f, 0.05587861f, 0.19468823f, -0.07077086f, -0.20074737f, -0.02840460f, 0.07602070f, 0.04608821f, 
    0.01129768f, 0.11850159f, -0.20378004f, 0.10909032f, 0.13250487f, 0.13018742f, 0.17866679f, -0.00188425f, 
    0.17550755f, -0.03399080f, 0.01036559f, -0.12699214f, 0.00366780f, -0.07652359f, 0.00797358f, -0.01450348f, 
    0.12184971f, -0.00050634f, 0.05467076f, -0.15624899f, 0.19918653f, 0.09481829f, -0.08289821f, -0.03814919f, 
    0.03275521f, -0.07385258f, -0.04031105f, -0.04459770f, -0.08978049f, -0.29347295f, -0.03834540f, 0.07007633f, 
    0.00464417f, 0.07148039f, 0.07700332f, 0.16720803f, -0.09266102f, -0.14961664f, 0.08806732f, 0.10286219f, 
    -0.12595108f, 0.10898311f, 0.13299668f, -0.01147297f, -0.04925469f, -0.00994165f, 0.06041139f, 0.23022671f, 
    0.12027682f, -0.03488389f, 0.05080845f, 0.13316022f, -0.01350795f, 0.08228531f, -0.01890280f, -0.22824620f, 
    -0.20934214f, -0.00087369f, 0.03202352f, -0.13680337f, 0.04293581f, 0.05450050f, 0.10942790f, -0.06908648f, 
    0.18644775f, -0.04582141f, 0.12911871f, -0.05734494f, -0.11883509f, 0.11755901f, 0.05627799f, 0.08769275f, 
    0.17253144f, -0.06482709f, 0.27020979f, 0.08666554f, 0.00684303f, 0.02082544f, 0.01958159f, 0.03938660f, 
    -0.05458076f, 0.24868336f, 0.05460334f, -0.21272779f, -0.07293848f, -0.10393479f, 0.15479407f, 0.07582285f, 
    -0.01256669f, -0.07388257f, 0.19327857f, 0.09901202f, 0.18996325f, 0.05421190f, -0.01083671f, -0.03766120f, 
    0.11397441f, 0.05744334f, -0.13832185f, 0.18518059f, -0.34035003f, -0.18372057f, 0.18401788f, -0.01163723f, 
    0.15306892f, 0.12222805f, 0.07350528f, -0.07562613f, 0.27259526f, -0.34455761f, -0.12500505f, 0.28133595f, 
    0.00992589f, -0.15133022f, 0.13236633f, 0.13094437f, 0.03190276f, -0.23642012f, 0.18011026f, 0.07103738f, 
    -0.01116204f, -0.10733068f, 0.26534086f, 0.12502255f, 0.04799546f, -0.29872385f, -0.24241953f, -0.22071746f, 
    0.27366865f, 0.08587684f, -0.18441784f, -0.08494915f, 0.22695787f, 0.05381688f, -0.01469014f, 0.03106882f, 
    -0.10318080f, 0.01352199f, -0.06095119f, 0.00282424f, 0.12365673f, 0.18279353f, 0.05686255f, 0.03364580f, 
    -0.06833118f, 0.28651741f, 0.12028442f, 0.11506592f, -0.21742493f, -0.14115384f, 0.17993660f, 0.01638747f, 
    0.24040814f, 0.35974282f, -0.01736150f, 0.21783371f, 0.01233856f, -0.12088257f, 0.06534846f, 0.00756190f, 
    0.10871111f, 0.09838156f, 0.17544936f, -0.06992080f, -0.07692152f, 0.00668613f, -0.13338564f, 0.09544253f, 
    -0.02022549f, 0.10444610f, 0.07177439f, 0.01552223f, -0.31143996f, 0.14518249f, 0.08644567f, 0.01160925f, 
    -0.10816585f, 0.06050561f, 0.15861124f, -0.31399703f, -0.08785664f, -0.15817741f, -0.07519659f, 0.07362549f, 
    -0.00803554f, -0.18910684f, -0.10843652f, -0.03924299f, -0.09017904f, 0.16588587f, -0.16728139f, -0.24268332f, 
    0.18613638f, -0.01067193f, -0.05934857f, 0.12094341f, -0.02458466f, -0.02934524f, -0.07310702f, -0.27875504f, 
    0.06982698f, -0.11411555f, -0.19712554f, -0.03823145f, 0.09325124f, -0.31173897f, -0.17911926f, 0.10434363f, 
    -0.31570065f, 0.06201832f, 0.14030476f, 0.00602587f, -0.15390432f, -0.14466137f, 0.07258852f, -0.17123234f, 
    0.40866014f, -0.00341382f, 0.01753152f, 0.09657500f, -0.06142991f, -0.05123077f, 0.08609921f, -0.00575828f, 
    0.04192748f, -0.72188246f, -0.23545666f, 0.35378397f, -0.01323518f, 0.03127530f, -0.05555908f, 0.06243378f, 
    0.09660002f, 0.04154583f, -0.20038460f, -0.36670616f, -0.36478123f, -0.17631906f, -0.29788253f, -0.14669991f, 
    0.05944006f, -0.04041831f, 0.07502472f, 0.72434843f, -0.32935256f, -0.20222430f, -0.01076027f, 0.01029136f, 
    0.03993147f, 0.06017902f, 0.13417345f, -0.01312700f, 0.20000418f, 0.25865307f, -0.01520590f, -0.01834724f, 
    0.11811523f, -0.09401891f, -0.02545158f, -0.08756230f, -0.02623519f, 0.49143863f, 0.05118764f, 0.20526171f, 
    0.13043015f, 0.07660580f, 0.26567599f, 0.11452999f, 0.03989878f, -0.04648733f, -0.13819534f, -0.10032377f, 
    0.05126077f, -0.11757066f, -0.01850757f, 0.23210537f, 0.00038571f, 0.15156764f, -0.00750565f, 0.12220624f, 
    0.17714760f, -0.28345713f, -0.02719641f, 0.14050576f, 0.18134651f, 0.00710626f, -0.08512231f, 0.07373179f, 
    0.58863086f, -0.08920930f, -0.41578680f, 0.01937767f, -0.10336670f, 0.00905563f, 0.04311094f, 0.03209144f, 
    -0.04933598f, 0.33302695f, -0.18264240f, -0.28129628f, -0.02118470f, -0.08567178f, -0.01192939f, -0.05049469f, 
    0.03720053f, 0.02028437f, 0.09177954f, 0.22746392f, 0.14082216f, -0.07931800f, -0.13749911f, -0.07166442f, 
    -0.05763917f, 0.02138477f, 0.03305562f, -0.26237774f, -0.36837190f, -0.44950691f, 0.04926795f, -0.01529836f, 
    0.12566379f, -0.05179411f, 0.13291483f, 0.08607169f, 0.19270663f, 0.18810809f, 0.07490354f, 0.02071990f, 
    0.10920192f, 0.02601352f, -0.06434524f, 0.11940647f, -0.02009795f, -0.07628646f, -0.16101547f, -0.00818663f, 
    -0.01394056f, 0.06253610f, -0.13769177f, -0.05189983f, 0.04371441f, 0.02131396f, 0.21941862f, 0.02788669f, 
    0.08271119f, -0.09560867f, 0.03064858f, 0.14753476f, 0.16527878f, 0.12292020f, 0.01537260f, -0.29163596f, 
    0.14696021f, -0.24425532f, -0.17897230f, 0.10617590f, -0.00177910f, -0.16527571f, -0.02745356f, 0.11006752f, 
    0.09849898f, 0.21890785f, 0.01731755f, -0.07904298f, -0.03681209f, -0.10303570f, 0.06914337f, 0.01965773f, 
    0.03835529f, 0.05439039f, 0.07320060f, -0.08037317f, -0.06848750f, -0.17112541f, -0.12023780f, 0.02702369f, 
    0.03693527f, -0.08048594f, -0.03026622f, -0.05406068f, -0.17514090f, 0.00613138f, -0.16261515f, -0.20309143f, 
    0.01688354f, -0.02998010f, 0.00167025f, -0.22563422f, 0.02998755f, -0.06535096f, -0.16384263f, 0.14753729f, 
    0.11053706f, 0.04421541f, 0.10372499f, 0.03746752f, -0.96148503f, -0.42295536f, 0.33384979f, -0.08307222f, 
    0.03928743f, -0.10419192f, 0.05341535f, 0.03846696f, 0.00945898f, 0.23570035f, 0.22189695f, 0.04685052f, 
    -0.08174866f, 0.07861912f, 0.15112768f, 0.16277599f, 0.00523362f, 0.15904327f, 0.36534664f, 0.18438329f, 
    0.14434485f, 0.00142883f, -0.05972458f, -0.01269959f, 0.11285151f, 0.09314100f, -0.03236824f, -0.12322253f, 
    -0.42009130f, -0.38678274f, -0.18006423f, 0.02886261f, -0.01333976f, -0.04773294f, 0.15625237f, -0.08704426f, 
    -0.12328574f, -0.08042616f, 0.11905958f, 0.05925889f, 0.08074059f, -0.14777613f, -0.18663922f, -0.02572145f, 
    0.09057854f, -0.03092224f, -0.05305646f, 0.07024008f, -0.08494016f, 0.22177047f, -0.18584165f, -0.00819287f, 
    0.10695950f, -0.03720762f, 0.12591857f, 0.21186234f, 0.06284232f, -0.07280143f, 0.01168916f, -0.00524498f, 
    -0.04906655f, -0.01867690f, 0.03490826f, -0.02670223f, 0.13293947f, -0.52206028f, -0.07842159f, -0.08426681f, 
    -0.03275923f, 0.07761654f, 0.00082859f, 0.00148031f, 0.05346008f, -0.18657558f, -0.38483164f, -0.54957879f, 
    -0.14319125f, -0.02569035f, -0.00633129f, 0.15340401f, 0.18071912f, -0.13427043f, -0.22934555f, -0.42055354f, 
    -0.01749625f, -0.32399058f, 0.12382478f, 0.04150111f, 0.13464300f, 0.07639471f, -0.73787624f, 0.08427544f, 
    -0.71076649f, -0.00769670f, -0.06237414f, -0.09405098f, 0.05074800f, -0.02639204f, -0.06445131f, -0.03970147f, 
    0.15428692f, 0.18893689f, -0.01695712f, -0.02732544f, -0.05688231f, 0.10682792f, 0.04539000f, -0.13423589f, 
    0.01949879f, 0.10956378f, -0.08850549f, 0.24534208f, 0.09158378f, 0.12521099f, 0.04020632f, 0.13831811f, 
    -0.22193679f, -0.03750603f, 0.13669118f, -0.13360305f, -0.28935280f, -0.20958549f, 0.02416176f, -0.09117129f, 
    -0.09047186f, 0.15284228f, 0.02244868f, -0.00740087f, 0.02071300f, -0.06771704f, -0.08668958f, -0.11281274f, 
    -0.03389213f, 0.00872304f, -0.00264230f, 0.01240766f, 0.22739969f, 0.06555115f, -0.06326690f, -0.28019777f, 
    -0.23410994f, -0.08417726f, -0.00831058f, 0.03150803f, 0.00895010f, 0.03494018f, -0.11092343f, 0.03121332f, 
    -0.07485390f, 0.03707764f, 0.09546622f, 0.06661079f, 0.06886867f, -0.00063915f, 0.05510120f, -0.00963389f, 
    -0.04725353f, -0.09348749f, -0.18064629f, 0.10086631f, -0.04712053f, 0.02922292f, 0.08560123f, -0.05609898f, 
    -0.03683348f, 0.02163946f, 0.10155193f, 0.10653845f, 0.37726876f, 0.14277810f, 0.00728262f, -0.10444915f, 
    -0.02964262f, -0.11205868f, 0.02749630f, 0.03769687f, -0.04785014f, 0.33122119f, -0.00579609f, -0.09972122f, 
    -0.20482758f, -0.24427810f, -0.04104509f, -0.07338295f, -0.13493186f, 0.04221885f, 0.16635326f, -0.02880476f, 
    0.07077869f, -0.09026337f, 0.16055225f, 0.01235135f, 0.12317442f, 0.07683222f, 0.04295680f, 0.04222711f, 
    0.04734316f, -0.20938660f, 0.36533457f, 0.33437720f, 0.33575997f, -0.03818179f, -0.12032371f, -0.04082010f, 
    0.04378955f, -0.09309967f, -0.09825841f, 0.02087634f, -0.00111598f, 0.13045667f, 0.03267770f, -0.03430536f, 
    -0.21679597f, 0.04157166f, 0.04331904f, 0.06209221f, 0.17960997f, 0.11236032f, 0.34669366f, 0.06386976f, 
    -0.18012430f, -0.08707833f, 0.06063683f, 0.02148820f, 0.01677263f, -0.04223759f, 0.03505773f, 0.27091655f, 
    -0.00352864f, 0.04272940f, 0.04205390f, 0.12032058f, 0.17442398f, -0.22198941f, -0.12823085f, -0.09414361f, 
    0.04545848f, -0.07220159f, -0.04589545f, -0.03588872f, 0.12084639f, 0.06130351f, -0.03763101f, -0.08870610f, 
    -0.33787861f, -0.15489875f, 0.06512330f, 0.06388886f, 0.10200203f, 0.10666818f, -0.07360556f, 0.09811065f, 
    0.27215290f, 0.43456900f, 0.36906129f, -0.04124667f, -0.22752085f, 0.04417304f, 0.06719723f, -0.05029265f, 
    -0.00371001f, 0.17938544f, 0.31593966f, 0.08307014f, -0.00837598f, -0.03174499f, -0.00255295f, 0.00565237f, 
    0.14821185f, -0.13905323f, 0.26300976f, 0.31863734f, 0.16322209f, -0.00464643f, -0.00187903f, 0.00933875f, 
    0.09903899f, -0.00214319f, -0.14663295f, -0.27747893f, -0.00119899f, -0.15661331f, -0.03861121f, -0.12098689f, 
    0.05951697f, 0.09733904f, 0.03640882f, -0.04079118f, -0.48337200f, -0.06193220f, -0.28255120f, -0.11841751f, 
    -0.14076418f, -0.30728585f, 0.01484278f, 0.09992409f, 0.10431724f, -0.09872440f, 0.04439364f, -0.09660853f, 
    -0.18233413f, -0.01126567f, -0.12618113f, 0.09080821f, -0.07334681f, 0.08857846f, -0.14062995f, 0.24334270f, 
    -0.03173140f, 0.08934788f, 0.04703086f, -0.41352427f, 0.06031730f, 0.03984636f, 0.15440749f, -0.27282721f, 
    -0.09766120f, -0.39114600f, 0.01009713f, -0.08681280f, -0.02704059f, 0.19438317f, 0.12459809f, 0.02906533f, 
    0.15922554f, -0.25442073f, -0.10460504f, -0.11513589f, 0.09810286f, -0.00304755f, 0.04767657f, 0.15437013f, 
    0.04856457f, 0.09828819f, 0.12953018f, 0.08255737f, -0.22380675f, -0.09024014f, -0.06364030f, 0.07474703f, 
    0.20030327f, -0.11443806f, 0.17077014f, 0.20914395f, 0.04980373f, 0.10016663f, -0.02894522f, -0.00714030f, 
    0.10630131f, 0.09180773f, 0.04409194f, -0.16040272f, -0.27639720f, 0.00744478f, 0.17906485f, 0.06955969f, 
    0.14808077f, 0.10423148f, -0.04663363f, -0.05469373f, 0.15771611f, 0.15499915f, 0.02785262f, -0.14462295f, 
    -0.15103200f, -0.07780275f, 0.01837015f, 0.04446978f, -0.00213657f, 0.16380426f, -0.11231668f, -0.08263744f, 
    0.00512882f, -0.08252238f, -0.19716890f, 0.01301425f, -0.06012860f, 0.02786487f, -0.47799072f, -0.21789522f, 
    0.14712460f, -0.10051936f, 0.04957387f, -0.16090459f, -0.04927650f, -0.01993210f, 0.14657378f, -0.03377153f, 
    -0.19130827f, -0.17176230f, 0.10942831f, -0.06915300f, 0.10378872f, 0.01145818f, 0.14590012f, 0.10436994f, 
    -0.16121988f, 0.02072533f, -0.24987428f, -0.15544668f, -0.20887475f, 0.07882661f, -0.02106721f, 0.07974453f, 
    -0.17550831f, 0.05742934f, -0.17143553f, -0.11682460f, 0.00940419f, 0.17649697f, 0.21400911f, 0.05060758f, 
    0.05314600f, 0.10879738f, 0.11710042f, -0.12511638f, -0.07609904f, 0.13832796f, 0.04561221f, 0.04294024f, 
    -0.10252672f, -0.20035575f, 0.00816267f, 0.24385419f, -0.14830741f, -0.21869385f, 0.10434720f, 0.06880721f, 
    0.11573139f, 0.02363058f, 0.06515728f, 0.05474519f, 0.08660679f, 0.10791383f, 0.19320782f, 0.00714397f, 
    -0.05532106f, 0.01849322f, -0.08781788f, 0.10313973f, 0.07474206f, 0.25013161f, 0.12010317f, 0.12236512f, 
    0.17861935f, 0.25014067f, 0.20204553f, -0.01513702f, 0.10465544f, 0.10289922f, 0.07358097f, -0.10848624f, 
    -0.09792418f, -0.03814800f, 0.00479366f, -0.13527565f, 0.04643660f, 0.03791578f, -0.12151382f, 0.22452919f, 
    0.02020857f, -0.10335873f, -0.08926805f, -0.08285209f, -0.02187780f, -0.20970771f, -0.11633544f, -0.08348978f, 
    -0.12345304f, 0.19986418f, -0.15546592f, -0.10560284f, 0.02934921f, 0.08203623f, 0.15451215f, 0.00899134f, 
    0.14846706f, -0.06272364f, 0.04492839f, 0.06785480f, -0.05872614f, -0.21768412f, 0.14229505f, 0.06336164f, 
    0.10261282f, -0.18050317f, 0.24458539f, 0.21913841f, -0.03080902f, -0.05019710f, -0.16248114f, 0.07848500f, 
    -0.06053926f, -0.01667286f, -0.01774448f, -0.49896631f, -0.32331085f, -0.28144345f, 0.10238361f, 0.03526777f, 
    0.03314991f, -0.12530833f, -0.04215867f, -0.03325029f, 0.14093852f, 0.17260931f, 0.02419494f, 0.23410337f, 
    0.19428423f, -0.04556870f, 0.09011647f, -0.07378358f, 0.04315237f, 0.06224600f, -0.13167833f, -0.03811751f, 
    0.01582644f, 0.04780600f, 0.02362616f, 0.06838333f, 0.01135179f, 0.00084681f, 0.12474874f, 0.02662456f, 
    -0.13856727f, -0.06858297f, 0.04177799f, -0.15864439f, -0.02681626f, 0.10129362f, 0.03407863f, -0.08501844f, 
    0.02240690f, -0.19004630f, -0.04902130f, 0.00314021f, -0.04474634f, -0.05355710f, 0.21070705f, 0.01313184f, 
    0.15867782f, 0.20188996f, 0.06615484f, 0.06456345f, -0.08607522f, 0.16030709f, -0.00306284f, 0.07215217f, 
    -0.18393731f, 0.02925885f, 0.18290026f, -0.10917699f, -0.12082738f, -0.27040139f, 0.02767911f, -0.04178696f, 
    0.10636204f, -0.04705678f, 0.00157912f, 0.14684866f, -0.04660912f, -0.09093569f, -0.20579576f, -0.01446520f, 
    -0.00140584f, 0.10670859f, -0.02187867f, -0.13024193f, -0.11599326f, -0.11925463f, 0.10769930f, 0.09693215f, 
    0.01982941f, -0.00551414f, 0.07423465f, -0.00723488f, 0.22070247f, -0.12425546f, 0.21901920f, 0.05993704f, 
    -0.06054835f, -0.13309519f, 0.14660850f, 0.12231582f, 0.06458502f, 0.17431524f, 0.33102295f, -0.07746454f, 
    0.05228075f, 0.18112364f, 0.20247769f, -0.12182289f, 0.09259503f, 0.02128373f, 0.31701374f, 0.29733557f, 
    -0.01769156f, 0.10585512f, -0.00664655f, 0.21029645f, 0.05515752f, -0.18020058f, -0.09703267f, -0.21089491f, 
    0.14336576f, -0.01934757f, -0.12992421f, -0.14994806f, 0.24672090f, -0.05575605f, 0.07976807f, -0.26514286f, 
    0.05222973f, -0.11134233f, -0.17702305f, 0.05365428f, 0.18036672f, 0.14413588f, -0.00564371f, -0.15766051f, 
    0.11976604f, 0.20054644f, 0.05854670f, -0.08444846f, -0.03157016f, 0.19859372f, -0.02039392f, -0.00063183f, 
    -0.03027902f, 0.14901559f, -0.03383882f, 0.10258739f, -0.03543818f, -0.01401231f, -0.03859930f, 0.08525047f, 
    -0.05461887f, -0.08020287f, -0.12575111f, -0.32605958f, 0.06067405f, 0.14755626f, -0.09095247f, -0.02374891f, 
    -0.02302476f, 0.06844360f, -0.02135624f, -0.10726690f, 0.04344908f, -0.16454831f, -0.31441262f, 0.05017780f, 
    -0.02600881f, 0.04993627f, -0.09923034f, -0.16572359f, -0.13461590f, -0.00761149f, -0.17674951f, -0.38645086f, 
    -0.04202485f, 0.06668136f, -0.07788745f, 0.21876286f, 0.26411131f, 0.08887451f, 0.13032202f, 0.33321312f, 
    -0.02100188f, -0.27383903f, 0.09523152f, 0.09146161f, 0.05917733f, -0.15642446f, -0.01246690f, 0.04555392f, 
    0.16985500f, 0.18782268f, 0.06655245f, -0.09944891f, -0.12132822f, -0.01185444f, -0.08969653f, 0.04454513f, 
    0.19812959f, 0.15062316f, -0.09544082f, -0.03182532f, -0.15490195f, 0.09882128f, 0.11057688f, 0.01735368f, 
    -0.21608531f, 0.16739760f, 0.14756468f, 0.03173059f, 0.11682705f, 0.08752046f, 0.04602091f, 0.12020274f, 
    0.06704675f, 0.06735967f, 0.02366921f, -0.00114113f, -0.04837227f, 0.05689272f, 0.12953469f, -0.08450526f, 
    0.00830296f, -0.12921588f, -0.19424932f, -0.09928150f, 0.17307918f, 0.01804462f, -0.06191874f, 0.06746286f, 
    0.10917779f, 0.04371922f, -0.05847801f, 0.00356936f, -0.13679393f, 0.07335672f, 0.05393316f, 0.02538899f, 
    0.06407365f, 0.14849816f, 0.01683157f, 0.11656786f, 0.19125147f, 0.11127705f, 0.05568398f, 0.05584027f, 
    -0.02860183f, 0.09953729f, 0.10358652f, -0.00076570f, 0.14024104f, 0.39235771f, 0.25467449f, -0.07628197f, 
    0.14399312f, 0.18452929f, -0.02791691f, -0.00006325f, -0.17018305f, -0.11393279f, -0.31503162f, 0.13760440f, 
    -0.04525129f, -0.13218933f, 0.01626718f, 0.00950804f, 0.02969506f, 0.00760131f, -0.07167549f, -0.09957326f, 
    -0.16788115f, 0.22783884f, 0.24545620f, -0.03418431f, 0.00618784f, 0.17860919f, 0.05621162f, -0.01382444f, 
    0.01926487f, 0.16863637f, 0.21607216f, -0.09528080f, 0.03030735f, -0.10817506f, -0.14096534f, 0.08206664f, 
    -0.00032614f, -0.23852932f, -0.01946019f, 0.01798842f, -0.06949569f, 0.19888049f, -0.06040101f, 0.10562132f, 
    -0.14461413f, -0.17391296f, -0.05533141f, -0.05334803f, -0.02024137f, 0.00453770f, 0.10115865f, -0.03729287f, 
    -0.03171217f, -0.12357271f, -0.04516899f, -0.29552668f, 0.06758865f, -0.22955884f, -0.17147867f, 0.15649769f, 
    0.09919022f, 0.11189884f, -0.04952979f, -0.04127789f, -0.05522481f, -0.11076427f, 0.02587423f, -0.00750367f, 
    -0.05329688f, 0.09681778f, 0.03576615f, 0.01924253f, -0.09365788f, -0.06787129f, 0.05155071f, -0.06028160f, 
    -0.05797626f, 0.09729508f, 0.07110807f, 0.02730769f, -0.11158901f, -0.10368044f, -0.16938579f, -0.00510953f, 
    -0.00033585f, 0.01914684f, 0.12132578f, 0.00631975f, -0.06325913f, 0.10143461f, 0.12133003f, -0.10437253f, 
    0.02542334f, 0.01279300f, 0.05637891f, 0.06034904f, 0.11739816f, 0.06581859f, -0.13659613f, -0.12688443f, 
    -0.14441349f, -0.02336527f, 0.07490873f, 0.00585144f, 0.10379802f, 0.01700526f, -0.19542840f, -0.16155429f, 
    -0.25051755f, -0.24193721f, 0.07936582f, 0.04586785f, 0.04076314f, 0.18472712f, -0.05520528f, 0.02079541f, 
    -0.05622205f, 0.04702942f, -0.07943189f, -0.10275708f, -0.04788833f, 0.08942184f, -0.03757811f, -0.00422854f, 
    -0.03677547f, -0.00072038f, -0.27779296f, -0.16126530f, 0.28160945f, 0.31905735f, -0.21373993f, -0.04184211f, 
    -0.00751948f, 0.12502064f, 0.11434743f, -0.08705708f, -0.07906660f, 0.04652649f, 0.03886062f, 0.09825221f, 
    -0.03861379f, -0.07315641f, 0.01442249f, -0.12023062f, 0.21386963f, 0.31566441f, 0.06673291f, 0.14444974f, 
    -0.06427786f, 0.07982994f, -0.11717103f, 0.19741186f, -0.02231866f, -0.17649250f, 0.22632991f, -0.01326238f, 
    0.08439818f, 0.04285160f, -0.00525528f, 0.03888302f, 0.10193068f, 0.16428176f, 0.05915675f, -0.09165365f, 
    -0.09583470f, 0.06550961f, -0.01775199f, 0.05434542f, 0.10920308f, 0.00791384f, -0.08886030f, -0.22149083f, 
    0.09557461f, 0.03475859f, 0.11800946f, 0.02160775f, 0.14949691f, 0.04627075f, 0.02768369f, -0.12600017f, 
    -0.15688837f, 0.00607833f, 0.10796578f, 0.02843017f, -0.04007374f, 0.12617946f, -0.01309186f, -0.12607433f, 
    -0.34529683f, -0.42249864f, -0.34725246f, 0.08256837f, 0.24512345f, 0.17108840f, 0.02888836f, -0.04746912f, 
    0.05511331f, 0.16680922f, 0.10262001f, 0.15261920f, -0.01105621f, -0.05770560f, -0.01621656f, 0.04359077f, 
    0.07035457f, 0.02924971f, -0.07693820f, -0.27690592f, -0.23170403f, -0.09973934f, -0.12010409f, -0.26549500f, 
    0.07786250f, 0.08096536f, 0.28188804f, -0.16009670f, 0.00094783f, -0.14412749f, 0.39071715f, 0.05954437f, 
    -0.13025314f, 0.07234965f, 0.03891828f, 0.02222957f, 0.01835063f, 0.10633732f, -0.15142021f, -0.01588004f, 
    0.09163079f, -0.00791966f, 0.18788484f, 0.07773431f, 0.09834515f, 0.18449734f, -0.04832080f, 0.09352136f, 
    -0.05834823f, -0.38445553f, 0.04333169f, 0.14942431f, 0.10795084f, -0.06387455f, -0.16393739f, 0.01573873f, 
    0.04899341f, -0.22318409f, -0.04514210f, -0.14586763f, -0.05082007f, -0.10631034f, -0.17978746f, 0.19777830f, 
    -0.12831225f, 0.28710452f, 0.06164276f, -0.06124461f, -0.01432715f, -0.12540248f, -0.09344605f, -0.09858834f, 
    0.11516764f, -0.03467184f, 0.04493072f, 0.20648861f, 0.04011012f, 0.14914456f, -0.06731121f, -0.22763881f, 
    -0.09622048f, 0.12410951f, 0.06116622f, 0.05826394f, 0.07728878f, -0.00657660f, -0.22857541f, 0.02502865f, 
    -0.07441524f, -0.10434151f, -0.09977096f, 0.18822488f, -0.08141936f, -0.19748092f, -0.05951368f, 0.15721868f, 
    0.06849489f, 0.06771378f, -0.17481764f, 0.09861214f, 0.02414719f, 0.13396022f, -0.09214458f, 0.11520793f, 
    -0.07550313f, -0.02179630f, 0.00406544f, 0.23456885f, -0.14305502f, -0.10441187f, 0.06271704f, -0.07527197f, 
    -0.23304734f, -0.12408393f, -0.04504995f, -0.08281823f, -0.15039290f, 0.06452738f, -0.01943841f, 0.04476741f, 
    0.26291180f, 0.15540676f, 0.02243935f, 0.00736866f, -0.00531909f, 0.13953750f, -0.11008904f, 0.15351816f, 
    0.06831274f, 0.03100721f, -0.39298552f, 0.14619336f, 0.01268761f, 0.16298012f, -0.03465592f, -0.16048141f, 
    -0.05585653f, 0.12361033f, -0.15371296f, -0.12052196f, -0.07831092f, -0.08693925f, -0.02019827f, -0.05649889f, 
    0.04357577f, -0.05874762f, -0.35546985f, -0.03316072f, 0.16292709f, -0.06190336f, -0.15991469f, -0.01600884f, 
    0.08180578f, 0.06716027f, 0.17046151f, 0.11858074f, -0.35704467f, 0.09003700f, -0.03818600f, -0.03279829f, 
    0.05728159f, 0.00951336f, -0.02013599f, -0.01821574f, -0.28297412f, 0.04261374f, 0.04072351f, 0.22107147f, 
    0.01208138f, -0.01875985f, 0.02374760f, 0.06278083f, 0.17362091f, 0.07902488f, 0.12539674f, 0.04277720f, 
    0.05126078f, 0.16585803f, 0.12111379f, -0.03494952f, -0.02951627f, -0.05908236f, 0.07195665f, -0.16028336f, 
    -0.15698433f, -0.23220676f, 0.01197402f, 0.11177395f, 0.01818631f, -0.05713301f, -0.00048403f, 0.17753039f, 
    -0.16318311f, -0.08279851f, -0.26156437f, -0.00678958f, 0.01825455f, -0.06091170f, 0.01112814f, -0.13862129f, 
    -0.26629719f, 0.02011913f, -0.17623833f, -0.18251047f, 0.07062760f, 0.14037409f, 0.05230694f, -0.09830769f, 
    -0.05021006f, -0.00687913f, 0.01879558f, -0.49481118f, -0.12877759f, 0.05163958f, 0.03019199f, 0.04375521f, 
    0.04067315f, -0.09138873f, -0.05919297f, 0.12409282f, 0.06680220f, -0.09740112f, 0.02601561f, 0.00800403f, 
    0.10407686f, 0.17162022f, 0.25729162f, -0.00915253f, -0.21237344f, -0.42917070f, 0.06356914f, -0.06496865f, 
    0.03420041f, 0.06795162f, -0.04244705f, 0.21096145f, -0.06842882f, -0.22727396f, 0.12188697f, 0.07207134f, 
    0.01697453f, 0.08129074f, -0.07095748f, 0.20713568f, -0.03271044f, 0.05320914f, -0.27427292f, -0.24883635f, 
    0.08250199f, -0.06199985f, -0.10312197f, 0.05509922f, 0.05073243f, -0.11599001f, -0.30979180f, -0.04144752f, 
    -0.10546582f, 0.17346987f, 0.04990737f, 0.21599357f, -0.00389621f, 0.03335334f, 0.00759853f, 0.11379692f, 
    -0.01434411f, -0.07438915f, 0.19713725f, 0.05801387f, 0.15644190f, 0.20814484f, 0.11692308f, 0.14491911f, 
    0.04605105f, -0.13174196f, 0.00187297f, 0.36375195f, 0.10597834f, -0.11169373f, 0.02987740f, -0.08448341f, 
    -0.05644914f, -0.00409796f, 0.04575388f, 0.17362018f, 0.01997069f, 0.08812521f, 0.21620302f, 0.06488791f, 
    -0.00509727f, -0.12029392f, 0.08185543f, -0.19939290f, -0.14257918f, -0.24325417f, -0.05610490f, 0.02395561f, 
    0.02503646f, 0.07154624f, -0.17232729f, -0.25874886f, -0.10120043f, -0.05091161f, -0.05213705f, -0.27706379f, 
    -0.13795280f, -0.04724530f, -0.05932823f, -0.00146273f, 0.03787531f, -0.27064049f, -0.03796529f, -0.02114485f, 
    0.02349637f, -0.03311678f, 0.02435232f, -0.14501910f, -0.08733885f, -0.01378141f, -0.12111425f, -0.07127199f, 
    -0.05913865f, 0.06243965f, 0.07258482f, 0.03609632f, 0.19648246f, 0.27110732f, -0.00598003f, -0.09595365f, 
    -0.03919941f, -0.25561059f, -0.05464961f, 0.03117049f, -0.08612312f, -0.14542815f, -0.16733550f, -0.11645783f, 
    0.04905378f, -0.12675354f, 0.04251201f, -0.01919536f, -0.17409092f, -0.06956931f, 0.05307920f, -0.12930126f, 
    0.06715751f, -0.41135702f, -0.33312839f, -0.10877827f, -0.09498433f, -0.05664350f, -0.00400106f, 0.24337192f, 
    0.03590155f, 0.10471786f, -0.01581041f, -0.37752429f, -0.07510475f, -0.02076448f, -0.16236983f, -0.12434679f, 
    0.14918298f, -0.12758972f, 0.09341256f, -0.31169283f, -0.61332226f, -0.15119319f, 0.00970331f, -0.11185693f, 
    -0.04931080f, 0.15750134f, 0.03753864f, 0.00898189f, -0.02239972f, 0.15584083f, 0.20818873f, 0.12306092f, 
    0.01462328f, -0.06768101f, 0.13280797f, 0.04502116f, 0.08253202f, 0.07350788f, -0.11399661f, -0.18777843f, 
    -0.10306133f, -0.00878778f, -0.02792043f, 0.05939773f, -0.01358685f, 0.01794026f, -0.31074300f, -0.12195142f, 
    -0.28044599f, -0.15902805f, -0.06140677f, 0.18221352f, -0.02222833f, -0.03103155f, 0.04749099f, 0.26447898f, 
    -0.32500723f, -0.19665316f, 0.30928183f, -0.07018698f, -0.26484755f, 0.03324193f, 0.05611484f, 0.04096719f, 
    0.21795516f, -0.27471077f, -0.10630960f, 0.00344100f, -0.07463416f, 0.06140074f, -0.08171970f, -0.02807388f, 
    -0.06473738f, -0.29745725f, -0.52004117f, -0.18115453f, -0.03935985f, -0.05740076f, -0.02542027f, 0.05171581f, 
    0.02033826f, -0.01475055f, -0.07361557f, 0.16288494f, 0.30473709f, -0.05644258f, -0.02363008f, 0.04471939f, 
    -0.02308351f, 0.01954285f, 0.06944875f, 0.00865329f, -0.26367104f, -0.08282746f, -0.05082170f, -0.03509462f, 
    0.08062902f, 0.02793887f, 0.09732113f, 0.08831050f, 0.17157979f, 0.12078489f, 0.06681203f, -0.06063674f, 
    -0.10166757f, -0.10234463f, -0.01590246f, -0.04415457f, -0.08463728f, -0.11802614f, -0.13313428f, 0.26694834f, 
    0.01175367f, 0.13960624f, -0.05505481f, -0.11196546f, 0.07742018f, 0.24834399f, -0.13787632f, -0.18881273f, 
    0.17069158f, -0.12426416f, 0.06426023f, 0.01519663f, 0.06691042f, 0.04591705f, 0.04077028f, -0.14520909f, 
    -0.25947300f, 0.22041616f, -0.01718183f, -0.19520219f, -0.07032607f, -0.18213333f, -0.01520896f, -0.09217542f, 
    -0.03398303f, 0.20931861f, 0.33408087f, -0.12656514f, 0.04685034f, -0.04213135f, -0.01175343f, -0.13491476f, 
    0.11287670f, 0.01236576f, -0.02837013f, -0.03993811f, 0.02012374f, 0.12752819f, 0.16404356f, 0.14748536f, 
    0.01538073f, 0.03753358f, 0.01828943f, -0.02442418f, 0.09980857f, -0.13218294f, 0.02722551f, 0.09960930f, 
    0.09775967f, -0.05275340f, 0.12799747f, -0.29022393f, -0.06028232f, 0.16693674f, 0.17222632f, 0.05600842f, 
    0.18568623f, 0.17654280f, 0.05257556f, 0.17459124f, -0.94743854f, -0.47512692f, 0.24785067f, -0.06543934f, 
    -0.09665931f, -0.02870145f, -0.11338608f, -0.06660150f, 0.15142062f, -0.07351720f, -0.06347889f, 0.10532246f, 
    -0.11727284f, 0.05089274f, -0.07735189f, 0.24774414f, 0.06755908f, -0.01513346f, 0.05709727f, 0.05162435f, 
    0.22312328f, -0.13886152f, 0.08198516f, -0.08892396f, -0.02723311f, -0.02546543f, 0.17456943f, 0.01551380f, 
    -0.59410286f, -0.07578621f, 0.20731485f, -0.12773539f, -0.28348070f, -0.04952237f, 0.00268827f, 0.20821489f, 
    -0.09573933f, -0.12946481f, 0.18388310f, 0.13576798f, -0.04385300f, 0.01374470f, -0.00395158f, 0.05587170f, 
    0.03637497f, -0.15897663f, -0.16063771f, 0.37062657f, 0.04686700f, -0.22139505f, -0.09010759f, 0.04475148f, 
    0.26974162f, 0.25148159f, 0.04243847f, 0.02820838f, 0.18690562f, 0.02235974f, 0.10313789f, -0.11277407f, 
    0.02903503f, 0.00939866f, 0.17571889f, 0.37924880f, 0.09225184f, -0.17704593f, -0.06072408f, 0.02953803f, 
    -0.08282891f, -0.02780965f, 0.06109485f, 0.00187153f, 0.07531511f, -0.36788455f, -0.11679792f, -0.02201805f, 
    -0.11630060f, -0.09865480f, 0.04324913f, -0.02682835f, 0.07146036f, 0.01916395f, -0.10707305f, -0.06107558f, 
    -0.01990051f, -0.14764437f, 0.00465481f, 0.08878189f, -0.23870806f, 0.11875095f, -0.24088997f, -0.58496046f, 
    0.02141469f, -0.16739771f, -0.08394507f, -0.19180641f, 0.15768421f, 0.02197192f, 0.05162937f, 0.14578225f, 
    0.07134896f, -0.07578985f, 0.04255078f, -0.01599880f, -0.10384608f, 0.22777312f, 0.02141158f, -0.00454211f, 
    0.05016520f, 0.05367327f, 0.04925830f, -0.00528983f, -0.05333424f, 0.05127375f, -0.04281971f, -0.05478071f, 
    0.04560239f, -0.06002639f, 0.00196694f, 0.05875593f, 0.00015616f, -0.05070472f, -0.04855888f, 0.03845374f, 
    -0.05323048f, -0.00688005f, -0.04563970f, 0.02703839f, 0.02298203f, 0.05264709f, 0.05843877f, 0.01020129f, 
    -0.05508690f, -0.05176969f, -0.02744824f, -0.02269966f, 0.02587232f, -0.04228369f, -0.04636275f, 0.01124416f, 
    -0.01864394f, 0.02002849f, -0.01318794f, 0.01032213f, -0.02967166f, -0.02657488f, -0.04642256f, -0.03792521f, 
    0.03653113f, 0.01001985f, -0.00432090f, -0.05314016f, -0.01502339f, -0.01913639f, -0.05763161f, -0.01733474f, 
    -0.05125592f, 0.02326813f, 0.00646980f, -0.02731852f, 0.02307270f, -0.04636246f, 0.04198079f, 0.03873400f, 
    0.02252376f, 0.00666171f, 0.05461505f, -0.02285737f, -0.06220178f, -0.05502944f, -0.05238191f, 0.05537920f, 
    -0.03916201f, 0.05437233f, 0.00776001f, -0.01768681f, 0.02710129f, -0.04954995f, -0.02089151f, -0.00781599f, 
    0.02897969f, -0.05273493f, -0.05494796f, -0.06150742f, -0.02591288f, 0.00949569f, 0.01185642f, 0.01381320f, 
    -0.04945363f, 0.00459255f, -0.02428306f, -0.02447259f, -0.02524727f, 0.00129998f, 0.02854272f, -0.00038987f, 
    -0.03616548f, -0.05667875f, -0.05725892f, 0.01864752f, 0.02464968f, 0.01073004f, 0.00144860f, -0.05644316f, 
    0.03321462f, 0.02752944f, 0.01834615f, 0.01948777f, -0.05653067f, -0.03460300f, -0.04304741f, -0.01291164f, 
    -0.01559075f, -0.05864681f, -0.05721243f, 0.02569466f, -0.06347282f, -0.04826146f, 0.02648612f, 0.04377521f, 
    0.03630882f, 0.04544394f, 0.03676428f, -0.00338117f, -0.06211933f, 0.00615453f, 0.02695263f, -0.05869355f, 
    -0.03321204f, 0.03982559f, -0.02969496f, -0.04543935f, -0.02129888f, -0.01553099f, -0.05704851f, -0.01298130f, 
    0.02680911f, -0.02905532f, -0.03039565f, 0.04669275f, 0.02915260f, 0.05053473f, 0.00219225f, -0.03303168f, 
    0.03138110f, -0.04800707f, -0.03545707f, -0.00785513f, 0.05708106f, 0.00209149f, 0.00973414f, -0.04505179f, 
    0.00120914f, 0.02107784f, 0.00828122f, 0.03867076f, -0.03032955f, -0.02157283f, -0.01656779f, -0.06278718f, 
    -0.05066605f, -0.05706471f, -0.00475215f, -0.04372118f, -0.04322411f, 0.05083094f, 0.01091130f, 0.03862754f, 
    -0.01064937f, -0.02761881f, -0.01517563f, 0.03759245f, 0.02780635f, 0.04301866f, -0.06232129f, 0.05089222f, 
    -0.05103614f, 0.01163108f, 0.01943312f, -0.01971384f, -0.00669906f, -0.01505612f, 0.03686386f, 0.04496889f, 
    -0.03199986f, 0.04177402f, -0.05301169f, -0.04155132f, -0.00507678f, -0.03714262f, -0.01162039f, -0.00849389f, 
    -0.02612427f, 0.05485415f, 0.02321148f, -0.01508388f, -0.00206870f, 0.03503035f, 0.03129482f, 0.02198655f, 
    0.00399509f, 0.00892419f, 0.01950845f, -0.05424633f, 0.05288448f, 0.02944926f, -0.02488557f, -0.03673622f, 
    0.00498237f, -0.03617227f, 0.02154249f, -0.02431227f, 0.02370996f, -0.00822230f, -0.03502869f, 0.01879225f, 
    0.03974621f, 0.03950744f, -0.02748973f, -0.00108397f, -0.03928636f, -0.03323548f, -0.01561060f, -0.01810028f, 
    -0.03269116f, 0.03413211f, 0.02686709f, 0.03473191f, 0.04877299f, 0.02331252f, 0.00669211f, -0.01832406f, 
    0.00876026f, 0.03003666f, 0.02224655f, -0.05563048f, 0.03093295f, 0.05258032f, -0.01188710f, 0.01061386f, 
    0.02722352f, 0.01015743f, -0.00482420f, -0.02448419f, -0.03227555f, -0.05706697f, -0.03188810f, -0.05460108f, 
    -0.01690791f, -0.05301397f, -0.04737735f, -0.02045250f, 0.01189807f, -0.01552153f, 0.04470912f, -0.03603116f, 
    -0.02650541f, -0.05047563f, 0.02325191f, -0.00101776f, -0.02754541f, -0.01807782f, -0.03003659f, 0.00049795f, 
    -0.00703800f, 0.02907419f, 0.00703822f, 0.05087100f, -0.02407572f, 0.04553021f, -0.05272699f, 0.01477098f, 
    0.01210542f, 0.04802095f, -0.00937092f, -0.01687284f, 0.04364502f, 0.00995107f, -0.01623723f, -0.02268516f, 
    0.01646048f, -0.02883584f, 0.01364554f, 0.03831458f, 0.05175119f, -0.00113320f, 0.04310718f, 0.02494203f, 
    -0.00598212f, -0.02184758f, -0.05102384f, -0.03497543f, 0.00564791f, 0.02648558f, 0.04591153f, -0.06208388f, 
    -0.04924223f, -0.18158205f, -0.04260840f, -0.08342890f, 0.13417774f, -0.06356747f, 0.02395247f, -0.03838737f, 
    -0.09569564f, 0.12945892f, 0.12665679f, -0.11948982f, 0.06111789f, 0.06780377f, -0.01186109f, -0.03180256f, 
    0.06827641f, 0.17486905f, -0.17639720f, -0.37457237f, -0.20992146f, 0.02835185f, -0.01611813f, -0.03329511f, 
    -0.04557004f, 0.05175350f, 0.14001518f, -0.19934954f, -0.21335129f, -0.40384391f, 0.16591035f, 0.01941649f, 
    0.01059080f, 0.05106431f, 0.07311361f, 0.04072855f, 0.03624788f, 0.18099497f, 0.00568634f, 0.17487215f, 
    -0.01256796f, 0.12414452f, 0.06630911f, -0.07469852f, 0.01667250f, -0.19222847f, -0.07432505f, 0.07074787f, 
    0.14743799f, 0.19238330f, 0.00558575f, -0.06611100f, -0.07216449f, 0.01634610f, 0.20041104f, 0.16192901f, 
    -0.10056693f, 0.02471786f, 0.13338961f, 0.09665931f, -0.05972676f, 0.02152214f, -0.16865869f, -0.01139748f, 
    -0.09375267f, -0.10183503f, 0.05525423f, 0.04798907f, -0.05845776f, -0.01474498f, 0.04654856f, 0.05169537f, 
    -0.05712551f, 0.16927107f, -0.14267492f, -0.04774622f, 0.22871858f, -0.09638174f, 0.12086146f, -0.05164260f, 
    0.05441881f, -0.16979647f, -0.28371555f, -0.13382594f, -0.02845607f, -0.02455575f, -0.08842128f, -0.02529535f, 
    0.08176020f, 0.01681573f, 0.40591279f, 0.21542376f, 0.32888272f, 0.06922054f, -0.11779988f, -0.07468308f, 
    0.02611367f, -0.10933571f, 0.01732701f, -0.20259778f, -0.14799879f, -0.21233302f, 0.19312739f, 0.14839484f, 
    0.10152631f, -0.09082834f, 0.00645444f, 0.08015114f, -0.10950174f, -0.05932156f, 0.06545322f, 0.14960039f, 
    -0.01703136f, 0.18113674f, -0.03138743f, -0.15660968f, -0.08504193f, 0.05019154f, -0.02754286f, 0.07727677f, 
    -0.03108831f, -0.06617558f, -0.06382140f, 0.15482716f, 0.13207778f, -0.02595743f, 0.01293721f, -0.09267518f, 
    -0.27966988f, 0.03985313f, -0.03550947f, -0.00059267f, -0.11122613f, -0.06605960f, -0.10259465f, 0.00198396f, 
    -0.13877919f, -0.25421005f, 0.12653410f, -0.07084658f, 0.11762051f, 0.00056171f, 0.06308765f, 0.14822826f, 
    0.35546124f, 0.15520039f, 0.42970857f, 0.19068712f, -0.02950339f, -0.11382339f, -0.02682822f, -0.02845103f, 
    0.02373282f, 0.28395596f, 0.14568597f, 0.02621425f, -0.06245046f, -0.09970292f, -0.05899917f, -0.07731244f, 
    -0.01252681f, -0.05004233f, 0.17593846f, 0.10253957f, 0.23313709f, -0.06783949f, -0.06276904f, 0.01572883f, 
    -0.14994794f, 0.04028622f, 0.05285071f, -0.11014404f, -0.19601503f, -0.14912908f, 0.21527286f, 0.00032047f, 
    0.10133974f, -0.01135565f, 0.07517066f, -0.07528479f, -0.17092521f, -0.27464423f, -0.20324524f, 0.09688503f, 
    -0.22444208f, -0.25052917f, 0.05978832f, 0.27100858f, -0.16741604f, -0.06342575f, 0.13223927f, 0.04932029f, 
    0.10076353f, -0.00355161f, -0.04897266f, 0.02961038f, -0.11838688f, -0.01910307f, -0.02719913f, 0.01203803f, 
    0.41801035f, 0.11058000f, 0.04317701f, -0.11380152f, 0.14415579f, 0.05147728f, -0.06109036f, -0.07712358f, 
    -0.08435951f, -0.03214175f, -0.16925323f, 0.22848096f, -0.02449595f, -0.03484724f, 0.04043567f, -0.06461409f, 
    0.00598352f, 0.16814022f, 0.12885529f, -0.14685357f, 0.12308257f, 0.01326071f, 0.20990929f, -0.14687450f, 
    0.01383541f, 0.15760778f, 0.21675992f, 0.17522477f, -0.19168551f, 0.12495908f, -0.05126839f, 0.02239761f, 
    0.04344292f, 0.00538764f, 0.19313565f, 0.08205352f, 0.13729346f, -0.04611259f, 0.09392128f, 0.00658864f, 
    -0.08154885f, -0.22486505f, -0.15417506f, 0.08865744f, -0.21984959f, 0.02395036f, 0.21064451f, -0.03414330f, 
    -0.24534117f, 0.04303336f, 0.14363003f, 0.04354829f, -0.12362999f, -0.26672694f, -0.28478977f, -0.03534601f, 
    -0.00864903f, 0.01444126f, -0.15109137f, -0.06734692f, -0.05660724f, 0.07725836f, 0.03982319f, -0.29858503f, 
    -0.03338616f, 0.13237752f, -0.06143766f, -0.18281470f, -0.00909007f, -0.03550938f, -0.15346523f, -0.41155243f, 
    0.05332627f, -0.01259177f, -0.00762615f, -0.01806027f, 0.08697636f, 0.12378288f, -0.01108215f, 0.21307102f, 
    0.08860765f, -0.11058927f, 0.16227269f, -0.04638649f, -0.01481413f, 0.05867898f, 0.22711289f, 0.03834286f, 
    -0.12782985f, 0.11242857f, -0.12319119f, 0.01678404f, -0.02582800f, 0.02767112f, -0.16106345f, -0.01858833f, 
    -0.11894982f, -0.19256757f, -0.31229848f, -0.40274966f, -0.03010763f, -0.10774187f, 0.01593825f, 0.07036959f, 
    -0.13899529f, 0.05121382f, -0.14130618f, 0.15547539f, 0.21065305f, -0.00049199f, -0.11202525f, -0.07633697f, 
    0.16171901f, -0.01768227f, 0.06217646f, 0.00259049f, 0.08719832f, 0.02395646f, -0.00740720f, -0.17474423f, 
    0.06688052f, 0.03842194f, 0.02377392f, 0.11066139f, 0.04561910f, 0.33319479f, 0.40144512f, 0.05304054f, 
    -0.04559772f, 0.18560161f, 0.06405529f, 0.14914867f, 0.08160851f, -0.10767322f, -0.19767208f, 0.06032171f, 
    0.03245508f, -0.02636881f, -0.00842372f, 0.14824019f, 0.16291094f, 0.18730889f, -0.19743368f, -0.38741663f, 
    0.12717357f, -0.07979229f, 0.18608263f, -0.09262495f, 0.03104255f, -0.23882617f, -0.11700474f, 0.07807361f, 
    0.09705096f, -0.07792082f, -0.21433276f, -0.06810366f, -0.07969850f, 0.05553403f, -0.01743903f, -0.09915420f, 
    0.03283986f, 0.05621790f, 0.30149201f, -0.20289761f, -0.05034819f, 0.17242293f, -0.07945887f, 0.04370219f, 
    0.05774999f, -0.19638392f, 0.29091537f, 0.07099898f, -0.10398860f, 0.04036431f, -0.05880304f, -0.00990689f, 
    -0.01904717f, -0.07268540f, 0.05507850f, 0.00668644f, 0.11736520f, 0.01894351f, 0.06413703f, -0.07782172f, 
    0.06150379f, -0.05305167f, -0.04071793f, 0.01065659f, 0.12243643f, 0.22685747f, -0.06472681f, 0.00272541f, 
    -0.08310927f, -0.04677799f, -0.02243695f, -0.11521458f, -0.08377343f, -0.09301562f, 0.35678887f, 0.06437530f, 
    -0.12101194f, -0.17699736f, 0.11911073f, 0.01539638f, -0.03172440f, 0.02331633f, 0.44323775f, 0.07751789f, 
    -0.05570181f, -0.02787736f, 0.03009962f, -0.01743720f, 0.20296930f, 0.05084627f, -0.15794854f, -0.06164142f, 
    -0.01289830f, -0.10992176f, -0.09156835f, 0.07332605f, -0.03435560f, -0.03342605f, 0.06820251f, -0.04859182f, 
    -0.08475264f, 0.22573180f, -0.09989205f, -0.20083278f, -0.06344854f, 0.03145011f, 0.00428007f, 0.05384758f, 
    0.03666333f, 0.08816028f, 0.33459017f, -0.01286916f, 0.06783743f, 0.01015049f, 0.12072258f, -0.02354055f, 
    -0.07116131f, -0.05509790f, 0.19811814f, 0.12930158f, -0.00962214f, 0.25852561f, -0.05641349f, 0.12414634f, 
    -0.11066921f, -0.08353228f, 0.08190002f, 0.23370075f, 0.20498541f, 0.05114001f, 0.17107572f, -0.05469450f, 
    0.00626909f, 0.01167411f, -0.00583595f, -0.09792280f, 0.09918264f, -0.14005004f, 0.03686044f, -0.14614590f, 
    0.07129098f, 0.05168764f, -0.01742292f, 0.00893753f, -0.12976098f, 0.17465423f, -0.72745878f, -0.22529210f, 
    -0.00722328f, -0.02841347f, -0.06642815f, -0.04745679f, 0.02409163f, -0.09789224f, -0.20795503f, 0.19307493f, 
    0.03378174f, 0.09497248f, -0.25711730f, 0.13556887f, 0.02386552f, 0.13368249f, 0.13586162f, -0.08273958f, 
    0.14075567f, -0.04127070f, -0.06545264f, -0.11362059f, 0.03211878f, 0.08567279f, 0.12700979f, 0.16745299f, 
    0.44106960f, 0.37179169f, -0.05031447f, -0.16850609f, 0.17455190f, -0.06737045f, 0.01329041f, 0.00629437f, 
    -0.02297169f, 0.22319463f, -0.10515377f, -0.08298748f, 0.23513201f, -0.12028509f, -0.01773834f, 0.02693553f, 
    0.04248135f, 0.01959544f, 0.15793636f, 0.05605094f, -0.19233902f, -0.08256504f, -0.12252370f, 0.08319868f, 
    0.03442682f, -0.00588318f, -0.05120184f, 0.05397642f, 0.05297545f, 0.07059465f, 0.10383184f, -0.17149872f, 
    -0.04784557f, -0.15117517f, -0.05968822f, -0.12074148f, 0.08392569f, 0.42906803f, -0.04258212f, 0.02682390f, 
    0.18909302f, 0.02785200f, -0.04817256f, -0.21379341f, -0.06441964f, 0.08255921f, 0.06432167f, 0.01805785f, 
    -0.02555228f, -0.02240726f, 0.16557352f, 0.02637921f, -0.11786836f, -0.36156338f, 0.20466486f, 0.03391392f, 
    0.10051185f, 0.18488467f, -0.03849598f, 0.05122638f, -0.10612082f, 0.15725972f, 0.04220290f, 0.11400899f, 
    -0.03103317f, -0.06152412f, 0.11076206f, -0.13701071f, -0.02647497f, -0.05351623f, 0.08890727f, -0.24119501f, 
    -0.04862842f, -0.19775023f, 0.06140567f, -0.04812798f, 0.14760068f, 0.04316518f, 0.00073719f, -0.07528604f, 
    0.04249624f, -0.29384756f, -0.10108752f, 0.09025966f, 0.00372592f, 0.12477655f, 0.03448638f, -0.12798400f, 
    -0.05270966f, -0.04105421f, -0.10744065f, -0.03041930f, -0.25087395f, -0.13105138f, 0.10454256f, 0.09982550f, 
    -0.07786105f, 0.04349654f, -0.02218262f, -0.01914015f, 0.04118263f, -0.02561044f, 0.02802985f, -0.00226145f, 
    0.00868195f, -0.02135173f, 0.05750162f, 0.13570009f, 0.03608796f, 0.14468299f, 0.00358548f, 0.08591399f, 
    0.05029379f, 0.01330969f, -0.04729620f, 0.14887814f, -0.14537065f, -0.13906173f, -0.42041928f, -0.11359834f, 
    -0.01951001f, -0.14515522f, -0.06937914f, -0.07354963f, 0.10109331f, 0.02033886f, 0.30406573f, 0.14841554f, 
    -0.19614811f, -0.16708764f, -0.03217304f, -0.02689231f, -0.03479612f, 0.00763013f, 0.19161893f, -0.19656584f, 
    -0.24861845f, -0.11714126f, 0.05305998f, -0.00406915f, 0.29281965f, -0.07156893f, 0.07506303f, -0.14867203f, 
    -0.11017718f, -0.18352161f, -0.06475826f, 0.01282833f, -0.01908501f, 0.12320340f, 0.03390041f, -0.01330162f, 
    -0.06153721f, -0.07278339f, -0.13271616f, -0.01287555f, 0.05569690f, 0.04128529f, 0.07772806f, 0.19183165f, 
    0.07561754f, 0.05762984f, -0.20572764f, -0.11206704f, 0.10706221f, 0.07346021f, 0.15322292f, 0.02123562f, 
    -0.03666297f, -0.01267717f, -0.06527553f, -0.07898730f, -0.11409464f, -0.10728877f, 0.06147657f, 0.01404431f, 
    0.09112800f, -0.01147510f, 0.13063186f, -0.02952356f, 0.06133279f, 0.19734232f, 0.17232245f, -0.04480660f, 
    -0.10062021f, 0.05161072f, -0.02072947f, 0.33513889f, -0.15223691f, 0.23909315f, 0.07837532f, 0.02551742f, 
    -0.04633937f, -0.09007952f, -0.06801603f, 0.06097139f, -0.03133235f, -0.10243249f, -0.14731495f, -0.04006817f, 
    0.10968413f, -0.03040988f, 0.08376131f, 0.17423688f, 0.08448870f, 0.10015894f, 0.04289569f, -0.00435688f, 
    0.00068160f, 0.10183381f, 0.09807587f, 0.08144795f, 0.12898786f, -0.06618908f, 0.16280663f, -0.10293032f, 
    -0.05544141f, -0.27253801f, 0.12710787f, 0.08825082f, 0.10284900f, 0.16366997f, 0.18234405f, 0.05192870f, 
    -0.11581383f, -0.14583081f, -0.13386612f, -0.15417412f, 0.18802339f, -0.04687773f, 0.04947880f, 0.03867367f, 
    0.10533772f, 0.04079756f, 0.06289093f, -0.11576137f, -0.07841752f, 0.07100563f, 0.07039668f, -0.04793745f, 
    0.11170985f, 0.07996849f, -0.03480810f, -0.05631287f, -0.32243496f, -0.01640369f, 0.07461378f, 0.05157101f, 
    0.14718394f, -0.03083488f, -0.00593439f, 0.08864260f, -0.06979746f, 0.08920855f, 0.04083021f, -0.10749226f, 
    -0.05746985f, 0.07826245f, -0.00816857f, 0.15476580f, -0.12688851f, -0.47347930f, -0.32663235f, 0.05774250f, 
    -0.12912488f, 0.04311221f, -0.07800173f, 0.13733788f, 0.12597308f, -0.03380488f, 0.02170708f, -0.13370673f, 
    -0.11178918f, -0.09724768f, -0.21395320f, 0.12301556f, 0.02338019f, 0.04070093f, -0.07091520f, -0.13459681f, 
    -0.12527645f, -0.18237562f, -0.04067476f, -0.11755510f, 0.01944735f, 0.10910234f, 0.05470274f, -0.13750511f, 
    -0.10165172f, -0.04185731f, 0.18698497f, 0.08109565f, 0.11677761f, -0.04291306f, 0.01305246f, 0.00734313f, 
    -0.24553308f, -0.01532905f, 0.07628960f, 0.12329607f, -0.12436064f, -0.00359995f, 0.10997003f, 0.08308171f, 
    0.07012766f, -0.21230713f, -0.03813209f, -0.01319909f, 0.13404827f, -0.00462218f, -0.00915908f, -0.03105006f, 
    -0.19253471f, 0.06733279f, -0.05563192f, -0.06378333f, 0.12598839f, -0.04430066f, -0.01687899f, 0.05212620f, 
    0.07468042f, -0.01578822f, 0.26139966f, -0.41670567f, -0.32375091f, -0.09100761f, 0.13136674f, 0.05984886f, 
    0.03208627f, -0.03051028f, -0.08404714f, 0.04303486f, -0.09365831f, -0.03888173f, 0.00507057f, 0.08549771f, 
    0.04365819f, 0.02980206f, 0.06759280f, -0.00213235f, -0.04103730f, -0.13232240f, -0.09648339f, -0.10388210f, 
    -0.04592604f, 0.04339935f, 0.00607020f, 0.02644845f, 0.07271072f, -0.15718199f, -0.14777263f, -0.17176427f, 
    -0.10027733f, -0.06621420f, -0.01144330f, -0.00144648f, 0.03130573f, 0.00283454f, -0.09313075f, -0.35457435f, 
    -0.16164631f, -0.13063425f, -0.02251427f, 0.01114901f, 0.07361038f, -0.19668047f, 0.08529896f, 0.13576454f, 
    0.17291698f, -0.12846507f, -0.01732579f, 0.06373743f, 0.09019323f, 0.07388993f, -0.08401975f, -0.25490105f, 
    -0.08710741f, -0.01234977f, 0.14231223f, -0.03333614f, -0.14873298f, 0.04116560f, 0.12680060f, 0.13406491f, 
    0.11548688f, 0.22320239f, 0.12948428f, 0.14195491f, 0.04584688f, 0.03144727f, -0.09498179f, -0.11681937f, 
    0.06620761f, -0.02002764f, 0.16130069f, 0.02210221f, 0.12741390f, 0.04582598f, -0.07899909f, -0.06387795f, 
    0.02128226f, 0.06083464f, 0.08092047f, -0.01883383f, -0.33430278f, -0.19721235f, 0.10310381f, 0.00374739f, 
    -0.06228257f, 0.03260750f, -0.00922426f, 0.00986569f, 0.21945888f, -0.16514164f, 0.04374483f, -0.08900309f, 
    -0.07238103f, 0.03798909f, -0.17463541f, 0.02351442f, 0.05665791f, 0.18238118f, -0.08725671f, 0.29232305f, 
    0.19682962f, 0.16507314f, -0.03806657f, 0.08025535f, -0.22781543f, 0.02381596f, -0.39875731f, 0.19213751f, 
    -0.06002787f, -0.03449850f, 0.15441631f, -0.09033370f, -0.02750387f, 0.05736508f, 0.08821551f, -0.02587185f, 
    0.09723873f, 0.16633141f, 0.07582266f, 0.25855950f, -0.01977742f, 0.18890132f, 0.07570380f, 0.12084186f, 
    -0.10044733f, 0.02600023f, -0.30206430f, -0.04005798f, -0.04340756f, 0.14324735f, -0.02988464f, 0.05075732f, 
    -0.22420534f, -0.19581489f, -0.38370278f, -0.08267715f, -0.23676696f, -0.02936632f, -0.06472373f, -0.12082991f, 
    -0.06498990f, -0.00479277f, -0.20139764f, 0.14093576f, 0.22783068f, -0.03661820f, -0.07670823f, -0.16541228f, 
    -0.11217387f, 0.04337268f, -0.04565602f, -0.10780720f, -0.21541299f, 0.16166818f, -0.01516446f, -0.05255885f, 
    0.17077690f, -0.10771110f, -0.12225919f, 0.03579259f, 0.06994016f, 0.03502488f, -0.04643880f, 0.13311243f, 
    0.08751579f, 0.03172709f, -0.11589570f, -0.02224739f, 0.07591901f, 0.03185315f, 0.24723019f, -0.00117496f, 
    0.03973760f, -0.02848656f, 0.04141488f, 0.05105493f, 0.06104793f, 0.04381751f, -0.16082375f, 0.21414033f, 
    -0.06869537f, -0.05665537f, 0.19481114f, 0.06784998f, -0.18576801f, -0.17435721f, -0.12585291f, 0.11142717f, 
    -0.36692330f, -0.06477598f, -0.22162379f, -0.04806206f, -0.12986416f, -0.13027593f, -0.07295483f, -0.10576268f, 
    0.00850759f, -0.03405023f, 0.03012667f, -0.23082209f, -0.00155745f, 0.08593890f, 0.19184166f, 0.00554193f, 
    -0.07720254f, -0.22700934f, -0.42230082f, -0.47748891f, -0.19388138f, -0.15117668f, 0.09098617f, 0.04411237f, 
    0.01904139f, -0.06224813f, 0.10184520f, 0.01576934f, 0.26608315f, -0.06025661f, -0.07777615f, 0.08768184f, 
    -0.01973280f, -0.15563616f, 0.07416189f, -0.01333278f, -0.16908199f, -0.07237177f, -0.18234257f, -0.22270642f, 
    0.03296131f, -0.07817379f, -0.07588210f, 0.03583456f, -0.00901889f, -0.34175360f, -0.10223716f, -0.05671974f, 
    -0.10439331f, -0.11491228f, -0.08627151f, 0.02185595f, 0.06727129f, 0.31898633f, -0.22799167f, 0.11350950f, 
    0.20026982f, -0.16387475f, 0.02632803f, 0.05513940f, -0.19938886f, -0.00331714f, 0.12940490f, 0.12922671f, 
    0.13645431f, 0.31291389f, 0.18395600f, 0.09872560f, -0.10603893f, 0.05240481f, -0.02522652f, -0.06806871f, 
    0.09082226f, -0.13408543f, 0.29512531f, -0.05262353f, 0.16642544f, 0.09255552f, -0.20706774f, -0.05143037f, 
    0.07446045f, -0.24567184f, 0.00114121f, 0.28381050f, -0.06760684f, 0.13347168f, -0.06784891f, -0.04385396f, 
    0.10407028f, -0.14394647f, 0.01887290f, 0.18864059f, 0.00266739f, 0.03093006f, 0.01146772f, -0.00071238f, 
    -0.10015952f, -0.01942840f, -0.22176038f, -0.36289501f, -0.15683462f, -0.08576217f, 0.06635578f, 0.09901451f, 
    0.01338606f, 0.07901622f, -0.20848626f, 0.12120233f, 0.15184315f, 0.14946847f, 0.00553847f, 0.11333235f, 
    -0.07083386f, -0.08718321f, 0.00793046f, -0.00220366f, 0.02581391f, 0.00505364f, 0.09294157f, 0.23752421f, 
    -0.14303347f, 0.12372172f, -0.12775734f, 0.00798961f, -0.05130495f, -0.04680060f, 0.02117436f, 0.12490781f, 
    0.00342535f, -0.06848815f, 0.15317203f, -0.07668961f, 0.15298440f, 0.08528905f, 0.09862936f, -0.10365417f, 
    0.03794554f, -0.22599159f, -0.01135608f, 0.15760840f, 0.05037828f, 0.00313707f, -0.07094350f, 0.03215529f, 
    -0.08792890f, -0.15559740f, -0.01751312f, -0.07090986f, 0.17647895f, 0.06031501f, 0.04081117f, -0.18172306f, 
    0.14339349f, -0.20114821f, -0.01881791f, 0.02612667f, 0.11828674f, 0.08719597f, 0.05240658f, -0.03536359f, 
    -0.29076862f, -0.25412178f, -0.12553702f, -0.17581104f, -0.07294005f, -0.22890987f, -0.01514026f, 0.06721553f, 
    -0.12325895f, -0.08179576f, -0.10215934f, -0.12464379f, -0.11401317f, -0.29870149f, 0.16857946f, -0.01150987f, 
    -0.06759317f, -0.11204243f, -0.03178538f, -0.07520264f, 0.19954734f, 0.17777905f, 0.25373703f, 0.10048354f, 
    0.19097356f, -0.05246787f, -0.13498004f, 0.06800492f, -0.15195119f, -0.12294236f, -0.10705676f, -0.41188180f, 
    0.03049975f, -0.10896690f, -0.04431379f, 0.02693350f, -0.06610382f, 0.03112864f, -0.07869684f, 0.14135899f, 
    -0.21802019f, 0.04639867f, -0.05304378f, 0.17395580f, 0.01213829f, 0.12114433f, 0.07461100f, -0.09160028f, 
    -0.01971938f, -0.04186731f, -0.07632388f, 0.13165550f, -0.03249773f, -0.16294603f, 0.03110184f, -0.01725309f, 
    0.12398124f, -0.05448427f, -0.09861742f, 0.11892220f, -0.08449505f, -0.02840808f, -0.10651529f, -0.10554951f, 
    0.04868712f, -0.18636303f, -0.17901002f, -0.08026116f, 0.02013861f, 0.09567536f, 0.02427415f, -0.03143143f, 
    -0.01077689f, 0.17003807f, 0.02243564f, 0.18973003f, 0.30070937f, -0.00246159f, -0.00190950f, 0.14866754f, 
    -0.00782115f, 0.00706687f, 0.03728146f, 0.04686512f, -0.08319137f, -0.09125645f, -0.04586228f, -0.11595856f, 
    -0.04964848f, 0.01880620f, 0.09520352f, 0.11368766f, -0.05021181f, -0.01236676f, -0.10357460f, -0.02401551f, 
    -0.05712194f, 0.11631698f, -0.01453185f, 0.12456588f, 0.01555090f, -0.01500762f, 0.05446405f, 0.27153909f, 
    0.03153894f, 0.05093569f, -0.01673030f, -0.11864071f, -0.02161725f, 0.10487613f, -0.18553907f, -0.20336415f, 
    -0.08744472f, -0.04526712f, 0.01417402f, 0.05355499f, -0.05582139f, -0.09309303f, 0.11026313f, -0.00858049f, 
    -0.08859767f, -0.00042319f, -0.01045990f, 0.07475306f, 0.05721827f, -0.17774537f, -0.03848256f, -0.16082528f, 
    0.10364436f, 0.14373538f, 0.05499828f, -0.08537718f, 0.13251573f, 0.08316689f, 0.13544565f, 0.07732140f, 
    0.01862932f, 0.02542315f, 0.13116327f, 0.11887111f, 0.10988654f, 0.12325910f, 0.06456069f, 0.08882862f, 
    0.03470507f, 0.11223871f, 0.16373630f, 0.23451628f, 0.05494237f, 0.08455187f, 0.07970629f, 0.14784203f, 
    0.14380747f, 0.04764804f, -0.08046540f, 0.02016762f, -0.09114574f, 0.06773821f, 0.10192148f, -0.01481278f, 
    -0.07954028f, -0.02908235f, 0.09884298f, 0.13685101f, -0.45216313f, -0.20081258f, 0.26563966f, 0.16314378f, 
    -0.00717095f, 0.18765211f, -0.02059867f, 0.04860080f, 0.01835136f, 0.15026714f, -0.06443975f, -0.02147348f, 
    0.06916992f, 0.05849494f, -0.06891339f, -0.02180219f, -0.21567154f, -0.10255286f, -0.02563254f, 0.05174300f, 
    0.16008446f, 0.00760271f, -0.00399202f, 0.15649825f, -0.04115923f, -0.04226576f, -0.23769437f, -0.07540876f, 
    -0.21215537f, 0.20031683f, -0.09213719f, 0.12131176f, -0.07527892f, -0.02619459f, 0.06391512f, 0.17244683f, 
    0.14583412f, 0.24906555f, 0.20977390f, 0.17636533f, -0.10754901f, 0.04328848f, -0.09020760f, 0.17398071f, 
    -0.14168528f, -0.12768805f, 0.19455095f, 0.45566973f, 0.15922238f, 0.03645823f, 0.08351275f, -0.08708265f, 
    0.17541417f, 0.10598766f, 0.09658805f, 0.12059946f, 0.18940908f, -0.07284788f, -0.03072533f, -0.00982100f, 
    0.04738339f, 0.04679165f, 0.15666223f, 0.11499378f, -0.18169053f, -0.05919927f, 0.01711923f, 0.11827089f, 
    0.16711751f, -0.20039062f, -0.05943898f, -0.50249410f, -0.06517879f, -0.10051680f, -0.10974422f, -0.07942612f, 
    0.02360338f, -0.11375894f, -0.11434736f, -0.10081277f, -0.05517058f, 0.05305424f, 0.00735830f, 0.12816280f, 
    0.09493849f, 0.03912893f, 0.25312531f, -0.06719321f, 0.06607713f, -0.10814237f, -0.30131257f, -0.11511510f, 
    0.15015262f, 0.02287359f, -0.08156380f, 0.13719383f, -0.19782777f, -0.00387640f, -0.25322059f, 0.00125425f, 
    -0.16454123f, 0.07586787f, -0.04074027f, 0.07280368f, 0.19141936f, -0.40309268f, 0.02009846f, -0.27795669f, 
    -0.39871776f, 0.02433359f, -0.05762354f, -0.06975248f, -0.22715558f, -0.05658063f, -0.04607820f, 0.06557403f, 
    -0.07178662f, -0.39787135f, 0.03949671f, 0.09533333f, 0.02041482f, 0.05338255f, -0.21001971f, -0.00156732f, 
    -0.27805218f, -0.21623591f, -0.03663038f, -0.05307217f, -0.11286018f, -0.16595939f, -0.03558121f, -0.10280024f, 
    0.02182086f, -0.01561112f, 0.16279133f, 0.19184384f, 0.37035927f, 0.28547531f, -0.07039458f, 0.07541914f, 
    -0.02233886f, 0.12742481f, -0.10263959f, -0.01441373f, 0.26527086f, -0.05818615f, 0.04697381f, 0.05981201f, 
    0.04787495f, -0.21200961f, 0.11141751f, -0.00633932f, 0.17236641f, -0.09261184f, 0.55667430f, 0.29593313f, 
    -0.09930959f, 0.07312469f, 0.03111169f, 0.10692827f, 0.08778463f, -0.06664276f, -0.04246682f, -0.17833433f, 
    -0.50819492f, -0.16078463f, -0.16853906f, 0.07231443f, -0.10700977f, 0.06742075f, -0.05666329f, -0.37462717f, 
    0.10783232f, -0.22883075f, -0.16634105f, -0.17452407f, -0.25542802f, 0.04439524f, 0.02173470f, -0.03535230f, 
    0.47005883f, -0.08539469f, -0.22078942f, -0.03008059f, 0.06825344f, -0.06755951f, 0.02192598f, 0.11216833f, 
    0.20981108f, -0.21957639f, -0.02131805f, -0.08894925f, 0.01394777f, -0.18898189f, -0.07061119f, -0.06404421f, 
    0.01423546f, 0.00364511f, -0.06498816f, -0.15275054f, 0.08130441f, 0.00370344f, -0.11469513f, -0.12789379f, 
    -0.10143105f, 0.10627963f, 0.00093832f, -0.24177612f, 0.17900854f, 0.18481509f, -0.01599798f, 0.19366467f, 
    0.20880534f, 0.10771899f, 0.08357154f, 0.06051576f, -0.12344992f, 0.11878916f, -0.00626053f, 0.11403622f, 
    0.10625979f, 0.04920980f, -0.05990153f, 0.25987008f, -0.05311106f, 0.01099087f, -0.00778672f, 0.16631706f, 
    0.04874004f, 0.06758627f, -0.09324304f, 0.08787551f, -0.05619792f, 0.22650672f, 0.04675203f, 0.08395120f, 
    0.07519232f, 0.05137923f, 0.12653425f, -0.01271775f, 0.05671524f, 0.00606976f, 0.18252644f, -0.00384472f, 
    0.08332855f, -0.15156983f, -0.18451646f, -0.05912670f, -0.03287904f, 0.05873388f, 0.07598235f, 0.19597200f, 
    -0.04480395f, -0.10254222f, 0.01418676f, -0.00506209f, -0.08210139f, -0.21100584f, 0.04549051f, 0.07079282f, 
    0.05963656f, 0.09129799f, -0.19042554f, 0.06352882f, 0.11097064f, -0.08681860f, 0.04454380f, -0.13259643f, 
    0.02394740f, 0.08358242f, -0.18886477f, -0.01477771f, 0.02706651f, -0.00551605f, -0.03250449f, 0.03342024f, 
    -0.02281948f, 0.12108430f, 0.08868451f, 0.23250994f, -0.02629381f, 0.15554531f, 0.03730907f, 0.10390795f, 
    0.07574964f, 0.09889755f, -0.00815005f, 0.04848933f, 0.06945080f, -0.51277512f, -0.15161639f, -0.07490288f, 
    -0.13515118f, 0.09736678f, 0.04424584f, 0.07653613f, 0.03549404f, -0.09255556f, 0.40043795f, 0.53642291f, 
    0.11801728f, 0.04884728f, -0.00979967f, 0.27090034f, 0.05382140f, -0.13965771f, -0.27785495f, -0.33591083f, 
    0.06305452f, -0.01644871f, -0.06005298f, 0.02793769f, 0.04760942f, 0.18796755f, 0.07160465f, -0.19239652f, 
    -0.05505933f, -0.06016807f, -0.12708564f, -0.10862356f, -0.04170842f, 0.02953545f, 0.12748899f, 0.07916848f, 
    -0.05086906f, 0.00635778f, 0.07988267f, 0.02576172f, -0.02184333f, -0.06856070f, -0.00864692f, -0.00430176f, 
    0.12551604f, -0.12796056f, 0.09835970f, 0.04937973f, 0.04023932f, -0.22328584f, -0.12449487f, -0.10575023f, 
    -0.23011561f, 0.11243382f, 0.01363133f, -0.10199232f, 0.08816056f, 0.05132060f, 0.18407768f, -0.03765131f, 
    0.07276449f, 0.05872125f, 0.01846764f, -0.01919153f, -0.06001236f, -0.31587636f, -0.13787258f, -0.03071602f, 
    -0.11642044f, -0.02909829f, 0.05375715f, 0.05954967f, -0.18163523f, -0.11944118f, -0.22041740f, -0.25165161f, 
    -0.16780384f, -0.23905037f, 0.05768148f, -0.05952664f, 0.10108472f, -0.30343291f, 0.00197269f, -0.32039106f, 
    -0.16433695f, 0.01122134f, 0.07750034f, -0.07245744f, 0.09813072f, 0.05111993f, -0.06460977f, -0.08438653f, 
    -0.23651490f, -0.05519616f, -0.13781609f, 0.12254778f, 0.16723007f, 0.06832562f, 0.00710643f, 0.04944753f, 
    0.04436156f, 0.08733584f, 0.02669930f, 0.04694533f, -0.05198949f, -0.04973104f, 0.11889497f, 0.02683610f, 
    0.01474638f, 0.10572653f, 0.01742860f, -0.00123517f, -0.01539891f, 0.08101906f, 0.20403549f, 0.19493075f, 
    0.12834072f, -0.04951342f, -0.02495065f, 0.03193278f, 0.03390725f, 0.01929411f, 0.01793761f, -0.00803371f, 
    -0.29791370f, -0.27291027f, 0.02078417f, -0.01979593f, 0.05836153f, -0.02344872f, -0.00674174f, 0.06204280f, 
    -0.09072037f, -0.25180534f, -0.20858407f, 0.26022586f, -0.12375856f, -0.04711770f, 0.01329968f, 0.03168838f, 
    -0.06524592f, -0.00177502f, -0.40804616f, -0.18257377f, 0.21243630f, 0.09094220f, -0.31676960f, 0.13370088f, 
    0.03598488f, 0.00787234f, -0.01884869f, 0.01109717f, 0.01353340f, 0.06319343f, 0.10940792f, -0.11047345f, 
    -0.08196486f, -0.15503712f, -0.15817595f, -0.02046260f, -0.23754741f, -0.04899716f, 0.19661270f, 0.05542345f, 
    -0.08012778f, -0.00811585f, 0.07199349f, -0.13236554f, 0.09546707f, 0.17104447f, -0.00049714f, 0.07421850f, 
    0.10083374f, 0.10327531f, -0.02844780f, 0.02867302f, -0.12224051f, 0.03682858f, -0.02656985f, 0.05089020f, 
    0.26964101f, 0.12344982f, -0.04685866f, -0.00692980f, -0.17429329f, 0.17430820f, 0.12224417f, -0.07953776f, 
    0.05984539f, 0.04513921f, 0.10961340f, 0.03968362f, -0.00170761f, 0.04660870f, 0.07226995f, 0.19700179f, 
    -0.02071693f, 0.12764241f, 0.08592208f, -0.02392027f, -0.03476806f, 0.10105195f, -0.06819471f, 0.09883720f, 
    0.04267643f, -0.04225080f, 0.10114934f, 0.14613098f, 0.01094586f, -0.19004269f, -0.01770315f, 0.05080042f, 
    -0.01204881f, 0.04999096f, 0.07760520f, -0.05805365f, 0.13511148f, 0.19666770f, -0.05940077f, -0.01480790f, 
    -0.06985461f, 0.03025366f, 0.00901589f, 0.09279227f, 0.00730847f, 0.03926588f, -0.20850359f, 0.05340582f, 
    -0.09637082f, -0.08982559f, -0.11463323f, 0.21501237f, 0.03371643f, -0.06279033f, 0.12278064f, 0.08356844f, 
    0.05856706f, 0.00927141f, -0.11311159f, -0.09256786f, -0.11290510f, -0.02766052f, 0.03355709f, 0.15254906f, 
    0.08670311f, 0.08149624f, 0.05648472f, -0.00080244f, -0.08011305f, -0.16148831f, 0.15151039f, 0.24876739f, 
    0.15727028f, -0.07623364f, -0.06731362f, 0.11030301f, -0.04444436f, 0.03720586f, 0.03878982f, -0.11245614f, 
    0.10861216f, -0.07277204f, -0.24385187f, -0.01442823f, -0.02915597f, 0.04116913f, 0.03344908f, 0.20922461f, 
    -0.02964542f, 0.04084664f, -0.13163973f, -0.11452697f, 0.00639842f, 0.03413032f, 0.01802279f, 0.16682540f, 
    0.17141022f, -0.11900102f, -0.05975875f, 0.11569572f, -0.15650211f, 0.08877525f, -0.07036737f, 0.00388797f, 
    -0.13863204f, 0.04580633f, -0.07969385f, 0.01402998f, 0.18027350f, -0.02886381f, 0.46453488f, 0.09831244f, 
    -0.00837739f, -0.09970564f, 0.10885070f, -0.01941698f, 0.22195798f, 0.04188225f, 0.09536997f, 0.03375213f, 
    0.03946242f, 0.01578329f, -0.06145562f, -0.03545465f, -0.19559383f, 0.01304457f, 0.06031498f, 0.05256460f, 
    0.25185204f, 0.09774158f, -0.11368638f, -0.08677229f, 0.12844473f, -0.01768126f, -0.42832300f, -0.01972765f, 
    -0.24628654f, -0.01279627f, -0.01967805f, 0.04054467f, 0.12660278f, 0.22515818f, -0.14708686f, -0.02950965f, 
    0.02720952f, -0.01718735f, 0.00653894f, 0.08658231f, -0.09353076f, -0.08114664f, 0.04081045f, 0.17411081f, 
    0.03723701f, 0.03597336f, -0.11380177f, 0.25374150f, 0.06738640f, 0.02198668f, 0.04584914f, 0.22881430f, 
    0.10036904f, 0.16699694f, 0.02071668f, 0.02915228f, -0.02047420f, 0.12449476f, -0.06983469f, 0.13581224f, 
    0.19753180f, 0.05694674f, 0.09739587f, -0.02727384f, -0.10138373f, -0.31127989f, 0.09233364f, 0.03606347f, 
    0.05349998f, -0.15810919f, -0.16948961f, -0.18167619f, 0.08548500f, -0.02270340f, -0.06036995f, 0.08982436f, 
    0.05060404f, -0.01961589f, -0.20111641f, -0.14420262f, -0.11699609f, 0.06070326f, 0.16923480f, 0.06039239f, 
    0.03635114f, 0.05933852f, 0.12037493f, -0.10298573f, 0.01856393f, -0.20137595f, -0.16959280f, -0.09617225f, 
    0.17974442f, 0.12377167f, 0.01572616f, -0.13172925f, -0.13424739f, -0.13194366f, -0.11185605f, 0.02785278f, 
    -0.13232686f, -0.07360152f, 0.08008756f, 0.04325698f, 0.08402576f, -0.16780609f, -0.17011872f, -0.27795714f, 
    0.08666496f, -0.10487222f, 0.07860460f, -0.08626381f, 0.05286822f, -0.16658092f, -0.10596111f, -0.00299497f, 
    -0.03758858f, 0.03131095f, -0.32279968f, -0.12959127f, -0.11732814f, 0.06056939f, 0.01507640f, -0.00707728f, 
    -0.05105829f, 0.17431955f, 0.17592308f, -0.13932839f, -0.05335011f, 0.03587284f, -0.11216757f, -0.02552370f, 
    -0.00313895f, 0.13662188f, 0.13963617f, -0.04690263f, 0.17228793f, 0.29471084f, -0.09730839f, 0.00880561f, 
    0.13410532f, -0.06842892f, -0.01870964f, 0.19691083f, -0.01419710f, -0.10927878f, -0.11901752f, -0.02246612f, 
    -0.08894066f, -0.12488687f, -0.05706705f, -0.09130139f, 0.12410245f, -0.07383762f, -0.07707844f, 0.16202444f, 
    -0.05683510f, 0.16926940f, -0.09645982f, -0.16940035f, -0.06452226f, -0.00762793f, -0.12318163f, -0.26489508f, 
    -0.06112771f, -0.07385802f, -0.04115753f, 0.16783980f, 0.03142682f, 0.02913075f, -0.03823121f, 0.22366637f, 
    -0.27313697f, -0.37643221f, -0.22300722f, -0.26066884f, -0.05604375f, -0.27728510f, -0.10243558f, 0.03275127f, 
    -0.15649860f, 0.29733175f, -0.06389067f, -0.10689734f, 0.12747504f, 0.07051078f, -0.01247450f, -0.06431218f, 
    0.25101274f, 0.01843329f, -0.11049718f, 0.13674784f, -0.01614926f, 0.21520387f, 0.00786796f, 0.01711336f, 
    0.01134191f, 0.02037668f, -0.09985052f, -0.35229775f, -0.02732484f, 0.02788116f, 0.06747702f, -0.08803988f, 
    -0.10782991f, -0.03838143f, 0.03162557f, -0.13745512f, 0.14829223f, 0.22139995f, -0.09422965f, -0.00644632f, 
    0.00110198f, 0.04256590f, -0.07152575f, -0.00638042f, -0.05844043f, -0.14654817f, 0.09627028f, 0.07333682f, 
    0.01351590f, -0.07411153f, -0.23148933f, -0.00227890f, -0.10060835f, 0.30559468f, -0.13665123f, -0.05233726f, 
    0.12681988f, -0.05535442f, 0.06195327f, -0.06707603f, 0.04903462f, 0.31132400f, -0.15232830f, 0.24721184f, 
    -0.25443041f, -0.09230340f, 0.02396791f, 0.15600522f, 0.08660649f, 0.08764285f, 0.15614434f, 0.05056267f, 
    -0.07914613f, -0.18247573f, -0.26807415f, -0.08330258f, -0.00728322f, -0.08921906f, -0.05652620f, 0.21216369f, 
    -0.28864065f, -0.25269562f, 0.05769146f, -0.01277704f, -0.00243130f, -0.15020497f, -0.06207168f, 0.05903048f, 
    0.03477463f, 0.14490941f, -0.23811845f, 0.05754723f, 0.15867044f, 0.10097668f, -0.01561267f, 0.10866021f, 
    -0.03429077f, -0.00608851f, -0.05356800f, -0.20695657f, 0.10548980f, 0.08041639f, 0.03965377f, -0.06503527f, 
    -0.04479275f, -0.10994351f, 0.07457540f, 0.05585274f, 0.08728740f, 0.14860526f, 0.04418445f, 0.03209984f, 
    0.23676440f, 0.09539513f, 0.02177657f, 0.25577444f, 0.53591919f, -0.11609970f, -0.39864650f, -0.05691294f, 
    0.02211476f, -0.03139125f, -0.11834559f, 0.14009869f, -0.01810716f, -0.06619415f, -0.01044440f, 0.21615894f, 
    -0.03057921f, -0.00085774f, -0.10267697f, 0.11027753f, -0.10910801f, 0.18093975f, 0.13419683f, -0.23896155f, 
    -0.27034414f, -0.08272941f, -0.00260341f, -0.10267754f, -0.18866947f, -0.01881869f, -0.16634129f, 0.07253463f, 
    -0.07670864f, 0.06602924f, -0.13603693f, 0.12901342f, -0.06779419f, 0.01238584f, -0.00304287f, 0.07244241f, 
    0.19145115f, -0.16351511f, -0.15751937f, 0.06981631f, 0.02626988f, 0.04072683f, 0.03002108f, 0.12086827f, 
    0.21917096f, 0.14289866f, -0.34067512f, -0.10752112f, 0.23376949f, 0.13623925f, 0.08777535f, -0.07393868f, 
    -0.05538566f, 0.08148804f, -0.16938353f, -0.07721019f, 0.01065021f, -0.06896173f, 0.00878247f, 0.03264544f, 
    0.02594868f, 0.13624041f, -0.06187288f, -0.17378210f, -0.07160044f, -0.08660547f, -0.10367231f, -0.16294669f, 
    -0.07966680f, 0.00460855f, 0.03165537f, 0.04662438f, -0.12860931f, -0.13365252f, -0.23450689f, 0.07070624f, 
    -0.12932041f, 0.00906861f, -0.09351774f, -0.01291209f, -0.14922133f, 0.18989301f, -0.46848872f, -0.03399890f, 
    0.10896348f, 0.01402984f, 0.17488547f, -0.04790629f, 0.07925595f, 0.02956542f, 0.32446429f, -0.08082498f, 
    0.08574468f, 0.03792106f, -0.10358536f, 0.02923783f, -0.00264891f, 0.10456781f, 0.07388204f, 0.05109192f, 
    0.05836528f, -0.25985608f, -0.25812763f, -0.08951953f, 0.01053254f, 0.15579221f, 0.07461744f, 0.06131901f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.05162027f, 0.20984542f, 0.02700149f, 0.30087614f, -0.02276729f, 0.14484295f, 0.15175974f, 0.16517432f, 
    -0.01146964f, -0.06803275f, -0.03471893f, 0.11633721f, 0.12055919f, 0.03086203f, 0.04645234f, 0.02094790f, 
    0.15809004f, -0.03704204f, -0.00585550f, -0.04933715f, -0.15263754f, 0.11796864f, 0.02695682f, -0.03121375f, 
    -0.01702399f, 0.00076536f, 0.15541275f, -0.03936780f, 0.03911358f, 0.17363621f, -0.07040340f, 0.14720131f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06455853f, 0.17557600f, -0.18668383f, 0.08691548f, -0.14159659f, 0.09498215f, 0.17588204f, -0.05788159f, 
    0.01357384f, -0.00143778f, 0.07506894f, -0.18984538f, 0.28275111f, -0.20955476f, 0.08582442f, -0.06325021f, 
    0.33651179f, 0.45579877f, -0.01516758f, 0.23671606f, 0.16155635f, 0.25420934f, 0.13116270f, 0.01177717f, 
    0.23279400f, -0.35415530f, 0.07902975f, 0.09700374f, -0.13934745f, -0.05556015f, 0.14414647f, -0.03345435f, 
    0.00170447f, 0.34203351f, 0.36959839f, 0.09464704f, -0.54682940f, 0.39592859f, 0.06631559f, -0.15914178f, 
    0.23314880f, -0.04405778f, -0.25611302f, 0.19570699f, 0.37162521f, 0.13195756f, 0.07209349f, -0.13848266f, 
    0.13809140f, -0.07290448f, -0.34694156f, 0.12334989f, -0.03377838f, 0.13581863f, -0.48654604f, -0.11553717f, 
    0.17214710f, 0.13294387f, -0.02718999f, -0.06526908f, -0.05121432f, 0.51283091f, 0.13362546f, 0.45061970f, 
    -0.00063319f, 0.11956427f, 0.12952112f, 0.08102758f, -0.03878279f, -0.03511226f, 0.06873935f, -0.15209097f, 
    0.29803240f, 0.07765029f, 0.25223047f, -0.06949801f, -0.05968635f, -0.03190911f, 0.02271500f, -0.17642820f, 
    0.20326941f, -0.28111190f, 0.27391443f, -0.13602005f, 0.25003800f, 0.03435028f, 0.44287983f, 0.15470624f, 
    0.05165734f, 0.22515935f, 0.05646104f, 0.11818750f, 0.05351945f, -0.34862667f, -0.20197205f, -0.35397366f, 
    -0.01569592f, 0.21138665f, -0.04160444f, -0.19782074f, -0.08820906f, 0.19593582f, 0.08193780f, -0.14034773f, 
    0.13728493f, -0.00913715f, 0.04700999f, -0.09443240f, 0.03780323f, 0.21027441f, 0.25734526f, 0.35070166f, 
    -0.18448000f, 0.42239258f, -0.14914544f, 0.01802311f, -0.09110908f, 0.27936944f, 0.37447870f, -0.07076172f, 
    0.19836184f, -0.17034964f, -0.19640298f, 0.17519037f, 0.33718562f, -0.02395090f, -0.04295827f, -0.22878259f, 
    0.00768277f, 0.17874391f, 0.07141060f, 0.15302134f, 0.11335695f, -0.28806245f, 0.15099703f, 0.26440686f, 
    0.08070779f, -0.26053736f, 0.12356955f, -0.20772092f, -0.05199013f, 0.18310551f, 0.11053668f, 0.03120597f, 
    0.02370527f, 0.05169291f, 0.36490554f, -0.02038631f, -0.24531506f, -0.13584352f, 0.20958516f, 0.10501537f, 
    -0.10210241f, 0.16079170f, -0.04996068f, -0.27630591f, 0.16247839f, 0.01718284f, -0.12413087f, -0.50309771f, 
    -0.13643885f, -0.09910420f, -0.11039047f, -0.01203058f, -0.05943185f, -0.15226001f, -0.02822846f, 0.06774075f, 
    -0.15894683f, 0.05247583f, -0.13697119f, -0.07202017f, -0.20429660f, -0.06095503f, -0.06852783f, 0.05828413f, 
    -0.17561226f, -0.15246613f, 0.04644642f, -0.09819502f, 0.06330891f, -0.12201887f, -0.11333674f, -0.01483217f, 
    -0.08310146f, -0.05464907f, -0.19610402f, -0.10280424f, -0.03875557f, -0.00229857f, 0.00257476f, -0.08591290f, 
    -0.06507547f, -0.12124933f, 0.31748712f, 0.03235067f, -0.05255169f, 0.34875724f, -0.17401585f, 0.22152376f, 
    -0.10799582f, -0.08856121f, 0.19217411f, -0.46546242f, 0.01836709f, 0.02034096f, 0.01391508f, 0.23097084f, 
    -0.15620817f, 0.34818009f, -0.01760947f, 0.23883052f, -0.25934365f, 0.21705429f, 0.01922710f, 0.05673530f, 
    -0.14616528f, -0.02136997f, 0.15960141f, -0.05778949f, 0.10701448f, 0.13051206f, 0.01811564f, -0.32729980f, 
    -0.11597190f, 0.13505298f, -0.14779131f, 0.06390483f, 0.31938162f, 0.23213378f, 0.19170305f, 0.34030250f, 
    -0.36321071f, -0.41358989f, 0.27818295f, -0.25340956f, -0.65290320f, -0.16742423f, -0.06873222f, 0.34977445f, 
    0.00388346f, 0.05648492f, -0.07418668f, 0.21528055f, -0.04225010f, 0.09244019f, 0.22409005f, 0.09936805f, 
    0.25209892f, 0.29234523f, -0.12996133f, 0.14034572f, -0.05160294f, -0.04264439f, -0.23481739f, 0.21596400f, 
    0.14902698f, -0.24585928f, 0.30588952f, -0.27358261f, 0.01599652f, 0.12668481f, -0.07389284f, 0.20030971f, 
    0.05024076f, -0.14698119f, 0.08538014f, -0.05379884f, -0.28317448f, -0.15047866f, 0.16532911f, -0.15279254f, 
    0.43308032f, -0.20352788f, 0.39677954f, 0.19993167f, -0.12549859f, -0.36002168f, 0.22443235f, -0.02732326f, 
    0.44469917f, 0.16874537f, 0.00833876f, -0.26660058f, 0.34707683f, -0.12039916f, 0.24943660f, -0.15911785f, 
    -0.15111418f, 0.48672882f, -0.39186877f, -0.01617474f, -0.14693329f, 0.32739210f, 0.21445566f, 0.06560670f, 
    -0.16405901f, -0.12491994f, -0.03250234f, -0.32145777f, -0.26481849f, 0.22797282f, -0.18427871f, -0.10802118f, 
    -0.11528511f, 0.25701788f, -0.16664773f, -0.03556987f, 0.18236007f, 0.45223948f, -0.01411157f, 0.04778930f, 
    0.12463848f, 0.20049170f, 0.28289795f, -0.01936999f, 0.26595622f, 0.34386492f, -0.04290764f, -0.19265214f, 
    0.10206528f, 0.25288948f, 0.32739955f, -0.09785479f, 0.05728362f, -0.55445886f, 0.02447429f, 0.14035508f, 
    0.02101729f, -0.25309241f, 0.19440722f, -0.05962089f, -0.61540163f, -0.01086099f, -0.08803617f, -0.06366950f, 
    0.13906495f, -0.49773696f, 0.27385262f, -0.07208850f, -0.00906928f, -0.04534858f, 0.03035694f, -0.03121797f, 
    -0.05341431f, 0.50332761f, 0.00479087f, 0.00896788f, -0.21469757f, -0.02828076f, -0.04867832f, 0.38740578f, 
    0.02277446f, -0.23242627f, -0.02975645f, 0.05513709f, -0.08948009f, -0.17543197f, 0.27097178f, 0.18334687f, 
    0.14815113f, 0.12491223f, 0.02438177f, 0.20759016f, 0.43691996f, -0.19415022f, 0.05188553f, -0.30808401f, 
    0.38411400f, 0.12739082f, 0.40464118f, 0.04848178f, -0.00489098f, -0.25615349f, 0.22624405f, -0.01519574f, 
    0.15516366f, -0.06523143f, 0.05974712f, -0.29666185f, -0.03043646f, -0.35397539f, -0.00779345f, -0.12559727f, 
    -0.13993828f, -0.10195422f, -0.33914694f, 0.34485897f, 0.21211417f, -0.40968481f, 0.32741073f, 0.22439046f, 
    0.07049677f, -0.15040924f, -0.00802103f, 0.19968969f, -0.24159722f, -0.40278322f, 0.04323277f, -0.03789840f, 
    0.08984272f, -0.37912568f, 0.31176364f, 0.06676929f, 0.28944948f, -0.04416220f, -0.12213030f, -0.07377499f, 
    -0.07307346f, 0.23057078f, 0.03675149f, -0.13415213f, -0.46833029f, 0.14995359f, -0.08749772f, 0.21339780f, 
    0.14448252f, -0.24276228f, 0.16956078f, -0.15865189f, 0.04645685f, -0.19341318f, -0.00992389f, 0.25091910f, 
    0.09466914f, 0.18516399f, 0.29231173f, 0.04144435f, 0.44354999f, -0.19000372f, -0.01984663f, -0.10913435f, 
    0.06893837f, 0.13840790f, 0.31367925f, 0.23798355f, 0.10100289f, -0.14752875f, 0.47973698f, 0.13156135f, 
    0.31161287f, -0.12591735f, -0.15138280f, 0.00222189f, 0.15603352f, -0.29717961f, 0.23484568f, -0.13230595f, 
    -0.13519666f, 0.16075297f, -0.09714996f, -0.03083625f, -0.01570274f, 0.45813656f, -0.15221956f, 0.28711915f, 
    -0.00445866f, -0.34712398f, -0.29222593f, 0.03163612f, 0.57657558f, 0.14662331f, 0.28253734f, 0.36883098f, 
    0.26180929f, 0.27680162f, -0.33437386f, -0.21418667f, -0.36009613f, 0.31778821f, 0.17451154f, -0.07174372f, 
    0.26721504f, -0.14634159f, -0.05628698f, -0.02302825f, 0.04855505f, 0.36137778f, 0.08698545f, -0.04639511f, 
    -0.15678288f, 0.43660566f, 0.17636241f, -0.05566852f, -0.02740913f, -0.49925819f, 0.03560545f, 0.23553005f, 
    0.10252549f, -0.18706699f, 0.15800676f, -0.13381456f, -0.09852190f, 0.21935573f, -0.03463803f, -0.17956394f, 
    0.11062104f, 0.05652718f, -0.08820654f, -0.19377865f, -0.25596073f, 0.10078917f, 0.21390951f, -0.09498039f, 
    0.19113694f, -0.05034195f, 0.03867448f, -0.19493733f, 0.37218618f, 0.24487084f, -0.07083686f, -0.21496068f, 
    -0.07051568f, -0.34780329f, -0.20584422f, 0.13055864f, 0.08099265f, 0.31714731f, -0.05127821f, 0.21902031f, 
    -0.18489879f, -0.37113020f, 0.19394292f, 0.26760459f, -0.08227552f, -0.13772702f, -0.20538546f, 0.15266950f, 
    0.40802112f, 0.40988779f, 0.21210892f, 0.24145964f, -0.02064868f, -0.10243410f, 0.44743615f, 0.16505730f, 
    0.18181464f, -0.25754935f, -0.09547207f, -0.02619633f, -0.02189276f, 0.01620178f, -0.02521929f, 0.04850455f, 
    -0.10223818f, 0.06525651f, -0.01887104f, -0.18257268f, 0.01256404f, 0.01201469f, -0.07324084f, 0.02299299f, 
    -0.15398671f, 0.04688551f, -0.16141666f, 0.05301072f, -0.08100791f, -0.06534487f, -0.23509543f, 0.10830413f, 
    -0.08479653f, -0.17199519f, 0.03749818f, -0.04796510f, 0.05223949f, -0.04086941f, 0.03783351f, 0.02151353f, 
    -0.02836407f, 0.04241753f, -0.24345683f, -0.03651778f, -0.05230331f, -0.03040241f, -0.24360633f, -0.02693786f, 
    0.00880309f, 0.13311014f, 0.34724182f, 0.13265720f, 0.01726366f, -0.14877331f, -0.15219171f, -0.27183026f, 
    -0.02391588f, -0.17008257f, 0.01292832f, 0.22691286f, 0.22822195f, 0.11665186f, 0.08929639f, -0.25569871f, 
    0.17392264f, -0.21788670f, 0.24685806f, 0.04045412f, -0.16563344f, 0.21966788f, -0.16665421f, -0.12605645f, 
    -0.05226495f, -0.24417043f, 0.21534668f, -0.20783047f, 0.05818037f, -0.41321570f, 0.03322949f, -0.16808765f, 
    -0.03565931f, -0.00642559f, 0.03184107f, 0.04061529f, -0.01692042f, -0.13612142f, 0.12881248f, -0.02217152f, 
    0.09250535f, 0.11209194f, -0.01340152f, -0.18787602f, -0.18348084f, 0.14261442f, -0.06261750f, 0.05996701f, 
    -0.01382335f, 0.04947503f, -0.12871635f, -0.16216552f, -0.20370132f, -0.16064817f, 0.00463247f, -0.17567076f, 
    -0.10411232f, -0.17134173f, -0.10340034f, -0.04326340f, -0.04903807f, 0.03347126f, -0.05869531f, -0.14644980f, 
    0.12366956f, 0.41921380f, -0.54373157f, 0.39317504f, 0.06336093f, 0.09888805f, 0.12482569f, 0.16331807f, 
    0.08114178f, -0.07648345f, -0.05102427f, 0.07398171f, -0.47034758f, -0.00650835f, 0.02242614f, 0.14337187f, 
    -0.19743237f, 0.16557428f, 0.18971391f, -0.06747725f, 0.21954161f, 0.29583177f, 0.23517945f, -0.11283902f, 
    -0.27525386f, -0.14204162f, 0.16143189f, 0.13146450f, -0.22484647f, 0.32560050f, -0.36114180f, 0.34773010f, 
    0.09823100f, -0.10888097f, 0.24656197f, -0.13935898f, 0.00348865f, 0.10845435f, -0.05147713f, -0.01653490f, 
    -0.26478735f, 0.08487178f, 0.18210842f, -0.21692970f, -0.21373782f, 0.12146584f, -0.16533686f, 0.26619384f, 
    -0.07718307f, 0.27582386f, -0.05412932f, 0.26277632f, 0.11477667f, 0.24251884f, 0.34381551f, -0.11504468f, 
    -0.04979066f, 0.20940594f, -0.04341279f, 0.18920000f, -0.29349196f, 0.05861082f, -0.04734974f, 0.05969604f, 
    -0.04600405f, 0.41852325f, 0.26409602f, -0.19417048f, -0.00933747f, 0.22881909f, 0.05643187f, 0.26333326f, 
    -0.10209747f, -0.36210540f, -0.02964004f, -0.10271603f, 0.16008286f, 0.09719570f, 0.34090263f, 0.21250547f, 
    0.12427492f, 0.10516594f, -0.50801611f, 0.01876390f, -0.56014562f, -0.07331970f, -0.08686503f, 0.01615142f, 
    0.08529790f, -0.18575594f, 0.14603277f, -0.38860786f, 0.35612029f, 0.20916674f, 0.18131514f, 0.00219562f, 
    0.04949648f, 0.26998228f, -0.22603694f, -0.08679692f, 0.00356925f, 0.08821539f, -0.11700360f, -0.04233530f, 
    0.10098465f, -0.13601606f, -0.18174629f, -0.01578007f, -0.04652634f, 0.13365573f, -0.04008804f, -0.03765623f, 
    -0.07852782f, -0.24553610f, -0.19638841f, 0.12383269f, 0.19772607f, 0.06365260f, -0.16360705f, 0.07919595f, 
    0.08726665f, -0.06949233f, 0.05208855f, 0.05359567f, -0.04859741f, 0.19960304f, -0.19478805f, 0.20536855f, 
    0.08160011f, -0.17134255f, -0.17831151f, -0.00470929f, -0.18647932f, -0.08784611f, 0.09664474f, -0.00459305f, 
    -0.17481826f, -0.17427145f, 0.10456534f, 0.10093723f, -0.08236398f, -0.06677311f, 0.01615779f, 0.12232579f, 
    -0.16897844f, -0.14248823f, -0.18239155f, 0.13202712f, -0.03829100f, -0.18266124f, -0.03267742f, 0.11787257f, 
    -0.00389042f, -0.05020884f, -0.16855134f, -0.17181715f, -0.11394300f, -0.17650585f, -0.17473117f, -0.14374731f, 
    0.16758680f, 0.20397794f, -0.10129297f, -0.05074033f, -0.12872103f, 0.04547644f, -0.02536484f, -0.10018507f, 
    -0.11857387f, -0.16136454f, -0.02274170f, -0.14619292f, -0.15016119f, 0.00276551f, -0.00272136f, -0.04569818f, 
    0.14630534f, 0.02595138f, -0.13761261f, -0.05187034f, 0.15541537f, -0.05097027f, 0.09282336f, -0.06204075f, 
    -0.05988243f, 0.01993689f, 0.11134729f, -0.11896535f, 0.01711742f, 0.23063554f, -0.11441468f, 0.09958224f, 
    -0.02685238f, 0.17673920f, 0.23665519f, 0.04347070f, -0.04535624f, -0.07713486f, -0.08875067f, 0.22409461f, 
    -0.22287413f, -0.09542770f, -0.11652162f, -0.02859084f, 0.07272457f, 0.01027587f, -0.07340304f, -0.21755211f, 
    0.23924372f, 0.46889386f, 0.12163597f, 0.27136180f, -0.32578000f, 0.04014138f, -0.25915760f, -0.18419130f, 
    0.21643981f, -0.25360310f, 0.22449799f, -0.41582790f, -0.06213712f, 0.14920805f, 0.30000472f, 0.22706757f, 
    -0.13278310f, -0.20942311f, -0.08342064f, 0.20146273f, 0.39862451f, -0.67157394f, 0.29048058f, 0.33065030f, 
    -0.29857665f, -0.06795911f, 0.27139667f, 0.16296175f, 0.02574354f, -0.07268580f, -0.27387655f, 0.20137374f, 
    0.18287259f, 0.08774554f, 0.05277577f, 0.34679183f, -0.01851259f, -0.10336298f, 0.13432154f, 0.03422325f, 
    0.16365352f, 0.09049974f, -0.06522681f, -0.22082520f, -0.27786174f, -0.12790407f, -0.26499486f, -0.03415033f, 
    -0.08300593f, -0.19825491f, -0.15162703f, 0.17659153f, -0.13968889f, 0.09280006f, -0.14880365f, -0.00174296f, 
    0.41610333f, -0.09375954f, -0.06596763f, -0.12478423f, 0.17948419f, 0.14197175f, 0.04637617f, 0.15636286f, 
    -0.21231848f, 0.10746267f, 0.14901759f, -0.23489988f, 0.09714542f, 0.44893521f, 0.28931150f, 0.12850358f, 
    -0.10051955f, 0.18138012f, -0.09467831f, 0.13806242f, 0.13434796f, 0.07751801f, 0.04568641f, -0.40083727f, 
    -0.05938386f, -0.21197346f, -0.11395609f, -0.19590752f, 0.06748444f, 0.17308515f, -0.01261874f, 0.03238755f, 
    -0.05729169f, -0.15744439f, -0.18061931f, -0.03684084f, -0.07373329f, -0.00539120f, 0.04282592f, -0.11835781f, 
    0.19427441f, -0.07852208f, -0.06206016f, 0.05937632f, -0.08813117f, 0.00616621f, -0.18768403f, -0.16996771f, 
    0.17936593f, -0.27341068f, -0.21977228f, 0.02975683f, 0.24184772f, -0.14762120f, 0.16501212f, 0.21449281f, 
    -0.08007724f, 0.02051982f, 0.13747472f, 0.03132876f, 0.06641937f, 0.11821752f, -0.15168276f, -0.07582943f, 
    -0.09822436f, 0.06541772f, -0.19333978f, -0.08430023f, -0.01514497f, -0.20940657f, -0.22738191f, -0.13474239f, 
    -0.14821702f, -0.02408096f, -0.09926648f, -0.00878144f, 0.01666261f, -0.02743132f, 0.14581382f, -0.00904849f, 
    -0.11354469f, -0.19265723f, -0.03070667f, -0.19570978f, -0.00718328f, -0.14828700f, -0.07648773f, 0.16692790f, 
    -0.09519648f, 0.18242650f, 0.25924930f, -0.27243185f, -0.23377870f, 0.26577461f, -0.15255524f, 0.01464740f, 
    0.12434579f, 0.11126525f, -0.23244546f, 0.05515091f, 0.34755915f, 0.22151935f, 0.09312570f, -0.03939321f, 
    0.12381051f, 0.38100022f, -0.00907311f, 0.17489581f, -0.28213426f, 0.06081996f, -0.44043022f, -0.00577200f, 
    0.17820676f, -0.20775281f, -0.07645645f, -0.12605162f, 0.21286820f, 0.43911746f, 0.07250746f, 0.34518817f, 
    0.01389284f, -0.08082274f, 0.13645121f, 0.25750861f, -0.48187557f, 0.24140681f, 0.28011957f, 0.19722426f, 
    -0.24766296f, 0.14328189f, -0.17174269f, 0.11580357f, -0.00942497f, -0.14165436f, -0.25543419f, -0.03731627f, 
    -0.27115989f, -0.21519409f, -0.20070888f, 0.20768186f, 0.33197230f, 0.08372166f, -0.45606095f, -0.00955653f, 
    -0.01651387f, 0.33038393f, 0.08258379f, 0.06960563f, -0.52557880f, 0.04548026f, -0.40417305f, 0.45790976f, 
    0.00809580f, 0.54665136f, -0.37404096f, 0.35336927f, 0.14494757f, -0.80497092f, 0.09917787f, 0.18465522f, 
    0.18779188f, -0.19748482f, -0.20303667f, -0.09273347f, 0.33775336f, 0.04774397f, -0.02711216f, 0.00132828f, 
    0.52091497f, -0.13144128f, 0.26905963f, -0.31362468f, -0.10386243f, 0.15452960f, 0.18324232f, -0.00888381f, 
    0.18123785f, 0.07577495f, 0.03348144f, -0.31414536f, 0.12530816f, 0.08380684f, -0.10511352f, -0.38276267f, 
    0.13132960f, 0.55210871f, 0.07812811f, 0.33448353f, -0.41521278f, -0.11491826f, 0.22354603f, 0.08981790f, 
    -0.16912046f, -0.28399229f, 0.10276634f, -0.09029736f, -0.49735799f, -0.15083261f, -0.23996402f, -0.35101062f, 
    0.33313808f, -0.34362167f, -0.00830752f, 0.01620734f, 0.11362281f, 0.07575707f, -0.06509919f, 0.00782229f, 
    -0.04551407f, 0.20274386f, 0.35935470f, -0.06398261f, -0.09879291f, 0.22823928f, -0.18184257f, 0.34979498f, 
    -0.16442943f, 0.35076201f, -0.23827961f, 0.48771587f, -0.01368583f, 0.27243188f, 0.14160815f, 0.11849499f, 
    -0.02611060f, 0.04524883f, -0.26780945f, 0.07713420f, -0.02922055f, 0.11462674f, 0.03794973f, 0.11487614f, 
    -0.13301261f, 0.24180178f, -0.05753230f, -0.08552012f, -0.06654701f, 0.16276892f, 0.09132071f, 0.09523527f, 
    -0.14536820f, -0.17941138f, 0.02038394f, 0.13125710f, -0.18975329f, 0.42274147f, -0.00863645f, 0.08242972f, 
    0.15171641f, 0.35375887f, -0.19445711f, -0.16341498f, 0.11140621f, 0.14253321f, -0.05409438f, 0.15810539f, 
    -0.25075948f, -0.06241868f, -0.01578739f, -0.21845321f, 0.25342539f, 0.19981414f, -0.03179360f, 0.25153890f, 
    0.21021666f, 0.34616116f, -0.19198783f, 0.02622367f, 0.01783986f, 0.11906477f, 0.27278942f, -0.14709182f, 
    0.10711691f, -0.35297281f, -0.18859406f, 0.10409845f, 0.08703525f, 0.28560427f, 0.03836344f, 0.16080324f, 
    0.05067644f, -0.10248055f, 0.14542083f, 0.20973034f, 0.05222876f, 0.06073127f, 0.05508123f, 0.15590774f, 
    -0.03084667f, -0.10139794f, -0.02413538f, 0.14440495f, -0.07408162f, -0.25714812f, -0.01476326f, 0.14110088f, 
    0.07923241f, -0.16512695f, 0.00452320f, 0.23643731f, -0.06126352f, 0.09106727f, -0.33710030f, -0.02265272f, 
    -0.11582247f, -0.20315813f, -0.00006498f, -0.12168225f, -0.28160864f, -0.07731217f, -0.21106420f, 0.07194041f, 
    -0.05349027f, -0.02917532f, 0.00518110f, -0.48276809f, -0.16324176f, -0.24601176f, -0.06881204f, 0.31324440f, 
    -0.10010976f, 0.10329938f, 0.04394164f, -0.05264071f, 0.21813038f, 0.04054182f, -0.12611166f, -0.11761504f, 
    0.27807471f, -0.34315968f, -0.10647468f, 0.02334281f, 0.11884157f, -0.21044455f, -0.11240323f, -0.10074083f, 
    0.33109957f, -0.03016500f, -0.13111623f, -0.09467717f, -0.04034032f, 0.16301490f, -0.22497229f, 0.18756673f, 
    -0.14528696f, -0.26829758f, -0.03828582f, 0.34788331f, -0.18190737f, 0.14242867f, 0.03495067f, -0.00536982f, 
    0.11066152f, 0.19593634f, 0.10283880f, -0.13961951f, 0.23606528f, -0.04671824f, 0.09428096f, 0.02744874f, 
    -0.02722807f, 0.53067744f, 0.23929735f, 0.11503136f, -0.18430690f, 0.12554303f, 0.06482378f, 0.02962203f, 
    0.08446408f, 0.07429671f, 0.09456196f, -0.05182152f, 0.27662161f, -0.13761348f, 0.01832843f, -0.48779914f, 
    -0.00972397f, -0.38567868f, 0.08219456f, -0.19696681f, 0.15779679f, -0.27364677f, 0.29700163f, 0.06247590f, 
    0.13602188f, -0.18687077f, 0.29557827f, 0.21348009f, -0.24295829f, -0.37104669f, -0.03685661f, 0.15348049f, 
    0.31120193f, -0.11602280f, 0.36115089f, 0.41738924f, 0.21343842f, -0.51885355f, 0.10775896f, -0.05525480f, 
    0.00825596f, 0.02657748f, -0.17443135f, -0.14675416f, 0.01772301f, -0.05901115f, -0.21202305f, 0.18542992f, 
    0.09500074f, 0.41794240f, -0.22599305f, 0.22328515f, -0.03805744f, 0.10662321f, 0.18776509f, 0.16632794f, 
    -0.17098816f, -0.11881767f, 0.03091619f, 0.14047891f, 0.04060936f, 0.04521870f, 0.24732828f, -0.23053971f, 
    0.27176693f, -0.11184552f, -0.25948218f, -0.13336822f, 0.03546295f, 0.19532865f, -0.04091432f, -0.03148866f, 
    -0.13585769f, 0.07742966f, 0.30420944f, -0.05534005f, -0.05799274f, 0.04356511f, 0.08381353f, 0.10098061f, 
    -0.02042134f, -0.25640297f, -0.13426243f, 0.55035383f, 0.01817072f, 0.43125257f, 0.19574960f, 0.02741856f, 
    -0.12995806f, -0.18612468f, -0.29670787f, 0.21720058f, 0.19797252f, -0.06216864f, 0.12068206f, 0.25029346f, 
    -0.03028586f, -0.11724816f, 0.12253904f, 0.22105947f, -0.11207494f, -0.07624165f, -0.05107404f, -0.09240758f, 
    -0.16934881f, 0.33912960f, 0.08484418f, 0.19425355f, -0.25695282f, -0.27530140f, -0.26122364f, -0.28574431f, 
    0.14665690f, 0.10915368f, 0.08488887f, 0.11543980f, -0.25290567f, -0.51132017f, 0.38814816f, -0.01726999f, 
    0.04339644f, 0.35832548f, -0.04133572f, 0.17086382f, 0.19570461f, -0.32457602f, -0.24051467f, -0.23119371f, 
    -0.19786483f, -0.05698481f, 0.21407577f, 0.19030976f, 0.38678253f, -0.41109180f, -0.13575710f, -0.01686307f, 
    0.23602167f, 0.21900435f, -0.30324668f, -0.01601941f, -0.38918245f, 0.05882832f, -0.31659824f, 0.25459567f, 
    -0.07818705f, 0.09807628f, -0.44890419f, 0.30308327f, -0.05486993f, -0.21917690f, 0.20853068f, 0.05395688f, 
    -0.17532128f, -0.04850312f, -0.16666877f, 0.08674135f, 0.00171729f, -0.15650952f, -0.04165395f, -0.26671180f, 
    -0.14795223f, -0.19248392f, 0.06606308f, 0.18030713f, 0.06404070f, 0.27439454f, -0.31313384f, 0.10699399f, 
    -0.03326473f, 0.21617854f, 0.15848951f, 0.19763783f, -0.29703638f, -0.20806603f, -0.04921290f, -0.23863050f, 
    -0.02502307f, -0.40836418f, 0.15894228f, 0.22751769f, -0.00431350f, -0.23301998f, 0.09248682f, 0.12458755f, 
    0.04492001f, -0.07015333f, 0.19850361f, -0.39474449f, -0.43602586f, -0.29004937f, -0.16554691f, -0.09594176f, 
    0.10862948f, 0.60122424f, 0.16130325f, 0.29061180f, 0.17049135f, 0.11054902f, 0.30517960f, 0.07359758f, 
    0.14135985f, -0.10617740f, 0.22206751f, -0.29684609f, -0.05391901f, 0.06985576f, 0.05516752f, -0.09819096f, 
    -0.06498168f, -0.48146793f, -0.32735115f, 0.12195237f, 0.10001611f, 0.09811993f, 0.10238687f, 0.14767081f, 
    -0.21245193f, -0.03398935f, -0.06041545f, 0.42037648f, 0.25229907f, 0.17301992f, -0.19430996f, 0.48033667f, 
    -0.03014163f, -0.33137804f, 0.07218670f, 0.21037105f, 0.12042164f, -0.20136742f, -0.29287493f, 0.12315595f, 
    -0.34120950f, -0.09382892f, -0.13341667f, -0.00936005f, 0.03624221f, -0.19341934f, 0.03023842f, -0.19390777f, 
    0.06099115f, -0.57140040f, 0.30416796f, 0.00162731f, 0.09590477f, 0.46850601f, -0.04460594f, 0.21893725f, 
    -0.23693082f, -0.17631429f, -0.32461223f, 0.09646817f, 0.35778505f, -0.06827936f, 0.02965737f, 0.17496456f, 
    -0.09283342f, -0.07706121f, -0.19227424f, 0.16217004f, -0.30446413f, 0.01728760f, 0.04280517f, 0.01163175f, 
    0.11951548f, 0.13875365f, -0.16282436f, -0.04915142f, 0.03522071f, 0.37666601f, 0.19077842f, 0.08272912f, 
    -0.00369748f, -0.38825056f, 0.15820442f, 0.19460577f, 0.03538566f, 0.13416608f, -0.08675649f, 0.20224653f, 
    -0.12599853f, -0.15995714f, 0.11774144f, 0.22469540f, -0.05783579f, 0.08595318f, 0.28583005f, 0.31604806f, 
    0.26332870f, -0.29741442f, 0.15286694f, -0.13352658f, 0.01220007f, -0.42394745f, -0.04673059f, 0.06275429f, 
    -0.09594444f, 0.06039621f, -0.08151813f, -0.15122752f, 0.19267167f, -0.16943069f, 0.15274602f, -0.07998452f, 
    0.07935958f, -0.13757955f, -0.33634719f, -0.14454472f, 0.18209228f, 0.29388404f, -0.09730458f, -0.10315906f, 
    0.01959466f, 0.21712376f, -0.15315318f, -0.00947136f, -0.08969037f, 0.05566656f, 0.08128853f, 0.02381246f, 
    -0.25541911f, 0.04288401f, -0.16858441f, 0.08177612f, -0.07033380f, -0.23073612f, -0.31878328f, 0.13412650f, 
    0.29358712f, 0.01556478f, -0.14438920f, 0.18554030f, 0.12296696f, -0.37834349f, 0.00431587f, -0.09032022f, 
    -0.12112443f, 0.01150805f, 0.43748811f, 0.17917472f, -0.45380059f, 0.46850613f, 0.05280583f, -0.05631553f, 
    -0.06047006f, 0.09141368f, 0.44168809f, -0.23335840f, -0.26689011f, 0.05430434f, 0.26140177f, -0.10703297f, 
    -0.04332479f, 0.24984075f, 0.12705639f, 0.26855808f, -0.10059213f, 0.10806754f, 0.17288145f, -0.19058545f, 
    -0.03750409f, 0.19502135f, -0.09695758f, 0.12994596f, 0.09399574f, -0.33143321f, -0.17644078f, -0.28938869f, 
    0.02972505f, 0.23960856f, -0.24467781f, 0.18992411f, -0.45914337f, -0.00737521f, 0.23364328f, 0.28052583f, 
    -0.13592227f, -0.51226711f, -0.02105881f, 0.41714785f, -0.16693585f, -0.00733001f, 0.11994094f, 0.05068119f, 
    0.05811080f, -0.45168403f, 0.15773840f, 0.07396400f, -0.04652713f, -0.37621349f, -0.11872782f, 0.03117633f, 
    0.22948925f, 0.19904430f, 0.19514871f, -0.04668478f, 0.00293189f, 0.17674553f, -0.45186245f, 0.22280023f, 
    -0.08883188f, 0.23564489f, 0.15852913f, 0.18658200f, -0.17751487f, 0.00744969f, -0.01087153f, -0.00865516f, 
    0.23507115f, -0.00818940f, -0.37017298f, 0.04983122f, -0.22314167f, 0.04534542f, 0.22420765f, 0.14421669f, 
    -0.07950728f, 0.16509011f, -0.07873666f, -0.04251492f, 0.04320948f, 0.17853117f, -0.37420771f, 0.12754855f, 
    -0.39767981f, 0.08353662f, -0.13785292f, -0.16058365f, -0.13288057f, 0.51998168f, 0.06743196f, 0.46066341f, 
    0.04781298f, 0.00839782f, -0.05113199f, -0.05664898f, -0.05516498f, -0.23394448f, 0.07162230f, 0.01339942f, 
    0.24150650f, -0.22201689f, 0.07949694f, 0.39423397f, -0.18710306f, 0.15043145f, 0.17397565f, 0.32171661f, 
    0.07262766f, -0.22448625f, -0.03974295f, -0.29530650f, 0.08243579f, -0.39036271f, 0.28425482f, -0.07319180f, 
    0.11849182f, 0.13150896f, -0.07718053f, 0.00921793f, 0.10823099f, -0.03606455f, -0.36994135f, 0.29365817f, 
    -0.12239302f, 0.11050851f, 0.14354438f, 0.11915847f, -0.03175920f, -0.28258464f, -0.09350827f, 0.21328506f, 
    0.12444319f, -0.56620318f, -0.11602374f, 0.17367299f, -0.02477400f, -0.09878963f, 0.15516073f, 0.21883437f, 
    0.31467199f, -0.11367951f, -0.32972646f, -0.25031072f, -0.36514136f, 0.08271623f, 0.06246992f, 0.15969367f, 
    -0.13910620f, 0.10306489f, 0.13737129f, -0.33646730f, 0.27536842f, 0.40107408f, 0.16103458f, 0.10295498f, 
    0.14860080f, -0.02015337f, 0.24390568f, -0.32976538f, 0.11502930f, -0.18477111f, 0.11524688f, 0.23859742f, 
    0.12946574f, -0.40576291f, 0.07303192f, 0.29520294f, -0.41233209f, 0.18059465f, -0.13108477f, 0.07273261f, 
    0.13781263f, -0.50150818f, 0.11457186f, -0.26949900f, -0.02528193f, -0.41416156f, -0.14360861f, -0.04584918f, 
    0.13231367f, 0.16182356f, 0.02865008f, -0.35601002f, 0.14170995f, 0.11855890f, -0.18166721f, 0.37114555f, 
    -0.03529279f, -0.30057165f, 0.19247586f, -0.18657191f, -0.14143792f, 0.15861955f, -0.17505248f, 0.01112737f, 
    0.27315378f, 0.09086420f, 0.22010645f, 0.22810976f, 0.46799234f, -0.00039285f, 0.15363520f, 0.37097916f, 
    0.06898532f, 0.27009401f, -0.10707010f, -0.02204766f, 0.02912541f, 0.17274831f, 0.48689690f, 0.02410395f, 
    0.18269460f, -0.07401123f, -0.33286354f, -0.00634205f, 0.03246960f, -0.16559790f, 0.18985161f, -0.12131344f, 
    0.11335038f, 0.08896068f, -0.31748590f, 0.26304355f, 0.11120579f, 0.08002583f, -0.06775506f, -0.41216537f, 
    -0.11604907f, 0.17197621f, -0.15859446f, -0.02254102f, 0.19461925f, -0.12541752f, 0.24051398f, 0.20612039f, 
    -0.10982486f, -0.07549020f, -0.03131961f, -0.28868410f, -0.02874701f, -0.12769754f, -0.16584197f, -0.17712887f, 
    -0.56258643f, -0.28089166f, -0.03455975f, 0.12236870f, -0.32336834f, 0.08958780f, -0.09688599f, 0.32118544f, 
    0.00108657f, 0.03909596f, 0.34245735f, -0.25803611f, 0.17732257f, -0.49539116f, 0.07426232f, 0.25005594f, 
    0.13953424f, -0.12948616f, 0.06031423f, 0.23636848f, 0.12569715f, -0.03482382f, 0.08133695f, 0.23812833f, 
    0.34900931f, -0.58135629f, 0.07731766f, -0.31973207f, -0.18107551f, -0.17141075f, 0.20452994f, -0.06942758f, 
    0.25436145f, 0.36693111f, -0.15296489f, -0.23170884f, 0.21023582f, -0.00521389f, -0.07301139f, 0.13591415f, 
    -0.04353442f, 0.01475082f, -0.30838877f, -0.02423276f, -0.08642554f, 0.26507920f, -0.06464946f, 0.15646327f, 
    0.40104163f, -0.05862719f, 0.02611710f, 0.16541456f, -0.14463083f, -0.00564894f, 0.27035895f, 0.41712716f, 
    -0.14978291f, -0.06713828f, 0.10310444f, -0.34114492f, -0.08305924f, 0.24287224f, 0.42045403f, -0.15461117f, 
    -0.12721778f, 0.10664305f, -0.18726218f, 0.16630080f, 0.29260454f, 0.02144390f, 0.00721134f, -0.07019260f, 
    0.13327779f, 0.06848107f, -0.02897544f, 0.42987573f, -0.00734844f, -0.28316072f, 0.24640602f, -0.18032880f, 
    -0.01491035f, -0.26630479f, -0.02234693f, 0.43810242f, -0.15534593f, 0.16025563f, 0.42924780f, 0.11576302f, 
    0.28206816f, -0.58749032f, -0.06794319f, -0.22126479f, -0.21848439f, -0.17143832f, -0.26370403f, 0.03760239f, 
    -0.10553266f, 0.39134273f, 0.20729934f, 0.00362779f, 0.29229131f, -0.08787499f, -0.09550513f, 0.34563529f, 
    -0.14912261f, 0.04673351f, 0.36252052f, 0.08053415f, -0.34122354f, -0.48050129f, 0.03779908f, -0.06613692f, 
    -0.27422464f, 0.03416645f, -0.16482368f, 0.01842045f, 0.45430514f, 0.04975108f, 0.17672436f, -0.11797146f, 
    0.36908370f, 0.06575101f, -0.18266633f, 0.17331962f, -0.23299089f, -0.24979319f, -0.33318728f, -0.04378762f, 
    0.27812827f, 0.19061141f, -0.03218879f, 0.00537653f, 0.20051302f, -0.15469147f, 0.05108877f, 0.07822370f, 
    0.17240693f, -0.00032268f, 0.56287450f, 0.12290915f, -0.02886652f, -0.47933447f, -0.04466482f, 0.16642578f, 
    0.03292712f, -0.20027053f, 0.18147199f, -0.19670531f, -0.04977360f, 0.04656965f, 0.05381039f, -0.23857127f, 
    0.23713432f, -0.06812496f, 0.12024221f, 0.29560888f, -0.27781731f, -0.02385025f, -0.25700107f, 0.15153718f, 
    0.03682284f, 0.19656071f, 0.02671100f, -0.45324653f, 0.26832405f, 0.44628799f, 0.08007609f, 0.16539378f, 
    -0.10531544f, 0.43242654f, 0.28930342f, -0.11826678f, -0.04523382f, 0.00517151f, 0.20149025f, -0.07449469f, 
    -0.20843430f, 0.06001526f, -0.11608128f, 0.27928394f, -0.11319431f, -0.02450099f, 0.25614321f, -0.33347741f, 
    0.36556113f, -0.25995752f, -0.01500375f, 0.08196581f, 0.12305529f, -0.16935264f, -0.35899135f, 0.14820547f, 
    0.21242808f, -0.17625289f, 0.21372391f, -0.33580396f, 0.20034686f, -0.05270889f, 0.10262360f, 0.24653266f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04008620f, -0.07795605f, 0.00084088f, -0.14676572f, 0.24455518f, -0.12667046f, -0.03118167f, 0.01405152f, 
    0.12072425f, 0.02353169f, 0.04278141f, 0.08348440f, -0.01447027f, -0.14340580f, 0.21412545f, 0.15312248f, 
    -0.08043846f, -0.07734036f, -0.01493007f, -0.18008132f, 0.15897754f, -0.25680268f, 0.18822569f, 0.11429910f, 
    -0.18220244f, -0.01842422f, 0.12328555f, 0.07324804f, 0.14025238f, 0.02257464f, -0.15490043f, 0.21385927f, 
    0.31866285f, 0.01796811f, 0.08406615f, 0.08974040f, -0.03610163f, -0.11314958f, -0.06744262f, 0.12121013f, 
    0.20753680f, 0.24346811f, 0.31694993f, 0.18843627f, 0.14005545f, 0.13098460f, -0.15909402f, -0.12405856f, 
    -0.11217570f, -0.10181143f, 0.10265905f, 0.01795202f, 0.16511069f, 0.16563781f, 0.06656321f, 0.12497310f, 
    -0.16412890f, 0.09656577f, -0.10891496f, 0.06125433f, 0.20207688f, -0.09695861f, 0.29734886f, -0.07841407f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.23002258f, -0.28083858f, 0.10238758f, 0.28123277f, 0.02513467f, -0.07231209f, 0.18269348f, 0.15708040f, 
    0.03866665f, -0.15406041f, -0.49699387f, 0.08173150f, -0.61432636f, 0.15885699f, -0.48576462f, 0.04749119f, 
    0.14926592f, 0.03584567f, -0.10147744f, -0.01696501f, -0.02975603f, 0.16327533f, -0.05229933f, -0.19021410f, 
    -0.11971051f, -0.05493769f, 0.02405392f, 0.11610346f, -0.07887115f, -0.22123487f, -0.00856698f, 0.00980905f, 
    -0.12671386f, -0.68601495f, -0.58297813f, -0.11997942f, 0.12477200f, -0.24471435f, -0.21262814f, 0.20091879f, 
    0.24948880f, -0.23129143f, -0.16562375f, 0.04584711f, 0.00155807f, 0.27679583f, -0.14345923f, -0.40810883f, 
    -0.32752517f, 0.05303213f, 0.32707849f, -0.80211198f, -0.03727284f, -0.11423870f, -0.56283236f, -0.29071364f, 
    0.10976796f, -0.37177876f, -0.28276706f, -0.24025740f, -0.28770357f, -0.09848335f, -0.05678691f, -0.10915017f, 
    0.10593536f, 0.06362212f, -0.19384219f, 0.17652902f, 0.11846794f, 0.01603705f, 0.23348697f, -0.05181379f, 
    0.01167055f, 0.21058787f, -0.59134287f, -0.08924506f, -0.51947194f, -0.02278570f, 0.34488532f, 0.03967508f, 
    0.08365303f, -0.14462794f, 0.02206949f, 0.05438744f, 0.03177464f, 0.04013643f, 0.20945773f, -0.06044281f, 
    -0.08865100f, -0.05481867f, 0.33976042f, -0.17969894f, 0.08822560f, -0.13418262f, -0.08334157f, 0.26831537f, 
    -0.11594399f, -0.12935778f, -0.31604904f, 0.05772367f, 0.17772666f, 0.11964965f, -0.22779560f, 0.17986237f, 
    -0.28096622f, -0.04242389f, 0.31732392f, -0.75231242f, -0.22138093f, 0.19762020f, 0.03869116f, 0.33700699f, 
    -0.12786685f, 0.05017712f, -0.08168776f, -0.51724339f, -0.03837471f, -0.73669016f, 0.07954771f, -0.21941519f, 
    0.00138808f, 0.22343743f, -0.23739414f, 0.02380998f, -0.47774881f, -0.09414123f, 0.11617687f, -0.15386572f, 
    0.05831606f, 0.10039452f, -0.11051129f, -0.24015129f, -0.19142166f, -0.10704815f, -0.52836156f, 0.13511409f, 
    -0.27133840f, 0.19143248f, 0.31981498f, -0.58668607f, 0.18296623f, -0.09667256f, 0.06420451f, 0.17781977f, 
    -0.48871142f, -0.04480261f, 0.05817559f, -0.08759192f, 0.23772082f, 0.09092532f, 0.08791357f, 0.18041329f, 
    -0.11605393f, 0.06320822f, 0.23401445f, 0.10246895f, -0.14097625f, -0.16495462f, -0.04932572f, 0.10287567f, 
    0.17493168f, 0.13670376f, 0.33684716f, 0.03819235f, 0.19730698f, 0.08106034f, 0.12005469f, -0.35397965f, 
    -0.24161220f, 0.00251392f, -0.65365016f, 0.20664020f, -0.12146883f, -0.20540377f, -0.29672322f, -0.24859743f, 
    -0.61079127f, 0.27193549f, -0.51244992f, 0.09013008f, 0.17050488f, -0.12195151f, 0.10860405f, 0.07848726f, 
    -0.29204652f, 0.20734106f, -0.01251153f, -0.15588014f, -0.18490130f, -0.14033563f, 0.10944178f, 0.05457919f, 
    -0.12049443f, -0.02652526f, 0.01220330f, -0.54191285f, -0.04726086f, -0.01029686f, -0.08453521f, 0.16014726f, 
    0.21198973f, -0.12602404f, 0.39087895f, 0.06180777f, 0.06028937f, 0.10453696f, -0.65237570f, -0.04445612f, 
    -0.06214207f, -0.08909356f, 0.51131403f, -0.04676305f, -0.45125648f, 0.03591434f, -0.11897066f, -0.16369781f, 
    0.01475754f, -0.00854111f, 0.23928465f, 0.08888919f, -0.40427706f, -0.00776294f, 0.09863802f, 0.07756012f, 
    0.29771900f, -0.50148511f, 0.14482890f, -0.41349554f, -0.44445589f, -0.14159049f, 0.23063459f, -0.09077875f, 
    0.22868048f, -0.21091540f, -0.45951432f, 0.28778362f, -0.27004790f, 0.11818242f, -0.29591331f, 0.08827799f, 
    0.13167746f, -0.42917284f, 0.06158179f, 0.04307303f, -0.16200393f, -0.20283334f, -0.20913078f, 0.21572962f, 
    -0.19611606f, -0.07287495f, 0.14905980f, -0.67199278f, -0.09990551f, 0.02299486f, 0.27122253f, 0.31370237f, 
    0.10897145f, -0.45546660f, 0.19171259f, -0.00039132f, 0.13186283f, -0.02472541f, -0.35913673f, 0.09020016f, 
    0.12884730f, -0.06252305f, 0.14462923f, 0.21715142f, 0.18199351f, 0.19619349f, -0.36093768f, 0.06386825f, 
    0.12096558f, -0.07604299f, -0.22629042f, 0.02911892f, 0.12680152f, -0.07098915f, -0.45063594f, -0.07639763f, 
    0.02938311f, -0.07184374f, -0.22361320f, 0.05937839f, 0.13369416f, 0.03499247f, 0.02112977f, -0.27490494f, 
    -0.68974555f, 0.38742223f, -0.10136096f, -0.11975442f, -0.03594057f, -0.08961654f, 0.03812806f, 0.03883344f, 
    0.23694107f, -0.21500617f, -0.18220495f, 0.17426765f, -0.17746787f, -0.03242995f, 0.08331961f, -0.42819589f, 
    0.00525849f, 0.03483691f, -0.16036697f, -0.07891390f, -0.31673154f, 0.25953487f, -0.30106869f, 0.15154651f, 
    0.08698133f, -0.14140929f, 0.14021549f, 0.20398621f, -0.49950498f, -0.38473246f, -0.15935944f, -0.22225027f, 
    0.05676034f, -0.26556274f, -0.04247252f, 0.08586644f, 0.05603769f, -0.06331564f, -0.02136025f, 0.15389188f, 
    0.13570334f, -0.00263539f, -0.03805042f, 0.00818014f, -0.29134455f, 0.06470022f, 0.17535692f, 0.09478599f, 
    0.09207085f, -0.09047262f, -0.25195783f, -0.06270079f, -0.16705808f, -0.07205435f, 0.28869838f, -0.07016404f, 
    -0.12789240f, 0.09519168f, 0.15000153f, 0.02972961f, -0.11443948f, 0.17603903f, -0.02905532f, -0.07439244f, 
    -0.77728444f, 0.14463240f, 0.07483102f, -0.12791006f, 0.21237877f, -0.28959298f, 0.09464082f, -0.08994913f, 
    0.00880591f, 0.05751138f, -0.44551906f, -0.50458109f, 0.04362907f, -0.12500393f, 0.13977885f, -0.02733727f, 
    0.18169601f, 0.11701170f, -0.04167116f, 0.18042083f, -0.44166163f, 0.04588344f, 0.15594058f, 0.03888362f, 
    -0.00590096f, -0.43374488f, 0.18369949f, -0.04783094f, 0.04237155f, 0.06692403f, 0.07118675f, 0.07755366f, 
    0.11339920f, 0.25104278f, 0.02825103f, 0.03583044f, -0.77020991f, 0.02496875f, -0.25936761f, 0.10284474f, 
    -0.36987364f, 0.22385679f, -0.34379786f, -0.40151986f, 0.08258125f, -0.42333591f, -0.02098609f, -0.50297350f, 
    -0.18012100f, 0.02419137f, -0.22380255f, 0.07993612f, 0.30376557f, 0.09904023f, -0.62119877f, 0.16177078f, 
    -0.02237790f, -0.10759567f, -0.29365057f, -0.56738335f, 0.07164992f, -0.21298625f, -0.03763764f, 0.00020201f, 
    0.37777752f, -0.60060328f, 0.36473066f, 0.16704951f, 0.07974984f, -0.02925320f, -0.06321873f, -0.20391504f, 
    -0.87527168f, 0.22772558f, 0.19378763f, 0.00137053f, 0.14490773f, -0.42342487f, -0.13569096f, -0.18702641f, 
    -0.15995261f, -0.21088393f, 0.33148184f, 0.33667040f, 0.05079353f, -0.04719992f, -0.33221057f, -0.20568392f, 
    -0.27396521f, 0.19796035f, -0.84382117f, 0.03570870f, 0.11879225f, -0.00283456f, -0.79945636f, 0.09413014f, 
    0.19438864f, 0.14475785f, 0.03776049f, 0.04499874f, -0.51302010f, -0.01994486f, 0.24220137f, -0.57700235f, 
    -0.44357732f, -0.84190428f, -0.14157134f, 0.14691363f, -0.18333156f, 0.19321962f, 0.03066522f, -0.36028361f, 
    -0.32370180f, 0.09313191f, 0.31663296f, -0.09017324f, -0.05544112f, 0.06303853f, -0.40417287f, -0.28363147f, 
    0.02112463f, -0.11028919f, -0.53747368f, 0.10763957f, 0.19600111f, -0.34051403f, -0.00739883f, 0.10934779f, 
    0.14336854f, 0.22730733f, -0.14866148f, -0.04074956f, 0.12323024f, -0.45999390f, 0.52510226f, 0.02787053f, 
    -0.06692472f, 0.06074300f, -0.15324076f, 0.56816190f, -0.06359794f, -0.29776889f, 0.04704490f, -0.05067923f, 
    -0.07733635f, -0.18321213f, -0.11479890f, -0.01740099f, -0.03016100f, -0.14606565f, -0.35042477f, -0.57877845f, 
    0.25753298f, -0.11785299f, 0.29048994f, -0.02068909f, -0.05965569f, 0.37789387f, -0.65775454f, -0.13557510f, 
    0.01387577f, 0.31151468f, -0.08678471f, 0.05804317f, -0.00596592f, -0.12280125f, -0.76809561f, -1.13428283f, 
    0.00749542f, -0.14072596f, -0.32282221f, 0.23931938f, -0.16390526f, -0.09949908f, 0.07880019f, 0.19076490f, 
    -0.37524757f, -0.13831420f, 0.03957760f, -0.12194087f, -0.06314648f, -0.53078312f, 0.15478861f, 0.01762682f, 
    -0.09400235f, -0.01013731f, 0.13550629f, -0.55107486f, -0.04139410f, -0.25080758f, 0.01354866f, 0.38696936f, 
    -0.27659053f, 0.08710434f, -0.13455693f, 0.02704944f, -0.04048157f, 0.01653433f, 0.00739182f, 0.00345978f, 
    -0.11624569f, 0.14123991f, -0.09195369f, -0.04357230f, -0.33842686f, -0.80387509f, -0.17631525f, -0.08998911f, 
    0.07405327f, 0.02964045f, -0.22664621f, -0.07190071f, 0.20297907f, 0.09387796f, 0.24347532f, 0.16416542f, 
    -0.01625799f, 0.13124025f, 0.06236115f, -0.02424631f, 0.29176384f, 0.25264031f, 0.07689597f, 0.38718683f, 
    0.05908318f, -0.23691092f, 0.10449441f, -0.36611354f, 0.18522398f, -0.02907147f, 0.02287340f, -0.01007884f, 
    -0.25152519f, 0.14953947f, -0.11759590f, 0.21890000f, 0.33997241f, -0.10279070f, -0.26918283f, 0.06129723f, 
    -0.12416192f, -0.11951879f, 0.12096579f, 0.03711741f, 0.16889195f, -0.18306240f, -0.45578384f, -0.22818783f, 
    0.04904925f, -0.19583447f, -0.13985458f, 0.26010692f, 0.03263732f, -0.09754022f, -0.12966909f, -0.47379717f, 
    0.12219229f, 0.48308069f, 0.19401844f, 0.08344802f, -0.31208622f, -0.00045055f, -0.58535266f, 0.25714901f, 
    -0.16855314f, 0.18764167f, 0.34481290f, 0.17624716f, 0.39159796f, 0.20077175f, -0.03076142f, -0.32268190f, 
    -0.09311723f, -0.22163470f, -0.05014310f, 0.00345640f, -0.06184570f, -0.34445956f, -0.05749214f, -0.19300197f, 
    -0.44944316f, -0.46370134f, -0.25048628f, -0.13062106f, 0.12440848f, 0.03728300f, -0.08181548f, 0.00337754f, 
    -0.72210526f, 0.03124092f, 0.28135768f, 0.27525777f, 0.31676131f, 0.08800241f, 0.02953427f, -0.05463970f, 
    0.06413500f, 0.12088560f, 0.40493914f, -0.43937773f, -0.34881243f, -0.08720810f, 0.00145429f, 0.25679034f, 
    -0.77916932f, -0.04810222f, -0.24720104f, 0.00977871f, -0.14143996f, 0.06822084f, 0.06751296f, 0.00722946f, 
    -0.09134380f, -0.08679165f, -0.62619102f, -0.41609281f, 0.37126523f, -0.10605016f, 0.00096811f, -0.09360567f, 
    -0.18063642f, 0.00841270f, -0.08451510f, -0.22208302f, -0.38706008f, -0.43331119f, -0.23786563f, 0.12114584f, 
    -0.24552768f, -0.12156293f, 0.04032512f, -0.21195827f, -0.49832672f, -0.39847836f, -0.89454705f, -0.08177687f, 
    0.10412318f, -0.70546538f, 0.38207743f, 0.00103007f, -0.00582303f, 0.23374744f, 0.12668017f, 0.13697553f, 
    0.12614612f, -0.29430476f, 0.31686264f, 0.33528748f, 0.21998480f, 0.04021588f, 0.09691434f, -0.28847462f, 
    -0.34063405f, -0.08466952f, -0.42831039f, -0.09924758f, -0.18816723f, 0.10248624f, -0.27795282f, 0.20671059f, 
    -0.32376072f, -0.40229362f, 0.04644905f, -0.30822784f, 0.19517088f, -0.37709889f, 0.05883209f, -0.27695179f, 
    0.35875764f, 0.15901992f, -0.26292452f, 0.02403758f, 0.20843837f, -0.00708920f, -0.25864139f, -0.08833461f, 
    0.03983785f, -0.20198573f, -0.40940991f, 0.12562181f, -0.07323310f, 0.10017572f, 0.02611034f, -0.24724720f, 
    0.05313761f, -0.25269735f, -0.27275604f, 0.06372013f, -0.02300030f, 0.03944943f, -0.25204796f, -0.33009222f, 
    0.21011560f, -0.06639291f, 0.27832690f, -0.16684993f, -0.41100287f, -0.41491011f, 0.29989314f, 0.18725172f, 
    0.31352311f, 0.00907869f, -0.41747442f, 0.25876054f, 0.18887320f, 0.40417960f, 0.25979367f, 0.20412356f, 
    0.02112597f, -0.20698243f, 0.05678036f, 0.12125295f, 0.18163739f, -0.18700501f, -0.23801045f, -0.22994383f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03882859f, 0.05555520f, 0.10260770f, 0.07114112f, -0.06797487f, -0.03843930f, -0.07521454f, -0.15117404f, 
    -0.04609516f, 0.20139703f, 0.01187392f, -0.04555473f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
