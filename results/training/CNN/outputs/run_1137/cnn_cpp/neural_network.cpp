#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.36387658f, 0.70424205f, 0.32937050f, -0.45007914f, -0.37081760f, -0.41836303f, 0.12961191f, -0.00141008f, 
    -0.05885436f, -0.31857905f, -0.13830552f, 0.26347667f, 0.04798380f, -0.25960997f, -0.12263630f, -0.22592576f, 
    -0.02969825f, -0.10594918f, 0.13854976f, -0.28756380f, -0.17163922f, 0.25033942f, 0.10368185f, -0.28014019f, 
    -0.63936245f, -1.05988848f, -0.11390309f, -0.39595082f, -0.72021937f, -0.60565799f, 0.71133357f, 0.28957534f, 
    -0.19044617f, -0.05417629f, 0.34508178f, -0.62390900f, -0.62263352f, -0.19901939f, 0.08857221f, 0.43790933f, 
    -0.28494549f, 0.18885060f, -0.22359332f, -0.35349932f, -0.31182450f, -0.01236369f, -0.31948483f, -0.24172188f, 
    -0.28651559f, -0.36038476f, -0.62712860f, -0.20207524f, -0.27033970f, 0.11206913f, -0.00914516f, 0.52671874f, 
    -0.02657867f, 0.33563718f, 0.55816031f, 0.35492498f, -0.26909864f, -0.27701133f, -0.00163916f, -0.13435744f, 
    -0.25182921f, -0.15801081f, 0.21155699f, 0.01983114f, -0.01829126f, -0.42825282f, 0.16740096f, 0.46186328f, 
    0.21911968f, -0.03682070f, -0.02470278f, -0.33465424f, 0.35241115f, 0.03289180f, -0.42266423f, -0.61036372f, 
    0.52776963f, -0.18302740f, -0.08610550f, 0.63852930f, -0.19551206f, -0.05784163f, 0.09037491f, 0.06635901f, 
    0.49628437f, -0.50818533f, -0.34747937f, 0.19478776f, -0.01916420f, -0.20999910f, -0.26086700f, 0.19612551f, 
    0.46693966f, 0.25221694f, -0.19212264f, 0.19056280f, 0.33821335f, -0.17614940f, -0.25763497f, -0.06938382f, 
    -0.95244384f, -1.35703969f, -0.76784319f, -0.32249123f, -0.83393621f, -0.80104679f, 0.26311034f, -0.17308651f, 
    -0.15399009f, 0.70611119f, -0.56381899f, 0.08459198f, -0.26345083f, 0.05040286f, -0.07860953f, -0.44128641f, 
    -0.26840511f, -0.33760074f, -0.26356581f, -0.23401769f, -0.18132183f, -0.76565844f, -0.67988735f, 0.49526438f, 
    0.29797301f, 0.30309623f, 0.43529737f, 0.10894521f, -0.42424387f, 0.03525602f, -0.03342923f, 0.11010110f, 
    0.20806673f, -0.15099536f, 0.18765035f, -0.33352160f, -0.25072509f, -0.19801332f, -0.15172255f, 0.20267795f, 
    0.38552770f, 0.04758456f, 0.05755676f, -0.20248733f, 0.12483849f, -0.22530995f, 0.64719796f, -1.22429132f, 
    0.77634805f, 0.24136573f, 0.37281865f, -0.78017467f, -0.68666703f, -0.39039600f, -0.17966017f, -0.39806855f, 
    -0.30282399f, 0.29276037f, -0.50166631f, -0.49483082f, -0.05495124f, -0.18810391f, 0.10668864f, -0.43843013f, 
    -0.06778776f, -0.36606121f, -0.18025124f, -0.21168682f, -0.21712972f, -0.47079167f, 0.31015778f, 1.35696387f, 
    -0.18339372f, -0.20130725f, -0.15671250f, -0.84808195f, 0.35279319f, 0.05522329f, 0.14992189f, 0.01540178f, 
    -0.31787983f, 0.37808588f, -0.23479636f, -0.31691301f, -0.23075078f, 0.18281889f, 0.34046072f, 0.28634036f, 
    -0.01493081f, -0.11670510f, -0.30398816f, -0.09504549f, -0.15144756f, -0.24180834f, -0.10880429f, -0.00979563f, 
    -0.52936822f, 0.12666389f, -0.26045090f, 0.03747934f, 0.50736517f, -0.01764321f, 0.43536273f, 0.31902322f, 
    0.14247423f, -0.34223363f, -0.26678488f, 0.83240384f, -0.12373300f, -0.43558508f, -0.11511888f, -0.17173365f, 
    0.26437026f, 0.05572945f, -0.10165900f, -0.42456532f, 0.19182137f, -0.02985066f, -0.04911377f, 0.02588771f, 
    0.41783971f, -0.53206676f, -0.09313188f, 0.33507764f, 0.22045918f, 0.12156367f, -0.65727508f, -0.11061811f, 
    0.20116211f, 0.07755005f, 0.41479987f, -0.17610058f, 0.03476857f, -0.20704147f, 0.51417351f, -0.07888737f, 
    -0.33309805f, -0.00177311f, 0.34464657f, -0.31060237f, -0.43164018f, -0.14637597f, 0.39464355f, 0.15823166f, 
    -0.07704457f, 0.24777137f, -0.90908891f, -0.49243805f, -0.82002836f, -0.51254296f, -0.50875700f, 0.14879557f, 
    0.08289202f, -0.13633160f, -0.53057873f, -0.48849058f, 0.26558483f, -0.24928117f, -0.60695428f, -0.65655470f, 
    0.24656795f, -0.18872002f, 0.00757357f, -0.71114910f, -0.56643414f, -0.70711941f, 0.33791140f, -0.20440359f, 
    0.50256932f, -0.04755370f, 0.09744196f, -0.77109098f, -0.73724663f, -0.00466574f, 0.13470709f, 0.03720363f, 
    0.67236835f, -0.20052877f, -0.22854535f, 0.14585999f, 0.26747537f, 0.27869013f, 0.03067021f, -0.15240504f, 
    0.34130451f, -0.18091775f, -0.47653881f, -0.10976706f, -0.26162693f, 0.14548182f, -0.28129449f, -0.04659093f, 
    -0.20029807f, -0.08005168f, 0.40427840f, -0.24926767f, -0.64612424f, -0.71874875f, -0.21353132f, 0.33376300f, 
    -0.00938114f, 0.78022599f, 0.68916136f, 0.11195641f, -0.32877076f, -0.23893930f, 0.13356031f, -0.18423347f, 
    0.08822785f, 0.22252017f, -0.36354065f, 0.29103518f, 0.06198087f, -0.06196228f, -0.39884481f, -0.22970811f, 
    -0.08002631f, 0.19043231f, 0.09524808f, 0.27552691f, 0.08204599f, -0.68415028f, 0.14703204f, -0.97678536f, 
    -0.64246714f, 0.12143899f, -0.61161679f, -0.67016238f, -0.25552693f, -0.73911244f, -1.10737026f, 0.01564237f, 
    0.02631806f, 0.02994060f, 0.42354754f, -0.21596570f, 0.20883365f, -0.00666790f, 0.10957975f, -0.04869351f, 
    0.00285371f, 0.10567358f, 0.29686537f, 0.00090530f, 0.26007828f, 0.38878438f, -1.09750426f, -0.74875277f, 
    -0.56838578f, -0.25842404f, -0.73556930f, 0.72265470f, 0.09113758f, -0.14353651f, 0.26588988f, 0.68725848f, 
    -0.05840725f, 0.12596002f, -0.14199579f, 0.09165152f, -0.38498244f, 0.07255504f, -0.14621185f, -0.11144394f, 
    -0.09259111f, -0.07438692f, -0.42756706f, -0.33095413f, -0.29489133f, -0.36383027f, -0.39162880f, 0.21479174f, 
    0.65633047f, 0.62382430f, -0.32909638f, -0.65210867f, -0.42598048f, -0.55173266f, 0.20143403f, 0.38777328f, 
    0.07037429f, -0.51397073f, 0.01697513f, 0.07612662f, -0.01865535f, 0.23590676f, 0.07377941f, 0.42082369f, 
    -0.38483188f, -0.36568612f, 0.30953500f, 0.07276187f, -0.06172897f, -0.36245972f, -0.22021008f, 0.31266370f, 
    -1.06816947f, -0.69272244f, -0.20107578f, -0.10569795f, 0.34976164f, 0.16393678f, 0.07936532f, -0.12320330f, 
    -0.04256592f, 1.07270896f, -0.12034207f, -0.05125191f, 0.00323915f, 0.08216421f, -0.11835787f, 0.30405128f, 
    0.25377622f, 0.00576974f, 0.12036275f, -0.14631237f, 0.15299535f, -0.02216781f, -0.04444756f, -0.33527279f, 
    0.07313423f, 0.62945080f, -0.85135138f, -0.02520346f, 0.37372217f, 0.53207827f, -0.03219250f, 0.56553370f, 
    0.25579688f, -0.44133234f, -0.30752638f, -0.32785282f, -0.09888612f, 0.53552580f, -0.39915660f, 0.09335744f, 
    -0.13069923f, -0.25164950f, 0.06736843f, 0.05653590f, -0.32153991f, 0.25530434f, -0.26415157f, -0.05426364f, 
    0.07364845f, -0.08967283f, 0.90837830f, -0.77560997f, 0.04074210f, -0.03340935f, 0.49801144f, -0.55982667f, 
    0.07961489f, 0.00053214f, -0.12859225f, -0.05441825f, -0.27221751f, 0.50932294f, 0.07712429f, 0.03027447f, 
    -0.30849883f, -0.09240786f, -0.20486039f, 0.13636641f, -0.12107486f, 0.13316813f, -0.07322239f, 0.40867713f, 
    0.11004891f, 0.03642521f, 0.05779535f, -0.88567275f, -0.06403299f, -0.02687931f, 0.91708237f, -0.06333885f, 
    -0.61394745f, -1.03557122f, -0.01102663f, 1.22073817f, 0.34976482f, -0.21770878f, -0.14956738f, 0.01873508f, 
    0.03286869f, -0.30946830f, 0.11220398f, -0.12750404f, 0.36151069f, -0.46333501f, 0.27401161f, -0.19360295f, 
    -0.27049467f, 0.01844176f, -0.14933801f, 0.24862869f, 0.22705024f, 0.39842221f, 0.10502923f, -0.36796120f, 
    -0.08050916f, -0.61881989f, -0.29186028f, 0.14276387f, 0.47926360f, 0.18108580f, 0.84480453f, -0.70043635f, 
    0.00405828f, -0.10502601f, -0.29628721f, -0.24341479f, -0.05499870f, 0.06732625f, 0.22446440f, -0.11400121f, 
    -0.06893663f, -0.03649921f, 0.19964597f, 0.07247411f, 0.31239438f, -1.15638804f, -0.66327757f, -0.32832772f, 
    -0.80910003f, -0.75286812f, 0.48909682f, 0.21216647f, 0.01626589f, -0.27766421f, -0.12795730f, 0.12421539f, 
    0.34905040f, 0.02887315f, -0.08982217f, -0.08762410f, -0.47622034f, -0.49104369f, -0.03346508f, -0.27067217f, 
    -0.12668155f, -0.31450105f, 0.03877466f, 0.42488295f, -0.30999309f, -0.06358165f, 0.54406947f, 0.29980177f, 
    -0.05101062f, -0.84070343f, -0.94501138f, 0.82657450f, 0.20706320f, -0.13099185f, -0.02724857f, 0.07926668f, 
    0.00334890f, 0.68774748f, -0.37947455f, 0.04835458f, -0.24182642f, 0.00660610f, 0.08730596f, 0.09894805f, 
    -0.00746387f, -0.29307291f, -0.15845025f, 0.29730156f, -0.06544942f, 0.05942873f, 0.12914510f, -0.10923374f, 
    0.33919945f, 0.37222183f, 0.15244605f, 0.49591032f, -0.15480286f, 0.06159200f, 0.28014693f, 0.51205081f, 
    0.25955948f, 0.25345635f, 0.04519554f, 0.00751405f, -0.04494709f, -0.12090107f, 0.05674620f, -0.09717202f, 
    -0.07664692f, -0.17537603f, -0.02423257f, 0.26902759f, 0.02776051f, 0.03315429f, -0.02875417f, -0.06957175f, 
    -0.15602207f, -0.46214288f, -0.38870630f, -0.54077917f, -0.81830758f, -0.62511772f, -0.44988987f, -0.08132286f, 
    0.10674551f, -0.50503117f, -0.14704281f, 0.61475223f, 0.43247652f, 0.18339922f, 0.00142630f, -0.03075571f, 
    -0.36976472f, 0.00255924f, 0.40939590f, 0.05165359f, 0.44046903f, -0.16508694f, -0.24750875f, -0.05217079f, 
    0.21281816f, -0.19117440f, -0.14268488f, 0.01534202f, -0.13003436f, -0.18898763f, -0.98701525f, -0.80457175f, 
    0.04898297f, 0.32273793f, 0.17853855f, 0.33792046f, 0.39037979f, 0.61421949f, 0.27536431f, -0.24296269f, 
    0.14822055f, -0.23477645f, -0.07352319f, -0.39926285f, -0.88504064f, 0.15733045f, -0.02082616f, 0.15669920f, 
    0.25534335f, 0.02332550f, -0.38216195f, -0.99835777f, -0.70786512f, 0.23731339f, 0.33128479f, -0.38784301f, 
    -0.52142060f, 0.33720490f, 0.09874538f, -0.09512907f, 0.30426314f, 0.37345573f, -0.07082790f, 0.42501092f, 
    -0.08004484f, 0.01251389f, -0.10124382f, 0.04887965f, 0.16069663f, 0.15091261f, -0.48285517f, -0.24787056f, 
    0.25928545f, -0.28017548f, -0.37769595f, 0.38686523f, 0.13244340f, 0.07304353f, 0.05514072f, 0.42879233f, 
    0.28254527f, 0.46634963f, 0.52677268f, -0.12713911f, 0.13155140f, 0.19930620f, 0.25810146f, 0.10565768f, 
    -0.42986038f, -0.23938167f, 0.20803152f, 0.05732386f, -0.41583934f, -0.32377660f, -0.27306485f, 0.03836447f, 
    -0.12531132f, -0.11179192f, 0.07497282f, -0.00330662f, 0.42928696f, -0.19822054f, 0.21459870f, 0.57213908f, 
    -0.52609909f, -0.46953601f, -0.55276823f, -0.23468745f, 0.30504417f, -0.58193654f, 0.33203077f, -0.20835485f, 
    0.01989978f, -0.36842722f, 0.58008307f, 0.14049123f, 0.21258757f, 0.20372963f, -0.27285138f, -0.06793049f, 
    0.07370282f, 0.10049814f, -0.10262531f, 0.33377308f, 0.20895700f, -0.71236140f, -0.53974003f, 0.31909570f, 
    1.03000510f, 0.69331539f, 0.63782942f, -0.21570253f, -0.55160505f, -0.81839079f, -0.38629422f, -0.35100582f, 
    -0.36188710f, -0.02794752f, -0.13776650f, -0.09429507f, 0.02419111f, -0.32226023f, 0.18995742f, 0.21736474f, 
    -0.02989276f, 0.22777292f, -0.29043850f, 0.02677488f, 0.25118285f, -0.09684533f, -1.34929347f, 0.49990761f, 
    -0.11652441f, -0.54722601f, -0.08963591f, 0.24629396f, 0.11233279f, -0.00631781f, 0.46560392f, 0.97155619f, 
    -0.10643171f, 0.37030262f, -0.35048148f, -0.19673257f, 0.11320888f, -0.03947816f, 0.15747371f, -0.32650793f, 
    -0.14687943f, -0.18846852f, 0.02525485f, 0.05614793f, 0.30719382f, 0.08495223f, -0.18074828f, -0.53818452f, 
    -0.36317340f, 0.15312321f, 0.18003516f, 0.40854496f, 0.02316787f, 0.23606011f, 0.03018947f, -0.06749219f, 
    0.05825371f, -0.52084589f, -0.31977859f, -0.28690210f, -0.41212228f, 0.46777147f, -0.16974817f, -0.31518286f, 
    -0.34004280f, -0.22092992f, -0.38911912f, -0.35143179f, -0.36882028f, -0.26566824f, -0.68707830f, -0.73776942f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.32433727f, -0.09654943f, -0.33167905f, 0.07900931f, -0.03184363f, 0.28118491f, 0.02002687f, 0.20371586f, 
    -0.09709140f, 0.42780897f, -0.26351011f, 0.19559085f, 0.40601286f, -0.15721957f, -0.11167091f, 0.41721743f, 
    0.40955076f, 0.57228124f, 0.13191377f, 0.42902818f, 0.15462990f, -0.21722439f, 0.50740981f, -0.17872776f, 
    0.05374142f, 0.33886093f, -0.00121205f, -0.04799736f, 0.07146615f, -0.04484897f, 0.30705753f, -0.11416592f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.44033906f, -0.65357953f, -0.42360693f, 0.23504230f, 0.03586560f, 0.00927947f, 0.08464374f, 0.00179120f, 
    -0.05473023f, -0.03511085f, 0.02646460f, 0.10158764f, 0.19116381f, 0.17700091f, 0.00269865f, -0.09622306f, 
    -0.04164564f, 0.14638735f, -0.28357455f, -0.11863107f, -0.17928405f, -0.04058868f, -0.06590567f, 0.10038671f, 
    0.04588056f, 0.03283292f, 0.11624919f, -0.10419947f, 0.01311274f, 0.07241827f, 0.05895925f, 0.03117112f, 
    0.05888554f, 0.22360757f, -0.04883213f, -0.15801783f, 0.03905589f, -0.07882454f, -0.00958992f, -0.02610080f, 
    -0.11450449f, 0.05078885f, -0.31071225f, -0.04707285f, -0.03054940f, -0.04587433f, -0.01469517f, -0.14885566f, 
    0.30653042f, 0.24234635f, 0.05475575f, -0.29622540f, 0.13794826f, -0.08338089f, 0.07685013f, 0.21718934f, 
    -0.01156109f, 0.02237932f, -0.03695129f, -0.00392534f, 0.40322253f, 0.15138546f, -0.01548072f, -0.09792493f, 
    -0.04207425f, -0.01196319f, 0.00842376f, -0.00051656f, -0.06806593f, -0.16294773f, -0.10896648f, -0.16560222f, 
    0.16884108f, 0.09429535f, 0.15300606f, -0.28213069f, -0.33464628f, -0.24480166f, -0.01906276f, -0.17196232f, 
    -0.01338852f, -0.05804069f, 0.03900762f, -0.03399236f, -0.25310719f, -0.45813540f, -0.19330043f, 0.12521116f, 
    -0.01763577f, 0.09729192f, -0.15538463f, 0.01769550f, -0.18157721f, 0.16821122f, 0.07121032f, -0.03569024f, 
    -0.08861391f, 0.04236696f, -0.19198339f, -0.06757897f, -0.05459018f, -0.04769550f, 0.11435691f, 0.04550898f, 
    -0.09132884f, -0.18024109f, 0.21544072f, -0.39682990f, -0.40638009f, 0.10195340f, 0.29494110f, -0.25897294f, 
    -0.06686181f, -0.08823545f, 0.02100168f, -0.10392353f, -0.10304877f, -0.10358232f, -0.12797242f, -0.15178017f, 
    0.36237600f, 0.22876970f, -0.09304390f, -0.14081882f, 0.15582369f, 0.29063872f, -0.03809651f, -0.14050506f, 
    -0.10116701f, -0.11496148f, -0.14788517f, -0.09403905f, 0.28215367f, 0.09036218f, 0.12777157f, -0.10268002f, 
    0.03316284f, 0.08018688f, -0.00660677f, -0.01613856f, 0.12254319f, -0.09132982f, 0.00375996f, -0.01291324f, 
    0.13192341f, -0.23399992f, -0.39672688f, -0.08182669f, -0.03370099f, -0.00961768f, -0.02315955f, -0.08141747f, 
    -0.01847334f, -0.14384353f, -0.20138825f, -0.02488900f, 0.41369373f, 0.30901062f, -0.30411330f, -0.18035561f, 
    0.02722161f, 0.08604010f, 0.02897522f, 0.03089933f, 0.01896189f, -0.05701235f, 0.01981601f, 0.04101880f, 
    0.25094563f, 0.08054598f, -0.00617714f, -0.13598900f, 0.19814794f, 0.14738007f, 0.07551292f, -0.11456959f, 
    0.06031775f, 0.14091076f, 0.08478902f, 0.09143086f, -0.69162422f, -0.42248622f, 0.18331163f, 0.03160970f, 
    -0.04609192f, 0.07005236f, -0.22714067f, -0.00195029f, -0.05643152f, -0.13244088f, -0.13294914f, -0.14523625f, 
    0.34785107f, 0.24355043f, 0.10552871f, -0.12511930f, 0.04665155f, 0.16029453f, 0.14817846f, -0.06027185f, 
    -0.07194928f, 0.02780500f, -0.00141629f, -0.03027439f, -0.43546605f, -0.57794309f, -0.24155016f, 0.03916512f, 
    -0.01426794f, -0.03564046f, 0.03628872f, -0.08695017f, 0.06373584f, -0.02429872f, -0.03265842f, -0.00645629f, 
    -0.22712488f, 0.18252501f, 0.02820859f, 0.00575919f, -0.22903523f, 0.04226623f, -0.11614368f, -0.05527476f, 
    -0.01308037f, -0.03264601f, -0.00942135f, -0.10604909f, -0.14090075f, 0.39645246f, 0.36127466f, -0.53787172f, 
    -0.10081211f, -0.08441427f, -0.01367444f, -0.11301498f, -0.10785174f, -0.11641674f, -0.05322732f, -0.06579620f, 
    -0.27515262f, -0.33144993f, 0.20551649f, -0.28868258f, -0.16395777f, 0.07802036f, -0.05470772f, 0.05209273f, 
    -0.03391494f, -0.06104723f, -0.03315675f, -0.11257518f, 0.32314622f, 0.18873645f, -0.02954549f, -0.12865339f, 
    0.16748136f, 0.20265377f, 0.02019593f, 0.01327329f, -0.16283996f, -0.30520821f, -0.08301322f, 0.15147549f, 
    0.15986487f, -0.76187176f, -0.67586571f, 0.02790503f, -0.03209327f, 0.06027778f, -0.20510994f, -0.19118668f, 
    -0.10191831f, -0.14773755f, -0.15335129f, -0.10693925f, -0.14040272f, -0.12732154f, 0.09937783f, 0.03826034f, 
    0.10593890f, 0.04143628f, 0.06296027f, 0.09356944f, -0.04865910f, 0.06130408f, -0.01303818f, -0.04116914f, 
    0.38330922f, 0.17277142f, -0.01190477f, -0.16933766f, 0.14467788f, 0.00648564f, -0.06765299f, -0.23406209f, 
    0.02398978f, 0.01827070f, 0.08223176f, 0.01149011f, 0.11215960f, 0.12290615f, 0.21027943f, -0.27233598f, 
    -0.10515641f, 0.07821706f, 0.08215499f, -0.04087961f, -0.06633598f, -0.11949676f, -0.18346176f, 0.00302418f, 
    0.44779748f, 0.29388085f, 0.10311690f, -0.13556784f, 0.09977245f, 0.00042185f, 0.06426626f, -0.05882007f, 
    -0.03069405f, -0.00195909f, -0.04547218f, 0.15939128f, -0.28753075f, -0.05680261f, -0.65180278f, 0.06275799f, 
    0.01087391f, 0.02352294f, 0.12591952f, 0.02919519f, -0.09024218f, -0.02687818f, -0.12763186f, -0.06958473f, 
    0.11854476f, 0.03157084f, 0.07875840f, -0.18864703f, -0.18963389f, 0.22653109f, 0.04475693f, -0.12637916f, 
    0.12742893f, -0.01658260f, -0.01681333f, -0.03379484f, 0.60536736f, 0.37589219f, -0.17452899f, -0.23355436f, 
    0.05654247f, -0.25663006f, 0.03384555f, -0.00395034f, -0.03792748f, -0.06528741f, 0.00498079f, 0.04909122f, 
    -0.26006448f, -0.34903103f, 0.12546253f, -0.13467805f, -0.07429204f, 0.12526903f, 0.05438521f, 0.12248994f, 
    -0.24173096f, 0.12471431f, -0.12698302f, -0.07607382f, -0.04819781f, 0.07118321f, 0.03793871f, 0.01868817f, 
    0.02661426f, 0.01953966f, 0.04830896f, -0.00529777f, 0.01720253f, -0.02020203f, 0.14873907f, 0.14738323f, 
    0.34849048f, -0.12823936f, 0.29451457f, -0.15653172f, -0.01287272f, -0.07385699f, -0.07729740f, 0.05475114f, 
    0.00653494f, 0.04712372f, -0.13339186f, -0.07215279f, 0.15632105f, -0.01448280f, 0.33234057f, -0.07963775f, 
    0.23985037f, 0.17337205f, -0.10769016f, -0.09517025f, -0.00222632f, 0.01894066f, 0.05346529f, -0.58584207f, 
    -0.18924522f, 0.15774591f, 0.08787407f, -0.08831014f, -0.09608914f, 0.08452290f, -0.04514593f, -0.01352747f, 
    -0.16370954f, -0.04166799f, -0.16206020f, 0.02856933f, -0.14856970f, 0.04609229f, 0.04518481f, -0.06641912f, 
    0.05877165f, -0.01384241f, 0.06023732f, 0.09594783f, -0.22310969f, -0.06945997f, 0.10111541f, -0.02089584f, 
    0.05175421f, -0.12049986f, 0.04244448f, -0.25164679f, -0.01243774f, -0.18960898f, -0.04674010f, -0.00055833f, 
    0.02402170f, -0.07339029f, -0.04292663f, 0.09374381f, 0.26169100f, 0.05408781f, -0.12506951f, 0.03721950f, 
    -0.08802573f, -0.01710644f, 0.13510534f, 0.07885274f, 0.01342914f, 0.14526644f, 0.17901839f, 0.14212768f, 
    -0.28015193f, 0.31778440f, -0.73691654f, -0.77139038f, -0.00176148f, 0.07355331f, -0.18294951f, -0.04302929f, 
    0.00536284f, 0.01784429f, -0.13887182f, 0.04795879f, 0.50058025f, -0.18820697f, 0.17509083f, -0.11042953f, 
    0.09185140f, -0.09683900f, 0.03015280f, -0.13648371f, 0.13027082f, 0.02674388f, -0.37979585f, 0.05202065f, 
    -0.14806503f, -0.06544431f, -0.03227578f, 0.16459487f, -0.05794523f, 0.03755748f, -0.00403693f, 0.00973263f, 
    0.14517097f, 0.11376197f, -0.18978448f, -0.03593813f, -0.31716001f, -0.09799577f, 0.03826603f, -0.03188277f, 
    -0.12064873f, 0.05731323f, 0.01429105f, 0.14864250f, -0.12260029f, 0.03646446f, -0.05912335f, 0.00666414f, 
    0.10142689f, 0.13842896f, 0.50082785f, -0.11660980f, 0.20558152f, 0.05141776f, 0.08627541f, 0.41993332f, 
    0.03627694f, 0.05721816f, -0.07455728f, -0.07472075f, 0.26323926f, -0.20175077f, -0.47668681f, -0.46221742f, 
    -0.11953747f, -0.07624653f, 0.06802475f, -0.00539925f, -0.04841520f, -0.28806505f, -0.01508970f, -0.00729961f, 
    0.17548478f, -0.21616557f, 0.20689985f, 0.01125507f, -0.11781264f, -0.05318937f, 0.12851584f, 0.15842554f, 
    0.03182103f, -0.10498799f, 0.19370316f, 0.05556877f, 0.09454253f, 0.12491637f, 0.40244511f, 0.26055044f, 
    -0.07989585f, 0.02028354f, 0.28312251f, -0.22722924f, -0.10924052f, 0.03734262f, 0.03748959f, 0.00775044f, 
    0.21452655f, 0.21441796f, -0.23653643f, 0.07027595f, -0.05704261f, 0.08707350f, -0.01253809f, -0.15852650f, 
    -0.01019212f, -0.21709323f, -0.05909937f, -0.39824915f, 0.06948000f, 0.06846797f, 0.30237368f, -0.22433753f, 
    0.07994107f, 0.01301198f, -0.00805492f, 0.03102173f, 0.13913393f, 0.03063566f, -0.04870787f, -0.05237789f, 
    -0.02879238f, 0.07374249f, -0.15820441f, 0.03516318f, 0.11488208f, 0.13318682f, 0.00229274f, -0.05397046f, 
    -0.03001737f, -0.16846566f, -0.03433746f, 0.02136230f, 0.64810091f, 0.14096037f, 0.39979443f, 0.47497585f, 
    -0.11346294f, 0.06966005f, -0.00944089f, -0.07000881f, 0.05098329f, -0.03989558f, 0.01313644f, 0.12654200f, 
    0.26703283f, 0.14581710f, -0.03766329f, -0.12167805f, -0.06169014f, -0.09424651f, -0.11399933f, -0.00437595f, 
    -0.11501634f, 0.01779331f, -0.05141692f, 0.09647046f, -1.24365568f, 0.37047899f, -0.00366918f, -0.25766933f, 
    0.29317206f, 0.07656062f, -0.11459301f, -0.15242732f, 0.07224485f, 0.02611803f, -0.03718542f, 0.02727816f, 
    -0.14368393f, 0.16372800f, 0.23677222f, -0.14672334f, 0.10091846f, 0.10208603f, 0.02632450f, -0.00885909f, 
    0.02421353f, -0.08718789f, -0.04328601f, -0.04402079f, -0.08184751f, 0.13995291f, 0.04928450f, -0.12183079f, 
    0.00350051f, 0.39883167f, 0.07379720f, 0.14759196f, 0.11154659f, 0.13307191f, -0.15616240f, 0.06765763f, 
    0.40723139f, -0.14422771f, -0.06016188f, -0.23198251f, 0.03210146f, -0.04675448f, 0.17293605f, 0.10121175f, 
    -0.08980391f, 0.21655014f, -0.21622242f, 0.08667720f, 0.05374981f, 0.10282947f, 0.15632446f, 0.20938709f, 
    -0.05688702f, -0.06379226f, 0.01123453f, -0.03713424f, 0.01897291f, 0.02842150f, 0.01605771f, 0.08940004f, 
    -0.12135957f, -0.04272719f, -0.00522103f, -0.02470757f, -0.17687242f, 0.29567215f, -0.29840511f, -0.11527967f, 
    -0.03505420f, -0.08343201f, 0.03373823f, 0.02939166f, -0.98476934f, -0.34779599f, -0.22446249f, -0.16252862f, 
    0.05301918f, 0.15910289f, -0.02633297f, 0.00662036f, 0.09211855f, -0.00658545f, -0.00449663f, 0.08688234f, 
    -0.24663536f, 0.08889940f, -0.20596048f, -0.02738241f, -0.16752279f, 0.21887426f, 0.26119453f, -0.11724568f, 
    0.15122493f, -0.13580993f, -0.03693356f, 0.05452278f, 0.45517892f, 0.07442544f, 0.25493363f, 0.08931943f, 
    -0.07971709f, -0.00114217f, 0.01405957f, -0.05102524f, 0.13317327f, 0.08398819f, -0.01542439f, 0.18205756f, 
    -0.14185549f, 0.19931026f, -0.09618898f, -0.04704795f, 0.00912962f, -0.09522282f, 0.09570865f, -0.09916002f, 
    -0.09641490f, 0.01907091f, -0.01552484f, 0.01263028f, -0.24595119f, -0.33553505f, -0.11253724f, -0.11511135f, 
    -0.13055681f, -0.34570500f, 0.09358459f, 0.03986901f, 0.12058254f, 0.03823234f, 0.06813548f, -0.05411366f, 
    -0.31943208f, 0.30030847f, 0.10355654f, -0.35257238f, 0.04649600f, -0.07044053f, -0.10038937f, 0.04238597f, 
    -0.08370238f, -0.01142550f, 0.05663218f, 0.10543025f, 0.11363897f, -0.03461716f, 0.28263727f, 0.09979293f, 
    -0.04903989f, 0.00895143f, -0.05389643f, 0.04244653f, -0.25178522f, -0.38756403f, -0.21852639f, -0.55822045f, 
    -0.00212866f, 0.09207133f, 0.21462506f, -0.20540299f, -0.02048608f, -0.03136626f, -0.00743069f, -0.05150525f, 
    0.04496877f, -0.06882861f, -0.05141107f, 0.15593524f, 0.16426992f, -0.19641110f, 0.70454001f, 0.69000924f, 
    0.00617502f, 0.04218150f, 0.10433672f, -0.05829316f, -0.16001485f, 0.01187430f, -0.03276137f, -0.09491357f, 
    -0.29187185f, -0.13671029f, 0.00559040f, 0.17931744f, -0.04593084f, -0.00468221f, -0.10161976f, 0.00663594f, 
    0.01547996f, -0.15985736f, -0.04460572f, -0.17928879f, -0.03280268f, -0.04543161f, -0.11487375f, 0.18600655f, 
    0.11020469f, -0.00712954f, -0.24540579f, 0.14615595f, -0.05883607f, -0.38716236f, -0.06898309f, 0.08375039f, 
    -1.05143857f, -0.42954031f, -0.27696690f, -0.34473658f, 0.12979594f, 0.09472203f, -0.17183167f, -0.44054869f, 
    0.04308073f, -0.02808546f, 0.17757283f, 0.01861779f, 0.22411144f, 0.15464054f, -0.19763419f, 0.10439175f, 
    0.08679133f, -0.06059638f, 0.08679026f, 0.11460838f, 0.02162036f, -0.02322182f, 0.03388336f, -0.12706883f, 
    -0.43828017f, 0.28348848f, -0.28357816f, 0.26688471f, -0.17502007f, 0.13472785f, -0.20053981f, -0.05414613f, 
    0.02744186f, -0.00701473f, -0.08057611f, -0.00494454f, -0.32500121f, 0.24771339f, 0.08158578f, -0.22224446f, 
    -0.00663704f, -0.04063167f, -0.07028107f, -0.27025127f, 0.10984393f, 0.23261321f, -0.15340100f, 0.20792675f, 
    -0.01712704f, -0.32143915f, -0.10669517f, -0.10114420f, -0.04677184f, -0.05708494f, 0.05197964f, -0.04940531f, 
    0.08439175f, -0.05652138f, -0.04096131f, 0.13891503f, 0.07458272f, -0.07836822f, -0.25131392f, 0.26574337f, 
    0.20160058f, 0.25443798f, -0.06241611f, 0.05616446f, 0.04596261f, -0.09623045f, 0.11625099f, -0.06581395f, 
    -0.46337807f, -0.08173858f, 0.51742792f, 0.02701229f, -0.00451097f, -0.16281998f, -0.01331092f, -0.19726925f, 
    -0.08452253f, -0.03044367f, -0.08813082f, -0.02163640f, 0.05281162f, 0.07050547f, 0.12247593f, 0.06397448f, 
    0.04622255f, 0.00746866f, 0.05782419f, 0.11916605f, -0.07077152f, -0.30233759f, 0.22293879f, 0.05493018f, 
    -0.01215409f, -0.47131696f, 0.48706809f, 0.03325702f, 0.12934482f, 0.03038574f, 0.03493407f, 0.04863637f, 
    0.09957837f, -0.10486352f, 0.16716933f, 0.02489793f, -0.85525596f, -0.67832476f, -0.30632383f, -0.40853029f, 
    0.07710569f, -0.04251849f, 0.26029843f, -0.09711622f, -0.01161956f, -0.01204515f, -0.01381355f, -0.03256222f, 
    0.13634029f, 0.16693296f, 0.46436191f, 0.42015949f, -0.03765285f, -0.09143414f, 0.05104751f, 0.11199667f, 
    -0.08902752f, -0.08751609f, 0.17097737f, 0.09022782f, -0.01655922f, 0.19453426f, 0.02130335f, -0.15598874f, 
    -0.15353081f, 0.00997036f, -0.01530257f, 0.12719959f, 0.03061614f, 0.06663472f, -0.30290985f, 0.09279943f, 
    0.08347198f, -0.22982082f, 0.13998786f, 0.34104759f, 0.11783770f, 0.06308010f, -0.02843048f, 0.16622284f, 
    0.17958285f, 0.00395348f, 0.01586183f, 0.13395323f, 0.19379580f, 0.06260294f, -0.30008790f, -0.03911487f, 
    0.01766091f, -0.01314153f, 0.06455073f, 0.03457920f, -0.00315205f, 0.01466918f, 0.14008312f, -0.16646142f, 
    -0.02841641f, 0.02434658f, -0.19958702f, 0.01285079f, -0.10510923f, 0.13081515f, 0.01046939f, 0.00481803f, 
    0.00780911f, -0.07812411f, -0.00117860f, -0.04150189f, -0.08816471f, 0.09169703f, -0.54866946f, 0.16386150f, 
    -0.07910746f, 0.03612340f, -0.00194803f, 0.01270455f, 0.00237024f, -0.03246410f, -0.08630095f, -0.00599530f, 
    -0.14504600f, 0.17180581f, -0.11872617f, -0.26221263f, 0.18804130f, 0.03160656f, 0.04784014f, 0.03643948f, 
    0.03087454f, 0.01338673f, -0.02627192f, 0.04431490f, -0.05329136f, 0.47861931f, 0.54300690f, 0.32568869f, 
    -0.07334203f, -0.15456468f, 0.26816809f, 0.02762212f, -0.05210131f, 0.07129483f, -0.01609458f, -0.09845134f, 
    0.03593435f, 0.28981438f, -0.09738959f, -0.10821238f, 0.10762561f, -0.04458756f, -0.15533385f, 0.17167346f, 
    -0.02401602f, -0.11619871f, -0.18963274f, 0.18723711f, -0.27729279f, -0.29257220f, -0.15006524f, 0.05337420f, 
    -0.02893922f, -0.05186399f, 0.05085739f, 0.09414455f, -0.03323279f, -0.02446223f, -0.05992278f, 0.04214144f, 
    -0.28212544f, -0.01018029f, -0.41075370f, 0.25063130f, -0.02109746f, 0.10796079f, 0.11037717f, -0.19772559f, 
    0.00071465f, 0.04681842f, -0.00233437f, -0.09315425f, -0.10648225f, -0.42419669f, -0.48425287f, 0.28279799f, 
    0.04534352f, 0.09409555f, -0.05709213f, -0.21405046f, 0.07341889f, 0.03101123f, -0.17737642f, 0.16187935f, 
    -0.08913363f, 0.08489326f, -0.06081355f, 0.16902113f, -0.12050478f, -0.04062308f, 0.08012688f, 0.04649528f, 
    -0.11940517f, 0.21185361f, 0.01368944f, -0.03540362f, -0.17002736f, -0.73981172f, -0.19731887f, -0.02904138f, 
    -0.01421540f, -0.07187451f, 0.05148055f, 0.03457912f, 0.02278149f, -0.11176804f, -0.06688679f, 0.03494548f, 
    -0.38003662f, -0.00325013f, 0.02971444f, 0.11183061f, -0.07625815f, -0.02735712f, 0.02234214f, -0.27878970f, 
    0.02876237f, 0.02646056f, -0.07177620f, 0.02526479f, -0.42474037f, 0.49421683f, -0.56070197f, -0.19813806f, 
    0.19975299f, -0.01843991f, 0.01813112f, 0.00637215f, -0.05532631f, 0.02766639f, 0.06345301f, -0.11067570f, 
    0.30726221f, -0.00608997f, 0.16177824f, 0.36298287f, 0.11747998f, 0.07212125f, 0.16294816f, -0.06306591f, 
    -0.09700087f, 0.12277281f, -0.28842205f, 0.24530205f, -0.07884490f, -0.22560169f, -0.16804910f, 0.05181356f, 
    -0.01007240f, -0.01821210f, -0.03977621f, 0.05984168f, 0.04940550f, 0.35043919f, -0.00598996f, -0.08723527f, 
    -0.19964111f, -0.05955393f, 0.31452480f, -0.08452746f, -0.39616227f, 0.01726437f, -0.26180804f, 0.08028593f, 
    -0.07509778f, -0.01934596f, -0.10524147f, 0.04719333f, 0.27145913f, -0.04629273f, 0.00219860f, 0.29150882f, 
    0.10308751f, -0.02158017f, -0.06148278f, -0.00884748f, -0.02663913f, -0.06138106f, -0.00148576f, 0.10901872f, 
    0.60046309f, -0.04842218f, 0.30570912f, -0.19200720f, 0.39074022f, 0.33722281f, 0.23123999f, 0.06657200f, 
    -0.22783472f, 0.08197650f, 0.14751565f, 0.08109991f, 0.24935679f, -0.43945447f, 0.22088361f, 0.39049712f, 
    0.16311383f, 0.01862997f, -0.14055637f, -0.02647752f, 0.10047437f, 0.40952155f, -0.15089993f, 0.02865008f, 
    -0.03905319f, -0.29752073f, -0.02779160f, 0.25114149f, -0.08588926f, 0.13664241f, 0.07864624f, 0.09874398f, 
    -0.05523056f, 0.04393041f, 0.19255199f, -0.10795184f, -0.86272049f, 0.70461541f, -0.65088803f, -0.74843377f, 
    -0.01985621f, -0.03149518f, -0.20061332f, 0.17878594f, -0.05134927f, -0.03596509f, 0.05232732f, -0.15033795f, 
    -0.35806191f, 0.20489524f, -0.00869754f, 0.19262373f, -0.06418101f, -0.00091496f, -0.03336650f, 0.06053434f, 
    0.05094070f, 0.06600968f, -0.09730611f, 0.08169858f, -0.85379094f, 0.05509180f, 0.10051747f, 0.23640543f, 
    -0.08448772f, -0.06643747f, 0.10361940f, 0.02560872f, -0.21702068f, 0.11360691f, -0.05431562f, 0.10154477f, 
    0.37959677f, -0.10700630f, -0.16135232f, -0.31972921f, 0.23361233f, -0.12154135f, 0.11426998f, -0.00622958f, 
    -0.37789840f, 0.24128546f, -0.16001780f, 0.05851091f, 0.52698761f, 0.25319082f, -0.11318881f, -0.30012721f, 
    -0.12424717f, -0.21381377f, -0.11893051f, 0.04702467f, 0.09146802f, 0.01324423f, 0.17195049f, -0.06613637f, 
    0.10067754f, -0.15861058f, -0.00545916f, 0.20228836f, 0.06044783f, 0.02155330f, 0.00376081f, -0.05215285f, 
    0.00320530f, 0.12128583f, 0.04713671f, 0.10708766f, -0.45018199f, -0.03149213f, -0.04803593f, -0.15486151f, 
    0.14172962f, 0.06785619f, 0.04671991f, -0.08544318f, -0.12852865f, -0.07135347f, 0.01869764f, -0.07538475f, 
    -0.33724177f, 0.52656972f, -0.14666525f, -0.22946817f, 0.08602567f, 0.12776104f, -0.11540696f, 0.05736657f, 
    -0.21935318f, 0.11726300f, 0.06241288f, 0.00264538f, 0.18721882f, -0.34062931f, -0.02831180f, 0.15838662f, 
    -0.02789758f, 0.08486228f, -0.00305336f, 0.11728764f, 0.11495335f, -0.04849486f, 0.08480164f, -0.11981196f, 
    -0.06612645f, -0.06666827f, 0.02438961f, 0.15930791f, 0.13017955f, 0.15801412f, 0.04850675f, -0.06891047f, 
    -0.05947935f, 0.02474456f, 0.03812623f, 0.03517272f, 0.08131920f, -0.05116324f, 0.44104984f, -0.48835039f, 
    -0.32532090f, -0.00558036f, -0.34589309f, -0.04005612f, -0.05326224f, 0.14971289f, -0.16092919f, 0.06090984f, 
    0.15246278f, -0.07995856f, -0.26422104f, -0.16179880f, 0.19186825f, 0.01913765f, -0.03784797f, -0.25981104f, 
    -0.10442886f, -0.07493319f, -0.12387533f, -0.04484231f, -0.51289737f, 1.27992141f, -0.63452303f, 0.18488860f, 
    0.10114778f, -0.14890812f, 0.10672425f, -0.19166572f, 0.13707595f, -0.03596234f, 0.08983753f, -0.07001787f, 
    -0.41648939f, 0.27969310f, 0.13777108f, -0.07054397f, -0.00163549f, -0.37373057f, -0.09741766f, -0.34637493f, 
    -0.18975879f, -0.05630311f, 0.06266001f, -0.01515691f, 0.22340217f, 0.14295468f, 0.00686814f, -0.43327150f, 
    -0.10787682f, -0.27670598f, -0.03473143f, -0.04791267f, -0.07321795f, 0.11987294f, -0.04401651f, -0.21030833f, 
    0.07419097f, 0.19493301f, 0.08415300f, -0.04094673f, -0.16276605f, 0.04320323f, -0.21377577f, -0.13577086f, 
    -0.17268930f, -0.13069656f, 0.03212947f, -0.39115188f, 0.13836274f, -0.24901673f, -0.01851548f, 0.26731035f, 
    0.13620479f, -0.10276923f, -0.01220724f, 0.07792833f, -0.03964801f, 0.06609094f, 0.10914189f, 0.07093890f, 
    -0.54949933f, -0.16630279f, -0.12066714f, 0.51661748f, -0.14185563f, -0.18141423f, -0.27005962f, -0.13936335f, 
    0.01482453f, -0.09837442f, 0.14774059f, -0.15870070f, -0.74838585f, -0.23082745f, 0.04217743f, -0.25152209f, 
    -0.04422754f, 0.04450495f, -0.06334610f, 0.07799478f, -0.05573422f, 0.00499297f, -0.18125071f, -0.17071813f, 
    -0.05546546f, -0.21671720f, -0.08441654f, 0.21912396f, 0.13243996f, -0.03824397f, 0.06840307f, 0.01034049f, 
    -0.00923288f, -0.17766204f, 0.16891101f, -0.10454738f, 0.27424484f, 0.17139739f, -0.12601620f, 0.04151911f, 
    0.06282690f, -0.04438757f, 0.17171521f, 0.23978712f, 0.05578477f, 0.04978137f, -0.03220677f, -0.14295304f, 
    -0.14854944f, -0.04028039f, -0.34448874f, 0.00448713f, 0.10181116f, 0.13806643f, 0.01172059f, -0.17945215f, 
    -0.15280618f, -0.19242769f, -0.02515210f, 0.05733271f, -0.59480095f, -0.16327959f, -0.19892834f, -0.12280112f, 
    0.14235120f, -0.11641173f, 0.04218939f, 0.01914557f, -0.35132518f, 0.09532455f, -0.07280394f, -0.02585765f, 
    0.05473386f, -0.15924743f, 0.15113829f, 0.16690506f, -0.02334646f, -0.21333830f, -0.04743800f, 0.17441641f, 
    0.03131763f, 0.02253334f, -0.14711237f, -0.22057077f, -0.22155654f, 0.66628420f, -0.19826676f, 0.46358261f, 
    -0.07236389f, 0.24586800f, -0.02666693f, -0.05903030f, -0.11835325f, 0.05002569f, 0.03071643f, 0.25731486f, 
    1.10387397f, -0.03262165f, -0.10939662f, 0.07841984f, 0.20757420f, 0.00605847f, 0.13220397f, -0.16371068f, 
    -0.14635590f, -0.02401515f, -0.14260396f, 0.13297914f, 0.16444053f, 0.29280907f, -0.15797389f, -0.10131194f, 
    -0.01896792f, 0.07263263f, -0.04975504f, -0.05035062f, -0.13472575f, 0.13821471f, -0.03181013f, -0.02414893f, 
    0.10796774f, 0.15390395f, -0.45349857f, 0.22779092f, 0.05526303f, -0.07732882f, -0.01217549f, -0.24367332f, 
    -0.00329398f, -0.08435427f, -0.01409336f, 0.05395858f, -0.24704146f, -0.18008058f, -0.15022530f, 0.01464206f, 
    -0.18232627f, -0.16251059f, 0.13937150f, 0.01552939f, 0.14112459f, 0.05948152f, 0.10294276f, 0.30487210f, 
    0.24857299f, 0.16505852f, -0.08612303f, 0.15715398f, 0.08052567f, 0.07149035f, 0.09211639f, 0.11289661f, 
    0.23827966f, 0.01485552f, -0.07638673f, -0.06343041f, 0.16488916f, 0.09557579f, -0.13733596f, 0.01854062f, 
    -0.13596129f, 0.05581452f, -0.02748281f, -0.04216829f, 0.22508506f, -0.27243966f, -0.09384701f, -0.21630685f, 
    0.07232978f, 0.31353790f, 0.24019876f, 0.11620379f, -0.06294412f, 0.05756002f, -0.12396450f, 0.04562414f, 
    0.02419178f, 0.03745814f, 0.00370154f, 0.04113296f, 0.04566147f, -0.57060230f, 0.16001949f, 0.17314944f, 
    -0.06996778f, 0.02768059f, -0.04128110f, -0.04722304f, -0.17317174f, 0.10491626f, -0.24497159f, 0.23953792f, 
    0.29050469f, 0.22865617f, 0.30513427f, 0.24662103f, -0.02349719f, 0.05325935f, -0.02011586f, 0.09323112f, 
    -0.10246781f, -0.00805983f, 0.03783750f, -0.05233425f, 0.15324761f, 0.37907982f, -0.19785784f, -0.01133389f, 
    0.19038099f, -0.00965065f, -0.12748474f, -0.11610536f, 0.08909900f, -0.06964801f, -0.09954920f, 0.18870410f, 
    0.25488427f, 0.08044332f, 0.03454108f, 0.01867610f, 0.06243481f, 0.06458501f, -0.03238552f, 0.14751397f, 
    -0.06801530f, -0.14938600f, -0.32699147f, -0.59352553f, -0.11064032f, -0.11639027f, -0.02116985f, 0.05070004f, 
    0.04967759f, -0.13660039f, 0.03722893f, -0.17936885f, -0.05652852f, -0.27887821f, -0.24079111f, -0.08579870f, 
    0.13093410f, -0.07377820f, -0.02019196f, 0.26503482f, 0.02220067f, -0.09025285f, -0.06790161f, -0.02500899f, 
    -0.04878516f, 0.01845240f, 0.01092865f, 0.16053581f, 0.11071889f, 0.10179117f, -0.34419668f, 0.21170409f, 
    0.02374504f, 0.03388817f, -0.04248791f, -0.00232649f, 0.02582884f, 0.10509492f, -0.26169792f, 0.01853627f, 
    0.38404256f, -0.36904249f, 0.03244299f, 0.07293040f, -0.01377542f, -0.06988987f, 0.02003361f, -0.18062137f, 
    -0.07291610f, -0.06659714f, -0.01806772f, -0.28466150f, 0.01781338f, 0.17553191f, 0.21187156f, 0.19867076f, 
    -0.08185124f, -0.16697612f, -0.23166616f, 0.09795777f, 0.08081234f, 0.02979423f, 0.02444069f, -0.01077162f, 
    0.02137276f, -0.09695584f, 0.09146570f, 0.12413472f, -0.13140666f, -0.05731772f, -0.01145271f, 0.12198455f, 
    0.08891353f, 0.13645034f, -0.06093168f, 0.10662528f, 0.00546352f, -0.06595794f, -0.44647250f, 0.11167517f, 
    -0.08643301f, -0.04811304f, -0.22603665f, -0.10434114f, 0.03331172f, -0.08417773f, 0.02163450f, -0.12038967f, 
    -0.16463758f, -0.02458420f, 0.02544055f, 0.16897975f, -0.38047844f, -0.06873057f, 0.04093702f, -0.07188384f, 
    0.02118475f, 0.10070180f, -0.02563909f, -0.00067609f, -0.33437082f, -0.84753871f, 0.20017837f, -0.60894722f, 
    0.11265516f, 0.05788748f, -0.00242993f, 0.00545302f, -0.05882569f, -0.10417180f, -0.16941555f, -0.01306849f, 
    0.05833568f, -0.13203304f, 0.12717523f, 0.07439885f, -0.11047958f, 0.09102444f, 0.25864643f, -0.02842550f, 
    0.00382466f, -0.13474104f, -0.02143888f, -0.06193181f, 0.12804630f, -0.24886741f, -0.16938110f, -0.06301407f, 
    -0.30401412f, -0.10146291f, 0.10103412f, -0.02999442f, -0.11502192f, 0.02926367f, 0.01538969f, 0.04298857f, 
    0.04127801f, -0.03221650f, 0.14647402f, -0.18224229f, -0.13923664f, -0.01495187f, -0.00798832f, 0.18385488f, 
    0.08454999f, -0.00714431f, 0.03393013f, -0.06689369f, 0.09382924f, 0.13263087f, 0.17842133f, 0.24428116f, 
    -0.04125326f, -0.33180797f, -0.04431562f, -0.30156916f, 0.02214612f, -0.09901549f, 0.05932289f, 0.07453396f, 
    0.01420213f, 0.23758076f, -0.27310982f, 0.10100868f, 0.18165040f, -0.13501367f, -0.04871025f, -0.21070816f, 
    -0.12356006f, -0.26216963f, 0.06860681f, -0.13699991f, 0.19483276f, 0.08444049f, -0.07336316f, -0.08290658f, 
    0.11268368f, 0.04899765f, 0.06137951f, 0.12498631f, 0.13881609f, 0.01255615f, -0.02353674f, 0.10377602f, 
    0.07975008f, 0.12297481f, 0.28384855f, 0.06482047f, -0.21853741f, -0.23982097f, -0.07711340f, 0.23363885f, 
    0.07064650f, 0.05119288f, -0.07712103f, 0.02413192f, 0.01418841f, 0.14996409f, 0.19428721f, 0.20379996f, 
    -0.06327073f, 0.00927817f, -0.12739590f, -0.09759329f, -0.09866158f, -0.00431118f, 0.07885394f, -0.18054654f, 
    -0.12063881f, -0.09593955f, 0.20279953f, 0.02801002f, -0.03076154f, -0.13630396f, -0.12824027f, -0.16135861f, 
    0.02941065f, 0.03860635f, 0.08286794f, 0.08998970f, 0.17800188f, -0.04265952f, -0.09183984f, -0.02194828f, 
    0.03374856f, 0.04778653f, 0.00295744f, 0.07466590f, 0.02407578f, 0.03371157f, -0.12425429f, -0.10753979f, 
    0.01336497f, 0.02089439f, 0.25198895f, 0.05370454f, -0.04318858f, -0.17499658f, 0.09235693f, 0.22059742f, 
    0.00983311f, -0.02340642f, -0.14283301f, -0.07336923f, 0.03067625f, -0.51295853f, 0.32994875f, 0.21251544f, 
    0.05543336f, 0.22585684f, 0.15900825f, 0.01352100f, -0.03482439f, 0.03803308f, -0.06208631f, -0.01747517f, 
    -0.08205595f, 0.20093834f, -0.46049041f, 0.02154118f, -0.03924334f, -0.06294340f, 0.04819745f, 0.04759385f, 
    0.03323824f, -0.40428174f, 0.02331069f, -0.13889278f, -0.32731223f, -0.17886481f, -0.26244944f, -0.07522074f, 
    0.06490823f, -0.04326843f, 0.04062090f, -0.02494401f, 0.15639898f, 0.11924007f, -0.01684367f, 0.43765783f, 
    -0.05987318f, 0.10087750f, -0.45015720f, 0.25814876f, 0.10193896f, 0.13079378f, 0.04013367f, 0.16960618f, 
    0.04360589f, 0.06972529f, 0.12075233f, -0.37797093f, -0.23744740f, 0.32394770f, 0.01771225f, -0.24053732f, 
    -0.05152563f, -0.09823050f, -0.00811881f, 0.03497475f, 0.00442514f, -0.10734689f, -0.30363432f, -0.15119432f, 
    -0.01803600f, -0.37376213f, -0.02062137f, -0.05163535f, -0.06070668f, -0.08081235f, -0.10292648f, -0.05609927f, 
    0.07208911f, -0.18140385f, 0.26167059f, 0.01425751f, 0.06354000f, 0.06856151f, -0.24134618f, -0.15367420f, 
    0.05826278f, -0.02154810f, 0.03926602f, -0.18950270f, 0.16365556f, 0.16179328f, 0.11370717f, 0.08273357f, 
    0.20538262f, 0.13259310f, 0.11154007f, 0.18309347f, 0.25214028f, 0.03764196f, -0.15109913f, -0.22290710f, 
    -0.02589927f, -0.01879779f, -0.01842477f, 0.03512646f, -0.05511076f, -0.16575070f, 0.38802779f, 0.14394276f, 
    0.03208732f, 0.05754498f, -0.04219925f, -0.09288682f, 0.09228734f, 0.06604972f, -0.14342788f, -0.19525163f, 
    0.49522185f, -0.44575012f, 0.43410048f, 0.20633262f, 0.25914109f, 0.05625049f, 0.12511249f, 0.03136605f, 
    -0.00736543f, -0.05584537f, 0.11111519f, 0.06170850f, 0.06284170f, -0.10015714f, -0.52955270f, -0.06311186f, 
    -0.02618312f, 0.01703256f, -0.00399946f, 0.22541496f, 0.09118677f, -0.34383652f, 0.15010391f, -0.21043327f, 
    -0.02660941f, 0.06579385f, -0.08814136f, -0.01250815f, 0.05838529f, -0.08768196f, -0.06757342f, -0.11050437f, 
    0.03038452f, -0.23991098f, 0.29159573f, 0.42920974f, 0.20435514f, -0.12483211f, 0.25871208f, 0.19757722f, 
    -0.03511207f, -0.09363937f, -0.01553993f, 0.10944817f, 0.23228130f, 0.29180372f, 0.10128811f, 0.13043602f, 
    -0.15377702f, 0.29738224f, -0.15492608f, -0.11217329f, -0.08154647f, 0.03314577f, 0.10952145f, 0.03907435f, 
    0.15152793f, 0.01444508f, 0.10332650f, 0.04873431f, -0.31598040f, 0.01690062f, 0.44066763f, -0.02183864f, 
    0.04327117f, -0.02184295f, -0.01492546f, 0.04331549f, 0.05446517f, 0.19605495f, 0.16134827f, 0.07411060f, 
    -0.22101298f, 0.31556463f, -0.34740329f, -0.11179301f, 0.06526811f, -0.15935139f, -0.08633550f, -0.06889482f, 
    0.13645180f, 0.06833162f, -0.18767981f, 0.07909916f, -0.08776019f, 0.26777667f, -0.03968453f, -0.21169713f, 
    0.24524999f, 0.23043466f, 0.03161371f, 0.01813895f, 0.01912673f, -0.02350737f, 0.06610428f, 0.12908930f, 
    -0.41017872f, -0.20406066f, -0.06026642f, -0.43431935f, 0.02692671f, -0.03192528f, -0.06051495f, 0.07471692f, 
    -0.03248515f, -0.12768131f, -0.00253395f, -0.02837535f, -0.03458676f, -0.34362203f, -0.30363339f, 0.49340391f, 
    0.18513615f, -0.09631944f, -0.06439330f, 0.04325263f, -0.07917539f, -0.15402918f, 0.03526241f, 0.14742979f, 
    -0.36984268f, -0.33773968f, 0.19259866f, -0.16150904f, 0.01936236f, -0.16856417f, -0.13343826f, 0.22660325f, 
    -0.21878950f, -0.02670266f, 0.10015615f, 0.02099571f, -0.02078467f, -0.25244540f, -0.10886077f, -0.21744406f, 
    0.01617025f, 0.00902646f, -0.00381875f, 0.15736550f, -0.08601360f, 0.07737373f, 0.02671283f, -0.12602302f, 
    -0.06296380f, -0.38798061f, -0.05177206f, 0.11585763f, 0.10995851f, 0.08857745f, -0.06771080f, -0.09187791f, 
    0.29933882f, 0.04020727f, 0.05687838f, 0.01967517f, 0.31247538f, -0.46528554f, 0.36892292f, 0.44387221f, 
    -0.08896945f, 0.05456030f, -0.01447731f, 0.13160026f, 0.13032174f, -0.09842832f, -0.04004877f, -0.06538606f, 
    0.15150857f, -0.09278504f, -0.37802491f, 0.14135087f, 0.21462318f, -0.14696148f, -0.07947768f, -0.12675463f, 
    -0.02334370f, 0.02530484f, -0.01191143f, 0.23476468f, -0.08989540f, 0.09048772f, -0.17819163f, -0.25090700f, 
    -0.09546049f, 0.16190493f, 0.05158573f, -0.14641505f, 0.08720957f, 0.03844533f, 0.03702599f, -0.35227677f, 
    -0.06308783f, 0.10807757f, -0.44940987f, -0.49156925f, 0.06917175f, 0.16465904f, -0.16874276f, 0.08350220f, 
    0.35041463f, -0.06128130f, 0.25922412f, 0.02714001f, -0.21234111f, -0.11209195f, 0.04340059f, 0.12128128f, 
    0.05791508f, -0.06875715f, -0.10558163f, -0.04676800f, -0.07652368f, -0.04279948f, 0.09033394f, -0.05798828f, 
    0.20428485f, 0.06430350f, -0.12146785f, 0.09959017f, 0.27923232f, 0.17119652f, 0.07836825f, -0.01006428f, 
    -0.04176116f, 0.07557341f, 0.04294569f, 0.09302034f, 0.15498953f, 0.00083094f, 0.11226514f, -0.01606842f, 
    -0.08547038f, -0.18161973f, 0.02810490f, 0.00051891f, -0.03900103f, -0.13383180f, 0.00276699f, -0.12504952f, 
    0.28267047f, -0.05398195f, 0.07468346f, -0.07779889f, -0.00016682f, -0.34756142f, -0.11765783f, 0.02749624f, 
    -0.03043635f, -0.01999026f, -0.08002041f, -0.22118711f, -0.10541245f, -0.10691032f, -0.38676238f, 0.19577238f, 
    0.04423682f, -0.00205903f, -0.03230784f, -0.03588959f, -0.02215992f, -0.16054948f, 0.00613867f, -0.02985410f, 
    0.22027014f, -0.24915417f, -0.16699404f, 0.02419446f, -0.02458182f, 0.40790212f, -0.09363986f, 0.06547096f, 
    0.01948293f, 0.11277194f, 0.14567146f, 0.01826860f, 0.13019402f, 0.05292274f, 0.20102155f, -0.22345969f, 
    -0.20564923f, -0.13584781f, -0.03096047f, 0.13972817f, -0.00027070f, -0.00842257f, 0.01323711f, 0.00788879f, 
    -1.16505313f, -0.22839881f, -0.29518157f, 0.07608091f, -0.16202983f, -0.06658486f, 0.11792021f, 0.01784763f, 
    0.20029011f, 0.10919926f, 0.06266316f, -0.06748822f, -0.06670318f, 0.00220919f, 0.18803778f, 0.03445179f, 
    0.08306546f, -0.03080868f, 0.03664880f, 0.01735756f, 0.01391754f, -0.12766138f, -0.45700607f, -0.64628112f, 
    0.31323704f, -0.02496007f, -0.06030894f, -0.25090367f, -0.01022574f, 0.04795043f, 0.08763332f, 0.03355266f, 
    -0.05157588f, 0.04116014f, 0.06836917f, -0.00885538f, -0.37429145f, -0.13371468f, -0.11649834f, -0.21363628f, 
    -0.15100430f, -0.04116375f, 0.09089643f, -0.02970054f, -0.01116057f, -0.04906551f, 0.11536651f, 0.24311770f, 
    -0.00487392f, -0.03620986f, -0.20218624f, -0.25093403f, -0.16765483f, -0.10680696f, -0.07306346f, 0.06161117f, 
    -0.05839845f, 0.05304336f, -0.15653484f, 0.10298029f, -0.22009481f, 0.25801638f, 0.31081605f, -0.17017783f, 
    0.00655473f, -0.19550838f, 0.05184110f, -0.01557292f, -0.02684741f, 0.06799609f, -0.17670372f, 0.04371953f, 
    -0.43224108f, -0.93298376f, -0.55580872f, -0.40892047f, -0.13635662f, 0.14723222f, 0.29236838f, -0.32555237f, 
    0.09988654f, 0.02532422f, -0.09522474f, -0.00013102f, -0.18523137f, -0.08421415f, 0.22555172f, 0.10276540f, 
    0.07370108f, 0.14574865f, 0.00670223f, -0.00994507f, 0.01609206f, -0.10248084f, 0.23171879f, -0.03000292f, 
    -0.78831774f, -0.70006585f, -0.68359303f, -0.34397694f, 0.00771946f, 0.09098960f, 0.11355885f, -0.10941318f, 
    -0.02338498f, -0.04013345f, 0.08509456f, 0.03697431f, 0.35632086f, 0.20368285f, 0.03224585f, -0.06226115f, 
    0.01439577f, 0.02897930f, 0.22520518f, -0.06593282f, 0.25148970f, 0.14211904f, 0.34621412f, -0.11882854f, 
    -0.25247774f, -0.10522679f, 0.34851453f, -0.03681864f, 0.06750149f, -0.14532995f, -0.05680932f, 0.09372137f, 
    -0.03866951f, 0.12086474f, -0.02402104f, 0.03373265f, -0.08908813f, -0.18389688f, -0.10896359f, -0.02532866f, 
    -0.09869303f, -0.03729358f, 0.05265031f, 0.06683978f, -0.03169677f, 0.01913629f, 0.02749015f, 0.02863389f, 
    -1.08181989f, -0.71385002f, -0.33831251f, -0.29031858f, -0.10045702f, -0.24110112f, -0.05026986f, -0.10104837f, 
    -0.08625447f, -0.03194572f, 0.15895270f, -0.17135160f, -0.36960447f, 0.09286704f, 0.53160447f, -0.07584951f, 
    0.06057750f, 0.07398989f, 0.01285321f, 0.06576624f, 0.17719314f, 0.28584367f, 0.13844234f, -0.09932019f, 
    -0.18134908f, -0.08051026f, 0.50827509f, -0.44489503f, 0.00151483f, -0.09845269f, 0.02400968f, 0.08040096f, 
    -0.18151474f, 0.21089035f, -0.02201190f, 0.06508724f, -1.04140353f, -1.27185643f, -0.75027061f, -0.27832663f, 
    -0.26425698f, -0.65108979f, -0.65951896f, -0.19328807f, 0.01030489f, -0.02400751f, -0.00629492f, -0.05722576f, 
    -0.21368600f, 0.11867564f, 0.41263342f, 0.23299420f, -0.03939603f, 0.04571427f, 0.04742526f, -0.04262139f, 
    0.05383438f, 0.13729168f, 0.00608114f, 0.01702172f, 0.47405964f, -0.17520863f, -0.17825508f, -0.06984793f, 
    -0.33185685f, 0.05933870f, 0.37213010f, 0.07905440f, 0.08387391f, -0.13035773f, 0.09230008f, -0.04706486f, 
    -0.21483754f, -0.03998990f, 0.28628683f, 0.04761805f, 0.03107404f, -0.32430565f, 0.28253797f, 0.23913580f, 
    -0.01281232f, 0.13390890f, 0.06261466f, -0.00240925f, -0.13969782f, -0.01321416f, -0.13762504f, 0.04860899f, 
    0.06308507f, -0.00259040f, 0.01083887f, -0.00422092f, 0.02383378f, 0.03287685f, -0.10255158f, 0.11066824f, 
    -0.25391233f, -0.22778903f, -0.22914517f, -0.01685778f, -0.00214297f, -0.06977049f, 0.05634196f, 0.11475470f, 
    0.00168141f, 0.00122507f, -0.03952982f, 0.10208952f, 0.10356885f, 0.19470756f, -0.70295697f, 0.17251498f, 
    -0.23142204f, 0.05581342f, 0.13500096f, 0.14708385f, -0.10181239f, 0.05582792f, 0.13850333f, 0.02844428f, 
    0.04580573f, -0.13062437f, -0.47717458f, 0.37723494f, 0.13161540f, -0.04827929f, 0.08821940f, 0.08749384f, 
    -0.06780606f, 0.03572667f, 0.08416042f, -0.18679368f, -0.85684103f, 0.19980206f, 0.97811139f, 0.08835225f, 
    -0.07386296f, -0.02653587f, -0.10675290f, -0.17517303f, -0.16904543f, -0.01427457f, -0.14155616f, 0.15238509f, 
    0.49721614f, 0.22417478f, 0.07996526f, 0.45230186f, 0.10052714f, -0.04596695f, 0.14029664f, -0.05169480f, 
    0.04926256f, 0.11505570f, -0.07174979f, -0.11323928f, 0.13080823f, -0.15027362f, -0.23255664f, -0.05677688f, 
    0.05095752f, -0.07326316f, -0.03536449f, -0.01191378f, -0.15918006f, -0.14914049f, -0.08002425f, -0.24549145f, 
    -0.79337764f, -0.25055978f, 0.21165258f, -0.35046974f, -0.09647227f, -0.06725647f, -0.01213397f, -0.28711405f, 
    -0.00174168f, -0.01735633f, -0.08975623f, 0.04425516f, 0.55079979f, 0.19844620f, -0.61935675f, -0.63347536f, 
    0.03797170f, -0.14364980f, -0.14792797f, 0.17625852f, -0.04888139f, 0.20647088f, -0.01838910f, -0.10164694f, 
    -0.33105740f, 0.06253827f, 0.21321781f, 0.00024242f, -0.37246481f, 0.22001819f, -0.15713470f, 0.16569884f, 
    0.16500360f, 0.01511524f, 0.17559077f, -0.07548561f, 0.02461850f, 0.02389561f, 0.06920806f, -0.21539028f, 
    0.09197393f, -0.05565770f, -0.03682321f, 0.00943728f, -0.05606121f, 0.07764962f, 0.07418942f, -0.13756974f, 
    0.09774326f, -0.18964018f, -0.13152121f, -0.14194214f, -0.19872096f, 0.02234883f, 0.10691851f, -0.34058729f, 
    0.02626315f, -0.12640920f, -0.01880208f, -0.03772033f, -0.18149012f, -0.82676029f, -0.16399908f, 0.73552865f, 
    0.28946006f, 0.07028113f, -0.14178438f, -0.23837088f, 0.00624784f, 0.01736992f, 0.02475809f, 0.08215734f, 
    0.06853259f, -0.12881035f, 0.19684027f, 0.49456468f, -0.00541661f, 0.10344090f, -0.11185828f, 0.25629944f, 
    0.08349762f, 0.07457864f, 0.25508657f, -0.13006149f, 0.01044770f, -0.00067876f, -0.12674275f, -0.08644166f, 
    0.01774127f, 0.02103435f, 0.07847607f, 0.05258757f, 0.11505161f, 0.02437260f, 0.47360960f, 0.24424055f, 
    -0.33832791f, 0.17448322f, -0.11172315f, -0.03032626f, -0.02828359f, -0.02789353f, -0.05422087f, 0.10535579f, 
    0.09672304f, -0.04632206f, 0.01555656f, -0.06849286f, -0.06263462f, -0.65774590f, -0.50318748f, -0.30440354f, 
    -0.05379282f, 0.05423263f, -0.01418919f, 0.13557157f, 0.05772748f, 0.04494264f, 0.03123519f, 0.16575381f, 
    0.27333105f, -0.04667662f, -0.08053669f, -0.19382241f, 0.07306497f, 0.07549471f, 0.09805068f, 0.08568583f, 
    0.06435818f, -0.20890318f, 0.14012523f, -0.04666312f, 0.18332712f, 0.03973146f, 0.03500652f, -0.14013982f, 
    -0.31911054f, 0.20692377f, 0.17581287f, 0.10276963f, -0.00964658f, 0.11595877f, 0.05383655f, 0.08513432f, 
    -0.67065781f, 0.16551447f, -0.39794791f, 0.46445903f, 0.01406453f, 0.14715703f, 0.07070089f, 0.16971961f, 
    -0.06964235f, 0.00988918f, -0.21007924f, -0.02935157f, 0.09970263f, 0.14901964f, -0.06230441f, -0.40909058f, 
    0.05532692f, 0.01609917f, -0.10858179f, 0.02162345f, -0.17631412f, 0.11812856f, -0.22893806f, -0.14449754f, 
    -0.18675262f, -0.34340426f, 0.21909913f, 0.03333084f, -0.02404253f, -0.36015442f, -0.03990735f, -0.23277186f, 
    0.01579623f, 0.00299102f, 0.00176437f, -0.05680549f, 0.07146971f, 0.10628974f, 0.25831592f, 0.02600207f, 
    -0.04184420f, -0.00723204f, 0.12304891f, -0.00505156f, -0.18023898f, -0.02375258f, -0.05725479f, -0.05522522f, 
    0.18697475f, 0.13845578f, -0.08124074f, -0.07710072f, -0.01974128f, 0.05494881f, 0.09778153f, 0.02270515f, 
    0.00085308f, -0.17896912f, -0.06358014f, -0.12944065f, 0.18716438f, 0.00851042f, -0.11814766f, 0.03245118f, 
    -0.08217920f, 0.03791231f, 0.00726413f, -0.10116364f, -0.08232455f, -0.08373119f, -0.00593820f, -0.13778096f, 
    -0.23837151f, -0.28488141f, -0.40256956f, 0.05443065f, 0.02767524f, -0.08374100f, -0.02181860f, -0.00700737f, 
    0.02485220f, 0.02590652f, -0.04359350f, 0.05002887f, 0.31254461f, -0.23727143f, 0.23045711f, -0.82394505f, 
    -0.02837736f, 0.08138102f, -0.07013669f, 0.04740655f, 0.11894927f, 0.12142909f, -0.06406929f, -0.08342312f, 
    0.15619425f, 0.11977019f, -0.05255546f, -0.23522802f, -0.10101996f, 0.16099949f, 0.02624115f, 0.03382840f, 
    -0.06440705f, 0.27110207f, -0.01342064f, 0.04411662f, -0.77238464f, 0.10607958f, -0.53728706f, 0.48771513f, 
    0.19332357f, -0.10719079f, 0.24680480f, 0.09238560f, 0.04798712f, -0.00588761f, -0.01609334f, 0.03669880f, 
    0.45515367f, -0.95724016f, -0.16252093f, -0.34608355f, -0.15494339f, -0.14296104f, -0.15832128f, 0.26334405f, 
    0.18753444f, -0.02143988f, 0.03198703f, 0.04766484f, -0.00584290f, 0.16464360f, -0.15305141f, 0.11716852f, 
    -0.05217376f, 0.07516313f, -0.09330942f, -0.08344314f, 0.01982117f, 0.13482140f, 0.12158380f, 0.01995077f, 
    0.53292441f, -0.11907966f, -0.04883822f, -0.19594483f, -0.08091755f, -0.07735637f, -0.38458490f, -0.02378071f, 
    0.04683118f, 0.00921910f, 0.04548194f, -0.02041298f, -0.00797496f, 0.03211806f, -0.14188571f, -0.04778396f, 
    0.04023579f, -0.04792532f, -0.03126422f, -0.14106789f, 0.01623459f, 0.09163942f, -0.04294586f, -0.15768221f, 
    -0.03941996f, -0.06096552f, 0.16046070f, 0.05345106f, -0.06304359f, -0.17444147f, 0.11265896f, -0.08609870f, 
    0.07253315f, 0.01599185f, 0.02006338f, -0.07563374f, 0.44436035f, -0.58328682f, 0.35390219f, 0.17963758f, 
    -0.17571792f, 0.01865246f, -0.31952301f, -0.18630695f, -0.05070594f, 0.13376595f, -0.07510309f, -0.02047875f, 
    -0.21839502f, -0.17088176f, 0.24802583f, 0.18131326f, -0.11889427f, 0.13875590f, 0.00689548f, -0.12956072f, 
    0.05550173f, 0.07402049f, 0.02940242f, -0.07003952f, 0.38379082f, -0.71295929f, -0.54048979f, -0.40995896f, 
    0.21246749f, -0.12772265f, -0.15030228f, 0.25765631f, 0.20396134f, -0.01190675f, 0.13595711f, 0.08744946f, 
    -0.26540223f, -0.00964656f, 0.19573775f, 0.02009587f, -0.26663181f, 0.01369237f, 0.14640743f, 0.00159721f, 
    0.01449619f, -0.13783829f, 0.11788439f, -0.11038766f, 0.16152586f, 0.01566685f, 0.03376858f, -0.22165754f, 
    0.04348861f, 0.04961143f, -0.03157447f, -0.03863587f, 0.02235030f, 0.01495299f, -0.05497335f, -0.04296925f, 
    -0.82596576f, -0.37315273f, -0.47087178f, -0.16130143f, 0.21569774f, -0.09995421f, 0.11175571f, 0.06360515f, 
    0.03592665f, 0.09062700f, -0.00786692f, 0.07472297f, -0.45359489f, -0.62101454f, 0.05143685f, 0.61600661f, 
    0.00792670f, 0.05395788f, 0.08994320f, -0.14984669f, -0.10113674f, -0.22173202f, 0.04697387f, -0.01503982f, 
    0.36764583f, -0.30757976f, -0.12649745f, -0.11554419f, 0.02620244f, 0.25590360f, 0.09852565f, 0.23666430f, 
    0.03779021f, -0.02241481f, 0.01793139f, 0.01215351f, -0.06936754f, 0.10794243f, 0.05264968f, -0.03382267f, 
    0.02915480f, 0.01883344f, 0.02459524f, -0.08101387f, -0.00642954f, -0.10087482f, -0.23945041f, -0.35820985f, 
    -0.06402510f, 0.03722790f, 0.07861034f, 0.11600148f, -0.17919737f, -0.01198422f, -0.14974578f, -0.17519233f, 
    -0.01395319f, 0.05191655f, -0.05206097f, -0.00194956f, 0.33256719f, -0.28619403f, 0.10957664f, -0.31689274f, 
    0.05253996f, -0.09311322f, -0.07743651f, 0.21628718f, -0.02613854f, 0.05696792f, 0.04976715f, 0.02891492f, 
    0.62642658f, -0.48010004f, 0.11629616f, -0.45034015f, 0.03219301f, -0.03730341f, -0.11047491f, -0.09068552f, 
    -0.05731275f, -0.18913698f, -0.04437217f, -0.32468262f, 0.15635356f, -0.19569100f, -0.16194771f, 0.10806102f, 
    0.04860599f, -0.13371024f, -0.06220834f, -0.05494092f, 0.02269629f, -0.02493621f, 0.14003071f, 0.17403680f, 
    -0.32255816f, 0.30312163f, 0.27114135f, 0.28842333f, 0.00354681f, -0.01303158f, -0.09076280f, 0.02919419f, 
    -0.19781291f, 0.01148192f, -0.21616313f, -0.00753921f, -0.14213869f, -0.43985668f, -0.33058932f, 0.09826791f, 
    0.14048207f, 0.18584011f, 0.12270465f, 0.18562287f, -0.22347231f, 0.00756704f, 0.07657875f, -0.43124297f, 
    -0.28531483f, -0.06121037f, -0.15690768f, -0.01937833f, -0.03549850f, -0.13157324f, -0.07529834f, -0.06953073f, 
    0.10184045f, 0.17584707f, 0.00118350f, 0.24104933f, -0.28928447f, -0.05295758f, -0.10624618f, 0.02075408f, 
    0.08802337f, -0.05574018f, -0.05924532f, 0.00760910f, -0.06872920f, 0.03617365f, 0.04553209f, 0.20190087f, 
    -0.02073953f, -0.27966318f, -0.34693930f, 0.08279491f, -0.04609491f, 0.01714944f, -0.10249717f, -0.14258204f, 
    0.01265918f, 0.02136076f, 0.08613994f, -0.06025268f, 0.14810027f, -0.07109263f, -0.20240352f, -0.21107860f, 
    -0.16273840f, -0.13676094f, -0.05550912f, -0.00246337f, 0.11847860f, -0.05513895f, 0.26597062f, 0.01389818f, 
    1.20639229f, -0.12995799f, 0.01689575f, -0.14937517f, 0.13515122f, -0.05713701f, -0.03014835f, 0.01141756f, 
    0.04494888f, -0.02651182f, 0.05346833f, -0.00821401f, -0.60018277f, -0.17678866f, 0.12018478f, 0.19039562f, 
    0.07887568f, 0.05708122f, -0.08582945f, 0.08677313f, 0.22486100f, -0.25864056f, -0.03045169f, -0.25066862f, 
    0.01658549f, -0.05343444f, -0.22469333f, -0.06941671f, -0.16096441f, 0.01737979f, 0.05027705f, -0.04818699f, 
    0.15352012f, 0.06858850f, 0.05556361f, 0.10804780f, 0.18457377f, 0.13293768f, -0.22180839f, -0.25261638f, 
    0.28538588f, 0.08639996f, -0.16081367f, 0.10943212f, 0.06445592f, 0.26037174f, 0.16862932f, 0.38281730f, 
    -0.36574924f, -0.70501757f, -0.90475798f, -0.54410762f, -0.16466124f, 0.00629924f, 0.04491808f, 0.00399912f, 
    -0.00824982f, 0.03510247f, -0.01554456f, 0.11110037f, 0.12898439f, -0.38883218f, -0.05382716f, -0.42285651f, 
    -0.08513208f, -0.09263697f, 0.03901852f, -0.04463339f, 0.07651410f, -0.00688267f, 0.09811989f, -0.13279252f, 
    -0.12831165f, -0.01468944f, -0.06207323f, -0.09897303f, -0.24874291f, 0.00910665f, -0.03842885f, 0.04170407f, 
    0.17658049f, 0.11725464f, -0.14245312f, 0.10885398f, -0.44241625f, -0.62545961f, -0.37481898f, 0.19321856f, 
    -0.16608149f, -0.11515119f, -0.15926738f, 0.02204089f, -0.00982425f, 0.00430764f, 0.03272908f, 0.14026441f, 
    -0.22223333f, -0.09645458f, -0.10293421f, 0.15242767f, 0.07164832f, 0.06729078f, 0.19243413f, -0.02920900f, 
    -0.28665739f, 0.16690962f, -0.27210316f, -0.56901604f, -0.56185925f, 0.24234149f, 0.14938076f, 0.22606158f, 
    0.16584897f, -0.15255576f, -0.13573734f, 0.08737282f, -0.17199723f, -0.07085077f, 0.21330293f, -0.11993001f, 
    0.06999547f, -0.31529993f, -0.30275926f, -0.17255224f, -0.04896966f, -0.00085967f, 0.16596280f, 0.17885900f, 
    0.05407700f, 0.08669439f, -0.00585856f, -0.03433960f, -0.01413309f, -0.08319493f, 0.00845083f, -0.01147915f, 
    -0.16097225f, 0.08541149f, 0.00729831f, -0.15586220f, -0.11663332f, 0.01098594f, -0.17618035f, 0.15445909f, 
    0.12708259f, -0.02542518f, -0.03335581f, 0.00635552f, -0.00261621f, -0.04966379f, -0.16525657f, -0.20174818f, 
    0.09926520f, 0.17813945f, 0.14607486f, 0.15814561f, 0.80979371f, 0.44404745f, -0.04774232f, -0.34780377f, 
    0.24983126f, -0.04812342f, 0.16712508f, -0.01020342f, 0.00275271f, -0.09023632f, -0.07661884f, 0.18691015f, 
    0.03741201f, 0.30282778f, -0.13038625f, -0.10701560f, 0.14029202f, -0.08371311f, -0.05791831f, 0.10975645f, 
    0.06956232f, 0.00581912f, 0.16881709f, 0.27690646f, -0.42855877f, -1.09416234f, -0.69562536f, -0.04500984f, 
    0.05716676f, 0.14713863f, 0.03016322f, 0.09718572f, -0.06035703f, 0.09244471f, 0.09374215f, 0.05868522f, 
    -0.65630436f, -0.12382231f, 0.18505792f, 0.51166034f, -0.02813413f, 0.16035365f, 0.08538059f, -0.00452596f, 
    -0.01813219f, 0.24300422f, -0.16187687f, 0.13872705f, 0.07698444f, 0.14849226f, 0.05132938f, -0.27965248f, 
    -0.00289197f, -0.09509771f, 0.01102167f, -0.13975221f, -0.04630078f, 0.04349041f, 0.06670443f, 0.07027330f, 
    0.00531490f, -0.63680398f, -0.41114247f, 0.44709077f, -0.30021018f, 0.03082518f, 0.07083330f, 0.29684195f, 
    -0.18390606f, -0.17500071f, 0.05739142f, -0.09692422f, 0.47744900f, -0.25086588f, -0.42744619f, -0.13575228f, 
    0.15642668f, -0.02951060f, 0.01842069f, -0.10426988f, -0.03118697f, 0.15923047f, 0.17484030f, 0.06882641f, 
    0.08324485f, -0.12113957f, -0.24892259f, 0.01830362f, 0.01528447f, 0.09963262f, 0.10792688f, -0.15725017f, 
    -0.01480241f, -0.42801008f, -0.20633329f, -0.19930685f, -0.37728462f, 0.05608226f, 0.07074667f, -0.30665395f, 
    -0.12036059f, -0.05249384f, 0.04143541f, -0.07984924f, 0.04264899f, -0.01133880f, 0.06551748f, 0.14791062f, 
    -0.04963642f, -0.12749474f, -0.02663552f, 0.12486427f, -0.00817761f, -0.14188068f, -0.26803964f, -0.13392259f, 
    0.23419607f, 0.13398544f, 0.21268149f, 0.09063517f, 0.54351395f, 0.44638094f, 0.09772936f, -0.34441990f, 
    -0.07972398f, -0.01031326f, -0.09545262f, -0.17392445f, 0.01871571f, -0.07944688f, -0.08014350f, 0.03780593f, 
    0.04420372f, -0.33514085f, 0.10217002f, 0.21510004f, -0.02295376f, 0.21047281f, 0.10126857f, -0.02249401f, 
    0.08752043f, 0.17487969f, -0.08043989f, 0.00279379f, -0.03823701f, 0.07221984f, 0.25306079f, -0.10430757f, 
    -0.03284672f, -0.09881753f, -0.02391203f, 0.05332752f, 0.05141829f, 0.05201024f, -0.13208161f, -0.64939892f, 
    -0.26253062f, -0.08777738f, -0.22380929f, -0.07899652f, 0.04312739f, 0.10747951f, 0.15159839f, -0.03338067f, 
    0.27435958f, -0.11946687f, 0.01994564f, 0.16287979f, 0.08740793f, 0.04842347f, -0.39854610f, -0.12131320f, 
    -0.01966810f, 0.06791784f, -0.04456453f, -0.04398059f, 0.11191402f, 0.05580936f, 0.14072873f, 0.02286357f, 
    0.33959606f, 0.29764622f, -0.02317086f, 0.45028123f, 0.13774793f, -0.07141563f, 0.17717053f, 0.01358026f, 
    0.03884339f, -0.13715813f, -0.19634596f, -0.01660784f, 0.02199651f, 0.22285065f, -0.49390787f, -0.26067361f, 
    -0.03995942f, -0.12157085f, 0.07766872f, 0.06460921f, 0.13002791f, -0.33473969f, -0.10127334f, -0.09650522f, 
    -0.06576561f, 0.52317637f, -0.06398707f, -0.03369544f, -0.07637814f, -0.13927791f, 0.21222371f, 0.31188267f, 
    -0.09028983f, 0.15865754f, 0.05853394f, -0.08951264f, -0.35795602f, -0.22650133f, 0.21636416f, 0.20166899f, 
    -0.04232620f, 0.08450720f, -0.11959754f, -0.02869913f, 0.04955136f, 0.02302217f, 0.06837491f, 0.14460193f, 
    -0.34583724f, -0.85216707f, -0.36024696f, -0.17879522f, 0.21365468f, 0.05306841f, 0.01914054f, 0.05768009f, 
    0.12543584f, 0.06014329f, 0.13347170f, -0.12449256f, 0.05754779f, -0.16498038f, 0.08405650f, -0.19441880f, 
    -0.01227006f, 0.01936947f, 0.01469141f, 0.19567916f, -0.04430204f, 0.02441224f, 0.16348562f, -0.06843940f, 
    -0.05530415f, 0.15916824f, 0.06691146f, 0.18462743f, 0.26386055f, -0.15519881f, -0.11691527f, -0.02561197f, 
    -0.05591550f, 0.08420997f, -0.26980197f, -0.10951461f, -0.05805597f, 0.14827435f, -0.17558149f, 0.28050789f, 
    0.01473971f, -0.04103220f, -0.09165228f, -0.00587262f, 0.00361598f, -0.15029253f, -0.18780144f, -0.12260733f, 
    -0.26304460f, 0.18586397f, 0.28075173f, -0.41291159f, 0.06640141f, -0.00584940f, -0.02910151f, 0.01128001f, 
    0.07170767f, -0.01586038f, 0.04839032f, -0.08161779f, 0.31318903f, -0.03968697f, 0.24923976f, 0.40527761f, 
    -0.02655771f, -0.03176539f, -0.12713389f, -0.25440004f, -0.13971843f, -0.06095789f, -0.04939765f, 0.02340355f, 
    0.08774113f, 0.22674611f, -0.06667993f, 0.55161619f, -0.01135039f, 0.28774223f, -0.50070745f, 0.05883316f, 
    0.06037348f, -0.13539624f, 0.06357643f, -0.08242425f, -1.02153301f, 0.16652639f, -0.05940122f, -0.29610825f, 
    -0.01420143f, -0.12593056f, 0.18193547f, 0.01194654f, -0.07055884f, -0.01903998f, 0.07913110f, -0.00133328f, 
    0.04918382f, 0.04564335f, 0.26684499f, -0.00840607f, -0.13582708f, -0.00471768f, -0.24449944f, -0.15761767f, 
    0.07806971f, 0.02746724f, 0.01837254f, 0.13947947f, -0.48369691f, 0.58575040f, -0.90723950f, -0.15882844f, 
    0.07570055f, -0.05326178f, 0.00037413f, -0.13832891f, 0.07770952f, -0.02932884f, 0.14916876f, 0.11285083f, 
    0.14129888f, -0.16699395f, 0.23573062f, 0.48504207f, -0.20709999f, 0.21371782f, -0.37375176f, -0.25796288f, 
    0.34347075f, 0.03470861f, -0.03736279f, -0.05145717f, -0.21585153f, -0.43641818f, 0.19490762f, -0.22857998f, 
    0.19670935f, 0.10590588f, 0.08601306f, -0.11499600f, -0.05582692f, 0.02511978f, -0.07639010f, 0.11933417f, 
    -0.07855739f, -0.58339036f, 0.10670913f, -0.09814642f, 0.43149397f, -0.21560109f, 0.05141421f, -0.08622404f, 
    0.16690008f, -0.11106983f, -0.13834079f, -0.09885512f, -0.60228795f, -0.43486080f, -0.31609705f, 0.19131827f, 
    0.13022019f, 0.09406839f, 0.06089983f, -0.15022951f, 0.13781522f, 0.09532093f, 0.13911131f, 0.01345679f, 
    -0.28091189f, 0.08899942f, -0.72047484f, -0.30809721f, -0.17592646f, -0.02916718f, 0.23709139f, -0.06054060f, 
    -0.12199924f, 0.06133892f, -0.06460024f, -0.00316997f, -0.47050193f, -0.11946161f, -0.24017484f, -0.43733707f, 
    -0.13421591f, -0.09300601f, -0.29544374f, 0.09591402f, 0.09661974f, -0.05105562f, 0.01723153f, 0.09240241f, 
    -0.03175227f, 0.04201691f, 0.24620938f, -0.97011322f, -0.03804791f, -0.00256067f, 0.07461583f, 0.15539163f, 
    0.01039607f, 0.12239337f, -0.18311565f, -0.03773279f, -0.32082716f, 0.00768703f, -0.03783172f, 0.29864898f, 
    0.05474306f, 0.21310581f, 0.09566215f, -0.03889846f, 0.20646408f, 0.15971719f, 0.11888171f, -0.14933877f, 
    -0.23341376f, 0.54119569f, 0.11465646f, -0.45456344f, -0.07648958f, -0.24731462f, 0.22703296f, 0.19060513f, 
    -0.17238393f, 0.03523701f, 0.04515636f, 0.00682497f, -0.12653378f, 0.41331893f, -0.01171341f, 0.28763884f, 
    0.00704132f, -0.10291846f, 0.02205500f, -0.12371150f, 0.23273902f, -0.07290251f, -0.04512918f, -0.04102748f, 
    0.03403329f, -0.21829793f, 0.32487631f, 0.25306791f, 0.08349191f, -0.27246389f, -0.16995513f, 0.07601321f, 
    -0.00934250f, -0.13005626f, 0.09392196f, 0.16392648f, -0.10549118f, -0.07453971f, 0.07812048f, 0.14948042f, 
    0.03074430f, 0.03312846f, -0.04998164f, -0.03922281f, 0.06354092f, 0.12222563f, 0.21333355f, 0.06398716f, 
    0.28795668f, -0.14448495f, -0.44247758f, -0.04689908f, 0.12176567f, 0.08906002f, -0.09200488f, -0.01196211f, 
    -0.04286144f, -0.22369391f, -0.16826072f, -0.08689970f, -0.42608663f, -0.99433476f, 0.31150571f, -0.31054002f, 
    0.03676242f, 0.28512871f, -0.04473742f, 0.33339849f, -0.12455521f, -0.04508794f, 0.02197143f, -0.03747530f, 
    -0.12854683f, 0.18183456f, 0.21642989f, 0.01506011f, -0.17253219f, -0.10492106f, -0.11113983f, -0.42581272f, 
    -0.06229274f, 0.00091720f, -0.02828263f, -0.16554250f, -0.05851096f, -0.10490373f, 0.26005876f, 0.22161509f, 
    0.10090667f, 0.08106432f, 0.05959528f, 0.04575663f, -0.19016068f, 0.16925344f, 0.26590005f, 0.26867467f, 
    0.17652912f, -0.13916276f, 0.22895135f, -0.04878790f, -0.09191290f, -0.10156228f, 0.03636956f, -0.01316625f, 
    -0.10032492f, 0.05985030f, -0.15078208f, -0.21639752f, 0.18623394f, 0.05732322f, -0.40558743f, 0.02471412f, 
    0.00919852f, -0.06733847f, 0.02669341f, 0.05040341f, -0.06351607f, 0.08995722f, -0.02896885f, -0.83598393f, 
    -0.18233588f, 0.11938368f, -0.07803239f, 0.13524994f, -0.14448316f, -0.17867418f, 0.10709905f, -0.22528881f, 
    -0.11909671f, 0.16322148f, -0.11794195f, -0.04294169f, 0.31187660f, 0.45583785f, 0.02304626f, 0.19380517f, 
    -0.03351627f, 0.13563474f, 0.13168494f, -0.05978395f, -0.15511060f, 0.28914568f, 0.16432920f, -0.01831172f, 
    -0.14472488f, 0.02000635f, -0.24163638f, -0.04928498f, 0.04219016f, -0.03487463f, -0.01912254f, -0.07043911f, 
    0.04809052f, 0.10779819f, -0.10897898f, -0.03591329f, -0.13012263f, 0.34023798f, 0.03297811f, -0.23296523f, 
    0.05078954f, -0.00765582f, 0.07170045f, -0.15994686f, -0.00411042f, 0.03704311f, -0.04770355f, -0.17130628f, 
    -0.71923298f, 0.19587663f, -0.23881771f, 0.32125074f, 0.10715082f, -0.24783620f, 0.24192384f, 0.40141711f, 
    -0.08414952f, 0.09157114f, -0.01106093f, -0.07507070f, -0.09996956f, 0.26956752f, -0.11504305f, 0.35002980f, 
    0.07140694f, -0.03295487f, -0.31839970f, 0.05629550f, -0.17491396f, -0.09015961f, -0.12793377f, -0.20817515f, 
    0.11900587f, 0.03247304f, 0.39186019f, -0.13683151f, -0.27091104f, -0.00798815f, -0.05784418f, 0.18599755f, 
    0.14390449f, -0.14633049f, 0.21723470f, 0.08802011f, -0.14728259f, 0.41579908f, -0.02096825f, -0.12241792f, 
    -0.11892213f, 0.16732880f, 0.15209579f, -0.04582436f, -0.09732184f, 0.15378520f, -0.00310160f, 0.26413491f, 
    -0.11645199f, -0.22780998f, -0.51926196f, 0.29244390f, 0.04392091f, 0.05764190f, -0.13297869f, 0.20371032f, 
    0.21399201f, 0.02887972f, 0.05356783f, 0.10479005f, -0.45790610f, 0.49683779f, -0.46253762f, 0.06181600f, 
    0.13093425f, 0.13323027f, -0.00038914f, -0.07641916f, 0.02161721f, 0.04605104f, -0.18523224f, -0.22498871f, 
    0.18617079f, 0.47872466f, -0.11796073f, 0.02780692f, 0.02578561f, 0.08869480f, 0.03602566f, 0.08242684f, 
    -0.10633960f, 0.11332114f, 0.10394777f, 0.15226978f, -0.10557767f, -0.04666442f, 0.04348001f, 0.19477302f, 
    -0.17533147f, 0.30644044f, 0.27903181f, 0.25053671f, 0.00817569f, 0.19153146f, 0.09902984f, 0.04860034f, 
    -0.06085981f, 0.24016021f, -0.27602932f, -0.08010473f, 0.13253158f, -0.14005217f, -0.21525623f, 0.06522736f, 
    -0.12969083f, -0.06335112f, -0.41265681f, -0.68984920f, -0.00838715f, -0.26206422f, 0.15570289f, 0.07385341f, 
    -0.28238532f, 0.01556091f, 0.25375885f, -0.01530985f, -0.13028744f, 0.05623432f, 0.11350258f, -0.04598647f, 
    -0.41930509f, 0.24238412f, 0.02600704f, -0.12552370f, 0.01829969f, -0.15491682f, 0.01683179f, 0.05054644f, 
    -0.41110730f, 0.04274648f, 0.17851251f, -0.02480127f, -0.55952233f, 0.19338843f, 0.17914715f, -0.12329087f, 
    -0.21437815f, 0.05487628f, -0.30535212f, 0.29036686f, 0.14054331f, -0.12084087f, 0.10971157f, 0.07803790f, 
    -0.72817785f, -0.06098739f, 0.28528836f, 0.25825393f, -0.07857466f, 0.19450988f, 0.31090117f, 0.47471085f, 
    -0.13916069f, 0.01544943f, 0.41624388f, 0.25960401f, -0.44653451f, 0.35705760f, -0.26260644f, -0.19524565f, 
    -0.00936912f, 0.23780413f, 0.13421032f, 0.15923771f, -0.05993449f, -0.03219699f, -0.02700550f, -0.04373691f, 
    -0.01395958f, 0.04807065f, -0.36497346f, 0.32596421f, -0.41572079f, -0.06768139f, 0.16242930f, -0.13072304f, 
    -0.01295763f, 0.12765177f, -0.01667608f, 0.32459262f, 0.30090678f, -0.33329031f, -0.15536956f, 0.05265539f, 
    -0.03454148f, -0.17377917f, 0.06860884f, 0.22381565f, -0.17667952f, 0.16651395f, -0.06223051f, -0.05517322f, 
    0.19861364f, -0.01786951f, 0.40935880f, 0.50751495f, 0.02394330f, 0.00670570f, -0.00764961f, -0.08923580f, 
    -0.19952618f, 0.01682445f, 0.11702261f, 0.10673919f, -0.44968808f, -0.20666464f, -0.54327744f, -0.84279037f, 
    -0.39258260f, -0.28691772f, 0.04476465f, 0.00993614f, 0.08696263f, -0.14342298f, -0.00425099f, 0.01194563f, 
    -0.23396884f, -0.17106004f, 0.43021128f, 0.24630688f, -0.06978031f, -0.08844467f, -0.38982534f, -0.00074545f, 
    0.10087218f, 0.10992471f, 0.11989649f, -0.10251296f, -0.64207304f, -0.03436598f, 0.08761653f, -0.19448353f, 
    -0.14722323f, 0.06788945f, 0.04419876f, -0.22381017f, -0.08757681f, -0.20014386f, 0.01948395f, 0.13100003f, 
    -0.85398829f, 0.22388889f, 0.04856435f, -0.09470983f, 0.04251034f, -0.03950521f, -0.10268841f, 0.20885780f, 
    -0.27621046f, 0.11430626f, -0.10165171f, -0.12108258f, -0.24355780f, -0.19751678f, -0.06649793f, -0.40845603f, 
    -0.05771660f, -0.14481460f, -0.17006737f, -0.06635986f, 0.01451998f, -0.31667730f, -0.11516723f, 0.08086464f, 
    -0.30707178f, 0.26104689f, 0.13339980f, -0.01599059f, 0.21698563f, -0.05674654f, 0.12363820f, 0.13477737f, 
    -0.13631231f, 0.02036734f, 0.18143244f, 0.20118131f, -0.53187132f, -0.50186414f, -0.32043782f, 0.19537242f, 
    -0.30547786f, 0.17141849f, -0.24515803f, -0.06718737f, 0.08432170f, -0.17323178f, -0.05215837f, -0.02419982f, 
    0.30439731f, 0.24328074f, 0.29483771f, -0.25790799f, -0.01390301f, -0.15882392f, 0.15432884f, 0.07328627f, 
    -0.18796407f, 0.03676561f, 0.06833262f, -0.05792345f, -0.00418503f, 0.39176929f, -0.00835059f, -0.19875504f, 
    -0.04014906f, 0.03745696f, 0.04020711f, -0.05702255f, 0.04271864f, -0.18433835f, -0.44822371f, -0.35607916f, 
    0.29642037f, -0.05523495f, 0.28027314f, -0.13461180f, -0.02504327f, 0.10920387f, -0.00691408f, -0.04741284f, 
    -0.06775298f, 0.15597402f, 0.21941450f, 0.01265772f, -0.56269044f, 0.42497095f, -0.16942650f, -0.11617041f, 
    0.00949545f, -0.09484623f, 0.06568603f, -0.02362927f, 0.07765233f, 0.10936466f, -0.03902475f, 0.10092566f, 
    -0.20416218f, -0.23911886f, -0.05851802f, 0.19630256f, 0.09469476f, -0.01707733f, -0.09743981f, -0.02271282f, 
    -0.23608106f, -0.16835651f, 0.04268200f, -0.22964665f, 0.07703016f, -0.86991078f, 0.46962425f, 0.16597572f, 
    0.01909071f, 0.12083122f, 0.19895202f, -0.02527548f, 0.12573820f, -0.06651863f, -0.05708459f, -0.12333318f, 
    0.09743594f, -0.45664689f, 0.46661180f, 0.02218588f, -0.09911099f, -0.49165156f, -0.13630813f, 0.01419956f, 
    0.01073973f, -0.01857992f, 0.12072621f, -0.01844450f, -0.33426076f, -0.11609548f, -0.24920285f, 0.15267383f, 
    0.00042715f, -0.02356980f, 0.17649202f, -0.08842185f, 0.12967308f, -0.03382082f, -0.00915358f, 0.14887409f, 
    -0.01326409f, 0.01904983f, 0.13441910f, 0.19626385f, -0.07853936f, 0.06321523f, 0.16572002f, 0.02724135f, 
    0.01917733f, 0.20134026f, 0.03440222f, 0.04140655f, -0.24877989f, 0.07141749f, 0.15214010f, 0.37251455f, 
    -0.08280816f, -0.09986553f, 0.25392175f, 0.14194858f, -0.24379377f, -0.02211081f, 0.04156685f, 0.02644200f, 
    -0.13989606f, -0.01029624f, -0.21255943f, 0.05183509f, 0.04341463f, 0.17371929f, -0.29427963f, 0.22893220f, 
    0.03459553f, 0.25092304f, 0.17757633f, -0.11961303f, 0.08564639f, -0.10887197f, -0.10638462f, -0.04455300f, 
    0.19755685f, -0.04041301f, 0.15317400f, -0.09894536f, -0.05270918f, -0.01453680f, 0.17085123f, -0.21845090f, 
    -0.53027546f, -0.39712253f, -0.06829768f, -0.20857064f, -0.46381891f, 0.12868363f, -0.21818332f, -0.29614487f, 
    -0.00920142f, 0.03683288f, 0.08880824f, -0.05490072f, -0.46610591f, -0.36466083f, -0.72256547f, 0.68390566f, 
    0.05828057f, -0.20128222f, 0.13505207f, -0.04534800f, -0.17329074f, 0.05167940f, -0.06339920f, 0.28107002f, 
    -0.71356815f, 0.08966168f, -0.33885616f, 0.41049552f, 0.16616918f, -0.15981594f, 0.02329608f, -0.01730710f, 
    -0.23946758f, -0.18848586f, 0.00383927f, -0.10849638f, 0.14599785f, -0.33464444f, 0.38397142f, -0.33600774f, 
    -0.05027381f, -0.25232175f, -0.61115974f, -0.09469446f, 0.01623100f, -0.09609013f, -0.07002574f, -0.21080422f, 
    -0.20108372f, 0.27500165f, -0.39225215f, -0.24963586f, 0.01944834f, -0.20128691f, -0.04369807f, -0.01880658f, 
    -0.01381463f, 0.02723077f, 0.11102866f, 0.06512015f, 0.56105250f, -0.28963259f, 0.48855236f, -0.10592300f, 
    0.22006102f, 0.16935328f, 0.29911840f, -0.05359346f, 0.00134894f, 0.13406454f, -0.00534300f, 0.09499559f, 
    -0.45829985f, 0.52749586f, -0.49816185f, 0.04881680f, 0.03357966f, -0.04759386f, 0.11800759f, -0.26593804f, 
    0.05175272f, -0.02462897f, -0.12688957f, -0.09523652f, 0.05828401f, 0.26544905f, -0.13374899f, 0.03555154f, 
    -0.06724153f, 0.00523601f, 0.01528587f, 0.13754603f, 0.00352657f, 0.04049717f, -0.05388037f, -0.03410600f, 
    0.37118277f, 0.46432319f, -0.11728440f, 0.18928139f, -0.07760960f, 0.27836451f, -0.19572750f, 0.41597059f, 
    -0.29036573f, -0.14142735f, -0.08437330f, -0.19165929f, 0.24795829f, -0.77947384f, 0.19030112f, 0.24809484f, 
    0.23816857f, -0.19447146f, 0.17366813f, 0.11635966f, -0.01900890f, 0.15240759f, 0.27724606f, -0.02069887f, 
    0.59705168f, -0.25443950f, 0.45294458f, 0.16529530f, -0.13391167f, 0.01008274f, -0.06280281f, 0.12364771f, 
    -0.23756444f, -0.04097554f, 0.04432828f, -0.14671357f, -0.23745818f, -0.36612010f, -0.19922730f, -0.34318742f, 
    -0.13749507f, -0.29929557f, 0.20002554f, 0.06283905f, -0.02428201f, 0.12338368f, 0.06961323f, -0.05192496f, 
    -0.62333322f, 0.07013902f, 0.20536445f, -0.01901584f, -0.01491429f, 0.14959002f, 0.08667269f, 0.00788364f, 
    -0.20289476f, -0.19492279f, 0.17206591f, 0.02901752f, 0.12530683f, -0.00603872f, -0.00384615f, -0.06833602f, 
    -0.04667621f, 0.17017505f, -0.02375624f, 0.05139181f, -0.16046032f, -0.04559625f, -0.18059677f, -0.16948533f, 
    0.08460049f, -0.33397377f, 0.14952533f, -0.35520798f, 0.18388595f, -0.28139159f, 0.00906551f, -0.01098766f, 
    0.06230475f, 0.09203056f, -0.07513174f, -0.04771115f, 0.26000127f, -0.28556713f, 0.18333529f, -0.14767212f, 
    0.09516417f, 0.08756255f, 0.19266285f, 0.26237464f, -0.16056320f, 0.29472172f, 0.26854816f, 0.12382662f, 
    0.06376887f, -0.37666562f, 0.06617442f, 0.09956630f, 0.14519779f, 0.03624420f, -0.05377316f, -0.02032683f, 
    0.11134071f, 0.20344277f, 0.00190093f, -0.01651167f, 0.02236826f, 0.21655519f, -0.08329184f, -0.16599615f, 
    -0.06873553f, 0.11112680f, -0.08622698f, 0.07033203f, -0.16233481f, 0.20283225f, 0.15321241f, -0.14095661f, 
    0.21137547f, 0.26080391f, 0.23396306f, 0.26880717f, 0.07460818f, -0.31770000f, 0.04094930f, 0.04264908f, 
    -0.06677227f, -0.20778736f, -0.08279070f, -0.14766940f, -0.33170208f, 0.35772175f, -0.17350842f, -0.03082426f, 
    0.01680722f, -0.16078284f, 0.22947633f, -0.22701325f, 0.04268011f, -0.03986227f, -0.13661201f, -0.09078337f, 
    -0.54764563f, 0.29540098f, -0.43481633f, -0.31237370f, 0.12843166f, 0.01874057f, -0.07700388f, 0.14610854f, 
    -0.03315738f, 0.05571704f, -0.07854722f, 0.01295555f, -0.20525359f, 0.12276138f, -0.38556978f, -0.15260625f, 
    0.16223937f, 0.07581421f, 0.00582056f, 0.00672092f, 0.25593492f, 0.08439556f, 0.12587468f, 0.15339027f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18672423f, 0.09826965f, 0.05837980f, -0.10324520f, -0.15674382f, 0.10724919f, 0.07538415f, -0.17283972f, 
    0.13668731f, 0.06575551f, 0.02675589f, -0.05519141f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
