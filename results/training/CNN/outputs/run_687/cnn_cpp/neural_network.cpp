#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.19927323f, 0.68156672f, -1.21563542f, 0.54839349f, -0.39729428f, -0.05742970f, -0.41260734f, 0.07425920f, 
    0.48798758f, -0.80856687f, -0.81391466f, -0.80348462f, 0.70301408f, 1.28525972f, 0.92294753f, -0.42913538f, 
    -0.14538224f, 0.14897130f, 0.05137206f, 1.15191197f, 1.10056651f, 0.15400037f, 0.67136562f, -0.07799937f, 
    0.30459574f, 0.35776648f, 0.30997068f, 0.79660457f, 0.72590137f, 0.77525663f, 0.16649508f, 0.26148033f, 
    0.79160625f, -0.40384707f, -0.25509161f, -0.45466751f, 1.17425191f, -0.88522452f, -1.14253306f, 0.59974802f, 
    0.08706156f, -0.80598450f, -0.42034638f, 0.28343379f, -0.14670110f, 0.37696010f, 1.49890900f, -0.03388722f, 
    -0.57157981f, 0.84466612f, -0.09792740f, 0.56548136f, -0.08051766f, -0.16559133f, 0.98218191f, 0.51153904f, 
    0.66914487f, 0.20671341f, -1.04691446f, 0.17783622f, 0.75141901f, 0.38586289f, -0.23314376f, 1.16671550f, 
    -0.34240586f, 0.90730822f, 0.74935925f, 0.29766071f, 0.77779764f, -0.43327561f, 0.07070258f, -0.17022237f, 
    1.32964242f, 0.94086009f, 0.67829275f, -0.35534325f, 0.70155859f, -0.44422349f, -0.13936350f, 0.35937726f, 
    -0.39068973f, -0.12309374f, 1.35817099f, -1.13160098f, -0.34646177f, -0.02073644f, -1.13901138f, 0.12038945f, 
    0.17836525f, 0.37421033f, -0.76820487f, -1.28423905f, 0.24135844f, 0.48912087f, 1.01652026f, 0.50558871f, 
    -0.39743531f, 0.02744976f, -0.54047316f, -0.71780354f, -0.84885740f, -0.37866613f, -0.23828606f, 0.00470528f, 
    -0.93402511f, 0.42905414f, 0.31041205f, -0.34926009f, -0.50985199f, 1.33733952f, 0.59769028f, -0.83703780f, 
    0.78705382f, 0.45182961f, -0.07717410f, 0.47607777f, -0.66650289f, 1.20823503f, 0.49966109f, -0.19239454f, 
    -0.42970604f, -0.80370486f, -0.20738596f, -0.45841533f, 0.47611871f, -0.02738135f, 1.18683863f, 0.39465627f, 
    -1.17750216f, -0.74900663f, 0.56173843f, 0.88638854f, -0.09185512f, -0.54175323f, 0.11923706f, 0.37911555f, 
    0.17735559f, 0.68944395f, -1.04222155f, -0.56251752f, -0.43914396f, 0.54804271f, 0.78944772f, -0.20857385f, 
    0.43058446f, -1.18855882f, 1.13280523f, 0.95025051f, 0.58715844f, -0.31510982f, 0.37438211f, 0.55902505f, 
    -0.06217255f, 0.84230381f, -1.02472126f, 0.84349853f, -0.57821572f, -0.86583400f, -0.68328243f, 0.31563428f, 
    -0.17466491f, -0.26137629f, -0.51557797f, -0.67241049f, 1.34871995f, -0.91398686f, 0.78233272f, -0.63521540f, 
    -0.26188487f, 0.01188834f, 0.28569612f, 0.59110796f, -1.12148488f, -1.07954252f, -0.95498484f, -0.31969702f, 
    0.52849317f, -0.43185988f, -0.11163458f, 0.16448288f, -0.36177385f, -0.61905909f, 0.48022100f, -0.56274289f, 
    -0.18891315f, 0.98678029f, -0.28112987f, -0.76032549f, 0.52310520f, -0.49757618f, -1.17719865f, 0.39323848f, 
    -0.80102533f, -0.40119106f, 0.80680746f, 0.52361929f, 0.21773587f, -0.50594330f, -0.14040579f, -0.15430491f, 
    0.35035515f, -0.78035814f, -1.23951256f, 0.03783700f, 0.23156336f, 0.62062615f, 0.00818542f, 0.72794461f, 
    0.33253422f, 0.59364116f, -0.02845524f, -0.68256754f, -0.68252856f, -0.37381592f, -0.61966783f, -0.56633443f, 
    -1.26216865f, 0.85713869f, -0.44030249f, 1.16531885f, -0.60395688f, 0.65427142f, 0.37823340f, -0.24843487f, 
    -0.07364774f, 0.55769086f, 1.13348031f, 0.71578157f, 0.33788177f, -0.81796294f, -0.93436438f, 0.06162688f, 
    -0.22975777f, 0.47055912f, -1.43292642f, 0.37820208f, 0.18917084f, 0.91009170f, 0.18884310f, -1.21918571f, 
    -0.32317540f, -0.02689368f, -0.35933879f, -0.72869384f, -0.71871066f, -0.48919865f, -0.05235850f, -0.26763648f, 
    -0.18807817f, -0.74206513f, 0.62095356f, -0.23018888f, -0.66025120f, -0.41413045f, -0.98002321f, 0.34122723f, 
    -0.99301451f, -0.36956823f, 0.63468635f, -0.01418612f, 0.27185279f, -1.06025743f, -1.15201211f, -1.14979374f, 
    -0.26165918f, 0.54614216f, 0.01729310f, 0.01074497f, -0.21837860f, 0.32694459f, -0.89582115f, -1.35950363f, 
    0.82173598f, 0.78901368f, 0.54480070f, 0.69241291f, 0.06550266f, -0.36507484f, -0.19095252f, 0.07169649f, 
    0.10922238f, 0.44846603f, -1.16174781f, -0.43677008f, -0.38543618f, -0.61488682f, 0.17255186f, -0.31079289f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00201571f, 0.22355013f, 0.34811082f, 0.15051554f, 0.43459642f, -0.03693091f, 0.33787239f, 0.33867645f, 
    0.21462485f, -0.01470698f, 0.02856425f, 0.23849119f, 0.20664676f, -0.07964558f, 0.07444478f, 0.05900647f, 
    0.06606624f, 0.19329928f, 0.00998721f, 0.04197786f, -0.04691466f, 0.06006746f, 0.07508773f, -0.00600209f, 
    -0.03095276f, -0.20806471f, -0.03789170f, 0.13951394f, 0.12248910f, 0.25835773f, -0.07858119f, 0.22352488f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20489958f, -0.30587566f, 0.14354955f, -0.14698689f, 0.33588067f, -0.05018746f, -0.08840846f, -0.05146976f, 
    0.06195002f, -0.03221906f, -0.05738343f, 0.10343112f, -0.07486417f, 0.07835896f, -0.06099322f, 0.15151259f, 
    -0.03842091f, 0.09913894f, -0.11450133f, 0.04189721f, 0.18218933f, 0.26844999f, -0.02427614f, -0.26885027f, 
    -0.34718528f, 0.08137397f, 0.14268747f, -0.13075493f, 0.11299510f, -0.16072088f, 0.07770114f, -0.03715497f, 
    0.01841125f, 0.08354588f, 0.11088613f, 0.09029611f, 0.09567559f, 0.09404150f, 0.01313354f, 0.03947000f, 
    -0.09663019f, 0.01529926f, 0.04059062f, -0.09312524f, 0.25638598f, 0.06485375f, -0.13166414f, 0.04930468f, 
    -0.04165132f, -0.06746666f, -0.00389246f, -0.04408435f, -0.00298654f, -0.06376772f, 0.04350886f, -0.09572408f, 
    -0.05657845f, 0.02044327f, -0.06194537f, -0.05399779f, 0.23189853f, 0.07538240f, -0.08054826f, -0.01236886f, 
    0.27246734f, -0.16562356f, -0.15554878f, -0.06046125f, 0.04044017f, -0.07025260f, 0.07861967f, 0.00565995f, 
    0.05475299f, -0.04130050f, 0.03188008f, 0.15516511f, 0.04502488f, -0.15501875f, -0.00836912f, 0.12171345f, 
    0.15541491f, -0.47504807f, 0.16279271f, 0.10070462f, 0.08990911f, 0.07491940f, -0.05636672f, 0.05078095f, 
    -0.06879369f, -0.07997992f, -0.22565405f, 0.09695420f, 0.07005604f, -0.03933164f, 0.00891839f, -0.09455806f, 
    0.09735122f, -0.02909708f, 0.00370629f, 0.00452935f, 0.22135168f, 0.16448641f, 0.08415885f, -0.21895778f, 
    0.42224002f, -0.08235805f, 0.02708498f, 0.10834149f, 0.00866486f, 0.01416031f, -0.04812192f, -0.06158642f, 
    -0.06724419f, -0.04775029f, 0.18047118f, -0.10196118f, -0.04712665f, 0.06546693f, -0.08599883f, -0.10363563f, 
    0.20074232f, -0.06624631f, -0.03538379f, -0.12229241f, 0.00528886f, -0.10574904f, -0.09249371f, -0.00228720f, 
    0.06660343f, 0.06753442f, 0.03348953f, -0.04552060f, -0.04808493f, 0.02561105f, -0.01253378f, -0.00748870f, 
    -0.06756059f, 0.01728466f, 0.03598726f, 0.04394353f, 0.44248983f, 0.03358262f, -0.00135138f, 0.02226274f, 
    -0.02793229f, 0.00554227f, -0.07900351f, 0.02918258f, 0.04082124f, -0.06566735f, -0.11641593f, 0.02209020f, 
    -0.03489745f, -0.03864884f, -0.01430309f, 0.11067731f, 0.03642172f, -0.06463640f, -0.07667857f, 0.08002447f, 
    0.21359283f, 0.19346312f, -0.05868287f, -0.30286205f, 0.19116902f, -0.11884685f, -0.19500647f, -0.21026017f, 
    0.05034249f, 0.04214407f, 0.00848045f, 0.08340949f, -0.00245232f, -0.04273206f, 0.05590003f, 0.08871029f, 
    0.06253248f, -0.05473743f, -0.02897995f, -0.04438230f, 0.09611003f, -0.09742708f, 0.15599957f, -0.12582482f, 
    0.18051006f, -0.03850507f, 0.07928777f, -0.01564929f, 0.01633045f, 0.14448753f, 0.04111055f, -0.00498832f, 
    -0.02051611f, -0.00106092f, 0.05739244f, -0.06593485f, -0.10474224f, 0.20297740f, -0.03637242f, -0.14304464f, 
    -0.28040320f, 0.28488961f, 0.25378898f, 0.00807839f, -0.30566540f, 0.07133251f, 0.03518031f, 0.09460093f, 
    0.08163663f, -0.06740829f, 0.03830726f, -0.02815090f, -0.02639852f, 0.03500405f, -0.07214891f, -0.01730626f, 
    0.02346156f, -0.04523651f, -0.02760896f, -0.04308423f, -0.46874142f, -0.56612176f, -0.12980749f, 0.14419582f, 
    -0.25145966f, -0.07984862f, -0.12053610f, 0.04158271f, 0.11204569f, -0.02680749f, 0.03182699f, 0.05957697f, 
    -0.12510802f, -0.17141709f, 0.02733771f, -0.04280537f, 0.05398950f, 0.04074987f, 0.03857651f, 0.01970179f, 
    -0.19048366f, 0.09943857f, 0.15759137f, -0.13060054f, 0.43741325f, 0.01641506f, -0.14892386f, 0.03731026f, 
    -0.06686587f, 0.03963357f, -0.10109877f, -0.05730160f, 0.09583389f, -0.09033902f, -0.02072389f, 0.06734015f, 
    -0.00195786f, -0.02472744f, 0.13357824f, -0.10951255f, 0.21766773f, -0.04844264f, 0.13226648f, -0.16885452f, 
    0.12913096f, 0.02222282f, -0.07640222f, -0.25459066f, 0.07087188f, 0.05815729f, -0.04575907f, 0.00295536f, 
    0.00916372f, -0.01044384f, -0.01972936f, -0.09218653f, 0.05728710f, -0.11131289f, 0.14151664f, -0.07547760f, 
    -0.31152749f, 0.11425661f, 0.01064624f, 0.06898307f, 0.32978114f, -0.10510090f, -0.02368986f, -0.10156331f, 
    0.01908520f, -0.02031847f, -0.03932216f, -0.12990031f, 0.13212214f, -0.00606208f, 0.05124214f, -0.03035749f, 
    0.04180833f, -0.10867475f, -0.15079772f, -0.09584994f, 0.05558445f, -0.06859417f, -0.02622565f, 0.18698804f, 
    -0.00279346f, -0.12101533f, 0.01632360f, -0.09954971f, -0.07432538f, -0.04128363f, 0.06087717f, 0.04997233f, 
    0.09400031f, -0.09029379f, -0.04535373f, -0.00333550f, 0.00672410f, -0.05632830f, 0.05056530f, -0.06111781f, 
    -0.12970716f, 0.06493925f, 0.24205798f, -0.01311474f, -0.45236918f, -0.11643198f, -0.13613699f, 0.00852636f, 
    -0.13356279f, -0.08171836f, -0.00641146f, 0.13849549f, 0.03321882f, 0.00326130f, 0.01548200f, -0.02575039f, 
    -0.04836963f, 0.06807658f, -0.12216606f, -0.00462133f, 0.41585195f, -0.35964245f, 0.07610527f, 0.05324538f, 
    -0.28630921f, -0.12278465f, -0.04750815f, 0.01701004f, 0.00534115f, 0.02265071f, -0.18312290f, 0.06786972f, 
    -0.12645045f, -0.03138798f, -0.04779966f, -0.09948391f, -0.13415700f, 0.17041430f, 0.10418588f, 0.08985073f, 
    0.00107573f, -0.38122284f, 0.15443672f, 0.17440344f, -0.31413549f, -0.02863922f, -0.02959162f, 0.14261645f, 
    0.14649923f, -0.08537403f, -0.08113567f, 0.06633414f, -0.05217580f, -0.02201000f, -0.02190029f, 0.05709266f, 
    -0.00091257f, 0.05450802f, 0.13930316f, 0.06828703f, -0.07089972f, -0.22553760f, -0.00158313f, 0.26822615f, 
    -0.30446512f, -0.01982964f, 0.06632645f, 0.05263710f, 0.01379870f, -0.03904672f, -0.06643201f, -0.03074235f, 
    0.13786641f, 0.01997912f, 0.01027840f, -0.12893435f, -0.03434313f, -0.07352830f, -0.01060798f, -0.11993802f, 
    -0.34487498f, 0.12938076f, -0.15726985f, 0.16609368f, -0.15235864f, -0.08286698f, 0.08091418f, -0.07744029f, 
    0.09812467f, -0.04452418f, 0.02794860f, 0.01484516f, -0.02689091f, -0.05751102f, 0.14784181f, -0.01136990f, 
    0.03935223f, -0.03394074f, 0.10210883f, 0.07129560f, -0.22862925f, -0.12585752f, -0.17298555f, 0.07092862f, 
    -0.28421360f, -0.20025653f, 0.10187729f, -0.02817721f, 0.11071863f, 0.15168606f, 0.03861568f, 0.00893656f, 
    0.00112047f, 0.01624317f, 0.06597193f, -0.03260292f, 0.01900067f, -0.09357972f, -0.04289918f, 0.04514883f, 
    -0.21578427f, -0.16953985f, -0.07678547f, 0.08252958f, -0.05582269f, 0.00016170f, 0.02872188f, -0.00464074f, 
    -0.13612811f, 0.01322997f, -0.11806964f, 0.00989762f, 0.06577262f, -0.18331853f, 0.00275043f, -0.07195266f, 
    0.05594277f, -0.18160073f, 0.00901366f, -0.02194762f, 0.17865978f, -0.04037335f, 0.03578444f, -0.09097750f, 
    0.06380769f, -0.07245445f, -0.19556132f, 0.03629679f, 0.07150509f, 0.09784211f, -0.08877914f, -0.02498502f, 
    -0.03853143f, 0.10416183f, -0.06561913f, 0.15086791f, -0.02677698f, 0.14050767f, 0.06278173f, 0.01236248f, 
    0.36383057f, -0.23122774f, 0.23301478f, -0.02945456f, -0.25330105f, -0.02352170f, 0.05374602f, 0.05879573f, 
    -0.05362721f, -0.00550297f, 0.03396177f, -0.06755850f, 0.02841299f, -0.01196929f, 0.21978453f, -0.11000074f, 
    -0.10037216f, 0.01131846f, 0.01391370f, -0.13253218f, 0.01682542f, 0.12061904f, 0.09397748f, -0.30801603f, 
    0.04351832f, -0.27062234f, -0.17597429f, 0.00305417f, -0.02160837f, -0.02403758f, -0.01546886f, -0.04903039f, 
    -0.03312380f, -0.00606109f, -0.02058023f, 0.03859449f, -0.04999482f, 0.05628306f, -0.06220489f, -0.07701994f, 
    0.29692703f, -0.00678348f, 0.32679784f, 0.07668471f, -0.08512218f, -0.02823423f, -0.16284296f, 0.02363183f, 
    -0.09967844f, -0.04866131f, 0.05534178f, 0.00246279f, -0.05363438f, 0.11767308f, -0.10995428f, -0.07183105f, 
    -0.13848509f, -0.03924945f, 0.03745913f, 0.01623487f, -0.16238573f, -0.20313658f, -0.11239490f, -0.13213156f, 
    -0.34134281f, 0.08797405f, -0.03022657f, 0.01099691f, -0.05173720f, 0.12658095f, -0.07036823f, -0.12351435f, 
    0.06548811f, -0.12048443f, 0.02628782f, -0.04730201f, -0.13014212f, 0.01387766f, -0.07218395f, 0.07103736f, 
    0.14228477f, -0.69831884f, -0.15167837f, 0.10300944f, -0.07766365f, -0.00913425f, -0.02024083f, -0.08892019f, 
    0.07138643f, 0.05720704f, 0.10456153f, 0.01198362f, -0.04129876f, -0.06832774f, 0.14330997f, 0.16221799f, 
    0.03505783f, 0.13118696f, -0.04776822f, -0.20197168f, 0.01949951f, 0.26702306f, -0.25191692f, -0.15191235f, 
    -0.44919115f, 0.04707209f, 0.00417756f, 0.13696915f, -0.01425386f, -0.02219872f, -0.03244820f, 0.02702519f, 
    0.02308702f, 0.07209923f, 0.06424458f, -0.03482408f, -0.03684372f, 0.07742420f, -0.08174324f, -0.02591497f, 
    -0.33251068f, 0.28891850f, 0.40018481f, -0.01621292f, -0.30386090f, 0.06058394f, 0.11739147f, 0.09034952f, 
    0.13498403f, -0.04252283f, -0.07879525f, -0.04745677f, -0.03253138f, -0.03495449f, -0.03554571f, -0.04267872f, 
    0.05768647f, -0.12984590f, 0.11886815f, 0.14223546f, 0.16712484f, -0.04304219f, -0.18787903f, 0.12088181f, 
    0.07549483f, -0.00692309f, -0.00226404f, -0.14322299f, 0.04125655f, -0.02680916f, 0.02436529f, -0.08318614f, 
    -0.09781297f, -0.10953176f, -0.01747450f, -0.00282309f, 0.01544433f, 0.05332618f, -0.05470639f, -0.07651164f, 
    0.10578927f, -0.59619987f, 0.11854333f, -0.36305004f, -0.02232549f, -0.00485183f, -0.32077453f, -0.01540243f, 
    0.04455628f, -0.11609586f, -0.11631738f, 0.00100408f, -0.10020951f, -0.09055163f, 0.01459758f, -0.17182246f, 
    0.07031927f, -0.16153882f, 0.07465823f, -0.20347531f, 0.05341352f, 0.03717944f, -0.21790607f, 0.03789869f, 
    -0.24221162f, -0.03561751f, 0.02838633f, -0.08959986f, -0.07031424f, 0.09864442f, 0.06274869f, 0.03017097f, 
    0.04363618f, -0.07262009f, -0.00116949f, 0.07103293f, 0.01083842f, -0.02705462f, -0.01636696f, 0.08664127f, 
    0.09167462f, 0.34401360f, 0.06657042f, -0.00961151f, 0.30392554f, -0.24477288f, 0.02920482f, 0.04440198f, 
    -0.05658663f, 0.11474314f, 0.01305828f, -0.02078870f, 0.09638040f, 0.04417871f, 0.04347922f, 0.05802225f, 
    0.02944257f, 0.01875516f, -0.05420637f, 0.04032860f, 0.15602003f, 0.26922402f, 0.15791303f, 0.15680405f, 
    0.16613205f, 0.02449498f, -0.03416772f, 0.01567902f, 0.04293257f, 0.15397707f, -0.10770418f, -0.04944845f, 
    -0.03699087f, -0.00949956f, -0.07182366f, -0.01574704f, -0.07624487f, 0.12344200f, 0.08432249f, -0.05387682f, 
    0.30318117f, -0.55873686f, 0.03865908f, -0.25678349f, -0.10780840f, 0.00182883f, 0.05262363f, 0.00685846f, 
    0.01871788f, -0.00570324f, -0.06453004f, 0.01852318f, -0.05585739f, 0.02376055f, -0.03998395f, 0.05887109f, 
    0.00565216f, -0.23181796f, 0.02361952f, 0.07212970f, 0.28687680f, 0.22041966f, -0.08312688f, -0.21747665f, 
    0.06709009f, -0.20652382f, -0.06015685f, -0.06055141f, -0.00741752f, 0.00909465f, 0.17676640f, -0.04889452f, 
    0.03647515f, 0.10039750f, -0.08989143f, 0.05537114f, 0.02618155f, -0.03512174f, -0.05638329f, -0.00818960f, 
    -0.12763907f, 0.16866972f, 0.24994136f, 0.05536221f, 0.07878751f, -0.11742347f, -0.05716300f, 0.06199891f, 
    -0.02492180f, 0.00698282f, -0.04057491f, 0.03915973f, 0.13859551f, 0.09916650f, -0.05972076f, -0.00710262f, 
    0.01439283f, -0.07275351f, 0.07942814f, -0.00806197f, 0.32070464f, 0.09137268f, 0.05015457f, 0.02515055f, 
    0.06553848f, -0.01564684f, 0.02162471f, -0.05064124f, -0.01772072f, 0.17772864f, 0.17356339f, 0.03219059f, 
    0.03286314f, -0.09492895f, -0.19229808f, 0.00109904f, 0.06682284f, 0.15001799f, 0.14332743f, 0.05200931f, 
    0.34439796f, 0.13134104f, 0.08194839f, 0.22875445f, 0.36737218f, -0.02217523f, -0.14941302f, 0.07656183f, 
    -0.01021118f, -0.00075033f, 0.02537591f, -0.08707163f, -0.13366137f, 0.10481917f, -0.13555749f, -0.02442254f, 
    0.13767681f, 0.04006174f, -0.03340890f, 0.00802450f, -0.06095856f, -0.09629267f, -0.22139817f, -0.46813980f, 
    0.09553251f, 0.03972517f, -0.09736630f, 0.04762341f, 0.02681497f, 0.06555054f, -0.01057214f, 0.16551858f, 
    0.12852244f, -0.00217728f, 0.31762108f, -0.02894215f, -0.02166451f, -0.23199356f, -0.14322712f, 0.00922944f, 
    0.29666966f, -0.08205431f, -0.21798600f, 0.07650156f, -0.16056095f, -0.00657653f, 0.01027742f, -0.00028910f, 
    -0.13628922f, 0.08391429f, -0.00459320f, 0.14185196f, -0.06144550f, -0.03098261f, -0.02974929f, 0.03534761f, 
    0.01997979f, 0.04042080f, -0.08441290f, 0.13245185f, 0.21823142f, 0.03494965f, -0.39580879f, 0.07419132f, 
    -0.18589289f, 0.06266209f, 0.03036643f, -0.02187393f, -0.01939093f, 0.21178262f, -0.11775430f, -0.15733771f, 
    0.08111928f, 0.16979660f, 0.00982537f, 0.13038093f, 0.09563824f, -0.18672736f, -0.18583585f, -0.04515051f, 
    -0.27210149f, 0.29042035f, -0.15749285f, -0.08736969f, 0.18567377f, -0.03526157f, 0.08984438f, 0.02382967f, 
    -0.02399350f, 0.05994607f, 0.12205477f, -0.00378461f, 0.02181367f, 0.17477137f, -0.14221232f, 0.03192252f, 
    -0.07636075f, 0.13976426f, -0.21629468f, 0.08012816f, 0.14833106f, -0.11979695f, -0.00149937f, -0.01783996f, 
    -0.00528419f, 0.10998864f, -0.12148213f, 0.12130733f, 0.04569801f, -0.09356673f, -0.02014517f, -0.10613012f, 
    -0.07862455f, 0.07331914f, 0.01513729f, 0.06022798f, -0.10305088f, -0.08144576f, -0.06909706f, -0.02042460f, 
    0.46667057f, -0.32127610f, 0.20120476f, -0.15986468f, -0.16265137f, -0.12421539f, -0.04435444f, -0.05802408f, 
    0.12087873f, -0.09241238f, -0.02726492f, 0.08326048f, -0.23914589f, 0.12941378f, -0.00079759f, -0.12657723f, 
    -0.04557651f, 0.08682372f, 0.00259504f, -0.04622912f, -0.25379384f, -0.15643698f, -0.11863458f, 0.05755289f, 
    -0.12600610f, 0.00965332f, -0.00528217f, 0.03991598f, 0.02081300f, -0.03572806f, 0.03755671f, 0.02286903f, 
    -0.06942302f, 0.04735975f, -0.06118388f, -0.00759704f, -0.01704510f, -0.05110386f, -0.09384342f, 0.04559182f, 
    0.15987752f, -0.22316927f, 0.12930210f, -0.08651842f, -0.02665324f, -0.18323702f, 0.04271113f, 0.02796353f, 
    0.15798230f, 0.10694238f, -0.05899932f, -0.28811172f, -0.06913506f, -0.12721823f, 0.04870362f, -0.00729527f, 
    0.13761152f, -0.04069649f, 0.09304798f, 0.07166743f, -0.08352286f, -0.00594903f, -0.02733168f, -0.14651401f, 
    -0.21901220f, 0.08874933f, 0.06297489f, 0.00465632f, -0.03560588f, -0.09289070f, 0.13670036f, 0.07856144f, 
    0.11501121f, 0.05802180f, 0.12122351f, -0.09219170f, -0.00782539f, -0.26205000f, -0.07480768f, -0.06363002f, 
    -0.59307384f, -0.06911951f, -0.10278100f, -0.17846917f, 0.10201689f, -0.12239295f, 0.07989533f, -0.11355504f, 
    -0.08666345f, 0.01158100f, 0.19935501f, -0.04246412f, 0.05519033f, -0.03154342f, -0.06348485f, -0.17073008f, 
    0.01193895f, -0.12086044f, -0.10159940f, 0.00038584f, 0.00842879f, -0.49114341f, 0.03675824f, -0.23064752f, 
    0.08701034f, -0.23350042f, -0.02492311f, 0.02459529f, 0.08965318f, 0.09270227f, -0.08796954f, 0.07069210f, 
    -0.00506498f, -0.03022632f, -0.09207799f, -0.02198719f, -0.17255801f, 0.04934706f, -0.03198891f, -0.12084916f, 
    -0.12320185f, 0.23502111f, -0.04029610f, -0.23510924f, -0.28364435f, -0.06804716f, -0.10387039f, -0.22440597f, 
    -0.08424343f, 0.10142851f, 0.04933759f, 0.04506221f, -0.06676672f, -0.02187652f, -0.03260422f, 0.06085143f, 
    -0.16050947f, 0.11575493f, 0.10633355f, -0.03576908f, -0.26606739f, 0.02840483f, -0.02823378f, 0.10829055f, 
    -0.19465181f, -0.01117482f, -0.08828279f, -0.03009127f, 0.15883635f, -0.06254314f, -0.14664657f, -0.14125581f, 
    0.03159557f, 0.06026847f, -0.15172169f, 0.03385299f, 0.00787788f, -0.00164393f, -0.01530854f, -0.04315897f, 
    -0.51344216f, -0.09390199f, 0.08181728f, -0.03792299f, -0.21636924f, -0.08958113f, -0.09229124f, -0.04942201f, 
    0.12961777f, -0.10308654f, -0.07760613f, 0.11404442f, -0.04789324f, 0.10311235f, -0.09513996f, 0.00862824f, 
    -0.14308231f, 0.06496002f, 0.01273963f, -0.06231094f, 0.00982029f, 0.07387565f, -0.05612352f, -0.06791057f, 
    -0.00958197f, -0.09469613f, -0.06387169f, 0.05661666f, 0.04520683f, -0.03333702f, -0.08600907f, -0.18423373f, 
    0.04144672f, -0.05644283f, 0.05895544f, -0.08759807f, -0.06304533f, -0.23004107f, -0.06760696f, 0.07309529f, 
    -0.37133521f, 0.14196226f, -0.12824896f, -0.08033178f, 0.12865938f, 0.07559074f, -0.07099795f, -0.04849681f, 
    -0.11983832f, -0.04221767f, 0.20700905f, 0.20559213f, -0.08260894f, -0.00801386f, -0.02734400f, -0.00316503f, 
    0.01076953f, 0.04624917f, 0.03345586f, 0.15402105f, 0.03641912f, -0.13641392f, 0.08566334f, 0.14582624f, 
    0.26786634f, 0.03267744f, -0.05079436f, 0.05779919f, 0.01943535f, -0.01747663f, -0.03751570f, -0.01059843f, 
    0.11130366f, 0.04939914f, 0.10021072f, -0.01820696f, -0.01912537f, -0.14893843f, 0.02012478f, -0.05724612f, 
    -0.44136649f, -0.19198728f, -0.26250580f, -0.06882708f, 0.01615519f, 0.14520398f, -0.06261072f, 0.05030225f, 
    0.09189641f, 0.07010003f, -0.02260470f, 0.10410309f, 0.00136346f, -0.12891187f, 0.04613874f, 0.07319471f, 
    -0.03219717f, 0.04566877f, -0.02498687f, 0.09965427f, 0.22121407f, -0.03961482f, -0.08241722f, -0.07879456f, 
    0.01957280f, -0.03406353f, -0.05327412f, 0.04438457f, 0.01031897f, 0.12549001f, 0.08848574f, 0.08031555f, 
    0.11847027f, 0.03407885f, -0.15274954f, -0.02783539f, 0.15297316f, -0.02353808f, -0.12671980f, 0.15450189f, 
    -0.02038123f, 0.19859141f, -0.02851065f, -0.07353956f, 0.03405060f, 0.21671489f, -0.00538302f, 0.08153039f, 
    -0.02354461f, -0.01100871f, 0.04443275f, -0.11190399f, 0.07474888f, 0.09351751f, -0.13933381f, -0.01718611f, 
    0.16326374f, -0.34596375f, 0.01833798f, -0.02910789f, 0.41938400f, 0.00524057f, -0.04112703f, 0.21256223f, 
    -0.17134048f, 0.03331520f, 0.05976360f, 0.06567957f, 0.09652693f, 0.11884695f, 0.03326461f, -0.02443936f, 
    -0.11408906f, 0.00814389f, 0.02506429f, 0.08387388f, 0.06374333f, -0.02804672f, -0.05621516f, -0.09907034f, 
    0.05034754f, 0.15652531f, -0.25892472f, 0.13882586f, -0.32920268f, -0.06056277f, 0.08486700f, -0.09098108f, 
    -0.08102781f, 0.19009693f, -0.01573519f, 0.08757265f, -0.15076925f, 0.04600211f, 0.15206838f, 0.04754206f, 
    0.11724397f, 0.06784128f, -0.07170280f, -0.00944075f, -0.09333789f, 0.00496324f, -0.20349981f, -0.05827501f, 
    -0.13838165f, 0.01618152f, 0.06843836f, 0.02513161f, -0.01005996f, 0.00540535f, -0.12199742f, -0.05046906f, 
    -0.04373700f, 0.10414377f, -0.03957157f, 0.02259040f, -0.07986552f, -0.09330263f, -0.02318734f, 0.14255497f, 
    -0.00420052f, -0.29483646f, 0.01965354f, -0.25098354f, -0.24953888f, -0.00316970f, -0.15739943f, 0.16786113f, 
    0.03788390f, 0.04593235f, -0.17947945f, -0.05708353f, -0.01171641f, -0.10177656f, -0.04624278f, 0.14162119f, 
    0.02363820f, 0.10119706f, 0.02255871f, -0.09596437f, 0.32137704f, 0.05244153f, 0.16026297f, 0.19649126f, 
    0.26706490f, -0.11611294f, -0.22538161f, -0.10372063f, 0.12699509f, 0.09369385f, 0.06130913f, -0.02019741f, 
    -0.04222462f, 0.01232208f, -0.03093841f, -0.07218498f, -0.11034604f, -0.03379722f, 0.01111309f, -0.13115038f, 
    0.20227812f, 0.06385397f, -0.07688241f, 0.06733102f, -0.00454554f, 0.02810609f, 0.09770376f, 0.06395523f, 
    -0.04796613f, -0.10032182f, -0.02657798f, 0.05075900f, -0.00801500f, 0.02057450f, 0.00281419f, -0.02326902f, 
    -0.10166315f, -0.09360234f, -0.03398106f, 0.01204705f, -0.19849992f, 0.04400632f, -0.10201913f, -0.13633955f, 
    0.06510574f, 0.16953571f, -0.08985312f, 0.07966777f, 0.03458399f, -0.03702371f, -0.08030085f, -0.00493644f, 
    -0.00180794f, 0.03429082f, -0.01882915f, -0.08773523f, -0.06008902f, -0.00671136f, -0.13748118f, 0.02536457f, 
    -0.24828264f, -0.44011012f, 0.10774886f, -0.32291284f, -0.22745048f, -0.04777519f, -0.10188184f, 0.08980010f, 
    0.08170338f, 0.06797425f, 0.02457837f, -0.07650498f, -0.04251228f, 0.02192994f, -0.00260049f, 0.05632995f, 
    -0.02198724f, 0.04914285f, 0.01603158f, -0.08514670f, 0.21298122f, 0.02827752f, 0.09407026f, -0.22148205f, 
    0.10149357f, 0.07368816f, -0.06927980f, 0.09295943f, -0.06535368f, -0.02729789f, -0.13216668f, -0.04590892f, 
    0.12929246f, 0.03663711f, 0.01726137f, -0.04582243f, -0.05906335f, 0.05155450f, 0.00218439f, -0.06079290f, 
    -0.22971946f, 0.06170862f, 0.04111408f, -0.04695437f, 0.08561707f, 0.05183425f, 0.02469462f, 0.05873458f, 
    -0.02480290f, -0.05792498f, -0.03037101f, 0.01856829f, 0.00980515f, -0.01893494f, 0.09311125f, 0.01677477f, 
    -0.08775219f, -0.08500522f, -0.03831926f, -0.05124782f, -0.32958239f, 0.08311634f, 0.10407982f, -0.14388309f, 
    -0.00220610f, 0.05468442f, -0.04470324f, 0.07424626f, 0.06487732f, 0.01531720f, -0.11595310f, -0.07281642f, 
    0.01410758f, 0.00421080f, 0.08578019f, -0.08138399f, -0.10654420f, -0.04201392f, -0.02581979f, 0.02983225f, 
    0.00584336f, 0.13923573f, -0.01238422f, -0.26791790f, 0.19874302f, 0.15648219f, 0.03791603f, 0.09401649f, 
    0.05658641f, -0.11691974f, -0.03214942f, 0.04648953f, -0.02054742f, -0.10210785f, -0.03952556f, 0.00163363f, 
    -0.00119418f, 0.00557994f, -0.07460835f, -0.05876098f, -0.08207401f, -0.05573437f, -0.27193388f, -0.51391709f, 
    -0.31947288f, 0.14253685f, -0.09582335f, 0.09445996f, -0.04748509f, -0.04911920f, -0.05004778f, -0.02515124f, 
    -0.03223386f, -0.17560586f, 0.01654148f, 0.05557106f, -0.07127983f, 0.21608709f, 0.05336719f, -0.06813715f, 
    0.22534811f, -0.05309329f, 0.09816141f, 0.05019834f, 0.17383072f, -0.14993292f, -0.09976386f, -0.04218312f, 
    0.03262022f, 0.11144591f, 0.04271932f, -0.06242192f, -0.06295585f, 0.01156220f, 0.01328298f, -0.01849316f, 
    -0.06760377f, -0.06658821f, -0.06598537f, 0.01579769f, 0.34899560f, -0.56002963f, 0.11652181f, -0.06636579f, 
    -0.16330269f, -0.10122938f, -0.03391225f, -0.11293736f, 0.03013962f, 0.02281364f, 0.06868587f, -0.00936395f, 
    -0.02796182f, -0.04356468f, -0.02437580f, 0.06152934f, -0.01148432f, 0.08871760f, 0.13426614f, -0.06594824f, 
    0.23544838f, 0.11009018f, -0.26570213f, -0.12096880f, -0.01926845f, 0.08285491f, 0.06881069f, 0.05662435f, 
    -0.07317333f, -0.04102075f, -0.08612374f, -0.08125009f, 0.11413944f, -0.01253910f, -0.00150709f, -0.02062331f, 
    -0.09665485f, -0.14116040f, -0.11419548f, 0.02917523f, -0.34167355f, 0.15689091f, 0.02012544f, -0.21491961f, 
    0.00341420f, 0.06572421f, 0.10367690f, 0.14273494f, 0.02884364f, 0.01852524f, 0.01381450f, 0.02471607f, 
    -0.00732265f, -0.11075523f, -0.05546527f, 0.10136566f, -0.00894963f, -0.01386868f, 0.03727066f, -0.01981189f, 
    0.06232693f, -0.06745261f, -0.24283803f, 0.12109572f, -0.24438097f, 0.03213841f, -0.14615980f, 0.11851324f, 
    0.15220937f, 0.10280992f, -0.05300769f, 0.06092323f, 0.04027158f, 0.04755783f, -0.06317738f, -0.09539448f, 
    0.05739452f, -0.02803817f, 0.06320235f, -0.01063318f, 0.07606525f, 0.11703555f, 0.06995001f, -0.07697169f, 
    -0.06755500f, -0.00341953f, 0.10167125f, 0.07862315f, -0.08043411f, -0.04806333f, 0.04359185f, -0.06199091f, 
    0.04442494f, 0.00823187f, -0.00160223f, 0.07724240f, 0.04615574f, -0.08376693f, 0.04927931f, -0.04054324f, 
    0.20334587f, -0.31909040f, 0.16506515f, -0.05767465f, -0.01815207f, -0.02809566f, 0.09400340f, 0.01324420f, 
    0.07904470f, -0.10691217f, 0.05317477f, -0.01232185f, 0.05824119f, -0.06438444f, 0.05472897f, 0.06867031f, 
    -0.06422780f, 0.06890026f, 0.10508513f, 0.01788251f, -0.63294274f, 0.13128923f, -0.19095153f, -0.17377862f, 
    0.00505317f, -0.02989896f, 0.20678809f, -0.01155678f, 0.01777861f, -0.16388264f, 0.06998605f, -0.15107027f, 
    -0.01981492f, -0.06811241f, -0.05793409f, -0.02473806f, 0.04330865f, 0.03851307f, 0.06389477f, -0.09445371f, 
    0.47248083f, -0.03199615f, -0.37890792f, 0.00876824f, -0.34402826f, -0.20373341f, 0.02559224f, 0.07151662f, 
    0.04754949f, -0.02040348f, 0.03887581f, -0.10018624f, -0.10468321f, 0.01499208f, -0.00348471f, 0.04111763f, 
    0.01785509f, 0.01838794f, 0.12116157f, -0.12195126f, 0.52205992f, -0.35994285f, -0.29583764f, 0.24588129f, 
    -0.47309437f, -0.01566233f, -0.06591716f, 0.15113275f, 0.09744635f, 0.00763970f, 0.03415117f, 0.00838754f, 
    0.03078480f, 0.04626133f, -0.05528604f, -0.06416378f, -0.00685238f, 0.13908254f, 0.06471615f, 0.04164622f, 
    0.19674766f, -0.00631169f, -0.27199826f, 0.17468981f, -0.20680168f, -0.07458035f, 0.01028895f, -0.05750803f, 
    -0.04948322f, 0.02600521f, 0.04137438f, 0.00408828f, 0.08917886f, -0.05887331f, -0.01967490f, -0.05563583f, 
    -0.06546902f, -0.08422247f, 0.03540834f, -0.00780751f, 0.21588977f, -0.09592787f, -0.09024002f, 0.05555405f, 
    -0.17905179f, -0.10804054f, 0.04691856f, 0.02530254f, -0.06807614f, -0.06430158f, 0.02022654f, -0.00667471f, 
    -0.00787337f, -0.04099787f, 0.01038651f, 0.07080256f, -0.13795590f, 0.04100075f, 0.07168555f, -0.07677604f, 
    0.02323363f, -0.00897641f, 0.02882525f, -0.09413064f, -0.17122091f, -0.02006969f, 0.09580954f, 0.07819546f, 
    0.06905109f, 0.03256307f, 0.02254719f, 0.00469348f, 0.11834471f, -0.11497150f, -0.08672711f, 0.00464316f, 
    0.03273885f, -0.01262754f, 0.03437207f, -0.08126169f, -0.15266967f, -0.14302561f, -0.01827678f, -0.08064400f, 
    0.06534510f, 0.15860893f, 0.13327880f, 0.06027925f, -0.02602651f, -0.05589191f, -0.07315101f, -0.00998567f, 
    -0.03317532f, -0.12334303f, -0.06386326f, -0.02524793f, 0.05049735f, 0.00429033f, -0.09963192f, -0.05604558f, 
    0.08879265f, 0.23366389f, 0.09587523f, 0.07009461f, 0.16467349f, -0.04298975f, -0.00717927f, -0.00000499f, 
    -0.00068239f, 0.04707649f, -0.06130974f, 0.00215268f, -0.03758732f, 0.07280730f, -0.02181217f, 0.05158141f, 
    0.06935065f, 0.02138942f, 0.03177960f, 0.01349763f, 0.06525090f, -0.01804535f, 0.05855941f, -0.07901654f, 
    0.00985027f, 0.13224253f, 0.13394712f, 0.08604248f, -0.10765779f, -0.09089401f, -0.03476866f, 0.11145187f, 
    0.00658003f, -0.03151219f, -0.03392214f, 0.06246331f, -0.04046848f, 0.02783422f, -0.20817718f, 0.03676115f, 
    0.49313244f, -0.35709614f, -0.08002128f, -0.06330165f, 0.01358699f, 0.03888236f, -0.00071150f, -0.02505020f, 
    0.09503256f, 0.07923755f, -0.03883663f, 0.03411601f, -0.09184190f, 0.11547308f, 0.03916725f, -0.00765527f, 
    -0.06985863f, -0.06935243f, 0.06793057f, -0.00221797f, 0.05138576f, -0.21743666f, 0.11275820f, -0.15418915f, 
    0.02219416f, -0.07866731f, -0.07832561f, -0.10342836f, 0.03006285f, 0.00615608f, 0.03954978f, 0.04191179f, 
    -0.02646959f, 0.03080811f, 0.00796872f, -0.04822050f, -0.00316844f, 0.02307059f, -0.01342650f, -0.04953429f, 
    -0.29824337f, -0.07650239f, 0.03673229f, -0.07392418f, -0.06132605f, -0.01620870f, -0.16616844f, -0.18621761f, 
    -0.00320298f, 0.10078318f, -0.06222543f, -0.00014076f, 0.05910243f, -0.08118062f, 0.02471637f, -0.03838755f, 
    0.02160266f, 0.12497014f, 0.02206994f, 0.08952586f, 0.23635536f, -0.27799186f, 0.05788789f, 0.08781022f, 
    0.21751507f, -0.21152653f, -0.05269630f, -0.26549530f, 0.01092500f, 0.09767197f, 0.11737504f, -0.07808181f, 
    0.04272777f, 0.02902488f, 0.00361007f, -0.08249622f, -0.12515503f, 0.04871839f, 0.01595947f, 0.07677211f, 
    0.21668969f, -0.00205084f, 0.05247789f, 0.04381210f, 0.14812078f, -0.22770680f, -0.10058175f, -0.01808709f, 
    0.05392890f, 0.04405478f, 0.09660508f, -0.07444634f, 0.00544954f, -0.11966857f, 0.06479745f, 0.05553811f, 
    -0.15172535f, -0.12292270f, 0.03809439f, 0.03118717f, 0.06690229f, 0.10350529f, -0.29409650f, -0.10590492f, 
    -0.01993953f, -0.05220409f, 0.09110313f, -0.02653391f, -0.05081154f, -0.01531036f, -0.06233200f, 0.03006507f, 
    -0.09551220f, -0.06330428f, -0.02756174f, -0.02286974f, 0.12370985f, -0.01387511f, -0.05590472f, 0.01876177f, 
    0.17976260f, -0.02679815f, -0.02111373f, 0.08706194f, 0.03697600f, -0.00861340f, -0.01016403f, -0.03317435f, 
    0.05105309f, 0.07378049f, 0.02295097f, 0.00188666f, -0.09836389f, -0.00911660f, 0.13060200f, -0.02552644f, 
    -0.00540768f, -0.00060904f, -0.09760854f, 0.08869905f, -0.07545058f, -0.11834513f, -0.13632336f, -0.14417091f, 
    -0.25469059f, -0.00336383f, -0.20142114f, 0.11729024f, -0.12827356f, -0.03605823f, -0.15326786f, 0.08010525f, 
    0.00435129f, -0.10740764f, 0.12734389f, 0.01601194f, 0.00053884f, 0.04577179f, 0.08719741f, 0.00180120f, 
    -0.13625300f, -0.28167138f, 0.04532669f, -0.00885338f, -0.04990458f, -0.13697352f, -0.10167595f, 0.07881787f, 
    0.07809194f, -0.09220060f, -0.03484264f, 0.09290931f, -0.07138363f, -0.03513385f, 0.04686533f, -0.03748965f, 
    0.00065562f, -0.11633265f, 0.04009543f, -0.04201230f, -0.34886086f, -0.59571522f, -0.16596426f, -0.14707580f, 
    -0.07599053f, -0.07114690f, -0.05748816f, 0.03107767f, -0.01091357f, -0.13691437f, -0.04453655f, -0.00639450f, 
    0.15863214f, 0.06738964f, 0.08834098f, 0.03021471f, -0.10033963f, -0.07617652f, -0.04479193f, 0.04749014f, 
    0.11592357f, 0.16143191f, 0.12671407f, 0.10561424f, -0.15490422f, -0.05454093f, 0.10897990f, -0.03784851f, 
    -0.00949376f, -0.02219289f, -0.08640230f, 0.01939773f, -0.01406232f, -0.00081628f, -0.05560032f, 0.04840085f, 
    -0.05052697f, 0.06619877f, -0.02269559f, -0.01583843f, -0.44216070f, -0.12279405f, -0.06782919f, -0.17158549f, 
    0.11348454f, -0.10724652f, -0.02210912f, -0.08677848f, 0.11350854f, -0.03987992f, 0.01403223f, 0.04356001f, 
    0.05307315f, -0.08794723f, -0.03740046f, -0.11098571f, 0.05129125f, -0.17227831f, 0.02579468f, -0.01669819f, 
    0.06602251f, -0.52095324f, -0.58455938f, 0.20958266f, 0.10691132f, -0.00158506f, -0.02161209f, 0.04516434f, 
    0.00215401f, -0.03016451f, -0.03639293f, 0.04682271f, -0.05681052f, -0.26760921f, 0.09838236f, -0.09691935f, 
    -0.08377232f, 0.11676198f, -0.01227777f, -0.14036001f, -0.19877352f, -0.36499640f, -0.31394324f, -0.14225723f, 
    -0.19916260f, -0.12390137f, 0.02246689f, 0.00016347f, 0.01640086f, -0.14072460f, -0.09927770f, -0.00150228f, 
    0.00900287f, -0.05943966f, 0.02555616f, 0.03386403f, -0.05784455f, 0.00924982f, -0.02380000f, -0.00247900f, 
    -0.57079911f, -0.11720800f, -0.53522754f, -0.00191569f, 0.12322232f, -0.15879183f, 0.03533598f, 0.02041163f, 
    0.00269687f, 0.02359289f, -0.10899334f, -0.01539511f, 0.07441008f, -0.02070082f, -0.02524956f, -0.04960682f, 
    -0.00073321f, -0.05796211f, -0.00101902f, 0.10894393f, 0.51140636f, 0.18884540f, -0.00917905f, -0.01584678f, 
    0.07740504f, -0.00443103f, 0.05106422f, 0.12827216f, 0.09845262f, 0.01741076f, -0.06681692f, -0.03448606f, 
    -0.07608793f, -0.01745829f, -0.04783342f, -0.02004723f, -0.04969078f, 0.15414451f, 0.13060778f, 0.15895088f, 
    -0.00066017f, -0.11836319f, 0.06613570f, -0.19278644f, -0.16363256f, -0.05975723f, -0.11277108f, -0.08560552f, 
    -0.03041657f, -0.01645594f, 0.01314979f, -0.07091441f, 0.05135277f, -0.07477693f, 0.04252950f, 0.01723651f, 
    0.00370822f, 0.02507548f, 0.14146325f, 0.15895937f, -0.16642754f, 0.11311591f, 0.11240732f, 0.01444300f, 
    0.03468116f, -0.06465465f, -0.06547638f, -0.07334123f, 0.01177809f, 0.04066042f, -0.04581424f, 0.05184627f, 
    0.04024446f, -0.05584895f, -0.04153280f, -0.15210903f, -0.01297429f, 0.08030678f, 0.05041676f, -0.13613307f, 
    -0.61035693f, 0.16104406f, 0.08271072f, -0.10926662f, 0.12548292f, 0.01787239f, 0.00187496f, -0.01828140f, 
    0.07337689f, -0.08014807f, -0.00478278f, 0.07550081f, -0.05673480f, 0.03972161f, 0.00973063f, -0.07440587f, 
    0.02375369f, -0.33035415f, 0.16961335f, 0.00937553f, 0.11579254f, -0.23765862f, -0.01605294f, 0.10637825f, 
    0.17282112f, 0.02095287f, 0.00715001f, -0.00811010f, 0.04295331f, 0.00355617f, 0.07640512f, 0.00648819f, 
    -0.11018824f, -0.00169410f, -0.01162295f, 0.02978021f, 0.01152569f, 0.04387483f, 0.00975112f, 0.04232368f, 
    0.09807929f, -0.29948923f, 0.00457962f, -0.05920315f, 0.02875767f, -0.15911950f, 0.01703078f, 0.06045872f, 
    -0.04726896f, 0.05100501f, -0.06585621f, 0.05236781f, -0.04789401f, 0.01529605f, 0.02038486f, -0.02853642f, 
    0.01837982f, -0.01576304f, 0.00090511f, -0.02127567f, -0.26462200f, 0.14819260f, -0.02028368f, 0.20794547f, 
    0.22421403f, 0.11830516f, 0.14717542f, 0.09834000f, 0.03640575f, 0.02747220f, 0.04364309f, -0.02173187f, 
    -0.01478610f, -0.21174130f, -0.04002730f, 0.00640892f, 0.00382630f, 0.03401893f, 0.00394771f, -0.17487961f, 
    -0.27660632f, -0.20683543f, -0.08458057f, -0.00362381f, -0.02104856f, 0.10090111f, 0.04234977f, -0.15756051f, 
    0.01319156f, -0.14995417f, -0.04218698f, 0.03863239f, -0.04106822f, 0.00428232f, -0.00022480f, 0.06619772f, 
    0.01059211f, -0.01777103f, 0.01408523f, 0.01533581f, 0.01663876f, 0.10746296f, 0.02571594f, 0.24427737f, 
    0.16750766f, 0.11414241f, 0.21760346f, 0.07950213f, 0.04714118f, 0.12456765f, 0.03725474f, 0.08945557f, 
    -0.12708732f, -0.14981358f, -0.14807090f, 0.02596193f, 0.00685610f, 0.16235933f, 0.10608064f, -0.07776117f, 
    -0.31688493f, 0.37946683f, 0.14730754f, 0.19778709f, 0.07118232f, 0.01630448f, 0.01046649f, 0.13908413f, 
    0.02639743f, -0.06210016f, -0.07197874f, -0.06285159f, -0.04739003f, 0.08629704f, -0.13592616f, 0.05740704f, 
    -0.07884584f, 0.02291376f, 0.11621182f, 0.04094566f, 0.14284745f, 0.14819992f, 0.15405479f, 0.16549836f, 
    0.00562994f, -0.02116636f, -0.04190067f, 0.00791114f, -0.09181298f, -0.03368150f, -0.03002205f, 0.03931152f, 
    -0.04096007f, -0.05845442f, 0.03955913f, -0.03260751f, 0.01094912f, 0.04224522f, 0.09426535f, 0.08960162f, 
    0.17404613f, -0.08667636f, 0.11987135f, 0.12060553f, -0.01982123f, 0.05359075f, -0.02180529f, 0.00118580f, 
    -0.09103774f, -0.07553086f, -0.15319227f, 0.03662726f, -0.07339759f, 0.01185139f, 0.08731680f, 0.00476173f, 
    0.08817948f, 0.02342288f, -0.12767340f, -0.00745881f, 0.20662905f, -0.05199365f, 0.29471904f, 0.01277892f, 
    0.05357493f, -0.07048161f, 0.07519253f, -0.04313263f, -0.16077548f, -0.13091227f, -0.05233893f, -0.01380179f, 
    -0.02239028f, 0.02791739f, 0.02584978f, -0.01241058f, 0.00190167f, -0.09037613f, 0.06267993f, -0.11497513f, 
    0.00719524f, 0.05826553f, 0.14521801f, 0.30603543f, 0.11570875f, 0.05828106f, 0.08855963f, -0.05100381f, 
    -0.06605229f, 0.07285246f, -0.02349672f, 0.00172457f, -0.07052255f, -0.04726565f, -0.06902335f, 0.04141894f, 
    -0.02745176f, -0.04248990f, 0.10259054f, -0.11487739f, -0.00806745f, -0.30129087f, -0.20662788f, 0.06939101f, 
    0.07187705f, 0.02940489f, 0.09728600f, 0.01531241f, -0.05358427f, 0.06579769f, 0.04392629f, 0.03040668f, 
    -0.08430804f, 0.01154947f, -0.07391027f, 0.04081514f, 0.18341185f, 0.13536285f, -0.00155253f, -0.01959596f, 
    0.08067081f, 0.32830960f, -0.22994612f, -0.02027361f, -0.02414002f, -0.03103032f, -0.02865876f, 0.04006193f, 
    0.05175500f, -0.07507164f, -0.03543156f, -0.12628248f, -0.01878437f, 0.00796844f, 0.00246868f, -0.00774095f, 
    -0.02287233f, -0.00055023f, 0.06019629f, 0.00211282f, 0.31618893f, -0.28040102f, -0.20623535f, 0.17862934f, 
    0.05277317f, 0.09085303f, 0.06516767f, 0.04744757f, -0.02844493f, -0.08889988f, 0.09845796f, 0.00094352f, 
    -0.15694025f, 0.02263242f, -0.10229255f, 0.03408004f, 0.06459628f, 0.09186837f, 0.02735710f, -0.05909831f, 
    0.46997207f, 0.09256993f, -0.03509049f, 0.17474252f, 0.00590756f, 0.06772409f, -0.10232400f, -0.09408128f, 
    0.11290704f, -0.00071849f, 0.01079553f, 0.02770964f, 0.00520665f, -0.00406550f, -0.01985295f, -0.09561832f, 
    -0.01108544f, -0.01043690f, 0.04088249f, -0.04089864f, -0.04079427f, 0.07032804f, -0.03806182f, 0.08431113f, 
    -0.03143413f, -0.11641124f, -0.05735117f, -0.12356519f, 0.03712781f, -0.04000051f, -0.11954236f, -0.05123715f, 
    0.03318286f, 0.07977622f, 0.02760190f, 0.01694906f, -0.02558967f, 0.10480799f, -0.01651324f, -0.02104908f, 
    0.22148162f, 0.31395587f, -0.21882410f, -0.00885263f, 0.05551155f, -0.07692724f, 0.01508957f, -0.01048844f, 
    0.01690245f, -0.02453467f, -0.06295490f, -0.05626373f, -0.03152005f, -0.04768676f, 0.06152458f, -0.02429896f, 
    -0.10486139f, 0.20470017f, -0.15726802f, -0.03026378f, 0.01849975f, 0.03699751f, -0.12161043f, 0.00731467f, 
    -0.08205997f, -0.08375661f, -0.24856260f, 0.07555694f, -0.05883264f, -0.00595826f, -0.11615992f, -0.02357585f, 
    -0.08253029f, -0.04854492f, 0.08502471f, -0.10116082f, -0.07317062f, 0.12274219f, 0.03206785f, -0.01151552f, 
    0.21960829f, -0.26661131f, 0.07765884f, -0.26084927f, -0.14614914f, -0.08696608f, -0.19453587f, -0.19493440f, 
    -0.06973833f, -0.01215423f, 0.06174622f, -0.07374692f, 0.12058251f, -0.08827157f, -0.00727684f, 0.03229443f, 
    0.08089818f, -0.03548542f, 0.00257018f, 0.05099115f, -0.21673511f, 0.30570903f, 0.06832145f, 0.19251534f, 
    0.17681445f, 0.10375465f, 0.14268740f, 0.01163896f, -0.06456553f, -0.01770092f, 0.07237586f, -0.06604923f, 
    -0.00348761f, 0.06033156f, -0.14065419f, 0.05738406f, -0.07349333f, 0.02304208f, 0.00753129f, -0.00121754f, 
    0.15854941f, -0.10420847f, -0.32845461f, 0.16489522f, -0.48808631f, -0.04042213f, 0.09001519f, 0.06306379f, 
    -0.09912347f, -0.04039390f, -0.12092434f, -0.00892773f, 0.16055371f, -0.15229121f, 0.03284143f, -0.05851596f, 
    0.01269586f, -0.07772160f, 0.02631061f, -0.05543849f, -0.69699228f, -0.13483769f, 0.07844733f, 0.12476288f, 
    0.20772754f, 0.10678223f, -0.06476693f, 0.07601837f, -0.00152704f, 0.16471663f, -0.03261688f, 0.01340495f, 
    0.09832562f, 0.08542978f, 0.02002309f, 0.03258875f, 0.06979366f, 0.10259848f, 0.10839288f, -0.14762616f, 
    -0.38183224f, 0.14969240f, -0.17126359f, -0.04459888f, 0.09518345f, -0.04204779f, -0.07938524f, 0.05467701f, 
    0.09928190f, 0.00137341f, -0.03976847f, 0.08254246f, -0.03203094f, 0.05671001f, 0.01016146f, 0.12296881f, 
    0.13918315f, -0.15730463f, 0.00911975f, -0.00631990f, 0.23698878f, 0.02449472f, 0.14536399f, -0.10265630f, 
    -0.07377647f, 0.04036998f, -0.01832360f, -0.01038289f, 0.03977367f, 0.03126257f, 0.09657954f, 0.00775256f, 
    0.09957643f, -0.00368635f, -0.08138938f, -0.02160610f, 0.06084993f, -0.03640797f, 0.01040233f, 0.08148116f, 
    -0.09751283f, 0.43153861f, -0.05672924f, 0.20397078f, -0.30543336f, -0.05976393f, 0.00421329f, 0.06383707f, 
    0.06539448f, -0.16637929f, 0.00204878f, -0.11151499f, -0.02721695f, 0.11262269f, 0.03984778f, 0.00779318f, 
    -0.11307149f, -0.01323796f, -0.00845066f, 0.13714512f, -0.44052032f, -0.23585114f, 0.05516734f, 0.08555336f, 
    0.04765466f, -0.01082931f, -0.02365371f, 0.14021008f, 0.00009022f, 0.02618399f, 0.07547634f, 0.01683425f, 
    -0.18796714f, 0.00430440f, -0.04289738f, 0.02004305f, 0.14163603f, -0.07334226f, -0.00789149f, 0.04687483f, 
    -0.20463115f, -0.26599303f, 0.08790620f, 0.10241447f, 0.07722173f, -0.18136960f, 0.02946412f, -0.14175703f, 
    -0.13300119f, 0.05566520f, 0.09393103f, -0.05583981f, -0.01509069f, -0.04232740f, 0.04256643f, 0.02357691f, 
    -0.11110987f, -0.05160004f, -0.06543476f, 0.00718918f, -0.15689538f, 0.19006966f, 0.04021232f, -0.17563128f, 
    -0.03597198f, 0.07382281f, 0.04064391f, -0.04322204f, 0.02268458f, -0.02391896f, 0.06386504f, 0.06215226f, 
    0.10334732f, 0.07237716f, -0.06591251f, 0.05081704f, 0.01934704f, -0.09564751f, -0.06275347f, -0.00952439f, 
    -0.06188346f, 0.03076550f, 0.33956751f, -0.05530259f, -0.16048867f, 0.01426350f, -0.04766843f, 0.01830736f, 
    0.06627788f, 0.05759091f, 0.15504713f, -0.00528800f, 0.05744765f, -0.18802924f, 0.03277640f, 0.03338498f, 
    0.00170743f, -0.13543046f, -0.04970931f, -0.00020650f, 0.05102990f, -0.22361362f, 0.10225531f, -0.05923813f, 
    -0.29659280f, -0.07245271f, 0.03303914f, -0.03179418f, -0.09334864f, -0.19323856f, 0.02279568f, -0.15512341f, 
    -0.01928561f, -0.06378547f, 0.12982385f, -0.14379713f, 0.12160181f, -0.01322760f, -0.07607253f, -0.00578083f, 
    -0.38105437f, 0.01212898f, -0.05377507f, -0.02689632f, 0.16960140f, -0.02362333f, 0.03648548f, -0.06677655f, 
    0.06476896f, 0.02070983f, 0.01274836f, -0.00883195f, 0.03790192f, 0.10807323f, 0.03497829f, -0.00190257f, 
    0.12075641f, 0.10891329f, 0.02241938f, -0.06853753f, -0.12800334f, 0.07194135f, 0.04632740f, -0.10752989f, 
    0.00513366f, 0.07173078f, 0.13928506f, -0.04180116f, 0.10323726f, 0.04341055f, -0.00103098f, -0.00743488f, 
    0.00133121f, 0.01473709f, 0.01760969f, -0.03490130f, -0.08998174f, -0.05842636f, 0.02348824f, 0.05929452f, 
    0.15723409f, 0.18008626f, 0.06779230f, 0.11777928f, -0.05117781f, -0.05943496f, -0.05852862f, 0.15390840f, 
    -0.09342228f, 0.03781515f, -0.04821819f, -0.04940464f, -0.14114767f, -0.03321557f, -0.00668705f, -0.07909576f, 
    -0.03781897f, -0.03713100f, -0.14565022f, -0.14176121f, -0.12466267f, -0.24363150f, 0.09380214f, 0.25096333f, 
    -0.12741590f, -0.28760940f, 0.09428527f, 0.10169777f, -0.02453130f, 0.01522804f, 0.07804737f, 0.06737203f, 
    0.06141146f, -0.11086313f, 0.01720285f, -0.01615012f, 0.03488715f, 0.03466787f, 0.00878012f, -0.00887038f, 
    0.41272962f, -0.07773453f, -0.00560777f, -0.19297892f, -0.16830476f, -0.02010000f, 0.00245595f, -0.01135623f, 
    -0.10975391f, 0.13276416f, 0.01176395f, 0.00360221f, 0.07223032f, -0.05658650f, 0.11631162f, 0.04343420f, 
    -0.07954469f, 0.09789947f, 0.04723908f, 0.03696520f, -0.31717381f, -0.39532739f, 0.18653300f, 0.12809467f, 
    0.06869129f, -0.11622559f, -0.05270736f, 0.01322299f, -0.15407456f, -0.04911134f, -0.08300716f, 0.00391468f, 
    0.03251516f, 0.04196052f, 0.09751310f, -0.09470344f, -0.14561833f, 0.03643521f, -0.05508610f, -0.05973382f, 
    -0.33947080f, 0.37316400f, -0.08929839f, -0.42141691f, -0.01635305f, 0.14827976f, -0.12889753f, -0.03171903f, 
    -0.02345735f, -0.18355820f, -0.04673988f, -0.07208133f, -0.08726821f, 0.06013839f, 0.02453616f, -0.00099529f, 
    -0.07739326f, -0.01528468f, -0.02680668f, -0.11833502f, -0.20596834f, -0.23999192f, 0.30158308f, 0.19675775f, 
    -0.10572718f, 0.06213984f, -0.02679695f, -0.00772748f, -0.03990099f, 0.04592278f, 0.12519091f, 0.04318028f, 
    -0.09056524f, -0.11314507f, 0.03314826f, 0.02007749f, -0.00238632f, 0.14500470f, 0.12882832f, 0.10748646f, 
    -0.36841619f, 0.04411566f, -0.02769130f, -0.19015144f, -0.08880011f, -0.00557213f, -0.09835660f, -0.06302019f, 
    0.02254392f, 0.04759663f, -0.04767843f, -0.11370759f, -0.00520601f, 0.05417959f, -0.03709327f, 0.03590700f, 
    0.07555791f, 0.02076991f, -0.04634774f, -0.01936436f, -0.15720811f, 0.30782983f, -0.28674179f, 0.05834592f, 
    -0.07713755f, 0.10481696f, -0.18216966f, -0.10418815f, -0.00705733f, 0.05324322f, -0.03001906f, 0.03127462f, 
    -0.06298231f, 0.02307546f, 0.06570886f, 0.09405299f, -0.03727923f, 0.10864960f, 0.02382555f, -0.10950348f, 
    -0.03490252f, -0.08784331f, 0.06582952f, -0.05058123f, 0.16805246f, -0.06351414f, 0.02520931f, 0.00402686f, 
    0.06373268f, -0.07134331f, -0.05408702f, -0.04533846f, -0.03262968f, 0.03401668f, 0.02523158f, -0.21203394f, 
    -0.04995002f, -0.12211597f, -0.07725988f, -0.11235580f, -0.15111418f, -0.07769852f, -0.05090518f, -0.08244198f, 
    0.20082684f, 0.08032621f, 0.05878777f, -0.05885402f, 0.02858849f, 0.10410264f, 0.04921682f, 0.17875712f, 
    0.01488225f, -0.08570024f, -0.13594611f, -0.00279805f, 0.05783483f, -0.12800008f, 0.12428913f, -0.09527750f, 
    -0.01853443f, -0.39432821f, -0.05158341f, 0.17574440f, 0.14799815f, -0.12721385f, 0.07691634f, 0.01032745f, 
    -0.04786023f, -0.07635067f, 0.11286068f, 0.04712730f, 0.02078302f, 0.05166699f, 0.02466130f, -0.08918385f, 
    -0.07554629f, 0.05925946f, -0.05539460f, 0.02765262f, 0.06393178f, 0.14155330f, 0.18921798f, 0.16726059f, 
    -0.03346175f, -0.02951554f, 0.06959846f, -0.01309127f, -0.01163174f, -0.05791913f, 0.14622024f, 0.05739994f, 
    -0.01195116f, 0.02634673f, 0.02696886f, 0.01618625f, 0.03036594f, 0.06407732f, 0.03788898f, 0.12924178f, 
    0.46626320f, 0.05374407f, -0.23312810f, 0.11303999f, 0.16980295f, 0.09583262f, -0.01572830f, 0.03377742f, 
    0.04148474f, -0.12664913f, -0.08644086f, -0.08966170f, 0.18027928f, -0.11266775f, -0.17729880f, 0.08265665f, 
    -0.04328937f, -0.11333868f, 0.04124964f, 0.00954247f, -0.28898442f, -0.02785778f, 0.18195696f, 0.13714367f, 
    0.02905414f, -0.09896309f, 0.06898667f, -0.14666843f, 0.06655807f, 0.03325912f, -0.07987362f, -0.02434431f, 
    -0.07517845f, 0.09400021f, -0.07796503f, -0.19816728f, 0.01511652f, -0.00993105f, 0.06219991f, 0.08938444f, 
    0.17479870f, 0.26731291f, -0.18910319f, -0.39631650f, -0.21840020f, -0.06049155f, 0.04894153f, -0.04618614f, 
    -0.00750334f, -0.05519748f, 0.01562347f, 0.02934123f, -0.05335003f, 0.09209021f, 0.08982861f, -0.08237137f, 
    0.07924630f, 0.03136894f, -0.02317169f, 0.01755050f, -0.06860713f, 0.12889020f, 0.15246101f, -0.03249088f, 
    0.13246772f, 0.11462949f, 0.10737608f, -0.12062421f, 0.16672769f, 0.00943707f, 0.01338382f, -0.01397579f, 
    -0.01979622f, 0.06463375f, -0.00101833f, -0.04596545f, -0.05934362f, -0.09018211f, 0.13169831f, 0.03583113f, 
    0.06700880f, 0.00538769f, 0.07164987f, 0.00451419f, 0.12588935f, 0.12429754f, 0.00126391f, -0.02088940f, 
    0.10213196f, -0.08305419f, 0.05533164f, -0.06354335f, 0.11232458f, 0.01564731f, 0.06977958f, -0.00848703f, 
    -0.07134949f, 0.02268271f, -0.10511727f, 0.12523772f, -0.34245113f, -0.07030926f, -0.03466102f, 0.07757072f, 
    0.16566473f, 0.10824676f, 0.01254881f, -0.10456058f, 0.13870238f, 0.05921054f, 0.07792348f, -0.03583673f, 
    0.10456362f, -0.02086872f, -0.05532711f, 0.02843213f, -0.04121459f, 0.02552484f, 0.12219970f, -0.08986334f, 
    -0.20036308f, 0.07349034f, -0.30191466f, -0.20177172f, 0.23856644f, 0.01746540f, 0.10934241f, 0.01741634f, 
    0.11951279f, -0.09457465f, 0.09845658f, -0.11948627f, -0.04658633f, 0.03841460f, 0.01948844f, -0.03365444f, 
    0.11994993f, -0.11142498f, 0.01201084f, -0.08307839f, -0.09628363f, -0.03897739f, 0.08386472f, 0.17806292f, 
    0.03553855f, -0.03986168f, -0.02738223f, 0.11021577f, -0.09189881f, -0.01227758f, 0.04031140f, 0.09085187f, 
    0.11747493f, 0.04857279f, -0.00359951f, 0.04110852f, -0.10769810f, 0.05166156f, 0.00275673f, -0.01840921f, 
    -0.02838511f, 0.34629065f, 0.02891815f, -0.11174434f, 0.01900953f, -0.08740705f, -0.08306203f, -0.03231677f, 
    -0.12686133f, 0.08677679f, 0.07762595f, 0.02760973f, -0.03211213f, -0.08731876f, -0.16810191f, -0.01286617f, 
    -0.14991371f, -0.10473906f, 0.09686188f, 0.14711303f, -0.29453138f, 0.20282573f, -0.18925571f, -0.20741290f, 
    -0.00928805f, 0.04671028f, 0.05551116f, 0.12403473f, -0.11039700f, -0.28524858f, 0.09914204f, 0.03785692f, 
    0.01655234f, -0.14967921f, 0.00323453f, 0.06681006f, 0.02598802f, 0.01128033f, 0.10284537f, 0.11901110f, 
    -0.14975908f, -0.12770173f, 0.10027413f, 0.15457144f, -0.46764046f, 0.04895478f, 0.03552496f, 0.01968649f, 
    0.07300065f, 0.01950443f, 0.00665705f, 0.02689954f, -0.00657060f, 0.02145271f, 0.01168879f, 0.00832034f, 
    0.03973370f, 0.07480831f, 0.05967239f, 0.06936555f, 0.17060177f, 0.13559996f, 0.18137817f, 0.04038198f, 
    -0.09121106f, -0.09643582f, -0.00991648f, -0.03444820f, -0.05998808f, 0.03757541f, 0.05149309f, 0.03413933f, 
    0.02467747f, 0.05509871f, 0.03336944f, 0.02275897f, -0.03832043f, 0.21777734f, 0.00306306f, 0.00405839f, 
    -0.08787031f, -0.18021607f, -0.11225610f, 0.00590350f, 0.15197895f, -0.00080087f, -0.07181174f, -0.05184036f, 
    -0.08968665f, 0.15524317f, 0.15026271f, 0.01248098f, 0.14974508f, -0.00846626f, -0.00991644f, -0.22911158f, 
    0.02336031f, -0.12113716f, 0.06310210f, -0.17898875f, 0.01880326f, -0.03961756f, 0.03984376f, 0.17579286f, 
    -0.17567532f, -0.05652803f, -0.12315602f, -0.12241520f, -0.11679446f, 0.13889596f, 0.01330911f, -0.07022214f, 
    0.07287142f, -0.02058426f, 0.00623018f, 0.05342030f, -0.13589871f, -0.05647671f, 0.17546080f, 0.07451873f, 
    0.10922801f, 0.05536602f, -0.01821112f, 0.21719496f, -0.03361224f, 0.06659575f, 0.05344285f, -0.09945921f, 
    0.09023621f, 0.03836242f, 0.00384440f, -0.06510329f, 0.00012876f, 0.01233795f, 0.07350617f, -0.01146524f, 
    0.11934732f, 0.11124871f, -0.02020410f, -0.02919202f, -0.01859809f, 0.16376936f, 0.24667841f, 0.10784589f, 
    -0.01876734f, 0.00113105f, -0.07694969f, 0.02704044f, -0.15596412f, -0.05101695f, 0.00500119f, -0.07020732f, 
    -0.14118682f, 0.01242018f, -0.01532953f, 0.01422495f, -0.06333236f, 0.05941707f, -0.01609086f, 0.04136070f, 
    -0.09244993f, -0.12851775f, 0.03974061f, 0.17065591f, 0.13457406f, -0.06518588f, 0.04808398f, 0.04840389f, 
    0.00907361f, -0.07511185f, -0.03404545f, -0.04281803f, 0.06711796f, 0.01443242f, 0.00224762f, -0.06905740f, 
    -0.11941578f, 0.15666631f, 0.03365288f, 0.04865539f, -0.09466781f, -0.00890861f, 0.22350967f, 0.32496777f, 
    -0.12282420f, -0.22329293f, -0.01272549f, 0.11547677f, -0.14386405f, 0.16859916f, 0.16853161f, -0.20798248f, 
    -0.04488564f, 0.02528531f, -0.31667113f, -0.00683513f, 0.00043396f, -0.41137439f, 0.13661210f, 0.00928449f, 
    -0.19263734f, 0.40640229f, -0.11808130f, -0.08536635f, -0.14386730f, 0.05888066f, -0.03666304f, 0.10027621f, 
    -0.06319842f, -0.13469645f, 0.07996722f, -0.03161462f, -0.00578492f, -0.10949121f, -0.03015296f, 0.06163254f, 
    -0.01122470f, -0.00151890f, 0.10395706f, -0.01036100f, -0.22279963f, -0.04217256f, -0.01515214f, -0.05753751f, 
    0.16482930f, 0.07891603f, 0.01303087f, 0.12771642f, 0.00801151f, -0.05975996f, -0.01566657f, 0.08111928f, 
    0.09463898f, 0.08888476f, 0.09329249f, 0.00335983f, 0.07866184f, 0.01841326f, -0.13048780f, -0.05307175f, 
    -0.04877179f, -0.06350161f, -0.03557503f, 0.10402240f, -0.40624669f, -0.21054038f, 0.01131954f, -0.10353617f, 
    0.02294337f, -0.06145458f, 0.15347876f, 0.14157373f, -0.02131574f, 0.07530674f, 0.04578220f, -0.02851604f, 
    -0.06025890f, 0.03397783f, 0.12616891f, -0.04226289f, 0.08452427f, 0.09361000f, -0.02938607f, 0.05812331f, 
    0.13084784f, 0.00461529f, -0.17011361f, 0.05430073f, -0.00578673f, -0.03800012f, -0.06372014f, -0.03742429f, 
    0.07204349f, 0.07677896f, 0.05623306f, 0.00544596f, -0.10681217f, -0.03823768f, 0.00263803f, -0.04101976f, 
    -0.01832554f, -0.01990086f, 0.05045796f, -0.04869192f, 0.24120258f, -0.04275353f, -0.06797492f, -0.00563756f, 
    -0.15051888f, 0.06721202f, -0.02262169f, -0.05639976f, 0.01273117f, 0.03913115f, -0.16839966f, -0.02998424f, 
    -0.02603589f, 0.10505860f, -0.01887563f, -0.00040220f, 0.18445458f, 0.09315953f, -0.05681946f, -0.03364882f, 
    0.15497848f, -0.12424397f, -0.11062472f, 0.00246014f, 0.08959150f, 0.17425272f, -0.06927279f, -0.16982821f, 
    -0.07680522f, 0.07484016f, 0.20741983f, 0.02833628f, 0.08826587f, -0.01642254f, -0.07962835f, 0.04184395f, 
    -0.46140122f, 0.22058921f, 0.15475446f, 0.31735605f, 0.02491773f, -0.09166970f, 0.03750256f, 0.08366122f, 
    0.09095874f, 0.13848625f, 0.14280888f, 0.00013766f, 0.06694800f, -0.04263816f, -0.10395966f, 0.08887473f, 
    0.16249521f, -0.05830463f, 0.04024999f, -0.07102182f, 0.01648752f, 0.02124741f, -0.08046614f, 0.25426883f, 
    0.22859366f, -0.08981775f, 0.00211993f, -0.05524779f, 0.18037213f, 0.02783057f, 0.01419823f, -0.08439977f, 
    0.13549300f, 0.08379692f, 0.10797779f, 0.04750210f, 0.04807220f, -0.14592582f, -0.21328753f, -0.24327914f, 
    0.13031459f, 0.11998390f, -0.16105314f, -0.01401960f, -0.31970543f, 0.15170406f, 0.01151992f, -0.05976207f, 
    -0.04667771f, -0.05343997f, -0.15373279f, 0.05021264f, 0.05273634f, 0.03599275f, 0.12040543f, 0.04743099f, 
    -0.08109191f, 0.05941836f, -0.11140229f, -0.00143487f, -0.23128241f, -0.34897247f, -0.06299673f, -0.14067088f, 
    0.03392485f, 0.09253006f, 0.19377472f, -0.08989862f, -0.03504905f, 0.04576068f, 0.11246100f, 0.03883256f, 
    0.01171362f, -0.00323156f, -0.05044067f, -0.12317270f, 0.06288335f, -0.10032330f, -0.11391774f, 0.10208378f, 
    -0.10083603f, -0.33000714f, -0.19231787f, 0.00986501f, 0.13807540f, 0.07299019f, 0.13926286f, 0.09344391f, 
    0.01456700f, -0.00710991f, -0.00676409f, -0.01650657f, 0.03605033f, 0.04053203f, -0.15307730f, 0.06482173f, 
    -0.09786724f, 0.07840260f, -0.14593188f, 0.14451264f, -0.28414121f, -0.11391235f, -0.06685599f, -0.07873172f, 
    -0.12225500f, 0.08489065f, -0.11359183f, 0.03330860f, 0.06025696f, 0.07624201f, 0.04530986f, -0.01260206f, 
    -0.08154562f, 0.02826467f, 0.00059558f, 0.02827758f, -0.13408001f, 0.07011355f, -0.36868963f, 0.06072982f, 
    0.17901286f, 0.07282452f, -0.05409633f, 0.13298392f, 0.17957878f, -0.07879484f, -0.09549779f, -0.04742165f, 
    0.08093003f, 0.13550986f, -0.00807961f, -0.25153786f, -0.05321075f, 0.22458334f, 0.11264694f, -0.01887267f, 
    0.13154487f, 0.00743799f, -0.18282248f, 0.00895639f, 0.02412911f, -0.13293904f, -0.01930558f, 0.09087852f, 
    0.21282586f, 0.06877327f, -0.05973935f, -0.03350268f, 0.03106569f, 0.00686789f, 0.00437500f, 0.07798143f, 
    0.07267573f, 0.10134996f, 0.12674670f, -0.09824251f, -0.02129119f, 0.01481356f, 0.02015137f, -0.07662678f, 
    -0.27610147f, -0.12712970f, 0.18482122f, -0.10351174f, -0.19072039f, 0.03639455f, 0.05821370f, 0.03460315f, 
    0.01308997f, 0.13034226f, 0.06523944f, -0.01886447f, -0.10338624f, -0.07871063f, -0.17954420f, 0.02319738f, 
    0.12366886f, 0.06944251f, -0.08236884f, 0.01506273f, 0.03642822f, -0.00773367f, -0.07229872f, 0.19057021f, 
    0.01797934f, -0.04409878f, -0.06725619f, 0.12936321f, -0.06329294f, 0.07280514f, -0.01244612f, 0.01448742f, 
    -0.01922816f, 0.02925779f, 0.09706157f, 0.10548078f, 0.01299364f, -0.06193396f, 0.19626923f, 0.06391568f, 
    -0.29326296f, -0.02901147f, 0.29472899f, -0.04427625f, -0.27482453f, -0.00233956f, -0.01313119f, 0.11986839f, 
    -0.08759345f, -0.12846979f, -0.06368335f, 0.01867657f, 0.06185846f, -0.19382375f, 0.09820394f, -0.09630412f, 
    0.01655342f, 0.06196670f, 0.17554404f, -0.06869769f, -0.25019059f, 0.06199242f, -0.22811668f, 0.01652580f, 
    0.00792484f, 0.08003571f, 0.11203580f, 0.13442850f, -0.04010073f, -0.02649544f, -0.11390042f, 0.11027033f, 
    0.00357590f, -0.09064973f, 0.09596137f, -0.04690453f, 0.02094539f, -0.04114944f, -0.03219389f, -0.27835894f, 
    -0.33536458f, -0.16933277f, -0.07563998f, 0.04138136f, 0.01562539f, -0.02827132f, 0.09339503f, -0.08954975f, 
    -0.10494360f, 0.12704112f, -0.00308224f, 0.21665803f, 0.00701929f, -0.00482621f, -0.02944067f, 0.08990718f, 
    0.02868987f, -0.17683685f, -0.06693536f, -0.04662580f, -0.97014475f, -0.17966092f, -0.37750268f, -0.29922467f, 
    -0.03818619f, 0.13680324f, 0.16012701f, 0.02189384f, -0.02674389f, -0.10908800f, 0.02978140f, 0.13287145f, 
    0.13054430f, -0.03714842f, 0.00718175f, 0.04544570f, 0.04454393f, -0.18260966f, -0.14024916f, 0.02537656f, 
    -0.56738842f, 0.14518255f, -0.16341487f, -0.00401951f, -0.31808108f, 0.09540844f, -0.04898948f, 0.06431298f, 
    -0.15710603f, -0.12975308f, 0.03874937f, -0.04158213f, -0.03639975f, -0.04045315f, -0.10458203f, 0.05357803f, 
    -0.13402535f, 0.10300694f, 0.06100417f, -0.07092168f, 0.13395776f, 0.05156218f, 0.13942575f, -0.10113289f, 
    0.06049009f, -0.00378044f, -0.02692177f, 0.02874781f, 0.06978678f, 0.09013181f, -0.06757404f, -0.07203034f, 
    0.04115231f, 0.03199995f, 0.14960566f, -0.15746184f, -0.03464817f, -0.06358547f, 0.03341398f, -0.02525377f, 
    0.19080999f, -0.01644227f, -0.18431655f, 0.22079086f, -0.04099923f, -0.10743405f, 0.17428449f, -0.09130956f, 
    -0.02915755f, 0.10141987f, 0.12914738f, -0.02027139f, 0.06785032f, 0.05639175f, 0.04517443f, -0.08501337f, 
    0.07219786f, 0.07770317f, -0.06518789f, 0.03901151f, 0.07042662f, -0.56004852f, -0.03943729f, -0.34779242f, 
    0.03770899f, -0.02054285f, 0.00225252f, -0.05504735f, 0.01555338f, 0.02097231f, -0.00418824f, -0.03242983f, 
    -0.04507076f, 0.14063995f, 0.02556535f, 0.00642280f, 0.01317728f, -0.12879212f, -0.17327647f, -0.03120740f, 
    0.21279262f, 0.07803669f, 0.13510373f, 0.16324422f, -0.04205650f, 0.02302546f, -0.19840993f, -0.00417690f, 
    -0.00528445f, 0.03235829f, 0.02112692f, 0.01196605f, -0.04200511f, -0.08135772f, -0.11259284f, -0.08612747f, 
    -0.07129794f, -0.04081724f, -0.18756925f, -0.08304494f, -0.32075885f, 0.17208628f, 0.05069439f, 0.22238307f, 
    -0.00969406f, -0.06342947f, -0.04908101f, 0.04431357f, 0.12379238f, -0.02110877f, -0.13228497f, 0.02285382f, 
    -0.02794907f, 0.08519422f, 0.15427102f, 0.07329910f, 0.05755007f, -0.20678528f, -0.03630298f, -0.15322958f, 
    -0.10422096f, -0.30093515f, -0.10634228f, -0.15388589f, 0.24472219f, -0.08012488f, -0.01368220f, -0.01895515f, 
    -0.00023973f, -0.06993089f, -0.00226836f, -0.08815769f, -0.13474379f, -0.03785777f, -0.04433345f, 0.06673970f, 
    -0.03029889f, 0.09508964f, -0.03905835f, 0.17561434f, -0.48155698f, 0.33584598f, 0.02115190f, 0.22591779f, 
    -0.36480853f, 0.19080502f, 0.06162528f, 0.11549544f, 0.12110158f, -0.20298906f, -0.00436325f, 0.03496873f, 
    0.00411341f, -0.02301066f, -0.04041510f, -0.00734641f, -0.00966210f, -0.00334890f, -0.02665479f, -0.18963259f, 
    -0.13234995f, 0.26385164f, -0.03203818f, 0.02642399f, 0.00707940f, -0.05111610f, -0.00407427f, 0.06883819f, 
    -0.01580184f, -0.13092194f, -0.08878469f, 0.06557163f, -0.04487692f, -0.05423690f, -0.09265513f, 0.04109952f, 
    0.00499189f, 0.10235462f, -0.02840699f, 0.04690659f, -0.17699453f, -0.05011756f, 0.03126625f, 0.16747236f, 
    0.36275864f, -0.11922601f, 0.02003952f, -0.09196128f, 0.10508960f, 0.03403293f, -0.21034506f, 0.00724266f, 
    0.03461494f, 0.13021296f, 0.13393001f, -0.08741327f, -0.01549199f, -0.08333424f, -0.09533647f, -0.15838407f, 
    -0.23970890f, 0.22642320f, 0.17930534f, 0.13404591f, -0.50269800f, -0.03564233f, -0.05549213f, 0.00582514f, 
    -0.01432044f, 0.05791510f, -0.04940604f, -0.02497882f, 0.04506950f, 0.00865716f, -0.04207240f, 0.07343467f, 
    -0.05155517f, -0.06435215f, -0.02386486f, -0.11700697f, -0.21259244f, -0.02274976f, 0.02229390f, 0.31584597f, 
    0.09490146f, 0.25092658f, 0.04090806f, -0.18732560f, 0.03432633f, -0.00503394f, -0.22754435f, 0.10429335f, 
    -0.01160605f, 0.09507128f, -0.03562623f, 0.13098247f, -0.01943806f, 0.20924935f, 0.07424204f, 0.06504818f, 
    0.13861001f, -0.53785402f, -0.00254682f, -0.06354940f, -0.01137691f, 0.00818795f, 0.06900122f, -0.00724882f, 
    0.01530466f, -0.04780988f, -0.02328579f, 0.04865525f, 0.07095399f, 0.08099487f, 0.00256083f, 0.05563805f, 
    0.05306765f, -0.09684595f, -0.19491729f, -0.04239476f, 0.04712646f, 0.13078870f, -0.23064086f, -0.30444112f, 
    0.03155056f, 0.11113154f, 0.05769817f, -0.01631379f, -0.11807629f, -0.14604394f, -0.00770436f, 0.02316816f, 
    -0.00954222f, -0.10407744f, -0.05214064f, -0.14275591f, -0.12559712f, 0.10203195f, -0.01732066f, 0.14744358f, 
    -0.01759402f, -0.13687216f, 0.11458930f, 0.01471934f, -0.14346719f, 0.17620885f, -0.09314793f, 0.06011890f, 
    -0.03172325f, 0.02760382f, -0.07525336f, -0.04271587f, 0.09074089f, 0.02710242f, -0.14900649f, -0.06414096f, 
    0.04923083f, -0.02653652f, 0.03926295f, -0.02200922f, 0.02376948f, 0.10404660f, -0.00931411f, -0.08065708f, 
    -0.28379497f, -0.05499418f, 0.07379524f, -0.02879980f, 0.06072005f, 0.02126501f, -0.06281901f, -0.06189675f, 
    0.08246691f, 0.06213354f, -0.05306893f, 0.01763646f, 0.08720821f, 0.15614806f, -0.00159599f, 0.13638967f, 
    -0.40143195f, 0.17487814f, -0.13907495f, 0.27895513f, 0.00302759f, 0.14683090f, -0.06025951f, 0.03078556f, 
    0.08479019f, -0.10596976f, 0.02651086f, -0.08284708f, -0.01267371f, 0.03070106f, -0.20695016f, 0.10227529f, 
    -0.01028394f, -0.17985286f, 0.01068295f, 0.06206216f, -0.08451867f, 0.19587409f, 0.06882313f, -0.00792348f, 
    -0.11979004f, 0.08710423f, 0.08684441f, -0.08347060f, -0.03225027f, 0.00767322f, -0.01286278f, 0.01062600f, 
    -0.00160305f, -0.05108151f, -0.20034438f, 0.01123323f, 0.00615959f, 0.13206844f, -0.07227913f, -0.05771357f, 
    0.16141464f, -0.37152180f, -0.19102138f, 0.23873334f, 0.37237287f, -0.01530608f, 0.00049732f, -0.04095070f, 
    -0.03144437f, 0.06526329f, -0.06707311f, -0.00485132f, 0.04074898f, -0.04494964f, -0.02735625f, -0.01423363f, 
    -0.12480181f, 0.00373166f, -0.23362747f, 0.06466923f, -0.02722713f, 0.17981955f, -0.02972934f, -0.16945922f, 
    -0.04501138f, -0.13889609f, -0.07935250f, 0.11202714f, -0.06055085f, 0.11099742f, -0.13340393f, -0.05337029f, 
    -0.08339255f, 0.01476891f, -0.01598676f, 0.12393971f, -0.23148458f, 0.06000448f, 0.16965342f, 0.12538928f, 
    0.34120321f, -0.28280118f, 0.00550356f, 0.09144858f, 0.10198016f, 0.08652025f, 0.05377607f, 0.04754237f, 
    -0.04096490f, -0.00874193f, 0.09516876f, 0.00036037f, 0.10514718f, -0.12469276f, 0.02037770f, -0.04771034f, 
    0.02239883f, 0.01097874f, 0.01355263f, -0.04174361f, 0.10003438f, -0.24487309f, 0.03088664f, -0.47055209f, 
    0.24827339f, 0.00253584f, -0.12455094f, 0.10307050f, 0.03838218f, -0.04789607f, 0.04943756f, -0.20439245f, 
    0.02049340f, 0.03306885f, -0.18905823f, 0.07384042f, 0.05404848f, 0.00294932f, 0.15427005f, 0.04816405f, 
    -0.17271769f, -0.35084957f, 0.14798938f, -0.13332656f, -0.10998830f, 0.13355176f, -0.04539194f, 0.04664330f, 
    0.00099031f, 0.05563146f, 0.03681857f, -0.06395690f, -0.02547745f, -0.00195768f, 0.09471038f, -0.01257854f, 
    0.12068475f, -0.00480881f, 0.14691606f, -0.19707701f, 0.14488375f, 0.02177592f, 0.06117819f, -0.01131851f, 
    -0.09218212f, 0.05155138f, 0.00030872f, 0.14170411f, -0.10400328f, -0.19604373f, -0.03701645f, -0.15676819f, 
    0.02055518f, -0.03332410f, 0.10919434f, -0.02495435f, 0.07127694f, 0.07878103f, 0.16754888f, -0.02401143f, 
    -0.07522514f, 0.09651928f, -0.06015724f, -0.18962924f, -0.05121938f, 0.10219879f, 0.13473357f, 0.09156311f, 
    0.04136968f, -0.08708925f, 0.09673979f, -0.03915880f, -0.00494829f, -0.05663281f, -0.08583814f, 0.05349448f, 
    -0.00053354f, 0.09332987f, 0.06122822f, -0.06945722f, -0.21888761f, 0.25165522f, 0.00157897f, -0.03178232f, 
    -0.36915568f, -0.02767002f, 0.02737705f, 0.10265677f, 0.04359441f, 0.08511709f, 0.00637583f, 0.06932214f, 
    -0.01161196f, -0.12164036f, 0.08166455f, -0.00001974f, -0.11984547f, 0.08802126f, 0.08191309f, 0.12979817f, 
    0.16345063f, -0.22342092f, -0.02525447f, 0.10638855f, -0.02781928f, -0.08822288f, -0.00870377f, -0.03670557f, 
    0.05158221f, -0.04405705f, -0.10225501f, -0.03197362f, 0.06896314f, 0.08908968f, 0.15827572f, 0.04940130f, 
    -0.02437053f, 0.01437412f, 0.00054849f, -0.07485601f, 0.15092686f, 0.31777349f, 0.02573849f, 0.14653143f, 
    -0.27324545f, -0.02828106f, -0.08562613f, -0.00303836f, 0.09807149f, -0.00852861f, -0.00266928f, 0.19602361f, 
    0.00713836f, -0.06049927f, -0.08700264f, 0.02937281f, -0.04382150f, 0.08505127f, -0.04946288f, 0.00116034f, 
    0.21372673f, -0.15571626f, -0.00080584f, 0.14156133f, 0.33911622f, -0.16435319f, 0.22796948f, 0.01736238f, 
    0.05751882f, 0.08547536f, 0.02555831f, 0.06808672f, 0.02208559f, 0.01762272f, -0.02512935f, 0.05409344f, 
    0.02047300f, 0.10814995f, -0.04932107f, 0.15368259f, -0.08972149f, 0.02069027f, 0.04040942f, -0.25714937f, 
    0.14360334f, -0.10484689f, 0.03677319f, -0.09230044f, -0.13175309f, -0.14701919f, 0.01536269f, -0.02609464f, 
    -0.08359829f, 0.04046933f, 0.05949170f, 0.10676841f, 0.00354368f, 0.06125421f, 0.04926100f, 0.01549097f, 
    0.02913946f, -0.04042536f, -0.07123323f, -0.14486010f, 0.05228230f, -0.07153311f, -0.01426698f, -0.02815671f, 
    -0.17932922f, -0.01938953f, -0.05626772f, -0.02601897f, -0.17502297f, 0.04413081f, 0.08498397f, -0.18193211f, 
    -0.08105969f, 0.01506711f, 0.10668489f, 0.09776565f, -0.17396227f, 0.03314854f, 0.03093409f, -0.43118665f, 
    0.21924071f, -0.11225960f, 0.02675406f, -0.05814411f, -0.12164868f, -0.10666496f, 0.00966014f, -0.07268919f, 
    -0.00801993f, 0.08680166f, -0.03901732f, 0.03552121f, 0.00227700f, -0.04288650f, 0.03388504f, 0.15177347f, 
    0.00732983f, -0.76767641f, -0.18432783f, -0.09609645f, -0.09175259f, -0.00420843f, 0.01901573f, -0.05293448f, 
    0.01207563f, 0.00039165f, -0.12222914f, 0.10495153f, 0.02101780f, 0.08922829f, 0.11594214f, -0.03855890f, 
    -0.01818722f, -0.03935852f, -0.01650541f, 0.07598369f, 0.01523954f, 0.05717217f, -0.08234916f, -0.07681069f, 
    -0.26456431f, 0.09160365f, 0.05934462f, 0.12127942f, -0.00556474f, 0.06857590f, -0.04203961f, 0.02078437f, 
    -0.05409484f, -0.02830003f, -0.06347977f, 0.01616985f, 0.03670861f, -0.01926866f, 0.10713532f, 0.08057810f, 
    0.11412331f, 0.32475635f, 0.07539605f, -0.01779472f, 0.08695403f, -0.08477651f, 0.16551822f, -0.01963622f, 
    0.03109061f, 0.07211677f, -0.09942285f, 0.05073496f, -0.04098942f, 0.01030898f, -0.05285215f, 0.08515885f, 
    0.01921147f, 0.10899197f, -0.04376499f, -0.01003252f, 0.05982969f, -0.00682109f, 0.21588625f, 0.03210156f, 
    0.06854452f, -0.05225053f, 0.05051856f, 0.08522358f, 0.00320634f, 0.00703059f, -0.04138124f, 0.06237272f, 
    0.01798586f, 0.02758162f, -0.10846464f, -0.02262754f, 0.01933049f, 0.04307044f, 0.03303222f, 0.02168189f, 
    0.06962758f, -0.20017675f, 0.10055723f, -0.12810978f, -0.29543966f, 0.09125030f, -0.01606355f, -0.00236353f, 
    -0.03534714f, -0.14290345f, -0.06196379f, -0.12074517f, -0.01607048f, -0.05771981f, -0.08972981f, 0.06131298f, 
    0.07913477f, 0.00896381f, -0.02142608f, 0.01342257f, -0.04790272f, -0.31022063f, -0.14111550f, -0.19979931f, 
    -0.23272751f, -0.05945608f, -0.09000103f, -0.00627650f, -0.05090844f, -0.05151076f, 0.03918080f, -0.04114860f, 
    -0.05990414f, 0.00045901f, -0.02763948f, 0.07141455f, -0.02679280f, -0.02949306f, -0.03606018f, -0.04155744f, 
    -0.04872835f, 0.12750198f, 0.00807937f, 0.01400127f, 0.24348505f, -0.13603951f, 0.07779437f, -0.04012740f, 
    -0.00612969f, 0.02415179f, -0.12003117f, 0.07137261f, -0.19382130f, -0.05750185f, -0.08095880f, -0.05448966f, 
    0.04921202f, 0.08567678f, -0.04720101f, -0.04101566f, -0.18426082f, -0.14044981f, 0.10843684f, -0.12713745f, 
    -0.31431481f, 0.00409546f, 0.03019318f, -0.01150156f, -0.05064749f, -0.03969549f, -0.01019333f, 0.01129739f, 
    -0.07599895f, -0.02872189f, -0.08352571f, -0.09088529f, 0.04453206f, 0.06858753f, 0.03026982f, -0.01106568f, 
    -0.51282007f, 0.01225529f, -0.25333700f, -0.24178354f, -0.09423595f, 0.04659557f, -0.05738894f, -0.05137697f, 
    -0.01956840f, -0.05414581f, -0.13084304f, 0.03060632f, -0.11258012f, -0.08391977f, 0.00134885f, -0.04178052f, 
    -0.01284245f, -0.00627836f, 0.02490102f, 0.04760154f, -0.11416659f, -0.14966340f, -0.17760196f, -0.11607137f, 
    -0.16033182f, -0.10795037f, -0.07807641f, -0.03993864f, -0.05635116f, -0.10065813f, 0.04742815f, -0.06569654f, 
    -0.04753558f, -0.07701993f, 0.00635232f, 0.03612617f, -0.10180524f, -0.02252441f, -0.08689867f, -0.01289271f, 
    -0.22932823f, -0.48547316f, -0.32147357f, -0.13250114f, -0.27029330f, -0.06265455f, -0.03444859f, 0.02118621f, 
    -0.00227893f, -0.11053590f, 0.00312916f, -0.04446210f, 0.00239457f, -0.00748199f, 0.04823140f, 0.02305578f, 
    0.03108606f, -0.03064601f, -0.02169067f, -0.02106758f, -0.32628155f, 0.24655396f, 0.10768975f, 0.03427874f, 
    0.17544641f, 0.00216448f, -0.08724076f, -0.15051404f, 0.18786764f, -0.06977347f, 0.02165953f, 0.03209154f, 
    0.01380506f, -0.00261479f, -0.14664875f, -0.07278211f, -0.07026129f, 0.10929507f, 0.00533654f, -0.07223856f, 
    -0.02725659f, 0.00156951f, 0.15871303f, 0.03458161f, 0.10921739f, 0.02862901f, 0.11423170f, 0.02784416f, 
    -0.00671955f, -0.11140986f, 0.06656860f, -0.06012064f, 0.02319016f, -0.05287628f, -0.03681094f, -0.05088817f, 
    -0.00095829f, -0.00363014f, 0.01292819f, -0.04067988f, 0.05358342f, 0.16690129f, 0.28083521f, 0.09409320f, 
    0.20152140f, -0.03270118f, 0.11814675f, 0.01182090f, -0.02343441f, -0.00754987f, 0.01074581f, -0.01595029f, 
    -0.02431620f, -0.07906969f, -0.03150133f, -0.04562931f, -0.01871331f, -0.05672372f, 0.01087436f, -0.00414496f, 
    0.08246282f, -0.57461810f, 0.08966024f, -0.07634541f, -0.39354658f, 0.06554533f, -0.09198522f, -0.07471792f, 
    -0.12079124f, -0.10151163f, -0.03170399f, -0.08327605f, -0.13573667f, -0.00076752f, -0.12262762f, 0.01387586f, 
    0.16431522f, 0.00776947f, -0.04298017f, -0.10856467f, -0.04272429f, 0.12527694f, -0.15303107f, 0.03230803f, 
    0.00020177f, -0.12546694f, 0.04688919f, -0.13544656f, -0.01004269f, -0.02223410f, -0.13410461f, 0.02896313f, 
    -0.01679439f, -0.12099378f, -0.06984787f, -0.02927686f, 0.05052891f, -0.01897466f, -0.00093383f, 0.05425350f, 
    -0.00392992f, 0.18722674f, -0.03318042f, -0.17116036f, 0.01848079f, -0.00196193f, 0.12383726f, 0.03870844f, 
    -0.08936910f, -0.03420080f, -0.04700852f, -0.02890142f, -0.02778292f, -0.16256160f, 0.06496319f, 0.03652183f, 
    -0.01772778f, -0.00664323f, -0.01326312f, 0.05782354f, 0.04324970f, -0.09737962f, -0.14075117f, -0.04511699f, 
    0.00505562f, -0.03458383f, -0.13294640f, -0.08823688f, -0.04918614f, -0.02348399f, -0.08999077f, -0.01900466f, 
    0.05656072f, -0.00255776f, 0.02735734f, -0.11837290f, 0.01205267f, 0.01538323f, -0.00079938f, 0.05645648f, 
    0.02228637f, 0.13248387f, -0.09112214f, -0.12277530f, 0.13988182f, -0.05428160f, 0.01128861f, -0.06049974f, 
    0.00743981f, -0.07821435f, 0.03603731f, 0.12865376f, -0.15951312f, 0.12925588f, 0.06337900f, -0.04158026f, 
    -0.05825565f, -0.10529975f, 0.01571268f, 0.06780450f, 0.05513426f, 0.12378614f, -0.26350346f, 0.13936701f, 
    0.36237240f, -0.17026341f, -0.15324953f, -0.07423752f, -0.04350884f, 0.02217927f, -0.10798695f, 0.04689515f, 
    -0.13125041f, 0.04264417f, -0.09763195f, 0.00929766f, -0.01120313f, -0.03292063f, -0.13676225f, -0.05250794f, 
    0.35162503f, -0.26411217f, 0.07082104f, -0.04581343f, 0.14646581f, 0.05274250f, 0.04588993f, 0.03031541f, 
    -0.03684584f, 0.08977894f, -0.09181318f, -0.00511241f, -0.03948637f, -0.01876625f, -0.00668556f, -0.00865142f, 
    0.13633414f, 0.05043460f, 0.10524802f, -0.05752528f, 0.23407532f, 0.27081174f, 0.25545648f, -0.04865663f, 
    0.30406314f, -0.05195548f, 0.14580293f, -0.06850214f, 0.01562642f, 0.00285358f, -0.01708079f, -0.06411318f, 
    -0.13105018f, -0.00643152f, 0.06105418f, 0.03849781f, 0.04149675f, 0.14236034f, 0.07073072f, -0.01267407f, 
    0.16852820f, -0.08150068f, 0.06983340f, 0.00740575f, 0.11905902f, -0.02815871f, 0.00430939f, -0.04897067f, 
    -0.02566918f, -0.04889290f, -0.00697058f, 0.04998243f, -0.01254124f, 0.01452354f, -0.04746639f, -0.02908472f, 
    0.04750948f, 0.02796636f, -0.00262301f, -0.15415946f, 0.27302206f, -0.14405374f, 0.10301311f, 0.16054803f, 
    0.18634868f, 0.03430790f, -0.01053633f, 0.02570347f, 0.01321716f, 0.02465732f, -0.02090014f, 0.06781688f, 
    -0.10130008f, -0.00776899f, -0.02935732f, -0.04521486f, -0.05202165f, 0.06128820f, 0.05494824f, -0.02977083f, 
    0.15787686f, 0.10805262f, -0.11919720f, -0.04711994f, 0.06204361f, -0.08997902f, -0.13835560f, -0.08440313f, 
    -0.12233043f, 0.03105381f, -0.01160953f, -0.02920654f, -0.02256101f, 0.00481550f, -0.04227209f, -0.15075362f, 
    0.00066524f, 0.01638573f, -0.02428166f, 0.01103170f, -0.13752660f, -0.02266282f, -0.21455166f, 0.02364588f, 
    0.12430935f, -0.13032593f, -0.12075249f, -0.06155282f, -0.07245062f, -0.07133623f, -0.10045785f, 0.09826244f, 
    0.00684317f, 0.07762279f, -0.13368294f, 0.02513420f, -0.09113743f, -0.10370990f, -0.05365872f, -0.03905990f, 
    -0.06066493f, 0.19386907f, 0.00957686f, 0.07012769f, -0.10166427f, 0.13371594f, -0.10562345f, 0.03554712f, 
    -0.01655327f, -0.01331189f, -0.04299574f, 0.02872593f, -0.03339664f, -0.12168638f, -0.01896049f, -0.00412490f, 
    -0.05220634f, -0.07541622f, -0.05526232f, -0.10747326f, -0.35753146f, 0.05927080f, -0.26088282f, -0.10678184f, 
    -0.07341085f, -0.02569371f, -0.15741041f, -0.11190676f, 0.01937313f, -0.11489150f, -0.06395154f, 0.02142650f, 
    0.07168911f, -0.06007467f, -0.09276155f, -0.00659844f, -0.02712065f, 0.00527034f, 0.02754280f, 0.03156289f, 
    -0.11212311f, 0.19493179f, 0.01893529f, 0.15323146f, 0.07368135f, 0.14171469f, 0.06566457f, 0.08073089f, 
    0.09490151f, -0.01976652f, -0.05048352f, -0.03844445f, 0.08924117f, 0.02388885f, -0.04930787f, -0.01665811f, 
    0.09299812f, -0.02443815f, 0.04552900f, 0.05521233f, 0.12743376f, 0.00824491f, 0.20790969f, 0.15463650f, 
    0.14586073f, 0.05363619f, 0.12510715f, 0.00077681f, 0.00355961f, -0.11609416f, -0.00059870f, 0.02023668f, 
    -0.11118214f, -0.01902800f, -0.02548002f, -0.08061110f, -0.00010626f, 0.01227485f, -0.03922487f, -0.02259749f, 
    -0.20532434f, 0.11499517f, 0.09722649f, 0.13658175f, 0.07736991f, 0.05917828f, -0.05328286f, 0.02325460f, 
    -0.01927857f, -0.02462613f, -0.04741986f, 0.00106356f, -0.07392823f, -0.13867655f, -0.01378557f, 0.03724579f, 
    0.00648916f, 0.08914720f, 0.05814245f, -0.08553620f, 0.03025053f, 0.14587031f, 0.28005156f, -0.00281090f, 
    0.13448618f, 0.09678417f, 0.08547771f, 0.05056754f, -0.00780390f, -0.00268983f, -0.06174376f, 0.07048390f, 
    -0.04845508f, -0.00566650f, -0.05255076f, 0.00739837f, -0.03285410f, 0.09246455f, 0.12462631f, -0.05438690f, 
    0.01684861f, 0.02156965f, 0.16988015f, 0.17295724f, 0.26957029f, 0.14521611f, 0.11294775f, -0.06996079f, 
    0.03486339f, -0.04707248f, -0.03501705f, 0.00089023f, 0.10309717f, -0.06610999f, -0.09036649f, 0.00016617f, 
    -0.04245419f, -0.00918141f, 0.02904098f, -0.00512305f, 0.18873273f, -0.18989639f, -0.05389948f, -0.04098987f, 
    0.13021408f, -0.01242824f, -0.11133039f, -0.05615354f, 0.03170388f, -0.02721442f, -0.02778753f, 0.05044349f, 
    -0.09772602f, -0.03089503f, -0.02556604f, -0.06901003f, -0.03608785f, -0.07077896f, -0.06808183f, -0.06759382f, 
    -0.12969413f, 0.05910343f, -0.13986291f, -0.01682881f, -0.13435827f, -0.06381958f, 0.08649489f, -0.10166214f, 
    0.02845721f, -0.00740162f, 0.13074279f, 0.03304202f, 0.03091182f, -0.08417883f, 0.07030950f, -0.10295676f, 
    -0.02070023f, -0.11114862f, 0.15452610f, 0.06886677f, 0.04891115f, -0.01735046f, 0.26490313f, 0.13133298f, 
    0.16007206f, -0.11062094f, -0.07725341f, 0.08580374f, -0.01619132f, 0.03870542f, -0.04316392f, -0.11038820f, 
    -0.04645285f, -0.15474698f, 0.03844626f, 0.06343395f, 0.02562045f, 0.01893693f, 0.08244481f, 0.06480354f, 
    0.21517205f, 0.11206786f, -0.17659427f, 0.13752069f, 0.22116588f, 0.13538694f, 0.05058629f, -0.07596283f, 
    0.04117742f, -0.05070789f, 0.00483653f, -0.04254111f, 0.05506122f, 0.02517105f, -0.03409505f, 0.10041261f, 
    0.04464272f, 0.01786340f, 0.09812656f, 0.05025401f, 0.20811765f, 0.12463524f, 0.03438696f, 0.09203693f, 
    0.12131867f, 0.06367648f, 0.13142130f, -0.08895509f, -0.03816818f, -0.03388699f, -0.02618591f, 0.01593255f, 
    -0.07330698f, -0.09713599f, 0.05376767f, -0.15154877f, -0.04674942f, 0.13296185f, 0.03028980f, -0.02942675f, 
    -0.00230985f, 0.19458380f, 0.04782852f, -0.09174684f, -0.16958795f, -0.19372930f, 0.02977560f, -0.05125056f, 
    -0.05529353f, -0.01240335f, 0.07221703f, -0.03065199f, 0.05075374f, -0.00948002f, -0.05516602f, -0.10588747f, 
    -0.07145206f, -0.17298429f, 0.04519135f, 0.00943222f, 0.05574268f, 0.13634805f, -0.32210672f, 0.15331820f, 
    0.16669363f, 0.19476114f, 0.00815621f, -0.10521843f, -0.02308909f, -0.04368962f, -0.10399719f, 0.05339678f, 
    0.09808312f, 0.03611866f, -0.03023827f, 0.10747594f, -0.10675625f, -0.09144666f, 0.13323708f, -0.02468972f, 
    0.05095659f, 0.16446272f, -0.05756124f, -0.01830096f, 0.05623685f, 0.16164069f, 0.05107807f, -0.04913859f, 
    0.03185467f, -0.00111096f, -0.01056078f, 0.03064635f, -0.01322691f, 0.04437264f, -0.06999546f, -0.03496410f, 
    0.01346885f, 0.11164026f, 0.04448888f, -0.07014777f, 0.20663287f, 0.26687700f, -0.00664437f, 0.03021468f, 
    0.13558656f, 0.02291426f, 0.02452867f, -0.12286490f, -0.11418137f, -0.07936530f, 0.09611005f, 0.04288021f, 
    -0.02451632f, -0.02543330f, 0.00903471f, -0.16143700f, 0.04734608f, 0.05535229f, 0.06348074f, -0.04775968f, 
    0.17943610f, -0.12408020f, -0.27204061f, 0.19817352f, 0.21149118f, 0.08707836f, 0.06751368f, -0.05332736f, 
    -0.07006191f, -0.06114397f, -0.06140703f, -0.08228747f, -0.04718916f, 0.02502507f, -0.02371749f, -0.03664985f, 
    -0.01045365f, 0.03881658f, 0.07827207f, -0.10828512f, -0.10179652f, 0.29016981f, -0.46841663f, -0.02613943f, 
    -0.14385158f, -0.00783385f, -0.05118940f, -0.27973014f, -0.06885134f, 0.01306994f, 0.10896488f, 0.04152599f, 
    0.17427517f, -0.00377580f, -0.02518423f, 0.10049081f, -0.12077430f, -0.25337127f, 0.11624893f, 0.10179322f, 
    0.06496288f, -0.10674866f, 0.17025793f, 0.03695547f, 0.11715977f, -0.11201123f, -0.07006116f, 0.01856723f, 
    -0.04615027f, -0.05731879f, 0.01470623f, -0.05286825f, -0.08521250f, -0.04230459f, 0.08505519f, 0.00308553f, 
    -0.05108099f, -0.01859403f, 0.05989515f, -0.01576451f, -0.14570227f, -0.20815639f, 0.19168852f, -0.17288704f, 
    -0.19567162f, -0.01174509f, 0.06984358f, 0.00017418f, -0.08036784f, -0.04120987f, 0.08086760f, 0.05567632f, 
    -0.11337885f, 0.12024444f, 0.02718538f, -0.06413430f, -0.04669572f, 0.02544003f, -0.17415647f, -0.03427303f, 
    0.09418666f, 0.14731127f, -0.09622248f, 0.17946023f, 0.09912434f, 0.11122803f, -0.05375212f, -0.07735616f, 
    -0.06626745f, -0.03117382f, -0.03182689f, -0.00979411f, -0.10662980f, 0.00475720f, -0.00504575f, 0.08312680f, 
    -0.01493694f, -0.03297602f, 0.09928261f, 0.02445394f, -0.08485796f, -0.09104642f, -0.16462575f, -0.10851368f, 
    -0.02549000f, -0.00995040f, 0.00087869f, -0.10384197f, 0.03771195f, 0.00982257f, 0.11490922f, 0.03053156f, 
    0.00127657f, 0.07022222f, 0.07528824f, -0.03431647f, 0.02256886f, -0.00691789f, 0.02985305f, 0.02269061f, 
    -0.10934040f, 0.13259718f, -0.23972560f, -0.02004298f, -0.08111870f, 0.02583508f, 0.02064168f, -0.02241347f, 
    -0.04950928f, 0.00038933f, 0.07309794f, 0.08338351f, -0.07203005f, 0.01631826f, 0.03573529f, -0.09312766f, 
    -0.12955475f, 0.01344007f, 0.10765620f, 0.02416920f, 0.02690813f, -0.04100529f, -0.19836453f, -0.28239906f, 
    -0.08166351f, 0.07258870f, -0.01971771f, 0.00253077f, 0.05943995f, -0.06911750f, 0.01232491f, 0.02712084f, 
    -0.08683529f, 0.07800768f, -0.04735537f, 0.09120748f, -0.01339032f, -0.01394360f, -0.06009109f, 0.10163485f, 
    0.24721272f, 0.04026242f, -0.04613575f, -0.01957542f, -0.00865125f, -0.11063433f, -0.00439812f, -0.04151292f, 
    -0.18167357f, 0.03569732f, 0.04571062f, -0.04151804f, 0.03181974f, 0.04981289f, 0.01385860f, -0.02139300f, 
    -0.02073910f, -0.09640016f, 0.08844912f, -0.00751183f, -0.23635787f, -0.13334449f, -0.03293828f, -0.36742666f, 
    -0.10931231f, 0.08182563f, 0.06890266f, -0.12546280f, -0.08886269f, -0.16490044f, 0.03442648f, 0.03617445f, 
    0.04602736f, -0.04783048f, -0.17695250f, -0.11013215f, 0.16457242f, 0.02674240f, -0.15929890f, -0.10881852f, 
    -0.15590000f, -0.27009538f, 0.00247450f, -0.22510214f, -0.08316956f, -0.11943315f, -0.02012767f, 0.00452928f, 
    -0.09814057f, -0.03411490f, -0.06625919f, 0.03279716f, 0.04649363f, -0.00535629f, 0.18161897f, 0.03882585f, 
    -0.01280823f, -0.00129726f, 0.11744972f, 0.05723878f, -0.41845524f, 0.27070239f, 0.05165275f, -0.35163853f, 
    -0.31779021f, -0.03433242f, -0.01509870f, -0.01323696f, 0.12495875f, -0.09296462f, 0.08939414f, -0.09978808f, 
    -0.14660354f, 0.03820099f, 0.06134532f, -0.06549555f, 0.05596989f, -0.02141933f, 0.07389171f, -0.01105277f, 
    -0.07876648f, -0.09060738f, 0.23021357f, -0.16887678f, 0.03795608f, -0.00433379f, -0.01638473f, -0.01381531f, 
    0.04751619f, 0.00846760f, -0.03532100f, -0.05890270f, 0.05327539f, -0.00963748f, -0.02372916f, -0.03102992f, 
    0.11063910f, 0.07624071f, -0.22250736f, -0.05288855f, -0.21314158f, -0.16642524f, 0.16889621f, -0.01799393f, 
    0.07388672f, 0.08139984f, -0.00083953f, 0.03313631f, -0.09678606f, -0.10720179f, 0.05882877f, -0.00136777f, 
    0.00957082f, 0.11789174f, 0.09086619f, 0.03401617f, 0.00444933f, 0.08571301f, -0.42071086f, 0.10089069f, 
    -0.07259960f, -0.07321803f, 0.03232028f, -0.25172675f, -0.15249482f, 0.05181791f, -0.11152691f, -0.00707122f, 
    0.02103386f, -0.13453782f, 0.05170134f, 0.03266430f, -0.04966735f, 0.07365657f, -0.01986252f, 0.16230461f, 
    -0.01898538f, -0.04830329f, -0.21040933f, 0.11584842f, -0.27300990f, -0.15254919f, 0.00218197f, 0.12502772f, 
    0.09844057f, 0.04029755f, 0.05495533f, -0.05616055f, -0.07563573f, -0.09788956f, -0.00949503f, 0.03237233f, 
    0.01039733f, -0.08754041f, 0.04643590f, -0.10881759f, 0.09621863f, 0.10651659f, 0.02514954f, -0.23325162f, 
    -0.12923269f, 0.11022270f, 0.08641930f, 0.04458005f, 0.04041662f, -0.08556502f, -0.09339149f, -0.17994373f, 
    -0.00552624f, -0.00506378f, -0.01920594f, -0.00520508f, -0.05362834f, 0.03279532f, 0.01805634f, -0.11578973f, 
    0.06383459f, 0.00902437f, -0.05165388f, 0.03775581f, -0.04062213f, -0.19956723f, -0.16320059f, 0.05999123f, 
    0.13908567f, 0.12260901f, -0.06181671f, -0.09567246f, 0.00752542f, -0.07294486f, 0.16281152f, -0.01799792f, 
    0.06067032f, -0.05493094f, 0.14478357f, -0.09278297f, 0.07732294f, 0.06612159f, 0.05506527f, -0.02864470f, 
    -0.07500490f, -0.15840900f, -0.03750578f, -0.08173681f, -0.31368652f, -0.02874203f, -0.12310137f, -0.02978277f, 
    0.00018156f, 0.04555308f, 0.11458434f, -0.06776652f, -0.02020885f, -0.02290761f, 0.15555324f, -0.02060744f, 
    -0.06219366f, -0.14285263f, -0.03036765f, -0.00035656f, -0.22841878f, -0.13547440f, 0.00645747f, -0.07051959f, 
    -0.18098269f, 0.00110394f, -0.01675196f, 0.00702847f, -0.05747232f, -0.10656734f, 0.01387131f, 0.03698855f, 
    -0.13101554f, 0.03404786f, -0.02867202f, 0.03675945f, -0.00099625f, -0.06353665f, -0.14659904f, 0.03012190f, 
    -0.20433700f, 0.01785112f, 0.26179034f, -0.22138575f, -0.25653481f, -0.03280039f, 0.01725544f, -0.02184214f, 
    0.04965134f, -0.05442835f, 0.02904278f, 0.13154265f, -0.01955738f, 0.03034445f, -0.00297587f, -0.05505912f, 
    0.00112648f, -0.08748773f, -0.01393295f, -0.05304766f, -0.26420400f, -0.01784468f, 0.31948772f, -0.10985619f, 
    0.00077293f, -0.06524076f, -0.05170601f, 0.03148264f, -0.01636123f, -0.02635773f, 0.00198091f, -0.01942708f, 
    0.00823503f, -0.00672494f, 0.00600357f, -0.04612837f, -0.05503987f, -0.00662459f, -0.05957716f, 0.02768241f, 
    -0.07399750f, -0.05133822f, 0.30361286f, 0.10736912f, 0.22916676f, -0.05329377f, -0.13697582f, -0.05700828f, 
    -0.16934909f, -0.05800438f, -0.00282976f, 0.00513827f, -0.04523499f, -0.00990924f, -0.00599234f, -0.02022267f, 
    -0.00387369f, 0.05285361f, 0.00455778f, 0.05261247f, -0.29056406f, -0.16696343f, -0.04868969f, -0.22921821f, 
    0.02980524f, 0.00923599f, -0.01536059f, -0.06878522f, 0.00478689f, -0.00264310f, 0.09807665f, 0.01918854f, 
    0.00732420f, -0.02091588f, -0.00445885f, -0.02153660f, 0.10443469f, 0.03965033f, -0.04734642f, -0.07429264f, 
    -0.84065503f, 0.19836198f, 0.31688112f, -0.02661677f, 0.13142319f, 0.10759110f, 0.02462851f, -0.00948903f, 
    0.05104904f, 0.03487828f, 0.03612245f, -0.08893906f, -0.06817824f, 0.14495753f, 0.07757702f, 0.05281180f, 
    -0.01527427f, 0.06322017f, -0.08090148f, 0.07570603f, 0.13422379f, -0.10572276f, -0.08504846f, 0.23458555f, 
    -0.03229066f, 0.19803697f, 0.03829480f, -0.03216692f, 0.07625121f, 0.07037651f, -0.03249578f, 0.05412688f, 
    -0.02786202f, 0.00269800f, -0.12684795f, -0.11689086f, -0.15873390f, 0.02826100f, -0.07654482f, 0.01274913f, 
    0.04971242f, -0.24825735f, 0.23539990f, -0.30287167f, -0.11943128f, 0.09356845f, 0.12484943f, -0.10421315f, 
    -0.08962293f, -0.10224073f, -0.04687153f, -0.00167904f, -0.00089174f, -0.00213467f, 0.05341836f, -0.06318185f, 
    -0.00241929f, 0.00629217f, -0.01474887f, 0.01310228f, 0.03222157f, -0.15898271f, 0.03685275f, 0.13095886f, 
    -0.15380669f, 0.06964634f, 0.15819706f, 0.07253904f, -0.08085379f, -0.23781058f, 0.08469933f, -0.07539577f, 
    -0.08624557f, -0.03587868f, 0.00273183f, -0.03285606f, -0.00864170f, -0.07426603f, -0.06075239f, -0.06666713f, 
    -0.32747957f, 0.45438322f, -0.05353187f, 0.18363264f, -0.04426415f, 0.17823088f, 0.05534431f, -0.03355908f, 
    0.12524220f, 0.10131103f, -0.13236976f, 0.01393425f, 0.04441918f, -0.01236236f, 0.15464619f, 0.28110784f, 
    -0.00519610f, 0.12220734f, -0.07571164f, -0.05795600f, 0.16636126f, -0.38702849f, 0.26340103f, -0.09198994f, 
    -0.08926456f, 0.04859538f, 0.08025196f, -0.09114168f, 0.06597653f, 0.07435629f, -0.09468579f, -0.07410492f, 
    -0.06856464f, -0.11517607f, -0.13359965f, -0.01491245f, -0.06163812f, 0.10524142f, -0.24739897f, 0.09493386f, 
    0.28095713f, -0.02153997f, 0.10587411f, -0.27781713f, -0.33509886f, 0.04076408f, -0.01572783f, 0.09926051f, 
    0.02233958f, 0.04375676f, -0.05714715f, 0.03321931f, -0.05759249f, -0.12092174f, 0.00850506f, 0.02266258f, 
    0.08142319f, -0.17188881f, 0.03120747f, -0.03242775f, 0.28582537f, 0.00396664f, -0.18994120f, 0.17842524f, 
    -0.06643096f, 0.09119498f, 0.12513004f, 0.07488993f, 0.00426510f, -0.21278441f, 0.03533884f, -0.01484947f, 
    -0.05343387f, -0.03347752f, 0.06330933f, 0.05732597f, 0.04106277f, -0.05477280f, 0.02072115f, 0.02473358f, 
    -0.28913537f, -0.07109990f, 0.15408151f, -0.14428404f, -0.24326214f, 0.06168671f, 0.16574757f, -0.08151667f, 
    0.00335384f, -0.06602984f, -0.09434721f, 0.10903633f, -0.17178634f, 0.05435223f, 0.00868198f, -0.03902588f, 
    -0.02306728f, 0.07956342f, 0.08008078f, 0.03641261f, -0.31840271f, -0.14907210f, 0.30490294f, -0.14507402f, 
    0.11557554f, -0.05053575f, 0.11271751f, 0.09070383f, 0.16987960f, -0.05747011f, -0.06229017f, -0.08577771f, 
    -0.07483836f, -0.00350245f, -0.19811583f, 0.04291040f, 0.05318140f, 0.23087321f, -0.03907283f, 0.06140929f, 
    0.18875021f, -0.15213856f, -0.02059112f, -0.00967690f, 0.04672001f, 0.16756432f, -0.10396403f, 0.03047860f, 
    -0.03722596f, 0.06426753f, -0.11458880f, 0.02655662f, 0.07780707f, 0.08570620f, 0.00274797f, -0.04175761f, 
    -0.02545157f, -0.09471133f, 0.03148142f, -0.04256704f, -0.06407844f, -0.31092396f, -0.17575286f, 0.19270395f, 
    0.16997859f, -0.02691715f, -0.02708013f, 0.07783546f, -0.09624787f, 0.03993865f, 0.13973281f, 0.07089226f, 
    0.00604952f, -0.09644108f, -0.04183599f, -0.00991252f, -0.01843437f, -0.01374782f, 0.07556061f, 0.02226012f, 
    0.39645335f, -0.65312886f, 0.28622103f, -0.00842776f, -0.02592936f, 0.04595877f, 0.03109688f, -0.12298863f, 
    0.03377487f, -0.01892603f, -0.00189807f, -0.02875054f, 0.00475267f, -0.14129925f, 0.09849238f, 0.05149975f, 
    -0.00234390f, -0.11491581f, -0.04266354f, 0.21178395f, -0.17875737f, 0.02828873f, 0.01686393f, -0.00569544f, 
    -0.23868392f, -0.00339477f, 0.06059512f, 0.00705652f, -0.11621069f, 0.12992242f, -0.09424830f, 0.06911094f, 
    -0.10770649f, -0.03919362f, 0.00768354f, -0.08105619f, -0.02138264f, -0.04364825f, 0.04319789f, -0.04779972f, 
    -0.29115692f, 0.13519494f, 0.12219701f, -0.00632515f, -0.27039075f, -0.09287153f, 0.02919451f, -0.00412422f, 
    0.06776226f, -0.05649815f, 0.00268363f, -0.01993134f, 0.13374144f, 0.09085060f, -0.00906122f, 0.04563332f, 
    0.04853141f, 0.05584225f, -0.02513688f, -0.01422884f, -0.01691918f, -0.00472284f, 0.17223528f, -0.36746305f, 
    -0.23527089f, -0.05561941f, 0.03401823f, 0.07586596f, -0.03146982f, 0.01235890f, 0.04874863f, -0.03157349f, 
    0.08450209f, -0.10092638f, -0.01609281f, -0.10690462f, 0.01842965f, 0.00901084f, 0.19265348f, 0.02585500f, 
    0.17349097f, 0.03151553f, -0.24739683f, -0.34805739f, -0.09743106f, 0.19269148f, 0.02731780f, -0.06149969f, 
    -0.11633182f, 0.03378676f, -0.05920836f, 0.13984300f, -0.08037382f, 0.16367827f, -0.10914096f, -0.07839154f, 
    0.06858785f, 0.09160359f, -0.00757026f, -0.05888159f, 0.24558993f, -0.16765398f, -0.21324407f, -0.27513033f, 
    -0.42527586f, -0.04073370f, 0.03161867f, -0.01959371f, 0.01606508f, 0.01188063f, -0.05341891f, -0.04333371f, 
    0.05236130f, 0.08318476f, 0.02546017f, 0.00600255f, 0.08984869f, 0.00853544f, 0.00466647f, 0.08497252f, 
    0.13779639f, -0.40260065f, 0.14852037f, -0.21986772f, 0.15776657f, 0.08107874f, -0.06505202f, -0.04988220f, 
    0.05964123f, -0.05292926f, -0.01724559f, -0.01881656f, -0.08211742f, 0.05864599f, -0.04416916f, -0.07316075f, 
    -0.01387593f, 0.07255366f, -0.00167468f, 0.07623773f, -0.24081855f, 0.09274032f, -0.24308248f, 0.22864531f, 
    -0.15217392f, -0.05415700f, 0.02457457f, -0.10735177f, 0.01647512f, 0.03435970f, -0.05365347f, -0.08487466f, 
    0.13504219f, 0.09715983f, 0.13178495f, 0.01658304f, -0.11395688f, 0.04394093f, -0.11554757f, 0.13739520f, 
    0.42769244f, 0.15881044f, -0.14923039f, 0.10325426f, -0.10236445f, 0.01837832f, -0.03184487f, 0.11900348f, 
    0.03973188f, -0.10939474f, -0.02930130f, 0.08807418f, 0.06310531f, 0.09408299f, -0.16729581f, 0.18136890f, 
    0.02924811f, -0.09899571f, 0.03469059f, 0.07928959f, 0.44070175f, -0.13714914f, -0.18907419f, 0.01761770f, 
    -0.00001465f, -0.02766264f, 0.00214240f, 0.07925761f, -0.05663725f, -0.04586078f, 0.09483393f, -0.10452623f, 
    0.04032989f, -0.11330432f, 0.10874329f, 0.02987158f, 0.01475966f, -0.03348809f, 0.09220847f, 0.06721582f, 
    0.03952708f, -0.06239484f, 0.10257193f, -0.14652041f, -0.10373166f, -0.06295960f, -0.00965683f, 0.04106026f, 
    0.01515132f, 0.07273363f, 0.00833381f, -0.02657619f, 0.00582970f, -0.16194609f, 0.04557692f, 0.12694360f, 
    0.08034372f, -0.09905804f, 0.15311658f, 0.02930432f, 0.05922761f, -0.16614099f, 0.06439774f, -0.18130982f, 
    -0.08530574f, -0.09200414f, 0.05837362f, -0.17045002f, -0.01417785f, 0.10235924f, -0.11804426f, -0.11055780f, 
    -0.04870133f, -0.02928870f, -0.07475515f, 0.10263857f, 0.03891046f, -0.01375096f, -0.00563599f, -0.02631976f, 
    -0.48634914f, -0.25806022f, -0.15984696f, 0.01466107f, -0.15928587f, -0.11406037f, -0.01582920f, 0.00090023f, 
    0.05256218f, 0.06746462f, -0.10458180f, -0.02103133f, 0.07127368f, 0.11886568f, 0.09901990f, -0.10852823f, 
    0.09104734f, 0.02981371f, 0.05099915f, 0.00206785f, -0.24830978f, 0.02733420f, 0.19674994f, -0.44808567f, 
    -0.17721237f, -0.06843426f, 0.06936051f, -0.11303145f, -0.03806909f, 0.08241580f, 0.10733194f, -0.17947032f, 
    0.01605732f, -0.09703848f, 0.01841622f, -0.04094939f, -0.01021620f, -0.00607506f, -0.30140382f, -0.05745650f, 
    -0.44443154f, -0.10242064f, 0.01576878f, 0.08844899f, 0.33233342f, 0.01534508f, -0.08661088f, 0.00291978f, 
    0.03844865f, 0.04978828f, -0.04826645f, -0.06171905f, -0.00576631f, 0.01285692f, -0.09242055f, 0.16616379f, 
    -0.00038083f, 0.00846066f, -0.06510220f, -0.11705963f, -0.12615728f, -0.12108938f, 0.01750048f, 0.20168273f, 
    0.01820840f, -0.07742904f, -0.10030363f, 0.09193628f, -0.09337682f, 0.10403612f, 0.06973140f, -0.03737201f, 
    0.01169332f, -0.00217591f, 0.00679407f, 0.08827061f, 0.00710180f, -0.04497099f, 0.07281502f, 0.07975598f, 
    -0.20994432f, -0.13653201f, -0.03666437f, 0.06624287f, -0.12269452f, -0.09568269f, 0.13946095f, 0.12876804f, 
    0.00967128f, -0.07038946f, -0.10687067f, 0.01302737f, 0.02149540f, -0.01321062f, -0.02950652f, -0.01959905f, 
    -0.02916440f, 0.07301541f, 0.07873408f, 0.01700170f, 0.05880985f, -0.34856391f, -0.07202484f, 0.29436049f, 
    -0.05481732f, -0.04964310f, -0.03280217f, -0.08814740f, -0.02237900f, 0.13943103f, -0.14212067f, 0.08981396f, 
    -0.13083018f, -0.03512022f, 0.03090270f, -0.09354005f, -0.01344629f, 0.08150274f, 0.09719413f, 0.02966932f, 
    0.63144952f, 0.00817407f, -0.18516035f, -0.07364143f, 0.14556134f, 0.16527392f, -0.19628558f, 0.08176944f, 
    -0.12766576f, 0.12177067f, -0.02443470f, 0.05598030f, 0.10603581f, 0.08599122f, 0.02109314f, 0.00285352f, 
    -0.01448853f, -0.14219391f, 0.00549205f, -0.05173140f, -0.04118582f, -0.30634856f, 0.20390204f, -0.14483298f, 
    -0.15941666f, -0.16817935f, -0.04994581f, -0.01974414f, 0.02550372f, 0.02819094f, 0.11557247f, 0.05234308f, 
    0.08644690f, -0.06800459f, -0.04850232f, -0.05953092f, 0.21340282f, 0.05499953f, -0.02292905f, -0.04762191f, 
    -0.39119452f, -0.50802022f, -0.02879126f, 0.02431993f, 0.30461815f, 0.13060813f, 0.11159095f, 0.11117426f, 
    -0.05063695f, -0.09871406f, 0.10428686f, -0.03519904f, -0.05322956f, 0.00945687f, -0.04518446f, 0.07695189f, 
    0.00288646f, 0.02114003f, 0.08604316f, -0.00757346f, 0.29450181f, 0.14391668f, -0.03705851f, -0.04955330f, 
    -0.06798606f, -0.24923646f, -0.08951063f, -0.01242394f, -0.00264792f, -0.09142730f, -0.08563333f, 0.04148313f, 
    -0.07292530f, -0.06436990f, -0.03056175f, -0.05138323f, 0.04112296f, 0.01481504f, -0.06320035f, -0.03810667f, 
    -0.63876015f, -0.16167162f, -0.31845963f, -0.27880764f, -0.03105096f, 0.08878734f, 0.02707473f, -0.19102104f, 
    -0.03591866f, 0.13734961f, 0.00679493f, 0.05330564f, 0.01970089f, 0.05079560f, 0.05546065f, 0.01934972f, 
    -0.00565942f, 0.14325520f, 0.06096043f, 0.11189152f, -0.40512460f, -0.23868482f, -0.20429504f, -0.14427176f, 
    -0.19680287f, 0.00666971f, 0.11810002f, -0.10150292f, -0.04417402f, -0.01516401f, 0.03007898f, -0.07317516f, 
    -0.07994055f, -0.09639807f, 0.02637869f, -0.07096710f, 0.01867935f, 0.13996606f, 0.09528508f, 0.01932690f, 
    -0.12646429f, -0.06737112f, -0.06325181f, 0.04772572f, 0.00102204f, 0.07958756f, -0.00952652f, 0.06088127f, 
    0.03665189f, 0.08662306f, 0.13109919f, -0.00906108f, 0.03064401f, -0.01464264f, 0.04574601f, -0.00191440f, 
    0.02216341f, -0.15471286f, 0.08867778f, 0.05350174f, -0.46252862f, -0.19053726f, -0.33571219f, -0.02313355f, 
    -0.04073548f, 0.05113757f, -0.02447128f, -0.17671862f, -0.05401053f, 0.02753611f, -0.04938908f, 0.04664063f, 
    -0.03920573f, 0.04119681f, 0.14402975f, 0.03746584f, -0.05839982f, 0.18110622f, 0.07929206f, 0.00099000f, 
    -0.38535902f, -0.00636778f, 0.13303751f, -0.06785534f, -0.04122117f, 0.15222952f, -0.01403514f, 0.00913934f, 
    -0.00720059f, -0.01198092f, 0.02638883f, 0.08703182f, 0.03170967f, 0.20089194f, -0.04453941f, 0.13516143f, 
    0.02249015f, 0.05832299f, 0.06203076f, 0.07480562f, -0.36853066f, -0.26316512f, -0.00169216f, -0.04609986f, 
    -0.10390170f, -0.03663089f, 0.07754714f, -0.00503699f, -0.07450580f, 0.02739255f, 0.03052983f, 0.00177088f, 
    0.10724685f, -0.01577506f, 0.04338794f, -0.03779284f, 0.00099046f, 0.14796710f, 0.10852281f, 0.12029221f, 
    -0.79019195f, -0.49056953f, -0.18413715f, -0.19083756f, -0.44979152f, 0.04204377f, 0.10327206f, -0.03595573f, 
    -0.10418496f, 0.09153850f, 0.00415515f, 0.10078438f, -0.03492518f, 0.03050831f, -0.00236653f, 0.08877894f, 
    -0.02006376f, 0.12053594f, -0.01579740f, 0.01459244f, 0.11439223f, -0.17357898f, -0.09730875f, 0.26048541f, 
    0.05912238f, 0.11798829f, 0.03244341f, -0.04390674f, 0.06962857f, -0.08352055f, 0.02727085f, 0.09855501f, 
    0.10163030f, -0.08461488f, 0.12034480f, 0.01823896f, 0.04795002f, -0.28964087f, 0.02223302f, -0.05242749f, 
    0.21574490f, 0.07305914f, -0.08258293f, -0.02529978f, 0.02388778f, -0.17724013f, -0.06248649f, -0.04414715f, 
    0.03790632f, -0.00449684f, -0.01296894f, 0.04166501f, -0.07064933f, -0.12864485f, -0.01992596f, -0.11894803f, 
    -0.04301565f, 0.13713956f, -0.05560170f, -0.05151243f, 0.23149000f, 0.11907565f, -0.07352458f, 0.06714773f, 
    -0.13513206f, -0.02969637f, -0.00272386f, 0.02108226f, -0.03828595f, 0.08422697f, 0.03306489f, -0.08330037f, 
    -0.01531287f, 0.07413639f, -0.03363807f, 0.13411608f, 0.02958653f, -0.14552571f, -0.12683631f, 0.03656247f, 
    -0.69160694f, 0.00054053f, -0.43128639f, -0.00705911f, 0.04125343f, 0.02962477f, 0.04209743f, -0.17920870f, 
    -0.03104390f, 0.17308579f, 0.05344729f, 0.12807354f, -0.11830861f, 0.04113917f, 0.07399346f, 0.07727088f, 
    0.02568090f, 0.14586176f, 0.01314422f, 0.11609638f, -0.16137254f, -0.23114705f, 0.13165359f, -0.02040215f, 
    0.03615140f, 0.06968539f, -0.01555271f, 0.00108984f, -0.04007906f, 0.01963540f, 0.01926119f, 0.03133031f, 
    0.03781326f, 0.11468407f, -0.03896067f, 0.07402166f, 0.02780863f, -0.12669846f, -0.11154737f, -0.00080684f, 
    -0.28513992f, -0.26680347f, -0.02853079f, -0.04583447f, 0.26704636f, 0.08601362f, 0.10966159f, 0.10394380f, 
    -0.06717812f, -0.16448134f, 0.02972752f, 0.00247898f, -0.02348044f, -0.04904435f, 0.03114727f, -0.02539156f, 
    -0.03002663f, 0.01506129f, -0.00774384f, 0.08165820f, 0.23039378f, 0.18082765f, 0.08474682f, -0.07848658f, 
    -0.08910251f, 0.13159662f, -0.07628265f, -0.12129425f, 0.06484228f, 0.01882172f, -0.07300739f, 0.10221570f, 
    -0.00563201f, 0.13425227f, -0.05491880f, 0.10105690f, 0.10533952f, 0.01495896f, -0.03067405f, 0.08541562f, 
    -0.16424464f, 0.09093656f, -0.04051020f, 0.08638746f, -0.17569080f, 0.00606689f, -0.01761081f, -0.05286788f, 
    0.06064415f, 0.07668840f, 0.10244214f, -0.03168849f, 0.10128266f, -0.07947288f, -0.03946872f, 0.01070906f, 
    0.03913944f, 0.16093832f, 0.10910664f, 0.13682535f, -0.11243593f, 0.18260144f, 0.24207856f, -0.02978086f, 
    -0.36101148f, 0.10840882f, -0.09529939f, -0.03846096f, -0.02691280f, -0.00581471f, -0.09890065f, 0.09676399f, 
    0.04331971f, -0.01573418f, 0.04577257f, -0.03179638f, -0.01127721f, -0.27860531f, -0.25055125f, -0.07737999f, 
    -0.06398603f, 0.15480363f, 0.00524820f, -0.06465387f, 0.00338032f, -0.09012423f, 0.09418304f, 0.00028061f, 
    0.16623056f, 0.10412499f, 0.09769653f, 0.03353752f, 0.04916377f, -0.09172742f, 0.09303895f, 0.06901344f, 
    0.06128226f, -0.02364059f, -0.10852458f, 0.13027792f, -0.13322097f, -0.28578636f, 0.00724322f, -0.05822778f, 
    0.05686923f, 0.03512308f, 0.08799089f, -0.01069105f, -0.02123241f, -0.00260321f, -0.00116905f, 0.06286296f, 
    -0.00884218f, -0.04874378f, 0.00865002f, -0.02493623f, -0.11159074f, -0.30394885f, -0.22675882f, 0.07748063f, 
    -0.05162673f, 0.04337179f, 0.01420370f, -0.02499591f, 0.01880611f, -0.11302301f, 0.09427243f, -0.01724579f, 
    0.06731872f, -0.04507609f, 0.08628215f, -0.06726108f, 0.06478510f, 0.02496484f, -0.09898324f, 0.01718064f, 
    0.13118018f, 0.06042123f, -0.05553561f, 0.17908213f, -0.11572277f, 0.23233669f, 0.04399691f, -0.11643865f, 
    -0.02309470f, 0.24727218f, 0.02618380f, -0.01119291f, -0.00398935f, -0.02868369f, -0.02422070f, 0.03591612f, 
    -0.00305918f, 0.08075269f, 0.00524584f, -0.03516013f, 0.09822788f, 0.02193630f, -0.17409852f, 0.05085091f, 
    0.28520891f, 0.26569682f, 0.10273693f, -0.07152146f, 0.02631093f, 0.13649705f, -0.05353905f, 0.04341917f, 
    0.07590637f, -0.01810457f, 0.03624335f, -0.00796973f, 0.04592394f, -0.02000566f, -0.04838201f, 0.01781821f, 
    0.16647965f, 0.03406269f, -0.05651668f, 0.13510329f, -0.43882126f, 0.07989205f, 0.19431743f, -0.16362986f, 
    -0.31051329f, 0.09871589f, -0.05429048f, 0.01089839f, -0.07953763f, -0.02284550f, -0.05490023f, 0.02538018f, 
    -0.07282772f, -0.01728696f, -0.02782095f, -0.11519438f, -0.18939638f, -0.14797445f, -0.16280778f, -0.18229525f, 
    -0.08372355f, -0.08415316f, 0.04258421f, -0.11593999f, 0.10187668f, 0.00842482f, 0.02127270f, 0.04127890f, 
    -0.02938558f, 0.02111912f, -0.01552147f, 0.08496666f, -0.12279011f, -0.01292842f, 0.07728355f, 0.05406727f, 
    0.00600692f, 0.15193003f, -0.02129718f, 0.05535046f, -0.48810446f, -0.11846421f, -0.11592869f, -0.20382743f, 
    -0.05198193f, 0.12388029f, -0.09593514f, -0.06592701f, -0.01094375f, 0.14054096f, -0.01388468f, 0.05139299f, 
    -0.02655745f, 0.07551142f, 0.02553384f, -0.04183890f, -0.05485196f, -0.09189333f, -0.00775160f, -0.04540580f, 
    -0.17145498f, 0.16119221f, -0.20925838f, 0.15398063f, 0.08482502f, 0.03443120f, -0.08011400f, -0.02833106f, 
    -0.14916010f, 0.02451245f, 0.04079967f, -0.10799985f, 0.09753103f, -0.05325904f, 0.11886575f, -0.07673399f, 
    -0.05443275f, -0.04855241f, 0.00847392f, -0.08871411f, 0.18479681f, 0.09566401f, -0.08467583f, 0.06042784f, 
    -0.01133258f, 0.05149634f, 0.06881272f, 0.15934563f, -0.07535867f, 0.07995877f, -0.04250735f, 0.00655391f, 
    -0.02458978f, -0.07775557f, -0.04739575f, -0.01415416f, -0.03920752f, -0.03832022f, -0.09842041f, 0.08131232f, 
    0.24213998f, 0.06318343f, 0.05313914f, -0.03963522f, 0.05019508f, -0.00805094f, -0.08052484f, 0.19071028f, 
    0.01397207f, 0.02852257f, 0.02183397f, -0.05666018f, -0.03123983f, 0.05891689f, -0.10206354f, -0.00486565f, 
    0.11223085f, -0.12884063f, 0.00590079f, 0.08648259f, 0.27171260f, 0.06128010f, -0.03669279f, 0.06146796f, 
    -0.18029825f, -0.08606765f, -0.02848049f, 0.03616586f, 0.02831953f, -0.02691523f, -0.01420262f, 0.03666738f, 
    -0.02635375f, -0.04525660f, -0.08803326f, -0.01298990f, 0.06083176f, -0.09348994f, -0.18196560f, -0.10767238f, 
    0.04558920f, 0.20477730f, -0.09375349f, 0.06528322f, 0.04960368f, -0.13147934f, -0.07350320f, -0.03306380f, 
    0.06120522f, -0.00703714f, 0.04351938f, -0.00546721f, -0.10958789f, -0.04156227f, -0.02249783f, -0.09904186f, 
    -0.05072638f, 0.14703871f, -0.00075962f, -0.04944651f, 0.09366920f, -0.01302045f, 0.15263887f, 0.05802380f, 
    -0.05395069f, 0.01754002f, 0.02424668f, 0.04951026f, 0.04178049f, 0.03380456f, -0.01527724f, 0.03440078f, 
    0.01139410f, 0.01205005f, 0.04768379f, 0.05707642f, 0.00033778f, -0.07079557f, -0.15234420f, 0.02523441f, 
    -0.04060355f, 0.21978548f, -0.24403991f, 0.19999124f, 0.06437501f, 0.24767070f, 0.01891921f, -0.06861951f, 
    -0.00749007f, -0.05433256f, 0.01668042f, 0.00562347f, 0.04648568f, 0.05242164f, 0.09055779f, 0.00239044f, 
    0.08710624f, -0.02043356f, -0.18902747f, 0.00287415f, -0.06996758f, -0.14703639f, 0.10481266f, 0.04848775f, 
    -0.12779790f, 0.09234190f, 0.05082494f, 0.02574641f, 0.00349813f, 0.01052457f, -0.17455283f, -0.14970744f, 
    0.04414267f, -0.00046627f, -0.08938477f, -0.13683420f, -0.03204257f, -0.11858899f, -0.09700844f, -0.02985648f, 
    0.34870836f, -0.01337115f, -0.16149621f, 0.10670602f, -0.10628857f, 0.01216821f, 0.03510767f, 0.00289346f, 
    -0.01687333f, 0.05053177f, 0.03531788f, -0.11568772f, 0.01854571f, 0.02682179f, 0.01994412f, 0.02231434f, 
    0.09131712f, -0.02059785f, 0.02220404f, -0.06386387f, -0.31810978f, -0.29512179f, -0.21483451f, -0.25511512f, 
    -0.27125362f, 0.03009073f, -0.07185160f, 0.12473638f, 0.04287994f, 0.09234413f, -0.00722549f, 0.04824366f, 
    -0.04127777f, -0.04039629f, -0.06335505f, -0.08033326f, 0.00998159f, -0.00454820f, -0.10540117f, 0.01417650f, 
    0.05231778f, -0.18636216f, -0.09227535f, 0.04545513f, 0.01078613f, 0.04678721f, -0.08451150f, 0.00298921f, 
    -0.08296496f, 0.04326925f, 0.00939367f, 0.00524193f, -0.03394960f, -0.04692882f, -0.03451474f, -0.07166898f, 
    0.09906326f, 0.05710522f, -0.06801087f, -0.08638618f, 0.45907480f, -0.15807034f, -0.14580026f, 0.05689095f, 
    -0.27789032f, -0.05388639f, 0.11797115f, -0.01351850f, 0.03850211f, 0.08362391f, -0.06161987f, 0.16842508f, 
    0.05169877f, 0.02836216f, 0.08690485f, -0.02487480f, -0.01575887f, 0.02174889f, -0.05078486f, -0.02365932f, 
    0.44607306f, -0.15150313f, -0.07734460f, -0.14373420f, -0.05933444f, 0.11220060f, -0.02593800f, 0.00888356f, 
    0.12199525f, 0.01532146f, 0.13038850f, -0.01993869f, 0.03343127f, 0.05094427f, 0.04089092f, 0.02692352f, 
    -0.03402639f, -0.00695297f, 0.00992652f, 0.06818568f, -0.44826111f, -0.41631660f, -0.19078293f, -0.21297497f, 
    -0.17672443f, -0.01660968f, -0.04144312f, 0.03407569f, 0.05814966f, 0.17915884f, -0.09257159f, 0.06747121f, 
    -0.03059189f, -0.07005861f, -0.01743782f, -0.03166064f, -0.05285540f, -0.02155374f, -0.09219071f, -0.11799196f, 
    0.52592582f, 0.05160720f, -0.27398565f, -0.02652481f, -0.16216940f, -0.01695537f, -0.05815747f, 0.07007379f, 
    -0.04856374f, 0.08412530f, 0.11763914f, 0.01137501f, -0.02569564f, -0.03807006f, -0.17462213f, -0.08613165f, 
    0.00404532f, -0.02196054f, -0.08896378f, 0.02622186f, 0.08334848f, 0.04768778f, -0.33854315f, 0.05700104f, 
    -0.03978495f, 0.00625465f, 0.04852536f, -0.05836736f, 0.02942489f, -0.12869520f, -0.01619551f, 0.10979087f, 
    0.10424823f, 0.04853668f, -0.10309224f, 0.03123111f, 0.17037211f, 0.04200310f, -0.15356427f, -0.04876415f, 
    -0.42654118f, -0.04830274f, -0.02792772f, -0.03025230f, 0.01109823f, -0.10493585f, -0.03151136f, 0.02390262f, 
    0.08996917f, -0.03787480f, -0.07972406f, 0.01403629f, 0.07235856f, -0.02710267f, -0.05948603f, -0.07531630f, 
    -0.08345757f, -0.00012450f, -0.11144198f, 0.03783759f, 0.08674922f, 0.15154211f, 0.00893671f, -0.11357530f, 
    -0.00705796f, -0.16009416f, -0.18954676f, 0.06136760f, -0.02978423f, -0.20825902f, -0.02189863f, -0.14598934f, 
    -0.06714526f, -0.02004449f, -0.04479811f, -0.03722599f, -0.09927329f, 0.07887790f, 0.17788802f, -0.02329828f, 
    0.09454902f, 0.13989486f, -0.16447560f, 0.01163421f, -0.33948043f, -0.09881274f, 0.04054636f, -0.06498152f, 
    0.12542227f, -0.02835025f, -0.02247617f, -0.04440348f, 0.16201116f, -0.11514318f, 0.13217212f, 0.06224521f, 
    0.05929765f, -0.03579182f, -0.09191486f, -0.02385410f, 0.06638514f, 0.23170805f, -0.17661300f, -0.02259338f, 
    0.09195871f, 0.13088879f, 0.06846818f, -0.01958577f, -0.05130478f, -0.00728120f, 0.11588671f, 0.04063947f, 
    -0.05030425f, 0.01856552f, -0.03088124f, 0.06929667f, -0.00415997f, 0.11916887f, -0.11649875f, 0.08234235f, 
    -0.44078419f, 0.32193297f, 0.03695158f, 0.16551971f, -0.16876136f, 0.13756542f, 0.06215753f, 0.01757768f, 
    0.09321431f, 0.01941201f, 0.02891297f, 0.11278419f, -0.06563468f, -0.04208020f, 0.08666688f, 0.02143311f, 
    0.08850427f, -0.04538479f, 0.03913933f, 0.06476122f, 0.25041690f, -0.02802001f, -0.12246101f, 0.04093222f, 
    0.13192122f, 0.11825613f, 0.04147362f, -0.05711988f, 0.11146352f, -0.01461915f, 0.06378916f, -0.00804469f, 
    0.00008310f, -0.00347560f, 0.06416559f, 0.00416600f, -0.09892718f, 0.02415536f, 0.04347575f, 0.09691378f, 
    0.02558245f, -0.10192765f, -0.10751946f, 0.19163443f, 0.13803330f, 0.14987348f, 0.01075289f, 0.05644606f, 
    0.09850340f, 0.08689041f, -0.02284907f, -0.02747623f, -0.01655395f, 0.04927417f, -0.02466081f, 0.05701030f, 
    0.02717665f, -0.09147537f, -0.02461410f, -0.07242925f, 0.17165031f, 0.07209095f, -0.11697181f, -0.16597024f, 
    0.54624832f, 0.20340425f, -0.26711461f, -0.03821864f, 0.06923275f, -0.04642327f, 0.04908856f, -0.12342444f, 
    0.09115178f, 0.07751944f, -0.06122494f, -0.00268863f, 0.09603401f, 0.00345270f, -0.00918713f, 0.09234647f, 
    -0.22842237f, 0.26965418f, -0.10173930f, 0.17503029f, 0.43912980f, 0.01273309f, -0.06635822f, -0.00822979f, 
    0.02231010f, 0.05376136f, -0.02734942f, 0.01381670f, -0.01741192f, 0.02426043f, -0.11103813f, 0.05014979f, 
    0.05537797f, -0.06451950f, 0.00897372f, -0.00001305f, -0.16908136f, 0.25569814f, -0.11655758f, -0.01344427f, 
    0.03863407f, 0.13008685f, -0.27361342f, 0.02051182f, -0.07977778f, -0.17380024f, 0.06927145f, 0.15702014f, 
    0.07658194f, 0.05448268f, 0.00535431f, 0.04478607f, 0.17571281f, -0.13011311f, 0.06225771f, -0.01208188f, 
    -0.29834753f, 0.25378218f, 0.01578189f, -0.12421142f, 0.20290960f, 0.00062282f, -0.14653155f, 0.02794185f, 
    -0.00265618f, 0.08261483f, -0.01430285f, 0.05084667f, 0.00301096f, -0.04608601f, -0.15411842f, -0.12552796f, 
    -0.10861421f, -0.04290299f, -0.00015392f, -0.00659750f, -0.40266109f, 0.33074871f, -0.13096042f, -0.21921141f, 
    0.10717140f, -0.02609832f, -0.04543282f, -0.06797151f, -0.06576443f, 0.19539866f, 0.00313496f, -0.00814739f, 
    0.08676490f, 0.05052935f, 0.11601511f, 0.03047788f, -0.09266993f, 0.01213960f, -0.04778283f, -0.12159378f, 
    -0.04744740f, 0.08832971f, -0.12920840f, -0.05106826f, 0.11370119f, 0.11582350f, 0.03411134f, 0.02196507f, 
    0.02924009f, 0.06475539f, 0.02108436f, 0.03843241f, -0.06453948f, -0.01712123f, 0.10521752f, -0.03911703f, 
    -0.12959306f, 0.07040469f, -0.00314475f, 0.07846536f, 0.34336275f, 0.04489839f, -0.25374243f, -0.19328156f, 
    0.05909145f, -0.01991034f, 0.02577118f, 0.01945830f, -0.01409576f, -0.03248034f, 0.09295701f, -0.13321069f, 
    -0.06059849f, -0.02087112f, 0.01005288f, 0.00274868f, 0.00675259f, 0.03467430f, 0.03414801f, 0.05657417f, 
    -0.15094437f, -0.15852173f, 0.03290217f, -0.03193906f, 0.13684188f, -0.09207024f, 0.17912774f, -0.00000174f, 
    -0.01924499f, -0.04060286f, -0.06357199f, 0.04813623f, 0.03369131f, -0.01719249f, -0.04898553f, -0.01716978f, 
    -0.05184198f, 0.03152102f, -0.05885915f, -0.08965848f, 0.44798797f, -0.01543678f, -0.30761790f, 0.01048160f, 
    -0.07079168f, -0.05533826f, 0.06644511f, -0.13333619f, 0.04881880f, -0.06581544f, 0.06290117f, -0.04295404f, 
    -0.00865477f, 0.08109786f, 0.00594389f, -0.01881740f, 0.02717571f, 0.02159564f, 0.01882933f, -0.05869446f, 
    -0.09811294f, -0.10841412f, 0.05033663f, 0.10214337f, -0.04138038f, -0.12108275f, 0.15593044f, 0.09726605f, 
    -0.04526009f, -0.03872133f, -0.02013857f, -0.20908506f, -0.04398939f, 0.11105194f, -0.08383867f, 0.01718010f, 
    0.01623010f, -0.05376780f, -0.05937485f, 0.06310298f, 0.24629687f, 0.12782785f, -0.11242840f, 0.01693795f, 
    -0.12497626f, -0.12459572f, -0.07575719f, 0.01558008f, 0.00936396f, -0.06643748f, 0.04194804f, 0.02148288f, 
    -0.02062288f, 0.06146041f, -0.00557649f, 0.00487055f, -0.12853484f, 0.05955822f, 0.03250743f, -0.10244732f, 
    0.25290510f, -0.18221277f, -0.02929593f, -0.06034556f, 0.05592509f, -0.17454359f, -0.00667062f, 0.05239547f, 
    -0.02372984f, -0.06586313f, -0.02440652f, -0.05007325f, -0.11191399f, -0.01137940f, -0.11798775f, 0.12261479f, 
    -0.12624846f, -0.00298813f, 0.09928939f, -0.10442186f, 0.29493287f, 0.01633179f, 0.06508798f, -0.04303220f, 
    -0.07405189f, -0.06663236f, -0.09498566f, 0.12066854f, -0.18731256f, -0.21668769f, 0.00364168f, -0.07608377f, 
    0.08383700f, -0.02673761f, -0.05111153f, 0.00755527f, -0.03351044f, -0.00661477f, 0.05407656f, -0.00289903f, 
    -0.53410119f, -0.04670687f, 0.07802857f, -0.10888625f, 0.11236002f, -0.10875289f, 0.08263773f, 0.04040132f, 
    0.06430522f, -0.11925389f, -0.06650925f, 0.00877156f, 0.09532718f, 0.01262399f, -0.08967865f, -0.08961455f, 
    -0.12024947f, 0.00145788f, -0.23959467f, -0.04310098f, 0.06402740f, 0.06631280f, -0.08983997f, -0.09837184f, 
    0.18128717f, -0.05640521f, -0.07040889f, -0.10666735f, 0.01511243f, -0.17242838f, 0.05625893f, 0.02368430f, 
    -0.08795246f, -0.01516777f, -0.11318750f, 0.18275785f, -0.10286373f, 0.06574036f, -0.04634990f, 0.10878100f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03847820f, 0.03263152f, 0.00132681f, -0.03110515f, 0.00227385f, -0.02786908f, 0.02588675f, -0.09700133f, 
    0.02704937f, -0.04535316f, 0.08497713f, 0.00432563f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
