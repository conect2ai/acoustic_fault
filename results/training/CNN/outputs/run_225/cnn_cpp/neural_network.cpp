#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.57175362f, 0.30275175f, -0.46500686f, -0.79970497f, 0.34374809f, -0.41586861f, 0.33490804f, 0.34392607f, 
    0.38639531f, 0.68637002f, 0.02762623f, 0.91237837f, 0.21264002f, -0.58960027f, 0.60456455f, -0.10851796f, 
    -0.04800057f, 0.08343375f, -0.78907102f, 0.35327932f, -0.60371411f, 0.54785413f, 0.04187227f, -0.59771258f, 
    -0.21777873f, 0.44891280f, -0.15644555f, -0.28518698f, 0.94321060f, -0.64153266f, -0.20716988f, -0.03093929f, 
    -0.59934586f, 0.26797408f, -0.03574311f, -0.39137337f, -0.36340240f, -0.32471454f, -0.52634364f, -0.60315424f, 
    -0.73018038f, -0.10881269f, -0.50881225f, -0.37372112f, -0.25159013f, 0.27008373f, -0.58953696f, -0.67316067f, 
    -0.43210104f, 0.62075645f, -0.40238115f, -0.11556748f, -0.02854096f, 0.36488542f, -0.14997284f, 0.29082978f, 
    0.49567059f, -0.73318547f, 0.00238835f, -0.60600156f, 0.24693327f, -0.05228231f, 0.40925840f, -0.83547199f, 
    -0.89665407f, -0.84629512f, 0.17454073f, 0.35830140f, 0.67958337f, 0.10433529f, -0.26789910f, 0.00038154f, 
    -0.91430020f, 0.66251802f, 0.41760567f, 0.39951640f, 0.54446149f, 0.44201466f, -0.26802686f, 0.01170956f, 
    0.11165550f, -0.65596145f, -0.84141922f, -0.64434689f, -0.75373423f, -0.54709417f, -0.01050779f, 0.16256373f, 
    0.33472005f, -0.03700459f, -0.12839805f, 0.59799951f, 0.11930563f, 0.06016866f, -0.77818775f, -0.99661320f, 
    -0.44194615f, 0.02187610f, 0.11056216f, -0.94209808f, 0.03102818f, -0.26939338f, 0.52296942f, 0.93302876f, 
    -0.16606641f, -0.06868841f, -0.24951467f, -0.12888297f, 0.53325659f, 0.83953768f, 0.68102086f, -0.12250765f, 
    0.06643663f, 0.24361962f, 0.18224157f, -0.06197092f, -0.30706158f, 0.43489957f, 0.49217039f, 0.59078419f, 
    0.58030087f, 0.60353714f, 0.32447907f, -0.13187692f, 0.53485882f, 0.60108244f, -0.04141123f, -0.12136455f, 
    -0.31389996f, 0.54696745f, 0.66561723f, 0.03556215f, 0.85768378f, 0.07958379f, 0.08256976f, 0.87795430f, 
    0.33521074f, 0.48654950f, -0.42582288f, 0.71560478f, 0.04269996f, -0.43278649f, -0.02656087f, -0.16232771f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.22095814f, 0.34099200f, -0.23656507f, 0.05951557f, -0.19339000f, -0.07248821f, 0.06236685f, 0.05633769f, 
    -0.41887015f, 0.70766413f, 0.09874240f, -0.23239692f, 0.34498265f, 0.25697795f, -0.05512032f, -0.18420751f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.45349643f, 0.05654626f, -0.14026678f, -0.02123706f, -0.09226748f, 0.07070976f, -0.06683514f, -0.08967780f, 
    -0.14336307f, -0.19901222f, 0.05324536f, 0.00699470f, 0.01565313f, -0.15666033f, -0.01298373f, 0.12740672f, 
    0.01081164f, -0.14309748f, 0.27596766f, -0.58311385f, -0.17980020f, 0.19377221f, -0.12622127f, 0.02272551f, 
    0.02896831f, -0.03444097f, -0.09752280f, -0.02390736f, -0.16773005f, -0.21045543f, -0.00298286f, 0.17425266f, 
    -0.02236741f, -0.07499570f, 0.02357444f, 0.08046467f, -0.20008454f, -0.27828383f, 0.02971109f, 0.06601197f, 
    0.11767592f, -0.03746193f, 0.03830631f, 0.08662811f, 0.16948716f, 0.05977287f, -0.33642256f, -0.00190964f, 
    -0.02199884f, 0.37330112f, -0.03071953f, -0.05144063f, -0.07047560f, -0.15676792f, -0.26843491f, 0.07206648f, 
    -0.23317963f, 0.04977796f, -0.03253587f, -0.05090128f, 0.02429779f, 0.04861984f, 0.05720915f, 0.53762722f, 
    0.37499416f, -0.24345198f, 0.12223009f, -0.10968914f, -0.09468250f, 0.11776019f, 0.05274525f, 0.10063207f, 
    0.14518595f, 0.08864016f, 0.17869666f, -0.00836925f, 0.22558470f, 0.03743933f, 0.04453018f, 0.01719548f, 
    0.01392209f, -0.05359309f, -0.02562967f, 0.16974409f, 0.02821390f, 0.00964112f, -0.02002746f, -0.18192741f, 
    -0.01647488f, 0.13886738f, -0.15091948f, -0.05134469f, 0.18835555f, -0.13337290f, 0.13507789f, 0.00953534f, 
    0.11384939f, 0.10161290f, 0.10234279f, 0.18728846f, 0.25091738f, 0.10086760f, -0.03159870f, -0.12076652f, 
    0.03580689f, 0.07949574f, 0.10586868f, -0.08824721f, 0.05994048f, 0.23960166f, 0.10234402f, -0.40624508f, 
    -0.00115639f, -0.09709457f, -0.03522618f, 0.04075158f, 0.03269349f, -0.06508530f, 0.36347437f, 0.17181680f, 
    -0.09473796f, 0.09355713f, -0.09423948f, -0.03072002f, -0.05042580f, -0.12942792f, 0.19572310f, -0.43880948f, 
    0.00122684f, -0.17211446f, 0.11414554f, 0.07974594f, -0.16777487f, -0.18457961f, 0.01246326f, 0.30516580f, 
    0.02911757f, -0.37326083f, -0.23804405f, -0.22248711f, 0.25488198f, 0.06213080f, 0.02227838f, 0.08141030f, 
    -0.01457791f, 0.28921416f, -0.13547003f, 0.34276965f, 0.14169449f, 0.00342382f, -0.07279797f, -0.07268718f, 
    -0.09945168f, -0.15391991f, 0.16644281f, -0.20744453f, 0.03190506f, 0.10605974f, 0.14809839f, -0.01779421f, 
    -0.07656682f, 0.20187321f, -0.14826237f, -0.19034101f, 0.02953984f, 0.06967928f, -0.11953691f, -0.11713608f, 
    -0.08974005f, 0.09692581f, 0.03419302f, 0.00165713f, -0.31188369f, 0.12407701f, -0.05079031f, 0.08264479f, 
    -0.01440304f, 0.08936264f, -0.03241421f, 0.02160590f, -0.46603596f, -0.09468096f, 0.16325907f, -0.13231672f, 
    -0.04664010f, -0.06251951f, -0.00310464f, 0.10867202f, 0.07563201f, 0.19127256f, -0.22360547f, -0.27598420f, 
    0.02576660f, 0.16785556f, -0.22632875f, -0.08388866f, -0.04623202f, -0.14416544f, 0.18405323f, -0.07627247f, 
    -0.00373294f, -0.21522634f, 0.17192379f, 0.04561761f, 0.02029713f, -0.16839437f, -0.06636254f, 0.01410155f, 
    0.08477233f, 0.24636717f, -0.03451268f, -0.00837920f, -0.10868137f, -0.03112874f, -0.11319216f, 0.18552163f, 
    0.65897065f, -0.00465549f, 0.22680427f, -0.31462789f, -0.10738681f, 0.16413987f, -0.12089985f, 0.22357959f, 
    0.09737931f, 0.18125075f, -0.19798341f, -0.27991951f, -0.23504433f, 0.09214853f, -0.23158032f, -0.08846311f, 
    0.00603692f, 0.10135149f, -0.08986645f, 0.14676188f, -0.10871913f, -0.04765907f, -0.10452173f, 0.02609583f, 
    -0.02842890f, 0.07701756f, -0.03942101f, 0.60703343f, 0.09275425f, 0.08424859f, -0.00742649f, -0.17237444f, 
    0.13205028f, 0.11293246f, 0.06721510f, -0.01615475f, -0.14905259f, -0.08799859f, 0.17102379f, -0.07814417f, 
    0.01683766f, 0.10497890f, -0.00255627f, -0.07777070f, 0.10904507f, -0.02597494f, -0.20829011f, -0.06092811f, 
    -0.18884625f, 0.23886876f, 0.09101432f, 0.01537327f, 0.20225659f, -0.02094815f, 0.04061346f, 0.32247025f, 
    0.37963387f, -0.01012303f, -0.15139177f, -0.14248241f, 0.08487105f, 0.06120026f, 0.25081804f, 0.00972735f, 
    0.20945072f, -0.13497604f, 0.19896269f, 0.05037421f, 0.13977554f, -0.14169483f, -0.12682380f, 0.06136162f, 
    -0.08305573f, -0.07448156f, -0.05546756f, -0.00761586f, -0.02690420f, -0.05365973f, 0.04580295f, -0.08719315f, 
    0.01261462f, -0.06765393f, 0.00115736f, -0.07947697f, -0.06162629f, 0.03525415f, -0.10171665f, -0.06167828f, 
    -0.01494922f, -0.10840600f, -0.12908199f, -0.13179606f, -0.03887194f, -0.04108555f, -0.06474393f, -0.10719596f, 
    -0.05072323f, 0.00941455f, -0.07477885f, 0.01923099f, -0.02015438f, -0.11079223f, -0.01730314f, 0.00486703f, 
    -0.06037999f, -0.09601238f, -0.09270972f, 0.00251828f, 0.00454839f, -0.12609081f, -0.07305895f, -0.00098277f, 
    -0.08259636f, -0.10930279f, -0.12510945f, -0.01718752f, 0.02476602f, -0.11053462f, -0.03213324f, -0.04299211f, 
    0.00779400f, 0.01621989f, 0.02741353f, 0.03606100f, -0.09743359f, -0.09631497f, 0.03304128f, 0.04684589f, 
    0.03661013f, -0.10095283f, -0.00288171f, -0.07726090f, -0.12573962f, 0.00315105f, -0.00107320f, -0.01357445f, 
    0.01820570f, -0.05329349f, 0.03646177f, -0.06766823f, -0.10842659f, 0.00450795f, -0.13253635f, -0.07662393f, 
    -0.09281223f, -0.09994283f, -0.06487395f, -0.03248156f, 0.02229338f, -0.12018481f, -0.06920379f, -0.05451355f, 
    -0.04570505f, -0.03743855f, -0.04029314f, 0.02349126f, -0.02269870f, 0.01683113f, 0.02470508f, -0.07010687f, 
    -0.03341791f, -0.00792188f, -0.04471930f, -0.05339113f, -0.12038361f, -0.08163366f, -0.04396471f, -0.09026814f, 
    -0.01500900f, -0.07486328f, -0.03046445f, -0.09809853f, -0.08560452f, -0.04332989f, -0.00141195f, -0.01318701f, 
    -0.12461241f, -0.08826054f, 0.00731328f, 0.02181016f, -0.05742254f, 0.01638524f, -0.06855747f, 0.01828101f, 
    -0.00810956f, -0.05376765f, -0.02840640f, 0.00696814f, 0.02773706f, -0.07140096f, -0.03115168f, -0.00194548f, 
    -0.04846914f, 0.02524524f, -0.02802584f, 0.03644242f, 0.00922990f, -0.12098020f, -0.09395043f, -0.07500585f, 
    -0.04385808f, 0.03594783f, -0.02247567f, -0.05201722f, -0.05828456f, -0.00167004f, -0.00365125f, -0.10319392f, 
    -0.03021407f, -0.10069494f, 0.02689465f, -0.01265214f, -0.09275427f, 0.04720575f, -0.03483100f, 0.03380948f, 
    -0.14454579f, 0.07279918f, -0.02559135f, -0.17596911f, -0.11326177f, -0.06479286f, 0.36117974f, -0.06083548f, 
    -0.17226984f, -0.22746579f, -0.18375562f, -0.39015749f, -0.10229141f, 0.15360366f, -0.02972400f, 0.20196052f, 
    -0.05071211f, 0.09726060f, 0.06232942f, -0.01701311f, 0.10478209f, -0.21203203f, -0.03654990f, -0.17846990f, 
    0.12083994f, -0.18432367f, 0.15897505f, 0.18118162f, 0.19766434f, -0.04694398f, -0.05078134f, -0.13461475f, 
    -0.16181444f, -0.06408620f, 0.20664459f, 0.17650497f, 0.29409781f, 0.13864242f, 0.02063210f, -0.18242949f, 
    -0.34229940f, -0.04377054f, 0.17167839f, 0.11417002f, 0.23742364f, -0.24952848f, 0.19255395f, 0.22421809f, 
    -0.09202912f, -0.19992696f, -0.02458686f, 0.05364833f, -0.23614211f, 0.04192039f, -0.20932043f, -0.04289913f, 
    0.06763872f, -0.09676088f, -0.27850047f, -0.23187363f, 0.03209491f, 0.12595825f, -0.04544855f, -0.16617790f, 
    0.15648937f, -0.03618657f, 0.06446238f, 0.12521817f, -0.14159228f, -0.04095084f, 0.01910425f, 0.24940696f, 
    -0.17215502f, -0.03276756f, -0.14557755f, 0.18793966f, 0.08623207f, 0.27613461f, 0.05180467f, 0.00326141f, 
    -0.10169249f, -0.08509610f, 0.31494293f, 0.09445691f, 0.10190106f, 0.22230685f, -0.04572790f, 0.27925608f, 
    -0.08960079f, 0.19833913f, 0.20432223f, -0.17761470f, 0.10121603f, 0.13745891f, -0.17905679f, 0.03385153f, 
    0.07807602f, -0.14813852f, 0.11289687f, -0.31227568f, -0.01603496f, -0.03733200f, -0.01099939f, 0.10168741f, 
    -0.09546482f, -0.08896568f, 0.19315483f, 0.19100761f, 0.54534233f, 0.15818296f, -0.10620166f, 0.06876896f, 
    -0.05980460f, -0.05721156f, 0.30370286f, 0.08528587f, 0.17721283f, -0.14498013f, 0.01060177f, 0.02059500f, 
    0.14482330f, 0.18562330f, 0.27740297f, 0.04132851f, 0.01018875f, -0.08551871f, 0.03810752f, 0.12502234f, 
    -0.00897904f, 0.38983265f, 0.25312006f, 0.15748829f, -0.24092475f, 0.11968756f, -0.25919574f, 0.21086505f, 
    0.21291164f, -0.00374744f, -0.15215446f, -0.06153476f, -0.02975900f, 0.21177916f, 0.04811537f, 0.03845487f, 
    -0.36054128f, 0.02902828f, -0.07430725f, -0.19519368f, 0.00547025f, -0.18867733f, -0.12214043f, -0.13589011f, 
    0.04213158f, 0.38950405f, 0.08324650f, -0.01015509f, 0.06383944f, -0.11177228f, -0.07417789f, -0.05014158f, 
    0.01541550f, -0.02961023f, -0.41503814f, -0.24103378f, 0.19501564f, 0.00262607f, -0.07091426f, -0.02865835f, 
    0.36262128f, 0.15610595f, 0.08111533f, -0.10360224f, -0.07328817f, 0.08183612f, -0.26295924f, -0.11695129f, 
    -0.09614755f, -0.16045994f, -0.01424932f, -0.01162702f, 0.21442875f, -0.18689607f, 0.34108856f, -0.06248289f, 
    0.02605775f, -0.03560881f, 0.10441206f, -0.01413850f, 0.11487138f, -0.19296563f, -0.17339957f, -0.00979441f, 
    0.04607737f, -0.07843823f, -0.03273880f, -0.20631655f, 0.10302448f, 0.04644739f, 0.03989546f, 0.02523560f, 
    -0.04155421f, -0.06187335f, -0.01840350f, 0.02227209f, 0.00154293f, -0.13050294f, -0.06014307f, -0.18861130f, 
    -0.21718939f, 0.14419927f, 0.18858171f, 0.18292814f, 0.21284609f, -0.08917282f, 0.02803056f, 0.06843659f, 
    0.70434684f, -0.19234225f, -0.28791425f, -0.10228062f, -0.08073309f, 0.16711725f, -0.14313771f, 0.07284521f, 
    -0.03086462f, -0.29117486f, 0.02755624f, 0.11748862f, 0.00259549f, 0.16167334f, -0.00873049f, 0.05711503f, 
    -0.01741365f, -0.04185900f, 0.09465563f, 0.16632694f, -0.01386939f, 0.01041465f, 0.03755213f, -0.08773071f, 
    0.17251043f, 0.05627846f, 0.06749394f, 0.25999838f, -0.28344628f, -0.08163865f, 0.17617276f, 0.08489893f, 
    0.07319513f, 0.08638694f, -0.07294787f, -0.03148491f, -0.05080221f, -0.11422933f, 0.39779648f, -0.05276170f, 
    -0.01541731f, -0.02268648f, 0.03650601f, 0.04486581f, -0.16749769f, -0.26568040f, -0.20813617f, 0.02300783f, 
    0.05443534f, 0.13112596f, 0.06381907f, 0.10810121f, 0.07289041f, -0.09118684f, -0.55272472f, -0.27004811f, 
    -0.04402928f, 0.17775126f, 0.07043650f, -0.03083610f, 0.05609021f, 0.02445245f, -0.09423304f, -0.39830846f, 
    0.08303356f, 0.18339683f, 0.25700662f, 0.12473328f, 0.13722484f, -0.14791766f, -0.04007220f, 0.15102902f, 
    -0.30071443f, -0.37315863f, -0.14648026f, -0.22662765f, -0.16628274f, -0.00003747f, -0.13129464f, -0.13740301f, 
    -0.00446773f, -0.49640307f, -0.48491338f, -0.04710487f, -0.04655738f, 0.00337408f, 0.00919751f, 0.04957410f, 
    0.08729643f, 0.20354894f, 0.49558985f, 0.05012750f, -0.09760899f, -0.18419136f, 0.07077521f, -0.00510284f, 
    0.06048933f, -0.03683216f, -0.09144844f, 0.36501008f, -0.03525093f, -0.08405762f, 0.17793100f, -0.02053008f, 
    0.02759621f, -0.07558373f, 0.11854767f, -0.20968330f, 0.02751929f, 0.19802696f, -0.01307751f, -0.05430190f, 
    0.12782659f, 0.03681391f, -0.14082670f, -0.02017596f, 0.20773554f, -0.11060456f, 0.07160915f, 0.06287156f, 
    0.06840452f, -0.13095301f, 0.09741687f, -0.01021262f, -0.08144379f, -0.17457569f, 0.04875133f, 0.06156971f, 
    0.13579029f, -0.08655194f, 0.16384213f, 0.31551850f, -0.11912113f, 0.01104494f, -0.12111643f, 0.23711093f, 
    0.32240492f, -0.13980287f, 0.17138921f, 0.06171346f, -0.06832869f, 0.16954903f, 0.23974799f, 0.23622774f, 
    -0.29561758f, -0.05543872f, 0.09230931f, 0.26653755f, -0.21128608f, -0.10786240f, 0.05840686f, 0.05142886f, 
    0.16137910f, -0.14807272f, 0.23070098f, -0.10871068f, -0.04461012f, -0.28345820f, 0.03841395f, -0.01785876f, 
    0.01453686f, 0.02864952f, 0.26230630f, -0.29107133f, 0.13405561f, 0.05208578f, -0.08716898f, -0.05037123f, 
    -0.03531878f, -0.14679357f, -0.07334784f, 0.01295186f, 0.08732218f, 0.28837374f, 0.08387507f, 0.18511301f, 
    0.10117360f, -0.04037121f, -0.15068094f, -0.09983602f, -0.19962248f, -0.21248141f, -0.09172841f, 0.06114464f, 
    -0.01321501f, 0.00048458f, -0.19913247f, 0.16467205f, 0.07721351f, -0.38205403f, 0.04733909f, -0.02680130f, 
    0.07867816f, 0.04842614f, -0.05110733f, 0.19153909f, 0.09484926f, 0.09651603f, -0.08725146f, 0.20317069f, 
    -0.11058205f, 0.00788924f, -0.18297549f, -0.14744607f, 0.17371325f, 0.20553504f, 0.10285120f, 0.29667887f, 
    -0.05684766f, -0.11446931f, -0.01271595f, 0.15449211f, 0.12382866f, -0.00778057f, -0.10003753f, 0.26073733f, 
    -0.11934751f, 0.02878954f, -0.23728439f, 0.22261037f, 0.00164138f, -0.02096392f, 0.06479907f, 0.06075410f, 
    0.06053819f, -0.32722533f, 0.09313686f, 0.17481829f, 0.08848358f, 0.28899318f, 0.00375334f, -0.13298850f, 
    0.02601551f, -0.00779025f, 0.11980359f, -0.11908939f, -0.06973086f, -0.09680928f, -0.02812193f, 0.04208469f, 
    0.01806580f, -0.00900422f, 0.09287079f, 0.22178110f, -0.05716512f, -0.08140102f, 0.21564484f, 0.00097193f, 
    0.19545923f, -0.23141013f, 0.01769895f, -0.15737860f, -0.26323500f, -0.14116111f, 0.26131207f, -0.08191492f, 
    0.09911924f, -0.02885583f, 0.00204147f, -0.13476227f, 0.02785822f, 0.15806136f, -0.28903675f, 0.21278168f, 
    -0.23566955f, -0.12400063f, -0.03660075f, -0.00304233f, 0.01766371f, -0.03317312f, 0.34774101f, 0.09679628f, 
    0.41243774f, 0.00427776f, -0.11384367f, 0.10640924f, 0.01298472f, -0.06248264f, -0.10521931f, 0.00615487f, 
    -0.30539644f, -0.00639452f, -0.36352468f, -0.11374111f, 0.02809701f, 0.06368570f, -0.02573352f, -0.16280004f, 
    0.16821173f, -0.31631631f, -0.10658126f, 0.03112893f, 0.14910527f, 0.00558387f, 0.14427562f, -0.06000858f, 
    -0.01702230f, 0.19485913f, -0.04127391f, 0.01336138f, 0.02730063f, -0.14047839f, 0.02224048f, -0.01782971f, 
    0.06423433f, -0.14593512f, 0.17697088f, 0.14656387f, 0.19874263f, 0.13810736f, -0.08352493f, -0.07205157f, 
    0.11564299f, 0.11236829f, -0.00941713f, 0.21830231f, -0.26055869f, 0.00270204f, -0.03564364f, -0.17264308f, 
    -0.10447776f, -0.03956883f, -0.04900201f, 0.11121771f, -0.32807383f, 0.42650104f, 0.17501408f, 0.15874319f, 
    0.07026582f, 0.15598626f, 0.10048679f, -0.08857088f, -0.07006025f, -0.44252375f, -0.03517989f, -0.05740818f, 
    -0.16749339f, 0.16314495f, 0.10125206f, 0.01384618f, 0.04132090f, -0.03929454f, 0.25002015f, -0.07401282f, 
    -0.07942483f, -0.05603766f, -0.05941740f, -0.07168575f, -0.18540218f, -0.07611354f, 0.00113045f, -0.17532064f, 
    0.27477849f, -0.02491509f, -0.12410966f, -0.17452887f, 0.12010628f, 0.12786180f, -0.29529878f, -0.01988123f, 
    -0.02167925f, 0.02496499f, -0.08642836f, -0.01318510f, -0.07183684f, 0.00289267f, 0.03518102f, 0.01205640f, 
    0.00972523f, -0.09916636f, -0.03475878f, -0.07298768f, -0.10945720f, 0.02086071f, -0.09126120f, -0.04545785f, 
    0.00456669f, 0.03441934f, 0.03514281f, -0.00002485f, -0.08270016f, 0.03199619f, -0.08781502f, -0.09917516f, 
    0.00427327f, -0.04986557f, 0.01897175f, -0.09391824f, 0.03658475f, -0.07187862f, -0.03849707f, 0.02938727f, 
    -0.01533193f, -0.10701428f, -0.06736328f, -0.09742761f, -0.04059057f, -0.02532669f, -0.08128858f, 0.01307265f, 
    -0.02589684f, -0.02969289f, 0.00384719f, 0.04315571f, 0.01708494f, -0.04784356f, -0.01238980f, -0.05075528f, 
    -0.04591611f, -0.07408889f, -0.05769153f, 0.04115228f, -0.09888828f, -0.05373648f, 0.00810148f, -0.05078677f, 
    0.05372491f, -0.04601654f, 0.03403685f, -0.05684876f, 0.05006758f, -0.00131027f, -0.04407965f, -0.10950539f, 
    -0.01398472f, -0.06687135f, -0.03609416f, 0.01438607f, -0.06335781f, 0.05214940f, -0.00655126f, -0.00631649f, 
    -0.09200738f, -0.05588725f, -0.07046092f, 0.03325085f, -0.08792087f, -0.05789336f, -0.09699079f, -0.08845397f, 
    -0.06255680f, -0.04040286f, -0.05986538f, 0.01933443f, -0.04450126f, -0.10668138f, -0.05435871f, -0.00811700f, 
    -0.09487429f, -0.00412032f, -0.02789149f, 0.02681773f, -0.10559390f, -0.10474172f, -0.00999154f, -0.02353965f, 
    -0.05075004f, -0.08859572f, -0.08589880f, -0.06027382f, -0.09100919f, 0.01323131f, -0.09517758f, -0.04309247f, 
    0.02560023f, 0.01496001f, -0.05134011f, -0.06433991f, -0.03299790f, 0.02941274f, -0.04039410f, -0.11004930f, 
    0.05421000f, -0.02689566f, -0.01265547f, -0.08302661f, -0.00007929f, 0.00050670f, -0.02016587f, -0.06443956f, 
    -0.02271676f, -0.08341470f, -0.04366070f, -0.01544969f, -0.04563820f, -0.02162225f, 0.04550377f, -0.03925354f, 
    -0.06350508f, -0.09553653f, 0.03445224f, 0.03841365f, -0.03049189f, 0.02891175f, 0.04952434f, 0.01370753f, 
    0.00535713f, -0.05631454f, -0.07420942f, -0.06824381f, -0.02287273f, -0.01776708f, -0.05294973f, -0.04177516f, 
    0.19054647f, 0.13552566f, -0.43896446f, 0.13070148f, -0.04204095f, -0.08545195f, 0.04523139f, -0.05537836f, 
    0.00081100f, 0.01202229f, 0.11695810f, 0.06855567f, 0.17532961f, -0.03870156f, 0.09673890f, 0.14533612f, 
    0.09215096f, -0.03980364f, -0.07173809f, -0.20411974f, 0.17372398f, 0.02466499f, 0.06235276f, 0.06779342f, 
    0.09470782f, -0.08096125f, 0.09705287f, -0.13353786f, 0.21459851f, -0.54818964f, 0.09522357f, -0.04288644f, 
    -0.08729022f, -0.06114611f, 0.19223815f, -0.11546288f, -0.15540123f, 0.00230889f, 0.02001770f, 0.16600686f, 
    -0.10908049f, 0.19508918f, 0.13946398f, -0.04982588f, 0.13518704f, 0.07164009f, 0.21131961f, 0.10809197f, 
    -0.26176083f, -0.08406185f, -0.21610868f, -0.09813853f, 0.05470763f, 0.21221785f, -0.04827114f, 0.19024640f, 
    -0.42410293f, 0.17615686f, -0.04988487f, 0.06963891f, 0.00951684f, -0.13200760f, 0.11005440f, 0.01063622f, 
    -0.35319123f, 0.51526994f, -0.00265363f, -0.01489151f, 0.07780527f, -0.07013078f, 0.10446594f, -0.02643643f, 
    -0.03113022f, -0.00110045f, -0.02109229f, -0.15383770f, 0.00832520f, -0.09302928f, -0.00603079f, 0.02209156f, 
    0.11217465f, -0.68762642f, 0.07007673f, 0.23017152f, 0.12801398f, 0.02663780f, -0.08224992f, 0.06255381f, 
    -0.05014871f, -0.02573728f, -0.08198298f, -0.18350019f, -0.33769742f, 0.16735317f, 0.03430107f, 0.01793414f, 
    0.16262265f, 0.00948035f, 0.13544287f, -0.22315988f, -0.15777633f, -0.09265311f, -0.06515979f, -0.36363474f, 
    0.02353985f, -0.05896351f, -0.16681245f, 0.05297519f, -0.04980556f, 0.20623906f, 0.12426230f, 0.20447701f, 
    -0.05672712f, -0.16760525f, 0.25698596f, 0.15059841f, 0.02641423f, 0.07517099f, 0.18026510f, -0.18666054f, 
    0.00342668f, -0.18139964f, 0.02831771f, -0.00940762f, 0.11586571f, 0.07959670f, 0.07321799f, 0.01357601f, 
    0.11412001f, -0.16604987f, -0.11719888f, -0.09477823f, -0.01250767f, -0.03234342f, -0.04820266f, -0.01993160f, 
    -0.28415844f, -0.33854371f, 0.07541080f, 0.01951161f, 0.06700806f, -0.03709207f, -0.03646741f, 0.05888746f, 
    0.11390813f, 0.09775744f, 0.14629079f, 0.04677541f, -0.13179968f, -0.01360880f, 0.10127826f, 0.05836785f, 
    0.19458844f, 0.27820662f, 0.22526065f, 0.24887650f, -0.08796299f, 0.04017308f, -0.11816592f, -0.05328461f, 
    0.12499679f, -0.01635132f, -0.45221514f, -0.35719740f, 0.04003580f, 0.39139315f, 0.14932114f, 0.04372753f, 
    -0.16840887f, -0.16521914f, 0.16214988f, 0.03954079f, -0.10838013f, -0.03662466f, 0.14571923f, 0.31052151f, 
    0.10821844f, 0.18997830f, -0.14985770f, -0.02241806f, -0.23966737f, -0.17766833f, 0.01010977f, 0.10354216f, 
    -0.11293400f, 0.26230872f, 0.07634609f, 0.17758304f, 0.11067299f, -0.18936086f, 0.09551054f, -0.15850320f, 
    0.31436542f, -0.05162603f, 0.10801179f, -0.17303114f, -0.00223198f, -0.27471256f, 0.14629368f, -0.09451265f, 
    -0.06738277f, 0.05777776f, -0.21019317f, 0.10584500f, -0.11150201f, -0.04698864f, -0.05890376f, 0.14254297f, 
    0.18262297f, -0.41461933f, 0.09949113f, 0.04084339f, 0.16530807f, -0.01414798f, -0.16338716f, -0.17128544f, 
    0.02918586f, 0.02663121f, 0.11925139f, -0.04593214f, -0.03117997f, -0.30120340f, -0.01586217f, -0.00556398f, 
    0.28603250f, -0.59709769f, -0.04105295f, 0.11809543f, -0.02217958f, 0.04725005f, 0.04365430f, 0.13472834f, 
    0.02882758f, -0.28298599f, -0.11082817f, -0.19564450f, 0.00566273f, 0.04286632f, 0.01295718f, 0.01809002f, 
    0.01892504f, 0.27086502f, 0.03566504f, 0.19557825f, 0.02791697f, -0.11598132f, 0.07121588f, -0.00211994f, 
    -0.16008765f, 0.09235559f, -0.17538685f, -0.07715438f, 0.35091168f, 0.06712998f, 0.15158656f, -0.15581085f, 
    -0.30772477f, -0.04018762f, 0.03232874f, 0.12420681f, 0.08406301f, 0.19350865f, 0.06557931f, -0.11269649f, 
    -0.19653647f, 0.09012394f, -0.23062852f, 0.09950960f, 0.28256842f, 0.07879651f, -0.14875627f, -0.14514621f, 
    -0.04033050f, -0.06679480f, 0.04483618f, -0.07846289f, 0.03463794f, 0.21558529f, 0.00639154f, 0.08653081f, 
    -0.27871260f, -0.22516949f, -0.05592509f, -0.10678554f, 0.05740848f, 0.03894685f, 0.30507419f, 0.05770329f, 
    -0.62699676f, -0.49508145f, 0.08147267f, -0.22889869f, -0.12372709f, -0.08138758f, -0.12357679f, 0.00387249f, 
    0.02730181f, 0.12763664f, -0.16297176f, -0.21945816f, -0.06047457f, -0.14126965f, -0.01677606f, 0.05365116f, 
    -0.06749173f, -0.09119542f, 0.18353377f, 0.12104417f, 0.19675508f, -0.10672315f, 0.09784579f, -0.17462572f, 
    0.06784046f, -0.02957204f, 0.08616352f, 0.05747678f, 0.09451377f, -0.08894828f, 0.05490688f, 0.00518090f, 
    0.12980571f, -0.05591544f, 0.04423703f, 0.03157157f, 0.26134878f, 0.13081641f, 0.30900064f, 0.00949622f, 
    0.03716481f, -0.02324186f, 0.06987138f, 0.02910459f, 0.03738333f, 0.11069411f, 0.19407292f, 0.00483563f, 
    -0.14908038f, -0.07939830f, 0.32363996f, 0.08830416f, -0.13555390f, -0.07653891f, -0.27495080f, -0.12723646f, 
    0.07731135f, -0.03265529f, -0.18999171f, 0.01886758f, -0.09269122f, -0.21408913f, 0.07449533f, -0.17623499f, 
    0.29699287f, 0.24193294f, 0.26318896f, 0.10180559f, -0.03091870f, -0.02577472f, 0.14328237f, 0.21027325f, 
    -0.00781641f, 0.10287988f, 0.09370834f, -0.21451344f, 0.02445327f, 0.09700767f, 0.07065783f, 0.03096918f, 
    -0.07161693f, -0.16214827f, 0.18756147f, 0.01427566f, 0.20193222f, -0.00008292f, -0.14668614f, -0.01880938f, 
    -0.08308616f, -0.07781713f, -0.00530169f, -0.33496580f, 0.11834515f, -0.04081013f, -0.24166805f, -0.04359791f, 
    0.12206362f, 0.03681239f, 0.13985243f, 0.75581056f, 0.25843400f, -0.14984952f, 0.06510821f, 0.02903037f, 
    0.04954329f, 0.18593819f, -0.00118091f, 0.09036632f, -0.46756577f, 0.09383883f, 0.06916653f, 0.08901384f, 
    -0.16973956f, 0.03134413f, -0.06251132f, 0.07418583f, -0.05051615f, -0.02221987f, 0.11788086f, -0.05042187f, 
    0.25255764f, -0.01693623f, 0.05266895f, -0.00620468f, 0.05192249f, 0.05988448f, 0.08346445f, 0.27804515f, 
    0.17592318f, 0.17645271f, -0.26019090f, -0.20867370f, 0.00433523f, 0.02280824f, 0.18513648f, -0.26819259f, 
    -0.43145448f, 0.05565017f, 0.04645666f, 0.19261180f, 0.06037224f, 0.05510010f, 0.02935724f, 0.23255514f, 
    0.05001574f, 0.03795269f, -0.08345126f, 0.03437479f, -0.07792349f, 0.02319804f, 0.00905840f, -0.06930100f, 
    -0.04497087f, 0.08532239f, 0.03638165f, -0.04394827f, 0.04095400f, -0.01464434f, -0.10456466f, 0.06064170f, 
    0.05012012f, -0.09919435f, 0.03838973f, 0.10347436f, -0.06841793f, 0.11035645f, -0.14600892f, -0.07364313f, 
    -0.09522473f, -0.01436589f, -0.06167071f, 0.01510452f, -0.07810017f, -0.00293088f, 0.07948771f, 0.00382797f, 
    0.02571896f, 0.09081139f, -0.10870155f, -0.06751768f, 0.01007151f, 0.00028860f, -0.12773743f, -0.05746945f, 
    -0.06446879f, -0.11943434f, -0.06920899f, 0.03938067f, -0.15987873f, 0.08538328f, 0.04129551f, 0.05202641f, 
    -0.04220751f, -0.07900131f, -0.08447064f, 0.00892548f, -0.02156951f, 0.00752446f, 0.03819852f, -0.01453112f, 
    0.03951823f, -0.11076549f, 0.01568718f, -0.04923181f, 0.02691026f, 0.02684602f, -0.03392143f, 0.07106844f, 
    0.06377840f, -0.01237850f, -0.00101017f, -0.07291326f, -0.05917515f, -0.00836387f, -0.11928932f, 0.00075022f, 
    -0.06917927f, 0.05145906f, -0.01825888f, 0.02400988f, 0.02154377f, -0.00960825f, 0.05004817f, 0.02809888f, 
    -0.03989791f, -0.05751333f, -0.03712464f, -0.11100341f, -0.07350012f, -0.02555127f, -0.00014899f, -0.00798568f, 
    -0.08727232f, -0.02339095f, -0.07838047f, 0.02562075f, -0.01014013f, -0.07962163f, -0.07627867f, -0.10737501f, 
    0.08210543f, -0.04774563f, -0.03881742f, 0.00590055f, -0.01761556f, -0.04995316f, -0.05777961f, 0.01121703f, 
    -0.08897178f, 0.00702308f, 0.04032331f, -0.02794821f, -0.04059643f, -0.00321536f, 0.00672909f, -0.09043901f, 
    -0.06974819f, -0.08147682f, -0.05272094f, 0.06501987f, -0.07149759f, -0.04393777f, 0.05689070f, -0.05162046f, 
    0.04361539f, 0.00734028f, 0.01974051f, -0.04856688f, 0.02459242f, 0.04010350f, 0.07173771f, 0.01111317f, 
    -0.01546420f, -0.09870998f, 0.01843480f, -0.01285383f, 0.01681257f, -0.05938214f, 0.01696904f, -0.07661103f, 
    -0.00330076f, -0.10903329f, -0.01284595f, -0.09572372f, -0.07847230f, -0.04410904f, 0.02729099f, -0.00220937f, 
    0.09156977f, -0.21469007f, 0.15123773f, 0.02612845f, -0.13062946f, 0.15554628f, 0.00629660f, -0.17600279f, 
    -0.00815916f, -0.77277756f, 0.23274757f, -0.20230602f, -0.02882129f, 0.03105464f, 0.01179495f, -0.03489554f, 
    0.05662542f, 0.27941439f, -0.18400647f, -0.12108252f, 0.01129282f, 0.04531831f, -0.01899792f, 0.01297400f, 
    -0.04120515f, 0.16769698f, 0.04426394f, 0.00706574f, -0.17075594f, 0.01041265f, -0.11097486f, -0.16704926f, 
    0.03300605f, 0.03113391f, 0.01382794f, -0.06525454f, -0.22156118f, -0.41325781f, 0.15647775f, 0.00106836f, 
    0.18067184f, 0.11948145f, -0.25887457f, -0.08495571f, -0.07541464f, 0.04642407f, -0.17132404f, -0.26934341f, 
    -0.01720583f, 0.20695420f, 0.16638543f, -0.09764307f, -0.01270696f, -0.14663634f, 0.09166104f, 0.10263105f, 
    -0.15622617f, 0.08242154f, -0.06427655f, 0.01379086f, 0.09868573f, -0.00220700f, -0.07858074f, 0.32126161f, 
    0.38179836f, 0.07686589f, -0.17267635f, -0.01010895f, -0.02095075f, 0.02251951f, -0.08039717f, -0.10343208f, 
    -0.22132847f, -0.10155226f, -0.30685678f, -0.00796440f, -0.27277845f, 0.03370097f, -0.13513753f, -0.02209350f, 
    0.08434527f, 0.46747881f, -0.11424299f, -0.26952684f, -0.00595952f, -0.08627632f, 0.04347491f, 0.11834414f, 
    0.07876359f, 0.02390922f, 0.28963163f, -0.05300076f, -0.04444586f, 0.17073554f, 0.13004760f, 0.11049394f, 
    -0.12534241f, 0.21009551f, -0.11561218f, 0.37558669f, 0.06430177f, -0.07051376f, 0.03045488f, -0.10919271f, 
    -0.08559410f, 0.07868236f, 0.06830197f, -0.13600619f, 0.16375235f, 0.09773199f, -0.33709133f, -0.08402102f, 
    0.19502184f, 0.19653583f, 0.03245137f, -0.09438935f, 0.00661187f, -0.03018241f, -0.03177623f, 0.07845243f, 
    -0.01821701f, -0.06431720f, -0.20578408f, -0.12172896f, -0.00019073f, 0.34106699f, 0.14451386f, 0.17357560f, 
    0.12874149f, 0.07332592f, 0.00601563f, 0.10437001f, 0.21867740f, 0.19927764f, -0.13899466f, -0.27828485f, 
    -0.17632101f, -0.10071865f, 0.10586236f, 0.09731965f, -0.04429263f, -0.08078057f, 0.02462568f, -0.05682930f, 
    -0.02521718f, 0.17381987f, 0.08272178f, -0.18760045f, -0.02216915f, -0.09529040f, 0.14544992f, 0.03897291f, 
    -0.08549864f, -0.10904261f, 0.01418265f, 0.36682630f, 0.06418862f, 0.04520745f, 0.08683865f, 0.25844052f, 
    0.07586606f, 0.03520760f, -0.41674605f, 0.00008534f, 0.04322422f, 0.10134131f, 0.00275658f, -0.19486676f, 
    0.11264484f, -0.00013472f, -0.02488345f, -0.35035503f, -0.15677488f, 0.10236429f, 0.10940785f, 0.13247928f, 
    -0.07972425f, -0.07773055f, -0.03091775f, -0.05041289f, -0.10587712f, 0.22083127f, -0.10906535f, -0.12456805f, 
    -0.00730761f, -0.01802911f, 0.09472993f, 0.16324808f, 0.04437905f, -0.39378062f, -0.50783020f, -0.22572435f, 
    -0.03086467f, -0.10686699f, -0.01828428f, -0.00271125f, -0.17608227f, 0.10058806f, 0.28791380f, 0.23113018f, 
    0.10615388f, -0.18580607f, 0.17549714f, 0.10898817f, 0.06329281f, -0.06390417f, 0.01149980f, -0.24767135f, 
    -0.13950445f, -0.53651667f, 0.15153921f, 0.02328743f, 0.20763110f, -0.08802517f, -0.06866351f, -0.16349828f, 
    -0.28167841f, -0.26504609f, 0.06528334f, 0.05316880f, 0.00632877f, -0.03204498f, -0.09145833f, -0.15490419f, 
    -0.04874901f, -0.17939588f, 0.18234415f, -0.47281554f, 0.27625579f, 0.11872607f, 0.15047409f, 0.21682702f, 
    0.00377726f, 0.06466558f, 0.23189449f, 0.16853119f, -0.16272348f, -0.01903487f, 0.29382449f, 0.11601496f, 
    -0.01787940f, 0.12067837f, 0.37162712f, -0.08373348f, -0.04414549f, -0.01406159f, 0.23915412f, 0.08511920f, 
    -0.04009190f, 0.09291093f, -0.18151404f, -0.12634282f, 0.21047123f, 0.16151471f, 0.32665294f, 0.14827579f, 
    0.08620975f, 0.01213189f, 0.27736032f, 0.01144993f, 0.25112337f, -0.05914512f, -0.04120237f, 0.17999263f, 
    0.11419304f, 0.08149698f, 0.06533830f, -0.10131661f, -0.04627932f, 0.11014830f, -0.06833468f, -0.02258835f, 
    -0.04756860f, 0.05775394f, -0.02399055f, -0.05545106f, 0.00252455f, -0.08188754f, -0.29115936f, -0.11429182f, 
    0.16345882f, 0.13182604f, -0.01238471f, 0.04527197f, 0.15193401f, -0.28100026f, -0.01175969f, -0.01563036f, 
    0.41501161f, -0.37193137f, 0.14705195f, 0.00045597f, 0.08739210f, 0.08594808f, -0.01766800f, -0.05858571f, 
    -0.04569745f, -0.25436145f, 0.13143383f, 0.14351553f, 0.21291433f, 0.04857656f, -0.01729633f, -0.02787365f, 
    -0.11416646f, 0.14538673f, -0.24917051f, -0.13149050f, -0.35687172f, -0.01523040f, -0.12599161f, 0.19687894f, 
    -0.01734079f, -0.06176815f, 0.04452140f, 0.11885083f, -0.24369757f, -0.45159692f, 0.06826158f, 0.09885576f, 
    0.11205681f, -0.12593541f, 0.00106431f, 0.12564634f, -0.27355307f, -0.26963064f, -0.21714060f, 0.24645537f, 
    0.13735500f, 0.17305309f, -0.17205867f, -0.06292892f, 0.01682958f, 0.11558667f, -0.19693664f, -0.15290523f, 
    -0.05060378f, 0.04458276f, -0.09007306f, 0.10876960f, -0.04636775f, -0.22912481f, -0.10644174f, -0.06978410f, 
    -0.28417715f, -0.11006076f, 0.09569730f, -0.09262171f, 0.05241537f, 0.14386839f, 0.09031461f, 0.45707273f, 
    0.42045984f, 0.12657966f, 0.01115530f, -0.00270229f, -0.16500622f, -0.08858362f, -0.02863088f, 0.05700734f, 
    -0.03217987f, 0.07818948f, 0.01675374f, 0.09530149f, 0.23385522f, -0.15866975f, 0.07441942f, 0.12513441f, 
    -0.01469216f, -0.01052394f, 0.11323141f, 0.11985425f, 0.24183121f, -0.08086564f, 0.18955176f, -0.03476606f, 
    0.04177483f, 0.04559653f, -0.18275243f, -0.43842164f, 0.09016862f, 0.02930320f, 0.05792010f, 0.02469156f, 
    -0.10224057f, 0.02074401f, -0.00942957f, -0.47621638f, -0.28386417f, -0.16998880f, -0.07778055f, 0.10460094f, 
    0.05597771f, -0.05641271f, 0.13591462f, -0.13718246f, -0.22491576f, -0.07070020f, 0.04915492f, 0.20218246f, 
    0.08365450f, 0.03646844f, 0.05503992f, -0.01529002f, -0.04244919f, 0.12216202f, 0.29064098f, 0.20715977f, 
    -0.06485697f, -0.02632826f, -0.08484709f, 0.00627580f, 0.09984310f, 0.46841076f, 0.29880977f, -0.17054236f, 
    0.11819189f, -0.10485399f, -0.10613965f, -0.16061306f, 0.08040965f, 0.07430840f, -0.08120321f, 0.00254328f, 
    -0.07024761f, 0.02425289f, -0.05276963f, -0.21010312f, -0.10958784f, -0.06747831f, 0.10632612f, -0.15735480f, 
    -0.05298416f, -0.13587826f, -0.17004140f, 0.02009562f, 0.09521793f, -0.21378200f, -0.05768147f, 0.10618917f, 
    0.10671300f, -0.23615326f, -0.18314019f, -0.02737646f, 0.10829001f, 0.09638701f, 0.09183051f, -0.08575556f, 
    0.09628168f, -0.12734495f, 0.20387857f, 0.14073074f, 0.20585652f, -0.20655102f, -0.13184403f, 0.00538796f, 
    0.07263620f, 0.02726758f, 0.04318966f, 0.64167720f, 0.03081123f, -0.05375677f, 0.07144234f, -0.09315196f, 
    -0.15577056f, -0.06150839f, 0.22389735f, 0.02821671f, -0.22501296f, 0.07693456f, 0.17595197f, 0.07933967f, 
    -0.04924943f, 0.25118053f, 0.03666967f, -0.01381530f, 0.03335107f, -0.08382418f, -0.09599417f, 0.12411280f, 
    -0.10408045f, 0.04989450f, -0.03537000f, 0.11183754f, 0.09140360f, 0.23247322f, 0.12357410f, 0.18231165f, 
    0.02356202f, 0.28649145f, -0.07145341f, -0.14834842f, 0.02575327f, -0.03275386f, -0.11498413f, -0.02366062f, 
    -0.06011965f, 0.14821269f, -0.12828277f, -0.05946653f, -0.14350714f, -0.04101635f, 0.04620480f, 0.05329144f, 
    0.00349003f, -0.16952831f, -0.40468124f, -0.03995444f, -0.15345424f, 0.22673394f, -0.04451984f, -0.07389160f, 
    -0.49823663f, 0.22998568f, 0.00299236f, -0.07857378f, 0.11171225f, -0.09332536f, -0.02522915f, 0.01156747f, 
    0.05580832f, 0.09698385f, 0.38793808f, 0.26980993f, -0.33404699f, 0.13726160f, 0.14109986f, -0.02417061f, 
    0.14991462f, -0.07809454f, 0.14503951f, 0.08322856f, -0.04674601f, -0.04837763f, -0.17319420f, 0.01911809f, 
    0.10962330f, 0.00467075f, 0.15531412f, 0.02886572f, -0.20775209f, -0.19610015f, 0.01724590f, 0.14749125f, 
    0.04613203f, -0.01572179f, -0.17801017f, -0.03295777f, -0.12022172f, -0.26231790f, -0.11456976f, -0.24283788f, 
    0.04764840f, 0.04081998f, 0.06570087f, 0.01782274f, -0.01092313f, -0.28474542f, 0.20526257f, 0.08984796f, 
    0.12859616f, 0.02123418f, 0.08629388f, -0.05657187f, -0.34377697f, 0.09677999f, 0.10516891f, -0.38204822f, 
    0.27319768f, -0.31511450f, 0.12850232f, 0.17232901f, 0.22537793f, 0.11098906f, -0.17492443f, 0.08805000f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.02269514f, 0.06056031f, 0.00169542f, 0.27663654f, 0.07556103f, 0.06465029f, -0.02573607f, -0.06116633f, 
    0.04250202f, 0.15458336f, -0.05517343f, -0.07405972f, 0.10408556f, 0.18517390f, 0.04778749f, 0.22510646f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.68056172f, 0.15434000f, 0.05089043f, 0.29304570f, -0.34509438f, -0.39159298f, -0.19339159f, 0.20699416f, 
    0.23473725f, 0.14450066f, -0.22485457f, -0.04018495f, -0.09097724f, -0.08628909f, -0.14375396f, -0.01218539f, 
    -0.12628415f, 0.37501842f, -0.17135407f, -0.04485968f, 0.00824213f, -0.11044021f, -0.03857059f, 0.24531510f, 
    0.31842005f, -0.32475734f, -0.13515279f, 0.06064558f, -0.55154747f, 0.22049925f, 0.28264028f, -0.55860347f, 
    -0.41069576f, 0.20140402f, 0.09651395f, 0.32610270f, 0.09463241f, -0.01302467f, 0.32824907f, 0.10598033f, 
    -0.42033932f, -0.21536992f, -0.47456181f, -0.21390337f, 0.06107333f, 0.39753067f, -0.48384112f, 0.38718081f, 
    -0.43267798f, -0.08052652f, -0.25796375f, 0.00342849f, 0.31131327f, -0.02695551f, 0.08459619f, -0.17016943f, 
    0.25507328f, 0.10179596f, -0.26290825f, 0.20955116f, 0.31914371f, 0.16652210f, -0.29359630f, 0.14268756f, 
    0.39085126f, -0.41160119f, -0.15533233f, 0.16292883f, 0.36104256f, 0.28974807f, 0.06538688f, -0.24101664f, 
    -0.06515370f, 0.36470756f, -0.23515582f, 0.18993771f, -0.46840104f, 0.25885460f, -0.51199025f, 0.13604577f, 
    -0.14123267f, 0.05254264f, -0.02173428f, 0.34148017f, 0.23931375f, -0.13336435f, 0.12512717f, -0.14747046f, 
    -0.42097819f, 0.10393494f, 0.36784968f, 0.20773035f, -0.48870450f, 0.31876162f, -0.56079793f, 0.14906245f, 
    0.17025593f, 0.22421309f, -0.11078228f, 0.12952156f, -0.25724563f, -0.25275683f, 0.08278653f, -0.01878160f, 
    -0.31908998f, 0.40724424f, -0.21274519f, -0.17997272f, 0.61904013f, 0.04171721f, -0.46365061f, 0.00761325f, 
    0.25289518f, 0.36724219f, -0.06586780f, 0.32043290f, -0.34878740f, -0.46705291f, -0.41991135f, -0.19226897f, 
    0.38674212f, 0.23584548f, -0.40585792f, -0.08641440f, 0.13978460f, -0.00508179f, -0.25027210f, 0.06567565f, 
    0.03362302f, -0.06051039f, -0.21040088f, -0.28208452f, -0.15358116f, -0.11249631f, 0.16296463f, -0.03841251f, 
    0.08152489f, 0.08387330f, 0.00343231f, 0.03733547f, -0.24078172f, 0.00914261f, -0.09269456f, -0.15100834f, 
    -0.11502826f, -0.21150959f, 0.21905398f, -0.12692961f, 0.02260032f, -0.06708440f, -0.20358777f, 0.14488432f, 
    -0.01849300f, -0.16793025f, -0.11861208f, -0.01697141f, 0.01859507f, 0.11158630f, 0.11956397f, -0.22142157f, 
    0.05266665f, 0.37371105f, -0.10080811f, 0.30991873f, 0.69366407f, -0.55270010f, 0.41718641f, 0.07141075f, 
    0.05310372f, 0.07326161f, -0.56235999f, -0.09612465f, -0.31070581f, 0.21250474f, -0.57151693f, 0.23743562f, 
    0.22080532f, 0.42683554f, 0.03363085f, -0.28100547f, -0.12682807f, 0.23020127f, 0.22248186f, 0.23388137f, 
    0.17649147f, -0.07695426f, 0.31348372f, -0.01047231f, 0.50452316f, -0.41822228f, 0.43281594f, 0.14653181f, 
    0.51693320f, 0.25754771f, -0.13667384f, -0.61509955f, -0.39041853f, -0.35477826f, -0.11511866f, 0.10796428f, 
    0.09009146f, 0.26845706f, -0.17702864f, 0.16512382f, 0.40562055f, 0.09784769f, 0.69266814f, 0.24303672f, 
    0.44440305f, -0.48572323f, -0.25033969f, 0.10096568f, 0.33220857f, 0.32276762f, 0.19641374f, 0.20928603f, 
    0.33273804f, -0.36889404f, -0.20769660f, -0.17418367f, -0.04702291f, -0.46973568f, 0.43743390f, 0.36289382f, 
    0.41893405f, 0.18895382f, -0.00900087f, -0.02042861f, 0.38927749f, -0.04548462f, -0.23536870f, -0.01687217f, 
    0.16957371f, 0.49508175f, -0.24754444f, -0.11464430f, -0.21002340f, 0.44364408f, -0.28417641f, -0.27495489f, 
    0.28574437f, -0.17043748f, -0.06584003f, 0.24623373f, -0.71933800f, -0.10071320f, -0.76933974f, 0.16311541f, 
    0.44656458f, 0.29042399f, -0.06312025f, 0.16771412f, 0.26723304f, -0.05755290f, 0.41287249f, -0.16398166f, 
    0.09541710f, 0.53522617f, 0.00665559f, -0.13632464f, 0.48285449f, -0.50072318f, 0.17576511f, -0.19653061f, 
    0.50785834f, -0.02608611f, -0.05720855f, 0.07381623f, -0.39211449f, -0.00378575f, -0.24297236f, 0.26451185f, 
    -0.35859758f, -0.19938810f, 0.09461848f, -0.13791540f, 0.37537509f, -0.13909735f, 0.47092137f, 0.07469283f, 
    0.27004907f, 0.25539798f, 0.18498926f, -0.17998295f, -0.33174524f, 0.03049375f, 0.69772905f, 0.33819076f, 
    0.70433623f, -0.33506352f, -0.14063601f, 0.23413973f, -0.02258406f, 0.35767767f, 0.40245536f, -0.11634717f, 
    -0.65496582f, 0.13849971f, -0.38958496f, 0.10866622f, -0.31093451f, 0.11032454f, 0.10493734f, -0.19226873f, 
    -0.07717452f, -0.50766033f, 0.16520061f, 0.06430513f, -0.63265657f, 0.18164995f, 0.42392293f, 0.16333079f, 
    -0.36971065f, 0.34630376f, -0.46781731f, -0.01293991f, 0.41062966f, 0.41953251f, 0.71538764f, 0.11182831f, 
    -0.18049170f, -0.09208602f, -0.15558726f, -0.08159483f, -0.14166756f, -0.13482949f, 0.18272898f, 0.05253112f, 
    0.03406348f, 0.10116696f, 0.13169417f, -0.04463169f, 0.15893820f, -0.15091296f, -0.09765306f, -0.13972245f, 
    0.15636480f, -0.12840877f, -0.03050753f, -0.23546678f, -0.01076466f, -0.14885420f, 0.13720348f, 0.22966805f, 
    -0.17224878f, -0.18070047f, 0.10693823f, -0.12732214f, -0.11973868f, -0.01861620f, -0.03395025f, -0.22601186f, 
    -0.41989818f, -0.26568353f, -0.27000430f, -0.14704643f, -0.29283619f, 0.51066351f, 0.23164250f, 0.08808337f, 
    -0.17706974f, 0.27459821f, -0.24514434f, -0.13939765f, 0.17668253f, 0.15491888f, 0.31818163f, 0.12361696f, 
    0.35924321f, -0.00379218f, -0.02840948f, -0.09370945f, 0.42444870f, -0.22122881f, -0.50143892f, 0.03719000f, 
    0.26362070f, 0.18887365f, 0.03188935f, 0.10209554f, 0.32801563f, -0.23910204f, 0.35224602f, 0.11840138f, 
    0.08645609f, 0.15288503f, 0.21952829f, -0.30310816f, 0.14057261f, 0.05526692f, -0.15235715f, -0.21869180f, 
    -0.06129661f, 0.60281187f, -0.10485785f, -0.01312085f, 0.48409769f, 0.00891282f, 0.58416104f, -0.36070043f, 
    0.19573969f, -0.19879979f, 0.01699368f, 0.08988763f, 0.54653591f, 0.25546655f, 0.41516504f, -0.17988521f, 
    0.30357790f, -0.11034020f, -0.41745427f, 0.01438801f, -0.16210142f, 0.60409498f, 0.00190169f, -0.01980438f, 
    0.37803125f, 0.09970270f, -0.21249644f, 0.15362348f, -0.04671880f, -0.30854401f, -0.34423351f, 0.24852315f, 
    0.30142882f, 0.29603115f, -0.22518013f, 0.19950968f, -0.29757968f, 0.34456971f, 0.11731613f, -0.23926568f, 
    -0.22970276f, -0.00959410f, -0.19337134f, -0.26818070f, 0.16678257f, 0.46199930f, -0.37468213f, 0.07349338f, 
    -0.13275394f, -0.13471641f, 0.57496774f, -0.30394372f, 0.44710124f, -0.06194085f, 0.00887023f, 0.06860059f, 
    -0.26285377f, 0.62437803f, 0.07483213f, 0.04410866f, -0.11288024f, 0.17202467f, -0.16003966f, -0.09677923f, 
    0.73853052f, -0.34255195f, 0.20448326f, -0.08068178f, 0.38570014f, -0.18092109f, -0.14499016f, 0.64466858f, 
    -0.01179567f, -0.29803643f, -0.09863593f, 0.23110352f, -0.19186693f, 0.43914637f, 0.27394667f, 0.13357148f, 
    -0.54927039f, 0.07789988f, -0.36652747f, 0.09782556f, -0.23171270f, 0.43185130f, 0.25855413f, -0.09639762f, 
    -0.13521735f, 0.04947290f, 0.23867981f, 0.10738653f, -0.05630867f, 0.17432849f, 0.58309317f, 0.08197746f, 
    0.10628313f, -0.20916879f, -0.44026852f, 0.14250530f, -0.04314740f, 0.05834243f, 0.46552464f, 0.22098675f, 
    -0.26476145f, 0.25666592f, 0.13036662f, 0.16236044f, 0.03304890f, -0.16823241f, 0.26190484f, 0.19827592f, 
    0.02500524f, -0.26795611f, 0.60486156f, -0.04557432f, -0.16679159f, -0.28419763f, 0.12547766f, 0.33654678f, 
    -0.08521859f, -0.23339361f, -0.04019440f, 0.22950117f, -0.10608745f, -0.08792685f, -0.22751015f, 0.17593077f, 
    0.41142067f, -0.05939544f, -0.25939387f, 0.17652777f, -0.06498729f, 0.25754371f, 0.63326931f, 0.04241798f, 
    -0.19964844f, 0.00212108f, 0.17364113f, -0.11104916f, 0.09962063f, -0.08697709f, -0.18097477f, 0.19836578f, 
    0.17027757f, -0.03493338f, 0.23751166f, 0.18887953f, 0.14301485f, -0.09724069f, -0.12833549f, -0.04879765f, 
    0.19908494f, 0.35403168f, 0.20146438f, 0.12968582f, 0.11178307f, 0.32906428f, 0.12563863f, -0.04698780f, 
    0.83045751f, -0.15245035f, 0.33574352f, -0.18326031f, 0.02529485f, -0.39159781f, -0.18998010f, 0.33143365f, 
    -0.13316135f, -0.12668997f, -0.12546816f, -0.19976409f, 0.12103437f, 0.03637572f, -0.08196548f, 0.14019322f, 
    -0.22739665f, 0.18621783f, 0.04183767f, -0.15476614f, -0.22975115f, -0.22500266f, -0.11073552f, -0.06838806f, 
    -0.01812065f, -0.40786877f, 0.16133805f, 0.13163380f, 0.42419374f, 0.23406637f, -0.21847641f, -0.18359531f, 
    -0.19543867f, 0.11301059f, 0.38761449f, -0.02999507f, -0.29562280f, 0.32336783f, -0.27963325f, -0.01585472f, 
    -0.49363542f, 0.15260473f, -0.04004180f, 0.04734843f, 0.14736129f, -0.12037448f, 0.03879352f, -0.17195040f, 
    -0.23636656f, 0.14853665f, 0.03973054f, 0.16390379f, 0.18056461f, 0.37527001f, 0.11303648f, -1.01994658f, 
    0.04034066f, -0.02401954f, -0.10865834f, 0.10167395f, -0.07237659f, -0.13724954f, 0.09781339f, -0.20863661f, 
    -0.07290760f, 0.21718785f, -0.45383960f, -0.11961008f, 0.64372367f, 0.34556192f, 0.52536494f, -0.02705755f, 
    0.21566755f, 0.01764606f, -0.25693998f, -0.28507176f, -0.07254396f, 0.33321521f, 0.38890556f, -0.14586410f, 
    0.04763804f, 0.17433907f, -0.09808601f, 0.06855233f, -0.16876484f, -0.14879782f, 0.43293220f, 0.16567837f, 
    -0.00989354f, -0.13505073f, 0.08819425f, -0.10255285f, 0.19903666f, 0.18375854f, -0.99845922f, 0.03831612f, 
    -1.21393752f, -0.01314952f, 0.71362144f, -0.07488855f, 0.18176757f, 0.12709223f, -0.06676186f, -0.06446731f, 
    0.47132644f, -0.10825610f, -0.05085992f, -0.09086721f, -0.36142522f, 0.28353485f, 0.56792885f, -0.21222909f, 
    0.04493570f, -0.00410912f, -0.09251813f, -0.03377891f, 0.33274299f, -0.22060074f, 0.47747707f, 0.39780679f, 
    -0.22976092f, -0.30030477f, -0.14000988f, -0.19671230f, 0.15295516f, -0.08973930f, 0.10783204f, -0.20352131f, 
    -0.17544201f, -0.24766339f, 0.15942669f, -0.16445762f, 0.11480199f, 0.07828680f, 0.19190140f, -0.30254799f, 
    -0.50407642f, 0.02773383f, -0.18693915f, 0.03513397f, -0.23953027f, 0.09299324f, 0.10977492f, 0.17065831f, 
    -0.38727388f, -0.08193286f, -0.33598986f, -0.02420627f, 0.36512563f, 0.30399010f, -0.17979218f, 0.41921708f, 
    -0.24301699f, 0.47483015f, -0.00953302f, 0.21499380f, 0.25631699f, -0.08512635f, 0.33723840f, 0.03584299f, 
    -0.46966386f, -0.47658831f, -0.10348725f, -0.20639323f, 0.26740241f, -0.05483067f, -0.33703172f, 0.53158921f, 
    0.12834023f, 0.07401340f, 0.20130026f, 0.21484762f, -0.31696424f, 0.46834490f, 0.65185165f, -0.13496496f, 
    -0.79423726f, -0.17415401f, 0.03762966f, -0.13963196f, -0.17447889f, 0.10914694f, 0.19178225f, -0.02769273f, 
    0.12630035f, -0.29022291f, -0.23074090f, -0.04636268f, -0.06400841f, 0.15849677f, -0.04852971f, -0.22640800f, 
    -0.28010899f, 0.01858402f, -0.25309649f, 0.00470587f, 0.13217087f, -0.19900203f, 0.08781243f, -0.12674640f, 
    -0.26555026f, 0.24181330f, -0.10218976f, 0.21924736f, -0.23650147f, 0.12609418f, -0.07123263f, -0.21221352f, 
    0.55402380f, -0.56522864f, 0.44648129f, -0.21745007f, -0.04074693f, -0.21566324f, 0.58954048f, 0.40894619f, 
    0.38938817f, -0.42689300f, -0.03785945f, 0.14745481f, 0.71260124f, -0.22470464f, -0.21492952f, 0.11109739f, 
    -0.76135939f, 0.55677056f, 0.19164263f, -0.17034073f, -0.15591851f, 0.34447306f, -0.10683386f, -0.37074861f, 
    -0.07750847f, -0.13388516f, 0.18169370f, -0.12356293f, -0.18171816f, -0.22455820f, 0.05030239f, 0.10865301f, 
    -0.12460391f, 0.20340316f, -0.09293293f, 0.10264897f, 0.18361644f, -0.12144818f, 0.08681263f, -0.07129940f, 
    0.12680838f, -0.08717442f, 0.00997267f, -0.09722658f, 0.52303988f, 0.07981260f, -0.55588508f, -0.10404751f, 
    0.31188309f, 0.28013352f, 0.35640407f, 0.14967661f, -0.24245137f, 0.29649335f, 0.45725679f, -0.59230828f, 
    -0.09750442f, -0.00119933f, 0.10404690f, 0.30043009f, -0.33958271f, 0.01223163f, -0.42926580f, -0.22050221f, 
    -0.38995138f, 0.03640629f, 0.64766997f, 0.22555676f, -0.08420534f, 0.17749842f, -0.20276715f, 0.06639471f, 
    -0.35469851f, 0.28099421f, -0.21574780f, 0.19782244f, -0.65484107f, 0.27045703f, 0.21146522f, -0.08047706f, 
    -0.15784800f, -0.52349800f, 0.05557386f, -0.11606370f, 0.21728560f, 0.35303485f, -0.10705536f, 0.47121474f, 
    -0.56227392f, -0.02626419f, -0.20702212f, 0.13511866f, -0.11133698f, -0.10565571f, 0.09469830f, 0.21435481f, 
    -0.19147278f, -0.03492599f, 0.26402849f, -0.11619443f, 0.27331930f, 0.06725992f, -0.14209086f, -0.04551110f, 
    0.07305935f, 0.59223920f, 0.16321553f, -0.00319100f, 0.00490441f, -0.19546850f, -0.15585692f, -0.13672963f, 
    0.33738732f, -0.02957197f, -0.30606738f, 0.18971393f, -0.32565629f, -0.30044800f, 0.05727613f, 0.00310460f, 
    -0.24606197f, -0.04421303f, -0.04180810f, 0.13020428f, -0.90272474f, 0.48542196f, -0.26643288f, -0.13133083f, 
    0.46036729f, 0.00240368f, 0.28007793f, 0.06405810f, -0.30969435f, 0.13539700f, 0.51076066f, -0.09507159f, 
    -0.03626350f, -0.07411442f, -0.12821874f, -0.31855553f, 0.11192451f, -0.14900738f, -0.13951188f, -0.12124553f, 
    0.04374474f, -0.10882895f, 0.12848637f, 0.15181570f, -0.00780747f, 0.13233404f, 0.08881691f, -0.21664296f, 
    -0.22807550f, -0.12821393f, 0.14661491f, -0.17053227f, -0.22695056f, 0.02664284f, 0.15802324f, -0.04199252f, 
    0.01488447f, 0.19200058f, -0.05781740f, -0.13680592f, -0.03459635f, -0.04658707f, 0.10250340f, -0.19960278f, 
    -0.22370088f, -0.19243146f, 0.13405307f, 0.17840771f, -0.03660467f, 0.09451341f, -0.38681301f, -0.05495863f, 
    0.30302387f, 0.37899756f, 0.52517664f, -0.07779216f, 0.03659423f, -0.24338208f, 0.25383547f, -0.07645577f, 
    -0.01604267f, 0.10586491f, 0.13152279f, -0.29049918f, -0.01637020f, 0.63093829f, 0.33876616f, -0.23241742f, 
    0.37710416f, 0.13024837f, 0.15565076f, 0.04344701f, -0.20616971f, -0.22504023f, -0.26512036f, 0.31494862f, 
    -0.30709234f, -0.15697815f, -0.02273485f, 0.09632418f, 0.21243875f, 0.38426605f, -0.46415135f, 0.12366766f, 
    0.77907544f, 0.48029479f, -0.24024674f, 0.26344797f, -0.09456654f, 0.32181540f, 0.38016933f, -0.34826279f, 
    -0.01641434f, 0.07545128f, -0.08254573f, -0.17884549f, -0.03932583f, -0.00569442f, -0.18547058f, -0.00706050f, 
    -0.12481153f, 0.03131661f, -0.16663060f, -0.07315648f, -0.09569111f, -0.22413462f, -0.18430468f, -0.20315522f, 
    0.63234979f, 0.00863873f, -0.12993129f, 0.28279337f, -0.22666824f, 0.00147588f, 0.10835771f, 0.24985376f, 
    -0.78806251f, -0.28727958f, 0.23795570f, -0.15058045f, 0.22116455f, 0.00455476f, -0.16760650f, 0.47599444f, 
    0.34940204f, -0.21062291f, -0.05889415f, -0.11538759f, -0.16079171f, 0.34052187f, -0.04175109f, -0.08679119f, 
    -0.27379537f, 0.28363749f, 0.12719542f, -0.19756271f, 0.40856081f, 0.13108072f, 0.19626507f, -0.35461369f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.16150685f, -0.19962125f, 0.35349506f, 0.63864511f, -0.08561786f, 0.22964688f, 0.40758267f, 0.32834423f, 
    0.02362923f, -0.16950718f, 0.05281073f, -0.11475971f, 0.05844963f, -0.19260161f, -0.07810283f, 0.25824240f, 
    -0.20222466f, 0.25238955f, 0.13626027f, 0.00301967f, -0.24119271f, -0.16407989f, 0.59509444f, 0.34165180f, 
    -0.11187675f, 0.23447196f, 0.30611238f, -0.15205765f, 0.16141181f, 0.46543789f, 0.07996536f, 0.39774072f, 
    0.52518409f, -0.27441818f, -0.41279384f, 0.23389286f, 0.32798082f, -0.26373076f, 0.11136217f, 0.09485202f, 
    -0.35424075f, 0.05856191f, -0.22188807f, 0.52744353f, 0.21472003f, -0.10718924f, -0.20832428f, 0.08780017f, 
    0.07571676f, -0.24520236f, -0.03534091f, -0.05382260f, -0.18091044f, 0.12768337f, 0.20429060f, -0.01217847f, 
    -0.07979181f, 0.22353828f, 0.51680642f, -0.43334571f, -0.06348775f, 0.01796156f, 0.21157959f, -0.03544596f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.29811767f, 0.26494727f, -0.20060085f, -0.09945221f, 0.30970803f, 0.23666337f, 0.16790584f, 0.15228789f, 
    -0.11071609f, -0.06627993f, -0.04987421f, 0.15360810f, 0.10691390f, -0.57493764f, 0.03805873f, -0.00149204f, 
    -0.30706400f, -0.23978350f, 0.25931898f, -0.22611572f, 0.06638234f, -0.11511364f, -0.25860909f, 0.30391520f, 
    -0.02427403f, -0.18159416f, 0.04404215f, -0.39372039f, -0.15841316f, -0.10335183f, -0.45992029f, 0.05172151f, 
    -0.15918183f, -0.06909118f, 0.12778786f, -0.01106420f, 0.16774838f, 0.36865887f, -0.21574788f, 0.01493392f, 
    -0.22574398f, 0.14689606f, 0.03000656f, -0.26035967f, 0.03221805f, -0.08607800f, -0.15521015f, -0.33414939f, 
    0.29291159f, -0.11839394f, -0.06738365f, 0.20583242f, -0.49087432f, 0.05581141f, -0.63513011f, -0.17989320f, 
    0.04537312f, -0.03556004f, 0.31237030f, -0.22161140f, -0.20910397f, -0.05273588f, 0.19055024f, 0.11732332f, 
    0.01419103f, -0.39156005f, -0.51841098f, -0.21349494f, 0.04381039f, -0.26138815f, -0.18018398f, -0.12924710f, 
    0.08082097f, 0.00150496f, 0.02353529f, 0.01560364f, 0.23167810f, 0.71059114f, -0.06139549f, 0.21900919f, 
    -0.16118789f, 0.17879501f, 0.48159033f, 0.30595019f, -0.09414335f, 0.08231083f, 0.10994473f, 0.25306535f, 
    0.18423116f, 0.02992037f, 0.08289108f, 0.24961390f, -0.73710078f, 0.21286590f, 0.21250658f, -0.28847104f, 
    0.19602638f, 0.03053689f, -0.28786686f, -0.00019420f, 0.00569968f, 0.04910576f, 0.16626161f, 0.14381509f, 
    -0.32344908f, 0.25233185f, -0.06769959f, -0.59226763f, -0.57777709f, 0.13064519f, -0.03646525f, -0.01546861f, 
    0.27593857f, -0.10639715f, 0.19883467f, -0.31603974f, -0.54905349f, -0.90132833f, -0.24877992f, -0.06079452f, 
    -0.10788734f, 0.01615126f, -0.00244449f, 0.51426554f, 0.02696296f, -0.02310775f, -0.19522524f, 0.27044901f, 
    0.27569136f, -0.23662005f, 0.06579310f, 0.03151096f, -0.54227948f, -0.33649218f, 0.37527499f, 0.25257593f, 
    0.00649990f, 0.11536366f, 0.38432539f, 0.22915067f, 0.33523646f, -0.75960785f, 0.13469197f, 0.00142085f, 
    0.39956528f, -0.48854429f, -0.44797474f, -0.11051318f, 0.08368077f, 0.10582045f, -0.63219494f, 0.26865044f, 
    0.06336968f, -0.07692073f, 0.01182846f, -0.54692781f, 0.28261992f, -0.75295496f, 0.01838524f, -0.30564678f, 
    -0.06632987f, 0.06864870f, 0.15051980f, -0.12352087f, -0.91109878f, 0.29641181f, 0.24502105f, -0.19163296f, 
    -1.40205562f, 0.22606327f, 0.00383157f, 0.17765105f, 0.37140149f, -0.23773213f, 0.05283091f, -0.12887545f, 
    -0.40412724f, -0.05379348f, -0.01878266f, -0.45688343f, 0.21934196f, -0.14434953f, 0.09683904f, -0.79120940f, 
    -0.15362339f, -0.12859507f, -0.57303882f, -0.11943134f, -0.36989439f, -0.08627321f, 0.09003343f, -0.08583964f, 
    -0.48544955f, -0.80251259f, 0.04008084f, -0.21158706f, 0.16842833f, 0.00123404f, -0.34132490f, -0.45971414f, 
    0.02343694f, 0.05302240f, -0.45464009f, 0.07174582f, -0.57580924f, 0.74499226f, -0.49573764f, -1.08988035f, 
    -0.22999127f, -0.05487245f, 0.11689264f, 0.09099349f, -0.01904000f, 0.09222820f, 0.34771419f, -0.53694743f, 
    0.02154832f, 0.01390007f, -0.44146976f, -0.11004853f, 0.25034168f, 0.21656629f, 0.25718588f, 0.05703535f, 
    -0.22357288f, -0.11531902f, 0.21570008f, -0.04072017f, 0.04243534f, 0.34526616f, -0.32478338f, 0.22063619f, 
    -0.41847107f, 0.27619109f, 0.08100872f, 0.11365885f, 0.19247554f, 0.30776411f, 0.00467910f, 0.12339193f, 
    -0.98103303f, -0.01149816f, -0.66568601f, -0.10161182f, 0.28621137f, -0.18437988f, -0.09340263f, 0.23107688f, 
    -0.06950406f, 0.09576734f, -0.27210703f, 0.68981683f, -0.17653407f, 0.09654693f, -0.00308226f, -0.18612860f, 
    -0.14982472f, -0.11827849f, 0.15444469f, 0.08553912f, -0.04909845f, 0.19836150f, -0.23409460f, -0.00350318f, 
    -0.08283526f, 0.06953114f, 0.24323866f, -0.43906572f, 0.58068454f, 0.11496534f, -0.17955318f, 0.10769905f, 
    0.20342200f, 0.23508081f, -0.07695830f, -0.24542075f, 0.08622840f, -0.00152007f, -0.25931650f, -0.02258894f, 
    -0.42405310f, 0.11410965f, -0.04174810f, -0.16736078f, 0.10813530f, -0.01020376f, 0.05579461f, 0.23721157f, 
    0.15637389f, -0.05375934f, -0.07990010f, 0.06430543f, 0.16887319f, -0.58234149f, -0.12546895f, 0.40597406f, 
    -0.09653799f, -0.20727153f, -0.11418517f, -0.05000941f, 0.27598584f, 0.03468074f, 0.06000888f, 0.12809300f, 
    0.05627586f, -0.04191573f, -0.01155929f, 0.10003267f, 0.06894469f, 0.06056364f, -0.09084012f, -0.04207882f, 
    0.04241025f, -0.02614482f, -0.06284196f, -0.80523354f, -0.12144659f, -0.03485237f, 0.05477922f, -0.56818390f, 
    -0.11624768f, -0.25739703f, 0.08978242f, 0.24175821f, 0.12322816f, 0.04972764f, 0.14276852f, 0.01136158f, 
    0.09801032f, -0.09689561f, -0.12478210f, -0.25171602f, -0.45238885f, -0.42609718f, 0.09831671f, 0.39202207f, 
    -0.30513978f, -0.29593277f, 0.13634211f, 0.29863581f, 0.09986267f, 0.01304548f, 0.32664001f, -0.18832317f, 
    -0.02785517f, 0.19006494f, 0.06544761f, 0.31290910f, -0.40054017f, 0.33452624f, -0.13650775f, -0.61145973f, 
    0.09722995f, 0.03145723f, -0.48547813f, 0.04216522f, 0.22774774f, 0.15543807f, 0.10564970f, -0.28282744f, 
    0.58152443f, -0.37987375f, 0.08600076f, 0.35341877f, -0.24703670f, -0.13214090f, -0.00057907f, -0.72778416f, 
    0.22675379f, 0.06386220f, 0.10601424f, 0.09911563f, -0.04053703f, -0.14183949f, -0.33262503f, 0.10741085f, 
    -0.01776013f, 0.10772848f, -0.08762041f, -0.34418392f, 0.24807610f, 0.03722078f, -0.18603103f, 0.10230853f, 
    0.00905496f, -0.91801709f, 0.22731622f, 0.01866110f, 0.20099574f, 0.23966046f, 0.05837196f, -0.00508443f, 
    0.09916749f, 0.07534641f, 0.31813428f, -1.00915360f, -0.58254826f, -0.37571153f, 0.11167174f, -0.80676371f, 
    0.09703995f, 0.32023165f, 0.24012786f, 0.25076386f, -0.01960538f, 0.06820911f, 0.11703242f, -0.37076697f, 
    -0.07047711f, 0.21924321f, 0.09905946f, -0.25455210f, -0.53997153f, 0.24881291f, 0.10658937f, -0.09747987f, 
    0.04989135f, -0.05170508f, -0.25859955f, 0.02488875f, 0.03260355f, -0.28127253f, 0.02341409f, -0.20020382f, 
    -0.35043067f, -0.12716685f, 0.06620604f, 0.05565359f, -0.01819070f, 0.22804108f, -0.03095273f, -0.72061044f, 
    0.26008093f, -0.06061016f, -0.11014000f, -0.00123880f, -0.02600362f, 0.10206851f, -0.19955447f, -0.37601435f, 
    0.06310570f, 0.09242398f, -0.22002102f, -0.15248255f, -0.09266439f, -0.09322119f, 0.02941449f, -0.12181423f, 
    -0.49283174f, -0.30895054f, -0.46777019f, -0.88037932f, -0.47661647f, 0.00295049f, -0.41300967f, -0.46655267f, 
    0.11978898f, -0.06667694f, -0.68279624f, 0.41823629f, 0.29141337f, 0.25707120f, 0.09066401f, -0.51143312f, 
    0.39723998f, -0.13155028f, -0.63894582f, -1.06906152f, -0.03035002f, 0.06358721f, -0.53180194f, 0.08792447f, 
    0.08952346f, -0.75381917f, 0.20097050f, 0.52000213f, 0.18413717f, -0.75986177f, -0.52245873f, 0.37033245f, 
    -0.54610336f, 0.05528236f, 0.15924998f, -0.07964554f, 0.11693846f, 0.38010383f, -0.54238850f, -0.18460226f, 
    0.42343530f, -0.11320437f, -0.00115071f, -0.58817172f, 0.07457779f, 0.12382936f, 0.00907661f, 0.29195997f, 
    -0.07784028f, -0.05860280f, 0.33198303f, 0.29637161f, 0.13438046f, 0.14306901f, -0.31753933f, 0.00186877f, 
    -0.08653756f, -0.00725954f, 0.05064235f, 0.12558514f, -0.49197364f, -0.02689900f, 0.19284509f, 0.04889719f, 
    -0.02835843f, 0.05486218f, -1.09051883f, -0.17866412f, -0.49303025f, -0.22725211f, -0.08113690f, 0.05820425f, 
    -0.03567192f, -0.02373822f, -0.65963590f, 0.06066661f, 0.19251998f, -0.10864798f, -0.00560542f, 0.14983965f, 
    -0.02511582f, 0.35081992f, -0.78321379f, 0.22123642f, -0.01683705f, -0.11324085f, 0.02183249f, 0.03886501f, 
    0.40578496f, -0.09388775f, 0.17764165f, 0.16017671f, 0.00829977f, -0.33755124f, -0.19301282f, -0.19084330f, 
    0.16011342f, 0.02880400f, 0.14893354f, 0.02702735f, -0.14094646f, 0.00024099f, 0.05440288f, 0.14127320f, 
    0.19920991f, -0.02257158f, 0.09355818f, -0.57299381f, -0.76995468f, -0.49533936f, 0.04378825f, 0.19540942f, 
    -0.22910181f, -0.03637159f, 0.36353430f, 0.01776206f, -0.18428493f, -0.22663110f, 0.21918210f, 0.39902556f, 
    0.07832474f, -0.02092087f, 0.32252324f, -0.05423682f, 0.40502357f, -0.08884907f, -0.89213872f, 0.14038281f, 
    0.12626535f, 0.67542154f, 0.10595100f, 0.16281840f, 0.27205855f, 0.12998655f, -0.07911174f, 0.25532693f, 
    -0.06582432f, -0.06349035f, 0.35307059f, -0.16137059f, -0.97502434f, -1.07643294f, 0.16542135f, -0.35313961f, 
    0.38255590f, -0.01851446f, -0.31300709f, -0.32216650f, 0.01019112f, -0.00212158f, -0.33769584f, 0.22660068f, 
    -0.32759193f, 0.20962761f, 0.12400028f, 0.38469720f, 0.12979572f, -0.26294917f, -0.02370913f, -0.12637724f, 
    0.11877333f, 0.05948488f, 0.09287078f, -0.11665390f, 0.12891825f, -0.50083584f, -0.07248480f, -0.51200730f, 
    0.18136960f, -0.38138118f, 0.01443237f, -0.10260273f, 0.05063765f, -0.44608194f, 0.00216521f, -0.08897293f, 
    -0.00470896f, -0.05143569f, 0.11570583f, -0.15267996f, -0.26118684f, -0.53190058f, 0.44504699f, -0.32939234f, 
    0.01968383f, -0.09338050f, 0.16614659f, 0.21812645f, 0.19745341f, -0.06965834f, -0.28227821f, -0.20079817f, 
    -0.53527170f, 0.07663277f, 0.00155793f, 0.24082842f, -0.50221246f, -0.17240642f, 0.06006407f, -0.19096760f, 
    0.03023226f, -0.01677121f, -0.89701515f, 0.15923762f, 0.74750721f, -0.59253007f, -0.82306415f, -0.42185888f, 
    -0.65845412f, 0.33488196f, -0.62216693f, 0.35456857f, 0.04153594f, 0.03626116f, 0.54256624f, 0.15639667f, 
    0.25757393f, -0.35063121f, -0.71776867f, 0.21914519f, 0.28636390f, -0.01683717f, 0.16007173f, 0.24972631f, 
    0.10652591f, -0.13869311f, -0.04189935f, 0.03416178f, -0.06986594f, -0.16420557f, 0.13500993f, -0.00563294f, 
    -0.22036743f, 0.30860797f, -0.09109247f, 0.38964981f, 0.10421511f, -0.11324829f, -0.08509244f, 0.27024588f, 
    -0.83775878f, 0.05558470f, -1.07802975f, -0.03347902f, 0.19079480f, 0.17089066f, -0.59044164f, 0.12602782f, 
    -0.13446309f, -0.01174248f, 0.27460727f, -0.27178249f, -0.23369639f, -0.01556258f, -0.07310820f, -0.06049309f, 
    0.18758467f, -0.54463983f, 0.15835221f, -0.21347094f, -0.08538431f, 0.06649786f, 0.04791460f, 0.26983279f, 
    0.03870567f, 0.06529179f, -0.08511177f, -0.08638556f, -0.54169953f, 0.05148210f, -0.24080810f, 0.24664088f, 
    -0.87459815f, -0.64055258f, 0.10756421f, 0.23075916f, -0.00030733f, 0.05563267f, -0.10186931f, -0.17334588f, 
    -0.54565561f, -0.19489567f, 0.09765630f, -0.79132199f, 0.08423355f, 0.12686534f, 0.04757917f, -0.01255677f, 
    0.14284317f, -0.08692986f, -0.03564372f, -0.11626860f, -0.08665165f, -1.43520391f, 0.13039418f, -0.11247370f, 
    -0.74250066f, 0.19918002f, -0.03062039f, 0.10346337f, 0.16553591f, 0.23667631f, 0.07599382f, 0.16389255f, 
    -0.17267200f, 0.06078961f, -0.91320032f, 0.24733514f, 0.40648153f, 0.03443897f, 0.32070631f, 0.18676476f, 
    -0.07320258f, -0.01403386f, -0.03373471f, -0.85132676f, -0.19828609f, -0.00103278f, 0.23742400f, -0.10209309f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.31683058f, -0.08575484f, -0.34796655f, -0.34372941f, 0.29129851f, 0.00900322f, -0.16862015f, -0.41986540f, 
    -0.21136594f, -0.04530330f, 0.48251551f, -0.02276205f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
