#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.22107661f, -0.48890361f, 0.38842383f, 0.40371022f, -0.35206604f, -0.67304790f, 0.26323748f, -0.32613024f, 
    -0.09326215f, -0.64384151f, -0.02075476f, -0.17679809f, 0.27946171f, -0.10623571f, -0.00654801f, 0.16886438f, 
    0.21530209f, 0.05379011f, -0.31398097f, 0.25131115f, -0.12682122f, 0.20935874f, 0.06141393f, -0.10980801f, 
    0.38695490f, -0.95453393f, 0.22405940f, 0.18486409f, -0.37871024f, 0.81791645f, -0.54502308f, 0.45025665f, 
    0.41575459f, -0.72110200f, -0.65899837f, 0.08925460f, -0.17990336f, 0.42146936f, 0.18733653f, 0.28763971f, 
    0.14920896f, -0.06638425f, -0.16986713f, 0.18652160f, 0.08756815f, 0.04953369f, -0.26676810f, 0.04108051f, 
    0.08978944f, 0.07389646f, -0.70313448f, -0.10327757f, -0.50239742f, -0.50778407f, 0.15510772f, 0.16709597f, 
    0.69665414f, 0.48380575f, 0.34880093f, 0.45600870f, 0.13299654f, -0.23233655f, 0.21343037f, -0.28137487f, 
    0.17355199f, 0.04581324f, -0.04598461f, -0.15936850f, 0.02183492f, -0.06285282f, -0.05215090f, -0.13016887f, 
    -0.11597244f, -0.00458849f, -0.11051505f, 0.06991239f, -0.85255736f, -0.39826092f, -0.20580210f, 0.39248446f, 
    0.37801945f, -0.53338408f, 0.31598237f, 0.36857983f, -0.32936525f, -0.28484356f, -0.08638974f, -0.29930544f, 
    0.18312758f, -0.20493911f, 0.08879428f, 0.01423772f, -0.10860232f, -0.17784859f, -0.21554749f, 0.03071564f, 
    0.20811394f, 0.07815452f, -0.11478458f, -0.03032062f, 0.48680094f, 0.35063982f, 0.36634755f, 0.07879245f, 
    -0.91354972f, -0.08208380f, 0.02427972f, 0.27763900f, 0.40535751f, 0.28951040f, 0.28926900f, 0.19537777f, 
    0.24103473f, -0.09970382f, 0.07174317f, 0.23848459f, -0.27117297f, 0.24177596f, -0.00843825f, -0.10683247f, 
    0.27226707f, -0.12924705f, 0.34883550f, -0.22631961f, -0.06176024f, -0.41972563f, 0.19522004f, -0.34234327f, 
    -0.14025670f, -0.72629946f, 0.66497874f, -0.28280815f, 0.06231632f, 0.40261769f, 0.35060328f, 0.13034736f, 
    -0.39054903f, -0.09493987f, 0.15853007f, 0.18386284f, 0.26093498f, -0.18305425f, 0.06000608f, 0.10529488f, 
    0.09561806f, 0.03412630f, -0.28688580f, -0.01262578f, -0.23031045f, -0.13013723f, 0.70600504f, 0.39573219f, 
    0.18743767f, 0.78086108f, 0.40593630f, 0.45623523f, 0.29958034f, 0.10324594f, 0.41792497f, -0.14607076f, 
    -0.49147364f, 0.08423328f, 0.02027823f, -0.14905834f, -0.09281753f, -0.16795871f, 0.16947447f, -0.03828457f, 
    0.09131139f, -0.01803962f, -0.21077810f, -0.27990550f, 0.01966006f, 0.13926560f, 0.03720403f, -0.57997596f, 
    -0.81852055f, -0.17605358f, 0.38173008f, 0.09547625f, -0.97842282f, -0.18456455f, -0.06811459f, -0.44810197f, 
    -0.03772246f, 0.42526978f, 0.29522973f, -0.17899592f, -0.10402632f, -0.02376135f, 0.08926930f, 0.38059151f, 
    0.15118313f, -0.34151202f, -0.46368736f, -0.13469133f, -0.14046974f, -0.02924161f, 0.21646315f, 0.18188882f, 
    -0.33190671f, -0.65336341f, 0.29873830f, 0.21622168f, -0.23656967f, -0.33565620f, 0.70599991f, 0.55464154f, 
    0.20869504f, 0.41921002f, -0.22504349f, 0.14583986f, -0.38240117f, 0.38035414f, -0.07394766f, 0.09881018f, 
    -0.06981416f, -0.37844971f, -0.01477539f, -0.12461419f, 0.07234329f, 0.18201208f, 0.16292529f, 0.20144854f, 
    0.16270052f, 0.42231464f, 0.37864381f, 0.35901764f, 0.87288082f, 0.52426070f, -0.08462803f, 0.38592920f, 
    0.26417539f, 0.32403427f, -0.01886890f, 0.11124194f, -0.05066037f, -0.11343355f, -0.10983448f, -0.32626849f, 
    0.09745325f, -0.52852213f, 0.03965819f, -0.18103121f, -0.01823755f, 0.04709557f, -0.06590317f, 0.19631054f, 
    -0.03609002f, -0.33107960f, 0.93071735f, 0.52567518f, -0.56271774f, 0.20080908f, 0.27199566f, -0.25755477f, 
    0.31610894f, 0.61257952f, 0.44660687f, 0.31361651f, -0.00319225f, -0.28854835f, 0.37437600f, -0.48328865f, 
    0.28276014f, -0.13849734f, -0.22039843f, -0.12885995f, -0.33062103f, 0.18846017f, 0.03261422f, -0.01786581f, 
    -0.16161190f, 0.05014494f, -0.14787541f, 0.44587407f, 0.67401314f, 0.11759209f, -0.11935358f, 0.84179604f, 
    -0.22306719f, 0.25086164f, 0.47001964f, -0.19017357f, 0.42449203f, -0.52556139f, -0.37948120f, 0.29829994f, 
    0.21174565f, 0.10852605f, 0.11788081f, 0.12513666f, 0.08607849f, 0.20316851f, 0.37637231f, 0.23272674f, 
    -0.00926318f, -0.01950522f, -0.18907325f, -0.10176133f, 0.19755839f, -0.26778480f, 0.09859933f, 0.52782381f, 
    -0.04430550f, 0.37914991f, 0.32717979f, -0.54128093f, -0.07737049f, 0.35173783f, 0.30380216f, 0.46607620f, 
    -0.36937216f, 0.02453331f, -0.18321812f, 0.21534032f, -0.47324523f, -0.01137503f, 0.22973955f, 0.17291765f, 
    0.20573536f, 0.26188499f, 0.41033933f, -0.24418455f, -0.35189143f, -0.59233701f, 0.48152128f, -0.54160029f, 
    0.20698966f, -0.77223969f, 0.70006639f, 0.63873434f, -0.32883540f, -0.11506812f, -0.48212707f, 0.00834508f, 
    0.07246145f, -0.27377987f, -0.10048572f, 0.30890727f, -0.17440028f, -0.08222625f, -0.18199874f, -0.10658660f, 
    -0.29962093f, 0.25185466f, -0.00846323f, -0.01596034f, -0.03646953f, 0.00714241f, -0.52607781f, -0.53412557f, 
    -0.44666660f, -0.43192291f, -0.53830731f, -0.22335809f, -0.08987854f, 0.06681449f, -0.15044913f, 0.19046743f, 
    0.33588174f, 0.37266508f, -0.24366316f, 0.08878307f, -0.34412283f, 0.23015381f, 0.34110200f, 0.16715871f, 
    -0.06647376f, 0.35450655f, -0.18126447f, 0.18131767f, 0.11236889f, 0.25282776f, 0.38317132f, -0.18162319f, 
    -0.16848451f, 0.64677441f, 0.42672351f, -0.66310072f, -0.03954259f, -0.53299576f, 0.04079389f, -0.25866982f, 
    0.26241717f, -0.56810373f, 0.05393225f, -0.41703784f, -0.03872239f, -0.10253926f, -0.23961383f, 0.36556962f, 
    -0.19875234f, -0.14383319f, -0.45622566f, 0.09975217f, -0.10397144f, -0.25675407f, -0.27711925f, -0.18214546f, 
    -0.54214114f, -0.93028128f, -0.57982498f, -0.08406918f, 0.16925780f, 0.09464677f, 0.19454770f, 0.54602045f, 
    0.02145588f, -0.17880909f, 0.02113959f, -0.16147198f, -0.14784203f, 0.24594301f, -0.09091312f, -0.08592642f, 
    0.14488408f, 0.23064265f, -0.08513154f, 0.05950094f, -0.12075300f, -0.29516712f, 0.25413880f, -0.15441066f, 
    -0.03691511f, 0.56017119f, -0.94053674f, 0.10627032f, -0.18578331f, 0.15185621f, -0.67356795f, 0.76973695f, 
    -0.10638869f, -0.06623951f, 0.58214682f, 0.12939537f, 0.22786501f, -0.27548677f, -0.05134634f, 0.10970329f, 
    -0.23504174f, -0.29046801f, -0.32772326f, 0.07552086f, -0.29316601f, 0.02975827f, 0.05345659f, 0.15298733f, 
    0.08034340f, -0.02149813f, 0.01811005f, -0.18034589f, 0.70358592f, 0.32522440f, 0.72455645f, 0.02495821f, 
    0.14934599f, -0.51931828f, -0.33661377f, -0.11371924f, 0.41706291f, 0.27369073f, 0.36542493f, 0.45579067f, 
    -0.37023556f, -0.03587873f, -0.21485960f, 0.00617032f, -0.13521753f, 0.09326977f, -0.13081966f, -0.04245312f, 
    -0.17321266f, 0.11250777f, -0.16562857f, 0.06301407f, -0.71628791f, -0.66077417f, -0.16738144f, -0.55151421f, 
    -0.13686712f, 0.71666414f, 0.26929080f, 0.12284569f, 0.44350985f, 0.41831887f, 0.10654254f, -0.14601302f, 
    0.06773447f, -0.00574319f, 0.15160118f, 0.20442390f, -0.03267774f, 0.05576756f, -0.05036644f, 0.11328133f, 
    0.02576609f, 0.09343591f, 0.17206138f, -0.23820730f, -1.00389206f, 0.31520727f, -0.01140476f, -0.66747552f, 
    -0.30987409f, 0.28540799f, 0.29464108f, -0.09001999f, 0.62124372f, 0.17631158f, 0.05432729f, 0.15955725f, 
    -0.28860927f, 0.14731747f, 0.20220686f, 0.27472189f, 0.30001572f, -0.03817425f, 0.00031625f, 0.22643721f, 
    -0.23297779f, -0.34299821f, 0.09085227f, -0.30514207f, 0.28781316f, -0.72488075f, -0.57151651f, -0.32382649f, 
    0.27546793f, -0.20588410f, 0.00504697f, 0.02766296f, -0.74714327f, -0.22332148f, -0.41818061f, 0.15356855f, 
    0.08212338f, 0.06928901f, 0.20567636f, 0.10356861f, 0.04293142f, -0.00529411f, 0.25689751f, -0.00123738f, 
    -0.10206260f, -0.07031034f, -0.03309280f, -0.37259400f, -0.05262532f, -0.01653978f, 0.01772707f, -0.61836815f, 
    0.61851352f, 0.66009051f, -0.35729867f, -0.03612594f, -0.02835547f, 0.57801908f, 0.02736150f, 0.15104951f, 
    0.18987535f, -0.43667844f, -0.21075630f, 0.04193682f, 0.25739187f, -0.16682270f, -0.09333135f, 0.03101473f, 
    -0.06741184f, 0.25676146f, -0.25402859f, 0.19997388f, 0.11802314f, -0.08613315f, 0.20190619f, 0.42069438f, 
    -0.44302964f, -0.84980243f, -0.75515819f, -0.30760986f, -0.33473438f, 0.77024078f, 0.07048052f, -0.20495687f, 
    0.32221854f, -0.18615404f, -0.18682766f, -0.01970712f, -0.15801236f, -0.06354100f, -0.10648578f, 0.04197580f, 
    -0.20250168f, 0.04097861f, -0.13269861f, 0.03601245f, -0.09779425f, 0.31137919f, -0.25967360f, 0.24380283f, 
    0.47040060f, 0.65921009f, 0.84115046f, -0.01316148f, 0.37028703f, 0.50191611f, 0.01392589f, -0.12325420f, 
    0.03639776f, -0.15544982f, 0.15277904f, 0.08642878f, 0.28611693f, 0.29832852f, -0.37298787f, -0.18599685f, 
    0.02741147f, 0.01110603f, -0.00093982f, -0.10835057f, -0.13044733f, -0.10336607f, 0.08333881f, -0.06830259f, 
    -0.05583673f, -0.83906502f, 1.17732179f, -0.11887459f, -0.56219125f, 0.13435465f, -0.40899178f, 0.68066496f, 
    0.23681253f, -0.01635069f, 0.13569541f, -0.30201301f, 0.21470127f, 0.18325911f, -0.39417699f, 0.10859576f, 
    0.45392275f, 0.18485977f, 0.15844499f, 0.18164361f, -0.18190664f, -0.06139994f, -0.05364999f, -0.09590226f, 
    -0.15709706f, 0.17806976f, -0.97508568f, -0.48129341f, -0.21695344f, -0.46116143f, -0.43935063f, 0.02559166f, 
    -0.64447534f, 0.25024185f, 0.26549104f, -0.03294289f, 0.26890326f, 0.32270265f, -0.04898094f, 0.17050414f, 
    0.03046258f, -0.45453367f, 0.32457948f, -0.26231512f, -0.03126618f, 0.14925493f, 0.23720783f, -0.07820663f, 
    -0.04024788f, 0.04430865f, -0.09785552f, -0.31004244f, -0.56316656f, -0.35536808f, -0.50785899f, 0.51965177f, 
    -0.13962056f, 0.30870888f, 0.44473386f, 0.07217597f, 0.22112207f, -0.40542740f, -0.44889536f, -0.31874073f, 
    -0.06785941f, -0.24795453f, 0.16313049f, -0.34671891f, 0.19532287f, -0.37988165f, -0.21548167f, -0.15150885f, 
    -0.13228056f, 0.36027056f, 0.29913905f, -0.06504133f, 0.80976552f, -0.24657297f, -0.40680248f, 0.36095738f, 
    -0.17839648f, 0.46557695f, -0.41477677f, 0.36274850f, 0.64072710f, 0.27160752f, -0.37786442f, 0.04709848f, 
    0.01309028f, -0.09149933f, -0.04520307f, -0.12417955f, -0.06118034f, 0.07194288f, -0.01190441f, 0.01594369f, 
    0.28682461f, 0.05555967f, -0.01551816f, 0.31484175f, 0.12715745f, 0.61385000f, -0.18303077f, -0.81829041f, 
    0.82845432f, -0.32850742f, -0.01307329f, 0.39144424f, -0.39511842f, 0.41801235f, 0.18209960f, -0.05228483f, 
    -0.11786373f, -0.24121973f, 0.09248024f, 0.05641783f, 0.10048693f, 0.13520558f, -0.02848875f, -0.11817299f, 
    0.20194562f, 0.03533699f, -0.10873521f, 0.07777563f, 0.24096343f, -0.19389489f, 0.85742927f, -0.05594864f, 
    -0.18942261f, -0.41786268f, -0.03641625f, -0.03547411f, 0.15188375f, 0.27855799f, -0.04712467f, -0.34408757f, 
    -0.27013636f, -0.33565691f, -0.15328099f, 0.08559515f, 0.24191463f, -0.19691196f, 0.33056951f, -0.00167923f, 
    -0.37673053f, -0.11737035f, 0.48732713f, -0.04818816f, 0.38510367f, -0.00397105f, -0.23389369f, 0.68099314f, 
    0.92583030f, -0.50161433f, -0.07420804f, -0.55406284f, 0.31836405f, -0.07652524f, -0.43026122f, -0.43623409f, 
    0.09976947f, 0.19858627f, 0.27485460f, -0.03267651f, 0.04753178f, -0.28444344f, 0.14583860f, -0.10923643f, 
    0.21503593f, 0.19572441f, -0.00351217f, -0.45726356f, 0.14193246f, -0.14802609f, -0.37425524f, -0.27698058f, 
    -0.55107778f, 0.03842381f, 0.54882836f, 0.11944857f, 0.25667790f, -0.78534567f, -0.14681181f, -0.27865791f, 
    -0.38935658f, -0.69282788f, 0.14756426f, 0.51810378f, 0.07344232f, -0.06595859f, 0.12289112f, 0.09900549f, 
    0.12559347f, 0.24088551f, 0.18704605f, 0.42516488f, 0.33657560f, 0.13096735f, -0.31745523f, -0.07737245f, 
    -0.12036673f, -0.49953225f, 0.64669603f, 0.36460945f, 0.20319755f, 0.46502262f, 0.68741781f, 0.13872239f, 
    -0.55089951f, 0.37499049f, -0.38595903f, -0.40746403f, 0.16786684f, -0.10189553f, 0.46848416f, -0.15778159f, 
    -0.17580570f, 0.06751462f, 0.27717403f, -0.33894491f, -0.01320332f, -0.32535344f, -0.08442570f, -0.05651649f, 
    -0.14610289f, -0.30268407f, -0.99370164f, 0.53454477f, 1.05869329f, 0.02602116f, 0.14263666f, 0.72875816f, 
    -0.26252013f, -0.17794268f, 0.21926565f, -0.36555845f, -0.29595396f, -0.24592412f, -0.12190530f, 0.10662744f, 
    -0.00123236f, -0.02044946f, 0.06587725f, -0.15062431f, -0.18248877f, -0.06057164f, -0.04391614f, 0.09581615f, 
    -0.31096461f, -0.09060904f, -0.27625549f, -0.01466331f, 0.65816343f, 0.49757791f, -0.06215299f, -0.24079931f, 
    -1.00644946f, 0.25024828f, -0.11975311f, -0.26916412f, -0.68726510f, 0.32993600f, -0.16764367f, -0.45379236f, 
    0.01489031f, 0.00972649f, 0.03209488f, -0.36832041f, -0.07674643f, 0.25536054f, -0.14947519f, -0.32692784f, 
    -0.17106679f, 0.09332828f, 0.13461232f, 0.14872098f, 0.40338075f, 0.59431881f, -0.63226402f, -0.86108303f, 
    -0.25455895f, -0.22681759f, -0.72687685f, -0.26992640f, 0.20110631f, -0.33200473f, -0.08627389f, 0.31365851f, 
    0.12553197f, 0.34029838f, 0.00979906f, 0.14338645f, -0.14300671f, -0.16238752f, 0.11715321f, -0.01895961f, 
    0.07725929f, -0.09830693f, -0.06205247f, 0.10495286f, 0.37005302f, 0.34728426f, -0.24721453f, -0.21386333f, 
    -0.16994739f, -0.03580350f, -0.31432343f, -0.15244144f, 0.35728806f, -0.29586542f, 0.42251381f, -0.24829338f, 
    0.39507762f, 0.15118244f, -0.42005131f, 0.09341619f, 0.06134426f, 0.20220950f, 0.14744671f, -0.15560496f, 
    -0.20737128f, 0.22477393f, 0.00092018f, -0.27980527f, -0.22154528f, -0.10590915f, -0.70548296f, -0.61580187f, 
    0.36390051f, -0.08474669f, -0.37104777f, -0.51577079f, -0.37058118f, 0.16611981f, 0.32349622f, -0.34417495f, 
    0.10211669f, -0.24244808f, -0.15174538f, 0.11098932f, 0.24575518f, 0.17553094f, -0.29838395f, 0.26568753f, 
    -0.21623313f, -0.37419102f, 0.26724666f, 0.23478869f, -0.10557934f, 0.27617809f, -0.05597118f, 0.76020736f, 
    0.79585850f, 0.56275862f, -0.28442082f, -0.15799265f, -0.51961690f, 0.23218800f, -0.32280076f, 0.01705937f, 
    0.50247496f, 0.10025605f, -0.07595260f, -0.04943655f, 0.20398277f, -0.00736926f, -0.11453983f, 0.00222449f, 
    0.35522237f, 0.12865536f, -0.23365201f, 0.25926593f, 0.05326487f, 0.05208030f, 0.11856165f, 0.33835709f, 
    0.29323977f, 0.42184639f, 0.16011991f, 0.31260926f, 0.45552081f, -0.22773866f, 0.36310726f, 0.19713402f, 
    0.24605307f, 0.48050749f, -0.26968667f, 0.32089379f, 0.39624894f, -0.02627697f, -0.03543141f, -0.11583038f, 
    0.07532919f, -0.01282398f, 0.31483689f, 0.10264396f, -0.45370170f, -0.16743152f, 0.13346638f, 0.39821079f, 
    0.13029641f, 0.07328747f, 0.54188764f, 0.30555505f, -0.14341885f, -0.23924409f, -0.45119920f, 0.37978449f, 
    0.05738661f, -0.01622478f, -0.66441685f, -0.09695215f, -0.05920951f, -0.16863850f, 0.30178654f, 0.04948682f, 
    0.09071277f, -0.19568384f, -0.42162049f, 0.03569437f, -0.07650679f, -0.19150935f, 0.22726610f, 0.24485332f, 
    0.02997170f, 0.15895665f, -0.41964787f, -0.35757110f, -0.32635465f, 0.76420557f, 0.50662845f, 0.57086945f, 
    0.50912559f, -0.29007190f, 0.39060521f, -0.25752369f, 0.00253645f, 0.06295731f, -0.33997205f, -0.23271646f, 
    -0.32528234f, 0.08193505f, 0.10960878f, -0.23518258f, -0.36958301f, 0.08187316f, 0.20890418f, 0.04134432f, 
    0.21245992f, 0.16385300f, 0.01640892f, -0.65822428f, 0.30974430f, -0.49808893f, -0.24458341f, 0.21370761f, 
    -0.74502552f, -0.23674847f, 0.34433532f, 0.27497467f, 0.38307714f, -0.21796128f, 0.01480892f, 0.43549442f, 
    -0.25200811f, 0.14745578f, 0.02117287f, -0.17947908f, -0.22602178f, -0.30248994f, -0.44963992f, 0.15585868f, 
    -0.05256622f, -0.12016152f, 0.16403249f, -0.03356838f, 0.94799966f, 0.65059173f, 0.65218204f, -0.05832681f, 
    0.23650093f, -0.36422038f, -0.59701377f, -0.16126364f, -0.19310872f, 0.17895290f, -0.20309913f, 0.13872159f, 
    0.11955541f, 0.24681272f, 0.16765149f, -0.10328352f, -0.15483327f, -0.02009810f, -0.06631040f, -0.02671585f, 
    -0.09055652f, 0.31530079f, 0.00170576f, -0.01612966f, 0.24749677f, 0.56720430f, 0.55202168f, 0.24100491f, 
    -0.16117525f, -0.05274820f, -0.45925522f, -0.26760170f, 0.08470815f, -0.11581235f, 0.60874557f, 0.26319325f, 
    0.01246017f, -0.10835351f, 0.04603234f, -0.20664676f, -0.10403681f, -0.22095206f, -0.03079059f, 0.40542683f, 
    -0.05877088f, 0.23112153f, -0.07637035f, -0.37901953f, -0.04379606f, 0.20630866f, -0.38073888f, -0.28216973f, 
    -0.48942506f, -0.54861385f, -0.50888366f, 0.00276129f, 0.01928188f, -0.03932348f, 0.22810985f, 0.36073649f, 
    -0.48873526f, -0.04500754f, -0.40821183f, -0.13764893f, -0.50309169f, -0.13549894f, -0.01305335f, 0.41890356f, 
    0.13264953f, -0.02732534f, 0.01407060f, 0.04681675f, -0.46088657f, 0.00358586f, 0.02676090f, 0.84277463f, 
    0.49067727f, 0.49366581f, 0.79045779f, 0.28891882f, -0.61855441f, 0.46815214f, -0.43303081f, -0.35636458f, 
    0.08220890f, 0.28292066f, -0.01196850f, -0.25456619f, 0.01259876f, -0.28077361f, -0.19345115f, -0.18225750f, 
    0.01034379f, 0.19907662f, -0.37362102f, 0.15559448f, 0.40927741f, 0.16552889f, 0.27739057f, 0.02255000f, 
    -0.82591003f, 0.43065390f, 0.11367600f, 0.14087078f, -0.30801192f, -0.10350310f, 0.41162077f, 0.13731061f, 
    0.39561662f, -0.00408887f, -0.33576888f, 0.23199457f, 0.30169383f, -0.04168451f, -0.31960890f, -0.35402596f, 
    0.04698863f, 0.13841838f, -0.12813845f, 0.02726521f, 0.34828648f, 0.18007597f, -0.08644776f, 0.19827123f, 
    0.34637290f, 0.62505627f, 0.55778307f, 0.49955574f, 0.23651300f, 0.64973360f, 0.61868286f, -0.02811949f, 
    0.02040927f, -0.14612740f, 0.19800958f, -0.20544410f, -0.00810298f, -0.11339852f, -0.14175297f, 0.08418866f, 
    0.40454206f, 0.16858022f, 0.08058149f, 0.05168495f, 0.05275142f, 0.38395169f, 0.33454430f, -0.09556220f, 
    -0.03110356f, 0.35581106f, -0.30650747f, -0.24431519f, 0.03801661f, 0.13745433f, 0.47191787f, -0.55038249f, 
    -0.54121304f, -0.64451241f, -0.61150914f, -0.42223531f, -0.35345367f, 0.14642416f, 0.32081279f, 0.29153350f, 
    0.03944066f, 0.22600658f, 0.12350990f, 0.13269962f, 0.07608617f, 0.04911033f, -0.15207753f, 0.07400522f, 
    0.28497189f, 0.09298563f, -0.19077042f, 0.71014655f, 0.63012058f, 0.50908244f, 0.60954356f, 0.38168341f, 
    0.46717721f, -0.23183379f, -0.38644567f, -0.11745719f, -0.47401375f, 0.34064394f, 0.33666098f, -0.21199679f, 
    0.14214790f, -0.17215060f, 0.12706117f, -0.10504422f, -0.06592041f, 0.00933028f, 0.12174255f, -0.18967110f, 
    -0.09222799f, -0.14591381f, -0.05376347f, 0.39567450f, -0.05164513f, -1.29136920f, -0.51437122f, 0.19697647f, 
    0.06743948f, 0.61967421f, 0.47229645f, 0.26703879f, 0.07558993f, 0.33987737f, -0.33233652f, 0.21410444f, 
    -0.04533033f, 0.29031736f, 0.12096461f, -0.37055552f, 0.12547489f, 0.10821062f, 0.02819094f, 0.12156998f, 
    0.02982889f, -0.01522473f, 0.03897248f, -0.16183147f, 0.14566197f, -0.74112219f, 0.34456468f, -0.22555448f, 
    -0.20871818f, -0.49559370f, 0.42710111f, 0.64302963f, -0.33742142f, 0.03745891f, 0.63021386f, -0.43928832f, 
    0.07518109f, 0.10722984f, 0.02816801f, 0.01693464f, -0.34088627f, 0.10013456f, -0.14101443f, -0.06437108f, 
    -0.12222659f, -0.34039876f, -0.28124979f, -0.09410574f, -0.22857021f, -0.06788713f, 0.31030670f, -0.60087085f, 
    -0.11332077f, 0.00459732f, 0.20090847f, 0.51241976f, -0.47991326f, -0.15029527f, 0.23583724f, 0.07591455f, 
    0.40719941f, 0.08057436f, -0.22747084f, 0.14089574f, 0.43051872f, 0.00339612f, -0.09856308f, -0.24140580f, 
    0.16766442f, 0.45138100f, 0.31879050f, -0.27351382f, 0.20588744f, -0.16873373f, 0.17940460f, 0.63050568f, 
    -0.13362199f, -0.08137532f, 0.92537081f, 0.69189739f, -0.12825498f, 0.08034056f, 0.17935997f, 0.15940748f, 
    0.04698854f, -0.05804793f, -0.15389119f, 0.12132488f, 0.05650910f, 0.26286858f, 0.20291588f, -0.38726085f, 
    0.13567474f, -0.18196416f, 0.29445726f, 0.03233626f, 0.34750441f, 0.44594160f, -0.30443424f, -0.16901645f, 
    0.04553911f, -0.71524262f, -0.18579625f, 0.73471338f, -0.24355948f, -0.60555691f, 0.14368047f, 0.40761289f, 
    -0.62368065f, -0.35108602f, -0.15312485f, -0.06696466f, 0.11457597f, 0.26524124f, 0.13599725f, -0.10692939f, 
    -0.35896081f, 0.20514831f, -0.04492446f, -0.04673638f, -0.21749650f, -0.03100477f, 0.15996855f, -0.01856051f, 
    0.26774564f, -0.48185784f, -0.07273363f, 0.06731271f, -0.73042005f, 0.03448837f, 0.15367956f, -0.45136142f, 
    -0.46878901f, -0.66019672f, -0.40495345f, -0.15138988f, 0.03530265f, -0.01424906f, 0.32047856f, 0.10302624f, 
    -0.32377267f, -0.17751081f, -0.33743775f, -0.44163689f, -0.06021981f, 0.04812243f, 0.18227378f, 0.14188823f, 
    0.27289334f, 0.10995159f, -0.78529727f, 0.67433196f, 0.62697035f, -0.34318683f, -0.22116026f, -0.57389235f, 
    0.16539823f, 0.10076368f, 0.23321381f, -0.38911328f, -0.10352853f, 0.04761636f, -0.51953149f, -0.08422786f, 
    0.03284959f, -0.05480206f, -0.11241762f, -0.10636075f, -0.24322301f, 0.02760058f, 0.29746053f, 0.25402001f, 
    0.19154406f, -0.10975521f, -0.33789647f, -0.29829323f, -1.02527821f, 0.41979679f, 0.58041942f, 0.06292695f, 
    0.35808361f, 0.53903174f, 0.75849146f, -0.31797475f, -0.43436164f, -0.11908565f, -0.12600404f, -0.28366262f, 
    0.33761960f, -0.15197015f, 0.01662074f, 0.35043240f, -0.40041119f, 0.00587987f, 0.14377199f, 0.19776900f, 
    -0.02819214f, 0.10336851f, 0.11757924f, 0.01051222f, 0.51382554f, 0.02139481f, 0.39917195f, 0.72728455f, 
    0.63488090f, 0.23878820f, -0.08696043f, -0.17128441f, -0.26317126f, -0.08877542f, -0.07660209f, -0.34855333f, 
    -0.28708300f, -0.04693424f, 0.03547174f, 0.26204398f, 0.32814121f, 0.34970173f, 0.22976883f, 0.02168297f, 
    0.03824105f, -0.20861770f, 0.17190085f, -0.11285062f, 0.22766255f, 0.61058056f, 0.42078915f, 0.00544829f, 
    -0.58418006f, -0.90558201f, -0.02859368f, -0.06794251f, 0.29034689f, -0.02278413f, 0.05039270f, 0.34117332f, 
    0.29581466f, 0.35632336f, -0.09585569f, -0.10369188f, -0.47203752f, -0.20476073f, 0.13358085f, 0.08402670f, 
    -0.04488054f, 0.15220134f, -0.02749526f, -0.00492496f, 0.17552795f, 0.17161773f, 0.04010753f, 0.51068389f, 
    -0.42636350f, -0.58592165f, 0.00274612f, 0.65645957f, -0.54711789f, 0.17888018f, 0.52150869f, 0.30333549f, 
    -0.32906488f, -0.25351909f, -0.17672388f, -0.23353517f, -0.24711405f, 0.39830393f, 0.14070025f, -0.35358191f, 
    -0.36704224f, 0.34281281f, -0.06051855f, -0.09989668f, 0.13607317f, 0.02433372f, -0.33598539f, -0.09806680f, 
    -0.20914112f, -0.26315966f, 0.01048983f, 0.46379602f, -0.03657738f, 0.38304263f, 0.53683847f, 0.30516446f, 
    0.41281900f, -0.36588261f, -0.45305541f, -0.13359064f, -0.02493811f, -0.32167709f, 0.37186173f, 0.21115576f, 
    0.28961787f, 0.35172817f, -0.35521433f, 0.03143239f, 0.10604368f, -0.35971877f, 0.05815689f, 0.00470087f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12766045f, 0.17944983f, -0.14208880f, 0.13817836f, 0.13752647f, -0.11733816f, -0.01116514f, 0.13076091f, 
    -0.05069456f, -0.00931522f, 0.04611771f, 0.00644496f, -0.05630264f, 0.14357692f, -0.02068534f, 0.14797163f, 
    0.11553019f, 0.00302978f, -0.09748831f, 0.05286996f, 0.15095261f, -0.09500042f, 0.11705402f, 0.14186631f, 
    0.11198587f, 0.03461049f, 0.05398631f, -0.17549117f, -0.16585115f, 0.02137020f, -0.07249517f, -0.12103837f, 
    0.05366487f, 0.05565032f, -0.00016066f, -0.00126519f, 0.14280955f, 0.08046214f, 0.03138572f, 0.21194571f, 
    0.10976025f, 0.09485401f, 0.12750565f, 0.06323390f, 0.05151275f, 0.10014543f, -0.12538801f, 0.00519213f, 
    0.13354337f, 0.25550732f, -0.06760958f, 0.00601403f, 0.20235769f, -0.03927188f, -0.01405206f, -0.04355973f, 
    0.06899528f, 0.28136989f, -0.02814484f, -0.05368774f, -0.09562339f, 0.12604003f, -0.16810143f, 0.15306588f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.20562287f, 0.01524266f, 0.09777877f, 0.22474596f, -0.04240583f, -0.05637398f, 0.01088099f, -0.08108815f, 
    0.07838461f, -0.03173430f, -0.09478462f, -0.10792847f, -0.44867632f, 0.11823998f, -0.05196977f, -0.03900539f, 
    -0.03686646f, 0.00054643f, -0.04018227f, 0.04282105f, 0.02152073f, -0.03719279f, 0.05859737f, 0.01539465f, 
    0.18774882f, 0.26495203f, 0.13810866f, -0.20410877f, 0.01143233f, 0.12406446f, 0.01260943f, 0.01139819f, 
    0.01325362f, -0.01778403f, -0.06474922f, 0.07869310f, 0.10667113f, 0.01065783f, 0.10594777f, -0.02010600f, 
    0.06951034f, 0.04557787f, 0.02157287f, -0.04188757f, -0.03228675f, -0.07510337f, 0.04915326f, -0.11944611f, 
    -0.15368278f, 0.08676075f, -0.26562163f, 0.02566314f, 0.05040638f, -0.06374441f, -0.07470836f, -0.20468053f, 
    -0.01427600f, 0.00147327f, 0.06467585f, -0.09801995f, 0.39962551f, -0.01467347f, -0.21612470f, 0.00873662f, 
    0.01918720f, -0.00738673f, 0.08947555f, -0.10168057f, 0.04131959f, -0.08469386f, -0.01240083f, -0.02394824f, 
    0.11547493f, -0.01470121f, -0.10549793f, 0.12677576f, -0.13726284f, -0.00049109f, -0.03213460f, 0.07269151f, 
    0.01041370f, -0.07187954f, -0.00497552f, 0.06071410f, -0.26491779f, -0.31043118f, -0.23794946f, 0.25649926f, 
    -0.00775482f, -0.08968398f, -0.02032099f, -0.06546166f, -0.01111406f, 0.13021629f, -0.01996203f, 0.07866029f, 
    -0.12781473f, 0.00701939f, 0.00938174f, 0.10349665f, -0.09278028f, 0.08859679f, 0.02546215f, 0.04444229f, 
    0.08987291f, 0.04629053f, -0.05603483f, 0.01572843f, 0.10409493f, 0.09976050f, -0.08177942f, 0.20463203f, 
    -0.23135576f, 0.08989020f, -0.05057738f, 0.03259844f, 0.03186952f, -0.02650450f, -0.02209174f, -0.20391391f, 
    -0.22680557f, 0.10177811f, -0.09571006f, 0.00577386f, -0.11652439f, -0.01621041f, -0.04645897f, 0.07141147f, 
    -0.05806401f, -0.00603135f, 0.06932972f, 0.07331390f, 0.01217170f, -0.08198383f, 0.05709071f, -0.17068791f, 
    -0.14089501f, 0.07748090f, -0.06886591f, 0.00257500f, 0.10371639f, -0.01403117f, 0.04925653f, 0.02032797f, 
    -0.07171742f, 0.11205515f, 0.07197429f, 0.06701294f, 0.01661290f, 0.01117547f, -0.02956055f, -0.05610492f, 
    -0.00061840f, -0.04645268f, 0.11215278f, -0.08352248f, 0.33621943f, 0.13222665f, 0.08218385f, -0.13033566f, 
    -0.10005509f, -0.06847379f, -0.03212690f, 0.01965397f, 0.03308574f, 0.01788137f, 0.02169075f, -0.01439662f, 
    -0.22925563f, -0.14984806f, -0.12035071f, -0.12018113f, -0.07880744f, 0.09045804f, 0.10308239f, 0.14065218f, 
    -0.06390832f, 0.01784222f, 0.00805922f, -0.05314783f, -0.13325374f, 0.00223879f, -0.17407548f, 0.31586179f, 
    -0.04423038f, -0.11560307f, 0.10763866f, -0.08344009f, -0.02533941f, 0.02012531f, -0.00793256f, 0.04556427f, 
    -0.18269777f, 0.16392490f, -0.03302641f, -0.19932202f, 0.09379464f, 0.09947015f, 0.00476259f, 0.03579407f, 
    0.00116692f, -0.03506330f, -0.03691599f, 0.00586358f, -0.08494291f, -0.18070728f, 0.10534309f, -0.00688322f, 
    -0.02283428f, -0.13668609f, -0.03122810f, -0.02599676f, -0.07191924f, 0.15840997f, 0.02947729f, 0.01558072f, 
    0.02350094f, -0.09440735f, -0.07936207f, 0.12528066f, -0.20445617f, -0.04437415f, 0.03650640f, 0.04652074f, 
    0.04997576f, 0.07840268f, 0.02504692f, 0.00400242f, -0.06107144f, 0.09979685f, -0.03303102f, -0.18843108f, 
    -0.02764424f, 0.01379658f, -0.07680193f, -0.01799709f, -0.02946901f, -0.04846310f, 0.05970998f, -0.01537159f, 
    0.20219813f, -0.00357018f, 0.02104991f, -0.14475286f, 0.03044099f, 0.03276413f, -0.03469236f, 0.07011650f, 
    0.08533061f, 0.03319753f, -0.00351289f, -0.01981479f, -0.34991717f, -0.22502464f, 0.02664263f, 0.04705682f, 
    0.06803000f, -0.09057599f, 0.10627207f, -0.04251835f, 0.13902666f, -0.07020719f, -0.09384600f, -0.00999296f, 
    -0.01289217f, -0.01860650f, -0.15004882f, 0.21984871f, -0.06895011f, 0.05604839f, 0.05543323f, -0.02712519f, 
    0.03241568f, -0.09605908f, 0.03188924f, 0.08956831f, -0.29320839f, -0.05892808f, 0.09798589f, -0.41729394f, 
    -0.07334349f, -0.04425154f, 0.09999739f, -0.06975415f, -0.06888682f, 0.00693083f, 0.02839821f, 0.00359757f, 
    0.00467797f, 0.07325169f, 0.00375538f, -0.12885992f, -0.05609806f, -0.07191592f, 0.00005602f, 0.03401684f, 
    0.11680565f, 0.02393350f, -0.04016171f, 0.00966086f, 0.22014786f, 0.01616520f, 0.15168880f, -0.10382659f, 
    0.00574807f, -0.06392602f, 0.00984092f, -0.07839157f, 0.00331528f, -0.07991004f, -0.09915676f, 0.04125593f, 
    -0.12522149f, -0.16178463f, -0.18996598f, -0.01590626f, 0.02310413f, 0.01485758f, -0.02573606f, -0.04677545f, 
    0.01681400f, -0.14163676f, 0.06751152f, -0.20198378f, -0.10054768f, 0.21583287f, 0.11799043f, -0.24413894f, 
    0.01660909f, 0.03090114f, -0.07989916f, -0.00163726f, 0.01793893f, 0.05386266f, 0.08407465f, -0.02986028f, 
    0.36987507f, -0.11729165f, -0.11402512f, 0.12642917f, 0.12770385f, 0.01682436f, 0.00683819f, -0.00597831f, 
    -0.01767066f, -0.00029560f, -0.02355412f, 0.09489121f, -0.04164203f, 0.16532336f, 0.06210819f, 0.26671416f, 
    -0.06855264f, 0.06856128f, -0.09737971f, -0.00230785f, -0.04288473f, 0.01166374f, 0.02570906f, -0.01413551f, 
    0.05380146f, 0.07964396f, -0.00746967f, -0.04850047f, -0.05184556f, 0.01126409f, 0.01480050f, -0.04549085f, 
    -0.17892523f, 0.03938419f, -0.01189169f, -0.07535321f, 0.00555456f, 0.10313056f, 0.13781416f, -0.38870940f, 
    -0.10743432f, -0.00624277f, 0.00661530f, 0.07135152f, 0.02459908f, 0.01572279f, -0.08048937f, -0.07732002f, 
    -0.18985938f, 0.07248286f, 0.07051756f, 0.00352665f, -0.02348576f, 0.03001708f, 0.04035949f, 0.04829729f, 
    0.10780326f, -0.11813567f, 0.02800642f, -0.05152878f, -0.16963072f, 0.01525276f, 0.00002730f, 0.06034319f, 
    0.07362476f, -0.05229447f, 0.07923034f, -0.05125410f, 0.00824489f, 0.06037289f, -0.09485129f, 0.05591040f, 
    -0.21273509f, 0.02869609f, 0.14629497f, 0.26992244f, -0.11796924f, -0.06724150f, 0.09775013f, -0.04039993f, 
    -0.01787804f, 0.01834192f, -0.01060410f, -0.01860542f, 0.02330391f, 0.13977008f, -0.02280701f, -0.00717725f, 
    -0.10460111f, -0.03468120f, -0.03921330f, 0.05753239f, 0.01426176f, 0.03736103f, 0.09735571f, -0.17025852f, 
    -0.11761071f, -0.01423824f, 0.17573899f, -0.40297526f, -0.05157962f, 0.04306591f, -0.00827253f, 0.01991315f, 
    0.01281398f, 0.02963347f, 0.09766711f, 0.05291016f, -0.13522752f, -0.15746580f, 0.06473688f, -0.14578032f, 
    -0.05646170f, -0.04727591f, -0.07375561f, 0.02735796f, -0.00163333f, 0.05226460f, -0.06778120f, 0.08053257f, 
    -0.19611713f, -0.03710353f, -0.18032211f, 0.13638908f, 0.03337822f, 0.04919528f, -0.12867539f, 0.07894687f, 
    0.06582965f, 0.09464829f, -0.06877059f, 0.02269949f, 0.04801981f, 0.06811021f, -0.02370938f, -0.10174479f, 
    -0.05353550f, -0.03870446f, -0.00994607f, -0.00607514f, -0.06037601f, 0.02207091f, -0.06915227f, 0.00928813f, 
    0.07194217f, -0.07482015f, -0.08100588f, 0.09616789f, -0.03716516f, -0.04180890f, -0.11430375f, 0.05679971f, 
    0.03017689f, -0.02225762f, 0.03665780f, 0.06721994f, -0.10716793f, 0.02743816f, -0.00375402f, 0.00340225f, 
    -0.12386602f, -0.01721352f, -0.11246465f, 0.06801914f, -0.01220577f, -0.06970660f, -0.06820792f, -0.06731799f, 
    -0.15002482f, 0.25618649f, 0.10085288f, 0.12638815f, 0.12006948f, 0.02936214f, -0.13078715f, 0.05229301f, 
    -0.04830458f, 0.06090305f, -0.05359644f, -0.13260576f, 0.00883187f, 0.03861373f, -0.11863296f, 0.05352713f, 
    0.01111321f, -0.05830834f, -0.13199165f, -0.07718986f, -0.04342139f, 0.08794750f, 0.06023880f, -0.04479268f, 
    0.24618933f, 0.09567460f, 0.02073094f, -0.19398394f, -0.12581193f, -0.08358146f, -0.06722584f, 0.12615475f, 
    -0.00625408f, 0.00976157f, -0.09931841f, 0.01720392f, 0.03470759f, -0.01347757f, 0.05888121f, -0.13242090f, 
    0.06406566f, 0.04302502f, -0.05583393f, -0.05274488f, -0.05265727f, 0.02274205f, -0.02253299f, -0.08999684f, 
    0.10665133f, -0.04067048f, -0.14413074f, -0.20465836f, -0.00890871f, -0.00173303f, 0.03142003f, 0.03741688f, 
    -0.01568889f, -0.02353657f, 0.06335142f, -0.01959369f, 0.17296089f, 0.11389581f, 0.02738271f, 0.23191617f, 
    -0.14621656f, -0.09295417f, -0.05554881f, 0.05897736f, -0.10052518f, -0.03517143f, -0.08502261f, -0.07344887f, 
    0.13861442f, 0.16107063f, -0.09012350f, -0.05688358f, -0.02995785f, 0.06119151f, 0.01631920f, 0.03586364f, 
    -0.05879272f, -0.01258856f, -0.11923216f, 0.00096525f, 0.11831861f, -0.09215309f, 0.04272353f, -0.06380598f, 
    -0.06274135f, -0.04625407f, 0.04623299f, 0.04911368f, -0.00751392f, 0.05080915f, -0.04354089f, 0.00988351f, 
    -0.03960123f, -0.07122494f, -0.05144325f, 0.11145024f, 0.09586036f, -0.04044481f, 0.04008050f, 0.02802340f, 
    0.02314197f, -0.08381318f, -0.08398565f, -0.06430040f, 0.10113379f, 0.04408097f, 0.03192677f, 0.01237964f, 
    -0.19994198f, -0.09144804f, 0.06016708f, 0.11850738f, 0.10027222f, 0.03229937f, -0.06032309f, 0.02961475f, 
    -0.00186210f, 0.01398298f, -0.10539236f, -0.04418337f, 0.01127529f, 0.00471683f, -0.02915872f, 0.03851930f, 
    -0.06214627f, -0.00525882f, -0.00572146f, 0.10725024f, 0.38928697f, 0.04190901f, 0.03361552f, -0.16906679f, 
    -0.02574957f, 0.06090590f, -0.04161849f, 0.04381130f, 0.14467210f, -0.08050090f, -0.04336737f, 0.07514226f, 
    0.00182276f, -0.14013140f, 0.08954221f, 0.04332484f, -0.09978750f, -0.00487592f, 0.03407265f, -0.02076145f, 
    0.07750843f, -0.03947261f, 0.07441551f, 0.04491032f, 0.15768744f, 0.03368173f, -0.17412265f, 0.26193956f, 
    -0.19642597f, 0.13224807f, -0.20321828f, 0.03688979f, -0.05746968f, -0.00297010f, -0.02499394f, -0.19929102f, 
    0.01151935f, 0.08056215f, -0.10913245f, 0.25062108f, -0.04009859f, 0.00990604f, -0.05683756f, 0.01896390f, 
    0.05170522f, 0.07088229f, -0.01160633f, 0.04371716f, -0.34370714f, -0.00087355f, 0.08326354f, -0.20629025f, 
    0.01485196f, 0.02203013f, 0.03332004f, -0.04432116f, -0.04918295f, -0.05094161f, 0.00952571f, 0.04086111f, 
    -0.17885827f, 0.01339955f, 0.02902527f, 0.16835004f, 0.02909743f, 0.04956745f, -0.00137533f, -0.14095610f, 
    0.00439617f, -0.04940962f, 0.04335370f, 0.04275284f, -0.38834214f, 0.23564532f, -0.00266078f, 0.22827981f, 
    0.00984936f, 0.04624939f, 0.02364524f, -0.01027638f, 0.01643399f, -0.11083095f, 0.02494612f, -0.05653182f, 
    0.14633110f, -0.14068538f, 0.02249034f, 0.24350689f, -0.20831355f, 0.02722396f, 0.06367606f, 0.10125634f, 
    0.03848217f, -0.04964131f, -0.02315770f, 0.06355464f, -0.40259063f, -0.05322674f, -0.06448206f, -0.05996240f, 
    -0.02556342f, -0.01281275f, 0.02592133f, -0.08219264f, -0.07541293f, -0.08039432f, 0.01762486f, 0.11090004f, 
    0.31102648f, -0.10043344f, 0.11634236f, -0.14458078f, -0.18281522f, 0.06302683f, 0.18517968f, -0.07539112f, 
    -0.06980594f, -0.04382532f, 0.02461845f, 0.07776595f, -0.01416879f, 0.12523647f, 0.01528453f, 0.05933156f, 
    0.02290216f, 0.09790242f, 0.04594230f, -0.04344301f, -0.05271761f, 0.06283658f, -0.00648506f, 0.02089865f, 
    -0.10731223f, -0.14716420f, -0.16002060f, -0.15185006f, 0.04042464f, 0.10604351f, -0.02959101f, -0.02074817f, 
    0.06909083f, 0.09995887f, 0.11075255f, 0.00171274f, 0.18927765f, 0.16271363f, -0.12756008f, -0.18286088f, 
    0.07136665f, 0.11852261f, -0.00415070f, -0.06686043f, -0.04599420f, 0.05547635f, -0.08312244f, -0.04997363f, 
    0.17490080f, 0.03451858f, -0.11601762f, -0.10857175f, 0.03850220f, 0.02092665f, -0.09099068f, 0.12229920f, 
    0.01864255f, -0.01355299f, 0.00111222f, 0.02116052f, 0.07050741f, -0.10051489f, 0.00323446f, -0.14572480f, 
    -0.04309231f, 0.01427913f, 0.02451031f, -0.00333659f, 0.10600647f, 0.08665644f, -0.03043884f, 0.00392409f, 
    -0.00299674f, -0.08316672f, -0.07005753f, -0.03516788f, -0.04447688f, -0.03826002f, -0.00401550f, 0.08263955f, 
    -0.04263855f, -0.02994590f, 0.07763547f, 0.09063943f, -0.27215651f, -0.04297125f, 0.04406526f, -0.09837089f, 
    0.14357810f, -0.07184988f, -0.03303325f, -0.08169038f, 0.03835820f, 0.06524090f, -0.00305900f, 0.01315251f, 
    0.17544135f, 0.04411503f, 0.03312282f, 0.23576781f, -0.06833908f, 0.03144269f, 0.00412205f, 0.03187011f, 
    0.02480250f, 0.01394721f, 0.01271329f, -0.04158401f, -0.01747533f, -0.02140158f, -0.09723202f, 0.07199828f, 
    0.07662138f, 0.05615146f, -0.10058794f, 0.15929601f, 0.00434264f, -0.15305994f, 0.12694481f, 0.08112067f, 
    0.05677927f, -0.01117195f, -0.10017627f, 0.03707429f, -0.00949455f, -0.02626870f, 0.00521598f, -0.04515514f, 
    0.07280979f, -0.02074316f, -0.22421189f, 0.00791714f, 0.21186890f, -0.02000106f, 0.15071617f, 0.29127395f, 
    -0.07301400f, 0.00142971f, 0.09074616f, 0.04129252f, -0.04705726f, -0.02663271f, 0.03841939f, 0.13669915f, 
    0.39530006f, -0.03423185f, 0.18115185f, 0.15264101f, 0.01655273f, -0.02613245f, -0.06981016f, -0.01317602f, 
    -0.01124237f, -0.00143186f, -0.25924161f, 0.04757536f, 0.22765702f, 0.08278563f, -0.00709268f, 0.02737057f, 
    -0.02267206f, -0.09296189f, -0.07162284f, 0.00879018f, 0.04767327f, 0.06935657f, -0.07385935f, 0.07160585f, 
    0.11213949f, -0.15374945f, 0.07100846f, 0.08891139f, -0.05910998f, -0.02461284f, -0.01566360f, 0.00600608f, 
    -0.07220834f, 0.04822684f, -0.13639313f, 0.10435104f, -0.33936036f, -0.08853140f, -0.20272362f, 0.00213391f, 
    -0.06360531f, 0.00629191f, 0.02259172f, -0.03413090f, -0.09210499f, -0.05481406f, -0.28869054f, 0.03892677f, 
    0.02932219f, 0.00336310f, -0.11769173f, -0.03543309f, -0.10128248f, -0.03928203f, -0.04013274f, 0.06062844f, 
    0.11555438f, 0.04713482f, 0.03175433f, 0.10729745f, -0.22197333f, 0.14735442f, -0.12504272f, 0.05755129f, 
    -0.13866922f, 0.00022810f, -0.02671398f, -0.15289047f, 0.00954208f, -0.09013185f, -0.06774329f, -0.32997146f, 
    0.22683333f, -0.01456326f, -0.16922823f, 0.06242992f, 0.00589834f, 0.00059798f, -0.00182156f, 0.08544984f, 
    0.01756727f, -0.03610650f, 0.01323948f, 0.00599071f, 0.28900880f, -0.18236135f, -0.00512746f, -0.01159996f, 
    0.06241162f, 0.13916498f, 0.03230807f, 0.02533336f, 0.03128153f, -0.09562354f, -0.28158861f, -0.13896969f, 
    -0.07499884f, -0.00563982f, 0.10262310f, -0.07095136f, -0.07663269f, -0.04701866f, -0.01282304f, -0.00134716f, 
    -0.02269031f, -0.17961648f, -0.04283142f, -0.21600001f, 0.22452359f, -0.29027349f, -0.17017084f, -0.01945474f, 
    -0.08528530f, 0.01267500f, 0.03537831f, -0.01957090f, 0.09121361f, -0.00813244f, -0.03750567f, 0.13568906f, 
    -0.36294553f, 0.03677232f, -0.06274158f, -0.03669419f, 0.06402508f, -0.05411560f, -0.00030354f, 0.00840087f, 
    0.04865509f, 0.15967935f, 0.04357157f, 0.01075847f, 0.04354303f, 0.12291930f, -0.03779295f, 0.05371746f, 
    -0.01739874f, -0.03915413f, -0.03970071f, 0.11673158f, -0.04288504f, 0.02681122f, 0.08079948f, 0.04483792f, 
    -0.13129272f, 0.22904272f, -0.00576423f, 0.18915652f, -0.13779303f, -0.01151185f, 0.03469630f, -0.03209362f, 
    0.00122490f, 0.06829109f, -0.00120847f, -0.00703779f, 0.37189960f, -0.19570249f, -0.00115534f, -0.38012967f, 
    0.02052583f, -0.08092202f, -0.04937223f, 0.08511042f, -0.09432623f, -0.05034772f, 0.02646443f, -0.02803290f, 
    0.09716505f, 0.02901165f, 0.09390562f, 0.03287604f, -0.12230720f, -0.06948455f, -0.00191103f, 0.02973556f, 
    -0.09145753f, -0.07857472f, 0.00832537f, -0.01584964f, -0.10882884f, 0.11977055f, -0.21636498f, -0.45365554f, 
    0.03371855f, 0.17757934f, -0.08345291f, 0.01318844f, 0.12087897f, -0.09237318f, 0.06380937f, 0.04603381f, 
    0.01281573f, 0.15457338f, 0.15364660f, 0.00625916f, -0.04367910f, -0.11050852f, 0.15123221f, 0.09321941f, 
    0.08177833f, 0.00056067f, -0.10925294f, 0.07533430f, 0.03335334f, -0.19298148f, 0.08112003f, -0.12916970f, 
    0.07472861f, 0.02068855f, -0.08255626f, 0.02761145f, 0.02717242f, 0.07358053f, -0.24615949f, 0.09445105f, 
    0.08163027f, -0.06702264f, 0.08344873f, -0.04076714f, -0.10161667f, -0.00499366f, -0.03806410f, -0.01524386f, 
    0.08357905f, -0.03015063f, 0.08918479f, 0.04564469f, 0.30584127f, -0.35575670f, -0.28683200f, -0.05648208f, 
    -0.04646838f, -0.06192316f, 0.04055394f, 0.02605857f, 0.02768212f, 0.15102166f, 0.04260878f, 0.18340027f, 
    0.15956129f, -0.15388694f, 0.03848987f, -0.08738919f, 0.09380076f, -0.05598691f, -0.08936256f, 0.00175517f, 
    0.09348983f, 0.04548705f, -0.05367796f, 0.04259340f, 0.27263081f, -0.18668868f, -0.05709021f, -0.35590023f, 
    0.07506101f, -0.07525223f, -0.03852173f, -0.10935106f, 0.07942361f, -0.01441125f, 0.02713650f, 0.06435876f, 
    -0.34298816f, -0.10774492f, -0.15480347f, -0.13619819f, 0.07699384f, -0.05313748f, -0.14474387f, -0.07269414f, 
    -0.08906813f, 0.13975582f, 0.12856580f, 0.06310593f, 0.14570031f, 0.03687697f, -0.13788329f, 0.02370975f, 
    -0.08651985f, -0.02310491f, -0.02551967f, -0.05885783f, -0.02450701f, -0.09013274f, 0.12230808f, -0.07108966f, 
    0.07325454f, 0.08956787f, -0.13646284f, -0.06786939f, -0.10083497f, 0.03048773f, -0.00779892f, -0.14822523f, 
    -0.06922171f, 0.02916448f, 0.04054560f, -0.03505714f, -0.19473875f, 0.11687280f, -0.39398322f, -0.11009435f, 
    -0.00235878f, 0.06264363f, 0.07760776f, 0.01380262f, 0.01071564f, 0.00886629f, -0.14143008f, 0.13262865f, 
    -0.06776018f, -0.20599368f, 0.01474375f, -0.20864044f, -0.02743464f, 0.02145363f, 0.08823931f, 0.16338423f, 
    -0.09996589f, 0.11040150f, 0.01849308f, -0.01232910f, 0.08669066f, 0.02009586f, 0.08480854f, -0.12546803f, 
    -0.00512987f, 0.03591400f, 0.02400641f, 0.08570345f, -0.02229760f, -0.02639109f, 0.13266933f, -0.04925267f, 
    -0.15706258f, 0.02997519f, 0.03110576f, 0.07756358f, -0.03576162f, -0.01719661f, -0.00542416f, -0.03775090f, 
    -0.04565240f, -0.06121214f, -0.12400022f, 0.15425718f, 0.17934760f, 0.13204691f, -0.05263220f, 0.03164695f, 
    -0.07940597f, -0.06894637f, 0.06272228f, 0.06234036f, 0.09856749f, -0.05558024f, 0.04041405f, -0.00915852f, 
    0.12146288f, 0.13574831f, 0.07058006f, 0.15152426f, -0.01987146f, -0.01208527f, 0.00958118f, 0.00755169f, 
    -0.04934891f, -0.01783722f, 0.04307377f, -0.04933418f, -0.10565248f, 0.02850918f, -0.09782458f, -0.04833029f, 
    -0.08323934f, -0.08630586f, 0.04225985f, 0.04348904f, 0.00545509f, 0.03716588f, -0.05342005f, 0.08133141f, 
    0.02968088f, -0.16136208f, -0.12050240f, 0.08867388f, 0.07747266f, 0.07386410f, 0.07761858f, -0.05233307f, 
    0.09193172f, 0.05545558f, 0.03376005f, 0.00625217f, 0.17225069f, 0.03009999f, -0.03354679f, -0.30699614f, 
    0.01882176f, 0.03363236f, -0.05199068f, 0.04637451f, -0.07830499f, -0.18855162f, -0.13315246f, 0.01761745f, 
    0.11228615f, -0.04163914f, 0.05435369f, 0.09102987f, 0.03998544f, -0.06709724f, 0.11503442f, 0.03071993f, 
    -0.05660119f, -0.04217408f, -0.02850424f, -0.00515399f, 0.07356109f, 0.02472860f, 0.04269766f, -0.05787929f, 
    -0.04857179f, -0.09562830f, -0.01066416f, 0.07245169f, 0.03025082f, -0.08743629f, -0.12217229f, -0.02173672f, 
    -0.12635334f, -0.01605229f, 0.00231780f, -0.10607500f, 0.11998715f, -0.06214067f, -0.01877892f, 0.03903401f, 
    0.10276575f, 0.07164245f, -0.05239093f, -0.01258018f, 0.17462988f, -0.08148829f, 0.08664287f, 0.20781662f, 
    -0.19438615f, 0.05982411f, 0.06226693f, 0.10042010f, 0.14455149f, -0.00040936f, 0.00113686f, 0.06560382f, 
    -0.28493541f, 0.01088077f, -0.12775907f, -0.01767201f, 0.06662955f, 0.00276982f, 0.02441769f, 0.05488967f, 
    0.00148536f, -0.11828572f, 0.09482226f, -0.04056085f, 0.19464524f, 0.00454247f, 0.08134683f, 0.08782393f, 
    -0.17214057f, -0.05512961f, -0.02366470f, 0.02520075f, 0.03011231f, -0.01302395f, 0.08236322f, 0.01482155f, 
    -0.11487930f, -0.05001343f, -0.02000037f, -0.25974214f, -0.01714124f, 0.02333635f, 0.10195516f, 0.04900603f, 
    0.07918721f, 0.05789969f, 0.07450331f, 0.10754759f, 0.06955204f, -0.07770582f, 0.19079988f, 0.18468964f, 
    -0.06542236f, -0.00188893f, -0.01124019f, -0.01956065f, -0.11084668f, 0.03809262f, -0.00521951f, -0.04816503f, 
    0.28423849f, -0.12749112f, -0.02843396f, 0.01035607f, 0.01452106f, 0.09613036f, -0.06018549f, -0.01363186f, 
    0.04151995f, -0.02960840f, 0.07128684f, 0.02954968f, -0.35738030f, 0.04009540f, 0.00752767f, -0.05107736f, 
    0.08073781f, -0.05787210f, 0.03349143f, -0.20198770f, -0.02273629f, 0.02452170f, 0.05059468f, -0.12608203f, 
    0.12171687f, -0.05342549f, 0.17403719f, 0.00214262f, -0.03180005f, -0.02325043f, -0.23256345f, -0.02477244f, 
    -0.20699120f, 0.07669330f, -0.04567458f, 0.00383452f, 0.07768832f, -0.15057822f, 0.21174720f, 0.09105454f, 
    0.04657951f, -0.03651270f, 0.07697897f, 0.00188194f, -0.03012277f, 0.14068228f, -0.01942921f, 0.13814580f, 
    -0.50847906f, -0.01631458f, -0.06383236f, 0.10796653f, -0.09336782f, 0.03621864f, 0.00132571f, 0.04640435f, 
    0.02979110f, -0.09926871f, 0.02601095f, 0.01702070f, 0.02367758f, -0.05181577f, -0.07104503f, -0.10311181f, 
    -0.02458837f, -0.01962579f, 0.09137160f, 0.05306427f, -0.03204344f, 0.04164275f, -0.18078370f, -0.06829978f, 
    -0.42822346f, 0.04782282f, -0.11457623f, -0.14975326f, 0.09209399f, -0.05675249f, 0.04958537f, 0.01798457f, 
    0.01737501f, -0.02265501f, -0.19376847f, -0.00112234f, -0.03822153f, 0.04268243f, -0.15613294f, 0.23548441f, 
    -0.10296454f, 0.03999645f, 0.00065288f, -0.06300402f, 0.04496653f, 0.06899991f, -0.12115295f, -0.01580171f, 
    0.17722863f, 0.00934543f, 0.08421191f, 0.08325011f, -0.03690365f, 0.02741764f, 0.01874026f, 0.07644637f, 
    -0.00520682f, 0.06190568f, -0.12166436f, -0.06010402f, 0.21324202f, -0.04525254f, 0.03801275f, -0.11515647f, 
    0.00175135f, 0.06115958f, 0.03374116f, 0.15261348f, 0.01350737f, -0.04934806f, 0.01489724f, -0.02270263f, 
    -0.30268389f, -0.13451311f, 0.12899129f, -0.16798261f, 0.03002255f, -0.14871258f, -0.08034635f, -0.06698475f, 
    0.14598177f, 0.02198966f, 0.04024697f, -0.07127325f, 0.10346545f, -0.07061557f, -0.05058300f, -0.00409124f, 
    0.03093102f, 0.05340808f, -0.05646269f, 0.10906803f, 0.15479884f, 0.03079708f, -0.05332600f, 0.00800341f, 
    0.02410587f, 0.00176851f, -0.26119995f, -0.01729345f, -0.03139009f, 0.04464835f, -0.00486145f, 0.08720353f, 
    0.04363568f, 0.03798498f, -0.15953715f, -0.07474635f, 0.21762988f, -0.00007287f, -0.26094425f, -0.06163397f, 
    0.13469942f, 0.04462441f, -0.03163411f, -0.04265954f, 0.03699262f, 0.01933257f, -0.06118729f, 0.01110958f, 
    0.24124281f, 0.12795019f, 0.11703760f, 0.27172223f, -0.14498764f, 0.05152293f, -0.04871168f, 0.09079590f, 
    -0.02431509f, 0.04881798f, -0.08287913f, 0.03648509f, -0.35911825f, -0.00209572f, -0.04982670f, 0.15756793f, 
    0.03745491f, 0.08561327f, -0.03465500f, -0.02887088f, 0.09538865f, -0.02142818f, -0.02848316f, -0.04929543f, 
    -0.03126319f, -0.02557483f, 0.08237380f, -0.08269849f, -0.13280876f, 0.00932447f, 0.00508296f, 0.05870551f, 
    -0.08514159f, -0.03717432f, -0.00201019f, -0.05141925f, 0.12482642f, 0.20460786f, 0.00457028f, 0.10370187f, 
    -0.07561925f, 0.04696232f, -0.01127791f, -0.02080587f, -0.06345072f, 0.02418963f, -0.03153795f, -0.08248071f, 
    0.01051238f, -0.01788235f, -0.00494146f, 0.00046070f, 0.09586962f, 0.02438981f, 0.03938648f, 0.01135449f, 
    -0.04165139f, -0.03608483f, -0.07285092f, -0.02838847f, 0.45184276f, -0.34220096f, -0.18094821f, -0.04968415f, 
    -0.05320657f, 0.02380491f, -0.02082449f, 0.04037139f, 0.04348192f, 0.04360256f, 0.04803989f, -0.17465419f, 
    0.30527318f, 0.06567702f, -0.04519660f, 0.10342693f, -0.26659063f, -0.00981132f, -0.02297315f, 0.03860789f, 
    0.01358721f, 0.03658136f, 0.04811857f, -0.03939779f, 0.06804065f, 0.00920926f, -0.08248454f, -0.04077804f, 
    0.04781688f, 0.03924150f, 0.00008840f, -0.02723712f, 0.07893547f, 0.09717080f, 0.09484324f, -0.12347695f, 
    0.08262550f, -0.01258375f, -0.08274483f, 0.04984232f, 0.06196761f, -0.06590057f, 0.16256899f, 0.00172305f, 
    -0.02460748f, 0.04515642f, 0.06662324f, -0.00580476f, -0.10807217f, -0.05868151f, 0.02949922f, -0.06164414f, 
    0.13377455f, -0.04640460f, 0.02600094f, -0.09054945f, -0.04262251f, -0.07219113f, -0.08114315f, 0.13085900f, 
    0.08466655f, -0.25695136f, 0.05386778f, -0.14042525f, -0.07164047f, 0.08979761f, 0.01810247f, -0.02133357f, 
    0.03664140f, 0.00656498f, 0.07426629f, 0.03109323f, 0.15899357f, 0.04654213f, -0.08200639f, -0.18046561f, 
    -0.02096424f, -0.04785457f, -0.01259470f, 0.02377356f, 0.01612286f, -0.05651191f, 0.04339556f, 0.02631037f, 
    -0.03455104f, -0.15282312f, 0.07820295f, 0.03486709f, -0.13587931f, -0.09841974f, -0.05315092f, -0.06858283f, 
    -0.04490006f, -0.07268654f, 0.07836450f, -0.08965361f, -0.19392847f, -0.18428615f, -0.17643647f, -0.15455092f, 
    -0.16365890f, 0.03448742f, 0.04945992f, 0.00754751f, 0.06946367f, 0.05104428f, -0.01567023f, 0.04426609f, 
    0.08959459f, -0.03356684f, 0.04052701f, 0.12076057f, -0.17291446f, 0.06710704f, 0.01033303f, 0.04621182f, 
    -0.00830660f, -0.04257717f, -0.06925764f, 0.08027546f, 0.25786805f, 0.05212398f, 0.19608286f, -0.08945760f, 
    -0.07199122f, 0.03095884f, 0.09229047f, -0.03748580f, -0.05086133f, -0.07711102f, 0.10878436f, -0.05275925f, 
    0.22235486f, -0.00758359f, -0.08389534f, 0.06710555f, 0.08256909f, 0.07668917f, 0.01563698f, -0.09723921f, 
    -0.07918914f, 0.04628839f, 0.01054848f, -0.09231237f, 0.22545756f, -0.11248822f, 0.22658293f, 0.13215666f, 
    -0.20372015f, -0.07477669f, 0.05497783f, 0.07425665f, 0.01843414f, -0.05359387f, 0.07347596f, -0.10096613f, 
    0.30974284f, 0.07002906f, -0.04196090f, 0.01610514f, -0.01876849f, -0.08405960f, -0.00698755f, 0.05796161f, 
    -0.13738431f, -0.07613252f, -0.02322921f, -0.07890112f, 0.31383872f, -0.18366291f, -0.09552016f, -0.17861974f, 
    -0.08323275f, -0.10263416f, -0.12706289f, 0.05108050f, -0.01868291f, -0.02911756f, -0.13073334f, -0.10725021f, 
    0.02237304f, 0.07360680f, -0.01230097f, -0.05399425f, -0.03204228f, -0.00599049f, -0.09771051f, 0.05126885f, 
    0.01236604f, 0.02694719f, 0.07001098f, -0.04567714f, 0.14364687f, 0.04952110f, 0.01819068f, 0.12632187f, 
    -0.05390284f, -0.05694641f, 0.02118857f, -0.04370782f, -0.05702151f, -0.01118892f, 0.00263252f, 0.11803606f, 
    0.09842108f, 0.04916352f, 0.03809848f, 0.08137687f, 0.08350325f, 0.05785260f, 0.00602967f, -0.01225568f, 
    -0.10764638f, 0.12086011f, -0.06441078f, 0.02155051f, 0.14855769f, 0.01791716f, -0.20574903f, -0.08058282f, 
    0.05588130f, 0.02345640f, 0.04544013f, 0.04622161f, -0.01077901f, -0.01119222f, -0.05710750f, -0.09518661f, 
    -0.07308821f, 0.12042966f, 0.09336649f, -0.01678815f, -0.03834208f, -0.05975153f, -0.07666321f, -0.04804655f, 
    -0.10370681f, -0.06086918f, 0.05653257f, -0.02495194f, 0.14487717f, -0.19807728f, -0.20394523f, 0.11568186f, 
    -0.12012663f, 0.06441467f, -0.04931434f, -0.19211029f, -0.04287241f, 0.06226861f, -0.00742894f, 0.11112961f, 
    -0.03035099f, 0.12801050f, -0.00897821f, 0.15388426f, 0.03293046f, -0.06301452f, -0.00065819f, 0.11271783f, 
    -0.04368534f, -0.02851217f, -0.08311163f, -0.08539098f, 0.11583114f, -0.32837048f, 0.01322923f, -0.03890701f, 
    0.04756905f, -0.02322071f, -0.03939831f, 0.05591600f, -0.15554048f, -0.03504702f, 0.05392289f, -0.02219746f, 
    -0.25249219f, 0.10444048f, -0.07488383f, -0.07535343f, 0.04162068f, -0.21727198f, 0.16013804f, 0.00187918f, 
    0.07576432f, -0.09878790f, -0.00170747f, 0.00814227f, 0.07772307f, -0.18716352f, 0.06181099f, -0.23827736f, 
    -0.00262800f, -0.10552938f, 0.15505490f, -0.05474246f, -0.00208960f, 0.00600513f, -0.01482167f, -0.11820046f, 
    0.20581765f, -0.06887317f, -0.12743594f, -0.01231306f, 0.04799395f, -0.01099135f, 0.05982939f, -0.01993327f, 
    -0.08331169f, -0.16579710f, -0.06342877f, -0.08540280f, 0.21500863f, -0.04346732f, -0.04595954f, -0.04657150f, 
    0.01289238f, -0.02452304f, 0.00299420f, -0.05734392f, -0.03666659f, 0.03247816f, -0.16355899f, 0.10317328f, 
    0.24064107f, 0.02368467f, -0.14485385f, 0.06273247f, -0.17087989f, 0.07173718f, 0.02782165f, -0.04902456f, 
    0.06009850f, 0.01143885f, -0.08061212f, 0.07833709f, 0.05106840f, 0.07419777f, -0.33725539f, -0.11245225f, 
    0.08082869f, 0.01480593f, -0.13701694f, -0.03648966f, -0.08043400f, 0.02588311f, 0.03279857f, 0.01520177f, 
    -0.42567065f, -0.11421546f, -0.04153538f, -0.16319956f, 0.04636678f, -0.01039502f, 0.08323326f, -0.00512495f, 
    0.00330190f, 0.09239011f, 0.04941965f, -0.04887737f, 0.25525719f, -0.03094013f, -0.03749166f, 0.05241602f, 
    -0.03204986f, -0.08757650f, 0.09044394f, 0.01032489f, 0.02841387f, 0.04516339f, -0.08895557f, 0.01543072f, 
    -0.05075716f, -0.21739386f, -0.29156736f, -0.03101090f, -0.13107027f, 0.02173361f, -0.04816110f, -0.00312217f, 
    0.01925611f, 0.07222816f, -0.00172653f, 0.05156473f, -0.04918059f, 0.01407276f, 0.02625902f, -0.06499752f, 
    0.06936420f, 0.07326418f, 0.03466178f, -0.06412721f, -0.01894421f, -0.01316790f, 0.03496775f, 0.01428076f, 
    0.13416843f, 0.01053843f, -0.01219638f, -0.00834795f, -0.03700830f, 0.07530906f, 0.02413991f, -0.00136079f, 
    -0.01192343f, -0.05212856f, 0.06271331f, 0.04162186f, 0.04674296f, 0.16596921f, -0.33564782f, -0.05271426f, 
    -0.06902565f, -0.02831818f, -0.04723576f, -0.05210377f, -0.09506389f, 0.03198676f, -0.00375512f, 0.00050904f, 
    0.05714519f, -0.25841147f, 0.09088527f, 0.03914590f, -0.02259214f, -0.05830242f, -0.16244543f, -0.04606945f, 
    0.05360987f, -0.00831301f, 0.02311664f, 0.00908882f, 0.14874104f, -0.07878749f, -0.10234854f, 0.08123858f, 
    -0.01685846f, 0.01267653f, -0.05365890f, -0.04229642f, 0.06542519f, 0.00149725f, -0.06437030f, -0.06416682f, 
    -0.28264472f, 0.13406999f, -0.04321998f, -0.15486731f, 0.04305305f, 0.08354879f, 0.02746298f, -0.04852545f, 
    -0.06642201f, 0.15790093f, -0.05654589f, 0.02095120f, -0.03840980f, 0.05950247f, 0.06339128f, -0.05259095f, 
    -0.00140863f, 0.10180756f, 0.14450611f, -0.10730715f, -0.04697659f, 0.00072119f, -0.05792062f, 0.02099874f, 
    -0.03410530f, -0.07051733f, 0.05436896f, 0.15457201f, -0.14904705f, -0.10206921f, 0.06609658f, -0.07698671f, 
    0.04402758f, 0.01343551f, 0.04693631f, 0.03206260f, 0.01547451f, 0.17684546f, -0.02962846f, -0.10499986f, 
    0.13716005f, 0.01866065f, -0.03349224f, -0.04068167f, -0.01661624f, 0.09671661f, -0.05558046f, 0.02711533f, 
    0.18388242f, 0.11782770f, -0.11816945f, 0.03626794f, -0.14703315f, -0.07731572f, -0.00631554f, -0.02922428f, 
    -0.02253946f, -0.00372593f, 0.00434214f, 0.03122743f, -0.07473524f, -0.09701282f, 0.03395445f, -0.01594146f, 
    0.14391071f, -0.05974625f, -0.01398174f, -0.10470770f, 0.04698039f, 0.03222539f, -0.06838678f, 0.02142891f, 
    0.04765062f, -0.06440236f, -0.04335325f, -0.15223947f, 0.07879163f, 0.05881573f, -0.07792664f, -0.00467531f, 
    -0.16683759f, -0.06371298f, 0.04227161f, -0.08038699f, 0.16790788f, -0.08336311f, -0.03558114f, 0.07417478f, 
    0.08265727f, 0.00887257f, 0.07676633f, -0.07969875f, 0.00317516f, 0.03474194f, -0.00168482f, 0.02901779f, 
    0.18604776f, -0.00548777f, 0.12441028f, 0.11402237f, -0.10215858f, -0.11866380f, -0.00027826f, 0.00839656f, 
    -0.00310200f, -0.14940475f, -0.02926232f, -0.06129549f, 0.35670608f, 0.05055894f, -0.01309897f, -0.12355022f, 
    -0.02987048f, 0.01525202f, 0.01663925f, 0.09955508f, -0.01594834f, 0.04262758f, 0.01863758f, -0.11205763f, 
    -0.18748850f, -0.04863469f, 0.04169760f, -0.06331886f, -0.04335484f, 0.05969131f, -0.00440958f, 0.02578807f, 
    -0.04682939f, -0.18596110f, 0.05176722f, -0.04780881f, 0.01555502f, -0.08673974f, -0.05724144f, -0.05650032f, 
    0.04332915f, 0.05317067f, -0.11563196f, -0.01155974f, 0.10502759f, -0.00832939f, 0.02882577f, -0.07037551f, 
    0.51116145f, -0.05425565f, -0.25124785f, -0.13095051f, -0.04131503f, -0.00333559f, 0.06929267f, -0.00770426f, 
    0.01979543f, 0.03368237f, -0.02354302f, -0.13043015f, -0.12789604f, 0.01260233f, -0.18339740f, -0.27891147f, 
    0.03350165f, -0.07191572f, -0.04429651f, -0.05494203f, 0.04116101f, 0.06454111f, -0.00578459f, -0.02573635f, 
    0.18638168f, 0.02156720f, -0.38229707f, -0.18946983f, -0.07007185f, -0.00956484f, -0.01561231f, 0.02608079f, 
    -0.04639260f, -0.05117597f, 0.02568757f, 0.04294023f, 0.12014323f, -0.11728807f, -0.00617667f, -0.00901109f, 
    -0.05088994f, 0.03346964f, -0.08342633f, 0.06640746f, 0.14270531f, -0.07454564f, -0.05531105f, -0.09016661f, 
    -0.16860056f, -0.15098505f, 0.01238339f, -0.04701303f, 0.05453670f, 0.02028134f, -0.09016196f, -0.04176373f, 
    -0.09720933f, -0.06652272f, -0.10997415f, -0.00018316f, -0.26432860f, 0.06044820f, 0.04219555f, -0.09447873f, 
    -0.04068137f, 0.04936539f, 0.08529502f, -0.04815361f, -0.05890762f, -0.03436722f, 0.07589798f, 0.05297352f, 
    0.03798632f, 0.19481449f, -0.04166861f, 0.17952435f, 0.07343177f, 0.14666429f, 0.11976761f, 0.05551242f, 
    -0.08233988f, 0.06593316f, 0.00127968f, -0.15521270f, 0.09128409f, -0.04500789f, -0.00257608f, 0.10455304f, 
    0.01305324f, 0.01119954f, 0.01193950f, 0.02620260f, 0.01988608f, -0.04597740f, -0.15957808f, 0.04499234f, 
    0.01255956f, 0.08205025f, 0.01749294f, 0.03066437f, -0.05408397f, 0.04464341f, 0.05878564f, -0.04142710f, 
    -0.00280577f, -0.06273558f, -0.05117849f, 0.01372653f, -0.15169609f, 0.20770055f, 0.26817968f, 0.05563626f, 
    0.11836857f, -0.05504841f, 0.03276688f, 0.04088555f, 0.03197590f, -0.03435377f, -0.08609197f, 0.01768452f, 
    -0.21981777f, 0.11943226f, -0.05950096f, -0.14068338f, 0.04134144f, -0.10425086f, -0.00892885f, -0.05790833f, 
    -0.00310022f, -0.07489209f, -0.04552692f, -0.04023570f, 0.03671942f, 0.05946206f, -0.06714012f, 0.15018666f, 
    -0.03896651f, 0.02586409f, 0.01358070f, -0.03703309f, -0.04167703f, -0.00459411f, 0.00827014f, -0.03596264f, 
    -0.08555415f, -0.28188008f, -0.16215491f, -0.07160991f, 0.00187256f, 0.05569063f, -0.02414655f, -0.06006410f, 
    -0.00293627f, 0.01352472f, -0.11352851f, -0.07469918f, -0.12822677f, 0.01960663f, -0.08217913f, -0.14234568f, 
    -0.04442818f, 0.04669033f, 0.01051813f, 0.02842282f, 0.07116570f, 0.07767124f, 0.05870660f, 0.07473235f, 
    -0.28430387f, -0.29376861f, -0.17483623f, 0.02491829f, -0.11045177f, -0.05830587f, 0.06082955f, 0.01176853f, 
    0.04867667f, 0.05112891f, 0.04972342f, 0.07537448f, -0.01859685f, 0.13392635f, 0.14455363f, 0.09373523f, 
    -0.01941537f, -0.13121785f, -0.01186618f, -0.00244529f, -0.06308403f, -0.03458680f, -0.07524897f, -0.04715861f, 
    0.03545932f, 0.02090878f, 0.04110963f, -0.07198711f, -0.01215038f, -0.03686725f, -0.00126085f, -0.10332234f, 
    -0.07212561f, -0.06755979f, 0.00201268f, 0.03109648f, -0.26376155f, -0.24693517f, -0.05816245f, -0.08160035f, 
    -0.03451153f, 0.02439442f, 0.03607208f, 0.00313368f, 0.03851165f, 0.07014662f, 0.02423766f, -0.11121931f, 
    -0.08760587f, -0.39160296f, -0.24333054f, -0.20738141f, -0.03939470f, -0.03552996f, -0.01473397f, 0.01413040f, 
    -0.11087476f, -0.07201640f, 0.02099473f, -0.06539369f, -0.44613162f, -0.35125011f, -0.02454841f, -0.03218811f, 
    -0.07855850f, 0.04532773f, 0.00064412f, -0.07588597f, 0.08229960f, -0.09320568f, -0.03637655f, 0.06189134f, 
    -0.12236551f, 0.04954004f, -0.02552275f, 0.05706300f, 0.01954417f, -0.05142431f, -0.20419094f, 0.01766068f, 
    -0.04963189f, 0.00004761f, 0.09920370f, -0.00161524f, 0.04330749f, 0.13031782f, 0.00739186f, 0.00566861f, 
    0.05495344f, 0.00878308f, 0.08072648f, 0.01175254f, -0.09367981f, 0.00631603f, -0.01993842f, -0.00000355f, 
    0.08139711f, -0.01247024f, 0.03813663f, -0.15068623f, -0.08623112f, -0.07187550f, -0.05546994f, -0.04677164f, 
    -0.01758034f, -0.08964964f, 0.03456479f, -0.03640732f, 0.04945138f, 0.05997398f, 0.16431870f, 0.10836311f, 
    0.02200620f, 0.09931001f, 0.07817423f, 0.08524463f, -0.02481977f, 0.08341690f, 0.03750663f, 0.13809091f, 
    0.10560991f, -0.05685368f, -0.02402076f, 0.01772912f, -0.05928721f, -0.02622857f, 0.07564327f, -0.00802321f, 
    -0.08256013f, -0.01696152f, 0.02880468f, -0.07533046f, -0.09935373f, 0.14743866f, -0.09010881f, 0.11900273f, 
    0.07912689f, 0.03872538f, -0.01806125f, -0.00660828f, 0.03121571f, 0.05340078f, 0.08557207f, 0.00500220f, 
    -0.31232381f, -0.07881895f, 0.23398241f, 0.27415612f, 0.09055449f, 0.13169695f, 0.00442163f, 0.04287569f, 
    0.01530297f, 0.12321965f, -0.06134771f, 0.03339880f, 0.03992055f, -0.26014137f, -0.10066251f, -0.09488310f, 
    -0.07121772f, -0.03635396f, -0.05701022f, -0.00260576f, -0.02744514f, 0.01480672f, -0.00241350f, 0.02307578f, 
    -0.05283826f, 0.10824671f, -0.00017680f, -0.19106993f, 0.01968482f, 0.00496411f, -0.05695362f, 0.07520112f, 
    0.05840048f, -0.08526438f, -0.03285838f, 0.01085897f, 0.05875301f, 0.09760797f, 0.00141912f, 0.00022879f, 
    0.07008382f, 0.05874600f, 0.04522180f, 0.01575010f, -0.01486151f, -0.00708369f, -0.08665106f, -0.00006012f, 
    0.10595968f, -0.03076236f, 0.08701568f, -0.14023595f, 0.02503039f, 0.09613968f, -0.04177774f, -0.01533054f, 
    -0.07449850f, -0.05271155f, 0.06264587f, -0.09288231f, -0.02666912f, -0.01433538f, 0.00459030f, 0.09445820f, 
    -0.02425128f, -0.03388325f, 0.03010989f, -0.04093949f, -0.09026513f, 0.06482236f, -0.00100405f, 0.00657575f, 
    0.21466540f, -0.42665082f, -0.00388423f, 0.05176207f, -0.02896802f, -0.04316615f, 0.03200623f, 0.01968049f, 
    0.05739227f, 0.01554926f, -0.05665649f, 0.08896623f, -0.32656771f, 0.29845417f, 0.00162194f, -0.10735163f, 
    0.01282050f, 0.04548071f, 0.01691619f, 0.20547347f, 0.02296334f, 0.09044921f, -0.05124784f, 0.01028092f, 
    0.08224854f, 0.05914782f, 0.01929802f, -0.09489843f, -0.10086644f, -0.07111809f, -0.03053023f, 0.00296700f, 
    -0.03306351f, -0.08296642f, 0.01740782f, 0.10147099f, -0.05345064f, -0.02147441f, 0.00935561f, 0.06124018f, 
    -0.03335360f, -0.08514912f, -0.00505697f, 0.02553252f, -0.00110764f, 0.07218588f, 0.00626029f, -0.11757137f, 
    0.05697022f, 0.06381830f, -0.08161932f, 0.02669203f, 0.00893192f, 0.04458743f, -0.00908605f, -0.11082196f, 
    -0.02865332f, 0.04959289f, -0.08121905f, -0.08900482f, 0.21965154f, -0.16380678f, -0.06396286f, -0.03920313f, 
    -0.05375881f, 0.00216405f, 0.06236210f, -0.06179193f, 0.13355239f, -0.01521544f, 0.04855837f, -0.02915801f, 
    0.02646137f, -0.08497535f, 0.13217413f, 0.07650026f, 0.01279384f, 0.14535442f, -0.09489587f, 0.03368735f, 
    -0.02602654f, -0.01213385f, -0.05671689f, 0.01525484f, 0.19662152f, 0.06739430f, -0.04297740f, 0.24339725f, 
    -0.17983809f, 0.08015665f, -0.00888226f, 0.10240410f, -0.01680015f, 0.01182511f, -0.06468587f, 0.04683331f, 
    -0.20845348f, 0.28173590f, 0.16986570f, 0.13749543f, 0.07223958f, 0.09467687f, -0.01476478f, 0.01745707f, 
    -0.05167183f, -0.01986828f, -0.09755109f, -0.01627612f, 0.50863057f, -0.07298882f, -0.07166059f, 0.07264016f, 
    -0.01392935f, 0.03150088f, -0.05157360f, 0.01000197f, -0.03941744f, -0.01197586f, 0.04316362f, 0.04317279f, 
    0.27641672f, -0.05168654f, -0.07048528f, 0.09529119f, 0.06442552f, -0.01972797f, -0.00474098f, 0.19734097f, 
    0.01194895f, -0.00038073f, 0.00402661f, 0.03344197f, -0.34039503f, 0.25772059f, -0.00147656f, -0.09198330f, 
    0.10520665f, 0.04190214f, 0.01733968f, 0.10137290f, -0.06010324f, -0.00911014f, 0.05342193f, -0.15213110f, 
    0.12107763f, -0.03397486f, 0.13255467f, -0.01503189f, 0.01279273f, -0.00373595f, 0.06856315f, -0.02839617f, 
    0.02905273f, 0.05230140f, 0.00582810f, -0.02205933f, 0.11552326f, 0.00357111f, 0.01289673f, 0.06839330f, 
    0.04157797f, -0.02874152f, -0.04469029f, -0.04081105f, -0.04330917f, 0.07734780f, -0.03448700f, 0.07038283f, 
    0.08668353f, 0.11184242f, 0.06320173f, -0.01315648f, -0.05264086f, -0.06651390f, -0.02622798f, -0.04010024f, 
    0.02707482f, 0.02850967f, -0.08354672f, 0.00715520f, -0.40160459f, -0.18614884f, -0.12186426f, -0.03869113f, 
    -0.03536731f, 0.02843287f, 0.01042932f, -0.08806435f, 0.01569891f, -0.03750154f, 0.01850259f, 0.05483379f, 
    -0.43763721f, -0.04762872f, -0.21199641f, -0.09809905f, -0.04620964f, -0.08728284f, 0.08079089f, 0.08064175f, 
    -0.01812234f, 0.00965085f, -0.10684650f, 0.15954286f, -0.14476869f, 0.14862624f, 0.04026240f, -0.01570472f, 
    -0.04924088f, -0.00118565f, 0.02442430f, -0.01862716f, -0.01810160f, 0.03987014f, 0.08205735f, -0.03139839f, 
    -0.02186819f, -0.00341465f, -0.12965922f, 0.07503619f, 0.04016702f, -0.18155949f, 0.08731464f, 0.03017506f, 
    0.03731655f, 0.05087716f, 0.04517086f, -0.06074627f, -0.03169961f, 0.22870630f, 0.04977958f, 0.03518356f, 
    -0.01296410f, -0.10355744f, -0.04014268f, -0.09638679f, -0.09491631f, 0.11215359f, 0.07390043f, 0.07736029f, 
    -0.03885674f, -0.37366715f, -0.20894974f, 0.12763555f, -0.00048040f, 0.04538565f, 0.10104410f, -0.02484263f, 
    0.00873577f, -0.08179778f, -0.11968546f, 0.02953113f, -0.10995623f, -0.03335947f, -0.13072516f, 0.18340962f, 
    0.01736375f, 0.01935805f, 0.03896388f, -0.05076792f, 0.03924083f, 0.04163310f, 0.02989919f, 0.02972606f, 
    -0.02266451f, 0.04007031f, 0.11248038f, -0.16504140f, -0.14554568f, 0.03331749f, 0.03006448f, 0.04480006f, 
    -0.04261032f, 0.00513807f, -0.00678648f, 0.11536027f, -0.55146170f, -0.33393711f, -0.05225513f, 0.10948107f, 
    -0.05703641f, 0.05233015f, -0.06015373f, -0.02410658f, -0.02776664f, 0.01880692f, 0.08627528f, -0.05875614f, 
    -0.16692349f, 0.15840688f, 0.02379921f, -0.09016685f, -0.09375725f, -0.01359161f, 0.02214357f, 0.02871742f, 
    -0.12561294f, 0.01682861f, -0.03618406f, 0.10317974f, -0.34299949f, -0.40347940f, -0.23137419f, 0.08489726f, 
    -0.12431246f, -0.03904993f, -0.00039558f, -0.05300294f, -0.05923562f, -0.14563870f, -0.02168176f, 0.05188026f, 
    0.07432412f, 0.21035360f, 0.21644901f, 0.16215861f, 0.06702340f, 0.09571443f, -0.13501650f, -0.05861240f, 
    0.05764839f, -0.07847585f, -0.07911318f, -0.08142501f, 0.04175821f, -0.36459130f, -0.15849189f, 0.18162096f, 
    -0.08778974f, 0.00228151f, 0.08475158f, 0.04469497f, -0.01391968f, 0.05135635f, 0.04680271f, -0.15216102f, 
    0.10807949f, -0.00761182f, -0.21455796f, -0.01713132f, -0.00561057f, 0.02195421f, -0.03543400f, -0.06695574f, 
    -0.04946873f, -0.03296774f, 0.09402885f, 0.02714407f, -0.18246809f, 0.05479302f, 0.02880603f, -0.08773997f, 
    -0.05106762f, 0.07317591f, -0.05301379f, 0.08685064f, -0.00198761f, -0.02675876f, -0.03871536f, 0.09627279f, 
    0.09525368f, 0.12233973f, -0.13907631f, 0.02904233f, -0.07029475f, 0.12384527f, -0.00409208f, 0.01938749f, 
    -0.00756809f, -0.01943134f, 0.09775583f, -0.05506082f, 0.04711147f, 0.04598101f, 0.06528858f, -0.02201983f, 
    0.05329090f, 0.16946957f, 0.02376600f, -0.06319112f, 0.05052892f, -0.01578881f, 0.03689346f, -0.08652186f, 
    0.18647580f, 0.00449957f, 0.22082317f, -0.11742999f, 0.04545450f, 0.00035600f, 0.06778281f, 0.06105223f, 
    -0.06639235f, -0.07739090f, -0.05781221f, 0.05450284f, 0.32109678f, 0.11432163f, 0.10887987f, 0.00445322f, 
    0.03197435f, -0.12492257f, -0.03522904f, -0.02945193f, 0.00951994f, 0.03599629f, 0.00864114f, -0.05627778f, 
    -0.18050510f, 0.31822520f, 0.14051428f, -0.08401874f, -0.01655788f, 0.03934099f, -0.03843059f, 0.07293831f, 
    -0.00411471f, 0.10606144f, 0.05457266f, -0.00974875f, 0.01393207f, -0.00991986f, 0.13095903f, 0.00154367f, 
    0.01080476f, -0.11488465f, -0.08607914f, -0.03522699f, -0.07583626f, -0.13606247f, 0.03077876f, 0.00982965f, 
    -0.26285142f, -0.28316736f, 0.01032199f, 0.28220651f, -0.03416973f, 0.01905575f, 0.02359761f, -0.05191801f, 
    0.07262736f, -0.08278200f, 0.14586067f, 0.07988794f, 0.04340086f, -0.27625147f, -0.10985888f, 0.04167217f, 
    -0.09393914f, -0.04283385f, -0.01055491f, -0.00940485f, -0.06510577f, 0.03427521f, -0.09108018f, 0.04120515f, 
    0.01615415f, 0.05520874f, -0.14425668f, 0.02864747f, -0.06269632f, 0.02580394f, 0.07127337f, 0.05446796f, 
    0.02538997f, 0.02966828f, 0.02631401f, -0.09718326f, -0.20571542f, 0.06234476f, -0.04661215f, -0.08841792f, 
    -0.08093250f, -0.09244519f, 0.06971207f, -0.06394121f, -0.01765587f, 0.02301655f, -0.04534694f, -0.02628704f, 
    -0.10610005f, 0.01632275f, 0.02812511f, -0.03916635f, -0.06503581f, 0.01860756f, -0.00614790f, -0.08104359f, 
    0.04271843f, -0.02439510f, -0.04940091f, 0.06023929f, -0.21021166f, 0.16837893f, 0.01831605f, 0.00435028f, 
    -0.02695967f, -0.11961083f, -0.06199766f, 0.03080353f, -0.07617223f, -0.12117797f, 0.10004960f, 0.06003777f, 
    -0.19870250f, -0.05019899f, -0.04796232f, 0.19646205f, 0.01236589f, -0.00409777f, 0.06693930f, -0.01556000f, 
    0.08757465f, -0.09120061f, 0.12333783f, 0.09175564f, -0.20976436f, -0.06430510f, -0.23683742f, 0.00486090f, 
    -0.01363556f, 0.02707729f, 0.08286213f, 0.05655107f, 0.00038601f, -0.00529890f, -0.03763457f, 0.00247315f, 
    -0.09651510f, -0.24444643f, -0.03932871f, -0.24442385f, 0.05607376f, 0.00688926f, -0.02734125f, 0.00098794f, 
    -0.10950166f, 0.08309398f, -0.12481052f, -0.05015180f, 0.04146125f, -0.04858650f, 0.06276025f, 0.08576597f, 
    0.01814720f, 0.10634514f, -0.00106770f, 0.11141647f, -0.01828212f, -0.05661952f, 0.00428179f, 0.00572333f, 
    0.15563904f, 0.10538450f, -0.01442736f, -0.04633981f, 0.00140280f, -0.08277827f, 0.02977234f, 0.10095520f, 
    -0.06029136f, 0.00241940f, 0.04132141f, 0.03152599f, -0.17173421f, -0.08238368f, 0.08839289f, -0.00427981f, 
    0.04500934f, -0.10049056f, 0.00163895f, 0.09552561f, 0.05321100f, 0.06963558f, -0.09334420f, -0.06422462f, 
    -0.44005230f, 0.08855169f, -0.01792169f, 0.00704176f, 0.20348805f, 0.02778723f, -0.08833092f, 0.07925051f, 
    -0.12345508f, -0.06609608f, -0.00806251f, -0.04429020f, 0.07841881f, -0.03014421f, -0.02792283f, 0.12774536f, 
    0.01105860f, -0.00132818f, 0.11040188f, 0.08847099f, 0.04218254f, 0.10089946f, 0.04170035f, 0.02560597f, 
    0.44511512f, -0.26250008f, -0.02790575f, 0.03025806f, -0.06786437f, 0.05699137f, -0.01497994f, -0.02761799f, 
    0.00442095f, 0.09241770f, 0.07897758f, -0.05052319f, 0.18977901f, -0.09004566f, -0.12836558f, 0.09527919f, 
    -0.14387648f, 0.02437776f, 0.11870861f, 0.00321482f, 0.05523569f, -0.01223445f, -0.01985462f, -0.17274173f, 
    -0.24302934f, 0.14301282f, 0.05699047f, -0.13945456f, -0.03004389f, 0.05286243f, -0.01377673f, 0.01129553f, 
    -0.03468497f, -0.05329125f, -0.02218154f, 0.03134334f, -0.18334740f, -0.06711131f, -0.01869814f, -0.17490725f, 
    0.14010487f, -0.02087548f, 0.13191262f, 0.04588905f, 0.11597513f, 0.04573122f, 0.01893365f, 0.00384055f, 
    0.07403743f, 0.01816512f, 0.05074116f, 0.15370487f, 0.09074609f, 0.06456575f, 0.02301981f, 0.14464320f, 
    0.00505663f, 0.06682029f, -0.00487782f, 0.02315244f, -0.00642239f, -0.06796587f, 0.10486194f, -0.23208696f, 
    -0.05215614f, 0.18694539f, -0.05988076f, 0.05089712f, 0.04480244f, 0.01672128f, 0.01493171f, 0.12891993f, 
    -0.35993984f, 0.02594648f, -0.13766250f, 0.05989591f, -0.00234179f, -0.04170070f, -0.01955682f, -0.01608376f, 
    0.04809232f, -0.07346062f, 0.06768497f, 0.02760993f, -0.63423342f, 0.15039445f, -0.00203928f, -0.16427837f, 
    0.08677945f, -0.15129897f, -0.10656679f, 0.04500386f, -0.03500246f, 0.01199542f, 0.02696252f, -0.03647418f, 
    -0.43183598f, 0.13283613f, 0.00374591f, -0.09122907f, 0.10802463f, -0.02420380f, -0.00754501f, 0.04650197f, 
    -0.01504564f, 0.05269760f, -0.01683802f, -0.01980476f, -0.49080095f, 0.14630654f, 0.11496823f, 0.18737388f, 
    -0.03997333f, 0.03784680f, 0.00396227f, 0.08401334f, -0.06001655f, 0.06981237f, 0.04601241f, 0.01061218f, 
    0.20231192f, 0.13717222f, 0.04635829f, 0.03302649f, -0.05991470f, 0.00035469f, -0.03312314f, 0.11179308f, 
    -0.03851404f, -0.00898127f, 0.05768717f, 0.07396000f, -0.20471205f, -0.00189049f, 0.19406497f, -0.06988298f, 
    0.07667761f, 0.07633384f, -0.05853158f, 0.00624243f, 0.04229232f, 0.01746700f, -0.02040976f, 0.06161291f, 
    -0.11599057f, -0.16713016f, 0.10846923f, -0.15798618f, -0.03657646f, 0.03049991f, -0.03685148f, -0.02460998f, 
    0.03016003f, -0.05395882f, -0.09609030f, -0.07753763f, -0.30626249f, -0.02471763f, 0.18985897f, 0.11554796f, 
    -0.02908516f, -0.06108528f, 0.04595438f, 0.06806798f, -0.02991562f, -0.06544641f, -0.00735974f, -0.00759440f, 
    -0.14302166f, 0.16417195f, -0.08283684f, -0.03523546f, 0.03115083f, -0.00256638f, -0.01828442f, 0.12502180f, 
    0.02890949f, 0.01775769f, -0.02223024f, 0.02129866f, -0.01542055f, 0.08196277f, 0.20357206f, -0.03598896f, 
    -0.08619958f, -0.00659190f, 0.08067334f, -0.04956378f, -0.01430585f, 0.12836488f, -0.13753588f, 0.03773625f, 
    0.28111574f, 0.12611958f, -0.05629241f, -0.05983897f, 0.07271606f, 0.13223979f, -0.00031120f, 0.16945082f, 
    0.01979187f, -0.08643326f, 0.04764443f, 0.02643631f, -0.09295370f, -0.08851229f, -0.14583373f, 0.12715776f, 
    0.06005580f, 0.08305035f, 0.02767531f, 0.13696374f, -0.04916130f, -0.08088011f, 0.02195932f, 0.12635188f, 
    -0.20227867f, -0.02661492f, -0.00107707f, 0.08433925f, -0.09954841f, -0.01001174f, 0.02317213f, -0.26176918f, 
    -0.04859176f, -0.03598800f, -0.00840092f, 0.02436783f, 0.07326433f, 0.21480250f, -0.05516911f, 0.03810039f, 
    0.03172778f, 0.00291941f, -0.04693320f, -0.01861095f, -0.15618764f, -0.13282751f, 0.01399463f, -0.03296154f, 
    0.22526518f, -0.11022937f, 0.08772347f, -0.05012535f, -0.02282145f, -0.02029518f, -0.03057527f, -0.02047862f, 
    -0.04180552f, 0.05934871f, 0.03813523f, 0.11797110f, -0.10615918f, -0.13489912f, -0.01744308f, 0.11778186f, 
    -0.10177874f, 0.06054391f, 0.16260149f, 0.00717153f, -0.00851567f, -0.06770087f, -0.00780321f, 0.07525031f, 
    -0.20294917f, 0.00679817f, 0.06943084f, -0.00795274f, -0.04681491f, 0.03138873f, 0.00909878f, -0.04568701f, 
    0.06295442f, -0.02211336f, 0.02216981f, 0.02130874f, 0.02604752f, 0.20154756f, -0.09529282f, -0.13981178f, 
    -0.05270219f, 0.07386872f, 0.02245180f, 0.01960295f, 0.00788707f, -0.01273532f, -0.07835471f, 0.11635895f, 
    0.24528718f, 0.33182752f, -0.25824642f, -0.28371119f, 0.00525522f, 0.10150994f, 0.03291075f, 0.06864371f, 
    0.01788042f, 0.04183211f, 0.00174530f, 0.04795371f, -0.10205588f, -0.08787874f, 0.23117547f, -0.01780547f, 
    0.02030307f, -0.01904925f, 0.10215341f, -0.14109698f, 0.06901542f, 0.01184335f, -0.03144846f, -0.16432846f, 
    0.11215308f, -0.16005823f, -0.23716556f, 0.03838782f, -0.20729716f, -0.01773111f, 0.06109453f, -0.01602608f, 
    0.02856934f, -0.06938855f, -0.00848704f, -0.05595591f, -0.09933043f, 0.05871499f, 0.03019632f, -0.05156939f, 
    0.00522127f, -0.00379169f, 0.00586784f, -0.08051498f, 0.08951146f, 0.01692397f, 0.05472223f, -0.01343307f, 
    0.18367055f, -0.04138762f, -0.03479957f, -0.11726817f, -0.02044157f, -0.02303006f, 0.15854660f, 0.01935860f, 
    0.03010182f, -0.09927262f, -0.01315798f, -0.02734368f, -0.23977691f, -0.09808480f, 0.07612137f, 0.02206257f, 
    -0.12462749f, -0.05687714f, -0.03249354f, 0.03412769f, 0.09895416f, 0.02034112f, -0.11893518f, -0.06251524f, 
    -0.03302935f, -0.04334176f, -0.07812225f, -0.07489991f, -0.04323532f, -0.09760001f, -0.02965922f, 0.08975473f, 
    -0.13802360f, -0.02983071f, -0.05222989f, -0.11235274f, -0.02982944f, 0.04905048f, 0.10072564f, -0.09978875f, 
    0.02656024f, -0.10472047f, 0.06556436f, -0.12423694f, 0.00607531f, -0.00046344f, 0.07491310f, -0.04138521f, 
    0.04705625f, 0.05757947f, -0.03271540f, -0.21404976f, -0.00179125f, -0.00262596f, -0.07743303f, -0.03902292f, 
    -0.00108356f, -0.02309746f, 0.01105299f, 0.01788906f, 0.26196748f, -0.12206934f, -0.00101968f, 0.04494718f, 
    0.03139665f, 0.04783771f, 0.07847341f, -0.00542545f, 0.01485886f, 0.12629595f, -0.02904299f, 0.05888991f, 
    -0.27333969f, -0.25968385f, 0.14285371f, 0.12270456f, -0.12839296f, -0.04681059f, -0.04572915f, -0.05955769f, 
    0.14931065f, 0.08102853f, 0.03180722f, -0.07507282f, -0.25472659f, -0.22748424f, -0.08829623f, 0.01926430f, 
    -0.10576648f, -0.13863356f, 0.00291970f, 0.00168689f, 0.06972215f, -0.07745086f, 0.07078623f, -0.09826280f, 
    -0.04017413f, -0.04134424f, 0.17574668f, 0.24638709f, 0.05472743f, -0.12489477f, 0.02217347f, 0.13210817f, 
    -0.01524758f, 0.03795645f, 0.07892587f, 0.10358365f, -0.17567256f, 0.10508882f, 0.24851245f, 0.08153566f, 
    -0.09766144f, -0.01087664f, -0.08464043f, -0.01245643f, 0.13507892f, 0.00840972f, 0.00322621f, -0.05717853f, 
    0.04563745f, 0.05877785f, 0.01839290f, -0.13059367f, -0.00611451f, 0.06303794f, -0.01602361f, 0.02391994f, 
    0.00834434f, -0.00991915f, 0.00799785f, -0.12741558f, 0.09168702f, 0.06201990f, -0.06475930f, 0.05805944f, 
    0.05528955f, -0.07287467f, -0.06073486f, 0.05139324f, 0.09988376f, -0.02853636f, -0.01633391f, -0.05910277f, 
    -0.16394185f, -0.00215680f, 0.20799917f, 0.18519294f, -0.02677804f, 0.01264234f, -0.06655331f, -0.05308649f, 
    0.15639812f, -0.01768600f, -0.08377724f, -0.00066374f, -0.06985748f, 0.10153225f, 0.11917420f, 0.01774156f, 
    -0.04458265f, -0.03776389f, 0.00529976f, 0.04077303f, 0.05777388f, -0.10620044f, 0.05363211f, -0.10361221f, 
    -0.60004568f, 0.21124198f, -0.01488409f, 0.15695360f, -0.01583997f, -0.05930289f, 0.04019859f, -0.07368586f, 
    0.01718575f, 0.04938420f, -0.13270807f, 0.02155020f, -0.17163140f, -0.11079630f, 0.14549473f, 0.20238096f, 
    0.04825176f, 0.00507370f, 0.08853327f, 0.15068837f, -0.00981510f, 0.08446404f, -0.05189418f, 0.10091420f, 
    -0.12292991f, 0.00599132f, 0.02081882f, 0.08321489f, 0.11837629f, -0.06560089f, 0.04194507f, -0.02134942f, 
    -0.00500864f, -0.26022238f, -0.04740550f, -0.07820795f, 0.17519662f, -0.10978127f, -0.07783979f, 0.06695458f, 
    0.00617853f, -0.03846824f, 0.04931527f, -0.00715874f, 0.07965745f, -0.03999633f, 0.04657670f, 0.05491211f, 
    -0.24439959f, 0.10211472f, 0.03857544f, -0.05068522f, 0.12820986f, -0.02098003f, -0.06112912f, -0.07556591f, 
    -0.08305979f, -0.02009265f, -0.01016051f, 0.03777413f, 0.01458884f, 0.00757979f, 0.10741427f, -0.16126344f, 
    -0.01385732f, 0.01658429f, -0.03463333f, 0.09336337f, -0.01703939f, -0.02669235f, -0.00769501f, 0.04506051f, 
    0.19072750f, 0.15406796f, 0.07941867f, -0.01431269f, -0.06164849f, -0.10790306f, 0.05205638f, -0.09372550f, 
    0.01860664f, -0.09177059f, -0.01004327f, 0.05393152f, -0.31775802f, 0.15604268f, -0.12144789f, -0.21056826f, 
    0.02773272f, 0.03827279f, -0.00527362f, 0.06871535f, -0.03173449f, 0.03996736f, 0.07043752f, -0.03220403f, 
    0.12163869f, 0.12912178f, 0.04839867f, -0.05659886f, 0.09052230f, 0.01513407f, 0.02719628f, 0.00619805f, 
    0.00440144f, 0.05998469f, 0.01491828f, 0.04033973f, -0.09739740f, -0.21268892f, 0.03331245f, -0.15142475f, 
    0.00203497f, 0.15032904f, -0.07124249f, -0.07300287f, 0.01452955f, -0.01763510f, -0.03217485f, 0.03068638f, 
    0.10210700f, -0.08234850f, -0.09862589f, 0.15441623f, 0.04265870f, 0.01756060f, -0.05776004f, 0.01385711f, 
    -0.03531817f, -0.04611825f, 0.06549429f, 0.02603331f, -0.11528032f, -0.02692482f, -0.05046841f, 0.09809994f, 
    -0.03788768f, -0.04626709f, 0.06358021f, -0.09671803f, 0.00455395f, 0.06592041f, 0.00982914f, 0.07120429f, 
    -0.07362564f, 0.07514380f, 0.09335009f, 0.13363330f, -0.06141485f, -0.02287802f, -0.00192747f, 0.04292418f, 
    -0.06667250f, -0.02448347f, -0.03045464f, 0.05620425f, -0.12843955f, -0.11246635f, 0.09616952f, 0.00050530f, 
    0.06378082f, 0.02193604f, 0.08259373f, 0.01616115f, 0.09297267f, 0.06642783f, 0.02140381f, 0.13582854f, 
    -0.35201156f, -0.02731314f, -0.07901113f, -0.09934000f, 0.03935390f, -0.00861241f, -0.01070257f, -0.14144050f, 
    0.04268117f, 0.04912433f, -0.04366349f, -0.00257888f, -0.19950119f, -0.05425873f, -0.13398229f, -0.05497755f, 
    0.07510738f, 0.05426690f, 0.01149538f, -0.01732814f, 0.04339127f, -0.01705883f, -0.12444117f, -0.01474464f, 
    0.26044351f, 0.07087879f, 0.02395164f, 0.02489341f, 0.01373215f, -0.18903834f, 0.03716625f, -0.01940545f, 
    0.10137285f, -0.06817807f, -0.05232259f, 0.01284231f, 0.07120842f, 0.02673640f, -0.03792140f, -0.01844053f, 
    0.09632757f, -0.14248709f, -0.02830653f, -0.09016272f, 0.12153430f, 0.06704955f, 0.05218491f, 0.05623837f, 
    0.01017173f, 0.07048444f, 0.22121237f, -0.04395368f, -0.00204765f, -0.05203725f, 0.07406559f, -0.11979835f, 
    -0.07858884f, 0.01806683f, -0.02299379f, -0.05484056f, -0.00994335f, -0.00235170f, 0.02201978f, -0.21020125f, 
    0.09267284f, 0.08529103f, 0.02474861f, -0.06033135f, 0.04405773f, -0.05437601f, 0.00427105f, 0.04428637f, 
    -0.15078102f, 0.10863427f, -0.07242162f, -0.10204045f, 0.03546070f, 0.02454740f, 0.09945548f, 0.05621650f, 
    0.00811815f, 0.05260908f, -0.06070407f, -0.03559382f, -0.04655514f, 0.14632669f, 0.03322448f, -0.10921264f, 
    0.05396329f, -0.11367311f, -0.00756531f, -0.02372953f, 0.02843985f, -0.06072792f, -0.13658321f, 0.10070795f, 
    0.08013028f, 0.12414849f, 0.08587301f, -0.17752628f, -0.08052434f, -0.11034844f, -0.05558438f, -0.10753644f, 
    -0.06391935f, -0.01911718f, -0.02446777f, -0.07734016f, 0.04503047f, 0.08229999f, 0.20790090f, -0.18557593f, 
    -0.01198238f, -0.12539294f, 0.07772142f, -0.00914633f, -0.05673681f, 0.12736510f, 0.12225106f, 0.07591035f, 
    -0.20457849f, -0.00544860f, -0.00006090f, 0.10116723f, 0.03789658f, -0.08191496f, -0.02280289f, 0.10996466f, 
    0.12276866f, -0.00510095f, -0.01872040f, -0.00585406f, -0.28880268f, 0.10038812f, 0.08626681f, -0.02246061f, 
    -0.03314783f, 0.09088239f, -0.07511450f, 0.02154205f, 0.02908206f, -0.03925962f, 0.06149847f, -0.14935683f, 
    -0.23233443f, -0.01405154f, -0.10066879f, 0.10727283f, 0.12268085f, -0.01141524f, 0.07359093f, 0.04547330f, 
    0.12114087f, 0.09702776f, -0.10140181f, 0.13008516f, 0.08674110f, 0.08684469f, -0.04868135f, 0.03268266f, 
    0.13077952f, -0.14004727f, -0.16170464f, 0.04312550f, 0.00316475f, -0.09477584f, -0.01109591f, -0.01835846f, 
    -0.24898632f, -0.01395079f, -0.16231745f, -0.14386787f, 0.09972808f, -0.07895531f, -0.05620357f, -0.19125383f, 
    0.03461608f, 0.05128663f, -0.00930719f, 0.01445277f, -0.25963938f, -0.10516515f, 0.08190238f, -0.11454283f, 
    -0.08746259f, -0.06234179f, 0.09664811f, 0.03482702f, -0.02535932f, -0.07570821f, -0.11865599f, -0.17547567f, 
    0.06926883f, 0.02799075f, 0.11445338f, 0.07589101f, 0.04491710f, 0.06350774f, 0.07117058f, -0.01634803f, 
    -0.03880694f, 0.06566320f, -0.00512672f, 0.21393853f, -0.24481674f, -0.05390092f, -0.10753798f, -0.08785252f, 
    0.17322004f, -0.11242065f, -0.02331539f, -0.00505956f, 0.06867461f, 0.00978710f, -0.07944530f, 0.06679191f, 
    -0.09011760f, -0.27103296f, 0.13229345f, -0.07290513f, 0.10966929f, -0.04215734f, -0.13714150f, -0.25449347f, 
    -0.01206991f, 0.03654135f, 0.04311424f, 0.15434735f, -0.22240263f, 0.05830562f, -0.04771048f, -0.08882523f, 
    -0.06750351f, 0.07124055f, -0.03928696f, -0.03108967f, -0.06682767f, 0.05903019f, 0.25402921f, 0.04479656f, 
    -0.02503778f, 0.02756644f, -0.06379296f, 0.02012589f, -0.01025829f, 0.02334882f, 0.02892714f, -0.03757536f, 
    -0.02564102f, -0.01530484f, 0.05320540f, -0.07860229f, -0.10996141f, -0.20693080f, -0.35283801f, 0.05780924f, 
    0.02054654f, 0.13649000f, -0.07561997f, -0.01143224f, 0.11407564f, -0.00906668f, -0.12819828f, -0.05930305f, 
    -0.00410650f, -0.03667989f, 0.15648176f, 0.12509942f, -0.01454377f, 0.06586996f, 0.12565546f, -0.02056150f, 
    0.01335495f, -0.06311847f, -0.01317625f, -0.02214332f, -0.12070804f, -0.19125412f, 0.05165688f, 0.11131552f, 
    -0.02267485f, 0.03708611f, -0.05629403f, -0.09524155f, 0.09084280f, 0.11872321f, 0.14648715f, 0.10506695f, 
    -0.42455178f, -0.53603059f, -0.29058179f, 0.16673173f, 0.12725760f, -0.04405769f, -0.05299200f, -0.10053531f, 
    0.01889248f, 0.13732420f, -0.11941331f, 0.12990703f, 0.11605994f, 0.14117314f, -0.01272365f, -0.16464444f, 
    -0.04477741f, 0.11209620f, 0.11858790f, -0.06957993f, 0.03315788f, -0.25147748f, -0.00266033f, -0.18676789f, 
    0.18522395f, -0.08220185f, -0.05267264f, -0.14011231f, -0.04923069f, 0.04763776f, -0.10498857f, -0.03934704f, 
    0.00020814f, 0.09655993f, 0.04825725f, -0.05244337f, 0.03903965f, 0.07788378f, 0.03321434f, -0.09142244f, 
    0.06875741f, -0.05252934f, 0.01325263f, -0.04854593f, -0.02056366f, 0.02149881f, -0.08598480f, -0.02582057f, 
    0.19056793f, -0.04801524f, -0.07654420f, 0.01242353f, 0.07050787f, -0.02124220f, 0.07815849f, 0.02835797f, 
    0.13058978f, 0.04480185f, 0.02045087f, -0.18868056f, -0.15584783f, 0.16029307f, -0.02529760f, 0.08941638f, 
    0.02179473f, -0.08875901f, 0.02567051f, 0.04445719f, -0.07202537f, -0.04109473f, 0.04472835f, -0.01702293f, 
    0.13212001f, -0.15276261f, -0.13981605f, -0.02435584f, -0.01675392f, -0.07836865f, 0.03171459f, 0.05315936f, 
    -0.03895864f, 0.05194532f, 0.04021847f, 0.14999247f, -0.10884753f, -0.07630621f, 0.33680642f, 0.06381071f, 
    0.04552632f, -0.00945748f, 0.00106715f, -0.07357474f, 0.00445451f, 0.01009665f, -0.03967628f, -0.04959577f, 
    -0.30653894f, -0.18816528f, 0.26569206f, 0.19351849f, 0.07454236f, 0.03677332f, -0.00867207f, 0.00752315f, 
    0.01059053f, -0.00345644f, -0.05468933f, -0.03445552f, 0.12792771f, -0.04255056f, 0.05702252f, 0.22637588f, 
    -0.15650052f, 0.02359176f, -0.02326730f, 0.08568503f, -0.08267117f, -0.14633845f, 0.01740916f, 0.05028176f, 
    -0.11497901f, 0.12915230f, 0.10240496f, 0.23123705f, 0.05021346f, -0.06878656f, -0.01000314f, -0.08337279f, 
    -0.04564045f, -0.15097213f, -0.05314943f, 0.09679271f, -0.00887895f, -0.01085971f, -0.13082519f, -0.03244188f, 
    0.02882786f, -0.06181930f, -0.08384180f, 0.11537150f, -0.01124605f, -0.10087635f, -0.07114218f, -0.14581400f, 
    -0.03443172f, -0.13497043f, -0.12936109f, 0.10069486f, 0.05930701f, -0.01065920f, 0.12624086f, 0.10825042f, 
    0.08057767f, 0.03885125f, 0.10800370f, -0.12292379f, 0.01627763f, -0.03539580f, -0.01707018f, 0.00696713f, 
    -0.04896409f, 0.03567276f, -0.01701804f, -0.02868059f, -0.07454240f, -0.06065838f, 0.13564938f, 0.03749789f, 
    0.03042997f, 0.03473069f, 0.04349006f, -0.27147612f, -0.10319685f, 0.07154756f, 0.12245639f, -0.14179468f, 
    0.04650226f, 0.04764921f, 0.05033476f, 0.03236970f, 0.05085762f, 0.05025530f, -0.01669563f, 0.24666259f, 
    -0.00809896f, 0.11733288f, 0.11153901f, 0.17268498f, 0.07309096f, 0.00166857f, -0.08991711f, -0.04620069f, 
    -0.15692975f, 0.13398753f, 0.19941847f, -0.18552884f, -0.09235287f, 0.03808168f, 0.07060258f, 0.04856767f, 
    0.07457834f, -0.00705701f, -0.13194953f, -0.02337943f, -0.25535679f, -0.11245312f, -0.12544554f, 0.04154711f, 
    0.08458740f, 0.11819991f, 0.05447610f, 0.00017806f, 0.01147533f, -0.16151570f, -0.07479963f, -0.04580965f, 
    0.14920615f, 0.12208465f, 0.05439245f, 0.11140920f, -0.04390630f, -0.09191349f, 0.03216108f, 0.01496929f, 
    0.00790220f, -0.08935729f, 0.06937417f, -0.01097346f, 0.10544714f, 0.01205190f, 0.07747836f, 0.05650426f, 
    -0.14563154f, 0.06891935f, -0.01042633f, 0.10026141f, -0.03839682f, -0.07673428f, 0.07124466f, 0.06244208f, 
    0.27662572f, -0.11179309f, -0.19771531f, 0.06349423f, 0.10189706f, 0.09311724f, -0.03583376f, 0.09402230f, 
    0.09785104f, -0.16152270f, 0.00803841f, -0.18648748f, -0.13591735f, -0.05848691f, 0.10964885f, 0.06161894f, 
    -0.10772231f, -0.11414116f, -0.00612136f, -0.01222718f, -0.04010123f, -0.10973172f, -0.05109480f, -0.02721410f, 
    -0.07869141f, -0.16489226f, 0.04939117f, 0.14320549f, 0.05041964f, 0.01147073f, -0.05783283f, 0.02899263f, 
    0.07859412f, -0.06437486f, 0.12244283f, 0.00087962f, 0.03305916f, -0.03935094f, 0.16453345f, 0.04307744f, 
    0.03539310f, 0.09393545f, -0.00319902f, 0.06711034f, 0.04371462f, 0.12653576f, -0.03752159f, 0.16418855f, 
    0.09605410f, -0.03069662f, -0.10068081f, -0.11314233f, -0.04515976f, -0.07801065f, -0.07873407f, -0.05841932f, 
    -0.12988874f, 0.10367777f, 0.19533986f, 0.21028396f, 0.03676220f, -0.00650978f, -0.05184454f, 0.03702572f, 
    0.02642818f, 0.12221726f, 0.04363386f, -0.11185206f, -0.08363599f, -0.04015533f, -0.02362145f, 0.16400628f, 
    -0.41720071f, 0.13052487f, -0.15991202f, -0.04581321f, 0.05366177f, 0.02726999f, -0.04396104f, -0.02392757f, 
    0.01563842f, -0.00128202f, 0.10172321f, -0.12136774f, -0.20038514f, -0.04503438f, -0.12727287f, -0.21469127f, 
    0.07010649f, 0.00876103f, 0.04327073f, -0.04849790f, -0.07262157f, -0.15902410f, 0.07226095f, -0.16831526f, 
    -0.23233648f, -0.17423268f, -0.20324348f, 0.02555951f, 0.08522920f, 0.04676668f, -0.04928505f, 0.03883250f, 
    0.18899605f, 0.16332833f, -0.12858605f, 0.11354069f, -0.00461480f, 0.17623517f, -0.02494714f, -0.23449814f, 
    -0.00656736f, -0.09951659f, 0.06874455f, 0.05180961f, 0.10009971f, -0.01864669f, -0.01423692f, 0.10413461f, 
    -0.02339765f, -0.03212849f, 0.01363622f, -0.11851989f, 0.09568028f, 0.02915120f, -0.07733657f, 0.03843253f, 
    -0.01286127f, 0.01923278f, 0.06676345f, -0.05066577f, -0.14676780f, -0.04263099f, 0.12672187f, 0.30373800f, 
    -0.03626261f, 0.01419524f, 0.04146184f, 0.08615319f, -0.06343272f, 0.05857687f, 0.12207433f, -0.09360839f, 
    -0.03601771f, -0.00870894f, -0.06529192f, 0.14684117f, -0.05861807f, -0.08963558f, 0.02753999f, 0.17225491f, 
    0.02738109f, 0.08631781f, -0.09824755f, -0.06974147f, -0.35990989f, 0.09092610f, 0.00265149f, -0.12975357f, 
    0.04903679f, -0.10291729f, 0.12470257f, -0.02897404f, -0.00065749f, 0.08319353f, -0.06004361f, 0.01936666f, 
    0.03883238f, 0.09862466f, 0.05471530f, -0.02707473f, -0.05313192f, -0.01053830f, -0.02195873f, -0.03091546f, 
    0.15490201f, 0.03567665f, 0.17104140f, 0.16457546f, 0.09072644f, 0.09178545f, -0.00923946f, 0.07806523f, 
    -0.03507777f, -0.12405790f, 0.06003016f, 0.02032638f, 0.00124587f, -0.11068216f, 0.02372170f, -0.06567591f, 
    0.17821781f, -0.00893232f, 0.12946473f, 0.06518690f, 0.09421194f, -0.10443459f, 0.02331548f, -0.23604620f, 
    -0.00698191f, 0.05215575f, -0.22894868f, -0.15302223f, 0.17489782f, 0.12348161f, 0.15392181f, -0.25929779f, 
    0.02708426f, 0.00209527f, -0.13391371f, -0.01935642f, 0.04630649f, -0.09813836f, 0.06898978f, -0.02786867f, 
    0.13532892f, -0.01114064f, -0.08099162f, -0.08911109f, 0.08223910f, -0.03351123f, 0.06015815f, 0.01086195f, 
    0.00652734f, -0.07643829f, 0.16972885f, -0.24853571f, 0.03949696f, -0.14647138f, -0.03157974f, 0.16975424f, 
    -0.08655763f, -0.00985056f, -0.00333868f, -0.02135502f, -0.01241258f, -0.06619630f, -0.09486202f, -0.15485917f, 
    -0.21469770f, -0.32530266f, -0.13378620f, -0.09185573f, -0.04752096f, 0.01137514f, -0.06815197f, -0.00949840f, 
    -0.02258088f, 0.01186737f, 0.00982403f, 0.08774189f, -0.09728795f, -0.04335905f, 0.05448022f, -0.20620990f, 
    -0.00437690f, -0.12317519f, 0.02994599f, -0.07272775f, -0.07808723f, 0.06950766f, 0.06956860f, -0.00176135f, 
    -0.38543028f, 0.02340823f, 0.09322581f, 0.28176877f, 0.01608064f, 0.12297568f, 0.16067110f, -0.01949893f, 
    0.01205680f, 0.07262407f, 0.03444862f, -0.04004843f, -0.09010809f, -0.05064897f, -0.06819884f, 0.16961454f, 
    -0.12131715f, 0.07739314f, -0.04753966f, 0.05460956f, -0.09346991f, -0.03557424f, -0.00798605f, 0.00968452f, 
    -0.17282259f, 0.13655743f, 0.10411994f, -0.21839277f, -0.17190167f, 0.06287330f, 0.02251808f, -0.00378514f, 
    0.08933213f, 0.04943445f, -0.03736587f, 0.06721674f, 0.20599374f, -0.02030972f, -0.19625877f, -0.22861436f, 
    -0.03555958f, 0.01785171f, 0.09451803f, -0.03323958f, 0.09414406f, 0.10415675f, -0.09030185f, -0.03570832f, 
    0.14523840f, -0.25337034f, 0.07103273f, -0.03243349f, 0.01552983f, 0.01863661f, 0.04094935f, -0.21896882f, 
    -0.06099800f, -0.09181061f, 0.27011657f, -0.01518814f, -0.01420622f, 0.13524994f, 0.12957717f, -0.28217298f, 
    -0.02513271f, -0.03651507f, 0.03322020f, 0.08772668f, -0.09521554f, 0.03820993f, 0.16644117f, 0.03048442f, 
    -0.57754481f, 0.14737558f, 0.09601971f, 0.08985049f, 0.01379474f, -0.04780288f, 0.08163685f, 0.10815258f, 
    0.00891523f, -0.10389628f, 0.13116455f, 0.04308073f, -0.37436515f, 0.07634801f, 0.18036513f, -0.04069040f, 
    0.00164977f, 0.05107322f, -0.02668117f, 0.04938744f, -0.07281335f, -0.12957884f, -0.00724294f, -0.10330249f, 
    0.16330023f, -0.02308879f, -0.01170211f, -0.10466479f, -0.02496636f, 0.10581812f, -0.05552624f, -0.00205729f, 
    0.04748966f, 0.07807105f, -0.04391631f, -0.13054916f, 0.30438253f, 0.03146717f, 0.17351981f, 0.23323329f, 
    -0.09238883f, 0.01078693f, -0.01619728f, 0.04445470f, -0.10790723f, -0.02867381f, 0.06631635f, -0.04461826f, 
    -0.18127964f, 0.02635665f, -0.36581701f, -0.12734857f, -0.12430326f, -0.07565569f, 0.00581130f, -0.19095042f, 
    -0.05112052f, -0.09223969f, -0.05069463f, -0.18810676f, 0.08400549f, -0.03313499f, 0.04135806f, -0.07117892f, 
    0.09083939f, -0.04320836f, -0.02487419f, 0.11907513f, 0.05236842f, 0.03552210f, 0.06783340f, 0.08667192f, 
    -0.17051217f, -0.05334204f, -0.07594211f, -0.15717250f, 0.07461763f, 0.02279268f, 0.02546866f, 0.14836767f, 
    0.06342568f, -0.02640225f, 0.00001875f, -0.02547730f, 0.50179428f, 0.01803262f, 0.14316024f, 0.05086987f, 
    -0.08609538f, 0.04669891f, -0.10431052f, -0.07002181f, 0.07001152f, -0.17449193f, 0.14298736f, 0.18687931f, 
    0.23536669f, -0.02603464f, 0.03935291f, -0.07977837f, -0.04362484f, -0.02979175f, -0.03380537f, -0.02784531f, 
    0.04774730f, -0.10197964f, 0.06238323f, -0.08736730f, -0.07543305f, -0.09298608f, -0.06053602f, -0.18842220f, 
    0.04163935f, 0.04450349f, -0.00846032f, -0.04630436f, -0.06203768f, -0.03051237f, 0.08442791f, -0.07330699f, 
    -0.09010075f, -0.18044925f, -0.18008885f, 0.13349049f, -0.06084471f, 0.01646107f, 0.04729704f, 0.00256858f, 
    0.02231069f, 0.02151761f, 0.01984441f, -0.05676307f, 0.02791711f, 0.03125004f, -0.11635472f, 0.00301168f, 
    0.04062124f, -0.08690334f, -0.03749301f, -0.03593698f, 0.08563600f, 0.01295959f, -0.10405242f, -0.06914637f, 
    0.28073525f, -0.23193505f, 0.09598452f, -0.08436099f, 0.13518991f, 0.01916139f, -0.03583802f, 0.04998323f, 
    0.04260555f, -0.12768587f, -0.03152907f, 0.03610690f, -0.02823185f, -0.11966776f, -0.14045259f, -0.06525441f, 
    0.01594655f, 0.02119523f, -0.00217686f, -0.10231351f, 0.11661115f, -0.02528993f, 0.09165629f, 0.07946783f, 
    -0.02075292f, 0.11563198f, 0.02050473f, 0.07609387f, -0.08569995f, -0.06880748f, -0.01373394f, 0.04600066f, 
    0.04178001f, 0.08348419f, 0.00084258f, 0.07448074f, -0.29612604f, -0.10468803f, -0.02751604f, 0.22030593f, 
    0.07511790f, -0.02536812f, 0.12956415f, -0.04324918f, -0.05420484f, -0.10429168f, -0.19231464f, -0.12263444f, 
    -0.04855165f, 0.04183440f, -0.14145978f, -0.13816753f, 0.02765919f, 0.11586571f, -0.04762078f, -0.07019086f, 
    -0.02764963f, 0.13387530f, 0.07721514f, -0.03462313f, -0.02312678f, -0.06914753f, 0.12550186f, -0.06767922f, 
    -0.01047402f, -0.12091488f, -0.09992535f, -0.03658848f, 0.02684828f, 0.13029669f, 0.01762876f, 0.17740734f, 
    -0.33609644f, 0.00346712f, 0.10673740f, -0.15787749f, -0.06148267f, -0.01039003f, 0.07167901f, -0.01357557f, 
    -0.01766857f, -0.01645667f, -0.06940864f, -0.13451479f, -0.03125242f, 0.01633024f, 0.14780317f, 0.01066095f, 
    0.02128111f, 0.12716633f, -0.04158923f, 0.01742481f, 0.00964854f, -0.08622862f, 0.02343566f, -0.06090344f, 
    -0.21787162f, -0.03757913f, -0.03855695f, 0.14886647f, 0.09314753f, -0.03474313f, -0.02804844f, -0.13501137f, 
    -0.03834281f, 0.00024508f, 0.00299933f, -0.01282129f, 0.08131818f, 0.11383551f, -0.00052194f, 0.30320331f, 
    -0.07040148f, 0.17691448f, -0.00177312f, 0.12893724f, -0.01807389f, 0.07609256f, -0.08876234f, -0.07837489f, 
    0.26404732f, -0.09589773f, -0.01208729f, -0.08225817f, 0.08865174f, 0.22579807f, 0.01419200f, -0.00126691f, 
    0.03437575f, -0.13212042f, -0.03574608f, -0.06168310f, 0.09399631f, -0.04337190f, 0.02512862f, -0.04991236f, 
    -0.00975600f, 0.02095855f, 0.03187925f, 0.06686598f, 0.00248281f, 0.05858900f, -0.09570093f, 0.05672185f, 
    0.36139211f, -0.06872740f, -0.06033035f, -0.09481896f, 0.05523669f, 0.01538312f, -0.02699494f, 0.13231944f, 
    -0.06353829f, 0.08653703f, 0.08901364f, -0.02233542f, -0.01255369f, -0.03189107f, 0.16615495f, -0.10924582f, 
    0.17323774f, -0.10503536f, 0.01564378f, 0.00846889f, 0.05125935f, 0.09640337f, -0.09162748f, 0.06454382f, 
    0.01352910f, -0.19835787f, -0.14901622f, 0.20452048f, 0.05951883f, 0.05928624f, -0.04067648f, 0.01930803f, 
    0.04174762f, -0.05884931f, -0.02855118f, -0.07775092f, -0.07208732f, -0.04439122f, 0.13137423f, 0.02849661f, 
    0.06419539f, 0.01243039f, -0.06289568f, 0.05428066f, 0.00609071f, -0.00405141f, 0.09833792f, 0.07300112f, 
    -0.11929022f, -0.04169548f, 0.04842781f, -0.20114465f, -0.02373144f, -0.14906617f, -0.12527968f, -0.10334617f, 
    -0.07187246f, -0.05867461f, 0.01281735f, 0.00563280f, -0.12135737f, 0.17939259f, 0.17022698f, 0.20182917f, 
    0.06726030f, -0.03756016f, 0.03232814f, 0.02069672f, -0.00359723f, 0.02420518f, -0.15190805f, -0.01740004f, 
    -0.17289971f, 0.12293045f, 0.13506518f, 0.07976893f, 0.06342330f, 0.01293325f, -0.06055728f, -0.09494473f, 
    0.07274792f, 0.08419050f, -0.03606817f, -0.03453258f, -0.01738676f, 0.07955462f, 0.02089895f, -0.12711535f, 
    0.10825136f, -0.09135714f, -0.01448551f, -0.01045658f, -0.03671183f, 0.05538942f, 0.07833394f, 0.09107649f, 
    0.19609897f, -0.19747770f, -0.06896681f, -0.01081640f, -0.02419055f, 0.11124744f, -0.03441029f, -0.02199336f, 
    0.00171691f, -0.11897276f, 0.06225025f, 0.04515449f, -0.39815852f, -0.01008275f, 0.09391619f, -0.11598405f, 
    -0.08000158f, -0.18348338f, -0.03066657f, 0.02201743f, -0.10935152f, -0.00008183f, 0.06130171f, 0.04985246f, 
    -0.08798677f, 0.20580076f, 0.05613853f, 0.03686814f, -0.04302615f, 0.04935052f, -0.05644803f, 0.06151387f, 
    -0.07623065f, 0.01849257f, 0.00577135f, -0.01037705f, -0.08514488f, 0.14455137f, 0.03271264f, -0.01110140f, 
    0.07795557f, 0.05230454f, -0.03907024f, -0.05435173f, 0.01842669f, -0.00729166f, -0.05323863f, -0.02680200f, 
    -0.26062277f, -0.12759769f, -0.19813856f, -0.12883675f, -0.05242346f, -0.09115467f, 0.03978664f, -0.15967226f, 
    0.05688270f, 0.12528975f, 0.05050460f, 0.01167301f, 0.12303519f, 0.14856319f, 0.02895539f, -0.25983399f, 
    0.17242089f, 0.03480360f, 0.04377789f, 0.09602974f, -0.06738550f, 0.16992371f, 0.08851559f, 0.07356793f, 
    0.15353383f, -0.02028178f, 0.10870665f, 0.00939838f, 0.00926757f, -0.02033790f, 0.07058779f, -0.03579895f, 
    -0.06005929f, 0.09410810f, -0.06873564f, -0.02740468f, -0.20075117f, 0.15247296f, 0.02613496f, -0.06330689f, 
    -0.00691477f, 0.04533195f, 0.00032560f, 0.04047135f, -0.03750928f, -0.03757596f, 0.01977824f, -0.17168722f, 
    0.00475883f, 0.01793502f, -0.12660182f, -0.23664102f, 0.11308587f, 0.13078581f, -0.00398887f, -0.01578165f, 
    -0.10213184f, -0.05412558f, 0.03113159f, -0.13838804f, -0.04832912f, 0.17028654f, 0.10598325f, -0.18241371f, 
    -0.12091987f, -0.06938581f, 0.00586662f, 0.03953957f, 0.15633148f, -0.03641636f, -0.02632221f, -0.09141047f, 
    0.00158035f, -0.13705347f, 0.09608265f, -0.21722701f, 0.01248700f, -0.00269906f, 0.06724300f, -0.01063036f, 
    0.02005239f, 0.06478684f, -0.10040805f, 0.05595041f, 0.08673377f, -0.06652871f, -0.03452791f, 0.11134426f, 
    -0.15640272f, 0.08528922f, -0.04988557f, 0.02343337f, 0.01109293f, 0.10227837f, 0.00284484f, 0.12779562f, 
    -0.04898855f, 0.08218080f, -0.02673621f, -0.28888869f, -0.07627234f, 0.03714196f, 0.17188565f, 0.01815096f, 
    -0.00071576f, -0.03389500f, 0.05048455f, -0.01510894f, 0.05299640f, 0.03655354f, 0.13177097f, -0.16248709f, 
    -0.08095443f, -0.00300825f, -0.01389939f, 0.07719906f, -0.07028282f, -0.01680330f, 0.02491833f, -0.14264779f, 
    0.04043299f, 0.02594090f, 0.08335202f, -0.13015892f, 0.08546847f, -0.08726428f, 0.01024683f, -0.04982738f, 
    0.00900213f, -0.02909650f, 0.06588646f, 0.02033436f, 0.07492397f, -0.06366937f, -0.08100121f, -0.11114164f, 
    -0.00733348f, -0.02698075f, -0.03217642f, -0.05852944f, -0.16027333f, 0.02862787f, 0.01959169f, 0.07456748f, 
    0.19007891f, -0.15069728f, -0.00489590f, -0.14569871f, 0.04465809f, -0.04596375f, -0.00467467f, -0.09102053f, 
    -0.13351579f, -0.03291149f, 0.09147874f, 0.02819803f, 0.29393539f, -0.41299933f, 0.14003523f, -0.04859480f, 
    0.11725545f, 0.15787676f, 0.00660746f, -0.10291118f, -0.02428609f, -0.02055726f, -0.04266035f, 0.01105188f, 
    0.06487208f, 0.18184623f, 0.13851993f, -0.31714419f, 0.03787035f, 0.03323339f, 0.01102169f, 0.07717612f, 
    0.00424355f, -0.05051393f, -0.11511685f, -0.05074891f, -0.11867686f, -0.00998571f, -0.12507838f, 0.33304185f, 
    0.10089738f, -0.02188347f, -0.05404583f, 0.00001384f, -0.06701302f, 0.01650245f, -0.11107080f, -0.07950095f, 
    -0.40455759f, 0.09256215f, -0.12166486f, 0.07917912f, -0.15061533f, 0.12282425f, 0.08419241f, 0.12369726f, 
    0.00064555f, 0.11353394f, 0.12992224f, 0.14481296f, -0.15583371f, -0.16319409f, 0.05734308f, -0.15094733f, 
    -0.04888797f, 0.01150060f, 0.03283062f, 0.03695236f, -0.07294247f, -0.00668458f, -0.08433992f, 0.08125287f, 
    0.21494906f, -0.03701589f, 0.07521970f, 0.02098613f, -0.06638890f, -0.03413840f, 0.02727568f, -0.06285246f, 
    -0.02590817f, 0.03608236f, -0.01033270f, -0.03787935f, 0.19402482f, -0.32265851f, 0.06693805f, 0.12397578f, 
    -0.03811715f, -0.03427812f, -0.03137562f, 0.01243760f, 0.02898182f, -0.03752154f, -0.06853667f, -0.06676266f, 
    -0.17601414f, 0.08643179f, 0.12112512f, 0.12164737f, 0.09913195f, 0.02488274f, 0.02031964f, -0.01716295f, 
    -0.02121406f, 0.02288852f, -0.01952470f, 0.00425067f, 0.14546783f, 0.10337878f, 0.13763736f, 0.05086518f, 
    -0.02404764f, 0.04004039f, -0.02426882f, -0.02464493f, -0.07783195f, -0.02415805f, 0.03536467f, -0.04931229f, 
    -0.06550673f, 0.02167253f, 0.01591444f, -0.12520963f, -0.09424065f, 0.03660999f, -0.04660643f, -0.01873924f, 
    -0.01598771f, -0.09869906f, 0.01797081f, -0.06468078f, -0.00986678f, 0.06106615f, -0.06812957f, 0.12778252f, 
    0.00146070f, 0.00241030f, -0.01741899f, 0.02450459f, -0.01632004f, -0.06695496f, 0.04510527f, -0.01607775f, 
    -0.04234637f, 0.14756066f, 0.01144511f, -0.08622861f, -0.04552608f, 0.04508873f, -0.01921297f, -0.04349947f, 
    -0.02284009f, 0.00826592f, -0.13659251f, -0.09107020f, 0.16076280f, -0.06552923f, 0.17709035f, -0.01745455f, 
    -0.10484190f, -0.03125492f, -0.03711439f, -0.12519789f, 0.01322192f, 0.07619172f, -0.00349474f, -0.03082998f, 
    0.11591461f, -0.00716577f, 0.00973148f, -0.04905991f, 0.05923056f, 0.06008657f, 0.01331909f, 0.02616258f, 
    0.00167172f, 0.02738496f, 0.06311414f, 0.01522205f, -0.18687336f, -0.02267585f, -0.10829750f, -0.11922154f, 
    -0.12418586f, 0.03241401f, -0.04817206f, -0.04980881f, -0.03834109f, -0.14676432f, 0.00169266f, -0.04280058f, 
    -0.18080392f, 0.03011817f, -0.06921303f, -0.11150430f, 0.01168951f, 0.01608574f, -0.04507373f, -0.07904099f, 
    -0.01699969f, -0.01720152f, 0.03978871f, -0.07850299f, 0.11905397f, 0.08405744f, -0.02825972f, 0.04775422f, 
    -0.02364110f, -0.01768665f, 0.00010771f, 0.01805392f, -0.09036391f, -0.05190265f, -0.03936517f, -0.02570135f, 
    -0.05707363f, -0.01359757f, -0.12378096f, -0.08295032f, -0.08928087f, 0.02246031f, -0.03820251f, -0.01631991f, 
    -0.04729425f, 0.00424114f, -0.04541503f, -0.02542658f, -0.00697728f, 0.07441658f, 0.01869712f, 0.08719554f, 
    -0.08286972f, -0.08629198f, 0.03001713f, 0.02816283f, -0.02050718f, 0.01471897f, 0.03286315f, 0.03943874f, 
    0.15737446f, 0.20344648f, 0.19526014f, 0.16648805f, 0.12922741f, 0.07357927f, 0.09019589f, -0.07160566f, 
    -0.03487967f, 0.05883153f, -0.06966071f, -0.09850579f, 0.10443559f, -0.05187671f, -0.00090989f, 0.10933836f, 
    0.05484614f, -0.03428530f, 0.01353869f, -0.03638961f, -0.03293511f, 0.02093020f, 0.03455579f, -0.01074691f, 
    0.08852589f, 0.10663687f, 0.13213506f, 0.02157681f, 0.09889951f, 0.05632421f, -0.01611559f, -0.02727998f, 
    -0.05274293f, 0.04640890f, -0.00994524f, -0.04488992f, 0.06728660f, 0.09039152f, -0.02160617f, 0.00105372f, 
    -0.10360943f, 0.00211526f, -0.02283776f, -0.00062485f, -0.07433081f, -0.03758512f, -0.07171340f, 0.04353208f, 
    -0.05963065f, -0.23811091f, 0.02959744f, -0.06643195f, -0.10025038f, -0.00178489f, 0.01670352f, -0.06009116f, 
    -0.05140110f, -0.04022831f, -0.01977771f, 0.03145345f, 0.07411379f, 0.19529499f, 0.17237309f, 0.05766879f, 
    -0.00705012f, 0.05882499f, 0.01226574f, -0.03031015f, -0.03119130f, 0.09840214f, -0.03394208f, -0.05268313f, 
    -0.05641077f, 0.07445025f, 0.04114008f, 0.04346557f, 0.05375430f, -0.02322900f, 0.06782003f, 0.00869666f, 
    0.00031058f, -0.11344926f, -0.02522684f, -0.01334270f, 0.02209035f, 0.00875768f, 0.15535796f, 0.02508958f, 
    0.01581257f, -0.00519962f, -0.03797666f, -0.06486777f, -0.05824995f, 0.06129434f, -0.05692778f, -0.11297723f, 
    0.14409871f, 0.01118096f, -0.08092079f, -0.12992403f, -0.03423459f, -0.06035673f, 0.02713428f, -0.05449333f, 
    -0.01526149f, 0.02880190f, 0.03425547f, -0.00774083f, 0.06698653f, 0.09858794f, 0.13840795f, 0.10706918f, 
    -0.01490292f, 0.05715763f, -0.01621800f, 0.03879434f, 0.00550644f, 0.03580367f, -0.11473851f, -0.04262173f, 
    -0.11230078f, 0.03800957f, -0.00746632f, -0.16326590f, 0.03666065f, -0.03244929f, 0.01998306f, -0.05556872f, 
    -0.06264615f, -0.02487135f, 0.02113682f, -0.01634398f, 0.09214053f, -0.13293017f, 0.11634803f, 0.17109399f, 
    0.07397052f, -0.05042212f, -0.04134566f, -0.02952402f, -0.00993865f, -0.03588555f, -0.09123329f, 0.00171343f, 
    0.10310419f, 0.12232466f, 0.09340010f, 0.23279385f, 0.12655593f, -0.00651913f, 0.06941938f, -0.05526268f, 
    -0.06460005f, 0.01832688f, -0.09495448f, -0.08404891f, -0.02647554f, 0.09370020f, 0.08540986f, 0.17130688f, 
    0.01322746f, 0.04390214f, -0.06748634f, 0.08274146f, -0.06412370f, -0.02766521f, 0.04590327f, 0.04745593f, 
    0.11797613f, 0.15872788f, -0.04285360f, -0.06314921f, -0.09676605f, 0.08406281f, -0.00186500f, 0.02996638f, 
    -0.03233272f, 0.05037481f, -0.01678541f, -0.09181779f, -0.22634357f, 0.19139731f, -0.06485965f, -0.07093622f, 
    -0.10347738f, -0.02662994f, -0.10118279f, 0.01928566f, 0.00875459f, -0.01144368f, -0.01417775f, -0.18016100f, 
    -0.10833792f, 0.03233288f, -0.11525273f, 0.04576972f, -0.08075535f, 0.00712063f, -0.00261179f, -0.06375912f, 
    -0.06035336f, 0.02185444f, 0.00852788f, -0.00299981f, -0.27937320f, 0.04832413f, 0.02368430f, 0.09346020f, 
    -0.01371396f, -0.01462177f, 0.01655931f, 0.03523697f, -0.08539189f, 0.03666703f, -0.02378135f, 0.02512494f, 
    0.18231553f, -0.24392048f, 0.15719512f, 0.04628022f, 0.00484247f, -0.04077877f, -0.01293916f, -0.01432592f, 
    0.03569765f, -0.05136229f, -0.04141506f, -0.10294868f, -0.28775901f, 0.17650124f, -0.03025149f, -0.03364311f, 
    0.04360446f, 0.05374497f, 0.01643967f, -0.06239703f, -0.04064446f, 0.06947541f, 0.00134732f, -0.03108226f, 
    -0.04374656f, 0.08390348f, 0.02848417f, 0.07472736f, 0.08963545f, 0.03310901f, -0.01423647f, -0.08703941f, 
    -0.04418654f, 0.03006277f, 0.04413207f, -0.07188673f, 0.11893140f, -0.27361935f, 0.14325823f, 0.04229725f, 
    -0.03462696f, -0.06505378f, -0.03580294f, -0.04911514f, -0.05340214f, -0.03169737f, -0.01211715f, -0.01213621f, 
    0.06136426f, 0.12254031f, -0.16822788f, 0.13264097f, 0.00416224f, -0.03984430f, -0.09638582f, 0.01811294f, 
    0.00677365f, 0.00705188f, 0.08473152f, -0.03388922f, 0.00580058f, 0.00058120f, 0.01307570f, -0.00444709f, 
    -0.06958058f, -0.04760040f, -0.00257501f, -0.02606134f, -0.06037242f, 0.04568955f, -0.06343232f, 0.01415040f, 
    0.10317527f, 0.07619387f, 0.05898406f, 0.09124240f, 0.08343250f, 0.02420729f, -0.02566469f, -0.05810565f, 
    -0.09518240f, -0.06176261f, -0.05756385f, -0.06549529f, -0.08258377f, -0.17921254f, -0.12359600f, -0.17919008f, 
    0.04403457f, -0.06036010f, 0.03018920f, -0.03628580f, -0.03657740f, -0.00846291f, 0.02488299f, 0.02819795f, 
    -0.01521257f, 0.03950911f, -0.00837881f, -0.09573088f, 0.00287891f, 0.00959589f, -0.00248528f, -0.02215462f, 
    -0.00789568f, -0.03228291f, -0.02677260f, -0.08277965f, 0.03405981f, -0.27929020f, 0.12689452f, 0.03482492f, 
    -0.03471873f, -0.01740392f, -0.06328278f, -0.07117262f, -0.05590777f, -0.04396789f, 0.02859027f, 0.01868794f, 
    -0.20168501f, 0.07931352f, 0.07155125f, -0.13267645f, -0.01700065f, -0.05474877f, 0.02212078f, -0.01550875f, 
    -0.01667107f, 0.04402152f, 0.06907380f, -0.03015462f, -0.00442056f, -0.04315748f, 0.03370597f, 0.02990590f, 
    0.07439804f, -0.07648445f, 0.01246059f, 0.03465763f, -0.01045418f, 0.05803088f, 0.06052579f, 0.03357733f, 
    -0.22183973f, -0.14078365f, -0.20496517f, -0.08002137f, -0.02662234f, -0.10829794f, -0.06002427f, 0.00873950f, 
    -0.12398443f, 0.05184396f, 0.07975173f, -0.02928812f, -0.18997256f, -0.02462207f, -0.16461545f, -0.14460127f, 
    0.02583710f, -0.04513464f, 0.02611156f, -0.02587575f, -0.11311622f, -0.01429498f, -0.06842369f, -0.00558814f, 
    0.07821240f, 0.17691597f, 0.06148687f, 0.18633293f, 0.11984944f, 0.04308486f, 0.13614725f, 0.02461478f, 
    -0.10037374f, -0.03555617f, -0.02948638f, -0.06802955f, 0.03680644f, -0.17741074f, -0.15065926f, -0.12305908f, 
    -0.03946454f, -0.08315302f, -0.04210731f, -0.07801963f, -0.03075531f, -0.03996296f, -0.03802654f, 0.00495925f, 
    0.02535296f, -0.08743512f, 0.04499259f, -0.09034193f, 0.07258841f, -0.04229252f, -0.02841823f, -0.05405606f, 
    0.01049291f, 0.03957016f, -0.04080507f, -0.06799337f, -0.13044193f, 0.14715101f, -0.15675004f, -0.13904148f, 
    -0.03249359f, -0.02974816f, -0.01556003f, -0.07588050f, -0.00303854f, 0.01912088f, -0.00723140f, 0.03154157f, 
    0.04914769f, -0.15650499f, 0.03338932f, 0.03774961f, -0.04821226f, -0.09656795f, 0.00447360f, -0.01020828f, 
    0.07434632f, 0.05234962f, -0.02232335f, -0.07213248f, -0.42532992f, 0.03792936f, -0.07399230f, -0.11183559f, 
    -0.05524677f, -0.00780356f, -0.01116415f, -0.02235854f, -0.09142262f, -0.02334974f, -0.01319203f, 0.04839111f, 
    0.00708356f, -0.07568005f, 0.05186361f, 0.02548066f, -0.05820048f, 0.06226921f, -0.02234159f, -0.02353819f, 
    -0.07939149f, 0.02585603f, -0.09064645f, -0.08654689f, 0.02392055f, 0.04146629f, -0.00999235f, 0.10599127f, 
    0.04687303f, -0.05421633f, -0.01526016f, 0.10242735f, 0.02663829f, -0.00694608f, -0.07448275f, 0.00268007f, 
    -0.21552031f, 0.12492343f, -0.19497211f, 0.02470520f, -0.06589998f, -0.04915013f, -0.04378798f, -0.16945677f, 
    0.02392201f, 0.01483991f, -0.05432965f, -0.01085257f, -0.04740003f, 0.05083194f, -0.13416310f, -0.10995451f, 
    -0.02216770f, -0.00477376f, -0.04284235f, -0.02517228f, -0.06443525f, -0.08179174f, 0.02028199f, -0.08954772f, 
    0.29678088f, -0.02180159f, 0.14415021f, -0.02765991f, -0.08763289f, 0.04610871f, 0.00004937f, 0.00891458f, 
    -0.01354628f, 0.00412445f, -0.09809847f, -0.04864774f, 0.03667172f, 0.07319796f, 0.01934407f, 0.20531403f, 
    0.01045262f, 0.01641534f, -0.04318815f, -0.05168791f, -0.00715574f, -0.03353053f, 0.04610728f, 0.00437586f, 
    0.22248931f, -0.26608798f, 0.15179013f, 0.07486714f, 0.13394429f, 0.07535254f, -0.04395742f, -0.08351647f, 
    -0.06266173f, -0.09539197f, -0.00965615f, 0.00103050f, 0.23052427f, -0.29410699f, 0.02596001f, 0.00333615f, 
    0.01293149f, 0.04017306f, 0.01645620f, 0.03864006f, 0.04582261f, 0.04884377f, 0.05867819f, -0.01085167f, 
    -0.23659316f, 0.04811077f, -0.08870623f, -0.11703035f, -0.10261019f, -0.04601474f, 0.03526962f, -0.08602037f, 
    -0.00808599f, 0.02142142f, 0.04647656f, 0.00913415f, -0.03749447f, 0.00577156f, -0.10384753f, 0.04232142f, 
    -0.10154036f, -0.06242935f, -0.01430407f, -0.07431719f, 0.00757057f, -0.01900409f, -0.01283395f, -0.00346727f, 
    0.20546082f, 0.20371445f, -0.06849023f, 0.11034372f, 0.00269776f, -0.04421780f, -0.08869760f, 0.02015136f, 
    0.02344958f, 0.04124800f, -0.00195146f, 0.04556499f, -0.05078916f, 0.00141490f, 0.03283155f, -0.02302608f, 
    0.01916424f, -0.00195943f, 0.00352473f, -0.08325505f, -0.03422283f, -0.03568972f, -0.02900215f, 0.05037975f, 
    -0.11084189f, -0.30191988f, -0.08397579f, -0.07036744f, -0.07617632f, -0.02278629f, 0.05175813f, -0.04050574f, 
    0.00553074f, 0.03031323f, -0.06785686f, 0.02652037f, -0.06485636f, -0.10292944f, 0.02222097f, -0.11409000f, 
    -0.05036863f, 0.03465574f, -0.07862165f, -0.15320024f, 0.00165699f, -0.00537936f, 0.08019337f, -0.03562450f, 
    -0.00538027f, 0.03250803f, 0.12365111f, 0.15524453f, -0.11560105f, -0.07085834f, -0.14013900f, -0.14876829f, 
    -0.01311328f, -0.01403636f, -0.02995840f, -0.17692190f, -0.24534716f, 0.06163621f, 0.13558707f, -0.10463563f, 
    -0.06251584f, 0.00778747f, -0.02155135f, 0.04950286f, -0.04215651f, 0.07754423f, -0.11588116f, 0.04411249f, 
    0.19429244f, 0.13996656f, -0.08358678f, -0.03695782f, 0.07273813f, -0.06652789f, 0.00905521f, 0.05803059f, 
    -0.05489448f, 0.02126868f, 0.06088760f, 0.02697555f, -0.07325201f, -0.06145642f, 0.13334912f, -0.00151742f, 
    0.05483717f, -0.03156408f, -0.08430383f, -0.11203516f, -0.05696831f, 0.05856935f, -0.00499182f, -0.11852721f, 
    0.24427330f, -0.10242167f, 0.16544925f, 0.14383729f, 0.12005482f, -0.02089113f, -0.05161066f, -0.08955484f, 
    -0.03030279f, -0.02180486f, 0.06926911f, -0.06565369f, -0.29147315f, -0.18898618f, 0.08960661f, -0.15560517f, 
    0.06728478f, 0.03437040f, 0.03127443f, -0.07418775f, 0.05049327f, 0.01854404f, -0.09804200f, 0.10694159f, 
    0.13203636f, -0.22291659f, 0.09352090f, 0.08168266f, 0.09988290f, 0.05474681f, 0.03346189f, -0.02569055f, 
    0.02498539f, -0.02585254f, -0.04396799f, 0.08473143f, 0.21686295f, -0.09282729f, 0.06236705f, 0.22097178f, 
    0.14776231f, -0.10002074f, -0.01740030f, -0.08811987f, -0.04227854f, -0.00286138f, -0.05020748f, -0.02071436f, 
    0.09800239f, 0.02201163f, -0.00920107f, 0.02838084f, 0.04899936f, -0.05546526f, -0.02687130f, -0.01997222f, 
    -0.03585338f, 0.11520411f, -0.06977422f, -0.12457851f, 0.13165206f, 0.02913077f, -0.04659582f, 0.06564984f, 
    0.06681867f, -0.04437873f, -0.10626540f, -0.02523200f, 0.00557060f, 0.07316057f, 0.05679113f, -0.16977428f, 
    0.19148168f, -0.11158674f, -0.01076137f, 0.09186269f, -0.08121209f, -0.06035224f, 0.06122617f, 0.09686350f, 
    0.00273284f, -0.06217774f, 0.04742705f, 0.01397228f, 0.17829895f, -0.01247074f, -0.17121275f, -0.11062150f, 
    0.02469487f, -0.05805208f, -0.05414915f, -0.01101634f, -0.00776754f, -0.01737405f, -0.09277779f, -0.02626502f, 
    -0.11359815f, -0.06898388f, 0.15857185f, -0.14538293f, -0.02310430f, -0.00830430f, 0.09204772f, -0.14853527f, 
    0.02454734f, -0.11002967f, 0.01117782f, 0.16425613f, -0.15867640f, -0.16036572f, -0.08889989f, -0.25695592f, 
    0.05865196f, -0.06861538f, 0.04699402f, 0.03509223f, -0.01591472f, -0.09820550f, -0.06200531f, 0.00054594f, 
    -0.28909749f, -0.04646401f, 0.17394377f, -0.09854934f, -0.01357989f, -0.01634110f, 0.01388770f, -0.14923659f, 
    -0.02275287f, 0.03578044f, 0.00953575f, -0.02020329f, 0.07476991f, 0.17450088f, -0.20075113f, -0.05185772f, 
    -0.07719252f, 0.08075000f, 0.00855059f, -0.03922675f, -0.00601642f, 0.06729091f, 0.11469894f, -0.02411462f, 
    -0.01765824f, -0.26075023f, -0.08350398f, 0.14762701f, 0.05773970f, -0.02480004f, -0.04233191f, -0.06508937f, 
    -0.02830581f, -0.03048071f, 0.08469338f, -0.01208151f, -0.02848710f, 0.11727084f, 0.10796948f, 0.11273120f, 
    -0.08398525f, -0.07139811f, -0.09379380f, 0.05595261f, -0.04763757f, -0.06657886f, -0.00817932f, 0.06228711f, 
    -0.00944710f, -0.02659792f, -0.02693604f, -0.00920902f, -0.05060708f, 0.03854721f, -0.06670740f, -0.03943738f, 
    0.00343832f, 0.03707012f, -0.10332870f, 0.09525003f, -0.15947577f, -0.28452435f, 0.03777356f, -0.18991427f, 
    -0.00446312f, -0.04953230f, 0.00077870f, -0.06974611f, -0.06101375f, 0.10317075f, 0.00514261f, 0.09865777f, 
    0.05238218f, -0.07378899f, 0.05737636f, -0.00161627f, 0.04180126f, -0.11315189f, -0.00342631f, -0.14913549f, 
    -0.02580708f, 0.09379401f, -0.09622177f, -0.02969740f, -0.16477637f, 0.24714720f, -0.09605092f, -0.12402570f, 
    -0.06389636f, 0.07126635f, 0.01451746f, -0.03826314f, 0.05463742f, 0.04502904f, -0.06414957f, -0.06545614f, 
    0.13555539f, 0.02445869f, -0.13288058f, 0.09643807f, 0.13184182f, 0.06047465f, -0.05419445f, -0.03633568f, 
    -0.02361366f, -0.02917456f, 0.09564696f, -0.10742652f, 0.10206731f, 0.15790533f, -0.03145757f, 0.14471748f, 
    -0.03174660f, -0.03977913f, -0.14490896f, -0.12724784f, -0.02162690f, -0.03609370f, 0.02646169f, 0.05582069f, 
    -0.18177432f, -0.01078680f, 0.16686343f, -0.08575340f, 0.00301886f, -0.04732100f, 0.08547201f, -0.05903472f, 
    -0.00955702f, -0.00369559f, 0.02432906f, 0.15006404f, 0.02780589f, 0.07168747f, 0.13608697f, 0.01516660f, 
    -0.06131319f, -0.06413236f, 0.03522934f, -0.28512928f, 0.07727767f, -0.03617010f, -0.11621159f, -0.18171184f, 
    0.02395046f, 0.04955272f, 0.11844252f, -0.02132634f, -0.02507843f, 0.01565616f, -0.01328260f, 0.12045155f, 
    0.04885859f, 0.02186842f, 0.02676553f, 0.01836806f, 0.06273821f, 0.10184906f, 0.02582223f, 0.09584595f, 
    -0.12860112f, -0.12246753f, -0.07154967f, 0.00818453f, 0.03252208f, -0.06169609f, 0.00583070f, -0.03483087f, 
    -0.05619052f, 0.12351677f, -0.05783172f, -0.27626386f, -0.08890549f, 0.03579355f, 0.05475786f, 0.10175872f, 
    0.09030453f, -0.00909041f, -0.03016803f, -0.07926230f, 0.06526861f, 0.15660068f, -0.41580030f, -0.03317918f, 
    0.09504368f, -0.07703711f, -0.26759282f, -0.01811539f, -0.04093108f, 0.02977949f, 0.05445063f, 0.02507070f, 
    -0.05692926f, -0.19367899f, -0.03513376f, -0.19410509f, 0.06166207f, -0.08850199f, -0.04626217f, -0.01514405f, 
    0.02108987f, 0.15582164f, -0.00021708f, 0.02371301f, 0.12643188f, -0.10316811f, -0.01184609f, 0.04888889f, 
    0.02999531f, -0.07303016f, -0.10574369f, -0.02907609f, 0.11447537f, -0.01999589f, -0.00070047f, -0.13413835f, 
    -0.00570160f, -0.19263391f, 0.04545682f, 0.01038838f, 0.04411354f, -0.20214181f, -0.07308776f, 0.07969587f, 
    0.05622634f, 0.02733536f, -0.04207919f, -0.01373649f, 0.01454918f, -0.13887784f, -0.11220802f, -0.02523945f, 
    0.08392514f, -0.01081359f, 0.02596621f, -0.08805514f, -0.03075086f, 0.07243211f, -0.08545302f, 0.12744658f, 
    -0.03588362f, 0.11702584f, -0.19952086f, -0.26447639f, 0.05774071f, 0.00967688f, -0.12925747f, 0.06852926f, 
    0.06584241f, -0.04148535f, 0.03714456f, 0.13895978f, 0.00734686f, 0.03579918f, -0.18324965f, 0.07019949f, 
    -0.03086256f, -0.03773639f, -0.10296352f, 0.00244064f, 0.07830971f, 0.00066244f, -0.08207007f, 0.07960660f, 
    -0.18711653f, -0.18502198f, 0.17617857f, -0.11821742f, -0.00908575f, -0.03344074f, -0.07358252f, 0.11599381f, 
    -0.04963054f, 0.07955869f, 0.06986274f, -0.03189695f, 0.00682955f, -0.04577479f, -0.29635888f, 0.08711100f, 
    0.09715463f, 0.02071254f, -0.01256137f, -0.00343319f, 0.02440024f, 0.01530918f, 0.13528472f, 0.00409358f, 
    0.19593096f, 0.01632803f, -0.02658182f, 0.06642994f, 0.05996136f, -0.02265606f, -0.04029056f, -0.12968883f, 
    -0.03655237f, 0.02689372f, 0.00003755f, 0.10141682f, 0.01914397f, -0.17152429f, -0.22109397f, -0.02048950f, 
    0.04130531f, 0.04657037f, 0.00723413f, -0.03543324f, 0.05952276f, -0.02989786f, -0.06096574f, -0.01632031f, 
    0.13221778f, -0.12867036f, 0.11742864f, 0.06187434f, -0.13801028f, -0.03613147f, 0.01773338f, -0.04128548f, 
    -0.01431118f, 0.01835374f, -0.12859055f, -0.01659798f, -0.09624173f, 0.05479013f, 0.09891263f, 0.14789097f, 
    -0.00305480f, 0.03784483f, -0.06731335f, -0.06860696f, 0.02668792f, -0.00841237f, -0.00737584f, 0.03442916f, 
    -0.03001088f, -0.14710422f, -0.16113736f, -0.00547450f, 0.10371263f, 0.06379283f, -0.04693893f, -0.03722949f, 
    0.05481391f, -0.00564810f, 0.08515081f, -0.01573874f, 0.10324515f, 0.02517900f, -0.32660231f, 0.00512403f, 
    0.03008809f, -0.00526335f, -0.08270227f, 0.00404945f, -0.07867078f, 0.08398786f, 0.17985015f, 0.07504021f, 
    -0.10238356f, -0.03886493f, 0.01049485f, -0.09008944f, -0.00422231f, 0.05207159f, -0.12813826f, 0.04138271f, 
    0.09380285f, -0.11680747f, 0.02661641f, -0.06340519f, -0.02305807f, -0.12994580f, -0.19997594f, 0.15623301f, 
    0.14282766f, -0.01597266f, 0.04796761f, 0.01093335f, 0.00540521f, -0.07850385f, 0.05477212f, -0.02533006f, 
    0.12508719f, -0.07890750f, 0.05994863f, 0.09507464f, 0.02134074f, 0.06859969f, -0.06806345f, -0.03415170f, 
    0.05887539f, -0.04718356f, -0.00257926f, 0.02145201f, 0.04191279f, 0.03581159f, -0.00015164f, 0.10428270f, 
    0.02729801f, 0.01936602f, -0.03682848f, 0.01172407f, 0.05215725f, 0.03529392f, 0.01179101f, -0.00118829f, 
    -0.22771710f, -0.08571827f, -0.17304863f, -0.21313712f, -0.08102664f, -0.02100644f, 0.00080794f, -0.08925430f, 
    0.02141762f, 0.07599828f, 0.02554785f, -0.02891734f, -0.08630856f, -0.00094918f, 0.03180746f, 0.16182061f, 
    0.15009108f, 0.09787437f, -0.09114397f, -0.08191967f, -0.07928929f, -0.00273791f, -0.03395912f, 0.03190563f, 
    -0.09992801f, 0.03336057f, 0.17730491f, 0.02688940f, -0.08238425f, -0.02538541f, -0.05909767f, 0.06334645f, 
    -0.04082976f, 0.05773807f, -0.00664062f, -0.06081964f, 0.12249465f, 0.06002362f, -0.08424190f, 0.13279516f, 
    -0.00216469f, -0.12496462f, -0.07057527f, -0.07270858f, -0.05423731f, -0.02128061f, 0.04901357f, -0.00159711f, 
    -0.03806903f, 0.06419744f, 0.05573136f, 0.00732600f, -0.11014616f, 0.04673827f, -0.03197745f, -0.06558562f, 
    -0.03599878f, 0.16316515f, -0.12078617f, 0.08035206f, 0.05988057f, -0.00012528f, 0.01985696f, 0.15174031f, 
    -0.00282863f, -0.04169741f, 0.01334699f, -0.01125822f, 0.04533805f, 0.07987823f, -0.04651286f, -0.10301539f, 
    -0.01381484f, -0.24242005f, -0.04060099f, -0.16129886f, -0.04725601f, -0.02136710f, 0.14148508f, 0.01576442f, 
    -0.04173521f, 0.00992917f, 0.02278149f, -0.10935928f, -0.20991386f, 0.05719775f, -0.05443747f, -0.23773271f, 
    0.08814349f, -0.03077270f, 0.02173774f, -0.07535863f, 0.04834165f, 0.08544869f, -0.05437005f, -0.10845952f, 
    0.06694175f, -0.09200260f, -0.02426218f, -0.09148850f, 0.06449327f, -0.08708046f, 0.07157905f, 0.07561561f, 
    0.09627549f, 0.07238197f, -0.02211067f, -0.07398232f, 0.06896231f, -0.03287471f, 0.07065307f, -0.03225651f, 
    0.00266517f, -0.07683128f, 0.08628368f, 0.00758318f, -0.04453321f, -0.01844278f, -0.03973452f, 0.07125102f, 
    -0.11817402f, -0.05394135f, 0.04204016f, 0.14559823f, 0.04500158f, 0.00350045f, 0.01646062f, -0.02989211f, 
    0.08518327f, 0.00952082f, 0.14900914f, 0.09037860f, 0.20618160f, 0.20529303f, -0.15767787f, -0.10344400f, 
    0.07570080f, 0.03930518f, -0.01192440f, 0.02770580f, 0.00064262f, 0.00670385f, 0.10557981f, 0.07588832f, 
    -0.01762804f, 0.16483007f, -0.07287822f, -0.09287220f, 0.02607098f, -0.12100043f, -0.07980817f, 0.02252894f, 
    0.04458603f, -0.03606744f, -0.22857119f, 0.11355376f, 0.10558847f, 0.01797538f, 0.08436662f, 0.09720148f, 
    -0.10099321f, -0.00016748f, -0.02576925f, -0.11267449f, 0.02048620f, -0.09332545f, 0.04699053f, 0.03374159f, 
    -0.01937868f, 0.09055120f, -0.05523894f, -0.02959345f, -0.01769748f, -0.05365130f, -0.02185483f, 0.01486071f, 
    -0.06272157f, -0.01386016f, -0.03779595f, 0.14755426f, 0.34695005f, -0.29521564f, -0.34322298f, -0.07235640f, 
    -0.08007796f, -0.03210997f, 0.06398165f, -0.00043088f, 0.06645353f, -0.02698390f, -0.00524371f, -0.17386730f, 
    0.10427175f, -0.35556495f, -0.07239857f, -0.04059592f, 0.01652463f, 0.00603034f, -0.03081369f, 0.10793864f, 
    0.03226056f, -0.07647518f, 0.07427595f, -0.09303064f, 0.30031791f, 0.15861188f, -0.08949324f, 0.21098915f, 
    -0.03169053f, -0.03115402f, -0.10764112f, -0.03861318f, -0.01862688f, -0.02570582f, 0.07035278f, 0.14983454f, 
    0.11377373f, 0.15451726f, 0.14593633f, 0.01798455f, -0.05571359f, 0.02301619f, -0.00484000f, -0.01347256f, 
    0.08666763f, 0.02863075f, -0.03880585f, -0.10688201f, -0.21555176f, 0.05603266f, 0.12949836f, -0.22535260f, 
    -0.10909216f, 0.00104860f, 0.10496470f, 0.14250530f, 0.12217190f, -0.09897693f, 0.01100454f, 0.04644702f, 
    -0.20005731f, 0.12844430f, -0.19742639f, -0.01825554f, 0.07760828f, -0.00639392f, 0.02594835f, 0.01693752f, 
    0.02174024f, 0.04987336f, -0.00867514f, -0.00058020f, -0.06311124f, -0.08568831f, -0.06171358f, 0.13899077f, 
    -0.10782969f, 0.11951837f, -0.03221152f, -0.04549706f, 0.02872440f, 0.04525082f, 0.07982241f, -0.17699793f, 
    0.16810934f, -0.16731659f, 0.23570913f, -0.03611267f, -0.03054284f, -0.10615379f, -0.04783960f, -0.12211637f, 
    0.05742808f, 0.07985574f, -0.00177738f, 0.04328484f, -0.15424068f, 0.05731345f, -0.02031105f, -0.10104210f, 
    0.00180184f, 0.06061063f, -0.06654937f, -0.04884350f, 0.06145763f, -0.02163874f, -0.06577467f, 0.02895125f, 
    -0.10077526f, 0.09847079f, 0.03074360f, 0.03411359f, 0.09838896f, 0.05155218f, -0.00362491f, -0.02529895f, 
    0.10258394f, -0.02677136f, 0.08262348f, 0.04431580f, 0.09761310f, -0.08217528f, -0.17810033f, 0.08605058f, 
    0.02899800f, 0.11951323f, 0.09280555f, -0.03370216f, -0.02365424f, -0.04397627f, -0.04523281f, 0.03321265f, 
    -0.14340384f, 0.25364456f, -0.07408115f, -0.22836664f, 0.02551548f, 0.00242173f, 0.07961664f, -0.17034352f, 
    -0.05614870f, 0.07144452f, -0.01175844f, 0.03968050f, -0.24599640f, -0.00838078f, 0.14539863f, 0.12083314f, 
    0.08604810f, 0.00801735f, 0.05070695f, -0.09273036f, 0.07216848f, 0.03637929f, 0.05565780f, 0.12014376f, 
    -0.09506033f, -0.36416757f, 0.01714814f, -0.02751886f, 0.10665692f, 0.03712052f, -0.09480707f, 0.04129314f, 
    -0.07585829f, -0.05451402f, 0.03321671f, -0.01246535f, 0.15268630f, -0.01293007f, 0.06077264f, -0.03632866f, 
    -0.07479814f, -0.01370380f, 0.10603943f, -0.07463082f, -0.04024902f, 0.03306313f, 0.11703048f, 0.03909650f, 
    0.28711301f, -0.09268729f, -0.01670956f, 0.23429255f, -0.12342675f, 0.01856283f, -0.03983659f, -0.02642408f, 
    0.06386985f, -0.04235533f, -0.00489415f, -0.03081221f, -0.24454241f, -0.17060009f, -0.04016273f, 0.17606099f, 
    0.01809546f, 0.04924376f, -0.05432842f, -0.05391793f, 0.02990707f, 0.10949447f, 0.03673680f, 0.07060480f, 
    -0.07344324f, 0.28073406f, -0.23529553f, -0.34249595f, -0.01575887f, 0.02111016f, 0.01489349f, 0.02768377f, 
    0.06932218f, 0.07609995f, -0.04783794f, 0.08082423f, -0.13335851f, -0.09023447f, -0.03812480f, 0.02363398f, 
    0.03371363f, 0.06160402f, 0.01123398f, -0.07981263f, 0.08737375f, 0.01730199f, 0.02668556f, -0.11216744f, 
    -0.22273499f, -0.24517053f, 0.04073989f, 0.06374230f, 0.02059950f, 0.02290881f, 0.13022690f, 0.06119873f, 
    -0.00913843f, -0.13424169f, 0.10998788f, -0.14908147f, -0.00024616f, -0.13075480f, -0.28136474f, 0.21150655f, 
    -0.09060292f, 0.01150240f, 0.06835494f, -0.04015886f, -0.00394259f, -0.00014901f, -0.13088495f, -0.08142493f, 
    0.21508418f, 0.13773009f, -0.04806963f, -0.10046945f, 0.01647195f, 0.01080531f, 0.04547881f, -0.10750666f, 
    0.04433567f, 0.07457095f, 0.01173001f, 0.13575438f, -0.22776154f, 0.11364526f, -0.01639664f, 0.15873051f, 
    0.00460731f, 0.03495724f, -0.08367713f, 0.10727017f, -0.05900928f, 0.05065922f, -0.01858874f, 0.04786899f, 
    0.00451226f, 0.04300323f, -0.00972907f, -0.33065924f, 0.00036038f, 0.08273415f, -0.03085804f, 0.01218480f, 
    0.02626975f, 0.01561867f, -0.04222508f, -0.02929956f, 0.45349279f, -0.49796733f, 0.08969238f, 0.07174566f, 
    0.04025387f, -0.04729288f, 0.08136801f, 0.10665510f, 0.00604294f, -0.03516795f, 0.03572866f, -0.10164246f, 
    -0.19497903f, -0.34362984f, -0.14310123f, 0.10982092f, -0.09510462f, -0.09982985f, 0.02199253f, 0.04576866f, 
    0.01612728f, -0.08973783f, 0.14094101f, -0.02351627f, 0.04902514f, -0.10002267f, -0.17757028f, 0.10583533f, 
    -0.02046202f, 0.01532174f, -0.13016480f, 0.06783405f, 0.00553805f, -0.02134070f, 0.15905267f, -0.00043105f, 
    -0.02884296f, 0.19527997f, 0.02429044f, 0.01900984f, 0.11401926f, -0.05854405f, 0.00733185f, -0.01847965f, 
    -0.04356370f, -0.01434782f, 0.03321101f, 0.00567500f, -0.57757562f, 0.13867192f, 0.01295065f, -0.12431989f, 
    -0.01291386f, 0.11041009f, 0.10429192f, -0.00631926f, 0.06768980f, -0.00558759f, 0.07528247f, 0.06503178f, 
    -0.04441461f, 0.17555960f, -0.10308761f, 0.23488417f, 0.02552870f, 0.11045092f, -0.14421467f, 0.06989464f, 
    -0.07496893f, -0.01938972f, 0.02721443f, 0.02271627f, -0.26194525f, 0.03035406f, 0.21247567f, -0.08692408f, 
    0.06239300f, 0.02846969f, 0.04468122f, 0.00330114f, 0.00763554f, 0.08815338f, -0.05824319f, -0.03012155f, 
    0.06523494f, -0.00357104f, -0.08236551f, -0.01371304f, -0.10987944f, -0.05602148f, 0.07288958f, -0.05971270f, 
    0.07394136f, -0.08157714f, -0.09835859f, -0.12593731f, -0.12259681f, 0.09745014f, -0.09170064f, -0.00736178f, 
    0.00338373f, 0.04581494f, -0.01836298f, 0.07627282f, 0.03322652f, 0.02330520f, 0.08808126f, -0.01857814f, 
    -0.09787607f, 0.00391432f, 0.01255343f, -0.08927101f, -0.02142266f, -0.05481329f, 0.01297641f, 0.04853606f, 
    -0.00767280f, -0.15457377f, -0.00227957f, 0.01154222f, -0.00516745f, -0.31325981f, 0.01385522f, -0.05634677f, 
    -0.02827912f, -0.02134052f, -0.10336671f, 0.00900166f, -0.00243740f, -0.01698187f, 0.15454549f, -0.02583193f, 
    -0.05024482f, 0.08696131f, 0.27516273f, -0.06425776f, -0.04785935f, 0.00294084f, -0.06883361f, 0.00955210f, 
    -0.01843049f, 0.09662987f, -0.05457553f, -0.01273693f, 0.01319524f, -0.00161922f, -0.18036464f, 0.09755222f, 
    -0.01088319f, 0.07109469f, 0.16496505f, -0.13944048f, -0.06846637f, 0.04227893f, 0.01994760f, -0.05224584f, 
    0.18070695f, -0.07835083f, -0.01038787f, 0.22468375f, -0.11756708f, 0.07386210f, 0.00756430f, -0.02844685f, 
    0.04256596f, 0.04648505f, -0.05829249f, -0.05806208f, 0.10654780f, -0.10072293f, 0.13246326f, 0.03590710f, 
    -0.00462993f, 0.05351364f, -0.10696384f, 0.02723373f, -0.16730945f, -0.03757962f, -0.03305679f, 0.00948926f, 
    0.09897348f, -0.13306449f, 0.00634630f, -0.03451468f, 0.02007974f, 0.01065911f, 0.00354158f, -0.04336029f, 
    0.11723131f, -0.02078966f, -0.11472780f, -0.09020292f, 0.09137803f, -0.24901511f, 0.07983413f, 0.00576045f, 
    -0.09857309f, 0.07164472f, -0.11767830f, -0.06551822f, -0.04353565f, 0.02953472f, 0.04594588f, 0.00737101f, 
    -0.22919925f, 0.09368126f, -0.20771447f, 0.24959578f, 0.06152477f, -0.06876112f, -0.03689947f, -0.02023862f, 
    -0.02485068f, 0.09224274f, 0.06808075f, -0.08058476f, 0.23353283f, -0.37095660f, 0.07454809f, -0.03537361f, 
    -0.11845247f, -0.02175406f, 0.14941677f, 0.07421206f, 0.12508337f, -0.01471555f, 0.13586853f, 0.03775991f, 
    -0.04385420f, -0.00299182f, 0.01328726f, -0.15269241f, 0.03449333f, 0.11069886f, 0.04852728f, -0.08803215f, 
    -0.08884966f, -0.05380234f, -0.11755536f, 0.00559594f, 0.03382707f, -0.08006220f, 0.18252067f, 0.03468129f, 
    -0.06422662f, -0.07296852f, 0.04333593f, -0.21667543f, -0.08801377f, 0.01705969f, -0.03285024f, 0.08837499f, 
    -0.10467014f, -0.15957423f, 0.02356518f, -0.12142590f, 0.00376701f, 0.12724584f, 0.01140225f, 0.00499293f, 
    -0.13993791f, 0.05677859f, 0.00763525f, 0.15217555f, -0.32315242f, 0.03782119f, -0.11225677f, -0.28339165f, 
    0.00076792f, 0.00724270f, -0.03099283f, -0.01484102f, -0.00480392f, -0.05867474f, -0.05945221f, 0.03000940f, 
    0.14038078f, -0.17657219f, 0.09545974f, 0.05960363f, -0.03812741f, -0.07980094f, 0.14168623f, -0.11190730f, 
    -0.02977034f, 0.04690904f, -0.08682629f, 0.15554707f, -0.07742605f, 0.17494556f, -0.06788953f, -0.08886135f, 
    0.07275350f, 0.02794941f, 0.01256264f, -0.06818949f, -0.10767511f, -0.09400579f, -0.04184227f, -0.10081854f, 
    -0.05257395f, -0.01556680f, -0.05366499f, -0.05643020f, -0.06056756f, 0.07303882f, 0.04453456f, 0.05832062f, 
    -0.01670597f, -0.05736724f, -0.16978683f, -0.02662620f, -0.10886494f, 0.18426564f, -0.10535706f, -0.32841209f, 
    0.09933709f, -0.07223984f, -0.00729373f, 0.09925429f, -0.03865461f, 0.07131191f, 0.05513225f, -0.13245991f, 
    0.06784166f, 0.00121212f, 0.07102349f, 0.00719302f, 0.12724364f, -0.00460552f, -0.02336890f, -0.03900268f, 
    0.04290625f, -0.05107118f, -0.01903449f, -0.01374195f, 0.06487723f, -0.19083598f, 0.15024333f, -0.13920203f, 
    -0.05254668f, 0.06067510f, 0.05648809f, 0.01812169f, 0.10326224f, 0.14175802f, 0.02242599f, 0.01163120f, 
    0.23345405f, 0.14822528f, -0.17852397f, -0.01380076f, 0.03536585f, -0.03483330f, 0.00513665f, -0.01903761f, 
    -0.06409170f, 0.02558110f, 0.13456719f, -0.03698899f, -0.22375979f, 0.15394279f, -0.12247017f, -0.12043805f, 
    0.02019821f, -0.00030713f, -0.12942885f, -0.09332151f, -0.11221161f, -0.04788808f, 0.02669805f, 0.03936424f, 
    -0.04854784f, 0.06628942f, -0.20713769f, -0.01732095f, -0.09164740f, 0.00707013f, 0.11031085f, 0.04181748f, 
    -0.04681794f, 0.05082366f, -0.00271216f, 0.01785980f, -0.09233939f, -0.11754603f, -0.22159004f, 0.03104195f, 
    0.04693979f, -0.04030114f, 0.01259656f, -0.04541998f, 0.10884627f, -0.10764002f, 0.08226503f, 0.06955996f, 
    0.16377150f, -0.25136995f, 0.14387341f, 0.10987829f, -0.05927295f, 0.12513839f, -0.03978409f, -0.01548097f, 
    -0.01205564f, 0.03686236f, 0.07848581f, -0.01684539f, 0.54502982f, 0.01493263f, -0.21312028f, 0.00111962f, 
    0.08363691f, -0.03308919f, -0.00553815f, 0.04440479f, -0.15337537f, -0.04043924f, 0.09572367f, -0.02453024f, 
    -0.06076431f, 0.09209718f, -0.17149581f, -0.09256481f, 0.12801982f, -0.08267064f, 0.03810306f, -0.08916554f, 
    -0.11254462f, -0.10536572f, -0.14518204f, -0.32795873f, 0.24555382f, 0.15349591f, 0.25396988f, 0.02189736f, 
    0.02004824f, -0.03928316f, 0.07690392f, -0.05301248f, 0.03090782f, 0.11544371f, 0.00436909f, 0.04917686f, 
    -0.06770831f, 0.04954786f, 0.07132616f, -0.21037365f, 0.05188175f, 0.02853692f, -0.07871329f, 0.13629472f, 
    0.06503356f, -0.07981940f, 0.06693371f, 0.09245792f, 0.17771587f, -0.08278846f, -0.10020995f, 0.06909039f, 
    0.01365961f, 0.02289950f, 0.07670479f, 0.01933860f, -0.16546968f, 0.07643230f, 0.06013812f, 0.02047680f, 
    -0.16652964f, -0.02067101f, 0.19611472f, 0.06677353f, 0.13454928f, 0.08822262f, 0.03533241f, 0.01638960f, 
    0.09220586f, 0.05754070f, 0.04247924f, 0.17653571f, 0.05151202f, 0.05775459f, -0.11565465f, -0.08430366f, 
    -0.03242980f, 0.08138562f, 0.04784923f, 0.01479569f, 0.08553153f, 0.11044834f, 0.03123187f, 0.07948946f, 
    0.25169191f, -0.01201310f, -0.01689040f, -0.05997862f, -0.13015018f, -0.17906788f, -0.00574357f, -0.06372309f, 
    -0.08800078f, 0.00250571f, -0.13619772f, -0.04114185f, 0.09938278f, 0.00339303f, 0.06627117f, -0.07214465f, 
    0.00961184f, -0.07016995f, 0.08922858f, 0.10197061f, 0.02939549f, 0.03219209f, 0.01326090f, -0.02001891f, 
    -0.21870947f, -0.04365877f, 0.11530752f, 0.05144072f, 0.11448941f, 0.02060138f, -0.02307090f, 0.00523917f, 
    0.06184884f, 0.07472388f, 0.08781590f, 0.20973952f, 0.02229020f, 0.00503910f, -0.00684159f, 0.00095763f, 
    -0.04811838f, -0.02289408f, 0.00844295f, -0.09971683f, -0.09568474f, 0.06008033f, -0.07602913f, 0.00412264f, 
    -0.36043558f, -0.21210800f, -0.07786730f, -0.21922642f, 0.04544743f, 0.06546342f, -0.06847918f, -0.03711706f, 
    -0.02235069f, -0.07961617f, -0.04378188f, -0.08215082f, 0.12600680f, 0.15528895f, 0.03176193f, -0.03134684f, 
    0.19369967f, 0.13630909f, 0.09309936f, -0.01002454f, -0.09745910f, -0.02311063f, 0.01420561f, 0.10677399f, 
    0.22248444f, -0.07375058f, -0.11644784f, -0.10388957f, -0.14828302f, 0.06711823f, 0.00740410f, 0.08891481f, 
    0.01459447f, 0.12196139f, -0.01594442f, -0.03299559f, -0.31743583f, -0.20674126f, -0.21786425f, -0.24292041f, 
    0.09499628f, 0.02117798f, -0.09020519f, -0.06224941f, -0.09796689f, -0.08694291f, -0.06824212f, 0.07223153f, 
    -0.17683725f, -0.27020013f, -0.19427888f, -0.07382806f, -0.02910877f, 0.15060577f, 0.05604387f, -0.05364388f, 
    0.00548138f, -0.05004578f, -0.14537048f, 0.06940138f, -0.28633747f, -0.07591576f, -0.09426758f, -0.06182212f, 
    0.07338723f, -0.03724612f, -0.08291304f, 0.09778500f, 0.06031739f, 0.09406292f, 0.05302237f, 0.03756550f, 
    0.07148957f, -0.05373498f, -0.08814189f, 0.07504793f, 0.03631249f, -0.13110958f, 0.07037438f, 0.00621532f, 
    0.09423841f, 0.05940120f, 0.00409704f, 0.10038154f, 0.08668583f, -0.04060575f, 0.00900514f, 0.15264329f, 
    -0.10660610f, -0.01998645f, -0.01503179f, -0.02405758f, 0.04113459f, -0.04353458f, -0.00879210f, -0.17625952f, 
    0.03700452f, 0.09015709f, 0.05676198f, -0.11841267f, -0.00460431f, -0.03000840f, 0.05245622f, -0.10280798f, 
    0.05245024f, 0.08514629f, 0.10680439f, 0.00284235f, -0.05465018f, 0.02450432f, -0.03923113f, 0.16515680f, 
    0.10206174f, -0.00396634f, -0.03017310f, -0.12005457f, -0.03465595f, -0.12534326f, -0.12013283f, -0.18053895f, 
    0.21579707f, -0.02033681f, 0.04360136f, -0.08889773f, -0.00299491f, -0.03300250f, -0.02020553f, 0.02587730f, 
    0.07179558f, 0.06724231f, -0.04131984f, -0.01414169f, 0.14061631f, -0.24440365f, -0.10835705f, 0.06720575f, 
    0.03638174f, 0.12801848f, 0.17575856f, 0.02779456f, 0.10573578f, -0.00411654f, -0.14927949f, -0.05061385f, 
    0.09761544f, 0.03676228f, -0.08865137f, -0.19665356f, -0.08376998f, -0.06418399f, -0.10023194f, -0.01391879f, 
    0.10641928f, -0.09740327f, 0.01459093f, -0.05027044f, 0.18113875f, 0.11004845f, 0.03638021f, -0.07681005f, 
    -0.08358070f, -0.04179464f, 0.08391023f, -0.15019034f, -0.00748692f, -0.12066071f, -0.00499787f, 0.07813254f, 
    0.09884072f, 0.08222440f, -0.04514172f, -0.01788906f, -0.02172190f, 0.02438403f, 0.01277685f, -0.04424752f, 
    0.01167225f, 0.11114538f, -0.04937479f, 0.09141031f, 0.17523625f, 0.10336075f, -0.12228238f, 0.02941645f, 
    -0.03535919f, -0.03234554f, 0.07809772f, -0.05987328f, -0.11303052f, -0.07907048f, -0.02915358f, 0.04586543f, 
    -0.11793463f, -0.06256343f, 0.01972049f, 0.03975761f, 0.01831760f, -0.06423949f, 0.01430276f, -0.01706252f, 
    -0.00964330f, 0.09977102f, -0.01318635f, 0.08160221f, 0.15245773f, -0.07361315f, -0.02379418f, -0.05308906f, 
    -0.06835145f, 0.02912389f, -0.01030624f, -0.04217735f, 0.08580133f, -0.02253753f, 0.01989962f, -0.12239386f, 
    -0.57906175f, -0.25754187f, -0.08291160f, -0.19990794f, 0.09752912f, -0.02704007f, -0.05132284f, -0.03726846f, 
    0.02106645f, -0.04405334f, 0.05051554f, -0.04766186f, -0.24035174f, -0.03004736f, -0.01549776f, 0.06888095f, 
    -0.00398505f, 0.02795015f, -0.12136543f, -0.10080196f, -0.03199785f, -0.00782688f, 0.07431085f, 0.01665220f, 
    0.11252054f, 0.12213704f, 0.09670810f, -0.20730796f, -0.03306186f, 0.03286424f, 0.07441401f, -0.01340977f, 
    0.06844009f, 0.01379844f, -0.03187952f, -0.07489011f, 0.18440811f, 0.03505038f, -0.00711861f, -0.01888051f, 
    -0.12966193f, -0.07578317f, 0.03891426f, -0.06966852f, 0.10677024f, 0.00825028f, -0.04917846f, -0.11047287f, 
    -0.37906846f, -0.36826286f, -0.09917240f, 0.05860806f, 0.05869839f, 0.05676444f, 0.02071358f, 0.01812681f, 
    0.00336701f, -0.09156683f, -0.02678115f, 0.13169728f, -0.28166398f, -0.09563085f, 0.03740777f, 0.14270671f, 
    0.06675435f, -0.01387309f, 0.08617903f, 0.04977541f, 0.17142190f, 0.07353908f, -0.02063116f, 0.13754743f, 
    -0.23196661f, -0.07842847f, 0.11005630f, 0.06257209f, -0.15144464f, -0.01600505f, 0.01279117f, 0.03902555f, 
    0.05354033f, 0.08643015f, 0.00154036f, -0.15440120f, -0.52061999f, -0.26827493f, -0.21935609f, -0.03922834f, 
    0.17516668f, -0.12575138f, -0.15675434f, -0.19038220f, -0.00014881f, -0.07026638f, -0.00015026f, -0.05949969f, 
    0.07307447f, 0.24187407f, -0.06425878f, -0.06185586f, -0.08486924f, -0.01412504f, 0.02782890f, 0.17426361f, 
    0.01730175f, 0.06758603f, 0.13428546f, 0.10671432f, -0.44889230f, -0.02039543f, -0.05318425f, -0.09803691f, 
    0.13329516f, -0.03371361f, -0.01774010f, 0.01282756f, -0.06264360f, -0.06432553f, 0.03973660f, -0.05469939f, 
    -0.45289588f, 0.06409463f, -0.11730251f, -0.07053333f, 0.17339115f, -0.09727370f, -0.11819205f, -0.03221276f, 
    -0.00525152f, -0.06154905f, 0.01626746f, -0.08494919f, -0.05163128f, 0.15697548f, 0.02856900f, 0.00237619f, 
    0.02125137f, 0.05511224f, 0.04838529f, -0.07064009f, 0.03241016f, -0.06828161f, -0.07980264f, 0.14596590f, 
    0.00908061f, -0.12704088f, 0.07932939f, -0.02917419f, 0.18669115f, 0.08822156f, -0.03394385f, 0.04818992f, 
    -0.07555331f, -0.01549513f, -0.07891056f, -0.00383832f, -0.06727258f, 0.04023650f, 0.00469953f, 0.01698964f, 
    0.01289199f, 0.13978863f, -0.02411440f, 0.04576497f, -0.00965362f, -0.10796752f, 0.01483973f, -0.02300316f, 
    0.04461360f, 0.09148675f, 0.05684592f, -0.15149555f, 0.05775165f, 0.12962221f, 0.00716654f, -0.04422047f, 
    -0.09621054f, 0.07192588f, 0.14241391f, 0.05344182f, -0.40652299f, -0.01011914f, 0.08187518f, 0.12249511f, 
    0.11880918f, 0.06578174f, 0.01858743f, 0.02821241f, 0.07133720f, 0.11101725f, 0.04105304f, 0.05229371f, 
    -0.13551944f, -0.16839358f, -0.08944904f, 0.00975222f, 0.00642860f, 0.04744850f, -0.03308139f, -0.03767773f, 
    0.05327240f, 0.07111447f, 0.09576222f, 0.00149193f, -0.17203584f, -0.02315885f, 0.08488473f, -0.08657848f, 
    0.09046777f, 0.04596008f, 0.08898669f, 0.02280774f, 0.07000761f, -0.02807212f, -0.06049642f, 0.08699790f, 
    0.32622480f, 0.00946401f, -0.04165095f, 0.06442093f, 0.00262679f, -0.04360305f, 0.03068845f, 0.10363719f, 
    0.04518037f, -0.04609624f, 0.00385574f, 0.05310366f, 0.12262315f, 0.03208135f, 0.01641556f, 0.05159529f, 
    0.04500296f, 0.12290212f, -0.05872094f, 0.01987794f, -0.09502462f, -0.00016328f, -0.07154071f, -0.10414381f, 
    -0.41344151f, -0.05125714f, 0.15034857f, -0.04185005f, 0.05101670f, 0.05460694f, -0.05536409f, 0.01970047f, 
    0.13606086f, 0.04633491f, 0.00309759f, 0.04274916f, -0.20272338f, 0.02850062f, -0.01469534f, 0.10002439f, 
    0.15396179f, 0.02103631f, -0.07092976f, 0.04419942f, 0.04588563f, 0.01293773f, -0.06754390f, 0.05997710f, 
    0.04209190f, -0.01061284f, -0.08021309f, 0.04618302f, -0.02124353f, -0.04899223f, -0.09855314f, -0.14285009f, 
    -0.07384457f, -0.04339998f, -0.06279110f, -0.21181180f, -0.29115313f, -0.08579147f, 0.00863100f, -0.19358836f, 
    0.03851784f, 0.06195835f, 0.03422311f, 0.02859129f, 0.06673209f, 0.00616196f, 0.02198105f, -0.07308013f, 
    0.04549100f, 0.02743683f, -0.08271588f, 0.00554737f, -0.00934839f, -0.00074389f, -0.03921613f, 0.12313037f, 
    0.10729292f, 0.07090124f, 0.14226934f, -0.00460698f, -0.34942809f, -0.23933211f, -0.04104584f, -0.18213329f, 
    0.10979966f, 0.03832398f, -0.02856308f, 0.04175684f, 0.13047704f, 0.07968845f, 0.11743680f, 0.10411905f, 
    0.34883326f, 0.09668499f, -0.07815888f, -0.07067262f, -0.04118272f, -0.08658960f, 0.12214898f, 0.01369126f, 
    -0.05941761f, 0.07239159f, 0.07735812f, 0.07026695f, -0.38726610f, -0.19069296f, -0.14004292f, -0.26938349f, 
    0.02137129f, 0.05948301f, -0.08299218f, -0.06576681f, 0.09444573f, -0.00373762f, -0.06550588f, 0.05843352f, 
    0.23360983f, 0.07748220f, -0.00085033f, 0.04301164f, -0.08311142f, 0.02358277f, 0.09798621f, 0.14833038f, 
    0.02285976f, 0.10399800f, 0.03802446f, 0.04626454f, -0.10690992f, 0.15651783f, -0.14703463f, 0.03838080f, 
    -0.09838933f, -0.08975970f, -0.02742846f, -0.05755037f, -0.05995867f, -0.08278134f, 0.06557416f, -0.21543510f, 
    0.09505937f, -0.02419478f, 0.19841161f, 0.08191212f, 0.05483514f, -0.00599492f, 0.02626204f, 0.07855312f, 
    0.15367316f, 0.10019606f, -0.07588436f, 0.10791602f, -0.16978985f, -0.22310475f, -0.08672816f, 0.01442575f, 
    -0.06154355f, -0.19516315f, 0.04618815f, 0.01989327f, 0.00580905f, 0.10491294f, -0.01214345f, 0.10887711f, 
    0.15454754f, -0.13427733f, -0.01396238f, 0.14259319f, 0.04197720f, 0.09343085f, -0.05146455f, -0.02476278f, 
    0.05806412f, 0.12989116f, -0.04245744f, -0.05601218f, 0.20556456f, 0.04548328f, -0.02189608f, -0.00454727f, 
    0.06948595f, 0.11284472f, 0.09359576f, -0.06004687f, 0.15492263f, 0.04203561f, -0.05196813f, -0.02545066f, 
    -0.33843210f, 0.03616634f, -0.17522755f, -0.10293860f, 0.10951800f, -0.04526361f, 0.04818144f, 0.00802025f, 
    -0.02669864f, 0.07916511f, -0.09185028f, 0.07595699f, 0.16568311f, -0.01283062f, -0.04933801f, -0.02411688f, 
    -0.06892478f, -0.05791108f, -0.01016200f, 0.07525909f, 0.06400327f, -0.00952505f, 0.07544294f, -0.11612766f, 
    -0.42461368f, -0.15630636f, -0.18850964f, -0.13946936f, -0.04674786f, -0.12335427f, -0.02387242f, -0.03250861f, 
    -0.03929711f, 0.06508568f, 0.03671749f, -0.02748822f, -0.16091312f, -0.00464692f, 0.07546480f, 0.04645383f, 
    0.07522275f, -0.02690746f, -0.04212312f, 0.08636551f, 0.06247761f, 0.11115956f, -0.00909321f, 0.00776327f, 
    -0.41953325f, -0.29266474f, 0.05412327f, -0.08661843f, -0.00949864f, 0.02935096f, 0.00481658f, -0.03953926f, 
    -0.03682761f, -0.09145901f, -0.19193502f, 0.01867648f, 0.08154438f, 0.07269292f, -0.00763195f, 0.02946597f, 
    0.09867350f, 0.08257706f, -0.02262246f, 0.06232924f, 0.04443453f, 0.04405796f, 0.11715780f, -0.05361253f, 
    -0.11315994f, 0.08449823f, 0.09190250f, -0.02328712f, 0.06685288f, -0.12275668f, -0.04403319f, 0.05353279f, 
    0.02443185f, 0.04690092f, -0.02241869f, -0.10890841f, -0.32508606f, 0.08872242f, 0.20286646f, 0.07913815f, 
    0.02007527f, 0.01394963f, 0.03776547f, 0.10233431f, -0.10955124f, 0.02196289f, 0.05689960f, 0.08530615f, 
    -0.13907756f, -0.16821800f, 0.08044515f, -0.01378530f, -0.01322972f, 0.05591783f, 0.06008844f, -0.00786661f, 
    -0.12122213f, 0.02760671f, 0.06569218f, -0.05911787f, 0.12869234f, -0.08764796f, 0.01100029f, -0.02721014f, 
    -0.00990190f, -0.08662879f, -0.08443863f, 0.04785934f, -0.06647397f, -0.05326694f, 0.11834455f, 0.02110155f, 
    0.03479199f, -0.01596406f, 0.09551759f, -0.01062937f, 0.09240779f, 0.01700773f, -0.13529314f, 0.09081765f, 
    -0.03752613f, -0.03519142f, -0.03813681f, -0.02299552f, 0.02331971f, -0.15169877f, -0.03438365f, 0.00863329f, 
    -0.07381187f, -0.04248285f, -0.10634298f, 0.10702822f, 0.00686082f, 0.03072385f, -0.00289494f, -0.07863723f, 
    -0.19388241f, -0.33694568f, -0.01164256f, -0.32829088f, 0.06937982f, 0.04578009f, 0.01707161f, -0.00000260f, 
    0.04078527f, -0.03262558f, -0.02012046f, 0.00858066f, -0.14689629f, 0.26305431f, -0.17469315f, -0.17538270f, 
    -0.00517324f, -0.06427983f, 0.00983761f, -0.04134653f, -0.10272133f, -0.06960119f, 0.02172975f, -0.05395695f, 
    -0.44907311f, 0.24535726f, -0.03887348f, -0.02855148f, 0.00616670f, -0.08327565f, -0.02336469f, 0.16114171f, 
    0.02301193f, -0.01172631f, 0.03776189f, -0.08711972f, -0.05112191f, -0.25939611f, -0.20454268f, -0.38589171f, 
    -0.02041921f, -0.02094163f, -0.02475720f, -0.03134944f, 0.02117331f, 0.03982088f, 0.04637514f, -0.07874340f, 
    -0.45952144f, 0.12367398f, -0.05554577f, 0.06164151f, 0.08062328f, 0.03704999f, 0.14370109f, 0.05736587f, 
    0.14568684f, 0.05153764f, -0.02438436f, 0.03492989f, -0.17699352f, 0.13740396f, -0.22373733f, 0.19891937f, 
    0.16032213f, -0.06524647f, 0.03164808f, 0.00114419f, -0.04368013f, -0.07727328f, -0.06869053f, 0.04355321f, 
    0.27864498f, -0.07069956f, -0.05012808f, 0.03538853f, 0.11689840f, 0.01890125f, 0.07881047f, -0.03098845f, 
    -0.01673348f, -0.17357804f, -0.02582395f, 0.01009556f, -0.06063304f, -0.28796971f, -0.09977342f, 0.07426379f, 
    0.04885735f, -0.01201747f, -0.00230574f, -0.02914662f, -0.01552395f, 0.04273875f, 0.11551904f, 0.06171044f, 
    0.14290282f, 0.11487485f, -0.10392839f, -0.04077310f, -0.14108485f, -0.12350905f, -0.08350866f, -0.19346595f, 
    -0.04971397f, 0.00208022f, -0.01060523f, -0.26467419f, 0.04022131f, -0.07776670f, 0.10685134f, -0.23886949f, 
    -0.17224346f, 0.07438625f, -0.00629865f, 0.03391933f, 0.04563123f, 0.08738816f, 0.02649231f, -0.00552422f, 
    0.07961889f, 0.01575460f, 0.09921727f, 0.02154298f, 0.01204507f, -0.05131892f, -0.06490904f, -0.01971007f, 
    -0.01890881f, 0.04224825f, 0.02819848f, -0.00256735f, -0.06678080f, 0.23791316f, -0.15112850f, -0.01005145f, 
    0.15207188f, -0.04049287f, 0.04328206f, 0.11197032f, 0.03486944f, 0.03148162f, 0.17004231f, 0.04261306f, 
    0.13017304f, 0.00516031f, -0.06215538f, 0.11520578f, 0.06259704f, -0.09081589f, 0.07260761f, 0.00475648f, 
    -0.04665790f, 0.02115714f, 0.00566400f, 0.09904218f, 0.02880154f, 0.10208990f, -0.01392978f, 0.02935889f, 
    0.09242641f, 0.00157771f, 0.04421315f, 0.03303036f, -0.05879377f, -0.01684535f, -0.05703526f, -0.17920032f, 
    -0.00083248f, 0.04524614f, 0.01716341f, 0.10300602f, -0.02635106f, -0.01542843f, 0.00018395f, -0.01601571f, 
    -0.05015867f, -0.02757504f, -0.01440199f, -0.07792404f, 0.06745555f, 0.03498514f, -0.14230129f, -0.02426923f, 
    0.02171887f, 0.01053810f, 0.00038711f, -0.15390128f, 0.06081076f, -0.02896966f, 0.08419826f, -0.03804200f, 
    -0.26111233f, 0.00330774f, 0.04017624f, -0.17417136f, 0.13144839f, -0.00060370f, 0.00531351f, 0.17722110f, 
    -0.00620017f, 0.00693380f, 0.01537561f, -0.01156721f, 0.12328786f, 0.12373456f, -0.06761599f, 0.13713738f, 
    0.13074228f, -0.07902397f, -0.01121053f, -0.01226946f, 0.00390421f, 0.02340918f, 0.03315225f, 0.03757942f, 
    0.21747743f, -0.15134400f, -0.13003382f, 0.03597253f, -0.04060331f, -0.00565441f, -0.00916477f, 0.01120850f, 
    0.02259809f, 0.05658217f, -0.02590228f, -0.00159437f, -0.21496499f, 0.16265860f, -0.05262080f, 0.07130421f, 
    -0.03260938f, -0.00633879f, 0.01201656f, 0.04473387f, -0.07425579f, -0.01553586f, 0.03503957f, -0.13646995f, 
    0.08009829f, 0.03476778f, 0.00040600f, -0.07717910f, -0.11093213f, 0.15609433f, -0.14073817f, -0.13143288f, 
    -0.10346276f, 0.00578547f, -0.04701338f, -0.19943814f, -0.21014886f, 0.08181358f, -0.12534182f, -0.02895406f, 
    0.07198384f, -0.14542928f, 0.10223391f, 0.10840411f, -0.01022437f, 0.02805340f, 0.09192841f, -0.12718403f, 
    -0.16789119f, 0.07224475f, -0.13109848f, -0.07789418f, 0.14631748f, -0.05401959f, 0.02627086f, 0.17081769f, 
    0.01630764f, 0.02356170f, -0.02593072f, 0.05148827f, 0.03010485f, -0.08972374f, 0.01565371f, -0.10063083f, 
    0.04002788f, -0.01282785f, 0.02988165f, 0.02417996f, -0.00579202f, -0.01003807f, -0.05151584f, -0.05003131f, 
    -0.08176250f, 0.08087844f, 0.15293363f, -0.05254873f, 0.04482163f, -0.08585277f, 0.08813629f, -0.04552280f, 
    -0.01342933f, -0.06414427f, 0.11269198f, 0.09252806f, 0.30484357f, -0.14118318f, -0.07571824f, 0.08562260f, 
    0.04929338f, -0.05003669f, -0.03522357f, -0.16847698f, 0.07473771f, 0.05457609f, 0.02281307f, -0.01659268f, 
    0.06614974f, 0.11710994f, -0.01994113f, 0.15658846f, 0.00138334f, -0.04405524f, -0.08951880f, 0.02138109f, 
    -0.01929237f, -0.04489785f, -0.13786457f, -0.09225105f, -0.11296917f, -0.03834803f, 0.00595274f, 0.03064552f, 
    -0.05495103f, -0.03185159f, 0.11572412f, 0.05920874f, 0.05082998f, -0.00826448f, 0.02947303f, 0.12063787f, 
    -0.19084543f, -0.16095038f, 0.08778695f, -0.09634170f, -0.16907828f, 0.09660935f, -0.01407133f, 0.02929700f, 
    0.07727270f, -0.05365267f, 0.01043970f, 0.06428992f, 0.38089702f, 0.01120734f, -0.03572855f, 0.08537433f, 
    0.02740339f, 0.04416294f, 0.00681100f, 0.02588461f, -0.01196833f, 0.01823065f, -0.07885224f, -0.02836949f, 
    0.15548886f, 0.17727797f, -0.13248494f, 0.20350562f, -0.05247303f, -0.02782827f, 0.03720711f, -0.10076728f, 
    0.04766984f, 0.11983842f, -0.07682730f, -0.01864342f, -0.17216976f, 0.11289182f, -0.08685923f, 0.09102221f, 
    0.02539820f, -0.01392620f, 0.12480651f, -0.11652674f, -0.00993835f, 0.01515020f, 0.03367020f, 0.03219897f, 
    -0.19911139f, 0.18630178f, -0.02699426f, -0.23883654f, -0.05138293f, -0.07699748f, -0.03879398f, -0.05150536f, 
    0.02003703f, -0.05229164f, 0.09698991f, 0.06009234f, 0.42883644f, 0.10638823f, -0.10729990f, -0.03990515f, 
    -0.09235985f, -0.07402126f, 0.02176833f, 0.04874514f, 0.05899604f, 0.10706374f, -0.01886402f, 0.05347672f, 
    -0.20298046f, -0.01693437f, -0.05399975f, 0.02449005f, 0.09866307f, -0.02279657f, 0.00692616f, 0.09297854f, 
    -0.03324527f, 0.00152768f, -0.10301451f, 0.04223291f, 0.25547081f, 0.03859301f, 0.08096014f, 0.03672551f, 
    0.06819344f, -0.01045916f, -0.11000089f, 0.09646120f, -0.01106044f, -0.11787688f, 0.06022352f, -0.10919042f, 
    0.07930258f, -0.07240712f, 0.02914761f, -0.14112367f, -0.04123891f, -0.07244840f, 0.06311234f, -0.07297876f, 
    -0.05306348f, -0.08591024f, -0.02174956f, 0.06113594f, -0.13428338f, 0.23982249f, -0.06333100f, -0.05848268f, 
    -0.02772361f, 0.02516194f, 0.04830917f, 0.03056125f, 0.11684361f, 0.10865257f, -0.08758300f, 0.01207573f, 
    0.40210778f, 0.21347612f, -0.18664578f, -0.02836008f, -0.05543524f, -0.04985445f, -0.00569332f, 0.00640649f, 
    0.10488577f, 0.03138987f, 0.01012655f, 0.00162304f, 0.39368981f, 0.15533526f, -0.11968505f, -0.02926032f, 
    0.07814084f, -0.02584585f, 0.05341614f, 0.07995097f, 0.10794202f, 0.11452713f, -0.03132064f, 0.07003665f, 
    0.10721748f, 0.01663397f, -0.04242945f, -0.05154153f, -0.21626700f, -0.00084898f, -0.10462687f, -0.10047420f, 
    0.00804151f, 0.03233473f, -0.03372392f, -0.14639957f, 0.42602971f, 0.04747922f, -0.34216878f, -0.13046043f, 
    0.09392898f, 0.02267521f, 0.01836395f, -0.09162048f, 0.02014493f, -0.03689761f, -0.00573666f, -0.00062908f, 
    -0.25445032f, 0.09898421f, 0.05998959f, -0.06914689f, -0.06486756f, 0.00052114f, 0.00700396f, -0.05307781f, 
    -0.00878049f, -0.05535177f, -0.08255181f, -0.00887897f, 0.12589911f, -0.07510842f, -0.13320710f, 0.02308325f, 
    0.01134777f, 0.03994339f, 0.00110629f, -0.03001798f, -0.03231927f, 0.01203752f, -0.05031179f, -0.09090189f, 
    -0.21198940f, 0.04051839f, -0.11259133f, 0.08820447f, -0.01813260f, -0.02465385f, 0.01099882f, 0.13186426f, 
    -0.02783199f, -0.10445806f, -0.08588763f, -0.10687765f, 0.31387430f, -0.18175927f, -0.10323749f, -0.07667169f, 
    0.08426310f, -0.05374055f, -0.01982768f, -0.03794136f, 0.04473767f, 0.11584521f, 0.04332598f, 0.07388021f, 
    0.06549772f, -0.14502595f, -0.00431315f, -0.01528006f, 0.00236530f, 0.04492907f, 0.02192137f, -0.00329429f, 
    0.08206573f, -0.03770354f, -0.06492617f, 0.02843451f, -0.03592762f, -0.03885543f, -0.08387125f, 0.05350005f, 
    0.04075947f, 0.04564537f, 0.00680216f, -0.01949355f, 0.00009974f, -0.01972914f, -0.15875231f, 0.06874456f, 
    0.08303005f, -0.20780627f, 0.04788660f, 0.11886641f, 0.01225985f, -0.03185245f, 0.00595251f, 0.05984680f, 
    -0.08810077f, -0.02818608f, 0.00492601f, -0.11329996f, -0.16788732f, -0.06743848f, 0.06605698f, -0.04668875f, 
    0.16652977f, -0.05261714f, -0.00316920f, 0.04733340f, -0.01222173f, -0.15799086f, -0.02772837f, 0.02257393f, 
    -0.29799879f, 0.06757571f, 0.08452707f, 0.08520976f, 0.13010608f, -0.01504457f, 0.00241437f, 0.01852456f, 
    0.07107297f, -0.04670014f, 0.01919903f, 0.00862911f, 0.01193233f, -0.12405658f, -0.03995735f, 0.19217460f, 
    -0.12759632f, -0.05618440f, -0.03314354f, 0.05313544f, 0.03147193f, -0.00123805f, 0.03097113f, 0.14529590f, 
    0.01465587f, 0.09419166f, -0.00423965f, 0.03356201f, -0.10556506f, 0.08076768f, -0.14209607f, -0.00221740f, 
    -0.03518384f, -0.10843850f, 0.08288857f, 0.07947784f, -0.33260444f, -0.02239918f, 0.10775454f, -0.07117761f, 
    -0.01839121f, -0.01688060f, -0.08640148f, -0.06509203f, 0.04521524f, 0.00829141f, -0.06946252f, 0.00947109f, 
    0.09546445f, -0.18360865f, -0.05119654f, -0.09643411f, 0.02871902f, 0.04536719f, -0.00116804f, -0.06823620f, 
    -0.12546726f, -0.10254666f, -0.03837529f, -0.05849631f, -0.07365734f, 0.04845290f, -0.00594134f, 0.03589975f, 
    0.02735466f, 0.03079460f, -0.08230305f, -0.02753288f, 0.03635839f, 0.04097949f, -0.02833330f, -0.02143619f, 
    0.07587441f, -0.08643514f, -0.05175927f, 0.03438120f, 0.12389626f, 0.00682650f, -0.17324676f, -0.01174065f, 
    -0.05594767f, -0.04398320f, 0.02309696f, 0.14121516f, -0.17679670f, 0.08610573f, -0.13309513f, 0.04016743f, 
    -0.04850156f, -0.08916494f, 0.01737321f, 0.05902464f, -0.01225158f, -0.02226978f, -0.00354730f, -0.11437026f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08505034f, -0.01216818f, -0.05724784f, 0.03032033f, 0.03721453f, 0.01709591f, -0.01479059f, -0.03682094f, 
    0.00938135f, -0.01111912f, 0.10025574f, 0.04230088f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
