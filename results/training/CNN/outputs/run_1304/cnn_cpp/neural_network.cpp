#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.09326325f, -0.23208562f, -0.27634346f, -0.64748591f, -0.17355683f, -0.42153910f, 0.65664309f, 0.53548509f, 
    0.58191252f, 0.64373040f, 0.65589333f, -0.60105658f, -0.43817294f, 0.47230774f, -0.44124299f, 0.28759441f, 
    0.20268723f, -0.20331104f, 0.28370142f, 0.49545416f, 0.47550663f, 0.21797517f, 0.14716487f, 0.71690845f, 
    -0.18576026f, 0.46521801f, -0.35449675f, -0.63672698f, -0.64569968f, -0.37692764f, 0.95379752f, -0.61967820f, 
    -0.56360757f, -0.50800747f, 0.22044234f, -0.50520670f, -1.06062627f, 0.32142735f, -0.30795991f, 0.69808501f, 
    -0.80322123f, -0.63712555f, -0.47012955f, -0.29610479f, -0.46174479f, -0.54383481f, -0.19468039f, 0.62904930f, 
    0.39350468f, 0.52071357f, 0.39311913f, 0.00345824f, -0.54196155f, -0.69684190f, 0.52194017f, 0.16759144f, 
    -0.95588219f, -0.74462116f, -0.64300925f, -0.33041424f, -0.30203602f, -0.57784581f, -0.25849852f, -0.51066667f, 
    -1.18419695f, -0.49824083f, 0.83026189f, 0.19332464f, 0.32881287f, 0.62649304f, -0.00928751f, -0.12008511f, 
    -0.57533121f, 0.91064394f, -0.09616571f, -0.57996517f, 0.70445663f, 0.12002973f, 0.58461016f, -0.26345745f, 
    0.40079677f, -0.80202502f, -0.85849524f, -0.06400592f, -0.31077734f, -0.76425308f, -0.35627866f, 0.06365613f, 
    -0.23603040f, -0.07847401f, -0.82571185f, -0.64542049f, -0.62121171f, 0.09626482f, -0.78719711f, 0.70966083f, 
    0.07825971f, 0.12281229f, 0.38132542f, -0.74239630f, 0.42398733f, 0.83023870f, 0.81564254f, -0.88627183f, 
    -0.20225875f, -0.01647742f, 0.21718952f, -0.31782213f, -0.12674005f, -0.18866824f, 0.16672789f, -0.67571783f, 
    -0.41337427f, 1.05913031f, -0.07093290f, 0.34928131f, -0.42260757f, 0.01212410f, -0.27736509f, -0.32926700f, 
    0.71979213f, -0.80885148f, -0.67543119f, 0.62230569f, 0.40320152f, 0.30029655f, 0.11428042f, 1.21517122f, 
    0.72511292f, -1.11137509f, -0.64991784f, -0.36912036f, -0.15060419f, 0.37095591f, 0.12885216f, 0.08280964f, 
    -1.06936443f, -0.88549650f, 0.41757321f, 0.40377718f, 0.91653526f, -0.39811465f, -0.18138118f, -0.30347055f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24852508f, 0.42476431f, 0.33300564f, 0.07850067f, -0.01238390f, 0.22731988f, 0.22149387f, 0.18177825f, 
    0.01097794f, 0.22630422f, -0.00357858f, 0.03423194f, 0.53362173f, 0.03817151f, 0.35120630f, -0.16988790f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.13475242f, 0.02832749f, 0.35903224f, -0.00218561f, -0.15558313f, 0.18690933f, -0.07371131f, 0.12287451f, 
    0.09037100f, 0.01358766f, 0.07624079f, 0.09086940f, 0.03528610f, -0.08800666f, -0.09419750f, -0.02788052f, 
    -0.17497364f, -0.27080545f, -0.29890931f, -0.27183267f, 0.07905627f, -0.00733094f, -0.20360051f, -0.34514695f, 
    0.22216886f, 0.02762159f, -0.12378932f, -0.04811708f, -0.19797276f, 0.02181386f, 0.10693790f, -0.00202671f, 
    -0.03216250f, 0.04341984f, -0.16576780f, 0.15963621f, -0.01117832f, 0.08315784f, 0.01678467f, -0.17165533f, 
    -0.05620160f, -0.02785628f, -0.24677269f, 0.20025666f, 0.22970903f, -0.02982295f, -0.19264622f, -0.10709251f, 
    -0.05391791f, 0.08064976f, 0.07414880f, 0.01833530f, 0.02892654f, 0.12592481f, 0.04804245f, 0.04366840f, 
    0.03065345f, 0.17588687f, 0.03494436f, -0.13328879f, -0.04282213f, -0.19949263f, 0.38205609f, -0.13785270f, 
    -0.04300285f, -0.04320609f, 0.05129665f, -0.00272256f, 0.04807926f, -0.05268288f, 0.10974718f, -0.03617247f, 
    -0.03082918f, 0.01281056f, 0.10305906f, 0.03758721f, 0.05035669f, 0.11352067f, 0.10533659f, 0.14907612f, 
    -0.10313090f, -0.13287719f, 0.35129753f, -0.18408522f, -0.05835327f, -0.12780347f, 0.20172893f, 0.01733541f, 
    0.15077353f, 0.09973875f, 0.12280437f, -0.07334045f, 0.06201459f, 0.02183564f, 0.04487791f, 0.05366668f, 
    0.08451735f, 0.08535185f, 0.07484837f, 0.21490690f, 0.01356139f, 0.10068815f, -0.06042377f, 0.07326221f, 
    0.09715298f, -0.28279555f, -0.10124433f, -0.15262647f, -0.10366707f, -0.15653294f, 0.03173550f, 0.09396178f, 
    -0.04066524f, -0.04169229f, -0.04727772f, -0.11291222f, 0.14301684f, 0.17234759f, -0.11858705f, 0.18009168f, 
    0.24827845f, 0.17855184f, 0.29529512f, 0.16347279f, 0.05438210f, 0.16623321f, 0.19520342f, 0.17459400f, 
    0.30645242f, 0.28061277f, 0.05558370f, 0.09143483f, -0.00626093f, -0.06761611f, -0.01810906f, 0.05275989f, 
    0.21991239f, 0.03966463f, 0.10181856f, 0.20925073f, 0.31304541f, -0.03185038f, 0.40409872f, -0.11235137f, 
    -0.03018420f, 0.00214476f, -0.14546856f, -0.35171935f, -0.01808682f, -0.14641392f, 0.11759684f, 0.08546331f, 
    0.02262285f, 0.02811677f, 0.16518630f, -0.08860422f, -0.00545259f, -0.02025294f, 0.03542677f, -0.14527042f, 
    -0.24259587f, 0.30042645f, -0.27262765f, 0.10724711f, -0.24190174f, 0.36237863f, -0.49502650f, 0.01856161f, 
    -0.16047505f, -0.11535093f, 0.06411452f, 0.05389499f, 0.02329639f, 0.17451541f, -0.01271440f, -0.11325084f, 
    -0.08726277f, 0.04060407f, -0.14613971f, -0.12327818f, 0.05247824f, 0.02056394f, 0.29940856f, 0.07858361f, 
    -0.16250835f, 0.15906356f, 0.26865351f, -0.01800516f, 0.16809866f, 0.13889165f, 0.14305349f, 0.03200448f, 
    -0.05828509f, 0.03129129f, 0.07349799f, -0.06404447f, 0.15322885f, 0.02981897f, 0.15992023f, 0.04768855f, 
    0.25587812f, -0.10374887f, 0.23026629f, 0.25682217f, -0.12220998f, 0.10958635f, 0.02015092f, -0.01185546f, 
    0.09673538f, -0.06861933f, 0.15173380f, -0.13582350f, 0.02978039f, 0.00285527f, 0.11130406f, -0.12574966f, 
    -0.01486580f, 0.00697031f, -0.06108442f, 0.00830366f, 0.16294789f, -0.14963588f, 0.19330034f, -0.20340289f, 
    0.00591570f, -0.18218014f, 0.01546739f, -0.30988720f, -0.02692520f, -0.11255176f, 0.13906258f, -0.13320616f, 
    0.01701334f, 0.00630100f, 0.00270282f, 0.15266818f, -0.04328990f, -0.07480139f, 0.08288438f, -0.02801692f, 
    0.02201337f, -0.11496967f, -0.04419870f, 0.18894365f, -0.02165817f, -0.01545213f, -0.05948206f, 0.01468299f, 
    -0.12445768f, 0.13136300f, 0.07290682f, 0.14663479f, -0.12392450f, -0.00910692f, 0.09421227f, -0.11554481f, 
    -0.03341451f, -0.08323208f, 0.08682053f, 0.09151073f, 0.30976367f, 0.02125001f, 0.47870839f, -0.30826819f, 
    -0.00311706f, 0.09313374f, 0.17852251f, -0.14600240f, 0.07482053f, 0.02798451f, 0.15772893f, 0.07628191f, 
    0.02840266f, 0.04497594f, -0.04202160f, 0.08731581f, -0.30127078f, -0.26787484f, -0.01784195f, -0.20489120f, 
    -0.67798203f, 0.24028358f, -0.15762372f, 0.43980816f, 0.05955324f, 0.00688612f, -0.04109208f, 0.01045403f, 
    -0.06203792f, 0.18581270f, 0.16193990f, -0.14104587f, -0.13298585f, -0.12163023f, -0.12977155f, 0.03078417f, 
    -0.07938730f, 0.20542872f, -0.10616545f, 0.06798427f, -0.00968117f, -0.19825146f, -0.15429743f, -0.02991920f, 
    -0.09025186f, -0.07273011f, -0.19427405f, -0.04967555f, -0.08848423f, -0.20996135f, -0.01121595f, 0.17218158f, 
    0.07512826f, 0.10013665f, 0.27123779f, -0.14480686f, 0.06762539f, 0.09294662f, 0.09405918f, 0.14117530f, 
    -0.00660673f, -0.24026448f, -0.11520775f, 0.08053462f, -0.00881664f, 0.05422099f, -0.02956968f, 0.09315007f, 
    -0.03281007f, -0.13764295f, 0.01077567f, -0.03134607f, 0.06042490f, -0.01595076f, -0.08306315f, 0.03028474f, 
    -0.03573276f, -0.00751436f, -0.13894942f, 0.10410520f, 0.20305339f, 0.08843125f, 0.08901496f, 0.12313128f, 
    0.15491894f, 0.05380321f, 0.03008199f, -0.11389962f, 0.01677073f, -0.04205044f, -0.00124402f, -0.08610163f, 
    -0.06163419f, 0.00578272f, -0.05798503f, 0.15087143f, 0.03670273f, 0.05649905f, 0.16601343f, -0.09811544f, 
    -0.01339286f, -0.13368340f, 0.00260550f, 0.04300921f, 0.06054689f, -0.04082936f, -0.10864160f, -0.15236883f, 
    -0.04134416f, 0.06292297f, -0.10065631f, -0.01485387f, -0.07537158f, 0.13180965f, -0.04112678f, -0.05158369f, 
    -0.02039715f, 0.10201298f, 0.02570732f, -0.15934549f, -0.25709182f, 0.08504779f, 0.11084041f, 0.04300771f, 
    -0.01379437f, 0.19500463f, 0.00583526f, 0.05984330f, 0.03168960f, 0.01938374f, -0.07027265f, 0.01627029f, 
    -0.03010191f, 0.07722687f, -0.01789779f, 0.11303163f, -0.08012160f, 0.10935511f, 0.11851707f, 0.10875602f, 
    -0.18223901f, 0.13609658f, 0.21105051f, 0.05601791f, 0.03372397f, 0.10871247f, 0.02055060f, -0.04059513f, 
    0.24599177f, 0.02664068f, -0.07894956f, 0.00475738f, -0.02733373f, 0.03777217f, 0.06737725f, 0.07328190f, 
    -0.04729944f, -0.06528067f, 0.05637313f, 0.05377541f, 0.03064462f, 0.16231903f, -0.19945441f, 0.04491658f, 
    0.25052530f, 0.06586969f, 0.00916193f, -0.02566766f, -0.08170843f, -0.03765901f, 0.10187919f, 0.02742798f, 
    -0.02589267f, 0.15527260f, 0.15574987f, -0.02419064f, 0.02023767f, 0.09244508f, -0.08486452f, -0.14160646f, 
    0.17056943f, -0.05040350f, 0.12503001f, 0.18093197f, 0.02947816f, 0.10444912f, 0.05812478f, 0.02263202f, 
    0.05391918f, 0.05111462f, 0.06529255f, -0.01633103f, 0.03839105f, -0.00205890f, -0.05946398f, 0.01553344f, 
    -0.00143338f, -0.03883221f, 0.15580411f, -0.02024967f, -0.34446657f, 0.03063533f, -0.19180769f, -0.21656139f, 
    0.01081972f, 0.05006774f, 0.09742973f, 0.08273756f, 0.09986162f, -0.02095510f, -0.02184467f, 0.04938585f, 
    0.11863127f, 0.04002231f, -0.09191990f, -0.11783190f, -0.06121254f, 0.02463645f, -0.02811230f, -0.05599504f, 
    -0.02894241f, -0.02981863f, -0.18126166f, 0.05509324f, 0.05605255f, -0.03735772f, -0.17096376f, -0.13566190f, 
    -0.00124577f, -0.03832182f, -0.12153330f, 0.00311060f, 0.14065181f, 0.07922583f, -0.18233602f, -0.08228607f, 
    0.02707788f, 0.12018903f, 0.15973027f, 0.07453298f, -0.05574266f, -0.00558016f, 0.18442769f, 0.04334762f, 
    -0.03298961f, 0.17199406f, 0.01866162f, -0.02062953f, 0.12220525f, 0.03483006f, 0.05702721f, -0.07379410f, 
    -0.02443390f, -0.00006346f, -0.00269992f, -0.01015419f, 0.01134675f, 0.03895714f, -0.13348992f, 0.02566515f, 
    -0.12719180f, -0.09725348f, -0.08778529f, 0.07582474f, -0.04631093f, 0.16787612f, 0.06947891f, 0.12932642f, 
    -0.04710404f, 0.01449942f, 0.00960637f, -0.00555876f, -0.06803469f, -0.11699654f, 0.00892379f, -0.00500766f, 
    0.04820320f, 0.08491757f, -0.14106740f, 0.11042462f, -0.25202894f, 0.53825647f, 0.40400016f, -0.24589834f, 
    0.16056485f, 0.05703966f, -0.05154622f, -0.10647637f, 0.33037290f, 0.02885136f, 0.15988331f, 0.06758123f, 
    0.01440707f, 0.06890653f, -0.05253104f, -0.00014124f, 0.02561317f, 0.07269728f, 0.09808176f, 0.02257183f, 
    0.35489026f, -0.17762206f, 0.05301932f, 0.21905115f, 0.08637138f, 0.18591753f, 0.07724527f, -0.01573124f, 
    -0.03896915f, 0.20943734f, -0.03336682f, 0.00519910f, -0.08585211f, 0.15602136f, 0.18757854f, 0.01769714f, 
    0.12980948f, 0.19904217f, -0.08138587f, 0.07301318f, -0.25150782f, -0.06489022f, 0.05167025f, 0.04925017f, 
    0.05571614f, -0.13560651f, 0.10986041f, 0.03621919f, -0.05585071f, -0.12374993f, 0.11119244f, -0.02174383f, 
    -0.03297105f, 0.01475036f, -0.08173380f, 0.02809967f, 0.00971525f, 0.03376513f, 0.23388614f, -0.04782037f, 
    -0.06788181f, -0.09503170f, 0.44124410f, 0.02387389f, -0.11197110f, 0.10478568f, 0.05487264f, -0.03802345f, 
    0.20109409f, -0.01662145f, -0.14074679f, 0.04184714f, -0.01022581f, 0.01158570f, -0.00695135f, -0.03380331f, 
    -0.08479105f, 0.17328933f, -0.13910811f, 0.16717337f, -0.11513155f, 0.17181595f, -0.01694168f, -0.21760704f, 
    0.01919569f, 0.31211632f, 0.03957363f, 0.18922141f, 0.01967637f, -0.03327560f, -0.03585787f, -0.00482213f, 
    0.13799508f, -0.02395996f, 0.14542159f, -0.17687225f, -0.22174697f, 0.00838784f, 0.03701930f, -0.03545086f, 
    -0.00614297f, -0.11745246f, -0.05119608f, 0.09318940f, 0.06194855f, -0.06828773f, -0.14169942f, 0.01233947f, 
    0.02247132f, -0.04910982f, -0.00595036f, -0.01638170f, 0.07694738f, 0.08059675f, 0.08293828f, -0.07772775f, 
    0.08628482f, 0.06157496f, 0.01666022f, -0.02027334f, 0.03314140f, 0.14447698f, 0.07307100f, 0.03675146f, 
    0.02854843f, -0.09172163f, 0.18154503f, -0.07214301f, 0.06010804f, -0.04088191f, 0.09403864f, 0.09140566f, 
    0.00449104f, 0.00625868f, -0.00430445f, 0.03192381f, -0.06179539f, -0.01104911f, 0.16743800f, 0.11556344f, 
    -0.03102326f, 0.11018511f, 0.06889413f, -0.09573460f, -0.14464490f, -0.02556251f, 0.01737325f, -0.02637721f, 
    -0.05341386f, -0.06384162f, -0.13368115f, -0.06276879f, 0.02825366f, 0.02850896f, 0.02267095f, -0.02009146f, 
    0.06435915f, -0.04575023f, 0.01234972f, 0.01020265f, 0.17003781f, -0.06082651f, 0.03638744f, -0.01437878f, 
    -0.15064210f, -0.01754799f, -0.04665029f, -0.02433538f, 0.19678649f, 0.02233781f, 0.12167724f, -0.09313886f, 
    0.00199546f, 0.01549117f, 0.08529846f, 0.05241419f, 0.10748690f, 0.14058472f, -0.07867946f, -0.03680735f, 
    -0.10534358f, -0.14442684f, 0.18025193f, 0.06119436f, -0.07918811f, 0.21180065f, -0.21167947f, -0.08716151f, 
    0.08427729f, -0.05901740f, 0.20918106f, 0.02228002f, 0.01090269f, 0.05790735f, 0.01087781f, -0.01027667f, 
    0.02118479f, 0.02310464f, 0.01314005f, -0.10428391f, -0.23689239f, 0.09131396f, -0.09952185f, 0.30815867f, 
    0.06349480f, 0.00107669f, -0.05991389f, -0.13972782f, -0.12274349f, -0.02302748f, -0.01012396f, 0.03458457f, 
    0.26833382f, 0.03858607f, 0.16656122f, 0.09937660f, 0.17132108f, -0.06558342f, 0.06189152f, -0.10053118f, 
    0.06904363f, -0.15002778f, 0.05564304f, -0.04788502f, -0.05305012f, 0.06673831f, -0.17423961f, -0.09249841f, 
    -0.12263614f, -0.06459579f, 0.13826689f, -0.00699178f, 0.15342836f, 0.06665206f, 0.10986105f, 0.18522774f, 
    0.02283612f, 0.10958342f, 0.00020515f, -0.10458606f, 0.10088927f, -0.31527776f, -0.18662515f, -0.05747904f, 
    -0.18000200f, -0.13870196f, -0.00129906f, 0.08093438f, 0.12539296f, 0.05512729f, 0.21251991f, -0.07793408f, 
    0.07293542f, 0.01975964f, -0.00683193f, -0.07141072f, 0.04874744f, -0.06557825f, 0.01439077f, 0.01970579f, 
    0.03795906f, 0.13482969f, -0.20362799f, -0.18592511f, 0.02186498f, -0.01959666f, 0.07181683f, -0.19724829f, 
    0.08685995f, 0.01012664f, 0.15618610f, 0.09248726f, 0.29258785f, 0.11679860f, 0.04737601f, 0.01596499f, 
    -0.15268864f, -0.07926203f, 0.14571892f, 0.00634117f, 0.10519361f, -0.21027246f, 0.01630928f, 0.13893999f, 
    -0.10895057f, -0.00341019f, -0.21402241f, -0.02652139f, -0.08959576f, -0.03381274f, 0.16846809f, 0.02484284f, 
    0.08566634f, 0.00271479f, 0.06827510f, 0.10384242f, 0.08855549f, 0.15571649f, -0.04381712f, -0.06094290f, 
    -0.02730919f, -0.27556685f, -0.17751071f, -0.05015473f, -0.22416745f, -0.00495178f, 0.08444186f, -0.00391662f, 
    -0.06184125f, 0.25077903f, 0.07598478f, 0.00527889f, -0.05422416f, -0.05014591f, -0.07047014f, 0.01963377f, 
    0.01797670f, 0.00180678f, -0.06175811f, 0.00523258f, 0.01340639f, -0.12629737f, 0.00129867f, -0.41580313f, 
    -0.17115571f, 0.21149325f, 0.03019785f, -0.17696835f, 0.19103679f, -0.07186418f, 0.00414766f, 0.02201308f, 
    0.03791079f, -0.01241419f, 0.07751854f, 0.02786283f, 0.20624699f, 0.19008598f, -0.03495798f, -0.11257212f, 
    0.39991364f, 0.23953782f, -0.10836037f, 0.34326929f, 0.17494042f, 0.18308054f, 0.26646990f, 0.26897848f, 
    0.09744681f, 0.17626058f, 0.12835760f, 0.04677569f, -0.00842144f, 0.07915315f, 0.04758046f, -0.07002950f, 
    0.22707306f, -0.03106816f, 0.12312657f, 0.10737962f, -0.10104221f, -0.11198446f, 0.17483947f, 0.09653512f, 
    -0.06658953f, -0.17133051f, -0.04691439f, 0.01017356f, 0.02719400f, 0.04428595f, -0.03855905f, 0.02379364f, 
    0.01152961f, -0.03717153f, 0.04263431f, 0.02946822f, 0.03680917f, 0.15362234f, -0.15192011f, 0.01228210f, 
    0.41915566f, 0.32288948f, -0.05276963f, 0.06629432f, -0.33527178f, 0.14700249f, 0.05875211f, -0.04696149f, 
    0.13434020f, 0.05815063f, -0.00687503f, 0.06418403f, 0.00012861f, -0.05175418f, -0.04846448f, -0.01100381f, 
    0.12681851f, -0.03050522f, 0.23090985f, 0.07697725f, 0.17885764f, -0.23609582f, -0.04560584f, -0.08401794f, 
    0.02866831f, -0.12603329f, -0.00077634f, 0.04579627f, 0.05451924f, 0.10165471f, 0.20837714f, -0.10984956f, 
    -0.09904905f, 0.00178976f, 0.04085597f, 0.00992431f, 0.04641860f, -0.07209206f, -0.00214116f, 0.07387543f, 
    0.13846411f, -0.18149248f, -0.15755783f, 0.13460064f, 0.04996345f, 0.03490872f, -0.00395253f, -0.12798110f, 
    -0.09573243f, 0.16608183f, 0.08657928f, 0.00877793f, 0.05010044f, -0.03489918f, -0.08690871f, -0.03959429f, 
    0.10064217f, -0.02903327f, -0.00029098f, -0.06346411f, -0.39857531f, 0.08951583f, 0.19015513f, -0.00590469f, 
    0.01785048f, 0.02063194f, -0.01412912f, -0.02946982f, 0.03563770f, -0.03794254f, 0.04881679f, -0.02464861f, 
    0.14225416f, 0.04569580f, 0.06343678f, -0.04506281f, 0.07762064f, 0.08669479f, 0.04637191f, 0.01916116f, 
    0.01754348f, 0.24058950f, 0.17041029f, -0.07366242f, -0.21585929f, 0.06327463f, 0.00139436f, 0.03751490f, 
    0.02591460f, -0.02247154f, 0.07255933f, 0.03685230f, -0.02349761f, 0.00550879f, 0.05670343f, 0.13098802f, 
    0.02831301f, 0.05154375f, 0.06059780f, 0.05619276f, 0.05717429f, -0.24606970f, 0.17047654f, 0.15196235f, 
    0.17747156f, -0.06224977f, 0.06293309f, -0.01410207f, 0.09606243f, -0.12785701f, 0.07793444f, -0.06814889f, 
    -0.12757288f, 0.00369718f, 0.04599340f, -0.05226596f, 0.03790523f, -0.02679230f, -0.05402244f, -0.15543699f, 
    0.19723439f, -0.38256067f, 0.19564189f, 0.09850792f, 0.02738338f, 0.08669282f, -0.07206696f, 0.14663565f, 
    0.08715621f, -0.07730296f, -0.00200906f, 0.01052751f, -0.08539861f, 0.01835973f, 0.00391259f, 0.02229429f, 
    0.13878044f, 0.11000386f, -0.14083663f, -0.00337954f, 0.11005484f, 0.15291302f, 0.12702890f, -0.10200050f, 
    -0.31512696f, 0.02872141f, -0.01073354f, -0.02865179f, 0.09243588f, 0.00611523f, -0.02481592f, 0.08083145f, 
    0.02026077f, -0.11000103f, -0.13551040f, -0.10140764f, 0.03114985f, -0.01389581f, -0.07739504f, 0.17359975f, 
    -0.17320770f, -0.10748868f, 0.10121612f, 0.19516301f, 0.23257035f, 0.03120011f, 0.18922302f, 0.03640332f, 
    0.01418949f, 0.02927506f, 0.02644831f, -0.07170789f, -0.04377628f, -0.03671241f, -0.05492190f, 0.14655742f, 
    0.19810991f, -0.09195447f, -0.08282138f, 0.08353234f, 0.19320539f, -0.18373674f, -0.09214911f, -0.09840322f, 
    0.16789845f, -0.05004109f, -0.03623514f, -0.00228687f, 0.05425262f, 0.08018631f, 0.22695738f, -0.00298277f, 
    -0.13477398f, -0.06546917f, 0.02709366f, 0.03980713f, 0.01830308f, 0.03556370f, 0.05138494f, -0.09323747f, 
    0.23237894f, 0.07737693f, -0.10443341f, -0.11219762f, -0.14405771f, 0.03251888f, 0.07332039f, 0.06180662f, 
    -0.04770455f, -0.02027286f, -0.00751052f, 0.00585757f, 0.10228413f, 0.02723356f, 0.01389086f, 0.07699247f, 
    -0.03748390f, 0.00722640f, 0.02860862f, 0.04632482f, 0.02207247f, -0.11537201f, -0.17153651f, 0.14258529f, 
    0.21584342f, -0.07664039f, 0.01643523f, -0.12811005f, 0.05698554f, -0.01448498f, -0.01060024f, -0.02280111f, 
    -0.12602305f, 0.02079563f, 0.05265760f, -0.03978909f, -0.04771710f, -0.01496156f, -0.14223060f, 0.17001212f, 
    0.50003117f, -0.09693663f, -0.25950116f, 0.15984485f, 0.32292342f, 0.00057379f, -0.05269230f, 0.09552982f, 
    0.22383384f, -0.09771438f, 0.05683264f, -0.00614697f, -0.08371216f, 0.06729537f, 0.03306720f, -0.04081570f, 
    -0.01474904f, -0.06658250f, -0.00522731f, -0.09404991f, 0.56137651f, 0.11043647f, 0.06817614f, -0.12606767f, 
    -0.01727110f, 0.14693795f, -0.09725985f, -0.00312601f, 0.03926922f, -0.07919340f, -0.09831075f, 0.04645235f, 
    -0.04281389f, 0.03269646f, 0.03046839f, 0.00145944f, -0.05857817f, -0.07591233f, -0.07057941f, -0.08420527f, 
    0.19713402f, 0.20045355f, -0.12474453f, -0.17872360f, -0.06545549f, -0.00951785f, 0.00994882f, 0.16163732f, 
    0.06524532f, 0.20953242f, 0.18430254f, -0.11301996f, 0.05300261f, 0.05243992f, 0.03235882f, -0.04741096f, 
    -0.15136145f, -0.07483257f, -0.13117442f, 0.11804122f, -0.04033802f, -0.11175280f, -0.02260859f, -0.03989653f, 
    0.02489582f, 0.12888643f, -0.04022515f, -0.15598768f, 0.00172707f, 0.29004681f, 0.02354597f, 0.13755019f, 
    0.04402104f, 0.00337274f, -0.02179146f, -0.05547941f, 0.03848970f, -0.09198483f, -0.01340274f, -0.03800329f, 
    -0.01841802f, -0.03398670f, 0.18395609f, 0.12140542f, 0.07262580f, -0.08670478f, 0.05720584f, -0.01813608f, 
    -0.00564952f, 0.13240214f, 0.12546928f, -0.03347975f, 0.05859487f, -0.06589317f, -0.04009994f, -0.03279791f, 
    0.03110311f, -0.05537161f, 0.02545344f, -0.00566717f, -0.15097871f, -0.21199726f, 0.24003404f, -0.05438937f, 
    0.48411411f, -0.26101205f, 0.17191482f, 0.09831291f, -0.01523461f, 0.25646621f, 0.09379680f, 0.09523330f, 
    -0.13913976f, -0.03284056f, 0.05712566f, -0.12603083f, -0.04961170f, -0.07232483f, -0.08914225f, -0.06298805f, 
    -0.31170902f, -0.35929075f, -0.32286930f, -0.03037897f, 0.11678944f, -0.08013671f, 0.10202582f, -0.13110687f, 
    0.00495568f, 0.06943760f, 0.03280389f, 0.06167116f, -0.10466228f, -0.07766054f, -0.03921377f, -0.04478505f, 
    -0.01891209f, 0.04155673f, 0.14340492f, -0.12144009f, -0.10153651f, 0.10210004f, 0.25605464f, 0.10787421f, 
    -0.14145565f, 0.13326985f, -0.05627618f, 0.02290602f, 0.09822404f, -0.10754967f, 0.09823161f, -0.00566147f, 
    0.16357358f, -0.08034482f, 0.13870962f, -0.06778124f, -0.04421569f, 0.08439473f, 0.02907126f, 0.02400686f, 
    0.20044987f, 0.20922713f, 0.36596388f, -0.01043843f, -0.21245763f, 0.05929268f, -0.12095973f, 0.00406199f, 
    -0.05125959f, -0.06120410f, 0.05806401f, 0.03171756f, 0.06340745f, -0.05418254f, 0.00751073f, 0.06465450f, 
    -0.04321464f, -0.22505528f, -0.05222469f, 0.01170391f, -0.04109877f, -0.09613448f, -0.25176439f, -0.02208672f, 
    0.11954048f, -0.00064871f, 0.18055926f, 0.10295144f, 0.28174299f, 0.17235808f, -0.08979803f, 0.00474831f, 
    0.03582259f, -0.02198489f, 0.05086355f, -0.02165518f, 0.00935833f, 0.10721655f, 0.02299569f, 0.02154415f, 
    0.18167283f, -0.14008349f, -0.20974608f, 0.05429069f, -0.03052151f, 0.18989518f, 0.00200752f, 0.05188167f, 
    0.12853545f, 0.12298004f, -0.02543917f, -0.06952830f, 0.01141130f, -0.01264934f, 0.13614671f, -0.09768996f, 
    0.10666385f, 0.21171351f, -0.07164978f, 0.12347372f, 0.33913288f, 0.10309002f, 0.23968497f, -0.03754878f, 
    -0.17914538f, 0.10508239f, -0.05601060f, -0.07181957f, 0.02976293f, 0.09448101f, 0.04964471f, 0.10865855f, 
    0.24682710f, 0.13160208f, -0.08294788f, 0.05964506f, -0.14328325f, -0.27063358f, 0.03679333f, 0.00370977f, 
    -0.36381415f, -0.23980594f, -0.27433670f, 0.04773286f, -0.00995657f, 0.01792718f, 0.13339691f, -0.00177282f, 
    -0.04023823f, -0.03473360f, 0.03950773f, -0.14790252f, 0.00585951f, 0.09294053f, -0.01614214f, -0.02584049f, 
    0.03484357f, 0.09144066f, 0.02178704f, -0.06829004f, -0.00206687f, 0.24869780f, -0.06008508f, -0.45636970f, 
    0.32771882f, -0.09332431f, -0.06251780f, 0.14771035f, 0.11657651f, 0.07089514f, 0.12354136f, 0.06305599f, 
    0.00816279f, -0.07421689f, 0.08897468f, -0.05913300f, -0.06551955f, -0.10844483f, 0.09455767f, 0.00165105f, 
    0.35786209f, -0.12200965f, 0.09210246f, -0.22777379f, -0.03735662f, -0.18403044f, 0.27773821f, -0.00857402f, 
    -0.09972443f, -0.02635566f, -0.00198723f, 0.08307979f, 0.09489754f, -0.05327708f, 0.01560469f, -0.03158425f, 
    -0.03979139f, -0.05264148f, 0.00001932f, 0.05229891f, -0.19227919f, -0.23746429f, -0.47628796f, -0.10908462f, 
    0.14708476f, -0.18978758f, 0.05601953f, -0.00691741f, 0.08562514f, -0.07196556f, -0.11365970f, 0.04804658f, 
    0.02506014f, -0.03842794f, 0.08511309f, 0.03342511f, -0.08193379f, 0.21102402f, 0.14181997f, 0.10487893f, 
    0.20021093f, 0.28431475f, -0.44536784f, -0.22824322f, 0.35156462f, -0.16986717f, 0.15643589f, 0.09348053f, 
    0.10417319f, -0.06800453f, -0.05448776f, 0.05198283f, 0.00063718f, 0.02591264f, 0.04728083f, 0.03982388f, 
    -0.12429465f, -0.02300311f, 0.15038951f, -0.11801761f, 0.43574831f, 0.43210205f, 0.12445796f, -0.03367618f, 
    0.12484372f, 0.01305997f, 0.16230386f, -0.06729168f, 0.17926711f, 0.07634355f, -0.07380701f, -0.01878999f, 
    0.17830119f, 0.00675404f, 0.18023147f, -0.06053149f, 0.05510099f, -0.08187503f, -0.05450221f, -0.07948639f, 
    -0.00609386f, 0.40680721f, -0.19453718f, -0.10779877f, 0.07080262f, -0.01750918f, 0.08325433f, 0.22650082f, 
    0.16152449f, 0.10719457f, 0.17926700f, 0.06916589f, 0.18675688f, 0.13353026f, -0.04740601f, 0.16996016f, 
    -0.01682285f, 0.00220073f, 0.15515882f, 0.07269446f, -0.50056148f, -0.22025232f, -0.03966819f, 0.01192037f, 
    -0.10950080f, 0.11673206f, -0.02850765f, -0.02935130f, 0.11622971f, 0.05800224f, -0.02778865f, -0.01975117f, 
    0.04918984f, -0.01693161f, -0.00151682f, -0.11753787f, -0.07824425f, 0.05814926f, -0.03145242f, -0.04777508f, 
    0.21021855f, -0.45004031f, 0.16899082f, -0.26529685f, 0.20271687f, -0.15486071f, -0.03814588f, 0.10949117f, 
    0.16377811f, -0.08562787f, -0.10957799f, -0.01926893f, -0.08169545f, -0.00345275f, 0.15351485f, -0.07992211f, 
    0.03070519f, 0.00467063f, 0.20178474f, -0.11070709f, 0.17987257f, 0.05753152f, -0.02200386f, -0.23378830f, 
    0.68711084f, -0.13515078f, 0.13625300f, 0.23116907f, 0.11020257f, 0.04795117f, 0.04914825f, 0.04979854f, 
    -0.11277696f, 0.00617582f, 0.03925701f, -0.13101275f, -0.17917819f, 0.00205120f, 0.05505009f, -0.12561274f, 
    0.04486819f, 0.03539654f, -0.01187256f, -0.01459003f, -0.02323653f, -0.03706447f, 0.01748091f, -0.03613678f, 
    -0.05719450f, -0.05915535f, 0.00954961f, -0.00509916f, -0.04641888f, -0.02497570f, -0.04261963f, 0.01389495f, 
    -0.05050607f, 0.00899816f, 0.00464165f, 0.03191793f, 0.02057595f, -0.02487024f, 0.02525674f, -0.00220587f, 
    0.04449931f, 0.02826140f, -0.00849753f, 0.04734616f, -0.00057253f, 0.01460604f, -0.01350308f, -0.03082557f, 
    0.02871604f, -0.03514273f, -0.00268172f, 0.01785508f, -0.02385285f, -0.05590321f, -0.03182405f, 0.03502159f, 
    -0.00258724f, 0.04110807f, 0.01013870f, 0.00207124f, 0.01007158f, 0.01723320f, -0.00195072f, -0.02412593f, 
    0.02281327f, -0.01275945f, 0.04160057f, -0.05104165f, -0.05900997f, -0.00071251f, 0.02555842f, 0.00199564f, 
    -0.03087680f, 0.00632880f, -0.00248012f, 0.01833895f, -0.04688611f, -0.05398403f, 0.03887242f, 0.02710461f, 
    -0.04738146f, -0.02752174f, 0.00571524f, 0.04267688f, -0.02453607f, -0.05273516f, -0.00094504f, -0.05725440f, 
    -0.02799844f, -0.04641436f, -0.02190469f, 0.00718238f, -0.05534215f, -0.03235866f, -0.04163124f, 0.01004746f, 
    -0.04179015f, 0.01843688f, -0.00350714f, 0.03720234f, 0.02209111f, -0.04874455f, 0.00411067f, 0.03402873f, 
    0.03444720f, 0.00217227f, 0.04964299f, 0.01780638f, 0.01496068f, -0.04861223f, -0.02532147f, -0.01607896f, 
    0.02676394f, 0.04167656f, -0.06170196f, 0.01554887f, -0.04674700f, -0.01226343f, -0.05348367f, -0.02403209f, 
    -0.01909844f, -0.04760001f, -0.04103490f, 0.00824597f, 0.03874137f, -0.00037228f, -0.03989809f, -0.04290899f, 
    -0.00190430f, 0.04568977f, 0.03513112f, 0.00628931f, -0.05770589f, -0.02449274f, 0.00350321f, 0.00444286f, 
    -0.00642647f, -0.04496743f, -0.01469298f, -0.01709169f, 0.00162690f, 0.01571738f, -0.02885817f, -0.04975317f, 
    -0.01283014f, -0.03988395f, -0.02086214f, -0.05177676f, -0.00001762f, -0.05734276f, -0.00068113f, 0.02434989f, 
    -0.02904094f, 0.02303677f, 0.02576231f, -0.05943926f, -0.04465521f, 0.03121160f, 0.00838746f, 0.02314064f, 
    0.01769466f, 0.02916941f, 0.00506377f, -0.05173400f, -0.03280183f, -0.02531390f, -0.02658437f, 0.03842415f, 
    -0.04414267f, -0.03948784f, 0.02507042f, 0.02749190f, -0.00134490f, 0.00020067f, 0.04154596f, -0.04721583f, 
    -0.00460434f, -0.04732057f, 0.01208324f, -0.00071407f, -0.03698765f, 0.00322614f, -0.05746474f, 0.00557030f, 
    -0.01252372f, -0.04698861f, 0.01968723f, -0.04653579f, -0.02814302f, -0.06062889f, 0.03648837f, 0.00935777f, 
    -0.02084517f, -0.03110554f, -0.05099688f, 0.01046929f, 0.04343654f, -0.04923627f, 0.03828440f, 0.00049502f, 
    0.02003431f, 0.00409030f, 0.00412471f, 0.02407125f, -0.01326387f, 0.01272864f, 0.00810426f, -0.01858707f, 
    -0.01571953f, 0.02938167f, 0.01850799f, 0.04187129f, 0.03276825f, -0.03890281f, 0.00645360f, -0.03923665f, 
    0.03408415f, -0.03032915f, 0.04592609f, -0.01170295f, 0.01339812f, 0.00131956f, 0.01717458f, 0.04577358f, 
    -0.00071150f, -0.03328675f, -0.04676016f, -0.05595457f, -0.03087779f, 0.04771946f, -0.05246190f, -0.02518819f, 
    0.03561667f, -0.02754283f, 0.04901461f, -0.04232399f, 0.02511043f, -0.05197555f, 0.01494916f, -0.03574962f, 
    -0.04967758f, 0.01262285f, -0.04333914f, 0.01914817f, 0.01155239f, 0.00024134f, 0.03963761f, -0.00557109f, 
    -0.05214420f, -0.02677789f, -0.02854465f, -0.03152097f, 0.03986409f, 0.03195022f, -0.04227089f, 0.03311193f, 
    -0.03147292f, -0.00137048f, -0.02528156f, -0.02593872f, 0.04738960f, -0.01716786f, 0.01007981f, -0.04327394f, 
    -0.00381512f, 0.03204513f, 0.02543295f, -0.02130006f, 0.03220522f, -0.04241147f, -0.03836481f, -0.04558852f, 
    -0.00904274f, -0.00225420f, -0.01932835f, 0.03963242f, -0.00762563f, -0.01349673f, 0.01655377f, -0.01599484f, 
    -0.05362549f, -0.03332292f, -0.00008854f, -0.05437684f, 0.03235269f, -0.00203096f, 0.00622333f, -0.05052321f, 
    0.01379383f, -0.02381206f, -0.00700010f, 0.02960413f, -0.06025249f, 0.04673193f, 0.04472365f, -0.05323427f, 
    -0.03447904f, -0.02341264f, 0.00922474f, -0.05225257f, 0.02299707f, 0.00235173f, -0.04750559f, -0.04569756f, 
    0.04047392f, -0.05277737f, 0.03722448f, -0.04536197f, 0.04020435f, -0.05057244f, 0.00097311f, -0.00167774f, 
    -0.04536058f, 0.01200124f, -0.00332293f, -0.02341186f, -0.01639806f, 0.01606124f, 0.03854285f, -0.02979412f, 
    -0.04816221f, -0.05683920f, 0.01938567f, -0.04478990f, 0.04363168f, -0.02644918f, 0.02922421f, -0.01398811f, 
    0.04026478f, -0.01861424f, -0.01097600f, -0.03244638f, -0.01526977f, 0.02466927f, -0.03108533f, -0.04405708f, 
    -0.25132993f, -0.26109293f, -0.27741727f, 0.09924984f, -0.11553401f, -0.04478829f, 0.07745545f, 0.00563934f, 
    -0.01746230f, -0.08360405f, 0.06571788f, -0.14147905f, 0.00624423f, 0.03316230f, 0.02739043f, -0.07070518f, 
    0.17271888f, 0.04102666f, 0.04937302f, 0.18520503f, 0.21477945f, 0.06423945f, 0.35308895f, 0.11050805f, 
    -0.02684463f, -0.04228826f, 0.06362440f, -0.10969377f, -0.03046630f, -0.09485565f, 0.02412875f, -0.04472657f, 
    0.04224782f, 0.14783284f, 0.04985571f, 0.14295337f, -0.00819101f, 0.15692076f, 0.20383698f, 0.07683004f, 
    0.09241313f, -0.05778677f, 0.25744051f, 0.02301983f, -0.11200795f, -0.12334710f, -0.03518321f, -0.08871966f, 
    -0.05534035f, -0.00660654f, -0.06803843f, 0.00320941f, -0.00034385f, 0.15414451f, 0.00539359f, -0.06638980f, 
    -0.03093009f, 0.14676580f, 0.12761016f, -0.00959548f, -0.16005126f, 0.19073421f, 0.06152146f, 0.14046168f, 
    -0.05690740f, 0.14034878f, 0.07039216f, 0.14694603f, 0.17773430f, 0.18405329f, -0.03173894f, 0.04597379f, 
    0.03463094f, -0.04974258f, -0.06688563f, 0.02957519f, -0.03500652f, -0.18210389f, 0.07387126f, 0.05932669f, 
    -0.21240520f, 0.08610946f, 0.08750830f, 0.16454594f, 0.00263805f, 0.22273044f, -0.07428893f, 0.18829587f, 
    0.15639156f, 0.04158758f, -0.03171390f, 0.03468997f, -0.01279086f, -0.05681065f, 0.02419388f, 0.02913941f, 
    -0.17762883f, -0.22129072f, -0.08306583f, -0.09821209f, 0.18191646f, -0.00700003f, 0.08916263f, 0.16995476f, 
    0.05644119f, -0.02728599f, -0.03683174f, -0.04320638f, -0.10591092f, -0.16924252f, 0.16641718f, 0.21503079f, 
    0.01235658f, 0.12513870f, 0.17035329f, -0.01992730f, -0.14156894f, 0.15685844f, -0.05189324f, -0.31403095f, 
    -0.03331603f, -0.02888628f, -0.04986203f, 0.09563736f, -0.10813496f, 0.20732787f, 0.09268521f, 0.12896495f, 
    -0.06518108f, 0.05640301f, 0.00639313f, -0.00114892f, 0.08179385f, -0.00978068f, 0.04304015f, 0.14383830f, 
    -0.02153968f, -0.09137586f, -0.09944811f, -0.29578701f, -0.16222897f, -0.15945558f, -0.29496115f, -0.09474470f, 
    -0.11262935f, -0.16168977f, 0.03774865f, 0.11992695f, 0.16177948f, 0.10067730f, 0.13244674f, 0.13752097f, 
    0.16719316f, 0.07236829f, -0.02840344f, -0.12776396f, -0.05024122f, -0.04862460f, -0.00376278f, 0.01826183f, 
    0.11399528f, -0.07604763f, -0.02235046f, 0.03311133f, 0.04090291f, -0.22536279f, 0.01624654f, -0.05635231f, 
    0.01127608f, -0.06648155f, -0.05040703f, 0.05173953f, 0.05587757f, 0.29697162f, 0.01054272f, 0.06971149f, 
    0.02011285f, 0.13936834f, 0.11338352f, 0.20044908f, -0.05199682f, 0.00667413f, 0.02886155f, 0.19614357f, 
    -0.01448402f, 0.13161105f, -0.02512010f, -0.01839851f, 0.09935438f, 0.02033953f, -0.10980178f, -0.00635205f, 
    -0.06274004f, -0.12720571f, 0.02583957f, -0.07964501f, -0.03179215f, 0.05300603f, -0.18443458f, -0.06785059f, 
    -0.25079784f, -0.00108860f, -0.13624407f, 0.01477941f, -0.17830405f, 0.08072577f, 0.12428387f, 0.05898898f, 
    -0.00074991f, 0.16086420f, -0.14153172f, -0.02432845f, -0.02697922f, -0.12293068f, -0.05468443f, -0.04229150f, 
    0.06043491f, -0.01668115f, -0.07309575f, 0.08116622f, -0.00265870f, 0.28258997f, 0.21238586f, 0.04938305f, 
    0.25537378f, 0.08846381f, -0.13581362f, -0.01771446f, 0.26130694f, -0.12617967f, -0.01160136f, 0.05548032f, 
    0.10673779f, 0.03452277f, 0.03784088f, 0.05940222f, 0.09038537f, 0.00921518f, 0.13278049f, 0.01909836f, 
    0.22148497f, 0.12103555f, 0.14898992f, 0.26244771f, 0.15433648f, 0.27084690f, 0.22098392f, 0.05410372f, 
    0.15473533f, 0.21219043f, 0.06684578f, 0.10474554f, 0.09229109f, 0.22298701f, 0.13614590f, 0.17659248f, 
    0.17908788f, 0.24607544f, 0.14129795f, 0.13410886f, -0.40009201f, -0.16895543f, -0.14467396f, 0.26558220f, 
    0.00182450f, -0.13294895f, -0.00047186f, 0.03266784f, 0.05954884f, -0.18426661f, 0.08384525f, 0.01235297f, 
    0.08260312f, -0.04853036f, -0.08081067f, -0.07077585f, 0.17800334f, 0.08799819f, 0.23688428f, 0.22213353f, 
    0.05682264f, -0.21907057f, 0.36973754f, -0.00125116f, -0.13273996f, 0.13168100f, -0.02304655f, -0.07384004f, 
    0.14960173f, -0.15960760f, -0.15768875f, 0.07339422f, -0.00827179f, 0.03393101f, 0.09221216f, 0.02889764f, 
    0.01141613f, 0.12206303f, 0.00290139f, 0.15614648f, -0.08483110f, 0.09102131f, 0.23161840f, -0.14637695f, 
    -0.13894485f, -0.04380012f, -0.14079253f, 0.06957162f, -0.05067142f, -0.06559695f, 0.00474161f, 0.04915266f, 
    0.09022406f, -0.16751374f, -0.06698740f, -0.18075633f, -0.21816148f, -0.03177101f, -0.02124168f, -0.10919209f, 
    0.13154203f, 0.26877287f, 0.18931985f, -0.00733237f, 0.05111330f, -0.11501713f, 0.01753960f, -0.12103564f, 
    0.01805205f, 0.14302410f, -0.05260237f, -0.00744739f, 0.05411018f, 0.09199230f, 0.00879010f, -0.00933287f, 
    0.11458086f, 0.02220443f, 0.12239579f, 0.24472848f, -0.29981703f, -0.23787892f, -0.14604178f, -0.09469005f, 
    -0.19684185f, 0.10919379f, -0.11924434f, 0.08537015f, 0.00669726f, -0.04404342f, -0.04408694f, -0.05876961f, 
    -0.05507661f, 0.00714703f, 0.01438006f, -0.12384862f, 0.12569803f, 0.09772279f, -0.07960867f, 0.10362282f, 
    -0.21842650f, -0.22741140f, -0.11490710f, -0.11120935f, -0.03610865f, -0.09021882f, -0.08196484f, -0.01411134f, 
    -0.09858628f, -0.13609512f, -0.11454558f, 0.04890955f, 0.03081996f, -0.12125996f, -0.01152790f, -0.03332314f, 
    0.04858725f, -0.07010302f, 0.00758506f, 0.03363914f, 0.28070551f, 0.41144159f, 0.08532622f, -0.13049966f, 
    0.20929106f, 0.08016063f, 0.28996173f, 0.16451108f, -0.01812451f, 0.07214852f, 0.01629203f, 0.06767144f, 
    -0.00578460f, -0.09233293f, 0.00805245f, 0.00518404f, -0.01070469f, -0.24284635f, -0.04140985f, -0.14173587f, 
    0.10089643f, 0.49008486f, 0.14530858f, -0.02104931f, 0.18120570f, 0.17465183f, 0.22942658f, 0.22222212f, 
    0.13151489f, 0.09545710f, 0.00775080f, 0.03384766f, -0.06585836f, -0.13195433f, 0.04941602f, -0.00186200f, 
    -0.13313258f, -0.13355386f, -0.25881016f, -0.18091999f, 0.11200767f, -0.16932435f, 0.14178802f, -0.00629913f, 
    -0.10489796f, -0.09658785f, -0.17542206f, -0.09302704f, -0.03664722f, -0.08410187f, -0.06662232f, 0.10209424f, 
    -0.07840996f, -0.00265608f, -0.04445227f, 0.06096964f, -0.14883138f, 0.02345039f, -0.03733298f, -0.07517531f, 
    0.24846688f, 0.34038270f, 0.13412052f, -0.06577080f, -0.03327807f, 0.23699440f, 0.10032727f, 0.13422690f, 
    0.02060444f, 0.20828380f, 0.00639425f, -0.03386659f, -0.06537841f, -0.00977197f, 0.02699731f, 0.03706446f, 
    -0.09389392f, -0.11673578f, -0.18248826f, -0.16385916f, 0.18504620f, 0.01974715f, -0.51299912f, -0.13451093f, 
    -0.01622108f, -0.14829917f, -0.04856272f, 0.12143985f, -0.11848909f, 0.13919200f, 0.01632281f, 0.01421622f, 
    -0.06770147f, -0.05409041f, 0.08566509f, 0.05686516f, 0.01536502f, 0.10163285f, 0.00044296f, 0.01127162f, 
    -0.15282190f, -0.07951052f, -0.01675483f, 0.09051705f, -0.11757723f, -0.21225710f, -0.06550939f, -0.04246311f, 
    -0.10892640f, -0.06952392f, 0.04737607f, 0.06348523f, 0.12739420f, 0.18997261f, 0.17492092f, 0.04391128f, 
    0.13700601f, 0.23334730f, -0.01002159f, 0.10887925f, 0.28376698f, 0.42100087f, 0.12603554f, -0.17819509f, 
    0.14390533f, 0.09625566f, 0.18538971f, 0.20409380f, 0.09337389f, 0.01686299f, -0.02035338f, 0.01385932f, 
    -0.13973074f, -0.16078700f, 0.01952934f, 0.03902175f, -0.01741485f, -0.08616021f, -0.10270566f, -0.18581967f, 
    0.11262160f, 0.25434014f, 0.03706252f, -0.01119493f, 0.06956439f, -0.02118197f, 0.37742803f, 0.22189748f, 
    0.13894582f, 0.06097247f, 0.00272923f, 0.02858756f, 0.00070405f, 0.02778737f, -0.07472226f, 0.12611055f, 
    0.16714624f, -0.07882608f, 0.02224066f, -0.09621450f, -0.59383100f, -0.08319177f, -0.00364135f, 0.19161592f, 
    -0.02565016f, -0.10686457f, -0.05875671f, 0.05587747f, 0.00045078f, -0.07054637f, -0.11365646f, -0.05110738f, 
    0.01713286f, -0.11478200f, 0.08125278f, 0.00423861f, 0.11498243f, -0.03879967f, 0.10015385f, 0.11474890f, 
    -0.30169401f, 0.05323949f, 0.30361426f, -0.05947024f, 0.14349626f, 0.07889510f, -0.01714138f, -0.03013237f, 
    0.06959880f, 0.07538661f, 0.03878047f, 0.02029564f, 0.11896624f, -0.08391079f, 0.13600175f, 0.12030525f, 
    0.01598319f, 0.03909363f, 0.07915600f, -0.00843310f, 0.15509135f, 0.34683946f, -0.16377138f, -0.03797435f, 
    0.13117971f, -0.02405777f, -0.07414971f, 0.08464345f, 0.06154765f, 0.08361871f, -0.12424362f, 0.08880213f, 
    0.00271091f, -0.00879594f, 0.04631153f, -0.01252094f, 0.11980208f, 0.06230587f, 0.08302826f, 0.26090449f, 
    -0.15553053f, -0.02256859f, -0.03282114f, 0.08820122f, -0.27364540f, 0.01233068f, -0.03653946f, 0.09903581f, 
    0.13566948f, 0.13204500f, -0.10826217f, -0.01669623f, 0.01765984f, 0.03250026f, 0.06136328f, 0.01838862f, 
    0.10308692f, 0.07292691f, 0.11795234f, -0.05168725f, 0.53531593f, 0.21893179f, -0.18818913f, 0.16417633f, 
    0.08513056f, -0.03173868f, 0.08525621f, 0.09726131f, -0.13438779f, 0.03914643f, 0.20162332f, 0.01368276f, 
    -0.00381689f, 0.01153801f, -0.13068400f, 0.08398092f, -0.08846247f, -0.05900089f, -0.05519357f, -0.13391380f, 
    0.01969252f, -0.01298055f, 0.00728873f, -0.00935584f, -0.03592350f, 0.00306123f, 0.00204766f, -0.00060687f, 
    -0.00415946f, 0.04344935f, -0.03867631f, -0.04097030f, 0.05242855f, -0.05444533f, -0.01403600f, 0.01487834f, 
    -0.06597351f, -0.00898420f, 0.04418532f, 0.01610109f, -0.02583015f, -0.05642825f, 0.01012829f, 0.02927601f, 
    -0.05521276f, -0.00557432f, -0.00548424f, -0.06854838f, -0.02013623f, -0.06027935f, 0.00058267f, -0.01749770f, 
    0.01085510f, -0.04534241f, -0.02200892f, -0.02901476f, 0.03489684f, -0.06143345f, 0.02788675f, 0.00369967f, 
    0.03518603f, -0.01646716f, -0.02966207f, -0.02813215f, -0.04606489f, 0.00208013f, -0.05940978f, 0.01795870f, 
    -0.06104674f, -0.04424410f, 0.02731446f, 0.03479107f, -0.04322436f, -0.01604498f, 0.04479683f, 0.00624987f, 
    -0.02624554f, 0.00678215f, 0.00110237f, -0.01434915f, -0.02899998f, 0.00943404f, 0.01307784f, -0.02820558f, 
    0.04575950f, 0.02541050f, 0.04022886f, 0.00718925f, -0.00600129f, 0.03061039f, -0.04412945f, -0.06002458f, 
    -0.01243086f, -0.01565215f, -0.00902389f, 0.03692633f, -0.00651146f, -0.01181863f, -0.03421810f, 0.03330311f, 
    0.01391987f, -0.00700107f, 0.01528576f, 0.00989026f, 0.02987757f, 0.02480770f, -0.02087945f, -0.05229504f, 
    -0.03724234f, 0.00779296f, 0.02184634f, -0.05391631f, -0.00598895f, -0.02945139f, -0.02986594f, -0.00298937f, 
    -0.04481873f, -0.01710456f, -0.01452954f, -0.00565394f, -0.02940865f, 0.00419695f, -0.06581750f, -0.01923778f, 
    0.03285893f, 0.02491692f, -0.00767783f, 0.02234020f, -0.05850791f, 0.00687342f, 0.01032549f, 0.00102985f, 
    -0.01244510f, -0.03311376f, -0.00057253f, 0.01368173f, -0.01261980f, 0.02365183f, -0.05043763f, -0.01750234f, 
    0.04860650f, -0.04429984f, -0.02433484f, -0.00363214f, -0.03385210f, 0.02031127f, 0.02833074f, 0.02582687f, 
    0.02113508f, 0.01272765f, -0.02272361f, 0.02995608f, -0.03342131f, 0.03157125f, -0.06166621f, -0.02258751f, 
    -0.02114403f, -0.04038979f, -0.03686005f, -0.02643998f, -0.04356931f, -0.01554753f, 0.00733227f, 0.01007422f, 
    -0.03849332f, -0.04295626f, -0.04987188f, -0.04250151f, 0.00159487f, -0.01441959f, 0.03999059f, 0.02538068f, 
    -0.02550075f, 0.04986674f, -0.00403084f, 0.03700043f, 0.04210766f, -0.01648590f, 0.03924868f, 0.01871442f, 
    -0.00979712f, 0.00857383f, 0.03310990f, -0.02086652f, 0.01777721f, -0.03926828f, -0.00267235f, -0.03261657f, 
    -0.03291577f, 0.02034955f, 0.05256741f, 0.03433264f, 0.04745134f, 0.02051296f, -0.03273362f, 0.01247902f, 
    0.04599851f, 0.04112371f, -0.05018342f, -0.03502055f, 0.06665772f, -0.02099755f, 0.00885837f, -0.05388592f, 
    0.04333397f, 0.01799699f, 0.06004705f, -0.03485288f, -0.00419983f, -0.02776359f, 0.01987532f, -0.04809285f, 
    -0.01975816f, -0.00323905f, -0.05416162f, 0.00920749f, 0.01204624f, 0.04004612f, -0.02183548f, 0.03183188f, 
    -0.00364554f, 0.02044098f, 0.03812569f, 0.02591981f, -0.03245514f, -0.01325876f, -0.01546559f, -0.04194826f, 
    -0.03433182f, 0.02793859f, 0.00223028f, 0.01010298f, -0.00976707f, 0.00017347f, -0.00685832f, 0.01784732f, 
    0.02332885f, -0.04707184f, -0.01187254f, -0.04803732f, -0.06132908f, 0.04029362f, -0.04342930f, 0.01575303f, 
    -0.02804643f, -0.06506883f, -0.00622115f, -0.04993796f, -0.01792422f, 0.03034342f, -0.02338470f, 0.00552697f, 
    0.04060644f, -0.05021285f, -0.05079158f, 0.01483587f, -0.04555842f, -0.01681776f, -0.00480567f, 0.00408570f, 
    -0.05861562f, 0.00261449f, 0.01892164f, -0.03816520f, 0.02993461f, -0.00843769f, 0.04403706f, 0.02880109f, 
    0.01954275f, 0.00495776f, 0.03277816f, -0.05758466f, 0.03390945f, -0.02288969f, -0.00340112f, -0.05146544f, 
    0.02060177f, 0.03481776f, 0.00372503f, 0.02057201f, 0.05452557f, -0.02429566f, 0.00197577f, 0.01336010f, 
    0.04285639f, -0.00362515f, -0.04862924f, -0.01214064f, -0.04487566f, -0.05315933f, 0.01640252f, -0.04249156f, 
    0.04861949f, -0.05179961f, 0.02459148f, 0.00895546f, -0.05605623f, -0.03290729f, -0.06112832f, 0.00754805f, 
    -0.03067784f, -0.02262783f, -0.04283237f, 0.02689604f, 0.02167193f, -0.04804045f, 0.01212384f, -0.00049477f, 
    -0.06150088f, -0.00243910f, -0.00421618f, -0.05015570f, 0.03030251f, -0.02846429f, -0.00902323f, -0.04977435f, 
    0.04235433f, -0.06566586f, 0.02730836f, 0.01704434f, 0.01402992f, 0.01901563f, 0.01880151f, -0.01479423f, 
    0.01285230f, -0.00175758f, -0.02241850f, -0.00630316f, -0.03264727f, 0.04104427f, -0.00113286f, -0.04931732f, 
    0.02821266f, 0.02728340f, 0.04480521f, -0.01857298f, 0.01192247f, 0.04510371f, 0.03375496f, 0.00880571f, 
    -0.20584689f, -0.13348188f, 0.03666830f, 0.02824629f, -0.02208417f, -0.03799994f, 0.03696913f, -0.17611486f, 
    -0.09767433f, 0.09044868f, 0.03131734f, 0.04310652f, 0.02622467f, -0.04638709f, 0.02495559f, -0.04965346f, 
    -0.10602652f, -0.03311680f, -0.03277912f, -0.13279688f, 0.27456737f, 0.04493218f, 0.00057146f, 0.10409077f, 
    0.04367782f, 0.04213557f, 0.07379527f, 0.20490927f, 0.08604500f, -0.09869567f, -0.05319475f, 0.03737558f, 
    0.05579540f, -0.02612679f, 0.02097097f, 0.14522424f, -0.02383841f, 0.17184743f, 0.02972065f, 0.10208472f, 
    0.07559182f, 0.07284079f, -0.05201280f, -0.07300165f, -0.06950665f, -0.10617229f, -0.04131837f, 0.02154243f, 
    -0.06929751f, -0.01342558f, -0.04872593f, -0.03652960f, -0.05192374f, -0.04678582f, -0.13870692f, 0.02858716f, 
    0.04105457f, -0.15346900f, -0.06967223f, -0.02174617f, -0.19289625f, -0.14814211f, -0.07046924f, 0.32215551f, 
    0.06482732f, -0.02872757f, -0.00373001f, -0.04028259f, -0.00023258f, -0.01356275f, 0.02325449f, -0.00710009f, 
    0.09882514f, 0.10772873f, -0.00173570f, 0.12379301f, 0.12886366f, 0.12576614f, 0.11072166f, 0.00002880f, 
    -0.07428612f, -0.31066194f, -0.04947384f, 0.34154987f, 0.07889915f, 0.03702069f, -0.07198299f, 0.07776669f, 
    -0.01153505f, -0.02330983f, -0.03170638f, 0.04858717f, 0.09460424f, 0.11124920f, 0.06141642f, 0.14927803f, 
    0.16955104f, 0.01557200f, 0.24821354f, -0.00938212f, -0.18276098f, 0.11554547f, -0.08363742f, 0.19792633f, 
    0.03240671f, 0.04180913f, -0.04195595f, -0.01721246f, -0.10109849f, -0.06527354f, 0.09550967f, -0.05959057f, 
    0.11096679f, -0.00883698f, -0.01428095f, 0.02590543f, 0.02422906f, 0.02565469f, 0.01882791f, -0.03060614f, 
    -0.01620180f, -0.11401190f, -0.26119331f, 0.06582507f, 0.22683577f, -0.06203980f, -0.03720734f, 0.04723942f, 
    0.01020898f, -0.13031614f, -0.01739359f, 0.06872644f, 0.10479515f, 0.12291664f, 0.13525756f, 0.14288540f, 
    0.06739466f, 0.15375374f, 0.05621781f, 0.00398874f, -0.29861563f, 0.14241625f, 0.34537417f, 0.22944388f, 
    -0.15899105f, -0.05907444f, -0.13468404f, -0.12746580f, -0.07356377f, 0.13600814f, 0.03487490f, 0.09610621f, 
    0.26121718f, -0.01817755f, -0.00731009f, -0.02145768f, -0.05880996f, -0.07943051f, -0.06259645f, -0.06427873f, 
    -0.12920751f, -0.24215230f, -0.01648672f, -0.10743699f, 0.02495955f, -0.08828568f, 0.02327622f, -0.04635350f, 
    -0.08825144f, -0.10946917f, 0.16732807f, 0.14270796f, 0.09302834f, -0.12421311f, 0.06374019f, -0.08806136f, 
    -0.07483736f, -0.06209453f, -0.07075945f, -0.01369375f, -0.28535658f, -0.13112640f, -0.06309813f, 0.38051552f, 
    0.10777321f, -0.20732842f, -0.25191718f, -0.13534531f, -0.18011823f, 0.00031334f, -0.04251328f, 0.01607244f, 
    0.13307568f, 0.10921562f, -0.01260868f, 0.07839746f, 0.07668184f, 0.13843839f, 0.12243299f, 0.06821369f, 
    -0.37431797f, -0.10357705f, 0.01127674f, 0.28710496f, 0.05719224f, -0.17370756f, -0.19395083f, -0.24088502f, 
    0.03832304f, 0.30638310f, -0.06657644f, 0.04840237f, 0.03223673f, -0.00667538f, -0.07458031f, -0.04836245f, 
    0.03611173f, -0.07173466f, 0.02163494f, -0.02366856f, 0.14647159f, -0.45795608f, -0.14987308f, 0.36109343f, 
    -0.12765808f, -0.03373441f, 0.10483363f, 0.12177849f, -0.28685099f, 0.06824019f, -0.06810626f, -0.08100948f, 
    -0.11290438f, 0.00903767f, -0.01394547f, 0.06465489f, 0.10915887f, 0.11710221f, 0.00597580f, 0.02399238f, 
    0.17135265f, 0.17309633f, 0.02256735f, 0.00947970f, 0.18800192f, 0.04176844f, 0.20318177f, 0.19258343f, 
    0.28626841f, 0.04392523f, 0.18785931f, 0.03804470f, 0.33387965f, 0.08126330f, 0.06954104f, 0.01099283f, 
    0.22863406f, 0.01513897f, 0.04688535f, 0.03748381f, -0.27933219f, -0.23393796f, -0.16295621f, 0.17315015f, 
    -0.17289902f, -0.02159286f, -0.17690058f, -0.05823283f, 0.01734018f, 0.15083615f, 0.02689497f, -0.05825127f, 
    0.01489234f, -0.01674979f, 0.02917915f, 0.03093295f, -0.09678820f, 0.07774848f, -0.10838832f, -0.15740460f, 
    0.42278761f, -0.06789741f, -0.13580260f, -0.01392234f, 0.30000412f, 0.19526169f, 0.26573917f, 0.30958301f, 
    -0.02647741f, 0.12762469f, -0.03129274f, -0.03893894f, -0.08050319f, -0.02755650f, 0.00915970f, -0.00870255f, 
    0.01635158f, -0.05120439f, 0.10565521f, 0.16366580f, -0.32551050f, 0.30670622f, 0.38577300f, 0.22115083f, 
    0.10381384f, -0.08976573f, -0.11843275f, -0.33247489f, 0.11393195f, -0.02509139f, -0.04592541f, -0.01415739f, 
    0.10638293f, 0.12285616f, 0.02122123f, 0.03414641f, -0.05245714f, -0.04279302f, -0.05306459f, 0.05642870f, 
    0.00668163f, -0.31360862f, -0.23636039f, 0.03699511f, 0.15272197f, 0.04695263f, 0.01214411f, 0.01543172f, 
    -0.07652310f, 0.06563126f, 0.09409541f, 0.17740071f, 0.03057356f, -0.06584203f, 0.06771225f, -0.02843294f, 
    -0.16423528f, 0.04500573f, 0.09819407f, -0.14088941f, -0.08851207f, 0.21914198f, 0.11805439f, 0.35869759f, 
    0.06912198f, -0.15954030f, 0.08396482f, -0.17273475f, 0.17912512f, 0.04871387f, 0.01427976f, 0.03243889f, 
    0.08901983f, -0.08649525f, 0.06903934f, -0.04923711f, 0.04371247f, -0.05291846f, 0.01632804f, 0.09864680f, 
    -0.00089990f, 0.13590664f, 0.13165194f, -0.00285768f, -0.19978277f, 0.03703415f, 0.15430076f, 0.09557860f, 
    0.04047678f, -0.03495447f, 0.01505049f, -0.04866287f, 0.04892811f, -0.04521047f, -0.00226778f, 0.07498193f, 
    0.13310146f, 0.01221077f, -0.17194134f, 0.11363968f, 0.02497852f, 0.07864843f, -0.25978059f, 0.05580088f, 
    0.12067340f, 0.02175802f, -0.06854501f, 0.08905329f, 0.17496651f, 0.13146457f, -0.15158845f, -0.07507932f, 
    0.05483965f, 0.12033418f, 0.04899374f, 0.03334690f, 0.06412967f, 0.10847110f, 0.13179365f, -0.04307937f, 
    0.23543341f, -0.11141973f, 0.12612416f, 0.05982009f, 0.03316050f, -0.01142759f, -0.07277898f, -0.06490185f, 
    0.02566451f, 0.05248716f, -0.03862491f, -0.03777219f, -0.00458700f, 0.13602088f, 0.10441850f, -0.01373453f, 
    0.15452348f, 0.18194437f, 0.08358330f, -0.02154087f, -0.04563167f, 0.12935595f, -0.07948221f, 0.01771165f, 
    -0.14283116f, 0.10845345f, 0.14090545f, 0.03023541f, -0.02343180f, 0.03918520f, -0.12349526f, -0.19797267f, 
    0.19940670f, 0.15907887f, -0.04710890f, 0.02159289f, -0.07255856f, -0.19438347f, 0.21497926f, 0.08664689f, 
    -0.09684353f, -0.30215225f, -0.10179289f, 0.08735057f, 0.41035190f, -0.14091079f, -0.24786276f, -0.11574416f, 
    0.03760200f, -0.12369809f, -0.04987141f, -0.01769547f, -0.04241822f, -0.06431260f, -0.03987627f, 0.03200444f, 
    -0.08434043f, 0.04689373f, 0.15356012f, -0.04920306f, -0.15058328f, -0.12916398f, -0.41644263f, 0.10232548f, 
    -0.09946425f, 0.14398557f, -0.02786862f, 0.15305322f, -0.01664792f, 0.04493537f, -0.05815990f, 0.08927427f, 
    0.19150259f, -0.00329702f, 0.05156735f, -0.02871366f, -0.00340018f, -0.02394983f, 0.04774525f, -0.00708952f, 
    0.16051102f, 0.14341599f, 0.01873493f, -0.07279188f, -0.06354043f, -0.07857682f, 0.18413779f, -0.22726414f, 
    0.14281961f, -0.02160928f, 0.10709851f, 0.01617201f, 0.24977547f, -0.13622984f, -0.07576290f, -0.10774087f, 
    0.02722759f, -0.12935765f, -0.03370989f, 0.09216384f, 0.06800058f, -0.12496577f, -0.19978584f, -0.08996420f, 
    0.11925868f, -0.12417132f, -0.17097522f, -0.13278414f, 0.04036092f, -0.02985533f, -0.08520910f, 0.04933983f, 
    0.03032782f, 0.04564977f, -0.01762310f, -0.08960490f, -0.03745527f, 0.07382125f, 0.07203873f, -0.00590967f, 
    0.43174991f, -0.29150179f, -0.07175833f, -0.36016825f, 0.19797979f, 0.16057527f, 0.04337103f, -0.19495399f, 
    -0.08385177f, 0.07229276f, 0.04413334f, 0.10398214f, 0.06254867f, 0.01018523f, 0.03028285f, -0.13712744f, 
    -0.10636888f, 0.04123767f, 0.06516211f, -0.12703842f, 0.11087769f, 0.51419139f, 0.33364105f, -0.17058733f, 
    -0.15041845f, 0.01374548f, 0.08383550f, 0.19525199f, 0.11963208f, -0.00576662f, -0.15463711f, 0.07503001f, 
    0.02306788f, 0.04501561f, 0.07722232f, -0.01198595f, 0.16390222f, 0.05018730f, -0.12631893f, -0.14587450f, 
    0.43141317f, -0.00488057f, 0.01825951f, -0.05728742f, 0.02861973f, -0.00133763f, 0.22686341f, 0.01189602f, 
    0.06227036f, -0.30379206f, 0.03633359f, -0.11008553f, -0.00754959f, -0.00079113f, -0.03322517f, -0.05304021f, 
    0.07947139f, 0.15985382f, -0.07580012f, -0.08361834f, -0.22841698f, -0.29950598f, 0.12540899f, 0.24152315f, 
    0.02522538f, 0.00571682f, -0.01045752f, 0.18380190f, 0.09604002f, 0.12647337f, -0.21066660f, 0.08005942f, 
    -0.13645598f, -0.00175417f, 0.04625680f, -0.06304362f, -0.07260244f, 0.21033402f, -0.03678899f, -0.29637173f, 
    0.66346306f, 0.26592937f, 0.45451611f, -0.03000427f, 0.01499158f, -0.00860179f, -0.03335567f, -0.08911646f, 
    0.04988773f, -0.05307623f, -0.05176527f, -0.02320340f, -0.02864573f, 0.00191101f, -0.06005726f, -0.14723137f, 
    0.09284696f, -0.18609767f, -0.05557308f, 0.14178073f, 0.01447585f, 0.01794651f, -0.17195143f, -0.28082266f, 
    -0.06755636f, 0.26459548f, 0.28445402f, 0.12874749f, 0.00162749f, 0.05677562f, -0.16234724f, -0.10727702f, 
    0.09444107f, 0.21366306f, 0.10704996f, -0.10214965f, 0.04074831f, -0.11953604f, 0.00189175f, 0.07660068f, 
    0.04908978f, -0.04585149f, 0.17299533f, 0.12204574f, 0.06916521f, -0.01429796f, -0.12607253f, -0.01330317f, 
    -0.11654373f, -0.16870460f, -0.03389206f, 0.08497892f, -0.13071625f, -0.21897693f, -0.05618363f, 0.00689825f, 
    -0.07407834f, -0.18082626f, -0.17173855f, -0.13068871f, 0.33897176f, 0.03378602f, -0.15016420f, 0.16315588f, 
    0.25342953f, -0.02251617f, 0.16502199f, 0.07466843f, -0.00771044f, 0.03260023f, -0.06910523f, 0.03034293f, 
    0.01536230f, -0.04890971f, -0.08466402f, 0.16537419f, -0.06485364f, 0.08997789f, -0.06452557f, -0.22589414f, 
    -0.04691210f, -0.10837578f, -0.08104067f, 0.04290788f, 0.09567247f, -0.14093363f, -0.00562152f, -0.21223190f, 
    -0.02561295f, 0.13117339f, -0.05931483f, -0.01728513f, 0.01481675f, 0.11831184f, -0.09950837f, -0.06424880f, 
    0.02073799f, 0.12806648f, -0.08510622f, -0.07013633f, -0.20074344f, -0.21938667f, 0.19113307f, 0.11946850f, 
    -0.19993573f, 0.08473412f, -0.09806247f, -0.02136314f, -0.16126460f, -0.09942184f, -0.05472511f, 0.07691223f, 
    -0.06508510f, 0.10974073f, 0.07845459f, 0.16969782f, 0.04192218f, 0.22237991f, 0.01655208f, 0.00820379f, 
    -0.15996972f, -0.33981162f, 0.25173435f, 0.01062913f, -0.05792904f, -0.12956905f, -0.03042398f, 0.05771126f, 
    0.09517305f, 0.01418741f, -0.12288786f, -0.03562203f, -0.05957937f, 0.11142799f, -0.06795345f, 0.10137863f, 
    0.20922685f, 0.09832856f, 0.16849807f, 0.13441585f, -0.24478844f, 0.16313943f, -0.25641063f, -0.07477697f, 
    -0.00431333f, -0.02325404f, -0.06445674f, 0.07499391f, -0.15512869f, 0.05960783f, -0.04086582f, 0.06720666f, 
    -0.00153273f, 0.22320931f, 0.02400628f, -0.19212739f, 0.16588804f, 0.30426511f, -0.02324305f, 0.26878649f, 
    0.18214087f, -0.06020428f, 0.22924261f, 0.09377783f, 0.08444978f, 0.03032398f, 0.16722122f, 0.07621646f, 
    0.25041300f, -0.04956429f, -0.00815443f, 0.06353573f, 0.03773988f, -0.05233464f, -0.02522506f, 0.09653944f, 
    0.08850046f, 0.06174054f, 0.31879658f, 0.22999355f, -0.18235375f, 0.12691461f, 0.19151881f, 0.25214860f, 
    -0.00985088f, 0.02724377f, -0.05775681f, -0.15474272f, 0.02903911f, 0.02784103f, -0.06306688f, 0.03160662f, 
    0.01609521f, 0.03202134f, 0.04557001f, -0.07774904f, -0.07817032f, -0.04653851f, -0.04262115f, -0.10115348f, 
    -0.08709285f, 0.13495979f, 0.07035986f, 0.25650069f, 0.04727065f, 0.23672977f, -0.31403747f, -0.04728993f, 
    0.16583702f, 0.15911262f, -0.05448687f, -0.02077392f, -0.11875009f, -0.02603227f, 0.01958347f, -0.21121702f, 
    0.03238166f, 0.08388703f, -0.00031797f, -0.13887686f, 0.02386381f, -0.20304073f, 0.24860853f, 0.01661060f, 
    -0.20318797f, 0.07987291f, 0.06416841f, -0.00487996f, -0.06357365f, 0.11550725f, 0.10643637f, -0.01085966f, 
    0.00185322f, 0.00768614f, -0.13896461f, -0.00022923f, 0.02917113f, -0.03593566f, 0.23630044f, 0.09214253f, 
    0.28241146f, -0.18785885f, 0.39648968f, 0.03542671f, -0.14723663f, 0.23563050f, -0.19203031f, -0.04143693f, 
    -0.02536860f, 0.08878127f, 0.08841626f, -0.04969119f, -0.06356094f, -0.20221390f, 0.03850670f, -0.07586291f, 
    -0.07514207f, 0.07043004f, 0.04662029f, -0.02741201f, 0.01965903f, -0.13413116f, 0.12955609f, 0.20351765f, 
    -0.30076557f, 0.01637101f, 0.06397837f, -0.03405377f, -0.05563593f, 0.21763401f, -0.02776160f, 0.16593242f, 
    -0.02262265f, -0.04986177f, 0.01813341f, 0.11195936f, -0.03233864f, 0.01488911f, 0.04600969f, 0.08579967f, 
    0.43850306f, -0.37180665f, 0.19703799f, 0.21104540f, 0.03084951f, -0.02121278f, 0.03233848f, -0.04262765f, 
    0.03968931f, 0.20038176f, -0.01429188f, -0.03808701f, 0.05351755f, 0.02352046f, 0.05618983f, 0.02832197f, 
    -0.05713248f, 0.00279005f, -0.13667138f, -0.02900133f, 0.09538881f, 0.08372571f, 0.14424203f, 0.36096042f, 
    -0.08000451f, -0.08202438f, 0.04657726f, -0.10803908f, -0.13282716f, -0.00261638f, 0.10086117f, 0.05550326f, 
    -0.09698345f, -0.10763955f, -0.05637063f, 0.02637960f, -0.11973263f, -0.01274378f, 0.10023800f, -0.23330855f, 
    -0.09363835f, 0.09627083f, 0.14340410f, 0.28090385f, 0.19085245f, 0.11258543f, 0.20286648f, 0.15017517f, 
    -0.01813565f, 0.21524675f, -0.04228158f, 0.04427205f, -0.10203216f, -0.10262723f, -0.07789596f, -0.00767312f, 
    -0.08000039f, 0.27699956f, -0.09061708f, 0.12936890f, -0.47350997f, -0.41574496f, 0.07475804f, -0.15717824f, 
    -0.15083060f, 0.13184102f, 0.07757854f, 0.03947417f, 0.16128525f, 0.06664665f, -0.16613075f, 0.02303391f, 
    0.17579114f, 0.19128199f, 0.18122670f, -0.13585167f, -0.06890808f, 0.12258327f, 0.14312810f, 0.21775968f, 
    0.09364222f, 0.15415980f, 0.08327164f, 0.01966975f, -0.08883069f, -0.04649583f, -0.11239190f, 0.12950017f, 
    0.12858196f, 0.01906078f, 0.00610311f, -0.00629650f, 0.04356810f, -0.05847685f, -0.04477217f, -0.00156029f, 
    0.03372660f, 0.07068706f, 0.05607054f, 0.04365869f, 0.08608267f, 0.08656544f, -0.12463192f, 0.01988920f, 
    0.03385390f, -0.08446092f, 0.13295498f, -0.04425193f, 0.05414644f, 0.00856620f, -0.03776338f, -0.00008782f, 
    -0.12977619f, 0.01425313f, 0.02412847f, -0.00582093f, 0.23517235f, -0.00822550f, 0.03919333f, -0.01005932f, 
    -0.16543712f, -0.08508459f, -0.11704742f, 0.03532644f, 0.15421684f, -0.01272329f, 0.07804061f, -0.03471996f, 
    -0.03082513f, -0.04851646f, -0.07586908f, 0.01316434f, 0.02340415f, -0.00201487f, -0.07737910f, 0.04379204f, 
    0.06172996f, -0.11149423f, -0.11006089f, -0.03916153f, 0.18734151f, 0.26188779f, -0.01747344f, -0.03328097f, 
    -0.01637223f, 0.03431079f, 0.02283987f, 0.09747121f, 0.02059539f, 0.06890883f, 0.05648796f, -0.09583015f, 
    0.06037063f, 0.00761919f, 0.12096444f, 0.10667303f, -0.04242595f, -0.11070122f, 0.07688389f, 0.07839475f, 
    -0.29564908f, 0.23993918f, 0.11439645f, -0.01188573f, 0.05652757f, 0.11262257f, 0.07364320f, 0.13130338f, 
    0.04957012f, 0.05794922f, 0.07896925f, -0.01381847f, 0.10584256f, 0.04596366f, 0.07626528f, 0.03706750f, 
    -0.16329949f, -0.11973091f, 0.05060086f, -0.11148199f, -0.22538815f, -0.09246721f, 0.02849336f, 0.19543228f, 
    0.23371778f, -0.05299971f, -0.01239178f, 0.01273650f, -0.05797960f, -0.06741870f, 0.02512135f, -0.05252745f, 
    0.04417205f, 0.02114349f, 0.15058754f, 0.07304558f, -0.09341561f, 0.00133715f, 0.02578547f, -0.20506354f, 
    0.43436086f, 0.12866652f, 0.11621727f, -0.05791536f, -0.09969252f, 0.10144453f, -0.22267966f, 0.02027217f, 
    -0.02065258f, 0.10975578f, 0.06287294f, 0.01130142f, 0.09403032f, 0.07163838f, 0.13882671f, -0.03144781f, 
    -0.08724298f, 0.06169112f, -0.02056419f, -0.16894099f, -0.01280784f, -0.25569567f, -0.27537706f, 0.06522531f, 
    -0.42457259f, -0.00422112f, 0.00230664f, -0.01703219f, -0.04777385f, -0.03861570f, 0.10221662f, 0.04389814f, 
    0.08021747f, -0.03974641f, -0.02869636f, -0.02914000f, -0.04421902f, -0.02549793f, -0.08159267f, -0.04578163f, 
    -0.20629120f, -0.00324071f, -0.16537423f, -0.01475928f, 0.06728002f, -0.08118649f, 0.03949773f, -0.11372736f, 
    -0.01602907f, -0.04260793f, 0.20154302f, 0.16400802f, 0.01196814f, -0.02658138f, 0.00257638f, 0.08598793f, 
    0.07463598f, -0.02602697f, 0.01852938f, 0.01039258f, 0.10621706f, 0.18315236f, 0.20796515f, 0.08874100f, 
    -0.16071759f, 0.10957800f, -0.14631312f, 0.17588598f, 0.01169257f, 0.04468241f, 0.05351029f, -0.07100706f, 
    0.03957817f, -0.03091000f, 0.07287628f, 0.06396677f, 0.06595264f, 0.07858315f, 0.08962324f, -0.01801791f, 
    -0.48960638f, -0.29986092f, 0.08021946f, 0.03716404f, -0.40376672f, 0.00583878f, -0.01607374f, -0.01412457f, 
    -0.14854841f, 0.17685018f, -0.04463106f, -0.06081352f, 0.01444868f, -0.10101518f, -0.05330869f, 0.04796088f, 
    0.03982894f, -0.06240012f, 0.03463025f, 0.04733319f, -0.39690989f, -0.17216815f, -0.07198497f, 0.02924714f, 
    0.02732881f, 0.03310801f, -0.04370932f, 0.04350878f, -0.03087523f, 0.01703592f, -0.07758734f, -0.04597559f, 
    -0.07965575f, -0.02257019f, 0.03161347f, 0.13520482f, 0.14869036f, 0.02737138f, -0.06328389f, -0.00478626f, 
    -0.03641390f, -0.02955930f, 0.17839451f, 0.27075261f, 0.21373211f, 0.17642224f, 0.10324358f, 0.03605283f, 
    0.13189901f, -0.06399152f, -0.01883791f, 0.01845829f, 0.08129510f, -0.00627325f, 0.15908611f, 0.00881114f, 
    0.11794115f, 0.00555697f, 0.09516308f, 0.17803878f, 0.25210935f, 0.01355617f, -0.04965217f, -0.07969803f, 
    -0.06323363f, -0.16461167f, 0.01181298f, 0.06911518f, -0.04157138f, 0.00597242f, -0.12300439f, 0.06855554f, 
    -0.05292225f, -0.08941864f, -0.01082000f, 0.02550494f, 0.07369295f, 0.18989114f, -0.04109580f, 0.05420436f, 
    0.38085443f, 0.59967411f, -0.02923865f, 0.07935256f, -0.21112746f, 0.17322287f, 0.05455310f, -0.05085175f, 
    0.08041129f, 0.02809591f, -0.14626047f, 0.02025396f, -0.03532013f, 0.01144385f, -0.00442993f, 0.12527184f, 
    0.11599554f, 0.08459962f, 0.10547464f, 0.09484129f, 0.08113249f, 0.01997849f, -0.30242181f, 0.23268634f, 
    -0.59477991f, 0.07011449f, -0.08196645f, -0.16550368f, 0.05270617f, -0.04811765f, -0.02701685f, -0.15416038f, 
    -0.05773607f, 0.07822131f, -0.03474621f, -0.03347166f, -0.04332072f, -0.08327925f, -0.08304978f, 0.03004346f, 
    0.01462762f, -0.03186255f, -0.04589883f, -0.05781966f, 0.00704565f, -0.02257172f, -0.01383203f, 0.00040451f, 
    0.00335230f, -0.05818016f, 0.03976997f, -0.02824542f, 0.01623595f, 0.04218242f, -0.04708605f, 0.00414553f, 
    0.02200069f, -0.03840824f, 0.00217544f, -0.03108177f, -0.01367333f, -0.05736513f, -0.01650815f, -0.04502492f, 
    0.01368125f, 0.03660370f, 0.03524856f, -0.02625287f, 0.03915048f, -0.04598264f, -0.04486676f, -0.03372651f, 
    0.02987659f, 0.01848846f, 0.04714581f, -0.04363092f, -0.04290860f, 0.03148274f, 0.02412637f, 0.03543545f, 
    -0.01958533f, -0.05801565f, 0.03622442f, -0.02372247f, -0.01215283f, 0.01628946f, 0.03393876f, -0.03008851f, 
    0.02562858f, -0.00347364f, 0.01659064f, -0.00970520f, 0.00147890f, -0.06247291f, -0.00037883f, 0.04209701f, 
    0.04304375f, -0.05715414f, -0.04101520f, -0.04487190f, 0.02434491f, 0.04933501f, -0.03472060f, -0.03145253f, 
    -0.00315907f, -0.05398060f, -0.03786857f, 0.03998232f, -0.05222773f, -0.01184382f, 0.04669436f, -0.05544166f, 
    0.03661643f, -0.00026353f, 0.04367180f, 0.04735624f, -0.01586110f, 0.04634125f, -0.05032083f, 0.02524459f, 
    -0.02012229f, -0.01013577f, 0.02115546f, -0.02540378f, 0.02629672f, -0.00630310f, 0.04124095f, -0.01971385f, 
    -0.04805094f, -0.04457012f, -0.02824321f, -0.04851801f, 0.02856396f, 0.04179126f, -0.02687039f, 0.04895741f, 
    -0.04036014f, 0.04510356f, 0.03879453f, -0.00280983f, -0.01473527f, -0.03324937f, 0.01196916f, -0.00473785f, 
    0.02263959f, 0.04505042f, -0.00372626f, 0.00997075f, 0.00121958f, -0.01937916f, -0.03088105f, 0.01601107f, 
    -0.01907930f, 0.00096670f, 0.02392397f, -0.04361293f, -0.03036972f, -0.04598112f, -0.03996349f, -0.05192922f, 
    -0.01224117f, 0.00480840f, -0.01558420f, 0.00982258f, -0.01271570f, 0.01371743f, -0.00332612f, -0.04130041f, 
    -0.01550379f, -0.00275682f, -0.01441450f, -0.04383424f, -0.02083737f, 0.01086522f, -0.01362166f, -0.02808528f, 
    -0.04442537f, -0.04666694f, 0.03239597f, -0.05727475f, -0.00183828f, -0.04140772f, 0.02908115f, -0.03763447f, 
    -0.05987003f, -0.04452557f, 0.03481142f, 0.01781011f, 0.04474493f, -0.01486970f, 0.04877506f, -0.04599146f, 
    0.00408820f, -0.03663871f, -0.00126701f, -0.03018966f, -0.03891805f, 0.01503974f, -0.03600459f, 0.04301993f, 
    -0.02341910f, 0.00143907f, -0.00747947f, -0.05784534f, 0.01208595f, -0.05196943f, 0.02934458f, -0.02627566f, 
    -0.05922087f, -0.01290694f, 0.04941835f, -0.04578897f, -0.05288485f, 0.00200017f, -0.00688873f, -0.04806183f, 
    0.04250715f, -0.03598857f, 0.00609879f, -0.02271639f, -0.05180890f, 0.04949550f, -0.02843185f, -0.01914617f, 
    -0.01499917f, -0.02403612f, 0.01669115f, 0.01391271f, -0.01293861f, -0.03075864f, -0.04730070f, 0.01433964f, 
    -0.04060163f, -0.04431445f, 0.03337647f, 0.00925671f, -0.02226127f, 0.00440113f, 0.00119648f, 0.04992294f, 
    0.01354792f, -0.03535635f, -0.01802427f, 0.01377983f, -0.04181869f, 0.03064516f, -0.04206150f, 0.01464275f, 
    0.04236894f, 0.05026273f, 0.01237338f, 0.00347808f, -0.00930196f, -0.00827970f, 0.01314407f, -0.00519633f, 
    -0.04274346f, -0.03441343f, 0.04540015f, -0.01216679f, -0.04586411f, 0.04368118f, 0.02898021f, 0.04301144f, 
    0.03993417f, -0.01056264f, -0.04156446f, -0.05424153f, 0.01545076f, -0.04154141f, 0.00591499f, -0.01708299f, 
    -0.03327275f, 0.04199725f, -0.02952476f, -0.01701551f, 0.03428752f, -0.02762773f, -0.00777728f, -0.00887261f, 
    -0.04787188f, -0.00530690f, 0.01570947f, -0.01497121f, 0.01611231f, 0.01256132f, 0.00073078f, 0.01288725f, 
    -0.01855589f, -0.05232920f, 0.00484863f, 0.00046015f, -0.01510482f, 0.03147587f, -0.00535578f, -0.01356449f, 
    0.03116594f, 0.02912882f, 0.00109883f, 0.00560230f, 0.00265473f, 0.04199167f, -0.01212107f, -0.02197926f, 
    -0.01128912f, -0.01640429f, 0.00629004f, -0.06096210f, -0.02709666f, 0.03877544f, 0.02046912f, -0.04612398f, 
    0.04505617f, -0.05491870f, 0.02964858f, 0.02597978f, 0.00002674f, -0.01274874f, -0.04755155f, -0.03201050f, 
    -0.01493524f, 0.04567336f, -0.03515339f, -0.02408663f, -0.02526773f, -0.03288024f, 0.00424982f, 0.00554521f, 
    0.05302228f, -0.04498591f, 0.04119637f, 0.03469235f, 0.01896888f, 0.04563307f, -0.03185898f, -0.02670674f, 
    -0.05220174f, -0.02599821f, -0.05049313f, -0.02997796f, -0.00869481f, -0.04317044f, 0.04502295f, 0.03025559f, 
    -0.03799405f, 0.05206347f, -0.04877015f, -0.02038136f, 0.04768701f, 0.04761414f, -0.04104276f, -0.04103268f, 
    -0.03835809f, -0.00264874f, 0.01774079f, 0.00324177f, 0.01010679f, 0.03018068f, -0.00723036f, 0.02354124f, 
    -0.11514319f, -0.21492147f, -0.10208305f, -0.04491249f, -0.05806761f, -0.05819147f, 0.01042320f, 0.03045192f, 
    0.17326766f, 0.06487994f, 0.03817032f, -0.17589858f, 0.01036396f, 0.04925162f, -0.07798471f, 0.03487490f, 
    0.14338644f, 0.06891249f, -0.04578912f, 0.16151944f, -0.28675261f, 0.04601103f, 0.08774921f, -0.18057710f, 
    0.02965232f, -0.02323844f, 0.01714048f, -0.06836003f, -0.02996949f, -0.07107189f, 0.01127178f, -0.02529807f, 
    -0.01154729f, -0.02829906f, 0.07341972f, 0.09009656f, 0.20509371f, 0.14824621f, 0.23225178f, 0.06056719f, 
    -0.34810007f, -0.17031316f, -0.04406091f, -0.10769588f, -0.11856152f, -0.14827597f, -0.14367789f, -0.09118341f, 
    -0.06991550f, -0.07650981f, -0.02409662f, -0.03223026f, -0.04439204f, 0.08489032f, 0.04028642f, 0.06764404f, 
    0.02765479f, -0.03347272f, 0.05085009f, -0.06978834f, -0.17888327f, 0.03823988f, -0.19577242f, 0.11438002f, 
    0.14905292f, 0.09332304f, -0.05755039f, 0.12425833f, 0.23722160f, -0.03111276f, 0.11760245f, -0.05038670f, 
    -0.06597475f, -0.03838538f, 0.02792263f, -0.00533795f, -0.01425301f, 0.05399776f, -0.03640001f, 0.03536953f, 
    -0.01463606f, 0.04830319f, -0.09743291f, 0.08238964f, 0.06301953f, 0.13022779f, -0.03826093f, 0.07676644f, 
    -0.03029257f, -0.05881503f, 0.08730726f, 0.03107324f, -0.09750590f, -0.01387427f, 0.03003512f, -0.06278853f, 
    -0.11107560f, -0.05716046f, 0.01915577f, -0.06071460f, -0.02641064f, 0.23655036f, 0.08902931f, 0.15728751f, 
    0.04327483f, -0.02271153f, -0.07489210f, -0.08953088f, -0.02290191f, -0.18664330f, 0.00923994f, -0.02703665f, 
    0.21338427f, -0.06905419f, 0.08901849f, 0.23388636f, -0.04113776f, -0.00479909f, -0.03941896f, -0.18161118f, 
    -0.02600120f, -0.10320394f, -0.23660035f, 0.22486128f, 0.18982120f, 0.02263178f, -0.08069985f, 0.10669925f, 
    -0.01629936f, 0.09902966f, 0.03711894f, 0.12883963f, -0.00850622f, -0.06297373f, 0.10969331f, -0.00032550f, 
    -0.03981479f, 0.03277096f, -0.08227343f, -0.08561348f, -0.12639548f, 0.09260669f, 0.23723212f, -0.04146094f, 
    0.08756533f, 0.04911608f, 0.00466364f, -0.10158917f, -0.00607385f, -0.07577932f, 0.07877553f, 0.09353312f, 
    0.22925651f, 0.08098441f, -0.00586538f, -0.02660806f, -0.06765616f, -0.03194092f, -0.03927343f, 0.07523119f, 
    -0.15426084f, -0.17533620f, -0.27285260f, -0.28647384f, -0.12071853f, -0.09912302f, -0.03573035f, -0.14789511f, 
    -0.10522056f, -0.19673055f, 0.01004585f, 0.14821069f, 0.23761804f, 0.04910227f, -0.06381910f, 0.05396335f, 
    -0.07057663f, -0.09456546f, 0.19683276f, 0.08699794f, -0.19426583f, 0.02623608f, -0.17212695f, 0.29907757f, 
    0.12404910f, -0.01485222f, -0.15659393f, -0.05219134f, 0.18174313f, 0.01072782f, 0.03843171f, -0.03357743f, 
    -0.03062833f, 0.02163165f, 0.05550444f, -0.00852318f, 0.15136178f, 0.15400852f, -0.31457448f, 0.01888853f, 
    -0.29329926f, -0.18070331f, -0.35500181f, 0.16232522f, 0.12922269f, -0.02396302f, -0.14360102f, 0.00596264f, 
    0.05557534f, 0.02728275f, -0.12381906f, -0.00489222f, -0.00644860f, 0.01533203f, -0.10493264f, 0.03116955f, 
    0.10721562f, 0.00696914f, -0.16335617f, 0.05739248f, 0.07120723f, 0.14134848f, -0.05969983f, -0.30669922f, 
    0.42318147f, 0.00781237f, -0.02025948f, -0.04445593f, 0.00857399f, -0.16746339f, 0.07200610f, -0.12715073f, 
    0.02328293f, 0.02551034f, 0.04730691f, 0.09580459f, 0.01330706f, -0.01355877f, -0.05148484f, -0.19302772f, 
    0.14797795f, 0.23758076f, -0.17607269f, 0.18390027f, 0.03783315f, 0.14848731f, 0.13695063f, 0.28243715f, 
    0.17548545f, 0.13682887f, 0.13029535f, 0.20160146f, 0.03520948f, 0.03893009f, 0.17679004f, -0.06908654f, 
    0.22920854f, 0.04654942f, 0.09509227f, 0.14252524f, -0.19533929f, -0.24464306f, -0.21608762f, -0.09829588f, 
    0.01195873f, -0.02757508f, -0.05618439f, -0.04180606f, 0.12519251f, 0.02612319f, 0.11749353f, -0.01721436f, 
    0.00193540f, 0.09560746f, -0.03036993f, -0.00830403f, 0.15575109f, 0.12840012f, 0.02794668f, 0.25509128f, 
    0.00556835f, 0.02746187f, 0.14019293f, -0.24655873f, -0.01146245f, 0.13085157f, 0.05425861f, 0.04014039f, 
    0.07556379f, 0.04114402f, -0.01056370f, -0.03836185f, -0.07852207f, 0.03367902f, 0.00889627f, 0.11839484f, 
    0.02075020f, 0.01309455f, 0.07162627f, -0.02020365f, 0.02468199f, 0.57411325f, 0.15370300f, 0.18076183f, 
    0.17227837f, 0.00397720f, -0.16672494f, -0.09770228f, -0.07301095f, -0.14029559f, -0.01075778f, -0.03652041f, 
    -0.01756776f, -0.10030778f, 0.15895739f, 0.04541003f, -0.03935390f, -0.03493703f, -0.10658402f, -0.08962891f, 
    -0.09353939f, 0.00573665f, -0.00615254f, 0.03322897f, 0.10653146f, -0.06655656f, 0.12930009f, 0.09139672f, 
    -0.01594465f, 0.02010921f, 0.05470337f, 0.05568734f, 0.03013290f, 0.07878708f, 0.04551592f, 0.00330739f, 
    0.02453660f, 0.04999441f, -0.03400353f, 0.08323785f, -0.26968837f, -0.14640078f, 0.13677622f, -0.04026077f, 
    -0.25012100f, 0.01012263f, -0.09076545f, -0.09908172f, 0.01519512f, 0.07788520f, 0.07027006f, 0.03970925f, 
    -0.00344088f, 0.05700903f, 0.07681202f, 0.08013079f, -0.00020792f, -0.04869669f, 0.21032982f, 0.08983769f, 
    -0.02559326f, -0.12937090f, 0.08591524f, -0.03713152f, 0.05531621f, 0.03128690f, 0.07944279f, 0.13544537f, 
    0.01859922f, 0.04140394f, 0.12115200f, 0.08869957f, 0.08831370f, 0.04058500f, 0.11989400f, -0.04890818f, 
    -0.17344254f, 0.06627358f, 0.07852415f, -0.06007175f, 0.23026691f, 0.19457209f, -0.04554139f, 0.06790128f, 
    -0.01223529f, -0.04587879f, 0.10865501f, -0.00855926f, 0.28106692f, 0.07307448f, -0.01626539f, -0.08432633f, 
    -0.07579566f, -0.12497290f, -0.10771341f, -0.18923266f, -0.00187039f, -0.03085944f, -0.11033018f, -0.03842277f, 
    0.14469372f, 0.25482112f, -0.21959554f, 0.15143695f, -0.03429448f, 0.08510450f, 0.20366514f, -0.10471170f, 
    -0.00303378f, -0.02825305f, -0.04526496f, 0.01001199f, -0.11765226f, -0.26613051f, -0.00936820f, -0.19665810f, 
    0.06185514f, 0.09888291f, -0.07903087f, 0.15754560f, 0.13886252f, -0.14560564f, 0.16288625f, 0.21650708f, 
    0.22780123f, 0.04585049f, 0.01820908f, 0.08656022f, -0.02249332f, 0.00600088f, -0.04533865f, 0.02106989f, 
    0.05915901f, -0.04654596f, 0.07065421f, 0.31846610f, 0.03176177f, -0.09471374f, 0.17451508f, 0.05363548f, 
    -0.25201312f, 0.07656964f, -0.05247691f, -0.12593322f, -0.23052916f, 0.05074451f, -0.00754411f, -0.05793505f, 
    -0.17349494f, 0.12519996f, -0.10805183f, -0.03026858f, 0.04930943f, -0.04361147f, 0.00484660f, -0.08870810f, 
    -0.09492785f, 0.03228502f, -0.02799014f, -0.04497301f, 0.50611049f, 0.06073648f, 0.21129744f, 0.13798600f, 
    0.08698227f, 0.00855302f, 0.04141857f, 0.15574698f, 0.05724186f, -0.02424900f, -0.19486892f, -0.04737329f, 
    0.05586677f, 0.13285328f, 0.05529127f, -0.06007884f, -0.05429855f, 0.00754215f, 0.01862584f, 0.11764457f, 
    0.09990021f, -0.11213654f, 0.07100315f, -0.01650446f, 0.05347322f, -0.01026955f, 0.07105842f, 0.12177454f, 
    0.08904763f, 0.02210122f, -0.09497464f, -0.11005955f, 0.03165032f, 0.15381728f, -0.11167326f, -0.07374561f, 
    -0.14001863f, -0.10950173f, 0.02753271f, -0.09792968f, 0.06843631f, 0.10123048f, -0.01003539f, 0.05645124f, 
    0.12505406f, -0.03966025f, 0.05576744f, 0.01136172f, 0.11274964f, 0.05585358f, -0.00603079f, -0.01168277f, 
    -0.09960074f, -0.14922020f, 0.02982566f, -0.05440661f, 0.05217027f, 0.03246116f, -0.32966635f, 0.00212613f, 
    0.10164162f, 0.27634043f, -0.07649916f, -0.11801453f, 0.04296036f, -0.08134982f, 0.10766787f, 0.08085768f, 
    0.09949532f, -0.14565144f, -0.14870329f, -0.02743812f, -0.00999248f, 0.05561629f, -0.02344371f, 0.02867906f, 
    -0.04241520f, 0.04165477f, -0.16606893f, -0.01757174f, -0.12362710f, 0.19619076f, -0.25011647f, -0.18246047f, 
    0.11931539f, -0.02390308f, 0.12174316f, -0.05634345f, 0.09528994f, -0.17522568f, 0.00767576f, -0.05172919f, 
    0.30205631f, -0.02453295f, 0.15910314f, -0.03173603f, 0.02905462f, 0.24293622f, 0.07411461f, -0.13630623f, 
    -0.37097400f, 0.21610163f, 0.10236184f, -0.16777901f, -0.01699486f, -0.02900042f, 0.19364186f, 0.13840489f, 
    -0.17521805f, -0.13174804f, -0.04220254f, 0.13815694f, -0.25937960f, -0.03237858f, -0.13225013f, 0.02039541f, 
    0.05208289f, 0.16426325f, -0.06538761f, -0.01805387f, -0.07848674f, 0.08806935f, 0.04239262f, 0.15962975f, 
    0.08733281f, 0.05742284f, 0.05185184f, 0.10310982f, 0.19598852f, -0.13462396f, -0.15862411f, 0.05064888f, 
    0.01351697f, 0.14998196f, -0.01116002f, -0.05967875f, -0.02411551f, -0.00734510f, 0.00827341f, 0.10421208f, 
    -0.19324054f, -0.21408458f, -0.06399363f, -0.35568771f, -0.06735857f, 0.10069705f, 0.00584170f, -0.20784132f, 
    0.00293141f, -0.13680016f, 0.03176400f, -0.10532092f, 0.12708142f, 0.08833063f, -0.01918712f, 0.09770176f, 
    -0.00768466f, -0.01887436f, 0.07622086f, -0.03684856f, 0.57563823f, 0.35475531f, 0.19412492f, 0.20965207f, 
    0.03342573f, 0.05970205f, 0.02089038f, 0.08037217f, -0.17108096f, -0.06949473f, -0.01025184f, -0.08991345f, 
    0.16683568f, -0.07428561f, 0.04472189f, 0.07983079f, 0.10143882f, 0.05897964f, -0.03084760f, -0.00512279f, 
    -0.15434547f, 0.11002558f, 0.06115542f, -0.15890770f, -0.17679723f, 0.09287015f, 0.25310880f, 0.01748389f, 
    0.14512224f, 0.25052449f, 0.00075342f, 0.01913075f, 0.00916248f, 0.03229408f, -0.00562642f, -0.11022814f, 
    -0.08482216f, -0.00520088f, -0.03714571f, 0.01015076f, 0.11054938f, -0.01666356f, 0.00310897f, 0.08665176f, 
    0.04532154f, 0.03780738f, -0.02961550f, 0.03485635f, 0.02421446f, 0.07443529f, 0.04023874f, 0.05516292f, 
    -0.07650489f, 0.10324829f, 0.06647130f, 0.06984221f, 0.13219307f, -0.07824337f, 0.00335181f, -0.07184725f, 
    0.15028518f, 0.09537373f, 0.11645960f, 0.18241493f, 0.19987942f, 0.06483225f, -0.00465059f, 0.07989857f, 
    0.03075427f, 0.04796794f, 0.18499437f, 0.14728712f, 0.05330255f, 0.09970865f, 0.06065329f, -0.07478347f, 
    -0.08877890f, -0.12248950f, -0.09355618f, 0.01983888f, -0.07420342f, 0.18336739f, -0.87861544f, -0.49521771f, 
    -0.22472280f, 0.00085537f, 0.01055862f, -0.00361584f, 0.05133643f, -0.11421352f, -0.12940292f, -0.12669669f, 
    0.01705020f, -0.00377383f, -0.12493102f, 0.06266027f, 0.04100739f, 0.03912341f, -0.13134739f, -0.04555985f, 
    -0.33462384f, 0.22884801f, -0.69474727f, -0.38655329f, -0.00148133f, 0.10662969f, 0.15949337f, 0.18439631f, 
    -0.11685507f, 0.03967518f, -0.03808415f, -0.00472452f, 0.08583606f, -0.07473814f, -0.09884043f, 0.14213899f, 
    -0.05083404f, -0.06477884f, -0.09309199f, 0.03313628f, 0.08002968f, 0.06638715f, 0.10626598f, 0.01130117f, 
    0.06419627f, -0.05949889f, -0.02623502f, 0.01693274f, 0.07205879f, 0.03187807f, 0.14337792f, 0.19572148f, 
    0.09070618f, -0.08250909f, -0.02208442f, -0.04045593f, -0.08911254f, -0.00873057f, 0.08178625f, 0.02810358f, 
    0.11805110f, 0.30913058f, -0.57586658f, 0.00301486f, -0.40441519f, 0.10124174f, -0.03743091f, -0.01947044f, 
    0.06201202f, 0.31252491f, -0.10373971f, -0.04662903f, -0.00052386f, 0.00405207f, -0.11772337f, -0.04684559f, 
    0.01647635f, -0.01654650f, -0.02913730f, -0.12106566f, 0.18968384f, -0.14455616f, 0.05996918f, 0.13069504f, 
    -0.04733875f, 0.00448717f, 0.07252178f, 0.05730588f, 0.00735913f, -0.06272806f, -0.06225013f, 0.10068743f, 
    0.02574959f, 0.08021859f, -0.13768783f, -0.10686737f, -0.06839298f, -0.02692925f, -0.02572022f, 0.00384231f, 
    -0.04031845f, -0.04534044f, 0.09814443f, 0.12718299f, 0.11704435f, -0.02456062f, 0.05713068f, 0.06198452f, 
    -0.01423299f, -0.00034084f, 0.05822846f, 0.19936700f, -0.03939601f, -0.00071994f, -0.02834738f, -0.08540290f, 
    0.05714067f, -0.17790726f, 0.00811537f, -0.01048028f, -0.29744428f, 0.28991500f, -0.73479033f, -0.56146520f, 
    -0.32211009f, 0.10268185f, 0.01885047f, 0.06529941f, 0.03538913f, 0.12198911f, -0.11220913f, -0.03309807f, 
    0.04316253f, 0.03254320f, -0.11166806f, 0.12844938f, 0.08504397f, 0.07739487f, -0.12839751f, -0.05099612f, 
    -0.73372954f, -0.49963871f, -0.41815600f, -0.25591239f, -0.70910180f, -0.11095861f, -0.02301304f, -0.09385714f, 
    -0.12602709f, -0.13336079f, -0.14749470f, -0.11207362f, -0.01092273f, 0.02527865f, -0.07054619f, -0.09970246f, 
    -0.00485021f, -0.01180616f, -0.12095138f, 0.01467906f, 0.24335991f, 0.11790384f, 0.04813221f, 0.16260007f, 
    0.20013404f, -0.10810250f, 0.07979383f, 0.22902425f, -0.01375641f, 0.08263820f, -0.01404009f, -0.09276943f, 
    0.09305589f, 0.06924646f, 0.05675686f, 0.27904138f, 0.07020859f, -0.08700886f, 0.06714345f, -0.21892193f, 
    -0.49609560f, -0.01934254f, 0.14881833f, 0.10120223f, -0.12506989f, 0.13295488f, 0.12827429f, 0.18523680f, 
    0.20346177f, -0.01737680f, 0.06171739f, 0.07027394f, 0.04305451f, 0.03427595f, 0.06598230f, 0.10954471f, 
    0.29693171f, 0.08286629f, 0.20634179f, 0.21151301f, 0.02255914f, 0.06546500f, -0.08411987f, -0.30285147f, 
    -0.04178091f, 0.27583405f, 0.06112280f, -0.10791443f, 0.26626080f, 0.09790631f, 0.03093784f, 0.19065061f, 
    -0.01546953f, -0.10459013f, -0.08390973f, 0.02812854f, -0.12847191f, -0.00190399f, 0.04436811f, 0.11312075f, 
    -0.15396008f, 0.33173960f, 0.31042352f, 0.06112832f, 0.16752508f, -0.01331064f, -0.05960520f, 0.15009168f, 
    -0.03661870f, 0.12662803f, -0.10374967f, -0.11129399f, -0.01671701f, 0.09665304f, 0.06286215f, 0.10946196f, 
    0.08928447f, 0.00159283f, 0.06648446f, 0.02802407f, 0.19968407f, -0.07733936f, -0.04190558f, 0.17031842f, 
    -0.80254835f, 0.09970600f, -0.15733054f, -0.21486481f, 0.12853827f, -0.20942067f, -0.07231480f, -0.22407250f, 
    -0.13854235f, 0.09901669f, -0.19186969f, -0.22141725f, -0.00552546f, 0.06078961f, -0.02854049f, -0.11984593f, 
    0.20373443f, 0.13046487f, 0.05419503f, -0.02038735f, 0.03357892f, 0.07783996f, 0.02576392f, 0.38673377f, 
    0.13269684f, 0.02028962f, -0.06307824f, -0.06100423f, -0.04253777f, 0.02824371f, 0.03549353f, 0.05391479f, 
    0.03282233f, 0.12062047f, 0.08978365f, 0.13146693f, -0.16263446f, -0.04411804f, -0.16842459f, 0.14153863f, 
    -0.09016798f, -0.14725775f, 0.00559185f, -0.02277452f, 0.05347531f, -0.10088570f, -0.12489228f, -0.05341616f, 
    0.00678671f, -0.02810682f, 0.03060788f, -0.11909670f, 0.00053344f, 0.02591356f, 0.04561502f, -0.06155038f, 
    -0.25696281f, -0.24919239f, -0.04335712f, -0.05031973f, -0.16909003f, -0.04598025f, -0.05243640f, -0.01209030f, 
    0.06564575f, -0.04192159f, -0.08997805f, 0.14602262f, 0.11940233f, 0.10541222f, 0.13737547f, -0.03129330f, 
    0.06274584f, -0.03709308f, -0.03930686f, -0.03711025f, 0.11379545f, 0.40395623f, -0.09427102f, -0.01078426f, 
    0.37424842f, 0.20303123f, 0.10726114f, 0.24230310f, -0.00560933f, 0.17200126f, 0.04071265f, -0.04163435f, 
    0.03190095f, -0.12405320f, 0.05510876f, 0.07808364f, -0.02704063f, 0.13729753f, -0.05541618f, 0.03002726f, 
    0.21607617f, 0.55165577f, 0.12447757f, -0.11709753f, 0.35924006f, 0.02846482f, -0.03853357f, 0.13804485f, 
    0.09998229f, 0.11931305f, 0.02756508f, -0.07642256f, 0.03550034f, -0.02212306f, -0.07394179f, 0.10014871f, 
    -0.14162141f, 0.08677430f, -0.00033626f, -0.01216658f, -0.19587496f, -0.07868125f, -0.05111634f, -0.32198235f, 
    -0.47277424f, -0.04890604f, -0.08071000f, 0.00390747f, -0.01184587f, 0.04953664f, 0.14496981f, 0.13857910f, 
    0.24065776f, 0.06788964f, 0.12684269f, -0.06244844f, -0.15509886f, -0.07554447f, -0.07341248f, -0.10667907f, 
    0.37452650f, 0.11869762f, 0.13217224f, 0.17717360f, 0.39200723f, -0.05276893f, -0.00717074f, 0.01043762f, 
    0.15323313f, 0.17492734f, 0.02243138f, -0.00030457f, -0.02451178f, 0.02665554f, -0.04751775f, 0.05302897f, 
    -0.14731102f, 0.24538203f, -0.03183819f, -0.07336025f, -0.24436924f, -0.02856137f, -0.48280752f, -0.05576012f, 
    0.02782250f, 0.12853281f, 0.11552532f, 0.17155731f, -0.03990895f, 0.12092423f, -0.09410692f, -0.15158342f, 
    -0.10881911f, -0.12624104f, -0.09253924f, -0.05216980f, 0.03139062f, 0.03280092f, 0.04294462f, 0.09915435f, 
    -0.12634757f, -0.12359128f, -0.12494229f, 0.00883129f, -0.12915397f, -0.03873694f, 0.01456770f, -0.02770081f, 
    0.08004904f, -0.03204841f, 0.06013565f, 0.22621790f, 0.02030171f, -0.05119369f, -0.02465119f, -0.07094788f, 
    0.11511283f, 0.05465661f, 0.12128934f, 0.06602710f, 0.25364029f, 0.28978568f, 0.05385279f, -0.22392912f, 
    0.23176771f, 0.06837137f, 0.06460381f, 0.17562148f, 0.05152537f, 0.00647306f, -0.01879613f, -0.04030524f, 
    -0.06527044f, 0.05544683f, 0.09096945f, 0.01654150f, -0.00353862f, -0.02671378f, 0.15642957f, 0.01616461f, 
    0.25284359f, -0.06625500f, 0.12686510f, -0.24312434f, 0.26384535f, 0.19529340f, 0.23994529f, 0.09517849f, 
    0.02601967f, -0.01805478f, 0.02648937f, -0.16337462f, -0.15041985f, -0.08284380f, -0.03685969f, 0.04806398f, 
    0.11418734f, 0.02131950f, 0.03910167f, 0.09907113f, -0.37015009f, 0.39429870f, 0.04002984f, 0.07628302f, 
    -0.11212710f, -0.02944445f, -0.09376066f, 0.00100391f, -0.01238104f, -0.09433467f, 0.00760389f, 0.02257185f, 
    0.02750820f, 0.07600530f, 0.04834697f, 0.06468954f, 0.07453812f, -0.14196008f, -0.12195669f, -0.16589905f, 
    0.06629727f, -0.17390715f, 0.22291458f, 0.05375992f, -0.15241528f, 0.04327920f, -0.03740854f, 0.02509319f, 
    0.13625599f, -0.22840315f, -0.10602077f, -0.13145277f, -0.12549455f, 0.10286580f, 0.12946583f, 0.01296722f, 
    0.07844041f, -0.05989765f, 0.05829890f, -0.13028787f, 0.17656420f, 0.21638040f, -0.14980091f, -0.00263454f, 
    0.12935154f, -0.00710476f, 0.18246847f, 0.28951311f, -0.04773894f, 0.09873369f, -0.06521969f, -0.24974459f, 
    -0.01730047f, -0.03790888f, 0.02120695f, 0.08029075f, 0.13371719f, 0.12263145f, 0.03253736f, 0.23219378f, 
    0.29421464f, 0.18574271f, 0.31607246f, 0.01537054f, 0.02244592f, -0.17300461f, -0.28157115f, -0.08712470f, 
    0.08528218f, -0.11501328f, -0.05284213f, 0.00719275f, 0.03209188f, 0.06495088f, -0.00509258f, -0.04440141f, 
    0.08908093f, 0.03522528f, 0.01030300f, -0.13215064f, 0.25751591f, 0.08342000f, -0.34489095f, -0.07484653f, 
    0.11337592f, 0.23360375f, 0.11503033f, 0.03674103f, 0.06955999f, -0.15962917f, -0.02307576f, -0.15771809f, 
    -0.20001867f, 0.12426362f, 0.07204949f, 0.06322565f, -0.01857525f, -0.05825674f, -0.05601292f, -0.02350223f, 
    0.03742680f, -0.02924147f, 0.01942927f, 0.03918968f, 0.04018272f, -0.00054660f, -0.01563993f, -0.05813989f, 
    -0.04939309f, -0.03921990f, -0.06251583f, 0.00137720f, 0.00821571f, -0.02966417f, -0.03838100f, 0.03133794f, 
    -0.03129243f, -0.04825279f, 0.00590208f, 0.04237437f, -0.06102584f, -0.01072014f, 0.04186536f, -0.05949798f, 
    -0.01543246f, -0.03777965f, -0.03482646f, 0.04023173f, 0.03217089f, -0.06508942f, 0.03434499f, -0.00713989f, 
    0.02320993f, -0.01023971f, -0.05813580f, 0.02685283f, 0.00573831f, -0.02877813f, 0.03019592f, -0.01997488f, 
    -0.00102333f, -0.03437570f, -0.03288260f, 0.02240374f, 0.01740281f, 0.02843626f, 0.03643214f, 0.02212096f, 
    -0.01338108f, -0.03598010f, 0.02752212f, 0.02127691f, 0.02582516f, 0.02001353f, 0.02911648f, -0.04750689f, 
    0.00528656f, 0.01857613f, 0.00991150f, -0.04525154f, -0.06313560f, 0.02206595f, 0.02138834f, -0.06247485f, 
    0.03402213f, -0.02245174f, 0.02525987f, 0.01970206f, 0.00996743f, 0.02206844f, -0.03649756f, -0.01119343f, 
    -0.05020609f, -0.01371540f, 0.00224372f, 0.02726554f, -0.03885318f, 0.01118379f, -0.03493181f, 0.02993655f, 
    -0.04089530f, -0.02433094f, -0.04973743f, -0.01730606f, -0.00232094f, 0.02630486f, -0.04607165f, 0.00910582f, 
    0.00295886f, -0.05910394f, -0.05494154f, -0.00097365f, 0.03225062f, -0.02109638f, -0.04242767f, 0.01587955f, 
    0.01937125f, -0.00421435f, 0.01582228f, 0.03418811f, -0.04437843f, -0.00113895f, 0.04570093f, 0.03189869f, 
    0.00222322f, -0.05642853f, -0.04241900f, -0.06511834f, -0.01270450f, 0.03386190f, -0.01496371f, -0.05762856f, 
    0.00943087f, -0.05941392f, -0.04554785f, 0.03648851f, 0.02870775f, -0.01700165f, -0.04251926f, -0.01898555f, 
    -0.06448409f, -0.01491696f, 0.01889963f, -0.01603313f, 0.01140217f, 0.03598100f, -0.05604899f, -0.00523164f, 
    -0.02496932f, 0.02593189f, 0.02696955f, -0.05222032f, 0.02327125f, 0.01900040f, -0.06264792f, 0.03665089f, 
    -0.00378238f, -0.02712089f, -0.02982478f, -0.03167719f, 0.01471432f, -0.00293895f, -0.03894871f, -0.00097703f, 
    -0.03757522f, -0.05476617f, -0.02313658f, 0.02493354f, 0.01951406f, 0.04471552f, -0.02253374f, 0.00512270f, 
    -0.03659831f, 0.00843339f, -0.06273194f, 0.03110856f, 0.02752458f, 0.02275377f, 0.01676553f, -0.00653312f, 
    0.05336359f, 0.01597651f, -0.05165306f, -0.03842057f, -0.01116107f, -0.02613246f, 0.04726840f, -0.00523343f, 
    -0.03822017f, 0.01572802f, 0.00872481f, -0.02638507f, 0.00766744f, -0.04081899f, 0.01949028f, -0.03308316f, 
    0.02397968f, 0.01757652f, -0.04675110f, 0.02227044f, 0.03995027f, -0.01259837f, -0.03579471f, 0.02356669f, 
    -0.00870658f, 0.02990877f, -0.05533470f, -0.04246848f, -0.05729753f, -0.02758197f, -0.04339673f, -0.03654329f, 
    0.04298575f, -0.04572506f, -0.02039505f, 0.01860220f, 0.04364375f, 0.01132171f, -0.02333047f, 0.02109551f, 
    -0.00458991f, 0.04043093f, 0.03535904f, 0.02985904f, -0.00367411f, 0.00494334f, -0.00951745f, -0.05853124f, 
    -0.00050514f, -0.04883578f, -0.03699265f, -0.02652268f, -0.02125335f, -0.02841648f, -0.02387386f, -0.00276443f, 
    -0.05704076f, 0.03837739f, -0.01165352f, -0.06566656f, 0.01446004f, -0.06193634f, 0.01577116f, -0.04077445f, 
    -0.05663672f, -0.05250594f, -0.03396687f, -0.04599920f, 0.02840842f, 0.02343768f, -0.01085158f, -0.04819010f, 
    -0.01371776f, 0.01757315f, 0.03943432f, 0.02350175f, -0.01323559f, -0.01468568f, -0.03828699f, -0.03716834f, 
    -0.06475194f, -0.06166885f, 0.02164686f, -0.00167297f, -0.01840433f, 0.00534723f, -0.03589721f, -0.00066073f, 
    0.02694204f, 0.01556938f, -0.05243196f, -0.03634466f, -0.06500554f, -0.02420116f, -0.01698898f, -0.03457710f, 
    0.00018933f, 0.02033887f, 0.03904115f, -0.01879971f, 0.03544012f, 0.01420655f, 0.03527742f, 0.03363251f, 
    -0.01705445f, -0.01402296f, 0.02484396f, 0.01674165f, 0.01545134f, 0.02523821f, 0.01701162f, -0.04456818f, 
    0.05037653f, -0.06509875f, 0.01997141f, -0.03050906f, -0.02518057f, -0.02503559f, -0.04302885f, -0.04432140f, 
    -0.01628802f, -0.01866964f, -0.01643178f, -0.01424512f, 0.02846386f, -0.02301257f, -0.06169523f, -0.02804290f, 
    0.03345829f, 0.01166158f, 0.03602705f, -0.05976633f, 0.04040341f, 0.00560011f, -0.03476156f, -0.06506164f, 
    0.03739852f, 0.01523211f, -0.02202666f, 0.00520367f, 0.05191680f, 0.02029019f, 0.01638541f, -0.06000338f, 
    0.02131545f, 0.01596751f, -0.01748699f, 0.01654956f, 0.01396066f, 0.01839175f, 0.02277076f, 0.04412165f, 
    0.02970487f, 0.01009999f, 0.03436159f, -0.03958625f, -0.03172436f, -0.02380744f, -0.02979271f, -0.03594133f, 
    0.20016044f, 0.02567411f, -0.08584566f, 0.04803247f, 0.02941698f, 0.10900554f, 0.03760069f, 0.16836581f, 
    -0.06982873f, 0.04263109f, 0.00775866f, 0.17315857f, -0.07085013f, -0.04283372f, -0.03466235f, -0.00069089f, 
    -0.03033783f, -0.03168076f, -0.01814884f, 0.04889967f, -0.14368193f, 0.10623209f, -0.00205199f, 0.21690272f, 
    -0.00102122f, -0.15594800f, 0.08672310f, -0.08709410f, -0.00933971f, 0.04936305f, -0.09558751f, -0.03434144f, 
    0.06838053f, -0.01978793f, 0.04270775f, -0.14817196f, 0.00679563f, -0.03619042f, -0.10020085f, -0.01539256f, 
    0.00902301f, 0.10060634f, 0.11627139f, 0.01499639f, -0.19455132f, 0.04145703f, 0.02888430f, -0.06530116f, 
    0.03679575f, -0.02581420f, -0.10232155f, 0.12230128f, 0.11797833f, -0.04695228f, 0.06947368f, 0.06617547f, 
    0.14054352f, -0.04104276f, -0.06790965f, -0.00879704f, 0.21194208f, 0.15113425f, 0.05474675f, -0.25525209f, 
    0.18166518f, 0.09801180f, 0.04793423f, 0.14388525f, -0.17516445f, 0.06030180f, -0.01622100f, -0.02375576f, 
    0.00086370f, -0.06420722f, 0.13824293f, 0.10756264f, -0.03430828f, -0.03753404f, 0.10699803f, 0.11641453f, 
    0.24864635f, 0.12687628f, 0.11426551f, -0.30374953f, 0.08486089f, 0.00858393f, -0.02445434f, 0.15946069f, 
    0.12085014f, 0.11616851f, -0.05029570f, -0.09084095f, -0.00849236f, -0.04614806f, 0.09352189f, 0.23776855f, 
    0.09106255f, 0.02754337f, -0.06484558f, -0.06013330f, 0.04007728f, 0.01639181f, -0.04868457f, -0.10601977f, 
    -0.48324516f, -0.02939812f, -0.07153256f, 0.08883211f, 0.05807681f, 0.02642217f, 0.07278918f, 0.19506626f, 
    -0.05117451f, 0.16085929f, 0.08570073f, -0.17364447f, -0.03856524f, -0.08267586f, -0.03027178f, -0.02152120f, 
    0.16441058f, 0.09333871f, 0.29185200f, -0.14078963f, 0.21628733f, 0.13062274f, 0.06509353f, -0.03183237f, 
    0.13953790f, -0.01857478f, 0.00425404f, -0.02713517f, 0.04547032f, -0.02377981f, -0.04545834f, 0.12618072f, 
    -0.03349765f, 0.05332750f, 0.15440732f, -0.00347664f, 0.03771171f, -0.16330150f, -0.62037730f, -0.07124903f, 
    -0.07281008f, 0.04103783f, 0.17016672f, 0.18923129f, 0.02142376f, 0.16998856f, 0.06625935f, -0.02780442f, 
    -0.09713703f, -0.01263698f, -0.04846156f, -0.09210183f, 0.02740933f, 0.03788030f, -0.04339736f, -0.03422502f, 
    0.09523323f, 0.17705587f, 0.06847755f, 0.09986330f, -0.02109560f, 0.00240069f, 0.03184198f, 0.01657867f, 
    0.09967574f, 0.00070509f, -0.05487708f, 0.04013290f, -0.10883846f, -0.08485415f, -0.00258677f, 0.00868042f, 
    0.03618175f, 0.17500539f, -0.03223792f, 0.01956538f, 0.52453333f, 0.13167983f, 0.03678839f, -0.52692252f, 
    0.07511760f, 0.19817840f, 0.15132071f, 0.13169724f, -0.03301232f, 0.06985458f, 0.04766035f, -0.01634415f, 
    -0.07056899f, 0.01832281f, 0.05307878f, 0.08686643f, -0.05116905f, -0.06094582f, 0.17533132f, 0.00934981f, 
    0.68481642f, -0.03772341f, 0.19898330f, -0.38201433f, 0.14007241f, 0.37507477f, 0.31805572f, 0.06483997f, 
    0.04249007f, 0.11020835f, 0.08603647f, -0.09827782f, -0.08891889f, -0.01136419f, 0.00979851f, 0.03979730f, 
    0.05043627f, -0.01762613f, 0.08653639f, 0.00111587f, 0.10928492f, 0.29543099f, 0.42452967f, 0.13803633f, 
    -0.13015027f, 0.12152650f, -0.14336608f, 0.12892704f, -0.00374387f, -0.03540917f, -0.10803540f, 0.14939936f, 
    -0.14698248f, 0.05601443f, 0.03303800f, -0.05537489f, 0.09975716f, -0.12522635f, -0.13367656f, 0.05443562f, 
    0.28923735f, -0.17649122f, 0.29862148f, -0.10422707f, -0.00894220f, -0.00709769f, -0.05427248f, -0.26409504f, 
    0.07658385f, -0.08085072f, 0.03189492f, -0.22030683f, 0.02671359f, -0.00841572f, 0.11427891f, 0.08155821f, 
    -0.08632509f, 0.00053170f, -0.04946718f, -0.14158921f, 0.19827475f, 0.12097170f, -0.13863724f, 0.11114378f, 
    0.05004578f, -0.08423591f, 0.23803635f, 0.26709697f, -0.12878744f, 0.17222600f, 0.03212693f, -0.06050466f, 
    -0.05916337f, -0.07885236f, 0.01300473f, -0.00674656f, 0.06724712f, -0.02477645f, -0.09246797f, 0.00381332f, 
    0.14963567f, 0.17584722f, 0.34082574f, 0.23244813f, -0.13452682f, -0.08757546f, -0.15104106f, -0.15416373f, 
    0.09555478f, -0.31177831f, 0.00973778f, 0.07454634f, -0.02212401f, -0.01090918f, 0.04772891f, -0.14050207f, 
    0.08115023f, 0.16455887f, 0.02922954f, 0.08943813f, 0.09304776f, -0.50376743f, -0.42063469f, -0.37950560f, 
    0.08185018f, 0.15887620f, 0.25945222f, 0.17273819f, 0.00029630f, 0.24685514f, -0.00455912f, -0.01002170f, 
    -0.06815298f, 0.16063353f, -0.04370501f, 0.01417937f, 0.03256493f, -0.05995668f, -0.02009099f, -0.03629543f, 
    0.02049301f, -0.06123162f, 0.03082543f, 0.02702559f, 0.02572844f, 0.00473927f, 0.00927179f, -0.00342378f, 
    -0.03777428f, -0.01377243f, -0.02953937f, 0.00938686f, -0.01334194f, 0.02327424f, -0.03060169f, -0.00149676f, 
    -0.01145916f, -0.03984200f, 0.00318084f, -0.01371952f, 0.00508165f, 0.01601747f, -0.01968085f, -0.03998654f, 
    -0.00207538f, -0.00875014f, 0.03452164f, 0.01080512f, -0.00375042f, -0.03529131f, 0.01510274f, 0.04847866f, 
    -0.06090884f, -0.06140395f, -0.02321716f, 0.01112406f, -0.05440777f, -0.02646487f, -0.00032243f, -0.03052947f, 
    0.03769278f, -0.04037325f, 0.03630192f, -0.03669426f, 0.00019405f, -0.01168643f, -0.01048464f, 0.02117713f, 
    -0.01089107f, -0.01936999f, -0.00141308f, -0.01935653f, 0.00994268f, 0.02268340f, 0.01841280f, -0.00751110f, 
    -0.04193227f, 0.02441850f, 0.02518812f, 0.03640194f, -0.01048406f, -0.05380026f, -0.04086068f, 0.00646839f, 
    -0.06146929f, 0.01105941f, -0.00485860f, 0.02060608f, 0.00150242f, 0.01928485f, -0.04269748f, -0.03208511f, 
    0.00134526f, -0.00631110f, -0.03125856f, 0.02889705f, 0.00396271f, -0.00936974f, -0.01836884f, 0.01388946f, 
    0.03866967f, 0.03857465f, 0.00417298f, 0.02528825f, -0.03698956f, 0.02860963f, 0.03177397f, -0.05193690f, 
    -0.00800840f, -0.05473992f, -0.02639440f, 0.01807315f, -0.01033953f, -0.04731984f, 0.03267192f, -0.01462105f, 
    -0.01604599f, 0.02811355f, 0.00804016f, 0.03522771f, -0.05518986f, -0.00370927f, -0.04503274f, -0.03956696f, 
    -0.00735934f, -0.05412057f, 0.01451031f, -0.02738906f, 0.02150290f, -0.00165255f, 0.01436147f, -0.03415046f, 
    0.00383832f, -0.04572866f, -0.01086358f, -0.00326140f, -0.01066193f, -0.06092915f, -0.00590797f, -0.06053245f, 
    -0.00739797f, -0.04261198f, -0.01587690f, -0.03190355f, -0.02467375f, -0.03652592f, -0.02696107f, 0.01142401f, 
    0.00761255f, -0.01486384f, -0.00940691f, 0.04068482f, -0.04218144f, 0.01792654f, -0.03215482f, 0.03490200f, 
    0.00805159f, -0.06143390f, -0.06028683f, 0.02442612f, -0.06117873f, -0.03901798f, -0.03003891f, 0.02744953f, 
    -0.05444922f, 0.04579422f, -0.01671852f, -0.03249181f, -0.04899140f, -0.00763805f, 0.04544100f, 0.04806640f, 
    0.01781639f, -0.02280244f, 0.02072142f, -0.01671502f, 0.00951630f, -0.02200676f, -0.04612421f, -0.04674728f, 
    0.00410549f, -0.04524700f, -0.02087645f, -0.02279650f, -0.06168872f, 0.01131947f, -0.05041369f, -0.03116569f, 
    0.00584187f, 0.05506951f, 0.00162325f, 0.01349590f, 0.02201905f, -0.01593159f, 0.01281677f, -0.05491643f, 
    0.01625748f, -0.02534472f, -0.01479463f, -0.05685601f, 0.01066068f, -0.03367861f, 0.02491968f, 0.00334326f, 
    0.00668283f, -0.03767863f, -0.02195896f, 0.00879146f, 0.02617642f, -0.03533823f, 0.00643023f, -0.05442397f, 
    0.03860539f, -0.04380846f, -0.00901421f, 0.00342540f, -0.00938035f, -0.02498464f, -0.04363960f, -0.02077024f, 
    -0.05241710f, -0.03303890f, -0.05094606f, -0.03677576f, -0.00860096f, 0.02403041f, -0.02583513f, 0.02644663f, 
    0.03047573f, -0.06167606f, -0.02782475f, -0.05404028f, 0.00067372f, 0.01564413f, -0.03641023f, 0.02510999f, 
    -0.02162350f, 0.00480110f, 0.02219568f, 0.03800978f, 0.00264220f, -0.00714994f, 0.03978744f, 0.00411658f, 
    -0.02135582f, 0.04435276f, -0.01443098f, -0.05664146f, -0.05197964f, -0.00027282f, 0.02398112f, 0.04278337f, 
    0.04459260f, -0.02240593f, -0.00520596f, -0.01014850f, -0.02167986f, -0.03400744f, 0.04902643f, 0.03689411f, 
    -0.00585958f, 0.01158765f, 0.02222555f, -0.05830535f, -0.04007551f, -0.05940721f, -0.03925497f, -0.01940134f, 
    0.01400803f, 0.00632131f, 0.02073438f, -0.04884746f, 0.00997796f, 0.01057901f, 0.04247114f, -0.00969575f, 
    -0.06021474f, -0.01644162f, 0.02451338f, 0.02429284f, -0.02366655f, -0.00197971f, 0.03665918f, -0.04152643f, 
    0.04170387f, -0.05496220f, 0.02671213f, -0.02080617f, 0.00856473f, 0.02763885f, -0.00575966f, 0.03723758f, 
    -0.03030996f, 0.04954094f, -0.03526950f, 0.02253421f, 0.02213500f, -0.05161368f, -0.00180853f, -0.04509085f, 
    0.00444481f, -0.01960473f, -0.03598011f, -0.00223352f, -0.04691184f, -0.03242698f, 0.03405269f, -0.06078072f, 
    -0.02286710f, 0.00390132f, -0.00005852f, -0.05405524f, 0.00178097f, -0.01780025f, -0.05464159f, -0.02120606f, 
    0.00636437f, 0.03303449f, -0.01957729f, 0.04767356f, 0.00252306f, 0.02259276f, -0.03558334f, -0.05988626f, 
    -0.00588236f, 0.03538543f, -0.00646100f, 0.01560562f, 0.01837567f, -0.02783589f, -0.04897179f, -0.02676672f, 
    0.00286644f, -0.00782597f, 0.04618350f, 0.01001090f, 0.01481222f, 0.00836483f, -0.00598105f, 0.05584668f, 
    0.28574353f, 0.24723934f, 0.00608488f, 0.13367151f, 0.00479253f, 0.03521335f, 0.04241971f, 0.10137631f, 
    0.09655342f, 0.10688976f, 0.05634221f, 0.07052202f, 0.14894909f, 0.15108885f, -0.01021689f, -0.00048225f, 
    -0.24488361f, -0.06029057f, -0.02065095f, -0.07840735f, -0.64366686f, -0.27639481f, -0.11671565f, -0.21321125f, 
    -0.46686620f, -0.04957254f, -0.15921691f, -0.19221209f, 0.01360173f, 0.08461900f, -0.04516866f, 0.07864743f, 
    -0.06753220f, 0.05399065f, 0.02772932f, 0.03106282f, -0.00742085f, -0.29169744f, 0.03214738f, -0.03958374f, 
    -0.13997661f, -0.32485583f, -0.42751935f, -0.54610300f, -0.14491543f, 0.09775875f, 0.01787963f, 0.11161857f, 
    0.03324375f, -0.17094554f, 0.07337517f, 0.06228477f, 0.01743126f, -0.11081046f, -0.03933724f, 0.08550677f, 
    -0.10460247f, 0.07967196f, -0.11067583f, -0.06953105f, 0.23755620f, 0.17193440f, 0.29801852f, 0.14365774f, 
    0.06797592f, -0.07090362f, 0.08933970f, 0.03570613f, 0.13138522f, -0.00169044f, 0.04301455f, -0.02815384f, 
    -0.03477483f, 0.07400858f, 0.07119097f, 0.03301707f, 0.10247060f, 0.03267670f, 0.11842255f, 0.12284701f, 
    0.24930854f, 0.30446541f, 0.19345437f, 0.17948112f, 0.08454721f, 0.04529835f, 0.13286482f, -0.15350194f, 
    0.08054696f, -0.07973715f, 0.08711714f, -0.01462389f, -0.04522791f, -0.01121616f, 0.11789740f, -0.06249266f, 
    0.07192725f, 0.14917281f, -0.09814717f, 0.12919706f, -0.03470825f, -0.30864421f, -0.00576348f, -0.11906175f, 
    0.05410285f, 0.00369547f, -0.03600771f, -0.06963089f, -0.00976015f, -0.00041674f, -0.00065604f, 0.05438335f, 
    0.11030693f, -0.07459757f, -0.02578652f, 0.16784911f, 0.01454179f, -0.02601805f, 0.15664572f, 0.12760818f, 
    -0.05915409f, 0.14702913f, 0.32731727f, 0.07932881f, 0.08589248f, -0.00172729f, -0.10504074f, -0.13646123f, 
    -0.22651866f, 0.11579062f, -0.03241106f, -0.01086901f, -0.01918032f, -0.03942506f, 0.08124026f, -0.06192704f, 
    0.05099241f, -0.06242653f, 0.02900814f, 0.04735949f, 0.15892446f, -0.01936966f, 0.08456675f, -0.05933182f, 
    0.08368086f, -0.08773405f, -0.06671039f, 0.23517798f, 0.05564871f, -0.03083875f, 0.02469828f, 0.02631244f, 
    0.06836105f, 0.00839806f, 0.02701947f, 0.15039350f, 0.01477379f, 0.02267735f, -0.03715624f, -0.09916622f, 
    -0.17689715f, -0.24530347f, -0.30868095f, -0.40506127f, -0.11207879f, 0.12828250f, 0.06756911f, -0.31545866f, 
    -0.02283812f, -0.06136278f, 0.12278467f, 0.05808222f, 0.29027972f, -0.17079842f, -0.14725038f, 0.12339474f, 
    -0.18914045f, -0.42523092f, -0.31387010f, -0.19668768f, 0.18069614f, 0.15702124f, 0.19942826f, 0.19558917f, 
    0.21044487f, -0.04783815f, 0.10140686f, -0.04572371f, 0.07913091f, 0.00970134f, 0.04469651f, 0.00221638f, 
    0.01594521f, 0.01447762f, 0.02059937f, 0.09539118f, 0.08705382f, 0.10250287f, -0.07538851f, 0.09999383f, 
    0.21653281f, 0.30694437f, 0.01714338f, 0.16065015f, 0.32555458f, 0.08336689f, 0.21977505f, 0.21093445f, 
    0.11866213f, -0.05947755f, 0.08751225f, 0.04587452f, 0.09906703f, 0.12462688f, 0.13003549f, 0.08083329f, 
    -0.01706426f, 0.08069463f, -0.08554985f, -0.11338639f, -0.39136925f, 0.23616722f, -0.41445157f, -0.55942619f, 
    -0.02333221f, 0.15231469f, 0.01287240f, -0.11160283f, 0.07316337f, -0.18132803f, -0.13631444f, -0.01674392f, 
    0.01808668f, -0.05325428f, -0.05260051f, -0.12162828f, 0.04784644f, 0.02512662f, 0.06803954f, -0.03806783f, 
    -0.19107409f, 0.16808908f, -0.17376082f, -0.16474958f, 0.11558685f, -0.11252770f, 0.10070866f, 0.01983409f, 
    -0.15842074f, -0.04663690f, 0.02977632f, 0.15513270f, -0.17514484f, 0.04691283f, -0.08619642f, -0.13351405f, 
    -0.04815842f, -0.01221839f, -0.22039682f, 0.12321053f, 0.30194622f, 0.20634298f, 0.18290384f, -0.13252607f, 
    -0.03528836f, 0.03753623f, 0.04039628f, 0.06303217f, 0.13207032f, 0.05493990f, -0.12367605f, -0.02877472f, 
    0.08517815f, 0.07174855f, -0.09543670f, -0.12778315f, -0.14175911f, 0.00977447f, -0.02576893f, -0.24111815f, 
    0.09870210f, 0.08803638f, 0.17382726f, -0.09780562f, -0.13209495f, 0.14816983f, 0.09573066f, -0.29445219f, 
    -0.04047773f, 0.14034419f, -0.00914105f, 0.00708779f, 0.07592976f, -0.07537957f, 0.04553331f, -0.13144886f, 
    0.05711170f, -0.15229619f, -0.08426895f, 0.09364029f, 0.48517373f, 0.55231869f, 0.28705904f, 0.31664434f, 
    0.06221601f, 0.11307694f, 0.21839459f, 0.23534048f, -0.16494119f, 0.02994126f, 0.22019164f, 0.17904648f, 
    0.07372504f, 0.13469817f, 0.25399959f, 0.17527388f, 0.21574305f, 0.11284190f, 0.00952950f, 0.06762961f, 
    -0.15792917f, -0.03005643f, -0.11184125f, -0.08232022f, 0.03473957f, -0.18819961f, -0.13491298f, -0.05920740f, 
    0.07780059f, -0.13343440f, 0.01642496f, -0.05928861f, -0.07446787f, -0.11169520f, -0.00685081f, -0.02732201f, 
    0.01861938f, 0.04789435f, 0.03271167f, 0.02213391f, 0.17724417f, -0.00571736f, 0.06090527f, 0.24255291f, 
    0.12719008f, 0.01364020f, 0.08680608f, 0.06181018f, 0.06436025f, 0.01543162f, -0.05865409f, 0.07120741f, 
    0.01022314f, -0.06564930f, 0.02381954f, 0.09536267f, 0.06002286f, 0.08810501f, 0.13770817f, 0.00130257f, 
    -0.11599964f, -0.01153348f, 0.09073175f, -0.03771687f, 0.06086750f, -0.04820662f, -0.08090352f, -0.04344860f, 
    0.02826684f, 0.07818536f, -0.08939198f, 0.02103811f, 0.01191745f, 0.11272570f, 0.04384165f, 0.03549707f, 
    0.14417589f, -0.02610026f, -0.02266380f, -0.04668653f, -0.10813407f, 0.05282144f, -0.47166619f, 0.25299343f, 
    0.06658498f, 0.19861932f, -0.20256999f, 0.18534186f, -0.15282556f, 0.13958023f, -0.06928300f, 0.01975224f, 
    0.05451934f, 0.17086874f, -0.08110613f, 0.10493701f, -0.00703531f, 0.18891658f, 0.06364338f, -0.00438487f, 
    -0.04457921f, 0.00709625f, -0.29585776f, 0.15152994f, 0.08688302f, 0.17049401f, -0.12699224f, 0.08101248f, 
    -0.00607839f, -0.02923868f, -0.05085531f, 0.08541854f, 0.03625066f, 0.01918251f, 0.03604463f, 0.07802525f, 
    0.01593938f, 0.12926503f, 0.24126004f, -0.07960991f, -0.19616531f, 0.14311917f, -0.04824181f, 0.06508339f, 
    0.18710284f, 0.04379696f, -0.01093142f, 0.00541474f, -0.10122051f, -0.00529225f, -0.02821861f, 0.00888352f, 
    0.23021652f, 0.20425718f, 0.22228178f, -0.04128901f, 0.10858281f, 0.08065416f, 0.00592083f, -0.06310958f, 
    0.09744530f, -0.33711758f, -0.30821115f, 0.02336057f, 0.03952818f, -0.01460249f, 0.01134455f, 0.07453305f, 
    0.02845015f, -0.23286501f, 0.02229199f, 0.01797941f, 0.09382984f, 0.05326497f, 0.08145811f, 0.07015262f, 
    -0.02838058f, 0.15814398f, 0.17761596f, 0.00001745f, -0.59917891f, 0.12098186f, 0.07751445f, 0.06676565f, 
    0.12155280f, -0.00803520f, -0.03839507f, -0.01685335f, 0.02734289f, 0.06411036f, -0.01928166f, 0.12920122f, 
    0.22433402f, -0.05442856f, -0.03495261f, -0.12474593f, -0.07859996f, 0.03184175f, -0.03221246f, -0.04103079f, 
    -0.07360261f, -0.13894227f, -0.03819985f, -0.03724801f, 0.09692717f, -0.12335412f, -0.03360045f, -0.06121215f, 
    0.02698326f, -0.00790160f, 0.09900087f, 0.25393462f, 0.22155830f, -0.08368316f, 0.05646154f, -0.06528194f, 
    0.04064403f, -0.10275292f, 0.23070888f, 0.04250428f, -0.16929540f, -0.10292733f, -0.27323383f, -0.04150962f, 
    -0.04117201f, -0.03435944f, -0.16031939f, 0.04951321f, -0.08379948f, -0.03408889f, -0.07857028f, 0.03715983f, 
    0.01559458f, -0.01363826f, -0.00971669f, 0.03581813f, 0.01586314f, 0.15115096f, 0.00495129f, -0.01519098f, 
    -0.46832278f, -0.14388035f, -0.17814165f, -0.24557026f, -0.13528399f, 0.05251277f, -0.25584671f, -0.03979736f, 
    -0.18569735f, 0.25036526f, -0.05654552f, 0.05122414f, -0.02888267f, -0.03779156f, 0.01474399f, -0.02212528f, 
    -0.04443162f, -0.05053801f, 0.04097157f, 0.00040835f, -0.23174432f, 0.07319523f, -0.03669816f, 0.14595245f, 
    0.04789719f, 0.07847931f, 0.09015056f, 0.07166298f, 0.00187340f, 0.09289673f, 0.04282941f, -0.04030374f, 
    -0.06989577f, 0.03456669f, 0.12308979f, 0.13341098f, 0.17717876f, -0.00056941f, 0.01437537f, 0.17338738f, 
    0.50345862f, 0.05623225f, 0.04705831f, 0.11134849f, 0.09911211f, 0.08691851f, 0.07613526f, 0.08800017f, 
    0.15104349f, 0.18917693f, 0.15054043f, 0.00462563f, 0.05750737f, 0.11182226f, 0.03517411f, 0.09157360f, 
    0.18087782f, 0.01974356f, 0.14681128f, 0.03640575f, -0.28761873f, -0.18494055f, -0.17834318f, 0.18523456f, 
    0.01918614f, -0.08280542f, -0.21816294f, -0.05629015f, 0.05375852f, 0.01986417f, -0.01245979f, 0.02416005f, 
    -0.08669615f, -0.09712549f, -0.07695684f, -0.05929446f, 0.04359788f, 0.23581274f, -0.00445287f, -0.00652882f, 
    0.41955400f, -0.06509506f, 0.32393599f, -0.19654740f, -0.01358456f, 0.07555532f, 0.21676944f, 0.09076440f, 
    0.05347282f, -0.08457465f, -0.05858048f, 0.08994009f, -0.05955849f, -0.02819645f, 0.09704991f, -0.09759040f, 
    0.10017018f, 0.09875661f, 0.05464441f, 0.08818608f, -0.21320727f, 0.27743709f, 0.20517632f, 0.03470902f, 
    0.40785325f, 0.08725896f, -0.06003841f, -0.02738552f, -0.04529247f, -0.00544433f, 0.00155124f, 0.02757673f, 
    0.16091175f, 0.04650286f, -0.03442000f, -0.07659997f, -0.04702395f, -0.04101720f, -0.06632642f, -0.09521341f, 
    -0.02016273f, 0.19038247f, 0.16200596f, 0.23022047f, 0.15467222f, 0.00134039f, 0.11027040f, -0.00977565f, 
    -0.09647963f, 0.06888974f, 0.11797091f, 0.00604258f, 0.05025972f, 0.06547197f, -0.08435976f, -0.05074203f, 
    -0.10248537f, -0.11241528f, -0.09300729f, 0.03077902f, -0.06440494f, -0.19346593f, -0.04443443f, -0.08536742f, 
    -0.26206949f, 0.01327297f, -0.04023099f, 0.03277467f, 0.10703841f, 0.14282881f, 0.06687254f, -0.00647231f, 
    0.01170120f, 0.20673215f, 0.10164239f, 0.04040433f, 0.02372195f, -0.07695843f, -0.00161164f, 0.02314360f, 
    0.13197963f, -0.23269083f, -0.17316172f, -0.15427561f, -0.08360172f, 0.02446148f, -0.00027455f, 0.03541883f, 
    -0.00362561f, -0.06247201f, 0.09640196f, 0.07768998f, 0.04364852f, 0.01360354f, 0.07047060f, 0.06468748f, 
    -0.07174440f, 0.08453106f, 0.02051035f, -0.07379385f, 0.03304944f, 0.06316570f, 0.27586424f, 0.28997603f, 
    -0.01116004f, -0.11533518f, 0.03771851f, -0.03916789f, 0.07230007f, -0.05623126f, 0.04120319f, -0.07950521f, 
    -0.04896944f, -0.09720358f, -0.05051097f, 0.01484415f, 0.06738424f, -0.26776212f, 0.00478196f, 0.07112835f, 
    0.03274943f, -0.11438317f, 0.07637921f, 0.29123124f, 0.06093619f, 0.06051932f, 0.07188799f, 0.05128096f, 
    0.01977417f, -0.11875506f, 0.02066304f, -0.05617502f, -0.05829255f, -0.02396790f, -0.07337793f, 0.02390707f, 
    0.08544851f, -0.06809760f, -0.07324545f, 0.21444802f, -0.08759855f, -0.46862376f, -0.02007707f, -0.06307967f, 
    0.10234107f, 0.00860688f, -0.07429137f, 0.12538916f, -0.10614789f, -0.00744788f, 0.02213035f, 0.12469707f, 
    -0.10939019f, -0.09433264f, 0.01560865f, 0.10216838f, 0.03081995f, 0.02231785f, 0.09712695f, 0.09840475f, 
    -0.08890403f, 0.17791942f, 0.12598383f, -0.03698406f, -0.15078934f, 0.01915952f, 0.04234587f, 0.00970160f, 
    -0.02809218f, 0.04870923f, -0.12561497f, -0.04205517f, 0.00960692f, 0.03210236f, -0.08472620f, 0.01017668f, 
    0.05599616f, -0.08034490f, -0.02195616f, 0.04394462f, 0.38506058f, 0.07545419f, 0.09260881f, 0.24843138f, 
    0.00741617f, -0.10012920f, 0.00796874f, 0.14009814f, 0.03133429f, 0.01507282f, 0.12988371f, 0.13255487f, 
    0.00651029f, 0.02390061f, -0.13575581f, -0.02334320f, -0.05471670f, -0.01571068f, -0.04409974f, -0.04237336f, 
    -0.09308787f, -0.20928077f, 0.06884924f, 0.14061001f, 0.03289422f, -0.06178618f, 0.06319627f, -0.03111982f, 
    0.00383274f, -0.06321609f, 0.05929932f, -0.05733788f, -0.01760316f, 0.13789672f, 0.10232858f, 0.00241996f, 
    -0.03934032f, -0.00293746f, -0.15488891f, -0.07655974f, -0.01841764f, 0.13981114f, 0.07988543f, 0.30384028f, 
    0.13700520f, -0.15655917f, 0.04307175f, -0.06661902f, -0.06918453f, -0.00526384f, -0.03828286f, 0.02206009f, 
    -0.02911841f, -0.07893351f, -0.12907402f, 0.01045812f, -0.00498067f, -0.09482142f, -0.04768864f, 0.13875927f, 
    -0.02030137f, 0.33749965f, 0.18939041f, 0.42372420f, 0.06354877f, -0.20194465f, 0.10375675f, 0.00484668f, 
    0.17713931f, 0.01080275f, 0.00322453f, 0.02895209f, -0.00805708f, 0.04115621f, -0.11624176f, -0.04056813f, 
    -0.05143865f, -0.04291007f, -0.08910349f, -0.05338984f, 0.13319634f, -0.33865258f, -0.47223711f, 0.25935102f, 
    -0.08830550f, 0.13944346f, -0.14210054f, 0.10781831f, -0.09466196f, -0.06523719f, -0.17562929f, 0.00294550f, 
    -0.06361762f, 0.05613566f, -0.05121184f, 0.02169163f, -0.06978577f, 0.04855005f, 0.12127991f, 0.01150783f, 
    -0.27285188f, 0.10677697f, 0.18756154f, -0.06023321f, 0.14138396f, 0.02778481f, 0.04075746f, 0.07246783f, 
    0.09063375f, 0.01468695f, 0.08077309f, 0.00772743f, 0.02425458f, 0.07288931f, 0.06332936f, 0.05133427f, 
    0.03278741f, 0.06017344f, -0.04450823f, 0.05859361f, 0.14655419f, 0.28763548f, -0.18409719f, 0.21197829f, 
    -0.07709167f, -0.01538614f, -0.13019376f, 0.10991213f, -0.01478894f, -0.00148412f, -0.05715869f, -0.08543029f, 
    0.04919542f, 0.04344276f, -0.08261240f, -0.02510863f, -0.05471761f, -0.22134288f, -0.00853586f, 0.01142254f, 
    0.08570398f, -0.03648924f, 0.07195890f, 0.13595915f, 0.13246474f, 0.08710343f, -0.03296343f, 0.00643503f, 
    -0.03404276f, 0.20730598f, -0.04434696f, -0.01433981f, 0.01488739f, -0.07272337f, -0.11155669f, -0.00895362f, 
    -0.02205179f, -0.07531251f, 0.08614790f, 0.04505267f, -0.14980163f, 0.05128054f, 0.54182267f, 0.36855599f, 
    -0.18362871f, -0.21691558f, 0.01488182f, -0.07263205f, -0.08342996f, 0.12058713f, 0.16065767f, -0.01679538f, 
    -0.13544916f, -0.08848455f, 0.08376451f, 0.01095321f, -0.04299424f, -0.04675974f, -0.07561240f, 0.03681652f, 
    -0.02156876f, 0.01679800f, -0.05471243f, 0.03267221f, -0.04766072f, 0.00312657f, -0.00830065f, 0.03965563f, 
    -0.02234606f, 0.02027759f, -0.00184089f, 0.01072657f, 0.03895174f, -0.02623780f, 0.04025374f, 0.02787970f, 
    -0.02328600f, -0.06325039f, 0.02351466f, 0.00105239f, 0.01501676f, -0.01879567f, 0.04507625f, 0.00166908f, 
    0.04427046f, 0.04118687f, -0.05451172f, 0.04106564f, -0.02417027f, 0.04435130f, 0.00403240f, -0.02998407f, 
    0.01739665f, -0.03227912f, 0.02650536f, 0.03702714f, 0.01126428f, -0.04141359f, 0.03569074f, 0.00205167f, 
    0.03828105f, 0.00552037f, -0.03551525f, 0.03328662f, 0.01470587f, 0.02154229f, -0.02046700f, -0.01337623f, 
    0.00959300f, 0.01602178f, 0.04045374f, -0.01740234f, 0.00715126f, 0.04257003f, -0.05567510f, -0.05141536f, 
    0.03807597f, -0.03848799f, -0.05015873f, 0.02995664f, -0.04322722f, -0.04018918f, -0.03357456f, 0.03941443f, 
    0.00085023f, 0.03587110f, 0.00278486f, -0.01044754f, -0.00043847f, 0.03118456f, -0.03383016f, 0.01308056f, 
    0.04159694f, 0.03501181f, -0.04955134f, -0.00955133f, 0.01379305f, -0.05306530f, -0.04125331f, -0.03883623f, 
    0.04408263f, 0.03821456f, 0.04239438f, 0.01028140f, 0.00463597f, 0.03610692f, -0.00971915f, -0.00784205f, 
    -0.06143869f, -0.03841403f, 0.03411077f, 0.02426148f, 0.00107134f, -0.06085089f, 0.00754541f, 0.02675235f, 
    -0.00302765f, -0.03931822f, -0.00968921f, 0.03329353f, -0.05913230f, -0.00424322f, 0.00383547f, 0.04720417f, 
    -0.04119617f, -0.05311994f, -0.03215918f, -0.05198688f, 0.04397940f, 0.03790976f, 0.01094706f, 0.02762149f, 
    -0.04873204f, -0.00042683f, 0.00944953f, -0.05429257f, 0.01727611f, -0.02575831f, 0.02239187f, 0.00811300f, 
    -0.04902151f, -0.04335422f, 0.01074970f, -0.01002404f, -0.00404511f, -0.04815934f, -0.04248539f, -0.03045774f, 
    -0.00703790f, 0.00722642f, 0.03264445f, -0.04303704f, 0.00411672f, -0.00090397f, 0.00462760f, -0.00936843f, 
    -0.04892651f, 0.00764341f, -0.00725889f, -0.02450164f, 0.00480462f, 0.04926751f, 0.01913241f, -0.03054291f, 
    0.04106548f, -0.04925817f, -0.05259185f, 0.01938380f, -0.02332307f, -0.02355027f, -0.02890420f, 0.03191844f, 
    0.01193508f, -0.05749375f, 0.03364536f, -0.02245450f, -0.00462915f, 0.03586293f, 0.04142102f, -0.00961360f, 
    -0.03808441f, -0.01848706f, -0.00673984f, 0.02571749f, -0.01277523f, -0.04532880f, 0.04286079f, -0.02831500f, 
    -0.05301724f, -0.02296693f, 0.00612023f, -0.03031438f, -0.00524332f, 0.03766386f, 0.00619222f, -0.04001198f, 
    0.01144084f, -0.03686880f, -0.05600436f, -0.00647180f, -0.01854727f, -0.05845896f, -0.00906402f, 0.01771501f, 
    -0.01674150f, 0.03979654f, -0.00627046f, 0.02330359f, 0.03518701f, 0.01535697f, -0.04982898f, -0.00735228f, 
    -0.04007861f, -0.05770928f, 0.04484036f, -0.04408645f, 0.01451026f, -0.04957380f, -0.00243155f, 0.00847991f, 
    -0.06199498f, 0.00618231f, -0.04317815f, 0.04371248f, -0.02149900f, 0.03089088f, -0.03957089f, -0.01167928f, 
    -0.05830152f, 0.04518029f, 0.00442459f, -0.00398791f, -0.00549347f, -0.01235518f, 0.00739972f, -0.04701291f, 
    0.04057462f, -0.01697583f, -0.01404325f, -0.04433661f, -0.02422331f, -0.00459063f, 0.03693486f, 0.02751546f, 
    0.01813641f, 0.04259147f, 0.03630250f, -0.04613923f, -0.04055677f, -0.00947713f, -0.03918913f, 0.00361994f, 
    -0.01826572f, -0.01071194f, -0.05943860f, -0.00882521f, 0.01271820f, 0.02552143f, 0.03267663f, -0.05407825f, 
    -0.02170788f, 0.00539625f, -0.05842999f, -0.03402578f, 0.01769494f, -0.00287271f, -0.03169617f, -0.00216789f, 
    -0.06252818f, -0.01096043f, -0.01044431f, 0.00201928f, 0.01833824f, 0.02268220f, 0.03499696f, -0.00772159f, 
    -0.03308753f, -0.05637829f, 0.03346659f, -0.02656483f, 0.00745917f, -0.02539923f, -0.00053360f, -0.02202242f, 
    0.00609719f, 0.02670616f, -0.01239700f, -0.03693615f, 0.04431232f, -0.04463501f, -0.05810328f, -0.02120567f, 
    -0.06376490f, -0.06074946f, -0.01571727f, 0.00538301f, -0.00796886f, 0.04450150f, 0.00180223f, 0.04333629f, 
    0.03147366f, -0.03044684f, -0.00441810f, -0.05168480f, -0.06085189f, -0.03662860f, -0.05384319f, 0.00248406f, 
    0.04765406f, -0.04189958f, -0.00325333f, -0.03660910f, -0.05554175f, -0.04256059f, 0.01486199f, -0.02011772f, 
    0.03941341f, -0.06368715f, 0.02239817f, -0.05849076f, -0.00174661f, 0.05006779f, 0.03772810f, -0.03125446f, 
    0.02379643f, -0.02630137f, 0.02396165f, -0.01547508f, 0.03747766f, -0.02062968f, -0.04926090f, -0.05083497f, 
    -0.03413501f, -0.00214435f, -0.00139495f, 0.01587277f, 0.01913991f, 0.02945253f, 0.04397225f, 0.01991404f, 
    -0.15320794f, -0.11138983f, -0.10729099f, -0.03943432f, -0.09831187f, 0.03567208f, -0.06776562f, 0.05948251f, 
    0.05637393f, 0.20209031f, 0.13761179f, 0.13435414f, 0.12189882f, -0.00205993f, -0.07221769f, -0.02312466f, 
    -0.03085075f, -0.04692997f, -0.10179351f, 0.00560317f, 0.00598010f, 0.13559096f, 0.06642611f, 0.03738420f, 
    0.08452483f, -0.13302402f, 0.02672346f, -0.13137352f, -0.05926258f, 0.08670723f, 0.00241350f, -0.06314312f, 
    -0.14137639f, 0.04399673f, 0.03942299f, -0.05182928f, 0.16243058f, -0.11988774f, -0.02245967f, 0.07966297f, 
    0.25428677f, 0.21456641f, 0.20607233f, 0.14017218f, 0.22093737f, 0.00910820f, 0.00652188f, 0.05433159f, 
    0.03589119f, -0.13493176f, 0.03690650f, 0.00713477f, -0.06182299f, -0.02736254f, 0.04398144f, 0.04887632f, 
    -0.07148918f, -0.12046904f, -0.17371210f, -0.07253189f, -0.28584734f, -0.43824327f, -0.37298927f, -0.66115338f, 
    -0.07473645f, -0.06054467f, 0.09106556f, -0.02986280f, 0.14909741f, 0.10052003f, 0.05040101f, -0.01707971f, 
    -0.02238218f, -0.00871507f, 0.11584269f, -0.03599903f, 0.05478939f, -0.02849983f, 0.10636745f, 0.22996695f, 
    -0.36821440f, -0.26517347f, -0.00673002f, -0.40374932f, 0.03396544f, 0.07153877f, 0.20621626f, 0.13770920f, 
    0.01816611f, 0.08262004f, -0.01996191f, 0.00813940f, 0.13337202f, 0.10526962f, 0.20015386f, 0.00189306f, 
    -0.06794818f, 0.00955679f, 0.24007897f, 0.08836878f, 0.20638977f, -0.00938437f, 0.20031910f, 0.21058920f, 
    0.21977837f, -0.06592946f, -0.02491235f, -0.00725990f, -0.03850023f, -0.15640910f, 0.02279279f, 0.05259167f, 
    -0.12005440f, 0.03017193f, -0.04806833f, 0.21396758f, -0.01948819f, -0.11484186f, 0.08599789f, -0.00928479f, 
    -0.11198056f, 0.16069105f, -0.26659748f, -0.04631391f, 0.00013463f, 0.16195031f, -0.02443651f, 0.13276422f, 
    0.00757662f, 0.47403204f, -0.08451433f, 0.06043711f, 0.05261233f, 0.07014199f, 0.02870223f, -0.03104180f, 
    0.10223920f, -0.08390300f, 0.11273060f, 0.03019744f, 0.45425004f, -0.56663853f, -0.39371005f, -0.04784178f, 
    -0.26616898f, -0.04889599f, 0.07301217f, -0.03708683f, -0.07345329f, -0.29988188f, 0.05430053f, 0.04536706f, 
    -0.03637297f, 0.05820630f, -0.10978652f, -0.06453273f, -0.01937565f, 0.09108295f, 0.03767473f, -0.03714810f, 
    -0.02062445f, 0.14437027f, 0.05680171f, 0.00593319f, -0.05646627f, -0.03650037f, -0.00177984f, -0.04229539f, 
    -0.07822925f, -0.04745025f, -0.01083886f, 0.02563375f, -0.10977886f, 0.09295236f, -0.06652670f, 0.03880922f, 
    0.02418255f, -0.13583143f, -0.09202567f, -0.05258479f, -0.09990919f, -0.10407341f, -0.22339977f, -0.40020019f, 
    -0.06779812f, 0.12381591f, 0.03915389f, 0.13637798f, 0.18716331f, 0.19514279f, 0.05385017f, 0.03358279f, 
    -0.01752130f, 0.03161004f, 0.11446001f, -0.06353271f, 0.01147738f, 0.04876493f, 0.06152250f, 0.18907401f, 
    0.07938180f, -1.00886512f, -0.55005300f, -0.41636270f, -0.61172688f, 0.08201797f, 0.02884557f, -0.06435758f, 
    -0.00144653f, -0.20540908f, 0.01302878f, -0.11562523f, -0.03722938f, 0.00807167f, -0.09772129f, -0.04431927f, 
    0.05974431f, 0.01403157f, 0.00757770f, 0.11455782f, 0.28868535f, 0.33884510f, 0.24381703f, 0.05616071f, 
    0.16382140f, -0.13260004f, -0.04815147f, 0.13979168f, -0.00854516f, -0.13126421f, -0.18779340f, -0.03008529f, 
    -0.04163582f, 0.08004413f, 0.01594977f, 0.21382251f, -0.02236315f, 0.07833371f, 0.10043363f, -0.15270881f, 
    -0.30800277f, -0.12050149f, 0.13669150f, 0.02045902f, -0.13180375f, 0.26883185f, 0.05926729f, 0.10793146f, 
    0.01710869f, -0.18908583f, -0.01391980f, 0.02836841f, 0.11634910f, -0.00334801f, 0.09944326f, 0.07565168f, 
    0.07376399f, 0.09303991f, -0.05060152f, 0.19731665f, 0.00597553f, -0.10764438f, -0.19315080f, -0.22255374f, 
    -0.01057761f, -0.05093563f, 0.11175519f, -0.00931265f, 0.05635205f, 0.15251680f, 0.05870181f, 0.22124994f, 
    -0.14250764f, -0.11071295f, -0.11218473f, 0.01491309f, 0.01924114f, -0.08124270f, 0.05678941f, -0.06058786f, 
    -0.01021655f, 0.52639347f, 0.36135620f, 0.24743697f, -0.00993578f, 0.03427203f, 0.06863062f, 0.00003821f, 
    0.09282017f, 0.23178749f, -0.03405739f, -0.08527913f, -0.05166397f, -0.02093502f, -0.10143219f, 0.09436221f, 
    0.02346750f, -0.04517997f, -0.04562534f, 0.11837146f, 0.12782401f, -0.85487527f, -0.60331142f, -0.07032930f, 
    -0.68854952f, 0.14298640f, 0.05275447f, -0.09531228f, -0.04504808f, -0.16821732f, -0.10563592f, 0.00300195f, 
    -0.11748556f, 0.01041735f, 0.08621595f, -0.01108479f, -0.00845206f, 0.07027660f, -0.02757666f, 0.11926612f, 
    0.30599055f, -0.18362509f, -0.48023188f, -0.18411942f, -0.09896813f, 0.16783684f, -0.09991019f, 0.00813526f, 
    0.10632412f, 0.02351717f, 0.02392365f, 0.15393785f, 0.08813025f, -0.11297034f, -0.05000106f, -0.09627282f, 
    -0.02944127f, -0.13214126f, -0.10905654f, 0.11604173f, -0.46275353f, -0.02337792f, 0.03955809f, 0.24187186f, 
    0.31001645f, -0.10923471f, 0.05362311f, -0.23866829f, -0.08288070f, 0.10173131f, -0.17297435f, 0.01344787f, 
    0.01901582f, -0.05375193f, -0.05012825f, 0.05790199f, 0.05039436f, -0.05116607f, 0.02279664f, -0.02047303f, 
    -0.22522382f, 0.00952348f, 0.12608862f, -0.01649518f, -0.05407146f, -0.06380272f, -0.06514470f, -0.34029144f, 
    0.04741521f, 0.03681215f, -0.07600605f, -0.03618737f, -0.07632642f, 0.08489396f, 0.00296226f, -0.04417843f, 
    0.07559800f, 0.11359024f, -0.12181003f, -0.10028165f, 0.07748883f, 0.02753693f, -0.04817828f, -0.09098167f, 
    -0.00182742f, 0.17589188f, -0.17395313f, 0.13139006f, -0.17901227f, -0.00536560f, -0.11248615f, 0.00774473f, 
    -0.01392401f, 0.10838916f, 0.01685224f, 0.02511262f, -0.06094532f, 0.16247053f, 0.04313595f, 0.08438721f, 
    0.16510649f, 0.18442592f, -0.01083833f, -0.24282646f, -0.05330052f, 0.13722217f, -0.04088956f, -0.02024479f, 
    0.02194683f, 0.04669492f, -0.02067909f, 0.06096912f, -0.00942665f, 0.01348779f, -0.00327553f, 0.03058938f, 
    0.08906145f, 0.11603937f, -0.00914156f, 0.11671226f, 0.06142887f, 0.11756082f, -0.12827532f, -0.15655994f, 
    -0.07707284f, 0.01189034f, -0.10488909f, 0.02921948f, 0.07351343f, 0.05129202f, 0.13062638f, 0.01558712f, 
    0.03550033f, 0.24826939f, 0.15783502f, -0.01970303f, 0.08572783f, 0.06595756f, -0.02584237f, 0.19635697f, 
    0.05049048f, -0.02469323f, 0.17391357f, 0.07045043f, 0.05495062f, 0.02844848f, 0.07914941f, 0.05183071f, 
    0.11859703f, 0.03054269f, 0.01255787f, -0.07079588f, 0.06862810f, -0.02473502f, -0.13242878f, -0.02570065f, 
    0.06034668f, 0.05552526f, 0.19986437f, 0.11295113f, -0.33346841f, -0.22309351f, -0.22168081f, -0.23195373f, 
    0.30272123f, 0.13366579f, 0.09193959f, 0.08908182f, 0.00752631f, -0.04578917f, -0.05071951f, -0.05342780f, 
    0.03679898f, 0.05680747f, 0.07477556f, -0.03373459f, 0.05234824f, -0.02213188f, -0.09461360f, -0.08894910f, 
    0.11457341f, 0.00502491f, -0.08952626f, -0.13481508f, 0.04505435f, 0.12614422f, -0.06681766f, -0.25488257f, 
    0.18139510f, 0.03152420f, -0.06365230f, 0.06436566f, 0.08798109f, -0.04977126f, -0.11199649f, -0.14213942f, 
    -0.07059027f, -0.14560015f, 0.12997204f, 0.01781042f, 0.35570252f, 0.02454433f, 0.02259079f, -0.35269305f, 
    0.05998937f, 0.21308081f, 0.09092879f, 0.16227607f, 0.01620413f, -0.06575790f, 0.03269220f, -0.07701591f, 
    -0.04920532f, -0.01876081f, -0.07636693f, -0.01130926f, -0.16194306f, 0.11833467f, -0.17054436f, 0.03041716f, 
    0.36247900f, -0.07195919f, -0.03424482f, -0.28228238f, 0.20138864f, 0.32676253f, -0.03661811f, 0.13297211f, 
    -0.07741862f, -0.09772161f, -0.02490363f, -0.06314725f, 0.03421764f, -0.04947740f, 0.12689446f, 0.03644057f, 
    0.00981594f, -0.02197889f, -0.08109625f, -0.04733546f, 0.09240627f, 0.82394427f, 0.15118717f, -0.33948827f, 
    0.10924806f, 0.13032652f, -0.13214684f, -0.07719638f, 0.28809831f, -0.08438129f, -0.03883225f, 0.18811625f, 
    -0.06258929f, 0.08015159f, 0.21873228f, 0.12809220f, 0.09971774f, -0.06116911f, 0.08166332f, -0.06976296f, 
    0.47193611f, 0.00138554f, 0.10519637f, -0.07938491f, -0.09053910f, 0.11747374f, 0.05826024f, -0.02888749f, 
    0.01611976f, 0.14454623f, 0.15210874f, -0.11329200f, -0.10605510f, 0.13911550f, 0.00675526f, -0.00156008f, 
    -0.03828745f, 0.00100887f, -0.18735349f, -0.00655241f, 0.07771229f, -0.04633495f, -0.43667394f, -0.02875145f, 
    -0.14442413f, 0.17696057f, -0.02193585f, -0.08586255f, 0.02945437f, -0.01803931f, 0.08056144f, 0.19286536f, 
    -0.02127454f, -0.00637064f, -0.03755933f, 0.04428673f, -0.02977603f, -0.03425360f, 0.08978363f, -0.10605355f, 
    -0.04656563f, 0.11585033f, 0.74847704f, -0.07256817f, -0.02699481f, -0.01468007f, 0.07573067f, -0.15095656f, 
    0.20266706f, -0.01179744f, 0.05560015f, 0.02556745f, 0.03692868f, 0.03919980f, 0.01825763f, -0.00861266f, 
    0.08406689f, 0.10942458f, -0.11708713f, 0.17361145f, 0.12177765f, -0.06324143f, -0.05734916f, -0.19992028f, 
    0.38690999f, 0.15715355f, 0.10248055f, 0.23007952f, -0.13223068f, 0.15586479f, -0.04510626f, -0.00818681f, 
    0.13937929f, 0.15559347f, 0.19975689f, -0.15351732f, 0.00180289f, 0.02858576f, -0.00287250f, -0.11177460f, 
    0.01950610f, -0.02182513f, 0.00827953f, -0.04289109f, 0.01403749f, 0.03056509f, -0.02337020f, -0.02733389f, 
    -0.05643279f, -0.00384061f, -0.06028919f, 0.01635843f, -0.01667198f, 0.03058410f, -0.02748093f, -0.03112913f, 
    -0.01099482f, -0.06018371f, -0.03086263f, -0.05995404f, -0.04958693f, 0.01822948f, -0.05347963f, -0.04110764f, 
    -0.01836546f, 0.00421365f, -0.03167731f, 0.03570008f, -0.00356702f, 0.04145299f, -0.04548461f, -0.03055414f, 
    -0.04547806f, 0.00434418f, -0.02401249f, -0.02023438f, 0.02259367f, 0.04318894f, 0.02710796f, -0.01919014f, 
    -0.03567351f, 0.01986346f, -0.01757380f, -0.03243027f, -0.02003104f, -0.01549185f, 0.04365923f, 0.00151616f, 
    0.01622409f, -0.01505797f, -0.00201272f, -0.02822893f, 0.02106182f, -0.05210007f, -0.01932877f, -0.04959840f, 
    -0.05686679f, -0.05636965f, -0.05375313f, -0.03113851f, 0.03425396f, 0.04380783f, 0.02375876f, 0.03716694f, 
    -0.05665558f, 0.02622782f, 0.00670083f, -0.00032411f, 0.02575637f, -0.00440141f, -0.02895245f, -0.02629970f, 
    -0.05311834f, -0.05866784f, 0.01239404f, 0.03690259f, -0.01364644f, 0.02714484f, -0.02782801f, 0.01110761f, 
    -0.04290039f, 0.03319092f, 0.01044663f, 0.04125180f, -0.05590473f, -0.01342529f, -0.05525069f, -0.01849436f, 
    -0.04740840f, -0.05206860f, -0.03566470f, -0.03920281f, 0.01466224f, -0.01666663f, -0.06096796f, 0.00188548f, 
    0.00410732f, -0.03277379f, -0.00581656f, -0.04153822f, 0.02222054f, 0.05255517f, -0.01480288f, 0.02747220f, 
    0.03115140f, 0.02187519f, 0.01039838f, -0.02685193f, -0.03754890f, -0.00458062f, -0.03571016f, -0.04112555f, 
    -0.04484001f, 0.01855765f, -0.03629198f, -0.00937301f, 0.03903355f, -0.06192145f, 0.02154754f, -0.04087001f, 
    0.04844600f, -0.06006838f, 0.02624305f, 0.02803389f, -0.02750408f, -0.06276660f, 0.01089049f, 0.03808837f, 
    -0.06504034f, 0.03289861f, 0.03201653f, -0.05817138f, -0.03024746f, -0.01572396f, -0.02073157f, 0.04460377f, 
    -0.06004184f, 0.04835249f, 0.02362685f, 0.03170966f, 0.00780285f, 0.00371546f, -0.01741043f, 0.03992542f, 
    -0.02593563f, -0.00903214f, -0.00764017f, 0.01903304f, -0.06399391f, -0.06279371f, 0.04478169f, -0.01376274f, 
    -0.03561430f, -0.03804637f, 0.03107373f, -0.03483234f, -0.03790995f, 0.03623756f, 0.04679598f, 0.00136268f, 
    -0.00358772f, -0.00494769f, -0.04351752f, 0.04705012f, -0.00921801f, -0.03204732f, -0.02154992f, -0.02021733f, 
    -0.00840990f, -0.03739156f, 0.02897923f, 0.02177853f, 0.01836371f, 0.01990725f, -0.03335221f, 0.01240540f, 
    0.04377006f, 0.01053009f, -0.04270408f, 0.00638769f, -0.05070077f, 0.01687601f, 0.00883313f, -0.02585652f, 
    -0.01769878f, 0.04376467f, 0.04360754f, 0.01761195f, 0.04584853f, -0.01977150f, 0.04632321f, 0.00285796f, 
    -0.03806162f, 0.04883829f, 0.04167288f, 0.03802080f, -0.03965425f, 0.02796715f, -0.04922631f, 0.04729197f, 
    0.00682474f, -0.04306713f, -0.05138429f, -0.04783447f, 0.04509564f, 0.03011422f, 0.01388566f, -0.04483355f, 
    0.02877221f, -0.02168924f, -0.00498690f, 0.00426740f, -0.05863836f, -0.02623199f, -0.02095941f, 0.00955945f, 
    0.04367787f, 0.00282818f, -0.04131050f, 0.02556068f, -0.01365577f, 0.02791600f, -0.05614284f, -0.01638018f, 
    -0.02845318f, 0.05106515f, -0.04616836f, 0.00493715f, 0.02893436f, -0.01371224f, 0.03490069f, -0.05076310f, 
    0.02977140f, 0.04238614f, 0.04087401f, -0.06078450f, 0.01258826f, -0.05105324f, -0.04989646f, -0.00929549f, 
    -0.02694330f, -0.02570145f, -0.03275979f, 0.01500407f, -0.00596651f, 0.01500547f, -0.04892828f, -0.02142941f, 
    0.01686257f, 0.02651359f, -0.05990532f, 0.02221972f, 0.01751282f, 0.03556136f, -0.05931097f, -0.04903292f, 
    0.00025928f, 0.03626746f, -0.01050245f, -0.03330931f, 0.03485267f, -0.00932574f, 0.00155673f, 0.01579890f, 
    -0.01168744f, -0.02680838f, -0.00951255f, 0.03195119f, 0.02385417f, -0.04572901f, -0.03923565f, -0.04516036f, 
    0.03820392f, -0.02094785f, 0.04673442f, -0.00167234f, -0.02704799f, 0.03026659f, -0.03524181f, -0.04113305f, 
    -0.05278578f, -0.04312266f, -0.06674603f, 0.03380641f, 0.01346271f, 0.03431128f, -0.02159971f, -0.02658254f, 
    0.03691272f, 0.00196737f, 0.04834193f, 0.04229660f, -0.01639282f, 0.03021867f, -0.02810972f, -0.05627763f, 
    -0.05791917f, -0.04531020f, 0.00669437f, 0.03951559f, -0.00839135f, 0.05122185f, -0.03892934f, -0.04905380f, 
    0.00881227f, 0.03023746f, -0.00975913f, -0.01528293f, 0.02722856f, -0.02303248f, -0.03064577f, 0.03862066f, 
    0.00640686f, 0.04087856f, 0.01154634f, -0.02696855f, 0.00209638f, 0.05960465f, 0.03597709f, -0.02351367f, 
    -0.03343635f, 0.01983905f, 0.03707175f, -0.06018388f, 0.02321998f, -0.03258355f, -0.01403681f, -0.05681421f, 
    -0.06001468f, 0.03493747f, 0.01558542f, -0.00893072f, -0.05657186f, -0.02209913f, -0.01852248f, -0.03056083f, 
    -0.03407485f, -0.03616813f, -0.02809917f, -0.05839045f, 0.04069118f, -0.04753920f, -0.02277748f, 0.03642177f, 
    -0.01807771f, -0.05511525f, -0.06528770f, 0.02513219f, 0.02669553f, -0.02997361f, 0.03978737f, 0.03415281f, 
    0.00868446f, -0.02699289f, -0.03591297f, -0.02379796f, -0.01339341f, -0.05762940f, -0.05880347f, 0.03900674f, 
    -0.03125582f, -0.00923140f, -0.04099412f, -0.01299816f, -0.00921634f, -0.02655026f, 0.01981213f, -0.00174427f, 
    -0.04856088f, 0.02394566f, -0.05397202f, -0.02305131f, 0.03394570f, 0.00590881f, -0.02950527f, 0.02999957f, 
    0.04484294f, -0.05404442f, -0.03690098f, 0.00903814f, -0.02653537f, -0.04529554f, 0.00621211f, -0.05089189f, 
    -0.00783256f, 0.04196030f, 0.03654230f, 0.02836632f, -0.02322971f, -0.02144697f, -0.01816747f, 0.01575395f, 
    0.02557689f, -0.02352937f, -0.00709597f, 0.00606984f, -0.01715133f, -0.02314065f, 0.02503284f, 0.04322472f, 
    -0.00072993f, 0.00748289f, -0.02607993f, 0.04384100f, 0.03951386f, 0.00970939f, -0.02579508f, -0.02106272f, 
    0.00524601f, 0.02453857f, 0.00730971f, -0.00440390f, 0.01750625f, -0.05405566f, -0.05256600f, -0.02076785f, 
    0.00887260f, 0.01578641f, -0.03518667f, -0.04711140f, 0.00677368f, 0.03835071f, -0.01855250f, 0.00520796f, 
    -0.04842944f, 0.00892576f, -0.05892333f, -0.01404479f, -0.03393353f, -0.05634972f, 0.00374002f, -0.00940690f, 
    0.03679685f, 0.03843178f, -0.03657854f, -0.04269863f, 0.03859612f, -0.01301096f, -0.01686067f, -0.04946719f, 
    -0.04555986f, 0.03429671f, 0.04396201f, -0.04353327f, 0.01782259f, -0.05749357f, -0.00392016f, 0.02366830f, 
    -0.02236207f, 0.01742967f, 0.02847385f, 0.00870954f, 0.01183086f, -0.00262656f, -0.06119593f, -0.02945918f, 
    -0.06523303f, 0.01042243f, 0.00573229f, -0.05363753f, -0.06626999f, -0.05324293f, 0.04763804f, 0.00409930f, 
    -0.04734528f, 0.00003699f, -0.00848500f, -0.04197441f, -0.02768605f, -0.00923769f, -0.03904398f, -0.05590319f, 
    0.04390281f, -0.02030984f, -0.03658367f, 0.02770289f, 0.03377177f, -0.03506071f, -0.02944421f, 0.04637115f, 
    0.00106941f, 0.04386805f, 0.03259438f, -0.00725230f, -0.02867749f, 0.04642404f, 0.02680119f, 0.03083673f, 
    0.02356229f, 0.01463673f, 0.00617526f, 0.02774603f, 0.00129165f, 0.03918809f, 0.03905654f, -0.03629048f, 
    -0.00504922f, -0.04623008f, 0.03519355f, 0.04836112f, -0.00954727f, 0.03094912f, -0.04094389f, -0.01675234f, 
    0.03686763f, 0.03458752f, 0.01400995f, -0.03250827f, 0.01884148f, -0.06414586f, 0.03412372f, 0.03036491f, 
    0.00218167f, 0.01615973f, -0.05605360f, -0.02833498f, 0.03800290f, 0.03384882f, 0.00966292f, 0.00094956f, 
    0.02957029f, 0.02617355f, -0.03970055f, 0.00539120f, 0.00658680f, 0.04258410f, 0.04457861f, 0.00280785f, 
    0.03267570f, 0.03854884f, -0.02365576f, -0.02744800f, -0.01969217f, 0.00061176f, -0.05518183f, 0.04250913f, 
    -0.00830680f, 0.04299096f, 0.03974941f, -0.02013158f, 0.02996995f, 0.01330321f, 0.00830065f, -0.01793612f, 
    0.03573770f, -0.01007281f, -0.05560994f, -0.01867722f, 0.00897577f, -0.05624524f, -0.03740232f, -0.05758814f, 
    0.02895355f, -0.02770273f, -0.04328471f, -0.04388688f, 0.04458956f, -0.05477926f, -0.05795046f, 0.04985959f, 
    -0.00016274f, 0.02668511f, 0.00474204f, -0.06075061f, -0.04001021f, -0.06473440f, -0.05011084f, -0.02945586f, 
    0.02357734f, 0.00247797f, -0.00129307f, 0.03319969f, 0.00405333f, -0.06175702f, 0.02509774f, -0.06168123f, 
    -0.05318935f, 0.02028278f, 0.01371880f, 0.01111032f, -0.04899875f, 0.00334815f, 0.04940430f, -0.05177366f, 
    0.00867037f, 0.00136321f, 0.00779729f, -0.01302903f, -0.04220080f, -0.04801727f, 0.04510035f, 0.04419120f, 
    0.01083495f, -0.00347943f, -0.04112520f, -0.05279179f, -0.03352881f, 0.03573285f, 0.01232893f, -0.05415410f, 
    0.03838050f, -0.01389639f, 0.03756175f, -0.02819557f, -0.01148073f, -0.05894976f, -0.03760714f, -0.00970803f, 
    -0.05939387f, 0.01455429f, -0.00362728f, -0.02386862f, 0.03118373f, -0.04094991f, -0.03557754f, -0.02663806f, 
    0.00325977f, 0.00171726f, -0.00886041f, -0.05204446f, -0.04982717f, 0.02169218f, -0.00598373f, 0.01873306f, 
    -0.00183958f, -0.01543130f, 0.04029372f, -0.00189397f, 0.04336948f, -0.03513797f, 0.03282660f, 0.01692734f, 
    0.04173006f, 0.02927222f, 0.00684003f, 0.05079600f, -0.03395974f, -0.03857531f, 0.01101696f, -0.03832711f, 
    0.02901717f, 0.08415588f, 0.24063064f, 0.08192328f, -0.12026967f, -0.03322346f, -0.05333994f, 0.11373905f, 
    0.06439968f, -0.04303128f, -0.05089953f, -0.03638914f, -0.12823133f, -0.02576639f, -0.09435585f, -0.08897415f, 
    0.11946322f, -0.00934109f, 0.03116104f, 0.09910762f, 0.37473652f, 0.07747614f, -0.02543752f, -0.14405397f, 
    0.14757386f, 0.02848727f, 0.14068432f, 0.11929556f, -0.05653475f, -0.01343915f, 0.03991054f, -0.02674641f, 
    -0.07151662f, 0.04825158f, 0.02571207f, 0.08788580f, 0.05934355f, 0.22194938f, 0.00285253f, 0.01647328f, 
    -0.03972868f, -0.13469510f, -0.16702217f, 0.19056316f, 0.19405670f, -0.10881167f, -0.03076498f, -0.11799452f, 
    -0.11719020f, -0.05669569f, 0.02038558f, 0.07948308f, 0.02875666f, 0.05713047f, 0.00609639f, -0.02609574f, 
    0.11202563f, 0.05608347f, -0.06302410f, 0.03191330f, 0.02097717f, 0.01002121f, 0.25264531f, -0.04454843f, 
    -0.15558483f, 0.00802365f, 0.10413203f, 0.09567145f, 0.00256721f, 0.03891458f, -0.07692553f, -0.11512791f, 
    -0.02249187f, -0.03057169f, 0.00606450f, 0.11201362f, -0.05669299f, -0.17508209f, -0.04380439f, -0.03088133f, 
    -0.18820028f, -0.01024016f, 0.32293853f, -0.01332413f, -0.06355993f, 0.02781582f, 0.05500491f, 0.12430000f, 
    0.14073870f, 0.02852415f, 0.00308914f, -0.04770185f, 0.00608027f, 0.06912182f, -0.03713546f, 0.03208949f, 
    -0.10195444f, -0.21154937f, -0.01180808f, -0.11414137f, -0.17070280f, -0.20146090f, -0.07372198f, 0.16256736f, 
    0.15597658f, -0.07357405f, -0.04260037f, -0.02448872f, -0.05905569f, -0.13428366f, -0.04585116f, 0.08541781f, 
    -0.02827845f, 0.05644386f, 0.05516520f, -0.10750631f, -0.08318222f, 0.10526393f, 0.00204093f, -0.16094878f, 
    0.26613510f, 0.22591701f, 0.13658595f, -0.05760319f, -0.11906986f, 0.10258925f, 0.07392447f, 0.17167979f, 
    0.10308981f, 0.08318616f, -0.05127893f, 0.05539115f, 0.04743334f, 0.05949639f, 0.03567673f, 0.05232371f, 
    0.00010758f, -0.00340341f, -0.05756776f, -0.09152815f, 0.40546769f, -0.33403423f, -0.38711059f, 0.09468043f, 
    -0.31766400f, -0.09798564f, 0.02857282f, -0.05392047f, 0.02723692f, 0.07056115f, 0.12305676f, 0.02388595f, 
    -0.09006796f, -0.07088335f, -0.03542865f, -0.07599166f, -0.02586786f, -0.01215400f, 0.03430939f, -0.09517851f, 
    -0.17976236f, 0.17779763f, -0.08961669f, 0.19693477f, 0.03421729f, -0.04078498f, -0.13860859f, 0.01142193f, 
    0.00472988f, -0.01588436f, 0.09946125f, -0.08906692f, -0.12072441f, 0.28250128f, 0.17574850f, 0.12281838f, 
    0.12959772f, 0.21973349f, 0.01961750f, 0.08702661f, 0.08065871f, 0.04892447f, 0.25440186f, 0.07928560f, 
    -0.16394231f, 0.09929289f, 0.05626866f, 0.12297943f, 0.10369664f, 0.06737656f, 0.06227687f, -0.04359800f, 
    -0.03417592f, -0.06855681f, 0.00767875f, -0.06176373f, -0.00103139f, -0.16193646f, 0.15579493f, -0.08215541f, 
    -0.04534922f, -0.18916272f, 0.14574969f, 0.18933241f, -0.32162023f, 0.05944597f, 0.07112443f, -0.00731068f, 
    0.10230371f, 0.16012117f, 0.01007375f, -0.10435611f, -0.17116581f, -0.13020998f, -0.10039068f, 0.00029735f, 
    0.01870945f, -0.05732732f, 0.05370613f, 0.12239940f, -0.11099781f, -0.53654432f, 0.08064915f, 0.23346137f, 
    -0.23363277f, -0.00320749f, -0.11157795f, -0.00946463f, -0.03339894f, 0.08394861f, -0.08668607f, 0.04778202f, 
    0.02747044f, 0.02291085f, 0.06876754f, 0.14047249f, 0.00666709f, 0.07237239f, 0.05897072f, 0.06469087f, 
    0.05508339f, -0.08396903f, 0.24778175f, 0.28923818f, 0.18937853f, 0.22978678f, 0.07811444f, -0.03795619f, 
    0.10068191f, 0.12781917f, -0.04978396f, -0.04513841f, 0.11405998f, 0.05806583f, 0.05182009f, 0.01649618f, 
    0.04253291f, 0.04054359f, 0.16082250f, 0.08013196f, 0.17594229f, 0.07348549f, 0.21622670f, 0.10262930f, 
    -0.02242171f, -0.21921411f, 0.10841539f, 0.03054410f, -0.09858669f, 0.05450288f, 0.02721977f, -0.01309782f, 
    0.07444197f, -0.10385612f, 0.00101871f, -0.03971263f, 0.10681707f, -0.05198868f, 0.10709109f, 0.07409575f, 
    0.00025840f, 0.30314159f, -0.18155710f, 0.45655864f, -0.24422482f, 0.14820364f, -0.00272657f, 0.08509404f, 
    0.05811603f, 0.11729655f, -0.12061037f, 0.05496404f, -0.05772550f, -0.08720538f, -0.15472443f, 0.18724728f, 
    -0.03688027f, 0.12757471f, -0.02980072f, -0.00921587f, -0.12356695f, -0.46303901f, -0.06824371f, -0.09320576f, 
    -0.42646933f, -0.03017160f, -0.01790272f, -0.06922288f, 0.17951381f, 0.00430311f, -0.03423623f, -0.05091168f, 
    -0.02315731f, -0.01867932f, -0.00559635f, -0.12946609f, -0.20276611f, -0.07822776f, 0.00133576f, 0.01124582f, 
    -0.01094575f, -0.01588567f, -0.04588082f, 0.03741885f, -0.04143804f, -0.05115733f, 0.04109754f, -0.00516282f, 
    0.03956311f, 0.02760871f, -0.05659565f, 0.03799296f, -0.04844957f, -0.01183982f, 0.04549894f, -0.04373348f, 
    0.01628474f, -0.01361000f, -0.00838859f, -0.02002117f, 0.00039962f, 0.01175287f, -0.02618934f, -0.00312555f, 
    -0.05194127f, -0.03098298f, 0.04212042f, -0.02232941f, 0.01639312f, 0.03360946f, -0.05699677f, 0.02269390f, 
    -0.05986838f, 0.01845084f, -0.00595038f, 0.02876077f, -0.00065929f, -0.04063509f, 0.01893374f, -0.03405042f, 
    0.03106952f, 0.02581144f, 0.01249748f, -0.00976235f, -0.02794302f, -0.03794463f, 0.00682380f, 0.03121460f, 
    -0.05538435f, 0.03621587f, 0.03967767f, -0.00857858f, 0.02874474f, -0.00461440f, -0.01601359f, -0.01320809f, 
    0.02001185f, -0.02197151f, -0.05074383f, -0.00678183f, -0.05092075f, 0.01642895f, 0.04097620f, -0.02575163f, 
    0.01393834f, -0.05560900f, 0.02279851f, 0.04284735f, -0.02830772f, 0.01681172f, 0.04357018f, 0.04394042f, 
    -0.01280495f, 0.03987545f, -0.04614985f, -0.02780702f, 0.01811997f, -0.01492342f, -0.00088493f, -0.02394152f, 
    -0.00928295f, 0.03629301f, 0.04084014f, 0.02394417f, 0.03259003f, -0.02034811f, 0.03589003f, 0.02946141f, 
    -0.00500110f, 0.00572379f, -0.01681341f, 0.00982165f, -0.02130150f, 0.01090145f, -0.03755350f, 0.02783865f, 
    -0.00847145f, -0.03697914f, 0.04299597f, -0.01245903f, -0.00149397f, -0.00265630f, -0.00162823f, -0.03064622f, 
    0.00721467f, 0.03819071f, -0.03340160f, -0.06567502f, -0.02533128f, 0.02428029f, -0.01320435f, 0.03257671f, 
    -0.06116451f, -0.02326049f, -0.05936136f, 0.02826080f, 0.01818978f, -0.01419689f, 0.01564480f, -0.02700985f, 
    -0.06574499f, -0.00153969f, 0.04142714f, -0.05335862f, 0.03293144f, -0.06580611f, -0.02761090f, -0.06205412f, 
    -0.01434066f, -0.00272676f, -0.03298825f, -0.02431275f, -0.03292862f, -0.05059402f, 0.03818988f, 0.03446844f, 
    -0.01993388f, 0.03280894f, 0.00356239f, 0.00093309f, -0.01535998f, -0.04849718f, 0.05225771f, -0.04492486f, 
    -0.01603113f, -0.05472746f, -0.02005598f, 0.03397396f, -0.02248542f, 0.03482420f, -0.04460030f, -0.00396776f, 
    -0.03521728f, -0.05528552f, -0.04705726f, -0.03084625f, 0.03771637f, -0.02682622f, -0.02754132f, -0.03524410f, 
    -0.01846088f, -0.01387616f, -0.06073619f, -0.03451970f, -0.05886800f, -0.02305502f, -0.02132635f, -0.01385758f, 
    -0.00733631f, 0.02761451f, -0.05832560f, -0.00793559f, -0.02861110f, -0.04786508f, 0.00646748f, -0.05997592f, 
    -0.05926244f, -0.05346772f, 0.01250294f, 0.02348875f, 0.01737369f, 0.04132478f, -0.06352405f, -0.03299767f, 
    -0.05499421f, -0.01587190f, 0.01790606f, -0.05964342f, -0.04076487f, -0.02605442f, -0.04622600f, 0.02996711f, 
    -0.04729314f, 0.04564173f, 0.02626968f, -0.05436421f, -0.00791050f, -0.01167494f, -0.03615360f, -0.02970627f, 
    -0.00581182f, -0.01883351f, -0.00847997f, 0.04042128f, -0.04449736f, 0.03542981f, 0.04270277f, -0.02297238f, 
    -0.05539826f, 0.01697600f, -0.05377701f, -0.05915609f, -0.05377026f, 0.03433190f, -0.01815064f, -0.06060556f, 
    -0.00353951f, -0.06166760f, 0.03870195f, -0.05900635f, 0.02665630f, -0.01699536f, 0.02359470f, 0.00522470f, 
    -0.02571181f, 0.03762666f, -0.04602817f, -0.02367105f, -0.03739679f, 0.02670869f, 0.00767463f, 0.02870782f, 
    -0.00944689f, -0.02787639f, -0.04900605f, 0.04196308f, 0.01933775f, -0.04104946f, -0.04240023f, -0.05838800f, 
    -0.00268487f, -0.06071030f, 0.00124441f, -0.01283670f, 0.00949400f, -0.06147261f, 0.01368415f, 0.03544788f, 
    -0.00238356f, 0.00707252f, -0.01952674f, -0.03360718f, -0.01333738f, -0.00696693f, 0.03966223f, -0.05729698f, 
    0.04161832f, -0.00065557f, -0.00040897f, 0.03983505f, 0.03654284f, -0.06381115f, -0.02468329f, 0.00163762f, 
    0.03720747f, 0.03606673f, -0.03240382f, 0.02433669f, -0.01949926f, -0.05669171f, 0.02717362f, 0.00781750f, 
    0.04598980f, -0.01943105f, -0.02368468f, 0.03153310f, 0.01781929f, 0.03189774f, -0.01594005f, -0.02989452f, 
    0.04162580f, -0.01506270f, -0.00759648f, 0.03804811f, -0.05542335f, -0.00127930f, 0.04586883f, 0.00373009f, 
    0.02884589f, -0.02544454f, -0.03335200f, -0.00921188f, -0.03749138f, -0.00625465f, 0.00170594f, -0.06321420f, 
    -0.01354300f, -0.06143332f, 0.04509431f, -0.00466758f, 0.00907357f, 0.01253163f, 0.03791111f, -0.03815329f, 
    0.02611504f, -0.02882138f, 0.02817575f, 0.03643602f, -0.00964821f, -0.02810932f, -0.02428471f, 0.04839222f, 
    -0.01338493f, 0.04136887f, 0.00264436f, -0.03794638f, 0.00059802f, 0.00398468f, 0.01479495f, -0.03495341f, 
    -0.08282372f, -0.01819603f, 0.14705208f, 0.06867905f, -0.11276863f, -0.04197428f, -0.04151601f, -0.15945512f, 
    0.05014277f, 0.05020912f, 0.01138700f, 0.02106155f, -0.00909988f, -0.01921019f, -0.02124578f, -0.02512388f, 
    0.11545243f, 0.03274303f, 0.09086508f, 0.01472559f, 0.06301062f, 0.00678228f, 0.11142568f, -0.19150038f, 
    -0.01836423f, 0.07156765f, 0.12573324f, 0.20135079f, 0.00065883f, 0.07707011f, 0.14518353f, 0.02694377f, 
    -0.01817046f, 0.07780873f, 0.02672733f, 0.15382133f, 0.08340283f, 0.19265926f, 0.00362339f, 0.17148210f, 
    -0.10545007f, 0.09205186f, 0.06674810f, 0.01448012f, -0.03287890f, -0.12207181f, -0.05966648f, 0.03759725f, 
    -0.10748181f, -0.08731049f, 0.01066914f, -0.06532262f, 0.01707259f, 0.00778312f, 0.05153823f, 0.14628984f, 
    0.06443489f, 0.03812280f, 0.07395344f, 0.10674681f, 0.10516486f, -0.25851575f, -0.10391616f, 0.01453867f, 
    -0.16128944f, -0.08760612f, 0.03072314f, -0.02418940f, -0.00222252f, -0.04749731f, 0.07826899f, 0.08952034f, 
    0.08860876f, -0.06353652f, 0.01797094f, 0.01830327f, 0.11276265f, -0.01577591f, -0.01224126f, -0.05774111f, 
    -0.06785863f, -0.28698498f, -0.17064461f, 0.09872970f, -0.14612649f, -0.08840694f, 0.06405117f, 0.18430844f, 
    -0.12888487f, 0.03540055f, 0.10823975f, 0.08128086f, 0.06372973f, 0.06467628f, 0.06660194f, 0.11361110f, 
    0.11172640f, 0.00761486f, 0.07733759f, -0.00901054f, -0.12667046f, 0.06248295f, 0.16883324f, 0.33461580f, 
    0.08594917f, -0.13194509f, -0.07278010f, -0.22097111f, -0.06696918f, -0.20242746f, 0.02630590f, 0.05465376f, 
    0.07872377f, 0.09364343f, 0.02926946f, 0.15626884f, 0.11267052f, 0.16830249f, 0.04255581f, 0.00141874f, 
    0.00023199f, -0.02092245f, -0.19528888f, -0.16376922f, -0.29758897f, 0.08655314f, -0.07862031f, 0.15488939f, 
    -0.09328709f, -0.08402338f, -0.02668548f, 0.09079205f, 0.03315905f, 0.16914615f, 0.12791915f, 0.10995885f, 
    0.09519029f, 0.17174706f, -0.04826497f, -0.04575709f, 0.27983123f, 0.06072582f, 0.51268512f, 0.24376066f, 
    -0.03645420f, -0.15083389f, -0.16275819f, -0.20250212f, 0.00523107f, 0.13424423f, 0.30921301f, 0.00948739f, 
    0.03339103f, 0.12323168f, 0.09942154f, -0.00928688f, 0.00260774f, -0.12715568f, 0.08423423f, 0.05116229f, 
    -0.18379539f, -0.09340931f, -0.05519223f, -0.00977821f, 0.04968984f, -0.09049958f, 0.00872824f, 0.04935643f, 
    -0.12812348f, -0.13883062f, 0.23255484f, 0.04641649f, -0.05034295f, 0.18247022f, 0.29404360f, 0.13991430f, 
    -0.05197713f, 0.02830767f, 0.00112955f, 0.06023184f, -0.02987796f, -0.10225567f, -0.03879265f, 0.03960815f, 
    -0.21910013f, -0.11942676f, -0.16072296f, 0.05186834f, 0.03149062f, 0.01063439f, 0.07768493f, 0.05837595f, 
    0.05799015f, 0.03016304f, 0.04436748f, 0.05030200f, 0.07971145f, 0.00610416f, 0.11990896f, 0.09346955f, 
    -0.24984135f, 0.02346020f, 0.04070799f, 0.14431089f, -0.30827782f, -0.14623187f, -0.17218649f, -0.03574450f, 
    0.07207751f, 0.14362800f, -0.09630232f, 0.07327520f, -0.02851571f, -0.02016858f, 0.00414930f, -0.08219419f, 
    -0.03461009f, -0.09212316f, 0.06657536f, 0.00906158f, 0.08474537f, -0.73183066f, -0.20337702f, 0.18690307f, 
    -0.07212908f, -0.01447201f, 0.06856114f, -0.02688245f, -0.13758929f, 0.16300960f, -0.06336327f, -0.00961684f, 
    -0.01722576f, -0.08146441f, -0.03216702f, 0.24258357f, 0.11194917f, 0.04265813f, 0.13187516f, 0.26557669f, 
    0.04086745f, 0.25265726f, 0.01083961f, 0.28619310f, 0.13799948f, 0.09252565f, 0.11933244f, 0.22560465f, 
    0.20056704f, 0.22626454f, 0.10763427f, 0.07284126f, 0.35927379f, 0.07514297f, 0.04026642f, 0.10178125f, 
    0.21078850f, -0.10418436f, 0.28489795f, 0.02031129f, 0.09281266f, -0.20410553f, -0.04895325f, 0.13226618f, 
    -0.01435831f, -0.07613719f, -0.08856098f, -0.14385691f, 0.07740477f, 0.01612965f, -0.03144173f, 0.10987110f, 
    0.12560774f, -0.09170043f, 0.01448251f, 0.06364742f, 0.03193040f, 0.02532315f, -0.06988931f, 0.16439441f, 
    -0.08173537f, 0.08765379f, -0.57219356f, 0.08120858f, -0.14343907f, 0.20174940f, 0.14058098f, 0.45545480f, 
    0.12118205f, 0.03472765f, -0.05331431f, -0.01177420f, -0.03403139f, -0.09225713f, -0.13415714f, 0.14822978f, 
    0.04729369f, 0.17267641f, 0.29556984f, -0.01852361f, -0.09856173f, -0.28578371f, 0.12666625f, 0.24982300f, 
    -0.11097682f, -0.16973296f, -0.24933635f, -0.11179315f, 0.08157302f, -0.02165234f, 0.11377040f, 0.07316146f, 
    0.06625342f, -0.03550589f, -0.10354476f, 0.04592655f, 0.02444149f, 0.03310091f, 0.11810789f, -0.04569969f, 
    0.07414769f, -0.10657753f, 0.06886307f, -0.06110543f, -0.03516845f, -0.06627114f, -0.06580500f, 0.08479585f, 
    0.13260219f, -0.02714866f, 0.01715126f, 0.05601713f, -0.00281487f, -0.15884243f, -0.06207033f, -0.05464492f, 
    0.03341711f, 0.05995937f, 0.06426083f, 0.00309681f, -0.12217882f, 0.10699633f, 0.12006723f, -0.04084181f, 
    0.09338351f, -0.08585688f, 0.11842122f, 0.11186404f, 0.00672983f, 0.00838893f, -0.02655485f, 0.01680767f, 
    0.06832653f, -0.10108654f, 0.03228551f, 0.08426804f, 0.11314362f, 0.13617009f, -0.08894238f, 0.00533274f, 
    -0.19404474f, 0.05697106f, -0.00220975f, -0.01178829f, -0.10017667f, -0.03577448f, 0.07443853f, -0.00886842f, 
    -0.07177919f, -0.04828091f, 0.01480188f, 0.03107137f, 0.04742033f, -0.03349354f, -0.05095244f, 0.07194827f, 
    0.16026051f, 0.04215473f, 0.00412359f, 0.09934781f, -0.02323012f, -0.39410949f, -0.25366142f, -0.06781395f, 
    -0.06541178f, -0.08546778f, -0.13622972f, 0.07280000f, 0.13671921f, 0.01695059f, 0.01012516f, 0.04413846f, 
    -0.00874340f, 0.01013224f, 0.03036015f, 0.07813409f, 0.04819896f, 0.11497544f, 0.13608319f, -0.08855065f, 
    0.13252127f, -0.33915925f, -0.17504132f, -0.11465368f, -0.13912764f, -0.16409244f, 0.03853837f, 0.10174298f, 
    0.02276695f, 0.08189961f, 0.02721629f, -0.04673451f, -0.02523499f, 0.05746604f, 0.02712054f, 0.09071685f, 
    0.17334828f, 0.04085417f, 0.22678719f, -0.08908299f, -0.09200076f, 0.20562094f, 0.06903537f, 0.19227535f, 
    -0.02519553f, -0.04545756f, 0.03839362f, -0.13308665f, -0.03136231f, -0.10523277f, 0.12964380f, -0.02074973f, 
    0.11284402f, 0.05757021f, 0.11568867f, -0.10864959f, 0.07216688f, 0.00703028f, 0.07132749f, 0.13731647f, 
    0.02440224f, -0.40624937f, -0.19152135f, 0.01206741f, 0.15434936f, 0.14424458f, -0.16071714f, 0.20754738f, 
    0.19937421f, -0.14287740f, -0.06047239f, 0.00815265f, -0.03815451f, -0.07450232f, 0.03255169f, 0.01844883f, 
    0.02348025f, 0.13388622f, 0.07704845f, 0.20602366f, -0.05762159f, 0.00410885f, 0.36095834f, 0.22608368f, 
    -0.02851487f, -0.03952581f, -0.12621880f, -0.16712373f, 0.10026363f, 0.03033487f, 0.09105288f, 0.03442658f, 
    0.15020323f, 0.01947019f, 0.14013396f, 0.02130862f, 0.00305408f, -0.10692793f, 0.02315174f, -0.06703520f, 
    -0.09814354f, 0.10941656f, -0.07445017f, -0.06357986f, -0.05422058f, 0.00096560f, -0.01648408f, 0.07892850f, 
    -0.04344052f, -0.04230837f, 0.06888855f, 0.13865776f, 0.03567260f, 0.00471886f, 0.09181052f, 0.04007377f, 
    0.02348114f, 0.04258094f, -0.00160251f, 0.04444929f, -0.00258969f, -0.29785514f, -0.17332785f, -0.06584584f, 
    -0.23862951f, 0.03108149f, -0.26089889f, 0.04654228f, 0.13276730f, 0.11317946f, 0.03140516f, -0.03412412f, 
    0.07020842f, 0.10515609f, -0.08844092f, -0.06347765f, 0.04230475f, -0.01362354f, 0.20327066f, 0.03435533f, 
    0.22161229f, -0.35648361f, -0.06034897f, -0.19135147f, -0.19799043f, 0.06700286f, -0.39194724f, -0.15424885f, 
    0.18500954f, 0.16458219f, 0.06180127f, -0.04666013f, 0.04963849f, -0.05644437f, 0.05407383f, -0.09722202f, 
    -0.13512622f, -0.06679321f, 0.02789731f, -0.03421016f, -0.00457947f, -0.01458329f, 0.05289532f, -0.08596036f, 
    -0.05778666f, -0.18871073f, 0.03545691f, 0.02597088f, -0.11887419f, -0.02461253f, 0.02545832f, 0.03954837f, 
    -0.01515812f, -0.12248769f, -0.11484392f, 0.11800478f, 0.10002016f, -0.08161777f, -0.12690338f, 0.14738578f, 
    0.46899182f, 0.01812266f, -0.09260201f, 0.13024640f, 0.01487928f, 0.16011627f, -0.01609343f, 0.07018941f, 
    -0.00662309f, 0.11503793f, 0.15225135f, 0.08451438f, 0.05926205f, 0.00668368f, 0.04755396f, 0.02997270f, 
    0.00664070f, -0.09833004f, -0.00642443f, -0.00307066f, 0.12695158f, -0.28151855f, 0.18824455f, 0.10678729f, 
    0.03895040f, -0.28435394f, 0.11107962f, 0.02112508f, 0.04059376f, 0.09989594f, 0.08893358f, 0.10961709f, 
    0.04971999f, -0.09750338f, 0.07786702f, -0.03731453f, 0.05044422f, 0.00288626f, 0.03770426f, -0.02657416f, 
    -0.06754664f, 0.17382523f, -0.38659522f, 0.07685076f, -0.21941175f, 0.15729132f, 0.14694646f, 0.27163067f, 
    0.04949956f, 0.05831044f, 0.10310275f, 0.08322156f, 0.01438822f, -0.14677899f, -0.10809025f, 0.08630115f, 
    -0.03808226f, 0.19019070f, 0.05923360f, 0.01157458f, -0.07919247f, -0.16647559f, -0.17010640f, 0.03125878f, 
    -0.06534126f, 0.07948200f, -0.18759775f, 0.02438072f, 0.19498129f, -0.13620238f, -0.01647955f, 0.16186275f, 
    0.21190445f, 0.09148370f, 0.23338932f, 0.03349292f, -0.05539947f, 0.04418960f, 0.02700304f, 0.03959577f, 
    -0.05373046f, -0.06384015f, 0.04503750f, -0.04276971f, -0.01373746f, -0.04787039f, 0.01791325f, -0.03092970f, 
    -0.03029772f, -0.00800977f, 0.00797506f, -0.05570754f, 0.02518161f, -0.05736288f, 0.02325542f, -0.00669492f, 
    -0.01683569f, -0.04341742f, -0.00184056f, 0.00062035f, -0.02871875f, 0.01650328f, -0.01728437f, -0.05086834f, 
    -0.00638030f, -0.05722179f, -0.02325219f, -0.06394783f, -0.04881038f, -0.04030403f, -0.02973191f, 0.02488969f, 
    0.03705043f, -0.05585073f, -0.00172683f, -0.01813987f, 0.00976854f, 0.01142527f, 0.03644089f, -0.00035180f, 
    0.03682322f, -0.03200345f, 0.00320033f, -0.01953288f, -0.02759331f, -0.05062642f, 0.01442608f, -0.05146792f, 
    -0.01013048f, -0.04319829f, 0.04760019f, 0.01968823f, -0.04770713f, 0.01653177f, 0.02370178f, -0.02350585f, 
    0.04816934f, -0.00559010f, -0.02691199f, 0.02413063f, -0.01954677f, -0.01715828f, -0.05038885f, -0.01947011f, 
    -0.04108346f, -0.03773593f, -0.05207061f, -0.01308014f, 0.00317406f, 0.02951359f, 0.02131451f, -0.04838359f, 
    0.00104010f, -0.03272321f, 0.03310824f, 0.03408600f, -0.00454485f, -0.06507850f, -0.04267162f, -0.04312814f, 
    0.00989641f, 0.01745831f, -0.01995636f, -0.05426253f, 0.03949067f, -0.02777011f, -0.03976167f, 0.04294474f, 
    -0.05321474f, -0.06154986f, 0.02625040f, 0.00741159f, 0.01447891f, 0.00811706f, 0.04453798f, -0.00822449f, 
    0.00725729f, -0.02500128f, 0.01961816f, -0.03323559f, -0.00943349f, -0.03564658f, 0.02468858f, -0.05460712f, 
    -0.01262736f, 0.02940673f, 0.01673224f, 0.00467422f, -0.04503219f, 0.03136170f, -0.00039780f, -0.04583857f, 
    -0.02863160f, -0.05554700f, -0.03479958f, -0.00324586f, 0.02795619f, -0.01150260f, 0.03927471f, -0.01816736f, 
    0.03489437f, 0.04315432f, 0.03263551f, -0.02166403f, -0.02923494f, 0.03453983f, 0.03544169f, 0.04594998f, 
    -0.02821278f, 0.03977843f, -0.06153742f, -0.02073820f, -0.02454970f, -0.05422629f, 0.03650969f, -0.05494724f, 
    -0.02200919f, -0.04551239f, -0.06058143f, -0.03711971f, -0.02484395f, 0.05619707f, 0.04693915f, 0.01937021f, 
    0.04019351f, 0.02436911f, 0.03914275f, -0.00675372f, 0.04018608f, 0.00772525f, 0.03648172f, 0.04183446f, 
    0.00110975f, -0.00990192f, -0.02138997f, -0.05353625f, 0.01969618f, -0.03465240f, -0.05125043f, 0.05180550f, 
    -0.06109482f, -0.00499342f, 0.04835818f, -0.02283078f, -0.02833647f, 0.02230334f, -0.01428515f, 0.01140188f, 
    -0.02144890f, 0.00860564f, 0.03662240f, -0.01240207f, 0.04480911f, -0.01932858f, -0.02958393f, -0.02812080f, 
    0.03090299f, -0.04553451f, 0.01119669f, -0.01763625f, -0.05815119f, -0.02912924f, 0.01630436f, 0.02856278f, 
    0.02286054f, 0.04013523f, 0.04838964f, -0.03344075f, 0.03060687f, -0.05053131f, 0.03758796f, 0.04018411f, 
    0.00567114f, 0.02779037f, 0.01340960f, 0.02132429f, 0.04161686f, 0.01321637f, 0.04119671f, -0.02944781f, 
    -0.03174279f, -0.05675209f, -0.03571012f, -0.05889574f, 0.00427858f, 0.02223312f, 0.00147062f, -0.04399425f, 
    0.02422295f, -0.06049954f, 0.00360068f, 0.04143000f, 0.00516658f, 0.03046637f, -0.00625659f, -0.05364993f, 
    0.03396689f, 0.04490790f, 0.01516410f, -0.01838348f, 0.05067443f, 0.03508513f, 0.02258975f, 0.01704167f, 
    -0.03943202f, 0.00953479f, -0.00469573f, -0.02286963f, 0.03843640f, -0.00113385f, -0.00744374f, 0.01922753f, 
    0.02364074f, -0.04393400f, 0.04918731f, 0.00066000f, 0.01168329f, -0.04045990f, 0.02646559f, 0.00598314f, 
    0.04537821f, -0.02962724f, 0.04425132f, 0.00522248f, 0.04257198f, -0.03863040f, -0.04950700f, 0.02380843f, 
    0.02141349f, 0.00289170f, -0.06366502f, 0.01285898f, 0.03649309f, 0.01535313f, 0.04418765f, -0.05294188f, 
    -0.03533160f, 0.03802985f, -0.02953893f, -0.03214991f, -0.03013777f, 0.04166314f, 0.02575828f, -0.02974886f, 
    -0.01203945f, 0.04185460f, 0.03756104f, 0.03691624f, 0.01357740f, -0.01233317f, -0.04851444f, -0.00222579f, 
    0.04277705f, 0.00270360f, 0.02193804f, -0.04901458f, 0.03596231f, -0.01602531f, 0.00601099f, 0.01824920f, 
    0.01560023f, -0.03217803f, -0.03768436f, -0.02125994f, -0.03151154f, -0.00735234f, -0.02282586f, 0.05100420f, 
    -0.04037294f, 0.00952151f, 0.02674186f, -0.03694075f, -0.05653941f, -0.04925305f, -0.00566872f, -0.04906664f, 
    -0.03415747f, 0.00027172f, 0.02069114f, -0.05815407f, 0.01724931f, -0.00152636f, -0.03938989f, -0.05754759f, 
    -0.00732171f, 0.00259225f, -0.04501967f, -0.04386609f, 0.04693617f, -0.03871220f, 0.01841096f, -0.03911068f, 
    -0.01486635f, -0.04311616f, -0.05436347f, 0.04143539f, -0.03200897f, 0.04769257f, -0.02270431f, -0.00923307f, 
    -0.13834658f, -0.19550055f, 0.04116086f, 0.02749955f, 0.01122583f, 0.19385006f, 0.06895185f, 0.16549663f, 
    0.22603974f, 0.10013010f, 0.07311942f, -0.10852440f, 0.09058053f, 0.08105640f, -0.02895210f, 0.06645307f, 
    0.05198375f, 0.01026492f, -0.00153495f, -0.03502747f, -0.03394104f, 0.13406345f, 0.06730139f, -0.15260054f, 
    0.13063000f, -0.02965366f, 0.02223670f, 0.03050564f, 0.04330707f, -0.01183195f, 0.06582835f, 0.03184044f, 
    -0.07288457f, -0.09435724f, 0.01523635f, 0.12816909f, 0.13880230f, 0.00125385f, 0.16040266f, -0.02020923f, 
    -0.01550969f, 0.06393146f, -0.02721518f, -0.03076668f, 0.01972849f, -0.01190963f, -0.02302515f, -0.01609436f, 
    -0.08369617f, -0.08718167f, 0.07891094f, -0.06240047f, 0.04836575f, -0.00532125f, -0.01984475f, 0.12666543f, 
    0.09476329f, 0.13082926f, 0.16768743f, -0.03946406f, -0.15225880f, 0.03265998f, -0.08880645f, -0.07698174f, 
    0.12348619f, -0.00962857f, -0.04527047f, -0.09576287f, 0.34417489f, 0.11505080f, -0.01173691f, -0.02074534f, 
    0.01647646f, -0.05322518f, 0.06718306f, -0.09580872f, -0.05309273f, 0.05392932f, -0.01286859f, 0.02292841f, 
    -0.00775670f, 0.10390097f, 0.07578461f, 0.02369641f, 0.09559318f, 0.02019616f, 0.12472482f, -0.14181300f, 
    0.01538757f, 0.04236258f, -0.02870491f, -0.01759608f, -0.06655636f, -0.00203296f, -0.07277285f, -0.11727878f, 
    -0.00375606f, 0.00766994f, 0.07259408f, -0.03968729f, 0.18211669f, 0.19459704f, 0.01928622f, 0.38411191f, 
    0.12102351f, -0.05375320f, 0.03157829f, -0.02390609f, -0.02836024f, -0.10638058f, 0.06416238f, -0.12459649f, 
    0.08260488f, -0.14789771f, -0.10924190f, 0.19436915f, 0.05603263f, -0.15232795f, 0.06535762f, 0.00188192f, 
    -0.05283796f, -0.06818523f, -0.14092800f, 0.14775962f, 0.20947407f, 0.01543831f, -0.12106335f, 0.11981957f, 
    -0.00306275f, 0.13616845f, -0.02981979f, 0.13279679f, -0.11320318f, -0.13128412f, -0.01231750f, -0.06551571f, 
    -0.01781597f, 0.03656088f, -0.09035615f, -0.09369196f, 0.07381739f, 0.11758591f, 0.34419346f, -0.08050917f, 
    -0.02804585f, 0.03513133f, -0.08237523f, -0.08071555f, -0.09385079f, -0.07711202f, -0.03962383f, 0.05664403f, 
    0.13546433f, 0.01031181f, 0.12504548f, 0.08225419f, 0.01703900f, -0.07037932f, 0.08332286f, 0.01291218f, 
    0.02145238f, 0.03984268f, -0.14123037f, -0.14581782f, -0.15250780f, 0.00624538f, -0.05563219f, -0.02340182f, 
    -0.18907319f, -0.14535296f, -0.05104568f, -0.00194603f, 0.04734581f, 0.14161715f, -0.08752562f, 0.04455759f, 
    0.00432004f, 0.03864235f, 0.10208559f, 0.05220446f, -0.26514491f, 0.04019586f, -0.02273181f, 0.22042026f, 
    0.07071567f, 0.01796602f, -0.09201192f, -0.16721235f, 0.15839960f, 0.14849025f, 0.05844839f, 0.03646152f, 
    -0.01234885f, -0.09162743f, 0.04058421f, -0.07249136f, 0.08162411f, 0.07046217f, -0.11363578f, -0.03193517f, 
    -0.02759338f, -0.16048388f, -0.25475353f, 0.02587189f, -0.04170992f, -0.00014382f, -0.13257995f, -0.04832774f, 
    0.12241418f, -0.08969881f, -0.05283184f, -0.02159880f, 0.08461659f, 0.00416172f, -0.05088111f, 0.01643514f, 
    0.04950083f, 0.11654636f, -0.09524637f, -0.01722898f, -0.01463775f, 0.30131850f, 0.21158437f, -0.37096196f, 
    0.23940201f, -0.22267336f, 0.11097311f, -0.14285681f, 0.13892032f, -0.12599948f, 0.07851030f, -0.11001147f, 
    0.13555393f, -0.06317127f, -0.07072175f, -0.00777378f, -0.01438696f, 0.04061193f, -0.08907999f, -0.15337791f, 
    -0.00195202f, 0.02419218f, -0.19500515f, 0.15416138f, -0.13142334f, 0.04724469f, 0.06581844f, 0.20317331f, 
    -0.13255605f, -0.03623687f, -0.01665694f, 0.16457601f, -0.11124587f, -0.02756658f, 0.04084492f, -0.06096849f, 
    0.09721838f, 0.04829488f, 0.06292496f, 0.15357825f, -0.17842923f, -0.25784475f, 0.14720473f, -0.15591758f, 
    0.18101439f, 0.08328275f, 0.17415771f, 0.11315021f, 0.15379025f, 0.03432988f, -0.00576674f, -0.04021097f, 
    0.09666342f, 0.08626428f, -0.00273060f, 0.09575303f, 0.04129744f, -0.03626651f, 0.03863670f, 0.07347458f, 
    -0.25023422f, 0.03859457f, -0.19843662f, 0.03738197f, -0.10204387f, 0.02022431f, 0.05449925f, 0.11656828f, 
    0.10668806f, 0.16047738f, 0.11309917f, -0.02896591f, -0.03780212f, 0.05635431f, -0.07918995f, 0.08898551f, 
    -0.08067106f, -0.10025858f, 0.08007327f, 0.02017642f, 0.26134118f, 0.60135883f, -0.12015240f, 0.03396257f, 
    -0.04414345f, 0.30583748f, -0.04665599f, 0.09877864f, 0.15929677f, -0.23997581f, -0.06357435f, 0.02057914f, 
    0.09106109f, 0.01429266f, 0.19524764f, 0.03694927f, -0.04921695f, 0.08549118f, 0.06133455f, 0.02514849f, 
    -0.02767784f, -0.00106428f, 0.04988775f, -0.04214387f, -0.02003402f, -0.00558789f, -0.06247690f, -0.02889133f, 
    0.01107062f, 0.01453439f, 0.01706917f, 0.01770545f, 0.00319595f, -0.01902133f, 0.04307964f, 0.01764220f, 
    0.03901224f, -0.02885400f, -0.05078365f, 0.03205536f, 0.01124194f, -0.00155952f, -0.00890617f, 0.03519171f, 
    -0.03411479f, 0.02829945f, -0.00306548f, 0.03404029f, 0.01220247f, -0.03225198f, 0.01138741f, 0.01069938f, 
    0.02296965f, -0.06262705f, -0.05113508f, 0.01509950f, -0.01538831f, 0.04149336f, -0.05528939f, 0.01228274f, 
    -0.00178457f, -0.03992920f, -0.00154513f, 0.04488567f, 0.02926400f, 0.00866551f, 0.00546785f, -0.05547983f, 
    0.00253172f, 0.01444510f, -0.06107846f, 0.03752887f, 0.02875140f, -0.02227074f, 0.01566107f, 0.02171253f, 
    -0.03634680f, -0.01330364f, -0.01903117f, -0.04732963f, 0.03816806f, 0.02258505f, 0.04258508f, -0.06421690f, 
    0.00761899f, 0.00349962f, -0.02552250f, -0.05180698f, -0.02634747f, 0.04892780f, -0.03466006f, -0.02529252f, 
    -0.00691269f, -0.01396541f, -0.00370663f, 0.04896710f, 0.03366286f, -0.03630572f, 0.04850185f, -0.01327853f, 
    -0.02827288f, -0.00745767f, -0.01449177f, 0.02688573f, 0.03854042f, -0.04350062f, -0.02318180f, 0.02752658f, 
    0.02323714f, -0.03336861f, -0.01124565f, -0.05892602f, -0.04271527f, -0.04317141f, 0.05172956f, -0.04681567f, 
    -0.02934848f, 0.03003313f, 0.04800915f, -0.00410421f, 0.04273395f, -0.01381383f, 0.00379492f, 0.02422176f, 
    -0.05066492f, -0.04802434f, 0.00865736f, -0.02994709f, -0.00566245f, -0.03182576f, -0.04460644f, -0.00200641f, 
    0.04451644f, 0.02964679f, -0.03308409f, -0.04975034f, 0.03804950f, -0.00203702f, -0.00189013f, -0.01902361f, 
    -0.03805538f, -0.01998861f, 0.02068315f, -0.03386658f, -0.03744429f, -0.02944659f, -0.01360665f, -0.01371559f, 
    -0.02188837f, -0.02307406f, 0.01294007f, -0.04132091f, 0.00598592f, -0.03843686f, 0.00039694f, -0.01480060f, 
    0.00845287f, -0.01054653f, 0.03511068f, 0.00087401f, 0.04402917f, -0.06069837f, -0.03695257f, -0.04944250f, 
    0.00640762f, 0.04430380f, -0.01594207f, -0.01913101f, 0.00962354f, -0.00052905f, -0.03377216f, 0.03625752f, 
    0.04979897f, -0.04899391f, -0.05882166f, -0.05108865f, 0.00431584f, 0.01306800f, 0.02717577f, 0.02657893f, 
    -0.05741605f, -0.01416369f, 0.01432694f, 0.00561982f, 0.01966932f, -0.00559427f, 0.03241290f, -0.06075659f, 
    -0.00879606f, 0.01244252f, -0.04978082f, -0.05223338f, 0.01558798f, -0.01134267f, -0.00356085f, 0.04552524f, 
    -0.02299668f, -0.05876578f, 0.03614204f, -0.04729382f, 0.00732972f, -0.01453970f, 0.00317642f, 0.01315458f, 
    0.03528293f, 0.03683321f, -0.05613377f, 0.03603961f, 0.04414586f, 0.01791112f, 0.01630385f, -0.01088143f, 
    0.02488966f, -0.01526093f, 0.03074696f, -0.00212825f, 0.03145161f, 0.01027176f, 0.04641666f, 0.00900371f, 
    -0.01406085f, -0.02260874f, 0.04574704f, 0.03627355f, 0.04153913f, 0.00104311f, -0.02175526f, 0.00857418f, 
    0.03321527f, 0.00206031f, 0.04469570f, 0.00029609f, -0.01553914f, 0.03176411f, -0.04747563f, -0.00381920f, 
    -0.01151736f, -0.05947316f, -0.06147542f, 0.02223195f, -0.02674526f, -0.05911899f, -0.04454443f, 0.00472482f, 
    0.02093198f, 0.01061667f, 0.02688527f, 0.02267284f, 0.04772899f, -0.03333536f, -0.01916874f, -0.00890724f, 
    -0.06716292f, 0.04426191f, -0.05043220f, 0.04447799f, 0.03870149f, 0.01249111f, -0.00104836f, 0.05140679f, 
    -0.00415928f, -0.02847320f, 0.00238075f, 0.03093569f, 0.01360324f, 0.00646359f, -0.03805936f, -0.03047632f, 
    0.02316565f, 0.03437129f, 0.02130558f, -0.00874222f, -0.02383219f, 0.01698932f, -0.02654645f, -0.02486599f, 
    0.01666295f, -0.05974025f, -0.05215294f, -0.03012538f, -0.02070111f, 0.05400646f, 0.03583440f, -0.02198395f, 
    -0.01922413f, -0.01169638f, -0.02056705f, -0.05462499f, -0.01659750f, -0.02844344f, 0.03970112f, -0.00509110f, 
    0.04524688f, 0.04009068f, 0.02257257f, -0.01656683f, -0.01543435f, -0.01304880f, 0.03888409f, -0.01970116f, 
    -0.01038405f, -0.06242276f, 0.02071258f, 0.01456825f, -0.05181149f, -0.04408039f, -0.00067068f, -0.02992364f, 
    -0.04334766f, -0.04470001f, 0.03389732f, 0.00759669f, -0.05509575f, -0.03607640f, -0.00307630f, -0.02073268f, 
    -0.00499817f, -0.02429982f, -0.04713589f, 0.04507764f, 0.04999723f, -0.06523538f, -0.05101159f, 0.00601286f, 
    0.03140036f, -0.02437129f, -0.05957833f, -0.03371887f, 0.03103956f, 0.04235386f, 0.03088771f, 0.00356673f, 
    -0.00325325f, -0.00941903f, 0.02411325f, 0.01639796f, -0.04088641f, -0.05467023f, 0.03079390f, 0.03338269f, 
    -0.02338598f, -0.09028172f, -0.05713920f, 0.11513359f, -0.00781796f, -0.03751740f, -0.10821963f, 0.04405313f, 
    0.03806004f, -0.07633759f, 0.07557957f, 0.08848228f, 0.14715293f, 0.05615434f, 0.01372189f, -0.07228943f, 
    -0.11271108f, -0.02430481f, -0.15726092f, -0.10908833f, 0.15110029f, 0.08823937f, 0.13007307f, -0.04483113f, 
    0.02255646f, -0.02165158f, 0.17723039f, -0.14407600f, 0.05040003f, 0.01871537f, 0.15694623f, 0.06005238f, 
    -0.02770574f, 0.01718005f, -0.02609967f, 0.08226506f, -0.02079703f, -0.18770006f, 0.06947728f, -0.07890511f, 
    0.07987598f, 0.07197089f, -0.02160250f, -0.01956385f, 0.12542309f, -0.01476760f, 0.08193661f, -0.00188299f, 
    -0.03405902f, -0.07150719f, 0.02628303f, -0.11739740f, -0.03829049f, 0.07356688f, -0.05157305f, -0.10074710f, 
    -0.09934986f, 0.10200866f, -0.06180518f, -0.04744762f, 0.10991687f, -0.13050787f, 0.24437442f, 0.04627515f, 
    -0.24285242f, 0.06217868f, 0.04944548f, -0.04721703f, 0.22843927f, 0.02005720f, 0.11717369f, -0.11540125f, 
    -0.12356115f, 0.00490810f, 0.06752973f, -0.01270145f, 0.04346440f, 0.10156558f, -0.02994102f, -0.02552471f, 
    -0.20729052f, -0.08094159f, 0.27429563f, 0.22524515f, -0.10339190f, 0.10240560f, -0.02694079f, -0.22387028f, 
    0.10597145f, -0.03135761f, 0.05650859f, 0.01166769f, -0.02231888f, 0.04884623f, 0.06658382f, -0.07934963f, 
    0.05620966f, 0.06459255f, -0.01344545f, 0.00236250f, -0.08319961f, -0.06952543f, -0.07960421f, 0.17510606f, 
    0.43686646f, -0.02689270f, 0.06748764f, -0.04690926f, -0.02217549f, -0.07032657f, 0.00717039f, -0.07178652f, 
    0.09515400f, 0.03252662f, 0.06074802f, 0.21699917f, 0.18871945f, -0.00681039f, 0.17799723f, 0.10552602f, 
    0.01140352f, -0.00772690f, 0.24663585f, -0.05067636f, -0.18272761f, 0.11776274f, -0.22098157f, -0.10920430f, 
    -0.15890007f, 0.09688806f, 0.00655454f, 0.04211276f, 0.08238853f, -0.05312493f, 0.03272083f, 0.08144838f, 
    0.04645021f, 0.05470290f, 0.08029698f, -0.05139553f, 0.26632157f, -0.26443166f, 0.22530507f, 0.01235509f, 
    -0.23450008f, -0.05150457f, -0.11825181f, -0.01103008f, 0.12534592f, -0.09068911f, 0.09169706f, -0.05251909f, 
    0.08783372f, 0.07862733f, -0.03285722f, -0.04548303f, -0.07544097f, -0.10509859f, 0.05989199f, -0.05699598f, 
    0.03447532f, 0.12623546f, -0.11300043f, -0.13069861f, 0.05646662f, 0.06602749f, -0.01727518f, -0.10446484f, 
    0.06640009f, -0.04453165f, -0.06949095f, -0.04834035f, 0.09280118f, 0.05984031f, -0.10664851f, 0.06562926f, 
    -0.12754861f, -0.09250370f, 0.03508643f, -0.08756456f, 0.15096854f, -0.13009490f, 0.29377675f, 0.29603121f, 
    -0.12806711f, 0.11988409f, -0.09448588f, -0.04638935f, 0.07865811f, 0.02950438f, 0.08338957f, 0.02977054f, 
    -0.01447476f, -0.10724124f, -0.06922089f, -0.02487155f, 0.07661125f, 0.06214031f, -0.13420829f, -0.01559834f, 
    -0.03256917f, -0.16578104f, 0.02169641f, 0.14243454f, -0.29544178f, 0.03621565f, -0.13518181f, 0.00849682f, 
    -0.11678223f, 0.01170964f, 0.04026784f, -0.03959807f, 0.05330278f, -0.08495294f, -0.02273018f, -0.06778391f, 
    0.00900425f, 0.06584726f, -0.13500765f, 0.01501128f, -0.04799681f, -0.11289390f, -0.01370249f, -0.37263337f, 
    -0.07072879f, 0.11327536f, 0.09701632f, -0.13892588f, 0.19302402f, 0.00702151f, -0.01353129f, 0.00769894f, 
    0.13107750f, -0.09609645f, 0.03428898f, -0.02056155f, 0.11253899f, 0.20365542f, -0.02648322f, -0.12163410f, 
    0.12853836f, 0.11389752f, -0.06460458f, 0.24655868f, 0.11418711f, 0.17940326f, 0.20390895f, 0.20634465f, 
    -0.19429055f, 0.07286464f, 0.00973210f, 0.17991662f, -0.08690997f, 0.09421412f, -0.03895638f, -0.06603270f, 
    0.18203954f, 0.07590033f, -0.01109366f, 0.19646560f, -0.09339325f, -0.18640506f, 0.33037680f, 0.07632691f, 
    -0.09427663f, -0.07789041f, -0.05635238f, -0.01721767f, 0.13702413f, -0.14179319f, -0.03894662f, 0.08153459f, 
    -0.06260274f, -0.00278041f, -0.04307451f, -0.02401409f, -0.04178476f, -0.01171614f, 0.09904784f, -0.21944579f, 
    0.16469386f, 0.31692016f, -0.07010733f, 0.10256795f, -0.24941362f, 0.20786333f, 0.10827839f, -0.08117472f, 
    0.03026524f, 0.21519116f, -0.06564298f, 0.01697982f, 0.06758305f, -0.01616143f, -0.05961084f, 0.05484144f, 
    0.01637520f, -0.07370095f, -0.09598768f, 0.03428254f, 0.16187699f, 0.00152591f, 0.10065113f, 0.11981338f, 
    -0.53602809f, -0.08480337f, -0.13960519f, 0.07184365f, -0.02440952f, -0.03305025f, 0.06245448f, -0.06126698f, 
    0.02575145f, -0.02980783f, 0.26501709f, -0.02266347f, 0.03757200f, -0.03487769f, -0.01396722f, 0.12816831f, 
    0.21115887f, 0.11538643f, -0.03537907f, -0.08805083f, 0.11619933f, 0.00606096f, -0.09947474f, -0.19613771f, 
    0.01045604f, -0.07604111f, -0.03446342f, -0.10277119f, -0.11333792f, -0.10247113f, -0.03433914f, 0.00219863f, 
    -0.01825579f, 0.14048640f, 0.06387132f, -0.10332452f, -0.01211041f, 0.09455900f, -0.07650375f, -0.07103965f, 
    0.17563081f, 0.11877624f, 0.02032372f, 0.06392448f, -0.01073480f, 0.05965808f, 0.00844155f, 0.04635715f, 
    -0.07367364f, -0.12804364f, -0.04041589f, 0.01267537f, 0.05646162f, 0.07336669f, 0.06951568f, -0.03669208f, 
    -0.27584398f, 0.08042455f, -0.06504793f, -0.07774916f, 0.02072840f, 0.04070518f, -0.01966064f, -0.07363722f, 
    0.03530450f, 0.07699728f, -0.03093096f, 0.02271391f, 0.03642190f, 0.10041262f, 0.04485726f, 0.10143889f, 
    0.13751183f, 0.03987806f, 0.04737627f, 0.03151773f, -0.00916252f, -0.09453221f, -0.30742785f, -0.13399410f, 
    0.00945843f, 0.18585163f, -0.14564906f, 0.02004128f, -0.06175344f, 0.07399135f, 0.02334128f, 0.00289681f, 
    0.01818614f, 0.14998358f, 0.00369111f, -0.05945127f, -0.06830251f, 0.27499622f, 0.09456187f, -0.01212757f, 
    0.08914655f, 0.04105744f, -0.22469619f, -0.23729855f, -0.08507228f, 0.01966026f, -0.13040967f, -0.10425010f, 
    0.02889709f, -0.03861776f, 0.00765586f, 0.04734505f, -0.01157518f, 0.00989146f, -0.00242532f, 0.02067922f, 
    0.00683112f, 0.26477215f, 0.06044402f, 0.02270853f, -0.07735553f, 0.26346248f, -0.04216136f, 0.09916779f, 
    0.15700059f, 0.02920558f, 0.00095944f, -0.13303751f, -0.00490867f, -0.02580413f, 0.09441698f, 0.10761268f, 
    0.20386161f, 0.14502646f, 0.15344967f, -0.06823477f, 0.11092763f, 0.12922494f, -0.02954146f, 0.02642435f, 
    0.13483894f, -0.21042514f, -0.06371885f, 0.09644178f, 0.01701189f, 0.02705232f, 0.06313865f, -0.00835614f, 
    0.08357137f, -0.17547767f, -0.02891639f, -0.01173295f, -0.01336183f, 0.01934217f, 0.03003515f, -0.10036889f, 
    0.03637298f, 0.15789925f, 0.21571997f, 0.20837493f, -0.35653934f, 0.18423496f, 0.41225630f, -0.17979276f, 
    0.25080484f, 0.08625908f, 0.04820516f, 0.07601026f, 0.07946164f, 0.06553128f, 0.04981874f, 0.10647567f, 
    0.14525071f, -0.02296128f, 0.13048264f, -0.02435509f, 0.04478299f, 0.01848501f, -0.05472539f, -0.00240260f, 
    -0.01251999f, -0.03114361f, -0.15757933f, -0.11001355f, 0.12134738f, 0.06824653f, -0.11569500f, -0.00990547f, 
    0.01026319f, 0.07814334f, 0.07458650f, 0.11144075f, 0.23742849f, -0.15850012f, -0.01070410f, 0.09204185f, 
    -0.07379996f, -0.09175404f, 0.10420100f, -0.03703736f, 0.08411275f, -0.11453537f, -0.11219450f, -0.18746428f, 
    -0.07814872f, 0.11737294f, -0.05679086f, 0.05114925f, 0.00088544f, -0.08748262f, 0.00067460f, -0.02531536f, 
    -0.02495797f, 0.06398619f, 0.00019547f, -0.05419927f, 0.00550197f, 0.04764630f, -0.06096166f, 0.00768513f, 
    -0.11803492f, -0.02997153f, -0.21998732f, -0.31529531f, -0.03454198f, 0.06526097f, -0.03823467f, 0.10743207f, 
    -0.12285878f, 0.15029363f, -0.03234774f, 0.03607973f, -0.03406379f, 0.01666553f, 0.05669121f, -0.04749316f, 
    -0.02087542f, -0.02540911f, 0.02626407f, -0.08341409f, -0.13358164f, 0.07363781f, -0.13722241f, -0.33035740f, 
    0.00329018f, 0.00545846f, 0.12849744f, -0.11404932f, 0.11523079f, 0.09788287f, 0.12261374f, -0.07738737f, 
    -0.09626481f, -0.00615401f, -0.07373584f, 0.15441422f, 0.10747623f, -0.06255681f, 0.04331809f, 0.19861561f, 
    0.36647424f, 0.19334196f, -0.27067727f, 0.09896921f, -0.02468245f, -0.00634593f, -0.12554602f, 0.05028355f, 
    0.04366647f, 0.33445910f, 0.22401741f, 0.08287457f, -0.07077929f, 0.07728871f, -0.11490428f, 0.03073738f, 
    -0.00939611f, -0.06064076f, 0.04506677f, 0.09669252f, 0.01851632f, -0.06342377f, 0.09658981f, -0.08225648f, 
    0.13349664f, 0.01433178f, -0.14849782f, -0.28698593f, -0.04805819f, -0.09298021f, 0.11703838f, 0.07813862f, 
    -0.01363933f, -0.04130378f, -0.06477947f, -0.06290025f, 0.02260449f, 0.21501170f, -0.06186865f, 0.08309844f, 
    -0.00202339f, -0.00124988f, -0.04829408f, -0.14741936f, -0.01563509f, 0.03311180f, 0.21823327f, 0.13666314f, 
    0.13471368f, -0.02888800f, 0.11540940f, -0.02053846f, -0.00411883f, 0.03237307f, 0.00449856f, 0.01536277f, 
    0.10560565f, 0.15151387f, 0.13981976f, -0.00777633f, 0.06756704f, 0.02027867f, -0.15006660f, -0.12175048f, 
    0.56421322f, 0.05687666f, -0.00424600f, 0.20902461f, -0.08891547f, -0.02146064f, 0.11244331f, 0.09589547f, 
    0.16787812f, 0.05889372f, 0.00098042f, -0.07745629f, 0.02039596f, 0.07882579f, -0.05367989f, -0.13937065f, 
    0.13105930f, 0.22378692f, 0.25923759f, -0.12803818f, 0.04034304f, -0.07846892f, -0.07531399f, 0.03796288f, 
    0.09668875f, 0.14563471f, 0.10345003f, 0.12427399f, -0.07067764f, -0.11136227f, 0.01913512f, -0.14793374f, 
    -0.36313534f, -0.29753760f, -0.03674278f, -0.33057731f, -0.15135118f, 0.06437750f, -0.04764450f, 0.00926799f, 
    -0.04212766f, 0.15029050f, -0.04424734f, 0.19196077f, -0.05075888f, -0.13304240f, -0.01046493f, -0.09881289f, 
    0.06597475f, -0.07348093f, 0.02221630f, -0.11433950f, -0.08394121f, 0.09140289f, -0.08497036f, -0.09753456f, 
    -0.10507946f, 0.21647239f, -0.03663977f, -0.00194961f, -0.17774557f, 0.04521098f, -0.01594595f, 0.18854587f, 
    -0.10758945f, -0.19758759f, -0.06525154f, -0.09072015f, 0.02253575f, -0.05418517f, -0.00152759f, 0.04969098f, 
    0.07174790f, -0.19488434f, -0.08336458f, -0.04919913f, 0.06196173f, -0.04853282f, -0.25740206f, -0.02297350f, 
    0.27796999f, 0.08627615f, 0.00165586f, -0.08532132f, 0.04539159f, 0.06559400f, 0.06010886f, 0.08497818f, 
    -0.01202754f, 0.07049778f, 0.09159909f, -0.09540800f, 0.17040128f, 0.34286439f, 0.01039990f, 0.05097406f, 
    0.38698170f, -0.05014872f, -0.22638848f, -0.09624775f, 0.14344621f, -0.01897460f, 0.19057336f, -0.00598191f, 
    -0.07814833f, 0.21079631f, -0.02033377f, 0.07540835f, -0.09328680f, 0.06478783f, -0.01936950f, 0.03393104f, 
    0.19719841f, 0.28961280f, 0.22832838f, 0.19115824f, 0.12257261f, 0.34525964f, 0.17427081f, -0.09857979f, 
    -0.03803794f, -0.16509220f, -0.04013869f, -0.11681822f, -0.00037968f, 0.00655313f, -0.04425911f, 0.01258455f, 
    0.10329349f, -0.05871239f, -0.02551124f, 0.10040769f, 0.16261820f, -0.07812566f, 0.03275897f, 0.32137492f, 
    -0.00875637f, -0.02659510f, -0.20131817f, 0.09663405f, 0.37158567f, 0.00257144f, 0.09886659f, 0.02155644f, 
    0.17447658f, -0.05817857f, 0.01127186f, -0.00964145f, -0.05187417f, -0.11080462f, -0.06612862f, -0.02938943f, 
    0.06993903f, 0.10895719f, 0.09256060f, 0.23611587f, 0.04720088f, 0.56957626f, 0.56039250f, 0.19938292f, 
    0.34534171f, 0.03645961f, -0.18121670f, -0.28219005f, -0.11610471f, -0.05609101f, -0.04220245f, -0.03214593f, 
    0.05621139f, -0.03799270f, 0.04618391f, -0.00177029f, -0.03987305f, -0.07444552f, -0.04253022f, 0.14088617f, 
    0.09929591f, 0.06930929f, 0.26064989f, -0.07913761f, -0.34777328f, -0.00175425f, -0.05560256f, 0.12046565f, 
    -0.19927436f, -0.17703392f, 0.16362666f, 0.10078890f, 0.12083246f, -0.13452397f, -0.04876215f, -0.33087632f, 
    -0.14044033f, -0.28557765f, -0.05463659f, -0.40080279f, -0.02528314f, 0.11059241f, -0.17398870f, -0.10353191f, 
    0.19794950f, -0.04104622f, 0.07963330f, 0.01914867f, -0.05914534f, 0.07187618f, -0.07638817f, 0.10856643f, 
    -0.09927398f, 0.07306065f, -0.04856308f, -0.00364304f, 0.02113014f, 0.09273840f, 0.09874196f, 0.11840385f, 
    0.28921735f, 0.14976951f, 0.17805769f, -0.04160547f, 0.33239561f, -0.07318929f, -0.00070994f, -0.08950389f, 
    0.12548330f, -0.09254999f, 0.08478859f, 0.05577932f, 0.03677376f, -0.14067023f, 0.05226509f, -0.06666187f, 
    -0.17631026f, 0.02260540f, 0.03984645f, -0.10300088f, 0.18888783f, 0.16359368f, 0.11964116f, 0.14072159f, 
    -0.06050776f, -0.33530220f, 0.26498172f, 0.08670931f, -0.40238515f, -0.06647857f, -0.00079863f, -0.15046659f, 
    0.02233442f, -0.17907198f, -0.10815272f, 0.08078425f, 0.03182891f, 0.00121413f, -0.08201761f, 0.11651874f, 
    -0.00776483f, -0.00048105f, -0.00623111f, -0.22079477f, -0.13230795f, -0.14848942f, -0.11392259f, 0.01804397f, 
    0.03311980f, -0.14342123f, -0.02168009f, 0.15020321f, -0.00370709f, -0.05051475f, 0.00058617f, 0.03745754f, 
    0.11928586f, -0.16982146f, 0.00773659f, -0.08268385f, 0.14330450f, -0.03654455f, 0.17629996f, -0.15128358f, 
    0.12480418f, 0.03493509f, -0.12043502f, -0.00732780f, 0.06165778f, 0.19565563f, 0.09716105f, -0.00874651f, 
    -0.05228555f, 0.07454120f, 0.08353401f, -0.26009789f, -0.40223891f, -0.07727205f, -0.25859326f, -0.06766425f, 
    -0.03938396f, -0.01790992f, -0.27594391f, -0.03338461f, 0.41500488f, -0.03285671f, 0.11555299f, 0.30114660f, 
    -0.12268723f, 0.01513793f, 0.17418611f, -0.15613385f, -0.08173590f, -0.15253520f, -0.04738089f, -0.08708508f, 
    0.03730685f, -0.06191516f, 0.05441601f, -0.07052780f, 0.08598781f, 0.30224252f, -0.06512947f, 0.21136759f, 
    0.53422576f, 0.14466906f, 0.02153484f, -0.04707824f, -0.02566683f, -0.08380682f, 0.01688908f, 0.02764248f, 
    0.10906298f, 0.12165811f, 0.03149257f, 0.06293774f, 0.24765596f, 0.12733765f, 0.02114025f, 0.19003819f, 
    -0.02029033f, -0.03522841f, 0.01237214f, 0.03884442f, -0.05320588f, 0.00780251f, -0.06098977f, 0.02711565f, 
    0.03476092f, 0.01437481f, -0.00218812f, -0.03933087f, 0.01320057f, -0.01851927f, 0.04828573f, -0.06194976f, 
    0.02898668f, -0.00255890f, 0.03544471f, -0.01957850f, -0.02699265f, -0.01203578f, -0.00925510f, -0.05497552f, 
    0.02018934f, 0.01187953f, -0.02474103f, -0.00692805f, 0.03051195f, -0.06275227f, 0.04178368f, -0.00281612f, 
    -0.05687769f, -0.05314190f, 0.00049771f, -0.03082700f, -0.02242873f, -0.05323593f, -0.05826743f, -0.02811475f, 
    -0.05935839f, 0.01063190f, -0.00838122f, -0.03267843f, 0.00541147f, 0.01010188f, -0.05799968f, 0.00070205f, 
    0.04041500f, -0.00293613f, -0.03681870f, 0.01936945f, -0.01695003f, -0.01057250f, 0.04425052f, -0.02000938f, 
    -0.00185845f, 0.03592502f, -0.05243290f, 0.00304044f, -0.04875555f, 0.03609243f, 0.01340746f, -0.00831248f, 
    0.00273495f, 0.00034140f, 0.02104833f, 0.02520430f, -0.02000215f, -0.05941892f, 0.00710682f, -0.01168580f, 
    -0.00754192f, 0.00990538f, -0.02293263f, 0.04590037f, 0.01081003f, 0.01215323f, -0.00542015f, -0.02490192f, 
    0.02064359f, -0.04478172f, -0.01965619f, -0.01690562f, -0.03840464f, 0.01860045f, -0.04360428f, -0.00592876f, 
    -0.02474406f, -0.04257899f, 0.03046445f, 0.01005922f, -0.04388588f, 0.01653230f, -0.04094018f, 0.03887190f, 
    -0.05766027f, 0.04995643f, -0.05075356f, 0.00443757f, 0.02226850f, -0.01571342f, 0.03592055f, -0.03762329f, 
    -0.02660085f, -0.01266031f, -0.05772738f, 0.04248728f, 0.04142072f, -0.03557714f, -0.00466022f, -0.00157993f, 
    -0.03480551f, 0.00348145f, -0.06024187f, -0.03364098f, 0.03025665f, -0.00052986f, -0.04197376f, -0.05099970f, 
    0.04348249f, -0.04733705f, -0.02806035f, 0.01298249f, 0.04202541f, 0.04570434f, 0.04720962f, 0.01580103f, 
    -0.04108866f, -0.03206626f, 0.00622788f, -0.04764874f, 0.02286026f, -0.05621587f, -0.04391500f, -0.04538550f, 
    0.00221434f, 0.03468622f, 0.01578152f, 0.01345587f, 0.03477229f, -0.02649213f, -0.00309800f, 0.04039025f, 
    -0.06611826f, 0.03590306f, 0.04192038f, -0.03553863f, -0.00787958f, -0.02088896f, 0.02438400f, -0.00362991f, 
    -0.04723057f, 0.03069181f, -0.04192130f, -0.03238954f, -0.05941523f, 0.00984058f, 0.03127159f, 0.01108769f, 
    -0.00286361f, -0.02874771f, 0.04266905f, -0.05696640f, 0.03236141f, -0.06139449f, 0.01277200f, 0.01032831f, 
    -0.02648571f, 0.03972455f, -0.04774880f, 0.00173377f, 0.00487865f, -0.05471471f, -0.02858924f, 0.00117919f, 
    -0.04005303f, -0.02787914f, 0.01312673f, -0.04212577f, 0.00574819f, -0.05643445f, -0.02404103f, -0.00336055f, 
    0.03127584f, 0.01626128f, 0.03881389f, 0.02025181f, 0.00809965f, -0.03625757f, -0.06150311f, 0.01312244f, 
    -0.04899554f, -0.02887975f, -0.04437127f, -0.05740792f, 0.02346835f, -0.01193844f, 0.03164957f, -0.01659047f, 
    0.01964944f, -0.01512117f, -0.05461569f, 0.03540261f, 0.00618184f, -0.04865745f, 0.00178504f, -0.02616351f, 
    0.02333602f, 0.05087551f, 0.01138926f, 0.03941742f, -0.06022313f, 0.00456753f, 0.00444928f, 0.01697339f, 
    -0.02259276f, -0.04218841f, 0.01427037f, -0.06390565f, -0.01605279f, -0.01604185f, 0.01493525f, -0.01316580f, 
    0.01446374f, -0.04066551f, -0.03430751f, 0.04795928f, -0.02303062f, 0.00834253f, 0.01006086f, 0.00508562f, 
    -0.03603207f, 0.03252365f, -0.00244141f, 0.01700672f, -0.04483753f, 0.00115054f, 0.00660455f, -0.06347635f, 
    -0.05214107f, -0.02674948f, -0.00565311f, 0.01707749f, 0.00460436f, 0.04058676f, -0.04648101f, -0.03969777f, 
    0.01522259f, -0.03197407f, -0.02855769f, -0.02983722f, 0.00168200f, -0.02666407f, -0.00668937f, -0.03857222f, 
    0.04002465f, 0.03126933f, 0.01173680f, -0.03070878f, -0.03702923f, -0.04737671f, 0.04065893f, 0.01977674f, 
    0.01616212f, 0.01138555f, -0.00151873f, 0.03938673f, 0.01342120f, -0.00808512f, -0.00714508f, 0.02132245f, 
    0.00798663f, 0.03949019f, -0.01273695f, -0.00931641f, -0.02542416f, 0.04127896f, 0.04504162f, -0.00380296f, 
    -0.03935826f, -0.03126511f, 0.03134234f, 0.04640549f, 0.03633399f, 0.01134436f, -0.04595335f, 0.03439882f, 
    -0.02303812f, 0.01942342f, 0.02406856f, -0.02144799f, -0.00711104f, -0.03920961f, 0.02336541f, -0.05450355f, 
    0.00964692f, 0.02129484f, 0.01508992f, -0.03435693f, -0.04414679f, 0.04087244f, -0.00208215f, 0.04272068f, 
    0.03689952f, 0.01866479f, -0.02040865f, 0.02741668f, -0.01481862f, 0.02229774f, 0.02458865f, 0.01214198f, 
    0.03538344f, 0.03157290f, -0.04715366f, 0.03495890f, 0.03938696f, -0.04344270f, 0.03596137f, 0.00263623f, 
    -0.01001914f, 0.01249410f, 0.05503124f, -0.00453735f, 0.01371239f, -0.00286575f, -0.03798984f, 0.02005792f, 
    -0.06158069f, -0.02484626f, -0.05576176f, -0.03848160f, -0.04213433f, 0.04139698f, -0.02019561f, -0.00330145f, 
    0.01786449f, 0.03549262f, -0.04175204f, 0.00734001f, 0.04657871f, 0.04591506f, -0.01460084f, -0.02885003f, 
    0.03079696f, -0.01500155f, -0.01093667f, -0.04962258f, -0.01895435f, -0.06257840f, 0.02132885f, 0.03622910f, 
    0.01042835f, 0.00522761f, -0.04943715f, -0.05576782f, -0.01284243f, -0.03377630f, -0.04637905f, -0.06142562f, 
    -0.05344524f, 0.01070096f, 0.01259742f, 0.00441772f, -0.04734209f, 0.02335426f, 0.05037145f, -0.04708746f, 
    0.02323313f, -0.01302870f, -0.05150183f, -0.02766483f, -0.03359587f, 0.00858126f, 0.02584083f, -0.03399251f, 
    -0.03813677f, -0.02363698f, -0.05158995f, -0.06122664f, 0.02541874f, 0.01437063f, -0.02392551f, 0.03219263f, 
    -0.02585476f, 0.04021319f, 0.02487424f, 0.01301205f, -0.05439269f, 0.03637446f, -0.01305603f, -0.02294727f, 
    0.03463823f, 0.02479919f, 0.02487323f, -0.01110412f, 0.03272624f, -0.03004964f, 0.00015117f, -0.02910875f, 
    0.01210044f, 0.03204513f, 0.00338308f, -0.05963422f, 0.00969406f, -0.04139723f, -0.04883450f, 0.01806885f, 
    0.04022437f, -0.02736980f, 0.04174080f, -0.01454237f, -0.03000411f, -0.04791641f, -0.01444322f, -0.00915108f, 
    0.00925214f, -0.00156076f, 0.01833577f, 0.00017826f, 0.01449829f, -0.03554494f, 0.02972907f, 0.00529158f, 
    0.03754786f, -0.02623522f, -0.01209566f, -0.01941209f, -0.00163046f, -0.03191961f, -0.04791830f, -0.04517420f, 
    0.02577766f, 0.03246647f, 0.04988058f, 0.04440053f, -0.04569980f, 0.00465321f, -0.05212625f, -0.00825557f, 
    -0.04422233f, 0.01779933f, -0.04287960f, -0.05228700f, -0.03212961f, -0.06403030f, -0.01045392f, -0.04091820f, 
    -0.02105591f, 0.01864491f, -0.02155667f, 0.00942460f, -0.02555845f, -0.04244187f, 0.02895592f, 0.00771667f, 
    0.04902828f, 0.03461117f, -0.00826786f, 0.04337815f, 0.00265372f, 0.03876429f, -0.03276231f, 0.05517410f, 
    0.03848576f, -0.01146408f, 0.04719857f, 0.04752358f, -0.02214715f, -0.05445633f, 0.03830940f, -0.05458447f, 
    -0.04774262f, 0.01180029f, 0.01112858f, -0.00375509f, -0.01216357f, 0.01622283f, -0.00761568f, -0.01157652f, 
    -0.00820712f, -0.02948383f, 0.00110900f, -0.01255855f, 0.03040088f, -0.02371979f, -0.03264880f, -0.00256489f, 
    -0.05214125f, 0.04107260f, -0.04654183f, -0.04704306f, 0.00789255f, 0.01650599f, 0.01318815f, -0.01845614f, 
    0.04476833f, 0.00850952f, 0.01934202f, 0.04347207f, -0.04019244f, -0.00885648f, 0.02794662f, -0.04604678f, 
    -0.05287092f, -0.01062864f, 0.02988841f, 0.01286008f, -0.04004233f, 0.04066734f, -0.03582069f, 0.03425112f, 
    0.00851430f, -0.05318471f, 0.04503771f, -0.03868152f, 0.02753485f, -0.01692488f, -0.01038733f, 0.04795254f, 
    0.06128417f, -0.00874027f, 0.02736647f, 0.02816353f, -0.05212569f, 0.01818492f, -0.03152912f, 0.04458359f, 
    0.03677529f, -0.01215438f, -0.04852246f, 0.02362415f, 0.03585606f, -0.02560277f, 0.06326140f, -0.03248816f, 
    0.00264602f, -0.00475244f, -0.04311822f, 0.01127618f, 0.04283912f, -0.02659058f, -0.02038486f, -0.04291634f, 
    -0.00180594f, -0.04866037f, -0.03593164f, -0.02165640f, 0.03271417f, -0.01788835f, -0.03613587f, 0.02774259f, 
    0.03000915f, 0.02303944f, -0.03449570f, -0.04485939f, -0.04096084f, -0.01714096f, 0.02534594f, 0.00561213f, 
    0.00887680f, -0.05600730f, -0.05665678f, -0.05544217f, -0.03926793f, 0.04939124f, 0.01547495f, 0.04174896f, 
    -0.04765626f, 0.04036273f, 0.02405696f, -0.00491674f, -0.01739273f, 0.02699841f, -0.04105302f, 0.02283025f, 
    0.04651215f, -0.05802330f, 0.03366542f, -0.06411181f, -0.01549327f, 0.01029748f, 0.02632529f, 0.02639639f, 
    -0.00861365f, 0.03516866f, 0.00236346f, -0.00554750f, 0.02836062f, 0.02231598f, -0.00633236f, -0.06405801f, 
    -0.03182104f, -0.01618425f, 0.00929827f, 0.01618263f, -0.03886991f, -0.02962305f, -0.05149128f, 0.04414461f, 
    0.03309245f, 0.02138370f, 0.04384140f, 0.02806339f, -0.02154124f, -0.01975296f, 0.00525536f, 0.04777963f, 
    -0.03673027f, -0.01839242f, -0.02195194f, -0.00337639f, 0.02340503f, -0.03593342f, -0.06091382f, -0.00882974f, 
    0.02894361f, 0.03181520f, -0.02644943f, -0.03649667f, -0.04455963f, -0.05501153f, 0.04135537f, -0.05037869f, 
    -0.01561671f, -0.00603461f, -0.02774563f, -0.00149346f, -0.04501283f, -0.01942654f, 0.04676474f, 0.02964752f, 
    0.04411188f, 0.04540598f, 0.02753627f, 0.03472662f, -0.00521953f, 0.02079485f, -0.01193197f, 0.02529133f, 
    -0.19502430f, -0.11336259f, -0.39339530f, -0.06427222f, -0.13312754f, -0.17623544f, 0.03157799f, -0.11334126f, 
    -0.02693010f, -0.09121288f, 0.10904124f, 0.02211587f, 0.11986990f, 0.15177259f, 0.03611942f, -0.14176683f, 
    -0.11242583f, 0.04645961f, -0.02354024f, -0.07988822f, -0.19408214f, -0.03047206f, 0.27877051f, 0.16959856f, 
    -0.24635243f, -0.18828431f, 0.12695034f, -0.21771844f, 0.12858358f, 0.12312711f, 0.07933274f, 0.06355084f, 
    -0.04933109f, 0.12777919f, 0.01193129f, -0.04663762f, 0.02614886f, -0.24105841f, 0.11811367f, 0.13550825f, 
    0.34169134f, 0.09661628f, 0.12848203f, -0.06220409f, 0.08127798f, -0.06473463f, -0.00117944f, 0.07891205f, 
    0.07893525f, -0.01080680f, 0.00038934f, 0.05948846f, -0.08915375f, 0.03264808f, -0.00828419f, -0.01516535f, 
    -0.09820459f, -0.03383015f, -0.05846112f, 0.02421935f, 0.24595729f, 0.16773608f, -0.03262737f, 0.14874923f, 
    -0.13524076f, -0.03153696f, 0.09684361f, 0.10991981f, 0.19116339f, 0.08771317f, 0.03739924f, -0.06870130f, 
    -0.02243578f, 0.00359661f, -0.02276537f, -0.00405463f, 0.08069325f, -0.04244635f, 0.12272976f, 0.09560692f, 
    0.05065841f, 0.23272319f, -0.21292013f, 0.20574051f, -0.05750879f, 0.18529558f, 0.02651580f, -0.01081367f, 
    0.01373038f, -0.04442622f, 0.10179511f, 0.06674110f, 0.04587559f, -0.07106137f, 0.12495304f, 0.02504805f, 
    0.03181417f, -0.00953425f, -0.15453660f, 0.03382884f, 0.11586376f, -0.42667133f, 0.24691069f, 0.13932461f, 
    0.19890887f, -0.00870069f, -0.05238611f, -0.08134749f, 0.03602507f, -0.02549682f, 0.12055766f, -0.02525454f, 
    0.09595922f, 0.05141510f, 0.10333838f, 0.19049364f, -0.02293081f, -0.10468423f, 0.05346495f, 0.03630586f, 
    -0.19355613f, 0.15989031f, 0.15050082f, -0.12472985f, -0.40810964f, 0.06226606f, -0.05786910f, -0.02016420f, 
    -0.23628391f, 0.03473552f, -0.04647572f, -0.05646682f, 0.10647874f, 0.01437510f, -0.01020403f, 0.11381071f, 
    0.05497694f, 0.04865146f, -0.06231433f, -0.00499758f, 0.14421104f, -0.17493111f, -0.14029260f, -0.09298480f, 
    -0.08680466f, -0.18342365f, -0.04121897f, 0.14893632f, 0.16441701f, -0.00493280f, 0.12840652f, -0.04949063f, 
    -0.02203647f, 0.05388770f, 0.04228265f, -0.01329831f, 0.01507478f, -0.01395863f, -0.04607388f, -0.05880200f, 
    0.09443562f, -0.21769007f, 0.12186521f, -0.15538566f, 0.24701497f, -0.14493458f, 0.17608927f, -0.10542534f, 
    0.05142326f, -0.05307501f, -0.01863191f, -0.07240238f, 0.05908007f, -0.03636622f, 0.02485369f, 0.04479375f, 
    -0.17563514f, -0.29570368f, -0.17217389f, -0.10858412f, 0.18292432f, 0.11147324f, -0.03618431f, 0.02224524f, 
    -0.00249861f, 0.00533181f, 0.07474940f, 0.12908052f, -0.04091161f, -0.05167839f, -0.03123272f, -0.05199068f, 
    0.01627344f, -0.05471236f, -0.00170261f, 0.14724484f, 0.05215199f, 0.07738121f, -0.12107701f, 0.00126891f, 
    0.03986190f, 0.34100392f, -0.10946319f, -0.05337094f, -0.00866966f, -0.03842993f, 0.08752512f, 0.16871960f, 
    -0.00423875f, -0.16081920f, -0.03572231f, -0.04326393f, 0.08383259f, 0.05540185f, -0.05480048f, 0.04563159f, 
    -0.05693449f, -0.12236010f, -0.17721249f, -0.06440607f, -0.07556613f, 0.28396153f, -0.26685628f, -0.13572992f, 
    0.21770766f, 0.28455311f, -0.07334989f, 0.04780156f, 0.22982347f, -0.10862193f, -0.17146088f, -0.00008343f, 
    0.08456477f, 0.00306584f, -0.03364009f, -0.02354254f, 0.16007410f, 0.02073383f, 0.10437474f, 0.04193841f, 
    -0.17724246f, 0.28875211f, 0.02823669f, 0.02908843f, 0.16939649f, 0.11133463f, 0.16108146f, 0.11904486f, 
    -0.02443037f, -0.00643141f, -0.02016724f, 0.17172422f, 0.02226709f, 0.13363597f, 0.02071683f, 0.16220638f, 
    0.12251891f, 0.04065343f, 0.04632012f, 0.05941375f, -0.10534170f, -0.04444982f, -0.28552678f, 0.09250414f, 
    -0.22627644f, -0.13011950f, -0.23823452f, 0.07131828f, 0.12498249f, -0.19842242f, -0.09039396f, 0.06248077f, 
    0.04796745f, 0.01816441f, -0.01249882f, -0.06993484f, -0.05882359f, 0.08416456f, 0.06573751f, -0.09665433f, 
    0.27373117f, -0.08554344f, 0.17422669f, -0.25437599f, -0.15264425f, 0.14735392f, 0.03208567f, -0.30070800f, 
    0.03307875f, -0.08104360f, -0.04178051f, 0.03559641f, 0.10687054f, 0.05510999f, 0.03195689f, 0.01518235f, 
    0.07046209f, -0.22387283f, 0.09906065f, 0.16075253f, 0.43565813f, 0.07169390f, 0.30880746f, 0.16129717f, 
    -0.23843835f, -0.12467158f, -0.04399767f, 0.17913938f, -0.21261857f, 0.08339018f, 0.14281046f, -0.16403522f, 
    -0.09144348f, -0.04274324f, -0.04890550f, 0.25979477f, 0.07826956f, -0.03716753f, -0.06076568f, -0.10952760f, 
    -0.39039356f, 0.06912320f, -0.08014780f, -0.15829821f, -0.10560670f, -0.08345947f, 0.10717124f, -0.07822956f, 
    0.02160920f, 0.09765796f, 0.09243309f, 0.08656204f, -0.04178273f, 0.02181513f, -0.01182737f, -0.10495188f, 
    -0.02500933f, -0.03506860f, -0.10423267f, -0.17575556f, 0.41336805f, 0.13697425f, -0.02406260f, 0.07094937f, 
    0.02551234f, 0.15091099f, 0.06990094f, 0.02038741f, 0.07063498f, -0.07302390f, 0.04245008f, 0.00721180f, 
    -0.04864979f, 0.02183383f, -0.03294087f, 0.01852381f, 0.01019154f, -0.04961585f, 0.07271560f, -0.05306638f, 
    0.22062601f, 0.11111825f, 0.18271524f, 0.12207328f, 0.22825761f, -0.05563762f, 0.00222471f, 0.00984412f, 
    -0.03182042f, 0.05713945f, -0.00315789f, 0.09738342f, -0.04297249f, -0.01686029f, 0.04133604f, -0.04640877f, 
    -0.04767497f, -0.19013748f, -0.08202102f, -0.12052841f, -0.46810129f, -0.42328766f, -0.81789410f, -0.25114557f, 
    -0.22679788f, 0.14087771f, -0.00751274f, -0.16639243f, -0.14235125f, 0.06978951f, -0.00902108f, -0.02749095f, 
    0.06109772f, 0.08372892f, -0.01548288f, -0.05792960f, -0.00731150f, 0.08550806f, 0.02147325f, 0.15328445f, 
    -0.30200693f, -0.09685462f, -0.69860029f, -0.37139094f, 0.01371835f, 0.23211573f, -0.16446443f, -0.08515207f, 
    -0.08571137f, 0.04304923f, 0.03330740f, 0.01856132f, 0.08576268f, 0.07978768f, -0.04711747f, -0.06652785f, 
    -0.02343729f, 0.10122143f, 0.12700635f, 0.13727885f, 0.14292672f, 0.04636212f, 0.05042869f, 0.04402736f, 
    0.24845004f, 0.01896242f, -0.04044745f, 0.05477554f, -0.03897398f, 0.08620144f, 0.13878918f, 0.17809673f, 
    0.06035024f, 0.03156338f, 0.06114491f, 0.26975492f, 0.18446815f, -0.11548810f, 0.09402049f, -0.13151936f, 
    0.07109505f, 0.07887617f, -0.53549904f, -0.24464503f, -0.09491075f, -0.01056748f, 0.21304494f, -0.07091057f, 
    0.14395693f, 0.07229736f, 0.01220493f, 0.00992402f, -0.01258668f, 0.04658241f, 0.05134463f, -0.09903021f, 
    0.00523914f, 0.04889292f, 0.27236924f, 0.07019281f, -0.09826735f, 0.18838134f, -0.18284003f, -0.28970081f, 
    -0.02740018f, -0.09994089f, -0.03098530f, -0.09288770f, -0.13378379f, 0.05120506f, -0.00383498f, 0.06788505f, 
    0.08889771f, 0.05705181f, -0.00708842f, -0.07876847f, 0.00637054f, -0.07108725f, -0.02252916f, -0.01217603f, 
    -0.02292175f, -0.06133891f, 0.14432175f, 0.06067457f, 0.01946248f, -0.07127332f, -0.05659832f, 0.02139357f, 
    -0.00237165f, 0.09071569f, -0.03706297f, 0.13371529f, 0.09335221f, -0.03732635f, -0.06608690f, -0.06292231f, 
    -0.02649831f, -0.10825413f, -0.01109525f, -0.09086077f, -0.67467004f, -0.29360962f, -0.62948710f, -0.37903392f, 
    -0.20378686f, 0.06990867f, 0.07580353f, 0.02687264f, -0.21322523f, -0.01350944f, -0.03666837f, -0.00569809f, 
    0.01584603f, -0.07726177f, 0.04285948f, -0.05369042f, 0.04448566f, 0.08536267f, 0.16852303f, 0.08596563f, 
    -1.06852424f, 0.21527037f, -0.02788356f, -0.36122471f, -0.46271893f, -0.22366704f, 0.04972898f, 0.08341637f, 
    -0.25539365f, 0.19638562f, -0.06915353f, 0.01690861f, -0.04190753f, 0.02040048f, 0.00947822f, -0.08863587f, 
    0.02944075f, 0.01012992f, -0.04264596f, -0.05386186f, 0.14275047f, 0.11996556f, 0.10172710f, 0.30673066f, 
    0.04289572f, 0.02734449f, 0.11158391f, -0.06062018f, -0.05269297f, 0.09015951f, 0.19735460f, -0.09384996f, 
    0.05900566f, 0.04150885f, -0.05122081f, 0.01395524f, 0.08456844f, 0.09146856f, 0.14945573f, -0.07486070f, 
    -0.36045021f, 0.11786611f, 0.17417780f, -0.08176386f, 0.11520475f, 0.00018497f, 0.05405313f, 0.18357956f, 
    0.25456548f, 0.13173808f, 0.06404553f, 0.12768432f, 0.19322440f, 0.10588749f, 0.04703741f, 0.07881565f, 
    0.24906570f, 0.03396994f, 0.27367780f, 0.19910541f, -0.43236682f, 0.00959793f, -0.07536440f, -0.14229815f, 
    -0.15690199f, 0.10763111f, 0.00139364f, -0.07137258f, -0.07976917f, 0.01763248f, 0.23128679f, 0.09090986f, 
    0.08450148f, -0.01491474f, -0.10487340f, -0.07065604f, -0.08597867f, -0.02877777f, -0.08179275f, -0.04470482f, 
    0.33492723f, -0.24477124f, -0.02196249f, -0.02151744f, 0.37570933f, 0.06377432f, 0.22077152f, 0.16454329f, 
    0.14438818f, 0.03552018f, -0.06112332f, -0.12085622f, -0.06078973f, 0.06716381f, 0.07576887f, -0.01706325f, 
    0.10600072f, -0.01716042f, 0.25274369f, 0.04859228f, -0.16936205f, -0.32101977f, -0.72098523f, -0.46278986f, 
    0.45245627f, -0.15755142f, 0.08207653f, -0.29862893f, -0.05479159f, 0.22623356f, -0.03517718f, -0.10037669f, 
    0.00538673f, 0.07126553f, -0.05789286f, -0.03430234f, 0.16360869f, 0.06173988f, 0.04882364f, -0.04828137f, 
    0.13058268f, 0.14607054f, 0.38834468f, 0.11681219f, 0.11233618f, 0.03889707f, 0.07325901f, 0.05749287f, 
    0.02147591f, 0.14351970f, 0.05830720f, 0.13098767f, -0.16958591f, -0.14814436f, -0.06018068f, -0.03319380f, 
    0.04773306f, -0.06200262f, 0.00596240f, -0.20034972f, 0.36266550f, -0.08844022f, -0.72652578f, -0.74081951f, 
    0.23332837f, 0.03084067f, 0.00834691f, 0.21671198f, -0.12153105f, -0.07806840f, 0.04163357f, -0.00953987f, 
    0.07399898f, 0.00399701f, 0.05970830f, 0.04735935f, 0.07254977f, 0.17469595f, -0.14764933f, -0.12810501f, 
    -0.42313901f, -0.10950053f, -0.66896307f, -0.01926384f, 0.05275126f, 0.00269851f, 0.05663116f, -0.00314044f, 
    -0.01923506f, 0.05878942f, 0.01459219f, 0.10083774f, 0.02482694f, -0.00689250f, 0.08226576f, 0.00238953f, 
    0.09737643f, -0.05453093f, -0.06146172f, 0.06825325f, -0.10290474f, -0.22254917f, 0.25870308f, 0.08584505f, 
    -0.02743804f, -0.12892812f, 0.07506622f, -0.04624764f, 0.01688186f, -0.12428081f, 0.04578247f, -0.12158323f, 
    -0.08698484f, 0.06140447f, 0.08315846f, 0.07885750f, 0.10754981f, 0.06189838f, -0.04325079f, -0.01335227f, 
    -0.18433097f, -0.35115382f, 0.32720801f, 0.11686665f, -0.05419276f, -0.04406548f, 0.01657150f, 0.04518349f, 
    0.03890442f, 0.00692711f, 0.07060627f, -0.07440675f, 0.02523171f, 0.11098450f, -0.04995177f, 0.02913550f, 
    0.08178885f, 0.00263065f, 0.10510321f, 0.00339072f, -0.68690872f, -0.04984223f, -0.45988849f, -0.08402407f, 
    -0.16186284f, -0.14691536f, -0.07598168f, 0.02166617f, -0.11239512f, 0.04900473f, 0.01484044f, 0.12258802f, 
    -0.04545345f, -0.04800224f, 0.02545516f, -0.20838420f, 0.10065573f, 0.00862500f, -0.09459257f, 0.03698434f, 
    0.10157143f, 0.08474360f, 0.19597027f, 0.15265781f, 0.08944833f, 0.08315753f, 0.10941710f, 0.05148603f, 
    0.25164554f, 0.09093887f, -0.01738392f, -0.01325088f, 0.06821388f, 0.10748935f, -0.01402469f, 0.00459065f, 
    0.03912342f, 0.07472572f, 0.02119069f, 0.05425646f, 0.38916585f, -0.05882561f, 0.10532586f, 0.15987177f, 
    -0.09577457f, -0.15806906f, -0.04201740f, -0.21836162f, 0.01020215f, 0.03640926f, 0.12612149f, -0.00987670f, 
    -0.02899147f, -0.01117848f, -0.00659874f, 0.00931196f, 0.01180839f, -0.04631819f, -0.06325751f, -0.11288865f, 
    -0.50421387f, 0.10354397f, -0.47731933f, 0.10083376f, -0.24245663f, 0.22845347f, -0.06717972f, -0.06196572f, 
    -0.02345678f, 0.04016127f, 0.22282507f, -0.03812269f, -0.13620645f, 0.06665773f, 0.15880309f, 0.02318495f, 
    0.12501028f, 0.10419607f, -0.08855806f, -0.04247441f, -0.10258497f, -0.09187927f, 0.18212394f, 0.21716729f, 
    -0.06100040f, -0.01393721f, 0.00056070f, 0.01236961f, 0.04319085f, 0.11116747f, 0.01182487f, -0.01911925f, 
    0.03559034f, 0.09698828f, 0.03677207f, -0.04931283f, 0.04061526f, -0.01571456f, 0.23973285f, 0.10205504f, 
    0.04907006f, -0.13262321f, 0.23119555f, 0.36116633f, 0.00552146f, -0.11616583f, -0.01760088f, -0.06968977f, 
    0.17293710f, 0.32956061f, 0.14383544f, 0.02929642f, -0.14189254f, -0.09485628f, -0.01005016f, -0.10377181f, 
    0.07207503f, -0.17297859f, 0.03437891f, 0.04697621f, 0.22560096f, -1.35427153f, -0.38536507f, 0.17275615f, 
    -0.67671710f, 0.06012019f, -0.04103004f, -0.16827911f, -0.32790950f, 0.06587555f, -0.06240964f, -0.03624831f, 
    -0.05145349f, 0.05592878f, 0.05286624f, 0.09314077f, 0.08271087f, -0.19200496f, -0.02854289f, -0.08368339f, 
    -0.03090342f, -0.09181702f, 0.00762182f, 0.14481038f, 0.10017912f, 0.02834713f, -0.08011960f, 0.11487640f, 
    0.09813416f, 0.18099627f, 0.09749239f, -0.09707839f, 0.17282873f, 0.01884238f, 0.06285930f, -0.09513881f, 
    -0.08099830f, -0.09457655f, 0.07458778f, 0.16115052f, 0.21711698f, 0.13151097f, 0.29747826f, -0.08072661f, 
    -0.02782338f, 0.03439514f, 0.07387736f, -0.10597473f, -0.04762836f, 0.27301908f, 0.15388377f, 0.07385839f, 
    -0.01145265f, 0.00016328f, 0.13232175f, 0.11894274f, 0.04937431f, -0.08591501f, -0.06663952f, -0.19223686f, 
    0.00152494f, 0.37795776f, -0.42163754f, 0.52013826f, 0.13122877f, 0.02430396f, 0.04960804f, 0.16893864f, 
    -0.08303628f, 0.18494719f, 0.03244653f, -0.18227503f, 0.07786080f, -0.17280607f, 0.02396611f, -0.00463173f, 
    -0.02322388f, 0.06562702f, 0.04935892f, 0.00550561f, -0.28846031f, -0.41838586f, -0.00466334f, 0.10900641f, 
    0.03504445f, -0.15465133f, 0.03054739f, -0.24298696f, 0.13572223f, 0.03160084f, -0.17573921f, -0.03157464f, 
    -0.02208528f, 0.18194631f, 0.16090880f, -0.13456616f, 0.02213301f, -0.12183014f, 0.02243712f, 0.04378425f, 
    0.04802550f, -0.04284506f, 0.03188004f, 0.05173398f, 0.04255884f, -0.03580882f, -0.04872046f, -0.05560039f, 
    -0.01691775f, 0.04463512f, -0.00251014f, -0.04680016f, -0.05739677f, 0.02721458f, -0.00157546f, 0.00628919f, 
    0.05081670f, 0.03622555f, -0.02141633f, 0.03244505f, 0.01821702f, 0.01764262f, 0.00723666f, -0.04369829f, 
    -0.00247966f, -0.00504769f, -0.00243678f, 0.00557735f, 0.04646806f, -0.03814642f, -0.02291713f, -0.05522347f, 
    0.03112715f, -0.02494272f, -0.03318654f, 0.04707569f, -0.00247002f, -0.00866975f, -0.00647077f, -0.02366808f, 
    -0.00998564f, -0.02706013f, -0.01047590f, -0.02315259f, 0.01020166f, -0.02189652f, -0.00504624f, 0.00904465f, 
    -0.02650832f, -0.01056654f, 0.02232275f, -0.02692908f, -0.02993584f, -0.04503670f, -0.00924939f, -0.01828139f, 
    -0.05340799f, -0.03317188f, -0.04538518f, -0.02696443f, 0.02987069f, 0.01417602f, 0.03048074f, -0.02920482f, 
    -0.04856609f, 0.00194412f, -0.01567271f, 0.03916253f, -0.05878003f, -0.00366506f, -0.01402175f, -0.05732968f, 
    0.04302569f, -0.03511622f, 0.00840308f, -0.06087882f, -0.01659711f, -0.05161263f, -0.05616923f, -0.05933643f, 
    -0.01700368f, -0.00864758f, -0.00915273f, -0.05871828f, -0.05581718f, 0.02411740f, -0.01820819f, -0.03755982f, 
    0.01440046f, 0.03886974f, -0.05452155f, -0.00616608f, -0.05180228f, -0.02476042f, 0.03974123f, 0.02543584f, 
    -0.04248970f, 0.02872749f, 0.00755074f, -0.02804668f, -0.00801607f, -0.06470162f, 0.02135396f, -0.00467511f, 
    -0.00180191f, 0.02395142f, 0.02360591f, 0.04763211f, -0.00789654f, -0.00357537f, 0.02214819f, -0.01829870f, 
    0.02678294f, -0.00953937f, -0.00132220f, -0.02252228f, 0.04138262f, -0.02948865f, 0.00678729f, -0.01668956f, 
    -0.06458633f, -0.01557181f, -0.01998836f, -0.05681851f, -0.04389254f, -0.01772626f, -0.03061724f, 0.01907672f, 
    -0.06107267f, 0.02711551f, -0.06210198f, 0.02345659f, 0.00396557f, 0.03568782f, -0.00282308f, 0.02831520f, 
    0.00803501f, 0.02598337f, 0.00181361f, -0.03963089f, 0.04599391f, -0.01185411f, 0.04814303f, -0.02836830f, 
    0.03683061f, 0.01117262f, 0.01322366f, 0.02905574f, 0.00624398f, -0.02160943f, 0.03062834f, 0.01280770f, 
    0.02651794f, -0.03095640f, 0.00256315f, -0.03218489f, 0.03554517f, -0.03237229f, 0.03530113f, 0.02980200f, 
    0.04841550f, 0.01055998f, 0.00473553f, 0.00735721f, 0.01437830f, 0.02809341f, -0.03696167f, -0.00622312f, 
    -0.00587466f, 0.00445337f, -0.00826229f, 0.02713163f, 0.00840893f, 0.01960289f, 0.01459697f, 0.01604741f, 
    -0.00530458f, -0.04992194f, -0.05012600f, -0.04170401f, -0.03235282f, -0.01185009f, -0.02029691f, -0.02967128f, 
    0.03997968f, -0.02691615f, -0.00896019f, -0.01714258f, -0.02388244f, 0.01348256f, 0.01912735f, -0.06052366f, 
    -0.05060393f, -0.02051990f, 0.02853868f, 0.00163213f, 0.01747423f, -0.05474155f, -0.06365126f, 0.02666811f, 
    -0.02062751f, 0.04246863f, 0.01528013f, 0.05301475f, 0.04267624f, 0.00845867f, 0.00292461f, -0.05313649f, 
    0.03753831f, 0.02446747f, -0.04934768f, 0.03882679f, -0.02209743f, 0.04422267f, 0.02117309f, -0.03132769f, 
    -0.01008282f, -0.05815307f, -0.02805046f, 0.03990231f, 0.01857681f, 0.00223775f, -0.02588960f, -0.00637290f, 
    -0.00598571f, -0.01176128f, 0.00010284f, 0.04777728f, 0.01501890f, -0.00717799f, -0.01511714f, 0.03086426f, 
    -0.01705289f, -0.04685415f, 0.04753060f, 0.02184745f, 0.01555399f, -0.01559586f, -0.05267708f, -0.04123697f, 
    -0.00540524f, -0.04941550f, -0.06072557f, -0.00216073f, -0.03059499f, 0.00896814f, -0.01405612f, 0.00316835f, 
    0.00710486f, -0.00265361f, -0.02311770f, -0.03718151f, 0.00507710f, -0.03157585f, -0.04630273f, 0.03996811f, 
    -0.03364853f, -0.03469597f, 0.00963667f, 0.03050894f, 0.04963248f, 0.03195174f, -0.04135907f, -0.04696900f, 
    -0.04356443f, -0.05430419f, 0.00979298f, -0.00644396f, 0.00095511f, -0.05677560f, 0.03255353f, -0.01916420f, 
    -0.00769509f, -0.03916714f, -0.05544356f, -0.02392593f, 0.00349386f, -0.05103312f, -0.04070864f, 0.01000092f, 
    0.03266072f, -0.02234354f, -0.03297590f, 0.04639308f, 0.00853321f, -0.01560914f, 0.04355840f, 0.02632681f, 
    0.00741402f, 0.03477713f, -0.03751897f, -0.03537757f, -0.00705943f, 0.00889078f, -0.03160835f, -0.02647285f, 
    -0.04130678f, -0.01770668f, 0.00302607f, 0.00598449f, -0.00243495f, 0.02339317f, 0.01127574f, 0.03453976f, 
    0.02110187f, -0.03468173f, 0.00539459f, -0.06055549f, 0.00887120f, -0.04413556f, -0.03316608f, -0.03595733f, 
    -0.02417068f, -0.01582081f, -0.01742135f, -0.03758897f, -0.06115664f, 0.04531954f, 0.02963971f, -0.05937617f, 
    -0.22189188f, 0.05644624f, 0.02966596f, -0.03015012f, 0.03033957f, -0.20541728f, 0.05338069f, -0.13830952f, 
    0.02806594f, -0.09630366f, -0.13202615f, -0.06466908f, -0.10075457f, -0.00195090f, 0.02528416f, -0.02078370f, 
    0.00277841f, 0.06574772f, 0.12064108f, 0.08104613f, 0.50268096f, -0.04000475f, 0.01428525f, 0.04689001f, 
    -0.05968062f, 0.18595885f, -0.08544397f, 0.16435418f, -0.04948778f, -0.07465961f, 0.04425872f, -0.05933986f, 
    -0.03320706f, -0.01473883f, 0.00356232f, 0.04866512f, -0.08030544f, 0.20760782f, -0.06906641f, -0.03377168f, 
    0.16914450f, -0.01385171f, 0.00890448f, 0.08507989f, 0.12350799f, 0.00520602f, -0.09752226f, -0.06663766f, 
    -0.06981341f, 0.12211003f, -0.05596066f, -0.03000269f, 0.08310322f, 0.04377124f, -0.03524365f, -0.19495709f, 
    -0.04254404f, -0.09756674f, -0.01368240f, -0.00030019f, -0.28833088f, 0.02268850f, 0.05002032f, 0.13400279f, 
    -0.12750216f, 0.08665395f, 0.07292232f, -0.00398933f, -0.06718875f, 0.10750571f, -0.04393798f, 0.05854846f, 
    0.04828704f, -0.03424102f, -0.14127649f, 0.01002726f, -0.08351236f, 0.03102123f, -0.01361279f, 0.05088902f, 
    -0.40484700f, -0.01086793f, 0.04897425f, 0.14467484f, -0.01011519f, 0.13096310f, 0.00418745f, 0.03095241f, 
    0.09977455f, -0.12670740f, -0.03438937f, 0.01248592f, 0.04782135f, -0.03060861f, -0.02997996f, 0.05627379f, 
    -0.14450157f, -0.05632671f, 0.06953450f, -0.02911604f, -0.02725985f, 0.02533747f, -0.02255730f, 0.01377133f, 
    0.15745938f, 0.02061627f, -0.01913986f, -0.05540128f, -0.10239422f, 0.04953711f, -0.10666677f, 0.11937752f, 
    0.09340692f, 0.11366488f, 0.19794612f, -0.14204039f, -0.04082063f, -0.06826556f, 0.05814649f, -0.14763241f, 
    0.07163950f, 0.06736770f, -0.06592586f, 0.02269264f, -0.21705393f, 0.00930349f, 0.29250842f, 0.08587929f, 
    0.08645269f, -0.15493459f, 0.10006479f, 0.01869077f, 0.02816768f, 0.15362863f, 0.11052320f, -0.03129731f, 
    -0.11580303f, 0.06846374f, 0.08980524f, -0.03009609f, -0.44494167f, 0.17228834f, -0.04767145f, -0.13413022f, 
    -0.12236696f, -0.15645152f, 0.09321709f, 0.03010431f, 0.04521572f, 0.14536554f, -0.09284651f, 0.10302332f, 
    0.01967781f, -0.22738257f, -0.04703260f, -0.01881059f, 0.03042900f, -0.01244776f, -0.06173741f, 0.03449660f, 
    0.01407802f, -0.19031791f, 0.03961242f, 0.04963962f, 0.06150048f, -0.08571146f, -0.08091196f, -0.06904475f, 
    0.01831078f, 0.12500766f, 0.11984596f, 0.08110013f, 0.05251762f, 0.08461124f, 0.12717456f, -0.08424592f, 
    0.05827275f, 0.00714408f, 0.11325137f, 0.06381746f, -0.21755512f, -0.06264513f, 0.07133713f, 0.16801332f, 
    -0.03549545f, -0.04886147f, 0.08609158f, 0.03627051f, -0.15395728f, -0.07017255f, -0.06819171f, 0.06143160f, 
    -0.01389415f, 0.02268712f, 0.01422834f, 0.02668966f, 0.02671400f, -0.03785944f, 0.17276676f, 0.07889099f, 
    -0.60178971f, 0.24334617f, 0.00906433f, 0.19454585f, -0.25680032f, -0.20853089f, 0.10441000f, 0.14188378f, 
    -0.13101925f, 0.31627032f, -0.09270775f, 0.13551342f, -0.08285458f, -0.02420410f, -0.06193930f, 0.09867730f, 
    0.09625384f, -0.04566728f, 0.09166025f, 0.10605453f, -0.24835132f, -0.23274815f, 0.03296611f, 0.31719476f, 
    -0.06284075f, 0.13631268f, 0.04766761f, -0.19930598f, 0.07943997f, 0.09678827f, 0.09882995f, -0.01098141f, 
    0.10762804f, -0.06644108f, 0.01705692f, 0.01431613f, 0.11688999f, -0.05092958f, 0.13607149f, 0.03504734f, 
    -0.03850204f, 0.00672213f, -0.01301338f, 0.32427421f, 0.25516096f, 0.08148966f, 0.14672582f, 0.07033642f, 
    0.11036265f, 0.34619278f, -0.03776360f, -0.00616037f, 0.21715479f, 0.10654138f, -0.02933924f, 0.23711984f, 
    0.24743472f, 0.00294579f, 0.32731599f, 0.06740785f, -0.22777124f, 0.11322278f, -0.07598098f, -0.01885649f, 
    -0.16405095f, -0.07879300f, -0.19258760f, 0.01539440f, 0.00715702f, -0.12545986f, 0.10302333f, -0.22244574f, 
    0.05443338f, -0.09731746f, 0.00887018f, -0.02452739f, 0.01306797f, 0.15287170f, 0.03115451f, 0.09239285f, 
    0.18170926f, -0.39545462f, -0.07750956f, -0.05160378f, 0.19357455f, 0.09635706f, 0.08400779f, 0.13774450f, 
    0.17904687f, 0.05769293f, -0.16298112f, 0.07089130f, 0.01281205f, 0.00020127f, 0.08413003f, 0.09269064f, 
    0.06923734f, 0.11658558f, 0.26571578f, 0.05357495f, -0.27459544f, 0.02274081f, 0.12800920f, -0.14063379f, 
    0.16267905f, -0.25321534f, -0.07599552f, -0.07955297f, 0.08349492f, 0.18671769f, 0.07825672f, 0.06038591f, 
    -0.08305215f, -0.09085222f, -0.17704341f, -0.07625765f, -0.06777620f, -0.01293139f, 0.10828448f, -0.07388018f, 
    0.11246496f, 0.21145466f, -0.03337244f, 0.01745020f, 0.04216754f, 0.01642604f, 0.14057446f, -0.07557379f, 
    0.06538047f, 0.02894645f, 0.06993514f, 0.05234829f, 0.04289613f, 0.09558400f, -0.05543911f, 0.03626423f, 
    0.10111316f, 0.00913220f, 0.11093257f, 0.22321887f, -0.26276201f, -0.13980380f, -0.02961252f, -0.10144670f, 
    -0.11178938f, 0.07211182f, -0.25830215f, -0.04982730f, -0.06763520f, -0.07565166f, 0.03853700f, -0.02372541f, 
    0.01438422f, 0.13996923f, -0.01050302f, 0.04724847f, 0.06875016f, 0.04053843f, 0.12720458f, 0.01069153f, 
    -0.11247586f, -0.28374466f, -0.11837572f, -0.15950203f, -0.00186462f, -0.05620054f, -0.09003401f, -0.08026754f, 
    -0.00339192f, 0.06510141f, 0.01419618f, -0.03691624f, -0.02864250f, 0.07745442f, 0.08544062f, -0.05447662f, 
    -0.02945802f, 0.06432457f, 0.02945153f, -0.03293644f, -0.18676269f, 0.29339051f, 0.08812348f, 0.22525191f, 
    0.16834518f, 0.07488355f, 0.24923678f, 0.16832979f, 0.13194278f, -0.01610101f, 0.01863947f, 0.08897148f, 
    0.06041470f, 0.07665858f, 0.00252526f, -0.06614590f, 0.04328078f, -0.01595800f, 0.10000665f, 0.10050493f, 
    -0.00367303f, 0.21874142f, -0.15559395f, 0.26808718f, 0.17949425f, 0.32755858f, 0.13369827f, 0.16951266f, 
    0.08581634f, 0.00259444f, -0.01216682f, 0.02492457f, 0.03270371f, 0.08682456f, 0.11895213f, -0.09860594f, 
    -0.07662501f, -0.01938739f, 0.03382515f, 0.24427696f, 0.11930809f, -0.06382950f, 0.08264169f, -0.23505588f, 
    0.08713704f, -0.03104179f, -0.09246437f, 0.02788030f, -0.01112328f, 0.03360888f, -0.07087597f, -0.04279846f, 
    -0.09101119f, -0.08878341f, 0.00755781f, 0.06731280f, 0.00334762f, 0.11481120f, -0.11721323f, -0.09716053f, 
    -0.21627250f, 0.20725781f, 0.03639725f, 0.22651492f, -0.08120421f, 0.08089627f, 0.37082258f, 0.06901880f, 
    0.01974690f, 0.16247313f, 0.03441458f, 0.03938134f, 0.04557693f, -0.02965704f, 0.04433717f, -0.06381579f, 
    -0.10716862f, -0.13724664f, -0.01797380f, 0.04116758f, -0.09658920f, 0.13731112f, 0.05936383f, 0.02038680f, 
    0.38899586f, 0.09448329f, 0.09590774f, 0.04415464f, 0.05170211f, -0.20989092f, -0.08132754f, 0.13370438f, 
    -0.03214102f, -0.03859342f, -0.13674791f, 0.04495955f, -0.07497764f, 0.10947716f, -0.01001538f, 0.05125932f, 
    -0.02615743f, -0.25169557f, -0.08437331f, -0.04566320f, -0.02384726f, -0.04479897f, -0.00859134f, -0.03908921f, 
    -0.11991788f, 0.01910514f, -0.04002513f, -0.01066836f, 0.13182320f, 0.14323992f, -0.12311858f, -0.00165856f, 
    0.14848070f, 0.05815213f, 0.00498784f, 0.02834503f, -0.30716500f, 0.20152700f, -0.07872774f, 0.09614674f, 
    0.08013883f, 0.03684074f, 0.19798553f, 0.02715495f, 0.15129617f, -0.05386587f, 0.00447029f, -0.00011567f, 
    -0.04795816f, 0.11979305f, 0.06062013f, 0.02995778f, 0.03235386f, 0.00710618f, -0.24075343f, 0.12989587f, 
    -0.25822046f, 0.51921767f, -0.17293957f, 0.19791229f, 0.36412865f, -0.02552803f, 0.06128673f, 0.24534102f, 
    -0.02615461f, -0.15523247f, -0.10894811f, 0.02711052f, -0.03801292f, -0.01668753f, -0.06848325f, 0.06825745f, 
    0.06834623f, 0.02905282f, -0.00729976f, 0.06179575f, -0.12653773f, 0.02481247f, -0.33621186f, -0.06864695f, 
    0.14556071f, 0.07414833f, -0.03577529f, -0.11617742f, -0.01775677f, -0.11443064f, 0.00668737f, -0.00120166f, 
    0.06353975f, 0.03228769f, 0.08304802f, 0.06731841f, -0.02501069f, 0.10122130f, 0.05983065f, 0.09083947f, 
    -0.24925387f, 0.22205278f, -0.04405658f, -0.18949287f, 0.05322654f, 0.03343673f, 0.02895385f, 0.03944748f, 
    -0.07785134f, 0.09825122f, 0.01123608f, 0.15136808f, -0.06055666f, 0.06485715f, -0.07787640f, 0.06782212f, 
    -0.07009656f, 0.09681667f, -0.16617349f, 0.16319282f, 0.02776017f, 0.34735978f, -0.25290975f, -0.09632756f, 
    -0.01328295f, 0.17590919f, -0.11244354f, -0.04770080f, 0.09680028f, -0.07724379f, 0.10353926f, 0.13072032f, 
    0.01524526f, 0.11103003f, -0.16743258f, -0.04530319f, 0.00820706f, 0.01786567f, 0.18323553f, 0.18022330f, 
    -0.19600949f, -0.23610762f, 0.31623319f, -0.15187816f, 0.15876947f, -0.08475972f, 0.08629878f, -0.02533591f, 
    -0.07138450f, 0.07002816f, -0.00932404f, -0.05165255f, 0.00225683f, -0.02157507f, 0.04983614f, 0.04979863f, 
    -0.03157522f, 0.06498323f, -0.14203508f, -0.14354818f, 0.08486728f, 0.65378875f, 0.55489916f, 0.35602969f, 
    0.52904123f, -0.15647760f, 0.02596606f, 0.09916575f, -0.27793056f, -0.04015146f, -0.02910187f, 0.01341188f, 
    0.02596691f, -0.11487681f, 0.00689393f, -0.04178188f, 0.05510253f, 0.03492566f, -0.00095153f, -0.09597762f, 
    -0.06051226f, -0.03834211f, -0.00454645f, 0.06094655f, 0.04833281f, -0.05303926f, -0.01882708f, 0.03218357f, 
    -0.01283170f, -0.02847303f, 0.05224839f, 0.01459047f, 0.02939902f, -0.02540359f, 0.00390217f, -0.05015259f, 
    0.02866965f, 0.02053811f, 0.00125034f, 0.03241567f, -0.03284254f, -0.02219961f, -0.01046132f, 0.01428882f, 
    0.02022951f, -0.04491860f, -0.07079391f, 0.02146035f, 0.04977656f, -0.04032452f, -0.03468435f, 0.02374215f, 
    -0.06016862f, -0.03685307f, 0.00940093f, -0.02858365f, -0.01122625f, 0.00157781f, 0.00604304f, -0.01508987f, 
    -0.05911435f, 0.03786870f, -0.03788045f, -0.04531060f, -0.05613981f, 0.03523869f, 0.01180399f, -0.02985076f, 
    -0.04247416f, -0.05705916f, 0.02588815f, -0.03308972f, 0.03723491f, -0.02704466f, 0.01938701f, 0.02197456f, 
    -0.03686569f, -0.05082622f, 0.03866358f, -0.03298050f, 0.00603079f, -0.04219219f, -0.01040787f, -0.00408724f, 
    0.05848775f, 0.03189030f, -0.00974906f, -0.04558261f, -0.05470860f, 0.01255282f, -0.02647015f, 0.00085912f, 
    -0.03252362f, 0.02618210f, -0.05253890f, -0.04481619f, 0.00159036f, -0.03719774f, -0.01819389f, -0.03962027f, 
    -0.01272640f, -0.02884733f, -0.03622590f, -0.04855713f, 0.04845189f, 0.00156888f, 0.02146555f, -0.00665198f, 
    0.02811129f, -0.04906391f, 0.03889912f, 0.04103665f, 0.00694840f, -0.05996647f, -0.05064631f, 0.00629609f, 
    -0.02577785f, -0.02835260f, 0.03185776f, 0.03784189f, -0.00308774f, 0.01578263f, 0.02925983f, 0.04211273f, 
    0.01530789f, 0.05746428f, 0.00832103f, -0.02140124f, 0.00020948f, -0.01110159f, -0.02236840f, -0.03673391f, 
    -0.02476578f, -0.05686832f, -0.01120962f, -0.03262559f, -0.02882831f, 0.06744225f, -0.06029174f, -0.01899078f, 
    -0.02146884f, 0.00145245f, -0.00407778f, -0.01367018f, 0.05907293f, 0.00949303f, 0.02917869f, 0.03982265f, 
    -0.02236592f, -0.04956236f, 0.04051518f, 0.00391093f, 0.02257578f, -0.03254926f, -0.04034965f, 0.01516591f, 
    0.02341820f, -0.04767007f, 0.00382027f, -0.01528266f, -0.05060884f, 0.01537121f, -0.00349298f, -0.03667359f, 
    -0.02849073f, 0.02115118f, -0.00149196f, 0.00048524f, 0.01153484f, 0.02101823f, -0.03916604f, 0.01985254f, 
    0.01857500f, -0.03187377f, -0.06665304f, -0.00957388f, -0.02028522f, -0.04026670f, -0.03986133f, 0.03294558f, 
    0.00143116f, -0.02546758f, -0.02598828f, 0.00542685f, 0.04643540f, -0.03831692f, -0.00026548f, -0.02579227f, 
    0.03525596f, -0.05840313f, -0.05125063f, 0.02013450f, 0.00216046f, -0.03794384f, -0.02735929f, 0.04479427f, 
    -0.02567486f, 0.03200833f, 0.04099099f, -0.01449525f, -0.03960950f, 0.05711533f, 0.04524388f, -0.04137412f, 
    -0.00489234f, -0.00865465f, -0.01249887f, -0.02500073f, -0.04843261f, -0.04050495f, -0.03155150f, -0.00565088f, 
    -0.00891257f, 0.02854254f, 0.05214406f, -0.02006193f, 0.05700172f, 0.00375081f, -0.04726462f, -0.05830531f, 
    0.05570134f, -0.02454726f, -0.01567183f, 0.04811740f, 0.06530777f, -0.03033538f, 0.02939874f, -0.00380072f, 
    0.01069060f, -0.01628428f, 0.05298566f, -0.02952127f, 0.05465103f, -0.02465053f, 0.04366621f, 0.02566725f, 
    -0.03755308f, 0.02449250f, 0.02310325f, 0.00790449f, 0.07573184f, 0.01785876f, 0.00643276f, 0.02668060f, 
    0.02359834f, 0.00119331f, -0.02384866f, 0.03725476f, -0.05993283f, 0.00885658f, -0.02414525f, -0.03654354f, 
    -0.02183041f, -0.00543310f, -0.06036849f, -0.05530326f, 0.02968497f, 0.05292248f, 0.00299557f, -0.01869061f, 
    -0.00471765f, 0.01846608f, -0.04587679f, -0.04254741f, 0.03719040f, 0.02137988f, -0.06763086f, 0.04407801f, 
    -0.01070527f, -0.03811042f, -0.06180467f, 0.04130011f, 0.04289389f, 0.03921683f, 0.01626832f, 0.03722575f, 
    -0.00520147f, -0.01738694f, 0.01309498f, -0.03290457f, -0.05833660f, 0.01708473f, -0.00291697f, -0.01488710f, 
    -0.04312950f, -0.02690272f, 0.04125094f, 0.03965261f, 0.01444944f, 0.00372383f, -0.04747694f, -0.03403778f, 
    -0.06518712f, 0.03371326f, -0.03377667f, 0.02519566f, -0.01511198f, 0.04359351f, -0.03116037f, 0.01112867f, 
    -0.04621665f, -0.02729396f, 0.02248350f, 0.01782303f, 0.04636244f, -0.05763426f, -0.01699280f, 0.02192460f, 
    0.00971006f, 0.01991895f, -0.04166208f, -0.03371459f, -0.02469176f, 0.01593227f, 0.06071449f, -0.05669630f, 
    -0.01835394f, 0.01815064f, -0.01680859f, -0.04840768f, -0.03703741f, 0.03548058f, -0.00011111f, 0.03858154f, 
    -0.01859865f, -0.00563489f, 0.04316930f, -0.02032604f, -0.05896031f, -0.00585306f, -0.02108705f, -0.02049735f, 
    -0.00106824f, 0.01479837f, 0.02758399f, -0.02782884f, 0.01491111f, 0.02646896f, -0.03942445f, -0.05326446f, 
    0.03393646f, -0.05850569f, -0.04928325f, -0.01232621f, 0.02550550f, -0.01236386f, 0.00152661f, 0.00210317f, 
    -0.05374798f, -0.06415157f, 0.02296286f, -0.02838335f, -0.04636341f, -0.01402070f, 0.00751525f, 0.03050523f, 
    0.04541800f, -0.01806953f, 0.04092934f, 0.01597182f, 0.02506384f, 0.02049695f, -0.03006359f, -0.03555853f, 
    -0.01136761f, -0.02222406f, -0.01559828f, 0.00818418f, -0.05551351f, -0.02919928f, -0.04173226f, -0.00968283f, 
    0.03100586f, -0.00056506f, 0.00253135f, 0.00050821f, -0.06209813f, -0.00318716f, 0.00699963f, -0.04534458f, 
    0.02591407f, 0.02657238f, 0.02006559f, 0.00063957f, -0.02720744f, 0.03181908f, -0.04329024f, 0.00236065f, 
    0.04101748f, -0.01035447f, 0.00539899f, -0.01624370f, 0.04062249f, 0.03565244f, 0.00310152f, -0.00593556f, 
    0.02010311f, 0.00309972f, -0.05171032f, -0.01720906f, 0.03789923f, -0.01549830f, -0.05760776f, -0.03028418f, 
    0.02613569f, 0.01246472f, -0.05958468f, -0.04031139f, -0.01151965f, -0.05812294f, -0.02595031f, -0.00234573f, 
    0.01968845f, -0.00904951f, -0.04078827f, -0.02813176f, -0.03710126f, -0.03546638f, -0.01539643f, -0.03722420f, 
    -0.03369998f, 0.01325977f, -0.05622439f, -0.00982779f, -0.05436848f, 0.00976987f, 0.00952899f, -0.05908381f, 
    0.00770001f, 0.04655260f, 0.00778326f, -0.04060266f, -0.00056438f, 0.00733853f, 0.02523268f, 0.04259021f, 
    0.03371533f, -0.04609910f, -0.05691975f, -0.03233810f, -0.04297803f, 0.04253966f, 0.03923101f, -0.06155342f, 
    -0.03250411f, -0.02184640f, -0.01204736f, -0.02266022f, -0.02953421f, 0.03610863f, -0.05213634f, -0.00372997f, 
    -0.00269699f, 0.00448192f, 0.02242799f, 0.00255616f, 0.02967340f, 0.02835754f, -0.05036064f, 0.02663227f, 
    0.01492353f, -0.04036115f, 0.04765952f, 0.03690176f, 0.00342392f, 0.00091760f, -0.00495694f, 0.01097583f, 
    -0.02331037f, 0.03820190f, -0.01179921f, 0.04483287f, -0.05030459f, -0.05319140f, 0.01029286f, -0.01254804f, 
    0.01462042f, -0.05133548f, 0.01163090f, -0.00016891f, -0.04565365f, 0.03244341f, -0.02631581f, -0.01449913f, 
    0.01740299f, -0.04607433f, -0.03232177f, -0.05435341f, -0.00461988f, -0.04900619f, 0.02444598f, 0.03690703f, 
    -0.00333393f, -0.03302139f, -0.01837063f, 0.03286301f, -0.00028120f, 0.04129032f, -0.00435150f, -0.01758029f, 
    -0.00341936f, -0.05507813f, 0.00834235f, 0.03889452f, -0.02684191f, 0.02272994f, -0.01907193f, -0.00882430f, 
    -0.06328229f, 0.02291455f, -0.00593693f, 0.02902137f, 0.04060386f, 0.02572197f, -0.01244753f, -0.01194723f, 
    0.00195006f, -0.00061096f, -0.03237588f, 0.02113492f, -0.02936873f, -0.04615969f, -0.05327287f, 0.04395054f, 
    -0.01221146f, 0.04172646f, 0.00874422f, 0.02976628f, 0.02012127f, -0.01914466f, -0.03028716f, 0.03988742f, 
    -0.05387928f, 0.02441007f, 0.02299825f, 0.02087156f, 0.00186254f, -0.01816461f, 0.01773117f, -0.06067430f, 
    0.00905169f, -0.02472699f, -0.00133983f, -0.00605789f, 0.00233180f, 0.00353105f, -0.00392095f, -0.03365547f, 
    0.02382127f, -0.04477276f, -0.01311056f, -0.02718605f, 0.02677242f, -0.00547490f, 0.04154709f, -0.00182444f, 
    0.04926204f, 0.02927439f, -0.03240503f, -0.05026460f, 0.01513732f, -0.04768546f, -0.00824796f, 0.02026541f, 
    0.04568436f, 0.03293509f, -0.02345433f, -0.00799836f, -0.05070852f, 0.05386864f, -0.03272429f, -0.05840174f, 
    -0.05108638f, 0.00198278f, 0.03774563f, -0.00370983f, -0.05413229f, -0.04424974f, 0.02009529f, -0.04677981f, 
    -0.02280179f, -0.02909722f, -0.04513523f, -0.01540868f, -0.01712161f, -0.03702120f, -0.01577738f, -0.01422708f, 
    -0.04704385f, -0.00768923f, 0.01781831f, -0.06086124f, 0.02324137f, 0.00214064f, -0.04887162f, -0.01994314f, 
    -0.05046009f, 0.02592311f, 0.03976280f, -0.05184862f, -0.02202603f, 0.04349554f, 0.00916906f, 0.03788724f, 
    0.04311908f, -0.00602229f, 0.03010714f, 0.02073128f, -0.00882348f, -0.01021392f, -0.01686830f, -0.05308264f, 
    0.02702737f, 0.00929313f, 0.01870371f, 0.00809551f, 0.04794870f, -0.05816480f, 0.01043565f, 0.01398967f, 
    -0.00709859f, -0.01279476f, 0.00226230f, -0.00707611f, -0.00880502f, 0.03193310f, -0.00312392f, 0.01460488f, 
    -0.02278853f, 0.03022426f, -0.02497875f, -0.03720897f, 0.04180944f, -0.03427420f, -0.03178127f, -0.00736630f, 
    -0.02160719f, -0.03216138f, -0.00063549f, -0.06491015f, -0.03022260f, -0.04540958f, 0.02433918f, 0.04219170f, 
    0.01296568f, 0.04337457f, 0.05047217f, -0.02540909f, 0.01008511f, -0.04375756f, 0.03015929f, -0.01657789f, 
    -0.00061979f, 0.02945159f, 0.00194428f, 0.02731822f, 0.04196867f, -0.03508041f, -0.04016891f, -0.03141244f, 
    -0.16582961f, -0.22533391f, -0.12551865f, 0.10731164f, -0.10170233f, 0.09671405f, 0.00871295f, 0.16531412f, 
    0.03315458f, 0.14309275f, -0.07011802f, 0.11642750f, 0.08893362f, 0.05655301f, -0.01887213f, 0.07105335f, 
    0.01345892f, -0.11046041f, 0.02314309f, 0.10292169f, -0.08153838f, 0.04009338f, 0.14063245f, 0.10165104f, 
    -0.02651035f, -0.14490670f, 0.17355068f, 0.05830031f, 0.07855570f, 0.03838434f, -0.01116307f, -0.07726534f, 
    0.08434059f, 0.06194087f, 0.04421093f, 0.03625983f, 0.00284535f, 0.06880804f, 0.01676229f, 0.08270484f, 
    0.11350156f, 0.00425084f, 0.13882783f, 0.12461027f, -0.12705421f, -0.02048028f, -0.00095914f, -0.01851283f, 
    -0.06738371f, -0.18389532f, -0.00855325f, 0.06377054f, 0.02142728f, -0.04140656f, 0.00110904f, 0.02216099f, 
    -0.04008532f, 0.10609011f, 0.00021400f, -0.03538176f, 0.04269746f, 0.09376730f, 0.15796570f, -0.00589566f, 
    0.11645340f, -0.10744138f, 0.10504248f, 0.01915006f, 0.04312903f, 0.03875819f, 0.00758313f, -0.03899706f, 
    0.00332459f, -0.11371932f, 0.11761203f, 0.06118548f, 0.04137635f, -0.17677636f, 0.01448455f, 0.01487684f, 
    0.02556569f, -0.08953820f, 0.18780510f, 0.06285813f, 0.12331620f, -0.05656933f, 0.07934778f, 0.19023043f, 
    0.07319319f, 0.07499211f, 0.01067537f, 0.04244706f, -0.02144767f, -0.03759885f, 0.03813903f, 0.11686506f, 
    0.09522706f, -0.18537268f, 0.05094847f, -0.01650565f, 0.07034075f, -0.09873475f, 0.08322766f, 0.17778842f, 
    -0.18969184f, -0.09191260f, -0.07143048f, 0.08499070f, 0.01790808f, -0.09536618f, -0.03960321f, 0.02182911f, 
    -0.07747587f, 0.06995634f, -0.04076296f, 0.02258004f, -0.14438090f, 0.04885373f, -0.02961236f, -0.10314574f, 
    0.06641007f, 0.10868360f, -0.02826324f, -0.04687453f, 0.08714331f, 0.15624015f, -0.10415607f, 0.14702180f, 
    0.09191656f, 0.22103180f, -0.07923850f, 0.05735426f, 0.01071555f, 0.02059901f, -0.05192574f, 0.14345999f, 
    0.06758250f, -0.05894135f, -0.09026344f, -0.05910716f, 0.39082536f, -0.21206051f, -0.40491354f, 0.24253418f, 
    -0.22599900f, -0.02311914f, -0.09463310f, -0.06603875f, -0.02657355f, -0.07313774f, 0.02247013f, 0.00050982f, 
    -0.02403010f, 0.04583013f, -0.03528412f, 0.02332581f, -0.01790427f, -0.06078570f, 0.08483016f, 0.02326107f, 
    0.05096962f, 0.08027249f, 0.13021955f, 0.19599749f, -0.14735791f, -0.04464863f, 0.02501777f, 0.15241830f, 
    -0.06296017f, -0.09109110f, -0.16001002f, -0.22515030f, -0.28652269f, 0.28102022f, 0.07741543f, 0.02918312f, 
    -0.00674753f, 0.23411062f, -0.07622725f, 0.05097288f, 0.04647976f, 0.11762987f, 0.02296528f, -0.06462462f, 
    0.02341243f, 0.08447603f, -0.04502642f, 0.01300114f, 0.12166286f, 0.18951941f, -0.03404488f, 0.06290735f, 
    -0.04130523f, -0.06358121f, -0.05064815f, 0.07846038f, -0.00620675f, -0.11860484f, 0.03467806f, -0.02310339f, 
    0.40247849f, -0.31111839f, 0.13424405f, -0.00871370f, -0.19905870f, 0.00586644f, -0.06675231f, -0.28478038f, 
    0.11895422f, -0.00849231f, 0.06515177f, -0.02458646f, 0.02810538f, -0.07687106f, -0.10334863f, 0.06489531f, 
    0.04157811f, -0.01757660f, 0.11444771f, 0.07381593f, 0.05746647f, 0.08228341f, 0.25870359f, 0.27766922f, 
    0.04906134f, -0.05511435f, -0.08819864f, 0.26460925f, -0.16331148f, -0.04554076f, -0.28086868f, 0.09005788f, 
    0.00070746f, 0.02607997f, 0.01895725f, -0.00403725f, -0.10766736f, 0.08582220f, -0.03551970f, 0.03627142f, 
    -0.04848203f, -0.24831906f, 0.34670860f, 0.06294276f, 0.01145253f, 0.03581718f, 0.12225603f, 0.02448920f, 
    0.07682911f, -0.15242916f, -0.08144712f, 0.00065685f, 0.20218469f, 0.05529353f, 0.21157750f, 0.12884143f, 
    0.03165900f, 0.17352851f, -0.09579077f, -0.08910938f, 0.01926358f, -0.09101754f, -0.18345256f, 0.19699277f, 
    0.03656945f, -0.13172029f, 0.09571112f, 0.21878244f, 0.05947157f, 0.22130169f, -0.11979854f, 0.01165826f, 
    0.00509817f, 0.05367847f, -0.00285897f, 0.01157783f, 0.08697202f, -0.20686208f, 0.06075267f, 0.11932243f, 
    -0.11329080f, 0.14209157f, 0.09681258f, 0.27868757f, -0.20398889f, 0.01349454f, 0.01580265f, 0.09680863f, 
    -0.06572037f, -0.03716360f, -0.05543112f, 0.11542010f, 0.06122942f, 0.02458220f, -0.07906227f, 0.10408837f, 
    0.00183428f, 0.05140654f, -0.08043217f, 0.01881082f, 0.01421849f, -0.38421866f, -0.08646612f, 0.01990542f, 
    -0.70959055f, 0.14942901f, 0.08035623f, 0.01393269f, 0.13143007f, -0.09320563f, -0.08000998f, 0.01986786f, 
    -0.07768106f, 0.02019094f, 0.02440946f, 0.03041349f, -0.05589290f, -0.04653576f, 0.00999394f, 0.02161067f, 
    -0.00503907f, 0.00704151f, 0.01479266f, -0.00661734f, 0.00391660f, -0.05664100f, 0.02812579f, -0.01399819f, 
    -0.05364140f, -0.00537698f, 0.00915929f, -0.04322824f, 0.02410875f, -0.00629574f, -0.06359714f, -0.03762830f, 
    -0.02921739f, -0.03308491f, -0.06081533f, -0.05035964f, -0.02285419f, -0.03159752f, 0.03540014f, 0.04322337f, 
    -0.00086225f, 0.00994070f, -0.01689706f, 0.04276853f, -0.01120393f, -0.03143929f, -0.05677217f, 0.00466736f, 
    -0.05031288f, 0.00988148f, -0.03323198f, 0.01271729f, 0.03955352f, 0.00364788f, -0.01017881f, 0.03446904f, 
    -0.02347210f, -0.01365670f, -0.01530934f, -0.00325510f, -0.00903300f, 0.00441992f, -0.05137977f, 0.00667894f, 
    -0.04498736f, -0.03276653f, 0.02056056f, 0.02595670f, -0.02355050f, -0.00113145f, -0.00899387f, 0.03845306f, 
    -0.05329081f, -0.05681465f, -0.00719127f, 0.02388839f, 0.00358637f, 0.02259886f, -0.05100737f, 0.00621864f, 
    0.02221225f, -0.02065232f, 0.00841395f, 0.02222285f, -0.04428416f, -0.00309779f, 0.02750335f, -0.05359872f, 
    0.02642412f, -0.01310540f, -0.06413405f, -0.00976116f, -0.05265854f, 0.02566956f, 0.01531425f, 0.03196794f, 
    -0.03452447f, 0.01559014f, -0.02711142f, 0.01768699f, -0.03804504f, -0.02597476f, -0.06159950f, 0.02865404f, 
    0.04286302f, -0.00461902f, -0.01250664f, 0.01520541f, -0.03867966f, -0.03616473f, 0.02080612f, -0.01409507f, 
    0.03794603f, 0.01628520f, -0.06524694f, 0.02245713f, 0.04739332f, 0.02047505f, -0.03466414f, 0.01082654f, 
    0.03454967f, 0.03465269f, 0.03448332f, 0.04367661f, 0.00748429f, -0.04458244f, 0.03414255f, 0.00208957f, 
    -0.05014377f, 0.02948655f, 0.03696745f, -0.03569862f, 0.04104713f, 0.01099018f, -0.03836279f, -0.02203848f, 
    0.03112894f, -0.04448070f, -0.01538912f, 0.03081948f, -0.00353817f, -0.01640095f, -0.02994921f, 0.03273179f, 
    -0.01484695f, 0.01593610f, -0.02679138f, -0.01482028f, -0.06445558f, 0.00152552f, 0.04126914f, 0.03989708f, 
    0.01819208f, 0.01913128f, -0.01855979f, 0.01707034f, -0.01919314f, -0.00271865f, 0.01208701f, 0.02210683f, 
    -0.01652678f, 0.02770464f, -0.06662851f, -0.02220345f, 0.02674249f, 0.01979510f, -0.04576758f, -0.03432518f, 
    0.01739853f, -0.05788833f, -0.07007589f, -0.00102620f, -0.05215881f, -0.05775795f, -0.06438100f, -0.00051024f, 
    -0.01319791f, -0.03198640f, 0.06256244f, 0.03973404f, 0.02004265f, -0.04025986f, 0.03204579f, -0.05738889f, 
    0.00632193f, -0.06461331f, 0.00216374f, -0.05497003f, 0.04360277f, 0.00484752f, -0.04484133f, -0.06583785f, 
    0.04394653f, 0.01683528f, -0.06095832f, -0.06198914f, 0.01895173f, -0.01641568f, -0.03415991f, -0.00398281f, 
    0.00900539f, 0.01837601f, -0.01158575f, 0.01589379f, 0.03828013f, -0.02506318f, 0.00978639f, 0.02359237f, 
    -0.03787133f, 0.01577566f, 0.02168562f, -0.05928442f, -0.02887989f, -0.06565039f, -0.02653749f, -0.01354074f, 
    0.02391147f, -0.03612988f, 0.00891156f, -0.05746512f, -0.03790180f, 0.01955879f, 0.01628160f, -0.00055425f, 
    -0.00783869f, 0.01075028f, -0.05329225f, 0.00705707f, 0.04307386f, 0.01256599f, -0.02215230f, 0.02984663f, 
    -0.00837558f, 0.01196716f, -0.03237683f, -0.05517828f, -0.03298112f, 0.02638748f, -0.02603970f, 0.04377045f, 
    -0.02950767f, -0.03343333f, 0.03435059f, 0.04005760f, 0.03428598f, -0.03799715f, 0.03257716f, -0.04794526f, 
    0.00571191f, -0.02307120f, -0.03861478f, -0.03576726f, 0.01140829f, -0.04226387f, 0.02904762f, -0.03744376f, 
    0.03203246f, 0.03826216f, 0.02649350f, -0.05412290f, -0.06627724f, -0.01593164f, 0.04263117f, 0.01338331f, 
    -0.04893042f, -0.01771249f, 0.01736664f, -0.00190788f, -0.01334291f, 0.01327490f, 0.00688807f, 0.03297059f, 
    -0.03620029f, 0.02896729f, -0.05215897f, -0.00836471f, 0.02379685f, 0.01694377f, 0.03336971f, 0.02882864f, 
    -0.05508313f, -0.01070975f, -0.01210769f, -0.00595599f, -0.02735871f, 0.02595988f, 0.02117699f, 0.02518081f, 
    -0.02802334f, 0.03941762f, 0.03527898f, 0.02113304f, 0.02777078f, 0.01242898f, -0.02950803f, -0.04478630f, 
    0.01380937f, -0.06169488f, -0.02282029f, -0.03736133f, 0.01441826f, -0.04400811f, -0.06626621f, -0.05624033f, 
    -0.04675771f, -0.06131529f, -0.02176274f, 0.03721513f, 0.01216484f, -0.02774276f, -0.02250383f, -0.04715456f, 
    -0.06307314f, -0.03909533f, -0.01662819f, 0.02066704f, 0.00304322f, 0.04047460f, -0.03100936f, -0.01046019f, 
    0.02021438f, 0.02373190f, -0.05209873f, -0.00416204f, 0.00427277f, 0.01740497f, 0.00294702f, -0.05572776f, 
    -0.00264892f, -0.06049748f, 0.01527580f, -0.02131894f, 0.03297576f, -0.02702908f, 0.02195832f, -0.05164548f, 
    -0.10850280f, -0.02253186f, -0.07142780f, -0.17055842f, -0.01049165f, -0.25703472f, -0.06986452f, -0.03512944f, 
    -0.07245819f, -0.02011263f, 0.17460674f, 0.21266063f, -0.28502691f, -0.23640218f, -0.06817421f, -0.16708428f, 
    -0.33833694f, -0.12656651f, 0.07020843f, -0.38716570f, 0.12661931f, 0.00491014f, 0.18060489f, 0.13137141f, 
    -0.06570724f, 0.00929617f, 0.06102895f, 0.07088016f, 0.12759501f, 0.05867894f, 0.07054175f, -0.01426781f, 
    0.08293480f, -0.03179917f, -0.06504997f, 0.03131992f, -0.03171990f, -0.09770460f, -0.11382935f, -0.14696833f, 
    0.21134801f, 0.26820773f, 0.04092678f, -0.08185873f, 0.05602629f, 0.00520041f, 0.13566159f, 0.17509666f, 
    -0.00291205f, 0.14154834f, 0.01282087f, -0.00512150f, 0.07323734f, 0.13433567f, -0.03665361f, 0.09873568f, 
    -0.05705418f, -0.19199026f, -0.27993852f, -0.05417556f, 0.22979702f, -0.13784739f, -0.06704614f, 0.03400701f, 
    -0.26583856f, -0.00728501f, -0.03895920f, 0.12249714f, 0.13208152f, 0.12831706f, -0.08786723f, -0.05631635f, 
    0.02317865f, 0.07448577f, -0.00106795f, 0.13465169f, 0.09497791f, 0.38337266f, 0.04040272f, 0.22884221f, 
    0.21545754f, -0.10349979f, -0.27879235f, 0.09215058f, -0.25370249f, -0.08254950f, 0.00710831f, -0.07047261f, 
    0.04626447f, 0.14541429f, 0.03815321f, -0.04711880f, 0.00240105f, 0.05109884f, 0.04949237f, 0.15614866f, 
    0.30853686f, 0.42336714f, 0.17081656f, 0.43633327f, 0.11216043f, 0.11605920f, 0.09164736f, 0.03572745f, 
    0.19445166f, -0.01411649f, -0.00248810f, -0.24714555f, 0.04819384f, 0.11991999f, -0.07730734f, -0.08827630f, 
    0.21938474f, 0.17175148f, 0.15433046f, 0.08764079f, 0.15938824f, -0.07474102f, 0.04933933f, 0.21731457f, 
    -0.16555117f, -0.08587780f, 0.07834417f, -0.16250390f, -0.28327939f, -0.01830719f, 0.12784369f, 0.01217139f, 
    0.01082335f, -0.05113861f, -0.11807127f, -0.19107640f, -0.01635621f, 0.04279694f, 0.03408701f, 0.07686357f, 
    0.08819230f, 0.30011696f, 0.26128134f, 0.33414793f, 0.03901095f, 0.31405002f, 0.41429120f, -0.07483054f, 
    0.06790335f, -0.13702938f, -0.04923535f, 0.10258535f, 0.14668441f, -0.02772905f, -0.07362366f, -0.04775817f, 
    0.16121535f, -0.00366529f, 0.20554331f, -0.07164443f, -0.25351778f, -0.18213771f, -0.08595499f, -0.04912469f, 
    0.25215331f, 0.02699834f, 0.29751211f, -0.07017492f, 0.13973318f, -0.01064854f, -0.08275063f, -0.02282737f, 
    0.14261039f, 0.27771991f, 0.08203668f, 0.05775624f, 0.10566154f, -0.22119212f, 0.08154476f, -0.05705045f, 
    -0.27534688f, -0.35462496f, -0.37358326f, -0.39308611f, 0.25430703f, -0.05305535f, -0.00695947f, -0.18200926f, 
    -0.09776781f, -0.00807485f, 0.11518294f, 0.07560240f, -0.04980056f, 0.08225778f, -0.03654680f, -0.00396025f, 
    0.12182424f, -0.03442070f, -0.10677139f, 0.06060586f, -0.04222161f, 0.16616450f, 0.34075570f, 0.24640793f, 
    0.36034012f, 0.25068620f, 0.21976782f, -0.24058747f, -0.11539108f, 0.02878311f, 0.05250151f, 0.02742144f, 
    0.01160943f, -0.04103668f, 0.01109355f, 0.05335193f, 0.01073231f, -0.03489683f, -0.03149985f, -0.18503405f, 
    -0.30052656f, -0.16979527f, 0.10155187f, -0.24523379f, 0.06613541f, 0.27316633f, -0.03377660f, 0.01241917f, 
    0.05944157f, -0.00112946f, 0.31092286f, -0.08354302f, 0.00530931f, 0.15024224f, -0.00388326f, -0.03022165f, 
    0.19946484f, -0.03802631f, -0.06376401f, 0.08130921f, 0.11675575f, -0.16162834f, -0.03611537f, 0.17429775f, 
    0.11421239f, 0.18136616f, -0.10293975f, 0.12249956f, 0.10517097f, -0.12312537f, 0.04521238f, 0.07329597f, 
    0.04642546f, 0.06237814f, 0.06446593f, 0.17566979f, 0.08640502f, 0.17347416f, 0.01148295f, 0.07785635f, 
    -0.06033612f, -0.22351776f, 0.17972481f, 0.05858475f, -0.18480393f, -0.23792882f, 0.33918226f, 0.03359153f, 
    -0.32873949f, -0.23398040f, -0.19773622f, -0.08743573f, 0.04175576f, -0.05195564f, -0.03439864f, -0.00663297f, 
    -0.00300610f, -0.15953530f, -0.07375839f, -0.08804048f, -0.36458650f, 0.11063742f, -0.09326603f, -0.24733490f, 
    0.22758938f, -0.23845232f, -0.16263562f, -0.19034915f, 0.16554219f, -0.04729892f, 0.06647308f, 0.18557750f, 
    0.03413977f, 0.05698633f, -0.09569176f, -0.09133235f, -0.04668831f, -0.09301762f, -0.02743035f, -0.13077557f, 
    -0.01663273f, -0.19264473f, 0.07238589f, 0.06796537f, 0.18831708f, -0.11479116f, 0.23700327f, 0.05961307f, 
    0.21735969f, -0.04788635f, -0.01976971f, 0.18822089f, 0.06813424f, 0.03423390f, -0.08748147f, -0.06645311f, 
    0.05499971f, 0.13086715f, 0.12949921f, 0.10722883f, 0.15056033f, -0.04440406f, 0.16433772f, 0.02061277f, 
    0.03479183f, -0.05183738f, 0.04545894f, 0.02307330f, -0.03018513f, -0.05170829f, -0.02704488f, -0.03078085f, 
    0.01906869f, -0.01933155f, -0.05222150f, 0.02091268f, -0.04739162f, -0.02036201f, 0.04939340f, 0.04304083f, 
    -0.03322883f, -0.06147343f, -0.04510196f, -0.01011398f, -0.03425354f, -0.05439026f, -0.05532457f, -0.04839033f, 
    -0.02880224f, -0.04363461f, 0.01159619f, 0.00462390f, 0.00724885f, -0.04637251f, -0.00730051f, 0.01062930f, 
    -0.04777806f, -0.02448749f, -0.02055924f, -0.05263778f, -0.03523101f, -0.05942583f, -0.05156502f, -0.02454735f, 
    0.04492156f, -0.01595992f, -0.01202647f, 0.00182564f, 0.01710372f, 0.04590189f, 0.03901146f, -0.04372551f, 
    -0.05890238f, 0.04610793f, -0.01767482f, 0.01392155f, -0.00074180f, 0.02391514f, 0.03956658f, 0.00843014f, 
    0.00189883f, 0.03549978f, -0.01603677f, 0.00568291f, -0.00091383f, -0.01226227f, 0.00832299f, -0.01054340f, 
    0.02154433f, 0.02604312f, -0.04821640f, -0.00118791f, -0.01847230f, -0.00296759f, -0.04719437f, -0.06111414f, 
    -0.00764207f, -0.04381332f, -0.00303414f, -0.01093655f, -0.02272073f, -0.04529786f, -0.00608573f, -0.05112248f, 
    -0.02379694f, -0.05098404f, -0.04330496f, -0.00552700f, -0.03493034f, 0.01472630f, -0.04143254f, 0.03361698f, 
    -0.04420203f, -0.01283325f, 0.01902431f, 0.00410086f, 0.04506277f, 0.02460582f, -0.02555803f, 0.03694812f, 
    -0.00096678f, -0.01095322f, -0.02954787f, 0.03909868f, 0.03314192f, 0.02308979f, -0.05710299f, 0.01869191f, 
    -0.04169947f, -0.05495505f, -0.00248937f, 0.02384662f, -0.01943898f, -0.05623413f, 0.00472488f, -0.03138790f, 
    -0.04790288f, 0.01514228f, -0.00848125f, -0.03796390f, -0.01623690f, -0.05528670f, 0.01501635f, -0.04826532f, 
    -0.00693547f, -0.01181487f, 0.02121712f, 0.03768816f, -0.04215850f, -0.04463483f, 0.05323714f, 0.03604812f, 
    -0.04797027f, -0.03800556f, -0.03998519f, -0.02926355f, -0.01144459f, 0.02850651f, -0.06144227f, 0.00875292f, 
    0.02986569f, -0.05270529f, 0.04415149f, -0.05600041f, -0.00034062f, -0.01004851f, -0.01706493f, -0.03603939f, 
    -0.00241583f, -0.05040080f, -0.01225185f, -0.00570909f, 0.02147747f, -0.00496761f, 0.00405838f, -0.01887988f, 
    0.03152660f, 0.01117381f, 0.03859321f, 0.03559365f, -0.04719122f, 0.02682883f, 0.03960874f, -0.03348191f, 
    0.04271469f, -0.05561449f, 0.04890862f, -0.04779844f, -0.03433476f, 0.04279416f, 0.01353230f, 0.01083412f, 
    -0.01313140f, -0.00423300f, 0.00697958f, 0.00573383f, -0.04751257f, 0.00127710f, -0.05108382f, 0.02003968f, 
    0.04985139f, -0.04406111f, -0.00685224f, -0.01516740f, 0.01031605f, 0.02092636f, 0.00237422f, -0.03022243f, 
    -0.00528116f, 0.05529987f, 0.04975624f, -0.03474165f, 0.02426070f, 0.05245163f, 0.02491198f, -0.00498948f, 
    0.02571391f, -0.03413834f, -0.01313477f, -0.04312384f, 0.04161651f, 0.04934485f, -0.06140358f, -0.02632403f, 
    -0.01396566f, 0.00852705f, -0.01001539f, -0.01958537f, -0.05300431f, 0.04991511f, 0.02055356f, 0.03760597f, 
    0.04388922f, -0.02018003f, 0.01386460f, -0.05952786f, -0.06005807f, -0.04798639f, -0.02176208f, 0.02607591f, 
    0.00007164f, -0.00039958f, -0.01515237f, 0.02026959f, 0.02885947f, -0.00600907f, 0.01816706f, -0.02763874f, 
    -0.00673837f, -0.04718329f, 0.01606646f, 0.01568439f, -0.05056237f, 0.04329970f, -0.06098424f, 0.03250396f, 
    0.04924523f, 0.04910964f, 0.02176017f, -0.02370548f, -0.03784786f, -0.02699884f, -0.04080479f, 0.03811436f, 
    0.02106299f, 0.04934808f, 0.03176013f, 0.02011771f, 0.00315426f, -0.00618077f, 0.03954353f, 0.00045654f, 
    -0.04792872f, -0.06132375f, 0.03994434f, 0.03138356f, -0.04879824f, 0.00046495f, 0.04538991f, 0.01173612f, 
    0.02447533f, -0.00512208f, -0.05114464f, -0.04138759f, -0.02519093f, -0.00092774f, 0.03399790f, 0.01603585f, 
    -0.02929897f, -0.03375523f, 0.04787555f, 0.00461305f, -0.05480576f, 0.02303390f, -0.03652547f, -0.03459806f, 
    0.00293460f, 0.04248783f, -0.01106096f, 0.00632988f, -0.01319269f, 0.01366919f, -0.00674090f, -0.03629383f, 
    0.00638865f, 0.00708323f, 0.01640706f, -0.04303392f, 0.00310832f, -0.01539319f, -0.05591878f, 0.00952507f, 
    -0.05919940f, 0.03109660f, 0.02909906f, -0.03682679f, -0.01932027f, -0.05728661f, 0.02943155f, 0.03979650f, 
    -0.00341850f, -0.00308047f, 0.01133119f, 0.02662457f, 0.00042506f, -0.04430165f, -0.03931456f, -0.05112633f, 
    0.02748070f, -0.00734127f, 0.05370865f, 0.03897877f, -0.05470683f, -0.00772471f, -0.04972837f, 0.04463789f, 
    0.01392710f, 0.04288061f, -0.00843094f, -0.01016973f, 0.04744195f, 0.00763592f, -0.05250816f, 0.03988501f, 
    -0.01677069f, 0.00134775f, -0.03867659f, -0.04085906f, -0.04438420f, 0.01319109f, -0.01137733f, -0.00017701f, 
    0.04149931f, 0.01130678f, 0.00583174f, -0.05994230f, -0.00461057f, 0.01462574f, -0.04742720f, -0.04836421f, 
    -0.04997874f, -0.04734597f, 0.02885928f, 0.04019390f, 0.02634102f, -0.01878448f, -0.03923107f, 0.04288832f, 
    -0.03961868f, -0.04564621f, -0.04483856f, -0.03015966f, 0.00997863f, 0.02016755f, -0.02810020f, 0.02770611f, 
    -0.05277669f, -0.02304275f, -0.01879041f, -0.00467988f, 0.00049231f, -0.02213805f, -0.02818882f, 0.02008650f, 
    -0.00108779f, 0.01598710f, -0.04226863f, -0.05905460f, 0.00739433f, -0.01151470f, -0.05744746f, -0.04811112f, 
    -0.00061950f, 0.00173538f, -0.00353478f, 0.02278322f, -0.03460499f, -0.02392946f, -0.05578827f, -0.05853425f, 
    -0.00814168f, 0.02187859f, -0.05405225f, -0.05393055f, -0.06160146f, 0.02008977f, 0.00619222f, -0.00589407f, 
    0.03908950f, -0.00565713f, -0.03760422f, -0.02993391f, -0.01846250f, 0.03292917f, 0.02647003f, 0.04415857f, 
    -0.01517482f, -0.02136584f, 0.00253868f, 0.02399440f, -0.01593908f, -0.00378377f, -0.04961253f, -0.06040279f, 
    -0.00017134f, 0.03634067f, -0.00236747f, -0.04220821f, 0.00440685f, 0.02305610f, 0.03593118f, -0.00098006f, 
    0.01752296f, 0.03422077f, -0.06053192f, 0.02452672f, 0.00748091f, 0.02712844f, 0.01854851f, -0.03862597f, 
    -0.05350808f, -0.00489195f, 0.04182458f, 0.02792724f, 0.01527354f, -0.03302455f, 0.01542509f, 0.03059277f, 
    -0.05928702f, -0.00144847f, -0.04931561f, -0.00471373f, -0.04789840f, -0.04767253f, -0.05227388f, 0.00700773f, 
    0.03224745f, -0.04232450f, -0.01274856f, -0.00213847f, 0.02544843f, 0.04009133f, 0.01429641f, -0.00813346f, 
    -0.05235345f, 0.02669742f, -0.04162619f, 0.02202983f, -0.00075997f, 0.04547622f, 0.04496591f, 0.01611106f, 
    -0.03873294f, -0.02848887f, -0.02131785f, 0.02831240f, -0.04003435f, -0.00320487f, -0.05506007f, -0.01981046f, 
    0.01194972f, 0.00729930f, 0.02147882f, -0.03127179f, -0.03649833f, 0.00206609f, 0.00135701f, 0.02093115f, 
    0.03497400f, -0.03054669f, 0.03577951f, -0.03767729f, 0.03558460f, -0.03071346f, -0.00642272f, -0.04566573f, 
    -0.01470194f, -0.00716074f, 0.02089676f, -0.03642907f, 0.01326254f, 0.02837977f, -0.00591296f, -0.02856653f, 
    0.01482433f, 0.01050343f, -0.04891009f, -0.01477506f, -0.05741927f, 0.03293766f, -0.02249157f, -0.00328548f, 
    -0.03748209f, 0.04214906f, -0.02420046f, 0.03624648f, -0.02123767f, -0.00904997f, -0.05737418f, 0.01545050f, 
    -0.00348054f, 0.03970992f, 0.01602907f, -0.00206163f, 0.01507071f, -0.02471768f, -0.03387116f, -0.01392831f, 
    0.02120437f, 0.02732719f, -0.05954397f, -0.05761959f, 0.01757350f, -0.04880716f, 0.03560847f, 0.00266583f, 
    0.03808485f, 0.02269018f, 0.02323966f, -0.04187037f, 0.03027718f, -0.03609867f, -0.02735491f, 0.04537433f, 
    0.02165481f, -0.04868303f, -0.05369532f, 0.04300523f, 0.00238648f, 0.03606488f, -0.05955827f, 0.04492783f, 
    -0.01199685f, -0.04869231f, 0.04719709f, 0.00866257f, -0.01901629f, -0.02358143f, 0.00958973f, -0.02470829f, 
    -0.04448366f, -0.05057950f, 0.03172775f, -0.01808909f, -0.03408826f, -0.00131566f, 0.03549704f, -0.05276625f, 
    0.02485332f, -0.01148107f, -0.02641148f, -0.05148121f, 0.03599459f, 0.01581398f, -0.05399842f, 0.04881358f, 
    -0.01446674f, -0.01035525f, 0.02967265f, -0.05720818f, 0.03487944f, -0.03233540f, -0.05167914f, 0.00508658f, 
    0.03482770f, -0.04658158f, -0.00400880f, 0.02243910f, 0.00058485f, -0.03390745f, 0.04361106f, 0.04644579f, 
    -0.06029414f, -0.04140034f, -0.04046075f, 0.03583052f, -0.03297074f, -0.02979912f, 0.03122247f, -0.02840845f, 
    0.01314300f, 0.00199934f, -0.01831977f, 0.03157250f, 0.00098770f, 0.01075020f, -0.05142796f, -0.04097556f, 
    0.00980510f, 0.02693365f, -0.03033140f, -0.00213108f, -0.00943372f, 0.00042091f, -0.05649616f, 0.00096823f, 
    -0.05792118f, -0.01367868f, -0.04376062f, -0.01242446f, 0.01780189f, -0.03887079f, -0.04715157f, -0.02780084f, 
    -0.00536071f, 0.02145979f, 0.02713138f, 0.02387677f, -0.06126336f, -0.04466842f, -0.05411136f, 0.04562969f, 
    0.00639084f, -0.02304488f, 0.03819333f, 0.01417784f, -0.00893374f, -0.05597344f, -0.01275557f, 0.04005767f, 
    -0.00231711f, -0.04638274f, 0.04157947f, -0.02541061f, 0.05898983f, 0.01071721f, 0.04168684f, -0.00807085f, 
    -0.04614374f, -0.01563558f, -0.04861718f, -0.02034237f, -0.01974068f, -0.04493590f, 0.05828663f, -0.03133226f, 
    -0.01589556f, 0.04654247f, -0.04347925f, -0.04485487f, 0.01640188f, -0.01734507f, 0.04678518f, -0.00172780f, 
    0.04226809f, -0.17367710f, -0.07362640f, 0.08171897f, 0.04639715f, 0.15862551f, -0.00441419f, -0.05789581f, 
    0.03090507f, 0.14973354f, -0.01569789f, 0.02118879f, -0.00005287f, -0.09877351f, -0.06996344f, 0.00764302f, 
    0.09391936f, 0.01021816f, 0.08269974f, 0.09836721f, -0.18055414f, 0.10263299f, 0.09101179f, -0.04129126f, 
    0.16389990f, 0.10534344f, -0.07715850f, 0.21266928f, -0.11028213f, -0.03947616f, 0.07814807f, -0.00202659f, 
    0.11769862f, 0.01953848f, -0.01041733f, -0.00966854f, 0.01522946f, 0.24708284f, -0.09444737f, -0.05675506f, 
    -0.02988813f, 0.10329733f, 0.13239153f, -0.03591324f, -0.12033921f, -0.00674337f, -0.08679568f, -0.11475650f, 
    -0.03895342f, -0.02171247f, 0.05459125f, 0.03638014f, -0.00299524f, 0.00176128f, 0.04176345f, 0.04801269f, 
    0.06704295f, 0.03823351f, 0.01744850f, -0.06162136f, -0.33034003f, -0.07342281f, 0.14044362f, 0.01518338f, 
    0.25344679f, -0.01250585f, -0.06601907f, 0.00976682f, -0.01237306f, -0.03867232f, -0.05171929f, 0.05222819f, 
    0.05418666f, 0.13411780f, 0.02842812f, -0.02873386f, -0.04345552f, -0.09350484f, 0.12188574f, -0.03284225f, 
    0.05062748f, -0.21875323f, 0.20255262f, -0.00610131f, 0.04611731f, 0.00816491f, -0.02062662f, 0.15066551f, 
    0.08675093f, -0.04102790f, -0.11326215f, 0.03415032f, 0.03446124f, 0.21967135f, -0.00857927f, -0.00043514f, 
    0.00327712f, 0.01995655f, -0.08177149f, 0.05524339f, 0.15005216f, 0.32597524f, 0.04276112f, -0.16924617f, 
    -0.11466313f, 0.03828333f, -0.03334421f, 0.02009622f, -0.01299668f, -0.04334582f, -0.09437360f, 0.00102664f, 
    -0.09510613f, 0.00297532f, -0.13630438f, -0.20216809f, -0.03971707f, 0.07312252f, -0.18763383f, -0.05894487f, 
    -0.00878752f, -0.03679929f, -0.01169889f, 0.33482859f, 0.32086012f, 0.04606722f, 0.31870148f, 0.14903967f, 
    0.17723806f, 0.04803507f, 0.09472593f, -0.02545561f, -0.03147373f, 0.05010923f, -0.04885033f, 0.05788771f, 
    0.10488820f, -0.19526047f, -0.15061338f, 0.03741667f, -0.07741223f, 0.01801710f, -0.04491680f, -0.22804295f, 
    0.22747132f, 0.09901843f, -0.04213034f, -0.05724807f, 0.11716856f, 0.06573135f, 0.07440092f, 0.09749102f, 
    -0.13494083f, -0.14743190f, -0.06378420f, -0.04869640f, 0.02900461f, -0.03614615f, -0.01362041f, -0.02583019f, 
    0.09647257f, 0.11059587f, -0.03327182f, 0.01037184f, -0.17874324f, 0.03664481f, -0.01153585f, 0.07695977f, 
    -0.13141248f, -0.06054571f, -0.04724401f, 0.02815971f, 0.07305388f, 0.09696304f, 0.06284233f, 0.10521924f, 
    0.14549939f, 0.19111660f, 0.05910346f, 0.12508152f, -0.21654308f, -0.07457455f, -0.12671492f, 0.05027066f, 
    0.07409523f, -0.05751040f, 0.06230739f, -0.06193667f, 0.09780455f, -0.07721628f, -0.00060263f, 0.09269934f, 
    -0.07390351f, 0.07875138f, 0.07541611f, -0.09586326f, -0.01870814f, -0.00897387f, 0.06260272f, 0.04601936f, 
    0.08571845f, -0.15797105f, -0.15057603f, 0.29399472f, 0.25822172f, 0.03318512f, 0.00453243f, 0.06437025f, 
    0.17087570f, -0.00002835f, 0.02885491f, 0.07955213f, -0.10519828f, 0.03432782f, 0.04542839f, 0.00476445f, 
    -0.01394129f, -0.02636929f, 0.11644080f, 0.06327704f, 0.37937263f, 0.09262922f, 0.36344650f, 0.06221154f, 
    0.18408442f, 0.08084889f, -0.11654726f, -0.07428328f, -0.01638023f, 0.00824169f, 0.05127887f, 0.03399549f, 
    -0.01492658f, 0.01778291f, 0.05789589f, -0.00763364f, -0.13896832f, -0.09829263f, -0.01560729f, 0.05428259f, 
    0.25120965f, -0.08299897f, -0.21174294f, -0.02359138f, -0.02108289f, 0.05550148f, -0.15309888f, -0.07474295f, 
    0.04583566f, 0.30536902f, 0.15200680f, -0.01300390f, 0.22032769f, 0.06913336f, 0.06235662f, 0.03859720f, 
    -0.09504515f, 0.00073416f, -0.07066359f, 0.10841953f, -0.13030732f, -0.02557916f, -0.00257480f, -0.15639581f, 
    0.09438063f, 0.12474561f, 0.01374245f, -0.10453168f, -0.06116867f, 0.31644654f, 0.19920370f, 0.14783898f, 
    0.06431811f, -0.05396581f, -0.09714993f, -0.03305077f, 0.12546274f, 0.00635797f, 0.15575229f, 0.12570466f, 
    -0.25989586f, -0.15109438f, 0.28762591f, 0.18977429f, 0.19056472f, -0.09299430f, 0.03229634f, 0.11926553f, 
    -0.06439637f, 0.11013855f, 0.06148480f, 0.06467672f, 0.02520934f, -0.02055696f, 0.07733821f, -0.05492708f, 
    -0.13881832f, 0.05973367f, -0.15167330f, -0.03413519f, -0.29422933f, -0.00163736f, 0.10249205f, -0.19571210f, 
    0.48554704f, -0.08442499f, 0.15868402f, 0.12986021f, 0.08907155f, 0.11785940f, -0.09600331f, 0.13463061f, 
    -0.03182875f, -0.06267420f, 0.09145209f, -0.17615706f, -0.07549493f, -0.02711461f, -0.06623296f, -0.07353611f, 
    -0.23047328f, -0.24405849f, -0.14652097f, 0.12728883f, -0.03470057f, 0.15661670f, 0.23969497f, 0.16378631f, 
    0.04681631f, 0.27495325f, 0.01732633f, -0.04377735f, 0.08536099f, 0.03332526f, 0.05391029f, -0.02232903f, 
    0.05102904f, 0.03617827f, 0.02723452f, 0.11646056f, -0.06301110f, 0.03304435f, 0.17884412f, 0.21609314f, 
    -0.07569883f, -0.04955617f, -0.03859045f, -0.07714011f, 0.05923333f, -0.07512023f, 0.01528268f, -0.06388377f, 
    0.03582126f, -0.02481857f, 0.04294009f, 0.01202152f, 0.07847595f, -0.01701806f, 0.12239278f, 0.01906393f, 
    0.17782700f, -0.01060341f, 0.09514172f, -0.01567486f, -0.14181799f, -0.03833802f, 0.01010491f, 0.02908017f, 
    0.00221875f, -0.07373426f, 0.00737641f, 0.01475732f, 0.07377218f, 0.03458324f, 0.00052126f, -0.10580987f, 
    -0.08608492f, 0.04671185f, -0.01090857f, -0.10444128f, -0.08976907f, 0.21580161f, -0.01696036f, 0.16341633f, 
    0.27274355f, -0.01056791f, 0.05651085f, -0.03081711f, 0.18522413f, 0.07175267f, -0.06518872f, -0.05552879f, 
    -0.03839437f, -0.12772526f, 0.06851307f, -0.05962682f, -0.02706990f, -0.07605623f, -0.00040750f, 0.04720274f, 
    0.09241932f, 0.07019856f, 0.04274700f, 0.20333165f, 0.25530636f, 0.07710021f, 0.08210255f, 0.04965240f, 
    0.04934392f, 0.00746376f, 0.02340461f, -0.00609006f, -0.02364024f, -0.11637603f, 0.11382652f, -0.04221090f, 
    0.00558419f, -0.21100697f, 0.06447329f, -0.04589712f, 0.18279484f, -0.09832618f, 0.08978088f, 0.06681615f, 
    -0.15066645f, -0.00836910f, -0.02136711f, 0.08729999f, 0.00562634f, 0.02075025f, 0.02049472f, 0.05123832f, 
    0.04239691f, -0.12858208f, -0.08846144f, 0.15593719f, -0.04134949f, -0.16130637f, 0.11121207f, -0.03050046f, 
    -0.17397474f, 0.02617308f, -0.15324560f, 0.15047185f, 0.27520037f, -0.02842345f, -0.16977008f, -0.04530067f, 
    -0.05348096f, 0.16171205f, 0.01768944f, 0.00878491f, 0.00896000f, -0.00679501f, -0.00628675f, 0.05953397f, 
    0.05288668f, -0.12597552f, -0.21566711f, -0.18262587f, 0.16931726f, -0.10696295f, -0.42878607f, -0.03320876f, 
    -0.07769954f, -0.01759943f, 0.03047033f, 0.08211309f, 0.04154755f, -0.05702455f, -0.05647508f, 0.02913737f, 
    0.04279692f, -0.09258576f, -0.15023509f, 0.03699197f, 0.00558429f, 0.06861492f, 0.01967438f, -0.00168005f, 
    0.07577025f, -0.09381454f, 0.01324592f, -0.07994127f, -0.11885156f, -0.10783280f, 0.09758152f, -0.03748378f, 
    0.00510191f, -0.05550023f, -0.06703867f, -0.00307866f, 0.01990586f, 0.08073971f, -0.22571318f, -0.09118553f, 
    0.09080642f, 0.01530974f, 0.04971061f, 0.04848425f, -0.16841415f, 0.12292559f, -0.07318483f, 0.20768379f, 
    0.32037699f, -0.07715548f, -0.14730681f, -0.18969609f, -0.00866508f, 0.12093755f, -0.10241205f, 0.03095449f, 
    0.05777002f, -0.01314162f, 0.10229717f, 0.00732351f, -0.03802058f, 0.00457342f, -0.16196416f, 0.01378681f, 
    0.04669212f, 0.01777393f, -0.04539218f, 0.08684650f, 0.33458319f, -0.01963390f, 0.04086586f, -0.09788816f, 
    0.11968216f, -0.09985477f, -0.02389954f, 0.04596850f, -0.00603116f, -0.05997065f, -0.08121429f, 0.04798771f, 
    0.04456452f, 0.06569471f, -0.01253125f, 0.08522093f, 0.21144603f, 0.33521098f, 0.20669994f, 0.21062161f, 
    0.15280631f, -0.05878177f, -0.07412315f, 0.13122982f, -0.08843293f, -0.19969206f, -0.04691375f, 0.01809851f, 
    0.08342724f, 0.05974388f, 0.07896437f, -0.13664328f, 0.05458107f, 0.12232598f, -0.07629637f, -0.10686251f, 
    -0.19556205f, 0.04592765f, 0.14744239f, -0.17814423f, -0.04223527f, 0.06485489f, 0.16867027f, 0.06793619f, 
    0.02932255f, -0.26331609f, -0.02905811f, -0.06921110f, -0.05144580f, 0.01996173f, 0.07685190f, 0.03259373f, 
    0.13914433f, 0.23486507f, -0.19568627f, 0.05293969f, -0.29114315f, -0.08158694f, -0.13871406f, 0.00188348f, 
    -0.03078299f, 0.13004255f, 0.06318163f, 0.35290235f, 0.22237007f, 0.19349052f, -0.12267194f, -0.02728070f, 
    -0.01188797f, 0.15224136f, -0.02182854f, -0.03967540f, 0.04769766f, 0.00992516f, 0.07115732f, 0.04358550f, 
    0.21768644f, -0.04059523f, 0.35911104f, -0.03144257f, 0.05350754f, 0.07693411f, -0.10164558f, -0.09202043f, 
    0.01145523f, 0.01339330f, -0.06799370f, -0.01811714f, 0.01610098f, -0.01300345f, -0.03677168f, 0.08407098f, 
    0.11329889f, -0.10588251f, -0.03918532f, 0.06496056f, 0.06329793f, 0.54850507f, 0.09607078f, 0.15282065f, 
    -0.12786694f, 0.18104735f, 0.08476546f, 0.04687297f, 0.08579486f, -0.02394288f, -0.03840806f, -0.05277818f, 
    -0.16913180f, -0.00851734f, 0.15014593f, 0.05513724f, 0.01052385f, -0.02886143f, -0.09010495f, 0.10858729f, 
    -0.00299039f, 0.08586703f, -0.01911351f, -0.01376986f, 0.04701319f, -0.06054054f, 0.08905753f, 0.04425564f, 
    -0.13489464f, 0.02285668f, 0.07557717f, 0.20277879f, 0.06821878f, -0.01223669f, 0.05006456f, -0.06802215f, 
    -0.14493605f, -0.07722842f, -0.06363912f, -0.03935152f, -0.18273462f, -0.09539053f, -0.00175464f, 0.25101233f, 
    -0.20396009f, -0.14323263f, 0.06074920f, 0.02447485f, 0.05460147f, 0.03583885f, -0.12680717f, 0.04842032f, 
    0.06562143f, -0.01293532f, 0.02690030f, -0.04715514f, 0.02983842f, -0.04419162f, -0.07483162f, 0.14010367f, 
    0.00011808f, -0.12867925f, 0.08865894f, 0.01980330f, -0.12759520f, -0.03944037f, -0.00732333f, 0.09418588f, 
    0.02697595f, -0.03134780f, -0.06252410f, 0.04494989f, 0.02059453f, -0.09978402f, 0.02144339f, -0.01094892f, 
    -0.04998717f, -0.04669089f, -0.12353741f, 0.02489239f, 0.30448827f, 0.29140049f, -0.08060372f, 0.03807260f, 
    0.09738569f, -0.08227692f, 0.10278896f, 0.06844591f, -0.10124909f, 0.09729779f, -0.05267795f, -0.02916935f, 
    0.02408836f, -0.06994896f, -0.02799241f, 0.08383630f, 0.13481265f, -0.12437386f, 0.03137906f, 0.08657080f, 
    0.24778223f, 0.25460598f, -0.31601068f, 0.10053662f, 0.06253184f, -0.09077554f, 0.13583452f, 0.11801575f, 
    -0.00367123f, 0.04249181f, -0.01583638f, -0.01344844f, 0.02339139f, -0.10287150f, 0.03987199f, 0.19218212f, 
    0.05350089f, 0.06052830f, 0.12989016f, 0.06553729f, 0.03339840f, -0.33731279f, 0.20760091f, -0.08416929f, 
    -0.08334285f, 0.00699601f, -0.06844745f, 0.07214406f, 0.00433943f, -0.03392776f, 0.04664335f, 0.06797109f, 
    0.03674116f, 0.02794599f, 0.02209035f, 0.09425066f, 0.00524150f, -0.02381114f, 0.06862501f, 0.11303644f, 
    -0.07206330f, 0.11754815f, -0.00895568f, -0.22023153f, -0.03326446f, 0.05077026f, -0.08065899f, 0.05053753f, 
    -0.02343075f, 0.05210228f, -0.15672244f, 0.00661501f, -0.00759361f, -0.05251065f, -0.05385936f, 0.12112209f, 
    -0.06308946f, 0.01315012f, -0.03221003f, 0.14136550f, 0.16129360f, -0.00692366f, -0.15251748f, 0.28961125f, 
    -0.04414416f, -0.02163394f, -0.06279635f, -0.04045278f, -0.07570482f, 0.04804454f, -0.02209874f, -0.06285890f, 
    0.02351120f, -0.00289861f, -0.05533247f, 0.01557247f, -0.01861296f, 0.03677162f, -0.04980887f, 0.05725631f, 
    -0.07128938f, -0.06820426f, 0.26189223f, 0.12251800f, 0.02828275f, -0.11500454f, 0.16348591f, 0.13435453f, 
    0.03158154f, -0.08485477f, 0.03327090f, -0.04945179f, -0.26674578f, -0.02626450f, 0.10115624f, -0.16986011f, 
    0.03874143f, -0.07658459f, -0.11339393f, -0.05133366f, 0.24542472f, 0.18719840f, -0.02736843f, -0.20816508f, 
    0.14551906f, -0.02980853f, 0.09600572f, 0.05157441f, -0.11769779f, 0.05201818f, -0.06731402f, 0.04093567f, 
    0.06493977f, 0.00554189f, -0.09480968f, 0.09485933f, -0.08124638f, -0.07569754f, 0.06223953f, 0.06378864f, 
    0.31035873f, 0.25249320f, 0.24256937f, -0.19472404f, 0.11050755f, 0.01536289f, 0.03799053f, -0.09364430f, 
    0.00755708f, -0.09236728f, -0.09408557f, 0.01298042f, 0.06429683f, 0.00066308f, -0.07131351f, -0.02719652f, 
    -0.02088960f, 0.00466214f, 0.06049161f, -0.06560625f, 0.01246443f, 0.06085607f, -0.18468277f, 0.35239446f, 
    0.02238878f, -0.09831858f, -0.07277929f, 0.31311515f, -0.21517096f, -0.03197790f, -0.17683321f, 0.08375198f, 
    -0.10151967f, -0.01423616f, -0.06595951f, -0.04975873f, -0.07437500f, 0.08576389f, 0.07934435f, 0.14132290f, 
    -0.14512983f, 0.00211277f, 0.37691680f, -0.15835269f, -0.02491023f, -0.09959614f, -0.02040279f, -0.09865347f, 
    0.02242275f, -0.32479706f, -0.06891716f, -0.03559086f, -0.01153233f, -0.00540062f, 0.02549054f, 0.11612751f, 
    0.02171439f, 0.04677878f, -0.00768733f, -0.19276042f, 0.29293096f, 0.17584713f, -0.27280712f, 0.26055768f, 
    0.06160863f, -0.04052563f, -0.01762781f, 0.15943821f, -0.05622459f, 0.03711309f, -0.20408392f, -0.05996255f, 
    -0.04412419f, -0.00714996f, 0.01500228f, 0.01517513f, -0.07122656f, -0.10019939f, -0.11836553f, 0.01564319f, 
    0.12783250f, 0.01925909f, 0.18430109f, -0.10513578f, -0.00441537f, 0.08153227f, 0.02092513f, -0.10710029f, 
    -0.01916414f, -0.17664728f, -0.02249333f, 0.07275660f, 0.07540248f, -0.01260032f, -0.04657195f, -0.04190502f, 
    -0.03874143f, 0.00449644f, 0.08932731f, 0.11327621f, 0.19108704f, 0.04381688f, 0.17380422f, 0.13381842f, 
    -0.27661082f, 0.18874589f, 0.09852844f, 0.01506196f, -0.10992794f, 0.09389749f, 0.01902985f, -0.03410877f, 
    0.08753571f, 0.10478214f, -0.02098637f, 0.15363242f, 0.03944592f, 0.02576884f, -0.03173500f, -0.03397650f, 
    0.02562607f, 0.30220532f, 0.10192692f, -0.01047795f, -0.03681673f, -0.10080575f, -0.03225020f, 0.03884583f, 
    0.07955373f, -0.03760796f, -0.02105600f, -0.03147137f, 0.05509604f, 0.04855756f, 0.03527602f, -0.04058229f, 
    -0.09715804f, 0.00350238f, -0.17076202f, -0.03293340f, 0.14399906f, -0.10656035f, -0.13490666f, -0.09971698f, 
    -0.16626115f, -0.15252653f, 0.05130735f, -0.08538357f, 0.10776039f, 0.04515260f, 0.03608777f, 0.05259833f, 
    -0.14189269f, 0.01571951f, -0.01808516f, 0.07565069f, 0.09059319f, -0.23104100f, 0.06346690f, 0.01959999f, 
    0.01842742f, -0.24053299f, -0.30799913f, -0.05525708f, 0.08803795f, -0.05791615f, 0.04463920f, -0.02087237f, 
    -0.02590755f, -0.09524720f, -0.06888834f, 0.05584655f, -0.00898462f, -0.06096680f, -0.01058473f, 0.02639065f, 
    -0.02017932f, 0.04004487f, -0.07689530f, -0.10536961f, 0.26104078f, 0.31634730f, 0.10296023f, 0.00033466f, 
    -0.13055316f, -0.00204154f, 0.09934476f, 0.09703494f, 0.16088405f, 0.15983404f, 0.09470291f, -0.09514190f, 
    -0.03920962f, -0.08344546f, 0.03256281f, -0.05256630f, -0.08361249f, -0.12814049f, 0.04566076f, 0.09507350f, 
    -0.03677884f, 0.33601165f, 0.05923251f, 0.12388889f, 0.02194030f, 0.09908960f, 0.14113779f, 0.01023542f, 
    0.04252756f, 0.11348407f, 0.10510050f, -0.03568542f, 0.01971762f, -0.05891346f, 0.02092208f, -0.00177001f, 
    -0.10716691f, 0.02004836f, -0.02315067f, 0.08500666f, -0.11070375f, -0.41730860f, -0.03445816f, 0.09983978f, 
    0.28546816f, -0.03479087f, -0.00266559f, 0.01400148f, -0.01134404f, -0.13027945f, -0.01472615f, 0.02664265f, 
    0.01893063f, 0.03045554f, 0.08657756f, 0.13742875f, -0.08198037f, 0.03457367f, 0.12240095f, -0.06476925f, 
    0.16977336f, 0.31768823f, 0.21746433f, -0.11298713f, -0.22337745f, 0.01539629f, -0.09782487f, 0.08726666f, 
    -0.09198964f, 0.20698816f, -0.07825943f, 0.02120818f, 0.03933212f, -0.03898729f, 0.09012265f, -0.04141530f, 
    -0.01209648f, 0.03188142f, 0.09104791f, 0.06890152f, 0.10958121f, -0.12526587f, -0.12649697f, 0.08897211f, 
    -0.24082407f, -0.01020298f, 0.01915852f, 0.01156447f, -0.03545806f, -0.06360064f, 0.08412633f, 0.03012135f, 
    0.03037100f, 0.14347801f, 0.05524268f, 0.02204518f, 0.02714469f, 0.00121530f, -0.00030802f, -0.05619626f, 
    -0.22608010f, -0.04887040f, 0.04687514f, -0.05964570f, 0.11590776f, -0.01355189f, -0.05291349f, -0.09775976f, 
    -0.05151483f, 0.00759215f, -0.02217500f, 0.07382514f, 0.07009724f, 0.05410798f, -0.06854643f, 0.00743381f, 
    -0.06095647f, -0.11234904f, -0.13293254f, -0.12393717f, 0.30209550f, 0.21150930f, 0.31565601f, -0.01504513f, 
    -0.01759483f, 0.13995160f, 0.09257275f, 0.14003375f, 0.05412901f, 0.13407595f, 0.04495807f, -0.05735676f, 
    0.00584575f, -0.16906287f, 0.00634361f, -0.05240094f, -0.04210704f, 0.00752177f, -0.12026057f, -0.01799641f, 
    -0.08171843f, 0.20160852f, 0.23934610f, -0.05980125f, -0.20675533f, 0.07756656f, 0.21749754f, 0.13286929f, 
    -0.03970694f, 0.09128796f, 0.00033875f, -0.01330689f, 0.01910008f, 0.03618181f, -0.03288748f, -0.04510220f, 
    0.03973053f, -0.01297480f, -0.14678164f, -0.00274891f, -0.55435252f, -0.14573799f, -0.28084967f, -0.15821396f, 
    0.05547055f, -0.03302096f, 0.05496697f, 0.09538316f, 0.01280355f, 0.02176236f, 0.03479397f, -0.02352062f, 
    0.00679513f, -0.07383163f, -0.06192797f, 0.02791788f, 0.09635477f, 0.08072250f, 0.01685275f, -0.00772078f, 
    -0.22815420f, 0.04839893f, 0.07538491f, 0.14856955f, 0.12165982f, 0.10441951f, 0.04971722f, -0.02812145f, 
    -0.03330308f, -0.08465762f, -0.00641129f, 0.12042360f, -0.18165883f, 0.01508920f, -0.01280470f, -0.03177057f, 
    0.07056882f, 0.04648500f, -0.02303883f, 0.02735730f, 0.20912443f, 0.20784189f, 0.04570486f, 0.03435480f, 
    0.02718341f, -0.13468881f, -0.05844650f, 0.06740610f, -0.00155273f, -0.20732990f, -0.13167715f, -0.05816188f, 
    -0.00954551f, -0.02402770f, -0.08285611f, -0.02293120f, -0.00787907f, 0.06105829f, -0.02333155f, 0.02136683f, 
    0.15788180f, 0.20528273f, -0.20477706f, -0.04696691f, -0.29585600f, 0.13957718f, -0.06577071f, -0.06399598f, 
    0.10585317f, -0.06463302f, -0.02313191f, -0.00770956f, -0.00351707f, 0.02593930f, -0.08562849f, -0.00448762f, 
    0.00416136f, -0.10740401f, 0.06932458f, -0.02853347f, 0.53356653f, 0.23929940f, 0.00584748f, 0.26026458f, 
    -0.48331979f, 0.11702523f, -0.01363888f, 0.15099236f, -0.08271866f, -0.03857720f, -0.00518375f, -0.04166563f, 
    -0.00124022f, 0.08735322f, 0.09688385f, 0.17601752f, 0.00903056f, 0.02414094f, 0.02736867f, 0.04190983f, 
    -0.01502896f, -0.04213974f, -0.02218579f, -0.05648269f, -0.02504255f, 0.03552695f, 0.04221831f, -0.03095192f, 
    0.03804499f, -0.05187326f, -0.00247134f, 0.02017978f, 0.02532740f, 0.01282507f, 0.04570161f, -0.05821146f, 
    -0.03419575f, 0.03596070f, -0.05244801f, 0.02529654f, -0.01418432f, -0.02946456f, -0.01661263f, -0.00514360f, 
    0.03919762f, -0.01148643f, -0.05271406f, -0.00746554f, 0.01992136f, -0.05059503f, -0.05428538f, -0.02797675f, 
    0.00203486f, -0.05336564f, -0.01783743f, 0.02207877f, -0.01995910f, 0.01402687f, -0.04584456f, -0.00655317f, 
    -0.00314353f, -0.03718527f, 0.04129265f, -0.01705747f, 0.00132648f, 0.03461015f, 0.03330999f, -0.05275654f, 
    0.03330119f, 0.00162051f, 0.01223140f, -0.04772231f, -0.03460241f, -0.04264010f, -0.04259486f, -0.00605955f, 
    -0.02476410f, 0.04706733f, 0.00777706f, 0.04495259f, 0.01320982f, -0.02058272f, -0.04606026f, -0.02246259f, 
    -0.04945027f, -0.01109337f, -0.02585553f, -0.01275997f, 0.00176258f, 0.02477769f, -0.04809241f, 0.02544730f, 
    0.01657901f, 0.02724726f, -0.02762814f, -0.03882645f, 0.00745623f, -0.03765046f, -0.02846893f, -0.01656315f, 
    -0.00049522f, -0.02928829f, -0.00738535f, -0.00332060f, 0.00087535f, 0.01184949f, -0.05596713f, -0.00620917f, 
    0.03990140f, 0.04178724f, 0.02937641f, 0.00021678f, -0.03913685f, -0.03660336f, 0.00578432f, -0.04555763f, 
    -0.00969868f, -0.02604865f, -0.02521585f, 0.04087804f, 0.01525621f, -0.01734473f, -0.00235695f, -0.05000225f, 
    -0.01404782f, -0.04444943f, -0.00929537f, 0.02424788f, -0.05537427f, -0.00424577f, -0.04192511f, -0.02832942f, 
    0.01521160f, -0.03197411f, -0.03655828f, 0.03134705f, -0.04494999f, 0.00166251f, -0.04578301f, 0.03088060f, 
    0.01398046f, -0.00322358f, -0.04104762f, 0.01818720f, -0.04434402f, 0.00860067f, -0.01206161f, -0.02814353f, 
    -0.04341919f, 0.04158050f, -0.00173060f, -0.02086964f, 0.01800616f, -0.01363150f, 0.00082373f, 0.01461232f, 
    -0.05692816f, 0.00706859f, -0.05592362f, 0.04240585f, 0.04330089f, -0.00685791f, 0.00473209f, 0.01866141f, 
    -0.05505333f, 0.01522267f, 0.02997969f, 0.04691600f, -0.05403573f, 0.01843827f, 0.00814005f, -0.04370017f, 
    -0.01233457f, -0.00861760f, -0.02480150f, 0.01525760f, -0.04840603f, -0.05688801f, -0.05958986f, -0.00554422f, 
    -0.00911188f, -0.04738689f, -0.02134312f, 0.01480112f, 0.02966586f, -0.05258188f, 0.04550168f, -0.01386224f, 
    -0.02104513f, -0.05140630f, 0.00928916f, 0.00980007f, -0.03752769f, -0.04205323f, 0.04344957f, -0.03207859f, 
    0.00546055f, 0.02357025f, -0.04512008f, -0.04624002f, 0.00549018f, -0.00364983f, 0.01375170f, -0.01118907f, 
    -0.02556508f, -0.03906123f, 0.03731945f, -0.01154859f, 0.02955532f, 0.04846727f, -0.06146856f, -0.01107504f, 
    0.02815085f, 0.04761873f, 0.04252575f, -0.03383955f, 0.02881319f, -0.01782231f, 0.01876490f, -0.04535392f, 
    0.00098469f, 0.05491357f, 0.04556349f, -0.05538390f, 0.05023091f, -0.01677572f, -0.05153397f, -0.00203954f, 
    0.03616592f, -0.05037619f, -0.03037071f, 0.03398955f, -0.04855611f, -0.04611740f, 0.02698060f, -0.06070542f, 
    0.00965761f, -0.03622367f, -0.02264938f, -0.01785777f, 0.01659260f, -0.04785614f, -0.04880179f, -0.05494308f, 
    0.02746602f, 0.04270608f, -0.00113691f, 0.03910519f, 0.00004083f, -0.03257085f, -0.03580186f, -0.04453678f, 
    -0.00744124f, -0.04393052f, 0.00915296f, 0.03034317f, -0.01603076f, -0.01591834f, -0.06010043f, -0.01526142f, 
    0.03495573f, 0.04127808f, 0.04859853f, -0.04058068f, -0.02113421f, -0.06169683f, -0.03588064f, 0.03813378f, 
    0.04468335f, -0.02157191f, -0.05993905f, 0.01366847f, 0.00302219f, 0.02877982f, -0.05240871f, -0.00377250f, 
    -0.00406799f, 0.00873443f, 0.02956451f, -0.02825619f, 0.03810825f, 0.02460903f, 0.04600991f, 0.02497946f, 
    -0.05018419f, -0.03112824f, -0.01416786f, -0.00785944f, 0.00899153f, 0.03566761f, 0.00577114f, 0.02553680f, 
    0.00653886f, -0.05141609f, -0.03181941f, 0.01928471f, 0.03539664f, -0.01913531f, 0.03601028f, -0.00386666f, 
    0.02496226f, -0.05903101f, 0.03631485f, 0.02045288f, -0.00076802f, -0.05583549f, 0.03121272f, 0.00718937f, 
    -0.03389394f, 0.04011837f, 0.02175717f, -0.03352429f, -0.03318059f, -0.00493116f, -0.05748697f, -0.02030119f, 
    0.03535959f, 0.01733184f, 0.01139712f, 0.00796765f, -0.00250161f, -0.05400159f, 0.02158038f, 0.01093863f, 
    -0.04863333f, -0.04093664f, -0.04737735f, -0.01390358f, -0.02204322f, 0.01901817f, -0.00003241f, -0.03712614f, 
    -0.05396218f, 0.03307260f, -0.05732838f, -0.02715934f, -0.00476054f, -0.04998852f, -0.04751620f, -0.03127404f, 
    0.08901894f, 0.30069035f, 0.17420499f, -0.09023084f, -0.11962601f, 0.01887880f, 0.13190465f, 0.02633832f, 
    0.04078704f, 0.01156138f, 0.10271043f, -0.01055007f, 0.07308008f, 0.14200577f, 0.07281427f, -0.05090550f, 
    -0.06999407f, -0.02263325f, -0.08425818f, -0.06211570f, 0.23480605f, -0.00225668f, -0.08933097f, -0.31226161f, 
    0.00653164f, 0.15256415f, -0.02494726f, -0.00908727f, -0.05873452f, -0.03177970f, 0.23094910f, 0.05701488f, 
    0.00042368f, 0.06757973f, -0.07834142f, -0.04945508f, -0.07903288f, -0.09257741f, -0.13487510f, -0.10388710f, 
    0.26799819f, 0.12320664f, -0.14553480f, 0.05158875f, 0.18826769f, 0.08967575f, 0.06557993f, 0.02848773f, 
    -0.01217674f, 0.11544608f, 0.17729159f, 0.03894488f, -0.05180780f, -0.07907738f, 0.00672426f, -0.12552357f, 
    -0.13406326f, -0.05661876f, 0.05251020f, 0.02380756f, 0.11523627f, -0.13143180f, 0.42031518f, -0.16424853f, 
    -0.13628584f, -0.03686521f, 0.13637626f, -0.10626779f, 0.09850246f, -0.09453132f, 0.03496347f, -0.06987529f, 
    -0.00112159f, -0.04874480f, -0.02930867f, -0.06898621f, -0.02189704f, -0.14714876f, -0.08878671f, -0.05871886f, 
    -0.08224243f, 0.00632620f, 0.28819975f, -0.12364220f, -0.14890377f, -0.01450595f, 0.05931922f, -0.05840230f, 
    0.04522034f, -0.09352547f, 0.06371574f, -0.02910999f, -0.01456008f, -0.06199036f, -0.04753228f, -0.10542858f, 
    -0.08288626f, 0.03321292f, -0.09519980f, 0.04644158f, 0.18040200f, 0.00433711f, 0.05099380f, 0.01504910f, 
    0.13799433f, 0.01020542f, 0.06854264f, -0.00648634f, 0.13924648f, 0.15212078f, 0.13357070f, 0.19088425f, 
    -0.16185281f, -0.07254376f, 0.04667231f, -0.01973412f, 0.02281795f, 0.00481582f, 0.07654252f, 0.11166185f, 
    0.01157833f, 0.29485518f, 0.31363091f, -0.08680686f, -0.28509668f, 0.13632283f, 0.18567136f, 0.01772645f, 
    0.01698109f, 0.09747638f, 0.05021920f, -0.02071404f, -0.11776641f, 0.04481852f, -0.02259748f, -0.04354156f, 
    0.06016288f, -0.02918455f, -0.05144148f, 0.16304301f, 0.50717229f, 0.09935845f, 0.31714931f, -0.29755795f, 
    -0.09605075f, -0.05231161f, 0.00554953f, -0.01741830f, -0.05764396f, -0.00291112f, 0.05962609f, 0.01605157f, 
    -0.18768640f, 0.07522210f, 0.09419367f, 0.10903283f, 0.03414537f, -0.00333879f, 0.04678508f, 0.00006138f, 
    0.15999769f, 0.10342907f, -0.06499460f, -0.01231239f, 0.04130839f, 0.10658555f, -0.06657530f, 0.03174736f, 
    -0.01316944f, 0.09837601f, 0.00158582f, -0.06537700f, -0.10890091f, 0.02451649f, 0.08003023f, 0.08226186f, 
    -0.04850557f, 0.03243826f, -0.25097594f, -0.12194461f, 0.15833366f, -0.01706535f, 0.24461518f, 0.02230150f, 
    -0.15044284f, 0.03772922f, 0.19447753f, 0.07909940f, 0.02274038f, -0.02463963f, -0.04687287f, -0.04890092f, 
    -0.08475242f, -0.02713416f, 0.02889014f, -0.06867004f, 0.01730317f, -0.13779242f, 0.10770215f, -0.02730854f, 
    0.12658766f, 0.33968195f, 0.18123049f, 0.18430749f, -0.15341942f, 0.01503711f, 0.19538605f, 0.29670474f, 
    0.05013745f, 0.05335359f, 0.00587829f, -0.00308678f, 0.07805362f, 0.06036618f, 0.08988099f, -0.05841509f, 
    -0.09671564f, -0.02867026f, 0.04591422f, 0.03585172f, 0.08688961f, -0.30685121f, -0.06688704f, -0.04469905f, 
    -0.00020555f, 0.07118241f, -0.01708507f, -0.17630993f, 0.07484661f, 0.07583027f, 0.07012235f, 0.05556662f, 
    0.12914002f, -0.02874863f, -0.13193610f, 0.00717610f, -0.03292811f, -0.05857525f, -0.01137781f, -0.03962940f, 
    -0.31119367f, 0.14896169f, -0.16291255f, 0.12483720f, 0.05717550f, -0.04792568f, -0.09465649f, 0.06725626f, 
    -0.11302833f, 0.30357203f, 0.06005659f, 0.09807479f, 0.04081644f, -0.03368578f, -0.08810587f, 0.03438960f, 
    -0.12894472f, -0.13273911f, 0.17099516f, 0.15680961f, 0.21977408f, 0.20052344f, 0.37184963f, -0.33752310f, 
    -0.11281685f, 0.05707946f, 0.11594281f, -0.06898981f, -0.04213090f, -0.11918998f, 0.14437152f, -0.02993953f, 
    0.22524098f, -0.03904499f, 0.07684183f, 0.01299476f, -0.07953576f, -0.24367881f, -0.00314286f, 0.04946968f, 
    -0.31934804f, -0.12225769f, -0.54606259f, 0.14186741f, 0.14220367f, 0.03569339f, -0.02670940f, -0.02387214f, 
    -0.00843129f, 0.11970650f, 0.15085033f, -0.02924815f, 0.00694695f, -0.00208006f, 0.01352153f, 0.07635278f, 
    0.03467764f, -0.07337400f, 0.10584410f, -0.10952467f, 0.26506984f, -0.27372050f, -0.10529247f, -0.03880844f, 
    -0.08358440f, -0.26257053f, -0.07090200f, -0.04898870f, 0.01854084f, 0.10155180f, 0.19296935f, 0.07088003f, 
    -0.01752451f, -0.05191276f, 0.02543351f, 0.06075945f, 0.01313093f, 0.01958916f, 0.12625173f, 0.08253303f, 
    0.28730896f, 0.05087281f, 0.18731397f, -0.10278503f, -0.05174826f, 0.09972128f, -0.14177610f, 0.08248155f, 
    0.13269046f, 0.02868647f, -0.05004973f, 0.03514778f, -0.02964073f, -0.07314021f, -0.08339129f, -0.08790143f, 
    0.06812888f, -0.00261168f, 0.10909595f, 0.11089552f, -0.21104658f, 0.13056450f, -0.03768313f, -0.19537668f, 
    0.28432456f, -0.01995355f, -0.05253540f, 0.09107249f, -0.06167559f, 0.00250314f, -0.06830557f, 0.01692257f, 
    -0.08489794f, -0.11267579f, -0.15541287f, -0.03864709f, 0.07141245f, 0.00062126f, -0.10544870f, -0.10307814f, 
    -0.38523915f, 0.19851597f, -0.06526092f, 0.14415972f, 0.03616299f, -0.08251324f, -0.02856011f, -0.09816191f, 
    -0.03510950f, -0.10939747f, 0.00773071f, -0.06598949f, -0.04121447f, -0.05486881f, -0.01911675f, -0.06115682f, 
    -0.00740590f, -0.04164286f, 0.03818050f, -0.07354435f, 0.16857517f, -0.07324255f, -0.01188653f, -0.37000901f, 
    0.15591048f, 0.04235153f, -0.03161832f, 0.10700180f, 0.02418415f, 0.01347461f, -0.00167572f, -0.04906904f, 
    -0.00439019f, -0.04075683f, 0.12827741f, -0.01457774f, -0.08112034f, 0.18062596f, -0.00162192f, 0.07895995f, 
    0.12816581f, 0.15243427f, 0.20767811f, -0.40112603f, 0.00716004f, -0.10343843f, 0.09036451f, 0.06290839f, 
    0.02131345f, 0.16229129f, 0.07086520f, -0.08075276f, 0.06382154f, 0.05200557f, 0.01940987f, -0.00093001f, 
    -0.00951357f, 0.16417600f, 0.02073207f, 0.02189482f, 0.07889216f, 0.31475037f, 0.07581808f, 0.01319213f, 
    -0.11204950f, -0.35073560f, -0.00408271f, -0.15833940f, 0.20876998f, -0.20565346f, 0.01503886f, 0.02106294f, 
    0.09457431f, 0.01148318f, 0.05405694f, -0.13638745f, -0.03201554f, 0.01268227f, -0.06631443f, 0.11033878f, 
    0.32315326f, -0.00403760f, 0.01462258f, 0.11404962f, 0.31640106f, 0.13613671f, 0.14783123f, 0.15585355f, 
    0.19698857f, 0.19399790f, 0.04777420f, 0.01381316f, -0.05340188f, -0.00981974f, 0.00940922f, 0.01643839f, 
    0.11176590f, 0.04474376f, 0.02444025f, 0.05137745f, 0.17340375f, -0.21870939f, -0.04082552f, -0.31808329f, 
    -0.03670040f, 0.12497744f, -0.03169023f, -0.12185360f, 0.00537754f, -0.04555805f, -0.03301980f, -0.03999654f, 
    0.03584041f, -0.00070633f, 0.18692541f, -0.11891328f, -0.04368991f, 0.04305464f, 0.06186588f, 0.05189691f, 
    0.03494776f, 0.40784404f, -0.22809255f, 0.05181772f, -0.27003101f, 0.11810822f, -0.31179577f, 0.11574983f, 
    -0.12151089f, -0.10281042f, 0.12378023f, 0.05882720f, 0.06452909f, -0.01554017f, -0.10493676f, -0.03886874f, 
    -0.01934952f, 0.01663068f, 0.06784929f, -0.04987890f, 0.23431464f, 0.01630368f, 0.06083039f, -0.30746996f, 
    -0.02711623f, 0.22630358f, 0.14173466f, 0.03192012f, 0.25586703f, 0.07077192f, 0.13089755f, -0.10960794f, 
    -0.16283923f, 0.05041688f, 0.04920000f, -0.06613261f, -0.04797868f, 0.05531117f, 0.13295402f, -0.06574732f, 
    0.41256279f, -0.36069849f, -0.17130712f, -0.23207478f, -0.07443279f, 0.21446051f, 0.09687308f, 0.08408645f, 
    0.08668905f, -0.01588990f, 0.10448783f, -0.10261256f, -0.07342658f, -0.00591417f, 0.03244460f, -0.02055572f, 
    -0.08901118f, 0.07316683f, 0.06504171f, 0.07305250f, -0.00901020f, 0.10475776f, 0.51553291f, -0.22405556f, 
    0.03565387f, -0.29373109f, 0.03290048f, -0.07682259f, 0.19301210f, -0.01981379f, 0.13940750f, -0.00306699f, 
    0.08427457f, -0.04813882f, -0.04391945f, 0.20867667f, 0.08245512f, -0.19125421f, -0.07843729f, -0.00086473f, 
    0.16672294f, -0.05138774f, -0.09816661f, 0.21177551f, -0.10462680f, 0.07356194f, -0.10406490f, 0.01974089f, 
    -0.06870764f, 0.11765683f, 0.03670663f, 0.09000365f, -0.06708027f, -0.05519363f, -0.05130150f, 0.06318224f, 
    -0.05488489f, -0.12025448f, 0.14107674f, 0.07045467f, 0.28855911f, -0.22513062f, 0.44234407f, -0.38516429f, 
    0.36008853f, -0.04376545f, 0.28172365f, -0.08703775f, 0.09546679f, 0.20149960f, 0.12471173f, 0.07422753f, 
    -0.00686725f, -0.12527594f, 0.05133070f, -0.05813020f, -0.00517531f, -0.00680928f, 0.04893474f, 0.33937588f, 
    -0.40558186f, 0.31899884f, -0.18718643f, 0.32713038f, -0.22008109f, 0.09582046f, 0.08300859f, 0.24128215f, 
    0.13867256f, 0.10151708f, 0.14375927f, -0.04068138f, -0.04335259f, -0.02730368f, -0.02706402f, 0.09505521f, 
    0.01271202f, 0.06306921f, -0.08125475f, -0.10699112f, 0.38196135f, -0.19051360f, -0.58090550f, -0.19630279f, 
    0.16303845f, 0.23404059f, -0.04629467f, 0.24387611f, 0.15956575f, -0.14585654f, -0.10368814f, 0.16350834f, 
    0.12819824f, 0.10796328f, 0.14314821f, -0.09554726f, -0.00959584f, 0.11689863f, 0.17134857f, 0.04273454f, 
    0.01379905f, -0.07411162f, 0.00238359f, 0.24220285f, 0.23509760f, -0.07035060f, -0.10440814f, 0.05063716f, 
    -0.10614695f, 0.14997320f, 0.11998015f, 0.16496612f, 0.03296145f, -0.17272756f, -0.11219324f, -0.14063869f, 
    -0.27601629f, -0.33139852f, -0.11596823f, -0.39175025f, -0.24130653f, 0.11885186f, 0.03643167f, 0.06578042f, 
    0.07498696f, -0.04002151f, 0.00344830f, -0.01106479f, -0.04195018f, 0.06281894f, -0.03924226f, -0.10521309f, 
    0.16509709f, 0.06444974f, 0.06423413f, 0.05338781f, -0.05413592f, -0.03621464f, -0.05836864f, -0.06582407f, 
    0.04046595f, 0.01418208f, 0.00347489f, -0.12270752f, -0.18890044f, 0.00318132f, -0.02179022f, 0.21051712f, 
    0.12507862f, 0.10460443f, 0.04737942f, -0.12364926f, -0.02590450f, 0.01733231f, 0.00040366f, 0.10281819f, 
    -0.04128397f, 0.04232888f, -0.20844111f, -0.01193430f, -0.13097253f, -0.22322448f, 0.08979142f, 0.25076404f, 
    0.08263163f, -0.09478597f, -0.10074585f, -0.15320225f, 0.05053871f, 0.00861059f, 0.12587877f, -0.00013791f, 
    -0.12756057f, 0.01322905f, 0.04717974f, 0.11912366f, 0.21964231f, 0.19680290f, 0.01368158f, -0.02366370f, 
    0.09658070f, -0.41132545f, 0.04843333f, 0.31995425f, -0.00045477f, -0.06276105f, 0.03623575f, -0.03235222f, 
    -0.04545103f, 0.05901991f, 0.02598885f, 0.05813256f, -0.03301955f, -0.01574462f, -0.07814053f, 0.15965471f, 
    0.26097882f, 0.13458326f, 0.21106540f, 0.18285601f, -0.20885020f, 0.09011313f, -0.02928727f, -0.10643174f, 
    -0.13015950f, -0.06936952f, -0.11699854f, 0.03381191f, -0.03110282f, 0.09208751f, 0.05132644f, 0.07140994f, 
    0.09060667f, -0.11166815f, -0.12117004f, -0.00568815f, 0.31403136f, 0.07684521f, 0.09759330f, 0.33543214f, 
    -0.17638266f, -0.12031163f, -0.00714319f, 0.18852454f, 0.28660905f, -0.01645267f, 0.05621424f, 0.01500274f, 
    0.16554202f, 0.09080472f, -0.06301538f, -0.02657782f, 0.07496580f, -0.08350114f, -0.07730939f, 0.07988364f, 
    0.08137311f, -0.01024834f, 0.02294466f, 0.30144447f, 0.24603471f, 0.13405065f, 0.47937578f, 0.36165032f, 
    0.24832149f, -0.01353915f, -0.19502197f, -0.05088362f, 0.02485539f, -0.26167253f, -0.06602617f, -0.00078590f, 
    0.05218128f, 0.06229215f, 0.01142983f, 0.07594404f, 0.01061487f, -0.00752203f, -0.04792826f, -0.01871814f, 
    0.17173755f, -0.04568171f, -0.18348841f, -0.15782897f, -0.39589047f, 0.20577849f, 0.19698451f, -0.18607739f, 
    -0.01125690f, -0.07072241f, -0.03144065f, -0.00395753f, 0.03768869f, -0.16143081f, -0.13347799f, -0.19187698f, 
    -0.16733693f, -0.42628241f, -0.26763737f, -0.15960701f, -0.23043631f, -0.15130135f, -0.06671257f, 0.18724272f, 
    0.18141775f, -0.09531742f, -0.03616459f, -0.14260404f, -0.08143076f, 0.07331502f, -0.07256765f, 0.11082502f, 
    0.07109880f, 0.12335524f, -0.01707740f, 0.04736479f, 0.12238688f, 0.04398949f, 0.02692883f, 0.20248948f, 
    0.29729271f, -0.12794590f, 0.04379369f, 0.24236625f, 0.26596901f, -0.17519231f, -0.29108137f, -0.23928900f, 
    0.14244184f, -0.08590019f, 0.07751215f, 0.09874886f, -0.06715713f, -0.02655502f, -0.01981536f, -0.03997499f, 
    -0.10434100f, -0.05270947f, -0.00381460f, -0.01749797f, 0.71686929f, 0.13154987f, -0.07548840f, -0.16966857f, 
    -0.22946875f, 0.15311146f, -0.05440324f, 0.18327954f, -0.31835848f, -0.04087479f, -0.20728624f, 0.03832703f, 
    -0.08316687f, -0.02693828f, -0.05920662f, 0.00267542f, -0.09541979f, 0.02539160f, 0.03047928f, -0.09981198f, 
    0.15067241f, 0.07221659f, -0.02810690f, -0.08038032f, 0.01876376f, -0.09695471f, 0.12177103f, 0.10259695f, 
    0.02279356f, -0.16543798f, 0.06306434f, 0.00958431f, 0.00754111f, 0.14972599f, -0.00602525f, -0.02598440f, 
    0.08402582f, 0.00300309f, -0.17830735f, 0.14200343f, 0.08968966f, -0.07855102f, 0.15809190f, 0.16552332f, 
    -0.06126136f, -0.07112124f, -0.11130919f, -0.02984674f, 0.01601278f, 0.14891689f, 0.02999560f, -0.01439850f, 
    -0.03924491f, 0.05312388f, 0.01588201f, -0.06666671f, -0.28881103f, -0.11300511f, -0.09298092f, -0.49182576f, 
    0.19827965f, 0.07665257f, 0.29987761f, 0.08906092f, 0.27860489f, 0.10283622f, 0.14815004f, 0.08061818f, 
    -0.12482635f, 0.21698627f, 0.05213122f, -0.18226896f, 0.03545673f, -0.19433074f, -0.08424198f, -0.04743007f, 
    -0.09551513f, -0.11334108f, -0.07564157f, 0.04917168f, -0.43981850f, 0.05179877f, 0.41773713f, 0.16829100f, 
    0.14029138f, -0.15995607f, -0.02952729f, -0.12247784f, 0.01163875f, -0.21232994f, -0.03446267f, 0.00173614f, 
    -0.04872356f, 0.16462469f, 0.33417487f, 0.13684984f, 0.23057911f, 0.06755027f, -0.07744192f, 0.13231324f, 
    -0.02306244f, -0.00876814f, 0.00436817f, 0.03924537f, 0.00096999f, -0.04595497f, 0.04397149f, -0.02486893f, 
    0.02028386f, -0.00004895f, -0.05770064f, -0.05367668f, -0.01889324f, 0.03834697f, 0.04993855f, -0.04673081f, 
    0.04081663f, -0.01318526f, 0.04595016f, -0.04592314f, 0.04619002f, -0.01165522f, -0.02498588f, -0.03533672f, 
    -0.04773156f, -0.00664316f, 0.01664537f, -0.00353368f, -0.04815862f, 0.04518827f, -0.04998120f, -0.02097639f, 
    -0.05969147f, -0.03774063f, -0.02850787f, 0.04133276f, 0.03728961f, 0.01256561f, 0.01673285f, -0.03555528f, 
    -0.00643324f, 0.03140185f, -0.03566862f, 0.01558431f, 0.01158902f, -0.03522594f, -0.01219382f, 0.04819483f, 
    0.02309807f, 0.01789410f, -0.05889516f, 0.01509548f, -0.00167933f, -0.04445365f, 0.04158282f, -0.02379915f, 
    -0.02975612f, -0.01872098f, 0.00942345f, 0.01469561f, 0.02876114f, 0.00829130f, 0.05907600f, -0.06198112f, 
    -0.01080977f, -0.05650513f, 0.01750477f, -0.04326636f, 0.02636623f, -0.03429355f, -0.01534426f, -0.01535130f, 
    0.00809480f, 0.01732466f, 0.03647218f, 0.04735698f, -0.02875763f, -0.03490542f, -0.01027139f, 0.00645569f, 
    -0.05614507f, 0.02638621f, -0.01600694f, -0.04266307f, -0.01032710f, -0.03722754f, 0.01170705f, -0.00439570f, 
    -0.02041973f, 0.02265474f, -0.04806972f, 0.02955106f, 0.00872364f, -0.00629070f, -0.05135072f, -0.00081040f, 
    0.00689063f, -0.04277898f, 0.02784475f, 0.01182866f, -0.02940715f, -0.02641121f, -0.05121045f, -0.03258200f, 
    -0.00517419f, -0.04335577f, 0.01117550f, 0.04579592f, -0.05026716f, 0.04901528f, -0.00575449f, 0.04205395f, 
    0.04231310f, 0.04413233f, 0.00762948f, 0.01751310f, 0.03787615f, -0.01240451f, -0.01091762f, -0.02565346f, 
    -0.02617844f, -0.06336742f, -0.05537298f, 0.03609896f, -0.01728168f, 0.04546032f, 0.03956712f, -0.01623533f, 
    -0.05066077f, -0.00559731f, -0.02662730f, -0.01538784f, -0.04814534f, 0.00709824f, -0.01746014f, -0.03247201f, 
    -0.03009820f, 0.00371233f, 0.01589044f, 0.00749769f, 0.01409173f, -0.03579133f, 0.03075696f, -0.05207244f, 
    0.01565645f, 0.00446633f, 0.03087578f, 0.04488590f, -0.01047377f, -0.03879738f, -0.02828098f, -0.04643843f, 
    -0.02989545f, -0.04669188f, 0.02761306f, 0.01793856f, -0.02685628f, 0.04172840f, 0.02726732f, -0.02075352f, 
    0.03160884f, 0.02765681f, 0.04550801f, -0.03572130f, -0.05932127f, -0.03577900f, 0.02322214f, 0.02742544f, 
    -0.05361759f, -0.03989419f, 0.02754165f, 0.01039515f, -0.02449590f, 0.04465925f, -0.04488004f, 0.02545680f, 
    0.04285083f, -0.01601111f, 0.02304964f, -0.00019835f, -0.04254516f, 0.04728152f, -0.05318031f, -0.02170043f, 
    -0.05779156f, 0.04949871f, 0.05490217f, 0.01606964f, 0.02435237f, 0.00291852f, -0.04702033f, -0.03217040f, 
    -0.04075266f, -0.01819276f, -0.00656440f, -0.02382830f, -0.00975454f, -0.00451795f, -0.04867817f, -0.01963411f, 
    0.01135121f, -0.03018514f, 0.02178781f, -0.01675673f, -0.04280341f, -0.04373941f, -0.02592194f, 0.01106078f, 
    0.01176993f, -0.04288658f, 0.02282706f, -0.03573011f, 0.01928249f, 0.03965144f, 0.02604694f, 0.02501004f, 
    -0.04100161f, 0.00065313f, -0.01403127f, -0.04038765f, 0.00527026f, 0.00792560f, 0.01330905f, 0.04973943f, 
    -0.05865186f, -0.01549021f, 0.02314308f, 0.02347566f, -0.02740735f, -0.03108064f, 0.04381442f, 0.03192898f, 
    -0.02618942f, -0.03752903f, 0.00062212f, -0.06530035f, -0.02540204f, -0.02832904f, -0.05419685f, 0.03195599f, 
    -0.06308246f, -0.03322140f, 0.00176171f, -0.02196561f, -0.02401511f, 0.02855565f, -0.04902244f, -0.06342851f, 
    -0.04571221f, 0.01096676f, -0.05840082f, -0.04256979f, -0.02462057f, -0.05695425f, 0.02577288f, -0.03350067f, 
    -0.02944946f, 0.02505052f, -0.05085852f, -0.00382836f, -0.00279317f, -0.02828322f, -0.04425085f, -0.03834265f, 
    0.00135933f, 0.01317943f, -0.02077574f, 0.00187182f, 0.05638992f, -0.01759630f, -0.01435398f, -0.06129633f, 
    -0.00951093f, 0.00258421f, -0.04726854f, 0.04823330f, -0.00859499f, 0.03751408f, 0.01530157f, 0.00602733f, 
    -0.05248760f, -0.01817214f, -0.03237948f, -0.05343057f, 0.04319753f, -0.05252412f, 0.04377822f, -0.01622076f, 
    0.01836699f, -0.04370034f, 0.00832880f, 0.01247202f, -0.05845137f, 0.02800356f, -0.04355941f, 0.04600000f, 
    0.03048259f, -0.04325031f, -0.03429621f, -0.02301391f, 0.01131899f, 0.05224247f, 0.00640324f, -0.02050566f, 
    -0.01737467f, -0.03101111f, 0.04987460f, 0.00498220f, -0.05168654f, -0.02356142f, 0.05611283f, 0.05363079f, 
    -0.02012892f, -0.01981730f, 0.04482215f, -0.03978219f, 0.04386335f, -0.04172016f, -0.03344132f, 0.04902449f, 
    -0.01643715f, 0.17071784f, 0.23144659f, -0.03393504f, -0.02453968f, 0.19838211f, 0.20122077f, 0.08380356f, 
    0.08501809f, 0.10771631f, 0.16674373f, 0.12554048f, -0.04380243f, -0.09542425f, -0.00929010f, 0.10567407f, 
    -0.10348018f, -0.13821246f, -0.06910245f, -0.03300833f, 0.32988787f, -0.04034972f, -0.25645816f, -0.04942876f, 
    -0.02176877f, 0.06140863f, -0.01556267f, 0.11539336f, -0.04508077f, 0.11035569f, -0.01316916f, 0.01679780f, 
    -0.02143036f, 0.01163874f, 0.01440790f, 0.07932551f, 0.08362864f, 0.08885147f, -0.09672046f, -0.04421705f, 
    0.06916398f, -0.12864140f, -0.24329162f, -0.01491587f, 0.15562950f, 0.01880667f, 0.04488894f, 0.02550174f, 
    0.04133642f, -0.01793805f, 0.04448600f, 0.05986618f, 0.06484193f, -0.04092607f, 0.02648051f, 0.05742931f, 
    0.11249626f, 0.01739351f, -0.10034078f, 0.03471616f, -0.22518846f, 0.05796622f, -0.00918055f, 0.18770508f, 
    0.00700032f, 0.00426243f, -0.03467651f, -0.04449802f, -0.20518604f, -0.01847324f, -0.12058385f, 0.04369530f, 
    0.02332900f, 0.09532622f, -0.06151483f, 0.04328230f, 0.04547821f, 0.02486151f, 0.04650040f, 0.10345882f, 
    -0.01664348f, -0.11930922f, -0.11035872f, 0.09851896f, 0.27113372f, -0.14641625f, 0.16505820f, -0.01856766f, 
    0.01804741f, 0.05682343f, -0.10260642f, -0.01574923f, 0.04248282f, 0.11689131f, 0.00622261f, 0.14170676f, 
    0.12889732f, 0.04508574f, 0.15464956f, 0.22824751f, -0.01383005f, -0.07298066f, -0.00464817f, -0.03497984f, 
    0.19891788f, 0.09332819f, 0.10820939f, 0.16897832f, -0.04478785f, 0.09182528f, 0.14382818f, -0.10025370f, 
    -0.10106813f, -0.00166655f, -0.01963826f, -0.00945262f, 0.03474634f, 0.16474171f, 0.02159989f, 0.17251219f, 
    0.07379014f, 0.21050109f, 0.02102349f, 0.09011056f, 0.02251174f, -0.14385477f, 0.00596700f, 0.04327565f, 
    0.31470430f, 0.16453266f, -0.07490908f, -0.01875156f, -0.07348213f, -0.01155795f, 0.01885225f, -0.08005293f, 
    -0.00486773f, 0.04048372f, 0.14801401f, 0.25032803f, -0.25293243f, 0.34787133f, 0.51312804f, 0.30248019f, 
    -0.02388347f, 0.08464907f, -0.02551206f, -0.23417896f, -0.07672874f, -0.03450672f, -0.22861919f, 0.19937168f, 
    0.12015399f, 0.00040775f, 0.00536048f, 0.07899234f, -0.10824579f, -0.01270472f, -0.04798399f, -0.01092597f, 
    -0.26470864f, -0.15859374f, 0.13839847f, 0.16638027f, 0.11963447f, 0.05800693f, -0.06121036f, 0.02795521f, 
    -0.05964558f, 0.06484084f, 0.08323504f, 0.14964628f, -0.13660294f, -0.06480210f, 0.05150600f, -0.00808221f, 
    0.16764911f, -0.04152166f, -0.08099654f, -0.06484599f, -0.28899240f, 0.13986383f, 0.11295769f, 0.17926912f, 
    0.03968804f, -0.04940596f, 0.01371846f, 0.03481563f, -0.03426251f, 0.24343558f, -0.04975233f, 0.03084153f, 
    0.05839625f, 0.06026493f, 0.01111561f, 0.01543740f, -0.05171637f, -0.08592005f, 0.18729265f, 0.15772334f, 
    -0.32979116f, 0.28840062f, 0.45662943f, 0.34985006f, 0.20283696f, 0.06165825f, -0.14735013f, -0.12564145f, 
    0.00605203f, -0.04050737f, 0.04687504f, -0.02188472f, 0.04370013f, 0.05085358f, 0.08112042f, -0.01918527f, 
    -0.08692478f, -0.02999578f, 0.08545335f, 0.02285336f, -0.09032946f, -0.16357969f, -0.17506714f, 0.49674270f, 
    0.05086266f, -0.17832714f, 0.15352099f, 0.21320799f, -0.37324074f, 0.26026511f, 0.05238985f, -0.06285606f, 
    -0.18186410f, 0.03832370f, -0.14938107f, 0.05953344f, -0.15459961f, -0.05743786f, 0.01805299f, 0.15411168f, 
    -0.17819571f, -0.23435047f, 0.22103339f, -0.14038648f, 0.08471018f, -0.10890778f, 0.02347141f, -0.07095952f, 
    0.10392376f, -0.06198307f, 0.02003532f, 0.03913642f, 0.08687694f, -0.04851532f, 0.10927836f, 0.03081321f, 
    -0.03468577f, -0.00155893f, 0.01646904f, 0.13271728f, 0.14995897f, 0.15338771f, -0.13810094f, 0.00953365f, 
    -0.02063018f, 0.18764497f, 0.08106861f, 0.03178132f, -0.05115490f, 0.04254097f, 0.13030283f, -0.00728151f, 
    0.05108205f, 0.07707461f, -0.08077536f, 0.07570456f, -0.15819599f, -0.05519584f, 0.02623074f, -0.26504925f, 
    0.05127421f, -0.04083568f, -0.02804563f, -0.05082995f, 0.35649794f, -0.05895771f, 0.17305909f, 0.19107866f, 
    -0.11895017f, 0.31881770f, 0.04283694f, -0.04874146f, -0.10612178f, -0.07028503f, -0.04585063f, -0.00260110f, 
    0.02317197f, 0.06122448f, 0.02545433f, 0.13396178f, -0.13705432f, 0.54832840f, 0.39382404f, 0.30984005f, 
    -0.17728512f, 0.18133405f, 0.11607937f, -0.24933232f, 0.19053017f, -0.03660591f, -0.20731257f, -0.00878034f, 
    0.13841854f, 0.11368369f, 0.14136994f, -0.02170342f, 0.02680512f, 0.01659890f, -0.00753957f, 0.09396196f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.01145457f, 0.12657253f, 0.12182667f, -0.06967942f, 0.12488297f, -0.04487821f, 0.24256591f, 0.05981989f, 
    0.01702391f, 0.17202094f, -0.03625862f, -0.03370788f, 0.08779204f, -0.00249946f, 0.19739552f, -0.02515209f, 
    0.19709529f, -0.00142178f, -0.03959239f, -0.09765826f, -0.02425632f, -0.07027857f, 0.14671504f, 0.05337135f, 
    0.01489071f, 0.07866216f, -0.01751442f, 0.01240763f, 0.01605100f, 0.06288338f, 0.03528037f, 0.17382576f, 
    -0.02492143f, -0.04430405f, 0.09480447f, -0.05613080f, 0.13407020f, 0.06719323f, -0.04427658f, 0.01145221f, 
    0.00193697f, 0.15079054f, 0.25657272f, 0.04038284f, 0.02531691f, 0.20923957f, 0.10180643f, -0.00986994f, 
    -0.01033194f, -0.01996442f, 0.01255215f, 0.05894760f, 0.01586343f, 0.00630826f, 0.03240256f, -0.00284203f, 
    -0.13038121f, 0.03534777f, -0.01301821f, 0.07736300f, -0.01719015f, -0.04589888f, 0.03457560f, 0.00982408f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.12828280f, -0.20228738f, -0.28140488f, -0.18298475f, -0.37754679f, 0.01950606f, -0.32349753f, 0.21940860f, 
    0.11354293f, -0.51879930f, -0.29110935f, -0.06776074f, -0.03207732f, -0.11144686f, -0.51098198f, 0.13746695f, 
    -0.33147183f, 0.14454159f, 0.02461797f, 0.22554177f, 0.04071076f, 0.20665278f, -0.24398457f, -0.02317869f, 
    0.01655317f, -0.15973526f, 0.28210869f, 0.07296335f, -0.04996244f, -0.13213851f, -0.11136523f, -0.22330077f, 
    -0.18755886f, 0.07347278f, -0.31432182f, 0.10242637f, -0.12137057f, -0.01711932f, 0.12132242f, -0.13294259f, 
    -0.00746147f, 0.35077649f, -0.15408254f, -0.44667134f, -0.10634512f, -0.22608261f, 0.05402403f, 0.05811223f, 
    -0.02377615f, -0.04865102f, 0.03535123f, 0.22569969f, -0.09416719f, 0.04197267f, -0.20439087f, -0.20631953f, 
    0.22363713f, 0.26383886f, -0.03686638f, 0.13574392f, 0.16779080f, -0.35501730f, -0.01173027f, 0.00125142f, 
    -0.23136322f, 0.02739554f, 0.04183378f, -0.14442040f, 0.06999812f, -0.04329063f, 0.14821070f, 0.22921865f, 
    0.06405549f, -0.09165261f, -0.00471159f, -0.62175792f, 0.24122629f, -0.07269403f, 0.10618459f, 0.17011569f, 
    0.32993212f, 0.03834077f, 0.02681356f, -0.12077324f, 0.07130194f, 0.31584418f, -0.06216900f, 0.18120763f, 
    0.01764969f, 0.33788210f, -0.19364847f, 0.00912190f, -0.03914984f, 0.03808753f, -0.07460397f, -0.04264508f, 
    -0.35269341f, -0.04153938f, 0.01500024f, -0.11673438f, 0.04994744f, -0.11497761f, -0.72267425f, -0.06533410f, 
    -0.05886919f, 0.49467257f, 0.50898200f, -0.33391756f, -0.02693662f, 0.02686675f, 0.09014246f, 0.04121692f, 
    -0.05225413f, -0.07130554f, -0.06693164f, -0.12805766f, -0.00265305f, 0.06972585f, -0.18192747f, 0.16303161f, 
    -0.01161230f, 0.30184129f, -0.06819586f, 0.05457041f, -0.32081452f, -0.36962122f, -0.06729212f, -0.07477742f, 
    0.21323556f, 0.13648127f, -0.08741992f, 0.19412830f, 0.10582827f, -0.00962660f, 0.17980361f, -0.55069506f, 
    -0.12014610f, -0.02529013f, -0.34445187f, 0.16136797f, -0.36604047f, 0.09919115f, 0.21927042f, 0.14831224f, 
    -0.32820582f, -0.32036251f, -0.01339432f, -0.35096115f, 0.06318327f, -0.02043084f, 0.05807097f, 0.12874353f, 
    0.09350386f, -0.34917882f, 0.26529720f, -0.01695299f, 0.11028495f, -0.22107424f, 0.06732560f, 0.02407478f, 
    0.00818849f, -0.08449014f, 0.00375193f, -0.00129546f, 0.11871105f, 0.11196490f, -0.29330704f, -0.03351169f, 
    0.07203371f, 0.43650955f, -0.61574584f, -0.34580836f, 0.05971866f, -0.03732086f, 0.19581579f, -0.03275096f, 
    0.01845533f, -0.29133239f, 0.10399795f, 0.15433733f, 0.11094690f, -0.06370632f, 0.11254150f, -0.18650554f, 
    -0.16241093f, -0.23084733f, -0.04505234f, 0.06702870f, -0.40803355f, 0.31918824f, 0.00378082f, 0.04172004f, 
    0.05716934f, 0.10039488f, -0.30629444f, 0.09085539f, 0.23933348f, 0.03736189f, -0.19781099f, 0.00948138f, 
    0.02648507f, -0.06026522f, 0.32963884f, -0.11768764f, -0.21522620f, -0.07045580f, 0.30564234f, 0.03707381f, 
    -0.16243456f, 0.20091245f, -0.08973301f, -0.01406963f, -0.02708475f, 0.17858788f, 0.11991629f, -0.17514329f, 
    -0.08134961f, -0.37675101f, 0.27572083f, 0.04959144f, 0.05329310f, -0.77212429f, -0.06175375f, -0.51189816f, 
    0.06635714f, -0.01601208f, 0.35117072f, -0.04508174f, -0.33850685f, 0.06862979f, 0.32499921f, -0.03734088f, 
    -0.01273653f, -0.33599892f, -0.46182007f, -0.49094737f, -0.10094006f, -0.30333313f, 0.15638508f, 0.03716430f, 
    0.02478052f, -0.21932189f, -0.07007272f, -0.16799271f, -0.02663427f, -0.05246489f, 0.24087608f, 0.27915543f, 
    -0.03298920f, -0.19419993f, -0.09633189f, -0.43682277f, 0.09580401f, 0.29310751f, -0.02163942f, 0.14837763f, 
    0.21208505f, -0.32796347f, -0.06645878f, 0.32818162f, -0.16471192f, -0.04531280f, -0.45367569f, 0.01720752f, 
    -0.11131521f, 0.03468975f, -0.04834100f, 0.13679899f, -0.13260138f, -0.08636527f, -0.26155639f, -0.14187805f, 
    0.14083807f, -0.05235815f, 0.08335984f, 0.06593718f, 0.07792532f, 0.19214889f, -0.21491778f, 0.29421526f, 
    0.01495555f, -0.19285303f, -0.06680361f, -0.08914761f, -0.08226934f, -0.01080807f, 0.08611918f, -0.09457746f, 
    -0.21629116f, -0.05222445f, -0.31763735f, -0.00397897f, -0.07827596f, -0.16033617f, 0.09203698f, 0.12356663f, 
    -0.08438493f, -0.29915467f, -0.28674832f, 0.64514583f, -0.07400248f, -0.05006782f, 0.03299753f, 0.05979986f, 
    0.05875932f, 0.02277544f, -0.02237356f, -0.11003119f, -0.04453193f, -0.12397856f, 0.15901463f, 0.03630379f, 
    -0.04136546f, -0.15976802f, 0.05147238f, 0.17626195f, -0.20927241f, 0.44642121f, -0.12131420f, 0.16606207f, 
    0.33266848f, 0.27570269f, 0.00704342f, -0.20841274f, -0.74565446f, 0.04666404f, 0.12125427f, 0.13903140f, 
    0.10801653f, -0.14139278f, -0.46642792f, 0.30845234f, 0.20911638f, 0.07720973f, -0.00270121f, -0.25246063f, 
    -0.32932469f, 0.10322957f, 0.05024442f, 0.08096508f, -0.05723120f, -0.18829247f, 0.00506758f, -0.12491009f, 
    -0.06815086f, 0.00784928f, 0.06458228f, -0.06461988f, -0.03495284f, 0.36709934f, -0.10698503f, -0.08222614f, 
    0.01144245f, -0.11587797f, -0.01463077f, 0.10710754f, -0.04621244f, 0.03357660f, -0.39756757f, -0.06686285f, 
    0.05909133f, -0.54728895f, -0.00302804f, 0.29346767f, 0.07346283f, 0.19214603f, -0.03605249f, -0.05864689f, 
    -0.12139571f, -0.04140034f, -0.04926203f, -0.69478214f, -0.10509470f, -0.01165329f, 0.16161147f, -0.12969838f, 
    -0.34307742f, 0.06832247f, 0.02848523f, 0.09937101f, 0.26740891f, -0.62561971f, -0.09595171f, -0.00638347f, 
    -0.27063689f, -0.13495973f, 0.02422168f, -0.20186785f, 0.30711910f, 0.01639470f, -0.05836124f, -0.40478212f, 
    -0.07461129f, 0.23883651f, -0.12358678f, 0.03422196f, -0.19950336f, 0.01734166f, -0.01022077f, -0.11046258f, 
    -0.29180393f, -0.46096492f, 0.05946796f, -0.38778070f, -0.06995491f, -0.82183504f, 0.24246565f, -0.25167677f, 
    -0.01639448f, -0.71206033f, -0.41770011f, -0.04805728f, 0.11122999f, -0.26566809f, -0.09141808f, 0.18103333f, 
    0.13697182f, 0.01437862f, -0.00341279f, 0.08545446f, -0.07797500f, 0.21658021f, 0.30906895f, 0.04250319f, 
    -0.08084617f, -0.10833599f, 0.37454748f, -0.08483303f, 0.06559945f, 0.28390121f, -0.20339707f, 0.02911834f, 
    -0.12515545f, -0.50831312f, 0.09570397f, 0.32885408f, 0.08998124f, 0.10854937f, -0.12424042f, -0.28896582f, 
    -0.32642603f, -0.29017675f, 0.03541140f, 0.13700090f, -0.28729910f, -0.13545685f, 0.01423777f, 0.08681031f, 
    0.27803811f, 0.04826624f, 0.07190663f, 0.22016425f, 0.07725571f, 0.08096536f, 0.11363614f, -0.32008237f, 
    0.03164371f, -0.19112198f, 0.11908933f, -0.02467129f, -0.35025293f, 0.00002506f, -0.11867905f, 0.07911754f, 
    -0.35390222f, -0.35284901f, 0.04633299f, 0.07928625f, -0.10641486f, -0.30999887f, -0.35823563f, -0.45054451f, 
    0.00064509f, 0.08135278f, -0.23197699f, 0.04939920f, -0.01014804f, 0.12770958f, 0.11117816f, -0.04547819f, 
    0.13012196f, -0.04962159f, 0.27627277f, 0.08337463f, 0.12959117f, -0.18226387f, 0.09026968f, -0.00060262f, 
    0.03687916f, -0.15535076f, -0.33662662f, -0.04528057f, 0.02790458f, -0.20207058f, -0.47810233f, -0.00215652f, 
    -0.07366391f, 0.23096530f, 0.09047955f, 0.03122401f, 0.00115436f, -0.08584654f, 0.08764914f, 0.19663690f, 
    -0.14912710f, -0.37662035f, -0.03852953f, 0.12546988f, 0.48933911f, 0.15352866f, 0.03573696f, -0.48131493f, 
    -0.70017236f, -0.07414366f, 0.22668982f, 0.31929663f, 0.21425396f, -0.01555089f, 0.18029164f, 0.06422636f, 
    -0.09748320f, -0.04855369f, 0.16507733f, -0.54244190f, 0.14856730f, -0.09701028f, 0.29360092f, -0.22022286f, 
    -0.00759809f, 0.14293046f, -0.02796088f, 0.15149371f, -0.07857407f, -0.34454411f, 0.19418514f, -0.61698848f, 
    -0.06949992f, -0.03866499f, 0.39080653f, 0.04281254f, -0.10041893f, 0.03506001f, -0.07856152f, 0.12547484f, 
    0.12728758f, -0.01509488f, -0.18457390f, -0.10799997f, -0.11257369f, 0.17756955f, -0.36124435f, -0.01899234f, 
    -0.07357937f, 0.14046694f, -0.23393857f, -0.56687665f, -0.12453097f, -0.07214703f, -0.08764159f, 0.02214224f, 
    -0.04384371f, -0.08745535f, -0.03128805f, -0.29482955f, -0.06026136f, -0.06052218f, 0.09696418f, -0.01734526f, 
    -0.20250848f, -0.51496392f, 0.08390503f, -0.33643991f, 0.24843219f, -0.46726802f, -0.08873004f, -0.64882809f, 
    0.27725983f, -0.35332584f, 0.02149512f, -0.47775084f, -0.53167444f, 0.03758827f, -0.35150215f, -0.28220209f, 
    -0.10140476f, 0.13316825f, -0.14468530f, 0.05316822f, 0.29575405f, -0.08736625f, 0.19698855f, -0.04002186f, 
    0.27693954f, -0.19490419f, 0.08759065f, -0.57082665f, 0.11427233f, -0.08775400f, -0.07404253f, -0.12447444f, 
    -0.00178721f, 0.06253267f, -0.51966500f, -0.00996575f, 0.02711714f, 0.14383508f, 0.00702583f, 0.31355101f, 
    0.32445559f, 0.01838982f, 0.27714884f, 0.04090911f, 0.14059192f, -0.02780429f, 0.25655267f, -0.02584947f, 
    0.03819553f, -0.20052968f, -0.28928825f, 0.46413714f, -0.04671298f, -0.26478881f, -0.26209021f, -0.08758024f, 
    -0.13013813f, -0.00181704f, 0.05811189f, 0.08071977f, -0.04108920f, 0.09789761f, -0.38225546f, -0.21533595f, 
    -0.08034256f, 0.20929660f, 0.11059862f, 0.07085964f, 0.24833669f, 0.18554167f, 0.00620618f, 0.19099067f, 
    -0.48599270f, -0.09334171f, -0.38702857f, -0.12554112f, 0.12901904f, -0.09519444f, 0.24030048f, 0.26313490f, 
    -0.05348454f, 0.20169973f, -0.48201594f, -0.10941277f, -0.00290847f, -0.09395874f, 0.10708096f, -0.01864436f, 
    -0.23993045f, 0.01491451f, -0.09642365f, -0.05026395f, -0.11975794f, -0.48075885f, 0.08316958f, 0.19040237f, 
    0.00196840f, -0.25236630f, -0.32507855f, -0.02887397f, 0.04105804f, 0.13910149f, -0.09709994f, 0.21360278f, 
    0.00071909f, 0.00714153f, -0.04493662f, -0.01528274f, -0.60606104f, -0.32144311f, 0.02042018f, -0.04330695f, 
    -0.13166058f, -0.17805775f, -0.33417726f, -0.35778767f, -0.08954567f, 0.17105329f, 0.15139332f, 0.04838840f, 
    0.03422251f, 0.39495492f, 0.05421807f, -0.50128162f, 0.00697712f, 0.10267969f, 0.22971728f, 0.30682722f, 
    0.37046596f, -0.30517760f, 0.11788049f, -0.35863164f, -0.40832317f, -0.20713812f, -0.03130498f, 0.26648021f, 
    -0.48786864f, 0.16384077f, 0.13645221f, -0.28648916f, -0.22635275f, -0.04114306f, 0.11037590f, -0.43583500f, 
    -0.11817163f, 0.23220229f, 0.54247147f, 0.40704641f, 0.24309115f, -0.03015822f, -0.20690371f, -0.25435829f, 
    -0.27678376f, -0.03087464f, 0.02634192f, 0.20210578f, -0.09562042f, -0.15615188f, 0.28771994f, 0.04712103f, 
    -0.01094317f, -0.11825094f, 0.17731902f, 0.10335556f, 0.03196425f, 0.12190809f, -0.08899766f, -0.06211905f, 
    0.02948486f, 0.10923278f, -0.40066633f, 0.09400440f, 0.16439794f, -0.07552075f, -0.42212617f, 0.01323075f, 
    -0.06880926f, 0.16876885f, -0.08966219f, -0.15999354f, -0.05616265f, 0.03455428f, -0.45526528f, -0.07315730f, 
    0.02505291f, 0.12895127f, 0.05575461f, 0.09239270f, 0.11380077f, -0.11983581f, -0.29911515f, 0.11229192f, 
    0.27831048f, 0.10861465f, 0.00549041f, -0.45398781f, -0.60975343f, 0.11858169f, -0.03134315f, 0.08578564f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.12615423f, -0.07247048f, 0.17767060f, -0.12775892f, 0.01634061f, 0.07609159f, 0.04697710f, -0.02953627f, 
    -0.01367479f, 0.01665966f, 0.11491381f, -0.05533270f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
