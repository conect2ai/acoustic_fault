#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.03781366f, 0.20141913f, 0.64079219f, 1.13474786f, 0.34330374f, -0.28176916f, 0.13268629f, 0.31233045f, 
    0.37369481f, -0.29884785f, -0.37591267f, -0.13588001f, -0.06994075f, 0.23211014f, 0.22859636f, -0.21533900f, 
    0.13303497f, 0.01459646f, 0.35292467f, 0.22305211f, 0.04992932f, -0.30242339f, -0.20965961f, -0.05572473f, 
    -0.04264881f, 0.18968752f, 0.31709406f, 0.60456473f, 1.06778908f, 0.07557071f, 0.05306017f, 0.19377950f, 
    -0.21916077f, 0.45493636f, 0.37833226f, -0.08972973f, -0.31555998f, 0.04722507f, -0.13441932f, -0.48794699f, 
    -0.27440780f, -0.13101362f, 0.27867001f, -0.24901941f, -0.32957643f, -0.00339554f, 0.11905561f, -0.30808866f, 
    0.10818379f, -0.19382757f, 0.15138203f, -0.03320945f, 0.07971168f, 0.03082786f, 0.50481170f, -0.60968846f, 
    -0.71672958f, 0.02788008f, -0.26706195f, -0.46622071f, -0.43081388f, -0.05718181f, 0.20330684f, 0.02631581f, 
    0.14571083f, 0.19456019f, 0.05645043f, 0.38136366f, 0.11677816f, 0.26967615f, 0.47880802f, -0.35529184f, 
    -0.24855068f, -0.34152567f, -0.31657100f, -0.29356217f, -0.25444114f, -0.58677471f, -0.33073771f, 0.09657956f, 
    -0.46630162f, -0.10262849f, 0.16225481f, 0.60676664f, -0.58563524f, -0.35897455f, -0.40869156f, -0.34296027f, 
    0.03164304f, -0.23819859f, -0.01577158f, 0.11701015f, -0.41983309f, -0.13840854f, -0.06211914f, 0.12760314f, 
    -0.05866686f, 0.26799357f, 0.08655287f, 0.19801652f, -0.48495194f, -1.25559449f, -0.45886564f, 0.45822045f, 
    -0.05048701f, 0.11067098f, 0.55505019f, -0.41794673f, 0.41670382f, -0.18342946f, 0.35928211f, 0.24453294f, 
    -0.15498464f, 0.30541450f, 0.14687391f, -0.04145673f, 0.12832518f, 0.29254743f, -0.12335837f, 0.15448421f, 
    0.07640064f, 0.01288386f, 0.15644187f, 0.06247172f, -0.05557913f, -0.08301691f, -0.45819417f, -0.21489049f, 
    -0.14275314f, 0.11452585f, -0.41915083f, -0.31553876f, -0.95900971f, -0.48867306f, -0.24531709f, -0.34293890f, 
    0.47896883f, 0.33642074f, 0.19677182f, -0.26891431f, 0.04196503f, -0.49255583f, 0.22612974f, -0.00633699f, 
    -0.13749143f, 0.02902731f, 0.11877206f, -0.07307388f, -0.00934277f, 0.34578577f, 0.18109788f, -0.15304296f, 
    0.45989284f, 0.26550823f, -0.80810410f, -0.33240452f, -0.05843563f, -0.28300974f, -0.46342877f, -0.34483835f, 
    0.19536394f, -0.26505357f, -0.59567851f, -0.21040420f, -0.05374528f, -0.10653720f, 0.22621496f, -0.44448808f, 
    -0.10191528f, -0.46299663f, -0.17747323f, 0.25718582f, 0.21582624f, 0.34053519f, -0.17874910f, 0.07130992f, 
    -0.58991235f, 0.66948467f, 0.29923430f, 0.36223611f, 0.40710124f, 0.07819992f, 0.76491207f, 0.14198387f, 
    -0.36118531f, 0.06028071f, -0.49972239f, -0.29019943f, 0.12056920f, 0.07337218f, 0.22882427f, 0.21992876f, 
    0.04777054f, 0.17426977f, 0.25960490f, 0.15737103f, 0.25780615f, 0.25408021f, -0.10021961f, -0.07342300f, 
    0.52512336f, -0.35871199f, -0.69043583f, -0.51250720f, 0.04510929f, 0.76460397f, 0.79870182f, 0.34406847f, 
    0.12835009f, 0.21721236f, -0.12498132f, 0.40561888f, -0.39526054f, 0.28040621f, 0.24666210f, 0.15323682f, 
    -0.03278971f, -0.28912377f, 0.29785025f, 0.14128883f, -0.10471848f, 0.08824504f, -0.17429858f, -0.16655155f, 
    -0.10314991f, 0.71753907f, 0.31001869f, 0.78276438f, 0.12340330f, 0.57366401f, 0.43634823f, -0.14549758f, 
    -0.50154310f, 0.14876930f, 0.06616893f, 0.15512367f, 0.53831726f, 0.04842329f, 0.11933658f, -0.15823771f, 
    -0.35913759f, -0.08977606f, -0.26532075f, -0.20643955f, -0.00021596f, 0.15476424f, -0.31000090f, -0.19090809f, 
    -0.11878359f, -0.13760610f, 1.20768094f, 0.22470142f, 0.07069638f, 0.38274354f, 0.32704747f, 0.03989596f, 
    -0.09709472f, -0.07936140f, -0.30470851f, 0.04658310f, -0.01685871f, 0.21511461f, 0.01819198f, 0.13764393f, 
    -0.10991794f, 0.17013955f, -0.00648179f, 0.34501180f, 0.20495030f, -0.02836494f, -0.08886786f, 0.25463316f, 
    0.08916774f, -0.06360434f, 0.08742841f, -0.74676013f, -0.64535791f, -0.44697383f, 0.27515352f, 0.19316889f, 
    -0.80335611f, 0.63694292f, 0.65371305f, -0.45787424f, 0.09191133f, 0.03624120f, -0.14456381f, 0.04247254f, 
    -0.20041811f, -0.03570752f, -0.28763753f, 0.09967049f, -0.14883073f, -0.19650964f, -0.38421905f, 0.15242083f, 
    0.18369877f, -0.04490212f, -0.04278145f, -0.06102125f, -1.06197882f, -0.65395975f, 0.29916781f, -0.47184378f, 
    -0.75375986f, 0.57431865f, 0.00861243f, 0.13563398f, -0.09382307f, 0.23617269f, -0.11155165f, -0.20217711f, 
    0.12842311f, 0.23768237f, 0.20496503f, -0.05222236f, 0.14040785f, -0.08088463f, -0.21682374f, 0.08899818f, 
    -0.02723284f, -0.02548102f, 0.18159255f, -0.01903021f, 0.04731352f, -0.99318492f, 1.19949496f, 0.31258976f, 
    -0.77675974f, -0.21184331f, 0.48181427f, 0.67882293f, 0.06905882f, 0.30251256f, 0.08075788f, -0.11583213f, 
    0.26740590f, -0.09029295f, -0.32458431f, -0.27504060f, 0.02168720f, 0.02637752f, -0.03398869f, -0.03979519f, 
    -0.32091403f, -0.10617762f, -0.10018776f, 0.02621478f, -0.09037478f, 0.04853390f, 0.77981240f, 0.56689787f, 
    0.52826005f, 0.26302245f, 0.61323881f, 0.19768414f, -0.63298142f, -0.31833375f, -0.23134431f, -0.30523241f, 
    0.12680808f, 0.01791065f, -0.03676876f, 0.03781053f, 0.16647570f, 0.28265837f, 0.01772896f, -0.08870026f, 
    -0.06957646f, 0.31302762f, 0.20812674f, 0.28213382f, -0.04911032f, -0.09449692f, 0.42418921f, -0.79450583f, 
    -0.27292302f, -0.68943864f, -0.55276066f, -0.20258875f, -0.02563245f, -0.65625381f, -0.25332001f, 0.37346292f, 
    0.07901712f, -0.07262137f, 0.01069713f, 0.29469725f, 0.26167831f, 0.07246742f, 0.25162765f, 0.14905073f, 
    0.32126480f, 0.06253316f, -0.04750168f, -0.06883144f, 0.04957065f, 0.26953763f, -0.34626287f, -0.14565818f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.04538651f, 0.10183716f, 0.03930782f, 0.02713391f, 0.47728682f, 0.12061828f, 0.21994551f, 0.15476529f, 
    0.25095251f, 0.11640441f, 0.02114810f, 0.26805273f, 0.11705464f, -0.00047561f, 0.22295514f, 0.13640441f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.27806228f, 0.21827805f, -0.20987161f, 0.25133792f, -0.08461501f, 0.04477141f, -0.01942134f, -0.01272152f, 
    0.17241514f, -0.02706774f, 0.09878686f, 0.14887606f, -0.08825891f, 0.18325505f, -0.02641996f, 0.07094786f, 
    0.02524763f, 0.06389181f, -0.00160603f, -0.12406661f, -0.16175497f, 0.08010598f, -0.05021695f, 0.01098481f, 
    0.18903670f, 0.21601360f, 0.09616529f, -0.07961318f, -0.19167794f, -0.13634086f, 0.12524818f, -0.08113774f, 
    0.04504842f, 0.22783926f, -0.01017649f, 0.26166770f, -0.10772428f, 0.23005827f, 0.09839078f, -0.09745254f, 
    0.09495986f, 0.11410095f, 0.15579504f, 0.02882750f, 0.06062536f, 0.12824824f, -0.03523671f, -0.15857418f, 
    0.14938094f, -0.32593653f, -0.14008622f, -0.01463362f, 0.17647777f, 0.08297204f, 0.04633069f, 0.06677439f, 
    0.05945596f, -0.08430978f, 0.01655771f, -0.03083288f, 0.24346781f, -0.06757583f, 0.00564789f, -0.02107008f, 
    -0.09880235f, 0.04366140f, 0.00414810f, 0.08056926f, -0.03464569f, 0.14323252f, 0.02646821f, -0.04995123f, 
    -0.02456669f, 0.39187926f, -0.18545330f, 0.27877393f, 0.12113016f, 0.13882309f, -0.03340446f, -0.21020614f, 
    -0.14279304f, 0.10533410f, 0.09199694f, -0.00360428f, -0.09642124f, 0.27996081f, 0.24232896f, 0.18446995f, 
    0.15435928f, 0.01650507f, 0.06416515f, -0.00972927f, 0.15296407f, -0.07597230f, -0.00331410f, 0.15253781f, 
    0.18195598f, -0.16904761f, 0.06587864f, -0.36878106f, 0.09554230f, -0.01648797f, -0.03323612f, 0.11717124f, 
    -0.00609375f, -0.04378774f, -0.01046061f, 0.01293412f, -0.00844507f, 0.19013374f, 0.30431393f, -0.11672468f, 
    -0.28883842f, -0.05218222f, 0.06641342f, -0.00289438f, -0.02201550f, 0.04431281f, 0.00185492f, -0.13358003f, 
    0.22891003f, 0.22187611f, 0.00159684f, -0.13978054f, -0.02500126f, -0.12514001f, 0.02886338f, 0.03947438f, 
    0.07888227f, 0.19439322f, 0.04160650f, 0.14440200f, 0.04451717f, 0.38292912f, -0.32274464f, 0.06996696f, 
    0.09302592f, 0.02385679f, -0.20783883f, 0.10056587f, -0.03964816f, 0.00868557f, 0.08279711f, -0.14652286f, 
    -0.36307240f, 0.01962700f, -0.21086439f, -0.10575677f, -0.09030518f, 0.10367394f, -0.16070360f, -0.05196628f, 
    0.05536353f, -0.00877852f, 0.00706946f, -0.12869550f, 0.09767271f, -0.64007801f, -0.08099524f, -0.18966636f, 
    -0.11245400f, 0.02436966f, -0.10215780f, -0.06556648f, -0.21254244f, 0.00816184f, 0.02830492f, -0.05343179f, 
    0.30307418f, 0.23609494f, 0.20159143f, -0.30735990f, -0.08261384f, -0.08210047f, 0.08529714f, -0.09116123f, 
    -0.07497565f, 0.00290320f, 0.15948190f, 0.22273113f, -0.18766600f, -0.28443047f, -0.09938016f, -0.27151564f, 
    0.13229208f, 0.10214306f, 0.02405563f, 0.03237480f, -0.02307982f, 0.00076091f, -0.00966043f, 0.01049605f, 
    -0.17759457f, -0.10118733f, -0.27163753f, 0.21241651f, -0.17021589f, 0.03430368f, -0.14020239f, -0.00535587f, 
    -0.03056112f, -0.09176075f, 0.03926700f, 0.07227927f, 0.03094867f, -0.13310611f, -0.08547233f, 0.21417579f, 
    -0.04673397f, 0.12145013f, 0.12178934f, 0.06752407f, 0.07226416f, -0.08317590f, 0.02075441f, -0.09683412f, 
    -0.12805568f, 0.16897725f, 0.03220347f, -0.02377591f, 0.14766280f, 0.08060164f, -0.01431383f, 0.04108257f, 
    -0.07438877f, 0.05797007f, -0.07829304f, 0.19141935f, -0.03922387f, -0.26150844f, 0.03659584f, -0.08066088f, 
    -0.05199714f, -0.00199672f, 0.14564715f, 0.03097993f, 0.01314497f, -0.12482665f, -0.06972729f, 0.16885899f, 
    0.56786549f, -0.28556320f, -0.15114540f, 0.02630522f, -0.03684333f, 0.10614814f, 0.08511616f, 0.16716678f, 
    -0.02343991f, -0.11149704f, 0.02295430f, 0.13776225f, 0.31210104f, 0.11421835f, -0.06745876f, -0.11146933f, 
    0.07205612f, 0.10996176f, -0.05717486f, 0.06604581f, 0.03099289f, -0.08903310f, 0.00841600f, -0.13091850f, 
    -0.50229967f, -0.01348371f, -0.07493806f, -0.08230604f, 0.11767890f, 0.06829316f, 0.16172791f, 0.05160434f, 
    0.07824054f, 0.06610986f, 0.10814784f, 0.18143383f, -0.60344243f, -0.00465888f, -0.06805667f, 0.08432515f, 
    -0.25167158f, 0.08435278f, -0.03751398f, 0.04146699f, -0.02770322f, 0.21714118f, 0.13790272f, -0.03816626f, 
    0.36423171f, 0.04409846f, 0.17240447f, -0.09195455f, -0.08265857f, -0.08042244f, 0.06800880f, 0.18024194f, 
    -0.01173881f, 0.06649630f, -0.02291950f, -0.06295168f, -0.14405452f, -0.14415011f, 0.05105452f, 0.10206801f, 
    0.07627036f, -0.01286610f, -0.03250150f, -0.03503291f, 0.18463916f, 0.00210001f, -0.07665910f, -0.03281774f, 
    -0.22183819f, -0.47520697f, 0.27603954f, 0.15130621f, 0.10608584f, -0.07271609f, -0.08720642f, -0.06051430f, 
    -0.06793309f, 0.07302023f, 0.05198897f, -0.09465814f, 0.58751291f, -0.00633817f, -0.05514938f, 0.11940865f, 
    -0.13636917f, 0.06891026f, 0.00332329f, 0.10018211f, -0.04349506f, 0.03875200f, -0.01741504f, 0.14512604f, 
    0.40777203f, 0.33054277f, 0.22695380f, -0.09378707f, -0.19280945f, -0.10003410f, -0.01050004f, 0.13009325f, 
    -0.01979540f, 0.03733269f, 0.03135418f, 0.06249496f, -0.14437610f, 0.58504963f, -0.42618302f, -0.32454398f, 
    -0.25448510f, -0.05174951f, -0.00699643f, 0.17403634f, 0.01635081f, 0.04001447f, 0.04405088f, -0.08500409f, 
    -0.18637688f, 0.02269901f, -0.00646026f, 0.27787808f, 0.10884964f, 0.00528693f, 0.05129826f, -0.08251189f, 
    0.08605761f, 0.09636915f, 0.08423463f, 0.05889447f, -0.00283211f, 0.46566850f, -0.11929771f, -0.27097505f, 
    -0.03571163f, -0.13955717f, 0.09597814f, 0.07643722f, -0.00506204f, 0.07848759f, 0.04638795f, 0.03648753f, 
    0.34292337f, 0.09193092f, -0.43153033f, 0.37782851f, -0.10802232f, 0.16507669f, -0.10425520f, -0.04973465f, 
    -0.11899548f, 0.06641144f, 0.04877003f, 0.12338872f, 0.11031831f, 0.10472156f, -0.29280251f, 0.48096019f, 
    -0.19760953f, 0.12092768f, 0.00472934f, -0.05966200f, 0.08272047f, -0.01954044f, -0.07946682f, -0.12758179f, 
    -0.20986073f, -0.09720419f, -0.12812963f, 0.07515160f, 0.06866594f, 0.10562246f, -0.12078721f, -0.02607081f, 
    0.00657178f, -0.18031999f, -0.21850818f, 0.04019311f, 0.02320103f, 0.35717484f, -0.00856025f, -0.42165434f, 
    0.11440673f, 0.14400530f, 0.15891959f, 0.04757457f, -0.01805674f, -0.01470053f, -0.03816114f, -0.00269876f, 
    0.09165403f, 0.06288280f, -0.13411693f, -0.07118840f, 0.12546772f, 0.05186344f, -0.01102262f, 0.03359692f, 
    -0.10253029f, -0.06258311f, 0.12208821f, 0.01763680f, -0.43084812f, -0.25501123f, 0.34595588f, -0.05773094f, 
    0.00690242f, -0.10558601f, -0.02513457f, 0.11495833f, -0.03293796f, -0.01937463f, -0.18659729f, -0.02592297f, 
    -0.08311065f, -0.22612597f, -0.35690472f, 0.09455952f, 0.11842187f, 0.00382892f, -0.05465487f, -0.12850808f, 
    -0.03611927f, 0.02329955f, -0.18705702f, 0.13249566f, -0.45323539f, 0.09503426f, 0.08009243f, 0.18418412f, 
    -0.10721084f, 0.10433058f, 0.07495332f, -0.02958968f, 0.15590534f, 0.04378411f, -0.00600800f, -0.15734912f, 
    0.40301418f, -0.22761980f, 0.01926002f, -0.36002824f, -0.01073591f, 0.09472644f, 0.05477446f, -0.25589439f, 
    -0.11798335f, 0.01518431f, 0.01714189f, -0.02991986f, 0.41962808f, -0.05510955f, 0.14601912f, 0.35554406f, 
    -0.07054504f, -0.08339726f, 0.03684850f, 0.08949279f, 0.03052944f, 0.14735635f, -0.11500362f, -0.15365864f, 
    0.76162893f, -0.14224951f, 0.05465242f, 0.22684178f, 0.02824203f, -0.13333870f, -0.05480104f, 0.12824143f, 
    -0.02650952f, 0.04511696f, -0.15539618f, 0.06454951f, -0.23094386f, 0.49267018f, -0.09820095f, 0.09216194f, 
    -0.01470198f, 0.13251193f, -0.08781943f, -0.15619311f, -0.00850024f, -0.08243956f, 0.07410457f, -0.08982356f, 
    -0.09128592f, 0.21381307f, 0.36203137f, 0.30696094f, 0.07294095f, 0.19335201f, -0.04583215f, 0.01771276f, 
    -0.02564672f, 0.04844743f, -0.05055900f, -0.01444790f, 0.00720002f, 0.47339776f, 0.08582753f, -0.14512520f, 
    0.00421207f, 0.15239412f, 0.10289522f, -0.19413817f, 0.07288156f, -0.15787138f, 0.16592610f, -0.12776068f, 
    0.42631775f, -0.13445647f, 0.05585634f, 0.18322854f, -0.04964358f, -0.01630299f, -0.02766954f, -0.08375739f, 
    -0.01921255f, 0.05896036f, 0.10998017f, 0.10383499f, 0.21208285f, 0.28464958f, 0.18308853f, -0.13695465f, 
    0.10516717f, -0.01095292f, 0.23185258f, 0.01644076f, 0.08810785f, 0.01900115f, 0.12478518f, 0.00656904f, 
    -0.01840278f, -0.02283928f, 0.01495423f, -0.08608354f, 0.00224172f, -0.02689921f, -0.07424979f, 0.01391073f, 
    0.01329509f, 0.03142953f, 0.00642414f, 0.01007802f, 0.01739156f, -0.08537339f, 0.06321404f, -0.05489243f, 
    0.01204879f, -0.02913515f, 0.01199974f, 0.00436679f, 0.00541291f, -0.02646970f, 0.00417839f, 0.00630099f, 
    0.02207552f, -0.07840101f, -0.02259654f, -0.01092621f, -0.06234326f, -0.08115374f, -0.00368582f, -0.05015801f, 
    -0.04825493f, -0.05737505f, -0.04937001f, -0.01560037f, 0.05919477f, 0.00844928f, -0.03378107f, 0.01778328f, 
    0.01242982f, 0.02072429f, 0.02320269f, 0.00170525f, 0.01890762f, -0.07330655f, -0.06814306f, 0.05521888f, 
    -0.01451372f, 0.05222679f, -0.01802812f, 0.02759260f, -0.04669710f, 0.03741890f, 0.00350526f, -0.00360811f, 
    0.02682260f, -0.05086642f, -0.04389032f, -0.01033555f, -0.05376568f, 0.03041219f, 0.00503757f, -0.07864626f, 
    -0.01925429f, 0.01066065f, 0.00354928f, -0.03133254f, -0.01607737f, -0.01264626f, -0.01548686f, -0.00517225f, 
    0.04310353f, -0.03894599f, 0.04982339f, 0.01995861f, 0.04827389f, -0.03389971f, -0.03815752f, -0.02442427f, 
    0.03169086f, 0.00224625f, -0.01608112f, -0.04610869f, 0.03060286f, -0.01852117f, 0.01731570f, 0.01978632f, 
    -0.02879347f, 0.02958763f, -0.02244618f, -0.01817156f, -0.05600752f, 0.06088433f, 0.05822380f, -0.04677333f, 
    -0.06285018f, -0.00013369f, -0.07449418f, -0.02378235f, -0.01515716f, 0.02085320f, -0.03423688f, 0.02318856f, 
    0.03894854f, 0.06286489f, -0.05807753f, 0.02101826f, -0.04909562f, -0.03700803f, -0.00638742f, -0.00124993f, 
    -0.05067923f, 0.04505246f, 0.02553687f, 0.03296781f, 0.02655083f, 0.00363955f, -0.01550521f, -0.02111776f, 
    -0.06055673f, 0.05884504f, 0.03406971f, 0.03853032f, -0.02947194f, -0.07200631f, -0.04132020f, -0.06413531f, 
    -0.06541152f, 0.03207221f, -0.03790587f, 0.00549538f, 0.02137087f, -0.03781233f, -0.07602723f, 0.02922065f, 
    -0.00180961f, 0.03191936f, -0.07243277f, -0.06666388f, 0.01235916f, -0.06598625f, 0.03931998f, -0.02955052f, 
    -0.03699622f, -0.07488266f, -0.06331079f, -0.03032423f, 0.02654736f, 0.02981358f, -0.00304867f, -0.00310154f, 
    -0.04523095f, 0.00570506f, -0.02474725f, -0.03107743f, -0.04648614f, -0.07047617f, -0.01882488f, 0.00691359f, 
    0.03499666f, -0.08330683f, -0.01689484f, -0.00008312f, -0.03438168f, -0.02619024f, -0.01776860f, -0.04391038f, 
    -0.09327494f, -0.00754302f, -0.00024607f, 0.05118324f, 0.03069404f, -0.07218669f, -0.00183594f, -0.05996356f, 
    -0.00650706f, 0.02999371f, 0.00189987f, 0.05305406f, -0.07588172f, 0.04342346f, 0.01360704f, 0.02315762f, 
    -0.01880994f, -0.06234381f, 0.01593746f, -0.07353789f, -0.07212134f, -0.06396085f, -0.03262817f, -0.00780861f, 
    -0.05229331f, 0.01450182f, 0.02380390f, -0.01963656f, -0.01723367f, 0.00020791f, -0.02496968f, -0.08238848f, 
    -0.05679779f, -0.01301045f, -0.04776474f, 0.04406913f, -0.01465099f, 0.03880022f, -0.05903782f, -0.02762116f, 
    -0.07558408f, -0.04571052f, -0.07320541f, -0.06582478f, 0.03813908f, -0.08708473f, 0.05442929f, 0.02303215f, 
    0.00310602f, 0.00755617f, 0.00243977f, 0.00732940f, -0.04266453f, -0.01837913f, -0.07131403f, -0.05456196f, 
    -0.07042202f, 0.00522555f, -0.02975204f, -0.00256612f, -0.00534810f, -0.02348138f, -0.05152962f, 0.00114789f, 
    0.01558075f, -0.01284935f, 0.00735218f, -0.04501024f, 0.06160489f, -0.02096623f, 0.03841422f, 0.03913492f, 
    -0.07344721f, -0.05143717f, 0.05584504f, 0.04007934f, -0.03715359f, 0.01127491f, -0.00750803f, -0.02045850f, 
    0.04203524f, -0.06154542f, 0.03855459f, 0.01266167f, -0.02726642f, 0.00183063f, 0.01858240f, 0.04043186f, 
    -0.05718375f, 0.00262860f, -0.03489359f, -0.02467538f, -0.01153607f, -0.08953435f, -0.04787861f, -0.04015635f, 
    -0.03497404f, 0.00299902f, -0.07619130f, -0.01485103f, -0.00344831f, -0.04768150f, 0.04873870f, 0.04602261f, 
    0.02520714f, -0.04056461f, 0.05614720f, 0.00439969f, -0.03311222f, -0.01409624f, 0.04518403f, -0.07992995f, 
    -0.07579821f, -0.01029607f, -0.01044475f, 0.01366421f, -0.02092587f, 0.06129472f, -0.01643097f, -0.02840295f, 
    0.03887003f, -0.00973271f, 0.05374498f, -0.07701636f, -0.04362611f, -0.02539105f, -0.08609823f, 0.05576249f, 
    0.01685346f, 0.04898101f, -0.04429401f, 0.01945658f, 0.01529658f, 0.04231129f, -0.01935159f, 0.02320748f, 
    -0.02747342f, 0.06074135f, -0.05051905f, -0.07879643f, 0.00782144f, -0.03375537f, 0.00042814f, 0.00200224f, 
    -0.04842936f, -0.04961663f, 0.00723677f, -0.09995142f, -0.06036136f, 0.06176833f, -0.08914886f, -0.02986269f, 
    -0.06076012f, 0.02645123f, 0.02516845f, -0.02170440f, -0.03314703f, -0.02304685f, 0.02245925f, 0.03669859f, 
    0.05257018f, -0.05438560f, -0.08549380f, 0.01683026f, -0.02791879f, -0.01875367f, -0.08101854f, -0.02691513f, 
    0.04268292f, -0.04022163f, -0.06146904f, -0.06267341f, -0.08247829f, -0.08626302f, -0.00349491f, -0.07234834f, 
    0.03647311f, -0.04598901f, 0.03469580f, -0.01756217f, -0.03342659f, -0.07405784f, 0.05409208f, -0.06029589f, 
    0.06467267f, -0.07988573f, 0.00990841f, 0.02397759f, 0.03605410f, -0.05931927f, 0.02111080f, -0.03979495f, 
    -0.07795828f, -0.04914700f, -0.04212860f, 0.00367829f, -0.05762277f, 0.04575115f, -0.03399615f, -0.07757417f, 
    -0.05464390f, 0.02483638f, -0.08949702f, 0.01458983f, 0.00895307f, -0.06930169f, -0.07352129f, -0.02192389f, 
    -0.01018379f, -0.01317786f, 0.05905619f, -0.00032620f, 0.01677528f, -0.01004553f, -0.04479779f, -0.06633801f, 
    0.02298551f, -0.00934998f, -0.00907804f, -0.03552500f, 0.05487909f, -0.06091659f, 0.02037757f, -0.06396853f, 
    -0.00424036f, -0.05058482f, 0.03413979f, 0.01192731f, -0.01148560f, 0.04332621f, -0.04271741f, 0.00098118f, 
    -0.04377398f, 0.04425740f, -0.06629269f, -0.04917384f, -0.03989653f, -0.00086012f, 0.04425639f, -0.01803638f, 
    -0.06659961f, -0.00233833f, -0.06430472f, -0.01475123f, -0.00074503f, -0.01976299f, -0.05244076f, 0.04334712f, 
    -0.05367067f, 0.03745144f, 0.01021550f, 0.02440311f, 0.00186559f, -0.04405854f, 0.00211049f, 0.02034008f, 
    -0.05529230f, 0.05337163f, 0.02817980f, 0.02858075f, 0.05950310f, 0.01418611f, -0.05634703f, -0.07499983f, 
    0.01130771f, -0.00001247f, -0.04668759f, 0.02521289f, -0.01958749f, -0.03884023f, 0.03741749f, -0.00650872f, 
    0.02078746f, -0.04928888f, -0.05936472f, -0.01975737f, 0.00981483f, -0.04829624f, -0.06662244f, 0.01364329f, 
    -0.03918715f, -0.03419767f, -0.05085789f, -0.04901462f, 0.05580219f, 0.03871751f, 0.04012758f, 0.04676030f, 
    0.04116090f, -0.04322758f, -0.06080850f, 0.01429791f, 0.00458160f, -0.07107403f, -0.07095831f, -0.05275709f, 
    0.03723191f, -0.01447425f, -0.01154402f, -0.08199549f, 0.01320656f, -0.04284000f, -0.05530954f, 0.03733290f, 
    -0.04514885f, 0.04266857f, -0.04685636f, -0.07113644f, 0.05132579f, 0.02942119f, -0.01102831f, -0.07299573f, 
    -0.02064181f, -0.01725218f, 0.01162135f, -0.07093430f, -0.02744916f, 0.03978879f, 0.02400256f, -0.04981457f, 
    -0.07600935f, 0.04258456f, -0.02938459f, -0.02259518f, 0.05517134f, -0.04223195f, -0.07171531f, -0.05488784f, 
    0.03443632f, 0.00395053f, -0.07901818f, -0.04987651f, -0.03326080f, -0.04671953f, 0.01020717f, -0.07707823f, 
    0.00058058f, 0.04712797f, 0.00517559f, 0.01767708f, -0.03278674f, 0.00298444f, 0.05222805f, -0.03976093f, 
    -0.06324606f, 0.01539894f, 0.02325254f, 0.01635500f, -0.05552610f, -0.04607201f, 0.05021042f, -0.04480791f, 
    -0.04132165f, -0.03097296f, -0.04195558f, 0.04962647f, -0.04606937f, 0.05096502f, -0.00402009f, 0.04544731f, 
    -0.04415611f, 0.00572351f, -0.01387350f, -0.01209110f, -0.01206671f, 0.02188880f, 0.05159357f, -0.04242377f, 
    0.04518766f, 0.05754631f, 0.01704421f, 0.00177565f, 0.06145874f, 0.00456138f, -0.00368094f, 0.01890727f, 
    0.03515105f, 0.02358969f, -0.06232393f, -0.02868284f, -0.03711154f, 0.01313195f, 0.05517529f, -0.07731491f, 
    0.00744247f, 0.01424165f, -0.04652786f, -0.02121799f, 0.01550535f, -0.01168930f, 0.02224201f, 0.01553413f, 
    -0.02095158f, -0.02429551f, 0.00272205f, -0.02235107f, -0.02036172f, 0.01135805f, 0.04474742f, 0.01491814f, 
    0.04607754f, 0.00526543f, 0.04441312f, -0.03204808f, 0.02879429f, -0.03601004f, 0.02521538f, -0.06214404f, 
    0.12620166f, 0.04470053f, -0.32705057f, 0.28953898f, -0.10242952f, -0.03363077f, -0.01476206f, -0.01359233f, 
    0.24638440f, -0.18039425f, 0.14148477f, -0.02101074f, -0.05890578f, 0.17621408f, -0.17202266f, 0.13664986f, 
    0.16316211f, -0.02101807f, -0.06196921f, -0.19449441f, -0.05245119f, 0.20712763f, -0.02851973f, 0.05994424f, 
    -0.18126717f, 0.01272391f, -0.17296338f, 0.01534906f, -0.13399668f, 0.09150634f, 0.03634442f, -0.07439240f, 
    0.01084266f, 0.00590388f, -0.04754361f, 0.06316103f, -0.56670219f, 0.10544479f, -0.02007295f, 0.14261104f, 
    -0.11639523f, 0.03759648f, -0.12137683f, 0.25298575f, 0.02564552f, -0.11099514f, 0.20980626f, 0.01839487f, 
    0.05909097f, -0.36245522f, -0.31469059f, 0.16487293f, -0.00900645f, 0.06118784f, 0.07288633f, 0.12711523f, 
    0.02038060f, -0.12194079f, -0.14529166f, -0.05559873f, -0.27767599f, -0.20581816f, -0.18056349f, 0.10744482f, 
    -0.15804736f, -0.10681175f, -0.02076549f, -0.01461332f, 0.03836681f, 0.19103988f, -0.25470483f, 0.09843612f, 
    0.02244177f, 0.03686925f, -0.22481909f, 0.08487603f, 0.02479785f, -0.07960012f, -0.08081628f, -0.21108213f, 
    -0.15562478f, 0.00592528f, 0.31305358f, 0.19555555f, 0.41016734f, 0.15331157f, 0.08516406f, 0.01616403f, 
    0.08095785f, 0.08970416f, 0.03246435f, -0.02956050f, 0.06273613f, 0.02426121f, 0.11254156f, 0.16864662f, 
    0.29251859f, 0.02151607f, 0.06099698f, -0.14543803f, 0.10413568f, 0.02093472f, 0.10325338f, 0.07955188f, 
    0.21759589f, -0.05205511f, 0.02038154f, -0.05956058f, 0.02959016f, 0.11893015f, 0.13954973f, -0.21489854f, 
    -0.02642503f, 0.12166955f, 0.12104014f, -0.06615584f, -0.07539291f, 0.02223090f, 0.13595976f, 0.06452617f, 
    0.16991220f, 0.34540012f, -0.27106339f, -0.00335883f, 0.14447159f, -0.14282145f, 0.06583252f, 0.02405720f, 
    0.01121684f, 0.12253454f, -0.09450395f, 0.11270035f, 0.06671751f, 0.00404139f, -0.29844573f, 0.17842446f, 
    -0.10165183f, -0.07574282f, -0.08438471f, 0.05818821f, 0.05533107f, 0.13478686f, 0.05352020f, 0.02800379f, 
    0.04737587f, 0.09454670f, 0.04119578f, -0.39315975f, 0.03252221f, 0.04294451f, -0.04163355f, -0.05221879f, 
    0.07371126f, 0.00974928f, -0.03173627f, 0.04725207f, 0.40619400f, -0.36881769f, 0.16294871f, -0.44989511f, 
    -0.02275080f, 0.09680013f, -0.16687655f, 0.03563819f, -0.03908438f, -0.00525270f, 0.03584455f, -0.01432514f, 
    0.15620929f, 0.10824365f, 0.10506455f, -0.34772280f, 0.19866824f, -0.04809355f, 0.02130897f, 0.01077035f, 
    -0.01705223f, 0.01321592f, 0.16066609f, 0.15871586f, -0.26398590f, -0.34666073f, -0.22397165f, 0.07434260f, 
    0.15120637f, -0.04383001f, -0.00189883f, 0.12853889f, -0.06570747f, -0.02509800f, -0.13440625f, -0.05125929f, 
    -0.10668433f, -0.08062469f, 0.09996466f, -0.01430075f, 0.02819765f, -0.01285357f, 0.03537142f, -0.10520347f, 
    0.11071111f, -0.10426234f, 0.02336679f, -0.05684125f, -0.02188073f, -0.09869672f, 0.18708016f, -0.28754151f, 
    0.13972679f, 0.05902972f, 0.00369532f, -0.13154830f, -0.08945203f, 0.18764101f, -0.06437362f, 0.05151533f, 
    -0.03335373f, 0.03582488f, -0.07147738f, 0.01027477f, 0.05016635f, 0.07586671f, 0.07189042f, 0.01024757f, 
    0.01606528f, 0.01103473f, -0.15089858f, 0.01964035f, -0.07598916f, 0.01884677f, 0.26948512f, 0.23069212f, 
    -0.15998133f, -0.15925933f, -0.15064596f, 0.11888148f, -0.09751464f, -0.04920629f, 0.13580300f, 0.04145221f, 
    0.51274878f, -0.24785055f, 0.29031053f, 0.06202737f, -0.13176420f, 0.04453675f, 0.09680828f, 0.03928677f, 
    0.02801747f, 0.05114073f, -0.07091847f, 0.07898389f, 0.07337499f, 0.10446789f, -0.26481649f, -0.22468737f, 
    -0.01506934f, 0.08921552f, 0.03342476f, -0.13665655f, 0.23972152f, 0.02933985f, -0.18986936f, -0.14963050f, 
    0.13617507f, -0.01082911f, -0.10203832f, -0.07481641f, -0.00226894f, -0.20593157f, -0.03330067f, -0.05943457f, 
    0.04314585f, 0.02556809f, 0.32016698f, 0.21830434f, 0.34242329f, -0.12413859f, 0.03339162f, -0.16642807f, 
    -0.04435677f, 0.01626805f, -0.14665358f, -0.02226806f, -0.19382627f, -0.01329448f, 0.06867465f, -0.06115546f, 
    0.19242477f, 0.25682363f, 0.17986314f, 0.23397847f, -0.07041070f, -0.04879319f, 0.07947839f, 0.09197475f, 
    -0.01272646f, -0.11166653f, 0.07268678f, -0.07554515f, -0.04582612f, 0.19361235f, -0.13173139f, -0.02609186f, 
    0.13122444f, 0.06919495f, -0.03320792f, -0.09181380f, 0.04576008f, -0.03261153f, 0.11433134f, -0.00046279f, 
    -0.47727069f, 0.10262942f, -0.20132893f, -0.08572143f, 0.25393412f, 0.08579548f, 0.01625433f, -0.06400285f, 
    -0.05739471f, 0.06231186f, -0.15246008f, -0.08037145f, 0.83060205f, -0.40454441f, 0.35870659f, 0.20692134f, 
    -0.04527070f, 0.02005373f, 0.06663316f, 0.07401936f, -0.01932470f, 0.14468792f, 0.07572073f, 0.09506767f, 
    0.53825670f, 0.49960086f, 0.29021272f, 0.17802846f, 0.10204570f, -0.12497327f, 0.13368434f, -0.03435335f, 
    -0.01178300f, 0.07230190f, 0.08787946f, 0.06209910f, 0.21725404f, 0.15842210f, -0.01465058f, -0.01426728f, 
    0.02568804f, 0.04973990f, -0.02081913f, 0.09601855f, -0.04667956f, 0.11425995f, 0.12109438f, 0.07091108f, 
    -0.41386372f, 0.14569291f, -0.20697793f, -0.06359943f, 0.10726105f, -0.09228514f, -0.02083962f, -0.01639507f, 
    -0.02481304f, -0.08063181f, -0.06636764f, -0.19117922f, -0.14084372f, 0.31462741f, 0.02048170f, 0.11295226f, 
    -0.01546810f, 0.02484222f, 0.07635133f, 0.12398472f, 0.14377028f, -0.05955807f, 0.03102438f, -0.11004958f, 
    0.00185254f, 0.01413924f, 0.05626206f, 0.03691446f, 0.00582390f, -0.01687291f, 0.04753210f, 0.02085785f, 
    -0.05525551f, 0.00786884f, 0.05585029f, -0.06267622f, -0.02679045f, -0.01500591f, 0.01870088f, -0.02563506f, 
    -0.02890425f, -0.07289488f, 0.05591165f, 0.03518380f, -0.03277864f, 0.04574633f, -0.06226548f, -0.05485459f, 
    -0.06235113f, -0.06889260f, -0.05033557f, 0.00317642f, -0.05513201f, 0.00576258f, 0.01008289f, -0.04519348f, 
    0.03363239f, 0.03121687f, -0.03233632f, -0.05180222f, -0.01078437f, -0.07412273f, -0.04712154f, 0.02290724f, 
    0.02581609f, 0.00079592f, -0.03782460f, 0.01094127f, 0.06080611f, 0.04709190f, -0.03810519f, -0.07301240f, 
    -0.01426766f, -0.00631535f, 0.00599948f, -0.00589706f, -0.06042173f, -0.07177266f, -0.03941019f, 0.01701500f, 
    -0.03713226f, -0.04244671f, 0.00641731f, -0.04187293f, 0.02567459f, 0.03418383f, -0.02452319f, 0.05817174f, 
    -0.05989185f, 0.00142115f, 0.05963779f, 0.05439306f, 0.05005357f, -0.02383970f, 0.04527354f, -0.06015310f, 
    0.06050918f, 0.02126225f, -0.07404505f, -0.07647450f, -0.05000728f, 0.04647632f, -0.01014725f, -0.01215772f, 
    -0.06048363f, -0.01264041f, -0.01778124f, -0.06314032f, 0.00223364f, 0.06422651f, 0.03696424f, 0.01406240f, 
    -0.00523090f, -0.01896277f, -0.05290995f, -0.04895040f, 0.01869724f, 0.00916878f, -0.00813894f, 0.01300778f, 
    0.05737682f, 0.00108160f, -0.04058515f, -0.06838951f, -0.03559181f, 0.04231812f, -0.06079120f, 0.03420474f, 
    -0.02420302f, 0.02465878f, -0.01186491f, 0.06007519f, 0.01354749f, -0.07317682f, 0.06796280f, 0.00697978f, 
    -0.04045994f, -0.01710518f, -0.02953726f, 0.02208626f, -0.07037278f, 0.04820278f, -0.03704782f, 0.05809719f, 
    -0.05375835f, -0.04958494f, 0.01467078f, -0.00508592f, 0.01110760f, -0.02572964f, -0.04392748f, 0.04251894f, 
    -0.07717636f, 0.04272251f, -0.03259369f, 0.04368771f, -0.00711333f, 0.00615447f, -0.05163573f, -0.00838085f, 
    -0.06587104f, 0.01201962f, -0.04284314f, 0.02880712f, -0.04563463f, -0.06610736f, -0.03061535f, -0.02479496f, 
    -0.03389796f, -0.06120250f, 0.02728653f, 0.01668989f, 0.00809519f, -0.05895379f, 0.02270574f, -0.01282247f, 
    0.04303890f, 0.05193779f, 0.00481682f, 0.01229417f, 0.02372424f, 0.06522828f, -0.07132713f, -0.07347006f, 
    -0.05715035f, -0.02813587f, 0.03377639f, -0.03129772f, -0.01405790f, 0.00670130f, -0.05362249f, -0.05990531f, 
    -0.02083233f, 0.02338623f, 0.03373862f, -0.04115393f, 0.03584874f, 0.01769189f, 0.05640705f, -0.06039068f, 
    -0.00873111f, -0.06990372f, -0.04021313f, -0.00509042f, 0.04293958f, -0.06004104f, 0.00062437f, 0.02888681f, 
    -0.06883423f, 0.00089887f, 0.04012403f, 0.01384902f, -0.02864824f, 0.06256349f, -0.00603028f, -0.00478965f, 
    0.13792799f, -0.07304399f, 0.27688989f, 0.01182359f, 0.01577549f, -0.17936985f, -0.00787334f, 0.05612404f, 
    -0.10725152f, 0.04873255f, 0.14898627f, -0.06213847f, 0.28532466f, -0.16811907f, 0.04642073f, 0.01488778f, 
    0.00109907f, -0.09745117f, 0.00297842f, 0.03215178f, 0.17393662f, -0.03457874f, 0.07361294f, 0.02437880f, 
    -0.02435821f, -0.07128175f, 0.02566366f, -0.04648126f, 0.01030750f, 0.07165708f, 0.03404984f, 0.03369692f, 
    0.15210111f, -0.11253956f, 0.18748148f, -0.17418796f, 0.19562191f, 0.01792890f, 0.20391060f, -0.21072625f, 
    0.21987468f, -0.10890233f, 0.07590764f, -0.06141918f, -0.06148968f, 0.18735510f, -0.00335291f, -0.01095689f, 
    -0.19021204f, 0.38566285f, 0.05486566f, -0.04397895f, 0.10012795f, 0.00726306f, 0.01356562f, 0.03372623f, 
    -0.10360163f, 0.09703014f, 0.10751410f, 0.01919859f, -0.15153742f, 0.02561975f, 0.28709435f, 0.16391921f, 
    0.02063937f, -0.08669814f, -0.05851470f, 0.10423373f, 0.10015857f, -0.20186518f, 0.13172317f, 0.11709435f, 
    0.01909838f, -0.21140979f, 0.34109873f, -0.06494743f, 0.22841199f, -0.04047970f, 0.11774627f, 0.12608773f, 
    0.07660209f, -0.00548812f, -0.11118678f, 0.09238000f, -0.03006013f, -0.12134367f, -0.00112722f, 0.03715489f, 
    -0.06304172f, -0.01669478f, -0.00821602f, -0.09376507f, -0.12065516f, -0.01549914f, 0.05933893f, -0.09348372f, 
    -0.15669535f, 0.00975034f, -0.26748279f, 0.13262179f, -0.09573440f, 0.05807153f, 0.05186919f, -0.16089292f, 
    0.09545354f, 0.10149114f, -0.04285425f, 0.00763169f, 0.46552965f, -0.21648379f, -0.13972372f, 0.09605917f, 
    -0.10004376f, -0.12443000f, -0.02017168f, 0.06147020f, 0.02072730f, 0.23476101f, 0.01285816f, -0.01537115f, 
    0.54755902f, -0.06052775f, -0.02708667f, 0.21469031f, -0.12752999f, 0.14403753f, -0.13883358f, -0.00809272f, 
    0.16487664f, -0.09468962f, 0.11989573f, 0.01422615f, -0.66918695f, 0.21769963f, 0.23328026f, -0.20287193f, 
    0.20447257f, -0.20086239f, 0.19828565f, 0.08410934f, 0.00188146f, 0.03207862f, -0.03560217f, 0.05040786f, 
    -0.23544790f, -0.24868904f, 0.19158047f, -0.11047819f, -0.12709466f, 0.20876797f, 0.10210296f, 0.03660261f, 
    -0.00693648f, 0.06707812f, -0.00292948f, 0.08815753f, -0.11453302f, 0.23765223f, 0.13588713f, 0.17739935f, 
    0.11431605f, 0.00735159f, -0.02574161f, -0.01941786f, 0.08690275f, 0.11757845f, -0.10375603f, 0.15719712f, 
    0.29418111f, -0.21162276f, 0.07377468f, 0.24376304f, -0.06046466f, 0.06994779f, -0.01558472f, 0.17370413f, 
    0.08001801f, -0.03349125f, -0.01472512f, -0.09786112f, 0.18378884f, 0.12195355f, 0.24509877f, -0.00427111f, 
    -0.01714014f, -0.08643597f, 0.01439205f, -0.07295301f, 0.12693705f, 0.08358540f, 0.23978409f, -0.01037792f, 
    0.53117615f, 0.22385259f, -0.07770654f, -0.05797556f, -0.02239704f, 0.21174461f, 0.01827277f, -0.16172296f, 
    -0.19454178f, 0.09911017f, 0.05309000f, -0.17753613f, 0.00328517f, 0.22522803f, 0.12495700f, 0.26553056f, 
    -0.14585842f, 0.03403002f, 0.09370804f, 0.04497626f, 0.05642742f, -0.18588589f, 0.07661617f, -0.07861244f, 
    0.22619481f, -0.37507513f, 0.20340319f, -0.11112543f, 0.01614519f, -0.12953772f, 0.02946814f, 0.05507714f, 
    -0.19252987f, -0.08065582f, 0.06086739f, 0.25350425f, 0.07134191f, -0.13975462f, 0.05110583f, 0.05990740f, 
    0.14796655f, 0.29355380f, 0.14970502f, 0.02695911f, 0.05346280f, 0.02623110f, -0.08748387f, -0.01544073f, 
    -0.26326230f, 0.12062758f, -0.19334525f, 0.14683475f, 0.23319639f, 0.10897042f, -0.06992932f, 0.02947591f, 
    0.06498252f, -0.09633776f, 0.06874283f, 0.12177772f, 0.11167664f, -0.02338047f, 0.19099031f, 0.24987936f, 
    -0.00925779f, 0.12569280f, 0.03870598f, -0.01849592f, -0.05979609f, -0.04375942f, 0.25289208f, -0.11532455f, 
    -0.17443185f, 0.14290695f, -0.05402129f, 0.18085934f, 0.00282104f, 0.14669147f, -0.08812881f, 0.26610866f, 
    -0.03128885f, 0.05219250f, -0.37080640f, -0.17524840f, -0.03254068f, 0.12403697f, -0.02047231f, 0.18215767f, 
    0.07868557f, -0.14974359f, 0.08116898f, -0.12775630f, 0.06527165f, 0.20408358f, -0.07271685f, 0.03843778f, 
    0.25843573f, -0.23785555f, -0.16429678f, -0.20710918f, -0.06971978f, -0.00371330f, -0.19548468f, -0.11968984f, 
    -0.01797430f, 0.13424818f, -0.12131305f, 0.19989915f, -0.32946628f, 0.28797677f, 0.20208299f, 0.00164712f, 
    -0.30551043f, -0.18359739f, -0.05178331f, 0.04962203f, -0.22538668f, -0.18039462f, -0.05410073f, -0.02459535f, 
    0.30138907f, 0.05787269f, 0.24765335f, 0.12493309f, -0.31946287f, -0.16183874f, 0.05190741f, -0.00321216f, 
    -0.03283750f, -0.01024954f, -0.06502146f, 0.07919495f, 0.07402504f, -0.12815657f, -0.28683728f, -0.06331837f, 
    0.02141198f, 0.00211824f, -0.22557572f, 0.08676779f, -0.04052699f, -0.04636143f, -0.00135658f, -0.06070388f, 
    -0.57110280f, 0.03943438f, -0.22472282f, 0.40517089f, 0.05348737f, 0.04218629f, 0.02857663f, -0.00793018f, 
    0.03706720f, 0.22802517f, -0.02396988f, -0.02351832f, -0.39874375f, -0.27749866f, -0.00851438f, 0.26979798f, 
    0.08966019f, -0.02111781f, 0.01834829f, -0.22750089f, 0.02356982f, -0.08245977f, 0.09039213f, -0.04269069f, 
    -0.08179297f, 0.07285761f, 0.18509692f, 0.07444245f, -0.19924967f, 0.01542212f, 0.15755954f, -0.03753101f, 
    -0.17454709f, 0.08330954f, -0.02933650f, 0.21443890f, -0.09362300f, -0.09684487f, 0.18133281f, 0.09090579f, 
    0.16266908f, 0.15887296f, 0.11305603f, 0.04134371f, 0.00375877f, 0.05975233f, 0.06240713f, 0.05580574f, 
    -0.07980790f, 0.16951402f, 0.14371870f, -0.12210561f, 0.07205273f, 0.01515842f, 0.21253593f, 0.05049894f, 
    0.16903944f, 0.01720229f, -0.17176750f, 0.09028770f, -0.10063937f, 0.25345054f, 0.11147099f, -0.16180520f, 
    0.05683470f, 0.14794175f, 0.02562310f, 0.06364195f, 0.04796287f, 0.30968770f, -0.04148359f, 0.32493365f, 
    0.15925574f, 0.30662408f, 0.04081342f, 0.12862810f, -0.06918581f, 0.09235829f, 0.22629753f, -0.13390578f, 
    0.10883060f, -0.11013019f, -0.09000969f, -0.05860188f, -0.04132132f, 0.09258068f, -0.04566692f, 0.32770583f, 
    -0.04834627f, -0.29571161f, -0.14928789f, 0.19933867f, -0.02100959f, 0.11781137f, 0.20778213f, 0.20685755f, 
    0.09936032f, -0.05793795f, -0.05652437f, 0.07334723f, -0.03882494f, -0.08940716f, 0.03137194f, 0.10650591f, 
    0.07897083f, -0.01203342f, -0.07791942f, -0.07966789f, 0.00679446f, 0.06633598f, -0.07367423f, -0.01029398f, 
    0.03472684f, 0.04518261f, 0.08614270f, -0.15505816f, 0.12705430f, 0.17733276f, -0.14898637f, 0.19518085f, 
    0.08564602f, -0.00215458f, 0.12400392f, 0.00348008f, -0.05003290f, 0.02263488f, -0.08317706f, -0.00245071f, 
    0.12693295f, 0.04559919f, 0.43119112f, 0.06666289f, 0.37099195f, -0.09578073f, -0.01348132f, -0.25086704f, 
    0.05317134f, 0.10045865f, 0.09037770f, 0.01942857f, -0.13463780f, -0.17719333f, -0.08738121f, 0.00948625f, 
    -0.59117770f, -0.03452857f, 0.13759646f, 0.26724961f, 0.13393211f, -0.00411622f, 0.05299662f, 0.15146141f, 
    0.09212150f, -0.00344367f, 0.11330747f, 0.09834950f, -0.26639080f, 0.22758809f, 0.10960931f, -0.26509333f, 
    -0.02560909f, 0.06443527f, -0.09045297f, -0.00415473f, 0.07518090f, 0.03592947f, 0.28266647f, 0.18543278f, 
    -0.22757444f, 0.24962556f, 0.02043027f, -0.16253573f, -0.10363173f, 0.14605367f, 0.00267176f, 0.01840221f, 
    -0.06372541f, 0.13487898f, -0.14096431f, -0.11884950f, 0.11157747f, -0.23395047f, -0.01987780f, 0.13924165f, 
    0.14381781f, -0.00471332f, 0.15191886f, 0.09885819f, -0.01204038f, 0.06596680f, 0.27157459f, 0.20675364f, 
    0.55586731f, -0.08049227f, -0.31391752f, -0.17309214f, 0.05431395f, -0.04581444f, -0.16576900f, 0.09822304f, 
    -0.08613344f, -0.01990764f, 0.13702050f, 0.07486672f, 0.21086773f, -0.16145557f, 0.06655303f, 0.05528259f, 
    0.01146960f, 0.15291731f, 0.17472610f, 0.21463846f, -0.02596283f, 0.31255040f, 0.11815778f, 0.04060194f, 
    -0.09431659f, 0.18500386f, 0.06806099f, -0.21020195f, 0.03060459f, -0.00672197f, 0.02528150f, -0.01233542f, 
    -0.04811891f, -0.15725531f, 0.07665639f, -0.27547425f, 0.21826796f, -0.13908042f, -0.31210858f, 0.21781865f, 
    -0.01191449f, 0.00361642f, 0.03279617f, 0.11844047f, -0.06080276f, -0.14991069f, -0.19903634f, -0.11345402f, 
    0.17905022f, 0.19925970f, 0.18013927f, -0.37189347f, 0.05410410f, 0.04276783f, 0.10846371f, 0.01799263f, 
    -0.03708404f, -0.02984157f, -0.22981024f, 0.11839642f, 0.18277915f, 0.35313955f, 0.00877429f, -0.49472219f, 
    0.12434302f, 0.02172571f, 0.01990622f, 0.08002726f, 0.14986427f, 0.19321895f, 0.02322206f, 0.27590337f, 
    -0.02680940f, 0.23920847f, -0.07556925f, 0.25012693f, 0.00427866f, 0.07949398f, 0.06679736f, -0.05917216f, 
    -0.01660556f, -0.20716599f, -0.14231251f, 0.02031071f, 0.17030814f, 0.26515082f, -0.03909282f, 0.18497702f, 
    0.03120893f, -0.21972232f, -0.15738600f, 0.19463231f, -0.01797150f, 0.13098216f, 0.16261138f, 0.13499130f, 
    0.28241444f, 0.22481896f, 0.09261570f, -0.09345122f, -0.03051770f, -0.07220782f, 0.07684887f, 0.11474998f, 
    0.06167314f, 0.03338329f, 0.07247855f, 0.01162995f, 0.03351338f, -0.02506662f, 0.02446610f, 0.11999913f, 
    0.06015043f, 0.01797031f, -0.03076504f, -0.06657930f, 0.07816237f, 0.13588895f, -0.06931899f, 0.02265173f, 
    0.61283237f, 0.13466528f, 0.30877939f, 0.21710075f, 0.04534232f, -0.08943150f, -0.14910078f, 0.04866173f, 
    -0.08123435f, 0.10031199f, 0.26611170f, -0.03882167f, 0.22809085f, -0.32390440f, 0.02305245f, -0.22021620f, 
    0.15782735f, 0.09520508f, 0.08294278f, 0.12496932f, -0.04608045f, -0.20012803f, 0.02072338f, 0.01221881f, 
    -0.35806751f, -0.34938589f, -0.02656808f, 0.18717287f, 0.16714713f, -0.00935348f, 0.02383824f, 0.05636996f, 
    0.04928444f, 0.06524313f, 0.05680366f, 0.00758336f, -0.08484785f, 0.26966289f, -0.03154597f, -0.10222149f, 
    -0.18959948f, -0.14172213f, -0.03827287f, 0.03663485f, -0.00145323f, 0.01804545f, 0.11938529f, 0.14517935f, 
    0.03430782f, 0.04992700f, -0.01752587f, -0.29619879f, -0.04652867f, -0.00369052f, 0.04259581f, -0.10165735f, 
    -0.16368127f, 0.04855079f, -0.13755220f, -0.16102144f, -0.01886069f, -0.01861637f, -0.15355079f, 0.16624101f, 
    0.15267065f, 0.05113992f, 0.02262286f, 0.02686842f, -0.04209325f, -0.00024270f, 0.23596267f, -0.02910777f, 
    -0.03271328f, 0.04806248f, -0.33903462f, 0.17140612f, 0.07416556f, 0.23967883f, -0.18728808f, 0.15314631f, 
    -0.08318002f, 0.04331753f, 0.03506993f, 0.06628878f, -0.29170552f, -0.39245579f, 0.08910725f, 0.04757554f, 
    0.03894142f, 0.29927018f, 0.07356852f, 0.07487346f, -0.03011409f, 0.27374139f, 0.02543190f, 0.04107179f, 
    0.20733322f, 0.19701023f, 0.05429135f, -0.09092078f, 0.03912096f, -0.08009437f, 0.01757690f, -0.00038069f, 
    -0.09292470f, -0.09567506f, 0.05311257f, -0.04436739f, 0.38745800f, 0.14942892f, -0.15184750f, 0.20789668f, 
    0.12111262f, 0.03594526f, 0.05450402f, -0.08803779f, -0.11460083f, -0.03801365f, -0.10589012f, -0.01465781f, 
    0.23515694f, 0.10313164f, 0.23472480f, 0.26411545f, 0.04369342f, 0.06585070f, 0.15190569f, -0.00235092f, 
    -0.03721912f, -0.04424480f, -0.03396028f, 0.10595624f, 0.20283557f, -0.08412723f, -0.00498355f, 0.27868786f, 
    -0.22390199f, 0.10324377f, 0.03125577f, -0.02463564f, -0.03660363f, 0.09889259f, 0.04952001f, -0.01698258f, 
    -0.08257996f, -0.01738693f, 0.06390997f, 0.07626510f, 0.02863064f, 0.22693224f, 0.11145192f, -0.13982204f, 
    -0.00196611f, -0.04793740f, 0.09982815f, -0.02707816f, 0.00079653f, 0.18056679f, 0.05093355f, -0.00266748f, 
    0.18679428f, -0.10726065f, 0.13379061f, -0.15562290f, 0.07779426f, 0.14131556f, 0.09445715f, -0.07294294f, 
    -0.16762084f, 0.08752111f, -0.09574812f, -0.11790258f, 0.05372848f, -0.02933762f, -0.02579342f, -0.03871544f, 
    -0.04220308f, 0.08338355f, 0.10288514f, -0.05137549f, -0.32794169f, -0.02652007f, 0.29340273f, 0.15318669f, 
    0.01445667f, -0.15385635f, -0.02030918f, 0.00702680f, -0.02267673f, -0.06509244f, -0.02705569f, 0.25951228f, 
    -0.06866697f, -0.24496606f, -0.10294092f, -0.12529965f, -0.13532712f, 0.19353814f, -0.00046176f, 0.03699902f, 
    -0.02660486f, -0.01376735f, 0.02024427f, 0.03566696f, -0.09087609f, 0.03282147f, 0.13245469f, 0.15169327f, 
    -0.10345791f, 0.10479830f, 0.03980138f, -0.15518183f, 0.06423564f, -0.18169081f, 0.03317737f, -0.05677665f, 
    -0.18378261f, -0.07920389f, -0.29349619f, -0.10070296f, -0.03163967f, -0.07516287f, -0.06161868f, -0.20835754f, 
    0.09882881f, -0.00609040f, 0.11594757f, 0.03804591f, 0.42113957f, -0.13600928f, 0.12961914f, 0.25129265f, 
    -0.13159914f, -0.08686832f, 0.10350885f, 0.04867024f, 0.05311749f, 0.15220378f, -0.05263944f, -0.02896898f, 
    0.79878157f, 0.09283584f, -0.03253468f, 0.29315522f, -0.10811194f, 0.14775047f, -0.01266912f, 0.06210312f, 
    -0.05089587f, -0.07521974f, -0.01689770f, 0.02028846f, -0.57015896f, 0.29222074f, 0.02763965f, -0.03803845f, 
    0.10677547f, 0.00300191f, 0.09758437f, -0.20343938f, 0.02164624f, -0.00807967f, -0.06827603f, 0.13061555f, 
    0.04672671f, -0.24688454f, 0.06584613f, -0.39005250f, 0.02352812f, 0.14943838f, -0.18004236f, 0.05377703f, 
    -0.05120298f, -0.00561604f, 0.11074862f, -0.05123259f, 0.37934634f, 0.07890680f, 0.06892740f, 0.07987041f, 
    0.03031646f, 0.09980402f, 0.22478151f, 0.03940507f, 0.08171313f, 0.11059803f, -0.01875560f, 0.10878398f, 
    0.44517133f, -0.21565215f, 0.13668777f, 0.22963662f, -0.10012865f, 0.14248528f, -0.03842408f, -0.03907645f, 
    0.15161707f, -0.20327947f, -0.06816059f, -0.21957514f, 0.03295257f, -0.25711775f, 0.24610145f, -0.00787577f, 
    -0.12946406f, 0.07030576f, -0.02045484f, -0.01588869f, -0.01233833f, 0.01231644f, 0.07684652f, -0.04309418f, 
    0.35677099f, 0.19019753f, 0.24005167f, -0.35164586f, 0.14335854f, 0.07471625f, -0.10472440f, 0.02456656f, 
    -0.02733736f, 0.02224417f, -0.09067531f, -0.02246330f, 0.34235793f, 0.05318115f, 0.29343152f, -0.18389837f, 
    0.09834253f, -0.02984198f, 0.06760200f, 0.17121013f, 0.17504686f, -0.11220282f, 0.18975167f, -0.01229764f, 
    -0.00810080f, -0.05362261f, 0.09746771f, -0.17246388f, -0.01505780f, -0.17642702f, -0.16149005f, 0.09722021f, 
    -0.02927896f, 0.13157700f, 0.26205990f, 0.16793554f, -0.12909704f, -0.14633748f, 0.03419480f, -0.16442980f, 
    0.05011499f, 0.04604843f, 0.00902046f, 0.05598746f, -0.01225021f, 0.05786544f, -0.11932387f, -0.00226963f, 
    0.26471299f, 0.00034889f, 0.00881936f, -0.25731930f, 0.23991978f, 0.01665618f, -0.01450658f, 0.01836154f, 
    0.03141006f, -0.05476479f, 0.05159257f, 0.03153647f, 0.02528400f, 0.06279780f, -0.14483978f, 0.03464158f, 
    0.04128325f, 0.02194566f, -0.08939698f, -0.02631699f, -0.03353182f, -0.12104972f, 0.30331638f, 0.02402046f, 
    0.07812344f, 0.10462718f, -0.07187313f, 0.16330341f, 0.12632480f, -0.09012986f, 0.12595090f, 0.02268921f, 
    0.08292174f, 0.01750352f, -0.20582601f, -0.03817671f, -0.33538190f, -0.02126694f, 0.08166301f, 0.24225897f, 
    0.16084436f, 0.03838291f, 0.00143815f, 0.16636081f, -0.00657344f, 0.12296548f, -0.05314754f, 0.07181942f, 
    0.25479671f, -0.35735443f, -0.08776741f, -0.18455063f, -0.01648105f, -0.00761758f, -0.09182553f, 0.06693922f, 
    -0.06863350f, 0.06111144f, -0.10157122f, -0.04314150f, 0.25809866f, 0.19331659f, 0.16240163f, 0.39411479f, 
    -0.17045066f, 0.03691614f, -0.01465047f, -0.00416973f, 0.07046534f, -0.15147883f, -0.10303293f, -0.10325833f, 
    0.45103800f, 0.06395917f, 0.22747031f, 0.06878167f, 0.12676027f, -0.00551619f, 0.06115376f, -0.08639773f, 
    0.18570316f, 0.00653102f, 0.09855099f, 0.13129680f, -0.05794790f, -0.02766094f, -0.02949497f, -0.12748781f, 
    0.00787290f, -0.06738661f, 0.01215383f, 0.02338750f, 0.00131968f, 0.02309169f, 0.04811642f, -0.01437632f, 
    -0.56689656f, -0.10749677f, -0.39538959f, 0.13254090f, -0.17109665f, 0.09621474f, -0.00125119f, -0.01044958f, 
    -0.07726464f, 0.06929067f, 0.06284442f, 0.01384843f, -0.69215667f, -0.39591932f, -0.32408834f, 0.21187326f, 
    0.01735826f, -0.05652935f, -0.10585707f, -0.08224092f, 0.02364652f, -0.01197565f, 0.04826329f, 0.09209655f, 
    0.00385296f, 0.09069812f, -0.11373196f, 0.19796231f, -0.06875309f, 0.14612184f, 0.00263305f, 0.03916238f, 
    -0.04416468f, 0.14024092f, -0.03861595f, 0.08942658f, -0.20261680f, 0.00521874f, 0.15788230f, -0.20481688f, 
    -0.04605992f, 0.12678868f, -0.05326826f, -0.23239733f, -0.05147816f, 0.13126652f, 0.07316828f, 0.09140859f, 
    -0.05836237f, 0.05135523f, 0.01799226f, -0.39603409f, -0.01011296f, -0.08857748f, -0.13761808f, 0.06346861f, 
    -0.13467288f, 0.16644186f, 0.04263954f, -0.00540878f, 0.07123889f, -0.05281358f, -0.00993567f, -0.33877090f, 
    0.11506672f, -0.08221694f, -0.03585419f, 0.13060628f, 0.12896088f, -0.00482756f, 0.17370744f, 0.10435976f, 
    -0.02080821f, -0.00295606f, 0.06353199f, 0.10148650f, -0.03205821f, -0.20875204f, -0.08171085f, 0.12701581f, 
    0.00371817f, -0.11736415f, 0.18068936f, 0.04381269f, 0.21847299f, -0.13780499f, -0.10251907f, -0.04435112f, 
    0.09010129f, -0.03513760f, 0.03214053f, 0.06379792f, 0.07683328f, -0.01324261f, -0.12596458f, -0.01838236f, 
    -0.07622030f, 0.36464152f, 0.13593423f, -0.24621284f, 0.07765421f, -0.06000984f, 0.02086934f, -0.02606287f, 
    -0.06419366f, 0.01790044f, 0.14245327f, 0.02462362f, 0.03347357f, 0.10322570f, 0.05667665f, 0.25634491f, 
    0.08089131f, -0.02491233f, -0.05284040f, -0.07746229f, -0.00736644f, -0.06277405f, 0.21814913f, 0.02122976f, 
    0.08290496f, 0.12967809f, 0.50503415f, 0.09139833f, 0.15231664f, -0.00570698f, 0.01662785f, 0.18703011f, 
    0.07145518f, 0.01596312f, -0.11185621f, -0.04304335f, -0.24015914f, -0.16248943f, -0.02433580f, -0.00858235f, 
    0.04996055f, -0.02871428f, -0.08784562f, 0.14172798f, 0.13709307f, 0.06685627f, 0.08880239f, 0.07144260f, 
    -0.14214948f, -0.22415338f, -0.03007726f, 0.08093096f, 0.08710765f, 0.11682413f, 0.12242044f, 0.07986490f, 
    0.08755312f, 0.07587276f, 0.03576953f, -0.02700940f, 0.01987380f, -0.04882276f, -0.01763009f, 0.17953169f, 
    0.11545047f, 0.08101571f, -0.04135262f, -0.08922411f, -0.01240936f, -0.04100569f, -0.02015523f, 0.20767227f, 
    -0.19882396f, -0.14892764f, 0.15193896f, 0.01502274f, -0.00842068f, -0.07530797f, 0.02653824f, -0.11967983f, 
    0.09792337f, 0.04387280f, 0.09022567f, 0.07975604f, -0.26996875f, 0.05120439f, -0.20687544f, -0.16337141f, 
    0.15984961f, 0.02971721f, -0.05446582f, 0.03375761f, 0.01038974f, 0.05810270f, 0.01966761f, -0.03175800f, 
    -0.18125722f, -0.18617138f, -0.31897083f, 0.34116125f, -0.13125484f, 0.25164774f, -0.02116734f, 0.16691345f, 
    -0.02356680f, -0.04305975f, -0.10380303f, 0.10269733f, -0.34988791f, 0.10856664f, -0.03488103f, -0.02910439f, 
    -0.01339906f, 0.00895739f, -0.06620667f, 0.10210520f, 0.09527378f, 0.04077477f, -0.04761557f, -0.00521563f, 
    0.14824733f, 0.07487955f, 0.15463921f, 0.27844241f, -0.03794048f, 0.03702846f, -0.00389039f, -0.13826467f, 
    0.14140478f, 0.01772845f, 0.16741487f, 0.22066152f, 0.23803109f, 0.14442851f, -0.15556450f, -0.05630148f, 
    -0.01372100f, 0.07372028f, 0.06860434f, -0.11875356f, -0.08755775f, 0.11937007f, -0.04336656f, 0.03175563f, 
    0.01802077f, 0.06782353f, 0.04547437f, -0.00544293f, 0.06588161f, -0.01041802f, 0.02496567f, 0.05890361f, 
    -0.02337526f, 0.05556897f, -0.00999036f, 0.05057763f, -0.04196317f, -0.04811019f, -0.04072824f, -0.00511367f, 
    0.03250190f, -0.03160887f, 0.04711390f, -0.00851012f, -0.07146952f, -0.05761633f, 0.06715945f, -0.01500070f, 
    0.05527454f, 0.03881573f, 0.04900299f, 0.00998209f, -0.02790150f, -0.03647705f, 0.05285861f, -0.04601644f, 
    0.04198366f, -0.02653289f, 0.00005372f, 0.04915113f, 0.00831642f, 0.06095768f, -0.06398086f, -0.06045426f, 
    0.02285836f, -0.05142014f, 0.01215559f, -0.05356853f, -0.02719551f, -0.05225751f, 0.02541172f, -0.00927817f, 
    -0.02278550f, 0.01449534f, 0.04400723f, 0.02265074f, -0.07101512f, -0.04221361f, -0.00731839f, -0.04405878f, 
    -0.03028464f, 0.00523848f, 0.00129868f, 0.05653109f, -0.05796496f, -0.03765222f, -0.05682107f, 0.02516576f, 
    -0.06832103f, 0.02808712f, -0.05681979f, -0.01472935f, 0.01342415f, -0.03590872f, -0.06004068f, -0.03174743f, 
    0.02354890f, -0.03290704f, 0.01716685f, -0.02704221f, -0.05792659f, -0.00815640f, -0.03556092f, 0.04918871f, 
    -0.00206662f, -0.06721739f, -0.03511526f, -0.04679497f, -0.03015156f, -0.06509283f, -0.03525337f, -0.01392906f, 
    0.00814209f, -0.05927400f, -0.03621222f, 0.04270788f, -0.01652734f, 0.03344730f, -0.07475649f, 0.00715099f, 
    -0.01184279f, -0.01404486f, -0.03003399f, 0.06660555f, -0.04672419f, 0.05181503f, 0.02267741f, -0.07012432f, 
    0.06691074f, -0.05512724f, 0.03368704f, -0.05668531f, -0.01295419f, 0.02616353f, 0.07775491f, -0.00389649f, 
    -0.03653372f, 0.04359714f, 0.05349235f, -0.02362637f, -0.02802504f, 0.04346415f, -0.08310617f, 0.05322085f, 
    -0.02364003f, 0.00710887f, -0.03615115f, -0.03718692f, -0.02949260f, -0.05991364f, -0.04874223f, -0.07090849f, 
    -0.04608934f, 0.02966361f, -0.02383119f, -0.03600622f, 0.03217620f, -0.03431515f, 0.02289837f, -0.00317947f, 
    -0.06179641f, -0.05154359f, 0.05274614f, 0.05586048f, -0.07558707f, -0.05457400f, 0.03201729f, 0.02548601f, 
    0.06011678f, -0.05595022f, 0.06235198f, 0.02009406f, -0.03811611f, -0.00626284f, 0.03754569f, 0.03262112f, 
    -0.06334431f, 0.03319915f, -0.02279932f, -0.05842568f, -0.07383975f, 0.06283697f, -0.01426073f, -0.05515950f, 
    0.02739265f, -0.06612813f, -0.06994244f, -0.01586585f, -0.04757467f, -0.04714743f, -0.03158456f, 0.04044895f, 
    0.03302239f, -0.05240141f, 0.06281018f, 0.01841049f, -0.02875669f, -0.06362215f, -0.00232712f, 0.06107023f, 
    -0.07029033f, -0.03570101f, -0.00189935f, 0.01781314f, -0.03679992f, 0.05839364f, -0.03642988f, -0.02385863f, 
    -0.07181407f, 0.03679442f, -0.00005324f, 0.04851084f, -0.05160936f, -0.03396841f, 0.06862452f, -0.02159468f, 
    -0.06004663f, 0.00240180f, -0.04262078f, -0.01740763f, -0.05265094f, 0.03318512f, 0.02933233f, -0.01107791f, 
    0.04919343f, -0.07372710f, 0.02901538f, -0.07331704f, -0.07470626f, -0.05817809f, 0.03477100f, 0.01767647f, 
    -0.06479479f, 0.04711299f, -0.01149947f, -0.03815950f, -0.02113072f, -0.04547463f, 0.05547075f, 0.06597608f, 
    -0.02651685f, -0.03607933f, 0.05143994f, 0.01780952f, 0.00738186f, -0.03194990f, -0.06646731f, 0.02051032f, 
    0.03522567f, -0.01103674f, -0.04439907f, -0.06832002f, 0.05912457f, -0.07489184f, -0.02140472f, -0.00585275f, 
    0.03912413f, 0.02415981f, 0.02620720f, -0.04823311f, 0.03840695f, 0.05020903f, 0.02657405f, 0.06302835f, 
    -0.06029695f, 0.05856629f, 0.04776149f, -0.06521574f, 0.00846444f, -0.05433729f, -0.01329382f, -0.04354318f, 
    0.03682046f, 0.03086914f, -0.03531050f, -0.07070524f, 0.00134886f, 0.05514834f, 0.03423045f, 0.01691932f, 
    -0.01310312f, -0.02372016f, -0.05872949f, 0.01510720f, -0.00252754f, -0.02882366f, 0.00652128f, -0.04141457f, 
    -0.00036945f, -0.02357172f, -0.06941143f, -0.00400368f, 0.02956369f, 0.03769972f, 0.06633110f, 0.05487152f, 
    -0.03653657f, -0.04383023f, -0.01304392f, -0.06848817f, -0.05940566f, -0.01720172f, 0.02439409f, 0.00849959f, 
    0.06350196f, -0.02914066f, -0.06153293f, 0.05158205f, 0.05977675f, -0.06460508f, -0.07512600f, 0.05713345f, 
    -0.03169217f, 0.03639109f, 0.06116445f, 0.04237261f, 0.00450708f, -0.01604037f, -0.00253464f, -0.06266800f, 
    -0.03374442f, 0.02767851f, -0.00012333f, -0.03281711f, -0.07674038f, -0.07551578f, 0.02740984f, -0.05060097f, 
    -0.05555249f, -0.03284087f, -0.01595183f, -0.02140571f, -0.06130923f, -0.00357302f, -0.07442711f, -0.03214565f, 
    -0.04539660f, 0.02468517f, -0.05245048f, 0.03249741f, -0.07027829f, -0.06479599f, 0.03945384f, -0.01120137f, 
    0.05498131f, -0.02410441f, -0.06440232f, -0.06389683f, 0.02080063f, 0.02385595f, -0.00002144f, -0.00640933f, 
    -0.05818541f, -0.06026605f, -0.07513078f, 0.02181203f, 0.03088561f, 0.00252436f, -0.04810572f, 0.03033926f, 
    -0.02650330f, 0.01396997f, 0.06148306f, -0.03832693f, -0.07708229f, -0.01771003f, 0.02803785f, -0.00541038f, 
    -0.04780995f, 0.04916926f, 0.00213787f, 0.02796093f, 0.04189453f, -0.06923711f, 0.05997525f, 0.00217731f, 
    -0.00344745f, -0.06526389f, -0.06255647f, -0.02320815f, -0.07017718f, -0.03156397f, 0.03410545f, 0.01550655f, 
    -0.04022884f, 0.05539415f, -0.03145272f, -0.03931002f, -0.02407729f, 0.01038530f, 0.02441942f, -0.04562202f, 
    0.01435598f, 0.03291712f, -0.00317846f, -0.04235549f, 0.04239985f, -0.02418213f, -0.00614483f, -0.06142255f, 
    0.05887442f, -0.06948947f, -0.04156487f, -0.05394439f, 0.06019796f, 0.03593740f, -0.04459030f, 0.02733406f, 
    0.00261373f, 0.05340233f, -0.00720854f, 0.02838988f, 0.00654843f, -0.06792326f, -0.02447208f, -0.04227285f, 
    -0.03286915f, 0.00984201f, -0.01843152f, 0.02365133f, -0.07188585f, 0.05070018f, 0.00228307f, 0.03136159f, 
    -0.06988639f, 0.01886648f, 0.05030634f, -0.04028046f, -0.06538457f, -0.01652526f, 0.05091476f, 0.05114881f, 
    0.06148245f, 0.05255755f, -0.06906468f, -0.01069409f, -0.01446663f, -0.05400154f, -0.01251346f, -0.07259061f, 
    0.02563361f, 0.04657665f, -0.08205096f, -0.00399153f, 0.01008120f, 0.05426771f, 0.00470196f, 0.01017547f, 
    0.03195191f, -0.05205962f, -0.06035297f, -0.03584304f, -0.05139651f, -0.00069191f, -0.04616332f, 0.05752354f, 
    -0.07295852f, -0.03641700f, 0.00504877f, 0.02588352f, -0.05816690f, 0.03916097f, 0.04420163f, -0.02379543f, 
    -0.03174701f, 0.02390802f, 0.06283082f, 0.01029576f, -0.04681520f, -0.01617820f, 0.04116051f, 0.00027642f, 
    -0.03889968f, 0.07001406f, 0.00240476f, 0.03014597f, -0.00008014f, -0.06225307f, -0.05660156f, -0.03866217f, 
    -0.00319222f, 0.03550817f, -0.03554361f, -0.03326879f, -0.06735707f, -0.06846248f, -0.01969328f, 0.03068510f, 
    -0.01530169f, 0.01529061f, 0.00658297f, -0.03837717f, 0.05388187f, -0.03192225f, -0.00429104f, 0.03489650f, 
    -0.05320790f, -0.07493955f, -0.04817086f, 0.00115355f, 0.01243257f, 0.04586682f, -0.05161069f, -0.00057967f, 
    -0.06202845f, 0.00739264f, 0.00792814f, -0.04496932f, 0.01545533f, 0.05295604f, -0.04543227f, -0.01501857f, 
    0.06319632f, 0.03295542f, -0.06088003f, 0.02660498f, -0.05374817f, 0.04844538f, 0.05131345f, -0.07522122f, 
    -0.01858820f, -0.00791132f, -0.07846823f, 0.01228663f, -0.06001025f, -0.01789418f, -0.05319708f, 0.03193359f, 
    0.02221547f, 0.04041668f, -0.04198466f, -0.05224775f, 0.03270287f, 0.03282404f, -0.06287204f, -0.06204461f, 
    -0.06697190f, 0.03660466f, 0.03302225f, -0.07018681f, -0.07479414f, -0.04470716f, -0.00062360f, 0.06376684f, 
    -0.06503663f, 0.03315303f, 0.00125428f, -0.02520899f, 0.01549483f, 0.00103179f, 0.02322402f, -0.04179242f, 
    -0.06020109f, 0.01535499f, 0.02081563f, -0.06384011f, 0.03728332f, -0.06494717f, -0.05812726f, 0.00000857f, 
    0.01096304f, 0.01594806f, -0.02414639f, 0.01774830f, 0.02055405f, 0.00245446f, -0.00598249f, 0.02673639f, 
    0.05245911f, 0.02592373f, -0.01629247f, 0.00397441f, -0.05104268f, -0.03036541f, 0.06019507f, -0.04444729f, 
    0.04310266f, 0.01691422f, -0.00922677f, 0.01997660f, 0.04607481f, -0.01089685f, 0.00724293f, -0.04460618f, 
    0.01026971f, -0.06272645f, 0.04025587f, -0.04849133f, -0.05527950f, 0.03661559f, -0.02014353f, 0.05872494f, 
    0.05350440f, -0.07169248f, 0.01101295f, -0.06255134f, -0.02960070f, 0.01006301f, 0.03374125f, 0.02484243f, 
    0.04639506f, 0.06390341f, -0.01106648f, 0.02662806f, -0.03966017f, -0.03723083f, -0.04502936f, 0.02963296f, 
    -0.07432023f, -0.05984656f, -0.06626449f, 0.06960619f, -0.04710064f, -0.01731461f, -0.04075437f, -0.03925671f, 
    -0.07595363f, 0.00675506f, -0.06590498f, -0.06203016f, -0.03547872f, -0.07912476f, 0.06301763f, -0.06781823f, 
    -0.05237522f, 0.05708410f, 0.04399937f, -0.05257918f, -0.07637299f, -0.07299420f, 0.02434202f, 0.02376762f, 
    0.04080924f, -0.03524855f, 0.02594137f, 0.02535534f, -0.07180192f, -0.05578502f, -0.05843681f, -0.06934635f, 
    -0.01359385f, -0.06483903f, 0.03056241f, -0.06007816f, -0.03409426f, -0.03357900f, 0.00938568f, -0.04314191f, 
    0.05440788f, -0.00924871f, 0.05334123f, -0.06806262f, 0.00691475f, -0.05587888f, 0.02193428f, -0.03385729f, 
    0.03969689f, -0.06349451f, -0.03767795f, -0.01514643f, -0.06974516f, -0.04385004f, 0.04384175f, -0.06731681f, 
    0.00131572f, 0.00539848f, -0.02402814f, 0.00215881f, -0.00697188f, -0.07068381f, 0.00075182f, -0.05388073f, 
    -0.04871323f, -0.02217306f, 0.04809700f, -0.07621454f, -0.00448950f, -0.06638680f, 0.03775765f, -0.06271737f, 
    0.01437092f, -0.07757626f, -0.07157890f, -0.00807765f, -0.06707259f, 0.05559003f, -0.00283844f, 0.02216984f, 
    0.02219009f, -0.05407612f, 0.00356475f, 0.00425287f, -0.07308643f, -0.04180535f, -0.06732838f, -0.06367961f, 
    -0.06954282f, -0.06526920f, 0.03201466f, 0.03289448f, 0.06082011f, 0.04770647f, -0.07539333f, -0.06486595f, 
    -0.01642374f, -0.06659877f, -0.02238584f, -0.04973074f, 0.01056259f, -0.05666285f, -0.06676574f, 0.00378777f, 
    0.04677288f, 0.04974917f, 0.02608688f, 0.01002184f, 0.03295077f, -0.07531594f, -0.07874026f, 0.04986369f, 
    -0.06350154f, 0.03517534f, 0.03767445f, 0.00293313f, -0.04968547f, 0.06267077f, 0.01949875f, 0.01508860f, 
    0.03149466f, 0.00800348f, 0.05695251f, 0.05973549f, 0.03855338f, -0.04034309f, 0.00749315f, 0.04037201f, 
    -0.05943631f, -0.01723832f, 0.01764253f, -0.01016967f, 0.01095681f, 0.04697602f, -0.04549643f, -0.03970226f, 
    -0.04658163f, 0.06015639f, -0.02895968f, -0.01048760f, -0.01041353f, -0.07087380f, -0.06638467f, -0.02717183f, 
    -0.04770701f, -0.00210031f, -0.02533964f, 0.03762109f, -0.07001846f, 0.05359073f, -0.01986687f, 0.01653915f, 
    -0.03695229f, 0.03350800f, 0.04788008f, -0.06176511f, -0.01186911f, 0.05960594f, -0.02903150f, -0.02450282f, 
    0.04993173f, -0.02544720f, -0.04437488f, -0.05052332f, -0.06722873f, -0.02305660f, 0.05964540f, -0.02223879f, 
    0.02623671f, 0.04039863f, 0.05118280f, -0.01524510f, -0.07581094f, -0.02981124f, 0.04770933f, 0.03692270f, 
    -0.04452568f, 0.02864654f, -0.05960998f, -0.05381443f, 0.01128917f, -0.07233498f, 0.02712602f, -0.05155892f, 
    -0.05829654f, 0.22848462f, 0.16883491f, 0.02236076f, -0.09986496f, -0.05366964f, 0.26636612f, 0.01770488f, 
    0.03929842f, 0.02276112f, -0.11427508f, 0.05842477f, -0.19253869f, 0.08819383f, -0.03610528f, 0.14557627f, 
    -0.18094161f, 0.00898587f, 0.03892235f, -0.00898944f, 0.01981804f, 0.08792204f, 0.02014598f, 0.12695228f, 
    0.24872114f, 0.19516487f, 0.23173513f, 0.28148046f, 0.09669378f, 0.29136968f, 0.18726620f, -0.04158513f, 
    -0.07996295f, -0.20292418f, -0.12000958f, -0.01783310f, 0.22937456f, 0.07754090f, -0.06334312f, 0.17672285f, 
    0.11487597f, -0.21755932f, 0.13528013f, -0.06519902f, 0.01860375f, 0.01418144f, 0.16710997f, 0.16726685f, 
    -0.19410855f, 0.19849581f, -0.10352422f, -0.14075369f, -0.10078246f, 0.00336212f, 0.02016264f, 0.13101551f, 
    0.05000383f, -0.05073544f, 0.01417329f, -0.11784697f, 0.12685385f, -0.04035631f, 0.46067151f, 0.16368675f, 
    0.07787900f, 0.09870195f, -0.04389337f, 0.03787767f, -0.01150672f, -0.13299371f, -0.14891163f, 0.15750925f, 
    -0.19955415f, -0.02252511f, 0.40814748f, 0.02362738f, 0.01966919f, 0.00081559f, -0.05842091f, 0.04774607f, 
    -0.00876689f, 0.14473414f, 0.20372835f, 0.09591687f, -0.02575909f, -0.29283890f, -0.02406192f, -0.06400670f, 
    -0.19013251f, 0.17817283f, 0.03781173f, -0.07687720f, 0.07729307f, -0.22552252f, 0.05101087f, -0.06114095f, 
    -0.62944591f, -0.10469384f, -0.06742141f, 0.05209319f, -0.11165229f, -0.12194600f, 0.00468076f, -0.04877834f, 
    0.14783226f, 0.12834114f, 0.07067127f, 0.25559944f, -0.53965795f, -0.17780448f, -0.01534119f, -0.28910181f, 
    -0.19160160f, -0.02947477f, -0.01010457f, 0.01393077f, -0.04355006f, 0.02492912f, 0.03893576f, 0.19213945f, 
    -0.14920925f, -0.07823684f, 0.31992412f, 0.04673046f, -0.43216226f, 0.14347725f, -0.20671108f, 0.00812511f, 
    -0.03579447f, 0.04695186f, 0.04481292f, -0.04054502f, -0.10457011f, -0.05523152f, 0.08602830f, -0.09781454f, 
    0.10808007f, 0.06609211f, 0.08543868f, 0.10298447f, -0.11641622f, 0.01573822f, 0.10832058f, 0.28480229f, 
    0.57613838f, -0.11384480f, -0.14970641f, -0.04994553f, 0.18375959f, 0.00939264f, -0.05592214f, 0.20732459f, 
    -0.05875622f, -0.01500231f, -0.00201880f, 0.15290588f, 0.35915905f, 0.45324987f, 0.15816964f, -0.01510773f, 
    -0.04034759f, 0.17205063f, 0.17769095f, 0.04040736f, -0.01730506f, 0.10200521f, -0.12256851f, 0.04729555f, 
    -0.11996423f, 0.10437053f, 0.42620504f, 0.04218644f, -0.16418254f, -0.14261433f, -0.11856095f, 0.02632115f, 
    0.11349054f, -0.17175564f, 0.01788810f, -0.10714618f, 0.21611609f, 0.24162318f, -0.17658827f, 0.09753119f, 
    0.05495066f, 0.05655141f, 0.18861459f, 0.09697609f, -0.00085904f, -0.07663698f, -0.14652774f, -0.16242540f, 
    -0.25700387f, -0.08261075f, -0.12405974f, 0.05548618f, -0.02886870f, -0.05686675f, 0.10040020f, 0.08783253f, 
    -0.13419613f, -0.11107890f, 0.29469064f, 0.19817479f, -0.03448554f, -0.02652649f, -0.18314143f, 0.06104162f, 
    -0.02467379f, -0.04452785f, 0.11885674f, 0.04178573f, 0.11267745f, 0.12869659f, -0.04370244f, 0.13925397f, 
    -0.18155353f, 0.02081536f, -0.12007804f, 0.21674718f, 0.00343539f, 0.02038092f, 0.07847212f, -0.09603447f, 
    0.05742161f, -0.10441826f, -0.15539640f, -0.02549745f, 0.22639620f, -0.05648150f, -0.06226806f, 0.27577272f, 
    -0.11939355f, -0.11129272f, -0.10897665f, 0.19967556f, -0.13900858f, 0.00840118f, 0.08498717f, 0.11438451f, 
    0.07694343f, 0.19505757f, -0.33685392f, 0.15303877f, 0.14584823f, 0.01162576f, 0.00086155f, -0.06506196f, 
    -0.06393801f, -0.09753434f, 0.17950547f, 0.06640643f, -0.13715951f, -0.13498844f, 0.22922412f, 0.15230024f, 
    0.01744177f, -0.11384083f, -0.15282984f, 0.13561909f, -0.08065668f, -0.06229171f, 0.08890741f, 0.12121454f, 
    0.06019343f, -0.08913141f, 0.15269634f, 0.37604457f, -0.09528252f, 0.18953669f, -0.09529640f, 0.16321388f, 
    0.18915839f, -0.05664656f, 0.10613150f, -0.00738146f, 0.17920010f, 0.09365907f, -0.01544000f, -0.23213714f, 
    0.00099870f, -0.06734183f, 0.18497470f, 0.00454810f, 0.04617294f, -0.00220931f, 0.12524727f, 0.00520368f, 
    0.05460344f, 0.06323484f, 0.07058094f, 0.23072366f, 0.13898030f, 0.17295898f, -0.09522738f, 0.04376393f, 
    -0.07711866f, 0.14314994f, 0.02841893f, -0.07766648f, 0.45900136f, -0.12157337f, 0.03663074f, 0.06382129f, 
    0.14716509f, 0.08591457f, 0.01590471f, 0.02792348f, 0.05076166f, 0.17565593f, -0.02360966f, -0.05258175f, 
    0.25574791f, -0.40887305f, -0.11776255f, 0.24949051f, 0.03290806f, 0.12622714f, -0.03354279f, 0.02768146f, 
    0.02762628f, -0.25830448f, -0.06029043f, -0.05321601f, -0.50734800f, 0.44417626f, -0.17059498f, 0.11176726f, 
    0.01743447f, -0.10499005f, 0.03043949f, 0.04130523f, -0.04685569f, 0.12060475f, -0.10527439f, -0.01812845f, 
    -0.38903075f, -0.15349284f, 0.02801372f, -0.06853773f, -0.01497736f, 0.01877479f, -0.00162355f, 0.01759839f, 
    -0.06827071f, -0.10338943f, -0.09628705f, -0.13608785f, -0.57417971f, -0.00179433f, 0.43181649f, -0.30976674f, 
    0.08889573f, 0.04829577f, -0.13131621f, 0.15349381f, 0.18591060f, 0.08596631f, 0.28116128f, 0.02299518f, 
    0.65794587f, -0.45732144f, -0.11026627f, 0.29512987f, 0.02544038f, 0.05572201f, -0.08050584f, 0.02905131f, 
    -0.27372509f, -0.11575259f, -0.00766187f, 0.05811618f, 0.43038037f, -0.07730106f, -0.28163218f, -0.00641654f, 
    -0.24042134f, -0.25948972f, -0.02525193f, -0.09206471f, 0.09189988f, -0.06432053f, 0.02667159f, 0.15402605f, 
    -0.07438669f, 0.09205128f, 0.26564115f, -0.08884829f, 0.06161625f, -0.03006456f, -0.21977495f, 0.09951624f, 
    0.10215759f, 0.11087412f, 0.02071032f, 0.02221263f, 0.36690408f, -0.19339626f, 0.24657252f, -0.21850087f, 
    0.05105550f, -0.06512184f, -0.07737330f, 0.13818896f, 0.07161026f, 0.00121863f, 0.31930101f, -0.06525944f, 
    -0.14937635f, -0.09005737f, -0.03255116f, 0.04242671f, 0.06797745f, -0.04006445f, -0.02199937f, 0.18738073f, 
    0.01218729f, 0.06930773f, 0.30940697f, -0.07064833f, -0.22012964f, -0.21106669f, -0.16214494f, -0.12217213f, 
    0.10556079f, 0.10434394f, -0.01533480f, -0.19615315f, 0.01567803f, -0.00494001f, -0.16365241f, -0.10942466f, 
    -0.04944321f, -0.06377992f, 0.21544679f, -0.18564898f, 0.17809345f, -0.00910809f, 0.03767724f, -0.00231332f, 
    0.00270696f, 0.16985086f, -0.08473234f, 0.02721186f, -0.07065263f, 0.11921928f, -0.15531728f, 0.02658589f, 
    0.21580851f, -0.01642713f, -0.01561440f, -0.03503608f, -0.14246090f, 0.03591290f, 0.35704124f, 0.03083565f, 
    -0.02249205f, 0.10779464f, 0.15468284f, -0.24990331f, 0.07554931f, 0.12486340f, 0.18139149f, 0.08347943f, 
    0.07824396f, 0.01667367f, -0.06347927f, -0.01141075f, -0.20781206f, 0.12016693f, 0.19901910f, 0.13285156f, 
    0.09760688f, -0.04884367f, -0.14347646f, 0.12395363f, -0.11469905f, -0.00993703f, -0.10938323f, 0.10822588f, 
    -0.18890916f, 0.01678157f, -0.08568608f, -0.00936260f, -0.13679263f, -0.05181584f, 0.18101729f, 0.17583269f, 
    0.08351514f, -0.18932639f, 0.01758256f, -0.13228129f, 0.28002211f, -0.04634499f, 0.13473372f, 0.33649591f, 
    0.09041567f, 0.01006175f, 0.04175916f, 0.02124176f, 0.12473529f, -0.01160483f, -0.01111815f, 0.21312357f, 
    0.01907283f, 0.18311018f, 0.13090128f, 0.20755434f, 0.30781350f, 0.09233269f, 0.05559546f, -0.17923829f, 
    0.10308480f, 0.04705025f, 0.27032560f, 0.25012696f, -0.11979974f, 0.15591811f, -0.07515516f, -0.05739075f, 
    0.09568959f, -0.03910604f, 0.10918685f, 0.10510848f, 0.04009049f, -0.05962400f, -0.06112849f, -0.00254285f, 
    -0.12025795f, -0.31015819f, -0.23028597f, -0.28799736f, -0.27675176f, 0.08300487f, -0.03456792f, 0.01336982f, 
    -0.03511530f, -0.06213710f, 0.09379885f, 0.01881389f, 0.25076202f, 0.03480893f, -0.28189591f, 0.08874587f, 
    0.01003392f, -0.19475922f, -0.02894491f, 0.09852441f, 0.08669265f, 0.02293737f, -0.13841209f, 0.13336901f, 
    0.03414983f, 0.04418212f, -0.01021023f, 0.31443846f, 0.16214207f, 0.15137132f, 0.02174719f, -0.07914212f, 
    0.23716304f, -0.02018601f, 0.00111336f, 0.01179228f, -0.40365481f, -0.34554082f, 0.18478796f, -0.07530597f, 
    -0.07941683f, 0.24560794f, -0.18775725f, -0.21315807f, -0.06403940f, 0.03263493f, 0.05412193f, 0.05588941f, 
    -0.07957772f, -0.19744672f, -0.04397962f, 0.10945819f, 0.15268369f, -0.15798004f, -0.29758486f, 0.00606606f, 
    0.03730607f, 0.25016171f, 0.02735374f, -0.02931694f, 0.13753539f, -0.07802939f, 0.11206189f, 0.03664965f, 
    0.10072533f, -0.15528347f, -0.28531420f, -0.00760191f, 0.01327284f, -0.05863914f, 0.08578281f, -0.09944424f, 
    -0.13223147f, -0.22722241f, -0.29532266f, -0.15684986f, -0.13849226f, -0.41667798f, -0.07104336f, 0.22227342f, 
    0.18637268f, 0.20299460f, 0.21754621f, -0.09686171f, -0.23815687f, -0.24705972f, -0.13593763f, -0.02867866f, 
    0.05075614f, 0.21473092f, -0.01771844f, 0.05936168f, -0.00942922f, 0.06585769f, -0.19487186f, 0.02803404f, 
    -0.58114314f, 0.00583156f, 0.38566515f, 0.14480826f, 0.10882283f, 0.12739760f, -0.08065730f, -0.03953063f, 
    0.00018681f, 0.04187225f, -0.00324302f, 0.06280542f, -0.10991962f, -0.00519295f, -0.31078538f, -0.06024299f, 
    -0.01278903f, -0.09265270f, 0.11505704f, 0.12642179f, 0.05801129f, 0.10017578f, 0.42852986f, -0.07086115f, 
    0.09309398f, 0.09907372f, 0.10908497f, -0.30064675f, 0.03846139f, -0.00977031f, 0.11545323f, 0.04999471f, 
    -0.06768343f, -0.07330471f, -0.10243785f, 0.03319698f, 0.41451505f, 0.34875208f, -0.17276345f, 0.05369657f, 
    0.04367592f, -0.29020944f, -0.09897663f, 0.00900288f, 0.05127441f, 0.09797610f, 0.00801487f, 0.15913010f, 
    0.01745308f, 0.37630963f, 0.05271522f, 0.25130615f, 0.10199620f, 0.00595786f, 0.16881353f, 0.10224986f, 
    0.23699868f, -0.11427096f, 0.02789651f, -0.12494371f, 0.10375485f, -0.02102364f, -0.16073649f, -0.05505442f, 
    0.32755953f, 0.12055355f, 0.00072258f, -0.03716460f, 0.03994028f, 0.06532899f, 0.00667012f, 0.09599952f, 
    -0.17448698f, 0.35698086f, -0.16997352f, -0.11665376f, 0.15536810f, -0.13089229f, 0.03185759f, -0.19734518f, 
    0.18100610f, 0.01858343f, 0.18565142f, 0.06250292f, -0.35352957f, -0.09017339f, -0.08472263f, -0.08848025f, 
    -0.02508765f, 0.04256889f, -0.07236053f, 0.25968525f, -0.01372535f, 0.09529848f, -0.06846479f, -0.08228467f, 
    -0.40553594f, -0.16187567f, 0.21820863f, -0.02206115f, -0.18886761f, 0.00320526f, 0.02843229f, -0.07874421f, 
    0.08897989f, 0.08521625f, 0.02351258f, -0.04958272f, 0.26945630f, -0.01077158f, 0.06595086f, 0.06561787f, 
    0.18390718f, -0.08281896f, -0.11707794f, -0.12844503f, 0.06327782f, 0.00024456f, 0.16021706f, 0.16800988f, 
    -0.16997567f, 0.15384209f, -0.04252242f, 0.00849730f, 0.17168927f, 0.09537107f, 0.06481786f, -0.02461283f, 
    0.10678289f, 0.11718899f, -0.08276761f, 0.13406490f, -0.25768834f, -0.37592852f, 0.23385870f, 0.19851312f, 
    -0.01633962f, 0.17803498f, -0.12602784f, 0.00740574f, 0.07184198f, 0.02027849f, 0.10612516f, 0.03738622f, 
    0.24209729f, 0.27708337f, -0.19631772f, 0.42503142f, 0.10989233f, 0.04312019f, 0.09334043f, 0.01303043f, 
    -0.09652461f, 0.01212395f, -0.09540199f, 0.08577041f, 0.18115376f, 0.00510706f, 0.13935743f, 0.51104027f, 
    -0.28939354f, 0.19498055f, 0.02859481f, 0.02044706f, 0.05400816f, 0.04615958f, 0.16921999f, -0.00745317f, 
    -0.01600053f, -0.30102158f, 0.03406487f, 0.01631273f, 0.06026531f, -0.00308401f, 0.21230632f, 0.10815461f, 
    -0.01785778f, 0.10161555f, -0.12682080f, 0.06127860f, -0.19104469f, -0.31065962f, -0.09518643f, -0.00332523f, 
    -0.13406226f, -0.05696682f, -0.12595634f, 0.14542486f, 0.06910098f, 0.01493920f, 0.11900354f, 0.32470641f, 
    -0.01091614f, -0.39787307f, -0.22339466f, 0.19264631f, 0.21684964f, -0.00546195f, -0.04936814f, 0.05217177f, 
    -0.12853049f, 0.02164339f, 0.04597408f, -0.11418063f, -0.37281185f, -0.09479872f, 0.17244402f, -0.05239940f, 
    0.13442881f, 0.01255602f, 0.14656776f, 0.13661073f, 0.01258398f, -0.08900521f, -0.07194414f, 0.13956955f, 
    -0.58956450f, -0.27645779f, -0.14459309f, -0.28696132f, -0.02252806f, 0.15636201f, 0.09574188f, -0.15771817f, 
    0.26140249f, 0.00992387f, 0.16147445f, 0.22756912f, 0.15913400f, 0.19597825f, -0.02661015f, 0.02931995f, 
    -0.01100255f, -0.01802196f, 0.05139605f, -0.15965730f, 0.08133768f, -0.01299506f, -0.03905478f, -0.11872134f, 
    -0.12849037f, 0.10928082f, 0.11688328f, 0.13414302f, -0.03528511f, 0.00549192f, -0.20543936f, -0.11398298f, 
    0.08356915f, 0.03016491f, 0.09883355f, 0.06712864f, -0.22437562f, -0.02597749f, 0.28869167f, 0.14694850f, 
    0.10077123f, 0.02784744f, -0.13802262f, 0.12974381f, 0.01447903f, 0.16331467f, -0.03977838f, 0.01711219f, 
    0.26508453f, 0.22004218f, 0.27608702f, 0.38212547f, -0.05561489f, 0.05965141f, -0.12296510f, 0.02245072f, 
    0.10408174f, 0.00126018f, 0.04645701f, 0.01872639f, -0.03204426f, -0.07689081f, -0.14261730f, 0.09471603f, 
    -0.05456892f, 0.08884746f, 0.08043757f, 0.05437493f, 0.00968577f, 0.08498371f, 0.07121374f, 0.14583039f, 
    0.20919983f, -0.15786853f, 0.02701001f, -0.26470345f, 0.20142835f, -0.11565430f, -0.02010078f, -0.07970574f, 
    -0.12765689f, 0.06868923f, 0.00516429f, 0.05738582f, 0.40887287f, 0.51952368f, -0.16855270f, -0.10024366f, 
    0.00187056f, 0.02903134f, 0.21982551f, 0.17686234f, -0.07752483f, 0.00854829f, 0.23327677f, 0.03577678f, 
    -0.16786709f, -0.00439634f, 0.38868409f, 0.35686469f, -0.05558684f, 0.07312729f, -0.09160256f, -0.04871324f, 
    0.14488672f, -0.04412887f, 0.04385781f, -0.12178682f, -0.12003066f, -0.15389524f, 0.20183010f, 0.11315047f, 
    -0.00510434f, 0.05073980f, 0.10882271f, 0.22821406f, 0.12387928f, 0.00153575f, -0.00226215f, -0.04194195f, 
    -0.02537618f, 0.04849897f, 0.04753812f, -0.06340969f, 0.03171245f, 0.01375696f, -0.00554060f, -0.05095962f, 
    -0.05019844f, 0.00231749f, 0.06241119f, 0.06256738f, 0.02876027f, -0.05906728f, 0.04828593f, -0.05240509f, 
    -0.05522387f, 0.03410807f, 0.00655008f, 0.05271314f, -0.02009372f, 0.05812005f, 0.05515623f, 0.03577824f, 
    -0.01784720f, 0.05742746f, 0.02274360f, -0.03004169f, -0.03926976f, -0.03606577f, 0.01650632f, -0.07151883f, 
    -0.00894748f, 0.02122875f, -0.00418801f, -0.06775027f, -0.04972826f, 0.03127684f, -0.06825694f, 0.06228612f, 
    0.00490342f, 0.02427541f, -0.01511596f, 0.00384181f, -0.03205015f, 0.01146800f, 0.02378590f, -0.03033858f, 
    -0.00703429f, 0.05203047f, -0.05428002f, -0.07653435f, 0.04461557f, -0.04763029f, -0.00053786f, -0.03314987f, 
    -0.01784485f, -0.03744016f, 0.00628597f, 0.05858088f, -0.01264707f, 0.03271271f, 0.01226271f, 0.03515650f, 
    0.00162655f, -0.00891155f, -0.00436748f, -0.05952082f, -0.04940283f, -0.05990858f, -0.05661099f, -0.03781260f, 
    0.01877835f, -0.04875440f, -0.07466707f, 0.05165400f, -0.08013382f, -0.03533421f, -0.05780540f, -0.06311236f, 
    -0.05921528f, -0.04876896f, -0.03654568f, -0.04433851f, -0.07854839f, 0.01164740f, 0.00396901f, 0.03770494f, 
    -0.05598652f, -0.04198365f, 0.01000862f, -0.00669933f, -0.05381722f, 0.04777909f, -0.07634209f, -0.02527898f, 
    -0.06972890f, 0.03497595f, 0.04745105f, 0.05055825f, -0.03994462f, -0.02244605f, -0.07064445f, 0.01015279f, 
    0.01020432f, -0.05113702f, -0.00522371f, 0.05858038f, 0.04492949f, -0.07449173f, -0.02336770f, 0.03213316f, 
    0.04040609f, -0.00184514f, -0.00655805f, -0.01398433f, 0.02535379f, -0.02332573f, -0.00532369f, -0.07136855f, 
    -0.01784106f, -0.03982150f, -0.05222094f, -0.05921901f, -0.01243549f, 0.01758670f, 0.05917164f, 0.05779668f, 
    -0.03055199f, -0.07194735f, 0.05387089f, -0.02399400f, 0.00063550f, 0.04538589f, -0.07037053f, 0.01216360f, 
    0.01612022f, -0.02642073f, -0.03187324f, 0.01223431f, -0.05450086f, -0.05688254f, -0.05713047f, -0.01696969f, 
    0.03294546f, 0.02715678f, -0.02646824f, -0.07820157f, -0.06344355f, -0.04363918f, 0.04587362f, 0.01767207f, 
    -0.00353822f, -0.00726972f, -0.03624482f, 0.02623850f, 0.01625206f, 0.05301762f, -0.04012819f, -0.07507227f, 
    0.06029170f, -0.03488720f, -0.03781053f, -0.07385434f, 0.05497847f, 0.05213450f, 0.03721776f, -0.05224730f, 
    -0.01793152f, -0.01915099f, 0.01810547f, -0.07932496f, -0.04402179f, 0.00993365f, 0.01652132f, 0.01614858f, 
    -0.02630030f, -0.07127794f, 0.03582801f, -0.03843375f, -0.02922136f, -0.00768872f, 0.04449086f, -0.03512534f, 
    0.05768616f, -0.03064816f, 0.03396291f, 0.01315125f, -0.04695493f, -0.03605827f, -0.00565025f, 0.02751203f, 
    0.15639128f, 0.11288433f, -0.19463891f, 0.38770339f, -0.04471326f, -0.04617418f, -0.15690669f, 0.12772153f, 
    0.08036643f, 0.07431314f, 0.12747540f, 0.26354301f, 0.25184804f, -0.20099708f, 0.01093922f, 0.19966242f, 
    -0.03608937f, -0.04498067f, 0.09254999f, 0.01953800f, 0.05575940f, 0.06920433f, 0.15235554f, -0.05562575f, 
    -0.12362074f, 0.04270103f, 0.05459085f, 0.01032315f, 0.05513484f, 0.10527247f, -0.11970127f, 0.14327890f, 
    0.08773603f, 0.09745754f, 0.12511159f, -0.04169380f, -0.23244727f, -0.27845958f, 0.01905876f, -0.19409521f, 
    -0.00277050f, 0.04124894f, 0.01450160f, 0.07504413f, 0.03459805f, 0.00436546f, 0.03953435f, 0.09673057f, 
    0.35462099f, -0.30234882f, -0.19999674f, 0.06537832f, 0.24884085f, 0.06946915f, 0.12848273f, 0.09783805f, 
    0.01903515f, 0.01464322f, 0.02860505f, 0.02744656f, -0.13997255f, 0.05057351f, -0.06789041f, -0.12259086f, 
    0.12513131f, -0.02738262f, 0.16101849f, 0.08141454f, -0.05735254f, -0.14716586f, -0.07170378f, 0.01511127f, 
    -0.25225815f, -0.11101303f, -0.08048043f, -0.09349667f, -0.02201399f, 0.15831247f, 0.15282348f, -0.12010495f, 
    0.19266027f, -0.12868290f, 0.11614204f, 0.15220413f, -0.20336163f, 0.29112896f, 0.06424458f, 0.08822574f, 
    -0.08985955f, 0.07673229f, 0.02109302f, 0.03118368f, 0.10959133f, 0.07201875f, 0.02898766f, 0.04033237f, 
    0.25996765f, -0.01718491f, -0.01913358f, -0.12689124f, 0.02143851f, -0.00633172f, 0.07720478f, 0.21034282f, 
    -0.00154608f, -0.10248130f, 0.13623470f, 0.07046402f, 0.23215136f, -0.13010536f, 0.21058227f, 0.22436817f, 
    0.11129848f, 0.00588343f, -0.02510696f, 0.02144086f, 0.20665623f, 0.12387419f, -0.06749158f, 0.03040203f, 
    0.48793605f, -0.09454410f, 0.03576992f, 0.11473793f, 0.08517241f, 0.07780881f, -0.03329237f, 0.02355283f, 
    0.08708794f, 0.12085982f, 0.05387088f, 0.10993310f, -0.14102520f, 0.36453813f, -0.14902882f, 0.14561285f, 
    -0.04853992f, -0.03632022f, 0.18484624f, -0.07165515f, 0.02573843f, -0.08745675f, -0.05142427f, 0.11180784f, 
    0.01173078f, -0.19174439f, 0.14761534f, -0.33814782f, -0.12743460f, 0.05872160f, 0.09006477f, -0.01803057f, 
    -0.11033425f, 0.00240366f, 0.02973546f, 0.03691243f, -0.02172078f, 0.25092447f, -0.25489867f, -0.20780607f, 
    -0.20750010f, -0.05791622f, 0.07761026f, 0.09532385f, 0.07821915f, 0.09154488f, 0.13944854f, 0.10768620f, 
    0.26991349f, -0.02442154f, 0.08994032f, -0.03844175f, 0.03254827f, 0.10227303f, -0.01774736f, 0.08149060f, 
    0.17325136f, 0.02001279f, 0.00461803f, 0.04006024f, -0.00565413f, -0.10134809f, 0.08673898f, -0.22686385f, 
    0.02034854f, -0.01277640f, 0.11889884f, 0.06910376f, 0.00380232f, 0.03094322f, 0.12262652f, 0.03566957f, 
    0.15198152f, 0.09959456f, 0.26453701f, 0.22129108f, -0.12508738f, -0.07295908f, 0.23517519f, -0.18395215f, 
    0.26649600f, -0.23178288f, 0.04237926f, -0.09055420f, 0.06174118f, -0.04880212f, 0.18864290f, 0.46398604f, 
    0.02682333f, -0.07259709f, 0.00240433f, -0.15390016f, -0.11905903f, 0.09117775f, -0.10664357f, -0.01193881f, 
    0.13526665f, 0.02682019f, 0.35951319f, -0.19740690f, 0.06693704f, 0.23570789f, 0.07863020f, -0.13421550f, 
    -0.06781457f, 0.15659501f, 0.12021237f, 0.06238661f, -0.27884650f, 0.02086409f, 0.25841168f, 0.18891986f, 
    -0.02229157f, 0.03343632f, 0.12338071f, -0.23117314f, -0.00985586f, 0.10417158f, 0.10653150f, -0.21406390f, 
    0.22357981f, -0.22376740f, -0.27168268f, 0.16653366f, 0.04828915f, -0.07443678f, 0.04894192f, -0.01934045f, 
    0.17328788f, 0.08032473f, -0.08606163f, -0.07186744f, 0.05728020f, -0.00685704f, 0.08654400f, -0.12297120f, 
    -0.11083024f, 0.02797684f, 0.11933558f, 0.02465471f, -0.18624842f, -0.02525018f, -0.30678353f, 0.09285773f, 
    -0.08557003f, 0.05085878f, -0.25583354f, 0.29883832f, -0.14141840f, 0.04032765f, -0.09553915f, 0.12319629f, 
    0.00832467f, -0.10734270f, 0.08866318f, 0.13775866f, 0.49977437f, -0.00062270f, 0.32090783f, 0.21908860f, 
    0.11046524f, 0.01969373f, -0.00874330f, -0.33647788f, -0.18632074f, 0.18040232f, 0.11589867f, 0.06659265f, 
    0.31165826f, -0.02865418f, -0.34104109f, -0.43725055f, -0.11531738f, 0.19106878f, -0.22517076f, 0.05760247f, 
    -0.05219354f, -0.06153348f, -0.04654421f, 0.17565134f, 0.07314008f, 0.21042573f, 0.21194670f, -0.10474115f, 
    -0.37792802f, -0.04597894f, 0.08379482f, -0.00841361f, -0.07771210f, -0.10232919f, 0.06449579f, -0.10521757f, 
    0.38047472f, 0.29445758f, -0.10340974f, 0.17681652f, -0.14347519f, 0.26560816f, -0.06264104f, 0.22358027f, 
    -0.21102650f, -0.02836494f, -0.04200109f, -0.02350971f, 0.07245804f, 0.02191182f, 0.14887248f, 0.24522476f, 
    0.14338307f, -0.12700756f, 0.09607895f, 0.03586877f, -0.02807668f, -0.04158387f, -0.06599553f, 0.10826590f, 
    0.10219719f, 0.05682983f, 0.02567031f, -0.44658485f, 0.37009230f, 0.02437073f, 0.13349649f, -0.02582808f, 
    0.00930410f, 0.13002045f, 0.08078901f, 0.09486905f, 0.00293226f, -0.43761906f, 0.19136894f, 0.09905959f, 
    -0.07452665f, 0.01492624f, -0.06688657f, 0.00447435f, -0.02578841f, 0.05196870f, 0.11662646f, 0.06701244f, 
    0.03473247f, -0.00789404f, -0.13998747f, -0.51121891f, 0.01660294f, 0.12066120f, 0.03914454f, 0.13509619f, 
    -0.19122964f, -0.02404557f, 0.03755595f, -0.04202833f, -0.40184820f, -0.27736130f, -0.00856708f, -0.23765631f, 
    -0.09169861f, -0.02881541f, -0.04790394f, 0.09161152f, -0.02825757f, -0.05358765f, 0.04260875f, -0.00617059f, 
    -0.14096299f, 0.10045752f, 0.04681448f, 0.19367135f, -0.01469272f, 0.04223383f, 0.11072057f, -0.19386862f, 
    0.01197212f, 0.04375943f, 0.06426654f, 0.00433705f, -0.39135769f, 0.13599442f, -0.14703394f, 0.24966593f, 
    -0.12761407f, 0.10603276f, -0.17113912f, -0.01108333f, -0.00497865f, -0.07263092f, -0.12271716f, 0.08526342f, 
    0.19462126f, -0.12643084f, -0.07420614f, 0.22396059f, -0.00453825f, -0.19933179f, 0.16489445f, -0.13875467f, 
    0.06504811f, 0.14952323f, -0.02253796f, 0.08368640f, 0.27472559f, 0.29726920f, -0.34241164f, 0.38116977f, 
    0.14812277f, 0.37161690f, 0.11230117f, 0.04471670f, 0.06807087f, 0.01481592f, -0.01312869f, -0.00870209f, 
    -0.86172307f, 0.26651892f, 0.05539649f, 0.07685311f, 0.07008816f, 0.09711938f, -0.04516894f, -0.08226676f, 
    0.10627697f, -0.01216536f, 0.00230974f, 0.10050128f, -0.03842932f, -0.16370060f, 0.11891741f, 0.29268163f, 
    -0.04814549f, -0.00063812f, -0.13291208f, 0.02545810f, -0.13482146f, 0.19990662f, 0.22279437f, 0.18610075f, 
    -0.04950127f, 0.18774220f, 0.00686090f, 0.17329866f, -0.23323216f, 0.26016283f, -0.17888264f, 0.22849771f, 
    -0.09410366f, 0.13580842f, -0.03762281f, -0.02101024f, 0.38596529f, 0.25166881f, 0.01037201f, -0.06320056f, 
    -0.10225836f, -0.02924295f, 0.04507314f, -0.21038902f, 0.21333106f, -0.04197840f, 0.06746078f, 0.04517752f, 
    -0.34860027f, 0.33139226f, -0.01691762f, -0.02697970f, 0.09835753f, 0.02483906f, -0.03058312f, -0.09686188f, 
    0.23008418f, 0.01528275f, 0.00168690f, -0.00012187f, -0.18174130f, 0.06017202f, 0.06197819f, -0.08623662f, 
    0.16100149f, 0.21626651f, 0.10583276f, -0.12770107f, -0.17221864f, -0.07470622f, -0.04636009f, -0.00244493f, 
    -0.40165395f, 0.18222889f, 0.15196890f, -0.05269610f, -0.18134359f, -0.04848767f, 0.11746771f, -0.03981789f, 
    -0.03754650f, -0.06660153f, 0.12885709f, 0.04576793f, -0.18223675f, -0.00966066f, -0.22660173f, -0.11568509f, 
    0.20288868f, 0.11723181f, -0.14306885f, 0.25623944f, -0.02637986f, 0.11133305f, -0.10513202f, -0.00408460f, 
    -0.14439005f, -0.05328680f, -0.27291819f, 0.09160099f, 0.19885434f, -0.03374054f, -0.19140291f, 0.13810061f, 
    0.24692135f, 0.10313351f, -0.01086377f, 0.03712227f, 0.36253628f, -0.19956750f, 0.47304040f, 0.07217196f, 
    0.19791785f, -0.01022300f, 0.00929862f, 0.00686205f, 0.21685962f, -0.12549207f, -0.00287116f, -0.00242709f, 
    0.15131889f, -0.10292839f, 0.04985882f, 0.11672867f, 0.01765856f, -0.00335425f, 0.08184352f, -0.16788715f, 
    -0.20531972f, -0.02575866f, -0.15666109f, 0.24858236f, 0.00720683f, -0.31230238f, -0.32690951f, 0.23888144f, 
    0.03195637f, 0.17248760f, -0.15242849f, -0.05643273f, -0.05375593f, -0.08699782f, -0.12277394f, 0.02288046f, 
    0.17186250f, 0.19574805f, -0.18180634f, -0.04266140f, 0.05853234f, 0.01504459f, -0.19427843f, 0.01984648f, 
    0.11761686f, -0.08290088f, -0.16473807f, -0.00453856f, 0.05603985f, 0.12431245f, 0.19723582f, -0.05598480f, 
    0.15533543f, 0.06696685f, 0.04225532f, 0.08292934f, -0.03652371f, -0.04110907f, 0.02516789f, -0.01197722f, 
    -0.03972150f, 0.08224511f, -0.06526710f, -0.25948223f, 0.08230850f, 0.02582871f, -0.13057595f, 0.21697435f, 
    0.01785834f, 0.03911407f, 0.02909312f, 0.12988989f, -0.32484749f, -0.24365732f, -0.05530233f, -0.09354918f, 
    -0.19974378f, -0.04179357f, -0.05027312f, 0.17836179f, 0.09661110f, -0.08547252f, 0.05536894f, 0.09040626f, 
    0.51877409f, -0.31351182f, -0.19298963f, 0.09093792f, -0.00915939f, 0.08464972f, 0.02462600f, 0.16414973f, 
    0.06043832f, -0.04943883f, -0.08991104f, 0.08887915f, 0.17326635f, 0.03911627f, -0.50674647f, -0.35205027f, 
    0.07961179f, 0.02807461f, 0.22839169f, 0.07103115f, 0.03189228f, 0.12388441f, -0.04130206f, -0.12689200f, 
    -0.10635551f, 0.14622274f, -0.23296578f, -0.21290277f, 0.08602525f, -0.06236582f, 0.09632450f, -0.08465040f, 
    0.03172263f, -0.03013236f, 0.04789288f, -0.05242936f, -0.11136891f, 0.15303198f, 0.01655389f, 0.15293750f, 
    0.08252305f, -0.07647187f, 0.00455628f, 0.11696681f, -0.02962471f, 0.19461897f, -0.01982518f, 0.00592844f, 
    0.53328770f, -0.02933038f, 0.19394709f, -0.08107930f, 0.09414764f, -0.04921156f, -0.01934434f, 0.24773970f, 
    -0.06556598f, 0.03360952f, -0.12827435f, 0.05743337f, -0.11493708f, 0.36780959f, 0.18070526f, -0.03422877f, 
    -0.04663222f, -0.08670625f, -0.02343115f, 0.00499609f, 0.07244036f, -0.09170483f, 0.09338092f, -0.01493654f, 
    -0.02800066f, 0.10755995f, 0.09854280f, -0.24485499f, 0.23092546f, -0.03530756f, 0.04183728f, 0.00016858f, 
    -0.06734472f, 0.16080301f, -0.10627467f, 0.01996400f, 0.62695712f, -0.11813630f, -0.12403788f, 0.27403268f, 
    -0.16568033f, 0.03847385f, 0.02175868f, 0.07343675f, 0.07206345f, 0.00289713f, 0.16324632f, -0.10721645f, 
    0.12755914f, 0.24367861f, -0.11971222f, -0.07882814f, -0.05475267f, -0.16291107f, 0.06516951f, 0.02902704f, 
    -0.05122249f, 0.02969791f, 0.08350959f, 0.05773191f, -0.17119658f, -0.22238900f, -0.23461977f, -0.00113481f, 
    -0.14738216f, -0.06341935f, -0.01077432f, 0.01065967f, -0.04676422f, -0.00356131f, 0.14033930f, -0.05287121f, 
    -0.32135156f, 0.21358392f, -0.03055470f, -0.31285349f, 0.10366527f, 0.03993066f, 0.15078549f, -0.03303169f, 
    -0.11569460f, 0.02696999f, 0.08624236f, 0.02908019f, -0.29092571f, -0.06224679f, -0.03308121f, -0.08257242f, 
    -0.04564215f, -0.05810915f, 0.01797305f, 0.17786978f, -0.11136504f, -0.01169247f, -0.10644519f, 0.05007445f, 
    -0.26457825f, -0.05023220f, -0.22359702f, 0.29046831f, -0.01785106f, -0.12615690f, -0.17456463f, 0.02690190f, 
    -0.11333247f, 0.01193923f, 0.27490434f, -0.04124499f, -0.32138687f, -0.11696529f, -0.12024979f, 0.23641206f, 
    -0.09322814f, -0.13434885f, -0.08547170f, 0.00466474f, 0.06710443f, -0.06739748f, -0.03509677f, -0.02386910f, 
    0.19364586f, -0.09893545f, 0.07287309f, -0.08868836f, 0.10947281f, -0.26066062f, -0.01790955f, 0.10507085f, 
    -0.00758604f, 0.20581667f, -0.02415581f, 0.25196680f, 0.15764375f, -0.44838831f, 0.10529117f, 0.09698546f, 
    0.00787621f, 0.24225464f, 0.13985929f, 0.03815748f, -0.05692202f, -0.04482312f, -0.18196759f, -0.09340987f, 
    -0.08377641f, -0.20457946f, -0.28760731f, 0.22395588f, 0.21986637f, 0.15636282f, 0.10294142f, -0.02068056f, 
    0.07003317f, -0.01693216f, 0.11705907f, 0.13108829f, 0.47698703f, 0.19416031f, 0.07534209f, 0.19787745f, 
    0.02152660f, 0.01899573f, -0.08218118f, -0.05705543f, -0.12708764f, 0.06400951f, 0.16832411f, 0.03119284f, 
    -0.29521066f, 0.28974804f, 0.06012310f, 0.31064248f, 0.05400987f, 0.12640022f, -0.01219960f, 0.27917811f, 
    0.13618511f, 0.00109026f, -0.15777281f, -0.06250167f, -0.06830270f, 0.33523223f, -0.05837072f, 0.00770300f, 
    -0.06536844f, -0.13361588f, -0.02883517f, -0.05998904f, 0.18157394f, 0.33069372f, 0.29522157f, 0.03640850f, 
    0.35484552f, 0.24334309f, -0.04102109f, -0.14531621f, -0.02170295f, 0.08298631f, 0.11631896f, 0.19984362f, 
    0.01390138f, 0.10565981f, 0.01631428f, 0.01643215f, -0.28412044f, -0.12894562f, -0.00742071f, -0.19890866f, 
    0.19622800f, 0.11923239f, 0.03232437f, -0.06071327f, 0.10891747f, -0.00041164f, -0.13679709f, -0.23132902f, 
    -0.58610350f, -0.29591247f, 0.08143983f, 0.16667300f, -0.03075645f, -0.08011632f, 0.11449829f, -0.03146634f, 
    0.15794328f, 0.07284146f, 0.18247402f, 0.12383176f, 0.01649889f, -0.01959391f, -0.04851476f, -0.00086991f, 
    0.04245852f, 0.18043566f, -0.04312789f, 0.19140513f, 0.02849782f, 0.05926601f, -0.31960815f, -0.12430158f, 
    -0.17476591f, -0.09862006f, 0.05035017f, -0.00258836f, 0.03890571f, -0.03155146f, 0.11901999f, -0.00705178f, 
    0.11381311f, 0.00443025f, -0.09068558f, -0.19820786f, -0.42243296f, 0.23871776f, 0.08224308f, -0.36624706f, 
    -0.03574455f, -0.01773340f, -0.29982036f, 0.02738813f, 0.13264562f, -0.03411980f, 0.13681224f, -0.12417478f, 
    -0.00802076f, -0.05423027f, -0.05818166f, 0.05339490f, -0.01294764f, 0.06895240f, 0.13601266f, -0.01808469f, 
    -0.03048615f, 0.31197068f, -0.01702111f, 0.33525059f, -0.15251096f, 0.01007123f, -0.21566491f, -0.18204492f, 
    0.03352590f, -0.01124296f, -0.00900293f, 0.10777695f, 0.08139668f, -0.05708082f, 0.14578339f, 0.19152485f, 
    -0.32400453f, -0.10268109f, 0.15151797f, -0.44672936f, -0.05135337f, -0.08825890f, 0.03954085f, -0.01724149f, 
    0.04981534f, -0.02104813f, 0.01384019f, 0.00660758f, -0.02449773f, -0.02641467f, -0.07739859f, -0.52475071f, 
    0.26322836f, -0.11570266f, -0.08802420f, -0.04778660f, 0.08376317f, 0.14045419f, -0.01988042f, 0.15576300f, 
    -0.11196098f, 0.37126729f, -0.01360810f, 0.23763587f, -0.00600649f, 0.10825431f, -0.08900330f, -0.08593334f, 
    -0.04540887f, -0.08257864f, -0.09058669f, -0.04159503f, 0.20715310f, 0.24914163f, 0.16419949f, 0.24320531f, 
    0.04820951f, -0.13563775f, -0.10788271f, 0.14556785f, -0.10695663f, 0.03498367f, 0.16871315f, 0.02850511f, 
    0.37765467f, 0.18303029f, 0.15495521f, -0.12273879f, -0.17338681f, -0.01169117f, 0.11615548f, -0.02905634f, 
    0.04762900f, 0.09231201f, 0.07842284f, 0.03356377f, 0.23331523f, 0.13872841f, -0.15118347f, 0.04765434f, 
    0.07947638f, -0.00605572f, -0.14879805f, -0.16031846f, 0.12695466f, 0.10739568f, 0.05196785f, 0.05175880f, 
    0.55836725f, 0.15459305f, 0.26329580f, 0.29538319f, 0.12096142f, -0.06084863f, -0.04251693f, 0.07878562f, 
    0.00399067f, 0.12715410f, 0.12940159f, -0.09866203f, 0.13502330f, -0.24459554f, 0.08762924f, -0.23778838f, 
    0.07407711f, 0.12401767f, -0.03550409f, 0.20279559f, -0.09761963f, -0.08943765f, 0.16786091f, 0.04839738f, 
    -0.05613570f, -0.12058805f, 0.06237625f, 0.10504342f, 0.01373218f, -0.02369264f, 0.19596466f, 0.17455947f, 
    -0.03819132f, 0.00306816f, 0.03020983f, -0.12263443f, 0.19599682f, -0.00155261f, -0.12872030f, 0.10834381f, 
    0.07262424f, 0.04627532f, 0.09078079f, -0.07336126f, 0.15255992f, -0.02849799f, 0.01729575f, 0.11440226f, 
    -0.36440533f, -0.18955927f, -0.16692929f, -0.11661028f, 0.13968888f, 0.07532828f, 0.08921103f, -0.04152676f, 
    -0.05965123f, -0.07866424f, -0.12417291f, -0.02703607f, 0.13095871f, 0.04405687f, 0.02565852f, 0.15155979f, 
    0.05579992f, 0.05715863f, 0.06083405f, -0.06923183f, -0.05273158f, 0.15806249f, 0.10369104f, 0.04400319f, 
    0.05575133f, 0.05179315f, -0.14245775f, 0.16545060f, -0.05946825f, 0.15126787f, -0.02597131f, 0.10619529f, 
    0.07048094f, -0.08008032f, 0.08969872f, 0.05379681f, -0.37081811f, -0.30290651f, 0.05588040f, -0.06383377f, 
    -0.02161930f, 0.01137079f, -0.15265721f, 0.20330124f, 0.06160049f, 0.14931718f, 0.02400037f, -0.00657422f, 
    0.26485342f, -0.05142333f, -0.15200906f, 0.02349863f, 0.10755302f, -0.02835787f, -0.02749143f, 0.04688815f, 
    -0.06756316f, -0.09969559f, 0.14538370f, 0.00591856f, 0.20045733f, 0.20885971f, -0.35593829f, 0.00129386f, 
    -0.10575941f, -0.00919042f, -0.05195726f, -0.22721894f, -0.03657068f, 0.02158489f, -0.12598465f, 0.12272335f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.02806707f, 0.16853471f, -0.07074929f, 0.04015989f, -0.05920113f, -0.06834225f, -0.05846367f, -0.01883821f, 
    -0.02644240f, 0.11607844f, -0.01277962f, -0.01557863f, 0.07083242f, -0.17101163f, 0.13775441f, 0.22706379f, 
    -0.03099681f, 0.00307178f, 0.03824480f, 0.00294229f, -0.06379467f, 0.16697694f, 0.15330116f, 0.11619499f, 
    -0.01098322f, 0.03135486f, 0.12841898f, -0.05446600f, -0.02965006f, 0.03004395f, 0.12494872f, 0.24075274f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10763241f, -0.17274112f, 0.09486992f, -0.03759910f, 0.02083889f, -0.11789901f, -0.18436198f, -0.58515376f, 
    0.13885050f, -0.11255725f, 0.53392887f, -0.11418302f, 0.19283722f, -0.03582616f, 0.42116296f, 0.36008471f, 
    0.03441345f, -0.14406800f, -0.00984312f, -0.13436253f, 0.14486153f, -0.07969939f, 0.25768536f, 0.05570031f, 
    0.21049175f, -0.01760624f, 0.02104527f, -0.20797446f, 0.21840800f, -0.18129030f, -0.02860239f, -0.17114076f, 
    -0.05768121f, 0.48333216f, 0.20068344f, -0.05784058f, 0.06942321f, 0.12430877f, 0.47101530f, 0.25311384f, 
    -0.00926196f, -0.02465129f, -0.37168974f, -0.16193268f, -0.29831040f, -0.04121570f, -0.39258656f, -0.19323398f, 
    -0.00152493f, -0.15120317f, -0.08762126f, -0.10729538f, -0.03544022f, 0.36523631f, 0.03203152f, 0.06490403f, 
    0.45172077f, 0.16539320f, 0.22909759f, 0.11392314f, 0.01959999f, -0.01529527f, 0.54158157f, -0.27968436f, 
    -0.05981313f, -0.19312228f, -0.07583206f, 0.10448026f, -0.09522849f, 0.14045049f, 0.07289450f, -0.15002176f, 
    -0.14335850f, 0.07990564f, -0.06609938f, -0.13691778f, -0.07799621f, 0.07746598f, -0.19485933f, -0.12954177f, 
    0.16686779f, 0.02080830f, -0.03416105f, 0.05200738f, -0.15915270f, 0.00837497f, 0.11627375f, 0.06754235f, 
    0.01459569f, -0.07870007f, -0.06863132f, -0.15551828f, -0.00316887f, 0.11190055f, -0.07061588f, -0.01119049f, 
    0.21618734f, -0.38828075f, -0.47604588f, 0.15057893f, 0.17519201f, 0.08038799f, 0.44415498f, 0.31961232f, 
    -0.09316617f, -0.06930933f, -0.15116203f, 0.51708966f, 0.30486327f, 0.02969480f, -0.32284093f, -0.15084405f, 
    0.04492502f, -0.03270566f, -0.10482711f, 0.08926521f, 0.28706577f, -0.33849820f, 0.10534533f, -0.08026919f, 
    0.13579364f, 0.00068103f, -0.11539032f, 0.16383885f, 0.11181147f, 0.19313462f, -0.58359468f, 0.09441329f, 
    -0.01102409f, 0.57918125f, 0.50809985f, 0.10604796f, -0.13511050f, 0.08691800f, -0.14902492f, -0.08001469f, 
    -0.09186917f, 0.03519464f, -0.01581695f, 0.21490295f, 0.01038163f, 0.49530599f, -0.41716903f, -0.12484479f, 
    0.09001896f, 0.06924141f, -0.16917075f, -0.00082958f, 0.50294209f, -0.24442835f, 0.10114728f, -0.33311054f, 
    0.44213620f, -0.06313030f, 0.22914293f, -0.23716098f, 0.05233216f, -0.19222313f, -0.37803409f, -0.31312424f, 
    0.57196611f, -0.19366147f, 0.60914522f, 0.05940856f, -0.08950429f, -0.04128789f, 0.79857641f, -0.16613716f, 
    0.16722141f, 0.14528537f, 0.54595757f, -0.05940251f, -0.07875068f, 0.29611295f, 0.17507029f, -0.21765065f, 
    0.02299965f, 0.08239178f, -0.01100873f, 0.14708081f, -0.07307840f, -0.05947665f, -0.11397348f, 0.28158486f, 
    0.36832917f, 0.02814126f, 0.26052889f, 0.53836513f, 0.18061839f, 0.28356788f, -0.13108839f, -0.45290178f, 
    0.20407642f, 0.34519783f, 0.72724962f, -0.03126597f, -0.05707604f, -0.16791031f, -0.03521523f, -0.11423082f, 
    0.01031970f, 0.18770374f, -0.28225645f, -0.06601713f, 0.32182607f, 0.10808976f, 0.42696828f, 0.27682725f, 
    0.16205736f, 0.06911535f, -0.02417758f, -0.03539977f, -0.04691368f, 0.18506572f, 0.01546419f, -0.30206624f, 
    -0.22948776f, -0.06060550f, 0.21145432f, -0.31761846f, -0.38685539f, 0.22208981f, -0.41456267f, 0.40640897f, 
    0.03007262f, -0.11434509f, 0.09762041f, 0.01924708f, 0.00318088f, -0.16634804f, 0.11419244f, -0.02922883f, 
    0.13566568f, -0.04006569f, 0.03375653f, -0.16463295f, -0.08635803f, -0.14906049f, -0.16187240f, -0.04716875f, 
    -0.00402698f, 0.14983165f, 0.15903042f, 0.07387051f, -0.10566816f, 0.09956142f, 0.07783914f, 0.01931218f, 
    -0.12646230f, -0.00533321f, -0.03327042f, -0.09101994f, 0.13151419f, -0.07635538f, -0.09969151f, -0.10492699f, 
    0.17423688f, -0.64407521f, -0.27818319f, 0.12964994f, -0.01265555f, 0.00670293f, 0.35278738f, -0.30949783f, 
    0.07774989f, 0.26286203f, -0.25432959f, 0.34744984f, 0.09864815f, 0.33365807f, -0.12055976f, 0.14362295f, 
    -0.00007285f, 0.09606582f, 0.00517347f, 0.02910554f, -0.00760904f, 0.16543098f, 0.33064681f, 0.48423138f, 
    0.15885845f, 0.16760452f, 0.19017366f, -0.19869778f, 0.13334243f, -0.14489993f, -0.59630013f, -0.05899733f, 
    -0.13787925f, 0.22146994f, 0.37121028f, 0.06225469f, -0.13454431f, 0.04350475f, -0.19565941f, 0.10721871f, 
    0.12107251f, 0.07875583f, -0.09613678f, -0.03650229f, -0.05761656f, -0.04481347f, -0.30398622f, 0.25550726f, 
    -0.11642827f, -0.04942494f, -0.07369847f, 0.00537442f, 0.18326820f, 0.18315716f, -0.36855099f, -0.28520253f, 
    -0.18069267f, 0.04878805f, -0.02112722f, 0.20348607f, 0.26237163f, -0.24237585f, 0.31965989f, 0.18945101f, 
    0.17551525f, -0.50779289f, -0.02512915f, 0.17016573f, 0.14362022f, 0.06132284f, -0.46229672f, -0.23753659f, 
    -0.04322577f, 0.19821656f, 0.26624590f, -0.16596887f, -0.00872961f, 0.11601274f, -0.04074668f, 0.07192999f, 
    0.16505450f, 0.01264075f, -0.07481122f, -0.16050099f, 0.08034109f, -0.16319716f, -0.01742544f, 0.02232172f, 
    -0.23561457f, 0.00239693f, -0.19608192f, -0.00228615f, 0.26245615f, -0.06025433f, 0.29140893f, -0.09997133f, 
    -0.09555018f, 0.22008580f, -0.31794754f, -0.08238090f, 0.05537940f, 0.15338252f, -0.30380502f, 0.12232707f, 
    -0.15349887f, -0.00543754f, 0.13556069f, 0.31505528f, 0.04969654f, 0.01057648f, 0.16188313f, 0.13592216f, 
    -0.16150571f, -0.14678261f, 0.03724049f, 0.06400988f, 0.26090601f, 0.16878276f, -0.16559964f, -0.39742637f, 
    0.32260451f, 0.13251422f, -0.10505854f, 0.03364116f, -0.11202022f, 0.15943108f, -0.12742715f, 0.11690353f, 
    0.05480138f, -0.17947583f, -0.02710244f, -0.10777667f, 0.07047048f, 0.12052374f, -0.06350599f, -0.03725686f, 
    0.15052372f, -0.16824764f, -0.02754251f, -0.00717122f, -0.00105802f, 0.14146943f, 0.14335255f, -0.04996075f, 
    0.08373538f, -0.11414559f, 0.10024710f, 0.01723309f, -0.06264317f, -0.08501402f, -0.12571517f, -0.10979701f, 
    -0.06037669f, 0.12526256f, -0.07880154f, -0.00787382f, -0.19819911f, -0.13426277f, 0.10045343f, 0.10855874f, 
    0.10503103f, -0.01213500f, 0.23185252f, -0.13275316f, -0.12048911f, -0.02064082f, -0.30506253f, -0.36269245f, 
    -0.09365288f, 0.41707185f, -0.03957725f, -0.32967043f, -0.18561102f, 0.19877066f, -0.11782699f, 0.12972093f, 
    -0.06992693f, -0.11027847f, -0.16981065f, 0.07874258f, -0.07455102f, 0.45971957f, 0.16994353f, 0.37125579f, 
    0.00378490f, 0.01463633f, 0.29989147f, -0.11152445f, 0.21030845f, -0.37403250f, 0.54100502f, 0.05008313f, 
    -0.09478941f, -0.09873667f, -0.02928293f, 0.13783923f, 0.05831924f, 0.04684641f, -0.22266088f, 0.23575899f, 
    -0.06276751f, 0.10207504f, 0.43834257f, 0.16049686f, 0.29257837f, -0.46232298f, -0.19475427f, 0.09412903f, 
    0.02287777f, 0.01463092f, -0.14292799f, 0.14145970f, 0.23285046f, -0.05756754f, -0.55817389f, 0.18549943f, 
    -0.33143434f, 0.13816750f, -0.42520061f, -0.37811697f, 0.18385759f, 0.04630097f, 0.08758824f, 0.11488188f, 
    0.52881712f, 0.32156631f, -0.35503364f, -0.07759967f, 0.11240284f, 0.01511494f, 0.04597813f, -0.14836031f, 
    -0.15659122f, -0.24870123f, 0.31396687f, 0.09184163f, 0.08397739f, -0.52782524f, 0.42867985f, 0.26965198f, 
    -0.17089921f, 0.05076645f, -0.03632310f, 0.13027140f, -0.16113625f, 0.09744608f, 0.22841033f, 0.05909066f, 
    0.02065039f, 0.04829395f, 0.18813507f, -0.20494407f, 0.12137469f, 0.50433171f, 0.43589598f, 0.02364379f, 
    -0.24183539f, -0.02536672f, -0.06396278f, 0.03206102f, -0.14223589f, -0.06251412f, -0.12617701f, 0.07210276f, 
    -0.13593920f, 0.07963584f, 0.07157683f, -0.24832782f, -0.18251666f, 0.05781185f, -0.06319716f, 0.17175008f, 
    0.10402546f, -0.07622989f, -0.01279483f, 0.07013389f, -0.35163701f, -0.07286938f, 0.11612731f, 0.31318974f, 
    -0.32581952f, 0.13841179f, 0.07682792f, -0.10724904f, -0.06696558f, -0.04837972f, 0.20868401f, -0.00400764f, 
    -0.08744593f, 0.27182129f, 0.25412029f, -0.14613928f, -0.20712829f, 0.15550885f, -0.18017730f, 0.02618238f, 
    0.01110206f, -0.24386141f, 0.14148480f, -0.17677575f, 0.01203224f, -0.11048107f, 0.24736872f, 0.26161212f, 
    -0.04790225f, -0.16507557f, -0.01919273f, 0.08143374f, -0.23653486f, -0.04811626f, 0.27915475f, 0.28019124f, 
    -0.07181831f, 0.16377857f, -0.09288566f, -0.48621234f, 0.27066955f, 0.13929194f, 0.31121236f, 0.13584678f, 
    -0.03820065f, -0.22567557f, 0.00826233f, -0.06477165f, 0.02509832f, -0.16549936f, 0.08219952f, 0.04847194f, 
    0.17265114f, -0.11396915f, -0.22538556f, -0.12849076f, 0.00570421f, -0.13331497f, -0.10971214f, -0.13111371f, 
    0.06910954f, 0.07108510f, 0.16288351f, 0.11103838f, -0.01970726f, 0.00912331f, -0.12677409f, -0.16604786f, 
    -0.13954063f, 0.05123101f, 0.03880313f, -0.13470295f, -0.14547838f, -0.14759442f, -0.17784160f, 0.09836749f, 
    0.10552900f, -0.14389220f, 0.07376824f, -0.10520671f, 0.04781247f, -0.07992759f, 0.13742274f, -0.17296238f, 
    0.15291667f, -0.04975000f, -0.15899053f, -0.03006564f, -0.23638394f, 0.08402678f, 0.05029380f, 0.04670551f, 
    0.04416893f, 0.15732069f, -0.09392406f, -0.11768711f, -0.14454393f, 0.04576990f, 0.00684887f, -0.07428858f, 
    -0.02997356f, 0.06806148f, -0.01410128f, 0.14091790f, -0.03452488f, -0.20776272f, -0.12726630f, -0.08062851f, 
    -0.54425937f, 0.14373539f, -0.06615622f, 0.01249902f, -0.09257985f, -0.03199655f, -0.50130844f, 0.09344998f, 
    0.08484602f, 0.22653164f, -0.00742651f, 0.25970548f, 0.32282373f, -0.21594238f, -0.25284556f, 0.37970659f, 
    0.08614765f, 0.00073127f, -0.17493100f, -0.01634794f, 0.29583248f, 0.51265544f, -0.35327417f, -0.03551149f, 
    -0.03438748f, -0.17286077f, -0.11242535f, -0.29640412f, -0.14785010f, -0.22621505f, 0.20770961f, 0.15903416f, 
    -0.23876163f, -0.38388172f, -0.08600554f, -0.11387308f, 0.05288531f, -0.08776628f, -0.06112319f, -0.32335737f, 
    -0.12629321f, 0.28185222f, 0.09010471f, 0.28137314f, 0.20255554f, 0.39827672f, -0.19732973f, 0.16015838f, 
    0.13958228f, -0.05685934f, 0.01756128f, -0.15887676f, 0.37868369f, 0.47538254f, -0.03131923f, -0.20444992f, 
    -0.03909902f, 0.17112869f, -0.03688247f, 0.33263731f, 0.39839727f, -0.27135631f, 0.24621341f, 0.17674534f, 
    0.02899617f, 0.02040126f, 0.02285247f, 0.03051598f, 0.01547124f, 0.15462609f, -0.18952633f, 0.10867429f, 
    -0.11243179f, 0.25834659f, 0.30529866f, -0.06814970f, 0.20770709f, 0.22714017f, 0.71431541f, -0.04443575f, 
    0.05316040f, 0.16168593f, -0.02347244f, -0.12026550f, -0.35710421f, 0.13726364f, 0.28687868f, -0.08961207f, 
    -0.04607391f, -0.00510197f, 0.30057225f, 0.44321534f, -0.42675191f, 0.20771746f, -0.23379034f, 0.01010584f, 
    -0.07717913f, -0.03703103f, 0.07084411f, -0.02985784f, 0.15838049f, 0.14811337f, -0.08603642f, 0.04630594f, 
    0.08598562f, -0.01795844f, -0.07335371f, -0.07324661f, -0.21255951f, -0.12199008f, -0.01829616f, 0.06279418f, 
    0.16631190f, 0.09679683f, -0.15642163f, -0.12891029f, -0.05526968f, -0.19439353f, -0.23050088f, -0.28050926f, 
    0.01956923f, 0.15822862f, -0.20656949f, 0.06863948f, 0.00112169f, -0.27857795f, -0.00740542f, -0.09255907f, 
    -0.13783914f, -0.57768923f, 0.11702608f, -0.08885939f, 0.01528836f, 0.03172283f, -0.07134242f, 0.18200848f, 
    0.07456335f, 0.04448005f, 0.22497703f, 0.11487454f, 0.22943637f, 0.08982844f, 0.06828520f, 0.14433783f, 
    0.05509257f, 0.06816073f, -0.15526360f, 0.14076345f, 0.09383764f, -0.00237765f, 0.07997107f, 0.23427542f, 
    -0.15748852f, 0.06455488f, -0.28372207f, 0.25111708f, 0.34626147f, -0.15063998f, -0.64444369f, 0.10087407f, 
    -0.39650795f, 0.22019814f, 0.00129221f, -0.05539896f, 0.12406339f, -0.00919620f, 0.04418607f, 0.30587241f, 
    -0.13095374f, 0.06519567f, 0.00660614f, -0.06021441f, -0.24756941f, -0.08553888f, -0.15701182f, -0.06932018f, 
    0.14046587f, 0.10249408f, 0.14643410f, -0.00051493f, -0.08158253f, -0.28652576f, 0.18678246f, 0.37089655f, 
    0.61787266f, -0.17875782f, 0.21506083f, -0.26351199f, -0.14262503f, 0.25265625f, 0.00626714f, -0.35394919f, 
    0.14920503f, 0.03425985f, -0.18563698f, -0.16305956f, 0.01944125f, 0.12130516f, -0.18919104f, -0.10659628f, 
    -0.10031723f, 0.10078596f, 0.08600035f, -0.12098677f, -0.05923083f, 0.08063550f, -0.18564607f, -0.05432472f, 
    0.12144396f, 0.12940998f, -0.05622430f, 0.01267948f, 0.07075775f, -0.16260444f, -0.05648505f, -0.14437854f, 
    -0.05680149f, 0.12888476f, 0.04271230f, -0.11759612f, -0.03046014f, -0.14207228f, -0.11768721f, -0.03934132f, 
    -0.20672077f, 0.43065938f, -0.20712027f, -0.00641487f, 0.07842828f, -0.02054513f, -0.48431045f, 0.31528112f, 
    -0.08299098f, 0.31755474f, 0.00143697f, -0.15072113f, -0.09372155f, -0.14938006f, 0.41245425f, 0.32578790f, 
    0.11501600f, -0.08109073f, -0.16693087f, -0.01320958f, 0.18377182f, -0.25675598f, 0.38785759f, 0.03496396f, 
    -0.23282649f, 0.15827586f, -0.11514427f, 0.27080303f, 0.05666691f, 0.19835164f, 0.20136999f, 0.12116089f, 
    -0.25130191f, 0.25446469f, -0.50098193f, 0.00949894f, -0.04482255f, 0.12106936f, -0.46068558f, 0.08242088f, 
    -0.00514047f, -0.00547764f, -0.40915915f, 0.29726779f, 0.00091882f, -0.10221357f, -0.05170314f, 0.13165182f, 
    0.09607723f, -0.11036316f, -0.01921310f, -0.11985870f, 0.34008664f, -0.35559362f, 0.39686677f, 0.23393214f, 
    -0.00466151f, 0.06630383f, 0.23945555f, -0.00473813f, -0.16046649f, 0.11843470f, -0.06960960f, 0.08678912f, 
    -0.41520894f, -0.20428462f, -0.28375536f, -0.12931830f, 0.11984582f, -0.02852622f, -0.00067112f, 0.35940316f, 
    0.07781303f, 0.12396035f, -0.42385921f, 0.29346341f, 0.23501021f, 0.03747825f, -0.12928009f, 0.04267128f, 
    0.08597091f, 0.02132428f, 0.13800423f, -0.05716080f, -0.11599224f, 0.31882596f, 0.35236490f, 0.27010837f, 
    -0.04918771f, 0.15839744f, -0.10012699f, -0.32468176f, 0.23511809f, -0.16705927f, -0.23199102f, 0.41056293f, 
    -0.13615115f, -0.00207388f, -0.11147144f, -0.07872449f, 0.06098910f, -0.05832008f, 0.15534163f, -0.17588952f, 
    0.17145443f, -0.01794047f, -0.10109299f, -0.15462171f, -0.06941905f, 0.09222583f, 0.08593031f, 0.09029405f, 
    -0.00505370f, 0.07513104f, -0.02661189f, 0.04761287f, -0.16361950f, -0.09288060f, -0.04801770f, -0.16787215f, 
    -0.15663742f, 0.08634304f, -0.03944540f, -0.09101544f, -0.10803273f, 0.11276425f, 0.14604174f, 0.02089931f, 
    0.11227794f, 0.43154258f, -0.14324273f, -0.07409330f, 0.15358274f, 0.14035000f, 0.38982987f, 0.46011248f, 
    0.14863321f, -0.39750507f, -0.16291840f, 0.30396628f, 0.11637080f, -0.37225291f, -0.29146412f, -0.18986923f, 
    -0.14142255f, 0.10548765f, 0.12597737f, -0.01328061f, -0.00743072f, 0.07802629f, -0.31273726f, 0.03696962f, 
    -0.13006215f, 0.16685852f, 0.12745063f, 0.26247847f, 0.18305689f, 0.43552449f, 0.45350176f, 0.29945067f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03962442f, -0.19552235f, 0.15304862f, -0.16482513f, -0.04976607f, -0.18054517f, -0.04076096f, 0.12345600f, 
    0.05450258f, 0.03197309f, 0.01384983f, -0.10243227f, 0.00318490f, 0.21579312f, -0.13345328f, 0.25993210f, 
    -0.16989122f, 0.11217957f, -0.04367551f, -0.09117813f, 0.25435728f, 0.00407074f, 0.07696845f, -0.20276287f, 
    -0.05031813f, 0.03074674f, 0.01109843f, 0.17961705f, 0.30803674f, -0.01915261f, 0.10467868f, 0.17953029f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.05215380f, 0.23315626f, -0.08330012f, -0.02782113f, 0.42871228f, 0.39588210f, 0.10031319f, 0.08961020f, 
    0.11384270f, 0.04229770f, -0.22067314f, -0.32778901f, -0.04744743f, 0.16890883f, -0.57959753f, -0.28982079f, 
    -0.38233590f, -0.51264411f, 0.12589236f, -0.00561909f, -0.31884539f, 0.13289647f, -0.19866662f, 0.13839446f, 
    0.02632862f, -0.40632921f, -0.05782231f, -0.51132804f, -0.63801003f, -0.74149978f, -0.06393967f, -0.11790314f, 
    0.26115081f, 0.25523919f, 0.14267930f, -0.57119316f, -0.03008424f, 0.29174945f, 0.33646145f, -0.07839645f, 
    -0.24736369f, -0.11687486f, -0.35279378f, 0.06317361f, -0.01335562f, -0.04924200f, -0.16442637f, 0.22628669f, 
    -0.07565367f, 0.07567723f, 0.12744109f, -0.20647079f, -0.09913199f, -0.23788574f, 0.35745919f, -0.04760539f, 
    -0.24901205f, 0.17107244f, -0.05143685f, -0.03958911f, -0.90471518f, -0.59250373f, -0.17004298f, -0.06709882f, 
    -0.46446213f, 0.18632112f, -0.00823539f, 0.31926540f, 0.48029175f, 0.05452130f, -0.02181395f, 0.14310667f, 
    -0.14694598f, -0.25833935f, -0.30789626f, -0.08123441f, 0.09020521f, -0.48693997f, -1.03059125f, 0.19597848f, 
    -0.41738120f, 0.33544487f, -0.02136846f, -0.13308285f, -0.71798831f, -0.54877836f, -0.27250516f, 0.01649576f, 
    -0.21808361f, 0.21446270f, 0.13205889f, -0.19656952f, -0.00559573f, 0.08560282f, 0.11099289f, 0.33820933f, 
    -0.68082827f, 0.26210484f, -0.04103724f, -0.18688069f, 0.28408939f, -0.46945193f, -0.13187316f, -0.15089466f, 
    -0.53385282f, 0.23328584f, -0.67695028f, 0.19135723f, 0.03588771f, 0.16474271f, -0.57389748f, -0.48910323f, 
    -0.02520935f, -0.31083450f, -0.05036080f, 0.03873446f, 0.34827992f, 0.41303954f, -0.16923484f, -0.23647355f, 
    -0.08236659f, -0.64057148f, 0.14787072f, 0.23968031f, 0.12144737f, 0.18441220f, 0.10689294f, 0.01692291f, 
    0.27525073f, 0.13740940f, -0.14228937f, 0.05219553f, 0.35335919f, -0.12532195f, -0.22856946f, -0.05817697f, 
    0.28299969f, -0.15225045f, -0.10821646f, 0.14986484f, -0.04111461f, 0.01237256f, 0.27986306f, -0.19362563f, 
    -0.33735356f, -0.20039183f, 0.15304127f, -0.09295909f, 0.36863351f, 0.22827744f, -0.37598380f, -0.02562565f, 
    -0.00958147f, 0.38710660f, -0.02018678f, -0.36329493f, 0.06882397f, 0.04580631f, -0.02261921f, -0.36430156f, 
    0.35304299f, -0.40215775f, -0.13315447f, -0.22032599f, -0.24910678f, 0.10671267f, -0.28529432f, 0.13004732f, 
    0.13078019f, -0.10421856f, 0.63255513f, -0.26068255f, -0.17214452f, 0.28545499f, -0.61070198f, 0.24679346f, 
    0.18854135f, 0.27627176f, 0.12762177f, 0.08545459f, -0.62136149f, 0.21570943f, -0.00256533f, 0.05986845f, 
    0.24668941f, -0.22022875f, -0.01563985f, 0.15064858f, -0.30849037f, -0.06861421f, -0.12387257f, -0.35095164f, 
    0.12745680f, -0.94225466f, -0.01738428f, 0.46622613f, 0.15314680f, -0.02072223f, 0.05055389f, -0.12526467f, 
    0.17926602f, -0.39895481f, -0.45109466f, 0.21399340f, 0.05559420f, -0.46787122f, -0.85515881f, 0.05005331f, 
    -0.30176413f, -0.53070045f, 0.10099685f, 0.09839231f, -0.54120833f, -0.09899815f, 0.34359643f, -0.01730570f, 
    0.23261069f, -0.26804891f, 0.10960776f, 0.26793918f, 0.33026159f, -0.21515073f, -0.09892159f, -0.23945566f, 
    0.00695612f, -0.16777715f, -0.14809300f, 0.18100119f, -0.14775543f, -0.33340189f, 0.00254382f, 0.17771804f, 
    -0.54654419f, 0.16542019f, 0.10490981f, 0.01083577f, 0.07513974f, -0.71560049f, 0.50615191f, -0.64971775f, 
    -0.00902708f, 0.18743911f, -0.03243680f, 0.03357838f, 0.16510740f, -0.01876055f, -0.49420106f, -0.02038530f, 
    0.38128778f, 0.52767563f, -0.07347392f, 0.19664580f, -0.19170465f, 0.10341643f, 0.04770176f, -0.00102894f, 
    -0.34281918f, 0.28589919f, -0.13450500f, -0.33194587f, 0.05560786f, 0.12282193f, -0.37220451f, -0.16928877f, 
    0.17020319f, -0.30953658f, 0.38655850f, -0.75312215f, 0.09474618f, 0.30062130f, 0.38981679f, -0.28502235f, 
    0.36093080f, -0.15544480f, -0.07608765f, -0.04328959f, -0.22770330f, -0.63564020f, 0.14885256f, -0.02688164f, 
    -0.17410536f, 0.54542965f, 0.05343676f, 0.27478051f, 0.34706146f, -0.15549679f, -0.12896782f, -0.40759566f, 
    -0.25902662f, 0.04423855f, 0.03150650f, 0.48421991f, -0.54727173f, 0.15628621f, -0.68975842f, -0.14647421f, 
    0.26781416f, -0.21021426f, -0.36971554f, -0.07192888f, -0.02515580f, -0.26122129f, 0.33610433f, 0.07245744f, 
    -0.06967299f, -0.40585947f, -0.16440408f, -0.09939126f, -0.17627570f, 0.10492256f, -0.11785056f, 0.04807132f, 
    0.14063768f, -0.09169931f, -0.13899696f, -0.38593882f, -0.18424864f, 0.24104297f, -0.08357523f, 0.39697763f, 
    -0.10019758f, 0.04428568f, 0.03347753f, -0.24954090f, -0.52474767f, -0.53764921f, 0.07255149f, -0.14404346f, 
    -0.49257916f, 0.09018213f, 0.14765748f, -0.04445788f, 0.02781190f, -0.03105691f, 0.24413171f, 0.60761231f, 
    0.07662250f, 0.17031386f, 0.03597523f, 0.08666262f, 0.15018874f, -0.17372626f, -0.33246398f, 0.00559632f, 
    -0.59663838f, 0.22527906f, -0.21063207f, 0.33107468f, 0.37530068f, -0.30901840f, 0.05190900f, 0.26600516f, 
    -0.31769913f, -0.18883072f, 0.12149692f, -0.12467113f, -0.36090323f, -0.37783954f, 0.86922234f, -0.06411307f, 
    0.28197590f, -0.08135260f, -0.46723422f, -0.23484066f, 0.09024695f, 0.13446234f, -0.85620725f, -0.17888284f, 
    0.19257262f, 0.04512179f, 0.03618737f, 0.00985836f, 0.12423303f, -0.02176710f, 0.14996842f, -0.10172779f, 
    0.11737158f, -0.73664641f, 0.06013190f, -0.07324867f, 0.00104918f, 0.43079758f, 0.14042337f, -0.23230709f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.25180906f, 0.08599300f, -0.05035726f, -0.06538250f, -0.03907324f, 0.16719188f, -0.11133448f, -0.14851408f, 
    -0.15354386f, -0.02078490f, 0.09301119f, 0.08840270f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
