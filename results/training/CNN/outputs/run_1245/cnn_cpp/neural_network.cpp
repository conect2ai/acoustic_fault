#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.28953660f, -0.68258703f, 0.01568518f, 0.38015607f, 0.38495120f, 0.68278986f, -0.40461344f, 0.16995558f, 
    0.62826830f, 0.74997962f, 0.02059206f, 0.22016712f, -0.37479103f, 0.37468565f, -0.32702738f, -0.44651407f, 
    -0.24967164f, 0.20943686f, -0.04076855f, -0.07515974f, 0.18180709f, -0.00429532f, 0.15843269f, 0.06203683f, 
    0.15913595f, -0.08446857f, -0.30143464f, -0.18822302f, 0.37814194f, 0.41120476f, -0.40096244f, -0.46093118f, 
    -0.38084245f, -0.12904967f, 0.13569872f, -0.17059240f, -0.21820496f, 0.07531474f, 0.35587862f, 0.14631921f, 
    0.40294132f, 0.04871160f, 0.49266717f, -0.18115044f, 0.15111892f, -0.34735575f, -0.39019921f, -0.18676585f, 
    -0.10310183f, -0.18800797f, -0.55455226f, -0.04939135f, -0.41065225f, -1.36313808f, -1.07503641f, 0.32861447f, 
    0.35864189f, 0.01271605f, 0.04191179f, 0.47065035f, -0.19467707f, -0.40800086f, -0.18069480f, -0.37434414f, 
    0.21065760f, 0.09635720f, 0.22038947f, 0.11075889f, 0.22640043f, -0.05064153f, -0.29293904f, -0.32574677f, 
    -0.20810001f, -0.33870330f, -0.02920540f, 0.25850749f, -1.10203493f, -0.63635230f, -0.22587027f, -0.40333387f, 
    -0.19775143f, -0.13548429f, 0.34171525f, -0.23379320f, 0.36874953f, -0.32017797f, -0.13230559f, -0.36092359f, 
    0.04804073f, 0.54120100f, 0.13520533f, 0.09103809f, -0.05397925f, 0.37494206f, -0.10098230f, -0.44254199f, 
    -0.30088609f, 0.28933606f, -0.00206639f, -0.14132008f, 0.70644152f, 0.95833379f, 0.53224295f, -0.43262646f, 
    -0.18228579f, -0.57109666f, -0.14925247f, 0.12372179f, -0.39058593f, -0.37223133f, 0.06493707f, 0.07069972f, 
    -0.28492293f, 0.22446088f, 0.00688673f, -0.13626486f, 0.14550026f, 0.34573200f, 0.19671607f, 0.17512780f, 
    0.14362095f, 0.16499251f, -0.41364071f, -0.50367016f, -0.49190423f, 0.56855512f, -1.39108503f, 0.14229816f, 
    0.72465986f, -0.25253218f, 0.50332588f, 0.95385563f, 0.06219721f, -0.55731940f, -0.63074648f, -0.19773459f, 
    -0.26066151f, -0.24480824f, -0.24479415f, 0.19989899f, -0.13176349f, -0.05779344f, -0.01285356f, 0.21545203f, 
    -0.25426233f, -0.11771002f, -0.12367105f, -0.01571251f, 0.20666732f, -0.47179741f, -0.42798427f, -0.02882915f, 
    -0.10208681f, -0.10854220f, -0.41093212f, -0.45280606f, -0.52731627f, -0.12102474f, 0.94071180f, -0.18354844f, 
    -0.14729924f, -0.14767325f, 0.55928183f, -0.26319748f, -0.25680280f, -0.19164219f, -0.37536415f, 0.04514428f, 
    -0.34881458f, -0.51627904f, 0.26166490f, 0.26682460f, -0.18825658f, 0.11362135f, 0.42071357f, -0.06568529f, 
    -0.03202571f, 0.37938100f, 0.70691651f, -0.09940408f, -0.24416494f, -0.42827204f, -0.86312938f, -0.34445336f, 
    0.35557964f, -0.22494332f, 0.11306867f, -0.28515804f, 0.19435434f, 0.04909189f, -0.15063390f, 0.30116072f, 
    -0.01844229f, -0.32343000f, -0.25514269f, -0.06164391f, -0.14004108f, -0.12227140f, -0.30405638f, -0.50402421f, 
    0.63960451f, 0.80058980f, -0.35640511f, -0.38578933f, -0.38995948f, -1.07726693f, -0.47502577f, -0.89722055f, 
    -0.96753383f, -1.07459617f, 0.00811939f, 0.33612013f, 0.16623767f, 0.29262540f, 0.15339147f, 0.04187514f, 
    -0.20333514f, 0.29625118f, 0.09374230f, -0.32620645f, -0.07828389f, -0.02054878f, 0.07649875f, 0.02166620f, 
    0.27111185f, 1.21038175f, -0.90489960f, -0.55733174f, -0.43177184f, 0.09546078f, -0.01327985f, -0.05289644f, 
    0.68848890f, -0.05050416f, 0.00058752f, -0.33536571f, 0.17164761f, 0.29490718f, -0.05655785f, 0.51514465f, 
    -0.09774987f, 0.04046355f, -0.16823785f, -0.00467706f, -0.30030912f, 0.16063365f, -0.32884169f, 0.18375395f, 
    0.04282133f, 0.14942433f, 0.92831868f, 0.96421713f, 0.52744353f, -0.49999267f, -0.59951514f, -0.15274060f, 
    0.20972639f, 0.55982894f, -0.33759457f, -0.55379331f, -0.47568688f, 0.02806625f, -0.01400974f, -0.11094059f, 
    -0.07647123f, 0.22216888f, 0.16103373f, -0.02972283f, -0.43516845f, 0.28885183f, -0.15533999f, -0.03338813f, 
    -0.37591293f, 0.01810017f, 0.11001030f, -1.10280025f, -0.00265156f, -0.64683914f, -0.86531633f, -0.54368478f, 
    -0.49482346f, -0.29323858f, 0.72146410f, -0.14617859f, -0.31262729f, -0.25067213f, 0.20872921f, 0.03198183f, 
    -0.47878057f, -0.37113699f, 0.10763493f, -0.34205735f, -0.25300813f, 0.19126453f, 0.31713486f, -0.08498675f, 
    0.33251455f, -0.31270847f, -0.43200466f, 0.21210478f, 0.29786518f, 0.22201447f, 0.23336717f, 0.43167704f, 
    0.27375820f, -0.47004464f, 0.03104739f, -0.46358085f, -0.56265432f, -0.19233388f, 0.10496858f, -0.24458161f, 
    -0.10507676f, 0.06062736f, -0.30978194f, 0.36932078f, -0.50255162f, 0.02815286f, 0.10595451f, 0.01782084f, 
    -0.13078524f, 0.19597934f, -0.18365292f, 0.32220933f, 0.00765532f, -0.53914517f, -0.76158702f, -1.07134688f, 
    -0.36061448f, 0.26320302f, -0.48933893f, -0.48965907f, -0.84506357f, -0.48803505f, -0.85091549f, 0.57528996f, 
    0.60655504f, 0.39868012f, -0.51408070f, -0.22099388f, 0.04826868f, -0.20184782f, -0.15676835f, -0.32583630f, 
    -0.18819298f, 0.13026424f, -0.50557411f, 0.02783596f, -0.22486344f, -0.52259147f, 0.23329486f, 0.38165399f, 
    0.47292769f, 0.27974162f, 0.20888957f, -0.55044472f, -0.34460938f, 0.17577459f, 0.32107133f, 0.22624740f, 
    0.05152347f, -0.10357048f, 0.13023591f, 0.43682358f, -0.38553801f, 0.12297670f, 0.07223187f, -0.17102912f, 
    0.03340835f, -0.22675495f, 0.19104126f, -0.00016182f, 0.04349221f, 0.09399816f, -0.29705307f, -0.17135054f, 
    0.63918495f, 0.95543343f, -0.97708833f, -0.47974783f, 0.32556692f, -0.42797107f, -0.23574859f, 0.21039070f, 
    -0.92212212f, 0.31123757f, -0.11596318f, -0.05632727f, -0.43778387f, -0.01024922f, 0.56421906f, 0.15441480f, 
    -0.17276692f, 0.27163205f, -0.72430360f, -0.26723292f, 0.23009014f, 0.27459475f, -0.28115737f, -0.34110892f, 
    -0.25889346f, 0.28694975f, -0.29955012f, -0.44455019f, 0.32641837f, 0.17989394f, -0.08113206f, 0.06644493f, 
    0.39393437f, -0.05883783f, 0.20064370f, 0.18029559f, -0.44268057f, 0.07263526f, -0.16459167f, -0.16389295f, 
    0.05076280f, -0.31555378f, -0.10289774f, -0.29973164f, 0.30033019f, 0.27025414f, 0.28369573f, 0.39904228f, 
    0.37132841f, 0.46036503f, 0.34871161f, -0.07629715f, -0.16445684f, 0.01336135f, -0.18497410f, 0.15437050f, 
    -0.09013501f, 0.11540380f, 0.41079101f, -0.01673324f, 0.44759178f, 0.13599466f, -0.24146317f, -0.50836754f, 
    -0.37639391f, -0.48622277f, 0.43296045f, -0.17598191f, 0.05607678f, -0.16988578f, 0.15705815f, -0.11981130f, 
    0.23016793f, 0.17859472f, -0.84020990f, -0.67510736f, -0.22298670f, -0.05299535f, -0.71862215f, 0.64514214f, 
    0.36114895f, 0.08617830f, 0.16061243f, -0.03935194f, -0.53157020f, 0.14565018f, 0.08523816f, 0.24616550f, 
    0.42255291f, 0.17655595f, 0.28906709f, -0.01520784f, -0.43721336f, -0.08874021f, 0.25067365f, 0.15654621f, 
    0.30860114f, -0.01300638f, -0.07648088f, 0.26156679f, 0.42403576f, 0.06903791f, 0.34588692f, 0.52454102f, 
    -0.05088600f, 0.33264935f, 0.00646397f, -0.13564284f, -0.38441026f, 0.05717110f, 0.14909606f, 0.05195585f, 
    0.07943162f, -0.11931607f, -0.28337440f, -0.11579622f, -0.14658602f, -0.18774374f, 0.22641863f, -0.02622302f, 
    -0.09933063f, 0.07922620f, 0.20628823f, -0.22217087f, -0.74870676f, -0.70040733f, -0.31263375f, -0.46579847f, 
    -0.59968311f, -0.04103291f, -0.73357731f, -0.80043906f, -0.76255983f, -0.60921443f, -0.46060514f, 0.08680136f, 
    -0.18492231f, -0.56303829f, -0.08243968f, -0.37960172f, -0.09194406f, 0.04590072f, -0.20348921f, -0.35720268f, 
    -0.04203493f, 0.20392011f, -0.10186005f, 0.01503208f, 0.23964377f, -0.36970389f, -0.27812091f, -0.26394442f, 
    0.13997671f, 0.43299967f, -0.33738461f, 0.37591529f, 0.12617682f, 0.12979271f, 0.37358850f, 0.25955677f, 
    0.27079883f, 0.10694183f, -0.38916430f, -0.47051570f, 0.16491975f, -0.04144175f, 0.09686994f, 0.27410161f, 
    -0.09965164f, -0.01125992f, 0.16251093f, 0.21701308f, -0.47776803f, 0.01273782f, -0.25645506f, -0.20336828f, 
    -0.44974434f, -0.22472101f, 0.59352022f, 0.46596053f, 0.56300956f, 0.12801321f, -0.46098545f, 0.25836083f, 
    -0.20460488f, -0.15213542f, -0.74247068f, -0.19392151f, -0.01777245f, 0.00979313f, -0.31577012f, 0.15388021f, 
    -0.24016605f, -0.55939996f, -0.27296245f, -0.22183038f, -0.51702654f, -0.57053328f, -0.61255306f, -0.30695906f, 
    -0.14738137f, -0.23287749f, 0.27208841f, 0.46652475f, 0.37856576f, 0.11412299f, 0.04699167f, -0.17612572f, 
    -0.32762986f, 0.23589642f, -0.26435032f, -0.30831540f, 0.08161815f, -0.03663139f, -0.09499785f, 0.14917712f, 
    0.18281791f, -0.10937831f, -0.28344604f, 0.01192542f, -0.46351612f, -0.07333063f, 0.44874689f, 0.39313409f, 
    -0.47328717f, 0.48707262f, 0.33943009f, -1.04576933f, -0.19211598f, -0.03685340f, -0.11359537f, -0.12488046f, 
    -0.58374768f, -0.61916500f, 0.10907858f, -0.02065850f, -0.19127519f, -0.07388731f, -0.24589381f, 0.22053102f, 
    -0.58430684f, -0.24958096f, 0.11173797f, 0.07332202f, 0.42723605f, 0.28008470f, 0.07791802f, 0.39836779f, 
    0.15558827f, -1.31047451f, -0.75141233f, -0.66687435f, 0.05211944f, 0.27808699f, 0.06295580f, -0.22102949f, 
    -0.39725003f, 0.07299427f, 0.88031256f, 0.13227996f, 0.23992363f, 0.33058012f, 0.37025616f, -0.03301046f, 
    0.20353846f, 0.21439092f, 0.07025786f, 0.10087115f, -0.09420935f, 0.12874837f, 0.21372689f, -0.13796507f, 
    -0.20211621f, 0.19176808f, -0.45570078f, -0.08513594f, 0.06229053f, -0.06739770f, -0.01151396f, -0.10406585f, 
    0.42922938f, -0.31615400f, -0.10194172f, 0.35587513f, -0.03973826f, 0.36364603f, -0.50652260f, 0.45266590f, 
    -0.10137035f, -0.23552054f, -0.29701906f, 0.05431050f, 0.20674188f, 0.06830513f, -0.15002744f, 0.08963615f, 
    -0.01892958f, 0.31989995f, 0.20568688f, -0.42525890f, -0.93787348f, 0.54793680f, 0.56502467f, 0.50160229f, 
    0.32342800f, -0.37556231f, -0.63768482f, -0.04979185f, 0.07878205f, -0.46056190f, 0.42070004f, -0.05994331f, 
    0.51519251f, -0.32123554f, -0.17860383f, 0.12635851f, -0.17358707f, -0.01887676f, 0.24240784f, 0.33088478f, 
    -0.20345400f, -0.27959606f, -0.14584662f, 0.25700715f, 0.25408697f, -0.69893402f, -1.42109537f, -0.85601181f, 
    -0.72486484f, 0.46590143f, 0.63954222f, 0.18785037f, 0.02129529f, 0.09420846f, -0.02491769f, 0.82931787f, 
    -0.32691509f, -0.24576704f, -0.27298802f, -0.54010004f, -0.39986271f, 0.12142217f, -0.37304151f, -0.64758462f, 
    0.17573132f, -0.19452126f, -0.14436527f, 0.20403558f, 0.37436891f, -0.95748985f, -0.78856117f, -0.16980202f, 
    -0.26309994f, -0.29821217f, -0.54093385f, -0.53985125f, -0.87316567f, -0.06598130f, 0.47895738f, 0.03415012f, 
    -0.48720747f, -0.36229426f, -0.02859167f, -0.47286552f, -0.03773018f, 0.03443628f, -0.15318380f, -0.25416890f, 
    -0.44408908f, -0.11792196f, -0.18364505f, -0.26110888f, -0.06096813f, 0.13268580f, -0.72509074f, -0.13109151f, 
    -0.53878480f, -0.71256006f, -0.75641930f, 0.26641521f, 0.27006036f, 0.51827890f, 0.50934273f, 0.46233243f, 
    0.27456978f, 0.15492180f, 0.26909995f, -0.08853686f, -0.25867090f, -0.25047135f, -0.25324908f, -0.30375558f, 
    -0.04677289f, 0.08374584f, -0.09524003f, -0.17817925f, -0.19365765f, -0.15771601f, -0.19658008f, 1.29530823f, 
    -0.23276158f, -0.85559195f, -0.92986840f, -0.53190440f, 0.84625638f, 0.69788069f, -0.02957969f, 0.31242511f, 
    -0.32450843f, 0.02736864f, 0.05848693f, -0.10314642f, -0.20418982f, -0.36154938f, 0.03210470f, 0.21298893f, 
    -0.03961227f, -0.05124233f, 0.30398819f, 0.11342901f, -0.05757220f, -0.30212379f, 0.17874797f, 0.21230027f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.50437117f, 0.09473761f, 0.15950873f, 0.06330717f, 0.33895814f, 0.07966123f, 0.23368336f, -0.12100762f, 
    0.15329963f, 0.37815696f, 0.70219290f, 0.39999223f, -0.00780360f, -0.20622256f, 0.11074612f, 0.41196731f, 
    -0.02998533f, 0.49283782f, -0.04841764f, -0.03368491f, -0.23422238f, 0.41507182f, 0.17864090f, 0.38044420f, 
    0.21904379f, 0.09996923f, 0.37119845f, 0.22033729f, 0.23685281f, -0.23342673f, -0.12778424f, 0.45150149f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12420855f, 0.05670858f, 0.46160877f, -0.28763002f, -0.05070108f, 0.11685768f, 0.04770496f, 0.01131260f, 
    0.00133697f, 0.07956663f, -0.27597544f, -0.34271830f, 0.16550954f, 0.20658922f, 0.09878913f, -0.11295944f, 
    0.10468373f, 0.00575227f, -0.07975981f, 0.15424809f, -0.04292971f, -0.03106358f, 0.05792128f, 0.02371720f, 
    -0.04224340f, 0.07325532f, -0.07485940f, -0.02256185f, 0.09998520f, 0.20821463f, -0.03232934f, 0.16909142f, 
    0.08210444f, 0.00937528f, 0.04419868f, 0.00804141f, 0.38514093f, 0.15802690f, -0.00982896f, -0.09538786f, 
    0.21920764f, 0.11594956f, 0.12067363f, -0.17553985f, -0.04828002f, 0.02761866f, 0.00085235f, 0.11639455f, 
    -0.13194376f, -0.01480489f, -0.02673361f, 0.12399602f, 0.07495234f, -0.00682929f, 0.02370138f, -0.21169986f, 
    -0.01560851f, 0.01409077f, -0.00593243f, 0.03773597f, 0.69265741f, -0.61095768f, -0.03067821f, -0.43969399f, 
    -0.01774917f, -0.05772097f, 0.06480861f, -0.10032021f, -0.06162410f, -0.13701859f, -0.08993442f, 0.30995381f, 
    0.08156528f, 0.12563893f, 0.17371340f, -0.23968463f, 0.07351074f, 0.13431938f, -0.11964739f, -0.37903827f, 
    -0.00678920f, -0.28596884f, -0.04370135f, -0.16430257f, -0.02769228f, 0.03979519f, -0.07758068f, -0.27399656f, 
    -0.06725755f, -0.26271600f, -0.25307974f, -0.19793673f, 0.01459847f, -0.11801022f, 0.03533691f, 0.09478688f, 
    0.39347053f, 0.11458731f, -0.40251806f, -0.17962834f, 0.06966791f, -0.21098006f, 0.14085726f, 0.02163126f, 
    0.03110803f, 0.10968509f, -0.01603732f, -0.01799806f, -0.18381785f, -0.08630212f, -0.27774656f, 0.12722667f, 
    -0.02322025f, 0.00694430f, -0.00843514f, -0.15734726f, -0.05372126f, -0.09180406f, -0.18413584f, -0.11512543f, 
    -0.73100519f, -0.88603681f, 0.01237629f, 0.38719824f, 0.06381328f, 0.00015875f, -0.08601046f, 0.06338887f, 
    0.02135716f, 0.01299816f, 0.02041539f, -0.09388488f, 0.20355420f, 0.24568039f, 0.06357872f, -0.15235963f, 
    0.16500117f, 0.07569245f, -0.04016989f, 0.03530756f, 0.00017411f, -0.06533125f, 0.03100140f, 0.09456970f, 
    -0.08054758f, -0.11590833f, -0.00924172f, -0.24979173f, -0.08242227f, 0.03285658f, -0.06775009f, -0.08612324f, 
    0.00638983f, -0.02358572f, -0.02822472f, 0.03285563f, 0.43000686f, 0.39118767f, -0.20831949f, -0.14109890f, 
    0.07504664f, -0.06661233f, 0.15217817f, 0.04698910f, -0.06999458f, -0.14930645f, -0.03661801f, 0.00910874f, 
    -0.33031356f, -0.23684928f, 0.22517887f, 0.06368262f, 0.10517046f, -0.03800110f, -0.00764545f, 0.00648677f, 
    -0.06143293f, -0.09786183f, -0.11758553f, 0.09831728f, -0.02008658f, 0.06449825f, -0.47152478f, -0.02750321f, 
    -0.36851087f, 0.20501079f, -0.38946387f, 0.05688022f, -0.00714322f, -0.10062783f, -0.03350213f, -0.06875562f, 
    0.02540502f, 0.04233009f, 0.02320682f, -0.02122191f, -0.01825709f, 0.15539825f, -0.01755296f, 0.03105906f, 
    -0.08881580f, -0.06066329f, -0.21148035f, -0.16914530f, -1.18294644f, -0.50010043f, -0.51094311f, -0.07757962f, 
    0.08871889f, 0.01373058f, 0.02877433f, 0.04087811f, -0.10447005f, -0.16760425f, -0.02140278f, 0.00752505f, 
    0.26934397f, 0.03682517f, 0.02221389f, -0.05551325f, 0.01078957f, 0.14844181f, -0.18807647f, -0.21944290f, 
    -0.19010717f, -0.01702455f, -0.01164980f, 0.11205853f, -0.41935101f, -0.31712601f, -0.11066496f, 0.21878825f, 
    0.10385611f, 0.04627032f, 0.03692381f, 0.07649544f, -0.03074756f, 0.03460031f, 0.01343714f, 0.02668526f, 
    0.43635643f, 0.33425814f, -0.17953482f, -0.29037294f, 0.11582004f, 0.16199078f, 0.09985127f, -0.13364601f, 
    -0.03908923f, -0.06048183f, 0.03938174f, -0.06856178f, -0.00254381f, 0.15127954f, 0.02833220f, -0.00520659f, 
    -0.03189511f, -0.14924489f, -0.02205279f, -0.09886658f, -0.08620738f, -0.09088748f, -0.08487708f, -0.02864305f, 
    0.27293044f, -0.01011816f, -0.23881108f, 0.04296243f, -0.03422570f, 0.02207061f, 0.01328708f, 0.02065236f, 
    -0.03136906f, -0.02063335f, 0.00404538f, 0.18087302f, 0.13965082f, -0.22668578f, -0.04253916f, -0.07393091f, 
    -0.31872302f, -0.02421722f, -0.00848663f, -0.00249042f, -0.06775769f, -0.17691390f, -0.02805093f, 0.02005856f, 
    0.03583882f, 0.06038031f, -0.29814512f, -0.09867824f, -0.10581676f, 0.30706653f, 0.03187827f, 0.03071325f, 
    0.00944215f, -0.06737514f, 0.05088732f, -0.11713442f, 0.24327055f, 0.27626374f, 0.16449831f, -0.14800629f, 
    -0.02783054f, 0.11112772f, 0.15028647f, -0.21614301f, 0.00826311f, 0.03743463f, -0.01705412f, 0.03834253f, 
    -0.04518906f, 0.01708356f, 0.09090969f, 0.00438880f, -0.15772240f, -0.20957099f, 0.02652920f, -0.06407598f, 
    -0.09519663f, -0.05573749f, -0.14937089f, -0.10386390f, 0.50823629f, 0.14093079f, -0.26465163f, -0.54155886f, 
    -0.08644793f, -0.38433740f, 0.03163721f, -0.12881319f, 0.11924367f, -0.15197650f, -0.09501204f, -0.19340594f, 
    0.18082015f, 0.00822049f, -0.31154492f, 0.05702240f, 0.18173859f, 0.11885348f, -0.14896411f, -0.20583376f, 
    -0.14667715f, -0.01477737f, -0.25242999f, 0.06580725f, 0.43328512f, 0.31277743f, 0.16392367f, -0.27363491f, 
    0.25341791f, 0.17502654f, 0.20314616f, 0.20846625f, -0.06893059f, -0.15231539f, -0.11429933f, -0.07298931f, 
    -0.24124058f, -0.33794940f, -0.01370199f, 0.02341572f, 0.13597256f, 0.07543492f, -0.01850485f, 0.04787722f, 
    -0.12127975f, 0.08704393f, 0.08847116f, 0.02267831f, 0.05991375f, -0.38933191f, -0.92642808f, 0.03910284f, 
    -0.00258634f, 0.11462835f, 0.01699962f, -0.09639132f, -0.10511114f, -0.09929062f, -0.09336848f, -0.34871873f, 
    -0.08098499f, 0.18300259f, -0.22384582f, -0.10821450f, -0.17228216f, 0.04607002f, -0.02483802f, 0.05438815f, 
    -0.02899554f, 0.03437350f, -0.06688388f, 0.15278764f, -0.18740475f, 0.02415138f, -0.10334323f, 0.00393244f, 
    0.05816558f, -0.00647635f, -0.00441306f, 0.07116456f, 0.23979338f, 0.05187179f, -0.03293442f, -0.01424249f, 
    0.13053748f, 0.06846769f, 0.10001507f, -0.00651150f, 0.05430228f, 0.07844435f, -0.29466039f, -0.56220740f, 
    0.05551150f, 0.03068611f, -0.11373419f, -0.28281742f, -0.10974468f, 0.22673194f, 0.12955673f, 0.14390847f, 
    -0.00569857f, -0.11840814f, 0.24760345f, -0.49369437f, 0.02970786f, 0.00356535f, 0.05684038f, -0.15612748f, 
    0.11488501f, -0.07527043f, 0.03034703f, -0.08086667f, 0.12277337f, -0.33533785f, -0.24257831f, 0.11593015f, 
    0.01200043f, -0.07036090f, 0.06883268f, 0.02737358f, 0.49879417f, -0.59846520f, 0.39000988f, 0.12990278f, 
    -0.08829266f, -0.02735838f, -0.01310807f, -0.14298731f, 0.09233741f, -0.22966112f, 0.39736167f, -0.09228941f, 
    -0.57481897f, 0.02026619f, -0.43751499f, -0.12679072f, 0.03398156f, 0.18493724f, 0.01444428f, 0.15865542f, 
    0.04893662f, 0.16917636f, 0.08282761f, -0.12280390f, -0.38832343f, 0.12246381f, -0.28104249f, -0.41975644f, 
    0.02033023f, 0.10632534f, 0.04595005f, 0.13930431f, -0.02869683f, 0.02305175f, -0.01975735f, -0.07950890f, 
    0.05852773f, -0.17460729f, -0.37296450f, -0.28640765f, -0.39178437f, -0.08327907f, 0.01426893f, 0.01229279f, 
    -0.06208305f, 0.00581633f, -0.00933144f, 0.17298049f, 0.70600116f, -0.03710938f, -0.12490718f, 0.01674326f, 
    -0.06668150f, 0.10365574f, 0.07752049f, -0.19875968f, 0.11850601f, 0.02829843f, 0.10188575f, -0.07094537f, 
    0.63591266f, -0.07051017f, 0.41026324f, -0.13466457f, 0.00213033f, -0.04631284f, -0.03085822f, -0.07659085f, 
    0.05532053f, 0.05133681f, -0.12664033f, 0.02335051f, -0.25685024f, 0.09533985f, -0.17665890f, 0.03318997f, 
    -0.14520364f, 0.05126456f, -0.15119761f, -0.21346557f, -0.12795989f, 0.06918116f, -0.05057113f, 0.02627060f, 
    0.21905972f, -0.03352201f, -0.06034527f, -0.43448424f, -0.23820229f, -0.11094112f, -0.02540917f, -0.17328356f, 
    -0.11393902f, -0.04044126f, -0.00012311f, -0.01766515f, -0.23550002f, -0.16613305f, -0.11856288f, 0.43726915f, 
    -0.13863243f, 0.24698862f, 0.03046006f, 0.06501194f, -0.00166661f, -0.03260458f, -0.06411008f, 0.10035619f, 
    0.09037411f, 0.05407654f, 0.14392874f, 0.14012657f, 0.03924606f, -0.06190868f, -0.03402615f, 0.01470336f, 
    0.05965973f, 0.04012161f, 0.04326196f, 0.05639230f, -0.11970797f, -0.31466874f, 0.26238176f, -0.45448852f, 
    0.10911807f, -0.00899554f, 0.08648252f, 0.26686421f, -0.09106153f, 0.27687967f, -0.28324139f, -0.13587351f, 
    0.03236673f, -0.00356695f, 0.12642537f, 0.08978551f, 0.18980278f, -0.01925718f, 0.02010872f, 0.00284206f, 
    -0.02436075f, -0.09200218f, 0.09477177f, -0.14222327f, 0.31071058f, 0.27200472f, 0.48258021f, 0.01795403f, 
    0.04711601f, -0.05315899f, -0.03358288f, -0.02665788f, 0.08618135f, 0.00619025f, -0.10983997f, 0.02614910f, 
    -0.22392444f, 0.05479652f, 0.37325090f, -0.01030141f, -0.01976954f, -0.02468577f, -0.04068446f, 0.11228798f, 
    -0.08160914f, -0.03829388f, 0.04069804f, -0.01680611f, 0.20096314f, 0.17506750f, 0.25737649f, 0.24786772f, 
    -0.02805290f, -0.10210517f, -0.03026912f, -0.08721472f, -0.02517854f, 0.03878310f, -0.00489250f, 0.05845840f, 
    0.09951487f, 0.28081349f, 0.22010270f, 0.20048974f, -0.09342183f, 0.10877614f, -0.23335218f, 0.21276429f, 
    -0.01041550f, 0.05486761f, 0.03934608f, 0.01461950f, 0.04257456f, -0.00183511f, 0.11084491f, 0.05011545f, 
    -0.08085780f, 0.07926755f, 0.02352349f, -0.14704899f, -0.12991656f, -0.07841272f, -0.16521370f, 0.07748188f, 
    0.17220181f, -0.17129160f, 0.18573098f, 0.14646614f, -0.04816122f, -0.01429394f, -0.15248621f, -0.01879730f, 
    -0.30305067f, -0.31785229f, -0.49796715f, -0.17480999f, -0.16731101f, -0.07535087f, 0.14487970f, 0.25465861f, 
    0.03348944f, 0.01725160f, 0.06260607f, -0.17895570f, 0.28467670f, 0.13648194f, 0.04075789f, -0.03723266f, 
    0.17097594f, -0.00259731f, 0.22787955f, 0.06816965f, 0.00061424f, 0.00130919f, 0.03543298f, 0.14887683f, 
    -0.05380861f, -0.08025277f, -0.03537226f, 0.12999824f, -0.31264055f, 0.02431263f, -0.12909518f, 0.05904655f, 
    -0.11943649f, 0.13697025f, 0.17939606f, -0.03078729f, -0.14701639f, -0.11105092f, -0.02578549f, 0.05172389f, 
    0.02874979f, -0.07640457f, -0.01422896f, 0.02914849f, 0.00339946f, 0.02847838f, 0.00152239f, 0.01084066f, 
    -0.00489840f, -0.06234490f, -0.01283708f, -0.02035167f, -0.41561216f, 0.31816560f, -0.15016678f, 0.20760478f, 
    -0.07556973f, -0.00650125f, 0.10652206f, -0.16788504f, 0.07270730f, -0.08661950f, 0.02890032f, 0.13771981f, 
    0.42529097f, -0.14388146f, -0.26308247f, -0.37737051f, -0.04461507f, 0.13664043f, 0.11463751f, 0.15313824f, 
    0.23219797f, -0.00712545f, -0.22702828f, 0.04201281f, 0.38602445f, 0.09415621f, -0.05442379f, 0.19293572f, 
    0.02362673f, 0.00181025f, -0.27436706f, -0.00093983f, 0.05246595f, 0.04876583f, -0.03882127f, -0.11298760f, 
    -0.06173221f, -0.11070338f, -0.28795451f, -0.24220705f, -0.04043135f, 0.03318121f, -0.03396178f, -0.06670783f, 
    0.13373399f, -0.13218360f, -0.08180811f, -0.01715381f, 0.86952549f, -0.21471260f, -0.61885816f, -0.13096720f, 
    0.04112494f, -0.17020179f, 0.21912180f, -0.03398852f, 0.01350872f, -0.03330119f, -0.04488354f, -0.06617539f, 
    -0.20045200f, -0.08764898f, -0.10545862f, 0.15913235f, 0.13165697f, 0.01019634f, 0.04839384f, 0.10500666f, 
    -0.21841791f, -0.19916859f, -0.00909742f, -0.03032100f, -0.02471789f, -0.07925791f, -0.02095145f, 0.04320222f, 
    -0.00842605f, -0.01299584f, 0.05167202f, 0.00593397f, -0.01136816f, 0.07444080f, 0.13145272f, -0.08038414f, 
    0.25516412f, 0.50151485f, 0.42347488f, 0.25388163f, -0.05734583f, 0.05796226f, 0.05169969f, -0.00295832f, 
    0.01282357f, 0.02227841f, 0.01092860f, 0.00680573f, -0.15100448f, -0.02679861f, 0.20745346f, -0.08016662f, 
    0.04928983f, 0.16244778f, 0.15853420f, -0.25223339f, 0.02038108f, 0.07743177f, -0.01132666f, -0.00394997f, 
    -0.08261624f, -0.05674326f, 0.09629437f, -0.23908468f, 0.01812889f, 0.02426477f, -0.45104215f, -0.04762454f, 
    0.10443640f, -0.06377494f, 0.00580491f, 0.12813038f, 0.00859468f, 0.15732813f, 0.06615081f, 0.06459744f, 
    0.03098410f, -0.02214138f, -0.03916472f, -0.04539117f, 0.07202607f, 0.11897761f, 0.20274188f, -0.16478872f, 
    0.06672258f, 0.06268276f, -0.27147976f, 0.05974946f, -0.08095215f, 0.17094149f, -0.09745376f, -0.02042162f, 
    -0.08141813f, -0.08338749f, -0.07145824f, -0.05395535f, -0.06166906f, 0.02489418f, 0.05809304f, -0.26289535f, 
    0.07218944f, -0.13617678f, -0.14593269f, -0.06733081f, -0.03940196f, 0.00810599f, 0.01525931f, 0.10542172f, 
    -1.06259251f, -0.92218161f, 0.05421343f, -0.32282132f, 0.07149293f, -0.02615339f, -0.39773321f, -0.37279084f, 
    0.05155909f, -0.05595740f, -0.04955158f, -0.07438808f, -0.31482539f, 0.35588783f, 0.10857492f, 0.10124167f, 
    -0.19417889f, 0.10452805f, 0.03351665f, -0.30496484f, 0.08998707f, 0.02124414f, -0.07430179f, -0.08584973f, 
    -0.04017787f, -0.23209806f, 0.06645197f, -0.48278326f, -0.07157008f, -0.00154067f, -0.08367489f, 0.08247795f, 
    -0.03269048f, 0.01288839f, -0.13004135f, -0.00963518f, 0.17336835f, 0.80760598f, 0.25426975f, 0.63250279f, 
    0.08707838f, 0.19816431f, 0.07040981f, 0.04872165f, 0.01543222f, 0.02846710f, -0.05173936f, -0.06093740f, 
    -0.22959855f, 0.33125162f, 0.13688242f, 0.04302658f, -0.12701806f, 0.00867372f, 0.07252773f, 0.19326589f, 
    -0.02963452f, -0.06970143f, 0.00757442f, -0.00401506f, -0.68435645f, -0.61310858f, -0.24287993f, -0.16415912f, 
    0.05789620f, -0.05329920f, 0.18436441f, 0.09549527f, -0.02191988f, 0.01224408f, -0.03921146f, -0.01970993f, 
    -0.33502379f, -0.10241458f, 0.00466073f, 0.08466191f, -0.10312548f, -0.08303045f, 0.05928683f, 0.02114954f, 
    -0.03636145f, -0.06419737f, 0.05890549f, 0.02794792f, 0.21671151f, -0.01436770f, 0.29913500f, -0.50260299f, 
    0.00657771f, -0.24721169f, -0.07750040f, 0.01368835f, 0.02268708f, 0.06678254f, -0.00621406f, 0.08849844f, 
    -0.08426254f, -0.22959301f, -0.08646007f, -0.04000756f, -0.02484215f, 0.00352582f, 0.03027840f, -0.03189860f, 
    -0.02801138f, -0.08133439f, -0.19112866f, 0.10351874f, -0.17931353f, -0.14382434f, 0.08172131f, -0.12175833f, 
    -0.01451574f, 0.02139440f, -0.02204886f, 0.04432517f, 0.05469666f, -0.14678076f, 0.04709357f, -0.11466503f, 
    0.07611331f, -0.09383797f, 0.39442918f, 0.22753191f, -0.06832082f, -0.06133882f, 0.19200432f, -0.18782003f, 
    0.04215126f, -0.01557709f, -0.01236539f, 0.01025800f, -0.07430700f, 0.13796411f, -0.41095978f, -0.29951429f, 
    -0.02572540f, -0.08226893f, 0.08846921f, 0.02486227f, -0.00620325f, 0.03169807f, 0.02027859f, -0.00064405f, 
    -0.85968155f, -0.66712624f, -0.23703693f, -0.12561774f, -0.17980455f, 0.03774581f, -0.13256717f, 0.13312490f, 
    -0.01991251f, -0.03222602f, -0.06656117f, 0.00229475f, 0.01144665f, -0.01227849f, -0.05374762f, 0.09968606f, 
    0.04746391f, 0.01648989f, 0.03260772f, 0.06356613f, 0.05648474f, -0.19409478f, 0.08213464f, -0.07330403f, 
    -0.03119532f, -0.34373322f, 0.15126801f, -0.05699939f, 0.01633600f, -0.05581085f, -0.01940292f, 0.01562033f, 
    0.20995338f, 0.21545291f, 0.07264155f, 0.10207407f, -0.08671518f, -0.02118954f, -0.02112217f, 0.15149246f, 
    0.16898590f, -0.04900989f, 0.06102654f, -0.08944532f, -0.09433217f, -0.02188428f, 0.05015972f, -0.02276959f, 
    -0.04347209f, -0.18907292f, -0.07116477f, -0.43333480f, 0.34875673f, -0.01627604f, 0.03837621f, 0.11033238f, 
    0.03316471f, -0.08417132f, -0.07330280f, -0.09318138f, 0.16898997f, -0.20408009f, 0.03363312f, 0.26164237f, 
    0.01530945f, 0.05541137f, -0.31678441f, 0.27496937f, 0.12574293f, -0.07413521f, -0.01735369f, 0.07622713f, 
    0.05752143f, -0.02359221f, -0.00066055f, -0.06704719f, 0.23679896f, 0.14418261f, -0.15638000f, 0.18217240f, 
    0.00522185f, -0.05085383f, -0.04107168f, -0.00121126f, 0.23006222f, 0.39378098f, -0.42489862f, 0.05699829f, 
    -0.01203091f, 0.09737943f, -0.21267842f, 0.33256149f, 0.04439072f, 0.00015592f, 0.00671694f, -0.08614557f, 
    -0.07055584f, 0.51855600f, 0.58512682f, -0.05344689f, -0.09878217f, 0.00966724f, 0.06976389f, -0.16840829f, 
    -0.15757765f, -0.14916325f, -0.10442273f, -0.03129087f, -0.33544919f, -0.03288165f, -0.01923869f, 0.01566705f, 
    -0.03351836f, -0.04876868f, -0.17726935f, 0.16699296f, -0.04884735f, -0.09010671f, 0.04963220f, 0.05550769f, 
    0.12955703f, 0.50693262f, 0.09126331f, 0.30542916f, -0.03388865f, -0.01206846f, 0.05294031f, -0.03046043f, 
    0.03316560f, 0.04773931f, 0.06937221f, 0.08808109f, -0.25387019f, 0.50549275f, 0.36227277f, -0.04292077f, 
    -0.12477022f, -0.14692572f, -0.05678332f, 0.12279995f, 0.09891412f, 0.04317619f, -0.15885749f, 0.03350178f, 
    0.07262204f, 0.13684708f, -0.13516296f, -0.65602678f, 0.40006435f, 0.13116126f, 0.03046491f, 0.11870058f, 
    -0.29722026f, -0.03732606f, -0.14160910f, -0.01592469f, 0.26873475f, 0.07132678f, -0.22729376f, 0.19609115f, 
    -0.13959718f, -0.08378757f, 0.04430586f, 0.00180362f, -0.03507038f, 0.18339674f, -0.08438678f, -0.04103125f, 
    0.60250300f, -0.33489680f, -0.08237924f, 0.29372275f, 0.13129088f, 0.01084824f, -0.00809893f, -0.16859742f, 
    -0.00759415f, 0.04109966f, -0.00745608f, 0.13231501f, -0.28759858f, -0.23793000f, -0.21930210f, 0.14259791f, 
    -0.06339680f, -0.05760759f, 0.07320604f, -0.29666445f, 0.06338964f, -0.09266007f, 0.05097915f, -0.06983359f, 
    -0.30291742f, 0.02120248f, 0.51794744f, 0.10316214f, -0.39132127f, 0.04460744f, -0.14409831f, 0.02638058f, 
    0.17628439f, 0.01650755f, -0.15746547f, 0.10617801f, -1.13298881f, 0.95685047f, -0.39181232f, 0.68252790f, 
    0.08659927f, -0.05774964f, 0.24977423f, -0.08958998f, -0.05743042f, -0.04271957f, 0.07553878f, 0.04757991f, 
    0.40547878f, -0.14582373f, 0.01355800f, 0.11734481f, -0.00525388f, -0.14049317f, -0.08028659f, 0.00850382f, 
    -0.09661770f, 0.15651424f, -0.02268166f, 0.11495887f, 0.18118356f, 0.14947517f, -0.08741914f, 0.37755844f, 
    -0.22267179f, -0.05137282f, 0.10176254f, -0.01323587f, -0.02517105f, 0.15690197f, -0.08764389f, 0.34065732f, 
    -0.08990572f, -0.24514584f, 0.30388033f, 0.36740309f, 0.00278507f, 0.20100838f, 0.03004833f, 0.06587853f, 
    -0.11041735f, -0.06531148f, 0.03612462f, -0.09879733f, -0.64395261f, 0.30023363f, -0.15906703f, 0.07242113f, 
    0.00190170f, -0.15292676f, 0.06565426f, -0.31690621f, -0.16073945f, -0.01080216f, -0.13399135f, -0.04711077f, 
    -0.31897798f, -0.23322529f, 0.61941022f, -0.21395163f, -0.25603473f, -0.47048450f, -0.09262764f, -0.06744230f, 
    -0.07613610f, 0.06846707f, 0.02826376f, 0.04225454f, 0.29170534f, -0.30900833f, -0.18168962f, 0.22504069f, 
    0.10220035f, -0.09136787f, -0.05401344f, -0.04221595f, 0.03775745f, -0.02907006f, 0.02671582f, -0.00403777f, 
    -0.12946080f, -0.02435713f, 0.00205057f, 0.40269259f, 0.06223746f, 0.01073284f, 0.18266420f, -0.07429467f, 
    -0.08560432f, -0.00855981f, 0.31173488f, 0.08496022f, -0.12906125f, -0.07830440f, -0.33667898f, 0.03457506f, 
    0.19965923f, 0.12235126f, 0.19220062f, 0.05702562f, 0.10924394f, 0.08745089f, 0.02262282f, 0.06226923f, 
    -0.24963668f, -0.23945461f, -0.04052876f, -0.20305182f, -0.38810432f, -0.05670277f, -0.41477180f, -0.05683057f, 
    0.08541052f, -0.12395672f, 0.17387214f, -0.12740885f, 0.26825318f, -0.12058786f, 0.36782604f, 0.08114429f, 
    -0.18678594f, 0.09382353f, -0.14177167f, 0.00457623f, -0.02866057f, 0.07647087f, 0.01471564f, -0.03699809f, 
    0.23421858f, 0.02331449f, -0.08023819f, 0.19776811f, 0.18664442f, -0.06464961f, 0.09616381f, -0.07359193f, 
    0.11920504f, 0.14871429f, 0.04978168f, 0.20059362f, -0.44819608f, -0.07566491f, -0.17806377f, -0.22748427f, 
    -0.04946807f, -0.25364003f, -0.06627619f, -0.32697535f, -0.07116089f, -0.00889865f, -0.04810449f, -0.07693483f, 
    -0.03232922f, 0.23601855f, -0.06421439f, 0.06899589f, 0.04897753f, -0.03156073f, 0.01801395f, 0.15248011f, 
    -0.19665919f, 0.13952085f, -0.29981619f, 0.07640354f, -0.17108256f, -0.14198884f, -0.06558895f, 0.20992802f, 
    -0.18552746f, -0.43372944f, -0.22956245f, 0.17800471f, 0.04055186f, -0.15470760f, -0.00865983f, 0.24612994f, 
    -0.11999780f, -0.20190194f, -0.07462095f, 0.13414329f, 0.00253809f, -0.01010864f, 0.06788897f, 0.11540263f, 
    -0.11616185f, -0.02546323f, -0.15940075f, -0.05283288f, 0.10406047f, 0.06300484f, -0.38330632f, -0.15532468f, 
    0.18263216f, 0.09073778f, 0.13830785f, -0.01687679f, -0.07398709f, 0.04184459f, -0.18239771f, -0.19032556f, 
    0.18371548f, 0.19017519f, -0.37694818f, 0.04750770f, 0.20937555f, -0.06205757f, 0.08308212f, -0.20280062f, 
    -0.23126082f, 0.07169944f, -0.00590138f, 0.13295157f, 0.05223481f, 0.30391705f, -0.37832007f, -0.20647100f, 
    0.16499710f, -0.10229583f, -0.08282645f, -0.23565933f, -0.43298000f, -0.20080589f, -0.09037802f, 0.01663838f, 
    0.25717404f, 0.05492334f, 0.04328381f, 0.14483389f, -0.05165633f, 0.02990664f, -0.14414413f, 0.03871725f, 
    0.06993069f, 0.19408926f, 0.06204362f, -0.18035495f, 0.16802543f, -0.19927840f, -0.23973896f, 0.00907446f, 
    0.13407108f, 0.01874104f, -0.07012896f, -0.07290287f, -0.09992974f, 0.08694494f, -0.08576600f, 0.12404842f, 
    0.06952608f, 0.00301706f, -0.41307122f, 0.07193588f, 0.02870047f, -0.02347416f, 0.00434717f, -0.18660615f, 
    -0.17995967f, -0.17577812f, 0.00938362f, -0.18218647f, -0.46058503f, 0.56996107f, -0.38867569f, -0.40892595f, 
    -0.09956648f, -0.05749438f, -0.12848286f, -0.02426941f, -0.10413218f, 0.02221324f, -0.01809673f, 0.21541172f, 
    -0.08217037f, 0.05296902f, -0.03801808f, 0.45921931f, 0.15339039f, -0.08763175f, 0.06377272f, -0.06981918f, 
    -0.05921199f, 0.15484737f, 0.17541653f, -0.00699067f, -0.09149869f, -0.16091728f, -0.05031785f, 0.10248064f, 
    0.02904505f, 0.06640416f, -0.15299755f, -0.13050386f, -0.17958559f, 0.13349620f, 0.00179282f, -0.01746702f, 
    0.42579263f, -0.43219680f, 0.00996861f, 0.28607681f, 0.25312963f, 0.16608755f, 0.05760380f, -0.01863982f, 
    -0.03745641f, 0.02214787f, -0.08759820f, -0.02338399f, -0.19292654f, 0.19057183f, -0.22895211f, 0.34130576f, 
    0.16794659f, 0.04171252f, 0.08865725f, -0.01559269f, -0.07479609f, -0.05728127f, -0.07526372f, 0.05338580f, 
    0.11583780f, -0.02073433f, -0.40131530f, 0.13549201f, -0.05292299f, -0.03373574f, 0.04504813f, -0.00215109f, 
    0.03015237f, -0.11351882f, -0.27493972f, -0.13572258f, 0.06957062f, 0.10381912f, 0.19941834f, 0.12328399f, 
    -0.06583454f, 0.05148944f, -0.07319956f, 0.06923991f, -0.18504331f, -0.02391871f, -0.11356906f, 0.07730698f, 
    -0.45273739f, -0.05140904f, 0.07275669f, -0.00616130f, -0.03653361f, -0.06649565f, -0.01785332f, 0.01469026f, 
    -0.12467840f, -0.00196910f, 0.03199943f, 0.03341934f, -0.17510140f, 0.13862349f, -0.06244279f, 0.00489644f, 
    -0.20482917f, 0.00569264f, -0.11613200f, -0.03750303f, -0.10923977f, -0.03837004f, -0.15735325f, 0.06700277f, 
    0.22053169f, 0.20601836f, -0.18788978f, 0.26236135f, 0.10088884f, -0.02445911f, 0.21435513f, -0.26715183f, 
    0.21149592f, -0.10224594f, 0.05897484f, -0.01912715f, -0.12796491f, -0.20449513f, -0.21350138f, -0.40188083f, 
    0.03488776f, 0.10677959f, -0.09969443f, 0.02468516f, 0.08473188f, 0.04846971f, -0.24214798f, 0.13503930f, 
    -0.17813912f, 0.07749767f, 0.18219927f, 0.09092879f, -0.20165309f, -0.08943571f, -0.19269116f, 0.02730908f, 
    -0.23023237f, -0.30247119f, 0.00143757f, -0.19178566f, 0.20952424f, 0.01365131f, 0.09782799f, 0.28779209f, 
    -0.00640352f, -0.11215471f, -0.18370005f, -0.16313715f, -0.00731995f, 0.02853478f, 0.09610078f, 0.05465879f, 
    0.11798317f, 0.48027584f, 0.24518685f, 0.31557903f, -0.05642445f, 0.10004222f, 0.15577319f, 0.24775380f, 
    0.01679749f, -0.03285940f, -0.02966261f, -0.16239469f, 0.05210148f, -0.33292633f, 0.03595221f, -0.10378646f, 
    0.03888116f, 0.07412644f, -0.08271138f, 0.00891437f, -0.06812526f, -0.13941608f, 0.05902253f, 0.03320909f, 
    0.06100988f, 0.57423145f, -1.01315010f, -0.12627347f, 0.01777180f, 0.06556761f, -0.00485612f, 0.01092703f, 
    0.04832607f, -0.02637794f, 0.01928894f, -0.15685439f, 0.00280093f, -0.09013519f, 0.17345029f, 0.03167057f, 
    -0.18550806f, -0.11083692f, -0.11252551f, -0.06481527f, 0.08128032f, -0.01789680f, -0.12990695f, -0.05500847f, 
    0.10145226f, 0.22206698f, 0.35947952f, 0.35149428f, -0.03980276f, 0.13306198f, -0.12089790f, 0.33011916f, 
    0.00496814f, -0.05883234f, -0.06858426f, -0.00827115f, 0.20231944f, 0.20823810f, 0.39467230f, 0.18245623f, 
    0.03459000f, -0.19248198f, -0.34151560f, 0.00559942f, 0.03904137f, 0.09869872f, 0.17961691f, 0.10550126f, 
    -0.01942467f, 0.14706582f, -0.08356044f, 0.01787169f, -0.04457690f, 0.11090252f, 0.06089464f, 0.01236127f, 
    0.12187780f, -0.02686703f, -0.01382316f, -0.01836028f, 0.18974960f, 0.09195550f, -0.30549672f, 0.16411348f, 
    0.10805310f, -0.25378200f, 0.11199784f, -0.41672841f, -0.04898094f, -0.18288086f, 0.01369896f, -0.04015610f, 
    0.16151386f, 0.02180888f, -0.00306517f, 0.10090664f, 0.10355311f, -0.01208244f, 0.00639496f, 0.07986911f, 
    -0.07720344f, -0.18832353f, -0.21524295f, -0.13962254f, -0.37671050f, -0.17161748f, -0.98355800f, -0.11578162f, 
    0.10378388f, -0.02997748f, 0.03029545f, -0.00620098f, 0.00085963f, -0.07662620f, -0.09307675f, -0.26005352f, 
    0.23094682f, -0.30292952f, -0.06492840f, -0.03650909f, -0.22848357f, -0.23680729f, 0.17119691f, -0.09802143f, 
    0.17721498f, 0.02017157f, 0.04837549f, 0.00216499f, -0.03836856f, -0.16710916f, -0.04327721f, 0.13073584f, 
    0.06258970f, 0.08839695f, 0.03362831f, 0.01881221f, 0.04589445f, 0.01189695f, 0.01689430f, 0.02163921f, 
    0.00132470f, -0.08777767f, 0.11097468f, 0.20285952f, 0.03164471f, 0.08963325f, 0.16024554f, 0.01497429f, 
    -0.05136557f, 0.01448190f, 0.02007810f, -0.06623110f, 0.14340198f, -0.03725186f, -0.04904442f, -0.03572755f, 
    -0.02493302f, 0.07745317f, -0.11692704f, 0.08662509f, 0.17617798f, 0.01743948f, 0.00984325f, -0.31579691f, 
    -0.32121202f, -0.11110412f, -0.08019596f, -0.09075094f, 0.02352973f, -0.01198848f, -0.00279395f, -0.06032434f, 
    0.27432629f, 0.21848063f, 0.22785673f, 0.23066762f, 0.02769881f, -0.31927916f, 0.12856597f, -0.03789091f, 
    -0.09680174f, 0.13104068f, -0.03896242f, 0.10786504f, -0.22863184f, -0.00808396f, -0.31088841f, -0.33776075f, 
    -0.00319194f, 0.01764412f, -0.17913879f, 0.22524112f, 0.14480829f, -0.15778475f, -0.19190103f, -0.18470205f, 
    -0.01089404f, -0.07993381f, -0.08247110f, -0.00004996f, 0.10075834f, 0.13614187f, 0.05103817f, 0.12986510f, 
    -0.31968343f, -0.09809213f, -0.03802830f, -0.09471344f, 0.03973080f, 0.08213058f, -0.04800175f, 0.00423667f, 
    0.04134376f, 0.07301367f, -0.09194671f, -0.07589746f, -0.09470447f, -0.01243949f, 0.01454272f, -0.17131305f, 
    -0.02365222f, -0.06908985f, -0.05786151f, -0.09874830f, -0.02068639f, -0.70366877f, 0.60610759f, -0.01976039f, 
    -0.15476649f, -0.00581236f, -0.12332622f, 0.05426730f, -0.06175226f, 0.09383885f, -0.01352237f, 0.05032726f, 
    0.11725335f, 0.15429817f, 0.07951047f, 0.19779104f, -0.10971289f, -0.20111024f, -0.00150873f, -0.12908177f, 
    -0.07779475f, -0.21005198f, 0.07350504f, -0.03191186f, -0.02891343f, -0.00824594f, 0.03120976f, 0.18921734f, 
    0.00887846f, 0.05410175f, 0.03427350f, -0.09899368f, 0.00190181f, -0.01619657f, 0.09774372f, 0.25676629f, 
    0.09416481f, 0.40118334f, 0.07321937f, 0.02046851f, -0.00819807f, -0.05320051f, 0.06148322f, 0.16562679f, 
    0.18605772f, -0.06939925f, -0.11615957f, 0.10970049f, -0.30764705f, -0.10946215f, 0.14272325f, -0.11334142f, 
    0.13023293f, 0.04718626f, -0.27428320f, 0.09128334f, -0.18815918f, 0.03287806f, 0.02128541f, 0.13261260f, 
    -0.39670554f, -0.46932331f, 0.43579146f, 0.25249845f, -0.11448011f, -0.13322367f, -0.04124127f, -0.07802948f, 
    0.27056298f, 0.04104080f, 0.21414839f, 0.00970500f, 0.03916167f, -0.13220590f, 0.11810777f, 0.06715409f, 
    -0.09952654f, -0.18477510f, -0.20482732f, -0.12167201f, -0.23359178f, -0.09993492f, -0.01194263f, 0.03101070f, 
    -0.09492581f, 0.09606411f, -0.24216761f, -0.33522949f, -0.02280771f, -0.11073735f, 0.02588604f, 0.33645010f, 
    -0.03372204f, -0.13337332f, -0.08874746f, 0.09976909f, 0.37422493f, -0.12094641f, 0.01564608f, -0.14960399f, 
    0.14018878f, -0.02457394f, -0.22105472f, 0.43947029f, 0.11605083f, -0.06542263f, -0.07679298f, 0.09012721f, 
    -0.01399335f, -0.11121999f, -0.29168960f, 0.04828110f, -0.01946106f, 0.00787275f, 0.16455528f, 0.02559284f, 
    -0.07697701f, 0.18252131f, -0.03588930f, -0.21991609f, 0.26178971f, 0.15253858f, 0.03128101f, -0.31747478f, 
    0.00124709f, -0.01034695f, -0.01525065f, -0.02425304f, -0.22568823f, 0.18217884f, -0.53037661f, -0.56645340f, 
    0.16777886f, -0.14483355f, 0.06602764f, 0.12827024f, 0.01809443f, 0.01404087f, 0.06366567f, -0.08100170f, 
    0.03587598f, -0.04247198f, 0.06416479f, 0.19241042f, -0.11360099f, -0.14189185f, 0.37416732f, 0.03283192f, 
    0.10530488f, -0.02626336f, -0.10368857f, 0.09105854f, 0.09671868f, -0.11339694f, 0.00239375f, -0.31837535f, 
    0.07897235f, 0.15887426f, -0.07852850f, -0.06580137f, 0.25361183f, -0.00481134f, -0.06381452f, -0.13129082f, 
    -0.01553434f, -0.01914934f, 0.04353819f, 0.03085125f, -0.20371504f, -0.35528263f, 0.22038670f, -0.17042641f, 
    0.22052258f, -0.25568831f, -0.08943522f, 0.28525814f, 0.16798848f, 0.12138218f, -0.12435243f, -0.02777437f, 
    -0.06653376f, -0.12814125f, -0.73936725f, 0.47681308f, 0.10224205f, 0.06225154f, -0.02254687f, 0.06298558f, 
    0.06208534f, -0.05358506f, 0.10417221f, 0.06029453f, -0.10341060f, 0.17152722f, 0.08592138f, 0.16420296f, 
    0.24746612f, 0.22867450f, 0.19650663f, 0.01751070f, 0.01743514f, 0.01242185f, 0.01840550f, 0.05093996f, 
    -0.06077452f, 0.09104875f, -0.21649003f, -0.03186123f, 0.33178991f, -0.08649211f, 0.09588987f, -0.00824866f, 
    0.14262827f, -0.03567296f, -0.08859795f, 0.10872497f, 0.21793480f, 0.31446296f, 0.19482851f, -0.29910630f, 
    0.15772802f, 0.06119064f, -0.03563666f, -0.10602863f, 0.00517743f, -0.12900637f, -0.04008096f, -0.02486036f, 
    -0.21630818f, -0.26222390f, 0.06904465f, 0.07960982f, 0.05252696f, -0.08732613f, 0.00793276f, 0.00323766f, 
    0.01080012f, 0.07982565f, -0.05661996f, -0.00234436f, -0.34916222f, 0.25495902f, -0.21688032f, -0.18679777f, 
    0.12453262f, -0.03580689f, 0.04834937f, 0.05267015f, 0.01807209f, -0.35848895f, 0.13409409f, 0.08908886f, 
    -0.20254603f, 0.05961012f, -0.07744363f, -0.18663083f, -0.45245743f, 0.03551852f, -0.07413377f, -0.13311771f, 
    0.10694717f, 0.02253387f, -0.09132504f, 0.13196921f, 0.11928603f, -0.23719504f, -0.39863747f, 0.26664135f, 
    -0.09829538f, -0.02647367f, -0.07734276f, 0.05257689f, 0.02091406f, -0.05862459f, 0.17715898f, 0.16679443f, 
    -0.21517918f, 0.03652777f, -0.34126258f, -0.10540340f, 0.31886727f, -0.02071040f, -0.01925472f, -0.00761700f, 
    0.14220230f, 0.02368109f, 0.03368621f, -0.00948083f, -0.17082267f, -0.01913846f, -0.12656642f, 0.00112653f, 
    0.08976986f, 0.09526090f, -0.03608478f, 0.02559549f, -0.06917959f, -0.04246977f, 0.02336455f, -0.05830237f, 
    0.13228984f, 0.13681914f, 0.19829985f, -0.13342582f, 0.18665132f, -0.01075991f, 0.16207300f, -0.18198141f, 
    0.07166448f, -0.01733757f, 0.09897020f, 0.04374762f, -0.16156234f, -0.08899471f, 0.01720933f, 0.12142723f, 
    0.03633081f, -0.21032108f, 0.10756619f, 0.06870171f, -0.01432854f, -0.11862846f, 0.17889196f, 0.26275247f, 
    -0.27704662f, 0.16736150f, -0.12632763f, -0.47512525f, -0.00660042f, -0.04728207f, 0.14003576f, 0.05562817f, 
    0.02843133f, -0.34199440f, -0.23754655f, -0.45894340f, 0.07675897f, 0.09006701f, -0.07604146f, -0.09260871f, 
    -0.08569209f, 0.04516945f, -0.06048844f, 0.06402895f, -0.05557036f, -0.01066593f, 0.18693209f, 0.37642652f, 
    -0.19217749f, 0.33461264f, 0.10980750f, -0.20139107f, 0.07049784f, 0.13531847f, 0.29111558f, 0.01945083f, 
    0.04325567f, 0.13840614f, -0.02727919f, 0.03329952f, -0.13885249f, -0.30575228f, 0.25204253f, -0.22566266f, 
    0.20369014f, -0.08492156f, -0.07228084f, 0.20376869f, 0.08501750f, -0.01534189f, -0.03157957f, 0.00732130f, 
    -0.15653090f, -0.11788294f, 0.22219013f, 0.05886771f, -0.09939262f, 0.18131442f, 0.08015979f, 0.02348316f, 
    0.12242287f, 0.17084259f, 0.14452158f, 0.12370642f, 0.33868334f, -0.23819084f, 0.32444119f, 0.03260563f, 
    0.08455913f, 0.01154583f, -0.05144469f, 0.15321861f, 0.02534232f, 0.06747975f, 0.02528339f, -0.07469639f, 
    -0.24005093f, -0.17445616f, -0.13173392f, -0.36814830f, -0.01312834f, 0.09261815f, 0.03930273f, 0.00429835f, 
    0.09563915f, -0.10489736f, 0.10604502f, -0.11735220f, -0.14960325f, -0.06674532f, 0.34484690f, -0.07698733f, 
    -0.14281152f, -0.02465608f, 0.01155665f, 0.09944637f, 0.08903029f, -0.09633775f, -0.14603855f, 0.05779414f, 
    -0.58792651f, -0.54984176f, -0.30385482f, -0.06407630f, -0.03637508f, 0.03265721f, -0.02776391f, -0.02110945f, 
    -0.12711392f, -0.06220437f, 0.14651987f, 0.00796962f, -0.12983473f, 0.01935288f, -0.23939833f, -0.43202451f, 
    -0.14837064f, 0.11946237f, -0.22072822f, -0.10804959f, 0.21092275f, -0.09975395f, -0.03776309f, 0.16438314f, 
    -0.32969478f, -0.08974859f, 0.30444643f, 0.29852140f, 0.00482708f, -0.01811687f, -0.06598082f, -0.02080382f, 
    -0.05191976f, 0.19667204f, 0.17622560f, 0.01362711f, -0.11202556f, -0.19351508f, -0.27823135f, 0.16725157f, 
    -0.21105994f, 0.11329009f, 0.13335645f, 0.03443310f, 0.17084698f, 0.00269215f, 0.05597197f, 0.13546687f, 
    -0.31010118f, 0.16823170f, 0.08818089f, 0.44801235f, -0.16249228f, 0.05385641f, 0.09138727f, 0.30243018f, 
    0.05389178f, 0.00017487f, 0.06532562f, -0.00174037f, -0.52884096f, -0.34024465f, -0.68829536f, -0.27397829f, 
    -0.06443086f, 0.15188867f, 0.03794673f, 0.22875039f, 0.13180202f, -0.02936650f, 0.10815547f, -0.03128447f, 
    0.30255541f, -0.17011791f, -0.14408100f, -0.11322856f, 0.03417209f, 0.16724516f, 0.25988463f, 0.03988010f, 
    0.06121353f, -0.01157129f, 0.05239673f, 0.02193190f, -0.46269932f, 0.03069017f, -0.02631702f, 0.16922849f, 
    0.01629713f, 0.09907710f, 0.08623544f, -0.11168092f, 0.12438599f, 0.03759233f, 0.33785495f, 0.01654586f, 
    -0.21638918f, -0.05648496f, -0.10152901f, -0.51969987f, -0.07814033f, -0.32001454f, 0.28504184f, 0.06203529f, 
    -0.10574290f, 0.11770386f, -0.12088135f, 0.00112842f, -0.13801017f, -0.47261903f, -0.56914943f, 0.25161591f, 
    -0.05454705f, 0.31770051f, 0.08349367f, 0.08877969f, 0.04192128f, 0.09739892f, -0.03420554f, -0.04221411f, 
    0.00635646f, -1.07825267f, -0.73333699f, -0.40805113f, -0.03707133f, -0.06637290f, 0.14116058f, -0.30022791f, 
    0.08251543f, -0.01991746f, -0.12872736f, -0.01057237f, 0.24912582f, 0.72278148f, -0.41692510f, -0.24957727f, 
    0.02959200f, -0.07865108f, 0.07484475f, 0.38429752f, 0.10613772f, -0.00817910f, 0.21571679f, 0.06121388f, 
    0.15941350f, 0.03431151f, 0.29196814f, -0.54504073f, -0.05386735f, 0.03967566f, 0.13986237f, -0.16791825f, 
    -0.02324698f, -0.05527841f, 0.05711072f, 0.05474168f, -1.08500397f, -0.38038895f, -0.03629477f, 0.14633887f, 
    -0.19920778f, -0.05692286f, -0.00046305f, -0.23536909f, -0.01502742f, -0.00252572f, -0.01760837f, 0.01827583f, 
    -0.71331388f, -0.84499824f, -0.62785643f, -0.03126509f, 0.30302694f, 0.05967471f, 0.15202802f, -0.11246589f, 
    -0.02773117f, 0.04293390f, -0.01471301f, -0.00525980f, -1.03625631f, -0.23069400f, 0.12747835f, -0.02891227f, 
    -0.22927961f, 0.04871485f, -0.40662074f, -0.39288011f, -0.09802582f, 0.00805469f, 0.00625684f, -0.00696781f, 
    0.14609867f, -0.14480500f, -0.37323612f, -0.24086604f, -0.09386539f, 0.08758196f, -0.01561934f, -0.00438755f, 
    -0.11899795f, 0.01817467f, -0.09199795f, -0.17290086f, 0.24389793f, -0.20198515f, 0.43745530f, -0.34748852f, 
    0.09135071f, 0.16078660f, -0.05827487f, -0.03901044f, 0.22891884f, 0.10373332f, 0.11231668f, -0.00882329f, 
    -0.15886267f, -0.03261076f, 0.03240368f, -0.13369311f, 0.15226728f, -0.32964221f, -0.04560765f, 0.00705997f, 
    0.04099398f, -0.02553811f, 0.02581830f, -0.34814718f, 0.03074321f, -0.04296202f, -0.21227674f, 0.03563065f, 
    0.07492372f, -0.09322757f, 0.02547408f, -0.02360915f, 0.04599600f, 0.13238584f, -0.19671114f, -0.01616354f, 
    -0.40714622f, 0.04957939f, 0.16236381f, -0.14006193f, -0.01512361f, -0.07848597f, 0.12580796f, -0.16893674f, 
    -0.02677604f, -0.00486295f, 0.00844907f, -0.02073536f, -0.48478857f, -0.12135043f, -0.01191632f, 0.04371789f, 
    0.13203029f, -0.07177855f, -0.06572720f, -0.00524218f, -0.02449257f, -0.01615423f, -0.02842342f, -0.02112721f, 
    -0.49391192f, -0.53203177f, -0.43317583f, -0.05390023f, 0.01274440f, -0.30281457f, -0.15880756f, -0.56913948f, 
    -0.04359622f, -0.05532316f, 0.08339208f, -0.08900147f, 0.00372267f, -0.06653775f, 0.20367229f, 0.02531794f, 
    0.00643625f, -0.04685736f, -0.06829423f, 0.19989105f, -0.04349359f, 0.13860448f, -0.14429542f, -0.28303859f, 
    0.02369281f, 0.03189075f, 0.06871781f, -0.00966965f, 0.02359800f, 0.05348566f, 0.11006431f, 0.09092448f, 
    0.03486821f, 0.22203165f, 0.43336287f, 0.32246494f, -0.10092633f, -0.12027434f, 0.09198070f, -0.18173045f, 
    0.23389071f, -0.13751970f, -0.13545255f, 0.14865132f, -0.08862101f, 0.04648269f, -0.12237737f, 0.05238643f, 
    -0.54874653f, -0.55640227f, -0.02034656f, -0.51521194f, 0.08102467f, -0.30231667f, -0.26642868f, -0.48260635f, 
    -0.05884350f, 0.00363063f, 0.00120339f, -0.10254398f, -0.48809969f, 0.02010535f, 0.26454407f, -0.01395439f, 
    -0.07317357f, -0.30158734f, 0.11201239f, 0.19805340f, -0.04802419f, 0.11633190f, -0.00159422f, -0.02715463f, 
    -0.08694611f, -0.10217264f, 0.06864986f, 0.29278684f, -0.12960662f, -0.26506415f, 0.07669993f, 0.09255969f, 
    -0.04845903f, -0.01622118f, -0.05897602f, -0.08539845f, -0.07619510f, -0.33382392f, -0.09646613f, 0.47314629f, 
    0.08424914f, 0.24398708f, 0.05579851f, 0.06248362f, 0.15552376f, -0.04075035f, 0.05358895f, 0.02386563f, 
    -0.49287149f, 0.72288370f, 0.36445254f, 0.44738045f, -0.03099316f, -0.08945523f, -0.01718534f, -0.01202426f, 
    -0.13623248f, 0.21228375f, 0.09240802f, 0.03364736f, -0.73742002f, -0.86088711f, -0.64807951f, -0.17720674f, 
    -0.17552735f, -0.10992098f, 0.18210228f, -0.15683563f, -0.05322792f, 0.11113509f, 0.00108835f, -0.06784988f, 
    -0.03799649f, 0.41781256f, 0.17139003f, 0.23976821f, -0.08526353f, -0.00733377f, -0.09402400f, -0.05452077f, 
    -0.02065277f, 0.07399426f, 0.03992609f, 0.09765188f, 0.15056486f, 0.37212795f, 0.06941603f, 0.17941196f, 
    0.10787318f, -0.27123407f, 0.16722730f, 0.01498849f, 0.13654611f, 0.11197156f, 0.04958529f, -0.01478778f, 
    0.44211143f, 0.10981922f, -0.07966155f, -0.50281286f, 0.00382259f, 0.05614341f, -0.12039280f, 0.08949260f, 
    -0.19830437f, -0.04722305f, -0.19185872f, -0.24883917f, 0.05807184f, -0.19461517f, 0.05379348f, -0.07269600f, 
    -0.02902074f, 0.29456180f, 0.03698451f, -0.02771201f, -0.11401171f, 0.03411153f, -0.04781752f, -0.00987891f, 
    -0.43490595f, -0.37647331f, -0.41844001f, -0.07516240f, 0.05848934f, 0.22960104f, 0.09675357f, -0.11630708f, 
    0.04827756f, -0.01616789f, -0.08810087f, 0.06053110f, -0.23727466f, -0.14092040f, -0.16256416f, -0.35932317f, 
    -0.01217717f, 0.00596146f, 0.17643583f, -0.17378315f, -0.01761024f, -0.02120092f, -0.03658284f, -0.06788972f, 
    -0.06904506f, 0.16053961f, -0.05530751f, -0.03303509f, -0.05302658f, 0.12517019f, 0.05093892f, 0.00933467f, 
    0.06226761f, 0.03601835f, 0.08787373f, 0.09908340f, 0.11097372f, -0.08160585f, -0.03006952f, 0.03389607f, 
    -0.02392682f, -0.08890832f, 0.01548066f, -0.00004917f, -0.02138498f, 0.06776557f, 0.14697541f, -0.08155892f, 
    -0.11079174f, 0.12816739f, -0.29031375f, 0.43385139f, -0.10213016f, 0.18595754f, 0.06848042f, -0.10347189f, 
    -0.06379759f, -0.05090258f, 0.00797359f, 0.09594670f, 0.22986424f, -0.65034533f, 0.00536164f, -0.03336280f, 
    -0.17581892f, 0.04066060f, -0.05612003f, -0.05561608f, 0.07129083f, -0.03111671f, 0.06807013f, 0.10255794f, 
    -1.12197185f, 0.55782485f, 0.12786463f, 0.33818507f, 0.08061246f, -0.18313009f, -0.03963669f, 0.03162743f, 
    -0.00072482f, -0.03448033f, -0.00819926f, -0.03443935f, -0.08176059f, -0.13909814f, -0.25342366f, 0.07748556f, 
    0.00258323f, -0.07966401f, 0.04001229f, -0.06475750f, -0.26425874f, 0.01932735f, 0.07263091f, -0.00830100f, 
    -0.07254219f, 0.32318568f, -0.25096253f, 0.16615105f, -0.02195885f, -0.00278903f, 0.07101081f, -0.03857600f, 
    0.00757071f, 0.02782854f, 0.07205527f, -0.06630134f, -0.22842282f, -0.12467816f, -0.62910324f, -0.45402533f, 
    0.17304137f, -0.24525753f, 0.08836597f, 0.01060576f, 0.06268801f, -0.04478055f, -0.00816523f, 0.06216228f, 
    -0.28612670f, 0.08123630f, 0.00147527f, -0.14036225f, 0.01807520f, -0.13070662f, -0.10291316f, -0.11492956f, 
    -0.01573858f, 0.00710128f, 0.01693184f, 0.03602321f, -0.31533071f, -0.50274390f, 0.20038496f, 0.03209783f, 
    0.18193875f, 0.18710853f, 0.13509284f, 0.22216117f, 0.01521864f, -0.10838342f, 0.04545116f, -0.04976668f, 
    0.06991062f, -0.04673291f, -0.04808525f, -0.00748411f, -0.04090622f, -0.01348875f, -0.13613656f, -0.00435636f, 
    -0.00115110f, -0.03359967f, -0.08177801f, 0.02923531f, -0.51910281f, 0.80081952f, -0.34787655f, 0.34266064f, 
    -0.28345951f, 0.10506703f, -0.17784718f, -0.15274437f, 0.04713641f, -0.03950950f, 0.00690351f, -0.05461541f, 
    0.16297314f, 0.07342946f, -0.05434657f, -0.00943371f, 0.00348350f, 0.06739493f, 0.12675005f, 0.04855939f, 
    0.00116326f, -0.04522483f, -0.06580868f, -0.01312639f, -0.06895556f, -0.00437962f, 0.11730587f, -0.03688423f, 
    -0.01829599f, -0.00933351f, -0.02482864f, -0.06571294f, 0.02212100f, 0.02264644f, 0.02897574f, -0.13466905f, 
    0.53186089f, -0.09595703f, -0.06606924f, -0.28296828f, -0.10081641f, -0.05075058f, -0.14844421f, -0.00957262f, 
    0.09115387f, 0.04577758f, 0.06636145f, -0.03545833f, 0.03275641f, 0.12598060f, -0.00977763f, -0.14934392f, 
    0.00253247f, -0.08585873f, -0.05198453f, -0.03573020f, 0.03346096f, 0.09392200f, 0.04091102f, -0.13244994f, 
    -0.29983342f, -0.42420787f, 0.34369799f, 0.05231326f, 0.02736038f, -0.10157529f, -0.07829631f, 0.15478207f, 
    0.06988914f, -0.03035591f, 0.00501664f, -0.08713548f, 0.18746646f, 0.02481473f, 0.01094991f, -0.18137902f, 
    -0.00862120f, -0.12681560f, 0.07219487f, -0.09664264f, -0.08959911f, -0.16496083f, -0.03061335f, -0.06448456f, 
    0.21607839f, -0.09095549f, 0.00372266f, 0.25543150f, 0.03584729f, -0.09261371f, -0.10653454f, 0.00864564f, 
    0.11099003f, 0.13455851f, 0.16725636f, -0.12915301f, 0.23896235f, 0.04061262f, 0.06221854f, -0.15987670f, 
    -0.13507614f, 0.00405323f, 0.01931733f, 0.04407910f, -0.03895277f, 0.04910946f, -0.16136776f, -0.08428768f, 
    -0.82374913f, 0.51742631f, -0.55894119f, 0.76941347f, 0.16302909f, -0.03744964f, -0.07547090f, 0.05369569f, 
    -0.04299300f, 0.01509949f, -0.04880969f, 0.05506691f, 0.63624471f, -0.05183861f, -0.05129450f, -0.12420435f, 
    -0.15466926f, 0.06510342f, -0.14953879f, -0.05455546f, 0.07627843f, 0.10857838f, 0.06449499f, -0.02570655f, 
    0.11568294f, 0.01918878f, -0.07520802f, -0.11458356f, -0.16277798f, -0.06869332f, 0.00337274f, -0.13044700f, 
    -0.03739271f, 0.04457433f, 0.02699245f, -0.05924737f, 0.14979935f, -0.17285372f, 0.18775037f, -0.43963417f, 
    0.02259467f, 0.12885989f, -0.25946721f, 0.03392447f, -0.09230671f, 0.12377320f, -0.02791647f, -0.04978257f, 
    -0.52410185f, -0.58575010f, -0.71157610f, -0.43379274f, 0.01256594f, -0.22821291f, 0.09122449f, -0.09057165f, 
    0.08704550f, 0.13442051f, 0.11190825f, -0.01387031f, 0.14483747f, -0.48664010f, -0.06403342f, 0.34894699f, 
    -0.02571671f, -0.06171756f, -0.03272714f, 0.15508859f, -0.01323991f, -0.03800517f, -0.18684772f, 0.02001900f, 
    0.66472399f, -0.37533468f, -0.23325838f, -0.12052660f, -0.04386630f, -0.00762022f, -0.00058318f, -0.06873854f, 
    0.20311010f, 0.05257384f, -0.19352086f, -0.00667017f, -0.59285146f, 0.01383164f, 0.17615910f, 0.11639445f, 
    -0.07067120f, 0.15183614f, 0.25586653f, 0.01217395f, -0.07077835f, -0.11223313f, 0.01097517f, 0.00106620f, 
    0.11473832f, -0.11378758f, -0.46989909f, -0.17434308f, 0.07636015f, -0.08551472f, 0.01648300f, 0.01505747f, 
    0.18711302f, 0.17648289f, 0.21404299f, 0.13211964f, 0.10127356f, -0.03305113f, -0.11480747f, -0.17079242f, 
    0.21844073f, -0.11210501f, 0.12703973f, -0.14482634f, 0.01963157f, -0.24465117f, -0.14895006f, -0.19593899f, 
    -0.20791458f, -0.65365475f, -0.14631815f, 0.52280378f, 0.20330703f, 0.22952810f, -0.12109379f, 0.09945823f, 
    -0.12064219f, -0.06198699f, -0.10309350f, -0.12131765f, 0.31940421f, -0.44193456f, 0.08461550f, 0.17580812f, 
    0.03362314f, 0.29517418f, 0.11135750f, 0.17121993f, 0.04338751f, -0.04298625f, 0.02272432f, 0.01645212f, 
    -0.46238232f, -0.01581342f, 0.03726226f, 0.09247950f, -0.00324674f, 0.25762826f, -0.27330428f, 0.01888015f, 
    -0.33225471f, -0.14830033f, -0.13054731f, -0.21298781f, 0.18111742f, 0.00500417f, 0.00677280f, -0.08073393f, 
    -0.11777915f, -0.09287815f, 0.03794472f, -0.02584489f, -0.04499812f, -0.21275219f, -0.12018242f, -0.07325049f, 
    0.20840667f, -0.12668069f, -0.21468896f, 0.34198296f, 0.47349074f, 0.10382689f, 0.15361108f, 0.06117505f, 
    0.06499705f, 0.09181915f, 0.02721629f, 0.22059858f, 0.00513266f, 0.30989784f, 0.12899598f, -0.22011204f, 
    0.05025889f, 0.04967608f, -0.11887679f, -0.11894496f, -0.05538414f, 0.04675413f, -0.17245182f, -0.07594337f, 
    -0.43442976f, -0.12611994f, 0.15102378f, 0.02333016f, 0.09816559f, -0.00384221f, -0.08880237f, -0.04807013f, 
    0.06556543f, 0.04952873f, 0.08244409f, 0.11609948f, -0.03664374f, -0.30702162f, -0.16962899f, -0.00531776f, 
    0.19984707f, 0.01925378f, -0.00909173f, 0.06790356f, 0.12541473f, -0.03223398f, -0.00984806f, 0.20927803f, 
    -0.89091420f, 0.14310683f, 0.28548855f, 0.25815722f, -0.06218844f, -0.14133495f, -0.21301907f, -0.03453808f, 
    -0.10986017f, -0.07775994f, 0.02078853f, -0.01517587f, 0.49138945f, -0.43173349f, -0.56600946f, 0.27358666f, 
    -0.15577881f, 0.12616482f, 0.04585743f, 0.26764733f, -0.02884028f, -0.11359381f, 0.01130783f, -0.07817025f, 
    0.19219761f, 0.29744315f, 0.48311904f, -0.16334477f, -0.16340446f, -0.14789140f, -0.21234550f, -0.24164784f, 
    0.01141366f, 0.12998009f, 0.00611862f, -0.07459927f, 0.32660869f, -0.46479988f, -0.75709492f, -0.50221777f, 
    -0.30403867f, 0.02706735f, 0.10606603f, -0.22607058f, -0.02214820f, 0.07499661f, -0.04208536f, -0.09057892f, 
    0.09014942f, 0.32230267f, -0.06119929f, -0.08299047f, 0.05491803f, -0.05266118f, -0.01113794f, -0.00913797f, 
    -0.03022405f, 0.09651075f, 0.07597136f, 0.05898212f, -0.06702551f, -0.18234204f, 0.03448155f, 0.39373502f, 
    0.33084029f, 0.07307398f, -0.22403575f, 0.17977962f, -0.02690535f, 0.18946524f, -0.18148182f, 0.01209439f, 
    -0.10409638f, -0.12044263f, -0.10709771f, -0.01112403f, 0.01822996f, -0.10797689f, 0.04148622f, -0.04570569f, 
    0.06258997f, 0.13441531f, 0.17400385f, 0.25938216f, -0.12248991f, 0.07627884f, -0.05246127f, 0.07253334f, 
    -0.06492276f, -0.07391558f, 0.07988682f, 0.03312465f, -0.01716184f, -0.00490811f, 0.20680864f, 0.26172578f, 
    -0.20540838f, -0.51417994f, -0.36217350f, -0.00341798f, -0.12249075f, 0.35134268f, 0.12120844f, 0.10082494f, 
    0.01690505f, -0.05201096f, -0.13166681f, 0.02503145f, -0.05466373f, 0.06531750f, 0.09984647f, -0.23638289f, 
    -0.08327200f, -0.06244959f, 0.04993501f, -0.10310866f, 0.01368113f, -0.00989354f, 0.01005516f, 0.00383295f, 
    -0.09159521f, -0.37240481f, -0.55035037f, -0.22178461f, 0.14518782f, -0.03259989f, -0.14021000f, -0.24143222f, 
    0.01597038f, 0.00949674f, 0.04533625f, 0.11539753f, 0.00824539f, -0.07018318f, -0.10880088f, -0.17936850f, 
    -0.06157880f, -0.04895579f, 0.10317872f, 0.11634842f, 0.06696638f, 0.12924702f, 0.13710503f, -0.00685739f, 
    0.03217250f, -0.07881542f, 0.08009642f, -0.11206059f, -0.02323460f, 0.00112647f, 0.01909812f, 0.02349609f, 
    -0.04354972f, -0.02387792f, -0.18432648f, -0.81733787f, 0.16773750f, 0.27393380f, -0.08771696f, -0.10797659f, 
    -0.17603432f, -0.11132938f, 0.05305961f, -0.03783668f, 0.24558826f, 0.05577494f, 0.19906519f, 0.13719305f, 
    -0.25639486f, -0.54344231f, -0.09495003f, 0.27978480f, -0.12435272f, -0.26053858f, -0.11607984f, -0.08413565f, 
    -0.00550969f, 0.09509329f, 0.17531499f, -0.02708052f, 0.00275863f, -0.23680927f, -0.17477149f, -0.01651032f, 
    0.15085368f, 0.06642677f, 0.16718179f, 0.09558319f, -0.07024933f, -0.06316755f, -0.02474708f, -0.04555360f, 
    0.14748678f, 0.05787809f, -0.06897335f, 0.02875589f, 0.01345296f, -0.09308478f, -0.00761515f, 0.08722972f, 
    0.09225994f, 0.08165302f, 0.15069200f, 0.13923234f, 0.71544647f, 0.01051932f, -0.28268662f, -0.17073014f, 
    -0.04871468f, 0.04376869f, -0.11941167f, -0.09659357f, 0.02551285f, -0.04185722f, 0.09899301f, 0.00351766f, 
    -0.71143126f, -0.79243672f, -0.12567975f, 0.31768653f, 0.10889943f, 0.25169063f, 0.13485390f, 0.02307734f, 
    0.10682887f, -0.05239113f, 0.16402505f, -0.03749895f, 0.08801121f, -0.11942516f, -0.41843215f, -0.41802773f, 
    0.10963950f, -0.14813738f, 0.00537624f, -0.01710124f, 0.08538595f, -0.01296877f, 0.06180308f, 0.02544042f, 
    -0.29927203f, -0.14024147f, -0.07045237f, -0.03913965f, -0.05854793f, 0.10975883f, 0.08575366f, 0.05069485f, 
    -0.23008646f, -0.06895622f, -0.07112031f, -0.39493605f, -0.58459729f, -0.04613351f, 0.22191788f, 0.35800734f, 
    -0.14521536f, 0.00887999f, -0.04053921f, -0.18663673f, 0.00481378f, 0.11229537f, 0.14944525f, 0.10251192f, 
    0.20824149f, 0.16201733f, 0.31270385f, 0.41610086f, 0.11197849f, -0.03785108f, -0.33963540f, -0.20035340f, 
    -0.01718469f, -0.17080694f, -0.15937752f, 0.14309044f, 0.13015415f, -0.10543999f, 0.11405497f, 0.04028350f, 
    0.05874073f, -0.04157906f, 0.14401264f, 0.18213287f, 0.00414982f, 0.12351183f, -0.03737430f, -0.02614218f, 
    0.17326416f, -0.17111453f, 0.14362343f, -0.55288434f, -0.32689691f, -0.30415976f, 0.09446491f, -0.08247208f, 
    0.11768351f, 0.02220115f, 0.04383450f, 0.10939872f, 0.03545453f, -0.54644656f, 0.28297558f, 0.37802991f, 
    -0.04819522f, -0.14786114f, -0.07812984f, 0.18801312f, -0.12849255f, -0.00756718f, -0.00040341f, 0.04232571f, 
    -0.28052750f, 0.38755387f, -0.47497058f, -0.16433294f, 0.03079909f, 0.10010038f, 0.26842973f, -0.02104020f, 
    0.04962428f, -0.03314140f, -0.08560707f, 0.07277827f, -0.03377996f, -0.51289618f, 0.05450569f, -0.03138749f, 
    0.03611486f, 0.02538090f, -0.24103102f, 0.29869577f, 0.11273046f, -0.02008246f, -0.01350024f, 0.23332022f, 
    -0.05659712f, 0.28980970f, -0.43070701f, -0.06697942f, -0.22047244f, -0.38830981f, -0.05190739f, -0.09530144f, 
    0.15645161f, 0.05394217f, -0.24013795f, -0.17612922f, 0.48630601f, -0.48131746f, 0.05191811f, -0.03146104f, 
    0.14737609f, 0.08020739f, 0.06312224f, -0.02394202f, -0.03756506f, 0.06306724f, -0.02259309f, -0.00704717f, 
    0.34195936f, 0.54548508f, -0.49956140f, -0.35656974f, 0.02557120f, -0.13068782f, 0.21489818f, 0.21724108f, 
    -0.08668268f, 0.08367764f, -0.19031528f, -0.06160466f, -0.04104000f, -0.26283106f, 0.56245768f, -0.27782196f, 
    0.13021015f, -0.37939024f, -0.12211696f, -0.42192328f, 0.00994161f, 0.08420377f, -0.08152220f, 0.08875637f, 
    -0.60059321f, 0.14119267f, -0.46214983f, 0.09721391f, 0.15441765f, -0.04629861f, 0.20810369f, 0.07242582f, 
    0.07892378f, -0.03901578f, 0.00689273f, 0.00568551f, -0.65027726f, 0.04239309f, 0.05591379f, -0.61530656f, 
    -0.05206775f, -0.30754724f, 0.14218923f, -0.07543537f, -0.03698133f, -0.03346948f, 0.12610385f, 0.12452748f, 
    0.10553574f, -0.92242789f, -0.04946275f, 0.01367708f, 0.09873609f, 0.33356845f, -0.00989678f, 0.13148847f, 
    -0.02423153f, -0.02983790f, -0.15789540f, -0.12150338f, -0.47078604f, -0.19486181f, 0.20279524f, -0.09878187f, 
    0.00453632f, -0.24256265f, 0.09867440f, 0.23841193f, 0.07386401f, 0.08195184f, -0.00715331f, -0.04461930f, 
    -0.28567913f, -0.02803434f, -0.54894257f, 0.34507984f, 0.27345580f, 0.06197198f, 0.17517638f, -0.15634155f, 
    0.15634297f, -0.15452513f, -0.07625772f, 0.07537214f, -0.24914703f, -0.00397263f, -0.53567237f, 0.31872630f, 
    -0.11156669f, -0.16092095f, 0.04946591f, -0.09286848f, 0.14212307f, -0.00565074f, -0.05275515f, -0.13014674f, 
    0.22028229f, 0.08295809f, 0.07456025f, 0.18572210f, 0.12671334f, -0.21759202f, 0.15043044f, -0.08710749f, 
    -0.12113970f, 0.03300872f, -0.11120504f, -0.21756104f, -0.17638381f, -0.22030379f, 0.13488616f, -0.32550064f, 
    0.05230005f, 0.04867048f, 0.16278815f, -0.17683007f, 0.07300276f, 0.13973190f, -0.21864483f, 0.02265632f, 
    0.06795676f, 0.31615874f, -0.74157351f, 0.10317235f, -0.17385469f, 0.13097098f, -0.23422690f, 0.01797833f, 
    0.18622471f, -0.03243982f, -0.05798053f, -0.04256593f, 0.12110033f, -0.41306129f, 0.05915829f, -0.11565676f, 
    0.13150202f, 0.22222829f, -0.00246356f, 0.05543286f, 0.15622273f, -0.12309683f, -0.01167986f, -0.12974693f, 
    0.14930503f, -0.08207675f, 0.06268834f, -0.23572710f, -0.14797240f, -0.00304554f, 0.02384535f, 0.27892330f, 
    0.07279006f, 0.04790583f, 0.09607544f, 0.01415659f, -0.11336069f, -0.00384333f, 0.38957408f, 0.27475885f, 
    0.19355772f, -0.07361557f, -0.26111636f, -0.26377472f, 0.14254330f, 0.12234223f, -0.15970658f, 0.04778844f, 
    0.12046944f, -0.15690792f, 0.24140824f, 0.18799697f, -0.00184653f, 0.14422913f, -0.06356592f, -0.01249372f, 
    0.11331456f, 0.16252899f, 0.18032981f, 0.18074064f, 0.04378652f, -0.05821695f, -0.02144166f, 0.09768502f, 
    0.08319007f, 0.10669022f, -0.09550357f, 0.11685114f, -0.30553630f, -0.01544712f, -0.19320977f, -0.29458722f, 
    -0.54711175f, 0.11501250f, -0.19136956f, -0.18416175f, -0.37326327f, 0.05042018f, 0.05586216f, 0.02352437f, 
    0.06537849f, -0.03491982f, 0.04029284f, -0.15793721f, 0.18748884f, -0.19142623f, 0.26278752f, 0.27434152f, 
    -0.06489167f, -0.00440525f, -0.10609218f, -0.28196090f, 0.17066590f, 0.06889112f, 0.05793069f, 0.07021540f, 
    -0.00609748f, -0.05369828f, 0.00762907f, -0.09960628f, 0.14571632f, 0.07835411f, -0.03210927f, 0.00352290f, 
    -0.13451754f, -0.31446481f, -0.22326764f, -0.01683771f, -0.78731281f, -0.91338605f, -0.12338912f, -0.23221000f, 
    0.16135514f, 0.04496348f, 0.08430413f, -0.15346557f, -0.15298767f, 0.03497489f, -0.06950109f, 0.04059025f, 
    0.51908255f, 0.02315240f, 0.77626026f, -0.73037386f, 0.04909562f, -0.24348038f, -0.18066001f, 0.02461872f, 
    -0.21096836f, 0.08522789f, -0.06457208f, 0.11588160f, -0.17424458f, -0.10182181f, 0.11984321f, 0.22850859f, 
    0.03809136f, -0.03022438f, 0.11284333f, 0.15153986f, 0.01919650f, 0.17935675f, 0.10698394f, 0.01348861f, 
    -0.02622681f, 0.31649810f, 0.58426052f, -0.11233235f, -0.08469889f, -0.26337782f, -0.04780132f, -0.22067381f, 
    -0.12014905f, 0.02895972f, 0.13215527f, 0.14966577f, 0.11131527f, -0.09259525f, 0.46753412f, -0.75080985f, 
    0.04358111f, 0.04918847f, 0.15996487f, 0.00938099f, -0.04792403f, 0.11735876f, -0.03557068f, -0.09758474f, 
    -0.09270144f, 0.49234122f, 0.05524755f, 0.12334594f, -0.00283820f, -0.10517482f, 0.05592394f, -0.07701676f, 
    -0.00589867f, 0.11045245f, 0.05790975f, 0.01424565f, -0.32507578f, 0.11076432f, -0.22916502f, -0.12257899f, 
    -0.04128519f, 0.31903157f, -0.05737152f, -0.00559671f, -0.19055717f, -0.24950472f, -0.17999841f, 0.01435484f, 
    0.00326491f, -0.13362662f, 0.21882322f, 0.03903296f, 0.09338786f, -0.15692307f, 0.05991274f, -0.03433049f, 
    -0.04321242f, 0.11711880f, -0.04557550f, -0.26701087f, -0.62702835f, 0.29355523f, 0.17304502f, 0.08552898f, 
    0.03941600f, -0.08528901f, -0.08994412f, 0.20000762f, 0.08656164f, 0.06338520f, -0.05336868f, -0.17233081f, 
    0.06641698f, -0.23661396f, -0.10288163f, -0.00382976f, -0.03299495f, -0.46352738f, -0.00333882f, -0.08007780f, 
    -0.17703752f, -0.00288231f, -0.26952714f, -0.26192975f, -0.34182230f, 0.33742282f, 0.00576143f, -0.07965782f, 
    -0.09084310f, 0.20979683f, -0.20792063f, 0.29240221f, -0.20246863f, -0.02254288f, -0.04999398f, 0.01594913f, 
    0.01610587f, 0.31017864f, 0.50529552f, 0.06896500f, -0.03662267f, 0.16773251f, 0.12688161f, -0.13987121f, 
    0.15774602f, -0.07963090f, 0.19886068f, 0.20561221f, -0.07911622f, 0.16049303f, -0.10218391f, 0.07405426f, 
    -0.22647779f, 0.14696467f, 0.18986170f, -0.07967713f, -0.04430520f, 0.02162336f, -0.19551295f, -0.23720087f, 
    -0.20603251f, -0.45111039f, 0.12367939f, 0.11456213f, 0.01491997f, 0.12156669f, 0.03968054f, -0.18239121f, 
    0.02612944f, 0.12960677f, 0.08366220f, -0.08604720f, -0.66666603f, 0.46311489f, 0.00705464f, 0.23140126f, 
    -0.00614088f, 0.05666395f, -0.22376685f, 0.45894545f, 0.06327301f, -0.04941630f, 0.06505419f, -0.12047639f, 
    0.02348976f, -0.50789762f, 0.08641154f, 0.09342276f, -0.21409763f, 0.02889186f, 0.14568761f, -0.00296352f, 
    -0.16194046f, -0.06595656f, 0.07727040f, 0.02060894f, 0.37152708f, -0.57448971f, 0.29182029f, -0.00764673f, 
    -0.12190641f, 0.13182037f, -0.02464023f, 0.23268177f, 0.03033126f, 0.17957409f, -0.01166035f, -0.21549350f, 
    -0.17870949f, -0.27771544f, -0.24999450f, -0.11851053f, -0.30290624f, 0.14761317f, -0.12141433f, -0.01584356f, 
    -0.03007300f, 0.19047590f, -0.02081090f, 0.09576908f, -0.32110941f, -0.23085065f, -0.27244964f, 0.14301683f, 
    -0.12214515f, -0.05227512f, -0.17058726f, 0.06966802f, 0.03007049f, 0.07773650f, 0.00599532f, -0.04147081f, 
    -0.27827960f, 0.02153043f, -0.26537010f, -0.35345426f, -0.51516932f, -0.04078916f, -0.00009762f, 0.04898994f, 
    -0.29712585f, 0.23354083f, -0.12354425f, 0.07929606f, 0.55222350f, -0.17389995f, 0.12943748f, 0.29403120f, 
    -0.12995917f, -0.20697513f, 0.27658185f, -0.03296345f, -0.04658028f, -0.10537588f, -0.48317659f, 0.19125284f, 
    0.13371746f, 0.25463676f, 0.20845331f, -0.13330515f, -0.25827608f, 0.06058907f, 0.11862382f, -0.05895541f, 
    0.17002942f, 0.20673801f, 0.43535814f, 0.28168270f, -0.21907909f, 0.30673605f, 0.05247050f, -0.26409376f, 
    -0.18348327f, -0.02052516f, 0.15754150f, 0.06263877f, 0.21396694f, -0.14015424f, 0.18270822f, 0.07166415f, 
    0.19232640f, 0.26303002f, -0.03955068f, 0.20788188f, 0.10465995f, 0.13578452f, -0.29274011f, 0.28203097f, 
    -0.27193999f, 0.16231854f, 0.07796398f, -0.01743560f, -0.28960475f, -0.41556156f, 0.05418832f, -0.15414669f, 
    -0.21258987f, 0.10143232f, -0.01042724f, -0.06744413f, 0.10601318f, -0.11567077f, -0.12388346f, -0.12179275f, 
    -0.17916700f, -0.03940215f, -0.44306073f, 0.20221634f, -0.17176816f, -0.00575974f, -0.06823300f, 0.12957521f, 
    0.04186920f, 0.13374376f, 0.09748053f, 0.05612844f, -0.38695461f, 0.02776091f, 0.03053443f, -0.10216513f, 
    -0.13750845f, -0.13641147f, 0.02289294f, -0.08938814f, -0.03251463f, -0.07975091f, -0.03927802f, 0.13243632f, 
    -0.03433790f, 0.20909330f, 0.19118620f, 0.11391605f, -0.06144160f, -0.03834242f, -0.05622502f, -0.02784086f, 
    -0.16530648f, -0.31658310f, -0.46124706f, -0.35794142f, -0.01681544f, 0.07610086f, -0.07595656f, 0.11647968f, 
    0.21930610f, 0.07272136f, -0.11609815f, 0.07713696f, 0.13852340f, 0.12760310f, 0.23000009f, 0.28543910f, 
    0.29048121f, -0.50417936f, 0.36056629f, 0.07270410f, -0.26564431f, 0.05327547f, 0.24720187f, 0.18098852f, 
    0.11581866f, -0.04335583f, 0.28775662f, 0.17408860f, -0.62438703f, 0.08676288f, -0.27961877f, -0.22976409f, 
    0.03720697f, 0.01514716f, 0.08875801f, -0.03182326f, -0.12217321f, -0.02918682f, 0.14495263f, -0.08422115f, 
    0.00760087f, 0.14520341f, 0.43095964f, 0.05069757f, -0.05037736f, -0.03967708f, -0.06274636f, -0.13753778f, 
    0.07439251f, 0.09252838f, 0.35556707f, 0.13877697f, -0.78044009f, 0.41511527f, -0.12795852f, 0.44652197f, 
    -0.10210913f, -0.13600682f, -0.05421932f, -0.06579199f, -0.11541261f, 0.08236547f, 0.09896839f, -0.05760999f, 
    0.19322510f, -0.18905063f, 0.07423802f, -0.09763093f, -0.06856210f, -0.00492025f, -0.05254811f, 0.05462139f, 
    0.09471068f, -0.15523714f, -0.05571475f, -0.21712576f, -0.30932447f, 0.17427538f, -0.48464519f, -0.23450381f, 
    -0.12582059f, 0.04466785f, -0.00425893f, -0.07739661f, -0.07019257f, 0.01993447f, -0.17081018f, -0.10905377f, 
    0.23380424f, -0.32402459f, 0.08620445f, -0.15930958f, -0.00068487f, -0.10076290f, -0.26950821f, -0.08632898f, 
    -0.03002447f, -0.18256614f, -0.21061762f, -0.36924255f, 0.17404670f, 0.15561615f, 0.38542637f, 0.16688697f, 
    -0.15589051f, -0.19146955f, -0.21457334f, -0.02206472f, -0.06893180f, 0.04416560f, -0.01819647f, -0.11809020f, 
    -0.37431493f, -0.33152908f, -0.23294075f, 0.25605577f, 0.25592479f, -0.14251077f, -0.01193948f, -0.04359147f, 
    -0.09329256f, -0.07830095f, 0.02679077f, -0.02539292f, 0.09143443f, -0.07859667f, -0.00538311f, -0.04904841f, 
    -0.01827569f, -0.27300194f, 0.00311823f, -0.01895208f, 0.10835096f, 0.21440938f, 0.29758152f, 0.03389061f, 
    -0.05208179f, 0.44712055f, -0.15682143f, -0.44084090f, -0.07724949f, -0.03191951f, 0.17574582f, -0.03525756f, 
    0.05240721f, 0.11439903f, 0.14232999f, 0.12686568f, 0.17620753f, 0.14032026f, 0.27071315f, -0.19461127f, 
    -0.11760805f, -0.06714281f, 0.01735270f, 0.27393702f, 0.04147113f, -0.04021407f, -0.13864309f, 0.07160012f, 
    0.26808676f, -0.03383071f, 0.39366528f, -0.15369342f, -0.13214086f, 0.02385062f, -0.20480511f, 0.02935739f, 
    -0.07493243f, -0.11024059f, 0.09776831f, 0.00751480f, -0.56308699f, 0.29177666f, -0.15870607f, 0.26764247f, 
    0.15998411f, -0.00862819f, 0.24970119f, 0.28753737f, -0.01242519f, 0.10071594f, -0.00150598f, 0.31975687f, 
    0.28758442f, -0.50358301f, 0.41864547f, -0.29992792f, 0.08319625f, -0.23108368f, -0.14400217f, 0.12043624f, 
    -0.02163219f, 0.05306108f, 0.18083169f, -0.25907940f, -0.10418743f, 0.18551326f, -0.05781167f, 0.01450880f, 
    0.13663334f, -0.23040400f, 0.15148315f, -0.01251094f, 0.11925592f, 0.08080231f, 0.17339064f, -0.00135749f, 
    0.56954634f, -0.19128229f, 0.38022807f, 0.05708203f, -0.06972532f, -0.02486196f, -0.37848896f, 0.05787155f, 
    -0.16328584f, 0.10138825f, 0.02784801f, -0.12033839f, -0.36300454f, -0.37154245f, 0.38409117f, 0.41913453f, 
    -0.08878487f, 0.07574639f, 0.03764527f, 0.21925694f, -0.19355159f, -0.09059497f, 0.05788811f, 0.03639858f, 
    0.41147271f, -0.06315354f, 0.25147411f, -0.32316530f, -0.05600557f, 0.00214091f, -0.13204417f, -0.04648450f, 
    -0.14322144f, 0.19911091f, 0.02735556f, -0.00799242f, 0.28393319f, -0.30288562f, 0.46307769f, -0.63398355f, 
    0.04539163f, -0.06400324f, -0.09603404f, 0.02770679f, 0.11067159f, 0.09387759f, 0.08964369f, -0.08736335f, 
    0.51901853f, 0.29008165f, 0.11181836f, 0.03111926f, -0.18429157f, -0.10755482f, -0.11726016f, 0.05937630f, 
    -0.01651871f, 0.01819316f, -0.05171021f, -0.08232041f, -0.50237763f, -0.74762112f, -0.04449456f, 0.34145197f, 
    -0.26188022f, -0.10742626f, 0.01190123f, -0.22809038f, -0.08824278f, 0.13522103f, -0.05600261f, -0.15766731f, 
    0.38164783f, -0.04182649f, 0.35100618f, -0.09605371f, 0.01529066f, 0.09502440f, 0.01077506f, 0.15292223f, 
    -0.15236461f, 0.05125592f, 0.09175830f, -0.08123030f, -0.07588125f, -0.20587632f, 0.33094329f, 0.03367786f, 
    0.05045709f, 0.16977775f, 0.13676547f, -0.18622972f, -0.01120641f, 0.11013592f, 0.23742762f, 0.15554143f, 
    -0.17727691f, -0.27477792f, -0.07388820f, -0.07761522f, -0.03930885f, 0.21120535f, -0.35521403f, 0.24131429f, 
    -0.30449381f, -0.31888774f, -0.18988082f, -0.28600323f, 0.25451607f, -0.08467687f, 0.28586730f, 0.13135578f, 
    -0.07999039f, 0.09260937f, -0.16963756f, 0.11323465f, -0.40160516f, 0.23261514f, -0.01668649f, -0.16086628f, 
    -0.25478160f, -0.00050283f, 0.13771170f, 0.14448041f, 0.13535571f, 0.03803012f, 0.14399633f, -0.08153914f, 
    -0.10175560f, -0.18500549f, -0.16456121f, -0.09999405f, 0.42925984f, 0.18335555f, -0.09247488f, -0.26487240f, 
    -0.07944734f, 0.16755378f, -0.06385012f, 0.07100759f, -0.00956032f, 0.07961237f, -0.09593412f, 0.11363158f, 
    -0.32930809f, -0.15313251f, -0.18442698f, 0.09561784f, -0.26403430f, -0.19752526f, -0.12373663f, -0.20511554f, 
    0.00609232f, 0.02849187f, -0.09777129f, -0.12199778f, -0.12463351f, 0.08275060f, -0.29197708f, 0.05815991f, 
    0.04271718f, 0.20201945f, -0.08921291f, 0.05067585f, 0.04498368f, 0.12897773f, 0.24084623f, -0.03456338f, 
    -0.43953392f, 0.32316887f, -0.49357545f, 0.14310157f, 0.08754624f, 0.11778179f, -0.03640290f, -0.03377236f, 
    0.12520416f, 0.06709668f, 0.19764329f, 0.28833658f, -0.25150108f, 0.12426139f, -0.07590962f, -0.02013674f, 
    0.08423511f, -0.02221130f, -0.06563020f, 0.02413457f, -0.13145041f, 0.20389700f, 0.14117591f, -0.04378078f, 
    -0.18527602f, -0.23915948f, 0.43634704f, -0.46296775f, -0.04663972f, 0.09218526f, 0.04352608f, -0.00211260f, 
    -0.03590418f, -0.02315220f, -0.20983829f, -0.03512449f, -0.26605254f, 0.24197969f, -0.27919611f, 0.14194196f, 
    0.19976687f, -0.10920338f, -0.07198445f, 0.01288287f, 0.11641990f, 0.00613013f, -0.03637247f, -0.25480527f, 
    -0.16334301f, 0.20122555f, -0.23274347f, 0.16399267f, 0.28581348f, 0.02564148f, 0.10127881f, -0.11568568f, 
    -0.10923155f, 0.13467340f, -0.23421779f, -0.07656438f, -0.34896994f, -0.12396710f, 0.01113063f, 0.33068112f, 
    0.21187136f, -0.11695154f, 0.25970152f, -0.01623852f, -0.04716827f, -0.02599454f, -0.07136946f, 0.05004973f, 
    -0.90669143f, -0.03774086f, -0.67800748f, 0.10603740f, -0.00436169f, -0.12264651f, -0.12624831f, 0.05039056f, 
    -0.31985861f, 0.06781039f, -0.00024137f, 0.03840279f, -0.17549844f, -0.20000659f, -0.41165608f, -0.11065973f, 
    0.07512515f, -0.11688406f, 0.11347870f, -0.23710029f, -0.01240523f, 0.14797859f, 0.16628157f, 0.00656361f, 
    0.01584405f, -0.28370717f, -0.08304752f, -0.40386587f, -0.03414113f, -0.12208659f, -0.00126691f, -0.14214629f, 
    -0.05278025f, 0.12808718f, 0.02846440f, -0.05961148f, -0.56376302f, -0.16591366f, 0.31917825f, 0.15180115f, 
    0.03807608f, 0.19096650f, -0.10399587f, 0.21282321f, -0.24056129f, -0.01646563f, 0.00978433f, 0.07978268f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20709175f, 0.09607174f, 0.05285374f, -0.10622983f, -0.15257792f, 0.15104729f, 0.06629945f, -0.19443291f, 
    0.08284190f, 0.06910077f, -0.02473476f, 0.00453121f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
