#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.72132260f, 0.53945178f, 0.33796307f, -0.55043286f, 0.08848553f, -0.76898390f, 0.66820103f, 0.65540707f, 
    -0.32574138f, -0.24019527f, -0.67362112f, 0.07107470f, 0.10827582f, -0.10940462f, 0.01791120f, 0.32216662f, 
    -0.03625358f, 0.09466466f, 0.28556898f, 0.15980932f, -0.08322759f, -0.07318649f, -0.20728017f, -0.32251775f, 
    0.12710063f, -0.26939613f, -0.69646239f, -0.58759791f, -0.42989501f, -0.32744512f, 0.03760488f, 0.58063322f, 
    0.52564704f, 0.29556426f, -0.02143144f, -0.22540267f, -0.09494774f, -0.14210781f, -0.27477631f, -0.46483713f, 
    -0.40188068f, -0.23833242f, 0.24511494f, 0.02072586f, -0.10732366f, -0.26706469f, 0.00583881f, -0.01451199f, 
    -0.30642059f, -0.05524944f, -0.42552954f, -0.93537998f, 0.25366655f, -0.28561157f, -0.13977866f, 0.43676326f, 
    -0.15120916f, 0.40896922f, 0.32343376f, -0.14800319f, 0.10812084f, 0.06164765f, -0.22133374f, 0.60215664f, 
    0.23239680f, 0.16999052f, 0.23804651f, 0.22847351f, 0.21363775f, 0.16329135f, 0.26097834f, -0.29092354f, 
    -0.06657990f, -0.23273285f, 0.06847924f, -0.76421958f, -0.75446463f, -0.73934668f, -0.04275781f, 0.04548403f, 
    0.55837971f, 0.73754787f, -0.01867927f, 0.45760161f, 0.48885339f, 0.42088372f, -0.26196483f, 0.13040158f, 
    -0.19853741f, 0.28756031f, -0.17872676f, -0.18099780f, 0.11330577f, 0.04722396f, -0.23271988f, -0.12783137f, 
    -0.07110081f, 0.02808049f, 0.29559565f, -0.21190210f, -0.61026728f, -0.13160469f, -0.38541913f, -0.10007716f, 
    0.15051620f, -0.21116105f, -0.29869145f, -0.61827397f, -0.44209969f, -0.07705468f, 0.08990416f, 0.17021552f, 
    -0.00837237f, -0.20132086f, -0.65888089f, -0.16812718f, -0.08845777f, 0.25628135f, -0.66630661f, -0.45993835f, 
    -0.38222179f, 0.11864813f, 0.35688314f, -0.07222564f, 0.19460371f, 0.80157787f, 0.78779578f, 0.90692395f, 
    0.22655489f, 0.44730046f, 0.18273376f, -0.14460966f, -0.09861135f, -0.57686752f, -0.24764475f, 0.13555290f, 
    0.21778563f, -0.04060712f, 0.19317578f, 0.11862075f, 0.36022946f, -0.02053881f, -0.16674748f, 0.17866090f, 
    -0.38830107f, 0.10365506f, 0.01523541f, 0.22700316f, 0.07652312f, 0.24326748f, 0.78144044f, 0.47979450f, 
    0.67994082f, 0.58507490f, 0.63208842f, -0.35720110f, -0.29616514f, 0.07420373f, 0.10889761f, 0.00826726f, 
    0.09823547f, -0.32882771f, 0.19384275f, 0.09528234f, -0.20935376f, 0.32374522f, 0.22106476f, 0.16895290f, 
    0.31067729f, 0.52933681f, 0.18688250f, 0.27619830f, 0.16423476f, -0.06514098f, -0.05556397f, 0.49021316f, 
    0.62541330f, 0.37859765f, 0.93204957f, 0.06637109f, 0.07915165f, -0.24129356f, -0.55032051f, -0.08062093f, 
    0.54493999f, 0.48212215f, 0.01446166f, 0.16653490f, 0.24090256f, -0.41350785f, -0.08621552f, 0.06752200f, 
    -0.12816548f, -0.05356682f, -0.29601544f, -0.39881593f, -0.23132665f, 0.05438466f, -0.11994130f, -0.27020156f, 
    1.11312807f, 0.52065605f, -0.23726545f, -0.78828651f, 0.14374924f, 0.25584230f, -0.62926179f, 0.20393750f, 
    0.05480857f, 0.40648395f, -0.06453367f, 0.46067464f, -0.19291703f, -0.05413264f, -0.24340732f, 0.27883974f, 
    0.32502139f, -0.11778216f, 0.04209688f, 0.18614060f, -0.27674741f, -0.04973636f, 0.00897892f, -0.16733895f, 
    -0.34267655f, -0.31188717f, -0.90060925f, -0.28574732f, 0.04458836f, -0.68969333f, 0.04709494f, -0.15595214f, 
    -0.00225877f, -0.34538561f, 0.39402112f, 0.01715332f, -0.14420508f, -0.42171919f, 0.33823726f, 0.08009948f, 
    -0.18254207f, -0.01683768f, -0.34724697f, 0.24913904f, 0.29240605f, 0.06005579f, 0.17527382f, -0.12148664f, 
    -0.13573487f, -0.20715985f, 0.24598669f, 0.20616853f, -0.30111894f, 0.80787915f, -0.03942516f, 0.76586068f, 
    0.38472259f, 0.41954234f, 0.30238068f, -0.22760954f, -0.53167158f, -0.38109338f, -0.39757895f, -0.32186270f, 
    0.19353378f, -0.35386142f, 0.07940532f, 0.17686813f, 0.28638980f, 0.05755477f, -0.10525966f, -0.28733820f, 
    -0.20760448f, -0.36665574f, -0.34968269f, 0.48175880f, 0.78788781f, -0.19407384f, -0.72659630f, -0.25477910f, 
    0.80774963f, 0.24732378f, -0.68944401f, -0.27869835f, -0.74851191f, 0.14020187f, 0.39155665f, -0.04943955f, 
    0.21110818f, -0.32015863f, 0.28627008f, -0.15937112f, 0.17789996f, 0.13664009f, -0.05104090f, 0.13774735f, 
    -0.12087438f, -0.02781031f, -0.09962895f, 0.11709020f, 0.74201465f, 0.65042412f, 0.45020741f, 0.58526045f, 
    0.44052333f, 0.16887243f, -0.50880045f, -0.00368717f, -0.05090299f, 0.33623824f, -0.29444891f, 0.01704113f, 
    -0.45317745f, -0.51373965f, -0.01841157f, -0.40994781f, -0.22864974f, -0.10797496f, -0.34368587f, -0.09741078f, 
    0.43796578f, 0.34860581f, 0.11351405f, -0.14543097f, 0.23878475f, -0.23276715f, -0.04681131f, -0.37777767f, 
    0.10095905f, 0.09665104f, -0.31763390f, -0.93005866f, -0.68772888f, -0.35004330f, -0.43205181f, -0.25064632f, 
    0.47443983f, 0.35314661f, 0.06439783f, 0.05905546f, 0.29086566f, -0.25245103f, 0.21953230f, 0.24319603f, 
    0.22836822f, 0.37318033f, 0.32936105f, -0.01760081f, -0.01316238f, 0.32645068f, -0.21035819f, 0.13804905f, 
    0.78975934f, -0.24626310f, -0.91609806f, 0.13023384f, -0.00956605f, -0.33319902f, -0.69049978f, -0.30728427f, 
    0.00764644f, 0.16734892f, -0.54143786f, -0.29698867f, 0.12400809f, -0.07280823f, -0.25185582f, -0.24441166f, 
    -0.12931576f, -0.26702321f, 0.22253865f, 0.25304714f, 0.06174030f, 0.01596024f, 0.13871431f, -0.79355967f, 
    -0.56097984f, 0.02009269f, 0.33032349f, -0.28273594f, 0.22402444f, 0.11328501f, 0.37753218f, -0.49263060f, 
    -0.59002936f, 0.11330771f, -0.41321397f, 0.08203869f, 0.00075780f, 0.11853065f, -0.28548640f, -0.18209597f, 
    -0.16718872f, -0.60276312f, 0.40045708f, -0.00559749f, 0.43436584f, 0.19232363f, 0.09978750f, -0.11619602f, 
    -0.24791808f, -0.67835432f, -0.61829275f, -0.40016866f, 0.21439412f, 0.32359669f, 0.93573660f, 0.13997149f, 
    0.32951865f, 0.04277891f, -0.07492330f, -0.25624275f, -0.24286485f, -0.31302449f, -0.21787201f, 0.17392145f, 
    -0.00075812f, -0.07796057f, -0.02290439f, 0.02647168f, -0.00872234f, -0.27448550f, -0.23648250f, 0.12490413f, 
    0.29870725f, 0.45904699f, 0.53478450f, 0.44621727f, 0.60622084f, -0.03299407f, -0.07074542f, 0.29122597f, 
    -0.12102218f, 0.54951710f, 0.04716903f, -0.33427623f, -0.37701121f, -0.39304596f, -0.14750445f, -0.31311187f, 
    0.05679976f, 0.22476031f, -0.28333357f, -0.42412975f, -0.22271854f, -0.18401735f, -0.00392293f, -0.05055405f, 
    0.36638206f, 0.29420602f, -0.48043749f, -0.36045241f, -0.79179865f, -0.50018710f, -0.00766124f, 0.09009824f, 
    0.18490212f, 0.25826734f, 0.19905518f, 0.67320448f, -0.20481354f, -0.10574087f, 0.47456422f, 0.13859256f, 
    -0.11555645f, 0.03514424f, 0.27793348f, 0.43139946f, 0.02539815f, -0.30509439f, 0.11405437f, -0.03365800f, 
    -0.44448733f, -0.06583332f, 0.25629672f, 1.23782861f, 0.54204899f, -0.65884811f, 0.86341834f, -0.18771932f, 
    0.00858753f, -0.06189277f, -0.22572592f, -0.37918359f, -0.49376708f, -0.13835229f, 0.02584229f, 0.01339541f, 
    -0.01339898f, -0.23026624f, 0.18217005f, -0.40194529f, -0.28773212f, 0.06072373f, -0.02460886f, -0.14155897f, 
    0.03003508f, 0.10136962f, -0.24532935f, -0.04147124f, -0.24111538f, 1.03831482f, -0.05404718f, -0.77423584f, 
    -0.27171826f, 0.19581929f, -0.27491286f, -0.42741835f, -0.48260570f, 0.16246212f, 0.04472518f, 0.32325387f, 
    0.09969196f, 0.11771231f, 0.22826248f, -0.22110587f, -0.09526496f, -0.12515037f, 0.09835278f, 0.14537467f, 
    0.17735203f, 0.12092131f, 0.39593476f, -0.15116452f, -0.04444397f, -0.15611094f, -1.23801887f, 0.10592337f, 
    0.61303163f, 0.46228319f, -0.84926438f, 0.58439106f, 0.46656871f, -0.24924150f, -0.22207549f, 0.52405566f, 
    -0.06890621f, -0.26497892f, -0.00803056f, 0.15086572f, -0.02970489f, 0.17982878f, -0.08608974f, 0.04148679f, 
    0.02380219f, -0.06927074f, 0.11079364f, -0.00052720f, -0.00911150f, 0.04909630f, -0.41575655f, 0.27918923f, 
    -0.47937274f, -0.89335924f, -0.76453602f, 0.72911108f, -0.48487991f, 0.01812472f, 0.34386274f, -0.17249863f, 
    0.32642367f, -0.29877037f, 0.10321673f, 0.27503431f, 0.07554638f, 0.25186193f, -0.01695783f, 0.17748936f, 
    -0.24181668f, 0.39596146f, -0.15224524f, -0.19669792f, 0.17100409f, -0.16781296f, 0.01939661f, 0.51778591f, 
    0.38287520f, 0.59789139f, 0.00608719f, 1.02429342f, 0.60060030f, -0.07846627f, -0.35677773f, 0.29383585f, 
    -0.13046338f, 0.25130978f, 0.24573484f, -0.15666409f, 0.22262737f, -0.08981580f, -0.25641543f, 0.15459050f, 
    0.26487979f, 0.18128835f, 0.19843617f, -0.08716000f, 0.48220941f, 0.12332863f, -0.09192935f, 0.22681202f, 
    -0.09727681f, -0.71332067f, 0.65289158f, 0.73627281f, 0.32729968f, 0.68725002f, 0.42354897f, 0.50885594f, 
    0.30502018f, -0.33268595f, -0.51581585f, -0.26830167f, -0.45659944f, 0.37148926f, -0.06082831f, 0.12350342f, 
    -0.04451582f, -0.50006348f, -0.04665894f, 0.16562574f, -0.12389915f, -0.18236735f, -0.01977404f, -0.17507437f, 
    0.01177507f, 0.18710028f, 0.42872092f, -0.51447088f, -0.83008766f, -0.26425666f, 0.16171111f, -0.13284543f, 
    -0.24206717f, 0.20984928f, 0.20194535f, 0.24802966f, -0.49049643f, -0.36536187f, -0.31140581f, -0.24217057f, 
    0.20111653f, 0.44675350f, 0.27081957f, 0.45307794f, 0.40457535f, -0.15024170f, -0.39949238f, -0.16550596f, 
    -0.36759111f, 0.30070421f, -1.40971875f, 0.88897014f, -0.82943481f, 0.07482185f, -0.00788190f, -0.29081729f, 
    0.78362924f, -0.06330763f, 0.46303302f, -0.20120327f, -0.02815009f, -0.18852049f, -0.05968068f, -0.22566056f, 
    0.11507497f, 0.05695926f, 0.01516459f, 0.14426228f, -0.01013017f, -0.32906398f, 0.29103944f, 0.41059363f, 
    -0.01295786f, 0.07713935f, 0.24408349f, -0.19518156f, -0.56223500f, -0.42605215f, -0.52869838f, -0.55328757f, 
    -0.57385880f, 0.52600473f, 0.66566557f, -0.46752101f, 0.19371331f, -0.16403058f, -0.24493673f, -0.38722733f, 
    -0.20229198f, 0.02880507f, 0.25843903f, -0.00391796f, 0.01763560f, -0.05624201f, -0.11378772f, 0.05862065f, 
    0.27883878f, -0.04631160f, 0.13488080f, 0.11033326f, -0.51620185f, -0.32444715f, -0.04117522f, 0.18497056f, 
    -0.31703216f, 0.14875464f, -0.29319435f, -0.11368091f, 0.61697292f, -0.61636162f, -0.43167332f, 0.11609113f, 
    0.13741472f, -0.41800603f, -0.23926516f, -0.15633598f, 0.32796347f, -0.41731486f, 0.11407756f, -0.48117462f, 
    0.13237205f, 0.35482353f, 0.24941102f, 0.15429448f, -0.09693214f, 0.88429368f, 0.71077037f, -0.03588684f, 
    -0.25262898f, -0.68222016f, 0.05358544f, 0.26421779f, -0.33996385f, -0.42171243f, 0.38702738f, -0.01863089f, 
    0.53339928f, 0.52078539f, 0.24442363f, -0.12741354f, 0.03315441f, -0.44857934f, 0.35020724f, 0.08991184f, 
    -0.21618837f, -0.03335072f, -0.01821973f, -0.00723565f, 0.02900434f, 0.17493962f, 0.19983913f, -1.17980134f, 
    -0.62435567f, 0.31257570f, -0.00698711f, -0.61642146f, 1.16753137f, 0.10070635f, -0.01273270f, 0.11688399f, 
    0.01417940f, 0.37137115f, 0.19008809f, 0.13881387f, 0.24553680f, -0.36576414f, 0.27692536f, -0.11636370f, 
    -0.03299471f, -0.16312188f, 0.26839694f, 0.22410665f, -0.14683567f, -0.02213085f, -0.00958396f, -0.23389702f, 
    0.55208522f, 0.83315969f, 0.37965992f, 0.11814982f, -1.33707774f, -0.26496607f, -0.70920867f, -0.65589631f, 
    -0.24533036f, 0.06770331f, 0.37803042f, -0.22250974f, 0.07511114f, -0.12206285f, -0.24016340f, -0.22654474f, 
    0.26221186f, -0.29539013f, 0.25432158f, 0.12771165f, 0.05686850f, -0.05157484f, 0.25648713f, -0.11768284f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.12747768f, 0.08557332f, 0.28408906f, -0.00989896f, 0.24750818f, 0.03929634f, 0.14414586f, 0.01959163f, 
    0.02795603f, -0.06128507f, 0.15257967f, 0.34935579f, -0.05695536f, 0.24137934f, 0.01143856f, 0.05752135f, 
    -0.02881489f, 0.21163575f, 0.17261861f, 0.04375468f, 0.30652899f, 0.22629252f, 0.19724102f, 0.21323973f, 
    0.10314433f, 0.02032994f, 0.19749156f, -0.02437240f, 0.04637331f, 0.11133148f, 0.04816375f, 0.34461454f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.04090599f, -0.00305916f, -0.04684464f, -0.03291287f, 0.04376666f, -0.03865846f, 0.03268147f, 0.01545062f, 
    -0.00991802f, -0.03470309f, -0.04054622f, -0.01934578f, 0.02260981f, -0.03741549f, -0.02118627f, -0.02621908f, 
    0.04334505f, 0.02070896f, -0.01650039f, 0.03307200f, -0.03880379f, -0.03844287f, 0.01363575f, 0.03717124f, 
    -0.03239956f, 0.04061191f, -0.04181607f, -0.02076843f, -0.00581693f, -0.00324722f, -0.04540806f, 0.00693249f, 
    0.00250043f, 0.03165981f, -0.00086918f, 0.02205881f, 0.03401199f, 0.03640603f, -0.05453514f, -0.01795045f, 
    -0.00911838f, -0.05473807f, -0.02265417f, -0.03757331f, -0.03001764f, -0.05088637f, -0.04101505f, -0.01425371f, 
    0.00223661f, 0.01195561f, 0.04120553f, -0.02960300f, 0.01224931f, -0.01568612f, 0.00990635f, 0.01616181f, 
    -0.05336899f, 0.02801102f, -0.00524854f, -0.03936276f, -0.02158674f, 0.01016490f, -0.02433686f, -0.04895588f, 
    -0.01680952f, -0.00509754f, 0.02096104f, 0.03377295f, -0.05870889f, 0.03848991f, -0.05100265f, -0.04576912f, 
    0.03501066f, -0.04328291f, 0.02282707f, -0.05095016f, 0.01138474f, -0.01504817f, -0.01177049f, 0.00836630f, 
    0.02954710f, -0.05802251f, 0.02050448f, 0.01150870f, 0.03333935f, 0.01944117f, -0.00664690f, -0.00354411f, 
    0.04477931f, 0.01015887f, 0.03842038f, -0.05356200f, -0.03889776f, 0.01547313f, -0.05868278f, 0.02515256f, 
    -0.05186872f, -0.05096692f, -0.01222748f, -0.05337423f, 0.02659075f, 0.01816759f, -0.04763013f, 0.01761677f, 
    0.03216178f, -0.05220096f, -0.00823758f, 0.00652582f, 0.02667617f, 0.00980140f, 0.01333025f, -0.04146567f, 
    0.03626541f, -0.05233763f, -0.00370988f, 0.00247948f, 0.03958793f, 0.02610864f, -0.02050113f, -0.04865346f, 
    -0.04944845f, 0.01942017f, -0.02423605f, -0.00015943f, -0.02185263f, -0.04396718f, 0.03035042f, -0.04092743f, 
    0.03011378f, -0.00429134f, -0.00054570f, -0.04745377f, -0.02636151f, 0.00808664f, -0.04958009f, 0.02797829f, 
    0.00053256f, -0.01810641f, 0.01817000f, -0.04422532f, -0.01640910f, -0.04043394f, 0.00964508f, 0.01030820f, 
    -0.04678187f, 0.02438967f, -0.03154828f, -0.03714402f, 0.04451954f, -0.02779052f, 0.04242953f, -0.00112433f, 
    0.01528086f, -0.03119091f, -0.05105973f, -0.02232536f, 0.00526526f, 0.03905902f, -0.02973621f, -0.06174793f, 
    -0.01605221f, 0.00581605f, -0.05254459f, -0.02994894f, 0.00970821f, -0.03155610f, 0.01526699f, -0.02308832f, 
    -0.01983420f, -0.02979627f, 0.00226340f, 0.00425833f, -0.00113188f, -0.01392417f, -0.04734459f, 0.03853057f, 
    0.02580046f, -0.01541877f, -0.01351601f, 0.01941043f, -0.02918782f, 0.00189719f, 0.02354063f, -0.04642114f, 
    0.03885087f, -0.00737210f, -0.01087536f, -0.02489522f, -0.03623911f, 0.00048353f, -0.01031095f, -0.01108609f, 
    0.04827867f, 0.03504347f, 0.02361333f, -0.02986366f, -0.05476680f, 0.03041128f, -0.03996510f, -0.00801268f, 
    0.03810373f, 0.00564403f, 0.02785755f, -0.04968543f, -0.01017136f, -0.00195282f, -0.02422960f, -0.02297539f, 
    -0.04614862f, 0.02528891f, -0.02947260f, -0.00755731f, -0.03422059f, -0.02812655f, 0.01367058f, 0.00362518f, 
    -0.03540758f, 0.03933945f, -0.02481342f, 0.00147015f, -0.01152655f, -0.03559269f, 0.01024458f, -0.01004379f, 
    0.00331663f, 0.00653188f, -0.00266839f, -0.00800918f, -0.01233490f, 0.01359216f, -0.02653326f, -0.03920261f, 
    0.01070357f, -0.02689644f, -0.04873246f, -0.00855024f, 0.01807852f, -0.01894940f, -0.00706306f, -0.03255655f, 
    0.03482770f, -0.04381118f, -0.03882584f, -0.04110802f, -0.02463904f, -0.03194379f, 0.03994567f, 0.00544580f, 
    -0.04280803f, 0.00127890f, -0.03772785f, -0.03106664f, -0.02066107f, 0.02535088f, 0.00662665f, -0.05435987f, 
    -0.04016352f, -0.03369024f, -0.05279906f, 0.04176401f, 0.04444714f, 0.01819636f, 0.01578820f, 0.02330775f, 
    0.02425522f, 0.03149112f, 0.01423931f, -0.00688895f, 0.00387578f, 0.03486469f, -0.04600195f, -0.04645985f, 
    -0.00026541f, 0.01851173f, 0.02045779f, 0.00841803f, 0.02551692f, -0.03105509f, -0.00253115f, -0.03804550f, 
    -0.04733950f, 0.00778643f, 0.02642028f, 0.00115252f, 0.00570211f, 0.02064184f, -0.03871736f, -0.00675972f, 
    -0.02645842f, 0.04006264f, 0.02783100f, 0.00067680f, 0.00229701f, 0.00501060f, 0.04599055f, -0.01888952f, 
    -0.01620505f, -0.05010334f, 0.02773851f, 0.00539220f, -0.05217555f, -0.00104847f, -0.04278983f, -0.04244716f, 
    0.00132643f, 0.04456022f, -0.05153665f, 0.01775197f, -0.03335235f, -0.05328719f, -0.03722800f, -0.05086533f, 
    -0.00116759f, -0.05288127f, 0.00185135f, 0.01086368f, 0.03678236f, -0.04566268f, 0.02944873f, -0.02291827f, 
    0.03196061f, 0.01575679f, 0.04404114f, 0.03993481f, -0.02795998f, -0.03521246f, -0.02653174f, 0.03943899f, 
    -0.02207323f, 0.01400636f, -0.03611641f, -0.04406290f, -0.03369333f, 0.02146984f, -0.00625691f, 0.00024609f, 
    -0.01021642f, 0.03888799f, 0.03127968f, -0.03144740f, -0.04514865f, -0.00561973f, -0.04510527f, 0.03807710f, 
    -0.04314335f, 0.04594988f, 0.01414706f, -0.05414339f, -0.03456179f, -0.03129472f, 0.04915584f, -0.00249515f, 
    -0.05465981f, 0.02903577f, 0.01890850f, 0.02834680f, -0.04556458f, -0.00904799f, 0.03189225f, -0.01576364f, 
    -0.00686597f, -0.04213338f, -0.03742582f, 0.01870839f, 0.00279112f, -0.02626739f, 0.02396964f, 0.01822084f, 
    0.02999665f, -0.04321127f, 0.01738812f, -0.00842034f, 0.01137965f, -0.02099201f, -0.00302514f, -0.01016592f, 
    -0.00973963f, -0.00111703f, 0.01046728f, 0.03680189f, 0.03527055f, -0.04621280f, 0.01970087f, 0.01782153f, 
    -0.10398298f, 0.15754245f, 0.09646148f, -0.07852282f, -0.02695082f, 0.06981245f, -0.17219666f, -0.11889618f, 
    -0.12010469f, 0.01268018f, -0.11936457f, -0.07285954f, -0.03913491f, 0.09781091f, 0.17657842f, 0.12527965f, 
    -0.09059469f, -0.03964403f, 0.00739130f, -0.07980554f, 0.07317615f, 0.07850848f, -0.04987507f, -0.09870393f, 
    -0.10381611f, 0.18325227f, 0.18022904f, 0.08960497f, -0.01326800f, 0.03174674f, -0.04627804f, 0.15899315f, 
    -0.02477180f, -0.03587085f, -0.06667291f, 0.01421132f, -0.17746009f, 0.00411277f, 0.09980227f, 0.19986038f, 
    -0.10682449f, -0.03652310f, 0.12640868f, -0.04905139f, -0.03736952f, 0.08837164f, 0.03700970f, -0.09257855f, 
    -0.03191204f, 0.09205270f, 0.10127882f, -0.00188867f, 0.10551769f, 0.03458907f, -0.00847853f, -0.02157255f, 
    -0.03301308f, -0.05488857f, 0.01606425f, -0.04255201f, 0.13268881f, 0.06360659f, -0.06350461f, 0.09149958f, 
    0.05209860f, -0.07224509f, -0.00118192f, -0.01711824f, 0.15306178f, 0.01948924f, 0.03924560f, 0.02108752f, 
    0.11213566f, -0.09495527f, -0.21172503f, 0.05904830f, 0.15542795f, -0.05944738f, -0.04662277f, 0.02664833f, 
    0.04069687f, -0.03774529f, 0.05898654f, 0.04734774f, -0.08891983f, -0.26402658f, 0.12053881f, -0.09477357f, 
    0.16659845f, -0.11861209f, -0.03335330f, -0.10003227f, -0.12155429f, -0.01958858f, 0.05054929f, 0.11739203f, 
    -0.21319818f, -0.22649603f, -0.10905963f, 0.02143034f, 0.05459261f, -0.05795924f, -0.12368871f, -0.18068907f, 
    0.06555855f, 0.01632973f, 0.10047189f, 0.02351305f, 0.06053686f, 0.02135311f, 0.17437923f, 0.26735929f, 
    0.04597077f, -0.04341195f, -0.03303000f, 0.05786530f, 0.10616449f, 0.10613804f, -0.23283871f, -0.00494229f, 
    0.24743699f, -0.06831843f, 0.15470932f, -0.12551962f, 0.05637235f, -0.02010348f, 0.19640307f, 0.05038977f, 
    -0.02219931f, 0.04487375f, 0.00449961f, -0.02872312f, -0.11695664f, -0.09274079f, -0.19709031f, -0.05556593f, 
    -0.01324229f, -0.01819578f, 0.12272120f, -0.07510778f, 0.00484032f, -0.01120326f, -0.02820553f, 0.03832082f, 
    0.18576463f, 0.04832131f, 0.16433664f, -0.14040910f, 0.13432284f, -0.08189239f, 0.05946929f, 0.09836815f, 
    0.17298655f, -0.02197749f, -0.01782085f, -0.01871324f, 0.00743241f, 0.12743297f, -0.05672297f, -0.09651425f, 
    -0.00517829f, -0.13977444f, -0.11114527f, 0.14183897f, 0.16732991f, 0.01939746f, 0.11013305f, -0.05016867f, 
    0.25707477f, -0.13082501f, 0.06425309f, -0.00578998f, -0.06979076f, 0.02197205f, -0.03734397f, 0.00842073f, 
    0.07100353f, -0.08108135f, -0.08151451f, -0.03398901f, -0.26993474f, -0.11488479f, 0.05150057f, -0.24538171f, 
    0.05692826f, 0.02776400f, 0.10037766f, 0.01618076f, -0.11533473f, 0.07456686f, -0.01542329f, -0.05226162f, 
    0.01126853f, -0.07536805f, 0.18029672f, 0.07581180f, -0.17045292f, -0.02997290f, -0.03296831f, -0.03991822f, 
    -0.00053250f, -0.15632236f, 0.03392964f, 0.01833077f, 0.23644435f, 0.03590440f, 0.08282369f, -0.09507786f, 
    0.10441487f, 0.01875960f, 0.02900796f, 0.05276724f, 0.05096048f, 0.05532619f, -0.11411095f, 0.09697052f, 
    0.03991017f, 0.02664438f, 0.05252704f, 0.23892060f, -0.00478429f, 0.05878752f, 0.09868313f, 0.07690540f, 
    0.11643549f, -0.03916157f, 0.18384412f, -0.13253978f, 0.04278703f, -0.01878929f, 0.11576802f, 0.00635591f, 
    0.16973084f, -0.10464028f, 0.10715316f, -0.24957697f, 0.03506675f, 0.01857553f, -0.06233956f, 0.03373959f, 
    0.15361612f, 0.17975546f, -0.22277796f, 0.18396460f, 0.12395748f, -0.00464566f, -0.00441484f, -0.08115494f, 
    0.11487684f, 0.12484497f, -0.01355107f, -0.03166216f, -0.40658563f, -0.01101239f, 0.05536135f, -0.17532925f, 
    0.01078868f, 0.01862517f, -0.10111952f, 0.06963000f, -0.06186192f, 0.12334581f, -0.08751322f, 0.02790261f, 
    0.26996836f, 0.12948994f, -0.07743464f, 0.08521651f, 0.17000259f, -0.03996360f, 0.05106661f, 0.03333134f, 
    -0.08307251f, 0.07271742f, 0.10085011f, 0.12710778f, -0.01129380f, 0.01805825f, -0.09888465f, 0.29252395f, 
    0.10271556f, 0.08142588f, 0.07380588f, -0.01728963f, 0.03698708f, -0.02194508f, 0.14934066f, 0.06149964f, 
    -0.14777201f, 0.07819662f, 0.05166243f, -0.16634120f, -0.12340241f, 0.01020641f, -0.02999774f, 0.08463883f, 
    -0.07694601f, 0.05330737f, -0.02187275f, 0.01799067f, -0.00121441f, 0.14199740f, -0.05495294f, 0.20662081f, 
    0.06365775f, 0.05190426f, 0.05140023f, -0.04529772f, -0.00702107f, 0.01970071f, -0.00726005f, 0.05644779f, 
    -0.23753147f, -0.10942921f, -0.10187662f, -0.16332923f, -0.02815506f, 0.01616710f, -0.09828175f, 0.00373870f, 
    0.12378372f, 0.08941822f, 0.09737507f, -0.01303384f, 0.04786475f, 0.23650458f, 0.24580714f, 0.11871206f, 
    -0.05211225f, 0.16949955f, -0.02485881f, -0.03830471f, -0.06485743f, -0.01719394f, -0.03369645f, -0.01347354f, 
    0.16281331f, -0.07108030f, 0.10745452f, -0.29937965f, -0.05116814f, 0.09049769f, 0.06221804f, 0.06992687f, 
    0.02893169f, -0.03419179f, -0.03627514f, -0.02096068f, 0.11021667f, -0.16855849f, -0.17858648f, -0.14066403f, 
    0.15978387f, -0.02661611f, -0.11221714f, -0.07662017f, 0.09503485f, -0.05245417f, 0.13640845f, 0.03976605f, 
    0.11438573f, 0.31130216f, 0.10063609f, -0.14877881f, -0.06166291f, 0.03466148f, -0.09131861f, 0.06169943f, 
    0.04837985f, 0.09898032f, 0.00152989f, -0.12393200f, 0.12363549f, -0.21394353f, -0.01362178f, 0.01150533f, 
    -0.01433391f, -0.16668150f, -0.03897305f, 0.06176249f, 0.18064216f, 0.03888524f, -0.00454227f, -0.03185546f, 
    0.19409238f, -0.34857133f, -0.03703774f, 0.02582809f, 0.01889854f, 0.13293591f, -0.18107837f, -0.06990982f, 
    0.07613195f, 0.10581569f, 0.08541399f, 0.02039686f, 0.21091749f, -0.03769675f, -0.20880622f, -0.03507311f, 
    0.09899217f, -0.02332494f, -0.12017123f, -0.11891412f, -0.02412515f, -0.01729108f, -0.02294316f, -0.10052870f, 
    0.13277298f, -0.00440960f, -0.07946899f, 0.19130351f, 0.12302974f, -0.15453136f, 0.09868399f, -0.04847563f, 
    0.05270489f, 0.13521048f, 0.04894204f, 0.11566140f, -0.27626637f, 0.06458767f, -0.26430795f, -0.07702398f, 
    0.09168865f, -0.06760661f, 0.12029134f, -0.02904485f, 0.03488914f, -0.09036696f, -0.02532463f, -0.14000146f, 
    0.03448893f, 0.06885853f, 0.23394023f, 0.21464689f, 0.04906342f, 0.06952848f, 0.12672776f, -0.02285677f, 
    0.00614054f, -0.17271687f, 0.13281243f, 0.03324226f, 0.02463019f, 0.09099915f, 0.14060836f, 0.02247855f, 
    -0.01770712f, 0.08082021f, -0.10724962f, 0.03476384f, 0.07339335f, 0.08703846f, 0.03578020f, 0.21973987f, 
    -0.06248262f, -0.07755416f, 0.18384397f, -0.23917241f, -0.03528063f, -0.15801455f, -0.03208234f, 0.01457812f, 
    0.19148375f, 0.22308236f, 0.05507899f, 0.27924237f, -0.14371544f, -0.03728537f, 0.26658475f, -0.24401601f, 
    0.10116134f, -0.07077544f, -0.00213613f, -0.13780501f, -0.05957758f, -0.16640496f, -0.02695169f, 0.12635364f, 
    -0.03411754f, -0.04508114f, 0.10466378f, 0.10965671f, 0.15173516f, -0.11302039f, -0.05287366f, -0.25978246f, 
    -0.02788856f, 0.04355161f, 0.06500884f, 0.10511889f, -0.07468224f, 0.07655574f, -0.21368077f, 0.41381150f, 
    0.11482910f, 0.01935138f, -0.14316916f, -0.12388254f, 0.03126775f, 0.21504177f, -0.14031239f, -0.03013416f, 
    0.16165446f, 0.20048571f, 0.16418365f, -0.08922753f, 0.19824533f, 0.03361299f, -0.02275393f, -0.04975733f, 
    -0.01307702f, 0.07908973f, -0.10450681f, -0.15141232f, -0.25182149f, 0.03708567f, 0.08719108f, 0.15781654f, 
    0.13036808f, 0.18632606f, -0.08827035f, -0.13311611f, 0.18358704f, 0.02952133f, 0.11159752f, 0.01876286f, 
    -0.06930112f, -0.01102383f, 0.04401661f, -0.16432802f, 0.04374733f, 0.06390990f, -0.01440928f, 0.03909326f, 
    -0.02912375f, -0.08368088f, -0.08133501f, -0.10584044f, 0.19799264f, 0.12777029f, 0.05800293f, 0.06339677f, 
    -0.09350601f, -0.03961109f, -0.06091189f, -0.02598072f, -0.26252794f, 0.16211759f, 0.19830753f, 0.11627816f, 
    -0.02867031f, 0.04474784f, -0.01200421f, 0.19963181f, -0.08779967f, -0.07274988f, -0.03079673f, 0.05381112f, 
    -0.02813309f, 0.02354383f, -0.03027888f, -0.00417071f, -0.13378876f, 0.04413885f, 0.03715237f, 0.22390290f, 
    0.19813570f, 0.05009089f, 0.10006158f, 0.05172379f, -0.10340521f, -0.00325105f, 0.06632219f, 0.19537519f, 
    0.23823883f, 0.03704092f, -0.10574161f, -0.00128018f, 0.16676718f, 0.06352774f, -0.08839074f, -0.17583711f, 
    0.09483240f, -0.02101208f, -0.06033211f, -0.05269638f, -0.04522115f, 0.05924955f, 0.13704333f, 0.00834332f, 
    0.02620953f, 0.18484583f, -0.07686040f, -0.11077470f, 0.21659580f, -0.05323622f, -0.08725876f, 0.15462552f, 
    -0.08685077f, -0.10230709f, -0.08827697f, -0.04501094f, 0.01498494f, 0.23483230f, -0.06837226f, 0.09479854f, 
    -0.04060556f, -0.00933026f, 0.13689783f, 0.01198125f, -0.50508463f, 0.00095601f, 0.17095667f, 0.03466521f, 
    0.03150042f, -0.07131273f, 0.24874857f, -0.21600746f, 0.02111472f, -0.01507555f, -0.05029152f, 0.17691061f, 
    -0.21481991f, -0.03120517f, 0.07058156f, 0.22873017f, 0.02623274f, -0.04646793f, 0.11219583f, 0.07015868f, 
    -0.07318506f, 0.16571650f, 0.04669006f, 0.00282603f, -0.38287792f, 0.02459124f, 0.00804072f, -0.20233123f, 
    0.09097687f, -0.07468329f, -0.07649489f, 0.11620405f, -0.02164196f, -0.03969467f, 0.01081138f, 0.00569717f, 
    -0.08694620f, -0.22364424f, 0.15077813f, 0.00794572f, 0.08117340f, -0.00422811f, 0.03425799f, 0.04760418f, 
    0.08074886f, 0.02507021f, 0.09645440f, 0.09727963f, -0.18664294f, 0.16892634f, 0.06114921f, -0.29254076f, 
    0.13318065f, -0.05921711f, 0.11654997f, 0.04794892f, -0.06479863f, 0.09451987f, 0.05658203f, 0.05330744f, 
    0.11921545f, 0.26260987f, -0.06433713f, -0.20971106f, 0.03065623f, 0.06442411f, 0.03989856f, 0.11767024f, 
    -0.02824480f, 0.10926495f, -0.09156641f, 0.17789413f, 0.06360289f, 0.13060652f, -0.05495749f, 0.13296428f, 
    0.03419042f, 0.06898008f, -0.12538897f, -0.01387150f, -0.13453017f, 0.05659094f, -0.03783720f, 0.06848842f, 
    -0.35447139f, -0.35379207f, 0.02337310f, 0.26840657f, 0.00742542f, 0.04689620f, -0.01965165f, 0.07356799f, 
    0.17898975f, 0.12474068f, 0.10999809f, 0.01320487f, -0.05406024f, 0.01395065f, -0.28744975f, -0.11789742f, 
    0.00343891f, 0.16067870f, -0.02303598f, 0.02752613f, -0.08724726f, 0.07562084f, -0.11358541f, -0.08287600f, 
    0.14138216f, -0.06779151f, 0.05413403f, 0.22383863f, 0.11458448f, 0.02576841f, 0.05220739f, 0.10230293f, 
    -0.06418961f, -0.03696228f, -0.02217987f, 0.03405574f, 0.01185524f, -0.13704191f, 0.01138068f, 0.12229067f, 
    0.02071082f, -0.03777010f, 0.11609720f, 0.05021022f, 0.18065719f, -0.21042863f, 0.10858547f, -0.01711526f, 
    -0.29195341f, -0.08394755f, -0.05040415f, -0.04627323f, 0.10704643f, -0.13158883f, -0.09909538f, 0.05717682f, 
    -0.00626573f, 0.06777479f, 0.06472562f, -0.18079410f, 0.13316138f, -0.03735250f, 0.16627567f, -0.06852736f, 
    -0.14440052f, -0.04164027f, 0.00306719f, 0.13547006f, 0.00798568f, 0.10726715f, 0.06777856f, 0.14813107f, 
    -0.03718110f, -0.02811403f, -0.01321787f, -0.01946385f, -0.02258869f, 0.01919130f, -0.00369304f, -0.00283028f, 
    -0.00235604f, -0.01103996f, 0.04008248f, -0.02478889f, 0.01541809f, 0.02090920f, 0.01458754f, -0.03255656f, 
    0.04417241f, -0.01258187f, 0.00535220f, -0.01157679f, 0.03223101f, -0.03883858f, 0.01571814f, -0.00259674f, 
    0.00807714f, -0.03604093f, 0.03849723f, -0.01228901f, -0.00562663f, -0.05770870f, -0.03653083f, -0.01379913f, 
    0.04246020f, -0.02284047f, 0.02309683f, 0.03251539f, -0.01417990f, -0.03847167f, -0.01608826f, 0.03906073f, 
    -0.00725331f, 0.00377705f, -0.03022865f, -0.00545079f, 0.03744437f, 0.03894575f, -0.04786906f, 0.02909251f, 
    0.01105518f, -0.05605176f, -0.04924024f, -0.03207238f, -0.01576695f, -0.02176248f, 0.01189561f, -0.03735185f, 
    -0.01581502f, -0.05353447f, -0.04384276f, -0.03498467f, -0.05208437f, 0.04181885f, -0.01632836f, 0.03017605f, 
    -0.01718429f, -0.01812107f, 0.00853873f, 0.03712574f, -0.02811523f, -0.05236189f, -0.03396143f, 0.03047694f, 
    0.01823863f, -0.03645134f, 0.02181106f, -0.00188505f, -0.01089914f, 0.01035651f, -0.04356048f, 0.02183362f, 
    -0.00548765f, 0.00151409f, -0.04170154f, -0.02364463f, 0.02636631f, -0.04511465f, 0.04028273f, 0.02018832f, 
    -0.04639820f, -0.01385882f, 0.04220871f, 0.03981824f, -0.00341717f, -0.02420405f, 0.00935997f, 0.00835075f, 
    0.02870965f, 0.01060273f, -0.02327232f, -0.03647022f, -0.04966905f, -0.01629021f, -0.00579315f, -0.03051794f, 
    0.02049102f, -0.02174420f, 0.04498450f, 0.02967807f, 0.03267530f, -0.04275288f, -0.04793705f, -0.02571651f, 
    -0.03004872f, -0.04218730f, 0.04012952f, 0.00474049f, -0.03416659f, -0.00534385f, 0.03540214f, -0.02743512f, 
    0.02927829f, 0.04218596f, -0.02570182f, -0.01972421f, 0.00520104f, 0.02750930f, -0.05676103f, -0.05797687f, 
    0.02556814f, -0.02843565f, -0.02972294f, -0.04590654f, -0.00329678f, -0.05412868f, -0.02442948f, 0.00774350f, 
    -0.03190229f, 0.04466094f, -0.00320757f, 0.01714584f, 0.03059752f, -0.05169753f, 0.03653149f, 0.01353800f, 
    0.00140967f, 0.02162429f, 0.02169534f, 0.01094093f, -0.04110508f, 0.00032592f, -0.03205002f, -0.05463793f, 
    0.03239170f, 0.03572709f, -0.03760700f, 0.02418686f, -0.00344078f, -0.05001269f, 0.04073985f, 0.04044134f, 
    -0.02894025f, -0.02406911f, 0.03264384f, 0.03403981f, 0.01250488f, 0.02471863f, 0.00113979f, 0.03157235f, 
    0.00766756f, -0.03703562f, -0.04564158f, 0.00951924f, -0.03996930f, -0.03236056f, -0.00634171f, -0.00580056f, 
    0.00815471f, 0.03906675f, -0.00342116f, 0.00724094f, -0.05936128f, 0.02635868f, 0.01033563f, 0.02365575f, 
    -0.03980418f, -0.05030682f, 0.00468882f, -0.02937690f, 0.01062605f, -0.02130685f, 0.00635323f, -0.03933137f, 
    -0.00942987f, 0.01018635f, -0.01970576f, -0.02858234f, -0.03580385f, -0.03922624f, -0.05229414f, -0.04012131f, 
    -0.03697778f, 0.00739736f, -0.04162796f, 0.00747319f, -0.05486953f, 0.01701613f, 0.01621149f, -0.05385172f, 
    0.02253134f, -0.00637264f, -0.03966856f, 0.02945082f, -0.04442095f, -0.03741033f, -0.00344953f, 0.02418480f, 
    -0.05607779f, 0.01911092f, -0.01204552f, -0.04432117f, 0.04780666f, 0.00258457f, -0.01749462f, -0.01939547f, 
    -0.01071951f, -0.01160184f, -0.01973051f, 0.02447188f, 0.00999397f, 0.00097485f, 0.01185759f, -0.00944780f, 
    -0.01623713f, -0.04669105f, 0.02356358f, 0.03349981f, 0.00637986f, -0.04314364f, -0.03158196f, 0.02916390f, 
    -0.02443269f, 0.02252008f, 0.02103996f, -0.03829164f, 0.03950851f, -0.03555402f, -0.04811070f, 0.01850269f, 
    0.03654970f, 0.01749468f, -0.01115396f, 0.04452254f, -0.01533617f, -0.04712034f, -0.02326747f, 0.02581400f, 
    0.03342678f, 0.03324076f, -0.04003306f, -0.01505058f, 0.00675444f, -0.01185563f, -0.02297140f, 0.03798902f, 
    0.02582660f, -0.05367366f, -0.04701937f, 0.01107988f, -0.05681660f, -0.01190849f, 0.00160547f, -0.00051990f, 
    -0.02460263f, 0.00505346f, -0.02957152f, -0.04174291f, -0.00227218f, -0.02621146f, 0.02545961f, -0.02875650f, 
    0.01404387f, 0.03932255f, 0.00526551f, 0.01924173f, 0.01661351f, 0.01701172f, 0.00019522f, -0.02674942f, 
    -0.00694326f, 0.00982246f, -0.04069990f, 0.02505708f, -0.05063920f, 0.01893539f, -0.00024397f, -0.04360047f, 
    0.03815048f, -0.03833632f, -0.05466711f, 0.02796481f, 0.03911467f, -0.05525425f, 0.02834724f, 0.03750317f, 
    0.01146260f, -0.00336611f, -0.04137293f, 0.02822766f, -0.02327986f, -0.03068784f, 0.01518330f, 0.03649129f, 
    -0.00511121f, 0.00758036f, -0.00746150f, -0.05074089f, 0.04184483f, 0.02369075f, -0.02364554f, -0.02256705f, 
    0.05034518f, -0.03103049f, 0.03274792f, -0.00692579f, -0.02758606f, 0.03430216f, 0.02401898f, -0.04463405f, 
    0.04006106f, -0.02035548f, -0.00483855f, 0.04738739f, 0.01790045f, 0.02270366f, -0.01796407f, -0.05098819f, 
    -0.01927779f, -0.02603702f, -0.02513060f, -0.02399491f, 0.01693771f, 0.04742102f, -0.05217960f, -0.04061634f, 
    -0.01951428f, 0.01812752f, -0.05354349f, 0.04457079f, -0.01675153f, -0.01126655f, -0.04457187f, 0.01243070f, 
    -0.04825282f, 0.02339391f, 0.00673614f, -0.02612587f, -0.05243820f, 0.03488651f, -0.04333963f, -0.01297232f, 
    0.01732020f, -0.04225741f, -0.04836746f, 0.01580525f, -0.01079127f, -0.01195205f, 0.00523013f, -0.02982739f, 
    -0.05712459f, 0.00168913f, -0.01535834f, -0.00456123f, 0.04327921f, 0.01160450f, -0.04763668f, -0.04914347f, 
    -0.04796575f, -0.02447713f, -0.05061596f, -0.04399153f, -0.04579951f, 0.03537838f, -0.02979212f, -0.01162741f, 
    0.00422596f, -0.03352175f, -0.03220468f, 0.00808520f, -0.00778325f, -0.04506532f, -0.03230437f, 0.03400418f, 
    0.01785263f, 0.00764586f, -0.05206558f, -0.00472247f, -0.02837466f, -0.04624905f, -0.04989456f, -0.05419041f, 
    -0.00774954f, 0.00500444f, -0.03699096f, 0.02780737f, -0.04059517f, -0.03983738f, -0.04857759f, 0.01029222f, 
    -0.01148356f, -0.01584004f, 0.01155795f, -0.00221419f, -0.01801554f, -0.04104478f, 0.00027599f, -0.05209693f, 
    0.04320916f, 0.02301962f, -0.03237514f, -0.01952272f, 0.02234102f, -0.01319156f, -0.03713141f, -0.01724041f, 
    -0.00407199f, -0.02951773f, 0.01525583f, -0.04183410f, 0.01626747f, -0.02619116f, 0.01244990f, 0.04451765f, 
    -0.01377566f, 0.04517433f, -0.03344092f, 0.03920583f, -0.00556099f, 0.00799774f, -0.04624363f, -0.00394626f, 
    0.03043780f, -0.05601398f, -0.05339365f, 0.03564506f, 0.01188650f, -0.03726355f, -0.01150277f, -0.00783025f, 
    -0.05480752f, 0.03439072f, -0.00011591f, -0.00031850f, 0.04391658f, 0.00541120f, 0.03671389f, -0.00808123f, 
    -0.01731137f, 0.00100064f, -0.04873000f, 0.04503993f, 0.00993620f, 0.00414457f, -0.04109953f, -0.04110823f, 
    -0.04425516f, -0.00283049f, -0.03014393f, 0.02239644f, -0.04838381f, -0.03318479f, 0.03484395f, -0.00702999f, 
    0.01779103f, -0.01375757f, 0.03448723f, -0.05586376f, 0.00861549f, -0.00722967f, -0.02184832f, 0.01783966f, 
    0.00534999f, -0.01396894f, -0.01137783f, -0.03992501f, 0.00859416f, 0.03157473f, -0.01974481f, 0.00426780f, 
    -0.05006946f, -0.02558203f, 0.04806151f, -0.04178689f, 0.01306001f, -0.02485592f, 0.01417702f, 0.02799017f, 
    0.01691612f, -0.02552517f, 0.02263981f, 0.00000973f, -0.02160956f, -0.00347667f, 0.01296883f, 0.01698493f, 
    -0.04178686f, -0.00175921f, -0.03460950f, -0.01064266f, -0.00981792f, 0.04016650f, 0.02939974f, 0.01887038f, 
    -0.02978332f, -0.01594093f, -0.01989901f, -0.02565351f, 0.03433939f, 0.00096229f, 0.04533069f, 0.03983038f, 
    -0.02716910f, -0.02376935f, 0.03157382f, 0.03126809f, -0.00368551f, 0.03855056f, 0.03015752f, 0.02812439f, 
    0.01990802f, -0.02266835f, -0.03658466f, -0.04601512f, -0.04663307f, -0.04620253f, 0.03388692f, 0.02556028f, 
    0.02113811f, 0.00019398f, -0.05050439f, 0.04111173f, -0.05238902f, 0.03127015f, -0.05028103f, 0.02820234f, 
    -0.03500881f, -0.04648534f, -0.04489538f, 0.02157695f, -0.04521554f, -0.03923345f, 0.02773454f, -0.02388745f, 
    0.04907569f, 0.04298715f, 0.01766323f, 0.00647732f, -0.04066838f, 0.03046461f, -0.02137060f, -0.05310729f, 
    -0.01501247f, 0.02211567f, -0.01259206f, -0.03760261f, -0.05587055f, -0.05084768f, -0.03237380f, -0.04059378f, 
    -0.03045986f, -0.04255401f, -0.02019636f, -0.01900358f, 0.01201080f, 0.00901915f, -0.02783149f, -0.02908083f, 
    0.02135432f, 0.02100058f, -0.02814408f, 0.00451671f, 0.04468187f, -0.00577442f, 0.00019646f, 0.00321377f, 
    -0.01528103f, -0.03811151f, -0.03596266f, -0.00812017f, -0.04925109f, 0.00599523f, -0.01996195f, -0.00646128f, 
    -0.04178469f, -0.00240092f, 0.00966559f, -0.01182163f, 0.04103730f, 0.01377228f, -0.05570544f, -0.02764652f, 
    0.01512507f, -0.05376705f, -0.02670771f, 0.02652788f, 0.00077339f, -0.02420760f, -0.00180631f, 0.00111041f, 
    -0.04604534f, -0.00979443f, -0.03484006f, -0.04679051f, 0.01764793f, -0.01733152f, 0.02671694f, 0.02057140f, 
    0.01278672f, 0.01204378f, -0.00718995f, -0.04153604f, 0.00683555f, 0.02135924f, -0.00356319f, -0.01721335f, 
    -0.04863485f, -0.00443652f, -0.00533434f, -0.05159488f, -0.02828862f, 0.02450063f, -0.01704205f, -0.04361009f, 
    0.01490506f, 0.01565499f, 0.02906032f, -0.05365884f, -0.00154918f, -0.02186101f, -0.00565008f, 0.02694940f, 
    -0.02010402f, 0.02288663f, -0.04353797f, 0.00042294f, -0.03888944f, 0.01880488f, 0.02735749f, 0.02096847f, 
    -0.04167816f, 0.02555128f, -0.04224906f, -0.05031618f, 0.00419684f, -0.03501621f, 0.00137210f, 0.04002275f, 
    -0.00921232f, 0.02803592f, -0.00603613f, -0.02815677f, 0.01036474f, -0.04162899f, 0.04427962f, 0.03917983f, 
    -0.03412804f, -0.05015721f, -0.01829121f, 0.02247060f, -0.04396324f, 0.01861375f, -0.05397946f, 0.02061176f, 
    0.00305073f, 0.01246615f, -0.04954068f, 0.03868064f, -0.03828912f, -0.02820690f, -0.00446432f, 0.01127972f, 
    -0.05244467f, -0.03886014f, 0.04131781f, 0.03294013f, 0.03429537f, 0.04345935f, 0.00274846f, 0.00635876f, 
    -0.01793751f, 0.01606014f, 0.02710097f, -0.02539963f, -0.04475084f, -0.04300524f, 0.02466143f, 0.03885946f, 
    0.04398438f, 0.02136730f, 0.02767935f, 0.04497311f, 0.03126545f, 0.03684800f, -0.05624520f, -0.01023821f, 
    0.02089793f, -0.02692582f, -0.03283999f, -0.02360894f, -0.00373521f, 0.03809927f, 0.03385482f, -0.00608528f, 
    -0.00811120f, -0.02367587f, 0.03509248f, -0.01053988f, 0.01443963f, 0.02039043f, -0.03829478f, -0.00357931f, 
    0.00136256f, -0.04690745f, 0.00900454f, -0.03997188f, -0.01951914f, -0.05630389f, -0.05147831f, 0.03825774f, 
    -0.03593083f, 0.01781436f, -0.03560682f, 0.01523220f, -0.00710238f, -0.04873899f, -0.03375103f, 0.00654857f, 
    -0.00070427f, -0.01154580f, -0.01681911f, -0.04095022f, 0.02198453f, -0.00411696f, -0.04088985f, 0.02455042f, 
    0.02218585f, 0.00966201f, 0.03555926f, 0.03775530f, 0.03539002f, -0.01434873f, -0.00556957f, 0.00997196f, 
    0.01841500f, -0.03697071f, -0.02124453f, -0.04044530f, 0.00799547f, 0.03377572f, -0.05559586f, 0.01907269f, 
    -0.02864821f, 0.02980914f, -0.04511115f, -0.05272360f, 0.01358121f, 0.01955004f, -0.02403482f, -0.02868395f, 
    0.07755688f, -0.35861075f, 0.03351043f, 0.14443505f, 0.00489258f, -0.13364804f, 0.21442017f, -0.03956936f, 
    0.03128170f, -0.06584580f, -0.09382544f, 0.01597443f, 0.08864674f, -0.25511181f, -0.01842891f, 0.12057590f, 
    0.02479012f, 0.06326078f, -0.09208199f, 0.01561459f, 0.09218636f, 0.16096985f, 0.01718006f, 0.19556537f, 
    0.31131166f, -0.06532671f, -0.16468179f, -0.03613904f, -0.01158324f, -0.01015883f, 0.11460426f, 0.00860069f, 
    -0.13902614f, -0.08079781f, -0.04956833f, -0.05789517f, 0.02697464f, -0.35949394f, -0.08557051f, -0.09452896f, 
    -0.07820497f, -0.02619568f, 0.02520282f, 0.09410404f, 0.00242681f, 0.11698622f, 0.01982558f, 0.09459478f, 
    0.14287910f, 0.18166803f, -0.06647542f, -0.03462003f, -0.13941182f, -0.01113038f, 0.02315823f, 0.07184471f, 
    -0.05011474f, 0.21922512f, 0.01071213f, 0.02305660f, -0.02361396f, -0.03140659f, -0.17104495f, -0.31827405f, 
    0.11097368f, -0.05357850f, -0.02606554f, 0.01408230f, -0.14463703f, 0.00093337f, -0.01252057f, -0.01525131f, 
    -0.25548378f, 0.14036542f, 0.08284307f, -0.41334251f, -0.07599586f, 0.15605061f, -0.04992850f, 0.01775481f, 
    -0.12943552f, -0.13040361f, -0.15316206f, -0.22004759f, -0.10268456f, 0.19133782f, 0.06222272f, -0.33101895f, 
    -0.01903217f, -0.03265304f, -0.11102002f, -0.00689788f, 0.16327946f, 0.18787080f, -0.09936184f, -0.01394071f, 
    -0.13068794f, 0.05487166f, -0.14668798f, 0.48303205f, 0.07221252f, 0.05032387f, 0.10852443f, 0.13910590f, 
    -0.03318038f, 0.10765702f, 0.12021930f, -0.11755185f, 0.32245043f, 0.13506445f, -0.03495339f, -0.05853878f, 
    -0.05347578f, 0.05676374f, 0.14502949f, -0.07758278f, 0.14356436f, 0.14398818f, 0.05786593f, 0.17624387f, 
    -0.18703105f, -0.18019952f, -0.10337571f, -0.09771063f, 0.06786651f, 0.04596411f, 0.26545107f, 0.03690777f, 
    0.12985362f, -0.11062966f, -0.09294108f, 0.05176529f, 0.20018497f, -0.29230753f, -0.03336528f, 0.34432766f, 
    0.18575217f, -0.00159745f, 0.04127574f, 0.04860785f, 0.01284044f, 0.03365664f, -0.05352449f, -0.10628124f, 
    -0.29443407f, 0.35430360f, -0.24356921f, -0.33077732f, 0.11309810f, 0.07160005f, 0.02849211f, -0.11104465f, 
    0.00838282f, -0.06729305f, 0.02774596f, 0.14217639f, 0.19090348f, 0.18972595f, -0.14047880f, 0.13313641f, 
    -0.00201456f, 0.06560437f, 0.12490934f, -0.08850762f, 0.07322421f, -0.07277400f, -0.10549433f, -0.16501617f, 
    0.42120823f, -0.19998975f, -0.01335088f, 0.14147705f, 0.15518823f, -0.13759263f, 0.02539542f, -0.02801099f, 
    -0.07885491f, -0.03089018f, 0.17391057f, 0.07828256f, 0.54070276f, 0.05389626f, 0.07258129f, 0.05633204f, 
    0.11371758f, 0.04479831f, -0.12445520f, -0.04797145f, 0.09897948f, 0.03614995f, 0.01354636f, 0.09188432f, 
    0.00661033f, -0.30772743f, -0.06723454f, 0.24545538f, 0.01975296f, -0.03838545f, -0.00211174f, 0.06839537f, 
    -0.09724479f, 0.09638458f, 0.23147030f, 0.04030532f, -0.21855868f, 0.09183440f, 0.17140317f, -0.31511900f, 
    0.16077106f, 0.06879967f, -0.00169474f, 0.07721599f, 0.00930648f, 0.08384908f, 0.14782462f, 0.07663803f, 
    -0.06761748f, -0.23763263f, 0.08893262f, -0.03501030f, -0.09852333f, -0.04799554f, 0.04343305f, -0.01216994f, 
    -0.08116095f, 0.14209558f, -0.02706351f, 0.18197058f, -0.37184700f, -0.07404048f, -0.03996259f, -0.16267742f, 
    0.05603301f, 0.10177865f, 0.04790267f, 0.02206723f, 0.02200477f, 0.10580399f, 0.04961640f, 0.13394555f, 
    0.38958579f, -0.16636986f, -0.02056872f, 0.25140423f, -0.07561353f, 0.02309371f, -0.14641827f, 0.15060253f, 
    -0.02663463f, -0.06746039f, -0.06382705f, -0.05917746f, 0.52355230f, 0.07385990f, 0.24612135f, -0.07595980f, 
    -0.02617868f, -0.04079926f, 0.15425028f, 0.07277019f, 0.02626049f, 0.05704933f, 0.15600763f, -0.07285313f, 
    0.06514547f, 0.00521074f, 0.13362287f, 0.13823412f, -0.12155876f, -0.00399278f, 0.02151556f, 0.01836989f, 
    0.04446274f, -0.14225431f, -0.04037145f, -0.05158353f, -0.30913427f, 0.22748494f, -0.17663436f, -0.10890529f, 
    0.15983605f, -0.00113060f, 0.01751018f, 0.05899327f, -0.00196874f, 0.02228671f, -0.02903630f, -0.08366665f, 
    0.36221671f, -0.23768921f, -0.06158299f, -0.28124502f, 0.13680986f, 0.04835375f, 0.02370545f, 0.08582388f, 
    -0.05654330f, -0.01821500f, -0.12680408f, 0.21498232f, -0.20243871f, -0.02247176f, -0.07293230f, 0.24679983f, 
    0.03354877f, 0.00976792f, 0.21759702f, 0.02621221f, 0.03736264f, -0.08622264f, -0.06529444f, -0.18418880f, 
    -0.15607393f, -0.38227180f, 0.24484092f, 0.48074722f, -0.00242637f, 0.04691992f, 0.09357898f, 0.04687255f, 
    -0.27035654f, 0.06621579f, 0.04639840f, 0.13836318f, 0.35863292f, -0.05507187f, -0.03918449f, 0.09515803f, 
    0.00181261f, -0.08629561f, 0.00776161f, -0.06081455f, -0.15485062f, -0.01138315f, 0.24406908f, -0.00834612f, 
    0.31680650f, 0.15514383f, 0.11915252f, 0.07405677f, -0.04467848f, -0.10108576f, 0.09717415f, -0.13142140f, 
    -0.04522729f, -0.02238315f, 0.26386485f, 0.11480720f, -0.07176550f, -0.02430739f, 0.11287421f, 0.34248504f, 
    0.14756064f, 0.05816413f, -0.00984417f, 0.00026544f, 0.02718637f, 0.10079704f, -0.17731936f, -0.08145825f, 
    0.18941686f, -0.18973799f, 0.05193460f, 0.07044502f, 0.00364000f, 0.08716898f, 0.14341170f, -0.14511999f, 
    -0.06655044f, 0.03969969f, -0.02633667f, 0.18351406f, 0.25869259f, 0.02281687f, 0.22963807f, -0.34633857f, 
    0.05099298f, 0.10132264f, 0.14665835f, 0.07897424f, 0.08152190f, -0.03224197f, -0.08473202f, 0.00926724f, 
    -0.00873909f, -0.01343414f, -0.04101520f, -0.04371389f, -0.02176723f, 0.01514685f, -0.05481872f, -0.04335397f, 
    -0.00038926f, -0.04810916f, -0.03473172f, 0.03924360f, 0.01223850f, -0.00253270f, -0.04532788f, -0.04533872f, 
    0.01073417f, -0.03142160f, 0.00933124f, -0.00927072f, -0.01903933f, -0.02606365f, -0.03272999f, 0.00760994f, 
    0.01170447f, 0.04175824f, 0.01243175f, 0.02379680f, -0.02668725f, 0.03919854f, 0.01468121f, -0.05545498f, 
    0.02705621f, 0.02004171f, -0.03773002f, 0.00455935f, 0.01776396f, -0.02952028f, -0.04569436f, 0.01476381f, 
    -0.01610336f, 0.04022339f, 0.04308721f, -0.02708802f, 0.01845162f, -0.04730989f, -0.02334502f, -0.04390621f, 
    -0.05116289f, 0.04196895f, -0.00988356f, -0.00288305f, 0.01265858f, -0.04396399f, -0.02386318f, -0.04683478f, 
    -0.00165679f, 0.01395384f, 0.03902858f, -0.05572515f, -0.02431619f, 0.03888359f, 0.00960460f, 0.02558927f, 
    -0.05101627f, 0.00191216f, 0.04174019f, 0.02585102f, -0.03618312f, -0.00452697f, 0.01582837f, -0.03580438f, 
    0.00678536f, 0.02353483f, -0.02312235f, 0.02343982f, 0.01077251f, -0.02725942f, -0.01704434f, 0.02027462f, 
    -0.00736556f, -0.02645791f, -0.05512006f, -0.01489106f, 0.01193949f, -0.05538279f, -0.04614986f, 0.00933622f, 
    -0.04658022f, -0.05616879f, 0.00209775f, -0.03384322f, 0.00101611f, -0.01372450f, -0.02710810f, -0.04829697f, 
    -0.00250714f, -0.00846378f, -0.04911204f, 0.03956032f, -0.01300524f, 0.03478585f, -0.02084048f, 0.01528661f, 
    -0.05447163f, -0.02823330f, -0.00015060f, 0.02804206f, -0.02420762f, 0.04172415f, -0.01677344f, -0.05350647f, 
    0.04114692f, -0.01343391f, 0.03983908f, 0.00790593f, -0.01850578f, -0.00147012f, -0.02549239f, -0.05048757f, 
    -0.04304538f, 0.03898289f, 0.01690506f, -0.00404709f, 0.01587252f, -0.05395650f, 0.02569334f, 0.01109090f, 
    0.00345149f, 0.04015766f, -0.03326725f, -0.02550462f, 0.01966802f, 0.02397428f, -0.00278028f, -0.01574781f, 
    -0.04990075f, -0.05369970f, -0.02001358f, 0.03997849f, -0.02389954f, -0.03358956f, -0.05645011f, -0.01478761f, 
    -0.00289487f, 0.00833331f, -0.04516496f, -0.01258952f, -0.05126435f, -0.02440507f, 0.02108817f, 0.03260926f, 
    -0.03406841f, 0.03074248f, 0.01605675f, -0.05021822f, -0.02922726f, -0.01019684f, 0.00922164f, 0.02420693f, 
    -0.01525571f, -0.02328395f, -0.02657310f, 0.04194435f, -0.00210377f, -0.05522905f, -0.03887469f, 0.02250252f, 
    -0.04636434f, -0.01226078f, -0.01473198f, -0.02163476f, -0.04651808f, -0.00204115f, -0.05285880f, 0.03429260f, 
    -0.00824523f, -0.00922031f, 0.02060001f, 0.01255498f, -0.04242560f, -0.03914919f, 0.01331489f, -0.00811853f, 
    -0.02783340f, 0.02708697f, 0.02006923f, 0.03850087f, 0.04173189f, -0.05255230f, 0.02437019f, -0.00943174f, 
    0.04073319f, 0.03930866f, 0.02789533f, 0.00784743f, 0.03094381f, 0.04269109f, 0.03663326f, -0.04221405f, 
    0.03255297f, -0.03095617f, -0.00919883f, 0.03341348f, -0.03188859f, -0.03372183f, -0.03711030f, -0.03317942f, 
    0.03686742f, -0.02597998f, 0.01036598f, -0.01896381f, -0.05321363f, -0.00438912f, 0.03598004f, -0.01514025f, 
    0.03992259f, -0.01556758f, -0.02286984f, -0.04752610f, -0.02160518f, -0.01929974f, 0.01135496f, -0.01587660f, 
    -0.01056833f, -0.02244747f, 0.00472595f, -0.02739250f, -0.02390803f, 0.01904721f, 0.03972076f, -0.04472954f, 
    0.03758072f, 0.04290076f, -0.01479845f, -0.04674708f, 0.03281303f, 0.01831807f, 0.01621978f, -0.02546744f, 
    0.00787825f, -0.05370664f, -0.05108288f, -0.03555957f, -0.03376409f, -0.01828076f, 0.01479902f, 0.00351200f, 
    -0.03594847f, 0.02231291f, 0.01752505f, -0.01384813f, -0.02021257f, 0.04206586f, -0.02359671f, -0.00484853f, 
    -0.02335369f, 0.00215049f, 0.01880066f, -0.00789519f, 0.03820421f, -0.02450708f, 0.04380820f, -0.00682390f, 
    -0.04451526f, 0.04229074f, -0.00926315f, 0.01791127f, 0.03653506f, 0.02696502f, -0.04877564f, 0.01354795f, 
    -0.03012268f, -0.00985906f, 0.00261944f, 0.03868540f, -0.01758975f, -0.03042374f, 0.03868466f, -0.03790847f, 
    -0.04064726f, 0.02195517f, 0.04384135f, 0.02664054f, 0.00091906f, 0.04017047f, 0.01600875f, -0.05157242f, 
    -0.03714295f, -0.00514781f, -0.00503616f, 0.00129073f, -0.03721816f, -0.04375539f, -0.01002683f, 0.02231566f, 
    0.03577763f, 0.04308953f, 0.02492969f, -0.03447488f, -0.00582533f, -0.04516026f, 0.04520829f, -0.01872757f, 
    0.03301457f, -0.01214657f, -0.03648975f, -0.00453123f, 0.00464947f, 0.02837407f, -0.02105048f, -0.01105715f, 
    -0.05077257f, -0.03270351f, 0.00551748f, 0.02488637f, 0.02811001f, 0.00038832f, -0.02602359f, 0.02233168f, 
    -0.00691576f, -0.04709122f, -0.02445040f, -0.04509060f, -0.02076817f, -0.01698919f, -0.02565670f, -0.02741656f, 
    0.03666989f, -0.04367305f, -0.01880550f, -0.00357664f, 0.00530110f, 0.02217249f, -0.03446151f, -0.03792486f, 
    0.00423550f, 0.02442135f, 0.03337735f, 0.00621248f, -0.01094748f, -0.03918803f, -0.03578928f, 0.03366372f, 
    0.01487514f, 0.01644335f, 0.04182044f, -0.03307426f, -0.03116539f, 0.02789789f, 0.02698031f, 0.02487553f, 
    -0.03664283f, -0.03392937f, 0.00833017f, 0.01619758f, -0.00562762f, -0.05308750f, -0.02538740f, -0.05260990f, 
    0.04234210f, 0.03715399f, -0.02536295f, 0.04096404f, -0.03119114f, -0.03996027f, -0.04170059f, -0.02640322f, 
    0.02760100f, -0.01249079f, -0.00524505f, 0.00835104f, -0.05259435f, -0.05106488f, 0.03365561f, 0.00675754f, 
    -0.03673702f, -0.02314868f, 0.02079746f, 0.02090862f, -0.00595826f, 0.03255920f, -0.01654200f, -0.04882437f, 
    0.00571345f, -0.04404897f, -0.04391224f, 0.00966541f, -0.03427385f, 0.01478304f, -0.05679506f, -0.00435553f, 
    0.00745692f, -0.01557480f, -0.04677537f, 0.03716981f, 0.03883800f, -0.04745030f, 0.03532473f, 0.04279136f, 
    -0.04118920f, -0.05784124f, -0.02949183f, 0.03253986f, -0.01539811f, 0.00405092f, 0.01622206f, 0.00302936f, 
    -0.05075401f, -0.05170086f, 0.00448663f, 0.01461826f, -0.01731481f, -0.01195602f, -0.05634639f, -0.02751340f, 
    -0.01742071f, 0.00679546f, -0.02189944f, -0.05199460f, -0.01896579f, 0.01643667f, 0.01788521f, -0.04230224f, 
    -0.00456554f, -0.03547274f, -0.01594583f, 0.02986328f, 0.03305430f, 0.03835821f, 0.02454763f, -0.05312272f, 
    -0.02721438f, -0.05000110f, 0.02593436f, -0.00938886f, -0.03877992f, 0.03483571f, -0.02649673f, 0.02817213f, 
    0.00818370f, -0.00053046f, -0.00773071f, -0.03741698f, -0.02632364f, -0.00819379f, -0.05162375f, -0.01097465f, 
    -0.04778484f, -0.01310005f, -0.03858876f, -0.02369247f, 0.01287213f, -0.03270288f, 0.04206596f, -0.04594633f, 
    0.00559043f, -0.05739680f, 0.00794011f, -0.01762031f, 0.03436580f, -0.05361617f, -0.01239832f, 0.00179121f, 
    -0.02021625f, -0.02131943f, -0.00086963f, -0.04371233f, -0.00033823f, 0.02442533f, -0.02249575f, 0.03020382f, 
    0.04154832f, 0.03050286f, 0.01873096f, -0.04894783f, -0.03478065f, -0.04008615f, -0.04047879f, 0.00801634f, 
    0.00330261f, -0.04461966f, -0.05156320f, 0.02387914f, -0.00785489f, 0.00663989f, -0.04067067f, -0.05001909f, 
    0.02657346f, 0.00604273f, -0.05495365f, 0.04457219f, -0.04971521f, -0.04631899f, 0.03387258f, -0.02507889f, 
    0.01360011f, 0.02220192f, 0.03264809f, -0.03141599f, -0.05465662f, -0.04925640f, -0.05150396f, 0.01324361f, 
    -0.00908855f, -0.04756587f, 0.01127163f, -0.00174060f, 0.03581089f, -0.01368862f, 0.03421675f, 0.01381099f, 
    0.01542487f, -0.04649135f, -0.02639139f, -0.02539072f, -0.05232974f, -0.00827618f, -0.02182626f, 0.03066248f, 
    -0.03307038f, -0.05737518f, -0.04011355f, -0.02889333f, -0.00477899f, -0.00387845f, -0.05041980f, 0.01505856f, 
    0.02520369f, 0.04260077f, 0.00240486f, -0.00881509f, 0.00739949f, 0.02682047f, 0.02316127f, 0.03456971f, 
    0.00769464f, -0.04446229f, -0.05844067f, -0.05852396f, 0.00731159f, 0.01935874f, -0.02158968f, -0.02848578f, 
    0.02745149f, -0.01355752f, 0.02088050f, -0.03126110f, 0.00221662f, -0.00629020f, -0.04731562f, 0.04963494f, 
    0.03506265f, -0.02529007f, -0.00046040f, -0.03648417f, -0.05530528f, -0.05720796f, -0.05184656f, 0.02939118f, 
    -0.01954207f, 0.03839834f, -0.00027065f, -0.01466535f, -0.05203844f, 0.03782918f, 0.03427403f, -0.05832978f, 
    0.02820631f, -0.02421847f, -0.03938586f, -0.01637722f, -0.05332030f, 0.00360984f, -0.05145838f, 0.00898219f, 
    -0.02816468f, -0.04424768f, -0.03342892f, -0.05620278f, 0.00550760f, 0.03720615f, -0.02827543f, 0.02224337f, 
    0.00624815f, -0.05769697f, -0.04129960f, 0.00401040f, 0.03906763f, -0.01362255f, -0.00688945f, 0.03097231f, 
    -0.01117116f, -0.00586662f, 0.01037664f, -0.01016850f, 0.02944223f, 0.02226409f, -0.02396630f, 0.03661357f, 
    -0.03997714f, 0.02084525f, -0.00555864f, 0.00784604f, -0.04001957f, -0.00356708f, 0.03292530f, 0.00453264f, 
    -0.00001935f, 0.01600508f, -0.01619271f, 0.03633319f, -0.03391677f, -0.05587527f, -0.04206739f, 0.03120233f, 
    -0.02552713f, -0.04201786f, -0.02366925f, 0.03585529f, -0.02708199f, -0.02378198f, -0.00029683f, 0.02180774f, 
    -0.00709131f, -0.04526142f, -0.03613050f, 0.02395520f, -0.04911573f, 0.03555996f, 0.03722195f, 0.01884922f, 
    -0.02075432f, -0.05733829f, -0.04181642f, -0.03536814f, 0.03686489f, -0.03734165f, -0.01366809f, -0.02558080f, 
    0.01683101f, -0.00211002f, 0.01569948f, 0.02546031f, -0.00730846f, 0.01970547f, 0.01061246f, 0.00919953f, 
    0.00936067f, -0.00089190f, -0.04095756f, 0.01626570f, -0.03433812f, 0.02014753f, -0.01381437f, -0.02584673f, 
    0.02329860f, -0.02098096f, -0.01596862f, -0.03552965f, -0.02303646f, 0.02913713f, -0.02520892f, 0.02298828f, 
    -0.01524268f, 0.00964794f, -0.01910848f, 0.02516656f, 0.02953637f, -0.04397401f, -0.02220870f, -0.03517082f, 
    -0.01271179f, -0.05459324f, -0.04007591f, 0.02855403f, 0.00437258f, -0.00743420f, 0.01344713f, -0.02422457f, 
    -0.03366692f, -0.03054365f, 0.03918895f, -0.01762997f, -0.01222192f, -0.02361313f, -0.04482566f, 0.02334846f, 
    0.01972866f, -0.03759159f, -0.00453053f, -0.03990409f, -0.01577920f, -0.00900435f, 0.03446338f, 0.01222786f, 
    0.02145758f, 0.00836458f, 0.00307139f, -0.02538203f, 0.02573758f, 0.01696980f, -0.00570314f, -0.01149813f, 
    -0.00509781f, -0.03860972f, -0.01489556f, -0.04798393f, -0.04836357f, 0.01361098f, -0.03351589f, 0.01388451f, 
    0.01678936f, -0.00819037f, 0.02918136f, -0.01632609f, -0.03977178f, -0.01757126f, -0.05305346f, -0.05163993f, 
    0.03292527f, 0.03622895f, 0.02293241f, 0.00587339f, -0.05095739f, -0.04362024f, -0.02228379f, -0.04169730f, 
    -0.02289608f, -0.03203031f, 0.01824694f, -0.03946659f, 0.03361382f, 0.00048124f, -0.02099824f, 0.03581439f, 
    -0.05102200f, 0.01709192f, 0.00248577f, -0.02627630f, -0.00665922f, 0.02309885f, 0.03939860f, -0.03862698f, 
    -0.01935474f, 0.00136682f, 0.01275747f, -0.01598383f, 0.03434230f, 0.04175563f, 0.04054313f, 0.02620826f, 
    0.02157871f, 0.03552783f, -0.01952066f, -0.01291215f, -0.03038649f, -0.05397046f, -0.02843502f, -0.03695171f, 
    0.03487021f, -0.00521651f, -0.04641245f, -0.04602107f, -0.02864949f, 0.03016370f, 0.02410024f, -0.00671080f, 
    0.13901886f, 0.25414860f, 0.00116381f, -0.11460258f, -0.00446273f, 0.02772589f, 0.02246778f, 0.15305604f, 
    0.02864211f, 0.10579541f, 0.07051223f, 0.02293944f, 0.12982154f, -0.00685549f, -0.02790776f, -0.00483690f, 
    -0.04137500f, 0.01395373f, -0.00343728f, 0.07265284f, -0.04216418f, -0.09071768f, -0.07252121f, -0.14890078f, 
    0.61570781f, 0.10294635f, 0.00184663f, -0.11601645f, 0.07323889f, 0.08164673f, 0.06005907f, 0.11146790f, 
    -0.07303123f, -0.01580941f, 0.25108832f, 0.11103114f, 0.55432332f, 0.10935940f, -0.04290255f, 0.16092220f, 
    0.07310890f, -0.06502476f, -0.06536036f, 0.18997283f, 0.07035272f, 0.01056171f, 0.03558281f, 0.08821543f, 
    0.32340264f, 0.17940061f, -0.03801525f, -0.11934207f, 0.05652606f, 0.05744346f, 0.10890078f, 0.05219848f, 
    0.06835280f, -0.13350740f, 0.15312541f, 0.06808202f, -0.09939440f, -0.23333572f, -0.02572376f, -0.26425543f, 
    0.11234417f, 0.05786022f, -0.07681847f, -0.15132791f, 0.09195127f, -0.07568631f, 0.14892396f, 0.00143692f, 
    -0.15933031f, -0.19436115f, -0.14743552f, 0.23301904f, 0.03016105f, -0.10678887f, 0.05612824f, -0.04395952f, 
    -0.05416707f, 0.01726066f, -0.08760817f, 0.13197520f, -0.22559541f, -0.01641276f, -0.08059135f, 0.12039188f, 
    0.12956935f, -0.10398827f, -0.03985679f, -0.04447926f, 0.14883801f, 0.07254126f, -0.07517600f, -0.12681504f, 
    0.07514305f, -0.22376145f, 0.13662739f, -0.04278539f, 0.08625224f, -0.04959100f, 0.25148964f, -0.03934627f, 
    -0.06233750f, -0.04543093f, -0.02922092f, 0.04050776f, 0.14722519f, -0.13735947f, -0.01244342f, -0.09428672f, 
    -0.07320291f, 0.06136532f, 0.01177705f, 0.02891212f, -0.04902908f, -0.06212902f, 0.09999996f, 0.14053120f, 
    -0.32992131f, -0.15283050f, -0.28647560f, 0.16342270f, 0.23010471f, -0.08240545f, -0.03602191f, 0.02055256f, 
    0.02387810f, 0.03200798f, -0.02158506f, 0.09036475f, -0.06041951f, 0.04432998f, 0.26816228f, -0.20834035f, 
    0.05150821f, -0.01027721f, -0.07107565f, -0.00409869f, -0.02551006f, 0.01258941f, 0.02581732f, -0.00431554f, 
    -0.09529978f, -0.19501016f, -0.05812877f, 0.10639571f, 0.09399213f, 0.01334083f, -0.03465745f, -0.15090579f, 
    0.02237614f, -0.07913797f, 0.01228647f, 0.03012265f, 0.17876568f, 0.07368699f, -0.05025153f, -0.02371123f, 
    0.15078907f, 0.17761838f, 0.16748871f, 0.04165447f, 0.04372557f, 0.13711494f, -0.11023977f, 0.00996418f, 
    -0.12552321f, 0.16962512f, -0.10425935f, -0.13439244f, -0.02223149f, -0.01151084f, 0.01951195f, -0.12197089f, 
    0.03189909f, -0.05171742f, 0.05241890f, 0.15919572f, 0.11886521f, 0.23675460f, -0.02738194f, 0.22376318f, 
    -0.15992475f, 0.01020214f, -0.16266976f, 0.09035803f, 0.00370580f, -0.01207887f, -0.10367197f, 0.10105906f, 
    0.12278029f, -0.10347471f, -0.05351167f, 0.12734619f, -0.00195285f, -0.11795583f, 0.01552169f, 0.12142896f, 
    -0.13494799f, 0.01303507f, -0.08691184f, -0.04906387f, -0.13045958f, -0.19361913f, -0.03790117f, -0.04641124f, 
    0.01529712f, 0.01091739f, -0.08488237f, -0.04001724f, 0.07264546f, -0.04931673f, 0.15899874f, -0.02596041f, 
    0.32610583f, -0.03200273f, -0.00832575f, 0.03595257f, -0.03143394f, -0.14721474f, 0.12449517f, 0.13813378f, 
    -0.04676640f, 0.04780896f, -0.06551975f, 0.02946094f, -0.20185126f, -0.39908192f, -0.06252692f, -0.27592701f, 
    0.01534797f, -0.04086044f, 0.08440540f, 0.04864999f, 0.13021058f, 0.09702165f, -0.04927450f, 0.01189969f, 
    0.02448733f, -0.11384204f, 0.14949650f, -0.33977392f, -0.02841476f, -0.04941891f, -0.04697869f, -0.09107003f, 
    0.11004838f, 0.10615817f, 0.13732614f, 0.08425243f, -0.04708548f, 0.21532702f, -0.09103726f, 0.29523516f, 
    -0.08112498f, 0.03476660f, -0.00314171f, 0.06737778f, -0.02498267f, 0.03263521f, 0.12936419f, 0.04341590f, 
    -0.25677586f, -0.16950530f, 0.24397613f, -0.44133043f, -0.03623048f, -0.00177149f, 0.07246582f, 0.24840428f, 
    0.12939659f, 0.03328777f, 0.05172971f, -0.06405003f, 0.12101179f, -0.15695608f, 0.01164358f, -0.19839302f, 
    0.12889381f, 0.01276403f, -0.04344751f, -0.00100485f, -0.09600810f, 0.02567116f, 0.22529210f, 0.10795812f, 
    0.37713754f, 0.09841647f, -0.12090977f, 0.07338329f, 0.09476753f, 0.02991347f, -0.13752753f, 0.05928924f, 
    0.01765340f, 0.04827166f, 0.00668802f, 0.01422359f, 0.05777827f, -0.19348915f, 0.40485308f, -0.17930199f, 
    -0.07090791f, 0.06865910f, 0.08180691f, 0.04709948f, -0.11952139f, -0.00104224f, -0.06055752f, 0.02380101f, 
    0.34284624f, -0.15463687f, -0.29762274f, -0.11898285f, -0.07817506f, 0.22750968f, 0.11929066f, 0.05258996f, 
    -0.03311243f, 0.05898285f, -0.01446019f, 0.04422325f, 0.18281770f, -0.13164833f, -0.20390244f, 0.06543498f, 
    -0.05719930f, -0.11995898f, -0.06283858f, 0.00219390f, 0.10424905f, 0.11422451f, 0.03829109f, -0.00655221f, 
    -0.28020015f, 0.02152170f, -0.13144951f, 0.17254494f, 0.04875597f, -0.05927685f, 0.03770011f, 0.03211616f, 
    0.21969603f, -0.05765390f, 0.02806542f, 0.04924457f, -0.10365753f, -0.01607785f, 0.16500360f, -0.10714757f, 
    0.01748397f, 0.01784454f, 0.14047194f, -0.07834307f, 0.07149934f, -0.03121714f, -0.04945223f, 0.14197516f, 
    0.08235863f, -0.31909323f, -0.34908953f, 0.21919423f, -0.03975353f, 0.11105981f, 0.04390996f, -0.04964810f, 
    0.01508294f, -0.01611366f, -0.06849334f, 0.06268644f, -0.20794049f, 0.44291842f, 0.06799649f, 0.08685902f, 
    0.01555101f, 0.20782115f, 0.07082047f, 0.00184162f, 0.00626930f, 0.03785947f, 0.05899920f, -0.05816426f, 
    -0.00758381f, -0.05320326f, 0.03739711f, -0.04098379f, 0.01779462f, -0.02960921f, 0.00631727f, 0.01058235f, 
    -0.02629714f, -0.03451226f, 0.02416516f, -0.03686281f, -0.03658722f, 0.00456200f, -0.00946210f, -0.03457214f, 
    0.00094949f, -0.00368505f, -0.05745008f, -0.05380569f, -0.03949288f, 0.02422846f, 0.01765331f, 0.00352648f, 
    -0.03338813f, -0.03536965f, -0.04853261f, 0.03181438f, 0.02473076f, -0.04522714f, 0.01328555f, 0.01644046f, 
    0.00934581f, -0.05303933f, -0.01148149f, 0.04248482f, -0.04989183f, -0.05074139f, -0.02075444f, 0.03496695f, 
    0.02219783f, -0.04973303f, -0.00664074f, 0.02223618f, 0.00413591f, 0.01071988f, -0.05051925f, 0.04410168f, 
    -0.03516655f, -0.05020874f, 0.00248506f, 0.00052515f, -0.03190467f, -0.01403445f, 0.00516097f, -0.03242484f, 
    0.03974979f, 0.01651529f, -0.02147701f, 0.01445955f, -0.01764120f, 0.04060909f, -0.02204490f, -0.02758633f, 
    -0.04920854f, 0.03962037f, -0.02932416f, -0.02801049f, -0.01494325f, -0.00709257f, -0.04113537f, -0.00280702f, 
    -0.02190318f, 0.00040215f, -0.02543430f, -0.01878282f, 0.03933372f, -0.01293993f, -0.00902981f, 0.01578218f, 
    0.00036421f, 0.00713798f, 0.01382331f, -0.00891098f, -0.03620366f, 0.01983517f, -0.01946880f, 0.03143836f, 
    0.03758216f, -0.00832207f, -0.04747441f, -0.00409786f, 0.03491011f, -0.05338060f, 0.01302922f, -0.03137838f, 
    -0.01781712f, -0.01679802f, 0.02157385f, -0.01588702f, -0.00582942f, 0.02644111f, 0.02672773f, -0.02641145f, 
    -0.00920959f, -0.03200885f, 0.01021475f, 0.04852401f, -0.03441277f, -0.02859182f, -0.03542303f, -0.04041742f, 
    -0.01378932f, -0.02046792f, 0.02220878f, 0.01273652f, 0.02868445f, 0.00993154f, -0.02827166f, 0.02869894f, 
    -0.01652294f, 0.02023931f, -0.04370533f, -0.00636425f, -0.04624427f, -0.02507123f, 0.02601255f, -0.00156792f, 
    -0.03546195f, 0.02928432f, -0.04440803f, 0.04250225f, 0.00775726f, 0.03097676f, 0.00772795f, -0.02177886f, 
    -0.00264263f, 0.03381975f, -0.02519362f, 0.01973441f, 0.01373179f, 0.04098142f, -0.02587700f, 0.02515108f, 
    -0.01201097f, -0.04853807f, 0.03268733f, -0.04050418f, 0.01290345f, -0.00890351f, 0.00802037f, -0.03114148f, 
    -0.05269982f, 0.02383450f, -0.02945515f, -0.04824166f, -0.02127446f, -0.04142358f, 0.01872833f, -0.03953734f, 
    -0.05648399f, 0.00079596f, -0.02314400f, -0.02289636f, 0.01110028f, 0.00332784f, -0.00425151f, -0.01137234f, 
    0.03434884f, -0.02163848f, -0.00879840f, -0.02247527f, -0.00927903f, 0.00438097f, -0.00926085f, 0.01604466f, 
    -0.03750665f, -0.01111914f, 0.00641323f, -0.00203933f, 0.01517731f, 0.02758561f, 0.03412288f, -0.04124510f, 
    0.00072669f, 0.02947054f, 0.04151984f, 0.00779795f, 0.00266241f, -0.03352828f, -0.00207749f, -0.04779416f, 
    0.02260551f, -0.04110021f, -0.04094946f, -0.02014451f, 0.02787756f, 0.03321449f, -0.02370371f, -0.03878798f, 
    -0.00228176f, 0.01200951f, -0.03624191f, -0.01698907f, -0.03818725f, -0.01676073f, 0.01264085f, 0.04253498f, 
    0.01585683f, -0.02555828f, -0.03076388f, 0.00066715f, -0.02511788f, -0.02434878f, -0.00587085f, -0.01812744f, 
    0.03136233f, 0.04125020f, -0.00023407f, -0.04338241f, 0.00640304f, 0.01063660f, 0.00716753f, 0.00876505f, 
    0.02937409f, -0.03312547f, -0.00728478f, 0.03843453f, -0.03898112f, 0.00535943f, 0.02050746f, -0.02890383f, 
    -0.02670925f, 0.03981324f, -0.00983157f, -0.01084824f, 0.03458622f, 0.01713606f, 0.01663660f, 0.02192240f, 
    0.01514588f, 0.02866035f, -0.02849809f, -0.00488978f, -0.05035512f, -0.01190000f, -0.04329150f, -0.01313325f, 
    0.03719958f, 0.00056690f, 0.03076580f, 0.01641659f, -0.04708873f, -0.04841297f, 0.00577691f, -0.03487729f, 
    -0.00608020f, -0.02123002f, -0.05684404f, -0.01434768f, 0.00826400f, 0.00165174f, 0.00638577f, -0.04075230f, 
    0.02760374f, 0.01834855f, -0.02716021f, 0.02824738f, 0.02991666f, -0.01947356f, 0.01361487f, 0.02589800f, 
    -0.00997897f, -0.04645466f, -0.03790914f, -0.03165979f, -0.01025723f, -0.01902574f, 0.02655902f, 0.01887691f, 
    -0.03262698f, 0.03116916f, 0.01771595f, -0.04428328f, -0.04254467f, 0.04300605f, 0.02343143f, 0.00390295f, 
    -0.04952795f, 0.00486366f, -0.00535273f, -0.01633012f, 0.03038097f, 0.00277431f, -0.01267862f, -0.02375697f, 
    -0.01293234f, -0.03407910f, 0.01603250f, 0.03547281f, -0.00086188f, 0.01336691f, -0.03733492f, 0.02669366f, 
    -0.03021719f, -0.03919854f, 0.00030028f, 0.00008546f, 0.00873204f, -0.04350021f, -0.00846862f, -0.03592605f, 
    -0.03252880f, 0.03751368f, -0.02865665f, -0.04095163f, -0.00251364f, 0.01570415f, -0.03039866f, 0.01952620f, 
    -0.03981699f, -0.00126820f, 0.00925596f, 0.04638667f, 0.04170437f, -0.01848853f, 0.02955831f, -0.00126739f, 
    0.01554695f, -0.05193831f, -0.04793873f, -0.02199360f, -0.00748729f, -0.04141843f, 0.03229824f, -0.01758279f, 
    -0.04123347f, -0.01607573f, -0.00683011f, -0.02440231f, 0.00100974f, -0.02821685f, -0.00779475f, 0.02705861f, 
    0.02960846f, 0.02442979f, 0.00329860f, -0.01417896f, -0.03857579f, 0.04072202f, -0.03249873f, 0.00754691f, 
    0.03304054f, 0.00453049f, -0.06193642f, 0.01863206f, -0.03593471f, -0.04647261f, 0.03591391f, -0.00715264f, 
    -0.02111400f, -0.03842192f, -0.00611897f, -0.01584102f, -0.03780593f, -0.05470929f, -0.04398699f, 0.00502546f, 
    0.02018630f, -0.01409499f, 0.01195796f, -0.03914923f, 0.01921735f, 0.02155355f, -0.05229293f, -0.04776008f, 
    -0.02136659f, -0.05450965f, -0.03087557f, 0.01898657f, 0.02331840f, 0.03110284f, 0.02921029f, 0.04271616f, 
    0.08222786f, 0.10192396f, -0.02091338f, -0.00504032f, 0.13352507f, -0.12392745f, 0.02980688f, 0.10069448f, 
    0.08465245f, 0.04811522f, 0.00263668f, -0.03916334f, 0.11758781f, 0.07563091f, 0.06724343f, 0.07754790f, 
    -0.06313677f, -0.00379549f, 0.02007305f, 0.08246918f, 0.07808360f, -0.11608197f, -0.12942520f, -0.19919254f, 
    0.16852760f, 0.02337725f, 0.17157814f, -0.00696769f, -0.09044833f, 0.14939073f, 0.08199307f, 0.04755043f, 
    -0.15804866f, -0.03053071f, 0.13484631f, 0.05296680f, 0.34413666f, -0.10224795f, 0.38669026f, 0.16200225f, 
    -0.18748292f, 0.00748637f, -0.03322891f, 0.13247694f, 0.05909463f, 0.07537315f, -0.10837725f, 0.07405800f, 
    -0.09928122f, -0.12189493f, -0.07846716f, -0.01950232f, -0.02210806f, 0.04488674f, 0.02395767f, 0.00086655f, 
    -0.01986324f, -0.02221217f, 0.11410005f, 0.00369529f, 0.32742235f, -0.14269419f, -0.33012193f, 0.03371404f, 
    0.25299114f, 0.07955428f, 0.14874528f, -0.15065317f, 0.03831695f, 0.00642736f, -0.02560559f, -0.02098699f, 
    -0.04377558f, 0.08547834f, -0.20857565f, 0.15149957f, 0.13406648f, 0.07496159f, 0.02829397f, -0.02732157f, 
    -0.13552409f, -0.02320449f, -0.00425744f, 0.01591205f, 0.21634655f, 0.12420752f, -0.06560236f, -0.10121180f, 
    0.24816844f, 0.04917818f, -0.10608243f, -0.07805605f, 0.11717688f, 0.21394095f, 0.10128637f, -0.03257027f, 
    0.03839975f, 0.34388337f, -0.17815110f, 0.07190932f, 0.21661581f, -0.13817351f, 0.09296463f, 0.03988139f, 
    0.03092186f, 0.00774291f, 0.05267534f, 0.06829028f, 0.18813054f, -0.19930311f, 0.37062341f, -0.17985617f, 
    -0.10698618f, -0.04019009f, 0.07476354f, -0.11593195f, -0.00433306f, -0.12617728f, 0.04658784f, 0.01981464f, 
    -0.03534495f, -0.12429362f, -0.01338160f, -0.11717460f, 0.03958904f, -0.16761899f, -0.09274722f, -0.04940765f, 
    -0.08623810f, -0.09120124f, 0.10996871f, -0.19944432f, 0.24286970f, 0.06540750f, -0.13866748f, 0.05328199f, 
    0.05477467f, -0.14907365f, -0.06632490f, -0.02551556f, -0.04338272f, 0.00788190f, 0.13182360f, -0.01366335f, 
    0.05835167f, 0.05078991f, -0.27818340f, -0.12099644f, 0.14612694f, -0.03188565f, -0.05667014f, -0.13700828f, 
    0.02553534f, 0.06194947f, -0.00459652f, -0.08060268f, -0.08751183f, 0.11171678f, -0.09262825f, -0.22512291f, 
    0.07341409f, -0.04508051f, 0.01414449f, -0.02719812f, 0.08002882f, 0.11025773f, -0.03233716f, -0.11684792f, 
    0.36989728f, -0.07969949f, -0.14290403f, 0.06327035f, -0.04091027f, -0.05035670f, 0.13531832f, -0.03227890f, 
    0.06551348f, 0.05189512f, 0.04184180f, 0.14491834f, 0.00887718f, -0.12707479f, 0.20756418f, 0.21204904f, 
    -0.15081920f, -0.01682344f, 0.01690423f, -0.03775691f, 0.13747299f, 0.11968734f, 0.03004049f, -0.09859075f, 
    0.12654532f, 0.04831352f, 0.17039947f, 0.03619390f, -0.11131100f, -0.01613699f, 0.03788015f, 0.16499555f, 
    -0.00125520f, 0.12923835f, -0.14629614f, -0.06445809f, 0.09094435f, -0.18514805f, -0.11614881f, -0.21164413f, 
    0.10690081f, -0.05872732f, -0.05629703f, -0.07414083f, -0.07918106f, 0.10075295f, -0.02928162f, -0.18448727f, 
    0.14542408f, 0.07657916f, 0.14321363f, 0.01723681f, -0.13609093f, 0.05441238f, -0.06244229f, 0.10773306f, 
    0.05706266f, -0.05411147f, 0.06492954f, -0.05115719f, -0.32828632f, -0.35549048f, -0.16211410f, -0.18419671f, 
    0.12593269f, -0.04448448f, 0.07782549f, -0.07879011f, 0.06191935f, 0.08915173f, 0.01366679f, -0.06167652f, 
    0.26787493f, 0.18935131f, -0.11810391f, -0.14473316f, 0.15300564f, -0.00017621f, -0.12205571f, 0.06671332f, 
    0.14566642f, 0.11854793f, 0.08117788f, -0.04268353f, 0.29434812f, -0.05413329f, 0.03702357f, 0.00084348f, 
    -0.04826858f, 0.03004561f, -0.04411946f, -0.03754476f, -0.02069687f, 0.02624691f, 0.06235283f, 0.14301570f, 
    -0.31708947f, 0.10238659f, 0.18366121f, -0.16204926f, 0.07825696f, -0.05633442f, -0.08077294f, 0.00321552f, 
    0.01582964f, 0.00737734f, -0.02946248f, -0.08714876f, 0.21848418f, -0.04158659f, -0.01879329f, 0.24843383f, 
    0.23968942f, 0.13036366f, -0.08374226f, -0.11871617f, -0.05058219f, 0.07277674f, 0.14537749f, 0.05067535f, 
    0.33419743f, -0.19538406f, 0.24285468f, -0.10177741f, 0.01156612f, -0.03940431f, -0.23031653f, -0.12139577f, 
    -0.06535044f, 0.16321574f, 0.03537323f, 0.03046723f, -0.07720020f, -0.00163369f, 0.09444673f, -0.07168384f, 
    -0.02008987f, 0.15994854f, -0.15250158f, 0.03233407f, -0.01329663f, -0.07323364f, -0.07771472f, 0.00548218f, 
    0.01001769f, -0.05667561f, -0.14861564f, 0.07085795f, -0.08824982f, 0.04391831f, -0.18158185f, 0.06952336f, 
    -0.11006014f, 0.04951518f, 0.09957465f, 0.10527112f, 0.53589773f, 0.30005038f, -0.00707940f, 0.22477914f, 
    -0.01191602f, -0.12621638f, 0.00381549f, -0.10120417f, 0.02799870f, 0.14503160f, -0.01654216f, -0.04413937f, 
    -0.29269409f, -0.06600332f, 0.16972488f, -0.01433251f, 0.01031312f, -0.19786076f, 0.13200703f, -0.03389102f, 
    0.11484367f, -0.06127237f, 0.06115810f, -0.00500635f, 0.27499840f, 0.21349277f, -0.22022766f, -0.07369978f, 
    0.18632531f, 0.00148896f, 0.11726800f, -0.03155006f, -0.02402386f, 0.10306799f, 0.11517574f, 0.08722177f, 
    0.45076868f, -0.07531745f, -0.11133438f, 0.03366907f, 0.02082272f, 0.08396431f, 0.06265916f, 0.01679803f, 
    0.15103990f, 0.00702658f, -0.07144184f, -0.03284794f, 0.37244505f, 0.19352156f, -0.34701118f, -0.03379848f, 
    0.14087306f, 0.03825989f, 0.05632367f, 0.01260433f, 0.07408859f, 0.09729973f, 0.07022730f, -0.08770035f, 
    -0.27338067f, 0.19279145f, -0.01227228f, 0.37807697f, -0.17059958f, -0.06455459f, 0.16800591f, 0.11682790f, 
    0.02215341f, -0.16722435f, -0.10284464f, -0.02488886f, -0.18991481f, 0.01990185f, -0.00997662f, -0.02195177f, 
    -0.07860517f, 0.08302764f, 0.12274862f, 0.09941009f, 0.02742382f, 0.19918992f, 0.05438861f, 0.17970277f, 
    -0.14001285f, -0.08465188f, 0.10101575f, -0.09697217f, -0.14784120f, 0.02018841f, 0.02418809f, 0.07517233f, 
    0.00643178f, -0.08023079f, -0.04405200f, -0.14553787f, 0.07326970f, -0.37010473f, 0.11185021f, 0.00564357f, 
    -0.09860013f, 0.02491449f, 0.16957486f, 0.05231270f, 0.00008419f, 0.06109831f, 0.02036236f, 0.04022086f, 
    0.02738120f, 0.06804737f, 0.11266388f, 0.09393609f, -0.11889879f, -0.12186330f, -0.10447268f, -0.06116931f, 
    -0.08454315f, 0.30258361f, -0.11205111f, 0.04575876f, 0.03475159f, -0.07794266f, -0.29122052f, -0.18039873f, 
    0.17532912f, -0.03872306f, -0.08263564f, -0.01326956f, -0.09596147f, -0.02707800f, 0.00882077f, -0.16429704f, 
    -0.06673305f, 0.12307115f, -0.06744450f, -0.26406401f, 0.25220278f, 0.24540448f, -0.04005603f, 0.03897328f, 
    -0.04209831f, -0.18193497f, 0.03015192f, -0.28362468f, 0.26190487f, 0.04022245f, -0.04737607f, -0.09070892f, 
    -0.02196209f, 0.15936805f, -0.10882224f, 0.10613095f, 0.11080855f, 0.18924162f, 0.11777127f, 0.06005455f, 
    -0.29488948f, -0.05493473f, 0.02316340f, 0.27934062f, 0.04182699f, 0.24905518f, -0.02010917f, 0.01329184f, 
    0.11742853f, 0.02100909f, 0.06797801f, 0.06278151f, 0.06276331f, -0.15158530f, 0.14694670f, -0.23727863f, 
    0.01639037f, -0.00512117f, 0.03228709f, 0.05925147f, 0.13048497f, -0.03105242f, 0.05773075f, -0.08594846f, 
    -0.01517627f, -0.27801642f, 0.05304603f, -0.21945231f, -0.08647387f, 0.09579155f, 0.26738375f, 0.10783248f, 
    0.03761815f, -0.16169034f, 0.05669605f, 0.13431250f, 0.07288155f, -0.17620461f, -0.20491019f, 0.17908517f, 
    -0.02908104f, -0.06908466f, 0.26688629f, -0.07850569f, 0.03828826f, -0.04419800f, -0.07952949f, 0.05605758f, 
    0.02311897f, 0.17226289f, -0.11883670f, -0.30940416f, 0.20317107f, -0.06521786f, -0.05279094f, -0.06978130f, 
    0.10417661f, 0.12092748f, 0.12136389f, 0.09743769f, 0.18021299f, 0.14512202f, -0.11526742f, 0.12306169f, 
    0.11910959f, -0.00643272f, -0.06119311f, -0.01855584f, 0.03315384f, -0.27635896f, -0.13012725f, -0.10507638f, 
    0.24198550f, -0.17793621f, 0.25348464f, 0.12037756f, 0.06915490f, 0.01176491f, -0.10231175f, 0.03362289f, 
    0.13290517f, 0.11349972f, 0.22437355f, 0.20587260f, 0.13401532f, -0.10096606f, 0.12974811f, -0.45046291f, 
    0.01973960f, 0.01328962f, 0.01334332f, -0.09043133f, 0.17343277f, 0.05481212f, 0.17069234f, 0.05085989f, 
    -0.14692529f, -0.24854159f, -0.01762781f, -0.01175915f, -0.18387538f, -0.12815280f, 0.17499343f, 0.13985480f, 
    -0.10851729f, -0.04215387f, 0.22294620f, 0.03666280f, -0.21755701f, -0.00908062f, -0.03171331f, -0.21610962f, 
    0.17560226f, -0.04034764f, 0.02372721f, 0.15892351f, 0.03836685f, 0.16977027f, 0.02423770f, 0.07780383f, 
    -0.01760142f, -0.05847969f, 0.08372845f, 0.17745483f, -0.04776210f, -0.05615572f, 0.14032243f, 0.00548804f, 
    0.07116059f, 0.01966752f, -0.09597226f, 0.01133321f, -0.06059933f, 0.29320136f, -0.14210284f, -0.05847703f, 
    0.17708813f, 0.20947604f, -0.12421112f, 0.01722337f, -0.01236910f, -0.03386050f, 0.22589506f, -0.02464491f, 
    0.30060583f, 0.04283801f, -0.18596347f, 0.29571751f, 0.19458038f, 0.06282289f, -0.08618157f, 0.13415211f, 
    0.08483925f, -0.16565213f, -0.10156567f, -0.00241378f, 0.43755478f, 0.17461082f, 0.06838118f, -0.00674525f, 
    0.12693182f, 0.01142010f, 0.06645770f, 0.05027006f, 0.13801388f, 0.01564892f, 0.08891597f, -0.10702032f, 
    0.54177040f, -0.06313816f, -0.25440302f, 0.14840569f, -0.11067653f, -0.10698847f, -0.08604420f, -0.20521906f, 
    -0.12282808f, -0.01542782f, -0.17778806f, 0.09814526f, -0.16132490f, 0.04904707f, -0.14357677f, 0.09693691f, 
    0.22110149f, 0.07575389f, -0.02521943f, -0.03947116f, 0.23072259f, 0.02778576f, -0.08107767f, 0.03805453f, 
    -0.38047966f, -0.24859045f, -0.00367869f, -0.21850345f, 0.11387395f, -0.05784635f, -0.03533909f, 0.14751160f, 
    0.09978577f, -0.09162871f, 0.07023206f, 0.13929366f, -0.07525320f, -0.02028108f, -0.05201191f, 0.44858205f, 
    -0.04836828f, -0.15225901f, 0.21511079f, -0.10265515f, 0.01973685f, -0.12882659f, -0.02840339f, -0.12166744f, 
    0.19284426f, 0.16890578f, 0.30574322f, 0.27460620f, -0.10861482f, -0.08163673f, 0.03950607f, -0.05434467f, 
    -0.24120091f, 0.02927452f, 0.07201667f, 0.04287627f, -0.11985733f, 0.13364913f, 0.12589848f, 0.08897744f, 
    -0.07213598f, 0.04052134f, 0.03454794f, -0.14403142f, -0.11890737f, -0.10648900f, 0.20528041f, 0.17286617f, 
    0.42853248f, 0.11976831f, 0.30424827f, -0.19793919f, -0.06827663f, 0.00072330f, -0.10319865f, 0.00591615f, 
    -0.01153893f, 0.15524998f, 0.10939785f, 0.14947827f, -0.21206610f, -0.02260286f, -0.15250611f, 0.20575836f, 
    0.12718470f, 0.15035561f, -0.19265576f, -0.02135896f, -0.03897194f, 0.17710723f, -0.10485820f, -0.04261157f, 
    -0.00555825f, 0.39363107f, 0.14583108f, -0.09514793f, 0.12325203f, 0.08036320f, 0.10059395f, -0.08419551f, 
    -0.01798439f, -0.01820128f, 0.08896760f, 0.15720986f, 0.44775283f, 0.16296627f, 0.17169282f, 0.02742653f, 
    0.13548985f, -0.03504919f, -0.04583967f, 0.06648790f, 0.11119957f, -0.03927380f, -0.12351572f, 0.02844232f, 
    -0.04605578f, -0.05612440f, 0.03290874f, 0.01592561f, -0.03403280f, 0.04330311f, -0.05338284f, -0.03650038f, 
    0.01098768f, -0.04563216f, -0.02351196f, -0.00160375f, 0.03571940f, -0.02263737f, -0.04210515f, -0.05272089f, 
    -0.00406536f, -0.01797071f, 0.02802832f, 0.04131731f, -0.02773534f, 0.04374065f, 0.02249940f, 0.00156189f, 
    -0.01238787f, 0.01115036f, 0.01409913f, -0.04453218f, 0.04014883f, 0.03208907f, 0.00033793f, -0.02593307f, 
    -0.02148117f, 0.02657310f, -0.01205140f, -0.03650907f, -0.05138350f, -0.02478258f, 0.03208515f, 0.02139700f, 
    0.00317002f, -0.00488079f, -0.00662541f, -0.04347822f, 0.01484787f, 0.03377277f, 0.03624443f, -0.04219337f, 
    0.04398282f, -0.03560239f, -0.00026833f, 0.00028177f, -0.01727852f, -0.01450903f, -0.02829688f, 0.04194740f, 
    0.02134930f, 0.01625653f, -0.02367492f, 0.00952394f, -0.03017760f, -0.01163559f, -0.03747674f, -0.01501208f, 
    -0.03222139f, -0.00440143f, -0.00093258f, 0.01146234f, -0.02966212f, -0.03888375f, 0.02028721f, -0.03763565f, 
    0.03111514f, 0.03255207f, -0.05292299f, -0.03513488f, -0.05192766f, -0.00696570f, 0.03567130f, 0.02598138f, 
    -0.01609654f, -0.01449162f, -0.02795383f, -0.02211118f, -0.01167185f, 0.03464382f, 0.01371040f, -0.00147567f, 
    -0.05601601f, 0.01338699f, 0.02927836f, 0.04194622f, -0.01632695f, -0.02295882f, -0.02930861f, -0.02417438f, 
    -0.02594722f, 0.00193186f, -0.01965339f, -0.05466461f, 0.00443573f, -0.00382493f, 0.01746025f, -0.02794706f, 
    -0.00255353f, 0.01631393f, 0.00534945f, -0.02185071f, 0.01464633f, 0.01835333f, -0.03734158f, -0.01025049f, 
    -0.03812088f, -0.01051703f, -0.00698771f, -0.04032031f, 0.01585395f, -0.03937842f, -0.05073223f, -0.03546945f, 
    0.04140556f, 0.00220226f, 0.03062964f, -0.02022339f, 0.02081434f, -0.02799758f, -0.02652292f, -0.00275940f, 
    -0.03218737f, -0.01452713f, 0.01030392f, 0.03084492f, 0.02998751f, 0.03518214f, -0.01870286f, -0.03680929f, 
    0.04089932f, 0.01963053f, 0.03213895f, -0.03515572f, -0.00952956f, 0.01659861f, -0.03932168f, -0.02479363f, 
    0.02554585f, -0.02068722f, 0.00420210f, 0.01438091f, -0.01077729f, 0.03154134f, -0.04829927f, -0.00347012f, 
    0.02820610f, -0.03763970f, -0.02339491f, -0.03703560f, 0.01628580f, 0.00199173f, -0.04725469f, -0.05394480f, 
    0.02364881f, 0.01963962f, -0.04323821f, 0.03731947f, -0.03087460f, -0.01739111f, -0.01589924f, 0.00031022f, 
    -0.05085178f, 0.01247345f, -0.02628201f, -0.05554682f, -0.05615681f, -0.03070701f, -0.03372599f, -0.00882071f, 
    -0.04017695f, -0.00845577f, -0.04457994f, -0.05066470f, -0.01149018f, -0.04763753f, 0.03809623f, 0.01087608f, 
    -0.04081350f, 0.00296925f, 0.02979409f, -0.03931577f, 0.01474328f, -0.01920097f, -0.01441506f, -0.04467007f, 
    -0.03454876f, -0.03647723f, -0.00409745f, 0.01703218f, 0.02391885f, -0.02844342f, -0.02785253f, 0.03258434f, 
    0.00362128f, -0.02997155f, 0.02281271f, -0.00651820f, -0.04826587f, -0.05449416f, 0.03914236f, -0.05664396f, 
    0.00794671f, -0.04836472f, -0.05358978f, -0.02138018f, -0.05307445f, -0.04323125f, 0.04006499f, -0.03665699f, 
    0.03966637f, -0.02448624f, -0.02785477f, 0.01356895f, 0.00574869f, -0.00228915f, -0.02967403f, -0.01569065f, 
    -0.04299214f, 0.03180079f, -0.00267678f, -0.02660739f, -0.01269557f, 0.03913306f, -0.04113097f, 0.00198324f, 
    -0.01522038f, -0.01607283f, -0.03302713f, 0.03762327f, 0.03372504f, -0.00183776f, -0.02947413f, -0.00006517f, 
    -0.03980314f, 0.01919146f, 0.00626189f, -0.05287527f, 0.02157027f, 0.00145352f, -0.03464857f, 0.02506458f, 
    -0.00399978f, -0.03100853f, 0.03829867f, -0.00863813f, -0.01966619f, 0.02614898f, 0.02711683f, -0.01245465f, 
    0.01376366f, -0.04162972f, 0.03099413f, 0.04107653f, -0.01122818f, -0.00427737f, -0.04109364f, 0.00961004f, 
    0.02444268f, -0.04227886f, -0.02743210f, -0.03760242f, -0.04354792f, -0.00554591f, 0.03762539f, 0.03723809f, 
    -0.05017388f, -0.03060650f, 0.01385773f, 0.04979850f, -0.04105017f, -0.02819451f, 0.02583873f, -0.01027251f, 
    -0.05502960f, 0.02835863f, -0.01125911f, -0.01186158f, -0.04944196f, -0.03168092f, -0.01848079f, -0.02841841f, 
    0.00503498f, -0.02459405f, -0.03670114f, -0.04015584f, 0.02801512f, -0.04448789f, 0.03840354f, -0.02004704f, 
    -0.03535438f, -0.00257846f, 0.03221057f, -0.02067744f, 0.01093610f, -0.02579889f, 0.02555143f, 0.02172851f, 
    0.03318666f, -0.04225860f, -0.03892429f, 0.03973789f, 0.03766915f, -0.04565459f, 0.02155037f, -0.00419712f, 
    -0.01525277f, 0.01658487f, 0.03368531f, 0.03003895f, -0.05368572f, -0.00294232f, -0.02370415f, 0.03160641f, 
    0.00010095f, -0.05611770f, 0.00613733f, 0.03603580f, -0.02689844f, 0.00591727f, -0.01823098f, -0.00251512f, 
    0.03004028f, 0.02656302f, 0.03855009f, -0.00959763f, 0.05057859f, 0.02388212f, 0.04177733f, 0.03734137f, 
    -0.00481173f, 0.01724719f, -0.00008941f, 0.03725039f, -0.01246749f, -0.00527141f, -0.01314592f, -0.01526691f, 
    0.04369130f, 0.00222009f, -0.02876426f, -0.00386670f, 0.00679056f, -0.02965380f, -0.05117867f, 0.01533030f, 
    -0.00778463f, -0.00174965f, -0.03079560f, -0.02863512f, -0.02065680f, 0.01677619f, -0.00541331f, -0.02257524f, 
    -0.00871937f, -0.01473850f, 0.02361216f, -0.04177293f, -0.03762794f, -0.04343952f, -0.02778626f, -0.03639046f, 
    -0.00497128f, 0.00069321f, -0.04854318f, -0.01897100f, -0.05312185f, 0.04347820f, -0.03873819f, -0.02737382f, 
    -0.04100241f, -0.04825652f, -0.01054185f, -0.03894324f, 0.02587854f, -0.03216414f, -0.04106891f, -0.04599229f, 
    -0.00495912f, -0.04797364f, 0.02779016f, -0.02079690f, -0.00140020f, -0.03507664f, 0.02046314f, -0.01577177f, 
    -0.01765192f, -0.03452922f, 0.00139865f, 0.03319345f, -0.01721642f, 0.02717170f, -0.00789859f, -0.04776046f, 
    -0.03515598f, -0.00117854f, 0.03916028f, 0.01041739f, 0.00469103f, -0.00986217f, 0.01654811f, 0.01318184f, 
    -0.02364635f, 0.00185195f, 0.01433508f, -0.01044584f, 0.00669110f, 0.04467988f, -0.00258451f, -0.01659738f, 
    -0.02587654f, -0.04030802f, 0.03001263f, -0.02827911f, 0.00064384f, -0.03659113f, 0.00696241f, -0.02518483f, 
    -0.04350049f, 0.01305975f, -0.02791005f, -0.05001046f, -0.01396129f, -0.03661718f, -0.01693984f, -0.04018656f, 
    0.01505240f, 0.02438189f, -0.00331612f, -0.02198275f, -0.02690329f, -0.05684437f, -0.04869546f, -0.00447595f, 
    -0.01539324f, 0.02792394f, -0.01365250f, 0.02249146f, 0.02213972f, -0.03928734f, -0.05656727f, 0.03209781f, 
    0.03628340f, -0.04909135f, 0.03011631f, 0.01845156f, -0.04306464f, 0.00939688f, 0.00723036f, -0.01370812f, 
    -0.00755746f, -0.05614018f, -0.01323351f, -0.00880673f, 0.02092776f, -0.03362838f, -0.05512143f, -0.05027778f, 
    0.03615039f, -0.02087373f, 0.01597363f, -0.03278570f, -0.00286583f, -0.00802619f, -0.00590967f, -0.01529435f, 
    0.02104103f, 0.00541194f, -0.05078765f, 0.00317286f, 0.03221259f, -0.03210557f, 0.02805485f, -0.05206090f, 
    -0.00183913f, -0.01848228f, 0.03242560f, 0.02685108f, -0.05260151f, -0.04921778f, -0.02468154f, -0.01704002f, 
    -0.01297739f, -0.05341161f, 0.03522016f, 0.02420547f, 0.01636141f, 0.00494031f, -0.03937368f, -0.01420857f, 
    0.00072031f, 0.01372482f, 0.04734930f, -0.04626486f, 0.00871971f, 0.00448244f, -0.03754963f, 0.00417976f, 
    0.03128181f, -0.02679524f, -0.04523363f, 0.03971745f, 0.03419894f, 0.03423933f, 0.04358667f, -0.01580589f, 
    -0.00665219f, 0.04229236f, 0.01665567f, 0.01474316f, 0.01870678f, -0.02635877f, -0.02637154f, 0.02109153f, 
    -0.03859284f, -0.04333218f, -0.01459446f, -0.03462585f, -0.03727685f, -0.01720573f, -0.05086608f, 0.01639218f, 
    -0.00314891f, -0.00290991f, -0.01244215f, -0.04988544f, 0.01619445f, -0.04729732f, 0.04930260f, -0.03854351f, 
    -0.03782470f, -0.04995897f, -0.04638996f, -0.01678861f, 0.01643237f, 0.02366889f, -0.05064336f, -0.00824803f, 
    -0.04344732f, -0.00705055f, -0.01602302f, 0.02710701f, -0.01180788f, 0.00708848f, 0.00358331f, 0.02595559f, 
    0.02062447f, 0.00033760f, -0.02806361f, -0.00335537f, -0.03366851f, -0.00152987f, -0.02515353f, 0.03623453f, 
    0.04749253f, -0.00709796f, 0.04433072f, 0.00473410f, 0.03185956f, 0.04381374f, 0.03467027f, 0.03920189f, 
    -0.00255046f, -0.04893752f, -0.03899128f, 0.04227114f, 0.03785028f, -0.04987241f, 0.00681411f, -0.01340570f, 
    0.00707707f, -0.01315532f, -0.01638841f, 0.02745551f, 0.03450086f, -0.02312294f, -0.04649819f, 0.02066618f, 
    -0.00058704f, 0.00808041f, 0.01648699f, -0.01629075f, 0.03635547f, -0.00988833f, -0.02814140f, -0.03700005f, 
    -0.00197514f, -0.05353916f, -0.04651396f, 0.01928832f, -0.01318189f, -0.01630857f, -0.03975160f, -0.04599246f, 
    -0.01001625f, 0.00356460f, -0.01483311f, -0.04728439f, -0.04739158f, -0.02334020f, -0.01635453f, 0.01916902f, 
    0.01832649f, -0.00556931f, -0.04633869f, -0.04942660f, 0.03328403f, -0.01797600f, 0.01132862f, -0.05628686f, 
    0.02592928f, 0.04224049f, -0.00629034f, -0.02831822f, 0.00583465f, -0.02754180f, 0.00449634f, -0.04364251f, 
    -0.02696573f, 0.03052404f, -0.05305932f, 0.00736432f, 0.03478257f, -0.03111761f, 0.02325541f, 0.02620589f, 
    -0.03208914f, -0.03438440f, 0.03964146f, -0.03646701f, 0.00117240f, -0.03941716f, -0.03525614f, -0.03265725f, 
    0.00949118f, -0.00091404f, 0.00971827f, -0.03707402f, -0.02548321f, -0.03040294f, 0.02189808f, -0.01810383f, 
    -0.01011911f, -0.04749160f, -0.04728218f, -0.00932502f, -0.01312276f, -0.02858258f, -0.02287744f, 0.04471229f, 
    -0.02109149f, -0.00947499f, -0.03565789f, -0.02503296f, 0.03112851f, 0.03315390f, -0.03974291f, -0.01389263f, 
    0.00745308f, -0.01500103f, -0.05128636f, -0.04140325f, 0.02801518f, -0.01982680f, -0.00675411f, -0.03399780f, 
    -0.00404057f, -0.01698767f, -0.00726679f, 0.01031457f, -0.00506937f, 0.00579716f, -0.03764556f, -0.05614139f, 
    0.02101136f, 0.04156538f, -0.03542034f, 0.02282299f, 0.00091120f, -0.04497811f, 0.00008277f, -0.01826809f, 
    -0.05031404f, 0.00325903f, -0.02315693f, -0.01475111f, -0.05553127f, 0.00520057f, 0.03303445f, 0.03206919f, 
    0.03466345f, 0.03212726f, 0.00887742f, -0.05273488f, 0.01543927f, -0.04255521f, 0.01431049f, 0.00888581f, 
    0.00522213f, 0.02502823f, 0.03744499f, 0.00738948f, 0.01432155f, -0.02166743f, -0.03241842f, -0.03471960f, 
    -0.02525684f, 0.01610062f, 0.01242276f, -0.01841015f, -0.02010720f, 0.01509837f, -0.00674004f, 0.02864434f, 
    -0.05031502f, -0.05256273f, -0.05172537f, 0.02473582f, -0.04157007f, 0.03474338f, -0.02743981f, 0.03780147f, 
    -0.01117099f, 0.00166995f, -0.00006169f, 0.01697513f, -0.05402479f, -0.01058980f, 0.00698397f, 0.00759553f, 
    0.04034708f, -0.00404050f, 0.01724515f, -0.03423956f, 0.00160968f, -0.00693622f, -0.05011135f, -0.01941311f, 
    -0.02125202f, -0.02112853f, 0.01631489f, 0.02847736f, -0.03920282f, -0.03689338f, 0.04167898f, -0.01258788f, 
    -0.02985676f, 0.04245304f, 0.00260033f, -0.01880422f, 0.04078944f, -0.02373052f, 0.00197113f, -0.05661495f, 
    0.02547576f, 0.00322168f, -0.02721589f, 0.03261162f, 0.01525608f, -0.03838481f, -0.05616141f, 0.01222675f, 
    -0.23847735f, 0.09079317f, 0.26397479f, -0.12406641f, -0.06640544f, 0.17932570f, -0.05133685f, -0.00542967f, 
    0.06063439f, 0.12203219f, 0.08714717f, 0.04877215f, -0.08796246f, 0.06856021f, 0.12218720f, -0.29323259f, 
    0.01006521f, 0.00317861f, 0.19179267f, 0.00602980f, -0.02418728f, -0.04402971f, -0.04602728f, -0.10342374f, 
    -0.07496017f, -0.00143916f, 0.19908355f, -0.00241332f, 0.01392404f, 0.14718449f, -0.04336766f, 0.08246358f, 
    0.10951226f, 0.03033814f, 0.10016847f, -0.04038544f, 0.06686089f, 0.11816292f, -0.01926252f, 0.14629702f, 
    0.06472183f, 0.05302616f, -0.02187526f, -0.09962036f, 0.11190388f, 0.09640922f, -0.04351895f, 0.03127854f, 
    0.04939673f, 0.10851056f, 0.00312906f, -0.04349246f, 0.12648429f, 0.05325920f, 0.02800269f, 0.06384898f, 
    0.07309884f, -0.09856954f, -0.01724933f, -0.04177494f, 0.02463839f, 0.15236266f, 0.05562196f, -0.03421801f, 
    -0.06887254f, 0.01171017f, -0.07347841f, 0.07832498f, 0.09953285f, -0.04398859f, 0.10815822f, 0.04060688f, 
    0.21583667f, -0.24972492f, -0.01289454f, 0.09917095f, -0.01521116f, -0.00690226f, -0.00101075f, 0.05082730f, 
    0.05975204f, 0.19921678f, 0.11520062f, 0.00497190f, -0.01637060f, -0.15070595f, -0.11350302f, 0.33357936f, 
    -0.03505174f, 0.04605469f, -0.01154268f, 0.08391466f, 0.05268442f, -0.00931779f, 0.04176237f, -0.02259092f, 
    0.09563792f, 0.10113767f, 0.06211486f, -0.26699522f, -0.07359511f, 0.15335749f, -0.09108828f, 0.01004190f, 
    0.04040900f, -0.09066632f, -0.05754025f, 0.14337106f, -0.22786264f, -0.17555045f, 0.16268884f, -0.09261508f, 
    0.03862878f, -0.13407499f, -0.01430079f, 0.03003733f, -0.04540389f, 0.00559132f, 0.06570960f, 0.16240650f, 
    0.20668356f, -0.04534147f, -0.09466019f, 0.16780031f, -0.01993490f, -0.05186005f, -0.07430244f, 0.06615611f, 
    -0.00129051f, 0.14906098f, 0.03650678f, 0.04906046f, -0.01504813f, 0.42376426f, 0.04434233f, -0.29425374f, 
    -0.12607640f, 0.06742658f, 0.04146397f, 0.03076084f, -0.04401724f, -0.11213545f, 0.02163751f, 0.06733612f, 
    0.04464300f, -0.24119915f, 0.20405358f, 0.17101347f, -0.08879022f, 0.00248785f, 0.02978838f, 0.04791600f, 
    0.02102249f, -0.07542087f, -0.14161125f, -0.04523121f, 0.13817424f, -0.09517627f, 0.13897432f, -0.12205158f, 
    0.00336995f, 0.01401901f, -0.06320578f, 0.11587986f, 0.10852783f, -0.02578303f, 0.07215436f, 0.10489786f, 
    -0.47126031f, 0.26587901f, 0.16829975f, -0.02127113f, 0.01301284f, 0.13649419f, 0.12980857f, -0.04590594f, 
    -0.01602537f, 0.08355696f, -0.02694890f, 0.02834160f, -0.19018194f, 0.13465650f, 0.00777761f, -0.01128842f, 
    -0.10278504f, -0.11197262f, -0.00009230f, -0.01182233f, -0.03949048f, 0.07807072f, -0.02497318f, 0.10798714f, 
    -0.04974679f, 0.19910547f, 0.03895010f, -0.26646951f, 0.02189289f, 0.13009287f, 0.14123139f, -0.02645849f, 
    0.02739183f, -0.15685058f, -0.09829508f, 0.07720514f, 0.04434820f, -0.05510265f, -0.00893499f, 0.23677137f, 
    0.00487179f, -0.08000112f, 0.00035438f, -0.06838373f, 0.08216059f, -0.09132125f, -0.05017335f, 0.05201041f, 
    0.06747050f, 0.22358540f, 0.10974214f, -0.00824458f, 0.11724418f, 0.08465721f, 0.00096707f, 0.12439065f, 
    0.13050717f, 0.02430506f, 0.08682384f, -0.05834550f, 0.36848339f, -0.00924257f, 0.10858775f, 0.05071883f, 
    -0.06126210f, -0.06474374f, -0.09513904f, 0.07683016f, 0.07855752f, -0.10819393f, -0.12414838f, -0.00720162f, 
    -0.11474650f, 0.26369458f, -0.11469313f, -0.18945883f, 0.20031136f, 0.00697108f, 0.14119524f, -0.13036072f, 
    0.03648590f, -0.02941777f, 0.14542362f, 0.07072855f, -0.48271367f, 0.02838336f, 0.00787262f, 0.22384621f, 
    0.07260130f, -0.06772514f, 0.08408187f, -0.03141133f, 0.05299886f, 0.03200362f, -0.12209844f, 0.12269625f, 
    0.37795907f, -0.10949691f, -0.07655219f, -0.25620589f, -0.08113914f, 0.08282638f, 0.07194173f, -0.02457922f, 
    -0.08616829f, 0.05872748f, 0.13754557f, 0.08928102f, 0.08107356f, -0.18229926f, -0.00534586f, -0.00964199f, 
    -0.17015919f, 0.00545842f, -0.06149857f, 0.08176062f, 0.06918664f, 0.02944028f, 0.07557718f, 0.06645783f, 
    -0.02329847f, 0.07852156f, 0.04146656f, 0.27023789f, -0.05697907f, 0.02882822f, 0.10568949f, -0.00197422f, 
    0.06778496f, -0.10760376f, 0.11186801f, -0.11694530f, 0.05758369f, 0.15739734f, 0.15192029f, -0.29665467f, 
    0.06432801f, 0.05797042f, -0.16842109f, -0.09481356f, 0.12854697f, 0.12890464f, 0.05318272f, 0.07763171f, 
    0.47205499f, 0.20328707f, -0.04573916f, -0.21473604f, -0.03316771f, -0.00929012f, -0.03448053f, 0.00858059f, 
    0.02115597f, 0.05835952f, -0.03038524f, 0.01125294f, -0.48176920f, -0.00703635f, 0.15698406f, -0.35648155f, 
    -0.03316246f, 0.08939473f, 0.02231111f, -0.02356735f, 0.12067264f, 0.01413450f, -0.14135627f, 0.09318478f, 
    0.05062559f, -0.01870259f, 0.10209353f, -0.04070646f, 0.13854170f, -0.04272134f, 0.03837721f, 0.12778513f, 
    0.12726375f, 0.04331260f, -0.05277525f, 0.04732706f, 0.01454872f, 0.05328307f, -0.15814559f, -0.06816488f, 
    0.06843459f, -0.07670617f, -0.04298909f, -0.07326239f, 0.00033380f, 0.06762354f, 0.17571940f, 0.05020151f, 
    -0.52292746f, 0.15558465f, -0.10558954f, 0.03389418f, -0.04707289f, 0.07743506f, -0.14652659f, 0.10210872f, 
    0.05796112f, 0.02681996f, 0.06253682f, 0.03876977f, -0.43010080f, 0.10058454f, 0.12054124f, 0.07388344f, 
    0.00773212f, -0.10491278f, 0.03530674f, -0.08336533f, 0.05547251f, 0.03631259f, 0.09767315f, 0.08781011f, 
    0.00170162f, -0.00860050f, -0.03498921f, 0.00223933f, -0.03396441f, -0.03591922f, 0.01285054f, -0.04147454f, 
    0.03812875f, -0.02538543f, 0.00510715f, -0.04297410f, 0.04109857f, -0.04540256f, 0.00324920f, 0.01549570f, 
    -0.03817284f, -0.02386193f, -0.02255386f, 0.02426046f, -0.03015066f, 0.03683410f, 0.01667028f, -0.00341833f, 
    0.03102593f, 0.00968467f, 0.00144777f, -0.00725934f, -0.04793527f, 0.00282606f, -0.05122254f, -0.04909474f, 
    0.04148420f, -0.01964431f, -0.05385905f, -0.05003690f, -0.04217747f, 0.03901715f, 0.01288366f, 0.00747891f, 
    -0.04246710f, 0.00409307f, -0.05288078f, 0.01035441f, 0.01796997f, -0.01846302f, 0.02716756f, 0.04395692f, 
    -0.00518673f, -0.04682854f, 0.00175109f, -0.02163129f, 0.03971517f, -0.03642212f, 0.00449546f, 0.03601802f, 
    -0.02660169f, 0.04165646f, -0.04561508f, -0.01407012f, -0.00286966f, 0.02414214f, -0.03739002f, 0.03554828f, 
    0.03735714f, 0.00840269f, -0.01592396f, 0.04185773f, 0.00097352f, 0.01024352f, -0.00024092f, -0.00907991f, 
    -0.04634293f, 0.01697251f, -0.05072715f, -0.05143386f, -0.02773968f, -0.05310435f, -0.05058942f, -0.01450601f, 
    -0.02354981f, 0.03874758f, -0.01363869f, 0.03845675f, -0.02913103f, -0.00821444f, 0.01854261f, 0.02991121f, 
    0.03455798f, -0.05376157f, -0.05576705f, 0.00143566f, -0.03075358f, 0.01206481f, -0.02712876f, -0.02676966f, 
    -0.04217320f, -0.00963915f, -0.02722434f, -0.01553793f, 0.01640580f, 0.04470699f, 0.01271640f, 0.02570728f, 
    0.02873839f, 0.00306051f, -0.03502693f, -0.01343799f, 0.02671234f, -0.03918578f, -0.02302907f, -0.04632012f, 
    0.04597244f, -0.03975677f, -0.04670837f, 0.00762948f, -0.00010779f, 0.01478507f, -0.01901566f, -0.05548049f, 
    0.04419556f, -0.02528314f, -0.00059664f, -0.01698973f, -0.01993350f, 0.03731135f, -0.01794124f, -0.01634069f, 
    0.04590541f, -0.00462607f, -0.04189914f, -0.04581073f, -0.04302968f, -0.04897334f, -0.04061414f, -0.01755013f, 
    0.02235950f, -0.03542255f, -0.01005756f, 0.00369292f, -0.04329836f, 0.03914245f, -0.04867997f, -0.03950698f, 
    -0.05132574f, -0.03489814f, -0.03393073f, 0.00845389f, -0.00163320f, -0.01288270f, -0.01620691f, -0.03671507f, 
    -0.04350394f, -0.00468780f, -0.02665944f, 0.01348641f, -0.04610387f, 0.02395424f, 0.00116409f, 0.02066572f, 
    0.03008459f, -0.04623073f, -0.04109771f, -0.02337556f, 0.04220297f, -0.03585513f, -0.03002760f, -0.02864503f, 
    0.03721228f, 0.02778624f, -0.02421883f, -0.03797504f, 0.01510261f, 0.01104930f, -0.02974834f, 0.01244545f, 
    0.03452400f, 0.04477125f, 0.00492767f, -0.01029335f, 0.04011906f, 0.00390860f, -0.00026768f, -0.01898771f, 
    0.01470274f, -0.02879941f, 0.02972946f, -0.03272920f, -0.03102436f, -0.02338143f, -0.00691562f, -0.01266725f, 
    0.01305898f, -0.03677439f, 0.04724913f, -0.00143770f, 0.01447240f, 0.04062761f, -0.02282529f, 0.04067082f, 
    -0.03327914f, 0.00951570f, -0.02935914f, 0.01773658f, -0.03267184f, 0.01125835f, -0.05587078f, -0.00002023f, 
    -0.01661131f, 0.03926308f, 0.04260405f, 0.04367191f, -0.04698784f, -0.00579206f, 0.02758462f, -0.02572679f, 
    -0.05253328f, -0.00480490f, -0.02488730f, 0.00803276f, -0.04781110f, -0.00643092f, 0.01477929f, -0.04962890f, 
    0.00053572f, -0.03009699f, -0.04270587f, -0.02448107f, -0.05382220f, 0.01773666f, 0.02280460f, 0.03987955f, 
    -0.01752230f, 0.04041408f, 0.00415004f, -0.02174088f, 0.01864759f, 0.01475502f, 0.00022303f, -0.04664408f, 
    -0.00731552f, -0.04022798f, 0.04340607f, 0.00263619f, -0.01815689f, -0.02511456f, 0.02117737f, -0.01641092f, 
    0.04019155f, 0.03544629f, 0.03208391f, 0.00557578f, 0.01414705f, 0.00916378f, 0.04519612f, 0.00480850f, 
    -0.04541504f, -0.01524174f, 0.04379579f, 0.02217193f, -0.05434167f, -0.02109468f, -0.00304149f, -0.04211359f, 
    -0.00202457f, 0.03802946f, -0.01575869f, 0.02344643f, 0.00974880f, 0.03266473f, -0.05091658f, -0.00011389f, 
    -0.04861804f, -0.02114803f, -0.02475311f, -0.02523300f, -0.00204691f, -0.00454034f, 0.03418399f, -0.00481196f, 
    0.04355913f, -0.02158088f, -0.03820438f, -0.05605481f, 0.03401255f, 0.03110953f, -0.04491711f, -0.01306109f, 
    0.03735999f, 0.01619656f, -0.01668877f, -0.03047427f, 0.02683987f, -0.04820333f, -0.04426313f, 0.04287523f, 
    -0.00307928f, 0.00792799f, 0.04335459f, 0.03633396f, -0.02424500f, 0.02624485f, -0.00982464f, 0.00066095f, 
    0.05082344f, 0.02470082f, -0.05240240f, 0.03304921f, -0.03294348f, 0.03660442f, -0.01913029f, -0.05278606f, 
    -0.00815507f, -0.04356946f, 0.02700050f, -0.03875519f, -0.00186284f, -0.04326598f, -0.00179524f, 0.02291220f, 
    -0.03475234f, -0.05218437f, -0.00286091f, -0.01000407f, -0.01938363f, -0.04288576f, 0.02126428f, -0.01644070f, 
    -0.01999005f, -0.01186348f, -0.01716683f, 0.00237376f, -0.03342066f, -0.00571388f, 0.00951582f, -0.02732054f, 
    -0.01556373f, -0.02205723f, -0.00537533f, -0.05204292f, 0.03627411f, -0.00157675f, 0.00499916f, -0.00017965f, 
    -0.01423771f, -0.01402577f, 0.00483342f, 0.03796446f, -0.04604582f, 0.00776551f, -0.03608872f, -0.02921325f, 
    -0.04015536f, -0.04118241f, 0.01470106f, -0.04312808f, -0.01076950f, -0.05163765f, 0.02847965f, -0.05124186f, 
    0.01092693f, -0.01327921f, -0.03124959f, 0.01428333f, -0.00392441f, -0.02440264f, -0.03452477f, -0.01236273f, 
    0.01213539f, -0.04377710f, -0.00706505f, 0.02923071f, -0.03366700f, -0.00855552f, 0.00625398f, -0.05591510f, 
    0.00032956f, -0.05259069f, 0.03790796f, -0.05119191f, 0.02689727f, 0.01227686f, -0.04030384f, 0.02473246f, 
    0.17515330f, -0.11999466f, 0.22231309f, 0.13180432f, -0.05336415f, 0.09380937f, 0.07746139f, -0.05781845f, 
    0.13531515f, 0.02839725f, 0.03312241f, 0.16428514f, 0.09760927f, 0.11977445f, 0.05481575f, -0.09794133f, 
    0.03428315f, 0.03522357f, 0.11953864f, 0.04329364f, -0.06214756f, 0.07000468f, 0.07614118f, 0.04614506f, 
    -0.08904444f, -0.02089504f, -0.09745635f, 0.00288941f, 0.04773419f, -0.12847710f, 0.03628355f, -0.01787697f, 
    0.24931686f, 0.03701195f, -0.10791492f, 0.00318760f, -0.22639583f, 0.25365621f, -0.09323384f, -0.16817614f, 
    0.05042486f, -0.09826875f, 0.18394156f, -0.11110935f, 0.07916813f, -0.06422712f, 0.12771644f, -0.07214875f, 
    0.17965530f, 0.09244740f, 0.27413201f, 0.23769854f, -0.00735320f, 0.01324019f, -0.03696767f, 0.07043648f, 
    0.02071794f, 0.21466321f, 0.07537472f, -0.01185764f, -0.48187336f, -0.26988471f, 0.03759493f, -0.15310416f, 
    -0.08101285f, -0.07645968f, -0.10812201f, 0.01453964f, -0.21590725f, -0.04170904f, 0.13144474f, 0.08054637f, 
    -0.20533447f, -0.11616611f, 0.03396224f, -0.18062402f, 0.01806963f, 0.14561704f, 0.00354339f, -0.03332196f, 
    0.08805192f, 0.09805641f, 0.15854309f, 0.09949526f, -0.17599642f, -0.00226343f, -0.11749269f, 0.05778963f, 
    -0.08304370f, 0.16242181f, 0.07963661f, -0.02492522f, -0.12367872f, -0.15999867f, -0.06178382f, 0.02303415f, 
    -0.35759127f, -0.09959853f, 0.02230265f, 0.08386196f, -0.14286749f, 0.14862065f, -0.08804838f, -0.01135632f, 
    0.00933812f, -0.06174664f, -0.14567138f, 0.01457748f, 0.02954869f, -0.02114945f, -0.07775936f, 0.04852621f, 
    0.09377088f, -0.02906810f, -0.12735812f, 0.08742431f, 0.00911729f, -0.01213731f, 0.06408072f, -0.10777786f, 
    0.08988249f, 0.28775042f, 0.10390261f, -0.08050887f, -0.15886684f, 0.05936852f, 0.00091509f, -0.10872322f, 
    -0.09663166f, -0.02388333f, 0.04545501f, 0.16360496f, -0.26725826f, 0.34422219f, 0.13139379f, 0.04917780f, 
    0.00139641f, 0.03153796f, 0.03374114f, 0.10481389f, 0.07323172f, -0.04630793f, 0.07645919f, 0.06598692f, 
    -0.28966531f, -0.15581846f, -0.09951787f, 0.01610387f, -0.02812399f, 0.00467845f, -0.09067947f, -0.05609579f, 
    -0.08347532f, 0.11517590f, -0.14105609f, -0.01349932f, 0.40071037f, 0.04497673f, 0.15020072f, 0.27906135f, 
    -0.00667683f, 0.08375135f, -0.05074301f, -0.00562746f, -0.17927255f, -0.04604131f, 0.04070641f, 0.14939009f, 
    -0.17841405f, 0.34825552f, 0.39283714f, 0.27987772f, 0.22525553f, -0.09953606f, -0.05736116f, 0.00613795f, 
    0.11984052f, 0.05644356f, -0.04989108f, -0.17047083f, 0.27234778f, -0.02641109f, -0.05663432f, -0.05750540f, 
    0.24695054f, 0.04443511f, 0.09228139f, 0.06176097f, 0.02635995f, 0.08040835f, 0.02382062f, 0.07308418f, 
    -0.05934170f, 0.29216549f, 0.05244046f, -0.00042754f, 0.00483050f, 0.06277704f, 0.09887384f, -0.01390651f, 
    0.01379250f, 0.03322147f, 0.02651190f, -0.02503227f, -0.29779649f, -0.02430921f, -0.13605547f, 0.04143292f, 
    -0.05984138f, 0.09259457f, -0.07140853f, -0.01710378f, 0.11915896f, 0.00583819f, -0.07043896f, 0.14653814f, 
    -0.18047032f, 0.06415592f, -0.13229980f, -0.09169815f, 0.11939457f, 0.04857446f, -0.01514760f, -0.11823736f, 
    -0.04136130f, -0.01577616f, 0.00911063f, 0.12081952f, -0.05710543f, 0.42261118f, 0.23862632f, 0.14365245f, 
    -0.05318408f, 0.10793217f, -0.00695652f, 0.00065495f, -0.08485869f, -0.17773817f, 0.11008783f, -0.01593611f, 
    -0.04815341f, 0.09753519f, 0.15857832f, 0.11208475f, 0.03449862f, -0.09210209f, 0.13827430f, -0.06618394f, 
    -0.11249258f, -0.05650301f, -0.08108297f, -0.03168971f, 0.12566297f, -0.00018118f, 0.03919511f, -0.04811271f, 
    0.10159265f, 0.01470605f, 0.05531874f, -0.04821550f, 0.02730268f, 0.01286352f, -0.08306550f, 0.03642331f, 
    0.20252888f, 0.13202555f, -0.21041930f, 0.10467775f, -0.07473347f, -0.00477171f, -0.03255443f, -0.10174843f, 
    -0.05187345f, -0.03065085f, -0.05826519f, 0.02695390f, -0.29567361f, 0.11912616f, -0.00069358f, -0.33020908f, 
    0.04283736f, 0.03076724f, 0.08005924f, -0.03384054f, 0.06958102f, 0.03085319f, -0.10003515f, 0.15178381f, 
    -0.43391374f, 0.20853975f, -0.08086052f, -0.02092121f, 0.08928303f, 0.00035013f, 0.05731991f, -0.08351222f, 
    0.19973780f, -0.12635088f, -0.02509267f, -0.06403475f, -0.09745543f, 0.10249225f, 0.00354627f, 0.06668776f, 
    0.11675986f, -0.00956914f, -0.03950132f, -0.04872465f, 0.07940882f, 0.02720177f, 0.05990314f, 0.11052276f, 
    0.06259761f, 0.11173447f, 0.27307922f, 0.13317874f, 0.04209315f, -0.04475766f, 0.21044612f, 0.03613265f, 
    0.08110960f, -0.01216444f, 0.04633559f, 0.01740376f, 0.12068354f, -0.12144101f, 0.15840769f, -0.18217161f, 
    0.14351524f, 0.10257456f, 0.06787295f, 0.11779480f, 0.11644616f, 0.00264203f, -0.19657131f, 0.06812083f, 
    0.32936075f, 0.13659795f, 0.11040348f, 0.37140083f, 0.10890473f, 0.06473802f, -0.04141632f, 0.06309153f, 
    -0.07084468f, 0.13798253f, 0.07972474f, -0.09211835f, -0.58989453f, -0.19674383f, 0.07785168f, 0.10296048f, 
    -0.17850138f, 0.08147321f, 0.00362501f, 0.07964970f, -0.04102883f, 0.04918249f, -0.01227432f, 0.01158281f, 
    -0.30442750f, 0.15828712f, 0.08158588f, -0.07923358f, -0.04082842f, -0.12713911f, -0.08412933f, 0.04680826f, 
    -0.09035128f, 0.15771611f, 0.00466382f, 0.05648872f, -0.00449356f, 0.08977801f, 0.31885543f, 0.25365996f, 
    0.04960969f, 0.00112432f, -0.00023343f, -0.03071507f, -0.08350038f, -0.02506899f, -0.03391514f, 0.08010183f, 
    0.07849818f, -0.20465529f, 0.13221383f, -0.10302705f, 0.01276332f, 0.03483846f, -0.05278672f, -0.01163175f, 
    -0.01307584f, 0.02978356f, -0.19375700f, 0.07056708f, 0.51813811f, 0.07753406f, 0.06834489f, 0.00646317f, 
    -0.12062057f, 0.00427797f, 0.02428680f, 0.02437866f, -0.11809844f, 0.04288534f, 0.02057357f, 0.05734253f, 
    0.26082441f, 0.10105250f, 0.01299437f, 0.13199466f, 0.05213137f, -0.02953957f, 0.05531640f, 0.02311016f, 
    0.02725764f, 0.10507896f, 0.00252003f, 0.07479189f, 0.29806569f, 0.36555502f, 0.09061225f, 0.01706318f, 
    0.05050863f, -0.06759541f, 0.03827489f, -0.00467812f, -0.00577290f, -0.08237908f, -0.05322665f, -0.08912829f, 
    0.18770929f, 0.24488145f, 0.18543942f, 0.06140179f, 0.00419343f, 0.02295929f, -0.08070533f, 0.07523944f, 
    -0.03588042f, 0.01212043f, 0.07686447f, -0.03028604f, -0.23226416f, -0.34113574f, -0.29463965f, -0.15043907f, 
    0.06525323f, -0.03868253f, 0.03988146f, -0.09506134f, -0.02373584f, 0.06541870f, 0.05488224f, 0.11394905f, 
    -0.15769599f, -0.37139952f, -0.09018252f, -0.02269819f, 0.00166644f, -0.07838208f, -0.07391794f, -0.06294783f, 
    -0.06977413f, 0.07501956f, -0.00289969f, 0.03583268f, -0.15450354f, -0.32592395f, -0.19666603f, 0.10412773f, 
    0.22279941f, 0.00962792f, 0.06908321f, -0.01494866f, 0.00205155f, -0.14003953f, -0.00701139f, -0.16470625f, 
    -0.20404363f, -0.06483365f, -0.08010527f, 0.19612075f, 0.09206041f, -0.05761607f, -0.01381520f, -0.00673016f, 
    -0.13855255f, 0.07821570f, -0.00365597f, -0.06785428f, 0.43828103f, 0.25432932f, 0.15867940f, 0.19933930f, 
    -0.13231240f, -0.08756095f, 0.02778364f, 0.01725937f, -0.00507618f, -0.02093181f, -0.04031617f, 0.25292185f, 
    -0.00288413f, -0.05450635f, -0.02585148f, 0.09627967f, -0.09354682f, -0.01856590f, 0.02212146f, 0.02162953f, 
    0.05174762f, 0.00550721f, 0.14486836f, -0.13992970f, 0.10143691f, -0.03124295f, -0.15754029f, -0.06096397f, 
    0.04723731f, 0.02519713f, -0.01532245f, -0.02360354f, -0.09749642f, 0.07248832f, -0.03607194f, -0.03939223f, 
    -0.20017445f, -0.22485064f, -0.26051837f, -0.07859619f, 0.01723428f, 0.00939298f, -0.06461883f, -0.10130709f, 
    -0.04249417f, 0.10370111f, 0.05878984f, 0.02948898f, 0.25703156f, 0.15235008f, 0.00795776f, 0.06437453f, 
    -0.04591075f, 0.05839594f, -0.08962941f, -0.08862652f, -0.14979452f, 0.00847882f, 0.05933634f, -0.01389586f, 
    0.02208420f, 0.24336801f, 0.05282165f, 0.17271282f, 0.10011027f, -0.06043775f, 0.02226052f, -0.06207917f, 
    -0.11863421f, -0.00473932f, 0.02110499f, 0.03602945f, 0.24697176f, 0.16111155f, 0.21945383f, 0.30444416f, 
    0.08379120f, -0.11431754f, 0.00087760f, 0.09706690f, 0.00840840f, -0.06559038f, -0.05569543f, 0.05032032f, 
    0.35892737f, 0.28538066f, 0.04923994f, 0.14604786f, 0.03185064f, 0.06019912f, 0.10621925f, 0.01669255f, 
    -0.04475218f, -0.04490161f, -0.05042483f, -0.00951023f, -0.21901463f, -0.26024571f, -0.23019589f, -0.09857558f, 
    -0.12609638f, 0.04221841f, -0.03621597f, 0.03433002f, 0.07380705f, 0.02204526f, 0.02046080f, 0.08158521f, 
    0.12378214f, 0.23793173f, 0.09885974f, -0.01853906f, -0.01090019f, 0.01831277f, -0.04880794f, 0.02436473f, 
    -0.14373048f, -0.08425641f, -0.03014919f, 0.02404662f, -0.03030216f, -0.26009887f, 0.06672367f, 0.06445196f, 
    -0.04039782f, -0.02670474f, -0.02479331f, -0.00769436f, -0.04268900f, 0.03938783f, 0.05355676f, 0.01589324f, 
    0.21275528f, 0.12630595f, 0.11439826f, -0.04501665f, -0.05677461f, -0.09937046f, -0.04942693f, -0.02280823f, 
    0.07487337f, 0.14702855f, -0.01343739f, -0.02972346f, 0.09522019f, -0.07596713f, 0.23387940f, 0.06512551f, 
    -0.07665807f, -0.01537914f, -0.07040504f, 0.00313310f, -0.13329506f, 0.00654203f, -0.01617252f, -0.10248311f, 
    0.03105102f, 0.32815033f, 0.10672330f, -0.07799141f, 0.07246327f, -0.02709375f, 0.11010675f, 0.06534629f, 
    0.08393556f, 0.08857469f, -0.04270786f, -0.00837245f, -0.13819197f, -0.19206552f, -0.20783252f, -0.10549620f, 
    0.03410829f, -0.01091405f, -0.03386693f, -0.03335887f, -0.08586983f, 0.08455713f, 0.03799604f, -0.09957984f, 
    -0.01570107f, -0.37394872f, -0.03507711f, 0.05864105f, -0.14160620f, -0.07311940f, 0.05086791f, 0.04736173f, 
    0.06396091f, 0.05506055f, -0.06856839f, -0.00559459f, 0.00137219f, 0.30162010f, 0.09132633f, -0.24083787f, 
    -0.06005287f, -0.06701861f, 0.02323950f, -0.00329793f, 0.03324531f, -0.03476456f, -0.08441860f, -0.01600534f, 
    -0.18599461f, 0.20968136f, 0.04013839f, 0.08659650f, 0.10259106f, 0.02822293f, 0.00575795f, 0.08231397f, 
    0.02143481f, 0.04922409f, 0.02127945f, 0.01632926f, 0.57867116f, 0.11811852f, 0.25267899f, 0.00100042f, 
    0.04168379f, 0.08755829f, -0.02844634f, 0.01248796f, -0.11848891f, 0.08306354f, -0.08592921f, 0.03117481f, 
    0.14133592f, 0.10494678f, 0.18262017f, 0.20372452f, -0.09236961f, 0.05514080f, -0.01910748f, 0.12810495f, 
    -0.17319219f, 0.00464350f, -0.02994733f, 0.00848090f, -0.04298842f, -0.23672351f, -0.02024560f, -0.02207929f, 
    -0.02397339f, -0.10395158f, 0.03179532f, 0.02416999f, 0.04589028f, -0.08447053f, -0.04312908f, 0.02171401f, 
    0.47687191f, -0.10214791f, 0.08811367f, 0.16965237f, -0.23068856f, 0.06435667f, -0.01608244f, -0.14535557f, 
    -0.15858369f, 0.03479888f, -0.08189321f, -0.01017154f, -0.13720036f, 0.01238700f, -0.04633911f, -0.04650296f, 
    0.10215887f, 0.01758466f, -0.01474419f, 0.05530281f, -0.19295412f, -0.00601463f, -0.06312895f, -0.01860213f, 
    -0.35548323f, 0.22984797f, 0.41059619f, -0.02711711f, -0.08437485f, -0.04784600f, 0.01318994f, 0.13081428f, 
    0.05287104f, -0.03488293f, 0.00167340f, 0.00003868f, -0.10702303f, 0.22011356f, 0.08278827f, -0.15128230f, 
    0.09196281f, 0.09455784f, 0.14729463f, 0.11340353f, 0.03653940f, 0.15076427f, 0.02299054f, 0.06312878f, 
    0.13044205f, -0.04572575f, 0.10760757f, -0.14545991f, 0.01027390f, 0.08355784f, -0.14195849f, -0.03094477f, 
    0.04834013f, -0.03322657f, -0.02444871f, -0.04072651f, 0.01111594f, 0.19179754f, 0.04273818f, -0.01861639f, 
    0.11235509f, 0.05191016f, 0.09694176f, 0.03781487f, -0.01641862f, 0.04704326f, 0.03288825f, 0.03604989f, 
    -0.04770463f, 0.14171891f, 0.14636862f, 0.20638667f, 0.04516810f, -0.01219915f, 0.01816442f, -0.00980475f, 
    -0.09479640f, 0.15908967f, 0.03265174f, -0.09960065f, 0.20788816f, -0.32472646f, -0.21124212f, -0.24875024f, 
    -0.22042860f, -0.16630732f, 0.00386577f, 0.03328787f, 0.04090561f, -0.11707975f, -0.05136790f, -0.16363813f, 
    0.24336608f, -0.15526640f, -0.18901862f, -0.02821188f, -0.08889057f, 0.06972402f, -0.10578874f, 0.10217432f, 
    0.04808268f, -0.08291515f, -0.02294869f, -0.07578518f, 0.08692901f, -0.16997275f, -0.21033239f, -0.02748738f, 
    -0.20801008f, -0.04336655f, -0.00214688f, 0.06702297f, 0.06075855f, 0.03726519f, -0.00463538f, 0.08898478f, 
    0.15303300f, -0.12728633f, 0.00949230f, -0.13098575f, -0.16939878f, 0.05389839f, -0.10527775f, 0.06957722f, 
    -0.02392263f, 0.01151532f, -0.05060084f, -0.03941847f, 0.23115814f, -0.06651135f, 0.03407934f, 0.00329772f, 
    0.11461728f, 0.00339362f, 0.02646322f, -0.02018252f, 0.11128005f, -0.05487807f, 0.03389584f, 0.07472249f, 
    -0.06210488f, -0.17320210f, -0.03719132f, 0.10631403f, -0.05247680f, 0.16872521f, 0.19399236f, -0.02034178f, 
    0.02569970f, 0.03385481f, 0.16651547f, 0.20761833f, -0.08110880f, 0.20070998f, 0.07305267f, 0.03710114f, 
    -0.13056506f, -0.00976801f, 0.08338787f, 0.07750993f, -0.04952179f, 0.05875289f, -0.02511175f, 0.02908118f, 
    0.25376156f, -0.14726807f, -0.14739403f, -0.01598442f, -0.06770889f, -0.05785360f, 0.02234614f, -0.05454979f, 
    0.02909716f, -0.07572966f, 0.02770847f, -0.00729680f, 0.23602864f, 0.06207659f, 0.07851644f, 0.28017437f, 
    -0.00313966f, -0.07751881f, -0.01264621f, 0.04433896f, 0.10358837f, -0.14991869f, -0.13844462f, -0.03293079f, 
    0.28804535f, 0.08728661f, 0.47320777f, 0.44737044f, 0.11192519f, 0.05098834f, -0.03991788f, -0.19769786f, 
    0.08476785f, 0.15265349f, 0.15668522f, 0.03014115f, 0.11552136f, -0.02248796f, 0.09062806f, 0.16722880f, 
    -0.14787750f, 0.08896455f, -0.02803392f, 0.05912341f, -0.02207107f, -0.00624736f, -0.00039797f, 0.03421007f, 
    -0.14221488f, 0.29049388f, 0.19503589f, -0.06010631f, 0.03952028f, -0.02992033f, 0.21355844f, 0.08766650f, 
    -0.15177818f, 0.03684880f, 0.08846636f, -0.02051550f, -0.09743957f, -0.07479901f, -0.13040434f, -0.04024512f, 
    -0.03466092f, -0.12637818f, -0.02105976f, 0.08153812f, 0.04325916f, 0.03106831f, -0.02252033f, 0.06685752f, 
    0.19094397f, 0.10773353f, -0.04029688f, -0.19593765f, 0.08133658f, -0.03384275f, 0.12592667f, 0.02301991f, 
    0.12284745f, 0.10437141f, -0.07491741f, -0.05610484f, 0.29839715f, 0.08714496f, -0.01858847f, 0.10319419f, 
    -0.10139190f, 0.03786899f, -0.04574692f, 0.09378757f, -0.09045707f, -0.12044059f, 0.08245274f, 0.07254545f, 
    0.19328484f, -0.07031702f, 0.06315979f, 0.04315000f, 0.06023670f, -0.01456110f, -0.04406086f, -0.06785998f, 
    0.02092510f, -0.15294605f, -0.01413474f, 0.02651244f, -0.43732005f, 0.27692994f, 0.02111535f, 0.16454229f, 
    0.02419554f, 0.07145679f, 0.05032550f, -0.01263487f, -0.02236710f, -0.03576134f, -0.04731202f, -0.01711770f, 
    0.41733742f, -0.13111171f, -0.06907360f, -0.03633385f, -0.09776004f, -0.06279958f, -0.02792672f, 0.03292858f, 
    0.02472667f, -0.04026780f, -0.02589729f, 0.00626118f, 0.06651259f, -0.05395869f, -0.12327299f, -0.00083179f, 
    -0.13507123f, 0.05788161f, 0.01023960f, 0.00339382f, 0.12672916f, -0.01572910f, -0.07016017f, 0.01521908f, 
    -0.29108387f, -0.03461171f, -0.07039385f, -0.03172343f, -0.02842121f, -0.04731229f, 0.09979536f, 0.04989218f, 
    0.09677757f, -0.15127358f, 0.14515941f, -0.00614691f, 0.27096081f, 0.05552768f, 0.15992779f, -0.09373876f, 
    -0.01533373f, 0.01393085f, 0.11415707f, 0.07733806f, 0.09581476f, 0.10591237f, -0.07020842f, 0.04597060f, 
    0.27992499f, 0.18835706f, 0.14156899f, -0.23335609f, -0.03828831f, -0.03977744f, -0.02120384f, -0.04945754f, 
    -0.18660463f, -0.00040348f, 0.06563777f, -0.02726410f, -0.06247619f, 0.14638565f, 0.22212552f, -0.07744413f, 
    -0.03233713f, 0.03618934f, 0.09495782f, -0.01835566f, 0.06550595f, 0.00367821f, 0.10882822f, 0.07941077f, 
    0.21191591f, 0.21550782f, 0.06110112f, 0.18179739f, 0.11024605f, 0.00213931f, -0.04535541f, 0.16803619f, 
    0.10412697f, 0.04994216f, 0.06512246f, -0.03546727f, -0.05909412f, -0.21314985f, 0.01713839f, -0.03114491f, 
    0.00325511f, -0.03666574f, -0.17926311f, 0.06494758f, -0.03228882f, 0.10239711f, -0.11679696f, 0.04057317f, 
    -0.48580107f, 0.20721361f, -0.05452868f, 0.12582138f, 0.05583362f, -0.02807305f, 0.08408498f, -0.09858137f, 
    -0.08701298f, 0.20224689f, -0.05212957f, 0.11005837f, -0.00077297f, -0.04065319f, 0.15496139f, 0.20733702f, 
    -0.09121092f, -0.02521146f, -0.13257900f, 0.01576635f, 0.06552293f, -0.01911195f, -0.05039311f, -0.00498309f, 
    0.26182243f, -0.20129240f, -0.15261640f, -0.01359637f, 0.13582467f, -0.03114992f, 0.21822514f, -0.00910979f, 
    0.02864158f, -0.00154438f, -0.05422290f, -0.00096912f, 0.15911877f, -0.07977288f, 0.01349100f, -0.05168101f, 
    0.12345898f, 0.05913459f, 0.02809476f, 0.04180031f, -0.00060955f, -0.04719700f, 0.02567289f, 0.12097040f, 
    0.15213172f, -0.01874569f, -0.15998930f, 0.00443547f, 0.07865567f, 0.06023804f, 0.19198586f, -0.00015732f, 
    -0.05651816f, -0.01580361f, 0.03630953f, -0.01003184f, 0.21572360f, 0.01306114f, 0.03331819f, -0.12074448f, 
    0.08048183f, 0.09721070f, -0.19637580f, -0.01588601f, 0.04732975f, 0.11619749f, -0.04863872f, 0.18410543f, 
    -0.05270641f, -0.23738211f, -0.25072643f, -0.23475572f, 0.02420000f, -0.03204820f, -0.03430988f, 0.06073017f, 
    0.10507429f, 0.03526784f, -0.11628193f, -0.02886027f, 0.01751624f, 0.35590437f, 0.09037735f, -0.10251264f, 
    0.08424485f, 0.01496649f, 0.00811912f, 0.08632047f, -0.02411952f, 0.06858834f, -0.02452994f, -0.02353182f, 
    0.03149573f, 0.22420448f, 0.31954131f, 0.04845230f, -0.08273845f, 0.04924053f, 0.02783601f, -0.12595437f, 
    -0.13898188f, -0.00455186f, -0.06923132f, -0.14306606f, -0.05653366f, 0.34820095f, 0.08376140f, 0.16022237f, 
    -0.11472159f, -0.05482269f, -0.02072849f, 0.08979107f, 0.04467024f, 0.17348742f, -0.03521546f, -0.15078226f, 
    0.30302897f, 0.20920044f, 0.15514226f, -0.07684720f, 0.04651069f, 0.18978621f, 0.20393661f, 0.19067772f, 
    0.01494918f, 0.00815185f, 0.15489064f, -0.05953656f, -0.06639789f, 0.07103376f, 0.01575403f, -0.20187666f, 
    -0.06558872f, 0.02628409f, 0.17267732f, -0.01409773f, -0.09641998f, 0.03547012f, 0.05233434f, 0.13013722f, 
    0.05798674f, 0.17936161f, -0.21391638f, 0.24632590f, -0.05232549f, 0.01359180f, -0.04613490f, 0.13356522f, 
    0.11793730f, -0.00230443f, -0.06721701f, 0.11008568f, 0.11255546f, -0.01203151f, 0.12782170f, -0.08700876f, 
    0.12104444f, -0.01256092f, 0.11381119f, 0.04178718f, -0.06536289f, 0.07565756f, 0.06750903f, -0.01554424f, 
    -0.07698672f, 0.29568750f, 0.24955766f, 0.16353168f, -0.12733987f, 0.11443567f, 0.04166696f, -0.04744219f, 
    -0.10483320f, -0.06275333f, 0.15614745f, 0.17586906f, -0.28559935f, -0.08925660f, -0.04190402f, -0.20899989f, 
    -0.02171527f, 0.11093645f, 0.19528574f, -0.02088474f, 0.03408138f, -0.00958198f, -0.16390333f, -0.06265630f, 
    -0.26772258f, 0.03479505f, -0.29553229f, -0.24015364f, 0.17752589f, 0.10389438f, 0.16406193f, 0.02107015f, 
    -0.15001890f, -0.03606471f, 0.04907778f, 0.09963313f, 0.26453605f, 0.23573309f, -0.04458852f, 0.19239163f, 
    -0.02070542f, 0.01687980f, -0.15847911f, -0.02622180f, 0.05341583f, -0.07503816f, -0.06436954f, 0.10912669f, 
    0.06474119f, -0.10737710f, 0.00818850f, -0.07208220f, 0.18607156f, 0.11484826f, -0.02115078f, 0.08221220f, 
    0.10360511f, 0.07838368f, -0.00985530f, 0.11424999f, 0.08797958f, 0.17807040f, 0.14701895f, 0.26665759f, 
    0.09397514f, 0.02109621f, 0.03427440f, -0.06471721f, -0.02222270f, -0.07732456f, 0.21187849f, -0.03190165f, 
    -0.05373069f, -0.06812146f, 0.10353342f, -0.07765194f, 0.16459925f, -0.04422820f, 0.04903324f, 0.12322947f, 
    -0.06242441f, 0.11570556f, -0.09307258f, 0.10082228f, -0.03463164f, 0.10065318f, -0.07226590f, 0.03818746f, 
    -0.08504815f, 0.02242036f, -0.11339159f, 0.18722263f, -0.00380383f, 0.20091961f, 0.06311902f, 0.02177469f, 
    -0.04736150f, 0.00948014f, -0.00453987f, -0.28505847f, -0.05759665f, 0.06836451f, 0.09720944f, -0.04167360f, 
    -0.00813845f, 0.00313369f, -0.05564606f, 0.03426231f, 0.75938380f, -0.22371717f, 0.02629855f, 0.22474477f, 
    -0.18533593f, -0.00552492f, 0.00562188f, -0.00751116f, 0.12627389f, -0.00957097f, 0.19556099f, 0.01619082f, 
    -0.21607526f, 0.13385211f, 0.06349795f, 0.05786315f, -0.04138271f, 0.15556374f, 0.08712734f, 0.11978135f, 
    0.09316100f, -0.04123525f, -0.06070648f, -0.00900096f, 0.08356506f, 0.21785931f, 0.17171273f, -0.10750484f, 
    -0.13607231f, -0.04015898f, -0.09592412f, 0.01713793f, -0.00101579f, 0.01686724f, -0.01619746f, -0.01725595f, 
    0.57749403f, -0.00276627f, 0.03495751f, 0.24880441f, -0.02177885f, 0.10516682f, -0.02651710f, 0.05678079f, 
    0.01369711f, 0.03330924f, 0.08645062f, 0.02514271f, -0.26377696f, -0.10615376f, -0.04200543f, -0.12303603f, 
    0.12061375f, -0.04207884f, 0.10378964f, 0.18123639f, 0.21704638f, -0.11327600f, 0.10890802f, -0.17675120f, 
    0.29516563f, -0.09220232f, -0.05917384f, 0.12057064f, 0.23246369f, 0.01434859f, 0.02958171f, 0.07862533f, 
    -0.03362852f, -0.11138002f, -0.02247200f, 0.12974672f, 0.11008976f, -0.12275983f, -0.16315575f, -0.01680036f, 
    0.11604270f, -0.07273045f, -0.06489403f, -0.06424475f, -0.03121082f, 0.02206329f, 0.20262316f, 0.03015954f, 
    -0.26026475f, 0.02973459f, -0.00071424f, 0.06298711f, 0.03011932f, -0.04472721f, 0.05641624f, -0.14408363f, 
    -0.07487988f, 0.00175954f, -0.01868647f, 0.10575625f, 0.08376256f, 0.42689085f, 0.19685484f, -0.05989016f, 
    -0.06931140f, 0.07257465f, 0.03758084f, -0.01711766f, 0.01097962f, 0.09061945f, -0.07492850f, -0.04104136f, 
    0.40884674f, -0.32133240f, 0.02326949f, 0.09868400f, -0.05186050f, 0.15055007f, 0.10783812f, 0.03293514f, 
    0.05466485f, -0.10998756f, 0.00473097f, 0.17953400f, -0.19754231f, -0.06580686f, -0.02646508f, -0.35664955f, 
    0.06930555f, 0.09501913f, 0.07693513f, -0.14884001f, 0.04885963f, -0.02046331f, 0.05812461f, -0.00753423f, 
    0.02425919f, 0.04133950f, 0.00571720f, -0.01482821f, -0.01284312f, 0.03389379f, -0.00655411f, 0.04465881f, 
    0.01283399f, 0.02965201f, -0.03990744f, -0.03489815f, -0.01564856f, -0.00573531f, -0.03411734f, 0.00587570f, 
    -0.05119075f, 0.03835182f, 0.01903713f, 0.00038528f, -0.04647309f, 0.02177536f, -0.01396315f, -0.05030359f, 
    -0.03497083f, -0.05103956f, -0.04079137f, -0.01623026f, 0.00626662f, -0.03708579f, 0.02929871f, 0.01364071f, 
    0.00598737f, -0.04569163f, -0.03690024f, -0.04695582f, 0.03379612f, 0.03164662f, -0.04174506f, 0.02002609f, 
    0.01756707f, 0.00824211f, 0.00349479f, -0.00865791f, -0.03597024f, -0.01685635f, -0.03327523f, 0.02529396f, 
    -0.01697061f, 0.01623886f, 0.02570585f, -0.03003627f, 0.00023636f, -0.05761861f, -0.00988165f, -0.03424402f, 
    -0.00830872f, 0.03630661f, -0.03236463f, -0.01988369f, -0.01086528f, 0.00244913f, -0.03949665f, -0.05509809f, 
    -0.02824944f, -0.03833006f, -0.05191921f, 0.00100288f, 0.03957763f, 0.03544744f, 0.03202753f, 0.01036192f, 
    0.01613753f, 0.01803526f, 0.01068992f, -0.04264589f, -0.05392987f, -0.00366663f, 0.02421985f, 0.00063041f, 
    -0.05791574f, 0.03721814f, -0.05323438f, -0.04522320f, -0.02265760f, 0.00467413f, 0.01851790f, -0.01853763f, 
    -0.02072069f, -0.04089030f, -0.00283137f, 0.01557352f, -0.02316510f, -0.03182888f, 0.02075678f, 0.00641681f, 
    -0.00743103f, 0.02156242f, -0.03282187f, -0.04113175f, -0.03428312f, 0.03798564f, 0.02911457f, -0.02199756f, 
    0.00647648f, -0.02424301f, 0.01154817f, 0.03106014f, 0.01363024f, 0.01096065f, 0.01095332f, 0.01077103f, 
    -0.03379509f, -0.00800280f, -0.05484543f, 0.04082628f, -0.01045843f, 0.00628467f, -0.03909502f, -0.03378211f, 
    -0.01875088f, -0.00941886f, -0.03758666f, 0.01558211f, -0.01688400f, -0.02146353f, -0.05093522f, -0.04757666f, 
    0.03155366f, 0.00083062f, 0.04626727f, 0.04009664f, -0.04362404f, -0.02524923f, 0.01380843f, -0.05263222f, 
    -0.03114177f, -0.04475294f, -0.00264718f, -0.00400041f, 0.02244629f, -0.04012661f, 0.04204862f, -0.01629538f, 
    -0.02647530f, 0.02741654f, -0.05504592f, 0.03757676f, -0.02701170f, -0.00356613f, -0.05581969f, -0.03744082f, 
    -0.03211058f, -0.03652725f, -0.02720636f, -0.02859045f, -0.01494928f, -0.04070838f, -0.01774917f, -0.03488720f, 
    0.02014207f, -0.00225348f, -0.02798519f, -0.04838603f, -0.00942669f, 0.01407280f, 0.00970018f, -0.01639571f, 
    0.00597892f, 0.01933949f, -0.00194107f, 0.02053059f, -0.00068634f, -0.02592008f, 0.00547090f, -0.00065151f, 
    0.00525209f, -0.00749242f, -0.02528513f, -0.01746582f, -0.01910923f, 0.00308434f, 0.00716236f, 0.00006450f, 
    -0.01680668f, -0.00441890f, -0.02072867f, -0.03026870f, 0.02841442f, 0.03226094f, -0.04799489f, -0.01552592f, 
    0.01873952f, -0.01977362f, 0.00083325f, -0.02823596f, -0.00910212f, 0.00130641f, 0.03823511f, -0.04441802f, 
    -0.01330535f, -0.03912700f, 0.01951049f, -0.03546968f, -0.04857418f, 0.02496929f, 0.03808246f, -0.00130814f, 
    -0.03481106f, -0.01420708f, -0.00996306f, -0.02859837f, -0.03664302f, 0.02696480f, -0.01969059f, -0.04620486f, 
    0.04361999f, -0.00872272f, -0.04010664f, 0.00929471f, -0.05695056f, -0.04529898f, 0.01365058f, -0.04870177f, 
    -0.03143306f, 0.02506820f, -0.01748143f, -0.03630564f, -0.04509008f, -0.03161094f, 0.01812812f, -0.05238996f, 
    0.04899796f, 0.02470564f, -0.01732735f, -0.02449453f, -0.02432838f, 0.00405665f, -0.05023047f, 0.02879599f, 
    0.02440263f, 0.02343852f, -0.05078031f, -0.01795254f, -0.00709195f, 0.00390368f, 0.02847042f, -0.04396958f, 
    0.04288282f, -0.00015489f, -0.04160978f, 0.02947046f, 0.03474831f, 0.00826402f, 0.02919613f, -0.02444315f, 
    0.01268053f, -0.01131452f, -0.04534718f, 0.04138950f, -0.00604512f, -0.03783889f, 0.02724971f, -0.00926630f, 
    0.04248374f, 0.00523384f, 0.03014869f, 0.00226515f, -0.03102998f, 0.02254202f, 0.00367757f, 0.02283721f, 
    -0.04282210f, -0.00036735f, -0.00555779f, -0.01456586f, 0.02722777f, -0.03484144f, -0.02529684f, -0.03641183f, 
    -0.02548646f, 0.03925325f, 0.02412329f, 0.02170170f, -0.00305301f, -0.04107817f, -0.02435142f, -0.03499119f, 
    0.02323342f, 0.01904649f, 0.01300791f, -0.03259931f, 0.03180648f, 0.02920529f, -0.02142271f, 0.02250699f, 
    0.04437410f, 0.00143710f, 0.01107923f, 0.01659708f, -0.03816024f, 0.01752536f, -0.04199250f, -0.03582385f, 
    -0.03752299f, -0.03082067f, -0.04656217f, -0.05266436f, -0.02451687f, -0.00861400f, 0.01814770f, -0.01690189f, 
    0.02393683f, 0.00244646f, 0.03173860f, 0.01654585f, 0.01720416f, -0.04312883f, 0.02926450f, -0.03267597f, 
    -0.00533454f, -0.05571935f, -0.04040327f, -0.03141811f, 0.02672323f, 0.02344598f, -0.03985691f, -0.03037069f, 
    -0.05580364f, -0.04894339f, -0.00927985f, -0.00093060f, -0.00684456f, -0.05191207f, 0.03258691f, -0.01351112f, 
    0.01675552f, 0.02973257f, -0.02426264f, -0.03267340f, 0.02272346f, -0.02845911f, -0.00100702f, -0.04731824f, 
    -0.00922175f, 0.03871154f, -0.04623479f, -0.00475820f, -0.02525710f, 0.03309085f, -0.00857680f, 0.03583988f, 
    0.04299705f, -0.04856887f, 0.04171602f, 0.04148536f, -0.02997726f, 0.01009101f, -0.04120428f, -0.02562346f, 
    0.00541765f, 0.04024109f, 0.04217377f, 0.00885737f, 0.03552826f, -0.02184041f, -0.01167581f, -0.03596945f, 
    0.02584970f, 0.02346089f, -0.00777457f, 0.03687015f, 0.04073323f, 0.02621320f, -0.01271392f, 0.03814967f, 
    -0.01363167f, -0.04112979f, -0.02245381f, -0.05441543f, 0.00635943f, 0.01647309f, 0.02848716f, -0.02055548f, 
    0.29596537f, -0.02066519f, 0.16415846f, 0.18489839f, -0.03387263f, -0.15172064f, -0.02310614f, -0.07375718f, 
    0.02294184f, -0.08357611f, -0.05509632f, 0.08601313f, -0.18839902f, -0.00329168f, 0.10046457f, 0.40109542f, 
    -0.10860670f, 0.03376166f, -0.00672177f, 0.01199040f, 0.03847797f, 0.14879352f, -0.04095820f, -0.01488168f, 
    0.17074066f, 0.05001594f, 0.03326013f, -0.08068947f, -0.08680718f, -0.08399706f, 0.03869843f, -0.09311402f, 
    0.03531205f, -0.16243833f, -0.12690619f, 0.04949966f, -0.44264814f, 0.01779318f, 0.06251778f, 0.18634582f, 
    -0.02642244f, -0.03350879f, 0.13026789f, 0.02958344f, -0.02860518f, -0.08811544f, 0.23749320f, -0.17755200f, 
    -0.11339602f, 0.15118581f, 0.27968419f, 0.10375354f, 0.02716356f, 0.16118923f, -0.00167994f, -0.02049602f, 
    0.03445811f, 0.09508634f, 0.02978599f, 0.07836118f, -0.14074901f, -0.03107239f, 0.11495997f, 0.11130796f, 
    0.20815536f, 0.08990914f, -0.09300160f, 0.01781988f, 0.00694947f, -0.03347849f, 0.16481675f, -0.16630374f, 
    -0.06649859f, -0.01693325f, -0.09577912f, 0.04946377f, 0.18879518f, 0.17940620f, 0.01794827f, 0.02982021f, 
    0.02426458f, -0.03136169f, 0.02894169f, 0.00242000f, -0.28805718f, -0.02044516f, 0.07156465f, -0.13902077f, 
    0.02078850f, 0.15678535f, -0.02818322f, -0.02356105f, 0.00482616f, -0.02437211f, 0.08754431f, 0.08006229f, 
    -0.23017378f, -0.14784481f, -0.19757856f, 0.22814229f, -0.08090576f, 0.09249351f, 0.03058734f, -0.07870308f, 
    0.10787681f, 0.05446127f, -0.01291132f, 0.07594083f, -0.14459619f, -0.09902348f, 0.06022735f, 0.05011690f, 
    0.18998031f, 0.16339998f, -0.04370758f, 0.17805736f, 0.11555939f, 0.01594167f, 0.01198114f, -0.11994621f, 
    -0.05550451f, 0.19894157f, 0.08609270f, -0.15183878f, 0.07884230f, -0.04154197f, 0.20660697f, -0.10722753f, 
    -0.04401128f, 0.04472861f, 0.02260193f, 0.03834012f, -0.15590653f, 0.23255944f, 0.06269124f, 0.05480050f, 
    0.02647005f, 0.00243358f, -0.05291038f, 0.10260087f, 0.10820828f, 0.02814844f, 0.07516294f, -0.02943452f, 
    0.08047986f, -0.02881223f, -0.10047729f, -0.07512841f, 0.21224706f, 0.01574661f, -0.02568847f, -0.03668448f, 
    0.09783428f, 0.07453970f, -0.07130104f, -0.07776169f, 0.02781182f, 0.13268098f, -0.04339036f, 0.14192052f, 
    -0.03876187f, -0.07969883f, -0.07871496f, 0.00072500f, 0.12994435f, -0.07810507f, -0.00974600f, 0.06797028f, 
    0.34902164f, -0.15967134f, 0.17007518f, -0.36242309f, 0.01124526f, -0.06041434f, -0.16172104f, 0.11174013f, 
    0.11777938f, -0.02945621f, -0.02439066f, 0.06772935f, -0.02096986f, -0.13427815f, -0.04081954f, -0.37396151f, 
    0.10076322f, 0.03032991f, 0.10365593f, 0.06912766f, 0.04582231f, 0.14356831f, -0.03058167f, 0.06063545f, 
    -0.31513888f, -0.13007042f, -0.02429087f, 0.30973226f, -0.05599997f, -0.18297644f, 0.03516563f, -0.02577135f, 
    -0.04732617f, -0.07772823f, 0.12363204f, -0.09095767f, 0.05931355f, -0.03302539f, 0.07812665f, -0.10397579f, 
    0.00893282f, 0.01184752f, -0.08881158f, -0.00680216f, 0.06032166f, 0.11112395f, -0.02799873f, 0.18930183f, 
    -0.11655241f, -0.10046861f, 0.09983423f, 0.36648038f, -0.02505205f, -0.04125275f, 0.04312435f, -0.00091641f, 
    -0.00245458f, -0.00715057f, 0.03823417f, 0.05250710f, -0.09565997f, 0.31336254f, 0.05207774f, -0.09819146f, 
    0.16958976f, -0.00472414f, 0.19055687f, -0.13372068f, 0.06270950f, -0.10598958f, 0.18774940f, 0.00025013f, 
    0.11773604f, -0.10372526f, 0.06865373f, 0.18216170f, -0.02226058f, -0.04964818f, -0.06767811f, 0.00362254f, 
    -0.07719021f, -0.07516696f, 0.00694053f, -0.02637256f, -0.27984905f, 0.02538773f, -0.05997119f, -0.20649831f, 
    0.13408059f, -0.05194583f, 0.04149500f, 0.05158570f, 0.00313255f, 0.07908715f, 0.06087509f, -0.01983304f, 
    -0.04078116f, 0.31044200f, 0.07945932f, 0.17368107f, 0.14994659f, -0.08782723f, -0.05997024f, 0.03435850f, 
    0.01871374f, -0.06322210f, -0.01034191f, -0.07323378f, -0.06192016f, 0.22848672f, -0.08364432f, -0.08852942f, 
    0.25866061f, 0.06955982f, 0.04655058f, -0.07647280f, -0.01210736f, -0.15813453f, -0.06842382f, 0.08743824f, 
    -0.09235405f, 0.32558438f, -0.06870128f, -0.20722032f, 0.07425280f, -0.09289500f, 0.08847778f, 0.05783869f, 
    0.08588929f, 0.02351554f, -0.00020566f, 0.02846037f, -0.13415338f, 0.11719935f, -0.03907522f, 0.37927145f, 
    0.02560317f, 0.04975849f, 0.06215014f, 0.11290392f, -0.12676413f, 0.06801092f, -0.00773893f, 0.11620188f, 
    -0.18201213f, -0.19036533f, 0.08096495f, -0.03926565f, -0.04283547f, -0.03659262f, 0.14954586f, -0.03903369f, 
    0.08992109f, -0.04100005f, -0.00578040f, 0.01593869f, 0.03499139f, -0.06252594f, 0.19002742f, 0.27933663f, 
    0.08564178f, 0.10253780f, 0.04059685f, 0.07026748f, -0.03867422f, -0.00278202f, -0.14992972f, 0.02403863f, 
    0.20035657f, -0.02137737f, 0.10005976f, 0.00872883f, -0.05962911f, 0.15393037f, -0.03473910f, 0.11800268f, 
    0.06122016f, 0.02552827f, 0.00194007f, 0.10314778f, -0.22488721f, -0.16476573f, -0.07463799f, 0.04304948f, 
    0.00494900f, 0.08493144f, 0.07022119f, -0.08470627f, -0.02808059f, -0.06036507f, 0.05746144f, 0.01621626f, 
    -0.13326645f, 0.45647231f, 0.06737094f, -0.09179576f, 0.00651988f, -0.04082986f, -0.03213056f, 0.02693692f, 
    -0.02781437f, 0.01367553f, -0.02906107f, -0.07916347f, -0.12018953f, -0.26615816f, 0.27385429f, 0.06104608f, 
    -0.03823217f, -0.01825303f, -0.04366463f, -0.02747994f, 0.06259242f, -0.03921554f, -0.04735985f, -0.09976880f, 
    -0.05329596f, 0.02890145f, -0.03474303f, -0.00224469f, 0.10469414f, -0.03771112f, -0.01383844f, -0.10885853f, 
    0.06790184f, 0.04399866f, 0.15781915f, 0.00786599f, -0.18479820f, -0.17339630f, -0.18241882f, 0.03503697f, 
    0.08659644f, 0.05450907f, -0.11447530f, 0.09043774f, 0.00939921f, -0.02437462f, 0.08138424f, 0.14003278f, 
    -0.11919856f, -0.17083171f, 0.02013263f, -0.08522426f, 0.10755224f, 0.06298196f, -0.15289766f, -0.21630436f, 
    0.04205818f, 0.10436035f, 0.00652688f, 0.10450188f, -0.43644658f, -0.07782827f, -0.24796565f, -0.12519734f, 
    0.02176545f, 0.02405379f, 0.09076393f, -0.08908483f, 0.01140307f, -0.09161976f, 0.02196993f, -0.07330301f, 
    -0.13935299f, 0.15069294f, -0.02327948f, 0.14584093f, -0.01011800f, 0.13030268f, -0.03088811f, 0.03950587f, 
    0.11169442f, 0.03984853f, 0.03493143f, 0.08602430f, 0.47278517f, 0.00813377f, 0.24735506f, 0.52709359f, 
    -0.04937930f, 0.17520849f, -0.01355551f, 0.02007697f, 0.00984372f, 0.00094271f, -0.03429885f, 0.07692014f, 
    0.29696375f, -0.01375585f, 0.18398938f, 0.12741791f, 0.07466962f, 0.00901347f, 0.08744476f, -0.00527858f, 
    0.12643363f, 0.02903451f, -0.05581583f, 0.16099426f, 0.26395774f, 0.01204004f, 0.12740597f, 0.12771486f, 
    0.00604655f, 0.01086723f, 0.06201962f, -0.03786645f, 0.12427231f, -0.16358046f, 0.01030737f, 0.13358912f, 
    0.28288734f, 0.52934432f, -0.22107293f, 0.12742789f, -0.10051268f, -0.11663748f, -0.23492917f, -0.00400464f, 
    0.13747525f, 0.06712661f, -0.05318578f, 0.04777842f, -0.29455414f, 0.04680250f, -0.05466696f, -0.06732069f, 
    0.06991269f, 0.14686424f, -0.07012016f, 0.02346319f, -0.05098194f, 0.09419967f, 0.18063998f, -0.11381745f, 
    0.10407319f, 0.16513899f, 0.15354005f, 0.00772545f, 0.02139106f, -0.05608030f, 0.01619346f, -0.04446626f, 
    0.02677833f, 0.06865937f, 0.30431390f, -0.07532857f, 0.42253137f, 0.25603595f, -0.09717610f, 0.31533694f, 
    0.07873270f, 0.17990461f, -0.14102645f, 0.04414460f, 0.14036974f, 0.07373627f, 0.01803258f, 0.11870070f, 
    0.16995415f, -0.13599247f, -0.21252577f, 0.33168486f, -0.03685569f, 0.00111852f, -0.03203406f, 0.03341680f, 
    0.03261596f, 0.00706515f, -0.04712427f, -0.17400196f, 0.02621902f, -0.03727956f, 0.01411019f, 0.16788384f, 
    -0.16279447f, -0.03018389f, -0.18941219f, -0.08972709f, 0.00922739f, 0.01823994f, 0.05352256f, 0.06578811f, 
    0.27165353f, -0.08851929f, 0.14735430f, 0.15942590f, -0.16435194f, -0.04758021f, -0.02821412f, 0.10304468f, 
    -0.07527450f, 0.21154657f, -0.03580637f, -0.06338409f, -0.09048640f, -0.06871501f, 0.13557726f, 0.00368449f, 
    0.03554647f, -0.04410240f, 0.25107887f, 0.13370368f, -0.19314812f, -0.07055356f, 0.13143052f, 0.07448559f, 
    -0.08192080f, -0.01708133f, -0.25463179f, -0.00345666f, 0.11488805f, 0.11867490f, 0.07898621f, -0.20182903f, 
    0.06312592f, 0.11327601f, -0.08377659f, 0.01610336f, 0.09179109f, -0.03534530f, 0.04985534f, 0.02125911f, 
    -0.05083307f, 0.08356234f, -0.02488667f, 0.04109701f, 0.00371671f, 0.06429034f, 0.01464020f, 0.00805128f, 
    -0.19880459f, -0.19293763f, -0.08441198f, -0.22930177f, -0.02777912f, 0.18911798f, -0.21143346f, -0.07419312f, 
    -0.02679331f, 0.00480455f, 0.01259723f, -0.01235888f, 0.36603835f, -0.01722345f, 0.04082344f, 0.33214292f, 
    0.07025913f, -0.08926071f, 0.11536741f, -0.05699964f, 0.05737486f, -0.12004274f, 0.03559738f, 0.15936497f, 
    0.07079461f, -0.09873345f, 0.20047680f, 0.22883904f, -0.08531279f, 0.03657563f, -0.01035692f, 0.16293249f, 
    -0.08076991f, 0.03563146f, 0.07100915f, 0.02578729f, -0.59755582f, 0.03208707f, 0.19281480f, -0.16042127f, 
    0.15966748f, 0.05676650f, 0.06591110f, 0.09713708f, -0.01059055f, 0.01087505f, -0.03298640f, 0.00924890f, 
    -0.22447470f, -0.11642698f, 0.10085338f, -0.04999312f, 0.21166512f, 0.09932203f, -0.05714356f, -0.06509031f, 
    0.20883027f, 0.03525057f, 0.14852980f, 0.00837348f, 0.36576623f, -0.06133022f, 0.12704557f, 0.16088484f, 
    0.00210736f, -0.09834938f, -0.08956247f, 0.08021161f, -0.04472286f, -0.13538945f, -0.07679324f, -0.07559010f, 
    -0.11812861f, 0.09215029f, 0.11585947f, 0.10613602f, 0.00907128f, -0.04442134f, -0.01899647f, -0.11268319f, 
    -0.05987117f, 0.05004916f, 0.02016058f, 0.12976456f, 0.22721626f, 0.29258668f, -0.09292199f, -0.11897669f, 
    -0.05177300f, 0.22305627f, -0.16016656f, 0.09615389f, -0.05768107f, 0.06817437f, -0.02678664f, 0.19175562f, 
    -0.44764832f, 0.18303835f, 0.14206512f, -0.02692981f, -0.06000429f, 0.05129829f, 0.03941344f, 0.09674276f, 
    0.12943977f, -0.02556587f, -0.04569470f, -0.05126546f, -0.21018130f, -0.03538794f, -0.27570030f, -0.16009340f, 
    0.10458472f, 0.06982040f, 0.14383084f, 0.07213485f, -0.04222086f, 0.02538897f, -0.20569159f, -0.03433606f, 
    0.01412006f, -0.09263137f, 0.02343847f, 0.12492064f, -0.06065253f, 0.07687522f, 0.09911291f, 0.16496846f, 
    0.01419738f, -0.00084911f, -0.09110594f, 0.06309532f, 0.54753530f, 0.02618686f, -0.12471259f, 0.20558414f, 
    0.05780429f, 0.03758128f, 0.11120755f, -0.01744486f, 0.14516802f, -0.12643547f, 0.01347705f, 0.13579071f, 
    -0.49227557f, 0.04424991f, -0.13920189f, 0.09422252f, 0.18165193f, -0.10117152f, -0.05874200f, 0.05919746f, 
    -0.04077501f, 0.09425383f, 0.05534760f, -0.00884597f, -0.00802775f, -0.12160660f, -0.10839149f, 0.17391472f, 
    0.03146482f, -0.05676058f, 0.07493435f, 0.08500899f, -0.15866539f, 0.04675865f, 0.08656731f, 0.07402386f, 
    -0.30302989f, 0.32750621f, 0.00168114f, -0.01355554f, 0.04073624f, -0.06788796f, 0.07376700f, -0.03495436f, 
    -0.15187190f, 0.03337722f, -0.09838507f, -0.02796601f, -0.34715319f, -0.17600457f, 0.08915732f, 0.09824559f, 
    -0.05076346f, 0.02541196f, 0.02537081f, 0.06115140f, 0.08370876f, 0.05487081f, 0.11418698f, 0.15619206f, 
    -0.04444831f, 0.05340436f, 0.06172352f, -0.10525537f, 0.02548567f, 0.10004848f, -0.05160077f, 0.08842070f, 
    -0.09594964f, -0.02978679f, -0.02873947f, -0.06512477f, -0.00260844f, 0.00912571f, -0.19857110f, 0.11051193f, 
    0.14910735f, 0.06880311f, -0.06286397f, 0.01527451f, 0.00928473f, -0.06682256f, 0.10741162f, 0.08079150f, 
    0.10374893f, 0.20346798f, -0.03258862f, -0.30988064f, 0.15625685f, 0.02676872f, -0.02243969f, 0.02066556f, 
    0.12716949f, -0.02403717f, -0.04901916f, 0.19590817f, -0.18784547f, 0.19420728f, 0.27685177f, 0.25557107f, 
    -0.12001462f, -0.05303121f, -0.06606056f, 0.04776587f, 0.20239022f, -0.05234863f, 0.07709648f, -0.18676108f, 
    0.14562950f, -0.07432450f, 0.08968909f, 0.27020156f, -0.10552322f, 0.02189189f, 0.08823368f, 0.04615590f, 
    -0.07114644f, -0.08328825f, -0.01622212f, -0.17133503f, -0.10159118f, -0.17216077f, 0.06936526f, 0.34224787f, 
    -0.09676453f, 0.04874100f, 0.13340169f, 0.16451681f, 0.14790262f, 0.02446631f, 0.04728445f, -0.01537079f, 
    -0.08619998f, -0.29038203f, -0.02086621f, 0.00986257f, -0.25930327f, 0.14247014f, 0.16286644f, 0.10415496f, 
    0.06543995f, -0.01051002f, 0.01256656f, 0.00886272f, -0.07855826f, 0.10068441f, 0.10718643f, -0.10193197f, 
    -0.12767673f, 0.07038215f, 0.15096974f, 0.25766394f, -0.08952840f, 0.08892080f, 0.03792630f, 0.07395828f, 
    0.02695685f, -0.15955496f, -0.22153968f, 0.18258932f, 0.12979646f, -0.02425832f, 0.20239194f, 0.11562532f, 
    0.11961366f, 0.16736303f, -0.00675663f, 0.22847699f, 0.24552578f, -0.02460903f, 0.08041787f, -0.14705366f, 
    -0.02804686f, 0.02904394f, 0.10314249f, 0.09024412f, -0.14552152f, 0.08580390f, -0.14349300f, -0.08509451f, 
    0.08427517f, -0.00975172f, 0.25739479f, 0.49167284f, -0.05430332f, 0.12070202f, 0.11224993f, 0.05937511f, 
    0.18520251f, 0.00764689f, 0.08549368f, 0.21744788f, -0.03300405f, -0.07398310f, 0.06124108f, 0.07582171f, 
    0.11675602f, 0.07535549f, -0.05477110f, 0.08413140f, 0.28346741f, -0.15629703f, -0.04537304f, -0.00015453f, 
    -0.18675853f, -0.03590151f, -0.01033300f, -0.43125382f, -0.02839752f, 0.12187529f, -0.04577722f, 0.04044124f, 
    -0.01602085f, -0.08468574f, 0.07135984f, -0.04496264f, 0.01408028f, 0.19469589f, -0.18186569f, -0.47601697f, 
    0.05509329f, -0.01489005f, -0.09786135f, -0.06216350f, 0.01993137f, -0.00206315f, -0.05088638f, 0.04228743f, 
    -0.46077606f, -0.45628056f, -0.11422907f, 0.16126411f, 0.04092081f, -0.11992502f, 0.05764868f, -0.01956330f, 
    -0.02812028f, -0.02772291f, 0.21362713f, 0.09568560f, 0.12087498f, 0.10258063f, 0.12173508f, 0.22716096f, 
    -0.11040105f, 0.04598496f, 0.10502633f, 0.11452977f, 0.01545433f, 0.09480866f, 0.24795428f, 0.18072622f, 
    -0.03625190f, 0.00781617f, 0.04194586f, 0.23377490f, 0.01581723f, -0.24214208f, 0.11397692f, 0.07347016f, 
    -0.00991532f, 0.04052721f, -0.02743018f, -0.00122489f, 0.63213962f, -0.02130576f, 0.13781887f, 0.04845938f, 
    0.12587339f, -0.02292327f, 0.01387156f, 0.14503497f, 0.12493041f, 0.08253062f, 0.03749962f, 0.03009163f, 
    0.12116815f, 0.01156449f, -0.03896972f, -0.01081267f, -0.11226886f, 0.00714653f, 0.06506841f, -0.00688346f, 
    0.06535392f, -0.09185430f, -0.06445974f, 0.06153724f, -0.12403493f, 0.01320237f, 0.12377347f, 0.14658701f, 
    0.01995504f, -0.04113575f, 0.03176311f, 0.08409302f, -0.03118802f, 0.10264454f, 0.11213370f, -0.09751716f, 
    0.16262811f, 0.15546295f, -0.10277246f, 0.03516338f, -0.03957722f, 0.11186907f, 0.06654160f, 0.09819933f, 
    -0.02364595f, 0.06485667f, 0.15564708f, 0.00060068f, 0.13312867f, -0.15996407f, 0.00605001f, 0.07623925f, 
    -0.16592279f, -0.12817381f, -0.09514140f, 0.09261114f, 0.01930504f, -0.18422253f, -0.03343590f, -0.04089323f, 
    -0.02645394f, 0.08245032f, -0.26495743f, 0.05387418f, -0.01069197f, 0.05611232f, 0.03779006f, 0.15276957f, 
    0.02675908f, -0.02213372f, 0.11214842f, -0.00500769f, -0.10864960f, -0.03323574f, 0.06866784f, 0.20680825f, 
    -0.11889578f, -0.04229244f, 0.22459003f, 0.04945699f, 0.02383346f, 0.02420197f, 0.14513302f, 0.01755082f, 
    0.07093261f, 0.25312832f, -0.18217555f, -0.29804888f, 0.13608065f, 0.12705009f, 0.20472331f, -0.04897308f, 
    0.05964351f, -0.08240532f, -0.08076534f, 0.03564765f, -0.20432375f, -0.31764206f, 0.10611964f, 0.13035247f, 
    -0.01744955f, -0.00277290f, -0.00305401f, 0.10306963f, 0.01042738f, -0.12425100f, 0.04842734f, 0.04740590f, 
    0.06105925f, -0.09315697f, -0.07829438f, -0.32315323f, -0.04277392f, 0.17473342f, -0.12764083f, 0.04288220f, 
    0.03494168f, 0.10470764f, -0.02844757f, 0.17603494f, -0.01053385f, -0.14078678f, 0.03462901f, 0.03808727f, 
    0.00090046f, -0.00518998f, -0.05063045f, -0.09591846f, 0.07542720f, -0.02430901f, -0.11239694f, 0.02312426f, 
    0.17256543f, 0.19222052f, -0.00389202f, 0.08631457f, -0.05592526f, 0.09669185f, 0.01011307f, -0.03009904f, 
    0.02409115f, -0.03462410f, -0.03579501f, 0.07234860f, -0.60917008f, -0.00165446f, 0.19049501f, 0.14214580f, 
    0.08992446f, 0.10261247f, 0.09721547f, -0.12290829f, 0.12961832f, -0.03969958f, -0.04322441f, -0.02941354f, 
    0.03246506f, -0.10602498f, -0.16691703f, -0.08558883f, -0.01528367f, 0.18156436f, -0.17641138f, -0.12648703f, 
    -0.00820046f, 0.18277697f, 0.11129896f, 0.00269699f, 0.21252392f, 0.02475252f, -0.12676711f, -0.14619160f, 
    0.03206259f, -0.11223696f, -0.04763803f, -0.12244865f, -0.02560896f, -0.13123186f, -0.01099772f, -0.12754464f, 
    -0.20025197f, -0.03472787f, 0.02940356f, 0.14646277f, 0.09304950f, 0.00232809f, 0.07531675f, 0.08978155f, 
    0.09087547f, 0.19202523f, 0.09632626f, 0.07494684f, 0.10954330f, -0.01757253f, -0.03061221f, 0.08871320f, 
    -0.09164174f, -0.01347133f, 0.03015796f, 0.05919154f, 0.06635390f, 0.01508563f, -0.10475878f, -0.01767651f, 
    0.08416200f, 0.04230629f, -0.02528018f, 0.08391713f, 0.11610720f, 0.02997069f, 0.11412079f, 0.04498756f, 
    0.05441922f, -0.27066728f, 0.02907993f, 0.04698159f, -0.13185155f, 0.32048196f, 0.17929855f, 0.15047522f, 
    0.05825000f, 0.16895880f, 0.00242978f, -0.00756913f, 0.17446317f, 0.11712785f, 0.07436346f, 0.26646399f, 
    -0.00125376f, -0.05356925f, 0.24947144f, -0.09296367f, 0.10300962f, -0.13722222f, 0.05557743f, 0.08878059f, 
    0.18712947f, 0.22929846f, 0.11858479f, 0.31870490f, -0.04702139f, -0.17751274f, 0.19719845f, 0.04848678f, 
    0.25260967f, -0.00169574f, 0.03224113f, -0.13618048f, -0.04957717f, -0.16160879f, 0.01728230f, 0.09501268f, 
    -0.19213910f, -0.09646245f, 0.14940089f, 0.02133534f, 0.22886238f, -0.07815396f, -0.08497364f, -0.30018616f, 
    0.00511844f, -0.03740160f, -0.00496498f, 0.08380149f, -0.09867445f, 0.00592297f, -0.17205368f, 0.27416632f, 
    -0.03115212f, -0.17995377f, -0.07427952f, 0.05417632f, -0.01524212f, 0.13756655f, -0.12891750f, -0.03490501f, 
    0.21826500f, 0.09843209f, 0.15272023f, -0.10963820f, 0.10460950f, -0.01333403f, -0.16822273f, 0.09386172f, 
    -0.00101153f, 0.06589334f, -0.12585908f, -0.21069911f, -0.09666616f, -0.15464123f, -0.17624816f, -0.06717978f, 
    0.10555539f, 0.14791285f, -0.00824888f, -0.07742147f, 0.09666824f, -0.04965772f, 0.02511694f, 0.11359245f, 
    -0.04678569f, 0.03206404f, 0.20118485f, 0.01234182f, 0.03170326f, 0.06238490f, 0.04891856f, 0.11812434f, 
    0.00554806f, 0.00624743f, -0.17449777f, -0.14001052f, 0.13032971f, -0.02162053f, 0.04898547f, -0.11787118f, 
    0.05698651f, 0.11863685f, -0.06358373f, 0.02601932f, -0.17198476f, 0.17835994f, 0.30835742f, 0.16008839f, 
    -0.43779022f, 0.01225734f, -0.19565994f, -0.02536904f, -0.07619439f, 0.04885608f, 0.07846113f, 0.08414673f, 
    -0.01584039f, -0.07567290f, -0.20304665f, -0.14741002f, -0.36270171f, -0.01768524f, 0.07028084f, -0.03850722f, 
    0.14502315f, -0.08476432f, 0.12269107f, -0.05727969f, -0.01458532f, 0.09430497f, 0.06127680f, 0.01013537f, 
    0.29806682f, -0.03754320f, -0.13906279f, -0.12748516f, -0.02338912f, 0.13356946f, -0.11590661f, -0.16827220f, 
    0.23446019f, -0.10145546f, -0.16125704f, -0.01797905f, 0.14459564f, -0.00918535f, 0.04399393f, 0.11482726f, 
    0.03996416f, 0.22017783f, 0.09272082f, -0.12867889f, 0.12600242f, -0.04423293f, -0.13416217f, 0.04113971f, 
    0.04209270f, 0.03007336f, -0.03626325f, 0.04042985f, 0.02129536f, 0.28381819f, -0.06413759f, 0.09221646f, 
    0.04572420f, 0.00878902f, 0.24066927f, -0.00861713f, -0.24322712f, -0.19697578f, 0.20747198f, -0.03461645f, 
    0.14289249f, -0.06427214f, 0.08045083f, -0.17682020f, 0.11730248f, 0.07337704f, -0.22114171f, 0.02787773f, 
    -0.30512789f, 0.23464556f, -0.22823146f, 0.06692400f, 0.05999702f, 0.01738726f, 0.17407399f, 0.10841402f, 
    0.08541299f, 0.23533773f, 0.09042957f, 0.09547343f, -0.25033727f, -0.02075206f, -0.01655942f, -0.04318968f, 
    0.12786181f, 0.02040747f, -0.09909865f, 0.01694643f, 0.02050542f, 0.05249353f, 0.02012962f, 0.14230907f, 
    0.01696803f, -0.12491094f, -0.04736561f, -0.10993830f, 0.11271890f, 0.08019875f, 0.05259071f, 0.02342088f, 
    -0.01459841f, 0.20720759f, 0.14599046f, 0.19845438f, -0.06111562f, -0.03723992f, 0.15775970f, -0.01931035f, 
    0.09553456f, 0.05979150f, 0.04184816f, 0.14143591f, 0.01389580f, 0.19257595f, 0.20279877f, 0.15470733f, 
    0.03633805f, 0.19702311f, 0.09843648f, 0.10765933f, -0.01085782f, 0.07591999f, -0.04631392f, 0.01062204f, 
    -0.05473070f, 0.12501110f, -0.08202861f, -0.04837244f, 0.01609448f, 0.12419131f, -0.10552621f, 0.06898027f, 
    0.10665888f, 0.06346749f, -0.18940166f, -0.09423819f, -0.03844468f, 0.01584716f, 0.01019764f, 0.09738699f, 
    -0.21559720f, -0.09254607f, -0.07988094f, 0.06601121f, -0.00911808f, 0.07794734f, -0.14015874f, 0.16364814f, 
    0.23262961f, 0.20453665f, 0.04579575f, 0.04730323f, -0.10689613f, 0.00097243f, -0.27840760f, -0.13987978f, 
    -0.08930939f, 0.10372861f, 0.00360758f, -0.00554836f, 0.07427500f, 0.01306223f, -0.13742656f, -0.02455705f, 
    -0.05397879f, -0.20716949f, -0.01102815f, -0.19424544f, 0.09161610f, 0.00072786f, 0.09489270f, -0.01348107f, 
    0.01244373f, -0.08710688f, -0.11545350f, 0.04057663f, 0.13532941f, 0.04471635f, -0.19575021f, 0.08228369f, 
    0.15573530f, 0.00600543f, 0.15012223f, -0.05320197f, 0.16190809f, -0.12830980f, 0.15947436f, -0.04353701f, 
    0.05810823f, -0.08224596f, -0.02386110f, -0.13804853f, -0.03334740f, -0.05111674f, -0.07608385f, 0.22965710f, 
    0.07519114f, -0.02496777f, 0.18495804f, -0.15778323f, 0.08750725f, 0.16497713f, -0.09120382f, 0.01187332f, 
    0.02425578f, -0.05736000f, 0.11876157f, 0.16170007f, 0.08273159f, 0.06966078f, 0.13005446f, 0.09638189f, 
    0.03558712f, -0.00127852f, 0.04058314f, -0.01554037f, -0.00480277f, -0.00801163f, 0.01076028f, -0.00838298f, 
    -0.00901909f, -0.02749684f, 0.02381148f, 0.00521914f, 0.01439623f, -0.05398022f, 0.03063551f, -0.03720452f, 
    -0.00551490f, 0.00840344f, 0.04458559f, -0.02212889f, -0.02296099f, 0.00848840f, -0.01404188f, 0.03315433f, 
    -0.05496677f, 0.01270303f, -0.03122221f, -0.01268623f, -0.00479578f, -0.01951650f, -0.03543446f, 0.00776455f, 
    -0.05181790f, -0.02732182f, -0.03603626f, 0.03854701f, -0.03748738f, -0.00886046f, 0.00033805f, -0.05136959f, 
    -0.01672911f, -0.04496849f, 0.01495975f, -0.01223743f, 0.01702235f, -0.02723073f, 0.04372973f, 0.03483668f, 
    0.00087771f, -0.00114625f, -0.00578005f, 0.02843994f, -0.02153664f, -0.05101214f, -0.00816739f, 0.00590767f, 
    -0.04114049f, 0.02678843f, 0.03743715f, -0.04622598f, 0.01753486f, -0.03273836f, -0.02933184f, 0.03173296f, 
    -0.01909711f, -0.01521020f, -0.01606072f, -0.04870883f, 0.01761327f, -0.02959589f, -0.03467143f, 0.01885020f, 
    -0.03244921f, -0.03934341f, 0.00257329f, 0.03827960f, -0.01292974f, -0.04303936f, 0.02951364f, 0.02558568f, 
    0.00721941f, 0.04442652f, 0.04246094f, 0.03972378f, 0.02603741f, -0.02588393f, -0.04654130f, 0.02810305f, 
    -0.01010549f, 0.00630228f, -0.05507341f, 0.02021984f, -0.04677411f, 0.02045772f, 0.00044734f, -0.00266799f, 
    -0.01470717f, 0.01397154f, -0.01697072f, -0.03118243f, -0.03995192f, -0.00754596f, 0.03961065f, 0.02607432f, 
    0.00247127f, 0.00661477f, 0.03760120f, -0.01733540f, 0.04844812f, -0.01837104f, -0.05530223f, 0.04011725f, 
    -0.01750240f, -0.00197979f, 0.02596597f, -0.02154909f, -0.02865032f, -0.05592379f, -0.02413059f, -0.05403355f, 
    -0.03096889f, -0.04935547f, -0.02752165f, 0.03749292f, -0.05042771f, 0.02640437f, 0.01333849f, 0.00730617f, 
    0.02170077f, -0.04146302f, -0.05387262f, -0.00009188f, -0.01192495f, -0.02554029f, -0.03647757f, 0.04155091f, 
    -0.00332785f, -0.01551243f, -0.02545027f, 0.01720158f, 0.03090193f, -0.05038279f, 0.04542888f, -0.02899504f, 
    0.00275081f, -0.04612065f, -0.02090253f, 0.01990684f, 0.01335066f, 0.02554707f, -0.04929560f, -0.00273371f, 
    -0.01840937f, 0.03929174f, -0.04562201f, -0.02968152f, -0.00291986f, -0.05255134f, -0.00023515f, 0.00797682f, 
    0.03531579f, -0.05124215f, -0.01192941f, -0.05000946f, -0.00661478f, -0.04209180f, 0.01501228f, -0.03997758f, 
    0.01543522f, 0.04432617f, -0.04412366f, 0.00201313f, -0.02564838f, -0.01038564f, -0.00388776f, 0.01862996f, 
    -0.00799389f, 0.03652425f, -0.04714100f, -0.02510558f, -0.01959123f, 0.00110277f, -0.03779892f, -0.04245730f, 
    0.03290685f, -0.00427387f, 0.00133034f, -0.00432447f, -0.01288882f, -0.02632687f, 0.03416134f, 0.01561616f, 
    -0.03145653f, -0.00613410f, -0.01315808f, 0.03441817f, 0.00315603f, -0.04474718f, 0.03827876f, -0.03493053f, 
    0.01931155f, -0.00569178f, 0.03879741f, 0.01229857f, 0.01020067f, -0.03425764f, 0.02557348f, 0.00169883f, 
    0.00082182f, -0.00959886f, -0.00240886f, 0.01903245f, 0.03682695f, -0.00566554f, 0.00149804f, -0.01002957f, 
    0.00550075f, -0.03161988f, 0.02236959f, 0.00760200f, -0.04963785f, 0.04031884f, 0.02236692f, -0.03272906f, 
    -0.04614400f, 0.00439721f, 0.00927232f, -0.01819020f, 0.02264972f, 0.02518461f, 0.03864084f, 0.00171268f, 
    -0.03932979f, 0.03821380f, -0.01576598f, -0.03883528f, -0.04291896f, -0.02163658f, 0.00529898f, 0.03736967f, 
    0.03573821f, -0.00898163f, -0.01287962f, 0.00639953f, -0.02491696f, -0.03906506f, 0.03719731f, -0.00152052f, 
    -0.02704441f, -0.04479892f, -0.03030537f, 0.01908974f, -0.05423599f, -0.00546293f, -0.00930803f, -0.02282562f, 
    0.01439154f, -0.04591691f, 0.01546315f, -0.00038352f, 0.00596731f, -0.03367154f, -0.05328411f, -0.02323382f, 
    -0.05561892f, -0.05208959f, 0.02569474f, -0.02837445f, 0.04076561f, -0.04601941f, 0.03894813f, 0.01529515f, 
    0.01073035f, -0.04242882f, 0.02814685f, 0.02274902f, -0.02219923f, -0.00435884f, 0.04031556f, -0.01149460f, 
    0.00649130f, 0.00808824f, 0.00782084f, -0.04219416f, 0.00809080f, 0.02746379f, -0.01689442f, 0.01945306f, 
    -0.02586979f, -0.03686656f, -0.04523410f, -0.03684331f, 0.00198239f, -0.04940926f, -0.02135665f, 0.01405054f, 
    0.02579628f, -0.04333131f, -0.04332348f, -0.00315104f, 0.03959572f, -0.00182180f, 0.02387591f, -0.03417062f, 
    0.03714804f, -0.03372337f, -0.04793436f, -0.04207307f, -0.01469853f, -0.03776568f, -0.02165296f, 0.01275181f, 
    0.02747677f, -0.02797705f, -0.02773828f, -0.03757619f, -0.04972625f, -0.01319435f, 0.03509132f, -0.00716260f, 
    0.00052595f, -0.05565013f, -0.02612346f, -0.01697304f, -0.00588934f, 0.00839988f, 0.03877280f, -0.00058033f, 
    -0.03580775f, 0.01604645f, 0.00049457f, -0.05600703f, -0.02416247f, -0.01050130f, -0.05024081f, -0.01774847f, 
    -0.00007817f, -0.05404163f, 0.00055937f, 0.00048499f, 0.03344852f, 0.00592746f, -0.00435106f, 0.00134876f, 
    -0.04570621f, -0.02711784f, -0.04071036f, -0.03776766f, 0.01327442f, -0.01313631f, -0.03264211f, 0.00380857f, 
    -0.00913314f, 0.00049202f, -0.02963095f, -0.01889771f, -0.04610411f, -0.00871703f, -0.04501405f, -0.03343866f, 
    -0.03766986f, 0.01667683f, -0.03794060f, -0.01978954f, -0.00501178f, 0.01990763f, -0.00687280f, -0.01821913f, 
    0.01373510f, -0.04176632f, -0.04324742f, -0.03689408f, -0.00059357f, 0.01589250f, -0.04405128f, -0.01906626f, 
    0.03452661f, -0.01174449f, 0.02267220f, 0.03198707f, 0.00122971f, -0.00419415f, 0.00908678f, 0.01789388f, 
    -0.01369075f, 0.03133737f, 0.02784358f, 0.04171395f, -0.00018748f, -0.05656362f, -0.03943203f, -0.04692838f, 
    0.03408689f, -0.00160483f, -0.00415526f, -0.02264852f, -0.01252008f, -0.05273826f, -0.03090381f, 0.00547798f, 
    -0.03602926f, 0.01209992f, 0.02474956f, -0.03976091f, 0.02362402f, 0.00173993f, -0.01857725f, 0.00654017f, 
    0.03085815f, -0.02942522f, -0.05409304f, -0.02308017f, -0.05091034f, -0.02573022f, 0.03548479f, 0.01547425f, 
    0.00521408f, -0.05396270f, -0.04492266f, -0.00094073f, 0.02975266f, -0.03296325f, 0.00561869f, 0.03392781f, 
    -0.00447928f, 0.01108151f, -0.04292466f, 0.02063562f, -0.02338096f, -0.04983931f, 0.00073163f, -0.02238157f, 
    -0.04132133f, 0.01742892f, -0.03627989f, 0.03922675f, -0.02055325f, -0.03241201f, 0.01740050f, 0.03074095f, 
    0.02629751f, 0.03736174f, 0.04654480f, -0.01933056f, -0.00171633f, 0.00247721f, -0.02723310f, 0.00109344f, 
    0.04593399f, -0.02181067f, -0.01236989f, 0.02068282f, -0.01086371f, -0.03161634f, 0.02779770f, -0.05901835f, 
    -0.01719798f, 0.03437398f, -0.01073396f, -0.02612219f, -0.03455615f, 0.03075931f, -0.04321954f, 0.03491996f, 
    -0.05389382f, 0.04460557f, 0.01737201f, -0.05548824f, 0.01267239f, -0.02865451f, -0.00616783f, -0.00171253f, 
    0.03086846f, 0.00829876f, 0.04728026f, -0.04599478f, 0.04246845f, 0.01270112f, 0.03772118f, -0.00048597f, 
    0.02534789f, -0.02723702f, -0.00411139f, 0.03418274f, -0.04143458f, -0.04265778f, -0.01317632f, -0.05767505f, 
    -0.02419905f, -0.01966435f, 0.00506251f, -0.02785745f, -0.03879939f, -0.01386887f, 0.00593077f, 0.00065400f, 
    0.04001527f, -0.03287798f, -0.03911169f, -0.00963475f, -0.02138340f, -0.01538928f, -0.01058228f, -0.02708034f, 
    -0.02420142f, -0.04658200f, -0.05534818f, 0.02620606f, -0.02335178f, 0.01402050f, 0.04448464f, 0.00390111f, 
    0.00109114f, -0.02088767f, 0.01359987f, 0.03674973f, -0.01074196f, -0.01927609f, 0.01104149f, -0.04568599f, 
    -0.01939592f, -0.05271509f, -0.00052167f, 0.00441007f, 0.00016997f, -0.03322401f, 0.02508718f, -0.04902221f, 
    -0.02968914f, 0.03963727f, 0.01141281f, -0.01324018f, 0.00407678f, -0.02983572f, -0.01324151f, -0.02513601f, 
    0.02900870f, 0.01236880f, 0.03393413f, 0.04506711f, -0.00295620f, 0.04771607f, -0.02505969f, -0.00300885f, 
    -0.00138195f, -0.04791820f, -0.05642282f, -0.03831071f, 0.02501653f, 0.01181562f, -0.05634541f, 0.00686808f, 
    0.02379812f, 0.01140183f, 0.02614269f, 0.03695257f, -0.03787673f, 0.02752024f, -0.01313360f, -0.00099373f, 
    -0.04328570f, -0.00569622f, -0.01119078f, 0.01742163f, 0.02050225f, 0.01806085f, -0.00874909f, 0.04611162f, 
    0.03525224f, 0.03708181f, -0.02172872f, 0.03628670f, 0.03886753f, -0.02878374f, -0.00867366f, -0.05000798f, 
    -0.02845606f, 0.03638845f, 0.03112178f, -0.01502099f, -0.04960458f, 0.00292283f, 0.02323128f, 0.00548855f, 
    -0.05185553f, -0.03640502f, -0.03266826f, 0.03424153f, -0.03202214f, -0.02000623f, -0.05443633f, -0.02930868f, 
    -0.01707563f, 0.01753791f, -0.03192861f, -0.05270192f, -0.05061685f, 0.01705761f, 0.01962440f, -0.05075862f, 
    -0.05211838f, -0.00857960f, 0.03520174f, 0.00804644f, 0.02891546f, 0.01753445f, -0.02672624f, -0.01251633f, 
    0.01504923f, -0.02986510f, -0.05290146f, 0.01044209f, 0.03484102f, -0.05565778f, 0.04006817f, -0.02248778f, 
    0.00220233f, 0.01300591f, 0.02302410f, 0.01266829f, 0.01940232f, -0.03228000f, 0.04829196f, 0.01036450f, 
    -0.00507767f, 0.02861094f, -0.01809100f, -0.03182252f, -0.00612234f, -0.04962151f, 0.01194878f, 0.02507378f, 
    -0.05328402f, 0.00033275f, -0.01387721f, -0.04631077f, -0.04057170f, -0.03670391f, -0.03036952f, 0.02002445f, 
    -0.05304279f, -0.01808226f, 0.02668614f, 0.00648682f, 0.01646437f, -0.04518230f, -0.02690383f, 0.04600805f, 
    -0.04092745f, -0.00383940f, 0.01918740f, -0.01142695f, 0.03146628f, -0.00849340f, 0.03889432f, 0.00130002f, 
    -0.00327176f, 0.02532898f, 0.01693286f, 0.00721599f, -0.01064653f, -0.05000876f, -0.02616330f, -0.00712423f, 
    -0.04455072f, 0.00646920f, -0.01782271f, -0.00393304f, 0.04220392f, 0.00734812f, -0.02093776f, 0.01328607f, 
    -0.05181733f, 0.04301338f, -0.01910932f, -0.01562558f, -0.03052961f, -0.03402834f, -0.05832335f, -0.01536873f, 
    -0.00751576f, -0.03296050f, 0.00023667f, 0.00948668f, -0.04068981f, -0.04290529f, -0.05588031f, 0.00941931f, 
    0.01926843f, -0.02983828f, -0.04338427f, -0.00154292f, 0.03962328f, -0.04229426f, 0.00439969f, 0.01659024f, 
    0.02826329f, 0.02120011f, -0.02326495f, -0.03865456f, -0.04891233f, 0.03411106f, 0.04147865f, 0.03346050f, 
    0.02380202f, -0.03203209f, 0.02347401f, 0.03134285f, -0.00728314f, -0.05037179f, -0.00421336f, -0.04026309f, 
    0.01703364f, -0.04945222f, -0.00133812f, 0.02389092f, -0.00060687f, -0.01571109f, -0.05455140f, -0.04333333f, 
    -0.00161138f, 0.04564396f, 0.05319095f, -0.03704415f, 0.01491911f, -0.00950368f, -0.05675147f, -0.00627621f, 
    0.02230204f, -0.01083013f, 0.00617628f, 0.02488656f, 0.02187784f, 0.02950173f, 0.02942611f, 0.03576561f, 
    -0.03908560f, -0.04712666f, -0.05837490f, -0.04011939f, 0.03632021f, 0.00177127f, -0.02804204f, 0.00350517f, 
    0.00868704f, -0.03825341f, -0.04499624f, -0.05188444f, -0.03773166f, 0.01218592f, -0.04636357f, 0.03407156f, 
    0.00996033f, 0.02887111f, 0.00061109f, 0.01999803f, 0.02002388f, 0.00319269f, 0.00137154f, 0.01382311f, 
    -0.00442887f, -0.00038638f, -0.00604068f, -0.04785047f, 0.03728393f, 0.02427987f, -0.04560204f, 0.03039674f, 
    0.39441451f, -0.08038064f, 0.13885449f, 0.07102075f, 0.02035896f, -0.07824875f, -0.00051599f, 0.03918865f, 
    -0.00692866f, -0.12782356f, 0.01148919f, 0.02076618f, -0.13094009f, 0.36536393f, 0.14534499f, 0.28374317f, 
    0.16240348f, 0.09968706f, 0.05945227f, 0.12664762f, -0.04415511f, 0.08174841f, -0.03171095f, -0.03387783f, 
    0.27424717f, 0.09622236f, -0.07206414f, -0.05603445f, 0.05034036f, -0.10363159f, -0.04144956f, -0.08260171f, 
    0.06874621f, -0.26319358f, -0.07550626f, -0.00260181f, -0.21256706f, 0.18271431f, 0.20799318f, 0.19579002f, 
    0.10218255f, 0.10313230f, -0.01877133f, 0.03637755f, -0.05710766f, 0.07211392f, 0.25632405f, -0.06713916f, 
    -0.19837302f, -0.24905366f, 0.22133550f, 0.01793657f, -0.07945200f, 0.09463432f, -0.01482648f, 0.02433959f, 
    -0.08137552f, 0.12996697f, 0.09796798f, -0.09216718f, 0.30642167f, -0.04323992f, -0.01667354f, -0.17540237f, 
    0.06537161f, -0.04187331f, -0.01836155f, 0.08956711f, -0.05366428f, -0.05973433f, 0.07167912f, -0.18309370f, 
    0.20155512f, 0.13341673f, -0.15128706f, 0.14579178f, 0.02463588f, 0.09984698f, -0.02014322f, 0.00766539f, 
    0.02080068f, -0.15842560f, -0.15064345f, -0.09789973f, -0.23143221f, 0.20525602f, -0.02589863f, -0.25425312f, 
    -0.12797968f, 0.03615322f, -0.11784048f, 0.02766226f, -0.03738193f, 0.02384802f, 0.04228203f, -0.06268275f, 
    0.44147858f, -0.07923047f, 0.07238851f, -0.30987731f, -0.04764554f, 0.06278163f, 0.07947323f, 0.09030814f, 
    -0.04369119f, -0.01925943f, -0.03236655f, -0.11590569f, -0.03834419f, 0.02466426f, 0.08853494f, 0.08594764f, 
    0.23938775f, 0.18189842f, -0.06591088f, -0.02252675f, 0.04628486f, -0.13768032f, -0.01634294f, 0.03839440f, 
    -0.06122378f, 0.27956903f, -0.04044133f, 0.06797518f, 0.02571605f, 0.08829042f, 0.10569157f, -0.02183727f, 
    -0.03482401f, 0.04669008f, 0.03445185f, 0.05019815f, -0.40385199f, 0.38398620f, 0.34562364f, -0.13292870f, 
    -0.02337972f, -0.07688372f, 0.00574615f, 0.02802006f, 0.02038738f, 0.13526356f, 0.13775982f, 0.02679137f, 
    0.25432777f, -0.03643815f, 0.13468087f, -0.01712255f, 0.08278184f, -0.00779404f, 0.06714583f, -0.04730311f, 
    0.00839183f, -0.02074978f, 0.07140166f, -0.06337911f, -0.25884888f, 0.03567489f, -0.04130821f, 0.03127686f, 
    -0.09049488f, -0.05272658f, 0.07452668f, 0.01451681f, 0.07846271f, 0.03194904f, -0.17899024f, 0.03516868f, 
    0.26947302f, -0.14357309f, 0.18361203f, -0.13971893f, 0.07850733f, -0.02649018f, -0.03003443f, -0.05832065f, 
    0.11422540f, 0.05357915f, 0.01915397f, 0.13986945f, -0.12187707f, 0.07942783f, -0.08592357f, 0.16037439f, 
    -0.03291181f, 0.01786909f, -0.10136522f, 0.18322529f, -0.07671158f, 0.07247015f, -0.02822078f, 0.07107178f, 
    -0.12861742f, 0.34814712f, 0.16819389f, 0.11684085f, 0.08054847f, -0.11284085f, 0.07324313f, 0.15057373f, 
    -0.10018364f, -0.03285423f, 0.17331763f, -0.05697238f, 0.17251080f, 0.05029723f, 0.09659263f, 0.04266864f, 
    0.03516763f, -0.17437024f, -0.07632698f, -0.04301077f, -0.03854784f, -0.00059289f, 0.01619121f, -0.05440721f, 
    0.18502663f, 0.01290070f, 0.05470245f, 0.20631990f, 0.20697303f, -0.04616841f, 0.14044394f, 0.00925339f, 
    0.05701063f, -0.01495408f, -0.13664761f, 0.08573983f, 0.01554182f, 0.36113527f, -0.09699265f, -0.04302881f, 
    -0.10815271f, -0.02755921f, 0.13164760f, 0.05128348f, -0.17187989f, -0.02079156f, 0.11631514f, -0.01839861f, 
    0.04197124f, -0.23251851f, 0.24127890f, -0.20370016f, -0.07292511f, -0.08635758f, 0.02648283f, -0.12866059f, 
    -0.05809674f, -0.10185642f, -0.06660035f, -0.04433391f, -0.13067344f, -0.00143747f, -0.23662640f, -0.05887456f, 
    -0.02340386f, 0.08009291f, -0.06908894f, 0.00737415f, 0.03561155f, -0.06586026f, 0.04573720f, -0.00715705f, 
    -0.03365761f, 0.12574345f, 0.20948255f, 0.18345754f, 0.07553157f, -0.01324875f, -0.00119337f, 0.15494542f, 
    0.08905523f, -0.11135710f, -0.06603447f, -0.12648077f, 0.11645534f, 0.25978547f, -0.11021885f, -0.00880326f, 
    0.08006597f, 0.10972270f, 0.10979483f, -0.09449095f, -0.01917004f, -0.04955954f, -0.08325028f, 0.02259906f, 
    0.16531065f, 0.29522365f, -0.01836483f, -0.03626572f, 0.12382475f, -0.08880018f, 0.07798155f, 0.04640032f, 
    0.19250703f, -0.08300790f, 0.04623650f, 0.03876180f, 0.14677545f, -0.11688530f, 0.18194023f, 0.03430311f, 
    0.05799532f, -0.01523079f, 0.10164163f, 0.26898795f, -0.08609899f, 0.05589931f, 0.01127832f, -0.02902446f, 
    0.35767847f, -0.25177512f, -0.04089636f, -0.16392918f, 0.10680941f, -0.07750639f, 0.06530477f, -0.10794860f, 
    -0.00474078f, -0.15567291f, 0.05848834f, 0.00841221f, -0.07189680f, 0.20515634f, 0.19338167f, 0.25714102f, 
    0.03096550f, 0.07783831f, 0.09474169f, 0.07963126f, 0.00605148f, 0.00775501f, 0.06271058f, 0.07112043f, 
    -0.12424192f, 0.14890805f, -0.03247084f, 0.12132770f, 0.06966466f, 0.02966562f, -0.07806128f, 0.07652140f, 
    0.09024768f, 0.07778914f, -0.01548998f, -0.00785112f, 0.04969143f, 0.17210092f, 0.13218132f, -0.27919915f, 
    -0.09797826f, 0.04821524f, -0.02164231f, -0.03521606f, -0.09026419f, 0.02618891f, -0.05494856f, 0.00522935f, 
    -0.15178159f, 0.23193939f, 0.01056049f, 0.01696616f, 0.11240388f, 0.00153575f, -0.02336507f, -0.12763306f, 
    0.01482507f, 0.04500309f, -0.16953650f, 0.04331683f, -0.10468142f, -0.45060727f, 0.04064381f, -0.04570971f, 
    -0.22203009f, 0.00172259f, -0.15119602f, -0.13396846f, 0.04766523f, -0.03806913f, -0.04451941f, -0.12393252f, 
    -0.03044677f, 0.01402833f, 0.02815048f, 0.02578332f, -0.00181292f, -0.00308353f, -0.00643643f, 0.00424800f, 
    0.01784524f, 0.01366585f, -0.04959001f, -0.03254157f, -0.02285826f, 0.03786327f, -0.00008018f, 0.04326165f, 
    0.01311589f, -0.04202550f, -0.00633521f, -0.04433870f, 0.02257246f, 0.00543459f, 0.04421021f, -0.00492558f, 
    -0.02783442f, 0.00205743f, 0.04660890f, -0.05032004f, -0.03173097f, -0.00272670f, 0.02261514f, 0.00789867f, 
    -0.02688785f, -0.04718936f, -0.02696778f, 0.01066714f, -0.00917351f, 0.02878592f, -0.05096298f, -0.00525543f, 
    0.01971000f, -0.03694303f, 0.00500403f, -0.01088309f, 0.04442176f, -0.03934873f, -0.04828018f, 0.00694327f, 
    -0.02674532f, 0.03045192f, -0.04242419f, 0.03635336f, 0.03572649f, -0.01570918f, -0.03872313f, 0.02356997f, 
    -0.04685146f, -0.04859640f, -0.00790490f, -0.01194587f, -0.04395716f, 0.01052390f, -0.03346353f, -0.03363241f, 
    0.04978482f, -0.01806741f, 0.02138322f, 0.03694095f, -0.01224968f, -0.04973959f, -0.02236914f, -0.04262079f, 
    0.02550756f, -0.02885357f, -0.01561144f, -0.00843215f, -0.00508657f, 0.01963285f, -0.01578560f, -0.03678928f, 
    0.02893236f, -0.04008348f, -0.03229599f, -0.03658166f, 0.02186402f, 0.00989553f, 0.01075430f, 0.00028435f, 
    0.01194390f, -0.00150992f, 0.03627407f, -0.04713509f, 0.03157417f, -0.03810058f, 0.01227900f, -0.00045128f, 
    -0.01638918f, -0.01544801f, 0.01120766f, 0.02709953f, -0.00174635f, -0.00677830f, -0.01253247f, -0.01479290f, 
    0.00544666f, 0.01030815f, -0.00534502f, 0.04354778f, -0.02100047f, 0.04723129f, -0.01244642f, -0.03492351f, 
    -0.03499545f, 0.04183147f, -0.00994155f, -0.03449075f, 0.00124306f, 0.02842028f, -0.02379532f, -0.02155878f, 
    -0.03587406f, 0.01670758f, -0.00410979f, 0.00055800f, -0.01060303f, -0.02772677f, -0.05045274f, -0.04954281f, 
    -0.03056816f, 0.03152930f, -0.03937363f, -0.00431330f, 0.01887539f, 0.00404361f, 0.01681154f, -0.02732155f, 
    0.05068145f, -0.03137287f, -0.01633061f, 0.00786941f, 0.03895594f, 0.02251704f, -0.00764825f, -0.02769453f, 
    -0.02094517f, 0.00232572f, 0.01905238f, -0.00194119f, 0.01026930f, 0.05073501f, -0.01584480f, -0.02760236f, 
    -0.01911620f, 0.02015593f, -0.03110665f, -0.03373152f, 0.03966861f, -0.02767608f, 0.03570363f, 0.00705367f, 
    0.00399305f, -0.02549877f, -0.03600580f, -0.04522719f, -0.04944834f, 0.04418397f, 0.04789137f, -0.04192442f, 
    -0.04024902f, 0.03073778f, 0.04165528f, -0.02568471f, -0.03879314f, -0.03893920f, 0.03373092f, 0.03220657f, 
    -0.00904483f, -0.04649433f, 0.03062935f, 0.02799376f, 0.03218196f, 0.00206124f, -0.01539985f, -0.04749152f, 
    0.02773107f, -0.04005175f, -0.02724857f, -0.04725475f, -0.03635652f, -0.00287228f, -0.04626378f, 0.00682625f, 
    -0.04509141f, 0.01781430f, -0.02259122f, 0.04025340f, -0.04848136f, 0.00427804f, 0.04875171f, -0.04826543f, 
    -0.03147123f, -0.04654024f, -0.00128800f, -0.02653344f, -0.03514184f, 0.04814234f, -0.03410950f, -0.01008946f, 
    0.02874804f, -0.04053626f, -0.00692799f, 0.03488750f, -0.00717303f, 0.01589967f, -0.00702933f, -0.01747677f, 
    -0.01973965f, -0.00168992f, -0.01600782f, -0.01621035f, 0.02805767f, 0.01005852f, -0.00926264f, 0.03951985f, 
    0.02008777f, -0.03247596f, 0.04452439f, -0.03021208f, 0.00881463f, -0.01573400f, 0.03788636f, -0.00188413f, 
    0.02373557f, 0.01195792f, -0.03722703f, -0.03689963f, -0.03173111f, -0.01522616f, 0.02332636f, -0.00974310f, 
    0.01750283f, -0.04888452f, 0.02160272f, -0.04089883f, -0.01583805f, -0.00792302f, 0.04978241f, 0.02635002f, 
    0.00314063f, -0.04747447f, 0.01701265f, 0.00421243f, -0.04892344f, -0.00851391f, -0.00172315f, -0.02283067f, 
    -0.03430394f, 0.04426922f, -0.00238167f, -0.00817093f, 0.00831687f, -0.04919442f, 0.04394662f, 0.03951221f, 
    -0.02948535f, -0.01170987f, -0.04013111f, 0.02598944f, -0.01287007f, 0.00647541f, 0.02493801f, 0.01891644f, 
    0.04094373f, -0.02861530f, 0.04396636f, -0.00546311f, -0.03876946f, -0.00371850f, -0.05003314f, -0.01764279f, 
    -0.02252626f, -0.03395283f, -0.00652466f, -0.02388807f, 0.02386377f, 0.02393558f, 0.02382107f, 0.00250948f, 
    -0.01612371f, -0.04971135f, 0.00234256f, -0.03333971f, 0.02430139f, -0.03627448f, 0.00580899f, 0.01442491f, 
    0.00324291f, 0.03741800f, 0.03223338f, -0.01237188f, 0.02801192f, -0.02345222f, 0.00752696f, 0.01629487f, 
    0.01592695f, -0.02591706f, 0.03370474f, 0.01160311f, -0.03405050f, -0.03842872f, 0.00452926f, 0.02923648f, 
    -0.02721428f, -0.00300838f, -0.00917726f, 0.00478233f, 0.01066404f, 0.02091380f, -0.03911479f, 0.04100880f, 
    0.03072421f, 0.02610887f, -0.03598900f, 0.01617253f, 0.02218681f, -0.02219436f, -0.00126470f, -0.04227833f, 
    -0.04086936f, 0.01062373f, 0.04704045f, -0.03701057f, -0.01930284f, -0.00651508f, 0.02469578f, 0.01840124f, 
    -0.03576581f, -0.01446066f, -0.03433155f, -0.01499241f, 0.01676688f, 0.01232478f, 0.00368154f, 0.00991431f, 
    -0.03053908f, -0.04464147f, -0.01292143f, 0.04411898f, 0.03286183f, 0.02698161f, -0.01502503f, -0.03579294f, 
    0.02187011f, -0.00822467f, 0.01363611f, -0.00868346f, 0.04573868f, -0.01981220f, -0.02589577f, -0.02963612f, 
    0.03770288f, -0.02880860f, -0.02380107f, -0.03368865f, -0.04564130f, 0.02009894f, -0.01472253f, 0.04686371f, 
    -0.03426738f, -0.02359152f, -0.04450453f, -0.02668745f, -0.03469945f, 0.02641940f, -0.04558648f, -0.03107104f, 
    -0.03264053f, 0.02462168f, 0.04818368f, -0.02173504f, 0.01397328f, -0.05016738f, -0.01749027f, 0.04549082f, 
    -0.01150645f, -0.01268623f, -0.00757667f, -0.01839950f, -0.05425164f, -0.05416987f, -0.01232626f, -0.02180675f, 
    0.04064326f, -0.02800833f, -0.02987866f, -0.03463067f, -0.03937977f, -0.04383173f, -0.01394914f, -0.02299560f, 
    -0.04561668f, 0.02658319f, -0.02534867f, -0.05739574f, -0.02295092f, 0.00805400f, 0.02073411f, 0.03531636f, 
    0.02654959f, 0.04196827f, 0.01388727f, -0.01045475f, 0.00875204f, 0.03933487f, -0.03029051f, -0.04114374f, 
    -0.02296717f, 0.00541438f, 0.01486900f, 0.01541147f, -0.04625686f, -0.00112913f, -0.05237669f, -0.03710565f, 
    0.01508159f, -0.05619114f, 0.00753622f, -0.02627479f, 0.00511641f, 0.00529917f, 0.00645972f, -0.04015486f, 
    -0.00525244f, -0.02400577f, -0.02912907f, -0.00506278f, -0.03919145f, -0.01432002f, -0.05328165f, -0.05438851f, 
    -0.02621117f, -0.02852148f, -0.00591758f, -0.00668498f, -0.03955141f, 0.02153552f, -0.03799747f, 0.02503979f, 
    -0.03857248f, -0.04420824f, -0.03135300f, -0.05667095f, 0.00898860f, -0.01920886f, -0.01264879f, 0.04243921f, 
    -0.04538970f, 0.04152544f, -0.04970639f, 0.03923404f, -0.04582655f, -0.01462239f, -0.04401849f, 0.01652287f, 
    -0.01625905f, -0.05511883f, -0.00929460f, -0.05276430f, 0.00794053f, -0.00068307f, 0.01586994f, 0.03307619f, 
    0.00726109f, 0.01804519f, 0.01943184f, 0.02898332f, 0.02001408f, 0.01203161f, 0.03283884f, 0.02369645f, 
    0.02240020f, 0.01278366f, -0.00739716f, 0.04233510f, 0.02115906f, 0.01371563f, 0.03058033f, -0.00163179f, 
    0.03388001f, -0.05394577f, -0.02718947f, 0.02481469f, -0.00598001f, 0.00169899f, -0.05037216f, -0.00753622f, 
    0.01523274f, -0.02862590f, 0.02527716f, -0.01451006f, -0.05858728f, -0.03833101f, -0.02139302f, -0.05887190f, 
    -0.00068681f, -0.00685534f, -0.00188195f, 0.00239044f, 0.00268248f, -0.01280113f, -0.00536822f, 0.03908412f, 
    0.01340506f, -0.02312005f, -0.03641176f, 0.01644982f, 0.04113428f, 0.03015118f, -0.04630185f, 0.00592175f, 
    -0.00908155f, -0.01381333f, 0.00071038f, 0.01457775f, 0.02311003f, 0.02824005f, -0.02133713f, 0.01064354f, 
    0.01566377f, 0.01767016f, -0.00249656f, 0.00124888f, 0.03401121f, 0.03586793f, -0.04154417f, -0.03086323f, 
    0.03795607f, -0.01858343f, 0.00705387f, -0.04421152f, -0.01087119f, -0.04426510f, -0.00577001f, -0.03480264f, 
    -0.00439213f, -0.05867599f, -0.01258343f, 0.03968303f, -0.00747089f, 0.00493608f, 0.02480557f, 0.03545261f, 
    0.02562826f, 0.02127248f, -0.00136810f, -0.02663926f, -0.03351092f, -0.03457122f, 0.03414679f, -0.02622729f, 
    -0.04428608f, -0.00698821f, 0.01551300f, -0.05531495f, -0.02593783f, -0.01988966f, 0.00325029f, -0.00943619f, 
    -0.00122350f, 0.01886578f, 0.02352468f, -0.00517830f, -0.04265054f, -0.01322985f, -0.04973382f, -0.00960398f, 
    -0.05633053f, -0.01038587f, -0.04701780f, 0.04257571f, -0.00786289f, -0.00237062f, -0.01045556f, 0.00264916f, 
    0.02169725f, 0.03331256f, -0.05803767f, 0.00163939f, -0.04758034f, 0.01513668f, 0.00519997f, 0.03397572f, 
    -0.03241448f, -0.00092338f, -0.04617840f, -0.02670569f, 0.04070215f, -0.02144693f, 0.02331914f, -0.01449238f, 
    -0.04002412f, 0.03675627f, -0.00671653f, 0.04015312f, -0.02161789f, -0.02940070f, -0.04546054f, 0.04089056f, 
    0.02760335f, -0.03099163f, -0.03642261f, -0.02789678f, -0.02018300f, 0.00309361f, -0.05435532f, 0.00948487f, 
    -0.04191415f, -0.00116211f, -0.03794473f, 0.00559012f, -0.02656285f, 0.00774435f, -0.04149885f, -0.03671699f, 
    -0.00011217f, 0.00865429f, -0.04129557f, -0.01260699f, 0.04379084f, 0.02411933f, 0.00807398f, -0.02386967f, 
    0.01269640f, -0.02972200f, -0.04479191f, 0.01095058f, 0.01514503f, -0.04507804f, 0.03708346f, -0.04605741f, 
    0.04248584f, -0.05734792f, -0.04104845f, -0.02321993f, 0.02197062f, -0.01488606f, 0.01684693f, 0.03633532f, 
    0.00911182f, -0.04795048f, -0.05025050f, -0.00382908f, -0.05466050f, -0.05354291f, 0.01954051f, 0.03403666f, 
    -0.01576366f, -0.02581627f, -0.01582134f, -0.01556251f, -0.01305644f, 0.02402569f, 0.01048055f, -0.05315923f, 
    -0.05866161f, 0.02217226f, 0.02091279f, 0.00981212f, -0.03084342f, 0.01472764f, 0.02801748f, -0.04551646f, 
    -0.03375832f, 0.02501318f, 0.01842292f, -0.05536830f, 0.00847079f, -0.05390039f, -0.00899827f, -0.01836134f, 
    -0.04694022f, -0.05832524f, -0.02366141f, -0.05717929f, 0.03282384f, -0.00690823f, 0.01334574f, -0.05138023f, 
    -0.05297618f, 0.00326442f, -0.05762136f, 0.01976529f, -0.04121771f, 0.00672715f, 0.00169328f, -0.00065573f, 
    0.03112387f, -0.01596774f, 0.03929055f, -0.05685113f, -0.00884723f, -0.05354557f, -0.04250399f, -0.02122781f, 
    -0.04381436f, -0.01079925f, -0.01120305f, 0.01711862f, 0.02465236f, -0.00332247f, 0.02454959f, 0.03861247f, 
    -0.00793670f, -0.01570796f, -0.02711976f, -0.03123346f, -0.04376315f, -0.00987924f, 0.01958753f, 0.02593507f, 
    -0.04548480f, -0.03307064f, -0.04607895f, -0.05099757f, 0.04112067f, 0.01801421f, 0.01941969f, 0.02820880f, 
    0.02534583f, 0.03745474f, 0.00810505f, -0.04260597f, -0.02882259f, -0.01060751f, 0.02922650f, 0.02868005f, 
    0.02365145f, -0.02371912f, -0.04081438f, 0.01196071f, 0.00000473f, 0.04010862f, -0.05735035f, 0.02180170f, 
    0.02076816f, 0.02342587f, -0.00605117f, -0.05321293f, 0.01412079f, -0.01956361f, -0.02194048f, 0.00479432f, 
    -0.02634783f, -0.03285500f, -0.00659114f, 0.02775882f, 0.02659179f, 0.03235552f, 0.03924219f, -0.02062098f, 
    0.01027980f, 0.01985236f, 0.01690458f, 0.01790705f, 0.01156754f, -0.02982130f, -0.00895983f, 0.01561147f, 
    -0.04334144f, -0.14173935f, -0.38605383f, 0.08734334f, -0.09018164f, 0.05962181f, -0.03642114f, 0.13887544f, 
    0.07677493f, -0.00700617f, 0.09126330f, -0.01860914f, 0.03109269f, 0.15115632f, -0.12569259f, -0.08361846f, 
    0.17340083f, 0.00345385f, -0.04799469f, 0.01271746f, -0.07698926f, 0.02823739f, -0.03078927f, 0.17056033f, 
    -0.20017262f, 0.01568453f, -0.14829624f, 0.18904939f, 0.16891082f, -0.01841485f, 0.13541295f, 0.09911283f, 
    0.00311524f, 0.05211043f, -0.01280536f, -0.01517976f, 0.06455528f, -0.12793075f, -0.10153767f, -0.11706203f, 
    0.10483628f, 0.13395980f, 0.00402958f, 0.06893028f, 0.03192605f, 0.05906042f, -0.04655863f, 0.03771761f, 
    -0.08740432f, -0.30420122f, -0.18605356f, 0.14426744f, -0.10836469f, -0.07186650f, 0.08860577f, -0.05604399f, 
    -0.03519441f, 0.00447969f, -0.10914106f, -0.02387645f, 0.33495116f, 0.24307525f, 0.05832528f, -0.18593049f, 
    -0.05794465f, -0.00116560f, -0.02182646f, 0.07549389f, -0.03315353f, 0.07737868f, -0.10787558f, 0.07759187f, 
    0.10665493f, 0.36553931f, 0.17267355f, -0.19092280f, -0.04657429f, -0.05482109f, -0.07068783f, 0.04260283f, 
    0.10936539f, -0.07184950f, -0.01298670f, -0.04437700f, 0.31988931f, 0.18640369f, 0.13745297f, -0.25672370f, 
    -0.01396431f, -0.15239833f, -0.00426100f, 0.06252068f, -0.02987279f, 0.03673837f, -0.04545091f, 0.10070240f, 
    0.32812396f, -0.01491111f, 0.44426987f, -0.16106351f, 0.18158676f, 0.00312713f, 0.09097939f, 0.01014628f, 
    0.01254812f, 0.05419455f, 0.12640561f, -0.15344910f, -0.09776623f, 0.12052976f, -0.23849314f, 0.09709106f, 
    0.11024866f, -0.08803058f, -0.03405842f, -0.15943147f, 0.00860126f, -0.03030878f, 0.01107823f, 0.06593758f, 
    0.00098942f, 0.00265156f, 0.02188207f, -0.08330541f, -0.07046535f, 0.12815723f, -0.05257959f, 0.11640760f, 
    0.02057698f, -0.09505257f, -0.10954370f, 0.03311593f, -0.14701034f, -0.27396101f, 0.03406778f, 0.05024690f, 
    0.00542382f, 0.02375347f, 0.17531078f, -0.15311900f, 0.09251154f, -0.01421971f, -0.00124827f, 0.06169511f, 
    0.14375246f, 0.21803506f, 0.18771921f, -0.20697685f, -0.09926972f, -0.01397697f, 0.10325812f, 0.06850930f, 
    -0.09479776f, -0.02407874f, 0.14076109f, 0.11222477f, -0.20563747f, 0.00039747f, 0.08339690f, 0.00544406f, 
    0.05050283f, 0.10280303f, 0.14310186f, -0.05278254f, -0.25717080f, -0.01981870f, -0.00246917f, 0.00072942f, 
    -0.20222031f, -0.12345966f, -0.06933535f, 0.23469652f, -0.13317104f, 0.05279837f, 0.03387196f, 0.07956865f, 
    -0.13660510f, 0.14275475f, 0.14258729f, -0.00451405f, -0.27112287f, 0.01046475f, 0.03881853f, 0.31281209f, 
    0.01477634f, 0.08507802f, -0.04899053f, -0.05569590f, 0.11409151f, -0.06440756f, 0.09363326f, 0.08032943f, 
    0.25369051f, 0.08580604f, -0.07377447f, -0.14197497f, 0.13847840f, 0.05657838f, 0.00686326f, 0.13890545f, 
    0.09432911f, 0.05329803f, -0.11391044f, 0.06760987f, 0.15463416f, 0.22858201f, 0.06618071f, 0.07995829f, 
    0.01419905f, -0.02212764f, 0.12524289f, -0.01054643f, 0.04299314f, -0.00580526f, 0.04443900f, -0.14235257f, 
    -0.02442406f, 0.01203247f, -0.15788202f, -0.04725318f, 0.21887583f, 0.13766015f, 0.15196049f, -0.02973871f, 
    0.05706898f, 0.09558529f, -0.05372217f, 0.09008784f, -0.19255559f, 0.28979859f, -0.10385609f, -0.05324344f, 
    -0.08900499f, 0.01768168f, -0.09284569f, 0.07731294f, -0.07266067f, 0.07417823f, 0.00357893f, -0.05474344f, 
    -0.26027423f, -0.09058102f, -0.01179361f, 0.01419133f, 0.07898469f, 0.11637833f, 0.07134222f, 0.04290274f, 
    -0.06397694f, 0.00900896f, 0.00352764f, 0.04097233f, 0.29372650f, 0.14046118f, -0.20666154f, 0.06964882f, 
    0.09497013f, 0.01542425f, 0.00059898f, 0.05619628f, 0.21480356f, -0.04306741f, 0.05724461f, 0.01814471f, 
    0.07780973f, -0.33111313f, 0.03332827f, 0.20577997f, -0.03004498f, 0.07416984f, 0.10561839f, -0.05900316f, 
    -0.01683900f, -0.02067763f, -0.14556937f, 0.03546258f, -0.10327956f, 0.14048441f, 0.09527054f, -0.07397791f, 
    -0.09524997f, 0.01220567f, 0.12557490f, 0.01231396f, 0.08515393f, 0.16881542f, -0.07330543f, -0.00150300f, 
    -0.11909907f, -0.10920747f, 0.03322269f, 0.11305822f, 0.08369863f, 0.16866548f, 0.05083804f, 0.14294009f, 
    0.09123603f, 0.07730488f, -0.03027981f, 0.03457944f, 0.34562272f, -0.22854210f, 0.03874786f, 0.02838764f, 
    0.02335188f, -0.13035546f, 0.09773438f, -0.00980068f, -0.07922677f, -0.08550586f, -0.04516267f, -0.07310592f, 
    0.05648978f, -0.11430074f, 0.11723329f, 0.29768032f, 0.05310873f, 0.01936911f, 0.01503866f, 0.01811142f, 
    -0.03880700f, 0.03323098f, 0.04474232f, 0.08284917f, -0.24871545f, 0.24688311f, -0.35259572f, -0.07567602f, 
    -0.01677527f, 0.04691676f, -0.01368946f, -0.04958926f, 0.02492112f, -0.01212320f, 0.17375366f, 0.05925278f, 
    -0.10854886f, 0.10177115f, -0.13784108f, 0.03428915f, 0.12849605f, 0.03516135f, 0.02354262f, -0.08714163f, 
    -0.08054777f, -0.01364067f, 0.05740469f, 0.06321178f, 0.09907382f, 0.36366650f, 0.13306747f, -0.06974702f, 
    -0.05610326f, 0.02791910f, 0.00666487f, 0.16447811f, -0.01009740f, 0.04468558f, -0.07610999f, -0.09034912f, 
    -0.18890016f, -0.12061749f, -0.01591304f, -0.00083341f, 0.16631250f, -0.02985788f, 0.15992177f, -0.03289410f, 
    0.06217667f, -0.11185777f, 0.11909832f, 0.01389280f, 0.54435307f, 0.04566589f, -0.11247879f, -0.09601250f, 
    -0.11585212f, 0.03130549f, -0.00783655f, 0.09692261f, -0.05917653f, 0.00852974f, 0.02960744f, 0.17509815f, 
    -0.30487835f, 0.41271818f, -0.29484197f, -0.04222094f, 0.04119796f, 0.12156615f, -0.04843862f, 0.13334139f, 
    -0.03035929f, 0.12695520f, 0.06824446f, 0.07312589f, 0.09038977f, 0.04744912f, -0.15193890f, -0.01452324f, 
    -0.01345743f, -0.08561486f, 0.03250218f, 0.02915955f, 0.03494142f, 0.01177599f, 0.11967801f, 0.01384548f, 
    -0.36360160f, 0.12669514f, -0.03629525f, 0.08843824f, 0.16578518f, 0.07312407f, -0.07714167f, 0.17466462f, 
    0.04876319f, 0.07725605f, -0.03272156f, 0.07761550f, 0.21030648f, 0.14284979f, -0.08881604f, -0.18760714f, 
    0.06479659f, -0.07526601f, 0.06274777f, 0.04237602f, 0.01459673f, -0.10478557f, -0.03827318f, 0.08234905f, 
    0.12799297f, 0.00621746f, -0.12592556f, 0.08209591f, 0.10094487f, -0.09907511f, -0.06222243f, -0.09537666f, 
    0.09046140f, -0.02028577f, 0.07157321f, -0.02510634f, 0.06881228f, -0.06685738f, 0.16321042f, 0.28319186f, 
    -0.04307464f, 0.01434905f, 0.17446701f, 0.00049802f, 0.15193978f, 0.10010130f, -0.08165270f, 0.06485648f, 
    0.01496258f, 0.11585932f, -0.07499932f, 0.12990940f, 0.02866591f, -0.11358985f, 0.09741736f, 0.00469747f, 
    0.03261656f, -0.07400841f, 0.06617131f, 0.11261845f, 0.42321226f, -0.11356986f, 0.01131842f, 0.20081979f, 
    0.02430843f, 0.09960736f, 0.16135930f, -0.07289838f, -0.06704909f, -0.07820547f, 0.10218469f, 0.06317609f, 
    -0.01895045f, -0.12813579f, 0.17858075f, -0.09795689f, 0.03391376f, -0.17867981f, 0.11768281f, -0.05146838f, 
    0.01745602f, -0.00785862f, 0.07312362f, -0.11542620f, 0.22061881f, 0.05955549f, -0.17273237f, 0.11838153f, 
    -0.05139504f, 0.05121888f, -0.00567254f, 0.01846974f, 0.00260670f, 0.01561727f, 0.01694000f, -0.09206363f, 
    -0.10175065f, -0.06255925f, 0.21288615f, -0.13768715f, 0.01479489f, 0.09752350f, -0.15384474f, 0.10423621f, 
    -0.00720670f, -0.02276861f, 0.05353253f, -0.09585379f, 0.18213888f, -0.37132502f, 0.01569951f, 0.04498320f, 
    -0.14257224f, 0.01005370f, 0.06784923f, -0.04924042f, -0.07701457f, -0.03922928f, -0.11875550f, 0.01486553f, 
    0.16413496f, -0.07344514f, -0.04038972f, 0.09971597f, -0.13362217f, 0.10298523f, 0.04858349f, 0.00454746f, 
    -0.00161629f, -0.00139032f, 0.08291288f, 0.12591298f, 0.04816893f, -0.06727939f, 0.01386388f, 0.09012612f, 
    0.06439378f, 0.00532476f, -0.10000259f, -0.02473607f, -0.03247769f, 0.04506437f, 0.18549684f, 0.10937414f, 
    -0.00189382f, 0.04479944f, -0.12739199f, 0.15467767f, -0.18555976f, 0.13924286f, -0.04946298f, 0.04202250f, 
    0.00893247f, 0.02770443f, -0.03986465f, -0.22133666f, -0.25659549f, -0.09121884f, 0.04893658f, 0.05074621f, 
    -0.07812967f, 0.11792218f, 0.07152897f, -0.07118767f, 0.10685198f, -0.06703878f, 0.14202623f, -0.21070331f, 
    0.27075201f, 0.13428508f, 0.00164039f, -0.11551933f, -0.05378131f, 0.04342128f, -0.07200538f, 0.08223876f, 
    0.10202629f, 0.18458219f, -0.05984594f, 0.08454218f, 0.10956553f, 0.03395535f, -0.20182589f, 0.01378419f, 
    -0.17599158f, 0.07868443f, 0.17504159f, 0.06813419f, -0.07505998f, 0.04372843f, 0.00029593f, -0.16992183f, 
    0.14573924f, 0.12427324f, -0.28405020f, -0.04602250f, 0.02981751f, 0.01873070f, 0.06438097f, -0.08166277f, 
    0.06904809f, -0.05451667f, 0.05819903f, -0.16849737f, 0.34311533f, -0.12435704f, 0.08064191f, 0.08945674f, 
    0.02163742f, 0.01647582f, 0.01453836f, 0.05126403f, 0.06552719f, 0.03535920f, -0.05342548f, -0.04249911f, 
    -0.03505666f, -0.00612777f, 0.06508099f, 0.01220496f, -0.06952608f, 0.09985220f, 0.02939004f, 0.09942640f, 
    0.05492155f, 0.09800204f, -0.03214645f, -0.11210626f, 0.08215084f, 0.15719543f, -0.04328903f, 0.09484274f, 
    0.00867774f, 0.11835162f, -0.15406929f, 0.01907261f, -0.05799223f, -0.03381562f, -0.06557780f, 0.03355509f, 
    -0.14375401f, -0.03514249f, -0.14074236f, 0.12149812f, 0.09075203f, 0.02615590f, 0.04777194f, -0.05960904f, 
    0.05600397f, 0.13384131f, -0.02916007f, 0.04912503f, 0.17750360f, -0.19862683f, 0.15667443f, 0.30519721f, 
    -0.13075015f, 0.10506196f, 0.05030197f, -0.05514802f, -0.01601483f, 0.00888200f, -0.06624394f, -0.01500574f, 
    -0.41667998f, -0.02577141f, 0.05007565f, 0.14818099f, -0.05246989f, 0.06369565f, -0.01207177f, -0.04605513f, 
    0.01016651f, 0.12839644f, 0.02378408f, -0.06760731f, 0.29095617f, 0.01906224f, -0.00034691f, 0.04463018f, 
    -0.08552466f, -0.11685714f, 0.07996031f, -0.02648084f, 0.02698796f, -0.02457750f, 0.10203946f, 0.01182589f, 
    -0.23849952f, 0.52821898f, -0.13435906f, -0.26886192f, -0.02854576f, 0.10060707f, -0.03113576f, 0.00304454f, 
    0.13664626f, -0.01700679f, 0.06580799f, -0.05984295f, 0.13969828f, 0.13729246f, -0.01865094f, 0.20336680f, 
    0.00524980f, -0.01684409f, 0.05643838f, 0.11710348f, 0.04337318f, 0.00729813f, 0.01761226f, -0.00507025f, 
    -0.18747815f, -0.07590305f, -0.27265370f, -0.07176871f, -0.12515239f, 0.11975482f, -0.02476169f, -0.00226755f, 
    -0.02023278f, 0.04479633f, -0.11414285f, -0.04404946f, 0.04957550f, 0.05150271f, 0.17473011f, -0.16597049f, 
    -0.06346957f, -0.04194136f, 0.02603110f, 0.17847531f, 0.00496072f, -0.02312186f, -0.07170613f, 0.13398799f, 
    0.45711157f, -0.13874051f, 0.01505302f, 0.02089308f, 0.00828746f, -0.04160024f, 0.12670377f, 0.08660468f, 
    0.13931818f, -0.05712302f, 0.09936562f, -0.01410233f, 0.27458093f, 0.27306473f, -0.39627197f, 0.52096027f, 
    0.12026739f, 0.10896615f, 0.04347442f, 0.03214533f, -0.09794923f, 0.03736793f, 0.04530820f, 0.08423813f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03738705f, 0.00295795f, 0.13714227f, -0.03429478f, -0.04974749f, 0.10322042f, -0.03818221f, 0.02032681f, 
    0.06148313f, -0.04032236f, 0.04156356f, 0.06940597f, -0.03447780f, 0.03321690f, -0.02373470f, -0.04551981f, 
    -0.01040663f, -0.00169675f, -0.04196259f, -0.06224401f, -0.05025472f, -0.00241489f, 0.00706190f, 0.04466082f, 
    0.16468112f, 0.00074340f, -0.00237958f, -0.07933341f, 0.00769082f, -0.01040694f, 0.06365263f, -0.01623051f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08908854f, -0.35660350f, -0.41308978f, -0.00135995f, -0.15202899f, -0.78574526f, 0.09193412f, -0.09877119f, 
    0.01536832f, 0.07475415f, -0.28711513f, -0.06839934f, -0.12513703f, -0.07596702f, 0.37288922f, -0.06884196f, 
    0.11940945f, -0.59972793f, 0.49086475f, 0.16691887f, 0.07992513f, -0.71223098f, -0.19770101f, -0.00324475f, 
    -0.12725100f, 0.05086040f, -0.07567120f, 0.30522048f, -0.09754121f, -0.06324209f, 0.27391845f, 0.09550707f, 
    -0.04867911f, -0.07922393f, 0.07448425f, -0.01382566f, -0.17773977f, -0.22423851f, 0.01991808f, -0.10311984f, 
    0.23970288f, -0.01393447f, -0.00776682f, -0.76711130f, -0.12368330f, -0.10502247f, -0.02581841f, 0.14036989f, 
    -0.62435883f, 0.25701335f, -0.29257098f, 0.26246205f, -0.02844852f, -0.50372058f, 0.08793296f, 0.16368482f, 
    0.10911613f, 0.16349821f, 0.04518506f, -0.06124040f, 0.00449007f, 0.03008416f, 0.10567985f, 0.31049663f, 
    0.16169961f, -0.20508760f, -0.72362107f, -0.03788105f, -0.04155968f, -0.03754871f, 0.00421834f, -0.05076710f, 
    0.28086784f, 0.06290552f, 0.43625462f, 0.18195587f, 0.01579397f, 0.16159219f, -0.39099947f, 0.11238200f, 
    -0.21900746f, -0.26311979f, -0.77200401f, 0.27627042f, -0.10049421f, 0.09006488f, -0.65545100f, -0.01438756f, 
    -0.17363995f, 0.16809089f, -0.16060002f, 0.24464311f, 0.02541575f, 0.00238931f, 0.10353492f, 0.36735180f, 
    -0.04664988f, -0.35800487f, -0.44635978f, 0.03354347f, 0.02163826f, 0.09115096f, 0.04838348f, 0.12543838f, 
    0.24233630f, -0.03322984f, 0.01473261f, 0.12466130f, -0.12152440f, -0.09066563f, -0.03397663f, -0.15633440f, 
    0.26491171f, 0.25176719f, 0.26233423f, -0.26458329f, -0.06117114f, 0.03959136f, 0.21620941f, 0.17774113f, 
    -0.37048671f, 0.10002736f, 0.09425358f, -0.41789013f, 0.08252220f, -0.13956226f, -0.60093790f, 0.15566330f, 
    -0.08072479f, 0.28533030f, -0.00973287f, -0.03144290f, -0.00743981f, -0.13285093f, 0.04059950f, -0.14144954f, 
    -0.19595711f, -0.11381555f, -0.60951895f, 0.16908094f, 0.16148674f, -0.01523997f, 0.02976597f, -0.13357890f, 
    0.05525065f, -0.45775825f, 0.10735249f, -0.17421980f, 0.01989515f, 0.47588366f, -0.07141767f, 0.40492266f, 
    -0.13517046f, 0.05013649f, 0.04907940f, 0.28735706f, -0.01486837f, -0.04531038f, -0.11505803f, -0.17606862f, 
    -0.03688218f, -0.13220814f, 0.55565834f, 0.08816472f, -0.13118470f, -0.30522886f, -0.16063750f, 0.06847625f, 
    -0.52154732f, -0.10258541f, -0.29019204f, -0.23474209f, -0.09203945f, -0.07479922f, -0.12506554f, -0.07913940f, 
    0.20525299f, 0.00746219f, -0.27001008f, -0.21627963f, 0.08417372f, 0.03648467f, 0.38070774f, -0.28183517f, 
    0.23680881f, -0.00196717f, -0.12412514f, -0.08300606f, 0.02200873f, -0.08376467f, 0.24769439f, 0.23353624f, 
    0.16050129f, -0.38617620f, -0.15885213f, 0.10223969f, 0.06853202f, 0.57794034f, 0.12429262f, -0.15673000f, 
    -0.65013224f, 0.09437197f, -0.22875361f, 0.52239299f, 0.04559892f, -0.08594968f, -0.22621213f, 0.01367467f, 
    -0.08459635f, -0.16564848f, -0.39279291f, 0.38157463f, -0.17002656f, -0.32747000f, -0.11073368f, 0.09840634f, 
    -0.07251082f, -0.09839333f, -0.09332854f, -0.51608819f, 0.10707504f, 0.09053709f, 0.26949352f, -0.08535901f, 
    0.03568257f, 0.33510208f, 0.12452556f, -0.11908710f, -0.12079332f, 0.26996309f, -0.17287923f, 0.08909532f, 
    -0.65465748f, 0.14242393f, 0.03274746f, 0.02097234f, -0.08663993f, 0.14976388f, -0.36659321f, 0.16789831f, 
    0.24063160f, 0.37391701f, 0.14059061f, -0.08911833f, 0.12031138f, 0.18423404f, -0.31524146f, -0.35917342f, 
    -0.25006008f, 0.02165109f, 0.01798884f, 0.31639594f, 0.14031003f, 0.08727688f, -0.18457320f, -0.11841243f, 
    -0.05739287f, 0.48685223f, -0.09910659f, 0.01921557f, -0.13953625f, -0.54623491f, -0.04187692f, -0.17181231f, 
    -0.32251346f, -0.15633301f, 0.46512371f, -0.03514462f, 0.16380401f, -0.08841556f, 0.34199017f, 0.02497092f, 
    -0.43676558f, -0.15760012f, -0.37868729f, -0.07202472f, 0.05151009f, 0.17971577f, 0.24982764f, 0.01034834f, 
    0.23242515f, -0.07576858f, 0.03743931f, -0.12356040f, 0.16702326f, 0.02989410f, -0.41082814f, -0.42016229f, 
    -0.14710729f, -0.66434109f, 0.21404094f, -0.16297846f, 0.04269956f, 0.46128806f, -0.00814560f, 0.06291687f, 
    0.40113378f, 0.04546548f, 0.09820037f, -0.13819116f, -0.05423396f, 0.06673534f, -0.23010707f, 0.02741507f, 
    -0.16373435f, -0.24831632f, -0.09806340f, 0.27404636f, 0.06864889f, 0.11710782f, -0.05766601f, -0.18579213f, 
    -0.30540913f, 0.08118572f, -0.09937704f, 0.48710161f, 0.01848268f, 0.00831813f, 0.07413004f, -0.82592016f, 
    0.10686492f, 0.16041242f, 0.48684505f, -0.17143954f, 0.03336351f, 0.23883344f, 0.13046823f, -0.12796801f, 
    0.40583080f, -0.18098108f, -0.01393500f, 0.11242710f, -0.08461876f, 0.13008724f, 0.04020773f, 0.10110579f, 
    0.20302148f, 0.31421387f, -0.08063871f, -0.31849316f, 0.06365637f, -0.13046916f, -0.64166498f, -0.19309042f, 
    0.31998271f, 0.04154143f, -0.02270494f, -0.61204392f, -0.03533229f, 0.01451997f, -0.08855566f, -0.13862483f, 
    -0.04684522f, 0.38544708f, -0.12790574f, -0.16350263f, -0.00420168f, 0.16902544f, 0.02481802f, 0.06015177f, 
    -0.16067314f, -0.17806296f, 0.31220955f, 0.48182258f, -0.04588250f, 0.11526863f, -0.23654111f, -0.10658972f, 
    -0.58921820f, -0.37530091f, 0.36749181f, -0.53244042f, -0.03315718f, -0.10849858f, 0.07276809f, -0.21427566f, 
    -0.18302621f, -0.00521070f, -0.07216039f, -0.01408278f, 0.08594552f, -0.08032087f, 0.18969060f, 0.24213277f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.11472214f, 0.03190019f, -0.12764183f, 0.03284831f, -0.09610477f, -0.02381200f, -0.11366164f, -0.24264993f, 
    -0.16856903f, -0.10807540f, 0.13126032f, 0.09921699f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
