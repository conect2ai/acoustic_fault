#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.55521548f, -0.89185405f, -1.28752244f, 0.07272147f, -0.21981835f, 0.05883816f, -0.42531824f, -0.81696242f, 
    -0.81216842f, -0.28717721f, -0.31492791f, -0.17234209f, 0.44052872f, -0.60899657f, 0.94705182f, -0.03679281f, 
    0.40707609f, -0.01546267f, 1.35507357f, -0.19195978f, 0.08425409f, -0.05646300f, 0.66045463f, -0.86652660f, 
    0.21647635f, -0.18664989f, -0.01598394f, -1.69702256f, 0.15959600f, 0.26297513f, 0.55176342f, 0.90201962f, 
    0.49756518f, 0.38691431f, -0.24362543f, -0.52014154f, 0.22447114f, 0.70377219f, 0.14032985f, 0.09054346f, 
    1.12402642f, 0.52010924f, -0.48249921f, -0.49697813f, -0.47573864f, 0.22250220f, 0.71192592f, -0.67108983f, 
    -1.10503554f, -0.97718972f, -1.12666190f, -0.55886924f, -0.85306597f, -0.30563152f, -1.76661062f, 0.40941650f, 
    1.10574710f, 0.17799054f, -0.96275109f, 0.86449486f, -0.16221279f, 0.10052323f, -0.10791123f, 1.02550125f, 
    -1.41780221f, -1.67599642f, 0.59211510f, 1.04363525f, 0.56394392f, -0.31566116f, 0.46599320f, -0.04575431f, 
    0.22420961f, -0.26337531f, -0.57393628f, 0.45292404f, -0.28612250f, -0.17681676f, 0.47529301f, 0.67066461f, 
    0.33988160f, 0.93046862f, 0.61425614f, 0.36481982f, -1.15899467f, -1.13096941f, 0.06848483f, -0.21166123f, 
    -0.66537821f, -0.69607848f, 0.08208336f, -1.69166887f, -1.06299984f, -0.90180397f, -0.60920382f, -0.85497934f, 
    0.38310707f, 0.65121949f, 0.18612647f, 0.24812284f, -0.52134556f, 0.63166457f, -0.83398825f, -0.11998072f, 
    1.09319782f, 0.16370779f, 0.02973851f, -0.33803031f, -0.78552741f, -0.81300521f, 1.35770226f, -1.26586843f, 
    -1.40499079f, -1.23128188f, 0.68946004f, 0.08920906f, 0.18327552f, -0.00524126f, 0.43221602f, 0.09500910f, 
    0.61670595f, -0.33318850f, -0.08539409f, 0.02482104f, 0.90363294f, -0.89818621f, 0.59686774f, 0.15536615f, 
    0.17561273f, -0.81056690f, -0.47483402f, -0.34690437f, 0.36556160f, 0.50486588f, 0.54926199f, 0.51103383f, 
    0.56436491f, 0.31936046f, 0.22498295f, 0.00060399f, 0.24805339f, 0.43009228f, 0.09892945f, 0.31788644f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.07113835f, 0.32041088f, 0.79035133f, 0.47059977f, -0.12019499f, 0.02717426f, 0.14635755f, 0.34152210f, 
    0.08064879f, 0.09169605f, 0.51185846f, 0.66948974f, 0.17434978f, 0.25009567f, 0.04415604f, -0.01472607f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.74175882f, 0.36778784f, 0.26298207f, -0.21906950f, -0.13172124f, 0.23291413f, 0.25215507f, 0.19596227f, 
    -0.09535547f, 0.13994440f, -0.05419859f, -0.00807535f, 0.01570072f, -0.10902467f, -0.03675944f, -0.00335220f, 
    -0.17308274f, -0.08015063f, -0.16397734f, -0.13649310f, -0.01720660f, -0.24479213f, 0.08589311f, -0.04808871f, 
    0.01135320f, -0.03257935f, 0.02582261f, 0.02215879f, -0.09191395f, 0.05415767f, -0.12876768f, -0.05975274f, 
    0.13325274f, -0.06106874f, 0.06961513f, 0.04770040f, -0.03492066f, -0.09167036f, -0.04540056f, -0.12162810f, 
    -0.74437004f, -0.48867711f, -0.31017196f, 0.03803392f, -0.05380562f, -0.10600684f, -0.05402100f, -0.06894454f, 
    -0.03928921f, 0.07714189f, -0.08666117f, 0.03038275f, 0.03410471f, 0.03505592f, -0.00161000f, -0.35743904f, 
    -0.10818326f, -0.27387390f, -0.23454373f, 0.03747247f, 0.15906279f, -0.57058257f, -0.09925117f, -0.04119822f, 
    -0.01555016f, -0.13032718f, 0.06813815f, 0.08273279f, 0.15699667f, -0.07707220f, -0.19235067f, -0.05553375f, 
    -0.14240275f, 0.13344008f, -0.13113151f, 0.03767092f, 0.03046104f, 0.04933159f, 0.02078107f, -0.01629116f, 
    -0.16912867f, -0.16862665f, -0.25123200f, -0.10638322f, -0.11148828f, 0.13535100f, 0.08690783f, 0.04401810f, 
    0.08615221f, 0.04925901f, 0.15018077f, 0.11471856f, 0.07024542f, 0.04098012f, -0.00215411f, -0.10859867f, 
    -0.13163683f, 0.13844946f, -0.07143525f, 0.04610506f, -0.04097474f, 0.44585866f, 0.17808624f, -0.26649132f, 
    -0.28768194f, -0.01106377f, 0.14717014f, -0.05523260f, -0.05728622f, 0.01555233f, -0.03714342f, -0.08623119f, 
    0.00161550f, 0.04746827f, 0.08606094f, -0.09406181f, -0.06258377f, 0.10300085f, 0.04005960f, 0.12119338f, 
    -0.37614238f, 0.31580791f, 0.88383198f, -0.78719807f, 0.19664638f, -0.42070502f, -0.11638457f, 0.06813394f, 
    0.04664966f, -0.49150521f, 0.13618785f, -0.18428653f, -0.28807586f, -0.19864412f, -0.01207718f, -0.28130057f, 
    0.01839708f, -0.01349372f, -0.26845768f, 0.12899217f, 0.48525664f, -0.10517909f, -0.61276513f, 0.17301472f, 
    -0.02815955f, 0.19361758f, -0.02252383f, 0.02505858f, -0.25380474f, 0.10741530f, 0.05848489f, -0.04546233f, 
    -0.09526335f, -0.11270089f, -0.05957755f, 0.05949839f, 0.15138060f, -0.06735671f, 0.01586947f, 0.01927638f, 
    0.20340262f, 0.01572889f, -0.04171148f, 0.13742802f, 0.11089448f, 0.04709423f, 0.01952573f, -0.00512611f, 
    0.09804746f, 0.03463858f, -0.00410428f, 0.16874376f, -0.02488085f, -0.04459616f, 0.02464798f, -0.08537582f, 
    -0.09407622f, -0.06226111f, 0.00191000f, 0.06459539f, -0.33689174f, 0.57343960f, 0.40418467f, -0.51475716f, 
    -0.07527185f, -0.23596701f, -0.18353559f, -0.35456601f, -0.03153734f, -0.01844423f, 0.04709025f, -0.03563415f, 
    0.00559488f, 0.04142779f, 0.04320852f, 0.19572826f, 0.10010503f, -0.01990782f, 0.18119399f, 0.07047168f, 
    0.62524706f, 0.46924448f, -0.12519340f, -0.46525612f, -0.19894968f, 0.13203877f, -0.11711267f, 0.02648800f, 
    -0.23461787f, 0.09256551f, 0.01768300f, -0.01430369f, 0.03081633f, 0.02115748f, 0.07793340f, -0.05268588f, 
    -0.10851061f, -0.08244756f, -0.05034045f, 0.07005120f, -0.73668182f, -0.43008891f, -0.02174063f, -0.06302096f, 
    -0.14942183f, -0.04132777f, -0.05166890f, -0.04628856f, -0.12895958f, -0.01638254f, -0.17178357f, -0.13161045f, 
    -0.11956441f, 0.06955153f, 0.03060085f, 0.16157998f, -0.22881292f, -0.01478146f, -0.11390964f, -0.13299438f, 
    0.46847281f, 0.59739035f, 0.28811026f, -0.89202756f, -0.16915677f, 0.09230865f, 0.19277859f, -0.11835101f, 
    0.11533857f, 0.15070575f, 0.11832854f, -0.01963327f, 0.04578728f, -0.09966341f, -0.09377106f, -0.02473221f, 
    -0.03561518f, -0.08760693f, 0.12970640f, -0.19002114f, -0.30263290f, -0.29727438f, -0.23439091f, -0.04850030f, 
    -0.13744275f, -0.06843149f, -0.07485823f, -0.04570570f, 0.06878788f, 0.01103423f, -0.24900866f, 0.14257835f, 
    -0.18025182f, -0.23084523f, -0.26738057f, -0.26205155f, -0.06303740f, -0.14609909f, -0.22766247f, 0.00166080f, 
    0.25098830f, 0.16209619f, 0.01280771f, -0.05013720f, -0.06397547f, -0.45964783f, -0.09204818f, -0.31348416f, 
    -0.01190117f, 0.01965254f, 0.05760933f, 0.05701100f, 0.06755083f, 0.00769274f, -0.02367982f, 0.00293986f, 
    0.00616958f, -0.02402900f, -0.26962599f, -0.21163808f, -0.02930884f, 0.00330509f, -0.03760252f, 0.12186221f, 
    0.09083791f, 0.02780551f, 0.00083843f, 0.11586577f, 0.06136813f, 0.05183825f, -0.12378886f, 0.05986966f, 
    -0.02187976f, 0.01750360f, -0.02386639f, -0.10207747f, -0.20268013f, 0.00384517f, 0.02172029f, 0.00013276f, 
    0.19732845f, 0.33737770f, 0.50026107f, 0.27730241f, -0.03939020f, 0.17551675f, -0.10896831f, 0.20437290f, 
    0.04402804f, 0.07040662f, 0.03816098f, 0.03293012f, 0.01449215f, -0.20024070f, 0.03793714f, 0.14117405f, 
    0.01571055f, -0.03781854f, -0.14934161f, -0.03850813f, -0.07542653f, -0.12531471f, -0.21022378f, -0.11167064f, 
    0.02253231f, -0.02253428f, 0.02186111f, 0.12749301f, 0.00535569f, -0.15100060f, -0.17520116f, 0.23057573f, 
    -0.19760624f, 0.00837345f, -0.18681937f, -0.11774469f, 0.11365376f, -0.02505442f, -0.06459840f, 0.03513748f, 
    0.43067878f, 0.19434242f, -0.06796748f, -0.04485182f, -0.04610613f, -0.11990118f, -0.10167246f, -0.05587390f, 
    -0.03647852f, -0.04062503f, 0.00419999f, 0.00880154f, 0.09943248f, 0.00122281f, 0.03509812f, 0.30026615f, 
    -0.12757333f, 0.11766911f, 0.24987474f, -0.01001008f, -0.00736244f, -0.52957356f, 0.00308011f, 0.21086948f, 
    0.05569569f, 0.06367064f, -0.03248934f, 0.03483302f, 0.01590960f, 0.05634494f, 0.03138105f, -0.05582747f, 
    -0.11637400f, 0.09294847f, 0.10952248f, 0.03990420f, -0.11729692f, -0.01576223f, 0.06843773f, -0.11531165f, 
    0.29195738f, 0.05872645f, 0.32227635f, 0.19794859f, 0.21385331f, -0.10903376f, -0.08689257f, 0.05086355f, 
    -0.10457721f, 0.00016801f, -0.08407106f, -0.00043801f, 0.01259938f, 0.01101660f, 0.09931334f, 0.16868356f, 
    -0.01769063f, -0.23339088f, 0.09499609f, 0.01033024f, -0.27793261f, -0.00060739f, -0.32099193f, -0.34590024f, 
    -0.66172957f, 0.07545715f, -0.24114151f, -0.27717397f, -0.18076195f, 0.09620921f, -0.05229278f, 0.01781833f, 
    0.05631174f, 0.03515710f, 0.03763179f, -0.12683265f, -0.03771600f, -0.17646725f, -0.25984451f, -0.26827350f, 
    -1.29184389f, -0.58253562f, -0.17064221f, -0.46793267f, 0.01683159f, -0.15384126f, 0.06096367f, 0.15515712f, 
    0.15707511f, 0.07211227f, -0.01571903f, 0.06291521f, 0.12827168f, 0.06257991f, 0.04403384f, 0.05420861f, 
    0.22388415f, 0.13136439f, 0.07421564f, -0.10069294f, 1.28160155f, -0.58531499f, -0.37125450f, -0.05718594f, 
    -0.39641863f, 0.00158108f, 0.12698650f, 0.08746932f, -0.23358354f, 0.00418802f, 0.26011524f, -0.05617847f, 
    -0.11529350f, -0.18704382f, -0.09960524f, 0.03223263f, -0.02752998f, -0.27523816f, -0.01478436f, 0.09896890f, 
    -0.08039531f, -0.10037422f, -0.14837015f, -0.13303742f, -0.15307961f, 0.05689743f, 0.00694109f, 0.11591908f, 
    0.01024898f, -0.19204324f, -0.00388032f, 0.32650784f, -0.01061532f, 0.03309162f, 0.03818552f, -0.07452801f, 
    -0.02905204f, 0.06338374f, 0.03634602f, 0.02953038f, 0.26852503f, 0.31572133f, -0.19136082f, -0.22057945f, 
    -0.38026536f, 0.07250819f, -0.13106211f, 0.00021969f, -0.18497546f, -0.16837214f, -0.01318176f, -0.06204378f, 
    0.00701266f, -0.04855979f, -0.02955203f, -0.03885734f, -0.19856365f, -0.07846636f, -0.07844571f, -0.35395494f, 
    -0.56899279f, 0.11185975f, -0.16603436f, 0.36357489f, 0.21706383f, 0.07697983f, 0.28582996f, 0.01187977f, 
    0.11490007f, 0.05917851f, 0.01914256f, -0.04775030f, 0.05469031f, 0.06312234f, 0.01806754f, -0.05212903f, 
    -0.00613614f, 0.05998293f, -0.06959908f, 0.10118770f, -0.07445087f, 0.31891987f, 0.14068395f, 0.12129467f, 
    0.15792200f, -0.02810034f, 0.14745855f, 0.04158008f, -0.13559517f, 0.17239818f, 0.06416508f, -0.00760229f, 
    -0.03188199f, 0.02814323f, 0.00359150f, 0.01599037f, 0.27612215f, 0.02939129f, 0.06629509f, -0.02725280f, 
    -0.54158086f, 0.49117121f, -0.16615014f, -0.19222568f, 0.19783904f, -0.09786289f, -0.25043079f, -0.26699910f, 
    0.32149076f, -0.07741357f, -0.06755361f, 0.01690081f, 0.11048480f, 0.05057509f, 0.05478803f, -0.03650632f, 
    -0.03576484f, 0.12428809f, -0.17997774f, -0.05155924f, 0.27914146f, -0.01563232f, -0.14924321f, 0.05047470f, 
    0.06973635f, 0.05830535f, -0.00044456f, 0.00424591f, 0.16489679f, -0.19526960f, -0.09085301f, -0.22226492f, 
    -0.06407410f, -0.11551172f, 0.19350471f, -0.32971209f, 0.07788783f, -0.00060756f, 0.12444866f, -0.25808507f, 
    -0.10091512f, -0.06287690f, -0.10192263f, -0.12454753f, -0.08491594f, 0.14568572f, 0.09877254f, -0.15611078f, 
    0.02027787f, 0.00034669f, 0.03751483f, -0.09120841f, 0.02608706f, 0.19811884f, 0.11088638f, 0.03805542f, 
    -0.01657580f, -0.06953420f, 0.17701165f, 0.01445960f, 0.07819758f, 0.07038964f, 0.05389783f, 0.09670599f, 
    0.15361814f, -0.07025750f, -0.13270909f, -0.02428672f, -0.02171984f, -0.06343844f, 0.07199889f, 0.01963529f, 
    0.10948633f, 0.09889901f, 0.08477046f, -0.24294867f, -0.06291745f, -0.07544424f, -0.00467368f, -0.04726837f, 
    -0.44214383f, 0.25157887f, 0.80828178f, 0.64248312f, 0.44220272f, 0.00772785f, -0.05808125f, 0.00333265f, 
    0.07195966f, 0.05315057f, -0.05668740f, -0.01489065f, 0.06891286f, 0.06847849f, 0.04406130f, 0.00140030f, 
    0.01658911f, -0.02721428f, -0.09264509f, 0.07972173f, -0.00054689f, 0.27565885f, -0.04371961f, 0.18503991f, 
    0.09882939f, 0.04598194f, 0.05182817f, 0.16521202f, 0.08324436f, -0.11459088f, -0.07284037f, -0.02833699f, 
    -0.39507920f, 0.12972714f, 0.09668241f, 0.05252718f, -0.10028973f, 0.09841382f, -0.03170474f, 0.00789620f, 
    -0.47254872f, 0.04256570f, 0.01241941f, -0.26614538f, -0.02922815f, 0.07714333f, 0.00585372f, -0.04832416f, 
    0.07936758f, 0.12797849f, 0.04319303f, 0.02832477f, 0.02767152f, 0.06675230f, -0.00975359f, 0.11918353f, 
    -0.03710189f, -0.37703553f, 0.15917185f, -0.03180538f, 0.05931109f, -0.26173037f, 0.19868307f, 0.03265032f, 
    0.36708957f, 0.07434293f, 0.06310513f, 0.00914030f, 0.09264292f, -0.13218063f, -0.12022826f, -0.01338010f, 
    -0.01887058f, 0.05154761f, 0.08825426f, 0.15023445f, 0.04178029f, 0.14414014f, -0.02238402f, 0.06360075f, 
    -0.19955078f, -0.47871128f, -0.52414715f, -0.48234358f, 0.11353951f, 0.06750609f, -0.04512386f, 0.04655622f, 
    -0.02126942f, 0.05145574f, -0.07448160f, -0.00918433f, -0.00926821f, -0.00557419f, -0.02284237f, 0.10990194f, 
    0.12279037f, 0.00218220f, 0.14616001f, -0.02409931f, -0.65027905f, -0.99798191f, 0.37762898f, -0.33706161f, 
    -0.22763079f, 0.06379011f, -0.04357192f, -0.21071950f, 0.04406611f, -0.06544784f, -0.06001095f, -0.03446754f, 
    -0.06204820f, -0.03674472f, -0.01342513f, -0.13182196f, -0.08631641f, 0.09184030f, 0.09499991f, 0.23728716f, 
    1.05744421f, 0.16547973f, -1.19953668f, 0.02566638f, 0.24285085f, 0.17399088f, 0.08285673f, -0.18599901f, 
    -0.02114590f, -0.08245821f, -0.29458162f, -0.08830708f, -0.04101821f, -0.09458259f, -0.05171910f, -0.06371851f, 
    0.12321802f, 0.13018923f, 0.04884901f, 0.06594776f, -0.14428093f, 0.53749514f, 1.01064980f, 0.15933166f, 
    0.30947986f, -0.03956639f, -0.08931974f, 0.25220415f, 0.05625803f, -0.16441482f, 0.16160800f, 0.02404433f, 
    -0.11359227f, -0.02270855f, 0.15696791f, 0.05394624f, -0.06624351f, -0.04628736f, 0.11674834f, -0.07374511f, 
    -0.11019492f, 0.07918198f, -0.08464291f, 0.09644304f, -0.00044853f, 0.05606189f, -0.11102594f, -0.00063246f, 
    0.15762812f, -0.20598833f, -0.23017985f, -0.08457100f, -0.17285185f, 0.01197507f, -0.00861061f, -0.03729433f, 
    -0.19968423f, -0.02033441f, 0.02286699f, -0.11736219f, -0.87770796f, -0.41480500f, 0.57419878f, 0.02849807f, 
    -0.45476606f, -0.14936435f, 0.12194735f, 0.04844389f, -0.10574881f, 0.07937118f, 0.02677032f, 0.02818520f, 
    0.01311546f, 0.08009400f, -0.03886472f, -0.01671026f, 0.17446843f, 0.19768903f, 0.03437863f, 0.09209980f, 
    -0.07706088f, -0.35121983f, -0.23677872f, 0.18248363f, -0.27266264f, 0.06416885f, 0.09634101f, -0.10457747f, 
    0.12256988f, -0.34151295f, -0.03585970f, 0.12616055f, 0.04853674f, 0.03245329f, -0.06636845f, 0.03907779f, 
    -0.04153643f, -0.08257966f, 0.07197911f, 0.01427426f, 0.07634559f, -0.02332351f, -0.22574587f, 0.08722180f, 
    0.17020687f, 0.00244276f, -0.00828647f, 0.03532054f, 0.00066289f, 0.10626417f, 0.11752211f, 0.15296146f, 
    0.06387719f, 0.09774804f, -0.05785417f, 0.02591234f, 0.01022233f, 0.21853994f, -0.02313446f, 0.02925555f, 
    -0.22773664f, -1.01492107f, -0.85534227f, -0.28238294f, -0.54387152f, 0.26515207f, 0.11636509f, -0.14601816f, 
    0.09242579f, 0.05061011f, -0.01547514f, -0.04368919f, -0.07003505f, -0.03768237f, -0.19079959f, -0.07614043f, 
    -0.01363600f, 0.08988197f, -0.32320577f, 0.03962224f, 0.04277538f, -0.10477231f, -0.05619981f, -0.33843866f, 
    0.03211868f, 0.01205796f, -0.02450892f, -0.01166242f, 0.06515433f, 0.13664620f, 0.03232600f, -0.16555224f, 
    0.07186870f, 0.10650003f, 0.04474335f, 0.32527456f, -0.13943595f, -0.13842483f, 0.14698170f, 0.06313647f, 
    -0.34300977f, -0.09415291f, -0.03224792f, 0.00716877f, 0.05697135f, -0.11962965f, -0.07678983f, -0.30051893f, 
    -0.27477854f, -0.05054051f, 0.11229602f, -0.02490075f, 0.06216041f, 0.08113146f, -0.13102478f, 0.07950068f, 
    -0.08645548f, 0.00479275f, -0.29648814f, -0.04265061f, -0.34832248f, -0.24929810f, -0.08446940f, -0.20578113f, 
    -0.02186191f, -0.08132168f, -0.17296825f, -0.07078607f, 0.07709016f, 0.09093195f, -0.10025479f, -0.13694957f, 
    -0.04436800f, -0.01840122f, -0.14805934f, -0.04421613f, -0.21885239f, -0.10084411f, -0.06882388f, -0.02850763f, 
    -0.12480236f, -0.10065754f, -0.29288259f, -0.09299590f, 0.36431319f, 0.09799940f, 0.09273047f, -0.06063480f, 
    0.01939159f, -0.04713354f, -0.14665267f, 0.00402061f, 0.07148569f, 0.12753984f, 0.08663263f, -0.09135209f, 
    0.17134562f, 0.10886096f, 0.05012647f, 0.05300754f, -0.60881335f, -0.19195028f, -0.44825411f, -0.35295647f, 
    0.16675624f, 0.34849748f, -0.00566121f, -0.00734407f, 0.16854514f, -0.43843082f, -0.02293485f, -0.08774336f, 
    -0.28323570f, -0.10685240f, -0.06173164f, 0.04258726f, 0.31647441f, 0.38918364f, -0.07781427f, -0.19793728f, 
    -1.14617443f, 0.32967713f, -0.52370012f, 0.55661386f, -0.55328375f, 0.24732147f, -0.52029252f, 0.11938588f, 
    -0.05202886f, -0.22368398f, -0.04453829f, 0.03024687f, 0.01718977f, -0.20867808f, -0.11284537f, -0.00410404f, 
    0.15302484f, 0.01698523f, 0.09687269f, -0.13125241f, 0.55508751f, 0.56812549f, 0.02315711f, -0.44716850f, 
    -0.17958122f, 0.55978566f, 0.14181916f, 0.01325020f, -0.15079334f, -0.06420799f, -0.37838358f, -0.20191103f, 
    0.20378056f, -0.16015175f, 0.06958345f, -0.09711678f, -0.02511396f, -0.36228088f, 0.00410921f, 0.19893573f, 
    0.04551345f, -0.39376870f, -0.00657109f, 0.30616596f, -0.43424138f, 0.29068431f, 0.19272763f, 0.09065575f, 
    0.37901166f, 0.23247799f, -0.09622435f, -0.16380903f, 0.24107891f, 0.05788597f, -0.03472336f, 0.10519657f, 
    -0.09094882f, -0.37387145f, 0.03186640f, 0.09104968f, 0.15994032f, -0.40424696f, -0.03750347f, 0.01199547f, 
    0.50383532f, -0.42088291f, 0.11908685f, 0.06039745f, 0.14808524f, 0.16397099f, 0.01090531f, -0.00961713f, 
    -0.02014776f, -0.19733608f, -0.07679465f, 0.01472570f, 0.01585959f, -0.02410754f, 0.15254562f, -0.11015888f, 
    0.67553931f, 1.20090914f, -0.12528212f, -1.00919724f, 0.01608712f, 0.14955162f, -0.24211480f, -0.09286509f, 
    -0.02365877f, -0.17560923f, 0.04849507f, -0.05661640f, -0.14017275f, -0.06688669f, -0.03208512f, 0.20971224f, 
    -0.11836886f, 0.15561987f, 0.12141413f, -0.06892896f, -0.35116211f, 0.79289633f, -0.01943744f, 0.13209130f, 
    0.51986384f, 0.28804994f, -0.00828395f, 0.00694750f, -0.22999439f, -0.04359685f, -0.23592819f, 0.03968003f, 
    0.12447609f, 0.00181603f, 0.07610302f, -0.00552741f, 0.09870689f, 0.00402014f, -0.12382420f, -0.12125704f, 
    -0.66146719f, -0.30435604f, -0.16551974f, -0.02382305f, 0.38010347f, 0.21313138f, 0.24649373f, 0.02431548f, 
    -0.02996168f, 0.13782273f, -0.05993455f, 0.02958741f, 0.10547334f, 0.02435328f, -0.34812024f, 0.18450142f, 
    -0.14438824f, 0.24963209f, 0.00884442f, -0.05861677f, -0.05741846f, -0.61896968f, 0.61081803f, 0.22778733f, 
    0.45138171f, -0.18817325f, 0.15596123f, 0.12203179f, 0.16385105f, -0.02551023f, 0.04869152f, 0.04618172f, 
    -0.15503612f, 0.04244958f, 0.06441639f, -0.07090613f, 0.08163278f, -0.00717062f, -0.04731566f, -0.08241101f, 
    -0.23912139f, -0.01349006f, -0.55595404f, 0.03675219f, 0.40739149f, 0.23242851f, 0.04931178f, 0.13826990f, 
    0.02357531f, 0.13638298f, -0.12321497f, -0.00165731f, 0.03646281f, -0.04444106f, 0.01931443f, 0.12700576f, 
    -0.15956940f, 0.16033804f, -0.13309583f, -0.01280687f, -0.56308722f, -0.25499317f, -0.16446060f, -0.54607379f, 
    -0.65053439f, -0.06223574f, 0.05429042f, -0.42368504f, -0.12199453f, -0.20694797f, -0.04497998f, 0.02290094f, 
    -0.18882465f, -0.06652351f, -0.03073722f, -0.12411395f, 0.01751613f, -0.05780325f, -0.13594618f, 0.03214386f, 
    0.39418098f, -0.06551282f, 0.06928070f, -0.01172849f, 0.47960076f, 0.02892138f, 0.17148143f, -0.13882624f, 
    0.11603810f, -0.02118532f, 0.08428617f, 0.01749496f, -0.08377725f, -0.14423414f, -0.06208890f, -0.00143846f, 
    -0.18248229f, 0.08900460f, -0.43981975f, 0.05589741f, -0.51111823f, 0.50356007f, -0.16729359f, -0.20970379f, 
    -0.25407621f, 0.00263634f, -0.15706572f, 0.02429342f, -0.06136599f, -0.05637138f, 0.21566331f, -0.15448871f, 
    0.00867917f, 0.22230442f, -0.07772523f, 0.13468963f, -0.28145573f, 0.10901628f, -0.11827625f, 0.05779237f, 
    0.02441813f, 0.01498008f, 0.24336489f, 0.08137092f, 0.28137073f, 0.18960816f, 0.01107688f, 0.18402047f, 
    0.09034385f, -0.00631951f, 0.17329940f, 0.00526927f, -0.05491696f, -0.01221973f, 0.16063672f, -0.05525330f, 
    -0.02543344f, 0.10731628f, -0.07122519f, 0.03969627f, -0.48688897f, -0.83780730f, -0.34533620f, 0.19408143f, 
    -0.48060748f, -0.23435202f, -0.07030914f, -0.35027122f, -0.16055776f, -0.14599228f, -0.01626934f, 0.16263205f, 
    -0.13903134f, -0.25709158f, -0.07760627f, 0.08892072f, 0.16113827f, 0.22568186f, -0.38769525f, -0.17566893f, 
    -0.13008575f, -0.26578438f, 0.06631055f, 0.12767820f, 0.07986464f, -0.38385195f, -0.01587141f, -0.12362108f, 
    -0.20898968f, -0.17264992f, 0.04643831f, 0.01593374f, -0.07377751f, 0.13232918f, 0.03806577f, -0.02376523f, 
    0.13579020f, 0.01900987f, 0.05150016f, 0.18744467f, 0.27088726f, 0.20456040f, 0.15143098f, 0.06292929f, 
    -0.02455598f, -0.17263068f, -0.12089451f, -0.07014254f, -0.00308208f, 0.03810483f, 0.18019772f, 0.02486182f, 
    -0.12090785f, -0.05944950f, -0.05786698f, 0.08487477f, -0.14035290f, -0.08973619f, -0.05813771f, -0.01319805f, 
    0.13248101f, -0.17300481f, -0.09543196f, -0.05840968f, 0.08946843f, 0.12310276f, -0.00131703f, 0.00459246f, 
    0.03979795f, 0.06029533f, 0.06168616f, 0.02289794f, -0.04813755f, 0.05283009f, 0.01892959f, -0.12868533f, 
    -0.02277121f, -0.09669140f, -0.16083431f, -0.12144363f, 0.09216088f, -0.40191808f, -0.00487063f, -0.16474949f, 
    -0.17891510f, -0.15515287f, -0.28127998f, 0.00070522f, -0.11095320f, 0.19718349f, 0.05241383f, -0.02076827f, 
    0.01350792f, -0.16836949f, -0.32188410f, 0.03582226f, -0.05071642f, 0.07045199f, -0.09139577f, 0.08042277f, 
    0.19508331f, 0.14633194f, -0.09070456f, -0.18003181f, -0.44067934f, 0.12211093f, 0.00384685f, -0.00580490f, 
    0.05151165f, 0.11089820f, 0.20468570f, 0.01451495f, 0.00346671f, -0.04510502f, -0.09960128f, -0.29193357f, 
    0.04658582f, 0.06986848f, -0.22840963f, 0.33376861f, 0.11690032f, 0.32009190f, 0.22872484f, 0.24692181f, 
    0.03310225f, 0.03780979f, 0.26335400f, 0.09175855f, 0.21360074f, 0.08492192f, 0.09771828f, -0.09079748f, 
    -0.10364261f, -0.00213661f, -0.06740329f, -0.00738115f, 0.09810721f, -0.11534047f, 0.17031898f, 0.31198975f, 
    0.20249325f, -1.32472730f, -0.63159776f, 0.33173174f, -0.57457119f, -0.20607971f, -0.31418997f, -0.02033640f, 
    -0.24043474f, -0.05861387f, -0.10764974f, -0.16138680f, 0.11505010f, 0.11763842f, -0.13267320f, -0.14232670f, 
    -0.19607608f, -0.00043781f, -0.15975007f, -0.10461954f, -0.14441437f, -0.26643968f, 0.14465655f, -0.05579070f, 
    -0.08357009f, -0.21462096f, -0.10602550f, -0.24905920f, -0.14964473f, -0.06293513f, 0.15009974f, -0.18983863f, 
    -0.06258103f, -0.00508596f, -0.04640066f, 0.01439325f, 0.10128259f, -0.04018831f, -0.10579120f, -0.12982206f, 
    0.31111589f, 0.17717203f, 0.11932989f, -0.00667150f, -0.02365214f, 0.09452743f, 0.03762373f, 0.05671843f, 
    -0.03024162f, 0.22792660f, 0.13286033f, -0.13707645f, 0.08453163f, 0.03617829f, -0.03866397f, 0.09462599f, 
    0.01593059f, -0.11706144f, -0.07063114f, -0.09643400f, 0.20462613f, 0.30595264f, -0.45654756f, 0.13214140f, 
    0.34715381f, -0.18007097f, 0.01255104f, -0.00542619f, 0.25624052f, 0.09695958f, 0.05994752f, -0.04042985f, 
    0.00325834f, 0.04579210f, 0.00089636f, -0.01176641f, 0.17785482f, 0.04552025f, 0.02125778f, 0.24780671f, 
    0.37202054f, 0.09798580f, 0.55116534f, 0.18211360f, 0.16598420f, -0.18050648f, -0.24823381f, -0.05742811f, 
    -0.20780694f, 0.11174466f, 0.09342729f, 0.08324695f, 0.04461366f, 0.02938377f, -0.00347235f, -0.02474505f, 
    -0.00346367f, -0.07557702f, -0.02020868f, -0.32495314f, -0.48796302f, 0.00547121f, -0.07852387f, -0.46914133f, 
    -0.05446490f, 0.01071033f, -0.15799728f, -0.01075528f, 0.26853111f, -0.07963163f, 0.11040832f, -0.08067764f, 
    0.05576404f, -0.14224935f, 0.01116839f, -0.04216407f, -0.35420400f, -0.15413433f, -0.08290958f, 0.24921963f, 
    -0.25842959f, 0.29075354f, 0.20790392f, 0.58576781f, -0.04256256f, -0.10717273f, 0.10092161f, 0.05675127f, 
    0.02415886f, 0.08248092f, 0.00212196f, -0.02724031f, -0.02708221f, 0.00546183f, 0.06650092f, 0.00745033f, 
    -0.08127605f, -0.25510040f, -0.08210581f, 0.02266947f, 0.05896828f, -0.08636526f, -0.17601898f, 0.31165621f, 
    -0.04870825f, -0.02170681f, -0.10821354f, 0.18853061f, -0.13585235f, 0.00444767f, -0.19627120f, -0.03184504f, 
    -0.03918396f, -0.09015696f, 0.01083089f, 0.08923103f, -0.08364676f, -0.17188424f, -0.09764077f, 0.02516812f, 
    -0.02883656f, 0.12206253f, 0.12853639f, -0.02885601f, 0.15054820f, 0.05595662f, 0.16907834f, 0.00182824f, 
    -0.01784751f, 0.22596470f, 0.06785560f, 0.02333197f, 0.02460158f, -0.12975343f, 0.04961742f, -0.03706715f, 
    -0.09246949f, -0.16631933f, -0.02925469f, -0.31243199f, 0.09866867f, 0.01166324f, 0.04530984f, -0.00236625f, 
    0.04591081f, 0.24342653f, 0.23315410f, 0.04763366f, 0.01576827f, 0.08009626f, 0.10720263f, 0.06578618f, 
    -0.00981163f, -0.04624593f, 0.15305267f, 0.11679877f, -0.00743612f, -0.07354285f, 0.01986381f, -0.00749072f, 
    -0.42226836f, 0.21948682f, -0.02936048f, -0.07684395f, -0.20198199f, 0.04282748f, 0.08537038f, 0.04760856f, 
    -0.03165880f, 0.13155900f, 0.06597095f, -0.07115950f, -0.09825616f, 0.08348478f, -0.01283812f, -0.19723561f, 
    -0.08357716f, -0.03016199f, -0.05802688f, -0.30234441f, -0.20735385f, -0.12772009f, -0.10180042f, 0.06950535f, 
    0.09194399f, 0.04455788f, 0.04531485f, -0.11911028f, -0.11116771f, 0.20398548f, 0.15409982f, -0.24118975f, 
    0.44290122f, 0.01843318f, -0.02025908f, 0.11225715f, 0.05479766f, 0.04593787f, 0.21619731f, 0.07712571f, 
    -0.04987816f, -0.23174414f, -0.26938602f, -0.34385970f, 0.40998113f, 0.04374760f, 0.11124625f, 0.03653964f, 
    -0.04588974f, 0.05968972f, 0.18468994f, -0.18789102f, -0.16703278f, 0.00166966f, 0.09268412f, -0.17206627f, 
    0.20866834f, 0.03840259f, 0.00235130f, -0.04658275f, -0.55870205f, 0.81750304f, -0.57094407f, -0.09700259f, 
    -0.08535646f, -0.03328726f, -0.10164336f, -0.11772958f, 0.03420567f, -0.06421725f, 0.23093185f, 0.12923221f, 
    -0.18568864f, 0.06559841f, 0.13102484f, -0.25028974f, -0.01998377f, 0.19640420f, 0.00742546f, -0.14994645f, 
    0.01388500f, -0.14106750f, -0.28278288f, 0.16877741f, 0.23017925f, 0.01930567f, -0.08837043f, -0.07993384f, 
    -0.07951722f, -0.08234293f, 0.06513812f, -0.17454590f, -0.08071401f, 0.17439651f, 0.14163110f, -0.13981941f, 
    -0.14134409f, 0.35819829f, -0.01224381f, -0.26778895f, 0.35196191f, 0.25973076f, 0.22950475f, 0.24544185f, 
    0.02078431f, 0.06868479f, -0.04509576f, 0.12881953f, 0.15280947f, 0.04482944f, 0.14942618f, 0.08273366f, 
    -0.02386419f, 0.00589591f, 0.00122805f, 0.10930103f, 0.02719560f, -0.00338209f, -0.41708231f, -0.43724808f, 
    -0.71394926f, -0.21499231f, 0.50780082f, 0.48729256f, -0.50158381f, 0.09046021f, -0.06340071f, -0.17328963f, 
    0.13220631f, 0.12695691f, 0.16256833f, 0.04914895f, -0.22697434f, -0.08214012f, 0.07505037f, 0.18219241f, 
    -0.04590500f, -0.16873582f, -0.09674474f, 0.10318546f, -0.50571376f, -0.12245950f, -0.49318540f, -0.50225407f, 
    -0.05120458f, 0.11850407f, -0.08370291f, -0.02108613f, -0.04245605f, 0.13337317f, -0.13104206f, 0.11350738f, 
    0.04300531f, -0.12048345f, -0.09742098f, -0.07669634f, -0.04286736f, 0.24066609f, -0.10126010f, 0.12352251f, 
    0.06078625f, 0.03464118f, -0.01795154f, -0.19622377f, 0.04271350f, -0.10202397f, -0.00856047f, -0.03193546f, 
    -0.18109329f, 0.08178952f, 0.18042749f, -0.22895245f, 0.13210431f, -0.09424611f, -0.10725904f, 0.10556126f, 
    0.16236438f, -0.05188282f, 0.03472416f, 0.03499895f, 0.09895423f, -0.21559660f, -0.09738292f, -0.07390894f, 
    -0.29665521f, 0.16629009f, 0.07462694f, -0.12783550f, -0.09682874f, 0.22610766f, 0.03511654f, 0.06103618f, 
    0.03522738f, 0.01928784f, -0.03834986f, -0.13937081f, -0.31035760f, 0.09217865f, -0.05737192f, 0.00578129f, 
    0.20752259f, -0.22018820f, 0.38177761f, -0.29880935f, -0.18103196f, 0.13293459f, 0.21231437f, 0.05828484f, 
    0.02409189f, -0.01187682f, 0.05957955f, 0.00068530f, -0.02452555f, -0.07438444f, -0.04237072f, -0.06353183f, 
    0.09027075f, -0.04289525f, 0.25192502f, 0.11346286f, 0.42779198f, -0.73580807f, -0.28961456f, 0.25234249f, 
    -0.08241297f, 0.13005802f, -0.38576457f, -0.08408643f, 0.01120636f, 0.15162674f, -0.06166898f, 0.09567222f, 
    0.03780705f, 0.06233616f, 0.25187656f, -0.00672441f, -0.05629409f, 0.07212317f, 0.16346689f, -0.04973895f, 
    0.09316070f, -0.41657332f, 0.38052025f, 0.10346440f, -0.62331873f, 0.10186058f, 0.00603592f, 0.00030950f, 
    -0.16495612f, -0.06862830f, 0.03816653f, -0.05469705f, 0.01492816f, 0.05452579f, 0.18985102f, -0.06961521f, 
    0.01917814f, 0.03133554f, 0.04750675f, 0.08963657f, -0.26684731f, 0.07743232f, 0.03617100f, -0.37032324f, 
    0.15656765f, 0.08246124f, -0.17152476f, -0.32017395f, -0.17097150f, 0.03877738f, 0.38849309f, 0.48785320f, 
    0.21709378f, 0.26829666f, -0.15412843f, -0.10592531f, -0.07463093f, 0.07853141f, 0.18717167f, 0.07167197f, 
    0.05738672f, -0.05942979f, -0.07535578f, 0.08225486f, 0.01734771f, -0.08572153f, -0.13991217f, 0.04426988f, 
    -0.04936940f, -0.06921566f, -0.18967755f, 0.04928932f, -0.12218293f, -0.06389660f, -0.07116526f, 0.03225780f, 
    0.13222021f, 0.08040629f, -0.27125677f, 0.20977093f, -0.05966275f, -0.12192927f, -0.16685645f, 0.10011704f, 
    0.06194193f, 0.10618757f, -0.02277550f, -0.06902374f, -0.07932456f, 0.10958882f, 0.12165452f, -0.20295125f, 
    0.03202860f, 0.04254765f, 0.11886656f, 0.22807811f, -0.01886765f, 0.06175242f, -0.06451952f, 0.07168625f, 
    -0.18713929f, -1.07621980f, -0.74869567f, -0.02426218f, 0.53732854f, -0.24313045f, -0.18005864f, 0.01345664f, 
    0.06105381f, 0.00775963f, -0.00823866f, -0.02253495f, 0.07821918f, -0.03005790f, -0.15094306f, 0.01857460f, 
    -0.05496171f, -0.01221511f, 0.16129461f, 0.03189449f, -0.22436404f, 0.27554408f, 0.10128009f, 0.08057770f, 
    0.03055119f, -0.14051166f, 0.00700214f, -0.01375445f, 0.08896744f, 0.10429656f, 0.13036433f, -0.01732852f, 
    0.08414643f, 0.16606452f, 0.11564878f, 0.03923388f, 0.06666613f, -0.07957178f, 0.01416666f, -0.04007790f, 
    0.24954344f, -0.10170560f, -0.09595308f, 0.12331221f, -0.16064723f, 0.07017715f, -0.00584719f, 0.08049761f, 
    -0.07719373f, -0.00904092f, 0.03072100f, -0.00610199f, -0.03138618f, -0.03400041f, 0.13714206f, 0.28924143f, 
    0.12310845f, 0.09281176f, -0.24156821f, 0.10952567f, -0.11035281f, -0.06013516f, 0.21167684f, 0.09872901f, 
    0.07006191f, 0.04688756f, -0.15779796f, 0.06049378f, -0.02262210f, 0.22294685f, -0.14284138f, 0.12753373f, 
    0.28141907f, 0.10193966f, -0.02592070f, 0.03940560f, 0.09082307f, -0.10435230f, 0.04663943f, -0.02311708f, 
    -0.28448027f, -0.05205448f, 0.04395219f, -0.23893243f, -0.05307071f, -0.08378981f, 0.02728766f, -0.00632144f, 
    -0.10947338f, 0.05423854f, 0.00203719f, -0.23682238f, -0.02345636f, -0.01662738f, -0.12993437f, -0.06145347f, 
    0.01076076f, -0.06507554f, 0.01890512f, 0.04544677f, -0.91711247f, -1.16196620f, -1.34235561f, -0.02763783f, 
    0.25766283f, -0.26674151f, 0.19829720f, 0.09015721f, -0.01453027f, -0.54832572f, 0.05201214f, 0.01756553f, 
    -0.00977303f, 0.10374879f, 0.12026027f, 0.01311805f, -0.01566734f, 0.29202145f, 0.25973246f, 0.17698333f, 
    -0.61775833f, -0.08970322f, -0.20292068f, 0.42983061f, 0.36783379f, -0.00506357f, 0.32702401f, -0.14451739f, 
    0.00576742f, 0.55178636f, 0.13395762f, 0.19013268f, 0.26248690f, 0.01790112f, -0.03211280f, -0.06181612f, 
    0.16369353f, -0.14519310f, 0.26466826f, -0.15060402f, -0.64732891f, 0.98269117f, 0.46202138f, 0.06848908f, 
    0.43284783f, -0.01262484f, 0.00374616f, -0.06123335f, 0.03829533f, 0.03466631f, 0.12277294f, 0.06859843f, 
    0.24500871f, 0.09761517f, -0.02738006f, 0.07313892f, -0.04813265f, 0.02303704f, -0.02083471f, -0.06486456f, 
    -0.11629554f, 0.30051282f, 0.21205051f, -0.09995092f, -0.11470015f, -0.07608888f, -0.01348058f, -0.16702566f, 
    -0.18931891f, -0.09885661f, -0.01410354f, -0.25213724f, -0.05739802f, 0.02918101f, 0.01574623f, -0.03389217f, 
    -0.17232887f, -0.03724629f, -0.08606946f, -0.11264744f, -0.37028849f, -0.10064977f, -1.07947803f, -0.52168792f, 
    0.08766107f, -0.08921263f, 0.14027990f, 0.27074659f, -0.01048140f, -0.02983349f, -0.00673419f, -0.00034734f, 
    0.05254354f, -0.02155277f, 0.05865385f, -0.06247182f, 0.03861332f, -0.03694738f, 0.08015646f, 0.13807414f, 
    -1.02422738f, 0.25279972f, -0.00664608f, 0.04391230f, -0.60082775f, -0.61146241f, 0.12321055f, -0.27949950f, 
    0.05990107f, -0.32523474f, 0.02343029f, -0.00906533f, -0.06947161f, -0.05702101f, 0.01007265f, 0.00251128f, 
    -0.03878557f, 0.13533632f, -0.04093692f, -0.36245480f, 0.10690202f, 0.19876623f, -0.36387599f, 0.00711164f, 
    0.04696316f, 0.05405197f, -0.01552228f, 0.04912478f, -0.07381378f, 0.13857995f, -0.06173158f, 0.09701768f, 
    0.09723534f, 0.07868049f, 0.02361122f, 0.09256963f, 0.20493990f, -0.35775161f, 0.20732053f, 0.10256521f, 
    -1.03611672f, -1.79942513f, -1.08827257f, -0.25567299f, 0.79527879f, -0.06755767f, 0.21951343f, -0.30660975f, 
    -0.29150236f, -0.56142086f, -0.08538201f, -0.02780385f, -0.14117596f, -0.06683154f, 0.11624289f, 0.02687181f, 
    0.00126265f, 0.02844461f, 0.34330902f, 0.05159953f, -0.02327638f, -0.17208485f, -0.01904002f, 0.14625002f, 
    -0.26063651f, 0.13057771f, -0.01645755f, 0.03347919f, -0.02342019f, 0.17396669f, 0.16683090f, -0.02936130f, 
    -0.02911942f, -0.12786278f, -0.05442077f, 0.34151587f, 0.13457111f, -0.11519100f, -0.08199938f, -0.02260156f, 
    0.31317136f, -0.09205957f, -0.35153374f, -0.15985167f, 0.15959489f, -0.16137411f, -0.00990763f, 0.06308793f, 
    0.18953618f, -0.08689352f, 0.04368357f, 0.01245238f, -0.29079798f, -0.06590094f, 0.10341081f, -0.05280922f, 
    -0.05697782f, 0.10717302f, 0.13534130f, -0.15513115f, 0.16824353f, -0.21879373f, -0.16541669f, -0.22121109f, 
    -0.06782823f, -0.02151681f, -0.02613209f, 0.03551767f, -0.01488924f, 0.06271244f, -0.12060763f, -0.10487358f, 
    -0.24646248f, -0.39806572f, -0.08479033f, -0.28072253f, -0.06791022f, -0.12584333f, -0.01715868f, -0.02647412f, 
    1.08267653f, -1.13359821f, -0.89665723f, -0.97915548f, -0.26590756f, -0.04341774f, -0.17466477f, -0.07370824f, 
    0.11820460f, -0.04766137f, 0.03155922f, 0.00290613f, 0.01356319f, -0.08253719f, -0.04873570f, -0.23760766f, 
    -0.00027087f, -0.01815808f, 0.04783776f, 0.01890430f, 0.25568643f, 0.10987245f, -0.03282339f, -0.26518220f, 
    -0.09932219f, -0.02838340f, 0.00570049f, 0.00733228f, -0.04971446f, 0.03570835f, -0.01747835f, -0.09635245f, 
    0.08983982f, -0.13649686f, -0.02361866f, -0.02809809f, -0.10536664f, 0.00800125f, 0.04187253f, -0.14093299f, 
    -0.01108542f, 0.12741043f, 0.20257081f, -0.15559149f, -0.08299643f, -0.07120495f, 0.00060190f, 0.05767790f, 
    -0.14789775f, -0.03701444f, 0.07082006f, -0.04659541f, 0.01667607f, 0.01624128f, -0.08699201f, -0.09609929f, 
    -0.27885562f, -0.27131587f, 0.07231363f, -0.00388718f, 0.42779595f, 0.40804663f, -0.03326849f, -0.21195625f, 
    -0.24652937f, -0.00241751f, 0.09831006f, -0.01932559f, -0.01177679f, -0.17388670f, 0.02639390f, -0.07730480f, 
    -0.18303473f, -0.28179339f, -0.38326791f, -0.01371597f, -0.03774592f, -0.12744568f, 0.06214947f, 0.06489977f, 
    0.01304318f, 0.20053652f, -0.14838988f, 0.17485325f, -0.32765019f, 0.03257250f, 0.08569236f, 0.03404270f, 
    -0.02571242f, 0.02139375f, -0.04019359f, 0.07139499f, -0.04262728f, -0.06416885f, 0.01031007f, 0.10485786f, 
    0.04117468f, 0.06950306f, -0.02413970f, 0.03002336f, -0.92281556f, -0.69732845f, 0.06515017f, 0.35780093f, 
    -0.00705667f, 0.08197465f, -0.09477084f, 0.06620210f, 0.03527826f, 0.23708579f, 0.05382998f, -0.05966506f, 
    0.02515948f, -0.06739883f, -0.06289197f, 0.14303826f, 0.22931367f, 0.01598737f, -0.02286966f, -0.03555569f, 
    0.91820759f, 0.72594124f, -0.23422237f, 0.16721191f, 0.01456878f, 0.28167382f, 0.26675805f, -0.19456896f, 
    -0.00249570f, -0.36467499f, -0.24549916f, 0.17003287f, 0.24401736f, 0.02673057f, 0.04019002f, -0.25775278f, 
    -0.16609013f, -0.00155890f, -0.08251759f, -0.43783489f, -0.26823893f, -0.26673353f, -0.20821673f, -0.13355701f, 
    -0.17351124f, -0.02555040f, -0.09074780f, 0.20303157f, -0.05542552f, -0.06219856f, -0.13223933f, 0.08728862f, 
    0.18450549f, 0.10274137f, -0.00170945f, 0.01352919f, -0.01842159f, 0.04073173f, 0.00676655f, 0.07295933f, 
    -0.10065327f, -0.04790763f, -0.02812335f, -0.04427604f, 0.08895976f, 0.01919347f, 0.08416168f, 0.06036681f, 
    -0.04898282f, -0.01082332f, -0.18627843f, -0.04913099f, 0.19524361f, 0.11938389f, 0.04956335f, 0.02387042f, 
    0.05202778f, -0.04994333f, 0.02814754f, -0.08641185f, -0.72261035f, 0.48219186f, 0.08845339f, 0.10761634f, 
    -0.13270652f, 0.19716021f, 0.09127073f, -0.08785199f, -0.27892101f, -0.09102201f, 0.06201867f, -0.00492856f, 
    0.05875159f, 0.05483387f, 0.03847873f, 0.19443649f, 0.33363536f, -0.14859311f, -0.08012810f, -0.11174265f, 
    0.04444325f, -1.11330879f, -0.32093942f, -0.28549227f, 0.27326182f, -0.05137295f, -0.02707885f, 0.16286302f, 
    0.00944193f, -0.04369859f, -0.02381261f, 0.05769761f, 0.06399349f, 0.01667218f, 0.07545687f, 0.01074146f, 
    0.02270196f, -0.07074367f, -0.13950638f, -0.07849580f, 0.17918521f, 0.07119005f, 0.00311740f, 0.08896555f, 
    -0.11486904f, 0.05473672f, 0.10409825f, -0.02208053f, -0.18099144f, -0.11651646f, 0.01609757f, 0.02732416f, 
    -0.09641967f, -0.07169730f, -0.01999201f, -0.12362700f, -0.28685081f, -0.01210482f, -0.06921946f, 0.07903685f, 
    -0.50307500f, -1.32269967f, 0.20600612f, 1.13546193f, 0.23624633f, -0.09063277f, 0.11498295f, 0.06882125f, 
    0.02222556f, 0.31609386f, 0.12728146f, 0.03686044f, -0.11231598f, -0.05279123f, -0.03178583f, -0.01834973f, 
    0.00021543f, -0.19507508f, 0.14328927f, -0.07543910f, 0.08925653f, 0.07728014f, 0.19944969f, -0.23520124f, 
    -0.06344965f, 0.07110821f, 0.06091218f, 0.02381216f, 0.01620018f, -0.10084195f, -0.01045075f, -0.11951295f, 
    -0.05214958f, -0.28411901f, -0.04948441f, -0.10672956f, -0.12450537f, 0.07561927f, -0.06947669f, -0.06897549f, 
    -0.36727089f, -0.26860940f, -0.09038492f, 0.12840557f, -0.18108675f, 0.09272526f, -0.09442375f, 0.22234347f, 
    0.10367493f, 0.16340888f, 0.10576864f, 0.04815912f, 0.09968072f, -0.02654766f, -0.03605181f, 0.04587677f, 
    0.02649273f, -0.01176840f, -0.00365723f, 0.02582821f, 0.03074477f, 0.18068855f, 0.00348821f, -0.06687682f, 
    -0.16243546f, -0.02170859f, 0.04763760f, 0.08592848f, 0.05525533f, -0.04710434f, 0.02871968f, -0.13069013f, 
    -0.00150335f, -0.05199176f, -0.08104318f, -0.00585960f, -0.02923158f, 0.04705402f, 0.06687173f, 0.00803407f, 
    -0.34760198f, -0.42536640f, -1.31895280f, -0.51589328f, 0.06403939f, -0.11196114f, -0.03713032f, 0.23727114f, 
    0.09559067f, -0.15137117f, 0.02782774f, -0.07825061f, -0.12980984f, 0.06947564f, 0.09753065f, 0.19379696f, 
    -0.06061551f, 0.06583147f, -0.13262665f, -0.12707616f, -0.10739904f, -0.27568308f, -0.36527640f, 0.11389165f, 
    -0.05077013f, -0.07683295f, 0.03295451f, 0.23917925f, 0.05148097f, 0.18906689f, 0.03664180f, 0.03090146f, 
    0.01007259f, 0.07828871f, 0.06802959f, -0.02819025f, 0.11209040f, -0.06574322f, 0.11556498f, 0.08806495f, 
    -0.29714298f, 0.10344239f, 0.17368317f, 0.24913844f, -0.04448580f, -0.04500984f, 0.00716144f, -0.08038364f, 
    -0.04534299f, 0.11449502f, 0.02673424f, 0.04266807f, 0.07377683f, 0.00776441f, 0.10841405f, -0.04597289f, 
    -0.11312135f, 0.02078749f, -0.12933193f, 0.13789609f, -0.10989057f, -0.15827920f, -0.10283084f, -0.20477565f, 
    -0.19462182f, -0.07808236f, 0.02446158f, 0.00148575f, 0.17435651f, -0.11914749f, 0.16196892f, 0.12880810f, 
    0.10621998f, -0.00493093f, 0.16765264f, -0.09591833f, -0.03285770f, 0.01602912f, -0.01145604f, 0.01664541f, 
    -0.54394042f, 0.20596935f, 0.32175440f, -0.00059045f, -0.31007180f, -0.17910048f, -0.07720324f, -0.14782739f, 
    -0.05487689f, -0.13261241f, -0.21532567f, -0.03362275f, 0.09692310f, -0.14487898f, 0.04647132f, -0.00778257f, 
    -0.00533830f, -0.10956657f, -0.00064420f, -0.24263145f, -0.00171606f, -0.12623847f, 0.12250204f, -0.11186571f, 
    -0.11547837f, 0.05394403f, -0.17584433f, -0.18180591f, -0.11592941f, -0.42686686f, -0.03135106f, 0.02678205f, 
    0.13590035f, -0.05208495f, 0.00702845f, 0.16430832f, -0.00286812f, -0.09406221f, -0.13302560f, -0.47267240f, 
    0.84145349f, -0.00057265f, -0.49519193f, -0.38398853f, 0.07548144f, 0.24103576f, -0.07663309f, -0.10032000f, 
    0.08776575f, -0.11542182f, 0.02199828f, 0.13086002f, 0.23734064f, 0.17874485f, 0.10405713f, 0.02906368f, 
    -0.23295647f, -0.30952710f, 0.01052888f, 0.02644601f, -0.48684829f, -0.95324510f, -0.28406411f, -0.02192740f, 
    0.25767416f, -0.12035401f, 0.27418414f, 0.18293791f, 0.11457608f, 0.08618832f, 0.11527315f, 0.02900256f, 
    -0.00807246f, 0.12944517f, -0.04893012f, -0.00681727f, 0.11301225f, -0.12094326f, 0.12182434f, -0.06269495f, 
    -0.26976332f, -0.30385637f, -0.21380441f, 0.03609748f, -0.00001696f, -0.08354609f, -0.09560451f, -0.04303972f, 
    0.02532560f, 0.02145734f, 0.09175408f, 0.03457187f, -0.12197407f, -0.08912840f, 0.04758912f, -0.13001518f, 
    0.26593599f, 0.23798153f, 0.23205981f, 0.17132586f, -0.28973949f, 0.35057467f, 0.44031215f, 0.35981157f, 
    0.06798805f, 0.16465044f, -0.25389603f, -0.10986916f, -0.17618312f, -0.20129524f, -0.02003797f, -0.08256086f, 
    0.00978667f, -0.13559543f, -0.11379227f, -0.20448434f, -0.31174800f, -0.00879564f, -0.26185265f, -0.35197932f, 
    0.30476990f, -1.05860591f, -1.08562624f, -0.03307519f, 0.01280560f, -0.14405319f, 0.06284104f, -0.07103214f, 
    0.03392703f, 0.31534103f, -0.14509961f, -0.14702855f, -0.03910515f, -0.03904728f, 0.05858180f, -0.06900200f, 
    0.09979037f, 0.10506345f, 0.13118660f, 0.12751321f, 0.30715930f, 0.46896413f, 0.07059202f, 0.04062147f, 
    -0.01577815f, -0.06415545f, -0.01943331f, -0.01004739f, 0.06966178f, 0.01423095f, 0.16734116f, -0.01354276f, 
    -0.01281692f, 0.09853557f, 0.00415805f, -0.06137897f, -0.05050562f, -0.00923879f, 0.11892408f, -0.17786416f, 
    1.04371333f, -0.24088268f, -0.19547637f, -0.33010837f, -0.29102966f, 0.13730942f, -0.08824297f, -0.12799081f, 
    0.13605471f, -0.19021526f, -0.00862487f, 0.13593718f, 0.24550797f, -0.04078633f, 0.05011346f, 0.04148992f, 
    0.15654559f, 0.12999345f, 0.08544448f, 0.07086673f, -0.22713600f, 0.01766251f, 0.05445692f, 0.04666680f, 
    -0.03627100f, 0.07753171f, -0.03816908f, 0.12176617f, 0.17429695f, -0.01419399f, -0.14116742f, 0.02623060f, 
    -0.13837339f, 0.03617330f, 0.10610501f, 0.02055633f, 0.15827987f, -0.05378983f, -0.06169101f, 0.11220428f, 
    0.38667649f, 0.01287781f, -0.14061762f, 0.04532062f, -0.20219316f, -0.04148356f, 0.02688953f, -0.26079291f, 
    -0.26951268f, -0.35521030f, -0.00828233f, 0.07271495f, 0.17049590f, 0.07158873f, -0.06287839f, -0.06911399f, 
    0.19926977f, 0.28507856f, 0.31765413f, 0.17373645f, -0.31117761f, -0.01925852f, 0.04925920f, -0.03682725f, 
    -0.17934203f, -0.09361690f, -0.16976568f, -0.14164197f, -0.00715309f, -0.08876119f, -0.06030133f, -0.01559977f, 
    0.00004062f, 0.07135212f, 0.14274713f, -0.01965017f, 0.14407413f, -0.00724571f, 0.04716031f, 0.09277318f, 
    -0.06147761f, -0.22407739f, 0.19745387f, 0.75825459f, -1.16190398f, 0.07706401f, -0.16141109f, -0.18167850f, 
    0.16718309f, 0.08239886f, 0.03817496f, 0.03583777f, 0.09601818f, 0.09580281f, 0.09661243f, -0.02407101f, 
    0.10345875f, 0.11879381f, 0.02719130f, 0.19313234f, 0.30154040f, 0.24117266f, 0.13309592f, -0.01816077f, 
    -0.00790814f, 0.16289623f, -0.30254403f, -0.27365375f, -0.26370940f, -0.29152721f, 0.05715683f, 0.11977845f, 
    0.00899461f, 0.02246452f, -0.05368828f, 0.09755190f, -0.12889631f, -0.25484696f, -0.03592100f, 0.05969712f, 
    0.17297292f, -0.41078839f, 0.08836524f, -0.34105060f, 0.17559414f, 0.01680088f, 0.17656943f, 0.21408530f, 
    0.02190766f, 0.13501196f, 0.06141374f, 0.06488365f, -0.02311298f, -0.04169160f, -0.07792547f, -0.13203685f, 
    0.03202787f, 0.02907709f, -0.17935304f, 0.05969970f, -0.40029898f, 0.35039583f, 0.24612731f, 0.63992524f, 
    0.13293837f, 0.02440787f, 0.12832537f, -0.43194398f, -0.17384169f, -0.23528458f, 0.19110222f, -0.20730159f, 
    0.07217737f, -0.20686446f, -0.00158277f, 0.16967270f, 0.05472325f, -0.20191941f, 0.08517703f, 0.06043389f, 
    -0.26932117f, -0.01389029f, -0.29031694f, -0.02137916f, 0.21224736f, -0.02992241f, -0.01225483f, 0.24127765f, 
    -0.02043637f, -0.03747245f, -0.10273431f, 0.13396055f, -0.08079375f, -0.10609502f, 0.03962279f, -0.01361993f, 
    0.02824761f, 0.12004344f, 0.05708393f, 0.15915757f, 0.30863816f, -0.11301802f, -0.63226420f, 0.21721308f, 
    -0.15326172f, -0.01209856f, -0.20407166f, 0.16566126f, -0.16844645f, 0.17027284f, 0.04100728f, 0.03777910f, 
    -0.06153795f, 0.07597119f, 0.01591873f, 0.05705830f, 0.08779070f, 0.24036995f, 0.20507874f, 0.20035322f, 
    -1.22881699f, -0.23385406f, -0.83156484f, 0.10582837f, -0.21017826f, -0.64076573f, -0.04082028f, 0.02646212f, 
    -0.35779938f, -0.12782183f, 0.18727003f, -0.05214944f, 0.02895772f, 0.05421777f, -0.07624289f, 0.04431739f, 
    -0.11334084f, -0.18038644f, 0.20433712f, 0.17770739f, 0.24787271f, -0.11975237f, 0.58563942f, -0.20033859f, 
    -0.54798919f, -0.02070792f, -0.38099009f, -0.21035287f, 0.07106838f, -0.20695804f, -0.09217891f, 0.08275210f, 
    0.11810683f, 0.37265623f, 0.03548182f, 0.07224999f, 0.00864871f, 0.00290594f, -0.04302518f, 0.10204431f, 
    0.12247007f, 0.21932860f, 0.78351992f, -0.13623792f, 0.01453163f, 0.02610375f, -0.17224351f, -0.23551399f, 
    -0.03374112f, -0.00237916f, 0.07273623f, 0.09872320f, 0.18031524f, 0.06159944f, 0.06463972f, -0.01346144f, 
    -0.16770639f, -0.08566671f, -0.04797788f, 0.00322800f, -0.20246786f, -0.56983924f, -1.69369388f, 0.33332151f, 
    0.03634845f, -0.01074682f, 0.07212862f, 0.37574786f, 0.03202643f, 0.02145002f, -0.00841114f, 0.03531702f, 
    -0.09188498f, 0.05239493f, -0.02111282f, 0.03314347f, 0.18607615f, -0.20570877f, 0.00136714f, 0.08957695f, 
    -0.47422180f, -0.15382615f, 0.73568851f, -0.12416774f, -0.47370908f, -0.05815106f, -0.47344089f, 0.27123848f, 
    0.06207344f, 0.20820683f, -0.02131759f, 0.06922958f, 0.03304903f, 0.00874279f, -0.13278514f, 0.05130717f, 
    0.06656211f, -0.02082256f, -0.16539676f, -0.09696185f, -0.40254265f, -0.17489594f, -0.51761311f, 0.10815264f, 
    -0.00325628f, -0.00719366f, 0.16985971f, 0.09196800f, 0.07675998f, -0.34599885f, -0.08122940f, -0.09315468f, 
    0.06178832f, -0.07801259f, -0.03034881f, 0.13950881f, 0.09411246f, -0.27653617f, -0.00920826f, 0.04260292f, 
    0.39792955f, 0.02317129f, -0.81185555f, 0.36632821f, -0.52886087f, -0.12764388f, -0.26065695f, 0.32355213f, 
    0.12524392f, 0.01103406f, -0.01665854f, -0.07031854f, -0.09457404f, -0.06511150f, -0.09319438f, 0.10272694f, 
    -0.05289402f, 0.03745926f, 0.07970478f, -0.27663726f, 0.06011922f, -0.16805345f, -0.24918510f, -0.30746400f, 
    0.30596140f, -0.19725761f, 0.31857434f, 0.11804949f, -0.06933235f, -0.01868125f, 0.13516209f, -0.03031453f, 
    -0.15180561f, 0.00903522f, -0.16345091f, -0.01098274f, 0.17898162f, -0.03166257f, -0.10672310f, 0.09889654f, 
    0.07002736f, 0.32915601f, -0.01099452f, -0.01142516f, -0.18471263f, 0.17360285f, 0.02913630f, 0.17148595f, 
    -0.03847637f, 0.03770484f, 0.15786722f, -0.14540841f, -0.10585905f, -0.19038564f, -0.12958951f, 0.11836970f, 
    -0.12055837f, -0.14789081f, 0.06763673f, -0.28486148f, -0.14089867f, -0.03168100f, -0.32344657f, -0.09665710f, 
    -0.05127272f, -0.04659548f, 0.11401448f, 0.23260067f, 0.10012290f, -0.09341362f, 0.17399235f, -0.00564655f, 
    0.03088778f, -0.19749399f, -0.22178687f, 0.28382581f, -0.01833525f, -0.01763830f, 0.10714944f, 0.00861650f, 
    -0.38431114f, 0.11204202f, -0.48549187f, 0.16836306f, 0.09135985f, -0.15852073f, -0.07400706f, 0.00627810f, 
    0.15390290f, 0.12660298f, -0.05152835f, 0.13052957f, -0.15582533f, -0.26536655f, -0.27344376f, 0.10376325f, 
    -0.14311340f, -0.01720701f, -0.04803250f, -0.21099968f, 0.04504774f, -0.05887074f, 0.40084621f, 0.44349423f, 
    0.02917503f, 0.02716881f, 0.07278861f, -0.27731234f, 0.03897405f, 0.07330003f, -0.22872803f, 0.14160712f, 
    0.10504118f, -0.09364486f, 0.04005260f, 0.00001575f, 0.03538449f, 0.09445648f, 0.13590963f, 0.16014913f, 
    -0.16090493f, -0.16777483f, 0.45275214f, 0.15227330f, -0.37086570f, 0.12575410f, -0.18832351f, -0.17753042f, 
    0.16836567f, -0.00412204f, -0.22340536f, 0.03235504f, -0.03298485f, -0.06867854f, 0.00667344f, -0.00605571f, 
    -0.01539370f, 0.16157895f, 0.09672683f, 0.09528215f, 0.55643928f, -0.34243959f, 0.44418496f, -0.17752846f, 
    -0.11707181f, -0.00648591f, -0.26111710f, 0.06375968f, 0.06120086f, -0.04745674f, -0.10497128f, 0.10864227f, 
    -0.22718424f, 0.03164401f, -0.21239330f, -0.07071150f, -0.16415121f, 0.21061127f, -0.04645165f, 0.00666767f, 
    0.02836109f, -0.71392322f, 0.33388215f, -0.45148173f, -0.39818147f, -0.10755714f, -0.02592023f, 0.14393836f, 
    -0.27736741f, -0.20653689f, 0.07412957f, 0.09043775f, -0.33510572f, 0.06482106f, -0.09823740f, 0.17333414f, 
    -0.04422998f, 0.11931438f, -0.35879409f, -0.40714964f, -0.06594715f, -0.12810495f, -0.55084795f, -0.01272351f, 
    0.10588990f, -0.12582335f, -0.00779267f, 0.39686239f, -0.31451839f, -0.10757563f, 0.01837061f, 0.12574254f, 
    0.03385068f, 0.06239726f, -0.03390737f, 0.15314849f, -0.20729150f, 0.05628414f, -0.36648402f, -0.41738781f, 
    0.67640746f, 0.10339545f, 0.68677956f, 0.58427805f, 0.24579784f, -0.33418986f, 0.00296804f, 0.17751136f, 
    0.04330801f, -0.00995128f, -0.12502907f, 0.01051150f, -0.18122861f, -0.19321656f, 0.23359473f, 0.12544620f, 
    -0.35472474f, -0.00889916f, 0.19644302f, 0.03552782f, -0.31746376f, 0.34404099f, 0.02119041f, 0.04279003f, 
    -0.00558962f, 0.22464362f, -0.19259113f, -0.14422640f, 0.12401386f, 0.09703057f, -0.00019675f, -0.05388115f, 
    -0.10670789f, -0.04380686f, -0.14987330f, -0.14373028f, -0.01396101f, -0.02069846f, 0.01535924f, -0.12683995f, 
    -0.13973515f, 0.01258878f, -0.09225462f, 0.27913851f, 0.01719538f, -0.03054324f, 0.12664159f, 0.00896368f, 
    0.00763528f, 0.02783864f, -0.09543055f, -0.21848784f, 0.04866853f, -0.01946064f, -0.01242419f, 0.04119941f, 
    0.10619896f, -0.00969427f, 0.13794337f, 0.37351269f, -0.25306037f, -0.29983658f, -0.52845192f, -0.10440390f, 
    0.20937955f, 0.04655602f, 0.04307683f, -0.33006054f, -0.06142650f, -0.19263962f, -0.05910860f, 0.17808487f, 
    -0.16577661f, 0.02805946f, -0.04161344f, 0.20520720f, -0.36891297f, -0.26013070f, -0.26893273f, -0.17259745f, 
    -0.78899574f, 0.27763414f, -0.20005932f, 0.24477547f, 0.16687211f, 0.06652020f, -0.03867952f, -0.07612478f, 
    0.15753452f, -0.15284975f, -0.12122022f, -0.03255093f, -0.00219201f, 0.03800788f, 0.03348147f, 0.05912625f, 
    0.06823536f, -0.15026060f, 0.11540815f, 0.20564321f, -0.51349974f, -0.57358664f, 0.43921223f, -0.40254343f, 
    -0.03035831f, 0.12001418f, -0.19576927f, 0.20379744f, 0.24323979f, -0.15408418f, -0.07578135f, -0.11545379f, 
    0.20244043f, 0.00275280f, 0.11806083f, 0.17038992f, -0.07081651f, 0.16164131f, 0.23242417f, -0.19180025f, 
    -0.77697021f, -0.09741894f, -0.14788012f, -0.19754434f, 0.01418683f, -0.11583762f, -0.19892401f, 0.33983779f, 
    -0.04555594f, 0.28510860f, -0.13905628f, 0.24181080f, 0.01300789f, 0.23711194f, -0.02799243f, 0.20383070f, 
    -0.02534526f, 0.03452455f, 0.00391152f, 0.02869792f, 0.13977110f, -0.24662876f, 0.61466753f, 0.19598226f, 
    -0.02311075f, -0.05163138f, -0.02595974f, -0.00386053f, -0.10678644f, 0.04791687f, -0.19228862f, -0.02717400f, 
    0.40243676f, 0.01142606f, 0.18990828f, -0.02076541f, 0.11832124f, 0.07982031f, 0.11307976f, 0.12430977f, 
    -0.67597979f, -0.50646824f, -0.00567826f, 0.01776031f, -0.03931683f, -0.00756130f, 0.02019451f, -0.00463917f, 
    0.03306573f, -0.15545240f, -0.12893511f, -0.02786935f, 0.14416987f, 0.02627503f, -0.09499254f, 0.11520177f, 
    0.08297338f, 0.09643153f, 0.33604801f, 0.39311939f, -0.10217912f, -0.84616280f, -0.97768694f, -0.04677998f, 
    -0.64519811f, -0.06454666f, -0.02186087f, -0.01576572f, -0.19806060f, -0.05186045f, -0.06238230f, 0.01603466f, 
    -0.10298239f, 0.05392417f, -0.03640920f, 0.06677894f, 0.04429600f, 0.29857022f, 0.12708288f, 0.20136286f, 
    0.03056596f, -0.51536345f, -0.04567234f, -0.41406280f, -0.37584701f, -0.09799553f, -0.05610643f, 0.00175178f, 
    0.02398153f, -0.07148279f, 0.01489272f, 0.06451674f, 0.33793521f, 0.14387751f, -0.00050177f, 0.09258920f, 
    0.10943229f, -0.08562177f, 0.14577930f, 0.16667353f, -0.10380965f, -0.08003251f, 0.43348813f, 0.02431968f, 
    -0.32602879f, 0.18949170f, 0.01165191f, -0.06559342f, 0.09666757f, 0.07995144f, 0.03133340f, -0.14063483f, 
    0.03133078f, 0.06007683f, 0.18377741f, -0.10250393f, -0.19453600f, 0.02486575f, 0.01257955f, -0.20461114f, 
    0.09060187f, 0.35873923f, -0.05240854f, 0.25984627f, -0.25041676f, -0.04763249f, 0.06794355f, 0.04422561f, 
    0.15748617f, -0.03439223f, -0.25492391f, -0.05984877f, -0.03478516f, -0.11315776f, -0.04390613f, 0.17044829f, 
    0.00933117f, 0.01922022f, 0.09634849f, 0.05595097f, -0.59396636f, -0.05135920f, -0.17070588f, -0.01566437f, 
    -0.10728133f, 0.09605230f, 0.36944509f, 0.19498353f, -0.23795348f, 0.18105410f, -0.10991687f, 0.12296714f, 
    0.15137967f, 0.17949997f, -0.07398391f, -0.03371473f, 0.04273031f, 0.09059369f, 0.16217704f, 0.18222037f, 
    -0.04970133f, -0.28792724f, -0.35043117f, -0.17675179f, 0.21531419f, 0.07702538f, 0.04633047f, -0.05744421f, 
    -0.06061508f, -0.17897767f, -0.35021716f, 0.07897799f, 0.12691393f, 0.07386827f, 0.02755566f, 0.26206759f, 
    -0.00930466f, -0.02848548f, -0.02739024f, 0.03040872f, 0.35738423f, -0.39793056f, 0.04126101f, -0.24375615f, 
    0.12464193f, -0.10696892f, -0.61557442f, -0.26225340f, 0.17362766f, -0.28663683f, -0.02817446f, 0.04551715f, 
    0.06358256f, -0.11130138f, 0.00664961f, -0.00292603f, 0.04234308f, -0.03884403f, 0.22010201f, 0.09749360f, 
    -0.47297770f, -0.68082565f, 0.44680241f, -0.07300612f, 0.55906731f, 0.54609948f, 0.15876034f, 0.45231918f, 
    -0.09538545f, 0.19579287f, 0.03508958f, -0.04093982f, -0.04793194f, 0.27047256f, 0.05676255f, 0.08235016f, 
    0.28815734f, 0.06330328f, -0.11369836f, 0.13916434f, -0.95263809f, 0.00536563f, -0.55773067f, 0.58130270f, 
    -0.27816764f, -0.10572895f, 0.27156454f, -0.18437998f, 0.54722840f, -0.08892344f, -0.16489494f, -0.13913672f, 
    0.01051155f, 0.05792629f, 0.08650241f, -0.06949472f, -0.17044915f, -0.03113644f, -0.07531389f, 0.11016557f, 
    -0.20901260f, -0.14135289f, -0.37926349f, 0.31802145f, 0.03375274f, -0.28523108f, -0.01405951f, 0.15847148f, 
    0.01104530f, -0.09537166f, -0.03073073f, 0.11771069f, -0.20319308f, -0.20323348f, 0.15900269f, -0.05346240f, 
    -0.24509951f, -0.08625668f, -0.44650009f, -0.46242312f, 1.17156601f, -0.55833787f, 0.87929153f, 0.17174827f, 
    -0.13346861f, 0.00654751f, -0.07911579f, -0.28855088f, 0.09951618f, -0.33510092f, -0.11321633f, -0.04517783f, 
    0.10436606f, -0.06329280f, -0.01502926f, 0.02565216f, 0.03891507f, 0.02857098f, 0.05662809f, 0.06110576f, 
    -0.14652574f, -0.45559874f, -0.58149862f, 0.23533887f, -0.38050649f, 0.05761556f, -0.26037872f, -0.02840604f, 
    0.02268231f, -0.19951120f, 0.01772120f, 0.06785532f, -0.15475094f, -0.12328814f, -0.03462015f, 0.01743075f, 
    0.00876353f, 0.04558728f, -0.01734038f, -0.08183670f, 0.33878767f, 0.02773308f, 0.46769261f, 0.07725673f, 
    0.14230490f, 0.05691458f, 0.14301328f, 0.12677225f, 0.27901584f, -0.22593334f, -0.08598502f, -0.18758591f, 
    0.04048337f, -0.01801947f, -0.18638477f, -0.02761251f, 0.09314258f, 0.04317886f, -0.12292373f, -0.01414351f, 
    -0.33898646f, -0.46328390f, -0.05705173f, 0.03157619f, 0.08788726f, -0.10804459f, -0.76089734f, 0.24326807f, 
    -0.42773241f, -0.16780131f, 0.07268084f, -0.05188125f, 0.01174787f, -0.00729399f, -0.17156629f, 0.07373936f, 
    -0.11501986f, -0.05508622f, -0.09010685f, 0.06938234f, 0.02317409f, 0.23000601f, -0.26846626f, 0.38356754f, 
    0.20693403f, -0.12995373f, 0.20683441f, -0.12760468f, -0.11992957f, 0.23067954f, -0.21884741f, -0.02023677f, 
    -0.35373056f, 0.34329847f, 0.00141323f, 0.18656456f, -0.09001876f, 0.32119521f, -0.18211865f, 0.08596429f, 
    0.37968671f, 0.21579136f, 0.32130662f, 0.16533522f, -0.00927327f, -0.10131049f, 0.14227432f, -0.01402499f, 
    -0.07265145f, -0.20466238f, -0.22495680f, 0.07850806f, 0.01665247f, 0.08672824f, 0.03544489f, -0.04970596f, 
    -0.21595626f, -0.05558435f, -0.17003207f, -0.05125989f, 0.31947517f, 0.14187907f, 0.39413723f, -0.06971060f, 
    -0.36815113f, -0.07303426f, 0.15091434f, 0.03235615f, 0.02212270f, 0.01352818f, -0.28061545f, 0.08740683f, 
    0.06187331f, 0.01069492f, -0.21289456f, -0.06461614f, 0.08466968f, -0.10689455f, -0.27741849f, -0.08563592f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.28094044f, 0.16827859f, 0.09825484f, -0.11996378f, -0.07864052f, 0.08947229f, 0.06474774f, -0.22932783f, 
    0.04789165f, -0.02190534f, -0.01599693f, -0.01099158f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
