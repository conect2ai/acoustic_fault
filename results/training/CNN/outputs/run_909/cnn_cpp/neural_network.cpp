#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.33947402f, -0.86845636f, -0.36296791f, -0.63957697f, 0.32726032f, -0.47766674f, -0.04313998f, 0.27826089f, 
    0.15303883f, 0.77958488f, 0.70469826f, 0.64844215f, 0.09237243f, -0.58570379f, 0.20676363f, -0.56056446f, 
    -0.12247834f, 0.16903602f, 0.46935165f, -0.58686697f, 0.36291727f, 0.17652360f, -0.92647332f, 0.22357561f, 
    0.42982092f, 0.46616274f, -0.03822673f, -0.62613225f, 0.57983774f, -0.35376334f, -0.46616873f, -0.36347637f, 
    -0.30844107f, 0.11257125f, -0.20420119f, -0.00173870f, 0.82213509f, 0.70375472f, -0.43706378f, -0.22586045f, 
    -0.58829051f, -0.51835787f, 0.30536878f, 0.29390955f, 0.11138543f, 0.04340488f, -0.08284254f, -0.51130670f, 
    0.62013000f, -0.21323052f, -0.41475707f, -0.41084278f, -0.35832068f, -0.29879794f, 0.52176297f, 0.38376954f, 
    -0.78138465f, -0.35179025f, 0.48149922f, 0.34883395f, 0.44368717f, -0.10373510f, 0.34495580f, 0.49981058f, 
    0.10411958f, 0.56594402f, -0.14673585f, 0.60812896f, 0.18673159f, 0.36251792f, 0.25860235f, -0.06296491f, 
    0.51534343f, -0.54853392f, -0.54416770f, -0.42111582f, -0.26819074f, -0.57074225f, -0.21560147f, -0.30373040f, 
    0.11312601f, -0.39064732f, 0.02229004f, 0.02752760f, 0.74971604f, 0.41984913f, 0.53346694f, -0.12963091f, 
    0.38380915f, 0.11588342f, -0.18951795f, -0.96395856f, -0.52756685f, -0.11275578f, -0.16601187f, -0.17306879f, 
    0.27289593f, 0.01159591f, 0.08625671f, -0.68743861f, -0.56427240f, -0.61126161f, 0.50060552f, -0.19155756f, 
    -0.13753395f, 0.51146871f, -0.31990355f, 0.24539068f, -0.44430932f, -0.40290949f, 0.21033052f, -0.42489076f, 
    0.18213144f, -0.66117013f, 0.38204119f, 0.26618573f, 0.20496181f, 0.88531411f, 0.25008720f, 0.31142578f, 
    0.83580494f, 0.38984635f, 0.07446007f, -0.14061044f, 0.26847953f, -0.17644438f, 0.37917426f, -0.51993006f, 
    0.44873136f, -0.71713245f, 0.66531789f, -0.30986813f, 0.06124040f, -0.09388281f, 0.36794430f, -0.25979707f, 
    -0.69666600f, -0.26435137f, 0.06391677f, -0.56902224f, 0.60209185f, -0.08615527f, -0.09370980f, -0.34936222f, 
    -0.48448944f, -0.73147494f, -0.71506953f, -0.46575901f, 0.65662062f, 0.81086171f, 0.06372494f, -0.02890008f, 
    -0.18258403f, 0.10532736f, -0.26904362f, 0.47058478f, -0.61481130f, -0.33589360f, -0.64295775f, -0.51731604f, 
    0.14594226f, -0.31039238f, -0.86029565f, 0.08086317f, 0.76472121f, 0.09566111f, 0.18288185f, -0.37944031f, 
    0.10597450f, 0.20669833f, 0.19793020f, 0.09570736f, 0.28478152f, 0.73408264f, 0.37602937f, 0.34351337f, 
    0.19222544f, -0.19209348f, -0.18345329f, 0.07236756f, -0.60011870f, 0.33011410f, 0.57274115f, -0.35321358f, 
    0.03698959f, 0.56960446f, -0.19694421f, -0.12497506f, 0.50581127f, -0.25275522f, -0.04689858f, 0.50509959f, 
    0.73999238f, 0.75063759f, -0.04423939f, 0.35649005f, 0.19070233f, 0.32234290f, -0.21625583f, 0.33994943f, 
    0.02835717f, -0.39519310f, -1.19535816f, -0.72827256f, -0.05103708f, -0.20175633f, 0.60100496f, 0.39351523f, 
    0.19763148f, 0.46681237f, -0.09796153f, -0.56040633f, 0.55551356f, -0.36290729f, -0.11649714f, -0.54852855f, 
    -0.88308513f, 0.86130601f, 0.01237168f, 0.54250371f, 0.35578942f, -0.36883578f, -0.26876026f, -0.21375029f, 
    -0.22596617f, -0.38396743f, -0.32530561f, -0.55806887f, 0.75050616f, 0.57878393f, 0.50297058f, 0.14662679f, 
    0.06099980f, 0.43391746f, 0.67931658f, 0.50524992f, 0.80998164f, 0.15337984f, -0.33601773f, 0.04623828f, 
    0.29650083f, 0.29601422f, 0.19400856f, 0.72466546f, 0.52906877f, 0.34161404f, 0.21507585f, 0.30586103f, 
    0.44503319f, 0.38698512f, -0.15067393f, -0.38660750f, -0.36555746f, -0.25900912f, -0.40199935f, -0.12973563f, 
    0.78062421f, -0.53001404f, 0.08521463f, 0.02119621f, -0.52121007f, -0.79053998f, -0.18191227f, -0.30161762f, 
    0.34504810f, 0.88070464f, 0.15982634f, -0.11137180f, -0.56005239f, -0.09523305f, -0.28506896f, 0.56977636f, 
    0.45729092f, -0.95930463f, 0.58404827f, -0.36081776f, 0.35159150f, 0.02881944f, -0.28235629f, -0.69713449f, 
    -0.63914686f, 0.23230642f, -0.67764127f, -0.37794679f, 0.63247436f, 0.40725940f, 0.05008104f, 0.38958383f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25718892f, -0.00504916f, -0.05893287f, 0.13290158f, 0.03536186f, -0.22461522f, -0.33386073f, 0.11298914f, 
    0.23594786f, -0.28016222f, -0.19951047f, 0.00911104f, -0.00256867f, -0.09136155f, -0.36491415f, -0.00365643f, 
    -0.20211600f, -0.44222555f, 0.01615125f, 0.34546903f, -0.13950267f, -0.17071992f, -0.21527198f, 0.10952448f, 
    -0.14538567f, 0.21313615f, -0.00278459f, 0.00761022f, -0.06588570f, -0.15302487f, -0.18605097f, 0.15121451f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.06723555f, 0.05023884f, -0.10814551f, 0.02417612f, -0.12946095f, 0.08176852f, -0.07964396f, -0.08568503f, 
    0.07350020f, 0.07499511f, 0.04104219f, 0.19171958f, 0.11636032f, 0.08186781f, -0.01309190f, 0.02040694f, 
    0.10605086f, 0.01698492f, -0.07023260f, -0.13674040f, 0.00245632f, -0.31652606f, -0.04688147f, -0.11258426f, 
    0.14780648f, 0.05342290f, -0.01918792f, -0.03901490f, -0.12179490f, 0.37012389f, -0.02746622f, 0.03568740f, 
    0.00210640f, 0.20683059f, 0.12998623f, 0.02153280f, 0.16344202f, 0.02728518f, 0.04372418f, 0.02932569f, 
    -0.03439608f, -0.04414078f, -0.03082719f, 0.00976930f, 0.11206269f, -0.11125778f, 0.17023180f, 0.18173791f, 
    0.05411531f, 0.10489127f, -0.11054239f, 0.05105578f, -0.00228452f, 0.13571951f, -0.22298712f, 0.06384352f, 
    0.04998332f, 0.10535643f, 0.05343993f, -0.06501194f, 0.05033092f, -0.03857833f, 0.04346412f, -0.20581189f, 
    0.09115142f, 0.29342669f, -0.00944353f, -0.04176243f, -0.06272122f, 0.01857535f, 0.15660350f, 0.12114551f, 
    0.06356400f, -0.07218955f, -0.05533462f, -0.01854731f, 0.08417800f, -0.00243089f, 0.11747751f, 0.09051242f, 
    -0.10260982f, -0.12399200f, -0.00547713f, 0.07286931f, 0.15822721f, 0.12573276f, 0.10100977f, -0.02970676f, 
    -0.07239132f, -0.00733487f, -0.30255446f, 0.12295013f, 0.06628510f, 0.14462487f, 0.08254983f, -0.09028578f, 
    -0.06319007f, 0.10911623f, -0.14129765f, -0.59693271f, 0.08145845f, -0.05571920f, 0.02284502f, 0.10898553f, 
    0.00093561f, 0.04955345f, -0.00004274f, -0.08868584f, 0.01562426f, -0.01497793f, -0.02901166f, 0.08624300f, 
    0.12642004f, 0.02166226f, -0.01143834f, -0.05791708f, 0.03624479f, -0.20292427f, 0.12195603f, -0.01306549f, 
    -0.06146003f, 0.07685879f, -0.14776529f, 0.03283144f, -0.03197102f, 0.04485184f, -0.19711362f, -0.08610449f, 
    0.13444604f, -0.15915170f, 0.16208488f, 0.03557926f, 0.13916951f, -0.07067641f, 0.12781681f, -0.38681677f, 
    -0.12206136f, -0.25950176f, 0.11236136f, 0.01186535f, -0.14200388f, -0.19021495f, -0.00333437f, -0.04232626f, 
    -0.30560127f, -0.06795470f, -0.30620572f, 0.11983965f, 0.10376640f, -0.05885552f, -0.15095459f, -0.11081433f, 
    0.04843465f, 0.10490807f, 0.10711671f, -0.01943652f, 0.06597538f, 0.03429437f, 0.04404145f, 0.04847618f, 
    0.23813488f, -0.08279894f, -0.08804011f, -0.20410231f, -0.13542792f, 0.10650299f, 0.02349722f, -0.17042923f, 
    -0.13872330f, 0.02639219f, -0.01555333f, 0.28133938f, 0.09102514f, -0.04038145f, 0.03100099f, -0.03197633f, 
    -0.12817554f, 0.14136034f, -0.08948185f, 0.03514556f, 0.00568627f, -0.08938406f, -0.24504593f, -0.20812958f, 
    0.00437043f, -0.00094232f, 0.02323709f, -0.00904307f, 0.02649000f, -0.30133241f, -0.31678605f, -0.10658201f, 
    0.06547742f, -0.01073206f, -0.05971588f, -0.18741061f, 0.14776203f, -0.03975264f, 0.08468439f, -0.06653444f, 
    0.18265828f, -0.06902023f, 0.05353855f, -0.14068836f, 0.21563949f, 0.11354829f, 0.10393845f, 0.07677835f, 
    -0.08738531f, 0.03474763f, 0.12624055f, 0.16445801f, 0.06730891f, 0.21971892f, -0.00297694f, 0.05300270f, 
    0.03157704f, -0.25223485f, 0.17683661f, 0.14344767f, -0.01276499f, 0.15124556f, 0.12165483f, -0.05740853f, 
    0.02451602f, -0.13743824f, 0.13211972f, 0.01561896f, 0.08585767f, 0.10295784f, -0.00321280f, 0.04458857f, 
    -0.06323002f, 0.05854353f, -0.02575964f, 0.08661137f, 0.33257750f, -0.06775781f, 0.25499198f, -0.05052880f, 
    -0.03927822f, -0.03927796f, -0.01797317f, -0.04512547f, 0.10271773f, 0.12869017f, 0.22224936f, 0.06119552f, 
    -0.02048127f, 0.04121798f, 0.03915680f, 0.02538254f, -0.32040033f, -0.03611029f, -0.08222290f, 0.21153332f, 
    -0.09606193f, 0.18638490f, -0.07838394f, -0.13099256f, -0.04576248f, -0.06940305f, -0.10558817f, -0.19104627f, 
    -0.07485317f, 0.06028767f, 0.07432713f, 0.10726520f, -0.01432599f, -0.03829688f, -0.22233903f, 0.08251921f, 
    0.07623670f, -0.00064309f, 0.06181055f, 0.01123697f, -0.13529953f, 0.06780834f, 0.07435957f, -0.41881478f, 
    -0.29868126f, -0.13867435f, 0.18320818f, 0.09608855f, 0.13220125f, -0.04328905f, 0.13666876f, 0.01451080f, 
    -0.02297927f, -0.08593275f, 0.15853824f, 0.08089611f, -0.14335638f, 0.12484660f, 0.02880424f, 0.04533143f, 
    0.03959563f, -0.10474285f, -0.00876533f, 0.30534896f, -0.04965044f, -0.04924237f, 0.10465141f, 0.16973172f, 
    0.02033497f, -0.05823773f, 0.27511421f, -0.07786822f, -0.06139359f, -0.16879453f, 0.05866973f, -0.17399691f, 
    0.04965495f, -0.13763270f, -0.02281039f, 0.20526850f, 0.00591584f, -0.02843696f, -0.10582636f, 0.07726807f, 
    -0.11758298f, 0.03723692f, 0.04275202f, 0.03817773f, -0.03223658f, -0.09275471f, 0.12368033f, -0.10857210f, 
    0.00442811f, -0.11388356f, -0.23614417f, 0.10310919f, -0.00815926f, 0.21373193f, 0.04913153f, 0.10219915f, 
    0.13655260f, -0.16441116f, 0.06489706f, -0.04336075f, -0.02491530f, 0.00591249f, -0.24997638f, 0.10098822f, 
    -0.08918396f, 0.00012140f, 0.01049495f, -0.15626675f, 0.15438400f, 0.03429037f, -0.09129012f, -0.19977868f, 
    0.24462529f, 0.01476650f, 0.00135714f, -0.07626987f, 0.15449569f, 0.01984834f, 0.04923132f, -0.16009788f, 
    0.24592610f, -0.12610877f, 0.03145045f, 0.09781621f, 0.00276013f, 0.02132141f, -0.13303040f, -0.00398109f, 
    0.09886843f, -0.04439256f, -0.03958398f, 0.01202605f, 0.04175022f, 0.02853497f, 0.05798029f, -0.08321415f, 
    0.03372739f, -0.24158423f, 0.01083140f, -0.18711093f, 0.31137246f, 0.26852539f, -0.12687515f, -0.02782227f, 
    -0.15289477f, -0.01762586f, -0.00485501f, 0.01122803f, -0.31352431f, 0.10013468f, 0.20913799f, 0.12390448f, 
    -0.03352763f, -0.12273783f, -0.01442473f, 0.04934077f, 0.06421641f, -0.10511600f, 0.00135332f, 0.00808111f, 
    -0.14237252f, 0.02430236f, 0.27380511f, -0.18918337f, 0.07440653f, -0.13481708f, 0.23723602f, 0.05370924f, 
    0.08603550f, 0.08671492f, 0.14731815f, -0.02299786f, -0.04219570f, -0.13314365f, -0.11886214f, -0.00916154f, 
    -0.12448940f, -0.16670057f, -0.10012288f, 0.12553836f, 0.03773838f, 0.05925304f, -0.04189355f, 0.16913922f, 
    -0.13793215f, 0.01396159f, 0.11364079f, 0.05391147f, -0.10463370f, -0.05726353f, -0.17459349f, 0.09904967f, 
    -0.24205066f, -0.07284644f, -0.01149467f, 0.07265110f, 0.02662717f, -0.16393809f, 0.14421868f, -0.28673449f, 
    -0.04637409f, 0.05355798f, 0.01587869f, 0.13710299f, -0.01921931f, -0.23364592f, -0.09409092f, 0.09212556f, 
    -0.01657805f, -0.06932164f, 0.14048587f, 0.12272548f, -0.25307962f, -0.01881737f, -0.05805316f, 0.03607974f, 
    0.05148388f, -0.23916057f, 0.05126897f, 0.15106231f, 0.05084652f, -0.05113272f, 0.21305597f, -0.01435923f, 
    0.14304225f, 0.06585455f, 0.02244090f, -0.09057517f, 0.06964635f, 0.09232394f, -0.04126360f, 0.04967074f, 
    -0.03255273f, 0.08287022f, 0.03710457f, 0.01929424f, -0.05225058f, -0.05477246f, -0.12319747f, -0.14427321f, 
    -0.03115663f, -0.03102280f, -0.02618320f, 0.07566360f, 0.06279650f, -0.19333035f, 0.03838694f, 0.01294483f, 
    0.06107219f, -0.06245432f, 0.00881690f, -0.16710120f, 0.03011690f, 0.02213493f, -0.07713123f, -0.00923258f, 
    -0.04434946f, 0.14762518f, -0.07611460f, 0.12947565f, 0.10642231f, 0.20780651f, 0.01823850f, -0.03206965f, 
    0.32433799f, 0.25562331f, 0.05792316f, -0.01206754f, -0.04821494f, -0.07172085f, 0.11780284f, 0.04428852f, 
    0.04714590f, -0.17045595f, -0.02969447f, 0.00679730f, 0.16414946f, -0.04684885f, 0.07440852f, -0.08356331f, 
    0.01889117f, -0.13050118f, -0.13886569f, 0.04287153f, 0.24113996f, 0.00981278f, -0.00118580f, 0.07439623f, 
    0.02815061f, -0.04820349f, 0.03684625f, -0.15242733f, 0.12014636f, 0.06369808f, 0.07519571f, 0.00184294f, 
    0.17566028f, 0.01701960f, -0.08155765f, -0.04478560f, -0.12649120f, -0.02177573f, 0.10126894f, 0.04379945f, 
    -0.10356806f, -0.15132314f, 0.04531277f, -0.10618904f, 0.20284024f, 0.02318301f, -0.08522204f, -0.12864439f, 
    0.03115891f, 0.05034821f, 0.08597063f, 0.04252671f, -0.05391518f, 0.02176367f, -0.12810777f, 0.09854466f, 
    0.14341839f, -0.25004736f, -0.05119680f, 0.03386404f, -0.06989860f, 0.04093010f, -0.04849672f, 0.19671880f, 
    -0.16793160f, -0.19683434f, -0.01303098f, 0.09624834f, 0.03944029f, 0.07328894f, -0.12047418f, -0.07554633f, 
    -0.05537746f, 0.00994694f, -0.04328873f, 0.04380553f, 0.01068603f, -0.01703318f, -0.00949061f, -0.03921362f, 
    -0.06041868f, -0.03440754f, -0.00877821f, 0.04653076f, 0.04265026f, -0.03847548f, -0.01754237f, -0.03313537f, 
    -0.05655275f, 0.02640251f, -0.05133077f, -0.01551653f, -0.01118133f, -0.00229935f, -0.00023770f, 0.02001509f, 
    -0.03401009f, 0.05130369f, 0.01057100f, -0.01497423f, -0.02052129f, -0.02819042f, -0.01659058f, -0.04304412f, 
    -0.06167735f, -0.03762217f, -0.03741577f, -0.03030380f, 0.02115268f, -0.03669058f, 0.03379416f, 0.04649196f, 
    -0.04310092f, 0.05517523f, -0.05255884f, 0.03005186f, -0.04932246f, 0.02193066f, -0.04332670f, -0.04838270f, 
    -0.02401143f, -0.04217857f, 0.00809930f, 0.02540133f, 0.04573186f, 0.04434849f, 0.00819919f, 0.01200390f, 
    0.03029690f, 0.04819537f, 0.03392407f, 0.05920830f, 0.05154971f, -0.02922799f, 0.05697568f, -0.01263436f, 
    0.03992689f, -0.05505395f, -0.04066367f, 0.01187755f, -0.05537095f, 0.04774422f, 0.05595259f, 0.04337259f, 
    -0.03070060f, -0.01380793f, 0.01346241f, 0.02687989f, 0.04004097f, 0.01123262f, 0.02402508f, 0.03011629f, 
    -0.01737888f, -0.02975122f, -0.03640187f, -0.04329302f, -0.05209566f, 0.04969268f, 0.00612345f, 0.04480699f, 
    -0.05478020f, 0.01578374f, 0.00160143f, -0.05459490f, -0.01326327f, 0.00642063f, 0.00089440f, -0.00791344f, 
    0.04887128f, 0.04923578f, -0.01585790f, 0.04535573f, -0.01321032f, -0.05469773f, -0.06614048f, -0.04153440f, 
    0.02594877f, 0.05210329f, -0.03639896f, 0.01283424f, 0.01901664f, 0.02791959f, 0.01517789f, -0.02453179f, 
    -0.05884494f, 0.05375526f, -0.03157358f, -0.05115320f, -0.04721699f, 0.05501058f, -0.05878412f, 0.04811343f, 
    -0.02641875f, 0.03339811f, -0.04453532f, -0.01898572f, 0.01128971f, 0.04894424f, -0.00358096f, -0.05716176f, 
    0.01124648f, -0.02008670f, -0.02856044f, -0.03756372f, 0.00765756f, -0.05785692f, 0.02668817f, -0.06038120f, 
    -0.06038702f, -0.01501306f, 0.03079700f, -0.01038781f, 0.03009035f, 0.01540008f, -0.00540434f, -0.05142155f, 
    0.01913748f, 0.05022500f, -0.01616202f, -0.00945013f, 0.01742887f, 0.04692450f, 0.01713891f, -0.00956511f, 
    -0.05459624f, 0.02262634f, -0.04155524f, 0.04468363f, 0.01378023f, -0.05947472f, 0.02908858f, 0.01302458f, 
    0.02762499f, 0.00778470f, -0.04669081f, 0.01262658f, 0.04530595f, -0.00440860f, -0.05672922f, 0.02908061f, 
    0.04228614f, 0.02269104f, 0.04622180f, -0.01763629f, -0.05400749f, 0.02932547f, 0.02847517f, -0.02537451f, 
    -0.01185993f, -0.02365582f, 0.02393767f, -0.03671771f, -0.03373574f, -0.04081436f, 0.01746529f, 0.01999349f, 
    -0.04681552f, -0.03859475f, 0.04748538f, -0.03729651f, -0.02898694f, 0.02033736f, -0.05239172f, 0.05318549f, 
    -0.03114595f, -0.05097927f, 0.03199491f, 0.02161580f, 0.04689727f, -0.01911675f, 0.01155510f, 0.04123167f, 
    0.00337054f, 0.02812258f, -0.06549073f, -0.03861688f, -0.01336872f, 0.05082828f, -0.06069170f, -0.02239594f, 
    0.01272318f, -0.00945355f, -0.05935536f, 0.03292514f, 0.04472371f, 0.02387016f, -0.01517494f, -0.02009346f, 
    -0.03565026f, -0.03314308f, -0.05464818f, -0.03147753f, 0.04007310f, -0.00468644f, 0.00053617f, -0.01409755f, 
    -0.02669337f, 0.01357330f, -0.01916119f, 0.04916403f, -0.00595003f, -0.03330390f, -0.05876076f, 0.03113036f, 
    -0.05773425f, -0.03344523f, -0.00736731f, -0.01002048f, -0.00846494f, -0.01503501f, -0.01197298f, -0.04515576f, 
    -0.04711847f, 0.04882830f, 0.00122399f, 0.04014238f, -0.04352449f, -0.03265217f, -0.05304819f, -0.00308089f, 
    -0.04119930f, -0.02464534f, -0.02646413f, -0.03462047f, 0.00239697f, -0.02730940f, -0.03479669f, -0.00371539f, 
    0.03130612f, -0.04975599f, 0.02283340f, -0.01545219f, 0.01536570f, 0.00506712f, -0.05539672f, -0.05614728f, 
    0.03928136f, -0.00553471f, -0.00003931f, -0.03782719f, 0.03439578f, -0.05193798f, 0.03718658f, 0.01294971f, 
    0.05673590f, -0.02095056f, 0.00504920f, -0.02578705f, 0.04683125f, -0.05465142f, -0.03659887f, -0.01428282f, 
    0.00765680f, 0.00449247f, -0.03717829f, -0.05029571f, 0.04405517f, 0.00044915f, -0.04526196f, 0.03318396f, 
    -0.05019260f, -0.05809670f, -0.00499352f, 0.03946323f, -0.03411185f, 0.00384483f, -0.02292649f, -0.04369241f, 
    -0.00453744f, -0.01620436f, 0.02296462f, -0.00911523f, -0.02985763f, -0.01656132f, -0.03611674f, 0.04669468f, 
    0.05085963f, -0.00194838f, -0.04629704f, -0.04014771f, 0.01259455f, -0.01308705f, 0.00979617f, -0.01806802f, 
    -0.04564684f, -0.05778443f, -0.02527454f, 0.00020164f, -0.04994457f, -0.05422580f, 0.04010670f, 0.03433794f, 
    0.00087072f, -0.02453062f, 0.03226398f, 0.00897581f, -0.03957783f, 0.01852600f, 0.03706538f, 0.02963283f, 
    -0.01468997f, 0.04262640f, 0.03606605f, -0.02095018f, 0.01337183f, 0.00842815f, -0.03914603f, -0.00962794f, 
    -0.06438109f, 0.00227353f, -0.05331619f, 0.01873759f, -0.02996957f, -0.04944790f, 0.03455922f, -0.01071702f, 
    -0.01538634f, 0.01601584f, -0.02209471f, 0.04761534f, -0.05458216f, -0.05576656f, 0.04197395f, 0.00625614f, 
    0.01951877f, 0.00110560f, -0.05581065f, 0.05883196f, -0.02941302f, 0.01899045f, -0.04660922f, 0.03547034f, 
    0.03642130f, -0.02179233f, 0.01671488f, -0.06551456f, -0.00482672f, -0.02264115f, 0.03870848f, -0.02463377f, 
    -0.00024753f, 0.01182015f, -0.00966374f, 0.03350072f, -0.03660549f, -0.01304177f, 0.00899519f, 0.04543973f, 
    0.02716580f, 0.06412483f, 0.03513025f, 0.01933863f, -0.03713480f, -0.04642510f, -0.02458321f, 0.02975886f, 
    0.02766131f, -0.01785554f, -0.02477177f, 0.01824134f, 0.01735804f, 0.04396163f, 0.03164904f, -0.01997078f, 
    0.01841462f, -0.05064898f, 0.00227500f, -0.05732498f, -0.00818121f, -0.06604671f, 0.04418455f, 0.01089889f, 
    0.01861102f, 0.01766031f, 0.03279911f, -0.03829714f, -0.00000274f, -0.05023547f, -0.03529479f, 0.04912930f, 
    0.01272112f, -0.02965760f, -0.04427158f, -0.01547382f, -0.02481865f, 0.03972735f, 0.02196346f, -0.05437128f, 
    -0.00684700f, 0.02146908f, -0.03906102f, -0.02121896f, -0.05598781f, 0.01172705f, 0.03102699f, 0.00852024f, 
    0.02657218f, -0.05120746f, 0.03458455f, 0.04303787f, 0.04473672f, 0.01708471f, 0.02494153f, -0.00644453f, 
    -0.00924517f, -0.01152995f, -0.01038540f, 0.01909775f, -0.03464705f, -0.02708116f, -0.02963826f, 0.01647695f, 
    0.03278174f, -0.01927972f, -0.04393946f, 0.05437139f, 0.02128916f, 0.02543776f, -0.00930371f, 0.02456012f, 
    -0.03302047f, 0.03711158f, -0.02329563f, -0.03772593f, 0.00885747f, 0.02620064f, 0.03965544f, 0.02356402f, 
    -0.03603877f, 0.01665282f, -0.00750903f, 0.02115491f, -0.05471476f, 0.03612797f, -0.05057548f, 0.00885468f, 
    -0.00914629f, 0.03855486f, -0.05356412f, -0.05319800f, -0.05477436f, -0.04656741f, 0.03694071f, 0.01711852f, 
    0.02176917f, -0.02715752f, -0.01028475f, 0.02772726f, -0.04768698f, -0.00333127f, 0.00221382f, 0.01219769f, 
    -0.04025253f, -0.05349455f, -0.01089104f, 0.00381614f, -0.02635441f, -0.05454149f, 0.02332907f, 0.02272008f, 
    0.00931611f, -0.02655614f, -0.05285506f, -0.02750274f, 0.01426828f, -0.05813447f, 0.03705131f, -0.00003974f, 
    -0.03742192f, -0.04784134f, -0.01432190f, -0.03969973f, -0.04400946f, 0.05294406f, -0.01545049f, 0.03706326f, 
    -0.00630149f, 0.01446625f, 0.01472973f, 0.01521829f, -0.02882050f, -0.01000931f, 0.01420662f, 0.03758470f, 
    0.00008132f, 0.03729787f, -0.02667255f, 0.03570471f, 0.02766165f, -0.03879416f, -0.05982561f, -0.00682385f, 
    0.05345935f, -0.00381732f, 0.00853872f, -0.05058023f, -0.00513834f, -0.06390852f, 0.06002786f, -0.02797713f, 
    0.05333845f, 0.03168312f, -0.04502758f, 0.01329784f, 0.02559363f, -0.02513220f, -0.02763185f, -0.03822419f, 
    0.00480587f, -0.04956726f, -0.04202670f, -0.03782908f, -0.02914444f, -0.00192774f, 0.03772947f, -0.05057900f, 
    0.00099901f, -0.05588894f, 0.01040105f, -0.05099730f, 0.01421720f, 0.05192297f, -0.02906953f, -0.02100536f, 
    0.03624199f, -0.01557332f, -0.03968176f, 0.01859879f, 0.01392355f, -0.00428767f, 0.04945989f, -0.06271088f, 
    -0.03961908f, 0.02116861f, -0.05096694f, -0.00390875f, 0.03573007f, -0.06802025f, -0.01814412f, -0.06284869f, 
    -0.01357762f, 0.03529260f, 0.00342349f, 0.02824166f, -0.03797961f, -0.04265347f, 0.04041034f, -0.03224181f, 
    0.23444708f, 0.07802881f, -0.30595973f, 0.00265359f, 0.04742543f, 0.05265563f, -0.11968257f, -0.03817890f, 
    0.02020857f, 0.49710923f, 0.06946620f, 0.16609067f, 0.08911011f, 0.05250869f, 0.11213121f, 0.02859198f, 
    -0.11831191f, 0.14911243f, 0.09016664f, 0.12506978f, -0.03519436f, 0.10899521f, -0.00002332f, 0.06053461f, 
    0.11325242f, 0.03425069f, -0.00532850f, -0.18839809f, -0.06024898f, 0.06666425f, -0.04208094f, 0.06811490f, 
    0.01318509f, 0.08017804f, -0.04873765f, -0.01296290f, 0.40974185f, 0.03510208f, -0.15927044f, 0.09962097f, 
    -0.00651366f, -0.02964982f, 0.03224299f, -0.04914919f, 0.07983685f, -0.23139481f, 0.10295323f, -0.22992273f, 
    -0.03098145f, -0.07238695f, 0.10464362f, -0.12128557f, 0.01454115f, -0.10561229f, 0.17998618f, -0.17036539f, 
    0.39522979f, 0.04438256f, -0.02783282f, -0.05042902f, 0.10677761f, 0.08613490f, -0.08057939f, 0.27731085f, 
    0.14655328f, 0.07667790f, 0.00482935f, -0.16976088f, 0.02129221f, 0.05721368f, 0.01362044f, -0.09340113f, 
    0.28072968f, 0.00076692f, -0.11122004f, 0.05568866f, 0.00434459f, 0.03277036f, -0.01657945f, -0.16617921f, 
    -0.05239283f, -0.19445390f, -0.31170437f, -0.04344307f, 0.01393460f, 0.05919959f, -0.01809305f, -0.04106761f, 
    -0.09800325f, -0.16218115f, 0.29064560f, 0.35886651f, -0.25219801f, -0.20757954f, 0.07735332f, -0.10951345f, 
    0.07943634f, -0.07680013f, -0.07308171f, 0.02057198f, 0.06153183f, 0.09723489f, -0.03418093f, -0.04399915f, 
    -0.04160329f, 0.14626019f, -0.12589067f, 0.07656401f, 0.07679712f, -0.02410019f, -0.15067470f, -0.01161071f, 
    -0.08551909f, -0.06821141f, -0.02894544f, 0.04820227f, -0.08679693f, 0.06704178f, 0.07023983f, 0.04471520f, 
    0.09925299f, 0.06529392f, 0.04333515f, -0.00865901f, 0.07889795f, 0.00254347f, 0.04192910f, -0.03295990f, 
    0.14532028f, 0.09066719f, 0.02755203f, -0.09607009f, -0.03696738f, 0.07746820f, 0.08421880f, -0.02953638f, 
    0.04478888f, -0.27016011f, -0.07604946f, 0.08882056f, 0.02987944f, 0.09269658f, 0.05886392f, -0.03745255f, 
    0.07376111f, 0.04995741f, -0.11719316f, -0.03989266f, 0.11848119f, 0.05329053f, -0.05027688f, 0.11796353f, 
    0.02797285f, -0.21313301f, -0.05663128f, -0.03000952f, 0.23381101f, 0.06330754f, 0.06192855f, -0.09203380f, 
    -0.02105812f, -0.00083523f, -0.40017861f, -0.07333360f, -0.06229252f, -0.14126039f, 0.05082309f, -0.08138932f, 
    0.05587116f, -0.02500737f, 0.02820991f, 0.05925561f, 0.10786590f, 0.02395478f, -0.06242832f, 0.01490146f, 
    0.00388574f, 0.02070229f, 0.04296365f, -0.04666612f, -0.07652421f, 0.00570813f, -0.04392749f, -0.07859291f, 
    0.09857783f, -0.05048254f, 0.09573823f, -0.06832437f, 0.03821581f, -0.22945058f, -0.28731900f, 0.02278423f, 
    -0.00222374f, 0.01546174f, -0.00051166f, 0.01729356f, -0.04992522f, -0.09496024f, 0.06047711f, -0.15647553f, 
    -0.16919404f, 0.03941207f, 0.10721261f, 0.04375770f, 0.03857833f, -0.03216494f, 0.03731598f, 0.27404585f, 
    -0.00065637f, 0.06712405f, 0.12142683f, 0.02673912f, 0.06969215f, -0.01354513f, 0.04535866f, -0.09841180f, 
    -0.56592846f, -0.12840471f, 0.00585527f, -0.08992532f, -0.03563658f, 0.05152600f, 0.01792597f, -0.11965268f, 
    0.04980174f, -0.14828542f, -0.15402344f, -0.00186355f, 0.00411925f, 0.11717173f, -0.00410884f, -0.01489172f, 
    -0.09610354f, 0.00445740f, 0.57050282f, 0.08375125f, 0.09320762f, 0.01772709f, -0.12652260f, 0.10149586f, 
    0.10530453f, -0.02284184f, -0.02966464f, 0.34949228f, 0.07429486f, 0.15487817f, 0.09766471f, -0.02763467f, 
    -0.03620005f, 0.06676348f, 0.19347921f, 0.08453605f, -0.07710648f, -0.24917564f, -0.00934344f, -0.06831786f, 
    0.04169427f, 0.21756423f, 0.04047997f, -0.04030474f, -0.01309273f, -0.38818401f, -0.21614236f, -0.04754912f, 
    -0.03260486f, -0.03852885f, -0.06460132f, -0.12136392f, 0.07477172f, -0.02569261f, 0.01908835f, -0.03258184f, 
    -0.13555957f, 0.08354507f, -0.05121453f, 0.09095278f, 0.04420881f, -0.08376472f, -0.04902449f, -0.20361733f, 
    0.11812492f, 0.01387344f, 0.08589697f, -0.08154220f, -0.12056077f, -0.19657221f, -0.11510151f, 0.06187248f, 
    0.14349477f, -0.04198780f, -0.21685727f, 0.08738744f, 0.06776663f, -0.07981522f, 0.02815541f, -0.14435349f, 
    -0.05424034f, -0.12991737f, -0.07677773f, -0.03844010f, 0.07476788f, 0.03805023f, -0.00348124f, -0.07686035f, 
    0.06137483f, 0.07543295f, -0.26152861f, -0.17057258f, -0.16051486f, -0.02054825f, 0.09599705f, -0.09299288f, 
    0.15850709f, 0.07539092f, -0.22015066f, -0.15015081f, -0.08079701f, -0.01134944f, -0.02968738f, 0.07243642f, 
    -0.12346087f, 0.07313023f, -0.01994620f, -0.03682614f, 0.03488658f, 0.10805757f, 0.11629598f, -0.04206710f, 
    0.11235848f, -0.04178761f, -0.06005170f, 0.07801878f, -0.13644959f, 0.00180769f, -0.10369647f, 0.31358978f, 
    -0.01062928f, 0.03007710f, -0.08189385f, 0.01873934f, -0.00074404f, 0.22728653f, -0.15762913f, 0.07287116f, 
    0.00903591f, -0.09112593f, -0.19556658f, 0.07211606f, 0.03819169f, 0.02632679f, 0.01781293f, -0.12470870f, 
    0.13667177f, -0.00744670f, 0.05969863f, 0.08596707f, 0.05555778f, -0.25226021f, 0.00081207f, -0.02528337f, 
    -0.13036907f, -0.20743968f, -0.15861070f, -0.04803991f, 0.06072630f, -0.02504457f, -0.01293500f, 0.01723472f, 
    0.00335623f, 0.43440443f, 0.21705553f, 0.19492033f, 0.08512037f, 0.05715352f, 0.05315642f, -0.06866789f, 
    -0.02117469f, -0.00044232f, 0.14995565f, -0.23657452f, 0.04467171f, -0.19278166f, 0.15346391f, -0.38998994f, 
    0.08343176f, 0.05707038f, -0.00607833f, -0.04656454f, -0.02193720f, 0.33335823f, -0.04871442f, -0.19851798f, 
    -0.08298574f, 0.02082960f, -0.10235728f, 0.09294724f, 0.11927969f, -0.12790269f, 0.03925991f, -0.06565943f, 
    -0.14253530f, -0.07458642f, 0.10153977f, -0.06291533f, -0.03346803f, 0.04699637f, -0.14820342f, -0.16135506f, 
    0.17824632f, 0.13433260f, 0.10889753f, 0.02764240f, -0.11502840f, 0.01872145f, 0.29522088f, 0.04862313f, 
    -0.12428834f, -0.02242198f, 0.15934001f, 0.08171328f, -0.21485467f, -0.07587652f, 0.05208227f, 0.09904105f, 
    0.08664384f, -0.06873958f, -0.11241037f, 0.24872695f, -0.10553011f, -0.05911941f, -0.02168337f, -0.04743992f, 
    0.16856958f, 0.14864066f, 0.21880946f, -0.07135614f, 0.04042465f, -0.02586654f, -0.09174062f, 0.11981413f, 
    0.17304128f, -0.10445315f, -0.04416744f, -0.23560870f, -0.06167809f, 0.09111115f, -0.04444878f, -0.17465980f, 
    0.12511672f, 0.10778879f, 0.24982953f, -0.12951010f, -0.24443887f, -0.16136059f, -0.01324775f, 0.08592106f, 
    -0.02166617f, -0.08530175f, -0.01227789f, 0.00573415f, -0.06285395f, -0.17062125f, 0.10694984f, 0.01725537f, 
    0.21769679f, 0.14685956f, 0.14152922f, 0.02272880f, 0.19303036f, 0.02555647f, 0.03372230f, -0.24503310f, 
    -0.02467009f, 0.20589934f, -0.04978528f, -0.03889977f, 0.00898623f, 0.35060102f, 0.11340991f, 0.14463571f, 
    0.10679698f, -0.02304858f, -0.00467562f, 0.02724199f, -0.05640474f, 0.11002711f, -0.17893380f, 0.21130319f, 
    -0.18143207f, 0.01123529f, -0.03796745f, -0.02993218f, -0.11947940f, 0.17198999f, -0.11020208f, -0.16992161f, 
    -0.08564474f, -0.23383725f, 0.01872481f, 0.03705439f, 0.08105151f, 0.08334755f, -0.07263061f, 0.16639248f, 
    0.32083288f, 0.08266916f, -0.12785794f, -0.15806323f, -0.08059255f, 0.04223494f, -0.08377917f, 0.12919091f, 
    0.03600814f, 0.08933517f, 0.17518948f, 0.27552295f, -0.04201632f, -0.07140002f, -0.00206619f, 0.02546591f, 
    -0.02288375f, 0.03002781f, 0.03628702f, 0.01145830f, 0.06893677f, -0.02245165f, 0.07433168f, 0.03801498f, 
    0.00385505f, -0.03475009f, -0.14535478f, 0.15660229f, -0.00318866f, -0.14331950f, 0.04078530f, -0.05258385f, 
    0.02717682f, -0.04242666f, -0.00610720f, 0.05468944f, -0.00105228f, 0.14169115f, 0.10376466f, 0.01588939f, 
    0.03856248f, -0.02807017f, 0.00066383f, -0.00500562f, -0.01973847f, 0.33394593f, 0.22471187f, 0.20003584f, 
    -0.01332908f, -0.08607706f, -0.00708094f, 0.01251054f, 0.03699411f, 0.02194518f, 0.11525231f, 0.02237937f, 
    -0.03217662f, -0.02796280f, 0.21655738f, -0.06611685f, -0.34638309f, 0.01511266f, -0.05848407f, -0.01970528f, 
    -0.08014417f, -0.26619124f, -0.15548244f, 0.03430298f, -0.04165339f, -0.00664078f, -0.00614724f, 0.02991943f, 
    -0.06776099f, 0.16646269f, -0.11097030f, 0.04364529f, -0.16077070f, 0.09048172f, 0.19299066f, 0.00186549f, 
    -0.10650795f, 0.35995397f, 0.16421573f, 0.08580521f, 0.08183897f, 0.01877084f, 0.09691778f, 0.15066728f, 
    0.03223687f, 0.24592519f, -0.21110253f, -0.45206606f, -0.09418220f, -0.03192848f, -0.04506407f, 0.01001477f, 
    -0.09198701f, 0.16668522f, -0.26006675f, 0.06392981f, -0.05626433f, -0.05420245f, -0.09184345f, 0.00688281f, 
    0.06711096f, 0.10274258f, -0.01285290f, 0.00408716f, 0.29800764f, 0.18980378f, 0.05602846f, 0.25040513f, 
    -0.02918914f, -0.05548530f, 0.06333360f, 0.09486002f, 0.05854151f, -0.08430661f, -0.32206827f, 0.04283766f, 
    0.01452587f, 0.03381592f, 0.01305073f, -0.09154024f, -0.00147276f, 0.03260617f, -0.02014696f, -0.03021187f, 
    0.09530155f, 0.01253011f, 0.15636790f, 0.00924278f, -0.02286042f, -0.00119002f, -0.30017510f, 0.24783112f, 
    0.09121846f, -0.04446067f, -0.06998990f, -0.00099193f, 0.03535770f, 0.06325008f, 0.06953847f, 0.00132512f, 
    0.19667640f, 0.17235564f, -0.21193331f, 0.02687491f, -0.13724215f, -0.00681309f, 0.18500073f, 0.07110609f, 
    0.13366771f, -0.20875359f, -0.26775780f, 0.03860653f, 0.08562070f, 0.31533736f, 0.11241406f, -0.07529676f, 
    -0.17549485f, -0.11758695f, 0.13109094f, 0.01028094f, 0.11574841f, -0.12797794f, -0.12264282f, -0.10042693f, 
    -0.09884930f, 0.11761937f, -0.11863539f, 0.11223987f, 0.05605209f, 0.14459495f, -0.01341477f, -0.04539906f, 
    -0.01345861f, -0.03117885f, -0.04924742f, 0.03855263f, -0.11493715f, 0.11029651f, -0.17626563f, 0.05068086f, 
    0.03466721f, 0.02410365f, 0.08233735f, 0.06736835f, -0.10966383f, -0.36974114f, -0.28551841f, -0.17124224f, 
    0.05791577f, -0.03003211f, 0.10113999f, -0.01825006f, 0.13487862f, -0.07926446f, -0.06123213f, -0.00618167f, 
    0.00718432f, -0.05410508f, -0.05896160f, 0.05111105f, 0.01261476f, -0.07024211f, -0.07910862f, 0.13459109f, 
    0.00176698f, -0.08757569f, -0.07105206f, 0.04684582f, -0.05023874f, -0.02394667f, 0.01298455f, 0.12615152f, 
    -0.23376735f, 0.12041857f, 0.15372638f, -0.05286799f, 0.07623123f, -0.01433393f, -0.06069424f, 0.15382195f, 
    0.05136712f, 0.00011427f, -0.00630894f, -0.14244896f, -0.03081873f, -0.03838361f, -0.19622640f, 0.02210903f, 
    -0.16504750f, 0.11362350f, 0.17586426f, 0.13419707f, -0.16014712f, -0.15877387f, 0.10819306f, -0.04746021f, 
    -0.03354134f, 0.00520167f, -0.05429735f, -0.06692533f, -0.12506807f, 0.02032217f, 0.08498694f, 0.15958883f, 
    0.17246673f, -0.01264863f, 0.04020314f, 0.07947198f, -0.01921356f, 0.00932451f, 0.03723077f, -0.09989324f, 
    0.03387872f, 0.10523622f, -0.13483095f, -0.13719787f, -0.35741165f, -0.08783874f, -0.36565036f, -0.04804036f, 
    0.17886488f, 0.07727532f, 0.11181361f, -0.00249276f, 0.06750540f, -0.01630273f, 0.14027514f, 0.09148236f, 
    -0.07247087f, 0.14538482f, -0.16487898f, -0.00099779f, 0.20405599f, -0.16778302f, -0.18768798f, 0.12170552f, 
    -0.04421527f, -0.11667281f, 0.12270299f, -0.01342411f, 0.01823145f, 0.03683404f, -0.16291261f, 0.08701370f, 
    0.03224211f, -0.18654414f, -0.05974839f, 0.00787841f, -0.01390834f, -0.03005255f, -0.21134230f, -0.09831332f, 
    0.00845189f, -0.12697150f, -0.05936337f, 0.08483141f, 0.20210530f, 0.21242841f, -0.00986284f, -0.00359402f, 
    -0.11705608f, -0.05302068f, 0.25625452f, -0.03111549f, 0.01035509f, 0.13159196f, 0.01452275f, 0.03337976f, 
    -0.02927909f, 0.04236718f, 0.07447608f, 0.11100937f, -0.17771469f, -0.10530455f, 0.13647828f, 0.15859380f, 
    0.02667259f, 0.06881572f, 0.06762480f, -0.02992093f, -0.01428178f, 0.27394390f, 0.02463553f, -0.02419936f, 
    -0.19211501f, 0.01319967f, -0.35978335f, 0.27246258f, 0.02064229f, -0.31668362f, -0.09114312f, 0.09488252f, 
    0.02430579f, 0.12270713f, 0.26933530f, -0.21094397f, 0.16169269f, 0.09925406f, 0.28958520f, 0.14857161f, 
    -0.01215703f, -0.07574129f, 0.06521825f, -0.19639598f, 0.02258619f, 0.01077140f, -0.02163404f, -0.35938007f, 
    0.17762175f, -0.08123871f, -0.07231761f, 0.01882710f, -0.05296391f, 0.07336339f, -0.04078615f, 0.02066398f, 
    -0.05747522f, -0.00202675f, 0.04022868f, -0.05723414f, -0.05165279f, -0.00583694f, -0.01686551f, -0.04242486f, 
    0.02322163f, -0.00874443f, -0.02235832f, 0.03606928f, 0.02893598f, 0.02139955f, -0.01664765f, -0.03022579f, 
    -0.04200829f, 0.04648332f, -0.02750676f, 0.00675023f, -0.03691873f, -0.02307533f, -0.02595670f, 0.01370232f, 
    -0.05177559f, 0.01001609f, -0.02382109f, -0.01931405f, 0.02690551f, 0.03704426f, -0.00519534f, 0.01002048f, 
    0.01232321f, 0.00443309f, 0.03250605f, -0.00328688f, -0.01328521f, -0.00380618f, 0.01305443f, -0.03887030f, 
    0.02723314f, 0.00390727f, -0.02147194f, -0.04400152f, 0.03096686f, 0.02187812f, -0.01583093f, 0.04031666f, 
    0.01509321f, 0.00254367f, -0.05706649f, -0.05039580f, -0.02570122f, -0.02830133f, -0.03046863f, 0.01004509f, 
    -0.05604854f, -0.04802876f, 0.03116082f, -0.06392776f, -0.01242487f, -0.02539416f, 0.01379489f, 0.02848577f, 
    0.02828110f, 0.04838699f, -0.00425284f, 0.00637648f, -0.05600103f, 0.02361913f, -0.01644030f, -0.01584425f, 
    0.02078327f, -0.00668972f, -0.05708863f, -0.04429306f, -0.05078299f, 0.02118276f, -0.01151070f, 0.03552475f, 
    -0.01670754f, 0.04775473f, 0.04197485f, -0.05711413f, 0.01891230f, -0.04325313f, -0.05424820f, 0.03488132f, 
    -0.03315195f, -0.05426830f, 0.05204007f, -0.00499610f, -0.04673993f, -0.01012940f, -0.03577568f, 0.05275494f, 
    -0.00699082f, 0.02110277f, 0.00922097f, 0.00589323f, 0.02714656f, -0.04943191f, -0.03462648f, 0.01254540f, 
    -0.01704960f, 0.01556967f, 0.05554219f, 0.04014922f, 0.04630780f, -0.03148270f, -0.00180431f, -0.04261946f, 
    0.04517449f, -0.04493985f, -0.04000019f, 0.04044842f, 0.01297435f, 0.01431144f, -0.04322442f, -0.05694904f, 
    0.03170109f, -0.00642697f, 0.00343989f, -0.06145308f, 0.04880545f, -0.06402901f, -0.00794680f, 0.02121890f, 
    0.00925837f, 0.01260454f, 0.03272432f, -0.05296827f, 0.00912884f, -0.04323950f, 0.01680706f, -0.00673395f, 
    0.02084799f, -0.05609310f, -0.00958171f, -0.02880420f, 0.00594151f, 0.02747067f, 0.05073888f, -0.01445219f, 
    -0.05749179f, 0.00087873f, 0.04897178f, 0.03422428f, -0.05386040f, -0.00991376f, -0.03194158f, 0.01226278f, 
    0.00867637f, 0.02376605f, -0.00690424f, 0.03781637f, 0.02708187f, -0.00862609f, 0.06153259f, -0.02785074f, 
    0.05293856f, 0.03478736f, -0.04088544f, -0.04343714f, 0.00211593f, -0.04060735f, -0.02763089f, 0.00235340f, 
    0.00613246f, -0.01011402f, 0.00530241f, 0.04963825f, 0.02928328f, -0.03173647f, 0.01800303f, 0.03656185f, 
    -0.01171907f, 0.00161445f, 0.00670735f, -0.00276683f, -0.02883110f, 0.02255242f, 0.01263387f, 0.03206090f, 
    -0.05751064f, -0.05268200f, -0.04062735f, 0.01299678f, 0.01211951f, -0.02299586f, -0.06110889f, -0.03104305f, 
    0.01201043f, -0.06084390f, -0.01740624f, -0.02320850f, -0.00320801f, 0.00130129f, 0.00603973f, -0.00951635f, 
    0.04586212f, -0.01872653f, -0.00087890f, -0.04064355f, -0.00752967f, -0.01032072f, 0.00017058f, 0.05095243f, 
    0.04539349f, 0.00933464f, -0.01494126f, 0.02637857f, 0.03920899f, 0.01087929f, 0.00842837f, 0.01454542f, 
    0.01414891f, -0.01055825f, -0.05772355f, 0.01419650f, -0.02866937f, 0.01754603f, 0.04387490f, -0.00596023f, 
    0.04215766f, -0.00092288f, -0.04415307f, -0.05421470f, 0.03515581f, -0.04700281f, -0.03981933f, 0.04120924f, 
    -0.05629337f, -0.05838279f, 0.00385884f, -0.03509577f, -0.05434751f, -0.05560239f, 0.02394482f, -0.00034685f, 
    -0.01196697f, -0.04253688f, -0.04085119f, -0.03708030f, -0.04386153f, -0.02105474f, -0.00259349f, -0.01213928f, 
    0.03042387f, 0.00297999f, -0.01072878f, 0.02773188f, 0.00081966f, -0.00230247f, -0.02618323f, -0.01452839f, 
    -0.04992557f, 0.01537654f, 0.00211603f, -0.03304557f, 0.01515367f, -0.00276801f, 0.00075767f, 0.02943329f, 
    0.01585116f, -0.01712125f, 0.04169065f, -0.05550488f, 0.01481177f, -0.04251623f, -0.00791577f, 0.05133116f, 
    -0.04694727f, 0.03469746f, -0.03669171f, 0.01900753f, 0.02691642f, -0.04052636f, 0.01521227f, 0.02578637f, 
    -0.05030147f, 0.02064842f, -0.05268044f, -0.00365767f, -0.04756657f, 0.03259499f, -0.02507669f, -0.05473028f, 
    -0.00154491f, 0.04850457f, 0.04348830f, -0.02264285f, -0.05767427f, 0.00444564f, -0.04801743f, 0.05003382f, 
    0.03663672f, 0.01406998f, 0.00892548f, 0.04943364f, -0.02346246f, -0.03658883f, 0.03887828f, -0.03221022f, 
    -0.05441349f, -0.04000228f, -0.03819980f, -0.05540390f, 0.03327197f, -0.03322687f, 0.04817769f, 0.00699516f, 
    -0.04874330f, -0.06013457f, 0.00805356f, 0.01975345f, -0.02463115f, -0.00426919f, 0.01255892f, -0.05103552f, 
    -0.01711118f, 0.00248188f, 0.04352505f, -0.00322256f, 0.00724931f, 0.01998028f, -0.04222920f, 0.02251959f, 
    0.01248401f, 0.04258801f, -0.00913615f, -0.00756017f, 0.04694128f, 0.00212240f, -0.02410587f, 0.00178241f, 
    -0.06087453f, -0.00174739f, 0.03282726f, -0.02193997f, -0.01076504f, -0.05881335f, 0.02947460f, -0.00885598f, 
    -0.05121159f, -0.05576047f, -0.03803466f, 0.01318540f, 0.03499567f, 0.00400263f, -0.06892777f, 0.02620504f, 
    0.02622964f, -0.02955994f, 0.04714518f, -0.03882633f, 0.03440011f, -0.01379584f, 0.00432525f, 0.04497933f, 
    -0.05351073f, -0.00061622f, 0.00842581f, 0.03846342f, -0.00024815f, 0.03202114f, 0.00410009f, -0.00491358f, 
    -0.04869962f, -0.01230774f, -0.04926527f, -0.01692306f, -0.06021719f, -0.02184653f, 0.04133391f, -0.04198731f, 
    0.02645178f, -0.06102123f, 0.02723983f, -0.05914785f, 0.01801221f, -0.04713900f, 0.03832188f, 0.04749693f, 
    0.02301078f, -0.03748692f, -0.00266629f, -0.06620051f, -0.00900271f, -0.01072478f, 0.02870967f, 0.03698451f, 
    0.02814615f, -0.05259689f, 0.04186377f, -0.03138917f, -0.04730527f, -0.04430244f, 0.02258795f, 0.04848875f, 
    -0.01410416f, 0.04897544f, -0.04746149f, -0.04164358f, 0.00217189f, -0.03958495f, -0.02839205f, -0.05020292f, 
    -0.02202049f, -0.03356892f, 0.01291274f, -0.04538205f, -0.03011122f, 0.03932604f, 0.03252525f, 0.04271916f, 
    -0.01098995f, -0.05787279f, -0.03873475f, 0.02247466f, 0.05115584f, -0.05316441f, -0.00672492f, 0.01545830f, 
    0.00470720f, -0.06137785f, 0.03568319f, -0.00156587f, -0.01023665f, -0.03662660f, -0.02575942f, 0.04460082f, 
    -0.02413456f, -0.02109252f, 0.01131169f, 0.02881336f, -0.04044271f, 0.00691168f, -0.00359705f, -0.04605816f, 
    -0.01130652f, -0.03774037f, -0.00860016f, -0.05138713f, -0.00434137f, -0.05823638f, 0.04401808f, 0.02862918f, 
    -0.04484820f, -0.02800472f, 0.04993840f, 0.00550558f, -0.01055834f, -0.02456149f, 0.01182913f, -0.01722023f, 
    -0.01928700f, 0.01549936f, -0.05184996f, 0.01498820f, 0.03814321f, -0.01183159f, -0.02506581f, -0.05959705f, 
    -0.01855202f, 0.02235291f, -0.01499362f, -0.03127423f, -0.05300971f, 0.04123097f, 0.02698309f, 0.01720812f, 
    -0.03849269f, -0.06523834f, -0.06220895f, 0.01616035f, -0.05874660f, -0.03446281f, -0.03291330f, 0.02427399f, 
    0.03562187f, 0.04911317f, 0.03343968f, -0.05927439f, -0.02318312f, 0.03306086f, -0.01289141f, -0.01638372f, 
    0.03705430f, -0.04368249f, 0.02037909f, 0.03768781f, 0.00109583f, 0.04543478f, 0.02934846f, 0.02200736f, 
    -0.01890618f, 0.05126873f, 0.04074685f, -0.05733994f, -0.03194116f, -0.00094039f, -0.01773670f, -0.03064254f, 
    -0.00178594f, 0.01433051f, -0.04827252f, 0.00060895f, -0.05450626f, -0.03605738f, 0.03199549f, 0.02879254f, 
    -0.06147423f, 0.02937188f, -0.05530215f, -0.05693430f, 0.03599143f, 0.04711620f, 0.02840005f, 0.01821187f, 
    -0.03751260f, -0.05555011f, 0.02618466f, 0.05475494f, 0.03224066f, -0.00605116f, 0.03255345f, 0.04101810f, 
    -0.00172905f, 0.03308427f, 0.03242073f, -0.01039467f, 0.02993027f, 0.03479291f, -0.04197140f, 0.00465928f, 
    0.02153204f, -0.01019440f, 0.01931934f, -0.05280331f, -0.06142890f, -0.01577125f, 0.03890701f, -0.05587810f, 
    -0.03434673f, -0.00345482f, 0.04679326f, -0.00155976f, -0.00765513f, -0.05451660f, -0.01569008f, -0.04468419f, 
    0.03828673f, -0.04272580f, -0.04269807f, -0.03058395f, 0.04065950f, -0.06121776f, 0.01216783f, 0.00690191f, 
    -0.04708103f, 0.02505485f, -0.01885511f, 0.03779346f, -0.04632007f, -0.05471343f, 0.02072931f, -0.01594064f, 
    0.00269784f, -0.06263003f, -0.02658719f, 0.03546242f, 0.00911222f, -0.06171884f, -0.06740759f, -0.00545969f, 
    0.00560372f, 0.02438318f, -0.02298946f, -0.02845500f, -0.01679555f, 0.01171062f, -0.02325371f, 0.03085388f, 
    -0.03349047f, -0.01842477f, -0.01510816f, -0.02964692f, 0.02032682f, 0.02623525f, 0.02978822f, 0.02030812f, 
    -0.01360404f, -0.04381182f, -0.01470623f, 0.02324748f, -0.03104118f, 0.00902129f, 0.01274089f, -0.04838461f, 
    -0.03792812f, 0.01163537f, -0.00380704f, -0.02409951f, -0.02218284f, 0.00055401f, 0.04932642f, 0.00188652f, 
    -0.02152447f, -0.05647584f, -0.04949898f, 0.00281565f, 0.00498087f, -0.00432908f, -0.02057535f, -0.06488042f, 
    -0.00755423f, -0.00890419f, 0.03585978f, 0.00122791f, 0.04703118f, -0.01097396f, 0.00948170f, -0.04732543f, 
    -0.05309174f, -0.00103180f, -0.00803661f, -0.01378571f, -0.03018052f, -0.00097358f, 0.03617099f, 0.03503171f, 
    -0.05241797f, 0.00720102f, 0.00914307f, 0.04874873f, -0.03671983f, -0.02714973f, 0.00770262f, 0.02515401f, 
    0.01314071f, 0.00800159f, -0.02062238f, -0.02203650f, -0.03977242f, -0.02550784f, 0.00576099f, -0.05758189f, 
    -0.00933078f, 0.04225893f, -0.01204515f, 0.01534927f, 0.00491424f, -0.05549292f, -0.01681066f, -0.05904932f, 
    -0.01450685f, -0.01858159f, 0.00078216f, -0.04395356f, -0.06110606f, -0.01468079f, 0.03486607f, 0.00370236f, 
    -0.05116013f, 0.00774609f, 0.06031526f, -0.02960155f, -0.05071482f, 0.05982404f, -0.06480404f, 0.03731563f, 
    0.04268226f, -0.06407039f, -0.06370404f, -0.02839455f, 0.02190061f, -0.04050177f, -0.03945087f, -0.02798549f, 
    0.02350599f, -0.03371813f, -0.01753352f, -0.05712835f, -0.05540590f, -0.04079189f, -0.05416784f, 0.01637251f, 
    0.02249675f, -0.04081100f, 0.05090016f, -0.00159443f, -0.02930820f, 0.03665999f, 0.03281939f, -0.00240970f, 
    0.00716154f, -0.02270373f, -0.04763978f, 0.02571465f, -0.00143737f, 0.04960852f, -0.05153884f, -0.06386869f, 
    0.00584445f, -0.04572575f, 0.02814127f, -0.01722088f, -0.02351608f, -0.05031376f, -0.00869959f, -0.02339665f, 
    -0.01214719f, 0.03844386f, -0.01689355f, 0.03827503f, 0.04739694f, -0.02208920f, -0.02553195f, -0.04830451f, 
    -0.00685061f, 0.03834708f, 0.03574626f, -0.04254248f, -0.00571919f, 0.02900620f, -0.03479594f, 0.04109703f, 
    -0.02243575f, 0.05760974f, -0.03942990f, -0.00176167f, 0.04810605f, -0.01712817f, -0.01859145f, -0.04408153f, 
    -0.02250183f, 0.02461115f, -0.03321135f, 0.04013112f, -0.02439136f, -0.04863570f, -0.02401050f, -0.03541542f, 
    -0.01410312f, 0.03831491f, -0.02794062f, 0.00284247f, 0.01042810f, -0.06232054f, -0.01252869f, -0.01801356f, 
    0.01863465f, -0.06129739f, -0.03043072f, -0.03430602f, 0.00376738f, -0.03189243f, -0.03496544f, -0.05396992f, 
    0.03883288f, 0.04876503f, -0.02034216f, -0.05431930f, 0.00450534f, -0.04544020f, -0.02613953f, -0.05744428f, 
    -0.05895016f, -0.00258871f, -0.01038603f, -0.01253366f, -0.04025931f, 0.00189682f, -0.04112998f, -0.02527427f, 
    0.03938176f, -0.00174225f, -0.00732004f, 0.04111460f, 0.03499871f, 0.04415027f, -0.01659939f, 0.01933476f, 
    0.03599188f, 0.03402074f, 0.05184470f, 0.04518007f, -0.01008414f, 0.04512304f, -0.05223333f, 0.04040492f, 
    -0.00754441f, -0.03211255f, 0.00289877f, 0.03484928f, -0.05188947f, 0.03525858f, 0.01791749f, 0.03918078f, 
    0.02084719f, -0.04580673f, -0.00618517f, -0.00673719f, 0.03235117f, -0.02845140f, -0.04185239f, -0.00622859f, 
    -0.01276279f, 0.00559826f, -0.03745814f, -0.04738085f, 0.04094987f, 0.01402517f, -0.00139237f, 0.01165817f, 
    -0.04320338f, 0.03952463f, -0.00760468f, 0.00782855f, -0.05852303f, -0.05342321f, 0.01549110f, -0.03559285f, 
    -0.03065922f, 0.01751638f, -0.05681656f, 0.02238606f, 0.05137495f, -0.01041489f, -0.00351533f, 0.00599071f, 
    0.01013911f, -0.02941480f, 0.03880290f, -0.04557838f, -0.00289666f, -0.01214399f, 0.03571535f, -0.04287605f, 
    -0.05299515f, -0.00876597f, 0.04468491f, 0.02356990f, -0.00228972f, -0.03397442f, -0.02642886f, -0.03538845f, 
    0.02461538f, 0.01360605f, 0.02320993f, 0.01186130f, 0.00396530f, -0.00263515f, -0.02395865f, 0.02560435f, 
    -0.01343177f, -0.01907659f, -0.04485354f, 0.00722813f, 0.01387782f, -0.03627823f, 0.03668991f, -0.04830367f, 
    0.20223998f, -0.13750812f, -0.14040904f, 0.14735237f, -0.04903633f, 0.05215534f, 0.01363032f, -0.00292952f, 
    -0.00928433f, -0.14761768f, -0.05948910f, 0.10590366f, 0.29423109f, -0.04036254f, 0.06248245f, -0.17306152f, 
    0.05091673f, 0.06892145f, -0.19512244f, 0.02256776f, -0.03546771f, 0.01953666f, 0.01207286f, -0.02803317f, 
    0.02184192f, 0.07730556f, 0.13659807f, 0.12394249f, -0.28039393f, -0.44189093f, -0.05396621f, 0.11675612f, 
    0.08922346f, 0.00739063f, -0.11293917f, -0.08051455f, -0.03695136f, -0.18749647f, 0.11375542f, 0.14760822f, 
    -0.02798035f, -0.00643921f, 0.00445893f, -0.08109177f, 0.10452230f, -0.04887903f, 0.08251075f, -0.12583619f, 
    -0.00789490f, 0.10084508f, 0.04380532f, -0.04868912f, -0.02823372f, -0.05286470f, 0.14297013f, -0.16461593f, 
    -0.03144890f, 0.10344145f, 0.01701685f, -0.06523455f, -0.02501767f, 0.07380469f, 0.13954881f, 0.05215845f, 
    -0.03037182f, 0.10936457f, 0.00126825f, -0.01056348f, 0.01258540f, 0.03458092f, 0.01641304f, -0.00497653f, 
    0.08633325f, -0.09592474f, -0.18273455f, 0.04880158f, 0.10412251f, 0.13367890f, -0.03931030f, 0.07077715f, 
    -0.10269280f, -0.09205074f, 0.06828194f, 0.15923522f, -0.04032465f, -0.02262560f, 0.01525762f, -0.07487695f, 
    0.11695043f, -0.15658556f, 0.15778148f, 0.37622336f, 0.01262222f, 0.06075520f, -0.21362904f, 0.18061374f, 
    0.07039823f, -0.00380984f, 0.07259501f, -0.00275218f, 0.33923680f, -0.04261791f, -0.04395531f, -0.10627118f, 
    -0.00204762f, 0.13820410f, 0.04363189f, -0.00786498f, -0.06048491f, 0.14035556f, -0.19639517f, -0.03062054f, 
    -0.12769097f, -0.00843014f, 0.04326123f, 0.10614011f, 0.08810100f, 0.23560724f, 0.13002247f, 0.02601161f, 
    0.01008494f, 0.00255587f, -0.08108267f, 0.07059372f, 0.00936608f, 0.00884784f, -0.33066079f, -0.20693442f, 
    -0.31197989f, 0.03755791f, 0.08231179f, -0.03561499f, 0.12498211f, 0.03774620f, -0.04801672f, -0.13863367f, 
    0.16994075f, 0.00826772f, 0.17915662f, -0.04935791f, -0.02709559f, 0.05668728f, -0.01233262f, -0.14410533f, 
    0.05338760f, 0.11039298f, 0.19723275f, 0.06273702f, -0.13989507f, -0.17172162f, 0.00056711f, -0.15649116f, 
    -0.00597107f, -0.12639035f, -0.18988909f, 0.06692527f, -0.11888879f, -0.02583761f, 0.02498235f, -0.08065090f, 
    0.00176185f, -0.10433684f, -0.31385550f, 0.20194304f, -0.13062869f, -0.08994188f, -0.05982660f, -0.08605479f, 
    0.04194542f, 0.12605320f, 0.09936266f, 0.21349484f, 0.07337894f, 0.07916526f, 0.03278052f, -0.05476861f, 
    -0.09908008f, -0.00831748f, -0.07724932f, 0.01652334f, -0.03016227f, 0.20409666f, -0.11380560f, 0.00333004f, 
    -0.12803839f, -0.01376059f, 0.06176666f, 0.06836947f, -0.13101132f, -0.08761974f, -0.02625065f, 0.17247672f, 
    -0.25108066f, 0.07003333f, -0.02409990f, 0.03786949f, 0.10159844f, 0.06267538f, -0.07820528f, -0.37597701f, 
    -0.19055642f, -0.06038753f, 0.09675039f, 0.04798377f, 0.02377536f, 0.09707399f, 0.03962113f, -0.11707833f, 
    -0.10463589f, -0.00772875f, 0.14429398f, -0.07795918f, -0.04413632f, 0.07050609f, 0.05216770f, -0.07058387f, 
    -0.36948156f, -0.05741268f, -0.06103394f, 0.03347487f, 0.01303010f, 0.07351922f, -0.13100821f, -0.11295798f, 
    0.02717247f, 0.00731366f, 0.04957277f, 0.23047185f, -0.04523262f, -0.03753843f, -0.15302068f, 0.02626831f, 
    0.06493542f, -0.10567762f, -0.04421056f, -0.08866024f, 0.17062694f, 0.25440389f, 0.11339376f, -0.07283060f, 
    -0.07673106f, -0.00089837f, 0.08952144f, 0.05313799f, -0.06280907f, 0.13235149f, 0.12178542f, 0.03761472f, 
    -0.06171134f, 0.03384864f, 0.10482749f, -0.02454037f, 0.03940394f, -0.09003473f, -0.13894831f, -0.08157500f, 
    0.03596167f, 0.11487725f, -0.11079548f, -0.27930030f, -0.15898713f, 0.04509787f, 0.07860790f, 0.01467632f, 
    -0.02905938f, 0.08511218f, 0.03590282f, -0.03616079f, -0.16112933f, -0.18378425f, 0.05138426f, -0.23774227f, 
    -0.07060975f, 0.00599519f, -0.00096166f, 0.08908336f, 0.04719308f, -0.02934499f, 0.01122062f, -0.10407639f, 
    0.26142642f, -0.21488021f, 0.09715083f, -0.05289451f, 0.10006050f, 0.01166907f, 0.06748795f, 0.16973665f, 
    0.10394300f, 0.09509042f, -0.11647374f, 0.23059304f, -0.10269993f, 0.09217568f, 0.01889977f, -0.14612181f, 
    -0.25426602f, -0.07127222f, -0.12697241f, -0.13263577f, -0.11222096f, 0.07973359f, 0.04773026f, -0.06934857f, 
    0.04090764f, 0.25887430f, 0.06587355f, -0.12580961f, -0.07490527f, 0.00143175f, -0.20407225f, 0.20841771f, 
    0.04135517f, 0.11602554f, -0.07907428f, 0.16249003f, -0.11287836f, 0.11664508f, -0.04585598f, -0.07479153f, 
    0.10521127f, -0.07536148f, -0.11818362f, -0.07583914f, 0.30060652f, -0.07354455f, 0.02302087f, 0.07355641f, 
    -0.05745413f, 0.15043272f, 0.18250640f, -0.10619452f, -0.27440506f, 0.14567867f, -0.00637983f, -0.23393483f, 
    0.09112237f, 0.13753396f, 0.03390732f, -0.26063719f, -0.02491077f, -0.05542934f, 0.01669186f, -0.06211950f, 
    -0.00703792f, -0.03403219f, -0.03858931f, -0.02077468f, -0.06176325f, 0.19424084f, -0.13064039f, 0.10801554f, 
    -0.04515559f, -0.03234255f, 0.02222336f, -0.04619311f, -0.22101535f, -0.03366097f, 0.04649648f, 0.18724388f, 
    0.21889640f, 0.09687851f, -0.10150804f, 0.06514828f, 0.12980232f, 0.19675285f, -0.28109792f, -0.03569469f, 
    -0.17629880f, -0.20512150f, -0.05393610f, -0.01679015f, 0.06814916f, 0.20701551f, -0.10736690f, 0.05708962f, 
    0.08851688f, 0.03205810f, 0.19386421f, 0.24578856f, -0.21903968f, 0.13897374f, -0.12392169f, 0.11580388f, 
    0.09306874f, 0.14266746f, 0.12168980f, 0.06706372f, 0.19839570f, 0.03488030f, -0.10583063f, -0.00480693f, 
    0.11068321f, 0.11573078f, 0.12930441f, -0.06348320f, -0.04097773f, 0.23808786f, -0.08611794f, -0.13408162f, 
    -0.02661773f, 0.14012921f, -0.01169890f, -0.02958300f, -0.15822542f, -0.24047682f, -0.15022820f, -0.11704144f, 
    0.09366544f, 0.05893153f, -0.07766223f, 0.09990285f, 0.03438131f, 0.11755581f, -0.09439667f, -0.01011163f, 
    -0.02007824f, 0.02605463f, 0.05470647f, -0.02016855f, -0.01215934f, -0.07008933f, 0.03115123f, 0.14468658f, 
    0.03714985f, 0.12245395f, 0.11398361f, 0.22460775f, -0.24535468f, 0.02346046f, 0.15911248f, -0.01045258f, 
    0.13135824f, 0.16842048f, 0.11188463f, 0.10868495f, 0.00254047f, -0.35653427f, 0.07976343f, 0.10960723f, 
    0.06045630f, -0.03663100f, 0.05278384f, -0.09400084f, -0.15852512f, -0.01258345f, 0.30817616f, -0.40037635f, 
    -0.07283714f, -0.14575669f, 0.13300660f, 0.18869716f, 0.07497451f, -0.08429381f, -0.02612108f, -0.01646781f, 
    -0.16749451f, -0.00531498f, 0.02859891f, -0.24757940f, -0.15224832f, -0.00263364f, 0.05213324f, -0.07433642f, 
    -0.01088400f, -0.13266568f, 0.10443620f, 0.09453816f, -0.14022881f, 0.08751743f, 0.04772159f, 0.01626050f, 
    -0.11554588f, -0.10187393f, 0.01274947f, 0.11653886f, 0.25462520f, 0.01726928f, 0.02607106f, 0.01476673f, 
    -0.10319442f, -0.04935561f, -0.11484722f, 0.19806713f, -0.13124579f, 0.01556780f, 0.07842101f, -0.09615298f, 
    0.03170655f, -0.07708964f, 0.12046675f, 0.17931199f, -0.03403840f, -0.10002200f, -0.08405918f, 0.03554064f, 
    -0.04589598f, -0.05883838f, 0.02181793f, 0.02456896f, 0.08559419f, -0.13373068f, 0.03082649f, 0.06068833f, 
    -0.04363790f, -0.01072404f, 0.02314726f, 0.10258555f, 0.02713096f, 0.10709479f, -0.18064724f, 0.11924332f, 
    -0.13252635f, -0.06437255f, 0.06399541f, 0.01647251f, -0.02298190f, 0.00762725f, -0.14293586f, 0.12028018f, 
    -0.03497831f, 0.12681377f, 0.06117076f, -0.16625392f, 0.12932222f, -0.05680478f, -0.00962120f, 0.09285591f, 
    0.01416545f, 0.18275465f, 0.11281272f, 0.09192082f, -0.21515898f, -0.13896115f, 0.17125569f, -0.00976370f, 
    -0.12461826f, 0.04813249f, -0.04767986f, 0.18715692f, 0.03866906f, 0.22011095f, 0.16937703f, 0.01049208f, 
    0.01019226f, -0.14477322f, 0.06168920f, -0.13291077f, -0.13010466f, 0.05304395f, 0.15584078f, -0.01497489f, 
    0.15961984f, 0.13400950f, 0.02873944f, 0.05392844f, 0.02004577f, 0.01358207f, 0.13724872f, -0.12015289f, 
    0.00465620f, 0.13782571f, 0.19011571f, 0.18269561f, -0.11278500f, 0.08511759f, -0.04804344f, -0.22634766f, 
    0.14324068f, 0.00685609f, -0.02849719f, 0.05747568f, -0.03427584f, -0.15501742f, 0.07277218f, -0.15800336f, 
    -0.48955169f, 0.22606719f, 0.17968167f, 0.13294496f, -0.01757551f, 0.06266479f, 0.01312277f, -0.06325130f, 
    -0.10716311f, -0.06914277f, 0.03328739f, 0.00533606f, 0.11318254f, -0.00340675f, -0.03425098f, -0.01656695f, 
    0.06255668f, -0.03363688f, 0.46609560f, 0.13674583f, -0.10251949f, 0.06901038f, -0.06977865f, 0.08084954f, 
    0.01715130f, 0.14033303f, 0.08948412f, -0.00784202f, -0.27734497f, -0.19098231f, 0.13881776f, 0.04575971f, 
    0.16378671f, 0.06404616f, 0.04059020f, -0.06414327f, 0.04636291f, 0.22829786f, 0.02449282f, -0.04847099f, 
    0.02588449f, 0.11539275f, -0.06156544f, 0.05078161f, 0.06593324f, -0.24697921f, -0.10480233f, -0.13540968f, 
    -0.04074489f, -0.11360064f, 0.01508779f, 0.23368470f, -0.06397717f, -0.09076090f, 0.03339139f, 0.12227251f, 
    -0.18785730f, -0.05118518f, -0.15916640f, -0.06127245f, 0.00664287f, 0.00889821f, 0.02103914f, 0.11972585f, 
    -0.11922715f, -0.01924290f, 0.09635312f, -0.04977150f, 0.01348825f, 0.00191122f, 0.03501870f, 0.08199602f, 
    -0.14595354f, 0.29378286f, 0.01641119f, 0.01819685f, -0.07949727f, 0.14452295f, 0.03070439f, -0.04569066f, 
    -0.18030944f, 0.06132745f, -0.02652229f, -0.12015583f, 0.04641233f, -0.17604537f, -0.08726393f, -0.03487035f, 
    0.08107259f, 0.18540289f, -0.05519282f, 0.19746430f, 0.13925861f, 0.09600947f, -0.08798768f, 0.04551750f, 
    0.00419114f, -0.07936200f, 0.02235519f, -0.12859197f, -0.11909223f, 0.16059634f, 0.03919616f, -0.06141237f, 
    0.11903545f, 0.07583890f, 0.10724232f, -0.14284754f, -0.50074929f, -0.14035042f, 0.17383012f, -0.01038796f, 
    0.09013683f, 0.05275511f, 0.10472740f, 0.04367395f, -0.03440817f, 0.07408846f, 0.15811135f, -0.03368300f, 
    0.03979355f, -0.19964224f, -0.02811795f, 0.04424184f, 0.19299506f, 0.09818152f, -0.24614641f, -0.14785853f, 
    -0.12569185f, 0.32179952f, -0.00828170f, -0.14936759f, 0.12042870f, 0.03306190f, -0.00528476f, 0.25321913f, 
    0.19041878f, -0.03630688f, 0.06996486f, 0.03059865f, -0.08047573f, 0.14315967f, -0.02941213f, -0.07319243f, 
    -0.14717045f, -0.10458476f, -0.16417035f, -0.08134793f, -0.08070148f, 0.02707117f, -0.07814572f, 0.03331925f, 
    -0.10222758f, -0.08852051f, -0.26480660f, 0.19761024f, 0.00719177f, 0.02032548f, -0.05520776f, 0.05978492f, 
    0.00356490f, 0.03359583f, -0.34532809f, -0.01393854f, 0.15157266f, 0.13542379f, -0.02078323f, -0.06663340f, 
    0.06298836f, 0.03949057f, 0.00272430f, -0.04898531f, 0.18389603f, 0.15078498f, 0.05544708f, -0.16190591f, 
    0.01295323f, 0.16871455f, 0.17912363f, -0.02987106f, 0.21537040f, -0.13717005f, 0.25247124f, 0.01897239f, 
    -0.10770383f, -0.14873998f, 0.02008247f, -0.01168972f, 0.09550162f, 0.03017025f, 0.35193032f, -0.27952161f, 
    0.14061870f, -0.20993848f, 0.02888686f, -0.05449303f, 0.14620148f, -0.03249873f, -0.13390966f, -0.01759834f, 
    -0.20987236f, 0.08035079f, -0.08360738f, 0.08018125f, 0.11789244f, 0.26022100f, 0.21507318f, 0.10064007f, 
    0.11438339f, 0.14407769f, -0.06387727f, -0.04893277f, 0.01864589f, 0.22633664f, 0.02414664f, -0.09558927f, 
    -0.33629230f, -0.09058469f, -0.31727815f, 0.15986685f, -0.14935720f, 0.02872824f, 0.06707245f, -0.00697390f, 
    0.08595015f, 0.06518823f, 0.01237760f, -0.01423594f, -0.10665490f, 0.09450326f, -0.06254027f, 0.10542622f, 
    -0.02895959f, 0.06919970f, 0.15688492f, 0.28893480f, -0.12640776f, -0.02971039f, 0.04498895f, -0.05338341f, 
    0.01028802f, 0.08895835f, 0.05462873f, 0.08002923f, 0.10374977f, 0.05117941f, 0.08624005f, -0.00616851f, 
    0.01194258f, 0.09361845f, -0.07732882f, 0.01165759f, -0.21157759f, -0.42409083f, -0.19834325f, -0.11789415f, 
    0.01936924f, 0.09941811f, 0.18376265f, -0.18400402f, 0.09789582f, 0.21269022f, 0.05050013f, -0.01643942f, 
    0.02949966f, -0.07676239f, -0.21106346f, 0.12621990f, -0.04851419f, -0.02352381f, -0.08344653f, -0.25449002f, 
    -0.22020054f, -0.07714085f, -0.06624746f, 0.00121046f, 0.09626394f, -0.17526972f, 0.08619353f, 0.02040957f, 
    0.11698902f, 0.18882886f, -0.06098292f, -0.02812553f, 0.08050850f, -0.03851199f, 0.01531743f, -0.06498595f, 
    -0.02263508f, -0.01342670f, 0.07279842f, 0.11123160f, -0.02775517f, 0.14607583f, 0.08878493f, 0.06378480f, 
    -0.06548464f, 0.14085858f, 0.05421911f, -0.17819095f, 0.08953924f, 0.06015757f, 0.04652087f, 0.08252656f, 
    0.07970761f, -0.12605083f, 0.01890618f, -0.21744840f, -0.07749358f, 0.09035961f, -0.07274994f, 0.07156911f, 
    0.06714366f, 0.05622083f, 0.05280026f, -0.12654044f, 0.01246376f, 0.17809755f, 0.29710242f, -0.01641696f, 
    -0.05522884f, 0.10774144f, -0.04543326f, -0.00557682f, 0.28484568f, 0.11398882f, 0.09238712f, -0.01316871f, 
    0.00106387f, -0.06663614f, 0.08784791f, 0.02427873f, 0.11538412f, -0.20488705f, -0.01892855f, 0.14335603f, 
    -0.16365600f, 0.05324327f, -0.10394637f, -0.02579455f, -0.29336250f, -0.35761547f, -0.07655875f, -0.05055108f, 
    0.06798586f, 0.12463012f, -0.16997325f, -0.00500622f, 0.06273367f, 0.24995002f, -0.09642587f, -0.06238453f, 
    -0.04126141f, -0.11602799f, 0.20903017f, -0.08827953f, -0.00698155f, 0.05891960f, 0.18210423f, 0.05845829f, 
    0.05159252f, -0.01917422f, 0.15179425f, -0.02731842f, 0.01832123f, 0.01403818f, 0.14350294f, 0.06150240f, 
    -0.07045817f, 0.16441287f, -0.09924123f, -0.04519716f, 0.02856626f, -0.05137045f, 0.08343325f, -0.03309796f, 
    0.04623903f, -0.08424139f, 0.03095855f, -0.07292868f, -0.24087919f, -0.17650238f, -0.04828760f, -0.17443016f, 
    0.10987724f, 0.01754154f, -0.10401940f, -0.06091951f, -0.04572305f, 0.06877770f, -0.01117296f, -0.00430076f, 
    -0.00607344f, -0.03585945f, 0.16670185f, 0.06727187f, 0.15370768f, 0.10484140f, -0.02804502f, -0.07835948f, 
    -0.00846000f, -0.06979967f, 0.17569207f, 0.09975455f, 0.03660907f, -0.18966833f, -0.20743895f, -0.17062601f, 
    0.13841791f, 0.19573358f, -0.01396764f, 0.14649741f, -0.07855719f, -0.10128376f, -0.07687479f, -0.07258709f, 
    0.04769223f, -0.12389433f, -0.08614188f, 0.10270932f, 0.04481124f, 0.21635495f, -0.03410980f, 0.21862330f, 
    -0.07288790f, 0.00896271f, -0.13765731f, 0.12631816f, 0.01668672f, 0.00531998f, 0.06864636f, -0.19743133f, 
    -0.06627256f, -0.04409133f, -0.11234806f, -0.21506090f, 0.13526306f, -0.31374004f, -0.28049508f, 0.22940023f, 
    0.06811503f, 0.09802513f, -0.16523694f, -0.24125239f, 0.03048669f, 0.17940019f, -0.01876062f, 0.05319223f, 
    0.13863635f, -0.03640825f, 0.07665876f, 0.12682833f, -0.04117353f, -0.03734265f, -0.12027384f, 0.05501633f, 
    0.17412812f, 0.10913688f, 0.12267796f, -0.14259122f, -0.07911330f, -0.12917390f, 0.06377283f, 0.11024563f, 
    0.04347922f, -0.01959195f, -0.13374312f, -0.13878766f, -0.08794846f, 0.09046917f, -0.09191053f, -0.07147826f, 
    -0.05395468f, -0.02149707f, -0.06563450f, 0.03538334f, -0.00938528f, 0.16914904f, -0.06503176f, -0.21963863f, 
    0.02126200f, -0.12614119f, 0.14911453f, 0.14747840f, -0.22560483f, 0.02771414f, 0.33896193f, 0.06089080f, 
    -0.07734951f, 0.15518986f, -0.19597775f, -0.11231012f, -0.05175828f, 0.09290677f, 0.06580918f, 0.05852546f, 
    -0.23436652f, -0.06370549f, 0.17531142f, 0.09444976f, 0.07343532f, 0.10758080f, -0.13478354f, -0.21397623f, 
    -0.37878704f, -0.28432429f, 0.05129055f, 0.17422268f, -0.22340372f, 0.02297066f, -0.09968831f, -0.03446338f, 
    -0.14808352f, 0.06271186f, -0.07769725f, 0.09291894f, -0.06823774f, 0.02378776f, 0.11940540f, 0.08252495f, 
    0.11063167f, 0.04537660f, -0.07913342f, -0.21335982f, -0.05988670f, 0.10478681f, 0.00520958f, 0.08986160f, 
    0.09795329f, 0.02555264f, 0.05688445f, -0.34251237f, -0.33272475f, -0.23206434f, 0.28111765f, 0.03598268f, 
    -0.12075458f, 0.13634542f, -0.21783210f, -0.05578556f, -0.01341312f, -0.13196537f, 0.06727552f, -0.00456264f, 
    -0.10649937f, 0.05123594f, 0.01613163f, 0.03567267f, -0.08021273f, 0.07654645f, -0.02023388f, 0.08396588f, 
    -0.23486936f, -0.03584744f, 0.05623705f, -0.07057542f, 0.00513955f, -0.02676876f, 0.23977531f, -0.01017181f, 
    -0.13954313f, 0.00290545f, -0.10297038f, -0.11026827f, 0.01230866f, 0.01193119f, 0.00975418f, 0.09472422f, 
    0.14983509f, -0.15265906f, 0.12009534f, 0.07141912f, 0.02460152f, 0.06399151f, 0.16321027f, -0.00025735f, 
    -0.14307438f, 0.12829290f, 0.10030568f, 0.01946003f, -0.01819735f, -0.17541578f, 0.15407090f, 0.01811252f, 
    -0.00398981f, 0.19791499f, -0.52984899f, -0.14978622f, 0.16894354f, 0.04041748f, 0.09166500f, -0.04205956f, 
    0.06812690f, -0.05370276f, 0.08013152f, -0.11107194f, -0.30588904f, -0.02651067f, 0.04781486f, -0.01143258f, 
    0.00073335f, 0.01283020f, -0.09907743f, 0.03336351f, 0.17227773f, -0.02223951f, 0.08530074f, 0.12015008f, 
    -0.02798057f, -0.06435988f, 0.02215841f, -0.02438255f, 0.29962537f, 0.06773983f, -0.08211423f, -0.02711189f, 
    0.08215236f, 0.03413757f, -0.08068267f, 0.04404000f, -0.01291912f, 0.12084406f, 0.08779139f, 0.04698025f, 
    -0.09362025f, 0.02735121f, 0.04521610f, -0.02192070f, 0.20830983f, 0.01849267f, 0.05780291f, -0.04845588f, 
    -0.10925165f, -0.15025564f, -0.05794481f, -0.08001863f, -0.02799285f, -0.07679801f, -0.06036194f, 0.06964301f, 
    -0.10322496f, 0.06068028f, -0.01872092f, -0.02252935f, -0.01053115f, 0.12585941f, 0.05498344f, -0.06473318f, 
    0.05751919f, 0.28669414f, 0.02283107f, -0.06121912f, -0.11892573f, -0.05274074f, 0.16590880f, 0.02152301f, 
    0.03712310f, -0.04425976f, -0.07144783f, -0.00215283f, -0.00067886f, 0.13906440f, 0.00184184f, -0.12085025f, 
    -0.09377240f, 0.09148434f, 0.06442048f, 0.04477559f, -0.23550270f, -0.28777209f, -0.02478672f, -0.03757090f, 
    -0.24442938f, -0.03594473f, 0.01953940f, -0.20404606f, 0.06685150f, 0.00852704f, 0.01091454f, -0.01164575f, 
    0.12445576f, -0.17889740f, 0.02661062f, 0.03473654f, -0.25218523f, 0.04447496f, 0.09110063f, 0.08662747f, 
    0.07203823f, -0.02991237f, -0.02432464f, -0.00835507f, -0.02144038f, -0.21781604f, -0.05530483f, -0.10238491f, 
    0.15411763f, 0.07938346f, -0.01017858f, 0.03730169f, 0.06443705f, -0.05112540f, -0.38477060f, 0.16756955f, 
    0.03176177f, 0.01841078f, 0.02859469f, -0.05898946f, 0.05143973f, 0.04532640f, 0.06545284f, 0.15440319f, 
    -0.07581049f, 0.18897893f, -0.03233360f, 0.16876502f, 0.03786802f, -0.12865135f, 0.04899605f, 0.25685707f, 
    -0.02200136f, -0.02897792f, 0.07050734f, 0.00703466f, -0.16374284f, -0.02818046f, -0.01475012f, 0.11032945f, 
    0.00112102f, -0.19824988f, 0.16189167f, -0.00825259f, 0.01943793f, 0.03921823f, 0.06379770f, 0.07901493f, 
    -0.26568675f, 0.02882317f, 0.13798472f, 0.20104398f, -0.05267260f, 0.01556934f, -0.08165093f, 0.08553816f, 
    0.10202467f, -0.11407084f, -0.06353112f, -0.06674208f, 0.08538583f, 0.01489308f, 0.03814718f, -0.07482564f, 
    0.19417733f, 0.00989946f, 0.15723595f, 0.01782173f, -0.01433486f, -0.01862030f, 0.03531038f, -0.00047050f, 
    -0.04746046f, 0.12147935f, -0.10179803f, 0.10159619f, -0.24019656f, -0.08044256f, 0.12688740f, -0.02603332f, 
    0.01472039f, -0.11992445f, -0.00739564f, 0.05586436f, 0.16675746f, -0.07757962f, 0.25095478f, 0.10424859f, 
    0.02599499f, 0.02392367f, 0.21098317f, 0.05111642f, 0.16287251f, -0.00619473f, -0.04824718f, 0.02192939f, 
    -0.36826652f, -0.07479467f, -0.04110610f, 0.21654704f, 0.13659994f, 0.01250257f, -0.08713372f, -0.03205743f, 
    0.65981972f, 0.24355489f, -0.06832270f, -0.06172846f, -0.14812303f, -0.05085447f, -0.06941307f, 0.02052721f, 
    -0.17890204f, -0.06752967f, 0.05223201f, -0.01873095f, 0.11810019f, 0.01097197f, 0.03457923f, -0.06784420f, 
    0.04068878f, 0.12885168f, -0.20416759f, -0.42749447f, -0.06518535f, 0.17692053f, 0.11628393f, 0.04307735f, 
    0.07247747f, 0.00493621f, -0.02758281f, -0.30785370f, -0.11040750f, 0.01164567f, -0.04618635f, 0.09591442f, 
    -0.10938419f, 0.08804626f, -0.12377110f, 0.02419044f, -0.10776064f, 0.14021812f, 0.10947016f, 0.07665075f, 
    -0.14379635f, 0.11723716f, -0.02772837f, -0.06842049f, 0.03011243f, -0.26437673f, 0.05319164f, -0.02473892f, 
    -0.04040185f, -0.05302886f, 0.00257302f, 0.09109972f, 0.05866833f, 0.13687122f, -0.32463589f, 0.27769670f, 
    0.18162721f, -0.03724092f, 0.02114832f, -0.06765287f, 0.07525729f, -0.02996526f, -0.01590603f, 0.17634813f, 
    -0.03793699f, 0.04533042f, -0.16363452f, -0.15597656f, -0.20733133f, -0.04812970f, 0.04162589f, 0.01891384f, 
    0.05335884f, -0.00729722f, -0.04371981f, -0.06925146f, 0.02429036f, 0.04080579f, 0.01578425f, 0.04189843f, 
    0.02184541f, 0.03814565f, 0.02815834f, -0.05644790f, -0.05570149f, -0.01766810f, 0.01490535f, -0.00179898f, 
    0.00435013f, -0.05248622f, 0.05311477f, 0.00942129f, 0.02997720f, 0.04228110f, -0.02417703f, 0.03239911f, 
    -0.02947642f, 0.02357693f, 0.00915714f, -0.00252051f, -0.01911267f, 0.04048108f, -0.03798677f, -0.00311302f, 
    -0.02646221f, 0.02429488f, -0.00955696f, -0.06115109f, 0.04049163f, -0.02822398f, -0.03155869f, -0.00896773f, 
    -0.01729494f, -0.05451587f, 0.02758844f, -0.00974534f, -0.01009433f, 0.03350215f, -0.01671921f, -0.00154896f, 
    -0.04999948f, -0.05282803f, 0.04030158f, 0.02290254f, -0.06685744f, 0.01953841f, 0.03763917f, -0.05873707f, 
    -0.04544844f, 0.01547282f, 0.00100764f, -0.00904577f, -0.02459587f, -0.02812063f, -0.00243931f, -0.05278412f, 
    -0.01514197f, -0.07268616f, -0.00625295f, 0.02358687f, -0.02866950f, 0.00044977f, 0.00463715f, -0.01804570f, 
    0.05008261f, -0.02120406f, -0.00753204f, 0.03482007f, 0.03835440f, 0.01365670f, 0.03830954f, -0.00720387f, 
    -0.05391116f, -0.05279044f, 0.02431477f, 0.02530811f, 0.04240000f, 0.02296514f, -0.04686794f, 0.01932095f, 
    0.06008730f, 0.01959396f, -0.03192772f, 0.00363055f, -0.05095001f, -0.06566209f, 0.02149349f, -0.02828097f, 
    -0.06360137f, 0.00096562f, -0.03206733f, -0.06238788f, -0.02992367f, -0.03004593f, -0.01557254f, -0.00462283f, 
    0.04338102f, 0.03184349f, -0.05478614f, 0.00102270f, 0.03525708f, -0.03072337f, 0.02367295f, -0.03370939f, 
    -0.03288555f, 0.04614891f, -0.01831144f, -0.03079735f, -0.00386385f, 0.02495123f, -0.05112687f, -0.05446433f, 
    0.02811623f, -0.04658510f, -0.03970411f, -0.04506262f, 0.03606624f, -0.05649872f, -0.03837069f, 0.03949916f, 
    -0.02597800f, -0.06505140f, -0.01156214f, -0.02121087f, -0.05459785f, -0.03972642f, 0.03633184f, -0.03542987f, 
    -0.03407103f, 0.03989491f, -0.04463012f, 0.03467320f, 0.05092368f, -0.00781244f, -0.06070528f, -0.04524781f, 
    0.00211891f, -0.01197168f, -0.01129455f, -0.04798066f, 0.01798886f, -0.03596270f, -0.01220487f, 0.02319154f, 
    -0.00998201f, 0.00054162f, -0.02144615f, -0.03914448f, 0.03153667f, -0.06165749f, 0.01643577f, 0.02483484f, 
    0.03116495f, -0.01690964f, -0.05297597f, -0.06663200f, -0.05810689f, -0.06838415f, -0.03934446f, -0.06195879f, 
    -0.00002132f, 0.05247911f, -0.03228135f, -0.02356082f, -0.03874885f, -0.07058227f, 0.03686622f, 0.03410437f, 
    0.03081471f, -0.03253654f, 0.03616634f, 0.01197964f, -0.02533290f, 0.02493190f, -0.06869322f, -0.04677762f, 
    0.01984418f, -0.01061724f, -0.06388834f, 0.03590126f, 0.02315686f, 0.04465789f, 0.03633533f, -0.06035103f, 
    -0.04630685f, 0.00797522f, 0.01261434f, 0.01345719f, -0.00532043f, 0.05153542f, 0.02338341f, -0.04955230f, 
    0.00336210f, 0.01709566f, -0.03410905f, 0.01396494f, 0.00304467f, -0.06063671f, -0.01866673f, 0.04038483f, 
    0.03781704f, 0.03613816f, -0.03647397f, -0.07453664f, 0.03845843f, 0.02208007f, -0.00116868f, -0.03877136f, 
    0.01410704f, 0.02918939f, -0.00454956f, 0.01739437f, 0.00715527f, -0.02212030f, -0.02814496f, 0.02611718f, 
    -0.03563472f, 0.04707561f, -0.05678882f, -0.03060285f, 0.04295518f, -0.02497343f, -0.00660101f, -0.02440639f, 
    0.04433075f, -0.06156461f, -0.01016807f, -0.00324661f, 0.01656266f, 0.03798667f, 0.00027865f, -0.01505877f, 
    -0.01881168f, 0.02800490f, 0.01975280f, 0.02769726f, 0.00407445f, 0.03888590f, -0.06660078f, 0.03244724f, 
    0.01567657f, -0.05151356f, -0.02039386f, -0.00124330f, 0.00216502f, 0.02615766f, -0.00252356f, -0.01346503f, 
    -0.03730353f, -0.06618689f, -0.02676982f, -0.02674051f, -0.06524249f, -0.04074916f, -0.05224188f, -0.01311834f, 
    -0.06090173f, -0.03753045f, 0.01404262f, -0.03634883f, -0.05274235f, 0.01045286f, -0.01459106f, 0.03245394f, 
    0.02178954f, -0.00586122f, -0.05107002f, 0.01607592f, -0.03078540f, -0.05730340f, 0.00112591f, 0.03274453f, 
    -0.02925725f, -0.00597445f, 0.02657870f, 0.00926236f, 0.03655325f, -0.02088951f, 0.05485342f, -0.03642868f, 
    0.00756934f, -0.12512873f, 0.07978279f, 0.14596170f, 0.14155309f, 0.01063387f, 0.05937194f, -0.06114402f, 
    0.02344403f, -0.33649412f, 0.00532180f, -0.12008633f, 0.04325860f, 0.00077358f, 0.19696018f, -0.10429099f, 
    0.09705601f, -0.11457831f, -0.15024282f, 0.00938677f, 0.14519061f, 0.02838455f, 0.00062746f, -0.02016277f, 
    -0.03681362f, -0.06467289f, -0.00356277f, 0.05640603f, 0.18245117f, -0.10037296f, 0.07786813f, 0.13340093f, 
    -0.10281108f, 0.14275561f, -0.00124741f, 0.06256128f, -0.19846556f, -0.10158160f, -0.00327687f, 0.12655424f, 
    0.08531705f, -0.06437209f, -0.17783388f, 0.18087594f, -0.03466008f, -0.17104334f, 0.07196456f, 0.04609738f, 
    0.07892353f, -0.01638055f, 0.11807318f, -0.07480644f, 0.11557692f, 0.05957671f, 0.20263840f, -0.18113886f, 
    -0.02171198f, 0.17775561f, -0.03681426f, -0.09403333f, -0.13435054f, -0.14944780f, -0.13657796f, -0.16290510f, 
    0.11892900f, 0.13913652f, -0.08471466f, 0.05112749f, 0.02621845f, 0.11918297f, -0.12647995f, 0.03401921f, 
    0.12925814f, -0.16169320f, 0.13278209f, 0.23158430f, 0.20174177f, 0.05598344f, 0.12952209f, 0.07143647f, 
    0.20201741f, 0.15403174f, 0.02362686f, 0.04622580f, 0.16193052f, -0.07061257f, 0.00732243f, 0.05519176f, 
    0.05371557f, -0.05583373f, 0.01898650f, -0.52144504f, 0.12437655f, -0.08442233f, 0.16051339f, 0.10132915f, 
    -0.23171929f, 0.00531291f, 0.08817375f, 0.24258748f, 0.07477985f, -0.06155828f, 0.00384308f, 0.12790762f, 
    -0.01633392f, -0.15900186f, 0.14047252f, 0.08680759f, 0.14392264f, -0.08017901f, 0.11756230f, -0.00034072f, 
    -0.08444323f, 0.18373838f, 0.06517579f, 0.00737464f, -0.00564562f, -0.24728906f, 0.03441679f, 0.07694914f, 
    -0.01031928f, -0.02039578f, 0.18103330f, -0.02835862f, -0.05528110f, -0.10019859f, -0.05862270f, 0.16865025f, 
    -0.15873787f, 0.05967945f, -0.19969063f, -0.02113662f, 0.10319497f, -0.15635125f, 0.06064876f, 0.04497561f, 
    -0.16936459f, 0.09482006f, -0.02734538f, 0.00878779f, 0.06812408f, 0.05164259f, -0.10366458f, 0.13544203f, 
    0.28358480f, -0.26940808f, -0.12982869f, -0.11288384f, 0.07681765f, -0.00792594f, -0.09607603f, -0.07985579f, 
    -0.00985960f, 0.00249589f, -0.16159117f, -0.09933372f, 0.13828684f, 0.01705224f, -0.08838139f, 0.08932398f, 
    -0.12564522f, -0.05356982f, 0.15925865f, -0.01620205f, -0.08267084f, -0.12441175f, 0.02998622f, 0.07240117f, 
    -0.00578609f, -0.03235476f, -0.17050649f, -0.02545312f, 0.18587521f, 0.08604782f, 0.08295572f, 0.01329233f, 
    0.19135350f, -0.03383411f, -0.02088654f, -0.29242787f, 0.05754003f, 0.10443866f, -0.20275605f, -0.07128828f, 
    -0.01153370f, 0.08891644f, 0.09775516f, -0.10264825f, -0.24661718f, -0.01335760f, -0.00577961f, 0.11604853f, 
    -0.13523914f, -0.03276709f, -0.00391654f, 0.08204173f, -0.06907946f, -0.03502636f, -0.14736053f, 0.00202646f, 
    0.05962358f, 0.00851977f, 0.06936215f, -0.27619585f, 0.02900243f, -0.07142726f, 0.14942971f, -0.06907135f, 
    0.06467663f, 0.10074877f, -0.03001936f, 0.07216002f, 0.15383509f, -0.01406049f, -0.08854095f, -0.28173959f, 
    -0.01653161f, 0.03017957f, -0.15904534f, 0.07481869f, 0.11105274f, 0.08429069f, 0.10123187f, 0.01371687f, 
    0.02470648f, 0.29685500f, -0.11228442f, -0.04603473f, 0.04004677f, 0.13917959f, -0.12604213f, 0.07247453f, 
    0.15560740f, -0.00698146f, -0.56981510f, -0.31773138f, -0.18199745f, 0.01418431f, 0.09824608f, 0.15121330f, 
    -0.09667987f, -0.07683612f, -0.03981257f, -0.45326570f, -0.06463304f, 0.10284808f, -0.18200378f, 0.08441704f, 
    0.17911163f, -0.13668746f, -0.10157515f, -0.05231669f, -0.00230879f, -0.06448217f, 0.13236456f, 0.07756064f, 
    -0.05349790f, 0.07099619f, 0.16555738f, 0.11156941f, -0.02519475f, 0.14530312f, 0.06678151f, 0.02849591f, 
    0.04508618f, 0.09667390f, 0.06032471f, 0.04998885f, 0.18935223f, -0.04248233f, 0.03725691f, 0.48723850f, 
    0.06290293f, 0.10462919f, 0.00277166f, -0.17112644f, 0.00909621f, 0.03055223f, 0.09362473f, 0.24489340f, 
    -0.03942837f, -0.10966496f, -0.11573546f, -0.18582094f, -0.05015963f, 0.12038792f, -0.04004860f, -0.05726085f, 
    0.23248833f, -0.09305128f, 0.08046056f, -0.11229648f, -0.05643044f, 0.04315117f, -0.04838875f, 0.02050721f, 
    -0.08489902f, 0.03053830f, 0.21885927f, -0.19710588f, 0.12471832f, 0.04280663f, -0.07886863f, -0.10483095f, 
    -0.02054580f, -0.00002114f, 0.09098491f, -0.07474335f, -0.29661751f, -0.11802524f, -0.03136391f, -0.05412744f, 
    0.01662800f, -0.01979656f, -0.09052023f, -0.28119311f, 0.17649223f, -0.01471455f, 0.12963820f, 0.00021140f, 
    0.00632516f, -0.02270748f, 0.07312503f, 0.11786713f, -0.02135207f, 0.23414953f, -0.26544189f, -0.11814127f, 
    0.01570187f, -0.21269345f, -0.11275972f, 0.00670373f, -0.09669882f, 0.34091568f, 0.12561119f, -0.06939346f, 
    -0.04003673f, 0.02117735f, 0.00448300f, 0.02817679f, 0.01761093f, 0.11821305f, -0.00354042f, 0.04601475f, 
    -0.04541586f, -0.03167135f, 0.05103948f, -0.05838321f, -0.07137462f, 0.03097560f, -0.07627573f, -0.09538877f, 
    -0.07694724f, -0.04750728f, 0.14941256f, 0.08810247f, -0.02018077f, 0.11580440f, 0.09080046f, 0.03753190f, 
    0.25881988f, 0.10015713f, -0.02228565f, -0.09009337f, -0.04208332f, -0.03103909f, 0.04694599f, 0.01908091f, 
    -0.01201469f, 0.00456127f, -0.11267794f, 0.24114276f, 0.08871417f, 0.01709923f, -0.01985116f, -0.04145268f, 
    -0.00779255f, 0.01887449f, 0.11407290f, 0.20070094f, 0.36581382f, -0.00467503f, -0.08229337f, -0.03471607f, 
    0.02710029f, 0.06165912f, 0.01113777f, -0.44383025f, -0.00509194f, 0.18643411f, 0.08579990f, 0.11075404f, 
    0.03727140f, -0.09536568f, 0.05324569f, 0.09315787f, -0.31548610f, 0.03024460f, 0.02053862f, 0.14697884f, 
    -0.00392821f, 0.00462510f, 0.01652313f, -0.04193294f, 0.11515593f, 0.47253150f, 0.11249802f, -0.04766518f, 
    -0.05737977f, -0.01991517f, 0.07065837f, -0.11951315f, 0.17574367f, 0.05929494f, 0.10268310f, -0.27029708f, 
    -0.32892835f, -0.03488737f, -0.05018539f, 0.03862509f, 0.05907220f, -0.05093553f, 0.06271826f, -0.09082594f, 
    -0.26238832f, 0.19161612f, 0.04365042f, 0.12060981f, 0.18803012f, -0.20894861f, 0.02521173f, 0.05315665f, 
    0.02711583f, -0.16538136f, 0.38054022f, -0.01077171f, 0.01335386f, -0.07451008f, 0.04701217f, 0.11565293f, 
    -0.06545231f, -0.08227280f, 0.09143816f, -0.15679473f, 0.07997652f, -0.10925480f, 0.09434772f, 0.00747734f, 
    0.07034504f, 0.05884182f, 0.09853169f, 0.19853772f, -0.14684789f, -0.07688688f, -0.04667335f, -0.05804925f, 
    0.00724858f, -0.03262036f, 0.04903706f, 0.00901843f, 0.16200587f, -0.41132143f, 0.00653296f, -0.16640601f, 
    -0.00811295f, 0.05566745f, 0.02201672f, 0.07015853f, 0.09782854f, 0.20697963f, 0.10334817f, 0.00821564f, 
    -0.05485707f, 0.05878056f, 0.05477136f, 0.04330330f, 0.10419173f, 0.25800413f, -0.25897747f, 0.04944197f, 
    -0.06051264f, -0.19277942f, 0.07342249f, 0.00839068f, 0.00383766f, 0.06163139f, -0.05456554f, -0.00168814f, 
    -0.26479617f, 0.10156060f, -0.00342805f, 0.04526985f, 0.06030713f, -0.04355995f, 0.00580617f, 0.02443081f, 
    0.15196601f, -0.03268727f, 0.06670584f, 0.05552427f, -0.01587864f, -0.03045874f, 0.14555131f, 0.03369617f, 
    -0.24301918f, -0.06439877f, -0.28004032f, 0.18484415f, -0.14473355f, -0.05268621f, 0.07232360f, -0.07788542f, 
    -0.03233452f, -0.24409702f, -0.16278647f, 0.18186805f, -0.00457895f, -0.05380201f, 0.07548258f, -0.01892362f, 
    -0.02976849f, 0.01876538f, 0.02110678f, 0.18192928f, -0.16686417f, 0.17207164f, 0.00743701f, -0.11918133f, 
    -0.08354288f, -0.00374208f, -0.04368633f, -0.06773398f, -0.00419080f, 0.33021286f, 0.00677830f, -0.04198766f, 
    0.13125429f, 0.02157569f, 0.01609160f, -0.07276110f, -0.28742197f, 0.15118498f, 0.16230673f, 0.21934049f, 
    -0.01680356f, -0.02672320f, -0.06190814f, -0.01754363f, -0.16278961f, -0.25474784f, -0.19525585f, 0.31646302f, 
    0.00511092f, -0.00814202f, 0.12563211f, -0.05096472f, 0.02977674f, 0.24199785f, -0.29878798f, 0.16148616f, 
    -0.17849489f, 0.00074697f, 0.06002139f, -0.07889672f, 0.01095366f, -0.01143344f, -0.17642808f, -0.11419830f, 
    -0.01128772f, 0.02322243f, -0.03751636f, 0.18737787f, -0.07175684f, 0.05241418f, -0.02387665f, -0.02515399f, 
    -0.19575244f, 0.13042288f, -0.04620986f, 0.07651701f, -0.06564518f, -0.00612217f, 0.01211352f, 0.03771678f, 
    -0.04645858f, -0.09701842f, 0.19163480f, 0.16252849f, -0.00294738f, -0.00606928f, 0.05236432f, 0.08011225f, 
    0.20556471f, 0.08075774f, 0.26126590f, 0.05779876f, -0.11908851f, -0.07635455f, 0.12580621f, 0.03398916f, 
    0.01456288f, -0.06409498f, -0.05563839f, 0.20620482f, -0.17191264f, 0.08013584f, -0.01015046f, -0.01429249f, 
    0.10189283f, -0.10270366f, 0.04639553f, 0.02856320f, -0.14135419f, 0.20209317f, 0.14271836f, -0.14600623f, 
    0.09248940f, -0.14699216f, -0.06887639f, 0.07071660f, 0.05599127f, -0.02755808f, 0.12186045f, -0.14085042f, 
    0.15210125f, 0.00538171f, -0.14194351f, 0.07532723f, 0.18547133f, -0.11673020f, -0.32829386f, 0.00946866f, 
    0.30499402f, -0.16551532f, 0.04683091f, -0.01232526f, -0.01550245f, 0.02703893f, -0.18296707f, -0.00777850f, 
    0.09565377f, 0.16164142f, -0.11375886f, 0.04636591f, 0.05568380f, 0.17324422f, -0.17291938f, -0.02386886f, 
    -0.12141322f, 0.03067179f, -0.26713830f, 0.04630059f, -0.10928437f, -0.05991865f, -0.04964270f, 0.08966551f, 
    -0.03160481f, 0.04762056f, -0.10024502f, 0.01805944f, 0.20954658f, 0.04410870f, -0.03784399f, -0.07426929f, 
    -0.22811018f, -0.04582438f, -0.27259529f, 0.06543000f, -0.09953921f, 0.26460892f, 0.12563974f, -0.03918121f, 
    -0.17859298f, 0.20887145f, 0.10493172f, -0.28707969f, -0.15655200f, -0.01140211f, 0.20794240f, -0.04769501f, 
    0.05667477f, 0.06641944f, 0.18508093f, -0.11140135f, -0.07035899f, 0.11887866f, -0.05336764f, 0.10550860f, 
    0.14625029f, -0.00829141f, -0.00513811f, -0.19269359f, 0.03688541f, 0.13758208f, 0.17786467f, 0.10634506f, 
    0.10272796f, -0.24636886f, 0.03369032f, 0.10905068f, -0.06722567f, -0.03525721f, -0.16459951f, 0.16242167f, 
    0.04534196f, 0.14880717f, 0.04223407f, -0.04449091f, 0.14791112f, -0.16138025f, 0.10152211f, -0.09170189f, 
    0.00850514f, -0.14770168f, 0.06886721f, 0.00949892f, -0.07354710f, -0.04630768f, 0.04036399f, -0.05679590f, 
    -0.00317507f, -0.40172297f, -0.22422385f, 0.15711454f, -0.01882792f, 0.03069190f, -0.01124732f, 0.00766170f, 
    -0.21245995f, 0.27408686f, 0.12787847f, -0.24165842f, -0.17782569f, 0.23153619f, 0.05106671f, -0.25591695f, 
    0.12470383f, 0.09692587f, -0.06297671f, -0.18753748f, 0.03713051f, -0.08990820f, 0.12017625f, -0.10742569f, 
    -0.04082971f, -0.12413277f, 0.13777545f, 0.12829697f, 0.08749539f, 0.06507645f, -0.02802714f, -0.07998509f, 
    -0.02352588f, 0.10225865f, 0.02973642f, 0.09525851f, 0.01101343f, -0.08011079f, -0.07096965f, -0.05909811f, 
    -0.05675294f, 0.05534675f, -0.04668776f, -0.02380944f, 0.16774490f, 0.06227663f, -0.13575293f, 0.19603895f, 
    -0.05157597f, 0.10431447f, -0.07747357f, 0.02631936f, -0.23594533f, -0.01881933f, 0.05798141f, 0.09121126f, 
    -0.17609540f, 0.05059782f, 0.01706221f, 0.13430482f, -0.14557618f, 0.10954845f, 0.08475927f, 0.13444969f, 
    0.25122720f, 0.17416123f, -0.04221185f, -0.05613530f, 0.15458591f, 0.00859006f, 0.20326093f, 0.16484219f, 
    -0.23044556f, -0.08057939f, 0.14588565f, 0.04120380f, 0.15523469f, -0.24541236f, -0.03555289f, 0.04437562f, 
    0.01507374f, 0.02272020f, 0.02204429f, 0.06803545f, 0.05728715f, -0.02958671f, 0.02137201f, -0.03860341f, 
    -0.03349048f, -0.15312798f, 0.05013825f, 0.22807862f, 0.20064802f, -0.12195425f, 0.00371730f, -0.06135822f, 
    0.00588103f, 0.01134177f, -0.10506485f, 0.06130718f, 0.17476164f, 0.13639988f, -0.16836630f, 0.16205215f, 
    0.02156262f, -0.05147988f, 0.07641089f, -0.06602719f, -0.42368042f, -0.37306225f, -0.13773002f, 0.04333021f, 
    0.21623218f, 0.08953645f, 0.14458714f, -0.00792962f, -0.20096666f, 0.16404937f, -0.11679771f, -0.04364400f, 
    0.16516694f, -0.11391576f, -0.20615369f, 0.00072063f, 0.05710628f, -0.11536563f, 0.20575708f, -0.02806523f, 
    -0.10500377f, 0.01774268f, 0.16206326f, -0.12442141f, 0.00488882f, -0.01783988f, -0.03425412f, -0.25768772f, 
    -0.25525668f, -0.06021485f, 0.08905889f, 0.03042377f, 0.06482565f, 0.23989014f, -0.05464070f, -0.06035174f, 
    -0.18775980f, -0.02804805f, 0.04190440f, 0.06304029f, 0.06655846f, 0.00225590f, -0.04656119f, 0.02594751f, 
    -0.07912099f, 0.09276013f, 0.03341809f, 0.31728145f, -0.19676229f, 0.24538144f, 0.05686682f, 0.09137115f, 
    0.03633093f, -0.05971719f, -0.39055690f, -0.21408114f, -0.08850770f, -0.05202141f, -0.00263495f, 0.03108155f, 
    -0.03377353f, 0.04615114f, -0.11112823f, 0.01198319f, -0.23699246f, -0.09896682f, 0.09030695f, 0.03711988f, 
    -0.02331768f, 0.07027341f, 0.04914223f, -0.10736512f, -0.29061946f, 0.03014110f, -0.01872727f, -0.22792357f, 
    -0.11020222f, 0.01078508f, -0.14255363f, -0.05560218f, 0.12312242f, 0.09696865f, -0.05659790f, -0.23030970f, 
    -0.03065911f, -0.04107582f, 0.10968594f, 0.14580962f, -0.11547714f, 0.11464588f, -0.04595057f, -0.03811231f, 
    -0.60821867f, 0.12128283f, -0.06514384f, 0.03778646f, -0.11763256f, 0.02840352f, -0.16015570f, -0.21766444f, 
    0.05176814f, -0.10308272f, -0.03314217f, -0.03412489f, 0.19122231f, -0.07062081f, 0.05335165f, 0.02245758f, 
    0.02959329f, -0.25073287f, 0.06477853f, -0.02255267f, 0.07251578f, 0.00105641f, -0.08430577f, 0.08093853f, 
    0.08520745f, 0.16445671f, 0.12396290f, -0.11094871f, -0.00398114f, -0.05019639f, 0.10509731f, 0.05182634f, 
    0.05336528f, 0.19829592f, -0.09420704f, -0.00196312f, 0.22166680f, 0.00642422f, 0.01887326f, -0.11190257f, 
    0.12634070f, 0.19175385f, 0.07869758f, 0.16288224f, 0.01181987f, -0.09289533f, 0.10043412f, 0.14832009f, 
    -0.04328229f, 0.22789769f, 0.10988067f, -0.16869086f, -0.19023205f, -0.19276503f, 0.05346144f, 0.01607085f, 
    -0.00556814f, -0.08427241f, 0.17562412f, -0.10656219f, -0.00688622f, -0.11397848f, 0.06848989f, 0.14027411f, 
    0.07691514f, 0.01987587f, -0.04769044f, 0.15345898f, -0.09805985f, 0.10289324f, -0.13665466f, -0.06446583f, 
    -0.16252328f, 0.02395078f, 0.06791659f, 0.09140780f, -0.13815209f, -0.04270430f, -0.26127222f, -0.13413580f, 
    -0.10872468f, -0.10508337f, 0.13627981f, 0.15653718f, 0.07618168f, 0.01122687f, -0.09908575f, -0.07966705f, 
    -0.37269068f, 0.17331550f, -0.19266909f, 0.10107524f, 0.02423096f, 0.06097932f, 0.06286458f, -0.12224875f, 
    0.20972757f, 0.17530325f, 0.02358778f, 0.30681708f, -0.17729391f, -0.11299352f, -0.03816656f, -0.07523462f, 
    0.04006387f, -0.06999276f, -0.40789554f, -0.11658570f, 0.16358568f, 0.13764846f, -0.06274994f, -0.12913668f, 
    -0.00203026f, 0.01084458f, 0.05266232f, 0.09844039f, 0.24099062f, 0.23709249f, 0.12152803f, -0.06630414f, 
    -0.13170169f, 0.08915633f, 0.05570460f, 0.14900637f, -0.19471954f, -0.13602869f, 0.03177096f, 0.09350108f, 
    0.12854132f, -0.14385398f, -0.10784506f, -0.00588260f, 0.07168122f, -0.31335720f, 0.27954513f, 0.20622024f, 
    -0.06349862f, -0.06758301f, -0.01693593f, 0.06211769f, 0.06441156f, 0.01649076f, -0.01417775f, -0.01802998f, 
    0.22878265f, -0.28558683f, -0.05545679f, 0.04111518f, -0.09073307f, -0.02417393f, 0.33426172f, 0.00223805f, 
    -0.13969310f, 0.09770985f, 0.03799589f, 0.17657574f, 0.01633623f, -0.03249713f, 0.03750511f, -0.03096754f, 
    0.40082687f, 0.34379706f, 0.12475482f, 0.07309585f, -0.02579885f, 0.04115468f, 0.17767470f, 0.01152612f, 
    0.04815084f, 0.26787490f, 0.05889726f, -0.42369017f, 0.01909007f, 0.07548637f, 0.00320132f, 0.20574562f, 
    -0.00649174f, -0.00017863f, -0.14361982f, 0.11785028f, 0.07126742f, -0.09944957f, 0.17960623f, -0.02285404f, 
    -0.04062593f, -0.11038830f, 0.01491495f, -0.02625710f, 0.03152949f, 0.06276889f, -0.17660099f, 0.05420562f, 
    -0.03087578f, -0.05782504f, -0.02778928f, 0.02384296f, 0.10999275f, 0.05009191f, 0.06324576f, -0.01019226f, 
    0.13164061f, 0.13414966f, -0.08487135f, -0.18001898f, -0.12309852f, 0.16292879f, 0.32573107f, -0.03720164f, 
    -0.02837495f, -0.04363544f, 0.10245129f, 0.09373910f, 0.00877393f, 0.01558656f, -0.33849862f, 0.08274163f, 
    0.04449344f, -0.07323526f, 0.03268070f, -0.08007829f, -0.04716551f, 0.14910068f, -0.12486219f, -0.02668036f, 
    -0.35104576f, -0.02637194f, 0.00778342f, 0.00173340f, -0.02488370f, 0.02466439f, 0.04437799f, 0.07449407f, 
    0.29263267f, -0.14034104f, -0.13541980f, 0.09393984f, 0.05417570f, 0.19676392f, -0.05322320f, -0.10890539f, 
    -0.06254312f, -0.29089084f, -0.10851906f, -0.12323464f, -0.03370324f, 0.11862202f, 0.13499582f, -0.11723311f, 
    0.11370330f, 0.08632918f, -0.65144873f, 0.13501292f, 0.05242182f, 0.22587693f, 0.12059810f, 0.08751070f, 
    0.06565499f, 0.16440184f, 0.06313279f, -0.27805099f, -0.08397768f, -0.08527987f, 0.18247068f, 0.11593091f, 
    0.18370128f, -0.02694318f, -0.07828083f, -0.15145434f, -0.08507191f, -0.06607619f, 0.00270508f, 0.11852457f, 
    -0.06127751f, 0.14881593f, -0.10939749f, 0.06645468f, -0.07146554f, -0.26440027f, -0.18031605f, -0.03776217f, 
    -0.05539509f, -0.04098063f, -0.12106867f, -0.15083931f, -0.03010552f, 0.03349815f, 0.43335405f, -0.14156611f, 
    0.02584227f, -0.15020625f, -0.02585682f, 0.00035984f, 0.04903533f, -0.10241354f, 0.06966957f, -0.22467312f, 
    0.01927011f, 0.03491597f, -0.02958969f, -0.03654708f, -0.04690699f, 0.01813884f, 0.07106405f, -0.01699081f, 
    -0.20062928f, -0.32670462f, -0.05378023f, 0.10379872f, 0.12220386f, 0.29504159f, -0.13127126f, -0.00226638f, 
    -0.10327509f, 0.26303643f, 0.19642453f, -0.00712400f, -0.02538315f, -0.06200710f, -0.01341757f, -0.09682038f, 
    0.00428456f, -0.06469990f, 0.32439891f, -0.09459276f, 0.27420363f, -0.25132266f, 0.04009615f, -0.01683437f, 
    0.06617264f, 0.01384026f, 0.04711403f, 0.08328737f, 0.18653059f, 0.19034845f, -0.08175976f, -0.05694284f, 
    -0.11893949f, 0.04576302f, 0.13054320f, 0.01819886f, 0.10409318f, -0.25786418f, -0.08038653f, -0.04869596f, 
    -0.08570284f, 0.13817410f, -0.00195490f, 0.04791097f, -0.01816169f, -0.09138265f, -0.26144138f, -0.02448773f, 
    0.01065565f, -0.04255400f, -0.12969926f, -0.13644765f, 0.11003863f, -0.02047695f, 0.11095100f, 0.01595719f, 
    -0.27879602f, 0.09465534f, -0.06480900f, 0.09007178f, -0.03833190f, 0.00813731f, -0.13416846f, -0.09198387f, 
    0.22357355f, 0.07645136f, 0.15380725f, -0.12744984f, -0.03697339f, 0.14814760f, -0.06789276f, 0.23748539f, 
    0.51008427f, -0.06434142f, 0.03736985f, 0.13310215f, 0.16462459f, -0.12935531f, -0.04235730f, -0.06754906f, 
    0.18154506f, -0.20132558f, 0.06954745f, -0.02988587f, 0.04696690f, 0.01374395f, 0.15855981f, -0.19022790f, 
    0.00171250f, -0.01816544f, -0.01582879f, -0.09578715f, -0.20850357f, -0.02521033f, -0.00129464f, -0.01235477f, 
    -0.01433496f, 0.05515847f, -0.11354766f, 0.15324529f, -0.00600076f, -0.01219095f, 0.02240334f, 0.04654836f, 
    -0.12820089f, 0.00292881f, 0.18890697f, 0.04873164f, 0.20429939f, 0.20706750f, -0.23999761f, -0.13472693f, 
    0.08233869f, -0.10205115f, -0.13456933f, 0.02402229f, -0.03012778f, 0.21762542f, -0.17684147f, 0.20370536f, 
    -0.04057252f, 0.00786876f, -0.06212580f, -0.01390694f, 0.10649189f, -0.07799345f, -0.21397471f, 0.06812752f, 
    -0.42391160f, 0.22695373f, 0.08567695f, 0.11058256f, -0.04583436f, 0.01073588f, 0.01754996f, -0.30626866f, 
    0.09920797f, -0.11679465f, -0.03638000f, -0.01444941f, 0.07627834f, -0.11228395f, 0.00026737f, 0.11340968f, 
    0.07325305f, -0.21814965f, -0.22815388f, -0.07939754f, 0.11187966f, -0.06639202f, 0.00486217f, 0.01632483f, 
    0.09720229f, 0.23479247f, 0.19043273f, 0.12795724f, 0.04795379f, -0.00056202f, -0.00695088f, 0.11287604f, 
    0.08679629f, 0.05204055f, -0.34243405f, 0.05945576f, -0.03576197f, -0.05655038f, 0.07307761f, 0.03693254f, 
    -0.05181586f, -0.01713413f, 0.01803875f, 0.02837733f, -0.01448994f, -0.00385235f, -0.22062935f, -0.23292521f, 
    -0.06040175f, 0.13902894f, 0.10160621f, 0.18926752f, 0.16695088f, -0.23901379f, -0.38139623f, 0.05011334f, 
    -0.06273649f, -0.00606258f, 0.18443085f, -0.11691187f, -0.04613169f, 0.24717970f, 0.17197427f, -0.13044028f, 
    0.21733545f, -0.03330364f, -0.15285258f, 0.13564451f, -0.08513521f, 0.00900655f, 0.08119503f, 0.22652538f, 
    -0.48558700f, 0.00424276f, 0.05793183f, 0.11790325f, -0.11205079f, -0.06216831f, 0.03937480f, 0.23563197f, 
    -0.06554136f, 0.02335678f, 0.05716345f, -0.06838032f, -0.09534846f, -0.08733457f, 0.01811613f, 0.01921153f, 
    0.01983849f, 0.09607113f, 0.06342109f, 0.17822245f, -0.10013250f, -0.03803905f, 0.02469149f, -0.00417850f, 
    -0.10070840f, -0.52415878f, -0.56207079f, 0.14262775f, 0.07534970f, 0.04573889f, 0.16544503f, -0.02364349f, 
    0.10950103f, 0.03722861f, 0.17991789f, 0.01467344f, -0.12924242f, 0.11170752f, -0.06466632f, 0.03585322f, 
    -0.08196829f, 0.20289378f, 0.02111130f, 0.24352321f, 0.12050460f, -0.05541204f, 0.08204177f, 0.01734789f, 
    -0.13696621f, -0.01603284f, -0.07402812f, -0.02668312f, 0.08970805f, 0.00292389f, -0.00575530f, 0.15673502f, 
    0.04309003f, 0.02750790f, -0.12251822f, -0.03741066f, 0.12504518f, 0.10533986f, 0.20770347f, -0.13606925f, 
    -0.06224446f, 0.03700185f, 0.14541025f, 0.03850788f, 0.04966601f, -0.16212803f, 0.03081871f, -0.16995393f, 
    -0.22724101f, -0.22922672f, -0.08852713f, 0.06722408f, -0.07026251f, 0.09413517f, -0.01190552f, -0.14032869f, 
    -0.05474235f, -0.09728307f, 0.06147427f, -0.18298467f, 0.01690926f, -0.00738113f, 0.15160665f, 0.05879710f, 
    -0.06227313f, 0.09582312f, 0.07049138f, 0.08199339f, 0.02539390f, 0.04159466f, -0.08858076f, 0.01609261f, 
    -0.15637989f, 0.06695294f, 0.09433417f, -0.02980971f, 0.03948914f, 0.02548646f, -0.05057659f, -0.06717165f, 
    0.09897441f, 0.05964737f, -0.05504584f, 0.04751491f, -0.24618395f, -0.00952579f, -0.17088293f, -0.04730610f, 
    -0.23166752f, 0.07776494f, -0.03570982f, -0.00039346f, 0.15117002f, -0.16824159f, -0.13570583f, -0.00388988f, 
    0.20310917f, -0.03531182f, 0.13326748f, 0.02688680f, 0.09422255f, 0.13312265f, 0.12535858f, -0.04307598f, 
    -0.03251529f, 0.02267608f, -0.05545957f, -0.07410029f, 0.08397061f, -0.56494910f, -0.16237234f, -0.34877682f, 
    0.04028961f, 0.03173601f, 0.01781729f, 0.06687391f, 0.01390591f, 0.21422513f, -0.23897256f, -0.24803375f, 
    0.11253802f, 0.14207660f, -0.03610026f, -0.08281495f, 0.00349260f, 0.04453244f, -0.08921364f, -0.05579410f, 
    0.10180117f, 0.16558318f, 0.01712742f, -0.09309296f, -0.06028106f, -0.09494156f, 0.06641904f, -0.11984371f, 
    0.08797465f, -0.10797005f, 0.10090551f, 0.01014948f, 0.03798281f, -0.17488006f, -0.04894514f, 0.09033089f, 
    -0.17536904f, 0.14659730f, 0.26702881f, 0.25911355f, 0.06212647f, -0.04684732f, 0.03967884f, -0.00248862f, 
    -0.08217313f, -0.08594648f, -0.07776333f, 0.13828118f, -0.04151154f, -0.08637388f, 0.00594415f, 0.02453342f, 
    -0.04861328f, -0.03177390f, 0.11696429f, -0.23374461f, -0.03418665f, -0.17700839f, 0.06688214f, 0.14332901f, 
    0.03400127f, -0.03635301f, 0.01868836f, 0.10000266f, -0.22153154f, -0.20132788f, -0.17112529f, -0.12887681f, 
    -0.02757495f, -0.02168399f, 0.19260871f, -0.06957222f, 0.03418744f, 0.02473682f, 0.10446394f, -0.16676866f, 
    -0.14152814f, -0.07359174f, -0.07286695f, 0.09990498f, 0.02178038f, 0.13707808f, 0.27104378f, 0.16070639f, 
    -0.03268863f, 0.17728251f, 0.03058012f, 0.00851878f, -0.01805482f, -0.02921857f, 0.03723944f, -0.33257768f, 
    -0.32614917f, 0.29961455f, 0.04390463f, 0.14261375f, 0.21583340f, -0.08013983f, -0.09845501f, -0.05002638f, 
    0.19775124f, -0.09451291f, -0.25435635f, -0.03084789f, 0.04552347f, -0.03690112f, -0.10553179f, -0.05694619f, 
    -0.04129340f, 0.25874147f, 0.17858139f, 0.07873487f, -0.04688115f, 0.00172305f, 0.03677940f, 0.00697799f, 
    0.17503452f, 0.13918178f, -0.82042325f, -0.17896739f, 0.03843673f, 0.12725180f, 0.02392409f, 0.28751296f, 
    -0.11413521f, 0.04136386f, -0.02928972f, -0.42231217f, -0.16891055f, -0.03601113f, -0.05997830f, -0.00894009f, 
    -0.07887416f, 0.06593277f, 0.08039581f, 0.11790444f, -0.09770359f, -0.10688242f, -0.09150815f, -0.05026082f, 
    -0.01852988f, 0.11924513f, 0.13384478f, 0.09959836f, -0.16016269f, 0.22341004f, 0.06103965f, -0.02933512f, 
    -0.01947101f, 0.04647638f, -0.00232425f, 0.09989985f, 0.07586668f, -0.01713910f, 0.00508587f, 0.04505154f, 
    0.02503580f, 0.18175620f, -0.00634219f, 0.02427979f, -0.19513772f, -0.06253336f, -0.07274223f, -0.01751219f, 
    0.04084806f, 0.02272762f, -0.11265839f, -0.12773438f, -0.03365041f, -0.02469919f, 0.06937405f, 0.16204146f, 
    -0.02790631f, 0.02580903f, -0.06073677f, 0.04621131f, -0.03886900f, -0.03178806f, -0.04600158f, 0.04432565f, 
    -0.04405715f, -0.02358063f, -0.00663249f, 0.03286332f, 0.04540735f, -0.01091929f, -0.03870445f, -0.03771851f, 
    0.01121434f, -0.03747977f, 0.02902197f, 0.03663189f, 0.03924619f, -0.05868593f, -0.05298845f, 0.01108886f, 
    -0.00761878f, -0.00323424f, 0.02089752f, -0.03252095f, -0.02650796f, 0.02019946f, -0.04069050f, -0.01554245f, 
    0.03728659f, -0.01925501f, -0.00721768f, -0.00102292f, -0.06167886f, 0.02301799f, 0.01586105f, 0.02775756f, 
    -0.04792714f, 0.03326874f, -0.00173466f, 0.01607557f, -0.02007807f, -0.01021655f, -0.01721853f, -0.05916793f, 
    0.00044237f, 0.04688479f, 0.04381155f, -0.01850808f, -0.05033797f, 0.02100409f, -0.04001372f, 0.04560521f, 
    -0.05746855f, 0.05941552f, -0.04247371f, -0.04726723f, -0.02490786f, 0.06141682f, 0.05068538f, 0.03884478f, 
    -0.00851495f, -0.03319908f, -0.00595205f, -0.02924639f, -0.04031700f, -0.02668855f, 0.02235477f, -0.03736303f, 
    0.04501064f, -0.02791630f, -0.00509366f, 0.02568390f, -0.03755437f, 0.04103822f, 0.03405910f, -0.04312320f, 
    0.02387523f, -0.04404624f, -0.05134967f, -0.05885749f, -0.03705883f, -0.00695298f, 0.04836177f, -0.01296951f, 
    0.01748797f, -0.05355849f, -0.02976831f, -0.04886546f, -0.02817694f, -0.04730745f, 0.01241593f, -0.04660247f, 
    0.01541159f, -0.05722736f, 0.02475749f, -0.02092842f, -0.04101099f, -0.05299620f, -0.01016310f, -0.00315751f, 
    -0.01061939f, 0.00094994f, 0.02275465f, 0.03836552f, 0.03046481f, 0.02664384f, 0.03360778f, 0.02111591f, 
    -0.05600818f, -0.02201821f, 0.03089785f, 0.03066191f, -0.05026186f, 0.04196727f, -0.00095370f, 0.00053188f, 
    -0.05191916f, 0.05550837f, -0.02004641f, 0.00806457f, -0.01237797f, -0.05620775f, 0.02413801f, -0.04021438f, 
    0.05020195f, -0.05098705f, 0.05211793f, -0.02424191f, 0.04254936f, -0.05217793f, 0.01701500f, -0.02380183f, 
    0.00990747f, 0.00546867f, -0.03610177f, 0.03881729f, 0.02746961f, -0.00262764f, -0.03344297f, -0.00295656f, 
    -0.05291189f, -0.04516155f, -0.00384634f, -0.03770161f, -0.04963135f, -0.04003230f, -0.02556275f, 0.03799300f, 
    0.04128935f, -0.05030004f, 0.01686210f, 0.01956953f, -0.06184471f, 0.01927467f, 0.00702864f, 0.00711794f, 
    -0.00673324f, -0.01352670f, 0.02841678f, -0.04833665f, -0.01221379f, 0.04309900f, 0.04075763f, 0.01514004f, 
    -0.01650959f, -0.01685394f, 0.01572563f, -0.04204794f, -0.01337029f, 0.02255123f, 0.02364301f, -0.05492171f, 
    0.03256292f, -0.01823292f, 0.02674900f, -0.00583000f, -0.00338769f, -0.03483933f, -0.06335122f, -0.06581081f, 
    -0.05045224f, -0.00044607f, 0.04185593f, 0.05053452f, 0.04996835f, 0.03976285f, -0.04408403f, -0.04498456f, 
    -0.02804202f, -0.05093683f, -0.03833792f, -0.01075284f, 0.00411086f, -0.00822080f, -0.06207693f, -0.00605487f, 
    -0.02612516f, 0.02239708f, -0.02337557f, 0.01025278f, -0.04365582f, 0.00072363f, 0.00512760f, 0.03103052f, 
    -0.04416459f, -0.00594783f, 0.03269160f, 0.00905669f, -0.02887092f, -0.02055420f, -0.05453089f, -0.05105276f, 
    -0.05941454f, 0.01252026f, 0.02799956f, 0.03811168f, -0.03387775f, -0.00121296f, -0.02441162f, -0.05643870f, 
    0.04917577f, -0.05725762f, 0.01001402f, -0.03065275f, 0.04595583f, -0.01308742f, -0.06272024f, -0.03632713f, 
    -0.04557091f, -0.06083309f, -0.03878611f, -0.06607360f, 0.02556326f, -0.02561864f, 0.04638168f, 0.00968220f, 
    0.04744794f, -0.04771428f, -0.05157192f, -0.06063446f, -0.06071489f, 0.00792745f, -0.01449524f, -0.04823682f, 
    -0.05608937f, -0.00452456f, -0.03151573f, -0.05034532f, 0.03936012f, 0.00373658f, -0.03032255f, -0.01384419f, 
    -0.02029631f, 0.02133946f, -0.00933239f, -0.02572529f, -0.02089027f, -0.05811959f, 0.02885225f, 0.01935690f, 
    -0.00472121f, -0.05507470f, -0.02387510f, -0.04928261f, -0.04911521f, -0.06132757f, 0.02723731f, -0.05184804f, 
    -0.02327903f, -0.02401758f, 0.02987702f, 0.00587878f, -0.04652074f, -0.02059102f, 0.01586755f, -0.06572852f, 
    0.01241455f, 0.00691375f, 0.00231359f, -0.00207595f, -0.05427186f, 0.00212441f, 0.04023212f, -0.05385472f, 
    0.02258316f, -0.04252847f, -0.02075903f, -0.02863781f, -0.04865016f, 0.03298809f, -0.02596164f, -0.03393783f, 
    -0.01852659f, 0.00790318f, 0.02260056f, 0.01857428f, -0.00066909f, 0.02015246f, -0.05343488f, -0.04079634f, 
    -0.04925932f, -0.00291773f, -0.00331203f, 0.01837012f, -0.02630709f, 0.03075988f, -0.00164835f, 0.04015169f, 
    -0.00567398f, 0.04050317f, 0.05142463f, 0.00280397f, 0.02955554f, 0.04606853f, -0.05547242f, 0.00600559f, 
    -0.00276951f, 0.05278900f, 0.04184128f, 0.04454571f, -0.05504276f, -0.02107565f, 0.00519272f, -0.06531039f, 
    -0.06580172f, 0.03337996f, 0.00005664f, 0.02584617f, -0.06016579f, -0.05232105f, 0.05025304f, 0.04672838f, 
    0.04199859f, 0.01043548f, 0.00543383f, -0.02504264f, -0.01810439f, 0.03504113f, 0.02898758f, 0.02216899f, 
    0.00152496f, 0.04638448f, 0.04690930f, -0.06160915f, 0.01675348f, 0.03607648f, -0.05160893f, -0.00614277f, 
    -0.01891597f, 0.00602540f, 0.02569063f, -0.04639643f, 0.03291032f, -0.03496201f, 0.03112194f, -0.01814048f, 
    0.00119687f, -0.02131601f, -0.00638795f, -0.06014797f, 0.00040186f, 0.00241342f, -0.05274961f, -0.05849615f, 
    -0.03411194f, -0.01245870f, -0.05321816f, -0.00607602f, 0.04944526f, -0.05164224f, 0.04355767f, 0.02764997f, 
    -0.06658407f, -0.03068496f, 0.01127213f, 0.02095228f, 0.02192976f, 0.02902550f, -0.05863680f, 0.01772453f, 
    0.01664361f, 0.01272367f, 0.04968515f, -0.01640501f, -0.05596111f, -0.00924758f, 0.04228241f, -0.02720095f, 
    -0.00983723f, -0.02258763f, -0.03829788f, 0.01263105f, -0.03847765f, 0.00595445f, -0.04093195f, 0.01385898f, 
    -0.01324237f, -0.05311773f, 0.01574355f, -0.05040976f, -0.03299762f, -0.05771535f, -0.00083790f, 0.00510915f, 
    -0.00329194f, 0.04502742f, -0.04669879f, -0.03269443f, 0.01903212f, 0.02630944f, -0.06130979f, -0.05649126f, 
    0.04250462f, -0.06556632f, -0.01258493f, -0.01503243f, 0.02283047f, 0.05054829f, 0.00125625f, 0.03524775f, 
    0.05017190f, 0.03658470f, -0.03541721f, -0.01420390f, -0.04814686f, -0.06325448f, -0.05799240f, 0.02217254f, 
    0.04977178f, -0.04605171f, 0.01487602f, 0.03516617f, -0.02164903f, 0.04434405f, -0.01044046f, -0.05835563f, 
    -0.00415238f, -0.02695478f, 0.01554354f, -0.05047630f, -0.03007280f, -0.02478538f, -0.06490760f, -0.03386758f, 
    0.04778959f, -0.06283111f, -0.06243339f, 0.04139357f, -0.04089919f, -0.03022549f, -0.05123721f, 0.01891483f, 
    -0.01174833f, 0.02271288f, -0.05265118f, -0.00837527f, -0.04054179f, -0.05509848f, -0.01502077f, 0.00060735f, 
    -0.02350476f, -0.03585002f, 0.00864070f, 0.00917148f, 0.01577978f, -0.03771338f, 0.00250095f, 0.00713968f, 
    -0.01304448f, 0.03750895f, 0.00838636f, -0.02005192f, -0.05155509f, -0.06506115f, -0.00674460f, 0.02347862f, 
    0.01351669f, 0.04589575f, -0.05244066f, -0.02978415f, -0.04403834f, 0.01676423f, 0.02748748f, -0.03721645f, 
    -0.04340672f, -0.01904936f, 0.02366533f, -0.00288382f, -0.02765507f, -0.03180678f, -0.00855028f, -0.06575231f, 
    -0.04592625f, 0.01457607f, -0.00098032f, -0.02141358f, 0.01517862f, -0.00620340f, -0.05618799f, 0.01887433f, 
    -0.06091423f, 0.02063388f, 0.02037372f, 0.02570299f, -0.01354565f, -0.05747614f, -0.01091798f, -0.01818650f, 
    -0.05045047f, 0.02719297f, 0.02681341f, -0.04681746f, -0.05745630f, 0.03122409f, -0.00762320f, -0.01431676f, 
    -0.02142805f, -0.05031284f, -0.01046100f, -0.01137127f, 0.02088614f, -0.03052586f, 0.01250013f, -0.04456563f, 
    0.00298496f, 0.00980282f, 0.04594445f, 0.00020550f, -0.02836612f, 0.02793553f, -0.02436611f, 0.01860128f, 
    -0.06405374f, 0.02260197f, 0.01625003f, 0.03588669f, -0.01548511f, 0.03955143f, 0.03123270f, -0.03256688f, 
    0.01862839f, 0.00538279f, -0.01361451f, -0.00347752f, -0.01131544f, -0.03740648f, -0.00752570f, -0.00426373f, 
    0.04269119f, 0.03782001f, -0.01632546f, 0.02721398f, -0.03350667f, -0.05976147f, -0.03885295f, -0.05948752f, 
    0.01507136f, -0.03854212f, 0.04629251f, 0.02797380f, -0.03091375f, 0.00597618f, 0.04681666f, -0.04251751f, 
    -0.03939161f, 0.02286861f, 0.03087610f, -0.06051691f, 0.01758835f, -0.01997989f, 0.00203089f, 0.01985863f, 
    -0.02280238f, -0.02884056f, -0.08767280f, -0.03753480f, -0.03612302f, -0.04020775f, -0.01529685f, -0.01942336f, 
    0.05178337f, -0.00147727f, 0.01074388f, -0.00402873f, -0.00995389f, 0.00018676f, -0.00113598f, -0.00991315f, 
    0.02932569f, -0.02458126f, -0.02633670f, -0.04239374f, 0.02457766f, -0.03301742f, -0.02681459f, 0.04420944f, 
    0.03425220f, -0.02233073f, 0.04173840f, 0.01788662f, 0.04238680f, 0.00699784f, -0.05373479f, 0.03855041f, 
    -0.01710903f, -0.00427275f, -0.01053622f, -0.01451736f, 0.00375968f, -0.04166481f, -0.05348923f, 0.02666609f, 
    -0.05683633f, -0.05232804f, 0.04943376f, -0.04239723f, 0.00779767f, 0.03648930f, 0.00924542f, -0.01129843f, 
    0.02188534f, -0.04357019f, -0.04592674f, -0.04673059f, -0.00757570f, 0.05661362f, 0.03459093f, -0.06353807f, 
    -0.03118639f, -0.00552495f, 0.04399320f, -0.06518404f, -0.06728762f, -0.04785774f, -0.03767330f, -0.02379578f, 
    -0.01851595f, 0.03822650f, 0.03271349f, -0.06353442f, -0.04799958f, 0.01502258f, -0.02254957f, -0.02147052f, 
    -0.06374621f, -0.01800971f, -0.07398945f, -0.00471460f, 0.03080685f, -0.01537941f, -0.01015739f, 0.00126070f, 
    0.00360933f, -0.05255838f, -0.02760058f, -0.04248957f, 0.04362025f, -0.02565844f, -0.01160636f, -0.06452826f, 
    -0.01306545f, -0.07902653f, -0.05561067f, -0.03097804f, 0.00899310f, -0.04413494f, -0.00343245f, -0.03975589f, 
    -0.01026786f, 0.00731135f, 0.01952730f, -0.04099808f, -0.06298770f, -0.05972019f, -0.01986998f, -0.02407070f, 
    -0.07653898f, -0.01207536f, 0.01047874f, 0.00715719f, -0.03513590f, 0.03312015f, -0.02578318f, -0.05433604f, 
    -0.04319801f, -0.02177808f, -0.06528582f, 0.03092121f, 0.01973550f, -0.02126907f, -0.03066430f, -0.06164463f, 
    0.03905970f, 0.03593701f, 0.01648027f, 0.04364851f, 0.02887045f, -0.02362016f, 0.00091734f, -0.02609181f, 
    0.02130988f, -0.01953406f, 0.00493036f, -0.06233469f, 0.00322569f, 0.00541147f, -0.04644790f, -0.00048683f, 
    0.04806548f, 0.00299711f, 0.00600434f, -0.03644646f, 0.05116223f, -0.00028391f, 0.03299913f, -0.06523483f, 
    -0.07198022f, 0.01104240f, -0.03239179f, 0.01581864f, -0.04147934f, -0.06109871f, 0.05270151f, 0.02560929f, 
    -0.04770901f, 0.03240090f, -0.01008567f, -0.01357849f, -0.04927714f, -0.04766544f, -0.02195347f, -0.00518483f, 
    -0.05333240f, -0.01312863f, 0.02214185f, 0.02701287f, 0.05359651f, 0.03869705f, -0.06039095f, -0.00290820f, 
    -0.06066427f, -0.00108169f, 0.00555722f, -0.02233551f, -0.02278690f, -0.03044313f, 0.01441009f, -0.06241102f, 
    0.01690813f, -0.06545881f, 0.02760572f, -0.06001855f, -0.00685662f, 0.03772547f, 0.03219694f, 0.04966606f, 
    0.01844026f, -0.04601118f, 0.03549657f, -0.03452364f, -0.07978512f, 0.00173504f, -0.07615463f, -0.03314973f, 
    0.04560799f, -0.05367447f, 0.02889546f, -0.01699732f, 0.03536929f, 0.03384786f, -0.01218389f, 0.03769787f, 
    0.03178095f, -0.01199894f, -0.01931592f, -0.03460192f, 0.04869839f, 0.03925967f, -0.04145550f, -0.06423453f, 
    0.01116364f, -0.03170953f, -0.04167761f, -0.03784819f, 0.02420108f, -0.03237908f, -0.06583913f, -0.01871003f, 
    -0.01817232f, -0.05565371f, -0.04997282f, 0.03066855f, -0.06696055f, -0.01938702f, -0.02710818f, 0.01688583f, 
    -0.02822409f, 0.03526744f, -0.04536541f, 0.04296366f, 0.00959160f, 0.00315404f, -0.05379087f, -0.01973064f, 
    -0.05819635f, -0.01390120f, 0.04011621f, -0.01356314f, 0.00343002f, 0.05180302f, 0.02882989f, -0.01642305f, 
    -0.04314544f, -0.02445451f, 0.00972651f, 0.05498065f, 0.01344247f, 0.03795883f, 0.05167734f, -0.02200750f, 
    -0.02053150f, -0.02499466f, -0.03642534f, 0.03990953f, 0.01934326f, 0.02071073f, -0.01042679f, -0.06599471f, 
    -0.01317646f, 0.01812977f, -0.05453254f, 0.00680148f, 0.00679062f, 0.00240619f, -0.04477859f, -0.03817677f, 
    0.02933442f, -0.05863856f, -0.01847716f, 0.04998454f, 0.00455931f, -0.02222303f, -0.00974934f, 0.01362846f, 
    0.04433604f, 0.02000102f, -0.00581438f, -0.02873183f, -0.00032229f, -0.01192491f, -0.02024093f, -0.09263987f, 
    0.02516736f, -0.03151991f, -0.07109755f, 0.00781494f, -0.05380328f, -0.02156814f, 0.03593789f, 0.01474650f, 
    0.15281169f, 0.02483341f, 0.17146260f, -0.03490550f, -0.06558056f, 0.04353024f, -0.18538597f, 0.04173530f, 
    -0.11749477f, 0.08699720f, 0.11273313f, 0.02648952f, 0.01756660f, 0.00716197f, -0.03832672f, -0.19856511f, 
    0.08360756f, 0.11795825f, -0.08231115f, 0.16837189f, -0.40238672f, -0.04646427f, -0.02402359f, -0.05273633f, 
    -0.17232731f, -0.03349487f, -0.08357313f, -0.22361666f, -0.04449997f, 0.04238559f, 0.07288327f, -0.13398109f, 
    -0.13774432f, 0.07906666f, 0.05504728f, -0.03382904f, -0.29695553f, 0.09933739f, 0.03813531f, -0.18954672f, 
    0.00013618f, -0.16581762f, -0.05566816f, 0.04652952f, 0.02428302f, 0.32213393f, 0.27477011f, 0.08157443f, 
    0.01359881f, 0.07171924f, -0.03398538f, -0.07875969f, -0.17013042f, -0.03462120f, -0.14157709f, -0.02388998f, 
    0.07044507f, -0.03822735f, 0.01854138f, 0.00701778f, 0.11783959f, 0.00309004f, -0.17304836f, -0.00359023f, 
    -0.14201008f, 0.03873176f, 0.08629829f, -0.07496032f, -0.09200905f, 0.03678109f, -0.08808205f, 0.01789566f, 
    0.12333491f, 0.04989850f, 0.05671494f, -0.08991381f, -0.09110194f, -0.02239361f, -0.13898511f, 0.00625859f, 
    -0.22471331f, -0.00125672f, 0.00610971f, 0.03104157f, -0.14349689f, 0.03142568f, -0.05129322f, 0.10786092f, 
    -0.01606972f, 0.10924774f, 0.32067332f, 0.11374097f, 0.28959501f, -0.03257844f, 0.09746281f, -0.02042622f, 
    0.06228632f, 0.16738191f, -0.00374611f, -0.31561235f, 0.12582405f, 0.22031274f, 0.14295499f, 0.04201487f, 
    0.03103814f, 0.07297989f, 0.09807988f, 0.05029226f, 0.02173721f, 0.06959209f, 0.15649439f, -0.06965119f, 
    0.00298472f, 0.00862434f, 0.00238142f, -0.17969081f, 0.04028187f, -0.00208825f, -0.23398444f, 0.09799556f, 
    0.05353076f, -0.04623236f, 0.08064077f, 0.16778162f, 0.00177211f, -0.02390683f, 0.18688914f, -0.25156376f, 
    -0.01364886f, -0.07217169f, 0.00543070f, -0.05669187f, -0.01040698f, -0.05557683f, 0.04966518f, 0.20034881f, 
    0.07142500f, 0.12438083f, 0.03915822f, 0.05412893f, -0.00437600f, -0.05153545f, 0.05658526f, -0.04161211f, 
    0.36938256f, -0.01200495f, 0.26004869f, 0.21168292f, 0.14375152f, -0.05405693f, 0.07370873f, 0.05306093f, 
    0.12543955f, 0.09868881f, -0.20830961f, 0.05269507f, -0.05168021f, -0.10548875f, 0.02284602f, 0.06774940f, 
    -0.00099032f, 0.09884484f, 0.26096866f, -0.19114818f, -0.11750769f, -0.03189432f, -0.00427079f, -0.07575861f, 
    0.06076957f, 0.07369997f, -0.03296547f, 0.03891325f, -0.33870670f, -0.08294566f, -0.08843691f, -0.07063175f, 
    -0.11810367f, 0.03911105f, -0.00711781f, -0.08206678f, -0.03568631f, -0.33147064f, -0.08053204f, -0.08976579f, 
    -0.24072418f, -0.11605940f, -0.01482779f, 0.10287793f, 0.01303123f, 0.10861003f, 0.20463376f, 0.09507611f, 
    -0.16513154f, 0.06206197f, -0.08270337f, 0.07281791f, 0.03952429f, -0.02146533f, -0.15837179f, -0.06929421f, 
    -0.19494531f, 0.03048965f, -0.13297895f, -0.02640619f, -0.06223754f, 0.05332433f, 0.00387403f, 0.12994181f, 
    0.14517331f, 0.05971040f, -0.04974788f, -0.05241224f, 0.06545171f, -0.14767738f, -0.10238422f, 0.11005206f, 
    -0.26568308f, 0.06706867f, -0.15715420f, 0.03263935f, 0.01772914f, 0.06568503f, -0.08804554f, 0.08263229f, 
    -0.00479916f, 0.00010315f, -0.09969035f, -0.01966027f, -0.10641086f, 0.00122810f, -0.06258899f, -0.00244388f, 
    -0.16385208f, 0.11763718f, -0.15822004f, 0.01969375f, -0.00643821f, 0.05199905f, -0.03001321f, 0.01131113f, 
    -0.01247677f, 0.07094012f, -0.01494559f, -0.20796679f, -0.22485137f, -0.00170726f, -0.08878926f, -0.01543636f, 
    0.00837702f, 0.19299076f, 0.01177748f, 0.13571373f, -0.03123603f, 0.21257357f, 0.32772008f, 0.09915470f, 
    -0.06022763f, 0.07371067f, -0.03510133f, -0.02437011f, -0.04621360f, -0.04406618f, 0.32182947f, 0.13109706f, 
    0.18770881f, 0.18081972f, -0.01760191f, -0.15370686f, 0.03495838f, 0.15745635f, 0.17797047f, -0.28143585f, 
    0.15744646f, 0.00941728f, 0.01556455f, -0.15060575f, -0.05487750f, -0.01727589f, -0.15699017f, 0.03307845f, 
    -0.18670230f, -0.05167964f, 0.04691040f, -0.14868149f, -0.10750452f, 0.03502172f, -0.04367025f, -0.12785406f, 
    0.03466403f, -0.05436191f, 0.04355596f, -0.03027800f, 0.04272724f, 0.01191603f, 0.01736041f, -0.01788401f, 
    0.04444776f, -0.02417468f, 0.03915744f, -0.04322984f, -0.04039011f, -0.04985434f, -0.04202144f, -0.04173912f, 
    0.00522264f, 0.00672164f, -0.00376760f, -0.03205257f, 0.04541179f, -0.01240296f, -0.01953852f, -0.05054253f, 
    -0.04833632f, -0.03883213f, -0.04517041f, 0.01217395f, 0.04429194f, 0.00345506f, 0.00669609f, 0.02696915f, 
    0.00412477f, -0.01619009f, 0.05195942f, 0.01486638f, 0.04418759f, 0.02519058f, 0.02330798f, 0.00373846f, 
    0.00638680f, 0.01630481f, 0.03528972f, -0.01930244f, 0.01015386f, -0.04937499f, -0.00985610f, -0.03744312f, 
    0.01305392f, -0.03245570f, -0.05618704f, -0.01685153f, 0.04743848f, -0.02928059f, -0.01085804f, 0.00178845f, 
    0.02812194f, 0.02103773f, 0.04926182f, -0.06056400f, -0.05232680f, 0.04256253f, 0.00578564f, -0.02767824f, 
    -0.00677858f, 0.00378077f, 0.04133500f, -0.01455017f, -0.03742000f, -0.01621837f, -0.01713241f, 0.02584088f, 
    0.04509607f, -0.06066889f, 0.02701626f, -0.02758583f, -0.03254405f, 0.03557062f, -0.00743003f, -0.02588349f, 
    0.02083169f, 0.01949723f, -0.04395815f, -0.01641195f, -0.00582139f, -0.01057537f, -0.03590221f, 0.01268222f, 
    0.01376123f, -0.03994186f, -0.05202661f, -0.05119733f, 0.02050695f, 0.00608612f, -0.03263318f, -0.01958274f, 
    -0.03297819f, -0.01318461f, 0.01774204f, -0.04590159f, 0.02222990f, -0.04643931f, -0.05455326f, -0.01297603f, 
    -0.03696305f, 0.01007576f, -0.02864951f, 0.00091146f, 0.03869314f, -0.02659664f, 0.01904110f, -0.00283598f, 
    -0.00081019f, 0.02447730f, 0.02158094f, 0.03344567f, -0.06987904f, -0.02520811f, -0.05044889f, -0.03260003f, 
    0.00522598f, -0.00861644f, -0.02965160f, -0.04501813f, -0.06096263f, 0.05494743f, -0.02194050f, -0.05953607f, 
    -0.03145449f, -0.06008917f, 0.03287253f, 0.04721596f, 0.03957881f, -0.05322479f, -0.02779984f, 0.00720660f, 
    -0.02412667f, -0.01761512f, -0.00227708f, 0.02037328f, -0.01888241f, -0.00781270f, 0.02662146f, -0.03072411f, 
    -0.06203146f, -0.01325844f, -0.02901014f, -0.03114025f, -0.02621626f, -0.03282382f, 0.01678434f, 0.01701396f, 
    -0.00795911f, 0.02678688f, -0.02235488f, -0.05279195f, 0.05869028f, -0.05360791f, -0.00198112f, -0.00455959f, 
    -0.00372122f, -0.03710579f, 0.04453427f, -0.01757964f, -0.00036603f, -0.01962470f, -0.01997579f, 0.00187959f, 
    0.05313961f, -0.00523954f, -0.06876795f, 0.03581475f, 0.03613484f, 0.00017624f, -0.05021192f, -0.03855654f, 
    0.02151793f, -0.00192634f, 0.03384894f, 0.00643453f, 0.05570387f, -0.02397770f, -0.04546656f, -0.00226483f, 
    0.03163445f, -0.02675591f, -0.05921586f, 0.00494564f, 0.03840610f, -0.01555080f, 0.02642497f, 0.05773970f, 
    -0.06160434f, 0.03807554f, -0.03661767f, 0.04785177f, -0.05835752f, -0.06437226f, -0.01566975f, 0.04328331f, 
    -0.03892796f, -0.04728004f, -0.02096003f, -0.01611993f, -0.03458670f, -0.00342205f, 0.00635511f, -0.04210057f, 
    0.04395488f, -0.04556029f, 0.03686422f, 0.01140903f, -0.03069732f, -0.05368990f, -0.03791685f, -0.04985108f, 
    -0.02472043f, -0.02861569f, 0.01325507f, -0.00659330f, 0.04373156f, 0.04906015f, 0.04045719f, -0.01766462f, 
    0.04609372f, 0.01619823f, 0.02546736f, -0.01768096f, -0.05671275f, -0.05085333f, -0.00479696f, -0.00453872f, 
    -0.06308825f, -0.05100382f, -0.03436766f, -0.02657311f, 0.04124841f, -0.06329926f, -0.00136039f, 0.00479003f, 
    0.02395225f, 0.03555343f, -0.06282794f, -0.01421822f, 0.05490550f, -0.04028803f, 0.04498136f, -0.00914533f, 
    -0.00473388f, -0.03250700f, 0.01069559f, -0.04879747f, 0.04231536f, -0.03604014f, -0.02648864f, 0.01037514f, 
    0.01578348f, -0.05421102f, 0.00097109f, 0.03453005f, -0.00276467f, -0.03004553f, -0.06697046f, 0.00835828f, 
    -0.02093735f, -0.04442791f, -0.03279894f, 0.04359369f, -0.03873580f, -0.05667476f, 0.05051961f, -0.06560893f, 
    0.01132046f, -0.02927850f, 0.00883337f, -0.04021924f, 0.04265932f, -0.02805588f, 0.00515449f, -0.05208664f, 
    -0.01549300f, 0.01155115f, 0.02065542f, 0.02505483f, -0.05463034f, 0.05303568f, 0.00354950f, -0.04539051f, 
    0.04957273f, -0.04375608f, -0.02571692f, 0.02673178f, 0.01655140f, 0.00545463f, 0.00651226f, -0.05402165f, 
    -0.05009905f, 0.03046978f, -0.03092429f, -0.00603767f, 0.00465335f, 0.01960949f, 0.03627857f, -0.04169139f, 
    -0.03274759f, -0.03316133f, -0.03439502f, 0.03876013f, -0.05443602f, -0.02323496f, 0.03955124f, 0.02421725f, 
    0.04467986f, -0.04820133f, -0.03599530f, 0.02762413f, 0.02991413f, -0.01178465f, -0.03284118f, -0.02445502f, 
    -0.02909143f, 0.00625338f, 0.03500589f, -0.01783305f, -0.03661505f, -0.02116449f, -0.00922460f, -0.05415839f, 
    0.04517996f, 0.04838990f, -0.03568112f, -0.06459417f, 0.00305861f, -0.00825615f, -0.02742990f, -0.06848865f, 
    -0.03895821f, -0.03918104f, 0.00397877f, -0.02854415f, -0.04542882f, -0.05281433f, -0.01170539f, 0.01814419f, 
    0.03190867f, 0.02864706f, -0.05587158f, 0.02948070f, -0.00350221f, -0.03870342f, 0.01599018f, -0.03843859f, 
    0.02515350f, 0.01629064f, 0.01719128f, -0.03687501f, 0.02906384f, 0.02094960f, -0.01681468f, 0.01678541f, 
    -0.04194885f, -0.02301793f, -0.02330759f, 0.00253890f, -0.05004993f, -0.01302900f, -0.01661940f, -0.00648897f, 
    -0.01286926f, 0.03567110f, -0.02338780f, -0.05146446f, -0.00299755f, 0.04728977f, 0.01673223f, -0.05487336f, 
    0.00540755f, 0.01157865f, -0.00724216f, -0.00074350f, 0.04282257f, -0.01654737f, -0.01847584f, -0.01779062f, 
    -0.05128736f, -0.01849764f, 0.00037230f, 0.02069260f, 0.00309731f, 0.00452399f, 0.01806187f, 0.01551059f, 
    -0.00451350f, 0.00636482f, 0.02130602f, -0.05296147f, -0.03835706f, -0.03285835f, 0.02344608f, -0.00254281f, 
    0.04429113f, 0.01897989f, -0.06286401f, 0.00851715f, 0.04008718f, 0.02389581f, -0.06458509f, -0.06720521f, 
    0.05900303f, -0.00952705f, 0.03942389f, 0.01666004f, -0.00411703f, -0.02936994f, 0.00302663f, -0.05902832f, 
    -0.01871851f, -0.00367331f, -0.01428940f, -0.05966289f, 0.02426084f, 0.04258081f, -0.03680161f, -0.05844930f, 
    0.00563328f, 0.00293987f, 0.00281093f, 0.00622180f, 0.01819382f, -0.06027798f, -0.00002003f, 0.00224310f, 
    -0.05363793f, -0.01834328f, 0.00863718f, -0.04842298f, -0.02803311f, 0.02156938f, 0.01752288f, -0.06543837f, 
    -0.05139014f, 0.03058042f, -0.00449067f, 0.04031911f, 0.04566047f, -0.03587676f, -0.01639118f, -0.02220570f, 
    -0.00574676f, -0.03632878f, -0.05535627f, -0.03196475f, -0.02204731f, 0.03033926f, -0.05943037f, -0.00238374f, 
    -0.01120992f, 0.01939078f, -0.00361659f, 0.01104406f, 0.02978517f, 0.03290092f, -0.00596434f, 0.03712572f, 
    -0.06242662f, -0.01262395f, 0.02364595f, -0.01445594f, 0.05423291f, 0.03844336f, -0.05308074f, -0.03659355f, 
    0.04773239f, -0.05736239f, -0.05148096f, 0.01328287f, -0.00171205f, 0.05063082f, -0.00907936f, -0.04641090f, 
    0.05667400f, 0.02163943f, -0.01334964f, -0.01718244f, 0.02753094f, 0.04004520f, -0.02666926f, -0.05265649f, 
    -0.01810346f, 0.04385605f, -0.05098334f, -0.00323752f, -0.04176344f, 0.00773482f, -0.05674420f, -0.01943504f, 
    -0.05488870f, -0.01594692f, -0.04474735f, -0.06150280f, 0.01499851f, -0.05010528f, -0.00291338f, -0.00202490f, 
    0.04459103f, 0.03467720f, -0.05663646f, -0.04428490f, -0.03969744f, -0.04027817f, -0.02739698f, -0.02548350f, 
    -0.04654735f, -0.04912831f, 0.05000936f, -0.06288256f, 0.00851666f, -0.06724638f, -0.05703839f, 0.01274027f, 
    0.00894476f, 0.01638345f, -0.05366310f, 0.00892672f, -0.01462572f, 0.02656917f, -0.02167241f, 0.02130601f, 
    0.05194150f, -0.03536793f, 0.00176418f, -0.05688078f, 0.04870874f, 0.03849281f, 0.00677153f, -0.03540605f, 
    0.03267995f, -0.02210826f, 0.01215529f, -0.03212264f, -0.01918968f, 0.01835457f, 0.00759055f, 0.00391650f, 
    -0.03128120f, -0.00461110f, -0.02808714f, 0.00797024f, 0.00836658f, 0.04379321f, 0.02806181f, -0.01858892f, 
    0.01275453f, 0.02693449f, -0.06384145f, 0.04297180f, 0.03714611f, 0.02730897f, 0.04962894f, 0.02791837f, 
    -0.03342779f, -0.05651040f, -0.05849805f, 0.01149131f, -0.05147438f, 0.04681921f, -0.03348178f, -0.06587316f, 
    0.02577990f, -0.00619754f, -0.05367247f, -0.04495092f, -0.06089213f, -0.02308337f, 0.04695920f, 0.02916650f, 
    0.02453726f, 0.04581597f, 0.03869192f, -0.00127020f, -0.04715763f, -0.02919162f, -0.05615054f, -0.06134404f, 
    -0.04416950f, -0.02073624f, -0.06344957f, -0.05897589f, 0.00568998f, -0.05003784f, 0.02279602f, -0.04282822f, 
    0.00533394f, -0.01460887f, -0.04516811f, -0.03281711f, -0.00735048f, -0.05411197f, -0.00497275f, 0.04857853f, 
    -0.02013937f, 0.00608833f, -0.03268998f, 0.03498392f, 0.03618066f, -0.04858986f, -0.03206031f, -0.02121213f, 
    -0.03936328f, -0.06202997f, -0.03145562f, 0.01152849f, -0.02898894f, -0.04835239f, -0.04362339f, 0.04602000f, 
    -0.05634412f, 0.04493637f, -0.03858663f, 0.02797103f, -0.05256709f, -0.02741642f, 0.03397678f, -0.03679151f, 
    0.05231456f, -0.00779813f, 0.04237710f, 0.00895515f, 0.04409203f, -0.01948297f, -0.03391840f, -0.06256711f, 
    -0.05445971f, 0.03383925f, -0.02272889f, 0.04873585f, -0.03622694f, -0.05760989f, -0.01530165f, 0.02773109f, 
    -0.00520650f, -0.04088900f, -0.05400785f, 0.00730017f, -0.06211136f, 0.02579742f, -0.00795994f, -0.02126647f, 
    0.00734741f, 0.03952689f, -0.02532500f, -0.06528337f, 0.03423044f, 0.00419015f, -0.05652953f, -0.04409770f, 
    -0.00750327f, -0.03444751f, -0.05498779f, 0.01781283f, 0.02803640f, 0.00156542f, 0.00165979f, 0.00876798f, 
    -0.03246722f, 0.03111130f, -0.04208296f, 0.01668028f, 0.03480742f, -0.02986220f, 0.01849865f, -0.02754979f, 
    0.01603842f, 0.01116262f, 0.02547176f, -0.00260963f, 0.03940599f, -0.02315500f, 0.02975571f, 0.00841740f, 
    0.00062921f, -0.00559398f, 0.00152631f, -0.04129326f, -0.04352913f, -0.01081886f, -0.05686696f, -0.01662114f, 
    -0.05522759f, -0.05346724f, -0.02278039f, 0.04684439f, 0.02996971f, 0.00515840f, -0.02530419f, -0.06550471f, 
    0.01404566f, -0.05286421f, 0.01097667f, 0.00815455f, -0.04524970f, 0.00543304f, 0.04273511f, 0.02375370f, 
    -0.02010420f, -0.06032326f, -0.00668172f, 0.01039026f, -0.00736848f, -0.01646835f, -0.01543591f, 0.02086020f, 
    -0.00916050f, -0.01464906f, 0.01749177f, -0.06472284f, -0.04891140f, 0.02227395f, -0.04052724f, -0.06317278f, 
    0.03412144f, 0.04579365f, -0.05610723f, 0.04438782f, 0.02849117f, 0.00661915f, 0.00535144f, 0.01335160f, 
    0.04536757f, -0.05056366f, -0.03149667f, 0.02349997f, -0.03353083f, -0.03681859f, 0.03012909f, 0.04296852f, 
    -0.01238090f, 0.01005444f, 0.00644619f, 0.04252377f, 0.04608486f, 0.03407923f, -0.02560819f, 0.04609460f, 
    0.00590932f, 0.01381568f, 0.04507210f, 0.02483005f, -0.02817789f, -0.00869365f, -0.02137244f, -0.03835798f, 
    0.04746172f, 0.00873377f, 0.02864018f, 0.00814553f, -0.03838375f, -0.00175872f, -0.06027851f, 0.03771238f, 
    -0.02564303f, -0.05753119f, -0.04421575f, 0.04732824f, -0.01964948f, -0.02583239f, 0.02135798f, -0.05773412f, 
    0.02278274f, 0.03292492f, -0.00886279f, 0.03906630f, -0.04292922f, -0.03671864f, -0.05182176f, -0.06134195f, 
    -0.05526530f, -0.02687810f, -0.00558354f, -0.01469023f, 0.00787187f, 0.02568577f, 0.00322652f, 0.00429065f, 
    0.01858466f, -0.03866449f, 0.01405064f, 0.02572838f, 0.04504445f, -0.04995728f, 0.04783361f, 0.03730506f, 
    -0.05513595f, -0.02302503f, 0.00030128f, -0.01699155f, 0.03051903f, -0.00059277f, -0.02517203f, 0.02116696f, 
    0.01573471f, -0.01703783f, 0.03451647f, -0.01629593f, 0.04520207f, -0.00104680f, 0.04270358f, 0.03548959f, 
    -0.01333959f, -0.04329934f, 0.01305255f, 0.04561115f, -0.01978073f, -0.02073910f, -0.00461364f, -0.01571782f, 
    -0.00936624f, -0.04942952f, 0.00893459f, -0.01009062f, -0.04811933f, -0.04209834f, -0.04192606f, -0.06704672f, 
    0.00354881f, 0.00242396f, -0.03916749f, -0.01153358f, -0.05595027f, -0.03328936f, 0.04716093f, 0.03347335f, 
    -0.01835058f, -0.02496863f, -0.01073179f, -0.02954426f, 0.02194917f, -0.03316620f, 0.04138727f, -0.06536872f, 
    0.02765601f, 0.03186396f, -0.00821530f, -0.03505541f, -0.02919281f, 0.03580174f, 0.04826435f, 0.03620135f, 
    0.02900146f, -0.04957834f, -0.00665661f, 0.00617688f, 0.02294552f, 0.03464690f, -0.01383024f, -0.04724681f, 
    0.03370791f, 0.02940679f, -0.00318219f, 0.03763383f, -0.06547502f, 0.01342841f, -0.06057847f, 0.04990747f, 
    -0.12984589f, -0.18660237f, -0.04216030f, 0.02888368f, 0.17586817f, -0.02427427f, -0.01652207f, -0.04848555f, 
    -0.16259216f, 0.08152192f, 0.18236619f, 0.13800497f, 0.07142914f, -0.11920694f, -0.11429869f, 0.00568154f, 
    0.01260285f, 0.17207426f, 0.13351651f, 0.10944584f, 0.17019159f, -0.07639331f, -0.05265227f, 0.09838947f, 
    -0.00637426f, -0.05013232f, 0.10304702f, 0.03629419f, -0.08144681f, 0.01881883f, 0.03315262f, 0.04652056f, 
    0.09460597f, -0.11185481f, 0.00825704f, 0.03988891f, 0.27557287f, -0.10299423f, 0.28146768f, 0.08834432f, 
    -0.06381192f, 0.06375498f, -0.17790647f, -0.13230427f, 0.19252744f, 0.00943494f, -0.08023489f, 0.03393906f, 
    0.04462058f, 0.09475160f, -0.15540205f, 0.07366384f, 0.14416429f, -0.21517077f, -0.28851295f, -0.39847869f, 
    0.23804358f, -0.03335608f, -0.06141049f, -0.13095118f, -0.02022832f, 0.03445352f, 0.01343419f, -0.04796201f, 
    -0.07732379f, -0.01314462f, -0.05703949f, 0.01236430f, -0.04104767f, -0.02392500f, 0.00082303f, 0.06402576f, 
    -0.15879989f, -0.19724081f, 0.02322492f, 0.05866921f, 0.07100984f, -0.03913116f, -0.10994123f, -0.07200331f, 
    -0.02823454f, -0.01150708f, -0.02033393f, -0.06342244f, 0.04829034f, -0.03375503f, -0.14636789f, 0.06808078f, 
    -0.14087912f, -0.00602055f, -0.11746548f, -0.04107994f, 0.24765310f, 0.10566308f, 0.15456429f, -0.07572814f, 
    -0.11878890f, 0.19421583f, 0.05471792f, 0.04272160f, 0.15040065f, -0.27367020f, 0.26826224f, 0.02169494f, 
    0.00700906f, 0.00835135f, 0.05109338f, -0.04269231f, -0.09119337f, -0.07336180f, -0.09748855f, -0.19616219f, 
    -0.00094867f, 0.17067802f, -0.01803917f, -0.04856519f, -0.19858982f, 0.08954095f, 0.02976567f, 0.08340986f, 
    -0.11026599f, 0.09765506f, -0.04515995f, 0.02756275f, 0.15083948f, -0.02238289f, 0.23294134f, -0.28877938f, 
    -0.03776285f, -0.18185365f, 0.22678086f, -0.15472804f, 0.08444186f, -0.18365879f, -0.02075762f, 0.03181469f, 
    0.18428069f, -0.12295438f, 0.01868550f, 0.07789551f, 0.05213931f, 0.04357726f, 0.08504440f, -0.22494645f, 
    0.34136888f, 0.17367247f, -0.41895619f, 0.07456911f, 0.22479740f, 0.15582193f, 0.04967142f, -0.06209964f, 
    -0.25634387f, 0.02616418f, 0.01615397f, -0.08216352f, 0.00679789f, 0.22156973f, 0.07843604f, -0.10948163f, 
    0.14221638f, -0.13118200f, -0.25897995f, -0.02145001f, 0.04644094f, -0.20376354f, -0.00288657f, 0.15986502f, 
    -0.04069938f, 0.10930777f, -0.09026328f, -0.18551829f, 0.05979582f, 0.12672861f, -0.07678119f, 0.10876983f, 
    -0.04151263f, 0.15758887f, 0.04176473f, -0.01719917f, -0.21825156f, -0.01248212f, -0.27409920f, -0.04540043f, 
    0.02378687f, 0.05135112f, 0.20522861f, 0.04867341f, 0.13037406f, -0.37888470f, -0.19261076f, 0.29245424f, 
    -0.07639783f, 0.11869691f, -0.06135380f, 0.05020718f, -0.06602057f, -0.02324069f, 0.07863928f, 0.10527461f, 
    0.08342326f, -0.08255954f, -0.05048970f, 0.19183664f, -0.22040088f, 0.24572493f, 0.17585866f, -0.00137058f, 
    0.12764753f, 0.10635728f, -0.06733821f, -0.15550432f, -0.06103210f, 0.07044297f, 0.15559453f, 0.16070151f, 
    0.02615851f, -0.10863768f, -0.01473675f, 0.04060981f, -0.04832942f, -0.06120335f, 0.01115321f, -0.06464634f, 
    -0.11846178f, 0.07540288f, 0.04972193f, -0.10236990f, 0.05532490f, 0.02340521f, 0.03413476f, 0.01954425f, 
    -0.00651734f, -0.07406851f, 0.03830181f, 0.16992773f, 0.16686247f, -0.20248219f, -0.10089309f, 0.08966017f, 
    0.01221882f, 0.16285349f, -0.01578184f, -0.07476639f, 0.03531579f, 0.02832354f, -0.16432425f, 0.10522470f, 
    0.05080489f, -0.05124313f, 0.19267429f, 0.02951956f, -0.04460311f, -0.27103758f, -0.31585473f, -0.02294068f, 
    0.18534414f, 0.07419598f, -0.02429774f, 0.06990453f, -0.23006716f, 0.45130053f, 0.18692103f, -0.01197593f, 
    0.16319638f, 0.12059534f, -0.01586664f, -0.00918631f, -0.02530123f, -0.01784432f, 0.08206206f, -0.05124763f, 
    -0.41463682f, -0.16795380f, -0.06248864f, -0.02645258f, -0.07714996f, -0.03714444f, -0.12728919f, -0.34531179f, 
    -0.00101940f, -0.01831808f, 0.06796963f, 0.00849638f, -0.01343466f, 0.02743861f, 0.02185467f, -0.08285456f, 
    -0.00671494f, 0.00130312f, -0.04112125f, -0.02057322f, -0.03883040f, -0.00156930f, -0.06438993f, 0.04213640f, 
    0.02617978f, -0.00155131f, -0.05361379f, -0.02967922f, -0.04450709f, 0.00133615f, 0.00352584f, -0.02517500f, 
    -0.01191111f, -0.05955671f, -0.01475960f, -0.06337413f, 0.04684982f, -0.03365650f, -0.05897002f, -0.00620884f, 
    -0.05082504f, -0.00421827f, 0.03242669f, -0.06330396f, -0.05896364f, 0.01810029f, -0.01294910f, 0.00926160f, 
    0.03360851f, -0.03317738f, -0.03875702f, -0.03798164f, 0.01567334f, -0.01778125f, -0.06635404f, 0.04740455f, 
    0.02986550f, 0.03115610f, -0.02903740f, -0.00786323f, 0.03570962f, 0.00349084f, 0.04655957f, 0.04039659f, 
    0.01816647f, -0.04814351f, -0.02926216f, 0.00287062f, -0.04674920f, -0.02799279f, 0.01395545f, -0.02832796f, 
    0.01170188f, -0.01592885f, 0.00654022f, -0.01655853f, -0.03608965f, 0.02428669f, 0.01465203f, -0.02619710f, 
    0.01657318f, -0.05446811f, 0.04192380f, -0.00739826f, -0.02821514f, 0.01071079f, 0.01378619f, -0.02114591f, 
    0.02723030f, 0.04279523f, -0.00081170f, -0.01250050f, -0.04798536f, 0.04374099f, -0.00928421f, 0.03601661f, 
    -0.01159042f, -0.02427112f, -0.00054696f, -0.00075923f, -0.02082207f, 0.02947486f, -0.01229767f, 0.03354603f, 
    -0.00363837f, 0.01790422f, -0.06148291f, -0.05371232f, -0.04228493f, 0.03921378f, 0.04317900f, -0.05417834f, 
    -0.06268029f, 0.03171427f, 0.03014615f, 0.04809730f, 0.04761517f, 0.04673439f, -0.05265388f, 0.00100305f, 
    -0.00664485f, -0.05323324f, 0.01823709f, -0.00687973f, 0.02963189f, 0.03407643f, 0.02022195f, -0.01791223f, 
    0.03655643f, 0.00563080f, 0.04723463f, -0.00092004f, -0.06259008f, 0.01736371f, -0.03567477f, -0.05845294f, 
    -0.03597703f, 0.00988255f, -0.04651333f, 0.04889546f, -0.01795396f, -0.04461058f, 0.01104988f, 0.03194457f, 
    -0.05789409f, -0.01230004f, -0.02257265f, 0.02041034f, -0.06580124f, -0.05340970f, 0.04968993f, -0.05908735f, 
    -0.02579415f, -0.03890449f, 0.03856583f, -0.01029784f, -0.06057074f, 0.05097281f, 0.03000662f, -0.04392540f, 
    -0.02860432f, 0.01656290f, -0.04867478f, 0.00562020f, 0.04920315f, 0.02179815f, 0.03760611f, 0.00801181f, 
    -0.00552902f, 0.01050525f, -0.01401299f, -0.03638031f, -0.04465932f, 0.02191292f, -0.06755088f, -0.01026389f, 
    0.05205003f, 0.01520989f, 0.04582751f, 0.02500885f, 0.03666252f, 0.01057057f, 0.03083859f, 0.03357549f, 
    -0.02317199f, 0.00334057f, -0.02415592f, -0.04925666f, -0.03228725f, -0.04002339f, 0.04234508f, 0.01626538f, 
    0.02542390f, -0.04231865f, -0.01526100f, -0.06079511f, 0.04421548f, -0.05990882f, 0.00267438f, -0.04819167f, 
    -0.03384786f, -0.05768381f, -0.03267815f, 0.00452655f, -0.03575862f, -0.01716834f, -0.02806866f, -0.04593615f, 
    -0.03246661f, -0.02557741f, -0.03702202f, 0.01774547f, -0.03020033f, 0.00869522f, 0.04106125f, -0.04739765f, 
    -0.04058778f, -0.02130116f, -0.04945663f, -0.03255630f, -0.02734413f, -0.02172348f, -0.03822405f, -0.05514965f, 
    0.02425336f, 0.00262398f, -0.04067916f, 0.03850394f, -0.06595231f, -0.00134177f, 0.01210024f, -0.03181307f, 
    -0.03251043f, -0.06002423f, -0.00954637f, -0.06274112f, -0.05577779f, 0.03512668f, 0.01261754f, -0.02996667f, 
    -0.01668464f, 0.02283465f, 0.02903801f, -0.02338492f, 0.00222483f, 0.01924330f, 0.00879405f, -0.03179083f, 
    -0.02777500f, -0.04817307f, -0.06132248f, 0.02984155f, -0.01214001f, -0.05746349f, 0.03357673f, 0.00091596f, 
    0.03067733f, -0.05099395f, 0.04800708f, 0.04542483f, -0.01512791f, -0.01411442f, -0.03044055f, 0.00638287f, 
    -0.00427137f, 0.03366330f, -0.01681691f, 0.04699275f, -0.03200686f, 0.01558145f, -0.05711365f, -0.01022845f, 
    -0.07007645f, -0.05084573f, 0.04203556f, 0.03755121f, 0.02409452f, 0.00354186f, 0.02455321f, 0.03268755f, 
    0.01406494f, -0.02688102f, 0.02217788f, 0.02087841f, -0.03192638f, -0.03497016f, 0.03615462f, -0.01468691f, 
    0.02888506f, 0.03819026f, -0.02639429f, 0.00773292f, 0.00059108f, 0.02354120f, -0.00018360f, -0.05840557f, 
    0.01480273f, -0.01971476f, 0.00049622f, 0.04941792f, -0.01194696f, 0.03760809f, -0.04925076f, -0.01218952f, 
    -0.15432119f, -0.12166221f, 0.06405600f, -0.09140559f, 0.16663110f, 0.02418371f, 0.01533737f, -0.04474575f, 
    -0.02127244f, 0.02799509f, 0.16452947f, 0.09851014f, -0.37691730f, -0.08560041f, -0.00976976f, 0.08597783f, 
    -0.03919560f, -0.17521985f, -0.20153159f, -0.09774391f, -0.23872629f, 0.18503799f, -0.02184013f, 0.01237574f, 
    0.03316685f, 0.19689396f, 0.08731100f, -0.13585046f, 0.03084466f, 0.08123730f, -0.04839323f, 0.17562081f, 
    0.01668348f, 0.08922976f, 0.02989401f, 0.18363361f, -0.21085769f, -0.02055432f, 0.19230396f, -0.27688468f, 
    0.12876655f, 0.02745853f, -0.09636970f, 0.17792180f, 0.04553138f, 0.07520819f, -0.06862790f, 0.18632904f, 
    -0.11469563f, -0.12856834f, 0.03135229f, 0.00634099f, 0.19960266f, 0.12942787f, -0.35627130f, -0.02102684f, 
    -0.01462376f, -0.14986934f, 0.05396237f, 0.03024139f, -0.00494728f, 0.05282953f, 0.01034363f, -0.07893695f, 
    -0.04953474f, -0.08997330f, 0.07709131f, 0.05628388f, -0.14523005f, 0.09183519f, 0.04945788f, -0.03100214f, 
    -0.05072996f, -0.14384776f, 0.10144813f, -0.05770054f, 0.16107206f, -0.02421492f, -0.01533506f, -0.08105344f, 
    0.14787003f, 0.22010852f, 0.19809656f, -0.03571654f, 0.07739831f, -0.05676730f, 0.14741743f, -0.09436737f, 
    -0.29187211f, -0.06140053f, -0.42129770f, -0.09423850f, -0.00725129f, -0.10669850f, 0.24676386f, -0.08442994f, 
    -0.00638592f, -0.05873515f, -0.03456983f, 0.01420483f, 0.06537416f, -0.12212864f, -0.08056444f, 0.00298352f, 
    -0.02977361f, -0.04293297f, 0.02370918f, 0.10480765f, -0.27394599f, -0.08666690f, 0.02436470f, 0.04895869f, 
    0.12894140f, 0.11684022f, -0.02996425f, 0.08355684f, -0.02899250f, 0.08841517f, -0.02156406f, -0.14581822f, 
    -0.09164593f, 0.20860089f, 0.12601040f, 0.20786576f, -0.02518895f, -0.13667512f, 0.15915191f, -0.10058212f, 
    -0.07917883f, -0.15293784f, 0.10867624f, -0.24222852f, -0.03389493f, 0.06748126f, -0.07545518f, 0.12894836f, 
    0.13504474f, -0.29162928f, 0.10627138f, -0.01819485f, -0.06509154f, -0.01792279f, -0.01949301f, 0.12276617f, 
    -0.18171456f, 0.23268445f, -0.29278105f, -0.12987785f, 0.14101461f, -0.09513862f, -0.14394675f, -0.01123814f, 
    0.01323443f, 0.07075261f, -0.02143539f, -0.07764161f, 0.06041794f, 0.05290626f, -0.08591080f, 0.07541953f, 
    -0.22479373f, 0.10532509f, 0.02204056f, -0.14814496f, 0.19736974f, 0.03891132f, 0.09650581f, 0.06722587f, 
    0.10696451f, 0.05629325f, 0.05997904f, 0.01994545f, 0.01694592f, 0.08384366f, 0.13932541f, 0.16942006f, 
    0.07836623f, 0.10749918f, 0.04280396f, -0.03757834f, -0.10070872f, -0.02885018f, -0.00697772f, -0.20787340f, 
    0.03993209f, -0.02602879f, 0.16599426f, 0.02968795f, -0.17958269f, 0.19898312f, 0.16633704f, 0.02414301f, 
    -0.08186539f, 0.01498995f, 0.02015723f, 0.06670479f, 0.11597892f, -0.00281145f, -0.07199172f, 0.20538013f, 
    0.00001177f, -0.13683695f, -0.01057814f, -0.09743770f, 0.17024675f, 0.05583916f, 0.08262348f, 0.03159152f, 
    0.09634027f, 0.01166191f, -0.18257387f, 0.00072562f, 0.12535906f, 0.16637008f, 0.03797913f, 0.08043655f, 
    0.66708046f, -0.12341058f, 0.17386249f, -0.23839667f, 0.04844086f, -0.12228223f, 0.18860559f, 0.10917365f, 
    0.08051829f, 0.24265003f, 0.20626329f, -0.12727943f, 0.02649301f, 0.08101286f, -0.00112078f, -0.00220821f, 
    -0.10973910f, -0.03025988f, -0.04062890f, 0.15358926f, -0.19605339f, -0.05853343f, -0.05300541f, -0.00321616f, 
    -0.02168782f, -0.00895766f, 0.04172118f, -0.00723109f, -0.05106886f, -0.14985357f, -0.19112772f, 0.06311727f, 
    0.09683204f, 0.18319310f, -0.11053108f, 0.01155671f, -0.03770584f, 0.33598721f, 0.04227475f, 0.20005403f, 
    -0.07561889f, 0.12530516f, -0.05389275f, -0.08550514f, -0.09545851f, 0.62533849f, 0.21875630f, 0.07192957f, 
    -0.19241945f, -0.06829402f, 0.10698017f, 0.09641328f, -0.08061378f, -0.01943588f, -0.25674689f, -0.03403185f, 
    0.06517317f, 0.01158237f, -0.07884445f, -0.06902164f, -0.03146467f, 0.12061838f, -0.01287903f, -0.25308484f, 
    0.08217612f, -0.26270705f, -0.04308851f, 0.13669896f, 0.06026958f, -0.02014512f, 0.11323640f, -0.10052203f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.08241980f, 0.05643507f, 0.00137949f, -0.04902229f, 0.05630728f, -0.07489939f, 0.10917601f, -0.05828055f, 
    -0.04039145f, -0.02965629f, 0.12099655f, -0.00642907f, 0.08680772f, 0.10846648f, 0.00621183f, 0.04277308f, 
    0.07796550f, -0.07530582f, 0.14801456f, 0.03628402f, 0.03245282f, 0.09402431f, 0.03803282f, -0.02831316f, 
    -0.02893218f, -0.11255668f, 0.00696788f, 0.02075219f, -0.02018467f, 0.01270470f, 0.04164371f, 0.13245565f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03824764f, -0.19734621f, 0.13967890f, 0.00268446f, 0.06252043f, -0.08766521f, 0.02491869f, -0.09056953f, 
    0.06856171f, -0.05572166f, 0.26201931f, 0.20740427f, 0.26825038f, -0.14775787f, -0.38661292f, -0.06498568f, 
    -0.00522313f, -0.35251448f, 0.21699904f, 0.30099145f, 0.54562509f, -0.22393665f, -0.00000854f, -0.03306885f, 
    -0.08941051f, 0.28134054f, 0.00120445f, -0.09540800f, -0.14907598f, 0.32844749f, 0.02237206f, -0.06770785f, 
    0.61197001f, 0.14519350f, 0.07103121f, 0.07551759f, -0.02163023f, -0.03408045f, -0.03947453f, -0.10350946f, 
    0.03622158f, 0.03746117f, 0.06597064f, -0.01559572f, -0.10842554f, -0.07991638f, -0.18683642f, -0.01594052f, 
    -0.05990595f, -0.27277082f, 0.30148897f, 0.59752786f, -0.01557027f, -0.33786538f, 0.12520024f, 0.11896554f, 
    0.02008890f, 0.18611869f, 0.13226822f, -0.10209203f, -0.09863246f, 0.04094721f, -0.11273713f, 0.29775175f, 
    0.30074421f, -0.20501357f, -0.07956691f, -0.09168104f, 0.34642497f, -0.26776648f, 0.21404496f, 0.09124413f, 
    0.13147871f, -0.03493761f, 0.06162607f, 0.41107306f, 0.05663234f, 0.17256078f, -0.20749909f, 0.12931481f, 
    -0.40503001f, -0.22337511f, 0.41065651f, -0.18345888f, -0.23198381f, -0.01179829f, 0.16439727f, -0.12925449f, 
    0.07398085f, 0.06061388f, -0.18621932f, 0.16364786f, -0.08183306f, 0.24709645f, -0.10309138f, -0.01380330f, 
    0.23399167f, 0.03710736f, 0.13942996f, -0.12569183f, -0.11464958f, -0.01066689f, 0.03810382f, -0.15484402f, 
    0.02026398f, -0.10077697f, 0.27427006f, -0.10231102f, -0.17601702f, 0.04685444f, 0.49713179f, -0.04159500f, 
    0.21836177f, 0.65760738f, -0.00507138f, -0.01647499f, -0.38692379f, 0.14932731f, -0.03428613f, -0.02730911f, 
    -0.15066426f, -0.06182065f, -0.12666765f, 0.16834390f, -0.02447576f, -0.12876236f, 0.14436893f, 0.11712249f, 
    -0.21733555f, -0.29815266f, -0.04646066f, 0.09907874f, -0.14508246f, 0.34061876f, -0.01203185f, 0.04040351f, 
    0.05741295f, 0.07856100f, 0.35989240f, 0.34743488f, 0.17938066f, 0.38317460f, -0.00466495f, -0.03256482f, 
    0.07676712f, 0.27614808f, 0.01404299f, -0.32721409f, -0.18977295f, 0.28197947f, 0.14689642f, -0.16343807f, 
    0.05618213f, 0.37755266f, 0.03169965f, -0.02704722f, -0.11392944f, 0.03952150f, 0.08724034f, -0.19045183f, 
    0.16999261f, 0.34406814f, 0.10639809f, 0.03591828f, -0.41599295f, 0.35673362f, -0.06277507f, -0.10480639f, 
    0.07000376f, 0.12112864f, -0.22906217f, 0.25989214f, -0.09739936f, 0.15144518f, 0.22147740f, -0.13404375f, 
    -0.36628971f, 0.27662668f, 0.10732307f, 0.28335640f, -0.14764011f, -0.13316830f, 0.16095585f, -0.09159214f, 
    0.10527738f, 0.67026395f, -0.06949278f, -0.07670342f, 0.14113541f, -0.20768172f, -0.01799788f, 0.21863398f, 
    0.05134392f, 0.26725101f, -0.14379533f, 0.01739857f, -0.28860939f, 0.25793615f, 0.23472728f, -0.16865644f, 
    -0.07702137f, 0.13135517f, -0.17183891f, 0.14032316f, -0.04792040f, 0.28272516f, -0.07229064f, 0.03638197f, 
    0.20030001f, -0.49394745f, -0.01279189f, 0.19600965f, 0.09848257f, 0.21967939f, -0.08590865f, -0.03726575f, 
    -0.00481447f, 0.01645526f, -0.01255226f, 0.14127977f, -0.10016388f, -0.16017665f, 0.03714148f, -0.00200733f, 
    -0.27944532f, -0.31341273f, -0.11688567f, 0.16612770f, 0.10738187f, 0.05638110f, 0.17589338f, -0.07638355f, 
    -0.03736803f, 0.13688469f, 0.27868038f, 0.22225404f, 0.07828952f, 0.32360688f, -0.22085622f, 0.16576551f, 
    0.23559777f, -0.61495572f, -0.20408113f, -0.10730691f, 0.00053485f, 0.10005321f, 0.03977721f, 0.15468267f, 
    0.03309347f, -0.26927450f, 0.16661705f, 0.00792616f, -0.07790253f, 0.38550007f, 0.11352732f, 0.22864327f, 
    -0.07981969f, 0.05847258f, 0.09243013f, 0.13888134f, -0.31668162f, 0.41031003f, -0.24102592f, -0.07178706f, 
    0.16834646f, -0.04271658f, 0.04642145f, -0.19333744f, 0.40536058f, 0.20190066f, -0.00186703f, 0.11490953f, 
    -0.29807618f, 0.44857275f, 0.15793878f, -0.07654506f, 0.24966399f, 0.11811931f, 0.14361119f, 0.14171670f, 
    0.08995002f, -0.43035811f, 0.13301769f, 0.10797647f, -0.01646942f, 0.07747764f, -0.11027615f, 0.10565087f, 
    -0.15628861f, -0.03034979f, 0.15627544f, -0.05165526f, 0.11308992f, -0.14717576f, -0.13792931f, 0.06921870f, 
    -0.08927999f, 0.13458478f, -0.03628549f, -0.01884772f, 0.06441651f, 0.03112688f, -0.08140091f, -0.06541806f, 
    -0.18385163f, -0.19436017f, -0.10310739f, -0.14222281f, -0.18136208f, 0.11698544f, 0.06505467f, -0.09262268f, 
    -0.14985107f, 0.10973261f, 0.16009544f, -0.10743155f, 0.07680757f, -0.05259122f, -0.04355124f, -0.05130122f, 
    0.06289477f, 0.53200376f, -0.10061079f, 0.10025012f, 0.10875432f, -0.09177164f, 0.11833277f, -0.11963563f, 
    0.04526963f, -0.08715072f, -0.44725916f, -0.11527433f, 0.05804103f, -0.25232387f, 0.12267890f, 0.17600718f, 
    0.24946959f, -0.21982931f, 0.33384424f, 0.03923376f, 0.23213281f, -0.21248852f, 0.10888667f, 0.01899066f, 
    -0.07134457f, -0.31784946f, 0.17853889f, 0.06039731f, 0.14719230f, 0.11455182f, -0.04932544f, 0.09396346f, 
    0.06513090f, -0.29541945f, 0.08638800f, 0.03911352f, 0.23118077f, -0.10173199f, -0.02526900f, 0.04341036f, 
    0.09549160f, 0.05451569f, 0.19006136f, 0.20117766f, -0.00969427f, -0.02494656f, 0.11731163f, 0.09429929f, 
    -0.18786030f, 0.04954828f, -0.13498357f, -0.20493180f, 0.12872246f, 0.26776606f, -0.09991582f, -0.03320888f, 
    0.03569692f, -0.14835182f, 0.15449871f, -0.16179684f, 0.11763392f, -0.07209794f, -0.08237199f, 0.10870050f, 
    0.12182146f, 0.02527878f, 0.11301765f, 0.12662220f, -0.05402531f, 0.29799598f, -0.01984505f, -0.17596014f, 
    0.17538327f, -0.12279779f, 0.28708357f, 0.17733660f, -0.12342918f, -0.11850148f, -0.34486455f, -0.12813494f, 
    0.00810684f, 0.33000988f, -0.29169032f, 0.34501386f, 0.07923421f, -0.16245499f, 0.03449190f, 0.04794495f, 
    -0.14545570f, 0.67491120f, -0.04924842f, 0.05185525f, -0.15324152f, -0.28862831f, 0.09027258f, -0.08961928f, 
    0.07561889f, -0.07168154f, -0.12197430f, -0.07310959f, -0.12986150f, 0.24530807f, -0.17367728f, 0.02182527f, 
    -0.11483230f, 0.14355910f, -0.23188981f, 0.21372440f, 0.18980671f, -0.06434805f, -0.13470162f, 0.15063281f, 
    -0.39783594f, -0.29111245f, 0.32909015f, 0.14390434f, 0.28601986f, 0.27858892f, -0.00280873f, -0.11550148f, 
    -0.08758715f, 0.15288873f, 0.02289876f, -0.11369263f, -0.06923766f, 0.04062900f, -0.09737562f, 0.11747429f, 
    -0.17384197f, -0.09811437f, 0.16335064f, -0.06823824f, 0.50128067f, 0.23506001f, 0.12580477f, -0.05265468f, 
    0.12429268f, 0.08712450f, -0.15909180f, -0.09594555f, 0.20851408f, -0.01452440f, 0.44049987f, 0.14841104f, 
    0.10959349f, 0.18430153f, 0.05337932f, -0.32679999f, 0.12098508f, 0.61420399f, -0.16572163f, 0.04691920f, 
    0.09090459f, -0.69812918f, 0.00430109f, 0.13701946f, 0.14055060f, -0.22061270f, 0.04400869f, -0.14070173f, 
    -0.02927400f, -0.18655831f, 0.11233872f, -0.15765455f, 0.43592986f, -0.01381580f, 0.10914262f, -0.17892472f, 
    -0.13118273f, 0.16875301f, -0.00807425f, 0.08988578f, 0.12113208f, -0.41680521f, -0.22850242f, -0.02452865f, 
    0.31897467f, 0.08669592f, 0.27490363f, -0.23288004f, 0.36331812f, -0.24372682f, 0.11304265f, 0.15604421f, 
    -0.10099571f, 0.14947048f, 0.10350170f, -0.08089880f, -0.07292843f, 0.29609582f, -0.15563686f, -0.19910070f, 
    0.50182503f, 0.22771659f, -0.01695466f, -0.16498385f, -0.02305144f, -0.33072799f, 0.01981887f, 0.18612210f, 
    0.09493411f, 0.11526152f, 0.09133486f, -0.13342790f, -0.03703123f, -0.21487927f, 0.24214961f, -0.05480584f, 
    0.07889032f, -0.14707516f, -0.03805069f, 0.51724595f, -0.27814996f, 0.12521577f, -0.13412485f, -0.17298543f, 
    0.16137637f, -0.02375546f, -0.00757599f, 0.01086748f, -0.05011449f, 0.09707511f, 0.03883065f, 0.28359979f, 
    0.05161166f, 0.08166592f, -0.06973471f, 0.07100347f, 0.01399243f, -0.02179376f, -0.13916601f, -0.09071472f, 
    -0.05440687f, -0.04705026f, -0.12843622f, 0.14353161f, -0.07179242f, -0.00729139f, -0.10460294f, -0.08752041f, 
    -0.20788600f, -0.14909065f, -0.17054000f, -0.11626159f, 0.00534433f, -0.03040530f, 0.14844686f, 0.02298152f, 
    0.11163692f, -0.00997908f, 0.16916785f, -0.07604287f, 0.15405667f, -0.05989679f, 0.14719521f, -0.01773053f, 
    -0.01493594f, -0.02205970f, -0.06505474f, 0.14708127f, -0.38027343f, -0.15365687f, -0.23831251f, 0.15220745f, 
    0.10413387f, 0.02084960f, 0.64238828f, 0.26690066f, 0.33823520f, 0.01708615f, -0.20956933f, -0.02684846f, 
    -0.00289303f, 0.30495760f, -0.00730135f, 0.06469095f, -0.14404441f, -0.16628069f, 0.12138967f, -0.05384836f, 
    -0.04678285f, 0.71428847f, 0.09883754f, -0.17135260f, 0.08246335f, 0.17482057f, 0.14067638f, 0.11772570f, 
    -0.04994107f, 0.41797763f, -0.08177925f, -0.16704629f, 0.11347558f, -0.14303035f, 0.18652120f, -0.09103835f, 
    0.16072837f, 0.02767181f, -0.42703605f, -0.21639924f, 0.16369754f, -0.44727224f, 0.46523064f, -0.08163164f, 
    0.21990833f, -0.25257772f, -0.04359951f, 0.21911389f, -0.28323045f, -0.05090048f, -0.09555773f, -0.16017210f, 
    -0.07075261f, -0.55133897f, 0.03156385f, 0.16566655f, 0.05472998f, 0.35155416f, -0.15875293f, 0.46305734f, 
    0.04129130f, -0.05340562f, -0.03869439f, -0.16180766f, -0.11686300f, -0.08218025f, -0.17439656f, 0.09096900f, 
    -0.01213309f, -0.05453653f, 0.07416392f, -0.14381236f, 0.08946434f, 0.07069214f, -0.00934558f, -0.07601557f, 
    -0.15650202f, -0.14908782f, -0.16252111f, -0.12643471f, -0.01039046f, -0.12606150f, -0.15891722f, 0.16364494f, 
    -0.12871662f, -0.06950783f, -0.07245976f, -0.14469580f, -0.12047029f, 0.06975674f, -0.10612262f, -0.12891503f, 
    0.02641560f, -0.15912156f, 0.00432130f, -0.15128551f, -0.00186926f, -0.22807561f, 0.04519091f, -0.10121875f, 
    0.06901717f, -0.17346427f, -0.19974464f, 0.03930894f, -0.24471989f, 0.08242034f, 0.03251612f, 0.01801360f, 
    -0.24078731f, -0.03756410f, -0.18856928f, -0.18581164f, -0.18223085f, -0.22190981f, -0.14424841f, -0.01479434f, 
    -0.15716234f, 0.09450095f, -0.11605906f, -0.11034431f, -0.04995750f, -0.14528054f, -0.16637477f, -0.20797659f, 
    -0.08712547f, 0.04673289f, -0.14529496f, 0.14574972f, 0.04503704f, -0.13114452f, -0.02272691f, -0.09809159f, 
    -0.01612791f, -0.12545559f, 0.04317804f, -0.12707719f, -0.19692552f, -0.07026086f, -0.20825060f, 0.05649666f, 
    0.00768559f, -0.04703196f, -0.07087015f, -0.08509761f, 0.07113031f, 0.06294179f, 0.04111766f, -0.08335701f, 
    -0.16058557f, -0.00927036f, -0.05616333f, -0.09463537f, 0.06753962f, -0.04379507f, 0.13551725f, -0.11087535f, 
    0.55321127f, 0.20390403f, 0.02797518f, -0.13100025f, 0.33417144f, -0.31546235f, 0.26884615f, -0.04710778f, 
    -0.01271941f, -0.04624228f, -0.21329641f, 0.01733569f, -0.25310615f, 0.44698063f, 0.15848239f, -0.18346320f, 
    0.00524395f, -0.14500688f, 0.23031029f, 0.03384879f, -0.12309355f, -0.00334363f, -0.10436713f, -0.07189308f, 
    -0.08622289f, -0.02245310f, 0.16583239f, 0.05465600f, -0.04667618f, -0.15073828f, 0.01267899f, -0.00950854f, 
    0.14332797f, -0.10855516f, 0.06120617f, 0.02512890f, 0.36906624f, 0.32409564f, 0.15940650f, -0.03728770f, 
    0.01558591f, -0.01406632f, 0.23866913f, 0.04154564f, 0.02311287f, 0.44295081f, 0.23573364f, -0.12954116f, 
    -0.01857418f, 0.49879584f, 0.07817789f, -0.56028086f, -0.05861427f, 0.06105101f, -0.16171253f, -0.00537154f, 
    0.16241007f, 0.12338521f, 0.14620320f, -0.06188522f, -0.05019676f, 0.03812091f, 0.01230121f, -0.18445809f, 
    -0.00872443f, -0.11879492f, -0.16012017f, 0.04977229f, 0.01723938f, -0.17724003f, -0.08306859f, -0.07397855f, 
    -0.05852076f, -0.12916753f, -0.09303540f, 0.01721717f, 0.07991424f, -0.15758274f, -0.12737677f, -0.15327318f, 
    -0.04775331f, -0.04063309f, 0.04532513f, -0.11729982f, 0.06140154f, 0.14365226f, 0.09342340f, 0.01549383f, 
    0.11698796f, 0.04423909f, 0.03750773f, 0.12669149f, -0.06042674f, -0.10147487f, 0.01853606f, -0.11128101f, 
    0.19675948f, 0.20632800f, -0.12306283f, -0.05540689f, 0.66805619f, -0.03965786f, 0.13800305f, 0.07848751f, 
    0.07264917f, 0.01777518f, -0.10861668f, 0.11032469f, -0.21172115f, -0.40506437f, 0.28003126f, 0.09412460f, 
    -0.04427328f, 0.26904744f, 0.06255226f, -0.16315779f, -0.26912805f, 0.23519486f, 0.12712178f, -0.11957543f, 
    0.16866158f, 0.02461264f, 0.13479073f, 0.09480456f, 0.02785551f, 0.09315271f, -0.18115643f, -0.13662489f, 
    0.25093386f, 0.11455595f, 0.13974465f, -0.12823361f, 0.41905895f, -0.21048950f, 0.06531263f, 0.03804003f, 
    0.14133112f, -0.07702792f, -0.12097090f, -0.16721042f, 0.10897420f, 0.10796223f, -0.04007301f, 0.14513078f, 
    -0.21765731f, 0.67697197f, 0.47909069f, -0.49459839f, 0.05555728f, -0.17252345f, 0.16346098f, -0.02224779f, 
    -0.00016949f, -0.06973881f, 0.13180475f, 0.01526477f, 0.04687276f, -0.09980352f, -0.06577064f, 0.10047924f, 
    0.35516435f, 0.37871265f, 0.05210249f, -0.13012721f, -0.17154615f, 0.19953105f, -0.25527510f, 0.14095922f, 
    0.00799869f, 0.12608512f, -0.27645499f, -0.43297789f, 0.19631922f, 0.03622883f, -0.00237039f, -0.14043827f, 
    -0.05583739f, 0.44413251f, 0.04835951f, 0.02584993f, 0.01209609f, -0.20814580f, -0.08482215f, -0.01492299f, 
    -0.15221007f, 0.29625583f, -0.11294375f, -0.14588094f, 0.01094884f, 0.14093165f, 0.08159344f, 0.38797984f, 
    0.17686276f, 0.19001807f, 0.07648038f, -0.13297996f, -0.23194931f, 0.10188819f, -0.17096429f, -0.01517742f, 
    -0.07197338f, -0.13607886f, 0.07958701f, -0.07364737f, -0.07240874f, 0.24233672f, 0.03677187f, 0.15925497f, 
    0.26597807f, 0.54838610f, -0.14877453f, 0.08984716f, -0.11856181f, 0.36275336f, 0.09313656f, 0.10464185f, 
    0.05943298f, 0.57553315f, -0.07890502f, 0.14466403f, -0.16401459f, -0.24195863f, 0.08021162f, -0.16615056f, 
    0.08083148f, 0.06923576f, 0.08735806f, -0.01876056f, -0.50528580f, 0.18391635f, -0.04355970f, 0.08355020f, 
    -0.12516698f, 0.15906799f, 0.10961304f, 0.01628553f, -0.01886133f, -0.09178758f, 0.00157764f, 0.01395679f, 
    0.21774125f, -0.27169657f, -0.16453440f, 0.52026963f, 0.19547471f, 0.38462514f, 0.05433498f, -0.04439170f, 
    -0.04654897f, 0.32802355f, 0.02310888f, 0.05253708f, -0.09926146f, -0.16637436f, 0.03117333f, 0.12787683f, 
    -0.02125213f, -0.33235317f, 0.12646385f, -0.07002077f, 0.57367736f, -0.03637607f, 0.37986726f, -0.03660594f, 
    -0.17526720f, 0.16595717f, -0.19926834f, 0.12438435f, -0.23168376f, 0.31587720f, 0.03090234f, -0.02519044f, 
    0.35300267f, -0.35065955f, -0.15146244f, -0.40153638f, 0.21708345f, 0.27993581f, 0.03781236f, -0.01623130f, 
    0.15743691f, -0.38077122f, -0.04410937f, -0.11075794f, 0.12036785f, 0.10379370f, -0.03754371f, 0.00750999f, 
    -0.00495873f, 0.23785226f, 0.04127217f, 0.08848382f, -0.07759482f, 0.02900728f, 0.15339646f, 0.12238435f, 
    -0.09358087f, -0.13982068f, -0.31095853f, -0.44722351f, 0.20434810f, -0.14924204f, 0.20024858f, -0.08492264f, 
    0.17785525f, 0.30318198f, 0.25978121f, -0.13952886f, 0.13264272f, -0.38605717f, -0.05463750f, 0.09761274f, 
    0.08780380f, -0.15523975f, 0.11211001f, -0.04925634f, 0.12325897f, 0.13672188f, 0.13270065f, 0.33759606f, 
    -0.31278202f, -0.11391024f, 0.14328814f, 0.17413875f, 0.22125077f, -0.04269604f, -0.35717276f, -0.01204718f, 
    -0.01482315f, -0.06869584f, 0.06978935f, -0.14103329f, 0.35687318f, -0.15161274f, -0.15371390f, 0.06784075f, 
    0.26393706f, -0.29081076f, 0.18888056f, 0.17795724f, 0.50533772f, 0.44512725f, 0.08712273f, 0.05012476f, 
    0.09930764f, -0.01824687f, -0.01260454f, 0.11551391f, 0.16452298f, 0.24273115f, 0.07132027f, 0.07984699f, 
    -0.11396720f, -0.12560722f, -0.00115084f, -0.15663147f, 0.03080825f, 0.05220161f, -0.14262003f, -0.11428405f, 
    -0.04595844f, -0.06446988f, 0.03376968f, -0.13816841f, -0.07497654f, 0.07266416f, -0.00174701f, -0.14550591f, 
    -0.09010509f, -0.07693654f, 0.10255317f, -0.17368604f, -0.13615689f, -0.00931787f, -0.10548888f, 0.10958496f, 
    -0.05163927f, 0.05629202f, -0.03108891f, 0.09538500f, 0.02251457f, -0.01533671f, -0.01692354f, -0.13793798f, 
    -0.20595962f, 0.11032877f, 0.09960292f, 0.15186122f, -0.24722198f, 0.32647416f, 0.19595577f, -0.02758496f, 
    0.15157703f, 0.07307249f, -0.27391693f, -0.19556712f, -0.19096699f, 0.00981263f, 0.21179776f, -0.08963034f, 
    0.48400557f, 0.01939092f, -0.06998224f, 0.33255935f, 0.33319816f, 0.16942075f, -0.15999168f, 0.12952659f, 
    0.01010585f, 0.14724287f, 0.04079825f, 0.12483859f, -0.11873467f, -0.05243527f, -0.04241445f, 0.26663971f, 
    0.32421696f, -0.02925157f, 0.13225685f, -0.07152562f, 0.44511378f, -0.26880190f, -0.02040708f, -0.12011807f, 
    -0.05214486f, 0.03304663f, 0.03727253f, 0.08133730f, 0.33919626f, -0.05939795f, -0.12046158f, -0.04420100f, 
    0.05137173f, -0.01811829f, 0.42137218f, -0.32539681f, 0.13792226f, 0.14656517f, -0.08595107f, 0.08316582f, 
    -0.12542509f, -0.17527755f, -0.02411775f, 0.13014774f, -0.18780494f, 0.12861198f, 0.15861505f, -0.16934864f, 
    -0.09250609f, 0.32077596f, -0.04595752f, 0.04993865f, -0.47606269f, 0.02487681f, -0.00778705f, -0.03428575f, 
    0.04536292f, 0.05497463f, -0.09499454f, 0.03039130f, 0.18550290f, 0.38452703f, 0.35288531f, -0.04908855f, 
    0.14430149f, 0.09381420f, -0.31124681f, 0.08828878f, -0.23734111f, 0.30334672f, -0.11595355f, 0.07028795f, 
    -0.02120493f, 0.16278963f, 0.05063030f, -0.09943145f, -0.11893073f, 0.11226933f, -0.08537365f, 0.32445803f, 
    -0.47820055f, 0.12548947f, 0.11844399f, -0.09677763f, 0.02149562f, -0.38175362f, -0.27944273f, -0.15257342f, 
    -0.03144061f, -0.05185460f, -0.14643914f, 0.32698289f, 0.18838897f, -0.02791115f, 0.08800097f, 0.12899072f, 
    0.19803791f, -0.04404598f, 0.03061775f, -0.03068076f, 0.08195481f, 0.60464984f, -0.16627751f, -0.03961395f, 
    0.03051830f, 0.18099663f, -0.04179995f, 0.07601567f, 0.07978772f, 0.23785818f, 0.12038917f, -0.09689577f, 
    0.23232260f, 0.29733494f, 0.11187794f, -0.07777202f, 0.15455702f, -0.42707166f, 0.43443146f, 0.08190731f, 
    -0.00760880f, 0.17094861f, -0.03080592f, 0.02380530f, 0.01334064f, 0.24478284f, -0.25305763f, -0.15258983f, 
    0.10838402f, 0.24430600f, 0.03572979f, -0.04890461f, -0.12245971f, -0.41084573f, 0.00905532f, 0.03158764f, 
    0.11768547f, -0.12196594f, -0.03943191f, -0.09834497f, -0.12100033f, 0.07811200f, 0.14628035f, 0.15095863f, 
    -0.15061021f, -0.04464108f, -0.08852660f, 0.08377212f, 0.31477770f, -0.07313768f, -0.24629776f, 0.13772602f, 
    0.05699660f, 0.10018168f, 0.09215725f, 0.17669915f, 0.31843963f, -0.11586677f, -0.36019170f, 0.00079039f, 
    -0.02780268f, -0.20060158f, 0.34827662f, -0.00158296f, 0.20392300f, 0.15999155f, 0.07633723f, 0.02648469f, 
    -0.05050439f, 0.39026454f, -0.09559968f, -0.17053454f, 0.16809833f, 0.34609741f, -0.14049990f, -0.08219175f, 
    0.16206627f, 0.01986884f, -0.11039029f, 0.01907618f, 0.46325275f, 0.41462475f, 0.43498394f, -0.00835778f, 
    -0.06507973f, 0.05550177f, -0.34168425f, -0.23255421f, -0.36769208f, -0.16725495f, 0.11463007f, 0.07393982f, 
    0.38411203f, 0.23717979f, -0.02453111f, -0.04430918f, 0.25810793f, -0.36318180f, -0.02613123f, 0.11743215f, 
    -0.08059212f, 0.03961649f, 0.10727013f, 0.08411722f, -0.07249519f, 0.03609112f, 0.15779556f, 0.11685187f, 
    -0.54602700f, 0.03711039f, 0.16761532f, 0.09735701f, -0.04866255f, -0.17262739f, -0.03257042f, -0.04622852f, 
    -0.11709342f, 0.01239702f, 0.15798803f, 0.21278104f, 0.33613256f, 0.41636577f, 0.13463888f, 0.07236166f, 
    0.34978324f, -0.24498118f, -0.27020106f, -0.14609300f, 0.07417646f, 0.24763018f, -0.13487259f, -0.11225937f, 
    -0.07811608f, 0.32387313f, -0.14128144f, -0.12012208f, -0.11508417f, -0.06258178f, -0.05501400f, 0.02022328f, 
    -0.36100543f, -0.13874860f, 0.05774650f, -0.07497467f, -0.07403666f, 0.20706420f, -0.32187933f, 0.12387931f, 
    -0.02475197f, 0.04954006f, 0.06861137f, 0.20124978f, 0.47029158f, -0.23457150f, -0.22449993f, 0.01675210f, 
    -0.05667211f, 0.33766472f, 0.14439705f, -0.05490645f, 0.50952226f, -0.02260985f, -0.05397820f, 0.04392953f, 
    -0.04294256f, 0.23425032f, 0.16675828f, 0.00371092f, -0.09519188f, 0.09593665f, -0.13685319f, 0.16182810f, 
    -0.18097825f, 0.22782546f, 0.08599135f, 0.00150541f, -0.40622497f, 0.44790670f, 0.22302893f, -0.02944028f, 
    -0.11466800f, -0.09125636f, 0.29242226f, 0.29793963f, 0.00889635f, -0.05324056f, 0.44851798f, 0.12475244f, 
    0.07256857f, 0.29681215f, -0.21969257f, 0.39794022f, -0.09600838f, 0.07541101f, 0.02231167f, 0.08768494f, 
    -0.11623067f, 0.30659875f, 0.13379364f, -0.14010444f, 0.16856210f, -0.41803479f, -0.01024360f, -0.09690505f, 
    0.29879892f, -0.17315064f, 0.04775894f, 0.02095413f, 0.24486344f, -0.11445932f, 0.08697525f, 0.00836398f, 
    -0.11752246f, -0.11972518f, 0.42825821f, 0.47716913f, 0.13069986f, 0.09202012f, 0.08757796f, -0.12079336f, 
    -0.21349455f, -0.17358612f, -0.02082809f, 0.24354140f, -0.28800759f, 0.10532591f, 0.05751973f, -0.06453428f, 
    -0.08166424f, 0.58141184f, 0.08831772f, 0.04121117f, -0.10723248f, 0.12456619f, 0.09843819f, -0.24358782f, 
    0.04950775f, -0.14224251f, -0.08493894f, 0.05741819f, -0.03338132f, 0.27108607f, -0.08305158f, 0.08096064f, 
    -0.09116720f, -0.06112893f, -0.20716527f, -0.03628965f, 0.14571594f, 0.31787103f, -0.32860193f, -0.07739449f, 
    0.07996427f, 0.07685963f, 0.03212570f, -0.38399348f, 0.39866507f, 0.21066214f, -0.08135714f, 0.11739530f, 
    0.03143666f, 0.33396274f, 0.14003693f, 0.11737147f, -0.13363990f, -0.19957620f, -0.10532196f, 0.01200459f, 
    0.16488436f, -0.07078097f, -0.12598120f, -0.09983608f, 0.44842494f, -0.11998203f, -0.14858343f, -0.01259921f, 
    -0.09853771f, -0.05327526f, 0.09495310f, -0.00351624f, 0.35859343f, -0.46344745f, -0.03841190f, 0.05146267f, 
    0.21504299f, -0.04479071f, -0.05367318f, -0.07780541f, -0.06238416f, 0.17838955f, 0.09687594f, 0.17520931f, 
    -0.15795942f, -0.34630862f, 0.00165235f, 0.06167649f, -0.01578943f, 0.25177482f, 0.02284671f, -0.18227825f, 
    -0.18500732f, -0.06425732f, -0.16855329f, -0.06710897f, 0.16192684f, -0.04075853f, 0.32335794f, 0.12559788f, 
    0.01974115f, 0.07222560f, 0.25260973f, 0.28925630f, 0.10559542f, 0.42683429f, -0.05553687f, 0.02930665f, 
    0.24047981f, -0.54801148f, -0.06982824f, 0.02739208f, -0.00301387f, 0.36121458f, -0.14891051f, -0.12476556f, 
    -0.11321156f, -0.41481254f, 0.16297205f, 0.04422445f, -0.01296902f, -0.19835941f, 0.11847887f, -0.20150116f, 
    -0.46197093f, 0.02374605f, 0.10925595f, -0.02220470f, 0.02497667f, 0.02883143f, 0.03618421f, 0.08433812f, 
    -0.15173629f, -0.06729452f, 0.13351639f, 0.16030976f, 0.54038435f, -0.16291918f, -0.03626140f, -0.11953774f, 
    -0.25955725f, -0.01493395f, 0.01151920f, 0.13746192f, 0.20216542f, -0.35086426f, -0.07493819f, 0.05763886f, 
    0.14951706f, 0.00340179f, -0.02021207f, -0.11453527f, 0.05573384f, 0.20260145f, -0.02172749f, 0.31737867f, 
    0.34729019f, -0.00712878f, 0.06799169f, 0.13858984f, -0.03766795f, -0.16594303f, -0.20352998f, 0.02250606f, 
    0.08493268f, 0.16293272f, -0.18642472f, -0.13516173f, 0.25007096f, 0.09301459f, -0.27459061f, 0.10955396f, 
    0.02022782f, -0.57564282f, 0.28279495f, 0.13152517f, 0.21358611f, 0.17470895f, 0.09322902f, -0.00657453f, 
    0.09165714f, 0.16396956f, -0.12298822f, -0.05330922f, 0.11557613f, 0.29049563f, -0.02943134f, 0.28571722f, 
    0.29056293f, 0.34916070f, 0.13475087f, -0.00246975f, -0.14878269f, 0.15504280f, -0.14279903f, 0.14447913f, 
    0.07058681f, -0.09579317f, -0.33567283f, -0.21123299f, 0.01062587f, -0.18915054f, -0.20905128f, -0.05854983f, 
    0.00025866f, 0.51361805f, 0.11286782f, -0.07179368f, 0.31010187f, -0.18019621f, -0.01767382f, 0.14862026f, 
    0.16289921f, 0.52603996f, -0.10340338f, 0.00207795f, -0.03554229f, 0.08903445f, 0.12116014f, 0.26818606f, 
    0.21201479f, -0.14218646f, -0.09642663f, -0.04034855f, -0.01376326f, -0.26892474f, -0.11729798f, -0.12863415f, 
    0.15177810f, -0.16792336f, 0.50290787f, 0.16052322f, 0.45073959f, 0.05134587f, -0.14612098f, 0.08912927f, 
    -0.06227828f, -0.32199556f, -0.08304807f, 0.32516116f, -0.13198577f, 0.41774559f, -0.09840517f, 0.04612339f, 
    0.02219654f, -0.17028959f, -0.03929885f, 0.10079926f, -0.00682155f, 0.26299700f, -0.12974584f, 0.03576668f, 
    -0.00060283f, -0.15227994f, 0.05252617f, 0.08168250f, 0.26884854f, -0.01802707f, 0.19853912f, 0.13705337f, 
    0.08621199f, 0.15677130f, 0.30291724f, 0.26721361f, 0.24691407f, 0.28245184f, -0.24267092f, -0.14742020f, 
    0.18491516f, 0.16013077f, 0.22837743f, -0.34379345f, 0.49165210f, 0.24511553f, -0.01360271f, -0.13382584f, 
    -0.16531971f, -0.17449225f, 0.00856162f, 0.12948848f, 0.15489708f, -0.17054547f, 0.11159910f, -0.33475271f, 
    0.19839559f, 0.33471403f, 0.10704940f, 0.05457392f, -0.27180171f, 0.22140193f, 0.05679268f, 0.08524180f, 
    -0.06882719f, 0.01425909f, 0.10851777f, 0.29962784f, -0.30978045f, -0.19956206f, 0.45374206f, 0.08243615f, 
    0.05127108f, -0.10970065f, -0.04157955f, 0.27571288f, -0.21628489f, 0.15883312f, 0.03637754f, 0.01377213f, 
    -0.05890835f, 0.50281119f, -0.17232259f, -0.16794561f, 0.04105051f, -0.28314027f, 0.08060873f, -0.22758877f, 
    -0.37942383f, 0.16393067f, -0.01892391f, -0.08210663f, 0.18692394f, -0.02314836f, -0.06269515f, -0.11105680f, 
    -0.04821711f, -0.09026352f, -0.10387199f, 0.06408491f, 0.02356693f, -0.14589573f, 0.16718645f, 0.07816121f, 
    0.08425750f, 0.22473958f, -0.19345057f, -0.12633079f, -0.17205872f, 0.34092981f, 0.01536323f, -0.06350634f, 
    -0.05133921f, -0.29995996f, 0.03533372f, 0.01310282f, -0.02104682f, -0.11503056f, -0.05302566f, 0.22480471f, 
    -0.09381632f, -0.00846518f, 0.05334545f, 0.05260407f, 0.03805804f, 0.11108550f, 0.21047394f, -0.14036889f, 
    0.00481830f, -0.11186530f, 0.56107605f, -0.01223929f, 0.02239416f, 0.16313955f, 0.01379730f, -0.07115366f, 
    0.46605745f, 0.07437826f, -0.26548019f, 0.23600553f, 0.09761786f, 0.24814521f, -0.13616832f, -0.09460811f, 
    -0.09084215f, 0.21543810f, -0.10776300f, 0.16667926f, 0.14376488f, -0.30325198f, 0.01726901f, -0.19237274f, 
    0.06898599f, 0.31091958f, -0.04688388f, 0.13377166f, -0.29833680f, -0.12031682f, 0.31791908f, -0.14735954f, 
    0.04900478f, -0.05505272f, 0.31705606f, 0.39179909f, 0.19645353f, 0.07182901f, 0.11840979f, -0.15944757f, 
    0.01960700f, -0.29622227f, -0.14272611f, 0.52463847f, -0.38737217f, -0.21507564f, 0.04411387f, 0.15925862f, 
    0.00381842f, -0.14132224f, 0.04098814f, -0.03578671f, 0.15703286f, -0.05961322f, -0.03024085f, -0.02452179f, 
    -0.07969522f, 0.44000378f, -0.16133560f, 0.00304339f, -0.40338343f, 0.47072664f, 0.26706910f, -0.15889819f, 
    -0.05870133f, 0.12886515f, -0.40449935f, -0.28494796f, -0.01540715f, 0.17700419f, 0.30565655f, -0.11170726f, 
    0.07630377f, 0.18132977f, -0.19717291f, 0.26784301f, 0.05250710f, 0.17879291f, -0.01042316f, 0.01292214f, 
    0.05204817f, -0.33891398f, -0.16681468f, -0.13583203f, -0.09951390f, -0.20377018f, 0.11079311f, 0.44693869f, 
    0.30239421f, -0.02226168f, -0.16531037f, -0.05970623f, 0.30950981f, -0.23234873f, 0.32112625f, 0.12988667f, 
    0.00087128f, -0.12611543f, 0.11481042f, 0.08221649f, 0.10001450f, -0.25224936f, 0.05407091f, 0.04226866f, 
    -0.27687925f, 0.25780666f, 0.21893334f, 0.04603248f, -0.24100548f, -0.48359939f, -0.02568208f, 0.09594627f, 
    0.04161379f, -0.06855021f, -0.01558812f, -0.04208843f, 0.07162911f, 0.42511216f, 0.17058012f, 0.37711895f, 
    0.07986604f, -0.00486176f, -0.03402707f, -0.14311866f, -0.14015731f, -0.07428367f, -0.06039372f, 0.08295855f, 
    0.02941823f, -0.14551941f, -0.06313374f, 0.10552229f, 0.11845491f, -0.10544321f, -0.17490746f, -0.03918609f, 
    -0.05746293f, -0.05797601f, -0.08448547f, -0.17320774f, -0.11483432f, -0.10725048f, -0.07069883f, 0.14753205f, 
    -0.02651623f, 0.11622085f, 0.00700622f, 0.03652016f, -0.04272432f, -0.11706668f, 0.08309544f, -0.07266428f, 
    0.28385600f, 0.12019601f, 0.14973633f, -0.05595213f, 0.30754414f, 0.06216871f, 0.34481078f, -0.08703686f, 
    -0.07321834f, 0.15380712f, -0.29270205f, 0.05594658f, -0.23773730f, 0.24741140f, 0.12991501f, 0.02042858f, 
    0.13532487f, 0.08741329f, 0.06887702f, -0.35561129f, -0.25474897f, -0.26210082f, -0.04920516f, 0.07457396f, 
    -0.06304736f, 0.09739500f, -0.02630610f, -0.14097752f, -0.14111683f, -0.11186236f, -0.01244217f, 0.14416616f, 
    0.21907724f, 0.17566185f, 0.16788915f, -0.13125610f, 0.00048723f, -0.00239510f, -0.02732829f, 0.06938256f, 
    -0.06333143f, -0.05953199f, -0.27699921f, -0.15330599f, -0.09506828f, -0.12352446f, 0.18985845f, 0.13469420f, 
    0.19693056f, -0.01051550f, -0.04155174f, 0.29533389f, -0.29443347f, -0.02692260f, 0.10650696f, -0.05449887f, 
    -0.01037475f, 0.53580999f, -0.08921770f, -0.08621109f, 0.15468967f, 0.21193002f, 0.03190514f, 0.28467503f, 
    -0.43715066f, 0.28004736f, 0.05076007f, 0.07883917f, -0.30996764f, 0.33876613f, -0.09675876f, -0.11754291f, 
    -0.12246113f, 0.01055348f, -0.36597684f, -0.01940004f, 0.27077389f, 0.30109978f, 0.45727426f, 0.06355577f, 
    0.20076525f, 0.22981937f, -0.19254306f, -0.18617922f, -0.13083144f, 0.27716380f, 0.09999529f, -0.12843123f, 
    0.05916316f, -0.08147690f, -0.15202191f, 0.14028025f, 0.06214959f, -0.11974533f, -0.18042246f, 0.32487592f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.21811025f, 0.11185805f, 0.07500017f, 0.16774981f, 0.01600093f, 0.12003820f, 0.36749730f, 0.23965107f, 
    0.05078897f, -0.13235898f, 0.11300119f, 0.01971617f, -0.19596930f, 0.02088714f, -0.15239725f, -0.22995305f, 
    0.14798135f, 0.11893289f, -0.01373583f, -0.05542923f, -0.12529540f, -0.11055734f, -0.17335992f, 0.16809411f, 
    -0.12959985f, -0.08421723f, -0.09612847f, 0.18179710f, -0.01423163f, 0.15036172f, 0.25175133f, 0.27456936f, 
    0.20152789f, -0.15992223f, 0.05864390f, 0.11791445f, 0.40617228f, 0.17660713f, -0.07081546f, 0.39074311f, 
    -0.06987610f, -0.13476795f, 0.25541714f, -0.07162910f, -0.08841073f, -0.19773686f, 0.12871802f, -0.20750831f, 
    0.14079294f, 0.22507921f, 0.06614332f, 0.08877781f, 0.15757079f, -0.02666776f, 0.09538598f, 0.01580291f, 
    -0.10104055f, 0.25174892f, 0.00825241f, 0.02947312f, -0.15935776f, -0.02992127f, 0.14126389f, -0.10681272f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.05180027f, 0.16289859f, -0.19090559f, -0.13142772f, -0.15303111f, 0.12654006f, 0.01785531f, 0.28630087f, 
    0.17408490f, -0.01214034f, -0.06203496f, -0.02063992f, -0.17409675f, 0.07369761f, -0.43135554f, -0.34116003f, 
    0.23611690f, -0.03361976f, 0.12645358f, 0.42363393f, -0.07358265f, -0.12833087f, 0.04915189f, -0.42333227f, 
    -0.66667801f, -0.12527540f, -0.55655843f, -0.77961051f, 0.23691082f, -0.27496821f, 0.18760325f, -0.34601942f, 
    0.06981216f, 0.20956711f, -0.04505667f, 0.18741950f, -0.30348283f, 0.36677450f, -0.06504539f, -0.07110448f, 
    -0.09923194f, -0.18700744f, 0.11476380f, 0.03053285f, -0.01209281f, -0.15482220f, 0.01057974f, -0.07566711f, 
    -0.25198889f, 0.31358439f, 0.20815240f, 0.00172303f, 0.26095882f, -0.77046090f, -0.58980256f, 0.35129681f, 
    -0.37889746f, 0.13485989f, 0.33674994f, 0.07609943f, -0.14460051f, -0.48958275f, 0.18432882f, 0.30610871f, 
    0.31861892f, 0.00384533f, -0.04906736f, -0.44854355f, -0.20831731f, -0.64089119f, -0.02434438f, 0.06569204f, 
    -0.08352590f, 0.06844489f, 0.19428287f, -0.08445528f, 0.07042399f, 0.00084132f, -0.16079041f, 0.28279823f, 
    -0.03588882f, -0.02584662f, 0.07297088f, 0.08963223f, 0.04509694f, -0.08674971f, -0.03893990f, -0.28626597f, 
    -0.44444147f, -0.09211310f, -0.12957884f, -0.03950708f, -0.16347463f, -0.08413769f, 0.02554971f, -0.10173757f, 
    0.14160815f, 0.51667958f, 0.11550158f, -0.00175334f, 0.14731097f, -0.25716525f, 0.47195333f, 0.03862530f, 
    0.37163866f, -0.09248091f, 0.21494520f, 0.23727721f, -0.19396369f, -0.05570741f, -0.10589222f, 0.29059526f, 
    0.04801261f, 0.24565384f, 0.12209668f, -0.06375349f, 0.16048725f, 0.15083277f, -0.25467056f, -0.44903621f, 
    0.00209528f, -0.00942346f, -0.33465070f, -0.04701916f, -0.16661970f, -0.71001190f, -0.15166575f, -0.32104996f, 
    0.23400830f, -0.00996433f, -0.32757589f, -0.56517059f, -0.21991804f, -0.03687251f, 0.15847094f, -0.08351954f, 
    0.32636520f, -0.02290660f, 0.16022414f, -0.04928466f, -0.14394946f, 0.34200802f, 0.31574669f, 0.19161722f, 
    -0.58066314f, 0.04940749f, -0.61692870f, -0.28258443f, 0.10351744f, -0.07065548f, -0.03734050f, -0.27624965f, 
    -0.02678344f, 0.04537995f, -0.37385798f, 0.09988700f, 0.09831745f, -0.18274942f, 0.10511370f, 0.21498679f, 
    0.15857667f, 0.26141095f, -0.09751578f, 0.24644351f, -0.00164317f, -0.44959128f, -0.61804706f, -0.22454010f, 
    0.00690393f, 0.42164826f, -0.26283321f, 0.36186892f, -0.08685023f, -0.58627933f, 0.51384538f, -0.56333661f, 
    -0.13274863f, 0.02829750f, 0.06819485f, 0.25057602f, -0.71380919f, 0.28142911f, -0.56304085f, -0.23106295f, 
    -0.19539660f, -0.60875893f, 0.22763474f, -0.28980833f, -0.08115030f, -0.17372169f, -0.34926209f, -0.03376728f, 
    -0.48610914f, -0.34232587f, -0.24737719f, 0.12277871f, -0.00705611f, 0.04732949f, 0.05305377f, -0.25774837f, 
    -0.27706736f, 0.01811082f, -0.01471766f, 0.00280497f, -0.53980911f, -0.02212060f, 0.45700926f, -0.46646345f, 
    0.12851626f, 0.08434556f, -0.36684296f, 0.30506837f, -0.03639105f, 0.01378940f, 0.03174862f, 0.00330101f, 
    -0.06703462f, 0.04401627f, 0.31064636f, -0.79179662f, -0.41740197f, 0.00004386f, 0.05913245f, 0.01650571f, 
    -0.46724278f, 0.07765307f, -0.04032467f, 0.10030968f, -0.15856315f, 0.20933135f, 0.10211255f, -0.32205853f, 
    -0.35609144f, -0.18337747f, 0.07825737f, -0.31762680f, 0.36005533f, 0.07896786f, -0.68269157f, 0.33239710f, 
    0.14675540f, -0.28780892f, -0.33575916f, -0.49551964f, -0.02765011f, -0.15682873f, 0.45778304f, 0.36853740f, 
    0.03826774f, 0.14611161f, 0.25433403f, -0.46105406f, 0.00321700f, -0.13194425f, -0.04474404f, 0.31348324f, 
    -0.16289134f, 0.20280598f, -0.43915662f, 0.30080366f, -0.24226649f, 0.13432486f, 0.21014629f, -0.30127329f, 
    0.00394616f, -0.08962214f, 0.03822613f, -0.49709874f, 0.16376276f, -0.32478347f, -0.24127932f, -0.34160715f, 
    0.22778150f, 0.04524504f, -0.04705837f, -0.09483653f, -0.05723271f, -0.09348451f, 0.06603371f, 0.16329660f, 
    -0.17094311f, -0.13149606f, -0.17029223f, -0.07269471f, 0.14090151f, 0.37542731f, 0.24426912f, -0.26049733f, 
    0.09550550f, -0.41976750f, 0.00158489f, 0.20213865f, -0.11220091f, 0.01705353f, -0.49361110f, 0.14914180f, 
    -0.65598267f, 0.17360437f, -0.28510571f, -0.41709504f, 0.24881287f, -0.10991079f, -0.28722793f, -0.34970939f, 
    -0.10904185f, -0.32190356f, -0.20006844f, 0.11413521f, -0.08268182f, -0.07114843f, 0.30544415f, -0.45506573f, 
    0.20534024f, 0.24515790f, 0.24722432f, -0.06949899f, 0.01882360f, -0.02382694f, 0.05675103f, -0.10196554f, 
    0.23333271f, 0.33990562f, 0.47423741f, -0.36489356f, -0.14723618f, 0.41645333f, 0.14192073f, -0.10474858f, 
    -0.06508802f, 0.09589166f, 0.02388544f, -0.16473596f, -0.07725843f, 0.40465245f, -0.55721748f, -0.19484238f, 
    0.16692640f, -0.11898512f, 0.00920555f, -0.15989538f, 0.01566559f, -0.05642905f, -0.05518335f, 0.26535124f, 
    -0.31357917f, 0.10311356f, -0.07873130f, 0.01521968f, -0.01621787f, -0.28829482f, 0.04563865f, -0.39084989f, 
    -0.19812399f, -0.13665141f, -0.07472928f, -0.20954999f, 0.10673939f, -0.16251926f, -0.15747604f, 0.08878347f, 
    0.14179178f, -0.31305006f, -0.50258893f, -0.18001314f, -0.07044388f, 0.28824148f, 0.07963295f, -0.31016013f, 
    0.01283210f, 0.03262046f, 0.26649368f, -0.06977823f, 0.19743177f, -0.11601887f, 0.35942471f, -0.44138509f, 
    -0.54051822f, 0.24509887f, -0.17994681f, 0.06759595f, 0.09172241f, -0.11202788f, -0.03775920f, -0.58003008f, 
    -0.11131273f, 0.16986735f, 0.18858141f, 0.06243309f, -0.48489994f, -0.57789409f, -0.13972920f, 0.07398887f, 
    -0.40764534f, -0.06353775f, 0.11754011f, 0.25759959f, -0.31397808f, -0.22372447f, 0.12719913f, 0.19531211f, 
    0.24024099f, 0.03200179f, -0.58207029f, 0.31525025f, -0.07187232f, -0.03771540f, 0.09512525f, 0.31715110f, 
    0.01989541f, 0.05520462f, 0.51236802f, 0.12135226f, -0.10788520f, -0.47196516f, -0.21861520f, 0.44011712f, 
    0.08140952f, 0.00317500f, 0.09347954f, -0.06607258f, 0.19314563f, -0.29925326f, -0.12320896f, 0.12652923f, 
    -0.08111480f, 0.35093036f, -0.41941005f, -0.63388616f, -0.65420431f, 0.00853373f, -0.36361754f, 0.36083463f, 
    -0.13359302f, -0.41292468f, 0.11818433f, -0.00181189f, -0.07513395f, -0.16800803f, -0.38042498f, -0.08324075f, 
    -0.44964525f, -0.20971359f, -0.16438329f, 0.13009204f, -0.00463659f, 0.30316436f, 0.17273834f, -0.57614470f, 
    -0.20547543f, -0.08479036f, -0.35892290f, 0.04533451f, 0.19123259f, 0.34950459f, -0.06221886f, -0.37140405f, 
    -0.29326218f, 0.00077385f, -0.49382046f, -0.15983087f, 0.45785040f, -0.06592004f, -0.58295006f, 0.01787704f, 
    -0.21329655f, -0.06399993f, 0.32296842f, -0.50584602f, 0.06288970f, 0.02177292f, 0.06384215f, -0.32688892f, 
    0.05618955f, 0.00287943f, 0.01908914f, -0.19053414f, 0.05284666f, 0.38554004f, 0.09395512f, -0.32930392f, 
    -0.34444201f, -0.04750971f, 0.03421669f, 0.10500048f, -0.40226433f, 0.05499486f, 0.07483912f, -0.30890200f, 
    0.04764615f, -0.00563396f, 0.14462690f, 0.05467616f, 0.20411336f, 0.20577814f, 0.10949181f, -0.12955475f, 
    -0.58866876f, -0.29974517f, -0.33170372f, 0.24170986f, -0.40895769f, -0.14973421f, 0.19665475f, -0.01358782f, 
    0.17455748f, -0.24951966f, -0.14863054f, -0.30890504f, 0.11162952f, -0.06853002f, 0.21543707f, -0.03547066f, 
    0.11655606f, -0.07509647f, 0.30505514f, 0.08761546f, 0.33791122f, -0.36261678f, -0.53347772f, 0.01226769f, 
    0.20219322f, -0.12492777f, -0.58245981f, 0.24706995f, 0.10194219f, -0.08558421f, 0.20052800f, 0.13541465f, 
    -0.23229998f, -0.11433613f, 0.38523167f, -0.52725983f, 0.07384409f, -0.14956439f, -0.00381974f, -0.35931692f, 
    0.28412068f, -0.01259845f, 0.08710498f, 0.18596320f, -0.26668027f, 0.13183650f, -0.26477081f, -0.19292383f, 
    -0.27838090f, -0.09720136f, 0.09978522f, -0.59149861f, 0.17050697f, -0.36074874f, -0.33948410f, -0.05469335f, 
    0.19514950f, -0.29562685f, -0.30515921f, 0.27569026f, 0.02666639f, 0.28029367f, -0.37856314f, 0.17279780f, 
    -0.10630226f, 0.16341820f, -0.18629305f, -0.32376087f, 0.25701389f, 0.26361167f, -0.49037638f, 0.12347775f, 
    -0.00672338f, -0.04090739f, -0.71571606f, 0.21023513f, -0.01051678f, -0.27792493f, -0.52084732f, -0.34832495f, 
    -0.27837265f, -0.11604790f, 0.00725230f, 0.15442504f, -0.01315872f, 0.14343068f, -0.17231205f, -0.39481965f, 
    0.27586758f, -0.03705505f, 0.14904863f, -0.38978747f, -0.71304172f, -0.08922361f, 0.06940813f, -0.13813491f, 
    -0.11686287f, -0.01005945f, 0.00838748f, 0.10900023f, -0.01175171f, -0.01327167f, 0.01400677f, 0.03019907f, 
    0.18538415f, 0.04685513f, 0.14924890f, 0.51269776f, 0.31735346f, 0.06879758f, -0.35426030f, -0.38565385f, 
    0.36189270f, -0.27914628f, -0.02427010f, -0.07591497f, 0.13548785f, 0.09481342f, 0.07807806f, 0.17907166f, 
    -0.14877337f, -0.01978035f, -0.28193375f, -0.01236739f, -0.18452823f, -0.33389667f, 0.01914673f, -0.25660911f, 
    -0.50808823f, 0.14984600f, -0.13543071f, 0.29556164f, -0.36340842f, -0.18204433f, -0.25857911f, 0.03188116f, 
    -0.68315899f, -0.20613149f, 0.17451325f, 0.12951443f, 0.02378071f, 0.13041314f, 0.01983674f, 0.17565662f, 
    -0.06788833f, -0.40425903f, -0.07308759f, -0.12335405f, 0.21122769f, -0.38572222f, 0.19931029f, 0.22899140f, 
    0.15521710f, 0.06983714f, -0.37808663f, 0.12797356f, -0.32029766f, 0.03550344f, 0.22063960f, -0.25546145f, 
    -0.22948718f, 0.15532920f, -0.03088046f, -0.56777251f, -0.00439164f, -0.21701139f, -0.06484830f, -0.00946215f, 
    0.07397405f, 0.04890203f, -0.37451643f, -0.20441116f, -0.17490698f, 0.19285670f, 0.18566614f, 0.32048422f, 
    -0.60725850f, 0.30869621f, -0.01448289f, 0.02109609f, 0.13243161f, 0.12481107f, 0.15453599f, -0.15821330f, 
    0.02384509f, -0.57277787f, 0.37205970f, 0.01761119f, -0.13373189f, 0.01566630f, 0.61429191f, -0.11878277f, 
    0.29983535f, -0.30648434f, 0.02491109f, -0.32214135f, 0.27507982f, 0.33462241f, -0.24723507f, 0.00416391f, 
    0.16216613f, -0.20865731f, -0.04965555f, -0.71059728f, 0.07511864f, -0.27068356f, -0.18009840f, 0.07537557f, 
    -0.06534049f, -0.20703323f, 0.20597546f, -0.12886325f, 0.08816410f, -0.20810963f, 0.21436262f, 0.38606527f, 
    -0.35634786f, 0.02460341f, 0.00839667f, -0.05507063f, -0.05681864f, -0.48066118f, 0.01481087f, 0.06372379f, 
    -0.30864826f, -0.06058221f, -0.28784665f, -0.03035657f, 0.03654821f, -0.00357280f, 0.01446478f, 0.21119119f, 
    0.27925587f, 0.09022261f, -0.06641952f, -0.14815715f, -0.64654964f, -0.51581883f, -0.22671367f, 0.44326425f, 
    -0.12914453f, -0.53277624f, 0.02124114f, 0.10972157f, -0.09546044f, 0.00248328f, -0.32000962f, 0.29855216f, 
    -0.31307331f, 0.27283627f, 0.24222770f, -0.48809981f, 0.05474649f, 0.06591816f, -0.25108618f, -0.41664451f, 
    0.35908860f, 0.08288711f, -0.33543688f, -0.52575493f, -0.25210130f, 0.18745390f, -0.20991135f, -0.11426470f, 
    0.09243365f, 0.22068579f, -0.00278312f, 0.02163439f, -0.13040298f, 0.42479986f, -0.15661569f, -0.03193796f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07649148f, -0.04112253f, 0.00250531f, -0.25906557f, 0.19794342f, 0.05806167f, 0.08741996f, -0.21715055f, 
    -0.14491615f, 0.15933864f, 0.33495626f, 0.06719192f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
