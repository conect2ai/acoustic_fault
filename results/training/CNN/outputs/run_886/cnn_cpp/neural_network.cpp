#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.42247063f, -0.07548349f, 0.71026331f, 0.66646791f, 0.98873883f, -0.43401542f, -0.52849978f, -1.54864752f, 
    -1.33576763f, 0.39478287f, 0.10319937f, 0.62931800f, 0.01546033f, 0.28881550f, 0.18273687f, -0.29281840f, 
    -0.66974652f, -0.01006516f, 0.09358214f, -0.17319629f, -0.16145585f, 0.33541390f, 0.19777295f, 0.19243547f, 
    0.07391965f, 1.30181897f, 0.90589857f, 1.19507766f, 0.70673472f, 0.86537629f, 1.46499121f, -0.66997015f, 
    0.41141418f, 0.60962081f, 0.32778054f, -0.50645024f, 0.08522771f, -0.21238670f, -0.15643348f, 0.05317226f, 
    0.20881836f, 0.28623238f, 0.16692072f, -0.51410443f, 0.16994768f, -0.38852626f, -0.13017046f, 0.23362440f, 
    -0.04374550f, 0.09065705f, 0.43940043f, -0.46221465f, -1.26756048f, -1.35253489f, -0.19581684f, 0.89260536f, 
    -0.34442016f, 0.52542764f, 0.80397677f, 0.22160017f, -0.89216095f, -0.42396066f, -0.15343358f, -0.26921180f, 
    -0.60589510f, -0.44345599f, -0.25027290f, -0.06523815f, 0.15685609f, 0.16954078f, -0.24441388f, -0.16361167f, 
    -0.71898556f, 0.08071458f, 0.36341128f, -0.86559075f, -1.05629539f, -0.47239339f, -0.47348121f, 0.89474040f, 
    -0.59352732f, -0.58410680f, -0.48484427f, -0.49126869f, -0.19190603f, 0.86828852f, 0.27527720f, 0.55486590f, 
    0.00021820f, -0.36012360f, 0.35760248f, 0.38880175f, 0.35848507f, 0.27363616f, -0.12641308f, -0.28918263f, 
    -0.27271131f, 0.10912164f, -0.26994091f, -0.54013777f, -0.74694258f, 1.30982590f, -0.93186593f, -1.19499457f, 
    -0.81010783f, 0.92921841f, -0.28157353f, 0.11677182f, 0.49716485f, -0.56032312f, 0.26251423f, -0.51964545f, 
    -0.51601797f, -0.17320779f, 0.06111550f, 0.44710535f, 0.18545471f, 0.10597733f, 0.00542351f, 0.52954614f, 
    -0.06520398f, -0.22178262f, 0.14728785f, -0.21700475f, 0.12623121f, -0.65453917f, -1.35635281f, -1.26720870f, 
    -0.52405328f, -0.74396175f, -0.69934940f, 1.07824266f, 0.65870553f, 0.12844840f, 0.81926185f, 0.50700545f, 
    -0.00907447f, 0.33473361f, -0.05547315f, -0.30163008f, -0.28819141f, -0.08754821f, -0.00740812f, -0.21337952f, 
    -0.14217757f, 0.06917495f, 0.14276861f, -0.20133083f, 0.16851743f, 0.55105227f, -0.33558285f, -1.41645491f, 
    0.03108134f, 1.07409775f, 0.19382946f, -1.55327094f, 1.17200649f, 0.16741265f, -0.77454203f, -0.16834857f, 
    0.65919542f, 0.52910960f, 0.11989027f, 0.12624583f, -0.05196188f, -0.34443405f, -0.05762627f, -0.17658462f, 
    0.19908370f, -0.34358060f, -0.12310953f, 0.01336276f, 0.20636769f, 0.38443372f, 0.16212174f, 1.30195212f, 
    -0.38119605f, -1.32298994f, -0.72620356f, 1.19257510f, 0.12754597f, -0.04126957f, -0.69105643f, 0.10658155f, 
    0.46128738f, -0.49109513f, -0.51587969f, 0.30061632f, 0.42184511f, 0.08212929f, -0.04291698f, 0.05473499f, 
    0.03996405f, -0.21189763f, -0.15367579f, 0.23434100f, 0.32793668f, 0.70092696f, 0.35972998f, -0.26724574f, 
    -0.82362247f, -2.24757195f, -0.48750433f, 0.27702424f, 0.28547767f, 0.59005350f, 0.76270169f, 0.91138065f, 
    -0.09304536f, 0.25002638f, -0.37746522f, 0.10976768f, -0.23142564f, 0.32149792f, 0.45436880f, -0.04374693f, 
    0.19511743f, 0.06447569f, -0.10784758f, 0.04400816f, -0.09619924f, -0.11081575f, -0.18875284f, -0.28260309f, 
    -0.09854162f, 1.51435387f, 1.09920919f, 1.39889920f, 1.22669899f, 0.66535819f, -0.66480464f, 0.49221736f, 
    -0.02044451f, -0.35371539f, -0.26574787f, 0.51317114f, 0.06827504f, -0.48547325f, 0.56182545f, -0.31996435f, 
    -0.30073330f, 0.20942709f, 0.48472628f, 0.15944827f, -0.27810222f, -0.00442499f, 0.22159427f, 0.29538521f, 
    0.28030348f, 0.16479386f, 1.34020102f, 0.88418669f, -0.00672336f, -0.63624102f, -0.86676788f, 0.65219444f, 
    0.84423029f, 0.92021227f, 0.80718380f, 1.07879722f, 0.85437924f, 0.43233803f, 0.21110731f, -0.24720082f, 
    0.12240632f, 0.20450339f, 0.66791016f, 0.03066921f, 0.46192569f, 0.74275458f, -0.13970567f, -0.02691846f, 
    -0.10640974f, 0.03183078f, -0.01501588f, 0.66354227f, 0.16366221f, -0.94781053f, 2.34419823f, 0.37228256f, 
    -0.15371521f, 0.33161387f, -0.23131579f, 0.94007039f, -0.12708169f, -0.14743745f, 0.16732429f, 0.11630542f, 
    0.53616184f, -0.21109706f, -0.02056459f, 0.05835380f, 0.08200315f, -0.45899254f, -0.11551666f, 0.08129404f, 
    -0.24894820f, -0.12167771f, 0.16683540f, 0.07387951f, 1.88380301f, -1.05946481f, -0.89867228f, 0.77973968f, 
    0.07972733f, -0.05972253f, -0.11725864f, -0.85549200f, 0.23329516f, 0.49587342f, -0.22282213f, 0.45182741f, 
    -0.28586301f, 0.19291689f, 0.27772805f, 0.11925367f, 0.13022234f, 0.00563618f, 0.11018405f, 0.25106952f, 
    -0.04785344f, 0.00481832f, 0.26481605f, -0.11535262f, 0.31120571f, -1.16381133f, -0.98880428f, -0.81448954f, 
    -0.65490282f, -0.89862645f, -0.03398041f, -1.15242672f, -0.32462159f, -0.15893039f, -0.12445905f, 0.38387042f, 
    -0.37089005f, 0.16159882f, 0.12131047f, -0.04455224f, 0.15724804f, 0.21002786f, -0.00566143f, 0.09815181f, 
    0.33809674f, 0.32027143f, 0.37836638f, -0.02603011f, 0.68405265f, -0.08371817f, 0.47577024f, -0.20413120f, 
    -0.54931307f, -0.38399881f, 0.05638408f, -0.37583432f, 0.01489633f, -0.68207359f, 0.08606621f, 0.07588910f, 
    -0.58808440f, -0.21945980f, 0.22828569f, -0.33947471f, -0.15485629f, -1.23688102f, 0.22817655f, -0.65657777f, 
    -0.57223403f, -0.28793514f, 0.24740507f, -0.21364880f, 0.05142633f, -0.23599249f, -0.37600806f, 0.65957719f, 
    1.30604517f, 0.22155853f, 0.46527255f, -1.31222284f, -0.80468708f, -0.16516131f, -1.06459820f, 0.27311552f, 
    0.34039727f, 0.88694942f, 0.12737244f, -0.56881565f, -0.60779089f, 0.24074644f, 0.25669000f, 0.04573881f, 
    0.03549419f, -0.11218980f, -0.31900945f, -0.14448172f, 0.00057439f, -0.21358714f, -0.39275360f, -0.43223962f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18687351f, 0.51732481f, -0.13208181f, 0.86965221f, 0.08777791f, 0.14519960f, 0.25633961f, 0.62917137f, 
    0.31817034f, 0.19998868f, 0.31560868f, 0.35177311f, 0.33849144f, 0.27769583f, 0.48899126f, 0.28809869f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.28310531f, -0.00504086f, 0.06043210f, 0.38016668f, -0.09608097f, -0.04018494f, -0.01744278f, 0.16723891f, 
    -0.14289270f, 0.12201593f, -0.19439836f, 0.01156092f, 0.41548738f, -0.22678360f, 0.07230955f, 0.29901209f, 
    -0.26692110f, -0.00629517f, 0.08427739f, 0.00490049f, -0.07837187f, -0.02594551f, -0.27365494f, -0.07226563f, 
    0.73820752f, -0.09845156f, 0.03129157f, -0.56416619f, 0.17800038f, 0.03395224f, 0.13322611f, -0.07487830f, 
    0.06224335f, -0.10222926f, -0.04806698f, 0.19526476f, -0.66335338f, -0.71831459f, 0.08544070f, 0.06680063f, 
    -0.17001794f, 0.12609550f, 0.02256677f, 0.13583486f, 0.12019069f, 0.14527664f, -0.10413948f, -0.14888550f, 
    0.77157253f, -0.13981798f, -0.10796246f, -0.49835962f, -0.24266152f, -0.04469155f, 0.04261437f, 0.02629939f, 
    -0.12084361f, 0.12587580f, 0.01317039f, -0.05731388f, -0.31017128f, 0.47561631f, -0.04804895f, -0.25454542f, 
    -0.03478419f, 0.08343435f, 0.00711959f, 0.16465418f, -0.11607847f, 0.04890618f, -0.22580533f, 0.14649911f, 
    -0.08566087f, -0.28405857f, -0.18623720f, 0.50616825f, 0.04455665f, -0.08827852f, -0.13916993f, -0.11494762f, 
    0.17721462f, 0.04468628f, -0.01861028f, -0.07180128f, 0.07072451f, -0.10129964f, 0.31898916f, -0.38264406f, 
    0.05104219f, 0.23178773f, 0.27576086f, -0.04625066f, -0.24151094f, 0.09664174f, 0.00296459f, -0.14741535f, 
    -0.33475283f, -0.05681640f, 0.07901030f, -0.24903008f, 0.28153807f, -0.06755254f, -0.14585264f, 0.12572202f, 
    -0.05449359f, -0.14450578f, 0.15691687f, 0.06386176f, 0.32050973f, 0.18713908f, -0.24740466f, -0.06245884f, 
    -0.61406010f, -0.22266962f, -0.00017863f, -0.02793430f, -0.14662673f, 0.00432682f, 0.02986771f, -0.15272205f, 
    -0.11278180f, 0.28667861f, 0.06055785f, -0.32858640f, 0.33076060f, -0.00508488f, -0.13646095f, -0.12174415f, 
    -0.07526059f, 0.07007157f, -0.02965870f, 0.08770767f, -0.11110303f, 0.47435057f, -0.41512445f, 0.60759348f, 
    0.06147556f, 0.14706235f, -0.15427931f, -0.16160801f, -0.12924516f, 0.03740059f, -0.04809608f, -0.04863568f, 
    0.49113035f, -0.99042481f, 0.35150731f, 0.36834407f, -0.19173628f, -0.36013651f, 0.00345929f, 0.23993161f, 
    -0.15199925f, 0.07785686f, 0.10515697f, 0.08570667f, -0.12776653f, -0.68825901f, -0.24065033f, 0.07014003f, 
    -0.10889532f, 0.30364177f, 0.26011577f, 0.16821939f, -0.00337565f, 0.04275500f, 0.13535081f, -0.04958121f, 
    -0.32099420f, -0.23806588f, -0.16052681f, -0.25751096f, -0.11223920f, -0.13010705f, -0.01181047f, 0.01222180f, 
    -0.06354649f, -0.09231014f, 0.06172462f, 0.06567860f, -0.27656761f, 0.08326707f, -0.28880885f, 0.30131164f, 
    -0.10392015f, -0.21486667f, 0.02637480f, -0.05944571f, 0.07406218f, 0.13080992f, -0.08363194f, -0.05985329f, 
    -0.08516020f, -0.09307338f, -0.00373528f, 0.03139989f, -0.02783446f, 0.02867614f, 0.05710869f, 0.15035293f, 
    0.01770690f, -0.06879420f, -0.05696086f, -0.23359157f, 0.33673146f, 0.12766100f, 0.20029128f, 0.39367348f, 
    -0.17859049f, -0.06215707f, 0.05892490f, 0.00834885f, 0.01587752f, -0.07873420f, 0.13857530f, -0.12863573f, 
    -0.22111407f, -0.69107217f, 0.13601770f, -0.40182862f, 0.08340056f, -0.14188926f, -0.19704780f, 0.03411618f, 
    0.00148252f, 0.01566503f, 0.15374546f, -0.16716024f, 0.28312889f, 0.04948655f, -0.00847582f, -0.13399944f, 
    0.24632414f, -0.18501748f, 0.08666088f, -0.01554440f, -0.09072837f, -0.01296415f, 0.15014006f, 0.17443956f, 
    -0.57633388f, -0.19558075f, 0.04968521f, -0.60145855f, 0.00060801f, 0.09339536f, 0.27315235f, 0.04271102f, 
    0.22921680f, 0.08725063f, -0.09669112f, -0.02969281f, 0.46000713f, -0.43708274f, -0.31260073f, -0.09659573f, 
    0.12836061f, -0.04209265f, 0.02961027f, -0.00004589f, 0.10547385f, -0.21938151f, -0.07468260f, 0.14702213f, 
    -0.39383611f, -0.35652420f, -0.08104850f, 0.21143270f, -0.18700963f, 0.12337079f, -0.18652298f, 0.11699563f, 
    0.10902850f, -0.04717166f, -0.06270634f, -0.12610818f, 0.44900644f, -0.48770681f, -0.06308983f, -0.67214066f, 
    -0.07328767f, -0.11357679f, -0.01195799f, -0.02843677f, -0.01929188f, -0.21715164f, -0.20566921f, 0.18255791f, 
    0.41793492f, -0.12438051f, -0.08474359f, 0.11343722f, -0.13436809f, 0.23723756f, -0.01906661f, -0.00689946f, 
    0.08070654f, 0.16034743f, 0.05783151f, 0.15016063f, 0.36973631f, 0.10091599f, 0.30636421f, 0.50351876f, 
    -0.10305008f, 0.02642633f, 0.01362852f, 0.01952750f, 0.10657179f, -0.08645730f, 0.17324656f, 0.12009198f, 
    0.62886155f, -0.16733128f, 0.12821013f, -0.10238140f, -0.16788858f, -0.30866277f, -0.22167432f, 0.00696735f, 
    -0.04261297f, 0.05753503f, -0.18556739f, 0.04157637f, 0.19421415f, -0.28258789f, -0.35482496f, 0.24096358f, 
    -0.02056393f, 0.12636194f, -0.30020425f, 0.20239808f, 0.08864050f, -0.09893303f, 0.00960476f, -0.04289376f, 
    0.60122389f, -0.24081014f, -0.19144252f, -0.15188846f, -0.01670103f, 0.05926605f, -0.14835648f, -0.05845992f, 
    -0.11159193f, 0.27992100f, 0.04432562f, 0.11815286f, -0.24900781f, 0.19546641f, 0.20298897f, -0.00459405f, 
    0.13118833f, -0.25412899f, 0.23716712f, 0.10017219f, 0.02025343f, 0.11971448f, -0.08795418f, 0.25788364f, 
    0.16370748f, -0.29995766f, -0.05050202f, -0.44132265f, 0.10081979f, -0.34679940f, 0.09771379f, 0.11399011f, 
    -0.13672827f, -0.10107769f, -0.14246705f, -0.57448912f, 0.15587768f, -0.26186728f, -0.49060211f, -0.28598753f, 
    -0.07816210f, -0.27394348f, 0.04833631f, -0.00229283f, -0.09721107f, -0.20591922f, 0.02926931f, 0.21244597f, 
    0.28382424f, -0.33599058f, -0.26542211f, -0.17124912f, 0.05788425f, 0.37393743f, -0.23602505f, 0.05741364f, 
    -0.08147084f, 0.13204229f, 0.03610685f, -0.08854321f, 0.05057086f, 0.26234818f, -0.01627706f, 0.16383852f, 
    0.10641319f, 0.21586302f, 0.00380119f, -0.07349776f, -0.08414461f, 0.13247685f, -0.06371110f, -0.09412276f, 
    -0.46585533f, 0.44852120f, -0.08686384f, 0.55273134f, -0.00883379f, -0.14335556f, 0.07473764f, 0.20877838f, 
    -0.17940053f, -0.05542974f, -0.09914307f, 0.15250652f, 0.47239494f, -1.09451437f, 0.02043328f, -0.07936104f, 
    0.00395509f, 0.08661709f, 0.01389644f, -0.18605420f, -0.32868922f, -0.08212437f, -0.34062198f, -0.21734034f, 
    -0.15915380f, 0.25351003f, -0.19880085f, -0.04532219f, 0.12551230f, -0.01334149f, -0.05466317f, -0.01751918f, 
    -0.10021367f, -0.14989227f, 0.08123182f, 0.01446714f, 0.78868479f, 0.16636087f, 0.34047204f, 0.53520751f, 
    -0.21342915f, -0.12825799f, -0.03379733f, 0.02433140f, -0.02351006f, 0.03707771f, 0.17489575f, 0.02309986f, 
    1.24630618f, -0.07192589f, -0.21514352f, -0.25402439f, -0.08606389f, 0.26167417f, -0.12899978f, -0.13481446f, 
    -0.05622456f, -0.06997740f, -0.00494150f, -0.08243449f, -0.35437524f, -0.54580653f, 0.02907285f, -0.35536847f, 
    0.15079163f, -0.01535374f, 0.02760639f, -0.13543871f, -0.10929206f, -0.08238252f, 0.11484595f, -0.10430170f, 
    0.48952186f, -0.01487608f, 0.05986657f, 0.22699711f, -0.37297228f, -0.22143130f, 0.02382975f, 0.16379394f, 
    0.08600006f, -0.13845934f, 0.04901744f, 0.01246993f, 0.12969093f, 0.20546439f, -0.33616495f, 0.07101129f, 
    0.13438261f, 0.14043689f, 0.04001100f, -0.07225733f, -0.10662331f, 0.05011252f, -0.20666964f, 0.08489946f, 
    0.00732061f, 0.10862319f, 0.22025828f, -0.23336679f, -0.26099783f, -0.18615110f, 0.22596848f, 0.12760396f, 
    -0.16357628f, -0.35588825f, 0.07760156f, -0.28733104f, 0.03134514f, -0.53220892f, -0.45524967f, 0.02616994f, 
    0.14877675f, 0.03613625f, -0.17886673f, -0.11503420f, -0.03908565f, 0.09967344f, 0.04525571f, -0.17405818f, 
    -0.05872383f, -0.06169531f, 0.11972786f, -0.33441553f, 0.12783994f, -0.01909595f, 0.10064148f, 0.20772357f, 
    -0.01350866f, -0.16916846f, 0.12378720f, -0.25686324f, -0.62905532f, -0.05974329f, 0.12972382f, -0.56071156f, 
    -0.03830124f, 0.10922579f, -0.59388769f, -0.24574052f, 0.10693633f, 0.10084188f, 0.06894002f, -0.05296348f, 
    -0.01479478f, -0.05480764f, -0.27543992f, -0.33683032f, -0.01093812f, -0.10424430f, 0.02974754f, 0.01023501f, 
    0.15972492f, 0.23390284f, -0.21935681f, 0.03998440f, -0.04833848f, -0.46680447f, 0.22905609f, -0.27783680f, 
    -0.25235173f, 0.04086596f, 0.13092965f, -0.02958645f, -0.06695128f, 0.01239549f, 0.06332858f, -0.12780596f, 
    -0.19812135f, 0.35720241f, 0.16380790f, 0.50709021f, 0.22801334f, 0.24425703f, -0.15121731f, -0.10186077f, 
    -0.01311890f, -0.08597964f, 0.00267546f, -0.18077607f, -0.63227642f, -0.60444057f, -0.84108293f, 0.16259517f, 
    -0.01435598f, -0.04607291f, 0.01082608f, -0.06288212f, 0.10111819f, -0.02581568f, 0.05578100f, 0.17756438f, 
    -0.35093072f, -0.13585207f, -0.16147618f, 0.12115684f, -0.17066444f, -0.03435282f, 0.13900506f, -0.01527016f, 
    -0.10126195f, 0.04692904f, -0.05325497f, -0.00709190f, -0.22854826f, 0.19132797f, 0.04632313f, 0.28763169f, 
    -0.02577112f, 0.10186422f, 0.16488701f, 0.16476522f, -0.09472227f, 0.20570789f, 0.10167193f, 0.06841215f, 
    0.30459180f, 0.19902946f, -0.06656481f, -0.01630789f, -0.21904068f, 0.14336598f, 0.15824500f, 0.20471227f, 
    -0.03681505f, -0.33906326f, 0.11684772f, -0.01914493f, 0.29133862f, -0.20747237f, 0.06792101f, -0.11931518f, 
    -0.14016551f, -0.05520815f, -0.08899187f, -0.04741796f, -0.08742060f, 0.08024316f, -0.08593599f, 0.07891936f, 
    -0.49901983f, 0.20759547f, 0.49955595f, -0.11245813f, 0.10914340f, -0.09893221f, 0.06830890f, 0.01513217f, 
    -0.09542087f, 0.20883350f, -0.27257979f, 0.17904907f, -0.04417609f, 0.26332334f, -0.04126960f, 0.20711342f, 
    0.04493596f, 0.12119856f, -0.18125221f, -0.08678277f, -0.05763054f, 0.11871700f, 0.07211407f, -0.10262623f, 
    0.49138623f, -0.15921333f, -0.16508812f, -0.08999198f, -0.14791566f, 0.02394746f, 0.24621543f, -0.16076247f, 
    -0.13709612f, 0.08546616f, 0.11372811f, -0.09725326f, -1.14291763f, -0.97841072f, -0.06334265f, 0.16502547f, 
    -0.18792215f, 0.14754836f, 0.07114215f, -0.04276858f, 0.09213249f, -0.13656954f, 0.14047650f, -0.08179099f, 
    -0.63578588f, -0.65526134f, -0.22018407f, -0.34921744f, -0.22727433f, -0.08980991f, -0.26863816f, 0.19076174f, 
    -0.08388042f, -0.09822898f, -0.10995900f, 0.02134487f, 0.60735381f, 0.02755800f, -0.28487104f, -0.07610122f, 
    0.03338498f, -0.15792829f, 0.33633193f, -0.22873262f, 0.13714330f, -0.24222600f, 0.09639790f, -0.08484751f, 
    0.35917047f, 0.12356682f, 0.29437163f, 0.16510680f, -0.05081811f, 0.16920124f, -0.34180892f, -0.06284807f, 
    0.17634812f, -0.25798693f, -0.08311075f, 0.01985709f, 0.42194349f, 0.27034903f, -0.27545136f, -0.16436629f, 
    -0.26417232f, -0.13792486f, 0.00118261f, 0.10940133f, -0.13654660f, -0.18769388f, -0.03806230f, -0.16379920f, 
    -0.01914998f, 0.12389692f, 0.10693155f, 0.28816143f, -0.02555453f, -0.07355323f, 0.02621842f, 0.02203669f, 
    0.01611647f, 0.10664614f, 0.15096650f, 0.02535895f, -0.04765125f, 0.17996761f, -0.29807049f, 0.21417210f, 
    0.01527271f, 0.37122464f, -0.01640688f, 0.18746437f, -0.06276210f, -0.00501674f, 0.03596918f, -0.28095984f, 
    -0.74410653f, 0.02110837f, 0.54765511f, 0.21742950f, 0.01871807f, -0.21116476f, -0.34812772f, -0.01170915f, 
    0.15438884f, -0.06478569f, -0.05805808f, 0.08883379f, 0.20787147f, 0.01537082f, -0.15882096f, -0.29364187f, 
    0.02221654f, -0.20799133f, -0.05654251f, 0.12407698f, 0.06453394f, -0.12561010f, 0.06568202f, 0.09170759f, 
    -0.52540010f, -0.56635863f, -0.15531768f, 0.51549107f, -0.01151734f, -0.16598909f, 0.08877106f, -0.00677475f, 
    0.00566635f, 0.04528368f, -0.03003624f, 0.04564881f, -0.18233539f, 0.20964557f, 0.05059882f, 0.23037314f, 
    0.14524676f, -0.10643125f, 0.01121850f, 0.11595366f, 0.30704299f, 0.16043380f, -0.05230201f, -0.13180929f, 
    0.43282273f, 0.29386824f, -0.36244166f, 0.16874477f, 0.12129743f, -0.09733275f, 0.05219635f, -0.10679340f, 
    -0.01815106f, 0.00125775f, 0.18962035f, 0.12896127f, -0.54516262f, 0.05032558f, 0.02458378f, 0.22606014f, 
    0.10883377f, 0.01038009f, -0.08366816f, 0.17957209f, -0.05781685f, 0.10228808f, 0.20517354f, -0.17993280f, 
    -0.68906671f, -0.13632694f, 0.04449613f, -0.12635994f, 0.01555484f, -0.09943467f, 0.06968173f, -0.00971056f, 
    -0.13409169f, -0.01124108f, -0.17778000f, 0.28986311f, 0.22310258f, -0.29962555f, -0.21619073f, 0.17471811f, 
    -0.02656091f, -0.01108581f, -0.15266241f, 0.05660393f, -0.12727942f, -0.02835081f, -0.13076046f, -0.10397306f, 
    -1.11821413f, 0.40755874f, -0.06837726f, 0.05713996f, -0.10721881f, -0.03820234f, 0.11137126f, 0.10262319f, 
    -0.00753741f, 0.05972781f, -0.09063564f, 0.07126042f, -0.15566263f, -0.02255358f, 0.37881032f, 0.04922421f, 
    -0.12104118f, -0.04365998f, 0.10619242f, 0.08812504f, 0.08585397f, 0.12625891f, -0.07139482f, -0.21498789f, 
    -0.43803945f, -0.15715812f, 0.10065155f, -0.02958822f, -0.06529503f, 0.19113502f, -0.04988656f, -0.06805234f, 
    0.01733123f, -0.00977372f, -0.05882957f, -0.22375254f, 0.55017263f, 0.13077821f, -0.14969438f, 0.15249585f, 
    -0.05706939f, 0.14151810f, -0.04367846f, -0.07187163f, 0.03930641f, -0.07858634f, -0.02483040f, -0.06166022f, 
    -0.06448801f, 0.49986017f, 0.06989586f, 0.22726904f, -0.24814622f, -0.02064731f, 0.27408123f, -0.20972548f, 
    -0.05281379f, -0.28606656f, -0.07106718f, -0.07796546f, 0.40365624f, -0.34587878f, 0.06770667f, 0.08306497f, 
    0.21661510f, 0.25496283f, -0.09107210f, 0.24206027f, 0.09324723f, -0.14087175f, 0.04210462f, -0.01270906f, 
    0.10958923f, -0.13640408f, 0.17061497f, 0.01505006f, 0.19544695f, 0.05487919f, -0.14093482f, -0.01033224f, 
    -0.07298332f, 0.23344459f, -0.00358784f, 0.11327440f, -0.42115897f, -0.42238066f, 0.05965272f, -0.36543727f, 
    -0.05299702f, 0.06804271f, 0.09860741f, -0.05931872f, 0.06423809f, 0.04084800f, 0.10712902f, 0.03494693f, 
    0.25595325f, -0.06292601f, 0.03981582f, -0.08737650f, -0.40318641f, -0.01985791f, 0.24744195f, 0.06917018f, 
    -0.24350236f, -0.07286757f, 0.22798206f, 0.01167632f, -0.07860401f, -0.05028975f, 0.34690866f, 0.25345227f, 
    0.10510331f, -0.10653012f, 0.17928678f, -0.09737284f, 0.00529507f, 0.06806763f, 0.07169560f, 0.08626606f, 
    0.36290616f, -0.16673349f, -0.21927497f, -0.09381478f, 0.01509736f, 0.24981196f, -0.34422007f, -0.15185399f, 
    -0.05251083f, -0.00228297f, 0.00684509f, -0.20319743f, -0.08228648f, -0.26541784f, -0.10553018f, -0.19924900f, 
    0.02221981f, 0.12640336f, -0.23283476f, -0.21240313f, -0.13899466f, -0.06144936f, 0.15911897f, 0.44051844f, 
    -0.19254868f, 0.05714784f, 0.17878978f, 0.19041127f, 0.39414394f, -0.06228618f, -0.16648072f, -0.18924937f, 
    -0.11789450f, 0.13574705f, -0.22111188f, -0.09930420f, -0.80173159f, -0.24818403f, -0.52053922f, -0.09867104f, 
    0.08882790f, 0.09543882f, 0.03601185f, 0.12501484f, 0.03773717f, -0.04491257f, 0.09651798f, -0.00923521f, 
    -0.11917111f, 0.13571133f, 0.09116185f, -0.23946947f, 0.10037680f, -0.10941365f, 0.13540025f, 0.13183217f, 
    0.10477955f, -0.16358776f, 0.02692600f, 0.08785187f, 0.01335439f, -0.04019133f, -0.07056660f, -0.35823402f, 
    -0.21313940f, -0.22552258f, -0.00057239f, 0.04564691f, 0.34812754f, 0.03589089f, 0.13211367f, -0.01262954f, 
    -1.11477172f, 0.37437576f, -0.43648911f, -0.19455670f, 0.27610025f, 0.07740925f, -0.02799931f, -0.34120280f, 
    -0.05034772f, 0.19632587f, -0.17534120f, -0.17699090f, -0.06262233f, 0.10057934f, 0.04072417f, 0.19871290f, 
    -0.18821377f, 0.11002734f, 0.04051247f, -0.04628233f, 0.03073880f, -0.11904929f, 0.16227424f, 0.18055865f, 
    0.50948137f, 0.24989310f, -0.07737041f, -0.04777675f, 0.06218831f, 0.00654619f, 0.15803911f, -0.27118191f, 
    0.06421365f, 0.01070794f, 0.10952105f, 0.17863056f, -0.15716903f, 0.08374045f, 0.36682552f, -0.48228747f, 
    0.10750825f, 0.01852040f, -0.01400791f, -0.11573584f, -0.02775381f, -0.11617120f, -0.03805601f, 0.06943003f, 
    -0.30964634f, -0.36245632f, -0.07566280f, 0.04261176f, -0.03377596f, -0.13407587f, -0.00407371f, 0.05717753f, 
    -0.09251468f, 0.05143285f, -0.14802757f, 0.13510139f, -0.49438292f, -0.23176828f, -0.11378761f, 0.42534003f, 
    0.17672302f, 0.03037244f, -0.01107121f, -0.01710068f, 0.05711646f, 0.09376246f, 0.01523237f, 0.03255688f, 
    0.18483378f, 0.02683422f, 0.11223897f, 0.17861165f, -0.07569464f, 0.26635215f, 0.15868080f, 0.04158918f, 
    -0.27524158f, -0.36695737f, 0.05081019f, -0.40356359f, 0.22096652f, 0.09698773f, 0.23202421f, 0.15908059f, 
    -0.00618643f, -0.10613863f, -0.11124723f, 0.15935674f, -0.04439999f, -0.05166500f, 0.07036124f, 0.06193817f, 
    0.16783173f, 0.16491403f, -0.12839180f, -0.43444607f, 0.16944635f, -0.02700891f, -0.00076213f, -0.28001553f, 
    0.01379720f, -0.06606992f, -0.08349202f, 0.05208250f, -0.31622609f, 0.43862033f, 0.18785991f, -0.06369106f, 
    -0.38096744f, 0.11545402f, 0.14859834f, 0.19920811f, -0.00558520f, 0.05732861f, -0.13690856f, 0.12227695f, 
    -0.39170539f, 0.07345921f, -0.18839419f, -0.12081109f, -0.05656535f, 0.03001437f, 0.37068513f, -0.09910915f, 
    -0.03408886f, 0.02694759f, -0.17281036f, 0.12926728f, -0.06310779f, 0.33184347f, -0.37083468f, -0.14590962f, 
    -0.05336361f, -0.06087918f, 0.08874351f, 0.12113322f, 0.02569152f, 0.03231762f, -0.10116374f, -0.11112908f, 
    0.13366455f, -0.24410254f, -0.06010122f, 0.62005025f, -0.20988593f, -0.19622844f, -0.10895157f, -0.14799862f, 
    0.08133739f, -0.01748764f, 0.23559193f, 0.17919643f, -0.27078569f, -0.28176203f, -0.05745186f, -0.55926174f, 
    -0.09645146f, 0.02508709f, -0.07002529f, -0.39047772f, -0.04451593f, -0.00950881f, 0.12844744f, 0.09364166f, 
    0.53829193f, 0.02350421f, 0.09304394f, -0.03242562f, 0.05532457f, 0.09711500f, 0.22954716f, -0.09180013f, 
    0.16239782f, 0.02212586f, 0.11714721f, -0.18474919f, -0.12861334f, 0.17076689f, 0.15784067f, -0.06273705f, 
    0.14058949f, 0.14259376f, -0.17251776f, -0.17769340f, -0.06978361f, -0.09159919f, 0.07103197f, -0.06881113f, 
    -0.04394716f, -0.71995419f, 0.11557026f, -0.19244701f, -0.08703399f, 0.00175407f, 0.11570972f, 0.26059064f, 
    -0.11766104f, 0.05921201f, 0.15248415f, 0.12158249f, 0.16490656f, 0.32229945f, 0.23266451f, -0.62275028f, 
    0.13822821f, -0.14460567f, -0.07691441f, 0.20600156f, -0.15425223f, 0.26361269f, -0.23270065f, 0.18349154f, 
    -0.71720392f, -0.04101336f, -0.46304870f, 0.42438918f, 0.13226129f, -0.07042179f, 0.03459707f, 0.27748129f, 
    0.08816521f, 0.01515445f, -0.01419975f, -0.42237180f, -0.21415839f, 0.14442082f, 0.25284988f, -0.11474610f, 
    0.04452720f, 0.13680845f, 0.08511063f, 0.03908936f, 0.07364058f, 0.04384701f, 0.13226621f, -0.25015911f, 
    0.16624513f, 0.04831259f, -0.15836181f, -0.32583147f, -0.12738042f, -0.04946972f, -0.29604557f, 0.06303030f, 
    -0.02189815f, -0.15156998f, 0.03479531f, -0.18131773f, -0.67239511f, 0.24018325f, -0.12967281f, -0.44653666f, 
    -0.12944776f, -0.23389716f, -0.14698139f, -0.18330491f, -0.19325358f, 0.13558257f, -0.13584037f, -0.30000958f, 
    0.02795846f, 0.23840196f, 0.05982897f, 0.06054729f, -0.08262356f, -0.15015556f, -0.18629594f, -0.09249879f, 
    0.06033405f, 0.11887299f, 0.21151108f, 0.46289024f, -0.06033219f, 0.37708366f, 0.08271836f, 0.36688566f, 
    0.08674825f, 0.26981574f, 0.13932683f, -0.02827631f, 0.05690918f, -0.08358140f, -0.15436739f, -0.11694139f, 
    -0.08588597f, -0.33023462f, -0.34004039f, 0.03592126f, 0.01111623f, -0.25448799f, -0.08070718f, -0.06402858f, 
    -0.10850827f, 0.12871128f, -0.20883518f, -0.09242476f, 0.17414063f, 0.23926608f, -0.12001754f, -0.24735820f, 
    0.00482976f, 0.07166015f, -0.06737243f, -0.23037405f, -0.21915789f, 0.00896001f, -0.11993792f, 0.03921928f, 
    0.55996561f, 0.31081325f, -0.06880431f, 0.27633440f, 0.16250201f, 0.23070453f, 0.27604559f, 0.29275426f, 
    -0.03561159f, 0.14720929f, -0.10690036f, -0.06071967f, -0.11065171f, -0.06014363f, 0.25882003f, -0.08370271f, 
    -0.01144459f, 0.00233299f, -0.05240597f, -0.12001237f, -0.05880305f, -0.09509610f, -0.14516971f, -0.07577570f, 
    0.04409280f, 0.38364792f, -0.14259373f, 0.43517622f, 0.24379998f, 0.02895128f, 0.00579295f, 0.09968621f, 
    -0.09361549f, -0.02454650f, 0.10208108f, -0.18379676f, 0.35600385f, 0.43952560f, 0.25006920f, 0.23347294f, 
    0.01119213f, 0.06204633f, 0.16428271f, -0.09449952f, -0.10651249f, 0.13398109f, -0.13310216f, -0.09911348f, 
    0.32896134f, -0.52264172f, 0.32859293f, -0.28965482f, -0.09913545f, -0.10941835f, -0.13067837f, -0.07593631f, 
    -0.02316784f, 0.08364180f, -0.10425705f, -0.00114045f, -0.10860578f, 0.08802996f, -0.11572123f, 0.03480916f, 
    -0.18358773f, 0.10912269f, -0.17301814f, -0.03329362f, -0.09539504f, -0.00248600f, -0.04021219f, -0.16570537f, 
    0.07211228f, -0.04288063f, 0.23959053f, 0.09081685f, -0.00399881f, 0.02781237f, 0.04872841f, -0.05109024f, 
    -0.11598884f, -0.01174401f, -0.06813090f, 0.08831123f, -0.33771595f, -0.50331879f, -0.41644242f, -0.04003897f, 
    -0.05895852f, -0.06161856f, 0.05072116f, -0.16337429f, -0.05996109f, -0.05742313f, 0.14077607f, 0.06973036f, 
    -0.49843210f, 0.42265940f, -0.05652517f, -0.33095694f, -0.03998381f, 0.06251986f, 0.06433169f, -0.10132450f, 
    -0.00071335f, 0.03609630f, -0.08273634f, -0.20716296f, -0.15724507f, 0.38777032f, 0.14506103f, -0.56154174f, 
    -0.00919350f, 0.01689449f, -0.02989358f, -0.25606403f, -0.12535352f, -0.20162702f, -0.12000944f, -0.27801552f, 
    -0.15839010f, 0.53663760f, -0.58802497f, 0.28354177f, -0.43339038f, 0.07194713f, 0.05789702f, -0.06987301f, 
    -0.10655954f, 0.12423726f, -0.10907762f, -0.42566723f, 0.03708072f, 0.37024119f, 0.06704298f, 0.56732249f, 
    0.13649160f, 0.04065128f, 0.09720170f, -0.04407494f, -0.12816684f, -0.06949840f, 0.02064440f, -0.17984796f, 
    0.04534342f, 0.08062933f, -0.18370001f, 0.15562148f, -0.06662270f, -0.13109820f, -0.05463479f, -0.07560056f, 
    0.02249279f, -0.08145371f, -0.10410810f, 0.05282313f, -0.39830711f, -0.17698207f, -0.01313522f, 0.07902599f, 
    -0.14050560f, -0.07790515f, -0.24276415f, -0.06348191f, 0.04906530f, -0.09058125f, 0.17162928f, -0.14209165f, 
    -0.01593500f, -0.08589799f, -0.45550525f, 0.04382961f, -0.08474397f, -0.07805030f, 0.06104141f, -0.02819460f, 
    0.27077857f, 0.02995030f, 0.15783235f, -0.21647048f, 0.19251789f, 0.12873293f, 0.28876081f, 0.28231311f, 
    0.15538217f, -0.01532942f, -0.20477529f, -0.23954181f, 0.00637936f, 0.10677478f, -0.02266667f, -0.20982568f, 
    -0.29969734f, 0.27023324f, 0.05105352f, -0.07368922f, -0.29311869f, 0.33149949f, -0.23075156f, 0.24113643f, 
    0.06538650f, -0.14751154f, 0.01318700f, -0.25829536f, -0.65463650f, -0.12950467f, 0.05403632f, -0.38838163f, 
    -0.07127916f, 0.01870583f, -0.15430862f, -0.17737488f, -0.05436610f, -0.12082316f, -0.00249227f, 0.14973289f, 
    -0.33102262f, 0.38259372f, -0.47288424f, -0.48233324f, 0.08296751f, -0.03323093f, -0.59925437f, -0.07517377f, 
    0.02767888f, -0.09902734f, 0.07288586f, 0.19032076f, -0.06491461f, 0.09104525f, 0.42244148f, 0.06774592f, 
    0.00578901f, -0.00871474f, -0.22532244f, 0.04017167f, 0.04205130f, -0.09545267f, 0.06777264f, -0.11827515f, 
    -0.01898991f, 0.11897152f, -0.23012061f, -0.21695213f, 0.00967988f, 0.17487822f, 0.20381902f, -0.25687811f, 
    0.13452393f, -0.11757432f, 0.08757403f, 0.24066612f, -0.35223401f, 0.31441158f, -0.08758226f, 0.03091993f, 
    -0.24975005f, -0.10945831f, 0.04236541f, -0.02211960f, 0.00672364f, -0.05612693f, -0.10865519f, -0.08088698f, 
    -0.41810906f, -0.01891213f, 0.25556922f, -0.00996095f, -0.10820344f, -0.17648792f, -0.06200586f, 0.15399440f, 
    -0.01287267f, 0.08124229f, -0.19294626f, -0.16982399f, 0.03177113f, -0.42283076f, -0.00575751f, 0.51127189f, 
    0.47426224f, 0.05084927f, -0.07571966f, -0.07116659f, -0.04995462f, -0.06943659f, 0.07814800f, 0.11887086f, 
    0.24340287f, 0.45687401f, -0.08420961f, 0.33066404f, -0.14115737f, 0.18044746f, -0.24992849f, -0.34695101f, 
    -0.01865863f, -0.08405667f, 0.07809722f, 0.29416823f, 0.34027436f, -0.34438899f, 0.25055873f, 0.16406932f, 
    -0.10844363f, -0.16442958f, -0.10868912f, -0.04519600f, -0.11050802f, 0.02247880f, -0.00187302f, -0.09808846f, 
    0.06808381f, 0.20291066f, 0.07365491f, 0.06168168f, -0.09363359f, -0.17450644f, -0.03085198f, 0.00953269f, 
    0.25639838f, -0.10770132f, -0.15287535f, 0.27024123f, -0.38777754f, 0.07265823f, 0.22245160f, -0.29736122f, 
    0.10090935f, -0.25758114f, 0.22774622f, 0.05650023f, 0.06474500f, -0.02536485f, 0.17308311f, 0.16275093f, 
    -0.27742964f, -0.10559724f, -0.26760012f, -0.10827310f, 0.11471637f, 0.13072962f, -0.23297378f, 0.01222024f, 
    0.02029048f, 0.04698677f, -0.19352211f, -0.11734304f, 0.11100210f, -0.25689521f, -0.53508586f, -0.30200940f, 
    0.25947183f, 0.00944509f, -0.23196280f, -0.01012097f, 0.01270716f, -0.06362206f, -0.25052285f, -0.08001945f, 
    -0.41936371f, 0.16772793f, -0.22643176f, -0.93438381f, 0.02615665f, 0.11833896f, 0.03088312f, -0.10785788f, 
    -0.01694479f, 0.01668013f, -0.11043826f, -0.02620886f, 0.02302197f, 0.14108887f, -0.11618605f, -0.61225843f, 
    0.22978970f, 0.20405149f, -0.33630159f, 0.00633734f, 0.06397136f, -0.12463859f, 0.16638522f, -0.18720578f, 
    0.06621653f, 0.56580198f, 0.42385039f, 0.01227582f, -0.01009771f, -0.05780708f, -0.15379541f, 0.19223189f, 
    0.13220806f, 0.07492951f, 0.09762517f, 0.17325538f, 0.10997005f, -0.39116591f, 0.03992923f, 0.20955463f, 
    0.03765143f, 0.11442721f, 0.09045684f, 0.01819447f, 0.08656218f, 0.13592437f, 0.02925900f, -0.22788931f, 
    -0.57317758f, -0.51425374f, 0.53830636f, -0.19439466f, -0.22696231f, 0.15282233f, 0.22394530f, 0.25874037f, 
    0.04830850f, -0.08300175f, 0.03626926f, -0.22914837f, -0.57934701f, -0.61473155f, 0.11911241f, 0.08575725f, 
    0.09160871f, -0.17646591f, -0.03323115f, 0.07573720f, -0.07746372f, 0.19233246f, -0.24130875f, 0.02051242f, 
    -0.09485052f, 0.00576314f, 0.02859121f, 0.08575258f, -0.04398024f, -0.19551463f, -0.08447140f, 0.00784673f, 
    -0.14940532f, 0.02241668f, 0.16993752f, -0.12105687f, -0.68278915f, 0.52603042f, -0.05007709f, 0.70115930f, 
    0.01558228f, 0.21076746f, -0.32019275f, 0.16144490f, -0.17844748f, -0.06174320f, 0.12225224f, 0.07936992f, 
    0.63952529f, -0.28255531f, -0.25139686f, -0.11658604f, 0.16851367f, -0.12045056f, -0.05062974f, -0.19577783f, 
    0.01101996f, -0.24510339f, -0.07774603f, -0.00671974f, -0.48359811f, -0.05377247f, 0.04272131f, -0.31153563f, 
    0.05218147f, 0.08043257f, -0.06708975f, -0.08155604f, 0.09626106f, -0.16124326f, -0.07467294f, -0.18931581f, 
    0.12454767f, -0.08519065f, 0.06099449f, 0.36915481f, 0.12252522f, 0.30426586f, 0.13584921f, -0.01678406f, 
    0.09500622f, -0.07264300f, -0.17627537f, 0.08960292f, -0.94524223f, 0.25389171f, 0.01318910f, 0.00877128f, 
    -0.07966615f, -0.31396782f, 0.16969688f, -0.00400198f, 0.02479360f, 0.13449878f, 0.00440786f, 0.09625008f, 
    -0.43281454f, 0.43133044f, 0.00318349f, -0.31538036f, 0.19650756f, 0.23506829f, 0.24621484f, -0.25616536f, 
    -0.07591818f, 0.04312719f, 0.24198499f, -0.09038846f, -0.05388482f, -0.26335052f, 0.01952646f, 0.05927720f, 
    0.16184382f, -0.02836497f, -0.15567918f, -0.06632410f, -0.15952846f, -0.08038012f, -0.08552765f, -0.05920094f, 
    -0.38823992f, 0.13881759f, 0.09277952f, 0.21273553f, -0.15104602f, 0.15524943f, 0.11959565f, 0.00471288f, 
    0.04887507f, 0.06764335f, 0.09123988f, 0.13704678f, -0.10252181f, 0.40467724f, 0.42717454f, 0.00589375f, 
    -0.25027061f, 0.22974995f, 0.01048643f, 0.00018380f, 0.02562984f, 0.04537351f, 0.15881708f, -0.05225120f, 
    0.43647963f, -0.01644936f, 0.00345658f, -0.10134894f, -0.03764930f, 0.07361402f, 0.15174916f, 0.08675572f, 
    0.23872581f, 0.19040972f, 0.08489919f, 0.02183681f, -1.53221524f, -0.92059481f, -0.16997190f, -0.68634909f, 
    0.18715465f, -0.03804654f, -0.06665231f, -0.04303543f, 0.07602538f, -0.01473210f, -0.14252818f, 0.07126630f, 
    -0.12915739f, -0.08120327f, -0.04066243f, -0.09400009f, -0.13102435f, 0.05452792f, -0.07296994f, 0.02038356f, 
    0.17377959f, -0.22738583f, -0.27043313f, -0.47180310f, 0.39332023f, 0.26413137f, 0.03821857f, -0.25769100f, 
    0.08047622f, -0.03461793f, 0.11315206f, 0.10476440f, 0.02829176f, -0.26838553f, 0.14636734f, 0.09080390f, 
    -0.14170335f, -0.51136065f, 0.08838825f, -0.14428751f, -0.03794580f, 0.02017425f, -0.16447258f, 0.05441700f, 
    -0.00931360f, 0.22636449f, -0.32083222f, -0.20349529f, 0.30967870f, 0.08643857f, -0.09369741f, -0.30947950f, 
    -0.09782993f, 0.04060857f, -0.09138833f, -0.01590799f, 0.11827201f, -0.07420073f, -0.01740974f, 0.05752876f, 
    0.40751362f, 0.19567654f, -0.05527045f, 0.21020810f, 0.00012685f, 0.29308447f, 0.20200880f, 0.07740606f, 
    -0.03374480f, -0.20104192f, 0.03670290f, -0.04399449f, -0.16775686f, -0.15765609f, -0.05449684f, 0.27858594f, 
    -0.00667481f, 0.11171068f, 0.32576600f, 0.05902398f, 0.19028388f, -0.00250202f, 0.03052687f, 0.07970978f, 
    0.43991861f, -0.02835273f, 0.02870909f, -0.08866806f, -0.14236017f, -0.05171311f, 0.06979550f, 0.06008035f, 
    -0.30789638f, -0.07388224f, -0.17072980f, 0.01313925f, -1.00678611f, -0.27235007f, -0.42400903f, -0.82395440f, 
    0.07254461f, -0.03731513f, -0.04298569f, -0.06112222f, -0.20134585f, 0.04611960f, 0.17396729f, 0.02238405f, 
    -0.28775910f, -0.27473184f, 0.10626185f, 0.03733139f, 0.23337168f, 0.00580962f, 0.05698379f, -0.03120849f, 
    0.17441511f, 0.20247781f, 0.12230870f, 0.27213019f, -0.26996589f, -0.51873690f, 0.02433487f, 0.15679100f, 
    -0.07812957f, -0.21996832f, 0.03576036f, 0.32513741f, 0.02675710f, 0.21450786f, -0.00672870f, 0.25200877f, 
    -0.92358613f, -1.02785003f, 0.00705849f, 0.02668796f, 0.17719218f, 0.13116147f, 0.18543337f, 0.02765960f, 
    0.09596279f, 0.19162637f, 0.22801960f, 0.22532876f, 0.31467345f, 0.03718522f, 0.12268982f, -0.06014060f, 
    -0.15391536f, 0.11818030f, 0.05031865f, -0.17546204f, 0.14538553f, 0.01561852f, 0.29008436f, 0.19052494f, 
    0.01891698f, -0.04145259f, 0.17041901f, 0.02518156f, -0.09026792f, 0.12766768f, -0.10199247f, 0.28335422f, 
    0.12025078f, -0.20103192f, -0.23096816f, -0.30385429f, -0.51107872f, -0.09913442f, 0.33330053f, 0.38194257f, 
    0.42583692f, -0.18681942f, -0.10414033f, -0.26633260f, -0.03693320f, -0.12690853f, -0.12654626f, 0.20260499f, 
    0.47623491f, -0.07832327f, -0.24055752f, 0.29531622f, 0.19291583f, -0.09555056f, 0.08740700f, -0.07024375f, 
    0.01889669f, -0.08495902f, -0.01960806f, 0.14880358f, 0.15537420f, -0.72063959f, -0.24391040f, -0.13067813f, 
    0.10041484f, -0.04368735f, -0.06114773f, 0.20087098f, 0.14770715f, -0.17169255f, 0.03197524f, -0.11020769f, 
    -0.14493473f, -0.07988334f, 0.01789452f, 0.11754297f, -0.15545399f, -0.19804820f, -0.02336935f, -0.03514393f, 
    -0.20094736f, -0.14124483f, -0.01616849f, -0.05356533f, -0.01046304f, 0.27465457f, -0.20544896f, 0.23569703f, 
    -0.32469073f, -0.10402589f, 0.32021546f, -0.21339384f, -0.15630007f, -0.07510646f, -0.01583938f, -0.22354129f, 
    -0.04581466f, -0.45045024f, -0.26474875f, 0.35756025f, -0.07889026f, 0.14279243f, -0.19852267f, -0.26494122f, 
    0.06693041f, 0.13883632f, -0.09803096f, 0.07989922f, -0.44231635f, 0.29404563f, -0.07186966f, 0.07137313f, 
    -0.02549185f, -0.07028063f, 0.13890059f, -0.17443077f, 0.00535249f, 0.07106967f, -0.06524711f, -0.09176114f, 
    -0.58823168f, 0.55100667f, -0.17413646f, -0.12951016f, 0.16823390f, -0.06104470f, 0.11242271f, -0.00515464f, 
    -0.24666327f, 0.08081984f, 0.12109721f, 0.00608884f, 0.34690645f, 0.25485468f, -0.20340012f, 0.24119797f, 
    0.18802801f, -0.40487474f, -0.01043778f, 0.14178753f, 0.11101557f, 0.05924920f, 0.00327299f, 0.01964435f, 
    -0.14614280f, 0.15195529f, 0.00566708f, 0.00264481f, -0.06609623f, -0.03242393f, 0.06020060f, -0.13431072f, 
    0.04443075f, -0.13161001f, 0.26648787f, -0.07454123f, 0.83401608f, -0.04945134f, -0.41300982f, -0.09667363f, 
    -0.02750153f, -0.07395492f, -0.07383084f, -0.13594417f, 0.09173568f, 0.07926685f, -0.18832779f, -0.07851376f, 
    -0.39246204f, -0.24929412f, 0.04670749f, -0.15293604f, 0.19920540f, 0.11813144f, 0.20957699f, 0.32485691f, 
    0.00933118f, -0.07316817f, -0.02266349f, -0.15412158f, -0.03460939f, -0.31048456f, 0.22165310f, -0.61783099f, 
    -0.05428115f, -0.07996046f, 0.12965347f, 0.01623240f, 0.01466935f, 0.41359007f, -0.10933729f, 0.04146465f, 
    -0.34228975f, -0.11497051f, -0.07470639f, -0.21399260f, 0.23530886f, -0.06216340f, -0.01639259f, 0.00288453f, 
    0.23901296f, 0.09701095f, -0.15463285f, 0.18122034f, 0.38267547f, 0.10431097f, -0.31936455f, -0.19332305f, 
    -0.59254277f, -0.00426605f, -0.34392065f, -0.16993468f, 0.05434044f, -0.18457103f, -0.05308827f, -0.21829362f, 
    0.14040561f, 0.29035458f, -0.33050802f, 0.08155433f, -0.12522851f, 0.02712642f, 0.07643727f, -0.04156734f, 
    0.23259646f, 0.20636758f, 0.18427823f, 0.11436874f, 0.85217762f, 0.05709061f, -0.02784747f, -0.40118143f, 
    -0.01272751f, -0.07328898f, -0.14247751f, -0.10497469f, 0.09121189f, 0.12143651f, 0.14586377f, 0.22553593f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.24843124f, 0.00453401f, -0.14286777f, 0.11943015f, -0.03241067f, 0.02411545f, 0.11179343f, -0.12854886f, 
    -0.05886490f, 0.03057799f, 0.14267194f, -0.04548410f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
