#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.21382803f, -0.14996338f, 0.03536714f, 0.55365610f, 0.55737919f, 0.49162030f, 0.18254949f, 0.24441962f, 
    0.24421544f, 0.20955588f, 0.31520581f, 0.12412541f, 0.09734676f, -0.18267605f, 0.27646625f, 0.08902492f, 
    -0.25001767f, 0.08185545f, -0.31628785f, -0.53220147f, -0.23569675f, 0.33104333f, 0.05555671f, -0.04585454f, 
    0.00521137f, 0.44133419f, 0.23385015f, -0.33605933f, -0.76298720f, -0.55049598f, -0.53519499f, -0.45341411f, 
    0.32900870f, 1.09206724f, 0.12497329f, 0.17314819f, -0.30692178f, 0.56831461f, 0.02451422f, 0.16299503f, 
    -0.45483914f, 0.27533293f, 0.44436449f, -0.46133593f, -0.35121295f, -0.11593353f, 0.20259190f, 0.16178690f, 
    -0.13332669f, 0.20006311f, -0.27928668f, -0.35346141f, -0.27701199f, 0.92266923f, -0.36667845f, 0.26164716f, 
    0.69678599f, -0.72378284f, 0.58523375f, -0.47145650f, -0.21896847f, -0.04685615f, -0.03051076f, 0.04519890f, 
    0.11005851f, -0.25234991f, -0.30861104f, 0.31974795f, 0.18595777f, 0.02354363f, -0.33480814f, 0.18603052f, 
    0.24993247f, 0.02302025f, -0.43951517f, 0.65740758f, 0.62121916f, 0.37110645f, 0.37171876f, -0.23617996f, 
    0.10019374f, -0.18995266f, -0.07241105f, 0.41841221f, -0.18793833f, -0.08856557f, -0.05850436f, -0.17783147f, 
    0.37912491f, -0.26442048f, -0.18063314f, 0.10669550f, -0.22849755f, 0.15195592f, 0.03246887f, -0.39097795f, 
    -0.30884829f, -0.36492339f, -0.29055971f, -0.62408680f, -0.64935243f, -0.94466698f, 0.36100829f, 0.09924026f, 
    -0.33362946f, 0.56258392f, -0.25701332f, -1.07956934f, -0.57075596f, 0.03848914f, -0.21043272f, 0.49827451f, 
    -0.10835986f, -0.22202122f, -0.27254188f, 0.00069583f, 0.42659959f, 0.24339242f, 0.23824874f, 0.46986720f, 
    -0.04793536f, 0.12743966f, -0.30376837f, -0.06170599f, -0.25972399f, -1.07852721f, -0.75264543f, -0.47674176f, 
    -0.66253871f, -0.52578759f, 0.81918621f, 0.41145328f, -0.16776642f, -0.08351128f, 0.55381453f, -0.39997947f, 
    -0.29317212f, -0.15722984f, 0.52985775f, -0.06272876f, -0.10415096f, 0.02437254f, -0.22767048f, -0.23437849f, 
    -0.74407488f, -0.28658459f, -0.03800268f, 0.03622570f, -0.34153900f, -0.35859239f, 1.32620549f, -0.94336385f, 
    -0.37307522f, 0.30736133f, -0.04195354f, 0.57273501f, 0.34691846f, 0.24337496f, 0.02335126f, 0.20068313f, 
    -0.47658461f, 0.36371851f, -0.58077931f, -0.35763133f, -0.20473768f, -0.20142214f, 0.00575152f, 0.24223651f, 
    -0.18897149f, -0.19473097f, 0.17521825f, -0.22404505f, 0.00548714f, -0.16292565f, 0.37909395f, 0.32827362f, 
    0.48419338f, 0.54821277f, 0.09491459f, 0.00310816f, -0.40124589f, -0.88272476f, -0.28453055f, -0.23445432f, 
    -0.33012572f, -0.26471668f, -0.25989193f, -0.46233824f, -0.35952806f, 0.01131635f, 0.17386186f, -0.45000499f, 
    0.04440739f, 0.75121582f, -0.33225501f, 0.00274561f, -0.28121746f, -0.04822059f, 0.28602022f, 0.19525687f, 
    -0.54959834f, -0.78667033f, 0.63142985f, -0.16498108f, 0.54473531f, -0.14146754f, 0.20343916f, 0.11629386f, 
    -0.54905206f, -0.59525698f, -0.07621197f, -0.26705185f, 0.04599728f, -0.34872243f, -0.07860576f, 0.14005660f, 
    -0.16283177f, 0.46488416f, -0.08530858f, 0.30532685f, -0.23893556f, -0.06600589f, -0.33527410f, -0.26901031f, 
    -0.03126667f, 1.10701501f, -0.76191485f, -0.83260465f, -0.79157948f, -1.19743490f, 0.74666214f, 0.22449990f, 
    0.32460055f, 0.17147674f, 0.24485618f, 0.26769021f, 0.18763028f, 0.08599568f, -0.12629540f, -0.11406781f, 
    0.22524354f, -0.19668905f, 0.24082921f, -0.28809386f, -0.07462364f, 0.01364016f, -0.19598730f, -0.30391958f, 
    0.03377672f, 0.27962953f, 0.47797230f, 1.03553081f, 0.24672741f, -0.47230256f, -0.42163032f, -0.43970731f, 
    0.28793058f, 0.37864614f, -0.34029749f, -0.47758698f, -0.42406073f, 0.23607543f, 0.40975618f, -0.36642852f, 
    -0.26527900f, 0.11772644f, 0.08685049f, -0.39618009f, 0.01664939f, 0.39531478f, 0.26212460f, 0.11360839f, 
    -0.35504401f, -0.20482694f, 0.50134313f, 0.35410655f, 0.69662040f, -0.70317155f, -0.51450169f, -0.66056108f, 
    -0.06306492f, -0.34544134f, 0.63743627f, -0.60122436f, -0.46689937f, 0.40173012f, 0.57715762f, 0.26919568f, 
    0.21152741f, -0.00047183f, 0.20442124f, -0.34471655f, -0.21527533f, -0.26833832f, -0.49297169f, 0.15085082f, 
    0.10180107f, -0.10402874f, -0.36727306f, -0.47886196f, -0.06403668f, -0.03001260f, -0.55864018f, -0.45478806f, 
    -0.26164663f, -0.41293865f, -0.13572234f, 0.44385752f, -0.24436077f, -0.42773360f, 0.34628364f, -0.37026826f, 
    0.48686007f, -0.41809025f, -0.22881995f, 0.17444614f, -0.17370929f, -0.18258861f, -0.35657030f, -0.52320701f, 
    0.07097001f, 0.43569049f, 0.44919518f, 0.41296825f, 0.74646300f, -0.33069456f, -0.24768275f, -0.55756176f, 
    -0.23659524f, -0.26525640f, -0.43523175f, -0.53439689f, -0.57574648f, -0.65975058f, 0.08187050f, 0.13579579f, 
    -0.04952904f, -0.34595314f, -0.63721788f, 0.63611436f, -0.19587758f, -0.13079660f, -0.21782757f, -0.18656446f, 
    -0.35175192f, -0.33162087f, -0.21954226f, 0.04487580f, -0.01031724f, -0.61337054f, -1.24343574f, 0.00825899f, 
    -0.55887979f, -1.10095668f, -0.04952336f, 0.31917384f, -0.39056781f, -0.57766426f, -0.40597078f, -0.13256863f, 
    -0.26010859f, -0.45362324f, -0.37217179f, -0.50391370f, -0.42143178f, 0.22411701f, -0.20747061f, 0.02151701f, 
    -0.12771061f, -0.21473953f, -0.10892349f, 0.19981720f, 0.03682854f, -0.27221826f, 0.00561920f, 0.27926347f, 
    0.94074166f, 0.77931362f, -0.82842100f, -0.94717199f, -0.68206084f, -0.03189902f, -0.21010862f, -0.48921812f, 
    -1.02555549f, 0.19517323f, -0.15791410f, -0.19726112f, 0.33448145f, 0.57282531f, 0.15616384f, -0.37516320f, 
    -0.41516706f, -0.48108897f, -0.35200340f, -0.23573171f, -0.30436337f, 0.08115126f, 0.05558257f, -0.27987030f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.02043387f, 0.33532467f, 0.39126033f, 0.19196402f, 0.16506159f, -0.12023580f, 0.36623219f, 0.14071685f, 
    0.18881202f, 0.46149653f, 0.45100820f, 0.16003224f, 0.30890232f, 0.23018596f, 0.04372613f, -0.10792294f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.20757705f, 0.27548954f, -0.03040530f, -0.30635819f, -0.04429022f, -0.22373447f, -0.15432273f, 0.06063524f, 
    -0.03124524f, 0.07506832f, 0.04197702f, -0.13013454f, 0.25647381f, 0.22096613f, -0.29081106f, 0.20090686f, 
    0.03704829f, 0.07910316f, -0.00605338f, -0.04924664f, 0.04582348f, 0.02210007f, -0.19566138f, 0.12434816f, 
    -0.40070146f, 0.43717614f, -0.06925535f, 0.07111974f, -0.04555894f, 0.13105507f, -0.14059228f, 0.08750860f, 
    0.19236517f, -0.01853996f, 0.12877260f, 0.14272685f, -0.39465263f, -0.03562057f, 0.12314637f, -0.06597418f, 
    -0.12365881f, 0.04675027f, 0.06357481f, 0.09277947f, 0.18024154f, -0.01786089f, 0.10747522f, 0.08312941f, 
    -0.32646644f, 0.06405638f, -0.25263271f, 0.24957205f, -0.06607646f, 0.20576511f, 0.10587925f, 0.00194645f, 
    -0.04628447f, -0.02677768f, -0.22166291f, 0.13613585f, 0.13432127f, -0.02822823f, -0.01736193f, 0.12072512f, 
    0.01923929f, 0.06346940f, 0.02726545f, 0.04898015f, 0.10974377f, 0.04718000f, 0.01165291f, 0.38288933f, 
    -0.69410872f, 0.45865977f, 0.45669776f, 0.03465451f, -0.05922437f, -0.06319702f, 0.10382745f, -0.09086455f, 
    -0.02061188f, 0.28661138f, 0.30294317f, 0.32391143f, -0.08137403f, -0.27795798f, 0.38536561f, 0.30949503f, 
    0.06137441f, 0.03058347f, -0.07190704f, 0.05412429f, 0.01053606f, -0.22124504f, 0.04257249f, -0.00503790f, 
    -0.08455436f, 0.26112953f, 0.02591890f, 0.14424339f, 0.10878894f, 0.15719259f, 0.08119558f, 0.16576594f, 
    0.13147716f, 0.21985120f, 0.01878858f, -0.00493627f, -0.77952331f, 0.26102746f, 0.19658631f, 0.48312277f, 
    0.04361586f, 0.07682029f, 0.26474270f, 0.03909719f, 0.06434387f, 0.22046170f, 0.10826438f, 0.02216257f, 
    -0.56112748f, 0.25558063f, 0.58606476f, -0.05790042f, 0.04154542f, -0.05522000f, -0.20856461f, 0.01708695f, 
    -0.41709232f, -0.07356041f, -0.02204139f, -0.07122938f, -0.40236634f, 0.15378430f, -0.05642727f, 0.11423035f, 
    -0.05055024f, 0.11534936f, 0.01594558f, 0.00085495f, 0.15680812f, 0.19843411f, 0.19840865f, -0.10837044f, 
    -0.13030462f, -0.12578796f, -0.10573177f, 0.05780398f, 0.06621432f, -0.10121217f, -0.12882604f, -0.02806500f, 
    -0.04514020f, 0.26748422f, -0.02257568f, -0.10076495f, -0.05474429f, -0.43566290f, -0.14409910f, 0.03943617f, 
    0.04381583f, 0.13647866f, 0.18188700f, 0.06612144f, 0.08834529f, 0.04684136f, 0.13360633f, 0.06600443f, 
    0.08436788f, -0.44926074f, -0.24314448f, -0.00743484f, 0.11431395f, 0.02997901f, 0.02191833f, 0.06599719f, 
    -0.06472803f, 0.01100369f, -0.07706423f, -0.06670593f, -0.08936160f, -0.20548724f, 0.16030666f, -0.05259166f, 
    0.17608400f, -0.03357802f, 0.09574968f, -0.11499575f, 0.09090564f, -0.09863134f, 0.12699841f, 0.07780608f, 
    0.09465343f, -0.15088210f, 0.16925596f, 0.34724978f, -0.06367952f, -0.11011557f, -0.01272570f, -0.35570484f, 
    0.09537597f, 0.05930650f, 0.04383089f, 0.03700279f, -0.40196168f, 0.12124264f, 0.18406816f, -0.42022121f, 
    -0.10415923f, 0.00469838f, 0.14504829f, -0.32333016f, 0.03802298f, 0.06098520f, 0.12392665f, 0.01875413f, 
    0.52819306f, -0.15917511f, -0.22212771f, -0.02191778f, 0.03031344f, -0.30179071f, -0.05216320f, 0.12921105f, 
    0.02194602f, 0.04693179f, 0.22929141f, 0.03743024f, -0.18294784f, -0.11976478f, -0.05759390f, 0.24793708f, 
    0.16502121f, -0.05110753f, 0.00549060f, 0.03066567f, -0.02877641f, -0.01001408f, 0.17773534f, 0.26936689f, 
    0.50130874f, -0.14478388f, 0.04633022f, -0.50085992f, 0.10580156f, 0.04260650f, -0.08042813f, 0.08681788f, 
    0.07974774f, 0.05811903f, 0.11392438f, 0.11770226f, 0.14031531f, -0.01139704f, 0.16052315f, 0.05934009f, 
    -0.01271734f, 0.01370346f, -0.04736264f, 0.06238794f, 0.17724535f, -0.09374350f, 0.18405403f, -0.02040491f, 
    0.35745084f, -0.42453876f, 0.18457566f, 0.08105971f, -0.20997563f, 0.05483798f, -0.16759370f, 0.03139212f, 
    0.04075014f, -0.13233928f, -0.08318028f, -0.19171825f, -0.00931564f, 0.26975003f, 0.01564761f, -0.01609365f, 
    -0.02520115f, -0.11452517f, -0.03523050f, 0.05751168f, 0.01452801f, -0.07078014f, 0.11289789f, -0.02749374f, 
    0.18072258f, -0.02622940f, -0.04086372f, -0.27183276f, 0.05904200f, -0.01371058f, 0.12355129f, 0.25465769f, 
    0.04226878f, -0.06590882f, -0.15171860f, -0.04732397f, 0.28628269f, 0.01224136f, 0.23249237f, -0.49307570f, 
    -0.03474440f, -0.09563399f, -0.05091628f, -0.17718939f, -0.03080701f, 0.02875462f, 0.06172879f, 0.12163512f, 
    -0.40894747f, -0.06438026f, -0.44788194f, 0.18812747f, 0.16070653f, -0.02931407f, -0.07887885f, 0.20808059f, 
    0.05796733f, -0.02172343f, -0.06075509f, 0.03364641f, -0.09575149f, 0.04114439f, -0.15558146f, -0.01641221f, 
    -0.12602776f, -0.08473823f, 0.08369614f, -0.23699351f, -0.01249398f, 0.13307884f, -0.03823549f, 0.16112041f, 
    0.05180910f, 0.23104131f, -0.00207658f, -0.12966253f, 0.05062612f, 0.16372390f, 0.08796600f, -0.09613519f, 
    -0.09989013f, -0.06780829f, -0.12124664f, -0.04264789f, 0.20789337f, 0.18615246f, 0.26412386f, -0.17610808f, 
    0.04669416f, -0.04325052f, 0.00412318f, 0.04630923f, 0.07658025f, 0.06430366f, -0.12303085f, 0.10803203f, 
    -0.09506379f, 0.37468272f, 0.12432376f, -0.12920378f, -0.10742436f, 0.21376698f, 0.10710900f, 0.14593877f, 
    0.06763192f, 0.02556279f, -0.06750894f, 0.23158173f, -0.14641404f, 0.15753230f, -0.25451955f, 0.06262437f, 
    -0.12532122f, 0.17909408f, -0.13827440f, 0.13856079f, -0.05437239f, 0.04637152f, -0.07189088f, 0.06719459f, 
    0.02675154f, 0.02093973f, 0.07782236f, -0.04094439f, 0.10279173f, 0.14848717f, 0.05774008f, 0.08192016f, 
    0.10496533f, 0.06357636f, -0.26407492f, -0.22863247f, -0.02893048f, 0.02490056f, 0.05618722f, -0.04635010f, 
    0.01495352f, 0.07220192f, -0.06267700f, 0.07592432f, 0.27024221f, 0.14001183f, 0.13685332f, -0.01927754f, 
    0.01481344f, -0.08918687f, -0.20682524f, 0.01743120f, 0.10660503f, -0.00234798f, -0.03114514f, 0.16259709f, 
    -0.24179228f, 0.01323739f, -0.01927770f, -0.16290738f, 0.10938308f, -0.02388603f, -0.01338372f, 0.05059543f, 
    0.03498751f, 0.03725354f, 0.02151021f, 0.03951885f, 0.10915603f, 0.14191024f, 0.00636772f, 0.19556689f, 
    0.16402735f, 0.09922899f, -0.15578811f, 0.02904448f, -0.03455987f, -0.30043364f, -0.12139005f, -0.48206681f, 
    0.11076687f, 0.08661650f, 0.01352065f, 0.08310995f, -0.16428246f, -0.28408027f, 0.13512880f, 0.30943802f, 
    0.04012198f, -0.08287087f, 0.03920627f, 0.12313088f, -0.65070504f, -0.11443109f, -0.01361949f, -0.52693945f, 
    -0.14891344f, 0.31348136f, 0.16988456f, -0.46620959f, 0.14865561f, 0.07140514f, 0.08790462f, 0.17250350f, 
    -0.04757538f, 0.07243063f, -0.03562050f, -0.30450386f, -0.30444899f, 0.18832001f, -0.39690971f, 0.06665561f, 
    -0.64733535f, 0.03709150f, 0.09126486f, 0.06689586f, 0.11262157f, 0.06814728f, 0.04151701f, 0.02990789f, 
    0.03450761f, 0.02425888f, 0.28496566f, 0.55910897f, -0.07167199f, -0.37599355f, 0.07413252f, -0.35103405f, 
    -0.03787411f, -0.27302420f, -0.06292626f, 0.01047651f, -0.27269644f, -0.14334686f, 0.10995031f, 0.08882895f, 
    0.15332387f, 0.04745616f, 0.07496376f, 0.09325369f, 0.12685271f, 0.39359602f, -0.00513386f, -0.03352163f, 
    0.06863952f, 0.12757502f, -0.08811329f, 0.04674224f, -0.10654937f, 0.14403196f, -0.14352286f, 0.19911411f, 
    0.24852733f, 0.16334924f, 0.02760025f, 0.07671683f, -0.01498044f, -0.15954159f, -0.02378935f, 0.18729383f, 
    0.02949337f, 0.06357469f, -0.04379148f, -0.15023333f, -0.07682943f, -0.29540548f, -0.11214602f, -0.13591741f, 
    0.19746280f, 0.14027894f, -0.12877521f, -0.13135566f, 0.13578849f, -0.13063914f, 0.25234270f, -0.07285011f, 
    0.10818455f, 0.05102142f, 0.03591943f, 0.06892582f, 0.07814027f, -0.10559687f, -0.04305188f, 0.10876764f, 
    0.07531155f, -0.11585195f, -0.30060577f, -0.17991221f, -0.43170992f, -0.10739112f, -0.19219813f, -0.00108012f, 
    0.18952337f, 0.26351443f, 0.16001202f, 0.13580224f, 0.00187794f, -0.24941319f, -0.51076448f, -0.42671910f, 
    -0.00818375f, -0.07977609f, 0.04714002f, -0.05129076f, -0.04646871f, -0.00134341f, -0.23858427f, 0.34979135f, 
    0.16210572f, 0.02819137f, -0.25792399f, -0.18235582f, 0.05911295f, 0.08291433f, 0.00597871f, -0.29645601f, 
    0.03281242f, -0.06683679f, -0.15921101f, 0.24103720f, -0.03838530f, -0.01847464f, 0.02193790f, 0.09646873f, 
    -0.10116609f, 0.14792466f, 0.19133691f, 0.16838971f, 0.19129187f, -0.22110245f, 0.10522625f, 0.05121611f, 
    -0.11805261f, 0.19867878f, -0.01554170f, 0.26529884f, 0.30099776f, 0.14615908f, -0.06488194f, -0.19185945f, 
    -0.29959187f, -0.06933057f, 0.26494983f, 0.51271963f, -0.13269663f, -0.03256609f, 0.09791762f, 0.20223193f, 
    0.18516822f, 0.10837570f, 0.05683206f, -0.00977662f, 0.14141868f, -0.08219545f, 0.13445240f, 0.10903509f, 
    0.06424855f, 0.08066458f, -0.00608126f, 0.00726420f, -0.13714042f, -0.02502358f, -0.21717151f, -0.14404471f, 
    0.00167218f, 0.35832325f, -0.05368953f, 0.08782054f, -0.05611418f, -0.09713720f, 0.31371951f, 0.06954142f, 
    -0.01747084f, 0.01110893f, 0.03326133f, 0.08480047f, -0.48489818f, 0.21494387f, 0.44204348f, -0.11157857f, 
    0.05448279f, 0.08045831f, 0.15510136f, -0.02422879f, -0.17506738f, 0.07885892f, 0.09133141f, 0.06143851f, 
    0.26144505f, 0.24002011f, -0.31976765f, 0.25829938f, -0.05670219f, -0.06120855f, 0.01241560f, 0.08420070f, 
    0.06615677f, 0.26840651f, -0.02973837f, 0.34838012f, 0.14157745f, -0.02623856f, -0.00248948f, -0.12890126f, 
    0.03323417f, 0.08651222f, 0.11567767f, -0.24268703f, 0.02098579f, -0.11640985f, 0.06708648f, 0.06348015f, 
    -0.04637548f, -0.12380740f, 0.19212377f, 0.09490427f, -0.04368266f, 0.11349452f, 0.25985184f, -0.13849849f, 
    0.03972761f, 0.08236440f, -0.03211570f, 0.06927305f, 0.58767724f, 0.03414822f, -0.35732859f, -0.02730684f, 
    0.09784728f, 0.07358979f, 0.05836377f, -0.14868009f, 0.05844946f, 0.09820081f, 0.03149549f, -0.09534393f, 
    0.60344553f, -0.30719423f, 0.16382368f, 0.08487514f, -0.10731712f, -0.13791619f, 0.05023364f, -0.02270451f, 
    -0.07866979f, -0.08984272f, -0.05773572f, 0.03591580f, 0.51252389f, -0.47325003f, 0.21175028f, -0.53630584f, 
    -0.17214847f, 0.02250864f, -0.05785052f, 0.03638587f, -0.20919086f, 0.09209342f, -0.05512427f, 0.07354771f, 
    0.01444961f, -0.07681312f, 0.22976013f, -0.31808794f, -0.09314652f, -0.07058508f, -0.00091066f, 0.07843328f, 
    -0.10129449f, -0.00738819f, 0.00893326f, -0.06212457f, 0.06213242f, 0.10869961f, -0.10595205f, 0.10302033f, 
    -0.07148561f, 0.09723010f, -0.03056563f, 0.08893718f, 0.11341581f, -0.17293487f, 0.14772314f, 0.02276097f, 
    0.21101220f, 0.45363501f, 0.22620955f, 0.27454877f, 0.25845441f, 0.21691760f, 0.12418275f, -0.05357892f, 
    -0.04612639f, 0.01922432f, 0.05722573f, -0.16407460f, 0.72036922f, -0.82624626f, 0.51125121f, -0.53445584f, 
    -0.14158460f, 0.13814151f, 0.01003803f, -0.10258146f, -0.11207460f, 0.03632716f, 0.06601737f, 0.04814523f, 
    -0.00650175f, 0.09432311f, -0.14343417f, -0.16707616f, -0.15684947f, -0.15323213f, -0.01789633f, 0.06457603f, 
    0.16310003f, 0.09321420f, 0.14135630f, 0.22528051f, -0.32125241f, -0.02709452f, -0.03485969f, 0.04812104f, 
    0.14635143f, 0.24339372f, -0.04817959f, -0.07996952f, -0.02869422f, 0.09876896f, 0.02941643f, 0.00558726f, 
    0.23797214f, -0.17946534f, -0.39583093f, 0.11739972f, -0.04846627f, -0.08613332f, 0.22244056f, 0.03803489f, 
    -0.05414291f, 0.16370432f, 0.10622199f, -0.23753031f, -0.09087504f, 0.06862550f, 0.17508864f, -0.08818123f, 
    0.06012683f, -0.07792778f, -0.09563140f, -0.01703992f, 0.03717389f, -0.23751485f, 0.01861734f, -0.13544874f, 
    -0.27408385f, -0.04224781f, 0.31914744f, 0.16248700f, 0.01364685f, -0.13276914f, 0.12303989f, 0.17901142f, 
    0.07617072f, 0.00641635f, -0.10060170f, -0.06669847f, -0.35577542f, -0.00109375f, 0.24170582f, -0.00920983f, 
    0.05022368f, 0.01779481f, 0.15167449f, 0.04870442f, 0.10119197f, -0.38463229f, -0.00147700f, -0.30056283f, 
    0.13238372f, -0.01993338f, 0.27061218f, 0.11693758f, -0.07564378f, 0.02928928f, -0.11758497f, -0.00988109f, 
    0.07415600f, -0.13167529f, -0.16347280f, 0.01526292f, 0.46305594f, 0.03201814f, 0.56244338f, 0.19208783f, 
    0.22882396f, -0.04002246f, -0.07566702f, 0.08161093f, 0.04414231f, 0.00622053f, -0.05315999f, 0.00726436f, 
    0.10247903f, 0.29212388f, 0.28448710f, 0.07506576f, 0.06230350f, -0.20469333f, -0.10179024f, 0.00785968f, 
    -0.07114334f, 0.13199477f, -0.15705082f, -0.16744266f, -0.22916612f, -0.08309618f, 0.03090226f, 0.01123325f, 
    -0.05856188f, 0.08649226f, 0.13165741f, 0.01090909f, -0.03352360f, -0.08308640f, -0.09111968f, 0.04361835f, 
    0.13268167f, 0.32280412f, -0.09225673f, 0.11713733f, 0.12838727f, 0.16899073f, -0.35310954f, 0.24175969f, 
    -0.08685945f, 0.00481759f, 0.07826392f, 0.13837948f, -0.30512944f, 0.09896623f, 0.28431171f, -0.02546286f, 
    0.11431043f, 0.00371520f, -0.12022526f, 0.08450170f, -0.03076039f, -0.23435232f, 0.15452777f, -0.17470258f, 
    -0.17585659f, -0.01885231f, 0.05261799f, 0.14406379f, 0.14841647f, 0.23301081f, -0.01980760f, -0.00078509f, 
    0.19077319f, 0.18142831f, 0.07029118f, -0.00185828f, 0.03917735f, -0.24245173f, 0.21257433f, 0.10249785f, 
    -0.02738165f, 0.00454820f, 0.13338581f, 0.02142624f, 0.12972967f, 0.01479225f, -0.10898777f, 0.12016348f, 
    -0.22864825f, 0.02284318f, 0.27943268f, 0.10505505f, 0.14121082f, -0.20412089f, 0.12289567f, -0.11185953f, 
    -0.00940828f, -0.05610920f, -0.01570353f, 0.14600763f, -0.38803461f, 0.19803160f, 0.04323826f, 0.25293857f, 
    0.22480191f, -0.01293289f, -0.14530617f, 0.11968927f, -0.00964267f, -0.04864214f, 0.04042674f, 0.07170589f, 
    0.33931839f, 0.12018566f, 0.11849645f, -0.27473336f, 0.21227749f, -0.01095399f, -0.04482962f, -0.15190628f, 
    0.12731560f, -0.07623593f, -0.02942705f, -0.08158851f, 0.04675172f, -0.22016983f, 0.05918955f, -0.20551638f, 
    0.12092402f, -0.20568621f, 0.11787485f, -0.04069085f, -0.15579042f, -0.21139005f, -0.10362834f, -0.06758389f, 
    0.48219234f, -0.13374047f, 0.01101282f, -0.37384528f, -0.01243289f, -0.21193051f, -0.20907967f, -0.26416290f, 
    0.13289486f, -0.06264624f, 0.07832421f, 0.13531193f, 0.02451673f, -0.26495141f, -0.28096008f, 0.05160893f, 
    0.11984162f, 0.11905354f, 0.35061613f, -0.02989681f, 0.18178284f, 0.26761314f, 0.20266895f, 0.42934802f, 
    -0.01315978f, -0.14178818f, 0.36630026f, -0.10288518f, 0.05544342f, 0.07046406f, -0.00484671f, 0.03923123f, 
    0.11680628f, -0.12262731f, -0.11122473f, -0.00590647f, 0.37848663f, 0.06512199f, -0.14540318f, -0.00199618f, 
    -0.11584857f, -0.10191862f, 0.07605715f, 0.01025051f, 0.25192451f, 0.02908033f, 0.08502973f, 0.31776908f, 
    -0.13379762f, -0.49824896f, 0.18517970f, -0.09904079f, -0.00113258f, -0.32941967f, -0.15964051f, 0.08452281f, 
    -0.19697405f, -0.03405400f, -0.04846299f, -0.01617902f, 0.17699382f, 0.29310271f, 0.10093497f, 0.33357161f, 
    0.27796939f, 0.11057220f, 0.00555382f, 0.01331954f, -0.05964208f, -0.11813124f, -0.19964701f, -0.18043292f, 
    -0.10849449f, 0.12109546f, -0.01639063f, 0.20113312f, 0.05593378f, 0.01450805f, -0.03289234f, 0.01167337f, 
    0.18739055f, 0.12948096f, -0.18197931f, 0.16437283f, -0.15973735f, -0.13905041f, 0.37088552f, -0.14711981f, 
    -0.24478486f, -0.31821069f, 0.05406417f, 0.08382408f, -0.19090158f, -0.02443733f, -0.04954651f, -0.00771400f, 
    -0.49660787f, 0.44902384f, -0.56138754f, -0.21417050f, 0.26248100f, 0.10058498f, 0.17767343f, 0.14441721f, 
    0.15693469f, -0.24366902f, -0.39637926f, -0.30117616f, 0.07391921f, 0.47748485f, 0.06295535f, 0.15699433f, 
    -0.02466817f, -0.15619586f, 0.14189695f, -0.08048595f, 0.28786305f, 0.07085843f, 0.26053905f, 0.15366384f, 
    0.07740457f, 0.18399712f, 0.13098110f, 0.08018212f, 0.20577060f, -0.20336796f, -0.07081719f, 0.11759281f, 
    -0.30492258f, -0.10973642f, -0.27233046f, -0.53377801f, 0.19935203f, 0.04651871f, 0.08687501f, 0.13630266f, 
    0.02669751f, 0.01868158f, 0.17098790f, 0.00959210f, 0.06895775f, -0.00895386f, 0.09129718f, 0.33199677f, 
    -0.12796597f, -0.02979989f, 0.11049961f, -0.02379742f, 0.00057819f, -0.03150583f, -0.07445124f, 0.14784497f, 
    0.13977385f, -0.11091460f, 0.02740439f, 0.12628837f, 0.00371383f, 0.79464352f, -0.30546018f, 0.67045903f, 
    0.01798455f, 0.10380107f, 0.23891973f, 0.17592670f, -0.11572694f, 0.08839960f, -0.09463176f, 0.10341907f, 
    -0.25342125f, 0.05555698f, -0.28968963f, 0.02259183f, 0.04446335f, 0.04339369f, -0.03177499f, 0.01615473f, 
    -0.13347073f, -0.02988385f, -0.14899071f, 0.09493338f, -0.39677218f, -0.39430195f, 0.35930365f, -0.03757066f, 
    0.13025610f, 0.23121691f, -0.12497264f, 0.09493974f, 0.01430316f, -0.09414440f, -0.01606602f, 0.15405180f, 
    -0.36590838f, -0.07851924f, 0.28474578f, 0.01812872f, 0.02821699f, 0.11772554f, 0.02939001f, 0.01765055f, 
    -0.03971173f, -0.03667721f, -0.21583949f, 0.09524105f, -0.19496548f, -0.07191798f, 0.06345566f, 0.10093314f, 
    -0.11641979f, 0.01123458f, -0.19026339f, -0.05675571f, 0.00610739f, 0.09156857f, -0.09066255f, 0.08437213f, 
    0.08446156f, 0.42097583f, -0.13392542f, 0.46935770f, -0.10622322f, -0.19708163f, 0.10942181f, -0.15530097f, 
    -0.14931494f, -0.01340533f, -0.01215106f, -0.01446123f, 0.11576933f, 0.29290366f, 0.09722378f, 0.35877523f, 
    -0.03932204f, 0.08453407f, 0.10290095f, -0.03621995f, -0.11016624f, -0.14597084f, 0.05301895f, 0.01347524f, 
    -0.33485901f, 0.43598744f, -0.13545015f, 0.29364437f, 0.15669282f, 0.08885103f, 0.02963942f, -0.12147017f, 
    -0.02277997f, -0.00357285f, -0.14537477f, 0.18872991f, 0.28532428f, -0.04113306f, 0.43467626f, 0.15723501f, 
    0.09500042f, 0.10690638f, 0.18762447f, 0.10106393f, -0.05674027f, -0.18786071f, -0.02787118f, -0.20475684f, 
    0.00538894f, 0.26692000f, -0.03826515f, 0.07271352f, -0.11040155f, 0.11364646f, -0.20324756f, -0.08493604f, 
    -0.00176173f, 0.07374138f, 0.05581308f, 0.01371028f, -0.41979375f, 0.16313455f, -0.09680837f, 0.45594072f, 
    0.07485366f, 0.12281968f, -0.06249784f, 0.07648966f, -0.03514541f, 0.04402809f, 0.02472119f, 0.08372760f, 
    0.03760092f, -0.31634563f, 0.62911087f, -0.13321316f, -0.00814119f, 0.20901582f, -0.25826973f, -0.08285276f, 
    0.03675686f, -0.09819996f, 0.03911558f, -0.42319542f, -0.07313660f, -0.37176561f, 0.12603302f, 0.18965957f, 
    0.08074486f, 0.20747107f, -0.11315596f, 0.05935556f, -0.07742524f, 0.01661689f, 0.10894917f, 0.24746557f, 
    0.21747351f, -0.03564967f, 0.24319941f, 0.27411222f, 0.07814842f, 0.08905758f, -0.19954988f, 0.02287468f, 
    0.02133864f, 0.04226004f, 0.02621986f, -0.05065362f, 0.01472530f, -0.01709428f, -0.24166612f, -0.10159155f, 
    -0.01657175f, -0.09192657f, -0.00140284f, -0.09693700f, 0.05470682f, -0.02839264f, 0.03528199f, 0.10657708f, 
    0.37731025f, -0.38398981f, -0.31827763f, 0.16810438f, -0.08086928f, 0.04908945f, -0.16012488f, -0.02015403f, 
    -0.10940960f, -0.00092068f, 0.06568858f, -0.14557548f, 0.18497598f, 0.03178728f, 0.43284851f, 0.09183145f, 
    0.30396524f, 0.19001110f, -0.01527077f, 0.03249973f, 0.07985571f, -0.02493884f, 0.07804820f, 0.01455232f, 
    -0.03310629f, -0.00896587f, 0.00996814f, 0.03011134f, -0.03301542f, -0.01903524f, 0.03317918f, -0.07538306f, 
    -0.02037823f, -0.01686310f, -0.02374069f, -0.06356116f, -0.02172551f, 0.02022120f, -0.05764518f, 0.02659667f, 
    -0.02753106f, -0.03065748f, -0.02648601f, 0.04140689f, 0.05847958f, -0.07443129f, 0.01497010f, 0.01631263f, 
    -0.02120726f, 0.04718705f, -0.00349187f, -0.02390455f, -0.02192865f, 0.00448754f, -0.06132162f, -0.07891330f, 
    -0.02244899f, -0.03114758f, -0.01213142f, -0.03642887f, 0.00561097f, -0.01371389f, 0.02636980f, 0.04232908f, 
    -0.02108756f, -0.07982114f, -0.03778317f, 0.00361157f, 0.05633128f, -0.02413334f, -0.03172591f, 0.03727641f, 
    -0.04036700f, -0.07188722f, 0.04951648f, -0.04942800f, -0.00331254f, -0.07752066f, 0.02721563f, -0.01322678f, 
    0.04451491f, -0.04190169f, 0.06088008f, -0.00487590f, -0.06812616f, -0.03574823f, -0.00935267f, -0.03156715f, 
    -0.04720028f, -0.01366161f, 0.06502239f, -0.05177668f, 0.04401021f, -0.05824553f, 0.01734670f, 0.00108311f, 
    -0.06143034f, 0.01726458f, -0.02171346f, -0.04769300f, -0.03650651f, -0.01438345f, 0.05807094f, -0.07157712f, 
    -0.05194973f, 0.02788585f, -0.03077322f, 0.06337752f, -0.07544538f, -0.03134524f, 0.05205965f, 0.02988202f, 
    -0.07639069f, 0.04339229f, -0.07694183f, -0.05111407f, -0.04172544f, -0.04531299f, -0.06324273f, -0.03939861f, 
    -0.07598825f, -0.07747211f, 0.01466381f, -0.00165435f, -0.05003487f, -0.03700767f, 0.05401240f, -0.00577297f, 
    -0.00997348f, 0.05798510f, -0.05857309f, 0.04944904f, -0.04555727f, -0.01621978f, 0.02258624f, -0.00221148f, 
    0.05229537f, -0.07553895f, 0.00232968f, -0.07054791f, -0.05685028f, -0.05901867f, -0.01469851f, 0.04160891f, 
    -0.06664276f, -0.04821180f, -0.02468499f, 0.01296827f, 0.01833741f, 0.02272612f, 0.06542988f, 0.01551007f, 
    -0.05262881f, 0.00221275f, -0.03118302f, -0.02611533f, 0.01710905f, 0.04243271f, -0.06075608f, 0.06027843f, 
    0.00419713f, 0.04370589f, -0.06037811f, -0.03583356f, 0.03482360f, -0.05887519f, -0.05175902f, -0.00268722f, 
    0.03784922f, -0.02373605f, 0.01600178f, -0.03215767f, -0.02531414f, -0.00248727f, -0.01157455f, 0.05581069f, 
    -0.04152779f, -0.06739889f, -0.06021461f, -0.00944785f, -0.04605605f, 0.03744650f, 0.04253099f, -0.02200975f, 
    -0.06794916f, -0.03605362f, -0.05284223f, -0.03154176f, 0.01590340f, 0.01553801f, -0.03519643f, -0.01021499f, 
    -0.03622478f, 0.04080470f, -0.04597021f, 0.02599936f, -0.04803535f, -0.00532104f, -0.00527638f, 0.02333960f, 
    0.05991954f, -0.05295968f, 0.00949910f, 0.05866759f, 0.05453784f, 0.00679038f, 0.06244605f, -0.06891386f, 
    -0.02999182f, 0.01807998f, 0.06544269f, -0.03154926f, 0.06715009f, 0.02908272f, -0.00295368f, -0.06837305f, 
    0.15892997f, 0.23085593f, -0.08570725f, -0.10687763f, -0.04959567f, 0.04376192f, -0.01427328f, -0.07346007f, 
    0.19794066f, -0.10022193f, -0.11333206f, -0.26355255f, -0.20273738f, -0.59687608f, 0.27806583f, -0.03794713f, 
    -0.15335466f, 0.19380261f, 0.05087383f, 0.05274419f, -0.13578258f, 0.03072944f, 0.22170421f, -0.01225545f, 
    0.20996760f, -0.11729058f, -0.01605116f, 0.00211380f, 0.13490504f, -0.07930774f, 0.09111796f, 0.10246033f, 
    -0.08703762f, 0.21940273f, 0.26355848f, 0.08413608f, 0.27942517f, 0.26516598f, 0.30090448f, 0.18237339f, 
    -0.10255446f, -0.11715467f, -0.09122163f, 0.04941704f, 0.06569485f, 0.29250112f, 0.25516838f, 0.17502461f, 
    -0.22465979f, 0.09610586f, 0.07547724f, 0.00197219f, 0.06785844f, -0.00907764f, 0.02627868f, 0.17401564f, 
    -0.05852900f, -0.14550580f, 0.06483285f, -0.05548250f, -0.02356703f, -0.13141763f, -0.44930971f, 0.09411757f, 
    -0.10815962f, -0.24006712f, -0.14965354f, 0.20993878f, -0.03502896f, 0.16737680f, 0.15144639f, 0.10422973f, 
    0.08038637f, -0.06520386f, -0.11991549f, 0.10462130f, -0.05343477f, 0.10403418f, 0.01794579f, 0.06814684f, 
    0.14952096f, 0.03719669f, 0.16882862f, 0.20163846f, 0.69625843f, 0.52669644f, 0.44667125f, -0.08337364f, 
    -0.18757054f, -0.34954914f, -0.19665042f, -0.27360719f, -0.04334910f, 0.12651414f, -0.00428312f, -0.02854736f, 
    0.03613124f, -0.11549651f, 0.07750662f, 0.02179017f, 0.19078970f, 0.01419072f, 0.03545896f, 0.02501952f, 
    -0.06793537f, 0.05052701f, 0.07537147f, 0.08234275f, -0.44960663f, -0.44732201f, -0.33492225f, -0.12637901f, 
    -0.11084060f, 0.05855752f, 0.14765312f, 0.12520215f, 0.05164826f, -0.05959480f, 0.02896434f, -0.00070936f, 
    0.42809531f, 0.31147808f, 0.57050580f, 0.03343276f, -0.15445580f, 0.02686297f, -0.24205281f, -0.14976680f, 
    0.05095103f, 0.20249406f, -0.07079552f, 0.01123897f, -0.44149894f, -0.32993948f, 0.15245752f, 0.34001231f, 
    0.05477919f, 0.10885574f, 0.03042272f, 0.08103218f, 0.11791924f, 0.08504989f, -0.14062740f, 0.21515249f, 
    -0.21997909f, -0.23368587f, -0.03472004f, 0.01007536f, -0.04225446f, 0.11852548f, 0.03940718f, -0.11936849f, 
    0.02315140f, -0.00934840f, -0.01539276f, -0.06348054f, -0.21618810f, 0.07775661f, -0.17455606f, 0.15967146f, 
    -0.20110567f, -0.01298193f, -0.08291027f, -0.17156154f, -0.11295635f, 0.05978801f, -0.01357661f, 0.09294053f, 
    -0.24324071f, -0.07946595f, -0.15043356f, -0.18319882f, 0.15180217f, -0.09089831f, -0.11054876f, -0.20539270f, 
    0.01092123f, -0.03644002f, -0.00831559f, -0.16085102f, -0.03779331f, 0.29056644f, 0.22570300f, 0.46623978f, 
    -0.02295689f, 0.04072497f, 0.10850857f, -0.21182980f, 0.04897607f, 0.02646643f, 0.04648210f, 0.15911263f, 
    -0.01828701f, -0.05439882f, -0.08265277f, -0.06626607f, 0.03645747f, -0.01223065f, 0.03341161f, 0.04101770f, 
    0.00435028f, -0.01585807f, -0.05196194f, -0.04892015f, 0.03934034f, 0.03110917f, -0.01969005f, -0.00927449f, 
    -0.07178318f, 0.00445245f, -0.08649118f, 0.02675698f, -0.01160706f, -0.00471478f, 0.00001049f, -0.07873768f, 
    0.01694527f, -0.04023102f, -0.01646969f, -0.06040047f, -0.02348257f, -0.07305600f, -0.01609300f, -0.07797946f, 
    0.00074814f, -0.00553353f, -0.00988214f, 0.00916512f, -0.03375336f, -0.08367845f, 0.03722418f, -0.05740847f, 
    -0.08045191f, -0.04166168f, 0.05415263f, 0.00098835f, -0.03627721f, -0.03253731f, 0.04378917f, 0.04366744f, 
    0.01302407f, -0.06408460f, -0.01458505f, -0.05647606f, -0.03631337f, -0.00615454f, 0.05027227f, -0.04865812f, 
    0.01135168f, 0.00424888f, 0.03045210f, 0.05446162f, 0.05389994f, -0.04434108f, -0.04433091f, 0.04275970f, 
    -0.04008307f, 0.02804494f, 0.03288860f, 0.00142184f, -0.02042822f, 0.05110836f, -0.02960204f, -0.05143470f, 
    0.02954093f, -0.00148673f, 0.01118856f, 0.06053922f, 0.05758680f, -0.05859037f, -0.08552184f, -0.02154602f, 
    0.02353695f, 0.03768642f, 0.02793355f, -0.01665231f, -0.06302675f, 0.01674266f, -0.04002882f, -0.00734191f, 
    -0.04103069f, 0.04369064f, -0.08169004f, -0.01322761f, -0.01801536f, -0.01199930f, 0.02478704f, 0.04284330f, 
    -0.04725650f, 0.03134490f, -0.07376444f, -0.01226452f, 0.04760015f, -0.06247686f, -0.04983113f, -0.06704868f, 
    -0.03454334f, 0.03209443f, -0.07202431f, 0.07266502f, 0.04465700f, -0.01818015f, -0.02126542f, -0.02677946f, 
    -0.01943719f, 0.04043831f, 0.01726792f, 0.04469277f, -0.00724148f, -0.00356352f, 0.01864844f, -0.03960956f, 
    0.00484214f, 0.02117250f, -0.01405843f, 0.03979125f, -0.08353322f, -0.02441769f, 0.05282984f, -0.04737221f, 
    -0.07207440f, -0.03831900f, -0.07978069f, -0.05405870f, 0.00982586f, 0.00793367f, -0.00035192f, -0.01850918f, 
    0.02648473f, -0.01723727f, -0.00951520f, -0.06254557f, 0.00327296f, -0.05803522f, -0.02287550f, 0.03452550f, 
    -0.01054693f, -0.02501174f, -0.00374213f, -0.01883690f, -0.03799755f, 0.03727022f, -0.02927376f, 0.03857434f, 
    -0.00653197f, 0.04406438f, 0.02819480f, -0.00078092f, 0.01764716f, -0.03653594f, 0.03526000f, 0.05449930f, 
    -0.07102223f, 0.05683954f, -0.06935459f, -0.00773557f, -0.06314455f, -0.05311853f, -0.02504463f, -0.02731710f, 
    0.02156300f, -0.04216751f, -0.05147771f, -0.07485082f, -0.02338376f, -0.02352789f, -0.04112509f, -0.04345206f, 
    -0.01814210f, -0.07990435f, 0.03092293f, 0.04262549f, 0.01438838f, -0.08041292f, -0.01722991f, 0.02524521f, 
    0.05437452f, -0.04634177f, -0.06005812f, -0.06190494f, -0.01345184f, 0.04878604f, 0.05930042f, 0.04196968f, 
    0.34022430f, -0.12429155f, 0.02138825f, -0.05196467f, 0.09508216f, -0.20911300f, -0.12434703f, 0.04093720f, 
    -0.05467711f, -0.08495715f, -0.01927618f, -0.04244120f, 0.56923038f, -0.02626075f, -0.17490090f, -0.06211184f, 
    -0.17751725f, -0.04536673f, -0.01437229f, 0.10926323f, 0.21737310f, 0.12557119f, 0.00157621f, -0.12808061f, 
    0.13744894f, -0.30862731f, -0.13596345f, 0.10652114f, -0.06105027f, -0.18435712f, -0.02053608f, -0.14474645f, 
    0.12620924f, 0.15312289f, 0.05479706f, 0.02361993f, 0.33349392f, -0.32979438f, -0.28902999f, 0.09767997f, 
    0.12101995f, 0.09024689f, 0.10151395f, -0.05225376f, 0.09254391f, 0.06747610f, 0.07692858f, 0.23028018f, 
    0.27072656f, -0.34591284f, 0.32983911f, -0.02402773f, 0.16802594f, 0.01894484f, 0.05511941f, -0.05190999f, 
    0.07023961f, 0.08458143f, -0.00167934f, 0.02147671f, -0.14794144f, -0.10242920f, 0.26553190f, -0.10825334f, 
    0.04416269f, -0.00484724f, 0.13181734f, 0.07607070f, 0.18683313f, 0.05768939f, 0.22402839f, 0.32701236f, 
    0.03146283f, -0.45861602f, -0.10613430f, 0.07745033f, -0.11832256f, -0.11023233f, -0.06679295f, 0.09361328f, 
    0.11995155f, 0.05679953f, 0.06699153f, 0.00201037f, 0.01706213f, 0.31307465f, -0.12429462f, -0.03922733f, 
    0.15124258f, 0.06348250f, 0.02574616f, 0.06719827f, -0.00851913f, -0.02478185f, 0.00124305f, 0.06800165f, 
    -0.02903710f, -0.21765824f, -0.04137520f, 0.07468152f, 0.04190900f, 0.00780938f, -0.04929885f, -0.01721460f, 
    0.01547341f, 0.21320288f, 0.00134552f, 0.25610629f, 0.42309171f, 0.30392671f, 0.21207216f, -0.12537168f, 
    0.02528054f, -0.17000912f, 0.21350601f, 0.05576006f, -0.10476796f, 0.09408771f, -0.10710312f, 0.18014114f, 
    0.11880577f, -0.06196418f, -0.67936033f, -0.19140191f, 0.19101797f, -0.04193034f, 0.17104657f, -0.09340651f, 
    0.10165885f, -0.00314071f, -0.16955465f, -0.13808848f, 0.51560032f, 0.41525897f, 0.18979289f, -0.12843758f, 
    -0.05941164f, -0.09051649f, 0.05230825f, -0.18078373f, 0.27242351f, 0.16342199f, 0.31397733f, 0.07689684f, 
    -0.02871482f, 0.12890315f, 0.05567722f, -0.14079018f, 0.10982942f, -0.05657396f, -0.00315067f, -0.02747088f, 
    -0.07827954f, -0.18112622f, -0.12128294f, -0.41705623f, -0.04319665f, 0.08258796f, 0.11556019f, 0.01775222f, 
    -0.02560305f, 0.04087723f, -0.03689783f, -0.11582800f, 0.03912523f, 0.03900886f, 0.23991452f, 0.12806191f, 
    -0.28816816f, 0.27358317f, 0.18149360f, -0.03896354f, 0.00408373f, -0.00203618f, 0.03013891f, -0.02582588f, 
    -0.04635800f, -0.11197513f, -0.04954069f, 0.07720000f, 0.06523363f, 0.34115949f, -0.28860274f, 0.11033767f, 
    -0.04665783f, 0.17455101f, -0.04579053f, 0.02130182f, -0.01462187f, 0.12465932f, 0.06469794f, 0.02687032f, 
    0.11799899f, -0.44244149f, -0.00485135f, 0.00367264f, 0.13002142f, -0.10749602f, -0.01390078f, -0.12306564f, 
    0.08909877f, 0.11343078f, 0.13939758f, 0.13254456f, 0.59106946f, -0.06876959f, -0.38102165f, 0.05101603f, 
    -0.19703266f, -0.09563497f, 0.02764434f, 0.06186597f, -0.02359521f, -0.02408785f, 0.09394819f, 0.03168646f, 
    0.31935430f, -0.00706527f, -0.17805646f, 0.05261534f, -0.13018344f, -0.00413696f, 0.08394719f, -0.17223155f, 
    -0.07315128f, 0.06009640f, -0.03590398f, 0.13800648f, -0.21930216f, -0.64275110f, -0.30443382f, 0.05372098f, 
    -0.08049305f, -0.03437306f, 0.14842109f, -0.14761084f, 0.02025849f, -0.13617273f, -0.12202039f, -0.26874375f, 
    0.07005770f, -0.00304350f, 0.24865310f, -0.24870637f, 0.19330989f, 0.20573327f, 0.15298410f, 0.10152537f, 
    -0.03695754f, 0.10078099f, 0.19621214f, 0.00850083f, -0.10960281f, 0.02823248f, -0.21719699f, -0.24843904f, 
    0.12304177f, 0.04971435f, -0.05028560f, -0.10335898f, -0.00930247f, -0.04182754f, -0.00392382f, -0.08761317f, 
    -0.17994110f, -0.53061485f, -0.16774762f, -0.08856978f, -0.05440763f, -0.25765073f, -0.08897916f, 0.20280370f, 
    0.22715659f, 0.06014555f, 0.14935431f, -0.08148453f, 0.10968217f, 0.12581843f, -0.00112191f, 0.18666354f, 
    -0.02095025f, 0.05234921f, -0.06082693f, 0.25691089f, 0.07243972f, 0.03118199f, -0.15956853f, -0.06802323f, 
    0.27882192f, 0.18463157f, 0.25669888f, 0.07689340f, 0.09413812f, 0.03004628f, 0.21885271f, 0.16155253f, 
    -0.11609177f, -0.02662972f, -0.13548985f, 0.10481562f, 0.05622242f, -0.60250759f, -0.27705693f, -0.30479985f, 
    0.02280538f, -0.10704479f, 0.01709952f, 0.18982632f, 0.04527607f, 0.02613186f, 0.11092927f, -0.01043672f, 
    -0.29470539f, -0.21626218f, -0.72492981f, 0.44597846f, 0.19696164f, -0.05882069f, 0.11910429f, 0.05563152f, 
    0.30074528f, 0.12416647f, -0.05799391f, 0.27272370f, 0.36647701f, 0.43119210f, 0.09159613f, 0.19149230f, 
    0.04162988f, -0.16058317f, 0.04484588f, -0.12601538f, -0.16786061f, -0.04985466f, -0.09473748f, -0.17909101f, 
    0.31303176f, 0.12992142f, 0.09097140f, 0.19034189f, 0.12237695f, 0.06423916f, 0.00740594f, -0.00336351f, 
    0.20050636f, 0.06890465f, 0.02703260f, 0.02650146f, 0.31798831f, 0.30908075f, 0.30214006f, 0.12407327f, 
    0.13005540f, 0.05573096f, 0.04384670f, 0.08918310f, 0.00599198f, 0.10419817f, -0.10138764f, -0.07446778f, 
    -0.03626034f, 0.42510054f, 0.19961801f, -0.23246449f, 0.10311814f, 0.18095838f, 0.20673572f, 0.08376999f, 
    -0.05787559f, -0.15787525f, -0.03582294f, 0.05408837f, 0.11923837f, 0.25782865f, -0.10935792f, 0.32042354f, 
    -0.22157718f, 0.09991980f, 0.03340368f, 0.11215380f, -0.14652471f, 0.11672423f, -0.03074679f, -0.09528141f, 
    0.09363069f, 0.07320510f, 0.07758480f, -0.08418887f, -0.08992121f, -0.11000820f, 0.01834258f, -0.15426664f, 
    0.21356945f, -0.07129357f, 0.16148311f, 0.08707393f, 0.54599112f, 0.28677136f, -0.33012766f, 0.15415868f, 
    0.01794383f, -0.15477191f, 0.06417149f, 0.05327560f, 0.18603961f, 0.19550011f, 0.21372887f, 0.10583900f, 
    0.29953486f, 0.20951149f, 0.19182965f, 0.13342148f, 0.06798796f, 0.21979469f, 0.05793061f, -0.04545117f, 
    0.12416309f, 0.18477146f, 0.10224260f, -0.03946799f, 0.24726555f, 0.08565825f, -0.03001825f, -0.00906339f, 
    -0.08374047f, 0.03922232f, 0.04223664f, -0.06364929f, -0.01018289f, -0.05521283f, 0.09019703f, -0.45646819f, 
    -0.38014835f, -0.19915926f, 0.17304213f, -0.10195264f, 0.08164070f, 0.09862336f, 0.13943294f, 0.19559251f, 
    -0.06881241f, 0.02471363f, 0.15739368f, -0.13281438f, -0.38717893f, 0.00186968f, -0.40516087f, -0.51435572f, 
    -0.02034324f, -0.11505894f, -0.00266918f, -0.10636410f, 0.03077095f, -0.02007437f, -0.20482527f, -0.25038648f, 
    -0.28818822f, -0.11631952f, 0.01790022f, 0.25836352f, 0.01548138f, 0.03135208f, -0.04362972f, 0.00769142f, 
    0.03423769f, -0.23242411f, 0.31383848f, 0.10359139f, 0.19767523f, -0.21368806f, 0.04987283f, 0.17427710f, 
    0.27794078f, 0.01021972f, -0.14772153f, 0.21205541f, 0.06915212f, 0.13276534f, -0.03967765f, 0.11610965f, 
    -0.05113064f, 0.05823538f, 0.32497799f, -0.02339413f, 0.02245241f, 0.00021892f, 0.18268417f, 0.10737519f, 
    -0.14402252f, 0.01568416f, 0.06624281f, 0.08318532f, -0.07591464f, 0.01480496f, -0.05409383f, -0.13689409f, 
    -0.09213642f, -0.03815499f, 0.02370209f, 0.34075499f, 0.05957232f, 0.04689813f, 0.12921149f, -0.04198646f, 
    0.01074834f, 0.04283343f, -0.07746278f, 0.21363334f, 0.10145989f, 0.05360404f, 0.32779485f, -0.04049793f, 
    0.00372616f, 0.05092491f, 0.10400435f, 0.21020459f, 0.00067181f, 0.21075378f, 0.17033997f, -0.06256403f, 
    0.08847407f, 0.09418717f, 0.17307551f, 0.00173231f, -0.15978479f, -0.10896626f, -0.04180485f, -0.26198721f, 
    -0.03993170f, -0.18271030f, 0.10376946f, 0.08451985f, 0.06866650f, 0.08167104f, 0.05135778f, 0.17144273f, 
    0.14475523f, 0.05460529f, 0.06915165f, 0.17448854f, -0.13538562f, -0.00716331f, 0.13004892f, 0.08365454f, 
    0.10272910f, 0.16508077f, 0.12397881f, 0.01622498f, 0.22310194f, 0.06831014f, 0.08088725f, -0.09752515f, 
    -0.30423626f, -0.06143028f, 0.19985025f, -0.12333752f, 0.02811512f, 0.00483985f, 0.30031642f, 0.03567578f, 
    0.07015491f, -0.01023477f, 0.09987360f, 0.17091984f, -0.31236932f, 0.10231788f, -0.09675485f, 0.14985460f, 
    0.04847375f, -0.02331140f, 0.11122960f, 0.01279844f, 0.03045967f, -0.06684783f, -0.02083475f, 0.03724864f, 
    0.03230106f, -0.09109008f, -0.09739166f, 0.11485551f, -0.12332658f, 0.18799521f, -0.05395623f, -0.18798548f, 
    -0.17363787f, 0.01190867f, -0.01657676f, -0.10558969f, -0.65369493f, -0.10465302f, 0.37778372f, -0.35243791f, 
    -0.02310848f, 0.06933171f, 0.16547650f, -0.32009968f, 0.06252736f, -0.02996109f, 0.02728414f, 0.13553926f, 
    -0.02469191f, -0.19611338f, -0.12411891f, -0.14366271f, 0.02908340f, -0.44859159f, -0.14332967f, 0.15958603f, 
    0.01872605f, 0.10554826f, 0.25771940f, -0.11227168f, -0.61261910f, -0.12233766f, -0.30194548f, -0.04063603f, 
    0.13358372f, 0.08426595f, 0.01450149f, -0.11315654f, 0.04294439f, 0.20999697f, 0.09772445f, 0.48507395f, 
    0.53476024f, 0.00923233f, 0.17415729f, -0.08298193f, 0.12372306f, -0.06751059f, -0.00008017f, 0.05165218f, 
    0.11584705f, -0.10610955f, 0.05968395f, -0.00475545f, 0.31937003f, 0.03101534f, 0.35097653f, 0.30890456f, 
    -0.04577940f, 0.10509238f, 0.00770172f, 0.08820419f, 0.14246050f, 0.00258776f, 0.12235801f, 0.15156831f, 
    0.22076057f, -0.29251915f, -0.01934138f, -0.06564769f, -0.23390235f, -0.01269672f, -0.04235289f, -0.08755936f, 
    0.04917121f, 0.21911453f, -0.13400598f, -0.10134905f, -0.05388597f, 0.23904501f, 0.08100928f, -0.04180127f, 
    0.11963066f, 0.08526536f, -0.05306599f, 0.04460536f, 0.01452952f, -0.07841215f, 0.08011007f, -0.09815387f, 
    0.09710810f, 0.05410651f, -0.22995527f, -0.13096458f, 0.09542546f, 0.05321149f, -0.07095076f, 0.13439400f, 
    0.07473529f, 0.04471271f, 0.01522000f, 0.02027771f, 0.07878677f, 0.29557154f, 0.28555995f, -0.31540501f, 
    -0.18995346f, -0.01452627f, 0.10322050f, -0.03260353f, -0.02215654f, 0.01675282f, -0.05312306f, 0.18374629f, 
    -0.19375122f, -0.17319918f, -0.37370840f, -0.23619030f, 0.09706897f, -0.12838154f, -0.02796573f, 0.17959659f, 
    0.11716144f, -0.01141181f, -0.11427080f, -0.21815625f, 0.05463254f, -0.09129133f, -0.08822392f, 0.02198325f, 
    -0.05372135f, -0.03088124f, 0.09212330f, -0.23709951f, 0.08337665f, 0.12885760f, -0.01815857f, 0.31032333f, 
    0.11706856f, 0.34124589f, 0.11325803f, -0.04977973f, -0.05813687f, 0.13425449f, 0.14561605f, -0.07609724f, 
    -0.10252299f, -0.19858444f, -0.19561431f, -0.17500696f, 0.12622701f, 0.21524253f, 0.04602363f, -0.03490082f, 
    0.06190258f, -0.08383258f, -0.05682146f, -0.05453915f, 0.04434115f, -0.03081786f, 0.09394838f, 0.05635027f, 
    0.02142023f, 0.27981034f, 0.02086280f, 0.06497001f, -0.03138969f, 0.04272706f, -0.07795212f, 0.16669822f, 
    -0.06075387f, 0.08897771f, -0.00862530f, 0.11019560f, -0.07231889f, 0.30316627f, -0.09153416f, 0.11945814f, 
    0.10906564f, 0.10553269f, -0.02304866f, 0.09255645f, 0.15866123f, 0.11660060f, -0.14633125f, 0.13401285f, 
    -0.05966683f, -0.08166863f, 0.02567628f, 0.29259098f, -0.00216671f, 0.03224741f, 0.08782583f, -0.00148828f, 
    0.16138949f, 0.08554917f, 0.23682733f, 0.41344973f, -0.39120004f, 0.21761644f, 0.33826610f, -0.31017324f, 
    0.07912446f, 0.02755626f, 0.23014352f, 0.05906207f, -0.07301367f, 0.06891020f, 0.05162336f, 0.03114951f, 
    0.31075466f, -0.30295983f, 0.48594472f, 0.16240130f, 0.02332522f, -0.03098917f, 0.07972723f, 0.07659045f, 
    0.16513735f, 0.14008643f, 0.04505900f, 0.12981208f, -0.02041153f, -0.13297257f, -0.15867670f, 0.02531625f, 
    0.06369516f, 0.02030580f, 0.08073806f, -0.06469879f, -0.15989053f, 0.09142522f, -0.17370814f, -0.02704097f, 
    0.18149830f, -0.07135479f, 0.17232777f, 0.00240434f, -0.08397430f, -0.06048902f, -0.12066987f, 0.12504515f, 
    0.04629773f, -0.15589306f, 0.13745342f, -0.02433045f, -0.12711161f, 0.28997251f, 0.01047262f, 0.01894027f, 
    -0.08146555f, -0.11679646f, 0.04495490f, 0.17437111f, -0.06159054f, -0.16737323f, -0.01989339f, -0.29048383f, 
    0.58337969f, -0.26185435f, -0.16234188f, 0.11556392f, -0.08252481f, 0.01561311f, -0.03539027f, 0.09172785f, 
    -0.02202934f, -0.10017233f, 0.09588414f, 0.04445803f, 0.30903935f, -0.04262235f, -0.35368255f, -0.06405405f, 
    0.10404332f, -0.08440346f, 0.27359405f, -0.02945103f, 0.06715546f, 0.03072317f, 0.04728935f, 0.04004611f, 
    0.00170437f, -0.08607858f, 0.14460710f, -0.19503960f, -0.11614031f, 0.12025694f, 0.06691009f, 0.12855580f, 
    0.12511818f, -0.12616213f, 0.02205143f, -0.12428372f, 0.63522452f, -0.05763797f, 0.17400198f, -0.39189488f, 
    -0.10753667f, -0.04298105f, -0.10448972f, -0.05803918f, -0.09578924f, -0.18761836f, -0.04850320f, -0.17483878f, 
    0.19928743f, -0.03216278f, -0.17892292f, -0.02646137f, 0.04303675f, -0.02050050f, 0.21607716f, 0.19868177f, 
    -0.00684196f, -0.05514287f, 0.03667134f, -0.06756346f, 0.07350849f, -0.25219750f, 0.34131649f, -0.24266714f, 
    -0.06605297f, 0.00381473f, 0.03307429f, -0.06892223f, -0.07566531f, 0.03712211f, -0.13486651f, -0.05593238f, 
    0.00260011f, 0.06858642f, 0.30437005f, -0.14347929f, -0.15854096f, 0.13234265f, 0.04126609f, 0.13714512f, 
    0.00226603f, 0.02235498f, -0.00408236f, 0.11107571f, 0.13615555f, 0.38799459f, 0.16538434f, 0.00267754f, 
    -0.08506744f, -0.10946024f, -0.03035652f, 0.13051105f, 0.08909027f, 0.06762110f, 0.06547725f, 0.09717957f, 
    -0.23499219f, 0.09040501f, 0.10892438f, 0.00719170f, -0.08469542f, -0.02332812f, -0.06487734f, -0.01799815f, 
    -0.00234534f, 0.04543166f, 0.09132597f, -0.01969866f, 0.01564256f, 0.20940575f, -0.10991532f, -0.02758555f, 
    -0.00926988f, 0.01561498f, 0.09919867f, 0.08568894f, 0.00227089f, -0.02693450f, -0.11270738f, 0.14991246f, 
    -0.07822824f, -0.02542295f, 0.05219446f, -0.05817700f, 0.02576130f, 0.03042901f, 0.04088803f, -0.05757209f, 
    -0.06919789f, 0.01651536f, 0.00082730f, 0.05359457f, -0.00302064f, 0.02050098f, -0.06501050f, 0.01133660f, 
    0.02476964f, 0.05672349f, -0.07880629f, -0.06102272f, -0.06944560f, -0.01159403f, -0.02239023f, 0.01604703f, 
    0.04199393f, -0.06440818f, -0.01616657f, -0.04469244f, -0.01873103f, -0.01537438f, 0.04180235f, -0.03303760f, 
    0.05945333f, 0.04567849f, 0.04097696f, -0.06654523f, 0.01612921f, -0.06078556f, 0.03339287f, -0.00795694f, 
    0.02752345f, -0.03773109f, -0.00042606f, -0.05106310f, -0.00396701f, 0.01246878f, -0.02574183f, 0.03529970f, 
    0.00324001f, -0.00021152f, 0.04976090f, -0.03413743f, 0.03631626f, -0.04436891f, 0.06436176f, -0.04596591f, 
    -0.05971685f, -0.05074556f, -0.01584182f, -0.06592283f, -0.00481970f, -0.02727608f, -0.06835386f, -0.04349717f, 
    0.01029245f, -0.04560956f, 0.00050617f, -0.02065469f, 0.02868134f, 0.01225974f, -0.07000592f, 0.03706496f, 
    -0.06094443f, -0.02761086f, -0.04470451f, -0.06717986f, 0.05699646f, 0.00900690f, -0.05793352f, 0.02955887f, 
    -0.05732492f, 0.01851709f, -0.04061577f, 0.02551388f, 0.03964476f, -0.07310597f, -0.02781684f, 0.01300858f, 
    -0.03505838f, -0.07068264f, -0.01192914f, -0.00992935f, -0.04148114f, -0.04867970f, 0.06768142f, -0.00437168f, 
    -0.00093133f, -0.00083147f, 0.01747252f, -0.01591779f, -0.02515587f, 0.03716610f, -0.00875481f, 0.03537712f, 
    -0.05312777f, 0.06908584f, -0.06921070f, 0.00195582f, 0.06711099f, 0.01383371f, -0.07682353f, 0.01016616f, 
    -0.06689055f, -0.05098474f, -0.05953271f, -0.05821925f, -0.05618279f, -0.07236662f, -0.00126154f, -0.05407539f, 
    -0.06955756f, -0.01199390f, -0.01242482f, 0.04115504f, 0.00336154f, -0.07500117f, 0.03923893f, 0.05763894f, 
    -0.01572349f, 0.04996713f, 0.02020960f, 0.03675785f, -0.01794905f, -0.02370341f, 0.01124203f, -0.02911525f, 
    0.02946380f, 0.00575151f, -0.00886655f, -0.02366932f, -0.06679378f, -0.03728456f, 0.06918410f, 0.02664155f, 
    0.02137683f, -0.07393047f, 0.05190377f, 0.03312768f, 0.02432013f, 0.04033124f, -0.04137317f, 0.00455945f, 
    -0.02042490f, 0.00419204f, -0.03512410f, -0.01659937f, 0.06536642f, 0.03514764f, -0.04254564f, -0.02734904f, 
    0.01710880f, -0.05124069f, 0.03215012f, 0.04490378f, 0.01586524f, 0.03503007f, -0.02383384f, -0.05282764f, 
    -0.06058727f, -0.04314584f, -0.00637411f, -0.05255881f, -0.00866472f, 0.00715274f, 0.00568386f, 0.06512102f, 
    0.00999130f, 0.06203675f, -0.02946099f, 0.01717918f, 0.02644467f, 0.01225433f, -0.03552886f, -0.04370788f, 
    -0.03348994f, 0.06768695f, 0.05937029f, -0.06328964f, 0.05955014f, -0.06127072f, -0.01630615f, -0.01959000f, 
    0.14697771f, -0.03233653f, 0.23612186f, 0.21885003f, -0.01098208f, -0.02390615f, 0.01700637f, -0.07391316f, 
    -0.06405790f, 0.12520728f, -0.00096830f, -0.03949580f, -0.29093555f, 0.32892954f, 0.27361584f, -0.26230171f, 
    0.02008084f, -0.01527257f, 0.04057366f, -0.10550918f, 0.13591014f, 0.18235625f, 0.08890846f, -0.07273307f, 
    -0.17777830f, -0.08487716f, -0.02181308f, 0.00529250f, 0.14567389f, -0.07415988f, -0.19049321f, 0.19491147f, 
    0.05161392f, -0.00373764f, 0.27145556f, -0.20250209f, 0.04923414f, 0.03810876f, 0.01470297f, -0.07339075f, 
    -0.01020435f, 0.01766120f, -0.00936963f, 0.06574751f, 0.23433346f, 0.06825061f, 0.24414223f, 0.44255611f, 
    -0.13091454f, -0.03521819f, -0.00258033f, 0.02058419f, -0.05838704f, -0.01124805f, -0.22374906f, 0.19734387f, 
    0.07903537f, 0.01045834f, -0.06340481f, 0.06901794f, 0.11498701f, -0.06374574f, 0.37250084f, 0.30731848f, 
    -0.03478085f, -0.09618773f, -0.02710788f, 0.18088476f, -0.01506784f, -0.12470871f, 0.10806733f, -0.08526026f, 
    0.98728663f, 0.22910170f, 0.17780496f, -0.17189677f, 0.00362734f, -0.02994068f, -0.07405727f, -0.13466556f, 
    -0.06516990f, 0.07810616f, -0.01475558f, -0.07194412f, -0.10580398f, -0.10773747f, -0.46769527f, -0.17990592f, 
    -0.15674473f, -0.13024779f, 0.04912794f, -0.08116377f, 0.02071231f, -0.11757319f, -0.02916184f, 0.03077228f, 
    -0.33443066f, -0.14961848f, 0.10588267f, -0.02591497f, -0.06281278f, -0.12287950f, -0.11707877f, 0.02881861f, 
    0.18774968f, 0.04557222f, 0.02426723f, -0.15150410f, 0.60147935f, 0.33171010f, 0.45308897f, -0.24233538f, 
    -0.09805932f, -0.05919269f, -0.13233797f, -0.23931606f, 0.11540622f, 0.09581945f, 0.04284418f, 0.13463654f, 
    0.39876142f, 0.18738942f, -0.14707950f, -0.42654535f, -0.17590041f, -0.12859853f, 0.20326185f, -0.00977957f, 
    0.02958979f, 0.00070152f, -0.10077107f, 0.00980411f, -0.18090403f, 0.02669842f, 0.23141973f, -0.18808809f, 
    -0.00693627f, -0.05920025f, -0.11089196f, 0.10853036f, 0.09534556f, -0.07577889f, -0.15264416f, 0.04065552f, 
    -0.04119451f, 0.17148839f, -0.05776941f, -0.13175565f, -0.15298288f, -0.00033013f, 0.37458247f, -0.08096909f, 
    -0.18778458f, -0.09683593f, 0.02595922f, -0.16272938f, -0.15667453f, -0.20272607f, 0.21527658f, 0.03693804f, 
    0.04989219f, 0.18449827f, 0.16068470f, 0.21255317f, 0.05252029f, -0.00006485f, 0.06816087f, 0.08053228f, 
    -0.06535292f, 0.05993790f, 0.15549095f, 0.36175019f, 0.09423541f, -0.08109398f, -0.09924433f, 0.14779525f, 
    0.02981493f, 0.06157085f, -0.11885744f, -0.00682751f, 0.12260810f, 0.02758245f, 0.11107414f, -0.25359112f, 
    -0.06385729f, -0.00258063f, 0.14293879f, 0.05353818f, -0.04898971f, -0.15636098f, -0.12597786f, 0.07019522f, 
    -0.03671389f, 0.02970894f, 0.06108647f, -0.12829135f, 0.06455692f, -0.03947066f, 0.06281040f, 0.04623710f, 
    0.29042992f, -0.03169581f, -0.07628769f, 0.05688998f, -0.18964499f, -0.08777243f, -0.00911854f, 0.00033626f, 
    0.19357605f, -0.02194715f, 0.10740072f, 0.18613891f, -0.00992616f, -0.00385289f, 0.00207284f, 0.11553925f, 
    0.56443393f, -0.15549570f, -0.21170163f, 0.00691957f, -0.02598708f, -0.04108406f, 0.10057943f, -0.13823786f, 
    0.12098318f, 0.13240759f, 0.05620938f, 0.28108671f, -0.12149984f, -0.06536891f, -0.00142661f, -0.08822788f, 
    0.09765894f, -0.02462215f, 0.03274393f, 0.02133816f, -0.14238398f, -0.10148335f, 0.14059766f, -0.11049139f, 
    0.48201615f, 0.11087160f, 0.05315103f, -0.22783856f, 0.12177405f, 0.13480482f, 0.19220605f, 0.09454120f, 
    0.07081895f, 0.02772829f, -0.07911041f, -0.13792075f, -0.03170652f, -0.20695621f, -0.27778766f, -0.18863375f, 
    -0.05517286f, 0.08253915f, 0.03784988f, -0.09614622f, 0.06389073f, 0.01231246f, -0.02994336f, 0.07062092f, 
    -0.07262429f, -0.67768550f, 0.07511502f, 0.27351454f, -0.03023857f, -0.01189377f, 0.02802089f, -0.08309682f, 
    0.19984765f, -0.04828361f, -0.06914244f, 0.10679580f, 0.21689339f, 0.37436932f, 0.17784733f, -0.15664548f, 
    0.10742747f, -0.21970598f, -0.23306900f, 0.08763196f, 0.04893442f, -0.01049597f, 0.02441172f, 0.04307294f, 
    0.47239998f, -0.10443798f, -0.10546543f, -0.06919094f, 0.16009155f, 0.12175629f, 0.17722367f, 0.06482459f, 
    0.04436152f, 0.05767417f, -0.09006911f, -0.09218843f, -0.20938818f, -0.48530799f, -0.17064515f, 0.05572971f, 
    0.04547618f, 0.06729012f, 0.19580537f, 0.19432382f, -0.11593484f, -0.07212935f, 0.04376001f, 0.04142325f, 
    -0.49108002f, 0.07196941f, -0.13210899f, 0.45062461f, 0.16178465f, 0.10584590f, -0.16490859f, -0.08413874f, 
    -0.12899099f, 0.04902210f, 0.15122713f, 0.10843331f, 0.02658969f, -0.01957979f, -0.12472006f, 0.03975257f, 
    -0.07263204f, 0.08908963f, -0.05446407f, -0.05580228f, 0.14932649f, 0.17005470f, 0.02489998f, -0.12270347f, 
    -0.12849335f, -0.09341063f, -0.08708923f, -0.12471893f, 0.21417364f, 0.07125445f, -0.08026677f, -0.05359347f, 
    -0.05343194f, 0.04558524f, -0.14763123f, 0.03140686f, 0.24878870f, 0.19195440f, 0.07213811f, -0.05759156f, 
    0.05734663f, -0.11871928f, -0.01173771f, 0.05485845f, -0.04452216f, -0.09566048f, 0.04792449f, 0.03990038f, 
    -0.04690204f, 0.32273862f, -0.13124287f, -0.29491580f, 0.00036392f, 0.02044692f, 0.23976569f, 0.05481579f, 
    -0.07172243f, -0.04302580f, 0.01465843f, 0.13937308f, -0.28218248f, -0.03018303f, -0.35012588f, 0.20301910f, 
    0.07674668f, 0.09547137f, -0.13508198f, 0.16982575f, 0.12479615f, 0.09510204f, 0.16492948f, 0.00631277f, 
    -0.23347509f, -0.23524016f, -0.12148078f, -0.13242145f, -0.05890287f, -0.22656336f, -0.14442316f, 0.06886190f, 
    0.18628863f, -0.07127535f, -0.00964922f, 0.10455669f, 0.21121569f, 0.56664366f, -0.22192799f, 0.23491181f, 
    -0.04645927f, -0.14504564f, 0.06037430f, 0.06353428f, 0.24443257f, 0.21418184f, 0.03817657f, 0.10623602f, 
    -0.36581716f, -0.06530342f, 0.29460642f, -0.00007574f, 0.01061737f, 0.16474570f, -0.13108061f, -0.11324856f, 
    0.13988000f, 0.14253739f, 0.01263586f, -0.05156398f, -0.18320984f, 0.02113163f, -0.11263286f, -0.27570844f, 
    -0.06963542f, -0.07647240f, 0.01337487f, -0.15025112f, 0.17713532f, 0.12945601f, 0.02738784f, 0.06367683f, 
    -0.37422448f, -0.47917068f, 0.21323320f, 0.33538103f, 0.00583502f, 0.09663512f, -0.12107367f, 0.08323951f, 
    -0.00204776f, 0.07108717f, 0.03488889f, -0.14880544f, -0.29826021f, 0.05660972f, 0.35292137f, 0.16705924f, 
    -0.10766739f, -0.01728155f, 0.07332251f, 0.14474709f, 0.07759917f, 0.02468311f, 0.06851871f, -0.05593439f, 
    -0.12931471f, 0.46092930f, 0.16638431f, -0.33807710f, 0.06641982f, 0.00035130f, -0.05875427f, -0.08544115f, 
    0.13705254f, 0.05346327f, 0.13337110f, 0.19103062f, 0.02510165f, -0.33592212f, -0.04878814f, 0.18060903f, 
    0.00571091f, 0.12608109f, 0.12471304f, 0.02062217f, -0.06627105f, 0.00050072f, 0.06565920f, -0.04169254f, 
    -0.35136193f, -0.08767758f, 0.09867234f, 0.18135856f, -0.14447027f, -0.07049911f, -0.18143165f, -0.03317194f, 
    -0.09159080f, 0.16127214f, -0.01706901f, -0.05247448f, 0.33760628f, 0.84616667f, 0.44538775f, 0.19299221f, 
    0.05535283f, -0.05204134f, 0.10563336f, 0.09071720f, 0.18167700f, 0.06937801f, 0.08558957f, 0.18302190f, 
    0.21347061f, 0.13858953f, -0.19232653f, -0.58928221f, -0.03427223f, 0.04663087f, 0.19443765f, -0.00873851f, 
    0.04336865f, -0.26285955f, -0.00505889f, -0.04373896f, 0.06256600f, 0.18619791f, 0.31354865f, -0.09584635f, 
    0.09784415f, -0.00000210f, 0.13092752f, -0.00448156f, 0.13060096f, -0.12243569f, 0.14713790f, 0.01349265f, 
    -0.12507768f, 0.05566612f, 0.12274440f, 0.06172447f, -0.02309744f, -0.01384178f, 0.24226870f, 0.08074419f, 
    0.09632785f, -0.01068981f, 0.08361244f, 0.00407940f, -0.34613341f, -0.21050493f, -0.01276036f, 0.11520054f, 
    -0.09148543f, 0.21034937f, 0.19063242f, 0.05703123f, 0.13814528f, 0.04102939f, 0.18985951f, 0.20062284f, 
    -0.34877580f, -0.38222969f, 0.10123920f, 0.18679404f, 0.05828992f, -0.09520000f, -0.04131341f, -0.02152685f, 
    0.07566313f, 0.00607391f, 0.05484496f, 0.04815177f, -0.22369257f, 0.07512636f, -0.05801096f, 0.05146751f, 
    0.28695980f, 0.01638203f, 0.14197583f, -0.04227231f, -0.07361943f, -0.10528898f, -0.03883052f, -0.03683427f, 
    -0.12247055f, -0.27548283f, -0.03671001f, -0.04058168f, 0.13765012f, 0.02238610f, 0.03181024f, 0.01670748f, 
    0.00428492f, 0.17960894f, -0.01597725f, 0.11271101f, 0.03013105f, -0.44206056f, 0.09565082f, -0.08013798f, 
    0.07735527f, -0.12357704f, -0.09919791f, 0.08129080f, -0.06607416f, 0.17102808f, -0.15008190f, -0.16469182f, 
    -0.14911811f, -0.38408104f, -0.33377552f, -0.05319397f, 0.09955161f, 0.00174596f, -0.11903884f, 0.01254542f, 
    0.03858610f, -0.28036234f, -0.05360505f, 0.15612975f, -0.13059971f, -0.26585743f, -0.20909801f, -0.00406978f, 
    -0.00984354f, -0.02511646f, 0.00180155f, 0.09703765f, 0.14083488f, 0.16161503f, 0.08083624f, 0.21498443f, 
    0.31350020f, 0.63064879f, 0.15419748f, 0.11735083f, -0.40665400f, 0.02251481f, 0.06651189f, 0.00368647f, 
    0.09614085f, -0.19602334f, -0.03448659f, 0.00918381f, 0.46687880f, 0.20992868f, -0.26835579f, 0.26135987f, 
    0.11235175f, 0.07242928f, -0.09910299f, -0.02742524f, -0.04346877f, 0.18104883f, 0.19296218f, 0.08098346f, 
    0.50084090f, -0.29467383f, -0.22525144f, -0.25035575f, 0.02274049f, 0.06117368f, 0.11872826f, 0.05190921f, 
    -0.21620758f, -0.00780293f, -0.04352254f, 0.07022368f, 0.08924539f, 0.09213439f, -0.21456872f, 0.09636834f, 
    -0.03104730f, -0.24154893f, -0.08701207f, -0.18024810f, 0.05602869f, 0.03077260f, 0.06225226f, -0.04961937f, 
    -0.00986563f, 0.22844118f, 0.13126309f, 0.11269895f, -0.11401222f, -0.03002888f, -0.08104514f, -0.19001976f, 
    0.01063144f, -0.13142854f, -0.16953374f, 0.03753697f, 0.19949031f, -0.50864440f, 0.01745668f, -0.10645595f, 
    0.06000572f, 0.01691434f, 0.02937108f, -0.11182047f, -0.16232690f, 0.13397473f, 0.10593159f, -0.08649458f, 
    -0.04931035f, -0.01105658f, -0.25615129f, 0.08103194f, -0.15104312f, 0.00868763f, 0.07924711f, -0.13393272f, 
    0.00835159f, 0.08962931f, -0.10104580f, -0.03190316f, 0.19363594f, 0.03856758f, 0.02616643f, -0.05723909f, 
    -0.02853251f, 0.03745532f, -0.02203476f, 0.19142191f, 0.03284020f, 0.14685009f, 0.09333866f, 0.20189312f, 
    0.22411954f, 0.49097109f, 0.25564730f, 0.43133643f, 0.06542815f, -0.12331761f, -0.05966797f, 0.04658140f, 
    -0.07186520f, 0.08711027f, 0.05124754f, -0.10668103f, 0.50164175f, 0.25409666f, 0.08301728f, 0.05031179f, 
    -0.04885085f, -0.15705302f, 0.06242441f, 0.16672032f, 0.06065777f, -0.09132716f, -0.02130873f, 0.05516258f, 
    0.51745081f, 0.24540398f, 0.01090479f, 0.14336817f, -0.07429016f, 0.02956333f, -0.09028330f, 0.02128812f, 
    0.00099018f, 0.04183988f, 0.02569372f, -0.00032574f, 0.64223528f, 0.37202099f, 0.14444162f, -0.08987394f, 
    -0.26822373f, 0.13571197f, 0.12304243f, 0.29536852f, -0.07804347f, -0.05083504f, 0.09820829f, 0.07809056f, 
    -0.27362821f, -0.18684706f, 0.04130214f, 0.17142041f, -0.09124464f, 0.03956140f, 0.03308899f, -0.13182649f, 
    -0.06263924f, 0.27417147f, 0.29172871f, 0.22994496f, -0.20036340f, 0.73217446f, -0.12255587f, -0.19650912f, 
    0.18413980f, -0.17144690f, 0.23178583f, 0.01760028f, 0.06250266f, 0.21139167f, -0.02675655f, 0.20690742f, 
    -0.16363454f, 0.24563420f, 0.20404246f, 0.12493248f, 0.06876762f, 0.12017144f, -0.07233015f, 0.09325060f, 
    0.24800277f, 0.11119232f, 0.29565331f, 0.26356176f, -0.13897184f, 0.05165090f, -0.06245067f, -0.15247414f, 
    -0.10190920f, 0.09293693f, 0.00717907f, -0.05456417f, -0.25478217f, -0.14440036f, -0.14518265f, -0.15575172f, 
    0.04339826f, -0.09793911f, -0.25515142f, -0.04121155f, 0.06427372f, 0.28461796f, -0.10111497f, 0.21762860f, 
    0.10632172f, 0.02223294f, 0.01196577f, -0.03827026f, -0.08007647f, 0.01296545f, -0.00528680f, 0.09672366f, 
    0.03347979f, -0.02245505f, -0.11672350f, 0.10408141f, -0.15904418f, 0.11938257f, 0.01791976f, -0.10497414f, 
    0.19717187f, 0.23967433f, 0.12795903f, 0.18065476f, -0.13618737f, -0.00063290f, -0.12638558f, 0.01986238f, 
    -0.05668464f, 0.13942453f, 0.11280221f, 0.09733306f, -0.32325613f, -0.48608661f, -0.45886022f, -0.10290995f, 
    -0.00012511f, 0.11882981f, 0.34229925f, 0.10576706f, 0.07813837f, 0.03276949f, 0.03815344f, 0.11653912f, 
    0.10715195f, -0.19828108f, 0.12679935f, -0.02948793f, 0.06448269f, 0.18562996f, 0.30155921f, 0.32989958f, 
    0.26021293f, -0.02878679f, 0.05431441f, -0.01838594f, 0.33593273f, 0.35370553f, 0.42932731f, -0.14286375f, 
    0.02361641f, -0.00615285f, -0.02880581f, 0.02963400f, 0.11504164f, 0.10630183f, 0.26802358f, -0.08182056f, 
    -0.36454648f, -0.18384267f, 0.26918268f, -0.19524404f, -0.21599032f, -0.01554396f, 0.25300071f, 0.18609425f, 
    -0.05254653f, 0.01160811f, 0.12745872f, 0.11122316f, -0.28657711f, -0.23909222f, -0.20434771f, -0.16859478f, 
    -0.00839279f, 0.02073197f, 0.07533168f, 0.12140002f, -0.03769159f, 0.11642277f, -0.23618521f, 0.00456327f, 
    -0.07119290f, -0.08338389f, -0.09409528f, -0.17449306f, -0.06438632f, -0.09470917f, 0.24472557f, 0.11358544f, 
    -0.08118670f, -0.02791958f, -0.01168555f, 0.24128401f, -0.08586361f, 0.03285100f, 0.09682512f, -0.17552546f, 
    0.02360316f, 0.11635016f, 0.10218360f, 0.23677577f, -0.02004500f, 0.09595936f, 0.07469863f, -0.16356660f, 
    0.14253247f, 0.01545527f, -0.14661165f, 0.02897971f, -0.08388007f, 0.17790511f, 0.17727485f, 0.14530073f, 
    0.06792299f, 0.14876482f, 0.02647900f, -0.04939985f, -0.02159313f, -0.59614581f, 0.17471722f, -0.64027226f, 
    -0.11916061f, -0.23657852f, 0.04956314f, -0.06739323f, 0.08124789f, -0.02442441f, 0.02716004f, -0.02270355f, 
    0.13266945f, 0.01594675f, 0.09410757f, -0.12577994f, -0.01034225f, -0.09549047f, -0.02842458f, -0.04862073f, 
    0.11938418f, 0.02407239f, 0.03281777f, -0.00746549f, 0.29110116f, 0.33160397f, -0.17921595f, 0.07273917f, 
    0.19515871f, 0.05328236f, -0.00729945f, -0.00822352f, 0.17953418f, 0.34791285f, 0.20702946f, 0.09792539f, 
    0.47591209f, 0.11963893f, -0.31240410f, 0.15465042f, -0.00614763f, -0.05499200f, 0.15082039f, -0.02732604f, 
    0.07863054f, 0.21350057f, 0.32466245f, -0.01213138f, 0.00460147f, 0.09416609f, -0.03207055f, -0.11207356f, 
    0.04619363f, -0.08442219f, -0.04995130f, -0.10401382f, -0.00014946f, -0.16985232f, 0.12058321f, -0.19330758f, 
    -0.32829407f, -0.22341888f, 0.11865959f, -0.28663400f, 0.08256567f, 0.18197301f, -0.09504011f, 0.34694305f, 
    0.04369144f, 0.06653844f, -0.08461403f, -0.07976724f, -0.37509340f, -0.41051856f, -0.27987564f, -0.38664800f, 
    -0.00978341f, 0.04193084f, -0.08522137f, -0.08933337f, 0.08528078f, -0.10085858f, 0.03810467f, -0.08013360f, 
    0.23787762f, -0.36069223f, 0.22422272f, 0.09549484f, -0.06293578f, -0.03989736f, 0.05630573f, -0.12055040f, 
    0.14262538f, -0.02103582f, -0.06901002f, 0.07466469f, 0.05689543f, 0.08644322f, 0.19778904f, -0.12867725f, 
    0.12310395f, -0.06377111f, -0.18579474f, 0.07185347f, -0.00579165f, 0.10645930f, -0.04216832f, 0.03215891f, 
    0.08889759f, 0.12430927f, 0.14698419f, -0.01757426f, 0.12732099f, -0.22134601f, 0.06581739f, 0.18041934f, 
    0.07233037f, 0.07764372f, -0.14103140f, -0.04408633f, -0.00501303f, 0.07054726f, 0.21373896f, -0.12830344f, 
    -0.01179480f, 0.01660632f, 0.17113471f, 0.11387492f, 0.11337367f, 0.20878518f, 0.15036497f, 0.07982482f, 
    -0.09640049f, 0.35919628f, -0.22288303f, 0.19909959f, 0.04665279f, 0.12265395f, 0.22680728f, 0.07832929f, 
    -0.04217634f, 0.17050442f, 0.01965521f, 0.23796532f, -0.11252983f, 0.52758378f, -0.15638873f, -0.09582230f, 
    0.01055706f, 0.02863136f, -0.12440387f, 0.18321608f, 0.06433818f, 0.01893960f, 0.05386185f, -0.11695010f, 
    -0.25652564f, -0.03939769f, -0.25909960f, -0.18362287f, 0.06823844f, 0.16903305f, 0.27986264f, 0.25032496f, 
    0.03882622f, 0.09162053f, -0.03713856f, 0.03260298f, -0.06378468f, -0.28116211f, 0.18702035f, 0.07660695f, 
    0.02565840f, 0.25853273f, 0.08021209f, 0.08168469f, 0.05393913f, -0.14645638f, -0.00170680f, -0.07939160f, 
    -0.25749865f, 0.17840779f, 0.24781419f, -0.11066105f, 0.02278956f, -0.06393836f, 0.27433336f, 0.00397556f, 
    0.03098707f, -0.07607955f, -0.00548851f, 0.00859260f, -0.48416647f, -0.03013151f, -0.13949785f, 0.09071444f, 
    -0.03764827f, -0.13891563f, 0.00867855f, 0.15780824f, -0.02732159f, -0.04075935f, -0.03479799f, 0.11253847f, 
    -0.17045087f, -0.06520474f, 0.02885771f, -0.13427080f, -0.05496643f, -0.03081926f, 0.04616215f, 0.06943480f, 
    0.10074200f, 0.01668956f, 0.00025538f, 0.18629768f, -0.01316095f, -0.05884837f, -0.29223847f, 0.33600560f, 
    0.00613303f, 0.03994773f, -0.03501780f, 0.01799913f, 0.11682609f, 0.00636233f, -0.17170398f, 0.13634032f, 
    0.09755541f, 0.34805104f, 0.04186901f, -0.04180838f, -0.20491825f, 0.08704923f, 0.05595000f, -0.16335504f, 
    -0.06712195f, 0.05048142f, -0.09346675f, -0.14099520f, -0.35608536f, 0.03037228f, 0.01794577f, -0.08592286f, 
    -0.00593550f, 0.00674677f, -0.05701318f, -0.09514856f, -0.06642685f, -0.14932890f, 0.08074387f, -0.34922495f, 
    0.17273849f, 0.24558242f, -0.01885299f, -0.08095507f, 0.28610140f, 0.05521110f, 0.25993660f, 0.10619128f, 
    -0.09082044f, 0.08944254f, 0.12098234f, -0.05146099f, 0.07253715f, -0.07746675f, -0.11087430f, -0.17889906f, 
    0.18551171f, 0.18181065f, 0.04875096f, -0.09027798f, 0.14426810f, 0.07493261f, -0.10591730f, -0.01148131f, 
    -0.26189423f, 0.41310909f, 0.29320484f, -0.00421409f, -0.02521254f, -0.09080590f, 0.07560944f, -0.11138076f, 
    0.28008407f, 0.06137259f, 0.00377806f, 0.07991422f, -0.20816380f, 0.07370277f, 0.28731707f, 0.06469373f, 
    0.07823343f, -0.01589321f, -0.32892236f, 0.05686917f, 0.05887413f, -0.04118251f, -0.00418839f, 0.04560790f, 
    0.46270412f, 0.07216396f, -0.14891809f, 0.06467367f, 0.18802588f, -0.03218864f, 0.02973106f, -0.06944907f, 
    -0.06880021f, 0.02797562f, -0.07034599f, -0.09070873f, -0.20478992f, -0.26035377f, -0.60018575f, 0.28822988f, 
    0.12806228f, 0.25187582f, 0.12032566f, 0.08206996f, 0.21082412f, 0.05139995f, 0.17342809f, -0.02023706f, 
    -0.32168150f, -0.15908565f, 0.03662903f, 0.71498531f, 0.14996012f, -0.01823492f, -0.35096276f, -0.10925097f, 
    -0.07901941f, 0.02459170f, 0.19809447f, 0.21032692f, 0.09511772f, 0.02275736f, -0.40634605f, 0.28012857f, 
    0.07218436f, 0.03118460f, 0.16005875f, -0.13262816f, -0.13104200f, -0.06153764f, -0.00705512f, -0.09551467f, 
    0.03941814f, 0.10153614f, 0.02628596f, 0.22270231f, 0.10782103f, 0.24156722f, -0.01467656f, -0.25465897f, 
    0.06616882f, 0.05752356f, 0.02470747f, 0.22909203f, 0.07907950f, 0.11012302f, -0.00758474f, -0.05158909f, 
    0.23631300f, 0.00990374f, -0.00698916f, -0.13981088f, 0.07763625f, -0.01848728f, -0.10609532f, -0.07727716f, 
    0.29049274f, 0.10654829f, -0.04135327f, -0.03661883f, 0.09875725f, 0.15897782f, 0.22532244f, 0.05284858f, 
    -0.02095133f, -0.03831795f, -0.03393261f, 0.11901136f, 0.03239866f, -0.23921238f, -0.05475304f, 0.06092186f, 
    0.02900699f, -0.02455801f, -0.01014102f, 0.15372783f, -0.13018496f, 0.05037051f, 0.11547612f, -0.06468093f, 
    -0.29341188f, -0.32053101f, -0.17383498f, -0.16116334f, 0.05890371f, -0.06311885f, -0.18136165f, -0.15721424f, 
    -0.04799396f, 0.11366289f, 0.00244044f, 0.13153648f, -0.00248858f, -0.00977342f, -0.08402439f, 0.10450395f, 
    -0.23582757f, 0.00901081f, -0.06561715f, -0.19097051f, -0.04167593f, -0.18619536f, -0.04366058f, 0.07294481f, 
    -0.31775233f, 0.29391760f, 0.09803668f, -0.28168845f, -0.01875767f, 0.28804734f, -0.28936923f, -0.04518929f, 
    -0.17637828f, -0.12661472f, -0.14960277f, -0.19387865f, -0.59544444f, -0.25757048f, -0.31590250f, -0.01157002f, 
    -0.23047285f, 0.02799718f, -0.11844774f, -0.18300153f, 0.33649600f, 0.14757581f, 0.02386825f, 0.16174442f, 
    -0.14181352f, 0.09448074f, 0.32379985f, 0.25325632f, 0.03870669f, -0.01890313f, -0.00243135f, -0.05595024f, 
    -0.17508353f, 0.04443801f, 0.11490506f, 0.20925529f, 0.21742870f, 0.13546999f, 0.21737918f, 0.27250415f, 
    0.14301249f, 0.03297050f, 0.03687746f, 0.00869227f, 0.11800062f, -0.05774789f, -0.00715582f, 0.00022131f, 
    -0.28682515f, 0.37431231f, 0.17634220f, -0.61564589f, 0.24509405f, 0.02863402f, 0.06120939f, 0.01768675f, 
    0.22118108f, 0.00679302f, 0.07727322f, -0.14609458f, -0.07911503f, -0.23660482f, 0.14513279f, 0.32285869f, 
    0.04955452f, 0.23325108f, 0.04677501f, 0.10337566f, 0.03753003f, -0.04783877f, 0.03543049f, -0.17718315f, 
    -0.15958808f, 0.35119712f, 0.00495211f, 0.12353025f, -0.06107132f, -0.16311406f, -0.19297405f, -0.05712775f, 
    -0.09724955f, 0.02620341f, -0.16706479f, 0.09401496f, -0.22029233f, 0.11600843f, 0.04238116f, 0.15501912f, 
    0.13163590f, 0.12950130f, -0.21126829f, -0.12819450f, 0.13748528f, -0.07028683f, 0.11364970f, -0.09170131f, 
    -0.19007353f, -0.05220594f, -0.08850431f, -0.03733203f, 0.04502456f, -0.15945679f, 0.02283535f, 0.02909328f, 
    0.30072179f, -0.16268715f, -0.02364855f, -0.07316885f, 0.18644528f, 0.13707449f, 0.04958123f, 0.38814738f, 
    0.16774365f, 0.02516380f, 0.23019424f, -0.19056116f, -0.06482311f, -0.11988070f, 0.12210513f, 0.00306664f, 
    0.38145322f, 0.27661744f, 0.25641197f, 0.51781923f, -0.00997283f, 0.25416595f, 0.14255689f, 0.06127297f, 
    0.32866454f, 0.02549466f, 0.16955516f, 0.11074584f, 0.03807771f, 0.14198124f, 0.17283618f, 0.24162491f, 
    0.04331955f, 0.02723228f, 0.22653207f, 0.00529497f, 0.11462190f, 0.03647393f, -0.09355714f, 0.07105290f, 
    0.12635042f, -0.17642489f, -0.05305261f, 0.13194327f, -0.11350709f, -0.00250684f, -0.04104845f, 0.20023419f, 
    0.05711116f, -0.02622506f, 0.00683174f, 0.14194395f, 0.11627407f, 0.29088384f, 0.02834873f, 0.35792831f, 
    0.04466985f, -0.06697159f, 0.12042835f, -0.09922575f, -0.12270063f, -0.04999592f, -0.06621800f, -0.02966372f, 
    0.05251820f, -0.10121639f, 0.14006537f, 0.00774862f, -0.07735873f, -0.03485666f, 0.05561548f, -0.08648217f, 
    -0.07057829f, 0.12044608f, 0.04708541f, 0.10324664f, -0.42518413f, 0.11177903f, -0.03803559f, -0.11441940f, 
    0.17534077f, 0.11700474f, 0.06294300f, 0.12105791f, 0.07284537f, 0.19665368f, -0.16378643f, 0.06915717f, 
    -0.30987865f, 0.22312064f, 0.08921149f, -0.14033657f, 0.00556601f, 0.01672404f, -0.07581073f, 0.11948549f, 
    0.01389039f, 0.03042628f, 0.15266779f, 0.07221733f, -0.23892771f, 0.29767945f, 0.20176101f, -0.19954161f, 
    -0.15629163f, -0.07315664f, -0.17836164f, -0.06331182f, -0.14471357f, -0.06765150f, 0.04515949f, -0.08318207f, 
    -0.01105604f, 0.26490125f, -0.27575773f, 0.02344939f, -0.04584321f, 0.10493045f, -0.12293109f, 0.05356438f, 
    -0.15189211f, -0.14744906f, -0.04204563f, 0.06092049f, 0.40285385f, -0.07061022f, 0.08043005f, 0.16771962f, 
    0.19652320f, 0.12673275f, 0.06014036f, 0.28400698f, -0.10157514f, 0.24809098f, -0.10368591f, -0.04148736f, 
    0.59341782f, 0.61272889f, 0.24440382f, -0.03896370f, -0.12519975f, 0.09523413f, 0.04148937f, -0.11834144f, 
    0.10287514f, 0.16078679f, -0.01256854f, 0.17708769f, -0.30402029f, 0.05008642f, -0.31129226f, -0.41821054f, 
    -0.20802604f, 0.12760372f, -0.13858332f, -0.23177633f, -0.02133196f, -0.10138620f, 0.04127657f, 0.06341024f, 
    0.11746576f, 0.01942530f, -0.12540878f, 0.00300417f, 0.13554105f, -0.03336983f, -0.02762567f, 0.03281154f, 
    0.01202506f, -0.17089637f, 0.18685366f, -0.07368238f, 0.42282826f, -0.11122233f, -0.28546095f, 0.05353140f, 
    0.05716677f, 0.14410289f, 0.16351868f, -0.13434598f, 0.27894709f, 0.09221577f, 0.13120814f, -0.01155506f, 
    0.12479685f, -0.14265327f, 0.43483374f, 0.06129628f, -0.36799684f, -0.22883098f, 0.07772755f, -0.10662532f, 
    -0.12144027f, -0.03324635f, 0.08786079f, 0.02263055f, 0.00292172f, -0.26573032f, -0.20237993f, 0.12681781f, 
    0.00492588f, 0.05094429f, 0.09851767f, 0.28417546f, -0.05981705f, -0.05142802f, -0.13744996f, 0.08186600f, 
    -0.16481973f, -0.06766240f, -0.08948915f, 0.06489281f, -0.10415682f, 0.08758805f, 0.32275966f, 0.01837720f, 
    -0.17860425f, 0.01254031f, 0.02043946f, 0.21143629f, -0.05364336f, -0.01873374f, -0.06799322f, -0.00209529f, 
    0.21621488f, 0.12139145f, 0.07133182f, 0.12092456f, -0.10149613f, -0.03833655f, 0.07904399f, -0.06294685f, 
    0.46505633f, 0.01862597f, -0.29974249f, 0.27459484f, 0.01803578f, 0.07088450f, -0.03438182f, 0.09299170f, 
    -0.05233572f, 0.00283060f, -0.02359469f, -0.02670685f, 0.20216128f, -0.58056402f, 0.20397787f, -0.43114904f, 
    0.07645109f, -0.06430927f, 0.14722024f, 0.00897244f, -0.09376366f, -0.12339816f, 0.19850662f, 0.07126670f, 
    0.20741703f, -0.03050393f, 0.20546104f, -0.00263254f, -0.05361402f, -0.03461844f, 0.01453258f, -0.11202712f, 
    -0.18231022f, 0.23044710f, 0.03866530f, -0.06658071f, -0.12433987f, -0.00063098f, -0.00313734f, -0.18147238f, 
    0.06044929f, 0.08278361f, -0.10970069f, -0.20990939f, -0.01525393f, 0.21272057f, -0.01880194f, -0.09207611f, 
    -0.28717160f, 0.15972769f, -0.43270895f, -0.21761940f, 0.14671010f, -0.03575644f, -0.25256911f, 0.25800660f, 
    -0.04691289f, -0.12488584f, 0.30629405f, -0.10373461f, -0.10520930f, 0.20569338f, 0.18574886f, -0.01601872f, 
    -0.12662306f, -0.06659057f, -0.03701109f, 0.02118527f, 0.10636041f, -0.01337458f, 0.15109703f, 0.33129999f, 
    -0.18198116f, 0.14715911f, -0.16169661f, -0.04188299f, -0.10274103f, 0.00137188f, -0.21450399f, 0.19061671f, 
    0.10584957f, -0.08691695f, -0.20625670f, 0.18825661f, 0.18304692f, -0.15104660f, 0.06377519f, 0.20059405f, 
    0.07622006f, 0.12566380f, -0.15731338f, 0.05690946f, 0.01109971f, 0.05363506f, 0.01789920f, 0.09328327f, 
    0.65949208f, 0.36929378f, 0.33505467f, -0.36079088f, 0.04818377f, -0.00934220f, 0.02663520f, -0.18711223f, 
    -0.17001690f, -0.02570956f, -0.05887841f, -0.08551234f, -0.23000504f, -0.12177462f, 0.07234789f, 0.08455658f, 
    -0.04630430f, 0.11129951f, 0.01445391f, -0.00683075f, 0.00760434f, -0.08516531f, 0.06139477f, -0.12387308f, 
    -0.13713452f, 0.16157080f, -0.11550288f, 0.04130314f, 0.08906497f, -0.06197992f, -0.23495252f, 0.03972033f, 
    0.21238716f, 0.04691051f, 0.02313457f, 0.00290374f, -0.00430424f, 0.01571138f, 0.31129816f, 0.07075896f, 
    0.00579150f, 0.06701815f, -0.01823034f, -0.17023629f, 0.12848981f, 0.12513319f, 0.13805668f, 0.19880779f, 
    0.05442889f, 0.32922515f, 0.08091556f, -0.34994420f, -0.12794848f, -0.01579437f, -0.04325062f, 0.06758717f, 
    0.02345979f, 0.12195586f, -0.08667200f, 0.07328516f, -0.39776468f, 0.14332080f, -0.11294486f, 0.15455803f, 
    0.07215235f, -0.13570291f, -0.03904660f, 0.24129835f, 0.21709368f, 0.03614962f, 0.01348011f, 0.07910340f, 
    -0.04612729f, 0.19654736f, -0.21769600f, 0.12923627f, -0.01282327f, 0.01285507f, 0.24331927f, 0.06103429f, 
    -0.17645331f, 0.04302826f, 0.00987481f, -0.01090871f, -0.10368805f, -0.36228994f, 0.02229473f, 0.06911391f, 
    0.10039795f, 0.13572451f, 0.15226571f, 0.04527145f, -0.05783337f, 0.04098732f, -0.02113377f, 0.03120391f, 
    0.18577355f, -0.06320596f, -0.02763697f, 0.28335983f, 0.05789080f, -0.03358740f, -0.09626315f, 0.07554702f, 
    0.07655396f, 0.03421173f, -0.07135188f, -0.13094111f, 0.08484016f, -0.03783426f, 0.30019769f, -0.12466616f, 
    0.09604628f, -0.05223667f, 0.02609422f, 0.08368745f, 0.06579604f, -0.07224231f, 0.03498481f, -0.01300699f, 
    -0.22882687f, 0.01593881f, -0.14072236f, 0.12432545f, 0.09615670f, 0.09418003f, 0.05963638f, 0.04115237f, 
    -0.06682819f, 0.07301679f, 0.35592014f, 0.24378328f, 0.13923505f, 0.22689705f, 0.09401475f, 0.22499613f, 
    0.02483600f, 0.05022332f, 0.02409684f, -0.19880742f, 0.13399287f, -0.11156435f, -0.18094316f, 0.26139557f, 
    -0.52512342f, 0.07616490f, 0.14141320f, 0.13235490f, 0.00777429f, -0.01733910f, 0.01459926f, 0.07592738f, 
    0.06987101f, 0.08040591f, -0.18590054f, 0.05291780f, 0.03580801f, -0.15359269f, 0.07257852f, -0.03478095f, 
    -0.08936736f, -0.03218367f, -0.00337911f, -0.02114185f, 0.12561065f, -0.02717661f, -0.22082709f, 0.14133200f, 
    -0.11049265f, -0.14212494f, -0.10325322f, 0.39794174f, 0.03030315f, -0.05683154f, 0.21493049f, -0.04419861f, 
    -0.05589050f, 0.04146105f, -0.00812908f, -0.05352548f, -0.36354744f, 0.33068594f, 0.35149518f, 0.40158501f, 
    -0.09615026f, -0.07297542f, 0.21263006f, -0.10197963f, 0.01306643f, -0.10736554f, -0.00668583f, 0.14403573f, 
    -0.60327679f, 0.51308835f, 0.02649944f, 0.24278235f, 0.08051055f, -0.05925236f, -0.13746463f, 0.08035666f, 
    -0.10350934f, 0.07892020f, 0.17256548f, -0.01481619f, 0.24095282f, -0.22075135f, 0.52280664f, 0.28880319f, 
    0.11433176f, 0.22188784f, 0.22824098f, 0.09494686f, -0.04576360f, -0.08067726f, -0.07314983f, -0.03894500f, 
    -0.03608626f, 0.21876396f, 0.10634326f, 0.08291198f, -0.09603615f, 0.18991435f, 0.04593580f, 0.01685708f, 
    -0.04695713f, 0.10703261f, 0.01583259f, 0.05083803f, -0.37687215f, 0.46267971f, 0.12179123f, 0.29195556f, 
    0.14777130f, 0.07055604f, 0.07725248f, 0.02276761f, -0.03838165f, 0.09974921f, 0.07801022f, 0.05672942f, 
    0.16610372f, -0.20848545f, 0.47931471f, -0.29033783f, 0.15029646f, 0.00553723f, -0.18620722f, 0.37472636f, 
    0.07645471f, -0.08634613f, -0.07657836f, -0.08878876f, 0.10803227f, -0.17712493f, 0.33524239f, -0.02901047f, 
    -0.03404345f, 0.02962304f, -0.01081038f, -0.07945282f, -0.04671227f, -0.05277407f, 0.17682920f, -0.02453375f, 
    0.03688230f, -0.18724726f, 0.08132832f, -0.04853688f, 0.07049203f, -0.00848151f, -0.31434619f, -0.04131818f, 
    0.05549395f, -0.01281610f, 0.00805052f, -0.02264952f, -0.14291286f, -0.11704013f, -0.05837641f, 0.07071617f, 
    -0.10572024f, 0.02321174f, 0.16121587f, 0.05006027f, 0.03820031f, 0.01612118f, 0.07800787f, 0.15534218f, 
    0.04258580f, -0.46942160f, -0.01668854f, 0.06459717f, -0.03926213f, -0.03390336f, -0.00032753f, -0.07470201f, 
    -0.01443601f, 0.03900694f, 0.06429587f, -0.02332301f, -0.06003762f, -0.09365801f, 0.33149913f, -0.09564781f, 
    0.25692943f, 0.06425063f, -0.15082474f, -0.11621752f, 0.13134249f, 0.12913488f, -0.04199364f, 0.05593741f, 
    0.11568072f, 0.00000440f, 0.06510831f, -0.12122122f, -0.37967527f, -0.05920853f, -0.02608186f, -0.17261849f, 
    0.10264947f, -0.10031686f, 0.06479829f, 0.23028144f, -0.44151855f, -0.18534137f, 0.14395729f, 0.07806744f, 
    -0.08099134f, 0.10649211f, 0.08611709f, -0.06680365f, 0.00709927f, 0.03175353f, 0.08636723f, 0.21754053f, 
    0.45872346f, 0.25716558f, -0.00888557f, -0.15590470f, -0.11484761f, -0.07207642f, 0.17925511f, 0.03415196f, 
    -0.01521538f, 0.15234266f, 0.07215299f, -0.05417340f, -0.16667049f, 0.31312233f, 0.16438796f, -0.03312197f, 
    -0.15788278f, -0.12796560f, -0.15852886f, -0.23321442f, -0.32699275f, -0.31278327f, -0.20534368f, -0.44916260f, 
    0.08291139f, 0.20360006f, 0.04159671f, -0.01611197f, 0.24589378f, -0.12034485f, 0.11452814f, 0.36099187f, 
    -0.10449053f, -0.05388861f, 0.10795643f, -0.06715846f, 0.46455404f, -0.08410047f, -0.04746960f, -0.09574182f, 
    0.12852739f, -0.05876428f, -0.03027617f, 0.08908565f, 0.08018918f, 0.03351742f, -0.09201656f, -0.47830144f, 
    0.58019459f, 0.28703260f, 0.19181482f, 0.09310662f, -0.30800509f, -0.01638039f, -0.02222706f, -0.03928554f, 
    0.09068716f, 0.04730389f, -0.10222735f, -0.02477016f, -0.08072588f, 0.28807342f, -0.05254234f, -0.23358870f, 
    0.03263817f, 0.19185907f, 0.02134619f, 0.08049799f, 0.06236636f, 0.00571661f, 0.04503557f, 0.05176064f, 
    0.54637402f, -0.02943664f, -0.06407218f, -0.14231619f, 0.25634083f, -0.04590939f, 0.02265067f, -0.03053747f, 
    0.02303868f, -0.06771447f, 0.02371442f, -0.19707000f, 0.02028977f, -0.75577742f, -0.56539464f, 0.08261479f, 
    -0.14824748f, 0.00672155f, -0.14318593f, -0.05537763f, 0.13505864f, -0.07259247f, 0.02665546f, -0.09835485f, 
    0.11408783f, 0.03300056f, 0.16171578f, 0.38624233f, -0.09101520f, 0.06856405f, 0.13238664f, -0.02212004f, 
    0.15713271f, 0.13618247f, 0.20182231f, 0.17640042f, -0.01030434f, -0.25042483f, -0.12015335f, 0.60187721f, 
    0.10794777f, 0.01533392f, 0.12086348f, -0.03869515f, -0.26062390f, -0.08117020f, -0.15515438f, 0.06398893f, 
    -0.02589457f, 0.05712888f, 0.20143473f, 0.39476922f, -0.00069969f, 0.50548065f, 0.40646282f, 0.08675570f, 
    0.01146272f, 0.01789331f, 0.10318781f, 0.46303058f, 0.15364432f, 0.34389150f, 0.14570253f, 0.08720829f, 
    0.28142664f, 0.01551470f, 0.00788328f, -0.02476947f, -0.00827857f, 0.01364904f, -0.16488732f, -0.09285071f, 
    0.22758088f, 0.26581714f, -0.10467110f, 0.25238779f, 0.06203317f, 0.12682126f, 0.10013971f, 0.12636721f, 
    -0.03070496f, -0.08983154f, -0.13724115f, 0.03591098f, 0.05604586f, -0.05401857f, 0.18044434f, 0.19008380f, 
    0.02063659f, 0.16446956f, 0.18532519f, 0.24039498f, -0.00564843f, -0.02845577f, 0.04761712f, 0.02600846f, 
    -0.07862626f, 0.16897812f, 0.04518625f, -0.11998279f, -0.01105453f, 0.01017669f, -0.11358460f, -0.00509852f, 
    -0.04205453f, 0.15741588f, 0.15069026f, 0.05139501f, 0.49459943f, -0.14128354f, -0.06435882f, 0.08737663f, 
    0.15791798f, -0.13727337f, -0.11666951f, 0.06181054f, 0.05713125f, 0.00402133f, -0.08018646f, 0.05806639f, 
    0.01962863f, 0.07482146f, -0.03949115f, -0.02967946f, 0.15479285f, 0.17329933f, -0.06383148f, 0.09912005f, 
    0.18928392f, -0.17766787f, 0.07144576f, 0.32777295f, 0.26066884f, 0.00669804f, 0.20538016f, 0.06540486f, 
    -0.10232063f, 0.05650649f, 0.09193712f, 0.03192999f, -0.07936163f, -0.19515453f, 0.04791004f, 0.06956249f, 
    -0.29713893f, 0.31224483f, -0.40240106f, 0.00563666f, -0.30003801f, 0.23632504f, 0.08752374f, -0.02356553f, 
    -0.06355329f, -0.13289051f, -0.20352612f, 0.00837025f, 0.02326721f, -0.08533080f, -0.42717966f, 0.03430373f, 
    -0.06966756f, 0.04957505f, -0.01307583f, 0.05361621f, -0.10101041f, 0.12083833f, -0.00123749f, 0.14195064f, 
    0.03462860f, 0.14265117f, 0.25489226f, 0.22265069f, 0.11805512f, -0.12473749f, -0.16416720f, -0.04165841f, 
    -0.25090197f, 0.19430587f, 0.04506127f, 0.22128892f, 0.15447961f, -0.22382274f, 0.14104810f, 0.11653298f, 
    0.05851256f, 0.06844282f, 0.09129762f, 0.05987855f, -0.02576223f, -0.12667421f, -0.07877351f, -0.00317958f, 
    -0.01675217f, 0.11602348f, 0.01631026f, 0.03820079f, 0.12696113f, 0.07915194f, 0.17140627f, 0.02121772f, 
    0.13985610f, 0.05033548f, 0.04991189f, 0.11400688f, -0.18723969f, -0.23868926f, 0.21331953f, -0.07945877f, 
    -0.03237930f, -0.01343428f, 0.07517671f, 0.15830643f, 0.00794652f, 0.12911311f, 0.11365010f, -0.06781574f, 
    -0.31609470f, 0.30027965f, 0.40675655f, 0.18686534f, -0.02653824f, 0.05113700f, 0.13484469f, -0.07312924f, 
    -0.17545636f, 0.05370775f, -0.13435961f, 0.07476871f, -0.27659705f, 0.13631561f, -0.08581226f, 0.08548652f, 
    -0.03311963f, 0.07439646f, -0.05780635f, 0.30884761f, -0.08743756f, 0.06054437f, 0.16168797f, 0.20162901f, 
    -0.20139031f, -0.26637703f, -0.17025742f, -0.08926197f, 0.11054137f, -0.23594826f, 0.04137690f, 0.28888601f, 
    -0.11121792f, 0.21747138f, -0.12822266f, -0.22164014f, 0.02881265f, -0.33628562f, -0.20329034f, -0.09804416f, 
    0.06202201f, 0.06395458f, 0.03983068f, 0.02363340f, 0.05720606f, -0.00425483f, 0.12375092f, 0.14942604f, 
    0.27093357f, -0.20903799f, -0.16466270f, -0.06861615f, -0.01393385f, -0.03620167f, -0.13632709f, -0.02835884f, 
    0.08091433f, 0.08794197f, 0.10539977f, -0.12620249f, 0.00618672f, -0.16675761f, 0.14532577f, -0.17127812f, 
    -0.06380156f, 0.04821865f, 0.17957495f, 0.29130712f, 0.16846226f, -0.13814278f, 0.16493391f, 0.23627910f, 
    0.17193696f, 0.10263471f, 0.08535348f, 0.18619856f, -0.00868373f, -0.06146010f, -0.12790123f, -0.08304536f, 
    -0.01041891f, 0.03954145f, -0.08981147f, 0.03657224f, 0.19348781f, -0.19893239f, 0.20579131f, -0.31696358f, 
    -0.13989663f, -0.04608386f, -0.03512672f, -0.10113721f, -0.01921629f, -0.11035088f, 0.13077338f, -0.28508174f, 
    0.27579257f, 0.00133755f, 0.06094685f, 0.16841544f, 0.15812337f, 0.03393701f, -0.08518522f, 0.18402366f, 
    -0.04524759f, 0.00050223f, 0.07453435f, 0.10079371f, 0.25350326f, 0.05165089f, 0.18376486f, 0.26042038f, 
    -0.04944740f, 0.07091033f, -0.00062404f, 0.00103570f, 0.23098956f, 0.23544729f, 0.12505597f, 0.30397820f, 
    -0.35576347f, -0.18776363f, -0.40678850f, -0.36088067f, 0.05250251f, -0.05169321f, 0.06799214f, 0.10374055f, 
    -0.11937866f, 0.03452985f, -0.00751696f, -0.02708064f, -0.37167028f, -0.35132381f, -0.87178671f, -0.19055009f, 
    -0.02689080f, -0.13911311f, -0.07376364f, 0.04119835f, 0.02363150f, 0.08970983f, -0.06237348f, -0.02584878f, 
    0.44517279f, 0.38524821f, 0.20862040f, 0.26167408f, 0.01782814f, -0.13635986f, -0.10757525f, 0.06736591f, 
    0.20148218f, 0.10632714f, 0.11785071f, -0.00726793f, 0.38705435f, -0.09274133f, -0.17166726f, 0.04469947f, 
    -0.07784189f, 0.13214515f, 0.11968029f, 0.05270901f, -0.15889636f, -0.01749762f, -0.05478137f, 0.01084704f, 
    -0.50757462f, -0.32000878f, 0.32938027f, -0.34248188f, 0.08840867f, -0.02203326f, 0.18846034f, 0.19855803f, 
    0.18373048f, 0.06852507f, 0.07102269f, -0.05229037f, 0.01291959f, -0.43131423f, -0.04958024f, -0.59168935f, 
    -0.02869879f, -0.12812845f, -0.17620315f, 0.00945293f, 0.24481557f, 0.14053020f, 0.08230288f, -0.09196175f, 
    0.45958775f, -0.01221127f, 0.12921882f, 0.02110089f, -0.05097787f, -0.07425784f, -0.05507144f, 0.00134165f, 
    0.16366212f, -0.13974050f, -0.05463744f, -0.01463741f, -0.09184238f, -0.45827836f, 0.45336536f, -0.03465327f, 
    0.07167655f, -0.17220078f, 0.19421813f, 0.04094448f, -0.12918530f, -0.20319629f, -0.14068110f, -0.11255211f, 
    0.30239910f, -0.18329029f, -0.10879803f, -0.03116746f, 0.08841640f, 0.24824101f, -0.03869157f, -0.00632159f, 
    -0.10292722f, -0.15998982f, 0.13423112f, -0.15495312f, -0.13452084f, 0.03211291f, -0.15604737f, -0.11954304f, 
    -0.06209826f, 0.08261041f, 0.13830510f, 0.09905314f, 0.09794971f, 0.19163378f, -0.11439689f, 0.24834862f, 
    -0.72688860f, -0.40824676f, -0.36891341f, -0.47033134f, -0.10779360f, 0.16482824f, 0.08322526f, 0.12037898f, 
    0.04901019f, 0.03099895f, 0.02294466f, -0.03705439f, 0.45696881f, 0.35543922f, 0.34100088f, 0.18449354f, 
    -0.09689420f, 0.35348013f, 0.29912579f, 0.05914178f, -0.06262250f, -0.03756092f, 0.01803260f, 0.04591646f, 
    -0.11904525f, 0.04538022f, -0.22008571f, 0.28647506f, -0.17017090f, -0.00875647f, -0.05112329f, -0.05454351f, 
    -0.36974764f, -0.02708471f, 0.03231604f, -0.12654558f, -0.03174147f, -0.20300460f, 0.27302492f, 0.05505563f, 
    -0.20162179f, 0.31557024f, -0.06288019f, -0.08330271f, 0.13560100f, 0.10246689f, 0.23420452f, -0.16145036f, 
    -0.08778137f, 0.17205021f, -0.02394067f, 0.44586074f, 0.14688517f, -0.14707018f, 0.21817613f, 0.18514755f, 
    0.13113034f, 0.19989000f, 0.27498701f, -0.10300317f, 0.19097146f, -0.01807129f, 0.09733904f, 0.15752542f, 
    -0.02456139f, -0.09047760f, -0.25002503f, 0.02270972f, -0.10316278f, 0.01193782f, -0.03906795f, -0.06976159f, 
    0.25816020f, 0.29968059f, -0.15579472f, 0.14066674f, -0.02850379f, -0.14158174f, 0.21378376f, 0.18806030f, 
    -0.03708223f, 0.01403700f, 0.04609517f, 0.09947363f, -0.31850839f, 0.25851089f, 0.30990592f, 0.07161207f, 
    0.14224963f, -0.11298987f, 0.10558809f, 0.14934093f, 0.00558616f, -0.03085012f, -0.06789450f, 0.02713233f, 
    -0.27298614f, 0.20285594f, -0.19563963f, 0.63873184f, -0.08890073f, -0.06421968f, 0.00738675f, -0.01357433f, 
    -0.08203519f, 0.14457658f, -0.07325576f, 0.00490781f, 0.23142716f, 0.17828079f, 0.49782732f, -0.07454943f, 
    -0.04825140f, -0.13584369f, -0.00522150f, -0.07773598f, -0.08696949f, -0.00924517f, -0.03597619f, -0.06893199f, 
    0.41643488f, 0.00048540f, 0.14631139f, -0.15014778f, 0.12875764f, 0.17296629f, 0.15754755f, 0.06563013f, 
    0.00114970f, 0.10522445f, 0.10519332f, 0.06730571f, -0.27071843f, 0.29350567f, -0.22784999f, 0.08559910f, 
    -0.16384915f, 0.12537414f, 0.02512905f, 0.12358623f, 0.00057203f, 0.04753218f, 0.00942605f, 0.10629556f, 
    0.39374840f, -0.39292690f, 0.48643342f, 0.06028464f, 0.01394153f, 0.16715270f, -0.30395091f, 0.17282078f, 
    -0.15988362f, 0.14461483f, 0.05395278f, -0.09615129f, -0.04629608f, -0.57214504f, 0.18913758f, -0.03814532f, 
    -0.17437339f, -0.07407417f, 0.05109460f, -0.13941285f, -0.29039741f, 0.01790373f, 0.05739985f, 0.22239515f, 
    0.09666912f, 0.01913833f, 0.09252304f, -0.24771650f, 0.07127551f, 0.11892828f, -0.12635663f, -0.04140329f, 
    -0.06664512f, -0.15181345f, -0.09138139f, -0.13360007f, -0.08463734f, 0.13680094f, -0.02479616f, 0.00484855f, 
    0.01792838f, -0.13462186f, -0.11218326f, -0.08741897f, 0.14916760f, 0.11330571f, -0.18492781f, 0.03590938f, 
    0.13862069f, 0.33850616f, 0.08170538f, 0.06237746f, 0.21381731f, 0.09068727f, 0.01947722f, -0.03119582f, 
    -0.10604838f, 0.03260403f, -0.10416023f, -0.07350166f, 0.11425932f, -0.42543998f, 0.40806893f, -0.26748633f, 
    0.01287035f, 0.06353017f, -0.03694323f, -0.16433936f, 0.03259471f, -0.01813236f, 0.03659228f, 0.01247757f, 
    0.03672208f, 0.12495596f, -0.14605634f, -0.08726158f, 0.10908958f, 0.07413780f, -0.06550203f, -0.03633794f, 
    0.04010522f, 0.00581488f, 0.11903074f, -0.09740074f, 0.59588534f, -0.15178736f, 0.03941380f, 0.29794270f, 
    -0.21328582f, -0.08327949f, 0.16848458f, 0.19850783f, 0.02386422f, -0.18686995f, 0.08704417f, -0.02859810f, 
    0.04954150f, 0.08434562f, 0.49530104f, 0.03108119f, -0.02982372f, -0.01297322f, -0.06889138f, -0.33736500f, 
    0.10925003f, 0.13810322f, -0.07336939f, 0.26511917f, 0.15071887f, -0.31014177f, -0.24060680f, 0.03474866f, 
    -0.19631787f, 0.04049782f, 0.18298285f, 0.01412107f, 0.29619250f, 0.33468002f, 0.14955625f, 0.20307069f, 
    -0.03186511f, -0.27428949f, 0.23610738f, 0.22885981f, 0.03069138f, 0.04481124f, 0.08329900f, -0.16728941f, 
    -0.20463656f, 0.02489865f, 0.11201215f, -0.07629052f, 0.01614572f, 0.33889952f, -0.13878559f, -0.13238557f, 
    -0.06579838f, -0.22430910f, -0.01003274f, 0.08134570f, 0.11173832f, 0.08184099f, 0.11379971f, 0.32755932f, 
    -0.76499957f, -0.17114598f, -0.17159301f, 0.22538711f, 0.14646819f, -0.21448191f, -0.08411688f, 0.09757864f, 
    -0.01213858f, 0.11341032f, 0.27519599f, 0.24545807f, 0.23513633f, -0.03560222f, 0.14171821f, 0.35388488f, 
    0.29552093f, -0.06895327f, -0.03917019f, -0.01116288f, -0.15946311f, 0.05870018f, -0.12700766f, -0.24089900f, 
    -0.22978391f, -0.03810075f, 0.07625109f, 0.10262789f, -0.00584042f, 0.21483232f, 0.22179726f, 0.11861170f, 
    0.03870944f, 0.21557511f, 0.05984655f, 0.22607765f, -0.31823021f, 0.35550255f, 0.00479195f, 0.21245325f, 
    -0.13863637f, -0.19037165f, 0.02831432f, 0.27203110f, -0.02526798f, 0.06582159f, -0.13708015f, -0.13897260f, 
    -0.12179261f, -0.05602062f, 0.07991382f, -0.28138793f, 0.25700837f, 0.06948006f, 0.19553055f, -0.05588486f, 
    0.03589949f, -0.21329178f, -0.12729062f, -0.22869009f, 0.31076914f, 0.13412456f, 0.33622774f, 0.09849653f, 
    0.00068737f, -0.10211790f, 0.16970900f, -0.08410195f, 0.02304046f, 0.05869374f, 0.14640111f, 0.03499127f, 
    0.12541874f, -0.04989797f, 0.16658506f, 0.04202173f, 0.15477225f, -0.13144875f, -0.30239412f, 0.08998176f, 
    0.00240203f, -0.06889186f, -0.15809086f, -0.32210183f, -0.10401072f, 0.26255101f, -0.10263167f, 0.10649943f, 
    -0.08032081f, -0.09489077f, 0.05599341f, -0.00656444f, 0.20067739f, 0.08216688f, 0.19346692f, 0.17516007f, 
    -0.20604803f, -0.30521712f, 0.10068706f, -0.07341538f, -0.02777418f, -0.07896113f, -0.06739186f, 0.12392515f, 
    -0.00042652f, -0.08807904f, 0.09614069f, 0.09696203f, 0.08446451f, 0.40108752f, -0.08989448f, 0.42271212f, 
    0.15875329f, 0.06546883f, 0.01941288f, 0.00946769f, -0.13660315f, 0.03408426f, -0.06596141f, 0.05482001f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.09363597f, 0.11276090f, -0.00154747f, 0.08407515f, 0.24820597f, -0.19350074f, -0.14198898f, 0.03010510f, 
    -0.02988656f, -0.03633989f, 0.01969019f, 0.04787663f, 0.25852317f, -0.06781030f, 0.11111199f, -0.01324085f, 
    0.08147340f, 0.00046400f, 0.24624844f, -0.12365971f, 0.31214628f, 0.28553334f, -0.02350019f, 0.01227801f, 
    0.09882127f, 0.02818708f, 0.16369919f, 0.03545834f, 0.02579501f, 0.08345166f, 0.07936167f, -0.05079234f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.38318586f, 0.41137657f, 0.26657096f, 0.12043411f, -0.52179533f, 0.05181993f, 0.05332310f, -0.01326081f, 
    -0.05574132f, -0.01915342f, 0.17143273f, 0.22483383f, -0.58198345f, 0.29348496f, -0.08719159f, -0.06533282f, 
    -0.41615781f, 0.47297990f, -0.84504974f, 0.25369203f, -0.21008484f, -0.51806343f, 0.25044432f, -0.04741760f, 
    0.05968052f, -0.37108299f, -0.19969584f, 0.08564367f, -0.19731195f, 0.01688166f, 0.20011146f, -0.03612205f, 
    -0.86778086f, 0.11588646f, 0.06238507f, 0.33249494f, 0.03718259f, -0.81071264f, -0.16091645f, -0.16479483f, 
    0.16717197f, 0.15170228f, 0.00338881f, -0.23171692f, -0.24456409f, 0.08549727f, 0.29844600f, -0.05737697f, 
    0.48175782f, -0.08103615f, -0.11743914f, 0.27293614f, -0.00089103f, -0.09402014f, -0.11716946f, -0.14321664f, 
    0.49520272f, 0.24669161f, -0.28010026f, 0.26204124f, -0.07388988f, 0.49188739f, 0.04197526f, -0.70992458f, 
    0.27832946f, 0.32500085f, 0.20745200f, -0.00327738f, 0.28797492f, -0.21607451f, 0.04042084f, 0.11683404f, 
    -0.33875689f, -0.13957933f, 0.09079291f, -0.94182211f, -0.26196861f, 0.46514958f, 0.02362610f, 0.13462421f, 
    0.27481392f, -0.17934139f, 0.29845279f, -0.82264280f, 0.10245843f, -0.05345503f, -0.12573007f, 0.05082170f, 
    0.09867494f, 0.22687289f, 0.31558225f, -0.30444038f, -0.42601833f, -0.93976521f, 0.35427117f, -0.12345417f, 
    0.54796219f, -0.30928531f, 0.18167581f, -0.05160340f, 0.02377642f, 0.01809899f, 0.38499108f, -0.17513357f, 
    -0.16973235f, 0.15765664f, -0.22861964f, -0.01103503f, -0.32674810f, -0.11597501f, -0.64851648f, -0.07208037f, 
    -0.13045950f, -0.49380144f, -0.06684571f, 0.24293758f, -0.35809064f, -0.43457457f, 0.20307583f, 0.35700217f, 
    0.19070157f, 0.40339503f, 0.17154446f, -0.01072358f, 0.34751028f, -0.20091252f, 0.00633198f, -0.00049563f, 
    -0.33209774f, 0.12994283f, 0.18349466f, -0.12563902f, 0.08547250f, 0.48468021f, 0.18747796f, -0.14364286f, 
    0.30311051f, -0.13675243f, 0.31204876f, 0.02572492f, -0.15992136f, 0.17562832f, 0.25044712f, 0.00688122f, 
    -0.09909235f, -0.04443900f, 0.17374614f, 0.11482681f, -0.52104670f, -0.33938345f, -0.23697491f, 0.20470315f, 
    -0.62135851f, -0.33111277f, 0.09989437f, -0.18971467f, -0.80425328f, -0.41505817f, -0.13900886f, 0.39838928f, 
    -0.54736251f, 0.14657772f, -0.14631595f, 0.08709422f, 0.28377759f, -0.12351109f, -0.46450201f, -0.11531445f, 
    -0.20392212f, -0.08608925f, 0.20018253f, 0.45903605f, 0.32008907f, -0.16315986f, 0.08730907f, 0.08687966f, 
    -0.14060602f, 0.17411904f, -0.10391520f, 0.01565542f, -0.20706597f, 0.16173457f, 0.22375761f, 0.01014586f, 
    -0.39515913f, -0.27569029f, -0.20078315f, 0.14734010f, -0.19344002f, 0.12557451f, 0.02850118f, -0.08699799f, 
    0.32065558f, -0.99840343f, 0.07551793f, 0.38287929f, -0.57748520f, -0.19852467f, -0.40411726f, -0.10566849f, 
    -0.46453306f, -0.08600906f, 0.43997958f, -0.74137557f, 0.09942317f, -0.97535986f, -0.21606867f, -0.01519091f, 
    0.12043674f, -0.35045728f, 0.51545799f, -0.94703490f, 0.13011576f, 0.07305352f, -0.29796225f, -0.45566469f, 
    0.25451225f, -0.03327993f, 0.09094103f, -1.10603523f, 0.16607675f, -0.28652632f, -0.35459581f, 0.35967374f, 
    -0.02926948f, -0.10314185f, 0.14629748f, -0.67749065f, 0.07879960f, 0.65615577f, -0.39996609f, 0.03345660f, 
    0.40936270f, -0.15437073f, 0.08339425f, 0.24639161f, 0.12537791f, -0.06418215f, -0.18839386f, -0.10315195f, 
    0.08119582f, 0.17465523f, -0.23032156f, -0.35552287f, -0.42362958f, 0.19680992f, -0.17394805f, -0.27063033f, 
    -0.03462794f, 0.28828242f, -0.55022347f, 0.30379733f, 0.06105079f, -0.06735484f, -0.62349433f, 0.17768972f, 
    0.32382950f, -0.31634411f, -0.32571900f, -0.22660041f, 0.39469218f, -0.63143814f, 0.24266453f, 0.14460950f, 
    -0.12959494f, 0.15497118f, -0.65323901f, -0.54245394f, -0.00460553f, -0.71766716f, 0.05685114f, -0.00099082f, 
    -0.43796313f, 0.65245026f, -0.03666038f, -0.21480915f, 0.20640427f, 0.16674283f, 0.31664464f, -0.32488275f, 
    0.31657597f, -0.11116941f, 0.11457203f, 0.23960884f, 0.31535465f, -0.51284271f, -0.39779010f, -0.59969401f, 
    0.08490248f, 0.40625095f, 0.09147248f, -0.33565071f, -0.25405636f, 0.40415582f, -0.57611042f, -0.05833123f, 
    -0.55784613f, -0.11016264f, 0.09571304f, 0.08801291f, 0.03333661f, 0.04665734f, 0.34178087f, 0.02625541f, 
    0.34165636f, -0.33288991f, 0.03378911f, 0.26352268f, 0.34631515f, 0.07048316f, -0.82970452f, 0.02164960f, 
    -0.30427298f, 0.31526864f, -0.07518673f, -0.79194653f, 0.20335315f, 0.10552001f, -0.75114530f, 0.02285834f, 
    -0.10668534f, -0.67339033f, -0.31506726f, 0.02521805f, -0.51540029f, -0.96326232f, 0.18799402f, -0.15202579f, 
    -0.12876345f, 0.02572634f, -0.64413470f, -0.14855601f, 0.28255263f, -0.45713621f, 0.38291949f, -0.00360840f, 
    -0.17445867f, -0.59536946f, 0.16779448f, -0.30740920f, 0.39716080f, -0.46260595f, 0.13469124f, 0.23943874f, 
    0.33447960f, -0.53062814f, 0.14620799f, 0.34069631f, -0.19835904f, -0.27824965f, 0.07003634f, 0.36162391f, 
    0.16163170f, -0.49852508f, -0.30001023f, 0.37868479f, 0.16486125f, -0.32630971f, 0.47279784f, 0.04907034f, 
    0.29849669f, 0.12842749f, -0.09630740f, -0.43659669f, 0.03065118f, -0.17123452f, 0.10879185f, -0.17871825f, 
    -0.19705588f, -0.10863432f, -0.21504635f, 0.18995775f, -0.13288529f, -0.15461947f, -0.54247820f, -0.66460431f, 
    -0.45746559f, -0.21350436f, 0.31705347f, -0.46988779f, 0.28227997f, -0.00475747f, 0.78375667f, 0.30956864f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13443373f, 0.16848852f, 0.13025475f, -0.18807308f, -0.19983053f, 0.11516448f, -0.00772380f, 0.05386875f, 
    0.20148392f, 0.16691330f, 0.05208101f, 0.13565803f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
