#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.07796187f, 0.67620164f, 0.55533332f, -1.11537254f, -0.11260334f, -0.71038377f, -0.05695025f, 0.32124984f, 
    0.05320952f, 0.64134818f, -0.48836502f, -0.42277139f, -0.08254042f, -0.37821537f, 0.52805477f, -0.03687941f, 
    0.30040410f, -0.13069744f, -0.56621343f, -0.37912691f, -0.48709562f, -0.69076383f, -0.71130544f, -0.81685930f, 
    -1.05567324f, 0.18576312f, 1.03622913f, 1.03615093f, 0.18079756f, 0.03088170f, -1.29083228f, -1.11747444f, 
    -0.57455856f, 0.33335906f, -0.33487213f, 0.18123409f, -0.39151952f, -0.23272428f, 0.30148450f, -0.38506329f, 
    0.03390089f, -0.23652907f, 0.31217608f, -0.05685997f, 0.08239104f, -0.26460946f, 0.21204248f, 0.15415454f, 
    -0.03879311f, 0.06622951f, -1.30459034f, 0.57436740f, 1.08498979f, 1.04282629f, 0.20707779f, -0.32252553f, 
    -0.34582984f, -0.67851126f, 0.02203959f, 0.19598687f, -0.43072483f, 0.20112494f, -0.41668802f, 0.66012841f, 
    0.01617927f, -0.10915688f, 0.10776944f, -0.25517499f, -0.19106872f, 0.21448189f, 0.22519308f, -0.09888967f, 
    0.00680377f, 0.00358337f, -0.26682675f, -0.65546024f, -0.64066768f, -0.40196669f, -0.94842678f, -0.85933113f, 
    -0.75557089f, -0.47308752f, -1.24161887f, -1.00451195f, -0.63780946f, -0.51879197f, -0.42555690f, -0.57586473f, 
    -0.41552624f, 0.17117015f, 0.24562776f, -0.01592216f, 0.00434046f, 0.37159586f, -0.02425129f, 0.17204158f, 
    0.02336804f, -0.39434156f, -0.16123843f, -0.07638277f, -1.24385226f, -0.40453607f, 0.61299819f, -0.07140554f, 
    0.12646860f, -0.07265504f, -0.34054568f, -0.02469724f, 0.45463058f, 0.45922112f, 0.12164112f, 0.46967027f, 
    0.20579173f, 0.07223002f, -0.56761920f, -0.16311373f, -0.30054218f, 0.24860211f, -0.56090420f, -0.41897637f, 
    0.19697963f, 0.78381121f, 0.47290781f, 0.32662514f, 0.05042182f, -0.58042240f, 0.08415577f, -0.58900577f, 
    -0.61707139f, -1.14570713f, 0.67229986f, 0.62910414f, 0.04993496f, -0.08380110f, -0.30232477f, 0.35879609f, 
    0.10386831f, 0.27675697f, 0.78947055f, 0.08555970f, -0.49773386f, -0.45384127f, -0.65187401f, 0.37906817f, 
    -0.35741109f, 0.26180527f, -0.22676888f, 0.52013302f, 0.32419208f, -0.16084959f, -1.60233271f, -1.33815670f, 
    0.12850258f, 0.95588797f, 0.69028646f, 1.23429465f, -0.03230800f, -0.33463481f, 0.06569061f, 0.98806095f, 
    0.15226378f, 0.16272303f, -0.25087047f, 0.03389213f, -0.57499236f, -0.35731712f, -0.34491521f, -0.00911791f, 
    -0.24150452f, -0.16809925f, -0.01981987f, -0.28747231f, -0.27262828f, -0.03352752f, 0.09838663f, -0.39851877f, 
    -1.00123060f, -0.50282621f, 0.11682166f, -0.33457282f, -0.99788016f, -1.03183210f, -1.62712443f, -0.62272519f, 
    -0.50511342f, 0.36387208f, 0.91480708f, 0.61185420f, 0.01620962f, 0.09274096f, -0.08145824f, -0.23348840f, 
    -0.28193367f, -0.13291177f, -0.45291349f, 0.17855650f, -0.37966695f, -0.28440785f, 0.27806920f, -0.21658251f, 
    -0.68103069f, -0.87947208f, -1.02532029f, -0.59052366f, -0.72518384f, 0.99584764f, -0.22600988f, -0.09761963f, 
    0.31159028f, 0.29394272f, 0.04304933f, -0.63645232f, -0.55490643f, -0.28384504f, -0.31406674f, -0.62753391f, 
    -0.05239533f, -0.14209308f, -0.45179936f, -0.91204637f, -0.45508340f, -0.02906492f, 0.16063023f, 0.05053302f, 
    -0.14015335f, -0.26927912f, -0.84178531f, -0.99693757f, -1.32149303f, -1.71872437f, 0.42086139f, -0.13611215f, 
    0.31604365f, 0.79478854f, 0.50313830f, 0.02067297f, -0.30009082f, -0.01794309f, -0.21869592f, 0.17205600f, 
    0.17542605f, -0.29902345f, -0.23248990f, 0.25096664f, 0.00906765f, -0.25972694f, -0.45934218f, 0.37064618f, 
    -0.33246553f, -0.15744914f, -0.46792379f, -0.61202121f, -0.10932039f, 0.40295044f, 0.37496337f, 0.36904639f, 
    0.92525911f, 0.36297086f, 0.31004101f, 0.04019179f, 0.00683269f, 0.02937825f, 0.21978034f, 0.19040132f, 
    -0.42682350f, 0.09189088f, 0.28623083f, -0.58663118f, -0.14841864f, 0.25806472f, 0.22704720f, -0.12313782f, 
    0.27964896f, -0.07750076f, -0.09423850f, 0.24250209f, 0.02853746f, 0.06652954f, 0.34629771f, -0.58837146f, 
    0.51368451f, -0.53548110f, -0.11112135f, 0.43001679f, -0.18301643f, 0.93705177f, -0.58491963f, -0.34978130f, 
    0.79413271f, -0.69517452f, -0.01621693f, 0.46357462f, -0.13537970f, -0.15570828f, -0.54598063f, 0.08837579f, 
    0.20037597f, -0.01084618f, -0.05543898f, 0.03043789f, -0.17600666f, -1.17941523f, -0.17738689f, 0.65949714f, 
    0.37548068f, -1.21179390f, -1.11202240f, -0.01254273f, -0.60317576f, -0.30790326f, -0.36823079f, -0.09209287f, 
    0.38331646f, -0.14483455f, -0.09415591f, 0.15042019f, -0.32374814f, -0.07988559f, 0.23961450f, -0.49841973f, 
    0.28090689f, 0.26413438f, 0.04800516f, 0.25848106f, 0.61375058f, -1.06562042f, -0.75152373f, -0.17803769f, 
    0.56569296f, 1.13324857f, -0.36819041f, -0.15896627f, -0.07685152f, 0.35054266f, 0.41088799f, -0.45856696f, 
    -0.36293587f, -0.74940181f, 0.61967802f, -0.03360055f, 0.20918249f, -0.06619229f, 0.13128456f, 0.64138943f, 
    0.03907254f, -0.09286762f, -0.26319706f, 0.11912254f, -0.19224378f, -0.20794047f, 1.02720976f, 0.44907618f, 
    -0.49419031f, 0.04610395f, 0.31850961f, 0.09626758f, 0.38161620f, 0.75298488f, 0.50261426f, -0.15953068f, 
    -0.63436657f, -0.54036456f, -0.44166857f, 0.09991428f, -0.43938550f, 0.11570510f, -0.11190564f, -0.01999207f, 
    0.01476344f, -0.32232612f, -0.01341064f, -0.11219440f, 0.14124097f, -0.19451843f, -0.11389522f, 1.16770029f, 
    1.56987095f, -0.42998216f, -1.06458414f, -0.50826877f, -0.77013326f, -0.48629567f, 0.42127272f, -0.83115894f, 
    -0.62552744f, 0.25205719f, -0.02226594f, 0.72415137f, 0.02778447f, -0.10190351f, -0.10541576f, -0.08549551f, 
    0.34943831f, -0.11792903f, -0.32087660f, 0.17587142f, 0.26270762f, 0.00916524f, -0.35801518f, 0.01869624f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.00520831f, 0.24459171f, 0.52065754f, -0.39364502f, 0.25781134f, 0.47174948f, 0.54005986f, 0.55439287f, 
    -0.46414837f, 0.23927438f, 0.51473087f, 0.73549724f, 0.54239756f, 0.29253414f, 0.40962556f, 0.66727191f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.74287593f, 0.06008192f, 0.17524986f, 0.18755500f, 0.03305773f, 0.13400941f, -0.08952981f, 0.05410298f, 
    -0.01869227f, -0.20427968f, 0.13793844f, -0.16082960f, -0.34725556f, 0.48978704f, 0.23404044f, -0.25432304f, 
    -0.14766276f, -0.07216886f, -0.49041012f, 0.02398641f, -0.00785651f, -0.13727316f, 0.02996309f, 0.03391606f, 
    -0.79167545f, -0.29932100f, 0.09312446f, -0.26951155f, 0.04616937f, -0.10830401f, 0.08307549f, 0.08665971f, 
    -0.00116179f, -0.01773218f, -0.13386619f, -0.03976226f, 0.48939800f, 0.48316130f, -0.06441563f, -0.24980612f, 
    0.16807662f, 0.26131094f, 0.13529362f, 0.04486783f, -0.14902225f, -0.07511722f, 0.11099134f, -0.05819793f, 
    -0.07356979f, 0.08682553f, 0.27976280f, -0.11497322f, -0.03034751f, 0.48100266f, -0.00653395f, -0.04437921f, 
    -0.04454179f, -0.26212537f, -0.21050026f, -0.18111816f, 0.29848334f, -0.44886184f, -0.23175858f, 0.03900050f, 
    0.19497247f, 0.04214071f, -0.26810908f, -0.16410179f, -0.05677080f, -0.14731744f, -0.15207444f, 0.07429264f, 
    0.64744353f, 0.29483396f, 0.45012820f, -0.27829561f, -0.17488477f, 0.07032744f, 0.17327158f, -0.05296493f, 
    -0.03841699f, -0.05112207f, -0.06409392f, -0.13398315f, 0.53529197f, 0.53249848f, -0.09481495f, -0.43882620f, 
    0.11454652f, -0.17203176f, -0.08800469f, -0.01119882f, 0.05634617f, -0.12140512f, 0.03516964f, 0.03699676f, 
    0.30852404f, 0.04060226f, 0.14993574f, -0.00961345f, 0.10222622f, 0.11150306f, -0.40718803f, -0.30467814f, 
    -0.18798561f, -0.02681285f, 0.01666362f, 0.08322766f, 0.18035059f, -0.06781927f, -0.05808477f, 0.01364060f, 
    0.11691025f, 0.15507172f, -0.05747357f, 0.11057550f, 0.00622949f, -0.08673174f, -0.02468206f, 0.10208759f, 
    0.09415174f, -0.02796892f, -0.09842838f, 0.06618202f, 0.01128960f, 0.05876790f, 0.09778322f, -0.09107561f, 
    -0.11600269f, -0.22693305f, -0.29284090f, -0.24085952f, -0.46815589f, -0.60487717f, -0.07671581f, -0.19076028f, 
    -0.22596748f, -0.20354214f, -0.15488407f, -0.00392938f, -0.13521597f, -0.29555902f, -0.26600868f, -0.28492910f, 
    0.32618561f, 0.29878855f, 0.02482359f, -0.47762930f, 0.04300860f, -0.09330904f, 0.10905467f, -0.35224399f, 
    -0.02417786f, -0.09330732f, -0.11770228f, -0.14424951f, 0.57852596f, 0.29780689f, 0.29182857f, -0.08849764f, 
    -0.22904666f, -0.05288566f, 0.04681421f, -0.44036773f, 0.13838668f, -0.04625236f, -0.21907735f, -0.00953612f, 
    -0.50411236f, -0.09666744f, -0.40970665f, -0.09919674f, 0.06722198f, 0.05083664f, 0.09512419f, 0.16872922f, 
    0.05180872f, -0.11172070f, 0.00823501f, 0.06667263f, 0.20140341f, -0.11063787f, -0.71064913f, -0.09381659f, 
    0.13584991f, -0.31488585f, -0.14275090f, -0.05168076f, 0.02725286f, 0.06191950f, -0.12577268f, -0.06318018f, 
    0.02869036f, -0.17449611f, 0.12133092f, -0.14821275f, 0.10769385f, 0.01385171f, -0.23243412f, -0.05996993f, 
    -0.38150105f, -0.04234744f, -0.29727492f, -0.28299731f, 0.25003037f, -0.21443687f, -0.12752938f, -0.54171640f, 
    0.13069761f, -0.53022945f, -0.19558252f, -0.01160967f, -0.00161790f, 0.03677706f, -0.05054763f, -0.01993906f, 
    -0.35016370f, 0.14372632f, -0.21846382f, -0.03721772f, 0.02975439f, -0.20066959f, 0.00406207f, 0.00495893f, 
    0.03828064f, 0.01515722f, 0.08017326f, 0.07526369f, 0.34500656f, 0.27174604f, 0.35377643f, 0.02327439f, 
    -0.07943301f, -0.08765249f, -0.43783280f, 0.04874242f, -0.11294302f, 0.01045148f, 0.10430577f, -0.07576625f, 
    -0.39539286f, 0.11045738f, -0.14978811f, -0.03467733f, 0.04131729f, 0.12998094f, -0.18270610f, 0.30730551f, 
    -0.20660083f, -0.00919188f, 0.10750034f, 0.07651841f, -0.09180525f, -0.73808593f, -0.06609615f, -0.43364289f, 
    -0.14625305f, -0.01823694f, 0.12220391f, 0.19153327f, 0.02858250f, -0.05474589f, 0.17036739f, 0.09557001f, 
    0.66568220f, -0.07273992f, -0.47586370f, 0.10851668f, -0.12429792f, 0.01809596f, 0.09313327f, 0.02553570f, 
    -0.03799387f, -0.16256188f, -0.37821320f, 0.13040981f, -0.39675206f, -0.02599891f, -0.15706807f, 0.12888965f, 
    -0.06283955f, 0.17810932f, -0.16677789f, 0.26685229f, 0.11276817f, -0.17912823f, 0.06849947f, 0.09761555f, 
    0.43340120f, 0.54867071f, -0.04296418f, -0.40062031f, 0.03846567f, -0.02433196f, 0.09213257f, 0.08109424f, 
    0.02485327f, 0.03161563f, -0.29790977f, -0.47640419f, 0.08269189f, 0.42661577f, 0.09454522f, -0.32860634f, 
    0.00289381f, 0.26168001f, -0.19550094f, -0.41052902f, 0.08731504f, -0.04715904f, -0.08512516f, -0.24422950f, 
    0.12039251f, -0.10215244f, 0.10650852f, 0.12318739f, -0.07160100f, 0.11023754f, 0.09087565f, -0.08045835f, 
    0.02441576f, 0.06790294f, 0.15774168f, 0.09133945f, -0.17732680f, 0.05926863f, -0.06782215f, -0.02499658f, 
    0.11846770f, -0.21492366f, 0.16392621f, 0.13968411f, 0.13002476f, 0.12520468f, 0.15036975f, 0.00591712f, 
    -0.50277901f, 0.36706609f, -0.10500778f, 0.06401370f, -0.34645885f, 0.21113162f, 0.17390510f, -0.15931478f, 
    -0.06186389f, 0.06682510f, 0.04420334f, -0.00083468f, -0.66154110f, 0.17976664f, -0.07337412f, 0.04051486f, 
    0.07977629f, 0.00760903f, 0.02124152f, 0.05474404f, 0.10748068f, -0.27751115f, 0.03796449f, 0.00869383f, 
    0.86999422f, 0.59267664f, 0.61539984f, 0.44307330f, 0.00577750f, -0.10634688f, -0.03555053f, -0.15621462f, 
    -0.02999855f, 0.09213380f, 0.01971024f, 0.02030094f, 0.32406196f, -0.20664848f, -0.01088577f, -0.18322641f, 
    -0.10916948f, -0.02791691f, -0.10885475f, 0.14760230f, -0.10968877f, 0.01175657f, -0.05803191f, 0.23272796f, 
    0.03584751f, -0.20225152f, -0.00048177f, 0.03939693f, 0.03159111f, 0.01979993f, -0.02920926f, -0.15858376f, 
    0.21706483f, 0.45971289f, -0.17580453f, 0.27457950f, -1.14423525f, -0.26621389f, 0.92282593f, -0.33649480f, 
    -0.09520632f, 0.05495249f, -0.08701541f, 0.16974054f, -0.05920865f, 0.00241538f, -0.01189946f, -0.02197673f, 
    0.11039445f, 0.36120445f, -0.59230131f, 0.11582624f, 0.04083305f, -0.09074728f, -0.04198111f, 0.09950273f, 
    -0.09403991f, -0.07073854f, 0.00174011f, 0.01317325f, -1.51174879f, -0.57593983f, 0.01346268f, -0.37800646f, 
    -0.04241763f, -0.19437960f, -0.28107917f, -0.09978049f, 0.06094981f, -0.02610402f, -0.05449032f, -0.04611893f, 
    0.16601154f, -0.51264763f, -0.38325974f, 0.18830007f, 0.25671622f, -0.03133539f, -0.13574895f, 0.02284097f, 
    -0.01101450f, -0.32910067f, -0.10624545f, 0.08241953f, 0.13462907f, 0.15842313f, 0.13961037f, 0.13606209f, 
    0.05107554f, -0.05345259f, 0.14169674f, -0.19122657f, 0.00709845f, -0.21721120f, 0.08645264f, -0.15138313f, 
    -0.10667890f, -0.21833259f, 0.02096964f, 0.30957565f, 0.01954311f, 0.04687583f, 0.03339069f, 0.22878462f, 
    -0.00112475f, 0.09656040f, 0.16454425f, -0.05885636f, -0.41803509f, -0.67362314f, -0.13151766f, -0.09016674f, 
    0.12159201f, 0.01962468f, 0.01652612f, -0.12140164f, 0.05486462f, 0.02771736f, -0.04905695f, -0.04637153f, 
    -0.70562071f, 0.60632527f, 0.92475939f, 0.31616676f, -0.10536578f, -0.05285322f, 0.08486850f, 0.02553206f, 
    -0.16928883f, -0.21267499f, -0.04995410f, -0.15651232f, 0.25853527f, 1.12726545f, 0.48003465f, 0.44740105f, 
    -0.12160876f, 0.04255587f, 0.33887726f, -0.22705631f, 0.00193795f, 0.07491805f, 0.00259609f, 0.12036773f, 
    0.00991512f, -0.36614683f, -0.05795271f, 0.14559643f, 0.00848280f, 0.00573767f, 0.17252836f, 0.11659995f, 
    0.14894590f, -0.17085236f, -0.12544820f, 0.00540931f, -0.51567364f, 0.06284184f, -0.23116407f, -0.23116823f, 
    0.02997039f, -0.02354236f, -0.02581802f, 0.07978895f, 0.12254874f, -0.39372954f, 0.19343805f, 0.33716625f, 
    0.01701985f, 0.03739750f, -0.87962300f, 0.19192579f, 0.06549246f, 0.12472650f, 0.17741136f, -0.11220989f, 
    -0.06316647f, -0.07381851f, 0.00238718f, -0.06276608f, 0.04506060f, -0.30407789f, -0.17414014f, 0.16489689f, 
    0.04826675f, 0.20096178f, 0.06765884f, 0.23129150f, 0.05285835f, 0.11572262f, 0.07628765f, -0.02171116f, 
    -0.24077204f, -0.62569988f, -0.17967418f, -0.23895606f, -0.07112760f, -0.05749333f, 0.04073539f, -0.02780996f, 
    -0.00735035f, -0.11329827f, 0.08219459f, 0.02366237f, -0.40761372f, -0.05062822f, 0.39006716f, -0.21014844f, 
    0.25719833f, 0.18535352f, -0.23095259f, -0.59176928f, 0.11306235f, -0.03084309f, 0.01899452f, 0.03112780f, 
    0.49530399f, -0.42268008f, 0.00861042f, -0.21149498f, -0.09257361f, -0.13083118f, -0.08353887f, 0.05094606f, 
    -0.10761148f, 0.02716876f, -0.17084593f, 0.11204111f, 0.16937092f, -0.48089078f, 0.32771903f, -0.04990740f, 
    -0.40095457f, 0.22941215f, -0.09637885f, 0.06540280f, -0.12014536f, -0.01291113f, 0.13890451f, -0.14652571f, 
    0.33407703f, 1.17792451f, -0.33014843f, -0.29016748f, -0.38310823f, -0.13519922f, -0.04983599f, -0.24464191f, 
    -0.21045102f, 0.01886882f, -0.16476758f, 0.15388353f, -0.13961160f, -0.41836569f, -0.03245658f, 0.23220393f, 
    -0.18749927f, 0.02448747f, -0.14773509f, 0.09071817f, 0.01850991f, 0.08280124f, -0.09442979f, 0.04619929f, 
    0.38968530f, 0.14266519f, 0.15058672f, -0.07405461f, -0.01560964f, -0.04699919f, 0.03126698f, -0.10045776f, 
    0.20912661f, 0.43125495f, -0.60333198f, 0.07267467f, -0.12905267f, -0.10662490f, 0.19243886f, 0.51943105f, 
    0.14728139f, -0.02500260f, 0.13171548f, -0.15734088f, 0.04861136f, -0.09140886f, 0.17848405f, -0.01319177f, 
    -0.82851350f, 0.51581317f, -0.27581817f, -0.62337911f, 0.23878783f, 0.17281850f, -0.05379477f, -0.05924549f, 
    -0.54961026f, -0.11957636f, -0.13103557f, -0.15757424f, -0.05934971f, -0.21235871f, -0.22226612f, 0.25730157f, 
    0.07906857f, 0.04161086f, 0.22568490f, 0.11617323f, -0.04005085f, 0.03484879f, -0.02837115f, -0.10549441f, 
    0.03163066f, -0.20455754f, 0.00512362f, 0.25743318f, 0.23347290f, 0.11226074f, 0.00978618f, -0.08822915f, 
    0.07253172f, 0.06758511f, 0.10523479f, 0.19971462f, 0.30169854f, -0.12062460f, 0.12470014f, 0.45102265f, 
    0.06316949f, 0.03254835f, 0.13649575f, -0.16546988f, 0.03097441f, 0.00969624f, -0.02213424f, 0.29329866f, 
    -0.06025977f, 0.44011965f, -0.36501512f, -0.87748605f, 0.23823713f, 0.24767435f, 0.08692219f, 0.08827373f, 
    -0.36755919f, -0.02702919f, -0.25108379f, -0.28881785f, -0.25433496f, -0.78850228f, 0.30699080f, -0.31577030f, 
    -0.30876213f, 0.09902757f, -0.13485964f, -0.07606968f, -0.00682026f, 0.04746167f, 0.07208976f, 0.14332533f, 
    0.03560410f, 0.09610375f, -0.30689251f, 0.33818960f, 0.06420780f, 0.07939983f, -0.08729020f, 0.02064668f, 
    -0.14327611f, -0.09482902f, -0.12575766f, -0.20400441f, 0.20845050f, 0.60902256f, -0.71708721f, -0.30620763f, 
    -0.03700684f, 0.12243614f, 0.02889627f, -0.06693158f, -0.05728482f, -0.19777411f, 0.18377696f, 0.12851542f, 
    0.32542223f, -0.16811001f, -0.27941617f, 0.05811723f, -0.05449258f, -0.13186486f, -0.09961097f, 0.22490655f, 
    0.04743702f, 0.10958917f, 0.20208737f, -0.06769207f, -0.45403719f, 0.09643160f, 0.21184611f, 0.25093788f, 
    -0.01183562f, 0.10059040f, -0.24241787f, 0.01362313f, -0.00660524f, 0.00798350f, 0.03410139f, -0.02237366f, 
    0.02413979f, 0.27968603f, -0.31614646f, -0.05444247f, -0.02090050f, -0.07952682f, 0.07181488f, -0.16320102f, 
    0.18304366f, -0.27675670f, 0.24668784f, 0.51966298f, 0.30715418f, 0.06209855f, 0.03957454f, 0.48020837f, 
    -0.07010808f, 0.00324185f, 0.09069353f, 0.15188639f, 0.10799199f, -0.15126251f, 0.03343695f, -0.02467784f, 
    -0.40443882f, -0.79974508f, 0.06944728f, 0.53426665f, -0.02263770f, 0.13936180f, -0.09560361f, -0.13966589f, 
    0.11062261f, -0.02306327f, -0.06407253f, 0.12218341f, -0.05674945f, 0.14029922f, -0.03999553f, 0.09298716f, 
    0.08276895f, -0.04055585f, 0.04412550f, 0.01236187f, 0.08927833f, 0.07446116f, -0.00597653f, 0.01516417f, 
    0.27356061f, 0.19529793f, -0.08569714f, -0.01029586f, 0.03949643f, 0.16627659f, 0.18927941f, -0.29829237f, 
    0.01297172f, -0.43863812f, -0.00078433f, -0.19182496f, 0.26026970f, 0.38538787f, -0.07505585f, 0.22063608f, 
    0.02537159f, -0.04944151f, -0.08512956f, 0.13370045f, 0.05405511f, -0.18267655f, -0.08829387f, 0.10348763f, 
    0.22303677f, -0.32063177f, -0.37114692f, -0.05057260f, -0.18034948f, -0.09988726f, 0.04970322f, -0.12274737f, 
    -0.09591710f, 0.12223097f, 0.04108337f, 0.02390475f, 0.27194494f, 0.26811790f, 0.40226948f, 0.10920393f, 
    -0.17887945f, -0.10558873f, -0.17264998f, -0.00360099f, -0.10125949f, 0.20394552f, 0.03819906f, 0.03767730f, 
    -0.06036717f, 0.09239818f, -0.05370637f, 0.26960486f, 0.01142655f, -0.00572791f, 0.01743759f, -0.00075665f, 
    0.00489061f, -0.08522344f, -0.04399713f, 0.19649516f, -0.42633763f, 0.14750095f, 0.05875394f, 0.17612259f, 
    -0.07885551f, -0.22671348f, -0.19856936f, 0.13664819f, 0.01034050f, -0.10702875f, -0.19070922f, 0.05947217f, 
    0.26173982f, 0.14759937f, 0.26169479f, -0.01182767f, -0.10822153f, -0.00754492f, 0.03631191f, 0.04665206f, 
    0.02809271f, -0.14019570f, -0.28707361f, -0.02670371f, 0.04902783f, -0.04968776f, -0.13656305f, -0.04338100f, 
    0.01638123f, -0.13474309f, -0.11443021f, -0.02571452f, -0.01216466f, -0.39740023f, -0.57968640f, -0.34246537f, 
    0.08928606f, -0.12616239f, 0.32022464f, -0.03263947f, -0.18296707f, 0.00702727f, 0.03698146f, -0.02081333f, 
    -0.04395825f, -0.14623287f, -0.03376981f, -0.16253890f, -0.55250150f, -0.57554924f, 0.26173142f, 0.05130706f, 
    -0.38130948f, 0.00133803f, -0.55302852f, -0.19531229f, -0.15919146f, 0.15048686f, -0.34437957f, 0.10923623f, 
    -1.17794907f, 0.20816377f, -0.50454092f, -0.52348310f, 0.21297082f, 0.18195415f, -0.03347072f, 0.16253242f, 
    0.04673250f, -0.07939261f, -0.05671284f, 0.05857372f, 0.10472845f, 0.02962329f, 0.08955087f, 0.25918394f, 
    -0.21823950f, 0.01180743f, 0.02356059f, -0.16199386f, 0.06372409f, -0.18399706f, 0.04991325f, -0.25556087f, 
    -0.30970311f, -0.13750842f, -0.07855379f, 0.22505599f, 0.00422980f, 0.09611736f, 0.04056302f, -0.02346611f, 
    0.00118632f, -0.15066509f, -0.31082842f, -0.69221932f, -0.54286748f, 0.16629164f, -0.13448824f, 0.11980972f, 
    -0.07259697f, -0.11717544f, 0.08132492f, 0.06595700f, 0.00899408f, 0.08557466f, -0.04239960f, 0.07071538f, 
    -0.43946648f, -0.94726974f, 0.91683918f, 0.12214761f, 0.01258828f, 0.01623234f, -0.04926244f, 0.15857083f, 
    -0.02936079f, -0.00476138f, -0.06628428f, -0.08126866f, -0.00376937f, 0.28241667f, 0.28650513f, 0.01066886f, 
    0.24388106f, 0.03727915f, -0.02870739f, 0.16525570f, 0.02583948f, -0.04253055f, -0.03003149f, 0.10824527f, 
    -0.00848054f, -0.30999482f, 0.24162053f, -0.02249607f, -0.33623812f, -0.56186926f, 0.05742102f, -0.11043058f, 
    0.22568306f, 0.03543772f, 0.32062793f, -0.09947553f, -0.39522558f, 0.15005866f, -0.40120187f, -0.26837692f, 
    0.10847214f, 0.15154855f, -0.09398020f, -0.15139589f, 0.11468895f, 0.29136613f, 0.01692509f, -0.20122474f, 
    -0.52998513f, -0.45616722f, 0.45419511f, 0.01770744f, -0.00734181f, -0.01062684f, -0.09868143f, -0.01493545f, 
    0.23869218f, -0.14849402f, 0.11575694f, -0.02739046f, 0.36377010f, 0.15129068f, 0.39535639f, -0.16943346f, 
    0.22469988f, 0.13362847f, -0.09814897f, -0.15099058f, -0.01755719f, 0.07715326f, -0.02492717f, 0.01084328f, 
    -0.19552793f, -0.23089832f, -0.06105088f, -0.31505769f, -0.20568222f, -0.02421897f, 0.07179946f, 0.02718437f, 
    0.13803019f, -0.19256382f, 0.02806291f, -0.31984207f, 0.06599723f, -0.54974300f, -0.27220210f, -0.33249059f, 
    0.02045367f, -0.14889787f, -0.16847162f, 0.31533492f, -0.03337613f, -0.11162592f, -0.00429754f, -0.15498053f, 
    -0.39829692f, -0.17164798f, -0.21785755f, 0.11325678f, 0.19645628f, -0.11303159f, -0.15812494f, -0.17128770f, 
    0.00929036f, 0.19862820f, 0.08708993f, 0.15646040f, 0.51659060f, 0.10910772f, -0.24009320f, 0.02294304f, 
    0.11699166f, 0.31247887f, -0.26813295f, -0.17231460f, -0.15502828f, 0.12390199f, 0.29230949f, 0.16260089f, 
    0.24970959f, -0.02105939f, 0.26582152f, -0.04414599f, 0.46546456f, 0.24515262f, 0.01543778f, 0.35367507f, 
    0.11278501f, 0.10740842f, -0.02434072f, 0.26996177f, 0.17549549f, -0.33836877f, 0.39073443f, -0.07692458f, 
    -0.07030331f, -0.24534570f, 0.29320970f, 0.02854214f, -0.24632920f, 0.12091214f, -0.07349869f, -0.22072536f, 
    0.32523960f, -0.22894745f, -0.10027061f, -0.05159194f, -0.04014423f, 0.02672932f, -0.04978335f, -0.11609425f, 
    0.11669636f, -0.03814549f, -0.22491042f, -0.02918489f, 0.31922272f, 0.07789031f, -0.24487409f, -0.16233237f, 
    0.01011535f, -0.05670338f, -0.07396632f, 0.03377066f, -0.11246724f, -0.06407325f, -0.00832962f, -0.16153899f, 
    0.51861602f, 0.00817263f, -0.32999912f, -0.04371571f, -0.14190154f, -0.06904102f, 0.17051780f, 0.22931242f, 
    0.03610237f, 0.27470765f, 0.41847348f, 0.28089657f, -0.15519550f, -0.77094936f, -1.10495341f, -0.21717612f, 
    -0.06881174f, 0.38983667f, 0.31569809f, -0.24268772f, 0.02828036f, -0.02875839f, -0.00792242f, 0.02826781f, 
    0.04782948f, -0.25998503f, -0.62565529f, 0.38844472f, -0.01210886f, 0.21341766f, -0.13032837f, -0.02994569f, 
    0.05663787f, -0.07044416f, 0.01689850f, -0.03831852f, -1.18331420f, -1.03916991f, -1.42533648f, 0.09247170f, 
    -0.33676603f, 0.11007725f, 0.10695779f, -0.77382833f, 0.08462238f, -0.01916148f, 0.08459664f, 0.03717417f, 
    -0.26028514f, -0.37707418f, 0.10929085f, 0.04190886f, -0.12904719f, -0.06318205f, -0.27945727f, 0.02701666f, 
    0.03123969f, 0.21959817f, -0.13883778f, -0.24671362f, -0.03259578f, 0.55365688f, 0.78232616f, -0.08324579f, 
    -0.04671691f, -0.02851669f, -0.27350050f, -0.08058667f, -0.13026653f, -0.10429631f, -0.03287836f, 0.18854538f, 
    -0.30534968f, -0.17182419f, 0.55995727f, 0.27954885f, -0.09823626f, -0.03477186f, 0.15739788f, 0.07420252f, 
    0.29450673f, 0.30635968f, 0.20974533f, 0.04601280f, -1.70965493f, -0.92688113f, -0.76282054f, -0.11493632f, 
    -0.21422628f, -0.04813327f, -0.23675619f, -0.29708830f, -0.10714170f, -0.07603931f, -0.11861326f, -0.00886379f, 
    -0.63264400f, -0.16699789f, 0.04995685f, -0.16763315f, -0.27170718f, -0.13206078f, -0.16445862f, -0.04046826f, 
    -0.11213496f, 0.21767139f, 0.08740263f, 0.24087936f, 0.15029454f, 0.58683091f, -0.39181224f, 0.82463324f, 
    -0.17554985f, 0.09130276f, -0.08558020f, 0.53505492f, 0.04286883f, -0.11992354f, 0.13193119f, 0.02889649f, 
    -0.01407024f, -0.06403571f, 0.30690196f, -0.14834026f, 0.05669576f, 0.08924681f, -0.22150400f, -0.00217615f, 
    -0.02294417f, -0.00318733f, 0.30561393f, -0.17136045f, 0.43729651f, 0.28587863f, 0.34140503f, -0.35674879f, 
    0.04509828f, 0.07865708f, 0.17230564f, -0.06606465f, 0.10990945f, 0.09382614f, -0.03097703f, -0.20398921f, 
    -0.44680241f, -1.07260418f, -0.73065495f, -0.14812844f, 0.20531014f, -0.56550920f, -0.47487846f, -0.29827729f, 
    -0.15491350f, -0.01092065f, -0.18819657f, 0.02530077f, -0.08435728f, -0.24008571f, -0.03850345f, 0.17342527f, 
    -0.17692934f, -0.02438580f, 0.03402863f, 0.46495396f, 0.03973990f, 0.03949698f, 0.22758619f, 0.08697872f, 
    -0.32609713f, 0.17909546f, -0.08302860f, -0.31438968f, -0.08047492f, 0.03531717f, -0.08058130f, 0.05171453f, 
    -0.01458133f, 0.03453651f, -0.00380909f, 0.02026493f, 0.87050080f, -0.31520063f, 0.01448759f, -0.73355204f, 
    0.13936780f, 0.10248033f, 0.21540534f, -0.00858140f, 0.05892476f, 0.16359209f, -0.11157747f, 0.02721492f, 
    -0.12232083f, -0.23078570f, -0.06670033f, 0.28964648f, -0.02258700f, 0.10018261f, 0.11749438f, -0.08101697f, 
    0.05243769f, -0.14933302f, 0.10485218f, 0.05907080f, -0.73216581f, -0.01127004f, -0.28001371f, 0.17135783f, 
    -0.22251908f, -0.02846202f, 0.01756897f, 0.04980757f, 0.10430228f, 0.04927743f, -0.00557003f, -0.02656661f, 
    0.29333240f, -0.11047651f, -0.23659456f, -0.14761919f, -0.17254716f, -0.15665661f, 0.02813906f, -0.09115331f, 
    -0.07697605f, 0.14934516f, -0.05274012f, -0.06803838f, -0.45078528f, -0.12600602f, 0.03420305f, -0.00471834f, 
    0.24999844f, 0.05778348f, 0.23301929f, 0.15419894f, -0.01433304f, -0.02628947f, -0.15577212f, -0.08647747f, 
    0.41980568f, -0.07025179f, 0.14616524f, 0.06896155f, -0.03398224f, -0.07521822f, 0.17787878f, 0.12453286f, 
    -0.06479484f, -0.00158752f, 0.14525658f, 0.10015233f, 0.24107511f, 0.07835883f, -0.17021614f, -0.10032919f, 
    -0.00618901f, -0.04149232f, 0.05098930f, 0.02837183f, 0.02329152f, 0.06416579f, 0.06682477f, 0.05433005f, 
    0.68639779f, -0.07571498f, 0.09023722f, -1.18888283f, 0.03897862f, 0.07157339f, -0.21440886f, 0.05924130f, 
    0.14544737f, 0.16249721f, -0.00688490f, -0.09201726f, -1.02630854f, -0.88165355f, 0.61731648f, 0.53523624f, 
    0.00944726f, -0.02263668f, 0.10508645f, 0.21932991f, -0.12397838f, -0.08891191f, -0.00008762f, 0.04405496f, 
    0.54625607f, -0.82819992f, -0.18850034f, -0.47585651f, -0.14919336f, -0.12927859f, -0.17660019f, 0.15613170f, 
    0.19662981f, 0.09278232f, 0.18787614f, 0.05022229f, -0.35983321f, -0.79421335f, -0.77464759f, -0.49655369f, 
    -0.21076505f, -0.11378634f, 0.10490248f, -0.25443572f, 0.18210796f, 0.01596148f, -0.04338177f, -0.10883245f, 
    0.17843489f, 0.19034348f, -0.15956523f, -0.11823476f, -0.07658435f, -0.08520497f, -0.11128086f, -0.03027352f, 
    -0.04318465f, -0.11061647f, -0.32538667f, -0.28587824f, 0.00532082f, -0.10929004f, 0.34186324f, -0.21606757f, 
    -0.19673751f, -0.01776803f, -0.09429874f, -0.05584550f, -0.11488019f, -0.16531710f, -0.31962028f, 0.04625796f, 
    -0.87982917f, -0.51256233f, 0.29407486f, 0.31542903f, 0.05827277f, -0.21446173f, -0.20220917f, -0.07462371f, 
    0.03516808f, 0.05828732f, -0.00804921f, -0.06493381f, 0.89141273f, -0.18416642f, -0.10619730f, -0.36687332f, 
    0.02097184f, 0.05550963f, -0.54597652f, -0.26123992f, -0.10531777f, 0.06774877f, -0.19139084f, -0.18578495f, 
    -0.00369446f, -0.03036045f, 0.10645110f, 0.17640571f, 0.08105503f, -0.06218549f, 0.12317684f, -0.04330286f, 
    -0.00516281f, -0.03946918f, 0.04502290f, -0.05376392f, -1.26983023f, 1.03772902f, -0.39694574f, 0.41556615f, 
    0.10607113f, -0.22530897f, 0.12737554f, -0.17060746f, 0.08899114f, -0.02871663f, 0.07536397f, -0.00744186f, 
    -0.60080695f, -0.20407477f, 0.03482290f, 0.17386550f, 0.18139115f, 0.06580163f, 0.00234251f, 0.24218425f, 
    -0.23027959f, -0.14376171f, -0.10129170f, -0.90081161f, 0.31980264f, 0.40362957f, 0.51123011f, 0.18016306f, 
    0.37407649f, -0.32667002f, -0.16987854f, -0.09769729f, 0.07426482f, -0.00756804f, 0.00732824f, -0.05472135f, 
    0.86024946f, 0.14058071f, 0.08625922f, -0.44940394f, 0.01655352f, -0.10804486f, -0.08235402f, -0.14485532f, 
    -0.04220767f, 0.14921154f, 0.19502790f, 0.06030102f, -0.24607386f, -0.12557960f, -0.46101841f, -0.24996461f, 
    -0.01356300f, 0.11987277f, 0.02015790f, -0.30436429f, -0.13708183f, -0.11993515f, -0.03636852f, -0.13061638f, 
    -0.00799789f, -0.15386775f, -0.40707570f, -0.07774305f, 0.27658087f, 0.11477640f, -0.09473379f, 0.02374624f, 
    -0.03223274f, 0.17353320f, 0.16836841f, 0.30035710f, -0.29829493f, -0.46517956f, -0.05454504f, -0.13162026f, 
    -0.22425273f, 0.24682520f, 0.08695288f, 0.11291414f, -0.01056561f, -0.11042819f, -0.08433238f, -0.05050411f, 
    0.03553040f, -0.04434464f, -0.79470676f, -0.36534324f, -0.02666095f, -0.30581707f, 0.08000115f, 0.06141708f, 
    0.16303743f, 0.05336465f, 0.19309852f, -0.09980190f, 0.54101050f, -0.71568948f, -0.52943635f, -0.12168382f, 
    -0.00002269f, 0.13113824f, 0.12232122f, -0.08803073f, -0.00577176f, 0.23694156f, -0.00357525f, -0.18050367f, 
    -0.22112814f, -0.57073289f, -0.10576018f, -0.11702363f, 0.08516064f, 0.10158960f, 0.27740011f, 0.18346757f, 
    0.11252506f, -0.11218603f, -0.09140801f, -0.14302219f, -0.47629058f, -1.32391346f, -0.20077060f, 0.32546774f, 
    0.07684617f, 0.44878912f, 0.12948923f, 0.06708328f, -0.29808351f, -0.01081062f, 0.12530099f, -0.27393261f, 
    -0.09393416f, -0.08462285f, -0.01480583f, -0.11337352f, -0.23800424f, 0.14715505f, 0.12851885f, 0.03106697f, 
    0.26917142f, 0.12044471f, 0.21097864f, 0.02302025f, -0.31488031f, 0.23799941f, -0.17685914f, -0.16405135f, 
    0.16313453f, 0.01600220f, -0.13363837f, 0.26725715f, -0.14087473f, 0.08189161f, -0.11129203f, -0.13940838f, 
    0.79449201f, -0.43908843f, -0.76063788f, 0.09451070f, 0.13182409f, -0.16124813f, -0.01371522f, 0.18105741f, 
    0.20641455f, 0.16907674f, 0.29335445f, 0.18092188f, 0.32520702f, 0.11881542f, -0.51819366f, -0.64831340f, 
    0.33492360f, -0.03068068f, 0.31484401f, -0.00729658f, 0.02570684f, -0.06947609f, 0.12685265f, 0.11083476f, 
    -0.79744476f, -0.07213572f, 0.28482935f, -0.16672224f, -0.18422729f, -0.20896612f, -0.18002991f, -0.15688600f, 
    -0.17378394f, -0.19066778f, -0.24654220f, 0.03570727f, -0.86603081f, -0.35204920f, -0.01633288f, 0.45974782f, 
    0.00922902f, 0.13802764f, 0.01285269f, 0.29785299f, -0.33116537f, 0.03982344f, 0.01176202f, 0.11391009f, 
    -0.11021486f, 0.31300181f, -0.22889100f, -0.05361414f, 0.11687024f, -0.07016803f, 0.01643381f, -0.19324802f, 
    0.13052419f, -0.08028983f, 0.31777161f, 0.41398999f, 0.25707945f, 0.18568528f, -1.54009283f, 0.48802105f, 
    0.11092043f, 0.34187371f, 0.29687440f, 0.01513419f, 0.04037933f, -0.05284927f, -0.13199325f, -0.18349038f, 
    -0.44210920f, -0.41346455f, -0.20791437f, -0.12830423f, 0.34503052f, 0.26393870f, 0.17059857f, -0.07127787f, 
    -0.16108087f, -0.10894608f, 0.03245750f, -0.23975852f, -0.44847310f, -0.16331077f, 0.24550284f, -0.26699260f, 
    -0.32070830f, -0.17109483f, 0.03683919f, 0.26817983f, 0.07048583f, 0.13860379f, 0.18133715f, 0.12335511f, 
    0.03395052f, 0.34775096f, 0.08178817f, 0.35958758f, -0.07818710f, -0.00848110f, 0.10465334f, -0.00574614f, 
    0.21474020f, -0.04993052f, -0.50052238f, 0.05759692f, 0.41134161f, 0.54440647f, 0.18090186f, -0.43351275f, 
    -0.03276042f, -0.10093161f, -0.22969827f, -0.20156597f, 0.01068841f, -0.18902516f, 0.00600039f, 0.07351271f, 
    -0.00079064f, -0.37405100f, 0.39300215f, 0.51604974f, -0.02537884f, 0.00252024f, -0.39309373f, -0.28487360f, 
    -0.18818007f, 0.17661822f, -0.04239900f, -0.05494050f, 0.04537780f, 0.15509760f, 0.16680893f, -0.18481869f, 
    -0.30618265f, -0.17704819f, 0.26453447f, 0.09811021f, -0.05118233f, 0.04419448f, -0.00136780f, -0.00191794f, 
    0.53970432f, -0.26431364f, 0.38032770f, 0.26701331f, -0.03096390f, 0.03088538f, -0.16206729f, -0.07866335f, 
    -0.01912115f, -0.00334781f, 0.19090201f, -0.00874930f, -0.08261875f, -0.16418569f, 0.66081959f, -0.77943927f, 
    -0.39954793f, -0.38886482f, -0.01355100f, -0.35319847f, -0.07318567f, 0.11483129f, 0.15679894f, 0.10726063f, 
    -0.05929058f, 0.23474509f, 0.03078383f, 0.45017067f, 0.19861984f, 0.06779201f, -0.43086335f, -0.02609755f, 
    0.18145104f, -0.06010823f, -0.04830592f, 0.07427794f, -0.05092213f, -0.13654280f, -0.80378109f, 0.06235717f, 
    -0.10282280f, 0.04421433f, -0.02652736f, 0.06075722f, 0.01693003f, 0.09206868f, -0.18831965f, -0.28674451f, 
    -0.65813065f, -0.22060397f, -0.58599073f, -0.07009105f, -0.12184798f, -0.39289436f, 0.17204224f, 0.14645477f, 
    -0.14756088f, -0.08615573f, -0.08771675f, -0.14111404f, -0.15524858f, -0.07423257f, 0.42594522f, 0.73876631f, 
    0.14243761f, -0.03766621f, -0.12064129f, -0.16546179f, 0.21723758f, -0.01876247f, 0.14695804f, 0.09408601f, 
    -0.15875217f, -0.25039589f, -0.43050483f, 0.22942545f, 0.14381917f, -0.23513533f, 0.33264139f, -0.09374261f, 
    -0.11619333f, 0.09161215f, 0.04907232f, 0.04064912f, -0.59471309f, 0.87276512f, -0.55765635f, -0.35137808f, 
    -0.19833586f, -0.32942784f, 0.30316648f, -0.19181491f, 0.14427188f, 0.15631285f, -0.22384892f, -0.13432162f, 
    -0.03373507f, 0.39903870f, 0.41502210f, -0.12839174f, -0.25837475f, -0.28035873f, 0.26493564f, 0.09123117f, 
    -0.40066677f, -0.08064958f, -0.41948193f, -0.53296643f, -0.17943989f, 0.09086238f, -0.40417743f, -0.40883365f, 
    -0.01918101f, -0.07694864f, 0.13767032f, -0.28052866f, -0.01041223f, 0.20044459f, -0.20910910f, 0.14511205f, 
    -0.23036797f, 0.64962769f, -0.17846480f, -0.00251075f, -0.45155382f, 0.35072553f, -0.10513597f, 0.10815511f, 
    -0.07358641f, 0.05016558f, 0.17666423f, -0.12106115f, -0.07054457f, -0.46249026f, -0.20074475f, 0.22653034f, 
    -0.07758876f, -0.08421676f, -0.09913070f, -0.12210933f, 0.16049524f, 0.13142297f, -0.02712218f, -0.10126635f, 
    0.02324984f, 0.44716713f, 0.00467487f, -0.36088845f, -0.04290706f, -0.12542059f, 0.05946202f, -0.27445322f, 
    -0.07510971f, 0.06807856f, 0.24863279f, 0.43971118f, 0.37522951f, 0.12658697f, 0.40067247f, 0.15133534f, 
    -0.12680082f, 0.14285579f, 0.11556731f, 0.03086973f, -0.07801591f, 0.18684791f, -0.02415443f, 0.20074606f, 
    -0.48973426f, 0.67171592f, -0.19441910f, 0.24357940f, 0.45442781f, 0.17255142f, 0.04696428f, -0.06754317f, 
    -0.04665223f, -0.26001891f, -0.16550879f, -0.02903903f, -0.62041551f, -0.30883208f, 0.13674146f, 0.22309153f, 
    0.02663229f, 0.26179487f, -0.16681530f, -0.03936709f, -0.10665825f, 0.22219728f, -0.13596606f, -0.05795171f, 
    -0.22081992f, 0.09120807f, -1.16366935f, 0.24193758f, 0.06940778f, -0.13123702f, 0.09414846f, 0.07670995f, 
    0.05010211f, 0.08418097f, -0.65153110f, -0.41337463f, -0.19151793f, -0.02865874f, 0.10657719f, 0.25800157f, 
    0.01298440f, -0.25277799f, 0.12930600f, 0.16215250f, 0.02956014f, -0.18940270f, -0.13408230f, -0.43364567f, 
    -0.28867781f, 0.26092920f, 0.42785650f, -0.56825507f, -0.11041325f, -0.23273113f, -0.35073462f, -0.03966202f, 
    0.07997330f, -0.08869485f, 0.03739285f, 0.13754474f, 0.18189521f, 0.78465712f, -0.30378723f, 0.13463514f, 
    -0.25736654f, 0.08687621f, 0.35668361f, -0.14829363f, -0.12612379f, 0.23596703f, -0.20465159f, 0.20456578f, 
    -0.55201298f, -0.17212084f, 0.20379516f, 0.59454095f, -0.16970065f, 0.26051402f, -0.11099606f, 0.23095073f, 
    -0.06219144f, 0.06526042f, 0.18841539f, 0.22538212f, -1.25127244f, 0.51615280f, -0.00203545f, -0.29193553f, 
    0.11032307f, 0.31407681f, 0.10162735f, -0.00955216f, -0.17086166f, 0.01618623f, -0.11717634f, -0.12499534f, 
    -0.48597944f, 0.19568469f, -0.46262011f, -0.62997562f, -0.65124363f, -0.19973300f, -0.33676732f, -0.18418385f, 
    0.26464561f, 0.29845086f, -0.24950044f, 0.02029531f, -0.01905869f, -0.69514352f, 0.07029746f, 0.53929734f, 
    0.03043919f, 0.20853914f, 0.15685074f, 0.05160717f, -0.31033069f, -0.12549311f, -0.10131215f, 0.23715235f, 
    0.19571438f, 0.16603746f, 0.08311948f, -0.40345266f, 0.04391987f, 0.07643327f, 0.02278917f, 0.27937004f, 
    0.14387198f, 0.20558992f, 0.09897728f, -0.03041583f, 0.98728180f, -0.26836541f, 0.80964792f, 0.01362209f, 
    0.15755461f, -0.12333447f, -0.05490437f, -0.13616116f, -0.17149433f, -0.07772054f, -0.06828518f, -0.12230977f, 
    -0.03291810f, 0.17306519f, 0.40265015f, -0.35224259f, 0.33339593f, 0.01298665f, 0.17785431f, -0.20349212f, 
    0.13951974f, 0.01025255f, 0.01281109f, -0.04301848f, 0.27160129f, -0.22921418f, -0.12219699f, -0.20538616f, 
    -0.35063541f, -0.30924177f, 0.35084125f, -0.24592131f, -0.02249585f, 0.19377851f, -0.02316501f, -0.05163094f, 
    -0.34500462f, -0.14550976f, 0.01061568f, -0.05940275f, 0.00652521f, 0.10504486f, 0.11600480f, -0.04452060f, 
    -0.18574847f, -0.15492195f, -0.21780504f, -0.79205632f, -0.43903017f, -0.19345252f, -0.06145851f, 0.29215229f, 
    0.03948133f, -0.02706124f, -0.12036958f, -0.07829592f, -0.13359033f, 0.14147054f, -0.53877020f, 0.11215801f, 
    -1.00736189f, -0.18851842f, -0.93810380f, 0.35038561f, 0.32233787f, -0.25715402f, 0.19355308f, -0.13756628f, 
    -0.01186611f, -0.15611920f, 0.37614444f, 0.11214247f, -0.30393648f, -0.73518980f, -0.36238787f, 0.15209433f, 
    -0.06541957f, -0.28687939f, 0.17679435f, -0.41952416f, 0.01494584f, 0.05848252f, -0.02808327f, 0.09158754f, 
    -0.51917475f, -0.28064078f, -0.22703832f, 0.11671756f, -0.04332061f, -0.09302408f, -0.18712215f, -0.09981403f, 
    -0.22094272f, 0.09664930f, 0.14488333f, 0.24555625f, 0.26867756f, -0.16815217f, 0.19893207f, -0.96056640f, 
    0.03408227f, 0.01874550f, 0.29508254f, 0.23620966f, -0.08267619f, 0.06739538f, -0.09913047f, 0.03720254f, 
    -0.37406552f, -0.03411300f, -0.38623434f, -0.08932039f, 0.28502461f, -0.10253917f, 0.11691146f, 0.16871029f, 
    0.04400362f, -0.01924007f, -0.20871717f, 0.04655018f, -0.19318850f, -0.37654173f, 0.90684474f, 0.83611059f, 
    0.08253156f, -0.05394338f, 0.18587774f, -0.22417191f, 0.10976924f, 0.22955284f, 0.20234504f, 0.31139261f, 
    0.12110870f, -0.35706654f, 0.33452815f, -0.05377287f, -0.21488319f, -0.60271472f, -0.09652042f, 0.06876071f, 
    -0.19576080f, -0.29060957f, -0.02233128f, -0.36310905f, -0.15453878f, -0.20385577f, -0.73202091f, 0.36287087f, 
    0.40212294f, 0.08139054f, 0.27823675f, 0.03477050f, 0.22989093f, 0.26661018f, 0.23206685f, 0.33412999f, 
    0.50316519f, -0.13887139f, -0.07053550f, 0.10375776f, -0.03418988f, 0.11467499f, -0.11868418f, 0.17256102f, 
    -0.18362314f, -0.02189734f, 0.08953028f, -0.01094159f, 0.21258637f, -0.46034920f, 1.09436977f, -0.61536354f, 
    0.17965209f, 0.20293410f, -0.33725509f, 0.10414742f, -0.24446104f, 0.23682441f, 0.05340270f, 0.03621975f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.40974480f, 0.22332849f, 0.23983654f, -0.18018043f, -0.26739800f, 0.09378200f, 0.08245488f, -0.29686126f, 
    0.11889203f, -0.03195244f, 0.18761677f, -0.03404578f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
