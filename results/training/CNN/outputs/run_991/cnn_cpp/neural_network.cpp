#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.90580398f, -0.06539147f, 0.02021566f, 0.67165160f, 0.72315586f, -0.46470976f, -0.37410089f, -0.39492181f, 
    -0.62331724f, -0.37711674f, -0.04101339f, 0.26016316f, 0.34053463f, 0.06558813f, -0.22637719f, -0.08388355f, 
    0.24612533f, 0.30077708f, 0.29479888f, 0.05040028f, 0.26570186f, -0.27084473f, -0.03165236f, 0.30138648f, 
    -0.00585699f, -1.69142926f, 0.06353299f, -0.35776475f, -1.46848547f, -1.19608021f, -0.28122514f, 0.47476077f, 
    0.16610783f, -0.41377753f, -0.19538248f, -0.31359297f, -0.51767021f, -0.49179924f, -0.96633440f, -0.26625958f, 
    -0.02260559f, 0.02503057f, -0.26960623f, 0.00527630f, -0.12637146f, -0.12052624f, 0.00107068f, -0.12740342f, 
    -0.25641495f, -0.34343022f, -1.07050538f, 0.06110283f, 0.22724038f, 0.33192128f, 0.03396051f, -0.18428309f, 
    0.82244521f, -0.07807155f, 0.26022491f, 0.30568069f, -0.11631466f, -0.12932821f, -0.11530130f, 0.57217425f, 
    -0.02623761f, -0.06285302f, -0.51087540f, -0.65774578f, 0.24720041f, 0.62055200f, -0.13273478f, 0.20638642f, 
    -0.01131180f, 0.43810481f, -0.09892119f, 1.31569350f, -0.10051439f, -0.18676688f, -0.05821922f, -1.17868543f, 
    0.64624280f, 0.78296560f, 0.48836705f, -0.69423717f, -0.64532280f, -0.19591452f, 0.17076471f, 0.05303488f, 
    -0.40277761f, -0.24322182f, 0.19408682f, 0.06226775f, 0.30428234f, -0.57169658f, 0.09136716f, 0.30221817f, 
    -0.37023735f, -0.04771358f, 0.40917134f, -0.16214155f, -1.23144495f, -1.12043691f, -0.35450479f, -0.09779580f, 
    0.26989096f, -0.52132988f, -1.01396775f, -1.29953992f, -0.95998144f, -0.67862982f, 0.11244851f, 0.30815813f, 
    0.03025673f, -0.26127437f, -0.39651784f, -0.10074298f, -0.36904684f, -0.47833034f, -0.53922772f, -0.51838964f, 
    0.32546845f, -0.20947628f, -0.74305248f, -0.46889785f, 0.35353813f, -1.91192269f, -0.62213731f, -0.50912660f, 
    -0.91695970f, -1.05031836f, 0.55659640f, 0.29516169f, 0.28764442f, 0.61137795f, 1.01911378f, -0.00398625f, 
    0.17241633f, -0.01419510f, 0.04637277f, -0.21356872f, -0.10682094f, -0.11210032f, -0.31979364f, -0.11198746f, 
    -0.32556370f, -0.01549167f, 0.12995057f, 0.32323828f, -0.12641628f, 0.15829246f, 0.28833029f, -0.22624795f, 
    -0.08447718f, 0.61529404f, -0.90721375f, 0.45072290f, -0.69463485f, -0.80707836f, 0.09601644f, -0.50431651f, 
    -0.01232161f, 0.76255673f, 0.18862161f, -0.01881075f, 0.86741614f, -0.29799658f, -0.07377734f, 0.06014182f, 
    0.00196847f, -0.07983943f, 0.07930031f, -0.06764575f, 0.02296787f, 0.16537604f, -0.24320698f, 0.68757367f, 
    0.62396312f, 0.51569748f, 0.12918913f, 0.15015531f, 0.37400827f, 0.56420410f, 0.58449841f, 0.21401198f, 
    0.25410587f, -0.10772861f, -0.10903452f, 0.05772193f, -0.23333374f, -0.25222754f, -0.21150944f, -0.17852658f, 
    -0.09630483f, 0.04379673f, -0.34635970f, 0.01446765f, -0.07074646f, 0.09951002f, -0.01173904f, 0.05235123f, 
    0.04575386f, 1.19903207f, 0.77809376f, -0.74453086f, -0.63988638f, -1.11944556f, -0.91967171f, 0.16754772f, 
    -0.32568339f, -0.39661664f, -0.15958332f, -0.12578949f, -0.08645622f, 0.00759057f, -0.07924566f, 0.23874675f, 
    0.34787041f, 0.25286424f, 0.28044125f, -0.07964001f, 0.14039676f, 0.04063933f, -0.34289193f, -0.32636270f, 
    -0.45844609f, 0.56063044f, -0.36200064f, 1.15057588f, -0.20111422f, -0.56320244f, -0.08425907f, -0.33131528f, 
    -0.66859365f, -0.36911649f, 0.09584933f, 0.45376584f, -0.44193259f, -0.17993148f, -0.00409026f, 0.49865857f, 
    0.50247109f, -0.21062936f, 0.04328132f, 0.12526925f, -0.43412390f, -0.19450010f, 0.30743313f, 0.19728540f, 
    0.11982676f, 0.01269888f, -1.49393177f, -1.12857807f, -1.03359330f, 0.98503947f, 1.48778760f, 0.98511052f, 
    0.69815141f, 0.30141607f, -0.17894258f, 0.04128214f, 0.12015180f, -0.57752466f, -0.35940439f, -0.41908583f, 
    0.03205753f, 0.18280357f, -0.08532383f, 0.02773315f, 0.00951588f, -0.05767757f, -0.07433788f, -0.29337060f, 
    -0.29419383f, -0.16202240f, -0.44382071f, 0.30743441f, -0.35623878f, -1.53893733f, -0.59232217f, 0.39072153f, 
    0.17877115f, 1.08332276f, -0.41058421f, -0.30903813f, -0.34878066f, 0.50658655f, -0.12499903f, 0.17081212f, 
    -0.17097682f, -0.04242595f, -0.40414709f, -0.67501658f, 0.20076968f, 0.44481558f, -0.29367265f, -0.25339621f, 
    0.05026948f, 0.22785929f, 0.04661204f, 0.47208324f, 0.94217545f, 0.44106749f, 0.53597611f, 0.13717218f, 
    0.08380772f, -0.27592525f, 0.15902930f, -0.31833944f, -0.53159440f, -0.12003282f, -0.35245377f, 0.98450613f, 
    -0.46601063f, -0.26366016f, -0.04890843f, -0.04060307f, -0.45306644f, -0.15445128f, 0.24837752f, 0.29428297f, 
    0.26600030f, 0.14524591f, -0.09188127f, -0.35436189f, 0.21768637f, -0.61306340f, -0.57803488f, -0.54843426f, 
    -0.66592091f, -0.55785829f, -1.12944746f, -1.22850049f, -0.87282896f, -0.65876436f, -0.77991843f, -0.07025465f, 
    0.03962331f, 0.28190735f, 0.84285718f, -0.27711907f, -0.02100981f, -0.21821342f, -0.01859148f, 0.32206979f, 
    0.16547412f, -0.03141528f, 0.21409541f, 0.27058446f, 0.15509047f, 0.42042017f, 1.47724032f, -0.68551892f, 
    -1.02727389f, -0.69967556f, -0.63677710f, 0.95614308f, 0.25514239f, 0.28803921f, -0.32545459f, -0.14680947f, 
    0.14304170f, 0.25387821f, 0.02708883f, -0.22569238f, -0.20122232f, 0.24730103f, -0.29118353f, 0.03216330f, 
    -0.15308391f, -0.57010800f, -0.51990843f, -0.47645128f, -0.29539382f, -0.58353329f, -0.45729056f, -0.25534001f, 
    0.82379448f, 0.65179986f, -0.36146995f, -0.82083750f, 0.29176676f, 0.27091917f, -0.46940336f, -0.19673747f, 
    0.60951591f, 0.32770643f, 0.60270190f, -0.40143737f, -1.11094284f, -0.08123723f, 0.20268044f, -0.19344400f, 
    0.14830169f, -0.20117417f, -0.71110791f, -0.26336047f, 0.23258692f, 0.17412452f, -0.42424640f, 0.46608669f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.31509960f, 0.16890588f, 0.60773087f, 0.73100489f, 0.26828486f, -0.05794373f, 0.35510212f, -0.28189036f, 
    0.61615121f, 0.41236952f, 0.18563057f, 0.62892091f, 0.44896165f, -0.21707276f, 0.26228341f, 0.46297020f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.09198149f, 0.09426222f, 0.03519326f, -0.04730983f, -0.16275026f, -0.28229475f, -0.41749012f, -0.08576994f, 
    -0.08819649f, 0.03767550f, -0.02560373f, -0.01382629f, 0.17206000f, 0.30085704f, -0.01289352f, -0.00825286f, 
    0.18849435f, 0.34055391f, -0.00054294f, 0.20935459f, -0.05050457f, -0.07870074f, -0.14656378f, 0.13503009f, 
    -0.19893032f, -0.05146134f, 0.23382010f, -0.09662626f, 0.01834576f, -0.07558161f, 0.02129691f, -0.01828828f, 
    -0.14453802f, -0.16564803f, -0.37976497f, -0.32477552f, -0.12719280f, -0.88318932f, -0.40312663f, -0.12410746f, 
    -0.09806913f, 0.04140019f, -0.37802464f, -0.07607637f, -0.00845914f, -0.20298885f, -0.13150682f, -0.00223491f, 
    0.59244525f, 0.45412982f, -0.31926346f, -0.43773934f, -0.04766257f, 0.03033327f, 0.22464609f, 0.05618805f, 
    -0.09261141f, -0.20306061f, -0.19319119f, -0.16857159f, 0.21202074f, 0.03565135f, 0.15186463f, -0.12083216f, 
    0.18009041f, 0.36648637f, 0.05880885f, -0.02529472f, -0.04274006f, 0.05725729f, -0.08591592f, 0.04902340f, 
    0.44453630f, 0.00511165f, -0.04950595f, -0.22485472f, -0.29541385f, -0.09692435f, -0.21054730f, 0.05238174f, 
    0.03500720f, -0.11020241f, 0.00120078f, -0.03836329f, -0.17845891f, -0.57260352f, -0.77978528f, 0.06251657f, 
    0.08399254f, 0.04475420f, 0.12273677f, 0.14350997f, 0.11021362f, 0.03085874f, 0.03746128f, 0.03032550f, 
    -0.03069476f, 0.19475821f, 0.11165650f, -0.08062712f, -0.03285880f, -0.01141757f, -0.14633599f, -0.00426944f, 
    0.10234687f, -0.01207934f, -0.06947834f, 0.02480356f, 0.04835081f, -0.09921650f, -0.08720745f, -0.35092449f, 
    -0.18091711f, 0.22051227f, -0.26728031f, -0.28671616f, -0.05070374f, 0.01785223f, -0.01039064f, -0.05515284f, 
    0.78631604f, -0.36974949f, -0.36216727f, 0.07214767f, -0.08186150f, 0.03706579f, 0.20629972f, -0.01813860f, 
    -0.10616128f, -0.06701614f, 0.06729353f, 0.16166513f, 0.21673481f, 0.09010918f, -0.81186813f, 0.06028013f, 
    0.11468007f, 0.04699234f, -0.25885713f, -0.15221679f, -0.01720015f, -0.32965729f, -0.56897837f, -0.06268891f, 
    -0.61587530f, -0.14451168f, -0.27981350f, 0.02831191f, -0.01473350f, 0.12951310f, -0.10346036f, -0.08185043f, 
    -0.10224235f, 0.05741825f, 0.13830133f, -0.09490361f, 0.57096666f, 0.39351490f, -0.06569929f, -0.49223053f, 
    0.11848442f, -0.00784609f, -0.12803791f, 0.02371575f, -0.04947492f, -0.07234959f, 0.05649291f, 0.01540943f, 
    0.25697124f, -0.13530493f, -0.64178711f, 0.24380362f, 0.05732187f, 0.05134065f, 0.08646226f, -0.03510028f, 
    -0.11274907f, 0.15891667f, -0.00601729f, 0.13582684f, -0.00711815f, -0.49689546f, -0.05040336f, -0.14465831f, 
    0.18844187f, 0.02379061f, 0.08768585f, -0.03257851f, -0.23907961f, -0.22421981f, -0.15436199f, -0.11404029f, 
    -0.01557201f, 0.10548642f, -0.06373817f, -0.04910052f, 0.05460781f, 0.05731257f, 0.10209771f, -0.18386602f, 
    -0.08261562f, -0.10580171f, 0.05307432f, 0.04441594f, 0.27735206f, 0.20307112f, 0.12084495f, -0.06476779f, 
    0.10991743f, 0.10942473f, -0.36801097f, -0.14137706f, -0.00715211f, 0.05850981f, -0.27549151f, -0.04916498f, 
    -0.12787963f, -0.05900337f, -0.01933303f, -0.10099073f, 0.01676038f, -0.02801870f, 0.09453878f, 0.05259965f, 
    -0.01868828f, -0.01827318f, 0.26487947f, 0.00836018f, 1.40791059f, -0.74287450f, 0.14736710f, 0.13963784f, 
    -0.14137398f, -0.20596679f, 0.16118014f, -0.04585057f, 0.23431776f, -0.10132381f, -0.03912739f, 0.05149035f, 
    -0.25961429f, 0.08051227f, -0.18757191f, 0.03218108f, -0.04644443f, 0.02294955f, 0.08648058f, -0.05180376f, 
    0.05541716f, -0.02486858f, -0.02291581f, 0.22184443f, -0.07820968f, 0.22089592f, -0.42144209f, -0.31046793f, 
    0.04572888f, 0.11856057f, 0.00623650f, 0.00376398f, -0.16259135f, 0.01855594f, -0.00504070f, -0.25561783f, 
    -0.22968392f, -0.16573584f, -0.12525675f, -0.15636078f, 0.11618870f, -0.06156348f, 0.22513564f, 0.20156659f, 
    0.18051952f, 0.20426445f, 0.11247643f, -0.01342026f, 0.45196375f, 0.25782529f, 0.29653928f, 0.27818736f, 
    -0.09788161f, 0.03597378f, -0.05457392f, -0.02343741f, -0.00842428f, 0.18371058f, 0.09051093f, -0.00518855f, 
    -0.12475528f, -0.13168739f, 0.18887001f, -0.44856074f, -0.04214333f, -0.31208128f, -0.16661984f, 0.00376714f, 
    -0.13841511f, 0.04147261f, -0.01155362f, 0.03937234f, 0.07729469f, -0.05139611f, -0.24051696f, -0.15606017f, 
    -0.19847488f, 0.16003773f, -0.09830019f, 0.07530879f, -0.14954241f, 0.17666490f, 0.12570404f, -0.07144838f, 
    0.00475170f, -0.42621532f, -0.10083076f, 0.16474117f, -0.06910550f, -0.03255345f, 0.01726468f, 0.05237496f, 
    0.20017396f, -0.26263940f, -0.11416466f, -0.08558602f, 0.15059967f, -0.29296079f, -0.13813065f, -0.34798324f, 
    0.10893217f, 0.22556882f, 0.04306234f, 0.19996963f, 0.13200195f, 0.12451868f, 0.05272854f, -0.02831788f, 
    0.52957702f, 0.06934237f, -0.20283586f, -0.28135401f, -0.15019856f, -0.04355588f, -0.17427810f, 0.02728172f, 
    -0.08678079f, -0.02688948f, 0.09406492f, -0.04226776f, 0.00704685f, -0.02287493f, 0.23208858f, 0.20517221f, 
    -0.09386516f, -0.07277068f, 0.01417475f, -0.23414662f, -0.07180396f, -0.09635317f, 0.07902471f, -0.00276127f, 
    0.67107821f, -0.19397859f, -0.25260699f, 0.00090418f, -0.06214805f, -0.05320249f, -0.10080685f, -0.11892337f, 
    -0.11605102f, -0.21672453f, -0.20777336f, -0.14910947f, 0.14326800f, -0.02806189f, 0.58987355f, -0.42208558f, 
    -0.07232548f, 0.23794483f, -0.14199328f, 0.11311254f, -0.03139021f, -0.31174567f, -0.16903172f, 0.06429465f, 
    -0.31064832f, -0.02081374f, 0.00936350f, 0.04953820f, -0.37485811f, -0.13618593f, 0.10599212f, 0.40266255f, 
    -0.00469397f, -0.06050298f, 0.14228041f, -0.09619994f, -0.20330812f, 0.67512971f, 0.70077717f, 0.45690727f, 
    -0.15893619f, -0.15845259f, -0.02125522f, -0.07235692f, -0.03414140f, -0.02319408f, -0.03051632f, -0.33531103f, 
    0.39742625f, -0.26703918f, -0.10532298f, 0.10934735f, 0.08055297f, 0.05788247f, 0.21248119f, 0.06076164f, 
    -0.12610200f, 0.10421943f, 0.05219920f, -0.11161703f, -0.43320945f, 0.17557837f, 0.12610616f, -0.52516592f, 
    0.07934486f, -0.19809981f, 0.11262198f, 0.00527035f, 0.13200551f, 0.21069445f, -0.03815993f, -0.19441901f, 
    -0.35862666f, -0.43352151f, -0.34991336f, -0.03067576f, 0.15861116f, -0.09364231f, -0.40100774f, 0.21852110f, 
    0.02429691f, 0.02908550f, -0.03904117f, -0.02978700f, 0.27442309f, 0.64005309f, 0.49178305f, 0.73147821f, 
    -0.08736216f, 0.07285575f, 0.09712989f, 0.08044698f, 0.00652588f, -0.12620792f, 0.06057090f, 0.22606578f, 
    -0.38664144f, 0.05125284f, 0.01950533f, -0.00007073f, -0.01252734f, -0.41857970f, -0.17537525f, -0.09985209f, 
    0.05475397f, 0.08942249f, -0.02715726f, 0.10847787f, -0.57244557f, -0.72216320f, -0.00000381f, -0.16543801f, 
    -0.01887735f, -0.03088162f, 0.03947591f, 0.03224906f, 0.08738874f, -0.00347697f, 0.06894092f, -0.18605843f, 
    -0.09560479f, -0.34428790f, -0.05998721f, -0.19989359f, 0.05261047f, -0.09280542f, -0.33168927f, -0.20881785f, 
    0.11627276f, -0.02614517f, -0.01613432f, 0.01724613f, -0.39516905f, -0.06036654f, 0.10211629f, 0.06023530f, 
    0.14852297f, -0.23348252f, -0.24229063f, 0.19726609f, 0.05996086f, -0.04887668f, 0.10322543f, 0.07174757f, 
    0.13704281f, -0.05235273f, 0.12062696f, 0.11467297f, 0.00361174f, -0.09621814f, 0.04851402f, 0.16136485f, 
    0.06127072f, 0.06263974f, -0.10437588f, -0.00113990f, -0.32595664f, 0.09716664f, 0.34314960f, -0.67330921f, 
    -0.08420523f, -0.10175561f, -0.11463884f, 0.06028725f, -0.13918304f, -0.12750612f, 0.18408364f, -0.28773129f, 
    -0.20633015f, 0.28643662f, -0.00622018f, -0.74517238f, -0.06813012f, 0.09149276f, -0.13573781f, 0.29318249f, 
    0.12744543f, 0.04177259f, -0.07206873f, 0.08302143f, -1.21437681f, -0.86657929f, -0.49415675f, -0.38654035f, 
    -0.10109365f, 0.06724728f, 0.12411678f, -0.20197171f, -0.01585932f, 0.00546949f, 0.02422471f, -0.11294313f, 
    -0.18821152f, 0.22120322f, 0.37102836f, -0.03428810f, -0.06899039f, -0.00861871f, 0.13197282f, -0.20342153f, 
    0.09385705f, 0.12834395f, 0.15684047f, 0.35660121f, 0.74151278f, -0.24720408f, 0.28728792f, -0.44660828f, 
    0.13955621f, 0.03475129f, -0.24351695f, 0.15014662f, 0.04569463f, -0.05414864f, 0.08059022f, 0.29810515f, 
    -0.01040590f, -0.05373444f, 0.20125404f, 0.70514745f, -0.03551605f, -0.10446437f, 0.35541207f, -0.31957531f, 
    0.24636276f, 0.09101380f, -0.00028632f, 0.24501844f, 0.42060161f, -0.47408539f, 0.18217814f, 0.34969133f, 
    0.11579724f, -0.04212325f, -0.09152565f, -0.09207816f, -0.09234075f, 0.07713681f, 0.17798267f, 0.18535991f, 
    0.18043385f, 0.34394348f, -0.34086892f, -0.53482044f, -0.20998964f, -0.01461187f, -0.04210206f, -0.04625518f, 
    -0.17505702f, -0.34457499f, 0.07768999f, -0.40435550f, -0.78620356f, 0.27660736f, 0.11045096f, 0.38144368f, 
    0.01184092f, -0.01617944f, 0.26781961f, -0.04127359f, -0.16905639f, 0.03162520f, -0.09403996f, -0.10585580f, 
    -0.09190977f, -0.15557967f, -0.13910849f, 0.17068619f, 0.15063302f, 0.07179778f, -0.13883594f, 0.14378522f, 
    -0.07854120f, -0.12290902f, -0.01028178f, -0.08639055f, 0.52100718f, -0.23363118f, 0.09266379f, 0.26587620f, 
    0.21420896f, 0.11533857f, 0.11759765f, 0.02508044f, -0.17227629f, -0.00390872f, -0.05289868f, 0.18389212f, 
    -0.46647206f, -0.29369059f, -0.24995869f, 0.28050011f, 0.16894370f, 0.02605806f, 0.10013260f, 0.02485445f, 
    -0.13737009f, -0.07993354f, -0.35207742f, -0.11933110f, -0.75559306f, -0.39227962f, -0.30778366f, -0.04763098f, 
    0.21805353f, -0.01922057f, -0.02848947f, -0.11558288f, -0.05470460f, 0.18286705f, 0.00063014f, -0.08275735f, 
    0.22697067f, -0.16154897f, 0.45548910f, -0.12910447f, -0.36337352f, 0.12541744f, -0.00096576f, -0.09335154f, 
    -0.09147312f, 0.09173128f, 0.07165913f, 0.05308932f, -0.09408942f, -0.08228152f, 0.64176798f, 0.53588712f, 
    0.02715982f, 0.03243124f, -0.03715824f, -0.17871054f, 0.14098635f, -0.28204232f, -0.10766484f, -0.03619046f, 
    -0.17634414f, 0.96558219f, -0.58694738f, -0.92188513f, 0.40495971f, 0.11201820f, -0.05659618f, -0.11845385f, 
    -0.40690833f, 0.11196669f, -0.10055070f, -0.08595926f, -0.17751889f, 0.31291363f, -0.45917270f, 0.29841918f, 
    0.01444819f, -0.19193597f, -0.07143597f, -0.30071351f, 0.08154558f, -0.06860176f, 0.27311602f, -0.06884409f, 
    -0.45151395f, -0.13878846f, 0.36318168f, -0.08434574f, -0.39720544f, -0.02740309f, -0.50192523f, -0.21088274f, 
    0.13908669f, -0.26320598f, -0.00780595f, 0.08237939f, -0.05151774f, -0.24386282f, -0.11023012f, 0.32624391f, 
    0.04569494f, 0.17961596f, 0.12526856f, -0.19541955f, -0.02538470f, -0.08394919f, 0.04341301f, -0.10815971f, 
    -0.53433245f, 0.14843622f, -0.12909397f, 0.34588349f, 0.04032236f, 0.20935537f, 0.05658520f, -0.15024495f, 
    0.01314390f, 0.20203470f, 0.16781497f, 0.23801342f, 0.15288199f, -0.09469317f, -0.21458589f, 0.29051140f, 
    -0.14314590f, -0.16018280f, -0.23434496f, -0.31259519f, -0.10727708f, -0.02627444f, -0.07812015f, -0.33568552f, 
    0.19288847f, 0.02702071f, 0.24905528f, 0.22445974f, -0.03389671f, 0.05115660f, 0.12848438f, 0.11300099f, 
    0.06371000f, 0.01023313f, -0.04114322f, -0.06848940f, -0.32511535f, -0.14661048f, -0.10817690f, 0.07106699f, 
    0.02446690f, -0.09717642f, 0.05910126f, -0.15134396f, -0.05601091f, -0.02866406f, 0.06064665f, 0.15833363f, 
    0.17229643f, 0.05261348f, -0.06991032f, -0.00239334f, -0.18745123f, -0.08886922f, -0.14382994f, 0.00590415f, 
    -0.34599581f, -0.20366949f, -0.63235569f, 0.00811187f, -0.16567139f, 0.16125749f, -0.45631573f, -0.54264283f, 
    0.24111721f, -0.25220561f, -0.03946267f, -0.10675728f, -0.11235101f, -0.07210923f, -0.08689108f, -0.24380498f, 
    0.19414729f, 0.11075224f, 0.51059425f, 0.26022494f, -0.09969019f, -0.02237794f, -0.09772456f, -0.01488159f, 
    -0.05541582f, 0.11268059f, 0.10617510f, 0.13041049f, 0.17034434f, 0.27608901f, 0.11525447f, 0.22131839f, 
    -0.24509276f, -0.19758643f, 0.14370620f, 0.01522963f, 0.12809698f, -0.18598215f, 0.02521660f, 0.02451542f, 
    0.26291031f, -0.06744669f, 0.25697926f, -0.00936750f, 0.09100001f, -0.06921090f, -0.02934284f, -0.03809047f, 
    -0.07891484f, -0.27045375f, -0.08984762f, 0.07560519f, 0.21029431f, 0.17815901f, -0.25692791f, -0.26082551f, 
    0.10453840f, 0.05590246f, 0.09881791f, 0.07907797f, 0.09957013f, -0.11269566f, -0.09390535f, -0.13058452f, 
    0.18131943f, 0.20919517f, -0.25868496f, 0.45648780f, 0.13658558f, 0.07846511f, 0.03444722f, -0.36118871f, 
    0.17390300f, -0.22115301f, 0.03474079f, -0.08383498f, 0.02468113f, 0.02481406f, -0.01267719f, 0.28335115f, 
    0.05976203f, 0.08056413f, -0.08464845f, -0.08926848f, -0.08620632f, -0.01748514f, -0.39881307f, -0.11518238f, 
    -0.07748722f, -0.91828555f, 0.17482461f, 0.07806550f, -0.06834556f, 0.06524120f, -0.06539102f, 0.03847559f, 
    0.04409685f, 0.16025451f, 0.00725084f, 0.05702711f, -0.19900547f, -0.16303204f, 0.07548308f, 0.12995392f, 
    -0.18321110f, -0.06273318f, -0.52297443f, -0.07130530f, -0.34026197f, -0.18960550f, -0.19365086f, -0.15077747f, 
    -0.03334711f, 0.10079780f, -0.03789707f, 0.53671789f, 0.22879596f, -0.05748752f, 0.25653207f, 0.01389150f, 
    0.08539501f, 0.13115861f, -0.05838123f, -0.09991403f, 0.01590196f, 0.28640467f, 0.33001244f, 0.29274625f, 
    -0.26644969f, -0.06763136f, 0.08557445f, 0.30470011f, 0.08406734f, 0.01470777f, -0.03409902f, 0.01496299f, 
    -0.03615544f, -0.21066251f, 0.06119971f, -0.02814605f, -0.04072518f, -0.12605602f, -0.02315545f, -0.16190253f, 
    0.23726784f, 0.05489302f, 0.00750050f, 0.34065747f, 0.03123614f, -0.24649134f, -0.85963714f, 0.03312870f, 
    0.00985443f, -0.21939352f, 0.17571497f, -0.14042541f, -0.10046349f, -0.14732507f, -0.14915213f, -0.02757110f, 
    0.10864505f, -0.35676196f, -0.14391138f, -0.22418533f, 0.02951469f, 0.05097593f, -0.19594494f, 0.16506819f, 
    0.10945513f, 0.08904695f, -0.05204364f, -0.07367127f, -0.16966030f, 0.37945405f, -0.04646600f, -0.11351944f, 
    -0.10725807f, -0.21279220f, 0.23036501f, 0.13289385f, 0.00496484f, -0.06475221f, 0.07690312f, -0.11761685f, 
    -0.33404338f, -0.32677954f, 0.09619452f, 0.40471658f, 0.22394933f, -0.15932955f, -0.04300516f, -0.01144600f, 
    0.27777097f, 0.08958665f, 0.02259692f, 0.20678681f, -0.33433586f, 0.16045396f, -0.87236112f, -0.25238690f, 
    0.08708360f, 0.30273342f, -0.26637155f, 0.04343592f, 0.13856815f, -0.00826251f, 0.12532233f, 0.01463860f, 
    0.19196124f, 0.23721898f, 0.33014172f, -0.25536269f, 0.01778602f, 0.10050572f, -0.09612705f, -0.05009997f, 
    0.08330351f, -0.05425428f, -0.06629476f, 0.10916057f, -0.96744823f, -0.60916787f, -0.26897100f, -0.34501174f, 
    -0.01538967f, -0.06180052f, -0.07924923f, -0.03232850f, 0.18832454f, -0.07104634f, 0.01486464f, -0.14237534f, 
    0.30667120f, 0.03879930f, -0.26031366f, 0.05362276f, -0.17059058f, 0.18068179f, -0.09999824f, -0.03924002f, 
    -0.06543802f, 0.11324553f, 0.10764614f, -0.15078150f, -0.01949056f, -0.17326567f, 0.03717992f, 0.25714886f, 
    -0.04232602f, -0.04628323f, -0.07368742f, -0.05608508f, 0.11429913f, -0.12479399f, -0.17604554f, 0.20474757f, 
    -0.12102974f, 0.31011611f, -0.08560620f, 0.24362874f, 0.02579835f, -0.06070197f, -0.07748969f, 0.36621976f, 
    -0.16221140f, 0.07412646f, -0.00199234f, -0.11186805f, 0.01045756f, 0.20108986f, -0.00015771f, -0.08983155f, 
    0.12316713f, -0.01764251f, 0.17116325f, 0.29650789f, 0.08707344f, -0.19415829f, 0.03158739f, 0.18098645f, 
    -0.55124962f, 0.39150971f, 0.21690269f, -0.30077147f, -0.10049415f, -0.19622250f, 0.03603952f, 0.03274036f, 
    -0.14697821f, -0.37446904f, -0.33975151f, -0.16675518f, 0.19240156f, 0.22693323f, 0.04921157f, -0.43134600f, 
    -0.10786103f, 0.16500407f, 0.31599405f, -0.04658984f, 0.18343338f, 0.22949088f, 0.07041552f, 0.12772276f, 
    -0.13064045f, -0.30667645f, -0.12257339f, 0.47700730f, 0.09968140f, -0.17106794f, 0.26191223f, 0.02079603f, 
    0.06185019f, -0.07728250f, 0.01569392f, 0.08459643f, 0.10909588f, 0.08463916f, 0.19442517f, -0.04642735f, 
    0.33667895f, 0.24574615f, 0.07244617f, -0.10773402f, 0.07842509f, 0.07545902f, -0.03579474f, 0.09640712f, 
    -0.04606441f, 0.05783123f, -0.26154658f, -0.50125295f, -0.03103755f, 0.04736038f, 0.16506867f, 0.09029409f, 
    -0.03225610f, -0.34301299f, -0.17934105f, -0.42998362f, -0.18685362f, 0.32752404f, -0.64780772f, -0.23691761f, 
    0.06998321f, -0.31412143f, 0.11828537f, 0.00246525f, 0.28582656f, -0.00094239f, 0.17692472f, 0.25420710f, 
    -0.15294437f, -0.41410747f, -0.14469919f, 0.12128586f, -0.08702177f, 0.01926061f, -0.20786886f, -0.48240831f, 
    0.02899009f, -0.08053682f, -0.16860706f, 0.13178587f, -0.95758200f, -1.09514391f, 0.14728427f, 0.07070573f, 
    -0.05938747f, 0.10470448f, -0.02469210f, -0.29313073f, -0.04992255f, -0.00359730f, 0.09845125f, -0.02033358f, 
    -0.24620175f, 0.00883542f, 0.10090411f, 0.09976834f, 0.08702172f, 0.11522026f, 0.00868440f, 0.05331537f, 
    -0.10285581f, -0.19266914f, 0.41695762f, 0.18048576f, 0.48211774f, 0.11656922f, 0.50818098f, -0.26372868f, 
    -0.04425526f, 0.02913919f, 0.28934428f, -0.16019416f, 0.11760423f, 0.06578519f, 0.20999449f, 0.36322013f, 
    -1.40386081f, -1.22210276f, -0.50001127f, -0.04433046f, -0.06122532f, -0.41186050f, -0.00549507f, -0.43024296f, 
    -0.14199927f, -0.00561466f, 0.01427376f, -0.04023252f, -0.68934667f, 0.16169988f, 0.73199975f, 0.37367344f, 
    -0.08999266f, 0.02605621f, -0.04420140f, 0.21472995f, -0.09134895f, 0.16786039f, 0.07476438f, -0.04174905f, 
    0.14005290f, -0.19920489f, -0.09083182f, 0.31668040f, -0.00994783f, 0.00692095f, 0.01976900f, -0.37777764f, 
    0.16243099f, -0.28805611f, -0.00635811f, 0.15368652f, -0.18167664f, 0.23169361f, -0.11659866f, -0.32396445f, 
    0.02877417f, 0.00811545f, -0.03744689f, -0.03386375f, -0.19918159f, -0.04180596f, -0.27088770f, -0.19355647f, 
    0.23285337f, -0.72284645f, -0.57104594f, -0.66864812f, -0.17017354f, 0.44891769f, 0.32342198f, -0.08159563f, 
    0.26989999f, 0.14490628f, 0.09761247f, 0.05213743f, 0.56777197f, -0.33399355f, -0.15913264f, -0.11632325f, 
    0.07074507f, -0.08780465f, 0.33411959f, -0.32546785f, 0.09806159f, -0.12248517f, -0.22899826f, -0.08014248f, 
    -0.18392956f, 0.01537130f, 0.24424420f, 0.03257728f, 0.10039030f, 0.03643512f, -0.03514850f, 0.10930171f, 
    0.10524503f, 0.15730396f, 0.15782493f, -0.02417915f, -0.69872826f, 0.46584854f, 0.31770179f, 0.58953470f, 
    -0.37017620f, -0.23220752f, -0.29893300f, 0.27007470f, -0.24834055f, 0.15939377f, -0.11590498f, -0.09799214f, 
    0.08765022f, -0.28059459f, -0.48267654f, -0.06425321f, 0.22463661f, 0.06998158f, 0.36550739f, -0.27723616f, 
    -0.03124692f, -0.13979676f, 0.05543199f, 0.14950942f, -1.10763681f, -1.51930141f, -0.76676697f, -0.67019141f, 
    -0.13515048f, -0.21791673f, -0.39234048f, -0.40209252f, -0.07002812f, -0.07206431f, -0.01505361f, 0.03309520f, 
    -0.05493898f, 0.52936137f, 0.12877455f, -0.04987968f, 0.05508290f, 0.07516482f, 0.02822746f, 0.04605268f, 
    0.09050846f, 0.13472490f, 0.20500068f, 0.10724824f, 0.42003310f, -0.27342293f, 0.10469193f, 0.00355306f, 
    0.11865368f, -0.08406632f, 0.17853855f, -0.02868830f, 0.13297001f, 0.27228528f, 0.12131213f, -0.28278691f, 
    -0.04245518f, 0.02265154f, 0.11346995f, -0.12467552f, -0.09357215f, -0.19792348f, 0.14922550f, 0.16144639f, 
    0.04747404f, 0.04564342f, 0.00965212f, 0.08051653f, -0.43709621f, -0.02361253f, -0.70933509f, -0.17527013f, 
    0.07501138f, -0.19377661f, 0.02674481f, 0.23170085f, 0.00558185f, -0.05754026f, -0.06312893f, -0.07094304f, 
    0.25469521f, 0.15807186f, -0.23947392f, -0.18992935f, 0.01307036f, -0.02881215f, -0.03484163f, -0.19447689f, 
    -0.33122614f, 0.19909123f, -0.14705022f, 0.12769188f, -0.15441072f, 0.41525081f, -0.18489362f, 0.55601507f, 
    -0.03967151f, 0.17100786f, 0.17285827f, 0.00398274f, -0.17926170f, -0.18811283f, -0.13271497f, -0.13036971f, 
    -0.30377796f, -0.86634189f, 0.94443500f, 0.12290705f, -0.10020519f, 0.00983368f, 0.13983969f, 0.21405925f, 
    -0.16089037f, -0.04744105f, -0.06924693f, -0.04534182f, 0.98910981f, -1.63548625f, -1.18017399f, -0.91031593f, 
    0.02830534f, -0.00950966f, -0.38680407f, 0.08766866f, 0.11968801f, 0.13157177f, 0.23095545f, 0.03219928f, 
    -0.36194026f, -0.01568995f, 0.41458338f, -0.15687463f, 0.02914964f, -0.09462773f, -0.01090020f, 0.08749551f, 
    -0.29875377f, 0.03248202f, 0.20042914f, -0.09350897f, -0.03689340f, 0.13703206f, 0.07134360f, 0.07657209f, 
    0.08836365f, 0.06674115f, -0.04394506f, -0.06707674f, 0.09237151f, -0.01685648f, 0.03634874f, -0.25093555f, 
    -0.53972185f, 0.29158652f, -0.73762149f, 0.31361616f, 0.01754009f, 0.07570484f, -0.09201548f, -0.23404166f, 
    0.00231922f, -0.22589828f, 0.02830908f, 0.20917059f, -0.48746139f, 0.10926742f, 0.11387151f, 0.00499715f, 
    -0.59613472f, -0.12544811f, -0.37654278f, -0.10113598f, 0.14758381f, 0.03695906f, -0.09632749f, -0.02863443f, 
    0.69182462f, -0.35898113f, -0.13238713f, -0.49846360f, 0.01537135f, -0.02329461f, -0.02178868f, -0.11822657f, 
    0.09393000f, 0.05316019f, 0.08036113f, -0.25078464f, -0.55680591f, 0.34332031f, 0.57558346f, -0.12596923f, 
    0.00381347f, -0.25019956f, 0.22758961f, -0.14466321f, -0.05468625f, -0.04441467f, -0.02865543f, 0.06739790f, 
    -0.17216970f, 0.17499511f, 0.04554424f, -0.27793995f, -0.05747499f, -0.21326219f, -0.06166269f, -0.13339131f, 
    0.02506264f, 0.06704409f, 0.04885972f, -0.07130630f, -0.75497395f, -0.87391913f, -0.36105067f, 0.38486505f, 
    0.20193094f, 0.15182802f, -0.17087600f, 0.00163741f, -0.06916613f, 0.03626704f, -0.02924447f, 0.03741059f, 
    -0.26193222f, -0.05069609f, -0.10529511f, 0.00672453f, -0.04462713f, -0.08250021f, 0.16698611f, 0.12774441f, 
    0.06341831f, 0.20186944f, 0.14836733f, 0.10108235f, 0.12450535f, -0.00112503f, 0.33797991f, 0.09981404f, 
    0.03338562f, 0.23526148f, -0.05229840f, -0.04607862f, 0.03334734f, -0.30172667f, 0.19371836f, -0.18897234f, 
    -0.08567102f, 0.03915066f, 0.03971260f, 0.04912488f, -0.06131019f, 0.05075150f, -0.05340321f, -0.10479123f, 
    0.15210539f, 0.14285415f, 0.11361571f, 0.12886433f, 0.36431631f, -0.60710508f, -0.62456441f, -0.17080216f, 
    -0.10431963f, 0.04825952f, 0.14697914f, 0.13519436f, -0.00769241f, -0.09019110f, -0.10922641f, -0.21408799f, 
    0.19220631f, -0.12005935f, -0.06029589f, -0.34590960f, -0.09425281f, 0.17227946f, 0.01846865f, 0.13421243f, 
    0.31917852f, 0.25109056f, 0.28874159f, 0.13715641f, -1.34714520f, -0.11616541f, 0.35909286f, 0.34145516f, 
    -0.27804279f, 0.17781609f, -0.33827582f, -0.08298906f, 0.11910819f, -0.04507351f, 0.08041444f, 0.34872368f, 
    0.74176973f, -0.41306099f, -0.70226336f, -0.73593676f, -0.26410007f, -0.23053387f, 0.20698288f, -0.08392815f, 
    0.10253500f, 0.14528334f, 0.00951926f, 0.05186193f, -0.59462464f, -0.71127731f, -0.83504564f, 0.25434855f, 
    0.07665728f, 0.30907667f, 0.10131617f, 0.09502918f, 0.06196694f, 0.09530008f, 0.04983999f, -0.13267937f, 
    -0.12256843f, -0.26394045f, 0.08572271f, -0.14636503f, -0.14583974f, -0.01068758f, -0.17403442f, 0.11582766f, 
    0.22330545f, -0.08836731f, 0.00068163f, 0.01943755f, -0.72105932f, 0.31187841f, 0.05574789f, -0.17476325f, 
    -0.14770649f, -0.16755351f, -0.18112338f, -0.08875865f, -0.12246722f, 0.03896330f, 0.05226810f, 0.22421740f, 
    -0.23442346f, 0.08883978f, 0.35354695f, 0.54082191f, 0.33265650f, 0.25335824f, -0.03975399f, 0.09453365f, 
    -0.35664654f, 0.05005896f, -0.06946518f, -0.39002341f, 0.10855766f, 0.00434184f, 0.21696980f, 0.20219766f, 
    0.16474470f, -0.18611614f, -0.37080082f, 0.01465013f, 0.11481789f, 0.35037237f, 0.28913796f, 0.03100130f, 
    0.25006583f, -0.03863939f, -0.63297492f, -0.32589698f, -0.28223932f, -0.36919746f, 0.08347899f, -0.12903513f, 
    -0.12820326f, -0.10493675f, -0.06244322f, 0.12121768f, 0.25714788f, -0.76038271f, 0.11120595f, -0.09115425f, 
    -0.11431611f, 0.27768612f, 0.21951658f, 0.07371051f, 0.01524145f, 0.08785816f, 0.22449610f, 0.20491394f, 
    -0.17983460f, 0.10663418f, 0.30121338f, -0.07052424f, -0.02266001f, -0.14593796f, -0.33985585f, -0.21291216f, 
    -0.12947291f, -0.02210956f, -0.03228658f, 0.05641361f, -0.26215774f, -1.01985598f, -0.18701911f, 0.14029911f, 
    -0.17215447f, 0.04654273f, -0.03924759f, 0.09711546f, 0.03045011f, -0.00379584f, 0.14958200f, 0.11863144f, 
    -0.31702843f, -0.40931526f, 0.16057578f, 0.15569228f, 0.05600782f, 0.16511606f, -0.03455278f, 0.13694876f, 
    -0.39164656f, -0.34465200f, -0.33626726f, -0.62776941f, -0.58793527f, 0.29524711f, 0.16892542f, 0.73702884f, 
    0.04706987f, -0.22741039f, 0.01014926f, 0.04810052f, 0.12207395f, 0.33172095f, -0.07055941f, 0.07731935f, 
    0.16878203f, -0.36288428f, -0.15201138f, -0.09881527f, 0.38764563f, 0.27627951f, 0.24030170f, 0.00905858f, 
    -0.05990929f, -0.03947671f, -0.23654521f, -0.09273475f, -0.50411600f, 0.00611341f, 0.15411836f, -0.24617565f, 
    -0.00058743f, -0.24587348f, -0.12136080f, 0.09430530f, 0.15839690f, 0.05262432f, 0.06499582f, 0.02677282f, 
    -0.27550560f, 0.40126017f, 0.03502262f, 0.24411815f, 0.11302819f, 0.00717912f, -0.31962734f, -0.01525339f, 
    -0.13730372f, -0.47676894f, -0.16346274f, -0.03428429f, -0.38396221f, -0.04174726f, -0.00420754f, -0.31153178f, 
    0.14394140f, -0.01610066f, -0.04311366f, 0.24173154f, 0.07240339f, 0.00486499f, 0.09398230f, -0.04612041f, 
    -0.62333500f, -0.26466641f, 0.20168880f, 0.04487837f, -0.12839897f, 0.00126903f, 0.17764030f, 0.07535192f, 
    -0.02433342f, 0.20853044f, -0.01193401f, -0.08528060f, -0.04894360f, 0.12153897f, 0.00944189f, 0.07165626f, 
    -0.22313115f, -0.30965242f, -0.37299833f, -0.33905196f, -0.00311454f, -0.16141489f, -0.05648040f, 0.08760817f, 
    0.69769984f, 0.09885059f, -0.29836905f, -0.32226732f, -0.11257227f, -0.00193758f, -0.10134877f, 0.22946456f, 
    -0.14895093f, 0.06006113f, -0.17720047f, -0.02156754f, -0.07716648f, -0.26567712f, -0.10486811f, 0.31556374f, 
    0.02889856f, 0.17220011f, 0.14153685f, 0.01276147f, 0.03762041f, -0.04760991f, -0.01197043f, 0.20382507f, 
    -0.43259639f, 0.85631555f, -0.85527116f, 0.11732069f, 0.02027939f, -0.01192606f, 0.20670579f, -0.10706376f, 
    -0.04238237f, 0.15378134f, 0.01582301f, 0.17150582f, 0.52858949f, -0.44676343f, -0.44887120f, -0.22583823f, 
    -0.02489918f, 0.26969084f, -0.30516312f, 0.12173765f, 0.13369560f, -0.14574105f, -0.33394146f, -0.03134991f, 
    -0.26093519f, -0.00184959f, 0.72278625f, 0.90117162f, 0.09908253f, 0.02118491f, -0.27851522f, -0.02793953f, 
    0.14820896f, 0.07253961f, 0.12531613f, -0.01770106f, 0.35974053f, -0.29285207f, 0.58462149f, -1.11628878f, 
    0.37246215f, -0.37985286f, -0.02333935f, -0.08905917f, -0.06759800f, -0.23509085f, -0.09084209f, 0.01680401f, 
    -0.03040348f, -0.59813941f, -0.26571015f, -0.57681727f, 0.17316508f, 0.39850184f, 0.21957703f, 0.24498805f, 
    0.14422673f, -0.03934044f, -0.11676931f, -0.13694343f, -0.47366044f, 0.27204451f, -0.09365028f, -0.02419990f, 
    -0.35722488f, -0.42160442f, 0.11448898f, 0.39514381f, -0.07271776f, 0.10820875f, 0.00292857f, -0.02351278f, 
    0.17904748f, -0.01841113f, 0.64944446f, -0.33692208f, -0.03444873f, -0.21694510f, -0.22704308f, 0.11088379f, 
    -0.01656454f, 0.19929929f, 0.07403762f, 0.09867158f, -0.68553960f, -0.38827112f, -0.18670586f, -0.15172470f, 
    -0.56210351f, 0.06434085f, 0.03647834f, 0.15339188f, 0.06350286f, 0.25060007f, 0.16666599f, -0.11534621f, 
    -0.68177783f, -0.72124356f, -0.22274601f, -0.07604560f, -0.04761422f, 0.07453798f, -0.60083675f, 0.14467607f, 
    0.17850713f, 0.09751526f, 0.13634251f, -0.33096835f, 0.36374265f, -0.96201313f, -0.05664909f, -0.08676293f, 
    -0.17107195f, 0.15037784f, -0.01265610f, 0.23328955f, 0.01911029f, -0.02177772f, -0.20409638f, -0.39250425f, 
    -0.16814145f, 0.41907063f, 0.61198688f, -0.38288119f, -0.27404854f, 0.28162530f, -0.07563737f, 0.13411495f, 
    0.07798361f, 0.10927624f, 0.08274774f, 0.12382900f, 0.03972788f, 0.06012921f, 0.46425536f, 0.11114101f, 
    -0.17335682f, 0.24711481f, -0.32950601f, 0.01912800f, -0.14763153f, -0.22230992f, -0.00653148f, 0.06756193f, 
    -0.39989376f, -0.18648228f, -0.31172234f, 0.07227153f, -0.28631049f, 0.15826139f, 0.06264502f, -0.07436731f, 
    -0.02413085f, 0.19375059f, 0.03326107f, -0.06269003f, 0.38350859f, 0.14550929f, 0.00702848f, -0.38995555f, 
    0.06055909f, -0.24203321f, 0.04053812f, 0.13417082f, -0.19070174f, 0.11692412f, -0.29568529f, -0.21551572f, 
    -0.70808470f, 0.57949644f, 0.01310799f, 0.13598713f, 0.25151825f, 0.45566455f, -0.16875739f, -0.12942491f, 
    -0.20822878f, 0.17483273f, 0.06436087f, -0.04501879f, -0.17309092f, -0.31158799f, -0.80204129f, -0.50666791f, 
    -0.14392774f, -0.32774836f, -0.11524093f, 0.00277818f, 0.10577540f, 0.02441558f, -0.17390853f, 0.11966254f, 
    0.21906367f, -0.39847684f, 0.08497716f, -0.13915607f, -0.02253972f, -0.43403500f, 0.02593513f, -0.06836075f, 
    -0.28810191f, 0.15256228f, -0.46260720f, -0.07075879f, -0.22996362f, -0.01794451f, 0.18355399f, 0.07621177f, 
    0.35191742f, -0.26908633f, 0.49945337f, 0.46357229f, -0.18228848f, 0.15908867f, -0.05997321f, 0.31192636f, 
    -0.48583859f, -0.01495008f, -0.15023273f, -0.04001513f, 0.02067985f, 0.26199499f, -0.19675612f, -0.02970237f, 
    -0.26990071f, -0.09325810f, -0.12186948f, -0.24981840f, 0.41469681f, -0.11158087f, 0.33913004f, 0.91541409f, 
    -0.11744834f, -0.06817168f, 0.10752019f, -0.12110106f, 0.23081551f, 0.33848062f, 0.10831688f, 0.25962454f, 
    -0.21023130f, -0.22372922f, 0.70157689f, 0.12135171f, -0.02999527f, -0.20744361f, 0.32387352f, 0.08532326f, 
    0.00051456f, -0.02530834f, 0.22776832f, -0.06463294f, -0.42272651f, 0.30052334f, -0.15241170f, 0.14353220f, 
    -0.07921728f, 0.05240771f, 0.02183969f, -0.02176111f, -0.06825978f, 0.28938261f, 0.07946011f, 0.20239013f, 
    0.02231617f, 0.04142251f, 0.02432482f, 0.26333857f, 0.15693142f, -0.35079795f, -0.21407934f, -0.00847578f, 
    -0.13520160f, -0.37734756f, -0.39257997f, -0.60193592f, 0.55336934f, -0.12983687f, 0.37222487f, 0.07632241f, 
    -0.19891502f, 0.13045785f, 0.14632143f, -0.14462519f, -0.16680901f, -0.53252500f, -0.11500400f, 0.24648561f, 
    0.73731565f, 0.52186173f, 0.16878405f, -0.06582034f, 0.03210478f, 0.02160810f, 0.07616583f, 0.18136786f, 
    -0.17337899f, 0.10675584f, -0.19265670f, -0.06869144f, 0.31026179f, -0.12308009f, 0.15160355f, -0.33702773f, 
    0.00933161f, 0.41143966f, 0.16167742f, -0.18289407f, 0.04771200f, 0.07973023f, 0.26909927f, 0.04278116f, 
    -0.30402517f, -0.22425704f, -0.34773147f, 0.44894060f, 0.08414959f, -0.01674188f, -0.01311053f, -0.07991963f, 
    0.12420683f, 0.03301401f, -0.40552887f, -0.19828507f, -0.33264291f, 0.19850786f, -0.16028081f, 0.10457703f, 
    -0.02660206f, -0.26808921f, 0.00463139f, 0.41477066f, -0.23276392f, 0.05919565f, -0.09347194f, -0.03658292f, 
    -0.82518697f, -0.99580616f, -0.22864836f, 0.48182437f, -0.03699877f, -0.11520364f, -0.02070066f, -0.34507737f, 
    0.08185821f, 0.08105380f, 0.14118068f, -0.11850843f, -0.64646077f, 0.20594499f, -0.51518410f, -0.60690433f, 
    -0.09373276f, -0.23029865f, 0.11458431f, -0.31404960f, 0.02442749f, 0.03779722f, -0.04311328f, -0.13536893f, 
    -0.33762512f, 0.45385227f, 0.03349669f, 0.53415388f, -0.04466526f, -0.20990331f, 0.21299034f, -0.09051010f, 
    0.05383985f, 0.15281528f, -0.35149601f, 0.34957105f, 0.24137218f, -0.25738049f, 0.19904070f, -0.12464663f, 
    -0.07391101f, -0.09853768f, -0.14047906f, 0.02270025f, -0.45589286f, 0.03164900f, 0.20744893f, -0.21348545f, 
    0.52748901f, -0.32875952f, 0.78202116f, -0.56117368f, 0.15689120f, -0.13710949f, -0.07564472f, 0.25059634f, 
    -0.02410499f, 0.05198661f, 0.12476483f, 0.02811835f, -0.29181316f, 0.28950915f, 0.35515141f, 0.18687227f, 
    0.13185234f, -0.24180500f, 0.55694091f, -0.48116431f, -0.02277444f, -0.24425797f, -0.03339748f, 0.10470749f, 
    -0.80136693f, 0.19230217f, -0.73387891f, 0.13606101f, 0.13689299f, 0.19971482f, 0.06598865f, -0.11418337f, 
    -0.09922551f, 0.16676533f, 0.53124106f, 0.15046729f, -0.51842999f, 0.34962675f, -0.30842438f, 0.37341663f, 
    -0.08273241f, 0.24520688f, -0.12363630f, 0.22458003f, -0.30048582f, -0.12306902f, -0.12301021f, -0.21346611f, 
    0.34994811f, 0.39522645f, 0.00822810f, 0.51520580f, -0.24554019f, 0.15015772f, -0.30234709f, -0.05484526f, 
    0.00059569f, -0.00654130f, -0.16090298f, 0.18913984f, 0.18649493f, -0.21206656f, 0.36045843f, -0.48320818f, 
    0.17823149f, -0.47520724f, -0.02670112f, -0.08199452f, -0.00292794f, -0.06100182f, -0.23345859f, -0.11285161f, 
    -0.85796148f, 0.04189676f, -0.13552633f, -0.11435425f, -0.05865253f, 0.11773246f, -0.01155870f, 0.16721585f, 
    -0.26677197f, 0.02251896f, 0.09282993f, 0.23619685f, -0.70438385f, 0.67800158f, -0.10299535f, -0.20720153f, 
    0.13856845f, 0.18946749f, 0.01189375f, -0.08148358f, -0.18118568f, 0.33620521f, 0.15041797f, -0.11472065f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.33271700f, -0.00856362f, 0.08378623f, -0.15716517f, -0.11938823f, 0.18606021f, 0.09549556f, -0.29372698f, 
    0.17562900f, 0.07263800f, 0.04302960f, -0.07181485f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
