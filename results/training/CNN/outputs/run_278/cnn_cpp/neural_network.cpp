#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.84225655f, -0.27433148f, 0.08212686f, 0.32245269f, 0.29071486f, -0.18241005f, 0.39405552f, 0.35583740f, 
    -0.02870031f, 0.35097015f, 0.27079937f, 0.10179836f, -0.15185392f, -0.28401917f, -0.08697642f, -0.20178606f, 
    -0.08724809f, -0.31268337f, 0.27494007f, -0.13237415f, 0.28507242f, 0.00434883f, -0.05175922f, 0.06761051f, 
    -0.09254671f, 0.45965734f, 0.65645289f, 0.61806923f, 0.30696121f, -0.22673824f, -0.06329474f, -0.01662697f, 
    0.15177086f, 0.22695072f, 0.15401803f, -0.03625118f, 0.23051396f, -0.21137057f, 0.06312355f, 0.00654728f, 
    0.33010373f, 0.04742452f, -0.20861891f, 0.00636729f, -0.44628650f, -0.25247291f, -0.24890614f, -0.53450334f, 
    0.14811678f, -0.09830206f, 0.84151542f, -0.36597586f, 0.46001291f, 0.38756299f, 0.66481483f, -0.21116833f, 
    -0.32009184f, -0.32371804f, -0.07589294f, 0.00036406f, -0.16722061f, 0.27649504f, 0.17693163f, 0.16928534f, 
    -0.05553763f, -0.50463402f, -0.13551088f, -0.30773351f, 0.20348655f, -0.16487657f, 0.17168573f, 0.10917005f, 
    -0.23022588f, -0.16260298f, -0.09866677f, 0.86528426f, 0.56174415f, 0.47991252f, -0.07429866f, 0.51781321f, 
    -0.01519761f, 0.16435425f, 0.07236139f, 0.32427126f, 0.37239546f, -0.23207657f, 0.18807445f, -0.13358985f, 
    0.20492126f, 0.17757419f, -0.33576244f, -0.04480961f, -0.20344242f, -0.24595302f, 0.06368562f, -0.09936056f, 
    0.07700446f, 0.16532181f, -0.00160738f, 0.03552666f, -0.43930426f, -0.71531552f, 0.20018956f, 0.43082395f, 
    -0.34965339f, 0.41895714f, 0.14682297f, -0.37999895f, -0.38719091f, -0.60985255f, -0.12207334f, 0.29766575f, 
    -0.01400066f, -0.10102626f, 0.29621312f, 0.17874619f, 0.25948107f, -0.35672653f, -0.03348669f, 0.14220248f, 
    -0.21357957f, 0.33914477f, 0.25241750f, -0.02996980f, -0.02110688f, 0.61978889f, -0.38250577f, -0.62163508f, 
    -0.34606102f, 0.08530488f, -0.64875078f, -0.22167157f, 0.03880293f, 0.05525564f, 0.29191929f, 0.41124249f, 
    0.07042880f, 0.04953596f, -0.04397482f, 0.15120852f, 0.11877852f, 0.24239823f, -0.15224148f, 0.18649426f, 
    0.01417746f, 0.21081375f, -0.11966903f, 0.21934116f, -0.09803738f, 0.50578296f, -0.62320256f, -0.65904480f, 
    -0.65187824f, -0.47238562f, -0.07567070f, -0.08876559f, 0.51329654f, 0.56716007f, -0.07838964f, 0.47904462f, 
    0.27606693f, 0.01673510f, -0.01426882f, -0.29301539f, 0.03954032f, 0.03118864f, -0.00467943f, -0.03442157f, 
    0.21464024f, -0.09624630f, 0.00551242f, -0.00111240f, 0.03548925f, 0.09741926f, 0.15885423f, 0.46305907f, 
    0.13304101f, 0.58294725f, 0.87804133f, 0.16141285f, 0.01744531f, 0.25903845f, 0.21591207f, 0.18065463f, 
    -0.16156960f, -0.64143771f, -0.25062245f, -0.33860874f, 0.31134754f, -0.06963828f, -0.05992385f, -0.16773975f, 
    0.12218318f, 0.21959533f, 0.04962733f, -0.18950887f, -0.13631798f, -0.14272289f, -0.12912925f, -0.01073559f, 
    -0.06101593f, 0.13154724f, 0.34366903f, -0.38517928f, 0.33491257f, 0.55586797f, -0.21202721f, -0.04198592f, 
    0.29590839f, 0.08508291f, 0.15870440f, 0.00115294f, -0.48882091f, 0.25052696f, 0.07741415f, 0.11984237f, 
    0.12793997f, -0.16695791f, -0.01079073f, 0.35761768f, 0.20825353f, 0.34035546f, 0.41031680f, 0.17340359f, 
    0.10437146f, -0.66540593f, -0.15013354f, -0.62111109f, -0.64560223f, -0.44249973f, 0.26163396f, -0.19919859f, 
    -0.18253522f, -0.11274717f, 0.14599541f, -0.15040527f, 0.11805306f, -0.22020876f, 0.18616296f, 0.26342022f, 
    0.04583741f, 0.31036618f, -0.14485861f, 0.16161744f, 0.32615271f, -0.10298292f, -0.06043321f, 0.03689180f, 
    -0.24373543f, 0.16253269f, 0.60914481f, 0.79655463f, 0.35864410f, 0.25732648f, 0.10121889f, -0.47402903f, 
    -0.93025690f, -0.42599520f, -0.48468119f, -0.36983305f, 0.10784728f, 0.43078971f, 0.08241188f, -0.18878311f, 
    0.12902044f, 0.18492478f, -0.12047321f, 0.22425131f, -0.00227916f, 0.16424134f, 0.16994458f, 0.35000601f, 
    0.00530657f, -0.08545419f, 0.06750775f, -0.22633086f, 0.92972583f, 0.50350183f, -0.26941437f, 0.17800671f, 
    0.50148994f, -0.17738757f, -0.13161395f, -0.16077729f, -0.09725533f, -0.39093921f, -0.06048735f, -0.18742970f, 
    0.04070789f, -0.17727149f, -0.38811320f, -0.05062078f, -0.12895449f, -0.16325524f, -0.04608370f, -0.18183464f, 
    -0.07143761f, -0.07675103f, -0.21975854f, -0.11192632f, 0.98146415f, 0.18714300f, -0.11611114f, 0.69773996f, 
    0.67030334f, 0.73861212f, 0.26147315f, -0.67667842f, 0.14533825f, -0.24790893f, -0.15880023f, -0.01583823f, 
    -0.17463917f, 0.12606712f, -0.18131933f, 0.05719259f, -0.05535247f, 0.10316994f, 0.11579549f, -0.11008105f, 
    0.13762578f, 0.11571161f, 0.10904901f, -0.03946968f, 0.18695615f, 0.76028925f, 0.26796293f, -0.02640571f, 
    0.79649377f, 0.54186100f, -0.23490147f, 0.24322285f, 0.23377433f, 0.02635172f, 0.20344217f, -0.06623025f, 
    0.08586385f, 0.38233301f, -0.16669424f, 0.11149484f, 0.14700541f, 0.02443783f, 0.28460199f, -0.21211436f, 
    0.25035751f, 0.01747315f, -0.18014707f, 0.23793471f, 0.02997665f, 0.17784899f, 0.21103276f, 0.15486921f, 
    -0.37231743f, -0.83909792f, 0.47323245f, -0.29125944f, -0.11858729f, -0.39003426f, -0.39405605f, -0.29583964f, 
    0.00366369f, -0.04364899f, 0.26672438f, 0.05979539f, -0.43781081f, 0.07079345f, 0.10078374f, 0.27761355f, 
    0.04531243f, 0.44570482f, -0.14959483f, -0.25724679f, -0.05918675f, -0.13618913f, 0.09819432f, -0.79154795f, 
    -1.10669506f, -0.35984939f, 0.35375625f, -0.13391827f, 0.54999769f, 0.69630146f, 0.37271860f, 0.11704639f, 
    0.21950616f, -0.34771594f, -0.24616426f, -0.27139154f, 0.05532794f, -0.00971207f, -0.06440704f, 0.09284079f, 
    -0.07933380f, -0.26443726f, -0.16565719f, -0.21225852f, -0.11156984f, 0.22517578f, -0.13611537f, -0.09839259f, 
    -0.24370050f, 0.52139431f, -0.29792798f, -0.59457868f, -0.60904795f, 0.67457455f, -0.54762650f, -0.01107537f, 
    0.46307749f, -0.37468755f, -0.17909701f, -0.06395584f, 0.30973119f, 0.14598072f, -0.04088657f, 0.07489885f, 
    -0.06607179f, 0.02214547f, 0.01236416f, 0.06705137f, -0.11050311f, 0.02803918f, 0.15754806f, 0.03493223f, 
    0.11382601f, -0.73784178f, 0.53540999f, -0.34973705f, -0.26219201f, -0.21564581f, 0.41499797f, 0.65984440f, 
    -0.28430852f, 0.33539525f, 0.59846997f, -0.38943347f, -0.29448265f, -0.01293374f, -0.30126780f, 0.15266600f, 
    -0.30067825f, -0.34760433f, 0.07909710f, -0.07639153f, -0.13705002f, 0.20428696f, 0.02042771f, -0.08756983f, 
    0.04710899f, 0.08526989f, -0.96877992f, 0.15487844f, 0.28611550f, -0.17101444f, -0.64110208f, 0.43499038f, 
    0.71386373f, -0.41755652f, 0.20047799f, 0.26995441f, -0.00397646f, -0.08405489f, -0.33049518f, -0.31342897f, 
    -0.18891256f, 0.15639672f, 0.27171358f, -0.02110569f, -0.18181182f, -0.35339844f, -0.07611083f, -0.17329124f, 
    0.15555485f, -0.00738343f, 0.09163972f, -0.36742041f, 0.61868227f, -0.49901938f, -0.41922966f, 0.13845655f, 
    0.35853156f, -0.14912339f, -0.49232468f, -0.11693905f, -0.58974332f, 0.10525472f, 0.18581820f, -0.04141702f, 
    0.32733110f, -0.11195906f, -0.18368299f, -0.16010730f, -0.42894801f, -0.47872660f, 0.41482356f, -0.09802366f, 
    0.01465405f, 0.05669592f, 0.28244150f, -0.40621990f, -0.71926844f, -0.54118687f, -0.46242517f, -0.26518157f, 
    -0.12616068f, -0.35541618f, -0.28407103f, 0.51169986f, 0.05053719f, -0.27208599f, 0.09721697f, 0.05692400f, 
    0.26427731f, 0.16168830f, -0.04464597f, 0.07152234f, -0.12485428f, -0.14228462f, -0.22278719f, -0.13983910f, 
    0.22531384f, 0.18057770f, 0.04577023f, -0.15463905f, 0.12116574f, 0.57101637f, 0.39010093f, 0.07351613f, 
    0.52548420f, 0.58170456f, 0.14402996f, -0.14170128f, 0.09795764f, -0.34877458f, -0.01433698f, 0.26923347f, 
    -0.21525627f, 0.02373690f, -0.05738047f, 0.04753718f, 0.31127447f, 0.26636657f, 0.20996720f, 0.31860030f, 
    0.32192627f, 0.15662552f, 0.13937715f, -0.09039540f, 0.16225964f, 0.26288345f, 0.61065841f, -0.06516436f, 
    -0.55428088f, 0.12981761f, 0.17864802f, 0.43793342f, 0.45680711f, -0.62300879f, 0.15207852f, 0.35884464f, 
    0.00725849f, 0.35297021f, -0.34218115f, 0.53200835f, -0.01376150f, 0.05937401f, -0.20667122f, 0.17964986f, 
    0.01512700f, -0.32047179f, 0.28314972f, 0.08485422f, -0.26792619f, -0.12606657f, 0.35454649f, -0.18276867f, 
    0.88834381f, 0.57514083f, 0.33035389f, 0.33185154f, -0.31490204f, -0.29547980f, -0.53877544f, -0.30688587f, 
    -0.24607515f, 0.15700071f, -0.08305378f, 0.01876517f, 0.08063682f, 0.07778627f, -0.11936296f, -0.21679248f, 
    -0.18126202f, -0.23839390f, -0.14201759f, -0.28389674f, 0.11466195f, -0.04078376f, 0.07790209f, 0.00202708f, 
    0.99024290f, 0.49641386f, 0.94248879f, -0.76183355f, -0.67871320f, 0.25303012f, -0.20296431f, 0.17925918f, 
    -0.05252803f, -0.24753691f, 0.29151216f, 0.15921594f, -0.39829057f, -0.29267383f, -0.19397213f, 0.03898951f, 
    0.04280451f, 0.04810081f, -0.13667570f, -0.16196272f, 0.19561924f, 0.13300161f, 0.04385626f, 0.07250158f, 
    -0.16554722f, -0.52537519f, -0.60359782f, -0.28346896f, -0.41190097f, -0.34970796f, -0.39979035f, -0.53906882f, 
    0.07585336f, 0.11675056f, -0.42576647f, 0.03813270f, -0.07795431f, -0.17530905f, 0.13853984f, -0.45802107f, 
    -0.11929728f, -0.04213522f, -0.09121766f, 0.26835606f, 0.09606072f, 0.00061413f, -0.07389682f, 0.10078323f, 
    0.04663493f, 0.01963139f, -0.75377625f, 0.40526640f, 0.49644643f, 0.14851446f, 0.55989116f, -0.58244240f, 
    0.29589376f, 0.11086186f, -0.54473919f, -0.02691627f, -0.25046363f, 0.00308688f, 0.36945131f, 0.03864057f, 
    0.30521828f, 0.19124494f, 0.20883481f, 0.21843812f, -0.00890019f, -0.01747063f, 0.15194935f, -0.06752049f, 
    -0.17440510f, -0.15984878f, -0.02291523f, -0.45211393f, -0.41062975f, -0.14817730f, -0.30305493f, -0.58800685f, 
    -0.43376040f, 0.54554105f, 0.53622907f, 0.01190476f, 0.06202950f, -0.35140678f, 0.36666185f, -0.07692995f, 
    0.20803845f, -0.36973822f, 0.04870391f, 0.02146521f, 0.11042837f, -0.16814618f, 0.12121014f, -0.23136714f, 
    -0.15380564f, -0.29070097f, -0.41948116f, -0.06243180f, 0.70123267f, 0.05800753f, 0.67635864f, 0.50336927f, 
    -0.34015280f, 0.19519332f, -0.63712454f, -0.16333194f, 0.37268671f, 0.02303837f, -0.18684401f, -0.32606724f, 
    -0.04619154f, 0.13549027f, 0.18552087f, 0.02575765f, 0.01704203f, -0.17866938f, -0.03962288f, -0.01679082f, 
    0.38906991f, 0.24686474f, 0.15816693f, -0.00334640f, 0.20028102f, -0.58092296f, 0.94064313f, -0.17820893f, 
    -0.60391456f, 0.40168431f, 0.37138501f, -0.42529312f, -0.56710690f, -0.20798963f, -0.25263086f, -0.36420536f, 
    -0.22463125f, -0.25334573f, 0.12117948f, -0.14099848f, -0.35934934f, -0.05197245f, -0.00307704f, -0.33835888f, 
    -0.47545236f, 0.12678853f, 0.11957871f, 0.09493743f, -0.03940076f, 0.10466531f, -0.38036683f, -0.44137976f, 
    -0.18876085f, 0.26111764f, 0.57750970f, -0.64392376f, 0.46767777f, 0.79744738f, 0.02872213f, 0.47162190f, 
    -0.00769140f, -0.43249771f, 0.26089618f, 0.12040642f, 0.14128481f, 0.03085921f, -0.03134411f, -0.19728011f, 
    -0.14078647f, -0.33985034f, 0.17340586f, 0.07974064f, -0.22527274f, 0.32553044f, -0.14587268f, -0.83559442f, 
    0.33727756f, 0.43803194f, -0.47133887f, -0.12329637f, 0.26530537f, 0.37889326f, 0.57972127f, 0.56112927f, 
    -0.31515154f, 0.04033436f, -0.22619092f, -0.48319623f, -0.18969348f, -0.12828588f, -0.26044726f, -0.20314094f, 
    -0.27846664f, -0.00066603f, 0.00360786f, -0.03194725f, 0.17540430f, -0.07759196f, -0.07909704f, -0.21066408f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.13692652f, 0.11117537f, 0.14039284f, 0.05791963f, 0.07014307f, 0.10996833f, 0.06922781f, 0.07633003f, 
    0.14184640f, 0.30877140f, 0.08807582f, -0.02468257f, -0.06097211f, -0.02765293f, 0.22490300f, 0.03119550f, 
    0.06231653f, -0.15432778f, -0.06536679f, -0.06801265f, 0.33458665f, 0.02177109f, -0.06326028f, 0.06700632f, 
    0.07953611f, 0.16817077f, -0.02164887f, -0.09094796f, 0.14772342f, 0.16006468f, 0.17047906f, 0.01433639f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.12213191f, -0.10406463f, 0.13291745f, 0.06372167f, -0.04561016f, 0.07776462f, -0.08176591f, 0.02431112f, 
    -0.03542383f, 0.01460083f, -0.05253801f, 0.09375376f, 0.02454227f, 0.24025540f, 0.04909818f, 0.20532484f, 
    -0.14541019f, -0.00859587f, -0.04426874f, 0.04184165f, 0.00319082f, 0.01366128f, 0.11810854f, 0.14034434f, 
    0.14709121f, 0.09254836f, 0.16549259f, 0.14922203f, 0.01465218f, 0.09754179f, 0.08067392f, 0.03226481f, 
    0.06547223f, 0.06986232f, 0.00189922f, 0.09178623f, 0.15922897f, 0.06403968f, 0.04373218f, -0.08226796f, 
    -0.17518815f, 0.05421359f, 0.13063005f, -0.00817915f, -0.06219309f, -0.13212691f, 0.07964142f, -0.04453142f, 
    0.04499730f, 0.13618149f, 0.06227975f, 0.37327495f, -0.00506217f, 0.22469622f, -0.00087493f, 0.08389561f, 
    0.01544454f, -0.00601402f, 0.15367080f, -0.01444853f, 0.29790509f, -0.26087421f, 0.17891268f, -0.03624295f, 
    0.21401933f, 0.03187204f, -0.02557668f, -0.06777968f, -0.07107501f, 0.05015661f, -0.07652546f, 0.02558185f, 
    0.31154618f, -0.01348647f, -0.19781011f, -0.30626908f, 0.10004660f, 0.03650603f, 0.05255106f, 0.09173970f, 
    0.08658805f, -0.03394197f, 0.01228776f, 0.12220407f, -0.00309494f, -0.13772210f, -0.05248595f, 0.06906592f, 
    -0.17911182f, 0.08525836f, 0.05290160f, -0.03656101f, -0.00079286f, -0.05451544f, 0.01875097f, 0.06294330f, 
    -0.10345553f, -0.08854478f, 0.12075732f, 0.01206343f, 0.04769040f, 0.07680363f, 0.03427734f, 0.03168087f, 
    -0.00277881f, 0.05063389f, 0.12351922f, -0.05187370f, -0.14953327f, -0.00189339f, -0.04527086f, -0.24742520f, 
    0.11748356f, 0.09984163f, 0.09990238f, 0.04053042f, 0.06979546f, 0.06024843f, 0.03092651f, 0.03335209f, 
    0.33906209f, 0.15276350f, 0.04704029f, 0.11331777f, 0.12652518f, 0.11374320f, 0.02109256f, 0.05252464f, 
    -0.14117317f, 0.05755209f, -0.06118735f, 0.08200935f, 0.00232122f, -0.08525160f, 0.14013726f, -0.05667515f, 
    -0.12660965f, -0.06408269f, 0.11575359f, -0.01739370f, -0.09330161f, -0.01747757f, -0.03312468f, -0.04195556f, 
    -0.00581045f, -0.29568183f, 0.07111166f, -0.03779279f, 0.02834701f, -0.03033253f, -0.02131799f, 0.07579055f, 
    0.00549673f, -0.03309140f, 0.04793159f, 0.02046906f, 0.00572939f, 0.14609520f, 0.09292579f, -0.09005528f, 
    -0.12629259f, 0.15287165f, 0.00034699f, 0.00757734f, 0.01040096f, -0.11701854f, 0.09487694f, 0.18859302f, 
    0.09591900f, 0.02374688f, 0.36546239f, -0.07983568f, 0.01888588f, 0.06861381f, 0.14273821f, 0.00897314f, 
    -0.08351029f, 0.04372715f, -0.02632503f, 0.14678928f, 0.38890451f, 0.23211417f, -0.15795778f, -0.08662658f, 
    0.07587462f, 0.07476333f, 0.08235936f, -0.01849700f, 0.06676044f, 0.03460659f, 0.10745908f, -0.05347520f, 
    -0.34717587f, -0.24915837f, 0.21775115f, -0.08810034f, -0.09599980f, 0.03188924f, 0.03258304f, 0.03105251f, 
    -0.00263981f, -0.01071117f, -0.02964384f, 0.11687259f, -0.09382435f, -0.03966177f, 0.13489266f, -0.23498695f, 
    0.02036197f, -0.00510794f, 0.11995057f, -0.03188003f, -0.04640183f, 0.03925283f, 0.07027041f, 0.18410814f, 
    -0.33991149f, -0.06087078f, -0.02088338f, -0.02484827f, 0.09298804f, 0.09853082f, 0.00277404f, 0.06333128f, 
    0.09987365f, 0.03373593f, 0.11072255f, -0.07949332f, 0.26271197f, -0.19305399f, 0.28144392f, 0.02275918f, 
    -0.06452531f, 0.02586718f, 0.04164146f, 0.11170644f, 0.06255098f, 0.00886669f, -0.06780011f, -0.11682690f, 
    0.01385623f, -0.03507617f, -0.12793817f, 0.10240013f, -0.03131462f, 0.02667822f, 0.07059576f, 0.01217939f, 
    0.10071252f, 0.02844228f, -0.02771824f, 0.03915035f, 0.11136047f, 0.01970804f, 0.17401464f, -0.07037878f, 
    -0.05037695f, 0.04002505f, 0.01996305f, -0.03272214f, -0.09917321f, -0.04781937f, -0.06001747f, 0.09280694f, 
    0.29164544f, -0.22403242f, 0.00520586f, -0.17020918f, 0.09589990f, 0.02291628f, -0.00236232f, 0.01139606f, 
    -0.03433815f, 0.01237818f, -0.04304278f, -0.08244191f, 0.46538854f, 0.02982788f, -0.17599674f, 0.01232254f, 
    0.09571992f, 0.05788924f, 0.05740416f, -0.06413101f, -0.18103035f, 0.01058722f, 0.05972548f, -0.02580671f, 
    -0.16600762f, -0.03341395f, -0.08196049f, 0.28369889f, -0.05500479f, -0.06264402f, 0.01519644f, 0.10313165f, 
    0.02652441f, 0.01681727f, 0.02853901f, -0.08575649f, 0.12502265f, -0.05201136f, -0.01945019f, 0.03872816f, 
    0.01185753f, 0.05844933f, 0.06430908f, 0.11787400f, 0.03804995f, 0.10951410f, -0.01444174f, 0.05504375f, 
    -0.00330149f, -0.06196000f, -0.01333803f, -0.03676375f, 0.01788243f, 0.09714118f, 0.01638621f, -0.08591615f, 
    -0.03836782f, 0.00475457f, 0.03539988f, -0.02447003f, -0.00266118f, 0.12506008f, -0.31483793f, -0.05079005f, 
    -0.03146706f, 0.08597240f, -0.06497069f, 0.22399686f, -0.02631863f, -0.02480361f, 0.05351406f, 0.03566544f, 
    0.19214243f, -0.06373230f, -0.17323086f, 0.02435571f, -0.07940692f, -0.09502596f, 0.09722883f, 0.00968242f, 
    -0.09181730f, -0.01037413f, 0.06948996f, -0.03286790f, 0.16258219f, -0.01861411f, 0.16209707f, -0.05259157f, 
    -0.04420390f, -0.14607877f, 0.14055617f, -0.01372874f, -0.08204230f, -0.06591396f, 0.04728755f, 0.07733838f, 
    -0.02491157f, 0.12449463f, -0.07097813f, -0.02031387f, 0.03097239f, 0.07162812f, 0.00718398f, -0.06806823f, 
    -0.02019237f, 0.13577235f, -0.02901651f, 0.01997477f, -0.28531954f, -0.00526904f, 0.01798611f, 0.01215543f, 
    0.04764725f, 0.03948782f, 0.10499143f, 0.10352332f, 0.08199122f, 0.07536571f, 0.02037970f, 0.00712537f, 
    -0.01071286f, -0.05192452f, -0.00705532f, 0.02888549f, -0.05599295f, 0.03306152f, 0.02443943f, 0.04212651f, 
    -0.03198671f, 0.01224441f, -0.02012961f, -0.04899368f, -0.05453827f, 0.04176351f, -0.05654773f, -0.01826848f, 
    -0.05369670f, 0.03016996f, 0.00167926f, -0.05593349f, -0.03644421f, -0.02948541f, 0.00413905f, -0.05412458f, 
    0.01777604f, 0.03476464f, 0.01562330f, -0.05397063f, 0.03526431f, 0.01954303f, -0.01949517f, 0.00995835f, 
    -0.04907092f, -0.01098211f, -0.05685995f, -0.03749878f, 0.00216215f, 0.03016391f, -0.03403424f, 0.03454049f, 
    0.01263325f, -0.01851677f, -0.04948879f, 0.01462678f, 0.04740731f, 0.01355415f, -0.04500176f, 0.04198364f, 
    -0.02472338f, -0.01649387f, 0.05363426f, -0.00160459f, 0.04160185f, -0.03878667f, -0.02779006f, -0.03141057f, 
    0.04571553f, -0.01545708f, 0.00240998f, 0.03792083f, -0.00012731f, 0.03007610f, 0.01342878f, 0.03296662f, 
    -0.04820628f, 0.01582726f, -0.05560241f, 0.02888962f, 0.02585730f, -0.03893838f, 0.01040884f, -0.04454093f, 
    0.03199234f, -0.01697698f, -0.01091476f, 0.01658965f, -0.00417452f, -0.05519331f, 0.00870212f, -0.04846593f, 
    0.04206840f, 0.01285014f, 0.00030717f, -0.05694817f, 0.04099675f, 0.00890785f, -0.03118688f, 0.02855858f, 
    -0.04633068f, -0.02249761f, -0.01446124f, 0.00606253f, 0.01545476f, 0.03481230f, 0.03293922f, -0.01721875f, 
    0.02792671f, 0.01224041f, -0.02644053f, -0.00285970f, 0.02914483f, 0.04525268f, 0.01433744f, -0.03866591f, 
    0.03019278f, 0.03517087f, -0.01643543f, -0.03830555f, 0.02610353f, 0.00848216f, -0.01232534f, 0.03948221f, 
    -0.01351089f, -0.04359479f, -0.03132703f, -0.03553734f, -0.04209387f, 0.01486147f, 0.02148537f, -0.00476798f, 
    -0.01677570f, 0.01506085f, 0.03455136f, 0.04209020f, -0.04498639f, 0.00429190f, -0.01516404f, 0.01948566f, 
    -0.00216736f, -0.03264255f, 0.01292548f, -0.03503548f, 0.01152492f, 0.01312057f, -0.04998751f, 0.02776599f, 
    0.02171426f, -0.01460484f, -0.01073298f, -0.01686565f, -0.01553662f, -0.01393732f, 0.03549044f, 0.03980257f, 
    -0.03469144f, -0.01437034f, 0.04751351f, 0.02584513f, 0.01968119f, 0.04543405f, 0.01773576f, -0.05581269f, 
    0.00013537f, -0.03124201f, 0.02009181f, 0.02458257f, -0.03090384f, 0.03229139f, 0.00431296f, -0.01336739f, 
    -0.03098550f, -0.02405901f, -0.01334531f, 0.01069370f, 0.01798620f, 0.03154111f, 0.01600609f, -0.02428541f, 
    -0.02569213f, 0.01028949f, 0.01515808f, -0.04003711f, -0.02119635f, -0.03400596f, 0.02160935f, -0.02268142f, 
    0.00531485f, -0.04129541f, 0.03614530f, -0.05446389f, -0.02852372f, -0.03752345f, 0.01619265f, -0.03241562f, 
    0.00157503f, 0.04796304f, -0.05432042f, 0.00805999f, 0.04571198f, -0.04957708f, -0.05164378f, 0.00536902f, 
    0.01299975f, 0.03015157f, -0.00413939f, -0.02784356f, 0.04139562f, 0.00565114f, -0.05117999f, -0.01781232f, 
    -0.03660435f, -0.01455909f, 0.02645880f, 0.01008740f, 0.01432791f, 0.02319106f, -0.02568193f, 0.01629979f, 
    -0.01849478f, -0.04515680f, -0.05713077f, -0.03384057f, -0.04467562f, -0.04827034f, 0.00472942f, -0.02106992f, 
    -0.03819587f, 0.01088535f, -0.02844406f, -0.00468639f, 0.00837042f, -0.05491881f, 0.02124311f, 0.03286493f, 
    -0.00938115f, 0.00605015f, 0.04174533f, 0.01172372f, -0.03753763f, -0.04262904f, 0.03326051f, -0.05611458f, 
    -0.03895069f, 0.04215452f, 0.00602425f, -0.01296190f, -0.00422640f, 0.00670049f, -0.02210451f, -0.05153546f, 
    -0.01187688f, 0.00978095f, -0.04856389f, 0.02211553f, 0.04327304f, 0.00121650f, -0.01221105f, 0.00052918f, 
    0.00987828f, -0.05480529f, 0.01768441f, 0.03909585f, -0.01093922f, -0.03862377f, -0.04079848f, -0.00294509f, 
    0.01002655f, 0.02474257f, 0.04175221f, 0.04281570f, -0.05164723f, 0.03044894f, 0.02447675f, 0.01174697f, 
    0.00051798f, 0.04168982f, -0.00221704f, 0.00068178f, -0.03604930f, -0.03610564f, -0.06033195f, -0.03893599f, 
    -0.05269827f, -0.00359048f, 0.04034914f, -0.03739604f, 0.03291252f, -0.05875275f, -0.01428210f, -0.01341123f, 
    0.00672557f, 0.00062150f, 0.00062287f, -0.00292233f, 0.03578555f, 0.00299099f, -0.02234397f, -0.01015712f, 
    -0.04479255f, -0.01321428f, -0.01681947f, -0.01122994f, -0.03434808f, 0.00713156f, -0.02247985f, 0.03527395f, 
    0.04258970f, -0.05405435f, 0.03901286f, -0.04700238f, -0.00506826f, 0.02652632f, -0.01473982f, -0.00155171f, 
    0.02242885f, 0.02430099f, -0.01166569f, 0.02697537f, 0.03322386f, 0.00585276f, -0.03478983f, -0.05394209f, 
    -0.02129075f, -0.00962672f, 0.03159270f, -0.04163219f, 0.04371214f, -0.00984371f, -0.04287666f, -0.00926351f, 
    -0.00035603f, 0.00227082f, 0.00743720f, -0.02201571f, -0.02405253f, 0.00763438f, -0.04002522f, -0.01610155f, 
    0.02388232f, 0.02053938f, 0.02844554f, 0.00108876f, -0.05173784f, -0.01255996f, -0.03982024f, 0.02578262f, 
    -0.05246053f, 0.03394975f, -0.03063168f, 0.02686920f, 0.01997346f, -0.03104679f, 0.03183492f, -0.05496676f, 
    0.01048180f, 0.02042898f, -0.00510484f, -0.05292800f, -0.05419925f, -0.00983507f, -0.02047887f, -0.05603790f, 
    -0.04777289f, 0.00549672f, 0.03597103f, -0.00504590f, 0.02910755f, 0.02379272f, -0.00467099f, 0.03232702f, 
    -0.00290940f, 0.01741485f, -0.00292232f, -0.03472327f, -0.01208619f, -0.01512082f, 0.02285738f, -0.04274055f, 
    -0.02257442f, 0.01318612f, 0.04137282f, 0.01852329f, -0.04731321f, 0.02060923f, -0.01359599f, -0.04806518f, 
    -0.03608101f, 0.00390758f, -0.00194420f, -0.00073372f, 0.03374000f, -0.01387398f, -0.01411927f, -0.00353159f, 
    -0.11863206f, 0.06769732f, -0.03060324f, 0.02851107f, 0.10747658f, 0.02278434f, 0.05147551f, -0.09155010f, 
    0.07899597f, 0.00548872f, 0.08632737f, -0.16162039f, 0.26107910f, -0.16840343f, 0.15601766f, -0.21282421f, 
    0.07212863f, 0.01219965f, -0.04976354f, -0.00357936f, -0.00980347f, 0.02632914f, 0.01786683f, 0.12841800f, 
    -0.13240094f, -0.07641457f, -0.12948883f, 0.05975810f, 0.01943472f, -0.03058227f, -0.03586164f, 0.00526074f, 
    -0.10847733f, -0.06157597f, 0.03955835f, 0.08118346f, 0.21880782f, -0.00819304f, -0.01929726f, 0.10545076f, 
    0.11471586f, 0.11024740f, -0.09179637f, -0.05879088f, 0.04636558f, 0.06776264f, -0.04974206f, -0.03409580f, 
    -0.15974924f, 0.11640139f, -0.16691622f, 0.01100362f, 0.02561479f, -0.08351452f, 0.02006568f, 0.06622824f, 
    -0.03213644f, 0.05958565f, -0.06104995f, 0.16037141f, 0.02751467f, 0.25109881f, -0.20639840f, 0.00752843f, 
    -0.15439774f, -0.02795207f, -0.00314035f, 0.11390620f, -0.05532982f, 0.11951606f, -0.01463694f, 0.04479552f, 
    -0.13160595f, -0.04075445f, 0.04324775f, 0.27079114f, 0.05250579f, 0.02481295f, 0.04322789f, 0.02952592f, 
    -0.08647525f, 0.05952570f, 0.06805758f, -0.11291417f, 0.31231928f, 0.23247515f, 0.03831143f, 0.05497970f, 
    0.08726972f, -0.02418438f, 0.00794301f, -0.05741736f, 0.09723130f, 0.09163149f, -0.00458409f, 0.08181474f, 
    0.06266334f, 0.02739370f, -0.06739084f, -0.14049070f, 0.03035704f, -0.01283619f, -0.04982641f, 0.00707067f, 
    0.01781589f, -0.15155761f, -0.14993760f, -0.05454355f, 0.00182485f, 0.04017190f, 0.06160674f, 0.24442413f, 
    0.15601952f, 0.07729418f, 0.05056236f, -0.00613958f, 0.08243939f, 0.02069516f, -0.06619442f, -0.04875943f, 
    -0.25305653f, -0.20808969f, 0.00814357f, 0.02701020f, -0.09363149f, -0.05033173f, -0.08823116f, -0.06469891f, 
    0.09410940f, 0.00689447f, 0.10701623f, -0.02767073f, 0.14745973f, -0.06674404f, -0.09045106f, -0.01245612f, 
    0.05005219f, 0.02288984f, -0.09407262f, 0.00637825f, -0.10104539f, 0.05934905f, 0.03731802f, 0.04037997f, 
    0.04096036f, 0.54649347f, 0.02071651f, -0.00065601f, -0.07472296f, 0.04515564f, 0.06013798f, -0.07450113f, 
    -0.05152583f, 0.01766658f, -0.04849115f, -0.01504840f, 0.08815911f, 0.00564060f, -0.00640313f, 0.06885898f, 
    0.07808156f, -0.06509038f, 0.11224876f, -0.09985643f, 0.00331861f, 0.01116888f, -0.11123621f, -0.08429754f, 
    0.07306634f, -0.14860862f, -0.09277558f, 0.12257621f, 0.09473281f, -0.07819682f, -0.06699635f, 0.06747732f, 
    0.06632353f, 0.09420597f, -0.03228785f, -0.10029729f, -0.42949626f, 0.17189816f, 0.01602926f, 0.13648668f, 
    0.06315157f, -0.02012823f, 0.02328379f, -0.08447970f, -0.01878565f, -0.04335350f, -0.04894261f, 0.00273171f, 
    0.05631854f, 0.02081503f, 0.05187876f, -0.15466687f, 0.13047718f, -0.15060990f, -0.07543530f, 0.24028251f, 
    0.17685540f, -0.13975126f, 0.01064195f, -0.03422912f, -0.25215089f, -0.05830013f, 0.10750838f, 0.10339155f, 
    0.12810622f, -0.04125037f, -0.01697825f, 0.00356768f, 0.07891861f, -0.00647132f, -0.02946531f, -0.05222516f, 
    -0.30951071f, 0.09155048f, 0.02754371f, 0.07410689f, 0.15480578f, -0.15204328f, -0.00790619f, -0.07136197f, 
    -0.07231790f, 0.01576876f, -0.00487426f, 0.09904218f, -0.21470335f, 0.05960270f, 0.00389169f, 0.07099961f, 
    0.14514615f, -0.11769602f, -0.08810673f, -0.03253991f, -0.10813873f, 0.08523251f, 0.12852915f, 0.11374798f, 
    0.03263419f, 0.10793761f, 0.03255428f, 0.17453246f, 0.11586306f, -0.02445382f, -0.05220429f, 0.11479355f, 
    -0.01559476f, 0.05046464f, -0.06770992f, 0.02969684f, -0.00000874f, 0.06199390f, -0.03141637f, 0.18207148f, 
    -0.02728423f, -0.05081797f, -0.03030263f, -0.03232333f, 0.01939281f, -0.02280219f, 0.00635948f, -0.07330894f, 
    -0.18651560f, 0.36179519f, 0.03346873f, 0.03881912f, 0.03307446f, -0.02085723f, -0.02189451f, -0.06948417f, 
    -0.04143379f, -0.08373887f, -0.07455584f, 0.08035122f, -0.32714453f, -0.24422845f, 0.16998690f, 0.12325220f, 
    -0.11229303f, 0.03061290f, -0.08808462f, 0.01476348f, 0.02661355f, -0.05191441f, 0.05496760f, 0.07364865f, 
    0.57700032f, -0.11887670f, 0.13871953f, -0.26082274f, 0.00852357f, 0.08012272f, 0.01818999f, -0.09937461f, 
    0.08864331f, 0.04862236f, 0.05994010f, 0.17317811f, 0.31755918f, 0.05427480f, 0.03786223f, 0.17340188f, 
    0.08165237f, 0.03768364f, -0.09652423f, -0.04928438f, -0.05858489f, 0.00317667f, 0.02361111f, 0.00867718f, 
    0.15200925f, -0.10510623f, 0.02516213f, 0.01557286f, -0.00244989f, -0.03290809f, 0.01629506f, 0.00786634f, 
    0.01914106f, 0.04094561f, 0.03946511f, -0.00617362f, 0.00858722f, -0.02571924f, 0.22443877f, 0.24429348f, 
    0.17052813f, -0.02812170f, -0.05403598f, -0.08793619f, -0.02242090f, 0.11277840f, -0.14970507f, 0.09656008f, 
    0.21060374f, 0.09003867f, 0.11916815f, -0.06049109f, -0.09153949f, 0.05811424f, 0.01760475f, -0.04218350f, 
    0.09985936f, -0.10557672f, 0.05248181f, -0.00202147f, -0.07253358f, -0.12013973f, -0.18951537f, 0.00586988f, 
    -0.14210935f, 0.10653158f, -0.15981734f, 0.01935376f, -0.03324206f, -0.12944826f, 0.05111063f, -0.02666045f, 
    0.04028646f, 0.00525853f, -0.05887738f, -0.04352024f, -0.00065411f, 0.04724930f, 0.03069724f, 0.15890419f, 
    -0.00052764f, 0.05074462f, 0.08348242f, -0.03930602f, 0.02386874f, 0.19256686f, 0.01315498f, 0.07426535f, 
    -0.00657597f, 0.08208397f, 0.02038980f, 0.00907744f, 0.06023488f, -0.00534024f, -0.02226340f, 0.04687915f, 
    -0.03559430f, 0.01173066f, 0.02025380f, 0.04511456f, -0.01990494f, 0.02069841f, -0.04571235f, 0.02854095f, 
    -0.05252508f, -0.02090232f, 0.02198914f, 0.03411863f, -0.02073066f, 0.04686921f, -0.00407746f, -0.02824218f, 
    -0.04292500f, 0.02927319f, 0.02256676f, -0.04585345f, 0.04523128f, 0.01814266f, -0.03693033f, 0.02207448f, 
    -0.00162955f, -0.00966705f, 0.04475374f, 0.03557670f, 0.00305657f, 0.01887955f, -0.01313847f, 0.04474747f, 
    -0.03286345f, 0.03222543f, -0.03944082f, -0.04407220f, 0.00217763f, 0.03143249f, -0.01614076f, -0.03524562f, 
    0.04189715f, -0.02522025f, -0.00011466f, -0.00646154f, -0.03258254f, -0.03224627f, -0.04680915f, 0.03911484f, 
    -0.01898739f, 0.02733048f, 0.01405599f, -0.04873876f, -0.01240968f, 0.00951512f, 0.02841804f, -0.02977310f, 
    -0.02769908f, -0.02485584f, 0.00183945f, -0.02451899f, 0.03194089f, 0.03511466f, -0.01176762f, -0.03394712f, 
    -0.00422829f, -0.01679694f, -0.04389312f, -0.02447347f, 0.00032910f, -0.01187100f, -0.05280943f, 0.03755599f, 
    0.01807071f, 0.05006620f, -0.01362672f, 0.00398126f, -0.01312190f, -0.01216229f, -0.02823348f, -0.02548712f, 
    0.01013625f, -0.02796518f, 0.03413117f, -0.03658372f, 0.02961279f, 0.00546109f, -0.01119184f, 0.00064740f, 
    0.00039637f, 0.02911138f, -0.04181234f, 0.02753239f, 0.02053097f, 0.00462078f, -0.02958806f, -0.01742542f, 
    0.03985184f, 0.02185100f, -0.02806386f, 0.03210379f, -0.02929211f, -0.03993698f, 0.03033810f, 0.00381122f, 
    -0.03675062f, 0.03787404f, -0.03083996f, -0.01728236f, 0.03807728f, -0.03648448f, -0.01736280f, 0.00065258f, 
    0.01433038f, -0.04569217f, -0.05817512f, 0.03180461f, 0.00895901f, -0.04311090f, -0.03877347f, -0.03033409f, 
    0.03110691f, -0.03982129f, 0.00831439f, 0.01040979f, 0.02047525f, 0.04974393f, 0.03300420f, 0.04119083f, 
    -0.05153123f, -0.05337474f, 0.00215091f, 0.02074999f, -0.03631773f, 0.00930517f, -0.04244993f, -0.01973213f, 
    0.03368463f, 0.03696461f, -0.00727858f, 0.01991164f, 0.03366648f, 0.02420642f, 0.01910699f, -0.03471382f, 
    -0.01085676f, -0.04053536f, -0.02392278f, 0.01363456f, 0.04564561f, -0.04586516f, -0.03026939f, 0.00532293f, 
    -0.01459186f, 0.03675794f, 0.01218835f, 0.04170283f, -0.03929643f, -0.04370000f, -0.00180758f, 0.04934491f, 
    -0.01184887f, -0.02135200f, 0.03748793f, 0.01123569f, -0.01297787f, 0.00800630f, -0.05582274f, -0.01320699f, 
    -0.05197457f, 0.02975854f, -0.00323673f, 0.00041126f, 0.03163659f, -0.05289182f, -0.02414549f, 0.03065299f, 
    -0.00408813f, -0.04222731f, -0.02934705f, 0.02822718f, 0.00867791f, -0.03972942f, -0.01868079f, -0.02322956f, 
    -0.03935134f, -0.00440893f, -0.03783559f, -0.02081255f, 0.03994057f, 0.01038436f, 0.04136634f, -0.00573240f, 
    -0.05099716f, -0.01134695f, 0.00728304f, -0.02120978f, -0.01235175f, 0.03128426f, 0.01400610f, -0.01521587f, 
    -0.02748569f, -0.01150080f, 0.02804827f, -0.00990261f, 0.01375556f, -0.00762457f, 0.00903322f, -0.02166667f, 
    -0.04615946f, -0.00370541f, -0.03670426f, 0.02625030f, -0.04722594f, -0.03860309f, -0.02611209f, -0.04744535f, 
    0.02320269f, 0.01190320f, -0.01029402f, -0.01321320f, 0.03150051f, 0.03746454f, -0.02771696f, -0.00775801f, 
    0.00287161f, 0.00949847f, -0.01696892f, -0.03503318f, 0.00958788f, 0.03640769f, -0.05080501f, -0.02268777f, 
    -0.04034975f, -0.01378748f, -0.00705182f, -0.02852971f, -0.03127657f, 0.03077083f, 0.02294056f, -0.00364047f, 
    0.03119924f, -0.03332137f, -0.02719008f, 0.04042386f, -0.04764157f, 0.02996009f, -0.01690822f, -0.03561834f, 
    -0.01550105f, -0.05611392f, 0.01231414f, 0.02098113f, 0.01622732f, -0.03299127f, 0.01610311f, 0.04090815f, 
    -0.05096379f, 0.02307671f, 0.01673107f, -0.02627360f, -0.04550513f, -0.04665340f, 0.00965150f, -0.00327646f, 
    -0.04294218f, -0.04127586f, 0.02907244f, 0.00949808f, -0.03297602f, -0.01071520f, -0.05074666f, 0.02459844f, 
    -0.05234048f, -0.03223376f, -0.03398545f, -0.03681435f, 0.02316585f, -0.05693992f, 0.02501838f, -0.01526658f, 
    -0.03372189f, 0.03465272f, -0.04046243f, -0.04800590f, 0.04382359f, -0.05188894f, -0.05091042f, 0.00356313f, 
    0.00280813f, 0.03913567f, -0.00658175f, -0.02234756f, 0.01024350f, 0.00420763f, 0.00898260f, 0.01389906f, 
    0.02913641f, 0.02451761f, -0.02088706f, -0.01453528f, 0.02246549f, 0.04058283f, 0.02514542f, 0.00270198f, 
    0.00871960f, -0.04760355f, 0.00952323f, 0.01497297f, -0.00585497f, -0.02552340f, 0.04539152f, 0.01519338f, 
    -0.04285425f, 0.01724740f, 0.03254399f, 0.00992252f, 0.04297860f, -0.04317321f, 0.04820117f, 0.00657830f, 
    -0.01486297f, 0.00569753f, 0.00989601f, -0.04001999f, 0.03798790f, -0.05399689f, 0.00981594f, 0.03302715f, 
    -0.04756493f, 0.04031106f, 0.02032668f, -0.00486256f, 0.04012921f, -0.03556414f, 0.01371472f, 0.03477889f, 
    -0.01260738f, 0.01934399f, 0.02877139f, 0.00676106f, -0.02424844f, -0.00162602f, 0.04386147f, 0.01113301f, 
    -0.04043868f, 0.00709751f, -0.04128808f, -0.01697882f, -0.02746134f, -0.05112972f, -0.00264182f, -0.00971485f, 
    -0.04415029f, -0.03687651f, -0.01643798f, -0.04945389f, -0.04254348f, -0.05659440f, -0.01974108f, -0.02553761f, 
    0.03227431f, -0.02638529f, -0.04045743f, 0.00455760f, 0.00117628f, -0.01382958f, 0.02783119f, -0.04073182f, 
    -0.00093331f, -0.05061407f, 0.00305397f, 0.00402018f, 0.02367125f, -0.05274540f, 0.02437426f, 0.03276119f, 
    -0.01541137f, -0.02465140f, 0.04492949f, -0.02582989f, 0.00962681f, 0.04392065f, -0.02559770f, 0.01231593f, 
    -0.03870659f, 0.02640084f, 0.00870905f, -0.03359308f, 0.04571447f, 0.04173810f, 0.00695101f, -0.02467329f, 
    -0.01558740f, 0.02251139f, 0.03944330f, -0.05432759f, -0.00796804f, -0.04221603f, -0.01416449f, -0.02583762f, 
    -0.02583349f, -0.02063236f, -0.00675875f, 0.00560256f, 0.04852978f, 0.04936732f, 0.03476624f, 0.03583055f, 
    0.03631802f, -0.02419543f, 0.03689969f, 0.00158414f, -0.04367542f, 0.01085428f, -0.02414510f, 0.04364683f, 
    0.02655599f, -0.00300595f, 0.02799877f, -0.04344727f, -0.02362165f, -0.03924437f, 0.02638456f, -0.02886408f, 
    0.04004312f, 0.00514979f, -0.04830610f, 0.01147286f, 0.00360908f, 0.03946580f, -0.04763642f, -0.04906303f, 
    0.01724537f, -0.04118019f, 0.00115082f, 0.00898265f, -0.01286021f, -0.03504744f, -0.00821574f, -0.00418484f, 
    0.02538005f, 0.03224086f, -0.04280837f, -0.04519558f, 0.02192209f, 0.02599848f, -0.02337227f, -0.00260657f, 
    0.02050663f, 0.03358506f, -0.01755406f, 0.02401341f, -0.02434354f, -0.01491755f, -0.00951846f, 0.00325635f, 
    0.03304116f, -0.04988040f, -0.05083572f, -0.00369249f, -0.05356509f, -0.06394902f, -0.03255165f, -0.00336789f, 
    -0.00024386f, 0.03713233f, 0.02746723f, -0.01299950f, 0.03173275f, 0.04209618f, -0.00473403f, -0.04540533f, 
    0.00187120f, 0.03700278f, 0.02211676f, -0.01541423f, 0.01011272f, -0.01162623f, 0.01469667f, 0.00636421f, 
    -0.00626866f, -0.03691694f, 0.02356811f, -0.01372083f, 0.00869741f, -0.02236312f, -0.05982579f, 0.02523889f, 
    -0.03514629f, -0.02467587f, -0.01488025f, 0.02416315f, -0.06108437f, -0.04700151f, 0.03560266f, 0.01121636f, 
    -0.02300832f, 0.01604152f, -0.00453382f, -0.02333907f, 0.03836061f, 0.02100424f, 0.01591052f, -0.01652098f, 
    0.03023102f, 0.03127644f, 0.05508667f, -0.03720706f, 0.02896474f, 0.01903109f, 0.02941113f, 0.01524050f, 
    0.00135130f, 0.00322421f, -0.01494830f, 0.01703841f, 0.03752470f, -0.05024905f, 0.00458226f, -0.00401149f, 
    -0.00410752f, -0.01544684f, 0.01775865f, 0.04086315f, 0.01775933f, -0.02170210f, -0.00951263f, 0.03957696f, 
    0.00011793f, -0.03456817f, -0.00491886f, -0.01533760f, -0.04991255f, 0.01185105f, -0.03413448f, -0.01416951f, 
    0.02922108f, 0.01292724f, -0.01524241f, -0.03818113f, -0.00919789f, 0.02178492f, -0.02650368f, 0.04829175f, 
    -0.02542132f, -0.06120141f, 0.00862850f, 0.01569854f, 0.00926460f, -0.03215157f, -0.00241144f, -0.04573603f, 
    -0.05380781f, -0.03061124f, 0.03347497f, -0.00224883f, -0.00174998f, -0.02686983f, -0.03690601f, -0.04491798f, 
    -0.01929754f, -0.02449307f, 0.02640875f, -0.01247475f, 0.00815169f, -0.01570361f, -0.01702341f, 0.02165125f, 
    0.03637639f, -0.02103891f, 0.02652289f, -0.00416365f, -0.01424610f, -0.00428393f, -0.00028324f, 0.01197795f, 
    -0.06217784f, -0.05514321f, 0.03893738f, 0.03879101f, 0.02068425f, 0.03308285f, 0.00854949f, -0.02472536f, 
    -0.00453789f, -0.04303775f, -0.05587972f, 0.03765607f, -0.02211318f, -0.05645501f, 0.01049229f, 0.01568623f, 
    -0.04740562f, -0.03848986f, 0.00901675f, 0.02823681f, -0.01964709f, -0.01244651f, -0.03091643f, 0.04892280f, 
    0.02594443f, 0.03823078f, 0.00675398f, -0.00866934f, 0.02523178f, -0.05031469f, 0.02331120f, -0.04326068f, 
    0.02970562f, -0.02707726f, 0.03831965f, -0.02155319f, -0.06013692f, 0.02992427f, -0.00260511f, -0.02464199f, 
    0.02449584f, -0.02106277f, -0.02094140f, -0.03072346f, -0.03964706f, -0.02110766f, 0.02641803f, 0.00744629f, 
    -0.00041667f, -0.04066176f, -0.00034887f, 0.00353829f, -0.06089187f, -0.02011596f, 0.02088959f, -0.03368915f, 
    -0.05299264f, -0.04830983f, -0.02373323f, 0.02170598f, 0.04256307f, 0.02346830f, -0.00027758f, 0.01744948f, 
    0.01405979f, -0.04644876f, -0.05565974f, -0.03360851f, -0.04618062f, -0.00697963f, -0.05235916f, 0.00760467f, 
    -0.05107844f, -0.03987631f, 0.01663508f, -0.00785816f, 0.01641798f, 0.01756035f, -0.02920253f, 0.03720437f, 
    0.02576808f, -0.02160981f, 0.03497712f, -0.03487654f, -0.00591208f, 0.02186925f, -0.02293079f, 0.02931195f, 
    -0.03060316f, -0.04284030f, -0.05461783f, -0.04303057f, -0.02356691f, 0.02582118f, 0.03458768f, -0.00936092f, 
    0.03442069f, 0.01264063f, 0.05064971f, 0.00203025f, 0.02029468f, -0.03498837f, -0.05430100f, 0.01679929f, 
    0.02989626f, -0.00496821f, -0.02263530f, -0.01955993f, -0.02256028f, -0.01749758f, -0.06504376f, 0.00177866f, 
    -0.02647636f, -0.03488260f, 0.01766760f, 0.02713418f, 0.03617495f, -0.02964870f, -0.04296052f, -0.04170287f, 
    -0.03712510f, -0.02433067f, -0.01966555f, 0.00355008f, 0.04573776f, -0.04023406f, -0.00887673f, -0.03969032f, 
    -0.03683626f, -0.00713619f, 0.03651749f, -0.03778659f, -0.05978144f, -0.05727986f, 0.00170595f, 0.02952649f, 
    0.00565335f, 0.03191073f, 0.01465061f, -0.04154778f, 0.02569716f, 0.02882174f, 0.02283174f, -0.00398579f, 
    0.00828800f, -0.00127478f, -0.01940208f, 0.04659966f, -0.02959859f, -0.01406382f, 0.01527905f, -0.05134613f, 
    0.03815373f, 0.00283105f, 0.00346684f, 0.03811769f, 0.03421851f, 0.03280124f, 0.04895332f, 0.01320431f, 
    0.00634504f, -0.03513156f, -0.03749672f, 0.02601077f, 0.03689191f, -0.01266154f, -0.00826795f, -0.02575477f, 
    -0.00892797f, -0.01553997f, 0.02390823f, 0.02681543f, -0.03127253f, 0.03810684f, -0.03350452f, -0.02120762f, 
    0.00339318f, -0.02872037f, 0.00658201f, 0.02706371f, -0.03290225f, -0.01831119f, -0.01021357f, -0.02880982f, 
    -0.03948988f, -0.02051955f, -0.02706775f, -0.01224915f, -0.05454253f, -0.02354350f, -0.02277778f, 0.04620895f, 
    -0.05250439f, 0.00269671f, -0.00323911f, -0.00879751f, 0.01542058f, -0.01236434f, 0.01594053f, -0.03354682f, 
    -0.01546604f, 0.00452807f, -0.05611748f, -0.01859087f, -0.02469886f, 0.02675664f, -0.05095874f, 0.03661664f, 
    0.02847921f, 0.04632837f, 0.03418226f, 0.02097819f, -0.02374605f, 0.00696884f, -0.00742615f, 0.00210816f, 
    -0.04987735f, -0.01215233f, -0.04495200f, -0.04515151f, -0.02424006f, -0.02456969f, 0.02457424f, -0.01687566f, 
    -0.01952203f, -0.02113823f, 0.02555652f, -0.00493379f, -0.02334004f, -0.03593510f, 0.02898523f, -0.04621544f, 
    -0.01511141f, -0.01886952f, 0.03863515f, 0.03439262f, 0.04331074f, -0.03200914f, 0.04164157f, -0.00224812f, 
    0.03655042f, -0.03252787f, -0.00841866f, -0.04319542f, 0.00405010f, -0.05126285f, 0.03821436f, -0.02540535f, 
    -0.04247547f, 0.04431295f, -0.04958223f, -0.01605581f, -0.01971531f, -0.05692717f, -0.00080125f, 0.00827123f, 
    0.01298345f, -0.00711225f, -0.00911080f, 0.02657896f, -0.05649390f, -0.03647442f, 0.00648216f, -0.00850182f, 
    0.00810158f, -0.04111743f, 0.02482720f, 0.03680360f, -0.02032109f, 0.03281014f, 0.00227480f, 0.04369341f, 
    -0.03560608f, 0.01498750f, 0.01169441f, 0.03320754f, -0.00610495f, 0.00318027f, 0.00073037f, -0.01612980f, 
    -0.04618571f, 0.00567122f, -0.01937536f, -0.04356799f, -0.00929420f, 0.02169140f, -0.04385512f, 0.00595640f, 
    -0.04930366f, -0.00977446f, -0.01267731f, -0.02565155f, -0.05176010f, 0.04374288f, 0.00132447f, -0.01209227f, 
    -0.04791781f, -0.00485241f, -0.01006226f, -0.04967881f, -0.00218465f, -0.02143521f, 0.01383187f, 0.01433115f, 
    0.00823324f, 0.02080370f, 0.02607441f, 0.03709173f, -0.05197156f, 0.01982515f, -0.03216187f, 0.01391232f, 
    0.01926778f, 0.01613404f, -0.04986241f, 0.02072353f, 0.03374297f, 0.00817669f, -0.00309956f, 0.00982802f, 
    0.04050445f, 0.04188099f, -0.05524253f, -0.03244082f, -0.00528403f, -0.04320608f, 0.03773103f, -0.03261858f, 
    0.01783713f, -0.03110735f, -0.03281009f, -0.00137874f, 0.02322770f, -0.05252197f, 0.02846088f, -0.04742672f, 
    0.01783152f, -0.03794958f, -0.05000576f, -0.05166529f, -0.00532365f, -0.02792891f, -0.00061852f, -0.03218210f, 
    -0.01122998f, 0.02827826f, 0.04204309f, 0.01917529f, -0.02258074f, -0.04675542f, -0.04606166f, -0.04278409f, 
    -0.04821012f, -0.04680123f, -0.04826406f, -0.03133645f, -0.02327826f, -0.00055901f, 0.01449525f, 0.00076172f, 
    -0.00196934f, 0.02492703f, -0.01695540f, 0.00458585f, 0.04102337f, 0.04064383f, 0.01677833f, 0.02675376f, 
    -0.03056210f, -0.00993076f, -0.01144088f, -0.05091470f, 0.04389579f, -0.03773490f, 0.04321263f, -0.02243051f, 
    0.03928149f, -0.02043623f, -0.04234925f, -0.05127611f, -0.02498804f, -0.03411528f, -0.00428474f, -0.05078480f, 
    -0.01572504f, -0.01092246f, -0.03998423f, -0.02943683f, 0.01450888f, -0.02555462f, -0.01540104f, -0.05028183f, 
    -0.00969354f, 0.03852080f, -0.04102001f, -0.03069957f, 0.03927466f, 0.02537566f, 0.02250819f, -0.05396869f, 
    -0.04760165f, -0.02701437f, 0.02059596f, -0.04886998f, -0.01073991f, 0.00153941f, -0.00917676f, 0.03066186f, 
    0.04205568f, 0.02157267f, -0.01084763f, 0.04421919f, -0.05414944f, -0.03899582f, -0.01038200f, 0.04354163f, 
    -0.03180252f, -0.03143726f, -0.05512499f, 0.03133138f, -0.01191319f, -0.00178300f, -0.01118750f, 0.01745405f, 
    0.01415763f, -0.03827100f, 0.04333356f, 0.02980479f, 0.02883367f, -0.04391671f, 0.00213864f, 0.02441660f, 
    -0.03078767f, -0.02072689f, 0.00128441f, -0.03657998f, -0.02504475f, 0.02695631f, -0.00181220f, 0.01950913f, 
    0.00890857f, -0.05162398f, -0.03332141f, -0.04822360f, 0.03514080f, 0.02769962f, 0.01861991f, -0.03150738f, 
    0.02532038f, -0.04053425f, 0.02543938f, -0.00935765f, -0.04947993f, -0.01063124f, 0.00600488f, -0.02591675f, 
    0.00828421f, 0.03524721f, 0.02811185f, -0.02588907f, 0.03225350f, 0.01539402f, -0.04387467f, 0.02263930f, 
    -0.03118932f, 0.00326816f, 0.00094400f, 0.01335517f, 0.04320426f, 0.00498117f, -0.01208269f, 0.00891040f, 
    0.02247926f, -0.04326877f, -0.04467234f, -0.01496865f, -0.01210620f, -0.02061843f, -0.03463826f, -0.00989250f, 
    -0.03578246f, 0.04232781f, 0.04055933f, 0.01661769f, -0.03717006f, 0.02081307f, -0.05427979f, -0.02038352f, 
    -0.03487254f, -0.05610722f, 0.00133744f, 0.02228319f, -0.04281351f, -0.02253458f, 0.00797309f, 0.00305737f, 
    -0.05286678f, 0.00529559f, 0.00746306f, 0.04466683f, 0.03380390f, -0.05022029f, -0.05300112f, -0.02985526f, 
    -0.04631305f, -0.03906943f, -0.04287850f, -0.00425070f, 0.00711712f, 0.03003079f, -0.00380718f, -0.04396553f, 
    -0.03407948f, -0.04199441f, 0.00039334f, 0.03760107f, 0.01767644f, -0.04878519f, -0.03731622f, 0.01064507f, 
    0.01548525f, 0.04109041f, 0.02173698f, 0.00816733f, 0.01348757f, -0.02281241f, -0.00473928f, -0.00017307f, 
    -0.03260546f, -0.00166857f, 0.04233300f, -0.04074887f, 0.02485690f, -0.04490447f, -0.00288048f, 0.01794159f, 
    0.00228077f, -0.04062245f, -0.04201073f, -0.02913940f, -0.04727775f, 0.03356133f, 0.03290753f, -0.05341247f, 
    -0.04926634f, -0.05045785f, -0.00413068f, -0.05642556f, -0.03862639f, -0.04866907f, 0.03367059f, -0.04729220f, 
    -0.05445696f, 0.02650205f, 0.01156474f, 0.02985035f, 0.00858228f, 0.02874457f, 0.00821927f, 0.03267609f, 
    0.00134768f, 0.03496642f, -0.04061853f, 0.00140820f, 0.00958257f, -0.05263984f, 0.03857512f, -0.01494496f, 
    0.04163667f, 0.01505875f, -0.02844605f, -0.04935718f, 0.01075381f, 0.04234454f, 0.01779979f, -0.04342077f, 
    0.01485316f, 0.03126716f, 0.01151645f, 0.02604364f, 0.03191629f, -0.05071575f, -0.02362411f, -0.04530593f, 
    -0.00265219f, 0.02180762f, 0.03045723f, 0.05641778f, 0.03065472f, -0.04579117f, 0.02563927f, -0.04998673f, 
    -0.00026785f, -0.02342648f, -0.02661267f, 0.01908185f, -0.04790884f, -0.00096923f, -0.00196588f, 0.03185543f, 
    0.02690380f, 0.00692277f, -0.04940921f, 0.00091984f, 0.00270608f, -0.03080981f, -0.00247651f, 0.01806254f, 
    -0.04976078f, 0.00852739f, -0.00119281f, 0.03186096f, 0.03069773f, 0.02611160f, -0.00195742f, 0.01592811f, 
    0.02752695f, -0.00941643f, 0.03533238f, -0.00057810f, -0.01892385f, -0.01168466f, 0.02704462f, -0.00819914f, 
    -0.03247777f, 0.01784561f, 0.02489152f, -0.00857315f, 0.01394263f, -0.01033912f, 0.01662333f, -0.06546537f, 
    -0.01165050f, -0.04567975f, -0.04393701f, 0.01213771f, -0.00370339f, -0.03857992f, -0.02020232f, 0.00119428f, 
    0.01331582f, 0.02589446f, -0.03859640f, -0.02701420f, -0.01289779f, 0.02038670f, 0.02858599f, 0.04103060f, 
    -0.00969379f, 0.03491078f, -0.02571887f, -0.00891318f, -0.00372772f, -0.03525016f, -0.00553560f, 0.02221700f, 
    -0.05841536f, 0.02124205f, -0.04754617f, 0.04300776f, -0.04431357f, -0.04996167f, 0.01142280f, 0.01326158f, 
    -0.01470540f, 0.02563608f, 0.01529080f, -0.01220982f, 0.00735633f, -0.04309692f, -0.03252984f, -0.04840349f, 
    0.02198317f, -0.03282995f, -0.04017971f, 0.03109496f, 0.00736527f, 0.01331226f, 0.03322539f, -0.05307487f, 
    -0.00945829f, -0.04595160f, -0.00563090f, -0.04085533f, 0.02207888f, -0.04782554f, 0.02938450f, 0.00086147f, 
    0.00690864f, 0.00105121f, 0.03558943f, -0.02301038f, 0.01029619f, -0.03488367f, -0.05425346f, -0.02938692f, 
    -0.04921556f, -0.05578686f, 0.02214104f, 0.03523992f, 0.01952052f, -0.01665884f, 0.02322016f, -0.03684460f, 
    0.03360470f, 0.01937673f, 0.02874106f, -0.05107275f, 0.03228665f, 0.02116696f, 0.01765073f, -0.03620143f, 
    -0.04625770f, 0.00943157f, -0.03989059f, -0.02775211f, -0.02842937f, 0.04303076f, 0.02508947f, 0.00022620f, 
    0.01123299f, -0.02931872f, -0.00424818f, -0.02939417f, -0.02993645f, -0.00585655f, -0.05919479f, -0.00531166f, 
    -0.04243756f, -0.03077361f, -0.02010098f, -0.04024497f, 0.00502841f, -0.03046839f, 0.03154484f, 0.02361274f, 
    0.03412249f, 0.01003793f, 0.01569325f, 0.02372940f, 0.04089262f, 0.02328814f, -0.01221220f, 0.03135088f, 
    0.00849599f, -0.06243253f, 0.01563325f, -0.04141793f, -0.03421938f, -0.03289999f, -0.05948530f, -0.05338554f, 
    -0.03299103f, -0.02688670f, -0.05426591f, -0.04164961f, 0.02170609f, -0.03891133f, 0.04773739f, -0.03062785f, 
    -0.04791874f, -0.02705239f, -0.04483447f, 0.02216612f, 0.03314781f, -0.00462055f, -0.02575365f, 0.03132388f, 
    -0.02259272f, -0.02550700f, -0.04377918f, -0.02497299f, -0.03409173f, -0.01836121f, 0.03472059f, 0.00166764f, 
    0.03137615f, -0.05301135f, -0.02748093f, -0.04639194f, -0.01354364f, 0.02477895f, 0.01843752f, -0.01706341f, 
    0.01639662f, -0.03560778f, -0.01914417f, 0.00414500f, 0.00051052f, 0.01788352f, -0.04754303f, 0.00935913f, 
    -0.02588900f, 0.05057070f, -0.04818325f, 0.01409089f, -0.05672473f, 0.00758824f, -0.03148492f, 0.00190326f, 
    -0.01439401f, 0.03184538f, -0.03881968f, -0.04766974f, 0.03827830f, 0.02364996f, -0.02528299f, -0.05009659f, 
    -0.02119531f, 0.02505959f, -0.02388064f, -0.06277692f, -0.00892242f, -0.04028419f, 0.01617737f, 0.02099394f, 
    0.00567660f, -0.04078896f, -0.00540508f, -0.06327122f, -0.02770115f, -0.04074950f, -0.02534150f, -0.04283040f, 
    -0.04201994f, 0.00244549f, -0.05885720f, -0.05150656f, 0.01518002f, -0.00891059f, 0.02741395f, -0.02736787f, 
    0.03383142f, 0.03441877f, 0.03024259f, 0.02976281f, -0.04286265f, -0.02470318f, -0.04432363f, -0.02666030f, 
    0.00241604f, -0.05258391f, -0.03036707f, 0.02364961f, -0.01743655f, 0.02424602f, -0.02437822f, 0.01562320f, 
    0.03298635f, -0.03597793f, -0.01542177f, 0.03113136f, -0.00555302f, -0.01592251f, 0.02940235f, 0.00949191f, 
    -0.01236177f, 0.01782580f, 0.02542055f, 0.01057903f, -0.04791302f, 0.03589480f, -0.01532077f, -0.03436050f, 
    -0.03131292f, 0.01105046f, -0.01556509f, -0.03708453f, 0.03077202f, -0.04616803f, 0.03816735f, -0.03661392f, 
    0.03576313f, 0.04190285f, -0.03838226f, 0.03377380f, 0.00931330f, 0.02600523f, 0.04678574f, 0.02302214f, 
    -0.00471954f, -0.03588622f, -0.04320712f, 0.01019749f, -0.01128676f, -0.03705382f, -0.01820524f, -0.02345659f, 
    0.01730696f, -0.00996384f, 0.03898141f, -0.03820256f, 0.03272732f, 0.03206997f, 0.02479898f, 0.01854676f, 
    -0.01242946f, -0.04256230f, 0.00621814f, -0.04048999f, -0.00493166f, -0.04614491f, 0.00523199f, 0.02406872f, 
    0.04477362f, 0.00814205f, -0.05894217f, -0.03572801f, 0.02331300f, 0.00608562f, -0.03809739f, -0.01867515f, 
    0.04421575f, 0.01763321f, 0.00591220f, 0.01454165f, -0.00145013f, -0.05322067f, -0.05440394f, -0.02547908f, 
    0.03467980f, -0.05015047f, -0.01295874f, -0.00484185f, -0.02345288f, -0.05673874f, 0.02601191f, 0.01709927f, 
    0.03660359f, -0.02805922f, 0.02280647f, -0.02294067f, -0.05626720f, 0.03085859f, 0.00566207f, -0.00516691f, 
    0.01422206f, 0.00507131f, 0.00558706f, -0.02534950f, -0.02011633f, 0.02431501f, -0.01340373f, -0.01902216f, 
    -0.00796064f, 0.02307016f, -0.00691091f, 0.02150368f, -0.00936549f, 0.03173897f, -0.00461815f, -0.02621279f, 
    0.01782409f, 0.02178838f, 0.01588499f, -0.03322875f, -0.04247022f, 0.03135343f, -0.05499515f, -0.05135778f, 
    -0.03770521f, -0.01448534f, -0.01214332f, -0.01730795f, 0.01334435f, -0.05576397f, -0.04357894f, -0.05667049f, 
    -0.06018420f, -0.06075715f, -0.01383384f, -0.04480743f, -0.05095012f, 0.02638386f, -0.01279816f, 0.00918611f, 
    0.02576246f, 0.03500417f, -0.02800546f, 0.01686557f, 0.00326621f, 0.03089094f, 0.04134335f, -0.02735114f, 
    -0.05579695f, 0.02056739f, -0.05812897f, -0.01019571f, 0.00866081f, 0.01528073f, -0.05008197f, 0.03311082f, 
    0.01247122f, -0.01759892f, -0.03920008f, 0.00465309f, 0.01404344f, -0.00722437f, 0.03904249f, 0.00703774f, 
    -0.04944841f, -0.04911014f, -0.02852374f, -0.03840357f, 0.01658926f, -0.01800354f, 0.00010282f, -0.00773013f, 
    0.02000404f, 0.00725653f, -0.00798013f, -0.05117773f, 0.00841170f, -0.01527151f, -0.04448609f, -0.01776875f, 
    0.02314490f, -0.05131475f, -0.00533653f, -0.02839571f, -0.02325779f, 0.03255195f, -0.01841377f, -0.00300207f, 
    0.00035684f, -0.01915726f, -0.00592408f, -0.04071466f, 0.02556754f, -0.05001058f, -0.03271613f, -0.01990895f, 
    -0.03359102f, -0.00264096f, -0.02552268f, -0.05940556f, -0.05100144f, -0.05217396f, -0.05192663f, 0.02454008f, 
    -0.03946514f, -0.00575998f, 0.02901164f, -0.04442851f, -0.00909274f, 0.02564972f, 0.02925262f, -0.01457055f, 
    0.01199226f, 0.02285463f, 0.01566237f, -0.03808012f, 0.02780803f, 0.01820443f, 0.02497982f, -0.04917484f, 
    0.03875414f, -0.02136851f, -0.03912387f, 0.00176378f, -0.03251075f, -0.04872552f, -0.00184373f, -0.04654154f, 
    0.02815376f, 0.00422248f, 0.01382124f, -0.00725607f, 0.01349089f, -0.05611680f, -0.05614382f, -0.01486048f, 
    -0.04026565f, 0.01319488f, 0.03341473f, -0.04320351f, 0.02530311f, 0.03282835f, -0.04261604f, -0.03119327f, 
    0.01933022f, -0.05616533f, -0.00745999f, 0.02433920f, -0.02645375f, -0.02143778f, 0.01348832f, 0.02565630f, 
    -0.00664044f, 0.01915941f, -0.02195062f, -0.03158935f, 0.01821064f, -0.04513345f, -0.02383173f, -0.04531113f, 
    -0.04333246f, 0.00465056f, -0.03934053f, -0.01973464f, -0.00635418f, 0.01026281f, 0.03013622f, -0.01752368f, 
    -0.02323879f, -0.04055307f, 0.03655371f, -0.02083139f, -0.05444857f, 0.03855887f, 0.03438613f, -0.04885524f, 
    -0.01642579f, -0.06192979f, 0.04732964f, 0.00195975f, -0.01675941f, -0.00639651f, 0.03960948f, 0.02705362f, 
    0.00850164f, 0.01214761f, -0.01420805f, 0.00832055f, -0.03464558f, -0.01638123f, -0.02038490f, -0.00941592f, 
    -0.03101000f, 0.01379746f, -0.01008242f, 0.03338324f, -0.05656333f, -0.04029667f, 0.03330597f, -0.05903715f, 
    -0.00985708f, -0.02209814f, -0.05234791f, 0.04030392f, -0.02231944f, -0.04550672f, 0.03935854f, 0.00144248f, 
    0.04180268f, 0.02857617f, 0.03955960f, -0.04620530f, -0.03599904f, -0.03819069f, -0.05911931f, -0.00216208f, 
    0.03596719f, -0.00971333f, 0.00521380f, 0.03400364f, 0.01452068f, -0.02724569f, -0.01600136f, 0.02098102f, 
    -0.01481615f, -0.00457188f, 0.02650173f, -0.00994971f, -0.00400739f, 0.02078964f, 0.03275559f, -0.01633018f, 
    -0.04815987f, 0.00219040f, 0.01971373f, 0.02185525f, -0.06247856f, -0.00335355f, 0.03909713f, -0.01820605f, 
    0.03903192f, -0.00405984f, -0.02842834f, 0.03876729f, -0.01053850f, 0.01138067f, -0.04541871f, 0.01718903f, 
    -0.01537807f, 0.00925242f, 0.02183160f, -0.00540039f, -0.00624474f, -0.02329716f, 0.01894010f, -0.01182909f, 
    0.01211277f, 0.01748611f, 0.03001182f, -0.01902650f, -0.01187760f, -0.05329856f, -0.01262603f, 0.01207362f, 
    -0.05547309f, -0.02113092f, 0.00589064f, -0.04697762f, -0.00765288f, 0.02778861f, -0.01077294f, -0.01034971f, 
    -0.02035496f, -0.00355380f, 0.00296772f, 0.01058445f, -0.05738775f, -0.03904200f, -0.01715954f, -0.00939001f, 
    -0.02792154f, -0.05478824f, -0.02554925f, -0.00576167f, 0.03545849f, -0.05419938f, -0.04052170f, 0.04768777f, 
    0.00501747f, -0.00222583f, -0.04654228f, -0.03244703f, -0.00827913f, 0.04315839f, -0.02436810f, 0.01046268f, 
    0.01045246f, 0.02614542f, -0.03343935f, 0.02453673f, 0.03145733f, -0.00152598f, -0.02287318f, -0.04838867f, 
    -0.01593451f, -0.02580216f, -0.00325446f, 0.01842001f, 0.01751710f, -0.01561367f, -0.01538981f, -0.00724417f, 
    -0.01987319f, -0.03396783f, -0.02385573f, -0.05174192f, 0.03139884f, -0.00585664f, -0.01703351f, -0.03541176f, 
    -0.04972686f, -0.01478990f, -0.03552877f, -0.02128879f, -0.00840643f, 0.00768336f, 0.01306389f, 0.00555592f, 
    0.01346918f, -0.03969871f, 0.02057530f, 0.01781486f, 0.02654137f, -0.05666255f, -0.02697373f, -0.06143164f, 
    0.00878706f, 0.02917222f, 0.02451600f, -0.04024992f, 0.00329102f, 0.03376104f, 0.01305687f, -0.02709129f, 
    0.03219954f, -0.05739341f, 0.03866358f, -0.03101636f, 0.03167344f, -0.00129904f, 0.03150208f, -0.04562554f, 
    0.03422729f, 0.03140635f, -0.01958438f, 0.02704888f, 0.03959414f, -0.02547226f, -0.02193565f, 0.02561329f, 
    0.01935692f, 0.00806562f, -0.05029414f, -0.01436019f, -0.03152097f, 0.01950388f, 0.02905994f, 0.03975086f, 
    -0.05065174f, 0.02577614f, 0.04205878f, -0.04046753f, 0.03611159f, -0.04390730f, 0.01032553f, -0.01843228f, 
    0.01088248f, -0.01978588f, 0.00135892f, -0.05294429f, -0.05680919f, 0.01551075f, -0.04746057f, -0.00567268f, 
    -0.03463584f, -0.02808855f, -0.04265604f, -0.03208881f, 0.02077423f, -0.02133249f, 0.03494687f, -0.04027763f, 
    -0.00019129f, 0.03837591f, 0.02067371f, -0.04765617f, 0.02846358f, 0.03562443f, 0.00594567f, -0.02109132f, 
    -0.00134070f, -0.01410575f, 0.01876397f, -0.04678131f, -0.02383967f, -0.03284947f, -0.02794999f, 0.01188117f, 
    0.13542408f, 0.09667534f, -0.10523308f, 0.11083645f, 0.11455321f, -0.07413940f, -0.02199959f, -0.00962393f, 
    0.03062717f, 0.00365502f, -0.00600026f, -0.02619046f, 0.38033459f, 0.03229074f, 0.08891561f, 0.04751710f, 
    0.06771361f, 0.00120728f, -0.12524025f, -0.16474754f, -0.03999754f, -0.01075329f, -0.01959572f, 0.07184841f, 
    -0.07928905f, 0.10938427f, 0.04471827f, 0.00361601f, 0.04650307f, 0.01701082f, 0.02905414f, 0.04179788f, 
    -0.03293728f, 0.03480679f, 0.08526771f, 0.00204459f, 0.40919873f, 0.13976187f, 0.01821451f, 0.05669288f, 
    0.12574133f, 0.02501295f, 0.00574966f, -0.15072039f, -0.08956720f, -0.10605406f, -0.03551105f, -0.12404255f, 
    -0.16496642f, 0.14492127f, 0.00149206f, 0.10414298f, -0.10508592f, 0.06747822f, 0.13043821f, 0.06389127f, 
    0.01853115f, 0.11910652f, -0.03100327f, 0.07276984f, 0.12426367f, 0.14622934f, 0.07248543f, 0.07465931f, 
    0.09135140f, 0.03751482f, -0.13248695f, 0.09697820f, -0.02805391f, 0.04540773f, -0.06928436f, 0.17182529f, 
    0.02761492f, -0.20318417f, -0.06919747f, 0.05470753f, -0.01161130f, 0.04629694f, -0.04222810f, 0.11266623f, 
    0.03100566f, -0.00823181f, -0.01183860f, 0.00901076f, 0.16117468f, 0.01599006f, 0.07963019f, 0.18357719f, 
    0.06117234f, -0.05367887f, -0.11404651f, -0.10724606f, 0.00998255f, 0.00729828f, 0.09351949f, 0.04778482f, 
    0.03821601f, -0.09176339f, 0.02621803f, -0.00946919f, -0.07654141f, -0.03840322f, 0.07166927f, -0.01749129f, 
    0.01949362f, -0.10151735f, -0.04244863f, 0.08018959f, -0.30868745f, 0.04575196f, 0.11478762f, -0.10760473f, 
    0.11674190f, 0.13365552f, -0.03988173f, -0.06266918f, 0.06798476f, -0.00270032f, 0.01008387f, -0.03140973f, 
    0.17107642f, 0.15057373f, -0.07584921f, -0.06101201f, 0.06637411f, 0.12854798f, -0.01458300f, -0.04821469f, 
    -0.03759055f, 0.03449322f, -0.00272548f, 0.00137039f, 0.10869716f, -0.20996121f, 0.08009104f, -0.01648707f, 
    0.07573143f, -0.02174775f, -0.08994852f, -0.08212408f, -0.09563452f, 0.01543315f, 0.15149985f, -0.02782185f, 
    -0.02458888f, 0.09714356f, 0.15775922f, 0.02943066f, 0.08743162f, 0.03473666f, -0.03062939f, -0.07278769f, 
    0.04441263f, 0.00288553f, 0.05176146f, -0.01618375f, 0.01080540f, 0.03935593f, -0.03008723f, 0.04562462f, 
    0.16145317f, 0.02589196f, 0.02408239f, -0.14505665f, 0.10426851f, -0.17052467f, -0.00630646f, 0.14246209f, 
    -0.10581938f, 0.02402386f, 0.05965343f, 0.03273344f, 0.02452776f, 0.05686860f, -0.01903347f, -0.08698186f, 
    -0.10144153f, 0.12828381f, 0.08079944f, 0.13221121f, 0.00118561f, 0.21212450f, 0.05009031f, -0.00396770f, 
    0.09044596f, 0.08157804f, 0.12535082f, -0.14580409f, 0.05871890f, 0.01211582f, -0.04685487f, -0.11866780f, 
    -0.51596451f, -0.11608228f, 0.19573385f, -0.33364254f, 0.01228246f, 0.00406290f, -0.07914203f, 0.10444776f, 
    0.13209753f, -0.09938494f, 0.03537367f, -0.01770407f, 0.04470138f, -0.16081017f, 0.00273387f, -0.12674084f, 
    0.12544641f, 0.00376419f, 0.06771282f, 0.05617194f, 0.09585214f, -0.03408524f, 0.00221801f, 0.06230415f, 
    -0.18218800f, -0.28871042f, -0.06761158f, -0.00975559f, 0.11238806f, 0.02345973f, 0.01778397f, -0.13906959f, 
    0.09780429f, -0.10581796f, -0.01830189f, 0.08921857f, -0.22856791f, -0.22331819f, 0.09957959f, 0.14820352f, 
    0.10583080f, -0.01435515f, -0.08993446f, 0.06354084f, 0.12458999f, 0.04162631f, 0.02237364f, 0.03973597f, 
    -0.17921720f, 0.00103996f, 0.03694044f, 0.17479210f, 0.06595346f, 0.00078113f, -0.03601813f, 0.08411413f, 
    0.15213898f, 0.08286756f, -0.05615297f, 0.06538044f, -0.00736172f, 0.08291478f, 0.03341640f, 0.12323559f, 
    0.07806816f, -0.13673057f, -0.03517257f, -0.07473846f, -0.11187521f, -0.09341002f, -0.00292171f, 0.09767692f, 
    0.25955978f, 0.13335332f, -0.11108451f, -0.07857019f, 0.04172339f, 0.11943024f, -0.01333076f, 0.08027446f, 
    -0.01097768f, -0.06785935f, 0.03655140f, -0.00802447f, 0.22316015f, -0.19967116f, -0.12065820f, 0.08019599f, 
    0.02401234f, 0.14139591f, -0.09709323f, -0.08890258f, -0.13020471f, -0.06018792f, 0.12204725f, 0.10995373f, 
    0.69352257f, 0.23909448f, -0.02442959f, 0.03728564f, 0.02820577f, -0.02516382f, 0.07051716f, -0.02374516f, 
    0.04887613f, -0.00157656f, 0.09470511f, 0.08355616f, -0.01330538f, -0.10136771f, 0.06294681f, 0.08136929f, 
    0.02837237f, 0.06304617f, -0.10142186f, -0.02891674f, -0.02240754f, 0.14168340f, 0.05475312f, 0.17551477f, 
    0.32125092f, -0.18334220f, -0.06428093f, -0.09339380f, 0.08929377f, 0.01253758f, -0.11000010f, -0.01399592f, 
    -0.07865140f, -0.12168532f, 0.05951000f, -0.00119202f, -0.09748979f, 0.16015483f, -0.19445138f, 0.13260296f, 
    -0.00552326f, -0.03493975f, -0.07905120f, 0.07088122f, 0.02885082f, -0.02456719f, -0.05809505f, -0.00244028f, 
    0.37517381f, 0.09530953f, 0.07611316f, -0.12167170f, -0.03420700f, -0.05353183f, 0.02874783f, 0.08863762f, 
    -0.02771707f, -0.04070998f, 0.06795303f, -0.09680109f, -0.31045315f, -0.19882280f, 0.06098710f, 0.05563063f, 
    -0.05153582f, 0.04262730f, -0.01516364f, -0.01431986f, 0.03215503f, -0.05302862f, 0.10235480f, 0.06115169f, 
    0.10449117f, 0.03690403f, 0.05084518f, -0.12606032f, 0.03732387f, 0.02507656f, -0.02202781f, 0.04690373f, 
    -0.01345170f, 0.12017836f, 0.14932963f, 0.00170790f, -0.15191819f, -0.12983859f, 0.00342113f, 0.14006113f, 
    0.05950929f, 0.02396052f, 0.03375813f, 0.18090083f, 0.10394434f, 0.11644184f, 0.02368103f, -0.00149432f, 
    0.12471151f, 0.15549774f, -0.07042915f, 0.01333345f, 0.16685906f, -0.12038545f, -0.07461318f, 0.06264488f, 
    0.06127452f, 0.01227215f, 0.04149215f, 0.02643711f, 0.40033740f, 0.11834226f, 0.10928094f, 0.02244426f, 
    0.06455984f, -0.02165928f, -0.14657596f, -0.09808592f, 0.09431265f, 0.13399693f, 0.06551906f, -0.06076394f, 
    0.11062267f, 0.11197463f, -0.10140012f, -0.04189170f, 0.06937233f, -0.08549458f, 0.06829681f, 0.06479968f, 
    -0.06658788f, 0.08321695f, 0.00350038f, 0.07873230f, 0.38219407f, 0.15465708f, 0.07693083f, 0.04472908f, 
    0.02014977f, 0.03525305f, -0.04125558f, 0.06499486f, 0.00229013f, -0.05525800f, 0.09235525f, -0.04174294f, 
    -0.27892366f, 0.10884059f, 0.13133797f, -0.01087834f, -0.05884490f, 0.02879858f, 0.05023986f, 0.11424354f, 
    -0.11471518f, 0.04609071f, -0.01120751f, -0.06850200f, -0.20275901f, 0.16132669f, 0.07041547f, 0.09540713f, 
    0.12978554f, 0.08067421f, -0.04347843f, 0.04731940f, 0.04128356f, -0.06260937f, 0.08399629f, 0.00025374f, 
    -0.53880316f, -0.02622401f, -0.07003904f, -0.16504975f, 0.11281668f, 0.03620762f, 0.02692493f, 0.01061891f, 
    -0.11290178f, 0.05525214f, 0.04370710f, -0.00629113f, 0.12622240f, 0.11525200f, 0.03266163f, 0.09269078f, 
    0.06615733f, -0.11176866f, -0.05969973f, -0.04246600f, 0.10447110f, 0.11809873f, 0.01144353f, -0.02594918f, 
    -0.03631684f, -0.12358566f, 0.01967255f, 0.00762782f, 0.00492627f, 0.05630392f, 0.07025736f, 0.10168950f, 
    -0.00794056f, -0.07374790f, -0.08720537f, 0.04958932f, -0.13720022f, -0.18051444f, -0.00194169f, -0.13547304f, 
    0.07352784f, 0.12908028f, -0.11203660f, -0.02796456f, -0.08203639f, -0.10977048f, 0.04022504f, -0.01075707f, 
    0.24146618f, 0.43854612f, 0.16112123f, -0.05025014f, 0.01233985f, 0.08246504f, -0.03083586f, 0.01342575f, 
    0.01268266f, -0.05974133f, 0.00543526f, 0.02806220f, -0.20711543f, -0.02310228f, 0.24760862f, 0.07113866f, 
    -0.07360294f, -0.03097446f, -0.06724813f, -0.15748166f, -0.02058592f, 0.09727219f, 0.17824003f, 0.05713226f, 
    0.11878528f, 0.11562921f, 0.11877303f, 0.03297862f, 0.11679021f, -0.05137655f, -0.00202416f, 0.00064541f, 
    -0.00909950f, -0.00186333f, -0.05006566f, -0.07772300f, 0.08799677f, 0.10964625f, -0.02384293f, 0.09629624f, 
    0.01410184f, 0.02336004f, 0.02213481f, -0.06095620f, 0.08241465f, 0.01869033f, 0.01672053f, 0.06761900f, 
    -0.11660887f, -0.04301713f, -0.10400416f, 0.11603340f, -0.05278030f, 0.07768647f, 0.00091620f, -0.00403070f, 
    -0.04112904f, 0.04562954f, 0.11230785f, 0.01966913f, -0.31340966f, 0.08105076f, 0.13988116f, -0.15848908f, 
    0.14775516f, 0.14301315f, -0.01225017f, -0.07982290f, 0.05061570f, -0.13126478f, 0.02223707f, 0.04043863f, 
    -0.00892458f, -0.14843312f, 0.09951825f, -0.24644797f, -0.01415762f, 0.05547673f, -0.15032279f, -0.13363048f, 
    -0.01266239f, -0.11434651f, 0.00944576f, 0.06586827f, 0.39384544f, -0.33930519f, 0.15615070f, 0.01700203f, 
    0.05710811f, 0.06227589f, 0.02222946f, 0.04041223f, -0.04850493f, 0.00408930f, 0.12259414f, 0.07841898f, 
    0.30254680f, -0.32073832f, 0.13978320f, -0.07024834f, 0.01543736f, 0.09752932f, 0.09960020f, -0.09344797f, 
    -0.01480272f, 0.07115652f, -0.13901064f, 0.06268056f, -0.33088338f, -0.19393237f, 0.11138915f, 0.05872302f, 
    -0.00392171f, 0.18104599f, -0.00273695f, 0.01110595f, 0.16265835f, -0.09698622f, -0.02830279f, 0.28765002f, 
    -0.39326727f, -0.07812610f, -0.12976494f, -0.03377338f, 0.00163416f, -0.03076033f, -0.06953477f, 0.02812808f, 
    0.12613736f, 0.08866094f, -0.04851491f, -0.03446885f, 0.21775444f, 0.10861889f, 0.12285370f, -0.01226088f, 
    0.18717085f, 0.01847406f, -0.07789660f, 0.02579367f, -0.08119635f, -0.02374543f, 0.04248081f, 0.01177638f, 
    -0.08490221f, 0.11990681f, -0.08546691f, 0.07840135f, 0.06811744f, 0.11741809f, 0.09588417f, 0.08479596f, 
    -0.03416425f, 0.06678934f, 0.04926456f, -0.01261619f, 0.06297123f, 0.04784769f, 0.09305985f, 0.11887353f, 
    -0.07951230f, -0.05665438f, -0.04723617f, -0.03225242f, 0.00080624f, 0.00899227f, 0.04783897f, 0.19742052f, 
    0.46589509f, 0.32824332f, 0.07390478f, 0.02432990f, -0.02036192f, 0.01975539f, 0.04529250f, -0.10709058f, 
    0.05046422f, 0.02040675f, 0.08057781f, 0.06190687f, -0.19686805f, -0.12262740f, -0.14363712f, 0.01428451f, 
    -0.03765233f, 0.04958306f, 0.02432922f, -0.07458792f, 0.01575551f, -0.05636771f, 0.03658215f, -0.04399243f, 
    0.05280771f, 0.05714151f, -0.06728488f, 0.01910675f, -0.01051440f, -0.08556475f, 0.03168474f, 0.02210848f, 
    -0.01511560f, -0.15625907f, 0.05312498f, 0.01166456f, -0.22547583f, 0.00547924f, -0.19877322f, 0.07855602f, 
    -0.11992486f, 0.10036192f, -0.05358375f, -0.01064432f, 0.15629233f, 0.09390795f, 0.03900370f, -0.01556926f, 
    0.43638769f, 0.11912161f, 0.09341606f, 0.01227878f, 0.11093655f, -0.08332407f, -0.02533857f, 0.03775651f, 
    -0.06060549f, -0.12590888f, -0.02996675f, -0.02433727f, -0.52280784f, -0.17016526f, 0.21813244f, 0.09468433f, 
    -0.04846142f, 0.04484820f, -0.00278171f, 0.00968192f, 0.12655219f, -0.04032842f, 0.11853263f, 0.08183618f, 
    -0.25011694f, 0.23638472f, 0.07626101f, -0.05883276f, 0.10439384f, 0.04158675f, 0.02844878f, 0.07394867f, 
    0.03115525f, 0.02179165f, 0.14776434f, 0.01300599f, 0.09056709f, -0.11156707f, 0.11357286f, 0.11003668f, 
    -0.02480873f, -0.05015675f, -0.04459558f, 0.11897476f, -0.00729355f, 0.02836277f, 0.14537139f, -0.03529499f, 
    -0.00020578f, -0.04799741f, -0.00658353f, 0.02015159f, 0.03162045f, -0.04735743f, 0.01468796f, -0.03921705f, 
    0.04666701f, -0.05192014f, 0.01432724f, 0.03451313f, 0.01686034f, -0.03247257f, 0.03320414f, -0.03386885f, 
    -0.00007425f, -0.02607462f, -0.02378608f, 0.03687937f, 0.03819456f, -0.05567300f, 0.02869938f, -0.04361576f, 
    0.02849305f, -0.04463568f, -0.04386514f, 0.03119887f, -0.04715815f, 0.01038565f, -0.03319071f, -0.03818305f, 
    -0.01303328f, -0.00349265f, -0.00913551f, 0.02580338f, -0.03891328f, 0.01198433f, -0.00237509f, -0.01000939f, 
    -0.02956229f, -0.00526609f, 0.05104318f, 0.03561283f, 0.00524347f, -0.02300159f, -0.05075525f, -0.03090531f, 
    -0.01949998f, -0.02143200f, 0.00561678f, 0.01489969f, 0.04226663f, -0.01098421f, 0.01406273f, 0.01811655f, 
    -0.00900759f, -0.05186031f, 0.02857646f, 0.00422987f, -0.01369158f, 0.00019551f, 0.02619574f, -0.01642943f, 
    0.01856386f, -0.01627120f, -0.02578231f, 0.00032158f, 0.00860946f, 0.04974107f, -0.03496379f, -0.03363345f, 
    -0.00011747f, -0.01184472f, -0.04556711f, -0.03794705f, -0.03868540f, -0.03358193f, -0.02494022f, -0.03157850f, 
    -0.04236532f, -0.02487465f, 0.03685717f, -0.01040325f, -0.02832125f, 0.04069521f, 0.02223967f, -0.03611327f, 
    -0.00794655f, 0.00183290f, 0.02036052f, 0.01630222f, 0.04188022f, 0.03682591f, -0.03128568f, -0.01341675f, 
    0.04116622f, 0.04438929f, -0.01409603f, 0.01094718f, -0.05055906f, -0.02459593f, -0.05426523f, 0.04208440f, 
    -0.01281091f, 0.03589904f, -0.03942662f, -0.01475349f, -0.05662661f, -0.00629336f, 0.01496888f, 0.04146004f, 
    -0.03145642f, -0.05452277f, 0.01455657f, 0.00643782f, 0.00363396f, -0.01555824f, -0.00050887f, 0.00938780f, 
    -0.04506755f, -0.03725630f, -0.05211689f, 0.03669128f, 0.04269848f, 0.02673887f, 0.03763507f, -0.00319898f, 
    -0.00607111f, -0.02058492f, -0.01131030f, 0.03065169f, -0.00029638f, 0.00422173f, 0.04077707f, 0.03751248f, 
    -0.05129376f, 0.01479154f, -0.01966811f, -0.02448289f, 0.03741985f, 0.01050981f, 0.02126485f, -0.03548507f, 
    0.00154683f, 0.04223021f, -0.05399056f, 0.02076370f, 0.03408250f, -0.01882673f, 0.00892406f, 0.01807961f, 
    0.04398789f, 0.02167688f, 0.01850621f, -0.02893023f, -0.05018930f, 0.02441203f, 0.02286225f, -0.03765136f, 
    -0.02934166f, 0.01007317f, -0.03954462f, 0.03272446f, -0.03016122f, 0.03997688f, 0.03259593f, -0.02528585f, 
    -0.01763206f, -0.04980801f, 0.00357396f, 0.00266118f, -0.01815849f, 0.02650036f, 0.01357582f, -0.02761269f, 
    -0.00937372f, -0.03999533f, -0.00796551f, 0.04071347f, -0.01281178f, -0.01146346f, 0.00665409f, 0.03890676f, 
    -0.02469396f, -0.01321976f, -0.05383730f, -0.04750880f, 0.03535195f, -0.01000253f, -0.01517912f, 0.03040932f, 
    -0.03521697f, -0.01940291f, -0.01183544f, -0.01272437f, 0.00291040f, -0.00971720f, 0.04073175f, -0.02613367f, 
    -0.03850329f, 0.04350439f, 0.01052605f, 0.00173561f, 0.04270375f, 0.00842073f, -0.00570368f, 0.01540185f, 
    -0.04788844f, -0.00430863f, -0.04706839f, -0.04863378f, -0.05611610f, -0.03022175f, -0.01409896f, -0.02745295f, 
    0.04362590f, -0.05312818f, 0.04144311f, 0.01594095f, -0.01004731f, 0.00107049f, 0.04618380f, -0.02236359f, 
    -0.03401279f, 0.03591879f, 0.00283272f, -0.01262314f, 0.00165663f, 0.00107992f, -0.04530105f, 0.04014746f, 
    -0.02367513f, -0.05330236f, 0.03871715f, -0.04901417f, 0.04337346f, -0.02771854f, -0.00990003f, 0.03536227f, 
    -0.02866904f, 0.03672960f, 0.02613374f, -0.03471607f, 0.02391679f, -0.02433716f, -0.03947733f, 0.03501056f, 
    0.01418475f, 0.03261415f, -0.02339584f, -0.01710973f, 0.02979874f, 0.03097431f, 0.00475125f, -0.02692508f, 
    -0.03959408f, -0.02358412f, -0.00419112f, -0.00923685f, -0.00637022f, -0.05320775f, -0.04057438f, -0.03489372f, 
    0.02711529f, -0.04832902f, -0.01518273f, -0.04061779f, -0.00980725f, 0.01725088f, -0.05192828f, 0.04024112f, 
    -0.03698798f, 0.04786145f, -0.01656246f, -0.01425572f, -0.05161170f, 0.00015917f, -0.00204590f, -0.01633384f, 
    -0.01298887f, 0.03248544f, 0.02669743f, 0.03967141f, 0.01462412f, -0.03812575f, -0.02663870f, -0.05298405f, 
    -0.01513793f, -0.01304488f, 0.03477964f, -0.03492416f, -0.00386723f, -0.02295448f, 0.00294239f, 0.03013275f, 
    0.03733290f, -0.01765300f, -0.01875308f, -0.02404966f, -0.00599959f, 0.02327503f, -0.02252251f, -0.04718327f, 
    -0.00948388f, -0.03518317f, -0.05585941f, 0.01326596f, -0.04486974f, -0.00203908f, -0.04214494f, -0.02540056f, 
    0.03911705f, -0.04583116f, -0.05160194f, -0.02570615f, -0.03124804f, -0.01820424f, 0.01251737f, 0.00443691f, 
    0.03019541f, 0.02279504f, -0.02535283f, -0.01478953f, 0.03797548f, 0.04040539f, 0.00839956f, 0.02598579f, 
    0.00502936f, 0.00369275f, 0.05597214f, 0.02269045f, -0.01755514f, -0.02215580f, 0.02627169f, -0.01087228f, 
    0.01667013f, 0.00176259f, -0.01456075f, -0.00292897f, -0.02240439f, -0.00701609f, 0.00526953f, -0.03439118f, 
    -0.05611920f, -0.05229347f, 0.00896740f, -0.03335069f, 0.02714607f, -0.01315824f, -0.00064091f, 0.01867872f, 
    -0.02519528f, -0.05422733f, 0.03790613f, 0.00017314f, -0.04349532f, -0.05303970f, -0.04526741f, 0.03093349f, 
    -0.03449368f, 0.03599131f, 0.04584976f, -0.03033374f, 0.01800735f, 0.01721031f, -0.02890016f, 0.01998504f, 
    0.03680031f, 0.00630911f, -0.01022585f, -0.03737276f, 0.04342763f, -0.05048754f, -0.01923346f, -0.05443538f, 
    0.02681336f, -0.04110723f, 0.00861451f, 0.04035772f, -0.00838568f, 0.00844992f, -0.00534008f, 0.02888993f, 
    -0.09013475f, 0.10492683f, -0.05189570f, -0.02284400f, 0.18612334f, -0.08070830f, -0.01557307f, -0.06434199f, 
    0.01707867f, -0.01304873f, 0.04923619f, -0.06248429f, -0.04294053f, -0.12793715f, -0.05922097f, -0.15716003f, 
    0.12635997f, 0.16055517f, -0.04865223f, -0.09240786f, -0.06094372f, 0.00588061f, 0.00224642f, -0.05753842f, 
    -0.34544647f, 0.09425199f, -0.07443050f, -0.16044605f, 0.11815993f, 0.05397369f, 0.12031009f, -0.00562841f, 
    -0.05387265f, 0.06256109f, 0.01372532f, -0.03710833f, 0.18862005f, 0.02956590f, -0.12208985f, -0.16189642f, 
    0.17566201f, 0.16667767f, -0.01915743f, -0.08548164f, 0.06399116f, 0.01085177f, -0.02457315f, -0.09527825f, 
    0.12267967f, 0.08087211f, 0.00206053f, 0.10135485f, -0.06614206f, 0.02739761f, 0.10622981f, -0.00824063f, 
    -0.05586153f, 0.06633276f, -0.04802508f, -0.00239581f, -0.22967488f, -0.16281146f, 0.13017295f, 0.04709477f, 
    -0.07847729f, 0.01645305f, 0.06934793f, 0.06142190f, 0.03692352f, -0.06875753f, 0.04811785f, 0.18872251f, 
    0.21426690f, -0.05513538f, 0.23683171f, 0.22460152f, -0.15303630f, -0.11118860f, -0.01999873f, 0.07731193f, 
    -0.05586581f, 0.07711385f, -0.00334899f, 0.07828899f, -0.17961720f, -0.01602687f, -0.23956987f, -0.02584730f, 
    0.06416737f, 0.00083989f, -0.05686882f, -0.02969150f, 0.02430235f, 0.09444482f, -0.00015119f, 0.01652754f, 
    0.09416787f, 0.15031748f, -0.03381038f, -0.00151979f, -0.00339924f, 0.05212501f, 0.05498376f, -0.02519240f, 
    0.17325805f, 0.08952510f, 0.02979467f, 0.15296899f, -0.03304630f, -0.01576918f, 0.26625648f, 0.06411650f, 
    0.15636791f, -0.05285067f, -0.03474764f, -0.04734859f, -0.02524211f, -0.05878707f, -0.06879431f, -0.02209129f, 
    -0.39552668f, 0.01069410f, 0.10523828f, -0.19937837f, 0.00049287f, 0.00101835f, 0.01927983f, -0.04303925f, 
    -0.04246924f, 0.08375540f, 0.04176351f, -0.06088646f, -0.17686686f, -0.14773266f, -0.02740518f, -0.15275773f, 
    0.12512530f, 0.02981155f, -0.03563612f, 0.04909086f, -0.10921285f, 0.08260217f, -0.05688610f, -0.17490079f, 
    -0.33806369f, 0.36764777f, -0.09947919f, -0.07161277f, 0.20034321f, -0.12650996f, 0.08561174f, 0.04271307f, 
    0.02191449f, 0.06157086f, 0.06882299f, 0.00715868f, 0.02308665f, -0.12791915f, -0.19891481f, -0.04956473f, 
    0.13048637f, 0.03103985f, 0.11849500f, -0.01204272f, 0.07483433f, -0.06567581f, 0.02001142f, 0.00492985f, 
    -0.22761646f, -0.07582375f, 0.08394416f, -0.12885907f, 0.00606235f, 0.05815160f, -0.02364405f, 0.08210331f, 
    0.09513175f, 0.16797979f, -0.04613226f, -0.01063652f, 0.15402038f, 0.15642111f, 0.10052723f, 0.11437811f, 
    -0.07252912f, -0.12107345f, -0.00454963f, -0.06142969f, 0.02578852f, 0.01949000f, -0.09666707f, -0.12755184f, 
    -0.12592605f, 0.33234537f, 0.11590280f, -0.16212663f, 0.03978907f, -0.08584449f, 0.02417898f, 0.08187565f, 
    0.01784203f, 0.04111174f, 0.02847098f, -0.02542802f, 0.37606570f, -0.02383649f, 0.10937314f, -0.00399290f, 
    0.11563776f, -0.09550924f, 0.12949492f, 0.03698992f, 0.12381518f, -0.00579401f, 0.09220172f, 0.02159055f, 
    0.33108735f, 0.07402638f, 0.19382061f, 0.14006002f, 0.17265767f, -0.01998538f, -0.00478696f, 0.03172048f, 
    0.08229449f, -0.05177035f, 0.05777405f, 0.04957637f, -0.28885281f, 0.02128802f, 0.01654728f, 0.04652749f, 
    0.06112798f, -0.03981147f, 0.02032116f, 0.13680868f, 0.09893527f, 0.12481364f, 0.02002649f, -0.01591876f, 
    0.00066179f, -0.17549951f, 0.02615379f, 0.13640307f, -0.07792536f, -0.08724657f, 0.03230763f, 0.09067291f, 
    -0.06202058f, 0.04491868f, -0.17268877f, 0.04346056f, -0.10130720f, 0.07053138f, -0.11528023f, -0.14508030f, 
    0.07314070f, -0.14321001f, 0.12207048f, 0.00518917f, -0.02996876f, 0.06451711f, 0.02985987f, 0.24993083f, 
    -0.23826066f, 0.21991882f, 0.03670834f, 0.06767648f, 0.07120466f, 0.01846682f, -0.00404238f, 0.09432129f, 
    -0.02530005f, 0.12892653f, 0.21232586f, 0.11520464f, -0.19825751f, -0.07952321f, -0.06445263f, 0.00786526f, 
    0.01586138f, 0.08977377f, -0.05093019f, -0.00241897f, -0.04430204f, 0.02945515f, 0.02675665f, 0.00645112f, 
    0.03223990f, -0.10621936f, 0.27548045f, -0.19306591f, 0.09568750f, 0.00907636f, 0.06337645f, -0.00424974f, 
    -0.01063193f, 0.05421675f, -0.02661595f, 0.10786320f, 0.04732921f, -0.15772070f, -0.06336754f, 0.11832674f, 
    0.00636562f, -0.01309117f, -0.13193238f, -0.08279029f, -0.05181298f, 0.10290189f, -0.08784983f, 0.07434372f, 
    0.39687756f, -0.11234400f, -0.22285667f, -0.05069639f, 0.08002627f, 0.01980118f, -0.03687146f, -0.05566566f, 
    0.10823989f, 0.08475526f, 0.12663057f, 0.03149930f, 0.48696515f, 0.03289587f, 0.04940313f, 0.06345025f, 
    -0.03075028f, -0.03105089f, -0.03512763f, 0.07014038f, 0.02232320f, -0.06026801f, -0.08326188f, 0.04976553f, 
    -0.06000693f, -0.01217024f, -0.03380747f, 0.06690390f, 0.08165108f, 0.03263187f, 0.02700169f, -0.05465094f, 
    -0.07372828f, 0.09815550f, -0.06834333f, -0.01698324f, -0.37563339f, -0.08294601f, 0.01781943f, -0.11377703f, 
    0.09981628f, 0.02931944f, -0.02581819f, -0.07020944f, 0.06176143f, -0.07982200f, 0.03481577f, -0.04349280f, 
    0.45697784f, -0.07663772f, -0.11051498f, 0.04360180f, -0.03147853f, 0.08302839f, -0.02463973f, 0.09677375f, 
    0.09117842f, 0.06037253f, 0.16765882f, -0.03989216f, 0.30824491f, -0.02037825f, -0.03202259f, 0.06936836f, 
    -0.02695928f, -0.13914700f, 0.00839440f, 0.09822318f, 0.03286286f, -0.08786258f, -0.01317220f, -0.06287854f, 
    -0.00416431f, -0.05290621f, -0.03174953f, 0.02203874f, 0.02673819f, -0.00013563f, -0.01004553f, -0.01805373f, 
    0.00808661f, 0.01089831f, 0.04328296f, 0.01000647f, -0.00720904f, 0.03959452f, -0.03130386f, 0.03400875f, 
    -0.05457142f, -0.02739971f, -0.02915815f, 0.02155052f, -0.02953845f, -0.00366224f, 0.00098881f, 0.03943667f, 
    -0.02502732f, 0.03050734f, -0.00757057f, 0.04204759f, 0.01287494f, -0.00741813f, -0.00954803f, -0.02159001f, 
    0.02581132f, 0.03552211f, -0.03862065f, -0.05420751f, -0.01664148f, 0.03447504f, -0.00668465f, 0.03780460f, 
    -0.02958541f, -0.00386296f, 0.03478964f, 0.02184461f, 0.00346860f, 0.03030437f, 0.01823658f, -0.03710769f, 
    -0.02474955f, 0.01392377f, 0.04816810f, -0.00000001f, -0.03075396f, -0.03052011f, -0.00790092f, -0.01639391f, 
    0.02823317f, -0.01358393f, 0.00580825f, 0.03116554f, 0.00077826f, -0.00972392f, -0.00825552f, 0.00965568f, 
    -0.00589532f, -0.04865409f, 0.03541905f, -0.04071486f, 0.02882561f, -0.02503406f, -0.04209468f, -0.01032454f, 
    -0.03379252f, -0.02589140f, -0.05100169f, -0.01412229f, 0.02038351f, 0.01341163f, 0.03766116f, -0.01254092f, 
    -0.04793276f, 0.04163383f, 0.01252413f, -0.00326051f, 0.00938506f, -0.02540370f, -0.04786411f, 0.00898161f, 
    0.00220892f, -0.04529151f, -0.02909811f, -0.00828597f, 0.03094513f, 0.03922533f, -0.01598297f, 0.01816428f, 
    0.00198814f, 0.03713430f, -0.00869664f, -0.04241830f, 0.01948384f, -0.00203330f, 0.00678622f, -0.03375752f, 
    -0.02437417f, -0.04144311f, 0.00916090f, 0.02660426f, -0.01663768f, 0.01969193f, -0.02431762f, -0.00503183f, 
    -0.03138814f, -0.00716692f, -0.04714185f, 0.01334304f, -0.03739698f, -0.02784047f, -0.01289205f, -0.00886046f, 
    0.00844359f, 0.04229382f, -0.04107136f, 0.00976180f, 0.00501445f, 0.00862966f, -0.02805963f, -0.04024775f, 
    -0.01799721f, 0.04283397f, -0.03028080f, -0.03808181f, -0.03582872f, 0.03893624f, 0.04328186f, -0.05469885f, 
    -0.02066002f, 0.01956117f, -0.04692052f, -0.02439757f, -0.04107521f, -0.02272089f, -0.02619665f, -0.01463062f, 
    0.02964003f, 0.03573218f, -0.04118188f, 0.00815811f, 0.01693173f, -0.01405508f, 0.04495097f, -0.03265694f, 
    0.01209632f, -0.03315522f, -0.01667409f, -0.01949039f, -0.01509454f, 0.01318150f, 0.00461347f, 0.02769404f, 
    0.00896223f, -0.02220707f, -0.02879085f, -0.01351037f, -0.01472170f, -0.00579315f, 0.03737887f, -0.01877139f, 
    -0.00220280f, 0.02365863f, -0.00741263f, -0.03330549f, -0.05661441f, 0.02474509f, -0.05681941f, -0.01979374f, 
    0.02573422f, 0.04282716f, -0.01060393f, -0.04627479f, -0.01042973f, 0.03828444f, -0.05017539f, -0.03721695f, 
    -0.00812138f, -0.04947396f, 0.03082642f, -0.01506107f, 0.01720975f, 0.00123844f, 0.01519116f, -0.01187620f, 
    -0.05385429f, -0.01619829f, 0.00516676f, -0.04945902f, 0.03164905f, -0.05597947f, -0.00692471f, 0.01568604f, 
    -0.04812562f, -0.02922520f, -0.01968412f, -0.04947337f, 0.02730561f, -0.04211264f, -0.02783915f, -0.03614881f, 
    0.00463766f, -0.00521088f, -0.03599085f, 0.04212430f, -0.02714458f, -0.05210857f, -0.01044619f, -0.01020637f, 
    0.02910984f, -0.02778839f, 0.02150711f, -0.02940421f, 0.01846118f, -0.05664567f, -0.03818688f, -0.02312853f, 
    -0.03843622f, 0.01473244f, 0.00475051f, -0.02184352f, -0.03525725f, 0.02746601f, 0.04335614f, 0.01306434f, 
    -0.00441147f, 0.04125630f, -0.03244929f, -0.04043091f, -0.00989589f, -0.02499823f, 0.03456770f, -0.01377732f, 
    0.02090266f, 0.02900256f, -0.04247401f, 0.00261062f, 0.04304243f, -0.03318333f, 0.01362238f, -0.04051361f, 
    -0.00869202f, -0.03869259f, 0.00437459f, -0.01971646f, 0.01276149f, -0.04101091f, -0.05110950f, 0.02493617f, 
    -0.02567910f, -0.03084704f, -0.02796020f, 0.01121352f, -0.00900407f, 0.02162260f, 0.03101851f, -0.05381452f, 
    -0.05459016f, -0.00124328f, -0.03374771f, -0.01720854f, 0.04240466f, -0.05267045f, 0.02903974f, 0.01250536f, 
    -0.00176538f, 0.02521977f, -0.01832329f, -0.02849972f, -0.03528643f, 0.00749162f, 0.00245482f, 0.04609645f, 
    -0.02494822f, -0.03558338f, -0.01657099f, -0.00878685f, 0.04071281f, 0.04448533f, 0.03367449f, -0.00834674f, 
    0.01392347f, -0.01382862f, 0.02872377f, -0.01986985f, -0.00936213f, 0.02112434f, -0.01776170f, 0.00488790f, 
    -0.01875214f, -0.01794129f, 0.02142978f, -0.04270886f, -0.03553446f, -0.04823539f, 0.03891940f, -0.01741074f, 
    -0.01082554f, -0.02322331f, -0.04273289f, -0.00707398f, 0.02642330f, 0.02989412f, -0.00280630f, 0.01538676f, 
    0.00921486f, 0.03481762f, -0.03420731f, -0.00548253f, -0.03590311f, 0.01341965f, 0.00594138f, -0.03306131f, 
    -0.04900654f, 0.01887569f, -0.04298924f, -0.01923493f, 0.03250304f, -0.01443020f, 0.03182455f, -0.05612194f, 
    -0.00060791f, -0.05011660f, 0.01818428f, -0.04211563f, 0.03951868f, -0.03876164f, -0.02606639f, -0.02433833f, 
    -0.00597434f, 0.01817929f, -0.00427952f, -0.05353680f, 0.01169976f, -0.00107330f, 0.00854898f, 0.03327485f, 
    -0.01373973f, 0.03686711f, -0.03509688f, -0.01339541f, -0.02607154f, -0.04460050f, 0.03818127f, -0.00917334f, 
    -0.00734469f, 0.00570280f, 0.03244220f, 0.02426371f, -0.05427999f, -0.02120106f, 0.01944808f, -0.03694951f, 
    0.00376891f, -0.01832138f, -0.00821401f, -0.05042479f, 0.01677667f, -0.02229960f, -0.05583870f, -0.03603507f, 
    -0.00810154f, 0.03107384f, -0.05637925f, 0.01027692f, -0.02384400f, 0.03556245f, 0.00433307f, -0.04122591f, 
    0.03096328f, -0.00592755f, 0.00305766f, 0.03978077f, 0.03970118f, -0.02787822f, -0.05166021f, 0.03024746f, 
    -0.02495866f, -0.02392633f, -0.00977873f, 0.00325965f, -0.05567284f, 0.03289794f, 0.04292936f, -0.05050803f, 
    0.02588128f, 0.02562570f, -0.05282912f, -0.04036782f, -0.00285765f, 0.01870374f, -0.04159389f, -0.00474667f, 
    -0.05537068f, 0.01201643f, -0.00215438f, -0.04135467f, 0.02875648f, 0.02528932f, 0.00910306f, 0.01697359f, 
    0.01747086f, 0.03612848f, -0.02029664f, -0.03292052f, -0.02274191f, 0.00407609f, -0.05496996f, -0.01522378f, 
    0.00508217f, 0.03327135f, 0.03393281f, 0.01982044f, -0.00374200f, 0.02179215f, -0.04377262f, -0.01546089f, 
    0.04241672f, 0.01323942f, 0.01675641f, 0.03657016f, 0.01147067f, 0.02939144f, -0.00965355f, -0.03916865f, 
    0.00485876f, 0.04274313f, -0.05108088f, -0.03022326f, 0.01165603f, -0.03669888f, 0.03834886f, -0.03085455f, 
    -0.02504170f, -0.01828792f, -0.02938521f, 0.04157051f, -0.01520674f, 0.00924585f, 0.03223761f, 0.01819681f, 
    0.02116612f, 0.02149493f, -0.02094175f, -0.00357609f, -0.04225747f, -0.01382019f, -0.02559840f, -0.05560777f, 
    0.00250859f, -0.04687836f, -0.00824978f, -0.01734761f, -0.01411202f, -0.02412885f, 0.01940069f, -0.02200375f, 
    -0.02838305f, -0.04484242f, 0.03791189f, -0.03774444f, -0.04203027f, -0.02967352f, -0.05192823f, 0.02958635f, 
    -0.01068938f, -0.01256459f, -0.02328281f, 0.03992724f, 0.01018825f, -0.04601041f, 0.01990413f, 0.02106627f, 
    0.01186545f, -0.03635368f, 0.03665236f, -0.01995890f, 0.01823593f, -0.02808216f, -0.03639943f, 0.04196685f, 
    0.02194706f, -0.02327423f, -0.05397207f, 0.00539052f, -0.05401356f, -0.03283155f, -0.04752989f, 0.03956023f, 
    -0.04607901f, 0.00769108f, -0.01255793f, -0.02785330f, -0.04943461f, 0.00937854f, 0.01331080f, 0.00090827f, 
    0.01568340f, 0.00283992f, -0.04982309f, -0.02326126f, -0.02315326f, -0.01671793f, -0.05252966f, 0.04151747f, 
    0.00427967f, 0.02623796f, 0.01214856f, -0.01453898f, 0.00891787f, 0.00740222f, -0.02263292f, 0.03154393f, 
    -0.01894534f, 0.03233852f, -0.03904646f, -0.04351937f, -0.01564689f, 0.04085498f, 0.04300739f, 0.01666661f, 
    -0.03453788f, 0.02229754f, 0.03594867f, 0.01328340f, -0.02971238f, 0.03986147f, -0.04748954f, 0.00258516f, 
    0.03003852f, -0.04395299f, 0.01700624f, -0.01877257f, -0.04067288f, -0.02554769f, -0.02152258f, 0.04420485f, 
    -0.02706815f, -0.00490729f, 0.02958479f, 0.01502017f, 0.02817917f, 0.02068406f, 0.02624316f, 0.01603394f, 
    0.00018695f, -0.03706843f, -0.02098488f, -0.01908870f, -0.00166599f, 0.00237790f, -0.01276687f, -0.03603853f, 
    -0.01848154f, 0.02323679f, -0.03589550f, -0.03076618f, -0.02818026f, 0.02752210f, -0.01427949f, 0.02772768f, 
    -0.04780122f, 0.04499404f, -0.00024851f, -0.01637265f, -0.01830580f, -0.00120897f, -0.04096375f, 0.03971906f, 
    -0.04059804f, -0.04223759f, 0.01805237f, 0.02494398f, 0.02444755f, 0.04021553f, -0.05696694f, -0.05205850f, 
    -0.00911305f, -0.04096010f, -0.00073705f, 0.01443116f, 0.03055160f, 0.02515508f, 0.03464557f, 0.00111410f, 
    -0.03228958f, 0.00047755f, -0.04368945f, 0.00684660f, -0.01884856f, 0.02897985f, 0.00211995f, -0.03102773f, 
    -0.01135295f, 0.01406809f, 0.00050699f, -0.02978471f, 0.00376107f, -0.04045092f, -0.05152209f, 0.00788107f, 
    0.01880786f, 0.00461691f, 0.04021528f, -0.00320888f, -0.05092188f, -0.04251974f, -0.04897644f, -0.02660137f, 
    0.00959426f, -0.00838897f, 0.05026026f, 0.03302572f, -0.02197519f, -0.00237707f, -0.05543069f, -0.02751501f, 
    -0.03582587f, -0.01396689f, -0.00232907f, -0.01423425f, -0.02752082f, -0.01055988f, -0.03748979f, 0.02461430f, 
    -0.02539261f, -0.03898304f, -0.01529264f, -0.02366018f, -0.01440971f, 0.02825026f, -0.04921519f, 0.02693018f, 
    -0.05419672f, -0.05386797f, -0.02275972f, 0.01594134f, -0.00577264f, -0.00062142f, 0.00397854f, 0.00342587f, 
    -0.03641293f, 0.00863127f, -0.05699381f, -0.00700251f, -0.01751790f, 0.01329275f, -0.04825407f, 0.01870839f, 
    0.00833350f, 0.04354887f, 0.03107871f, -0.03824066f, 0.03029748f, -0.05236406f, -0.02714922f, 0.00240476f, 
    0.01124611f, 0.00744782f, -0.05091171f, -0.02380257f, -0.00017797f, -0.00049712f, -0.04290913f, 0.00366329f, 
    -0.03094153f, -0.05293545f, -0.05694073f, -0.02017168f, 0.00284849f, -0.03609502f, -0.04609923f, -0.01667788f, 
    0.02161847f, -0.00388126f, -0.04169666f, -0.03336581f, -0.02221441f, 0.02954028f, 0.01766127f, -0.00463571f, 
    -0.02855734f, -0.01172808f, -0.01990671f, 0.01289191f, -0.00203161f, -0.00600813f, 0.02531083f, -0.03746602f, 
    -0.00573481f, 0.03465352f, 0.00893928f, 0.03663966f, -0.05636417f, -0.03941092f, -0.00451343f, -0.01124229f, 
    0.00677856f, -0.01672975f, -0.04463078f, 0.02178676f, -0.03871000f, 0.03805736f, -0.00900201f, 0.00511765f, 
    0.02982857f, -0.05624707f, -0.04608062f, 0.04672793f, -0.02229692f, 0.03996873f, 0.03557358f, -0.05142998f, 
    -0.03126668f, -0.04520962f, 0.00782173f, -0.03929365f, -0.03866985f, -0.05192482f, -0.01046672f, 0.04080996f, 
    -0.01433260f, 0.03471507f, -0.03497368f, -0.01437243f, 0.01962094f, 0.00518490f, -0.03851649f, -0.02570377f, 
    0.03402769f, -0.04161423f, 0.01517716f, 0.00347414f, -0.04461249f, 0.01657473f, -0.00525175f, 0.04292631f, 
    0.02709855f, -0.00735076f, -0.05476027f, 0.00645600f, -0.02720157f, 0.03407278f, 0.03045625f, 0.03043435f, 
    -0.00063070f, -0.05320938f, -0.01853170f, -0.00362610f, 0.00293408f, -0.03155820f, -0.01407748f, -0.01471132f, 
    -0.02149476f, -0.05621820f, -0.02206119f, -0.03324207f, 0.01628140f, -0.00353064f, -0.03947381f, -0.02042855f, 
    0.07929231f, 0.14920680f, 0.28660399f, -0.04703882f, -0.07555000f, 0.00976913f, -0.01719361f, 0.02680012f, 
    0.11658516f, -0.11142507f, 0.06959439f, -0.04214619f, 0.04165957f, 0.11136191f, 0.07587660f, -0.07702529f, 
    -0.02603931f, 0.08981728f, 0.15083075f, 0.25623032f, -0.00237310f, 0.01526774f, 0.09450368f, 0.02906129f, 
    -0.12325912f, 0.07925118f, 0.13470121f, 0.07977084f, 0.08000419f, -0.05690521f, -0.10541011f, 0.10760275f, 
    0.08859307f, -0.12384255f, 0.00459807f, -0.02678283f, -0.04523367f, 0.21149786f, 0.11568844f, 0.14513703f, 
    -0.02073427f, -0.04198772f, 0.04402224f, 0.10352599f, -0.05630912f, 0.10771582f, -0.03825933f, 0.08641361f, 
    -0.21635084f, -0.14762987f, 0.06349422f, -0.33015981f, -0.13541248f, 0.04066402f, -0.14918104f, 0.00632115f, 
    0.02063216f, -0.08284980f, 0.08549827f, -0.00308871f, 0.27233347f, -0.12241075f, -0.21277127f, 0.01670756f, 
    -0.08247508f, 0.00596061f, 0.05977574f, 0.11434301f, -0.02673608f, 0.11115353f, -0.06473517f, -0.17385955f, 
    -0.06333926f, 0.01593189f, -0.08463866f, 0.20426260f, 0.04232080f, -0.01348213f, -0.04845532f, 0.07625058f, 
    0.11144270f, -0.08445997f, 0.04235307f, -0.08196921f, 0.07836690f, 0.36177909f, 0.07491797f, -0.08412693f, 
    0.11275825f, 0.09725718f, 0.04411887f, 0.09482960f, -0.12194524f, 0.16142812f, -0.12370864f, 0.13256407f, 
    0.17200927f, 0.04818220f, -0.01257152f, 0.03854891f, -0.00899005f, 0.03045778f, -0.11053126f, -0.02366989f, 
    -0.14782281f, -0.11743931f, -0.15547593f, -0.07799950f, 0.03779597f, 0.09225541f, -0.00227788f, 0.30157503f, 
    -0.09022873f, -0.17800941f, 0.09003005f, 0.05595814f, 0.04853985f, 0.05203018f, 0.11419172f, 0.02050862f, 
    -0.27242541f, -0.15534325f, 0.01541812f, 0.27502277f, -0.04018544f, 0.05056192f, 0.11200734f, -0.08907121f, 
    0.19698256f, -0.10611092f, 0.09848790f, 0.05699950f, 0.40971798f, 0.08116009f, -0.17871541f, 0.14217234f, 
    0.00557758f, 0.13686548f, 0.14241818f, 0.07472986f, -0.00936019f, 0.07006010f, 0.05965240f, 0.08476384f, 
    0.42343208f, -0.18576321f, 0.08844399f, -0.08106872f, -0.00010110f, 0.02435782f, -0.05584736f, 0.07222304f, 
    0.11298420f, 0.02652450f, -0.05067308f, 0.08309849f, 0.36470962f, 0.12630229f, 0.11126257f, -0.01868814f, 
    -0.06153946f, 0.05043493f, 0.08805272f, 0.12071464f, 0.00059713f, 0.05034850f, -0.08245829f, -0.04370355f, 
    0.09937311f, -0.07066457f, -0.06497194f, 0.00195907f, -0.00228618f, -0.14633027f, 0.11137544f, 0.02418706f, 
    -0.03283431f, -0.04555177f, 0.04616798f, -0.07193844f, -0.33721778f, -0.07523074f, -0.20487988f, 0.08875370f, 
    -0.02864613f, 0.12153015f, -0.12346258f, 0.16206579f, 0.06161506f, 0.02861423f, -0.03967461f, 0.11305901f, 
    -0.03631755f, -0.09591807f, -0.12613733f, 0.24616161f, 0.00988084f, 0.02327617f, 0.06642686f, 0.01028256f, 
    -0.03288705f, 0.08153769f, 0.09098598f, -0.11725540f, -0.22981386f, 0.01025644f, 0.03632796f, 0.13802320f, 
    0.04267340f, -0.01428424f, 0.01530605f, 0.07694359f, -0.01183797f, -0.03434334f, -0.02071787f, -0.04233939f, 
    -0.19040473f, -0.24360979f, -0.04401769f, -0.07587209f, -0.02101913f, -0.17116509f, 0.07381566f, 0.02885837f, 
    -0.05403912f, 0.06802820f, 0.00046832f, 0.06818905f, -0.07985251f, 0.02321249f, -0.12696388f, -0.08337470f, 
    -0.01619615f, -0.00726765f, -0.00818420f, -0.18138732f, -0.15898070f, 0.02388115f, 0.02418214f, -0.00196068f, 
    0.03774212f, 0.09709085f, -0.10969050f, 0.00928892f, 0.10412206f, 0.07936172f, 0.02836791f, 0.11092363f, 
    0.06276981f, -0.06595837f, -0.01083782f, -0.05501387f, 0.16037077f, 0.10595212f, 0.05150450f, 0.10275697f, 
    0.03094369f, -0.02069370f, -0.01478885f, 0.05364027f, 0.09656836f, -0.00527347f, -0.03989524f, -0.13311908f, 
    0.15389195f, -0.20140572f, 0.06635626f, -0.11976926f, 0.02140784f, -0.02401131f, -0.05753435f, 0.02490413f, 
    -0.03010016f, -0.02527036f, -0.02173162f, 0.01177530f, 0.05027527f, 0.13292111f, 0.08237045f, 0.10017858f, 
    -0.15095966f, 0.11955579f, 0.09804811f, -0.08663586f, -0.00286570f, 0.01331121f, -0.06544363f, 0.06300747f, 
    -0.19194397f, -0.13446155f, 0.06465169f, -0.00742976f, 0.04630854f, 0.05587263f, 0.05343967f, -0.02642378f, 
    0.03107775f, -0.14815918f, 0.13478473f, -0.08700787f, -0.03068558f, -0.05663735f, 0.00844979f, 0.03949098f, 
    0.01604112f, -0.05744065f, -0.04339037f, -0.04366126f, -0.02201099f, -0.00971504f, 0.01036609f, 0.12029234f, 
    -0.02354101f, 0.12579823f, 0.00230610f, 0.01425857f, -0.01181892f, 0.05187088f, 0.11953072f, 0.02607268f, 
    -0.06280701f, 0.04961000f, -0.10212517f, 0.02758002f, -0.15437040f, 0.06877232f, 0.05166608f, 0.27239853f, 
    0.05109899f, -0.15906335f, -0.04004948f, -0.01932628f, -0.03274650f, 0.11064395f, -0.04485054f, 0.01401266f, 
    -0.20378125f, 0.20719761f, 0.15576775f, -0.05452404f, -0.14007518f, 0.09922842f, -0.05086536f, 0.10868195f, 
    0.09565423f, -0.04018339f, 0.16845493f, 0.02896061f, 0.23071048f, -0.14813972f, -0.11724907f, 0.02172147f, 
    -0.07302409f, -0.00823494f, 0.03945290f, -0.05211741f, 0.00534299f, 0.11776429f, -0.12314121f, 0.06833688f, 
    0.01264797f, -0.08219109f, -0.01748695f, 0.03398736f, -0.04687807f, -0.03778661f, 0.00032847f, -0.03376637f, 
    0.00825112f, -0.04872296f, -0.06583890f, -0.00692732f, 0.22308546f, 0.13714324f, -0.12618978f, -0.00828678f, 
    -0.02147970f, 0.00594057f, -0.00908734f, 0.02196062f, -0.01910911f, 0.03517239f, 0.07245407f, -0.04456127f, 
    0.02255564f, 0.02774812f, 0.11449180f, -0.22495177f, -0.03621145f, -0.00688044f, -0.10021897f, -0.06547233f, 
    0.02837125f, -0.08753669f, 0.00968499f, -0.09475611f, -0.05807041f, 0.01421202f, 0.07503738f, -0.10043243f, 
    0.15792890f, 0.15615351f, -0.04446542f, -0.03481379f, -0.13798088f, -0.08466976f, -0.05456535f, 0.05327283f, 
    -0.01199662f, 0.03893360f, 0.08769950f, 0.00811115f, -0.03119112f, 0.00443190f, 0.02111165f, -0.00478074f, 
    -0.02031661f, -0.05365084f, 0.11290117f, -0.04524448f, -0.19584735f, 0.02173853f, -0.01974539f, 0.01595605f, 
    0.08659350f, 0.04343644f, -0.14097752f, -0.10478126f, -0.07452461f, -0.06944787f, 0.00694088f, 0.05265212f, 
    0.23018202f, -0.11838865f, 0.11062282f, -0.08863236f, -0.12306795f, -0.04900652f, 0.00287578f, 0.10091058f, 
    0.14576936f, 0.16537137f, -0.15138869f, -0.02145817f, -0.27659926f, 0.15545942f, 0.00220467f, -0.01801582f, 
    -0.00767306f, 0.02850147f, -0.16469018f, 0.05686571f, 0.21961024f, -0.02118078f, -0.03913747f, 0.11245706f, 
    -0.30158707f, -0.06732567f, 0.15794890f, -0.05774570f, 0.00474061f, 0.03015207f, 0.11383657f, -0.17832562f, 
    -0.03169240f, 0.07309760f, 0.03241585f, 0.03838103f, -0.12189125f, -0.01419775f, 0.16691718f, -0.28540701f, 
    0.13658294f, -0.01965394f, -0.02421008f, -0.07674688f, -0.08596717f, 0.07633887f, 0.01853815f, -0.02776437f, 
    -0.11492733f, 0.13638081f, 0.00052264f, 0.16578025f, -0.02750787f, -0.07425919f, 0.12217520f, 0.12751199f, 
    -0.03445197f, 0.14218454f, -0.06486348f, 0.10734843f, -0.01527548f, 0.06031618f, -0.02091694f, 0.21986608f, 
    0.02113754f, -0.02913317f, -0.07695526f, -0.14575887f, 0.07040497f, 0.09370107f, 0.01162864f, 0.04243527f, 
    0.01631507f, -0.00471945f, -0.07970875f, 0.08483730f, 0.09036475f, 0.04431713f, -0.06131962f, 0.03448333f, 
    -0.10175055f, -0.05633059f, 0.05474894f, 0.11209884f, -0.01071709f, 0.05496257f, -0.02008585f, 0.14281052f, 
    0.19693114f, -0.06043864f, -0.11238714f, 0.05245822f, 0.09492724f, 0.04432809f, 0.00883824f, -0.12300926f, 
    -0.22529551f, 0.00186895f, 0.00457853f, -0.14872751f, -0.00543312f, 0.05723270f, 0.09674089f, -0.16256016f, 
    0.19906041f, -0.07590445f, 0.01400889f, 0.08767305f, -0.25936186f, 0.15301749f, 0.13124365f, -0.23474386f, 
    0.18401015f, -0.03601377f, 0.02601988f, -0.13286000f, -0.01939263f, 0.04200569f, 0.05058188f, 0.14069253f, 
    0.10786638f, 0.06645326f, -0.19955838f, 0.32880685f, 0.02613834f, -0.09689357f, -0.07931266f, -0.07556760f, 
    0.10329451f, -0.01389292f, 0.08196101f, 0.09018815f, -0.13607456f, -0.05096306f, 0.15605205f, -0.12528266f, 
    -0.01353981f, -0.17132966f, 0.24582222f, -0.04567622f, -0.08402712f, 0.01537488f, -0.02858693f, -0.00417527f, 
    0.43470949f, 0.32750022f, -0.15847768f, 0.44004819f, -0.04750622f, 0.12753747f, -0.08665362f, -0.01646480f, 
    -0.04777139f, -0.05214814f, -0.00595055f, -0.02587272f, -0.15781742f, 0.11432541f, -0.19140196f, 0.11075637f, 
    -0.08351196f, 0.13029169f, -0.04915144f, 0.05323052f, -0.00728235f, -0.08156009f, 0.01687996f, -0.15990177f, 
    0.11921067f, 0.10026588f, -0.10712794f, 0.01812845f, 0.08496489f, 0.16613582f, 0.01789785f, -0.09622594f, 
    -0.00146785f, -0.06187387f, -0.08484239f, 0.01518978f, 0.17874339f, 0.08925270f, -0.01839105f, 0.23899679f, 
    0.01328359f, -0.11745476f, -0.13220738f, 0.09535622f, 0.11254954f, 0.03450234f, -0.08235046f, 0.22048198f, 
    -0.11721480f, -0.00555652f, 0.16658206f, -0.18032975f, 0.14966656f, 0.12263155f, 0.04574161f, -0.08194740f, 
    -0.03227096f, 0.10767162f, 0.16932374f, 0.13494083f, -0.22343548f, 0.06750643f, 0.08940043f, -0.13714108f, 
    0.00055013f, 0.04493577f, -0.07247615f, -0.02681717f, -0.03070286f, -0.00875724f, 0.03094759f, 0.13598619f, 
    -0.10821900f, 0.04751321f, -0.12573996f, 0.01901981f, 0.05343559f, 0.09985948f, 0.01936709f, 0.05484957f, 
    0.15048213f, -0.16372146f, 0.14578412f, 0.08600900f, -0.06657276f, 0.05167608f, 0.08788015f, 0.15956189f, 
    0.07038084f, 0.01436161f, -0.10818253f, 0.11674631f, 0.03514318f, 0.02180917f, -0.04902359f, -0.02656747f, 
    -0.21575604f, 0.02396788f, -0.15665175f, 0.33518618f, 0.21953624f, -0.02199057f, 0.02609365f, 0.01386693f, 
    0.10681274f, 0.08023371f, -0.00339491f, 0.02049678f, -0.03854970f, 0.11514174f, -0.01187572f, -0.08420512f, 
    0.14488932f, 0.06215819f, 0.01355580f, -0.22402593f, -0.08827736f, 0.02667549f, -0.05933428f, -0.08082457f, 
    -0.01308638f, -0.04573404f, 0.16368276f, 0.04669639f, 0.06975242f, 0.03015175f, -0.05345347f, 0.15819444f, 
    0.02548810f, 0.05581011f, 0.12515645f, -0.08428478f, 0.23702517f, -0.17576732f, -0.01556939f, 0.07181265f, 
    -0.04065816f, -0.04817522f, 0.00614357f, -0.11055436f, -0.04340392f, -0.06639899f, 0.01411728f, 0.17830160f, 
    -0.16609049f, -0.03349994f, 0.16574956f, 0.02538736f, 0.01555207f, 0.05667277f, 0.00131588f, 0.08953758f, 
    0.07504603f, 0.06320480f, -0.01319736f, -0.08142899f, 0.00597850f, 0.06445007f, 0.18701556f, 0.44707012f, 
    0.14354570f, 0.11791827f, -0.13777213f, 0.17285550f, 0.11589064f, 0.11766327f, 0.13594683f, -0.09411044f, 
    -0.06747121f, -0.17911582f, 0.15086028f, -0.17716512f, 0.02614287f, -0.05750331f, 0.24228519f, 0.02773125f, 
    0.02253428f, -0.10512841f, 0.01854625f, -0.00688763f, 0.28957227f, -0.21988757f, -0.09526602f, -0.04949437f, 
    0.07469445f, -0.15056080f, -0.09133368f, -0.07254241f, 0.05712361f, -0.00874743f, -0.03177080f, 0.09210233f, 
    -0.37333199f, 0.04704729f, -0.15077889f, -0.12819844f, 0.11999336f, -0.01575733f, 0.15805629f, 0.09307441f, 
    0.04891586f, -0.03692738f, 0.06571294f, -0.02960626f, -0.09544003f, -0.11940719f, -0.10211498f, -0.21493554f, 
    -0.02306297f, -0.01657882f, 0.06354694f, 0.12263861f, 0.13295458f, -0.02931181f, 0.00792087f, -0.07881995f, 
    0.11762458f, 0.00437356f, -0.15781684f, 0.03564723f, 0.07054365f, -0.05705395f, 0.06946244f, -0.01222693f, 
    0.12063877f, -0.01416198f, -0.06396402f, 0.08341722f, -0.18637183f, -0.16203098f, -0.15983808f, -0.06480263f, 
    -0.01400022f, 0.01161195f, -0.02401897f, 0.08185268f, 0.09231790f, 0.09799368f, 0.09126810f, 0.06894898f, 
    0.07850557f, -0.14669316f, 0.19062482f, 0.00240429f, 0.20666111f, -0.06293280f, -0.04631013f, 0.01368926f, 
    0.11587729f, -0.07163206f, 0.01092958f, 0.06973395f, -0.06483374f, 0.15887323f, -0.15246022f, 0.10756498f, 
    0.16367185f, -0.05926106f, 0.19933164f, 0.00040357f, 0.06735300f, 0.10443158f, -0.00092922f, -0.10802683f, 
    -0.25392649f, 0.23449355f, 0.02261963f, 0.04422718f, 0.04686113f, 0.06333353f, 0.04984503f, 0.00491866f, 
    -0.08868726f, 0.05641948f, -0.02062446f, -0.17967114f, -0.23459381f, 0.00937095f, -0.11214454f, -0.34818622f, 
    0.06145551f, 0.05008134f, 0.08250004f, 0.14483148f, 0.03680220f, -0.03239946f, -0.08192484f, -0.00185162f, 
    0.11119838f, -0.03581272f, 0.02969490f, 0.12531027f, 0.05188933f, 0.06695203f, -0.07183085f, 0.14193934f, 
    -0.05148963f, -0.01350536f, 0.01293059f, -0.06547699f, 0.28724077f, -0.04816668f, -0.05721562f, 0.12791590f, 
    -0.24694510f, -0.01315335f, -0.11616593f, -0.06434128f, 0.00089015f, -0.05271590f, 0.01291554f, -0.01454215f, 
    0.25038850f, 0.07888064f, -0.08629502f, 0.12487051f, -0.04298297f, -0.04237429f, 0.01706029f, 0.02523212f, 
    0.14154738f, -0.10744572f, 0.01225307f, -0.06805729f, -0.06715883f, 0.13941447f, -0.07757056f, 0.04878056f, 
    0.03041706f, 0.15965845f, 0.01866434f, 0.10785700f, 0.13681453f, -0.07300130f, 0.12059111f, 0.16437258f, 
    0.11739253f, -0.21773526f, -0.06742923f, -0.03570298f, -0.02678700f, 0.06660777f, 0.05935016f, 0.02909203f, 
    0.08135378f, 0.02793843f, 0.03004879f, -0.04319956f, -0.23131473f, -0.11515459f, -0.11550926f, -0.09856776f, 
    0.10839800f, 0.06002036f, -0.04710276f, 0.05076042f, 0.01489016f, 0.07752738f, -0.09122143f, -0.15972859f, 
    0.09574789f, -0.09852963f, -0.12528628f, 0.38878340f, 0.05496809f, -0.01237881f, 0.07335893f, -0.01956013f, 
    0.02615334f, 0.03815222f, -0.02590294f, -0.07972103f, -0.22457314f, -0.08253423f, -0.06103817f, -0.00835297f, 
    0.00180106f, 0.04379391f, -0.08457562f, 0.23984183f, -0.02589864f, -0.07152405f, 0.02116979f, 0.07041724f, 
    0.22054729f, -0.09711049f, -0.19395038f, 0.21264957f, 0.03657827f, 0.18436792f, 0.02710201f, -0.10553701f, 
    -0.12625961f, 0.02184279f, 0.03021779f, -0.01167845f, -0.01484881f, -0.01624907f, -0.04091368f, 0.11598283f, 
    -0.05947430f, 0.02557051f, -0.01033790f, -0.02621396f, -0.02704717f, -0.03306631f, 0.02485447f, -0.08839344f, 
    0.04821615f, 0.05704319f, 0.04190670f, -0.05383101f, -0.21967973f, -0.01857100f, 0.00470278f, 0.00132417f, 
    -0.12128682f, 0.12136852f, -0.01003497f, -0.07851592f, 0.16491444f, 0.04073718f, -0.07865255f, 0.02928654f, 
    0.01590172f, 0.11127423f, 0.08743157f, -0.01071215f, -0.04254121f, -0.04206286f, 0.02441878f, 0.02611502f, 
    0.14266126f, 0.20670229f, -0.10144918f, -0.16490601f, -0.02450087f, 0.00736267f, 0.09479594f, -0.07126773f, 
    0.02804714f, 0.07538365f, 0.09628336f, -0.06125886f, -0.05771143f, -0.17903100f, -0.05516181f, 0.07507720f, 
    0.06543095f, 0.03753658f, -0.03215457f, 0.06563276f, 0.08447698f, -0.03867228f, 0.08902768f, -0.19136281f, 
    0.03255221f, -0.17408839f, 0.10468186f, 0.20167540f, -0.04676640f, -0.09991597f, 0.14124483f, -0.06830063f, 
    0.02537601f, 0.03518406f, -0.11456563f, 0.00639163f, 0.15722102f, 0.02137877f, 0.04142248f, 0.15010375f, 
    -0.08945104f, -0.00433844f, 0.01779500f, 0.07034314f, 0.17607072f, 0.06368706f, 0.01921643f, 0.06646783f, 
    -0.13468805f, -0.11446293f, 0.17509873f, -0.20890741f, -0.03872235f, 0.04814743f, -0.05943383f, -0.01788262f, 
    0.03431983f, -0.00209821f, 0.09651757f, 0.02085562f, 0.05698449f, 0.19333275f, -0.09298053f, -0.06230675f, 
    -0.05817245f, 0.10468280f, -0.01009231f, -0.09557953f, 0.11118256f, -0.04226236f, 0.01599932f, -0.17842722f, 
    -0.42669785f, 0.22603172f, 0.06141237f, 0.13731225f, -0.08300770f, -0.07020929f, 0.06405695f, 0.05807198f, 
    -0.01318493f, -0.08531271f, -0.02398189f, 0.10275394f, -0.11085065f, 0.22923097f, 0.14919735f, -0.02482207f, 
    -0.17102867f, 0.05404871f, -0.04175683f, -0.05314738f, 0.05765723f, 0.07913487f, 0.04392198f, -0.14039989f, 
    0.09881338f, 0.08822760f, -0.00001541f, -0.16107911f, 0.13466145f, 0.11061755f, 0.02804999f, 0.07349914f, 
    0.06666692f, -0.02977609f, 0.03392012f, 0.07629212f, 0.20445749f, 0.09376121f, -0.02850989f, 0.24885108f, 
    0.08592579f, 0.10454451f, 0.02908648f, -0.04279347f, 0.13008156f, 0.03993723f, 0.06818972f, 0.13678624f, 
    -0.30889046f, 0.20083000f, -0.19176441f, 0.07440796f, 0.08000693f, 0.00574012f, 0.05012749f, 0.07658681f, 
    -0.05603931f, -0.06240238f, -0.02707474f, 0.01909539f, -0.17001532f, 0.18565837f, 0.01014559f, -0.13490050f, 
    -0.00512812f, 0.21480000f, -0.03560543f, -0.04742417f, -0.05297336f, 0.10208855f, 0.12634732f, 0.06070409f, 
    0.31627727f, 0.06076753f, 0.15644731f, 0.05768158f, -0.09054265f, 0.03014976f, -0.07928997f, 0.01992509f, 
    0.07095523f, 0.03993533f, 0.05745240f, 0.05934468f, 0.03449069f, -0.00517956f, -0.07725976f, 0.14532246f, 
    -0.04295797f, -0.02403031f, 0.09738356f, 0.18683271f, -0.10069266f, 0.07599000f, 0.00636795f, 0.09457202f, 
    -0.00764286f, -0.08468515f, 0.19945286f, 0.36213690f, 0.03524297f, -0.02403411f, -0.13469626f, -0.02265124f, 
    0.16145159f, -0.00292921f, 0.04614501f, -0.06803019f, -0.00859338f, -0.00733283f, -0.01280149f, 0.06516678f, 
    0.00676717f, -0.03161182f, 0.00557817f, 0.01590091f, -0.12870730f, 0.04175799f, 0.05298924f, 0.17706282f, 
    -0.18906389f, -0.16457075f, -0.02393728f, -0.29710716f, -0.07598943f, -0.07251675f, -0.05040263f, 0.02067389f, 
    -0.00347570f, 0.00932158f, 0.05748222f, 0.05069360f, 0.07931715f, 0.12689915f, -0.01628084f, -0.05208705f, 
    -0.07359643f, 0.01374266f, -0.02571443f, -0.00455279f, 0.03910043f, 0.00645736f, -0.09357970f, 0.03562830f, 
    -0.15583813f, -0.05372062f, -0.02794585f, -0.02776808f, -0.01716040f, -0.02945346f, -0.05571265f, -0.01266774f, 
    0.04720868f, -0.08088789f, 0.08582704f, 0.11803012f, 0.17448376f, 0.06951391f, 0.04867852f, 0.15439247f, 
    0.03540785f, -0.07383528f, -0.02007604f, 0.02358097f, -0.03863382f, 0.07059103f, 0.18690495f, 0.00356284f, 
    0.12589020f, -0.03384542f, -0.01473957f, 0.09943374f, -0.03388380f, -0.02254709f, 0.10818067f, -0.00445074f, 
    -0.09138194f, -0.07312279f, -0.05361702f, -0.02995604f, -0.15695500f, 0.12621760f, 0.01836403f, -0.03368055f, 
    -0.06540105f, -0.14401254f, -0.02835939f, 0.07501119f, 0.09609772f, 0.07949392f, 0.02576715f, -0.00089017f, 
    0.02236296f, -0.28769004f, -0.11094636f, 0.19414453f, 0.09212508f, 0.15189454f, 0.01770593f, 0.05843784f, 
    0.17212288f, -0.05260629f, 0.06066491f, 0.06768870f, 0.56282264f, -0.00272725f, -0.03724946f, 0.12448832f, 
    0.06604335f, -0.00196065f, -0.02166337f, 0.08701304f, 0.11739193f, 0.05040625f, 0.00077612f, 0.09641109f, 
    0.65792596f, -0.32576576f, 0.07833043f, 0.19895209f, -0.02412849f, 0.11729642f, -0.06123332f, -0.01436914f, 
    0.09749556f, -0.00564206f, 0.12375374f, 0.10905489f, 0.39694750f, 0.01843384f, 0.18941388f, 0.14521800f, 
    -0.02790496f, -0.10766684f, -0.02197844f, -0.04560543f, -0.02389882f, -0.03060301f, 0.00273824f, 0.07396906f, 
    -0.09107807f, 0.13414216f, 0.01905537f, -0.17593162f, -0.07431935f, -0.12428371f, 0.00298158f, 0.03331276f, 
    0.06862134f, -0.00757597f, 0.12732176f, 0.15040419f, -0.25109640f, -0.22702087f, 0.03583199f, -0.07572323f, 
    -0.02090356f, -0.01306667f, 0.00889820f, -0.02757539f, 0.02503726f, -0.04440727f, -0.03172911f, 0.01320988f, 
    0.04199556f, 0.02908441f, -0.15468927f, -0.06999562f, -0.06703883f, 0.02165199f, -0.05889935f, 0.07674085f, 
    0.03959322f, 0.00200101f, -0.01242562f, -0.04803031f, -0.16851591f, 0.19001518f, -0.12757863f, -0.02799846f, 
    -0.01720351f, 0.08193709f, -0.06430139f, 0.10274149f, -0.10961187f, 0.00040004f, -0.02273127f, -0.06892848f, 
    -0.16672833f, -0.12390618f, -0.02672847f, -0.17805216f, -0.00048634f, -0.01499500f, 0.03549724f, 0.03572804f, 
    -0.01189828f, -0.08931432f, -0.12092993f, 0.09910794f, 0.24275096f, 0.22271994f, -0.07603803f, -0.19244172f, 
    -0.08877590f, -0.07008460f, 0.03639702f, -0.03764436f, -0.10291580f, 0.03656440f, 0.09327139f, -0.05155041f, 
    -0.10981259f, -0.00940457f, 0.09619125f, -0.10590730f, 0.07383763f, -0.01471709f, -0.08033027f, 0.08133665f, 
    0.06177965f, -0.12387203f, 0.10707768f, 0.07679642f, 0.18411312f, 0.07713139f, 0.09267431f, 0.26938999f, 
    -0.03134034f, 0.01638351f, -0.00824990f, 0.00324543f, 0.09158030f, 0.04269218f, 0.07231931f, -0.00327822f, 
    0.32792351f, -0.06655169f, -0.13560036f, -0.08169619f, -0.06978641f, -0.03330329f, -0.09419074f, 0.03141046f, 
    -0.01933210f, -0.10138255f, 0.13521123f, 0.02106036f, -0.06255433f, 0.02869055f, 0.03489219f, 0.13538358f, 
    -0.01053686f, 0.05988663f, 0.05495918f, 0.04256693f, 0.11182021f, 0.04210552f, -0.10352194f, -0.01204876f, 
    -0.05235269f, 0.28877562f, -0.22102825f, 0.08157382f, 0.06252722f, 0.04425431f, 0.03174980f, 0.04224733f, 
    0.11358264f, -0.02766648f, -0.10391238f, -0.07479797f, -0.13381141f, -0.08942083f, 0.16026460f, -0.07019120f, 
    -0.03503580f, -0.08961643f, 0.00073498f, 0.02060080f, 0.05000447f, 0.03862821f, 0.05295233f, 0.15752326f, 
    -0.24461877f, 0.05819463f, 0.23054494f, 0.09463147f, -0.00816928f, 0.08704541f, 0.02046293f, -0.00093959f, 
    0.00134906f, 0.08422091f, -0.07356788f, 0.06094581f, -0.17870006f, -0.07981739f, 0.05718254f, 0.06726465f, 
    0.06904417f, -0.21106745f, 0.00874553f, -0.03835083f, -0.01434298f, 0.05774022f, 0.03767160f, 0.18591085f, 
    -0.19914941f, -0.12488772f, 0.01198821f, 0.15013364f, -0.12925403f, 0.08160543f, -0.00590567f, 0.05300011f, 
    0.12308307f, -0.02359215f, 0.07885278f, 0.02106368f, 0.33356792f, 0.04778991f, 0.02272981f, -0.03116303f, 
    -0.12940495f, -0.00984424f, -0.06712010f, 0.07690565f, 0.09270833f, 0.08967780f, -0.08652502f, 0.02611144f, 
    -0.11148829f, -0.03100076f, 0.24680044f, 0.12721771f, -0.06527683f, -0.02741801f, 0.04842206f, -0.15424331f, 
    -0.03676751f, -0.01992904f, -0.10765130f, -0.05387228f, 0.09318792f, 0.11182340f, -0.07021637f, 0.05133783f, 
    0.02508898f, -0.11988810f, 0.04645516f, 0.01914100f, 0.10178236f, 0.01457134f, 0.08876987f, 0.09068857f, 
    0.06424221f, -0.02627300f, 0.22441767f, -0.10414615f, -0.05439113f, -0.07894450f, -0.06129448f, -0.06910039f, 
    0.10411990f, -0.09288983f, -0.05225210f, -0.04347096f, 0.08488940f, 0.07489697f, 0.26481768f, -0.12200151f, 
    0.01081850f, 0.12296779f, -0.06125661f, 0.00462905f, -0.05362694f, -0.01231558f, 0.12140425f, 0.14845222f, 
    0.10706506f, 0.05361884f, 0.02285095f, -0.09850983f, 0.01865877f, -0.04750444f, -0.06215466f, 0.10375422f, 
    -0.01710417f, -0.04502547f, 0.03627875f, 0.03743708f, 0.00203767f, 0.18444051f, 0.20007071f, 0.17802575f, 
    -0.07915889f, -0.02094992f, -0.00349365f, -0.06878459f, 0.02115981f, 0.00834680f, -0.03420002f, -0.00577607f, 
    -0.06059469f, 0.16627978f, -0.03834188f, 0.06579450f, -0.02915046f, 0.17209148f, -0.01750607f, 0.01211906f, 
    -0.00686878f, 0.06308649f, -0.01625373f, -0.02981414f, 0.12960126f, -0.16016451f, 0.06453213f, -0.03576113f, 
    0.09523965f, -0.01826095f, -0.08519778f, 0.16623816f, 0.02166255f, 0.08154905f, -0.04405511f, -0.02570057f, 
    -0.18418211f, -0.05275669f, -0.22206761f, -0.10754655f, 0.25288936f, 0.12451301f, 0.09306974f, 0.00054517f, 
    0.03498426f, 0.06417315f, 0.03247039f, -0.06804235f, 0.07652303f, 0.29421243f, 0.10305601f, -0.21796317f, 
    -0.02301086f, 0.09284187f, 0.01894554f, -0.00843965f, -0.03026286f, 0.07306250f, -0.09654728f, 0.04584389f, 
    -0.08563603f, 0.06622252f, -0.03775708f, -0.02610317f, 0.01278911f, -0.02769963f, 0.09528420f, 0.01058193f, 
    0.00599926f, 0.12842664f, -0.09990161f, 0.11901272f, -0.00830406f, 0.00945495f, -0.03506984f, 0.18959005f, 
    0.13760120f, 0.12730013f, 0.06247585f, -0.12955904f, 0.09290526f, 0.11998228f, 0.03344633f, -0.00133728f, 
    0.02006160f, 0.11345351f, 0.12000775f, 0.15593334f, -0.11455446f, 0.00020283f, 0.01993519f, -0.02684196f, 
    -0.13235156f, 0.07032168f, 0.11746178f, 0.21237122f, -0.13642138f, 0.02561346f, 0.07018312f, 0.02824714f, 
    -0.00308620f, -0.11690301f, 0.07059248f, -0.03565685f, -0.09213314f, 0.01898755f, 0.10326357f, -0.21655303f, 
    -0.12089638f, 0.13846165f, 0.05013326f, -0.26738828f, -0.04196174f, 0.01178155f, 0.03472445f, -0.06026999f, 
    0.07414962f, 0.02177976f, -0.02635165f, 0.10917798f, -0.06944403f, 0.12250052f, 0.17954880f, -0.24443275f, 
    -0.01697329f, 0.08042365f, 0.08929171f, -0.03568171f, 0.08046739f, 0.02131664f, 0.07820835f, 0.14146788f, 
    0.26092279f, -0.09717119f, -0.06835382f, 0.17291585f, 0.11365503f, -0.02890568f, 0.08237277f, -0.00587235f, 
    0.02048516f, 0.02027373f, 0.00345255f, 0.04278614f, -0.32418612f, 0.17241101f, -0.35515282f, -0.14060009f, 
    0.08888313f, 0.14543885f, 0.11893722f, -0.06575900f, -0.04637213f, 0.03095499f, -0.06736832f, 0.00436426f, 
    -0.03736332f, -0.23143725f, 0.05739918f, 0.14428632f, 0.00242076f, 0.02788446f, 0.15241469f, 0.08196697f, 
    -0.01390552f, -0.01837398f, 0.01006727f, 0.03663335f, -0.29891983f, -0.16400820f, -0.03992308f, 0.06452087f, 
    0.10223617f, -0.01731432f, 0.03995924f, 0.00562615f, 0.06693275f, -0.07217599f, 0.06337702f, -0.13394502f, 
    -0.38208419f, 0.01215212f, -0.16207005f, 0.06342690f, 0.12002123f, 0.04301625f, 0.03082664f, -0.14813657f, 
    -0.00850883f, -0.02005679f, -0.06830784f, -0.02094151f, -0.20679827f, -0.18980719f, 0.08972501f, 0.16790600f, 
    0.07458053f, -0.04386675f, -0.02614469f, -0.00406090f, 0.00672253f, 0.10471959f, -0.06818407f, 0.03842217f, 
    -0.16205353f, -0.06207053f, -0.16182187f, -0.01846216f, 0.20708570f, 0.16086856f, 0.04446634f, 0.04738130f, 
    0.02044366f, 0.01184231f, -0.03482781f, -0.00308270f, 0.03006391f, 0.09474730f, 0.15972388f, -0.18955615f, 
    -0.04268624f, -0.02146109f, -0.03970315f, 0.05491583f, 0.09320528f, 0.03583786f, -0.04868529f, 0.05961208f, 
    -0.05901032f, -0.06732501f, -0.03065563f, -0.15444858f, 0.16418882f, 0.03034117f, 0.02650709f, 0.05505675f, 
    -0.00160001f, -0.11793002f, -0.08781476f, 0.05589197f, 0.11257832f, 0.03652989f, 0.14539596f, 0.08909259f, 
    -0.15106535f, -0.00995767f, 0.05823870f, -0.00112021f, -0.11156243f, -0.01907044f, -0.01335195f, 0.06662952f, 
    -0.12007525f, -0.20591396f, 0.05758206f, 0.24944393f, 0.09804542f, -0.01437956f, 0.07141540f, -0.05888351f, 
    0.04474968f, 0.03591409f, 0.08160682f, -0.03105663f, 0.30854481f, -0.01452440f, -0.02514074f, 0.12400273f, 
    0.18855329f, 0.05624964f, 0.01659445f, -0.00284870f, -0.08236830f, -0.04875740f, -0.08214992f, -0.01261081f, 
    0.04360356f, 0.00089297f, -0.13227665f, -0.23511104f, 0.01044621f, 0.07221851f, -0.02471691f, 0.10017299f, 
    0.04654993f, -0.00704126f, 0.22075452f, -0.10245878f, -0.03554678f, -0.13472566f, -0.23086306f, 0.18390068f, 
    0.15962654f, -0.05981743f, -0.11638755f, -0.01732896f, -0.05431605f, 0.04036340f, -0.01462693f, 0.02785646f, 
    0.09062562f, 0.12725012f, 0.17140581f, -0.02260736f, -0.09495559f, -0.04848190f, 0.04262549f, 0.02964965f, 
    0.10815349f, 0.02302351f, 0.07067697f, 0.01327514f, -0.15202101f, -0.09272537f, 0.01252783f, 0.30541846f, 
    -0.08781566f, 0.07238597f, 0.13231429f, 0.05668841f, -0.05170076f, -0.01942033f, 0.14445555f, -0.09953565f, 
    -0.19662952f, 0.01760383f, -0.13846232f, -0.22179520f, -0.00223999f, 0.00782069f, 0.13281737f, 0.15261343f, 
    0.01848899f, -0.00015931f, 0.04818574f, 0.05875735f, 0.09087349f, -0.14294389f, -0.01574771f, -0.08299719f, 
    0.06468981f, -0.03835128f, -0.03370655f, -0.02635975f, 0.03842264f, 0.00603939f, -0.09199866f, -0.04437683f, 
    0.05005867f, -0.01847998f, 0.02268228f, -0.02466783f, -0.01898187f, -0.03162461f, -0.01535266f, -0.05096358f, 
    -0.00081991f, -0.02635351f, -0.03297644f, 0.00203615f, 0.00578035f, -0.03046436f, 0.03270456f, -0.02738237f, 
    0.02943603f, -0.03484708f, -0.04365645f, 0.00615829f, -0.02298052f, 0.03711260f, 0.04393345f, -0.00180715f, 
    0.01680278f, -0.00638602f, -0.04578761f, -0.03330921f, 0.01590990f, -0.04018723f, 0.01495166f, 0.02277321f, 
    -0.01056693f, -0.00158415f, 0.00740267f, -0.04294037f, -0.00794203f, 0.02301608f, -0.00783129f, -0.03256063f, 
    0.02749958f, -0.00204136f, 0.03915467f, 0.03208747f, 0.02027923f, -0.04529496f, -0.03721705f, 0.01130641f, 
    -0.01280108f, 0.01874466f, -0.02092244f, 0.01385758f, 0.02135702f, -0.03208093f, -0.02680320f, -0.04463176f, 
    -0.03129343f, -0.02282001f, -0.00591033f, -0.02393647f, 0.00223555f, 0.02436473f, -0.01135457f, 0.01116399f, 
    0.01804404f, 0.00013148f, -0.03725331f, -0.02233395f, 0.02956305f, -0.03028795f, -0.02470622f, -0.01161748f, 
    -0.03051905f, 0.03579729f, -0.03898596f, 0.03363828f, -0.03273592f, -0.04506665f, -0.02373070f, 0.01898992f, 
    -0.00392434f, 0.00327853f, -0.04849202f, -0.03743205f, 0.02706477f, -0.00243107f, 0.01028789f, -0.01022827f, 
    0.02860855f, 0.03673737f, 0.01568575f, 0.02923634f, -0.00525427f, -0.01024411f, -0.03057321f, -0.00101186f, 
    -0.04600437f, -0.03332565f, -0.04443812f, -0.00727462f, -0.02064792f, 0.02442251f, 0.04671663f, 0.00027030f, 
    0.03428062f, -0.03498247f, 0.01226222f, 0.03252304f, 0.00319379f, 0.00583815f, -0.02003879f, -0.03271030f, 
    0.01761825f, -0.00796825f, 0.00889916f, -0.00397444f, -0.03960872f, 0.01638490f, -0.03448421f, -0.01614163f, 
    0.00021156f, -0.03117769f, 0.01873169f, 0.00725678f, 0.02327258f, -0.04089807f, 0.01208140f, 0.00591814f, 
    0.00107580f, -0.03135490f, -0.01801798f, -0.05021656f, 0.01915117f, -0.00831487f, -0.02394461f, -0.02263558f, 
    -0.02039558f, -0.01209256f, -0.02650639f, 0.04557080f, -0.01131154f, -0.04041636f, -0.01145146f, -0.00079150f, 
    -0.03979341f, 0.03408340f, 0.04443815f, 0.03775227f, 0.01127671f, 0.00341510f, 0.02957048f, 0.01861778f, 
    -0.00646971f, 0.02513894f, -0.03364562f, -0.04695398f, 0.00787811f, 0.00743969f, -0.01066748f, -0.02069942f, 
    -0.02938342f, 0.02405972f, 0.02822238f, -0.04720743f, -0.00369704f, -0.01717659f, -0.01979557f, 0.00534948f, 
    -0.00599612f, -0.02666371f, -0.00988594f, -0.02229350f, 0.04255803f, 0.03062927f, -0.02565002f, 0.02760796f, 
    -0.03225623f, -0.02323105f, -0.03203662f, -0.03597606f, -0.00600649f, 0.00503492f, -0.03678596f, 0.02740074f, 
    0.03586464f, -0.03050215f, -0.01913006f, -0.00009767f, -0.01258540f, -0.04967575f, -0.00318738f, -0.01254365f, 
    -0.04756184f, -0.05285292f, -0.00330830f, 0.01193770f, 0.00904535f, -0.01973410f, 0.04529709f, -0.01143385f, 
    0.02860532f, -0.05395695f, 0.00967803f, -0.01634773f, -0.00848230f, -0.04922540f, -0.02644525f, 0.00502580f, 
    0.04255494f, -0.04495255f, 0.01018002f, 0.04257035f, -0.00896477f, -0.03450323f, 0.04168751f, -0.04815246f, 
    0.02662230f, 0.00626801f, 0.03036065f, 0.05127634f, 0.02824138f, 0.00099560f, -0.03675538f, 0.01744919f, 
    -0.01812333f, 0.02983622f, -0.00308134f, 0.02955405f, -0.05233043f, -0.02776734f, 0.04300868f, -0.01737476f, 
    0.04887139f, 0.02598184f, -0.05170456f, -0.01949302f, 0.03013152f, -0.02557635f, 0.01094702f, -0.01156540f, 
    -0.03086432f, -0.02853314f, -0.00873640f, -0.04393589f, -0.03196757f, -0.04921234f, 0.00072733f, 0.00485809f, 
    -0.05224434f, -0.03950690f, 0.01355517f, -0.02637697f, -0.00797438f, -0.01381231f, 0.03455980f, -0.02377032f, 
    0.02797759f, -0.03987484f, 0.00615410f, -0.01216335f, -0.00980901f, -0.01350217f, 0.04581698f, 0.03945246f, 
    -0.05379312f, 0.04370306f, -0.02329436f, -0.03283213f, -0.02606181f, 0.02788294f, -0.01367418f, -0.01687526f, 
    -0.04606772f, -0.03605840f, 0.04250846f, 0.00028405f, 0.04073288f, -0.02962772f, -0.05365036f, -0.04953077f, 
    0.00744732f, -0.01034934f, 0.04450902f, 0.02009977f, 0.01663645f, -0.01229132f, 0.00036100f, -0.02570170f, 
    0.01181604f, -0.04270268f, 0.03864511f, 0.00294330f, 0.00464737f, 0.03740067f, -0.03263953f, -0.03211277f, 
    0.01878700f, -0.04820814f, -0.02161759f, -0.01303582f, 0.00839418f, 0.01598824f, 0.01250363f, -0.04758478f, 
    -0.04248519f, 0.02616737f, 0.04735462f, -0.04962213f, -0.04518398f, 0.04834118f, 0.00724058f, -0.01395316f, 
    -0.04777422f, 0.00932850f, 0.04104779f, -0.04081706f, -0.02961128f, -0.05505468f, -0.04428823f, -0.02557662f, 
    -0.02771275f, -0.03788859f, -0.02692729f, 0.01719292f, -0.01828514f, 0.01725983f, 0.02860576f, 0.01678452f, 
    -0.02415018f, -0.00721314f, -0.04742932f, -0.02711103f, 0.01527925f, -0.01530798f, 0.03385829f, -0.02930927f, 
    -0.05039814f, 0.01610040f, -0.02512469f, 0.00319711f, -0.00814549f, 0.00315414f, 0.02444774f, -0.04066785f, 
    -0.02991294f, 0.01991471f, -0.01049731f, -0.04628222f, -0.01626708f, -0.00336433f, 0.02190686f, -0.05447868f, 
    0.02647678f, 0.02205367f, 0.01718161f, -0.00388907f, -0.02383477f, -0.01671158f, -0.00558553f, -0.00583389f, 
    -0.04065743f, -0.00335673f, 0.00957519f, 0.00875424f, -0.00598277f, 0.03551415f, 0.03330537f, -0.02121384f, 
    -0.02988766f, 0.02212084f, 0.04489565f, -0.02798788f, 0.02346755f, 0.03197657f, 0.03602038f, -0.01951755f, 
    0.03496723f, 0.04761685f, 0.02078134f, 0.04222906f, -0.05335420f, -0.00294893f, 0.03605849f, 0.00750991f, 
    0.17804153f, -0.08271800f, 0.20450662f, -0.03185317f, -0.03343416f, 0.03898655f, -0.03943714f, -0.04103340f, 
    0.10263489f, 0.04824956f, 0.06912784f, 0.02333020f, -0.18157780f, 0.08847733f, 0.22390312f, 0.10235637f, 
    0.10149991f, 0.13185348f, -0.06940784f, 0.01202307f, 0.12563567f, -0.01551033f, 0.09602410f, 0.17222880f, 
    0.06421188f, 0.01101020f, 0.22453044f, -0.02016639f, -0.00195333f, -0.00171830f, -0.12308577f, 0.07558570f, 
    0.18001294f, -0.01787772f, 0.05930834f, 0.02877573f, -0.28152084f, 0.07654972f, 0.19412622f, 0.23463060f, 
    -0.09484594f, 0.02445617f, -0.00308566f, -0.02868843f, 0.07780048f, 0.04108987f, -0.13459596f, 0.12125573f, 
    0.07753268f, 0.18680571f, -0.13904844f, -0.09168416f, 0.00008370f, 0.07782394f, -0.09674929f, -0.03786402f, 
    0.06279059f, -0.00583337f, 0.07883085f, 0.07684901f, -0.00876384f, -0.28284121f, 0.12634769f, 0.06096642f, 
    0.06146337f, 0.01497462f, -0.06996972f, 0.02278622f, 0.01389012f, 0.02882293f, 0.03808188f, 0.06172925f, 
    -0.14893295f, -0.16415888f, -0.27170306f, -0.24474879f, 0.04238608f, -0.02018586f, 0.00991303f, -0.07408860f, 
    0.06796622f, 0.03635039f, 0.06058902f, 0.00973550f, 0.06894848f, 0.17682965f, 0.16649722f, -0.16511589f, 
    0.07328025f, 0.06289864f, 0.03895688f, 0.04502576f, -0.02477108f, 0.02562422f, -0.11596465f, 0.02655162f, 
    -0.05650068f, 0.05499112f, 0.05279852f, -0.05812607f, 0.12015117f, -0.00215750f, 0.05243740f, 0.08081029f, 
    0.03373107f, 0.09703897f, 0.03504257f, 0.05006430f, -0.01569517f, -0.02447318f, -0.11417432f, 0.02704624f, 
    -0.09638125f, 0.06089367f, 0.14409457f, 0.05735529f, 0.05486311f, 0.18209814f, -0.03057936f, 0.00725064f, 
    -0.12237767f, -0.04001209f, 0.12427718f, 0.05538052f, -0.01418059f, 0.11115374f, 0.03262697f, -0.06174615f, 
    0.04773593f, 0.00680760f, 0.03917153f, 0.24080521f, -0.09435311f, 0.07470012f, -0.03445258f, 0.01601817f, 
    0.06032364f, -0.05893934f, 0.00777782f, 0.04003092f, 0.06472825f, 0.01314626f, 0.01283363f, -0.01609267f, 
    -0.11086394f, 0.09392034f, -0.05516258f, -0.24295473f, 0.00931629f, -0.00182327f, 0.02780118f, 0.06060365f, 
    0.10712352f, -0.05896031f, 0.13519360f, 0.12166643f, -0.17391996f, 0.09671690f, 0.18163452f, -0.17886934f, 
    -0.03075109f, -0.03006123f, -0.01899947f, 0.07075498f, 0.07196727f, 0.10067174f, 0.09096028f, 0.12992552f, 
    0.32133353f, 0.14894275f, 0.03519701f, -0.09337744f, 0.07025331f, 0.00590828f, 0.14539512f, 0.00934876f, 
    0.12990834f, 0.01213060f, 0.01529042f, 0.06137732f, -0.09410946f, -0.03234616f, -0.30372187f, -0.09144516f, 
    0.00045604f, -0.04662708f, 0.00281583f, 0.06845324f, -0.04366861f, 0.05248834f, 0.02366105f, 0.17419305f, 
    -0.05840261f, -0.35672697f, 0.09395851f, 0.06658068f, -0.10184753f, 0.04866474f, 0.08410934f, 0.04187382f, 
    0.06892947f, 0.04867604f, -0.01164706f, 0.09544472f, -0.32463679f, -0.14733867f, -0.08434690f, 0.03830396f, 
    -0.05554253f, -0.00496024f, 0.01684180f, -0.01250997f, -0.01949621f, 0.08857451f, 0.04264761f, -0.01054215f, 
    -0.43627340f, -0.12649208f, -0.28132221f, -0.04394802f, -0.03403961f, 0.07532940f, -0.08691184f, -0.03031180f, 
    -0.03914835f, 0.09555866f, 0.06840515f, 0.05335223f, 0.13064483f, -0.24176739f, 0.01682522f, 0.08824673f, 
    0.09357807f, 0.03456295f, -0.02236774f, -0.02359279f, 0.04911142f, 0.05831016f, -0.10658742f, 0.12203973f, 
    -0.04617745f, -0.00834317f, -0.10547369f, -0.18782935f, 0.13681504f, 0.11734765f, 0.06998808f, 0.07429460f, 
    -0.05250810f, 0.00228460f, 0.10698182f, 0.04121757f, 0.07230002f, 0.03035290f, 0.07191847f, -0.11559530f, 
    -0.10630877f, 0.05105606f, -0.07726311f, 0.08179173f, 0.07383860f, 0.09815332f, -0.04214697f, -0.12832825f, 
    -0.01356838f, -0.02111979f, 0.02761507f, 0.00597563f, 0.11457568f, -0.00352612f, -0.01309736f, 0.05313288f, 
    0.07869922f, -0.03238084f, -0.06108701f, 0.08576899f, -0.11777256f, 0.13101697f, 0.18871483f, -0.20391597f, 
    -0.08690149f, 0.00039673f, 0.02803743f, 0.02801314f, 0.04873579f, -0.02823665f, 0.01207315f, 0.00035677f, 
    -0.34856334f, -0.02910830f, -0.01990897f, 0.32206252f, 0.09333319f, 0.11481638f, 0.08510376f, -0.02282497f, 
    0.03590198f, 0.06177760f, 0.07677585f, 0.08980584f, 0.24707319f, 0.05873395f, 0.01519584f, -0.21686561f, 
    -0.00897092f, -0.01742166f, 0.01992608f, 0.04383845f, -0.03031443f, 0.06749116f, -0.08546263f, 0.07295936f, 
    -0.09695596f, 0.17381036f, -0.02809650f, -0.17355110f, 0.04747286f, 0.03612079f, 0.02446954f, 0.09942003f, 
    0.06343484f, 0.01480328f, 0.11845530f, -0.06559425f, -0.19839180f, -0.25387812f, -0.21514304f, -0.04027381f, 
    0.03204542f, -0.03204457f, 0.01756591f, -0.10058847f, -0.00652322f, -0.04768999f, 0.18881275f, 0.11916444f, 
    -0.27757031f, 0.05349157f, 0.35504571f, 0.06193848f, 0.05776303f, 0.01230240f, 0.06275377f, 0.05068082f, 
    0.01612745f, 0.00481140f, 0.11465040f, -0.00938216f, 0.21083792f, 0.02680459f, -0.04183575f, 0.15072769f, 
    -0.10872640f, -0.01397652f, 0.03998050f, 0.15526144f, -0.09772550f, 0.01558260f, 0.00075104f, -0.01362926f, 
    -0.10481843f, -0.15542063f, -0.03216702f, 0.01571183f, 0.05528437f, -0.04698660f, 0.13831218f, 0.15150599f, 
    0.01120035f, -0.03153946f, -0.09317884f, 0.12755486f, 0.12025516f, -0.08579223f, -0.04495785f, -0.14866421f, 
    0.06441664f, -0.04846695f, -0.05506072f, -0.05145157f, -0.02138441f, 0.05846807f, 0.00430052f, 0.07971125f, 
    0.20324190f, 0.04151968f, -0.12037618f, 0.15797299f, 0.00218736f, 0.04957382f, 0.06641195f, 0.07076418f, 
    0.13417061f, -0.02197876f, -0.21768221f, 0.11546106f, 0.27592197f, 0.09576683f, -0.11323991f, 0.00773199f, 
    0.06064465f, -0.01356155f, -0.12470867f, -0.07777087f, 0.04280653f, -0.04908978f, -0.11775409f, 0.15158878f, 
    -0.05148568f, -0.09067167f, 0.06581277f, 0.13735497f, 0.13358858f, -0.13106386f, -0.03744078f, 0.17842099f, 
    0.16206929f, 0.14483446f, 0.04598974f, -0.18627073f, 0.56519979f, -0.01303021f, -0.04989425f, 0.13800406f, 
    0.03770586f, -0.00383868f, 0.12208390f, -0.06698640f, -0.02985134f, -0.04971335f, -0.01674741f, 0.00368708f, 
    -0.21980225f, -0.02686513f, -0.03962715f, 0.08069354f, 0.13516463f, -0.02090990f, 0.19917080f, -0.09295425f, 
    0.04192075f, 0.07598300f, -0.03121433f, 0.13568102f, 0.24124430f, -0.03513646f, 0.06188551f, -0.06348666f, 
    0.23604529f, 0.02802544f, -0.08689600f, 0.20516163f, -0.16803172f, 0.24694863f, 0.02186102f, 0.05659497f, 
    0.32245007f, 0.20488687f, 0.01231100f, 0.03200106f, -0.04955721f, 0.06318399f, 0.02955460f, 0.10472371f, 
    0.02803605f, 0.02083266f, -0.07874696f, -0.01902696f, 0.22972311f, -0.10695134f, -0.02551816f, 0.07946984f, 
    -0.01919692f, 0.03840991f, -0.07016208f, -0.04040599f, 0.02737421f, -0.01379109f, -0.01383922f, -0.10937107f, 
    0.01970957f, -0.11421825f, 0.20919544f, 0.05760029f, 0.02858021f, -0.01877882f, 0.03841176f, -0.02785560f, 
    -0.10487621f, 0.13337474f, 0.05991996f, 0.12356270f, 0.14102836f, 0.16407768f, 0.06638009f, -0.10908590f, 
    0.03661147f, 0.08764492f, 0.02635249f, -0.16019769f, 0.08749216f, 0.10698198f, 0.01229808f, -0.06056203f, 
    0.15639544f, 0.17344704f, -0.05361510f, -0.03814899f, 0.03288587f, -0.03347838f, 0.07693716f, -0.01253747f, 
    0.09432945f, 0.05372316f, 0.08531368f, 0.12731911f, -0.16830374f, 0.05513062f, -0.05990068f, -0.00416357f, 
    0.06768004f, 0.01373539f, 0.04365468f, -0.22443913f, -0.03766024f, -0.03382899f, 0.06759336f, -0.14286953f, 
    0.24197607f, -0.40392298f, 0.16634952f, 0.09353319f, -0.06704608f, 0.07709569f, -0.01837937f, -0.02144513f, 
    0.02821273f, 0.17096812f, -0.03952550f, -0.03486377f, 0.25120977f, -0.01766423f, 0.00481562f, 0.26023653f, 
    0.04621619f, 0.05513953f, -0.05651015f, 0.07589305f, -0.04584758f, -0.05626202f, -0.01028709f, 0.08163029f, 
    0.04400165f, -0.08583636f, -0.04107163f, 0.07037054f, 0.09002139f, 0.04615804f, 0.08356462f, -0.05721133f, 
    -0.18797804f, 0.06361787f, 0.05154241f, 0.16147658f, 0.19296107f, 0.34884092f, -0.05846344f, 0.06378277f, 
    -0.01477566f, 0.01834315f, -0.04111453f, -0.11790064f, 0.05126992f, 0.02819118f, -0.12699267f, -0.08357657f, 
    -0.31117392f, -0.22061829f, -0.11786062f, -0.32433149f, 0.07969818f, -0.05316558f, 0.03337326f, 0.00826615f, 
    -0.06477465f, 0.06124616f, 0.10485520f, 0.01189817f, -0.01702861f, -0.02810544f, -0.08767296f, 0.06974757f, 
    0.03587915f, -0.07715768f, 0.02895651f, -0.00237575f, 0.05831899f, 0.02035642f, -0.00612848f, -0.13628358f, 
    -0.16966861f, -0.01929966f, -0.11025631f, 0.00272155f, -0.04363218f, -0.05125198f, -0.00007002f, -0.15924484f, 
    0.00444975f, -0.04642666f, -0.08273979f, 0.02015794f, -0.29058504f, -0.22770220f, -0.02623238f, -0.08742223f, 
    0.06246920f, -0.13413157f, 0.16079877f, -0.13756020f, 0.03114454f, 0.10523366f, -0.02382468f, 0.02238364f, 
    -0.00543134f, 0.20639625f, 0.04433298f, -0.07983173f, 0.09421436f, 0.02431224f, 0.00603633f, 0.05046159f, 
    0.01177286f, -0.07697552f, -0.03364942f, -0.09956250f, 0.15242417f, -0.05535536f, 0.05205186f, 0.14557794f, 
    0.07731915f, 0.01369234f, -0.01672963f, 0.04878780f, -0.01178227f, 0.13045187f, -0.13626191f, 0.11803589f, 
    0.38212648f, -0.31538543f, -0.07098752f, -0.01134673f, -0.05458851f, -0.03468579f, -0.11760215f, 0.03423841f, 
    -0.02652122f, -0.06691293f, -0.14939371f, -0.02605462f, 0.16674900f, -0.02575031f, -0.08303116f, 0.08540088f, 
    0.09299024f, -0.03627370f, 0.00167160f, -0.09390911f, -0.01810235f, -0.04427398f, 0.04245933f, 0.12188321f, 
    0.25129575f, 0.16614403f, 0.00361032f, -0.26199478f, 0.00475330f, -0.04549015f, -0.09883646f, -0.08048695f, 
    0.04522566f, -0.12284042f, 0.03649586f, 0.08222751f, -0.00831766f, 0.05211828f, 0.14830473f, -0.02140631f, 
    0.04369295f, -0.02699334f, -0.00324434f, 0.01901088f, 0.01884906f, 0.05299593f, 0.01513918f, 0.01874097f, 
    -0.14703621f, 0.14341535f, -0.27170190f, -0.22565150f, -0.07010654f, -0.00804021f, -0.07654510f, 0.02459319f, 
    -0.06609110f, 0.00410288f, 0.12899798f, 0.01078972f, 0.03749337f, 0.23835593f, -0.11003083f, -0.09268374f, 
    -0.11960205f, 0.00615090f, -0.07672868f, -0.07796884f, 0.09225693f, -0.08071666f, 0.04102236f, -0.21049975f, 
    0.14281793f, 0.09669121f, 0.00080046f, -0.02625841f, -0.08998805f, -0.10823119f, 0.08463966f, 0.15404038f, 
    0.06733402f, 0.04543873f, 0.08806901f, 0.05117114f, -0.32249954f, -0.06375200f, -0.15052183f, -0.01548711f, 
    0.05776927f, 0.08525883f, 0.20155060f, -0.01016397f, 0.09104033f, -0.05624638f, 0.05248763f, -0.02736735f, 
    -0.01325196f, 0.27394736f, -0.16664504f, -0.02214438f, -0.00797930f, 0.06050877f, -0.13990667f, 0.10254718f, 
    0.01739162f, 0.18994398f, -0.01931422f, 0.03513839f, -0.20395911f, -0.06252590f, 0.02279496f, 0.03789260f, 
    -0.03919260f, 0.12445539f, -0.05754033f, 0.07339784f, 0.00003885f, 0.04157864f, -0.07596339f, -0.13483883f, 
    -0.19888735f, 0.16349587f, -0.12048770f, -0.14725748f, -0.01007308f, 0.01651186f, 0.08111697f, 0.06317077f, 
    0.04028432f, 0.01777707f, 0.01068175f, -0.03404636f, 0.11832202f, -0.13120137f, -0.21848701f, -0.12210930f, 
    -0.15329716f, -0.04489696f, 0.15095259f, 0.15848534f, -0.09202717f, 0.04759688f, -0.01823766f, -0.01496744f, 
    0.05415142f, -0.11363374f, -0.13642021f, 0.23356514f, 0.08075505f, -0.04186726f, -0.01080480f, -0.02419779f, 
    0.06045240f, 0.04709886f, -0.04493228f, 0.04550991f, 0.19158064f, -0.20573597f, -0.17784852f, -0.18485478f, 
    -0.07764801f, -0.03968746f, -0.02231565f, 0.08073656f, 0.03249844f, 0.12207838f, 0.16932590f, 0.03525030f, 
    -0.09839661f, -0.23527916f, 0.20302592f, -0.03781917f, 0.03846168f, -0.14832254f, -0.03020273f, 0.06474951f, 
    0.05900918f, -0.02533186f, -0.03904595f, 0.04148133f, 0.00258144f, 0.27786228f, -0.28258857f, -0.03323199f, 
    -0.00414873f, -0.08221993f, 0.17078097f, -0.02026329f, 0.07181267f, 0.14254396f, -0.08155461f, -0.17567711f, 
    -0.18700396f, 0.23026848f, 0.18523456f, 0.10859934f, 0.01269648f, -0.00082260f, 0.01350085f, -0.05576277f, 
    -0.07628395f, 0.01989700f, 0.07220085f, -0.10888194f, 0.09700927f, 0.01158884f, -0.11269493f, -0.10319505f, 
    0.02732928f, 0.00142761f, 0.05633056f, 0.09561322f, 0.07341865f, 0.04929966f, 0.07100137f, 0.01766738f, 
    0.17785813f, -0.01339725f, -0.01137540f, 0.10033943f, -0.04552560f, 0.04035208f, -0.07334887f, 0.07318436f, 
    -0.04843725f, -0.07862341f, -0.03602804f, -0.04772806f, 0.26576212f, 0.05878683f, 0.03574796f, 0.12495121f, 
    -0.06790388f, -0.03464751f, -0.10118707f, -0.02246340f, 0.02852034f, -0.02696848f, 0.07266714f, -0.06548471f, 
    0.22131641f, -0.07201137f, -0.14122462f, 0.22284321f, -0.01798509f, -0.09919317f, 0.00183108f, 0.02124228f, 
    0.10848782f, -0.10998511f, 0.00568962f, -0.08472428f, 0.28495368f, 0.12830350f, 0.08098976f, 0.08482098f, 
    0.06061753f, 0.11194594f, 0.14545932f, 0.05894836f, 0.06757084f, 0.02339474f, 0.14514802f, 0.09603290f, 
    0.44938445f, -0.25760114f, 0.07423214f, 0.23107965f, -0.06043877f, 0.03533648f, 0.00966008f, 0.05886793f, 
    0.00449149f, 0.00740424f, -0.06737950f, 0.00564600f, 0.15903328f, -0.03971729f, -0.03838798f, 0.08271949f, 
    0.05033145f, -0.01722779f, 0.07213743f, 0.02777717f, -0.03391035f, 0.01529689f, -0.14479345f, -0.07533041f, 
    -0.09554943f, -0.06526840f, -0.08487684f, 0.30376551f, 0.01326230f, -0.06156976f, 0.00470487f, 0.05552574f, 
    -0.01117369f, 0.02297082f, 0.05345207f, -0.00722365f, -0.37567669f, -0.02918111f, 0.14082707f, -0.01588801f, 
    0.04880458f, 0.02532867f, -0.05606302f, 0.09404245f, -0.02357753f, -0.04763439f, 0.07001834f, -0.01817170f, 
    0.37335211f, 0.20755470f, -0.29233989f, 0.12558414f, 0.10086780f, 0.04857259f, -0.05721288f, -0.11561696f, 
    -0.06320328f, -0.02603726f, 0.02003629f, -0.05987405f, -0.00390595f, 0.10197620f, -0.06310664f, 0.09751587f, 
    -0.03105004f, -0.02219599f, -0.07792797f, 0.05445894f, 0.01126241f, -0.08766113f, 0.00540323f, -0.12401591f, 
    0.17380533f, 0.21655357f, 0.24063756f, -0.10600338f, -0.09406673f, -0.03059199f, 0.08596839f, 0.04004194f, 
    -0.10554553f, 0.05394035f, -0.13182157f, -0.05860870f, 0.18308415f, 0.34674498f, 0.05489996f, -0.05037016f, 
    -0.01874544f, -0.04685874f, 0.11355093f, -0.09432835f, -0.16580668f, -0.05310269f, 0.06150962f, -0.03304695f, 
    0.08916225f, 0.09636971f, -0.04308057f, -0.02865182f, -0.02975387f, -0.02400609f, -0.05548467f, -0.09986197f, 
    0.03909618f, -0.03212290f, 0.04262239f, 0.00767033f, 0.06426862f, -0.15913393f, 0.01413457f, 0.21459882f, 
    0.01335529f, 0.02127899f, -0.02793047f, 0.00495051f, 0.03889198f, -0.07027950f, 0.04519149f, -0.08329864f, 
    0.02774472f, -0.17515583f, -0.06563222f, 0.14256017f, -0.08157223f, -0.05333021f, 0.02030914f, -0.12124082f, 
    0.01128407f, -0.06817164f, -0.11588936f, -0.06380066f, 0.00168953f, -0.06019425f, 0.00431218f, 0.22420196f, 
    -0.03570593f, -0.01512145f, 0.08313260f, 0.00039303f, 0.08573478f, 0.04716558f, -0.02590034f, 0.00404346f, 
    0.00752375f, 0.01589091f, 0.12489629f, -0.21029645f, -0.04222265f, -0.06442514f, -0.05090704f, 0.02770670f, 
    0.04765797f, -0.03398360f, -0.01808376f, -0.01571762f, -0.07393145f, 0.04797123f, 0.00831736f, 0.12964845f, 
    0.03498300f, -0.00570071f, 0.01386934f, -0.05900855f, 0.09442356f, -0.10734353f, 0.01684049f, -0.19153547f, 
    -0.37388372f, 0.12023593f, 0.12691841f, 0.19284400f, -0.14323926f, 0.04809598f, 0.04275025f, -0.00539348f, 
    -0.01010158f, 0.03884323f, -0.14309703f, 0.16310102f, -0.09086560f, 0.17631719f, 0.22237091f, 0.14173076f, 
    -0.10324543f, 0.03659422f, -0.01931498f, 0.02985595f, 0.15054080f, 0.14307261f, -0.13276622f, -0.02231729f, 
    0.19470555f, 0.02040102f, -0.14680260f, 0.00582621f, 0.05953302f, 0.08000903f, -0.11084480f, 0.09049195f, 
    0.13037825f, 0.01053802f, -0.01016487f, 0.14085843f, 0.26985520f, -0.00820867f, 0.07569436f, 0.13517623f, 
    -0.02836177f, -0.01201273f, 0.00039617f, -0.06325426f, 0.11228108f, 0.07020970f, -0.03494790f, -0.00315842f, 
    -0.26509583f, 0.31936929f, -0.04642124f, 0.05809710f, 0.02933554f, 0.05367364f, -0.06510051f, -0.09316756f, 
    -0.02536790f, -0.02260034f, 0.01404845f, -0.09411856f, -0.03788068f, 0.23970443f, 0.11157311f, -0.02478231f, 
    -0.00182280f, 0.13014579f, 0.02752682f, -0.05095937f, 0.08105541f, 0.04246315f, 0.11397143f, 0.04102523f, 
    -0.09433102f, 0.06337064f, -0.05102769f, -0.02557931f, 0.01544058f, 0.14127466f, 0.09589647f, -0.02205177f, 
    -0.07765630f, -0.06846359f, -0.09456238f, 0.09792134f, -0.19216827f, 0.04552279f, -0.12913424f, -0.08058042f, 
    -0.00234966f, 0.05328894f, 0.11287195f, 0.03522902f, -0.03233388f, -0.04668971f, 0.06040968f, 0.00050650f, 
    -0.05897066f, 0.07688186f, 0.03989641f, 0.18568341f, 0.04050364f, 0.05561574f, -0.03679135f, -0.02348770f, 
    -0.01663120f, -0.08702569f, 0.01196079f, -0.01666302f, -0.11085322f, -0.10633286f, -0.14984527f, -0.09238018f, 
    0.07116994f, -0.06992444f, 0.13835119f, -0.06771620f, 0.01178340f, -0.03939816f, 0.00971312f, 0.06495398f, 
    0.31118315f, -0.17585257f, 0.09415043f, 0.23260254f, 0.06380431f, 0.15042754f, 0.05455124f, 0.03160992f, 
    -0.00348863f, 0.00396165f, -0.04573342f, -0.01494306f, 0.37226343f, -0.05862007f, 0.06835876f, -0.04892555f, 
    0.13960569f, -0.05703683f, -0.00619932f, -0.24741976f, -0.13080448f, 0.02195501f, -0.03012183f, -0.01735993f, 
    0.44707742f, 0.05019540f, 0.15603895f, 0.18814452f, -0.12881511f, -0.05900795f, -0.05462134f, 0.02463491f, 
    -0.01778828f, -0.08939347f, 0.02565560f, -0.00819808f, -0.23848033f, -0.25970209f, 0.05183563f, -0.22288747f, 
    -0.12670779f, 0.00995090f, -0.05181547f, -0.01176682f, -0.01785128f, -0.07432812f, -0.03267555f, 0.06289692f, 
    0.03494914f, 0.06104792f, 0.00021624f, 0.09074141f, 0.01631782f, -0.01793670f, -0.04172799f, -0.09319863f, 
    -0.03988392f, 0.04219456f, 0.08502060f, -0.10163128f, 0.18015982f, 0.19078468f, 0.07639031f, 0.12624250f, 
    0.02288134f, 0.01733933f, 0.07875234f, 0.00867951f, -0.06651326f, -0.02474993f, 0.05775945f, -0.04997500f, 
    -0.07681213f, -0.04955509f, -0.13019274f, 0.16733524f, 0.20812048f, 0.04872391f, -0.04060569f, -0.06893951f, 
    -0.07254522f, -0.01386915f, 0.02077452f, -0.03260082f, 0.32214332f, -0.02275708f, -0.16342716f, 0.04064216f, 
    -0.08345439f, -0.00025328f, 0.06277960f, 0.00432147f, 0.04704897f, 0.09857441f, -0.06153244f, 0.20511203f, 
    -0.06481633f, -0.33975452f, -0.02642783f, -0.04098418f, 0.09357519f, -0.02437375f, -0.08099888f, -0.09989952f, 
    -0.04231142f, 0.03005003f, 0.05528241f, -0.07212251f, -0.05442607f, 0.02033871f, 0.04570935f, -0.11981834f, 
    0.04244403f, 0.08141121f, -0.14104652f, 0.07841446f, -0.04039735f, -0.12820926f, 0.07051431f, 0.05346429f, 
    0.00213976f, 0.11839119f, 0.18584089f, 0.14779451f, 0.11324806f, -0.02569377f, 0.03640020f, -0.07758346f, 
    -0.11343792f, -0.00347176f, -0.09394197f, -0.02237477f, 0.38752660f, 0.01638085f, -0.03954969f, 0.10564248f, 
    -0.05947395f, 0.02089979f, -0.03791935f, 0.20882791f, 0.06675003f, 0.05140549f, 0.09750386f, 0.07760461f, 
    0.06006173f, 0.22840397f, -0.02096081f, 0.26196936f, 0.16330963f, 0.07817029f, 0.09680000f, 0.03576537f, 
    -0.01533789f, 0.11221435f, -0.05153157f, 0.09796059f, -0.20418741f, 0.17388038f, 0.00787526f, -0.04614079f, 
    -0.07433829f, -0.02038092f, -0.00647079f, 0.12396764f, -0.01714637f, 0.00120266f, 0.05788391f, 0.03172611f, 
    -0.12787828f, 0.14134224f, -0.04917504f, 0.07794263f, 0.01753952f, -0.05880995f, 0.04288649f, 0.22714140f, 
    -0.04479083f, 0.04318615f, 0.23262860f, -0.12245278f, 0.26315373f, 0.11786201f, -0.00252489f, -0.03265458f, 
    -0.05493978f, 0.06211119f, 0.08115979f, 0.02982801f, -0.02863438f, -0.08224384f, -0.02014777f, -0.17443052f, 
    0.28912190f, 0.18864636f, 0.10026519f, 0.18773831f, -0.05044603f, -0.06780270f, 0.02181333f, -0.11699808f, 
    -0.05573235f, -0.08605186f, -0.00100908f, -0.00252057f, -0.17394328f, -0.04386217f, -0.05710644f, -0.02009922f, 
    0.03101251f, 0.01988881f, 0.08564302f, -0.15477122f, -0.05328019f, -0.10193731f, -0.03728117f, -0.08237153f, 
    0.36052671f, -0.21521924f, -0.02663089f, -0.09653949f, -0.05803599f, 0.00550078f, -0.03498799f, -0.03354304f, 
    0.02522293f, 0.04680263f, -0.12180007f, -0.16806322f, 0.20565912f, 0.06610273f, -0.13629568f, 0.03900131f, 
    0.20202687f, 0.01577400f, 0.00594671f, -0.05937864f, -0.18256803f, -0.04930713f, 0.05417870f, -0.09713795f, 
    -0.23276307f, -0.16588521f, -0.09113676f, -0.04742586f, 0.10739683f, -0.09493178f, 0.02269694f, 0.10551584f, 
    -0.10024887f, -0.04878945f, 0.02224571f, -0.05288769f, 0.03314537f, 0.10647282f, 0.16095486f, 0.07398139f, 
    0.00522509f, 0.09344498f, -0.00702316f, 0.00079566f, -0.00338038f, 0.06889110f, 0.00966650f, 0.03016310f, 
    -0.00919826f, -0.06747896f, 0.07748411f, 0.00995373f, -0.02860315f, 0.05048081f, 0.00689775f, 0.04661720f, 
    -0.06050279f, 0.11078530f, -0.14178173f, 0.05010685f, 0.22008362f, 0.21994938f, 0.05169539f, 0.08957481f, 
    -0.06829111f, -0.05701267f, 0.06553953f, 0.12679745f, -0.14758965f, -0.03509146f, -0.03706508f, -0.05133926f, 
    -0.09553050f, -0.04475467f, -0.20669246f, -0.10451493f, 0.00515649f, 0.05359332f, 0.02005367f, -0.06602038f, 
    -0.01345526f, -0.00568782f, 0.11115680f, 0.02076380f, 0.31376976f, 0.16509099f, -0.02015129f, -0.05086894f, 
    0.07404818f, -0.10469517f, 0.04418815f, -0.05166335f, -0.08743578f, 0.12310276f, -0.04291893f, 0.20102100f, 
    0.13261470f, -0.14264372f, -0.05021089f, 0.01871032f, 0.01031321f, 0.05110868f, -0.06957013f, -0.05846900f, 
    -0.01510212f, -0.04911826f, -0.11203685f, 0.08752801f, -0.29897195f, 0.05672132f, -0.02290587f, -0.03172151f, 
    0.03993270f, 0.17771831f, 0.02808104f, 0.03231478f, -0.01303311f, 0.00947195f, 0.08584008f, 0.06575067f, 
    -0.14790267f, 0.02921809f, 0.13250548f, -0.02710937f, -0.04891210f, 0.07791758f, 0.06057382f, -0.04572852f, 
    -0.04054943f, 0.05985262f, 0.11585884f, 0.00821688f, -0.07671481f, -0.04174952f, 0.20246419f, -0.07413044f, 
    -0.09790747f, -0.02304731f, 0.07986376f, 0.08044777f, 0.12516204f, 0.07859761f, 0.14844278f, -0.01729834f, 
    0.26519310f, -0.01097789f, -0.16216849f, -0.06527565f, -0.04526578f, 0.14474075f, 0.07995117f, -0.01153691f, 
    -0.15668824f, -0.09937208f, -0.01973570f, 0.15338694f, -0.22753601f, 0.02674233f, 0.03408189f, -0.00693075f, 
    -0.05860463f, 0.01418214f, -0.05632561f, 0.15129009f, 0.11076637f, 0.01494584f, 0.12462181f, 0.01001064f, 
    0.05237997f, 0.23808350f, 0.08031397f, 0.17228511f, 0.06239655f, 0.05734695f, -0.15250862f, 0.12639777f, 
    -0.06773664f, -0.09578660f, 0.07391741f, -0.02522843f, -0.07518840f, -0.00999382f, -0.03062874f, 0.15972416f, 
    -0.02251864f, -0.05864791f, 0.17407690f, -0.11556840f, 0.00768249f, -0.11124137f, 0.04026958f, -0.05579744f, 
    -0.31979841f, -0.06395587f, -0.13061360f, -0.14066502f, 0.17032833f, 0.02017344f, 0.03694869f, -0.06328499f, 
    -0.06380039f, 0.06455754f, 0.07025754f, -0.00681261f, 0.01704355f, 0.09232519f, -0.04198316f, -0.13958155f, 
    0.00333513f, 0.06397061f, 0.17755026f, 0.07587592f, 0.02302110f, 0.01300284f, -0.05462188f, 0.13130869f, 
    -0.05701206f, 0.03904574f, -0.11631157f, -0.05029319f, 0.07806550f, 0.05091880f, -0.01866221f, 0.07280946f, 
    0.09321565f, -0.05998530f, 0.05370641f, -0.09677064f, 0.03440784f, -0.06273977f, -0.10791675f, 0.04915654f, 
    0.00474851f, 0.04917195f, -0.02251534f, 0.12818047f, 0.02477846f, -0.11133943f, 0.05769469f, 0.10436907f, 
    0.00029542f, -0.11732591f, 0.07894284f, -0.04592863f, -0.08782136f, 0.04275825f, -0.05260184f, 0.05519943f, 
    -0.06976685f, -0.00366689f, -0.01596354f, -0.13897853f, -0.07561812f, 0.01938637f, 0.04984353f, -0.06122464f, 
    -0.09582464f, 0.05750456f, 0.12149976f, 0.13266741f, -0.00251999f, -0.02081591f, -0.01209854f, 0.14436549f, 
    -0.22395281f, 0.51579589f, -0.25029662f, -0.14038861f, 0.00561637f, -0.01670871f, 0.06121634f, 0.15369390f, 
    -0.01209557f, -0.01851155f, 0.01280683f, -0.06854917f, -0.23069119f, 0.04221610f, 0.05636005f, -0.20192461f, 
    -0.13717814f, 0.04092193f, -0.01095514f, 0.03350097f, 0.11247363f, 0.08093984f, -0.02126690f, -0.12211473f, 
    0.15150413f, -0.02808721f, 0.14758670f, 0.10406748f, 0.00821645f, 0.01688986f, 0.04888227f, 0.07372900f, 
    0.09471457f, -0.04670774f, -0.09020501f, -0.11637099f, -0.24118438f, -0.05991479f, -0.15434194f, -0.03237358f, 
    0.07363430f, 0.14902037f, -0.00527463f, 0.09550258f, -0.02612445f, -0.04331072f, 0.24201588f, 0.13350439f, 
    0.38369110f, -0.15319067f, 0.22041327f, 0.14425640f, -0.03651487f, -0.02112004f, 0.06617763f, -0.02343685f, 
    0.04243532f, -0.07100056f, -0.11508285f, 0.07196802f, -0.15303035f, -0.02385844f, 0.26194176f, 0.02030768f, 
    -0.02185884f, 0.00898635f, 0.04088891f, -0.12482931f, 0.01175060f, -0.00668977f, 0.01839158f, 0.10934049f, 
    -0.09251130f, 0.06101286f, 0.09812284f, 0.07458447f, -0.02529988f, 0.03317469f, -0.03511974f, 0.14178975f, 
    -0.09268814f, 0.22418208f, 0.04081676f, -0.02591561f, 0.17115046f, 0.11212926f, 0.11214712f, 0.19239737f, 
    0.02069472f, 0.16068372f, -0.08911023f, 0.14196749f, 0.04806936f, -0.08223148f, 0.07651645f, 0.05636607f, 
    0.02686741f, -0.08932934f, -0.07938347f, 0.06119668f, -0.11313054f, 0.03388942f, 0.05702224f, 0.00415095f, 
    -0.07685253f, 0.16757655f, -0.02337690f, 0.01755818f, 0.07233911f, 0.05431096f, -0.10673020f, -0.15336369f, 
    -0.10300279f, 0.10712615f, 0.01616816f, 0.09538351f, 0.03968721f, -0.05607705f, 0.02580472f, -0.16379026f, 
    -0.34574860f, 0.28198391f, 0.05452126f, 0.07032152f, 0.03232878f, -0.07984101f, 0.13528989f, -0.02365699f, 
    -0.01248698f, 0.18026409f, -0.03394930f, 0.01354898f, -0.16654822f, -0.11423436f, 0.15833469f, -0.10520787f, 
    -0.12032191f, -0.05894821f, 0.07002061f, 0.09277715f, 0.00693923f, 0.04413274f, 0.13183531f, -0.04139908f, 
    0.00934761f, -0.20668186f, 0.10146438f, 0.11882809f, -0.02169115f, 0.08777140f, 0.05356891f, 0.07247111f, 
    -0.06045414f, 0.17578438f, 0.04579353f, -0.03333661f, 0.25079197f, 0.01361688f, -0.08062372f, 0.11783513f, 
    -0.08541309f, 0.00675450f, 0.06086467f, 0.06528541f, -0.02211913f, -0.04222618f, -0.06417609f, -0.02366756f, 
    -0.04154479f, -0.03731366f, 0.22639397f, 0.09048013f, -0.02999786f, 0.02345059f, 0.13003623f, 0.10163035f, 
    0.04331128f, -0.05849174f, -0.04202687f, -0.01818861f, -0.10874312f, -0.16806963f, 0.09315059f, 0.01888686f, 
    0.15945239f, 0.18752795f, -0.00426856f, -0.00848348f, -0.04805030f, 0.09680045f, 0.04593729f, 0.10983963f, 
    0.28687352f, 0.08965015f, -0.02383831f, -0.05059943f, 0.12263515f, 0.05189726f, -0.04653955f, -0.10047457f, 
    -0.05128643f, -0.00422214f, -0.04870532f, -0.03445567f, 0.30277789f, 0.05141321f, 0.10944904f, 0.14875676f, 
    -0.02362359f, -0.03688345f, -0.09282847f, 0.03815781f, -0.08084907f, 0.01812173f, -0.03575086f, 0.02871319f, 
    -0.24668166f, -0.01365643f, -0.00537821f, 0.04714122f, 0.02251585f, -0.01527963f, 0.09941116f, 0.04658543f, 
    -0.02820721f, -0.08060084f, -0.00731036f, 0.04153391f, -0.04538815f, 0.02265006f, 0.13166496f, 0.02154602f, 
    0.10968212f, 0.05654974f, 0.08708408f, -0.07830475f, -0.02553503f, -0.00939015f, 0.09538215f, 0.07305939f, 
    -0.03085970f, -0.08805473f, -0.06540912f, 0.19346109f, 0.00889978f, 0.10451391f, 0.11656477f, 0.01704686f, 
    -0.01526012f, 0.08035064f, 0.02476757f, 0.14438613f, -0.04199881f, 0.08969720f, 0.03552748f, -0.03873360f, 
    0.02026968f, -0.13334754f, 0.07396832f, 0.00948628f, 0.22782029f, 0.03503943f, 0.04618160f, 0.14133096f, 
    0.11382966f, 0.03318804f, -0.15166676f, -0.11204366f, -0.08283681f, 0.09951701f, 0.03201790f, -0.07664466f, 
    0.07843760f, -0.00713636f, 0.09204923f, 0.09151911f, -0.21870445f, 0.03644408f, 0.03131276f, 0.07351842f, 
    -0.11600275f, 0.01041028f, 0.04137077f, 0.03199544f, 0.10766851f, 0.08573950f, 0.02523107f, 0.06810620f, 
    0.21307065f, 0.01980698f, -0.00460620f, 0.12018237f, 0.20539403f, 0.01077294f, -0.09498286f, -0.05862436f, 
    0.01591768f, -0.14903979f, -0.03139009f, 0.03393976f, 0.14109741f, 0.08794364f, -0.08530529f, 0.11074048f, 
    0.11850799f, -0.02335995f, -0.00120979f, -0.12106520f, -0.11587756f, 0.01393605f, 0.08883493f, -0.08210900f, 
    0.20954701f, -0.05358970f, -0.02946748f, -0.07086918f, -0.03869782f, 0.00253613f, 0.02598418f, 0.04219058f, 
    -0.01440186f, -0.03275838f, 0.05339867f, -0.04039975f, 0.00805105f, -0.13309984f, 0.02770375f, -0.22629741f, 
    -0.05224826f, 0.00514462f, 0.01038340f, 0.01544649f, 0.12937462f, -0.06371421f, -0.02188694f, 0.05178527f, 
    -0.04391423f, 0.02033501f, 0.05544218f, -0.05805653f, 0.02331835f, 0.03682944f, -0.11872518f, 0.04136146f, 
    -0.11477453f, -0.10786135f, 0.11288791f, -0.09323702f, 0.16598897f, 0.06324701f, -0.09334899f, 0.07791770f, 
    -0.14776672f, 0.02164989f, 0.12430169f, 0.16925989f, -0.02630140f, -0.04266323f, -0.03926866f, -0.02001217f, 
    -0.01689388f, -0.06700262f, -0.09945843f, -0.13849084f, 0.13912126f, -0.05574547f, -0.06111814f, 0.02261500f, 
    0.03427213f, 0.06559868f, -0.01995512f, -0.12196982f, -0.01108498f, 0.14878824f, -0.18574201f, -0.11938981f, 
    -0.11866257f, 0.09787066f, -0.02575720f, -0.01326159f, 0.05255282f, -0.03440163f, 0.00246577f, 0.22464094f, 
    -0.24935076f, 0.18847531f, -0.22406383f, -0.09468751f, -0.07065192f, -0.04164116f, -0.03216798f, 0.05694744f, 
    -0.05612089f, 0.02091669f, 0.00321065f, -0.17590491f, -0.19970925f, 0.13280605f, 0.01512808f, -0.03827119f, 
    -0.06047561f, -0.01207662f, -0.10024732f, 0.00703130f, 0.05281457f, 0.01536069f, -0.00749297f, -0.09765972f, 
    0.14150023f, 0.18448107f, 0.02212838f, 0.07210846f, 0.08264919f, 0.09334309f, -0.03538199f, 0.06998818f, 
    -0.06153128f, -0.08788741f, -0.09996707f, -0.18562749f, 0.28383681f, -0.31922436f, -0.10350506f, 0.06036670f, 
    0.01817356f, 0.01142180f, -0.05744766f, 0.22828688f, 0.01664643f, 0.11013510f, 0.21541554f, 0.23896626f, 
    0.24254198f, -0.10182627f, 0.19543619f, 0.17643856f, 0.06460427f, -0.06461323f, 0.09633525f, 0.04076770f, 
    0.17402633f, 0.01210651f, -0.04396304f, -0.00023343f, -0.12871365f, 0.06020573f, 0.14445665f, -0.05189622f, 
    -0.07344726f, -0.03162812f, -0.05331491f, -0.05584642f, 0.03647271f, 0.11237383f, -0.06891634f, 0.29281372f, 
    -0.20134671f, 0.07993849f, -0.08754265f, 0.08895752f, -0.06478854f, -0.07551621f, -0.03474225f, 0.08193603f, 
    -0.04584662f, 0.19286633f, 0.18920326f, -0.00520679f, 0.11797563f, -0.01982041f, -0.07005525f, 0.08616267f, 
    0.12451290f, 0.02439681f, -0.09181423f, 0.02362442f, 0.02549628f, -0.12283787f, 0.05813213f, -0.05500010f, 
    0.24031231f, 0.20535851f, 0.18939976f, 0.00366945f, -0.09821738f, 0.02516485f, 0.07432190f, -0.02627384f, 
    -0.01820343f, -0.03140572f, 0.11660991f, -0.01434565f, -0.02901026f, -0.08694517f, -0.13434896f, -0.04200145f, 
    -0.12254766f, 0.06863458f, 0.05209689f, -0.01982096f, 0.00611828f, -0.05030958f, -0.04968040f, -0.21123432f, 
    0.07444508f, 0.19082746f, 0.11477930f, 0.13872345f, -0.05620745f, 0.01327176f, 0.03865062f, -0.05364946f, 
    -0.03146747f, 0.16725628f, -0.16910425f, -0.03544761f, 0.05915972f, 0.00846307f, -0.07139662f, -0.37407878f, 
    0.11685929f, -0.06778133f, -0.03953005f, 0.00629614f, 0.08156417f, 0.09450980f, 0.11335775f, 0.01926750f, 
    0.05467020f, -0.02426588f, -0.03909919f, 0.02125130f, 0.01375907f, -0.00791088f, -0.09921084f, -0.00305631f, 
    -0.14119090f, 0.03484757f, 0.14794515f, -0.02886467f, 0.11602153f, 0.33098862f, 0.16596389f, -0.11618446f, 
    -0.06763388f, 0.06594259f, 0.04681413f, 0.10864259f, 0.12334412f, 0.00419338f, 0.09640139f, -0.00657604f, 
    -0.01550467f, -0.00817693f, 0.07026841f, -0.10075036f, -0.06680989f, -0.05040811f, 0.06697356f, 0.05723974f, 
    -0.01860019f, -0.03056421f, -0.10268027f, 0.03287189f, -0.12234882f, -0.15353332f, 0.28764665f, -0.20784153f, 
    0.02951637f, 0.05951348f, 0.11430323f, -0.00248098f, -0.07064021f, -0.07280386f, 0.21612298f, -0.09830128f, 
    0.02343051f, 0.05273224f, -0.01572162f, -0.12602924f, 0.03114150f, -0.00716624f, -0.01120302f, -0.08686437f, 
    -0.07631419f, -0.11057311f, 0.07049539f, 0.03178216f, 0.22253615f, 0.15652283f, -0.11161449f, -0.12442950f, 
    -0.02903193f, -0.03758993f, -0.06107407f, -0.00861929f, -0.02783663f, 0.08489957f, -0.00816126f, 0.21315117f, 
    -0.04019073f, -0.18739781f, 0.04913093f, 0.14082813f, 0.09476475f, -0.03724609f, -0.04943733f, -0.00169610f, 
    0.00234252f, -0.00692910f, -0.01493815f, 0.08352787f, -0.35567740f, -0.16317070f, 0.00642450f, -0.08046432f, 
    0.07034586f, 0.22291026f, 0.03191519f, -0.05019236f, 0.01351618f, 0.06587125f, 0.10619518f, 0.11423963f, 
    -0.05771604f, 0.00724346f, 0.02592313f, -0.03563619f, -0.03382517f, -0.00893769f, -0.00253920f, -0.03354535f, 
    -0.03840954f, -0.01423105f, -0.05626007f, 0.01110359f, -0.03252050f, -0.05436856f, -0.05780614f, -0.02164152f, 
    -0.03158695f, -0.03537701f, -0.02273465f, -0.01636431f, -0.02375558f, 0.01736010f, 0.04405642f, 0.01288205f, 
    -0.01836886f, -0.02441388f, 0.00229144f, -0.04599321f, -0.02873678f, 0.00919092f, -0.03453510f, -0.05356748f, 
    -0.01067356f, 0.04531886f, 0.01384992f, -0.00183441f, 0.00228266f, -0.00521707f, -0.02938361f, 0.00033289f, 
    -0.01531999f, 0.04701222f, 0.03717124f, 0.00340367f, 0.02579484f, -0.01448392f, 0.00092472f, -0.04429547f, 
    -0.01085960f, 0.01989532f, 0.02809376f, -0.01341304f, -0.00505919f, -0.01946742f, 0.03889666f, -0.01115053f, 
    -0.01693703f, 0.00659249f, -0.03455142f, -0.02129462f, 0.00597400f, -0.03552055f, 0.03374131f, -0.04915075f, 
    -0.05344636f, -0.00287720f, -0.02664441f, -0.02016629f, -0.04088601f, -0.02402427f, -0.04353829f, -0.00017344f, 
    -0.03646748f, -0.02928507f, -0.04476222f, 0.02576997f, 0.00050241f, -0.02691486f, 0.03411790f, -0.03018061f, 
    0.00235972f, -0.05755097f, -0.03124050f, 0.03046299f, -0.04907039f, -0.00469409f, -0.00714599f, 0.01068234f, 
    0.01734711f, 0.01704101f, -0.03997944f, -0.05213161f, -0.01317856f, -0.06074032f, 0.01039723f, -0.01034085f, 
    0.03140292f, -0.02093548f, -0.02989642f, -0.04175457f, -0.00778848f, -0.01062736f, -0.04113391f, 0.03429483f, 
    0.01004282f, -0.00902249f, -0.05790736f, 0.02837753f, 0.00168170f, 0.01886623f, 0.03469349f, -0.03918332f, 
    -0.00007397f, 0.02747986f, -0.00992739f, -0.00145261f, -0.05217453f, -0.05614556f, 0.02808808f, 0.02742583f, 
    0.02080187f, -0.03989927f, -0.05540790f, -0.04088453f, -0.06060301f, -0.02537994f, 0.01754757f, 0.01030149f, 
    -0.01915204f, -0.01051885f, -0.05163188f, -0.03338325f, -0.00890524f, 0.02055615f, -0.01753512f, -0.00273211f, 
    0.02953682f, 0.01780371f, 0.01984962f, -0.00415474f, -0.06011721f, -0.05973131f, -0.05616641f, -0.04688311f, 
    0.03644824f, -0.01662772f, 0.04066065f, -0.03964364f, 0.00692603f, -0.01481866f, 0.01576075f, -0.04184246f, 
    0.03078437f, -0.00341854f, -0.01821501f, -0.04271050f, 0.02192815f, -0.00617235f, -0.03968190f, 0.04247750f, 
    0.02449930f, 0.04607991f, -0.05006066f, 0.04672308f, -0.05085971f, -0.00326672f, 0.03207254f, 0.04053716f, 
    -0.04669632f, -0.02076357f, -0.01469249f, -0.02470663f, -0.01071801f, -0.01973285f, -0.00001847f, 0.03638197f, 
    -0.05724781f, 0.01854152f, -0.03050988f, -0.05622530f, -0.03775802f, -0.01083737f, -0.00826387f, 0.03338429f, 
    0.01958066f, -0.01851900f, -0.00429990f, 0.03620388f, -0.02545135f, 0.03323138f, -0.00231762f, 0.01391727f, 
    0.02765526f, 0.03154269f, -0.04634911f, -0.06028659f, -0.03142421f, 0.01065252f, 0.01911633f, -0.04618604f, 
    -0.02500399f, 0.02039002f, 0.02261173f, -0.02004608f, -0.02016388f, -0.01564563f, -0.05011760f, 0.00856627f, 
    0.00480338f, -0.02290483f, 0.00410880f, 0.00986301f, -0.00257273f, 0.01353339f, -0.01430877f, -0.00211094f, 
    0.02326967f, -0.02684098f, 0.01304128f, -0.02862263f, -0.02870273f, 0.02454862f, -0.05466011f, 0.02543669f, 
    0.02209495f, 0.01513140f, 0.01161954f, 0.02285924f, 0.02740721f, 0.01855746f, 0.01324342f, -0.02062357f, 
    -0.01942829f, -0.03110477f, -0.02389551f, -0.03170295f, 0.02534313f, -0.01589748f, 0.00184057f, -0.04022000f, 
    -0.03929670f, -0.03921465f, 0.02333156f, 0.03808944f, -0.04117180f, -0.04334191f, -0.02909534f, 0.02088746f, 
    0.01985749f, -0.05429410f, 0.00019489f, -0.00813453f, -0.04832717f, 0.03090533f, -0.04614968f, 0.03306037f, 
    0.03781131f, -0.04618815f, -0.02792407f, 0.03567552f, 0.02937488f, 0.03026271f, 0.03265584f, 0.00666556f, 
    -0.02447044f, 0.03933938f, -0.00627263f, -0.04796452f, -0.03846123f, 0.03843898f, 0.01010348f, 0.00536329f, 
    0.01995837f, -0.02480049f, 0.02910542f, -0.05525256f, -0.05969746f, -0.05739700f, 0.03166298f, -0.03321297f, 
    -0.03822863f, -0.05613900f, -0.03357499f, 0.03952454f, 0.00104856f, -0.02673793f, -0.02038981f, -0.04941921f, 
    0.01502740f, 0.03178822f, -0.04082203f, 0.00670788f, -0.04694760f, -0.02256152f, -0.04491404f, -0.01921177f, 
    0.02924515f, -0.01775124f, -0.04223057f, -0.05291822f, 0.03838784f, -0.00353597f, 0.03832856f, -0.00916611f, 
    0.03589333f, 0.02050533f, -0.00491285f, 0.00186928f, -0.01378060f, 0.03469417f, -0.01238168f, 0.03298835f, 
    -0.03816106f, 0.04060310f, -0.03942469f, 0.00977409f, -0.04107774f, -0.04030848f, 0.01243099f, 0.02456166f, 
    0.00318312f, -0.02259200f, 0.00224462f, -0.04126677f, 0.01008785f, 0.02367330f, -0.04427106f, -0.02223207f, 
    0.03526296f, -0.06043035f, 0.00288423f, -0.01233826f, -0.02957521f, -0.01113717f, 0.00323601f, -0.05156709f, 
    -0.00288068f, -0.01212800f, 0.03676995f, 0.02168410f, -0.01601940f, -0.04114475f, 0.01878777f, -0.02626828f, 
    -0.03757086f, 0.01472897f, -0.00110771f, -0.04343747f, 0.01203930f, -0.04841578f, -0.04868610f, -0.00042532f, 
    0.01710347f, 0.03817614f, 0.01470112f, -0.00812299f, 0.00214046f, -0.02636568f, 0.03145928f, 0.00015038f, 
    -0.01263098f, -0.00757259f, -0.01390758f, -0.05623947f, -0.05901584f, -0.03980505f, -0.00907425f, 0.02808421f, 
    -0.00174156f, 0.01384998f, 0.03360501f, 0.02590676f, -0.05195786f, -0.02225960f, -0.05087898f, 0.03866577f, 
    -0.01067945f, 0.00859600f, 0.03289858f, 0.00450146f, 0.02427115f, -0.04464852f, -0.02428206f, -0.01744147f, 
    0.22729599f, -0.12290531f, -0.08130293f, -0.08356637f, 0.07326700f, 0.01124398f, 0.14307687f, 0.05543609f, 
    -0.03858283f, 0.04023243f, -0.06741821f, 0.04840269f, -0.11443607f, 0.11137769f, -0.11340604f, 0.06889924f, 
    0.02220914f, -0.14602213f, 0.02219656f, 0.00479499f, 0.10866243f, -0.05241713f, 0.00477290f, -0.11778535f, 
    0.34356457f, -0.05121234f, -0.07968856f, -0.16857408f, -0.17894626f, -0.04531016f, 0.00465723f, -0.12113826f, 
    -0.03272638f, 0.02439642f, -0.05276647f, -0.01094022f, -0.00815929f, 0.01643868f, -0.00932701f, -0.08073682f, 
    -0.09641797f, -0.06741921f, -0.02340472f, 0.11369825f, 0.02846722f, -0.13746959f, 0.00274202f, 0.00038655f, 
    0.04065760f, 0.02042550f, 0.05430398f, 0.16719289f, 0.21887425f, -0.07354090f, -0.09090800f, -0.09765805f, 
    -0.03252522f, 0.00743930f, 0.13798727f, -0.06108976f, -0.04821853f, -0.19433805f, 0.15622498f, -0.03964702f, 
    0.21313861f, -0.07610370f, 0.15600961f, -0.12587222f, -0.02794994f, -0.00747309f, 0.12954451f, -0.13330978f, 
    0.13089348f, 0.20984368f, -0.03075548f, -0.23140910f, 0.12998891f, 0.14993133f, 0.03234280f, 0.00477940f, 
    0.06865308f, 0.20385644f, -0.10379422f, 0.07258619f, 0.10053136f, 0.05570109f, -0.08295958f, -0.08246502f, 
    -0.06645151f, 0.03419340f, -0.07225124f, 0.00438307f, 0.07247878f, -0.07199934f, -0.09794688f, -0.03721170f, 
    -0.16791973f, -0.10463918f, 0.22071670f, -0.08359413f, 0.15961163f, 0.12948895f, -0.07300422f, -0.04981703f, 
    0.02441105f, 0.09141277f, 0.06694253f, -0.03926251f, 0.44050542f, -0.03692811f, -0.06261057f, 0.02745661f, 
    0.02968579f, 0.00654280f, -0.00033279f, 0.02014791f, 0.02252037f, -0.02298187f, -0.03546542f, -0.06226845f, 
    -0.08148594f, 0.39818278f, 0.19157003f, -0.05549850f, 0.00045334f, -0.14918405f, -0.05722736f, 0.00249099f, 
    -0.03393487f, -0.06387110f, -0.06402165f, 0.07204210f, -0.42428765f, 0.38486579f, 0.08687013f, -0.12411980f, 
    -0.10566579f, 0.05502916f, -0.02050707f, 0.00488768f, 0.06984918f, -0.08246688f, -0.05900579f, 0.05088802f, 
    -0.08012861f, -0.02512831f, 0.12506880f, -0.13810356f, -0.11813596f, -0.07755436f, 0.07747731f, 0.02100465f, 
    0.04593118f, 0.08557054f, -0.01101297f, -0.12926951f, 0.07297423f, 0.05968781f, -0.10251307f, 0.10243560f, 
    -0.19038299f, -0.01400375f, -0.12403624f, 0.11969019f, -0.07622156f, 0.19534180f, 0.07021584f, -0.23683850f, 
    0.07426924f, 0.07202721f, 0.07859517f, 0.10826119f, 0.03739750f, 0.06782992f, 0.01469871f, 0.13521534f, 
    0.08084641f, -0.15972528f, -0.02827675f, -0.07563527f, 0.22812168f, -0.06249728f, -0.01962211f, 0.00052051f, 
    0.04400333f, 0.19533415f, -0.07309471f, 0.16138919f, -0.03106476f, 0.10497025f, 0.05975887f, 0.15470698f, 
    0.41408813f, 0.02345691f, -0.19268495f, 0.01658882f, -0.01084109f, -0.00429494f, 0.17332701f, -0.21879335f, 
    0.00442476f, 0.11193316f, 0.11943506f, 0.03802799f, 0.43412119f, -0.09669166f, -0.07449527f, -0.08539025f, 
    0.01114404f, 0.04101545f, -0.02034287f, 0.00537039f, -0.02650636f, 0.07427806f, 0.05923916f, 0.12638190f, 
    0.61426651f, 0.20048335f, 0.05404452f, 0.08775107f, -0.03991647f, 0.16482069f, 0.01114404f, 0.08568975f, 
    -0.06646705f, 0.12932324f, -0.01208706f, -0.00291550f, -0.26086363f, -0.10621116f, 0.00621543f, -0.05316330f, 
    -0.07291041f, 0.14895716f, -0.02115911f, -0.10001395f, 0.09268674f, -0.09491505f, -0.19098561f, 0.05949070f, 
    0.04467267f, 0.10017109f, 0.01821139f, -0.09803830f, -0.08818663f, 0.06158967f, 0.05800796f, -0.06483252f, 
    0.02194188f, 0.01790775f, 0.03389431f, 0.00899073f, 0.09065416f, -0.00871257f, 0.09269384f, -0.23402870f, 
    0.16131553f, -0.04681392f, -0.02898675f, 0.06842809f, 0.10935191f, 0.10879619f, 0.01641907f, -0.11036476f, 
    -0.24301349f, -0.39494604f, 0.09569031f, 0.02528183f, 0.02984465f, -0.08375344f, 0.07525957f, 0.15187509f, 
    0.17918827f, 0.21901084f, -0.13078058f, -0.12193335f, 0.05001900f, 0.26503232f, 0.09549226f, -0.11592369f, 
    -0.00959857f, -0.18255593f, -0.07197476f, -0.01274415f, 0.01874880f, 0.06100807f, -0.05087770f, 0.05759569f, 
    -0.36972114f, 0.09598473f, 0.05189937f, 0.10614624f, -0.03709638f, -0.09328561f, -0.03410918f, -0.14103790f, 
    -0.23073576f, 0.01665077f, 0.07939089f, 0.01928429f, -0.13758034f, 0.19923261f, -0.01629354f, -0.07109603f, 
    -0.08809990f, 0.04577435f, 0.16929550f, 0.03060134f, 0.13135672f, -0.03211623f, -0.01461032f, -0.10706776f, 
    -0.03456391f, 0.16512102f, -0.21348524f, 0.03867263f, -0.17198467f, -0.11381808f, -0.02398372f, -0.02286414f, 
    0.01537280f, 0.00874426f, 0.06993148f, -0.00683561f, 0.20661061f, -0.07519887f, -0.03437199f, -0.04415417f, 
    -0.08750442f, 0.15426348f, 0.17940427f, 0.01302228f, 0.14402962f, -0.02787901f, 0.05286328f, -0.10596787f, 
    -0.12349081f, 0.07402834f, -0.09624783f, 0.08184180f, 0.02306569f, -0.05276391f, 0.02145224f, -0.07619344f, 
    -0.15631154f, 0.09349172f, 0.02315731f, 0.07299197f, -0.39197063f, 0.12884901f, 0.12711495f, -0.07315433f, 
    0.10887934f, -0.05423591f, -0.00068770f, 0.06789836f, 0.08223445f, 0.10333278f, 0.07252871f, 0.05661976f, 
    -0.03098359f, 0.05182548f, -0.17765285f, 0.07870059f, 0.01266245f, 0.07155889f, -0.02566421f, -0.00170193f, 
    0.06101260f, -0.04167448f, -0.01280162f, 0.00923666f, 0.19211441f, -0.16919512f, 0.02299285f, 0.01343347f, 
    -0.02124968f, 0.10436843f, 0.06190099f, -0.05503491f, -0.19876757f, -0.05573362f, 0.01610667f, 0.03119465f, 
    -0.03498545f, 0.00167009f, -0.00946946f, -0.04845612f, -0.04076878f, -0.01964572f, -0.02668595f, 0.00049337f, 
    0.02403270f, -0.00071963f, -0.03897462f, 0.02810392f, 0.00617974f, 0.00892814f, -0.00555380f, -0.01052492f, 
    0.00109053f, -0.02573329f, 0.03682722f, 0.02520732f, 0.01910342f, 0.04332886f, -0.05416045f, -0.02978950f, 
    -0.02973858f, -0.03375681f, -0.01817985f, 0.02102013f, -0.00869941f, 0.01302760f, 0.01974984f, 0.02500136f, 
    -0.05495436f, 0.02092162f, 0.02330695f, 0.03844031f, -0.01102761f, 0.00579222f, -0.04123749f, 0.00183807f, 
    0.03112886f, -0.01460074f, -0.03994388f, 0.00175556f, 0.03376538f, 0.03329453f, -0.01608292f, 0.02462659f, 
    -0.02100062f, 0.00077736f, -0.03651833f, -0.01504280f, 0.00425332f, 0.01676895f, -0.03080605f, 0.03573750f, 
    -0.00062434f, -0.03491149f, -0.01119809f, 0.01763870f, -0.02650843f, -0.03206448f, -0.02823189f, 0.04627432f, 
    -0.03210002f, -0.05132183f, 0.02148320f, 0.03958637f, -0.01717487f, -0.02013843f, 0.01398271f, -0.03831005f, 
    0.03630714f, 0.01111613f, -0.00176797f, -0.03782628f, -0.04402892f, 0.01880177f, 0.01905614f, -0.00618524f, 
    -0.00938231f, 0.00897933f, -0.01391882f, -0.03516834f, -0.01623755f, -0.04260872f, 0.00065530f, -0.05395139f, 
    0.03022368f, 0.02471666f, 0.00696882f, -0.02422310f, 0.03129640f, -0.00842265f, -0.00326825f, 0.04067430f, 
    -0.00568344f, 0.00674352f, -0.03094794f, -0.04573999f, 0.02357176f, 0.04336472f, -0.01510704f, -0.00670068f, 
    -0.04515054f, -0.02567785f, -0.00466816f, -0.05565308f, -0.00455938f, 0.02866418f, 0.03441602f, 0.00558755f, 
    0.00009188f, 0.01797338f, -0.04732690f, 0.01046730f, 0.00903025f, 0.02946784f, -0.04465607f, 0.02365720f, 
    -0.04820599f, -0.03841755f, 0.00488862f, -0.00545471f, 0.01361045f, 0.04387169f, -0.04521864f, -0.03936082f, 
    -0.02091621f, -0.03071640f, -0.01223527f, -0.03921262f, -0.02941014f, -0.00538880f, 0.02374026f, -0.04898269f, 
    -0.04146459f, -0.04678040f, 0.00604673f, -0.04632255f, -0.05209461f, -0.01482391f, -0.00513579f, -0.02097334f, 
    -0.04496073f, 0.01921154f, -0.05462312f, -0.05176200f, 0.00719696f, -0.03928320f, 0.00557338f, -0.02692097f, 
    -0.03799887f, -0.03859081f, -0.00871094f, 0.03909159f, -0.03926349f, -0.03053838f, 0.02668777f, 0.01936763f, 
    0.01877625f, -0.02707747f, 0.01564910f, -0.03556816f, -0.05054584f, 0.04276973f, -0.04128256f, -0.04391102f, 
    0.01779665f, 0.02010741f, 0.03775479f, 0.02610079f, -0.05511869f, 0.03608247f, 0.00204815f, -0.00650606f, 
    -0.02926784f, 0.00301119f, -0.04997210f, -0.00699337f, -0.00574258f, -0.02373273f, -0.03791117f, -0.03209484f, 
    0.02715490f, -0.04898008f, 0.01144460f, -0.02084383f, -0.03293158f, 0.02516249f, 0.04029129f, -0.00164437f, 
    0.04338233f, 0.00311009f, 0.01298586f, -0.04424392f, 0.01604796f, -0.00363756f, 0.01504640f, 0.01267172f, 
    0.01647790f, -0.04489071f, -0.00975070f, 0.03846528f, -0.02631850f, 0.00328183f, -0.03172598f, -0.04052359f, 
    0.01626069f, -0.04392933f, -0.04491350f, 0.02307712f, 0.01516521f, -0.03037746f, 0.01335277f, -0.02406100f, 
    -0.04828080f, -0.04048239f, -0.03657664f, 0.01409686f, 0.00104847f, -0.01398456f, 0.03355161f, 0.00964039f, 
    0.03728725f, 0.03270032f, 0.00720162f, -0.04288965f, -0.04558805f, 0.02109785f, -0.03892694f, -0.00332537f, 
    -0.00631874f, -0.04390246f, -0.01618584f, 0.02288478f, 0.01799583f, 0.03821993f, -0.04399282f, -0.00541813f, 
    -0.00865020f, 0.02353983f, 0.00900945f, -0.02536518f, -0.01602891f, -0.03941572f, -0.04620075f, -0.01888385f, 
    0.03211246f, -0.02165177f, -0.01871513f, 0.03724945f, -0.04978234f, -0.02807177f, -0.03657160f, -0.01540325f, 
    0.03668341f, -0.01273721f, 0.02381188f, 0.03069006f, 0.03827119f, -0.03731660f, 0.01147473f, 0.03774909f, 
    0.03485579f, 0.02839336f, -0.01902492f, -0.05573909f, 0.02198508f, -0.04603972f, 0.02472261f, 0.03427594f, 
    0.02326810f, -0.03061211f, 0.03986276f, -0.00784317f, -0.00027470f, -0.02004631f, 0.00876683f, 0.02742602f, 
    0.02937697f, -0.04118918f, -0.03149202f, 0.00850730f, 0.03457778f, 0.04018485f, -0.00717321f, -0.03978385f, 
    0.04586116f, -0.05205264f, 0.01827282f, -0.01918305f, -0.05037585f, 0.00432044f, -0.04896484f, -0.00601204f, 
    0.04619006f, 0.00289397f, 0.02226118f, 0.01572176f, -0.02207697f, 0.04090396f, 0.00163220f, 0.00818135f, 
    -0.02610591f, 0.00523674f, 0.03683653f, -0.05324802f, 0.01045687f, 0.00611324f, -0.04253940f, -0.05189616f, 
    0.03127260f, -0.00849263f, -0.00565090f, -0.04952766f, -0.02282308f, 0.04071411f, -0.02497024f, -0.01302774f, 
    0.02685351f, -0.03916801f, -0.02818155f, -0.00110917f, -0.02161232f, 0.02934843f, -0.05108501f, 0.00545512f, 
    -0.04449004f, -0.00517433f, 0.04477451f, 0.03745300f, -0.00458142f, 0.03284580f, -0.04543363f, 0.02030083f, 
    -0.01906901f, -0.04551844f, -0.00974230f, -0.00228988f, 0.01361563f, -0.02832584f, -0.03168044f, 0.03159739f, 
    -0.04076938f, 0.03211845f, -0.03501341f, 0.01733459f, -0.04099882f, 0.03585165f, -0.00293847f, 0.01225663f, 
    -0.01567518f, 0.03147940f, -0.02259636f, 0.00449968f, 0.00828814f, 0.02926306f, 0.00819859f, 0.00837434f, 
    0.03182439f, -0.04193890f, -0.01683418f, 0.04141657f, 0.02098230f, -0.00634670f, 0.02866274f, -0.03119485f, 
    0.04219745f, 0.04311159f, 0.04281101f, -0.02205329f, 0.00425853f, 0.02727943f, 0.04138297f, 0.03642093f, 
    0.02798639f, 0.03243706f, -0.04827004f, -0.03468170f, 0.03015161f, 0.03656161f, 0.00330974f, -0.04607167f, 
    -0.03326595f, -0.04908005f, 0.03214297f, -0.01190291f, 0.05019714f, -0.00076074f, -0.01895258f, -0.05378353f, 
    -0.00387573f, 0.02247533f, -0.03965224f, 0.02939290f, -0.01782795f, -0.00116916f, 0.02165504f, -0.03377534f, 
    0.00250211f, 0.00401369f, 0.04458423f, -0.05768301f, -0.04474909f, -0.00255244f, -0.05851686f, 0.02665608f, 
    -0.04111030f, 0.02366058f, 0.02013728f, -0.01198552f, 0.04670469f, -0.02690576f, 0.00589542f, 0.00219774f, 
    -0.02749310f, -0.03487896f, -0.02077049f, 0.02095539f, 0.03632067f, 0.00580412f, 0.04341288f, 0.01753586f, 
    -0.02330288f, 0.03387015f, -0.04367908f, 0.00589554f, -0.01443010f, 0.02922065f, 0.02072925f, -0.03697038f, 
    0.00816893f, -0.03383748f, 0.02969004f, -0.03549726f, -0.01973162f, 0.00114178f, -0.05868325f, 0.03077185f, 
    -0.04988063f, -0.00282567f, -0.06003833f, 0.02009482f, -0.04149482f, -0.02390168f, 0.01278128f, 0.02645766f, 
    0.00481967f, -0.04904698f, 0.03512140f, 0.04089846f, -0.04633603f, -0.04313890f, 0.00743930f, -0.01499874f, 
    0.01313274f, -0.00501182f, 0.04077438f, -0.02785228f, -0.03709075f, -0.04742120f, 0.03071646f, -0.02422471f, 
    0.00065896f, -0.02358417f, 0.00416094f, -0.01335998f, 0.03980702f, -0.04478509f, 0.01589298f, 0.00666442f, 
    -0.03327871f, -0.03446829f, 0.02744937f, -0.02207568f, -0.02255347f, 0.03185924f, 0.00464583f, 0.00231843f, 
    0.00495016f, -0.01968789f, -0.01776165f, -0.01164694f, -0.02871298f, 0.01866046f, -0.02328498f, 0.01512839f, 
    0.00231380f, -0.02188417f, -0.03064249f, -0.00737745f, -0.01487592f, -0.04426289f, -0.03670633f, 0.03175725f, 
    -0.02173842f, -0.02769249f, -0.05794437f, -0.01817799f, 0.03026828f, -0.05258029f, -0.04587391f, -0.03752491f, 
    -0.03015979f, -0.04033206f, -0.05537317f, 0.03928337f, -0.00496738f, 0.02074665f, 0.00638333f, -0.00485109f, 
    -0.03864503f, 0.03074174f, -0.05150726f, 0.00656951f, -0.02407147f, -0.05141506f, -0.02941142f, 0.01876184f, 
    0.00056845f, -0.05380913f, -0.05712483f, -0.02943334f, 0.04456054f, 0.01722653f, 0.03242822f, -0.03767546f, 
    -0.01389822f, -0.00431120f, 0.03223082f, 0.01790766f, 0.02103279f, 0.01958138f, 0.01114795f, -0.00663401f, 
    0.04295099f, 0.01617091f, -0.02519113f, -0.04342594f, -0.01450625f, 0.01651131f, 0.03184039f, 0.03778494f, 
    0.02368511f, 0.03732174f, 0.00420711f, -0.04707618f, -0.01818454f, 0.03740453f, -0.00961935f, 0.02440909f, 
    0.03846668f, -0.04986377f, -0.01839306f, 0.02351796f, -0.03384291f, -0.00611217f, 0.02967281f, -0.02118142f, 
    -0.02474456f, 0.02136168f, 0.02840611f, -0.03068462f, -0.00183938f, -0.01886580f, -0.01338421f, -0.02831254f, 
    -0.04337960f, -0.01473040f, 0.01317658f, 0.01013180f, 0.02776246f, 0.03211522f, -0.03346749f, -0.05253025f, 
    0.00412981f, 0.02330860f, 0.01995628f, -0.03088797f, -0.04575810f, 0.03418555f, -0.05139966f, -0.06059051f, 
    0.02343978f, 0.03478323f, 0.02054686f, 0.01572822f, 0.01457131f, 0.01785160f, -0.03106080f, 0.02380041f, 
    0.04484057f, -0.01703610f, 0.00250394f, 0.02420113f, 0.03720582f, 0.01468083f, 0.03117542f, -0.00295502f, 
    0.02531419f, -0.06040262f, -0.04620109f, -0.01970037f, -0.02631546f, 0.03015306f, 0.01508883f, 0.03185895f, 
    0.00822593f, -0.02033274f, 0.00264349f, -0.04922096f, -0.03113994f, -0.00278885f, 0.02191638f, -0.02991050f, 
    0.02801716f, -0.03796099f, -0.04238687f, -0.05966118f, 0.02229286f, -0.03825325f, 0.02778172f, 0.01692936f, 
    0.01933371f, 0.00812666f, 0.03055892f, 0.03222222f, -0.02846943f, -0.05988748f, 0.01887020f, -0.00803573f, 
    -0.03231084f, -0.00165439f, 0.01690068f, -0.03281211f, 0.01601503f, -0.04837502f, -0.03313466f, -0.03932865f, 
    0.00219149f, 0.02697996f, 0.03782374f, 0.01451457f, 0.03547221f, -0.03366797f, -0.03788202f, 0.02663550f, 
    -0.00284483f, 0.00198358f, 0.01276246f, 0.01673434f, -0.01190044f, 0.04559643f, 0.00167050f, -0.05057502f, 
    0.04220666f, -0.02552610f, -0.05363549f, 0.02891740f, -0.00033898f, 0.01643889f, 0.03353998f, -0.05440526f, 
    0.02796150f, 0.00191618f, 0.01516634f, 0.03621384f, -0.03827145f, -0.03457296f, 0.00622756f, -0.01665742f, 
    0.02096980f, 0.02688110f, -0.01674966f, 0.02841968f, 0.02032820f, 0.02754393f, -0.03128266f, -0.05569475f, 
    0.03525533f, -0.01807421f, -0.04857923f, -0.01345931f, -0.04116803f, -0.02639232f, 0.01423632f, -0.03558910f, 
    -0.02367543f, 0.00073505f, 0.00279554f, -0.00476106f, 0.03807263f, 0.01713748f, -0.04587240f, -0.02827241f, 
    0.01129926f, 0.02138192f, -0.00008899f, 0.03355331f, 0.03127740f, -0.02054246f, -0.05561870f, -0.01809564f, 
    0.00975668f, 0.04259456f, 0.01232110f, 0.03457000f, -0.00829456f, -0.03066069f, 0.00082470f, 0.00213561f, 
    -0.02004414f, 0.01559299f, -0.04339278f, -0.00984928f, -0.04554592f, 0.03487682f, 0.01976126f, -0.00534236f, 
    0.02177703f, -0.03810264f, 0.04634380f, 0.00793332f, 0.00018563f, 0.03878548f, -0.02236774f, -0.02873448f, 
    0.03251320f, -0.02114116f, -0.04166239f, -0.00403598f, -0.00637903f, 0.01072513f, 0.02916764f, 0.03822011f, 
    -0.05714862f, 0.03199001f, -0.04946052f, -0.00111733f, 0.04402957f, 0.03333359f, -0.05219903f, 0.01781414f, 
    -0.05563678f, -0.05254310f, -0.04190307f, -0.03647193f, 0.02378725f, 0.00665908f, 0.04394894f, -0.00980766f, 
    -0.03877020f, -0.02465271f, 0.02201807f, -0.03867753f, 0.02227710f, -0.01981144f, 0.02706066f, 0.03093301f, 
    -0.04831206f, -0.03152803f, -0.02850429f, -0.02343548f, 0.01669584f, -0.03843945f, 0.03783437f, -0.02730707f, 
    0.04058134f, 0.02976017f, 0.01229111f, -0.01508900f, -0.03072455f, -0.02471799f, 0.02326976f, -0.01481822f, 
    -0.05103581f, -0.03582247f, 0.03306187f, -0.01287365f, -0.00636041f, 0.03704809f, -0.00674293f, 0.04701070f, 
    -0.01032294f, 0.01476636f, 0.02821393f, -0.04329108f, -0.04617943f, 0.02178852f, -0.05120957f, 0.03049551f, 
    0.01124076f, -0.00086744f, -0.03875034f, -0.00606959f, -0.04199936f, 0.02082375f, 0.01957729f, 0.02408458f, 
    -0.02321670f, 0.02183280f, -0.04186536f, -0.02710044f, -0.04901902f, -0.02215291f, 0.05584114f, -0.03159354f, 
    0.00094673f, 0.02355235f, 0.03507104f, 0.04336538f, -0.01103501f, 0.02342385f, 0.00268111f, -0.01542562f, 
    0.04587838f, -0.00210147f, 0.01861861f, -0.04763771f, -0.01375549f, -0.03131288f, 0.02636554f, -0.00995643f, 
    0.02441742f, -0.03973754f, 0.01687121f, -0.01880898f, -0.00548202f, -0.00168842f, -0.05488130f, -0.01946000f, 
    -0.00562906f, -0.02280576f, 0.03290253f, -0.00666041f, -0.04189419f, -0.02049884f, -0.02356463f, -0.01897263f, 
    -0.00665910f, -0.03798034f, -0.05401554f, -0.01840414f, -0.01224109f, -0.01181755f, -0.04003908f, -0.04570838f, 
    -0.04923289f, 0.00661704f, 0.04775871f, 0.02459296f, 0.03409221f, 0.01209834f, 0.00949580f, 0.02476663f, 
    -0.00968517f, -0.05142258f, -0.00111076f, -0.04069290f, 0.03573230f, -0.04068161f, -0.04763509f, 0.01834234f, 
    -0.04164355f, -0.01936794f, 0.01436039f, -0.04725880f, -0.03233641f, 0.00634983f, -0.02988036f, -0.02832680f, 
    -0.05296427f, -0.02038178f, 0.00529533f, -0.05049305f, -0.01886714f, 0.02218986f, 0.00033396f, -0.00666581f, 
    0.03129792f, -0.04566443f, -0.00269819f, -0.03709158f, -0.03972087f, -0.03936559f, -0.03299215f, 0.01101538f, 
    -0.02050973f, -0.01920919f, -0.00113502f, -0.05338673f, -0.00856306f, -0.04393701f, 0.04466110f, 0.04320018f, 
    -0.03775131f, 0.05115749f, 0.02595078f, -0.05100187f, -0.02094476f, 0.02870255f, -0.01918252f, -0.04551333f, 
    0.01593407f, -0.03755546f, -0.03944086f, -0.00606916f, -0.02186919f, 0.00661883f, -0.03077400f, 0.04563647f, 
    -0.05313977f, 0.01449821f, 0.02334123f, -0.03574667f, -0.03048787f, -0.03288040f, 0.01228676f, 0.00878805f, 
    -0.05031730f, -0.04023769f, 0.01640555f, -0.05468412f, -0.00205043f, 0.01317296f, -0.01909663f, 0.03389001f, 
    -0.03209027f, -0.01206661f, 0.03298295f, -0.03553284f, -0.01058711f, -0.02599344f, -0.04224258f, 0.00508134f, 
    -0.00060116f, -0.05158714f, -0.00629299f, 0.04216386f, 0.02008250f, -0.02816090f, 0.03531074f, -0.00853688f, 
    0.00800417f, 0.03922134f, -0.01495077f, 0.00568731f, 0.04374985f, 0.00935701f, -0.01827765f, 0.01941714f, 
    0.03350203f, -0.01966202f, -0.00304467f, -0.03303694f, 0.00359860f, -0.00601757f, -0.02102403f, -0.00140410f, 
    0.02760454f, -0.02621248f, 0.00982045f, 0.03129561f, -0.02110209f, -0.05276010f, 0.04693137f, -0.04161525f, 
    0.03260015f, 0.03659505f, 0.00237827f, -0.03438316f, -0.02538558f, -0.03023455f, 0.01576099f, -0.05300516f, 
    -0.00128603f, -0.03033556f, 0.02695453f, 0.02173883f, 0.02277820f, -0.05399589f, 0.03774490f, -0.00929057f, 
    0.04076993f, -0.02707683f, 0.03989404f, -0.04605874f, -0.01331517f, -0.00677349f, 0.03358991f, 0.03357634f, 
    0.03150280f, 0.03708517f, 0.04295915f, 0.02075266f, 0.00166582f, 0.02010805f, 0.00347291f, -0.04427035f, 
    -0.04137032f, 0.04654538f, -0.04955516f, -0.05341169f, 0.00471824f, 0.01677006f, 0.00823713f, -0.03309327f, 
    0.03807992f, 0.02749221f, -0.03413469f, 0.01571786f, -0.02763087f, -0.05071273f, -0.01811260f, 0.01962663f, 
    -0.02154459f, -0.02458786f, 0.00279772f, 0.01945606f, -0.02266871f, 0.04105166f, -0.01165541f, -0.00752658f, 
    0.02136880f, 0.04894245f, 0.01050078f, 0.02569908f, -0.01593179f, -0.03728284f, 0.01569773f, -0.00493444f, 
    0.03796369f, -0.04665913f, 0.03313212f, -0.01623712f, 0.04552497f, -0.03992992f, -0.05662672f, 0.00773579f, 
    -0.04044249f, -0.01539617f, 0.02610639f, -0.02032800f, 0.00242634f, -0.00862053f, 0.04773699f, -0.02802816f, 
    -0.01441294f, -0.02093611f, 0.01151199f, 0.03157165f, 0.01733475f, -0.03323439f, 0.04070112f, 0.01820063f, 
    0.04206273f, -0.04953756f, 0.00484958f, -0.00824492f, -0.03116354f, 0.03867082f, 0.02699770f, 0.00743337f, 
    -0.04232818f, -0.00101529f, 0.02067525f, -0.05549880f, -0.04193457f, 0.00061338f, -0.03025834f, -0.03364388f, 
    -0.00992736f, -0.03806873f, -0.00571281f, 0.03892259f, 0.01151145f, -0.04619555f, 0.00366022f, -0.02600033f, 
    0.01449336f, 0.00610441f, -0.01771307f, -0.01752697f, -0.05403268f, -0.00479285f, -0.02498874f, -0.02114686f, 
    0.01034999f, -0.04835364f, 0.02230223f, 0.00983054f, -0.02351051f, -0.00696329f, 0.03817685f, -0.00139580f, 
    -0.01591829f, -0.03234529f, -0.00470586f, -0.01610415f, -0.04062859f, -0.00263881f, 0.03695988f, 0.01387972f, 
    -0.01496883f, -0.01148849f, -0.02724889f, 0.01123794f, -0.02823224f, -0.01456296f, 0.01875593f, -0.01665976f, 
    -0.01700335f, -0.00603573f, 0.01492985f, 0.03818431f, -0.03665859f, 0.01583210f, -0.01416735f, -0.04254183f, 
    0.00351070f, 0.04573739f, 0.03304224f, -0.02226293f, -0.03160946f, 0.03956010f, 0.00577087f, -0.05665987f, 
    -0.01858660f, -0.02166468f, 0.00753218f, 0.00170435f, 0.01836232f, -0.02003717f, -0.04064120f, 0.02901017f, 
    -0.03020117f, 0.02525860f, -0.02698296f, -0.04419476f, 0.04434521f, 0.03971680f, 0.00425789f, 0.04353935f, 
    -0.04697189f, -0.03978297f, -0.02982241f, -0.04069731f, 0.00531822f, 0.01293857f, -0.01876843f, 0.02161484f, 
    0.02037241f, 0.00955192f, -0.03201722f, 0.01125025f, -0.02480722f, -0.03834433f, -0.04572138f, -0.00925416f, 
    -0.00850332f, -0.04206775f, -0.01810521f, -0.02749370f, -0.05820902f, -0.00600190f, -0.03957121f, -0.01241658f, 
    0.03615179f, -0.02396902f, 0.02222553f, -0.01888238f, -0.00637358f, 0.02930812f, -0.03121848f, -0.00439168f, 
    0.02453558f, 0.00089054f, 0.03842178f, -0.00938762f, 0.01915880f, -0.01066865f, -0.02458926f, -0.02811739f, 
    0.02233793f, 0.01919056f, -0.03031713f, -0.03427698f, -0.02280595f, 0.01070318f, -0.04296621f, 0.01862573f, 
    -0.01534314f, -0.01748160f, -0.04639553f, 0.04016107f, 0.05125330f, 0.02321529f, 0.03031679f, -0.05757285f, 
    -0.01599711f, -0.05172290f, -0.00807700f, -0.05246979f, 0.04436740f, -0.02729703f, 0.03966696f, 0.00684748f, 
    -0.02283648f, 0.00985077f, 0.02951603f, -0.03866158f, -0.01693087f, 0.01285541f, 0.04213406f, -0.04515440f, 
    0.03301144f, 0.02641482f, -0.01329566f, -0.01525509f, 0.00377732f, -0.00148485f, -0.03604784f, -0.05503775f, 
    -0.05231111f, 0.03926478f, -0.01162610f, -0.03918954f, -0.01822774f, -0.01289815f, -0.03367310f, -0.03195246f, 
    -0.05522236f, -0.02625621f, -0.05546848f, -0.00592769f, 0.00955683f, -0.00730471f, 0.00767755f, 0.02361282f, 
    -0.04448533f, 0.00800702f, 0.01435073f, -0.03313195f, -0.03041268f, 0.04200852f, -0.01870953f, -0.01743552f, 
    0.03723025f, 0.01481101f, -0.01807458f, 0.02065087f, 0.00836840f, -0.00995592f, 0.04202113f, -0.02955021f, 
    -0.02779059f, -0.05782090f, 0.03579348f, 0.00092373f, -0.00064367f, 0.00882249f, 0.00123436f, -0.03229097f, 
    -0.02036841f, -0.03363242f, -0.02772563f, 0.00911119f, -0.04344391f, 0.02495860f, 0.04088541f, -0.03317133f, 
    -0.04039722f, 0.03097913f, 0.01157966f, -0.04728991f, -0.03390947f, -0.00282968f, 0.03477302f, -0.02067766f, 
    0.00120510f, -0.04396993f, -0.01337170f, -0.04741481f, -0.00455782f, 0.00166083f, -0.02804732f, -0.02579387f, 
    -0.02151118f, 0.02593784f, -0.01490466f, 0.03532861f, -0.05011017f, -0.03901982f, -0.04145703f, -0.04674690f, 
    0.03689058f, -0.02014806f, -0.04353151f, 0.01875547f, 0.03778807f, -0.01909257f, -0.01276475f, -0.04433700f, 
    -0.02775206f, -0.03014409f, 0.02425692f, -0.02163220f, -0.04359434f, 0.03044390f, -0.04363514f, -0.01676218f, 
    -0.02928281f, 0.02982480f, -0.03326347f, 0.01435746f, -0.02191142f, -0.02606267f, 0.00001479f, -0.04428405f, 
    0.03288203f, -0.00258770f, -0.02435402f, 0.00879945f, 0.00709238f, -0.01278378f, -0.04075813f, 0.02923692f, 
    0.01703165f, -0.05739981f, -0.01243640f, -0.05197314f, 0.01561979f, -0.02994902f, -0.00684416f, -0.01310589f, 
    -0.02414389f, -0.00294545f, -0.02603842f, -0.02589536f, -0.03895087f, 0.02448131f, 0.02174734f, 0.01104174f, 
    -0.03098843f, -0.03302890f, 0.03328273f, 0.01524253f, 0.04171859f, -0.05492914f, 0.00753242f, -0.03032817f, 
    -0.02684729f, -0.04232083f, -0.05786146f, -0.02073672f, -0.00807182f, -0.01299253f, -0.02117034f, -0.01539727f, 
    -0.00302643f, 0.03724526f, -0.05062649f, -0.00686873f, 0.03015973f, 0.02672946f, 0.03928353f, 0.04003380f, 
    -0.00486160f, -0.00563619f, -0.05715050f, -0.01839246f, -0.05290119f, -0.05206799f, 0.00489450f, -0.04034280f, 
    -0.05124578f, -0.05468397f, -0.03131985f, -0.01700741f, 0.01033222f, 0.02119575f, -0.05826211f, 0.02218759f, 
    -0.00397805f, 0.03287754f, 0.04394388f, 0.03627586f, -0.04523651f, 0.01336894f, 0.02212444f, -0.02100383f, 
    -0.04605676f, 0.00172846f, -0.04623255f, 0.01239637f, -0.01519173f, -0.02092914f, 0.03639225f, -0.01393405f, 
    0.04254509f, 0.01865978f, -0.01912638f, 0.00269128f, -0.00196779f, 0.01098961f, 0.01597744f, -0.00575568f, 
    0.02806543f, 0.00226010f, -0.01099716f, -0.00028784f, 0.03131441f, 0.00793281f, -0.02359420f, 0.04154324f, 
    0.03996474f, 0.00319536f, -0.04007494f, 0.02708687f, 0.04010450f, 0.01964229f, 0.04071306f, 0.04016951f, 
    -0.04630959f, 0.04208872f, 0.02877600f, -0.02059639f, 0.02141502f, -0.01063397f, -0.03773423f, -0.04193113f, 
    -0.02869100f, 0.01753592f, -0.04204958f, 0.01529433f, -0.03787866f, 0.01344395f, 0.00900452f, -0.04411222f, 
    0.01797070f, -0.03524324f, -0.05234899f, -0.01950535f, -0.01734221f, 0.02465420f, -0.02248222f, 0.02149619f, 
    -0.00711882f, -0.00867287f, -0.03560705f, -0.02028073f, 0.02556347f, 0.01131354f, 0.00234624f, -0.03744075f, 
    0.02466807f, 0.02173556f, -0.01464028f, -0.02113673f, -0.01161834f, 0.00488228f, 0.01355701f, 0.03346603f, 
    -0.05589933f, -0.05849973f, -0.01345952f, -0.04583938f, 0.00897936f, -0.04219740f, -0.02956769f, 0.03298710f, 
    0.02500382f, -0.04699190f, -0.00965516f, -0.05784099f, -0.03780453f, -0.00589908f, 0.01439527f, -0.01820021f, 
    0.01527798f, -0.05694929f, -0.02412754f, 0.02956017f, 0.00099547f, 0.02300806f, -0.03451576f, -0.04307706f, 
    -0.05432799f, -0.01090031f, -0.04463238f, 0.03733874f, 0.00951266f, -0.03802162f, -0.01890632f, 0.02543528f, 
    0.01625376f, -0.05138563f, 0.01300713f, -0.00233292f, -0.03872095f, 0.02274510f, -0.05257110f, 0.00229027f, 
    0.04222534f, -0.00674841f, -0.01837250f, -0.02631676f, -0.05241457f, 0.03787987f, -0.04499716f, -0.03040083f, 
    -0.01281572f, -0.01755870f, 0.01486344f, -0.02185415f, 0.02807881f, 0.00016821f, -0.05237462f, 0.00419161f, 
    -0.01915874f, 0.00080842f, 0.00878686f, 0.02077366f, -0.00124195f, -0.03708266f, 0.04150765f, -0.01239650f, 
    -0.03913550f, -0.02972313f, 0.00958796f, -0.01897754f, -0.04548506f, 0.02912632f, -0.05305143f, -0.03004104f, 
    0.42646506f, 0.14445709f, 0.24781843f, 0.01876581f, -0.08631790f, -0.13900059f, -0.15468475f, 0.15604514f, 
    0.10878212f, 0.01164974f, 0.02353581f, 0.01843100f, 0.15405945f, 0.17060450f, 0.08105443f, 0.14539617f, 
    0.02399840f, 0.04460475f, 0.09590705f, 0.06030776f, 0.06923384f, 0.04432342f, -0.02095238f, -0.04990173f, 
    0.11911289f, 0.05927192f, 0.21626876f, -0.07238171f, 0.05823116f, -0.03335156f, -0.01706602f, 0.13304248f, 
    0.10786530f, 0.04002625f, 0.06097180f, -0.04080868f, 0.15745275f, 0.24221063f, 0.23617937f, 0.13230352f, 
    -0.05747558f, -0.06431467f, -0.02552942f, 0.10921042f, -0.03256328f, 0.03596338f, -0.07145804f, 0.06599957f, 
    -0.27391565f, -0.03084430f, 0.01980539f, -0.30078322f, -0.11736404f, 0.05043383f, -0.05087566f, -0.06362522f, 
    -0.00582117f, -0.05290581f, 0.07973795f, -0.10081334f, -0.08724497f, -0.12379878f, 0.13223468f, 0.04309282f, 
    -0.04597117f, 0.03980873f, 0.05713720f, 0.05151840f, 0.07486195f, -0.02364916f, 0.09389720f, 0.01763857f, 
    -0.16451931f, -0.02321473f, -0.06836876f, -0.06990219f, 0.06376239f, 0.08861054f, -0.07469223f, 0.01973077f, 
    0.17076859f, -0.00901736f, 0.05762298f, 0.24776836f, 0.17679083f, 0.33468890f, 0.14525099f, 0.25172201f, 
    0.11199566f, 0.06733631f, 0.05888372f, 0.12452509f, -0.01532777f, 0.11915240f, -0.00647405f, 0.00292733f, 
    -0.00757876f, 0.05817695f, 0.09025542f, 0.07444576f, -0.02150527f, 0.06917994f, 0.08667316f, -0.01874969f, 
    -0.04872629f, 0.06054996f, -0.00422691f, -0.00584757f, -0.06927257f, -0.02687861f, 0.02496707f, -0.12736395f, 
    0.09671096f, -0.03573779f, 0.00815660f, 0.12702478f, -0.03558759f, 0.09032387f, 0.05088839f, 0.03974279f, 
    -0.22600438f, 0.13954651f, 0.22912715f, -0.13502078f, 0.01778338f, 0.03756274f, 0.08945382f, 0.07181073f, 
    0.08260921f, -0.02201203f, -0.03262262f, 0.18333820f, -0.03475144f, 0.15779315f, -0.00441804f, 0.13102749f, 
    0.03612652f, -0.04115083f, 0.14923836f, 0.02024509f, 0.07353309f, 0.04495749f, -0.02164409f, 0.00382035f, 
    0.36394042f, -0.16145536f, 0.09419215f, 0.13266246f, 0.04996960f, -0.03694138f, -0.02490003f, 0.10505842f, 
    0.11505421f, 0.09008920f, 0.01899889f, 0.01209412f, 0.36180714f, 0.02498886f, 0.10220269f, 0.18144055f, 
    -0.16851898f, 0.00723153f, 0.01546093f, 0.07987694f, -0.03766491f, 0.12504223f, 0.00123724f, -0.01964219f, 
    -0.12214085f, 0.03295930f, -0.07500102f, -0.30333212f, -0.01831416f, -0.02129627f, 0.08480333f, 0.08446258f, 
    0.01169989f, -0.10355230f, 0.18517856f, 0.08356901f, -0.13215707f, -0.08866847f, 0.05871914f, -0.01705435f, 
    -0.05334987f, 0.16790932f, -0.09030151f, -0.04487209f, 0.13573976f, 0.08199524f, -0.07628111f, 0.18494251f, 
    0.03153107f, -0.01934361f, -0.08032411f, -0.07389557f, -0.00046160f, -0.01793201f, 0.02455327f, -0.14577262f, 
    -0.02128370f, 0.10949969f, 0.10611113f, 0.01741516f, 0.44633731f, -0.05726104f, -0.01350020f, 0.08850186f, 
    0.07049679f, 0.03411146f, 0.03730381f, 0.04265658f, -0.05353284f, 0.04788553f, 0.07797017f, -0.05426056f, 
    0.49531409f, -0.27897733f, 0.02519089f, -0.05233792f, 0.04794658f, 0.01107750f, 0.05576796f, -0.02559376f, 
    0.14244150f, -0.00857172f, -0.15381242f, 0.13126802f, -0.26770598f, -0.08360369f, -0.10210548f, -0.16928259f, 
    -0.06126020f, 0.11969934f, -0.00334322f, -0.09300330f, 0.11152642f, 0.03021468f, -0.05040244f, 0.13452607f, 
    -0.23365009f, -0.11237978f, 0.02858161f, -0.12384149f, 0.01787385f, 0.01505563f, -0.05516621f, 0.10986485f, 
    0.09355893f, -0.01770141f, 0.06373536f, 0.09277170f, 0.28588143f, 0.20227925f, 0.17173599f, -0.03795744f, 
    0.04884649f, 0.05968689f, -0.02499818f, 0.06401698f, 0.04584119f, 0.03733891f, 0.06590128f, 0.05415409f, 
    0.02671903f, -0.10863508f, -0.02786266f, -0.06968976f, -0.09277095f, 0.09510296f, -0.04739033f, 0.14885862f, 
    -0.03537574f, 0.07038772f, 0.10642377f, 0.00293933f, -0.05415051f, 0.28685620f, 0.08882659f, -0.07249768f, 
    -0.06365160f, -0.03436767f, 0.07060225f, -0.03111670f, 0.05487917f, 0.01483635f, -0.16195793f, 0.07586306f, 
    -0.07532033f, 0.27316004f, -0.02801831f, 0.21656322f, -0.04711468f, -0.06970508f, 0.06760398f, -0.06906540f, 
    0.03109351f, -0.12990209f, 0.00225808f, -0.09165135f, -0.23983164f, -0.19217676f, -0.01410600f, -0.14106654f, 
    -0.06938661f, -0.04603586f, 0.05198838f, 0.03667135f, 0.03318809f, 0.04809776f, 0.01196115f, 0.10783669f, 
    0.05812326f, 0.13583672f, -0.12296101f, -0.00855537f, -0.03051699f, 0.00275170f, 0.07284223f, -0.06421658f, 
    0.04568540f, -0.00103480f, 0.02621676f, -0.03268144f, -0.07076703f, -0.13510074f, -0.08409026f, -0.00623735f, 
    0.05121377f, -0.13004665f, 0.12393741f, 0.01938561f, 0.12947863f, 0.10765309f, 0.15689352f, 0.10259761f, 
    -0.17951450f, 0.11641955f, 0.05968235f, 0.27223340f, -0.05342286f, 0.02142925f, 0.05048271f, 0.14997822f, 
    0.04683615f, 0.08000817f, -0.01527871f, -0.01207065f, -0.30052581f, -0.02690625f, 0.05473321f, -0.16284600f, 
    0.05861545f, 0.08058056f, 0.12816148f, 0.03597478f, 0.13207597f, 0.04112071f, -0.02062047f, -0.09416828f, 
    -0.01925789f, -0.07713484f, 0.16728762f, 0.05976844f, -0.05770877f, 0.07578965f, -0.02261204f, -0.12731975f, 
    0.08906297f, -0.03241718f, 0.01896854f, 0.09534236f, 0.51266563f, -0.05227349f, -0.02435677f, 0.11650126f, 
    -0.05585567f, -0.10634273f, 0.08226378f, 0.00265975f, -0.02325913f, -0.06928557f, 0.08664238f, -0.06428184f, 
    -0.11870964f, 0.16057900f, -0.18162136f, 0.21245351f, 0.13663483f, 0.02100231f, 0.19077891f, 0.01744720f, 
    0.00166555f, -0.02492576f, 0.04269474f, 0.06643052f, 0.11507768f, -0.00856082f, -0.03653808f, -0.05341024f, 
    0.13948031f, -0.00148177f, -0.11514135f, -0.09654424f, 0.13215931f, 0.02821134f, -0.08202611f, -0.03390305f, 
    -0.29350773f, 0.13237040f, -0.01839561f, 0.00096471f, 0.08701729f, -0.02362791f, -0.00172121f, 0.03027477f, 
    0.17549877f, 0.12524112f, -0.05998856f, 0.02792599f, -0.02890440f, 0.03924519f, -0.03753217f, 0.10086495f, 
    0.17521203f, 0.11415629f, 0.02683781f, -0.10078227f, 0.08275808f, 0.10129869f, -0.02073698f, 0.03960168f, 
    0.05925928f, -0.16790535f, -0.05044831f, -0.19988903f, 0.04268943f, -0.11638800f, 0.05398272f, -0.03081765f, 
    0.05380644f, -0.05845061f, -0.06715547f, 0.13376628f, 0.11976292f, 0.19217181f, -0.14853929f, -0.07314868f, 
    0.02714380f, 0.00047588f, -0.02944527f, 0.08505187f, -0.10134929f, 0.14265709f, 0.10797917f, 0.01523795f, 
    0.35402071f, -0.08028954f, 0.18115784f, 0.45107001f, -0.13114822f, -0.04894677f, -0.00570077f, 0.15971673f, 
    0.00275628f, -0.02276612f, -0.01390256f, -0.15446533f, 0.04541436f, -0.07608420f, -0.02371717f, -0.03459026f, 
    0.12796907f, 0.03376652f, -0.13736583f, 0.01929083f, 0.00598503f, -0.00408022f, -0.03361633f, 0.05977745f, 
    0.21371597f, 0.00576604f, 0.00569472f, -0.04475839f, -0.04650347f, 0.03749182f, -0.11317416f, -0.04317324f, 
    0.01586770f, -0.11923745f, 0.09350254f, -0.09789842f, 0.08136585f, 0.04568153f, 0.08916494f, 0.15735142f, 
    -0.07506981f, -0.00447188f, 0.15590693f, 0.09579518f, -0.00622645f, -0.03037608f, -0.00461399f, -0.08596912f, 
    -0.14894728f, -0.03342177f, 0.02562004f, -0.10308710f, 0.11165711f, -0.01527272f, 0.01185484f, -0.13717172f, 
    0.24395099f, 0.05175406f, -0.04429230f, -0.17278913f, 0.26582190f, -0.02931307f, -0.17471844f, 0.00058767f, 
    0.02791230f, 0.23540780f, -0.12955073f, -0.09060051f, 0.02711081f, 0.05278204f, 0.06438977f, 0.10921296f, 
    0.04134164f, 0.07836252f, -0.02357377f, -0.01878192f, 0.04366275f, -0.01028628f, -0.02159452f, -0.02537635f, 
    0.00735486f, 0.03651550f, -0.00960695f, 0.02461282f, 0.11015594f, -0.05446946f, -0.13678539f, 0.24485452f, 
    0.16266219f, -0.04578498f, -0.02396546f, 0.02187229f, -0.01387920f, 0.02321923f, -0.05113614f, -0.12802210f, 
    -0.10629220f, 0.09808724f, -0.13036935f, -0.09437820f, 0.08083593f, 0.01478615f, -0.01217517f, -0.00025092f, 
    -0.08476517f, 0.00350672f, -0.07136430f, -0.13660637f, 0.37076440f, -0.20317078f, 0.05514885f, 0.24344242f, 
    -0.07852094f, -0.14757627f, -0.06462939f, 0.18542270f, 0.09963229f, 0.07260104f, -0.03037187f, 0.04197902f, 
    -0.46364611f, 0.08118516f, 0.07718509f, -0.20778292f, 0.18324198f, 0.00530024f, 0.05502995f, 0.18614468f, 
    0.14732468f, 0.02913332f, 0.11210190f, -0.10748763f, 0.07374125f, -0.03699040f, 0.00715762f, 0.09123310f, 
    0.00967006f, 0.02641922f, 0.05439806f, 0.08798482f, 0.10506662f, 0.14681286f, -0.09650895f, 0.12638335f, 
    -0.07283853f, -0.24302526f, -0.13682362f, 0.00760384f, -0.05696552f, -0.22540899f, 0.07767450f, 0.06994690f, 
    -0.03795015f, 0.01645047f, 0.07686964f, 0.08533351f, -0.15902221f, -0.06588510f, -0.29627723f, -0.17798564f, 
    0.10076199f, 0.03666863f, -0.03852956f, 0.00173618f, -0.02094485f, 0.06090666f, 0.11843470f, -0.01805676f, 
    0.17491691f, 0.16422363f, 0.08999076f, 0.05069165f, 0.02123203f, -0.02101217f, 0.04815904f, 0.15726754f, 
    0.08897482f, -0.04719874f, 0.00114617f, -0.02979080f, -0.04797064f, 0.03989132f, -0.14361317f, 0.27257267f, 
    0.14611956f, -0.16714244f, 0.04992048f, -0.09332149f, 0.04446697f, 0.05256564f, -0.12537846f, -0.11815397f, 
    0.15781091f, 0.10864203f, 0.13690731f, 0.02031725f, -0.06140658f, 0.00971670f, -0.02874084f, -0.07216518f, 
    -0.01284197f, 0.10158762f, -0.02032442f, -0.01646944f, 0.05660012f, 0.04722122f, -0.00237968f, -0.10146857f, 
    0.09134629f, 0.07980719f, -0.17313319f, -0.10592574f, 0.15780252f, -0.00759548f, 0.09569556f, 0.06624465f, 
    0.45926398f, 0.03245360f, 0.15258160f, -0.29275587f, -0.02619455f, 0.12471838f, -0.01619020f, -0.09344828f, 
    -0.02751157f, -0.03595104f, 0.14892335f, 0.14070822f, -0.06653748f, 0.01227732f, 0.12125849f, -0.05498032f, 
    0.03476380f, 0.06335497f, -0.12901531f, 0.02680752f, 0.15513577f, 0.06854787f, 0.10538419f, 0.19101301f, 
    0.35043994f, 0.03565290f, -0.07155423f, 0.00942340f, -0.04529608f, -0.05241679f, -0.11592476f, 0.04823401f, 
    -0.00796151f, 0.09615594f, -0.08661129f, 0.04894353f, -0.06850542f, 0.22403140f, 0.31790575f, -0.08676507f, 
    -0.00009251f, 0.00594736f, 0.12938635f, -0.01897678f, -0.05033163f, -0.04064034f, 0.05327385f, -0.11876728f, 
    -0.15002097f, 0.09488956f, 0.10303443f, -0.08529601f, 0.03150027f, 0.16353317f, -0.04752415f, -0.15234850f, 
    0.01170942f, -0.06336233f, 0.15561047f, 0.04551458f, -0.03523077f, -0.01887033f, -0.38945180f, -0.25682786f, 
    0.02933726f, 0.03444473f, -0.09763742f, -0.12968378f, 0.10506661f, -0.05435068f, -0.07842557f, 0.16384369f, 
    0.38337639f, -0.13188156f, -0.02327991f, 0.14198136f, 0.01041077f, -0.11259731f, -0.07329610f, 0.08290263f, 
    0.01358126f, 0.14780936f, 0.01372381f, 0.04020445f, -0.12312009f, 0.00375969f, -0.09647944f, -0.08401883f, 
    0.02391109f, 0.15644924f, -0.00803440f, 0.13955778f, 0.00169205f, 0.10719982f, 0.06780051f, 0.02084018f, 
    -0.01626258f, -0.05767312f, 0.04274055f, -0.05249953f, -0.03809780f, -0.02785628f, 0.03531312f, -0.04228674f, 
    0.03045735f, -0.03119286f, 0.03193574f, 0.02527303f, 0.00589582f, 0.00183195f, -0.06100354f, -0.03886662f, 
    -0.00611867f, 0.02898041f, 0.01383374f, -0.00058204f, -0.00611668f, -0.01563286f, -0.03960189f, 0.00900909f, 
    0.02209134f, 0.02881233f, -0.03555369f, -0.02967552f, 0.00684870f, -0.04755658f, -0.03837223f, 0.03613780f, 
    -0.03906657f, 0.04873871f, 0.04045747f, -0.03823690f, -0.04327189f, -0.03457720f, 0.00111440f, 0.02791635f, 
    -0.04567435f, -0.00759692f, -0.04640921f, -0.05500651f, -0.00773454f, -0.00504512f, -0.04686997f, 0.03857118f, 
    0.04268518f, -0.04540662f, 0.00744856f, -0.05078324f, -0.01754702f, -0.04716401f, 0.02812174f, -0.05617411f, 
    0.00503315f, 0.01336918f, 0.02886127f, -0.04583259f, 0.02454523f, 0.01388055f, 0.02305269f, -0.04865706f, 
    0.01785819f, 0.00776486f, 0.03568542f, 0.02110734f, 0.02408256f, -0.04190371f, 0.01712271f, 0.03149375f, 
    -0.02782897f, 0.00031365f, -0.00993630f, 0.00128301f, 0.00516365f, 0.02425951f, -0.03086543f, 0.01101242f, 
    0.02212490f, -0.04414982f, 0.04168856f, 0.03074259f, -0.03370298f, -0.01015562f, -0.03301895f, -0.03929267f, 
    -0.00615628f, -0.01296754f, -0.01972829f, -0.04643651f, 0.04920282f, -0.03186747f, -0.02991847f, -0.05373930f, 
    -0.03608124f, -0.04980271f, -0.04109824f, 0.03623379f, -0.03949177f, 0.01503134f, -0.00084460f, -0.00068759f, 
    -0.00541304f, -0.02290560f, 0.02189501f, -0.03065787f, -0.00648493f, -0.02495552f, 0.03973701f, 0.01539414f, 
    -0.03168776f, 0.02193481f, -0.03164415f, -0.02358070f, -0.01784480f, 0.03120448f, 0.04384778f, -0.00734591f, 
    -0.02643059f, -0.04672009f, -0.01050704f, 0.03978692f, 0.01281926f, -0.03902023f, -0.03755359f, -0.04794047f, 
    -0.03944583f, 0.00487233f, -0.04039978f, 0.00418090f, -0.04928349f, -0.02998747f, 0.01968869f, 0.01916400f, 
    0.00088288f, -0.03195508f, -0.00257282f, -0.02583245f, -0.03098407f, 0.00428806f, 0.01793654f, -0.02394945f, 
    0.03889302f, 0.05210022f, 0.01599156f, 0.01471924f, -0.04227620f, 0.04360406f, 0.03670919f, -0.01929001f, 
    0.03769721f, 0.03357669f, -0.00326633f, 0.01211514f, 0.01219831f, 0.00005570f, -0.04166624f, -0.01321208f, 
    -0.00983484f, -0.03588205f, -0.01915110f, -0.04297446f, 0.01064061f, -0.04795884f, -0.05371412f, -0.01215809f, 
    -0.01646143f, -0.01527857f, 0.04492201f, -0.03572300f, 0.01830287f, -0.05513600f, -0.03362668f, 0.02735235f, 
    -0.02934563f, -0.00957459f, -0.04295751f, 0.03363672f, -0.00307817f, 0.01081958f, -0.03361013f, 0.01354630f, 
    -0.05328692f, -0.02493947f, 0.03738622f, -0.03271750f, -0.03527868f, -0.00992442f, -0.00961749f, -0.03799307f, 
    0.02825751f, -0.03924943f, -0.00894964f, 0.03411463f, -0.01518232f, 0.03982797f, 0.04193189f, -0.00969005f, 
    -0.00599563f, -0.02845096f, 0.01069104f, 0.03693326f, 0.02089443f, 0.00635816f, -0.03566524f, -0.01978738f, 
    -0.02770863f, 0.00277430f, -0.02408207f, -0.00184278f, 0.01344604f, -0.02790524f, 0.01742271f, -0.05623587f, 
    -0.04879144f, -0.00848934f, -0.00239524f, -0.00357285f, -0.00282479f, 0.00072376f, -0.02965612f, 0.03184251f, 
    0.02326518f, 0.02452555f, 0.01597407f, -0.00467655f, 0.04679484f, 0.04525921f, -0.00325086f, 0.01802735f, 
    0.00911077f, 0.01333387f, -0.02948376f, 0.03756048f, -0.00940968f, 0.03530263f, 0.03980221f, -0.00655804f, 
    -0.01904167f, 0.01287797f, 0.04274281f, -0.01929789f, 0.02318032f, -0.00098212f, 0.03539246f, -0.02954360f, 
    -0.04602954f, 0.03442507f, 0.02587726f, -0.01529214f, 0.03589611f, -0.01540083f, 0.03057069f, -0.00615925f, 
    0.01885976f, 0.00119393f, 0.02534524f, -0.00989654f, 0.04088266f, -0.03819938f, -0.03555802f, -0.03483700f, 
    0.02712560f, 0.03519054f, -0.01182121f, -0.00681664f, 0.00247115f, -0.01588666f, 0.03681299f, -0.00670086f, 
    -0.02999808f, -0.02066879f, 0.01704837f, -0.04368731f, 0.01353183f, -0.05420298f, -0.02167942f, 0.02115041f, 
    -0.01353889f, -0.04730902f, -0.02800636f, 0.02672180f, -0.01959448f, 0.02033271f, 0.01557970f, -0.02563570f, 
    0.00451920f, -0.00948785f, 0.01992775f, -0.05269153f, -0.03499728f, -0.02149232f, -0.05708292f, -0.05211415f, 
    -0.02035065f, -0.02221767f, 0.04903593f, -0.01112455f, -0.04967511f, -0.04237037f, -0.03295895f, 0.01013324f, 
    0.03620014f, 0.00936942f, 0.02624972f, -0.01661248f, 0.01010956f, -0.02922293f, 0.02073435f, -0.05153797f, 
    -0.05153710f, 0.02368856f, -0.01742662f, 0.03037005f, -0.03488124f, -0.02073844f, -0.00176049f, -0.01228169f, 
    0.00723921f, -0.00792277f, -0.01861137f, -0.01269679f, -0.01542579f, 0.03230752f, 0.01204369f, 0.04001155f, 
    0.03073063f, 0.03486449f, 0.05102487f, 0.03371241f, -0.02074900f, -0.00209376f, 0.03440475f, 0.01386934f, 
    -0.04473663f, -0.04293291f, 0.02531792f, -0.05237002f, 0.03900180f, -0.01055336f, -0.04543338f, 0.03412592f, 
    -0.03268746f, -0.01562349f, -0.02120888f, 0.03272119f, -0.02541685f, -0.00185308f, -0.01767925f, 0.01049130f, 
    0.02767269f, 0.03903968f, -0.00357100f, -0.04781060f, -0.00293823f, -0.05273544f, -0.02249618f, -0.00221263f, 
    -0.00496572f, -0.00362312f, 0.01682214f, 0.01656909f, -0.04621238f, -0.04153642f, 0.04376727f, -0.00922778f, 
    0.04224289f, -0.03961309f, 0.02545884f, -0.01474482f, 0.02834113f, -0.04592559f, 0.02992667f, 0.03966325f, 
    -0.04601109f, 0.02698477f, -0.00974162f, 0.00995526f, -0.01017481f, -0.02859887f, 0.00206676f, 0.01675604f, 
    0.29331234f, -0.01993134f, 0.09064208f, 0.17271486f, -0.03070719f, 0.04438252f, -0.03445102f, 0.04771867f, 
    -0.05762034f, -0.05188750f, 0.02755420f, 0.15181756f, -0.15868787f, 0.15206438f, -0.04900385f, 0.14780885f, 
    0.08972505f, 0.09346516f, -0.01517413f, -0.00331292f, 0.12295272f, -0.04757859f, -0.04469730f, -0.00514778f, 
    -0.02078054f, 0.16099602f, 0.16048288f, -0.13252307f, -0.08167403f, 0.02636359f, -0.05452611f, -0.00563439f, 
    0.15384772f, 0.03039118f, -0.03099954f, -0.04108588f, -0.28487846f, 0.12230482f, 0.07646456f, 0.13394643f, 
    0.04510790f, 0.00606923f, 0.04078142f, -0.09156288f, -0.05317476f, 0.03027578f, -0.11222741f, 0.11649075f, 
    0.31049785f, -0.19750376f, 0.06151388f, -0.19199120f, -0.03142681f, -0.01151738f, 0.00500628f, -0.17140548f, 
    0.04736199f, -0.05472860f, 0.04221363f, -0.10335321f, 0.01668425f, -0.22777872f, 0.16741191f, -0.07055188f, 
    0.03034171f, 0.02072889f, -0.02814898f, -0.10703288f, 0.00886456f, -0.09140562f, 0.12412477f, -0.02317564f, 
    0.42739889f, -0.13775073f, 0.08296698f, -0.02590683f, -0.10637739f, -0.03419718f, -0.02876383f, -0.01490240f, 
    0.15122934f, -0.02911367f, -0.01069485f, 0.06596631f, -0.08271645f, -0.04027186f, 0.08807254f, -0.03697787f, 
    0.06893276f, 0.05647287f, -0.08676644f, -0.03387358f, -0.00052548f, 0.02558136f, -0.06997335f, -0.00266049f, 
    -0.00965765f, 0.10820153f, 0.15423630f, 0.12358535f, 0.01360355f, 0.10963330f, -0.02338702f, -0.00372649f, 
    -0.01856166f, 0.06525315f, 0.12724330f, -0.01774321f, 0.00061316f, 0.08737817f, -0.11720391f, -0.09142921f, 
    -0.14043024f, -0.10388792f, 0.12060629f, 0.17404701f, -0.06039655f, 0.05198684f, -0.07248717f, 0.01171697f, 
    -0.21238652f, 0.13521412f, 0.02772705f, -0.15022519f, 0.12370291f, 0.05564136f, 0.07843795f, -0.02274438f, 
    0.10355224f, 0.05572794f, -0.05646388f, 0.02874149f, 0.06260710f, 0.16618587f, -0.15204538f, -0.02937086f, 
    0.05582777f, 0.05452210f, -0.06444060f, -0.05616749f, 0.16255249f, 0.08018681f, -0.03949130f, 0.08460920f, 
    -0.18800327f, -0.12634665f, -0.03055991f, -0.05694584f, 0.05005208f, -0.04992390f, 0.01355700f, -0.02308490f, 
    0.01543039f, 0.02353287f, 0.08293021f, -0.00696836f, 0.08358824f, 0.12109430f, 0.14332579f, 0.09975221f, 
    -0.06664500f, 0.04487919f, -0.04702948f, 0.10403289f, -0.10218282f, 0.05677942f, 0.04547291f, -0.02209830f, 
    -0.01012570f, 0.22032501f, 0.00827396f, -0.18897590f, 0.02985482f, -0.01119872f, 0.00370444f, -0.00043000f, 
    0.01374441f, -0.12157482f, 0.01078421f, -0.11585151f, 0.65512979f, -0.28142020f, 0.06409250f, 0.02730139f, 
    -0.17103161f, -0.03096030f, -0.11633747f, 0.14584622f, 0.06381819f, 0.17515109f, 0.04667174f, 0.09219313f, 
    -0.11451423f, 0.18615462f, -0.05007719f, 0.12033349f, -0.01061439f, 0.01984693f, 0.17108476f, -0.01624211f, 
    0.10213128f, 0.14816026f, 0.04537239f, 0.02814755f, 0.04133449f, 0.10415094f, -0.13483822f, 0.05615634f, 
    -0.01857597f, 0.00061506f, 0.01474829f, 0.06308223f, -0.08123950f, 0.10731281f, -0.06591263f, 0.18093489f, 
    0.11919290f, -0.18322958f, -0.23834589f, 0.03792938f, -0.01438575f, 0.02833799f, 0.01062551f, 0.10382047f, 
    0.06771396f, 0.02453447f, 0.16106153f, 0.00000590f, 0.02782016f, 0.01675586f, -0.20281574f, -0.08377828f, 
    0.02982572f, 0.07244696f, -0.07350763f, -0.06822322f, 0.06338593f, 0.01962219f, -0.06170482f, -0.00496870f, 
    0.00128779f, 0.04437890f, 0.19597720f, -0.11214066f, -0.08933459f, 0.01912993f, 0.04321487f, 0.00015734f, 
    -0.01419977f, -0.09308292f, 0.06374713f, 0.04496839f, -0.08578847f, 0.13772458f, 0.00426649f, -0.00679301f, 
    0.03997402f, 0.01443524f, 0.08735394f, 0.03603490f, 0.04035235f, 0.02868075f, -0.06492888f, 0.00096126f, 
    0.18008192f, -0.06803016f, 0.05014144f, -0.04691279f, 0.00176608f, 0.05995423f, 0.07024693f, 0.08233592f, 
    0.02769621f, 0.15991019f, 0.08239983f, -0.01805537f, 0.08370823f, 0.17989430f, -0.07699363f, -0.26522720f, 
    0.17876665f, 0.07182437f, -0.04477805f, -0.07389287f, 0.05516483f, 0.07393863f, -0.05883723f, -0.08097542f, 
    -0.46463069f, 0.11332940f, -0.09037628f, 0.16934688f, 0.02732559f, -0.02499325f, 0.10108040f, 0.03060671f, 
    -0.00665198f, -0.02609333f, 0.08742209f, 0.02539879f, -0.36157131f, -0.01418206f, 0.05130246f, -0.27193302f, 
    -0.07332342f, 0.02863029f, 0.03984522f, -0.03562852f, 0.00660198f, 0.08426608f, 0.06342081f, 0.09604415f, 
    0.27840140f, 0.04827022f, -0.10245875f, -0.10816937f, 0.08273027f, 0.00701796f, -0.03188102f, -0.03856183f, 
    0.04258677f, 0.12591755f, -0.03265953f, -0.04820663f, 0.14509001f, -0.16494115f, -0.07862108f, -0.24917613f, 
    -0.06030592f, -0.05647063f, 0.17372186f, 0.01675512f, -0.10412401f, -0.18050000f, 0.12756792f, 0.04042628f, 
    -0.54283428f, 0.00776244f, 0.04931978f, 0.01971928f, 0.00968525f, 0.11225648f, 0.00807400f, -0.06607999f, 
    -0.01912634f, 0.10700953f, 0.08093067f, 0.01881465f, 0.00182430f, 0.08951425f, -0.11613159f, -0.22424029f, 
    0.13453726f, -0.07387593f, 0.05807083f, 0.00542453f, 0.01911960f, 0.10143941f, -0.11565734f, 0.03355423f, 
    0.28887039f, -0.32855618f, 0.13073052f, 0.09018023f, 0.04595761f, -0.10012828f, -0.04713030f, -0.04555750f, 
    0.09217724f, 0.05483070f, -0.06072123f, 0.10408638f, 0.13130103f, -0.22651066f, -0.15771101f, -0.07508820f, 
    0.08201934f, 0.04552412f, 0.05421599f, 0.09831702f, -0.07180177f, 0.02006509f, 0.07480066f, 0.01061349f, 
    0.03091207f, -0.04292467f, -0.00287923f, -0.04987891f, 0.05048844f, -0.01141084f, -0.04592326f, 0.01863996f, 
    -0.03825702f, -0.01730637f, -0.05460296f, 0.03336999f, -0.00789235f, 0.03643163f, 0.04152641f, -0.02634636f, 
    0.03078253f, -0.02764599f, 0.02013233f, -0.01189261f, -0.05203350f, -0.03738998f, 0.02323109f, 0.03536246f, 
    0.02521964f, -0.01795560f, -0.04619630f, 0.01143873f, 0.02721432f, 0.02760814f, 0.01653662f, 0.02055821f, 
    -0.01490643f, -0.04489506f, 0.01430987f, -0.05632811f, -0.02815007f, -0.00619660f, 0.01912098f, -0.00909792f, 
    -0.02873488f, -0.02342508f, -0.04790463f, 0.03137382f, 0.03166713f, 0.02849491f, 0.00310954f, 0.04013827f, 
    -0.00823614f, 0.03076217f, 0.03391916f, 0.01391504f, 0.01462532f, -0.01840612f, -0.03739341f, 0.00405156f, 
    -0.00125823f, 0.02817295f, 0.00123270f, -0.00968602f, 0.01301064f, -0.03836003f, 0.01407065f, 0.02701562f, 
    0.02310029f, -0.02322824f, 0.03429467f, 0.00132325f, 0.02172150f, -0.04040020f, -0.01552450f, -0.05069914f, 
    -0.04245416f, -0.01257113f, -0.04896966f, 0.00572077f, 0.03872532f, -0.04580000f, 0.00245713f, 0.04368475f, 
    0.02388932f, -0.05617127f, 0.04285442f, 0.00969465f, -0.01647830f, -0.02158793f, -0.04325534f, 0.00710604f, 
    -0.04488543f, 0.01666487f, -0.05734179f, 0.00676341f, 0.02506136f, -0.01001576f, -0.02831464f, -0.04244767f, 
    -0.03714814f, -0.00406710f, 0.03513755f, -0.02647256f, -0.05477810f, 0.03245902f, -0.05872709f, -0.00428914f, 
    0.04672926f, 0.00353738f, -0.02879756f, -0.03596937f, -0.03767848f, 0.03027581f, -0.02629115f, 0.02138053f, 
    0.04122465f, 0.01246040f, -0.02898057f, 0.01638370f, 0.04104204f, -0.05192753f, 0.02256702f, -0.02861571f, 
    0.04911533f, -0.04185947f, -0.03979281f, -0.03141521f, 0.02695481f, -0.00471981f, 0.03550478f, 0.01937160f, 
    -0.05372355f, -0.04078535f, 0.03559944f, 0.03522402f, 0.04293925f, -0.00345682f, -0.00053782f, 0.03050897f, 
    0.04148913f, 0.01612290f, -0.04319625f, -0.03323023f, -0.02219766f, -0.03450654f, -0.05221581f, 0.04191648f, 
    0.01726364f, 0.00991228f, 0.00658902f, -0.03962219f, 0.02538897f, -0.05547451f, -0.01395206f, 0.02671135f, 
    0.01972938f, -0.03473966f, -0.02282649f, -0.03005880f, -0.00590048f, 0.03312504f, -0.02806081f, -0.00019019f, 
    -0.04098951f, 0.03159680f, -0.01327023f, -0.02653591f, 0.02832775f, -0.04277499f, 0.01738176f, -0.03129743f, 
    -0.03988595f, -0.02823070f, 0.03841747f, 0.02570280f, -0.04673031f, -0.01781500f, 0.00602898f, -0.01585919f, 
    -0.01073876f, 0.03307835f, 0.00812734f, -0.00243569f, -0.02489733f, 0.03566530f, 0.03931047f, -0.02120028f, 
    -0.05671800f, -0.03896276f, -0.02554793f, 0.04189574f, -0.04122633f, -0.00324512f, 0.02153119f, -0.05563143f, 
    -0.01621792f, 0.02119682f, 0.01656110f, -0.03744476f, 0.00678717f, -0.03798058f, -0.00151086f, -0.01554401f, 
    -0.04225393f, -0.04463444f, 0.02866630f, 0.00795478f, -0.01710075f, -0.01445680f, 0.00295628f, 0.01242598f, 
    -0.01948444f, -0.04451304f, 0.00245756f, -0.05190620f, -0.04870495f, -0.01083228f, -0.00414998f, -0.04147186f, 
    -0.03193319f, 0.03956911f, 0.01682224f, 0.02592439f, -0.01042709f, -0.01005451f, -0.00982978f, 0.00139302f, 
    0.04388820f, -0.00638214f, -0.02979825f, -0.01478875f, -0.00888256f, -0.01191098f, -0.01574120f, 0.03937593f, 
    -0.00169588f, -0.03419342f, 0.02527254f, -0.02079099f, 0.02863143f, -0.05354707f, 0.04137342f, -0.02236167f, 
    -0.00494514f, 0.02420449f, -0.01118833f, 0.00174345f, -0.03848604f, -0.00409306f, 0.04682483f, 0.00838591f, 
    0.02075816f, -0.04816939f, -0.02258590f, 0.03764526f, -0.01641569f, -0.02854150f, 0.03461125f, 0.00823444f, 
    -0.04770124f, 0.01746844f, 0.03855734f, -0.04273764f, -0.01957375f, 0.03240193f, 0.00977983f, -0.04905679f, 
    -0.01157842f, -0.02934437f, -0.03532137f, -0.04054990f, -0.04865593f, -0.01420023f, 0.03796756f, 0.02552260f, 
    -0.03727236f, -0.02628701f, 0.02068707f, 0.03159475f, -0.02754490f, -0.05401818f, -0.00971396f, -0.01005514f, 
    -0.03048359f, -0.04582641f, -0.01698547f, 0.03939715f, 0.05121184f, -0.02136711f, 0.01398467f, -0.02734723f, 
    -0.02864740f, -0.05086989f, -0.01220892f, 0.00436601f, 0.03219294f, 0.00164458f, 0.02933954f, 0.02514237f, 
    -0.04485211f, 0.00988549f, 0.01700049f, 0.01985063f, 0.00684919f, -0.01282551f, 0.03833702f, -0.05446430f, 
    -0.05207740f, 0.01859709f, -0.04568683f, -0.01693941f, -0.04485763f, 0.02513660f, -0.03739148f, -0.01916340f, 
    0.01047928f, 0.02805252f, -0.02805995f, 0.03461686f, -0.03310398f, 0.02516102f, -0.00486668f, -0.03124483f, 
    -0.04505799f, 0.00390793f, 0.02277706f, -0.04534684f, 0.02169024f, 0.00210659f, -0.00157067f, -0.02095962f, 
    -0.04300685f, 0.00562082f, 0.01151708f, -0.00519922f, 0.00396132f, 0.03585598f, 0.01844875f, -0.02518047f, 
    -0.01614909f, -0.00465368f, 0.00309044f, -0.03451996f, -0.01991599f, 0.03841728f, 0.01802874f, -0.03116226f, 
    0.00352854f, 0.03258546f, -0.00031296f, 0.00948482f, 0.02979242f, -0.02648779f, -0.02608501f, -0.00978158f, 
    -0.05632341f, -0.03192749f, -0.00135946f, -0.04194998f, -0.00673144f, -0.02418758f, -0.04112969f, -0.03260994f, 
    -0.04426279f, 0.00487030f, 0.03275227f, 0.00519926f, 0.00585396f, -0.03216199f, -0.05077767f, 0.02671973f, 
    0.02532778f, 0.00665005f, 0.01091509f, -0.01675693f, 0.01713116f, -0.05602729f, -0.04635040f, -0.01206609f, 
    0.01538130f, 0.02075449f, -0.04939245f, 0.00412209f, -0.02464816f, -0.01773479f, -0.01823887f, -0.00832538f, 
    0.02856236f, 0.13846117f, 0.05217401f, -0.03098341f, 0.01049450f, -0.02489402f, 0.10528234f, -0.15078205f, 
    -0.05782257f, 0.02673463f, 0.11162913f, -0.07082380f, -0.16700271f, -0.01691120f, -0.10405979f, 0.01828581f, 
    0.01164287f, 0.02346879f, 0.24978893f, 0.18130161f, 0.10412446f, 0.05998825f, -0.02169527f, -0.09699631f, 
    0.10217856f, 0.07883126f, -0.11000416f, -0.04299122f, -0.00937046f, 0.00907138f, -0.03544264f, -0.20839275f, 
    -0.03135844f, -0.07516682f, -0.10916618f, 0.08474668f, -0.21050374f, -0.00180334f, -0.04519406f, -0.10333791f, 
    0.04825849f, 0.00711059f, -0.20038036f, 0.00940097f, 0.03873447f, 0.04105455f, 0.07546227f, 0.15174493f, 
    0.17173694f, -0.26022360f, 0.01460223f, -0.25140077f, 0.06840322f, -0.07719743f, -0.15913783f, 0.04024043f, 
    0.07466448f, -0.07479018f, -0.00408706f, -0.09110972f, -0.09621619f, 0.03064021f, -0.04058329f, 0.04938490f, 
    -0.18594354f, -0.13601108f, 0.17860924f, -0.14886366f, 0.00023681f, -0.05802530f, 0.04665538f, -0.15352541f, 
    -0.09860444f, -0.05348892f, 0.19484645f, 0.26278657f, -0.00796577f, 0.04213640f, 0.03624287f, -0.00386475f, 
    -0.10929143f, -0.09236956f, 0.11937138f, -0.00827020f, -0.01157200f, 0.18426593f, -0.01673028f, 0.03989017f, 
    0.00911304f, -0.00382317f, 0.11300676f, -0.00625122f, -0.03685711f, -0.04304524f, 0.04614967f, 0.13158719f, 
    0.09610914f, 0.13341998f, -0.08168777f, -0.09496947f, -0.01926977f, 0.01683895f, -0.19176358f, -0.01237452f, 
    0.02734881f, -0.06756832f, -0.06044651f, -0.10896368f, 0.30558336f, -0.01735118f, 0.03734666f, 0.26417872f, 
    0.00175146f, -0.18105727f, 0.03227868f, 0.18614803f, -0.05441963f, -0.22138505f, -0.08296584f, 0.01615808f, 
    -0.30593354f, -0.05597857f, 0.09546149f, 0.03892142f, -0.00821121f, -0.06988485f, -0.09227693f, -0.05327882f, 
    0.10583612f, -0.09177041f, -0.03492210f, -0.13361906f, 0.23440398f, 0.21155970f, -0.00274345f, -0.06342357f, 
    -0.05286080f, 0.13431174f, 0.02493076f, 0.23109370f, 0.13056777f, 0.01342383f, 0.08335083f, 0.26791254f, 
    0.10389733f, 0.27256402f, -0.08933803f, -0.05396651f, 0.05938511f, -0.04261123f, -0.00778103f, 0.03107014f, 
    -0.10091252f, 0.01109735f, -0.01503307f, 0.03272387f, 0.23876117f, 0.09498895f, 0.01171214f, 0.13686304f, 
    -0.00299830f, -0.15886700f, -0.00664249f, 0.01877089f, -0.14221145f, 0.07020564f, -0.13520826f, -0.20462425f, 
    -0.13955563f, 0.01528394f, -0.11341605f, -0.08209307f, -0.03745555f, -0.11675214f, -0.00265231f, 0.06972410f, 
    0.16392845f, -0.11708931f, -0.14470324f, -0.19989152f, -0.13453531f, -0.38575563f, 0.16982318f, -0.02459707f, 
    -0.04057179f, 0.06394460f, -0.09818190f, 0.28520408f, -0.03382070f, -0.01641279f, -0.00206323f, 0.22355956f, 
    0.54804605f, 0.27228943f, -0.23949325f, 0.15390837f, -0.00888715f, -0.08128835f, 0.08149763f, 0.00539490f, 
    0.06760169f, 0.09225123f, 0.04664344f, 0.01636461f, 0.33336663f, 0.15073153f, -0.07887013f, 0.08398087f, 
    0.05893021f, 0.06401820f, 0.00445885f, 0.07113878f, -0.02727704f, -0.00881123f, -0.02305233f, 0.09481058f, 
    0.55767268f, 0.02798696f, 0.05330342f, 0.02569403f, -0.01779774f, -0.02017406f, 0.07722142f, 0.25570583f, 
    -0.08256222f, 0.14472763f, -0.00743574f, 0.10543773f, 0.07526846f, 0.26946777f, -0.22101448f, -0.20497018f, 
    0.06948875f, 0.02860978f, -0.04496780f, 0.00151772f, 0.03191656f, -0.09673179f, 0.14776787f, 0.01426482f, 
    0.16363904f, -0.01551223f, 0.02266810f, -0.02119066f, -0.05876106f, 0.03454391f, -0.05832282f, -0.00769568f, 
    -0.07935970f, 0.00618767f, 0.04851683f, 0.00118848f, 0.07735641f, 0.10267690f, -0.04271016f, 0.05514199f, 
    0.10288547f, -0.04636310f, -0.03131877f, -0.03572366f, -0.00337496f, -0.03798991f, 0.05487892f, -0.20860235f, 
    -0.21749933f, 0.17608915f, 0.12074115f, 0.08120714f, -0.04769292f, -0.04687294f, 0.00029398f, -0.06665670f, 
    0.12051969f, 0.07027762f, -0.02038894f, 0.01369001f, -0.19848236f, 0.12274544f, 0.15329930f, -0.03183813f, 
    0.03523414f, -0.00526187f, -0.10925323f, 0.11000922f, 0.03081558f, 0.05299103f, 0.01405491f, -0.01986920f, 
    -0.18298520f, -0.01045716f, 0.16155489f, -0.14501794f, 0.05515882f, 0.09037665f, 0.05837905f, -0.07492228f, 
    0.00550149f, 0.07610807f, -0.02737488f, 0.01652557f, -0.19826847f, -0.03950450f, -0.01317914f, -0.02170985f, 
    -0.09545013f, 0.00155620f, 0.00212197f, 0.03844656f, -0.10316911f, -0.13456558f, 0.04246920f, 0.03159587f, 
    0.08183189f, 0.04049395f, 0.11700496f, 0.25324309f, 0.03710343f, -0.03319550f, 0.08904737f, -0.07513994f, 
    0.03650187f, -0.07781793f, -0.15386820f, 0.01243941f, 0.17428124f, -0.09923810f, 0.30610204f, 0.10422888f, 
    0.08801814f, -0.01854773f, 0.23481230f, 0.10554631f, -0.08087528f, -0.01248844f, 0.05992565f, 0.05979886f, 
    -0.17567098f, -0.05021388f, -0.00975605f, 0.02602605f, 0.01147115f, 0.12116760f, -0.17607823f, -0.20267941f, 
    0.01443907f, -0.07127920f, 0.04632533f, 0.02526948f, 0.15262502f, 0.05406532f, 0.04819895f, -0.10231528f, 
    0.03654653f, -0.08110970f, -0.12468363f, -0.00227843f, -0.00291868f, 0.15956946f, -0.01054512f, 0.07557212f, 
    0.17210336f, -0.19789878f, 0.01182669f, 0.10498068f, -0.05252806f, -0.00570827f, 0.09984443f, -0.06723970f, 
    -0.02729112f, -0.07877144f, 0.06977392f, 0.01445128f, 0.52097875f, 0.11568063f, -0.06255283f, -0.00804966f, 
    -0.09358972f, -0.03009514f, 0.07152688f, -0.08418702f, -0.13206252f, -0.07848597f, 0.17986304f, 0.15020598f, 
    0.07907878f, -0.01078507f, -0.09219947f, 0.06368054f, 0.00570995f, 0.14269757f, -0.00677416f, -0.03332756f, 
    0.01662957f, 0.02259585f, 0.00979598f, -0.01523146f, -0.00001048f, -0.08512750f, -0.10655408f, -0.04588586f, 
    -0.01056512f, -0.04509478f, 0.00212361f, -0.04875538f, -0.06009461f, -0.00307572f, -0.04278537f, 0.20617840f, 
    -0.05728560f, -0.18269415f, 0.01078771f, 0.25249487f, -0.04654697f, 0.05349326f, -0.10314196f, 0.01522825f, 
    -0.00894237f, -0.03041436f, 0.07015560f, -0.15726091f, 0.02286004f, -0.04750269f, -0.07731806f, 0.17657577f, 
    -0.00451208f, -0.05615431f, 0.02779179f, -0.07478774f, -0.05411743f, 0.01822490f, 0.04081053f, 0.03943864f, 
    0.05931932f, -0.08320300f, -0.19317384f, -0.04703559f, 0.17001505f, -0.01803782f, 0.07663387f, -0.10680649f, 
    0.10914835f, 0.15828770f, -0.04800405f, 0.17021573f, 0.18803965f, 0.11913560f, -0.06990336f, 0.03077183f, 
    -0.00781078f, -0.03463054f, -0.09694245f, -0.07031146f, -0.17765655f, 0.11486988f, -0.01112196f, 0.08793271f, 
    0.19409862f, 0.06012509f, 0.27540377f, 0.21760722f, -0.03309376f, 0.05872494f, 0.00116038f, -0.04783054f, 
    -0.06226357f, -0.03742038f, 0.03230647f, 0.05637044f, 0.18535872f, -0.09527369f, 0.07013010f, 0.05020690f, 
    -0.09552094f, -0.10608754f, 0.00204568f, -0.07715648f, 0.04394566f, -0.00257535f, 0.09567997f, -0.01195614f, 
    -0.08288393f, -0.00604166f, -0.00207152f, -0.08966922f, -0.06108630f, -0.08373984f, 0.03001039f, -0.12718807f, 
    -0.14720407f, 0.06128700f, 0.01934739f, 0.00830626f, 0.18965138f, 0.26659003f, 0.15731531f, 0.27963814f, 
    0.15493983f, 0.00337335f, 0.13711724f, -0.02628735f, 0.04136162f, 0.10195855f, -0.10309543f, 0.01779460f, 
    -0.24603085f, -0.32876390f, -0.12234741f, 0.09657130f, 0.09391126f, -0.01679623f, -0.08167577f, -0.00344104f, 
    0.09019054f, 0.02503910f, -0.00074045f, 0.04142852f, 0.19684888f, 0.07388751f, -0.17949972f, -0.01848330f, 
    0.05908161f, 0.00818852f, -0.07943159f, 0.00352539f, -0.01380496f, -0.01182304f, -0.02608570f, 0.12804179f, 
    0.02954726f, 0.01254901f, -0.00368240f, 0.07039283f, -0.14866684f, 0.04263442f, 0.01186736f, -0.04841844f, 
    -0.00363497f, 0.00848639f, 0.02173611f, -0.14642881f, 0.00458281f, 0.09670570f, -0.00543477f, 0.12698767f, 
    0.01187411f, -0.07927417f, -0.13835639f, -0.10417144f, -0.06366253f, -0.06712569f, -0.02636116f, -0.03552439f, 
    0.13738836f, 0.10025800f, -0.14065054f, 0.10768129f, 0.13882589f, 0.00128313f, -0.10697647f, 0.08375163f, 
    -0.02069526f, 0.06171612f, 0.10049937f, -0.00206548f, 0.08477150f, 0.07434838f, 0.19738747f, 0.15262981f, 
    0.00021272f, -0.04953715f, 0.12133174f, 0.09046075f, 0.05080738f, 0.03062678f, 0.03340454f, 0.10440922f, 
    0.19732556f, 0.18962516f, -0.03997517f, -0.06306905f, 0.12771706f, -0.07327599f, 0.06186543f, 0.08522125f, 
    0.17484803f, 0.09664199f, 0.06933168f, 0.11725531f, -0.36183223f, 0.23930451f, -0.15005420f, 0.10466021f, 
    0.06948490f, -0.11753810f, -0.15486170f, 0.12749761f, 0.09543871f, -0.01296813f, 0.02769732f, 0.00588016f, 
    -0.25565344f, 0.25990030f, -0.01552353f, 0.09278217f, 0.01423463f, -0.06857126f, -0.08723123f, -0.02855222f, 
    -0.04428156f, -0.01217560f, 0.10688080f, 0.07090959f, 0.00099923f, 0.15894158f, -0.03748862f, 0.00466664f, 
    0.05902198f, -0.20331185f, 0.09562837f, 0.03305456f, -0.00684061f, -0.11895163f, 0.05843093f, 0.08655174f, 
    0.20533496f, 0.19739735f, 0.25857249f, 0.06839008f, 0.13833012f, 0.11733767f, -0.08642039f, 0.02458334f, 
    -0.09250011f, -0.05873270f, 0.05293286f, 0.11199024f, -0.09890336f, -0.10744814f, -0.04585457f, 0.00949875f, 
    0.02964899f, -0.00459070f, -0.02225218f, -0.05108338f, 0.03314482f, -0.05030006f, -0.06238464f, -0.01033701f, 
    0.22719561f, 0.09632760f, -0.13043289f, 0.03773238f, -0.04355392f, -0.07511166f, -0.16653678f, -0.11985052f, 
    0.02298762f, -0.10177445f, 0.03177961f, -0.07330740f, -0.32543087f, -0.21582077f, 0.02835612f, -0.07061559f, 
    0.10566344f, -0.00616717f, -0.04945577f, 0.02561519f, -0.01144974f, -0.06432770f, -0.01677806f, 0.06354981f, 
    0.13427807f, 0.02438372f, -0.12200890f, -0.21492843f, 0.13155432f, -0.12314447f, -0.06235658f, -0.00312637f, 
    0.07097873f, -0.03150992f, -0.02532877f, 0.03753864f, 0.12882219f, 0.19021851f, 0.39556959f, -0.01330189f, 
    0.10908896f, 0.00363425f, -0.00702084f, 0.06170842f, -0.07410508f, 0.06988788f, 0.03125409f, 0.10552826f, 
    -0.15800796f, -0.18460807f, 0.04186003f, -0.19195391f, -0.04009978f, 0.01596564f, -0.13435999f, 0.01930843f, 
    -0.02869815f, 0.15062469f, -0.04866809f, 0.02535925f, 0.11210080f, -0.10936707f, 0.36058736f, 0.10019018f, 
    0.11754549f, -0.01476165f, 0.06323327f, -0.01386633f, -0.15788746f, -0.00601326f, 0.00740165f, 0.04622009f, 
    -0.09179848f, -0.06783164f, 0.02898587f, 0.03855735f, -0.20570688f, -0.06593185f, 0.04781134f, -0.00176694f, 
    -0.00267595f, 0.03700976f, -0.06648184f, -0.00012185f, 0.07420914f, 0.04378558f, -0.26182339f, -0.03053679f, 
    0.00381115f, -0.00178988f, -0.03960112f, 0.09824560f, 0.05824551f, 0.00221184f, 0.08710515f, 0.08404987f, 
    0.05069441f, -0.15152219f, 0.08134297f, -0.02336490f, -0.14244363f, -0.03154099f, -0.14963345f, 0.06706915f, 
    -0.00289930f, 0.01901485f, -0.12548740f, 0.10649968f, -0.13701583f, -0.08206654f, 0.07004618f, -0.06369694f, 
    -0.03941404f, 0.03637434f, -0.00898677f, -0.00461432f, 0.00851522f, -0.03604096f, -0.14271468f, 0.13323878f, 
    0.01648147f, -0.06506500f, -0.02834291f, 0.29793504f, 0.05875729f, 0.07768805f, 0.00018436f, 0.03290032f, 
    -0.01736249f, 0.07608710f, -0.01458893f, 0.11196440f, -0.06018157f, -0.06381809f, -0.12540643f, 0.18335865f, 
    -0.07478054f, -0.07369375f, -0.06402656f, 0.00767025f, 0.09360208f, 0.04853399f, 0.00182293f, 0.05013080f, 
    -0.00766203f, -0.12472828f, 0.10391276f, 0.11379775f, 0.00310619f, 0.06728512f, 0.07387181f, -0.01201153f, 
    0.05350093f, 0.16212963f, -0.05145840f, 0.07549653f, 0.14897002f, -0.08211257f, 0.06793890f, -0.00433992f, 
    -0.00007123f, 0.09472173f, 0.05854078f, 0.00050375f, 0.07186090f, 0.06246497f, 0.03887777f, -0.06841682f, 
    -0.11614576f, 0.14202943f, -0.12862094f, 0.11014594f, 0.11421104f, 0.01890095f, 0.08919118f, -0.04512540f, 
    -0.09117763f, -0.10169321f, 0.05511791f, 0.12278527f, 0.09131223f, -0.22745313f, 0.06887250f, -0.02048720f, 
    -0.07110639f, -0.01969635f, 0.13357590f, -0.08072086f, -0.15874404f, 0.01017431f, 0.03191992f, 0.02220315f, 
    0.34697959f, 0.05076715f, -0.06796247f, -0.05204164f, -0.11714520f, -0.12419599f, -0.05586225f, 0.15921204f, 
    0.04013506f, -0.01535898f, -0.04706447f, 0.08345494f, 0.05497292f, -0.09748238f, -0.17594871f, 0.43565786f, 
    -0.04405981f, 0.00609408f, 0.07420934f, 0.04964033f, 0.11254403f, -0.01682123f, 0.03079232f, 0.03557258f, 
    0.06529564f, -0.12700678f, 0.03745256f, -0.14266381f, 0.08897731f, 0.04392713f, -0.03167040f, -0.11513519f, 
    0.15759756f, -0.03289546f, 0.13980825f, -0.10746460f, -0.12890360f, 0.01807842f, 0.04112643f, -0.33898756f, 
    0.05146850f, -0.01891678f, 0.15404718f, 0.17131197f, 0.02498825f, -0.03927349f, 0.05704557f, 0.03583867f, 
    -0.06476528f, -0.10990510f, 0.15157783f, -0.16301394f, -0.02016081f, 0.02815478f, 0.01112735f, 0.08941055f, 
    0.02978062f, 0.07520179f, -0.11460640f, -0.08286522f, -0.00383722f, -0.01409376f, 0.04737397f, -0.15650529f, 
    -0.04721919f, 0.09659736f, 0.05152819f, -0.07758567f, -0.00928354f, -0.01983533f, -0.01114544f, 0.09032217f, 
    0.04945568f, -0.03697798f, -0.01849977f, 0.25955644f, 0.02940729f, -0.05881124f, -0.03215457f, 0.14546229f, 
    -0.16077030f, 0.01343756f, 0.02799094f, -0.08765662f, 0.22562210f, -0.21684809f, -0.18896988f, 0.37887710f, 
    -0.12428824f, 0.00695961f, -0.01963143f, 0.04933181f, 0.07560591f, 0.00315386f, -0.02023518f, -0.04976478f, 
    -0.18027142f, 0.09728463f, 0.29384169f, -0.45993087f, -0.01169334f, 0.17639194f, 0.08848719f, 0.19791719f, 
    -0.01069763f, -0.00040735f, -0.04087939f, 0.06028166f, 0.37071860f, 0.08325179f, -0.08861710f, 0.24150702f, 
    -0.04179171f, 0.03887228f, -0.13225310f, -0.02339320f, 0.09716473f, 0.09173820f, 0.04134906f, 0.01708279f, 
    -0.28829968f, -0.17930315f, 0.21071327f, -0.44103172f, 0.02702414f, -0.11219443f, 0.09704050f, 0.10474577f, 
    0.05052120f, 0.07099415f, 0.02012439f, 0.05504802f, 0.28069973f, 0.05261714f, 0.16388984f, -0.15614681f, 
    0.06949884f, -0.01119199f, 0.14006153f, -0.06764629f, 0.11715584f, 0.09152362f, 0.02868729f, 0.19568111f, 
    0.06718358f, 0.01845814f, 0.07915570f, -0.01538652f, -0.02625415f, -0.06479385f, -0.00713914f, 0.13400827f, 
    0.14646454f, 0.03770928f, 0.08158707f, 0.01489961f, -0.00519333f, 0.01872421f, 0.05108704f, -0.27669078f, 
    -0.04516290f, 0.12565245f, 0.15401053f, -0.02205958f, 0.02882829f, -0.03498764f, 0.13781305f, -0.19636858f, 
    0.17696108f, -0.05324401f, 0.04976760f, 0.09487489f, -0.10755187f, -0.11139739f, -0.02384112f, 0.15803730f, 
    0.06456902f, -0.05159653f, -0.03465221f, 0.05592891f, 0.17817566f, -0.05909389f, -0.07959600f, 0.15702097f, 
    0.02828903f, 0.00253392f, 0.08606959f, 0.07689141f, -0.05002608f, 0.06303602f, -0.05522155f, -0.03599380f, 
    0.05637047f, 0.11952513f, 0.10687737f, 0.06957521f, -0.02383565f, -0.04806364f, -0.01300418f, 0.02690985f, 
    -0.02536036f, 0.10962710f, -0.04146813f, -0.08427971f, -0.08562148f, 0.07439352f, -0.06645022f, -0.20752385f, 
    0.05490863f, 0.00827636f, 0.02329741f, -0.08462512f, 0.05771375f, 0.05542176f, 0.04869160f, -0.04252780f, 
    0.05625949f, 0.07772387f, 0.14339480f, -0.27260292f, -0.12023604f, 0.00983894f, 0.04322477f, -0.01851977f, 
    -0.07795981f, 0.00867024f, -0.05515528f, -0.00595229f, -0.03257426f, -0.15056488f, 0.09955510f, -0.00728992f, 
    -0.03644666f, -0.06050903f, 0.08853509f, 0.27581799f, 0.05589211f, 0.09654524f, 0.03338894f, 0.18680099f, 
    0.03513912f, 0.03723249f, -0.05951584f, 0.06058617f, 0.01793963f, -0.00111847f, 0.05694528f, -0.10181288f, 
    -0.01165731f, 0.10528888f, -0.03200850f, 0.07476795f, -0.10445896f, 0.02047809f, 0.12937400f, -0.23172876f, 
    0.02433999f, 0.11577569f, 0.09902571f, 0.09379990f, -0.03363702f, -0.02182530f, 0.06972761f, 0.04874185f, 
    0.02107216f, -0.12580948f, -0.13354112f, 0.16423966f, -0.01430898f, -0.03024313f, 0.00012630f, -0.09522539f, 
    -0.07133023f, -0.04298207f, -0.01368981f, 0.07438006f, 0.08310608f, 0.06115440f, -0.04577391f, -0.53018320f, 
    -0.01513051f, -0.00655297f, 0.10719628f, -0.01036244f, -0.04836910f, -0.06204671f, -0.07486662f, 0.05335916f, 
    0.25104180f, 0.11318199f, -0.02770193f, 0.21475339f, -0.06838065f, 0.02830081f, -0.14341509f, -0.02964716f, 
    0.02724333f, 0.19074981f, 0.04286453f, 0.02982302f, -0.09527039f, 0.15461417f, 0.03741212f, 0.05855947f, 
    -0.02179353f, 0.06042005f, 0.12966150f, 0.05743522f, -0.06516103f, 0.00038348f, -0.01413450f, -0.02155836f, 
    -0.01227270f, 0.01429827f, 0.00491535f, -0.01104262f, -0.02599905f, 0.01282143f, -0.04388360f, -0.01466693f, 
    0.01356048f, -0.05704884f, -0.01963560f, 0.03963203f, -0.02808210f, 0.03085919f, 0.00635029f, 0.02475791f, 
    0.02024218f, -0.02191024f, -0.04119610f, 0.02306417f, -0.02020694f, 0.03201516f, -0.05058795f, -0.04333286f, 
    -0.04306564f, 0.03412838f, 0.01634117f, -0.03206291f, -0.04334667f, 0.03648281f, -0.03225394f, -0.01253275f, 
    -0.00243859f, -0.01698087f, 0.00119528f, 0.03338952f, -0.00460386f, 0.01453701f, 0.03223614f, 0.03540046f, 
    -0.00373615f, -0.03820919f, -0.05765278f, -0.04187008f, -0.01315947f, -0.02738678f, -0.03969492f, -0.05584037f, 
    -0.05188058f, 0.00379734f, -0.03092797f, 0.02351190f, -0.03249888f, -0.05266589f, -0.03989684f, -0.03965802f, 
    0.00787980f, -0.01990578f, 0.00096986f, -0.04522260f, -0.05016139f, 0.00983828f, 0.00130393f, 0.01641092f, 
    0.03827591f, 0.03229004f, 0.04309586f, -0.02348446f, -0.03387136f, -0.00674978f, 0.03644058f, -0.05875612f, 
    0.03798791f, 0.00005748f, -0.04526094f, 0.03754121f, -0.05199947f, -0.02128826f, -0.03114450f, 0.00592733f, 
    -0.01786778f, -0.00913176f, 0.02411585f, -0.02639122f, 0.00160947f, 0.03813151f, -0.01507245f, 0.01430022f, 
    -0.00613199f, -0.00291986f, -0.03007228f, -0.01538199f, -0.04588758f, -0.02041091f, -0.04292310f, 0.00272106f, 
    -0.02779849f, 0.02466860f, 0.03773605f, -0.01225646f, -0.01858136f, 0.00890085f, 0.03265372f, -0.02774283f, 
    0.03624443f, -0.05442788f, -0.05822977f, -0.01588696f, 0.04015305f, -0.04707080f, -0.03149386f, -0.02271848f, 
    -0.01219179f, 0.01424007f, 0.01250823f, -0.02042961f, -0.03680322f, -0.05044539f, -0.04854184f, 0.00528889f, 
    -0.02492718f, 0.03841920f, 0.03729593f, -0.00730327f, 0.00679992f, 0.00901196f, -0.01384886f, 0.01542857f, 
    0.01768098f, -0.03126690f, -0.04443849f, 0.01823299f, -0.05703133f, -0.00262592f, 0.02946456f, -0.03019673f, 
    0.03698026f, -0.02301056f, -0.02523269f, 0.02156845f, -0.00617546f, 0.01882886f, -0.04310045f, -0.02305436f, 
    -0.03297591f, 0.02616297f, 0.00238169f, -0.04921607f, 0.03356098f, -0.02336537f, -0.00442070f, 0.02792496f, 
    -0.05720590f, -0.02977308f, 0.01052382f, -0.05138392f, -0.05593801f, 0.00501744f, 0.00236429f, -0.02855331f, 
    -0.03432147f, 0.01591520f, 0.03396050f, -0.03735035f, -0.03874939f, -0.01523001f, 0.01015529f, -0.00922112f, 
    -0.05676269f, 0.01836051f, -0.03002841f, -0.05077607f, 0.00410741f, -0.04754000f, -0.04967458f, 0.02791939f, 
    -0.03129661f, -0.01332017f, -0.05471614f, -0.03978071f, -0.01881499f, -0.00051619f, -0.04340578f, -0.05586431f, 
    -0.02340908f, 0.03887326f, 0.01781880f, -0.04277741f, -0.03804104f, -0.05616257f, -0.01354519f, -0.05364146f, 
    0.01935253f, 0.01276364f, -0.02731984f, -0.01081282f, 0.03259270f, -0.00144957f, 0.03154443f, 0.00320216f, 
    0.00047867f, -0.02843801f, -0.02579122f, 0.02623454f, -0.04367273f, -0.01071735f, -0.01299804f, -0.04568841f, 
    0.02569899f, -0.00383375f, 0.01180413f, -0.02382552f, -0.01792761f, 0.01503990f, 0.02955918f, -0.02055810f, 
    -0.00368012f, -0.00713788f, -0.04911954f, -0.03281560f, -0.00420292f, -0.02200036f, -0.03670868f, 0.03768658f, 
    0.00182364f, -0.01636077f, -0.05100438f, -0.04308277f, -0.00027275f, 0.03381540f, 0.01200018f, -0.03641702f, 
    -0.03654363f, 0.04041309f, 0.03528773f, -0.03770783f, -0.02477402f, 0.03213906f, -0.02201221f, 0.00658340f, 
    0.02956468f, 0.02581840f, 0.03943577f, -0.04039042f, -0.01212359f, -0.05582987f, -0.05564317f, 0.03667924f, 
    -0.05026484f, -0.01295855f, 0.00143907f, -0.01286118f, -0.05354078f, -0.01853966f, -0.02944872f, 0.04044357f, 
    -0.01816586f, -0.00415439f, -0.04881756f, -0.01215554f, -0.05427535f, -0.00824735f, 0.00869600f, -0.02035828f, 
    -0.04959373f, 0.02917238f, 0.01957534f, 0.03403704f, 0.02797266f, -0.00420619f, 0.01952995f, -0.04416159f, 
    0.02107817f, -0.03442133f, 0.02100796f, -0.02435456f, -0.00716327f, -0.03842633f, 0.03720211f, -0.01913031f, 
    0.02689645f, -0.04827026f, 0.02701211f, -0.01722351f, 0.01396879f, -0.00032535f, 0.04089847f, -0.04290343f, 
    -0.04584693f, 0.00898794f, -0.04699191f, 0.04222075f, -0.00226028f, -0.00895224f, 0.00982271f, -0.00967919f, 
    -0.04782185f, -0.00821165f, -0.02431922f, -0.00156443f, 0.01011721f, -0.01287773f, -0.04857339f, 0.01547395f, 
    0.00177405f, -0.02084866f, 0.00511005f, 0.02924799f, -0.01363601f, -0.00634357f, -0.04876045f, 0.01883794f, 
    -0.04795612f, -0.04001867f, -0.04047439f, 0.01350931f, 0.01969353f, 0.00431755f, 0.01872243f, 0.04145598f, 
    -0.04645994f, -0.00599103f, -0.01433393f, -0.00432764f, 0.00253225f, -0.02294308f, 0.04154435f, -0.01689438f, 
    0.01407175f, 0.03888662f, -0.01353216f, 0.00019761f, -0.04738720f, 0.03709371f, -0.04620020f, 0.03951474f, 
    0.03681596f, -0.02739303f, 0.03761236f, 0.02596803f, -0.01121437f, 0.02914801f, -0.00542127f, -0.00088364f, 
    -0.04511452f, -0.05294106f, -0.02316147f, -0.04089514f, -0.02243825f, -0.05518976f, -0.01090136f, -0.04509106f, 
    -0.03117540f, 0.03625700f, 0.02558707f, 0.03939016f, -0.04189735f, 0.01238443f, 0.03800496f, -0.00589563f, 
    0.04063840f, -0.01076279f, -0.04347954f, -0.03860961f, 0.02273710f, 0.01708273f, 0.00539006f, -0.02115280f, 
    -0.04015185f, -0.01094428f, -0.02349853f, 0.01032768f, -0.01048914f, 0.01337915f, -0.01800428f, -0.01094212f, 
    0.03222809f, -0.00126587f, -0.03457616f, 0.01518564f, 0.00331077f, -0.01908665f, -0.00145497f, -0.01905873f, 
    -0.06668454f, -0.00685871f, 0.01787778f, -0.03518778f, 0.00410009f, -0.05403562f, 0.03237534f, 0.03514069f, 
    -0.02666852f, -0.01985937f, -0.04553883f, -0.04359652f, 0.00376036f, -0.03268558f, -0.02350070f, 0.01091658f, 
    -0.04868729f, 0.01384953f, -0.00358381f, 0.02618751f, 0.03248262f, -0.01656454f, 0.01710629f, -0.05064001f, 
    0.01119379f, -0.02077538f, 0.01010166f, 0.01179970f, 0.00832209f, -0.00409593f, 0.03216532f, -0.02927807f, 
    -0.01574591f, 0.03328140f, -0.02488044f, -0.05711255f, 0.02393132f, -0.04610634f, 0.03134276f, -0.00944679f, 
    -0.02611948f, 0.02381979f, -0.05180934f, 0.04933548f, -0.04573288f, 0.01211445f, -0.02194442f, 0.01534739f, 
    0.04969631f, -0.01302924f, -0.00032273f, -0.05106669f, -0.03388644f, 0.03346578f, 0.01333956f, 0.01702370f, 
    -0.00547383f, 0.01687638f, 0.01991107f, 0.02844836f, -0.02166843f, 0.02250554f, -0.01180491f, 0.01670641f, 
    -0.01704031f, -0.05300679f, 0.04181886f, 0.03132207f, -0.02481578f, 0.02694544f, -0.04446865f, 0.04474714f, 
    0.03420632f, -0.01399909f, -0.00902453f, -0.02119685f, 0.01016787f, -0.01518193f, 0.04130225f, 0.04198677f, 
    0.02823780f, -0.03219188f, 0.03290822f, 0.03006981f, -0.02513427f, -0.00026577f, -0.01029872f, -0.03590320f, 
    0.01136439f, 0.00231390f, -0.05176020f, -0.02310758f, -0.02176011f, 0.03953681f, 0.03392569f, -0.04651415f, 
    0.04124877f, -0.05206620f, -0.01319066f, 0.03837918f, -0.03112370f, -0.04768033f, 0.04113468f, -0.02358689f, 
    0.02377638f, -0.01266448f, 0.01234739f, 0.00845440f, 0.02839283f, -0.00122544f, 0.03840430f, 0.00195272f, 
    -0.03133264f, 0.03134161f, 0.01455409f, -0.04665924f, 0.00610665f, -0.00282001f, -0.04313738f, -0.01906434f, 
    -0.01187293f, -0.02139619f, -0.01531198f, 0.00488420f, 0.01976752f, -0.05171154f, -0.03568040f, 0.01335532f, 
    -0.05043361f, -0.02714379f, 0.02481393f, -0.01894615f, -0.00983867f, 0.02851120f, -0.01314987f, -0.04264050f, 
    -0.02476571f, -0.01100072f, -0.00081564f, 0.01187456f, 0.00899991f, 0.04138782f, 0.03490490f, 0.00458501f, 
    0.00580477f, -0.00404252f, -0.01818664f, 0.00910281f, 0.00452960f, 0.02730362f, -0.04379328f, 0.02520697f, 
    0.00895351f, -0.04194248f, 0.01619704f, -0.05851734f, -0.00604228f, -0.05129080f, -0.05584882f, -0.00185195f, 
    0.05275225f, -0.02281917f, 0.02634438f, -0.00443655f, 0.01571651f, 0.00388222f, 0.03044626f, -0.00236499f, 
    0.01927055f, -0.01132520f, -0.01745403f, -0.02992785f, -0.00566172f, -0.05372987f, 0.00540894f, 0.03154843f, 
    -0.03547019f, 0.01279430f, 0.02250133f, 0.03661128f, -0.03496201f, -0.00557710f, -0.05274287f, -0.05475976f, 
    -0.00401540f, -0.00904139f, -0.00333360f, -0.03452193f, -0.05163949f, 0.04185117f, 0.01110013f, -0.01264660f, 
    0.01692919f, 0.02704845f, -0.02176679f, -0.01047128f, -0.05020757f, -0.04788033f, -0.03400894f, -0.05370066f, 
    0.00634547f, 0.04230763f, -0.01054741f, -0.03008247f, -0.00377874f, -0.05109884f, -0.01894004f, 0.03795008f, 
    -0.00377679f, 0.03052688f, -0.05157687f, 0.00190549f, -0.02256975f, -0.05905035f, -0.02615542f, -0.02350418f, 
    -0.04408620f, 0.02498161f, 0.03657513f, 0.01879374f, -0.02128433f, -0.02947386f, -0.01610458f, 0.01696531f, 
    -0.02637521f, 0.01373815f, 0.00342206f, -0.01810066f, 0.00865331f, 0.00027277f, -0.06055421f, 0.01626974f, 
    0.04096590f, -0.02036553f, -0.05440266f, -0.00624492f, 0.00203013f, 0.00189231f, -0.00700179f, 0.00757401f, 
    -0.04653011f, 0.01007379f, 0.01365496f, -0.01778511f, -0.02899454f, 0.01738182f, -0.03420023f, -0.00870768f, 
    -0.00610850f, -0.06261516f, -0.05494656f, -0.01854543f, -0.01137125f, -0.00060686f, 0.01061436f, 0.02823239f, 
    0.04842697f, 0.02471888f, 0.00514431f, -0.00878854f, -0.02225239f, 0.01332417f, 0.01277738f, -0.05716804f, 
    -0.04975943f, 0.01974387f, -0.05174340f, 0.00577838f, -0.01133286f, 0.03662892f, -0.00176464f, -0.04401790f, 
    0.01651679f, 0.03110876f, 0.03106365f, -0.01430454f, -0.01390038f, -0.00287998f, 0.01650575f, -0.02627968f, 
    -0.02472936f, 0.03453802f, -0.03754358f, -0.01480467f, 0.03466405f, 0.03802021f, -0.02334661f, -0.00309402f, 
    -0.02820203f, -0.02862408f, 0.03719211f, 0.00456573f, -0.05030379f, -0.04531460f, 0.03461916f, 0.01764301f, 
    0.00063661f, -0.05373457f, 0.02179943f, -0.03380244f, 0.01846063f, 0.04285007f, -0.04033757f, -0.02991438f, 
    0.00311100f, -0.00789485f, -0.04864794f, -0.01818399f, 0.04108865f, -0.01503797f, -0.03364460f, 0.03323232f, 
    0.01216601f, 0.04036564f, -0.01224936f, 0.02490479f, -0.05050437f, 0.00296586f, -0.01898445f, 0.00917185f, 
    -0.03416672f, 0.03844764f, 0.02219541f, -0.04227571f, -0.02494601f, 0.01856144f, -0.00053568f, 0.03912749f, 
    -0.03269199f, 0.02043021f, -0.03667942f, -0.01402484f, 0.00563070f, -0.01350088f, -0.00757685f, -0.01338817f, 
    0.01328918f, 0.01061552f, -0.05732133f, -0.03984020f, -0.03659147f, 0.03108414f, -0.03753089f, 0.00692513f, 
    -0.00075457f, 0.00140986f, 0.03802156f, -0.01103638f, 0.00014132f, -0.03266259f, -0.05008098f, -0.02525886f, 
    -0.03718260f, 0.02685616f, -0.03430147f, 0.01201886f, 0.03695974f, -0.03631471f, -0.03649331f, -0.00057872f, 
    -0.03691591f, 0.02852263f, 0.01646991f, -0.04332722f, 0.02205518f, 0.00978620f, 0.01913144f, -0.05249639f, 
    0.03820785f, 0.02736895f, -0.00151820f, 0.02881247f, 0.03758810f, -0.02575228f, 0.02913961f, 0.02388905f, 
    -0.01199481f, 0.01302816f, 0.01897207f, 0.01208660f, 0.01504311f, -0.02994992f, -0.02731243f, 0.00923934f, 
    -0.20460577f, -0.10154265f, 0.03567146f, -0.13198654f, 0.00048471f, -0.05187940f, -0.04811315f, -0.07232864f, 
    0.06894097f, -0.08077508f, -0.07426061f, -0.16540834f, -0.25837249f, -0.29972807f, 0.13727877f, -0.04577995f, 
    0.09827628f, 0.01954343f, -0.07733797f, -0.18135265f, -0.12636012f, -0.12658107f, -0.03539808f, 0.05097007f, 
    -0.06616710f, -0.02466929f, 0.07160348f, -0.07515459f, -0.06088339f, -0.02256957f, 0.01803964f, 0.02048765f, 
    -0.19220442f, -0.01812402f, 0.04014927f, -0.11480556f, -0.12545460f, -0.09120614f, -0.02701129f, -0.01907096f, 
    0.00293784f, 0.02709383f, -0.09308419f, -0.09439772f, 0.07036632f, -0.04317736f, -0.12224336f, -0.06580704f, 
    0.20349088f, 0.16877489f, -0.14625296f, 0.14841276f, 0.15775442f, 0.05071033f, 0.13837084f, -0.01857566f, 
    -0.07047527f, 0.13050753f, -0.02382168f, 0.15317103f, -0.10541000f, -0.00152664f, 0.06834795f, -0.09454188f, 
    -0.09590895f, 0.03596417f, -0.05430673f, 0.18707062f, 0.07789472f, 0.00524123f, 0.09048772f, 0.05135040f, 
    0.01512009f, -0.00266693f, 0.09426606f, 0.05227967f, 0.13297796f, 0.15663315f, 0.14747728f, -0.03189407f, 
    -0.00906863f, 0.04793984f, 0.01816075f, 0.12587778f, -0.03657340f, 0.08902562f, 0.01267425f, 0.00160552f, 
    -0.05212654f, -0.00934490f, -0.01176955f, -0.08577320f, -0.04012233f, 0.01368701f, -0.05835257f, -0.04964501f, 
    -0.24403970f, 0.14944388f, -0.11356540f, -0.16752957f, 0.01131907f, -0.12000157f, 0.05604257f, 0.04570206f, 
    0.11230427f, 0.15726094f, -0.02492005f, 0.11970486f, 0.09958466f, 0.02451709f, -0.02382248f, 0.26678678f, 
    0.33730906f, 0.10918539f, 0.10413797f, -0.12173934f, 0.09320693f, 0.14972779f, -0.05570716f, 0.04469870f, 
    -0.16828372f, 0.03035044f, 0.14819604f, -0.03948963f, -0.11783310f, -0.11851011f, -0.02458455f, -0.02874300f, 
    -0.11253985f, 0.07265797f, 0.08824554f, 0.06570246f, -0.34664401f, 0.02771463f, 0.01125821f, -0.11980440f, 
    0.01151811f, -0.02492562f, -0.04947226f, -0.01726538f, -0.15646544f, -0.06007453f, -0.10256730f, -0.22933739f, 
    -0.37362346f, 0.39782023f, -0.07483759f, -0.16710946f, -0.06366625f, -0.05696897f, 0.14733975f, -0.01175830f, 
    0.02513185f, 0.02761514f, 0.00837221f, 0.05016097f, -0.34679517f, -0.16585380f, -0.06348372f, -0.14833161f, 
    0.02682162f, 0.03258761f, 0.04246056f, -0.05174181f, 0.00002118f, -0.00632336f, 0.02808809f, 0.03253435f, 
    0.26697308f, -0.01059874f, 0.03916734f, 0.04864296f, 0.05081347f, 0.04680514f, -0.02695362f, 0.05077605f, 
    0.04152615f, 0.05296743f, -0.04083467f, -0.02223947f, -0.03043607f, 0.30622277f, -0.03794323f, 0.04743991f, 
    0.06692489f, -0.04038722f, 0.25582701f, -0.13951717f, -0.00164496f, 0.00381664f, -0.07711619f, -0.02683336f, 
    0.07776029f, 0.08302776f, 0.08019079f, 0.10898118f, 0.08967574f, -0.09284786f, 0.09890611f, 0.05847315f, 
    0.06765823f, 0.02143778f, 0.03377099f, -0.03313360f, -0.14157686f, 0.05278777f, -0.02680377f, 0.07613008f, 
    0.10562615f, -0.07770965f, 0.02399704f, -0.07237637f, 0.09184568f, -0.02134851f, 0.05214403f, -0.13201578f, 
    -0.03770902f, 0.29124454f, 0.04233103f, 0.21593307f, 0.11213098f, 0.04894553f, -0.04594221f, -0.16957687f, 
    0.04058082f, -0.02370079f, 0.07220824f, 0.00562264f, -0.06317850f, 0.03657405f, 0.05604251f, 0.10971580f, 
    0.07959555f, -0.03672450f, 0.03809190f, -0.00714980f, 0.06352392f, 0.15854034f, -0.04037561f, 0.07252872f, 
    0.06042492f, 0.02050602f, 0.07846302f, 0.09714440f, 0.22420375f, 0.15966809f, 0.10727721f, 0.13821313f, 
    -0.05345383f, 0.10105240f, -0.08114840f, 0.04662235f, -0.18363526f, -0.10302613f, 0.00484468f, -0.21801548f, 
    -0.09631356f, 0.00144253f, 0.02644953f, 0.00716753f, -0.01500579f, 0.11884155f, 0.01592741f, 0.13076213f, 
    -0.35976717f, 0.01539937f, -0.06218764f, 0.05503888f, 0.09880371f, -0.01009665f, -0.13966785f, 0.01855632f, 
    0.07932542f, -0.08623659f, 0.06830984f, 0.18017325f, -0.21041761f, 0.00517695f, 0.19661085f, 0.01334697f, 
    -0.04824144f, 0.04661489f, -0.11302633f, -0.03485771f, -0.00115515f, -0.00710092f, -0.02337177f, 0.02951437f, 
    -0.08187593f, -0.33680514f, 0.08550534f, -0.04407552f, 0.04660170f, 0.01475251f, 0.04342659f, -0.14152631f, 
    -0.07663679f, 0.00517497f, -0.00141839f, 0.15309861f, 0.34789351f, 0.07213858f, 0.07469993f, 0.14996921f, 
    0.32406861f, 0.10942346f, 0.00388550f, 0.00820442f, -0.06180792f, -0.02787780f, -0.08112136f, -0.03631889f, 
    0.07217009f, 0.01303014f, -0.01868605f, -0.04350995f, 0.04844699f, 0.02128560f, -0.05649777f, 0.08527976f, 
    0.04221604f, 0.05545185f, 0.11032525f, -0.08090380f, 0.38656685f, -0.05990356f, 0.06923100f, 0.11106878f, 
    0.27760223f, 0.10669633f, -0.04119305f, -0.06676301f, 0.03422363f, 0.05581677f, -0.07045660f, 0.09839444f, 
    -0.03686104f, -0.00230670f, 0.14821459f, 0.02239853f, -0.04478095f, -0.12601553f, 0.05539805f, -0.03110546f, 
    -0.06646062f, 0.08056442f, -0.02022147f, 0.02839336f, -0.09389248f, 0.14003871f, -0.00195259f, 0.07690532f, 
    0.07520244f, 0.05978691f, -0.02075518f, 0.00385436f, -0.09566864f, -0.04782287f, 0.07476202f, -0.21368797f, 
    0.12328731f, -0.09064281f, -0.18051866f, -0.14986916f, -0.01354809f, 0.08693650f, -0.07637646f, 0.21182516f, 
    -0.00340788f, -0.02450501f, 0.06124980f, -0.04267733f, 0.22118908f, -0.04338402f, 0.01718173f, -0.03079490f, 
    -0.04704263f, -0.01251273f, -0.02881912f, -0.12557627f, 0.08586066f, -0.03457778f, -0.20778516f, -0.05947972f, 
    -0.01556036f, 0.03266497f, 0.03863643f, 0.00838753f, 0.02387352f, 0.00460670f, 0.01827805f, 0.00512503f, 
    -0.00577756f, 0.02858731f, -0.04232432f, -0.01461504f, 0.03640706f, -0.02235203f, -0.01675819f, -0.04763108f, 
    0.00277888f, -0.04479511f, -0.02066069f, -0.04324852f, 0.04167573f, 0.03916239f, -0.02235133f, -0.03171463f, 
    -0.01231814f, 0.01995958f, -0.03442026f, -0.02473282f, -0.02337892f, 0.01120696f, -0.04363807f, -0.05339775f, 
    -0.04293742f, -0.05933608f, -0.03537593f, -0.00603649f, -0.00113747f, -0.00671944f, 0.03553199f, -0.04307792f, 
    -0.01863505f, 0.00855754f, -0.01526681f, -0.03426426f, -0.05165951f, 0.00576382f, -0.02221142f, -0.04373638f, 
    0.02181865f, 0.04734952f, -0.01040269f, -0.01206006f, -0.03887070f, 0.03928979f, -0.05162489f, -0.03791615f, 
    0.00688964f, -0.00890867f, 0.02398897f, -0.02856851f, 0.03779283f, -0.02417878f, -0.00822143f, 0.01523781f, 
    0.04111113f, 0.02539900f, -0.03118919f, 0.00528372f, 0.01271040f, 0.01277550f, -0.04132531f, 0.00474545f, 
    -0.00271173f, -0.05234261f, 0.04025083f, 0.01552728f, 0.01316019f, -0.02622648f, -0.01514395f, -0.05223900f, 
    -0.03157319f, -0.01371598f, -0.01874034f, -0.01751252f, 0.00832534f, 0.00354489f, 0.01203186f, -0.01189833f, 
    0.01305831f, -0.05615391f, -0.04558738f, -0.02178110f, -0.00493634f, 0.02525778f, 0.02850311f, 0.00596061f, 
    -0.01335668f, 0.04120564f, -0.03794226f, -0.04073519f, -0.03917174f, 0.00240736f, -0.00705179f, 0.00342601f, 
    0.02023396f, 0.00227922f, 0.01814578f, -0.01861708f, -0.00518486f, 0.03335560f, -0.00322714f, 0.03934319f, 
    -0.00218151f, 0.00119931f, -0.03789864f, 0.02924680f, 0.01778080f, 0.00649090f, 0.04121838f, -0.04304121f, 
    0.03200598f, -0.03788799f, 0.03898717f, 0.01406209f, -0.02886723f, -0.00005493f, -0.02382160f, 0.02715518f, 
    -0.04066747f, -0.02306579f, 0.00052067f, 0.01955189f, -0.02747836f, -0.01678992f, 0.00463052f, 0.01723812f, 
    -0.02542432f, -0.05371394f, -0.04102505f, -0.03752369f, 0.03509275f, -0.00911809f, -0.03216787f, -0.02798417f, 
    0.02876077f, 0.00415690f, 0.03520123f, -0.04793160f, 0.03291648f, 0.04128532f, 0.04146621f, 0.03014447f, 
    -0.04189132f, -0.01073687f, -0.03410571f, 0.04391774f, -0.05116945f, 0.02080251f, 0.03219711f, -0.01253034f, 
    0.01552508f, -0.02497354f, -0.01187494f, -0.05385702f, -0.05466856f, 0.01869064f, -0.04021773f, -0.00654093f, 
    -0.04574575f, 0.00801522f, -0.02836657f, -0.00035254f, -0.05269087f, -0.02545731f, -0.01181086f, 0.02089588f, 
    0.01038054f, 0.00555007f, -0.02630381f, -0.01955703f, 0.03851520f, 0.02247495f, 0.01059355f, 0.02231424f, 
    -0.04122650f, -0.01974608f, -0.02067084f, -0.03657435f, -0.05435432f, -0.04324524f, -0.04144897f, -0.04834384f, 
    0.05212697f, -0.02210034f, -0.04092180f, -0.04623307f, -0.02978206f, 0.01106943f, 0.00306047f, 0.01596068f, 
    0.03803406f, 0.01642829f, -0.04072848f, -0.00616856f, -0.00332751f, -0.00962080f, 0.00333167f, 0.03620921f, 
    -0.00025067f, -0.03317749f, -0.04559681f, 0.02471187f, 0.00035959f, -0.04171108f, -0.01044022f, -0.04218398f, 
    -0.02249380f, 0.01924604f, 0.01644235f, 0.03953592f, 0.04016880f, -0.01055667f, -0.04746297f, -0.00238586f, 
    0.02700008f, -0.03251048f, -0.03212246f, -0.03530396f, 0.03050844f, -0.03964408f, 0.03547928f, 0.01002909f, 
    -0.02520757f, -0.00017751f, 0.04258695f, 0.03659911f, -0.00966648f, 0.01934980f, -0.03771468f, 0.00727894f, 
    -0.03993148f, 0.02341533f, -0.00173954f, -0.00109293f, 0.01332339f, 0.03936363f, -0.04056480f, -0.03703354f, 
    0.00796893f, -0.00776051f, 0.02824270f, -0.03271059f, -0.02871536f, 0.03581829f, -0.02818505f, -0.01372993f, 
    0.02726151f, 0.03479655f, -0.01221671f, -0.03730541f, -0.03207595f, 0.02894555f, -0.02510818f, 0.01259454f, 
    -0.05771143f, -0.04496568f, -0.03593375f, -0.04459256f, -0.05153959f, 0.01542137f, 0.00596434f, 0.01431538f, 
    0.00431325f, 0.01707186f, 0.01090505f, 0.02791385f, -0.00677162f, 0.02982030f, -0.01360342f, -0.03454629f, 
    -0.03246860f, -0.03573453f, 0.02483855f, -0.04090174f, -0.02729067f, -0.03185166f, 0.03839112f, 0.03901655f, 
    -0.04659640f, -0.03222659f, 0.01052309f, -0.02183992f, -0.02603024f, -0.01974069f, 0.01257813f, -0.04978937f, 
    -0.01828137f, -0.03976907f, -0.03042495f, 0.03061590f, 0.04368215f, 0.01098280f, -0.02732868f, -0.00919135f, 
    -0.02835865f, -0.05220125f, 0.00341999f, 0.04484349f, -0.03116865f, 0.02132073f, -0.02356863f, 0.02987673f, 
    0.03881733f, -0.04310773f, 0.02912928f, -0.02976045f, -0.00284539f, 0.04846562f, -0.02749399f, -0.00514120f, 
    -0.05347770f, 0.02879865f, -0.01530294f, -0.01368652f, -0.02387423f, -0.02275947f, -0.03108292f, 0.04423938f, 
    0.00086807f, 0.01905048f, 0.02814020f, 0.02147273f, -0.01609801f, -0.00169921f, 0.04279692f, -0.03756289f, 
    0.03443225f, -0.01180833f, -0.04263803f, -0.02516046f, 0.02280836f, -0.04435206f, -0.03394249f, -0.01364950f, 
    -0.05229141f, -0.05250892f, -0.02851014f, 0.04001614f, -0.04625070f, 0.04671178f, 0.01700850f, -0.02024952f, 
    0.02921274f, 0.03661302f, -0.05541852f, 0.01590303f, -0.00544179f, 0.01344253f, -0.01437457f, 0.03663962f, 
    0.01940820f, -0.02279291f, -0.01409598f, -0.05525807f, -0.03650812f, -0.02919552f, 0.01516118f, 0.02061801f, 
    -0.05350628f, -0.03365873f, -0.02745190f, -0.00086973f, -0.04046818f, 0.03203856f, 0.04537995f, -0.01300318f, 
    0.02713532f, 0.03553421f, 0.03775838f, 0.03939988f, -0.01685685f, 0.03474215f, 0.02674732f, 0.01838201f, 
    -0.35422507f, 0.01270019f, -0.22920001f, -0.05861180f, 0.14663181f, 0.01087787f, 0.17788686f, -0.01337792f, 
    0.07517796f, -0.03044591f, 0.04501375f, 0.07270103f, -0.24339429f, -0.04117853f, -0.11905984f, -0.06562391f, 
    0.08463134f, 0.00488938f, -0.02593010f, -0.03472712f, 0.10316470f, -0.03475336f, 0.00520414f, 0.06134111f, 
    -0.05421785f, -0.00723977f, -0.00618719f, 0.01129131f, 0.09685238f, -0.11523299f, -0.08533072f, 0.01738019f, 
    0.20003152f, 0.08004117f, -0.02383855f, 0.02420089f, -0.21670404f, -0.16484067f, -0.20859447f, -0.04786621f, 
    0.04865187f, 0.04308865f, 0.01195538f, -0.02443388f, 0.20308702f, 0.05212611f, 0.03862068f, 0.14869124f, 
    0.17650554f, -0.18973905f, 0.08045824f, -0.06684791f, 0.19450183f, -0.16698477f, 0.10574320f, 0.00151301f, 
    0.03671969f, 0.08810692f, -0.07812250f, 0.04563809f, -0.12940764f, 0.11207553f, -0.00810492f, 0.10527106f, 
    0.15382344f, -0.03789346f, 0.17370155f, 0.12279387f, 0.04277674f, 0.08883626f, -0.00289868f, 0.03731215f, 
    0.02514655f, 0.19739817f, 0.02395716f, 0.11984600f, -0.13982388f, -0.01257489f, -0.04980003f, -0.00222713f, 
    -0.05512085f, -0.05843012f, -0.02536066f, -0.01958701f, -0.27759138f, -0.21916430f, -0.08100554f, -0.31422248f, 
    0.07412843f, 0.08817006f, -0.13484897f, 0.06028228f, 0.03452301f, -0.03658255f, 0.01158904f, 0.03329194f, 
    0.07389190f, 0.03397656f, 0.03791191f, 0.03994091f, 0.12363553f, 0.04609097f, -0.07520324f, 0.04884907f, 
    -0.03564756f, 0.05666927f, 0.04369537f, -0.00552314f, 0.27432090f, -0.06747091f, -0.02491179f, 0.11203153f, 
    -0.24622136f, -0.03665779f, 0.01856049f, 0.02951553f, -0.03781234f, -0.02919824f, 0.00550077f, -0.00944034f, 
    0.16895756f, 0.14987662f, 0.07915781f, 0.02284162f, 0.10469704f, 0.00251951f, -0.00102260f, -0.05470110f, 
    0.14108111f, -0.08729217f, 0.03122561f, -0.10316034f, -0.18928662f, 0.11025006f, -0.08553199f, -0.00400274f, 
    0.16078949f, 0.07418020f, -0.04511510f, 0.07808638f, 0.23573194f, -0.03939187f, 0.06300639f, 0.09543360f, 
    0.08748058f, -0.45396984f, 0.00786849f, -0.05281021f, 0.07362411f, 0.02485213f, 0.04619225f, 0.01691529f, 
    0.05638140f, -0.00651035f, 0.11903509f, 0.01072625f, -0.14090227f, -0.30215299f, -0.21040797f, -0.03478061f, 
    0.22920085f, -0.03685783f, -0.01079841f, 0.07603338f, -0.03261198f, 0.09436162f, -0.02773220f, -0.04103637f, 
    0.03255485f, 0.05314622f, -0.11817009f, 0.20410566f, 0.04557478f, 0.01998225f, 0.09825762f, 0.02989805f, 
    0.02006154f, 0.04446430f, -0.00671006f, -0.05319456f, 0.13515182f, -0.14746703f, -0.09121809f, 0.04439579f, 
    -0.21658580f, -0.22777563f, -0.01903267f, 0.19372897f, 0.00355978f, -0.06445251f, -0.06566130f, 0.10921135f, 
    -0.02079906f, -0.12299059f, -0.16833195f, -0.09783488f, 0.10806607f, 0.08723855f, 0.07541788f, -0.09211745f, 
    -0.14297397f, 0.05715127f, 0.04760357f, -0.07801275f, 0.13904972f, -0.00458058f, -0.19048558f, 0.18603927f, 
    -0.19376987f, 0.03210564f, 0.07030909f, -0.04277239f, 0.05715284f, 0.06444606f, 0.01338855f, -0.10590093f, 
    0.15512942f, -0.03664630f, -0.03961352f, -0.05494422f, -0.22010697f, -0.04404424f, -0.00255185f, 0.01324570f, 
    -0.05101358f, 0.06193160f, 0.02320934f, -0.10804548f, 0.19405027f, 0.00718927f, -0.19750763f, -0.09777909f, 
    0.13532998f, 0.04649255f, 0.12733038f, 0.08112767f, -0.04729481f, 0.05707815f, 0.03894868f, 0.03287690f, 
    0.18370403f, 0.16739987f, 0.04148106f, -0.20895778f, 0.04331179f, 0.03820555f, 0.11994343f, -0.01158481f, 
    -0.06911940f, -0.04359202f, 0.08134357f, -0.02403799f, -0.09090020f, -0.23232551f, -0.08323210f, 0.03550277f, 
    0.10229373f, 0.01379005f, 0.00728097f, 0.05750995f, 0.10352591f, 0.07750235f, 0.04784012f, -0.04722815f, 
    0.08634826f, -0.12574767f, 0.03056614f, 0.22625659f, -0.04979210f, -0.03401873f, 0.00643250f, -0.02555578f, 
    0.14539586f, -0.13751084f, 0.02814628f, 0.00731503f, 0.06999667f, 0.28398800f, -0.00443238f, 0.05115942f, 
    0.13711782f, 0.02944323f, -0.09789126f, 0.06748827f, 0.18593363f, 0.01966639f, -0.01002284f, 0.06915288f, 
    -0.20287541f, 0.05669513f, 0.19070318f, -0.12636769f, 0.00252970f, 0.16853206f, -0.02020244f, -0.13770956f, 
    0.03481557f, 0.03513848f, -0.06104254f, 0.14376323f, 0.00583225f, 0.08942914f, -0.04199391f, -0.14642470f, 
    -0.00450017f, 0.07308090f, 0.11658880f, 0.04133538f, 0.03154220f, 0.02683069f, 0.09338764f, 0.01704648f, 
    -0.32101238f, 0.21227446f, -0.03925797f, 0.04920121f, 0.02615941f, 0.01009499f, 0.04518884f, 0.05481794f, 
    0.09280758f, -0.04806078f, 0.02880436f, 0.12605423f, -0.00344248f, 0.22288597f, 0.08266716f, -0.05159301f, 
    -0.25063992f, -0.06460660f, 0.06302609f, -0.04434236f, 0.00623178f, -0.06842645f, 0.15448396f, -0.13255158f, 
    -0.14819953f, -0.10194031f, 0.06674919f, 0.03509368f, 0.07033005f, 0.04679824f, -0.05786934f, -0.00602518f, 
    0.09445962f, 0.11258925f, 0.07754393f, 0.10329018f, 0.15888533f, 0.18903075f, 0.01644019f, 0.08165181f, 
    0.16143782f, 0.02295873f, 0.05412075f, -0.01461763f, 0.12769862f, 0.08779012f, 0.05969336f, 0.09054787f, 
    0.01717589f, 0.11206327f, -0.14021148f, 0.19475549f, 0.08338796f, -0.07169931f, -0.10143029f, 0.00082304f, 
    -0.00619291f, -0.10089106f, -0.01702322f, 0.02623031f, 0.06232173f, -0.00142668f, -0.14363083f, -0.11430266f, 
    -0.15642633f, 0.11338981f, 0.02148833f, 0.00705360f, -0.00538130f, 0.13852943f, 0.04068519f, 0.11451916f, 
    -0.07760924f, -0.04683732f, -0.02385720f, -0.15635648f, -0.01168054f, 0.04838966f, -0.08289591f, -0.21921717f, 
    0.05096332f, -0.01107439f, -0.03709412f, -0.14056842f, -0.09519265f, -0.17179692f, -0.15804331f, 0.04937939f, 
    -0.09760360f, 0.13380894f, 0.01710970f, -0.06050370f, -0.12360685f, -0.06096203f, 0.06100480f, 0.12287958f, 
    0.09028731f, -0.19656657f, -0.02978290f, 0.17409971f, -0.01199175f, 0.05105868f, -0.03236115f, -0.10668615f, 
    -0.10114137f, -0.00977682f, -0.03163469f, -0.06966963f, 0.30194938f, -0.26751643f, -0.10745487f, -0.19889829f, 
    -0.00748016f, 0.04700143f, 0.07858081f, -0.01138236f, -0.08873902f, -0.07335585f, 0.05439895f, -0.03642275f, 
    -0.26596028f, 0.06172336f, -0.04169087f, 0.01906571f, 0.07472283f, -0.03421891f, -0.14882047f, 0.09019517f, 
    0.03217400f, 0.02840283f, 0.12932192f, 0.15451045f, 0.15405054f, -0.28942332f, -0.17489998f, 0.02063450f, 
    -0.16255957f, -0.04691656f, 0.07428279f, 0.04403009f, 0.03918308f, 0.02474523f, -0.04224875f, 0.04478375f, 
    -0.04004505f, 0.22924680f, -0.10691769f, -0.22640169f, 0.10195992f, 0.13221334f, 0.04714572f, 0.10661905f, 
    0.10352196f, 0.02841362f, 0.05057473f, 0.09634361f, 0.16460505f, 0.24054341f, -0.17678766f, 0.32130352f, 
    -0.01148561f, 0.05133482f, -0.07900688f, -0.09338455f, -0.08591256f, 0.03984776f, 0.09835266f, 0.10199435f, 
    0.00357629f, -0.07519916f, -0.10175233f, -0.25670859f, 0.08374111f, -0.04784071f, -0.06470405f, -0.05574876f, 
    0.11412171f, -0.07938801f, -0.03682460f, 0.06467434f, 0.05649619f, -0.01884329f, 0.08444332f, 0.11880659f, 
    0.09852349f, 0.05066583f, 0.09112828f, 0.10381094f, 0.14533763f, -0.04050495f, 0.01735133f, 0.07632304f, 
    -0.08708870f, -0.18248616f, 0.25101596f, 0.26891291f, -0.26826963f, -0.03535743f, -0.16040474f, -0.15246622f, 
    0.06513592f, 0.06335256f, 0.02933371f, 0.08793858f, 0.02049326f, 0.02556523f, 0.15834507f, -0.04753738f, 
    -0.00240361f, 0.00522010f, 0.07274073f, -0.03061981f, -0.11095810f, 0.00053894f, -0.06812298f, 0.04242845f, 
    0.31646588f, -0.03579209f, 0.14310706f, 0.06890786f, -0.03108645f, -0.02237093f, -0.05557938f, -0.08779111f, 
    -0.00100577f, 0.03137360f, -0.06076200f, 0.07859614f, 0.27266997f, -0.16496697f, -0.18140061f, 0.17976965f, 
    -0.28087327f, -0.03916637f, 0.00721478f, -0.14897519f, -0.08150899f, -0.06039121f, -0.01099260f, 0.11036005f, 
    -0.12418393f, 0.01101830f, 0.36903802f, -0.11643236f, -0.05845706f, -0.10677654f, 0.14671023f, 0.11164281f, 
    0.13146482f, 0.09380164f, 0.07175902f, 0.05249613f, -0.33185035f, 0.37377670f, -0.35829672f, -0.03721474f, 
    0.07836773f, 0.05292748f, 0.05671594f, 0.08229128f, 0.05636197f, 0.05043167f, 0.06246430f, 0.10245753f, 
    0.14403322f, 0.01414333f, -0.25082621f, -0.19973464f, -0.00138285f, -0.06714930f, 0.06526599f, -0.01642326f, 
    -0.03691525f, 0.15738457f, 0.00720324f, 0.12077601f, -0.02241123f, 0.05331738f, -0.04310182f, -0.15399960f, 
    0.08653486f, 0.00806955f, 0.14240715f, -0.01821210f, 0.12498336f, 0.01653049f, 0.01607643f, -0.01810598f, 
    -0.05808775f, 0.38419494f, 0.14353262f, -0.05582672f, 0.10717955f, 0.08529085f, 0.01393976f, 0.21823722f, 
    0.09945070f, 0.12965763f, 0.00677131f, -0.00066971f, 0.02001426f, 0.20259058f, 0.15815413f, -0.28463864f, 
    -0.00126265f, 0.02492034f, 0.13736765f, 0.11781155f, 0.03618087f, 0.07671254f, -0.03475447f, -0.01140740f, 
    0.10758410f, -0.06876231f, -0.21253520f, 0.16126114f, 0.03514165f, -0.03126718f, -0.01867881f, 0.10153152f, 
    0.09054463f, 0.15686403f, 0.01340797f, -0.02961489f, 0.18084678f, -0.01459216f, 0.09514340f, 0.00297876f, 
    0.02655865f, -0.03761335f, -0.07658415f, -0.04936276f, -0.08550517f, 0.04902915f, -0.02218693f, 0.17787501f, 
    -0.16467404f, -0.24293661f, -0.04630011f, -0.13268124f, -0.06713042f, -0.12211400f, -0.03386121f, -0.07262214f, 
    -0.02449955f, 0.03136718f, -0.13369775f, 0.01261399f, -0.27213895f, -0.05230833f, 0.25178611f, 0.24336952f, 
    -0.08506802f, 0.09393606f, -0.01491496f, -0.08364143f, -0.14924341f, 0.05365812f, 0.00483893f, 0.05241716f, 
    -0.34799340f, -0.18718734f, 0.23201746f, -0.25917253f, -0.08680779f, 0.05781412f, -0.02707669f, 0.00753819f, 
    0.10528447f, -0.10927257f, 0.02128107f, 0.06873344f, 0.14689255f, -0.09313326f, 0.07954670f, 0.29287350f, 
    0.04846250f, 0.06167265f, 0.03066911f, 0.14055423f, 0.08422691f, 0.01841215f, 0.04491382f, 0.01254536f, 
    -0.21485126f, -0.06254952f, 0.06872043f, 0.14732313f, 0.04980295f, 0.04919480f, -0.08555530f, -0.13676780f, 
    -0.06881922f, 0.06187781f, 0.06473994f, 0.04055251f, 0.12729968f, 0.11188091f, 0.05564447f, 0.07519193f, 
    0.12407604f, 0.04903485f, -0.04676622f, 0.19153766f, 0.13139810f, 0.12348326f, -0.08056625f, 0.00722167f, 
    0.14190130f, -0.11622483f, -0.05061137f, 0.19241625f, 0.03598877f, 0.04293663f, -0.06396253f, -0.20340389f, 
    0.13959727f, -0.06950725f, -0.08466639f, 0.25596029f, 0.05622413f, -0.00750911f, 0.05961464f, -0.03782660f, 
    -0.03702035f, -0.03550001f, 0.08039888f, -0.07796296f, 0.06170755f, -0.00103757f, -0.04512032f, -0.08118816f, 
    -0.05711073f, 0.23106751f, -0.46618429f, -0.01808989f, -0.07383601f, 0.07599319f, -0.04180235f, -0.09217229f, 
    0.10779206f, 0.08189130f, 0.06373485f, 0.07836235f, 0.15156248f, 0.40253267f, 0.01607767f, -0.17479514f, 
    -0.04067196f, 0.11673509f, 0.19593723f, -0.07192113f, -0.00130463f, 0.00250775f, -0.00497818f, 0.05066369f, 
    -0.05369337f, -0.05793052f, -0.02409819f, -0.01217814f, -0.01406982f, -0.04624121f, -0.04417597f, -0.01532685f, 
    -0.03002378f, 0.03898026f, 0.01972009f, -0.04043566f, 0.05161236f, 0.01885474f, -0.01858289f, 0.00502217f, 
    -0.03668611f, -0.05116715f, -0.00082815f, 0.00442044f, -0.06210936f, 0.03702158f, -0.03673532f, -0.03997607f, 
    0.03603654f, 0.03571653f, -0.03493044f, -0.01739162f, -0.00474721f, 0.02962206f, -0.04617113f, -0.01478131f, 
    0.01807715f, 0.03971149f, 0.02629912f, -0.02394004f, 0.01300979f, -0.04791592f, -0.00623835f, -0.01908861f, 
    -0.03771098f, 0.00003906f, 0.00841616f, 0.03790733f, -0.02782246f, -0.03067972f, 0.01162742f, 0.00200315f, 
    -0.01822533f, -0.03247701f, 0.03620562f, -0.02974164f, -0.02333640f, -0.02601230f, 0.00394455f, 0.03902036f, 
    -0.04481835f, -0.04551475f, -0.01794391f, 0.00552417f, -0.02947056f, 0.02150922f, 0.03344930f, 0.01263623f, 
    0.04345288f, -0.00739168f, 0.01945161f, 0.04330269f, -0.03202473f, -0.03898322f, -0.05631759f, -0.01306383f, 
    -0.05618525f, 0.03031979f, 0.05082790f, 0.04387229f, 0.03849666f, 0.03198134f, -0.05447412f, 0.04204611f, 
    -0.03584006f, 0.03948950f, -0.00553361f, -0.04348268f, -0.02394375f, 0.01303554f, -0.00644711f, -0.03734959f, 
    -0.04307188f, -0.03844609f, -0.00506711f, 0.03022677f, 0.03026366f, -0.01066730f, -0.00144479f, -0.01195728f, 
    -0.01248368f, -0.00982408f, 0.00977145f, -0.03452307f, 0.00920764f, -0.04273867f, -0.04757007f, 0.02152881f, 
    -0.04454495f, -0.01061284f, 0.02110957f, 0.00865178f, 0.01937545f, -0.04399376f, 0.03018008f, 0.03058395f, 
    0.01047271f, -0.00932619f, -0.01034897f, -0.03987049f, 0.00698741f, -0.02484393f, -0.04153292f, -0.04675967f, 
    0.00069571f, -0.04984880f, -0.03026882f, -0.02137214f, -0.01163187f, -0.02103073f, 0.02939951f, 0.00955381f, 
    -0.02157195f, 0.00789066f, 0.01904905f, -0.00697573f, -0.02022861f, -0.02995155f, 0.03984863f, -0.02675251f, 
    0.01789069f, -0.01987472f, -0.01181045f, 0.03979243f, -0.05540307f, -0.01410955f, -0.04068957f, 0.00293437f, 
    -0.00845899f, -0.01951023f, 0.02650079f, -0.03805813f, -0.00800329f, -0.05792239f, 0.02928197f, -0.02755505f, 
    0.00355480f, 0.01637620f, 0.03854284f, 0.03767085f, 0.03191354f, 0.00944497f, 0.04646295f, 0.00946783f, 
    -0.03128066f, -0.01704754f, 0.03575451f, -0.02736399f, -0.02450327f, 0.01122580f, 0.02373582f, -0.01443235f, 
    -0.02299034f, -0.01166043f, 0.00148459f, 0.03161139f, 0.02523588f, -0.04907869f, -0.02270691f, 0.00166171f, 
    -0.03432682f, -0.01225046f, 0.03378111f, -0.01470859f, -0.02193179f, 0.04975978f, 0.03849552f, -0.03940310f, 
    0.04033411f, 0.04635542f, -0.01612035f, -0.03586762f, -0.05671660f, 0.03361994f, -0.05371311f, 0.01752461f, 
    0.01119384f, -0.03670851f, -0.05017646f, -0.03327635f, -0.00644962f, 0.04083180f, 0.02953012f, -0.02821932f, 
    -0.03445308f, 0.00345045f, 0.00502960f, -0.03423088f, -0.02575414f, -0.03980832f, -0.01817890f, 0.02520376f, 
    0.00368996f, -0.00437311f, -0.01164903f, -0.04502984f, 0.01402358f, 0.01597635f, -0.03637326f, 0.01968487f, 
    0.00765468f, 0.00175062f, -0.04361343f, -0.03797195f, 0.02876490f, 0.03854504f, 0.01615266f, 0.02778659f, 
    -0.04601551f, -0.00450455f, -0.06479475f, 0.02965591f, -0.04985214f, 0.00940521f, -0.05590900f, -0.01555598f, 
    -0.01020760f, 0.00319897f, 0.02076330f, -0.04816181f, -0.00094109f, -0.00891843f, -0.02840444f, 0.00553834f, 
    0.03540043f, 0.03549618f, -0.01491767f, 0.01721698f, 0.00977700f, 0.04275454f, 0.02740002f, -0.02490247f, 
    -0.00689316f, -0.03146873f, -0.02769338f, 0.04435176f, 0.01554029f, 0.04247005f, 0.03167916f, -0.00824162f, 
    0.02778656f, 0.03452611f, -0.00773502f, 0.03145865f, -0.01043253f, 0.01241313f, -0.04850923f, -0.00693448f, 
    -0.05055108f, -0.03210947f, 0.02365832f, 0.05079171f, -0.01072989f, -0.04963420f, -0.04118950f, 0.01827102f, 
    0.01325198f, 0.00455312f, -0.00281640f, 0.04093819f, 0.01500480f, 0.01588178f, 0.04652025f, 0.04904808f, 
    -0.02247059f, 0.00418032f, -0.05981308f, 0.00907384f, 0.00019027f, -0.00664434f, -0.01562921f, -0.02856014f, 
    -0.03672163f, -0.04328479f, 0.02164786f, -0.03319112f, 0.03355641f, 0.00869693f, 0.02787847f, 0.02246463f, 
    -0.05115163f, -0.01784414f, 0.03959143f, 0.02304865f, -0.00071178f, -0.05273417f, -0.04486172f, -0.01494017f, 
    -0.01347120f, 0.02897755f, -0.05367864f, -0.02909171f, -0.00269498f, -0.01523741f, -0.01988360f, 0.04231925f, 
    -0.05690984f, -0.01591101f, -0.03279735f, -0.00646876f, 0.00154124f, -0.02608882f, -0.00596888f, 0.03063023f, 
    -0.03646221f, 0.01627022f, 0.03583452f, -0.04916367f, -0.05173316f, -0.00226069f, 0.02607760f, 0.01941788f, 
    -0.04259711f, -0.02890887f, 0.00973100f, 0.03880127f, -0.00298145f, -0.02318136f, -0.00210123f, 0.00565454f, 
    -0.00815089f, 0.00306939f, 0.01689814f, 0.03091365f, -0.06112599f, -0.02785649f, -0.03561845f, -0.04903264f, 
    -0.02374907f, 0.03207297f, -0.00486199f, 0.00351229f, -0.04075355f, -0.01602931f, -0.02009677f, 0.02354728f, 
    0.00041365f, 0.01283318f, -0.05467099f, 0.01766260f, 0.00521632f, -0.00565330f, 0.00189880f, -0.03078841f, 
    0.01223978f, 0.03016956f, 0.01247109f, 0.04091214f, 0.00705980f, 0.01700176f, -0.01677416f, -0.04477289f, 
    -0.01311934f, 0.04089988f, -0.01997718f, -0.02931396f, -0.01656251f, 0.01682728f, -0.01790860f, 0.03743109f, 
    -0.01249016f, 0.02401517f, 0.03209259f, -0.03230453f, -0.03150570f, 0.02971634f, 0.00958493f, 0.00244611f, 
    -0.00721742f, 0.02832671f, -0.04550430f, -0.00121556f, -0.05722173f, -0.03900412f, -0.05412668f, -0.05588206f, 
    -0.01427074f, 0.03794038f, -0.01338965f, 0.04375509f, -0.03093510f, 0.02592630f, 0.02708004f, -0.04875673f, 
    0.03155725f, 0.01946650f, -0.05878990f, -0.04690427f, -0.02420358f, 0.02622184f, 0.00144610f, 0.02483481f, 
    -0.00616890f, -0.01769154f, 0.03845180f, 0.00788250f, 0.03625138f, 0.03586360f, -0.04071702f, 0.01179449f, 
    -0.00682515f, -0.01217767f, -0.00003284f, 0.03667004f, -0.04682055f, -0.00329806f, 0.02448858f, -0.00753929f, 
    0.01365035f, 0.03795442f, 0.00554871f, -0.04528236f, -0.05649051f, -0.03782824f, -0.00422463f, 0.00171524f, 
    0.00476860f, 0.04027731f, -0.03062016f, -0.00675219f, -0.05041151f, -0.04892388f, -0.00058145f, 0.00497543f, 
    -0.04708910f, -0.00440055f, -0.01829858f, -0.05991321f, -0.02212188f, -0.04330460f, 0.00514679f, 0.01131427f, 
    -0.04244975f, -0.04792121f, -0.04344827f, -0.02506057f, 0.02275893f, -0.00429802f, 0.01427499f, 0.01510135f, 
    -0.02063815f, -0.01605939f, 0.01557747f, 0.02316559f, -0.03458329f, 0.04022111f, 0.00110734f, -0.00954312f, 
    0.00697771f, 0.02804740f, 0.04635980f, -0.01739970f, 0.01337638f, -0.03077852f, -0.01865320f, -0.01449878f, 
    -0.03937105f, -0.04704338f, 0.02468228f, -0.00310068f, -0.02291867f, -0.05346248f, 0.02401993f, -0.02380331f, 
    -0.00167057f, -0.02730259f, -0.01822435f, -0.04872391f, 0.02879071f, 0.03849321f, -0.00303961f, -0.00070074f, 
    -0.00918509f, -0.05469745f, 0.01679009f, 0.01024028f, 0.03308554f, 0.03201474f, -0.01328353f, -0.01024961f, 
    -0.01566246f, -0.04650444f, -0.05326144f, 0.03090663f, -0.02775458f, 0.04106805f, -0.02789343f, -0.03930051f, 
    -0.04103572f, -0.05350809f, -0.02274434f, 0.02336278f, 0.01935305f, -0.00851911f, -0.04697034f, 0.00366226f, 
    -0.04336965f, -0.06011736f, -0.03212983f, 0.02365389f, -0.01346423f, 0.04516442f, -0.04783031f, -0.04661528f, 
    0.03226105f, -0.03247683f, 0.04745755f, 0.00679956f, 0.00565814f, 0.03574938f, -0.01918876f, -0.04426374f, 
    0.01770678f, 0.04621486f, -0.03231864f, -0.00536912f, -0.01597442f, 0.00362571f, -0.02573787f, -0.04084071f, 
    -0.04244655f, -0.02916895f, -0.04536517f, -0.00287144f, 0.03631787f, 0.00911725f, -0.04615902f, -0.01796225f, 
    -0.04754671f, -0.01659489f, 0.02910529f, -0.02343328f, 0.01192374f, 0.00062775f, 0.03159600f, -0.04957702f, 
    -0.04214845f, 0.03543846f, -0.04151317f, 0.02187446f, 0.02877093f, 0.02942712f, -0.01482481f, 0.01922519f, 
    0.02621489f, -0.04822205f, -0.02262072f, -0.04188091f, 0.00643126f, 0.00344339f, 0.02635860f, 0.02694952f, 
    -0.00040281f, -0.02957951f, 0.00175103f, -0.01731144f, 0.00644602f, 0.04530972f, 0.02021259f, 0.00998430f, 
    -0.05059919f, -0.05000599f, -0.01124454f, 0.02940684f, 0.02593804f, 0.02829621f, -0.04688497f, 0.01178253f, 
    0.04038394f, 0.03349364f, -0.00413229f, 0.01162113f, 0.01330119f, 0.00595686f, -0.00047007f, -0.01504734f, 
    -0.03548819f, -0.02379783f, 0.03107446f, 0.02786397f, 0.02750068f, -0.01257494f, 0.03662679f, 0.04605499f, 
    0.00154968f, -0.05890331f, 0.04493124f, -0.04504127f, -0.00619116f, -0.05050276f, -0.01941590f, -0.03814692f, 
    -0.02955404f, -0.04915123f, 0.03987683f, -0.00387249f, -0.00123989f, -0.03866944f, -0.02980864f, -0.01227707f, 
    -0.04157593f, -0.05736427f, -0.00518440f, 0.03845337f, -0.05557074f, -0.05951450f, -0.00903125f, -0.02014206f, 
    0.00287370f, -0.04818375f, 0.01431295f, -0.03506118f, -0.04090611f, -0.04124456f, -0.01065832f, -0.01207715f, 
    -0.03993512f, -0.04140704f, -0.00904291f, -0.00622806f, -0.02382954f, 0.01359479f, 0.02718655f, 0.01996161f, 
    -0.04227940f, 0.00297240f, -0.03226915f, 0.03461180f, -0.03721032f, 0.02370979f, 0.01459287f, -0.00353082f, 
    -0.04136014f, 0.02579907f, -0.02633325f, -0.03699789f, -0.02436819f, 0.04552130f, 0.03240949f, 0.00438885f, 
    0.01268433f, -0.05861773f, -0.03727655f, -0.03815658f, -0.02718592f, -0.03563279f, 0.02713777f, -0.00033851f, 
    -0.01970642f, 0.00140762f, -0.02124764f, 0.00508599f, -0.01761565f, 0.00374620f, -0.02148777f, 0.00613016f, 
    0.01557478f, 0.02374944f, 0.03239459f, -0.06122971f, -0.00870727f, 0.02719609f, -0.02949012f, -0.02585823f, 
    -0.05506235f, -0.02572283f, -0.05223688f, 0.02568286f, 0.01101800f, 0.00391391f, 0.03911263f, 0.00146708f, 
    -0.03891378f, -0.05332698f, 0.01755838f, 0.02901482f, -0.02305482f, -0.04904641f, -0.05884611f, -0.04171452f, 
    0.03204947f, -0.05239623f, -0.01425512f, -0.00861164f, 0.02286237f, 0.00162287f, -0.00892704f, 0.03358407f, 
    -0.00581749f, 0.02603057f, 0.01473792f, -0.04407210f, -0.03024561f, 0.01609088f, -0.02794551f, -0.01679686f, 
    0.03963881f, 0.03758916f, -0.05695021f, -0.03691586f, -0.00227427f, 0.01975240f, 0.02180289f, -0.00569474f, 
    -0.01678363f, -0.03684440f, -0.03855484f, 0.03780240f, 0.01964778f, -0.03833101f, -0.02487785f, 0.00031539f, 
    -0.04014527f, 0.01098230f, -0.00328319f, 0.00956721f, -0.04464819f, 0.00134177f, -0.00310183f, 0.03034120f, 
    -0.00502048f, 0.02614957f, 0.03894715f, 0.02106102f, 0.03309021f, -0.00884833f, -0.04722509f, -0.03311321f, 
    -0.02680773f, -0.03549802f, -0.02295985f, 0.04122905f, 0.00409390f, -0.02581443f, 0.00322743f, 0.02780557f, 
    -0.00151348f, -0.03079733f, -0.04381594f, -0.04452918f, -0.05234687f, 0.03391258f, -0.05021635f, 0.00414002f, 
    -0.01508829f, -0.01358065f, -0.03971849f, 0.02567190f, -0.03267024f, -0.00045886f, 0.00541500f, -0.04332949f, 
    -0.05794419f, 0.03553499f, -0.03085471f, 0.03183903f, -0.04158015f, 0.02294133f, 0.03589344f, -0.02126126f, 
    -0.04814094f, 0.00249326f, -0.00792850f, 0.03907785f, 0.04101538f, -0.05709629f, -0.01664848f, 0.03040519f, 
    -0.00354094f, 0.03968471f, -0.02661563f, 0.00868182f, 0.00031786f, -0.02883018f, 0.02765471f, -0.00002266f, 
    -0.02300338f, -0.02946709f, -0.04925900f, 0.00560297f, 0.03628898f, -0.02879997f, 0.00023781f, -0.05086331f, 
    -0.05673653f, 0.03828100f, -0.02805559f, -0.05032037f, 0.02853757f, 0.03154234f, -0.02742516f, 0.03731680f, 
    0.04268099f, -0.04764052f, -0.02741727f, -0.00566402f, -0.04910757f, 0.02705338f, -0.00458001f, 0.04018489f, 
    -0.03069979f, -0.03280272f, 0.02820469f, 0.03551340f, -0.02862011f, 0.02070938f, 0.01596709f, 0.00952992f, 
    -0.03005245f, -0.03843651f, -0.00899682f, 0.03452852f, 0.02751641f, -0.01426496f, 0.03165455f, 0.03485261f, 
    -0.03731723f, 0.04623229f, -0.00464474f, -0.03421726f, -0.00130198f, 0.00919634f, 0.02250320f, 0.00662351f, 
    0.04338924f, -0.02803229f, 0.04613262f, -0.03811033f, 0.00006907f, -0.05889466f, -0.04040136f, -0.04594038f, 
    0.01078749f, -0.02132517f, -0.04692049f, -0.04458731f, 0.00239111f, 0.00157508f, -0.04521218f, -0.02693979f, 
    -0.02513034f, 0.01300418f, 0.00932872f, 0.03186585f, -0.03069632f, 0.04889311f, 0.00953461f, -0.03021366f, 
    -0.05601100f, 0.02953658f, -0.05386575f, 0.01256017f, 0.02193502f, -0.05200201f, 0.03367993f, -0.00063095f, 
    0.00776373f, 0.01990015f, -0.02139723f, -0.04856570f, 0.00795674f, 0.02675609f, -0.02661615f, 0.01238669f, 
    -0.00939449f, -0.02517126f, -0.00751111f, 0.01405970f, 0.01917299f, 0.00493513f, 0.02690254f, 0.03665635f, 
    0.00315150f, -0.03551638f, 0.03737358f, 0.01247416f, 0.02927448f, -0.00318191f, -0.01197672f, -0.00098790f, 
    -0.04760245f, -0.05540970f, 0.01340190f, -0.02414676f, 0.02551330f, -0.00778737f, 0.02034934f, -0.02517621f, 
    -0.03931054f, 0.00158751f, -0.01193089f, -0.03193117f, 0.04009951f, -0.03440328f, 0.04162693f, 0.00944157f, 
    0.00902992f, -0.04528990f, -0.05467992f, -0.04288109f, -0.04221158f, -0.03631087f, -0.00734588f, 0.02198021f, 
    -0.05055643f, -0.04489101f, -0.02625816f, -0.02226669f, -0.05589550f, 0.01403455f, -0.03732480f, 0.01885003f, 
    0.04423306f, -0.01492694f, -0.02551083f, 0.03097882f, -0.04108927f, 0.04490812f, -0.03655897f, 0.01521636f, 
    0.02797632f, -0.01923705f, 0.01495377f, 0.00304747f, -0.01298238f, -0.00803476f, -0.01059306f, 0.03400169f, 
    0.00359695f, -0.03940923f, 0.03897174f, -0.00522256f, -0.05859163f, -0.04815800f, -0.01943912f, -0.01746653f, 
    -0.02254768f, -0.02589205f, 0.00500476f, -0.00202071f, -0.04246730f, -0.02398022f, 0.02460155f, 0.03491683f, 
    0.00750365f, 0.00210148f, -0.02927049f, 0.02323929f, -0.01365202f, -0.05892803f, 0.02261998f, -0.04503379f, 
    -0.00762790f, -0.04238297f, 0.01142781f, 0.02763991f, -0.00558831f, -0.04642081f, 0.03434676f, 0.04067633f, 
    -0.02651672f, -0.01149868f, 0.02679097f, 0.03949527f, 0.00449001f, 0.01764929f, -0.03119545f, -0.02568836f, 
    0.02368660f, -0.01287382f, 0.01741846f, -0.00024242f, 0.00654857f, -0.04163994f, 0.00998560f, -0.04347622f, 
    -0.05074419f, 0.01654230f, -0.02438233f, 0.00994326f, -0.02662724f, -0.03353126f, -0.04061081f, 0.02002694f, 
    -0.03240111f, 0.01858834f, -0.03007859f, -0.01458080f, 0.03209585f, 0.03373860f, -0.05869452f, 0.02901350f, 
    0.00338065f, -0.03643042f, -0.01832793f, -0.03215144f, -0.00628628f, 0.01045127f, -0.03417941f, -0.00187016f, 
    -0.05167104f, 0.02572230f, -0.01980520f, 0.03551172f, -0.02067266f, -0.04990311f, -0.02001818f, -0.00690468f, 
    0.03916368f, -0.01074597f, -0.03275544f, 0.01863756f, -0.04688010f, 0.00638120f, 0.01406590f, -0.00007575f, 
    -0.02909901f, 0.00285475f, -0.04656311f, -0.06002227f, 0.02398948f, -0.01772804f, 0.02170167f, -0.05074267f, 
    -0.04992991f, 0.03105484f, -0.01719315f, 0.01533137f, -0.01007648f, -0.03288639f, -0.03341671f, -0.01247473f, 
    0.03684002f, -0.00275261f, -0.02066929f, -0.04291682f, -0.02385476f, 0.02457234f, -0.03473388f, -0.05664666f, 
    -0.02249678f, 0.02382692f, -0.03633333f, 0.01880716f, -0.02946818f, 0.00672448f, -0.00703530f, 0.03049694f, 
    -0.05147824f, 0.02644831f, -0.04249142f, 0.00358985f, 0.04240166f, -0.03179343f, -0.01873706f, -0.03338454f, 
    -0.02705369f, -0.02274709f, 0.01594209f, 0.04144364f, -0.04348686f, 0.04332875f, -0.04133755f, -0.02784225f, 
    -0.00577002f, 0.02429272f, -0.05060971f, 0.00419321f, -0.01127906f, 0.03966888f, -0.01581715f, -0.01798782f, 
    0.02876325f, 0.02784954f, 0.03306768f, 0.02406213f, -0.01606043f, -0.00764150f, -0.01160495f, 0.03181854f, 
    0.04082001f, -0.03811594f, 0.01580621f, 0.01628237f, 0.03084768f, 0.02134442f, 0.01129200f, 0.01620264f, 
    0.02815398f, 0.02412277f, -0.03068663f, -0.03192497f, -0.02254727f, -0.02454487f, 0.01516481f, -0.05546258f, 
    0.02743094f, -0.01907095f, 0.00290597f, -0.02977584f, -0.02282473f, 0.02120466f, -0.04880588f, 0.01528918f, 
    -0.00329447f, 0.01853634f, 0.01470552f, -0.05581609f, 0.00107578f, -0.03061404f, -0.04208114f, 0.01345692f, 
    -0.03342196f, -0.04000575f, -0.03612347f, -0.00134556f, -0.05805301f, -0.04152590f, -0.05257895f, 0.02571791f, 
    -0.01508241f, 0.03055132f, -0.00240446f, 0.01976013f, -0.00614225f, -0.04483412f, -0.02583854f, -0.01346726f, 
    -0.04902808f, -0.01911889f, -0.04324876f, 0.02021536f, 0.01139277f, 0.00029720f, 0.00030757f, 0.02150487f, 
    0.02756634f, 0.02014358f, -0.02670402f, 0.03146534f, 0.01574966f, -0.01566027f, -0.03916387f, 0.02885956f, 
    -0.00649010f, -0.02483679f, -0.03307384f, -0.05251172f, -0.02861337f, -0.05355316f, 0.00035473f, -0.03546118f, 
    0.04393727f, 0.04340453f, -0.00577077f, 0.02141153f, -0.01203085f, 0.03822894f, -0.00353569f, -0.01836168f, 
    0.02631026f, -0.00479353f, 0.00623621f, -0.05434210f, -0.01945566f, 0.01804933f, 0.00751676f, -0.03374887f, 
    -0.01925156f, -0.03029889f, 0.04071829f, -0.03263015f, -0.03363716f, -0.00867569f, -0.02334281f, -0.05190718f, 
    -0.01360762f, -0.01157441f, 0.00248225f, -0.02791062f, -0.03771904f, -0.05519791f, -0.00171510f, 0.00808227f, 
    -0.01367348f, -0.00532734f, 0.00419017f, -0.05497079f, 0.04121748f, -0.04266725f, 0.01756489f, -0.02804031f, 
    0.02493433f, -0.00654966f, -0.01123499f, -0.02162461f, -0.04574687f, 0.03109696f, 0.04317200f, 0.02484134f, 
    -0.00800752f, -0.02717007f, 0.00271203f, -0.03545357f, -0.01072439f, -0.01417241f, -0.05341820f, 0.02662986f, 
    0.00706834f, 0.01122641f, -0.05476767f, -0.03270916f, -0.00693110f, 0.01259034f, 0.00207917f, 0.00308529f, 
    -0.00370728f, 0.00432470f, -0.02937402f, -0.05294094f, 0.02546829f, -0.00817491f, -0.01239332f, 0.01223108f, 
    -0.03854821f, 0.00870888f, -0.04997209f, 0.01567027f, -0.03463141f, -0.03149921f, 0.03147710f, 0.02653678f, 
    0.04093344f, 0.03604540f, -0.04757997f, 0.02482820f, -0.05410992f, -0.02093327f, 0.02905640f, 0.03029788f, 
    0.00774830f, -0.05573661f, 0.01432651f, 0.01701243f, -0.04727517f, -0.00484359f, 0.03359959f, 0.03319021f, 
    0.02224037f, 0.03535375f, -0.00500592f, -0.02116815f, 0.00204415f, 0.00442461f, -0.01568648f, -0.05216012f, 
    -0.02613574f, -0.04958680f, 0.00921216f, -0.00266611f, 0.03721548f, -0.03815525f, -0.03588285f, 0.04368142f, 
    -0.01021677f, 0.03066578f, -0.04550666f, 0.02833419f, -0.01161341f, -0.05388639f, 0.01225189f, -0.00291717f, 
    0.02506888f, -0.03335459f, 0.03079701f, -0.05353605f, -0.02259021f, -0.00661848f, -0.01925342f, 0.04205094f, 
    0.00592725f, -0.00738326f, -0.05623645f, -0.05607786f, -0.01424055f, 0.02629469f, -0.03753846f, -0.05289937f, 
    -0.03924215f, 0.03751491f, -0.00616825f, 0.03859850f, 0.03478403f, 0.00515409f, -0.03575645f, 0.01695438f, 
    -0.00414673f, -0.03337521f, -0.05007156f, -0.00855636f, -0.05389414f, -0.01685262f, 0.04063119f, 0.00215667f, 
    -0.03348074f, -0.03863103f, -0.02497729f, 0.03886186f, -0.03226350f, 0.00945817f, 0.01185260f, 0.02204656f, 
    0.00896532f, -0.05682855f, 0.01276403f, -0.02795704f, 0.04252133f, 0.03674820f, -0.04442229f, -0.03849122f, 
    0.04088552f, -0.02901367f, 0.02041681f, 0.02603147f, 0.03340453f, -0.00760153f, 0.02582753f, -0.05289754f, 
    0.03303406f, -0.02950725f, -0.04830793f, -0.00062123f, -0.05393554f, -0.02446084f, 0.03417341f, 0.02461636f, 
    0.03056843f, 0.01519951f, -0.00326527f, -0.02554870f, -0.03403508f, -0.03189711f, 0.03844377f, 0.00887701f, 
    0.03388007f, -0.05319628f, 0.03273026f, 0.02773235f, -0.03832037f, -0.03690306f, -0.02911368f, -0.01185274f, 
    0.03959516f, -0.01328588f, 0.01627245f, 0.01580083f, -0.03442465f, -0.03026663f, -0.02589697f, -0.05492143f, 
    -0.01402358f, -0.05147307f, 0.00951384f, 0.00472785f, 0.03534443f, -0.01176309f, 0.03526774f, -0.03721198f, 
    -0.01310894f, -0.00400389f, -0.04434856f, 0.02062505f, 0.00743552f, 0.02277345f, 0.04280242f, 0.00639124f, 
    -0.02186312f, 0.03707891f, 0.00636523f, -0.02581507f, -0.02340577f, 0.02822457f, 0.01174617f, 0.04006447f, 
    -0.01307272f, -0.02732377f, 0.04251159f, 0.00029111f, 0.00890535f, 0.00561992f, 0.04489986f, -0.01132611f, 
    -0.05079266f, 0.03536275f, 0.03372404f, -0.04829009f, -0.03840093f, -0.02957327f, -0.01249457f, -0.00597661f, 
    0.00373351f, 0.04207911f, -0.04153141f, -0.04330671f, -0.02519443f, -0.04717562f, -0.02301404f, -0.02593323f, 
    -0.03986596f, -0.01372612f, -0.00049818f, -0.03611207f, -0.00274183f, -0.03580891f, 0.00225194f, 0.02247449f, 
    0.03415527f, -0.00374791f, -0.01548770f, 0.02588577f, -0.03328384f, 0.01224386f, 0.00152710f, -0.03863306f, 
    -0.03492158f, -0.00570967f, -0.01457095f, 0.01961984f, 0.00675652f, 0.02249287f, -0.01655064f, -0.03963942f, 
    -0.05092443f, 0.01420886f, -0.00542539f, -0.04788248f, 0.00744747f, -0.05282833f, -0.03185702f, 0.01282240f, 
    -0.03464540f, -0.02990649f, 0.03375481f, 0.00981672f, 0.01308580f, -0.05539617f, -0.05225965f, 0.00810936f, 
    0.01218395f, 0.04165413f, -0.02983007f, 0.00878746f, -0.04501081f, -0.03244270f, -0.03013633f, -0.01852687f, 
    -0.01124970f, 0.00612779f, -0.04479347f, 0.01881662f, -0.01822644f, -0.03968378f, -0.05411062f, -0.00181598f, 
    0.00021396f, -0.04298704f, 0.03301940f, -0.04920221f, -0.03187084f, 0.00257787f, -0.00375069f, 0.01177569f, 
    -0.05244543f, -0.00483506f, -0.02021400f, 0.04092984f, 0.03563287f, 0.04104987f, -0.04522897f, -0.01745959f, 
    -0.03383475f, -0.00364423f, -0.00380529f, 0.01931168f, 0.00773834f, -0.04720863f, 0.02042338f, -0.01761682f, 
    0.02609112f, -0.01272375f, -0.01414132f, -0.02249493f, -0.05618744f, -0.01906710f, -0.03743319f, -0.03730050f, 
    0.01909111f, -0.02616160f, 0.02362476f, -0.03796701f, -0.04367018f, 0.03205090f, 0.03763444f, -0.00557198f, 
    0.01102936f, -0.04959649f, -0.00938273f, 0.04073965f, 0.01995243f, -0.02625210f, -0.05248926f, -0.00684733f, 
    0.02495562f, 0.03256211f, 0.03343016f, -0.02452659f, -0.03335076f, 0.00021897f, -0.02472500f, 0.02055544f, 
    0.18081670f, -0.21561147f, 0.01773139f, 0.12095565f, -0.00324167f, 0.12616302f, -0.09879301f, 0.07288318f, 
    0.14675342f, 0.10133200f, -0.16004482f, 0.07863428f, -0.01293800f, -0.01794995f, -0.15808700f, 0.16800237f, 
    -0.03218001f, 0.02542436f, -0.15439749f, -0.11037739f, -0.10133632f, -0.08408577f, -0.10752447f, 0.25295672f, 
    0.10024855f, -0.22733781f, 0.26953322f, 0.33673361f, 0.03091680f, -0.05823731f, -0.00545142f, 0.09538597f, 
    0.20046248f, 0.06372385f, 0.01728602f, -0.12199784f, 0.31914836f, -0.23148547f, -0.01969651f, 0.02257598f, 
    -0.06186685f, -0.01314667f, 0.11774939f, -0.11888409f, 0.01771518f, -0.01648678f, -0.02258464f, -0.03482799f, 
    -0.27862698f, -0.02343672f, -0.12212674f, 0.03414595f, 0.07621558f, 0.03775285f, 0.07917303f, 0.05754253f, 
    0.02589992f, 0.14407998f, -0.02051067f, 0.17313018f, 0.01551269f, -0.08406354f, 0.10747522f, -0.07568271f, 
    0.08986212f, 0.08538261f, -0.09244806f, 0.12734698f, 0.00230799f, 0.15647869f, -0.01788822f, 0.16302191f, 
    0.08570713f, 0.15825073f, -0.00336772f, -0.30737290f, -0.00725130f, -0.00858008f, 0.04719679f, -0.07249140f, 
    0.00621369f, -0.06519278f, -0.05858130f, 0.13421330f, 0.12967506f, -0.04222243f, -0.02889976f, 0.34910157f, 
    -0.08105404f, 0.00644048f, -0.06233002f, -0.08305724f, -0.02557394f, -0.09258276f, 0.19188710f, -0.08669241f, 
    -0.11197564f, -0.13445960f, 0.08907134f, 0.02914802f, 0.02086519f, -0.03288322f, 0.14795829f, 0.01427271f, 
    0.01541421f, 0.17284119f, 0.04245036f, 0.21157850f, -0.17258635f, 0.07605419f, -0.00343538f, -0.18351895f, 
    0.05967540f, 0.10007221f, 0.04333789f, -0.12339143f, 0.13360816f, 0.12506595f, -0.02541923f, 0.10780473f, 
    0.26411226f, -0.05445192f, -0.01870947f, 0.13009852f, 0.03930368f, 0.07485814f, -0.01707408f, 0.06477708f, 
    -0.00099371f, 0.05242630f, 0.08331384f, 0.28378901f, -0.11561292f, -0.07415660f, 0.07647397f, 0.01249290f, 
    0.07830293f, -0.14633204f, -0.00854401f, -0.12166815f, -0.03346530f, -0.04069909f, 0.07713433f, -0.13187023f, 
    0.29042327f, -0.43778828f, 0.15693128f, 0.30587262f, -0.09691244f, 0.08126845f, -0.01797767f, -0.00748988f, 
    0.06513904f, 0.00974119f, 0.05931087f, 0.08210419f, 0.13432366f, -0.11643983f, -0.00226237f, 0.21312927f, 
    0.02921658f, 0.00981206f, -0.01044330f, -0.09541621f, 0.09387297f, -0.00629118f, 0.00666022f, 0.16711602f, 
    -0.00157369f, 0.15137513f, 0.10853909f, -0.16999534f, 0.02089560f, 0.03562726f, 0.02817280f, 0.10972798f, 
    -0.07903374f, 0.06053962f, 0.17855904f, 0.25192350f, 0.00981298f, 0.32733336f, -0.13460609f, -0.03558911f, 
    0.05805653f, -0.05913568f, 0.16108714f, -0.20263992f, -0.05129658f, -0.00381979f, -0.06604508f, -0.08687372f, 
    -0.21338221f, -0.21999905f, -0.06908545f, -0.27801201f, -0.06582624f, 0.00358733f, -0.02837335f, 0.03944524f, 
    0.06455175f, -0.02786127f, 0.07485245f, 0.01919819f, -0.17028700f, 0.07853454f, -0.27007550f, -0.20009546f, 
    0.01260332f, -0.05570273f, -0.00907687f, 0.05173979f, 0.03196133f, 0.00287071f, -0.05307129f, -0.18344700f, 
    -0.38866419f, 0.10678856f, -0.09302270f, -0.09884804f, 0.01626056f, 0.04501635f, -0.02753204f, -0.19906983f, 
    0.09225978f, -0.17705144f, -0.07954731f, 0.05324620f, 0.16046831f, -0.07551112f, 0.06483597f, -0.13292915f, 
    -0.05032194f, -0.07273898f, 0.19853437f, 0.04836522f, -0.00472482f, 0.03942257f, 0.00760601f, -0.06652363f, 
    -0.06838672f, 0.09286194f, 0.02393760f, -0.12084514f, 0.06141787f, 0.07285655f, 0.03234148f, 0.06896278f, 
    0.00079308f, -0.09682544f, 0.15795049f, 0.14197004f, 0.08210154f, -0.15505482f, 0.16580142f, 0.10881670f, 
    -0.04119475f, 0.09584053f, 0.01400283f, 0.02482371f, 0.07221572f, 0.19425774f, 0.07278387f, 0.25015157f, 
    0.34022620f, -0.23742810f, -0.18520750f, -0.03455767f, -0.05135387f, -0.05269590f, -0.11647756f, 0.04498829f, 
    0.03374984f, -0.25516403f, 0.08147755f, 0.10423609f, 0.02255295f, -0.06102334f, -0.03702714f, 0.21274233f, 
    0.02863819f, -0.05273681f, 0.03806482f, 0.00243409f, 0.01710646f, -0.02016532f, -0.08382682f, -0.02626718f, 
    -0.05027029f, 0.20393908f, -0.12071682f, 0.00492644f, 0.07449415f, -0.05192677f, -0.10482831f, -0.01075017f, 
    0.11176841f, 0.03859763f, -0.03691301f, 0.04486775f, 0.01187797f, 0.06500981f, 0.30619448f, -0.00339520f, 
    0.03489850f, -0.09693991f, 0.06974465f, 0.06081480f, 0.01947537f, -0.00040191f, 0.00947566f, -0.01772668f, 
    -0.43851098f, 0.13586786f, -0.00123551f, -0.07165181f, 0.02669511f, 0.03107487f, -0.12345910f, 0.04359079f, 
    -0.00481790f, 0.07804640f, 0.10347819f, -0.00888604f, -0.13406992f, 0.04325379f, -0.15338863f, -0.17536466f, 
    -0.01093941f, -0.00199763f, -0.10012588f, -0.01672759f, 0.05257804f, -0.02867679f, -0.08684295f, 0.08912597f, 
    0.02514867f, -0.13642530f, 0.04625576f, 0.29340947f, -0.07741136f, -0.11706426f, 0.08322694f, 0.14420839f, 
    0.16975340f, 0.13852377f, 0.01274727f, 0.11215167f, 0.03194547f, 0.03705821f, 0.06211336f, 0.00069596f, 
    -0.01045860f, -0.00189701f, 0.06436030f, 0.15668565f, 0.09408481f, -0.07339171f, 0.06530651f, -0.09296791f, 
    -0.14559631f, 0.27522039f, -0.01681389f, -0.04999273f, 0.07639549f, 0.02514247f, 0.00666159f, 0.03673745f, 
    0.01342627f, 0.16759722f, -0.09005502f, 0.03467558f, -0.14807779f, 0.02898049f, 0.06171247f, -0.05150010f, 
    0.00275588f, 0.02590633f, 0.00142260f, -0.02713913f, 0.05801953f, 0.03273540f, -0.21526459f, -0.03864879f, 
    0.03915010f, -0.05290248f, -0.03209565f, -0.05729060f, -0.02983896f, -0.00794399f, -0.00297858f, -0.03042720f, 
    -0.03142563f, -0.05582815f, 0.00336995f, 0.03978533f, 0.00519290f, 0.02114997f, -0.04898530f, -0.04371856f, 
    -0.02790638f, 0.02958927f, 0.02475698f, -0.00108267f, 0.01255345f, -0.00788295f, -0.03900397f, -0.02903936f, 
    -0.03934761f, -0.05277174f, -0.00140394f, -0.04101457f, -0.02072217f, -0.04614774f, 0.02902440f, 0.01021933f, 
    0.03991579f, 0.00635344f, 0.01355404f, -0.02307222f, 0.01082277f, -0.05998362f, -0.00334704f, 0.01277526f, 
    0.01828617f, -0.01377193f, 0.02149332f, 0.03168131f, 0.00451477f, -0.05219619f, 0.01619009f, 0.01171757f, 
    -0.01929588f, -0.04761264f, 0.02623771f, -0.00464320f, 0.03909713f, 0.03229791f, -0.00287546f, 0.00706404f, 
    0.02978271f, 0.03178291f, 0.02907371f, -0.00245402f, -0.06020911f, -0.05332020f, 0.00875164f, 0.04007636f, 
    -0.03201023f, 0.01827175f, -0.03876168f, -0.01381425f, -0.03141681f, 0.02755050f, -0.05052070f, 0.04500357f, 
    -0.01094158f, -0.04087886f, 0.00979969f, -0.03300847f, 0.00512392f, -0.00675471f, -0.00505901f, -0.04696956f, 
    -0.04785830f, -0.00144104f, 0.00341753f, -0.03534771f, -0.02304151f, -0.03472039f, -0.01168739f, -0.01314239f, 
    -0.01980512f, 0.00837376f, 0.00141553f, -0.02563224f, 0.01162504f, -0.06082963f, -0.04039225f, 0.01878464f, 
    0.02796553f, 0.00098080f, -0.03295830f, 0.00630246f, 0.00729353f, 0.00860454f, -0.00773036f, -0.01988206f, 
    -0.05064374f, -0.03402144f, 0.01748916f, 0.00482803f, -0.00099095f, -0.03112238f, 0.01985874f, 0.01466646f, 
    0.00540050f, 0.01577594f, 0.03963662f, -0.00461684f, -0.00248732f, -0.05444699f, 0.02676800f, -0.04033335f, 
    -0.00267895f, -0.00927199f, 0.01804886f, -0.06042647f, -0.00879474f, -0.05887838f, -0.04173228f, -0.02338964f, 
    -0.02039539f, 0.04110639f, -0.00680132f, 0.03669254f, -0.01266223f, 0.00380860f, -0.05549244f, -0.02145258f, 
    -0.00614014f, -0.05117172f, -0.05531520f, 0.04042988f, -0.04025977f, 0.01782322f, -0.03685031f, 0.03341728f, 
    0.00349540f, -0.03740229f, 0.04134228f, -0.00621848f, -0.05233492f, 0.02976333f, -0.00592408f, -0.05291818f, 
    0.00928325f, 0.03362295f, -0.04306356f, 0.02193916f, -0.03929064f, 0.03172106f, -0.03527230f, -0.02400858f, 
    -0.00339229f, -0.04317881f, 0.04244546f, 0.03093657f, -0.01429222f, 0.01104899f, -0.00190417f, 0.04455706f, 
    -0.00676830f, 0.03693861f, -0.02008476f, -0.00901375f, 0.01210667f, -0.05347002f, -0.03096863f, -0.06174121f, 
    -0.02898482f, -0.01420206f, 0.01861911f, -0.01941247f, -0.03106979f, -0.03930292f, -0.01380780f, -0.00568402f, 
    -0.00073271f, -0.05273874f, 0.03391878f, 0.02203717f, -0.03682683f, -0.02513579f, -0.00866042f, 0.00609970f, 
    0.00569785f, 0.00359358f, -0.01650026f, 0.00912014f, -0.03830519f, -0.04654902f, -0.04817568f, 0.01527399f, 
    -0.02342973f, -0.03423384f, 0.01289000f, 0.00611584f, -0.01234882f, -0.04326749f, -0.01277172f, 0.01749428f, 
    0.01590447f, -0.04014396f, 0.00242472f, -0.04151470f, 0.01649177f, -0.00328532f, 0.03832541f, -0.00015772f, 
    0.00983907f, -0.00424278f, 0.03383068f, -0.00439785f, -0.03646744f, -0.02349265f, 0.03764795f, 0.03685966f, 
    -0.04014450f, 0.02991209f, 0.01048672f, -0.01831288f, 0.02248888f, -0.06124748f, 0.01956112f, -0.00491454f, 
    0.02279804f, 0.01067609f, 0.04648758f, -0.02777535f, -0.02496261f, -0.06039341f, -0.02990923f, 0.02394952f, 
    0.00019215f, 0.04208049f, -0.05146900f, -0.01668032f, -0.00720926f, -0.00482034f, -0.05687704f, -0.01859239f, 
    -0.01143349f, -0.04722747f, -0.04136622f, -0.01909541f, -0.02600823f, -0.04084013f, 0.01087945f, -0.06242668f, 
    0.03901223f, 0.01549934f, 0.00988661f, -0.05380045f, 0.00616139f, -0.03905054f, 0.01676694f, 0.01086903f, 
    -0.00786486f, 0.02233777f, 0.04080140f, -0.02419782f, -0.06429163f, -0.00533081f, 0.00785702f, -0.00733340f, 
    0.00187904f, -0.05689626f, 0.03820975f, -0.03745664f, -0.05855247f, 0.03218961f, -0.04519320f, 0.03510012f, 
    0.00885583f, 0.01441746f, -0.02796363f, 0.03106789f, 0.02478859f, -0.03427629f, -0.03563824f, 0.01732047f, 
    0.01311052f, -0.01993091f, -0.05180646f, -0.00905756f, -0.02291392f, 0.02959820f, 0.04132321f, 0.02747076f, 
    -0.04385843f, -0.04606052f, 0.00128804f, 0.03623673f, 0.00255783f, 0.00860390f, 0.02542073f, 0.01523333f, 
    -0.01859179f, 0.00134838f, -0.03143333f, 0.02742017f, 0.00585045f, -0.00821761f, -0.02271775f, -0.04936401f, 
    -0.02402320f, 0.04045894f, 0.02313512f, -0.03256794f, -0.01610995f, -0.02774454f, -0.03430706f, -0.05702639f, 
    0.01228092f, -0.00625667f, 0.03887084f, -0.01157137f, -0.01733119f, 0.00211820f, -0.01221456f, -0.04858522f, 
    -0.01257309f, -0.01339605f, 0.01626368f, -0.01559191f, 0.00876441f, 0.00822554f, 0.01783935f, -0.04300864f, 
    -0.03087266f, -0.02231254f, -0.00764273f, 0.01116508f, 0.03308694f, -0.02721732f, 0.00598894f, -0.03694645f, 
    0.01363351f, -0.04370713f, -0.03057181f, 0.03930031f, -0.06603003f, -0.00175921f, -0.04584331f, 0.04285145f, 
    0.02244682f, 0.03979113f, 0.04190163f, -0.02141410f, 0.00460512f, 0.01030076f, 0.03754948f, 0.02713598f, 
    -0.01256749f, 0.00453749f, 0.00141197f, -0.02403834f, 0.00779725f, -0.04548305f, 0.02775501f, 0.03052334f, 
    0.01762300f, -0.04225603f, 0.03745200f, -0.05273073f, 0.03631442f, 0.03061461f, -0.02863938f, 0.01939440f, 
    0.00942363f, 0.02306252f, -0.03903561f, -0.00458409f, -0.03921349f, -0.02589550f, -0.05849183f, 0.00716972f, 
    -0.29225376f, 0.16222481f, 0.10306212f, -0.12050539f, -0.00533566f, -0.05726317f, 0.10888051f, -0.12291002f, 
    -0.01638765f, -0.02668048f, 0.18691514f, -0.05440109f, 0.05466541f, 0.01166992f, 0.18361266f, -0.23419006f, 
    -0.06361699f, 0.08961675f, 0.09697970f, 0.04729662f, 0.04790859f, 0.09423140f, 0.13789618f, 0.01797826f, 
    -0.05143122f, 0.27491039f, -0.20079775f, -0.04047276f, 0.00652269f, 0.07103009f, -0.00590597f, 0.00590672f, 
    -0.11825698f, -0.13380338f, -0.05201406f, 0.26543778f, -0.16423915f, 0.17792618f, -0.00328737f, -0.11505599f, 
    0.09277973f, -0.02153871f, -0.09029406f, 0.03804290f, 0.03376807f, 0.02124625f, 0.06349678f, 0.01556677f, 
    0.10332227f, 0.10433470f, 0.10620518f, 0.11604200f, -0.04993488f, 0.16094665f, -0.10757644f, 0.11395282f, 
    -0.00159134f, -0.07329855f, 0.04045670f, -0.09356315f, 0.10856688f, 0.13345674f, -0.10936130f, 0.18703791f, 
    -0.00097273f, -0.12873907f, 0.11823065f, -0.10808486f, 0.02655555f, -0.09716891f, -0.08498640f, -0.12643686f, 
    -0.23816702f, -0.13443953f, -0.12957339f, 0.09442035f, 0.11924066f, 0.04766211f, 0.05651361f, 0.10630954f, 
    -0.02660201f, 0.08081760f, 0.07206550f, -0.20140365f, -0.07457572f, 0.15113123f, 0.07055262f, -0.22564684f, 
    0.01806601f, 0.01381577f, 0.09263021f, 0.05041424f, -0.02451642f, 0.10850456f, -0.08702346f, 0.18470296f, 
    0.09809999f, 0.07838033f, -0.18013653f, 0.00729538f, -0.01537810f, 0.03390002f, -0.12088313f, 0.13432075f, 
    -0.07109599f, -0.15425767f, -0.04896908f, -0.13207026f, 0.05283231f, -0.06608472f, -0.04575404f, 0.26119626f, 
    0.05942452f, -0.07734787f, -0.04324798f, 0.11002896f, -0.02948596f, -0.12412192f, 0.04683981f, -0.08139838f, 
    0.00099593f, 0.01684436f, 0.04129450f, 0.11107717f, -0.05258770f, 0.04367513f, -0.02167672f, -0.10868835f, 
    -0.07023715f, -0.03830404f, -0.07588910f, -0.24586819f, 0.32654372f, -0.11359518f, 0.02604823f, -0.00291849f, 
    -0.06613951f, 0.08892941f, 0.06684706f, 0.14543778f, -0.01953712f, 0.12236769f, 0.10144811f, 0.14208153f, 
    -0.22239374f, 0.40281242f, -0.15307684f, -0.28493008f, 0.16891040f, -0.05102418f, -0.02105497f, 0.00138922f, 
    -0.04215858f, -0.06758396f, 0.03912949f, -0.00941079f, -0.28070131f, 0.21858212f, 0.00607176f, -0.29850423f, 
    0.08355106f, 0.05639148f, 0.06008874f, -0.01061580f, 0.05880592f, -0.07423628f, -0.06640135f, 0.00860200f, 
    0.08381129f, -0.08946682f, 0.04792505f, 0.27823782f, 0.09159297f, -0.05594666f, 0.03813871f, -0.08495706f, 
    0.11758781f, -0.05002337f, -0.13676745f, -0.11265931f, -0.28749412f, -0.07250219f, -0.13403060f, -0.01530435f, 
    0.09343447f, 0.11198964f, -0.01009190f, 0.21077558f, 0.08085671f, -0.02411266f, 0.17032142f, 0.06378970f, 
    0.14174037f, 0.05357736f, 0.16316466f, 0.29218253f, 0.03760910f, 0.04232211f, -0.02709805f, 0.15997089f, 
    0.00217118f, -0.05969274f, -0.07268909f, 0.01316277f, -0.19455837f, -0.12132927f, 0.26209995f, -0.04829659f, 
    -0.02269356f, 0.07056086f, 0.07346974f, -0.00294500f, -0.01941368f, -0.01044350f, 0.14126074f, 0.14990704f, 
    -0.12560949f, -0.04324946f, 0.07362655f, 0.07293530f, 0.10360768f, -0.03654122f, 0.03708899f, 0.10242034f, 
    -0.10700143f, 0.19563092f, 0.07947797f, -0.01460327f, 0.09263050f, 0.04366791f, 0.10206037f, 0.18384057f, 
    0.08102183f, 0.04394384f, -0.07996359f, 0.09793339f, -0.05474178f, -0.08380783f, 0.09407829f, 0.00329905f, 
    -0.00570789f, -0.04541593f, -0.20096597f, 0.21590662f, -0.03864384f, -0.02708836f, 0.07359670f, -0.06073032f, 
    0.02287058f, 0.14418165f, -0.00279945f, -0.01536861f, -0.03462625f, 0.06314664f, -0.01239587f, -0.10436293f, 
    0.07228722f, -0.06041060f, 0.02667220f, -0.06338613f, -0.06719019f, -0.15675728f, 0.03060063f, -0.20849256f, 
    -0.26567963f, 0.19958134f, 0.05219861f, -0.10889139f, 0.11912689f, -0.05540933f, 0.14095551f, -0.06855195f, 
    -0.01289606f, 0.06789242f, -0.07775535f, 0.00454830f, -0.00309951f, -0.15599287f, 0.10065804f, 0.02636321f, 
    -0.11520118f, 0.03099398f, -0.01917670f, 0.02755513f, -0.11055985f, 0.03833472f, 0.15973894f, 0.01956636f, 
    0.13759249f, -0.24653904f, 0.18152508f, 0.06611620f, -0.05239728f, 0.05884814f, 0.04514530f, 0.06163847f, 
    -0.02196323f, 0.10706463f, 0.20882946f, -0.00231829f, 0.22395256f, -0.00753490f, -0.15866895f, 0.22933084f, 
    0.02700262f, 0.08719870f, -0.07534914f, 0.02127253f, -0.00409769f, 0.00693442f, -0.04985124f, -0.04675128f, 
    0.22321029f, -0.12916446f, 0.17872888f, 0.08971732f, -0.00286629f, 0.00814271f, 0.05028528f, 0.06208780f, 
    -0.02104675f, -0.14054155f, -0.09986639f, 0.04176974f, -0.13399555f, 0.06707577f, 0.02179007f, 0.19752194f, 
    0.08336307f, 0.05501124f, -0.04417433f, 0.06646541f, -0.10986722f, 0.13623618f, -0.04064427f, -0.00212284f, 
    0.30102107f, 0.09983842f, 0.03578041f, -0.22730702f, 0.11129974f, 0.06373616f, -0.06700785f, -0.10970265f, 
    -0.06832187f, -0.08514137f, 0.00671843f, 0.02129754f, 0.24334206f, -0.06333163f, 0.05434346f, 0.27636445f, 
    -0.05974416f, 0.01994528f, -0.04277911f, -0.02400086f, -0.04538222f, 0.06780478f, 0.01546465f, 0.18609767f, 
    0.01268297f, -0.13573119f, -0.10151181f, -0.10759130f, 0.01160664f, -0.03128559f, 0.18648048f, 0.02036745f, 
    -0.08081935f, -0.08985252f, 0.04890409f, 0.07305096f, -0.09736950f, 0.02088204f, 0.02380045f, -0.00028248f, 
    0.01980111f, 0.04815565f, 0.07689139f, 0.06050781f, 0.03179318f, 0.03272081f, 0.19079033f, 0.18027571f, 
    0.01856671f, -0.04864826f, 0.02282340f, -0.00124024f, 0.01392677f, -0.03193094f, -0.05069305f, -0.04812299f, 
    0.02677308f, -0.05115998f, -0.00023923f, -0.01175187f, -0.04249881f, -0.05002301f, 0.01790843f, 0.04259847f, 
    -0.03257144f, 0.00205883f, 0.00291363f, 0.00897969f, 0.02975593f, -0.02855964f, -0.04869351f, -0.02149418f, 
    -0.02852660f, 0.03063145f, 0.02191833f, 0.00486463f, -0.04907811f, -0.00053711f, 0.01650546f, 0.02872958f, 
    -0.04749864f, -0.02987495f, 0.01599777f, -0.02902399f, -0.00564407f, -0.04873796f, -0.04534444f, -0.03004249f, 
    -0.01293698f, -0.02382993f, 0.02179095f, 0.02738821f, -0.04156767f, -0.01531382f, 0.02107480f, 0.02604865f, 
    0.03508719f, 0.00782101f, -0.00330436f, -0.05418615f, -0.04564926f, 0.01532337f, 0.01076077f, -0.03322193f, 
    0.00538054f, 0.02314302f, 0.00319038f, -0.05454926f, 0.00823932f, -0.05683758f, 0.04222123f, -0.05724159f, 
    -0.00118339f, 0.00154173f, -0.01694097f, -0.02011567f, 0.02916399f, -0.04481187f, -0.05287897f, -0.04735895f, 
    0.03977170f, -0.01898828f, 0.02125883f, 0.02195587f, -0.02305487f, -0.00509314f, -0.04417366f, -0.01472374f, 
    -0.02578556f, -0.00883602f, -0.04061594f, 0.03113451f, -0.03309131f, 0.00536987f, 0.03386575f, -0.01841673f, 
    0.03359913f, 0.02325870f, 0.02825311f, -0.00910318f, -0.02403933f, -0.05244378f, -0.04119522f, 0.02366579f, 
    -0.02636346f, 0.00162240f, -0.03380292f, -0.04478707f, 0.04326984f, -0.03929472f, 0.04109937f, -0.04783922f, 
    -0.02870741f, 0.03640988f, 0.01252068f, -0.02951633f, 0.00659003f, 0.01845744f, -0.00923710f, -0.05768489f, 
    -0.01922884f, 0.03274750f, -0.01251604f, -0.04735761f, 0.00944493f, -0.02886837f, -0.03654145f, -0.02691164f, 
    -0.04575368f, -0.02895531f, -0.05835110f, -0.05280961f, 0.02638708f, 0.01174133f, -0.01445650f, -0.02117818f, 
    0.02339534f, 0.02672208f, 0.03111470f, 0.04123336f, -0.03586833f, 0.03312040f, 0.02786605f, -0.01338958f, 
    -0.05676039f, -0.01603436f, -0.03010498f, 0.01935066f, 0.00700678f, -0.04743637f, -0.04160427f, -0.05617278f, 
    0.00466545f, 0.00747321f, -0.04278115f, 0.01501569f, -0.05626567f, -0.04214721f, 0.00890660f, -0.03954963f, 
    0.04177951f, -0.04135330f, 0.00516220f, -0.00396494f, -0.02761908f, 0.03490869f, -0.01365346f, -0.02182005f, 
    -0.03270193f, -0.00081054f, -0.05689728f, 0.02096949f, -0.00780462f, -0.05650420f, -0.03745600f, -0.04264338f, 
    0.01287618f, -0.04872615f, -0.00306599f, 0.03566421f, -0.00495797f, 0.02098020f, -0.01103607f, 0.02931587f, 
    0.04251097f, -0.05299295f, -0.01142072f, 0.01168066f, 0.01253552f, -0.03596256f, 0.02179000f, 0.03636721f, 
    -0.00257868f, -0.01005307f, -0.00127574f, 0.03697532f, 0.04118895f, -0.00536474f, -0.03451857f, -0.00345874f, 
    0.02047457f, 0.02353362f, 0.01260145f, -0.04330239f, -0.00407751f, -0.05252614f, -0.04857975f, -0.03202148f, 
    0.00494657f, -0.00101962f, 0.01394184f, -0.00855686f, -0.04177389f, -0.04012123f, 0.04170503f, -0.03417173f, 
    0.01271196f, 0.00414365f, 0.03260974f, -0.00350603f, 0.02960625f, -0.01941913f, -0.03612102f, 0.02695634f, 
    0.01480825f, 0.01614739f, -0.02883535f, 0.01582550f, -0.04855024f, -0.03630527f, 0.00844169f, -0.03556687f, 
    0.01568894f, 0.00506534f, -0.01085343f, 0.02146346f, 0.03758304f, -0.03397514f, 0.02887277f, 0.02788872f, 
    -0.00571215f, -0.02100237f, -0.02595041f, 0.03062916f, 0.02176329f, 0.03000261f, -0.02817702f, -0.05423583f, 
    0.04055201f, 0.01030421f, -0.00825293f, -0.04701344f, 0.02117050f, 0.00634367f, 0.01423125f, -0.03647763f, 
    -0.04830185f, -0.03403420f, 0.02973165f, -0.04108460f, 0.01062154f, -0.02112142f, 0.03569710f, -0.03212989f, 
    -0.05135370f, -0.05797186f, 0.04163660f, 0.02232240f, -0.02553078f, 0.01618672f, -0.04445867f, -0.05478700f, 
    0.02644231f, -0.04718831f, 0.01727705f, 0.04258135f, 0.03500285f, -0.02193896f, -0.01834197f, 0.00769773f, 
    -0.03433796f, -0.04613972f, 0.03572660f, 0.02883758f, 0.01243598f, -0.04963504f, 0.01265112f, -0.05742712f, 
    -0.00310698f, 0.01840144f, 0.00006003f, 0.03063574f, -0.04533674f, -0.02343175f, -0.00778815f, 0.03437467f, 
    -0.03736810f, 0.01316746f, 0.00918620f, 0.00666785f, -0.05421475f, 0.00379207f, 0.02786938f, -0.00882220f, 
    -0.02157293f, -0.04810876f, -0.02012910f, -0.03749475f, -0.03255207f, -0.03938697f, 0.00688567f, 0.04339477f, 
    0.01198991f, 0.02737990f, 0.05535210f, 0.03159545f, -0.01742202f, -0.05510812f, -0.01784959f, 0.01685901f, 
    0.04238207f, -0.03087856f, 0.04143236f, -0.03118788f, 0.01353173f, -0.02612613f, -0.03857553f, 0.01447061f, 
    -0.00612832f, 0.02553857f, 0.03294685f, 0.01692501f, 0.00484855f, -0.02641449f, -0.05659852f, -0.00880190f, 
    -0.03194480f, -0.00360538f, -0.02019072f, -0.02175011f, -0.04376403f, -0.02702072f, -0.01099358f, -0.04438860f, 
    -0.01298258f, 0.02895976f, -0.04615631f, -0.04229243f, 0.02292518f, -0.02674924f, 0.02732842f, -0.01073992f, 
    -0.05502206f, 0.00253156f, -0.00259445f, 0.03216167f, -0.02987120f, -0.01420826f, 0.00414160f, -0.01720369f, 
    0.00023654f, 0.02753095f, -0.02334155f, -0.03314535f, 0.02898643f, 0.00222653f, 0.03857427f, 0.01244709f, 
    0.03094423f, -0.03054415f, -0.01454840f, 0.02143476f, -0.04529428f, -0.03168428f, 0.01459296f, 0.02849886f, 
    -0.00707970f, 0.00020294f, 0.02087566f, -0.02472685f, -0.01427967f, -0.00377314f, 0.02264330f, -0.05391153f, 
    -0.01712988f, -0.05314844f, 0.00414432f, 0.00000845f, -0.01694135f, 0.02151461f, 0.02458539f, 0.04176150f, 
    -0.37569833f, -0.15377226f, 0.03913557f, -0.15709455f, -0.11037578f, 0.04443032f, -0.06342266f, -0.12389721f, 
    0.02757783f, -0.00868259f, 0.08531412f, -0.09632558f, -0.30988154f, -0.33596635f, -0.07296357f, -0.02361045f, 
    -0.07044372f, -0.00196753f, 0.01360540f, -0.00480007f, -0.08101452f, -0.01459719f, 0.03315526f, -0.01954711f, 
    0.00554707f, -0.15845709f, 0.12161473f, 0.16101491f, -0.04562332f, 0.02530459f, -0.03097811f, -0.09723811f, 
    0.03075296f, -0.02710986f, -0.02776160f, 0.04346222f, -0.21816315f, -0.27202910f, -0.13522822f, -0.26720986f, 
    -0.12518670f, 0.07138785f, -0.13112608f, -0.06398192f, 0.10598563f, 0.06365999f, 0.03359171f, 0.03454144f, 
    -0.00342779f, 0.10085420f, -0.13324901f, 0.01254954f, 0.08058699f, 0.00404045f, -0.10673090f, 0.08555551f, 
    -0.03592935f, -0.04096105f, 0.04043937f, 0.09446459f, -0.12374463f, -0.05627327f, -0.12631553f, 0.08212082f, 
    -0.19368343f, -0.04510617f, 0.19264124f, 0.13129285f, 0.04298820f, 0.02801063f, 0.00026741f, 0.07248208f, 
    -0.20178856f, -0.01306621f, 0.03189602f, -0.08586736f, 0.10786685f, 0.03086511f, 0.03553414f, 0.09717812f, 
    -0.00809652f, 0.01140418f, -0.01647801f, 0.06461321f, -0.09796515f, 0.09311818f, -0.07244214f, 0.20261590f, 
    -0.09067226f, -0.01598548f, 0.04599097f, 0.00934464f, -0.02007698f, 0.01581058f, 0.09262732f, -0.02214823f, 
    -0.04688408f, 0.10360937f, -0.15829164f, -0.15440296f, 0.05038489f, -0.00301871f, 0.00508557f, -0.00528035f, 
    0.14615475f, -0.11824088f, -0.01246397f, 0.02314511f, 0.01333179f, -0.10366646f, 0.04563240f, 0.14911775f, 
    0.14544521f, 0.02891405f, 0.03293209f, 0.08953300f, 0.06929775f, -0.02805774f, -0.00041005f, 0.10925490f, 
    -0.04163286f, -0.23432927f, 0.20274714f, 0.20690136f, -0.22903259f, -0.05235892f, -0.13466518f, 0.03816240f, 
    0.04873974f, 0.01480773f, -0.05214445f, -0.02456402f, 0.07946633f, 0.00167304f, 0.01327008f, -0.01668333f, 
    0.00338018f, 0.00900703f, 0.03479193f, 0.14575240f, -0.04959172f, -0.04086079f, -0.03543675f, 0.07962328f, 
    0.18014047f, 0.06751272f, -0.10790686f, 0.23359729f, -0.09189326f, -0.02467273f, -0.05004673f, 0.04549764f, 
    -0.02903984f, -0.10412475f, 0.01314394f, 0.12208874f, 0.02112405f, -0.31585634f, -0.14412929f, 0.05033906f, 
    -0.14699297f, 0.00177721f, 0.03007443f, -0.11041790f, 0.03092259f, 0.00970905f, 0.01657417f, -0.03200614f, 
    -0.00344747f, 0.02404208f, 0.26757699f, -0.06713659f, -0.02074940f, 0.00787410f, 0.06900617f, 0.22474965f, 
    0.09838060f, 0.12119947f, -0.05928975f, -0.00759116f, -0.27121109f, 0.05167991f, -0.06111693f, -0.08428361f, 
    0.13088596f, -0.06949073f, 0.01117355f, 0.04892106f, -0.06600478f, -0.03948356f, 0.01808224f, -0.07152070f, 
    0.18149987f, 0.02050759f, -0.03366022f, -0.12039720f, 0.01098975f, -0.04679503f, 0.10321681f, 0.04919492f, 
    -0.00414995f, 0.08650820f, -0.01341457f, 0.01167331f, -0.10957529f, 0.22673774f, -0.03077919f, -0.02684489f, 
    0.02326067f, 0.03364464f, -0.04966719f, -0.08242660f, 0.03431017f, 0.07679157f, -0.02288228f, -0.09290964f, 
    0.02076695f, 0.28604981f, 0.19527458f, -0.08168950f, 0.04203687f, 0.00038125f, -0.06777222f, 0.14838023f, 
    -0.03160027f, 0.07143760f, -0.00054547f, 0.05599562f, 0.35044032f, 0.34608608f, 0.04780597f, -0.11249858f, 
    0.02019081f, 0.08522268f, 0.05776132f, 0.17696397f, -0.09843221f, 0.07258814f, 0.11480250f, -0.13545389f, 
    0.26129264f, -0.16220900f, 0.01088960f, 0.07273906f, 0.04745383f, 0.05228075f, 0.04674827f, 0.06200312f, 
    -0.06594905f, 0.04905120f, -0.01284483f, 0.02472590f, 0.02794040f, -0.06207021f, -0.01245079f, 0.06942923f, 
    -0.20116869f, 0.03374787f, 0.01336549f, -0.03750254f, 0.00060362f, -0.00858434f, 0.12847431f, 0.03090366f, 
    -0.38026562f, 0.02722355f, -0.04055398f, 0.10455980f, 0.09141239f, -0.11382455f, -0.03706955f, -0.03723388f, 
    0.03918411f, -0.01452261f, 0.14241146f, 0.16485721f, -0.27958220f, 0.07538076f, 0.23019728f, 0.12375406f, 
    -0.14050235f, 0.00143409f, 0.00278907f, 0.09834425f, 0.02267396f, 0.03922809f, -0.02537120f, -0.05947953f, 
    -0.35189393f, -0.17829791f, 0.22943938f, -0.08838803f, -0.09161641f, 0.04293218f, -0.03953516f, 0.05279328f, 
    -0.06271377f, -0.02036995f, -0.07159568f, 0.12031429f, 0.17235105f, -0.05205770f, 0.10585081f, 0.12508480f, 
    0.04641107f, -0.06102828f, 0.06600957f, 0.14306785f, 0.06907211f, 0.00093186f, 0.05630988f, 0.05729296f, 
    -0.33193526f, 0.13332444f, 0.16883056f, 0.09557717f, -0.06852996f, 0.03328351f, 0.01756405f, -0.08409517f, 
    -0.01599784f, 0.11993836f, -0.07234426f, 0.08884222f, 0.12227663f, -0.01190876f, 0.21805912f, -0.04946850f, 
    0.13341132f, 0.06114993f, -0.00753632f, 0.11555925f, -0.02517911f, 0.11249889f, -0.06053867f, 0.22216451f, 
    -0.10439055f, -0.25290588f, -0.00823725f, 0.22253713f, 0.04431285f, 0.06776785f, -0.01108069f, -0.12615547f, 
    0.03457775f, 0.05085322f, -0.05096146f, 0.11477272f, 0.48179045f, 0.16349006f, 0.09346376f, -0.02041009f, 
    0.03429271f, 0.02513180f, -0.09524309f, 0.03363418f, -0.06779867f, 0.03924888f, -0.13196550f, -0.09070329f, 
    0.05157772f, 0.11471281f, -0.10608856f, 0.02497482f, -0.04907006f, 0.09470300f, -0.03878682f, -0.01897820f, 
    0.02314916f, 0.00978555f, 0.02344383f, -0.04275895f, 0.27929327f, 0.29308480f, 0.08271873f, -0.07752061f, 
    -0.03837311f, 0.02037905f, 0.14704022f, -0.11353368f, 0.02834709f, 0.04119539f, -0.02885711f, 0.12689479f, 
    -0.04540591f, -0.04106632f, -0.02181586f, 0.01115195f, 0.02755419f, -0.05825331f, -0.06173297f, 0.01264548f, 
    0.03843244f, -0.05298772f, -0.04166758f, 0.03701506f, 0.04373519f, -0.05427654f, -0.03058130f, 0.03897903f, 
    -0.03562618f, -0.00903333f, 0.03204849f, -0.04239459f, -0.05681272f, -0.04575287f, -0.05185342f, 0.03242745f, 
    -0.05503176f, -0.01265913f, -0.01918337f, -0.04354995f, -0.04593344f, -0.01271133f, 0.01179078f, -0.05013186f, 
    0.01959366f, -0.04490800f, -0.03177294f, -0.04234464f, -0.04595062f, 0.04393664f, 0.01376320f, 0.02148094f, 
    -0.00932469f, 0.00958565f, 0.00791469f, 0.03454125f, -0.04037289f, -0.04563107f, 0.01466857f, 0.00206092f, 
    0.02190751f, -0.05228364f, -0.04109999f, 0.02664843f, -0.02853995f, 0.03023380f, -0.03804854f, 0.01343283f, 
    -0.04542276f, -0.03497196f, -0.03632531f, -0.02314138f, 0.02869534f, 0.01152060f, 0.01286444f, -0.00318001f, 
    -0.04667310f, 0.02090183f, -0.01262667f, -0.02034884f, 0.00300419f, 0.03592194f, 0.02145071f, -0.04623886f, 
    -0.03403131f, 0.02881015f, 0.00434886f, 0.03490807f, -0.05680894f, -0.00973047f, -0.01610374f, -0.01613940f, 
    -0.02989213f, 0.03878895f, -0.04102136f, 0.02086704f, -0.02847602f, -0.03944729f, 0.01728020f, -0.03193341f, 
    0.03662048f, 0.03935092f, 0.02472274f, -0.03254237f, 0.03885853f, 0.01965121f, 0.02994819f, -0.02002057f, 
    -0.00034361f, -0.04135303f, 0.03401458f, -0.00301985f, -0.02648796f, -0.03406877f, 0.03425367f, -0.04457074f, 
    -0.00312311f, -0.00661445f, 0.01477845f, 0.02112265f, 0.02771224f, 0.03191444f, 0.00128356f, 0.01729904f, 
    -0.00648903f, -0.01717856f, 0.00069843f, 0.01668430f, 0.00532535f, -0.01813333f, -0.00901883f, -0.04788299f, 
    -0.01606781f, -0.04243252f, -0.04418641f, 0.02864546f, -0.03939767f, -0.00997483f, 0.00748381f, 0.03386946f, 
    -0.01430111f, -0.01453461f, -0.03881996f, -0.04079531f, 0.04040084f, -0.02431256f, -0.01640253f, 0.02240644f, 
    0.01967322f, 0.03047346f, -0.04009030f, -0.01072221f, 0.00588174f, 0.02739232f, -0.03481851f, 0.03306807f, 
    -0.01863014f, -0.00350121f, 0.02241519f, 0.02476170f, -0.03571186f, 0.00991281f, -0.05311614f, -0.04129546f, 
    0.03783680f, -0.00159170f, -0.03940459f, -0.02645249f, -0.02897033f, 0.02405730f, 0.01981690f, 0.00332766f, 
    0.02090096f, -0.05892828f, -0.02023496f, -0.04878360f, 0.01808074f, -0.00294298f, 0.02916382f, -0.05241336f, 
    -0.03435112f, -0.00699383f, 0.01483149f, 0.03499529f, -0.00541047f, -0.00829960f, -0.02961237f, -0.04112783f, 
    -0.01608631f, -0.04954883f, -0.04421674f, 0.01035910f, 0.03302692f, 0.01219869f, 0.03013064f, -0.02096245f, 
    0.03655140f, 0.00870922f, -0.02724647f, -0.02822652f, -0.02637766f, 0.00921338f, -0.00203328f, -0.04603779f, 
    -0.01397797f, 0.02764895f, -0.02719107f, 0.05037294f, 0.02744396f, 0.01049190f, -0.02618289f, -0.05721937f, 
    -0.01977434f, 0.00042640f, 0.02440425f, 0.01210194f, 0.02064035f, -0.01393061f, -0.02746868f, -0.04275384f, 
    -0.02433680f, -0.00551577f, 0.01779646f, -0.00641052f, 0.03429930f, -0.01363315f, 0.00355690f, -0.02423587f, 
    0.04160894f, -0.00920324f, 0.00680085f, -0.03956353f, 0.02991213f, -0.04520957f, 0.02569161f, 0.01000175f, 
    -0.04852884f, -0.04416151f, 0.02903542f, 0.01896450f, -0.01265798f, -0.00286097f, 0.00771913f, -0.03391794f, 
    0.04311177f, -0.02351188f, -0.01013345f, -0.03441509f, -0.03402639f, -0.03473653f, 0.01473637f, -0.00046284f, 
    0.00505573f, 0.01753393f, 0.05404640f, 0.04721510f, -0.05566069f, -0.04407691f, -0.04719183f, 0.00074483f, 
    -0.00178562f, -0.00612664f, 0.03698331f, 0.03657272f, -0.05163556f, -0.03001164f, 0.02166347f, 0.03857760f, 
    -0.05004524f, 0.01893457f, -0.01741151f, 0.03635130f, 0.02185248f, -0.03703226f, -0.04242383f, 0.00738882f, 
    -0.01817022f, 0.03176629f, -0.02788076f, -0.02746341f, -0.02407429f, -0.04728328f, 0.00900816f, 0.00967356f, 
    -0.04211106f, 0.00775926f, -0.00810535f, -0.02492660f, -0.01747909f, 0.01359780f, 0.00684237f, -0.03118388f, 
    0.01486171f, -0.02505707f, -0.02837311f, -0.00684482f, -0.00047115f, 0.04579903f, 0.00877343f, 0.00283790f, 
    -0.04082955f, -0.02375964f, -0.01398133f, -0.02964488f, -0.02074428f, 0.00848583f, 0.03680434f, 0.02950741f, 
    0.01575606f, 0.02004213f, 0.02099626f, -0.02726789f, 0.01403592f, 0.02596758f, 0.04132899f, -0.00467658f, 
    -0.01001814f, -0.00119682f, -0.05206306f, 0.02825820f, 0.02440830f, 0.04359546f, -0.00317623f, 0.01004635f, 
    -0.00598510f, -0.00331236f, 0.03292423f, -0.05255968f, 0.03172350f, -0.01001966f, 0.02556906f, 0.02505161f, 
    0.02599611f, 0.02269668f, -0.04102000f, -0.01291275f, -0.01583684f, 0.01172709f, 0.03480782f, 0.03492064f, 
    -0.04157307f, -0.01189586f, 0.00222336f, -0.02739782f, 0.00302947f, -0.04656177f, -0.02463195f, -0.03974320f, 
    0.01797533f, 0.00477069f, 0.02921535f, -0.04633072f, 0.02871980f, -0.06177007f, -0.00597197f, -0.03020947f, 
    0.02892969f, 0.00633053f, 0.01978632f, -0.00256396f, 0.00175753f, 0.02766011f, 0.00985050f, -0.00063654f, 
    0.01509345f, -0.05509586f, -0.00506266f, -0.04694046f, -0.05369991f, 0.02362079f, 0.02679941f, -0.00784533f, 
    0.00828966f, -0.00635120f, 0.05257158f, -0.03378338f, 0.00275488f, 0.04636246f, -0.01360217f, 0.01516975f, 
    -0.05868284f, 0.03376236f, -0.03659475f, 0.01010735f, 0.03743280f, -0.04756846f, -0.04741768f, -0.02243808f, 
    -0.05404194f, -0.01855671f, 0.04981918f, -0.04604143f, 0.01930291f, 0.00270242f, 0.00625514f, -0.03177808f, 
    -0.00311510f, 0.02394291f, -0.01942949f, 0.04382246f, 0.02045003f, -0.05303255f, -0.02521469f, -0.03580937f, 
    -0.03442816f, -0.00697292f, -0.05706802f, -0.03748367f, 0.02258577f, -0.04342678f, -0.03177847f, -0.04463439f, 
    -0.05747934f, 0.01029464f, -0.03931240f, -0.00010218f, -0.02464284f, -0.01313822f, 0.00028022f, -0.03191021f, 
    0.01338207f, -0.01724961f, -0.04633179f, -0.02386420f, -0.05059575f, 0.04102032f, -0.01360007f, 0.02460315f, 
    -0.00234777f, -0.00665748f, 0.02964129f, -0.04594475f, -0.01674437f, 0.01184058f, -0.04623330f, 0.04262460f, 
    -0.02258726f, -0.00854711f, -0.01853374f, -0.02988474f, -0.02464958f, 0.02079321f, 0.03129087f, -0.02548608f, 
    -0.02592717f, -0.03617484f, 0.00672859f, 0.03436350f, -0.02109186f, -0.01029118f, -0.00602471f, -0.04443418f, 
    -0.01847276f, 0.02854732f, 0.03027062f, -0.01738336f, -0.01838783f, 0.02378874f, -0.04535999f, 0.03492376f, 
    -0.05738586f, -0.02223594f, -0.04896267f, 0.02925855f, -0.04182252f, 0.03426773f, 0.03418094f, 0.01384765f, 
    -0.03673661f, -0.02521835f, -0.02228163f, -0.05572305f, 0.03581981f, -0.04423304f, -0.01329986f, 0.02164924f, 
    -0.04088459f, -0.03262044f, -0.00801496f, 0.02310308f, -0.01426232f, -0.01618455f, -0.02220584f, 0.03497416f, 
    -0.02228953f, -0.01264925f, 0.04014615f, -0.05454659f, -0.04824783f, 0.00093536f, 0.04044333f, -0.03133027f, 
    -0.02485307f, 0.00681400f, -0.04956272f, -0.04025882f, 0.00914915f, -0.02041416f, -0.02674094f, 0.02817860f, 
    -0.01598853f, 0.01182032f, -0.00419358f, -0.01253882f, 0.03816572f, 0.00469671f, 0.00902882f, -0.02497401f, 
    0.04012294f, -0.04471124f, 0.03851871f, -0.04848206f, -0.00969080f, -0.01280341f, -0.04854538f, 0.03462313f, 
    -0.01119372f, 0.03554371f, -0.04410031f, 0.04520210f, -0.00897993f, 0.01383655f, -0.01583308f, 0.00511369f, 
    0.03717630f, 0.03994684f, 0.01667122f, -0.04442025f, -0.02134871f, 0.03437898f, -0.03040193f, -0.02432785f, 
    0.01304015f, 0.01237573f, -0.02932074f, 0.02046362f, 0.00059808f, -0.00134079f, -0.02918412f, -0.02916454f, 
    -0.00103892f, -0.05693963f, -0.00495390f, -0.01692253f, -0.01589980f, 0.01670991f, -0.04717724f, -0.05355373f, 
    -0.00206059f, -0.03923927f, -0.02938145f, -0.03901942f, -0.05469205f, 0.03388415f, -0.02290437f, -0.01763585f, 
    -0.04741970f, -0.00825953f, -0.01554857f, 0.01117424f, -0.00985738f, -0.03777933f, -0.02205506f, -0.02194216f, 
    -0.05395038f, -0.05360225f, 0.03493721f, 0.03225389f, 0.03968047f, 0.00397305f, -0.03673371f, 0.03838149f, 
    0.03254675f, -0.03228762f, -0.01717546f, -0.04196413f, -0.02206520f, -0.05335657f, -0.03306631f, 0.03315734f, 
    0.03620713f, -0.01990301f, -0.03864851f, 0.01596114f, -0.01764693f, -0.00667581f, -0.03932329f, -0.00572277f, 
    -0.02922886f, -0.02922742f, -0.01298137f, 0.02160287f, -0.05291722f, 0.00867078f, -0.02490371f, -0.05829024f, 
    -0.04363732f, -0.00909566f, 0.01017147f, -0.04670427f, -0.00801490f, 0.03163090f, -0.01690697f, 0.03522822f, 
    -0.05421110f, 0.02394304f, 0.01712112f, 0.02441424f, -0.02015847f, -0.02439954f, -0.03593561f, -0.01909773f, 
    -0.05381186f, 0.00811485f, -0.04422624f, -0.05124013f, 0.02280671f, 0.03590761f, -0.00260663f, -0.05272223f, 
    -0.02046227f, 0.02802004f, 0.02393164f, 0.00213252f, -0.01748856f, 0.01053930f, -0.01161814f, 0.04142614f, 
    0.00359548f, 0.02137695f, -0.01508975f, 0.02471814f, 0.00132611f, -0.01781624f, -0.03941708f, 0.01067647f, 
    -0.01417430f, -0.00971966f, 0.03447902f, -0.02022432f, -0.01524625f, 0.04464819f, -0.03459211f, 0.04109646f, 
    -0.05199077f, 0.00234682f, 0.01752318f, -0.02787573f, 0.00803156f, -0.04619076f, -0.03191413f, 0.00568519f, 
    0.01220614f, -0.01358791f, 0.04178388f, -0.01010362f, 0.03800249f, 0.01284019f, 0.02644503f, 0.02982255f, 
    0.04392244f, -0.00202241f, 0.02178556f, -0.01576925f, -0.00274266f, -0.03590957f, -0.05130677f, -0.05195495f, 
    0.03255967f, 0.03870032f, 0.00839072f, -0.01866775f, 0.04525874f, -0.04136528f, -0.01651138f, -0.02322632f, 
    0.00026399f, 0.03013103f, -0.02808202f, 0.03670822f, -0.05491922f, -0.04500930f, 0.02447615f, -0.04913636f, 
    -0.00959838f, -0.03158037f, -0.01834021f, 0.03208978f, -0.02189902f, -0.02106353f, -0.04794897f, 0.04155660f, 
    -0.04851035f, 0.02296102f, -0.05213523f, 0.01770926f, -0.00720420f, 0.00970172f, 0.02110201f, 0.00874465f, 
    -0.04762403f, -0.00705726f, -0.03895766f, 0.03376212f, -0.02526044f, -0.01781194f, 0.00656491f, 0.03951344f, 
    -0.02325965f, 0.01743718f, -0.01086521f, 0.01874435f, -0.03960923f, 0.00097044f, -0.01746808f, 0.01622429f, 
    -0.01771030f, 0.02602955f, -0.03499402f, 0.01584332f, 0.00831038f, -0.05549160f, 0.01284447f, 0.00625934f, 
    0.01921980f, -0.00541084f, 0.00673099f, -0.03812513f, 0.00137569f, -0.01927768f, -0.03748100f, 0.02996649f, 
    -0.02654861f, 0.03605997f, 0.04012629f, 0.00826701f, -0.04173551f, -0.00731143f, -0.01978932f, 0.04133903f, 
    0.03675966f, 0.02301886f, 0.02311315f, -0.04240650f, -0.00422328f, 0.02023516f, 0.00094476f, 0.03620431f, 
    -0.04452582f, 0.03906023f, 0.03206852f, 0.00627309f, -0.01261332f, 0.00685898f, -0.03072203f, 0.00149442f, 
    0.02868197f, -0.01257274f, -0.04685284f, -0.03409956f, 0.00798623f, -0.02875596f, -0.02893922f, -0.02002917f, 
    -0.01151700f, 0.01168152f, 0.00455088f, 0.00085017f, 0.02169214f, 0.01400876f, 0.03175009f, -0.01092952f, 
    -0.03464288f, -0.02711265f, -0.05816943f, -0.03701823f, 0.00711556f, -0.04421107f, -0.00697318f, -0.00083348f, 
    -0.05903016f, -0.01400693f, -0.02082922f, 0.03412112f, -0.04017983f, 0.04083313f, -0.03662892f, 0.01028923f, 
    -0.03761416f, 0.02076119f, -0.00269581f, -0.03268798f, 0.00185893f, 0.00885724f, -0.01372483f, -0.03206953f, 
    0.03698987f, -0.01994015f, -0.04604226f, 0.01861109f, 0.01534074f, 0.04021369f, 0.02934028f, 0.01731227f, 
    -0.02909446f, 0.02248186f, -0.03709033f, -0.03022546f, -0.02935417f, -0.04550407f, 0.02515876f, -0.05164764f, 
    -0.03518986f, -0.05146173f, 0.03815946f, -0.00568108f, 0.00722768f, -0.02857734f, -0.00933833f, -0.05386014f, 
    0.02766859f, 0.01885512f, -0.00463910f, 0.00715451f, 0.01193685f, -0.01192560f, 0.01172687f, -0.01158993f, 
    -0.04257638f, 0.01685983f, 0.03308079f, 0.03672019f, -0.05688064f, -0.04434049f, -0.01421861f, 0.01972461f, 
    0.04080227f, -0.03972514f, -0.04495810f, 0.01157062f, 0.00278297f, -0.04573108f, -0.05142087f, 0.00541375f, 
    0.01504076f, -0.01662745f, 0.03718638f, -0.03181532f, -0.02917452f, -0.04237244f, 0.01431947f, -0.04923066f, 
    -0.02476148f, -0.02143716f, 0.03522751f, 0.04130361f, -0.05552066f, 0.01815880f, -0.01949352f, -0.01741927f, 
    0.00470228f, -0.00591388f, -0.01443455f, 0.02077003f, -0.04820884f, -0.03480114f, -0.02688261f, 0.00512164f, 
    -0.02540809f, 0.03848678f, 0.00313704f, -0.02476832f, -0.01834184f, 0.02301257f, 0.03583852f, 0.03649588f, 
    0.01580677f, -0.02743011f, -0.04140567f, -0.01396786f, 0.03752971f, -0.02085613f, 0.04848444f, -0.05393107f, 
    -0.02365002f, -0.02131047f, -0.02884162f, -0.03448080f, -0.04234245f, 0.02355552f, 0.02678888f, -0.03055399f, 
    0.01904396f, -0.05140270f, -0.04592087f, 0.03740397f, -0.02804852f, -0.01843720f, 0.03098221f, -0.04073785f, 
    -0.03201363f, 0.01291526f, 0.02793794f, -0.05619160f, -0.04332615f, 0.00212866f, -0.01671876f, 0.00023168f, 
    -0.04378644f, -0.04489562f, 0.03123688f, 0.01995893f, -0.04705235f, -0.04640820f, -0.01982851f, 0.00404528f, 
    -0.01509597f, -0.01707564f, 0.00435159f, -0.03777302f, -0.05927835f, 0.00784781f, -0.02988669f, -0.01192132f, 
    -0.03265122f, 0.04442926f, 0.00598072f, -0.02627888f, -0.04498760f, 0.00766994f, 0.03937428f, -0.01123761f, 
    0.02795385f, -0.00654388f, 0.04554892f, 0.04123019f, 0.00036963f, 0.02306974f, 0.01890578f, -0.02890141f, 
    0.01892534f, -0.02083027f, -0.03395868f, -0.04168418f, -0.00009683f, 0.01869739f, -0.00437607f, 0.03129819f, 
    0.01701957f, -0.01377717f, 0.04508308f, -0.01250756f, 0.02288422f, 0.00559640f, -0.01115059f, -0.03288321f, 
    -0.03896497f, 0.03011312f, -0.05177775f, 0.00502749f, 0.03561752f, 0.01718716f, -0.05430440f, -0.00836371f, 
    -0.02759260f, -0.04597094f, 0.02294822f, 0.01792321f, -0.03410769f, -0.02185898f, 0.01000035f, -0.00231234f, 
    -0.04683566f, 0.00270949f, 0.02195407f, -0.01365617f, -0.04686758f, 0.02716714f, -0.02288302f, -0.00643947f, 
    0.04070371f, -0.02615079f, 0.00199938f, 0.03740566f, -0.00669967f, -0.01991586f, -0.01961338f, 0.02299860f, 
    0.04508672f, -0.03006065f, -0.02008995f, 0.03438492f, -0.01726121f, -0.05196999f, -0.04595355f, -0.00041502f, 
    0.01893084f, 0.02597795f, -0.00329844f, 0.03687328f, -0.01583430f, -0.04353861f, -0.04802836f, -0.01063337f, 
    0.03534006f, 0.00225580f, -0.01320157f, -0.00554259f, 0.01063301f, 0.00149980f, 0.01030731f, 0.03634970f, 
    -0.01480373f, -0.02508441f, -0.03771909f, 0.03129537f, -0.05015690f, -0.02678698f, 0.01449097f, -0.00759193f, 
    0.01654374f, 0.01257521f, 0.00007576f, -0.05449715f, 0.02091754f, 0.02345397f, -0.05021822f, -0.02909194f, 
    0.03021110f, -0.02767859f, -0.05375483f, -0.01215646f, -0.02655573f, 0.00665370f, -0.03065434f, -0.01948585f, 
    0.01006509f, 0.02141654f, 0.01282591f, 0.05511521f, -0.04183337f, -0.00208755f, -0.02376898f, 0.01190422f, 
    0.04126124f, -0.03705199f, 0.03751364f, -0.01853806f, -0.04285224f, 0.02595440f, 0.03098827f, 0.01930424f, 
    -0.00882526f, 0.01865850f, -0.01922063f, 0.02781725f, -0.05718553f, -0.04647414f, 0.00640285f, -0.05765109f, 
    -0.04300407f, 0.02001581f, -0.05348694f, -0.00406375f, -0.01499211f, -0.01409302f, 0.02992841f, -0.04324596f, 
    0.03019311f, -0.01092636f, -0.01491585f, 0.01324009f, 0.04005306f, -0.00579603f, 0.01336016f, 0.01185767f, 
    -0.03526119f, -0.00780643f, 0.04397323f, -0.00507146f, -0.01450743f, -0.04870266f, -0.03763660f, 0.02209214f, 
    -0.01617973f, 0.02552955f, 0.00040605f, 0.00400601f, -0.03296858f, 0.02391571f, -0.03874660f, 0.01140158f, 
    -0.05413280f, 0.01370330f, -0.01114448f, -0.04296011f, 0.01741090f, -0.02864431f, -0.02395058f, 0.03046912f, 
    -0.04491121f, -0.01141612f, -0.00154678f, -0.02972816f, -0.03323201f, -0.02188127f, -0.00118578f, -0.04044895f, 
    -0.00690054f, -0.03226042f, -0.00946228f, -0.02368167f, 0.01149073f, -0.02853928f, -0.04809018f, -0.05096602f, 
    -0.01296636f, -0.04186031f, 0.01766633f, -0.00734364f, -0.01409743f, -0.03955596f, 0.01480860f, -0.01169083f, 
    0.01472940f, 0.04425039f, -0.03758107f, 0.00593134f, 0.00917717f, 0.02557883f, -0.00718754f, -0.02963035f, 
    0.03080156f, 0.01145663f, -0.01149280f, -0.00298117f, 0.01587844f, 0.02968284f, -0.00116815f, -0.01694581f, 
    -0.02620750f, 0.04347986f, 0.03870837f, -0.04266248f, 0.02448678f, 0.00280741f, -0.02564750f, 0.00483059f, 
    0.04000059f, -0.00285501f, 0.04296269f, -0.03254090f, 0.00746096f, -0.02204990f, -0.02139787f, -0.02244961f, 
    0.05341892f, -0.03076146f, 0.03371619f, -0.04932600f, -0.01077517f, -0.04239485f, 0.02027352f, -0.04983141f, 
    -0.03064793f, 0.02564382f, -0.02535367f, -0.01157272f, -0.02047427f, -0.03416760f, -0.04359802f, 0.03791563f, 
    -0.05751240f, 0.02291158f, 0.03669786f, -0.02509716f, 0.02155724f, -0.01252644f, -0.05336287f, -0.02400451f, 
    -0.00653516f, -0.02243926f, -0.02387818f, 0.01023151f, -0.01892976f, 0.03503607f, -0.04520860f, -0.00053446f, 
    -0.00542234f, -0.02133967f, 0.03632285f, 0.01096583f, -0.02027659f, -0.03609569f, 0.02692333f, -0.05887255f, 
    0.03165960f, 0.03831490f, -0.04410336f, 0.02864534f, 0.03783827f, 0.03405011f, 0.03914277f, -0.00679390f, 
    -0.02287600f, -0.00362880f, -0.03939673f, 0.00595355f, -0.03332101f, 0.01959300f, 0.00955542f, -0.04108584f, 
    0.00437683f, 0.00266416f, -0.01593127f, -0.00975095f, -0.05661308f, -0.02737149f, 0.01687508f, 0.00455622f, 
    0.02307853f, 0.00580291f, -0.04133293f, 0.03829465f, 0.03460848f, 0.04363313f, 0.00673426f, 0.03771316f, 
    0.03853511f, -0.00900847f, 0.00379504f, 0.02195339f, -0.02025367f, 0.03090627f, 0.03874498f, -0.00448311f, 
    0.00259885f, 0.02129952f, -0.05490165f, -0.01679717f, -0.02824353f, -0.01547698f, -0.03449878f, -0.02653181f, 
    -0.03651089f, 0.03047359f, 0.03575999f, 0.02407192f, -0.03389705f, -0.04099336f, 0.01117943f, -0.01080281f, 
    0.02455003f, 0.01201707f, -0.00668137f, -0.03977663f, 0.02876996f, -0.01970657f, 0.00476728f, -0.05855913f, 
    -0.03250514f, 0.04654296f, 0.02288234f, -0.01416312f, -0.00190444f, 0.02011085f, -0.05732487f, -0.04972297f, 
    0.02078223f, -0.04523845f, -0.02980881f, -0.02629106f, -0.00686134f, -0.00104050f, -0.03368437f, -0.00490484f, 
    -0.01237692f, 0.01474772f, -0.01614457f, 0.02241211f, -0.00958619f, -0.04743391f, -0.00801654f, -0.01645694f, 
    -0.04234352f, 0.02322259f, -0.01337309f, -0.00680084f, 0.02068652f, -0.02217054f, -0.02102635f, 0.04000661f, 
    0.02385857f, 0.02720771f, 0.01761408f, 0.01134451f, -0.05026634f, 0.00923047f, -0.05109345f, 0.01161196f, 
    -0.04694957f, -0.02922025f, -0.05111671f, 0.01996087f, -0.05346369f, 0.03670542f, 0.02419354f, -0.05690374f, 
    -0.00012106f, 0.01877512f, -0.05229084f, -0.01454476f, -0.05092654f, 0.02024781f, -0.01812018f, -0.03409263f, 
    0.03009117f, 0.02499554f, -0.03353186f, -0.04518274f, -0.04535017f, 0.03061102f, 0.00766948f, 0.02013353f, 
    -0.00974460f, 0.03900770f, 0.04429110f, -0.00770275f, -0.00831556f, -0.01214174f, 0.03101597f, 0.03048972f, 
    0.03165934f, -0.04398543f, 0.01452330f, -0.05592461f, 0.04380215f, 0.01358306f, 0.01554600f, 0.00610752f, 
    -0.02255416f, -0.04161050f, 0.00996913f, 0.00591508f, -0.01321749f, 0.03105587f, -0.04210094f, -0.02869231f, 
    0.01126448f, -0.03896824f, -0.04882419f, -0.03272897f, 0.03468970f, -0.04137803f, 0.03262329f, -0.04360534f, 
    -0.05827459f, -0.03158725f, -0.05788243f, -0.03476524f, 0.00857071f, -0.02463119f, -0.04496757f, 0.00357542f, 
    -0.02395765f, -0.04323646f, 0.00002539f, -0.04339500f, -0.02745693f, -0.00167529f, -0.00603067f, -0.01169563f, 
    -0.01976812f, 0.01790041f, -0.05473827f, -0.01544308f, 0.03634298f, 0.01485134f, 0.00910506f, -0.04174072f, 
    0.01403397f, 0.00124447f, 0.02290270f, 0.00878359f, -0.02883375f, 0.02106120f, -0.04945004f, -0.03491629f, 
    0.00671450f, -0.02804371f, -0.06167451f, -0.01963619f, -0.03264958f, -0.01243700f, 0.01128890f, 0.01835152f, 
    -0.03040730f, -0.03728916f, -0.00920476f, -0.01113459f, -0.04316679f, -0.03359031f, -0.01833737f, -0.05075615f, 
    -0.04651020f, -0.05170939f, -0.00431012f, -0.05572422f, -0.03770991f, -0.01800498f, -0.03350957f, -0.01279487f, 
    -0.05740371f, -0.05633977f, -0.02323198f, -0.05454458f, -0.00878063f, -0.02929443f, 0.03225775f, 0.01706870f, 
    -0.00441847f, -0.01570472f, -0.01520788f, 0.03002650f, -0.04242741f, 0.03110509f, -0.02271193f, 0.02762668f, 
    0.02745502f, 0.02327694f, -0.03091838f, -0.02278726f, 0.01565051f, 0.00280409f, -0.05072779f, 0.00421593f, 
    0.03930233f, -0.04681193f, -0.03774125f, -0.00291777f, 0.00121056f, -0.02192875f, -0.05476010f, 0.01465461f, 
    -0.00257323f, -0.02156454f, 0.00428525f, -0.05366066f, -0.01069792f, -0.03107041f, -0.03892718f, -0.04334534f, 
    0.02289080f, -0.04528819f, -0.00490674f, -0.00859213f, -0.02750236f, -0.04050652f, 0.01172528f, -0.01004408f, 
    -0.02330321f, 0.04395879f, 0.02732134f, -0.02998304f, 0.04128359f, -0.03539406f, -0.04344261f, -0.02660773f, 
    0.02402391f, 0.02252769f, 0.03184214f, 0.02200426f, 0.02328699f, -0.02680177f, 0.02724592f, -0.03063857f, 
    0.02624384f, 0.02780727f, -0.00407362f, -0.05452074f, -0.05330863f, 0.00901482f, -0.00362449f, 0.04003355f, 
    -0.02754009f, 0.01998264f, 0.03468776f, 0.02624148f, -0.01628884f, -0.02624702f, 0.02644887f, -0.01821222f, 
    0.01664284f, -0.04619024f, 0.02125566f, 0.01355491f, 0.03332379f, 0.02361895f, 0.03775868f, -0.01606725f, 
    -0.00503189f, 0.01350214f, -0.05226916f, -0.03771596f, -0.01814272f, 0.00965661f, 0.03879280f, -0.03935442f, 
    -0.00172680f, 0.01016819f, -0.02922039f, -0.03998547f, -0.00998950f, 0.02670435f, 0.02106035f, -0.02021871f, 
    -0.02084263f, 0.02117215f, -0.02547251f, -0.05150676f, -0.04592879f, 0.02559545f, -0.01361801f, -0.02555076f, 
    0.01247650f, -0.02829686f, -0.04831848f, -0.01411923f, -0.00735899f, 0.01853724f, 0.01910953f, -0.01408411f, 
    0.01796869f, 0.03695791f, -0.00110579f, 0.01635400f, -0.01990396f, -0.01258836f, -0.04312669f, -0.00103164f, 
    -0.03939079f, -0.01410928f, -0.04667643f, 0.00821127f, -0.00268893f, 0.02713427f, 0.03244400f, -0.05696404f, 
    -0.02163073f, -0.04858710f, 0.03696549f, 0.03442299f, 0.02347764f, -0.03516022f, -0.02218914f, 0.01134729f, 
    -0.04773259f, -0.04830996f, 0.02073123f, -0.04456667f, -0.05183490f, 0.01528729f, 0.02115932f, -0.03063608f, 
    -0.03060799f, -0.04404586f, -0.01778815f, -0.02049620f, -0.03915224f, 0.00262786f, 0.00791851f, -0.00600695f, 
    -0.02194652f, -0.00007701f, -0.00308560f, -0.03760438f, 0.01070425f, 0.02767240f, 0.00844190f, -0.01016688f, 
    -0.03078352f, 0.01193049f, 0.01459000f, 0.03867647f, -0.01108407f, -0.02522988f, 0.01025424f, -0.04549266f, 
    -0.01808363f, 0.03768514f, 0.01866255f, -0.02510284f, -0.00270225f, -0.03509384f, 0.01979722f, -0.00281301f, 
    0.02920537f, -0.02368227f, 0.03862984f, 0.03915322f, -0.02330963f, 0.00159914f, 0.01894707f, 0.00108888f, 
    -0.04257014f, 0.00663923f, 0.03119773f, -0.01419987f, 0.01106497f, 0.00398311f, 0.03102979f, -0.03576693f, 
    -0.02293396f, 0.00109380f, -0.04310905f, -0.05851463f, 0.02142502f, 0.02893030f, -0.02813625f, -0.00188475f, 
    -0.01601901f, -0.04817216f, -0.03317523f, -0.02198769f, 0.03133466f, -0.00880701f, 0.04034281f, -0.03251708f, 
    0.04087154f, 0.03363457f, 0.02613851f, -0.02259498f, 0.02754895f, -0.03986337f, 0.02123174f, -0.04843682f, 
    0.01281879f, 0.03760836f, -0.01339645f, -0.00145056f, 0.03324207f, -0.03750903f, 0.00875181f, -0.05596900f, 
    0.01856126f, -0.02577755f, 0.00644695f, 0.02339129f, -0.01023716f, -0.03730522f, 0.04336268f, 0.02795091f, 
    -0.00704475f, 0.02633137f, -0.05825952f, -0.02249614f, -0.03027240f, 0.04230499f, -0.00983452f, -0.05487496f, 
    -0.04364456f, -0.05476003f, 0.01625327f, -0.05752942f, 0.03826097f, -0.04472227f, -0.00187784f, 0.02907068f, 
    0.02097740f, -0.04446751f, 0.01821859f, 0.02866510f, -0.01913278f, 0.01073474f, -0.05307715f, -0.04070475f, 
    -0.02612198f, 0.02002409f, 0.03910555f, -0.01083584f, -0.00213585f, 0.01950825f, -0.03054975f, 0.04269972f, 
    -0.03873582f, -0.04340845f, -0.02467797f, 0.03404591f, -0.02523590f, 0.02767442f, -0.04937571f, 0.02916275f, 
    -0.05744907f, -0.05587650f, -0.01345765f, -0.00723012f, 0.03331695f, 0.02910448f, 0.04058481f, 0.03545285f, 
    -0.03079295f, -0.01984634f, 0.03699551f, -0.05798835f, 0.01717819f, 0.01216707f, -0.04023082f, -0.01370164f, 
    0.00532365f, -0.01409050f, -0.05702652f, 0.01247812f, 0.00797166f, 0.02233146f, -0.03289073f, -0.00853562f, 
    -0.03276533f, 0.02092783f, -0.00371710f, -0.05629597f, -0.05467340f, -0.03821287f, 0.01680392f, 0.00097330f, 
    0.02262301f, 0.00470089f, 0.03062062f, 0.00100893f, 0.00385797f, 0.03955385f, 0.01116303f, -0.00142974f, 
    -0.02938592f, -0.05213613f, -0.02946281f, -0.03135429f, -0.03811585f, -0.01951890f, 0.00157363f, 0.01384039f, 
    -0.02070848f, -0.00480527f, 0.03956462f, -0.05740533f, -0.01277666f, -0.03307696f, 0.03282271f, -0.03534584f, 
    0.02796081f, -0.01106169f, 0.04284441f, -0.00014391f, 0.03082538f, 0.01916222f, -0.03473226f, 0.03557642f, 
    -0.05508862f, -0.01605011f, -0.01344336f, 0.02403022f, -0.01138998f, -0.04377824f, -0.04026593f, -0.03155367f, 
    -0.03187376f, -0.00192952f, 0.02443593f, -0.02361739f, -0.01580845f, 0.01072825f, -0.02695180f, 0.01140430f, 
    0.00978312f, -0.01357095f, -0.00510388f, 0.03199801f, -0.02215656f, -0.01612311f, -0.02532009f, 0.01939723f, 
    0.00300045f, -0.03969876f, -0.02148919f, 0.03744797f, -0.05742411f, 0.03384184f, 0.01522704f, -0.02739611f, 
    0.03338507f, 0.01028526f, 0.00700121f, -0.04140765f, -0.01425451f, 0.03376901f, 0.00249616f, -0.03110728f, 
    -0.02629735f, -0.05708983f, -0.05286460f, 0.02302884f, -0.01803219f, -0.01229009f, 0.01347356f, 0.01465492f, 
    -0.03896893f, -0.05477540f, -0.03338235f, 0.00887850f, -0.00590151f, -0.02941127f, 0.02514245f, 0.03618033f, 
    -0.01366554f, 0.01832909f, 0.00886098f, -0.04423063f, -0.05845688f, 0.03990494f, 0.00994020f, -0.02447390f, 
    -0.04112623f, -0.04445921f, -0.05716094f, -0.03331413f, -0.02970007f, -0.04709131f, -0.02713572f, -0.01241303f, 
    0.02364287f, 0.01506783f, 0.02794991f, 0.00395400f, -0.02784887f, -0.04909592f, 0.02970869f, 0.02955775f, 
    -0.05491966f, -0.00671170f, -0.01001614f, -0.01584102f, -0.05468438f, -0.00200110f, -0.02351370f, 0.00398295f, 
    -0.04783573f, -0.01673680f, 0.00493084f, -0.05637516f, -0.00535210f, 0.02741747f, 0.00212263f, -0.05223262f, 
    0.03985106f, -0.02211886f, -0.01610176f, -0.01476218f, 0.03876069f, -0.04211348f, -0.01903960f, -0.02385654f, 
    -0.00766045f, -0.04087875f, 0.03008741f, 0.03391241f, -0.03716435f, 0.00537757f, -0.01708273f, -0.01701654f, 
    0.03515966f, -0.05668070f, -0.03260341f, -0.02679297f, -0.01658853f, -0.03485484f, 0.00911154f, -0.03574868f, 
    0.02698128f, 0.01223903f, -0.05441381f, 0.02143971f, -0.01400487f, 0.03870029f, -0.01225800f, 0.02356808f, 
    -0.02005859f, 0.00698767f, 0.03181234f, -0.03730653f, -0.05511161f, 0.02544332f, 0.03124179f, -0.04702977f, 
    0.02013063f, -0.00661970f, 0.02140354f, -0.03405749f, -0.00109854f, -0.01907856f, 0.01511613f, 0.02479433f, 
    -0.04521448f, -0.02305480f, -0.03396878f, -0.03293559f, 0.00984194f, 0.02680358f, 0.00470717f, -0.00134802f, 
    -0.04939650f, -0.03628873f, 0.03727558f, 0.02339983f, 0.03709166f, -0.01039976f, -0.01876200f, -0.04945066f, 
    -0.05883958f, 0.02227325f, 0.00697219f, -0.00309686f, -0.03277577f, -0.02758048f, 0.01532596f, 0.00499423f, 
    -0.02720951f, -0.05405291f, -0.01084476f, 0.04149144f, 0.01138034f, -0.00988439f, -0.00703656f, -0.02615502f, 
    -0.10883006f, -0.02894587f, -0.11051965f, -0.08687126f, 0.04182559f, -0.03370214f, 0.00165322f, 0.01826291f, 
    -0.10532431f, 0.05349832f, 0.10048068f, 0.00742071f, 0.14214021f, 0.12743528f, 0.04543761f, -0.03796474f, 
    0.05525647f, -0.01680444f, 0.01557009f, 0.03430872f, 0.02824008f, 0.01612186f, 0.04858886f, -0.02320152f, 
    0.30493528f, 0.06807286f, -0.19418733f, -0.01652476f, -0.00925002f, 0.05111825f, 0.11574258f, -0.05395658f, 
    -0.09571583f, -0.03798271f, 0.08822197f, 0.09440179f, -0.02496959f, -0.05912717f, -0.11130175f, -0.05155619f, 
    -0.10127714f, -0.04328163f, -0.08411267f, 0.08663128f, -0.01323099f, -0.15849625f, 0.09200313f, -0.05842930f, 
    0.17660818f, 0.07496406f, 0.29693264f, 0.26040471f, -0.01760926f, -0.02145272f, -0.00471038f, 0.18003543f, 
    -0.01092294f, 0.12427969f, -0.00258547f, -0.16390078f, -0.24641453f, 0.31817004f, 0.05365839f, 0.06546138f, 
    0.10050463f, -0.04084801f, -0.06931649f, -0.08192656f, 0.11853135f, -0.11837544f, 0.07563365f, -0.00360183f, 
    -0.36928335f, 0.01942937f, 0.04986172f, -0.20881958f, 0.11120510f, 0.14883779f, 0.10681359f, -0.14840926f, 
    -0.10392002f, 0.14048260f, 0.11375112f, -0.09904769f, 0.00145063f, -0.11167263f, 0.02803452f, -0.17155084f, 
    -0.01400974f, -0.06898730f, -0.00653192f, -0.00451138f, 0.08890513f, -0.02985693f, 0.00140341f, -0.02914009f, 
    -0.09259909f, -0.07292297f, 0.02817166f, 0.06188817f, -0.02548098f, 0.00290070f, 0.10892181f, 0.19770829f, 
    -0.02234646f, -0.06681537f, -0.03285211f, 0.00287601f, 0.08427149f, -0.12802504f, -0.13894616f, -0.04102088f, 
    -0.04066162f, 0.08012459f, -0.12400775f, -0.06333405f, 0.05940753f, -0.08776700f, 0.00373558f, -0.04179118f, 
    0.40409741f, 0.21513470f, -0.17988543f, -0.06231995f, -0.01323640f, -0.04629160f, -0.05640129f, 0.08301072f, 
    -0.06980806f, -0.07337114f, -0.06097682f, -0.04908325f, -0.17744185f, 0.05902402f, 0.19888644f, 0.08647816f, 
    -0.03470972f, -0.11087359f, -0.02275592f, 0.05442551f, 0.03646192f, -0.08312852f, 0.04965929f, 0.11886442f, 
    -0.23271269f, 0.21505664f, -0.11638380f, 0.02018389f, 0.04640168f, 0.00651264f, -0.04664073f, -0.03268384f, 
    -0.01035423f, -0.06223469f, 0.00356926f, -0.03884405f, -0.29549026f, 0.12661375f, 0.08476758f, -0.24023280f, 
    -0.00749976f, 0.04313258f, -0.03467529f, -0.05301589f, -0.00341465f, 0.01941664f, 0.00575036f, -0.08089095f, 
    0.05277864f, -0.01487782f, -0.00974732f, 0.35149050f, -0.03014294f, 0.06818236f, -0.08769237f, -0.05825201f, 
    0.10090996f, -0.01854849f, -0.02213586f, -0.00182510f, -0.19333732f, -0.08871929f, 0.22074969f, -0.24811524f, 
    0.13114588f, 0.10471527f, 0.17333326f, -0.00217288f, -0.08536083f, -0.09084038f, 0.17054267f, 0.01882832f, 
    0.51929915f, 0.13213164f, 0.02621138f, 0.28720933f, -0.00182709f, 0.09022997f, -0.06367438f, -0.12534764f, 
    0.00413036f, -0.08311273f, -0.06454462f, 0.15158376f, 0.07759460f, -0.03407527f, 0.04642987f, -0.01037691f, 
    -0.00590404f, 0.09128910f, -0.04331259f, 0.01853298f, -0.03919094f, -0.01444732f, 0.12707467f, 0.09242425f, 
    0.21328260f, 0.18112442f, 0.09001895f, 0.03916673f, -0.00972301f, 0.20050657f, 0.01086152f, -0.02682784f, 
    -0.08026128f, 0.07699898f, -0.01467973f, 0.02870862f, 0.13720824f, 0.03267468f, 0.14562775f, 0.35337391f, 
    0.06563603f, 0.14178413f, -0.04633035f, 0.09602092f, 0.14738196f, -0.11059006f, 0.04634477f, 0.13331860f, 
    -0.08339075f, -0.00646291f, -0.00555959f, 0.00992073f, -0.03209646f, -0.01458282f, 0.02560653f, -0.20500594f, 
    0.01842765f, 0.15124869f, 0.08707536f, 0.02456065f, -0.06360624f, -0.04120419f, -0.01617419f, -0.13843517f, 
    0.06049088f, 0.05582264f, -0.03069919f, -0.01100220f, -0.05671966f, -0.10134991f, 0.08123237f, -0.03312895f, 
    -0.14569175f, 0.23217759f, -0.04114170f, 0.07095125f, -0.04677014f, 0.05390713f, 0.15426710f, -0.07761605f, 
    0.06235204f, -0.01866607f, -0.02652691f, 0.00733707f, 0.10008856f, -0.15795714f, -0.00987494f, -0.01951941f, 
    0.00384261f, -0.11563341f, 0.01480306f, 0.08430730f, -0.00314965f, 0.09767137f, 0.09650827f, 0.02449641f, 
    0.33052546f, 0.14731295f, -0.13664392f, 0.25761563f, 0.04771847f, -0.06327934f, -0.07847059f, 0.04993748f, 
    -0.03103624f, 0.15646051f, 0.07991850f, -0.04783970f, -0.01999226f, 0.17062677f, -0.07299636f, 0.02773645f, 
    0.00662168f, 0.13661613f, 0.13195413f, -0.07830441f, -0.00355618f, -0.07380131f, 0.02684064f, -0.23876944f, 
    -0.07950908f, -0.12982711f, 0.25134280f, 0.14120561f, -0.04003111f, -0.00148973f, 0.04433134f, 0.11611465f, 
    -0.00547812f, -0.10019454f, 0.07053585f, 0.04134648f, -0.11463137f, -0.08263375f, -0.01534501f, -0.02805073f, 
    -0.06276178f, 0.19193207f, -0.01488282f, -0.01986348f, 0.09760188f, 0.01733972f, 0.03323283f, -0.03309760f, 
    0.49129227f, 0.04698117f, -0.15076475f, -0.12740505f, 0.11621440f, 0.01927650f, -0.02757597f, -0.03085927f, 
    -0.01094375f, -0.04870167f, -0.04049742f, -0.03696022f, -0.07854634f, 0.02893418f, 0.29903600f, 0.33065769f, 
    0.01935332f, -0.03563858f, -0.12405115f, -0.01286288f, 0.03101540f, 0.05084205f, 0.14318614f, 0.09287927f, 
    -0.33126467f, 0.06932844f, 0.20193984f, -0.10428622f, 0.14879447f, 0.07288879f, 0.16079737f, 0.02768827f, 
    -0.01824697f, -0.02808324f, 0.10020778f, 0.04434545f, -0.19133332f, -0.15613677f, 0.09737029f, 0.07227533f, 
    0.07017728f, 0.04752300f, -0.03454489f, -0.04541877f, -0.04119695f, 0.05264570f, 0.12503590f, 0.13738400f, 
    -0.48182398f, -0.04151398f, -0.12135953f, -0.09198944f, 0.19684501f, 0.01434529f, 0.09763832f, -0.06834716f, 
    -0.04436291f, -0.01167661f, 0.11300649f, -0.06272069f, -0.05582081f, -0.12749469f, 0.11438248f, -0.11869325f, 
    0.12908617f, 0.11902013f, -0.19418083f, -0.12486060f, 0.05046666f, -0.06137407f, 0.04741983f, 0.01523931f, 
    -0.18500789f, 0.21278700f, -0.01808087f, -0.05660454f, 0.17607735f, 0.03356878f, 0.13179658f, 0.05876685f, 
    0.07216121f, 0.06148037f, -0.01561028f, 0.05029581f, -0.25881809f, -0.11418498f, -0.19833171f, -0.13591506f, 
    0.17864814f, 0.11665808f, -0.02101954f, -0.12394749f, 0.11018190f, -0.02995577f, -0.01858460f, 0.05606178f, 
    0.09799619f, 0.12933825f, -0.05273404f, 0.08976440f, 0.12080067f, -0.04572560f, 0.07487617f, 0.14519711f, 
    0.10811403f, 0.06499691f, -0.05219434f, 0.15254517f, -0.15203728f, 0.14134425f, -0.07852402f, 0.14970037f, 
    0.12135247f, 0.02512208f, 0.10592455f, 0.12109607f, 0.13637838f, 0.08324819f, -0.01851198f, 0.16675964f, 
    -0.06973769f, -0.06777303f, -0.03010477f, 0.10290225f, -0.10163107f, -0.06641774f, 0.00683780f, 0.06537296f, 
    -0.09559466f, 0.05300869f, 0.03090193f, -0.12492757f, -0.35096782f, -0.16085894f, 0.00858471f, -0.32577786f, 
    0.10233232f, -0.03993274f, -0.02285096f, -0.03226136f, 0.03175521f, -0.02619205f, 0.00815155f, 0.09027979f, 
    0.00846897f, -0.03306257f, -0.08517396f, -0.01623099f, 0.19140065f, -0.07294599f, 0.07848201f, 0.19737028f, 
    0.08631513f, -0.00864147f, -0.00188810f, 0.09079716f, 0.00520276f, -0.14287785f, 0.00838289f, 0.07950865f, 
    -0.07176718f, 0.02685156f, -0.08940663f, -0.03872576f, 0.08904737f, 0.00242729f, 0.06147046f, 0.03354119f, 
    0.29087359f, 0.07682046f, 0.05640996f, -0.02462868f, 0.00539661f, 0.03263500f, -0.02112096f, -0.12433951f, 
    -0.01823175f, 0.06597495f, -0.04576412f, -0.13173510f, -0.20156612f, -0.18250450f, 0.02729495f, -0.10817616f, 
    0.04807881f, 0.07427914f, -0.18431300f, 0.10952341f, 0.05255587f, -0.07215254f, 0.09084659f, 0.02087328f, 
    -0.27126986f, 0.16314673f, -0.11954990f, -0.19961885f, 0.24896988f, -0.01101838f, 0.07884324f, -0.05985047f, 
    0.03927519f, -0.09092791f, 0.07298186f, 0.06885781f, -0.51597369f, -0.21333733f, -0.13723341f, -0.26029322f, 
    0.23230070f, -0.05881058f, -0.02522757f, -0.04686748f, 0.14759384f, -0.06442721f, -0.04400464f, 0.05482505f, 
    0.08814298f, -0.05644820f, -0.03290369f, 0.13467607f, -0.00793166f, 0.03760452f, 0.11977135f, -0.04567092f, 
    0.08585641f, 0.25147110f, -0.04137480f, 0.01819325f, -0.02582280f, 0.10438479f, -0.05916046f, -0.03999338f, 
    -0.07866613f, -0.20349354f, 0.12664676f, 0.07773368f, 0.00081426f, -0.13084091f, -0.01455911f, -0.11180639f, 
    -0.34285271f, -0.13187312f, 0.21922047f, -0.10952519f, 0.02339628f, 0.13993913f, -0.09997890f, 0.17045215f, 
    -0.02859806f, -0.07978849f, -0.10017893f, 0.02850795f, -0.03702306f, -0.16928877f, 0.03675693f, -0.02758939f, 
    -0.16804215f, 0.03412754f, 0.00682045f, 0.06231450f, 0.01826872f, 0.00725271f, 0.05845890f, -0.05198634f, 
    -0.24844413f, -0.14043982f, -0.08781376f, -0.06269614f, -0.14424622f, 0.01436806f, -0.04302863f, -0.04896102f, 
    -0.05708164f, 0.03837395f, 0.03690060f, 0.00276400f, 0.31676441f, -0.07229952f, -0.04682057f, 0.08027656f, 
    0.12593915f, 0.12040755f, -0.01692817f, 0.19538796f, 0.07915708f, 0.08782430f, 0.12798750f, 0.10787053f, 
    0.17745903f, 0.05332068f, -0.10771275f, -0.02692633f, -0.00649670f, -0.01735081f, 0.12382077f, 0.03166368f, 
    0.02556749f, 0.19297814f, 0.04663086f, 0.03993943f, -0.22947353f, -0.15145485f, -0.06285720f, -0.00249885f, 
    0.15329516f, -0.13680071f, 0.01969107f, -0.10036774f, 0.02230024f, -0.00400555f, 0.02754942f, -0.07281518f, 
    -0.11093000f, 0.27246141f, 0.07613356f, 0.12770402f, 0.20352723f, -0.01521176f, 0.04277565f, -0.02262732f, 
    0.13247520f, -0.12058778f, 0.04232558f, 0.17911403f, 0.12141666f, 0.04985650f, 0.08844110f, 0.06380845f, 
    0.02801841f, 0.12588300f, -0.10109975f, 0.15091060f, 0.11023588f, -0.01709103f, 0.12639354f, 0.07583337f, 
    0.18914178f, -0.14320740f, 0.25847802f, -0.04827990f, 0.08088590f, 0.22869904f, -0.01829739f, 0.06282607f, 
    0.06279255f, 0.05700056f, 0.04557759f, 0.18110533f, 0.27044034f, 0.05616562f, -0.14492097f, -0.08272313f, 
    -0.00873835f, 0.09076703f, -0.02394221f, 0.00211830f, 0.04568220f, 0.06905665f, 0.08150344f, 0.09519974f, 
    0.04387729f, 0.11890250f, 0.08102439f, -0.01288945f, -0.01910850f, -0.06876718f, 0.04350244f, 0.22803406f, 
    0.09261928f, -0.08899791f, 0.04682002f, 0.06356455f, -0.04146938f, 0.19194639f, 0.03845513f, -0.00101947f, 
    -0.20097628f, -0.01609968f, -0.05285870f, 0.02623483f, -0.00928939f, 0.06737684f, 0.10670448f, 0.00592880f, 
    0.11625408f, -0.07522478f, 0.26183292f, -0.10565584f, 0.17487399f, 0.08638252f, 0.00404917f, -0.03366397f, 
    0.01803755f, -0.03929357f, 0.05114854f, 0.01632957f, 0.12780768f, 0.01252642f, -0.00177838f, 0.19615082f, 
    0.09774957f, 0.14843699f, -0.04749979f, 0.05147335f, 0.04114326f, -0.02671836f, 0.15950792f, 0.08923673f, 
    0.04991291f, 0.02893822f, -0.09317779f, 0.03979718f, 0.12712313f, -0.06917281f, 0.12485576f, 0.19346605f, 
    -0.06836247f, 0.04478006f, 0.08957194f, 0.01002972f, -0.12888317f, -0.01811378f, 0.00633502f, -0.09429213f, 
    0.01462642f, -0.03303623f, -0.06037949f, 0.16842790f, 0.01517401f, 0.19638415f, 0.01278861f, 0.13716210f, 
    -0.04800286f, -0.07981517f, -0.12276953f, -0.08810487f, 0.10987739f, 0.02313848f, 0.03059774f, 0.00016974f, 
    0.03075993f, 0.03384391f, -0.07874618f, -0.00433121f, -0.05224727f, -0.10585152f, -0.14136916f, 0.04975145f, 
    0.10501957f, 0.05954423f, -0.09470377f, -0.03038154f, -0.11475960f, -0.06234808f, -0.07569620f, 0.09218922f, 
    0.06438915f, -0.20952344f, 0.00495308f, 0.21557532f, 0.00852365f, 0.04355605f, 0.02852708f, -0.06353144f, 
    0.07028444f, 0.04675492f, 0.04258405f, -0.12259027f, 0.21630584f, -0.27384207f, -0.14314526f, -0.14002676f, 
    0.06376880f, 0.05651698f, -0.01629721f, -0.11547564f, 0.02937965f, -0.04692818f, 0.02535453f, -0.04233216f, 
    -0.01625161f, -0.07413191f, 0.03948703f, 0.20573530f, 0.07705137f, -0.01568212f, 0.12335224f, 0.08855787f, 
    -0.03933663f, 0.19584103f, -0.04322395f, 0.09130348f, -0.19868951f, 0.18100221f, 0.06032229f, -0.03097822f, 
    0.06197024f, 0.00910582f, -0.08323514f, 0.06830311f, 0.15650852f, -0.00836928f, -0.07337730f, 0.12818874f, 
    -0.11619827f, 0.12155959f, 0.23756920f, -0.07045776f, -0.03068332f, 0.04002822f, 0.09885550f, -0.13611300f, 
    -0.05797213f, 0.10008509f, -0.07905960f, 0.07791664f, -0.04996547f, -0.16999798f, -0.12133481f, 0.07423457f, 
    -0.04148056f, -0.08027357f, -0.05311237f, -0.13923883f, 0.08277096f, -0.00185797f, 0.23394878f, -0.16171382f, 
    -0.06309467f, 0.04910942f, 0.04665523f, 0.13236353f, 0.01298098f, -0.06808749f, 0.15153073f, 0.03631439f, 
    0.00636207f, 0.11117633f, 0.01832483f, 0.14609011f, 0.01131348f, -0.06491312f, 0.03686895f, -0.03090604f, 
    0.10829562f, 0.09427738f, -0.10948703f, -0.24359757f, 0.01706364f, 0.04098072f, -0.00391502f, 0.02752975f, 
    0.32041988f, -0.08368076f, -0.07032315f, 0.13175488f, 0.02971621f, 0.01976049f, -0.05939582f, 0.08185420f, 
    -0.06950623f, -0.03075501f, 0.03247272f, 0.20944878f, -0.30341381f, -0.05493476f, 0.19956057f, 0.00893732f, 
    0.08237264f, -0.18139756f, -0.03728529f, -0.03465416f, 0.00356658f, -0.01005953f, 0.01936102f, -0.08465954f, 
    0.01434014f, -0.23679185f, 0.08127324f, 0.22673880f, -0.01032339f, 0.08465267f, 0.06860723f, -0.10126870f, 
    0.08880715f, 0.00189382f, 0.01746001f, 0.08077899f, -0.04060499f, -0.04438842f, -0.08911060f, 0.06001720f, 
    0.11825455f, -0.06641825f, -0.00100214f, -0.07476094f, 0.02854045f, 0.02760580f, 0.06801356f, 0.05234183f, 
    -0.04344654f, -0.00064640f, -0.00581750f, 0.16690040f, -0.03566858f, 0.04955588f, -0.05552230f, 0.00334471f, 
    0.01741794f, 0.15170708f, 0.15960914f, 0.20278634f, -0.01499419f, 0.20304978f, 0.21738917f, -0.13307610f, 
    0.02531757f, -0.18339433f, 0.17375262f, -0.25497714f, -0.12387459f, -0.06339761f, -0.06083032f, -0.19177777f, 
    0.19717909f, 0.17449056f, -0.06839053f, 0.00537811f, -0.00630439f, 0.08115106f, -0.11150519f, -0.08924042f, 
    -0.04970058f, 0.02495486f, -0.00593897f, 0.02442182f, -0.00167629f, 0.09782194f, -0.23094459f, -0.06300876f, 
    -0.04873171f, 0.01239301f, -0.03330687f, 0.02293628f, 0.01735822f, -0.06127638f, 0.03057747f, -0.15670303f, 
    0.06199224f, 0.33631891f, 0.21049881f, 0.06837997f, 0.01581764f, 0.13414896f, 0.00060740f, -0.11566522f, 
    0.07882270f, -0.16621827f, -0.07110509f, -0.04128296f, 0.16336656f, 0.05251833f, 0.10102471f, 0.11904132f, 
    -0.03810887f, -0.16534187f, 0.14309379f, 0.10896052f, 0.06039926f, 0.06662152f, -0.07183734f, -0.00672542f, 
    -0.02841066f, -0.00961682f, 0.09084344f, -0.07615824f, -0.02447076f, -0.01273645f, -0.01383360f, -0.04458817f, 
    -0.10011293f, 0.07308611f, 0.03869606f, 0.09245533f, -0.13772939f, -0.15405306f, 0.03965381f, 0.06157105f, 
    0.06160859f, 0.01184006f, 0.00175669f, 0.06341621f, -0.02113061f, 0.11341096f, 0.15470482f, 0.24547400f, 
    -0.01705485f, -0.07533675f, -0.16946514f, 0.09153255f, -0.03073204f, 0.00496028f, -0.00760481f, 0.04970071f, 
    0.03328897f, -0.18351924f, 0.09205515f, 0.10313950f, -0.07996535f, -0.07305704f, -0.06564358f, 0.29238987f, 
    0.05971252f, -0.04621408f, 0.02241693f, 0.11273032f, 0.03399106f, 0.03149224f, -0.02064210f, -0.01820490f, 
    -0.09853757f, 0.12313936f, -0.10034280f, -0.00710800f, 0.08686601f, 0.00880120f, -0.02060956f, -0.00393455f, 
    0.09454568f, 0.02032392f, -0.09818877f, 0.10444141f, 0.01651737f, 0.04795042f, 0.12309678f, -0.03019410f, 
    0.08174668f, 0.03518476f, 0.06712859f, -0.13428096f, -0.07432299f, -0.08653896f, 0.00465905f, -0.19076622f, 
    -0.33749998f, 0.05422654f, 0.10344736f, 0.12795962f, 0.02301780f, -0.02975761f, -0.08190916f, -0.01625671f, 
    0.06084589f, 0.01645373f, 0.13997002f, 0.08763590f, 0.14641722f, 0.00418702f, 0.00831800f, -0.07970175f, 
    -0.10294808f, 0.09002579f, -0.08137068f, -0.06525427f, 0.09766337f, -0.04527806f, -0.13305464f, 0.06145086f, 
    0.12525478f, -0.22974069f, -0.13746062f, 0.17257984f, -0.03958257f, -0.04042337f, 0.03352516f, 0.11850426f, 
    0.09767183f, 0.13257791f, -0.13162395f, 0.13874297f, -0.05108313f, 0.08490507f, 0.22909659f, 0.22857924f, 
    0.13151552f, 0.01409617f, 0.01644202f, 0.06349910f, 0.11027412f, 0.01347545f, 0.10583182f, -0.12242930f, 
    -0.09921772f, 0.24159779f, 0.01624071f, -0.03674209f, -0.01092843f, 0.09428389f, 0.00581880f, 0.06902889f, 
    0.03066145f, 0.08132719f, 0.00456224f, -0.09878010f, -0.05423401f, 0.01991461f, 0.08617048f, -0.04439300f, 
    -0.03451871f, -0.10905470f, -0.12477113f, -0.06389660f, 0.09478121f, 0.02532017f, -0.20034160f, 0.01376561f, 
    0.01865626f, -0.04952940f, -0.03720627f, -0.02302997f, -0.04662722f, -0.03002064f, -0.03058590f, -0.01087775f, 
    0.02863856f, -0.04583517f, 0.01865383f, 0.00957862f, 0.02722006f, 0.00631922f, -0.01969517f, -0.02973027f, 
    0.00659905f, 0.02920480f, -0.04817940f, -0.02508657f, 0.03130145f, 0.01861966f, 0.03539928f, -0.01706551f, 
    -0.02516307f, 0.00777172f, -0.04504280f, -0.00259070f, -0.01972931f, -0.03672189f, -0.03378045f, -0.04380793f, 
    -0.02934614f, -0.03079584f, -0.01759673f, -0.04005192f, 0.02190884f, 0.01070362f, -0.00566525f, -0.01103114f, 
    -0.03654237f, -0.02066867f, -0.05003110f, 0.02392993f, 0.00059636f, -0.01480155f, -0.02482900f, 0.00327381f, 
    -0.05064484f, 0.00371622f, -0.04307047f, -0.05161808f, 0.00642962f, 0.02099834f, -0.04221170f, 0.03387633f, 
    0.01915853f, -0.05434524f, 0.04352643f, -0.00440177f, 0.03709248f, -0.02064721f, 0.01648173f, -0.02599664f, 
    -0.01854840f, 0.02533374f, 0.03234335f, 0.03790884f, -0.04176662f, 0.02821399f, -0.03406564f, 0.02960354f, 
    -0.02912704f, -0.00027461f, -0.01924499f, -0.00803651f, 0.00493709f, -0.05622551f, -0.00667473f, -0.01465708f, 
    0.00567745f, 0.04094741f, -0.05176396f, 0.03161523f, -0.01391313f, 0.02163412f, -0.00805921f, 0.02154352f, 
    -0.05275114f, 0.01180881f, -0.02587398f, -0.01672046f, -0.04060277f, -0.01078309f, 0.04439856f, 0.00335669f, 
    -0.05476976f, 0.00190667f, 0.01461219f, 0.02827401f, 0.00158533f, 0.03886277f, -0.02853172f, 0.03811642f, 
    0.02396190f, -0.04516308f, -0.03011913f, -0.05335034f, 0.03550946f, -0.03685137f, -0.00231969f, 0.00167351f, 
    -0.05736114f, -0.05697579f, 0.00468715f, -0.01265396f, 0.00815431f, 0.01414844f, -0.01998330f, -0.03667860f, 
    -0.04573558f, -0.03817021f, 0.04401342f, 0.00106343f, -0.00673256f, -0.04161536f, -0.00185148f, -0.03174654f, 
    -0.01765407f, 0.03816707f, 0.01506297f, -0.03081159f, 0.03603575f, 0.00391997f, -0.05104367f, 0.00817926f, 
    -0.04802882f, 0.01718942f, -0.01656988f, -0.03096725f, -0.03329100f, -0.02874976f, 0.01250252f, -0.05640464f, 
    0.01210232f, 0.00976552f, 0.04242042f, -0.04595093f, -0.03136591f, -0.05089931f, -0.03917619f, 0.00798615f, 
    0.01864175f, 0.03583616f, 0.02281661f, 0.01281900f, 0.00866933f, -0.02826940f, 0.04257716f, -0.00559773f, 
    0.02126201f, -0.05641647f, -0.04537615f, 0.03405302f, -0.05423687f, 0.04230911f, 0.01372180f, 0.01826940f, 
    -0.00696445f, -0.03128764f, -0.05681599f, 0.02112680f, -0.01385936f, -0.03365183f, 0.03556499f, 0.02100681f, 
    -0.03996783f, 0.01529905f, 0.03951819f, -0.01307471f, -0.02965685f, -0.01476472f, -0.05212598f, -0.02793933f, 
    0.01518585f, -0.01846316f, -0.03534402f, 0.03436596f, 0.01925911f, 0.02056110f, 0.03101104f, 0.01538801f, 
    -0.00113302f, 0.02942008f, 0.00940306f, 0.00562172f, 0.03746859f, 0.02594230f, 0.00010293f, -0.02942596f, 
    0.03965390f, -0.03288710f, -0.02429061f, -0.01181980f, 0.03678464f, -0.05439614f, -0.04359052f, -0.01609859f, 
    -0.01977149f, 0.01935720f, -0.05175313f, -0.03914649f, 0.02319454f, -0.04407832f, -0.02744638f, 0.02237417f, 
    0.01135547f, -0.01618003f, 0.00868517f, -0.03456782f, -0.02198834f, 0.00830998f, 0.00329524f, 0.04008661f, 
    -0.05363909f, -0.04112510f, 0.01930978f, -0.00614366f, -0.01517719f, -0.01198496f, 0.02302244f, -0.04273834f, 
    -0.00135460f, -0.01806832f, -0.03581344f, -0.02818746f, -0.01899776f, -0.03919304f, -0.02666753f, -0.02762413f, 
    0.02638992f, -0.05417154f, 0.03055276f, -0.01862872f, 0.02979429f, -0.05432218f, -0.01049360f, -0.00682321f, 
    0.01537651f, 0.00557582f, 0.02881897f, -0.01395382f, -0.02754149f, -0.03810118f, -0.02889955f, -0.04499248f, 
    -0.02702467f, -0.05251624f, 0.03916487f, -0.00114426f, -0.04334124f, -0.05232548f, 0.03844893f, -0.05374937f, 
    0.03202183f, -0.00962460f, 0.01255881f, -0.04164763f, -0.04075766f, -0.01979952f, -0.05188980f, 0.00517069f, 
    -0.02696729f, 0.03350845f, 0.02962920f, -0.00253856f, 0.01911052f, -0.04759979f, -0.01835172f, 0.03589628f, 
    -0.00142003f, 0.00646457f, -0.03806790f, -0.04953196f, -0.01318863f, -0.01751442f, 0.01547669f, 0.02121951f, 
    0.01149517f, 0.04330771f, -0.04725304f, -0.00180464f, -0.03366700f, 0.01062303f, -0.04698135f, -0.04815946f, 
    0.03801609f, 0.03405000f, -0.03106742f, -0.03199990f, -0.02510783f, 0.00108866f, -0.01967235f, -0.03036812f, 
    -0.02595461f, 0.00241108f, -0.04729942f, -0.02131153f, -0.02915914f, -0.02538598f, 0.02502978f, -0.05090332f, 
    -0.03144580f, -0.03628802f, -0.02870236f, 0.00346948f, -0.04913483f, 0.03704752f, -0.04881161f, -0.04202949f, 
    0.04208003f, 0.01609970f, 0.01271407f, 0.00915943f, 0.03153417f, 0.03721410f, 0.03205781f, -0.05700121f, 
    0.02613660f, -0.01995397f, -0.04933701f, 0.01762498f, 0.04018022f, -0.02285086f, 0.01280129f, -0.01191721f, 
    -0.05035866f, 0.03696418f, -0.01463120f, 0.01758571f, 0.00623661f, 0.00957099f, -0.00009280f, -0.01211391f, 
    0.04006342f, 0.04360345f, -0.01044456f, -0.05101849f, 0.02110400f, 0.00064329f, 0.02174794f, 0.02814036f, 
    0.04272303f, -0.05299028f, -0.01017412f, -0.00082352f, -0.00721389f, 0.01989362f, -0.03146940f, -0.01292086f, 
    -0.01796321f, -0.00016726f, 0.04294982f, -0.05249432f, -0.01496655f, 0.02214388f, -0.03321797f, 0.04338749f, 
    -0.02959447f, -0.00256670f, 0.04316749f, 0.02409983f, -0.00942730f, -0.05473142f, -0.00744111f, -0.03319195f, 
    0.03930708f, -0.03855887f, -0.05316004f, -0.05187829f, 0.00407836f, -0.00429446f, -0.01432787f, -0.03292556f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06029711f, -0.03192121f, -0.06227448f, -0.00783661f, 0.02999477f, -0.01520044f, 0.03430175f, 0.01844535f, 
    0.01511247f, -0.02082175f, -0.01270125f, -0.01876069f, -0.00296467f, 0.02222167f, 0.00926962f, 0.07434499f, 
    0.00174192f, 0.03558212f, 0.09882838f, 0.00123326f, 0.14068083f, 0.05939261f, -0.10046518f, 0.07686608f, 
    0.00016442f, 0.10377113f, 0.00331764f, 0.03307546f, -0.03251602f, 0.04009172f, -0.00751228f, 0.02981254f, 
    -0.03119044f, 0.06939273f, 0.04631533f, 0.08812153f, 0.02533598f, -0.03866912f, 0.01544752f, 0.02853032f, 
    0.04092311f, -0.01467138f, 0.03404655f, -0.02052156f, 0.12774894f, 0.04296022f, -0.02987817f, -0.00518898f, 
    0.00830992f, 0.03396359f, 0.07832476f, 0.03585558f, -0.02489572f, -0.00433348f, -0.02624302f, -0.02113363f, 
    -0.02113433f, 0.01903817f, -0.02469794f, -0.02798618f, -0.00305743f, 0.08839236f, -0.00591648f, -0.03885310f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.04915657f, 0.04622309f, -0.29638267f, -0.10618343f, 0.09331676f, 0.04488376f, 0.06443071f, 0.07616021f, 
    -0.12895392f, 0.20551580f, 0.04865799f, 0.02124605f, 0.10648943f, 0.01186578f, -0.24042268f, -0.49772844f, 
    -0.02379875f, -0.05224153f, -0.26546586f, -0.09492398f, -0.25428680f, 0.05627334f, 0.12700221f, -0.34513530f, 
    0.07961860f, -0.08152309f, 0.07801736f, 0.53141832f, -0.07006203f, 0.00576327f, -0.05234157f, 0.00555403f, 
    0.15473551f, -0.29372048f, 0.03089043f, -0.16403192f, -0.05392759f, 0.15403497f, -0.28289720f, 0.26041749f, 
    0.06069887f, -0.08153281f, -0.29714790f, -0.06898376f, -0.11944781f, 0.37309283f, 0.06431708f, 0.01927311f, 
    0.08462141f, -0.05291566f, 0.15273583f, 0.10214402f, -0.24156430f, -0.01384563f, 0.09267150f, -0.04972431f, 
    0.10522525f, 0.12865126f, 0.03880510f, -0.13194805f, 0.15700808f, -0.45422921f, 0.18832995f, 0.01061536f, 
    0.22243683f, 0.03752892f, 0.05040119f, 0.05000448f, -0.11042839f, -0.08641800f, 0.04210971f, 0.04174417f, 
    0.11565059f, -0.04269652f, -0.12727553f, -0.19261523f, 0.08546846f, -0.04694627f, 0.14785309f, -0.45500940f, 
    -0.23164372f, 0.14987770f, 0.08550312f, 0.03581211f, 0.11220689f, 0.32133791f, -0.16182487f, 0.15561599f, 
    -0.16891304f, 0.10345873f, -0.09762146f, -0.21062331f, -0.02930618f, 0.05166964f, -0.06155039f, -0.10653733f, 
    0.03801483f, 0.11930673f, 0.02937655f, 0.07901779f, -0.08370218f, -0.61689621f, 0.22849292f, 0.16494465f, 
    0.11599457f, -0.06685530f, -0.14194752f, 0.00755853f, -0.28264391f, 0.08619948f, -0.08364583f, 0.09695652f, 
    -0.09907159f, 0.04999747f, 0.35480550f, -0.12245422f, -0.21900646f, 0.10468882f, -0.35559565f, 0.03055718f, 
    -0.10381616f, 0.10396764f, -0.08051237f, 0.10456239f, -0.37391484f, -0.32591954f, -0.13193110f, 0.07202275f, 
    0.00846278f, 0.11943855f, -0.35083106f, 0.03079379f, 0.00240684f, 0.11295252f, -0.07056706f, 0.02324294f, 
    -0.00423753f, -0.07970818f, 0.03093532f, 0.33720732f, 0.09276550f, -0.08583149f, 0.22563520f, -0.19433919f, 
    -0.02143431f, -0.00268798f, -0.29523245f, -0.10097294f, -0.37561348f, -0.00532662f, -0.00151464f, 0.35395548f, 
    -0.34356001f, -0.26159042f, -0.03661649f, 0.02949493f, -0.04111466f, -0.00105494f, -0.12841830f, 0.08256566f, 
    0.12446989f, 0.30680129f, 0.01853696f, 0.27923387f, 0.08740233f, 0.37044474f, -0.30081341f, 0.07294209f, 
    0.09939023f, 0.04266195f, -0.50290155f, -0.09210732f, 0.19754811f, -0.01024390f, -0.04386661f, 0.12460994f, 
    -0.04988342f, 0.05885531f, -0.48737943f, 0.10322294f, -0.01681730f, -0.05632733f, -0.23187336f, 0.04778954f, 
    -0.05869060f, -0.10556719f, 0.10356098f, -0.09759318f, -0.42685342f, -0.07921231f, -0.25376824f, 0.00991889f, 
    0.18785955f, -0.01468998f, -0.27641392f, 0.00262901f, 0.02409346f, -0.01697363f, -0.03330284f, -0.07389791f, 
    -0.25695121f, -0.66194993f, -0.02015746f, -0.33153832f, -0.12078588f, -0.11122246f, -0.18225291f, 0.00966792f, 
    0.08901873f, 0.32661396f, -0.48485181f, 0.00212944f, -0.08658934f, -0.46962065f, 0.18696779f, 0.29202840f, 
    0.12393335f, 0.15899543f, -0.06836602f, -0.50780779f, 0.01701237f, -0.03563098f, -0.00276063f, -0.12307645f, 
    -0.40318558f, -0.10112797f, 0.04652540f, -0.07163151f, 0.02640926f, 0.09321430f, 0.03122629f, 0.06020692f, 
    0.03574756f, 0.05230357f, -0.26434040f, 0.08161287f, 0.03277944f, 0.11049604f, 0.04426641f, -0.11871883f, 
    0.06267433f, -0.11609032f, 0.24494210f, -0.10943515f, 0.01323823f, -0.07147425f, 0.38964227f, -0.10078404f, 
    0.04579901f, 0.10651210f, 0.02911106f, 0.02453519f, 0.10650855f, 0.13748570f, 0.22280517f, 0.07971700f, 
    -0.28198218f, 0.00981734f, 0.31782705f, 0.00384334f, 0.11078415f, -0.08225772f, -0.04682417f, 0.01680098f, 
    -0.22364369f, -0.06249734f, -0.08957446f, -0.11137217f, 0.04068146f, -0.00790792f, 0.33876529f, -0.12627009f, 
    0.15323955f, 0.12878856f, 0.04907754f, 0.11630163f, 0.11010224f, -0.21622218f, 0.15518321f, -0.31851175f, 
    0.16549698f, -0.06071585f, 0.08244241f, -0.19125763f, 0.07749759f, 0.07270170f, -0.06417871f, -0.07283033f, 
    0.01261286f, 0.03272019f, -0.03513693f, -0.25992301f, 0.06521074f, 0.37806153f, -0.06875762f, -0.08567370f, 
    -0.04051933f, 0.11595689f, 0.07896674f, 0.05977435f, 0.03547057f, 0.34958661f, 0.02756367f, 0.04413381f, 
    -0.03014037f, -0.12021475f, -0.20207690f, -0.09856585f, 0.08357212f, 0.08977259f, 0.30966026f, 0.06574100f, 
    0.10415571f, -0.05206532f, -0.03267032f, -0.11626459f, -0.19556916f, 0.00496373f, -0.20979901f, 0.05276548f, 
    0.16002741f, 0.09103923f, 0.02374370f, -0.09039207f, 0.00802084f, -0.12475047f, 0.06738049f, -0.06905933f, 
    0.16528270f, 0.15752566f, 0.02167937f, 0.12543824f, 0.08231217f, -0.04624633f, 0.02527308f, 0.28822336f, 
    -0.18584149f, 0.03082418f, 0.34339273f, -0.11775021f, 0.11767747f, 0.00408376f, -0.12293516f, -0.36167464f, 
    0.01657246f, -0.55585057f, 0.10997614f, -0.29950935f, 0.01122426f, -0.02912628f, -0.11994459f, -0.02172210f, 
    0.02837130f, -0.44929022f, -0.07163455f, -0.31190950f, -0.05286939f, -0.63274211f, -0.40013057f, -0.32935500f, 
    -0.09702922f, -0.03008844f, 0.17891672f, -0.09704929f, -0.42310849f, 0.11373044f, 0.08671389f, -0.08858874f, 
    -0.02983121f, -0.10982908f, 0.22937365f, -0.01674381f, 0.03145097f, 0.07676663f, -0.05217107f, -0.04895145f, 
    0.10460858f, -0.00609764f, -0.08948824f, 0.08373458f, 0.13019110f, 0.03224850f, 0.22877842f, 0.02514079f, 
    0.02426312f, -0.12357230f, -0.34277430f, 0.09789807f, 0.10329080f, -0.03438756f, -0.04901706f, -0.12086158f, 
    -0.15770297f, 0.03050098f, 0.09554016f, -0.34725887f, -0.09249194f, 0.10210428f, 0.09919447f, 0.27304798f, 
    -0.06191968f, 0.09632541f, 0.08372054f, 0.03298084f, 0.28308222f, -0.33869031f, -0.28295091f, -0.04309451f, 
    0.16334899f, 0.27574742f, -0.08144290f, 0.27882561f, 0.11848571f, 0.12083952f, -0.03759497f, 0.00027878f, 
    0.15188061f, -0.13261272f, -0.04040502f, 0.34540403f, 0.10363502f, 0.26000229f, -0.04811820f, -0.21566904f, 
    -0.03819489f, -0.07977113f, -0.28501001f, 0.02447621f, -0.12269777f, -0.75687236f, -0.04142256f, -0.11656729f, 
    -0.05443415f, 0.07157053f, -0.24063790f, -0.04873551f, 0.02524029f, 0.10385940f, -0.48370224f, -0.05446884f, 
    -0.05347474f, -0.06854718f, 0.09203164f, 0.02408178f, 0.19394489f, -0.19302286f, -0.23500656f, 0.09203139f, 
    -0.20048541f, -0.02326219f, 0.29987377f, -0.08194634f, -0.05656885f, 0.10797036f, 0.07847880f, 0.00797831f, 
    -0.22826958f, -0.35268405f, 0.02508066f, 0.15454252f, -0.10492007f, 0.08383004f, -0.17205369f, 0.18093522f, 
    -0.02207449f, -0.31058201f, 0.04440535f, 0.03367689f, -0.32001573f, -0.07411043f, 0.10868213f, 0.18135002f, 
    0.11144116f, 0.15616325f, -0.07377542f, 0.11383787f, 0.07995246f, -0.05333113f, -0.06855649f, 0.01553179f, 
    -0.33324727f, -0.06888646f, -0.04956295f, -0.04426212f, -0.00963954f, 0.26125100f, 0.26401386f, -0.27210882f, 
    -0.03641070f, 0.09355782f, 0.32389694f, 0.04100560f, -0.41849750f, 0.17723890f, 0.00456659f, -0.04511739f, 
    -0.03936610f, -0.00491827f, -0.31891742f, 0.11395082f, 0.11651974f, 0.11306743f, 0.02897211f, 0.08244587f, 
    -0.01052033f, -0.10801547f, 0.10182071f, 0.06213200f, 0.15031770f, -0.38217193f, 0.14441164f, 0.01429758f, 
    -0.33206612f, -0.08360343f, 0.22998962f, 0.03662442f, 0.10241020f, 0.10883935f, 0.09606387f, 0.08059901f, 
    0.17892529f, 0.11835671f, 0.03397314f, 0.11516043f, 0.05777822f, -0.00805921f, -0.09988686f, 0.17650405f, 
    -0.26097775f, 0.26525319f, -0.32724687f, 0.12396931f, -0.26587662f, 0.14551565f, -0.03425717f, -0.34928811f, 
    -0.44133428f, -0.28794613f, 0.08477255f, -0.52710563f, -0.08152730f, 0.10886580f, -0.01668958f, -0.05437351f, 
    0.10170612f, 0.20608403f, -0.02291745f, -0.00007113f, -0.08623201f, 0.04236377f, 0.24332304f, -0.05257415f, 
    0.03010330f, -0.01964437f, -0.06101746f, -0.13549805f, -0.03445193f, -0.44038054f, 0.09162097f, -0.10708372f, 
    -0.04445278f, 0.01785284f, 0.26910669f, 0.08153541f, -0.40563700f, -0.03096339f, -0.17757910f, 0.10842422f, 
    -0.10041904f, 0.11016602f, -0.00446857f, 0.02440836f, -0.05042750f, -0.10180932f, 0.20761067f, 0.08898135f, 
    0.05968330f, 0.01623915f, 0.29394358f, -0.05708662f, 0.08213872f, -0.00179925f, 0.01733611f, -0.11289173f, 
    0.26056305f, 0.16544200f, -0.00858574f, 0.36733305f, 0.11262069f, 0.01583157f, -0.29669887f, -0.32055938f, 
    -0.24304721f, -0.43532962f, -0.03805398f, 0.06474980f, -0.00065050f, -0.26130855f, -0.58311141f, -0.20104997f, 
    0.26914555f, 0.25747025f, -0.07986745f, -0.23948719f, -0.03032823f, -0.07684749f, -0.05353506f, 0.08705724f, 
    -0.16273811f, 0.23984896f, -0.08911389f, -0.06547016f, -0.03061937f, -0.09016010f, -0.28815737f, 0.17029323f, 
    0.09838350f, -0.09222300f, 0.18890746f, -0.00549250f, -0.31952220f, -0.26348805f, -0.07608745f, -0.06210569f, 
    -0.07836902f, -0.12038341f, -0.59875107f, -0.04216966f, 0.24847753f, 0.07918966f, -0.20224321f, -0.01552747f, 
    0.08679875f, 0.06406443f, -0.09058917f, 0.05721798f, 0.15325554f, 0.36854887f, -0.42885336f, -0.01571554f, 
    -0.03677510f, 0.02978320f, -0.29265875f, -0.07102711f, 0.05170768f, -0.04752053f, 0.04191150f, 0.08786718f, 
    -0.30045137f, -0.43154657f, 0.10941192f, 0.20345825f, -0.05318409f, -0.12979710f, -0.35155240f, 0.14243649f, 
    0.09471557f, -0.38966444f, 0.10327950f, 0.00370698f, 0.30389160f, 0.17808919f, -0.31771100f, 0.00808573f, 
    -0.14823695f, 0.07551324f, -0.07141792f, 0.24658202f, -0.05449796f, 0.03824542f, -0.12291510f, -0.11172222f, 
    -0.18706134f, 0.01228993f, -0.12700203f, 0.15146217f, -0.12967207f, -0.35406223f, -0.00963926f, -0.00911607f, 
    0.10058849f, -0.00888357f, 0.37403426f, 0.10448639f, 0.38104162f, -0.16071022f, -0.13752945f, 0.10099850f, 
    -0.00026000f, -0.01506840f, 0.24877627f, 0.08213494f, -0.36274713f, 0.08177799f, 0.06272847f, -0.10904945f, 
    -0.04005511f, 0.11304410f, 0.10047680f, -0.11121221f, -0.21819048f, 0.31528378f, 0.22841157f, -0.00336832f, 
    -0.02283981f, 0.06188259f, -0.01535114f, 0.08581004f, -0.06015492f, -0.12093420f, 0.03993536f, 0.06500694f, 
    0.08185807f, 0.17065986f, 0.02997834f, -0.48519766f, 0.07585624f, 0.00948812f, -0.01903324f, -0.05800638f, 
    0.40187573f, -0.09939799f, -0.04097416f, -0.04060891f, -0.17680153f, 0.28212041f, 0.29242536f, 0.03413382f, 
    -0.04169762f, 0.15776241f, -0.01120969f, 0.00352815f, -0.08114638f, 0.02335445f, 0.01588258f, 0.10824872f, 
    -0.22533159f, 0.09368877f, -0.06686086f, -0.28580147f, 0.00639520f, -0.32060936f, -0.14017923f, -0.31906343f, 
    0.02477057f, 0.10063707f, -0.41435388f, -0.13091163f, 0.20802060f, -0.35747311f, -0.03190659f, 0.09584348f, 
    -0.05319084f, 0.08387163f, 0.01233130f, -0.00445800f, 0.04751157f, -0.06678841f, -0.46772400f, 0.02191599f, 
    0.03803943f, 0.09903778f, 0.06021039f, 0.02489903f, 0.31451711f, 0.20941621f, 0.08967891f, -0.03183413f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13481021f, 0.13612303f, 0.02454467f, -0.06716394f, -0.14220001f, 0.06765523f, 0.06662212f, -0.02959337f, 
    0.01752253f, 0.10290227f, 0.06828703f, 0.04505244f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
