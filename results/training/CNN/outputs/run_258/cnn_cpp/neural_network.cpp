#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.11212149f, 0.37572858f, -0.70468265f, 0.34880301f, -0.69102722f, -0.17004943f, 0.38743806f, -0.35049540f, 
    0.80732471f, -0.13031743f, -0.59904677f, -0.70151913f, -0.94849807f, -0.28558499f, -0.55734515f, 0.34404832f, 
    0.53994328f, 0.05812491f, 0.50613964f, -0.37933537f, 0.43617794f, 0.36011702f, -0.99812436f, -0.11088243f, 
    -0.18781762f, 0.38107786f, 0.20977850f, -0.70442623f, -0.44665089f, -0.30002037f, 0.38372734f, 0.61072928f, 
    0.20536113f, 0.09109099f, -0.06021123f, -0.51568103f, 0.35180509f, 0.38551748f, 0.24105249f, -0.09508903f, 
    -0.97140431f, -0.82800800f, 0.54100180f, 0.65697676f, -0.33280426f, 0.72348505f, -0.04253909f, 1.06286228f, 
    0.69583493f, -0.12494695f, -0.12293171f, 0.13138717f, -0.40087163f, 0.06366170f, 0.74402994f, -0.34557593f, 
    -0.52757376f, -0.13580970f, 0.04303828f, 0.67078710f, -0.01219407f, 0.17630970f, 0.75860542f, 0.99569815f, 
    -0.93367016f, -0.33494571f, 0.79498518f, -0.65271109f, 0.17419311f, 0.04192247f, 0.10662911f, -0.18595386f, 
    0.22730185f, 0.06851673f, -0.69979239f, -0.16985562f, -0.47728905f, -0.42322505f, -0.58718723f, -0.42481560f, 
    0.45520917f, 0.42669716f, 0.58327252f, 0.77535999f, 0.17058642f, -0.62521178f, 0.69444472f, -0.41792881f, 
    -0.28791034f, 0.18352661f, -0.18003933f, -0.78088355f, -0.55202049f, 0.28533056f, 0.80602098f, -0.25414219f, 
    -0.19611493f, 0.14195478f, -0.27133563f, -0.45438427f, -0.02951296f, -0.76514602f, -0.19135582f, -0.73946398f, 
    0.27737850f, -0.58554578f, 0.40232307f, -0.10894471f, 0.56071830f, 0.09963895f, -0.51777560f, -0.29868636f, 
    0.48274773f, -0.64967477f, 0.57792604f, 0.58376932f, 0.25630322f, -0.66147816f, 0.89184386f, -0.54269761f, 
    -0.48165190f, -0.01260437f, -0.77914852f, 0.02945364f, -0.36196899f, 0.20819032f, 1.05054617f, -0.86824870f, 
    -0.25638330f, 0.64798045f, 0.29473132f, -0.23898080f, -0.19111946f, -0.35378101f, -0.59734994f, 0.44090518f, 
    0.44054031f, -0.02442896f, -0.66550833f, 0.28840247f, 0.81002903f, -0.21032561f, -0.44033369f, -0.75475472f, 
    0.09708408f, -0.51206243f, 0.58089447f, -1.02258420f, 0.61099958f, -0.17246561f, 0.27928677f, 0.42799774f, 
    -0.26170865f, 0.97215837f, 0.89440918f, -0.37828001f, 0.83512777f, 0.65190071f, 0.04485478f, 0.29248387f, 
    -0.31014889f, -0.03117433f, -0.72787404f, 0.02824896f, -0.41037157f, 0.43701819f, 0.70244396f, 0.04997400f, 
    -0.36660174f, -0.60105598f, -0.12343398f, 0.12631382f, -0.15346731f, -0.19611713f, -1.05871153f, 0.38653222f, 
    0.62183225f, 0.10175645f, -0.11273019f, 0.50031728f, -0.51484114f, 0.12968262f, -0.39415619f, 0.71493059f, 
    1.04251993f, -0.80859786f, 0.47702947f, 0.17097716f, 0.19706655f, -0.88128531f, 0.44106486f, -0.47825533f, 
    0.55475777f, -0.40948871f, -0.76978594f, -0.20956980f, 0.39448220f, -0.47206840f, -0.30527875f, -0.46803564f, 
    -0.55820072f, 0.69083595f, -0.01213965f, 0.70908266f, 0.01048719f, -0.49550125f, 0.05823601f, -0.78654343f, 
    0.56522006f, 0.56176949f, -0.24361208f, -0.68103039f, -0.04444697f, 0.18084604f, -0.02618216f, 0.39243627f, 
    0.97521490f, 0.78701228f, 0.31970802f, -0.77306420f, -0.53238451f, 0.07291637f, 0.17003605f, -0.05701685f, 
    0.31135926f, -0.79026639f, -0.91236669f, -0.95061529f, 0.23435348f, -0.31013134f, 0.08253755f, 0.15335852f, 
    0.11384414f, -0.02082637f, 0.84164947f, 0.81496292f, 0.72170895f, -0.16444194f, 0.09555279f, 0.08080508f, 
    0.03281115f, 0.38589597f, -0.12149823f, -0.57577169f, 0.68245625f, -0.38756973f, -0.12497814f, 0.55701768f, 
    0.76227230f, -0.17584775f, 0.59744847f, -0.38182324f, 0.72371829f, -0.43347025f, 0.56149501f, 0.72596967f, 
    0.30207860f, 0.72582519f, 0.34996527f, 0.29252896f, -0.94234186f, -1.04934692f, -0.61374533f, 0.04683995f, 
    0.39826262f, -0.57787335f, 0.08862424f, 0.35131168f, 0.33739868f, 0.43251479f, -0.97307312f, -0.09978873f, 
    -0.93312073f, 0.01016582f, 0.72855258f, 0.69988239f, 0.42434251f, -0.09562330f, 0.48728362f, 0.59074771f, 
    0.62024832f, 0.67541474f, 0.76451355f, 0.48085868f, 0.34250757f, 0.18084945f, 0.67167401f, 0.23219797f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.32286718f, 0.09412481f, 0.11590336f, -0.19252346f, 0.07314564f, 0.14241338f, 0.08829781f, -0.10680791f, 
    0.31984818f, 0.03649761f, 0.08322978f, -0.14667606f, 0.20156372f, 0.06921218f, -0.00758705f, 0.12317035f, 
    -0.33749342f, -0.02159862f, 0.23344502f, -0.14356333f, -0.03891679f, -0.03664525f, -0.08419569f, -0.10695241f, 
    -0.04876113f, -0.20108391f, 0.09907235f, -0.25371259f, -0.13339862f, 0.21293393f, 0.07710885f, 0.10545385f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.06370758f, -0.14072324f, 0.08408748f, 0.07269502f, -0.09796631f, -0.08490207f, 0.02398483f, -0.11959139f, 
    0.02920043f, -0.11430738f, -0.11263089f, -0.23332217f, 0.29306707f, 0.13993815f, -0.00050122f, 0.07058565f, 
    -0.17694765f, 0.13284332f, 0.09006505f, 0.21988457f, -0.16419661f, -0.01147266f, 0.05804488f, -0.04010755f, 
    0.12777251f, -0.08089652f, 0.16317855f, 0.07298893f, -0.20044769f, -0.14298595f, -0.31463015f, -0.13163468f, 
    -0.02461607f, -0.02600126f, -0.01082572f, 0.06704493f, 0.03529560f, 0.21008149f, -0.03059170f, 0.04871602f, 
    0.01035298f, -0.02328746f, 0.11133478f, 0.09491888f, 0.00391243f, 0.26290733f, 0.09673105f, -0.04267709f, 
    0.04466270f, -0.05572781f, 0.06444968f, 0.17358015f, 0.05892724f, -0.10743123f, 0.23833849f, -0.25213787f, 
    0.24919270f, 0.02648320f, -0.00592233f, 0.14597321f, -0.01649840f, -0.05951259f, -0.05655994f, 0.33308753f, 
    -0.00963874f, 0.21051404f, -0.03442922f, -0.08892454f, 0.01413380f, -0.05199039f, -0.01165099f, -0.15458068f, 
    -0.00733462f, -0.09208914f, 0.09390136f, 0.03810449f, 0.04966695f, 0.01278168f, 0.10920469f, -0.06088956f, 
    0.24686712f, 0.18248685f, 0.24025990f, 0.11413806f, -0.17236772f, -0.01306589f, 0.07929989f, 0.12436993f, 
    -0.15088409f, 0.08587375f, 0.20828423f, -0.01487403f, 0.08980149f, 0.01268009f, -0.06824686f, -0.00392344f, 
    0.05444486f, 0.16754478f, 0.34732372f, -0.19643590f, -0.15768825f, 0.19250070f, -0.21966827f, -0.02901515f, 
    0.05746216f, 0.17571099f, 0.05556968f, 0.33487380f, 0.24257351f, -0.00014151f, -0.10853662f, -0.02587547f, 
    0.06687830f, 0.01981368f, -0.08639153f, -0.22093999f, 0.02606245f, -0.03736179f, -0.18803519f, 0.05237302f, 
    0.17707148f, 0.03029298f, 0.02003628f, 0.02323561f, 0.07982957f, 0.30072609f, 0.47572559f, -0.35577455f, 
    -0.16739328f, 0.02796509f, 0.09354890f, -0.00774872f, -0.10945620f, 0.23756851f, 0.03943203f, 0.10561296f, 
    0.00651762f, 0.17337485f, -0.08117817f, 0.02616514f, 0.04727581f, 0.16788393f, 0.07691801f, 0.16120891f, 
    -0.13833095f, -0.06296171f, 0.21038553f, 0.01096053f, -0.03072770f, 0.13523185f, 0.00322729f, 0.05138602f, 
    0.07006713f, 0.25263524f, -0.09389399f, 0.12521099f, -0.13965456f, 0.04214089f, 0.08353418f, -0.02065566f, 
    -0.00057108f, -0.06365678f, 0.00921993f, -0.14429061f, 0.00027467f, -0.15099528f, -0.12675995f, 0.08564211f, 
    0.11375158f, 0.10379273f, 0.13475159f, 0.07946735f, -0.05287501f, -0.02037995f, 0.01631660f, 0.00872099f, 
    0.05897777f, -0.07927062f, -0.10112187f, -0.12995046f, 0.45258969f, -0.19989935f, 0.12699322f, 0.02564295f, 
    -0.08964523f, -0.11520783f, -0.22099616f, 0.03973445f, -0.03796308f, 0.10630306f, -0.05747678f, 0.01631681f, 
    -0.00621677f, 0.06297448f, 0.08723134f, 0.04962686f, 0.24384162f, -0.07143648f, -0.12361818f, 0.00525085f, 
    -0.06661245f, -0.03364678f, -0.05391224f, 0.14022407f, 0.09372812f, -0.04618827f, 0.15539071f, 0.06616250f, 
    0.03261741f, -0.18124230f, 0.09572736f, -0.00524315f, -0.12491065f, 0.04053209f, -0.08134017f, 0.04166976f, 
    0.34807298f, 0.23956284f, -0.00087766f, -0.10795186f, -0.10620487f, -0.13974968f, 0.03059985f, 0.10340940f, 
    0.06001167f, 0.01102740f, -0.08012924f, 0.02575091f, -0.20610464f, -0.13608959f, -0.20639260f, -0.00809111f, 
    -0.23401566f, 0.01204486f, 0.32843307f, 0.34027478f, -0.02183688f, -0.05025525f, -0.07257172f, -0.03488277f, 
    0.06068501f, -0.02595966f, 0.08746747f, -0.05436167f, -0.03318486f, 0.04061601f, -0.29752040f, 0.27052239f, 
    -0.00217814f, 0.03467774f, -0.12953481f, -0.12292273f, 0.35814241f, -0.17466211f, -0.11574809f, -0.12467203f, 
    0.14316711f, 0.03334912f, -0.12316217f, -0.05512915f, -0.36933571f, 0.09676635f, -0.01318442f, -0.05879579f, 
    0.08623872f, 0.04849213f, -0.28046972f, -0.02802324f, -0.18462545f, -0.07667275f, 0.40983668f, 0.00455215f, 
    0.01610180f, -0.06170059f, -0.21980436f, 0.12803300f, -0.07541513f, -0.13370855f, -0.15131405f, 0.07229788f, 
    0.13527566f, -0.13244082f, 0.07518029f, 0.01741657f, -0.03244348f, -0.05276548f, -0.14448716f, -0.13195714f, 
    -0.03561937f, -0.18255675f, 0.06941779f, 0.21038741f, -0.03533049f, 0.13412976f, -0.02050773f, -0.18382958f, 
    0.04434678f, 0.22260584f, 0.03096887f, -0.16022512f, 0.16492948f, -0.18372327f, 0.06924152f, -0.01163462f, 
    -0.03035316f, -0.07635836f, -0.10891744f, -0.22892888f, 0.12506190f, 0.08759051f, 0.12440974f, 0.09065559f, 
    -0.01859040f, -0.09198555f, 0.10728145f, 0.21862830f, 0.06568284f, 0.06305430f, 0.05043752f, -0.02944387f, 
    -0.07630646f, -0.07426149f, 0.04313820f, -0.03573555f, 0.17865004f, -0.11999399f, -0.02302682f, -0.01863085f, 
    -0.03221092f, 0.00951489f, 0.19914021f, -0.07388854f, 0.00710119f, -0.55695242f, -0.07004031f, 0.07521886f, 
    0.18496726f, 0.05690828f, 0.04086525f, -0.03086878f, -0.06689411f, 0.21307471f, -0.13471910f, -0.05435764f, 
    -0.04180774f, 0.01683092f, 0.10872814f, -0.01264223f, 0.18138263f, 0.00473626f, -0.03681505f, -0.39695787f, 
    -0.03768675f, 0.00120056f, 0.07692992f, 0.04904753f, 0.00732036f, -0.12540178f, -0.12283307f, -0.05695704f, 
    0.14009643f, 0.05068127f, 0.16373038f, 0.11572243f, 0.08200769f, 0.10703642f, -0.12130257f, -0.01054741f, 
    0.00636134f, -0.22978479f, -0.25252807f, -0.04838327f, 0.21215361f, 0.05402697f, 0.05480666f, -0.34045023f, 
    0.20425802f, 0.13926052f, 0.26816142f, 0.00675833f, -0.14527915f, -0.16137461f, -0.11231641f, 0.09341424f, 
    0.17370275f, 0.19685733f, 0.04136923f, 0.31257346f, 0.12215766f, -0.09307906f, -0.07231868f, -0.03815999f, 
    0.14000323f, 0.03763605f, 0.20977287f, 0.12728475f, -0.09109291f, 0.01517574f, 0.08422093f, 0.12192824f, 
    -0.07942233f, -0.03464691f, 0.06509389f, 0.02561605f, 0.02392458f, 0.00059347f, -0.12240243f, 0.17021672f, 
    0.21045755f, 0.00867792f, -0.03740110f, 0.06705462f, -0.27017987f, -0.04061531f, -0.25519496f, 0.04543341f, 
    -0.08564360f, 0.00015367f, 0.17795776f, -0.04988564f, 0.03031847f, -0.04524472f, 0.09914068f, 0.09735505f, 
    -0.27155957f, 0.05323426f, 0.04390506f, 0.11550888f, -0.15972486f, 0.00355104f, 0.03067691f, 0.02192224f, 
    -0.07071416f, 0.12176949f, -0.14954703f, 0.22797588f, -0.24615335f, -0.02485683f, 0.06911027f, 0.01314932f, 
    -0.11712316f, -0.43997622f, -0.26525787f, -0.12581097f, 0.18081850f, 0.18641065f, -0.18104565f, -0.10514757f, 
    -0.05391259f, 0.03470244f, 0.03803820f, 0.01155608f, 0.03735583f, 0.13294487f, 0.19944556f, 0.10770674f, 
    -0.13169026f, 0.03996361f, -0.09418010f, -0.05483240f, 0.04520822f, -0.04865886f, 0.05871698f, -0.03372955f, 
    -0.06981175f, -0.00332072f, 0.13289225f, 0.02070570f, -0.00751277f, 0.03266036f, -0.10140268f, -0.05359098f, 
    -0.07601338f, 0.07843418f, 0.16038439f, 0.21183489f, -0.21766935f, 0.07919872f, -0.03779184f, 0.01426324f, 
    -0.01346517f, -0.18562527f, -0.02089755f, 0.10707499f, 0.14582570f, -0.03155310f, 0.08302950f, -0.05475082f, 
    0.18560588f, -0.05663877f, 0.10908800f, 0.09787159f, 0.03523766f, 0.00006456f, -0.02737927f, -0.04281575f, 
    0.03606821f, -0.05246963f, -0.36171818f, -0.00630035f, 0.02982924f, -0.02673659f, 0.03997750f, 0.02153734f, 
    -0.11214358f, 0.04409345f, -0.03780116f, -0.03470370f, 0.04393941f, 0.09548306f, 0.07792430f, 0.09154539f, 
    0.04929905f, 0.24777298f, 0.30021393f, 0.03593152f, -0.08101273f, -0.13627991f, 0.12500924f, -0.02737113f, 
    0.17199537f, -0.00859395f, -0.33914953f, -0.22632100f, -0.08805651f, 0.18585713f, 0.08547679f, 0.03894506f, 
    0.14667962f, -0.07244676f, 0.05720152f, -0.08104664f, 0.07359748f, 0.06714143f, 0.04172792f, 0.06920015f, 
    -0.16239507f, -0.02569243f, 0.05083793f, 0.09929902f, -0.38220400f, 0.02725535f, 0.04272785f, 0.26722917f, 
    0.11298735f, 0.11557655f, 0.15113857f, 0.00032798f, 0.03159454f, 0.21976823f, 0.15299131f, 0.03825098f, 
    -0.03417010f, -0.04231961f, 0.24808691f, -0.06475385f, 0.01689105f, -0.03257887f, 0.25341326f, 0.16534697f, 
    -0.07410035f, -0.05084225f, -0.04082518f, -0.07879011f, 0.09173620f, -0.07028843f, -0.08753563f, -0.32085690f, 
    -0.05564355f, 0.01938704f, 0.23845616f, 0.01806029f, -0.06376613f, 0.17491835f, -0.12278602f, 0.19311644f, 
    0.09100709f, 0.10876204f, 0.15360463f, -0.15886636f, -0.10629355f, -0.14768960f, -0.20290641f, 0.15097637f, 
    0.08486722f, 0.19755167f, -0.15414551f, -0.00823483f, 0.10301185f, 0.08060141f, -0.00009728f, -0.00618001f, 
    0.06731462f, -0.01157058f, 0.02480835f, -0.03428248f, 0.02091985f, 0.00436751f, -0.11333801f, -0.11909483f, 
    0.11106272f, 0.05648512f, -0.06713112f, 0.16522883f, -0.15466626f, 0.26800722f, -0.20927255f, -0.22435729f, 
    -0.03644373f, -0.03838456f, 0.13834028f, -0.00391786f, 0.24640067f, -0.10821835f, 0.35084358f, 0.08064575f, 
    -0.01219367f, -0.13642856f, -0.12577361f, 0.13334660f, -0.12283510f, -0.03974210f, 0.10883916f, -0.20767024f, 
    0.17177320f, 0.03144623f, 0.21837464f, -0.11408202f, 0.13391736f, -0.13462934f, 0.27344701f, 0.01181983f, 
    0.02133768f, -0.18564060f, 0.07119227f, 0.08387113f, 0.00917483f, 0.10435174f, 0.09761406f, 0.06610750f, 
    -0.08536012f, 0.00495354f, -0.03041377f, -0.06766194f, -0.17875539f, 0.05517409f, -0.11729933f, -0.05885603f, 
    -0.12802488f, -0.06018149f, 0.07496835f, 0.18628529f, -0.03801329f, -0.04611154f, 0.09464892f, 0.01675619f, 
    -0.02102234f, -0.13894685f, 0.10292196f, -0.09748418f, 0.20500138f, -0.03131737f, 0.21661593f, -0.10007797f, 
    0.15953384f, -0.00622245f, -0.12149265f, -0.00762716f, 0.37697780f, -0.05752704f, -0.17641172f, 0.06368854f, 
    0.10034336f, 0.07285941f, -0.10148934f, -0.21428370f, -0.16679938f, -0.03099099f, 0.03357385f, 0.07524671f, 
    0.12666066f, -0.01773924f, 0.03704124f, -0.08783570f, 0.16773932f, -0.02669149f, 0.14114563f, 0.06211422f, 
    -0.14874843f, 0.04110455f, 0.07824763f, -0.10060257f, 0.02478727f, 0.10145121f, -0.07898194f, -0.02204184f, 
    0.11890312f, -0.08473573f, -0.08749384f, 0.24582571f, 0.14923026f, -0.02819778f, 0.07588663f, 0.31529421f, 
    0.21343331f, -0.07661858f, -0.01508412f, -0.07167646f, -0.05593880f, -0.06205978f, -0.06642692f, -0.32145008f, 
    -0.08192340f, -0.13112570f, 0.03014658f, 0.11565365f, 0.11891107f, -0.06450025f, 0.17262834f, 0.10545672f, 
    0.28868273f, 0.11184647f, -0.18806714f, -0.09804096f, 0.11358491f, -0.00200644f, -0.03212449f, 0.05531977f, 
    -0.20245998f, 0.05798664f, 0.01530063f, 0.04055440f, 0.12962836f, -0.12585309f, 0.12763529f, -0.00679557f, 
    -0.02599458f, -0.21433863f, 0.05564125f, 0.10126440f, 0.14571765f, -0.07150365f, -0.00580930f, 0.05244549f, 
    -0.04655983f, -0.10240869f, 0.22358555f, -0.02927423f, -0.13661179f, -0.16039468f, -0.08675463f, -0.01656718f, 
    -0.09764816f, 0.11829848f, 0.02122146f, -0.01337787f, 0.16704687f, 0.05858717f, 0.00669662f, 0.06313612f, 
    -0.14898527f, 0.06228818f, 0.02404375f, 0.10233827f, 0.05758653f, -0.07321567f, -0.32888758f, 0.04927610f, 
    -0.17580391f, -0.24094573f, 0.10376209f, -0.06513128f, 0.20519301f, -0.05259310f, -0.03864778f, 0.03134582f, 
    0.33834833f, -0.06740864f, 0.26665550f, 0.01231512f, -0.10484299f, -0.23385201f, 0.01498111f, 0.24276152f, 
    0.21648385f, -0.09797318f, -0.16300052f, -0.03308758f, -0.05999956f, -0.03189677f, -0.17637210f, 0.01712192f, 
    -0.18806648f, 0.37178019f, 0.17563942f, 0.05868315f, 0.15587951f, 0.05678698f, 0.05740257f, 0.07987896f, 
    0.02968045f, -0.08227251f, -0.25638112f, 0.29053178f, -0.09243575f, -0.16413736f, -0.08957888f, -0.03835687f, 
    -0.09306537f, -0.12918456f, -0.25176856f, 0.15673481f, 0.08049431f, 0.22298893f, -0.02527016f, 0.13364200f, 
    0.05201760f, -0.00111543f, 0.00108334f, 0.19702537f, 0.01489483f, 0.30792448f, -0.42370355f, -0.04284301f, 
    0.19489644f, -0.16689430f, 0.09396646f, -0.08134768f, 0.07726968f, 0.09539566f, -0.04673553f, 0.17268834f, 
    -0.10077927f, 0.16939884f, 0.02867503f, -0.17566650f, -0.07547633f, 0.03517925f, -0.14798544f, -0.04819366f, 
    -0.19209583f, 0.00622717f, -0.18909298f, 0.04172035f, -0.10287267f, 0.06117491f, -0.08082842f, -0.02812815f, 
    0.24594679f, -0.20850112f, -0.03013493f, 0.05317060f, -0.00144135f, 0.03271521f, 0.08701938f, -0.23999308f, 
    -0.16822422f, -0.07691872f, 0.10432077f, -0.09491102f, 0.23973687f, -0.00763128f, -0.05763688f, -0.13088092f, 
    -0.03875227f, 0.09180513f, -0.02671633f, 0.08274875f, 0.17610025f, 0.11204793f, -0.05263060f, 0.12428405f, 
    -0.03440560f, 0.13068263f, 0.04129680f, 0.16428162f, 0.09996432f, 0.29861856f, -0.03259032f, -0.09299865f, 
    0.00655923f, 0.14372209f, 0.13786890f, 0.03095153f, -0.12545906f, -0.06647435f, -0.06585589f, -0.11373168f, 
    0.07443117f, 0.01485854f, -0.04412260f, -0.35105982f, -0.12132668f, 0.23299478f, 0.12233398f, 0.08428212f, 
    0.12285388f, -0.08397729f, 0.02943926f, 0.11652822f, -0.25805050f, -0.01463593f, -0.00307523f, 0.02623993f, 
    0.04764252f, -0.12973258f, 0.05347335f, 0.07301079f, 0.00649665f, 0.26541552f, -0.00860216f, -0.38433400f, 
    -0.06596137f, 0.07842094f, 0.06858923f, -0.06582060f, -0.10040127f, -0.23957521f, 0.10855260f, -0.07683288f, 
    -0.12999290f, 0.02115937f, 0.07918499f, 0.13862038f, -0.13180064f, -0.00566007f, -0.08219612f, 0.08555252f, 
    0.09986754f, 0.06613204f, 0.00244486f, -0.18467408f, 0.06910486f, -0.03854241f, -0.01705145f, -0.07060232f, 
    0.37332413f, -0.00012504f, 0.08728211f, 0.12507781f, 0.20691103f, -0.07298309f, -0.13351655f, 0.06852526f, 
    0.04061831f, 0.22502026f, 0.10338049f, -0.28782997f, -0.10824054f, -0.08052831f, 0.02402431f, -0.01854592f, 
    -0.12208273f, -0.14212266f, -0.41317621f, 0.01916466f, 0.29593939f, 0.09889740f, -0.10390569f, 0.10151344f, 
    0.01981287f, 0.08952539f, 0.15255903f, 0.36201507f, -0.03040440f, 0.23066263f, 0.10714751f, 0.06163903f, 
    0.19897434f, -0.12210375f, -0.16706693f, -0.02224940f, 0.01358869f, 0.09843083f, 0.03406489f, -0.05379308f, 
    -0.04434588f, -0.36084616f, -0.15135095f, 0.08457457f, 0.19068824f, 0.00155368f, 0.18459952f, 0.06198166f, 
    0.11765702f, 0.19947194f, -0.18383685f, 0.07927465f, -0.03907069f, 0.18986252f, 0.24957988f, 0.20476091f, 
    0.18167146f, -0.30368403f, -0.06509162f, 0.13575861f, -0.04335662f, 0.08456147f, 0.13374515f, 0.05565817f, 
    0.13614479f, 0.04347379f, -0.20326038f, 0.00960549f, 0.14455825f, -0.03264822f, -0.01852111f, 0.04287197f, 
    0.03187371f, -0.02550097f, -0.05894906f, 0.24974617f, -0.07096652f, 0.06102812f, 0.09906179f, 0.15484557f, 
    -0.13188691f, -0.31878620f, 0.12239222f, 0.13268384f, -0.04357097f, -0.03091352f, 0.07996615f, 0.05287198f, 
    0.02432130f, -0.37765199f, -0.11000723f, -0.15432110f, 0.16401818f, 0.12297281f, 0.06949860f, 0.04003438f, 
    -0.05654829f, 0.08197454f, 0.08572334f, 0.21463554f, -0.10501453f, -0.04011073f, -0.10113954f, -0.13299526f, 
    -0.08282365f, -0.01510474f, -0.10342416f, -0.13308865f, -0.31780615f, -0.04014282f, 0.02256941f, 0.13440892f, 
    -0.00967425f, 0.00184477f, -0.02348199f, 0.03879422f, -0.07272368f, -0.01629984f, 0.07786671f, 0.06711870f, 
    0.04884528f, -0.00411686f, 0.27307177f, -0.04667545f, -0.05177716f, 0.08366439f, -0.07791902f, -0.18120104f, 
    0.15999161f, 0.09320085f, 0.06155262f, 0.00054405f, -0.13304242f, -0.05349999f, 0.12936507f, 0.15671259f, 
    0.02925164f, -0.08278970f, -0.00600123f, 0.04917166f, 0.00166910f, 0.26815131f, 0.05423693f, 0.05724619f, 
    -0.14219071f, 0.01568886f, -0.17346562f, 0.06580035f, 0.00283977f, -0.09515045f, -0.07061587f, -0.03976002f, 
    -0.21161066f, -0.22981054f, -0.27248672f, 0.20873126f, 0.33938682f, 0.21542688f, 0.12540050f, 0.02662782f, 
    -0.05234155f, 0.02839523f, -0.13693592f, 0.12971410f, -0.11831149f, -0.01795480f, 0.05013444f, 0.00528456f, 
    -0.05812455f, 0.01295714f, -0.20355611f, 0.03734725f, 0.06817073f, 0.09908926f, 0.02425258f, -0.00818479f, 
    0.16019532f, -0.07737073f, -0.12130409f, -0.10318439f, -0.11728455f, 0.01579108f, -0.10909006f, -0.06429937f, 
    0.10175682f, 0.12208756f, -0.03048092f, -0.20200881f, -0.13053314f, -0.04723810f, -0.00150547f, -0.11723011f, 
    0.05882308f, 0.06393673f, -0.00547917f, 0.02217253f, 0.07206095f, -0.13119704f, -0.10985506f, -0.20066372f, 
    0.02275136f, 0.10474700f, 0.02997615f, 0.06808737f, 0.04640664f, 0.01426065f, 0.08363716f, -0.19939303f, 
    0.05998285f, -0.25455505f, -0.08114312f, 0.07033502f, 0.00833695f, -0.15822017f, -0.00125225f, -0.17921014f, 
    0.27542007f, 0.00981609f, 0.14431234f, 0.08489457f, -0.10620616f, -0.02704346f, 0.09918188f, 0.05992109f, 
    -0.09810149f, -0.06527808f, 0.17055798f, -0.04259659f, -0.05820074f, 0.02309079f, -0.16271535f, -0.10500355f, 
    0.02999318f, 0.05903362f, 0.12802212f, -0.25461492f, -0.19200447f, -0.14875451f, -0.01967540f, 0.02486532f, 
    0.06573431f, 0.00645499f, -0.05370845f, -0.04981291f, 0.32147762f, 0.11745495f, 0.08675456f, -0.10506923f, 
    0.15696545f, -0.10157841f, 0.14467245f, -0.07382016f, 0.10594462f, -0.10631047f, -0.02073814f, -0.01252379f, 
    0.01388470f, -0.07763490f, 0.07304709f, 0.00406291f, -0.10305331f, -0.12536734f, -0.10216092f, -0.27274191f, 
    0.12050860f, 0.05639238f, 0.17280966f, 0.03467821f, 0.03460250f, -0.04394862f, 0.05350097f, -0.08931302f, 
    -0.06354193f, 0.05119972f, 0.14398697f, 0.06378573f, 0.07408415f, 0.04201690f, 0.06706258f, -0.00058975f, 
    -0.13208155f, -0.07630398f, -0.13401161f, 0.04495593f, -0.14813539f, 0.08712102f, -0.00202375f, -0.13999309f, 
    0.21219443f, 0.13055848f, 0.15067810f, -0.00767311f, 0.09690035f, -0.03577012f, 0.11982349f, 0.15207347f, 
    -0.06135689f, -0.26929706f, -0.19096161f, -0.07731423f, -0.02661923f, 0.07735987f, 0.07916129f, 0.02624188f, 
    0.02124069f, -0.08202124f, -0.01304762f, 0.16926338f, -0.03284528f, 0.13374259f, 0.03853137f, 0.14624797f, 
    -0.01663420f, 0.13172430f, -0.00602965f, 0.16936129f, 0.13161254f, 0.02424911f, -0.06573930f, -0.01596556f, 
    0.13052374f, 0.02523733f, 0.01493657f, 0.00744699f, -0.03337798f, -0.01384005f, 0.12134346f, 0.09808158f, 
    0.02660400f, -0.12892675f, -0.09269013f, 0.04605336f, -0.01515239f, 0.08821351f, 0.02391721f, 0.19769824f, 
    -0.01333076f, -0.20100912f, -0.16094317f, 0.08178333f, 0.12841338f, -0.07245525f, -0.26650929f, 0.09416528f, 
    -0.04171928f, -0.08740125f, -0.03471045f, -0.01699713f, 0.14914498f, -0.07326881f, -0.05116870f, -0.15406512f, 
    -0.01893714f, -0.46381316f, -0.04841610f, 0.09900165f, 0.08146712f, 0.14708520f, -0.01116289f, -0.08675351f, 
    -0.12001780f, 0.15538356f, -0.18338996f, -0.00346424f, -0.09129308f, 0.02500510f, -0.01158693f, -0.01389420f, 
    -0.02126710f, -0.07442018f, 0.05985684f, 0.04098503f, 0.13672246f, 0.06696723f, 0.02911559f, 0.03870708f, 
    -0.04243220f, 0.05599834f, -0.06140184f, -0.00224381f, 0.04186399f, 0.00867524f, -0.01124136f, -0.07462914f, 
    -0.16935523f, 0.07489458f, 0.02539195f, -0.18439865f, 0.06138526f, -0.02031372f, -0.07458767f, -0.02120551f, 
    -0.01630051f, -0.12689696f, 0.11229011f, -0.05752108f, 0.24100968f, 0.15520692f, 0.04472842f, 0.21164221f, 
    -0.01575433f, -0.07562842f, -0.09983018f, -0.00036986f, 0.01949855f, 0.11496102f, 0.13825504f, 0.22942694f, 
    -0.13834934f, -0.18952565f, -0.08209863f, 0.01364297f, 0.09245390f, -0.04641552f, 0.05391462f, 0.07583279f, 
    -0.02508450f, 0.05123153f, 0.10452027f, 0.07773881f, 0.04305305f, -0.01551576f, 0.00882361f, -0.34109685f, 
    0.06716412f, 0.16006260f, 0.08254039f, -0.13332237f, 0.02088473f, 0.06168658f, 0.02165755f, 0.00717230f, 
    0.20276432f, -0.02452573f, 0.00150870f, 0.08796181f, 0.03300722f, 0.03265730f, 0.06500579f, 0.11227418f, 
    -0.10098185f, 0.10335628f, 0.13984236f, -0.02435975f, 0.05861823f, 0.08409037f, -0.01549690f, 0.05211513f, 
    -0.06965216f, 0.21225601f, 0.18087615f, -0.15863943f, -0.20282668f, 0.09790245f, 0.09705115f, -0.04251724f, 
    0.19797312f, 0.06256239f, 0.03354838f, -0.24160953f, 0.09016834f, 0.11763454f, -0.12154908f, -0.00637903f, 
    -0.04326481f, -0.04884962f, -0.10910448f, 0.07978533f, -0.14697878f, -0.00675601f, -0.27077267f, 0.21491882f, 
    0.07018750f, 0.06026392f, 0.09973710f, -0.06651385f, -0.20527042f, 0.08042891f, 0.04350431f, -0.11117529f, 
    0.02451749f, 0.02574413f, 0.09451589f, -0.06640972f, -0.05575012f, -0.00898547f, -0.13014799f, 0.07719273f, 
    0.08399741f, 0.12327442f, 0.04677552f, -0.21238267f, -0.01830832f, -0.00609470f, 0.04598256f, 0.06346195f, 
    -0.16493167f, -0.18082313f, 0.08889345f, 0.10478024f, 0.10889007f, 0.06874272f, -0.04352220f, -0.09932390f, 
    -0.21737777f, 0.13976549f, -0.08948100f, 0.03789197f, -0.02961506f, 0.02583063f, -0.08151539f, 0.07876028f, 
    -0.10339941f, 0.32018283f, -0.15920062f, 0.18007433f, 0.04465355f, 0.21832335f, 0.01934861f, -0.07549585f, 
    0.04165568f, -0.06673461f, -0.44652840f, 0.17040661f, 0.07579817f, 0.07830554f, 0.01640027f, -0.06324356f, 
    -0.11892333f, 0.03925870f, -0.12928805f, 0.42855915f, -0.20850776f, -0.19059612f, -0.03937283f, 0.08331323f, 
    -0.11058565f, 0.07557066f, 0.09261760f, 0.04456365f, -0.21153830f, 0.17373854f, 0.32277873f, 0.09168848f, 
    -0.03851076f, -0.10855817f, 0.04037657f, 0.13781777f, -0.01696629f, -0.34711847f, -0.40462929f, 0.22725102f, 
    -0.08149939f, 0.20035782f, 0.13849156f, 0.06381115f, 0.01072783f, -0.09244112f, -0.03250603f, -0.13757509f, 
    0.00748276f, -0.00820534f, -0.03794704f, -0.00361071f, 0.14948119f, 0.02062820f, 0.12283728f, -0.15103598f, 
    -0.05575543f, 0.03426677f, -0.00763670f, 0.13382259f, 0.12369077f, 0.04995142f, -0.05981866f, -0.07719719f, 
    -0.30636808f, -0.20879398f, 0.09809817f, -0.14016400f, 0.18642575f, -0.10557289f, -0.06868496f, -0.04957590f, 
    -0.09028760f, -0.22791879f, 0.04442765f, 0.14025493f, -0.14846265f, 0.14064741f, 0.05614992f, 0.03966935f, 
    -0.01365524f, -0.03575592f, 0.13766971f, -0.26159716f, 0.09866286f, -0.03200700f, 0.19103552f, 0.12928617f, 
    0.12358000f, -0.09458411f, 0.12783831f, -0.52589238f, -0.39337319f, 0.11300955f, -0.06319281f, -0.13513984f, 
    0.19661023f, 0.11390999f, 0.08390487f, 0.26169434f, 0.18636250f, 0.09909160f, -0.02255550f, 0.08342171f, 
    0.03356032f, -0.00207350f, -0.03565074f, -0.03641111f, -0.00953140f, -0.08021554f, -0.11439715f, -0.56884640f, 
    0.10832547f, 0.19282606f, 0.14453669f, -0.13019359f, 0.03420029f, 0.01439369f, -0.00286979f, -0.36885715f, 
    -0.08378474f, 0.14865847f, -0.13868520f, 0.04235515f, -0.10379708f, 0.03112910f, 0.05493001f, -0.39464763f, 
    0.29393181f, -0.14634190f, -0.00607213f, -0.18888235f, 0.03366478f, -0.06032825f, 0.05718689f, 0.01111699f, 
    0.30856761f, -0.02281614f, -0.26754263f, -0.01300487f, 0.00343188f, -0.00501872f, -0.24781822f, 0.01981724f, 
    -0.08313145f, 0.08020893f, -0.29734007f, 0.12257067f, -0.25510269f, -0.07108790f, 0.15382861f, -0.06135865f, 
    0.06098710f, -0.00576884f, 0.21351112f, 0.03490185f, -0.08571171f, 0.04573613f, -0.02534856f, 0.04329613f, 
    -0.02205273f, 0.15315706f, -0.07962754f, 0.64940393f, -0.05159086f, -0.26632807f, -0.05046287f, -0.05909000f, 
    0.07200629f, -0.09415469f, 0.06320313f, 0.06542072f, 0.16561262f, -0.10224760f, 0.11400587f, 0.07378242f, 
    -0.10007765f, -0.19186012f, 0.02484271f, -0.02384305f, 0.07286657f, 0.09628601f, -0.29115713f, -0.21398230f, 
    -0.19677164f, 0.06690392f, 0.06792342f, 0.18618159f, 0.09900053f, -0.16191675f, 0.07287771f, 0.32153791f, 
    -0.01748934f, 0.10196608f, -0.03049618f, -0.09275952f, 0.15248413f, 0.02463736f, -0.02795036f, 0.18679208f, 
    0.25632581f, -0.34978110f, 0.15369482f, 0.16780718f, -0.11112144f, 0.02466861f, -0.03004409f, -0.02688168f, 
    -0.03829233f, 0.04571962f, -0.09488273f, -0.08434056f, -0.10193969f, 0.04831957f, -0.05903296f, -0.03014326f, 
    0.06082541f, 0.05770024f, -0.33680120f, 0.17476465f, -0.24127601f, 0.01259577f, -0.04063400f, 0.00503126f, 
    -0.03669223f, 0.10124577f, -0.09392587f, 0.10983712f, 0.11700827f, -0.08485088f, 0.00879768f, 0.10086830f, 
    0.00271238f, -0.00677638f, -0.26902276f, 0.15174811f, 0.19766188f, -0.29367226f, 0.06730615f, -0.10578422f, 
    -0.05261352f, 0.10194765f, 0.10951247f, 0.16231996f, -0.10103873f, 0.13470905f, -0.10626598f, 0.04312336f, 
    0.09643258f, 0.06894121f, -0.02843817f, -0.03594044f, -0.13280720f, 0.05903761f, 0.08892279f, -0.02506367f, 
    -0.03869183f, -0.12618899f, 0.04101770f, -0.06017787f, 0.04641280f, -0.10792249f, 0.60442257f, 0.14270517f, 
    -0.19577688f, 0.09933637f, 0.17745806f, -0.06627283f, 0.10610689f, -0.06314953f, 0.07016544f, -0.28864235f, 
    0.12088425f, -0.00881437f, -0.11235595f, 0.12246350f, -0.03274755f, -0.07461578f, -0.08108784f, -0.04842620f, 
    -0.31958210f, 0.27937815f, -0.22683673f, -0.08156046f, -0.02043209f, -0.03955423f, 0.04668799f, -0.06044792f, 
    0.12141804f, -0.22510450f, 0.25477490f, -0.28760019f, 0.16996874f, -0.09078740f, 0.01746190f, -0.01867199f, 
    0.06744297f, -0.04149451f, -0.04498867f, -0.07592769f, -0.15481009f, 0.03158828f, 0.04910405f, 0.06414744f, 
    0.08661874f, 0.18072975f, -0.06863699f, -0.31620604f, -0.32509363f, 0.09395159f, 0.13776298f, -0.15079480f, 
    -0.23054869f, 0.07195570f, 0.07642363f, -0.18521203f, 0.14548475f, -0.03954449f, -0.41710991f, 0.01772862f, 
    0.09751259f, 0.02695107f, -0.10095581f, 0.26465589f, -0.09990916f, -0.13766193f, 0.03950292f, 0.07330784f, 
    -0.07696305f, 0.11378537f, -0.08372089f, -0.12095422f, 0.02939221f, 0.11566333f, -0.02037042f, -0.10315938f, 
    0.08858463f, -0.24490091f, 0.05717903f, 0.08787663f, 0.06060082f, -0.01036810f, -0.01627861f, 0.03304720f, 
    0.09942212f, 0.37795258f, 0.05216413f, -0.00160627f, 0.04238596f, -0.08474933f, 0.23869465f, 0.04069497f, 
    -0.07635510f, 0.05572663f, -0.22721817f, 0.07849095f, -0.13008626f, 0.02421556f, 0.16070294f, 0.07071081f, 
    0.09501332f, -0.09581465f, 0.09254385f, 0.11465205f, 0.13476403f, 0.08806139f, -0.03121043f, 0.05128303f, 
    0.09008884f, 0.12801726f, -0.07004128f, -0.01131495f, -0.00848997f, 0.07148887f, -0.11162353f, -0.00132972f, 
    -0.01056877f, 0.07323261f, -0.04999000f, -0.08518068f, 0.05575452f, -0.02787735f, 0.22933351f, 0.02042433f, 
    -0.20253645f, 0.02376204f, -0.11058019f, -0.08082566f, 0.10590744f, 0.21459648f, -0.17807946f, -0.12938349f, 
    0.04968851f, -0.07157231f, 0.14077215f, -0.00294866f, -0.07885757f, -0.40726361f, -0.15544590f, -0.30057940f, 
    0.38809475f, 0.03755572f, 0.06508498f, -0.01352767f, 0.01642662f, -0.10759420f, 0.27590108f, 0.07433748f, 
    0.25088441f, -0.09845607f, -0.01967314f, -0.06259706f, -0.00178827f, 0.08455531f, 0.17730694f, -0.15706427f, 
    -0.18623640f, 0.09893449f, 0.16368985f, -0.09762646f, 0.22143061f, -0.00043927f, 0.05715694f, 0.05944232f, 
    -0.19247358f, -0.04133325f, -0.28819647f, 0.11221809f, 0.11458907f, -0.08563550f, -0.06313782f, -0.17138760f, 
    0.10379480f, 0.15839326f, 0.22394173f, -0.06900938f, -0.16208717f, -0.01576144f, -0.20596720f, -0.08951083f, 
    0.05704368f, 0.12254565f, -0.08112347f, 0.01445350f, 0.08071655f, 0.07610021f, -0.02483472f, -0.09910914f, 
    -0.01921554f, 0.00686678f, -0.13499677f, 0.18830499f, -0.22588459f, 0.24086732f, 0.04175591f, -0.18990393f, 
    0.04851399f, -0.05334473f, 0.10744899f, 0.00423041f, -0.14193180f, -0.13644917f, -0.12714307f, -0.03585001f, 
    -0.13499446f, 0.08529396f, -0.02272744f, 0.04447192f, 0.04157935f, -0.22106066f, -0.20181121f, 0.09949912f, 
    0.07610343f, 0.01506081f, -0.12761828f, 0.10559967f, 0.05250864f, -0.14232618f, 0.07051716f, 0.13833942f, 
    0.09805905f, -0.03786403f, 0.06615014f, -0.08268336f, 0.00445656f, 0.03745280f, -0.05873168f, -0.00015953f, 
    0.10109977f, -0.16635688f, 0.07863496f, -0.05419315f, 0.06745684f, 0.00118137f, 0.00503409f, -0.05350368f, 
    -0.26259768f, 0.01674189f, -0.18677884f, 0.27884099f, 0.11607258f, 0.07863777f, -0.07256466f, 0.10462835f, 
    0.09237262f, -0.50367415f, 0.00515876f, 0.37799820f, 0.06421024f, 0.09514666f, -0.11878289f, -0.17192763f, 
    0.03523022f, 0.14523196f, -0.07224732f, 0.05708820f, -0.00318951f, 0.14601186f, -0.02710099f, -0.05819667f, 
    0.02151968f, 0.09919111f, 0.08253213f, -0.15781634f, -0.09857418f, -0.13413131f, 0.05688502f, -0.13817862f, 
    -0.04994638f, 0.14993420f, 0.05218085f, -0.15365489f, 0.14156151f, 0.07307155f, 0.08657153f, -0.20854405f, 
    -0.01563211f, -0.09303575f, 0.07816147f, 0.00904160f, 0.09812122f, 0.03790218f, -0.16693720f, 0.27812693f, 
    0.02765175f, 0.13487661f, 0.07316639f, -0.10971344f, -0.04470735f, 0.14415920f, -0.11566876f, -0.12134797f, 
    0.31568056f, -0.08051581f, -0.09619258f, 0.15266572f, -0.06409249f, 0.03917384f, -0.01206078f, 0.13264853f, 
    0.18598327f, -0.06415212f, 0.08998363f, -0.10011736f, -0.05744356f, 0.01027945f, -0.01479505f, 0.10951477f, 
    0.07477587f, 0.03794576f, -0.06394103f, 0.39946857f, -0.05923961f, 0.16204488f, -0.04122201f, 0.13414793f, 
    -0.11419266f, 0.10716449f, 0.10036644f, -0.29229671f, 0.10059766f, -0.03664608f, 0.22474746f, -0.00478664f, 
    -0.18233852f, -0.09254966f, 0.03986092f, 0.03153143f, 0.12964416f, 0.09860574f, -0.03211483f, 0.28224993f, 
    -0.04810163f, 0.10680577f, -0.05637256f, 0.00220517f, 0.04795299f, -0.15306178f, -0.00614778f, -0.01423212f, 
    -0.08357810f, 0.00367463f, 0.06713182f, 0.11945546f, 0.04923033f, -0.21604146f, 0.00930714f, 0.32233483f, 
    -0.01346836f, 0.14917484f, -0.04923294f, -0.05901574f, -0.11801343f, 0.26526269f, 0.09795272f, 0.02692983f, 
    0.03311254f, 0.03057977f, -0.09738712f, -0.00836565f, 0.08566555f, 0.02555911f, 0.03160234f, 0.04469505f, 
    0.32604417f, 0.01074872f, -0.15034978f, -0.23655948f, 0.05836247f, 0.06864244f, 0.06264263f, 0.18612073f, 
    0.04861752f, -0.05660788f, 0.11933635f, -0.07236177f, 0.06267843f, -0.06339215f, -0.04167687f, 0.05416712f, 
    0.05585481f, 0.08516289f, -0.10900927f, 0.04285829f, -0.09385236f, 0.13224196f, -0.24893056f, -0.11716112f, 
    -0.04784277f, 0.20314738f, 0.08568593f, -0.01511073f, -0.09499502f, 0.12793662f, 0.05876783f, 0.01126767f, 
    -0.08136365f, 0.16580133f, 0.27093172f, -0.16532421f, -0.06100065f, 0.04853624f, 0.09184496f, -0.16064115f, 
    -0.00409955f, -0.01819633f, -0.14728397f, 0.33873883f, 0.26458016f, -0.12509552f, 0.04709937f, -0.02357808f, 
    -0.09065856f, -0.02275362f, 0.01209853f, 0.06962732f, 0.38798112f, -0.12047379f, 0.05617844f, 0.17926705f, 
    -0.09440889f, 0.08203973f, 0.05975333f, -0.05233974f, 0.10793748f, -0.18936482f, -0.04440290f, -0.17598300f, 
    -0.02577152f, 0.11081334f, 0.05624836f, -0.14064507f, -0.08856922f, -0.29718214f, 0.29521391f, -0.10189819f, 
    -0.06414034f, 0.36509827f, -0.04295786f, -0.17280102f, -0.04629071f, -0.24229041f, 0.04177951f, -0.12251253f, 
    0.01688449f, -0.10155675f, 0.11982154f, -0.04335872f, -0.03092503f, -0.04352775f, -0.13771237f, 0.00645644f, 
    -0.24706978f, 0.14283521f, -0.29835445f, 0.00397255f, 0.04254122f, 0.09884176f, -0.16429803f, -0.01719624f, 
    0.18159838f, 0.19460499f, -0.22288112f, -0.07482425f, 0.06860635f, -0.06789850f, -0.19272843f, 0.12794833f, 
    0.08493739f, 0.09652641f, -0.09159464f, 0.00436377f, -0.03084703f, 0.08999892f, 0.11111221f, -0.02089347f, 
    -0.25116915f, 0.11405040f, -0.12756111f, -0.24731575f, 0.14647885f, 0.04241076f, 0.02860594f, -0.09413905f, 
    -0.12983030f, 0.13305852f, 0.04857599f, -0.03191769f, -0.19107176f, -0.12174657f, -0.09596948f, -0.09279982f, 
    0.19647479f, 0.04760574f, 0.10761834f, -0.12609416f, 0.09346142f, -0.20621546f, -0.01573366f, -0.43055549f, 
    0.04768535f, 0.07994308f, -0.01604647f, -0.04399213f, 0.04217774f, -0.10973737f, 0.01728752f, 0.01871466f, 
    0.11109253f, -0.05677631f, 0.10554381f, -0.17603193f, -0.06238551f, 0.06623727f, -0.11946376f, -0.17207946f, 
    -0.22592072f, -0.02786554f, 0.03377069f, 0.14397046f, 0.03750016f, -0.06450018f, -0.02642977f, -0.14309876f, 
    0.29191875f, 0.00848798f, 0.07084693f, 0.21244037f, -0.26569659f, 0.18316029f, -0.06849020f, -0.06605209f, 
    -0.08955853f, 0.29616919f, 0.67951405f, 0.10590839f, -0.08030227f, 0.12552251f, -0.03777315f, 0.00089731f, 
    0.03913581f, 0.11499932f, 0.14930771f, -0.21032394f, -0.00531476f, 0.18734255f, 0.04144438f, 0.06543244f, 
    0.04511942f, -0.10063244f, 0.11642966f, -0.18536067f, -0.12033898f, 0.02193246f, 0.10294703f, -0.06455743f, 
    -0.10119827f, 0.04722697f, 0.31940013f, 0.25164872f, 0.15877894f, 0.00191039f, 0.04601730f, 0.18048248f, 
    -0.03366613f, -0.02789697f, -0.01552205f, -0.01306339f, 0.08319240f, -0.10355186f, 0.32751936f, 0.07610015f, 
    -0.00777806f, 0.04743948f, 0.04172336f, 0.05600559f, 0.07019801f, 0.03947061f, 0.07274799f, 0.19895679f, 
    0.04130344f, -0.02108178f, 0.19867472f, -0.18926658f, 0.00218524f, 0.01185675f, -0.00951817f, 0.25962442f, 
    -0.08099891f, 0.09139585f, 0.02327226f, -0.21152979f, -0.21951242f, 0.17044872f, -0.00971810f, 0.24288772f, 
    -0.12613235f, 0.17405127f, 0.04828811f, 0.07506835f, 0.09960316f, 0.06003447f, -0.02932063f, -0.10875106f, 
    -0.03592372f, -0.17213514f, -0.16899990f, 0.21365663f, 0.00740794f, 0.03936096f, -0.04050396f, -0.18549292f, 
    -0.00464039f, 0.08405839f, -0.08454220f, -0.19150031f, 0.21996242f, -0.01421668f, 0.03780561f, -0.14249106f, 
    0.12630834f, -0.06741380f, 0.09427624f, 0.42588705f, 0.34201586f, -0.20437184f, -0.12526947f, -0.03014172f, 
    0.05927927f, 0.06067177f, -0.10440974f, 0.04102987f, 0.09317937f, -0.02538957f, 0.04411438f, 0.19927859f, 
    -0.06660117f, -0.12207676f, -0.00857501f, -0.16370367f, 0.19652675f, -0.15211502f, 0.01211471f, 0.35333407f, 
    0.07234550f, 0.02604479f, -0.05330291f, -0.04182592f, 0.10738544f, -0.08419403f, -0.20268221f, 0.08441187f, 
    0.01246970f, 0.04439795f, -0.08071454f, -0.00809081f, -0.11002524f, 0.08380052f, -0.07419243f, -0.52384233f, 
    -0.37281331f, -0.04624594f, 0.03640880f, 0.18428779f, -0.10269103f, 0.01038937f, 0.07280076f, -0.04827485f, 
    -0.09950971f, 0.02620079f, -0.02840678f, 0.00436013f, -0.03461691f, 0.10106787f, 0.03399902f, 0.04321880f, 
    0.20619068f, -0.02558473f, 0.06296905f, 0.13940434f, -0.00182311f, -0.07899263f, -0.03036106f, 0.04962483f, 
    -0.00242190f, 0.04839769f, 0.03686106f, -0.10363691f, -0.17610613f, 0.09372035f, 0.02096717f, 0.16241130f, 
    -0.07684397f, -0.21966848f, -0.12152679f, -0.12194286f, -0.06809830f, -0.11730550f, -0.04870759f, 0.15088561f, 
    0.07194585f, -0.17271960f, 0.02503547f, 0.03195902f, -0.06191629f, -0.02993359f, 0.09106086f, -0.03088858f, 
    -0.05680540f, 0.11403991f, 0.03237263f, -0.05825391f, -0.04226105f, 0.13189749f, 0.05630263f, 0.22908719f, 
    0.04791793f, -0.03813842f, 0.16176333f, 0.01368318f, 0.20096110f, 0.13847604f, -0.53905463f, -0.07828891f, 
    0.02791832f, 0.01709028f, -0.00499715f, 0.10027000f, -0.10101370f, 0.01980333f, -0.01140323f, -0.02180315f, 
    0.00889729f, 0.00429630f, 0.14765781f, 0.03511000f, 0.05652959f, 0.13691401f, -0.04067973f, 0.02134403f, 
    0.23085253f, -0.02858744f, -0.17689095f, 0.00061931f, 0.13789776f, 0.01168473f, -0.07194667f, -0.20985310f, 
    -0.08151226f, 0.20195836f, -0.03841912f, -0.03213209f, 0.08981364f, -0.12311042f, 0.09503927f, 0.04446698f, 
    -0.07393123f, 0.01931997f, 0.08915724f, 0.16625535f, -0.18671727f, -0.01877877f, -0.09105359f, 0.04737909f, 
    0.10256712f, -0.01926526f, 0.05426165f, 0.07193959f, 0.05160837f, -0.20126680f, 0.01053845f, -0.09270283f, 
    0.06551625f, 0.08878244f, -0.05818139f, 0.11975811f, -0.08139579f, 0.00966857f, -0.01452636f, 0.06292605f, 
    0.09775369f, 0.18817802f, 0.13750613f, -0.02068368f, 0.06786365f, -0.02932681f, -0.14005910f, 0.03382799f, 
    -0.05920229f, 0.05244231f, 0.11510127f, 0.02530103f, -0.11142329f, 0.11532806f, -0.07979459f, -0.02996863f, 
    -0.28826633f, 0.02863933f, -0.04072408f, -0.01420094f, 0.02987426f, -0.02392578f, -0.00541870f, 0.07055833f, 
    -0.20694353f, 0.05907564f, 0.08634818f, -0.23716600f, -0.06814082f, -0.05731856f, 0.04755694f, 0.09441834f, 
    0.22846964f, 0.17529055f, 0.02833128f, -0.03312575f, -0.01807641f, 0.00467792f, -0.11986188f, -0.05073091f, 
    0.05906811f, -0.14058653f, -0.08559676f, -0.18517354f, -0.06664230f, 0.08774468f, -0.08434089f, 0.05017835f, 
    0.07378745f, 0.17634155f, 0.27194801f, 0.16338566f, 0.09934032f, 0.05617973f, -0.10907860f, 0.05669760f, 
    0.07732565f, 0.01921531f, -0.13551860f, -0.15196310f, 0.04807772f, -0.13023241f, -0.03943039f, -0.10552352f, 
    -0.04170303f, 0.06547557f, -0.19069923f, 0.05429250f, -0.04820659f, 0.06943168f, 0.23136105f, 0.16562530f, 
    0.02531681f, -0.27464086f, -0.01894115f, -0.04686931f, -0.16234502f, -0.35388026f, -0.46561283f, -0.09052412f, 
    0.00488960f, 0.14168596f, -0.04711018f, 0.04476483f, 0.01314191f, 0.04575362f, -0.20355932f, 0.21560416f, 
    -0.43311405f, -0.03485063f, -0.12842353f, 0.05812125f, 0.13011530f, 0.02613852f, -0.07542421f, 0.15130566f, 
    0.17391963f, 0.21180867f, 0.16936620f, 0.09875317f, -0.05335746f, 0.01320176f, -0.19406523f, -0.11109594f, 
    0.44550622f, 0.13991341f, 0.08919492f, -0.22498049f, 0.09914911f, -0.06161630f, 0.06196396f, 0.02705730f, 
    0.00547530f, -0.00751531f, 0.02989757f, 0.21025109f, 0.00787936f, 0.06073335f, -0.06450941f, -0.08532155f, 
    -0.06786420f, -0.15725896f, 0.16265815f, -0.33815387f, 0.08648006f, 0.03140447f, 0.14040597f, 0.05458149f, 
    -0.03591589f, -0.11434236f, -0.17648430f, 0.27491468f, 0.04561132f, 0.17090259f, 0.12741783f, 0.06219386f, 
    0.06154528f, 0.08284583f, 0.26354584f, -0.03113267f, 0.03578528f, -0.48347265f, 0.11868987f, 0.03287219f, 
    0.07104088f, 0.07167441f, 0.00884242f, -0.06121830f, -0.20720272f, 0.00645014f, -0.18210883f, -0.02372806f, 
    0.01019522f, 0.05607013f, -0.10331674f, -0.10871885f, 0.01963230f, 0.20742269f, 0.18097432f, 0.10266981f, 
    -0.02746368f, -0.01359741f, -0.03727409f, -0.09224027f, -0.09670448f, -0.06191665f, 0.02435807f, 0.23385943f, 
    -0.01291692f, -0.01387538f, -0.07335171f, -0.03923497f, 0.00139732f, -0.10545424f, 0.03541006f, -0.13976417f, 
    0.22248875f, 0.04696020f, 0.00518790f, -0.18151499f, -0.00223109f, -0.08550248f, -0.14916152f, -0.04019950f, 
    -0.12433483f, -0.12716377f, -0.29659510f, 0.00226696f, -0.10506823f, 0.08681472f, -0.04892729f, -0.05154406f, 
    -0.07360580f, 0.16781941f, 0.17243135f, 0.00325246f, 0.10491185f, 0.03483748f, 0.00771231f, 0.02432617f, 
    0.11911070f, 0.03207679f, -0.04460552f, 0.03272506f, 0.15090974f, 0.05151187f, -0.08801424f, -0.10992399f, 
    0.19764534f, -0.14910336f, 0.01427835f, -0.09123826f, 0.00155904f, -0.18185362f, 0.04724089f, 0.00799216f, 
    0.09776323f, 0.02759171f, -0.06515264f, -0.02454542f, 0.05485228f, 0.24091759f, 0.20144008f, 0.17412248f, 
    -0.11118306f, -0.05250436f, 0.19411042f, -0.18396322f, -0.12508520f, -0.03781481f, 0.07007296f, 0.00954081f, 
    -0.15684699f, -0.03984658f, 0.11287136f, -0.15244378f, -0.17036255f, -0.03236952f, 0.00813262f, -0.31627703f, 
    0.02579354f, 0.17391226f, 0.08442196f, 0.04634203f, -0.09100249f, 0.01216984f, -0.08728424f, 0.15516955f, 
    -0.12366215f, 0.05562731f, 0.10295113f, -0.03169538f, -0.20773031f, -0.07741506f, -0.07601287f, -0.08423787f, 
    -0.02023750f, -0.11371032f, 0.18850698f, 0.06839899f, -0.04043252f, -0.10187592f, -0.05807110f, -0.01056684f, 
    0.05710259f, 0.08687386f, 0.02058985f, -0.07271502f, -0.00778331f, 0.20390292f, -0.05451280f, 0.03357432f, 
    0.08156168f, 0.02849448f, -0.10602269f, -0.16462456f, -0.00220137f, 0.00113753f, -0.03364678f, -0.11264039f, 
    0.19154094f, 0.05096182f, -0.02131464f, 0.03828885f, 0.22800417f, 0.14173748f, 0.05027412f, -0.00856771f, 
    -0.08150426f, -0.01898268f, 0.11017373f, -0.04087250f, 0.00631105f, 0.32380113f, 0.03755490f, 0.05798264f, 
    0.01742701f, 0.07859166f, -0.09893783f, 0.03315292f, -0.01344042f, -0.17022328f, 0.14136420f, -0.05966527f, 
    0.11411577f, 0.15074214f, 0.26784068f, 0.08963561f, 0.01011521f, -0.09047500f, 0.14736681f, -0.25440916f, 
    -0.24315017f, 0.23373140f, 0.09611193f, 0.18928862f, 0.07762603f, 0.12993713f, -0.08943232f, -0.00079201f, 
    0.10803144f, -0.70390594f, 0.01666796f, 0.02247626f, 0.05357337f, 0.12285613f, -0.16069108f, 0.01485607f, 
    0.00012937f, 0.16333468f, 0.11870304f, 0.15388206f, 0.04300779f, -0.01791158f, 0.05537957f, 0.21140386f, 
    0.22809847f, -0.06458947f, -0.22835781f, -0.32284912f, 0.04996992f, -0.12510072f, -0.05084370f, 0.13417618f, 
    -0.03446046f, -0.00155065f, -0.03437449f, -0.37844890f, 0.06976662f, -0.18821156f, 0.14280851f, -0.03883468f, 
    -0.00087977f, 0.07837950f, 0.00534801f, 0.16379166f, -0.00136053f, 0.09411709f, 0.05923247f, -0.06154488f, 
    -0.08744163f, -0.03474654f, -0.05530265f, 0.01947376f, 0.15747309f, -0.05643832f, -0.03679900f, 0.20909181f, 
    -0.15146342f, -0.01499343f, -0.05413152f, 0.02969475f, 0.10944924f, 0.10833362f, 0.03088553f, 0.16864543f, 
    0.07460887f, -0.02912512f, -0.14147790f, -0.02276370f, 0.05752682f, 0.09357975f, 0.16792855f, -0.21669237f, 
    0.00554129f, -0.00921858f, 0.00145116f, -0.08250561f, 0.20055762f, 0.00290301f, -0.00611039f, -0.05099092f, 
    -0.04871393f, 0.00584560f, 0.02579837f, -0.04214187f, -0.01112983f, -0.00209950f, -0.06220682f, 0.02407927f, 
    -0.02176650f, -0.04682418f, 0.00985308f, 0.01932733f, -0.06886765f, -0.01001247f, -0.02240719f, -0.01895646f, 
    0.01391405f, 0.04859279f, 0.02282074f, 0.03772181f, 0.02882654f, 0.01000770f, 0.01614118f, -0.04881484f, 
    -0.05223735f, -0.04814695f, -0.00862798f, -0.02537279f, 0.01059189f, -0.00872844f, 0.02896071f, -0.01508369f, 
    0.04536174f, -0.05017112f, -0.03469637f, -0.01554065f, -0.03539107f, 0.04090786f, -0.00971432f, 0.00124218f, 
    0.00738086f, 0.03381237f, 0.04271670f, 0.02102997f, 0.02410577f, -0.04419433f, 0.03762888f, -0.00669699f, 
    -0.02128423f, -0.03424483f, 0.02588129f, 0.02718068f, -0.02477852f, 0.03425187f, 0.00889053f, 0.02063819f, 
    -0.03444470f, -0.04251670f, -0.02608471f, -0.06511879f, 0.03927511f, 0.03935198f, -0.02092903f, -0.04085647f, 
    -0.03960627f, -0.04092385f, -0.00960522f, 0.03156366f, 0.03578559f, -0.06559299f, -0.01382177f, 0.01509507f, 
    0.04765248f, -0.03421278f, 0.03468460f, 0.03834919f, -0.02451820f, -0.00515694f, 0.03680201f, 0.01130909f, 
    -0.06660473f, -0.01664915f, 0.02204618f, -0.07206839f, -0.02261421f, 0.04451529f, -0.06615861f, 0.04043562f, 
    0.02202788f, 0.03379472f, 0.00166152f, -0.04214728f, -0.00915371f, -0.05692182f, -0.00154580f, 0.04219895f, 
    -0.02792467f, -0.03077993f, -0.01084069f, -0.02710874f, 0.03010383f, -0.03712094f, -0.01448403f, 0.03864428f, 
    0.01822911f, -0.00195444f, -0.02043375f, -0.03082422f, 0.03933648f, 0.00863993f, -0.02568251f, -0.00862577f, 
    0.00882038f, 0.01507698f, -0.06746511f, 0.00961076f, -0.00677307f, -0.05389602f, 0.00754092f, 0.00883636f, 
    -0.02620121f, -0.00427047f, -0.02139707f, 0.02578695f, -0.00697900f, -0.05153528f, -0.00058448f, -0.01589607f, 
    -0.01829337f, -0.06669847f, -0.02982396f, 0.04423260f, -0.00023316f, -0.04742943f, 0.02495291f, -0.03924233f, 
    -0.02799737f, -0.02464530f, -0.02217646f, -0.02959624f, -0.06864373f, -0.05461458f, -0.06600043f, -0.04003583f, 
    -0.00817833f, -0.00489823f, -0.00700397f, -0.00195624f, 0.04054633f, 0.02402110f, 0.01583429f, 0.01815452f, 
    -0.02250797f, -0.04807622f, 0.03451556f, 0.00545227f, -0.06902025f, 0.03319791f, 0.03019348f, 0.01023056f, 
    0.01770982f, -0.00085586f, -0.00107245f, 0.03948512f, -0.03907361f, -0.00075762f, 0.02726535f, -0.01184679f, 
    0.00348357f, -0.06664939f, -0.03627522f, 0.05298008f, -0.02349930f, -0.01950936f, 0.01314293f, 0.03231185f, 
    0.01487670f, -0.00596038f, 0.00203549f, -0.00473342f, 0.03766968f, 0.00897949f, 0.00267724f, 0.00390891f, 
    0.00811380f, -0.01267211f, -0.03019309f, -0.01601430f, -0.01294230f, 0.00327264f, -0.05423794f, -0.05409858f, 
    -0.05285937f, 0.00636784f, 0.02460358f, 0.00124112f, -0.00529032f, -0.05585751f, -0.00613088f, 0.02298288f, 
    -0.00343342f, 0.02577617f, -0.02489663f, -0.04732515f, 0.04540728f, -0.04138795f, -0.05638946f, -0.01563032f, 
    -0.04023508f, -0.01548184f, 0.01975945f, -0.00894241f, -0.00363310f, 0.03059060f, -0.03049653f, 0.01497745f, 
    -0.02560459f, -0.03735336f, -0.01353162f, 0.04583239f, -0.03089920f, -0.03835623f, 0.00665990f, -0.04896217f, 
    -0.06768142f, -0.04949318f, -0.04468101f, -0.02407039f, -0.05193439f, -0.03027656f, -0.00147831f, 0.02995013f, 
    -0.03088817f, -0.05639240f, 0.01370651f, -0.06113037f, 0.00959782f, 0.00946030f, 0.03958080f, 0.03123421f, 
    0.04618716f, 0.00649582f, -0.04367952f, -0.06348120f, -0.01062443f, -0.02718929f, -0.03639336f, 0.04500812f, 
    0.05103509f, -0.06639018f, -0.06202796f, -0.05828355f, -0.04595997f, -0.02199824f, -0.06547948f, 0.00854981f, 
    -0.00003142f, -0.01512350f, 0.04246538f, -0.06451371f, -0.04838056f, -0.02157985f, 0.01003731f, 0.04170699f, 
    -0.06987374f, -0.01233313f, -0.00450556f, -0.01946344f, 0.04328493f, -0.02516812f, 0.03954986f, 0.03575759f, 
    -0.04182943f, -0.00268622f, -0.00870954f, -0.04889572f, 0.00047851f, 0.01938390f, -0.02174496f, 0.02880028f, 
    0.01040294f, 0.02858599f, 0.00989516f, 0.01499910f, -0.06594439f, -0.00279408f, 0.00693243f, 0.02138103f, 
    -0.56434482f, -0.00320248f, 0.04751789f, -0.20120351f, 0.05618675f, -0.08424103f, -0.16622941f, -0.14863098f, 
    0.07885580f, -0.45596871f, -0.40182325f, 0.06389999f, -0.10981615f, -0.04400861f, 0.01048240f, 0.10313136f, 
    0.05017193f, 0.02347825f, -0.00716634f, -0.00201556f, 0.13614880f, -0.03004115f, 0.11428776f, -0.02973974f, 
    0.05908746f, 0.16516735f, 0.08171773f, 0.10591644f, 0.30893379f, 0.10123326f, 0.04953399f, 0.10984143f, 
    -0.10962104f, 0.07942795f, -0.08529263f, -0.00315212f, -0.18600857f, -0.01391320f, 0.17407814f, -0.09979158f, 
    -0.06113247f, -0.03268137f, -0.02779427f, 0.14513099f, -0.02777258f, -0.14196686f, -0.05283538f, 0.12808514f, 
    -0.11356699f, -0.05420950f, 0.06424157f, -0.00160578f, 0.12869349f, 0.00634662f, 0.08083120f, -0.17012465f, 
    -0.12975655f, 0.00985851f, 0.10737235f, 0.00233957f, 0.01461490f, -0.05838609f, -0.06312651f, 0.55478007f, 
    -0.11328624f, 0.05866593f, 0.05934420f, 0.16243269f, 0.14291131f, -0.07808153f, 0.00820813f, -0.24720055f, 
    -0.13039994f, -0.06094629f, 0.12854828f, -0.14666501f, -0.02687352f, -0.10581992f, 0.10211420f, 0.15583651f, 
    0.10781642f, -0.11544765f, 0.00575723f, 0.14169036f, -0.03999533f, -0.02696798f, -0.06449077f, 0.15685858f, 
    0.01499023f, -0.01353137f, -0.27205035f, 0.04665340f, -0.12886837f, 0.05948753f, 0.12561028f, 0.13383180f, 
    -0.08638662f, 0.04568527f, -0.06588220f, -0.09190801f, -0.18884592f, -0.03012012f, -0.01160527f, -0.01527607f, 
    -0.14857455f, 0.18232128f, -0.06270386f, 0.16319360f, -0.16350217f, -0.11183549f, 0.03079991f, -0.03372690f, 
    0.04227988f, 0.12734543f, -0.00843341f, -0.00080089f, -0.00616207f, 0.10678379f, -0.13823158f, 0.04225608f, 
    -0.02279754f, 0.04971974f, 0.11418150f, -0.06363624f, -0.03484979f, -0.21825080f, 0.43888795f, -0.02057990f, 
    0.01980767f, -0.06942674f, -0.05699380f, -0.05500324f, 0.04484357f, -0.11407829f, 0.04331063f, -0.02887928f, 
    0.06534526f, 0.01808341f, -0.32272944f, -0.03991362f, -0.16343984f, 0.18791774f, 0.15985034f, 0.10063936f, 
    -0.42925158f, -0.45412582f, -0.20755069f, 0.07330208f, -0.10644580f, -0.18536000f, -0.07175097f, -0.02433052f, 
    0.03566077f, -0.08658817f, -0.03371076f, 0.00222617f, -0.06785391f, 0.08568896f, 0.02077956f, -0.01523519f, 
    0.10988906f, 0.13058537f, 0.58014971f, 0.18996647f, -0.05027538f, 0.00536693f, 0.04526126f, -0.07001673f, 
    0.13551413f, 0.14012910f, 0.02099557f, -0.20151314f, -0.00395216f, -0.28588343f, 0.02054990f, -0.07424738f, 
    -0.01315362f, -0.05352417f, -0.00712618f, 0.20443614f, 0.43387520f, -0.16572307f, 0.32908481f, 0.02655318f, 
    0.06059504f, -0.07913344f, 0.01428216f, 0.03584299f, 0.06445182f, -0.04789864f, -0.27371347f, 0.10764075f, 
    0.20679517f, 0.03008264f, -0.06815795f, 0.08856936f, -0.04525919f, -0.05222228f, 0.23638159f, 0.36453173f, 
    -0.36469704f, 0.10366014f, 0.14244768f, 0.09813247f, -0.10996943f, -0.05837473f, -0.05816608f, -0.34545371f, 
    -0.07085310f, -0.20735708f, -0.02207264f, 0.11721507f, -0.11750221f, -0.01939182f, -0.06327436f, 0.02255742f, 
    0.09788617f, 0.02383050f, -0.00057576f, -0.23408446f, -0.05817223f, -0.08343963f, -0.26803091f, -0.02249342f, 
    0.09951879f, -0.29335141f, 0.22508754f, -0.20874138f, 0.04858113f, 0.07941803f, -0.00333244f, 0.08698250f, 
    -0.02368711f, -0.14572518f, 0.13148706f, 0.16379844f, 0.06438650f, -0.02185601f, -0.01167813f, -0.14309043f, 
    -0.05790640f, -0.03967426f, -0.01247998f, 0.02361961f, 0.12363743f, -0.18710071f, 0.08827687f, -0.19404170f, 
    -0.07176094f, -0.00129886f, -0.01563392f, 0.03589758f, 0.30257052f, 0.11836674f, -0.38508895f, 0.01299049f, 
    -0.01036984f, 0.16316116f, -0.08416499f, 0.07060388f, 0.05870331f, -0.41258934f, -0.04990446f, 0.08617420f, 
    0.01117962f, 0.04735183f, -0.11734241f, 0.04483615f, -0.08105325f, 0.08311047f, 0.54228866f, 0.34910303f, 
    -0.36117157f, 0.14376064f, -0.01346492f, -0.06453089f, -0.04788846f, 0.10864507f, -0.04298254f, -0.23869111f, 
    0.23058489f, 0.05859117f, 0.14484864f, -0.03896327f, -0.17470981f, 0.04831847f, 0.02278201f, 0.08065327f, 
    0.05960127f, -0.02435647f, 0.03693241f, -0.02433177f, -0.04428079f, -0.00077675f, -0.06089735f, -0.05000495f, 
    -0.00687014f, -0.02004858f, 0.03574848f, -0.01340991f, 0.01341546f, 0.03714802f, 0.02243959f, 0.01627177f, 
    0.04872809f, -0.03504826f, -0.05281546f, -0.01546738f, -0.02250676f, 0.04201941f, -0.03795322f, -0.03020975f, 
    -0.00588386f, -0.02118455f, 0.03771982f, -0.03001630f, 0.00344793f, -0.04948341f, 0.03710924f, 0.01932758f, 
    0.00047575f, -0.03664973f, -0.05372533f, -0.02032496f, 0.00819345f, -0.03954456f, -0.03892246f, -0.02475969f, 
    -0.01669262f, 0.01060616f, 0.00829719f, 0.04061621f, -0.02555753f, -0.06311551f, -0.02291596f, 0.00846762f, 
    0.01832953f, 0.03503988f, -0.04333253f, 0.02728534f, 0.00013384f, 0.01450415f, 0.04810573f, 0.01180263f, 
    -0.01220889f, 0.01001075f, -0.05639597f, 0.00990730f, 0.01451910f, -0.03381412f, -0.06166993f, -0.02320581f, 
    -0.04013182f, -0.03618804f, -0.02338517f, 0.02796547f, 0.01509095f, -0.05318652f, -0.04242707f, -0.06172135f, 
    0.00404519f, 0.01219003f, -0.02573925f, 0.00184113f, -0.05328787f, 0.04916682f, 0.01707751f, -0.04872482f, 
    0.03528909f, -0.06225829f, 0.00537089f, -0.04674357f, -0.06314098f, 0.04090207f, -0.05278783f, -0.00435069f, 
    0.01803852f, -0.00701105f, -0.05283317f, 0.01706553f, -0.01156968f, 0.02218319f, -0.01024266f, -0.03427221f, 
    -0.01639460f, 0.04416646f, 0.03831109f, 0.00741012f, 0.05290824f, -0.04157872f, 0.02290435f, 0.01145066f, 
    0.03902515f, -0.00237607f, -0.03561510f, -0.04893697f, 0.00912124f, -0.04816682f, -0.00905666f, -0.04185507f, 
    0.01832871f, 0.02844171f, -0.01092510f, -0.02013090f, 0.03420529f, -0.01744534f, 0.01769937f, -0.01461654f, 
    -0.05495377f, 0.00975010f, 0.02800894f, -0.00329845f, 0.03648857f, -0.02281268f, 0.01401798f, 0.03304159f, 
    -0.00232473f, -0.04763498f, -0.02859658f, -0.01322574f, -0.00235320f, -0.02475298f, -0.01609916f, -0.04401271f, 
    -0.04297219f, -0.04246292f, 0.01722373f, -0.01767317f, 0.03583205f, -0.00054722f, -0.04988351f, -0.04625255f, 
    -0.03674125f, -0.02183305f, 0.01853558f, -0.02127048f, 0.05209831f, -0.03287587f, -0.01276913f, 0.01735995f, 
    0.01587095f, 0.04342669f, 0.01369307f, 0.01813206f, -0.01626550f, 0.00174001f, -0.04123760f, 0.02893478f, 
    -0.00830380f, -0.00531943f, -0.05177735f, 0.03506502f, -0.01206461f, 0.02299947f, -0.03713133f, -0.00742469f, 
    0.00124620f, 0.00051100f, -0.05573216f, -0.06122933f, -0.01340317f, -0.01212534f, 0.03155761f, 0.00129343f, 
    0.03515451f, 0.05454311f, 0.00687294f, -0.04405272f, 0.02424790f, 0.03841726f, 0.05470583f, -0.02892580f, 
    -0.01289946f, -0.01731813f, -0.05008807f, -0.00869052f, -0.05617879f, 0.05090343f, 0.02266605f, -0.02828766f, 
    0.00485354f, -0.02183707f, -0.05332226f, -0.01345123f, -0.03387355f, -0.00679003f, -0.06288373f, -0.02885693f, 
    0.04503858f, 0.02949027f, -0.00466472f, -0.01443360f, -0.00240707f, 0.02932092f, -0.03014235f, 0.03984941f, 
    0.01188111f, 0.02397276f, 0.05036338f, 0.05644870f, 0.05366544f, -0.04914299f, -0.02682463f, 0.01657261f, 
    -0.02998023f, 0.05058702f, -0.00640754f, 0.01737143f, -0.00070036f, 0.04670462f, -0.04096021f, 0.04116698f, 
    -0.05775521f, 0.01959144f, 0.04233911f, 0.05497935f, -0.01081839f, 0.00880457f, -0.00295101f, 0.04436144f, 
    -0.05196507f, 0.01704565f, -0.05292766f, 0.04482099f, -0.01001985f, -0.03264778f, -0.03019228f, 0.03299341f, 
    -0.04612402f, -0.03451498f, -0.01963423f, -0.00584102f, 0.03220440f, -0.05784311f, 0.01147390f, 0.04762604f, 
    0.01956638f, -0.03239031f, -0.01869154f, -0.00869607f, -0.04042085f, -0.02131916f, -0.04082644f, 0.02202383f, 
    -0.04560052f, -0.03758484f, -0.02777356f, -0.00253770f, 0.03334597f, -0.05352640f, -0.05044562f, -0.03505747f, 
    -0.04269388f, 0.04642260f, -0.03528513f, -0.02542371f, -0.02541563f, 0.01606143f, 0.02301765f, 0.00698592f, 
    -0.03582898f, -0.03668222f, 0.04038318f, -0.04636711f, 0.03395479f, -0.02183789f, -0.02447809f, 0.02821736f, 
    -0.01063069f, -0.00026373f, 0.00352534f, 0.02099467f, 0.04864805f, -0.02286714f, -0.06051064f, -0.05358564f, 
    0.32394901f, 0.10877754f, -0.30011031f, -0.00796089f, -0.03273296f, -0.27216747f, 0.13165474f, 0.01663936f, 
    0.11196321f, 0.42718074f, 0.09584730f, -0.09349766f, -0.12277637f, -0.02671728f, -0.13021949f, 0.06345364f, 
    0.05939120f, 0.21539044f, -0.12835240f, 0.08680516f, 0.05325756f, -0.06732491f, 0.02872590f, -0.08913112f, 
    0.04931590f, -0.11694948f, 0.12229773f, -0.30564311f, -0.01409130f, 0.07044532f, -0.03411105f, -0.00811843f, 
    -0.03336207f, -0.20266126f, 0.09581275f, -0.04254523f, 0.17319024f, -0.05426442f, -0.06659134f, 0.20502029f, 
    -0.08117743f, -0.04333713f, -0.06672326f, 0.05802904f, 0.04926083f, 0.21092676f, 0.15159875f, -0.00713612f, 
    0.07270239f, 0.12085309f, -0.04477795f, -0.07444172f, -0.05645939f, -0.00188191f, 0.12639348f, -0.10766892f, 
    -0.01573474f, 0.05850590f, 0.12249850f, -0.00026864f, -0.07500401f, 0.06119910f, -0.15354078f, 0.09160466f, 
    0.28371471f, 0.13450913f, -0.12143381f, -0.04217003f, -0.00834844f, 0.00568322f, -0.13900857f, 0.13048182f, 
    -0.04720472f, 0.00171476f, -0.11512218f, -0.04016823f, -0.01248918f, -0.00700825f, 0.09528646f, 0.16098693f, 
    0.14539741f, 0.20932141f, 0.03237015f, 0.13799073f, 0.08827782f, 0.13529463f, -0.09263731f, -0.11713494f, 
    -0.07048600f, 0.03012554f, 0.19510490f, -0.03410806f, 0.03055815f, 0.04292345f, -0.12704495f, -0.08036768f, 
    -0.33262441f, 0.00685440f, 0.04355299f, -0.27085242f, -0.04126352f, 0.01652000f, 0.30450079f, -0.14050737f, 
    0.24047141f, 0.04512133f, -0.01938612f, -0.00117116f, 0.30477479f, -0.19443779f, -0.01901758f, 0.08939461f, 
    -0.16677500f, -0.11644739f, -0.10261556f, 0.06315984f, -0.02936367f, -0.01497964f, -0.05649016f, -0.23091668f, 
    -0.16321729f, -0.11408851f, -0.15129372f, 0.26307657f, -0.03456999f, 0.10377607f, 0.18675785f, 0.33454010f, 
    0.16080889f, -0.09613690f, -0.04283577f, 0.04111518f, -0.01827705f, 0.13839704f, -0.01643631f, 0.10982203f, 
    -0.07371017f, 0.10532501f, 0.02261486f, -0.06786899f, -0.07704283f, 0.15483864f, -0.04972460f, -0.08485345f, 
    0.20725977f, -0.13014559f, -0.21120232f, 0.00905308f, 0.06653240f, -0.15490252f, 0.12649868f, -0.02831292f, 
    0.07696143f, 0.27690226f, 0.04512527f, 0.22477028f, 0.11740785f, -0.03780625f, -0.14268005f, 0.06699676f, 
    0.16400877f, 0.09082873f, -0.20893614f, -0.08064289f, 0.17285000f, -0.11323022f, 0.03626788f, 0.02064478f, 
    -0.05070796f, 0.12294000f, -0.11765174f, 0.01554985f, 0.09996558f, 0.01139580f, -0.15401520f, 0.14167649f, 
    -0.21596156f, -0.00115006f, -0.02754177f, -0.15814725f, 0.02260187f, -0.05859768f, -0.17662080f, -0.10715376f, 
    -0.10109819f, 0.01994496f, -0.10737748f, 0.06951047f, 0.11321535f, -0.17942086f, 0.06539852f, -0.14282416f, 
    -0.01942985f, -0.14829174f, -0.10619123f, 0.15808885f, -0.10079643f, 0.15471597f, -0.26775467f, 0.17817138f, 
    0.07019798f, -0.12216777f, 0.01214925f, 0.15744370f, -0.01706742f, 0.08889597f, -0.06403899f, 0.01370217f, 
    0.07286222f, 0.08351605f, -0.24015073f, -0.08605649f, 0.00275740f, -0.06658795f, -0.12600443f, 0.05100250f, 
    0.26223770f, -0.18401115f, 0.14533977f, 0.36561254f, -0.19740909f, 0.09455845f, 0.11169316f, -0.02516418f, 
    -0.19281472f, -0.05927903f, 0.30473945f, 0.14721197f, -0.13789174f, 0.07556736f, -0.07052281f, -0.08047248f, 
    -0.01657047f, -0.15882984f, 0.19544838f, -0.21940462f, 0.18435571f, 0.27530161f, -0.00621535f, -0.03347902f, 
    0.04505082f, -0.29904774f, -0.14853337f, -0.05953522f, -0.14462297f, 0.32748967f, -0.08311310f, -0.12122440f, 
    0.02541927f, 0.01930136f, -0.11937010f, -0.18246651f, 0.10422274f, -0.09052616f, 0.07969663f, 0.12792277f, 
    0.10150890f, -0.12219529f, -0.07320995f, 0.17734170f, -0.20332718f, 0.12692448f, 0.23955604f, 0.06023330f, 
    -0.10749295f, -0.11119636f, -0.15066026f, 0.01287084f, -0.04840754f, 0.17878905f, -0.06774914f, 0.13640985f, 
    0.16071510f, -0.12012301f, 0.04601834f, -0.03885030f, -0.16884343f, 0.06267775f, -0.09844223f, 0.14294459f, 
    -0.26249349f, 0.09221251f, -0.07918390f, 0.06835482f, -0.01690589f, 0.07352635f, -0.04791277f, 0.05946206f, 
    -0.00847542f, 0.05315273f, -0.05019192f, 0.00782974f, 0.03790514f, 0.01081367f, 0.03141799f, 0.03766610f, 
    -0.02355517f, 0.00783546f, 0.00423322f, -0.04114739f, -0.05912404f, -0.02112122f, 0.03719297f, 0.01040619f, 
    0.03968225f, -0.07133784f, -0.04035176f, 0.00328060f, 0.02826126f, -0.05811520f, -0.01380526f, 0.01942052f, 
    -0.06176198f, 0.03926669f, 0.03478887f, 0.00249658f, -0.06500905f, 0.02338525f, -0.07748985f, 0.02174515f, 
    0.01975968f, 0.03952685f, -0.01411810f, -0.03674971f, -0.02835421f, 0.01105452f, -0.03318032f, -0.07391205f, 
    -0.01239373f, -0.02493230f, 0.00149417f, -0.06966115f, -0.01002957f, -0.02759025f, 0.02360984f, -0.03302075f, 
    -0.04122550f, -0.02934067f, 0.00824091f, 0.00853268f, -0.01832600f, 0.04025986f, -0.03241524f, -0.03414487f, 
    -0.07039820f, -0.01306888f, 0.03973964f, 0.00676689f, -0.01371532f, -0.06012405f, 0.04239365f, -0.03854869f, 
    0.01159907f, 0.02077940f, -0.01081044f, -0.02846295f, 0.03158602f, -0.05766020f, -0.05889115f, -0.01970484f, 
    -0.04638787f, 0.01290615f, 0.01425614f, -0.02686027f, -0.05831411f, -0.05647794f, -0.01998477f, 0.00757644f, 
    0.01179735f, 0.02728662f, 0.00212190f, -0.08124465f, 0.00086992f, -0.01027813f, -0.02715095f, 0.00536472f, 
    0.01593264f, -0.04562690f, 0.03799416f, -0.06320694f, -0.07370555f, -0.00552680f, 0.03366608f, -0.01144167f, 
    -0.03628706f, 0.04698365f, -0.05372551f, -0.01892594f, -0.04165116f, 0.00390399f, 0.02559541f, -0.06097038f, 
    0.00809665f, -0.03655207f, 0.03561607f, -0.04419774f, -0.01922479f, -0.03397615f, 0.00148509f, -0.04905354f, 
    0.03513849f, 0.00104515f, -0.00935380f, -0.00819117f, 0.01135812f, -0.01195778f, -0.04600131f, 0.03925111f, 
    -0.05901253f, -0.03396582f, 0.01635615f, 0.02358200f, 0.01761505f, -0.06634618f, 0.01289416f, -0.04133481f, 
    0.00739780f, 0.01191481f, 0.01920195f, -0.07243431f, -0.05103110f, -0.04805401f, 0.01040977f, 0.02214800f, 
    -0.02949199f, 0.03382084f, -0.00914533f, -0.00283021f, -0.01730481f, -0.00144798f, 0.00094678f, 0.03441369f, 
    0.01141233f, 0.03240434f, -0.02414172f, -0.05729116f, 0.01037321f, -0.07292945f, -0.03386174f, 0.04339720f, 
    0.00303832f, 0.01351232f, -0.04813267f, -0.01389780f, 0.01149176f, 0.04529911f, -0.02119059f, -0.05536704f, 
    0.01745816f, 0.05053037f, -0.07409199f, -0.07832697f, -0.01700391f, -0.02711339f, -0.06541740f, 0.03933806f, 
    -0.02862593f, 0.00623565f, -0.02359979f, 0.02906587f, 0.02886103f, 0.01788804f, -0.00893037f, 0.04319913f, 
    0.03862602f, -0.05723353f, -0.02024939f, -0.03474490f, 0.00878333f, 0.02012848f, 0.00041946f, 0.02957477f, 
    -0.04044670f, -0.00953478f, -0.02017743f, 0.00637847f, 0.01179756f, -0.03304005f, -0.05676352f, 0.00648142f, 
    -0.00044843f, -0.03339189f, -0.07154668f, -0.03361282f, 0.02693675f, -0.02356947f, -0.05689110f, -0.02504982f, 
    -0.00802772f, -0.03375015f, -0.07473688f, 0.00847255f, 0.01475692f, -0.01764751f, -0.03285635f, -0.04950088f, 
    -0.05224026f, -0.07570617f, -0.05935420f, -0.04548932f, -0.03509648f, -0.03790465f, -0.06378724f, 0.00592312f, 
    -0.07832561f, -0.00354651f, -0.06204278f, 0.01168284f, 0.04692734f, -0.01454072f, -0.07645231f, 0.02697005f, 
    0.01260896f, -0.00421614f, -0.01940412f, -0.03408815f, -0.02261697f, 0.03127931f, -0.01114243f, -0.07608421f, 
    0.01672027f, -0.06669234f, 0.00956572f, 0.04963904f, -0.04372484f, 0.05363065f, -0.05168996f, -0.04201025f, 
    0.03606883f, 0.01575250f, 0.02032262f, 0.03007100f, 0.01923635f, 0.03214427f, -0.01482559f, -0.01839943f, 
    -0.01716892f, -0.03221206f, -0.04273458f, -0.06483452f, -0.02068365f, 0.00869514f, 0.00685328f, 0.01478943f, 
    0.01209746f, 0.04047434f, -0.02320358f, -0.03121428f, 0.03905424f, -0.04030046f, -0.02426013f, -0.02611900f, 
    -0.04976524f, -0.07725342f, 0.03463012f, -0.00899987f, -0.05629787f, -0.05327882f, 0.03351492f, -0.01610176f, 
    -0.00635821f, 0.01447553f, -0.04470605f, 0.02606412f, 0.04684475f, -0.02740900f, -0.05218552f, 0.03540380f, 
    0.01625107f, -0.04351979f, -0.05037992f, 0.02754764f, -0.01931054f, -0.02608864f, -0.03779071f, -0.03136839f, 
    0.15081006f, -0.05104529f, -0.02751207f, 0.10657374f, 0.10386991f, -0.11653151f, -0.08205370f, 0.09869628f, 
    -0.16536312f, 0.10050263f, 0.02527096f, -0.14534362f, 0.05891312f, 0.17024814f, 0.00040150f, -0.06037346f, 
    0.11953501f, -0.07241867f, 0.00776224f, -0.19248310f, -0.04738799f, -0.10817092f, -0.01801887f, 0.00978101f, 
    0.03441915f, 0.00152863f, 0.00546068f, -0.22501530f, 0.04508043f, 0.09230383f, -0.08962083f, -0.02337792f, 
    0.08854770f, -0.24075471f, 0.26989767f, 0.16366063f, 0.08894069f, -0.12453107f, 0.03560248f, -0.06787943f, 
    -0.08186134f, -0.00328122f, 0.07326550f, 0.01934946f, 0.06326719f, 0.02445707f, -0.13206461f, -0.18550065f, 
    0.00393174f, 0.03262668f, 0.10393808f, -0.00883209f, 0.15125406f, -0.06220444f, -0.07961711f, 0.11487581f, 
    -0.19083326f, -0.02987188f, -0.01035970f, 0.15462443f, 0.14765516f, 0.22755061f, -0.24634436f, 0.03779544f, 
    -0.16462712f, -0.12211357f, -0.02988592f, -0.13753034f, 0.00623131f, -0.25211802f, 0.00092821f, -0.11171047f, 
    0.16182265f, 0.10620716f, -0.05762190f, 0.13233258f, 0.10488982f, -0.03816404f, -0.00562040f, -0.02096534f, 
    -0.08858312f, 0.03009278f, -0.06891737f, -0.12318455f, -0.11648995f, 0.15317154f, -0.00706816f, -0.12122948f, 
    0.02726880f, -0.06122375f, -0.15804400f, 0.04849718f, -0.04137077f, 0.01340370f, -0.00240606f, 0.23062356f, 
    -0.03368731f, 0.12624544f, 0.03739766f, -0.15054391f, 0.02921412f, 0.04450770f, 0.15034518f, 0.05557375f, 
    -0.02507148f, 0.09763008f, -0.01798276f, 0.17906475f, 0.06006743f, 0.03143973f, -0.00935836f, -0.04333848f, 
    0.04533787f, -0.07856394f, 0.04446942f, 0.13132846f, 0.09561171f, 0.15411726f, -0.04730617f, 0.01480443f, 
    -0.05647767f, 0.08361833f, -0.12855844f, 0.09872186f, 0.04028820f, 0.07227680f, -0.13022956f, 0.08494082f, 
    -0.04987663f, -0.06653821f, -0.09337904f, 0.10560536f, -0.19474305f, -0.03198919f, 0.01834983f, -0.05920121f, 
    0.17104459f, 0.02738348f, -0.01499619f, 0.19461308f, 0.03860247f, -0.00679668f, -0.02428151f, -0.13085112f, 
    0.10795820f, 0.20899981f, 0.01386795f, -0.16705543f, -0.04409886f, -0.03011088f, 0.03490660f, 0.08251267f, 
    -0.08923294f, -0.05652119f, -0.12827796f, -0.02533430f, 0.12901297f, 0.04604165f, 0.10540321f, -0.30730891f, 
    0.03501602f, -0.08734892f, -0.08559687f, -0.09249519f, 0.16265628f, -0.10425892f, 0.07781875f, 0.19470081f, 
    -0.07300701f, 0.13977705f, 0.00846367f, -0.38249153f, -0.03723975f, 0.01170357f, -0.12716666f, 0.09142142f, 
    -0.16596587f, 0.16548604f, 0.00363221f, -0.21107082f, 0.12383594f, 0.04191269f, 0.02423511f, 0.02794587f, 
    0.07443785f, 0.02442734f, -0.18836598f, 0.13183299f, 0.04558483f, 0.30280143f, -0.05160717f, 0.10021488f, 
    -0.23301470f, -0.04032188f, 0.03407606f, 0.11997992f, 0.05482551f, 0.16350900f, -0.28185141f, -0.08240095f, 
    0.15728630f, -0.01272442f, 0.19053100f, 0.03928461f, -0.12733346f, 0.02636377f, -0.11773287f, -0.02992502f, 
    0.12469684f, 0.12001289f, -0.27245188f, -0.00932055f, 0.06024921f, 0.15077475f, 0.08241951f, -0.16075611f, 
    0.30907974f, 0.01986808f, -0.09059626f, -0.01638623f, -0.09362408f, -0.12695301f, 0.05413155f, 0.12620707f, 
    0.05346954f, 0.12254860f, -0.02891113f, -0.17070395f, -0.00338614f, 0.05084935f, 0.01709465f, 0.02410960f, 
    -0.03651013f, 0.02040256f, 0.31726801f, -0.09241200f, 0.00670624f, 0.01388689f, 0.08824321f, -0.00259213f, 
    0.11868862f, 0.02367181f, 0.09300856f, -0.24178371f, 0.19427460f, -0.01001529f, -0.06264141f, 0.05493778f, 
    -0.04253123f, 0.03695122f, -0.16990155f, -0.17078261f, -0.25538743f, -0.10291067f, -0.04025825f, -0.01821990f, 
    0.19443539f, 0.03135681f, -0.15508544f, 0.01632734f, -0.15090553f, 0.12334231f, 0.00354059f, -0.07481469f, 
    -0.04611555f, 0.07090759f, 0.00273418f, 0.16696207f, 0.05542247f, -0.03290140f, -0.08836003f, 0.02907932f, 
    -0.03107733f, 0.01040079f, 0.20769121f, -0.10318633f, 0.09215871f, -0.04777242f, -0.06004957f, -0.24488574f, 
    -0.11059944f, -0.07082709f, 0.05768729f, 0.05904107f, 0.07173498f, 0.17784441f, -0.04005477f, -0.23464207f, 
    0.31331465f, 0.06939320f, -0.14294356f, 0.10665604f, -0.00429169f, -0.00253516f, -0.12207910f, 0.10215230f, 
    0.00143265f, 0.21366806f, 0.27994239f, 0.06864013f, 0.19787751f, -0.02934072f, 0.07027769f, -0.08064429f, 
    0.13049057f, 0.08289403f, 0.05129165f, -0.10277943f, 0.22021891f, 0.14510047f, 0.19976132f, 0.00153851f, 
    -0.04384493f, 0.04445474f, 0.06890513f, 0.06933765f, 0.02075861f, -0.17074239f, 0.02377154f, -0.14657007f, 
    -0.16269271f, 0.12534060f, -0.00197216f, -0.24694352f, 0.37751943f, 0.20289938f, -0.14542878f, 0.16044429f, 
    0.02550989f, 0.18828902f, -0.13087374f, 0.08051741f, 0.13687512f, -0.79685032f, -0.37563390f, 0.16344056f, 
    -0.07325412f, 0.09396809f, -0.04633407f, 0.07468557f, -0.15750344f, 0.07729727f, -0.10898264f, -0.08128823f, 
    0.08353848f, -0.09427069f, 0.00237020f, -0.07367716f, 0.16159658f, -0.00181148f, 0.15106925f, -0.10593473f, 
    0.13711339f, 0.05220501f, 0.11535756f, 0.10439751f, -0.04137299f, -0.07922422f, -0.02614504f, 0.08765427f, 
    -0.06077342f, 0.09604183f, 0.13700335f, 0.15324984f, 0.00353727f, 0.13070276f, 0.11582331f, 0.12844545f, 
    0.03943877f, -0.61174178f, -0.33015159f, 0.15649812f, 0.20431140f, 0.10856460f, 0.03355410f, -0.04777356f, 
    -0.09411462f, -0.05940603f, 0.02736604f, -0.02991422f, -0.18186098f, 0.08990280f, -0.05628535f, 0.09517554f, 
    -0.16341242f, 0.06227624f, -0.02009188f, -0.31977966f, -0.24164663f, -0.00504405f, 0.09841073f, 0.20470545f, 
    0.02643166f, -0.07895497f, -0.10710149f, 0.10012325f, -0.04983223f, -0.05963749f, -0.10643331f, -0.05761998f, 
    -0.00348491f, 0.00659401f, -0.04243934f, 0.15236861f, 0.24888101f, 0.14695004f, -0.17707843f, -0.04919776f, 
    0.15283781f, 0.06510710f, 0.21455581f, 0.05367624f, -0.04651774f, -0.11034637f, 0.07470299f, 0.14883488f, 
    -0.26377064f, 0.09840688f, 0.08335003f, -0.14873624f, 0.10775773f, 0.03629369f, -0.00947622f, -0.09501474f, 
    -0.32835445f, 0.13198052f, 0.18438216f, -0.06684255f, -0.02883532f, -0.02948820f, -0.19786094f, -0.02157292f, 
    0.22057308f, 0.10271608f, 0.12548839f, 0.04957872f, -0.08759034f, -0.08314081f, 0.04751119f, 0.01251298f, 
    -0.06551837f, -0.35257334f, -0.18784246f, -0.26962733f, -0.11014117f, -0.06640658f, -0.16900489f, -0.03155556f, 
    0.06777750f, 0.05429051f, 0.27050695f, -0.00005457f, -0.02436431f, -0.02835722f, -0.01251524f, 0.16053343f, 
    0.11961117f, 0.03207085f, -0.02894553f, -0.29215360f, -0.32160321f, -0.04585765f, 0.01421119f, -0.06380169f, 
    0.02249349f, 0.12718609f, 0.00542004f, 0.04373913f, 0.00937872f, 0.02909498f, -0.08186834f, -0.19404507f, 
    -0.09832183f, 0.10871302f, -0.05951345f, 0.07549851f, 0.30260104f, 0.16327436f, -0.15564442f, -0.04523890f, 
    -0.06643935f, 0.07152936f, 0.00513478f, 0.12130284f, -0.15470694f, 0.04180606f, 0.12008746f, 0.18885538f, 
    -0.08662240f, 0.05555202f, 0.13963087f, 0.08229130f, -0.11217672f, 0.07877726f, -0.03515810f, 0.32897413f, 
    0.15188521f, -0.21420494f, -0.01565773f, 0.14835632f, -0.05186250f, 0.09377290f, -0.08478084f, 0.18944463f, 
    -0.34143478f, 0.07647981f, -0.06100890f, 0.28357098f, 0.00735364f, 0.12554777f, 0.00659829f, -0.01492011f, 
    -0.00686731f, -0.09874250f, 0.27851960f, -0.06156423f, -0.06287675f, -0.06056287f, -0.09239825f, -0.11064132f, 
    0.07800646f, 0.07797690f, -0.65415490f, -0.39357093f, -0.17028631f, 0.11776163f, 0.00252324f, 0.02826514f, 
    -0.13583063f, -0.07722411f, -0.11516680f, -0.08372255f, -0.01999122f, 0.07876568f, -0.08282793f, -0.02403675f, 
    0.02913823f, 0.08297125f, 0.03738749f, 0.00871364f, -0.20580372f, -0.51587015f, 0.13459988f, -0.05023739f, 
    0.05809234f, -0.08362819f, -0.09901533f, 0.14899082f, 0.23926480f, -0.07356103f, 0.12689701f, -0.04604560f, 
    -0.02759926f, -0.10525411f, -0.02719335f, -0.13550399f, 0.26650774f, 0.20332462f, 0.23056467f, 0.09926927f, 
    0.01744936f, 0.03614882f, -0.07498786f, -0.04740283f, 0.16505194f, 0.02283616f, 0.12453414f, -0.86924553f, 
    0.06633888f, -0.23538293f, -0.05673169f, -0.01924240f, -0.02077626f, -0.01004710f, 0.07239456f, 0.06401941f, 
    0.04120832f, 0.04390440f, 0.03315537f, -0.04481509f, 0.04428767f, -0.05286571f, -0.02291230f, -0.06140363f, 
    -0.01083564f, 0.04648336f, 0.03500719f, -0.03938283f, 0.00617903f, -0.04979525f, -0.05621880f, -0.04291839f, 
    -0.05455732f, -0.01551232f, 0.00790175f, 0.04058908f, -0.03332634f, -0.04302751f, -0.05561125f, 0.02316063f, 
    0.01563252f, 0.00501384f, -0.06598219f, -0.04059925f, -0.05978350f, 0.03168834f, -0.03153317f, -0.06900169f, 
    0.02353991f, -0.04460526f, -0.00162602f, -0.02514754f, -0.05584228f, 0.04340842f, -0.02769621f, 0.00169895f, 
    -0.02560768f, 0.03008881f, -0.03028055f, -0.05633572f, 0.03314441f, -0.07278759f, 0.04401919f, -0.04902237f, 
    -0.03438986f, 0.00784635f, -0.03339738f, 0.00322607f, -0.01425421f, 0.05348063f, -0.03138280f, -0.04471672f, 
    -0.05585112f, 0.03853622f, -0.05585318f, -0.04530114f, -0.00740198f, 0.05014496f, 0.05265278f, -0.06014799f, 
    0.02973678f, -0.00812248f, 0.01336951f, 0.02740901f, 0.03524080f, -0.03668651f, -0.00725466f, 0.01584127f, 
    -0.05755958f, -0.00936021f, 0.02790800f, 0.01383939f, -0.00826848f, -0.04565658f, 0.03384323f, -0.06088647f, 
    0.03351659f, 0.03900274f, -0.06464806f, -0.01145289f, 0.04209154f, -0.05707034f, -0.00599830f, -0.02616364f, 
    -0.02194477f, -0.03798722f, -0.05216821f, -0.02664518f, 0.03230221f, 0.01562625f, 0.05214698f, -0.00129514f, 
    0.01192707f, 0.00647947f, -0.02239759f, -0.01134101f, -0.04474473f, 0.00864070f, -0.00458708f, 0.04776139f, 
    0.03499497f, -0.04544653f, 0.00388428f, -0.00666278f, 0.03306462f, 0.04507365f, -0.00738176f, -0.02300985f, 
    0.04834639f, -0.05325000f, -0.05970194f, -0.05720593f, -0.01472457f, -0.00628690f, -0.05377988f, -0.04983085f, 
    -0.01143463f, -0.02285160f, -0.02898610f, 0.02265259f, -0.04200825f, -0.00760535f, -0.00884767f, -0.03164629f, 
    -0.01577451f, -0.04075049f, 0.03307213f, -0.04788709f, 0.05166623f, 0.03763036f, -0.00671980f, -0.04302326f, 
    0.04857577f, 0.02709872f, -0.02182464f, 0.02060925f, 0.00517782f, 0.00954905f, 0.02088063f, 0.00124048f, 
    -0.00864021f, -0.01965711f, -0.00315631f, -0.05866281f, 0.03068067f, 0.02872405f, 0.02819741f, -0.00742846f, 
    0.04067664f, -0.00693363f, 0.02236572f, -0.00388213f, 0.00442729f, -0.02918766f, -0.00649186f, -0.06142909f, 
    -0.01686513f, 0.04763303f, 0.01607119f, -0.04110994f, -0.02724040f, -0.01262461f, 0.05217552f, 0.04104000f, 
    0.01456492f, -0.02469614f, 0.01487864f, -0.04807924f, -0.04968467f, -0.04969832f, -0.02533988f, -0.06067262f, 
    -0.06363063f, -0.00081579f, -0.05315369f, 0.00545615f, -0.05900986f, 0.04948078f, -0.05449551f, 0.01979158f, 
    -0.02607036f, -0.00759440f, 0.02197475f, -0.03033359f, 0.02829453f, 0.03601546f, -0.00181774f, -0.04390297f, 
    -0.04923812f, -0.02000802f, 0.04155710f, -0.05176684f, 0.02689078f, 0.04030449f, 0.01768987f, -0.02359427f, 
    -0.03592027f, -0.00927580f, 0.00177511f, -0.00791158f, -0.02514117f, -0.00000230f, 0.00012536f, -0.03295424f, 
    -0.06534851f, -0.05787776f, -0.02110244f, 0.01555358f, 0.04513975f, 0.02337349f, -0.01336231f, -0.05001399f, 
    -0.03422150f, 0.00123605f, 0.03918265f, -0.06311416f, 0.03744409f, -0.04088127f, -0.05050998f, 0.01306834f, 
    -0.05444881f, -0.01031424f, -0.04093317f, -0.03225357f, -0.02078927f, 0.00422466f, -0.04907806f, 0.00033622f, 
    -0.03288322f, -0.05709742f, 0.00961105f, 0.03433764f, 0.03339906f, -0.04193703f, -0.05581347f, -0.06258210f, 
    0.00156251f, 0.05500516f, 0.00531579f, -0.00492315f, -0.06031663f, 0.05035160f, -0.03529874f, -0.02397683f, 
    -0.02724446f, -0.02112034f, 0.00041897f, 0.04197955f, -0.03508894f, -0.00065177f, -0.01594942f, 0.01311150f, 
    0.01328129f, -0.06680325f, 0.01608813f, -0.05080914f, -0.04466392f, -0.04259450f, -0.03392612f, -0.03880702f, 
    -0.03847203f, -0.04192617f, 0.03882483f, 0.04516461f, 0.05292221f, -0.02196309f, 0.02967118f, -0.02819357f, 
    0.04952901f, 0.05201506f, 0.00082376f, 0.02716425f, -0.04365758f, 0.03390376f, -0.00328546f, 0.04620862f, 
    0.01337923f, -0.03907623f, -0.04021218f, 0.03912134f, -0.01915019f, -0.04730352f, -0.02647096f, -0.06015671f, 
    -0.27376398f, 0.39225930f, 0.06882256f, -0.02820678f, -0.11650115f, 0.09641808f, -0.06837093f, 0.00229236f, 
    0.03015483f, 0.02721022f, 0.06084447f, 0.16769099f, -0.08339091f, -0.03116257f, -0.04941813f, -0.13577144f, 
    -0.14085677f, 0.04770943f, 0.22563758f, -0.17691359f, -0.53766567f, -0.12987885f, 0.02259556f, 0.12153452f, 
    -0.02989268f, -0.16450801f, -0.06857602f, 0.20961565f, -0.01742461f, 0.27583185f, 0.03314263f, -0.17534402f, 
    0.01657347f, 0.08004691f, 0.05264032f, 0.23359598f, -0.00939063f, -0.01824291f, -0.39818630f, 0.03699275f, 
    -0.18550698f, 0.11732563f, -0.06992587f, -0.09887088f, -0.05146709f, 0.19307420f, -0.12750551f, -0.22308765f, 
    -0.18887404f, 0.03749321f, -0.05569924f, 0.20281452f, -0.11042001f, 0.01718153f, 0.24009429f, -0.08053283f, 
    -0.02916680f, 0.00790982f, -0.02009409f, -0.07220822f, -0.10726385f, 0.08479717f, 0.19782653f, 0.19539031f, 
    -0.03589573f, -0.07602912f, -0.08434031f, 0.17221415f, -0.04513522f, 0.14462742f, -0.01929291f, -0.02315444f, 
    -0.02948375f, 0.04066985f, 0.11127392f, -0.08638905f, -0.18618059f, -0.02513031f, 0.00283976f, -0.07436451f, 
    0.00851540f, -0.16547297f, -0.07965165f, -0.18100351f, -0.00388028f, 0.08852553f, 0.05612523f, 0.05932349f, 
    0.03935930f, 0.00229094f, 0.13716263f, -0.06991444f, 0.23592216f, -0.09445177f, 0.12887327f, -0.01706696f, 
    -0.12631978f, -0.00661844f, -0.09721014f, 0.03735033f, 0.07638285f, 0.29731292f, -0.12228445f, 0.11605285f, 
    0.08582245f, -0.05018575f, -0.00832531f, -0.00857142f, 0.07164613f, -0.00552168f, -0.21976061f, 0.02877646f, 
    -0.03615672f, 0.00268336f, -0.00836801f, -0.14383523f, 0.17335522f, -0.52179390f, 0.06664166f, 0.05668696f, 
    0.18647978f, 0.01367373f, -0.09290453f, -0.11292119f, 0.10176850f, -0.15661818f, 0.20982966f, -0.27856755f, 
    0.08712797f, -0.00188028f, 0.02332733f, -0.04085473f, 0.15430491f, -0.08156156f, 0.11250579f, -0.05398192f, 
    -0.28340566f, -0.04242747f, 0.03701673f, 0.10445546f, 0.06304332f, -0.06393518f, 0.13133918f, 0.09426405f, 
    -0.24244173f, -0.13730323f, -0.27298483f, -0.11714835f, 0.02418925f, -0.00218251f, 0.01788376f, 0.02413332f, 
    -0.02504562f, 0.19191480f, 0.14577790f, -0.01210043f, 0.08171515f, 0.15629004f, -0.08651469f, 0.29560155f, 
    -0.11675161f, -0.01641457f, -0.00069489f, -0.06007458f, 0.20529372f, 0.11554569f, -0.03586808f, 0.07500033f, 
    -0.11935782f, -0.01750547f, 0.05643806f, -0.00690184f, -0.00880221f, -0.08327805f, -0.10211994f, 0.05983306f, 
    0.05301566f, -0.01344737f, -0.09435251f, 0.22947019f, -0.21427728f, 0.15238757f, 0.03352854f, 0.05188960f, 
    -0.01124276f, -0.00040495f, -0.07192405f, -0.14219625f, 0.19398834f, -0.05121575f, 0.06794973f, -0.00286582f, 
    -0.06269018f, -0.08339049f, 0.07528911f, 0.11082956f, 0.00221714f, 0.04453268f, 0.04697074f, 0.00781399f, 
    -0.08030713f, 0.04407405f, 0.05088992f, -0.05294305f, 0.17357163f, 0.11013401f, -0.07258001f, -0.07400984f, 
    -0.20380355f, -0.27867198f, 0.31712797f, -0.11922646f, -0.04966750f, 0.09342223f, 0.05822353f, 0.04505742f, 
    -0.32158574f, -0.06448013f, -0.18467931f, 0.09486204f, -0.03027192f, 0.00309283f, -0.16638426f, -0.18178993f, 
    0.02790843f, 0.12275995f, 0.12205026f, 0.55421048f, 0.21057363f, 0.02949723f, 0.00697783f, 0.08733218f, 
    -0.03125636f, 0.11120504f, -0.28988740f, 0.13971375f, 0.02308678f, 0.08373524f, -0.09232162f, 0.10419669f, 
    -0.10719509f, -0.03377270f, 0.04098668f, -0.28722367f, -0.18838073f, 0.07778887f, -0.05106054f, 0.11660638f, 
    -0.10234272f, 0.17662290f, 0.00551222f, -0.08633404f, 0.12375672f, -0.15535188f, 0.03484751f, 0.14440729f, 
    -0.03642926f, 0.01055344f, 0.15253420f, -0.05473387f, 0.11679778f, 0.18823087f, -0.20475696f, 0.24175137f, 
    0.01795207f, -0.06040353f, 0.25671500f, -0.06421831f, 0.06148515f, 0.03844087f, -0.04403701f, -0.14512666f, 
    0.15970647f, -0.16701563f, 0.14689948f, -0.05125274f, 0.08699480f, 0.02624460f, 0.13944861f, 0.27250630f, 
    0.09639870f, 0.05100683f, 0.10016885f, 0.00022570f, 0.10233025f, 0.03181843f, 0.11739439f, 0.07897665f, 
    -0.00358511f, -0.06467719f, -0.03055396f, -0.03601533f, -0.00711413f, 0.00129479f, -0.04817788f, 0.00377552f, 
    -0.01945299f, 0.05002679f, 0.00283517f, -0.01798491f, -0.03322471f, -0.00774824f, 0.01155279f, -0.00591143f, 
    -0.05747071f, 0.03388996f, -0.05437550f, 0.00103724f, 0.00025415f, 0.02378327f, 0.01716491f, 0.03763223f, 
    0.00367847f, -0.03298651f, -0.02716103f, -0.02684632f, -0.01097272f, -0.02205803f, 0.02623589f, 0.02750036f, 
    0.03257959f, 0.03304495f, 0.01683751f, 0.03309856f, -0.04695930f, -0.00215263f, 0.00261184f, 0.04697966f, 
    0.00442185f, -0.03329749f, -0.03013477f, 0.03062310f, -0.06317750f, 0.00625973f, -0.02580480f, 0.03049627f, 
    -0.00478522f, 0.02176495f, -0.02577073f, -0.01587516f, -0.03367049f, 0.01985589f, -0.06367137f, -0.01289745f, 
    -0.00998396f, 0.01790880f, -0.01366456f, -0.02986757f, -0.04182157f, 0.04545519f, 0.04672693f, -0.04684177f, 
    0.02063858f, 0.03461584f, 0.04597482f, -0.05407699f, -0.03057619f, -0.04000414f, 0.02586631f, -0.03970992f, 
    -0.03682703f, 0.05086330f, 0.03437661f, -0.01452059f, 0.03503118f, 0.02013765f, 0.04792823f, -0.06526358f, 
    -0.02262005f, -0.00657777f, -0.05892092f, -0.04176290f, 0.03235020f, -0.05322144f, 0.02071375f, -0.03819634f, 
    0.03190457f, 0.05720874f, -0.05502657f, 0.05040157f, -0.03409078f, -0.01578612f, -0.02829746f, 0.04553270f, 
    -0.01929014f, -0.05549362f, 0.03865197f, -0.04599284f, 0.03542548f, -0.04038992f, -0.06226215f, -0.01246137f, 
    0.05076822f, -0.02417940f, -0.00883000f, -0.00505203f, 0.04743432f, -0.02442559f, 0.04517775f, -0.03794613f, 
    -0.05212299f, -0.01511500f, 0.01375743f, -0.03817482f, 0.00418905f, -0.06341883f, 0.01306032f, 0.04410493f, 
    0.02988241f, 0.01804099f, -0.03786154f, 0.02252890f, -0.01641120f, 0.02464564f, -0.04452280f, -0.02358122f, 
    0.00462428f, -0.04484756f, -0.00252176f, -0.01278070f, 0.00546965f, -0.06176091f, -0.03125633f, -0.00169695f, 
    -0.01167987f, -0.03505941f, 0.00090250f, 0.03329572f, -0.04137338f, -0.00663398f, -0.04215989f, -0.05631066f, 
    0.05351030f, 0.00595229f, -0.05842920f, -0.02534664f, 0.03866571f, 0.00609497f, -0.05226064f, 0.00435553f, 
    -0.02706459f, -0.03108294f, -0.01978726f, -0.03419820f, 0.05189446f, 0.03560396f, 0.01788582f, -0.00386635f, 
    -0.01679471f, -0.03535391f, -0.00167847f, -0.00412639f, -0.01224255f, 0.04805194f, 0.03179957f, -0.04808390f, 
    0.02220219f, -0.01939023f, 0.01713934f, -0.00354349f, 0.04648983f, -0.03411695f, 0.00793732f, 0.01132288f, 
    0.05465614f, 0.05152937f, 0.02210441f, 0.03936816f, -0.05850675f, -0.05809869f, 0.01432924f, -0.03575755f, 
    0.00195308f, -0.03374495f, -0.03565111f, 0.04687310f, 0.03147903f, -0.01708420f, -0.02551281f, -0.05901519f, 
    -0.05836908f, 0.00249692f, -0.06138621f, 0.01538147f, 0.04385079f, 0.03226730f, -0.03605235f, 0.01082496f, 
    -0.00582575f, -0.03390133f, 0.03343869f, -0.02422270f, -0.03998628f, -0.02190884f, 0.05391727f, 0.00099848f, 
    0.00843434f, -0.00233487f, -0.02583462f, 0.02036957f, -0.05576612f, 0.02058404f, -0.05341259f, -0.02987781f, 
    -0.00350760f, -0.00486304f, 0.04364158f, 0.02855438f, 0.05204374f, -0.05009134f, 0.03218651f, -0.00616381f, 
    -0.01028194f, 0.00042808f, 0.04739029f, -0.01266312f, -0.00711817f, -0.00803255f, -0.01652593f, -0.00400480f, 
    0.01986142f, -0.00454571f, -0.00336345f, -0.00487092f, 0.04684589f, -0.00993395f, 0.02044215f, 0.04579603f, 
    -0.06438542f, -0.04512378f, 0.03138188f, -0.03375655f, -0.04656105f, 0.00079421f, 0.00163252f, -0.04114446f, 
    -0.06179699f, -0.01059533f, -0.03971362f, 0.00671907f, -0.03843483f, 0.04426954f, -0.01126854f, -0.02223672f, 
    -0.06654810f, 0.03833424f, -0.01419270f, 0.03168213f, 0.02600975f, -0.01619716f, 0.05048820f, 0.00534351f, 
    0.03119651f, 0.00897153f, -0.05545751f, -0.04734255f, -0.02617569f, 0.02418322f, 0.02219037f, -0.00697000f, 
    -0.02428296f, -0.02392439f, -0.06414278f, -0.01157503f, 0.05253427f, -0.05902884f, 0.04879297f, 0.00085118f, 
    -0.04412936f, -0.03771956f, 0.00350902f, 0.00333394f, -0.01692046f, 0.01756527f, 0.04259320f, -0.01711120f, 
    -0.10980817f, -0.25654140f, 0.23145981f, 0.06206777f, 0.02800301f, -0.10672565f, -0.01839109f, -0.10203535f, 
    -0.12251571f, -0.12398077f, -0.15736444f, -0.07733085f, -0.04672331f, 0.12409698f, -0.04196488f, 0.13043322f, 
    0.06750404f, -0.08761907f, -0.10062565f, 0.12454142f, -0.03289388f, -0.03296126f, -0.01759859f, 0.00763905f, 
    0.22824138f, -0.02803628f, 0.18101504f, 0.19129115f, 0.03996129f, -0.16043395f, -0.02548199f, 0.15135925f, 
    -0.16741538f, 0.05320251f, -0.07556503f, 0.05841609f, -0.41131082f, -0.31275764f, 0.14641832f, -0.05212237f, 
    0.06743006f, -0.00808903f, -0.20725690f, 0.00881397f, 0.03838091f, -0.17704885f, -0.00538461f, 0.06528212f, 
    0.00767074f, -0.01441421f, 0.12963057f, 0.25678629f, 0.00098345f, -0.02789262f, 0.09690853f, -0.05403001f, 
    0.10213045f, -0.17062174f, 0.04453930f, -0.08438183f, 0.15735362f, -0.00292054f, 0.08411141f, -0.35098052f, 
    -0.11509010f, -0.01065448f, -0.18240017f, -0.00100594f, -0.03779412f, -0.07675415f, 0.07394990f, -0.07957821f, 
    0.22448851f, -0.05682035f, -0.02561933f, -0.07853559f, -0.04049073f, -0.00876712f, -0.07169757f, 0.03892653f, 
    0.06428720f, -0.10419329f, -0.00374369f, -0.20160083f, 0.06743080f, -0.03447916f, 0.12761807f, 0.12729040f, 
    0.00476293f, -0.02638756f, -0.16012920f, -0.21950831f, 0.06766964f, 0.06684025f, 0.10008246f, 0.01087333f, 
    0.00942129f, -0.02323328f, 0.01264986f, 0.26148337f, -0.01862955f, 0.07743222f, 0.04586063f, -0.00505153f, 
    0.22950894f, 0.00896176f, 0.11668134f, 0.19338028f, 0.19853973f, -0.20268577f, 0.10911731f, -0.00089172f, 
    0.10781114f, -0.08127699f, 0.10366127f, -0.05350088f, -0.21634410f, -0.15143333f, 0.02993278f, -0.10646859f, 
    0.08768950f, 0.06477110f, 0.17648056f, 0.05577348f, 0.02215710f, 0.05513442f, -0.24669479f, -0.40380526f, 
    0.14164998f, 0.02131682f, 0.04675570f, -0.10952406f, -0.11590341f, 0.07527362f, 0.19491956f, 0.04699744f, 
    0.15760326f, -0.24406655f, 0.01238003f, -0.02822736f, 0.05765743f, 0.17823079f, 0.03552358f, 0.08167603f, 
    -0.17935142f, -0.18754666f, -0.08797049f, -0.10764898f, 0.13972779f, -0.03434017f, 0.11445238f, 0.01547811f, 
    -0.08014753f, -0.32175562f, -0.17763771f, 0.18680196f, -0.20149577f, -0.06626215f, -0.16815898f, -0.02782073f, 
    0.07276318f, -0.04941439f, -0.09662573f, 0.11262120f, -0.13951169f, 0.20581520f, 0.13323557f, -0.03500316f, 
    0.10875326f, 0.07246755f, 0.01402995f, 0.16486275f, 0.10221605f, 0.00365200f, 0.04744296f, -0.01181750f, 
    -0.04532956f, 0.12598778f, -0.06845357f, -0.01741091f, -0.20595187f, -0.18581034f, 0.10127877f, 0.01478581f, 
    -0.11230788f, 0.08028646f, -0.07598558f, -0.02140850f, 0.03257584f, 0.12714313f, 0.09371438f, -0.09777040f, 
    -0.01081282f, -0.08255113f, -0.01086108f, 0.12199290f, 0.16672798f, -0.00144808f, -0.02393086f, 0.03999592f, 
    -0.04895060f, 0.25822148f, 0.09107998f, -0.09010771f, 0.06128860f, 0.05963568f, 0.10751335f, -0.45586956f, 
    -0.14116369f, 0.12206214f, 0.24387217f, 0.02851475f, 0.02590336f, 0.01055426f, -0.18399398f, 0.08837295f, 
    0.39402503f, -0.29916504f, -0.11345822f, -0.15208657f, -0.24828170f, 0.02646416f, 0.12146381f, -0.08925645f, 
    -0.02132202f, -0.01366226f, 0.09373774f, 0.06623793f, 0.19617289f, 0.02440851f, -0.10064783f, 0.12209789f, 
    -0.04156681f, -0.07204481f, 0.26150081f, -0.00556224f, 0.15168166f, -0.08020630f, 0.00978815f, 0.15103664f, 
    0.10845181f, 0.06203563f, -0.00771836f, 0.00403343f, 0.06778447f, -0.19122349f, 0.03351900f, 0.02025843f, 
    0.16172168f, -0.06640840f, 0.02328856f, -0.09779502f, -0.23868616f, -0.02245907f, 0.04760211f, 0.16401768f, 
    0.08902265f, 0.08003071f, -0.14509165f, 0.05063207f, -0.07580674f, 0.04372297f, 0.04746792f, -0.15176781f, 
    0.19585307f, -0.09746849f, 0.04214161f, 0.10019281f, -0.02200017f, 0.03905376f, 0.41438633f, 0.14702182f, 
    -0.22063594f, 0.17582375f, -0.08604491f, -0.07895648f, 0.05327028f, -0.12091429f, 0.18922850f, -0.08056015f, 
    0.14329201f, 0.32309401f, -0.07014988f, -0.07770389f, 0.00062773f, -0.00516908f, -0.12640299f, 0.08442806f, 
    0.12855712f, 0.15751491f, -0.10667683f, -0.05999664f, -0.03118465f, 0.06365765f, 0.12736854f, -0.20911334f, 
    0.08297286f, -0.02383793f, 0.04681602f, -0.09209660f, 0.02159079f, 0.03846650f, -0.05155291f, -0.18507405f, 
    -0.05775990f, 0.06822030f, -0.00915946f, -0.33894622f, -0.09763923f, -0.00883364f, 0.11531886f, -0.01901784f, 
    0.10978023f, 0.03056685f, 0.10476072f, 0.41677573f, 0.27042714f, 0.23952781f, 0.17619413f, 0.03514182f, 
    0.00173985f, -0.04901635f, -0.03486848f, 0.19248080f, 0.00120017f, -0.29393137f, -0.15741286f, -0.09653296f, 
    -0.07669539f, -0.04428520f, -0.07327966f, 0.07542088f, 0.09714514f, -0.27497905f, 0.04741383f, 0.00303128f, 
    0.07902626f, -0.02186798f, -0.06149584f, 0.04871444f, 0.01955597f, 0.07151692f, -0.00697616f, 0.03898706f, 
    -0.27509362f, -0.08734277f, -0.02084465f, -0.12976450f, 0.04460106f, 0.05309774f, 0.09953153f, 0.04620670f, 
    0.02653182f, -0.11096078f, 0.05633678f, -0.07892871f, -0.01518638f, 0.02343682f, 0.07564032f, 0.17401828f, 
    0.07007048f, 0.04150455f, -0.00919850f, -0.08504738f, -0.08180750f, 0.15814759f, 0.15789327f, -0.07284459f, 
    0.06324986f, 0.05403207f, -0.28617683f, 0.08260716f, 0.05946259f, -0.18339987f, -0.02674376f, 0.10762646f, 
    0.05647129f, -0.06518848f, 0.12227266f, 0.29988024f, -0.04112694f, 0.08066510f, 0.02235490f, 0.03868441f, 
    0.07874203f, 0.13773981f, 0.10494569f, -0.00661901f, 0.21295777f, 0.20481585f, -0.00356051f, 0.01901147f, 
    0.05297471f, 0.00008421f, 0.15826076f, -0.04080537f, -0.17861013f, -0.07783916f, -0.00594235f, -0.07102170f, 
    0.05936977f, -0.02615741f, -0.16692060f, -0.00444642f, -0.01155519f, 0.10011590f, 0.01233402f, 0.05596948f, 
    -0.02440512f, -0.06791467f, -0.08546339f, -0.11510044f, -0.03474593f, 0.03487296f, 0.02653713f, 0.12305845f, 
    -0.13356823f, 0.07565025f, -0.02260444f, -0.15735634f, -0.05150535f, 0.09834936f, 0.03020151f, -0.19376528f, 
    -0.06367851f, 0.15672287f, -0.14653407f, 0.02366459f, 0.01527114f, 0.05262425f, -0.01536392f, 0.00358359f, 
    -0.53281844f, 0.05908659f, -0.04201989f, 0.05961274f, -0.23869143f, 0.03762995f, -0.02679724f, 0.04758178f, 
    -0.06848511f, -0.07561346f, 0.28523165f, -0.13314916f, 0.00626508f, -0.09549472f, -0.18973416f, -0.09824484f, 
    -0.03100869f, -0.07310753f, 0.22882089f, 0.10871994f, 0.05884758f, 0.06905993f, 0.09696203f, -0.06161128f, 
    0.00903068f, 0.09543118f, 0.01475033f, -0.05053748f, 0.00745490f, -0.21337071f, 0.08375907f, 0.07958101f, 
    -0.06498583f, -0.01653816f, -0.11496075f, -0.02805076f, -0.05217140f, 0.16093941f, -0.02654477f, -0.12473323f, 
    0.01210345f, -0.22060570f, -0.11213949f, 0.11350866f, 0.02725801f, 0.59217072f, -0.15132658f, -0.03679071f, 
    -0.10714336f, 0.10915219f, -0.13779081f, 0.00838416f, 0.10820002f, -0.00278610f, 0.24456155f, 0.04909410f, 
    0.05257168f, 0.10843299f, 0.00812716f, -0.06291378f, -0.01695585f, 0.07619090f, -0.16901974f, 0.10005042f, 
    -0.07152590f, 0.08107105f, -0.02013516f, -0.10148627f, -0.00224549f, -0.07989334f, -0.00624536f, 0.05199222f, 
    -0.29406637f, -0.22423184f, -0.11804405f, -0.19910429f, 0.09639358f, -0.14057167f, -0.03011336f, -0.01467700f, 
    0.08725315f, 0.06300548f, 0.19310296f, 0.27472812f, 0.16503035f, 0.09453203f, -0.17165636f, -0.03316906f, 
    0.14101160f, 0.02471824f, -0.47692990f, -0.16759114f, 0.10807241f, -0.05984869f, 0.02188571f, -0.02810906f, 
    -0.11901554f, 0.06495615f, -0.08953899f, -0.09687905f, 0.17065692f, -0.03213844f, 0.10062815f, 0.11487316f, 
    -0.14205164f, 0.01851061f, 0.02320111f, -0.02478056f, -0.18141526f, 0.05855061f, 0.05431080f, -0.14214782f, 
    -0.09983378f, -0.06108188f, 0.21290269f, -0.04047693f, 0.08251543f, -0.04178360f, -0.03271486f, 0.09620950f, 
    -0.01609154f, 0.03092085f, 0.08747348f, -0.15297221f, 0.01630614f, 0.06279541f, 0.04470356f, 0.09612303f, 
    0.05933137f, 0.03081698f, 0.04121486f, 0.01661167f, -0.03729283f, -0.05497972f, 0.11285384f, -0.05749385f, 
    0.02655236f, 0.03316084f, 0.04744331f, 0.08458524f, -0.06183926f, -0.08726106f, 0.06580433f, 0.05518655f, 
    -0.08778278f, 0.14471871f, -0.18300144f, 0.06230651f, -0.08729600f, -0.05861275f, 0.16293707f, 0.07988402f, 
    0.07157697f, -0.20310463f, -0.04899855f, -0.08078936f, -0.05495166f, 0.03650795f, -0.04569299f, -0.19814566f, 
    -0.04382723f, -0.15222871f, 0.00328330f, -0.03893920f, -0.17501701f, -0.10178970f, -0.03868736f, -0.11818732f, 
    -0.09577669f, 0.02651758f, -0.02941420f, 0.32266712f, 0.42921278f, 0.29412520f, 0.12697314f, -0.02358188f, 
    0.26581636f, -0.00276861f, 0.13053291f, -0.13211490f, -0.46599302f, -0.25588149f, 0.01678395f, 0.02981777f, 
    -0.08387718f, -0.06474347f, -0.00580040f, 0.06726345f, -0.04298139f, -0.06517600f, 0.10207541f, -0.10854230f, 
    0.12224968f, 0.04261121f, -0.04341142f, -0.02864322f, -0.04091350f, -0.00323536f, 0.12727511f, 0.09213335f, 
    -0.03256723f, -0.06594001f, 0.15000683f, -0.17208466f, 0.06063509f, 0.07347182f, 0.03322217f, 0.06319205f, 
    -0.02338207f, -0.16531533f, -0.02642360f, 0.03656192f, 0.07322524f, -0.00602154f, -0.13810515f, -0.02635202f, 
    0.06865504f, 0.14018212f, -0.02357906f, 0.08989310f, -0.00385752f, 0.04097463f, -0.17839600f, -0.00333745f, 
    -0.05361499f, 0.06498645f, 0.19137889f, -0.18902172f, -0.15595876f, 0.18257226f, -0.12444115f, -0.14677930f, 
    -0.03393795f, -0.02199057f, -0.04996889f, 0.34241611f, 0.13755596f, -0.03711565f, -0.01285808f, -0.04039475f, 
    0.20931238f, 0.05530131f, -0.09405794f, 0.17258431f, 0.08193904f, 0.16700959f, -0.00944469f, 0.06828908f, 
    -0.17255156f, -0.23739961f, 0.14060712f, 0.12345834f, -0.34976381f, -0.06080623f, 0.05032288f, -0.04091426f, 
    0.07515121f, 0.01702883f, 0.00057875f, -0.01056208f, -0.09502456f, -0.20542242f, 0.00024024f, 0.11158624f, 
    -0.00650182f, -0.11120445f, 0.01493980f, -0.03412870f, -0.00394996f, -0.11166532f, -0.09872400f, 0.03605107f, 
    -0.02818950f, -0.04012254f, 0.06246627f, -0.01535907f, 0.19406852f, 0.09787632f, -0.10124888f, 0.03325733f, 
    0.15166783f, -0.11129157f, -0.04913551f, -0.12030646f, 0.02323281f, 0.02383933f, 0.04823528f, 0.02400397f, 
    0.11821221f, 0.03438436f, 0.15749350f, 0.05651353f, -0.02098023f, -0.10568957f, -0.07291918f, 0.02728663f, 
    0.03561911f, -0.24347284f, 0.29091433f, 0.05011389f, -0.05929996f, -0.08305931f, 0.00672797f, -0.03633113f, 
    0.03405563f, 0.15523830f, 0.04026185f, 0.14885657f, 0.11661595f, 0.17007838f, -0.05791843f, 0.01489658f, 
    0.02755003f, 0.07864571f, 0.06943708f, 0.04811057f, 0.08535884f, -0.11811357f, 0.13029508f, 0.02495715f, 
    -0.15432622f, -0.05093160f, 0.14950022f, 0.06172478f, -0.07372811f, 0.36132684f, -0.00707351f, -0.01214533f, 
    -0.21155407f, 0.08254758f, 0.13790065f, -0.02271599f, -0.11570905f, 0.08273906f, 0.10173889f, -0.18820971f, 
    0.07810880f, 0.10302222f, -0.09721664f, -0.02468397f, 0.11463506f, -0.10491257f, 0.17877217f, 0.11696192f, 
    0.09265573f, 0.02908853f, -0.08341774f, 0.12774904f, 0.26970455f, -0.05967926f, 0.18988124f, -0.02826180f, 
    -0.22590600f, 0.00481874f, 0.03984211f, 0.11317703f, -0.11384548f, -0.03228218f, 0.09124642f, -0.10729214f, 
    -0.26663554f, 0.15297429f, -0.21936759f, -0.06872040f, 0.06620130f, 0.05077357f, -0.16366619f, 0.10996322f, 
    0.04358789f, 0.17855841f, 0.22146873f, 0.00868121f, 0.10791120f, 0.05645588f, 0.06846774f, 0.14608802f, 
    -0.03675862f, 0.10919427f, -0.15141472f, 0.09272123f, -0.12383340f, 0.00423596f, -0.10308451f, 0.02008787f, 
    0.02241091f, 0.03968666f, 0.02084378f, 0.07060433f, -0.02383572f, -0.10646290f, 0.20072973f, -0.03391456f, 
    -0.13122207f, 0.07209128f, -0.14321576f, 0.11055002f, 0.21854700f, 0.00266302f, -0.18126573f, 0.10161940f, 
    -0.03802526f, 0.11257271f, 0.07373244f, -0.03343015f, -0.02594669f, 0.20158598f, 0.02311021f, -0.00511083f, 
    -0.14169632f, 0.00590685f, 0.04104180f, 0.10093559f, 0.08499620f, -0.05130630f, 0.13587742f, 0.12747002f, 
    0.04217430f, 0.08101608f, 0.11107191f, 0.01022283f, 0.16626272f, -0.16222969f, 0.08526927f, 0.01328531f, 
    0.20187980f, -0.01141831f, -0.10432966f, 0.02974964f, 0.02244067f, 0.00273610f, -0.02230187f, 0.10725524f, 
    -0.05951687f, 0.10720702f, -0.02450999f, -0.18692420f, 0.11651917f, -0.13018052f, -0.01002410f, 0.15696582f, 
    0.19649614f, -0.24088022f, -0.13771816f, 0.20217644f, 0.03886664f, 0.08495954f, -0.05679683f, -0.14020158f, 
    0.00723542f, -0.03152588f, -0.03713734f, -0.10880885f, 0.08945731f, -0.16468585f, 0.05401621f, -0.01696474f, 
    -0.07319544f, 0.19335045f, 0.10250850f, 0.00039928f, -0.10479271f, 0.11634199f, 0.10299201f, -0.02401242f, 
    0.15936472f, -0.00911357f, -0.15074919f, 0.01788948f, 0.02597091f, -0.08036173f, 0.07600942f, -0.08683796f, 
    -0.05805106f, -0.09165009f, -0.04369868f, 0.06684459f, 0.07283125f, -0.14903335f, -0.01560238f, 0.14575508f, 
    -0.02110166f, 0.11191755f, 0.05648599f, 0.23090504f, 0.16946726f, 0.12502381f, -0.01102339f, -0.04309862f, 
    -0.18662338f, 0.24181813f, 0.03755504f, -0.04993324f, -0.13829945f, 0.09602240f, -0.07317521f, -0.01669336f, 
    -0.16073936f, 0.06756152f, -0.02032804f, 0.38139063f, -0.08172806f, -0.11363858f, 0.06887784f, 0.01243396f, 
    0.08879571f, 0.00181565f, -0.02081185f, -0.01793480f, 0.12504084f, -0.00630407f, 0.29989681f, 0.10913138f, 
    0.16927366f, -0.13695493f, 0.14560491f, 0.24143913f, -0.03473425f, 0.06059954f, 0.07278991f, 0.36284918f, 
    -0.07580902f, -0.10101178f, -0.17010768f, 0.05683433f, 0.02578688f, 0.29352033f, -0.06046406f, 0.01386893f, 
    0.11924498f, -0.11352925f, -0.06450810f, -0.09329572f, -0.06380687f, 0.07950739f, -0.08078226f, 0.08472356f, 
    -0.15201376f, 0.02719743f, -0.02401802f, 0.23109855f, -0.24795957f, 0.06947773f, 0.02138195f, 0.27685311f, 
    -0.05218384f, -0.05275407f, -0.09613561f, 0.09553121f, 0.06519154f, 0.08666475f, 0.31701976f, 0.02883775f, 
    -0.25078213f, 0.15779123f, -0.09127906f, 0.07277639f, 0.00764314f, 0.14038515f, 0.12126436f, 0.12472950f, 
    0.00278901f, 0.09569154f, -0.03499395f, 0.13790627f, 0.07531742f, 0.06221904f, -0.14225698f, -0.22970143f, 
    0.01260964f, 0.12055475f, -0.09723788f, 0.00663576f, 0.16040608f, 0.32495400f, 0.06516408f, -0.02438211f, 
    -0.18554039f, -0.12916937f, 0.17220882f, -0.04791070f, 0.12069505f, -0.06992372f, -0.05832446f, 0.10211827f, 
    0.10571343f, -0.37212852f, 0.15613478f, 0.04385093f, 0.26637173f, -0.02248750f, 0.14904648f, 0.16760592f, 
    0.12547271f, -0.05768248f, 0.19001128f, 0.04328001f, -0.05428450f, 0.14178503f, -0.03565157f, 0.05433103f, 
    0.11377056f, -0.05253940f, 0.06078450f, -0.16032700f, -0.08382671f, -0.16403262f, 0.02423277f, 0.06811498f, 
    0.13868326f, 0.12291794f, 0.08798590f, -0.08161816f, -0.13784665f, 0.17170353f, 0.15110293f, 0.22716138f, 
    -0.00746204f, 0.13736007f, 0.14960741f, -0.04928174f, 0.08735894f, 0.16145092f, -0.10172881f, 0.05636286f, 
    -0.04650787f, -0.04064734f, -0.03346929f, -0.05752182f, -0.00043170f, 0.16346152f, -0.07813119f, 0.06272613f, 
    -0.18283850f, 0.01696086f, 0.08374799f, -0.03096623f, -0.06650913f, 0.00171216f, -0.05546925f, 0.06030352f, 
    -0.18035220f, 0.07444192f, 0.01930389f, -0.06769964f, -0.00724424f, -0.13371947f, 0.14612147f, -0.03869849f, 
    -0.21854441f, -0.14218439f, 0.18310450f, -0.39155290f, -0.11519749f, -0.12658213f, -0.03295821f, 0.09092426f, 
    -0.06107952f, -0.18870875f, -0.07211202f, 0.06355565f, 0.09619948f, 0.14433818f, 0.02404575f, 0.07444729f, 
    -0.09925915f, -0.04893273f, -0.42861333f, 0.14186913f, 0.09098725f, -0.04387191f, 0.01967938f, 0.20099321f, 
    0.20105983f, 0.15719563f, -0.04462539f, -0.12319798f, -0.02989764f, -0.08516922f, 0.11676593f, -0.03401989f, 
    0.16047491f, 0.09589447f, -0.11665487f, 0.02217601f, -0.26295799f, 0.02822524f, -0.03401130f, 0.13783866f, 
    0.40400252f, 0.04206331f, 0.10642542f, -0.14962763f, 0.09991048f, 0.01025348f, 0.00189213f, 0.05567736f, 
    0.14588001f, 0.01280027f, 0.06773506f, -0.13947532f, 0.11343658f, -0.06337927f, 0.01345059f, 0.11257458f, 
    -0.01630285f, -0.02689005f, 0.01446191f, 0.16574624f, 0.06188166f, -0.12086393f, -0.07775465f, -0.48781377f, 
    0.12010130f, 0.09866342f, 0.26326269f, 0.02861060f, 0.19175798f, 0.18279830f, 0.23265272f, -0.08124064f, 
    0.25124079f, -0.06958655f, -0.17994297f, -0.09813920f, -0.21800759f, -0.01376075f, 0.06865135f, -0.16913576f, 
    -0.00272363f, 0.02701509f, 0.25044638f, -0.06944222f, 0.03510850f, -0.00230396f, 0.00003599f, -0.04216981f, 
    0.20670201f, -0.15703720f, 0.22081123f, -0.18903156f, 0.24567926f, -0.01319364f, -0.13829502f, 0.15071702f, 
    0.02602302f, -0.09818202f, 0.05106959f, -0.15918578f, -0.00454645f, -0.20670049f, -0.04647122f, 0.04238580f, 
    0.14496499f, 0.02999055f, -0.08195253f, 0.00642949f, -0.02230352f, 0.03747327f, 0.09143553f, -0.00052084f, 
    -0.10408952f, -0.15089804f, -0.03558960f, 0.06855757f, -0.26345906f, -0.21780758f, 0.08821071f, 0.29914862f, 
    -0.07913168f, 0.03849474f, 0.02310071f, 0.06898696f, 0.04301775f, -0.12646994f, 0.11290225f, -0.06046867f, 
    0.01262220f, 0.18406604f, 0.03960525f, 0.08599035f, 0.00780354f, -0.03676822f, 0.13100344f, 0.15522139f, 
    0.00625958f, -0.36695340f, -0.05062808f, -0.17464027f, 0.07241420f, -0.02659492f, -0.03808547f, 0.07337363f, 
    0.21817227f, -0.03592581f, -0.07231269f, 0.17205942f, 0.03282427f, -0.16249008f, -0.00716504f, 0.06027422f, 
    0.13048486f, -0.24607119f, -0.10943989f, 0.60896635f, 0.11730975f, 0.13816434f, 0.00447419f, 0.00185697f, 
    -0.08589949f, -0.04658104f, -0.11398720f, -0.06724872f, 0.14620292f, 0.03256586f, 0.05467017f, 0.08885905f, 
    -0.06601551f, 0.11996798f, 0.05075287f, 0.00825124f, -0.13769673f, 0.12775880f, -0.13009040f, 0.09367770f, 
    0.03396614f, -0.10676086f, -0.09075680f, 0.23092011f, 0.02895218f, 0.11754259f, -0.05020121f, 0.00760722f, 
    -0.09770595f, -0.05091076f, -0.10596405f, 0.10581049f, -0.00461349f, 0.44106850f, 0.20508210f, 0.11577632f, 
    -0.00179610f, -0.06011705f, -0.18941197f, 0.03151001f, -0.01756349f, 0.06246821f, 0.01077819f, 0.23546976f, 
    -0.14538071f, 0.00316666f, -0.09552504f, -0.02793332f, -0.01903439f, -0.06116035f, -0.04293877f, -0.29715732f, 
    0.06441049f, 0.10636386f, 0.07627808f, 0.23527047f, 0.14335409f, 0.03325746f, -0.07701182f, -0.10071772f, 
    0.14363509f, 0.13302273f, 0.11080710f, -0.09982638f, -0.20314391f, 0.04422633f, -0.20282477f, 0.23603271f, 
    -0.07315626f, -0.42439294f, 0.21046014f, -0.09537014f, -0.03789826f, -0.02994282f, 0.07746999f, -0.03556358f, 
    -0.05097817f, -0.14250018f, 0.12434664f, -0.20132922f, -0.18987918f, -0.03904544f, -0.03965620f, 0.18864390f, 
    0.05604126f, 0.07953187f, 0.08442470f, -0.07666070f, -0.03810927f, -0.21789949f, 0.00280148f, -0.15254405f, 
    0.02330486f, 0.04471771f, 0.04743606f, -0.07288226f, 0.11978539f, 0.11552703f, 0.00322695f, 0.08417778f, 
    0.03644717f, -0.04033126f, -0.00163932f, 0.06679863f, -0.18325500f, 0.61147082f, 0.00690057f, 0.12259492f, 
    -0.08057180f, 0.01996010f, 0.01522719f, 0.00001014f, 0.13835922f, -0.01252574f, -0.11655129f, -0.22732255f, 
    -0.13532481f, 0.02611324f, 0.06881092f, 0.14961797f, -0.04414221f, -0.12474438f, 0.04256162f, 0.16661523f, 
    -0.11308411f, 0.20093344f, 0.28166813f, -0.05775470f, -0.07613587f, -0.12105863f, 0.13081741f, -0.23099270f, 
    -0.30098566f, -0.28557858f, 0.23422153f, 0.12130675f, 0.03683612f, -0.09640574f, 0.03332644f, -0.01240151f, 
    -0.04048245f, -0.05304535f, -0.26475677f, 0.14422248f, -0.07214582f, 0.08541038f, -0.06720533f, 0.02920868f, 
    -0.07826050f, -0.01880707f, -0.37606561f, 0.15766968f, 0.39543116f, 0.05052316f, 0.04758268f, 0.08977686f, 
    -0.06588146f, -0.02362373f, -0.04470170f, -0.02029095f, 0.11256988f, -0.16117072f, 0.01094101f, 0.15995534f, 
    0.22115125f, 0.10052199f, -0.17597905f, 0.19942200f, -0.08079465f, -0.01115422f, -0.26918307f, 0.03650933f, 
    0.04989323f, 0.06411167f, -0.06049583f, -0.24339654f, -0.15873855f, 0.21621317f, -0.00379570f, 0.02862216f, 
    0.09971906f, 0.00454508f, -0.05358929f, 0.08402734f, 0.04029374f, -0.09892323f, 0.10434933f, -0.09893967f, 
    -0.12713590f, -0.02496175f, 0.04253520f, -0.02766118f, 0.04946325f, 0.01870544f, 0.02337389f, -0.35473344f, 
    0.10617889f, 0.03206877f, -0.14304586f, 0.03554135f, 0.02852722f, 0.06079912f, -0.00983869f, -0.12376158f, 
    -0.16275637f, -0.07893672f, 0.03255921f, 0.10944142f, 0.01903890f, -0.00162584f, 0.05561629f, -0.18724810f, 
    -0.02258172f, -0.12005318f, -0.08722688f, -0.00980754f, 0.17093897f, 0.11972555f, 0.27820459f, 0.09208043f, 
    -0.02205787f, -0.05233947f, -0.13579981f, 0.19346137f, 0.23365758f, 0.03795177f, 0.05304935f, 0.20946550f, 
    -0.05483116f, -0.12247223f, 0.12682645f, -0.12998296f, 0.00589243f, -0.23215474f, 0.07619940f, -0.08533911f, 
    0.21474077f, 0.06038843f, 0.05273048f, -0.14302051f, -0.20462926f, 0.08193927f, -0.04147931f, -0.04451112f, 
    -0.08857700f, 0.15615402f, 0.06783052f, -0.11567102f, 0.28440908f, -0.11841304f, 0.07830520f, 0.26817906f, 
    -0.08878737f, 0.13136142f, 0.02694769f, 0.03399149f, 0.05319504f, 0.03821192f, -0.15021537f, -0.10686195f, 
    0.02509788f, 0.04706636f, 0.00844708f, -0.03544805f, -0.15410089f, -0.08971728f, 0.16423437f, -0.24045643f, 
    -0.19336508f, -0.02930644f, 0.04531152f, 0.14560214f, -0.05843300f, -0.01714984f, -0.05962821f, 0.00230631f, 
    0.14503536f, -0.19790505f, -0.06349403f, 0.03591206f, 0.05542749f, 0.16355696f, -0.07794119f, 0.06521668f, 
    0.11850315f, 0.22537054f, 0.16353635f, 0.06189416f, -0.20698351f, -0.05543366f, -0.01138902f, -0.10913210f, 
    0.07049122f, 0.03483786f, 0.04671593f, -0.25989360f, -0.10789837f, 0.18334423f, 0.03193292f, 0.15071353f, 
    -0.06034036f, -0.02978364f, -0.04751927f, 0.15872400f, 0.01306959f, -0.17755744f, 0.10670363f, -0.05961202f, 
    0.11410400f, -0.02195727f, -0.14622319f, 0.21781333f, -0.11615272f, -0.35102060f, 0.11669233f, 0.07596706f, 
    0.09739468f, -0.06477512f, 0.11310039f, -0.01874374f, 0.06491356f, 0.19398928f, -0.05064524f, -0.16132131f, 
    0.05768998f, 0.18974470f, 0.14279705f, -0.20712410f, -0.05335587f, -0.10987596f, -0.14703815f, -0.33070183f, 
    -0.04952519f, 0.15359126f, 0.12191540f, -0.20850272f, 0.04127007f, -0.01991074f, 0.01356406f, 0.17462511f, 
    0.19400913f, -0.07727126f, 0.11873247f, -0.16573590f, 0.17880961f, 0.14557683f, -0.05254603f, -0.13213435f, 
    -0.27071562f, -0.02149275f, -0.12497339f, 0.05814701f, -0.06805499f, -0.04817529f, -0.09815640f, -0.02197975f, 
    -0.16640130f, 0.15141362f, -0.23928772f, 0.08585582f, -0.31962502f, -0.11284315f, -0.20561761f, -0.00684454f, 
    0.07228564f, 0.00330194f, -0.09059168f, 0.10200863f, -0.13341638f, 0.02212287f, 0.09854060f, -0.07554417f, 
    -0.00980146f, 0.10295055f, -0.04708606f, -0.17644073f, -0.09794693f, -0.04554557f, 0.22337459f, 0.00761749f, 
    -0.00093240f, -0.06261648f, 0.09382854f, 0.17795412f, -0.38091701f, -0.25488558f, -0.03702803f, -0.02206795f, 
    0.04066257f, 0.17220491f, -0.03602218f, -0.03245761f, 0.02042591f, -0.11802515f, -0.10549421f, -0.37033796f, 
    0.04252053f, 0.08564559f, 0.11009609f, 0.07295822f, 0.01153634f, 0.07012317f, 0.12934494f, 0.21849781f, 
    -0.09091673f, -0.01674457f, 0.12389682f, -0.10068824f, 0.12854752f, -0.07714892f, -0.06660828f, -0.28861135f, 
    -0.06311809f, -0.29213047f, 0.02636574f, 0.09864479f, -0.11110920f, 0.08321332f, 0.11474918f, 0.02115437f, 
    0.08209933f, 0.12678178f, -0.18535139f, 0.12279554f, -0.37912345f, 0.18635948f, -0.00964074f, -0.11954685f, 
    0.18627356f, 0.18001400f, 0.46151420f, 0.10325579f, -0.04368689f, 0.04105503f, -0.01123225f, 0.06228129f, 
    0.04971341f, 0.01917694f, 0.19048133f, -0.03391224f, -0.07182536f, -0.07704456f, -0.16807339f, 0.04433031f, 
    -0.00838333f, 0.03355855f, -0.03804718f, -0.09179270f, 0.10264697f, -0.17682323f, 0.16868654f, -0.15622886f, 
    -0.15479602f, 0.07112373f, 0.01090579f, 0.12479086f, -0.08305244f, -0.12346431f, 0.28881899f, 0.01522902f, 
    -0.03286633f, -0.24790104f, 0.08293149f, 0.06762208f, -0.08414375f, -0.10224883f, 0.26183873f, -0.03794061f, 
    0.00878878f, 0.07026730f, 0.08646842f, 0.13700132f, 0.02264754f, -0.04134019f, 0.24461204f, 0.22215585f, 
    -0.05031044f, -0.00660106f, -0.03044712f, -0.03749291f, 0.00166907f, 0.04516011f, -0.07846864f, 0.09681360f, 
    0.10406179f, 0.25467238f, -0.16146417f, -0.04462219f, -0.27959034f, 0.01681872f, 0.03167043f, 0.07598502f, 
    -0.06027681f, -0.05598436f, -0.00698979f, 0.04614336f, -0.03208873f, -0.02279026f, -0.00792998f, -0.01446078f, 
    -0.01653561f, 0.03016148f, 0.03042710f, -0.01552042f, 0.02057181f, 0.02770580f, -0.04476007f, -0.04827329f, 
    0.01346669f, -0.04922833f, 0.06215451f, -0.01640203f, 0.04082914f, -0.02302507f, 0.01785038f, -0.03965876f, 
    0.01803062f, 0.02358146f, -0.03269156f, -0.01226166f, 0.03101333f, -0.04800339f, -0.00139746f, -0.00320041f, 
    -0.01315993f, -0.05620072f, 0.00604865f, 0.05534815f, -0.03700215f, 0.00888732f, 0.02695388f, -0.06881406f, 
    0.02527113f, -0.00101485f, -0.03549886f, -0.06310154f, -0.03408701f, 0.00005452f, 0.02111225f, -0.06383051f, 
    -0.03130625f, 0.01223879f, 0.03567775f, -0.01524134f, -0.01982722f, -0.03063950f, 0.04655281f, 0.04456642f, 
    -0.06207880f, 0.01421728f, -0.07606678f, -0.04406940f, 0.00829105f, -0.05473998f, 0.04443219f, 0.03902446f, 
    -0.05900974f, -0.05924688f, 0.01676741f, 0.03440025f, -0.04831119f, 0.01280355f, -0.03758485f, 0.03272595f, 
    -0.02648482f, -0.03475654f, -0.06397118f, -0.06960773f, -0.01831139f, -0.05209814f, 0.02626241f, 0.02946798f, 
    -0.00617457f, -0.05930458f, -0.03862953f, -0.06901787f, -0.04576415f, -0.04192995f, -0.01321798f, -0.03436589f, 
    0.02499235f, -0.00454391f, -0.00951742f, -0.00454046f, 0.00380310f, -0.00570711f, -0.01237418f, 0.03850001f, 
    -0.06587818f, 0.00934716f, -0.05329588f, 0.05217967f, -0.02299052f, 0.00001719f, 0.03031345f, -0.06952489f, 
    0.01809968f, 0.06378741f, 0.00729387f, -0.02059238f, 0.03448024f, 0.02984514f, -0.06441496f, 0.00907085f, 
    -0.00461730f, 0.01134482f, -0.00748223f, -0.00073234f, 0.02127172f, 0.01735796f, -0.04832183f, 0.03502571f, 
    -0.06438659f, 0.01179395f, -0.05371717f, -0.02202299f, -0.03357075f, 0.05342989f, 0.01673959f, 0.03471467f, 
    0.04819291f, 0.04754011f, 0.04894219f, -0.04661307f, -0.02313355f, -0.00056814f, 0.01087881f, 0.01834906f, 
    -0.00066549f, -0.02718982f, -0.00598369f, -0.01349779f, 0.01189696f, -0.01422843f, 0.03968826f, -0.05569176f, 
    0.03464792f, -0.00776155f, -0.02219248f, -0.05177817f, -0.06899941f, 0.03568787f, 0.02683087f, -0.05167098f, 
    -0.06015453f, -0.03156224f, 0.00197063f, -0.04287228f, -0.00086130f, -0.03131304f, -0.06262202f, 0.02393692f, 
    0.02671496f, -0.01081680f, 0.01637722f, -0.04292714f, -0.02822311f, -0.06433287f, -0.06614541f, 0.01610442f, 
    -0.02153452f, -0.05971782f, 0.03728724f, 0.01321311f, -0.00119445f, 0.03417407f, 0.03166154f, 0.04067586f, 
    -0.01718968f, -0.03513218f, 0.01439347f, -0.01087279f, 0.03324024f, 0.02487276f, -0.04990299f, -0.05597613f, 
    0.02583482f, -0.06623083f, -0.05364499f, -0.05705829f, -0.00943187f, 0.00469145f, 0.00296994f, -0.04986627f, 
    0.01807331f, -0.01052232f, 0.03117357f, -0.00175896f, -0.00288936f, -0.01567171f, 0.02769631f, -0.01107201f, 
    -0.03359497f, -0.02749151f, -0.04153313f, 0.02303776f, -0.06715769f, 0.04833755f, -0.03050068f, 0.04337277f, 
    -0.06610467f, -0.05964191f, -0.04413167f, -0.06366248f, -0.00289418f, 0.02155772f, 0.03504558f, 0.01265570f, 
    0.04456372f, -0.03132098f, 0.04434329f, -0.04001844f, 0.01012586f, 0.01235094f, -0.02191309f, -0.03130624f, 
    -0.06174825f, 0.01114996f, -0.01507680f, -0.04392769f, -0.02660966f, -0.04256976f, 0.01245813f, 0.03076310f, 
    -0.00492081f, -0.01761511f, -0.01213922f, -0.03418037f, -0.01461473f, 0.02270561f, -0.03641675f, -0.01119710f, 
    0.03931813f, -0.04921564f, 0.02643734f, -0.03981043f, -0.02055327f, -0.02878489f, -0.00610924f, 0.02970563f, 
    -0.01625442f, -0.02814937f, -0.00885018f, -0.02065095f, -0.03645976f, 0.01039521f, 0.04301070f, 0.03006341f, 
    -0.05054137f, -0.02414702f, -0.01404285f, 0.03282583f, -0.00818744f, 0.04582771f, -0.02264579f, 0.04579247f, 
    -0.04268205f, 0.01608327f, -0.00334694f, 0.04829066f, 0.01976592f, 0.01304986f, 0.03830390f, 0.04225029f, 
    0.05603879f, -0.00932737f, -0.01957604f, -0.02585236f, -0.02402411f, -0.02520533f, 0.05596637f, -0.04447221f, 
    -0.01454750f, 0.00678882f, 0.00772556f, -0.02776418f, 0.02505480f, -0.05151628f, -0.04789045f, -0.06509028f, 
    -0.06885138f, -0.06815207f, -0.05680820f, -0.00740804f, 0.12191051f, -0.14854759f, -0.04980950f, -0.09402268f, 
    -0.08871963f, 0.12545711f, 0.01557737f, -0.28691906f, 0.06847408f, 0.04083093f, -0.08669722f, 0.05322748f, 
    -0.05124659f, -0.02934732f, -0.01691939f, 0.10871661f, -0.02329394f, 0.08541662f, -0.07039899f, 0.11046211f, 
    0.02149464f, 0.08790276f, 0.03952448f, -0.28561512f, -0.20407206f, -0.19478577f, 0.08810803f, 0.13481753f, 
    0.05079623f, 0.05070003f, 0.07419038f, -0.11618419f, 0.30359626f, -0.04040883f, -0.15048140f, -0.04170651f, 
    0.01027104f, 0.06009791f, 0.07813001f, -0.02734515f, 0.06054394f, 0.23805673f, 0.16900407f, 0.20419531f, 
    -0.07485567f, 0.06768875f, 0.06130705f, -0.00886806f, 0.01729401f, 0.01542200f, -0.04227477f, -0.00675369f, 
    0.25255439f, 0.16241011f, -0.03787332f, 0.02246980f, -0.11109371f, 0.05055609f, 0.12576726f, -0.26190475f, 
    0.15409671f, -0.14334832f, 0.06794196f, -0.16292720f, -0.00022311f, 0.09486373f, 0.11241461f, 0.07513524f, 
    0.11770780f, 0.06769338f, -0.13463134f, 0.18807481f, 0.12475476f, 0.16569288f, 0.09004410f, -0.00358450f, 
    0.02078666f, 0.46717513f, 0.08880527f, 0.25001574f, 0.07635457f, -0.10861085f, -0.01965397f, 0.02718180f, 
    0.08011788f, 0.20124285f, -0.10833845f, -0.33866537f, 0.01924057f, 0.19818471f, 0.01511197f, 0.20549993f, 
    0.13996564f, -0.14047156f, -0.01133225f, -0.07136645f, 0.27221671f, -0.14508088f, 0.00022295f, -0.00887168f, 
    0.08489080f, 0.17917024f, 0.10545151f, -0.05898869f, 0.20867051f, 0.04817522f, 0.29677135f, 0.00691444f, 
    0.00489285f, -0.00612444f, 0.18782413f, -0.04872446f, 0.05636480f, 0.01930303f, -0.00398715f, 0.23324317f, 
    -0.10548371f, 0.03222324f, 0.00151420f, 0.00440234f, -0.00826085f, -0.14899583f, -0.17400385f, -0.09227902f, 
    -0.11996714f, 0.16066274f, 0.13168938f, 0.00173522f, 0.12882900f, 0.05863890f, 0.05911661f, 0.16836374f, 
    0.16564822f, 0.25392252f, 0.10778830f, 0.01881389f, -0.06406809f, 0.10225011f, -0.02030538f, 0.27322054f, 
    0.39071795f, 0.13688841f, 0.17612861f, -0.23023242f, 0.12826911f, -0.09897518f, -0.00916321f, -0.02184620f, 
    0.21019168f, 0.34077132f, 0.02622116f, 0.22200342f, 0.03361375f, 0.12678383f, 0.00192408f, -0.05694635f, 
    0.08488514f, 0.05061759f, -0.23104361f, -0.11836734f, 0.10682970f, 0.09748955f, 0.12596467f, -0.04710745f, 
    0.03659465f, 0.15939720f, 0.02406550f, -0.16528991f, 0.05293587f, 0.23460098f, 0.05133210f, -0.01542205f, 
    -0.14536086f, 0.03924071f, -0.02748723f, 0.19373563f, -0.18780701f, -0.03571423f, 0.25818425f, 0.13716336f, 
    0.11162835f, 0.06551290f, 0.06216202f, -0.09206413f, -0.02247554f, -0.20592117f, 0.04280192f, 0.21488562f, 
    -0.02407331f, 0.05937909f, -0.05681872f, 0.06698426f, -0.01649873f, 0.15740886f, -0.29998684f, -0.04426070f, 
    -0.06117320f, 0.05920495f, 0.18297718f, 0.02413982f, 0.18083982f, 0.02521991f, -0.14306542f, -0.22479273f, 
    -0.06068605f, 0.16273351f, -0.31175688f, -0.06257825f, -0.02633849f, -0.02355898f, 0.07730152f, -0.00900069f, 
    0.33866838f, 0.10286923f, 0.08839952f, -0.08868185f, -0.00997314f, 0.05590980f, -0.03515441f, 0.11601913f, 
    -0.02059743f, 0.15738523f, 0.15638134f, -0.49569380f, -0.05333084f, 0.06043675f, -0.04743017f, 0.11707700f, 
    0.32814011f, -0.22243871f, 0.49863386f, 0.14570086f, 0.16644180f, -0.08184156f, -0.07079866f, 0.02399013f, 
    0.05484583f, 0.18065320f, -0.05547030f, -0.19505879f, -0.23116162f, 0.19364688f, -0.05771591f, 0.23743258f, 
    0.04476184f, -0.10276543f, 0.06226723f, -0.00326136f, 0.03402162f, -0.13157634f, 0.17326221f, -0.06376605f, 
    0.06851847f, -0.01182112f, -0.03482928f, 0.11717977f, 0.13962771f, -0.21733691f, -0.05096040f, -0.09863113f, 
    0.08165172f, 0.07696982f, -0.09375112f, 0.13679376f, 0.12384597f, 0.10284508f, -0.35420033f, -0.15308273f, 
    0.16278908f, 0.10067488f, 0.03734797f, -0.06350659f, 0.07883223f, 0.13692021f, -0.09679130f, 0.30534127f, 
    -0.02880443f, 0.11633453f, 0.02904354f, 0.09696399f, -0.02286238f, 0.01522843f, 0.17882463f, -0.05479040f, 
    -0.14327937f, -0.06385557f, 0.12742963f, -0.10315415f, 0.04528438f, 0.02264774f, 0.00335493f, -0.13216156f, 
    0.02809678f, -0.18024926f, -0.13838272f, -0.24691501f, 0.13913412f, 0.28018513f, 0.05150035f, 0.01407866f, 
    -0.18578887f, -0.07129251f, 0.14830129f, 0.15176740f, -0.11803810f, -0.13462523f, -0.09037573f, -0.00136350f, 
    0.06492020f, 0.03559089f, 0.09365066f, -0.08486600f, -0.30144620f, -0.33025259f, 0.12918431f, 0.21871512f, 
    0.04057353f, 0.03871695f, -0.03476058f, -0.00221079f, 0.20458642f, 0.02695297f, 0.09481218f, -0.11820420f, 
    0.07894509f, 0.12698519f, 0.13759661f, 0.06443694f, 0.03217360f, 0.17432152f, -0.03766866f, 0.09568551f, 
    -0.13390057f, 0.04015172f, 0.09242143f, 0.08589898f, -0.00455637f, 0.02084465f, -0.15411404f, -0.16768637f, 
    -0.03570811f, 0.03551902f, 0.05406788f, -0.03135562f, -0.03858024f, -0.15047401f, -0.12539251f, 0.04448355f, 
    0.06818995f, -0.25676638f, -0.09659176f, 0.05547623f, 0.05849382f, 0.00211318f, -0.10624507f, -0.07371713f, 
    -0.04357833f, -0.10532777f, 0.02292359f, 0.00192433f, 0.04972086f, 0.13296191f, 0.02751254f, 0.07356855f, 
    0.09717169f, 0.12164022f, 0.30466709f, 0.25375971f, -0.04241140f, 0.05434171f, -0.04267353f, 0.14514579f, 
    0.03993869f, 0.09647893f, -0.03020756f, -0.52099627f, -0.42857665f, 0.03488860f, 0.18635061f, 0.03593437f, 
    0.04357548f, -0.05706567f, -0.00998542f, -0.14150147f, 0.07129981f, -0.03778780f, -0.15695082f, 0.03556576f, 
    0.01642065f, 0.05725741f, 0.04980704f, 0.11814935f, 0.08465616f, -0.19847575f, 0.05558866f, -0.07602768f, 
    0.10052200f, -0.05238133f, 0.06575477f, -0.07454672f, -0.05601427f, 0.19883943f, -0.26624930f, 0.03679812f, 
    -0.19048397f, -0.04061753f, 0.01840243f, -0.10241272f, 0.05835190f, 0.00424016f, 0.27141792f, -0.23504762f, 
    -0.33841401f, -0.08743158f, 0.12930986f, 0.11504239f, -0.02669564f, -0.02516443f, 0.06014815f, 0.02284026f, 
    0.12555398f, 0.15493295f, -0.02895019f, 0.12764940f, -0.14385781f, 0.05375910f, 0.10886494f, 0.03895025f, 
    0.10754801f, -0.14090434f, -0.13510618f, 0.01134267f, 0.07438846f, 0.00831054f, -0.01355391f, -0.21784842f, 
    0.05797955f, -0.29621005f, 0.22336993f, 0.27320215f, -0.06882416f, 0.09446533f, 0.03917215f, 0.03873568f, 
    0.03008553f, -0.03821346f, 0.27181572f, -0.29644653f, -0.01572722f, 0.04624746f, 0.15696797f, 0.07575840f, 
    -0.02417482f, 0.04736998f, -0.08972671f, -0.14638768f, -0.24400762f, 0.10190634f, -0.01099536f, 0.04742054f, 
    -0.13507557f, -0.02135051f, -0.18310304f, 0.12061368f, -0.34081569f, -0.16790064f, -0.06369989f, 0.14764231f, 
    0.03509367f, -0.12373140f, 0.04797333f, -0.10225639f, -0.11794141f, -0.32760146f, -0.15060163f, -0.10987895f, 
    0.06181212f, 0.01407268f, -0.04776280f, 0.09580590f, 0.01794147f, -0.07077929f, 0.16828777f, -0.12015682f, 
    -0.25997281f, 0.02853987f, 0.15597321f, 0.23629488f, 0.07261615f, -0.14732283f, -0.12623133f, -0.05966557f, 
    -0.05509163f, -0.07989774f, -0.07498164f, -0.01648395f, -0.00095634f, -0.06397727f, 0.02382118f, 0.07579271f, 
    0.10119726f, 0.22675765f, 0.21059240f, -0.13480642f, 0.01205661f, 0.10478339f, -0.20324756f, 0.01053645f, 
    0.09489436f, -0.06307174f, 0.28959659f, -0.43315080f, -0.00563369f, 0.05091617f, 0.06693527f, 0.07675023f, 
    0.08407060f, -0.10916905f, 0.10666718f, 0.27996194f, 0.31233808f, 0.05737656f, -0.09390699f, 0.02796570f, 
    0.03019237f, 0.17571728f, 0.02448764f, 0.05301772f, -0.38626736f, -0.26231876f, 0.03440578f, -0.13246945f, 
    0.01419713f, 0.17210039f, 0.00921244f, -0.11891678f, 0.28234327f, 0.08211575f, 0.10176646f, -0.05180245f, 
    -0.05942198f, 0.27199128f, 0.03725806f, 0.00008044f, -0.02862312f, -0.26848507f, -0.12236536f, -0.26336494f, 
    0.06949865f, 0.13422452f, 0.02349465f, 0.03165529f, 0.03846276f, 0.00893256f, 0.03883726f, -0.49047622f, 
    -0.17032894f, 0.04880285f, 0.12105924f, 0.09891434f, -0.08461944f, -0.02068529f, -0.10828339f, 0.25462386f, 
    0.18229304f, 0.32256228f, 0.05206742f, 0.09518275f, 0.05514276f, 0.06198309f, 0.04056713f, -0.08732662f, 
    0.25104013f, 0.09310415f, 0.07963386f, -0.11734946f, 0.02140037f, -0.11221889f, -0.10076924f, 0.08535261f, 
    0.00846579f, 0.19973846f, -0.10712663f, -0.04274108f, 0.05871563f, -0.11553472f, -0.03493544f, -0.06021718f, 
    -0.02955075f, -0.02592881f, -0.04249071f, -0.31428492f, -0.07358979f, 0.09574869f, 0.02996591f, -0.06812580f, 
    -0.07667737f, 0.00311070f, -0.13472015f, 0.16736230f, 0.21993591f, 0.12083404f, -0.17538334f, -0.20455033f, 
    -0.17865023f, 0.03205823f, 0.02094697f, 0.16900942f, 0.32531083f, -0.09202743f, 0.11382727f, 0.02248858f, 
    0.05273090f, -0.13444476f, 0.24415435f, 0.00513830f, 0.01751498f, -0.09926879f, -0.36619779f, -0.03335886f, 
    0.11119362f, 0.16643223f, 0.18306059f, -0.02461940f, -0.00058205f, -0.13154203f, 0.36288488f, 0.14190915f, 
    0.10860137f, -0.03179391f, -0.04314702f, 0.08253394f, 0.14699051f, 0.07885051f, 0.09142362f, 0.00480751f, 
    0.00829338f, 0.09917340f, 0.02417170f, -0.18677837f, -0.05481486f, 0.17553519f, -0.04019189f, -0.05479150f, 
    -0.08025523f, -0.19000468f, 0.02732691f, 0.12684181f, 0.16294034f, -0.10674916f, -0.01982024f, 0.01383045f, 
    0.04281689f, -0.15827131f, -0.30514282f, -0.04531452f, 0.14280641f, 0.16782098f, 0.23039426f, -0.02675894f, 
    -0.08029668f, 0.02014466f, 0.04620815f, 0.13954745f, 0.08806365f, -0.10863775f, -0.07806300f, -0.09899382f, 
    0.05852521f, 0.07681431f, -0.01780738f, -0.01187178f, -0.31747478f, -0.25117916f, -0.19950356f, 0.05796167f, 
    0.07318559f, 0.08675869f, 0.00466632f, 0.12904613f, -0.02612843f, 0.06112571f, 0.14951572f, 0.07944399f, 
    -0.00829418f, -0.08188266f, 0.09233639f, 0.14672844f, 0.03804011f, -0.11087230f, -0.36835676f, -0.12778367f, 
    0.03944620f, 0.05956861f, 0.02598473f, 0.06035200f, 0.01391905f, -0.09730742f, -0.32477736f, 0.24633858f, 
    0.07439106f, -0.07783346f, 0.07916884f, -0.07535431f, 0.06087705f, -0.05725097f, 0.15147638f, -0.03733002f, 
    -0.19190508f, -0.37631395f, 0.05868801f, 0.14930253f, 0.10287520f, -0.06149818f, 0.05161396f, 0.00521330f, 
    0.20718807f, 0.09473382f, -0.31169602f, 0.14399518f, -0.02784500f, 0.06276166f, -0.15473412f, 0.05452206f, 
    -0.15796895f, 0.12294790f, -0.06916650f, 0.02304223f, 0.07167622f, 0.12619294f, 0.19323318f, 0.18451571f, 
    0.07247338f, 0.05763820f, 0.18914114f, 0.24568780f, 0.06308127f, -0.07502671f, -0.17278944f, -0.10093992f, 
    0.00139541f, 0.03456142f, 0.05139885f, 0.14504129f, 0.09772502f, -0.20097330f, 0.06330398f, -0.13555740f, 
    0.04075676f, -0.14275482f, 0.19913200f, 0.09184592f, 0.20789739f, 0.12414670f, 0.18129493f, -0.06118651f, 
    -0.19534841f, -0.00654808f, 0.05453684f, -0.07806212f, 0.13391542f, -0.27723938f, -0.10144330f, 0.20196030f, 
    -0.17580979f, -0.11083385f, -0.09953704f, 0.00050706f, 0.14416219f, -0.02553727f, 0.22481324f, 0.17890266f, 
    0.19694646f, -0.22322726f, 0.10514785f, -0.17309612f, -0.15759088f, 0.09311084f, -0.05102858f, 0.00693287f, 
    0.28836963f, 0.03152911f, 0.04302012f, 0.17168975f, -0.25410157f, 0.01742131f, -0.04138007f, 0.10577071f, 
    0.34468594f, 0.14565839f, -0.24550073f, 0.20527907f, 0.05663358f, 0.22197311f, 0.12456670f, 0.00091688f, 
    0.10748872f, 0.07320153f, 0.07048117f, 0.01742895f, -0.21984670f, -0.18472001f, -0.15973045f, -0.07878401f, 
    0.03195215f, 0.16642405f, 0.22492917f, -0.03086251f, -0.29250839f, 0.15734124f, 0.10583723f, 0.09409498f, 
    -0.07502402f, 0.01120052f, -0.04285311f, 0.00769587f, -0.12436233f, 0.10139827f, -0.20868610f, -0.11086047f, 
    -0.19651790f, 0.00625926f, -0.00923986f, -0.13955605f, -0.14823240f, 0.30418125f, -0.23302044f, -0.02338793f, 
    0.14561956f, 0.14030936f, 0.09394630f, 0.00779314f, 0.11319170f, -0.04907725f, 0.13054192f, 0.12082390f, 
    -0.16823386f, -0.02885233f, -0.16362812f, -0.07870672f, 0.00277622f, 0.05996400f, 0.24981597f, 0.21540892f, 
    -0.02688072f, -0.18815169f, -0.14752169f, -0.14714199f, 0.01218402f, 0.00603487f, 0.09280959f, -0.01583668f, 
    -0.14166166f, -0.08719932f, 0.22658487f, 0.04306149f, 0.16313161f, 0.09648151f, 0.01594893f, 0.03344974f, 
    -0.09042362f, 0.03487911f, -0.03677651f, -0.05635944f, -0.00251199f, -0.07281884f, -0.17014289f, -0.17797160f, 
    -0.12356267f, -0.14068036f, 0.16367567f, 0.06682565f, 0.19344895f, 0.02186109f, 0.10997698f, 0.19100839f, 
    0.20030642f, -0.04531151f, -0.05069564f, -0.13542826f, -0.12679745f, 0.14416425f, -0.03596679f, 0.03423764f, 
    0.08086591f, 0.05082082f, -0.05302480f, -0.13762604f, -0.02281721f, -0.03498606f, 0.18472090f, 0.13351132f, 
    -0.01153063f, -0.01984810f, 0.17676204f, -0.04893200f, 0.29901284f, 0.16803190f, 0.02722467f, -0.22379149f, 
    -0.01988396f, 0.01727868f, 0.03014362f, 0.05895846f, 0.05653647f, 0.01567904f, 0.07348242f, -0.10773589f, 
    -0.00199106f, -0.05575940f, 0.00848872f, -0.09651870f, 0.00824433f, -0.01146661f, 0.07751663f, -0.04578969f, 
    -0.11453753f, -0.07867136f, -0.01406808f, -0.13353015f, -0.13161421f, -0.02293908f, -0.02814734f, -0.34584492f, 
    -0.34801203f, -0.05244952f, 0.04909369f, -0.08899319f, 0.11241706f, -0.10524052f, 0.05623885f, -0.11133389f, 
    0.11389608f, 0.07957336f, 0.00445306f, 0.00444643f, -0.05571718f, 0.13745141f, 0.15270843f, 0.01048498f, 
    0.01322606f, -0.10837535f, 0.08650471f, 0.13026270f, 0.23905921f, -0.12205331f, 0.11519036f, -0.02219770f, 
    -0.01164458f, -0.05729336f, -0.25421757f, 0.08719216f, 0.00982614f, 0.03639007f, 0.10787122f, -0.03719512f, 
    -0.24693534f, 0.07866518f, -0.10031706f, -0.02424154f, -0.06902009f, 0.07993907f, 0.18797642f, 0.11096916f, 
    0.02051141f, 0.06931642f, 0.05631461f, 0.17392045f, 0.13551539f, 0.01745137f, 0.06367759f, 0.01769347f, 
    -0.11930808f, -0.00222982f, 0.14770266f, -0.01600595f, -0.24713597f, -0.24334946f, 0.01568322f, 0.23536509f, 
    0.01368565f, -0.00360531f, 0.15821655f, -0.06173975f, 0.06997401f, 0.08604136f, 0.05369223f, -0.05854395f, 
    0.01870617f, 0.06544960f, -0.07575501f, 0.15314803f, -0.06807675f, 0.19316870f, 0.19421564f, 0.12893230f, 
    -0.00229231f, 0.13668004f, -0.09376118f, 0.08873495f, -0.09356684f, 0.01564513f, 0.11096037f, 0.14296700f, 
    -0.22376414f, 0.00290510f, 0.04715477f, -0.02939614f, 0.05026570f, 0.02776757f, 0.16156791f, -0.11307465f, 
    0.12467787f, 0.22071341f, 0.11705628f, -0.10656795f, -0.19953579f, -0.02378963f, -0.11135947f, 0.17646444f, 
    -0.07423215f, 0.05150752f, 0.05494471f, 0.05458350f, 0.05948723f, 0.07400658f, -0.00026293f, 0.16558668f, 
    0.09729398f, 0.04603353f, 0.07379181f, -0.05914950f, 0.01508888f, -0.02368229f, -0.08301831f, -0.02292657f, 
    0.19116533f, 0.15319370f, -0.04966473f, 0.07542604f, -0.43159917f, -0.05284153f, 0.11515360f, 0.13082954f, 
    0.18976709f, -0.13430278f, -0.00667509f, -0.02935674f, -0.22963364f, -0.25453410f, -0.20806086f, 0.19175138f, 
    0.14024924f, 0.18346986f, -0.04843550f, -0.06319389f, 0.06139851f, -0.24881558f, -0.14927447f, 0.04806826f, 
    -0.01363588f, 0.27556488f, -0.06090287f, 0.03234575f, -0.00675428f, -0.18307368f, 0.01873973f, -0.05423510f, 
    -0.23879272f, -0.08748747f, -0.00540621f, -0.10217733f, -0.02440952f, -0.07649387f, 0.02568351f, 0.17221233f, 
    -0.07771861f, 0.09806751f, 0.25544104f, -0.13813052f, 0.04877974f, 0.07320751f, 0.07419110f, -0.09474685f, 
    -0.05104658f, -0.85463715f, 0.01825992f, 0.19784176f, 0.20831025f, 0.02356790f, -0.01792292f, 0.01712061f, 
    0.04059056f, -0.24207422f, -0.35859653f, 0.05575457f, 0.22617894f, 0.09739141f, 0.07012200f, 0.06656947f, 
    0.01355633f, 0.11509659f, 0.00238599f, -0.12372403f, -0.11537339f, -0.17048787f, 0.16720498f, -0.12469816f, 
    -0.05415422f, 0.01637962f, -0.02234811f, 0.15203096f, 0.01279948f, 0.05160349f, -0.15551448f, -0.08506867f, 
    -0.01138923f, 0.03100112f, 0.00548256f, 0.09754609f, 0.00572954f, -0.33902070f, -0.33509296f, -0.07389494f, 
    -0.00333712f, 0.04072979f, 0.02880873f, 0.13013323f, -0.00596533f, -0.00380105f, -0.55788893f, -0.10895541f, 
    -0.12014653f, 0.17903022f, -0.01182691f, 0.15404269f, -0.02599170f, -0.03342069f, 0.00993910f, -0.23627639f, 
    0.10997322f, 0.03490644f, 0.01025083f, 0.12427134f, 0.05347033f, 0.00510054f, -0.11670219f, -0.00329762f, 
    -0.23173077f, -0.18455580f, -0.06943547f, 0.01710457f, 0.20257059f, -0.09864724f, 0.04448680f, -0.01790276f, 
    -0.19411169f, 0.41946599f, -0.00573120f, -0.08797834f, -0.10605273f, 0.00229066f, 0.09811126f, -0.00742351f, 
    -0.01611765f, -0.24724263f, -0.43346339f, -0.08853376f, 0.03066629f, 0.10608093f, 0.09282272f, 0.00258126f, 
    -0.00449195f, -0.04875884f, 0.17185973f, 0.15831454f, -0.20750459f, 0.02512240f, -0.25707307f, -0.03302277f, 
    -0.15685090f, -0.03182439f, 0.04268279f, -0.13692874f, -0.14665538f, 0.03868592f, -0.05139751f, 0.00566749f, 
    0.01571491f, 0.12637356f, 0.13603485f, -0.02618350f, 0.08467278f, -0.07200014f, -0.01632204f, 0.08946110f, 
    0.06535939f, -0.03736123f, 0.05208376f, -0.04123065f, -0.07982939f, 0.02821730f, 0.09002484f, 0.06825490f, 
    0.14667773f, 0.03227675f, -0.16879641f, -0.06652628f, 0.02925469f, -0.02898793f, 0.18135998f, -0.38396588f, 
    0.22706297f, 0.09186621f, 0.24686879f, 0.05589112f, -0.01985518f, 0.00952396f, 0.17217594f, -0.20239860f, 
    -0.19652201f, -0.28285539f, -0.16675772f, 0.03414374f, 0.06712844f, 0.01432287f, -0.00951620f, -0.11534375f, 
    0.07873050f, 0.03595373f, 0.11018654f, -0.02688039f, 0.14498594f, 0.01554767f, -0.06166138f, -0.18666734f, 
    -0.08622189f, 0.25976938f, -0.02000329f, -0.29382706f, 0.12222219f, -0.06669227f, -0.03332623f, 0.03443564f, 
    -0.07671445f, -0.05659345f, -0.05535550f, -0.20231852f, -0.17234571f, -0.26846227f, 0.21575467f, 0.04313158f, 
    0.06481477f, 0.01152722f, -0.09558579f, -0.10554128f, 0.21287002f, 0.08386475f, 0.07953195f, -0.08194946f, 
    0.00205354f, 0.02470979f, 0.06534084f, 0.07569710f, -0.07124627f, -0.24579126f, -0.15199973f, -0.37953860f, 
    0.21703553f, 0.08679222f, 0.05135894f, -0.19603184f, 0.02033867f, -0.02639477f, -0.16659705f, 0.13915017f, 
    0.01024696f, 0.07746357f, 0.02597285f, -0.11307321f, -0.09129035f, -0.00949928f, -0.05989615f, -0.09287224f, 
    -0.01240135f, -0.10435063f, 0.08299951f, 0.02052447f, -0.05496149f, 0.04963385f, 0.04213036f, 0.07778210f, 
    0.26128364f, 0.03838556f, -0.15613823f, -0.08725954f, 0.04215843f, 0.16856012f, 0.04210708f, -0.00682920f, 
    -0.06500577f, 0.39727846f, -0.24874385f, -0.01846640f, -0.08647838f, -0.12534851f, -0.05007285f, 0.01152294f, 
    -0.07607772f, 0.26602098f, 0.13582918f, 0.18004075f, -0.08948637f, -0.14352475f, -0.05782965f, -0.04934329f, 
    0.02746547f, 0.03473002f, -0.10851739f, 0.59610671f, 0.07696196f, -0.01179930f, 0.23631482f, -0.05490346f, 
    0.07727837f, -0.01472847f, 0.00002641f, 0.25891963f, 0.14936022f, -0.06615715f, 0.14068843f, -0.23319310f, 
    0.01488084f, 0.07830875f, 0.10715853f, 0.11314620f, 0.02052330f, -0.03224730f, -0.25129437f, -0.31236526f, 
    0.02080651f, 0.12379888f, 0.05601439f, 0.00104835f, -0.00001079f, -0.04562920f, -0.02156715f, 0.27649274f, 
    0.11987728f, -0.17132762f, -0.21296059f, -0.17427844f, 0.00337845f, 0.10922582f, -0.03742011f, 0.05297346f, 
    0.19410953f, -0.32917580f, -0.11973450f, 0.18195340f, 0.00613364f, 0.13041161f, -0.18081111f, 0.05455885f, 
    -0.08939131f, 0.01247074f, -0.16266853f, 0.01557477f, -0.20727114f, 0.18936740f, -0.03912290f, 0.13612588f, 
    0.13079411f, -0.12516588f, 0.13528928f, 0.12590390f, 0.02159808f, 0.01082372f, -0.00529013f, -0.08592286f, 
    0.08358223f, 0.02854454f, -0.15679291f, 0.02838101f, 0.00156090f, 0.20268606f, 0.01218744f, 0.18551210f, 
    -0.14834243f, 0.06054659f, 0.11402602f, 0.27072293f, 0.27154407f, -0.32059145f, -0.31857282f, 0.02270737f, 
    -0.02560413f, 0.16939233f, 0.08188067f, 0.06844719f, 0.04672326f, 0.26685512f, 0.18123809f, -0.08581272f, 
    -0.09934293f, -0.26052013f, 0.07349700f, 0.17482461f, 0.04976633f, -0.00914648f, 0.17135325f, 0.10711180f, 
    0.01736741f, -0.03961565f, 0.03835569f, -0.00547819f, 0.05510384f, 0.05029965f, 0.20078668f, 0.27272344f, 
    0.09471273f, -0.11246674f, -0.14790161f, -0.03661182f, 0.02635339f, 0.02544515f, 0.07121645f, 0.13748418f, 
    0.02712356f, 0.10450465f, 0.16629185f, -0.09662276f, -0.08719620f, -0.17036484f, 0.06862889f, 0.23225293f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.06188790f, 0.17191547f, 0.08642130f, -0.09526458f, 0.04498262f, -0.10223984f, 0.07783758f, -0.01082445f, 
    -0.02800709f, -0.16679339f, 0.04249579f, 0.04172258f, -0.02991976f, 0.06252076f, -0.02091126f, 0.06766551f, 
    0.16900721f, 0.01364473f, -0.02289377f, -0.02681218f, 0.01765829f, -0.09425541f, -0.07716773f, 0.15200570f, 
    0.05237606f, 0.15310235f, -0.00403133f, 0.13833135f, 0.16933250f, 0.04371298f, 0.16417667f, 0.13160537f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21822713f, 0.39666325f, 0.03762393f, 0.38329872f, 0.09405366f, 0.16325231f, -0.09931986f, -0.20640045f, 
    -0.09239841f, 0.17858027f, -0.09662917f, 0.31818697f, -0.18437883f, -0.20931415f, -0.13595334f, -0.07614984f, 
    0.06088851f, 0.01724711f, 0.36741814f, 0.04502900f, 0.01692096f, 0.91156280f, 0.32336923f, 0.02669108f, 
    0.31018835f, -0.21757349f, -0.11060425f, -0.14537452f, -0.18138446f, -0.06281708f, 0.03439226f, -0.18473795f, 
    0.17500293f, -0.24652466f, 0.14382707f, 0.27969873f, -0.01180152f, 0.32186574f, 0.15369315f, -0.42934912f, 
    -0.11135210f, 0.19656646f, 0.05501796f, 0.07948110f, 0.00183525f, 0.06508024f, -0.11311528f, 0.03119617f, 
    0.27940860f, -0.04118251f, 0.08377740f, -0.13336143f, -0.42423517f, 0.21895155f, -0.12742986f, 0.39750165f, 
    0.62578863f, -0.28576264f, 0.12237512f, 0.02106422f, 0.25339341f, -0.08047734f, -0.05717289f, -0.42296180f, 
    0.21901837f, -0.16326579f, 0.22968413f, 0.13745411f, 0.15549795f, -0.12915955f, 0.19978723f, -0.15862353f, 
    -0.17442094f, -0.23979172f, -0.03823434f, 0.41484028f, -0.16669370f, -0.32638833f, -0.03404447f, 0.09711500f, 
    -0.19137007f, 0.13723460f, 0.23791619f, 0.06188910f, -0.01419661f, 0.04603032f, -0.18111734f, 0.30168766f, 
    0.32933342f, -0.24038081f, 0.14151232f, -0.01043379f, 0.41603187f, -0.02641003f, 0.57583725f, -0.38188389f, 
    -0.20438235f, 0.50693911f, -0.15833795f, -0.40197569f, -0.22861640f, -0.43439454f, -0.07895882f, 0.45317057f, 
    0.27765054f, -0.06309959f, -0.03088083f, -0.52073765f, 0.03030318f, 0.05297941f, 0.01838589f, -0.02040226f, 
    0.24445730f, -0.05345614f, -0.25977376f, 0.08949874f, 0.05211222f, 0.12092815f, 0.02956413f, 0.06487419f, 
    0.10907730f, 0.44112036f, 0.02751281f, 0.19075868f, 0.30175555f, -0.18591796f, 0.28516352f, 0.21700095f, 
    0.21839674f, -0.01586289f, 0.13733642f, 0.00873614f, 0.15561986f, 0.83389550f, -0.30902743f, 0.07282031f, 
    0.03809445f, 0.49019659f, 0.05340521f, 0.33203283f, 0.07946134f, -0.10899045f, -0.14426561f, 0.34440255f, 
    0.10664061f, 0.05478537f, -0.20892210f, -0.17417023f, 0.63690400f, -0.16325648f, 0.27354100f, -0.02581728f, 
    0.03385480f, 0.21533202f, 0.02344864f, -0.12873560f, -0.47775316f, 0.13832369f, -0.64226961f, 0.31390107f, 
    -0.17516452f, 0.33226842f, -0.01740284f, 0.14321680f, 0.27943021f, -0.48026705f, -0.41398403f, -0.12459844f, 
    0.02560738f, 0.25399154f, -0.10422330f, 0.45478806f, -0.16072193f, 0.07166325f, -0.13799682f, 0.00324591f, 
    0.07315354f, -0.04364076f, 0.10298819f, 0.03763052f, 0.30014920f, 0.42771533f, 0.44222316f, 0.40672001f, 
    0.08099717f, 0.11010945f, -0.03041546f, 0.02631722f, 0.05685157f, -0.04590053f, 0.01348071f, -0.45173451f, 
    -0.21447690f, 0.43282035f, 0.40150002f, 0.24047969f, -0.02508178f, 0.45063683f, 0.06052342f, 0.15276608f, 
    -0.05332525f, 0.25225997f, 0.02356939f, -0.28220758f, 0.07226947f, -0.01784649f, -0.18716773f, 0.03005558f, 
    0.44929174f, -0.16901724f, 0.53223479f, -0.13027681f, 0.19422440f, 0.49690530f, 0.09833483f, -0.04492057f, 
    -0.19384278f, 0.34543249f, 0.11128377f, -0.19292335f, -0.43018642f, 0.24554473f, -0.39937130f, 0.49332434f, 
    0.46777183f, -0.06384631f, -0.26278758f, -0.19760586f, -0.04214818f, 0.16687016f, -0.17810927f, 0.27141222f, 
    -0.27254817f, 0.09449095f, 0.09524868f, -0.33247018f, 0.03861838f, 0.27158481f, -0.05100615f, 0.24912867f, 
    -0.16761790f, -0.06815706f, 0.12937096f, -0.01436030f, 0.49111789f, -0.36431125f, -0.56626385f, 0.10743711f, 
    0.37127325f, 0.23838371f, 0.02703461f, 0.23164609f, 0.36095545f, -0.26185682f, 0.07567953f, -0.09801526f, 
    -0.09569228f, -0.08694302f, -0.14382161f, 0.02204351f, -0.14339046f, -0.04396322f, -0.01127861f, -0.02464782f, 
    0.00718413f, 0.02740272f, 0.11486003f, 0.08263601f, 0.08053060f, 0.09427745f, -0.13702716f, 0.14461134f, 
    0.15986836f, -0.07425050f, 0.10630464f, -0.13438527f, -0.17688283f, 0.01320824f, -0.17755510f, -0.10467162f, 
    0.07664640f, -0.03305811f, 0.10548709f, -0.14767456f, -0.00938131f, -0.09831915f, -0.12796527f, -0.06659213f, 
    0.09110809f, -0.13811529f, 0.32088488f, 0.46533927f, 0.33882439f, -0.37538749f, -0.00842649f, -0.06818764f, 
    0.03137847f, 0.39000911f, 0.10405926f, 0.62594563f, -0.16649202f, -0.12786426f, 0.14976178f, 0.19675364f, 
    -0.13094722f, 0.02950132f, 0.24661021f, -0.00406934f, 0.17301920f, 0.10060307f, -0.00397993f, 0.27047420f, 
    0.26959836f, -0.38406777f, -0.06003221f, -0.13888089f, -0.30286786f, 0.20193306f, -0.19506304f, -0.42183974f, 
    0.00752612f, 0.37462819f, 0.16840471f, -0.21540155f, -0.01322689f, -0.68901819f, 0.29910785f, 0.01614207f, 
    0.03131843f, -0.48236042f, -0.10108642f, -0.25698093f, -0.07025991f, 0.44145563f, 0.04717031f, -0.12474132f, 
    0.09443595f, -0.02434010f, -0.11215153f, -0.16597079f, -0.28237295f, -0.14294246f, -0.16805534f, 0.23083587f, 
    -0.10527346f, 0.37461081f, -0.06422045f, 0.30967414f, -0.04157250f, -0.09928531f, 0.46825626f, 0.18759869f, 
    0.06358514f, -0.00979163f, -0.11289041f, 0.02370395f, -0.18111962f, 0.02938860f, 0.11953000f, -0.07760451f, 
    0.07270469f, -0.15320010f, 0.09432939f, -0.11739679f, -0.18479078f, -0.19229528f, -0.05648848f, 0.08819134f, 
    -0.17896663f, -0.16946845f, 0.10875181f, -0.02796315f, -0.03289560f, 0.02529046f, 0.00897303f, -0.01597789f, 
    -0.04621558f, -0.06925473f, -0.11880759f, -0.10335863f, 0.09689535f, -0.06181586f, 0.05749540f, 0.06643580f, 
    -0.05869476f, -0.10858598f, -0.02570911f, -0.13618453f, -0.07200405f, -0.06460354f, -0.10502712f, 0.10799004f, 
    -0.01691411f, 0.13530214f, -0.02635977f, -0.04588258f, 0.12751608f, -0.03984380f, 0.00171655f, -0.11610863f, 
    -0.17248279f, -0.03753801f, -0.17745724f, -0.08893646f, -0.15363266f, 0.14436646f, 0.16750032f, -0.04531305f, 
    -0.04711651f, 0.10911158f, -0.13313100f, -0.10953005f, 0.05501849f, -0.04360556f, -0.08631404f, 0.06959222f, 
    -0.01146059f, 0.16767406f, 0.37041363f, 0.14150578f, 0.56015307f, 0.15177880f, -0.70355487f, 0.09703873f, 
    0.13905539f, -0.18870479f, 0.04920422f, -0.65913272f, -0.11043677f, 0.04700810f, 0.17850332f, 0.56554109f, 
    0.08551016f, 0.11042487f, -0.44124952f, -0.03337701f, 0.23763841f, -0.33986560f, 0.09988503f, -0.00139398f, 
    0.38779986f, -0.19122341f, 0.08209200f, 0.06299306f, -0.28538969f, 0.27840620f, -0.19139090f, -0.03844767f, 
    -0.05461513f, 0.09985339f, -0.44046181f, -0.49526232f, -0.39703777f, 0.17415000f, 0.25669080f, 0.34527674f, 
    0.53803784f, 0.41610897f, 0.10763442f, 0.39465943f, 0.09061836f, -0.29796755f, -0.07874496f, -0.51756740f, 
    -0.14178710f, 0.01565652f, -0.18836603f, -0.02043509f, 0.06336471f, 0.42833287f, 0.27589798f, 0.00710198f, 
    -0.11518163f, 0.38871646f, -0.00535805f, 0.07363046f, 0.29420501f, -0.06037264f, 0.07193592f, 0.41326329f, 
    0.28885767f, -0.01342385f, -0.44807404f, 0.02929032f, -0.11281495f, 0.26353252f, -0.43599626f, -0.01492012f, 
    0.14796278f, 0.10174648f, -0.00442156f, 0.74701172f, -0.17405394f, -0.35531387f, 0.21177693f, -0.29568636f, 
    -0.18480740f, -0.16845050f, -0.40018594f, -0.12080581f, 0.37135568f, -0.07660558f, 0.37539998f, 0.30348873f, 
    -0.21475241f, 0.04844857f, 0.11368865f, 0.12663691f, 0.42674094f, -0.07872648f, -0.09865580f, 0.00828269f, 
    0.21631193f, 0.10490431f, -0.14620526f, 0.02637179f, -0.03249897f, 0.18342750f, 0.20327255f, -0.14709431f, 
    0.05123961f, -0.29959559f, 0.11447865f, 0.36437064f, -0.03596941f, -0.31437764f, -0.11409846f, -0.31734720f, 
    0.32442859f, -0.10566223f, 0.09524291f, 0.15593795f, -0.22444662f, -0.05247169f, 0.40277445f, 0.05253686f, 
    -0.23403867f, -0.18987641f, -0.00950679f, -0.02395313f, -0.06393976f, 0.08269899f, 0.00623090f, 0.07572723f, 
    0.21755071f, -0.27658010f, -0.07249440f, -0.13390408f, -0.23738068f, 0.04751040f, 0.08074223f, -0.25869462f, 
    -0.12433592f, -0.02979567f, 0.10042667f, 0.29485169f, 0.05113247f, 0.02174978f, -0.15249227f, -0.27360931f, 
    0.19000790f, 0.13871425f, 0.11891612f, -0.18407463f, -0.40894839f, -0.14593993f, -0.08375572f, 0.38638356f, 
    0.36307386f, 0.14004092f, -0.11325565f, 0.29198563f, 0.45474249f, -0.14420708f, 0.26466343f, -0.24686418f, 
    0.23172101f, 0.22033657f, 0.21894844f, -0.15315829f, -0.16007993f, 0.83080393f, -0.13960305f, -0.23839585f, 
    -0.09052536f, -0.04594354f, 0.07435325f, -0.00830014f, -0.08059720f, -0.02038992f, -0.12347762f, 0.23808075f, 
    0.77995676f, 0.05768159f, -0.60296601f, 0.13569506f, -0.13964027f, -0.25814974f, -0.00930399f, -0.06060584f, 
    0.17901458f, 0.14036126f, 0.07022780f, 0.15216367f, -0.29642156f, 0.07577568f, -0.33466542f, 0.20746094f, 
    0.02885325f, -0.13834858f, -0.42807832f, 0.29001725f, -0.17691541f, 0.31327295f, 0.55737561f, -0.04421395f, 
    -0.15299186f, 0.29667667f, -0.15765989f, 0.25840628f, 0.06492373f, 0.16841981f, 0.06343292f, -0.37130088f, 
    -0.37331828f, 0.00769648f, 0.72834027f, -0.04038481f, -0.07243215f, 0.15751399f, 0.36072353f, 0.08610255f, 
    0.13206835f, -0.17080440f, 0.13872091f, 0.10619890f, 0.64293092f, -0.14647324f, 0.28239432f, -0.11984438f, 
    -0.00705880f, -0.11699414f, -0.15975271f, -0.16968215f, 0.06936567f, 0.02831532f, 0.01103273f, -0.04850611f, 
    -0.02499700f, -0.17838664f, -0.16752478f, -0.13001470f, 0.06250116f, -0.14923429f, -0.07800720f, 0.09693193f, 
    0.03472372f, -0.13101728f, 0.07302143f, -0.07857049f, 0.08918042f, -0.04249587f, -0.14468724f, -0.01554115f, 
    0.03407652f, 0.11746309f, 0.10126621f, -0.12857290f, 0.12458559f, -0.13013795f, 0.13773169f, -0.09596112f, 
    0.15217714f, -0.15098460f, 0.06911342f, 0.04974814f, 0.20574155f, -0.02527318f, 0.55956405f, -0.13249868f, 
    -0.35238773f, -0.01598819f, 0.08616436f, -0.36361101f, -0.16498165f, 0.43108872f, 0.15663135f, 0.20840046f, 
    0.71588188f, -0.03388192f, 0.31298172f, 0.15622932f, -0.47280064f, -0.11247873f, -0.43005049f, 0.04730270f, 
    0.19135815f, -0.32808229f, 0.13642606f, 0.25036499f, 0.23308551f, 0.02201718f, -0.27529296f, -0.10472206f, 
    0.23071554f, 0.19995697f, -0.32458958f, 0.06928879f, 0.09916579f, 0.15546562f, -0.24028891f, 0.13279100f, 
    -0.26324013f, -0.07467794f, -0.12738238f, 0.09382294f, -0.01887103f, 0.26889792f, -0.05206845f, -0.09563050f, 
    -0.50867361f, 0.00419685f, -0.00263028f, 0.04968506f, 0.66774118f, -0.46432620f, -0.30139250f, 0.06546368f, 
    -0.18832614f, 0.54787594f, 0.08277459f, 0.14148518f, 0.27563897f, 0.18952183f, 0.12500599f, 0.13381043f, 
    -0.01228167f, 0.28481072f, 0.35786235f, 0.02671851f, 0.52336323f, -0.22582132f, -0.37442365f, -0.14239441f, 
    0.36947876f, 0.12356097f, -0.08619588f, -0.27155674f, -0.09482130f, -0.21073952f, 0.14292957f, 0.40672910f, 
    0.11307125f, -0.15663083f, -0.12068261f, -0.07877351f, -0.10194843f, 0.31788573f, 0.37961915f, 0.12436542f, 
    0.19044232f, -0.32935852f, -0.09672008f, 0.11371289f, -0.10695118f, 0.14366610f, -0.15228534f, -0.15571366f, 
    -0.17937084f, -0.20501229f, 0.13895217f, -0.00290705f, -0.07040732f, -0.10242045f, -0.07623712f, -0.10248425f, 
    0.06772990f, 0.08242197f, 0.00697680f, -0.09865983f, 0.13454629f, -0.20289072f, -0.09919893f, -0.17519216f, 
    -0.06548459f, -0.02966449f, 0.02226893f, 0.02572176f, 0.07835486f, -0.02009619f, 0.07406987f, -0.00250775f, 
    0.06774172f, -0.02387210f, -0.03638329f, -0.15530798f, 0.12625001f, -0.12713903f, -0.18800786f, 0.03040306f, 
    -0.12393548f, -0.01805849f, 0.05639817f, 0.02152026f, -0.13515824f, -0.12783422f, -0.12723938f, -0.19606791f, 
    -0.00774515f, -0.16467595f, 0.00917615f, 0.06510103f, -0.02146855f, 0.04631561f, 0.13981895f, 0.11468613f, 
    -0.17482619f, 0.10173570f, -0.13713500f, 0.11745425f, 0.13032416f, 0.04362002f, -0.02668708f, 0.03827653f, 
    -0.06370872f, -0.16777547f, 0.12699582f, -0.19808497f, 0.06051690f, 0.11455084f, 0.04964046f, -0.05246692f, 
    0.16922097f, 0.01759621f, 0.04466592f, 0.36560750f, -0.08839735f, 0.11020619f, 0.64220583f, 0.26093382f, 
    -0.56320423f, -0.53593636f, -0.12459382f, 0.10545224f, 0.05425368f, 0.31733862f, 0.00773334f, 0.06087827f, 
    0.14704473f, -0.07776269f, 0.34416175f, -0.10975806f, -0.07757145f, -0.40220013f, -0.16065305f, -0.24335517f, 
    -0.49358365f, 0.11114225f, 0.03798241f, 0.19813649f, -0.03329505f, 0.37620038f, 0.20246474f, 0.39814094f, 
    0.03359791f, -0.16082940f, 0.43624455f, 0.16210631f, -0.37022728f, -0.02730112f, 0.45350572f, -0.15481721f, 
    0.06123514f, -0.29544994f, 0.00814986f, -0.01268947f, -0.00757123f, -0.04874909f, 0.15911286f, -0.12485316f, 
    -0.31352043f, -0.13588025f, 0.25648716f, 0.05120897f, -0.01390375f, 0.02077747f, 0.07893671f, 0.06928983f, 
    0.11629247f, -0.08436065f, 0.11614095f, 0.05500789f, -0.34909436f, -0.01486333f, 0.22586952f, 0.43861783f, 
    -0.03012828f, 0.15541641f, 0.23151520f, 0.05047902f, 0.29303932f, -0.15113612f, -0.14919403f, 0.17635101f, 
    0.32483792f, 0.24014890f, 0.11711614f, 0.25205150f, -0.07170862f, -0.34933946f, -0.07592007f, 0.13788864f, 
    -0.26095966f, 0.10982796f, -0.20713054f, -0.08958406f, 0.15716270f, -0.01810475f, 0.02433766f, -0.07486504f, 
    -0.16049162f, -0.04643024f, 0.02010232f, -0.01109377f, -0.19756137f, 0.21065289f, -0.14940307f, 0.01527963f, 
    -0.15868707f, -0.17710152f, 0.11801478f, -0.01847430f, -0.16161081f, -0.05876623f, 0.09773411f, -0.07554138f, 
    -0.12705019f, -0.16219962f, -0.09354318f, -0.02958975f, 0.10857796f, 0.17253321f, -0.02019412f, 0.11577128f, 
    -0.01204959f, 0.10826140f, -0.00995591f, 0.06803823f, -0.02092536f, -0.01537644f, -0.17034122f, 0.06054493f, 
    -0.13512604f, 0.07856715f, -0.16964564f, -0.12748474f, 0.10628060f, -0.16085890f, 0.08894392f, -0.13444051f, 
    0.10535862f, -0.15637256f, 0.47060123f, 0.44316599f, 0.19759013f, 0.21924970f, -0.60070562f, -0.21849330f, 
    0.22038643f, -0.28539702f, 0.12459428f, -0.32450950f, 0.11618868f, 0.04500034f, -0.03045124f, 0.29989383f, 
    -0.41231942f, 0.05268883f, 0.04593432f, -0.03177977f, 0.18864231f, 0.16318269f, 0.39895004f, 0.12573160f, 
    0.40506744f, -0.06673941f, 0.08002058f, -0.02041046f, 0.08222081f, -0.21985249f, 0.39013335f, 0.09496298f, 
    -0.15306678f, 0.19603178f, 0.16702425f, -0.33901769f, -0.10296652f, -0.03665048f, -0.03007820f, -0.13705778f, 
    0.59635526f, -0.21590221f, -0.04797540f, -0.25839061f, -0.09615329f, -0.13718888f, -0.14345610f, 0.09500862f, 
    0.32492802f, -0.12387992f, -0.47037649f, 0.11589844f, -0.26724583f, 0.52484262f, 0.23906280f, 0.10863166f, 
    -0.03025542f, 0.04617501f, -0.05899080f, 0.22634766f, -0.10784581f, -0.06515075f, 0.17390141f, 0.39116940f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08689160f, 0.16354184f, 0.16711505f, 0.08860389f, 0.06549200f, 0.21755071f, -0.05240362f, 0.21496287f, 
    0.05400727f, -0.03581684f, 0.23936306f, 0.04042906f, 0.12764272f, 0.06532915f, -0.20607938f, 0.01406360f, 
    0.19798374f, 0.15352446f, 0.22903131f, -0.11128560f, -0.13797069f, -0.04857301f, 0.06825431f, -0.10935693f, 
    -0.10454661f, -0.18678415f, 0.12833108f, 0.29688367f, 0.20741215f, 0.16922677f, 0.16536945f, 0.20383261f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02558355f, 0.21750730f, 0.05850185f, -0.57277453f, 0.28862083f, 0.34573320f, -0.22045325f, -0.33726266f, 
    0.00396077f, 0.42743805f, -0.31868687f, -0.01535850f, 0.06451245f, -0.22503449f, 0.21515468f, 0.53899378f, 
    0.48291931f, 0.17179835f, -0.01778000f, -0.00279353f, 0.11318194f, -0.58815575f, -0.09038786f, -0.03159233f, 
    -0.17852770f, 0.08449609f, -0.29601458f, -0.10942344f, 0.31076437f, -0.11254808f, -0.07750059f, -0.17259519f, 
    -0.25873971f, -0.11929709f, -0.17376298f, 0.06145144f, 0.33104989f, -0.09412814f, 0.18707617f, 0.44055775f, 
    0.03426911f, -0.33329713f, -0.31553611f, -0.01980198f, 0.09588077f, -0.55384570f, 0.43691325f, 0.36474594f, 
    -0.12329777f, 0.06301806f, 0.00526306f, 0.25200227f, 0.03916866f, -0.42031583f, 0.30266985f, -0.53466582f, 
    0.09473646f, -0.14197955f, -0.05760929f, -0.23301363f, -0.13237537f, -0.05991312f, -0.21321087f, -0.43307677f, 
    -0.90721047f, -0.13401653f, -0.30079693f, -0.61969656f, 0.33991036f, -0.78773499f, 0.08988527f, -0.17268665f, 
    -0.03197887f, -0.51214391f, -0.15640603f, -0.06796785f, -0.11917438f, 0.23219611f, -0.02078591f, -0.01297131f, 
    0.43372962f, -0.07224534f, 0.54712844f, -0.16899323f, 0.03200988f, -0.11108458f, 0.00743793f, -0.13975744f, 
    -0.04231595f, 0.02586151f, 0.35592490f, 0.34437677f, 0.06475570f, -0.12951998f, 0.28148767f, 0.27699465f, 
    0.07683185f, 0.55294925f, -0.18795162f, -0.28564718f, 0.29941916f, -0.06180168f, 0.17906848f, 0.11375633f, 
    -0.01082178f, 0.25752041f, -0.52621102f, 0.08258895f, -0.05293755f, 0.26179275f, -0.04667769f, -0.52277404f, 
    -0.49834228f, -0.10480797f, 0.40177193f, -0.39819726f, 0.03455202f, 0.45253366f, -0.62875313f, 0.15431713f, 
    -0.03652979f, -0.04753898f, -0.61870003f, -0.43548405f, 0.20235981f, 0.05811376f, -0.11415605f, 0.07453734f, 
    0.17808202f, 0.19394182f, 0.23691835f, -0.03997655f, -0.10276277f, 0.11726391f, 0.06120709f, 0.03807250f, 
    0.05164193f, 0.15218517f, 0.13797452f, 0.11206064f, 0.10774833f, 0.10724950f, -0.59068054f, -0.35018960f, 
    -0.26012668f, -0.03195196f, -0.20292723f, -0.10915722f, 0.14883341f, -0.31760046f, 0.00589943f, -0.08567597f, 
    0.09208507f, -0.00086965f, -0.09554057f, 0.51692605f, -0.05191217f, 0.06573623f, 0.52149391f, -0.07396521f, 
    0.24037941f, -0.47588575f, 0.00448805f, 0.51078415f, -0.36903521f, 0.10903418f, -0.21105145f, -0.06321033f, 
    -0.00414639f, -0.28941378f, 0.21795832f, -0.07098698f, 0.06429402f, -0.19315891f, 0.56025088f, 0.20158790f, 
    -0.11253503f, -0.04840190f, -0.52574790f, -0.00497243f, 0.14332968f, -0.80659753f, -0.02841669f, 0.07395297f, 
    -0.10788994f, 0.08616788f, -0.29850090f, 0.26167542f, 0.19626869f, 0.15933920f, 0.04056271f, 0.54007262f, 
    -1.05895376f, 0.41163537f, -0.02765236f, 0.25581139f, -0.34764761f, 0.10955209f, -0.65728539f, 0.29933065f, 
    0.00975658f, -0.47011995f, 0.14833590f, 0.16268237f, 0.11030733f, 0.23107478f, -0.16615312f, 0.11452003f, 
    -0.24478543f, 0.43310216f, 0.24748482f, 0.04180514f, -0.07033143f, 0.29355976f, -0.00214324f, 0.00562800f, 
    0.04282280f, -0.08860543f, -0.31798589f, -0.54844284f, -0.47276935f, 0.11543842f, 0.27033043f, 0.12696502f, 
    0.41150290f, 0.11129691f, -0.37357092f, -0.40934780f, 0.11841474f, 0.27263412f, 0.40564489f, -0.66574907f, 
    -0.10156776f, 0.14001857f, -0.85114086f, -0.08463918f, -0.12310205f, 0.14092952f, 0.01310557f, -0.14410239f, 
    -0.06289566f, -0.69411832f, -0.71152329f, 0.45067275f, 0.06135567f, -0.25667897f, -0.41793713f, 0.26737550f, 
    0.15237762f, 0.03548574f, -0.32532716f, 0.24069948f, 0.12442875f, -0.17740667f, 0.34220856f, -0.38502988f, 
    -0.10185001f, -0.51052654f, -0.56501019f, 0.18540561f, -0.34060660f, -0.17831030f, 0.17366655f, 0.04984584f, 
    0.02546488f, -0.31630263f, 0.46351805f, 0.00853147f, 0.11409107f, -0.51447010f, 0.29102111f, -0.67748576f, 
    -0.42335305f, 0.09330437f, -0.45840907f, 0.24167937f, -0.01305517f, 0.51777798f, -0.01181371f, -0.51101685f, 
    0.07818139f, -0.13842063f, 0.47400340f, 0.14682829f, -0.20999910f, 0.02655252f, -0.60781956f, -0.14114465f, 
    0.11970215f, 0.52270430f, 0.59778178f, -0.46181574f, -0.70781898f, -0.05221403f, -0.51617789f, 0.18750319f, 
    0.15201226f, 0.25846305f, -0.04664369f, -0.02238705f, -0.06856018f, -0.42878735f, -0.38989964f, -0.09241679f, 
    0.38447553f, 0.22005142f, -0.60304332f, 0.47223216f, -0.00729165f, 0.53345305f, -0.04369836f, -0.13122563f, 
    0.02632319f, 0.01847654f, 0.30358833f, 0.11347895f, -0.37362620f, 0.08965497f, -0.11147176f, -0.68158060f, 
    -0.07415330f, -0.22447737f, -0.57217842f, 0.41186136f, -0.07736039f, 0.08425272f, 0.44595417f, -0.43025002f, 
    0.13707989f, -0.40046847f, 0.21490708f, -0.16505274f, 0.16257116f, -0.00118246f, -0.03679940f, -0.44794261f, 
    0.43094495f, -0.32435882f, 0.44050777f, -0.65966016f, 0.08255615f, 0.21811424f, -0.35496241f, 0.05512368f, 
    -0.10619123f, 0.04127003f, 0.10103560f, -0.36649388f, -0.09139570f, -0.00746427f, -0.49178651f, 0.49350470f, 
    -0.66410458f, -0.70100093f, -0.33113387f, 0.04943898f, 0.38044867f, 0.15297566f, 0.04804365f, 0.36098960f, 
    -0.15608194f, 0.19941838f, -0.01307231f, 0.12638949f, 0.07544934f, 0.59869534f, -0.61176342f, -0.12655510f, 
    -0.51131189f, -0.72371095f, -0.05541454f, -0.63008183f, 0.14305221f, -0.10751836f, 0.44955972f, 0.17617452f, 
    0.02898198f, -0.04954783f, 0.11719076f, -0.71128285f, 0.63673109f, 0.06282894f, -0.02609256f, -0.56862229f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04529292f, -0.12428446f, 0.08111237f, -0.20424643f, 0.13805707f, 0.06857760f, -0.00056001f, -0.37577280f, 
    0.01683724f, 0.17785074f, 0.09568992f, 0.07260202f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
