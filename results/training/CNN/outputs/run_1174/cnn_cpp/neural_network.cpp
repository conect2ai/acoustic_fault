#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.45208135f, 0.37302464f, 0.17951606f, -0.27153558f, 0.27248418f, 0.09493182f, 0.13809571f, 0.19909130f, 
    0.11308698f, 0.02271122f, -0.06420328f, -0.13258857f, 0.17977600f, 0.22716299f, -0.03170326f, 0.25368637f, 
    -0.23233452f, -0.19942233f, -0.10188348f, -0.08037768f, 0.16608927f, 0.07723275f, 0.11943057f, 0.04494084f, 
    -0.08326841f, -0.09899782f, 0.31913909f, 0.60869396f, -0.33901384f, -0.50083494f, -0.01161637f, -0.33146057f, 
    -0.21863312f, 0.22165860f, 0.03275546f, -0.08231224f, -0.29461759f, -0.15113319f, 0.09637556f, -0.03836637f, 
    0.28706220f, 0.18304093f, 0.01287225f, -0.06194862f, 0.12165459f, -0.12582016f, -0.28664744f, -0.17957479f, 
    -0.31242332f, 0.02005964f, -0.32446668f, -0.57552946f, -0.37413970f, -0.13642821f, -0.26755962f, -0.63759893f, 
    -0.72437793f, -0.39142546f, 0.05507577f, -0.60668129f, 0.44400242f, 0.27786398f, 0.30674902f, 0.24552789f, 
    -0.06409174f, -0.00853699f, -0.18477753f, 0.18467322f, -0.19225864f, 0.23171677f, 0.14670654f, 0.24566561f, 
    -0.32641292f, -0.02917656f, 0.30991688f, -0.19242725f, -0.26629817f, -0.36319149f, 0.33836088f, 0.37570792f, 
    0.13218504f, 0.16047134f, -0.56373912f, -0.17043148f, -0.32940456f, 0.39400518f, -0.54346114f, 0.34559533f, 
    -0.04141930f, 0.27145261f, -0.24036863f, -0.30339304f, 0.06291852f, 0.05249108f, 0.37517014f, -0.19407515f, 
    -0.18026464f, 0.28918669f, -0.21879025f, 0.20554948f, -0.60367960f, -0.68933260f, 0.63995934f, 0.40534693f, 
    -0.03757045f, -0.07689978f, -0.49002749f, 0.09182023f, -0.06264455f, -0.00996881f, -0.22984262f, 0.14815645f, 
    -0.06720366f, -0.15931627f, 0.19190109f, -0.12940787f, -0.18768269f, -0.26346859f, -0.32168618f, -0.21148162f, 
    -0.17377858f, -0.41826409f, -0.25929582f, -0.45873794f, -0.44573444f, -0.36751431f, -0.52016735f, 0.16734537f, 
    -0.24386002f, -0.28373098f, -0.61029321f, -0.53906822f, -0.06809432f, -0.30775267f, -0.35037854f, -0.15959322f, 
    -0.18868984f, -0.19967957f, -0.38292038f, -0.53219080f, -0.25297177f, -0.23677388f, -0.32678947f, -0.00597246f, 
    -0.13726285f, -0.35458025f, -0.31434119f, -0.19139519f, -0.18783340f, 0.18529797f, 0.57282799f, 0.51032037f, 
    0.35011077f, -0.03003549f, -0.44808313f, -0.42080712f, -0.32277125f, 0.14553674f, -0.03343707f, -0.26570538f, 
    -0.19666022f, 0.22680043f, -0.11862966f, 0.02512566f, 0.05843206f, -0.21612261f, -0.11093961f, 0.10077538f, 
    0.10160212f, 0.00629069f, -0.08717202f, 0.09114180f, -0.17343254f, 0.13030697f, -0.06441972f, -0.36288759f, 
    0.55921596f, 0.26303104f, -0.53372753f, 0.29717994f, -0.29695272f, 0.34415725f, 0.28549820f, -0.24050874f, 
    -0.32521045f, -0.09904405f, 0.20041052f, 0.35215631f, -0.31130052f, -0.31120849f, 0.45197076f, -0.36892560f, 
    -0.44638756f, 0.26662922f, 0.10576689f, -0.06754585f, 0.18638025f, 0.15098958f, -0.08953844f, 0.02759791f, 
    -0.55486840f, 0.10333589f, 0.36291599f, 0.27361891f, -0.24254993f, -0.72461021f, -0.20385368f, 0.51254982f, 
    0.25111812f, -0.31105807f, -0.00992730f, -0.00895465f, 0.00347903f, 0.23015310f, 0.04686741f, 0.08866309f, 
    -0.18874897f, -0.07929660f, -0.09052237f, -0.52213264f, -0.13204196f, 0.10412768f, 0.17201708f, 0.06543591f, 
    0.27528685f, -0.10551214f, -0.16195038f, 0.08144800f, 0.23675108f, 0.25110805f, -0.07553046f, -0.01479894f, 
    -0.10295042f, 0.24189192f, 0.22361296f, 0.16985059f, 0.00258608f, 0.21069816f, -0.02243401f, -0.07314239f, 
    0.09448557f, 0.18267120f, 0.04019658f, 0.08199547f, -0.08777060f, 0.18562032f, -0.06453527f, 0.04390918f, 
    -0.24020872f, 0.29215327f, -0.25242922f, -0.52268457f, 0.16058151f, 0.22687805f, 0.40789267f, 0.03299222f, 
    -0.02196890f, 0.17386618f, 0.11813051f, -0.02117098f, 0.04412187f, -0.09698662f, 0.10641211f, 0.26309821f, 
    -0.41044173f, -0.18398871f, 0.23708242f, -0.22536048f, -0.04389732f, 0.16951056f, -0.12843883f, -0.12807424f, 
    0.17554091f, -0.12319531f, 0.18228146f, -0.29920918f, -0.33213812f, -0.42211187f, 0.41185614f, 0.33638650f, 
    0.12279275f, 0.85996658f, -0.61512125f, -0.44394517f, -0.07622433f, -0.19292700f, -0.04437892f, -0.07260389f, 
    -0.04710387f, 0.17002217f, -0.14057347f, -0.33226684f, 0.03633745f, 0.11898773f, -0.19689412f, 0.12170496f, 
    -0.02940402f, -0.01839444f, 0.06671089f, 0.04444253f, -0.67912728f, -0.09573906f, -0.39728898f, -0.44964507f, 
    -0.53153950f, 0.25815508f, 0.26306871f, 0.20595211f, 0.15108781f, 0.52697730f, 0.07547283f, 0.18169802f, 
    0.03536127f, 0.07448962f, -0.28290436f, 0.00008688f, -0.07658789f, 0.02106660f, 0.04543379f, 0.10499462f, 
    0.02273085f, -0.00644868f, 0.19272694f, -0.22483043f, 0.13007160f, -1.10127461f, -0.61235225f, -0.59686476f, 
    -0.47518814f, -0.64590228f, 0.56598210f, 0.38939676f, 0.05980070f, 0.21498469f, 0.54240400f, 0.14882360f, 
    0.03277488f, -0.10186936f, 0.06662805f, -0.43974316f, -0.39583671f, 0.21181609f, -0.27120864f, -0.32675099f, 
    -0.12698786f, -0.25033677f, -0.10391045f, -0.03295276f, 0.13710937f, -0.06597093f, -0.91575217f, -0.01723881f, 
    0.00486967f, -0.33154142f, -0.81115764f, 0.23335101f, -0.01528703f, 0.16267510f, -0.25573981f, 0.31442580f, 
    -0.36244628f, 0.58284771f, -0.25749460f, 0.19082065f, -0.32609162f, 0.26264989f, -0.03187402f, -0.16852076f, 
    -0.10651262f, 0.16033399f, 0.07637919f, 0.31915349f, -0.24085340f, -0.04884214f, 0.12311686f, -0.09890689f, 
    -0.53629947f, -0.31090105f, 0.23797534f, 0.42018819f, -0.08192892f, -0.19698669f, 0.05083437f, 0.26620826f, 
    -0.22090606f, 0.45977777f, -0.24375327f, 0.03854846f, -0.22589995f, 0.14566219f, -0.07143914f, -0.06993464f, 
    0.17171252f, -0.35099176f, -0.54929054f, 0.26544580f, 0.27744287f, 0.11415229f, 0.21815167f, 0.18254434f, 
    0.47979328f, 0.28002557f, 0.00367394f, -0.41930926f, -0.22892405f, -0.02069667f, 0.35081002f, 0.22047931f, 
    -0.02436237f, -0.28585342f, 0.23752798f, 0.20690486f, -0.32051250f, -0.27557114f, 0.25615180f, 0.19892542f, 
    -0.14807104f, 0.07485493f, 0.16115913f, -0.28092629f, 0.15001544f, 0.05096631f, -0.44448483f, -0.06851479f, 
    0.35220063f, -0.88050747f, 0.27945653f, 0.42791814f, -0.35362819f, -0.36397156f, -0.00462523f, 0.26269153f, 
    0.34522593f, 0.04228995f, -0.08011625f, -0.12025716f, -0.01445492f, -0.10875890f, -0.22938566f, 0.05622111f, 
    0.34050870f, -0.05653930f, 0.04340383f, -0.04263279f, -0.17129673f, -0.08032346f, -0.08037079f, -0.25978324f, 
    -0.33007425f, -0.22391993f, -1.00189900f, -0.70775574f, -0.18675748f, -0.44328433f, -0.67254817f, 0.42774048f, 
    -0.03384237f, -0.56772351f, -0.54194915f, -0.08492155f, -0.14315850f, -0.13798110f, -0.25735140f, -0.35789013f, 
    -0.33706254f, -0.02580365f, 0.11057898f, -0.31243113f, -0.36316752f, -0.03769055f, -0.19786343f, -0.13788621f, 
    -0.08621384f, -0.02787841f, 0.11321595f, -0.14147095f, 0.61636209f, 0.53788131f, -0.13164984f, -0.28990620f, 
    -0.44729859f, -0.39923212f, -0.01732567f, 0.18764135f, -0.55672365f, 0.47754657f, -0.15821004f, -0.25625053f, 
    -0.01741222f, -0.50950557f, -0.18561602f, -0.20856825f, 0.27507150f, 0.09467309f, -0.36849391f, -0.04770723f, 
    0.01090503f, 0.11764712f, -0.28384927f, -0.14213027f, 0.23433083f, 0.23616342f, -0.15404293f, -0.06243888f, 
    0.18113595f, -0.01315986f, -0.49836373f, -0.35094959f, 0.49277824f, -0.06653932f, -0.27636847f, -0.35514015f, 
    -0.01380564f, 0.08723857f, 0.13217284f, 0.15224847f, 0.42296949f, -0.18312979f, 0.00586712f, -0.31823206f, 
    -0.45078179f, -0.03266440f, -0.33148924f, -0.30134815f, -0.44403002f, 0.36865047f, -0.68788934f, -0.37786210f, 
    -0.18361707f, -0.22468899f, 0.37420911f, -0.06364226f, 0.10898660f, 0.04847781f, -0.38723961f, 0.26024720f, 
    0.09659577f, 0.13542300f, 0.05019784f, -0.04280724f, -0.04645527f, -0.24502242f, 0.17391838f, -0.15392259f, 
    -0.21993577f, 0.14939800f, -0.08793401f, -0.08438561f, -0.20674480f, -0.49626088f, 0.14488067f, 0.25538379f, 
    0.18551202f, -0.32277244f, 0.17003991f, -0.39952132f, 0.09406879f, 0.50112861f, -0.20642993f, -0.27687234f, 
    -0.40206474f, 0.35283047f, 0.39267170f, 0.16867910f, -0.45930094f, -0.04194191f, -0.07742660f, -0.38045883f, 
    0.09832411f, 0.07402802f, -0.11165396f, -0.15699957f, -0.00845391f, 0.30925483f, -0.25924480f, -0.51282853f, 
    -0.52495927f, -0.23337437f, 0.06274863f, -0.52751791f, -0.46772835f, -0.34528941f, -0.33720055f, -0.53659207f, 
    -0.30200940f, -0.06310930f, 0.01506479f, -0.01651231f, 0.29804012f, 0.03860823f, 0.20843776f, 0.21572328f, 
    -0.24070054f, -0.31542245f, -0.36663109f, -0.10377399f, 0.05785079f, 0.20151161f, 0.17130078f, 0.18235457f, 
    0.39162639f, 0.03339772f, 0.01685283f, 0.00345037f, 0.12345681f, -0.11136346f, -0.27279833f, 0.05866120f, 
    -0.20066218f, -0.19493292f, -0.21503015f, 0.39833671f, -0.36140424f, -0.31345016f, 0.27302319f, 0.08890589f, 
    0.11331610f, 0.04873440f, 0.14028479f, -0.08962004f, 0.22921486f, -0.06173341f, -0.10323700f, 0.12405919f, 
    0.19022660f, -0.44673866f, -0.35623834f, -0.10992185f, 0.28962839f, -0.08530623f, -0.31346759f, -0.24996150f, 
    0.24389158f, 0.52600294f, 0.16519625f, 0.01152542f, -0.08498140f, -0.19285671f, 0.27699244f, -0.13007984f, 
    -0.00927651f, 0.08464563f, -0.22123955f, -0.27246180f, 0.37951300f, -0.01770260f, -0.26175401f, -0.25020763f, 
    0.05589936f, 0.09555463f, -0.25657284f, -0.37266415f, -0.25629249f, 0.59261328f, 0.02094847f, -0.58061832f, 
    -0.00504379f, -0.83991098f, -0.20869805f, 0.54026723f, 0.04538846f, 0.34251454f, -0.07553331f, 0.12789173f, 
    -0.11006311f, -0.03820381f, 0.27639630f, -0.14247975f, -0.28196928f, -0.14329936f, 0.17302282f, -0.33783704f, 
    -0.17952085f, 0.09170327f, 0.30405158f, 0.39522532f, 0.22901659f, 0.24201237f, -0.04370114f, -0.31901610f, 
    -0.14453381f, -0.07401821f, 0.02544089f, -0.01785194f, 0.36101797f, 0.04227291f, 0.23400699f, -0.19771431f, 
    -0.17641512f, -0.10516528f, -0.22649074f, 0.01195970f, 0.17339011f, 0.16087392f, -0.18511333f, 0.01039941f, 
    -0.05077529f, -0.31508836f, 0.18716709f, 0.02721282f, 0.02496071f, 0.40280303f, -0.16231997f, -0.07400130f, 
    0.23530456f, 0.02313732f, -0.15407921f, -0.13695055f, 0.18171056f, -0.17570256f, -0.15870705f, 0.02350670f, 
    -0.01483492f, 0.13268340f, -0.24526840f, 0.19115561f, -0.15750243f, 0.04687063f, 0.09170936f, -0.19406106f, 
    0.13847479f, -0.28220242f, -0.33646575f, 0.21827899f, 0.12954496f, 0.44910398f, -0.06289006f, -0.33591202f, 
    -0.26423788f, 0.20592473f, -0.36818486f, -0.00793603f, 0.35885924f, 0.10921680f, -0.31538883f, -0.23675011f, 
    0.02497671f, 0.73214734f, -0.56768149f, -0.02507287f, 0.29601711f, 0.00835017f, -0.07638668f, 0.02656884f, 
    -0.27794346f, -0.18758532f, -0.13063441f, -0.18625212f, 0.10921939f, 0.06649202f, 0.35688648f, 0.25047782f, 
    0.20280500f, -0.29825196f, -0.48283339f, 0.25416416f, 0.14503717f, 0.16109443f, -0.14721790f, 0.04669226f, 
    -0.00402573f, 0.20065880f, -0.27202752f, -0.10077816f, -0.08722760f, -0.12337750f, -0.25764591f, 0.13066514f, 
    0.20498697f, -0.24940336f, -0.08051500f, 0.15686084f, -0.14712033f, 0.16817963f, 0.34897420f, 0.40475750f, 
    0.53801876f, -0.29643756f, 0.28750652f, -0.89064354f, 0.17836058f, -0.05342881f, -0.15843989f, -0.14230663f, 
    -0.19683960f, 0.33857667f, -0.29806679f, 0.07739230f, -0.19200034f, -0.20836234f, -0.12950346f, -0.02898167f, 
    -0.01043164f, -0.18284677f, -0.24689782f, -0.30569124f, 0.03520432f, -0.16329251f, -0.29290822f, -0.04560911f, 
    -0.17813666f, -0.15780251f, 0.19402486f, -0.18018325f, 0.23460945f, 0.35784680f, 0.39697474f, 0.02753843f, 
    0.03401852f, 0.38878357f, 0.23273227f, -0.19076478f, -0.19745769f, -0.22549120f, 0.15625130f, 0.11085181f, 
    -0.14323498f, 0.09083205f, -0.17184269f, -0.46398929f, -0.05110231f, -0.00311577f, 0.00465435f, -0.17457339f, 
    -0.23552127f, -0.19120544f, -0.53353667f, -0.30910417f, -0.27199894f, -0.67252558f, -0.20357350f, 0.08008918f, 
    -0.33919525f, -0.39825973f, -0.08395781f, 0.05996611f, 0.00088876f, 0.45808885f, 0.33071706f, 0.51943254f, 
    -0.39657956f, -0.29943508f, -0.35251850f, -0.33926731f, -0.39266065f, 0.39470184f, -0.14074653f, -0.09861722f, 
    0.18615375f, -0.19250420f, -0.89544117f, 0.07017994f, 0.52019322f, 0.13277075f, 0.26805410f, -0.81351995f, 
    -0.53522325f, -0.20078745f, 0.04730581f, 0.60098171f, -0.19970405f, -0.34956381f, 0.52530342f, 0.13706693f, 
    0.03890526f, 0.05404270f, 0.10567510f, 0.01719345f, -0.36926913f, -0.39559412f, 0.23168314f, -0.17979725f, 
    -0.05286212f, -0.00851548f, 0.07231786f, 0.01924853f, 0.44503170f, 0.49970362f, -0.00950136f, -0.16693041f, 
    -0.68310142f, -0.64057577f, -0.57885867f, -0.27335230f, -0.37427250f, 0.40740108f, -0.18923454f, -0.14033143f, 
    0.41574293f, -0.07813004f, -0.05926048f, 0.18989025f, -0.03959006f, -0.19586676f, 0.08882771f, -0.11579730f, 
    0.26203480f, -0.07646688f, -0.08018075f, -0.19669293f, -1.01688492f, -0.62265599f, -0.36365962f, 0.33934778f, 
    0.44392151f, -0.02160007f, -0.31952345f, 0.02398565f, 0.42258093f, 0.11197815f, -0.19402179f, -0.12444940f, 
    -0.05614565f, 0.43680587f, -0.01002777f, 0.23190720f, -0.12237965f, 0.22487523f, 0.13579997f, 0.08915599f, 
    -0.10495417f, 0.23483428f, -0.15887754f, 0.00072108f, -0.24095646f, 0.28672773f, 0.30725932f, 0.15925379f, 
    0.06389018f, -0.27990249f, 0.50124407f, 0.17395607f, -0.15276289f, 0.10021278f, -0.00254297f, -0.22928262f, 
    -0.08984881f, -0.09937883f, -0.28930339f, -0.23187001f, 0.14429398f, -0.06966075f, 0.11934225f, -0.20461413f, 
    0.02057909f, -0.23551086f, 0.12546009f, 0.24203824f, -0.13298161f, -0.19282064f, 0.38744149f, -0.40598950f, 
    -0.39197525f, -0.31074494f, -0.42916292f, -0.03056093f, -0.16007751f, 0.00998267f, -0.11534007f, -0.28799704f, 
    0.25574124f, 0.32265925f, 0.10868144f, 0.37775099f, 0.15012306f, 0.18745145f, -0.24217619f, -0.02549289f, 
    0.21656364f, 0.01044265f, -0.14110477f, -0.21378186f, 0.20325822f, -0.03642951f, -0.24164926f, 0.64240801f, 
    0.47919866f, -0.24498910f, 0.29996711f, -0.47502121f, -0.18367903f, -0.28410953f, 0.16559932f, 0.07582147f, 
    0.02938215f, -0.01857978f, -0.02450320f, 0.20052329f, -0.27109885f, -0.21451353f, -0.15647183f, 0.15992689f, 
    0.18809579f, -0.17061985f, -0.06451306f, -0.07105643f, -0.17484885f, 0.04080882f, -0.02182756f, -0.24318159f, 
    1.03323281f, 0.04305128f, -0.84237313f, -0.54591805f, -0.88865495f, 0.13577746f, 0.09249053f, 0.28467411f, 
    0.42072657f, 0.23274481f, 0.14941703f, 0.29979947f, 0.20742232f, -0.08455052f, -0.21634586f, 0.01694939f, 
    -0.13742752f, -0.15951079f, -0.11960802f, 0.01862661f, 0.00175563f, -0.01663715f, -0.10172889f, -0.03996205f, 
    -0.09951273f, -0.36599696f, -0.60074413f, -0.38775605f, 0.01206946f, 0.32847935f, -0.17460197f, 0.07073247f, 
    0.41943985f, 0.43704361f, 0.05676166f, -0.42985722f, -0.48543289f, -0.33448845f, 0.14798580f, 0.05491780f, 
    0.02884409f, -0.11276456f, -0.26806131f, 0.36680698f, -0.04378803f, -0.51536870f, -0.27989730f, -0.27672389f, 
    -0.55575144f, -0.36294976f, -0.44774076f, 0.45951203f, -0.15868114f, 0.35824013f, -0.23992607f, -0.44971439f, 
    0.03616910f, -0.06623475f, 0.30616263f, 0.51371324f, 0.08540043f, -0.23932631f, -0.32090360f, -0.04531801f, 
    -0.00974053f, 0.07848027f, -0.18065299f, -0.13554281f, 0.02729331f, 0.08530156f, -0.25371212f, 0.15536577f, 
    0.18822011f, 0.03110229f, -0.07183836f, -0.70982623f, -0.45614129f, 0.20902666f, 0.63368672f, 0.65542001f, 
    0.67565972f, -0.09700013f, -0.61105633f, -0.31892225f, 0.05639495f, -0.06839563f, -0.02322769f, -0.12376751f, 
    -0.11707669f, -0.01992735f, 0.10020976f, -0.08708364f, 0.25846690f, 0.48308545f, -0.08978540f, 0.04569732f, 
    -0.15416752f, -0.16924110f, -0.06099653f, -0.08831482f, -0.12811488f, -0.34974596f, 0.13061672f, 0.86521333f, 
    0.35890111f, -0.13588928f, -0.57038373f, -0.56813538f, -0.43178383f, 0.02351633f, 0.20732872f, 0.03641067f, 
    -0.14391667f, -0.19451493f, 0.24929559f, -0.12439346f, -0.09063276f, 0.34074736f, 0.13645710f, -0.01765932f, 
    0.08769613f, -0.15430628f, -0.11177791f, 0.37728128f, -0.07434131f, -0.82222545f, -0.74031782f, -0.50354540f, 
    0.01777825f, -0.26238400f, 0.83848155f, -0.24418901f, -0.51823920f, 0.03949381f, 0.92990983f, -0.01200753f, 
    -0.03804586f, -0.09535348f, 0.12028740f, -0.05426082f, -0.10140437f, -0.01231875f, -0.01144016f, 0.20202121f, 
    0.10084999f, 0.15721469f, -0.13035192f, 0.08957595f, 0.26673108f, -0.07062643f, 0.19412638f, 0.00101712f, 
    -0.54654527f, -0.47114879f, -0.11901456f, 0.44384438f, 0.30576256f, 0.02960662f, -0.30887750f, -0.15067145f, 
    0.19103993f, 0.52263635f, 0.13945524f, -0.02848104f, -0.31908086f, -0.24234830f, 0.00382999f, 0.02664456f, 
    -0.35524425f, -0.38087729f, 0.00216001f, 0.16480823f, 0.24090815f, 0.28733739f, 0.33545342f, -0.48324051f, 
    -0.29097152f, 0.14583434f, 0.30500293f, 0.27325162f, 0.24105252f, 0.15038183f, 0.10290095f, 0.01685911f, 
    -0.10821249f, -0.08327729f, -0.21306999f, 0.31484497f, -0.15024112f, -0.04432667f, -0.10741989f, -0.01221761f, 
    -0.13450603f, -0.21278001f, 0.26623228f, -0.29190841f, -0.05153880f, 0.28931099f, -0.07116542f, 0.24640469f, 
    -1.03304732f, -0.38684452f, 0.27441612f, 0.52667123f, 0.27129450f, 0.11667955f, -0.25161543f, -0.36877516f, 
    0.39134499f, 0.60470134f, -0.05413954f, 0.23350669f, 0.23832500f, -0.10341356f, -0.10998616f, -0.37937242f, 
    -0.00948537f, -0.24656413f, 0.25002694f, 0.13347529f, 0.03692219f, 0.17238906f, 0.11880959f, -0.01170798f, 
    -0.13502383f, 0.08591630f, -0.33985570f, 0.11954907f, 0.19134423f, 0.09973655f, 0.01439773f, -0.25605661f, 
    0.18153398f, -0.32129067f, 0.25034809f, -0.12102371f, 0.01077367f, -0.14754081f, 0.06306902f, 0.20038556f, 
    0.19948530f, -0.30372852f, -0.33704400f, 0.23442468f, -0.00664746f, 0.11179627f, -0.17174138f, 0.11146799f, 
    0.04075946f, 0.13790248f, -0.47809669f, -0.78762931f, -0.42901570f, 0.11913716f, -0.18250611f, 0.38141602f, 
    0.36954546f, 0.24594992f, 0.21311609f, 0.22411476f, 0.30019385f, 0.15480345f, 0.19224958f, 0.05842649f, 
    0.12296714f, 0.09473550f, -0.23933138f, 0.01169437f, -0.20931590f, -0.19949073f, 0.14187731f, -0.07822776f, 
    0.18936987f, -0.00395976f, -0.24400288f, 0.00235845f, -0.48282292f, -0.18289770f, -0.12626915f, 0.07931101f, 
    -0.25594154f, -0.32097918f, -0.19832084f, -0.44266915f, 0.03461470f, 0.36449581f, -0.24273431f, 0.54856449f, 
    -0.32838386f, -0.25735390f, 0.13450184f, 0.00145314f, 0.11115288f, 0.05052864f, 0.21001630f, 0.13125862f, 
    0.00534011f, -0.21837954f, -0.05532964f, 0.00559495f, 0.57690793f, -0.29141498f, -0.47377375f, -1.01587939f, 
    -0.73843014f, -0.23122421f, -0.24594964f, 0.10883313f, 0.31063017f, 0.40207115f, -0.07667693f, 0.22725578f, 
    0.36372638f, 0.08511500f, -0.01914546f, -0.06830671f, -0.07608074f, 0.02611685f, -0.09984843f, 0.11593424f, 
    0.19247597f, -0.34206775f, -0.41909999f, 0.22191507f, -0.22946487f, -0.75854230f, -0.57593608f, -0.64042264f, 
    0.11803482f, 0.27749065f, -0.11867755f, -0.10158222f, 0.20470764f, -0.00796912f, -0.55125725f, 0.09741044f, 
    0.54798377f, 0.34723839f, -0.06883780f, -0.01038521f, -0.01197371f, -0.23684901f, 0.17776279f, -0.11660517f, 
    -0.32620347f, 0.05349087f, 0.09273706f, 0.27352437f, -0.11301028f, -0.26411885f, -0.54344285f, -0.00474976f, 
    0.28086782f, 0.27608746f, 0.25532374f, -0.67672098f, -0.35614893f, -0.08012624f, 0.39384261f, 0.39383203f, 
    -0.09884883f, 0.40981901f, -0.03532820f, -0.02227788f, -0.28575987f, 0.10116734f, -0.00057783f, -0.01042036f, 
    0.08248086f, -0.17048220f, -0.10647775f, -0.11685273f, 0.24007311f, -0.26966164f, 0.26041546f, -0.60637355f, 
    0.10945135f, 0.25837845f, 0.28432998f, -0.13236342f, 0.38194954f, 0.14285992f, -0.37467185f, 0.28963387f, 
    -0.22069117f, -0.39021108f, 0.09160190f, 0.11987678f, 0.28341013f, -0.01693626f, -0.16580027f, -0.02151310f, 
    -0.02240185f, -0.21793789f, 0.40122950f, -0.30388743f, 0.30609629f, 0.43010640f, -0.18878484f, -0.30263585f, 
    0.51060474f, -0.36306909f, 0.17833801f, -0.20684859f, -0.40396488f, 0.65347630f, 0.26929072f, -0.06889471f, 
    -0.75275534f, 0.30316445f, 0.01131239f, -0.22196321f, -0.17795356f, -0.06354063f, -0.15495741f, 0.15102063f, 
    -0.18417259f, -0.10317909f, 0.22165629f, 0.21293923f, -0.15591876f, -0.02663612f, -0.11783423f, 0.00716398f, 
    0.06314202f, 0.86621749f, -0.90037298f, -0.35475826f, 0.35502383f, 0.47181699f, 0.35280147f, 0.46767592f, 
    0.40014389f, -0.13811335f, -0.38842872f, -0.54659736f, -0.43727794f, 0.32621235f, -0.37061933f, 0.37833139f, 
    -0.09905011f, 0.05283000f, -0.00037731f, -0.16622745f, -0.19391455f, 0.10553128f, -0.11358870f, -0.34446728f, 
    -0.00423113f, 0.12644671f, 0.34163460f, 0.15828532f, 0.06525724f, -0.02624038f, -0.35268936f, -0.04664629f, 
    0.05977825f, 0.46844897f, -0.12112544f, -0.23913516f, -0.23890378f, -0.11811922f, 0.32184055f, -0.34748229f, 
    0.06655207f, 0.01238962f, -0.08167043f, -0.21415769f, -0.11484712f, -0.21645215f, 0.12152395f, 0.23589659f, 
    -0.15989269f, -0.09843498f, 0.38548720f, 0.58732110f, 0.39156744f, -0.33573174f, -0.12385149f, -0.13252498f, 
    -0.10985631f, -0.32940695f, 0.27477175f, -0.20946616f, -0.28679076f, 0.25272378f, 0.09907716f, -0.03505145f, 
    0.03941061f, 0.16270052f, 0.06105404f, -0.04516352f, -0.13869829f, -0.12558995f, -0.24200623f, 0.23912893f, 
    0.36659497f, -0.13373329f, -0.25013259f, -0.08535559f, 0.01571827f, -0.38382608f, -0.36431268f, -0.02355324f, 
    -0.02571566f, -0.28560504f, -0.09165954f, 0.01650095f, 0.05671646f, 0.14537016f, -0.53288394f, -0.57537192f, 
    0.20539972f, 0.07562746f, -0.24203007f, 0.41128239f, 0.27986193f, 0.14619124f, -0.05890512f, -0.26200742f, 
    -0.15552108f, -0.06431710f, 0.03475309f, 0.11984648f, 0.12665813f, -0.21855544f, 0.44955567f, 0.00072713f, 
    -0.62239093f, -0.61210811f, 0.25622520f, 0.18533491f, -0.09717950f, 0.61031497f, -0.08111554f, -0.02242002f, 
    -0.36232847f, -0.04163940f, -0.51315832f, 0.11730447f, 0.30673367f, -0.13362917f, 0.11674323f, 0.19666065f, 
    0.22313076f, 0.07471424f, 0.07446662f, -0.19253330f, -0.23652232f, 0.04543459f, -0.57179725f, -0.34165135f, 
    -0.46887746f, 0.06029565f, 0.43378007f, -0.42957392f, -0.29425210f, -0.53962082f, -0.39858675f, 0.10742572f, 
    -0.26471323f, -0.50696945f, -0.16313504f, 0.20274666f, -0.49454102f, -0.19172436f, -0.46086541f, -0.15330705f, 
    -0.03504187f, -0.27538174f, 0.01799638f, -0.11251234f, -0.13015820f, -0.20325436f, -0.14969607f, -0.17396694f, 
    0.23673005f, 0.23587735f, -0.54821092f, -0.61072141f, -0.46673757f, -0.17586407f, -0.59922445f, -0.55844539f, 
    -0.40495086f, 0.18497686f, 0.24833648f, -0.27446175f, -0.17906426f, -0.03931779f, -0.06317420f, -0.06197193f, 
    -0.20776324f, -0.19203475f, -0.36012152f, 0.00841775f, 0.17799017f, 0.11087948f, 0.34464654f, -0.08453008f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.02896275f, 0.06732291f, -0.01992538f, 0.25505272f, -0.04163473f, -0.17713889f, 0.30852231f, 0.06874017f, 
    0.25784966f, 0.03092086f, 0.25914574f, 0.16232461f, 0.11593495f, -0.06045594f, 0.02940455f, 0.06630238f, 
    0.31754145f, -0.02329523f, -0.07699353f, -0.12444912f, -0.00650546f, -0.07182650f, 0.02814724f, -0.26077524f, 
    0.04728329f, 0.16887344f, 0.18622726f, 0.26682985f, 0.24168146f, 0.17127006f, 0.22663289f, 0.12190232f, 
    0.06108211f, -0.19535720f, 0.17630307f, 0.05758348f, 0.02783578f, 0.10958135f, -0.09724956f, 0.18719216f, 
    0.08888807f, -0.20337084f, 0.08526851f, 0.26289764f, 0.26261574f, 0.03054894f, 0.13670905f, 0.42110509f, 
    0.14794911f, 0.17744152f, -0.00295428f, 0.10406327f, 0.34346265f, 0.13226762f, 0.13111238f, 0.27045244f, 
    0.26182070f, 0.26473653f, 0.02425831f, 0.07422600f, -0.15228535f, -0.14678548f, -0.08060601f, -0.01382548f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08826271f, 0.00336952f, -0.04852952f, 0.01795381f, 0.05553715f, 0.02519055f, 0.04473987f, -0.00147861f, 
    -0.00298791f, -0.00356034f, -0.02455543f, 0.03930619f, -0.04850411f, 0.01764029f, -0.05562024f, -0.06348278f, 
    0.02146849f, 0.06770517f, -0.10310245f, 0.10450555f, -0.01488494f, -0.05859872f, 0.03316021f, -0.03878042f, 
    0.30602038f, 0.28178421f, -0.05669092f, -0.27524331f, -0.09574296f, -0.05204029f, -0.06121987f, -0.04749470f, 
    0.02882714f, -0.03479046f, 0.01871552f, -0.04847556f, 0.21637179f, 0.04173011f, -0.06094734f, -0.23678440f, 
    -0.05667229f, -0.04093966f, -0.03772856f, -0.14299551f, 0.07614885f, -0.05692317f, -0.09006831f, 0.00177464f, 
    0.18727703f, 0.12053659f, 0.15993427f, -0.20687163f, -0.10140565f, -0.09212460f, 0.05075017f, -0.05949251f, 
    0.02676050f, -0.03476511f, 0.08828627f, 0.11471490f, 0.26087993f, 0.18773521f, 0.05303225f, -0.05804036f, 
    0.09532831f, -0.01467998f, 0.10530397f, 0.08726729f, -0.09694817f, -0.17792964f, -0.13158858f, -0.04404853f, 
    -0.13729228f, -0.07492760f, -0.02629812f, -0.16387758f, 0.03875253f, -0.03961736f, -0.09322438f, -0.04879332f, 
    -0.01409837f, 0.04091248f, -0.01644439f, -0.01955681f, -0.26876503f, 0.08849715f, -0.09974823f, 0.06602808f, 
    -0.07604828f, 0.06991605f, 0.00339789f, -0.04004589f, -0.00010263f, 0.03073456f, 0.02776156f, 0.00352969f, 
    -0.16007653f, -0.08975779f, 0.24388704f, -0.04839262f, -0.09117144f, -0.03088683f, -0.11164211f, -0.17773153f, 
    -0.00631231f, -0.06013950f, -0.16693787f, -0.13085288f, -0.02387025f, 0.02272520f, 0.04755008f, 0.05425128f, 
    -0.14161243f, -0.01829734f, 0.01764845f, 0.02894412f, -0.20547071f, -0.20368378f, -0.00750938f, -0.01961437f, 
    0.03007023f, -0.02655885f, 0.00801084f, -0.04932980f, 0.02876063f, -0.04678474f, 0.03712806f, 0.02094224f, 
    -0.10908569f, -0.06631999f, -0.09070431f, -0.22052962f, 0.17670572f, 0.19113545f, -0.01746882f, -0.05072985f, 
    0.03014907f, -0.16210853f, -0.02819672f, -0.23338223f, -0.12780237f, -0.20175534f, -0.09539794f, 0.04324783f, 
    -0.05794328f, -0.14842303f, 0.00005662f, 0.05028963f, 0.09394939f, 0.06242092f, -0.01150795f, 0.07316492f, 
    -0.10104799f, -0.05974719f, 0.00376465f, -0.02999265f, 0.24449912f, 0.04421333f, -0.04050154f, -0.07350889f, 
    0.15714626f, 0.15916033f, 0.05814316f, -0.07675881f, -0.02413989f, 0.12552346f, 0.02230434f, -0.06350411f, 
    0.13952194f, -0.11192682f, -0.00744258f, -0.19729747f, -0.00857411f, 0.16239224f, 0.10782170f, 0.01262267f, 
    -0.03089860f, -0.03191851f, 0.01913434f, -0.02381817f, 0.01388708f, 0.07440723f, -0.03693470f, -0.19244736f, 
    0.00966549f, 0.18348630f, -0.00443450f, -0.13834655f, -0.05552891f, -0.07722625f, -0.09307833f, -0.10430648f, 
    -0.10111224f, -0.42132971f, -0.27796173f, 0.15737277f, -0.02090373f, -0.02766495f, -0.21786407f, -0.03637305f, 
    -0.10321923f, -0.09680597f, -0.13014056f, -0.14042497f, -0.20395997f, -0.07867492f, 0.07116535f, -0.02742551f, 
    -0.03495587f, 0.07697403f, 0.03994561f, 0.01023220f, 0.02392359f, 0.10781741f, 0.07822782f, 0.12373469f, 
    0.33142525f, 0.16896011f, -0.05729096f, -0.17007034f, 0.10539415f, 0.12318897f, 0.19806206f, 0.12358607f, 
    -0.01418368f, -0.02899230f, -0.00514866f, -0.06536549f, -0.24853726f, 0.11641086f, 0.09345433f, -0.09460142f, 
    -0.04903856f, 0.02601891f, -0.09377946f, 0.08739999f, -0.04912055f, 0.03598218f, 0.02281588f, 0.04678254f, 
    -0.22434118f, 0.05676033f, 0.12790024f, 0.02606795f, -0.03026208f, 0.01119466f, -0.03258718f, -0.01313914f, 
    -0.04765379f, -0.03574206f, -0.10986897f, 0.06778735f, 0.15406542f, -0.13997661f, -0.19789134f, -0.01352530f, 
    0.02413043f, 0.08781025f, 0.01474365f, -0.00724374f, -0.04338418f, 0.12345567f, -0.00205384f, 0.14373735f, 
    -0.38980627f, -0.02533079f, -0.14681071f, 0.14264329f, -0.05861801f, -0.01116099f, 0.07860190f, 0.04266327f, 
    -0.00389325f, -0.00393581f, 0.12854648f, 0.06662060f, 0.19637324f, 0.07459211f, -0.00516600f, -0.30767563f, 
    0.05732995f, -0.00000900f, 0.09464466f, 0.08088957f, -0.01400076f, -0.00186843f, -0.01469347f, -0.00865247f, 
    0.01927674f, 0.04412717f, -0.00292224f, -0.00603783f, -0.11687967f, -0.18008040f, -0.18319215f, -0.13480714f, 
    -0.04847852f, 0.00413734f, -0.01347501f, -0.03947916f, -0.05220537f, 0.11618940f, 0.17073514f, -0.17486376f, 
    0.04117018f, -0.01756364f, 0.12156375f, 0.04784192f, -0.02832649f, -0.06715430f, -0.01342269f, -0.07416530f, 
    0.14572757f, 0.24904686f, -0.03056291f, -0.44426978f, -0.01884747f, -0.05428091f, 0.10006572f, 0.08584850f, 
    0.03268815f, 0.01259490f, -0.05965429f, -0.03345257f, -0.31899613f, -0.27899367f, -0.25259832f, 0.03845009f, 
    0.00461912f, 0.04942772f, 0.01574264f, 0.03901703f, -0.04285458f, 0.01623221f, -0.02110335f, -0.03313364f, 
    -0.51111293f, 0.02998654f, -0.44106072f, 0.07063577f, 0.03447423f, -0.03117312f, -0.03281281f, 0.06164981f, 
    -0.01255253f, 0.03669076f, 0.04720472f, -0.05177901f, -0.19449243f, -0.10937261f, -0.12198188f, 0.07109932f, 
    -0.10475495f, 0.04143702f, -0.10178635f, -0.08075530f, -0.09513021f, -0.05371153f, -0.13423572f, 0.13170129f, 
    -0.06400653f, -0.31117964f, -0.13867749f, 0.08382132f, 0.04147288f, 0.02088107f, -0.02049255f, 0.00933662f, 
    -0.10771650f, -0.05722281f, -0.05833450f, -0.04421912f, 0.01544705f, -0.18021269f, -0.11179978f, -0.06322753f, 
    -0.02722824f, -0.05924613f, -0.09672832f, -0.13318910f, -0.14619571f, 0.03801560f, -0.07556235f, 0.12567548f, 
    -0.04560732f, -0.22790173f, -0.23820491f, 0.03526135f, 0.00401809f, 0.06512590f, 0.01101765f, 0.04327434f, 
    -0.11944851f, 0.05237916f, -0.12356502f, 0.08247493f, 0.22117043f, 0.20446199f, -0.10400571f, -0.10538900f, 
    0.02313237f, 0.08083229f, -0.06724457f, -0.11974768f, 0.09138346f, -0.13389672f, -0.12028596f, 0.01003562f, 
    0.01691975f, 0.12472666f, 0.18387674f, -0.27001557f, -0.02283433f, 0.05008835f, 0.09485126f, 0.16810443f, 
    -0.00093928f, -0.10857768f, -0.00402008f, -0.03907228f, 0.03607119f, 0.07281704f, -0.02143407f, -0.20592019f, 
    -0.05350812f, 0.06715550f, -0.13810873f, -0.02925912f, 0.02449238f, 0.04712322f, 0.02159977f, 0.02411556f, 
    0.34201136f, 0.21616502f, 0.14559585f, -0.16565594f, -0.01985407f, 0.12170371f, 0.10955653f, -0.09397104f, 
    0.10066052f, -0.03343822f, -0.08746666f, -0.00322894f, -0.23470698f, -0.06616687f, -0.36219391f, -0.03701847f, 
    0.07612283f, -0.03458613f, -0.00933039f, 0.07931317f, -0.03712773f, 0.02101419f, 0.01352910f, 0.06542787f, 
    0.24175021f, 0.06935398f, -0.07106690f, 0.06781930f, 0.06076935f, 0.04426942f, -0.01102842f, -0.01014720f, 
    0.03252872f, 0.12175496f, -0.04741039f, 0.01884547f, -0.56072932f, -0.15848313f, -0.19612020f, -0.04636498f, 
    0.05940187f, 0.06882828f, -0.00203173f, -0.00858200f, -0.05628499f, 0.00344463f, -0.04207198f, 0.05209567f, 
    -0.12422088f, -0.45149198f, -0.16987900f, 0.11258381f, 0.03348711f, -0.00689091f, 0.02074331f, 0.12669569f, 
    -0.20535976f, -0.03345717f, -0.08879658f, 0.02794655f, 0.14285849f, -0.01598155f, 0.17696281f, -0.04257448f, 
    0.01690825f, 0.07941432f, 0.07269195f, -0.05815241f, 0.08901387f, 0.01850189f, 0.17300755f, 0.21188699f, 
    -0.61044246f, 0.10464783f, 0.18883243f, -0.11915629f, -0.00170799f, 0.01266832f, -0.01090095f, 0.02919621f, 
    0.01613363f, -0.03973095f, -0.08622713f, -0.06374799f, 0.34788960f, 0.11027851f, -0.18078044f, -0.11382356f, 
    -0.13791029f, -0.23689300f, 0.04774243f, -0.10259675f, -0.07660757f, -0.13886929f, 0.03378966f, 0.01009838f, 
    0.01753382f, 0.13971321f, -0.02656943f, -0.17816652f, -0.05077738f, -0.10982874f, -0.14719892f, -0.07347687f, 
    -0.01542448f, -0.03151457f, 0.01318928f, 0.01905317f, 0.32686964f, 0.16463923f, 0.09663235f, -0.18829137f, 
    0.03717146f, 0.15751682f, 0.00850080f, -0.06777308f, 0.06803989f, 0.01005934f, -0.00916399f, 0.01725752f, 
    0.10476887f, -0.02861085f, -0.34026715f, 0.02906946f, 0.11036427f, 0.11286651f, -0.12031108f, -0.24709851f, 
    -0.08563449f, -0.27084851f, -0.03869451f, -0.05531732f, 0.04491114f, -0.12778729f, -0.05373357f, -0.22397983f, 
    -0.01376794f, -0.10496135f, 0.09913108f, -0.01282263f, -0.01849412f, -0.02469295f, -0.07217827f, -0.17619918f, 
    0.12275248f, 0.27504593f, 0.27685156f, -0.36372781f, -0.07159647f, 0.03528354f, 0.04741311f, -0.00158391f, 
    -0.00741897f, -0.04019741f, 0.00261982f, -0.23089150f, -0.12029348f, 0.06525825f, 0.06122824f, -0.03838262f, 
    -0.00515824f, -0.01693594f, -0.01533766f, -0.01024403f, -0.02130396f, 0.00931167f, -0.00561887f, 0.00308948f, 
    -0.00259552f, 0.09498361f, -0.06927503f, 0.09325311f, 0.06033247f, 0.08156130f, 0.04968062f, 0.03504393f, 
    -0.12234556f, -0.12455992f, -0.19404098f, 0.08527824f, 0.26546302f, 0.18407485f, -0.13860351f, -0.22530836f, 
    0.01060855f, 0.01664477f, -0.07271712f, 0.01332780f, 0.00357825f, -0.02514040f, -0.03101680f, 0.00346814f, 
    0.13040999f, -0.07146512f, -0.05214200f, 0.05718966f, 0.14430243f, 0.03430013f, -0.24962544f, -0.14239556f, 
    -0.02058733f, -0.06879609f, 0.06823454f, 0.05454467f, 0.19287698f, 0.25641054f, -0.11184561f, -0.11679276f, 
    0.02973530f, 0.03137253f, 0.09333799f, -0.10551208f, 0.00135537f, -0.09162287f, -0.02425464f, 0.00696173f, 
    -0.10616552f, 0.30202481f, 0.28367057f, -0.30751288f, -0.03618537f, -0.01551747f, 0.04783923f, -0.01728625f, 
    -0.02849177f, -0.09645288f, 0.03868620f, -0.05450034f, -0.10159026f, -0.34977823f, -0.06046536f, -0.05283622f, 
    0.00824621f, -0.01720740f, -0.04484871f, -0.00960042f, -0.09524793f, -0.14595972f, -0.07068654f, -0.07821592f, 
    0.21232499f, -0.07196120f, -0.56225926f, -0.18630706f, -0.00455049f, -0.01487845f, 0.03410437f, -0.05773712f, 
    -0.02704520f, 0.01463378f, -0.10357358f, -0.07039677f, -0.02629179f, -0.64749300f, 0.02021826f, -0.09522761f, 
    0.00107925f, 0.02558217f, 0.06123201f, 0.02503412f, 0.12034274f, 0.03590434f, -0.00382650f, 0.00349213f, 
    -0.10192058f, -0.54054475f, -0.13502891f, 0.11883413f, 0.09364967f, -0.02958355f, 0.00842714f, 0.03496381f, 
    0.01258902f, -0.03564302f, 0.04826701f, -0.00789454f, -0.07167166f, -0.22550464f, -0.46250036f, 0.07120774f, 
    -0.22456396f, -0.04661695f, 0.07082443f, -0.08679659f, -0.10492206f, 0.07214577f, -0.03724007f, -0.15514559f, 
    0.17081493f, 0.24427219f, 0.13869902f, -0.01672181f, -0.01491987f, -0.01972574f, 0.13571747f, -0.02572632f, 
    -0.08292385f, -0.01998213f, 0.00593848f, 0.00391504f, -0.18851003f, 0.07379449f, -0.00952297f, -0.00999126f, 
    0.01093390f, 0.30048978f, -0.08665510f, -0.04714416f, 0.03198203f, 0.05155973f, 0.08258253f, -0.05251862f, 
    0.32168964f, 0.19375476f, 0.12016925f, -0.10151766f, 0.02053599f, 0.09347443f, 0.10691541f, -0.02025433f, 
    -0.05288820f, -0.14535719f, -0.15564646f, -0.20085800f, 0.18109764f, 0.10440433f, -0.15010963f, -0.19108276f, 
    0.02896162f, 0.13150916f, -0.06506192f, 0.06045712f, -0.02448769f, -0.04464477f, -0.03386934f, -0.03551108f, 
    0.20125613f, 0.10514110f, 0.09886810f, 0.11377147f, -0.00375237f, -0.02429802f, 0.05864809f, 0.03885487f, 
    -0.00796304f, -0.00643936f, 0.05031233f, 0.00150713f, -0.00092334f, -0.00718054f, 0.09567820f, -0.16005510f, 
    0.21997555f, 0.00609594f, -0.05603207f, 0.10111576f, 0.10355429f, -0.01445408f, -0.14124106f, -0.05683779f, 
    -0.24577917f, 0.12728830f, 0.04171700f, 0.09231292f, 0.04483735f, 0.02067628f, -0.16179200f, -0.15088670f, 
    -0.05330449f, -0.04744828f, 0.00867942f, 0.02988900f, -0.22130625f, 0.02288816f, -0.08146249f, -0.05397685f, 
    0.14187931f, -0.01355333f, 0.04004540f, 0.08536465f, 0.08366042f, 0.14418766f, 0.05993987f, 0.01092375f, 
    -0.20409581f, 0.04479419f, -0.10483126f, -0.29079685f, 0.01026332f, 0.04499574f, -0.01104725f, -0.00274923f, 
    -0.34573790f, -0.28736320f, -0.16172037f, -0.45866898f, 0.05442812f, 0.11553009f, -0.10495836f, 0.00411616f, 
    0.02057614f, 0.08482378f, -0.09441934f, 0.02548615f, 0.05469048f, 0.09286317f, 0.00504375f, 0.03354337f, 
    0.15512189f, 0.01134720f, 0.11980820f, -0.11848795f, 0.04543929f, -0.02888322f, -0.05192912f, -0.04829049f, 
    0.02904318f, -0.02764237f, 0.01618529f, 0.05373829f, 0.18885465f, -0.18364194f, 0.03647622f, 0.05311440f, 
    -0.30041039f, -0.10263275f, 0.17527501f, -0.07456922f, -0.07390233f, -0.00067087f, 0.05835285f, 0.04140773f, 
    -0.40000927f, -0.16649187f, -0.10511047f, -0.23597139f, -0.15044664f, 0.07628978f, 0.11293898f, 0.02955126f, 
    -0.00824174f, 0.04184712f, 0.01803165f, 0.01826015f, 0.03121694f, 0.05910573f, 0.08140770f, 0.02060118f, 
    0.02268901f, 0.07290201f, -0.03386192f, -0.00624250f, 0.09352981f, 0.02006574f, -0.05869244f, -0.00534026f, 
    -0.00688400f, 0.03607966f, 0.09146839f, 0.03438895f, -0.05414517f, -0.00211834f, 0.02441666f, -0.06303939f, 
    -0.02644580f, 0.02589389f, -0.04270473f, 0.06912792f, -0.00519297f, -0.44716465f, 0.08807560f, -0.01061052f, 
    -0.04380986f, 0.03273866f, 0.03180644f, 0.00253808f, 0.06775544f, -0.04570291f, 0.13799842f, 0.04625892f, 
    -0.01718108f, 0.02012875f, -0.11152922f, -0.07737128f, -0.03975386f, 0.01401322f, -0.03681594f, -0.18449180f, 
    -0.02269608f, 0.01384189f, -0.06842854f, -0.00380947f, 0.48961815f, -0.13173279f, -0.15269843f, -0.19501941f, 
    -0.04886813f, 0.05019466f, 0.03478363f, -0.17162985f, 0.11681745f, -0.15867756f, -0.10982401f, -0.16736721f, 
    -0.07586706f, 0.13299967f, -0.06566315f, 0.08175766f, -0.08273993f, 0.10019890f, -0.21043743f, -0.07409355f, 
    -0.06434729f, -0.00882502f, -0.07934678f, 0.05219045f, -0.25864884f, 0.24555375f, 0.02991801f, 0.03897241f, 
    -0.04436840f, 0.06015943f, 0.04118599f, 0.06128212f, -0.03075271f, 0.08641316f, -0.04607852f, -0.05720523f, 
    0.29900882f, -0.04263258f, 0.04636473f, -0.02351579f, 0.00276975f, 0.09182380f, 0.02724399f, -0.14248939f, 
    0.11386913f, 0.04325094f, 0.02965108f, -0.05536140f, -0.12218921f, -0.15612875f, 0.02683359f, -0.04666456f, 
    0.00083431f, -0.00227850f, -0.05989299f, 0.01192525f, -0.14677288f, -0.05636666f, -0.22135557f, -0.31313279f, 
    0.39850730f, 0.21464837f, 0.27454770f, 0.20725790f, 0.16182673f, 0.22283854f, -0.06727796f, -0.06546772f, 
    0.07534689f, 0.05956259f, -0.05043183f, 0.01356742f, -0.13967526f, -0.43141666f, 0.01219346f, -0.56397736f, 
    0.02591466f, -0.08133154f, -0.16632195f, 0.02895219f, 0.04415604f, 0.00749333f, -0.03633160f, -0.04833164f, 
    -0.11019960f, 0.01932537f, 0.01195583f, -0.05037061f, 0.05764110f, -0.02710026f, -0.02629048f, 0.04039617f, 
    -0.27422351f, 0.15684597f, -0.19141571f, 0.11729607f, 0.11844907f, -0.08947661f, -0.12383471f, -0.06360855f, 
    -0.07413228f, -0.03460394f, 0.05502592f, 0.04311098f, -0.07055413f, -0.03735129f, -0.09879281f, 0.08998252f, 
    0.16513674f, -0.24144556f, 0.16584961f, 0.01225362f, 0.08832923f, -0.02372689f, 0.05935854f, -0.06906751f, 
    -0.01879153f, -0.01395987f, 0.14508498f, 0.08629399f, 0.12255572f, 0.13535640f, 0.32169029f, 0.16813216f, 
    0.02131345f, -0.08943906f, 0.01104226f, 0.00418141f, 0.01510111f, 0.01608930f, 0.02571216f, 0.01496919f, 
    0.10680716f, 0.04265374f, -0.02236856f, -0.05505401f, 0.00191497f, -0.05185378f, 0.04697112f, -0.08789235f, 
    -0.00634580f, -0.00152901f, -0.01317943f, -0.04058804f, -0.21469069f, -0.00877677f, 0.00390199f, -0.04025335f, 
    0.07561951f, 0.02198120f, 0.04257310f, -0.13646629f, 0.02813565f, -0.17551154f, -0.18547095f, 0.10591562f, 
    -0.38059127f, 0.15945651f, -0.24513721f, -0.21949543f, -0.06489510f, 0.02604599f, -0.21711242f, -0.13211653f, 
    0.21106863f, -0.07534098f, -0.07417783f, 0.04699833f, 0.22905239f, 0.09263380f, 0.29548612f, -0.08809092f, 
    0.00999675f, -0.02582909f, -0.02387165f, 0.00925575f, 0.04664740f, -0.12309173f, 0.06536535f, 0.06230428f, 
    0.07406093f, 0.07852396f, 0.22163191f, 0.29407445f, -0.00912498f, -0.00763357f, -0.00694662f, -0.07199440f, 
    0.11390106f, -0.05946773f, 0.01262310f, 0.04381065f, 0.23332702f, -0.20203036f, 0.03141837f, 0.08433812f, 
    -0.08189727f, 0.01747828f, 0.16229597f, -0.19505163f, 0.22044526f, 0.00951413f, -0.07931782f, 0.05409069f, 
    0.23606652f, -0.03779012f, 0.15799414f, 0.00996950f, -0.08994496f, 0.02106776f, 0.04607309f, -0.01313227f, 
    -0.00051657f, -0.02639132f, 0.05562386f, -0.00579300f, 0.02102336f, -0.09926067f, 0.05058390f, -0.38564360f, 
    -0.03334131f, -0.03312765f, -0.08179336f, -0.08365420f, -0.01521498f, -0.06989993f, -0.13399217f, -0.00440588f, 
    0.15706706f, 0.12464928f, 0.09854269f, 0.05686680f, 0.00211905f, -0.01185797f, -0.02819809f, 0.00925274f, 
    -0.18071081f, -0.28931648f, -0.13539286f, -0.04821372f, -0.40385446f, -0.09184035f, 0.22976962f, -0.05878414f, 
    0.03624659f, 0.09072176f, 0.04165151f, 0.00990583f, -0.11432629f, -0.03589186f, 0.12925541f, -0.02519086f, 
    -0.65220881f, 0.10052057f, -0.31492114f, -0.00361907f, 0.11262713f, -0.00834881f, -0.05574321f, 0.01565961f, 
    0.01830137f, 0.03971042f, 0.01552030f, -0.07039780f, -0.01021342f, 0.01996128f, -0.16790695f, -0.26309001f, 
    -0.03664737f, -0.29081389f, -0.03359393f, 0.19530024f, -0.01336596f, 0.00301836f, -0.05183036f, 0.05573266f, 
    -0.57522684f, 0.07367840f, 0.01906275f, 0.10615410f, -0.06611671f, -0.08091104f, 0.09607008f, -0.00251652f, 
    0.03346598f, -0.10639841f, 0.04486271f, -0.07735915f, 0.31645715f, 0.16675845f, 0.24695578f, 0.16074853f, 
    -0.03335258f, -0.00313975f, -0.01643500f, 0.02091461f, -0.07154935f, 0.02841865f, 0.04392562f, 0.00248118f, 
    -0.10878721f, -0.09715648f, -0.04493311f, -0.01292280f, -0.06676146f, 0.21013322f, 0.17868388f, -0.03475082f, 
    0.25230154f, -0.05494516f, 0.00042385f, 0.01015009f, 0.13589174f, -0.00186586f, 0.17339501f, -0.08629259f, 
    -0.01379618f, -0.00494724f, -0.00496519f, -0.07910179f, -0.00172651f, -0.01708604f, 0.02625407f, 0.15437315f, 
    0.37554342f, -0.26986814f, -0.03265138f, -0.20277528f, 0.00338897f, -0.00536460f, -0.00680823f, -0.01209546f, 
    0.24496479f, -0.00432382f, -0.01448439f, 0.04404230f, -0.28008559f, 0.06382326f, -0.04806421f, 0.11413211f, 
    0.07008199f, -0.01238214f, -0.05151847f, -0.18436976f, -0.17159751f, -0.24940288f, -0.09366302f, -0.13846436f, 
    -0.29023027f, 0.10229591f, 0.22988337f, -0.21803734f, 0.02711019f, -0.01698598f, 0.01975551f, -0.03472804f, 
    0.13398317f, -0.02974439f, -0.01303293f, -0.08063338f, 0.05907000f, 0.06072281f, -0.06180263f, 0.15951987f, 
    -0.02863947f, 0.01910874f, 0.08533098f, 0.16537985f, 0.17065364f, -0.02708111f, -0.00991798f, 0.01306150f, 
    -0.30647555f, 0.25007185f, -0.10058574f, 0.07855698f, -0.20499559f, -0.14834318f, -0.19332930f, 0.11453418f, 
    -0.01992867f, -0.03672232f, -0.02098919f, 0.00685955f, 0.30821207f, 0.20605347f, -0.04273925f, -0.17961162f, 
    -0.09447640f, -0.09172241f, -0.09561546f, -0.08922061f, -0.01445068f, -0.10993739f, 0.07681573f, -0.07028610f, 
    0.13925660f, -0.20121028f, -0.14962496f, -0.06125919f, 0.05346501f, 0.04775453f, 0.08433717f, 0.11171832f, 
    0.04490472f, 0.12858433f, -0.10876055f, 0.05246410f, 0.00503528f, -0.00397075f, 0.12229548f, 0.08608547f, 
    -0.02545674f, 0.05138160f, 0.03341280f, 0.00322556f, 0.01307799f, 0.12046549f, 0.06766923f, 0.09079253f, 
    -0.07722271f, 0.26553443f, -0.11735993f, 0.08624852f, -0.08737677f, -0.02596122f, 0.11213238f, 0.03954040f, 
    -0.14583556f, -0.01154451f, -0.08161519f, 0.20115675f, 0.09768276f, 0.01334885f, -0.01661537f, 0.05864360f, 
    0.00424060f, -0.00846529f, 0.05575269f, -0.06637878f, -0.03248925f, 0.00568798f, 0.02096284f, -0.05940448f, 
    0.08549411f, -0.11911400f, -0.18323459f, -0.10023934f, -0.09606253f, 0.00601838f, 0.03326868f, 0.00068190f, 
    -0.13709092f, 0.10291971f, 0.14285612f, 0.01734617f, -0.04521528f, 0.09543423f, -0.32148737f, 0.04935242f, 
    -0.16810450f, 0.03317340f, -0.00731033f, -0.14572670f, 0.02005937f, -0.09457100f, 0.00803135f, -0.02803617f, 
    0.12094762f, -0.29044473f, 0.08876245f, -0.02889298f, 0.08055650f, 0.11770941f, -0.10486999f, -0.13116781f, 
    0.18682581f, -0.01139794f, 0.06073079f, 0.00188938f, -0.48282185f, -0.16070919f, -0.05330054f, 0.16982709f, 
    -0.08969554f, 0.15376340f, 0.08958464f, 0.15236425f, -0.06015482f, 0.00503228f, -0.00994436f, 0.09114965f, 
    -0.44556996f, 0.06220280f, 0.17198169f, -0.02926769f, 0.05642759f, 0.08591286f, -0.14723684f, 0.02428712f, 
    0.10154495f, -0.09256630f, 0.08017856f, 0.06685789f, -0.09440444f, 0.18363836f, 0.05151287f, -0.10197756f, 
    0.02879234f, -0.08933524f, 0.01892803f, 0.01125352f, -0.15120043f, -0.00003180f, 0.13304062f, 0.00306649f, 
    0.52291942f, -0.03425664f, -0.25096554f, 0.01704503f, -0.05842360f, -0.06020983f, 0.03241153f, -0.02265971f, 
    0.08736769f, -0.09777603f, 0.17705618f, -0.07205749f, 0.83801359f, -0.15337823f, 0.33449402f, 0.43437389f, 
    -0.04623054f, 0.00870178f, 0.03778520f, -0.02522322f, 0.11510935f, 0.00701710f, -0.10910335f, -0.07655417f, 
    0.52568561f, 0.04735136f, -0.07510129f, 0.13237728f, -0.14477958f, 0.01137835f, 0.03642846f, -0.00435527f, 
    -0.06251001f, -0.00284714f, -0.15584825f, -0.03788276f, 0.08125915f, -0.12513417f, -0.00894429f, -0.13594331f, 
    -0.00841289f, -0.05057450f, -0.04369391f, 0.08391922f, -0.05781767f, 0.01762933f, -0.16960788f, 0.14680426f, 
    0.11745586f, 0.20207033f, 0.19846155f, -0.04072409f, 0.31033751f, 0.07084239f, 0.09875084f, -0.17324841f, 
    0.05464000f, -0.03920665f, -0.03394644f, -0.13577494f, -0.09747247f, 0.01634661f, -0.02807254f, -0.08860800f, 
    -0.13183643f, 0.08212228f, 0.00655596f, -0.05216710f, -0.11744785f, -0.02866847f, -0.18448456f, -0.21874823f, 
    0.01436908f, -0.07138906f, 0.01645600f, 0.11475644f, 0.14442042f, -0.15497658f, 0.13471857f, 0.02012573f, 
    0.06657469f, 0.03701191f, 0.00094912f, -0.10888146f, 0.10420405f, -0.11549870f, 0.06791670f, -0.04016017f, 
    -0.10496775f, -0.07601138f, -0.17465797f, 0.17506722f, -0.08538150f, 0.05959899f, -0.02260800f, 0.12885110f, 
    -0.06398824f, -0.29452962f, -0.08818530f, -0.04801578f, -0.03319147f, 0.00412317f, 0.01278346f, 0.01266956f, 
    -0.04693914f, -0.02639886f, -0.09184143f, -0.02941779f, 0.06048815f, 0.05112715f, -0.04751136f, -0.05315687f, 
    0.01154490f, -0.00802390f, -0.07159580f, -0.03075881f, -0.02442729f, 0.12035644f, 0.01291811f, 0.10604142f, 
    -0.56350988f, -0.44475162f, -0.73314518f, -0.02351648f, 0.01997653f, 0.04798624f, -0.09984322f, 0.05806029f, 
    0.01201806f, 0.03937279f, 0.01234915f, -0.01652120f, -0.11195121f, 0.14664993f, -0.11113239f, -0.16905770f, 
    -0.09828616f, -0.05629476f, -0.03661206f, 0.17716099f, -0.03784195f, 0.15932825f, 0.00560222f, -0.16982041f, 
    0.24356513f, 0.05462310f, -0.11815202f, 0.06560449f, -0.06173152f, -0.03072304f, -0.05951885f, -0.00842072f, 
    -0.07151444f, 0.16910392f, -0.01313145f, 0.02253777f, -0.28103429f, 0.09170652f, -0.14880005f, -0.16453338f, 
    -0.01586412f, 0.09487348f, -0.09276190f, -0.07565231f, -0.06445409f, -0.08617185f, 0.04039776f, -0.01570068f, 
    -0.25557271f, -0.01611605f, 0.20726928f, -0.13248119f, -0.05227540f, 0.03013905f, -0.02736969f, 0.01228947f, 
    0.05573424f, -0.01574993f, 0.00245741f, 0.06747326f, 0.28120098f, -0.26910666f, -0.05414544f, -0.17592645f, 
    0.08834451f, -0.10483134f, 0.09268156f, 0.09653537f, -0.06325314f, 0.01779727f, -0.01606660f, -0.03123899f, 
    0.13463663f, -0.00198112f, -0.31240025f, 0.12129196f, 0.02803342f, 0.01789601f, 0.04701961f, -0.07443470f, 
    -0.00760832f, -0.00873964f, 0.02376257f, 0.03200381f, -0.09694415f, -0.03881804f, -0.07605616f, -0.01709090f, 
    -0.02403268f, 0.01612469f, -0.02739837f, 0.10439621f, -0.08909766f, 0.03606331f, 0.02430607f, -0.02420997f, 
    0.05407616f, 0.02821371f, -0.20945281f, 0.10148133f, -0.09441319f, 0.00447474f, 0.03165260f, 0.05829087f, 
    0.07666162f, 0.01652401f, 0.02770383f, -0.08845386f, 0.10552306f, -0.03435821f, 0.05236613f, 0.07700095f, 
    0.01185104f, -0.02537546f, 0.07840401f, 0.18571876f, -0.02031197f, -0.02624092f, 0.04037632f, -0.15081029f, 
    0.15584929f, 0.24102299f, 0.12912521f, 0.16461748f, 0.01665982f, 0.07433438f, 0.03934829f, 0.07895314f, 
    0.14158535f, -0.03985225f, 0.05907834f, 0.02607115f, 0.11218695f, 0.46030912f, 0.54624903f, 0.25893381f, 
    -0.02003972f, 0.00007878f, 0.04420146f, 0.08739571f, -0.09255501f, -0.24401228f, -0.03271721f, -0.06226835f, 
    0.33545977f, -0.04734004f, 0.16445711f, 0.25318399f, -0.03580174f, 0.07435684f, -0.00182821f, 0.10163987f, 
    0.07801174f, -0.04330299f, -0.05598541f, 0.07958964f, -0.09559429f, -0.11042083f, -0.18327351f, 0.17813523f, 
    -0.15251018f, -0.08168281f, 0.06379961f, -0.07827946f, 0.04529224f, 0.03449584f, -0.06060451f, -0.01141832f, 
    0.00278305f, 0.06247249f, 0.12046398f, -0.21935922f, -0.00261878f, 0.06243149f, -0.16430338f, 0.15371460f, 
    0.13874936f, 0.11092311f, -0.05266883f, 0.09833920f, 0.19622262f, 0.05146362f, 0.03873904f, 0.03148011f, 
    0.03069610f, -0.02047271f, -0.01412429f, -0.06002091f, -0.04512189f, 0.01681386f, 0.01573439f, 0.09214872f, 
    -0.10905934f, 0.02855286f, 0.40384009f, 0.32242504f, -0.05596420f, -0.02095325f, -0.08374246f, -0.00449219f, 
    0.00590212f, 0.04050099f, -0.03287618f, 0.05941709f, -0.03861994f, 0.12579444f, 0.14952746f, -0.49274844f, 
    0.05527700f, -0.05425085f, -0.03319095f, -0.03174709f, -0.00596785f, -0.02832355f, 0.05890579f, 0.00381666f, 
    -0.04774340f, -0.01440618f, 0.00838412f, 0.06739704f, 0.01767527f, -0.05015708f, 0.03362650f, -0.10831536f, 
    0.09379609f, 0.09430312f, 0.04268203f, 0.07915930f, -0.04751853f, 0.06408435f, 0.11995856f, -0.02013665f, 
    -0.02861373f, -0.07418908f, -0.00013006f, 0.04466849f, 0.09150134f, 0.03378703f, 0.20351519f, 0.06140107f, 
    0.14999838f, -0.29983816f, -0.23588133f, 0.00793202f, -0.07725734f, -0.01530434f, 0.07412964f, 0.01863364f, 
    -0.06394051f, 0.00892920f, 0.01060551f, -0.15770148f, -0.23170145f, -0.41815272f, -0.15327397f, -0.16845985f, 
    -0.08581901f, 0.11460555f, 0.04073884f, -0.17475837f, 0.00385974f, -0.05370589f, 0.01422787f, 0.04763693f, 
    -0.07516374f, -0.02069433f, 0.00992740f, 0.03443686f, -0.20173974f, -0.10353686f, -0.08158677f, 0.07046930f, 
    0.01934530f, -0.05868898f, -0.03094558f, -0.00617908f, 0.03679051f, 0.19676788f, -0.15165116f, 0.17820485f, 
    -0.02702722f, 0.08166765f, -0.02495713f, 0.03722168f, 0.04271625f, 0.06982440f, -0.07280492f, 0.08374200f, 
    0.00357039f, -0.38000911f, 0.06159646f, -0.03712211f, 0.05181064f, 0.06149259f, -0.30379578f, 0.03290049f, 
    -0.07020129f, -0.01804153f, -0.00021345f, 0.06838068f, -0.14775245f, -0.04363713f, 0.19114593f, -0.21206899f, 
    0.06146958f, -0.03374900f, -0.01866063f, 0.04595145f, -0.01059467f, -0.09640045f, 0.07045054f, -0.04954814f, 
    0.05828392f, -0.06563979f, 0.06702716f, -0.10233498f, -0.01836982f, 0.01086006f, 0.00332980f, 0.02638321f, 
    -0.03338079f, -0.05286884f, 0.10624545f, -0.08336315f, 0.02308435f, 0.14901109f, -0.05329075f, 0.10126221f, 
    -0.05800122f, 0.01044848f, 0.05262532f, -0.05383955f, -0.03108613f, 0.20463558f, 0.13431937f, 0.09178258f, 
    -0.02597153f, 0.01679871f, 0.04856458f, -0.36094132f, 0.01616899f, 0.00797846f, -0.05225014f, 0.08024906f, 
    -0.01816402f, -0.11684743f, 0.00735446f, -0.10613979f, -0.15879865f, 0.08153114f, 0.02371450f, -0.36023733f, 
    0.00195181f, -0.04565139f, -0.11332645f, -0.11775210f, -0.00166934f, -0.04389054f, 0.13503850f, 0.15407817f, 
    -0.13706350f, -0.27578613f, 0.17697373f, 0.01978055f, 0.01449303f, -0.01775205f, -0.01090244f, 0.00772578f, 
    0.09299024f, -0.00356354f, 0.10572879f, 0.03986162f, -0.09570654f, -0.43098056f, 0.09849621f, -0.16000254f, 
    -0.04260491f, -0.05680639f, 0.04222055f, -0.20312622f, -0.15262799f, -0.01641120f, -0.07360425f, -0.01628204f, 
    0.14928648f, -0.40533802f, -0.19662404f, 0.03755988f, -0.03833058f, -0.11655252f, -0.15143865f, -0.01552899f, 
    -0.00751383f, -0.01957186f, -0.07207950f, -0.08971047f, -0.30703497f, -0.19230683f, 0.07529509f, -0.45107061f, 
    -0.02545376f, -0.08847819f, -0.20763658f, 0.01461513f, 0.02395166f, 0.02168777f, 0.04437807f, 0.05060441f, 
    -0.09943549f, -0.10055938f, 0.04736611f, 0.28184590f, 0.00895878f, -0.01012549f, -0.16313420f, 0.15911163f, 
    0.03654118f, -0.01350674f, 0.05744442f, -0.07744170f, -0.18496890f, -0.00584624f, -0.05065535f, -0.46648759f, 
    0.04018965f, -0.01047160f, -0.03614496f, 0.02308917f, 0.01183489f, 0.00983768f, 0.02125322f, -0.03685107f, 
    -0.14314848f, 0.03234218f, 0.00913919f, -0.02802675f, -0.10748964f, -0.12915704f, 0.18022929f, -0.25274748f, 
    0.06095720f, 0.03015861f, 0.06486892f, 0.03640526f, -0.39969811f, 0.13544974f, 0.13673541f, -0.02117306f, 
    -0.01382464f, -0.01464258f, -0.00735581f, -0.05028607f, 0.01822823f, -0.03981710f, 0.05699971f, 0.01872709f, 
    -0.26294646f, 0.65498203f, -0.07105193f, 0.10144739f, -0.03491753f, 0.03792223f, 0.00172655f, -0.26642400f, 
    -0.04617006f, -0.04697822f, -0.11439501f, 0.09743136f, -0.03196801f, -0.01102655f, -0.01560234f, 0.13744989f, 
    -0.06298893f, 0.02713924f, 0.04982854f, 0.05522872f, 0.12810694f, -0.00224221f, 0.05008036f, -0.04936547f, 
    0.02695136f, -0.06783126f, -0.01501192f, 0.02349546f, 0.02026713f, 0.03213364f, -0.01500120f, 0.06082966f, 
    -0.05539371f, 0.00161927f, -0.08078373f, 0.14296585f, -0.08204809f, 0.20050515f, -0.13486949f, 0.18155856f, 
    0.08293108f, 0.02617705f, 0.00236921f, 0.16475977f, -0.03044521f, 0.00884116f, 0.06845473f, -0.10244887f, 
    -0.36288223f, 0.13801061f, -0.03051444f, -0.08230522f, -0.05549275f, -0.09329703f, 0.03170254f, 0.11104524f, 
    -0.01920504f, -0.02242711f, 0.04354357f, -0.01350989f, 0.02821607f, -0.05520778f, 0.33187166f, 0.41875437f, 
    0.04039027f, -0.08531729f, -0.03802884f, 0.27027926f, 0.06130327f, 0.02027232f, 0.02389004f, 0.02511278f, 
    -0.02875544f, -0.16172919f, 0.07708192f, -0.10304724f, 0.07269035f, -0.00523923f, -0.05656782f, -0.13257410f, 
    -0.03884395f, -0.25574803f, -0.07778240f, -0.04656965f, -0.01109318f, 0.05875130f, -0.15260315f, 0.09609625f, 
    0.03071194f, 0.04723000f, 0.06550164f, 0.00991242f, 0.04334547f, 0.01195093f, 0.00922532f, -0.04476868f, 
    0.03542588f, -0.02451162f, -0.17800392f, 0.20541406f, 0.05489848f, 0.01661795f, 0.01683312f, 0.05479487f, 
    0.00619266f, -0.16549934f, 0.07389873f, -0.09706688f, -0.07039800f, 0.02891113f, -0.16161948f, 0.11436940f, 
    -0.02224606f, 0.04429468f, -0.00960150f, 0.00840423f, -0.02006842f, -0.02860201f, 0.02808920f, -0.02143732f, 
    0.01165439f, 0.01015342f, 0.34471437f, 0.06295506f, -0.04687987f, -0.00645514f, 0.04746970f, 0.08100644f, 
    -0.09806923f, -0.04716274f, 0.04662717f, 0.07814699f, -0.17216110f, -0.30386454f, -0.12286441f, -0.00420857f, 
    0.10785285f, 0.06550821f, 0.06139213f, 0.08856407f, 0.05116510f, 0.00682897f, 0.10400259f, -0.04543480f, 
    -0.04272731f, 0.44018784f, -0.13989165f, 0.26890633f, -0.07552426f, 0.03805914f, 0.15374537f, -0.05169037f, 
    -0.03710204f, 0.14320222f, 0.02479152f, 0.03048537f, -0.13157809f, 0.08792989f, 0.00063734f, 0.07207003f, 
    0.00457969f, -0.11548296f, 0.12219711f, 0.06591982f, 0.02601783f, -0.01994660f, 0.02056365f, -0.02043159f, 
    0.15088481f, -0.03675029f, -0.17959237f, 0.12798803f, -0.11136997f, 0.10272267f, -0.04684700f, 0.02654206f, 
    0.01465906f, -0.12946649f, 0.04121763f, 0.04465068f, -0.05293895f, 0.11877599f, -0.15350793f, 0.10222252f, 
    0.09454189f, -0.14527629f, 0.07540193f, 0.01119095f, 0.08669816f, 0.18617079f, 0.10884282f, -0.16671127f, 
    -0.08684577f, 0.07373341f, 0.16328698f, -0.18334979f, -0.01188236f, 0.00090413f, -0.09892739f, 0.09274717f, 
    0.07577337f, 0.11902257f, 0.08684169f, 0.01936292f, 0.06074483f, 0.09281486f, -0.11135993f, 0.19434781f, 
    -0.00888582f, -0.01665285f, 0.00227412f, -0.05111188f, -0.01163294f, 0.01461553f, 0.08233382f, -0.22243716f, 
    -0.03909383f, -0.00894028f, -0.09160935f, -0.08747493f, -0.01141777f, 0.06152819f, -0.04771486f, -0.00475489f, 
    -0.02808965f, -0.00690253f, 0.04823716f, -0.16586989f, -0.34667811f, -0.15235096f, -0.06052750f, 0.07712953f, 
    -0.03337921f, -0.06327020f, -0.35030308f, -0.00963865f, 0.11736279f, 0.00403912f, -0.17507112f, 0.14535718f, 
    -0.12534405f, -0.11195073f, 0.04856592f, 0.12891105f, -0.08169564f, 0.16060829f, 0.05845663f, -0.27040714f, 
    0.00701440f, -0.04012612f, 0.02691442f, 0.01463403f, 0.06634937f, 0.20159914f, -0.03641004f, 0.01579710f, 
    -0.09541452f, -0.09128163f, -0.16750392f, 0.00857369f, -0.00306473f, 0.06208144f, -0.03504859f, 0.03219428f, 
    -0.28652534f, -0.28638348f, -0.06003229f, -0.12049972f, 0.05512369f, 0.10591432f, -0.06839405f, -0.06737702f, 
    -0.01723433f, -0.04438550f, 0.03584123f, -0.10602562f, -0.32036468f, -0.36736441f, -0.03387927f, -0.43816417f, 
    0.20414004f, -0.13678861f, -0.04884421f, -0.14586279f, -0.00626349f, -0.07753316f, -0.11372780f, 0.03093670f, 
    -0.49966294f, -0.30704921f, -0.23137482f, 0.04632288f, -0.06443870f, -0.16691507f, -0.16682965f, 0.01019020f, 
    -0.05616643f, -0.12221257f, 0.11296954f, -0.07112651f, 0.27818444f, -0.00843716f, 0.35052121f, 0.05021173f, 
    -0.29410872f, 0.11259599f, -0.00588258f, -0.03420856f, 0.06030220f, 0.13660985f, 0.02825315f, -0.01434552f, 
    0.01698029f, -0.18818192f, -0.10991462f, 0.00156220f, 0.12586319f, 0.14555357f, -0.02140768f, 0.13735141f, 
    -0.00916365f, 0.09521358f, -0.00218193f, -0.15333039f, -0.08493162f, 0.14980201f, -0.34371454f, -0.09650523f, 
    0.09018802f, 0.07654905f, 0.08631619f, -0.05993768f, 0.00371441f, -0.15415250f, 0.00830407f, -0.21907350f, 
    -0.12006541f, 0.19524844f, -0.11786364f, 0.12789270f, 0.04223332f, -0.00875609f, -0.10982788f, -0.01786347f, 
    -0.04525982f, 0.00228978f, -0.16261634f, -0.00309236f, -0.07250531f, -0.06565685f, 0.01198218f, 0.11194461f, 
    0.00870063f, 0.10171447f, 0.00151128f, 0.04311807f, -0.03567802f, -0.01225449f, -0.05773784f, -0.03382174f, 
    -0.22444202f, -0.22209510f, 0.35772449f, -0.02147049f, -0.16420451f, -0.17731813f, -0.14846776f, -0.00957179f, 
    0.06773128f, -0.10040960f, -0.04340725f, -0.03358307f, 0.45123947f, 0.08586677f, 0.10980789f, -0.07005485f, 
    -0.04223146f, 0.01110801f, -0.22034316f, -0.09503770f, -0.04450182f, -0.04703978f, 0.18300660f, -0.12826079f, 
    0.27233753f, 0.06992407f, 0.05747890f, -0.09701605f, -0.02037777f, -0.04135722f, -0.07443233f, -0.02062580f, 
    0.03867155f, -0.08134448f, 0.22713247f, -0.00699037f, -0.02354678f, -0.01265191f, 0.13601528f, -0.14122032f, 
    -0.16135505f, -0.02934205f, 0.00690003f, -0.07783685f, 0.06510581f, 0.02358267f, -0.07844669f, -0.22838074f, 
    -0.32488543f, 0.22291550f, -0.34056410f, -0.65630406f, -0.03003787f, 0.07082222f, -0.00454761f, 0.10865907f, 
    -0.10834852f, -0.12075222f, 0.04628634f, -0.16820915f, 0.11042978f, 0.43304157f, -0.57933348f, -0.13207035f, 
    0.12183139f, -0.08565143f, 0.04496393f, -0.14316152f, -0.06153190f, -0.13793983f, 0.05130967f, 0.01100027f, 
    0.27816606f, -0.27423289f, -0.05022614f, 0.16049196f, 0.05576828f, 0.07599922f, 0.00587817f, -0.08962370f, 
    -0.11909753f, 0.01427538f, -0.03282328f, -0.03723357f, 0.03421838f, -0.22662099f, 0.05322994f, 0.16065846f, 
    0.20350568f, 0.10110388f, 0.05933619f, -0.00215847f, -0.00216098f, 0.03517229f, -0.00661940f, 0.04672618f, 
    0.10055801f, 0.00333446f, -0.14866225f, 0.18995929f, -0.01322541f, -0.09561728f, -0.01633040f, -0.07737565f, 
    -0.09326728f, 0.11628984f, -0.01795151f, -0.01156680f, 0.08038231f, 0.28324908f, 0.01432642f, -0.16378978f, 
    -0.05953012f, -0.07652880f, 0.00942727f, 0.00292187f, -0.01409663f, 0.18427889f, 0.04221967f, -0.00609657f, 
    -0.26204953f, -0.00627467f, -0.02477085f, 0.18850991f, -0.04576384f, -0.12528236f, 0.02317653f, 0.04796046f, 
    -0.13038553f, -0.12713580f, 0.01852395f, -0.04918919f, 0.44424301f, 0.04730639f, 0.08655477f, 0.09378469f, 
    0.19592947f, -0.03933121f, 0.04536920f, -0.01357285f, -0.10483276f, -0.03531066f, 0.07285739f, 0.06788446f, 
    -0.13745350f, -0.09542123f, -0.05772550f, 0.11059269f, 0.02604439f, -0.03159368f, -0.00705076f, 0.03193657f, 
    -0.04990370f, 0.13609605f, -0.07913973f, 0.11034190f, 0.17743224f, -0.27184281f, 0.40816194f, -0.03499356f, 
    -0.09527428f, 0.14929396f, -0.16069190f, -0.01050065f, 0.02126555f, 0.05660057f, 0.01644109f, 0.07603033f, 
    0.06291499f, -0.09273623f, -0.10673581f, 0.02465377f, -0.23331249f, -0.06107194f, -0.04485381f, 0.08589801f, 
    -0.04211560f, 0.19333407f, 0.05922188f, 0.00885249f, -0.25860235f, 0.12717806f, -0.00433910f, 0.13394111f, 
    0.17188267f, 0.17785200f, -0.07765138f, 0.00361474f, -0.13570854f, 0.03401380f, 0.09959038f, 0.06859290f, 
    0.13847749f, -0.02715118f, 0.19307111f, -0.21490413f, -0.07332106f, -0.16143569f, -0.04957707f, -0.09291475f, 
    0.11197837f, -0.03487433f, 0.00205765f, 0.04291463f, 0.04430128f, -0.00005290f, -0.07056823f, 0.21664207f, 
    -0.00609718f, 0.04142076f, -0.03995585f, 0.06095313f, -0.13817024f, 0.09140597f, -0.17456973f, -0.06798475f, 
    -0.17098796f, -0.06558828f, 0.23036095f, 0.00023117f, -0.11078981f, -0.10060709f, -0.09593046f, -0.08168538f, 
    0.04513935f, 0.01105352f, -0.16357461f, -0.10555294f, 0.02169169f, -0.08599103f, -0.07050772f, -0.24929662f, 
    0.03696871f, -0.03038616f, -0.06194525f, -0.00364672f, -0.01110425f, 0.06147705f, -0.02754206f, -0.10441525f, 
    0.12198915f, -0.01596818f, -0.21078683f, 0.11274917f, -0.12419690f, -0.05820081f, -0.09525577f, 0.03352808f, 
    -0.09009342f, 0.17944221f, -0.13069753f, 0.01692074f, -0.44365615f, -0.02500377f, -0.07278700f, -0.09789758f, 
    -0.12852398f, -0.14378381f, -0.04181804f, -0.13126788f, 0.01001287f, 0.07913189f, -0.11012889f, -0.00106601f, 
    0.21927831f, -0.13381869f, 0.11435538f, -0.09796000f, -0.09612390f, -0.10248425f, -0.13155374f, 0.02016370f, 
    -0.00507571f, -0.00945460f, 0.03036265f, 0.01040460f, -0.00284351f, 0.19730949f, -0.19945802f, 0.18471088f, 
    0.04566845f, 0.02830283f, 0.04984177f, -0.04707888f, -0.05218385f, 0.09136295f, -0.02372755f, -0.16845043f, 
    -0.24996708f, -0.09585612f, -0.04522076f, 0.23120327f, 0.07993052f, -0.09407409f, -0.07044071f, -0.10222636f, 
    -0.01161247f, 0.00106519f, 0.10327915f, 0.01304840f, -0.33546841f, 0.02642235f, 0.11924940f, 0.14147896f, 
    -0.00700931f, 0.03088086f, -0.23491545f, -0.02804981f, 0.12566474f, 0.05576556f, 0.05919769f, -0.00196065f, 
    0.28118980f, 0.09714411f, -0.23084685f, -0.26831046f, 0.15945706f, 0.11020032f, 0.14182457f, -0.03629582f, 
    -0.14156674f, 0.03262258f, 0.05115741f, -0.13447347f, -0.00643061f, -0.07291153f, 0.06039512f, 0.28915823f, 
    0.06812160f, 0.00529216f, 0.12529114f, 0.21564496f, -0.07903209f, 0.00991646f, -0.07813236f, 0.06569675f, 
    0.27337572f, 0.12566276f, -0.07113998f, -0.06293682f, -0.04663219f, -0.08993910f, -0.02034569f, 0.00390274f, 
    -0.04484437f, -0.00786856f, -0.08940265f, -0.00728329f, 0.06434333f, -0.14065632f, 0.18966910f, 0.08878516f, 
    0.09420824f, 0.17479515f, 0.05474371f, 0.02396061f, 0.08422781f, 0.00688788f, 0.08416177f, 0.04870756f, 
    0.12937649f, 0.19278897f, -0.12933527f, -0.28978544f, -0.00375917f, -0.00362205f, -0.03530550f, 0.05203710f, 
    -0.15700410f, -0.10536849f, 0.02413816f, -0.00098098f, -0.20047227f, 0.00161991f, 0.13598977f, -0.11386830f, 
    -0.00060566f, 0.19851354f, 0.02140085f, 0.04529430f, -0.06170077f, 0.11964668f, 0.01597910f, 0.05334156f, 
    -0.32085660f, -0.15718730f, -0.09949242f, 0.28442514f, 0.13906969f, 0.14041328f, 0.07926863f, -0.00952201f, 
    0.00877900f, -0.14664710f, 0.22967613f, -0.03578492f, -0.49625745f, -0.15702249f, -0.18836744f, -0.11036403f, 
    -0.16877413f, 0.10696693f, -0.10786428f, 0.04187285f, 0.08057085f, 0.26222533f, -0.24444830f, 0.01677024f, 
    -0.46959496f, -0.01196289f, 0.04436679f, 0.48982194f, -0.07945992f, 0.12565379f, -0.13216673f, -0.04904972f, 
    -0.03952928f, 0.04996906f, 0.04362798f, 0.09672482f, 0.25475076f, 0.14065243f, -0.23069441f, -0.11346631f, 
    0.09334458f, 0.09308057f, 0.11396602f, 0.01488490f, -0.08164976f, 0.05085904f, 0.11055133f, 0.05002853f, 
    0.28848895f, 0.02364268f, -0.01542382f, -0.13681901f, 0.04475765f, 0.11658641f, 0.04339955f, -0.06160874f, 
    -0.11720773f, -0.10215829f, 0.08088561f, -0.09640660f, -0.32619756f, 0.62742549f, -0.00684861f, 0.14056671f, 
    0.01735202f, -0.01055556f, -0.13234843f, -0.07440894f, -0.24370492f, -0.05294382f, 0.06798605f, 0.10100620f, 
    -0.00957071f, 0.06196847f, -0.12170863f, 0.25723156f, 0.04499300f, -0.04490285f, 0.01598010f, -0.06620906f, 
    -0.08508926f, 0.01358271f, -0.09295199f, 0.09487867f, -0.21551113f, -0.14168645f, 0.03404547f, -0.14993061f, 
    0.14412239f, 0.10346059f, 0.01012250f, -0.20507446f, -0.13374057f, -0.02106712f, 0.05072481f, 0.12139013f, 
    -0.00806565f, 0.06431384f, 0.01044059f, 0.29474971f, 0.00100057f, -0.16114987f, -0.00894901f, -0.12258521f, 
    0.03245445f, 0.16783887f, 0.07162413f, 0.02197687f, -0.37394342f, 0.32038632f, -0.26057643f, -0.53677708f, 
    0.09636904f, -0.02301775f, -0.05329150f, 0.14966668f, -0.11970768f, -0.06015702f, -0.01198402f, -0.20885581f, 
    -0.05863568f, 0.17896074f, 0.02518605f, -0.60212111f, 0.17397018f, 0.09744223f, 0.00378740f, 0.13585195f, 
    0.04194472f, -0.04013814f, -0.04883649f, 0.00241809f, -0.43548602f, 0.11091249f, -0.24309961f, -0.12771812f, 
    0.01636485f, -0.18018645f, -0.10488567f, -0.21783352f, -0.08805746f, -0.15074250f, -0.02831050f, 0.08594544f, 
    -0.11439422f, 0.05587432f, -0.02794478f, -0.05901697f, 0.17902000f, 0.09737838f, 0.08223730f, -0.12481312f, 
    -0.17053849f, 0.01146587f, 0.05915976f, 0.02120334f, -0.09370095f, 0.00479892f, -0.18348943f, 0.09650726f, 
    0.00254177f, 0.04841672f, -0.03618148f, -0.14794889f, -0.07901277f, 0.01233317f, 0.08396342f, -0.04912162f, 
    -0.16676240f, -0.07735524f, 0.04971039f, 0.26926491f, -0.07630046f, -0.04730128f, 0.04567322f, -0.01368512f, 
    -0.05062801f, 0.01098339f, 0.04025069f, 0.07423022f, 0.06721917f, -0.06047143f, -0.19127966f, -0.03146015f, 
    0.10738674f, 0.07207683f, 0.04668073f, 0.02180540f, 0.05789966f, 0.01719748f, 0.10444463f, 0.00934368f, 
    0.36472258f, 0.21852328f, -0.35475045f, -0.34087113f, -0.16183746f, -0.08716931f, -0.05289927f, -0.09877878f, 
    0.07343336f, 0.06724037f, -0.05923615f, -0.03785460f, 0.00302313f, 0.49907619f, 0.01868757f, -0.13175377f, 
    -0.04900660f, 0.14735961f, -0.12827915f, 0.14553949f, -0.22646843f, 0.05899761f, -0.15314773f, -0.15510103f, 
    -0.61750484f, 0.11454769f, 0.15444626f, 0.12017169f, -0.05175143f, -0.04020992f, 0.00876775f, -0.05168342f, 
    -0.09173555f, -0.15254356f, 0.01340420f, -0.01010610f, -0.34873453f, 1.11323106f, -0.69722474f, 0.06357995f, 
    0.07122248f, -0.03576561f, -0.02084316f, -0.06869189f, -0.11910070f, 0.04745513f, -0.08233480f, -0.20738484f, 
    -0.06748430f, 0.21499117f, 0.04613764f, 0.20551375f, 0.09829216f, 0.03415326f, -0.25341344f, 0.04746719f, 
    -0.12304320f, -0.00255156f, 0.00580728f, 0.05678511f, -0.18192233f, 0.01119608f, 0.21221256f, 0.14271982f, 
    0.12288266f, 0.20149034f, -0.05271360f, 0.04871304f, -0.06519665f, -0.12080615f, 0.03494560f, -0.04698414f, 
    -0.03092766f, -0.03066781f, -0.28709537f, 0.06377915f, -0.29227674f, -0.06935802f, -0.06041216f, -0.10311101f, 
    -0.10821398f, 0.01186558f, -0.07213569f, -0.11938647f, 0.71328789f, -0.30092072f, 0.14369744f, 0.25372431f, 
    0.00413957f, 0.07759805f, -0.10575101f, 0.22458479f, 0.03093727f, -0.13109660f, 0.09221712f, -0.02385883f, 
    -0.02159690f, -0.02434443f, -0.19284546f, 0.04596912f, -0.01540800f, 0.01754395f, 0.01907352f, 0.05320730f, 
    -0.01544579f, 0.01616143f, 0.03943582f, -0.02625860f, 0.12497211f, 0.00447014f, 0.08643492f, 0.19435251f, 
    0.05574158f, 0.01641049f, -0.00296419f, 0.03651326f, -0.01399459f, 0.05438281f, -0.04448059f, 0.00928820f, 
    0.10260446f, 0.10735969f, 0.00888652f, 0.08332212f, 0.08501371f, 0.13066553f, 0.02413665f, 0.02504033f, 
    0.11470746f, -0.00276020f, -0.02244156f, -0.06296110f, 0.02574436f, 0.03500486f, -0.16869363f, 0.07410293f, 
    -0.13153355f, -0.02807310f, -0.07930152f, -0.14481516f, -0.12100393f, -0.07642195f, -0.02047114f, 0.12733360f, 
    0.13466464f, 0.12440964f, 0.35118714f, 0.12568131f, -0.13318658f, -0.11317047f, 0.03057187f, 0.09821513f, 
    0.15506624f, 0.00330191f, -0.02013450f, -0.04315355f, -0.12047080f, -0.18187305f, 0.12510000f, 0.10018089f, 
    0.03496243f, -0.25794318f, -0.14489006f, 0.05068256f, -0.34953451f, -0.05694615f, -0.02776892f, 0.02009091f, 
    -0.02892251f, -0.05213697f, 0.01925331f, 0.07165308f, -0.02196373f, -0.03547072f, -0.01797173f, -0.00454781f, 
    0.12978083f, 0.17353325f, 0.14772177f, 0.38459170f, -0.03073633f, 0.06314020f, 0.00600045f, 0.06585319f, 
    -0.04011681f, 0.01234404f, -0.01209711f, 0.05097815f, 0.05727569f, 0.02580671f, 0.05340211f, 0.01098615f, 
    0.00363246f, 0.05553289f, -0.12830327f, 0.12707296f, 0.02978766f, -0.01655596f, 0.05563859f, -0.07950412f, 
    0.03222761f, 0.03283586f, 0.03057550f, -0.03608105f, 0.11617099f, 0.04043826f, -0.15950359f, -0.05708340f, 
    0.06418125f, -0.05603440f, -0.18584783f, 0.01789122f, 0.09053399f, -0.07817042f, -0.13134816f, -0.10897590f, 
    -0.02341500f, -0.02480843f, -0.00173856f, 0.06408364f, -0.07794889f, -0.06737304f, -0.00670511f, 0.01267621f, 
    0.03733443f, -0.07286631f, -0.04890493f, -0.16895337f, 0.04818796f, 0.02175065f, 0.02018294f, 0.06601087f, 
    0.06915028f, -0.03091457f, 0.02908095f, 0.01182188f, -0.12156138f, 0.00804951f, -0.04728963f, 0.02156748f, 
    -0.00392273f, -0.31553388f, 0.12695371f, -0.08142811f, -0.02026074f, 0.02933682f, 0.02813575f, 0.05441810f, 
    -0.17176223f, -0.00208471f, 0.04177392f, -0.05037033f, -0.15109603f, -0.29021117f, -0.08590662f, 0.14735802f, 
    0.04208064f, 0.05994630f, -0.10832102f, -0.05256679f, -0.08881818f, 0.07046793f, -0.16221943f, -0.10421081f, 
    0.11146952f, 0.16510355f, 0.02982915f, 0.04970802f, -0.05781741f, -0.10439604f, -0.08716279f, -0.00096989f, 
    0.03633863f, -0.09120321f, 0.02331137f, 0.00009815f, 0.10144223f, 0.15607721f, 0.19447167f, 0.24916911f, 
    -0.09941056f, -0.09008717f, 0.00623108f, 0.01672333f, 0.00408478f, -0.04837510f, 0.03980730f, 0.11896978f, 
    0.10510199f, 0.09568592f, 0.17833808f, 0.02573020f, -0.03030436f, -0.15141559f, -0.00913848f, -0.12646860f, 
    0.05606288f, -0.05630252f, 0.09376876f, -0.04178598f, 0.10867654f, -0.25112301f, 0.25789800f, -0.08763488f, 
    0.03937925f, -0.09076120f, -0.04626723f, 0.06740715f, -0.07298841f, -0.15177247f, -0.16125663f, -0.17796199f, 
    -0.07015321f, 0.18759854f, 0.00771163f, -0.15909430f, 0.10215883f, -0.00695073f, 0.06263288f, 0.00165584f, 
    -0.08028858f, 0.16216555f, -0.13271564f, -0.26604101f, -0.06022891f, -0.15127903f, -0.13368025f, -0.04700969f, 
    -0.06881779f, -0.06841628f, 0.00027336f, -0.00833974f, 0.01667446f, 0.05501928f, 0.10872060f, 0.14563283f, 
    -0.04151947f, -0.07364544f, -0.03920127f, 0.08882103f, -0.01195404f, -0.08628907f, -0.05827498f, -0.07953088f, 
    -0.03761096f, -0.05567187f, 0.06414297f, 0.05908764f, 0.38055462f, 0.03785487f, -0.19629417f, 0.27283156f, 
    0.01769003f, -0.09487917f, 0.18128192f, -0.03084064f, 0.09891368f, -0.08331570f, 0.13220519f, 0.05235954f, 
    0.11222367f, 0.11571556f, -0.00449684f, 0.03530897f, -0.02277926f, -0.00584165f, -0.06486116f, -0.06775691f, 
    0.01595146f, -0.01886701f, 0.01295402f, 0.22756329f, -0.01362416f, -0.11693400f, 0.14638573f, 0.05784861f, 
    0.01205858f, -0.01900919f, 0.00220142f, -0.07792500f, 0.29354516f, -0.08885852f, -0.10292160f, 0.14647396f, 
    -0.15507312f, -0.01735197f, -0.15712558f, -0.25933748f, 0.06958912f, 0.05026595f, -0.05906046f, -0.05405712f, 
    -0.03682104f, 0.00148276f, -0.08868392f, -0.09429409f, 0.04329877f, 0.09014204f, 0.12247715f, 0.18798915f, 
    -0.01455724f, 0.00517584f, 0.03548739f, 0.02976709f, 0.03054996f, 0.01293791f, 0.06288614f, 0.00259160f, 
    0.07752719f, 0.08524903f, 0.00587835f, 0.04065381f, 0.02218806f, -0.09143014f, 0.11849956f, 0.06526819f, 
    0.01545086f, -0.03287962f, -0.07194242f, -0.05086387f, 0.07013237f, -0.06523442f, -0.03719995f, -0.04496177f, 
    -0.13869950f, -0.07064325f, 0.00924608f, 0.01053986f, -0.05305377f, 0.01988697f, -0.07736453f, 0.01893001f, 
    0.11274799f, 0.05647950f, 0.09835009f, 0.21157651f, -0.01507188f, -0.08360290f, -0.11020113f, -0.24258013f, 
    -0.24169721f, -0.04038600f, -0.00449959f, -0.11856228f, 0.08633579f, -0.29483375f, -0.29569298f, 0.01274508f, 
    0.06955973f, 0.02902448f, 0.01883269f, 0.03014334f, -0.04138818f, 0.11292496f, -0.01802418f, -0.05025486f, 
    -0.11353068f, -0.20829907f, -0.13287590f, -0.07523590f, 0.03644490f, 0.03851785f, -0.04011978f, 0.06760804f, 
    0.00198710f, 0.01546424f, -0.04134161f, 0.01591693f, -0.00051074f, -0.03313762f, 0.09571949f, -0.49268630f, 
    -0.04668233f, -0.03658797f, -0.21616060f, -0.05566061f, -0.11198089f, -0.21863019f, 0.01504168f, -0.07348150f, 
    -0.02565310f, 0.10880220f, 0.01001090f, 0.01540429f, 0.12162348f, -0.04788523f, 0.02190495f, 0.02563876f, 
    -0.11524413f, 0.07689875f, -0.07382040f, -0.12603846f, 0.03277719f, 0.10554811f, -0.04315834f, 0.10688496f, 
    0.07103132f, -0.05423877f, -0.01003661f, -0.14493026f, 0.04752527f, -0.01548253f, 0.02955755f, -0.03256591f, 
    -0.10988790f, -0.13579951f, -0.07404988f, 0.07352142f, 0.03411964f, 0.00540990f, 0.07987983f, 0.01480361f, 
    0.04910670f, -0.11338907f, 0.00499024f, 0.08732598f, 0.16915743f, 0.12561683f, 0.09492129f, 0.24545819f, 
    -0.08014572f, -0.07070421f, 0.00034586f, 0.02095940f, 0.15568739f, 0.11696850f, -0.04252301f, 0.09092005f, 
    -0.16077384f, 0.02631225f, 0.04074091f, 0.26905686f, -0.13767233f, -0.00716902f, -0.21712349f, -0.22086425f, 
    0.06242999f, -0.02632613f, -0.01138165f, -0.02862800f, -0.01683136f, 0.24238314f, 0.04093754f, 0.32123423f, 
    0.11264018f, 0.11947572f, -0.02625797f, 0.07900465f, 0.08557659f, -0.02722312f, -0.03175433f, -0.05946275f, 
    -0.13479745f, -0.25642884f, 0.09541883f, 0.08784334f, -0.23721768f, 0.06091179f, -0.22582728f, -0.03825907f, 
    -0.05165728f, 0.04264335f, -0.05720828f, 0.09403252f, 0.25550583f, -0.11712667f, -0.08216110f, -0.10157426f, 
    0.05385055f, 0.02092275f, 0.07900699f, -0.00096658f, 0.03095553f, -0.05490243f, 0.08493783f, -0.01525132f, 
    0.12733738f, 0.09159875f, 0.19958156f, 0.07801895f, 0.06730390f, -0.07406560f, 0.12508242f, -0.02796081f, 
    0.06138074f, 0.03902124f, -0.05048330f, 0.07312862f, 0.05465282f, -0.10742769f, -0.01818669f, 0.08248854f, 
    0.01722940f, -0.00892673f, 0.02363580f, 0.08808663f, 0.10780478f, -0.02907206f, 0.07127029f, -0.03579605f, 
    -0.29298452f, -0.02281308f, 0.04526443f, 0.00693716f, 0.08957691f, 0.05775620f, 0.02833286f, 0.00647034f, 
    0.04666739f, -0.15277363f, 0.05424416f, 0.02788294f, -0.33750939f, -0.02983525f, -0.09310459f, -0.13707350f, 
    -0.03814451f, 0.04981463f, -0.02865667f, 0.06516323f, 0.05407751f, 0.08589976f, -0.08877037f, 0.25978863f, 
    0.13426155f, -0.16566144f, -0.33033338f, -0.16533165f, 0.05614046f, -0.06581640f, 0.09259278f, 0.07192640f, 
    0.00260280f, 0.01723328f, -0.02200979f, 0.00850194f, 0.07580959f, -0.47314841f, 0.20805210f, 0.15345521f, 
    0.03169667f, 0.05645284f, -0.01973656f, -0.18618701f, -0.13775218f, -0.04826970f, -0.06886946f, 0.06114995f, 
    -0.01133422f, -0.01232856f, 0.22290152f, 0.15811121f, 0.06305978f, -0.11566544f, 0.07787759f, 0.07828231f, 
    -0.05154248f, -0.02571164f, -0.01917836f, -0.01898195f, -0.03667106f, 0.19253589f, -0.12362773f, 0.13817783f, 
    -0.21035163f, -0.07917473f, 0.04028301f, -0.02216689f, -0.02631439f, 0.04755560f, -0.07896816f, 0.08943482f, 
    0.11642613f, 0.02370495f, -0.00556131f, 0.05451394f, -0.00168279f, -0.04576867f, -0.13489699f, -0.16978940f, 
    -0.11687212f, -0.34237915f, 0.03955033f, -0.07052659f, 0.21340017f, -0.29415393f, -0.02975830f, -0.05113434f, 
    0.00057775f, 0.04169948f, 0.01646355f, -0.02896076f, -0.20553227f, -0.08113991f, -0.12771438f, -0.12522320f, 
    0.17384942f, -0.02047722f, -0.22230856f, -0.01256237f, 0.00440122f, -0.05335439f, 0.06035053f, -0.07828938f, 
    -0.09337804f, -0.00929386f, -0.19537769f, -0.13476756f, 0.08292046f, -0.12352860f, 0.10039645f, -0.04218506f, 
    -0.17415319f, 0.01899771f, 0.01290998f, 0.01892834f, -0.02581409f, -0.02476158f, -0.09668779f, -0.02916704f, 
    0.14883804f, 0.04394145f, 0.07913927f, 0.06593386f, 0.02559371f, -0.00615850f, 0.05598069f, 0.02577296f, 
    0.20034009f, -0.12818161f, -0.11488051f, -0.06094213f, 0.00383497f, 0.04210311f, 0.20817016f, 0.09291428f, 
    -0.05211348f, -0.04825349f, 0.02653759f, 0.06246566f, 0.10577758f, 0.01436296f, -0.08278066f, -0.00030701f, 
    -0.12343747f, 0.05808602f, 0.06372022f, 0.01634920f, 0.01636220f, -0.07507490f, -0.08669057f, -0.12410398f, 
    -0.00968074f, 0.01112752f, -0.07933504f, 0.04328243f, 0.07340770f, -0.05694707f, 0.21614863f, 0.06851523f, 
    -0.10873662f, -0.09128637f, -0.19309628f, 0.05438462f, 0.08431177f, -0.01708491f, -0.01356162f, -0.00595970f, 
    -0.40141550f, -0.28512251f, -0.13301909f, 0.12880710f, -0.15163490f, -0.07563448f, 0.09441248f, -0.02394480f, 
    -0.06185225f, 0.04204332f, 0.07494553f, -0.06949402f, 0.21515945f, -0.37126178f, 0.04424771f, -0.06917012f, 
    0.02303502f, -0.01644353f, -0.06238194f, -0.09964080f, 0.09932861f, -0.13226539f, -0.13704230f, 0.09632589f, 
    -0.15614356f, 0.03996975f, -0.04287921f, -0.16709343f, 0.14705485f, 0.09416614f, -0.06768797f, 0.02781405f, 
    -0.19422084f, -0.01064241f, -0.09211443f, 0.10151942f, -0.15779243f, -0.73429090f, 0.07524458f, -0.78835595f, 
    0.09948414f, 0.07975633f, 0.01521104f, 0.06003826f, 0.02949937f, -0.08453909f, 0.06813791f, 0.04369011f, 
    0.01490998f, 0.04097731f, 0.00365437f, -0.15976395f, 0.00606297f, -0.03262027f, 0.03830721f, 0.05686945f, 
    -0.00180829f, 0.02133550f, -0.14839943f, -0.16363539f, 0.01927659f, -0.02987058f, 0.15711787f, -0.05406780f, 
    -0.04762576f, 0.11885696f, 0.06710305f, -0.13086145f, 0.10072400f, -0.09299847f, 0.12578826f, -0.12327459f, 
    -0.23851605f, -0.17916903f, 0.02796776f, -0.13940267f, 0.05873100f, 0.14517467f, -0.06963750f, -0.05480624f, 
    -0.01066657f, 0.07706209f, 0.01227508f, -0.03587376f, -0.04574454f, -0.08481230f, -0.08111358f, 0.09779628f, 
    0.04565588f, -0.24895470f, -0.22990105f, -0.02382624f, 0.03601607f, 0.06865336f, 0.12115942f, 0.16020736f, 
    -0.13821124f, 0.01929111f, 0.12979339f, 0.05203940f, -0.04891180f, 0.09052172f, -0.10873154f, -0.07563643f, 
    -0.05442885f, 0.03261371f, 0.00712278f, 0.13770576f, -0.01672039f, 0.17464907f, 0.05841658f, 0.23728174f, 
    0.12070170f, 0.11937548f, 0.09210955f, -0.04065514f, -0.01267077f, 0.01937523f, 0.08460118f, -0.07814729f, 
    -0.12470089f, -0.13180685f, 0.01467211f, -0.02629400f, -0.02702907f, -0.00167884f, -0.02923957f, -0.00895766f, 
    0.02801329f, 0.07559356f, 0.04480674f, 0.07596187f, -0.12160848f, -0.10138634f, -0.06447253f, 0.13487121f, 
    -0.05881014f, -0.07440428f, -0.09559289f, -0.04309700f, -0.16622621f, -0.05174654f, -0.09587134f, -0.16869707f, 
    0.22723427f, -0.02071226f, 0.01248800f, 0.02092366f, 0.11408739f, 0.24631792f, 0.11594994f, -0.07573183f, 
    0.01365252f, 0.01896315f, -0.00459641f, 0.08046948f, 0.27710113f, 0.10607289f, -0.06641121f, -0.00296764f, 
    -0.08593520f, 0.21958153f, 0.02655397f, 0.00199150f, 0.11901446f, -0.04815516f, -0.09693740f, 0.19776525f, 
    0.09417595f, -0.18127047f, 0.12848826f, 0.19763526f, 0.08150501f, -0.03236754f, -0.02469701f, -0.01857493f, 
    0.08048490f, -0.18323709f, -0.22043739f, -0.32591817f, 0.20972326f, -0.03342263f, 0.16007617f, 0.07342792f, 
    -0.06271892f, -0.08623799f, 0.04850587f, -0.07872815f, 0.09278741f, 0.03657781f, -0.05612530f, -0.08548363f, 
    -0.11478209f, -0.07890706f, -0.28518340f, 0.24393544f, 0.01208170f, 0.10697645f, -0.05052689f, 0.05646034f, 
    -0.04027954f, 0.00415691f, -0.04848021f, -0.04939106f, -0.53994727f, 0.23231380f, -0.15796950f, 0.08666680f, 
    0.21799870f, -0.03046406f, 0.05779159f, 0.00469693f, 0.17172040f, 0.09220567f, -0.03823519f, 0.06211690f, 
    -0.01179870f, -0.04513101f, 0.10149825f, 0.14365073f, 0.09440584f, 0.10388488f, -0.05898255f, -0.03534446f, 
    0.02218076f, 0.02510155f, -0.12133375f, 0.06755920f, -0.04767817f, -0.09037882f, -0.01244832f, 0.00727475f, 
    0.01422471f, -0.18423223f, -0.02723042f, 0.03959209f, -0.11146595f, -0.05351550f, 0.05027139f, 0.11446142f, 
    0.07930056f, -0.13920628f, 0.03439945f, 0.09273278f, 0.08882245f, -0.09247156f, -0.02030210f, -0.02006096f, 
    0.08050857f, 0.06477377f, 0.08132780f, 0.13881025f, 0.04578289f, 0.36778855f, 0.03490431f, -0.31425333f, 
    -0.07242750f, -0.13106504f, 0.02812952f, 0.11832626f, 0.09923714f, 0.08974873f, -0.11193047f, 0.01730838f, 
    -0.38215521f, -0.29952005f, -0.22800072f, -0.11460165f, -0.01004367f, -0.02175707f, 0.03417553f, 0.07053196f, 
    -0.06189777f, -0.00220800f, 0.02938130f, 0.01778065f, -0.56294644f, -0.11722306f, -0.24892034f, -0.18531165f, 
    -0.01472098f, -0.00288264f, -0.05459333f, 0.03024017f, 0.00980285f, -0.04406068f, 0.07554635f, 0.04012395f, 
    -0.17832427f, -0.04885855f, -0.09770087f, -0.02821427f, 0.20976937f, -0.00877480f, 0.13933864f, 0.13540547f, 
    0.04394018f, 0.01492709f, 0.04721768f, 0.02067228f, 0.14211740f, -0.13180375f, -0.07963201f, -0.07953431f, 
    -0.17056341f, 0.05708947f, 0.11120509f, -0.02039345f, 0.07376411f, -0.03700083f, 0.11014773f, 0.15808386f, 
    -0.16411015f, 0.03230595f, -0.26585150f, -0.08012659f, 0.07233465f, -0.04537148f, -0.12298147f, 0.09993470f, 
    0.04369527f, -0.08883049f, 0.03507460f, 0.26718318f, -0.26868036f, 0.16217889f, -0.16861768f, -0.05272666f, 
    0.03340827f, 0.01312217f, 0.00169429f, -0.00004784f, 0.07918950f, -0.26784435f, -0.14022042f, -0.03033450f, 
    -0.12671654f, 0.03365122f, 0.06973781f, -0.19113484f, -0.01346605f, -0.01142593f, 0.05460113f, -0.06573215f, 
    0.08493295f, -0.04702634f, 0.10814081f, 0.00639248f, -0.21682085f, 0.24969310f, -0.28281501f, 0.36936960f, 
    0.10017388f, -0.05822628f, 0.11153483f, -0.02819960f, -0.01873237f, 0.03809709f, -0.04270583f, -0.00709555f, 
    0.03447732f, -0.11975636f, 0.05684497f, -0.04673519f, -0.01694930f, 0.06630608f, 0.09834909f, -0.03517961f, 
    0.12280396f, -0.39513147f, 0.04445110f, -0.48097125f, 0.12221739f, 0.07210054f, -0.12865044f, -0.23950176f, 
    0.05609098f, 0.06938257f, -0.02084938f, -0.05196780f, -0.10401830f, -0.11487949f, 0.16607316f, -0.26004896f, 
    -0.05380097f, 0.14528516f, -0.17094886f, 0.26712272f, -0.05333897f, 0.09854813f, -0.08179075f, -0.06891293f, 
    -0.02832351f, 0.11018704f, -0.04836426f, -0.05037313f, -0.00842433f, 0.02363063f, 0.03630677f, -0.09023423f, 
    0.09563802f, 0.13411464f, 0.02412482f, -0.01324514f, 0.11056930f, 0.00410283f, 0.02270612f, 0.07838637f, 
    -0.08215350f, -0.09085885f, 0.00585055f, 0.00336751f, 0.06644750f, 0.19236821f, -0.08731147f, 0.14975862f, 
    -0.03186680f, 0.08015274f, 0.13490954f, 0.10056349f, 0.02118710f, -0.24777451f, 0.01590525f, 0.18504059f, 
    0.06421143f, 0.04092199f, -0.01799874f, 0.11246956f, -0.17461424f, -0.01595884f, 0.01341731f, -0.05092267f, 
    0.13573718f, -0.00945365f, 0.28656900f, -0.05955148f, 0.12195877f, 0.04839382f, 0.10465869f, 0.25283402f, 
    -0.06421825f, -0.06135683f, 0.04411430f, 0.01029876f, -0.04593260f, 0.11642992f, -0.35608327f, 0.24577305f, 
    0.07666097f, -0.01869484f, -0.03614071f, -0.01821166f, -0.03087559f, 0.02719044f, -0.03877864f, -0.00529130f, 
    -0.16805145f, 0.13385497f, -0.16778837f, -0.11747964f, -0.00202640f, 0.04429624f, 0.01975218f, 0.01468481f, 
    0.00517469f, 0.02458765f, -0.00336385f, 0.06336259f, 0.13876627f, -0.03433831f, -0.03914583f, 0.03412761f, 
    0.05990980f, 0.13334396f, -0.07184954f, -0.07099561f, 0.01913104f, -0.20680022f, -0.04489831f, 0.02083759f, 
    -0.08718006f, 0.07809382f, -0.27823606f, -0.08329077f, 0.00811018f, 0.01272914f, -0.09157503f, -0.03734684f, 
    0.18996413f, -0.01941915f, -0.08084393f, 0.22044216f, 0.40670013f, -0.04791417f, -0.27514124f, 0.16163242f, 
    0.06087255f, 0.13950509f, 0.13025896f, 0.15480690f, -0.03582826f, -0.16000398f, -0.27049756f, -0.19102408f, 
    -0.19576137f, 0.09340042f, -0.19127642f, -0.09705050f, -0.00293276f, -0.02631947f, 0.06202488f, 0.01143664f, 
    0.15010367f, -0.00843320f, -0.18326896f, -0.08429001f, 0.20046706f, -0.00733364f, -0.05645338f, -0.19272999f, 
    0.07272898f, 0.02520576f, -0.00545001f, 0.01004579f, -0.09752322f, 0.02012207f, -0.04265968f, -0.19720951f, 
    0.15806104f, 0.01191367f, 0.41581243f, -0.00670260f, -0.00758924f, -0.06666227f, -0.01921286f, 0.18960671f, 
    -0.05321412f, 0.01586909f, -0.07173643f, 0.15141433f, -0.04277250f, -0.11590906f, 0.22306019f, 0.04810945f, 
    -0.08353976f, -0.12558386f, 0.11853011f, -0.14509177f, -0.01742467f, 0.06537207f, 0.01129930f, -0.08861556f, 
    -0.00606404f, -0.22731823f, 0.11683445f, -0.03813546f, 0.20445085f, -0.04313674f, 0.02162335f, -0.08082618f, 
    0.02266450f, 0.07110152f, -0.02564351f, 0.00014770f, 0.02411192f, -0.18562891f, -0.45201865f, 0.11489344f, 
    0.03445244f, -0.00956185f, -0.02509227f, -0.05099010f, 0.09734319f, -0.10101802f, -0.03641668f, -0.03391143f, 
    0.04717024f, 0.05392076f, -0.10077845f, -0.11211929f, 0.09756781f, -0.11367480f, -0.17221051f, -0.00860228f, 
    -0.23416205f, 0.05357139f, 0.04417357f, -0.06755587f, 0.45092809f, -0.11071612f, -0.13007244f, 0.03237433f, 
    0.03887295f, 0.10436227f, -0.04754965f, 0.08439509f, 0.02485328f, -0.07796012f, 0.04153854f, -0.16897272f, 
    0.34124276f, -0.18541864f, -0.27164596f, -0.10664510f, -0.01930499f, 0.04045636f, -0.04105439f, -0.06299955f, 
    -0.00052011f, -0.11465440f, 0.00256240f, -0.08023470f, -0.01334557f, -0.29160112f, 0.12562630f, -0.08832918f, 
    -0.03133504f, -0.04313256f, -0.04999491f, 0.12966181f, -0.07689011f, -0.02246039f, -0.33286023f, -0.49169135f, 
    0.07186361f, -0.18915421f, -0.11301835f, 0.36610577f, -0.01942901f, -0.03871544f, -0.04596512f, 0.04400720f, 
    -0.00462220f, 0.12362365f, -0.00899902f, 0.02866967f, -0.16458644f, -0.02220331f, 0.26378497f, -0.31076744f, 
    -0.06401597f, -0.11616892f, -0.01800443f, -0.00085692f, 0.04367627f, 0.06344411f, -0.08188450f, -0.01747654f, 
    0.29100525f, -0.27171093f, 0.16754930f, -0.23781708f, 0.16432182f, 0.23747173f, 0.15939747f, 0.04596487f, 
    0.08142036f, 0.04991202f, -0.00441781f, 0.06988148f, -0.49144545f, -0.37437695f, 0.15265299f, -0.08242467f, 
    0.09871335f, 0.09565058f, -0.05299799f, 0.04638543f, 0.04814195f, 0.06020159f, -0.05170849f, -0.03000648f, 
    -0.12413082f, 0.12894090f, -0.08229342f, -0.16417731f, -0.12938310f, 0.04866688f, -0.03086889f, -0.04005599f, 
    0.14074019f, -0.05344701f, 0.09959635f, -0.07961042f, 0.00357526f, -0.17448613f, 0.12321524f, 0.23012757f, 
    -0.07316932f, -0.01997975f, 0.02744912f, 0.04164356f, 0.14875661f, -0.04380030f, -0.08333480f, 0.10922374f, 
    -0.37337965f, -0.60536104f, 0.36768764f, 0.14440516f, -0.12995194f, -0.10783920f, -0.12938271f, 0.03453850f, 
    0.15636054f, 0.07723383f, 0.16184485f, -0.09804709f, -0.18691844f, -0.02874641f, 0.10600355f, 0.04238045f, 
    0.10908056f, -0.07907896f, -0.04856893f, 0.11105503f, 0.06700161f, -0.01053221f, -0.07036912f, 0.14430512f, 
    -0.14031217f, -0.26178902f, -0.18633886f, -0.13177614f, 0.03743741f, 0.00420268f, -0.06352223f, -0.00135419f, 
    0.16851173f, 0.06883395f, 0.00919400f, -0.21501777f, 0.12502640f, 0.03017585f, 0.27319318f, -0.03027599f, 
    0.15542975f, 0.00890614f, 0.00057242f, 0.10443857f, -0.02993653f, 0.08517286f, 0.08180996f, 0.10443494f, 
    0.12700695f, -0.07917075f, -0.12748036f, -0.13659726f, -0.03743946f, -0.03248636f, -0.00699728f, 0.19895048f, 
    -0.04512979f, -0.08817987f, 0.00208044f, -0.08914753f, 0.24224870f, 0.24275266f, 0.05821183f, -0.08065791f, 
    0.08234273f, 0.00663337f, 0.13235651f, -0.19773795f, 0.09620804f, 0.03195184f, 0.00718785f, -0.02051223f, 
    -0.13640852f, -0.27009609f, 0.18511260f, 0.25082281f, 0.00553236f, -0.13331676f, 0.09177091f, 0.12456898f, 
    -0.03856027f, 0.03421330f, -0.01151166f, 0.07283495f, -0.06351787f, -0.35342425f, -0.06520429f, 0.31049195f, 
    -0.13312624f, 0.02668945f, 0.12990402f, 0.00262742f, 0.12192576f, 0.04013731f, -0.06844533f, -0.16201808f, 
    -0.00910739f, 0.05805257f, -0.17832674f, -0.13256584f, 0.03073448f, -0.12162110f, -0.00025014f, 0.04597484f, 
    0.06887181f, 0.08694244f, -0.17340156f, 0.00375144f, -0.37488115f, -0.20032518f, 0.10053968f, -0.22150181f, 
    -0.05887666f, -0.00999075f, -0.04258677f, 0.02794810f, -0.06250548f, 0.09651311f, -0.06831805f, 0.00410897f, 
    -0.14357662f, -0.20906149f, -0.20064646f, -0.10835773f, 0.11463455f, 0.02976906f, -0.02185829f, 0.04612802f, 
    0.06713190f, 0.00505751f, 0.19078645f, 0.28933966f, 0.23097783f, 0.01603669f, -0.03822967f, -0.08595334f, 
    -0.00822166f, -0.09491712f, 0.09139732f, 0.01017442f, -0.02660539f, 0.04335771f, 0.04079249f, -0.08388185f, 
    0.12139018f, -0.15068798f, -0.03948448f, -0.00110897f, -0.05261268f, -0.10683238f, -0.16582482f, 0.13594662f, 
    -0.01781027f, -0.08011401f, 0.00557377f, 0.25399706f, -0.15878370f, -0.03888895f, -0.32549989f, -0.14199439f, 
    0.11892106f, -0.19787192f, 0.16446804f, 0.13548204f, -0.11214565f, -0.01571703f, -0.01160010f, 0.26874316f, 
    -0.01216403f, 0.20750527f, 0.24467660f, -0.03412814f, -0.09334350f, -0.11033465f, -0.07873888f, 0.12869239f, 
    0.07539839f, 0.03047112f, -0.07868479f, 0.14013222f, -0.03131869f, 0.21965553f, 0.05948281f, -0.10633344f, 
    0.02577897f, 0.00519362f, 0.05807827f, 0.00166520f, 0.05524100f, 0.01445982f, 0.04319623f, -0.02396188f, 
    0.02745274f, 0.00922019f, -0.03683945f, -0.10784964f, 0.03134307f, 0.00255931f, 0.02209783f, -0.01289292f, 
    -0.10595655f, -0.06848083f, -0.08867335f, -0.14310409f, 0.12660509f, -0.03008560f, -0.11995669f, 0.07668456f, 
    -0.10347345f, 0.16205974f, 0.05162384f, 0.09998254f, 0.03741243f, 0.03196841f, 0.10633754f, 0.07978807f, 
    -0.74480897f, -0.46031815f, -0.28411204f, -0.27864376f, -0.13661486f, -0.24896811f, -0.12266820f, -0.19299036f, 
    0.00793710f, -0.05801572f, -0.04173214f, 0.01020680f, -0.42697021f, -0.25125575f, 0.15643913f, 0.45345068f, 
    -0.02312638f, -0.04709304f, 0.03552190f, -0.08992609f, -0.08427917f, -0.12415059f, 0.03798772f, 0.12846686f, 
    -0.17490654f, -0.09088136f, -0.33525231f, 0.08969766f, -0.05750326f, 0.05478534f, 0.03825333f, 0.05416115f, 
    0.11002685f, -0.07562336f, 0.17974381f, 0.03527418f, -0.19929020f, -0.51486659f, -0.36115748f, -0.29331857f, 
    -0.09150907f, -0.04175423f, 0.01835917f, -0.07795081f, -0.01257023f, -0.00734079f, 0.01438841f, 0.04262360f, 
    0.23322308f, -0.15383761f, -0.16313910f, -0.16095428f, -0.03597767f, 0.04655968f, 0.25348681f, 0.00746556f, 
    -0.03501448f, -0.07724831f, -0.01667811f, -0.01460526f, -0.14798528f, -0.11226895f, -0.05142375f, 0.14954224f, 
    0.15996893f, -0.10157315f, 0.07594190f, 0.09723902f, -0.00393387f, 0.04457737f, -0.00989468f, -0.14025721f, 
    -0.08996081f, -0.06607988f, -0.17329308f, -0.52755708f, -0.04480328f, -0.10624216f, 0.04170652f, 0.00452116f, 
    -0.00115678f, 0.03778590f, 0.12078510f, -0.12240864f, -0.04374140f, -0.12949578f, -0.03898059f, 0.00881525f, 
    -0.04999370f, -0.06408280f, -0.01924474f, -0.04194640f, -0.04348657f, -0.10055212f, -0.05732080f, -0.12361672f, 
    -0.11819346f, 0.01739129f, 0.15526883f, -0.02844821f, 0.03436671f, 0.04134817f, -0.04513410f, 0.09018847f, 
    0.04040356f, -0.01453158f, 0.00073856f, -0.06316867f, -0.20543629f, -0.37386340f, 0.03980780f, 0.24294944f, 
    0.03270771f, 0.02987143f, 0.02731754f, 0.07053125f, 0.06392094f, 0.14711222f, -0.00382936f, 0.06977757f, 
    -0.16801526f, 0.04873022f, 0.32026568f, 0.15422042f, -0.07283396f, -0.02253845f, -0.10170358f, 0.11978544f, 
    0.05186434f, 0.09222074f, -0.04132304f, 0.04188499f, -0.52323896f, 0.12108652f, 0.39898622f, 0.06177491f, 
    -0.06625205f, -0.05611518f, 0.00116180f, 0.02072406f, -0.10573851f, 0.15384060f, -0.02587449f, 0.03532853f, 
    -0.43994248f, -0.43235594f, 0.46071187f, 0.49014854f, 0.13552380f, -0.19034156f, -0.04760124f, -0.14509368f, 
    0.00022734f, 0.08662376f, -0.01526508f, 0.02115481f, -0.15511508f, -0.09835806f, 0.07421401f, -0.04475529f, 
    -0.00688437f, -0.10311092f, -0.11735304f, 0.05083185f, -0.01646166f, 0.03048058f, 0.02171706f, -0.18410282f, 
    0.21867430f, 0.07620308f, -0.04205959f, -0.16228700f, 0.06446575f, -0.10195810f, 0.14691016f, -0.13664323f, 
    0.05424007f, -0.02189787f, 0.05276035f, -0.06414310f, 0.00563575f, 0.02903962f, 0.14941511f, 0.00750851f, 
    -0.03992274f, 0.05884714f, 0.02441968f, -0.04743723f, 0.00458064f, 0.03348537f, 0.11052807f, 0.05848872f, 
    -0.54218453f, -0.70657778f, -0.19098139f, -0.31363627f, -0.11493269f, -0.23719066f, -0.07559364f, -0.15550421f, 
    -0.01486236f, -0.03245676f, 0.05862619f, -0.00760928f, -0.28887224f, -0.28160745f, -0.15519512f, -0.42509809f, 
    0.11682232f, 0.05915448f, 0.01866038f, -0.04528590f, 0.01594843f, 0.05136072f, -0.03700536f, 0.06655344f, 
    0.07444763f, 0.06646898f, -0.11525925f, -0.04794749f, -0.02155622f, 0.05142225f, 0.01095458f, 0.11924955f, 
    0.08580193f, 0.11695226f, 0.06795298f, 0.09995091f, -0.07393680f, 0.26416230f, 0.06112106f, 0.01431622f, 
    -0.01568878f, 0.04868212f, 0.00660565f, -0.10615204f, 0.04380886f, 0.05036069f, -0.11812178f, 0.10981558f, 
    -0.18870419f, 0.04655003f, -0.06860397f, -0.35698333f, 0.08989713f, 0.03409474f, -0.00296826f, 0.10516113f, 
    -0.04501995f, 0.00789160f, 0.00651641f, -0.01613885f, -0.55430430f, -0.48071083f, -0.45472983f, -0.34355545f, 
    -0.18496892f, -0.32246643f, -0.22505963f, -0.25793818f, -0.02751507f, 0.01604956f, -0.00137576f, -0.00960985f, 
    -0.01423677f, -0.07617719f, -0.06520808f, -0.06283476f, -0.08852474f, 0.00266281f, 0.11016797f, -0.17181689f, 
    0.00617530f, -0.09008599f, -0.03172112f, 0.01588359f, 0.04380504f, 0.15571940f, 0.03187301f, 0.04745522f, 
    -0.05259321f, 0.02039899f, 0.05325475f, 0.05012428f, 0.02392012f, 0.00262961f, 0.18663523f, -0.02923154f, 
    -0.12896115f, -0.59736878f, -0.43084905f, 0.17428862f, -0.20367678f, -0.06139699f, 0.17447056f, 0.10961287f, 
    0.14576325f, 0.06498460f, -0.08224163f, -0.08657228f, 0.03636890f, -0.00298248f, -0.18793082f, 0.05293030f, 
    0.06419179f, -0.01249359f, 0.07677589f, -0.06415748f, 0.00068592f, 0.08814435f, -0.03377743f, 0.00815954f, 
    -0.05563213f, -0.08896933f, 0.00118757f, -0.23430479f, 0.02523957f, 0.03329515f, 0.02801828f, -0.02290509f, 
    -0.03296187f, 0.10642795f, -0.11222601f, 0.03921388f, -0.07969747f, 0.27565134f, -0.35194427f, -0.21485382f, 
    0.03910946f, -0.06559207f, 0.02999709f, 0.18851195f, 0.00051351f, 0.23282778f, -0.01013713f, 0.04825621f, 
    0.07774464f, 0.01696040f, -0.12063035f, -0.07045399f, 0.08315687f, -0.06502862f, 0.05861683f, -0.05052320f, 
    0.01480953f, 0.00367541f, -0.09480327f, 0.02851197f, 0.15920623f, 0.00211841f, 0.09628168f, -0.12173476f, 
    0.05000411f, -0.05225657f, 0.20192882f, 0.09757771f, 0.07582596f, 0.18672335f, -0.00969604f, 0.09921256f, 
    0.14969584f, 0.06470899f, 0.18460597f, 0.03952705f, -0.03996089f, -0.00869911f, -0.02053639f, 0.06273314f, 
    0.15534081f, 0.16439503f, 0.15217929f, 0.15699324f, -0.12012770f, 0.04147041f, -0.15889929f, -0.38580832f, 
    -0.06006847f, -0.06646458f, -0.08407079f, -0.00779051f, -0.11090824f, -0.02446192f, 0.03188232f, 0.12891208f, 
    0.17287956f, -0.44491848f, -0.57528567f, -0.17017858f, -0.11074272f, -0.01059775f, 0.10521692f, 0.10950255f, 
    -0.00579362f, 0.01361875f, -0.02500577f, 0.03758060f, -0.00463483f, -0.43575746f, -0.52228612f, -0.26070631f, 
    -0.00274277f, 0.17605895f, 0.07104275f, -0.16470364f, 0.04731192f, -0.04307116f, 0.03441267f, -0.03423966f, 
    -0.19515386f, -0.16741338f, -0.03240861f, -0.15594657f, -0.06223226f, -0.09211364f, 0.02575101f, 0.00540520f, 
    0.05736893f, 0.02741617f, 0.03889477f, 0.02952413f, -0.11382160f, -0.05344392f, 0.02536118f, -0.11752226f, 
    -0.03723245f, 0.01414867f, -0.01273262f, -0.01471144f, 0.00127758f, -0.00553324f, 0.00324953f, 0.00181729f, 
    0.00420566f, 0.16828822f, -0.03108760f, -0.15784073f, -0.13046746f, -0.04864103f, -0.20675997f, -0.03890480f, 
    -0.03224054f, -0.05127821f, 0.02479815f, 0.04144818f, 0.10785202f, -0.00977192f, -0.10845674f, -0.12606190f, 
    -0.04451859f, 0.00070015f, 0.08150385f, 0.02767903f, -0.09009597f, 0.16937542f, -0.13906556f, 0.05054036f, 
    0.42085314f, 0.31562304f, -0.04741897f, 0.13125359f, -0.01243345f, -0.02712222f, -0.09804086f, -0.01120713f, 
    0.01572187f, 0.06877993f, 0.04505732f, -0.06700821f, -0.00477605f, 0.08184435f, -0.02582239f, -0.02736903f, 
    -0.07838625f, -0.03664008f, 0.06940038f, 0.10069146f, 0.00026691f, -0.02837549f, 0.08040549f, 0.06941888f, 
    0.09628688f, 0.07901993f, -0.22560155f, 0.07906955f, -0.06044609f, 0.02813765f, -0.00507149f, 0.09073763f, 
    -0.06329422f, 0.00768073f, 0.16391301f, -0.17343214f, -0.13013302f, -0.26932722f, -0.05971490f, 0.22181122f, 
    0.25694215f, 0.09357326f, 0.03279157f, 0.02937106f, -0.01702911f, 0.07490330f, 0.03191707f, 0.01791497f, 
    -0.29525909f, -0.46905100f, -0.28753483f, 0.36077398f, 0.07595710f, 0.17156379f, 0.03959694f, -0.09321468f, 
    -0.00019039f, 0.01803700f, 0.02843670f, 0.07119471f, -0.37509421f, -0.14418073f, 0.16195783f, 0.35421130f, 
    -0.11716881f, -0.01304525f, 0.11305004f, 0.18310201f, -0.03882827f, 0.10265984f, -0.02969012f, -0.03133122f, 
    -0.23510289f, 0.24335721f, 0.24903485f, -0.08353927f, -0.00064655f, -0.21828109f, -0.11080989f, 0.18254688f, 
    -0.03121789f, 0.09752282f, -0.12138962f, -0.03201124f, -0.04310450f, -0.01660884f, 0.21919838f, 0.13384864f, 
    -0.00715877f, -0.01261693f, -0.10185077f, 0.11560421f, 0.03860901f, 0.00016981f, 0.11873297f, 0.07396108f, 
    -0.09764809f, -0.21993820f, 0.11419330f, 0.09991365f, 0.02232395f, 0.09039638f, -0.05021202f, 0.02062875f, 
    0.15590803f, 0.04654583f, 0.10305543f, -0.00711752f, -0.00315440f, -0.05974970f, -0.10321085f, 0.10648135f, 
    0.07254064f, 0.04478942f, 0.02022184f, 0.01662414f, -0.06837021f, -0.01699122f, 0.00601020f, -0.06586116f, 
    -0.22323230f, 0.41654113f, 0.28046077f, -0.00227921f, -0.04196794f, 0.04212648f, -0.09840006f, -0.02930180f, 
    0.05193234f, -0.02018228f, -0.02722089f, 0.16321269f, -0.25560677f, -0.19084762f, 0.11804508f, 0.14840451f, 
    -0.04232290f, -0.03554407f, -0.05643958f, 0.00528362f, 0.05812154f, 0.04169364f, -0.10953686f, -0.03024708f, 
    0.52548218f, 0.29994366f, -0.20853540f, -0.03240307f, -0.13390292f, -0.00165413f, 0.01593719f, 0.30572450f, 
    0.06654038f, 0.05929618f, -0.02283734f, 0.03438768f, -0.53770262f, 0.32132241f, 0.18281457f, -0.30612996f, 
    -0.14823678f, -0.04293270f, -0.15204072f, -0.17433070f, -0.10216679f, 0.02560854f, -0.05472030f, 0.08133803f, 
    0.08915858f, -0.04324947f, -0.09189995f, -0.03734285f, -0.03524119f, -0.09780649f, 0.10255293f, 0.13970411f, 
    -0.12177322f, 0.05558300f, -0.00188191f, -0.14404529f, -0.06996350f, 0.02538468f, 0.06005707f, -0.00956933f, 
    0.00666517f, 0.09876764f, -0.07098263f, 0.01793388f, 0.04658322f, 0.05608562f, 0.03069405f, 0.15191406f, 
    0.11602768f, 0.02459035f, 0.32597739f, 0.15278955f, 0.13305026f, 0.07554116f, 0.04329832f, -0.04553095f, 
    -0.08021068f, 0.04599433f, 0.11105932f, -0.01753626f, -0.41978982f, -0.00703045f, -0.03598208f, -0.07178636f, 
    0.02100893f, 0.00731858f, -0.00149733f, -0.00173588f, 0.06787471f, 0.02767706f, 0.02056360f, 0.11105216f, 
    -0.21163686f, 0.09125153f, -0.04363597f, -0.48782551f, -0.02436538f, -0.04962965f, 0.07440267f, 0.02275711f, 
    0.04645562f, 0.09371381f, -0.00648016f, 0.07703275f, 0.36252555f, 0.13526456f, 0.07321514f, -0.26951033f, 
    0.07075112f, -0.02110424f, 0.09705634f, 0.13834134f, 0.07133790f, -0.02033680f, 0.03188698f, -0.14764461f, 
    -0.25982976f, -0.22710645f, -0.22912082f, -0.29746404f, -0.17666233f, -0.07604124f, 0.16046049f, 0.06024401f, 
    0.04204974f, 0.06716977f, -0.06515592f, 0.04035083f, 0.09888221f, -0.05910654f, 0.06627750f, 0.22108553f, 
    0.03588763f, -0.03444456f, 0.05663393f, -0.01799933f, 0.04411314f, 0.01570258f, 0.07881478f, -0.09798496f, 
    -0.06098705f, -0.63571405f, -0.55747807f, -0.05214917f, -0.08826349f, -0.07770567f, 0.04243570f, -0.04857735f, 
    0.00017502f, 0.00758344f, 0.03708094f, 0.13570124f, -0.46423462f, -0.63271272f, -0.31696358f, -0.30642986f, 
    -0.12565425f, -0.07018667f, -0.19777940f, -0.24398053f, -0.03175705f, -0.07091798f, -0.05425854f, -0.12288651f, 
    -0.05263781f, 0.05752844f, -0.01209265f, 0.04915801f, 0.02927007f, -0.04003052f, 0.01000658f, 0.00962702f, 
    0.05181598f, -0.05484127f, -0.01450182f, -0.02673963f, -0.01815360f, 0.09162325f, 0.06640861f, 0.04235516f, 
    -0.06679877f, 0.09220779f, 0.00944032f, -0.05477218f, -0.07207872f, 0.03421668f, 0.01755325f, 0.23632462f, 
    -0.42781845f, -0.41543403f, -0.14537942f, 0.21866843f, -0.06422711f, -0.03696997f, 0.00798121f, 0.00192197f, 
    -0.02623909f, 0.05784668f, 0.02497025f, 0.07121132f, -0.04997454f, -0.15983383f, 0.18460903f, -0.24393468f, 
    0.06182719f, 0.01166465f, 0.05693737f, 0.06829774f, -0.05292031f, -0.01643604f, 0.07963867f, 0.02043702f, 
    0.06081312f, -0.40270060f, -0.05302272f, 0.09404406f, -0.06486208f, -0.07998979f, 0.01342650f, 0.02644998f, 
    0.12199666f, 0.18395939f, 0.17743474f, 0.09846593f, -0.18879485f, -0.01722963f, -0.12777007f, 0.35440961f, 
    -0.09392464f, -0.01567966f, -0.10714462f, 0.08314808f, -0.03825903f, -0.08747867f, -0.04549645f, 0.08111482f, 
    -0.06123417f, 0.15752420f, -0.05089761f, -0.03762383f, -0.01573288f, -0.02835341f, -0.06094268f, 0.00420737f, 
    -0.00901588f, 0.03287989f, 0.06795756f, -0.01304206f, -0.06363888f, 0.12583750f, -0.20601888f, 0.26499602f, 
    0.05493670f, -0.05534727f, 0.08919403f, 0.05925257f, -0.02339594f, 0.08853807f, -0.12983003f, 0.05419959f, 
    -0.21642484f, 0.27396792f, -0.29709917f, 0.40879774f, -0.18949708f, 0.04388160f, -0.05627403f, -0.11566735f, 
    -0.05387701f, 0.05805661f, 0.02839915f, 0.00458067f, 0.08588489f, 0.02490562f, -0.01307737f, -0.09283683f, 
    0.02117343f, 0.02240371f, -0.03786377f, -0.04725822f, -0.06838205f, -0.04398384f, -0.03781393f, 0.02963938f, 
    0.03725777f, 0.07048463f, -0.08252538f, -0.10224573f, 0.00591747f, 0.04749065f, 0.01088799f, -0.00854855f, 
    -0.04800004f, -0.00494322f, -0.25995997f, -0.25781465f, 0.21726967f, -0.14801863f, 0.22395408f, -0.21178146f, 
    -0.12326788f, -0.05718268f, 0.06774423f, -0.00807680f, -0.02382979f, -0.00114823f, 0.06365071f, 0.03022183f, 
    0.23237428f, -0.04462865f, -0.06876921f, -0.00708997f, -0.01601236f, -0.05931348f, -0.11647943f, -0.01236491f, 
    0.02878814f, -0.09543195f, -0.02271613f, 0.04717258f, 0.39659163f, -0.52017421f, -0.52698141f, -0.61950445f, 
    -0.00139058f, -0.10472870f, -0.15855913f, 0.13756154f, 0.14423463f, 0.07442502f, 0.00150078f, -0.01296969f, 
    -0.19249421f, -0.27635399f, -0.39806530f, -0.52142811f, 0.16635805f, -0.09055939f, -0.09502384f, -0.03378291f, 
    0.05335389f, 0.01913450f, 0.00755125f, 0.02799468f, 0.17485161f, -0.10026579f, 0.06433565f, -0.00041124f, 
    -0.01174265f, 0.03111084f, 0.13655381f, 0.03245184f, 0.04707986f, 0.03737085f, -0.08107655f, 0.00699025f, 
    -0.03919382f, 0.13783126f, -0.00546534f, 0.11041375f, 0.04929636f, -0.05012730f, 0.04284502f, -0.11427940f, 
    -0.04999091f, 0.00736753f, -0.07111860f, 0.02678035f, 0.06067743f, -0.00399105f, -0.04001829f, 0.14522032f, 
    -0.01827242f, -0.00911701f, 0.00427802f, -0.04937449f, 0.08647221f, -0.04906893f, -0.02248761f, 0.05173635f, 
    -0.08639952f, -0.38239011f, -0.00390858f, -0.22148953f, 0.00238274f, -0.10603558f, -0.07616488f, 0.19801739f, 
    0.00158792f, -0.00027267f, -0.07446136f, -0.07668722f, -0.30283338f, 0.33086979f, 0.14331043f, 0.08787547f, 
    -0.09689109f, 0.04118457f, -0.05868206f, 0.02169662f, 0.06856120f, 0.02263199f, 0.03606359f, 0.01228924f, 
    0.07869827f, -0.08420885f, 0.05895880f, -0.04605961f, 0.00105898f, -0.06268301f, -0.01198807f, -0.09198064f, 
    0.02909019f, -0.06389086f, -0.03466464f, -0.04173559f, -0.08501068f, -0.05613203f, -0.10067989f, -0.13451558f, 
    0.04133996f, 0.07209329f, 0.04412501f, -0.00090355f, 0.04963411f, 0.03874583f, -0.12525947f, -0.08244194f, 
    -0.42266610f, 0.20543553f, -0.33628130f, 0.11009148f, 0.00670663f, -0.01353817f, 0.03820123f, 0.10656799f, 
    0.07727965f, 0.02932717f, -0.05837439f, -0.10996665f, -0.24416213f, -0.23989363f, -0.05647261f, 0.18775792f, 
    -0.03502838f, -0.01446259f, 0.02087888f, 0.02780246f, 0.01498583f, 0.06855076f, 0.04152893f, -0.05661060f, 
    -0.02321246f, 0.05056390f, 0.02824295f, -0.07928963f, 0.04265628f, -0.16004795f, -0.07726507f, -0.02605455f, 
    0.03432838f, 0.02330732f, -0.00021363f, 0.03243925f, 0.15436223f, -0.07984588f, 0.02073761f, -0.10327880f, 
    -0.04133668f, -0.01825453f, -0.07824396f, -0.02442022f, -0.02304306f, 0.02084126f, -0.14914688f, -0.01628200f, 
    -0.11610547f, -0.50691539f, 0.33674920f, 0.05385988f, -0.03432299f, 0.02874420f, -0.03762233f, 0.03090324f, 
    -0.06535657f, -0.07042177f, 0.01761031f, -0.05903838f, -0.07104772f, -0.01298321f, 0.08679026f, -0.05251445f, 
    0.05614005f, 0.03665170f, -0.06538182f, -0.04230725f, -0.02539951f, 0.04665070f, 0.00067295f, -0.01446991f, 
    0.03189861f, 0.01185511f, 0.00273497f, -0.06417999f, -0.00917286f, -0.02767099f, 0.00095433f, -0.00548819f, 
    -0.02564474f, -0.00675560f, -0.03535394f, -0.04364181f, -0.41425332f, 0.07241938f, -0.37518671f, 0.11738222f, 
    0.03200198f, -0.09589160f, 0.02879363f, -0.08891815f, -0.07105858f, 0.04325740f, -0.02635712f, -0.12756500f, 
    0.02847933f, 0.10970773f, 0.01394240f, -0.01901317f, -0.01804489f, 0.07057616f, 0.00932659f, -0.04468197f, 
    0.03586936f, 0.02946979f, -0.01353878f, -0.03793139f, -0.00276923f, 0.20024930f, 0.06257890f, -0.04797537f, 
    -0.05877225f, -0.00894124f, -0.09810044f, 0.03426495f, 0.02237835f, -0.02678222f, 0.03590064f, -0.06990235f, 
    0.06678724f, -0.13957028f, 0.02275777f, -0.08856858f, 0.01747193f, -0.04012204f, -0.00859179f, -0.05353328f, 
    0.11803547f, -0.05032378f, 0.01471060f, -0.16466717f, -0.43936056f, -0.27479666f, 0.01070127f, 0.17741156f, 
    0.09269349f, -0.04219107f, 0.00175370f, 0.02611959f, 0.02287561f, 0.11150385f, 0.00058066f, 0.04055437f, 
    -0.14159480f, -0.39780024f, -0.12673904f, 0.27077833f, 0.04895513f, 0.07553821f, 0.11126088f, -0.14103097f, 
    -0.02746546f, -0.07019491f, 0.03098558f, -0.03554297f, -0.39529616f, -0.26321432f, -0.14128299f, 0.19951351f, 
    -0.15618882f, 0.04145520f, 0.05864930f, -0.01296694f, 0.01531817f, -0.05217458f, 0.08438394f, -0.03286020f, 
    0.64695209f, -0.32210764f, -0.09343124f, -0.32610685f, -0.14314103f, 0.22839305f, -0.17801408f, 0.10332260f, 
    -0.05181212f, 0.09830927f, -0.04842284f, -0.03136389f, 0.04548309f, 0.09860639f, -0.00667073f, 0.00896956f, 
    0.09858269f, 0.01433015f, 0.01634187f, -0.00257148f, 0.04072633f, -0.00763589f, 0.07708970f, 0.01327509f, 
    -0.03300725f, -0.00192880f, -0.03912985f, -0.06535343f, 0.01951298f, -0.01917321f, 0.03547459f, 0.02965253f, 
    -0.17897743f, 0.07956773f, 0.03650593f, 0.04393572f, -0.05991764f, 0.12376501f, 0.00822159f, -0.03034783f, 
    -0.00007742f, 0.00080463f, -0.01317026f, -0.07078911f, 0.04954484f, -0.09818268f, 0.04958050f, -0.01567594f, 
    -0.17026269f, -0.14478321f, -0.13428816f, 0.04753360f, 0.00243952f, 0.02445787f, 0.05078229f, -0.04334181f, 
    -0.10231279f, 0.11459209f, -0.02041681f, -0.02706825f, 0.17670153f, -0.19749026f, -0.32607168f, 0.03152845f, 
    -0.00258346f, -0.03379101f, -0.00549829f, -0.08234130f, 0.13005421f, 0.00902849f, -0.00466575f, 0.13526554f, 
    0.11632470f, -0.19608246f, 0.08694632f, -0.10121796f, 0.01895043f, 0.08640636f, -0.04295989f, -0.06580452f, 
    -0.05452669f, 0.01917473f, -0.04130471f, -0.02983836f, 0.19592009f, -0.10188314f, 0.03318997f, -0.33820075f, 
    0.01242622f, -0.00053824f, -0.01303497f, 0.06996737f, -0.12359114f, 0.03729818f, 0.01103389f, -0.04974820f, 
    -0.11776903f, -0.31708536f, 0.21514146f, -0.09642702f, -0.05902600f, 0.04408281f, -0.07820547f, 0.02496550f, 
    0.05089180f, 0.00963162f, 0.01691188f, -0.01591293f, 0.65564346f, -0.56374943f, 0.13926463f, -0.39898109f, 
    -0.23960578f, 0.09537429f, -0.15650763f, 0.26906136f, 0.06988300f, 0.05194811f, -0.01247057f, -0.00586085f, 
    -0.10326494f, 0.15298566f, 0.15446259f, 0.06119979f, -0.05320548f, -0.11646563f, 0.11621368f, 0.01456006f, 
    0.01842029f, 0.02859098f, 0.05600315f, 0.05702627f, 0.10091073f, 0.09514710f, -0.17285183f, -0.12767228f, 
    0.03352587f, 0.00071386f, 0.02176426f, -0.01761746f, -0.06579018f, 0.06483521f, -0.04736348f, -0.24459007f, 
    0.37599850f, -0.03726376f, -0.02038331f, -0.33186334f, 0.06383038f, 0.09671088f, -0.10413221f, 0.01661462f, 
    -0.01818898f, 0.02460058f, -0.07940750f, -0.14887857f, 0.04640406f, -0.02757409f, 0.03587874f, -0.03049465f, 
    -0.01286062f, -0.00200361f, -0.01089875f, -0.06670304f, -0.01218245f, 0.02835079f, -0.03156046f, 0.01180833f, 
    0.26854765f, -0.16773503f, -0.21748613f, -0.23543957f, 0.01065899f, 0.03853903f, 0.02550872f, -0.00387378f, 
    -0.02095492f, -0.09003501f, -0.07382586f, 0.10915028f, -0.37746277f, -0.35142159f, 0.12784420f, -0.12337597f, 
    0.05442925f, -0.02350448f, 0.03888960f, -0.00001873f, 0.02087597f, -0.03696615f, -0.04670366f, 0.02455305f, 
    -0.57851952f, -0.24186507f, -0.17223100f, -0.20486791f, -0.11618706f, 0.06408563f, 0.11353415f, 0.05581491f, 
    -0.16268207f, 0.00256221f, 0.01796986f, 0.05376029f, 0.33481833f, -0.29266119f, -0.14435668f, -0.08356661f, 
    0.10932194f, 0.05605061f, -0.00709890f, -0.03686247f, 0.00479732f, -0.02725878f, 0.04417346f, 0.00696595f, 
    0.31755322f, -0.09480167f, -0.01962454f, -0.02001294f, -0.00289607f, 0.09482203f, 0.00353616f, -0.14361413f, 
    0.00365945f, -0.02464936f, -0.09080054f, -0.00305232f, 0.12883659f, 0.08156894f, -0.09451772f, -0.16230610f, 
    -0.06951676f, 0.03593867f, -0.02390795f, 0.02057197f, -0.14677876f, 0.05061912f, 0.07631028f, -0.08699246f, 
    -0.01469754f, 0.08459058f, 0.19074257f, 0.23982882f, 0.02453203f, 0.09012889f, 0.09646490f, -0.07341310f, 
    -0.11191451f, 0.04828157f, -0.03961640f, 0.05892959f, 0.03276700f, -0.17569111f, 0.05842311f, 0.00154490f, 
    0.10340279f, 0.04193646f, 0.05688115f, -0.08859900f, 0.00968176f, -0.04964869f, -0.09964700f, -0.12224039f, 
    0.05987811f, 0.30748451f, -0.09170032f, 0.10868909f, 0.03370333f, 0.02216029f, 0.01849403f, -0.03860467f, 
    0.06076233f, 0.01775249f, -0.16273656f, -0.10000294f, -0.19009386f, 0.23097517f, 0.04605966f, 0.06735413f, 
    0.03089094f, -0.11962818f, -0.02317676f, 0.01196487f, 0.05300753f, -0.03403863f, -0.01318823f, -0.06674338f, 
    -0.44075641f, -0.32406649f, -0.15648068f, 0.06106728f, 0.03866370f, 0.15117013f, 0.07124722f, 0.04966566f, 
    -0.00455884f, 0.08899796f, 0.02673407f, -0.04233043f, 0.05002619f, 0.22244097f, -0.02969447f, 0.07120220f, 
    -0.12646103f, 0.32184201f, 0.09031191f, -0.13923478f, 0.03526394f, -0.03405192f, 0.02663197f, 0.07625078f, 
    -0.06147251f, -0.38446972f, 0.27281636f, 0.23893793f, 0.03853601f, 0.02125748f, 0.00582009f, 0.04289871f, 
    -0.05088664f, -0.07378196f, -0.13285513f, -0.00121687f, -0.56666994f, -0.08954579f, -0.06430589f, 0.56245530f, 
    0.03809818f, -0.01099291f, -0.04377863f, -0.07749478f, 0.03845443f, -0.07160718f, -0.04541782f, -0.01857567f, 
    -0.31214619f, 0.03341528f, 0.03533107f, -0.09717058f, -0.03448141f, -0.02952024f, -0.01727128f, -0.02802488f, 
    0.00508035f, 0.07834622f, 0.03884257f, 0.10488272f, -0.26398510f, -0.08114140f, 0.00763377f, 0.08871430f, 
    0.16221818f, 0.00792479f, 0.02721017f, -0.03371559f, -0.14214137f, -0.02206880f, 0.07968919f, -0.22643188f, 
    0.08851199f, -0.45790535f, -0.24632202f, 0.02536693f, -0.13720009f, 0.02767158f, 0.04714294f, 0.05724815f, 
    -0.09586734f, 0.02359983f, 0.03301431f, 0.00983039f, 0.36685124f, 0.07584248f, 0.03198199f, -0.08978825f, 
    -0.04592232f, -0.02735122f, -0.03118085f, 0.00567083f, 0.01133261f, 0.02091837f, -0.05756763f, 0.01190458f, 
    0.16853462f, 0.10799276f, -0.10481568f, -0.11009906f, 0.07140527f, 0.03062712f, 0.03078923f, 0.01009349f, 
    0.02800044f, -0.02006597f, -0.16852787f, -0.46057889f, -0.00648625f, -0.12097570f, -0.18628462f, -0.25096181f, 
    -0.03893748f, -0.03592674f, 0.00804218f, -0.10459509f, 0.06327049f, 0.00246514f, 0.03103626f, -0.00950693f, 
    -0.16379538f, 0.09356560f, 0.08116191f, 0.03100207f, 0.00876250f, 0.02889296f, -0.05115493f, 0.03131427f, 
    0.00732450f, -0.08181453f, 0.09418409f, 0.00629627f, 0.08475713f, -0.07494933f, -0.03714336f, -0.02879485f, 
    -0.09971328f, 0.02689387f, 0.00987086f, 0.05365632f, -0.12717155f, 0.02529550f, 0.07871500f, -0.01430271f, 
    0.28153777f, 0.23518308f, -0.17384449f, -0.04691197f, 0.23360199f, 0.06567374f, 0.05868341f, 0.20379649f, 
    0.12948088f, 0.10023419f, 0.22002669f, 0.16586486f, 0.02265835f, 0.00196760f, -0.06878996f, -0.05409586f, 
    0.04801916f, -0.02648229f, 0.03045463f, -0.00715732f, 0.04176354f, 0.08259489f, 0.04647625f, 0.05977352f, 
    0.09657045f, 0.06366236f, -0.19121346f, -0.24276924f, -0.05607108f, -0.01740337f, -0.07213837f, -0.02155479f, 
    0.08334226f, 0.03957248f, 0.08046062f, -0.00708836f, 0.03465221f, -0.01736739f, -0.03365719f, -0.11953940f, 
    -0.21644028f, 0.06970017f, 0.04842087f, 0.06137566f, 0.04214370f, 0.14752166f, 0.04835074f, 0.15587305f, 
    -0.10855491f, -0.19707578f, -0.04354028f, 0.12205890f, -0.00294221f, 0.08702214f, 0.07126775f, 0.13024777f, 
    0.05497198f, 0.05544880f, 0.01135652f, -0.01959212f, -0.57833332f, -0.34556890f, -0.31743026f, -0.03771611f, 
    0.03185431f, 0.17069012f, 0.11889278f, 0.11365223f, -0.09377751f, -0.01130966f, 0.01840966f, -0.01115587f, 
    0.00873100f, -0.52413803f, -0.14640595f, 0.40523922f, 0.02455450f, 0.27568424f, 0.08499130f, 0.20363133f, 
    -0.12122183f, 0.00619052f, -0.00935852f, -0.00826783f, 0.00065090f, -0.13544318f, -0.18701203f, -0.23901896f, 
    0.14847912f, -0.06850766f, -0.04928657f, 0.02449343f, 0.01015107f, 0.15523815f, 0.02545916f, 0.25493217f, 
    -0.26791340f, -0.01720505f, 0.19387071f, 0.05712371f, -0.02441905f, -0.04328157f, -0.08754205f, 0.01323954f, 
    0.00936483f, -0.00080765f, 0.02029356f, 0.08831053f, -0.07550253f, -0.09821475f, 0.01213194f, 0.03634198f, 
    0.02553712f, 0.01529446f, 0.03172727f, 0.02559352f, -0.26295567f, 0.00188971f, -0.16324081f, -0.45873344f, 
    -0.16488795f, -0.18962729f, -0.44642156f, -0.23576477f, -0.06151214f, -0.05976290f, 0.07948111f, -0.10219601f, 
    0.03930302f, -0.06797896f, 0.02050329f, 0.06970819f, 0.15222237f, 0.30679348f, -0.03124891f, -0.06513740f, 
    0.10551731f, -0.04202825f, -0.08191311f, 0.01596003f, -0.15442310f, -0.00801687f, -0.08956212f, -0.02171833f, 
    -0.18875590f, -0.07415847f, -0.02224999f, -0.05524201f, 0.05744090f, -0.06499661f, 0.09818338f, 0.00411674f, 
    -0.02406015f, -0.13147137f, -0.18134634f, -0.32742611f, -0.03953797f, -0.07094298f, 0.00987020f, 0.01915800f, 
    -0.02061912f, -0.03041009f, -0.00839998f, 0.00262640f, -0.15743260f, -0.12169031f, -0.35497478f, -0.43054157f, 
    -0.02907316f, 0.03177741f, -0.17550786f, 0.16894203f, -0.06808641f, -0.07672763f, 0.07515018f, 0.03215752f, 
    -0.05474491f, -0.00305047f, -0.07049214f, 0.05540476f, -0.14685337f, -0.34561148f, -0.21460269f, -0.27127555f, 
    0.06945065f, -0.07317586f, -0.11185324f, 0.15658718f, 0.02302117f, 0.04601383f, 0.01326135f, 0.11270425f, 
    -0.10011510f, 0.03725698f, 0.04861184f, 0.00987059f, 0.07623597f, 0.11660933f, -0.01964142f, -0.03154432f, 
    0.09586099f, 0.02230282f, 0.08183056f, 0.04372219f, 0.21679996f, 0.10833792f, -0.01206851f, -0.12476669f, 
    0.00802126f, 0.10228968f, 0.08785311f, 0.01899901f, 0.09109581f, -0.06503620f, 0.06612533f, -0.11133211f, 
    0.44848228f, 0.05450610f, 0.09012698f, 0.00248318f, 0.01167191f, 0.06198082f, 0.15249766f, -0.11568269f, 
    0.15142432f, 0.07261851f, 0.11730395f, -0.00594451f, -0.04003428f, 0.08408798f, -0.01055008f, 0.08845068f, 
    -0.03798589f, -0.02561522f, -0.04724040f, -0.00919067f, -0.02158175f, -0.04202592f, -0.00618712f, -0.01229023f, 
    -0.04592040f, 0.11074629f, 0.15724124f, -0.15354629f, 0.01691177f, -0.12521079f, -0.02787225f, -0.01409458f, 
    -0.01126397f, -0.01666014f, 0.00950001f, -0.04599239f, 0.05177072f, -0.30499572f, -0.14925514f, 0.21585825f, 
    0.06631604f, 0.09942155f, 0.16991900f, 0.10039783f, 0.14074844f, -0.18997841f, -0.15299420f, 0.09757832f, 
    -0.21370214f, 0.06926493f, 0.03494742f, 0.13285933f, -0.04368428f, -0.05464355f, -0.07223725f, 0.02058236f, 
    0.10604578f, 0.05870477f, 0.10698836f, 0.09730630f, -0.53865212f, 0.01844964f, -0.13572106f, 0.22197005f, 
    0.03690584f, 0.04432395f, -0.05403654f, 0.06123742f, -0.05968198f, 0.01132214f, -0.07391355f, -0.20935257f, 
    -0.20078602f, -0.03516515f, 0.05360908f, -0.20147125f, -0.10275771f, -0.03786342f, -0.03299780f, -0.00762160f, 
    0.10024735f, 0.13891539f, -0.09368366f, -0.21069033f, -0.28136957f, -0.59278661f, -0.47925839f, -0.39660931f, 
    -0.00913106f, 0.12398192f, 0.16598976f, 0.05608788f, 0.09359239f, 0.07433253f, 0.03254177f, -0.06485888f, 
    0.57515782f, -0.07227670f, -0.05394563f, -0.12235715f, 0.23872504f, -0.00015625f, 0.05059947f, 0.12559502f, 
    0.04108657f, 0.01108345f, 0.12037282f, 0.00763523f, 0.07662001f, 0.18823740f, 0.05705841f, -0.12188026f, 
    0.18188182f, -0.11114636f, -0.08226344f, 0.03675475f, -0.11987641f, 0.02342232f, -0.05766135f, -0.04032291f, 
    0.15294382f, 0.04597344f, -0.41789478f, -0.39590061f, 0.07335438f, 0.09521683f, 0.18960762f, 0.07315258f, 
    0.04683281f, -0.07369832f, -0.10975896f, 0.03323892f, -0.32523036f, 0.09479870f, 0.17415865f, 0.12473880f, 
    -0.08914281f, -0.12204779f, -0.08606490f, -0.04363170f, -0.04448946f, -0.01698148f, -0.17268506f, 0.01502460f, 
    -0.04581069f, -0.16520856f, -0.05241150f, 0.00042226f, -0.07261474f, 0.06691743f, -0.19549982f, 0.02557497f, 
    -0.13124220f, -0.15272634f, -0.10216039f, -0.13038668f, -0.57654899f, 0.04101054f, -0.06409121f, 0.15139708f, 
    0.00900603f, -0.07540460f, -0.03453223f, -0.08192309f, -0.09238949f, -0.11000654f, -0.17375821f, -0.01917635f, 
    -0.59809291f, 0.08333620f, -0.00316083f, 0.11972992f, 0.03177403f, 0.04950346f, -0.01567906f, -0.04991021f, 
    -0.05997112f, 0.06653199f, -0.09861260f, 0.03260254f, 0.16631623f, -0.00238726f, 0.00871551f, 0.02819488f, 
    0.01139350f, 0.05469655f, 0.06647915f, 0.11093727f, -0.12920341f, -0.23759411f, -0.04145976f, -0.35666040f, 
    0.28841650f, 0.19820389f, -0.00187299f, -0.14856519f, -0.02368660f, -0.02497011f, -0.03522848f, -0.03556775f, 
    0.03488817f, 0.07659585f, 0.07122361f, 0.12500131f, 0.14377978f, 0.21519645f, -0.00286080f, -0.22808537f, 
    -0.02688280f, -0.16116482f, 0.01192869f, -0.03180149f, 0.04277881f, 0.08170782f, 0.01395452f, 0.05107103f, 
    0.34216207f, 0.22055718f, 0.10422834f, -0.07050963f, -0.08708323f, -0.08325442f, 0.06551956f, -0.20371427f, 
    0.03514934f, 0.09173273f, 0.00870814f, -0.03500187f, -0.00702382f, -0.21903405f, -0.59362322f, -0.07643742f, 
    0.09920974f, -0.08850246f, 0.31741047f, 0.00248362f, 0.03056560f, -0.14978996f, 0.01444034f, 0.05191249f, 
    -0.38136554f, -0.20713876f, -0.03053588f, 0.08664763f, 0.03117283f, 0.07708860f, 0.08408054f, 0.07711814f, 
    0.13378151f, 0.11475313f, -0.00583829f, 0.13621719f, 0.10198821f, 0.02278497f, -0.10160833f, -0.13457839f, 
    -0.05385633f, -0.07844318f, -0.02199457f, -0.02772860f, 0.14463969f, 0.08082402f, 0.11243727f, 0.12206124f, 
    0.15388553f, 0.04437394f, -0.14697617f, -0.21945590f, 0.04717398f, -0.07304887f, 0.05625662f, -0.08149509f, 
    0.00644141f, 0.03015243f, 0.18478665f, 0.10617823f, 0.12213060f, 0.01130864f, -0.02975481f, -0.05333621f, 
    0.02204624f, -0.02108905f, -0.06387779f, -0.07477402f, 0.04661560f, 0.08193301f, 0.11332968f, 0.03248835f, 
    -0.27386373f, -0.39506522f, -0.17230292f, -0.20766687f, -0.06166444f, 0.05452704f, 0.04123383f, 0.03363520f, 
    0.15503067f, -0.02427325f, 0.03908888f, -0.16275288f, 0.21854089f, -0.03110899f, -0.25958076f, 0.09105376f, 
    0.09768262f, -0.01875114f, 0.10856464f, 0.07799482f, -0.02303631f, 0.02639883f, -0.07147750f, -0.02850100f, 
    -0.12446608f, -0.26942480f, -0.09220906f, 0.17869784f, 0.16026032f, 0.10752174f, 0.09198527f, 0.05316120f, 
    -0.19364034f, -0.13868950f, 0.01347508f, 0.02639294f, -0.00759183f, -0.30957788f, -0.39872539f, -0.05197597f, 
    -0.08961374f, 0.14339130f, 0.09440720f, -0.09496664f, -0.09866954f, 0.06186319f, -0.01210797f, 0.02809592f, 
    0.55313349f, 0.05925198f, -0.19700494f, -0.22590086f, 0.10609534f, -0.11233445f, -0.03224609f, -0.03820028f, 
    0.02022006f, 0.07796162f, 0.06118755f, 0.00537214f, 0.09409454f, -0.02683108f, 0.00621150f, -0.04718777f, 
    -0.01651480f, -0.09459762f, 0.00626527f, 0.02523197f, 0.09326483f, -0.00528410f, -0.05374368f, 0.24442405f, 
    -0.16697687f, -0.38308847f, 0.32935458f, 0.20036776f, 0.07951023f, 0.04872076f, -0.12273889f, -0.00809918f, 
    -0.03764558f, 0.00577321f, 0.08643287f, -0.12677634f, 0.07681011f, -0.18557423f, -0.12063167f, -0.08653127f, 
    -0.03819191f, -0.00122605f, 0.01559829f, -0.13869837f, -0.01358631f, -0.06626058f, -0.04645132f, 0.07400934f, 
    -0.44177487f, -0.02029480f, 0.00291125f, 0.24448654f, 0.08745360f, -0.03674031f, -0.03204474f, -0.01855263f, 
    0.01706206f, 0.05229354f, 0.03740318f, 0.15986650f, -0.43721616f, -0.08175023f, 0.01012355f, 0.11080090f, 
    0.04926478f, 0.07768823f, -0.11775567f, -0.07523983f, 0.00026141f, 0.04456998f, 0.13192868f, 0.08516352f, 
    0.18457870f, -0.17234260f, 0.03222428f, 0.06729291f, 0.18175569f, 0.00059605f, 0.18742983f, 0.01406975f, 
    0.05994890f, 0.01181657f, 0.03157089f, 0.02646411f, -0.22745104f, -0.08070533f, -0.03775040f, 0.18603048f, 
    -0.03843253f, -0.07996936f, -0.01537535f, 0.00598614f, -0.06088779f, -0.02287621f, -0.00443410f, -0.23352796f, 
    0.14787395f, -0.08573718f, -0.26578394f, -0.33575037f, 0.01975449f, -0.00762957f, -0.04860961f, 0.01403458f, 
    0.07371879f, -0.01037287f, 0.01890854f, -0.03515450f, -0.24480227f, -0.20553350f, -0.14776669f, -0.15064187f, 
    -0.00390144f, 0.10872939f, -0.04271200f, 0.04389994f, 0.04297527f, 0.10516448f, 0.08068547f, 0.04134066f, 
    -0.14098279f, 0.05981252f, -0.05522778f, -0.02328486f, 0.12106970f, -0.09778451f, 0.06453855f, -0.09143823f, 
    0.20444560f, 0.03814008f, -0.07380829f, -0.00264133f, -0.06426087f, 0.13077293f, -0.22031552f, -0.02919655f, 
    0.03231963f, -0.13250664f, 0.13289237f, 0.02076541f, 0.09438530f, 0.08268712f, 0.08839937f, 0.15957829f, 
    -0.06053027f, 0.26979864f, 0.13154486f, -0.06318585f, 0.04030072f, -0.29454187f, 0.20268114f, 0.12566818f, 
    -0.07007998f, -0.06960367f, -0.06066985f, -0.04532884f, 0.39044610f, -0.30339292f, 0.16974142f, -0.45257178f, 
    0.06480262f, -0.01422630f, -0.14418146f, -0.10159156f, 0.06230646f, -0.08026166f, -0.06719172f, -0.05376764f, 
    -0.07312078f, 0.00644224f, 0.11771263f, 0.04034190f, 0.02909292f, 0.03535908f, -0.04338303f, -0.04815491f, 
    -0.08549197f, 0.14344771f, 0.14466755f, 0.14852640f, -0.30489358f, -0.01689218f, -0.02382568f, -0.00333646f, 
    0.02737262f, -0.01387547f, 0.03236668f, 0.05676153f, 0.04773622f, 0.10628377f, 0.16052225f, -0.05050092f, 
    -0.04968152f, 0.20037341f, -0.46259737f, 0.01217259f, 0.04369245f, 0.11034999f, 0.12210691f, 0.07380836f, 
    0.12004980f, -0.08788104f, 0.00613711f, 0.03553557f, -0.59247822f, 0.16364849f, 0.16496044f, -0.12082377f, 
    -0.07367455f, -0.04970050f, -0.14804171f, 0.02466436f, -0.00576326f, -0.06025359f, -0.01197308f, -0.10378005f, 
    -0.35883027f, 0.10736648f, -0.28121418f, 0.17331402f, 0.02644989f, -0.07447374f, 0.00162186f, 0.04788776f, 
    0.01243794f, -0.13309062f, -0.00777652f, -0.05866016f, -0.01440718f, -0.14089590f, 0.06923989f, 0.10763457f, 
    0.10020825f, 0.11260055f, 0.06145212f, -0.08274263f, 0.14740930f, 0.03685823f, -0.05513876f, 0.03022001f, 
    -0.08953764f, -0.14533035f, 0.04319679f, 0.25557500f, 0.06782967f, -0.05475548f, -0.11619115f, -0.07577787f, 
    0.04100075f, 0.00570516f, -0.02479181f, 0.00393525f, -0.07148675f, -0.55635720f, 0.08076473f, -0.23874038f, 
    0.01830439f, 0.09754724f, -0.26471758f, -0.01988800f, -0.18860990f, -0.04272509f, -0.04229619f, -0.00644258f, 
    0.12336197f, 0.12341744f, 0.06875499f, -0.10239292f, 0.04300419f, -0.13437375f, -0.05035456f, -0.20350502f, 
    0.02410127f, -0.05610669f, 0.04069060f, 0.05889605f, 0.25043437f, 0.06182586f, 0.01746548f, 0.05930938f, 
    0.00775772f, -0.09773324f, -0.15087578f, -0.08841363f, 0.01394537f, 0.00863933f, 0.01474363f, 0.05519237f, 
    -0.30434111f, 0.20390944f, -0.41206518f, -0.53239143f, -0.29881999f, 0.05648107f, 0.10102481f, -0.10419129f, 
    0.16618824f, -0.06899621f, -0.00189032f, -0.04121063f, 0.14264569f, -0.04535788f, 0.21885031f, 0.14561792f, 
    0.30094850f, -0.12836908f, -0.00832179f, 0.02821206f, -0.00091065f, -0.06268542f, -0.16012263f, -0.08760117f, 
    -0.12202815f, -0.12140937f, -0.01418341f, -0.06899699f, 0.08307905f, -0.06273759f, 0.11176645f, 0.01928399f, 
    -0.03194180f, 0.06186983f, -0.05532390f, -0.14278278f, -0.12491713f, 0.12636146f, 0.00608608f, 0.25371784f, 
    -0.09150710f, -0.05374072f, -0.04090847f, 0.02617778f, 0.24500538f, 0.08818601f, 0.00834340f, 0.07946515f, 
    -0.39804882f, 0.04473506f, -0.18915632f, -0.26185921f, -0.12138832f, -0.03012419f, -0.01936526f, 0.12500678f, 
    0.06902856f, 0.04759838f, 0.02964172f, -0.03729209f, -0.22915159f, -0.21932431f, -0.72475743f, 0.30848023f, 
    -0.11593311f, 0.15714988f, 0.19268794f, -0.06153169f, 0.00886393f, 0.00639561f, 0.00070777f, -0.02952439f, 
    0.11812651f, -0.09744756f, -0.13569443f, 0.07445978f, 0.12082040f, -0.02071596f, 0.12226378f, 0.02552745f, 
    0.02997823f, 0.04405014f, 0.09394652f, 0.05215978f, 0.06687121f, -0.02704472f, 0.26140901f, 0.02866692f, 
    -0.06200905f, -0.03792669f, -0.06125133f, -0.02370707f, 0.03381116f, 0.13450950f, 0.01456018f, 0.06980504f, 
    -0.24926740f, 0.03598509f, -0.01806256f, 0.01871210f, 0.09286106f, -0.15204802f, 0.09093950f, 0.01705322f, 
    0.14408411f, -0.04962564f, 0.01694229f, -0.03577917f, -0.27828774f, 0.02945071f, -0.10515589f, -0.06021115f, 
    -0.20686267f, -0.01498657f, 0.05291436f, 0.23127644f, 0.02097972f, 0.00860333f, 0.01383420f, -0.06282316f, 
    0.00323654f, -0.14225684f, -0.12759888f, -0.16884495f, 0.11660910f, 0.05942908f, 0.12841640f, 0.12315276f, 
    -0.01578178f, -0.06234115f, -0.12343206f, -0.06732441f, -0.06311193f, 0.13459364f, 0.02124605f, 0.14651574f, 
    0.00480438f, -0.16787842f, -0.03879657f, -0.10436282f, 0.07029894f, 0.07552068f, 0.04534034f, 0.07631580f, 
    -0.12280606f, -0.34418932f, 0.04181020f, -0.14647660f, -0.03827464f, -0.01755170f, -0.10487231f, 0.02584478f, 
    -0.08509731f, -0.02151880f, -0.03021784f, 0.04303337f, -0.03054910f, -0.19931673f, -0.12790355f, -0.04052344f, 
    -0.00100825f, 0.13633478f, 0.09293844f, -0.05999226f, 0.04031980f, 0.05976025f, -0.01609190f, 0.06096913f, 
    -0.10028534f, -0.04989294f, -0.18315415f, 0.11899523f, 0.13072929f, 0.02099813f, 0.15813862f, -0.03911989f, 
    0.02571439f, -0.01655688f, -0.09935544f, -0.00130983f, -0.38522059f, 0.07041405f, 0.14557007f, -0.09482938f, 
    0.17664143f, -0.19975488f, 0.13348289f, -0.07141612f, -0.13312775f, -0.01300188f, -0.02658335f, -0.03781494f, 
    -0.05137680f, -0.18399192f, -0.07026239f, -0.13824648f, -0.06405815f, 0.03588960f, 0.09134003f, 0.04018654f, 
    -0.01413088f, 0.03289689f, -0.04008003f, -0.16085100f, 0.00272044f, 0.11218547f, -0.17929785f, -0.11570402f, 
    0.04959605f, -0.00465834f, -0.06590606f, 0.20407410f, 0.06220798f, 0.09203381f, 0.10540784f, 0.07196780f, 
    0.15895435f, 0.03503382f, 0.16098304f, 0.20499451f, -0.03261236f, 0.06111937f, -0.03064706f, -0.05088968f, 
    0.04037363f, 0.15706424f, 0.10771075f, -0.05434334f, 0.18128633f, 0.25445351f, 0.07090238f, -0.05997918f, 
    -0.16359051f, -0.08063346f, 0.00645820f, -0.06597761f, 0.09970532f, -0.02091201f, -0.00277993f, 0.03141756f, 
    -0.32443872f, 0.03793377f, -0.38979098f, 0.11213278f, -0.01817207f, 0.05288428f, 0.06869587f, -0.17335659f, 
    0.01606975f, -0.11786234f, 0.02332381f, -0.01735121f, 0.14862639f, 0.35778627f, -0.81514430f, 0.01881939f, 
    0.09627543f, 0.06875188f, 0.20974895f, 0.03301457f, -0.03686937f, -0.03184233f, -0.04944380f, -0.04323156f, 
    -0.09939782f, 0.21742283f, 0.08467179f, 0.44766575f, -0.05422961f, -0.06276722f, -0.06473215f, 0.00696918f, 
    0.12120997f, -0.06552956f, -0.00259494f, 0.10528320f, -0.13177614f, -0.22756615f, -0.08810940f, 0.05313667f, 
    0.06645896f, 0.03691138f, 0.10775911f, 0.07065130f, 0.00940437f, -0.00263579f, 0.00608003f, 0.10356397f, 
    0.16771454f, -0.00634254f, 0.17812969f, -0.06188856f, -0.02170068f, -0.20674321f, 0.00975952f, 0.11321601f, 
    -0.07218366f, 0.10052843f, 0.00631791f, 0.00113023f, -0.05936732f, 0.04227442f, -0.20497903f, 0.06762903f, 
    0.06881890f, 0.06380755f, 0.04416071f, -0.01691750f, 0.03608843f, 0.00523040f, 0.01502214f, -0.03976105f, 
    -0.06529653f, 0.26286095f, 0.62930828f, -0.53156292f, 0.08032420f, -0.19292371f, -0.01496047f, 0.03390980f, 
    -0.05687575f, 0.10116856f, 0.04479612f, -0.02118529f, -0.00188605f, 0.08797985f, 0.14650445f, 0.35514340f, 
    0.04196728f, -0.02457147f, -0.00120162f, -0.07128572f, 0.05610090f, 0.07300196f, 0.10946189f, 0.21389423f, 
    -0.30220801f, -0.22051238f, -0.03516106f, 0.05357618f, -0.04398289f, -0.00174007f, 0.01914722f, -0.07113933f, 
    0.03036688f, -0.06916050f, 0.00518857f, 0.06726268f, -0.11529814f, -0.66569632f, 0.11293113f, 0.03303116f, 
    -0.03260472f, 0.23251359f, -0.10007132f, -0.04043576f, 0.10927383f, 0.03575749f, 0.04747457f, 0.03738981f, 
    0.28818911f, -0.74996060f, -0.10212099f, -0.20166461f, 0.05585439f, 0.09540863f, 0.01596671f, 0.04001519f, 
    -0.11414044f, 0.01155460f, 0.02552049f, -0.06573594f, 0.26445052f, -0.35502523f, 0.07012869f, -0.32121560f, 
    -0.23811246f, 0.03691768f, -0.26309541f, -0.24821489f, 0.08765589f, -0.09627821f, -0.07248818f, 0.09999755f, 
    0.28110111f, 0.13281322f, 0.17499426f, -0.16112751f, 0.14128891f, -0.09211084f, 0.03472124f, 0.05071545f, 
    -0.06003720f, 0.05875092f, -0.01060255f, 0.05914571f, -0.17385605f, 0.16967416f, 0.07788067f, 0.15454473f, 
    -0.00546947f, 0.01378357f, -0.16286162f, -0.04241391f, -0.06405792f, -0.03521483f, 0.00637578f, -0.02905722f, 
    -0.15830128f, -0.12147519f, 0.24130768f, 0.37471810f, -0.00331349f, -0.00726251f, -0.20463583f, -0.16236518f, 
    0.01677978f, -0.09545534f, -0.09515881f, 0.07735608f, 0.03316292f, -0.22730860f, -0.01466345f, -0.06245701f, 
    0.03256940f, 0.22194622f, 0.00994340f, -0.05866865f, 0.02470116f, -0.07317329f, 0.05956832f, -0.08117758f, 
    0.24032907f, 0.22426130f, 0.30869162f, 0.33922422f, 0.00851450f, -0.10936648f, -0.12607017f, -0.17552924f, 
    -0.00258066f, 0.10605731f, -0.02574106f, 0.09379956f, -0.14106527f, 0.19425301f, -0.09604909f, -0.34962341f, 
    -0.10944836f, -0.02770391f, 0.06655660f, 0.04691776f, 0.02666141f, -0.03832574f, -0.10260129f, 0.00733322f, 
    -0.16679136f, 0.37578189f, 0.50275421f, -0.51453584f, 0.02292888f, -0.15806028f, -0.00088124f, -0.23830602f, 
    -0.08031534f, -0.04743398f, 0.06397101f, 0.09520332f, -0.25915900f, -0.04402122f, 0.13369350f, 0.22122926f, 
    0.11205255f, -0.24270320f, -0.16071065f, 0.12200097f, 0.03654762f, -0.10428432f, -0.07640661f, -0.02263102f, 
    -0.50944501f, -0.30339563f, -0.07984609f, 0.18280962f, 0.07602442f, 0.03205200f, -0.09961399f, -0.13948287f, 
    0.18232581f, -0.12387805f, 0.03295479f, -0.02363303f, -0.10040646f, 0.05932361f, -0.09320471f, 0.02621944f, 
    0.09131331f, 0.04708673f, -0.11647731f, 0.05071471f, 0.12135709f, -0.18257150f, 0.00403679f, 0.19972864f, 
    -0.17000301f, -0.48748103f, -0.07569341f, -0.31665152f, -0.05346832f, 0.05099061f, -0.03905030f, 0.10776516f, 
    0.14748757f, -0.05732437f, -0.01682805f, 0.10312928f, 0.16517642f, -0.16108434f, 0.05977518f, -0.07782296f, 
    0.08163775f, -0.05148607f, 0.05397283f, 0.00422127f, -0.13596469f, 0.05828125f, -0.05662500f, 0.14638416f, 
    -0.13609712f, -0.11850647f, -0.07456862f, 0.08438013f, -0.00465039f, 0.02554948f, 0.02040802f, 0.03186360f, 
    0.00246343f, -0.03630905f, -0.05051569f, -0.06051629f, -0.17679723f, 0.15412916f, -0.38298422f, 0.06514455f, 
    0.12433498f, 0.00601518f, 0.09795689f, -0.10705219f, 0.12208045f, 0.00169559f, -0.14154723f, -0.21358892f, 
    0.04750076f, 0.19318151f, -0.24964839f, 0.14570779f, -0.05091053f, -0.29411995f, -0.12681654f, -0.03205347f, 
    0.08752428f, 0.05553282f, -0.07343137f, -0.04248503f, -0.08097824f, -0.09626033f, -0.15741824f, -0.30470061f, 
    -0.04344850f, 0.03128088f, 0.23389407f, -0.17478989f, 0.11957266f, 0.01196418f, -0.09522498f, 0.05529749f, 
    -0.20647828f, -0.25069433f, 0.05013794f, 0.03263240f, -0.00562759f, 0.06830996f, 0.00377774f, 0.03567389f, 
    -0.00171477f, 0.08005271f, 0.06400395f, -0.01451483f, -0.14866990f, 0.09665637f, -0.11753658f, -0.10248911f, 
    -0.10159425f, -0.10122162f, 0.12306382f, 0.09017742f, 0.03680257f, 0.01818957f, -0.08592347f, -0.04765271f, 
    -0.14961082f, -0.23650102f, -0.33434182f, -0.33059874f, -0.09029464f, 0.09456105f, 0.00631390f, -0.00745277f, 
    -0.13057840f, 0.11885949f, -0.09272309f, 0.06912059f, 0.02733370f, -0.02461381f, -0.07724556f, 0.05337110f, 
    -0.08515922f, -0.04768818f, 0.02104739f, 0.02699740f, 0.06313763f, -0.03127187f, -0.28148904f, 0.02271422f, 
    -0.34992737f, 0.06843033f, -0.13339972f, -0.04421386f, -0.10213698f, 0.10974895f, -0.04143717f, -0.12905441f, 
    -0.11908890f, -0.02956940f, 0.01517141f, 0.10341351f, -0.47569481f, 0.32481334f, 0.15554711f, 0.48321930f, 
    0.00349301f, 0.02121663f, 0.02589371f, -0.05535084f, 0.09462617f, 0.07060730f, 0.08142747f, 0.08033129f, 
    -0.03231735f, 0.03277536f, 0.11634706f, -0.11707310f, -0.02754423f, 0.05521031f, 0.08236693f, 0.09426931f, 
    -0.07565231f, -0.09631955f, -0.35365981f, -0.34291559f, -0.04547328f, -0.22475071f, -0.00890854f, -0.04481663f, 
    0.06920831f, 0.05004204f, 0.02075462f, -0.06924632f, 0.03894228f, 0.04944866f, -0.06538063f, -0.08771532f, 
    -0.09345646f, -0.23808838f, 0.11006650f, -0.18022451f, -0.01812072f, -0.05673433f, 0.02729482f, -0.04516292f, 
    -0.06270439f, 0.11774674f, 0.15308887f, -0.02990696f, 0.44163749f, -0.22903155f, 0.21453243f, -0.13100086f, 
    -0.06420952f, 0.10525468f, 0.17858453f, 0.24628329f, 0.08160944f, -0.06230917f, 0.02324613f, 0.16629444f, 
    0.16904359f, 0.15566809f, 0.10502619f, -0.17778510f, -0.07815525f, 0.06813532f, 0.05533265f, 0.19244382f, 
    0.01105072f, 0.08606979f, 0.03194328f, 0.15179864f, -0.29244119f, -0.10250643f, -0.29207969f, -0.25038397f, 
    -0.11139460f, 0.06910232f, 0.09490680f, -0.05421700f, 0.02329323f, -0.03185607f, 0.09519657f, 0.04885705f, 
    -0.32606912f, 0.34619004f, 0.00386794f, -0.11417056f, -0.10313373f, 0.03694461f, 0.13215494f, 0.09130233f, 
    0.07969213f, -0.02530049f, -0.07478143f, 0.07020362f, -0.01316035f, 0.17873359f, 0.28619096f, 0.21860105f, 
    0.00245158f, 0.04153577f, -0.07505085f, 0.06959139f, 0.13027452f, 0.10793188f, 0.09155047f, 0.08086511f, 
    0.16415875f, 0.16372176f, 0.12839811f, -0.09370939f, 0.01684721f, -0.10569531f, 0.13560808f, 0.06958044f, 
    -0.11867195f, 0.04196999f, -0.00491492f, -0.04982106f, 0.01147824f, 0.15132195f, -0.12757708f, -0.11723657f, 
    0.04777615f, -0.05923937f, -0.12004454f, -0.10122617f, -0.04242746f, 0.03848627f, -0.17617090f, -0.38634896f, 
    0.26042885f, 0.27604854f, 0.27806312f, 0.01527568f, -0.07158555f, 0.09112162f, 0.04556729f, 0.13941818f, 
    -0.15403995f, 0.13886350f, 0.17318693f, -0.05900441f, -0.20520793f, 0.29520270f, -0.20774293f, 0.29957804f, 
    0.01715559f, 0.01479709f, -0.04851370f, -0.07478276f, 0.17615741f, -0.03105907f, 0.15591505f, 0.31393027f, 
    0.16310507f, -0.12501557f, 0.17152847f, 0.12849948f, -0.06089032f, -0.01946140f, 0.09323280f, 0.11857150f, 
    -0.01833219f, 0.03123860f, 0.05843150f, 0.01607152f, 0.43597499f, -0.25802913f, 0.15152527f, -0.23700309f, 
    -0.06750374f, -0.04853117f, -0.03727619f, 0.04665992f, -0.23327002f, -0.08382630f, -0.22667018f, -0.14916542f, 
    -0.08399065f, -0.24053475f, -0.25758502f, -0.06108892f, -0.02990555f, 0.00847122f, -0.00073011f, -0.04460341f, 
    -0.02447895f, 0.10965496f, 0.12395056f, -0.09930103f, -0.03381897f, 0.04806499f, -0.13905913f, 0.09142918f, 
    -0.14188465f, -0.06112535f, 0.03263588f, -0.20220426f, 0.03949909f, 0.06454510f, -0.08534519f, 0.05525837f, 
    -0.15399210f, 0.20015955f, -0.31435764f, -0.06779538f, -0.08817969f, 0.03504828f, -0.02041425f, -0.05203616f, 
    -0.12569286f, -0.30807361f, -0.19555140f, -0.23825933f, -0.20093617f, 0.09829134f, -0.33541578f, 0.29100621f, 
    -0.01907276f, -0.09919851f, -0.04770128f, 0.08163714f, -0.14293940f, -0.33836746f, -0.19113407f, -0.24956074f, 
    -0.16172545f, -0.06206665f, 0.26509303f, 0.12560970f, 0.01496163f, 0.05579932f, -0.07072546f, 0.09758652f, 
    0.11959095f, -0.15834726f, -0.09659373f, -0.10128628f, -0.20304447f, 0.10210097f, -0.22241253f, 0.07322152f, 
    -0.02587893f, 0.08720530f, -0.06712657f, 0.04647386f, 0.01877968f, 0.14849983f, 0.05130985f, 0.06831598f, 
    -0.16313015f, 0.02906480f, 0.13769314f, -0.06447449f, -0.01768125f, -0.01760146f, 0.01667347f, -0.00181728f, 
    -0.18670735f, -0.02151298f, 0.09498458f, -0.02295652f, -0.18650648f, 0.22255610f, 0.13351719f, -0.21075302f, 
    0.05318942f, 0.08046117f, -0.16330008f, 0.03124543f, -0.06408931f, -0.13652404f, -0.07730998f, -0.38738635f, 
    -0.37549782f, 0.05843224f, -0.01432736f, 0.14278492f, 0.04754540f, 0.22087249f, 0.07128592f, -0.07909261f, 
    -0.00227980f, 0.06504972f, 0.03676695f, -0.00806543f, -0.07698663f, 0.06061327f, 0.12703869f, -0.07761589f, 
    -0.07222974f, 0.04919608f, -0.09350160f, -0.12933652f, 0.13373722f, 0.00390893f, -0.00728424f, 0.03178581f, 
    0.02077585f, 0.15591916f, 0.05155981f, -0.04660006f, -0.21129265f, 0.05964850f, 0.07126047f, -0.03722954f, 
    0.10033248f, 0.18509851f, -0.10455383f, 0.03998066f, -0.18433110f, 0.13159592f, 0.18910055f, 0.06770962f, 
    0.01425349f, 0.04022954f, -0.19756719f, 0.18030955f, 0.08807711f, -0.16034973f, -0.04176963f, -0.03680026f, 
    0.15446441f, -0.16232236f, 0.21513110f, 0.15055346f, -0.09322473f, -0.05590551f, 0.06235444f, -0.00834480f, 
    0.12145885f, 0.00957129f, 0.01488053f, 0.05094259f, 0.02404701f, -0.09677222f, 0.14743344f, 0.19220962f, 
    0.01461277f, 0.15369806f, 0.20471026f, -0.09063928f, -0.09408963f, -0.16881543f, -0.16553143f, -0.24664690f, 
    -0.08052383f, -0.00219650f, 0.04847040f, 0.01992823f, -0.06524076f, -0.15699193f, 0.07735205f, -0.08376966f, 
    -0.17095613f, -0.03203249f, -0.16593100f, -0.07254490f, -0.13006209f, 0.04663581f, -0.04751393f, 0.05967676f, 
    0.06608823f, 0.14204477f, -0.16030335f, -0.02613743f, -0.02600464f, 0.07513399f, 0.04904255f, -0.08740503f, 
    -0.26323661f, -0.11634934f, 0.29091722f, 0.02599554f, -0.16065393f, 0.08866619f, 0.11339951f, -0.13882831f, 
    -0.10839973f, 0.03356410f, 0.01412215f, 0.04165376f, -0.11129137f, 0.04146043f, -0.50610918f, -0.08172623f, 
    -0.15622465f, -0.11162237f, 0.15290004f, -0.21763420f, -0.13900413f, 0.19887164f, -0.11053685f, -0.01367248f, 
    -0.28856272f, 0.36102045f, -0.29698589f, -0.15189211f, -0.08020610f, 0.02973867f, 0.22350621f, 0.06901013f, 
    -0.26118851f, 0.03262515f, -0.01876252f, -0.14078434f, 0.03646086f, -0.11280019f, 0.06113142f, 0.15360464f, 
    -0.07929212f, -0.06391227f, -0.04298318f, -0.17529486f, 0.00637746f, -0.08797786f, -0.08360374f, 0.15968069f, 
    -0.24452774f, -0.20163967f, -0.10381956f, 0.13200364f, -0.06232915f, -0.08235595f, -0.07368496f, 0.10225213f, 
    -0.14911172f, 0.04641476f, -0.06003894f, 0.00996407f, -0.27391061f, 0.03741246f, -0.13932519f, 0.18596976f, 
    -0.08310934f, 0.01366714f, 0.05499320f, -0.07067303f, -0.09590565f, -0.08611519f, 0.02005846f, 0.03103547f, 
    -0.20974264f, -0.16867925f, 0.00873823f, 0.15314886f, -0.08392575f, -0.05600613f, 0.02012548f, 0.02561866f, 
    0.02589965f, -0.16864537f, -0.02416658f, -0.08315372f, -0.14670511f, 0.12303384f, 0.08063103f, -0.20572397f, 
    -0.12026643f, 0.05588462f, 0.01009928f, -0.12938488f, -0.02426565f, 0.01162530f, -0.24052761f, -0.46848035f, 
    0.01730742f, 0.10787701f, 0.17313370f, -0.13196348f, -0.08024213f, 0.14458802f, 0.10899717f, -0.02236215f, 
    0.04944463f, -0.03356120f, -0.11754695f, 0.03689502f, -0.34655812f, -0.10588613f, -0.30515650f, -0.00503799f, 
    -0.09338889f, 0.13382964f, 0.02875034f, -0.06315372f, 0.05603290f, -0.15422650f, -0.06321306f, -0.09909955f, 
    -0.35100424f, -0.04972251f, -0.16594405f, 0.01421016f, 0.04641016f, 0.10469180f, -0.09328792f, -0.08756706f, 
    0.14480355f, -0.05561899f, -0.07621652f, -0.01283717f, -0.53608614f, 0.17304446f, -0.28294992f, 0.15013936f, 
    0.18314219f, -0.03115204f, -0.07143757f, -0.10222084f, -0.21039572f, 0.11667000f, 0.06024152f, -0.11985209f, 
    0.21671885f, 0.00107921f, 0.21167441f, 0.07628699f, -0.14689952f, -0.00244326f, 0.03810662f, 0.03713949f, 
    -0.07718684f, 0.04245951f, 0.16940729f, 0.16362835f, -0.03570837f, -0.03345205f, 0.15969405f, -0.01525474f, 
    -0.10848793f, -0.02919501f, 0.09652309f, 0.09115010f, 0.00315453f, 0.07349337f, 0.01688580f, 0.18572927f, 
    -0.28029412f, 0.10113059f, -0.02346706f, -0.30658332f, 0.04007388f, 0.01532765f, -0.01919757f, 0.07897222f, 
    -0.00970695f, 0.07472706f, -0.04481655f, 0.09517722f, -0.19601832f, 0.05698387f, 0.18497194f, -0.11769898f, 
    -0.09333750f, -0.02480083f, 0.02309276f, 0.19194023f, 0.22265387f, 0.03357373f, 0.07936574f, 0.05499757f, 
    -0.09309810f, 0.19534102f, -0.05356866f, -0.05055295f, 0.07330681f, 0.06086618f, -0.15349880f, 0.03726599f, 
    -0.10577533f, -0.03239227f, -0.12521668f, 0.02599327f, -0.22277525f, -0.26038611f, 0.08506342f, 0.22628134f, 
    0.05356607f, 0.00092412f, -0.02931134f, -0.06670106f, -0.01656827f, -0.20604005f, 0.02764346f, 0.03606809f, 
    -0.17848705f, 0.04822709f, 0.02218628f, 0.14676863f, -0.01395632f, -0.01602737f, -0.13095580f, 0.11653945f, 
    0.12315571f, -0.00513655f, -0.09908972f, -0.12724310f, -0.05638125f, -0.07479249f, 0.06985366f, 0.01674792f, 
    -0.13129450f, 0.07835743f, -0.07356965f, 0.05661342f, 0.05226331f, 0.06006229f, 0.04999201f, -0.01286817f, 
    -0.29859623f, 0.15983629f, -0.04605712f, -0.16275689f, -0.06796691f, 0.04292453f, 0.00356115f, 0.12032079f, 
    -0.07745430f, 0.00937055f, -0.10798719f, 0.05280564f, 0.18967679f, 0.22268176f, 0.01689885f, -0.07237995f, 
    -0.03453195f, 0.00555636f, 0.08000945f, 0.04082509f, -0.15721299f, 0.13208738f, -0.01667911f, 0.08328725f, 
    0.02680206f, 0.07942885f, 0.18944377f, 0.37233254f, 0.06565595f, -0.13468660f, 0.04234571f, -0.00558655f, 
    -0.01644166f, 0.05474930f, -0.30631262f, -0.08420131f, -0.42203847f, 0.55579698f, -0.00623913f, 0.00031442f, 
    -0.04549257f, -0.00954875f, -0.01457046f, 0.26782912f, 0.12381362f, -0.17276113f, 0.23690943f, 0.17450204f, 
    -0.13855650f, -0.18257104f, 0.46205738f, 0.07691007f, 0.03516989f, 0.12038541f, 0.09026418f, 0.05413736f, 
    0.04249161f, -0.25324056f, 0.20232931f, 0.14044203f, -0.10258003f, -0.27641267f, -0.02473207f, 0.30997545f, 
    0.01488698f, 0.03133332f, 0.08755773f, -0.17702778f, -0.22258174f, -0.10504112f, 0.10195889f, 0.07287332f, 
    -0.29789269f, -0.01270673f, -0.06501410f, 0.16235143f, -0.16285899f, 0.14098424f, 0.13704298f, 0.16524926f, 
    -0.05085643f, 0.09094923f, -0.10973973f, 0.02241172f, 0.16771360f, -0.01574186f, 0.31296715f, 0.05278547f, 
    0.04252775f, -0.11283359f, -0.05945764f, -0.09842557f, -0.00139021f, -0.06687608f, -0.16908258f, -0.13659351f, 
    -0.13253166f, 0.12174595f, -0.38120350f, 0.05370907f, -0.00826785f, 0.10926365f, 0.02406733f, -0.03866914f, 
    0.09015724f, 0.09281662f, -0.07969362f, -0.08092092f, -0.08090721f, -0.38164017f, 0.18315366f, -0.00437592f, 
    -0.08602210f, -0.05728612f, 0.09667382f, -0.05539414f, -0.02156273f, 0.00913599f, 0.20598236f, 0.08912281f, 
    0.30702338f, 0.00579191f, 0.14434557f, -0.13230446f, -0.03124191f, 0.14294349f, -0.03379926f, 0.06212977f, 
    -0.04407779f, -0.05334155f, 0.07058899f, -0.00381884f, 0.11307780f, -0.12181085f, 0.24330457f, 0.00758651f, 
    -0.04738615f, -0.13442329f, 0.24974170f, 0.03678297f, 0.19567548f, -0.07487917f, 0.13665056f, 0.02532128f, 
    0.11119472f, -0.38541448f, 0.07451345f, 0.03781252f, 0.11479333f, -0.22718351f, -0.16616231f, -0.07224581f, 
    -0.01846725f, 0.00387777f, -0.06868944f, -0.18623981f, -0.30994055f, -0.02844719f, 0.01038589f, 0.20235717f, 
    -0.14319825f, -0.00713904f, 0.06247653f, -0.00831649f, 0.01291148f, 0.05181422f, 0.14019546f, -0.00027005f, 
    -0.25431794f, -0.13498874f, -0.02043597f, -0.14822800f, 0.14675368f, -0.05909034f, 0.02583302f, 0.02646123f, 
    0.09267532f, 0.07667486f, 0.05155577f, 0.15418480f, -0.06819116f, -0.45853105f, 0.13021040f, -0.04132076f, 
    0.02023406f, -0.11178212f, -0.04256054f, -0.11669538f, 0.00326281f, 0.07875896f, 0.05267839f, 0.09011899f, 
    0.31083381f, 0.09982976f, 0.23312892f, 0.13296381f, 0.00065153f, -0.03774614f, -0.03832426f, 0.08294178f, 
    -0.13609631f, 0.04758152f, -0.03968289f, 0.04236570f, 0.17416140f, 0.01393548f, 0.31031227f, -0.25038859f, 
    0.01962575f, 0.26642308f, -0.22803983f, -0.06146251f, -0.09827189f, 0.04202483f, -0.00880929f, 0.13451506f, 
    0.19304214f, -0.24877056f, 0.06419601f, 0.06329150f, 0.05098477f, -0.13442431f, -0.00054115f, 0.05741715f, 
    -0.09606918f, -0.02108780f, -0.03339156f, -0.00780005f, 0.04099011f, 0.06417978f, -0.04138502f, 0.02546898f, 
    0.04036273f, 0.05872202f, 0.07000086f, 0.01822788f, 0.15211475f, 0.06511074f, -0.00344144f, -0.09592009f, 
    -0.01993711f, 0.00339073f, -0.01774241f, 0.11659431f, 0.04587282f, 0.02188549f, -0.04891941f, -0.01213361f, 
    0.04913150f, 0.00473362f, 0.14093824f, 0.13630436f, -0.51657057f, 0.28254363f, -0.54630852f, 0.39171579f, 
    0.10075907f, -0.01004317f, 0.07873124f, -0.05971837f, 0.05718153f, 0.08403353f, 0.02970123f, 0.00915632f, 
    -0.10351898f, 0.04123519f, -0.11510251f, -0.18860182f, 0.03992561f, 0.03089507f, 0.04411761f, -0.05824921f, 
    -0.11657449f, 0.10037006f, -0.07182520f, -0.15250298f, -0.48579651f, 0.00754183f, -0.41988027f, -0.25777316f, 
    -0.03387631f, -0.13868070f, -0.04661137f, -0.03726079f, -0.09587584f, 0.10662974f, 0.03639704f, -0.04864825f, 
    -0.06106098f, 0.12674357f, -0.13341926f, -0.37326860f, 0.02716594f, -0.18488657f, 0.01756749f, -0.06278139f, 
    0.18114007f, -0.09945805f, -0.11458923f, -0.03984613f, -0.09488152f, -0.06206389f, -0.08598446f, 0.12535734f, 
    -0.02451132f, 0.04304615f, -0.07362945f, 0.03373610f, -0.01561214f, -0.13361432f, 0.16263832f, -0.19000457f, 
    -0.05558303f, 0.06955996f, -0.08644408f, 0.09469678f, -0.14538690f, 0.03627706f, -0.03845696f, 0.16309676f, 
    -0.16138074f, 0.00595358f, 0.23819396f, 0.03155960f, 0.05102081f, 0.08194530f, -0.03884052f, -0.21139920f, 
    0.00895254f, 0.13010366f, 0.10683061f, 0.03023818f, -0.01360248f, 0.04872872f, 0.11538932f, 0.06208927f, 
    -0.17421845f, -0.10428993f, -0.19077325f, 0.12376411f, -0.15403041f, -0.09184847f, 0.01374003f, -0.14837864f, 
    -0.00494701f, 0.04039649f, -0.00719118f, -0.00184754f, 0.37657133f, -0.13217349f, 0.37204668f, 0.14681804f, 
    -0.04920861f, -0.02387723f, -0.03235048f, 0.04177047f, -0.07399767f, -0.02135747f, 0.09467012f, -0.02559651f, 
    0.25598669f, 0.02006640f, 0.07907448f, 0.10007437f, 0.04498530f, -0.06296971f, -0.02042395f, 0.19037533f, 
    0.07599679f, 0.15313742f, 0.07410138f, 0.11320382f, -0.18677439f, -0.15578598f, 0.12484489f, 0.23639376f, 
    -0.04014454f, -0.00268843f, 0.02291650f, 0.04657023f, -0.13496087f, 0.03115384f, 0.10440401f, 0.00243479f, 
    0.49949387f, 0.01840099f, 0.44104674f, -0.18356401f, -0.09047173f, 0.18234096f, -0.09270259f, 0.11225297f, 
    -0.08239035f, 0.14740407f, 0.04248115f, 0.03060764f, -0.17403989f, -0.08021065f, -0.07730275f, -0.10727117f, 
    -0.15708402f, -0.24295880f, -0.11689102f, -0.27682063f, 0.02314145f, -0.07417610f, 0.03906544f, -0.01952723f, 
    0.12286343f, 0.15607581f, -0.02744462f, 0.20523430f, 0.00600467f, 0.08209759f, -0.04102221f, 0.00661258f, 
    -0.10054144f, -0.08354811f, -0.21062575f, -0.00068181f, 0.12624274f, -0.39828029f, 0.06348375f, 0.02313593f, 
    0.11444220f, 0.00170309f, 0.04886270f, 0.04032609f, 0.04521757f, 0.14858653f, 0.15352064f, 0.13200101f, 
    -0.25101548f, 0.15568718f, -0.37528166f, 0.15707429f, 0.11980441f, -0.23514737f, 0.27136460f, -0.13439947f, 
    0.09731069f, 0.08378267f, 0.14677548f, 0.07685316f, 0.15360910f, 0.00062338f, 0.10068613f, 0.08361188f, 
    -0.04453209f, -0.03753287f, 0.03866210f, 0.01650699f, -0.20082846f, 0.02552535f, -0.05114922f, -0.06435811f, 
    0.28779727f, -0.08301941f, 0.07498158f, 0.13586015f, -0.02037944f, 0.05973025f, -0.05801227f, 0.08356864f, 
    -0.05016587f, 0.05013802f, -0.14181246f, 0.10994672f, 0.20737909f, -0.08066700f, 0.34498462f, -0.11277714f, 
    0.00168664f, 0.02047015f, -0.16147426f, 0.21383619f, -0.08376808f, 0.19516416f, 0.17281355f, 0.03264140f, 
    -0.01694435f, -0.01297146f, 0.00952512f, -0.01377931f, -0.06231581f, 0.01936567f, 0.01931352f, 0.02771612f, 
    -0.31696969f, 0.07171386f, -0.00872877f, -0.07450334f, -0.35346371f, -0.13238101f, 0.08974816f, -0.02238814f, 
    -0.06509143f, 0.02251261f, 0.15464570f, 0.02763955f, 0.04773276f, 0.12492114f, 0.23345596f, 0.12758842f, 
    -0.30140385f, 0.08676947f, -0.37964910f, -0.01763917f, 0.01870951f, 0.00898304f, 0.01410383f, -0.06991886f, 
    -0.01138806f, 0.03764165f, 0.19514054f, 0.13916990f, -0.71923691f, -0.26097330f, -0.30759498f, -0.08583298f, 
    -0.13112670f, -0.22580297f, 0.01641356f, -0.08160178f, -0.00559196f, 0.00585784f, -0.01180292f, 0.12933554f, 
    0.08119228f, -0.12667134f, 0.03176536f, -0.21132408f, 0.11974279f, -0.09048537f, 0.12765670f, -0.04068412f, 
    -0.04681919f, 0.06753051f, 0.21866347f, 0.01677779f, 0.26730901f, -0.00537969f, 0.56605375f, 0.17593223f, 
    -0.06061745f, -0.16707383f, -0.17104284f, -0.03639875f, -0.08172035f, -0.02622557f, 0.01956729f, -0.03249332f, 
    0.02700074f, -0.33143577f, 0.08341711f, 0.07166974f, 0.17508538f, 0.02849137f, -0.01782881f, -0.03950574f, 
    0.03164289f, 0.04437563f, 0.16834825f, -0.02616625f, -0.05164938f, -0.00398430f, 0.03757978f, -0.02027019f, 
    0.00724407f, 0.00440768f, -0.08360580f, -0.05669282f, -0.03787417f, -0.00701438f, 0.05309710f, -0.08471268f, 
    -0.13556403f, -0.24141192f, 0.11665093f, 0.10556602f, -0.10645508f, -0.09332630f, -0.15914202f, -0.07014394f, 
    0.01275673f, -0.11664440f, -0.09106050f, 0.00351535f, 0.27776104f, -0.11109030f, 0.24820010f, 0.11691945f, 
    -0.02599488f, -0.06192818f, 0.10199620f, 0.11852189f, -0.08751398f, 0.07446566f, 0.07439949f, -0.13048069f, 
    -0.21292451f, -0.51713836f, 0.17069423f, 0.04841328f, -0.08214764f, 0.07180960f, 0.05442673f, 0.15956558f, 
    -0.08985934f, 0.16424260f, 0.09469921f, -0.04680494f, 0.15661459f, -0.01800698f, 0.10511550f, -0.01263033f, 
    0.09378499f, -0.00334951f, 0.03986142f, -0.01689446f, 0.00729687f, 0.13235983f, 0.14985715f, 0.15454723f, 
    0.04014403f, 0.02759884f, -0.09458704f, 0.26035103f, 0.05108281f, -0.06799820f, -0.06447496f, -0.12887751f, 
    0.02549016f, 0.00132316f, 0.02144340f, -0.03960812f, -0.26761097f, 0.15455244f, -0.23210490f, -0.00103724f, 
    -0.05172935f, 0.00509238f, 0.14725320f, -0.18175130f, -0.04629286f, 0.02869183f, 0.13409458f, 0.00899665f, 
    0.10980558f, 0.28523880f, -0.09462531f, -0.05071423f, -0.12095271f, -0.28208661f, -0.00898150f, 0.01549355f, 
    -0.06381753f, 0.01247015f, -0.05800150f, -0.05594222f, -0.14622541f, 0.40774846f, -0.34038275f, 0.34444454f, 
    0.23597267f, -0.01748434f, 0.09458793f, 0.06910862f, -0.03070254f, 0.03099570f, -0.06912248f, 0.00325331f, 
    -0.26196036f, -0.01780424f, -0.18358490f, 0.00434794f, -0.18558592f, 0.05052995f, 0.01211301f, 0.15292950f, 
    -0.22731704f, 0.07231917f, -0.12054203f, -0.26417181f, -0.17205945f, -0.07641976f, -0.12383561f, -0.10058054f, 
    0.10333678f, 0.05304331f, 0.00126827f, -0.07352141f, 0.00003917f, 0.03464069f, 0.08412392f, -0.08953865f, 
    -0.11460479f, 0.03374128f, -0.34546137f, 0.12481406f, 0.11934739f, -0.07900291f, 0.10590195f, -0.12986101f, 
    0.00712520f, -0.00026055f, -0.06442141f, -0.07299255f, 0.09200533f, 0.10745268f, 0.04875826f, -0.08269871f, 
    -0.00403343f, -0.06121524f, 0.08540951f, 0.00573354f, 0.01264971f, -0.06739496f, -0.07496243f, -0.01301785f, 
    -0.52506936f, -0.20986846f, -0.38968620f, 0.13370208f, 0.02213267f, -0.05812559f, 0.08710364f, -0.02170558f, 
    -0.09439409f, 0.04468671f, -0.00087117f, -0.07527049f, -0.02756863f, -0.08743975f, 0.02710078f, 0.02760689f, 
    -0.16578190f, -0.09781382f, 0.03147769f, -0.06707570f, -0.04597883f, 0.04194583f, 0.04741155f, -0.18297954f, 
    -0.19513716f, -0.45702100f, 0.21803683f, -0.24237141f, 0.05527024f, -0.00962772f, 0.10949028f, -0.01373564f, 
    0.02678920f, 0.15697783f, -0.02713824f, -0.12781543f, 0.01385399f, -0.46214968f, 0.16177189f, 0.09455593f, 
    -0.03320135f, 0.08959447f, -0.12228977f, -0.08443493f, 0.00149202f, 0.01308092f, 0.03036780f, -0.21902652f, 
    0.09354215f, 0.01486657f, -0.11557452f, 0.12961441f, 0.10159729f, 0.14076021f, 0.02910139f, -0.08720668f, 
    -0.18268596f, 0.12677914f, 0.04225358f, -0.06704616f, -0.13760304f, -0.14076410f, 0.07545107f, 0.04092040f, 
    0.11770357f, 0.06668255f, 0.03210711f, -0.08582278f, 0.09361593f, -0.10489485f, 0.03506431f, -0.02477062f, 
    -0.44775802f, 0.46934727f, -0.06398317f, 0.02478755f, -0.09927762f, -0.08102505f, 0.05542871f, 0.06970948f, 
    -0.04116157f, -0.02104833f, 0.03528871f, 0.10208022f, -0.40775388f, 0.08984070f, -0.11643833f, 0.10547222f, 
    -0.03113072f, 0.01908699f, 0.00144164f, 0.08163834f, -0.20486115f, -0.06019873f, 0.08794951f, 0.10264665f, 
    0.13105315f, 0.02697658f, 0.09497273f, -0.40725508f, -0.07252248f, -0.02096530f, -0.00380150f, -0.04575713f, 
    -0.01433614f, 0.01540460f, 0.05602015f, -0.14358041f, 0.11962958f, 0.04076941f, 0.12573254f, -0.03533057f, 
    -0.13852042f, 0.10742013f, 0.00167013f, 0.06562810f, -0.16414739f, -0.07162427f, 0.14145280f, 0.11959241f, 
    0.15295100f, 0.27583152f, 0.13067739f, -0.03659053f, -0.05861839f, -0.21741596f, -0.14693576f, 0.20080248f, 
    -0.07958993f, -0.09459230f, 0.12135337f, -0.05258051f, 0.05065236f, -0.12127088f, 0.41113237f, -0.16004327f, 
    0.07051046f, 0.13237812f, 0.04022474f, -0.04795231f, 0.05305526f, -0.03330518f, 0.16001929f, 0.04591259f, 
    -0.09338531f, -0.39967489f, -0.14234407f, 0.04317890f, -0.08909734f, -0.06530549f, -0.01143164f, -0.18028833f, 
    0.03096830f, 0.06822509f, 0.15669192f, 0.02186332f, -0.04201814f, -0.03697427f, -0.07908122f, -0.08749929f, 
    -0.27467173f, -0.16310909f, 0.02783778f, -0.28949547f, 0.01746820f, 0.01803208f, -0.04226844f, -0.05389508f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.15780295f, 0.09718479f, 0.09669438f, -0.09324986f, -0.08530001f, 0.03917331f, 0.06243857f, -0.13308150f, 
    0.06574001f, 0.05739013f, 0.03244638f, -0.04244146f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
