#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.02702916f, 1.11406267f, 0.17465042f, -0.00986769f, 1.32027841f, -0.28706402f, -1.17168462f, -0.30402884f, 
    -0.78081208f, 0.19465581f, 0.64939505f, 0.65861499f, -0.02048826f, 0.29607153f, 0.20611128f, 0.64975876f, 
    0.14495771f, -0.18327180f, 0.49957353f, 0.58623588f, 0.61291212f, -0.16388421f, -0.35512599f, -0.11885369f, 
    -0.07250371f, -0.75408196f, -0.83464354f, -1.08383358f, -0.39319563f, -0.31097808f, 0.65023851f, 1.65105903f, 
    0.26415855f, 0.93110645f, 0.98823220f, 0.08327954f, -0.29220623f, -0.39569578f, -0.87478113f, -0.44485259f, 
    0.12509100f, -0.10593754f, -0.08951148f, -0.11993664f, -0.11454962f, -0.09029271f, -0.32551897f, -0.02786873f, 
    0.02368249f, 0.26623145f, -1.46638155f, 0.17868663f, 1.33675599f, 0.53264868f, -1.00787199f, 0.98406279f, 
    0.03737087f, -0.03652543f, -0.24336688f, -0.21771745f, -0.02688486f, 0.28208461f, -0.16858889f, 0.04331158f, 
    0.20778500f, -0.25658494f, 0.09881069f, 0.07272144f, -0.08684403f, -0.04745167f, 0.05847140f, -0.36317027f, 
    -0.40696201f, -0.11011785f, -0.46342924f, -1.52852368f, 1.21303761f, 0.98788047f, 0.12718709f, 0.86523002f, 
    0.91586971f, -0.48775268f, -0.87347847f, 0.13519688f, -0.93796897f, 0.21599878f, -0.42471507f, -0.02376134f, 
    0.07301037f, -0.51712310f, 0.31018484f, 0.21186854f, 0.02443431f, -0.23046291f, 0.11221474f, -0.15876146f, 
    0.37274972f, 0.17892016f, 0.22692318f, 0.03822054f, -0.51375836f, 1.13703191f, 0.89811587f, -0.27780813f, 
    -0.25980166f, -1.24604976f, 0.69631493f, -0.45145637f, -0.65338159f, -0.58822578f, 0.05046638f, 0.23681940f, 
    -0.76933759f, -0.79548734f, -0.24982610f, 0.29613900f, -0.51033801f, 0.00749927f, -0.44526061f, 0.09082241f, 
    -0.20751362f, 0.00374371f, 0.26841176f, 0.19959839f, -0.08049037f, 1.40300715f, 0.14429091f, 0.65142339f, 
    1.98677397f, 1.12242568f, -0.55559576f, 0.33483815f, -0.09961256f, 0.25181848f, 0.47418866f, 0.12839924f, 
    -0.07248716f, -0.13143760f, 0.23876797f, -0.19891970f, -0.32121944f, -0.19376338f, -0.08264233f, 0.18376014f, 
    -0.25745657f, 0.35546756f, 0.20883761f, -0.12994646f, 0.11227202f, -0.15301764f, -0.22397752f, -1.22059226f, 
    -0.82868528f, -0.60102940f, -0.76783174f, 0.60475022f, -0.67007756f, 0.52886397f, 0.75270438f, -0.35849729f, 
    0.50285560f, 0.04614442f, -0.21330312f, 0.41396317f, 0.56422448f, 0.00362093f, -0.09092892f, 0.24966507f, 
    0.05925949f, 0.19755456f, -0.01803983f, -0.30626184f, -0.22499609f, -0.32960829f, -0.07871256f, -0.09462395f, 
    -1.40398419f, -1.09627521f, 0.02944723f, 0.39928415f, -0.99828714f, -1.18178010f, -0.63817227f, -0.46832433f, 
    0.38503665f, -0.06021397f, 0.72168142f, 0.14660783f, -0.08392842f, -0.38570958f, -0.02104139f, -0.44705716f, 
    -0.16351919f, -0.44517171f, -0.38732168f, -0.14309481f, -0.13884263f, 0.08429085f, 0.05876662f, -0.42260647f, 
    1.11777353f, 1.04313636f, -0.52836442f, -0.05232083f, 0.97907829f, 0.90981930f, -0.32225090f, 0.22985965f, 
    0.81330401f, 0.44025880f, -0.49493536f, -0.01209039f, -0.10971250f, 0.03065720f, 0.61681712f, -0.62554282f, 
    -0.12880826f, -0.64212859f, -0.17291878f, -0.09236174f, -0.60533977f, 0.25811628f, -0.52688503f, 0.00008572f, 
    -0.12971283f, -1.12676370f, 1.48691690f, 0.31680438f, -1.02929235f, 0.17711852f, -1.15716767f, 0.21732861f, 
    -0.09408288f, -0.78563857f, -0.41003513f, 0.10975740f, 0.40477058f, 0.29992262f, 0.53717077f, 0.46980900f, 
    0.11522588f, -0.07687984f, -0.21455067f, -0.02056381f, -0.48828667f, 0.14181991f, 0.10934602f, 0.11962127f, 
    0.38705796f, 0.27700529f, 0.03361527f, -1.07234633f, -0.30219269f, 1.61360502f, 0.38836762f, -1.34048402f, 
    -0.53592235f, 0.35289037f, -1.19667387f, -0.34447318f, -0.02978982f, 0.12921053f, -0.00846272f, 0.26122433f, 
    0.28795946f, 0.13528208f, 0.31954265f, 0.24810094f, -0.30357742f, 0.20943530f, -0.19366717f, 0.15639621f, 
    -0.00925495f, 0.36120051f, -0.06046962f, 0.96274960f, 0.01225218f, 1.50905502f, -0.23306732f, -1.31292892f, 
    0.03694387f, -1.27982235f, 0.34126785f, 0.26395682f, 0.28292030f, 0.90950054f, 0.40524331f, 0.06459083f, 
    0.05777892f, -0.23799993f, -0.17770235f, -0.08667945f, -0.08339638f, -0.17227253f, -0.10116136f, 0.45269156f, 
    0.34057057f, 0.18893398f, 0.10590191f, 0.09638917f, -1.62641835f, -1.35481632f, -0.13211910f, 0.07313844f, 
    -0.41832867f, 0.34364361f, 0.20825446f, -0.34635019f, 0.04371260f, -0.01434291f, 0.35759917f, 0.60884964f, 
    -0.46274069f, 0.50341344f, 0.17478552f, 0.38203424f, 0.37505662f, 0.11738619f, -0.05234903f, -0.19571306f, 
    0.06941306f, -0.03775568f, 0.78974485f, 0.15783060f, -0.20511758f, -0.88595253f, -1.68439686f, -0.52190894f, 
    -0.17265487f, -0.53383756f, 0.13500129f, -0.27066198f, 0.01023443f, -0.28704363f, -0.31099698f, -0.44127327f, 
    -0.50831652f, -0.20955318f, -0.32167041f, -0.39788413f, -0.30012935f, 0.34262928f, -0.35222518f, -0.27990562f, 
    0.20446181f, -0.24250749f, 0.59241760f, 0.34061411f, 0.43083116f, 0.01981140f, 1.95567095f, 0.65383285f, 
    -0.02870160f, 1.02706409f, -0.36780271f, 0.69646251f, 0.51325619f, 0.01103735f, 0.30746585f, 0.22226635f, 
    0.23921138f, 0.36952099f, -0.20165370f, -0.07042712f, 0.13169344f, 0.30918092f, -0.36621600f, 0.43738165f, 
    -0.31535801f, 0.39234787f, -0.09522433f, 0.28333104f, 0.12490658f, 0.04022513f, 0.22240366f, 1.59788024f, 
    1.10077608f, 0.90210211f, -0.58990657f, -0.25576586f, -0.50031191f, 0.31349596f, -0.70787841f, 0.54553235f, 
    0.67589140f, -0.27177155f, -0.06017032f, -0.25816146f, -0.41816145f, -0.26667571f, 0.14672723f, -0.01580095f, 
    -0.40875459f, -0.03023161f, -0.33001190f, -0.24187453f, 0.10272502f, 0.23209180f, -0.14277561f, -0.18385361f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25272819f, 0.24292152f, 0.08991481f, -0.08130460f, 0.00091501f, 0.22705609f, 0.47300458f, 0.66302425f, 
    0.15908419f, 0.32653385f, 0.17410989f, 0.37293419f, 0.57404113f, 0.23935680f, 0.49276829f, 0.35812116f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.56517440f, -0.05104451f, 0.40809429f, -0.26720640f, -0.22031464f, 0.21552925f, 0.04742827f, 0.04990606f, 
    0.20126061f, -0.17483336f, 0.08924564f, 0.02120668f, 0.49335027f, 0.47241253f, 0.16966413f, -0.32792917f, 
    0.04553410f, 0.09735872f, 0.05935022f, -0.10087982f, -0.07137695f, 0.17114995f, -0.06464732f, 0.11667194f, 
    -0.33721745f, 0.19983606f, 0.08818487f, 0.53761595f, -0.25177842f, -0.03646772f, 0.36418802f, -0.26852211f, 
    0.01088919f, 0.20580608f, 0.11842857f, -0.08051267f, -0.47938639f, 0.05032986f, 0.05466506f, -0.27214247f, 
    -0.27142519f, -0.11184239f, 0.08934139f, -0.07647323f, 0.14787269f, -0.11806450f, 0.17463416f, 0.07742382f, 
    -0.21411265f, 0.03541190f, 0.36608988f, -0.14185309f, -0.03883811f, -0.09342579f, -0.05860166f, -0.03115767f, 
    0.04049397f, -0.07679048f, 0.13660599f, -0.24199396f, 0.47973016f, -0.09087653f, -0.18797651f, 0.83751810f, 
    -0.11766510f, -0.13113998f, -0.03819386f, -0.05955771f, -0.17617019f, -0.07071616f, 0.14706433f, -0.10158624f, 
    0.33521366f, -0.32415536f, -0.37128323f, -0.26727512f, 0.07796125f, -0.04102955f, -0.05647686f, -0.07666898f, 
    0.01909807f, -0.26780176f, 0.01048128f, 0.07238272f, -0.05854987f, -0.73220253f, 0.40049681f, 0.13957538f, 
    -0.23943783f, -0.25225440f, 0.06309076f, 0.20026979f, -0.24023609f, -0.04415201f, -0.11046252f, -0.09048737f, 
    0.54049128f, -0.42104918f, 0.24088897f, -0.04016884f, -0.23905160f, -0.10184094f, 0.14691310f, 0.15567958f, 
    -0.06879603f, 0.07972175f, 0.12581915f, -0.05283895f, -0.68845403f, 0.06337917f, 0.08643164f, -0.14886318f, 
    -0.06115543f, 0.13461785f, 0.11853275f, 0.06010494f, -0.23087136f, -0.03661796f, -0.08344147f, -0.08466399f, 
    0.26828015f, -0.16093603f, -0.46193385f, 0.63645422f, 0.15847450f, 0.03453285f, -0.16687666f, -0.23535311f, 
    0.05093479f, -0.21985243f, -0.02962565f, -0.18375023f, -0.00141267f, -0.15287040f, -0.28955993f, 0.25377101f, 
    -0.12553850f, 0.04970807f, 0.08163962f, -0.46733877f, -0.05489169f, 0.02950882f, -0.17534246f, -0.00922763f, 
    -0.54878753f, -0.04082601f, 0.13703001f, 0.10416702f, 0.02571923f, 0.13255984f, -0.15037341f, 0.18751669f, 
    0.21033807f, 0.02504123f, 0.00256573f, -0.23984091f, -0.41339940f, -0.08301508f, -0.17382602f, -0.22877674f, 
    0.13442685f, 0.05634042f, 0.07213046f, 0.02207159f, -0.10524392f, -0.07602137f, 0.02669200f, -0.08787616f, 
    0.36579862f, -0.04719368f, -0.47277033f, 0.24665171f, -0.56454289f, -0.02872776f, -0.45546481f, 0.16330226f, 
    -0.04147127f, 0.02164819f, -0.22386745f, -0.15636081f, 0.00125623f, 0.20375074f, -0.02967181f, -0.26360926f, 
    0.03896195f, -0.42578870f, -0.09672362f, 0.19435965f, 0.01889555f, 0.05927548f, 0.05042174f, -0.20753874f, 
    0.01794814f, -0.04972846f, 0.07066132f, -0.05568397f, -0.03570571f, -0.07802934f, -0.01608843f, 0.02313833f, 
    -0.16558419f, 0.17561780f, -0.18632133f, 0.17670329f, 0.35760751f, -0.29604363f, -0.05337059f, -0.08165337f, 
    0.19857822f, -0.05118021f, -0.16147530f, 0.07691531f, 0.11835706f, -0.07557385f, -0.06116286f, -0.07819191f, 
    -0.36722499f, 0.03984392f, -0.10626926f, 0.20618396f, 0.06669604f, 0.03526708f, -0.10541081f, -0.34082589f, 
    -0.13015056f, -0.14983712f, -0.09273054f, 0.02896133f, 0.20976153f, 0.10335802f, -0.12827002f, -0.14582323f, 
    0.04714109f, 0.22254537f, 0.07150263f, -0.14424556f, 0.00827220f, 0.09617730f, 0.07533974f, -0.16406082f, 
    -0.30990291f, 0.24722563f, -0.84298974f, -0.31606513f, -0.10315633f, 0.25836062f, 0.02905494f, -0.06701563f, 
    -0.08589749f, -0.12915793f, 0.01824689f, -0.05758989f, 0.35056686f, -0.06193051f, 0.27940157f, 0.42504779f, 
    -0.34079143f, 0.18574537f, 0.03405961f, 0.06226007f, 0.26261732f, -0.03821268f, -0.20186654f, -0.02541238f, 
    -0.17950857f, 0.18428636f, 0.01238619f, -0.12773363f, 0.07612902f, 0.21728815f, -0.04554564f, 0.14201304f, 
    -0.10866725f, 0.15963463f, 0.01590837f, -0.00608054f, 0.08910067f, -0.12804115f, -0.07834577f, -0.12175759f, 
    -0.07235590f, -0.06323227f, -0.07781623f, 0.11021652f, -0.03948531f, -0.25641766f, -0.04591212f, -0.11186681f, 
    0.02057843f, -0.02704955f, -0.03751643f, 0.11745955f, 0.05429058f, -0.12530392f, -0.04731834f, -0.00080092f, 
    -0.05184832f, -0.09708262f, -0.07419920f, -0.06345699f, -0.55511963f, 0.31465673f, -0.16394614f, -0.54033589f, 
    0.03595653f, -0.06221988f, 0.02757242f, 0.16303550f, 0.18592346f, 0.18257113f, -0.08392180f, -0.02145205f, 
    -0.92079389f, -0.23252238f, -0.18241259f, 0.16372454f, -0.09409525f, -0.09907296f, -0.14319779f, 0.20697437f, 
    0.12947440f, 0.11308467f, 0.18855023f, 0.15175813f, -0.61482888f, 0.25288901f, -0.18018448f, -0.11058896f, 
    -0.04645468f, -0.08705512f, 0.00054808f, 0.20146161f, 0.12616412f, 0.01877478f, 0.13521419f, -0.14129047f, 
    0.00677077f, 0.09021500f, -0.63039547f, 0.03666235f, 0.01561575f, -0.12478002f, -0.08680023f, -0.01175657f, 
    -0.07420789f, -0.09617066f, -0.13136235f, 0.28160053f, 0.15702111f, 0.11261155f, -0.16701077f, 0.08509435f, 
    0.07615198f, -0.36151594f, -0.08381880f, 0.03221208f, 0.19933060f, 0.14567339f, -0.19700180f, -0.05318678f, 
    0.63342404f, -0.15423062f, 0.45908976f, 0.25283906f, -0.20531319f, -0.24937236f, 0.02819037f, -0.01792447f, 
    -0.11790791f, 0.07437195f, -0.16774572f, 0.29336044f, 0.55370200f, 0.05404398f, -0.05395786f, 0.22985403f, 
    0.06642886f, -0.09527987f, 0.11570792f, 0.01225310f, -0.13294098f, -0.23848894f, -0.16630115f, 0.00457457f, 
    -0.13104504f, -0.08512803f, 0.00836903f, -0.02677727f, 0.16434459f, 0.00509361f, 0.21577571f, -0.34585315f, 
    -0.20032191f, -0.14062370f, 0.06603950f, -0.16122751f, 0.58743924f, 0.06686623f, 0.32354110f, 0.37908742f, 
    -0.23901330f, -0.23580445f, 0.13857044f, 0.42689666f, 0.03084648f, 0.25615421f, 0.03103072f, -0.05522621f, 
    0.44831476f, 0.12847000f, -0.13504405f, -0.21396849f, -0.10740978f, 0.05897754f, -0.03652171f, 0.09648468f, 
    -0.22856915f, 0.07223269f, 0.02887278f, -0.16469884f, 0.57925570f, -0.03584413f, -0.16656908f, 0.14488731f, 
    -0.08102207f, -0.06333391f, -0.10077985f, -0.19209902f, -0.13894519f, -0.31191310f, 0.03978615f, -0.18106769f, 
    0.38360947f, 0.14357470f, -0.69272274f, -0.19127536f, 0.04371726f, -0.01822936f, -0.07471170f, 0.04706115f, 
    -0.00354539f, -0.12856944f, 0.08456665f, -0.13430017f, -0.14822432f, 0.29192618f, -0.16377224f, 0.12713982f, 
    0.27830410f, 0.13309911f, -0.09332950f, -0.16531736f, -0.08883262f, 0.14097360f, 0.08611324f, 0.07043318f, 
    -0.20272925f, 0.33699226f, 0.29752746f, 0.23757328f, -0.28495023f, -0.05761757f, 0.07466993f, -0.00503613f, 
    0.02153048f, -0.13696322f, -0.02096133f, -0.18380998f, 0.15957348f, -0.55618250f, 0.29692990f, -0.47746164f, 
    -0.15431100f, 0.14170860f, -0.11477578f, -0.08899292f, 0.03910236f, -0.06997979f, -0.04110020f, -0.11548784f, 
    0.06356633f, -0.02231581f, 0.04998888f, -0.16507420f, 0.08251641f, -0.08981060f, 0.18485244f, -0.12877887f, 
    0.05851837f, -0.15105923f, 0.10020375f, -0.01492110f, 0.13443789f, -0.06276231f, -0.95670760f, -0.58383828f, 
    0.36039287f, 0.14624187f, -0.06309915f, -0.13818537f, -0.20935152f, 0.08475088f, -0.09971212f, -0.10849246f, 
    0.99289930f, -0.25075430f, -0.41601503f, -0.06166104f, 0.04213411f, 0.20632820f, 0.00343438f, 0.09711497f, 
    -0.04628449f, -0.04201499f, 0.17112461f, -0.29084444f, -0.97502178f, 0.12143553f, 0.15691777f, -0.18490091f, 
    -0.19208103f, 0.24504435f, -0.11792904f, -0.15654096f, -0.04593986f, 0.00071514f, -0.05605009f, -0.02472081f, 
    0.82242966f, -0.09828769f, 0.19247155f, -0.22653930f, -0.32045415f, -0.10214393f, -0.43699449f, 0.09076989f, 
    0.04338503f, -0.15549479f, -0.07929254f, -0.07368738f, -0.34455103f, -0.36180615f, 0.00216964f, -0.33231771f, 
    -0.35179901f, 0.00457025f, -0.35493791f, -0.24882163f, 0.13897893f, 0.02754711f, 0.16681615f, -0.01498359f, 
    0.36381274f, 0.16884717f, -0.00877063f, -0.29673555f, -0.05936091f, -0.06555622f, 0.00382294f, 0.20504217f, 
    -0.03972723f, 0.08769556f, 0.14551489f, -0.19427104f, 0.10041787f, 0.09083009f, 0.11451636f, -0.43091151f, 
    -0.00990790f, 0.04109634f, 0.09665285f, 0.04718481f, -0.06927491f, 0.07547560f, 0.04090649f, -0.20396787f, 
    -0.08353150f, -0.50589436f, -0.22961044f, 0.61450130f, 0.05684398f, 0.17347087f, 0.11182244f, 0.01456248f, 
    0.06324293f, -0.07848874f, -0.02881235f, -0.10216078f, -0.35765019f, 0.23083287f, -0.25072968f, -0.25971907f, 
    -0.08616353f, -0.11562102f, -0.03625796f, -0.06638985f, -0.21372010f, -0.13576311f, 0.15955701f, -0.09333123f, 
    -0.05231990f, 0.33096179f, 0.15806237f, 0.07146507f, 0.08377849f, -0.09205677f, 0.02916100f, 0.29619628f, 
    0.07724033f, 0.08678507f, 0.09091555f, 0.12006817f, 1.04807854f, 0.04828938f, 0.01747142f, 0.22047675f, 
    0.27811158f, -0.13066947f, -0.19295307f, 0.11648241f, -0.04558949f, -0.01908616f, 0.07093659f, -0.23081252f, 
    -0.59635848f, 0.48992768f, 0.17905518f, 0.00531887f, 0.12362643f, 0.12657976f, 0.07783053f, 0.16009733f, 
    0.00421545f, 0.09009554f, 0.16495889f, 0.04904657f, -1.06167769f, -0.40413389f, -0.03413699f, 0.03814782f, 
    -0.11750356f, -0.06068609f, 0.13181168f, -0.19468655f, 0.02199520f, -0.03080284f, 0.01769650f, -0.08329395f, 
    0.26262984f, -0.14232445f, -0.10994472f, -0.21344055f, 0.06176293f, -0.00944839f, -0.26416561f, 0.04566444f, 
    0.12974618f, 0.00428283f, -0.01644256f, 0.08863818f, 0.41561192f, 0.46771291f, -0.10272518f, 0.36311153f, 
    -0.03223845f, 0.19127898f, -0.22737193f, 0.01856069f, 0.14549448f, 0.24877734f, -0.03252303f, 0.03278533f, 
    -0.17792937f, -0.08572112f, -0.18198568f, -0.17434022f, -0.28259811f, -0.15371415f, 0.02470269f, -0.12749264f, 
    0.08056146f, -0.00155026f, 0.18791415f, -0.08847138f, 0.04351015f, 0.22391666f, 0.34024346f, -0.16217485f, 
    0.09989966f, -0.09431648f, 0.16682087f, 0.09607776f, -0.12350996f, 0.10285448f, 0.19884944f, 0.08146089f, 
    0.15307024f, -0.12293252f, 0.55403209f, 0.23792532f, 0.30107599f, 0.12712097f, 0.16242987f, -0.12597941f, 
    0.07395271f, -0.13884014f, -0.07886784f, -0.13743620f, 0.01855285f, -0.63481975f, -0.27369621f, 0.17281961f, 
    -0.05364307f, 0.03397807f, 0.09313048f, -0.11260927f, -0.13756786f, -0.07515813f, -0.19017883f, -0.01173256f, 
    0.01660869f, 0.22777417f, -0.01031058f, -0.34276310f, -0.22882450f, -0.39007244f, -0.31234634f, -0.12766263f, 
    -0.00047388f, 0.03885983f, 0.11515220f, -0.00852402f, 0.50766116f, -0.10445581f, -0.14863344f, 0.10339320f, 
    -0.39533326f, -0.23610917f, -0.12751324f, 0.23025404f, -0.03565631f, -0.23883273f, 0.03317323f, -0.05768032f, 
    -0.22356661f, -0.72096777f, -0.67842090f, -0.22415698f, -0.32434443f, -0.18606667f, -0.19975811f, 0.07421181f, 
    -0.00457525f, -0.11232407f, -0.01802588f, -0.20528784f, -0.62001771f, -0.24577565f, -0.53203976f, -0.03191483f, 
    -0.19263878f, 0.10895351f, 0.10745544f, 0.05111217f, -0.04161756f, 0.05103429f, 0.05090632f, 0.11173279f, 
    -0.29392430f, -0.61018777f, -0.19163226f, 0.25000563f, -0.39310908f, -0.11891706f, 0.00179197f, -0.37482113f, 
    0.21027616f, -0.04352598f, -0.09962840f, -0.17978334f, -0.81627721f, -0.05886419f, 0.13770762f, 0.42855802f, 
    0.12137469f, -0.02126536f, -0.05317253f, 0.07382255f, -0.14406379f, 0.02633866f, 0.29556665f, -0.01183291f, 
    0.16761374f, 0.16112609f, -0.24056335f, -0.88893682f, 0.06397583f, 0.08914710f, 0.05192051f, 0.26483852f, 
    -0.10855606f, 0.12825969f, -0.10325897f, 0.01300554f, 0.06192312f, 0.67209244f, 0.10020472f, -0.35304427f, 
    -0.02797174f, 0.08207779f, -0.25683001f, 0.04294259f, 0.11094592f, -0.12557968f, 0.03612505f, 0.10450587f, 
    -0.10856605f, 0.04102910f, 0.49494296f, 0.03530219f, -0.11116352f, 0.02541012f, 0.13558175f, -0.10283291f, 
    -0.01687391f, -0.02512579f, -0.22861785f, -0.00873026f, 0.07108781f, 0.11431833f, 0.25538018f, 0.20231688f, 
    -0.05545789f, 0.13480552f, 0.12272079f, 0.00409204f, 0.07761589f, 0.07490666f, 0.00896848f, -0.12800710f, 
    -0.11541627f, 0.17803279f, 0.01634143f, 0.28575033f, 0.06807882f, -0.06025508f, -0.04609940f, 0.00332468f, 
    0.09442513f, -0.14817823f, -0.05130559f, 0.00124729f, -0.06925268f, -0.15735464f, 0.06264971f, 0.34000409f, 
    0.09666122f, 0.04533162f, 0.12384640f, -0.12981948f, -0.04325824f, 0.17192614f, 0.02370551f, -0.01993952f, 
    0.38565543f, -0.42104375f, -0.18833439f, 0.18604602f, -0.11379129f, 0.06432591f, -0.04060007f, 0.13428098f, 
    -0.05976454f, -0.02250713f, 0.00333906f, 0.27390784f, 0.29993731f, -0.09494585f, 0.25446901f, 0.24871513f, 
    -0.22366175f, -0.27397835f, 0.25788784f, -0.09642721f, 0.07232079f, -0.12951036f, -0.01280082f, 0.06623903f, 
    -0.53236967f, -0.20689718f, 0.27176589f, 0.19922160f, -0.13732173f, 0.04087679f, -0.15531611f, -0.14522094f, 
    -0.03000443f, -0.01893791f, -0.19257714f, 0.00497835f, -0.13599469f, -0.55214852f, 0.10443668f, -0.25073123f, 
    -0.12684052f, 0.07254141f, -0.23123471f, -0.24300031f, 0.12383268f, 0.00669034f, 0.01613090f, 0.05123867f, 
    -0.00245264f, 0.11823464f, 0.06994060f, -0.19449884f, 0.17728281f, 0.02805280f, -0.07350185f, 0.16555905f, 
    0.13891420f, -0.08001857f, -0.23150808f, 0.10215590f, -0.33433515f, -0.19086236f, -0.19575725f, -0.09145260f, 
    0.17592938f, 0.33177799f, 0.02519853f, 0.06737019f, -0.18757656f, -0.11100500f, 0.14350839f, 0.12958993f, 
    -0.16464676f, 0.04336622f, 0.12778309f, -0.07756756f, -0.06652747f, 0.06015796f, -0.01815865f, 0.00210474f, 
    0.09935796f, -0.09458531f, 0.05319442f, -0.14497913f, -0.45557961f, -0.09199367f, 0.21909635f, -0.05107375f, 
    -0.22170126f, 0.06358115f, 0.02892700f, 0.07625803f, 0.04061092f, 0.16414079f, 0.16072455f, 0.06790130f, 
    -0.05851547f, 0.10379977f, 0.05709316f, 0.12608060f, -0.18017583f, -0.11043084f, 0.01746873f, 0.16148327f, 
    -0.26714489f, 0.06316038f, 0.07302148f, 0.41399178f, -0.00104744f, 0.35935557f, -0.28299335f, -0.33378625f, 
    0.09398334f, 0.11997610f, -0.02264044f, -0.25472021f, 0.09064230f, -0.13697514f, -0.24930647f, -0.02476593f, 
    -0.62759471f, -0.44466367f, 0.09364384f, -0.14251468f, 0.05093608f, 0.09040343f, -0.30061707f, 0.04556571f, 
    0.01849022f, -0.03653182f, -0.00796684f, -0.23524737f, -0.37780502f, -0.43751943f, 0.60263968f, 0.38922241f, 
    -0.14821731f, 0.01942530f, 0.23187409f, -0.17948264f, -0.08644310f, 0.10030381f, -0.24745911f, 0.25018740f, 
    -0.13145299f, 0.00015831f, 0.03377476f, 0.34410974f, -0.18519355f, -0.15753542f, -0.04916402f, 0.08116330f, 
    0.12981986f, 0.20202337f, -0.24129759f, 0.11549767f, -0.20696682f, 0.20643400f, 0.17613193f, -0.51280516f, 
    0.10401064f, -0.09916511f, 0.01956813f, 0.09131815f, 0.08331720f, 0.00720718f, 0.11127723f, 0.00490874f, 
    -0.63320589f, -0.47798795f, -0.65590233f, 0.14557050f, 0.06913372f, -0.14691938f, -0.20745918f, -0.11815818f, 
    0.09912198f, 0.20503643f, -0.03356533f, 0.25611332f, -0.20556211f, -0.14734934f, -0.13856317f, 0.22646606f, 
    0.00405496f, -0.06309697f, -0.00974550f, -0.00910242f, 0.06865414f, -0.16888230f, 0.14463924f, 0.18529439f, 
    0.28785869f, 0.18294074f, 0.22700112f, -0.29440686f, -0.12009516f, -0.02057282f, -0.01104616f, -0.36486331f, 
    -0.35086554f, -0.11122873f, -0.18949315f, -0.24124923f, -0.06075446f, 0.02159321f, 0.21944736f, 0.48660725f, 
    -0.10229111f, -0.07480890f, 0.15547936f, 0.04661360f, -0.06129360f, -0.14032590f, 0.20578393f, 0.12340608f, 
    0.23883322f, -0.08151668f, -0.13531280f, -0.57347411f, -0.05870844f, -0.03905702f, -0.00445842f, 0.15995274f, 
    -0.05588087f, 0.05802102f, -0.04290380f, 0.26295224f, 0.00586966f, 0.09902782f, -0.00191844f, 0.39337745f, 
    -0.08694864f, -0.20373563f, 0.16675645f, 0.09275103f, 0.24340466f, -0.20419601f, -0.03648501f, 0.03636250f, 
    -0.74229556f, -0.13498917f, 0.13301572f, -0.12826297f, 0.23759559f, 0.00457198f, 0.17743300f, -0.06357853f, 
    0.15299183f, 0.16798474f, -0.06319469f, 0.15336503f, -0.09547814f, 0.07095713f, -0.24826130f, 0.14859354f, 
    0.04722085f, 0.26598909f, 0.44676736f, 0.05189161f, -0.01682125f, 0.18058389f, -0.09659687f, -0.31164548f, 
    0.01629055f, 0.14394678f, -0.10060310f, 0.02399873f, 0.24612342f, 0.06823863f, 0.12917368f, -0.04968650f, 
    -0.04772552f, 0.08734694f, 0.24897934f, -0.12807132f, 0.04675078f, -0.12525725f, -0.15235864f, -0.00831509f, 
    0.03113942f, -0.00512722f, 0.04087987f, -0.01354903f, 0.06297433f, -0.11708137f, -0.09935604f, -0.00669836f, 
    0.29131466f, 0.25061780f, 0.14873134f, -0.39870745f, 0.09413213f, 0.15504059f, -0.11583938f, 0.06737849f, 
    -0.02422876f, -0.23104869f, 0.12687205f, -0.42876408f, -0.19444902f, -0.53097212f, -0.11488874f, -0.00867232f, 
    -0.14447339f, -0.04312617f, 0.07470216f, 0.03293046f, 0.08381329f, 0.07648695f, 0.12492125f, 0.37178823f, 
    0.65612870f, -0.26893416f, 0.32212219f, 0.17029373f, 0.13618839f, -0.07011756f, -0.14107771f, 0.11537491f, 
    0.32958496f, -0.00697329f, 0.10489525f, -0.10337085f, 0.56379354f, -0.18593182f, -0.09838010f, -0.15938675f, 
    0.03690862f, -0.12028609f, 0.04311660f, 0.05518880f, 0.07767467f, 0.12528543f, -0.12402039f, 0.05184379f, 
    0.00983002f, -0.33447862f, -0.01344522f, -0.13030823f, 0.34129393f, 0.07380109f, 0.25215733f, 0.05928909f, 
    -0.02804398f, -0.03853135f, -0.00140767f, 0.08430435f, 0.46962762f, 0.24439600f, 0.12931839f, -0.90717858f, 
    -0.14517194f, 0.17629103f, 0.01661939f, 0.07224691f, -0.20848289f, 0.22502454f, 0.14686494f, 0.03215462f, 
    -0.40331772f, -0.27937314f, 0.16064911f, -0.05183161f, -0.05060743f, -0.04943618f, 0.11688644f, -0.13458969f, 
    -0.05249758f, -0.22669664f, 0.04150674f, 0.01797423f, 0.07888836f, 0.30637816f, -0.08344722f, -0.67670494f, 
    -0.13968162f, 0.16901547f, -0.01794833f, 0.01358923f, -0.00637051f, -0.18677551f, -0.13832243f, 0.02361708f, 
    -0.77101243f, 0.36932001f, -0.10656683f, 0.02955389f, -0.38041314f, -0.11480657f, 0.07255100f, 0.22674845f, 
    0.04431036f, 0.08004263f, 0.05453356f, 0.28798601f, -0.27949920f, -0.27015677f, -0.15659855f, 0.07769516f, 
    0.03084203f, -0.00063137f, -0.19360074f, -0.00587194f, -0.10947768f, 0.16838087f, -0.20451954f, -0.11023562f, 
    0.18084803f, 0.12874521f, 0.01820275f, -0.38202351f, 0.17921247f, 0.09933408f, 0.10145358f, -0.19286467f, 
    -0.03717946f, -0.05658912f, -0.04234945f, -0.20913376f, -0.62847805f, -0.08990110f, -0.25860304f, 0.37688935f, 
    0.23331535f, 0.08151830f, -0.13909104f, 0.16995071f, -0.29440263f, -0.12399880f, -0.05841289f, -0.18711095f, 
    0.00404604f, 0.06247721f, -0.06698412f, -0.09328090f, -0.12316485f, 0.15084480f, 0.04189542f, 0.11318699f, 
    -0.14677629f, 0.12551101f, 0.00766108f, -0.31800473f, 0.11342261f, -0.18067040f, 0.01592914f, -0.56025046f, 
    -0.22210059f, -0.15819146f, -0.01114566f, -0.15964691f, 0.13298853f, 0.08187236f, 0.07136596f, 0.37862539f, 
    -0.45528251f, 0.24879879f, -0.05952424f, 0.02431743f, -0.27534652f, 0.13746558f, -0.09424274f, 0.08316137f, 
    -0.02378698f, 0.01098828f, 0.00149081f, -0.07151088f, -0.75893331f, 0.13781202f, 0.22662169f, 0.42929557f, 
    0.18441676f, 0.04470086f, -0.04219228f, 0.07101350f, -0.11391298f, 0.03074863f, 0.29165781f, 0.08491155f, 
    -0.95815414f, 0.16939038f, -0.55744046f, -0.07743400f, 0.09391916f, -0.13182782f, 0.00425809f, -0.01746217f, 
    0.04067280f, -0.05789743f, 0.02776375f, -0.14966816f, -0.46745849f, 0.44448918f, 0.19435167f, -0.00897505f, 
    0.09132449f, -0.12942787f, 0.12526734f, -0.15828842f, 0.01053189f, 0.01813790f, 0.24977952f, -0.15016298f, 
    0.40676722f, 0.15586711f, -0.05166553f, 0.32902527f, 0.29836899f, 0.08123988f, 0.15904009f, -0.05564669f, 
    0.03161211f, 0.05366185f, -0.03284104f, -0.32111821f, -0.36468837f, 0.08748754f, 0.11905187f, -0.01939287f, 
    -0.06985071f, 0.03992866f, 0.02308563f, -0.13761215f, -0.11080066f, 0.05489524f, 0.08196674f, -0.24182878f, 
    0.41095001f, -0.58076239f, 0.50292146f, 0.25657079f, -0.07317503f, -0.15013312f, -0.09534460f, 0.03294882f, 
    -0.33880758f, 0.03301315f, 0.05751920f, -0.05676289f, -0.03439912f, -0.01951625f, -0.52875102f, -0.53872877f, 
    -0.00136672f, -0.00540052f, -0.05957020f, -0.19350640f, -0.08184952f, -0.13055196f, -0.06043470f, -0.29015151f, 
    0.01049047f, 0.31457427f, -0.01058980f, 0.29102784f, 0.00012816f, -0.01696602f, -0.11857563f, -0.12368776f, 
    0.04709584f, -0.11941408f, -0.16133089f, -0.19059497f, 0.00889730f, 0.07995949f, 0.21411110f, 0.05897863f, 
    -0.07827191f, -0.04010769f, -0.19779888f, -0.04459832f, -0.06675503f, 0.07333274f, -0.09926749f, -0.11796407f, 
    0.05021319f, 0.34083790f, -0.38220289f, -0.12250146f, 0.06955633f, 0.17373437f, -0.08732655f, -0.01741878f, 
    -0.11865489f, 0.05541182f, 0.08323209f, -0.24852355f, 0.45132208f, -0.32822961f, 0.27834246f, 0.36099029f, 
    0.11190360f, -0.15051594f, -0.22726329f, -0.15366733f, -0.07929219f, -0.10052957f, -0.08063693f, -0.03965404f, 
    0.63426620f, 0.02262513f, 0.03851052f, -0.14074990f, -0.23805615f, -0.13267858f, 0.03565694f, -0.10236204f, 
    0.03177555f, 0.13957177f, 0.00298164f, -0.26971447f, -0.11382782f, -0.04189877f, -0.27205607f, 0.01332243f, 
    -0.03419849f, -0.23308940f, -0.07447857f, -0.04748987f, -0.15975177f, -0.01905162f, 0.03196799f, -0.05882640f, 
    0.19198632f, 0.09441276f, 0.42570499f, 0.22204633f, 0.12960421f, 0.16987506f, -0.04501500f, -0.05324352f, 
    -0.15730123f, 0.14449812f, 0.09642287f, -0.10298403f, 0.02385478f, 0.23092817f, 0.19753218f, 0.49999809f, 
    0.19785711f, 0.03177813f, 0.12610170f, 0.09708246f, -0.18587658f, 0.09037621f, 0.04124222f, 0.03335596f, 
    -0.79630476f, 0.40280503f, 0.07135724f, -0.12251430f, -0.15262465f, -0.00761898f, 0.08489360f, -0.10319787f, 
    -0.05809712f, 0.00458138f, -0.07745772f, -0.16088213f, -0.24509200f, -0.49716932f, -0.40671265f, -0.15939608f, 
    -0.03285946f, -0.02746358f, -0.09624135f, -0.07307602f, -0.06766082f, -0.00004389f, -0.02738080f, -0.00511128f, 
    -0.07383675f, -0.12750258f, -0.21828617f, -0.14614169f, -0.10398084f, -0.10207272f, -0.11368237f, -0.03380594f, 
    0.03682838f, 0.20161979f, 0.16465995f, 0.12715958f, 0.17292701f, -0.01675729f, 0.20083977f, 0.36546597f, 
    -0.38269219f, 0.21341796f, -0.07805502f, -0.26503244f, -0.04210325f, -0.30666313f, -0.40559646f, -0.07155097f, 
    0.24486677f, -0.30686381f, -0.00273447f, -0.15246150f, -0.15865885f, -0.28776920f, 0.16792998f, 0.07592204f, 
    -0.16082308f, -0.20736970f, 0.00978268f, 0.12685494f, -0.40929019f, -0.24660891f, -0.37325424f, -0.13442764f, 
    0.14229292f, -0.33930376f, -0.11930949f, -0.15074895f, 0.28200054f, 0.13982601f, -0.05794632f, 0.02151409f, 
    -0.01937471f, -0.31374985f, -0.05685138f, 0.01552022f, 0.02064946f, -0.23699820f, 0.11104862f, -0.25259784f, 
    0.00250747f, 0.15204257f, -0.34470040f, 0.08109701f, 0.11384700f, -0.25486174f, 0.14739610f, 0.64795613f, 
    0.18345247f, -0.25042844f, 0.00534284f, -0.02626795f, 0.04282196f, -0.15027869f, 0.20020923f, -0.18834716f, 
    -0.17741799f, 0.29302105f, 0.50110894f, -0.19153534f, 0.01923557f, 0.18959929f, 0.01350147f, 0.05780345f, 
    -0.25537360f, 0.23372813f, 0.13034245f, 0.10025967f, -0.60245246f, 0.22017926f, -0.09415419f, -0.46184909f, 
    0.03355530f, -0.10592352f, 0.06644125f, -0.13935031f, 0.01687512f, -0.12339725f, -0.00609811f, 0.04566290f, 
    0.13814673f, 0.03815887f, 0.06524628f, 0.09204438f, 0.24741995f, 0.06128370f, -0.16073301f, -0.06103685f, 
    0.17919233f, 0.25179881f, -0.04378985f, -0.27989358f, 0.26295683f, 0.34387362f, -0.48165417f, -0.22712357f, 
    0.00755468f, -0.06547286f, -0.03519271f, -0.02255315f, -0.00956985f, -0.01339628f, 0.17847508f, 0.12967479f, 
    -0.42864504f, -0.41483259f, -0.30188578f, -0.22303157f, -0.16893488f, -0.16210179f, 0.31047666f, -0.20949395f, 
    0.13901813f, 0.24263623f, -0.27988467f, 0.23602451f, 0.50467378f, 0.07395139f, -0.22590598f, -0.15053231f, 
    0.23109981f, -0.00182593f, 0.10457364f, 0.19614102f, 0.06208043f, 0.00770988f, 0.00863230f, 0.15646048f, 
    -0.14583121f, -0.50251657f, 0.36912400f, -0.25074250f, -0.10983453f, -0.09274100f, 0.48974222f, -0.44837716f, 
    -0.03330939f, 0.01703875f, 0.10883799f, 0.28755686f, -0.61869407f, -0.16569316f, 0.52612048f, -0.74750519f, 
    0.04070119f, -0.21268030f, 0.45636898f, 0.05023530f, 0.03837207f, -0.21183543f, -0.39450255f, -0.24968660f, 
    0.35135159f, 0.04214694f, 0.08793101f, 0.19065255f, 0.19472976f, 0.05976355f, -0.00916417f, -0.07519780f, 
    -0.06986141f, -0.01880904f, -0.08802653f, -0.05929152f, 0.28940517f, 0.01032119f, -0.51466727f, 0.07219552f, 
    -0.00541849f, 0.03710496f, -0.02711204f, -0.14152442f, 0.02676905f, 0.00047381f, -0.46955165f, 0.00674009f, 
    -0.30606037f, 0.42066276f, 0.20423731f, -0.33968467f, -0.10905223f, 0.01894874f, 0.18952586f, -0.19859678f, 
    0.01914511f, 0.01497005f, 0.05965234f, -0.28774384f, -0.36617911f, -0.57850260f, -0.02165031f, 0.01590015f, 
    0.22613339f, -0.07045006f, -0.04713562f, 0.25208524f, 0.08770418f, 0.12365488f, 0.15037990f, 0.08700868f, 
    -0.10781639f, 0.48224556f, -0.12426507f, -0.16377068f, 0.10483889f, -0.00028331f, 0.05727055f, 0.01052291f, 
    -0.08969844f, -0.07152098f, 0.01518655f, 0.25175813f, -0.36177972f, -0.13884723f, -0.22385289f, -0.35832909f, 
    -0.24629328f, -0.04765119f, 0.04784153f, 0.18851924f, -0.20501630f, -0.24834071f, -0.07792010f, -0.34292069f, 
    0.16596885f, -0.36306727f, 0.08155923f, -0.12678893f, 0.04945923f, 0.00235307f, -0.07818606f, 0.02578686f, 
    -0.05583814f, -0.15138970f, 0.39327016f, -0.01529424f, -0.83892626f, 0.17040305f, -0.14313668f, -0.54581326f, 
    0.18515685f, -0.19092627f, -0.05020337f, -0.12472653f, -0.30717194f, -0.27211004f, -0.17423514f, 0.09266340f, 
    0.36416131f, -0.11655189f, 0.19825794f, 0.17958975f, 0.03404968f, -0.03608790f, 0.36449924f, 0.21504836f, 
    0.09958565f, -0.23690635f, -0.03954622f, -0.17706384f, -0.76561546f, -0.35749194f, 0.23528224f, 0.05369259f, 
    0.01841793f, 0.23251823f, -0.04407221f, -0.05116571f, 0.04543179f, 0.09464989f, -0.14206284f, 0.06894243f, 
    -0.38506669f, 0.60247803f, 0.24738452f, -0.08252278f, 0.29559749f, 0.28974333f, -0.13798435f, 0.03111725f, 
    0.22110456f, -0.11639486f, 0.12687893f, 0.12647331f, 0.51471519f, -0.85578507f, -0.06860568f, -0.39494237f, 
    -0.10660203f, 0.05614167f, -0.05402634f, -0.07244487f, -0.19713134f, -0.19249932f, 0.01766379f, -0.00720196f, 
    -0.09499867f, 0.17322463f, -0.09803756f, -0.22319365f, -0.05404284f, -0.20871146f, 0.15007339f, 0.13922545f, 
    0.01940051f, 0.11175665f, 0.22792470f, -0.15264706f, 0.81339133f, 0.25053847f, 0.34228984f, -0.45339096f, 
    -0.12585777f, 0.08671784f, 0.14156963f, -0.11511423f, -0.03651913f, 0.03800627f, -0.05185185f, 0.03778564f, 
    0.06587648f, -0.61902857f, -0.15733483f, 0.47957119f, -0.05547714f, 0.07581261f, -0.10188583f, -0.25742719f, 
    -0.02393431f, -0.10508775f, 0.16690254f, -0.15558013f, 0.21229632f, -0.05248390f, -0.03133648f, 0.23056157f, 
    0.05199127f, 0.11434089f, -0.27633190f, 0.06305416f, -0.25689694f, -0.00308362f, 0.02186462f, 0.21364167f, 
    -0.46021512f, 0.68131518f, 0.02965508f, -0.02881710f, 0.05328614f, 0.11239788f, 0.20505778f, -0.07898141f, 
    0.05279892f, 0.01091969f, 0.09543459f, 0.03324238f, 0.19989915f, 0.06363463f, 0.46214294f, 0.06042992f, 
    -0.09876759f, 0.15124415f, -0.21220626f, -0.02308556f, -0.08289540f, 0.18093185f, 0.07193408f, -0.01679137f, 
    0.01604769f, -0.13475107f, -0.19811733f, -0.00118854f, 0.24760030f, -0.03755990f, 0.05562768f, 0.15940402f, 
    0.05521038f, 0.28078768f, 0.13189653f, 0.28840241f, 0.33712426f, 0.08644342f, -0.24791327f, 0.00513568f, 
    -0.36201480f, -0.17529356f, 0.00849262f, -0.02067742f, 0.06272839f, -0.14006129f, -0.22617649f, -0.14344861f, 
    -0.30555069f, -0.17549132f, -0.13820979f, 0.26960716f, -0.28739983f, -0.02321077f, 0.20145658f, -0.36063951f, 
    -0.21658212f, -0.05852789f, -0.10627227f, -0.24011537f, -0.67843747f, 0.07448764f, -0.22509801f, -0.24176934f, 
    0.36893925f, 0.01112885f, -0.13459189f, 0.19834885f, 0.04302522f, 0.08468641f, 0.05904247f, 0.19285734f, 
    -0.62828213f, 0.28802368f, -0.07834583f, -0.14825901f, -0.04313269f, -0.10626270f, 0.00244001f, -0.14097603f, 
    0.11512412f, -0.16581115f, -0.21701559f, 0.12460979f, -0.59873372f, -0.40044710f, -0.33340120f, -0.44519943f, 
    -0.03485065f, -0.17547067f, -0.27983543f, 0.16856001f, 0.04917890f, 0.01145997f, -0.11383176f, -0.12151303f, 
    0.31459227f, -0.08601455f, 0.15182239f, -0.27936995f, -0.14073275f, 0.07046560f, 0.09319612f, -0.05974327f, 
    -0.07248981f, 0.35086927f, -0.07705335f, -0.07934508f, 0.68219525f, 0.08231156f, -0.13986938f, 0.02114784f, 
    0.29108420f, 0.04511774f, 0.09404860f, 0.02855858f, 0.01176902f, -0.13411589f, 0.04435876f, -0.20567568f, 
    -0.32688585f, -0.42103070f, -0.32845950f, -0.01887341f, -0.03814808f, 0.06953155f, -0.00933868f, -0.06674341f, 
    0.31278330f, -0.02425438f, -0.34386826f, 0.02415285f, -0.07612562f, 0.12210287f, -0.07286595f, -0.25535601f, 
    0.03464357f, 0.29935470f, 0.10007574f, -0.10081451f, 0.12916921f, 0.05720036f, -0.02293356f, 0.02025909f, 
    0.18845332f, 0.32799706f, -0.16898565f, -0.00248079f, 0.04283613f, 0.10130989f, 0.03614669f, 0.16160502f, 
    -0.14228764f, 0.03774563f, -0.00751619f, 0.32137245f, -0.43666905f, 0.16956471f, 0.30374697f, 0.23090486f, 
    0.23021191f, 0.00598039f, 0.06355286f, 0.08930506f, -0.08123818f, 0.38531825f, 0.09780240f, 0.07389227f, 
    0.16557431f, -0.03765122f, 0.08231462f, 0.05981474f, -0.16116409f, 0.01493662f, 0.21479169f, -0.02057092f, 
    -0.09978875f, 0.06606775f, 0.23910296f, 0.17633098f, 0.09909443f, 0.01726847f, 0.12368025f, 0.09000318f, 
    0.00473256f, 0.02661482f, 0.10083955f, -0.51880670f, 0.18594785f, 0.19038506f, 0.00957599f, -0.08905452f, 
    -1.38380969f, -0.93733162f, -0.11326180f, -0.32517728f, 0.05523130f, -0.06706962f, 0.11106501f, -0.14739953f, 
    0.24604693f, 0.07221717f, 0.10225644f, 0.25312871f, -0.96297908f, -0.49234968f, 0.15057528f, 0.09295150f, 
    0.18966421f, 0.21390612f, 0.08871482f, -0.17675351f, 0.03801329f, -0.12740850f, -0.32107145f, 0.03618234f, 
    0.33942047f, 0.16073023f, -0.34885275f, 0.57619029f, 0.31428114f, -0.08236139f, -0.11774964f, 0.26205122f, 
    0.01887252f, 0.06961422f, 0.04376392f, -0.32304004f, -0.29217350f, -0.00886760f, -0.00226327f, -0.19849040f, 
    -0.08458231f, -0.01158487f, 0.16047260f, 0.03001263f, -0.25784880f, 0.08527229f, 0.02640150f, -0.23105335f, 
    -0.01531842f, -0.32309324f, -0.04995115f, -0.03162402f, -0.12216748f, 0.14430921f, -0.11856404f, -0.03210142f, 
    0.20222259f, -0.01208876f, 0.11047456f, 0.18244454f, -0.21968855f, -0.30531764f, -0.20118363f, 0.35811454f, 
    -0.17528445f, -0.08051503f, -0.02594624f, -0.08249843f, -0.07859512f, -0.27811393f, 0.11344736f, 0.03421612f, 
    0.78474957f, 0.31644276f, -0.31983230f, 0.08830150f, -0.31262141f, -0.04476570f, -0.26774129f, 0.03985663f, 
    -0.13494097f, 0.03972908f, 0.21690209f, -0.27636886f, 0.18884689f, 0.00627486f, -0.38798156f, -0.86005980f, 
    0.08470220f, -0.01102440f, 0.01085221f, 0.09723836f, -0.03601130f, -0.11145554f, -0.07045377f, 0.17102680f, 
    0.21562497f, -0.16294855f, 0.12008325f, -0.15176417f, -0.02021172f, 0.02662956f, -0.15459774f, -0.25872254f, 
    -0.14573438f, 0.01138033f, 0.05709449f, -0.29840267f, 0.12811409f, 0.22404960f, -0.60265762f, -0.35499346f, 
    0.35958722f, -0.30871654f, 0.08687419f, 0.15049282f, 0.05695859f, 0.31919795f, 0.04051023f, 0.24165721f, 
    -0.18030635f, -0.44627151f, -0.01408103f, 0.24727249f, 0.15778434f, -0.00715593f, -0.17904186f, 0.07939348f, 
    0.21704699f, -0.23048475f, 0.29055807f, -0.07863500f, -0.06997190f, 0.01453868f, -0.15071535f, 0.30372214f, 
    -0.13459945f, 0.03590942f, -0.02178098f, 0.12523980f, 0.11094519f, -0.04717496f, 0.07589273f, 0.19676788f, 
    -0.46239311f, 0.48774162f, -0.02994781f, 0.01040152f, 0.11797587f, -0.02208301f, 0.01197428f, -0.04091666f, 
    -0.07243747f, -0.15268955f, -0.02496174f, -0.05256032f, 0.62292147f, 0.04006301f, 0.06782787f, -0.35265103f, 
    0.26678807f, -0.06202776f, -0.26437357f, 0.20088482f, 0.12333822f, 0.12130953f, 0.15747404f, 0.03121745f, 
    -0.07316560f, 0.38590240f, -0.11411007f, -0.13285546f, -0.17153701f, -0.07889277f, -0.11117868f, -0.06526936f, 
    -0.11186606f, 0.00844158f, -0.13321035f, -0.07373822f, 0.07436095f, -0.17653462f, 0.14764665f, -0.10404791f, 
    -0.36440438f, -0.38401160f, -0.16820094f, -0.20542777f, 0.15229057f, -0.09048491f, 0.12061165f, -0.08621077f, 
    -0.12259600f, -0.86026889f, 0.15596616f, -0.31869254f, 0.27117193f, 0.04168490f, -0.10675173f, 0.01759833f, 
    -0.17069511f, -0.05882621f, -0.02645589f, -0.01798899f, 0.72334594f, 0.57176363f, -0.18762958f, -0.11099919f, 
    -0.13205534f, -0.06153113f, -0.01983134f, -0.12069771f, 0.05787526f, 0.06587030f, 0.05426924f, 0.09406888f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25296664f, 0.19670987f, -0.11280205f, 0.03350173f, -0.02971721f, -0.03400409f, 0.06201194f, -0.08580337f, 
    -0.15446050f, 0.02029309f, 0.17133349f, 0.01603919f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
