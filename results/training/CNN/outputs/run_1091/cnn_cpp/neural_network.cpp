#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.96793401f, 0.79134864f, -0.20219825f, -0.62263584f, -0.01690435f, -0.11451066f, 0.08427777f, 0.22365128f, 
    0.51214194f, 0.33944869f, -0.56570214f, -0.99966425f, 0.03891560f, 0.41131428f, 0.31703913f, -0.38042781f, 
    -0.23926277f, -0.43236339f, -0.69700682f, -0.79039222f, 0.06699991f, 0.66683185f, -0.39454699f, -0.41685432f, 
    0.26911980f, -0.52561605f, -0.24360833f, 0.10830162f, 0.13766742f, 0.19873011f, -0.73670721f, 0.56433970f, 
    0.29364437f, -0.13334629f, 0.32063472f, -0.19516601f, 0.53893739f, -0.25632581f, -0.06557381f, 0.48216709f, 
    0.66882640f, 0.65474313f, -0.25228143f, -0.18976147f, 0.17690434f, -0.69347882f, -0.49719781f, -0.81272161f, 
    0.24552883f, 0.14540121f, 0.06835843f, 0.66986400f, 0.35043845f, 0.43002519f, -0.14623618f, 0.05222540f, 
    0.13568293f, -0.54227662f, -0.74321824f, -0.97661644f, 0.20041257f, 0.43032148f, -0.00752406f, -0.97621250f, 
    -0.01013094f, 0.36601397f, -0.35616896f, -0.55881947f, 0.87036997f, -0.38090217f, 0.18504544f, -0.05704406f, 
    0.28178641f, 0.46665990f, 0.35735503f, 0.23191461f, -0.14528583f, -0.32147112f, 0.02569272f, 0.43963969f, 
    -0.67832142f, -0.26237532f, 0.00537211f, 0.65009272f, -0.14264509f, -0.18587229f, -0.19602594f, 0.35280761f, 
    0.31103566f, 0.63481331f, 0.05645539f, 0.10272007f, 0.38240692f, 0.34885922f, 0.39712110f, 0.39114159f, 
    0.80422801f, -0.70218724f, -0.09904598f, 0.02725216f, -0.64827019f, -0.20062581f, 0.31215915f, -0.72435552f, 
    -0.62035131f, 0.14286998f, 0.69305342f, -0.07371770f, -0.05422011f, 0.33173874f, -0.17364021f, 1.00523162f, 
    -0.71955913f, 0.05778098f, -0.18149091f, -0.26443973f, -0.14999616f, -0.81004411f, -0.09922343f, 0.26071137f, 
    0.73990452f, 0.67570966f, -0.41863352f, -0.33378091f, -0.10666928f, -0.28016552f, -0.51241577f, 0.12204587f, 
    -0.37686697f, 0.01566458f, 0.48281223f, -0.12275162f, 0.07397508f, 0.84122819f, -0.30493852f, -0.49586934f, 
    -0.23006178f, -0.49377850f, -0.26322994f, -0.16499032f, -0.80689454f, -0.34503263f, -0.34048051f, 0.14835297f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.49432442f, -0.19383724f, 0.60086024f, 0.22545925f, -0.16421388f, 0.45439461f, 0.33766493f, 0.35923791f, 
    0.47747657f, -0.06093375f, 0.28653443f, -0.19199561f, -0.13393246f, 0.02763832f, 0.25589913f, -0.14560741f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.01766770f, -0.05610752f, 0.03482583f, -0.05668453f, -0.06706695f, -0.01845010f, -0.02758262f, -0.06734427f, 
    0.05256571f, -0.01957211f, 0.05415668f, 0.05055103f, -0.04563483f, 0.03075054f, -0.06456619f, 0.03800061f, 
    0.04893800f, 0.02540600f, -0.05435663f, -0.07798494f, -0.02052909f, 0.01478193f, -0.00811227f, -0.06459383f, 
    0.00170126f, -0.05429100f, 0.03364552f, -0.08000941f, -0.00731326f, -0.08365583f, -0.03924119f, -0.00778458f, 
    0.04781890f, -0.05565045f, -0.03818103f, 0.02104577f, 0.06024011f, -0.03006930f, -0.06807604f, -0.00312011f, 
    0.01936732f, -0.01130181f, -0.03220573f, -0.08914643f, -0.03292216f, -0.07065511f, -0.03877939f, -0.07898740f, 
    0.05053234f, -0.03109077f, 0.04210050f, -0.04502199f, -0.06557100f, 0.06742484f, 0.03894354f, -0.10672443f, 
    0.03177001f, 0.01979602f, 0.03934281f, 0.02027835f, -0.00666639f, -0.04745711f, 0.00504695f, -0.08389454f, 
    0.03470640f, 0.03639552f, -0.05666547f, -0.07336330f, -0.02095356f, 0.00296835f, -0.08355621f, -0.09865134f, 
    -0.03782298f, -0.05449257f, -0.00147839f, 0.06303962f, -0.08378854f, -0.00808163f, -0.04694654f, -0.04698474f, 
    0.00158528f, -0.09546551f, 0.04055899f, -0.00932931f, -0.09926245f, 0.02385566f, -0.02974330f, 0.00245420f, 
    -0.07894454f, 0.01928593f, -0.07770048f, -0.02551114f, -0.06499841f, -0.08113868f, 0.00759121f, 0.05040432f, 
    0.01871974f, 0.06620223f, -0.07777934f, -0.07412163f, -0.07998968f, -0.01082141f, 0.02082339f, 0.04471178f, 
    0.03086706f, 0.07103547f, -0.00039203f, -0.09028807f, 0.01593190f, 0.01317363f, -0.08505196f, 0.04731651f, 
    -0.06613581f, -0.04128540f, -0.03744402f, -0.02933074f, -0.09344929f, -0.08645710f, -0.06802273f, -0.06471900f, 
    -0.07676588f, -0.00732189f, -0.08180146f, 0.03077264f, -0.02869490f, -0.03361536f, 0.00125279f, -0.05598761f, 
    -0.05173717f, -0.05624031f, 0.05276396f, -0.05148641f, 0.04116651f, 0.05114699f, -0.03962730f, -0.09602252f, 
    -0.05098384f, -0.04522535f, -0.01071693f, -0.05668472f, -0.04617554f, 0.08332709f, -0.05464307f, -0.07228614f, 
    0.02502564f, 0.00907649f, -0.02184461f, -0.09364521f, -0.05534380f, -0.00398339f, -0.08983776f, 0.03826375f, 
    0.06124583f, 0.00841132f, -0.05288601f, -0.03473926f, -0.03082074f, -0.08003683f, 0.01256070f, -0.07025018f, 
    -0.01565363f, -0.09488699f, 0.04755973f, -0.02686594f, 0.05296003f, 0.00830516f, -0.09171940f, -0.07566369f, 
    -0.03617588f, 0.04251277f, 0.02044356f, 0.01486920f, 0.02285392f, -0.03747746f, -0.05780628f, 0.00142569f, 
    0.02180285f, -0.09632454f, 0.06497203f, -0.03733370f, -0.04648930f, -0.05434119f, -0.05905817f, 0.04386801f, 
    0.01954016f, 0.04155105f, 0.04453725f, 0.06375996f, -0.08832288f, -0.06765709f, 0.04373116f, -0.05599155f, 
    -0.09114323f, -0.06316223f, -0.05349568f, 0.02649704f, 0.05049672f, -0.02597708f, -0.09149240f, -0.02396264f, 
    0.03580454f, -0.07405583f, -0.06715822f, -0.05952614f, 0.00955985f, 0.03175129f, 0.00080246f, 0.02350880f, 
    0.03317566f, 0.01102449f, 0.01546342f, 0.03436411f, -0.06859493f, -0.00597786f, -0.05260360f, -0.08225340f, 
    -0.00697249f, -0.00777303f, -0.00524176f, 0.03317475f, 0.01713609f, 0.02123622f, -0.02802330f, -0.06800016f, 
    0.06566580f, 0.01456046f, -0.09026995f, -0.02566388f, -0.02324126f, -0.02589556f, -0.08182305f, -0.02909095f, 
    -0.00924885f, -0.07849974f, -0.04716308f, 0.00412474f, -0.08357006f, 0.01784245f, -0.07514349f, 0.01980672f, 
    -0.05549560f, -0.02766050f, 0.06582435f, 0.06304806f, 0.05056291f, -0.05756672f, 0.04145683f, 0.01417268f, 
    -0.02470884f, 0.05133795f, 0.06174454f, 0.05773760f, -0.04939128f, -0.06260423f, 0.01699782f, -0.06237507f, 
    -0.05627336f, -0.09164466f, -0.08821153f, 0.02480161f, 0.05170051f, -0.04862098f, -0.08134069f, -0.06564741f, 
    -0.04028853f, 0.01121050f, 0.03032967f, 0.00782544f, -0.05308235f, 0.03798278f, -0.09824391f, 0.01404493f, 
    0.04043504f, -0.08298213f, -0.07777856f, -0.08517536f, 0.00659678f, 0.04397064f, 0.00029798f, 0.01455129f, 
    0.02468551f, -0.08246379f, 0.00622312f, -0.05744621f, 0.06598452f, -0.00685800f, -0.06314950f, -0.08857764f, 
    0.01096625f, 0.17804776f, 0.02890162f, 0.01275566f, 0.06301422f, 0.11927732f, 0.07577461f, 0.06556682f, 
    0.13653027f, -0.01957776f, -0.10624416f, 0.01004396f, 0.03527537f, -0.05121147f, -0.25724089f, -0.28713301f, 
    -0.28436726f, -0.49778911f, -0.10589654f, 0.13426837f, -0.00937800f, 0.11946812f, -0.08805144f, -0.09480166f, 
    -0.32227221f, -0.18294668f, -0.14195204f, -0.05351561f, -0.20614956f, 0.33519968f, 0.06326484f, 0.13029473f, 
    0.05796752f, -0.10272340f, 0.25080949f, 0.01795487f, -0.23631102f, -0.25249553f, 0.08387186f, 0.24605297f, 
    0.15775000f, 0.07995491f, -0.02572611f, -0.24963821f, -0.23614196f, 0.01079188f, -0.02692697f, -0.14294907f, 
    -0.09416635f, -0.13233393f, -0.00768009f, 0.18008684f, 0.04364109f, 0.10116132f, 0.10230657f, -0.16656417f, 
    -0.29945746f, 0.01114389f, 0.14908761f, 0.15479340f, 0.31286150f, 0.09010836f, 0.12459791f, 0.11100597f, 
    0.13434401f, 0.31968358f, 0.01583187f, 0.10275414f, 0.02365966f, -0.05349837f, -0.01055024f, 0.01827296f, 
    -0.20182300f, -0.14842033f, 0.03508187f, 0.15868744f, 0.14566639f, 0.00825163f, -0.04342268f, -0.13560836f, 
    -0.12612769f, 0.22924310f, 0.13684288f, 0.24693622f, 0.06591759f, 0.12061021f, -0.07012876f, 0.39787021f, 
    0.37009832f, 0.37709031f, -0.01485243f, -0.21410820f, 0.11288856f, 0.25132772f, 0.17807475f, 0.09278584f, 
    -0.10781341f, 0.06567260f, -0.23888282f, 0.19360809f, 0.11013470f, -0.07358526f, -0.01441900f, -0.02503657f, 
    0.06074300f, 0.32158795f, 0.16946815f, 0.14561337f, 0.07000915f, -0.13808742f, -0.05334929f, 0.16716699f, 
    -0.12119272f, 0.06878120f, -0.16907804f, -0.11955559f, -0.03389024f, 0.03624809f, -0.23397565f, 0.03315525f, 
    0.11896858f, -0.14530459f, 0.03589443f, -0.03373102f, -0.01105622f, -0.16478808f, 0.11028951f, 0.08065764f, 
    0.13759816f, 0.10700905f, 0.16115867f, -0.04781346f, -0.01201828f, 0.10267369f, 0.03864587f, 0.30373830f, 
    0.07931475f, 0.11772271f, -0.02762591f, 0.04785941f, 0.09784126f, -0.09585088f, -0.06924099f, -0.07257054f, 
    -0.14186330f, 0.24499123f, -0.10601000f, 0.15171814f, 0.08511316f, 0.21806671f, 0.11161178f, 0.02123450f, 
    0.04390773f, 0.22444376f, -0.15199175f, 0.25973260f, -0.15757683f, -0.38197511f, 0.11874656f, 0.04398094f, 
    -0.00863900f, -0.03867748f, -0.03123028f, 0.17638132f, 0.11568885f, -0.03928967f, 0.03399089f, -0.16987440f, 
    0.17538586f, 0.04597774f, 0.10001826f, -0.41227302f, -0.26263997f, -0.23004702f, 0.06999686f, 0.30027106f, 
    -0.08882444f, 0.03124162f, -0.08080640f, 0.14541067f, 0.13078757f, 0.01881244f, 0.07179387f, -0.21270664f, 
    -0.21906212f, -0.14925212f, 0.13405764f, 0.05050983f, 0.02396935f, -0.05513579f, -0.03292452f, 0.38075402f, 
    0.23175715f, -0.15844606f, -0.32144669f, 0.00756050f, 0.06284939f, 0.10807911f, 0.20188801f, 0.32926077f, 
    0.18385355f, 0.15603983f, 0.02108200f, -0.08367133f, 0.12101381f, -0.05191817f, 0.11206932f, -0.11206187f, 
    -0.31077349f, -0.35593465f, -0.06147805f, -0.14346935f, 0.07225904f, 0.12979496f, 0.13343541f, -0.03936246f, 
    -0.09175909f, -0.04764391f, -0.07107373f, 0.06963867f, 0.14828213f, -0.07377886f, 0.26639915f, 0.23400986f, 
    0.15456635f, -0.00872302f, 0.10637143f, -0.37712744f, -0.10799711f, -0.01500039f, -0.02957335f, 0.24825902f, 
    0.17262493f, -0.03048930f, -0.06424755f, 0.11719171f, 0.05656575f, -0.11758412f, 0.01641252f, -0.07308165f, 
    0.00893969f, 0.27469218f, 0.07616469f, 0.11421188f, -0.18332475f, 0.21833250f, -0.31858635f, 0.10332245f, 
    -0.00038719f, 0.21307416f, -0.11509597f, 0.10474284f, 0.08284073f, -0.19719952f, -0.43829781f, 0.11228815f, 
    -0.05969050f, -0.03144084f, 0.23234937f, -0.11494721f, -0.25595522f, 0.11047912f, -0.10795080f, -0.00118164f, 
    -0.32502809f, 0.10838112f, -0.45117125f, 0.04817485f, 0.06835847f, -0.11828564f, -0.02117302f, 0.07234270f, 
    0.15341698f, 0.05309284f, 0.05416804f, -0.06281552f, 0.07060563f, 0.10302604f, 0.07557452f, -0.35434374f, 
    -0.17746545f, 0.17142235f, -0.10645591f, -0.00426365f, -0.11273504f, 0.20812669f, 0.11391924f, -0.08754280f, 
    -0.10258883f, -0.08480692f, -0.04212324f, -0.08407105f, -0.00915514f, 0.00144657f, -0.04245449f, -0.07317989f, 
    0.02566720f, -0.01869474f, -0.05001663f, 0.02188162f, -0.04188725f, -0.08417618f, -0.04124150f, 0.00908041f, 
    0.01527239f, -0.05553945f, 0.01709526f, -0.11225550f, -0.05071557f, 0.04970409f, -0.03132195f, 0.02564616f, 
    0.01691994f, -0.10589086f, 0.04900844f, -0.02170594f, 0.06701593f, -0.06410692f, -0.07339762f, -0.02575664f, 
    -0.04680292f, -0.01834287f, -0.06010018f, 0.00409114f, -0.01312409f, 0.04703292f, 0.06168106f, -0.04818989f, 
    0.05829681f, -0.01346159f, -0.00522629f, -0.06554578f, -0.01668584f, -0.02781024f, -0.04359368f, 0.04037260f, 
    0.07679653f, -0.05504497f, -0.09103540f, 0.00196819f, -0.00040957f, -0.07552470f, -0.04167289f, 0.02136280f, 
    -0.01178099f, 0.00328317f, -0.01466218f, -0.07573225f, -0.04936526f, 0.01745719f, -0.00087586f, -0.03591805f, 
    -0.08378138f, -0.03044648f, -0.00099066f, -0.09523250f, -0.08243582f, -0.00588378f, -0.04417529f, -0.11550535f, 
    0.01564442f, -0.06067693f, -0.11281828f, -0.08068853f, -0.09005728f, -0.04026353f, -0.02378466f, 0.05905275f, 
    -0.03174677f, 0.02268241f, 0.04827072f, 0.00437702f, 0.05601333f, 0.01196680f, -0.01587592f, 0.04341226f, 
    0.04727527f, 0.01608658f, -0.10466111f, -0.00327314f, 0.04128689f, 0.01724639f, 0.04636557f, -0.09015255f, 
    -0.05357147f, -0.00319844f, 0.01682867f, 0.05332011f, -0.01903845f, -0.02634508f, -0.07520615f, 0.03639171f, 
    -0.03951522f, 0.04025569f, -0.03900917f, 0.00898185f, 0.01703944f, -0.07399663f, 0.00268911f, 0.07347307f, 
    -0.01605474f, -0.07718699f, 0.00437917f, -0.00975354f, 0.05693089f, -0.00296727f, 0.00119679f, -0.05824884f, 
    0.01315854f, -0.10225228f, -0.00968678f, -0.06904832f, -0.12127627f, -0.06867147f, -0.04067646f, 0.05582324f, 
    0.01822469f, 0.03478448f, -0.01555466f, -0.04619615f, -0.04836732f, -0.08280509f, -0.02809930f, -0.00994036f, 
    0.03813013f, -0.11738060f, 0.07664451f, 0.00034538f, -0.10385755f, 0.00264528f, 0.04461993f, 0.01574992f, 
    -0.17040733f, 0.01453404f, -0.02042402f, 0.12747961f, 0.12184310f, -0.02839949f, 0.00754734f, 0.00087721f, 
    -0.05720831f, 0.01079379f, 0.08090100f, -0.00720839f, 0.22990519f, -0.00897680f, 0.09795590f, 0.13986579f, 
    0.21157898f, 0.02643621f, 0.18407612f, -0.55887282f, 0.03652244f, -0.04082007f, 0.03661205f, -0.37319127f, 
    0.07040542f, 0.14543979f, -0.05556849f, -0.06536238f, 0.12471180f, -0.22682352f, 0.04835253f, -0.14479157f, 
    0.12524322f, -0.03398874f, 0.11044229f, -0.26088011f, 0.18386792f, 0.12523150f, 0.01231711f, -0.10435589f, 
    -0.24902809f, -0.18529199f, 0.11407554f, 0.13363621f, 0.01600065f, 0.57747954f, 0.01328269f, -0.41576803f, 
    0.09253445f, -0.07329638f, 0.12011617f, 0.05609624f, 0.13424623f, -0.05742829f, -0.16804340f, -0.19814765f, 
    0.25756326f, 0.02612331f, 0.03783178f, -0.03834051f, 0.06682795f, -0.21898757f, -0.01412127f, 0.20348875f, 
    0.21613009f, 0.00958595f, -0.20999441f, 0.14775106f, 0.05317034f, -0.08550190f, -0.08911289f, -0.23398724f, 
    -0.05709461f, -0.07681318f, 0.28103036f, -0.15244213f, -0.02464489f, -0.11331043f, 0.02976375f, -0.04436263f, 
    0.01302335f, 0.09729292f, 0.24482082f, 0.15768036f, 0.26467973f, 0.01449634f, 0.21234296f, -0.20449078f, 
    -0.08554923f, -0.00307984f, 0.10906956f, 0.15292843f, 0.18062276f, -0.25878823f, -0.16020873f, -0.11306386f, 
    0.08781761f, -0.03284751f, 0.06902605f, -0.19146495f, -0.20659867f, 0.28551954f, -0.02072445f, -0.04198993f, 
    0.10350682f, 0.15069328f, -0.28954569f, 0.11748667f, -0.00121836f, -0.05878824f, 0.13751712f, -0.02406225f, 
    0.09095968f, 0.10903473f, -0.03839897f, 0.18222658f, 0.29531282f, 0.35023087f, -0.03121097f, 0.07285273f, 
    -0.32296544f, 0.15337248f, -0.02282758f, -0.02866009f, 0.05363710f, 0.02860578f, 0.50517994f, -0.03911206f, 
    -0.18202612f, -0.02600401f, -0.19728981f, 0.06907441f, 0.09049007f, -0.18816838f, -0.01539455f, 0.21323758f, 
    -0.00152536f, -0.07727151f, 0.07524254f, 0.09955229f, -0.34448466f, -0.05727747f, -0.17028145f, 0.01677033f, 
    -0.55910778f, -0.49876696f, -0.14561622f, 0.02384276f, 0.02675961f, -0.11505142f, -0.09634871f, -0.04717664f, 
    0.10170120f, -0.25648078f, 0.33001938f, 0.18520358f, -0.08059089f, 0.12105056f, -0.19427358f, -0.00045343f, 
    -0.17325148f, -0.21818155f, 0.05657122f, 0.10694383f, 0.16127563f, 0.11797463f, 0.08749213f, 0.11160074f, 
    0.09644411f, 0.10550816f, 0.10188589f, -0.16857311f, 0.03799915f, 0.28395262f, -0.13288471f, -0.20089433f, 
    0.02146752f, 0.26184645f, 0.01159245f, 0.23465541f, -0.03452134f, -0.17681383f, -0.11979853f, 0.00418936f, 
    -0.16766676f, -0.03723103f, -0.01174791f, -0.02792951f, 0.11044179f, 0.29046077f, 0.09679587f, 0.21272157f, 
    0.03344522f, 0.08578614f, 0.03641291f, 0.02184882f, 0.12291471f, 0.05431874f, -0.32766974f, -0.03268932f, 
    0.11416619f, -0.02111002f, -0.00431738f, 0.18373138f, 0.06582065f, -0.01093126f, 0.15798379f, -0.20454802f, 
    -0.07058311f, 0.22413842f, -0.00632274f, 0.10010889f, -0.01424455f, 0.06782000f, 0.11007115f, 0.08925800f, 
    0.12302485f, -0.22536679f, 0.07628683f, 0.07232157f, -0.35064787f, 0.14043178f, 0.08464181f, 0.07877359f, 
    0.10195504f, -0.22018898f, 0.17556806f, -0.24431306f, 0.10784046f, 0.10933458f, -0.11888187f, 0.05256404f, 
    0.18197051f, 0.25894192f, -0.28303993f, -0.36861542f, -0.22849630f, -0.20138532f, -0.10212198f, 0.08418123f, 
    0.01471190f, -0.08771037f, 0.11418045f, -0.02612513f, -0.00837008f, 0.30120763f, -0.03042338f, -0.03032273f, 
    -0.22432137f, -0.03809532f, 0.09376606f, 0.11034324f, -0.25006980f, -0.28835040f, 0.03822060f, 0.03197916f, 
    -0.07632315f, 0.07865377f, -0.20290191f, -0.00777354f, -0.03466268f, -0.27003998f, -0.18803719f, 0.43022919f, 
    -0.02207830f, 0.05767900f, -0.01451887f, 0.00110847f, 0.05596375f, -0.16619378f, 0.14642000f, 0.11369061f, 
    0.40851781f, -0.14172488f, 0.31378233f, 0.14134490f, 0.12314554f, -0.06548378f, 0.05958943f, -0.09859226f, 
    0.06276952f, 0.40873760f, -0.10967824f, -0.00425489f, -0.07583086f, 0.02515261f, 0.07191525f, -0.16927145f, 
    0.05710472f, -0.07349391f, -0.02585794f, 0.16803828f, -0.07235022f, 0.05416195f, 0.17848244f, -0.11310197f, 
    0.17080620f, -0.28826264f, -0.07966430f, -0.36266869f, -0.12038279f, -0.11400265f, -0.15269825f, -0.16014737f, 
    -0.05451461f, -0.02204924f, -0.08113641f, -0.02932218f, -0.05314508f, 0.03156760f, 0.17129612f, 0.09675488f, 
    0.19121301f, 0.02396581f, -0.16494797f, 0.09140750f, 0.05459958f, 0.04781921f, -0.06340408f, 0.03835275f, 
    0.15636732f, 0.00268872f, 0.01760108f, 0.12025147f, 0.09000509f, 0.14445676f, -0.00082051f, -0.17113508f, 
    -0.07689579f, -0.09193564f, -0.12942035f, -0.18961573f, -0.11374350f, -0.16225360f, -0.00391320f, -0.31523091f, 
    -0.11399141f, 0.06965376f, -0.07101910f, -0.05502934f, 0.14612903f, -0.01497894f, -0.34315291f, -0.13562329f, 
    0.01736514f, 0.20851259f, 0.08521921f, 0.12851605f, 0.07275253f, -0.04148014f, 0.01451260f, -0.20317943f, 
    -0.12927148f, 0.00717969f, 0.31902379f, 0.02820668f, -0.00016748f, 0.12293452f, 0.11515777f, 0.25091118f, 
    0.00091664f, 0.08789770f, 0.17535442f, 0.16525576f, 0.06005395f, 0.03721436f, 0.18761571f, 0.20453554f, 
    0.10420640f, -0.31599149f, -0.01869596f, 0.03762845f, -0.08745875f, -0.07383696f, -0.10276175f, -0.06174609f, 
    0.20806366f, 0.47900689f, 0.20782244f, 0.25062427f, 0.04691572f, -0.04899282f, 0.05328519f, 0.09538577f, 
    -0.08226798f, -0.10607389f, -0.07607899f, -0.15025380f, 0.21511036f, -0.13953921f, -0.16441013f, 0.02501818f, 
    0.01602722f, -0.06706502f, -0.09943231f, 0.15835413f, -0.10616750f, 0.20957582f, -0.10854530f, -0.12094267f, 
    -0.02130293f, -0.02035141f, 0.23816398f, -0.16148312f, 0.04843768f, -0.23175243f, -0.20791979f, 0.14643900f, 
    -0.02065608f, -0.03536813f, -0.13735706f, 0.12168276f, -0.18621060f, -0.07963978f, -0.01264880f, 0.18191817f, 
    0.24166740f, -0.04457137f, -0.01093343f, -0.00609794f, 0.10975615f, 0.24577993f, 0.15612499f, -0.08252367f, 
    0.03296852f, 0.03274664f, -0.05949473f, -0.05427358f, -0.05898953f, 0.08546627f, -0.17003764f, -0.01574943f, 
    0.54480010f, 0.03689791f, -0.17006624f, 0.15959480f, -0.02650097f, 0.20027512f, 0.09138167f, 0.03842096f, 
    -0.05782578f, 0.00048450f, 0.13292928f, 0.23917994f, -0.11342878f, 0.00804657f, 0.00893086f, 0.14910340f, 
    -0.07949417f, 0.19882737f, 0.07423531f, 0.12496972f, 0.43571746f, 0.17454910f, -0.10594855f, 0.02539314f, 
    0.06216510f, 0.06970111f, 0.05372124f, -0.08636098f, -0.16484499f, -0.02889499f, 0.04304930f, 0.04510305f, 
    -0.10843973f, 0.17729199f, -0.10910037f, -0.04209515f, -0.28205019f, -0.02622754f, -0.03514910f, -0.25861984f, 
    -0.09328965f, -0.09001919f, 0.11386413f, 0.12434369f, 0.11886103f, -0.43423516f, 0.40345794f, 0.28793079f, 
    -0.02873334f, 0.24860679f, -0.09745259f, 0.04042504f, 0.07896905f, 0.03690830f, -0.22490756f, -0.32993338f, 
    -0.42225918f, -0.03322687f, 0.10001556f, -0.20331031f, 0.06566945f, 0.02756444f, -0.16021541f, -0.23054229f, 
    -0.44188851f, -0.10210228f, -0.17602310f, 0.08390901f, -0.00748296f, 0.08199906f, 0.08673035f, 0.07663264f, 
    -0.09273359f, -0.38832825f, -0.11486731f, 0.22613999f, 0.12226045f, 0.03958830f, 0.10636643f, 0.13926794f, 
    0.13331917f, 0.09155872f, -0.32707402f, -0.01892275f, -0.20054571f, 0.02830865f, 0.02511803f, -0.00917772f, 
    -0.23937310f, -0.07989680f, 0.08693267f, 0.20758940f, 0.03211074f, 0.03475955f, -0.01631426f, -0.15870234f, 
    0.04947309f, -0.04438398f, 0.33838341f, -0.14614424f, -0.35342398f, -0.56991535f, -0.21289010f, -0.18251458f, 
    -0.46055162f, -0.06313790f, -0.01527439f, -0.07362249f, -0.31771502f, -0.34637889f, -0.11785822f, -0.03205710f, 
    -0.15304783f, -0.02133051f, 0.13247380f, -0.00587420f, -0.04143460f, -0.41802102f, -0.05478870f, 0.20278874f, 
    -0.11304449f, 0.14272955f, -0.10342187f, 0.00032029f, -0.00436478f, 0.18872963f, -0.27244708f, 0.17539437f, 
    0.54723722f, 0.17931253f, -0.13178907f, -0.11808831f, 0.02706955f, 0.00018141f, 0.04784194f, -0.33949134f, 
    0.20437026f, -0.10224469f, 0.02285929f, -0.20610651f, -0.00173101f, 0.00108256f, -0.03039602f, 0.04553096f, 
    0.09457011f, -0.05976369f, 0.15998752f, 0.02680105f, 0.05119643f, -0.09439427f, -0.01678436f, 0.13689785f, 
    -0.04700619f, 0.02750881f, 0.34213489f, 0.26185223f, -0.15476719f, 0.09870405f, -0.10004541f, -0.00084535f, 
    -0.03735209f, 0.15710199f, -0.46660772f, 0.46343541f, 0.23189907f, 0.19509931f, 0.02380263f, 0.13080780f, 
    0.05728713f, 0.11251775f, 0.14900689f, -0.23491481f, -0.12771592f, -0.17007156f, -0.37713519f, -0.08133333f, 
    -0.22695063f, -0.11043450f, -0.07638188f, 0.24745019f, -0.29703543f, -0.20071919f, -0.13113509f, -0.22496065f, 
    -0.08490618f, -0.27950063f, 0.02664292f, 0.09938646f, 0.00530682f, -0.33581915f, 0.00276103f, 0.26493621f, 
    0.19824710f, 0.33147019f, -0.02770053f, -0.04733872f, 0.12031125f, -0.07649456f, -0.01279687f, -0.17611861f, 
    0.17858037f, 0.03184741f, -0.06023493f, -0.06414544f, -0.13804133f, -0.11723207f, 0.03239619f, 0.56009966f, 
    0.29467279f, 0.04521741f, 0.06234676f, -0.02979103f, 0.06066893f, -0.00908446f, 0.00075395f, -0.11856987f, 
    -0.02879593f, 0.04154489f, 0.30717969f, -0.06877322f, 0.06372374f, 0.05191316f, -0.00905041f, 0.05065188f, 
    0.33586672f, -0.16714822f, -0.71620363f, -0.38147566f, -0.24302284f, -0.15436715f, 0.02914860f, 0.00949110f, 
    -0.15137741f, -0.05813392f, 0.18110536f, 0.01709655f, -0.00084317f, 0.21139933f, -0.14923988f, 0.14886746f, 
    0.14586814f, -0.05144124f, 0.31731975f, -0.25311494f, 0.09433276f, 0.11451455f, -0.13090007f, -0.11805170f, 
    -0.15250912f, -0.03863434f, -0.05847762f, -0.04149336f, -0.01820886f, -0.42094284f, -0.05334786f, 0.03611439f, 
    0.10004482f, -0.15468143f, 0.16040668f, -0.01796309f, -0.12929685f, 0.03405466f, 0.21326859f, -0.01831213f, 
    0.06314260f, 0.00426850f, 0.03682644f, -0.03599854f, -0.06459686f, 0.11102756f, 0.31695259f, 0.00610029f, 
    0.18598533f, 0.03609754f, -0.07860252f, 0.02235172f, -0.02615159f, 0.01716627f, 0.17012522f, -0.19834058f, 
    -0.01030563f, 0.34994903f, 0.00923999f, -0.00535786f, -0.14936939f, 0.00378139f, 0.09555488f, -0.11978775f, 
    0.58885807f, 0.32272699f, -0.14496648f, -0.10115232f, 0.01759686f, -0.07489682f, -0.02421661f, 0.12769310f, 
    -0.05744654f, -0.66962212f, 0.00973754f, -0.15914711f, 0.14585975f, 0.05395463f, 0.20867859f, 0.01387944f, 
    0.06903835f, 0.19156621f, 0.00334401f, 0.01392689f, 0.19033764f, 0.01463799f, -0.03647240f, -0.08794598f, 
    -0.16555698f, 0.11383510f, 0.18347956f, -0.01025575f, -0.23486422f, -0.09214104f, -0.01103848f, 0.11129174f, 
    0.05524826f, -0.17039637f, 0.06748252f, 0.09288330f, -0.16051489f, 0.16140759f, 0.02051474f, -0.01404656f, 
    -0.02183847f, 0.10366888f, -0.13322645f, -0.09479728f, 0.15284936f, -0.20994702f, 0.11003432f, 0.02211929f, 
    -0.07377231f, 0.20790784f, 0.02182907f, 0.00030003f, 0.10797052f, -0.22959013f, -0.28734604f, -0.01810107f, 
    -0.06336072f, 0.00856124f, 0.10193860f, -0.26537728f, 0.10387311f, -0.05065523f, 0.03511980f, 0.26786283f, 
    0.21376631f, 0.12037554f, 0.00443849f, 0.04324312f, 0.12334512f, -0.06853773f, -0.08376727f, 0.03787891f, 
    0.13009727f, 0.26894552f, 0.02009950f, -0.08754980f, 0.03051107f, -0.36410964f, -0.03509641f, 0.12983350f, 
    0.02134380f, -0.13933624f, -0.09243082f, -0.09645045f, -0.28660405f, -0.20543994f, -0.33541134f, 0.23434703f, 
    -0.02457891f, -0.17668289f, 0.09137095f, 0.05019189f, 0.13761719f, -0.09091525f, -0.07556817f, -0.17059994f, 
    0.14115994f, 0.08799431f, 0.03330624f, 0.03896909f, -0.35293829f, 0.19911574f, -0.01596955f, -0.03776503f, 
    -0.08719867f, 0.07153433f, -0.18903127f, -0.01207851f, -0.36220250f, -0.27434507f, 0.17393471f, -0.24794322f, 
    -0.18110733f, 0.10104298f, 0.10671338f, 0.05968289f, 0.11431619f, -0.24979219f, -0.07156367f, -0.14805874f, 
    0.07508698f, 0.21067618f, -0.05971020f, 0.16347738f, 0.00042066f, 0.12866522f, -0.08434660f, -0.20741545f, 
    0.38766500f, 0.11117097f, 0.23011476f, 0.15734544f, -0.07327691f, 0.10356630f, 0.23994602f, -0.02033155f, 
    -0.14459960f, 0.09049703f, -0.19767559f, 0.07419767f, -0.19420040f, 0.02068213f, -0.01872195f, 0.10171063f, 
    -0.03030479f, -0.06384234f, -0.00308827f, 0.03876102f, 0.07494312f, -0.08798080f, 0.04117622f, 0.00511121f, 
    0.03097506f, -0.05971479f, -0.07244415f, -0.03170393f, -0.05582738f, 0.07526149f, 0.00771867f, -0.00093963f, 
    -0.08784983f, -0.05593364f, -0.03112396f, -0.00859176f, -0.02020662f, 0.07919937f, 0.02231371f, 0.05746124f, 
    0.01568143f, -0.08580068f, -0.00874772f, -0.01683995f, 0.01267943f, 0.04319691f, -0.05516028f, 0.00844271f, 
    -0.01387855f, -0.01196597f, -0.06451359f, -0.07567497f, -0.00189622f, -0.01180107f, 0.04909620f, 0.05426288f, 
    0.05338226f, -0.05784000f, -0.00663465f, -0.01101766f, -0.06589645f, -0.05372132f, -0.00772580f, 0.06143781f, 
    -0.07552505f, -0.02909311f, -0.03328416f, -0.05640231f, -0.00527618f, -0.05569463f, -0.02892018f, 0.00111532f, 
    0.07062146f, 0.04248384f, 0.05485951f, 0.06344979f, -0.04264816f, -0.03153383f, 0.01010612f, -0.00376530f, 
    -0.02282958f, 0.04229071f, -0.02004483f, -0.05981031f, -0.03102205f, -0.02787173f, -0.04380354f, 0.04285084f, 
    -0.01016738f, 0.01527217f, 0.03599046f, 0.04897278f, 0.04760837f, -0.05981405f, 0.00910524f, -0.04289808f, 
    0.03435462f, -0.04884668f, -0.00228419f, 0.00013961f, -0.02251616f, 0.06880268f, 0.06017118f, 0.07451661f, 
    -0.01112496f, -0.06786083f, -0.02836592f, 0.00046232f, -0.05286557f, -0.07884077f, -0.01401716f, -0.06593477f, 
    -0.00084150f, -0.08453338f, 0.01022473f, -0.04084807f, -0.07045411f, -0.01952300f, -0.05693081f, 0.05862419f, 
    -0.05336807f, 0.01944664f, -0.03142827f, 0.07121522f, 0.04459445f, -0.01900329f, -0.05954639f, -0.02781513f, 
    0.06857983f, -0.07708810f, -0.01828156f, -0.09463933f, 0.03519874f, 0.01348281f, -0.02315555f, 0.01294640f, 
    0.00061415f, -0.03614501f, -0.03700333f, -0.07255309f, 0.01314559f, -0.02109808f, 0.07543455f, -0.06233214f, 
    -0.08909880f, -0.00928283f, 0.03983016f, -0.07424444f, -0.01592322f, 0.02792685f, 0.03429957f, -0.04013811f, 
    -0.05945759f, -0.07120284f, 0.02108298f, -0.07914183f, -0.05889273f, -0.05315129f, -0.08201858f, 0.03950541f, 
    0.44011447f, 0.37195587f, -0.01278839f, 0.10241314f, -0.00958247f, 0.09327517f, 0.11672564f, 0.00587613f, 
    0.11746109f, -0.17604081f, -0.09871718f, -0.53225273f, 0.09353746f, 0.01823271f, -0.02922480f, -0.21669325f, 
    -0.09989519f, 0.08662909f, -0.00454919f, -0.30778819f, -0.02762214f, -0.01399105f, 0.19857678f, 0.25690174f, 
    0.00673938f, 0.16192266f, -0.14806895f, -0.06160052f, 0.06000596f, 0.39554960f, -0.10350651f, -0.19809063f, 
    -0.10929225f, -0.03164663f, 0.09864429f, -0.07290303f, 0.06229072f, -0.11107467f, 0.06886200f, -0.02715446f, 
    -0.04371047f, -0.21289735f, -0.16942416f, -0.16004708f, -0.01237950f, -0.40643644f, -0.36552221f, -0.14125717f, 
    -0.01369233f, 0.16471972f, 0.09854553f, 0.04610749f, 0.06131957f, -0.08583359f, -0.46841383f, 0.00228123f, 
    0.12950121f, -0.23848392f, -0.13382711f, -0.00085372f, 0.01252559f, 0.10406809f, 0.01454567f, -0.20676471f, 
    0.52297521f, -0.05439939f, 0.11009762f, 0.05046058f, 0.03733216f, 0.03041775f, 0.00056025f, 0.01147788f, 
    0.17494163f, 0.52813035f, -0.02539536f, 0.18190385f, -0.21149577f, -0.09937701f, 0.00786604f, 0.06322785f, 
    0.07820407f, -0.25251156f, -0.10586093f, -0.10005047f, 0.04528572f, 0.09644940f, -0.04062013f, 0.09260080f, 
    -0.06995586f, -0.06386398f, 0.10943133f, 0.09774466f, 0.21135466f, 0.13042353f, 0.01194626f, -0.12422320f, 
    0.09005164f, 0.13400602f, 0.07231750f, 0.18139395f, -0.27811161f, 0.45191163f, -0.02211982f, -0.11341322f, 
    -0.13629882f, -0.15747641f, -0.02059958f, -0.02286426f, -0.45528513f, -0.42404020f, 0.20618641f, -0.05807856f, 
    -0.16954124f, -0.03119930f, 0.14838661f, 0.19438669f, 0.02940071f, -0.01396040f, -0.59656096f, -0.09367917f, 
    0.18934678f, 0.17730805f, -0.19532916f, -0.00699951f, -0.15724085f, 0.24644183f, -0.18776615f, -0.66084105f, 
    0.14113200f, 0.21262939f, 0.05500619f, -0.09583316f, -0.02149173f, 0.01655319f, 0.11012086f, 0.05671988f, 
    -0.60845244f, -0.34333065f, -0.09086455f, -0.00994229f, -0.11928882f, 0.13052443f, 0.01820465f, 0.00082696f, 
    -0.20854504f, -0.30426764f, -0.39011455f, 0.10085034f, -0.08992845f, 0.16465595f, 0.03810767f, -0.00462262f, 
    0.04777737f, 0.33196056f, -0.13762876f, 0.03203562f, 0.04407959f, -0.05188158f, 0.17974600f, 0.13278677f, 
    0.02574609f, -0.11298130f, 0.53352153f, 0.03961978f, 0.02553954f, -0.02481124f, 0.03876363f, 0.11924860f, 
    0.06614381f, 0.13535646f, -0.03477473f, -0.42081881f, -0.23554859f, -0.01694712f, 0.25869685f, -0.22845823f, 
    0.05149242f, 0.01461580f, 0.17179619f, 0.07244250f, 0.13038717f, -0.42702788f, -0.72105217f, 0.07020451f, 
    -0.33127567f, -0.12319648f, 0.15533493f, 0.08550493f, 0.03650890f, 0.08503982f, 0.19284205f, -0.12225433f, 
    0.09217506f, 0.01323449f, 0.24566831f, 0.02594338f, -0.02102946f, 0.07698387f, 0.25691459f, 0.28655472f, 
    0.32500246f, -0.20049758f, 0.02020564f, -0.23613457f, -0.11797691f, -0.10729742f, 0.18000405f, -0.42154205f, 
    -0.07431929f, 0.23791169f, -0.02922191f, 0.17770146f, -0.03082982f, 0.04199275f, 0.11401413f, 0.10834114f, 
    -0.04101498f, 0.07787526f, -0.05294157f, 0.00345940f, 0.00302305f, 0.05062182f, -0.17441101f, 0.11795080f, 
    0.13328029f, -0.17293850f, -0.19825444f, -0.17707680f, -0.22411551f, -0.23721804f, -0.00274083f, 0.14603245f, 
    0.11031630f, 0.07537049f, -0.22918837f, 0.23671880f, -0.10927545f, 0.12510863f, -0.01931174f, -0.07940702f, 
    0.10352482f, 0.10226133f, 0.10662937f, 0.30514348f, 0.45238352f, 0.22598310f, -0.08551091f, -0.05281061f, 
    -0.01321207f, 0.11345533f, -0.10498418f, 0.17773826f, 0.01766582f, 0.63204741f, -0.29278150f, -0.52680624f, 
    -0.18901141f, 0.15422969f, 0.08586790f, 0.08392736f, -0.05417118f, 0.05633961f, 0.06838965f, -0.21675611f, 
    -0.06475095f, -0.07689209f, -0.04048029f, -0.02947472f, 0.13326316f, 0.05095985f, -0.27332130f, -0.21160255f, 
    -0.11073734f, 0.13912910f, 0.24394278f, 0.10261928f, 0.04563724f, -0.04858985f, 0.13486341f, 0.51795059f, 
    0.28645688f, 0.29613748f, -0.00914722f, -0.00926696f, 0.19276173f, 0.09405552f, -0.00406761f, 0.01448822f, 
    0.14958683f, 0.08254261f, -0.02634236f, 0.10764051f, -0.07218204f, 0.15782404f, 0.13896185f, 0.00142756f, 
    -0.10700440f, 0.00617710f, -0.39516580f, -0.38855016f, 0.08808661f, -0.11327919f, -0.03507607f, -0.06418385f, 
    -0.09282274f, 0.24677895f, -0.04319082f, -0.42175934f, 0.09168406f, -0.04926365f, 0.14718486f, -0.20091343f, 
    0.03853399f, -0.00963609f, 0.06548087f, -0.67608756f, 0.03363173f, -0.06760062f, -0.00128879f, -0.03265605f, 
    -0.14046448f, 0.11566950f, 0.08446277f, 0.11608111f, 0.32064238f, -0.15021610f, -0.05549658f, -0.03932881f, 
    -0.10122429f, -0.10207388f, 0.03822068f, -0.01803485f, 0.09713779f, 0.13857269f, -0.18918093f, 0.31780013f, 
    0.06754903f, 0.05591505f, -0.13589391f, 0.03890849f, -0.03345046f, 0.02822549f, -0.18757513f, 0.29648834f, 
    0.08551724f, -0.00109471f, 0.06251722f, -0.11307257f, -0.03931085f, 0.09260438f, -0.17590018f, -0.42961660f, 
    0.44734955f, 0.15259337f, -0.10541390f, -0.06217894f, -0.06643665f, 0.06798444f, 0.00405287f, 0.12975718f, 
    0.10772890f, 0.08249561f, 0.10127294f, -0.08869167f, -0.10183629f, -0.10241448f, -0.01513952f, 0.12243052f, 
    0.11424245f, -0.56173575f, 0.29271480f, -0.20652166f, -0.10164923f, 0.19496474f, -0.05427894f, -0.07195538f, 
    -0.13458495f, -0.05744599f, -0.00576306f, 0.18527436f, 0.39227322f, -0.18350257f, -0.12502035f, -0.20536387f, 
    -0.04796365f, -0.13044657f, 0.00734683f, 0.07130064f, 0.07199962f, 0.27805865f, -0.17096622f, -0.08103605f, 
    -0.15600421f, 0.01177142f, 0.07992201f, 0.02961782f, -0.43082872f, -0.24718498f, 0.42351970f, -0.02586000f, 
    -0.18731514f, -0.02114694f, 0.06676903f, -0.20722210f, -0.08514930f, -0.45623255f, 0.08285395f, -0.11623518f, 
    -0.20734069f, 0.02400578f, -0.29365006f, -0.07336329f, 0.08591824f, 0.01275561f, 0.30612463f, 0.24741592f, 
    -0.08648106f, 0.15498887f, -0.05657410f, 0.28471100f, 0.10167194f, 0.21697877f, 0.03523505f, -0.23821948f, 
    0.26845777f, 0.23154317f, 0.01254805f, -0.08031122f, 0.04108230f, 0.15551163f, 0.06440003f, 0.10212068f, 
    -0.03185547f, -0.07460818f, 0.07340809f, -0.04447407f, -0.05946159f, -0.04439722f, 0.06644739f, -0.04753107f, 
    -0.03401226f, -0.04758276f, -0.00854104f, -0.08929778f, -0.01776963f, 0.03390166f, -0.02210696f, -0.05566616f, 
    0.02703717f, 0.07291952f, 0.03542051f, -0.05867983f, -0.05311963f, 0.02995138f, -0.08418461f, -0.04999705f, 
    -0.04805413f, -0.05140826f, 0.02092158f, -0.01088976f, 0.01911277f, -0.04049550f, -0.03605926f, 0.03731468f, 
    0.02936194f, -0.00872081f, -0.02706644f, -0.03382401f, 0.00538742f, 0.04829138f, 0.04224026f, 0.00731939f, 
    0.04306104f, 0.05710147f, -0.04053478f, -0.08851037f, -0.06107780f, 0.04030421f, 0.02076046f, -0.08424494f, 
    -0.08010466f, -0.08821201f, -0.01896214f, 0.02233961f, -0.07106407f, -0.03860341f, 0.06689119f, -0.01338208f, 
    -0.00915984f, -0.03018014f, 0.02640411f, -0.00952067f, -0.09159627f, -0.02938971f, -0.08659919f, -0.00672084f, 
    0.04915763f, -0.08079374f, 0.00614304f, 0.05476591f, 0.01681215f, 0.03409987f, 0.01117820f, -0.06227725f, 
    -0.01482577f, -0.07909122f, -0.08846647f, 0.02876927f, -0.02213374f, 0.05171122f, -0.02796613f, -0.03388473f, 
    -0.07507247f, 0.04333385f, 0.03278557f, -0.01927292f, 0.05453759f, -0.02167945f, -0.04944797f, -0.05486739f, 
    0.05233452f, -0.07467408f, -0.03687251f, -0.01833772f, -0.06266709f, -0.01121810f, 0.04704299f, 0.05356398f, 
    0.05813694f, 0.07407147f, 0.07010711f, -0.07734175f, -0.05652131f, 0.01653737f, 0.04212419f, -0.01308576f, 
    0.04125556f, -0.06359158f, -0.08888528f, 0.04907014f, -0.04790463f, -0.06295612f, -0.05745493f, 0.06412915f, 
    0.06906022f, -0.08082189f, 0.01591759f, -0.04925866f, 0.03758195f, 0.07079272f, 0.06012072f, -0.08817347f, 
    -0.02125316f, -0.01060569f, 0.00456514f, 0.02902993f, -0.02311025f, -0.02095876f, 0.02878053f, -0.07730395f, 
    0.01675382f, -0.02428759f, 0.06471431f, -0.04518462f, -0.08049128f, 0.00563449f, -0.07465182f, -0.00578807f, 
    -0.03495760f, 0.07351790f, -0.01205580f, -0.01420670f, 0.07315698f, -0.05621088f, -0.08750200f, -0.01256714f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.00245226f, -0.01251692f, -0.11080386f, 0.14645083f, -0.08605433f, -0.19526479f, 0.12870263f, 0.30850554f, 
    0.38078114f, 0.18519160f, -0.03681136f, -0.00656313f, 0.09765208f, 0.13870594f, 0.10006474f, 0.07270613f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.16153930f, 0.24057806f, 0.24158524f, 0.04809657f, -0.14643994f, 0.26240733f, 0.05920159f, -0.24842592f, 
    -0.46999648f, 0.29613733f, 0.19145806f, -0.09396928f, -0.66714710f, -0.11556450f, 0.14002712f, 0.08489584f, 
    0.22310254f, -0.22258848f, -0.09964757f, 0.20424850f, -0.17716767f, -0.24322988f, -0.03274157f, -0.47382939f, 
    -0.31986418f, 0.10611877f, -0.31412259f, -0.01613423f, -0.15920599f, 0.47488752f, -0.12664165f, -0.15509909f, 
    0.08211472f, -0.21863371f, -0.24163257f, -0.02867357f, -0.20240930f, 0.34492016f, -0.57100683f, 0.26021859f, 
    0.32380229f, -0.16236833f, 0.34189287f, -0.14598078f, 0.41387159f, 0.16951320f, 0.31276956f, 0.07892194f, 
    -0.15487827f, -0.21641555f, -0.30929166f, -0.21611246f, -0.00384337f, 0.38219389f, 0.12828346f, 0.22944662f, 
    0.43087223f, -0.35654169f, 0.11420335f, 0.03350492f, -0.31862018f, 0.34754363f, 0.19230203f, -0.19358727f, 
    0.14750111f, 0.03620547f, -0.10809419f, 0.23150465f, 0.10737509f, -0.27375323f, -0.18538280f, -0.00626737f, 
    0.24395643f, -0.17490789f, 0.23256491f, -0.05873420f, -0.16109952f, 0.21366911f, 0.69109011f, 0.18747665f, 
    0.16369224f, -0.00626400f, -0.17192914f, -0.14158967f, -0.01519823f, -0.00439090f, -0.18054457f, -0.16677940f, 
    -0.23620930f, 0.07606087f, 0.03032722f, -0.04450005f, -0.17182714f, 0.06062291f, -0.11828285f, -0.10539138f, 
    0.03141873f, -0.13612667f, 0.05088397f, 0.43722808f, -0.00863944f, -0.47014713f, -0.15547816f, -0.26501665f, 
    -0.20694803f, 0.36272082f, 0.56892329f, -0.04966599f, 0.16060382f, -0.16076967f, 0.28904182f, -0.09714442f, 
    0.11639667f, 0.03183144f, 0.18260166f, -0.06298348f, -0.16357267f, 0.10322990f, -0.07525808f, 0.06468432f, 
    -0.40970567f, -0.26567701f, -0.21222074f, 0.03124671f, 0.27817446f, 0.52836490f, -0.18404366f, 0.01828355f, 
    0.23335509f, 0.10754073f, 0.01674162f, 0.48415160f, 0.04018741f, 0.16217722f, -0.10681395f, -0.21562107f, 
    0.31652495f, 0.34259656f, -0.03548959f, -0.23196591f, -0.44060290f, -0.20279768f, -0.40223601f, 0.09234583f, 
    -0.08988366f, 0.03166913f, -0.06687136f, 0.13523442f, 0.15546268f, 0.00002097f, 0.22727609f, 0.12519759f, 
    -0.03527681f, -0.41018274f, -0.04664148f, -0.13142191f, 0.05915137f, 0.20546772f, 0.04530498f, 0.07440788f, 
    -0.06803137f, 0.11741191f, -0.14607340f, 0.01432786f, -0.07326068f, -0.15684718f, 0.03351923f, 0.05404499f, 
    -0.02713682f, -0.31106490f, -0.30531865f, 0.22903362f, 0.00344291f, 0.70580131f, 0.67871535f, -0.06375429f, 
    0.08336098f, 0.00408879f, -0.09275616f, -0.13588747f, -0.06378479f, -0.44565636f, 0.36635873f, -0.46006626f, 
    -0.25298250f, -0.00826361f, -0.02527276f, 0.08783734f, 0.21431386f, 0.19679034f, 0.64816713f, 0.22354411f, 
    -0.02822191f, 0.17759365f, -0.16268700f, 0.10295320f, -0.24524155f, -0.17514792f, -0.23611158f, 0.01120892f, 
    -0.10008651f, -0.16419324f, -0.14225936f, -0.19323331f, 0.16753793f, -0.15692049f, 0.01507497f, -0.04075950f, 
    -0.04920010f, 0.05912136f, -0.40199524f, 0.22634417f, -0.20996842f, 0.26382378f, -0.13840999f, -0.17329153f, 
    -0.19238415f, 0.34965658f, 0.06637798f, -0.19952172f, 0.12518488f, 0.00240336f, 0.72772455f, -0.13610309f, 
    0.15210299f, -0.10099838f, -0.26347503f, 0.10265107f, 0.21242060f, -0.31202677f, 0.27315453f, 0.26807988f, 
    0.35650378f, -0.14184934f, 0.09120508f, -0.05687028f, -0.40231663f, 0.11289658f, 0.31267962f, -0.11528280f, 
    0.11375228f, -0.15226649f, -0.07821795f, 0.13520133f, 0.12010213f, -0.06385969f, -0.05401362f, -0.20988926f, 
    -0.23105231f, 0.16369548f, -0.19890229f, -0.07721844f, -0.25740233f, -0.28184026f, 0.04858349f, -0.04171812f, 
    -0.02550760f, 0.05281854f, -0.28461224f, 0.46332830f, -0.18048738f, 0.24187487f, 0.14921694f, -0.26600441f, 
    0.41328576f, 0.13709882f, -0.16880579f, -0.07960796f, -0.07351622f, -0.23481262f, 0.33005446f, -0.07913628f, 
    -0.08805648f, 0.14321369f, -0.12285301f, 0.26528615f, 0.02290288f, -0.62362140f, 0.05466679f, -0.44645423f, 
    0.03294983f, 0.31625259f, 0.45560265f, -0.19506927f, 0.33260974f, -0.05630638f, 0.19463424f, -0.05768444f, 
    0.03384971f, -0.09273237f, -0.02946878f, 0.10011637f, -0.08272321f, 0.11969763f, -0.31581229f, 0.07301787f, 
    0.31142175f, 0.10305672f, -0.11839028f, 0.00476432f, 0.28428459f, -0.15895642f, 0.26181403f, 0.11880004f, 
    0.08011216f, 0.14229521f, 0.30844548f, -0.05695781f, 0.21263161f, -0.05002417f, 0.44808602f, 0.09698674f, 
    -0.39565724f, 0.26111197f, -0.02589164f, -0.06075495f, -0.26849046f, -0.17847718f, -0.06924345f, -0.18286458f, 
    0.03512147f, -0.03068393f, 0.07693061f, 0.21228363f, -0.22597943f, 0.09840146f, -0.15837035f, -0.13025430f, 
    0.19433159f, -0.04612705f, -0.17069323f, 0.09775811f, 0.03978021f, -1.20560837f, 0.24800120f, -0.07302845f, 
    0.16007245f, 0.10275327f, 0.35658160f, -0.37807900f, 0.19011205f, -0.10016853f, 0.29205358f, -0.08945529f, 
    0.04586165f, -0.07379241f, 0.40822056f, 0.18239503f, -0.04690126f, 0.16000839f, 0.24934128f, -0.00751960f, 
    -0.18621808f, -0.02462633f, -0.05362979f, 0.15052012f, -0.26031050f, -0.31686494f, 0.31056643f, 0.25817001f, 
    0.17361620f, 0.06657042f, -0.27243969f, -0.15353146f, -0.06051207f, -0.13440938f, 0.11898368f, 0.22489633f, 
    0.06256285f, -0.06357035f, -0.11065260f, -0.10380229f, 0.03382048f, 0.00596318f, -0.03467223f, -0.06996360f, 
    -0.23629916f, -0.17580065f, -0.03918427f, 0.17765760f, -0.24797899f, -0.19198996f, 0.02647182f, -0.06573331f, 
    -0.10782692f, 0.20233953f, -0.11922884f, -0.16560958f, -0.20124847f, -0.25170970f, 0.11813579f, -0.21241897f, 
    -0.15615727f, -0.05192440f, 0.22517295f, -0.08401662f, -0.14310586f, -0.15991971f, -0.08742106f, 0.02739900f, 
    0.20019841f, -0.10148022f, -0.14848687f, 0.31957078f, 0.00320850f, 0.47025350f, -0.42244592f, -0.02495334f, 
    0.36724326f, 0.03369812f, -0.23450503f, 0.09213039f, -0.29185104f, 0.18060434f, -0.07769251f, 0.18740910f, 
    0.17133148f, 0.13181236f, -0.30203584f, -0.15264609f, 0.17730419f, 0.14477995f, 0.33903849f, 0.22450946f, 
    0.53117460f, -0.07436098f, -0.03407068f, -0.23959690f, 0.07425442f, 0.17904960f, -0.43417558f, 0.24792835f, 
    0.23543957f, 0.17961697f, 0.13956210f, -0.29814363f, 0.04919515f, 0.12245847f, -0.25208643f, 0.22376049f, 
    0.12527487f, 0.11883768f, -0.20865513f, 0.23178104f, 0.26276845f, -0.00919955f, -0.13066705f, 0.12575145f, 
    -0.03097481f, -0.00513527f, 0.15235791f, -0.10319474f, 0.25014195f, 0.23519051f, -0.06021003f, -0.29741517f, 
    -0.32145008f, 0.02649878f, -0.07633621f, 0.10464027f, 0.53652233f, 0.51792717f, -0.33183128f, 0.20897983f, 
    0.22125915f, -0.15315196f, -0.48085609f, 0.06250996f, 0.07359979f, -0.10708082f, 0.12659197f, -0.38996431f, 
    -0.05350272f, -0.22368117f, -0.17995423f, 0.20086397f, 0.38401306f, 0.46000990f, 0.30803171f, -0.22551230f, 
    0.04955685f, -0.03836680f, -0.15160492f, 0.07015292f, 0.07475684f, -0.20183221f, -0.12591828f, 0.05300935f, 
    -0.10957594f, 0.00843528f, -0.07492407f, 0.10292092f, 0.03163976f, -0.14228959f, -0.16923222f, -0.08146068f, 
    0.13037053f, 0.15488951f, -0.25920552f, 0.21223797f, -0.06178849f, 0.24548328f, -0.35646451f, -0.05523703f, 
    -0.18700314f, 0.58995670f, 0.08784145f, 0.07759762f, -0.15799388f, -0.27395135f, 0.60579771f, 0.18198547f, 
    0.14295343f, 0.11263531f, 0.04428706f, 0.09121741f, -0.10246986f, -0.02125564f, -0.21567871f, 0.26876333f, 
    0.01184655f, 0.04506440f, 0.10088597f, -0.06183925f, -0.01245045f, -1.02670932f, 0.05557041f, 0.22717959f, 
    0.08296880f, 0.02840716f, -0.09344705f, -0.05617591f, -0.00265264f, -0.29948092f, 0.14129236f, -0.04548433f, 
    0.75678670f, -0.36822072f, 0.21151629f, -0.24804178f, 0.40984488f, 0.39938110f, -0.06514916f, 0.23758730f, 
    0.22672725f, 0.01639573f, -0.17975046f, 0.11742859f, -0.21663499f, -0.16545862f, -0.25131100f, 0.45691517f, 
    0.30738407f, 0.56803042f, 0.18856566f, 0.18930623f, -0.22698709f, -0.04737607f, -0.81058729f, 0.18662901f, 
    -0.16649002f, -0.02787488f, -0.43432245f, -0.08818657f, 0.06881642f, 0.12902577f, 0.47388905f, -0.27978024f, 
    0.06695722f, 0.36658058f, 0.17082839f, -0.21521273f, -0.02592526f, -0.31003061f, 0.45346797f, 0.14772761f, 
    -0.22528346f, 0.19756499f, -0.71457040f, -0.13515879f, -0.24668725f, 0.69281799f, 0.22308856f, -0.21009447f, 
    -0.47768900f, 0.50637543f, 0.15789557f, 0.20929249f, 0.12862279f, 0.04008752f, -0.23884566f, 0.17916003f, 
    -0.07556416f, 0.03714116f, 0.08620276f, 0.05019111f, 0.28036761f, 0.01650502f, -0.22171710f, -0.07519089f, 
    0.34751648f, 0.06191572f, 0.20706050f, -0.19248164f, 0.29531565f, 0.00597815f, -0.07282331f, 0.10626593f, 
    0.00835929f, 0.01272591f, -0.18914099f, 0.25051451f, -0.07231902f, -0.01607424f, -0.11226544f, 0.26176009f, 
    -0.04574494f, 0.38840410f, -0.15405980f, -0.03535376f, -0.29262584f, 0.00138925f, 0.20993084f, -0.18435198f, 
    -0.16961624f, -0.02144768f, -0.20551370f, 0.13922520f, -0.08970380f, 0.13871725f, 0.43022427f, -0.14152865f, 
    0.06231267f, 0.42354670f, -0.06594563f, 0.00659991f, -0.60448837f, -0.23470765f, -0.80172145f, -0.24915156f, 
    -0.18184629f, 0.15637445f, -0.08470634f, -0.21082371f, 0.22476014f, 0.01987964f, -0.21623951f, 0.09268650f, 
    -0.09600261f, 0.00661707f, -0.17097017f, 0.02733687f, -0.06889543f, -0.22488517f, 0.21370789f, -0.19074020f, 
    0.11978495f, 0.04750350f, 0.21225324f, -0.33131614f, 0.17453450f, -0.12492191f, -0.43527150f, 0.19699784f, 
    -0.07920101f, 0.08875372f, -0.58008069f, -0.08814654f, 0.18053025f, -0.18312746f, 0.19347692f, -0.02283418f, 
    0.14190650f, 0.19020388f, 0.21758313f, 0.15591933f, 0.19548415f, -0.20671502f, 0.52171403f, -0.25769705f, 
    0.60931748f, -0.21085009f, -0.21266803f, 0.21425647f, 0.18995722f, -0.16961852f, 0.30113411f, 0.02981046f, 
    0.08862221f, -0.07826144f, 0.26391101f, 0.25673929f, 0.21664417f, -0.41026652f, 0.32252261f, 0.07112624f, 
    -0.19867887f, -0.17212161f, -0.07303785f, -0.20878105f, 0.14524043f, 0.03619199f, 0.29825568f, -0.19146773f, 
    0.16467659f, 0.10183983f, -0.22525343f, 0.26935703f, 0.18345882f, 0.22307070f, 0.39621750f, 0.15921883f, 
    -0.50291622f, -0.04055151f, -0.36219203f, 0.00845846f, 0.69195461f, 0.05447823f, 0.41438532f, 0.13928694f, 
    0.05325103f, 0.15192740f, -0.42654219f, -0.18053262f, 0.07068386f, 0.34154719f, 0.28176495f, -0.92143923f, 
    -0.18936807f, -0.10874899f, -0.31537506f, -0.03682351f, 0.36976129f, 0.34169865f, 0.09149638f, 0.18280557f, 
    -0.09994476f, 0.10611109f, -0.14936280f, -0.27713618f, 0.12706554f, 0.16781341f, 0.19764298f, 0.42210087f, 
    0.33700752f, -0.22069278f, -0.24914202f, 0.05090688f, 0.06107615f, 0.41365895f, -0.16450375f, -0.23314802f, 
    -0.08896211f, -0.03131124f, -0.31185761f, 0.06953708f, 0.19363038f, 0.25084585f, -0.28747192f, 0.18380812f, 
    0.50620586f, 0.09540189f, 0.08600079f, 0.04687886f, -0.16497262f, -0.32196113f, -0.09561714f, 0.23939785f, 
    0.25342259f, 0.23594579f, 0.13356467f, -0.13294387f, -0.12507276f, -0.43162462f, 0.40112242f, -0.04771101f, 
    0.18384078f, -0.12979625f, 0.05600502f, 0.14653133f, 0.58605045f, 0.02796954f, -0.07937603f, 0.04647310f, 
    0.06257203f, 0.10882738f, -0.10108696f, -0.07950711f, 0.12386035f, -0.03918478f, -0.31145370f, 0.14339083f, 
    0.34725994f, 0.18554446f, 0.49561062f, 0.08904578f, 0.36407313f, 0.02280086f, 0.14246349f, 0.17558593f, 
    0.17348376f, 0.16910082f, -0.10339115f, 0.44473785f, -0.19911456f, -0.34694189f, -0.08614440f, -0.33228192f, 
    -0.09663735f, -0.22053121f, -0.18851413f, -0.01124927f, 0.40645361f, 0.49882576f, 0.10245307f, 0.06754196f, 
    -0.06473580f, 0.06166572f, -0.00826888f, -0.03511554f, 0.01925696f, 0.18072699f, 0.32608458f, -0.26768357f, 
    -0.45587376f, -0.37164304f, -0.16586550f, -0.14262660f, 0.23150739f, 0.49362004f, -0.06976004f, 0.04890492f, 
    0.14156590f, -0.17198369f, -0.45159769f, -0.04210017f, -0.07116283f, -0.19242243f, -0.17189747f, 0.22125147f, 
    0.13160369f, 0.15118645f, 0.49210122f, -0.01701850f, 1.04140437f, -0.23410623f, 0.38234919f, 0.07157648f, 
    -0.21814899f, 0.17084302f, 0.19183043f, 0.06274527f, 0.07344786f, -0.63945645f, 0.22025296f, 0.32595307f, 
    0.02125422f, 0.54563189f, 0.11654014f, -0.01359111f, -0.68091780f, -0.08277164f, -0.03439179f, 0.21928300f, 
    -0.05261660f, -0.16844803f, 0.13060310f, -0.21414386f, 0.06207699f, -0.10601890f, 0.05423094f, -0.17728204f, 
    -0.22369334f, -0.23306488f, 0.00693100f, -0.24630612f, -0.08976218f, -0.15005568f, 0.21362384f, -0.10219210f, 
    -0.06555468f, 0.02495745f, 0.05298936f, -0.21366379f, -0.19657528f, -0.16317800f, -0.14963388f, -0.23949358f, 
    -0.11343935f, -0.17599303f, 0.24187621f, 0.21916017f, -0.06145042f, -0.10732490f, 0.01686600f, 0.17384776f, 
    -0.16295153f, -0.01413823f, 0.07447582f, -0.15815493f, -0.15893416f, 0.13834737f, 0.20919600f, 0.19654380f, 
    0.09656499f, -0.09562894f, 0.18844584f, -0.07198209f, -0.36804265f, 0.04143561f, 0.26215249f, 0.22563057f, 
    -0.08336952f, 0.07061238f, 0.33484903f, -0.09984123f, -0.17561494f, -0.28525674f, 0.43560293f, 0.22953093f, 
    -0.36573091f, 0.27305287f, -0.05545386f, 0.18472216f, 0.21968080f, -0.07454345f, 0.22004044f, 0.17503084f, 
    -0.12551835f, 0.10721774f, 0.13531536f, -0.30877659f, -0.05541564f, -0.11094996f, 0.35310054f, 0.15980312f, 
    -0.15806121f, -0.02087222f, 0.29896712f, 0.19695629f, 0.26215881f, -0.07632849f, 0.30075279f, -0.20298609f, 
    0.09720702f, 0.22200920f, -0.35879263f, 0.26901412f, -0.17908980f, -0.24346550f, 0.26389971f, -0.47777063f, 
    0.54469818f, 0.26903474f, -0.08215138f, 0.00043863f, -0.53569293f, 0.11072966f, -0.41279703f, 0.10177644f, 
    0.04081281f, -0.19292897f, 0.05989777f, 0.11068210f, -0.17049617f, -0.26510975f, -0.27864581f, 0.19414799f, 
    0.43600237f, 0.01529463f, -0.28643778f, -0.16501062f, -0.13482942f, 0.18168734f, 0.13110617f, -0.16181909f, 
    0.02566329f, -0.01155302f, -0.37885264f, -0.12209024f, 0.19421543f, 0.41737396f, 0.20069809f, -0.89139420f, 
    0.10423713f, -0.27942091f, -0.12750195f, 0.20974204f, 0.30128139f, 0.43071517f, 0.49364546f, -0.22602922f, 
    0.22801825f, 0.04098304f, -0.21351163f, 0.31147707f, 0.19723806f, -0.10947201f, 0.30604050f, -0.17199492f, 
    -0.07698697f, 0.05538227f, -0.42792842f, 0.08014546f, -1.11050439f, 0.44827557f, 0.33505943f, 0.05381856f, 
    -0.09105977f, 0.21106884f, 0.01899005f, 0.21272714f, -0.22400387f, -0.27589390f, 0.02966902f, 0.27756977f, 
    -0.62109143f, 0.08277493f, -0.06503537f, 0.21918605f, -0.19929074f, 0.34653988f, 0.22612041f, -0.23129730f, 
    -0.19882609f, -0.02440220f, 0.25708789f, 0.28250632f, -0.19415915f, -0.26180312f, 0.47310838f, -0.05550380f, 
    -0.35844830f, -0.15547061f, -0.07013039f, 0.12009309f, -0.11116908f, 0.28702420f, -0.03395767f, -0.23526010f, 
    0.23851977f, 0.22630535f, -0.04030210f, 0.20154344f, -0.14218588f, -0.22146927f, 0.10902268f, 0.08937182f, 
    -0.38092273f, 0.11642697f, -0.16102271f, 0.10281454f, 0.06185841f, 0.16818263f, -0.08128659f, -0.15283962f, 
    -0.17922209f, 0.09522434f, 0.25686908f, -0.01954401f, -0.14048229f, 0.22339635f, -0.07824173f, -0.06998234f, 
    -0.36862892f, -0.44101349f, 0.40639520f, -0.00890373f, 0.04261482f, 0.12077495f, -0.02649211f, 0.02220663f, 
    -0.18934163f, -0.07149691f, 0.07957812f, 0.12241554f, -0.17430238f, -0.05748767f, -0.58092916f, -0.05840066f, 
    -0.00857055f, 0.31561169f, 0.25935635f, 0.10085564f, -0.37759903f, 0.18555379f, -0.24699050f, -0.18466362f, 
    0.23467398f, 0.07902671f, -0.18248372f, 0.12517947f, 0.08440639f, -0.23705524f, 0.43705556f, -0.22405997f, 
    0.24934049f, 0.03411042f, -0.42030752f, -0.20965695f, -0.57389021f, 0.22591163f, -0.61047989f, 0.13425818f, 
    0.10611815f, 0.01571508f, 0.12437353f, 0.24976103f, -0.02954872f, -0.27187294f, -0.32645497f, -0.15559091f, 
    0.16936418f, 0.50820374f, 0.46771333f, 0.14752521f, 0.05734633f, -0.14820246f, 0.05279675f, -0.11702841f, 
    0.25828204f, 0.20061684f, 0.12411524f, -0.15271993f, -0.23187433f, 0.08687786f, -0.10957361f, 0.09171524f, 
    -0.67799246f, 0.32299939f, 0.20956008f, 0.04871739f, 0.82721019f, 0.04261213f, -0.01227927f, -0.23979695f, 
    0.11214355f, -0.21749535f, -0.22477075f, 0.34856799f, -0.12582316f, -0.70255947f, 0.38166392f, 0.22312461f, 
    0.31540796f, 0.32362595f, 0.23895504f, -0.00727803f, -0.10041901f, -0.26355323f, -0.07338502f, -0.02841270f, 
    0.09044061f, 0.19318867f, -0.48185655f, 0.03681798f, 0.23778316f, 0.38980603f, -0.11309302f, -0.22373974f, 
    0.39330128f, 0.32738873f, 0.21145552f, 0.06270267f, 0.28494462f, 0.04332179f, -0.70116585f, -0.09381642f, 
    0.17481531f, 0.09841049f, -0.13370359f, -0.39092675f, -0.06006197f, 0.17595759f, 0.28502762f, 0.27094945f, 
    -0.16792165f, 0.13817981f, -0.51292652f, -0.21149015f, 0.37070912f, 0.30115247f, -0.01053524f, -0.05865725f, 
    0.14174676f, 0.14586447f, -0.07871434f, 0.01725879f, 0.00834220f, -0.14873031f, -0.22714746f, 0.09291222f, 
    0.28591403f, 0.47682106f, 0.16770835f, -0.14388745f, -0.00242254f, 0.04153855f, -0.92900962f, -0.09005652f, 
    -0.10922086f, 0.15290713f, 0.26343212f, -0.21033171f, 0.20736982f, 0.16390292f, -0.62094247f, 0.12841068f, 
    -0.28102908f, 0.01925048f, 0.04276767f, 0.18346930f, -0.16760834f, 0.31754151f, 0.05501109f, 0.17084041f, 
    -0.24535623f, 0.12601393f, -0.12908149f, -0.32454005f, 0.06314688f, -0.42796400f, 0.31570801f, 0.04275545f, 
    0.68395352f, 0.03944205f, 0.58497858f, 0.15775491f, -0.35103455f, 0.10842630f, 0.30874690f, -0.06132899f, 
    -0.16994992f, 0.19238327f, 0.06444003f, -0.19906726f, -0.11690237f, -0.00525572f, -0.04286743f, 0.12024430f, 
    0.35320011f, -0.30182931f, 0.01300793f, 0.20715016f, -0.20817572f, 0.36919168f, -0.02471473f, -0.04795724f, 
    0.06588477f, 0.06891745f, 0.10862128f, 0.00916387f, 0.04748172f, 0.02803171f, -0.43259147f, 0.06323354f, 
    -0.26595184f, -0.82219321f, 0.42942286f, -0.14962691f, 0.27465236f, 0.15012878f, -0.46711248f, 0.13652018f, 
    0.11689066f, 0.19332869f, -0.04001545f, 0.02509592f, 0.00589831f, 0.31648406f, -0.28699699f, -0.26457682f, 
    -0.44151074f, 0.35190812f, 0.05324473f, -0.12103338f, 0.55389500f, -0.04886597f, 0.45813352f, 0.03185688f, 
    0.03352362f, 0.00299356f, -0.01717426f, -0.22234111f, 0.18137094f, 0.32077628f, 0.15235940f, -0.15674005f, 
    0.75243348f, -0.09909368f, 0.25514048f, -0.19355780f, -0.11493123f, 0.06220533f, 0.07117273f, 0.14323735f, 
    0.12222816f, 0.01715987f, 0.03422024f, -0.18644169f, -0.12873213f, 0.02917776f, 0.51645446f, 0.01270766f, 
    0.41942418f, -0.14211218f, 0.12792659f, -0.21652734f, 0.42559457f, -0.13980994f, 0.25188854f, 0.16249284f, 
    0.22555353f, -0.10275444f, -0.24340910f, 0.17773104f, 0.19535773f, -0.02790695f, 0.14185001f, 0.36103517f, 
    0.48160732f, -0.18936381f, -0.12320866f, 0.10014250f, -0.82013965f, 0.13651921f, 0.17981760f, 0.08298287f, 
    -0.25855333f, 0.06030935f, -0.06505876f, -0.14031975f, 0.26038003f, -0.54758704f, -0.01597621f, 0.24919146f, 
    0.22906981f, 0.29624942f, 0.37663290f, 0.08029085f, 0.66657406f, -0.00309155f, -0.30238226f, 0.13677447f, 
    0.18769044f, -0.05711187f, -0.06646363f, 0.08850173f, 0.01390271f, 0.25556555f, 0.09941510f, -0.06917776f, 
    0.06708071f, 0.20134239f, -0.21700069f, -0.07088763f, -0.37985295f, -0.01444168f, -0.94812882f, 0.18326363f, 
    -0.18039514f, 0.04597705f, 0.32057202f, -0.13550596f, -0.19951607f, -0.35998651f, 0.14799426f, 0.13878565f, 
    0.27488753f, -0.24678889f, 0.53545195f, -0.23205984f, -0.14737268f, 0.17744507f, -0.23422590f, 0.05169702f, 
    0.21361929f, -0.09801965f, -0.14672314f, 0.25144082f, 0.15578690f, 0.05694358f, -0.21467519f, -0.00802506f, 
    -0.06949455f, 0.05344572f, 0.15148079f, 0.06418111f, 0.44360024f, 0.06706418f, 0.17378467f, -0.14841408f, 
    0.02003357f, -0.09774914f, 0.20633112f, -0.04515326f, 0.21256453f, 0.05167146f, 0.23437981f, 0.18230920f, 
    0.03386091f, -0.40662414f, -0.66371667f, 0.15505569f, -0.18413049f, 0.20407100f, -0.35459268f, 0.04579780f, 
    0.04396014f, 0.08341858f, -0.48436445f, 0.28250888f, -0.15387724f, -0.05147570f, -0.25082839f, -0.57442373f, 
    0.62394327f, -0.03495695f, 0.35328382f, -0.07043428f, 0.27363268f, 0.49678758f, -0.22544923f, 0.05759113f, 
    0.24525248f, 0.07968894f, -0.36995161f, -0.13310683f, -0.04918514f, 0.03877830f, 0.30521479f, -0.82611185f, 
    -0.17009337f, 0.06342375f, 0.45058671f, -0.11801916f, 0.65172756f, 0.13560346f, 0.53879172f, -0.02802840f, 
    -0.07272009f, 0.13685694f, 0.19342978f, 0.01276093f, 0.02705328f, -0.23324393f, 0.02041937f, 0.21102493f, 
    -0.33880952f, 0.11453132f, -0.25089344f, -0.14712054f, 0.32256359f, 0.09912124f, -0.62776297f, -0.18522654f, 
    -0.18407451f, -0.15103205f, -0.11212046f, -0.08318683f, -0.21299239f, -0.24662194f, -0.07629778f, 0.08896447f, 
    0.79600930f, 0.51624501f, -0.16764031f, -0.12400794f, -0.50113481f, 0.06028444f, 0.29164654f, -0.10904930f, 
    -0.20078342f, -0.15962629f, 0.05701535f, -0.10974195f, 0.15909594f, 0.02859805f, 0.25095072f, -0.06170489f, 
    -0.37803328f, -0.01460984f, -0.60556358f, 0.06223752f, -0.89404994f, 0.60048473f, -0.68724543f, -0.03284532f, 
    -0.14377730f, -0.06607074f, 0.06530793f, 0.21329701f, 0.17021728f, -0.28368536f, -0.16408855f, -0.03592183f, 
    0.52500814f, 0.32687125f, -0.11901447f, -0.01634565f, -0.77635157f, -0.03975864f, 0.13638423f, -0.07453097f, 
    -0.14284474f, -0.10156228f, -0.64557338f, 0.33545536f, -0.20733017f, 0.00287742f, -0.35081270f, -0.53519738f, 
    -0.02690792f, 0.54781067f, 0.45423770f, 0.07792855f, -0.19116770f, 0.23664534f, -0.13791169f, -0.14474763f, 
    -0.08259859f, -0.20255440f, 0.01933081f, 0.41090846f, 0.19554575f, -0.53507644f, 0.34367183f, 0.26704735f, 
    -0.50735760f, 0.13790706f, -0.18070358f, -0.06436349f, -0.30830291f, 0.18949777f, 0.06999847f, -0.19857071f, 
    0.23494455f, 0.11460378f, -0.15587014f, -0.32907629f, 0.16649294f, -0.14403391f, 0.32208940f, 0.28399280f, 
    0.56360769f, 0.12491431f, -0.43663824f, -0.15451510f, 0.16690299f, 0.19010529f, 0.58768320f, 0.15856032f, 
    0.19623242f, 0.16949321f, -0.15589049f, 0.38472441f, -0.04615805f, 0.12229999f, -0.05359870f, 0.01726131f, 
    0.07657950f, 0.48125422f, 0.18124107f, 0.18524563f, -0.28601581f, -0.29017076f, 0.18415606f, -0.09588643f, 
    -0.08891559f, -0.18542038f, -0.28304058f, 0.20203379f, 0.17344657f, -0.53519750f, -0.07395728f, -0.00605670f, 
    0.49878442f, 0.63054281f, 0.48874819f, 0.11732413f, -0.18861645f, -0.10793856f, -0.30920261f, 0.18301859f, 
    -0.20378533f, -0.08864848f, 0.18311878f, 0.42159069f, -0.19510826f, -0.11985941f, -0.01834844f, -0.16240324f, 
    -0.40541577f, 0.28057322f, 0.25282595f, 0.02874775f, 0.23827590f, -0.18189596f, 0.20233013f, -0.18710977f, 
    -0.04292084f, -0.09312764f, 0.18401909f, -0.19263454f, -0.23703413f, -0.22835483f, 0.23817734f, 0.33873519f, 
    -0.10376006f, 0.18970339f, 0.23256440f, 0.10820463f, 0.50659168f, -0.09249939f, -0.52240044f, 0.21503736f, 
    0.18142080f, -0.17977984f, -0.27429169f, 0.14833248f, 0.03120114f, 0.34289467f, -0.22850041f, -0.37607226f, 
    -0.01724068f, 0.47100669f, 0.19087107f, -0.23052873f, 0.15170610f, 0.06737754f, -0.42544121f, -0.03461258f, 
    -0.18109921f, -0.01865807f, 0.17493309f, -0.42065668f, 0.19742328f, -0.19905195f, -0.18206517f, -0.08809617f, 
    0.30859855f, -0.29054797f, 0.32567346f, -0.22316203f, 0.39624172f, 0.00969085f, 0.32893917f, 0.21947971f, 
    0.17462212f, -0.07632106f, -0.34397498f, -0.19459969f, 0.16947545f, 0.37441522f, 0.31143937f, -0.12999316f, 
    -0.48175225f, -0.18627378f, 0.06235411f, 0.03504878f, 0.17863168f, 0.46165749f, 0.55034220f, 0.14014161f, 
    -0.13590828f, 0.00858718f, -0.08797767f, -0.06770758f, 0.22113076f, -0.17279550f, 0.07178026f, -0.15130259f, 
    0.03146867f, 0.18792370f, 0.53723621f, 0.03575048f, 0.38716972f, -0.09251428f, -0.49130517f, 0.16445288f, 
    0.19242899f, -0.12857869f, 0.07936666f, -0.47048798f, -0.11180443f, -0.05764740f, 0.29343557f, 0.23547153f, 
    0.48105520f, 0.10911062f, 0.11207422f, 0.01349953f, 0.11702735f, -0.05912277f, -0.14912510f, 0.21876779f, 
    -0.15384546f, 0.07998005f, 0.08213392f, -0.03579310f, -0.13105167f, -0.23911852f, 0.25380284f, -0.23226801f, 
    -0.18239482f, 0.07822109f, -0.53395104f, -0.13929379f, -0.68210977f, 0.46456480f, -0.65758711f, 0.24677601f, 
    0.10388263f, 0.19119862f, -0.49325150f, 0.13130468f, -0.04140214f, -0.14511108f, -0.20013176f, -0.12463350f, 
    0.63266659f, 0.06927779f, 0.46036729f, -0.18677333f, -0.49869448f, 0.24126275f, 0.71304262f, -0.03542182f, 
    0.05922493f, 0.23143800f, -0.09304300f, 0.21938643f, 0.14482081f, 0.21507198f, 0.17307889f, -0.09409370f, 
    -0.44014269f, 0.04621141f, 0.04555849f, 0.04981276f, -0.01929879f, -0.00128257f, 0.61879033f, -0.15153311f, 
    -0.12358305f, 0.13605081f, 0.12286662f, 0.00866001f, 0.08618551f, 0.01766933f, 0.25439847f, 0.12575632f, 
    -0.04011302f, 0.35568562f, -0.15210798f, 0.08972254f, -0.38734868f, -0.12937029f, -0.66426063f, 0.18722197f, 
    0.11109958f, 0.05275863f, -0.02699024f, -0.23487130f, 0.16289283f, 0.47673085f, -0.66588670f, 0.13605589f, 
    -0.29778323f, -0.03500889f, 0.07685563f, -0.10676547f, 0.30750689f, 0.28224829f, 0.07726651f, -0.09336394f, 
    -0.09712538f, 0.18351683f, -0.08801662f, -0.04880730f, -0.12565368f, -0.04253450f, -0.23478383f, 0.18584894f, 
    -0.13742410f, 0.01018031f, -0.03495582f, 0.09168407f, -0.18087785f, -0.11095393f, -0.17942341f, -0.13118157f, 
    0.16326988f, 0.19311607f, -0.13580719f, -0.18124259f, -0.06727916f, -0.15646379f, -0.14769834f, -0.12214652f, 
    -0.07180852f, -0.04155087f, -0.14639746f, -0.11826596f, 0.10999894f, 0.12957510f, -0.25936967f, -0.24486691f, 
    -0.12056011f, 0.00711338f, -0.62055534f, 0.21958983f, -0.07887882f, -0.05481743f, 0.32001966f, -0.45002264f, 
    0.04425103f, 0.68509585f, 0.38771972f, -0.00908826f, -0.21513399f, -0.28874868f, 0.20116483f, -0.04667603f, 
    -0.07031870f, -0.19246730f, -0.04650765f, 0.49043843f, -0.13894472f, 0.01019548f, -0.26327312f, -0.42873123f, 
    -0.28099149f, -0.22879383f, 0.24544114f, 0.19606495f, -0.35203728f, 0.29103938f, 0.52590746f, -0.01140315f, 
    -0.07025127f, -0.23250395f, -0.73549122f, 0.19399302f, 0.03679346f, 0.08511046f, -0.32569158f, 0.02909796f, 
    0.76153123f, 0.42896512f, 0.25575584f, -0.19558960f, -0.55136424f, -0.02491368f, -0.00657786f, -0.19247594f, 
    0.16418427f, -0.20506892f, 0.07767837f, 0.03232260f, -0.17043768f, 0.11389955f, -0.15569815f, -0.06430244f, 
    -0.14530699f, -0.18837379f, -0.11648633f, -0.04802462f, -0.53542334f, 0.02915757f, 0.65984696f, 0.10189050f, 
    -0.16055240f, 0.15244217f, -0.43723649f, 0.11225986f, -0.08482089f, 0.37604374f, 0.43250418f, 0.18904686f, 
    0.05140911f, 0.14792827f, -0.38046983f, -0.14921062f, 0.21474068f, 0.02568235f, -0.69072300f, -0.10441283f, 
    0.22812070f, -0.04956638f, 0.04959588f, 0.03457224f, -0.03790044f, 0.04191758f, -0.29477465f, 0.21431656f, 
    -0.05805419f, -0.14244938f, 0.13119394f, -0.17075816f, -0.41546005f, 0.27519459f, 0.19895451f, -0.00682742f, 
    0.11288563f, -0.16917165f, 0.15785006f, 0.35186782f, 0.12323791f, -0.43426302f, 0.27432385f, 0.03031651f, 
    -0.25671694f, -0.07321776f, -0.06609330f, -0.04962897f, -0.29307178f, 0.32113430f, -0.08048143f, 0.14936697f, 
    -0.16188501f, -0.10618486f, -0.21714380f, 0.02489193f, 0.12397756f, 0.08281884f, 0.08845315f, 0.16575703f, 
    0.58584803f, -0.21154420f, 0.02865393f, -0.12872143f, -0.01930142f, 0.17904374f, 0.00063844f, 0.08222176f, 
    0.18819110f, 0.02466740f, -0.02139381f, 0.11562595f, -0.11449661f, 0.10584488f, -0.03764557f, 0.03471547f, 
    0.59067231f, 0.00880831f, 0.20304613f, 0.15002047f, 0.14126369f, -0.09847376f, -0.47566372f, 0.07730503f, 
    -0.16559777f, -0.03043880f, 0.21088590f, -0.10082050f, -0.12850305f, 0.34679142f, -0.18035090f, -0.16199088f, 
    0.03950510f, 0.19854964f, -0.28321573f, -0.03183381f, -0.62332809f, 0.27143088f, -0.34765542f, -0.13621090f, 
    0.18247059f, -0.01965414f, -0.44973755f, 0.31505331f, -0.22396690f, 0.19671221f, 0.24705218f, -0.45221666f, 
    -0.29490533f, 0.10286454f, 0.14122447f, -0.20629919f, 0.01549395f, 0.00143200f, 0.56114954f, 0.23925924f, 
    -0.12244010f, 0.06974013f, -0.08226471f, 0.12843788f, -0.14044717f, -0.47106341f, 0.25323907f, 0.23438300f, 
    -0.07857532f, -0.00239696f, -0.11893804f, 0.10418196f, 0.34979081f, 0.27811024f, -0.81195194f, 0.18142913f, 
    -0.21507299f, 0.22258852f, -0.44016996f, -0.24711132f, 0.16600873f, 0.12122246f, 0.37444144f, 0.33410531f, 
    0.19392799f, -0.12642142f, -0.16012987f, 0.07616544f, -0.17048989f, 0.06349747f, 0.43492997f, -0.23507522f, 
    -0.15486638f, -0.19416153f, 0.19225226f, 0.04509357f, -0.00226716f, -0.34562838f, -0.00143810f, 0.17167099f, 
    0.11953262f, -0.31638676f, 0.25064823f, 0.01959860f, 0.00585403f, 0.21346541f, -0.04088767f, -0.14648378f, 
    0.05917532f, -0.03606091f, -0.42565894f, -0.23575789f, -0.16205087f, -0.14675170f, 0.33102688f, -0.19733180f, 
    0.51024675f, 0.03255590f, 0.40567979f, 0.17129916f, -0.05910167f, -0.02658505f, 0.28167605f, -0.03757490f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.29940787f, -0.07710586f, 0.01737043f, 0.17081347f, -0.17031932f, -0.19807981f, 0.17337528f, 0.25717163f, 
    0.44495460f, -0.15675505f, 0.08538241f, 0.23075131f, -0.13007808f, 0.09995077f, -0.28006029f, 0.07591791f, 
    0.30712768f, -0.09455844f, 0.02815209f, 0.31379819f, -0.10136895f, -0.27696306f, -0.22210166f, -0.17486259f, 
    -0.00399890f, 0.08493879f, 0.08122883f, -0.29543230f, 0.12712134f, -0.19405700f, 0.24381787f, -0.23929369f, 
    -0.55617869f, -0.13563915f, -0.12960783f, 0.41675189f, 0.32303908f, -0.46924049f, 0.16273414f, 0.42591253f, 
    -0.19591948f, 0.08012470f, 0.04320193f, 0.09047258f, -0.01345046f, 0.36181423f, -0.16294059f, 0.04000695f, 
    0.29486391f, -0.21983284f, 0.06150097f, 0.28744537f, 0.13184328f, 0.50578380f, 0.02276919f, -0.06333494f, 
    -0.26833886f, 0.10574409f, 0.01289219f, 0.16413534f, -0.07282107f, -0.30678451f, -0.16672671f, 0.22746898f, 
    0.29645365f, 0.62101632f, -0.35504818f, 0.21862189f, 0.19383168f, 0.18228470f, 0.20304789f, 0.32507852f, 
    0.33209890f, 0.20304045f, 0.30723813f, -0.21615040f, 0.07707907f, -0.05945330f, -0.07873724f, 0.21103333f, 
    0.00902558f, -0.03506612f, 0.28253254f, -0.01779496f, 0.05023338f, -0.03985054f, -0.24317774f, 0.09012021f, 
    0.48096183f, 0.05042931f, 0.32410407f, 0.20104527f, 0.03273550f, 0.24895570f, 0.34929678f, 0.33708218f, 
    -0.17040375f, 0.18453439f, 0.27408987f, 0.32635075f, -0.32906649f, -0.00583632f, 0.36074820f, -0.32031539f, 
    0.17805794f, -0.11164007f, -0.20969518f, 0.04451900f, 0.08518430f, 0.05830552f, -0.11033101f, -0.24648570f, 
    -0.11667939f, 0.12516735f, 0.42301700f, 0.26846287f, -0.32237974f, 0.39394948f, 0.14577091f, 0.57570183f, 
    -0.08053331f, 0.15587434f, 0.23517415f, 0.45575109f, 0.39954820f, 0.12262592f, -0.13577643f, 0.06737317f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.07385489f, 0.19189772f, -0.16752793f, 0.40014234f, 0.09890521f, -0.04165396f, -0.58093345f, 0.24060200f, 
    -0.42066950f, 0.04393913f, 0.39277330f, 0.17081231f, 0.06367973f, -0.34993747f, -0.09198056f, 0.00675182f, 
    -0.47745842f, -0.56544679f, -0.07370554f, -0.09833524f, 0.18645462f, 0.09955807f, -0.42997888f, 0.03438284f, 
    0.06683020f, 0.08110227f, 0.07373428f, -0.00329696f, 0.16942653f, 0.29984567f, -0.03122404f, 0.40214536f, 
    0.16341433f, 0.55626464f, -0.16190137f, -0.34008670f, 0.03676596f, -0.08790144f, -0.16901658f, -0.53500283f, 
    -0.04961478f, -0.12887028f, -0.42253354f, -0.18623173f, -0.06792717f, 0.36411911f, 0.35213414f, 0.01319486f, 
    -0.03757160f, -0.30556712f, 0.08945395f, 0.23890273f, -0.59047943f, -0.24057211f, -0.03586733f, 0.08097368f, 
    0.04354877f, -0.17307906f, -0.10328410f, -0.16548856f, -0.05912209f, 0.45058423f, 0.12423837f, 0.06902144f, 
    -0.02038423f, -0.02290533f, 0.00943562f, -0.01550425f, -0.05469717f, -0.48840186f, -0.08846495f, -1.15782762f, 
    0.04285176f, 0.16690822f, -0.28014714f, -0.00484583f, 0.13377433f, 0.29086488f, -0.46028706f, 0.04201234f, 
    0.12879360f, -0.26107892f, 0.08934992f, -0.27663508f, 0.09924100f, 0.00108879f, -0.11663933f, 0.34339404f, 
    0.28722870f, 0.23867005f, -0.10149345f, -0.11093356f, 0.26028377f, -0.28752482f, -0.20778543f, -0.00897678f, 
    0.14883530f, -0.42126003f, -0.75759363f, -0.39722341f, -0.53533351f, -0.17815226f, -0.40371069f, 0.25695035f, 
    -0.30074081f, -0.19013309f, 0.13133240f, 0.09292429f, -0.05027951f, -0.11800982f, -0.06344736f, -0.00550121f, 
    -0.03021785f, -1.01302838f, 0.01311835f, -0.44230214f, 0.23683862f, -0.07935818f, 0.11850927f, -0.00999045f, 
    0.05160353f, -0.15723233f, 0.19701520f, -0.12514682f, 0.06365170f, 0.12043201f, -0.08267057f, -0.41254348f, 
    -0.09271892f, 0.11033302f, 0.15763682f, -0.03528444f, -0.23116182f, 0.06358285f, -0.27457345f, 0.09126999f, 
    -0.03787979f, 0.03747590f, 0.09138023f, -0.07840690f, 0.06322297f, -0.40429199f, -0.02071993f, 0.05536040f, 
    -0.20626450f, -0.31235558f, 0.09607551f, -0.01954162f, 0.00353570f, -0.08722146f, 0.10172849f, -0.04281687f, 
    0.02027309f, -0.21352716f, 0.17801078f, 0.06784891f, 0.02586892f, -1.09504414f, -0.01642217f, 0.06804229f, 
    -0.04855083f, 0.19263953f, -0.07664638f, -0.55211043f, -0.38827679f, -0.05785322f, -0.06150359f, 0.17261383f, 
    -0.04785877f, -0.04200451f, 0.10573300f, -0.01467977f, 0.07663079f, -0.95552450f, 0.24537925f, -0.07758950f, 
    0.25931317f, -0.10283659f, 0.06881510f, 0.15317450f, 0.50302386f, -0.03755502f, -0.08765901f, 0.03499906f, 
    -0.08988354f, 0.07969026f, -0.01392538f, 0.17535801f, 0.04416917f, -1.56754827f, 0.23089817f, 0.08915903f, 
    0.11332417f, 0.15990038f, -0.12648639f, -0.20951588f, 0.44038683f, -0.12432641f, 0.04434414f, 0.06670503f, 
    -0.13245916f, 0.25806683f, 0.00342269f, -0.05795688f, -0.30723900f, 0.04977296f, 0.12982987f, 0.02110084f, 
    -0.04056549f, 0.07857001f, -0.02564902f, 0.13483728f, 0.27399594f, 0.04223987f, -0.03413163f, 0.08186173f, 
    -0.27758265f, -1.00710690f, 0.16475974f, 0.03451573f, 0.33114785f, -0.01753879f, -0.65881461f, 0.08820526f, 
    0.35854775f, -0.20874372f, -0.20539577f, -0.07286181f, 0.08220211f, -0.23421100f, 0.61288869f, 0.07647444f, 
    -0.25132143f, 0.05815833f, 0.34025186f, -0.83977014f, -0.21177098f, 0.10648617f, 0.12302464f, -0.04539447f, 
    0.03005159f, -0.58955610f, -0.24898115f, -0.69751859f, 0.02036484f, 0.44429779f, -0.05046395f, 0.05960827f, 
    0.04556438f, -0.01032504f, 0.15842906f, -0.25779042f, 0.30692968f, 0.29296914f, 0.00786643f, -0.21974273f, 
    0.05947947f, -0.91425294f, -0.38977110f, 0.01559726f, -0.38040543f, 0.06386908f, -0.09625783f, -0.37297890f, 
    0.29417360f, -0.10987407f, -1.07371151f, -0.56058884f, 0.03805539f, -0.23609003f, -0.00694253f, -0.06996273f, 
    0.15922220f, -0.03093904f, 0.00033712f, 0.09931993f, 0.10799497f, 0.00878714f, -0.08984125f, 0.06383004f, 
    0.02850974f, -0.05772691f, 0.10749494f, 0.06090887f, -0.54138821f, -0.52340609f, 0.05264749f, -0.27757806f, 
    0.07870376f, -0.12559356f, 0.10129230f, 0.52623534f, 0.37964505f, 0.01543239f, -0.08892617f, 0.79579329f, 
    -0.01749266f, 0.33725074f, 0.16157015f, -0.15087488f, -0.32033345f, 0.06077253f, -0.09883438f, -0.08957663f, 
    0.03868775f, -0.16455594f, -1.34763312f, -0.99487931f, -0.61685044f, 0.19991627f, -0.01506648f, 0.06822899f, 
    0.00858026f, -0.04855232f, -0.04883933f, 0.42628831f, -0.10232803f, -0.63774455f, -0.31338692f, -0.52786762f, 
    -0.17935526f, -0.13077670f, -0.00246164f, -0.00460368f, 0.17920138f, -0.01933216f, -0.33127064f, 0.16802754f, 
    0.37794888f, -0.15507472f, 0.33094940f, 0.24830072f, 0.27455249f, 0.00885874f, -0.20478871f, -0.29698429f, 
    0.06361645f, 0.11292730f, 0.07081030f, -0.04666741f, 0.14842005f, -0.00403507f, -0.22757436f, 0.15710372f, 
    0.12628128f, -0.78611070f, -0.11968067f, 0.37430289f, -0.54464138f, 0.16990115f, 0.34529078f, -0.02370262f, 
    -0.16029729f, 0.10879403f, 0.43947944f, -0.01344268f, -0.05958193f, 0.11539646f, -0.75423610f, -0.58787680f, 
    0.32007304f, 0.20575656f, -0.70866442f, -0.02461410f, -0.21488474f, 0.23273866f, -0.06930713f, -0.05337329f, 
    0.04898755f, 0.35910943f, -0.38950965f, 0.29730326f, 0.20177840f, 0.57010722f, -0.09904099f, -0.07802915f, 
    0.01939925f, 0.06567250f, 0.13043347f, 0.04977151f, 0.22799072f, 0.08912467f, -0.18052647f, 0.23165584f, 
    0.43625173f, 0.14716540f, -1.69484270f, -0.35138977f, -0.30168208f, -0.04522099f, 0.08272650f, 0.08292108f, 
    0.34577158f, -0.22558337f, -0.10617545f, -0.12860756f, 0.08540376f, 0.20383514f, -0.26939312f, -0.04545338f, 
    -0.01482532f, -0.05268449f, -0.19832061f, 0.06093317f, -0.09660451f, -0.28016210f, -0.23467459f, 0.04764997f, 
    -0.05063549f, 0.19148044f, -0.30827072f, -0.16306107f, 0.12502013f, -0.23836507f, 0.08062372f, 0.64571792f, 
    0.16835484f, -0.80369431f, 0.05140658f, 0.07529126f, 0.52738899f, -0.30657804f, 0.10022251f, 0.23751524f, 
    0.06501461f, -0.23719388f, -0.60729754f, -0.10909314f, 0.06687087f, 0.09367940f, -0.43310586f, -0.42956179f, 
    -0.24898085f, -0.18370566f, -0.05213648f, 0.07591093f, -0.86128932f, -0.00479829f, -0.02231152f, 0.07658169f, 
    -0.28941134f, -0.05681947f, -0.21294487f, -0.01980824f, -0.31579879f, -0.26878965f, 0.09175638f, 0.09974239f, 
    -0.00931855f, 0.14470269f, 0.08386893f, 0.22163460f, -0.02512030f, 0.08563800f, 0.48337618f, -0.29188251f, 
    0.22260363f, -0.04301222f, 0.19865209f, -0.50868344f, -0.56875247f, -0.48573646f, 0.13187842f, 0.49167207f, 
    -1.16415989f, -0.79560459f, -0.29346347f, -0.31938750f, 0.51679885f, -0.34553006f, 0.14521347f, 0.38746387f, 
    0.12332577f, 0.00086502f, 0.21433640f, -0.24782869f, 0.12250404f, -0.05176368f, 0.41237736f, 0.12133106f, 
    -0.49805078f, 0.09369581f, 0.03411238f, 0.19678773f, -0.06531240f, 0.22161971f, -1.00343919f, -0.08967893f, 
    0.08625210f, -0.65165120f, 0.00326339f, -0.10382821f, 0.09490233f, 0.07685804f, -1.17611456f, 0.06018073f, 
    -0.06285562f, 0.26405481f, 0.09775099f, 0.19844429f, -0.02398861f, 0.24689552f, -0.03303344f, 0.03069598f, 
    -0.52314168f, -0.12628089f, 0.13619103f, 0.22724929f, -0.01997798f, -0.37126425f, -0.39968893f, -0.40615982f, 
    -0.10732944f, 0.02043746f, 0.24118033f, 0.17697419f, 0.06420954f, 0.01827604f, -0.19552641f, 0.08770549f, 
    -0.09804495f, 0.16397169f, 0.16107970f, 0.13335757f, -0.01794454f, 0.10439632f, -0.04518703f, -0.03653615f, 
    0.10262220f, -0.00089516f, -0.06360009f, -0.08285938f, -0.25513855f, 0.01283433f, -0.01011034f, -0.04359844f, 
    0.05321547f, 0.01208989f, -0.07889552f, -0.01654315f, 0.12363853f, 0.20742346f, 0.13081267f, -0.66624641f, 
    -0.12558286f, 0.19504973f, -1.01851404f, 0.38167110f, -0.02859629f, 0.12376474f, -0.13686986f, 0.13956445f, 
    0.01590948f, 0.00043390f, 0.10368282f, 0.07812261f, 0.25790837f, 0.27001286f, 0.00879564f, -0.17348449f, 
    0.05644664f, -0.03179852f, 0.01172374f, 0.10923237f, -1.27945161f, -0.27324140f, 0.01863008f, -0.02337385f, 
    0.03645526f, -0.06432297f, 0.04292060f, 0.11865149f, -0.14803472f, 0.18209244f, 0.05301102f, -0.10307905f, 
    0.05120524f, -0.01874010f, 0.30749977f, -0.34129164f, 0.16034801f, -0.20560373f, 0.04545781f, -0.17328693f, 
    -0.36777166f, -0.07822893f, -0.83116943f, 0.09826938f, -0.09408655f, 0.05144885f, 0.11093395f, 0.07599086f, 
    -0.07816643f, 0.21945742f, 0.14683664f, -1.00685084f, -0.38347697f, -0.09104926f, 0.13638854f, -0.39826709f, 
    0.08728479f, 0.28479949f, -0.12127183f, -0.44353971f, -0.08864478f, -0.17983657f, -0.15786503f, 0.03942614f, 
    -0.09447216f, -0.07678232f, -0.45451510f, -0.03377803f, -0.07387996f, -0.08482762f, -1.18652320f, 0.07831370f, 
    -0.87799662f, -0.13275829f, -0.15770364f, 0.04648254f, 0.13652246f, -0.19251387f, 0.25514099f, -0.08207650f, 
    0.03854465f, 0.06359253f, 0.27626929f, -0.57283145f, -0.21496885f, 0.22757155f, -0.02676239f, 0.08762638f, 
    0.06353812f, -0.03945028f, -0.12560895f, 0.30693057f, 0.02893628f, 0.10645960f, -0.01169868f, 0.19059828f, 
    0.01482025f, -0.02411188f, 0.04269515f, -0.01204890f, 0.18145470f, -0.03027237f, 0.09349193f, 0.08110859f, 
    0.02777942f, -0.04664420f, 0.04937863f, -0.02405477f, 0.04715894f, -0.16287762f, 0.11291084f, 0.07868415f, 
    -0.31578141f, 0.01973473f, -0.04898903f, 0.04186849f, -0.23081562f, 0.05144197f, 0.15710300f, -0.07739994f, 
    -0.00190563f, -0.11147215f, -0.19275172f, 0.07017138f, 0.01243479f, -0.10430042f, 0.03046481f, -0.22272138f, 
    -0.02847268f, -0.07907199f, 0.10122564f, -0.37843215f, -0.53980303f, -0.13278806f, 0.08157358f, -0.08826066f, 
    -0.01785615f, -0.33565769f, -0.26217875f, 0.03961667f, -0.02581616f, -0.12073526f, 0.04450197f, -0.17093204f, 
    -0.13206483f, 0.07274986f, -0.11117414f, -0.09819426f, -0.25688750f, 0.21473017f, -0.04640357f, -0.08507128f, 
    0.08524042f, 0.11141574f, 0.07487429f, -0.07256057f, -0.00340319f, -0.13176519f, 0.06161275f, 0.11660066f, 
    0.00194172f, 0.11188061f, -0.00872522f, 0.22298422f, -0.00242304f, 0.07335834f, 0.12577465f, 0.10136882f, 
    -0.61232710f, 0.00479331f, -0.00150111f, 0.13328084f, 0.13239823f, 0.08454963f, 0.16416383f, -0.20665942f, 
    -0.20306000f, -0.14386477f, 0.09598112f, 0.08658062f, -0.39164537f, 0.15841387f, -0.04047114f, -0.75179470f, 
    -0.10138026f, -0.32072896f, 0.14791833f, 0.11004712f, 0.12542488f, 0.17684078f, -0.04826084f, 0.18442923f, 
    -0.02257242f, -0.00273752f, 0.12841423f, 0.03619542f, 0.15819167f, -0.03627279f, -1.34249198f, -0.10074621f, 
    -0.40958411f, 0.07011038f, -0.04817960f, -0.07573531f, 0.02725399f, 0.11143621f, 0.05190835f, -0.00784351f, 
    -0.06127285f, -0.18627101f, 0.16260365f, -1.00018740f, -0.21293420f, -0.32669368f, 0.10047845f, 0.13753213f, 
    -0.01417498f, -0.09340712f, 0.17817892f, -0.03763866f, 0.11635682f, -0.27979532f, 0.01260081f, -0.45666808f, 
    0.03177143f, -0.74450785f, 0.18371627f, 0.43415585f, 0.10801818f, -0.08689736f, -0.20641987f, -0.35643920f, 
    0.14223717f, -0.10999121f, -0.08592572f, -0.41709614f, 0.03365838f, -0.44444367f, 0.21338840f, -0.06390673f, 
    0.01379188f, -0.17686599f, -0.06987878f, -0.24581526f, 0.15124565f, -0.02893516f, -0.06877261f, 0.00637054f, 
    0.05319660f, 0.23094602f, 0.35021767f, -0.07551807f, -0.63591844f, -0.46593258f, -0.02976835f, -0.32388964f, 
    0.00719426f, 0.65392041f, 0.16422784f, -0.30787006f, -0.27745655f, 0.16147824f, -0.06404095f, -0.40038717f, 
    -0.02844366f, -0.24499187f, -0.09079607f, -0.44938174f, -0.58507776f, -0.23367164f, 0.26913226f, 0.32531866f, 
    -0.09045234f, 0.17521699f, -1.52905786f, -0.49094626f, -0.06270178f, 0.00952821f, 0.01093843f, 0.06347195f, 
    0.08304650f, -0.40185323f, -0.10589729f, -0.26131564f, 0.09435822f, -0.14943427f, -1.19211257f, -0.84772789f, 
    -0.82741219f, -1.08158970f, -0.12520736f, 0.12373381f, -0.87801284f, 0.09564513f, -0.37158281f, 0.12543966f, 
    0.19980130f, -0.18407531f, 0.29758674f, -0.03741029f, 0.46473700f, 0.24497089f, 0.07861177f, -0.51456177f, 
    0.46130127f, 0.09571456f, 0.26029825f, 0.15287420f, 0.14026731f, 0.30654722f, -0.01588408f, -0.12739095f, 
    0.07487775f, -0.65636766f, -0.31175956f, 0.57767344f, -0.34196982f, 0.12523428f, -0.13514775f, -0.86274439f, 
    0.33064005f, -0.03187799f, 0.33720204f, -0.26005280f, -0.00434597f, 0.03508017f, 0.25257269f, -0.22781701f, 
    0.00364356f, 0.24878016f, -0.72622418f, 0.49522325f, -0.46861780f, 0.07950703f, -0.10032017f, -0.06163124f, 
    -0.00199068f, -0.07135709f, -0.83969194f, 0.62812793f, -0.09318845f, -0.03895354f, 0.07669459f, -0.70047987f, 
    0.20331490f, 0.22057259f, -0.18396027f, -0.84109670f, -0.51610380f, 0.44765258f, 0.03218961f, 0.27849898f, 
    -0.41677806f, -0.55129635f, 0.05710472f, -0.01976782f, -0.24162987f, 0.08104680f, -0.32843730f, -0.00075520f, 
    -0.15029663f, 0.05686141f, -0.74457461f, 0.34189001f, -0.08719877f, 0.33721316f, 0.23169950f, -0.00256601f, 
    0.14197572f, -0.33557916f, -0.03495596f, 0.01497052f, -0.00793484f, -0.15276767f, 0.21144108f, -0.03983923f, 
    0.01628447f, 0.05446721f, 0.13722417f, -0.03683259f, 0.08236475f, -0.08791277f, -0.05639265f, 0.03418759f, 
    0.04206910f, -1.15514648f, -0.07480958f, 0.74613714f, 0.89147824f, 0.01999778f, 0.06772982f, 0.00518296f, 
    -0.01201250f, 0.06005111f, -0.03535927f, -0.12924783f, 0.29363137f, -0.15733038f, 0.15625593f, 0.00515236f, 
    -0.33318713f, 0.04148056f, -0.87701112f, 0.08109723f, -0.00479309f, -0.65361667f, -0.03966486f, -0.02395262f, 
    0.08479933f, 0.12854341f, 0.01556463f, -1.12226021f, -0.03843788f, 0.82120115f, 0.02820917f, -0.10828720f, 
    -0.22301680f, -0.16427909f, -0.13881317f, -0.54196358f, -0.38229543f, -0.02766342f, 0.14659689f, -0.67628598f, 
    0.18185301f, 0.29313022f, -0.17509145f, -0.05935300f, -0.07012180f, 0.00489435f, -0.13604908f, 0.19646367f, 
    -0.02288205f, 0.15485844f, -0.83251143f, -0.32102907f, -0.25478867f, -0.28700432f, 0.07992065f, 0.06197876f, 
    -0.48435035f, 0.71135575f, 0.09485355f, -0.61149102f, -0.36384761f, -0.36343357f, 0.09862383f, -0.73936450f, 
    -0.08538678f, 0.05247828f, -0.87959677f, 0.02248631f, 0.05889519f, 0.15135150f, -0.84068501f, 0.42458019f, 
    -0.21814509f, 0.07544793f, -0.32499787f, 0.06172519f, 0.18987748f, -0.02179907f, 0.17515366f, -0.12144755f, 
    0.05056144f, 0.39724633f, -0.23365742f, -0.55933326f, -0.36890849f, 0.47480550f, 0.00799808f, -0.94468582f, 
    0.00252630f, 0.05853355f, -0.39822659f, 0.51435173f, -1.09956145f, 0.19050182f, -0.10826198f, 0.21231809f, 
    -0.03128212f, -0.44274548f, -0.10225018f, 0.00980320f, -0.00677836f, 0.05001504f, 0.25993991f, -0.00972463f, 
    -0.13789794f, 0.05573466f, -0.62538040f, -0.94085377f, -0.00021520f, -0.79607582f, 0.00478396f, -0.04090050f, 
    -0.22142857f, 0.19354200f, -0.30463114f, 0.17369771f, -0.01038660f, 0.30549887f, 0.08067859f, -0.08190879f, 
    -0.00460064f, -0.62119114f, -0.03320113f, -0.29875788f, 0.16734141f, -1.34836674f, -0.14511670f, -0.87503231f, 
    -0.18771428f, 0.15488717f, -0.02367669f, -0.80898410f, 0.21878549f, -0.04729441f, -0.13587886f, -0.77556968f, 
    0.03221209f, -0.95433116f, -0.00080407f, 0.27094865f, -0.03723686f, -0.17032479f, -0.27530247f, 0.02930911f, 
    0.37941974f, 0.08363973f, -0.36590791f, 0.03505917f, 0.06913594f, 0.12403344f, -0.03138764f, 0.02574760f, 
    0.08493651f, 0.25774667f, 0.31682977f, -0.75273067f, -0.10756423f, -0.73666704f, -1.41953099f, 0.21166992f, 
    0.17786777f, 0.08692591f, -0.04033696f, 0.00606071f, -0.70422232f, 0.14848655f, 0.16381767f, 0.22979578f, 
    0.28388980f, -0.31709608f, 0.18879727f, -0.32605001f, 0.06193179f, 0.14522724f, -0.70633626f, -0.21604054f, 
    -0.16662493f, 0.16993201f, -0.03031816f, 0.22220431f, -0.00084673f, 0.41850749f, 0.05610517f, 0.22990163f, 
    0.09051029f, -2.02795601f, 0.21162221f, -0.97677290f, -0.49261406f, -0.24238175f, -0.03463148f, 0.25803035f, 
    -0.75863713f, -0.10275636f, -0.01401022f, 0.20179963f, 0.29693544f, 0.12222325f, -0.19512510f, -0.65658271f, 
    0.47937229f, 0.06347218f, -0.50629854f, -0.94155002f, -0.07424019f, -0.06283323f, -0.38382581f, -0.03039569f, 
    0.00467657f, -0.35719460f, -0.63808030f, -0.19783075f, 0.18983953f, -0.42486885f, 0.01226350f, 0.18795228f, 
    -0.03699176f, 0.08260826f, -0.38360238f, -0.80423981f, 0.21003142f, 0.17882696f, 0.30100611f, -0.09677014f, 
    -0.66790128f, 0.08512446f, 0.18821093f, 0.05074311f, 0.28552234f, -0.01613269f, 0.14331867f, -0.40666163f, 
    0.29561636f, 0.01478130f, -0.04043894f, 0.24166937f, -0.01287755f, 0.36290962f, 0.11271745f, 0.02954023f, 
    0.31206870f, 0.13977236f, 0.27188617f, -0.33175820f, -0.37581745f, -0.68122625f, 0.10067520f, 0.02493419f, 
    -0.08391725f, 0.39680111f, -0.05005028f, -0.09285888f, -0.33837450f, 0.43021736f, -0.07641985f, 0.31053960f, 
    -0.12651603f, -0.09963877f, 0.11916871f, -0.16618538f, -0.60556173f, -0.02368378f, 0.16200896f, -0.42922923f, 
    0.00163125f, -0.34827015f, 0.02257787f, -0.08636992f, -0.05901800f, -0.84975547f, -0.18434335f, 0.31508324f, 
    -0.14754905f, 0.02934401f, 0.36048305f, -0.20527050f, -0.01349691f, -0.02458511f, 0.01438780f, -0.06625823f, 
    -0.10638723f, -0.34341785f, -0.48446664f, 0.22265594f, 0.24108523f, -0.37890780f, 0.14169571f, -0.24490425f, 
    -0.24977013f, -0.17063195f, -0.05345541f, 0.19430876f, -0.32763755f, 0.13477764f, -0.36013359f, 0.12579580f, 
    0.12977611f, -0.56632304f, -0.01181194f, -0.28837258f, -0.12789236f, -0.06220510f, -0.17897527f, 0.06898160f, 
    -0.11864737f, -0.19079524f, 0.37065634f, -0.24664135f, -0.27300110f, -0.21586971f, 0.18938547f, 0.11122086f, 
    0.24787670f, -0.70546317f, -0.52311355f, 0.08782625f, -0.60114849f, 0.38609910f, 0.38006309f, -0.05504403f, 
    -0.20413880f, 0.18144475f, 0.14662051f, 0.06716525f, -0.66398555f, 0.07069383f, -0.42108643f, -0.56455833f, 
    -0.26653945f, -0.45483920f, -0.79542971f, 0.29914603f, 0.06377961f, -0.19323465f, 0.18222949f, -0.04324215f, 
    -0.10601722f, 0.05725401f, 0.33566421f, 0.47267914f, -0.46930170f, -0.11231389f, 0.04479253f, 0.02480899f, 
    0.19368473f, 0.13356657f, -0.25188994f, 0.07103481f, -0.23331335f, 0.08659019f, -0.04515320f, -0.06976632f, 
    0.51926029f, -0.48824331f, -0.20855103f, -0.11148459f, 0.12400433f, -0.00488957f, 0.15273196f, -0.38315243f, 
    0.01544244f, -0.07576513f, -0.00871578f, 0.47853023f, -0.05933137f, 0.15601291f, 0.04285589f, -0.05849360f, 
    0.21117169f, -0.05726466f, -0.29195774f, 0.25973815f, -0.26385397f, 0.20612690f, 0.14948981f, -0.06570100f, 
    0.05632646f, -0.17913508f, -0.39965481f, -0.54021424f, -0.58738685f, -0.76215804f, -0.01364818f, 0.10492121f, 
    -0.55087811f, -0.97371900f, -0.13255782f, 0.43209264f, -0.34148303f, -0.40299058f, 0.16028151f, -0.21513982f, 
    -0.07008399f, -0.11731368f, 0.29621452f, 0.20264916f, 0.14202681f, -0.28396794f, -0.47750047f, -0.29778236f, 
    0.04903394f, -0.13504760f, -0.60741901f, -0.08783706f, -0.96711856f, 0.23818535f, -0.02377683f, 0.03989390f, 
    0.16795456f, 0.29165146f, 0.24533042f, -0.84599257f, -0.05512737f, -0.50763649f, 0.08098871f, 0.19967671f, 
    0.10987366f, 0.00257455f, -0.11769094f, -0.04985118f, -0.73429811f, 0.07040592f, -0.06882644f, 0.11943422f, 
    -0.68339211f, 0.04716930f, -0.55574894f, -0.35760069f, 0.21173449f, -0.28161341f, -1.00730169f, 0.15514904f, 
    -0.04135688f, 0.15439546f, 0.15620898f, -0.60184419f, -0.23391235f, 0.01317507f, -0.10965879f, -0.80814195f, 
    -1.69394183f, -0.20330802f, -0.19007567f, 0.22812481f, -0.59937221f, 0.38705122f, -1.24723113f, 0.26343030f, 
    0.27527469f, 0.08912937f, -0.17798793f, 0.18850085f, -0.46006763f, -0.64727205f, -0.09291947f, 0.00928169f, 
    -0.86823756f, 0.15887704f, -0.71926397f, -0.08100268f, 0.30104554f, 0.08017835f, -0.29179853f, -0.06562823f, 
    -0.11675747f, 0.06934085f, 0.03575256f, -0.44684190f, 0.05095083f, -0.55798411f, 0.16030738f, 0.11535431f, 
    -0.25358301f, -0.16628660f, -0.49092114f, 0.04004272f, -0.45695525f, 0.15398872f, -0.11194907f, 0.18389727f, 
    0.55875409f, -0.08665580f, -0.04598872f, -0.75635856f, 0.04240974f, 0.04187926f, 0.17017040f, -0.44684732f, 
    -0.21596609f, -0.34493271f, -0.24287023f, 0.26337400f, 0.01221644f, 0.14400247f, -0.16800685f, -0.00145480f, 
    0.01545599f, 0.40440610f, -0.03644665f, -0.14266610f, 0.34734955f, 0.19766451f, -0.11058317f, 0.01873650f, 
    0.03746994f, -0.52585268f, -0.49534303f, 0.03863559f, 0.07019670f, -0.93972516f, -0.14150025f, 0.12391686f, 
    0.36520284f, -0.12906294f, -0.00363645f, 0.16588625f, -0.07477248f, 0.11023027f, -0.11782695f, 0.09992171f, 
    0.00005263f, -0.57058567f, -0.02312826f, -0.09379610f, -0.07320055f, -0.13750362f, -0.56521338f, -0.13059640f, 
    0.02999501f, 0.17182502f, -0.38010448f, -0.17919096f, 0.21778846f, -0.07695209f, -0.05990877f, 0.05956445f, 
    -0.08613116f, 0.03148721f, 0.13542192f, -0.28087443f, -0.15246789f, -0.92656982f, -0.41615552f, -0.35894495f, 
    -0.29123902f, -0.27536249f, -0.04880228f, -0.06219198f, -0.29451469f, 0.19842811f, 0.18721853f, 0.01434541f, 
    0.01172683f, -0.42742100f, -0.01537548f, -0.13979833f, 0.28565875f, -0.07316544f, -0.07749090f, 0.32237566f, 
    0.03689741f, 0.06126764f, -0.98272538f, 0.29346618f, 0.04253157f, -0.02125464f, 0.10425960f, 0.25354427f, 
    0.28143951f, 0.44262955f, -0.14940287f, 0.03326198f, -0.63500667f, -0.24969333f, 0.45222723f, -0.27826232f, 
    -0.08630992f, 0.00164627f, 0.08307484f, 0.12103702f, -0.01923168f, 0.16127242f, 0.23052469f, -0.11923468f, 
    0.30614838f, -0.07002585f, -0.48240671f, 0.07127361f, -0.03665107f, -0.11909252f, -0.07861260f, -0.05961872f, 
    0.01807234f, 0.33810344f, -0.01178360f, -0.23639704f, 0.32253075f, -0.77568388f, -0.17706740f, -0.34789905f, 
    -0.14179015f, -0.02513447f, 0.30815166f, 0.08830366f, -0.33466533f, -0.82463843f, -0.13581385f, 0.32538295f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.22001083f, 0.02271760f, 0.04722249f, 0.08173310f, -0.12690991f, -0.10292521f, -0.08704208f, -0.04218237f, 
    0.13160881f, 0.12222385f, 0.18736689f, -0.07506609f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
