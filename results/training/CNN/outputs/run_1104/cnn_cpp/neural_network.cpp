#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.78383875f, -0.83786672f, -0.01761322f, 0.24409311f, -0.62009883f, -0.25885344f, -0.61058348f, -0.84827822f, 
    -0.76234484f, -0.47003046f, -0.23639184f, -0.27520946f, 0.05369936f, -0.19607706f, -0.35069528f, 0.08356175f, 
    -0.32532617f, -0.40782753f, -0.23479588f, -0.42078415f, 0.09929105f, -0.14180209f, -0.32928717f, 0.07914063f, 
    0.37084413f, 0.82105184f, 0.36424598f, -1.08573425f, -0.83753175f, 0.75332296f, 0.35455057f, -0.27632484f, 
    -0.30581570f, -1.04645073f, -1.07973897f, 0.46338868f, 0.12061385f, 0.20730776f, 0.10534935f, -0.18851741f, 
    0.03793837f, -0.23976527f, -0.23475251f, 0.16762124f, -0.12535076f, 0.03734014f, 0.19728418f, 0.14221936f, 
    0.06368634f, 0.14488392f, 0.76708317f, -0.01538507f, -0.12233668f, 0.00198732f, -0.63369888f, -0.28848353f, 
    0.10284278f, 0.73892051f, -0.18413413f, -0.09744677f, -0.20327890f, -0.05889398f, 0.85377032f, -0.52831948f, 
    -0.13218792f, 0.04456860f, -0.19866513f, -0.34330678f, 0.00701521f, 0.18104257f, 0.09579042f, -0.01331315f, 
    -0.20419426f, -0.05041480f, 0.37473321f, -0.58046681f, -1.14392042f, -0.62419802f, 0.09981619f, 0.72909987f, 
    -0.65854472f, -0.05390803f, -0.13515422f, 0.14388528f, 0.54157919f, 0.37339282f, 0.64568579f, 0.39073423f, 
    -0.06018067f, 0.18904628f, 0.05927165f, 0.27278200f, -0.28848910f, -0.23526663f, -0.10549215f, -0.32923236f, 
    -0.34790650f, -0.20537932f, -0.17283338f, 0.20069937f, -0.50813812f, -0.36082864f, -0.58452845f, -0.68142593f, 
    -0.32317427f, -0.70119488f, -0.66387302f, -0.02802336f, 0.06198744f, -1.17937410f, 0.07398649f, -0.42854318f, 
    0.05575658f, 0.37108657f, 0.71369874f, -0.08700754f, -0.05219682f, -0.11130973f, -0.06086358f, -0.20762728f, 
    0.05474131f, -0.02264448f, 0.17150681f, 0.26160657f, 0.36119980f, -1.28524601f, 1.51226997f, 0.06917329f, 
    -0.65627348f, -0.04016230f, -0.61967230f, 0.20457362f, 0.05509262f, 0.03317565f, 0.28066853f, -0.08598666f, 
    -0.36774167f, -0.12957078f, -0.36222929f, 0.34708437f, 0.24279214f, -0.13909982f, -0.16183138f, -0.42901474f, 
    -0.48511159f, -0.28817210f, -0.25500479f, -0.53351790f, -0.37355110f, -0.55851126f, -0.36941326f, -0.85019714f, 
    -0.55638427f, -0.65799576f, -0.75377852f, 0.50656790f, 0.39809906f, -0.03103595f, 0.13007131f, 0.84086496f, 
    -0.48772299f, -0.45176709f, -0.69335681f, 0.02798611f, 0.02645900f, 0.22544952f, 0.33977231f, -0.11106132f, 
    0.00570980f, -0.15867843f, -0.07958142f, -0.46108142f, -0.21714851f, -0.36715364f, -0.36780515f, -0.75637770f, 
    -0.15043287f, -0.27297416f, 0.89170927f, 0.10402791f, 0.16554672f, 0.91059160f, -0.84900391f, -1.13226020f, 
    -0.42517963f, -0.70242846f, -0.39818296f, 0.44666928f, -0.47412020f, -0.13386860f, -0.33929011f, -0.00022259f, 
    -0.06540597f, -0.32196325f, -0.19373071f, 0.17816706f, -0.03628253f, -0.33102763f, -0.26705408f, -0.16148174f, 
    0.63653582f, -0.17656307f, -0.05050588f, -0.06169654f, -0.84185654f, -0.67323136f, -0.38130307f, -0.68723339f, 
    -0.68959600f, -0.75815153f, 0.43513301f, 0.03907751f, -0.20921457f, -0.08281948f, -0.08322689f, -0.08078823f, 
    0.32965288f, 0.19464664f, -0.03122219f, -0.08819298f, -0.45622164f, -0.35667133f, -0.28667510f, -0.16870227f, 
    -0.23965780f, -1.13161731f, -0.37955499f, -0.28944525f, 0.21771531f, 0.43479168f, 0.46412468f, -0.16373846f, 
    0.28386733f, 0.78388947f, 0.43633607f, -0.16065764f, -0.28960425f, -0.27610248f, 0.31422243f, -0.21326947f, 
    0.04585849f, -0.04264452f, -0.18756665f, 0.20485915f, -0.54275656f, -0.10138032f, 0.19456939f, 0.29999828f, 
    0.11661576f, 0.11727092f, -0.38779688f, -0.04999858f, -0.89778799f, -0.50300819f, 0.89392072f, -0.32739407f, 
    0.47999376f, -0.57688087f, -0.41226277f, -0.03076452f, -0.36300305f, -0.17611960f, -0.30550796f, -0.28000736f, 
    -0.52945340f, 0.04858143f, 0.01640372f, -0.06208950f, 0.02837477f, 0.01736503f, 0.02500161f, 0.08559546f, 
    0.40103397f, 0.45281237f, 0.26247099f, -0.47151309f, -0.07489862f, -0.49911290f, -0.95650196f, -1.18814933f, 
    0.91448587f, 0.22150400f, -0.04815340f, 0.32363677f, 0.25242141f, 0.03936737f, -0.07636508f, 0.25564942f, 
    0.15078451f, 0.24911733f, -0.15876305f, -0.05885570f, -0.29097900f, 0.16744712f, -0.43235195f, 0.01127491f, 
    0.10316239f, 0.57924962f, 0.07570764f, 0.03504230f, -1.20248544f, -0.73236823f, -0.33185512f, 0.45617196f, 
    0.59507293f, 0.45823982f, 0.54267657f, 0.59159315f, 0.32664299f, -0.15153651f, 0.00243296f, 0.07111400f, 
    -0.09688798f, 0.49581480f, -0.24227306f, -0.11380307f, -0.20793404f, -0.26749942f, 0.21331123f, 0.36632237f, 
    -0.02999695f, -0.25543815f, 0.15686801f, 0.19475840f, -0.15509728f, 0.40607071f, 0.11348243f, 0.37447485f, 
    0.52697372f, 0.22763456f, -0.24953358f, 0.25620416f, 0.38083428f, 0.28458685f, 0.36501071f, 0.04491124f, 
    0.14166398f, 0.04868747f, -0.40805787f, -0.38911137f, 0.23255014f, 0.03836586f, 0.02571597f, -0.27024490f, 
    -0.12327848f, -0.21076801f, 0.12645431f, 0.09955677f, -0.11897161f, -0.07185718f, 0.34060812f, -0.00543037f, 
    -0.15254495f, 0.64747488f, 0.13164581f, -0.21453311f, -0.11724923f, -0.61212486f, -0.59602928f, 0.06452297f, 
    0.09394664f, 0.06592060f, -0.22496994f, -0.49924219f, 0.77762365f, -0.08647599f, 0.09771975f, 0.00761124f, 
    -0.03488451f, 0.22916518f, 0.28165293f, -0.35948810f, 0.35236317f, 0.00244226f, 0.10717390f, 1.02370906f, 
    0.63102126f, -0.06344386f, 0.16916786f, 0.21700358f, -0.33213365f, -0.21024188f, -0.00204505f, 0.34718105f, 
    -0.25447822f, -0.23357496f, 0.18309984f, -0.04946252f, -0.07481126f, -0.35232052f, -0.26863480f, -0.04592572f, 
    0.18170653f, -0.35744402f, -0.09508547f, -0.25591177f, 0.03408537f, 0.16242790f, -0.20753892f, -0.18522507f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.25388908f, 0.38881168f, 0.63301557f, 0.21311411f, -0.10703612f, 0.17960146f, 0.35496420f, 0.38934949f, 
    -0.19950777f, 0.27849948f, 0.17685600f, 0.34800008f, 0.31279981f, 0.00244725f, 0.28436288f, 0.19070211f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.61623383f, -0.52901840f, -0.23249133f, -0.02248315f, 0.14787234f, -0.08413241f, 0.04094211f, -0.30723271f, 
    -0.10694785f, 0.04287179f, 0.14753127f, -0.00323374f, 0.14596209f, 0.19965744f, 0.18474720f, 0.00014117f, 
    0.18993779f, 0.07305957f, -0.10420635f, 0.09071307f, 0.02367750f, -0.07980086f, 0.01840431f, -0.00219494f, 
    0.57879275f, 0.02384853f, 0.37083372f, -0.13505593f, -0.01556928f, 0.02207617f, 0.10355417f, 0.12749366f, 
    0.12101593f, 0.07486067f, 0.13071497f, -0.03054574f, -0.50917721f, 0.21194734f, -0.02717650f, -0.08530191f, 
    -0.04161391f, 0.08585218f, -0.05587593f, 0.15658297f, 0.19312049f, 0.02578068f, -0.15107405f, -0.02327045f, 
    0.20319168f, -0.51887357f, -0.18313722f, -0.40751395f, -0.11641268f, -0.29345903f, -0.22241618f, -0.06084139f, 
    -0.13169999f, -0.20068638f, -0.09492795f, -0.01428705f, -0.19460268f, -0.21851675f, -0.00224326f, -0.19363408f, 
    -0.08033684f, 0.06758044f, 0.04662670f, 0.24738179f, -0.11628939f, -0.02714596f, 0.28890115f, 0.05954096f, 
    -0.15478300f, 0.08320139f, -0.50557953f, 0.04287528f, 0.05084001f, -0.00660087f, 0.13501252f, -0.02324751f, 
    -0.05542629f, 0.11737233f, 0.05257218f, 0.16938689f, -0.12541227f, 0.01426791f, -0.23358241f, 0.27721828f, 
    0.17320730f, -0.00322134f, 0.33015358f, 0.07809363f, -0.07070864f, 0.20090090f, 0.22049779f, 0.07206995f, 
    0.23213938f, -0.20429653f, 0.19248122f, 0.25700366f, 0.01330919f, -0.11057204f, 0.07423493f, -0.16735159f, 
    0.08879059f, 0.04537013f, -0.01026093f, 0.13678467f, -0.20304362f, -0.24839264f, 0.05624152f, 0.00700962f, 
    -0.08143187f, 0.02893823f, -0.05012703f, 0.05831989f, -0.15104325f, 0.13998698f, 0.10394727f, 0.21671742f, 
    -0.22071786f, -0.01427047f, -0.30962184f, 0.00959016f, 0.05714938f, -0.04168621f, -0.33893591f, 0.14269115f, 
    -0.09846941f, -0.01563366f, -0.15145431f, -0.13274840f, -0.51052362f, -0.13257959f, 0.05105682f, 0.11257078f, 
    0.13445574f, -0.14142419f, -0.00088226f, 0.16707948f, 0.08351602f, 0.01646045f, -0.02348328f, -0.06856444f, 
    -0.26799095f, -0.09243512f, -0.04338566f, -0.02731085f, 0.04928776f, 0.04074297f, -0.06863797f, -0.05855594f, 
    0.02969741f, 0.06077189f, -0.02203250f, 0.22785106f, 0.44726595f, 0.17613935f, 0.12231497f, -0.05455579f, 
    -0.08359192f, 0.02833176f, 0.00220553f, 0.10556969f, -0.00391948f, 0.09123125f, 0.05674693f, -0.15828644f, 
    0.16419245f, 0.24714924f, -0.26389280f, 0.16377032f, 0.14401411f, -0.12472434f, -0.02496135f, 0.02762536f, 
    -0.07482501f, -0.14923373f, -0.20548292f, 0.02344362f, 0.99427742f, 0.43072814f, 0.05321243f, 0.11719008f, 
    -0.02460304f, -0.07498491f, -0.14154136f, 0.16125354f, 0.03201871f, 0.07849880f, 0.04083732f, 0.16709553f, 
    0.05068087f, 0.17382358f, 0.09381941f, 0.06901263f, -0.00013833f, -0.12318184f, -0.36011595f, -0.28471652f, 
    -0.01275342f, 0.00856668f, 0.13169864f, 0.11123178f, 0.05680221f, 0.52933311f, 0.32622409f, 0.12687023f, 
    0.23455203f, 0.24544826f, -0.19115166f, -0.23558351f, 0.25413412f, 0.06791063f, 0.00534880f, -0.08294780f, 
    -0.23020899f, -0.11795112f, -0.47047448f, 0.12484523f, 0.14312667f, -0.11652607f, -0.05445937f, -0.14081043f, 
    0.05084143f, 0.01663401f, 0.06543569f, -0.01983896f, 0.15546083f, -0.04787390f, 0.07380726f, -0.02010953f, 
    0.20771711f, -0.22169138f, -0.01344814f, 0.04414861f, -0.48258182f, -0.37926900f, 0.06208851f, -0.06458674f, 
    0.51310283f, 0.07359126f, 0.25603038f, 0.47877303f, -0.00216601f, -0.28378183f, -0.27566662f, 0.18192686f, 
    0.12163124f, -0.01081187f, -0.03204399f, -0.02812254f, 0.37306863f, 0.35178339f, -0.11033915f, 0.20573273f, 
    -0.08194932f, -0.04793616f, 0.15526767f, -0.16428269f, -0.17343618f, -0.14632469f, 0.24189243f, -0.18261614f, 
    -0.38378105f, -0.13673787f, 0.01932934f, -0.07850707f, -0.13191459f, 0.07201896f, -0.03666249f, 0.15079720f, 
    -0.22043058f, -0.07994136f, -0.24361756f, 0.17596327f, -0.25970778f, 0.09445747f, 0.03912675f, -0.18401775f, 
    -0.14508533f, -0.14012274f, -0.17315145f, -0.04100178f, -0.09830294f, -0.08661052f, -0.16520444f, -0.09480513f, 
    0.09577204f, 0.13374841f, 0.31643650f, 0.21367319f, -0.14003527f, 0.13635840f, 0.01266279f, -0.32070911f, 
    -0.09757821f, 0.00002231f, 0.03965742f, -0.18411179f, 0.29670489f, -0.34862083f, 0.04983152f, -0.00385598f, 
    0.07073159f, -0.02395419f, -0.04410261f, 0.11457675f, -0.07631986f, 0.12845927f, -0.10744409f, -0.03564675f, 
    -0.01255585f, 0.29650149f, 0.07895029f, 0.06950709f, -0.21344547f, -0.19464797f, -0.26728666f, -0.04629476f, 
    0.01362750f, 0.03652997f, -0.02545112f, 0.09288131f, 0.22470610f, 0.14182052f, -0.18271597f, 0.17396778f, 
    0.11903617f, -0.16791064f, -0.02634686f, 0.09412414f, 0.54582036f, 0.18359958f, 0.17211604f, 0.25152785f, 
    0.06920382f, 0.00059410f, 0.05783997f, -0.13048586f, 0.17347568f, -0.01673512f, -0.10690381f, -0.01544290f, 
    -0.30143365f, -0.03341387f, -0.22337660f, 0.14972606f, 0.10371214f, 0.09757157f, 0.00499499f, 0.05125931f, 
    0.06199843f, -0.02380383f, 0.01797076f, 0.06115985f, 0.03952101f, -0.10710295f, -0.05997193f, -0.12005487f, 
    0.14427550f, -0.14943098f, 0.04617470f, -0.00123731f, -0.00125443f, 0.12704134f, 0.13377850f, 0.46151683f, 
    0.00651350f, 0.11581157f, 0.07727476f, -0.03851447f, 0.21360336f, -0.40885422f, -0.22048566f, 0.11836845f, 
    -0.04757426f, 0.10940067f, 0.09235230f, 0.04829717f, 0.13424270f, -0.05281127f, 0.00042290f, -0.12026478f, 
    0.20090200f, 0.06099086f, 0.11836579f, 0.20152099f, 0.05686080f, 0.03400776f, 0.08946242f, 0.11658043f, 
    -0.04538681f, 0.05291458f, -0.01206921f, -0.02445971f, -0.12936804f, 0.37968779f, 0.11382557f, 0.30878627f, 
    -0.13754596f, 0.29703021f, -0.10821376f, 0.01450932f, -0.07982149f, -0.14550339f, -0.11004252f, -0.29820278f, 
    -0.71190357f, 0.04374086f, 0.05840192f, -0.08846921f, 0.26549160f, -0.27126306f, -0.14116573f, -0.02996648f, 
    -0.00722472f, -0.10192697f, 0.02730182f, -0.19845639f, 0.32759815f, -0.19870123f, 0.18883465f, 0.08364949f, 
    0.17502187f, 0.27193171f, 0.06728780f, -0.21061993f, -0.01890906f, 0.14813177f, 0.03643911f, -0.26979449f, 
    0.61619508f, -0.13766122f, -0.19244081f, -0.02339272f, 0.00696700f, 0.01659528f, -0.15225701f, 0.39018956f, 
    0.13168497f, -0.00183702f, -0.10239685f, -0.04024285f, 0.28330708f, 0.05750690f, 0.01725212f, 0.24971379f, 
    -0.06899101f, 0.02173807f, 0.08393070f, 0.10629465f, 0.00565416f, -0.01032338f, 0.24692905f, 0.14672153f, 
    -0.41946423f, 0.02200369f, -0.16066656f, -0.22250742f, -0.10270739f, -0.04709486f, 0.14674924f, 0.13420078f, 
    -0.01317659f, -0.10620239f, 0.01869130f, 0.30188406f, -0.11492763f, 0.49055925f, 0.11121696f, 0.33359402f, 
    -0.02876962f, 0.02339175f, -0.10810507f, 0.00229684f, -0.16524221f, -0.01203246f, 0.07985073f, 0.05875370f, 
    0.03424744f, 0.08003591f, 0.15383819f, 0.71531415f, -0.00257771f, 0.03869183f, 0.09029452f, 0.35684082f, 
    0.10616423f, 0.31612843f, 0.03552113f, -0.06609556f, 0.27194163f, -0.08481811f, 0.13344252f, -0.02751872f, 
    0.24780644f, -0.04977980f, -0.29123998f, -0.15366864f, 0.05941164f, -0.14286005f, 0.12103001f, -0.14344050f, 
    -0.08828846f, 0.51440322f, -0.05037991f, -0.11601517f, 0.01218046f, -0.08990031f, -0.11648359f, -0.06840884f, 
    -0.22065222f, 0.02188235f, -0.20279403f, 0.06805432f, -0.08537475f, -0.25109059f, -0.20230091f, -0.04851384f, 
    0.02221154f, 0.04442078f, 0.00509646f, -0.25817680f, -0.00707007f, -0.05903134f, -0.19572173f, 0.05682789f, 
    0.03247211f, 0.15338959f, -0.68274599f, -0.09116745f, 0.56037360f, 0.27226743f, -0.41902527f, -0.11791393f, 
    -0.06105027f, -0.09188729f, -0.00781850f, 0.06120120f, -0.02592289f, 0.09223243f, 0.03915269f, -0.00815439f, 
    0.22650792f, -0.12463582f, -0.16410476f, 0.19359052f, -0.00975666f, -0.05297368f, -0.02706581f, -0.12563138f, 
    0.26642609f, 0.30089977f, 0.14528085f, -0.22716342f, -0.09786578f, -0.06704868f, 0.02120318f, 0.02174730f, 
    -0.19058447f, 0.01528165f, -0.27293384f, -0.36294577f, 0.61705297f, -0.03088740f, 0.23429248f, 0.30760774f, 
    0.09200001f, 0.04566732f, -0.21816693f, 0.22188330f, -0.01170128f, 0.10750621f, 0.16999210f, 0.07886951f, 
    -0.25265989f, -0.09939226f, -0.04350183f, 0.27646264f, 0.07752221f, -0.05289324f, -0.09451628f, -0.04460127f, 
    0.02691233f, 0.21671237f, 0.06396807f, -0.07267682f, -0.16890407f, -0.34981075f, 0.27519217f, 0.38475367f, 
    -0.02171950f, 0.15307626f, -0.07249754f, 0.14581174f, -0.11825278f, 0.00513625f, 0.16064429f, 0.10316379f, 
    0.03503749f, 0.26550338f, 0.33734924f, 0.43665987f, 0.06289207f, 0.14809595f, -0.19273072f, 0.16212121f, 
    0.19423874f, 0.11530031f, 0.31195405f, 0.37949982f, -0.40116718f, -0.23832008f, -0.25077158f, -0.07569724f, 
    0.05377267f, 0.02737607f, 0.02062305f, -0.02647968f, 0.16223653f, -0.04656553f, -0.17406338f, -0.00027244f, 
    -0.21523955f, -0.05049708f, -0.19105478f, -0.03101105f, 0.02652003f, -0.04271544f, 0.10532959f, 0.23178531f, 
    -0.00544696f, -0.11413722f, 0.03224941f, -0.02501941f, 0.54020411f, -0.10812318f, 0.18187737f, -0.25828907f, 
    0.23544259f, 0.07418386f, -0.00272877f, 0.04669844f, -0.27723891f, -0.09982741f, -0.26864201f, -0.21689877f, 
    0.21469897f, 0.01675227f, 0.13431366f, 0.24386454f, 0.09035265f, -0.04840574f, 0.13041593f, -0.12645301f, 
    -0.16016099f, -0.20180663f, 0.03397333f, -0.26157227f, -0.18713301f, 0.15449299f, -0.15462899f, 0.11911478f, 
    -0.02786417f, 0.20073894f, -0.05645039f, 0.18028182f, -0.04289225f, 0.00875114f, 0.14023106f, 0.15805288f, 
    -0.27056366f, -0.21919315f, -0.06548490f, 0.12178295f, -0.16989139f, -0.03612253f, 0.12333804f, -0.01774918f, 
    -0.00305064f, 0.03914963f, -0.24078019f, -0.11359406f, 0.08855316f, 0.27276170f, -0.16342840f, 0.04067359f, 
    0.17092967f, -0.05325880f, -0.10149013f, -0.19931084f, 0.04729940f, -0.02052376f, 0.29601583f, 0.36200774f, 
    0.26593730f, -0.11601316f, -0.03913992f, 0.15301892f, -0.16916609f, 0.11989696f, 0.13059801f, 0.04067869f, 
    -0.07908507f, 0.02551660f, -0.01076103f, 0.08023036f, -0.04981596f, -0.03099485f, 0.37188452f, 0.36707982f, 
    0.16231699f, 0.28478536f, 0.14195883f, -0.07635424f, -0.08712126f, 0.24228805f, -0.04316141f, -0.03170524f, 
    -0.26069367f, 0.35474512f, 0.01852325f, -0.15000828f, 0.18944806f, 0.01287621f, 0.01853430f, 0.03562507f, 
    0.15506609f, -0.09888855f, 0.32201332f, -0.03521574f, -0.18435998f, 0.47100630f, 0.09615092f, -0.18672293f, 
    -0.21119100f, -0.07938743f, -0.07416809f, -0.17910095f, -0.08216497f, 0.10558236f, -0.01329051f, -0.03677255f, 
    -0.19101779f, 0.03732534f, -0.04496738f, 0.13256238f, -0.06972786f, -0.05267233f, 0.05467787f, -0.01225116f, 
    0.13176328f, 0.09987684f, 0.18322904f, 0.04601492f, -0.42939252f, 0.46671003f, 0.76771957f, 0.17171879f, 
    -0.16076232f, -0.20328169f, -0.37286487f, -0.00590734f, -0.01717857f, 0.10364032f, -0.14900492f, 0.14791788f, 
    -0.07091692f, 0.00318301f, 0.00357158f, 0.05583310f, 0.06194693f, -0.05028085f, -0.04782497f, -0.00793143f, 
    0.02250021f, -0.06294803f, -0.04360088f, -0.03141483f, -0.01700551f, -0.00721870f, -0.03768174f, -0.00514715f, 
    -0.00559705f, -0.02868517f, 0.01166031f, 0.02727903f, -0.03753181f, 0.05936585f, 0.03792534f, -0.05560125f, 
    -0.07361019f, -0.00538326f, 0.00504866f, -0.06416206f, 0.00210949f, -0.04221633f, -0.05125861f, -0.00016334f, 
    0.05745793f, -0.06120135f, -0.02028532f, 0.00159730f, -0.06279993f, 0.00125854f, -0.03754975f, 0.05285317f, 
    -0.06137902f, 0.03688273f, 0.04095348f, -0.05236492f, 0.05713550f, -0.03836579f, -0.00568323f, -0.00247959f, 
    0.05263218f, 0.01557954f, 0.01658390f, -0.07274240f, -0.02353515f, -0.04334133f, 0.03516033f, -0.05611857f, 
    -0.02832553f, 0.04933007f, 0.04303148f, -0.02833919f, -0.06801993f, -0.02722945f, 0.02832107f, 0.00580116f, 
    0.05285267f, 0.05334694f, -0.01595077f, 0.00033570f, 0.03592658f, -0.05369293f, 0.07957818f, -0.01456707f, 
    -0.03466551f, 0.03321288f, -0.06725071f, 0.01063139f, -0.01274210f, -0.04498730f, 0.06883929f, -0.01806443f, 
    0.05263609f, -0.01078679f, -0.06220596f, -0.02675319f, -0.02835521f, 0.01008307f, -0.04276495f, -0.05320746f, 
    -0.02548738f, 0.00892071f, -0.04555045f, 0.03415952f, 0.06741053f, 0.06297169f, -0.03964799f, 0.01354604f, 
    0.00671615f, 0.06210163f, 0.05135288f, 0.04125055f, -0.02591021f, 0.01756117f, 0.00976960f, -0.05888391f, 
    -0.06382568f, -0.04496124f, -0.04800237f, 0.03116863f, -0.05936432f, 0.03120951f, 0.01973767f, 0.02801719f, 
    0.00339741f, -0.08260368f, -0.02758635f, -0.01769218f, -0.07495542f, -0.06173713f, 0.02912238f, 0.03119528f, 
    -0.02850202f, 0.05458188f, -0.00784109f, 0.00738621f, -0.04283815f, 0.04899877f, -0.06099392f, 0.01287937f, 
    -0.00420853f, 0.01559021f, -0.06420241f, -0.03909912f, -0.00267080f, -0.05919993f, 0.02764153f, 0.01932243f, 
    -0.07456645f, 0.05839181f, -0.01944267f, -0.06121289f, 0.00142024f, -0.00252765f, 0.03863418f, 0.04748764f, 
    0.00719251f, -0.03373046f, -0.00839973f, 0.05286545f, -0.00843020f, -0.08980236f, -0.03264734f, -0.01446201f, 
    -0.02664448f, 0.02635582f, 0.03056841f, 0.04315018f, -0.04462494f, -0.03421320f, -0.03718330f, 0.02906545f, 
    0.04097046f, 0.03242274f, -0.03652397f, 0.02695592f, -0.01386683f, 0.03250900f, -0.01189384f, -0.06997974f, 
    -0.02155559f, -0.05709418f, -0.04467385f, 0.02235789f, 0.05848598f, -0.05355561f, -0.01411228f, 0.04063641f, 
    0.04982940f, -0.05106613f, -0.07119878f, 0.05152922f, -0.00438493f, -0.00984181f, -0.02238180f, -0.04536892f, 
    0.05714525f, -0.01281200f, -0.00022224f, -0.01359806f, 0.03335786f, 0.02493868f, -0.06433973f, 0.03280611f, 
    -0.04134675f, 0.03674864f, 0.03301561f, -0.08305910f, -0.04546222f, 0.02887070f, -0.05167547f, 0.02905956f, 
    0.05601760f, 0.03274810f, -0.07863732f, 0.02011545f, -0.02026420f, 0.04715142f, 0.04510233f, 0.02482769f, 
    -0.01051699f, -0.05486242f, 0.04098997f, -0.02216033f, 0.00232537f, -0.06231240f, 0.03081376f, 0.05817852f, 
    -0.04889415f, -0.04289021f, 0.05882220f, -0.03074078f, 0.04355717f, -0.03601667f, -0.00775520f, 0.03111686f, 
    -0.00738630f, -0.05384486f, -0.03489980f, 0.00913625f, 0.02276057f, -0.02382776f, -0.00381136f, -0.07493812f, 
    0.03212623f, -0.05525884f, -0.05096701f, -0.05147352f, 0.04118795f, -0.06001695f, -0.01948355f, 0.03731003f, 
    -0.06368125f, -0.04686242f, 0.03636727f, -0.00819600f, 0.02848339f, -0.04636413f, -0.06490164f, 0.05003665f, 
    0.00943214f, -0.05581448f, -0.05725467f, -0.06123588f, -0.00675939f, -0.02761891f, 0.01189048f, 0.04730932f, 
    -0.01371819f, 0.02786999f, 0.01035649f, -0.08376041f, -0.03222333f, -0.03053542f, 0.04311330f, 0.02479577f, 
    -0.07780138f, -0.04800210f, -0.06306557f, -0.08430345f, 0.04027908f, -0.05849942f, -0.02087442f, 0.01462695f, 
    -0.08042018f, -0.06703538f, -0.01961234f, 0.02962617f, 0.00201315f, 0.04147450f, 0.04134364f, -0.02252098f, 
    -0.00798760f, -0.05340686f, -0.02245320f, 0.01767485f, -0.04360084f, -0.04871409f, 0.00692668f, 0.04891382f, 
    0.04704845f, 0.04893321f, 0.04591048f, 0.00139915f, 0.00191299f, 0.01907206f, 0.00015528f, -0.04634109f, 
    -0.02408817f, -0.02027217f, -0.06577849f, -0.06835660f, 0.00057180f, 0.01021352f, -0.08216798f, 0.06070497f, 
    0.00532517f, -0.00022149f, -0.00276045f, -0.06940563f, -0.07530892f, 0.05460674f, -0.06985681f, -0.00977357f, 
    -0.02451332f, -0.06138692f, 0.01103672f, 0.01895291f, 0.06101142f, 0.01485491f, 0.01899083f, 0.03471518f, 
    0.00950533f, -0.03297571f, -0.00548028f, -0.00807014f, -0.00882339f, -0.07251835f, 0.01531730f, -0.04732398f, 
    0.02615700f, 0.00655418f, -0.01185317f, 0.05357903f, 0.05889349f, 0.06504060f, -0.01649089f, -0.03071597f, 
    -0.01176461f, 0.05508292f, -0.01248360f, -0.03243651f, 0.01538119f, 0.01655616f, -0.00125474f, -0.04614963f, 
    -0.03545192f, 0.02059820f, -0.01879333f, -0.01776726f, -0.06126416f, -0.05795249f, -0.00318864f, 0.05240477f, 
    -0.01823839f, -0.04887794f, -0.04987803f, -0.00445509f, 0.02376458f, -0.06902597f, -0.07466737f, -0.07067709f, 
    0.06005818f, -0.05344471f, 0.06215995f, -0.02361737f, -0.06125738f, 0.04618066f, 0.06335020f, 0.02297007f, 
    0.01250435f, -0.04118641f, 0.01018022f, -0.06880707f, 0.01791413f, 0.03348078f, -0.08372115f, 0.00444275f, 
    0.04259644f, 0.00665415f, 0.00295664f, -0.01458946f, -0.04121632f, -0.06821782f, 0.01299140f, 0.05257178f, 
    -0.30269217f, -0.20097934f, 0.11671829f, 0.15069132f, -0.01555439f, 0.00420685f, -0.07939161f, -0.02082356f, 
    0.05342792f, 0.06462012f, 0.01855422f, 0.09062024f, -0.20758988f, 0.10019385f, 0.77084672f, -0.10301097f, 
    0.11127587f, 0.20524599f, -0.09961566f, -0.07646941f, 0.16758469f, -0.01274500f, 0.14557219f, 0.00911888f, 
    0.06481341f, 0.13493910f, 0.45383441f, 0.28563887f, 0.13667330f, 0.10841750f, 0.27670884f, 0.09340258f, 
    0.11734347f, 0.14337014f, 0.37515697f, 0.35257077f, -0.04013473f, -0.17237964f, 0.07994597f, 0.00189383f, 
    0.11979031f, -0.09723883f, -0.05046641f, -0.03341180f, 0.15310185f, -0.19238058f, 0.21827592f, -0.22772110f, 
    -0.29833344f, -0.01728537f, -0.17271939f, 0.05214667f, 0.17865233f, -0.11906875f, -0.25761122f, 0.16502544f, 
    0.09188037f, -0.05650821f, -0.05253157f, 0.02018698f, 0.16431075f, 0.21251798f, -0.13759959f, -0.00080612f, 
    0.04279701f, 0.01967919f, 0.28396693f, 0.11827399f, 0.16624784f, -0.13798966f, -0.00622948f, -0.18203866f, 
    -0.32389623f, -0.21639471f, -0.10247603f, 0.06324129f, 0.00986877f, -0.03520278f, 0.04111635f, 0.22141469f, 
    0.02836581f, -0.21759953f, -0.05051922f, -0.24618003f, -0.33068606f, -0.23009034f, 0.26479831f, 0.19640864f, 
    0.07920120f, 0.23523609f, 0.05401551f, 0.07315960f, 0.06814963f, 0.02295699f, 0.02312151f, 0.01481927f, 
    -0.10109217f, 0.07175650f, -0.13913219f, 0.25099045f, -0.09962327f, 0.03301282f, 0.07465000f, -0.14751235f, 
    -0.05207867f, -0.04340228f, 0.17886549f, -0.26762429f, 0.05951458f, -0.23850477f, -0.07909331f, 0.08379836f, 
    -0.01212401f, -0.08934095f, -0.17165937f, 0.03576095f, 0.11897779f, 0.20704427f, 0.18079741f, 0.26307890f, 
    -0.21966282f, -0.04780679f, 0.25826901f, 0.10856312f, -0.04952316f, 0.03660421f, 0.00176909f, 0.26300028f, 
    -0.01877924f, -0.00561436f, 0.09149268f, 0.15226406f, -0.48823375f, 0.06960428f, -0.10621847f, 0.01567304f, 
    -0.03843182f, 0.03870041f, 0.33158171f, 0.15430908f, 0.22847019f, 0.11983729f, -0.08374497f, -0.05734770f, 
    0.11719790f, 0.08473437f, -0.08320430f, -0.15137008f, -0.08375354f, 0.05702241f, -0.01171667f, 0.10637302f, 
    0.31720790f, 0.19765548f, 0.14602415f, 0.12663111f, 0.06226965f, 0.37387621f, 0.10209721f, -0.08964119f, 
    -0.03837097f, -0.08954463f, -0.09562527f, -0.17473280f, 0.12058148f, -0.00051490f, 0.07769904f, -0.02737032f, 
    0.04944962f, -0.04178637f, 0.08016420f, -0.02981344f, 0.28574935f, 0.27210897f, 0.14899252f, 0.42993715f, 
    0.13509682f, 0.01170996f, 0.04003920f, 0.02113353f, 0.23800930f, 0.16208613f, -0.08955186f, 0.06805050f, 
    0.04111946f, -0.05082327f, 0.00200692f, 0.00410538f, 0.00262847f, -0.11921209f, -0.03488547f, -0.17307508f, 
    -0.10641404f, 0.09559837f, 0.24206521f, 0.28742474f, 0.11191585f, 0.23170193f, 0.03266256f, 0.10604981f, 
    0.04033214f, -0.04962013f, 0.07953549f, 0.16923055f, 0.22846033f, -0.10157430f, 0.01754456f, -0.54513198f, 
    -0.04045529f, 0.38891703f, 0.00167418f, 0.11712677f, -0.00352502f, -0.15932782f, 0.04869864f, -0.05251486f, 
    0.30043125f, -0.20105255f, 0.20152068f, -0.33691078f, -0.03330025f, -0.10495238f, -0.15257482f, 0.17292541f, 
    -0.02217301f, -0.05849704f, -0.03696639f, -0.05383601f, 0.06449868f, -0.10081712f, 0.04946322f, 0.30336016f, 
    0.06857207f, 0.05319859f, -0.19702609f, 0.04814111f, -0.13622557f, 0.03528558f, 0.13227093f, 0.15157701f, 
    0.11769184f, 0.20501411f, 0.44528383f, 0.30443612f, -0.01478293f, -0.02101106f, 0.01314869f, 0.11013319f, 
    -0.03908978f, 0.00757500f, -0.01232427f, 0.03551640f, -0.31728172f, 0.17110707f, 0.11931942f, 0.11955222f, 
    0.14852773f, 0.03704194f, -0.06342053f, 0.07132870f, 0.11920960f, -0.03240671f, 0.02868837f, 0.11113857f, 
    -0.14746755f, 0.36300901f, 0.47108886f, -0.04182846f, 0.08740674f, -0.08057544f, -0.24005111f, 0.02219371f, 
    0.01740538f, 0.02758744f, -0.03145980f, 0.40591106f, -0.29448301f, 0.16950656f, 0.00635541f, 0.14329217f, 
    0.05206351f, -0.02051590f, -0.15140826f, 0.20939831f, 0.05853619f, 0.13084055f, 0.27892065f, -0.06844232f, 
    0.17801867f, 0.22984825f, 0.32468987f, 0.05081767f, -0.16267562f, -0.02797316f, -0.13974521f, 0.10552271f, 
    0.02261296f, 0.06820323f, 0.11654183f, 0.10857876f, -0.53377241f, -0.33892626f, 0.18029450f, 0.68697560f, 
    0.04130212f, 0.01859961f, 0.05073728f, -0.00705729f, -0.11728343f, -0.22250818f, 0.12781909f, 0.15101719f, 
    -0.33286545f, 0.25814918f, -0.02838430f, 0.03376642f, -0.08501142f, 0.28119215f, -0.04689607f, -0.07422096f, 
    0.07431737f, 0.07385711f, -0.03337473f, -0.04342159f, -0.13307790f, 0.27833581f, 0.20411082f, 0.00516784f, 
    0.03356664f, 0.03886143f, 0.15275851f, -0.23041517f, 0.10258923f, -0.00612700f, -0.04082464f, -0.11814588f, 
    -0.37938514f, -0.40708125f, -0.00250700f, 0.25698292f, 0.12876959f, -0.07061746f, -0.09594164f, 0.05508760f, 
    -0.03488288f, 0.18368183f, -0.00491174f, 0.20190164f, -0.03980878f, -0.19078870f, -0.15748747f, 0.09179431f, 
    -0.08762287f, -0.05465090f, -0.05662905f, 0.04730077f, 0.04189789f, 0.00848894f, 0.11407492f, 0.07690471f, 
    0.18596311f, 0.18099812f, 0.08381375f, 0.22802556f, 0.12423870f, 0.01221832f, 0.16520813f, 0.42635489f, 
    0.01752506f, 0.00552387f, -0.09005658f, -0.06441692f, 0.61409360f, -0.08484942f, 0.12202013f, 0.17544857f, 
    -0.09465753f, 0.03573633f, 0.04674535f, 0.08380137f, 0.00435415f, -0.02531717f, 0.08766821f, -0.01445920f, 
    -1.35384810f, -0.26425987f, -0.91533971f, -0.10291168f, 0.23915501f, 0.30728248f, 0.10165483f, -0.00106398f, 
    -0.11785677f, 0.05828391f, -0.14319667f, -0.06965882f, 0.46158487f, 0.01839126f, -0.02946748f, 0.13200672f, 
    0.46471211f, 0.03709385f, 0.15546881f, 0.01775902f, 0.01736681f, -0.10043529f, -0.07684556f, -0.09096284f, 
    0.77104104f, 0.08147450f, 0.18243225f, -0.14615619f, 0.00054457f, -0.24102914f, -0.08613148f, 0.03257562f, 
    0.36892921f, 0.00627779f, 0.02370936f, -0.02869063f, -0.60516351f, 0.25502101f, 0.06053648f, -0.21502090f, 
    -0.05666266f, 0.13050979f, 0.13643585f, 0.33361822f, 0.02332827f, 0.09892613f, -0.11679199f, -0.09710889f, 
    -0.23489562f, -0.49737474f, -0.85375071f, -0.24972560f, 0.05345977f, -0.12004887f, 0.11585089f, -0.03349128f, 
    -0.19382901f, -0.12842040f, 0.07250776f, -0.00600804f, -0.10541012f, -0.07317005f, 0.12268273f, -0.38158792f, 
    -0.12794125f, -0.15568978f, -0.02589015f, 0.09479797f, 0.07700004f, 0.08986861f, 0.18799438f, 0.04303294f, 
    -0.27925122f, -0.36066613f, -0.71346998f, -0.21989162f, -0.06081903f, -0.02684406f, -0.13550183f, 0.01412883f, 
    -0.16198558f, 0.00185747f, 0.17192790f, 0.13087063f, -0.13551496f, -0.45389086f, -0.06048280f, 0.19703339f, 
    0.28832662f, 0.30478066f, 0.19557542f, 0.05598808f, -0.03402194f, 0.04485120f, 0.06997033f, -0.13287358f, 
    0.38951519f, -0.60356849f, -0.07720240f, 0.19395976f, 0.42232171f, 0.06097142f, 0.30223152f, -0.18706094f, 
    0.06400202f, -0.05833396f, -0.04500194f, -0.09820145f, -0.23745742f, 0.24408601f, 0.48764765f, 0.01178748f, 
    -0.00430807f, -0.03669233f, -0.03924963f, -0.00056234f, 0.11256842f, 0.07498375f, 0.02849305f, 0.28534827f, 
    -0.05888839f, -0.08380773f, -0.18072134f, -0.12379372f, 0.18565162f, 0.04581305f, -0.03175566f, 0.03459577f, 
    -0.12803744f, -0.04632302f, 0.06476256f, 0.12622683f, -0.03403157f, -0.00637399f, -0.25993627f, -0.10314522f, 
    0.13418193f, -0.32517758f, -0.11133941f, 0.01304220f, 0.05374716f, 0.04538285f, 0.01216678f, -0.08658408f, 
    -0.15400225f, 0.09552348f, 0.21526495f, 0.07586946f, 0.03645850f, 0.05765957f, -0.08035141f, -0.06190713f, 
    -0.10265318f, 0.03334846f, -0.00986395f, 0.22854322f, 0.31387505f, 0.03699074f, 0.02870123f, 0.03763251f, 
    -0.09445874f, 0.00675147f, -0.01624766f, 0.10241649f, 0.05709983f, -0.01027310f, -0.03306280f, 0.03827233f, 
    0.10920896f, 0.01946776f, -0.07574295f, 0.08456416f, 0.24736655f, 0.12574576f, -0.03231831f, -0.08431657f, 
    -0.06723958f, -0.10802466f, -0.00052577f, 0.09070212f, 0.59597743f, 0.23206007f, 0.08361989f, 0.01241269f, 
    -0.02223758f, -0.02945073f, 0.06738576f, 0.10107639f, 0.07264913f, 0.11370146f, 0.03639540f, 0.21649322f, 
    -0.20807856f, -0.09698126f, -0.31457174f, 0.17089699f, -0.15376502f, -0.01800416f, 0.03652144f, 0.02127357f, 
    -0.10399106f, 0.11170775f, -0.00847858f, -0.08616379f, 0.28457874f, -0.19704649f, 0.29039961f, 0.40612194f, 
    0.05158845f, -0.07276636f, -0.13051690f, 0.04022704f, -0.04827615f, -0.06081416f, 0.02538436f, -0.07207211f, 
    -0.12466712f, 0.25579065f, 0.16801405f, -0.29248011f, 0.09060080f, -0.11132397f, -0.06550624f, 0.00166753f, 
    -0.02316717f, -0.11267176f, -0.11442216f, -0.16785540f, -0.43091935f, 0.28102961f, 0.12778792f, 0.11190035f, 
    0.07471492f, -0.07698482f, -0.04729251f, -0.12285066f, -0.01548056f, 0.04892500f, 0.09396946f, -0.08006744f, 
    0.06241267f, -0.06525824f, -0.11564952f, 0.00181185f, 0.01379006f, -0.09822251f, -0.04859494f, 0.06102805f, 
    0.01773466f, -0.00674700f, 0.08420099f, 0.03140176f, 0.50386471f, -0.17914195f, -0.11129350f, -0.14374767f, 
    -0.11800975f, -0.08231851f, 0.17658369f, 0.00203781f, 0.10344910f, -0.04548094f, 0.28678483f, 0.12593634f, 
    -0.14394027f, 0.06795819f, -0.23353356f, 0.22190648f, 0.00190075f, 0.02574416f, 0.16773809f, -0.08277088f, 
    0.07700722f, 0.20444286f, 0.08819252f, 0.08894215f, -0.41125473f, -0.30987090f, -0.15038128f, 0.13746145f, 
    0.12013821f, 0.19816537f, 0.13574642f, 0.05685867f, 0.01976817f, 0.08095888f, -0.17917646f, 0.29172933f, 
    -0.19564165f, -0.28986087f, 0.00230684f, 0.27728090f, 0.05638525f, 0.01152501f, 0.17589134f, 0.12245610f, 
    0.09476524f, 0.21669263f, -0.06662744f, 0.00547547f, 0.34071395f, 0.66514629f, -0.02315721f, 0.09286713f, 
    0.15983257f, -0.06941704f, 0.02753123f, 0.08970807f, -0.08709496f, 0.13047703f, -0.02328605f, 0.00785989f, 
    0.11144279f, -0.21172041f, -0.06057952f, -0.05494104f, -0.02735849f, -0.07424882f, -0.02527739f, 0.13826121f, 
    -0.09832690f, -0.02049052f, 0.06102814f, -0.10721848f, 0.50935996f, 0.41240945f, 0.19957493f, 0.16216716f, 
    0.12391162f, -0.21145590f, -0.07431985f, -0.00350698f, -0.05110027f, 0.13448004f, 0.09656165f, 0.24532560f, 
    -0.26008123f, 0.57163590f, 0.43709463f, -0.07866808f, 0.23830469f, 0.04824803f, -0.14917526f, -0.04185761f, 
    -0.09804035f, 0.07099488f, 0.07788645f, 0.05982266f, 0.17961341f, -0.07400380f, -0.11854167f, -0.25720021f, 
    0.07778750f, 0.14586695f, 0.09644839f, 0.06072554f, 0.00716727f, 0.06610295f, -0.07823002f, -0.16224959f, 
    0.08369989f, -0.11716875f, -0.18887344f, 0.10900640f, 0.09022125f, -0.00848388f, 0.01788929f, -0.16671441f, 
    -0.10027798f, -0.02605038f, -0.09648915f, -0.10061686f, -0.19252197f, -0.05645014f, -0.20736314f, -0.13582961f, 
    -0.11118288f, -0.10051416f, 0.01768188f, 0.01829862f, -0.01932318f, 0.10558819f, -0.02429243f, 0.11887912f, 
    -0.04415568f, 0.05184092f, -0.04548466f, 0.00956843f, -0.06383155f, 0.01325256f, -0.02480799f, -0.00407988f, 
    0.05800980f, 0.03084805f, -0.06466283f, 0.04982914f, -0.05157430f, -0.01546650f, -0.04138279f, -0.03225901f, 
    0.05229406f, -0.05387560f, -0.02620931f, -0.05370434f, -0.04805163f, -0.04818687f, 0.05441355f, -0.05282797f, 
    -0.06774811f, 0.02285671f, 0.00148965f, -0.04687056f, -0.07449505f, -0.06164645f, 0.05846392f, 0.01917442f, 
    -0.01711432f, -0.03326776f, 0.01693064f, -0.06424373f, -0.07168542f, 0.04306822f, -0.01319634f, -0.05724549f, 
    0.03735015f, -0.06662881f, 0.04900863f, -0.06688461f, -0.01100319f, -0.05661290f, -0.01057012f, -0.00060094f, 
    -0.07740069f, 0.02960589f, -0.00940879f, -0.05457760f, -0.00182765f, -0.03010192f, -0.07075763f, -0.01121008f, 
    0.05360106f, -0.05884923f, 0.01718972f, -0.05237499f, 0.04593642f, 0.03630549f, -0.03541002f, -0.03870258f, 
    -0.00546990f, -0.02404634f, -0.01300980f, 0.01742733f, 0.04075621f, -0.05265078f, -0.04890015f, 0.04013056f, 
    0.04339525f, -0.07764982f, -0.04568710f, -0.00213764f, -0.02066330f, -0.06793737f, 0.02186132f, -0.02564005f, 
    0.06138252f, -0.01298412f, -0.00252620f, 0.00959351f, 0.04453415f, 0.04402284f, 0.01966321f, 0.01394468f, 
    -0.02267962f, -0.00390451f, -0.02203663f, -0.07414690f, -0.06361851f, 0.00190661f, 0.04591770f, -0.05054905f, 
    0.06053818f, -0.01746840f, 0.03065134f, -0.01941399f, -0.04981107f, -0.03926884f, 0.06344233f, 0.03745081f, 
    -0.01750046f, -0.01630747f, 0.02388932f, 0.04903748f, -0.05571354f, -0.07320526f, -0.04585988f, 0.04379699f, 
    0.01804249f, -0.00602124f, -0.00228511f, -0.05122400f, -0.07276996f, -0.07016092f, -0.00953246f, 0.01589861f, 
    -0.05310139f, -0.05248948f, 0.03183096f, 0.03050528f, -0.07062534f, -0.01389271f, -0.04784378f, -0.06813097f, 
    -0.05766142f, 0.00429956f, -0.02394276f, 0.00920185f, -0.02311140f, -0.00172943f, 0.02808294f, 0.00021702f, 
    -0.01686657f, -0.02706370f, 0.04785901f, 0.02607543f, 0.01863504f, -0.02795690f, -0.02559019f, -0.03456336f, 
    -0.04010941f, -0.01324374f, 0.02910226f, 0.05874242f, 0.04573003f, -0.02522130f, -0.03145064f, 0.03977403f, 
    -0.03742156f, 0.05641827f, 0.04770175f, -0.02418215f, -0.06638838f, 0.04680028f, -0.06499635f, 0.05406192f, 
    -0.01583011f, 0.04159448f, -0.05428057f, -0.06521965f, 0.01956175f, 0.04114424f, 0.05590130f, -0.03434036f, 
    0.03434246f, 0.03187703f, 0.03333058f, -0.03970098f, 0.00962610f, -0.05066638f, -0.06483651f, 0.03678004f, 
    -0.02965941f, -0.01837265f, 0.00023798f, -0.03054118f, -0.00334352f, -0.06087760f, 0.04507979f, 0.02458969f, 
    0.04435812f, -0.01100448f, 0.00345890f, -0.04568028f, -0.06510889f, -0.06921446f, -0.06565630f, 0.04864373f, 
    -0.26742151f, -0.12013973f, 0.17022397f, 0.40494856f, -0.03310957f, 0.17078467f, 0.08396486f, -0.03529711f, 
    -0.00258094f, 0.01973461f, -0.07196567f, -0.04586389f, 0.01834256f, -0.13985564f, 0.39872950f, 0.27100575f, 
    0.00011717f, -0.17137571f, 0.20743553f, 0.19582415f, -0.04481596f, 0.00761654f, 0.01250781f, 0.18766597f, 
    0.31297818f, 0.17666127f, -0.04510741f, -0.04003512f, -0.28972629f, 0.08972540f, 0.00551678f, -0.00485865f, 
    -0.02796231f, -0.14025441f, -0.13383079f, -0.10590570f, -0.12881903f, -0.13935453f, -0.12487071f, 0.11503004f, 
    0.03905760f, 0.05939349f, -0.03767271f, -0.20851000f, 0.00737178f, 0.30863178f, -0.10962783f, 0.10570700f, 
    -0.49638677f, -0.01368592f, 0.20589285f, 0.24147494f, -0.03671894f, 0.08548813f, 0.26443374f, -0.16732414f, 
    -0.11178098f, 0.09627841f, 0.05387707f, -0.08587167f, 0.48003289f, -0.29907036f, -0.08204839f, 0.08012796f, 
    0.10323489f, -0.08166580f, 0.04616278f, -0.19206813f, 0.02995972f, -0.05721177f, -0.00910939f, 0.30598122f, 
    -0.15164824f, 0.00447526f, 0.18212757f, 0.32041550f, -0.04484262f, 0.17874721f, -0.04186766f, -0.19814599f, 
    0.10191758f, 0.07866608f, -0.08985148f, -0.08799782f, -0.16375159f, -0.35567424f, 0.08827327f, -0.03070198f, 
    0.28727913f, 0.16850062f, 0.12662083f, -0.01014718f, -0.00881087f, 0.08363501f, -0.11959603f, 0.07914033f, 
    -0.17797339f, -0.03231540f, 0.00327595f, -0.06813462f, 0.06142718f, 0.15342730f, -0.00757787f, -0.07898208f, 
    0.06444748f, -0.06539885f, -0.00488010f, 0.05167104f, 0.19417290f, 0.51253414f, -0.30218995f, -0.02294510f, 
    -0.01748348f, 0.05251117f, 0.11537519f, 0.00779354f, -0.14950480f, -0.05625864f, -0.06745722f, -0.07332688f, 
    -0.14049530f, -0.43095404f, 0.14127988f, 0.09963815f, 0.12588865f, -0.08851972f, 0.16473670f, 0.07692544f, 
    -0.06812811f, 0.01511309f, -0.03733893f, -0.06617262f, 0.21980032f, 0.49929693f, 0.53593153f, 0.14107355f, 
    -0.04108953f, 0.03451091f, 0.23392269f, 0.05392753f, -0.15673019f, -0.02958859f, 0.16183776f, 0.11630284f, 
    0.18448795f, 0.09202254f, 0.31057778f, 0.07816358f, -0.17331760f, -0.01114616f, 0.01714179f, 0.08246604f, 
    -0.02555640f, 0.09696374f, 0.07881435f, -0.14488561f, 0.09424991f, 0.05493813f, 0.06725131f, -0.16358607f, 
    -0.03775192f, 0.03126628f, -0.01119110f, -0.01385820f, 0.05122387f, 0.04465558f, -0.12843050f, -0.10289247f, 
    -0.15144026f, -0.09988347f, 0.09841675f, 0.08458776f, -0.17652954f, -0.21442801f, -0.20188099f, -0.33018300f, 
    -0.02102555f, 0.02297218f, -0.11592733f, 0.01037155f, -0.33574334f, 0.27766481f, 0.27665219f, -0.34759906f, 
    0.03600718f, -0.18434103f, -0.07271674f, -0.07930107f, 0.15615490f, 0.06730036f, 0.01626929f, 0.06244037f, 
    0.19467576f, 0.26954180f, 0.27123436f, 0.10720616f, 0.28963107f, 0.36977595f, -0.33620426f, 0.17066619f, 
    0.07011804f, -0.07680879f, -0.08055710f, 0.04162091f, 0.00582319f, 0.00055708f, -0.51545745f, 0.39695302f, 
    0.02514985f, 0.33585593f, 0.10040035f, 0.18194035f, 0.01209072f, -0.00223949f, 0.02732497f, 0.21287532f, 
    0.36043236f, -0.33520171f, 0.46325600f, 0.42084554f, -0.18533303f, 0.10437331f, -0.09179926f, 0.25308293f, 
    0.18091974f, -0.14107995f, 0.26320907f, 0.29273441f, -0.08032060f, 0.01735378f, -0.24803427f, -0.15173961f, 
    0.09157848f, 0.25154173f, -0.11566249f, 0.13882470f, -0.20424125f, -0.03362768f, -0.20297705f, 0.11182945f, 
    0.10902975f, 0.24463914f, -0.08364084f, -0.09349827f, 0.03793294f, 0.53059751f, 0.09696892f, -0.01011736f, 
    -0.07354344f, 0.10912225f, -0.09509461f, -0.03619482f, 0.13448676f, 0.15054138f, 0.32395637f, 0.04166469f, 
    0.10999320f, 0.00704343f, 0.04689542f, 0.04646917f, -0.19036499f, -0.16624790f, -0.55522591f, -0.26914600f, 
    0.12086466f, 0.27224997f, 0.21756025f, -0.27255902f, 0.24476460f, -0.12060077f, -0.01450321f, -0.04413690f, 
    -0.08256900f, -0.10385107f, -0.26106384f, -0.13008043f, 0.36667281f, 0.74249828f, 0.08327609f, 0.11974283f, 
    -0.05258517f, 0.03346889f, -0.10873761f, 0.14959870f, 0.00818116f, -0.22810808f, 0.10442251f, -0.33385584f, 
    -0.07493965f, -0.18701027f, -0.00088464f, 0.04365588f, 0.13228540f, 0.12548688f, -0.36128670f, -0.07139064f, 
    -0.13224967f, -0.13721576f, -0.05438064f, -0.18694234f, -0.23529500f, -0.05005670f, 0.27130654f, -0.12009729f, 
    -0.21348037f, 0.13517654f, 0.05298855f, -0.16938664f, 0.07699853f, 0.06873962f, 0.01513500f, 0.05921976f, 
    0.21047203f, 0.65866745f, 0.08100709f, 0.19788188f, -0.11787047f, 0.39347714f, 0.16899487f, -0.01355721f, 
    0.11532810f, 0.07310432f, -0.02127396f, 0.02451529f, 0.22173305f, -0.02245099f, 0.25290442f, 0.16388132f, 
    -0.07382632f, 0.15339188f, 0.13614100f, 0.04348407f, -0.04198096f, 0.14304498f, 0.03873643f, -0.00473714f, 
    -0.09782446f, -0.02684507f, -0.05415174f, -0.08639681f, 0.00082506f, 0.02697784f, 0.05005453f, -0.12247609f, 
    -0.04160550f, 0.23040330f, -0.11824154f, -0.10970502f, 0.10541318f, -0.13577665f, 0.18759137f, 0.14062566f, 
    -0.09953492f, -0.16218986f, -0.13513786f, -0.01044199f, -0.22259280f, -0.22386919f, 0.05931224f, 0.13935816f, 
    -0.35419160f, 0.33573928f, -0.02733887f, 0.01845944f, 0.25354162f, 0.01591311f, 0.18755123f, 0.39451250f, 
    0.02015783f, 0.25367394f, 0.12914692f, 0.04140859f, 0.43294543f, 0.16571921f, 0.40136874f, 0.27929509f, 
    -0.25467113f, -0.01208221f, -0.13659035f, 0.16060227f, -0.03856216f, 0.05097540f, -0.02179198f, -0.16161385f, 
    0.07039952f, 0.02316754f, 0.37856179f, -0.01999696f, 0.18716459f, 0.21491131f, 0.02730324f, 0.14800519f, 
    0.05968995f, -0.07148030f, 0.00604653f, 0.15174858f, 0.04153631f, 0.41336277f, 0.12461706f, -0.20313860f, 
    0.09652604f, 0.07871649f, 0.10893738f, 0.07755900f, -0.06632537f, -0.03566324f, -0.06448031f, 0.06123722f, 
    0.24803253f, -0.25412342f, -0.02410468f, -0.12074722f, 0.00256084f, 0.05712469f, 0.08430935f, -0.10111364f, 
    -0.00211803f, 0.21051373f, 0.02448590f, -0.11437834f, 0.41521192f, -0.20116659f, -0.15445919f, 0.02441103f, 
    -0.03617318f, 0.04969939f, -0.04415699f, 0.02679965f, 0.11045705f, 0.03176137f, 0.17268434f, -0.06132200f, 
    0.15104891f, 0.08104540f, 0.37222356f, 0.20325053f, 0.11536202f, 0.12368690f, -0.14281759f, -0.01896305f, 
    0.04640090f, -0.01063267f, -0.05434236f, -0.01660923f, -0.65331841f, 0.02935159f, -0.21029034f, 0.10318818f, 
    0.07560681f, -0.01313615f, -0.00343570f, -0.00144627f, 0.10157780f, 0.02588203f, 0.00695155f, 0.01701878f, 
    -0.18863946f, -0.02883584f, -0.05478336f, -0.24330197f, 0.07388095f, -0.15759622f, -0.11075028f, 0.20740075f, 
    0.03840381f, 0.01830283f, -0.28552076f, 0.31324100f, 0.09838882f, 0.13177091f, 0.19042313f, -0.10731843f, 
    -0.19281539f, -0.31667227f, -0.01225486f, 0.06760566f, -0.03091846f, -0.02285170f, 0.13018826f, -0.16099051f, 
    0.33042228f, 0.29640219f, 0.12425727f, -0.13703980f, -0.04720737f, -0.07041526f, -0.15865362f, 0.06974444f, 
    -0.01616844f, -0.09656511f, 0.19516893f, 0.08999234f, 0.12731905f, -0.38973007f, -0.00297855f, -0.01230027f, 
    -0.05914716f, 0.03459658f, 0.09464458f, 0.03181064f, 0.00284010f, -0.15063725f, -0.01262734f, -0.11112079f, 
    -0.22423857f, 0.37863609f, 0.12996300f, -0.05353249f, 0.11801404f, 0.09482805f, -0.17985550f, -0.15067774f, 
    -0.04376688f, -0.00500695f, -0.09590723f, -0.06239112f, -0.29872364f, -0.25239715f, -0.28279480f, -0.26267344f, 
    -0.06562509f, -0.00435573f, 0.14023748f, 0.11412512f, 0.20007232f, -0.13064820f, 0.10561568f, -0.11635039f, 
    0.28936556f, -0.33337796f, -0.29418427f, 0.02977346f, -0.01214543f, -0.00389507f, 0.05501718f, 0.05487125f, 
    0.08282137f, 0.13571729f, -0.08235601f, 0.11081967f, 0.20370875f, 0.19119392f, 0.21466234f, 0.18865155f, 
    0.14810748f, 0.07139092f, -0.03182932f, 0.06963412f, 0.12960576f, 0.01883462f, 0.10235786f, 0.12481955f, 
    0.20779428f, 0.12854566f, -0.05597692f, 0.04520331f, -0.09745920f, 0.10636240f, -0.00115111f, 0.33292067f, 
    -0.05547373f, 0.04088387f, -0.05830576f, -0.06188486f, 0.96466857f, -0.01181483f, 0.08385745f, 0.35269088f, 
    0.06663472f, 0.13872103f, 0.08896836f, 0.06860653f, 0.03517601f, 0.01508766f, 0.20252904f, -0.07668357f, 
    0.09778374f, 0.00335309f, -0.17289823f, -0.40157491f, 0.03663840f, -0.02779795f, 0.08394016f, 0.04443088f, 
    0.04883337f, -0.15963170f, 0.05372267f, 0.01715436f, -0.16932583f, 0.24641858f, 0.06110325f, -0.50133824f, 
    0.21996830f, 0.08535958f, -0.09179012f, -0.03727154f, 0.07829511f, -0.07030450f, -0.15873583f, -0.19009683f, 
    -0.25875536f, 0.50521839f, -0.31485212f, -0.25246409f, 0.38403723f, -0.14088167f, 0.08214111f, 0.04545091f, 
    -0.03996709f, 0.10400548f, 0.15208359f, -0.06008057f, 0.27942345f, 0.05151105f, 0.78124249f, 0.22477254f, 
    -0.03723470f, -0.18801686f, 0.00512410f, 0.23536563f, 0.16451786f, 0.12967175f, 0.15019107f, 0.07003723f, 
    0.25385809f, -0.05606076f, -0.10559039f, -0.14921488f, -0.00709494f, -0.27223465f, -0.18210225f, -0.17275223f, 
    -0.06010849f, -0.13069125f, -0.08320016f, -0.11765850f, -0.32707232f, 0.37471926f, 0.01109173f, 0.36502090f, 
    -0.20834906f, -0.06527213f, -0.02647807f, 0.06729615f, 0.19213574f, 0.30731040f, 0.54367876f, 0.44076875f, 
    -0.01897474f, -0.02310369f, 0.21221353f, 0.01731743f, 0.12051066f, 0.10102172f, 0.20415895f, 0.28034878f, 
    0.16401312f, 0.00909495f, 0.15734175f, 0.46271899f, 0.00849303f, 0.22446382f, -0.01507211f, 0.10854730f, 
    0.07785533f, 0.01568457f, -0.12255575f, 0.21651746f, -0.05659202f, 0.13106143f, 0.01509263f, 0.10506435f, 
    0.10158661f, 0.09314746f, 0.10287131f, 0.03667400f, 0.15488784f, 0.07361814f, 0.28720498f, 0.04203076f, 
    0.08062353f, 0.14154327f, 0.20750971f, 0.11402590f, 0.19128387f, -0.23623972f, 0.55840051f, 0.54713947f, 
    0.11497845f, -0.20313612f, -0.20917273f, -0.07492591f, 0.20864972f, 0.05689998f, 0.08814937f, -0.06158081f, 
    -0.21715596f, 0.22004467f, 0.04888256f, -0.18858956f, 0.11727175f, -0.07895243f, -0.11256828f, 0.20164761f, 
    -0.22345132f, -0.13369964f, -0.02663211f, -0.05069553f, 0.04969461f, 0.15594447f, -0.17775840f, -0.11649562f, 
    -0.16661482f, -0.12747651f, 0.07426533f, -0.01828422f, 0.10208835f, -0.12515764f, -0.17218703f, -0.02715105f, 
    -0.27029178f, 0.17005874f, -0.10904145f, 0.50779051f, 0.21669006f, -0.05002014f, -0.27543083f, -0.00897618f, 
    0.13142845f, -0.01435998f, 0.06819696f, -0.00260589f, -0.15946807f, -0.14384295f, -0.26927456f, 0.04972724f, 
    0.14183822f, -0.04267211f, -0.04625062f, 0.03013960f, 0.13350397f, 0.08109514f, 0.09828829f, 0.19058017f, 
    0.04739471f, -0.55948091f, -0.17921123f, -0.13474718f, 0.13874601f, 0.22923487f, 0.01038905f, 0.20814367f, 
    -0.10011020f, -0.15177326f, -0.26019549f, -0.22953956f, 0.23839737f, -0.36207196f, -0.26989716f, 0.02650334f, 
    -0.00479795f, 0.17356801f, 0.22213826f, -0.05543884f, -0.01686328f, -0.10073922f, 0.07728323f, 0.05478274f, 
    0.00753869f, 0.00713938f, 0.00214951f, -0.19226141f, 0.14010373f, 0.09121253f, -0.04266065f, -0.08929861f, 
    0.04241695f, 0.08941820f, 0.00505268f, 0.05387169f, -0.06244930f, -0.09019829f, 0.05668362f, -0.14562269f, 
    0.01244377f, 0.11176206f, 0.00816575f, 0.02377258f, 0.04561965f, 0.13394465f, -0.00243485f, 0.03560694f, 
    0.39096838f, -0.07699362f, 0.46763667f, 0.28288892f, 0.11001353f, 0.07731853f, 0.26987484f, 0.07584872f, 
    0.20952277f, 0.01674440f, 0.32422200f, 0.54906690f, -0.36268318f, 0.25189230f, 0.25028551f, -0.30789980f, 
    0.02736123f, -0.02132332f, -0.03678318f, 0.31324843f, 0.18454780f, -0.31958768f, 0.05945877f, -0.14296456f, 
    -0.10090567f, 0.23520645f, -0.20089817f, -0.06030171f, 0.24734129f, -0.13094231f, -0.19649403f, -0.00858918f, 
    0.10576250f, 0.02757097f, 0.00245341f, 0.14168094f, -0.27683717f, 0.11467675f, -0.06282469f, -0.13891514f, 
    -0.05707099f, 0.09127813f, 0.19341326f, 0.32281253f, 0.12221985f, 0.15135175f, 0.03219903f, -0.23471330f, 
    -0.08971079f, -0.03188695f, -0.12127215f, -0.00503398f, -0.00011252f, -0.08800004f, 0.13590021f, 0.18100862f, 
    -0.07138310f, -0.17025656f, 0.01283295f, -0.45290413f, 0.18534742f, -0.21857974f, 0.34471914f, 0.25151491f, 
    -0.12654139f, 0.09662487f, 0.16681632f, 0.05440828f, 0.18365146f, -0.03669788f, 0.07225206f, 0.07143246f, 
    0.03174542f, -0.01457195f, -0.28409007f, -0.07400212f, 0.07743778f, -0.01264902f, 0.03164108f, -0.17262861f, 
    -0.03771682f, -0.17207080f, 0.09325262f, -0.25023019f, -0.46354350f, -0.00138620f, 0.15505581f, -0.16154392f, 
    -0.22919098f, -0.14938976f, -0.14476922f, -0.00962643f, 0.18205963f, 0.40272310f, -0.08527894f, 0.28689206f, 
    -0.09115696f, 0.01180413f, 0.20609213f, 0.18998456f, -0.14359626f, 0.20024513f, -0.03110317f, 0.21972485f, 
    0.01422225f, 0.07943638f, 0.15253672f, 0.08945927f, -0.23126079f, 0.07629011f, -0.17215995f, -0.04462010f, 
    0.15131773f, 0.01636534f, 0.07413377f, 0.18579333f, 0.04482134f, 0.09417973f, -0.10801326f, -0.15262470f, 
    -0.23183860f, -0.08642092f, 0.25373140f, -0.13774668f, -0.13768648f, -0.07081827f, -0.03852089f, -0.06631685f, 
    0.17152870f, 0.14402999f, -0.08662619f, 0.01208327f, 0.16554588f, 0.19760153f, -0.01771797f, -0.02251211f, 
    -0.06988046f, -0.09962008f, -0.11502625f, -0.14494868f, -0.05902077f, -0.16061495f, 0.13170932f, 0.05756474f, 
    -0.20919135f, 0.01111132f, 0.01400386f, 0.03585126f, 0.34193701f, 0.13906713f, 0.29363945f, 0.27224460f, 
    0.08060589f, 0.02621015f, 0.29627579f, 0.06333004f, 0.04357522f, 0.19833049f, -0.25255278f, -0.21130088f, 
    -0.07458551f, 0.01935704f, -0.01243070f, 0.06457109f, -0.09290213f, -0.07982712f, -0.08328325f, -0.03087102f, 
    -0.07356168f, -0.06350528f, -0.10199665f, 0.11470348f, -0.15096551f, 0.04394350f, 0.04996362f, 0.19570456f, 
    -0.04811434f, 0.03602820f, -0.08327794f, 0.15269655f, -0.11953226f, 0.09192463f, 0.42272642f, 0.17636268f, 
    0.37036020f, 0.00699833f, 0.02690672f, -0.03097212f, 0.10095087f, -0.41972476f, 0.04916839f, -0.31700096f, 
    -0.48020485f, 0.44125420f, -0.14075622f, -0.24889559f, 0.20294471f, -0.20722890f, -0.07053870f, -0.08184957f, 
    -0.25900581f, -0.03374808f, -0.17392400f, -0.23920567f, 0.16706623f, 0.01915921f, 0.53451061f, 0.25451186f, 
    -0.05173990f, -0.03686374f, 0.04440206f, 0.05436295f, 0.02857564f, 0.14786728f, -0.02571661f, 0.06589058f, 
    -0.04731654f, -0.12662962f, -0.09245525f, 0.15317392f, -0.10405221f, -0.17141283f, -0.04108920f, 0.13604051f, 
    -0.09090561f, -0.03932063f, -0.04543660f, -0.05015536f, 0.47430667f, 0.12529516f, -0.16504063f, 0.24604605f, 
    -0.09161191f, -0.23354463f, 0.24806511f, -0.14256518f, 0.26899946f, 0.12703878f, 0.45253804f, 0.38979986f, 
    -0.44989166f, -0.10934070f, 0.08280282f, 0.14939389f, -0.08137209f, 0.03195431f, 0.01908037f, 0.17883664f, 
    -0.01293188f, 0.12716995f, 0.07222751f, 0.36564121f, 0.03186776f, -0.25764000f, 0.12161819f, 0.17155161f, 
    -0.02238681f, 0.00279031f, -0.03324417f, 0.10168274f, 0.00611449f, 0.23915811f, -0.04755152f, 0.09206423f, 
    -0.08082584f, 0.16775052f, 0.07017232f, 0.43725130f, 0.14286068f, 0.33916384f, 0.12747884f, 0.11639883f, 
    0.26436153f, 0.17178425f, 0.16265513f, 0.10090033f, 0.14275378f, 0.02504133f, 0.35682675f, 0.31696245f, 
    -0.08439883f, 0.05732153f, -0.09150525f, 0.08964539f, -0.05143842f, 0.02625197f, 0.05367657f, -0.14196712f, 
    -0.35442898f, -0.14787549f, -0.05685333f, 0.01755818f, -0.05106737f, -0.04185584f, -0.18623617f, 0.01435415f, 
    -0.17051934f, -0.26073200f, 0.02476236f, 0.03759830f, 0.21106872f, 0.29912180f, 0.04083281f, 0.33658367f, 
    -0.05967237f, -0.23792599f, -0.13611399f, -0.11953485f, 0.15439534f, -0.16540235f, -0.19884732f, 0.00430575f, 
    -0.14032035f, 0.45764935f, 0.48314512f, 0.20840737f, -0.03210041f, -0.03739528f, -0.35136527f, 0.08667143f, 
    -0.04067075f, 0.22935407f, -0.03348945f, -0.08166930f, -0.07291464f, -0.23730782f, -0.13377018f, -0.19886658f, 
    0.05093599f, -0.03733256f, 0.04408891f, 0.06196554f, 0.12239810f, -0.05514640f, 0.08148318f, 0.22125053f, 
    -0.09961155f, -0.29241216f, 0.16756961f, 0.32591799f, 0.24925372f, 0.38718611f, -0.03804001f, 0.17767090f, 
    -0.29542547f, -0.15548529f, -0.38204125f, -0.02795919f, -0.16796497f, -0.38078582f, -0.01441756f, 0.17409073f, 
    -0.06263840f, 0.02295762f, 0.00619736f, -0.33217901f, -0.00918391f, -0.19105776f, 0.26214394f, 0.32118338f, 
    0.05626529f, -0.14496712f, -0.16622064f, -0.07246188f, -0.25814271f, -0.04664303f, -0.00596739f, -0.17200612f, 
    -0.09038088f, -0.07347128f, -0.00979740f, -0.03469557f, 0.03990261f, -0.16361937f, 0.08212531f, 0.27491459f, 
    0.02270917f, 0.00176984f, 0.00532433f, 0.08280808f, 0.06392135f, 0.10095248f, 0.19738720f, -0.01450795f, 
    -0.37269816f, -0.13472196f, 0.46134335f, -0.35236678f, -0.01202789f, 0.12237438f, 0.06068189f, 0.04699941f, 
    -0.04678481f, -0.12703989f, -0.11372062f, -0.26502645f, 0.07497958f, 0.17956409f, -0.03550239f, 0.02645164f, 
    -0.03062029f, 0.01995462f, -0.09713360f, -0.07778224f, -0.06903853f, 0.11324857f, 0.17491426f, -0.05959161f, 
    0.08320095f, -0.00555818f, 0.04857661f, 0.15575317f, -0.18382721f, -0.03850986f, -0.12647332f, 0.11839709f, 
    0.03787885f, -0.01007428f, -0.08875360f, 0.08679534f, 0.42349014f, 0.01789018f, -0.20691104f, -0.08888160f, 
    -0.10185894f, -0.12347365f, 0.23062818f, -0.08529618f, 0.23829807f, -0.04693030f, 0.37083414f, 0.22577085f, 
    -0.31690696f, 0.18968168f, -0.06202495f, 0.06919677f, -0.03471104f, -0.04792771f, 0.26792669f, -0.00148982f, 
    -0.03399117f, 0.19139707f, -0.15502101f, 0.19838317f, 0.25846803f, -0.30397683f, 0.00562866f, -0.02120271f, 
    -0.07281611f, 0.23716749f, 0.22254162f, -0.20109671f, 0.01903654f, 0.03791609f, -0.10421526f, 0.13375767f, 
    0.01248862f, 0.16854340f, 0.00111898f, -0.03172136f, 0.16235341f, -0.03107467f, -0.07154845f, -0.03057381f, 
    0.06456097f, 0.10512069f, 0.13445871f, -0.01871051f, 0.52567917f, 0.30093884f, -0.38587445f, 0.08975880f, 
    -0.01462106f, -0.07810760f, -0.04296276f, 0.05224835f, 0.25075638f, 0.12763536f, -0.15704527f, -0.12402918f, 
    -0.02447394f, -0.11540346f, 0.11236148f, 0.13122384f, 0.01778259f, 0.00750448f, -0.10020724f, 0.07456701f, 
    0.03074682f, -0.05847259f, -0.01296538f, -0.06696866f, 0.17585696f, 0.03571199f, 0.09367517f, 0.24886857f, 
    -0.09618727f, -0.01101086f, 0.07912588f, 0.07235878f, -0.09649428f, -0.10390124f, -0.07916219f, 0.19821399f, 
    0.26653481f, -0.02608760f, 0.20166498f, -0.12605232f, -0.06070247f, 0.02804042f, -0.03248727f, 0.08774057f, 
    0.17705297f, 0.17308228f, -0.06807812f, 0.22412786f, 0.02911974f, 0.20099173f, -0.03260594f, -0.26082587f, 
    -0.05248616f, 0.06197501f, 0.05293734f, 0.04715845f, 0.13738242f, -0.05626597f, 0.11825965f, -0.13641293f, 
    0.02148678f, 0.31864646f, 0.05283022f, 0.14181408f, -0.04420258f, 0.05169488f, 0.07145909f, 0.13428295f, 
    -0.02325105f, -0.00034746f, -0.07449177f, 0.03103882f, -0.15728609f, 0.11439348f, -0.09960389f, 0.10289098f, 
    -0.02838927f, -0.08492099f, 0.02183755f, -0.02396646f, -0.02531083f, 0.00131783f, 0.00256131f, -0.04556460f, 
    -0.05315844f, 0.03345241f, 0.03017166f, -0.06239793f, -0.05609347f, 0.01699253f, -0.04728212f, 0.03014874f, 
    0.01247385f, -0.00281257f, 0.00353197f, -0.05612690f, 0.04038820f, 0.00982325f, 0.05417048f, -0.07178086f, 
    -0.04297971f, 0.03388798f, -0.02731324f, -0.01406597f, 0.04572646f, 0.01826829f, 0.02121233f, 0.02132789f, 
    0.00667980f, -0.05434436f, -0.03865961f, 0.04937509f, -0.00054051f, -0.05222403f, 0.00998737f, -0.00125874f, 
    0.03733326f, -0.01383278f, -0.05868389f, 0.06224820f, -0.02386199f, -0.05334606f, -0.05388092f, -0.01348164f, 
    -0.01013020f, 0.03385970f, -0.05328436f, 0.04750596f, 0.02029724f, 0.03017882f, 0.02597324f, -0.06487868f, 
    -0.04814836f, -0.05755565f, 0.01514208f, 0.04653010f, -0.05938476f, -0.05986145f, 0.04144660f, 0.05817657f, 
    0.02167430f, 0.06104870f, 0.04119846f, -0.06146425f, -0.03134239f, 0.05676037f, 0.02781132f, 0.00938017f, 
    -0.04618178f, 0.03433934f, -0.01846802f, 0.03749391f, -0.02868444f, -0.03961965f, 0.03073907f, -0.01502487f, 
    -0.04575452f, -0.06787054f, 0.05284557f, -0.03359780f, -0.03087332f, 0.01812944f, 0.05810177f, -0.01033256f, 
    -0.08079189f, 0.04778211f, -0.06437197f, 0.04071494f, -0.01187982f, -0.03752943f, 0.03141062f, 0.00906484f, 
    0.06212083f, -0.06286342f, -0.00177179f, -0.01033401f, -0.01673412f, 0.03645471f, -0.07890696f, -0.07567970f, 
    0.04439965f, -0.06392809f, -0.00587416f, 0.04864879f, -0.06544054f, 0.03391768f, 0.02084224f, 0.06316281f, 
    -0.07575888f, 0.05141311f, -0.00734011f, 0.00152088f, -0.00046688f, 0.04907287f, -0.06657939f, -0.06592418f, 
    0.02237292f, 0.00888816f, -0.00700861f, 0.03511256f, 0.05914691f, 0.04466986f, 0.01989209f, -0.07548859f, 
    0.05407534f, -0.02659567f, -0.06963423f, -0.05539489f, -0.01165868f, 0.00050796f, -0.05818838f, -0.02830441f, 
    -0.02200021f, -0.02771419f, -0.03754040f, -0.06729119f, -0.04485447f, -0.06859356f, -0.04267375f, 0.02845229f, 
    -0.02287507f, -0.03833845f, 0.01333760f, -0.00339715f, -0.06092954f, -0.07709917f, -0.05591185f, 0.00834538f, 
    -0.03855338f, 0.06009918f, -0.00277871f, -0.00307855f, 0.02240351f, -0.00667422f, 0.00103522f, 0.03924887f, 
    -0.04372881f, -0.00670801f, 0.03377342f, -0.04491838f, -0.07934331f, -0.03446849f, -0.05864026f, -0.05203621f, 
    -0.00447812f, -0.07832618f, 0.03632465f, -0.07441165f, -0.02448223f, -0.04660604f, 0.05174469f, 0.05012616f, 
    -0.00405569f, -0.04420860f, 0.04264577f, 0.06125933f, -0.03203955f, -0.07519508f, -0.03224653f, -0.05578688f, 
    -0.07976555f, 0.03534173f, 0.06192386f, -0.07476901f, -0.03206708f, -0.02517086f, -0.01180484f, -0.04101420f, 
    -0.07401911f, -0.02086573f, -0.01030975f, 0.01903815f, -0.05381241f, 0.04649117f, -0.03964680f, 0.01114822f, 
    -0.19574441f, 0.00314016f, 0.12536325f, 0.09553132f, -0.10502808f, -0.03201613f, 0.25463396f, -0.00126345f, 
    0.06407940f, -0.02008276f, 0.06001234f, -0.23983584f, 0.21223886f, -0.17205530f, 0.18292078f, -0.53901714f, 
    -0.25749117f, -0.04406704f, 0.25122169f, 0.40394899f, -0.00300243f, 0.04280411f, -0.10897147f, 0.18778113f, 
    0.71923035f, 0.11388785f, 0.40255573f, -0.08592450f, -0.02116784f, 0.08243375f, 0.36531019f, 0.20283495f, 
    0.01037150f, 0.20473295f, 0.16701807f, 0.17031899f, -0.28835735f, 0.00324914f, 0.13496369f, 0.19931956f, 
    -0.01567665f, 0.02462516f, -0.05186188f, 0.00295681f, 0.29804307f, 0.10164132f, 0.11930526f, 0.06864333f, 
    -0.39174896f, 0.24077237f, 0.22295891f, -0.19679804f, 0.07739852f, -0.33280763f, 0.01629222f, -0.30610019f, 
    -0.11546408f, 0.03725502f, 0.00407749f, -0.09862730f, -0.88133001f, 0.00469065f, 0.02123204f, 0.00848650f, 
    0.02270090f, 0.02382324f, -0.20781538f, 0.18384255f, -0.04365609f, 0.06546345f, -0.07263299f, 0.13623129f, 
    0.34668955f, 0.24881034f, 0.20032440f, 0.04866615f, 0.12677720f, 0.00112464f, -0.09050055f, 0.02553725f, 
    0.32408425f, -0.05249150f, 0.29570058f, 0.03569064f, -0.31769323f, -0.18891780f, 0.27166778f, 0.05196485f, 
    0.20788468f, 0.06676102f, -0.03104845f, 0.00230582f, 0.13159645f, 0.13722889f, 0.00519606f, -0.17641920f, 
    -0.06207066f, -0.02275295f, -0.01489022f, -0.30416778f, -0.13929796f, -0.29392338f, 0.15203030f, 0.10637516f, 
    -0.14256932f, -0.05023530f, -0.09323005f, -0.04270735f, -0.28512207f, 0.12846687f, 0.17128140f, 0.70254022f, 
    0.10720136f, -0.12021883f, -0.02379688f, -0.05353740f, -0.02045568f, -0.11515921f, 0.19298932f, 0.05269911f, 
    -0.20309781f, -0.24507506f, 0.11615740f, -0.22381668f, 0.18906628f, 0.12855557f, 0.19075164f, 0.27803481f, 
    -0.01749392f, 0.07783085f, -0.02290187f, -0.06305399f, -0.20726326f, 0.29499105f, 0.21561922f, -0.59936690f, 
    -0.07263666f, -0.06024598f, 0.20443216f, 0.13762617f, -0.20831217f, 0.04140231f, 0.05314650f, -0.04623479f, 
    -0.13593495f, -0.10143083f, 0.09748759f, 0.39312923f, 0.09005709f, -0.07954500f, -0.00898382f, -0.05567003f, 
    0.25524434f, -0.01348075f, 0.43959102f, 0.23882426f, 0.14998758f, -0.00618553f, 0.05376208f, 0.26166865f, 
    0.04658766f, 0.07646813f, 0.02950899f, 0.00523322f, -0.05243898f, 0.04659651f, 0.08101821f, 0.01797269f, 
    0.17523363f, -0.00785943f, -0.08227447f, -0.10654302f, 0.00535432f, -0.09001940f, 0.09354155f, -0.10240363f, 
    0.00127483f, -0.00665924f, -0.07284559f, -0.04397586f, 0.71731228f, 0.23721164f, -0.08047016f, -0.20701747f, 
    0.03747426f, 0.02661820f, 0.08589634f, 0.05954503f, -0.04583333f, 0.04645198f, -0.02964706f, 0.09177448f, 
    0.01007668f, 0.03028380f, -0.00533795f, -0.06583213f, -0.01866703f, -0.07014640f, 0.02026995f, 0.01784691f, 
    -0.01776289f, 0.03966850f, 0.04626858f, -0.02397285f, 0.04206634f, -0.03984773f, -0.07236971f, 0.06262983f, 
    0.05881673f, -0.05093770f, -0.02097180f, -0.00362426f, -0.03945351f, -0.02455763f, -0.04200783f, 0.04498047f, 
    -0.03946599f, -0.03550755f, -0.00592007f, -0.01901124f, 0.00281906f, -0.03624729f, -0.01116459f, -0.06687646f, 
    -0.06915897f, -0.01057401f, 0.02391796f, 0.03407656f, -0.06779335f, -0.02445315f, 0.04610519f, -0.02143937f, 
    -0.05274825f, -0.07220878f, 0.01261597f, -0.04114835f, -0.01601288f, 0.01901849f, 0.02824129f, 0.01755385f, 
    0.05882079f, -0.07983708f, -0.03880761f, -0.03270433f, -0.00826226f, -0.02426416f, -0.06257758f, -0.01984128f, 
    0.06231641f, 0.02652974f, -0.01793304f, 0.03869816f, -0.00487601f, 0.06048080f, -0.00374016f, -0.04261002f, 
    0.05304259f, 0.02334286f, 0.04139577f, 0.00541571f, -0.04476757f, -0.01794508f, -0.01375322f, 0.00606259f, 
    -0.04416492f, -0.01518102f, -0.02531584f, -0.00840070f, 0.02338235f, 0.02202969f, -0.07426200f, 0.01528359f, 
    0.01433804f, -0.07799575f, -0.00016425f, 0.00289543f, 0.04366389f, 0.03838357f, -0.05722874f, -0.00624181f, 
    0.04334021f, -0.03845983f, -0.06557601f, -0.05505743f, 0.02319041f, 0.04820734f, -0.07050672f, -0.00985784f, 
    0.05114350f, -0.00048094f, 0.03802120f, 0.03436616f, -0.05502946f, 0.02429604f, -0.03623230f, 0.01018078f, 
    -0.02773407f, -0.02998203f, -0.00366525f, -0.07014371f, -0.06459901f, 0.00931874f, 0.02187661f, -0.07773034f, 
    0.04696297f, 0.03638610f, -0.01160878f, 0.03774911f, -0.00085181f, -0.05689837f, -0.07427035f, 0.00383122f, 
    -0.00161598f, 0.01765568f, 0.03464362f, 0.00345075f, -0.02919651f, 0.00197474f, 0.04015420f, -0.05614186f, 
    0.03864017f, 0.05486986f, -0.00078850f, -0.04846115f, 0.05128177f, -0.06840858f, -0.04943964f, -0.07459296f, 
    -0.03996132f, 0.00378445f, -0.03940130f, -0.04013018f, -0.00562657f, -0.07499470f, 0.05956205f, -0.00081582f, 
    0.05973659f, 0.02440224f, -0.05946045f, 0.02125165f, -0.05244309f, -0.01270615f, -0.00175211f, -0.07638355f, 
    0.00227207f, -0.05069435f, -0.05946856f, 0.01978704f, -0.00259158f, -0.04915427f, -0.03313712f, -0.01077008f, 
    0.02598643f, -0.03189391f, -0.04608146f, 0.04043928f, -0.03411840f, -0.04246423f, 0.04674995f, -0.05701434f, 
    0.04051601f, -0.05493253f, 0.01940966f, -0.01871806f, -0.00081826f, 0.00936283f, 0.00043215f, -0.06287899f, 
    -0.06224626f, -0.05717741f, -0.03361016f, -0.01360971f, 0.02502905f, -0.04662576f, -0.06944606f, -0.07752772f, 
    -0.02011648f, -0.04296285f, -0.05962282f, 0.02797798f, 0.01313898f, -0.05876490f, 0.00981692f, 0.01242414f, 
    0.27052170f, 0.32692465f, 0.32029894f, 0.26959193f, -0.11989177f, 0.04062663f, 0.30226824f, 0.16320886f, 
    0.04628183f, -0.03570881f, -0.05044740f, 0.00687264f, 0.64736217f, 0.14960019f, -0.19533178f, 0.17850217f, 
    -0.16358779f, -0.02502801f, 0.28975573f, 0.28695223f, -0.13823374f, -0.08146774f, -0.01011144f, -0.06791053f, 
    0.17730455f, -0.33974501f, -0.22362176f, -0.24963121f, -0.19709280f, 0.02641974f, -0.05721295f, -0.03189440f, 
    -0.19920804f, -0.24441008f, -0.16927950f, -0.08609642f, 0.06080208f, 0.25420526f, -0.18250936f, 0.19543576f, 
    -0.15873457f, 0.04203453f, -0.10834900f, -0.25398323f, 0.09764905f, 0.13341643f, 0.04405033f, 0.11743747f, 
    0.42040718f, 0.41510424f, 0.52963591f, 0.27877456f, -0.15051942f, 0.06517800f, 0.23527838f, 0.08644156f, 
    -0.09046037f, -0.01765832f, 0.04410665f, -0.04996441f, -0.20415473f, -0.13103101f, 0.16965221f, 0.19993682f, 
    0.08974867f, -0.08668443f, -0.01748689f, -0.01780135f, 0.02471403f, 0.09242751f, -0.10719493f, 0.19628605f, 
    0.46921119f, 0.46404994f, 0.09869341f, -0.06168529f, 0.19861813f, 0.07902556f, 0.13050930f, -0.03450464f, 
    0.17335318f, 0.12185282f, 0.03681872f, -0.10448286f, 0.05626085f, -0.06787174f, 0.33698741f, 0.12594287f, 
    0.11174633f, 0.07647324f, 0.17603800f, 0.00701735f, 0.02386237f, -0.14696109f, 0.01478033f, 0.20276040f, 
    0.36346856f, 0.28654265f, 0.29384476f, 0.02281877f, -0.11877420f, -0.11204270f, -0.09394744f, 0.37020606f, 
    -0.03602043f, 0.02038938f, -0.00349472f, 0.20372489f, 0.14230794f, 0.39303318f, 0.02869844f, 0.03056720f, 
    0.10768069f, 0.02155381f, 0.22093989f, -0.02501080f, -0.03381585f, 0.06305707f, -0.16092367f, -0.11257296f, 
    0.24304797f, 0.02639505f, 0.07329180f, 0.13925220f, 0.02856429f, 0.08461960f, 0.15863115f, 0.04471221f, 
    -0.06274582f, -0.10675979f, -0.08083902f, -0.21765465f, 0.59611958f, 0.32271874f, 0.16236819f, -0.08348880f, 
    0.10199111f, 0.02476143f, 0.03163288f, 0.03035652f, -0.16053399f, -0.07456150f, 0.09007358f, 0.04149729f, 
    -0.08398885f, -0.08556546f, -0.09384402f, -0.11526425f, -0.06090012f, 0.10361364f, 0.11367495f, -0.10619849f, 
    -0.02879763f, 0.18631968f, 0.11554892f, 0.07155244f, -0.44794020f, -1.04303169f, -0.15708172f, 0.13366936f, 
    -0.01911479f, 0.13263170f, 0.01951104f, -0.00185655f, -0.11900034f, 0.04180669f, -0.18283282f, -0.19541685f, 
    0.17893066f, 0.21506961f, 0.13798138f, -0.08698767f, -0.15723947f, -0.14987221f, 0.04750290f, 0.05623487f, 
    -0.05778469f, -0.06155402f, 0.11552487f, -0.11748382f, -0.47278377f, -0.48659283f, -0.45376918f, -0.25565866f, 
    -0.18447514f, -0.05656166f, -0.03533238f, -0.04331776f, -0.11413509f, -0.04096013f, -0.35134408f, 0.05668562f, 
    0.52898216f, 0.45973593f, 0.10306065f, -0.17881268f, 0.36836487f, 0.27113980f, 0.11855405f, 0.25611103f, 
    0.09013909f, 0.09592164f, 0.07568412f, -0.08647893f, 0.53122890f, 0.17204079f, -0.51026237f, 0.43563998f, 
    -0.09707285f, 0.12283700f, 0.38272113f, -0.01048519f, -0.16363728f, -0.03966816f, -0.01107447f, 0.16675992f, 
    -0.07371164f, -0.18589312f, 0.02221392f, 0.24531645f, 0.05090894f, -0.03165663f, -0.14029969f, -0.13394260f, 
    0.01272256f, -0.07020915f, -0.09996783f, 0.18965094f, 0.13020527f, -0.04888341f, -0.19322219f, -0.13811995f, 
    -0.01178114f, 0.18221401f, 0.09721962f, -0.00244051f, 0.04623187f, 0.02200110f, -0.16865012f, -0.18894728f, 
    0.57875222f, 0.43809202f, 0.31378135f, 0.19152096f, 0.18158923f, 0.08930626f, 0.21641821f, 0.47750440f, 
    -0.03759455f, -0.07441881f, 0.02132918f, 0.03545164f, -0.50612313f, 0.16640446f, 0.07166383f, -0.02444483f, 
    0.14157538f, 0.17044434f, -0.00249681f, 0.03325980f, 0.03600583f, -0.28192118f, -0.30546385f, -0.33003134f, 
    0.44963354f, -0.10149509f, -0.27105638f, -0.20709842f, 0.27782387f, 0.08908106f, -0.21067625f, 0.08190435f, 
    -0.11086503f, -0.08909170f, -0.08201756f, -0.22934578f, 0.60497516f, 0.16187544f, 0.23371308f, -0.19682895f, 
    -0.03764989f, 0.06494945f, 0.27389407f, 0.26085046f, -0.03021792f, -0.00450871f, 0.01947916f, 0.08610389f, 
    0.62611771f, 0.36063677f, 0.06140407f, 0.01935663f, 0.13079631f, -0.08686760f, -0.10264551f, 0.49100441f, 
    -0.00378439f, -0.09389629f, 0.00306685f, -0.09227862f, 0.06956064f, 0.30813158f, 0.27415600f, -0.32339364f, 
    0.01432103f, -0.00103704f, 0.09687785f, -0.05243816f, 0.14011863f, 0.12822209f, 0.07714191f, 0.24365729f, 
    0.37441182f, 0.55564028f, 0.05750035f, 0.07390510f, 0.20589514f, 0.27483624f, -0.06741341f, -0.31150335f, 
    0.02097514f, 0.03240582f, 0.00385587f, 0.15274304f, -0.00395014f, -0.50352377f, -0.42948261f, -0.28276429f, 
    0.13064781f, 0.12091317f, -0.19042349f, 0.11818223f, -0.15598534f, 0.05157696f, 0.04897865f, -0.11638068f, 
    0.29573175f, 0.01130061f, -0.18368174f, -0.16912067f, -0.05647348f, -0.05901754f, -0.04312310f, -0.07029895f, 
    0.10236024f, -0.06434207f, 0.05891620f, 0.23377307f, -0.07156249f, -0.00823991f, 0.07437975f, -0.02573395f, 
    -0.04553942f, 0.02156988f, 0.03166707f, -0.03625396f, 0.05141453f, 0.09792241f, 0.06092382f, 0.19291410f, 
    0.16127543f, 0.11586733f, 0.03465210f, -0.05771220f, 0.01096463f, 0.10192111f, 0.00648779f, 0.12591024f, 
    0.02245964f, 0.04574503f, 0.01762296f, 0.03299138f, -0.07479197f, 0.18170653f, 0.06710684f, 0.24411336f, 
    0.03997094f, -0.04687013f, 0.00753886f, -0.04331687f, 0.01151050f, 0.08754189f, -0.04024192f, 0.16556062f, 
    0.33631641f, -0.07461928f, -0.25602967f, -0.21608047f, 0.10283870f, -0.16394441f, 0.03512225f, -0.04955528f, 
    -0.07103830f, -0.07632210f, -0.03244888f, -0.08882334f, -0.28067964f, -0.27240387f, -0.46073356f, -0.15460874f, 
    0.00825331f, -0.17855088f, 0.11274379f, -0.02117222f, -0.03322946f, 0.14244814f, 0.12629387f, -0.10287105f, 
    0.08278107f, 0.27009490f, -0.33066219f, 0.41870978f, 0.01118175f, 0.15689312f, 0.01735271f, 0.01023164f, 
    0.11883231f, 0.08848385f, 0.07214379f, 0.20427905f, 0.22599849f, 0.25480995f, 0.06379402f, -0.11682036f, 
    -0.06319335f, 0.06420238f, 0.21868217f, 0.11147065f, 0.09607164f, 0.15912712f, -0.09293588f, 0.13511215f, 
    0.05813920f, -0.30345702f, -0.14224707f, -0.42221567f, -0.00847347f, 0.12981768f, 0.18555914f, -0.23122388f, 
    -0.01004901f, -0.05556932f, 0.02490451f, -0.02855863f, 0.23093872f, -0.19442445f, 0.25054991f, -0.04888722f, 
    -0.00659908f, 0.07005265f, -0.15093303f, -0.02034166f, -0.15894589f, 0.46810353f, 0.17772342f, 0.26740158f, 
    0.37992910f, 0.01859972f, 0.30968967f, 0.31861815f, 0.03918840f, 0.24787647f, 0.20740110f, 0.03248494f, 
    0.06235899f, 0.11164459f, 0.19201976f, 0.04294454f, 0.41797677f, 0.45996952f, -0.32087570f, -0.01606734f, 
    0.08762937f, -0.09429301f, 0.00069993f, -0.03386604f, -0.09209653f, 0.01930877f, -0.02596711f, 0.07656574f, 
    -0.17094177f, -0.10199648f, -0.09518402f, -0.27887261f, 0.11166959f, 0.01104502f, 0.16602981f, -0.22994351f, 
    0.00673041f, 0.08289151f, 0.02719073f, 0.14747837f, -0.16141303f, -0.15189326f, 0.05856607f, -0.06776818f, 
    0.05243692f, 0.01415768f, 0.05699806f, -0.04369480f, -0.07215318f, 0.18496075f, 0.17850800f, 0.09577329f, 
    0.39215627f, -0.17363089f, -0.34515393f, 0.02535045f, 0.01189194f, 0.00320320f, 0.22670670f, 0.15034308f, 
    0.00247241f, -0.02723690f, 0.04491302f, 0.01194963f, -0.04119364f, -0.02211574f, 0.16529936f, 0.47173205f, 
    0.07506569f, 0.28041726f, -0.02939568f, 0.06429385f, -0.08998597f, -0.04485395f, -0.05466235f, 0.02203903f, 
    -0.12197282f, -0.30499622f, 0.19029500f, 0.16463253f, -0.07980713f, 0.08189771f, 0.26808292f, 0.09347571f, 
    0.07687315f, -0.18648572f, 0.25732014f, -0.17030668f, -0.26280206f, -0.04567956f, -0.13565874f, -0.09674322f, 
    0.01204125f, -0.06798728f, 0.06413782f, 0.07790540f, -0.07811244f, 0.06766862f, -0.14737016f, 0.03481413f, 
    -0.18539047f, -0.12959102f, 0.00581283f, 0.06874570f, -0.23162629f, 0.07751832f, 0.00442726f, -0.15025902f, 
    0.09778668f, -0.00708178f, -0.00075288f, 0.00948908f, -0.92049444f, 0.13872801f, 0.38302448f, -0.19029680f, 
    -0.01785800f, -0.03497758f, 0.01406041f, -0.07878338f, -0.10884746f, -0.00574726f, -0.16299337f, 0.08292876f, 
    0.01015436f, -0.04052661f, -0.07008894f, -0.02009554f, -0.06311096f, -0.06165082f, 0.02380811f, -0.03250092f, 
    -0.05136194f, -0.00199391f, -0.00262574f, -0.03482896f, 0.04940375f, -0.03542209f, 0.03840374f, -0.00479750f, 
    0.04624107f, -0.05115387f, -0.02691785f, 0.02526028f, 0.06133398f, -0.04956463f, 0.05430686f, -0.05832401f, 
    -0.05920329f, 0.03343460f, -0.02331104f, -0.00091253f, 0.00066821f, 0.05646082f, -0.03005149f, 0.01483831f, 
    0.02730506f, 0.04942258f, 0.06018725f, -0.06313640f, -0.00326135f, 0.01009286f, 0.04355254f, -0.06763582f, 
    0.04767474f, -0.07001693f, 0.03611031f, 0.00876744f, -0.06993164f, -0.01596156f, 0.02937218f, -0.01611235f, 
    0.02404209f, -0.01654244f, -0.07719911f, -0.07603256f, 0.03198016f, -0.04944091f, -0.06118611f, -0.00085703f, 
    -0.05416131f, 0.06318995f, -0.04796903f, 0.01471399f, 0.05678221f, 0.06713754f, 0.05514051f, -0.04526164f, 
    -0.04034796f, 0.00362252f, 0.02891663f, -0.00711281f, -0.01910334f, 0.01253996f, -0.03194677f, -0.06126700f, 
    -0.02948739f, -0.07411911f, -0.01552012f, -0.00459654f, 0.02952944f, -0.05253107f, 0.06263424f, -0.00781003f, 
    -0.07133245f, 0.05883724f, 0.02941509f, 0.04396430f, -0.04152282f, 0.00651059f, -0.00210896f, -0.03643205f, 
    0.03153838f, 0.02355788f, 0.00217519f, 0.00855656f, -0.04113683f, -0.07431023f, -0.06427421f, -0.06069048f, 
    -0.02791565f, -0.06718908f, 0.00445663f, -0.06203584f, 0.05628160f, 0.04424106f, 0.05250011f, -0.01356548f, 
    0.04964844f, -0.00172562f, 0.02579606f, 0.02086699f, -0.07461643f, 0.01914778f, -0.02805052f, -0.01334170f, 
    -0.00703130f, 0.00334134f, 0.04660520f, -0.01974064f, 0.04921462f, -0.01490858f, -0.07066676f, -0.07943996f, 
    0.05611166f, -0.06527282f, -0.03727778f, -0.04103003f, -0.05005275f, -0.01187011f, 0.04462000f, 0.03676879f, 
    -0.06895279f, -0.03442980f, 0.04988246f, -0.07058463f, -0.04189163f, -0.01788836f, -0.00035768f, -0.02663894f, 
    -0.01261751f, -0.07267768f, 0.01662374f, -0.05263604f, -0.03338449f, 0.00264814f, 0.02335732f, -0.01684834f, 
    -0.00418408f, -0.05951483f, 0.02194470f, -0.01197791f, 0.03734856f, 0.06234487f, -0.05254810f, -0.05233081f, 
    -0.00152066f, 0.06040595f, -0.07223352f, -0.06724449f, -0.04703525f, -0.03163259f, -0.02895556f, 0.04555833f, 
    -0.02768452f, 0.05200307f, -0.00625579f, -0.01977006f, -0.01121867f, -0.08000246f, -0.04507125f, -0.02728738f, 
    -0.03935478f, 0.05587649f, 0.03981031f, -0.05647307f, -0.00665190f, 0.02112211f, -0.00726387f, -0.06527328f, 
    0.02013540f, 0.03256676f, -0.07439005f, -0.07107506f, -0.00928510f, -0.01108580f, -0.06565478f, -0.04952297f, 
    -0.07059744f, 0.02741201f, -0.05935406f, 0.05959459f, 0.05161749f, 0.02653803f, 0.03926433f, 0.03385745f, 
    0.05735387f, -0.03427685f, 0.02918021f, 0.05044835f, -0.04440739f, 0.05202082f, -0.01187107f, -0.00275315f, 
    0.04646865f, -0.04818298f, 0.02714420f, 0.02142726f, -0.01939774f, -0.04743087f, -0.05437055f, 0.05570960f, 
    -0.03123215f, -0.03069027f, 0.02521893f, -0.04215742f, -0.04279789f, 0.02425640f, 0.05282791f, -0.04331396f, 
    0.00049023f, -0.01070322f, -0.02277800f, 0.04405840f, -0.00087850f, -0.00553943f, -0.06631234f, 0.05401395f, 
    -0.06224693f, -0.05502896f, -0.01646181f, 0.03889475f, -0.06094418f, -0.04746982f, -0.03501320f, -0.01403316f, 
    0.01760694f, 0.00984587f, -0.07026176f, 0.02386950f, -0.07307692f, 0.00022684f, 0.01282019f, 0.05873412f, 
    -0.03289149f, 0.00640452f, 0.04097098f, 0.01781240f, -0.02941278f, -0.05461260f, 0.00590298f, -0.04491015f, 
    0.05868742f, -0.06907050f, 0.04127527f, -0.01377455f, -0.04688470f, -0.00757417f, -0.02398314f, 0.05964353f, 
    -0.02657781f, -0.03247671f, -0.02164457f, -0.05884868f, 0.04679539f, 0.03378144f, -0.06224152f, -0.07178516f, 
    -0.01610116f, 0.00953386f, 0.01268531f, -0.03216316f, 0.04997611f, -0.03730128f, 0.04650357f, -0.06234432f, 
    0.00531483f, -0.05590100f, -0.00502699f, -0.07559893f, -0.03334088f, -0.00298514f, -0.06027056f, 0.00999177f, 
    0.01888503f, 0.00578337f, 0.03423076f, -0.04472245f, -0.00491333f, -0.03958623f, -0.03964043f, -0.04771282f, 
    0.06047236f, -0.02511430f, -0.07003028f, -0.02149288f, 0.05828938f, -0.04676991f, -0.01552904f, 0.03893442f, 
    -0.04813349f, -0.00733657f, 0.01713007f, 0.05849999f, -0.07308308f, 0.02611029f, -0.02448140f, -0.07185078f, 
    -0.01277984f, 0.05080193f, 0.06978690f, -0.02406644f, 0.01151340f, -0.00576874f, -0.01946982f, -0.00843754f, 
    0.03191668f, -0.02290837f, 0.02142668f, -0.02103771f, 0.04741053f, -0.05866305f, 0.01596180f, 0.06537730f, 
    0.01950336f, 0.02482447f, 0.03709534f, -0.02630855f, 0.02946805f, 0.04885406f, 0.05748222f, -0.01265278f, 
    0.06942490f, -0.04787268f, -0.04133205f, -0.01569560f, -0.04141763f, -0.02127327f, -0.02999884f, 0.04423834f, 
    -0.06918044f, -0.01455573f, -0.00041160f, 0.00720144f, 0.05598819f, -0.06523507f, 0.01339091f, -0.01411308f, 
    -0.06816823f, -0.02959933f, 0.01857375f, -0.03642062f, 0.01270082f, -0.05770875f, -0.05603005f, -0.04079362f, 
    0.04438356f, 0.03224871f, -0.04394072f, 0.00250842f, -0.06437901f, -0.01700565f, 0.06058747f, -0.07571337f, 
    -0.06967425f, -0.00120180f, -0.04569106f, -0.04483704f, -0.04463673f, -0.06128902f, 0.02694414f, 0.03420478f, 
    -0.06498052f, -0.04920264f, 0.01468712f, 0.02245802f, -0.00204399f, 0.06059928f, -0.05491964f, 0.03974167f, 
    0.01363277f, 0.01529558f, -0.05266875f, -0.00789017f, -0.06226947f, 0.01595374f, 0.06548178f, 0.05084158f, 
    0.07482811f, 0.14576498f, 0.08920501f, -0.12630023f, -0.00694481f, 0.21820666f, 0.12162766f, 0.30399153f, 
    -0.01495435f, -0.09406532f, 0.05005286f, 0.00016423f, 0.14126982f, 0.05951278f, -0.07871682f, -0.19590524f, 
    0.16094744f, -0.09870000f, 0.44011718f, -0.00427072f, 0.05867898f, 0.04847055f, -0.07565238f, 0.15721527f, 
    -0.15173115f, 0.25358430f, -0.36459041f, -0.07018702f, -0.04807722f, 0.06413626f, -0.04310254f, -0.08971962f, 
    0.12148642f, -0.09253003f, -0.06505375f, 0.07543496f, 0.46615368f, -0.29541910f, 0.17950077f, 0.17956716f, 
    -0.02652639f, -0.00779167f, -0.04284597f, -0.11219297f, -0.14009283f, -0.03253882f, -0.00103435f, 0.14535354f, 
    -0.29276827f, 0.39530411f, 0.18615489f, 0.29335359f, 0.25200403f, -0.04037271f, 0.34954995f, -0.00173777f, 
    -0.13334277f, 0.08341645f, -0.01875170f, -0.03094797f, -0.33615020f, 0.29574338f, -0.09403803f, 0.48034644f, 
    0.00511380f, -0.08462133f, -0.06942079f, -0.25008196f, 0.10351234f, -0.04446178f, -0.16546148f, 0.06279947f, 
    -0.04902817f, -0.14411403f, 0.11329998f, 0.02021546f, 0.05044096f, 0.00847568f, -0.33456987f, 0.09980209f, 
    0.17402171f, -0.07914281f, -0.09678735f, -0.09622018f, 0.16776071f, -0.32539660f, 0.48654869f, -0.33546352f, 
    -0.00088936f, 0.05774610f, -0.00037501f, 0.07571095f, 0.02608873f, 0.01335137f, -0.11797164f, -0.04746695f, 
    0.15882947f, 0.42802611f, 0.16617818f, -0.22844662f, 0.07303455f, 0.07178351f, -0.00979906f, 0.12653579f, 
    -0.04721233f, -0.08143765f, 0.14163268f, -0.10457468f, 0.20496111f, 0.30886796f, 0.21634956f, 0.26390183f, 
    -0.12676096f, -0.03521460f, 0.06695871f, -0.10310612f, 0.14312395f, -0.10024483f, -0.13094409f, -0.10976468f, 
    -0.33257580f, -0.30656490f, 0.33356506f, -0.20091030f, 0.28403509f, 0.06736870f, 0.33894095f, -0.03136327f, 
    0.01114973f, 0.02792317f, 0.09769117f, 0.06598974f, -0.02863278f, 0.04271169f, -0.29014200f, -0.57637960f, 
    -0.09484681f, -0.04584607f, 0.08310243f, -0.04575140f, 0.07273979f, 0.02179580f, 0.19785739f, -0.00896473f, 
    0.55144876f, -0.08284002f, 0.22677507f, 0.27996618f, -0.11485345f, -0.28485325f, -0.07455222f, -0.02009336f, 
    0.12070714f, 0.02975943f, -0.02812542f, 0.15014708f, 0.00526298f, -0.00578064f, 0.16010287f, 0.24609466f, 
    0.03333675f, -0.06069117f, 0.04366327f, -0.10850117f, 0.30055025f, 0.01714494f, 0.03808599f, 0.33802661f, 
    0.10447048f, -0.26479504f, 0.20154323f, -0.25297949f, -0.08162500f, 0.16456021f, -0.14520003f, -0.00740601f, 
    -0.11453980f, 0.03440126f, -0.01387546f, -0.02200002f, -0.15053940f, -0.19109383f, -0.08750115f, 0.05274198f, 
    0.00033941f, 0.02244805f, 0.22266778f, -0.14624666f, 0.12878437f, -0.01616229f, 0.00429706f, 0.15360695f, 
    -0.07434726f, -0.06879453f, 0.02383440f, -0.06202867f, 0.00470046f, 0.01893742f, 0.05434203f, 0.04752059f, 
    -0.03949919f, -0.04728863f, -0.00776126f, 0.01357280f, -0.06989640f, -0.04715354f, 0.00727424f, 0.04407252f, 
    -0.01213461f, 0.04853471f, -0.05749993f, 0.03620469f, -0.04909691f, 0.05716106f, -0.03403889f, 0.00888218f, 
    -0.06465286f, -0.07418018f, -0.05251127f, -0.01841705f, 0.04587434f, -0.00476320f, 0.02996581f, -0.06515574f, 
    -0.03514853f, -0.03351988f, 0.05367215f, -0.01082696f, 0.02619711f, -0.02246796f, 0.02859504f, -0.00162823f, 
    -0.03695483f, 0.05179591f, -0.06582840f, -0.02714776f, -0.03161847f, -0.07723612f, -0.06203299f, 0.02885842f, 
    -0.03137130f, 0.06337909f, -0.05945433f, -0.06406612f, 0.03474966f, 0.00998573f, -0.06204933f, -0.03633767f, 
    0.03264638f, 0.03242285f, 0.03929849f, 0.05156067f, 0.02968297f, -0.05135144f, 0.04514606f, -0.07673743f, 
    -0.06331781f, -0.00269214f, -0.01065316f, -0.03899331f, -0.01290341f, 0.00491511f, 0.00739554f, -0.00770304f, 
    0.05470875f, 0.06653193f, -0.06188991f, 0.02933956f, -0.06049179f, -0.04026189f, 0.04030847f, 0.05761837f, 
    -0.00260856f, -0.06082315f, -0.06651536f, 0.03513175f, -0.06813807f, 0.04525877f, -0.03218891f, 0.00295450f, 
    -0.04128492f, -0.04911149f, -0.04114510f, -0.03945080f, -0.01280866f, 0.04513570f, -0.00632850f, -0.07018841f, 
    -0.06488362f, 0.00872464f, -0.00951740f, -0.04670849f, -0.00411907f, -0.05357616f, -0.03617853f, -0.03093198f, 
    0.04234979f, -0.07595766f, -0.05382733f, 0.06529067f, -0.05537106f, 0.04607461f, -0.02111729f, 0.05194772f, 
    0.05764549f, -0.04516945f, -0.02065483f, -0.05829263f, -0.00760608f, 0.04984400f, -0.01207235f, 0.02708028f, 
    -0.00918428f, -0.01718230f, 0.02436127f, 0.03458519f, -0.00247554f, -0.05178513f, -0.06500147f, -0.06960392f, 
    -0.00046517f, 0.04018671f, -0.02894783f, -0.01944137f, -0.05583859f, -0.07715198f, -0.00119706f, -0.04990358f, 
    0.04919003f, 0.05208304f, 0.05576738f, -0.02753526f, -0.06425051f, -0.05644928f, -0.00698997f, -0.04420646f, 
    0.00840483f, -0.07714327f, 0.01745235f, -0.00669342f, -0.01863056f, 0.02613822f, 0.06972560f, -0.01008194f, 
    -0.04850262f, -0.06454045f, 0.05985977f, 0.05631985f, -0.06968033f, -0.03212348f, -0.05964306f, -0.03333624f, 
    0.03434378f, -0.05577506f, 0.03283365f, -0.04587301f, 0.00677887f, 0.00630228f, 0.02125563f, -0.06300391f, 
    -0.02072117f, -0.01288843f, 0.04710276f, 0.06087963f, -0.06981306f, -0.02572607f, 0.06532616f, -0.06150377f, 
    0.02211382f, -0.00335057f, -0.05068136f, -0.02818117f, 0.00778883f, -0.04173445f, -0.01867549f, 0.01400201f, 
    -0.05524632f, -0.02793843f, -0.05063797f, -0.06190309f, -0.05036475f, -0.03406101f, -0.01486499f, -0.04148749f, 
    -0.07189255f, -0.20861346f, 0.12716457f, 0.17272086f, 0.05893456f, -0.16765112f, 0.01727916f, -0.06620218f, 
    -0.10866685f, 0.01806583f, -0.11003847f, -0.11699666f, -0.20076144f, 0.32066834f, 0.03937887f, 0.15987124f, 
    -0.01154780f, -0.11563724f, -0.02803598f, -0.04118156f, -0.03010441f, 0.13668592f, 0.12778729f, 0.06621161f, 
    0.25659072f, -0.18137057f, 0.02752211f, 0.24976474f, -0.06867082f, 0.13446425f, 0.12958850f, -0.12237372f, 
    0.09034459f, 0.17942818f, -0.12839694f, -0.02598957f, -0.14905195f, -0.06471962f, -0.35688186f, -0.29553762f, 
    0.00399660f, -0.01930770f, 0.03982760f, -0.00137698f, 0.14031202f, 0.16562441f, 0.22634828f, -0.06374405f, 
    0.13117501f, -0.48482710f, -0.22359626f, -0.02756101f, -0.08467036f, 0.09202849f, -0.01201676f, 0.03413087f, 
    0.10593332f, 0.09925653f, 0.02585914f, 0.04933154f, 0.46708021f, -0.22773184f, 0.15788116f, -0.10989073f, 
    -0.04602511f, 0.09220056f, 0.04700290f, 0.04648162f, -0.03469700f, 0.07925268f, 0.27318835f, -0.00641157f, 
    0.10706685f, -0.08891242f, -0.34188175f, 0.17437069f, -0.11827512f, 0.19406338f, 0.30845544f, -0.10039897f, 
    -0.07444613f, 0.07768951f, 0.16843607f, 0.00596152f, 0.08289874f, 0.17067669f, -0.13927889f, 0.19994614f, 
    -0.06475893f, -0.10595413f, 0.41851360f, -0.01154418f, -0.07117606f, 0.07685197f, 0.02129068f, 0.16041121f, 
    -0.16772759f, -0.01029807f, 0.27404830f, 0.28957382f, -0.14863938f, 0.05538169f, 0.20944658f, 0.11682548f, 
    -0.02805327f, -0.09370884f, -0.18607031f, 0.13391212f, 0.40576378f, -0.09999392f, -0.35772976f, -0.50727284f, 
    0.02853510f, 0.01131031f, 0.00669884f, 0.20434199f, -0.23063388f, 0.09578189f, 0.17496824f, 0.05972568f, 
    0.15433644f, -0.02606441f, -0.18002030f, 0.06227922f, 0.05003544f, -0.08693102f, -0.02118356f, 0.13658303f, 
    -0.02418469f, -0.01869603f, -0.02133025f, -0.03703272f, -0.21410806f, -0.36545476f, -0.06952243f, 0.28363213f, 
    -0.07006576f, 0.05400993f, -0.13244073f, -0.03384204f, 0.05280129f, 0.04202381f, 0.12158214f, 0.02281556f, 
    0.19925648f, 0.05201228f, -0.41399908f, -0.44309399f, -0.11454737f, 0.08736563f, 0.13979653f, -0.10894884f, 
    -0.17871676f, -0.03284158f, 0.14768000f, 0.07593283f, 0.20181532f, 0.24192545f, 0.25648710f, -0.11746780f, 
    -0.04971711f, 0.00234739f, 0.02996152f, 0.03677300f, -0.00170076f, 0.22022521f, -0.02262285f, -0.12772200f, 
    -0.06275254f, 0.20852563f, 0.08461002f, -0.00676440f, -0.18399686f, -0.15483896f, -0.01365351f, -0.21927731f, 
    0.05873086f, -0.01074607f, -0.02539230f, -0.03144670f, 0.03989678f, 0.43621463f, 0.21453734f, -0.04141752f, 
    0.00408580f, -0.13221934f, -0.14291283f, -0.04721965f, 0.08701128f, 0.13351929f, 0.12985513f, 0.07888184f, 
    0.26678744f, 0.03570414f, -0.04764680f, -0.01931829f, 0.13545407f, -0.25948888f, 0.02499888f, -0.25845942f, 
    -0.13761649f, -0.08788861f, -0.15345840f, 0.00305834f, -0.21305302f, 0.05281326f, -0.16428655f, 0.11077239f, 
    -0.05574863f, -0.02939225f, 0.03860353f, 0.10852659f, -0.20704150f, 0.08607650f, 0.09619872f, 0.02613373f, 
    0.21234277f, -0.13122973f, -0.09181860f, 0.27262819f, -0.12402162f, 0.11936305f, 0.06297680f, -0.04264325f, 
    0.06803630f, 0.13007452f, -0.22341827f, 0.04942342f, 0.15980388f, 0.26477641f, -0.32806674f, -0.07247788f, 
    0.01435449f, 0.23363481f, 0.22841592f, -0.02261858f, 0.20259857f, 0.13490309f, -0.14213553f, 0.12581344f, 
    0.29537037f, -0.38722473f, -0.10637169f, -0.40157837f, -0.09910972f, 0.26491201f, 0.03676098f, 0.04802933f, 
    -0.00625516f, -0.12520741f, 0.01384586f, -0.02627697f, 0.34968713f, -0.33967873f, 0.16914940f, -0.25122747f, 
    0.16059296f, 0.15812305f, -0.14186142f, -0.01581111f, -0.07842003f, 0.30240440f, 0.22754002f, 0.15517999f, 
    0.39945784f, 0.15046230f, 0.11880675f, 0.23873459f, -0.04576110f, 0.13764389f, 0.33259118f, -0.00239966f, 
    -0.12209865f, 0.14296542f, 0.12979297f, 0.30930153f, 0.30731869f, 0.53069597f, -0.54264456f, 0.15487415f, 
    -0.00026424f, -0.27274105f, 0.12869754f, -0.07803039f, -0.04957826f, -0.02227186f, 0.03312592f, 0.20419538f, 
    -0.06058307f, -0.21486805f, 0.00066091f, 0.05862707f, 0.01574049f, 0.00471702f, -0.00627721f, -0.16578639f, 
    -0.00175844f, 0.05132719f, -0.02440722f, 0.19697529f, -0.01550129f, -0.24876477f, -0.16568410f, -0.33362314f, 
    0.11906116f, 0.04064598f, -0.03319874f, 0.15693231f, -0.07220952f, 0.11650847f, 0.14796332f, 0.18744251f, 
    0.60664421f, 0.12522364f, -0.41334125f, 0.26938424f, -0.12745507f, -0.03962239f, -0.11645641f, 0.10687089f, 
    0.03425067f, -0.04130999f, -0.04080638f, -0.06923910f, 0.07247324f, -0.15915987f, 0.41696888f, 0.62651992f, 
    0.10071628f, 0.37966964f, -0.05194784f, 0.20782079f, -0.16672726f, -0.15788229f, -0.03806525f, 0.01143056f, 
    0.03228993f, -0.25854003f, -0.14973152f, -0.24659739f, -0.00999433f, 0.13908400f, 0.36564982f, 0.06594753f, 
    0.07630043f, -0.01785407f, 0.03507047f, -0.08582357f, 0.01221284f, 0.16543832f, 0.05826633f, -0.21337910f, 
    0.01991702f, -0.01803784f, 0.00129992f, 0.14116901f, -0.18373141f, 0.16722167f, -0.11729077f, -0.13708593f, 
    -0.24855950f, 0.18827944f, -0.11918786f, 0.27287909f, -0.12380371f, -0.14060481f, 0.16252087f, -0.16309981f, 
    0.08252984f, 0.04566664f, -0.12231303f, 0.06120707f, -0.23068564f, 0.49390957f, 0.64437348f, -0.06124861f, 
    0.00426244f, -0.11606162f, -0.12631059f, -0.00669760f, -0.04960370f, 0.04205639f, -0.05128929f, 0.13050665f, 
    -0.01348922f, 0.03402321f, 0.14625353f, 0.02824756f, 0.19484414f, -0.01181859f, -0.18374342f, 0.22330491f, 
    0.02622672f, 0.06909301f, 0.02915177f, 0.12209573f, -0.15382311f, 0.43327093f, 0.08499205f, 0.33052379f, 
    0.18926431f, -0.08706243f, 0.07196412f, -0.16360876f, -0.01112269f, -0.04220817f, -0.08242112f, 0.04351440f, 
    -0.15730837f, 0.28915879f, -0.59121990f, 0.73489988f, 0.21496092f, -0.14011547f, -0.13614953f, -0.15909785f, 
    0.12478260f, 0.22199261f, 0.08742103f, 0.28213096f, 0.00178741f, -0.29872206f, -0.07932232f, -0.15940416f, 
    0.14898226f, -0.19453967f, 0.20761168f, 0.00328155f, 0.13397272f, -0.09979296f, -0.15603912f, 0.05736400f, 
    0.04320920f, -0.08192263f, -0.25173315f, 0.07336933f, 0.18520305f, 0.08582078f, 0.17407760f, -0.08429023f, 
    0.03469678f, 0.06012272f, 0.00654085f, -0.03912152f, 0.27421567f, 0.02871834f, 0.14575036f, 0.23716462f, 
    -0.04006759f, -0.02501935f, 0.10811001f, 0.00692112f, -0.09253184f, -0.13057348f, -0.19933556f, -0.17816572f, 
    0.18271662f, -0.39511961f, -0.14255653f, -0.00894716f, 0.06958354f, 0.16271286f, 0.01853253f, 0.10477576f, 
    -0.02189054f, -0.08135980f, 0.09649713f, -0.22997622f, -0.08287424f, 0.32465550f, -0.02237124f, -0.03127296f, 
    0.04156542f, 0.05415969f, 0.02748482f, 0.15128382f, -0.04538437f, -0.11064935f, 0.01939030f, 0.05919088f, 
    -0.07797592f, -0.18923630f, -0.15131180f, 0.17949334f, 0.03988781f, 0.12602052f, 0.20625740f, 0.10551139f, 
    -0.02423897f, -0.00154614f, -0.00974035f, 0.04894688f, 0.48173353f, 0.01418068f, 0.19883774f, -0.31432787f, 
    0.10655934f, 0.08781706f, 0.02663490f, -0.03032099f, 0.00641187f, 0.15451890f, 0.14922099f, 0.06272727f, 
    0.17152199f, 0.04758611f, -0.08833566f, -0.10186528f, -0.01333738f, -0.09199537f, 0.35058758f, 0.05299208f, 
    0.09265086f, -0.20744775f, 0.04216958f, 0.15243486f, -0.13629888f, -0.22330077f, -0.33426633f, 0.07257177f, 
    0.07157993f, 0.08142132f, 0.02279063f, 0.10698497f, 0.19530313f, 0.17805131f, 0.13979003f, 0.08853771f, 
    0.39245674f, 0.51033616f, -0.39794838f, -0.46758696f, 0.09465690f, 0.01807361f, -0.08282754f, -0.20810300f, 
    -0.10737459f, -0.06353695f, 0.14961471f, -0.14509629f, 0.07775323f, 0.03125878f, 0.11432392f, 0.16969214f, 
    0.04143159f, -0.18421125f, -0.02039774f, -0.37655848f, -0.14936216f, 0.01054637f, -0.08607036f, 0.08963683f, 
    0.00066541f, -0.59732795f, 0.07062869f, -0.23200366f, 0.18287729f, 0.34596220f, 0.05778009f, 0.11260841f, 
    0.13753475f, 0.12192684f, 0.18478832f, 0.06681126f, -0.20825183f, 0.01404474f, 0.19432920f, -0.08897357f, 
    0.01838159f, -0.16310436f, 0.04477989f, -0.09184090f, 0.07777741f, -0.04282840f, -0.09044936f, -0.05072111f, 
    -0.25701660f, -0.26849139f, 0.15641405f, 0.19789094f, 0.05020191f, 0.03404615f, -0.16551247f, -0.04900626f, 
    0.05031176f, -0.03099233f, -0.21678314f, 0.03426205f, -0.60355288f, 0.19029710f, 0.57874852f, -0.13457829f, 
    0.34429771f, 0.21395056f, -0.08462153f, -0.17222063f, 0.20921706f, -0.07963107f, 0.15103623f, -0.00980073f, 
    -0.02841557f, 0.33522189f, -0.18931071f, 0.27519640f, 0.21051569f, -0.04835223f, 0.02611790f, -0.05813184f, 
    0.11511083f, 0.31327614f, 0.18839012f, 0.22044006f, 0.25420204f, -0.24304520f, 0.21185941f, 0.06427196f, 
    0.24042366f, 0.04508092f, -0.01277950f, 0.18908529f, 0.13047677f, -0.00128661f, 0.01161671f, 0.10189623f, 
    -0.17249963f, -0.20240073f, -0.24762540f, 0.04059008f, 0.06959691f, 0.04518736f, -0.07300445f, -0.12855493f, 
    -0.05185671f, -0.04602562f, -0.02758592f, 0.06785501f, 0.55898583f, 0.04242429f, -0.03031149f, 0.10793479f, 
    0.05067796f, -0.05470830f, 0.02334486f, 0.06839927f, 0.01873283f, 0.13076299f, 0.07931043f, 0.14799754f, 
    -0.26033443f, -0.12669180f, 0.21629591f, 0.24049692f, -0.07661218f, 0.06116661f, 0.12338863f, 0.25505161f, 
    -0.11711411f, -0.11723512f, -0.16196619f, 0.25251555f, -0.16232987f, 0.31579012f, -0.08748609f, 0.09871627f, 
    0.10566224f, -0.15878141f, -0.12143821f, 0.04390432f, -0.17058079f, 0.14493370f, 0.09658695f, -0.15863666f, 
    -0.35792181f, -0.02960733f, 0.01724268f, 0.34814927f, -0.00348083f, 0.32528323f, 0.10426170f, -0.30382222f, 
    0.02183301f, -0.03145878f, -0.00378432f, -0.03376836f, -0.10770639f, -0.65390927f, 0.00220007f, -0.27775335f, 
    -0.09329667f, 0.11229181f, -0.07758651f, 0.11934319f, -0.04343282f, -0.02762953f, 0.29241419f, 0.12774824f, 
    -0.14774540f, 0.03791532f, 0.05437685f, 0.06403614f, -0.07672317f, -0.03611885f, -0.16509402f, 0.06048813f, 
    0.01113176f, 0.04182444f, -0.00177038f, 0.10923428f, -0.31770512f, 0.13506593f, 0.29132143f, 0.53181654f, 
    -0.03473775f, -0.08353975f, 0.12361420f, -0.01686984f, 0.19591451f, -0.06474351f, -0.04648077f, -0.01840073f, 
    -0.27324653f, 0.09421710f, -0.10631038f, -0.00288969f, -0.09770523f, -0.03843237f, 0.12664317f, 0.00547539f, 
    0.02212139f, 0.17608713f, -0.03787118f, -0.13991308f, -0.14241542f, -0.10111336f, 0.02982152f, -0.26311561f, 
    -0.27798837f, -0.35087830f, -0.11414417f, -0.06187258f, -0.01274983f, -0.06207915f, -0.01250415f, -0.03332805f, 
    -0.29211172f, -0.20727307f, 0.02782759f, 0.39825016f, 0.19408694f, 0.25110543f, 0.11432593f, 0.33236164f, 
    -0.04089136f, 0.06093316f, -0.08418791f, 0.10126550f, 0.17518151f, -0.04578711f, 0.44720617f, 0.00086263f, 
    -0.07104031f, 0.01669485f, 0.00678817f, -0.01806558f, -0.00726714f, 0.01174336f, 0.16039547f, -0.07632617f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12212822f, -0.09222852f, -0.15611221f, 0.19424231f, 0.00397273f, 0.02867014f, 0.24169815f, 0.11653534f, 
    0.24394059f, -0.11214060f, 0.05540805f, 0.12264390f, 0.10829440f, -0.03036501f, 0.11518548f, 0.35330594f, 
    -0.05135303f, -0.08447659f, -0.05060120f, 0.36779502f, -0.02485023f, -0.26994264f, -0.00422322f, 0.08578309f, 
    -0.02532690f, 0.04957494f, 0.05896402f, 0.04202721f, -0.15810718f, 0.03374318f, 0.06274863f, 0.12876381f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.28369892f, -0.09724199f, 0.10250650f, -0.79763967f, -0.14637977f, 0.04167548f, -0.88686866f, -0.16192475f, 
    -0.23159468f, -0.21662837f, -0.12415814f, -0.74486738f, 0.11614317f, 0.01600954f, 0.14680792f, -0.14345948f, 
    -0.19617763f, 0.16205411f, -0.05475958f, -0.28323722f, -0.07908107f, 0.27980053f, 0.31872040f, 0.30177888f, 
    -0.15146647f, 0.12124297f, -0.05750104f, -0.13592821f, 0.03574280f, 0.36194518f, 0.00105815f, -0.75316399f, 
    0.56942940f, -0.29362383f, -0.86343151f, 0.03164940f, -0.03871044f, 0.12712072f, -0.26149410f, 0.05980271f, 
    0.63718253f, -0.25663993f, 0.12643868f, 0.33961919f, 0.07391486f, 0.01354601f, -0.50877583f, -0.02681254f, 
    -0.71287078f, -0.34317333f, 0.13429819f, 0.25167185f, 0.17556512f, 0.41284254f, 0.19710602f, -0.02309649f, 
    -0.17313288f, 0.07904068f, 0.13582882f, -0.11073696f, 0.11202741f, 0.07155441f, -0.00883630f, -0.39065191f, 
    -0.43813458f, 0.03028283f, -0.33779559f, 0.28506061f, 0.14995323f, -0.10007780f, -0.11489193f, 0.08421867f, 
    -0.88704079f, -0.21044676f, -0.15042041f, 0.42627403f, 0.12710564f, -0.13852976f, 0.14799601f, -0.15666398f, 
    0.27039418f, 0.00046502f, 0.16983989f, 0.05684996f, -0.05058922f, -0.46432164f, -0.42712265f, 0.29306945f, 
    0.09993477f, 0.06744381f, 0.15607525f, 0.16249463f, -0.38932109f, 0.10644356f, -0.29388732f, 0.56851798f, 
    -0.24438041f, 0.28311482f, 0.18922025f, 0.33998305f, -0.09526347f, -0.08604585f, -0.31780255f, -0.01866345f, 
    -0.28331980f, 0.28635818f, 0.06377637f, -0.05421142f, 0.04868755f, -0.42964846f, -0.19729543f, -0.56135893f, 
    0.16796738f, -0.20699462f, -0.16498421f, -0.71967357f, -0.04824254f, 0.12072837f, 0.05270978f, 0.02074182f, 
    -0.15315112f, 0.13330871f, -0.52460909f, 0.03276162f, 0.47389412f, 0.34199095f, 0.41889304f, 0.22691841f, 
    -0.35506856f, 0.28401071f, -0.00751460f, -0.65109068f, 0.11401805f, -0.13840108f, -0.09553101f, 0.15433866f, 
    0.18695314f, -0.01759693f, -0.01476731f, 0.15867159f, -0.12234653f, 0.20264480f, -0.09935189f, -0.20153861f, 
    0.45800176f, 0.38132653f, -0.13517873f, -0.30167282f, -0.16551398f, 0.18272567f, 0.05365937f, -0.29304954f, 
    -0.14874472f, -0.04090646f, 0.17836972f, -0.07588627f, 0.09169333f, -0.08543731f, -0.56194419f, 0.01797328f, 
    -0.45107090f, 0.29018381f, -0.14294302f, -0.24055085f, 0.05959125f, 0.10426057f, 0.15105568f, 0.15429121f, 
    -0.34007326f, -0.60875881f, -0.09529880f, -0.74608403f, 0.21280958f, 0.22828190f, 0.12378798f, 0.25335413f, 
    -0.18767238f, -0.51817179f, -0.05544436f, -0.01580949f, 0.03344005f, -0.10607525f, 0.18015857f, -0.19050480f, 
    0.11557981f, 0.06011640f, 0.11460844f, 0.16147856f, -0.32763743f, -0.24847254f, 0.26200303f, 0.25840431f, 
    0.32331148f, 0.10552620f, -0.75823605f, -0.04203563f, 0.14199165f, 0.15519966f, 0.11365245f, -0.30585089f, 
    0.29042214f, 0.33246714f, -0.02202226f, 0.13738474f, -0.63149458f, -0.38630068f, 0.24517523f, 0.38527870f, 
    0.24746165f, -0.04257971f, -0.12104533f, 0.14608565f, 0.10782284f, -0.76579523f, -0.72747409f, 0.22109342f, 
    -0.11592618f, -0.04894060f, -0.28602409f, 0.11270471f, 0.01194496f, 0.06316852f, -0.13227925f, 0.19437464f, 
    -0.18400285f, 0.25000703f, 0.51970905f, -0.34119138f, 0.09647474f, -0.15888724f, 0.12110163f, -0.73976791f, 
    -0.43665478f, -0.12020297f, -0.08971056f, 0.38802284f, -0.15564880f, 0.10607459f, -0.02335685f, -0.26676264f, 
    0.02121057f, 0.11730768f, -0.06534670f, -0.05780890f, -0.01581347f, -0.82451123f, -0.03626390f, -0.28094372f, 
    -0.10942356f, 0.01293851f, 0.18218087f, -0.00554451f, 0.33710670f, -0.07013452f, 0.57935804f, 0.22931159f, 
    -0.30571508f, -0.44403341f, -0.33864906f, 0.50130951f, -0.03367503f, 0.01350867f, 0.33525810f, -0.48329255f, 
    -0.51863110f, -0.56873387f, 0.07512712f, -0.05958324f, -0.15956573f, -0.25048718f, -0.48276344f, 0.20442441f, 
    -0.42568195f, 0.21083918f, 0.06717556f, -0.18504786f, 0.00046202f, -0.98738968f, 0.18682769f, 0.29984373f, 
    -0.14888804f, -0.01569558f, -0.14798672f, -0.02064535f, 0.35831109f, 0.42225587f, 0.23017636f, 0.20537202f, 
    -0.32394299f, -0.01686080f, 0.25353006f, -0.09324440f, 0.13026255f, 0.03896644f, 0.01106377f, -0.03430833f, 
    0.00714047f, 0.21943101f, 0.07878924f, 0.02670222f, -0.73592836f, -0.26896572f, 0.50490212f, -0.23930049f, 
    0.31750226f, -0.04502630f, -0.03069436f, 0.40008330f, 0.05901260f, 0.00476040f, -0.08708120f, -0.15759642f, 
    -0.06286453f, 0.15759590f, 0.51884830f, 0.14738137f, -0.58169383f, -0.88314569f, -0.05887922f, -0.25957328f, 
    -0.36941421f, -0.31798398f, -0.06350941f, 0.49115643f, -0.18581404f, 0.09741186f, 0.22763567f, -0.17982760f, 
    -0.30368879f, 0.52217913f, 0.11673425f, 0.25988442f, 0.33394483f, -0.88038146f, -0.85496944f, 0.49317107f, 
    -0.08595605f, 0.44300050f, 0.14251411f, -0.15847200f, 0.02066300f, 0.00030811f, 0.15884008f, -0.56471443f, 
    0.07212611f, 0.09940120f, -0.17922859f, 0.07778670f, -0.21235429f, -0.53626090f, -0.09383845f, -0.24369301f, 
    0.58779156f, -0.41659603f, 0.49577773f, 0.10064642f, -0.03827687f, -0.06634222f, 0.07774163f, 0.25017741f, 
    -0.09912305f, -0.05004798f, -0.15746377f, -0.27345935f, 0.07953034f, 0.09383097f, -0.03449930f, -0.06891893f, 
    -0.48102567f, 0.19246224f, 0.02672803f, 0.36093181f, 0.13710886f, -0.01946507f, -0.33275697f, -0.25017011f, 
    -0.10940834f, 0.11009123f, -0.93284208f, -0.03054414f, 0.19940911f, 0.30936065f, -0.77879763f, 0.04444013f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.30475441f, -0.01399944f, 0.07881407f, -0.31674317f, -0.28485215f, 0.11232368f, -0.04176020f, -0.29139525f, 
    0.04962038f, -0.00107457f, 0.04683719f, -0.15927018f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
