#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.66089100f, 0.43422264f, 0.33111918f, 0.28381428f, -0.07569098f, 0.19850275f, -0.90139705f, -0.24734187f, 
    0.42874306f, 0.24390212f, -0.34510538f, -0.35611847f, -0.31947809f, 0.10687574f, 0.27372754f, -0.13363488f, 
    0.27189657f, 0.21270241f, -0.00429183f, -0.03479737f, -0.17258942f, 0.26070079f, 0.09344330f, 0.16577168f, 
    -0.28886801f, -0.63904679f, 1.01370418f, -0.07399411f, -0.44677594f, -0.71102208f, -0.91139144f, -0.34236953f, 
    -0.15780385f, -0.53450483f, -0.59170461f, 0.15195180f, 0.38746059f, 0.19945391f, -0.08518572f, 0.17807972f, 
    -0.11257583f, -0.08626582f, 0.12723865f, 0.18401627f, 0.04907878f, 0.20571655f, -0.03283542f, -0.49895707f, 
    -0.13059410f, 0.46957147f, -0.76332378f, -0.09871981f, -0.36260873f, -1.44700074f, -0.21404052f, 0.18896757f, 
    0.02105099f, -0.22983444f, 0.47723842f, 0.20245270f, -0.58796191f, -0.62815559f, -0.21404484f, 0.03371109f, 
    -0.09627887f, -0.10820514f, -0.01800030f, -0.19977482f, -0.08423918f, 0.00293042f, -0.10286465f, 0.01199905f, 
    0.17466217f, 0.01208121f, 0.01694233f, -0.46166918f, 0.68541282f, 0.47703686f, -0.50308996f, 0.10846149f, 
    0.39737189f, -0.25276145f, -0.37747800f, 0.12490375f, 0.46521235f, -0.24983056f, 0.03686621f, -0.26354966f, 
    -0.42121637f, -0.14831863f, 0.11329188f, -0.13117142f, -0.13450125f, -0.14869575f, -0.15789835f, -0.28302601f, 
    -0.42076463f, -0.49287906f, -0.39890227f, -0.67234373f, -0.77267939f, -0.70871097f, 0.57645839f, 1.00906265f, 
    0.66483009f, -0.35845849f, -0.72662055f, -0.93151361f, -0.41316479f, -0.02061053f, -0.00689307f, -0.07348088f, 
    -0.19429143f, 0.06685434f, -0.30196941f, -0.49667490f, 0.19219905f, 0.00573866f, -0.30999535f, -0.31976414f, 
    0.10628892f, 0.10865542f, -0.27526361f, -0.21873677f, -0.06897883f, -0.97494471f, -0.68033999f, -0.57073820f, 
    -0.05792586f, -0.50968504f, 0.31969294f, 0.05636971f, -0.48068982f, -0.18156444f, 0.83658767f, -0.10780963f, 
    -0.38489339f, -0.12611841f, 0.29025236f, 0.23785311f, -0.37304613f, -0.01662924f, -0.42396790f, -0.23063916f, 
    -0.59049994f, -0.22886771f, -0.28904128f, -0.08615202f, -0.05578265f, -0.26085785f, 1.06646514f, 0.46541286f, 
    -0.51903892f, -0.66869891f, -0.46806556f, 0.62034351f, -0.23663130f, -0.22668031f, -0.16573903f, -0.34963635f, 
    -0.05696855f, 0.16791134f, 0.30412290f, 0.22045368f, -0.13592511f, -0.13058488f, 0.03527942f, 0.50664723f, 
    -0.17383032f, -0.30478379f, -0.43156031f, -0.40506768f, -0.12750782f, 0.51998329f, 0.04243406f, -0.06661929f, 
    0.53849226f, 0.14711048f, -0.35563976f, 0.46180752f, 0.17398457f, -0.00626653f, -0.23121552f, 0.18134935f, 
    -0.12331135f, -0.24329677f, -0.03346083f, 0.08284784f, 0.26880932f, 0.25889620f, 0.19083107f, -0.45354021f, 
    -0.26710972f, 0.27014539f, -0.27024007f, 0.03621848f, -0.00842267f, -0.26999331f, 0.03511639f, 0.48364568f, 
    -0.57967120f, 0.46767399f, 0.65473175f, -0.24195997f, 0.12112780f, -0.72581917f, -0.12641671f, 0.79803187f, 
    0.36087987f, -0.34824297f, 0.00740616f, 0.27030277f, 0.04737802f, -0.11198831f, -0.46491480f, 0.48406589f, 
    -0.06411317f, -0.36290857f, -0.02055324f, -0.00929082f, -0.05117328f, 0.38397807f, 0.19678327f, -0.14931148f, 
    -0.24701561f, -0.11711335f, -0.04045422f, 0.37455761f, 0.48518211f, 0.57027376f, 0.24116741f, 0.43127313f, 
    0.39453360f, 0.28006503f, 0.01535884f, -0.08942552f, 0.15286210f, 0.45933869f, -0.22504033f, -0.10520951f, 
    0.11322442f, -0.14335032f, -0.10840634f, -0.07265528f, -0.08653897f, 0.16559103f, 0.07682224f, 0.00106312f, 
    -0.03390277f, -0.09105138f, 0.40396091f, -0.56833202f, -0.50560272f, -0.62849814f, -0.62154824f, -0.44795680f, 
    -0.11204370f, 0.33353359f, 0.54961133f, 0.22019108f, 0.30163336f, 0.36732283f, 0.30470562f, 0.43712965f, 
    -0.23458697f, -0.06571703f, -0.41851810f, -0.28986266f, -0.25170237f, -0.23760949f, -0.26212746f, -0.33248070f, 
    -0.02608125f, -0.22180609f, -0.46292576f, -0.39323094f, -0.14034240f, -0.61192548f, -0.09163952f, 0.31523195f, 
    0.11690454f, 0.14707904f, -0.55263394f, -0.16770077f, 0.11182445f, -0.43605042f, -0.49155810f, 0.17845750f, 
    0.17938550f, -0.42537290f, 0.05797013f, 0.40853027f, 0.08534683f, -0.25933921f, 0.17571487f, -0.10186800f, 
    -0.52177024f, -0.44890448f, -0.14758454f, 0.20365439f, -0.10032395f, 0.63253152f, 0.66600990f, 0.45168218f, 
    0.35003254f, 0.01362064f, -0.31701839f, -0.13624421f, -0.45486468f, -0.41958869f, -0.30686739f, -0.25589415f, 
    0.33607909f, -0.18856271f, 0.18467608f, 0.02936940f, 0.12553473f, 0.05155266f, 0.01249285f, 0.06826454f, 
    -0.04216501f, -0.27759323f, -0.09300423f, -0.02430274f, -0.24867791f, -1.03747332f, -0.46849713f, -0.16170640f, 
    -0.52298552f, -0.55000347f, 0.26722386f, -0.46399638f, -0.45224658f, -0.25503564f, 0.21709728f, -0.39022988f, 
    0.09280476f, 0.31790918f, 0.22428294f, 0.26015615f, 0.15083514f, 0.14771973f, -0.02342717f, -0.29026335f, 
    0.10329449f, 0.36879423f, 0.56046206f, 0.42287347f, -0.02418715f, 0.01659191f, -0.04481702f, 0.08599530f, 
    0.03619239f, -0.11603609f, 0.15967017f, -0.30546772f, -0.12326710f, 0.16216680f, 0.20187594f, -0.10128809f, 
    0.21709919f, 0.05682027f, -0.20487139f, -0.08285788f, 0.18901443f, -0.23043299f, 0.37113214f, 0.10505986f, 
    -0.22491011f, 0.35904929f, 0.14935400f, 0.13991094f, 0.17238730f, 0.07247221f, -0.44544619f, 1.28916872f, 
    -0.73762006f, -0.92929250f, -0.40136033f, -0.82243782f, 0.88831753f, 0.39913955f, 0.50437313f, 0.04704928f, 
    0.26019812f, 0.22881442f, -0.01807308f, -0.24173288f, -0.30156639f, -0.15901297f, 0.24278365f, -0.00190577f, 
    0.24117181f, -0.05150396f, -0.29035464f, 0.09668133f, -0.11841034f, 0.12988280f, -0.17173731f, 0.09132275f, 
    -1.34585857f, 0.07867026f, -0.51309651f, -0.46549815f, 0.00202138f, 0.33886772f, 0.43388468f, -0.18786290f, 
    0.77536249f, 0.89570367f, 0.15168662f, 0.18407604f, -0.23469079f, -0.25596523f, -0.46872446f, -0.04268557f, 
    -0.46463001f, 0.05511393f, -0.12814201f, -0.21820247f, 0.02562859f, 0.26410970f, 0.07714241f, 0.00300435f, 
    0.43822876f, 0.82675892f, 0.41195261f, -0.06523383f, -0.43774274f, -0.63721895f, -0.05988060f, 0.26606852f, 
    0.24705799f, 0.07753012f, 0.17845561f, -0.06565055f, 0.54613972f, -0.28393057f, -0.33398467f, 0.19286315f, 
    -0.04982878f, 0.18015850f, 0.10031959f, -0.29920536f, -0.16747603f, -0.00097085f, 0.01396077f, -0.17167120f, 
    -0.16196273f, 0.22987466f, -0.72940761f, -0.10328697f, -0.48926726f, -0.48371062f, -0.02289750f, -0.14566560f, 
    -0.84986311f, -0.75697052f, -0.89837116f, -0.64579153f, -0.20977975f, 0.12202654f, -0.13364162f, -0.56840205f, 
    -0.34015957f, -0.17993751f, -0.51221949f, -0.34892979f, -0.09986205f, -0.49106196f, -0.08218591f, -0.10245261f, 
    -0.00108109f, -0.04854019f, 0.02506546f, -0.11301887f, -0.02520123f, -0.01171103f, -0.05618691f, 0.25848585f, 
    0.03831079f, 0.33069175f, 0.25821146f, 0.57167894f, -0.26429856f, -0.06918407f, -0.11593579f, 0.01848771f, 
    -0.03502946f, 0.14824164f, -0.23908719f, -0.10947374f, -0.05603570f, -0.29767299f, 0.26342741f, 0.27534315f, 
    0.12569501f, -0.04472962f, -0.11941313f, 0.15811105f, -0.11079718f, -0.36762369f, -0.41395867f, -0.43134302f, 
    0.04243984f, -0.82980806f, -1.06956959f, 0.26748100f, -0.99776399f, -1.03831768f, 0.55672282f, -0.30124912f, 
    0.43019140f, 0.34055805f, 0.08644186f, -0.01590665f, 0.07284120f, -0.13263436f, 0.11824191f, 0.11361348f, 
    0.03862406f, -0.09388423f, -0.07909720f, 0.27505103f, -0.08219735f, -0.73954010f, -0.51324916f, 0.05893780f, 
    0.76890671f, -0.08199999f, 0.16687158f, -0.91857111f, -0.16325907f, 0.51392329f, 0.40283942f, 0.29937568f, 
    -0.27790383f, -0.40348884f, 0.07978493f, 0.45693752f, -0.12495169f, -0.21231242f, -0.21061482f, 0.15507208f, 
    0.21373621f, 0.17238709f, -0.44394547f, 0.05922052f, 0.45093048f, -0.13290115f, -1.00113857f, -0.47301453f, 
    0.09527841f, 0.58186841f, 0.47278941f, 0.66923702f, 0.21386446f, 0.04737434f, -0.15124553f, -0.04945349f, 
    -0.35956982f, 0.25683683f, -0.28181574f, 0.18344244f, -0.06079517f, 0.17146480f, -0.27644509f, -0.29372647f, 
    -0.10526397f, -0.36439851f, 0.18335727f, -0.06102662f, 0.07122251f, 0.28499061f, 0.34843683f, -0.66131949f, 
    0.29515913f, 0.49965698f, -0.21774246f, 0.21824732f, -0.76695710f, 0.10196159f, 0.39475879f, 0.49188057f, 
    0.05936374f, -0.51977867f, -0.23489018f, 0.01024522f, 0.39128211f, -0.49782467f, 0.46966037f, 0.07118551f, 
    0.21092238f, -0.52775025f, -0.01949152f, -0.03609758f, -0.10777613f, -0.18723662f, 0.05715610f, 0.05304007f, 
    0.08560245f, 0.37544057f, -0.34696221f, -0.27338532f, 0.44288978f, -0.10299761f, -0.52298605f, -0.06694247f, 
    0.24265844f, -0.16862485f, 0.40024087f, 0.25657648f, 0.01725427f, -0.21159221f, 0.01905319f, -0.26853213f, 
    0.16094744f, -0.35378602f, 0.17115566f, -0.01021607f, 0.10548071f, 0.47962007f, -0.29651773f, 0.54726422f, 
    0.40012679f, -0.61742532f, -0.33698544f, -0.71281302f, -0.28546831f, -0.14835273f, 0.44901672f, 0.53137463f, 
    0.08467463f, 0.47843260f, -0.27943903f, 0.25620779f, 0.02486498f, 0.20294145f, 0.08953891f, -0.00074082f, 
    0.05877495f, 0.05714254f, 0.13668416f, -0.07833485f, -0.05643893f, -0.16015366f, 0.10321585f, 0.08027698f, 
    -0.14986712f, 0.20687196f, -0.93851191f, 0.26360038f, -0.69163620f, -0.64394182f, -0.56397676f, 0.21126537f, 
    0.40574005f, -0.14358802f, -0.18940893f, 0.60547173f, 0.44239524f, 0.10092948f, 0.36772838f, 0.14421649f, 
    0.13713150f, -0.11090977f, -0.11007604f, 0.05620151f, 0.09757293f, -0.11872968f, 0.16778468f, -0.04942061f, 
    0.17592952f, 0.10020953f, -0.26157513f, 0.07839940f, -0.60696000f, -0.44122732f, -0.58425659f, -0.07258656f, 
    -0.39283335f, -0.59178478f, 0.40417460f, 0.65982205f, -0.17506652f, 0.13871942f, -0.58432156f, 0.64591396f, 
    -0.57662022f, 0.15498716f, 0.27313566f, -0.41713926f, -0.04310426f, -0.11895798f, 0.25697514f, -0.21617322f, 
    -0.03651598f, -0.15974586f, -0.16045247f, 0.22012304f, -0.89737731f, -0.47348410f, 0.44232079f, 0.41469872f, 
    0.18035537f, 0.95205861f, 0.62705046f, -0.59458315f, -0.48681104f, 0.00047090f, -0.22780208f, -0.10957118f, 
    -0.32865751f, 0.34350789f, -0.33549497f, -0.03320114f, -0.09848660f, -0.25038210f, 0.20618293f, 0.06243225f, 
    -0.01184069f, -0.25287250f, 0.14192668f, 0.18241623f, -0.22893305f, 0.57536727f, -0.75619048f, -1.03626466f, 
    -0.73648798f, -0.68386310f, 0.32535776f, 0.09623775f, 0.27311996f, 0.34503883f, 0.13576253f, 0.03053082f, 
    0.80031335f, -0.01734196f, -0.26368946f, -0.28040192f, -0.23880641f, -0.12808843f, 0.10092062f, -0.36461735f, 
    0.28167194f, 0.09508590f, 0.03671694f, -0.32908845f, 0.28813758f, 0.39885297f, 1.05262184f, 0.43658367f, 
    0.46635544f, 0.47088766f, -0.70902866f, 0.18941222f, -0.49192312f, -0.44467700f, -0.40700042f, -0.69045067f, 
    0.08694257f, -0.38363123f, -0.30201456f, -0.10753532f, 0.06037062f, 0.21369797f, 0.28249457f, 0.35030374f, 
    -0.17464596f, 0.20316555f, -0.10436289f, -0.03603461f, -0.19803283f, 0.15951769f, 0.05169173f, -0.92489523f, 
    -0.65403461f, -0.72147316f, -0.02981732f, 0.16077030f, -0.39021233f, -0.29034841f, -0.14854839f, -0.04894524f, 
    0.26843131f, -0.47106367f, -0.41653937f, 0.14063966f, -0.11562017f, -0.37192231f, 0.20487964f, 0.05253785f, 
    -0.07519976f, 0.03899156f, 0.12078953f, -0.36465624f, -0.39766285f, -0.17418697f, -0.26268259f, -0.48657757f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11196546f, 0.26412424f, -0.03173688f, -0.02884664f, 0.05455261f, 0.02786596f, 0.48451400f, 0.16122104f, 
    0.32778302f, -0.08858285f, -0.13534933f, 0.16214238f, 0.02060283f, -0.22237125f, 0.19295277f, 0.34894747f, 
    0.19237775f, 0.51533860f, -0.21160169f, -0.03634303f, 0.11033241f, 0.32036337f, 0.38729081f, 0.30125356f, 
    0.06424136f, 0.01163193f, 0.16050750f, 0.40964589f, 0.32528973f, 0.50835204f, 0.24944860f, -0.18316257f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.13416168f, 0.26991400f, 0.17549922f, -0.62672567f, -0.14243817f, -0.24348718f, 0.01164900f, 0.01204401f, 
    0.07772771f, -0.04614910f, -0.12276948f, 0.03211061f, 0.18405166f, 0.17527211f, -0.20401745f, -0.24480590f, 
    -0.09274154f, -0.10057700f, -0.08475722f, 0.03642367f, 0.14200813f, 0.08884557f, 0.06379793f, 0.03748753f, 
    0.04385915f, 0.09967287f, 0.04930816f, -0.11725723f, -0.09146604f, 0.29860684f, -0.03975928f, 0.04266840f, 
    0.01605338f, -0.03579444f, 0.01581376f, -0.09610311f, -0.89081913f, 0.21931629f, -0.15261741f, -0.08940325f, 
    0.00419204f, 0.10471378f, 0.02614556f, 0.04739870f, -0.02836979f, 0.06542394f, 0.06584179f, 0.03520956f, 
    0.52703416f, 0.28369230f, 0.08156413f, -0.40066099f, -0.07695322f, -0.07882357f, -0.01424120f, -0.01984922f, 
    -0.04185911f, -0.02074609f, -0.03387377f, 0.02868301f, 0.32691279f, 0.17738716f, 0.01808024f, -0.18525167f, 
    0.08710782f, 0.12510246f, -0.10941692f, -0.21114129f, 0.05747925f, -0.19610235f, -0.07246629f, 0.05750552f, 
    0.07958382f, -0.42148563f, -1.08961976f, 0.08421335f, -0.01359936f, -0.06977316f, -0.44103771f, -0.09646125f, 
    -0.16003837f, 0.03435504f, -0.12172712f, 0.00607082f, -0.33538395f, -0.04278069f, -0.11313920f, 0.11401875f, 
    0.02226096f, -0.04107083f, -0.04226822f, 0.00177136f, -0.07027803f, 0.11766787f, -0.06155857f, -0.22720128f, 
    -0.77118486f, -0.15655994f, 0.25093150f, 0.14164910f, -0.07990640f, -0.05042037f, -0.09795202f, 0.07267714f, 
    -0.07285622f, -0.12934177f, -0.02392038f, 0.04792066f, -0.08496323f, -0.05528762f, 0.01480883f, 0.05805416f, 
    0.10297767f, 0.03755322f, 0.05293697f, 0.03981003f, -0.07068611f, 0.05541140f, 0.10092758f, 0.03837993f, 
    0.17977552f, -0.14080204f, -0.03102928f, 0.05456773f, 0.07489139f, -0.03695806f, 0.01821740f, 0.01619272f, 
    -0.10268894f, 0.01705517f, 0.05373703f, 0.35496464f, 0.27623492f, 0.16764289f, -0.16432114f, 0.04803176f, 
    0.00975944f, 0.01922933f, 0.01762439f, 0.06696933f, 0.02682956f, -0.03797913f, 0.07735200f, -0.15503545f, 
    -0.14156155f, -0.07904731f, 0.02907139f, 0.29398519f, 0.01988127f, -0.07345130f, -0.06847122f, -0.03502438f, 
    -0.06580964f, 0.04333996f, 0.10580152f, 0.14272659f, 0.39609730f, 0.25259110f, 0.04500432f, -0.15042624f, 
    -0.06335518f, 0.18483330f, -0.14524785f, -0.03425191f, 0.00843927f, -0.06973483f, 0.03954703f, -0.03481112f, 
    -0.04458138f, -0.00236490f, 0.08517698f, 0.00141612f, -0.30671495f, -0.10381025f, -0.18874173f, 0.00987256f, 
    -0.04572582f, -0.08778927f, -0.09680694f, -0.00334280f, -0.01152037f, -0.28950700f, -0.51306909f, 0.10161261f, 
    0.11161594f, 0.07699183f, -0.15479486f, -0.14394853f, -0.02924288f, 0.07394481f, -0.18195930f, -0.02389823f, 
    -0.08580930f, 0.08174129f, 0.27908352f, -0.09740983f, 0.07365852f, 0.10650050f, 0.04503177f, -0.03392795f, 
    0.01755409f, 0.06729290f, -0.16838847f, -0.07005346f, -0.22924078f, -0.54893184f, -0.21578614f, 0.08491555f, 
    -0.01277434f, 0.07187958f, -0.07220865f, -0.05922422f, -0.26835436f, -0.11984047f, -0.16824146f, -0.19422799f, 
    0.30679783f, 0.37150997f, -0.24044321f, -0.10250054f, 0.10459191f, 0.21419068f, 0.04577440f, -0.00608909f, 
    -0.08632164f, -0.20181361f, -0.21967040f, -0.18138407f, -0.02818364f, 0.04409599f, 0.00229319f, -0.10153975f, 
    0.00560790f, 0.02274488f, 0.05851717f, 0.03273592f, -0.03519827f, -0.00831825f, 0.03984068f, -0.23751687f, 
    0.44358081f, 0.19819446f, -0.11193278f, -0.40585101f, -0.03425426f, 0.02746860f, -0.07843551f, 0.20515791f, 
    0.05635006f, 0.06315824f, -0.05376324f, -0.04520934f, -0.05475352f, 0.11740115f, 0.38853630f, -0.54762197f, 
    -0.08527109f, -0.06485652f, -0.11901485f, 0.00365384f, -0.08538282f, 0.01077560f, -0.11599717f, -0.19646387f, 
    0.10807809f, 0.01493214f, -0.03316205f, -0.28188249f, -0.11232966f, -0.06753559f, 0.14774269f, 0.02009301f, 
    -0.11741187f, -0.08301270f, -0.11449938f, -0.25550786f, -0.89878243f, 0.11172561f, 0.40512460f, -0.13264903f, 
    -0.06759249f, -0.00660717f, -0.03578977f, 0.08050076f, 0.10515403f, -0.13223186f, -0.07638691f, -0.06223490f, 
    0.03727971f, 0.09683967f, 0.04096067f, 0.09360173f, -0.18921216f, -0.04205978f, -0.32108727f, -0.08063950f, 
    -0.04793402f, -0.02686337f, -0.01326748f, -0.13064378f, 0.08730710f, 0.03468681f, -0.13379362f, 0.08488336f, 
    0.09361951f, 0.16077781f, -0.02382940f, -0.03182881f, -0.09888369f, -0.00452343f, -0.05534180f, 0.01622458f, 
    0.22715546f, 0.12983669f, 0.01079681f, 0.10170057f, 0.11788470f, 0.07914939f, -0.00524095f, -0.04604490f, 
    0.00411068f, -0.07178847f, -0.05598792f, 0.06786745f, 0.10318774f, 0.07454906f, 0.07103994f, -0.26552525f, 
    -0.01281151f, -0.02055508f, 0.01728463f, -0.10518983f, 0.01713786f, -0.14596447f, -0.02531460f, 0.02436025f, 
    0.65870434f, -0.41906914f, -0.41783085f, -0.30202082f, -0.03632048f, -0.14118755f, 0.09903150f, 0.03946285f, 
    -0.10390608f, -0.18306729f, -0.02811808f, -0.09004956f, 0.19371866f, 0.00889716f, -0.24610576f, -0.19078666f, 
    0.15994577f, -0.00041587f, -0.06730541f, -0.08422931f, -0.11874530f, -0.03182854f, 0.11571600f, -0.00217136f, 
    -0.15186825f, -0.07750390f, -0.09765180f, -0.08877061f, -0.08408532f, 0.08724213f, -0.32247081f, 0.00522816f, 
    -0.10143964f, 0.04814436f, 0.04454861f, 0.06926216f, 0.47888163f, 0.32231712f, 0.18696804f, -0.00479515f, 
    0.22361337f, 0.17641295f, 0.17755155f, -0.06109349f, -0.10516491f, -0.09071615f, -0.00369952f, 0.08084806f, 
    -0.60422450f, 0.27904278f, 0.12137354f, -0.32105500f, 0.28633806f, -0.12446772f, -0.04498379f, 0.04071625f, 
    0.01988560f, 0.05499944f, 0.03761439f, -0.03857427f, -0.02441194f, -0.08408883f, 0.14789689f, -0.16031370f, 
    0.00664929f, -0.00329708f, -0.30280003f, -0.05719606f, -0.04099718f, 0.02528881f, -0.01720636f, 0.13086002f, 
    0.21359156f, 0.27353531f, 0.10913067f, -0.01715193f, 0.15266827f, -0.12374141f, 0.08003350f, 0.03560148f, 
    -0.02083484f, 0.01110202f, 0.01003839f, -0.29566279f, 0.13388565f, 0.19561811f, 0.12210213f, -0.01594494f, 
    0.01032587f, 0.04082951f, -0.11932664f, -0.06995039f, -0.51919174f, -0.34669000f, -0.32823578f, -0.05069922f, 
    -0.84008271f, -0.10425761f, -1.03005600f, -0.37506419f, 0.03067847f, -0.16700725f, 0.13486689f, 0.08048838f, 
    -0.04772237f, 0.00822240f, -0.10481486f, -0.10342956f, 0.23779194f, 0.00599799f, 0.03183806f, -0.01933588f, 
    0.10373435f, 0.11374570f, 0.08245861f, -0.09274743f, -0.09403438f, 0.01475593f, 0.23454361f, -0.34730822f, 
    0.33565873f, -0.33702427f, 0.00206126f, -0.07064538f, 0.11123479f, -0.05874978f, 0.10811085f, -0.11047194f, 
    0.28585795f, 0.28782079f, -0.11800358f, 0.16931891f, 0.36603320f, 0.08840786f, 0.05961836f, 0.25082129f, 
    -0.07799938f, 0.03989371f, -0.00490396f, -0.04906137f, 0.01880009f, -0.15046066f, 0.05857571f, -0.04540598f, 
    -0.04814348f, -0.46926722f, 0.31326619f, 0.17599927f, 0.02008802f, -0.09047415f, -0.12796156f, 0.02905791f, 
    -0.05013204f, 0.01859728f, -0.10102770f, 0.15801744f, 0.25189167f, 0.12372954f, 0.22196960f, 0.20917574f, 
    -0.05817620f, -0.06345589f, -0.00485083f, -0.06957553f, -0.00177753f, -0.04309404f, 0.06017989f, 0.01171296f, 
    -0.18763952f, -0.33488604f, -0.21684843f, -0.19191502f, -0.04928504f, 0.04467339f, 0.06145077f, 0.00223245f, 
    0.13316682f, -0.22228980f, -0.13272177f, 0.07247341f, 0.04853492f, -0.00943969f, -0.06662104f, 0.09110928f, 
    0.22329500f, 0.06854028f, 0.08502696f, -0.11439385f, 0.15374289f, -0.11479611f, -0.08496515f, 0.02387965f, 
    0.16504398f, 0.16761678f, 0.00375864f, 0.04591120f, -0.04129535f, -0.08167929f, -0.09154557f, -0.05092487f, 
    0.02798526f, 0.05351142f, -0.00252282f, -0.03368128f, -0.20381203f, 0.22182122f, 0.29449880f, 0.28138581f, 
    0.00394609f, -0.00014280f, -0.14643562f, 0.17835616f, -0.21653140f, 0.03368360f, 0.06784806f, -0.06052829f, 
    -0.02857940f, 0.04852978f, 0.06036903f, 0.04356907f, 0.15327269f, 0.05320172f, 0.04741142f, -0.11742420f, 
    -0.20452331f, 0.06236993f, -0.06891144f, 0.03894430f, 1.05389786f, -0.08123330f, -0.00278899f, -0.15874018f, 
    -0.09371653f, -0.08176704f, -0.06411699f, -0.12882809f, -0.02066507f, -0.19047549f, -0.03558374f, 0.15269817f, 
    -0.24516352f, 0.19081295f, -0.21022774f, -0.33294427f, -0.07416572f, 0.07451816f, -0.09373316f, -0.00536249f, 
    -0.03550449f, 0.07738853f, -0.19454716f, 0.11427540f, 0.36892825f, -0.04272411f, 0.33942538f, -0.15074523f, 
    -0.05571448f, 0.06120848f, 0.11778159f, -0.09063172f, 0.05348381f, 0.13002737f, -0.21706843f, -0.03613155f, 
    0.11829425f, 0.01925206f, -0.03028653f, 0.36527729f, -0.03538569f, 0.14470170f, -0.01395143f, 0.13388090f, 
    0.02437470f, 0.04722428f, -0.04870203f, 0.07054928f, 0.01149060f, 0.01262579f, 0.08661246f, 0.17284723f, 
    0.00701236f, -0.06774238f, 0.01204632f, 0.04097645f, 0.06110515f, 0.01769312f, -0.08478136f, -0.08070014f, 
    -0.13648352f, 0.19614953f, 0.01962594f, -0.06043902f, -0.21135204f, -0.02000900f, 0.30623198f, -0.28574735f, 
    -0.06737909f, -0.00161307f, 0.05819745f, 0.06362199f, -0.54256797f, 0.39720196f, -0.08722587f, -0.13863303f, 
    0.15795231f, -0.01943783f, 0.09462493f, 0.07542022f, 0.03629670f, 0.05445936f, -0.00384485f, 0.00977765f, 
    -0.08924296f, -0.31890479f, 0.14603956f, 0.36708847f, -0.05044739f, 0.03905534f, 0.10068673f, 0.00268085f, 
    0.12689471f, 0.07802745f, -0.00635834f, 0.17943902f, -0.32993183f, 0.02162452f, 0.32518265f, 0.01868708f, 
    0.02822952f, 0.03043464f, -0.03678793f, -0.01123656f, 0.09561938f, 0.21918888f, -0.32012662f, 0.06541459f, 
    -0.01679285f, -0.03356964f, -0.08473884f, 0.06575178f, 0.30770376f, 0.03485011f, -0.08984199f, -0.02491023f, 
    -0.20024468f, -0.09559218f, -0.00632775f, 0.12611075f, -0.08006317f, -0.19884560f, -0.15133911f, 0.03168270f, 
    -0.06284886f, 0.02094668f, 0.06727123f, -0.07718949f, -0.12102588f, -0.08561915f, 0.05108023f, -0.09024200f, 
    -0.31870535f, -0.23356226f, -0.07376150f, -0.23303659f, 0.04441538f, 0.02689977f, -0.05771396f, 0.15767883f, 
    -0.15192088f, -0.03325088f, 0.11539049f, 0.04245707f, -0.36645681f, 0.12334834f, -0.27974528f, 0.11717001f, 
    -0.02040152f, -0.00176043f, 0.05707336f, -0.39118731f, 0.12006333f, 0.00754139f, -0.09052298f, -0.15275255f, 
    0.64981622f, -0.47896597f, 0.27434579f, 0.12693696f, -0.06226893f, -0.05265969f, 0.03153993f, 0.02045407f, 
    0.06660270f, -0.08731996f, 0.30347329f, 0.08139047f, 0.31094241f, -0.17409043f, -0.19983965f, -0.23773101f, 
    0.09602962f, 0.23879865f, 0.05228387f, -0.04176629f, 0.06122740f, 0.08387561f, -0.07871308f, 0.03532539f, 
    0.37403452f, -0.01305168f, -0.09200109f, -0.27648586f, -0.06483699f, -0.27510369f, -0.27189398f, -0.10334588f, 
    0.03568901f, -0.00335108f, -0.00366273f, 0.06484168f, 0.07562396f, 0.22915946f, -0.10003688f, 0.16460620f, 
    -0.14834550f, -0.12469636f, -0.12216038f, -0.27958691f, 0.01200707f, -0.04557781f, -0.18327454f, 0.03689371f, 
    -0.26049453f, 0.05841708f, -0.03254418f, -0.00871587f, 0.07712243f, -0.01599715f, -0.01549758f, 0.16258875f, 
    -0.03118113f, -0.00075176f, 0.01172569f, 0.05311992f, 0.00016515f, -0.37962806f, -0.18915275f, -0.17305779f, 
    0.22281094f, 0.14457645f, -0.31988695f, -0.20177406f, 0.00265133f, 0.04265351f, -0.02925104f, -0.03000094f, 
    -0.34599829f, 0.40120602f, 0.27345589f, 0.56501275f, 0.02575695f, 0.02198954f, -0.00216280f, -0.10786323f, 
    0.03679970f, -0.02753345f, -0.05056683f, -0.09905637f, 0.15934362f, -0.16709623f, -0.08189550f, -0.04132019f, 
    0.05340643f, -0.00473315f, -0.04447698f, -0.01306631f, 0.06816062f, 0.22202675f, 0.04019487f, 0.17318602f, 
    -0.20365681f, 0.84821886f, -0.27976912f, 0.11103427f, -0.04124787f, -0.04114640f, -0.18055037f, 0.01229588f, 
    -0.05141740f, -0.06461398f, 0.03245630f, -0.04331481f, 0.27194405f, -0.14443202f, 0.61848736f, 0.35179114f, 
    -0.07290377f, 0.01117322f, 0.02197982f, 0.15430400f, -0.05409960f, -0.24403445f, -0.17622821f, 0.05397832f, 
    -0.40224522f, 0.07967558f, 0.31479335f, -0.32618427f, 0.03880920f, -0.18905497f, 0.09084634f, -0.37170759f, 
    -0.04804788f, -0.14576589f, 0.11677581f, 0.02754650f, 0.01135402f, -0.14388722f, -0.12778571f, 0.11121527f, 
    -0.01536390f, 0.02732332f, -0.07719330f, 0.12835097f, -0.13180323f, 0.06256291f, 0.01714353f, -0.26360255f, 
    0.33467644f, -0.25379860f, -0.34626460f, -0.11344878f, -0.07206837f, 0.23948130f, 0.09367553f, -0.03849825f, 
    0.00650437f, -0.10706301f, -0.08123463f, 0.19474316f, -0.11347504f, -0.08197287f, -0.22440432f, 0.05702350f, 
    -0.02690360f, -0.04923835f, 0.11335341f, 0.05424416f, -0.04787395f, -0.14599587f, 0.24179670f, -0.04664239f, 
    -0.14185020f, 0.45412722f, -0.11607743f, 0.23276344f, -0.05659147f, 0.01547133f, 0.04825463f, -0.29102820f, 
    0.04935371f, 0.09082611f, 0.05964849f, 0.15436786f, 0.17512576f, -0.29169297f, 0.16815877f, 0.11583148f, 
    0.13393386f, 0.09510390f, 0.14222458f, 0.19708011f, 0.08347331f, 0.10966066f, 0.00756970f, -0.06668534f, 
    -0.07578828f, 0.12354416f, -0.13529947f, -0.21155864f, -0.01343458f, -0.08618486f, 0.02236781f, 0.07015859f, 
    -0.00423511f, 0.07450633f, 0.11611138f, -0.10882243f, 0.04852147f, -0.29664996f, 0.17770243f, 0.33779949f, 
    -0.26687387f, -0.02915567f, 0.00691627f, -0.06136872f, 0.04244613f, -0.00755266f, -0.02013248f, 0.04352426f, 
    -0.03301019f, -0.01131371f, -0.05693762f, 0.11605950f, -0.06555624f, -0.12347372f, 0.10679813f, -0.03226897f, 
    0.06079851f, 0.08702605f, -0.08852512f, 0.11995090f, -0.45182967f, 0.60463160f, 0.34116432f, -0.05248944f, 
    -0.01691663f, 0.02738728f, -0.14852458f, -0.11511369f, 0.11034784f, 0.01255812f, -0.03210050f, 0.18056455f, 
    0.01293103f, 0.17915545f, 0.02702260f, 0.34791487f, 0.06829000f, 0.07709428f, -0.12134787f, -0.07166157f, 
    -0.04598885f, -0.08140945f, -0.17886336f, 0.02916459f, -0.13591237f, 0.17159225f, 0.10512784f, -0.18224253f, 
    0.03893960f, 0.03058293f, -0.06798999f, 0.02071038f, 0.14779009f, -0.00960321f, -0.19937012f, 0.17156841f, 
    -0.76307547f, -0.65912288f, -0.31189382f, -0.30202070f, 0.17893696f, -0.06275893f, -0.12823607f, -0.01075894f, 
    -0.04393142f, -0.06908222f, 0.05491724f, -0.03860397f, 0.02999663f, -0.10653125f, -0.19375189f, 0.02275934f, 
    0.00467031f, -0.03209286f, 0.06140716f, 0.01187843f, -0.09980724f, 0.08343544f, -0.16912432f, -0.17898856f, 
    -0.88374561f, -0.50832093f, -0.41945145f, -0.15216190f, -0.10131218f, -0.17018947f, 0.19770822f, -0.07364736f, 
    0.06408852f, 0.04187479f, 0.03189499f, -0.06084983f, 0.03848004f, 0.12477810f, -0.27338007f, 0.18631442f, 
    -0.03284027f, 0.03792678f, 0.04919082f, 0.13426138f, -0.03958095f, 0.10929050f, -0.11256970f, 0.12490522f, 
    -0.07668149f, -0.14688942f, -0.18052103f, 0.14449774f, 0.09451746f, -0.03158071f, 0.02183883f, -0.02336831f, 
    0.00686213f, -0.07146973f, -0.10281332f, -0.09810697f, 0.05337611f, -0.34755638f, -0.51287001f, 0.07319430f, 
    0.01771743f, 0.06031885f, 0.00055414f, 0.04035241f, -0.10779931f, -0.09324612f, 0.21107879f, -0.13552982f, 
    -0.10947975f, -0.16518396f, 0.08677484f, -0.02931109f, -0.08048511f, 0.01264930f, -0.07520849f, 0.09020599f, 
    0.02361803f, -0.05910548f, -0.00677384f, 0.07908259f, -0.11402187f, 0.14664084f, 0.20710559f, 0.06299443f, 
    -0.01099427f, -0.05873121f, 0.11988261f, 0.10472438f, -0.01446357f, 0.07195679f, 0.08475510f, 0.03720821f, 
    0.43927178f, 0.02279248f, 0.26508227f, 0.20982856f, -0.04923038f, -0.01539291f, 0.01251080f, -0.11773635f, 
    0.02338169f, -0.11227729f, 0.06830368f, 0.00936925f, -0.03065510f, 0.40228420f, -0.39276043f, 0.19712178f, 
    0.01055576f, 0.07161971f, 0.18340780f, -0.19870900f, -0.07066797f, 0.07013594f, 0.06199125f, 0.06469565f, 
    0.13460530f, 0.01782060f, 0.10018339f, 0.06961076f, 0.11560231f, -0.02091223f, 0.03270718f, -0.05311461f, 
    -0.04588473f, -0.09299996f, 0.11956693f, -0.27475646f, 0.00503017f, 0.51388341f, 0.02781171f, 0.05845685f, 
    -0.02423566f, 0.07949089f, -0.00148206f, 0.18717551f, -0.05082296f, 0.04985211f, -0.12486306f, 0.09158127f, 
    -0.95564204f, 0.11472607f, 0.08965545f, -0.44695950f, -0.04843492f, -0.09766719f, 0.02220905f, -0.01364451f, 
    0.01793801f, 0.07014042f, -0.08545375f, -0.02205489f, -0.48874816f, -0.24234083f, 0.15217468f, 0.36166978f, 
    -0.13574882f, -0.10384990f, -0.05833520f, -0.03053802f, -0.02375948f, 0.07015445f, 0.12227990f, -0.25918695f, 
    0.51127279f, 0.19744772f, 0.52803481f, -0.36137503f, -0.34554526f, 0.08122145f, -0.13959491f, 0.05406201f, 
    -0.00916885f, 0.09399775f, -0.02772475f, -0.09082844f, 0.12232446f, -0.17633399f, 0.12099998f, -0.09362487f, 
    0.03919875f, 0.18485007f, 0.05069049f, 0.07155800f, -0.07989561f, -0.24607264f, -0.03477421f, -0.06413630f, 
    0.67835760f, -0.27833319f, -0.10930490f, 0.26328033f, 0.01401039f, -0.08309408f, -0.16608243f, 0.02222458f, 
    0.12595533f, 0.02533991f, -0.00379525f, 0.21885841f, 0.50861174f, -0.10911068f, 0.06260205f, -0.21971951f, 
    -0.17535105f, 0.16672118f, 0.23563012f, 0.08238316f, 0.15440290f, 0.06104068f, -0.04684477f, -0.05380898f, 
    -0.19257256f, 0.41101587f, -0.23435803f, 0.19752546f, 0.04349065f, -0.13490771f, -0.01647121f, 0.07998008f, 
    -0.13273640f, 0.04033956f, 0.05961412f, 0.21799645f, -0.03400866f, -0.14784078f, 0.04760730f, 0.18205786f, 
    0.10754523f, 0.00716610f, -0.06138038f, -0.07946713f, -0.02601986f, 0.02010569f, 0.08404468f, 0.12884797f, 
    -0.52965957f, -0.20423831f, 0.30065560f, 0.41605395f, -0.08312699f, -0.21447486f, 0.22731158f, -0.15817986f, 
    -0.06191433f, 0.06173299f, -0.01613898f, -0.13225867f, -0.21615854f, 0.12600449f, 0.19259281f, -0.21959300f, 
    0.03709680f, -0.05331948f, -0.08644513f, -0.26745346f, -0.14297801f, -0.37745991f, 0.12090845f, -0.28918940f, 
    0.64261770f, 0.00532711f, 0.09012177f, -0.47696814f, -0.11528559f, -0.14466214f, -0.18543373f, 0.19001769f, 
    0.08888903f, -0.02532580f, 0.00262028f, -0.13648528f, -0.65854305f, -0.25390106f, -0.19834654f, -0.47985703f, 
    0.07659396f, 0.21272725f, -0.10503270f, -0.10738112f, -0.00922588f, -0.01744554f, 0.05006422f, 0.04715062f, 
    -0.16461247f, -0.05655538f, 0.04473884f, 0.19597885f, -0.06362841f, 0.00980711f, 0.07000003f, 0.15563038f, 
    -0.06568906f, -0.06614654f, 0.02946297f, 0.11942276f, 0.07285280f, -0.10534906f, -0.24030839f, 0.08703953f, 
    -0.06461904f, -0.02781691f, -0.01667891f, -0.05632056f, -0.14053610f, 0.06662733f, -0.06926053f, 0.07557292f, 
    -0.12091837f, 0.33435795f, 0.13449438f, -0.06445019f, -0.23131412f, -0.03917848f, 0.13625048f, -0.13975762f, 
    0.29826093f, 0.27283224f, 0.01517246f, 0.26669508f, 0.06673105f, -0.11140557f, -0.03100381f, 0.19403283f, 
    0.04989843f, 0.00257634f, -0.08416212f, 0.03825317f, -0.00152886f, 0.28857583f, -0.22135708f, 0.16237034f, 
    0.03982889f, -0.17228737f, -0.02616562f, -0.32577515f, 0.04391627f, -0.02641714f, -0.05127837f, -0.01070210f, 
    0.03349106f, -0.12169411f, -0.16624348f, -0.12867227f, -0.63737166f, 0.18435457f, 0.04270081f, 0.23090857f, 
    0.03552143f, 0.15804115f, 0.29765803f, 0.01876879f, -0.14561699f, -0.02204743f, 0.24566582f, 0.05042776f, 
    0.94542408f, -0.02807911f, -0.18061446f, 0.03310602f, 0.22961538f, 0.06389296f, 0.10804828f, -0.03403790f, 
    -0.19413218f, 0.06397620f, 0.04798838f, -0.05505442f, -0.65031838f, 0.01567046f, -0.08287015f, 0.21324918f, 
    -0.29270256f, -0.08003725f, -0.31268981f, -0.01905559f, -0.01310726f, -0.11386827f, -0.07265113f, -0.13958529f, 
    -0.04319794f, -0.14470464f, 0.01264888f, 0.15974060f, 0.00639506f, 0.04020417f, 0.04930122f, 0.04795979f, 
    -0.04837460f, -0.03001256f, -0.13961881f, -0.02302815f, -0.02644281f, -0.22207776f, -0.07463542f, -0.37256214f, 
    0.27416080f, 0.15716603f, 0.04251555f, 0.10916403f, 0.04535551f, -0.03363060f, -0.26583269f, -0.26389834f, 
    -0.04357744f, -0.24077295f, -0.11797739f, 0.14758138f, -0.04699094f, 0.17289993f, 0.20940670f, 0.04923820f, 
    0.03239097f, -0.05207381f, -0.00925927f, -0.11760847f, -0.26847565f, 0.06589755f, 0.17236875f, -0.71398962f, 
    0.02762197f, -0.20359352f, -0.12840170f, -0.24141265f, 0.06403183f, -0.03009932f, 0.05868571f, 0.03894250f, 
    -0.48079997f, 0.68563890f, -0.21267609f, -0.42587149f, 0.15344948f, 0.01288494f, 0.00674314f, -0.16695477f, 
    -0.47457296f, 0.01464501f, -0.02462625f, -0.04906356f, 0.91051275f, -0.23372684f, -0.03397354f, -0.54927236f, 
    -0.35764524f, -0.18187886f, -0.12820664f, -0.16346762f, -0.13361819f, 0.12802769f, 0.18783686f, 0.00063054f, 
    -0.22854541f, 0.11902809f, 0.05189443f, 0.06229844f, -0.00344532f, 0.01878800f, 0.10454533f, -0.17225751f, 
    0.04073485f, 0.15157159f, -0.07759230f, -0.22151265f, 0.00420177f, -0.10955222f, -0.16163881f, 0.12731025f, 
    0.31506526f, 0.21655184f, -0.09506955f, -0.03211844f, 0.04069726f, 0.01449831f, -0.13298884f, -0.07191125f, 
    0.19518293f, -0.31938869f, -0.03722997f, 0.24869365f, 0.08253627f, 0.05461027f, -0.00891077f, -0.30804184f, 
    -0.13007046f, -0.20920318f, 0.09637751f, -0.06822095f, -0.01537158f, -0.13956292f, -0.34437463f, 0.09828141f, 
    -0.08542196f, -0.06344616f, -0.13097435f, 0.08614723f, -0.03004814f, -0.04490576f, 0.01159596f, -0.09813994f, 
    -0.57517886f, 0.95084018f, -0.34607190f, -0.11435799f, 0.03688134f, 0.25356662f, -0.13726610f, -0.10287718f, 
    -0.37706923f, -0.13513808f, 0.02274407f, -0.09264623f, -0.12517220f, 0.06624980f, -0.08180490f, 0.32499796f, 
    0.01458460f, -0.02150313f, 0.00519181f, 0.01375854f, -0.05638027f, 0.13626492f, 0.01839547f, 0.10161015f, 
    -0.24162284f, -0.12160671f, 0.41208932f, 0.45715389f, -0.30322596f, -0.10742027f, -0.00703287f, -0.00028341f, 
    0.04711859f, 0.06515209f, -0.19609299f, 0.01799132f, -0.01221641f, 0.02926615f, -0.25541952f, 0.05770912f, 
    0.12006619f, 0.02806125f, 0.15972656f, -0.04861648f, -0.07691281f, 0.07491217f, -0.07452793f, 0.19855669f, 
    0.20888561f, -0.49480128f, -0.48262039f, 0.33373782f, -0.12943302f, -0.12860607f, 0.02348252f, -0.24309798f, 
    -0.00518726f, -0.10951776f, -0.02346034f, 0.06388780f, 0.07874329f, 0.27934960f, 0.22867113f, 0.36232406f, 
    -0.07780179f, -0.03333499f, 0.15692483f, 0.00488319f, 0.13905302f, -0.02617828f, -0.01076801f, -0.11457359f, 
    -0.47765255f, 0.04870681f, 0.06068940f, 0.02479893f, -0.10106699f, 0.06152743f, -0.24756347f, -0.14453228f, 
    -0.07065196f, 0.01000308f, 0.05104828f, 0.00757075f, 0.35719365f, -0.28782591f, -0.49242616f, 0.06570646f, 
    0.07653978f, -0.07973757f, -0.00203874f, -0.05662297f, 0.14967871f, 0.18618466f, 0.30355331f, 0.28321460f, 
    -0.04826524f, -0.18679035f, 0.56739771f, 0.22232831f, 0.12721354f, -0.09111389f, -0.12912060f, -0.15331911f, 
    -0.02544901f, -0.03798189f, 0.04527520f, 0.08921548f, 0.11088327f, 0.23045081f, -0.06295522f, 0.14636503f, 
    -0.11798509f, -0.06726085f, 0.08429534f, -0.03827124f, 0.14690147f, 0.04485789f, 0.00095877f, 0.21769604f, 
    -0.03173544f, 0.24310048f, -0.14490756f, -0.11901370f, 0.03949378f, -0.04106688f, -0.29892522f, -0.16554447f, 
    -0.04465277f, -0.03180034f, 0.04218824f, -0.15388189f, 0.04247193f, -0.04290492f, 0.00911893f, 0.12247756f, 
    0.10818702f, -0.05446672f, -0.04393604f, 0.11114547f, -0.00311126f, 0.12130916f, -0.15097791f, -0.01653411f, 
    0.11000157f, -0.19122241f, -0.20336874f, -0.45364952f, 0.09915786f, -0.07406714f, 0.10614025f, -0.07109091f, 
    0.11625134f, -0.10606153f, 0.06367823f, -0.19843814f, 0.07297771f, 0.07084543f, -0.02711255f, -0.06485008f, 
    0.15653853f, 0.03988892f, 0.07662176f, 0.07182953f, 0.04424109f, 0.10940766f, -0.02644459f, 0.06470998f, 
    0.03363248f, 0.13280481f, 0.14890978f, 0.19149832f, 0.03894478f, -0.01654866f, -0.00537231f, -0.08551895f, 
    0.16068202f, 0.06121369f, 0.15323958f, 0.00306222f, -0.12897083f, 0.02345485f, 0.21405797f, -0.08815503f, 
    -0.08668412f, 0.16592498f, -0.10086308f, -0.25056946f, -0.15189992f, -0.00055815f, -0.06939431f, -0.05061376f, 
    0.21067794f, -0.01360374f, 0.19360042f, 0.29709455f, 0.07992455f, 0.02718687f, 0.02467264f, -0.00357634f, 
    0.07963115f, 0.00068938f, 0.07558540f, 0.12712178f, 0.10345449f, 0.04523658f, -0.10601998f, 0.00562557f, 
    -0.24883980f, -0.05191364f, 0.00162192f, 0.00994277f, 0.19789237f, -0.00410197f, 0.05718701f, 0.07370397f, 
    0.05288513f, 0.05075321f, 0.05231449f, 0.01676163f, -0.06984784f, -0.09765077f, -0.09720245f, -0.07452826f, 
    0.17234202f, -0.17136209f, -0.00210634f, -0.06131040f, -0.31522724f, -0.23435311f, 0.05420500f, 0.03690373f, 
    0.02847175f, -0.10062896f, -0.16348889f, 0.04980554f, 0.06139253f, -0.07937723f, -0.19871336f, 0.08616927f, 
    0.05944117f, 0.17688890f, -0.24853709f, 0.12569182f, -0.14707090f, -0.15756458f, 0.00694635f, 0.16581436f, 
    -0.06206715f, -0.27427405f, -0.03481074f, -0.08977988f, -0.02664862f, -0.11775069f, -0.22579223f, -0.17528929f, 
    0.11151211f, -0.09981682f, -0.05775177f, -0.08186673f, -0.18503790f, 0.15799241f, 0.14462401f, -0.06457614f, 
    0.11090159f, 0.06295541f, 0.20368457f, 0.09689467f, 0.08372220f, -0.05516408f, 0.05321759f, 0.08774241f, 
    -0.02576301f, -0.01025389f, 0.06117317f, -0.04705187f, 0.23610201f, 0.17035803f, 0.06232063f, -0.10006111f, 
    0.08347333f, 0.05432569f, 0.05454899f, 0.07488376f, -0.06945410f, -0.12164830f, -0.07726654f, -0.05575067f, 
    0.11716888f, 0.35045654f, 0.31296408f, 0.21676548f, -0.10871834f, -0.08290232f, -0.21538651f, 0.17930263f, 
    0.10719821f, -0.07725605f, -0.08473983f, 0.02649824f, 0.05179080f, -0.24615909f, -0.42539132f, -0.02260271f, 
    -0.20841783f, -0.10068154f, -0.00979968f, -0.15529338f, -0.33511838f, -0.13866377f, -0.36852115f, 0.16899736f, 
    0.40992692f, -0.44827393f, -0.06361016f, 0.09549896f, -0.02250522f, 0.13962899f, -0.04344656f, -0.04072645f, 
    -0.05870644f, -0.09955945f, -0.21601392f, -0.31556752f, -0.45665702f, -0.53113353f, -0.12916246f, -0.43317631f, 
    0.05748061f, 0.07211380f, 0.08651017f, 0.05784629f, 0.17335512f, -0.17837743f, -0.11216638f, -0.14868605f, 
    0.10225567f, 0.09364190f, 0.14471187f, 0.04431049f, 0.13112538f, -0.12856241f, 0.08088570f, -0.02777825f, 
    -0.11115047f, -0.01802259f, -0.09581956f, -0.17088267f, 0.22384252f, 0.01148227f, 0.02911157f, 0.01978229f, 
    -0.05285002f, -0.11490204f, 0.01208356f, 0.07568191f, 0.04518910f, -0.11501581f, 0.07904837f, -0.02372623f, 
    0.01007951f, 0.35142460f, -0.07562709f, 0.13876325f, -0.01214319f, -0.12085540f, -0.00603738f, 0.03940939f, 
    0.20547059f, -0.11267295f, -0.06960884f, 0.04399364f, -0.09716947f, 0.03396352f, 0.21162535f, -0.01898350f, 
    -0.00566855f, 0.00182795f, -0.15126155f, -0.04123710f, -0.05699770f, -0.06333993f, -0.09906659f, -0.13291720f, 
    -0.16868678f, -0.64566463f, 0.09112734f, -0.04526168f, 0.01625407f, 0.06491291f, 0.08881535f, -0.14599097f, 
    -0.13034934f, -0.02792863f, -0.22549714f, -0.00373743f, 0.15942995f, 0.03226578f, 0.14508525f, -0.00141996f, 
    -0.06917442f, -0.10692082f, -0.05797342f, -0.13839339f, -0.04026542f, -0.17823012f, -0.01639099f, -0.03918892f, 
    0.28384238f, 0.34698877f, 0.04242397f, 0.08591241f, 0.35208848f, 0.10646766f, -0.05120825f, 0.24136972f, 
    0.05424162f, -0.03567829f, -0.03641368f, -0.09386774f, -0.14873210f, -0.13237511f, 0.12032618f, 0.05025410f, 
    -0.20046981f, 0.04456780f, 0.02478955f, -0.01407543f, -0.02352248f, 0.04841341f, 0.07572204f, 0.11875190f, 
    -0.11267938f, -0.31846508f, 0.21378577f, 0.04696696f, -0.04229711f, 0.14556001f, -0.11711378f, 0.16887219f, 
    0.06748224f, 0.07343175f, 0.03351580f, -0.07036979f, -0.05105865f, 0.24999973f, -0.11933762f, 0.23928510f, 
    0.11311014f, 0.18312673f, -0.03335542f, 0.08012196f, -0.06059806f, 0.01942767f, 0.03034871f, 0.06547903f, 
    -0.19476402f, 0.08223037f, -0.03810340f, -0.21682674f, 0.14060804f, -0.15647238f, 0.14069968f, -0.03462501f, 
    -0.00755991f, 0.04771547f, -0.12375662f, 0.22428097f, -0.49486849f, -0.22593951f, 0.06455889f, -0.09002636f, 
    0.03540497f, -0.00075590f, 0.01361143f, 0.13965157f, 0.18566144f, -0.46005091f, -0.42800793f, -0.33389729f, 
    0.37224671f, -0.26804706f, 0.61238772f, -0.09982555f, -0.01416609f, 0.00942854f, 0.08594301f, 0.06102025f, 
    0.06478692f, -0.04422212f, 0.03257237f, -0.02637516f, -0.40916526f, -0.08699176f, 0.13652121f, -0.29138088f, 
    0.00379647f, 0.00814178f, -0.06277710f, 0.09930295f, 0.08044492f, 0.05399937f, -0.27132672f, -0.14339413f, 
    0.08238832f, 0.29992741f, -0.38925147f, -0.43935764f, -0.01776389f, 0.40689605f, -0.31151143f, 0.01058335f, 
    0.04182246f, -0.35426137f, 0.06628903f, -0.13790268f, -0.67631292f, 0.00159532f, -0.04620137f, -0.07113038f, 
    0.14010423f, 0.07182413f, -0.00339841f, 0.12042645f, 0.14678635f, 0.11840391f, 0.02808642f, 0.48458239f, 
    -0.42062563f, 0.25655544f, -0.25269502f, 0.31471071f, 0.16913442f, -0.13896619f, 0.06591950f, -0.13416985f, 
    0.07274046f, 0.09239686f, 0.01740879f, -0.08530966f, -0.01879455f, -0.17754523f, -0.00302528f, 0.08014105f, 
    0.02634866f, -0.05165923f, -0.07292802f, -0.02116666f, 0.02848519f, -0.10390778f, 0.08216657f, -0.00543328f, 
    0.32266057f, -0.24688734f, -0.20556854f, -0.04076053f, 0.07555760f, 0.00145942f, -0.06134173f, 0.01692449f, 
    -0.22548255f, -0.01579392f, 0.05349949f, -0.27974978f, -0.06655716f, 0.12292951f, 0.19865791f, -0.16249228f, 
    -0.16671950f, -0.10007481f, -0.29137906f, 0.15465586f, -0.11490214f, 0.03107901f, 0.01614735f, 0.07855526f, 
    -0.19235280f, -0.24300453f, 0.04595445f, 0.16257067f, 0.09808166f, 0.01392013f, -0.06396563f, 0.15637246f, 
    -0.06524921f, -0.09775792f, -0.07381091f, -0.07954815f, -0.02058063f, 0.00765478f, -0.07447751f, -0.20940325f, 
    0.37688363f, 0.04823172f, 0.34306884f, 0.00933028f, 0.07375184f, 0.05139060f, 0.02416859f, 0.00053083f, 
    0.07228050f, -0.06445099f, -0.14282380f, -0.01062272f, -0.09281174f, -0.03390210f, 0.15033771f, 0.16632377f, 
    0.00777070f, 0.13449802f, 0.10521172f, -0.02577996f, -0.00971724f, -0.24536990f, -0.53618544f, -0.40160656f, 
    0.00284007f, 0.04028013f, 0.04030045f, 0.07562537f, -0.00447232f, -0.01115812f, -0.07981213f, -0.27428326f, 
    -1.13303685f, -0.47387314f, 0.09904366f, -0.00812223f, -0.14401171f, -0.04798193f, 0.03963797f, -0.01779302f, 
    0.14242746f, -0.14628749f, 0.05353113f, 0.26259187f, 0.04825643f, 0.05891483f, -0.58780318f, 0.07690354f, 
    0.15043139f, -0.01758087f, -0.11913077f, 0.16210724f, 0.27831289f, -0.27194953f, 0.10244641f, 0.14653379f, 
    0.00169089f, 0.29584953f, 0.20702045f, -0.22508945f, 0.12237815f, 0.09984426f, 0.09093905f, -0.08432445f, 
    0.07878776f, 0.01742993f, 0.12493230f, 0.10100324f, -0.05459945f, -0.27182159f, 0.04071217f, 0.21807568f, 
    -0.10376813f, -0.05333744f, 0.00507974f, -0.03290857f, 0.03460936f, -0.03892935f, 0.22026780f, 0.27288988f, 
    0.11390279f, 0.16546749f, 0.07741182f, -0.06797989f, 0.31683916f, 0.10698242f, -0.16516238f, -0.12531197f, 
    -0.01583328f, -0.04210735f, -0.00680083f, 0.02654634f, 0.23373881f, -0.53095508f, 0.17183854f, 0.17805240f, 
    -0.13031881f, 0.01043192f, 0.12692499f, 0.18119924f, 0.16397327f, -0.02653605f, 0.18408720f, -0.02956146f, 
    -0.30271503f, 0.11223686f, 0.16402109f, -0.17582525f, -0.01870897f, -0.11300936f, -0.07112522f, -0.09219321f, 
    0.14936228f, -0.05757161f, 0.00679414f, 0.29840216f, -0.17303079f, 0.00261329f, -0.05296926f, 0.41109711f, 
    0.18976389f, -0.08394755f, 0.02354155f, 0.01924889f, -0.11056916f, -0.22709286f, 0.05400785f, 0.05678675f, 
    0.00874644f, 0.00806362f, 0.09983685f, -0.19662859f, -0.41414908f, 0.42040309f, -0.07387255f, -0.12774350f, 
    0.13446002f, 0.01499534f, 0.05350997f, 0.05663301f, -0.09588427f, 0.03066339f, -0.27381292f, -0.21026321f, 
    0.11770727f, 0.01112475f, 0.07423589f, -0.01345107f, 0.11750922f, 0.05224261f, -0.18918805f, 0.07638711f, 
    -0.35959038f, -0.12887558f, -0.04068332f, -0.17535238f, 0.01465509f, 0.01869723f, 0.03158863f, 0.03289549f, 
    0.04939087f, 0.11193371f, -0.05429073f, -0.19431362f, 0.42959160f, -0.08941977f, 0.19135441f, 0.05612207f, 
    0.04345723f, 0.17280546f, -0.20343554f, 0.10146715f, -0.06019388f, -0.12824711f, 0.03896199f, 0.28280109f, 
    -0.62472820f, 0.15693709f, -0.06534673f, 0.04757494f, -0.00148170f, -0.10546479f, -0.01907621f, 0.11259311f, 
    0.19413362f, 0.15825169f, -0.20973159f, -0.07000341f, -0.15264939f, -0.27889246f, 0.00977431f, 0.02867499f, 
    -0.00832109f, 0.12295320f, -0.14281084f, 0.00725686f, 0.12896341f, -0.01509696f, 0.07266334f, 0.04532863f, 
    0.00859819f, -0.05719283f, -0.28175300f, -0.10759754f, 0.16602744f, 0.13433518f, 0.08760265f, 0.10339924f, 
    0.00584917f, 0.03070826f, 0.14338511f, -0.04745951f, -0.11355915f, 0.02639918f, 0.24493217f, -0.17615880f, 
    0.05918486f, -0.10151178f, -0.13919349f, 0.08861247f, 0.03809117f, -0.04555279f, -0.10253184f, -0.16547588f, 
    -0.11825433f, -0.08839205f, -0.36335447f, 0.31639951f, -0.37047091f, 0.30327892f, -0.06446858f, 0.00200920f, 
    0.07559270f, -0.09200074f, 0.09418750f, -0.03769422f, -0.83526158f, -1.20643890f, -0.45093170f, -0.56307024f, 
    -0.16523339f, -0.13694587f, 0.20237234f, -0.19909272f, 0.07408347f, -0.03658808f, -0.01187763f, -0.00974825f, 
    -0.60749942f, -0.71370363f, -0.48110059f, 0.07508180f, -0.00188541f, -0.01887792f, -0.13747127f, 0.17987798f, 
    -0.00845238f, -0.06560346f, 0.04650056f, 0.09005188f, 0.14780618f, -0.11411507f, -0.11619554f, 0.02626825f, 
    -0.00109237f, 0.07659471f, -0.01990793f, 0.12675892f, 0.22235945f, 0.35852119f, 0.31520900f, 0.13250425f, 
    -0.31094852f, -1.09083760f, -0.73085868f, 0.14141941f, 0.17742346f, 0.27448529f, -0.08867402f, -0.11508437f, 
    0.02186340f, 0.07177553f, 0.02376364f, 0.07361358f, -0.58963722f, -0.08016486f, -0.14374208f, -0.17611198f, 
    -0.06632362f, -0.03095759f, 0.11781334f, 0.07140999f, -0.01850769f, 0.15443321f, 0.10473900f, 0.06972522f, 
    0.43136272f, 0.27121180f, -0.18666248f, -0.57310224f, 0.07680045f, -0.16735101f, 0.13468301f, 0.04429998f, 
    0.08712506f, -0.09964426f, -0.21472350f, -0.06708235f, -0.15118515f, -0.07760982f, 0.07899877f, 0.00482245f, 
    0.04643572f, -0.07192324f, 0.11021604f, 0.03837632f, -0.02179401f, -0.01061703f, 0.05095214f, -0.05639137f, 
    0.22031972f, 0.04135770f, -0.14444938f, -0.59283590f, 0.03103316f, -0.01248509f, -0.08936510f, 0.04349299f, 
    -0.07807080f, 0.08468836f, 0.13235229f, -0.23277390f, 0.03130378f, -0.09553753f, -0.03997853f, -0.10956099f, 
    -0.01256558f, 0.00865673f, -0.03022980f, 0.07448352f, -0.01347121f, -0.06188035f, -0.36007133f, -0.16941343f, 
    0.16844338f, 0.60172981f, 0.22428484f, -0.05206140f, -0.07814260f, -0.04929127f, -0.10117475f, 0.02922979f, 
    0.02558118f, 0.16791706f, 0.02392911f, 0.06487463f, -0.16779308f, -0.18053383f, 0.14052281f, -0.03661980f, 
    -0.15703197f, -0.14946002f, 0.19633168f, 0.06394779f, -0.04678022f, 0.04791350f, 0.00761799f, 0.13334475f, 
    -0.13232994f, -0.26611918f, -0.22164424f, 0.13217823f, 0.05428510f, 0.12036166f, -0.03562392f, 0.03296787f, 
    -0.03474210f, -0.08454721f, -0.11661693f, 0.09338418f, -0.63355923f, -0.22433132f, -0.16917263f, -0.29119533f, 
    0.11082693f, -0.17678715f, -0.09158455f, -0.25307238f, -0.03524698f, -0.03954929f, 0.00860725f, 0.03799681f, 
    0.08573948f, -0.03301680f, -0.08619368f, -0.00090605f, -0.06403262f, 0.13470915f, -0.01352098f, -0.09298322f, 
    0.16249470f, -0.18477015f, 0.06353541f, -0.15614593f, 0.10072193f, 0.36812416f, -0.05859341f, 0.31872192f, 
    0.11287457f, -0.03427604f, 0.09188165f, 0.18699817f, 0.15267183f, 0.14598945f, 0.16661876f, -0.17820926f, 
    -0.28299743f, -0.21890859f, 0.27439371f, 0.22986120f, 0.00616844f, -0.24996629f, 0.06499772f, 0.12178459f, 
    -0.16828969f, 0.28194249f, 0.17725225f, 0.00783593f, 0.46765855f, 0.11043327f, -0.13150027f, 0.00586748f, 
    0.05250838f, -0.16317086f, 0.24059002f, -0.01944556f, 0.04859442f, 0.13418582f, 0.18045834f, -0.00597114f, 
    -0.57673937f, -0.84831566f, -0.54996884f, -0.27518973f, -0.12414336f, -0.28575143f, -0.18019721f, -0.47338104f, 
    -0.09574836f, 0.00219711f, -0.06058890f, -0.15182000f, -0.13397218f, 0.05024610f, 0.11872809f, -0.10190857f, 
    0.05481021f, -0.04749026f, -0.03742312f, 0.01635384f, 0.01808667f, -0.12844312f, 0.10350091f, 0.01565427f, 
    -0.80750388f, -0.55575937f, -0.06443236f, -0.25667372f, -0.20242034f, -0.30368403f, -0.25301540f, -0.37612256f, 
    0.10742158f, 0.00105557f, 0.02672608f, 0.04608367f, -0.10343944f, -0.16072363f, -0.20959839f, 0.41718161f, 
    -0.07242602f, 0.27002981f, 0.03155071f, 0.18686537f, 0.16034506f, -0.11210156f, 0.25629124f, -0.04521774f, 
    -0.05600732f, -0.37493783f, 0.11025798f, 0.10244033f, 0.03028562f, -0.14250815f, -0.10385580f, 0.01279990f, 
    -0.03286782f, 0.19414936f, 0.05338435f, -0.16069393f, 0.11656143f, -0.09255006f, 0.17859222f, -0.41129428f, 
    -0.19495781f, 0.07722595f, 0.01629918f, 0.04156008f, -0.06178292f, 0.12770912f, -0.10378203f, 0.13537566f, 
    0.09934545f, -0.05064692f, -0.14289920f, -0.00988733f, 0.07677498f, -0.17579611f, 0.04852510f, 0.07827993f, 
    0.05155520f, -0.11589213f, 0.01598106f, -0.12639928f, -0.46422794f, 0.34461942f, 0.37880722f, 0.01829001f, 
    -0.10241987f, -0.06132784f, -0.12661538f, -0.02546827f, -0.14826685f, 0.02468845f, -0.03869000f, 0.00756007f, 
    0.03995427f, 0.19340056f, 0.40435711f, -0.00755226f, -0.03747956f, 0.04069214f, -0.08545993f, -0.00783115f, 
    -0.10571447f, 0.10448612f, 0.02240567f, 0.08928274f, 0.12158694f, 0.72670811f, -0.25999665f, 0.67657852f, 
    -0.07115452f, -0.06092960f, -0.01722495f, 0.21599670f, 0.03663193f, 0.07273396f, 0.06542735f, 0.09484062f, 
    0.06479636f, -0.26797745f, 0.09791610f, 0.05014089f, 0.01470693f, 0.11557287f, -0.10714380f, 0.02967773f, 
    0.09581011f, 0.12775558f, 0.07396016f, 0.15300699f, -0.21991974f, 0.67585552f, 0.04440434f, 0.60145503f, 
    -0.05940118f, -0.15499195f, -0.04654172f, -0.05675706f, -0.02248422f, 0.03560853f, -0.07951101f, -0.07365397f, 
    0.02346735f, -0.66190755f, -0.06317325f, -0.21718210f, -0.08718681f, 0.13257089f, 0.31900680f, -0.45499796f, 
    0.03950320f, -0.03072425f, 0.00571583f, 0.11475277f, -0.10504843f, -0.53812146f, -0.29221439f, -0.26807541f, 
    -0.32871759f, 0.14202547f, 0.06921538f, 0.08979594f, -0.02616452f, 0.03264085f, 0.08674503f, 0.11496995f, 
    0.23291638f, -0.22172795f, 0.18685739f, -0.09703285f, -0.01917585f, 0.01694222f, -0.12722296f, -0.04373712f, 
    -0.04755975f, -0.03057721f, 0.10359620f, -0.02025864f, -0.53325015f, 0.07915159f, -0.66335094f, 0.71640921f, 
    0.13122572f, -0.15440226f, -0.03792864f, -0.01117771f, 0.05764709f, -0.00353949f, 0.03613706f, 0.03738147f, 
    -0.20558512f, -0.03026838f, -0.48039475f, -0.49993226f, -0.06470332f, 0.37939724f, -0.01593479f, 0.12699474f, 
    0.07349909f, -0.01300251f, -0.04165700f, 0.08676438f, 0.08021297f, 0.02914467f, 0.14687712f, 0.03067945f, 
    0.09647194f, -0.00720010f, -0.13144146f, -0.03249609f, 0.08601710f, -0.02678828f, 0.09259285f, -0.05203778f, 
    0.01819846f, -0.78830934f, 0.24296305f, 0.19562693f, -0.11281470f, -0.04366580f, -0.01696864f, 0.09990219f, 
    0.07707231f, 0.08631052f, -0.04137558f, -0.02277980f, 0.56541079f, -0.69460434f, -0.06359101f, -0.31983870f, 
    -0.27074558f, -0.19004053f, -0.16151622f, 0.17195207f, 0.18098901f, 0.08840253f, -0.12000541f, 0.07845705f, 
    -0.22234465f, 0.25662076f, 0.45045602f, -0.09853128f, -0.08489201f, -0.01590570f, 0.04774975f, 0.17332129f, 
    -0.14138098f, 0.03683240f, 0.08009095f, -0.02771639f, 0.08835717f, 0.16676097f, -0.02078301f, -0.05161348f, 
    -0.06683859f, 0.03154141f, 0.01844069f, -0.04255307f, -0.05330862f, 0.11552601f, -0.06027719f, -0.19127646f, 
    -0.02983374f, 0.21378945f, -0.11960023f, 0.30629563f, -0.15182284f, 0.10321020f, -0.01373534f, -0.08100709f, 
    0.01202121f, 0.02640173f, -0.18157776f, -0.05455675f, 0.11185991f, 0.09724104f, -0.03201185f, -0.02959535f, 
    0.02419875f, -0.05580405f, 0.00618549f, -0.00559663f, 0.02558612f, 0.02458974f, -0.08585613f, -0.07152306f, 
    0.21958776f, -0.59382057f, -0.27657112f, -0.10235269f, -0.03787744f, 0.05796221f, 0.04017522f, 0.05138762f, 
    0.14804725f, 0.10673039f, 0.03849249f, -0.01461471f, -0.10079610f, -0.50949806f, 0.47101483f, -0.43600988f, 
    -0.08670137f, 0.16830698f, 0.08874256f, 0.12442376f, -0.04126578f, -0.01176505f, -0.11463159f, -0.11344796f, 
    0.03722891f, 0.09571688f, -0.18785635f, -0.02065999f, -0.03010087f, -0.08408540f, -0.05422418f, -0.00243452f, 
    0.00674500f, 0.02041317f, 0.04762577f, 0.03503397f, 0.43215054f, -0.32364443f, -0.19889575f, -0.37252730f, 
    0.04673429f, -0.04247694f, -0.14364251f, 0.01236045f, 0.01859189f, 0.01644123f, 0.03541303f, -0.01444185f, 
    0.04179892f, 0.01001811f, -0.00961861f, -0.03486828f, 0.04454451f, -0.14241171f, -0.00780521f, -0.08772952f, 
    -0.01642873f, -0.01162703f, 0.03253869f, -0.03311132f, -0.39320475f, -0.27119997f, 0.14949179f, -0.05416379f, 
    -0.01749893f, -0.04042513f, 0.24603103f, 0.01922013f, -0.03206114f, 0.02510869f, -0.03190306f, 0.02648616f, 
    0.87659913f, -0.48132643f, -0.18399315f, -0.61275959f, 0.11837393f, 0.06376772f, 0.00499282f, -0.03105941f, 
    -0.00423198f, -0.10295140f, 0.01070125f, -0.17668377f, -0.08187687f, -0.01156666f, 0.05395344f, 0.00066420f, 
    -0.03276371f, 0.00294749f, -0.03963064f, -0.08234014f, -0.01794956f, -0.06443913f, -0.03449637f, -0.19312929f, 
    -0.36655238f, -0.16738141f, 0.53445596f, 0.42929399f, 0.00692903f, -0.15318790f, -0.09841177f, 0.04534772f, 
    -0.06253657f, -0.16657814f, -0.03635130f, -0.00154103f, 0.18098560f, 0.03232396f, -0.06676587f, -0.08146175f, 
    0.06957035f, 0.09407558f, 0.00439220f, -0.06286313f, -0.07718572f, 0.04967808f, -0.06675121f, -0.12062958f, 
    -0.41425118f, 0.38869902f, -0.57799649f, 0.46093982f, 0.23359373f, 0.12015139f, -0.02285161f, 0.15030612f, 
    0.00979070f, -0.00601950f, -0.05440638f, 0.01568929f, 0.47065625f, -0.40415782f, 0.21175516f, -0.16561097f, 
    -0.04140233f, 0.15144178f, -0.21491705f, -0.09931909f, -0.13770163f, 0.17034735f, -0.02940603f, -0.05129053f, 
    0.34644142f, 0.11603347f, 0.00960272f, -0.28263038f, 0.08454712f, -0.00333297f, 0.04538034f, 0.11890434f, 
    -0.04982908f, 0.04304240f, 0.10384902f, -0.14156225f, -0.05049339f, 0.28966132f, -0.27727637f, 0.05787782f, 
    0.02709041f, 0.10976505f, -0.06160897f, -0.07282819f, -0.16422130f, -0.06227229f, -0.00017974f, -0.00736467f, 
    -0.03955965f, -0.05396067f, 0.06086960f, 0.02004367f, -0.04501487f, -0.27217072f, 0.04433565f, -0.13116401f, 
    0.02053275f, 0.05424343f, -0.01128752f, -0.01349517f, 0.28280085f, -0.07623385f, -0.06595397f, -0.14084220f, 
    -0.01080262f, -0.05078693f, -0.01443943f, 0.03666483f, 0.04098463f, 0.01188047f, 0.08990961f, 0.05254892f, 
    0.70671797f, -0.33581313f, -0.34313622f, -0.31817311f, 0.08309478f, -0.02502477f, 0.05311154f, 0.01121026f, 
    0.10974702f, -0.11445539f, -0.02150903f, 0.06166271f, -0.42296860f, 0.00079901f, -0.51701063f, -0.16115221f, 
    0.02458738f, 0.05631531f, 0.06925544f, -0.02287695f, -0.07086959f, -0.01791569f, 0.00264938f, -0.07658335f, 
    0.27496201f, -0.04828003f, -0.05443656f, -0.26902857f, 0.04113859f, 0.01383904f, 0.00554110f, 0.06138557f, 
    -0.15464334f, 0.06677768f, -0.07012703f, -0.11545638f, -0.72628623f, -0.45956215f, -0.89873755f, -0.41894901f, 
    -0.23462589f, -0.22874589f, 0.02970438f, -0.09653822f, -0.04814440f, -0.04712421f, 0.02515252f, -0.01331632f, 
    -0.00413272f, 0.20286413f, 0.02551406f, -0.30976483f, 0.07428510f, 0.05462128f, 0.01485174f, 0.04863422f, 
    -0.01889423f, 0.01474256f, 0.06357036f, 0.01642105f, 0.42478099f, -0.64980948f, -0.29020068f, -0.25976336f, 
    0.02406479f, 0.05381083f, -0.07879484f, 0.36005095f, -0.02544194f, -0.21239486f, -0.00756631f, 0.02565470f, 
    0.21327272f, 0.22630271f, 0.16665711f, -0.24012154f, 0.34439892f, -0.35721898f, 0.00020640f, 0.02690690f, 
    0.06646070f, 0.09459096f, -0.05074558f, 0.13239273f, -0.06873141f, -0.14029926f, -0.05057906f, 0.00345887f, 
    -0.01875377f, -0.04116645f, -0.01680999f, 0.17399117f, -0.00673153f, 0.01208734f, -0.00909869f, -0.03330667f, 
    -0.17638163f, -0.43167445f, -0.23973086f, 0.26408023f, 0.12639262f, -0.09079245f, 0.10120992f, 0.19073784f, 
    0.00945117f, 0.00533683f, 0.06156993f, 0.19953291f, -0.20979479f, -0.04610670f, 0.09773300f, -0.07472989f, 
    -0.06178620f, -0.17903487f, -0.07270432f, 0.00406465f, -0.32920733f, 0.08630933f, -0.50556892f, -0.56969720f, 
    0.80520988f, 0.40722957f, -0.08286075f, -0.39954212f, -0.04210163f, -0.05182892f, -0.05213206f, -0.08890742f, 
    -0.04042019f, 0.02225388f, 0.01704509f, 0.05124126f, -0.17644297f, -0.58081084f, -0.41883257f, -0.26466706f, 
    0.15545133f, 0.29202878f, 0.33768243f, 0.12270210f, -0.15007931f, -0.10234788f, -0.05017053f, -0.13967288f, 
    -0.57100064f, -0.18157984f, 0.18723953f, 0.30439538f, 0.06106332f, -0.09869459f, 0.29824486f, 0.12374199f, 
    0.04221615f, -0.04466517f, 0.06416445f, 0.12160765f, -0.21186529f, -0.07896386f, -0.00931238f, -0.17182717f, 
    0.02920594f, -0.05220180f, 0.08644371f, -0.01921539f, 0.11681470f, 0.01287224f, 0.09639558f, 0.04633186f, 
    0.17373726f, 0.16971360f, -0.05568516f, 0.15330055f, -0.01584179f, 0.05766318f, -0.15305768f, -0.00835103f, 
    -0.01780374f, 0.05245881f, 0.14765568f, 0.20884176f, -0.17458801f, -0.06325580f, -0.01828061f, -0.21534884f, 
    -0.05109189f, 0.01098568f, 0.06566676f, 0.00693284f, -0.06737117f, 0.08057893f, -0.08531982f, 0.10561915f, 
    0.06751209f, -0.09653755f, -0.21358004f, -0.13773844f, 0.01110370f, 0.11518434f, 0.01535502f, 0.08194931f, 
    -0.11725388f, -0.05686690f, -0.34809077f, -0.42549348f, -0.02015972f, -0.22960250f, -0.27070406f, 0.21789771f, 
    0.00402402f, 0.09681413f, 0.08847357f, -0.07178715f, 0.08499066f, -0.11342327f, 0.05621329f, -0.07535603f, 
    -0.04747565f, 0.00489185f, 0.10881917f, -0.01200927f, -0.03788729f, -0.08813805f, -0.00683217f, -0.07727436f, 
    -0.10124073f, -0.08740031f, -0.12014659f, -0.13219890f, -0.29990941f, -0.75292391f, -0.36059892f, -0.11907618f, 
    0.08243689f, -0.01144465f, 0.12905745f, -0.16150725f, -0.11562245f, 0.01411799f, -0.01699545f, 0.04672138f, 
    0.00138768f, 0.07591556f, 0.07683709f, 0.00785504f, 0.02250618f, 0.14022449f, 0.00949976f, 0.14585227f, 
    -0.01981893f, 0.01019567f, 0.06290256f, 0.10276042f, -0.64226675f, -0.27960563f, 0.25608248f, 0.08860670f, 
    -0.00550511f, 0.14096971f, -0.04893051f, -0.10968988f, 0.01541266f, 0.03992388f, -0.05964790f, 0.05385612f, 
    -0.21972905f, -0.28096667f, -0.42221722f, 0.21469180f, -0.02915945f, 0.01521399f, 0.05197486f, -0.06309350f, 
    0.13893041f, 0.29145694f, 0.00229440f, 0.03780464f, -0.63347596f, 0.01967669f, 0.16185148f, 0.12176963f, 
    0.04473206f, 0.05670264f, -0.01386877f, 0.01047388f, -0.21389173f, 0.06913081f, 0.00976130f, 0.24824238f, 
    -0.23993014f, -0.32483494f, -0.77699465f, -0.64463955f, -0.08405185f, -0.25045848f, -0.03006589f, -0.14541446f, 
    0.13655674f, 0.06603243f, 0.03562092f, 0.06213051f, -0.11640499f, -0.02525901f, 0.12139707f, -0.17753090f, 
    -0.09551831f, 0.01091505f, 0.10757376f, -0.02381351f, -0.03105425f, 0.09722752f, 0.11986410f, 0.21731167f, 
    0.15349418f, -0.28139094f, -0.41626838f, 0.12299182f, -0.20150784f, -0.01315366f, 0.10159193f, -0.03804044f, 
    0.07626530f, -0.04617202f, 0.01384844f, -0.03503720f, 0.55504531f, 0.08977763f, -0.15864597f, -0.49637449f, 
    0.17124915f, 0.00854649f, 0.05922487f, -0.05302620f, 0.12738457f, -0.08089853f, 0.24162649f, -0.06484323f, 
    0.20976447f, -0.17950208f, -0.17739983f, -0.23490067f, -0.19819252f, 0.02136130f, -0.01468386f, -0.02407219f, 
    0.12378878f, 0.20852564f, 0.15485634f, 0.07361773f, 0.37576866f, 0.09620334f, -0.15184231f, -0.16466489f, 
    0.05522259f, -0.07449610f, -0.12074539f, 0.13293703f, 0.11229466f, 0.05087232f, 0.09399682f, 0.08037745f, 
    0.00827995f, -0.01890470f, -0.07773407f, -0.01826148f, -0.00595322f, -0.19131413f, 0.11261965f, 0.05228163f, 
    0.10356355f, 0.19389917f, 0.30958027f, 0.16667543f, -0.13695961f, -0.19182038f, -0.11615688f, -0.16615705f, 
    -0.03032136f, 0.04668003f, 0.06212842f, 0.10554396f, 0.11118131f, -0.05508890f, -0.05099157f, 0.11442697f, 
    -0.12553388f, -0.43328837f, -0.34348068f, -0.14073515f, -0.01851927f, 0.13050222f, 0.05111964f, 0.05216986f, 
    0.04088126f, -0.06578698f, -0.05006216f, -0.10657611f, 0.45131445f, -0.25195682f, -0.08634838f, -0.02337163f, 
    0.21428676f, -0.04179990f, 0.35687894f, 0.04216103f, -0.04788575f, -0.08967344f, -0.09293522f, 0.07817297f, 
    0.15865171f, 0.03900603f, 0.03692809f, -0.22828974f, -0.11930183f, -0.09785045f, -0.05847964f, 0.02123527f, 
    0.07788744f, -0.04288021f, -0.01532438f, 0.16386162f, -0.03890680f, -0.45596445f, -0.30227518f, 0.36303937f, 
    0.03221732f, 0.12831432f, 0.39281461f, -0.11131725f, -0.00350718f, -0.09198081f, 0.15294459f, 0.14668919f, 
    -1.01296675f, 0.18663843f, 0.27128920f, 0.20157397f, 0.13200946f, -0.14913012f, -0.26818529f, -0.26854190f, 
    -0.01067263f, -0.04652271f, 0.05311378f, 0.00594541f, 0.15015592f, -0.25303707f, -0.46041203f, -0.14643949f, 
    0.04860504f, 0.06555741f, 0.19272330f, -0.02018492f, 0.11527394f, -0.10265132f, -0.10322399f, -0.14804374f, 
    0.07916321f, -0.45188120f, -0.64966422f, 0.04365377f, 0.01255741f, -0.02968955f, 0.15884061f, -0.15560396f, 
    0.09534688f, -0.16078220f, -0.03400670f, 0.06863701f, -0.44937524f, 0.71725863f, -0.18447937f, -0.23481293f, 
    -0.08247859f, -0.23931450f, 0.20201629f, -0.08975152f, -0.02434148f, 0.04268669f, 0.05972197f, -0.03048026f, 
    0.22345880f, -0.08926057f, -0.17890045f, -0.22006434f, -0.17132701f, -0.20164622f, 0.04411563f, -0.10568426f, 
    0.02003344f, 0.02408799f, 0.07373677f, -0.02458507f, -0.12552388f, -0.14739197f, 0.03801410f, -0.01884904f, 
    -0.01086492f, 0.02940907f, 0.04996694f, -0.14743617f, 0.07749338f, 0.11831777f, 0.27585143f, 0.01054141f, 
    -0.27436808f, -1.09725678f, 0.06804905f, 0.07782976f, -0.00114208f, 0.26518470f, 0.07139699f, 0.10049742f, 
    -0.00633156f, 0.13739106f, 0.03392268f, -0.04874050f, 0.16282900f, -0.19719085f, 0.25797036f, 0.24397214f, 
    -0.07039618f, -0.06579600f, -0.12699270f, -0.17716214f, -0.05820226f, 0.08531924f, 0.10629672f, -0.00792002f, 
    0.20866117f, 0.13628073f, 0.21981539f, -0.01997637f, 0.02143930f, -0.14180961f, -0.02320580f, 0.15495029f, 
    -0.13011488f, -0.01812678f, 0.04975231f, 0.00500219f, -0.14308095f, 0.14516747f, -0.05020266f, -0.00227297f, 
    -0.12867576f, -0.05120257f, -0.01461790f, -0.22589239f, -0.05362308f, -0.09584617f, -0.20764123f, -0.03117276f, 
    -0.94828969f, 0.27989942f, -0.56772822f, 0.50348544f, 0.09209726f, -0.08376598f, -0.04903055f, -0.01622967f, 
    0.18952981f, -0.13631319f, -0.08745021f, -0.07256611f, -0.25218219f, -0.05364925f, 0.11124709f, 0.31495571f, 
    0.14767766f, 0.23415592f, -0.01089033f, 0.03728161f, 0.14537087f, 0.08009174f, -0.02021875f, 0.09689911f, 
    0.07479828f, 0.17526875f, 0.60078073f, -0.04734966f, 0.06045666f, -0.20711693f, -0.06683031f, -0.14357410f, 
    0.06023940f, 0.20232834f, 0.05664261f, 0.07455884f, 0.00923678f, 0.08858481f, -0.26304343f, -0.12490231f, 
    0.01422070f, -0.04765819f, 0.00161809f, -0.13482876f, 0.12687600f, 0.09569990f, 0.01870185f, -0.06899968f, 
    -0.20818359f, -0.36036891f, -0.17686780f, -0.06243358f, 0.18103555f, 0.17798893f, 0.32617715f, 0.12078684f, 
    0.00694280f, -0.12412374f, -0.05715197f, 0.11893442f, -0.09262428f, 0.16805187f, -0.10026980f, -0.18791443f, 
    -0.31853515f, 0.09302021f, -0.01553314f, 0.01885246f, 0.14456078f, -0.13423623f, 0.04128385f, -0.00812641f, 
    -0.00603502f, 0.02096656f, -0.08422572f, -0.07992912f, 0.24785510f, -0.02323765f, -0.06202025f, 0.11155889f, 
    0.07278960f, -0.02567938f, -0.07293805f, 0.07186190f, 0.30759344f, -0.13765077f, 0.56051731f, -0.46087456f, 
    0.02871267f, -0.08554909f, -0.07764744f, -0.05233056f, -0.00092685f, 0.07432870f, 0.07984877f, -0.04206002f, 
    0.24994284f, 0.08938642f, 0.41229707f, 0.09715143f, 0.04380975f, -0.09563007f, 0.03613382f, -0.24208139f, 
    -0.02419908f, 0.06580720f, -0.21677758f, -0.02582132f, -0.22670867f, 0.20749308f, 0.06484355f, -0.45615101f, 
    -0.07809547f, 0.02380771f, 0.02906479f, 0.06490397f, 0.09829710f, 0.00980384f, 0.03435126f, -0.19333477f, 
    -0.50519800f, -0.13323557f, 0.13785118f, -0.20935982f, -0.16482146f, -0.00132979f, 0.25866321f, 0.21185072f, 
    0.09736259f, 0.07285555f, 0.10103774f, 0.00867101f, -0.09825771f, -0.01760453f, -0.03596834f, 0.16788203f, 
    0.15135643f, -0.04439130f, 0.01865048f, 0.06732111f, 0.21123475f, -0.10056797f, 0.09381630f, 0.06079074f, 
    -0.31560093f, 0.13838306f, -0.41459405f, -0.17600363f, 0.21696599f, -0.12041557f, 0.20416345f, 0.27844772f, 
    -0.07345042f, 0.05946553f, 0.00612980f, -0.01375333f, 0.02564654f, -0.28084630f, 0.24649379f, 0.09529258f, 
    -0.08059298f, -0.07895266f, -0.27897903f, -0.26357332f, -0.10763273f, -0.02406363f, 0.06111458f, 0.10255693f, 
    -0.01591364f, 0.08825862f, 0.00922705f, 0.27935117f, 0.00715182f, 0.22254007f, -0.21412951f, 0.02184534f, 
    -0.26273268f, -0.12949273f, -0.05324998f, -0.13569616f, -0.48803389f, 0.32475114f, -0.94633728f, 0.44383061f, 
    0.28187829f, -0.22734454f, 0.05202163f, -0.09319943f, 0.22757173f, -0.07730734f, -0.08076200f, -0.15593845f, 
    -0.08414461f, 0.03708181f, -0.05943224f, 0.05586236f, 0.10646173f, -0.38203016f, 0.18141121f, -0.04330772f, 
    0.08562449f, 0.05006443f, -0.31629449f, -0.21335959f, 0.29990780f, 0.15462542f, 0.06114071f, 0.10070038f, 
    0.23598923f, -0.06777216f, -0.13747083f, -0.10323125f, 0.08851703f, -0.01967598f, 0.05161759f, 0.11615706f, 
    -0.10024752f, 0.30038446f, 0.19769482f, -0.31736675f, -0.13062619f, -0.22521533f, -0.16868505f, -0.38742346f, 
    -0.02126468f, 0.02641215f, 0.03132862f, 0.13537808f, -0.28560793f, -0.10908598f, 0.11891802f, -0.47038376f, 
    -0.06817981f, -0.42973205f, 0.13323300f, -0.02394342f, -0.15631816f, 0.08689050f, -0.02584203f, -0.10269824f, 
    -0.31468394f, -0.23234202f, 0.07812140f, 0.03339007f, -0.13724838f, 0.23758413f, -0.25321665f, -0.05966969f, 
    -0.02553330f, -0.21904494f, -0.08173371f, -0.03181049f, 0.14537209f, 0.10064511f, 0.71588182f, -0.73973447f, 
    0.06877336f, -0.22600903f, -0.06096650f, 0.04513951f, -0.15922639f, 0.01295669f, 0.00520373f, 0.12879114f, 
    0.20482115f, -0.18092041f, -0.29979366f, 0.01939671f, 0.02833512f, 0.00315328f, 0.04149637f, 0.23795882f, 
    0.02371471f, -0.01974010f, -0.04441254f, -0.04283168f, -0.18449160f, 0.07002254f, 0.07671233f, 0.21504867f, 
    0.11248234f, -0.12241430f, -0.17290348f, -0.02154795f, 0.16207626f, 0.14478126f, 0.12108797f, 0.13888377f, 
    -0.02892836f, -0.03266497f, -0.79389018f, 0.19401814f, -0.06344459f, 0.07366189f, 0.25574541f, -0.28048196f, 
    -0.11421753f, -0.01451773f, -0.15447016f, 0.10323099f, 0.05507062f, -0.80477363f, 0.29017973f, 0.03345439f, 
    -0.24910989f, 0.25568029f, 0.51583856f, 0.24612519f, -0.06566710f, 0.12595472f, 0.13909334f, -0.03130228f, 
    0.14036474f, -0.14019071f, -0.05363366f, 0.01796915f, -0.08326054f, -0.04568428f, 0.21506757f, 0.04249277f, 
    0.04684944f, 0.15987881f, -0.16066496f, -0.36925349f, 0.13303675f, 0.25458363f, -0.02777020f, 0.02213341f, 
    0.01105287f, -0.16240016f, 0.14407240f, -0.11727535f, -0.14296427f, -0.38824669f, -0.40922999f, -0.11569484f, 
    -0.75546658f, 0.09647262f, -0.52364731f, 0.11434428f, -0.20047323f, 0.08467170f, 0.15837459f, 0.01185081f, 
    -0.07000063f, 0.06597452f, -0.10973012f, -0.08439650f, -0.28205553f, 0.27257076f, -0.47711533f, -0.12937059f, 
    0.03682092f, 0.00474316f, -0.02055237f, 0.07246108f, -0.21229866f, -0.08743715f, -0.20330076f, -0.32678863f, 
    0.10640673f, -0.24233964f, -0.26201478f, 0.39999375f, 0.08626383f, -0.07807259f, -0.09147679f, 0.08488720f, 
    -0.03006041f, 0.07129847f, 0.04823455f, 0.08174264f, 0.16248025f, 0.06931135f, -0.04246882f, -0.43689021f, 
    -0.28179857f, 0.14491861f, 0.27737883f, -0.05069416f, 0.27415255f, 0.09098882f, 0.00182040f, 0.00567985f, 
    0.38831916f, 0.08541553f, 0.28205052f, -0.12926188f, -0.24222359f, -0.08174307f, 0.17952068f, 0.09513853f, 
    -0.02597368f, -0.01145489f, 0.02267169f, 0.09214546f, -0.37255311f, -0.58367026f, 0.02532725f, -0.79912454f, 
    -0.11371540f, -0.08455410f, -0.05326223f, -0.16224024f, 0.10602188f, -0.26632869f, -0.11642351f, 0.06790676f, 
    -0.39986479f, 0.03594501f, -0.03677329f, -0.25801897f, 0.00752939f, -0.20720796f, 0.00522198f, 0.12277546f, 
    -0.02702270f, -0.46175703f, -0.46237174f, -0.28301144f, -0.12861140f, 0.19603692f, -0.06810458f, 0.25149590f, 
    0.02051769f, -0.01931146f, 0.07065843f, -0.25325885f, -0.01541802f, -0.05510579f, 0.03746410f, -0.27278572f, 
    -0.05889539f, -0.71870452f, 0.08712988f, -0.23807310f, -0.59082067f, -0.06339881f, -0.02788259f, -0.18804094f, 
    0.02748094f, -0.21563597f, -0.12236906f, -0.16316319f, -0.08618148f, 0.13398397f, -0.08704870f, 0.06118813f, 
    0.03724998f, -0.10552821f, -0.13789921f, 0.09582412f, -0.24443151f, 0.11352455f, 0.14954242f, 0.06081683f, 
    -0.22653566f, 0.08689501f, 0.07689538f, 0.00647429f, -0.16600274f, -0.06256643f, -0.04139423f, 0.09143254f, 
    -0.21305288f, 0.11566012f, 0.17159893f, 0.16793297f, -0.24531041f, 0.09829766f, -0.26864377f, 0.40452090f, 
    -0.02644418f, -0.20430510f, 0.05419233f, 0.07723291f, -0.20249914f, -0.09084094f, -0.13508996f, -0.08973858f, 
    0.24085550f, 0.18735425f, 0.21098030f, -0.55125207f, -0.10096756f, -0.12841815f, 0.06880889f, -0.09041875f, 
    -0.02529944f, -0.14010796f, 0.16465491f, -0.09039988f, -0.15387607f, -0.02146193f, 0.23868060f, 0.14483118f, 
    -0.27640337f, 0.00874359f, -0.03986963f, 0.05155318f, -0.19357616f, -0.19181399f, 0.22431490f, 0.09238759f, 
    -0.02908196f, -0.55897188f, -0.30793953f, -0.07746559f, 0.02098262f, -0.02051941f, 0.05892384f, 0.13672039f, 
    0.15252139f, 0.16561766f, 0.08523453f, -0.04949092f, -0.10418867f, 0.32536456f, 0.01665774f, -0.38220507f, 
    -0.36692446f, -0.06202268f, 0.04059861f, -0.04599363f, 0.18897557f, -0.15168281f, 0.17550118f, -0.00354198f, 
    -0.28204510f, -0.56335437f, 0.06485230f, 0.42991880f, -0.08506101f, 0.08795676f, -0.19456388f, -0.09973402f, 
    0.06027067f, 0.20189573f, 0.06583092f, 0.05544083f, -0.82242197f, 0.24799098f, -0.00794984f, -0.07530390f, 
    0.04321405f, 0.30460510f, -0.15557730f, -0.01033280f, -0.09813947f, 0.00723138f, -0.25673434f, -0.20141554f, 
    -0.04729924f, 0.22604467f, 0.09593817f, 0.21412893f, -0.02549164f, -0.02858040f, -0.05570915f, 0.13652736f, 
    0.22480723f, 0.06122701f, 0.25244328f, 0.20668168f, 0.15034334f, 0.50866574f, 0.20739307f, 0.08580685f, 
    -0.49599457f, 0.27459306f, 0.08409394f, 0.07678692f, -0.09829635f, 0.00392246f, -0.09164398f, -0.05030719f, 
    -0.17457317f, 0.14460655f, -0.16330190f, -0.00452095f, -0.27598470f, -0.03442657f, 0.31731623f, -0.03463854f, 
    0.16222756f, 0.11308667f, 0.38264611f, 0.30649078f, 0.39417070f, 0.20449087f, 0.27608570f, -0.00372128f, 
    -0.09769588f, -0.13332377f, 0.05620673f, 0.01375882f, -0.10332903f, 0.19842242f, 0.20653555f, 0.02136312f, 
    0.16968378f, 0.10161989f, 0.18731587f, 0.19961120f, 0.04275016f, 0.04229404f, 0.18842763f, 0.17350808f, 
    -0.15133089f, 0.05661384f, -0.10854109f, -0.03881154f, -0.14872009f, 0.08360425f, 0.46204937f, 0.34151047f, 
    -0.03440096f, -0.02142043f, 0.01068512f, 0.11928985f, 0.11400526f, -0.16098736f, 0.09095143f, 0.06179228f, 
    -0.03769525f, 0.50116926f, 0.17385520f, 0.05311000f, 0.08564784f, 0.00873619f, 0.01272448f, -0.02855368f, 
    -0.01189004f, 0.10595839f, 0.02960598f, 0.09774399f, -0.04525828f, 0.07139634f, 0.09228302f, 0.16926412f, 
    -0.04174595f, 0.00609676f, -0.00489806f, -0.04242853f, 0.18039033f, -0.00604302f, 0.20275962f, -0.04627570f, 
    0.11940444f, -0.05752316f, -0.40567985f, 0.10590954f, -0.00479791f, 0.12694018f, -0.17436752f, -0.10822043f, 
    -0.15314615f, 0.01430073f, -0.00559296f, -0.00690601f, -0.20978032f, -0.10735378f, 0.05389455f, -0.10076174f, 
    0.03682964f, 0.12481692f, -0.22286303f, -0.05461241f, -0.21911821f, 0.06143590f, -0.21454395f, -0.31836510f, 
    0.17808568f, 0.07015500f, 0.23332237f, 0.29964936f, 0.12197579f, 0.00151110f, 0.06659234f, 0.17487815f, 
    -0.01220504f, 0.17404833f, -0.01338993f, -0.27268791f, -0.08069611f, -0.10547531f, 0.06739715f, -0.26232263f, 
    -0.06374413f, -0.17401232f, -0.23756884f, -0.07984126f, -0.03243449f, -0.02748117f, -0.13633636f, -0.07918765f, 
    -0.01727208f, 0.16159447f, 0.47893906f, -0.69800150f, -0.07809003f, 0.05624851f, 0.20658964f, -0.05880013f, 
    0.01900143f, -0.07635860f, 0.06749283f, 0.06478724f, -0.15016086f, 0.07559688f, 0.08670093f, 0.00527701f, 
    -0.04545306f, 0.07104670f, 0.08412088f, 0.01064395f, 0.04452994f, 0.24644785f, 0.11894431f, 0.17699589f, 
    -0.37482268f, 0.18676159f, -0.10973815f, -0.04300653f, 0.07255258f, -0.07061325f, 0.15370008f, -0.10360476f, 
    0.01696020f, -0.02967137f, 0.05733275f, -0.06737302f, -0.39771873f, 0.49679127f, -0.67977393f, -0.08218203f, 
    -0.07162802f, -0.23704508f, 0.14252356f, -0.05570073f, 0.03039634f, 0.01328426f, 0.02142827f, 0.16366346f, 
    0.07762723f, -0.14444812f, 0.41478828f, 0.35944474f, -0.02839751f, 0.09338474f, 0.17257354f, 0.21873641f, 
    -0.17173988f, 0.08896528f, -0.02455034f, -0.01428434f, 0.47307003f, -0.12982547f, -0.02211606f, -0.14317155f, 
    -0.00889099f, 0.13953447f, 0.01157050f, 0.00893749f, 0.14544450f, 0.24737686f, 0.09695177f, 0.16089301f, 
    0.23420776f, -0.11672744f, 0.46673030f, -0.37239113f, 0.06818423f, 0.29377487f, 0.05469495f, 0.04848333f, 
    -0.19871287f, -0.08022773f, 0.06069593f, 0.00633359f, -0.11029126f, 0.13079026f, -0.23525971f, -0.19482987f, 
    -0.03654022f, -0.06524708f, 0.02151292f, 0.01710777f, -0.02142593f, 0.09104854f, -0.02336334f, -0.18411037f, 
    -0.36679706f, -0.73838377f, -0.24763860f, -0.17177112f, 0.01036637f, 0.09108161f, 0.04977912f, 0.07641898f, 
    -0.19084975f, 0.05228430f, 0.11559699f, -0.04734040f, -0.17144346f, 0.16934945f, 0.09146883f, 0.20162456f, 
    0.00411532f, -0.07921627f, 0.14075424f, 0.05069458f, -0.08731330f, 0.10265518f, 0.21019726f, 0.13918200f, 
    0.40661690f, 0.21536589f, 0.14458343f, -0.61360240f, 0.10489494f, 0.01454766f, -0.00701037f, 0.09052697f, 
    -0.01962070f, 0.10706145f, -0.04239163f, 0.00129329f, -0.23439498f, -0.01295666f, 0.02962341f, -0.18030061f, 
    0.00614216f, 0.17968290f, -0.08847654f, -0.33691376f, 0.04767966f, -0.11153758f, -0.14985210f, -0.13252982f, 
    0.14972064f, 0.12825727f, 0.03412567f, -0.07262712f, -0.01108816f, 0.25693265f, 0.05097742f, -0.05901394f, 
    0.04486344f, -0.03279034f, -0.10208334f, -0.17125431f, -0.56419551f, 0.22388756f, -0.08557327f, 0.25335017f, 
    -0.12086848f, 0.06589141f, 0.04044685f, 0.16964144f, -0.29875201f, -0.04084950f, 0.24467808f, 0.13213632f, 
    -0.51932353f, 0.12178153f, -0.28547052f, 0.01628581f, 0.20392434f, -0.02849240f, -0.32243568f, 0.14194812f, 
    -0.12283866f, -0.14066225f, 0.12014578f, -0.15591589f, 0.09136568f, -0.07096660f, 0.03470454f, 0.28234422f, 
    0.05763965f, 0.16466503f, 0.05459470f, 0.07862805f, -0.33259401f, -0.07564830f, 0.05766455f, 0.05675412f, 
    -0.53756833f, -0.80633307f, 0.21952845f, 0.11204154f, -0.33257541f, -0.15146814f, -0.33268872f, -0.13001186f, 
    -0.02428113f, 0.10585868f, -0.06263276f, -0.06170281f, -0.02068637f, -0.08054869f, -0.13209136f, -0.09336485f, 
    -0.03299323f, 0.14457834f, -0.05464138f, 0.00404105f, 0.14750214f, -0.08255332f, -0.14193003f, -0.19730176f, 
    0.02206525f, -0.64276606f, 0.56918377f, -0.35931283f, -0.23168290f, -0.00634884f, -0.27953556f, -0.09079669f, 
    0.01965583f, -0.10962972f, -0.06372534f, 0.05100278f, 0.07310133f, -0.00217743f, 0.23593105f, 0.62115508f, 
    0.27284473f, -0.28712302f, 0.13527341f, -0.00538154f, 0.08539183f, 0.18440445f, 0.01837686f, 0.10417391f, 
    -0.50514066f, 0.02768653f, -0.47604677f, 0.03230218f, 0.18120572f, -0.11904877f, 0.06553011f, -0.12451328f, 
    -0.16098246f, -0.13149019f, -0.10837072f, 0.09238555f, 0.36302307f, -0.53386647f, 0.29998341f, -0.04015490f, 
    -0.01118923f, -0.01232292f, 0.09342592f, -0.05533372f, -0.10837726f, 0.16736658f, 0.30884051f, 0.05857232f, 
    0.37658095f, -0.01600591f, 0.05233429f, -0.08575819f, 0.06356215f, 0.31340611f, -0.24641865f, 0.34449044f, 
    -0.22855774f, -0.06487703f, -0.14001007f, -0.28850049f, -0.29183021f, -0.13515349f, 0.39718804f, 0.15453750f, 
    -0.17168576f, 0.05380572f, -0.10517975f, -0.02107001f, -0.07665053f, -0.11438184f, -0.12447041f, -0.17535831f, 
    -0.66891778f, 0.16402385f, -0.44266042f, 0.26188186f, -0.06482360f, -0.06647996f, -0.11642169f, 0.07260714f, 
    0.06453328f, 0.07083981f, -0.11015318f, 0.00577704f, 0.20406371f, -0.63577944f, 0.50305289f, -0.45928964f, 
    0.08170085f, -0.17957640f, -0.12819910f, 0.12448843f, 0.05555753f, 0.14202639f, 0.19463436f, -0.12126734f, 
    -0.68398160f, 0.26816320f, -0.42702764f, 0.16329369f, 0.16620095f, 0.05414229f, 0.13771993f, -0.26806128f, 
    -0.09000017f, 0.01513756f, 0.04871356f, 0.22646613f, -0.19361331f, -0.18065417f, 0.00739845f, 0.16116692f, 
    0.07060903f, -0.14260170f, 0.05452965f, 0.16887707f, 0.02203065f, 0.03365856f, -0.12640153f, -0.20561548f, 
    0.51190501f, 0.23870894f, 0.46359190f, 0.20066591f, -0.05736638f, -0.09924110f, 0.03725678f, -0.06586678f, 
    -0.09287884f, 0.03139772f, -0.02296217f, -0.04682806f, -0.02844314f, -0.09684945f, -0.09074177f, -0.11699025f, 
    -0.02330420f, 0.02775199f, 0.32392278f, 0.02167725f, 0.03054359f, 0.24547459f, 0.25099558f, 0.01454615f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.17693883f, 0.15840589f, 0.12647915f, -0.09358791f, -0.11493408f, 0.11059245f, 0.06988723f, -0.13703716f, 
    0.06414136f, 0.07804997f, -0.00888812f, -0.02800916f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
