#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.92644387f, 0.61340964f, -0.16064526f, 0.24634515f, -0.56715780f, -0.51572645f, -0.36133680f, 0.29394636f, 
    -0.00606373f, -0.30542502f, 0.10575479f, 0.03025040f, 0.33935839f, 0.06283697f, -0.13487484f, 0.04183023f, 
    -0.18443856f, 0.25325978f, -0.40081888f, -0.33140698f, -0.24143319f, -0.01715737f, -0.15182529f, 0.08552299f, 
    -0.25087813f, -1.16650534f, -0.04975051f, -0.60585248f, -0.12916382f, 0.35740289f, 0.26446980f, -0.36104757f, 
    -0.06253226f, 0.13742773f, 0.53706014f, 0.00779374f, -0.30312148f, -0.04076599f, 0.12478364f, -0.36864063f, 
    -0.26683533f, -0.11280160f, -0.24972777f, 0.07644145f, -0.51246744f, 0.00301894f, 0.21255872f, -0.24510267f, 
    -0.45065603f, -0.51945150f, -1.08452916f, -0.23801684f, -0.04299717f, 0.73416263f, 0.30435342f, -0.12107331f, 
    -0.22634503f, 0.23438759f, 0.30934951f, 0.39408159f, -0.57762665f, -0.50244135f, -0.46069273f, 0.42244163f, 
    -0.04831758f, 0.31402963f, 0.07897794f, -0.22772799f, 0.12724835f, 0.25387034f, -0.37299818f, -0.33891144f, 
    -0.17837605f, -0.22782233f, -0.34350476f, -0.60390115f, -0.25603089f, 0.04851729f, -0.50374782f, -0.40291116f, 
    -0.09356456f, -0.33648065f, -0.90973639f, -0.67295319f, -0.83374393f, 0.18558602f, -0.00823008f, 0.35987213f, 
    0.08389870f, 0.16674362f, 0.17745712f, -0.35741496f, 0.13776405f, -0.17911661f, 0.08191744f, -0.03911393f, 
    0.35260600f, 0.25284895f, 0.26455384f, 0.10433447f, -0.10080361f, 0.02521598f, 0.62986505f, 0.83689857f, 
    0.07906677f, -0.12210632f, -0.52443552f, -0.50073659f, -0.93500382f, -0.50513512f, -0.09808411f, -0.37794673f, 
    -0.31622124f, -0.15765184f, -0.12318649f, -0.19706261f, -0.10354702f, 0.16312757f, 0.36041838f, 0.47599047f, 
    0.37256899f, -0.18290564f, -0.18230665f, -0.09660310f, -0.18083544f, -0.05344988f, -0.80223757f, -0.55510426f, 
    0.62147290f, 0.23520784f, -0.57719302f, -0.55726641f, -1.05369067f, -0.45642364f, 0.11942799f, 0.36637482f, 
    -0.12579729f, 0.12110508f, 0.32169399f, -0.10750732f, -0.15465122f, 0.30681396f, -0.44393578f, -0.31593770f, 
    -0.59311056f, -0.38594556f, -0.19964863f, -0.14079483f, -0.04820737f, -0.46487644f, -0.80310166f, -0.49729934f, 
    -0.60916060f, -0.44120991f, -0.16813354f, -0.12181814f, -0.25932762f, 0.42152920f, -0.14025454f, 0.46106783f, 
    -0.04012760f, -0.29080969f, 0.10196473f, -0.49840915f, -0.23922615f, 0.39018363f, 0.18802087f, -0.12043618f, 
    -0.12538035f, 0.17390664f, -0.20223980f, -0.36310387f, -0.18092376f, -0.25482672f, -0.28178415f, 0.48142368f, 
    -0.33217534f, 0.12333892f, -0.17166154f, 0.42736426f, -0.62634283f, -0.08929248f, 0.24661846f, 0.20857744f, 
    -0.10314480f, -0.00655759f, -0.04706957f, -0.34110895f, -0.12665482f, 0.34994245f, 0.19274758f, -0.01209696f, 
    -0.32058379f, -0.02402908f, -0.46210063f, -0.15623175f, 0.19705963f, 0.25522193f, 0.15400279f, 0.48064131f, 
    0.77057320f, -0.43701679f, 0.04068428f, -0.40629378f, -0.09219029f, 0.19729935f, -0.01451792f, -0.37868816f, 
    0.07339056f, -0.10985922f, 0.01467257f, 0.07771982f, -0.02583641f, -0.15341969f, 0.36453906f, -0.32009163f, 
    0.26252484f, 0.25245073f, -0.26218760f, -0.22433053f, -0.41008353f, -0.21267925f, -0.37894806f, -0.29086694f, 
    -0.41652733f, 0.16686878f, 0.94710958f, 0.03713002f, -0.51721936f, -0.26259652f, -0.84510469f, -0.67340243f, 
    -0.42921677f, -0.38707572f, -0.81709671f, 0.19315989f, -0.00878566f, 0.07329933f, -0.07390063f, 0.21119387f, 
    0.14050847f, -0.19574904f, 0.28349084f, -0.04262852f, 0.09194118f, -0.18655796f, 0.34553301f, 0.04036089f, 
    0.06768867f, 0.29917052f, 0.84002781f, -0.88215643f, -0.84419262f, -0.04629013f, 0.00017910f, 1.04497027f, 
    1.00379550f, 0.22954476f, -0.42374220f, -0.34100604f, -0.20039693f, 0.24984999f, -0.35070735f, -0.17236128f, 
    0.28464863f, 0.00845922f, -0.28378570f, -0.16273671f, 0.00999063f, -0.02211801f, 0.30944750f, -0.38993052f, 
    -0.20946389f, 0.46781120f, -0.17714895f, 0.81153554f, 0.99559629f, 0.71112359f, -0.37564793f, -0.03456040f, 
    -0.12569870f, -0.16392463f, -0.04988391f, -0.31053343f, 0.13333005f, -0.14203922f, -0.37034485f, 0.61476773f, 
    -0.32038024f, -0.26820877f, 0.18680099f, 0.09517705f, -0.06057248f, 0.00136024f, -0.01672970f, -0.17365775f, 
    0.20721929f, 0.02943054f, 0.08591047f, -0.26901352f, 0.67442459f, 0.90396422f, 0.05303233f, -0.39433962f, 
    -0.65851319f, 0.42677313f, 0.18811731f, 0.37838009f, -0.34529436f, -0.37193012f, -0.34673473f, 0.32169357f, 
    -0.16140030f, -0.26624304f, 0.16750944f, 0.10783894f, -0.00834407f, -0.18503751f, -0.08756227f, 0.12758517f, 
    0.05106433f, -0.20254055f, -0.31086558f, -0.16283511f, 0.13313387f, 0.20205420f, -0.77807349f, -0.59100187f, 
    -0.06673094f, -0.32006127f, -0.52208066f, 0.11962694f, 0.40378779f, 0.54397666f, -0.26901683f, -0.41715536f, 
    0.49624971f, 0.23586491f, -0.09760705f, -0.24430287f, -0.10747797f, -0.24261011f, -0.30929878f, -0.30972290f, 
    -0.23486717f, -0.07596430f, 0.26187208f, 0.19249739f, -0.09183539f, 0.05635203f, 1.11804092f, -0.74136925f, 
    -0.19817731f, 0.32353544f, -0.24119002f, 0.04218894f, 0.56750739f, -0.41602233f, -0.45306829f, 0.08738025f, 
    0.45545328f, -0.09893548f, -0.41573504f, -0.06188642f, 0.46761119f, 0.29270211f, -0.52951592f, -0.21134984f, 
    0.32188517f, -0.04329575f, -0.14337447f, 0.44459605f, 0.21145010f, -0.23353164f, -0.01943681f, -1.07312655f, 
    0.46613610f, -0.51360214f, -1.08871388f, 0.10197881f, 0.35967246f, 0.66400582f, -0.09056231f, 0.63099205f, 
    -0.10382191f, -0.28895578f, -0.27499402f, -0.10267687f, 0.03932323f, 0.26629707f, -0.21435605f, 0.09675114f, 
    0.17500919f, 0.20616327f, -0.05548945f, 0.05406069f, 0.00441954f, 0.14386363f, 0.05343672f, -0.15635476f, 
    0.41764253f, -0.89510292f, -0.01314844f, 0.33701640f, -0.56692415f, -0.68281519f, -0.23266461f, -0.28943661f, 
    -0.25797069f, -0.72486526f, -0.09522022f, -0.05652603f, -0.24157171f, -0.19433247f, -0.37423784f, 0.29586667f, 
    -0.21992831f, -0.08189324f, -0.26743332f, -0.44773510f, -0.39488113f, -0.04934665f, -0.14010856f, -0.11818712f, 
    -0.32978827f, -0.79931784f, -0.44870880f, -0.25980690f, -0.23549263f, 0.18862273f, 0.44039840f, -0.07158180f, 
    -0.01620551f, 0.20559703f, 0.97040743f, 0.05015603f, -0.03901062f, -0.05063171f, 0.19278197f, 0.12948464f, 
    -0.35564116f, -0.03606991f, -0.18020183f, -0.13794263f, -0.70455849f, -0.04178870f, 0.23088373f, 0.58447605f, 
    0.48715344f, 0.24118043f, 0.04383177f, -1.02562320f, -0.66482615f, 0.15526456f, -0.08733531f, 0.29025874f, 
    1.05238354f, -0.65781146f, -0.89605743f, -0.46953249f, -0.29970124f, -0.16842763f, -0.26231742f, -0.44517338f, 
    0.18737924f, -0.35794628f, 0.32529557f, 0.24846087f, 0.17962188f, 0.16084984f, 0.14789586f, -0.35845879f, 
    0.01667145f, -0.23585451f, -0.36980665f, 0.34117267f, -0.07038280f, 0.29363826f, 0.62334943f, 0.32559085f, 
    0.38040942f, 0.28831580f, 0.31675318f, 0.00030605f, 0.34029448f, 0.27954182f, 0.28953275f, -0.00751392f, 
    -0.19867617f, 0.29709923f, 0.16377480f, 0.20345616f, 0.13696411f, 0.15605795f, -0.33446398f, -0.03772432f, 
    0.30552632f, 0.22641054f, -0.15291376f, -0.14167915f, -0.66255516f, -0.53486550f, -0.53540915f, 0.02647720f, 
    -0.17609979f, -0.29076609f, 0.40172926f, -0.52074808f, -0.89353222f, -0.16479497f, -0.43376514f, -0.35541058f, 
    -0.15687399f, -0.38538188f, -0.33667618f, 0.02318676f, -0.12786731f, -0.26622409f, 0.11131500f, 0.09708373f, 
    -0.08189775f, -0.02704768f, -0.05490369f, -0.03207103f, 0.03346280f, -0.87694263f, -0.47002929f, 0.22150223f, 
    -0.64285207f, -0.61358404f, 0.11626879f, -0.05677204f, -0.38634992f, -0.38851577f, 0.22154941f, 0.09874561f, 
    -0.01510491f, 0.12425261f, 0.45451877f, 0.37566346f, 0.02023599f, -0.23318328f, -0.35167280f, -0.39798170f, 
    -0.41965011f, 0.20261911f, -0.29242858f, 0.39964858f, -0.20644972f, 0.31771407f, -0.46714732f, 0.70554030f, 
    0.38217816f, -0.85872746f, -0.01551505f, -0.32837817f, 0.09870686f, 0.19943173f, -0.03318043f, -0.01015156f, 
    0.41307852f, -0.05387419f, -0.35594830f, -0.64157850f, 0.13910994f, 0.07159863f, 0.45551538f, -0.12389318f, 
    -0.15697850f, -0.44860050f, -0.08053070f, 0.19240050f, -0.19393419f, -0.37444848f, -0.53506726f, -0.46293506f, 
    -0.09704788f, -0.79196990f, -0.53648537f, -0.49564883f, -0.10984328f, 0.22689439f, 0.36350363f, -0.31814021f, 
    -0.20857531f, 0.08331171f, -0.29451844f, -0.51087743f, -0.45115933f, -0.02708677f, -0.33401826f, -0.06461478f, 
    -0.32168379f, -0.07677667f, -0.14277317f, 0.22889727f, -0.11949586f, 0.17303550f, 0.51800621f, -0.10251658f, 
    0.26963323f, -0.64792776f, -0.96489447f, -0.98292035f, -0.72918934f, 0.33511168f, 0.16230598f, 0.38200814f, 
    0.08842997f, -0.07638133f, -0.08311114f, -0.17682168f, 0.05032543f, 0.32175443f, 0.04638006f, -0.07024357f, 
    0.20232090f, 0.30725342f, -0.22012946f, -0.14091527f, -0.22854963f, -0.25353214f, 0.10666142f, -0.22257450f, 
    -0.18098152f, -0.16771512f, 0.15981370f, 0.14868341f, 0.30578914f, -0.02364185f, 0.44585046f, -0.63656062f, 
    -0.03865431f, -0.14056812f, 0.57228720f, -0.04634150f, -0.21435565f, -0.22658564f, -0.03372305f, 0.49242750f, 
    -0.06534680f, -0.20607537f, -0.36379454f, 0.21315508f, 0.10683884f, -0.12972058f, -0.12551129f, -0.38625726f, 
    0.13044140f, 0.06636176f, -0.99592531f, -0.69156677f, -1.06924701f, -0.30934432f, 0.72548997f, 0.11042892f, 
    0.38000569f, 0.02581515f, 0.50947654f, 0.39521194f, 0.46168694f, 0.43348193f, -0.22845468f, 0.13838038f, 
    -0.28961745f, -0.15402842f, 0.03227616f, -0.13936324f, -0.08290645f, 0.14593054f, -0.04896685f, -0.02550686f, 
    0.20518261f, 0.18865915f, 0.17339167f, 0.16559033f, 0.22835554f, -0.55611151f, -0.36922157f, 0.66005343f, 
    0.20026894f, -0.36197332f, 0.73002791f, -0.71283519f, -0.73427242f, 0.10048817f, 0.10450875f, -0.06373098f, 
    0.23060264f, -0.33328247f, -0.13293318f, 0.38557410f, -0.06227738f, 0.18036591f, -0.12754485f, -0.13376170f, 
    -0.11346371f, -0.24418610f, -0.33382267f, 0.19067912f, 0.31744590f, 0.52457041f, -0.20852178f, -0.37877080f, 
    -0.43932238f, -0.33542261f, -0.28777465f, 0.25235555f, 0.03436358f, 0.21138583f, -0.32597604f, -0.03072813f, 
    0.37256211f, -0.09521168f, -0.17037317f, 0.36632711f, 0.12476270f, -0.31431171f, -0.31037256f, -0.38068679f, 
    -0.38353521f, -0.31035373f, -0.47998029f, -0.45974585f, -0.74827260f, -0.23006229f, 0.04226672f, -0.26176459f, 
    0.33515403f, 0.53414208f, -0.16473682f, -0.13166246f, 0.02215651f, -0.05879768f, -0.11113231f, -0.12803216f, 
    -0.08840483f, 0.04019697f, 0.15490973f, -0.13170604f, 0.13508238f, -0.46170661f, 0.49403411f, -0.21298924f, 
    -0.69058859f, -0.37046981f, 0.09449176f, 0.35524344f, 0.42388889f, 0.47584647f, 0.48472604f, -0.44503742f, 
    0.32954383f, 0.07728937f, 0.35944161f, 0.10549834f, -0.42314193f, -0.04193226f, 0.24788712f, 0.62169236f, 
    -0.11027108f, 0.36817747f, -0.08694658f, -0.20446587f, 0.23876026f, -0.29911324f, -0.32434729f, -0.09985087f, 
    -0.09996908f, -0.19944367f, -0.28543907f, 0.18738587f, 0.14035141f, -0.34888023f, 0.14140093f, 0.73965651f, 
    -0.04067262f, 0.27185902f, -0.19685647f, -0.44630653f, -0.06132624f, -0.26298806f, 0.15597646f, 0.52728105f, 
    0.07421216f, 0.62345165f, -0.47292286f, -0.33199003f, 0.03681253f, -0.37691751f, -0.29936442f, 0.27863783f, 
    -0.13286228f, 0.01438073f, -0.36918539f, 0.19499318f, 0.20932576f, 0.02534008f, 0.01258189f, -0.12842870f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.26435533f, 0.03538327f, 0.05216422f, 0.30706200f, -0.25984788f, 0.18311419f, -0.05249674f, 0.26253995f, 
    0.09473156f, 0.30061126f, 0.57075548f, 0.00592727f, 0.50380701f, 0.61216819f, 0.11213785f, 0.34144437f, 
    0.15990323f, 0.25186941f, -0.06006223f, -0.13632800f, 0.12573515f, 0.01425646f, 0.39104676f, -0.16318367f, 
    -0.15718700f, 0.48698935f, 0.62113976f, 0.01885091f, 0.11312953f, 0.26207396f, 0.23269010f, 0.33308291f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.03112643f, 0.01644532f, -0.00768556f, -0.01171692f, 0.03938645f, -0.01389644f, -0.03801804f, -0.01178891f, 
    -0.00719047f, -0.01741206f, 0.00004615f, -0.02630136f, -0.03794893f, 0.03981980f, 0.03090642f, -0.03936530f, 
    0.01985789f, 0.03484374f, -0.03587844f, -0.03745854f, 0.01666299f, 0.02753739f, 0.01618268f, 0.00994797f, 
    0.00648623f, -0.02526509f, 0.01837024f, 0.00615342f, 0.03202170f, 0.02559497f, -0.03202006f, -0.03934008f, 
    0.01451444f, -0.02074190f, -0.02343946f, 0.02026080f, 0.04067624f, 0.02293347f, 0.01650853f, 0.02110343f, 
    0.04957663f, 0.01737770f, 0.02894383f, -0.00446732f, -0.00653270f, -0.04448320f, -0.05200509f, 0.01009259f, 
    -0.02905021f, -0.04286099f, 0.02338593f, -0.00685971f, -0.00093319f, 0.03978497f, -0.02482284f, 0.00521214f, 
    -0.05438272f, -0.03254054f, -0.02501048f, 0.04228007f, -0.03653742f, 0.00624391f, 0.03755072f, -0.00464156f, 
    -0.00105130f, 0.02940819f, -0.00600004f, -0.04918295f, -0.03097798f, 0.02710884f, -0.03955549f, -0.02668427f, 
    0.01598554f, 0.04529596f, -0.04134938f, -0.00165049f, 0.02902879f, -0.05434587f, 0.00392262f, 0.02035752f, 
    0.04144831f, 0.01924379f, 0.00502248f, -0.04088750f, -0.01987037f, -0.03415496f, -0.04885909f, -0.05417321f, 
    0.02849903f, 0.03540508f, -0.03783572f, -0.03441386f, -0.01565560f, -0.00845328f, -0.03949451f, 0.02828196f, 
    -0.00045222f, -0.03453652f, 0.01897969f, -0.02418766f, 0.00040752f, 0.00471262f, -0.02206147f, -0.01859111f, 
    -0.03409415f, -0.05534427f, -0.05214595f, -0.02937964f, 0.03189876f, -0.01714452f, -0.01258749f, -0.04162143f, 
    0.00881558f, 0.01179602f, 0.00524043f, 0.04217438f, 0.02840094f, 0.02061825f, -0.02759140f, -0.00935435f, 
    -0.02179363f, 0.00305962f, 0.01917910f, 0.02062283f, 0.01564983f, 0.01418779f, -0.03917373f, 0.03588466f, 
    0.03074602f, -0.02340782f, -0.01786293f, -0.04785125f, -0.01844829f, -0.04104453f, -0.02023964f, -0.03538873f, 
    -0.01730595f, -0.02678964f, 0.01346856f, -0.03368679f, 0.02162941f, 0.00311333f, -0.01647194f, 0.04215194f, 
    -0.01419490f, 0.02649172f, 0.01387629f, -0.01620603f, 0.02953884f, -0.05044020f, 0.01206240f, 0.02776878f, 
    0.03119968f, -0.00135014f, -0.04943649f, -0.01980496f, -0.04106736f, -0.03014831f, -0.00928100f, -0.01122892f, 
    0.02369061f, -0.00919259f, -0.00456157f, 0.03722792f, 0.03170832f, 0.01500335f, -0.00832831f, -0.00698574f, 
    0.03258596f, -0.03577527f, -0.03632502f, -0.05489423f, 0.04213724f, 0.04613545f, -0.03964715f, 0.00871956f, 
    0.03386232f, 0.03653062f, 0.00824219f, -0.02637400f, -0.03981807f, -0.04441644f, -0.01354545f, 0.02482410f, 
    0.01049735f, 0.02696423f, -0.01874847f, -0.01862757f, -0.03288664f, -0.00646617f, 0.03779894f, -0.02640171f, 
    -0.03776164f, 0.00055538f, -0.00945629f, 0.01814876f, -0.05559631f, -0.02845278f, -0.02350157f, 0.00544475f, 
    0.02405837f, -0.01755647f, -0.02862939f, -0.00884117f, -0.01920839f, 0.01084413f, 0.00947733f, 0.03473800f, 
    -0.04429162f, -0.03487939f, -0.04722818f, -0.02456401f, 0.02411899f, -0.01464634f, -0.03135358f, -0.04193323f, 
    0.00797291f, -0.00600525f, 0.03323513f, -0.04244324f, 0.01920771f, -0.02397851f, -0.02543891f, -0.02768237f, 
    -0.00928344f, 0.02807133f, -0.05782126f, -0.03702099f, 0.02069375f, -0.01066389f, -0.05022525f, -0.05572428f, 
    0.04007436f, 0.00214035f, -0.03836859f, 0.02113974f, -0.01228442f, 0.00215547f, -0.01725189f, 0.04353109f, 
    -0.00502167f, -0.02180304f, 0.00339730f, 0.03524437f, 0.01611348f, 0.00987093f, 0.03318415f, -0.01611923f, 
    0.00585226f, 0.00212858f, -0.02149197f, -0.00320759f, -0.00280245f, -0.04465661f, 0.00967650f, -0.00537114f, 
    0.02629985f, -0.03598842f, 0.00033798f, 0.04248390f, -0.05210861f, 0.01617872f, -0.00920876f, -0.01154181f, 
    -0.00807493f, 0.01908471f, 0.01985621f, 0.01756291f, 0.01140297f, -0.01753490f, 0.04034856f, -0.00536129f, 
    0.04275234f, 0.03151747f, 0.02615603f, -0.03670403f, -0.04434143f, -0.04154534f, 0.03049500f, 0.01551737f, 
    -0.00241233f, -0.00592451f, -0.04156398f, 0.03351830f, -0.04249546f, -0.04382553f, -0.05297856f, -0.03319672f, 
    0.03645893f, 0.04158600f, -0.04955288f, -0.01731592f, -0.02391981f, -0.02921162f, -0.00932145f, -0.04655813f, 
    0.03416472f, -0.04522622f, -0.05091020f, 0.01268943f, -0.05046958f, -0.02527689f, 0.03070929f, -0.04685796f, 
    0.03932517f, 0.02230561f, 0.01798068f, 0.00795703f, 0.01431647f, -0.05782666f, 0.03230229f, -0.01029960f, 
    0.02590274f, -0.00974410f, -0.02955935f, 0.01046719f, -0.01740876f, -0.05184133f, 0.02709875f, -0.00935143f, 
    0.01752173f, 0.03370816f, -0.02894836f, 0.02798779f, 0.00177333f, -0.04540887f, -0.01331108f, -0.01213842f, 
    -0.04886000f, -0.05423921f, 0.04906622f, 0.00034818f, 0.00569083f, -0.03623373f, -0.03145209f, 0.02890782f, 
    0.02051651f, 0.01024560f, -0.02917158f, -0.00924411f, -0.04574906f, -0.00081767f, 0.02551053f, 0.02559102f, 
    0.01248077f, 0.01670981f, -0.04848024f, 0.04074345f, -0.04093149f, -0.04043812f, 0.02389216f, 0.01166039f, 
    -0.04375299f, 0.04589348f, -0.02888462f, -0.03844615f, -0.03298144f, -0.05447474f, -0.04380885f, -0.03724594f, 
    -0.02857697f, -0.05261047f, -0.03637766f, -0.02114710f, 0.01488815f, 0.02752431f, -0.02061876f, -0.02041308f, 
    -0.04132792f, -0.00305949f, 0.03103555f, -0.00386987f, 0.01478494f, -0.04154184f, 0.03981613f, 0.00108183f, 
    0.02865441f, -0.02880107f, -0.03869524f, 0.01899691f, -0.00968140f, 0.01362244f, 0.01161274f, -0.05024081f, 
    -0.15675232f, -0.16493930f, 0.18193731f, 0.12267958f, 0.07640044f, 0.05155023f, -0.14681564f, -0.11770781f, 
    -0.09242802f, -0.00040637f, 0.06716534f, 0.20129891f, -0.21932058f, 0.33023652f, 0.07715382f, 0.14692883f, 
    -0.02543786f, 0.05824632f, 0.04492510f, -0.06106199f, -0.02520900f, -0.03501549f, 0.04629771f, -0.14605017f, 
    -0.35707223f, -0.26766476f, 0.19515742f, -0.06371991f, -0.05434242f, -0.06867985f, 0.02186370f, -0.07764129f, 
    0.16838442f, 0.03558175f, -0.13757984f, 0.02152479f, 0.35132724f, 0.41428548f, 0.03379636f, -0.05447498f, 
    -0.04145119f, 0.20959680f, 0.20861381f, 0.27236131f, -0.00646927f, 0.03122047f, 0.01481326f, -0.00312653f, 
    0.41531330f, 0.09154470f, 0.00823568f, -0.47653520f, -0.01043813f, -0.23170227f, -0.00512191f, 0.24044918f, 
    -0.01731345f, -0.07287696f, -0.09365474f, -0.18736199f, 0.37432945f, 0.43515366f, 0.31686911f, -0.06302866f, 
    0.13362941f, -0.00816077f, 0.23338243f, 0.08705018f, -0.05410049f, 0.02081190f, 0.12461367f, 0.04493287f, 
    -0.01391077f, 0.22458333f, 0.17037925f, -0.04620880f, 0.11579479f, 0.09931635f, -0.12701225f, -0.09066006f, 
    -0.01563344f, -0.07908172f, 0.01673598f, -0.07714205f, -0.05068778f, 0.06934465f, 0.08539312f, 0.07215181f, 
    0.05258879f, -0.03255672f, -0.03333874f, -0.06372568f, -0.00977105f, -0.02260380f, -0.09525134f, 0.06224632f, 
    -0.01457211f, -0.08930486f, -0.04848086f, -0.01231010f, 0.00859239f, -0.10305156f, 0.00897635f, -0.06675072f, 
    -0.05136727f, -0.08583261f, -0.02388238f, -0.09629647f, 0.24136299f, 0.33372945f, -0.09746382f, 0.06113797f, 
    0.06262483f, -0.00705305f, 0.04739536f, 0.18796907f, -0.13593024f, 0.13503651f, -0.01234404f, 0.08676542f, 
    0.55647218f, -0.25924337f, 0.05524932f, 0.01330182f, -0.08726577f, -0.07535817f, -0.06513264f, -0.02256782f, 
    0.28365126f, 0.13989934f, -0.05658115f, 0.11186512f, 0.08828097f, 0.08635119f, 0.16167788f, 0.22411999f, 
    -0.01720154f, -0.04132064f, -0.05970701f, -0.00738571f, -0.01957746f, 0.00441126f, -0.04026256f, 0.01243788f, 
    0.07071607f, -0.11966236f, -0.20354293f, 0.15850762f, -0.03908083f, 0.05623599f, -0.00713865f, 0.03779339f, 
    0.06270044f, 0.05015577f, 0.07088156f, -0.01411287f, 0.19036058f, -0.11440710f, -0.12143424f, 0.12113021f, 
    0.07759135f, 0.18093860f, 0.13094383f, 0.00175363f, 0.12102739f, -0.05265364f, 0.08168867f, 0.02677480f, 
    0.17593879f, -0.03476441f, -0.07819658f, -0.07898052f, -0.16446809f, 0.00857065f, 0.06179380f, 0.06053561f, 
    -0.28595552f, 0.21170589f, -0.00791420f, 0.02649950f, -0.40500870f, -0.01331643f, 0.07204112f, -0.16839716f, 
    0.00181190f, 0.14759010f, 0.08101862f, 0.12448901f, -0.11033899f, 0.08147792f, -0.04461287f, -0.20292880f, 
    0.42866045f, 0.23309052f, 0.25027311f, -0.10504863f, 0.21845195f, 0.15652530f, 0.00775135f, 0.19844493f, 
    -0.12910472f, -0.08623738f, 0.07370848f, 0.11451194f, -0.30651775f, 0.30180317f, -0.03418941f, 0.03464988f, 
    -0.10536423f, 0.06267307f, 0.05230099f, -0.18530248f, 0.11377949f, -0.14057475f, -0.08856373f, -0.11614923f, 
    0.48041448f, 0.21057650f, 0.18871820f, -0.06232567f, 0.11824990f, 0.18400650f, -0.10309333f, 0.17964484f, 
    -0.07787578f, -0.05635263f, 0.02097713f, 0.04338344f, 0.06133518f, 0.02853331f, 0.01113648f, 0.08282232f, 
    -0.03022846f, -0.03041888f, -0.00350733f, -0.04663844f, -0.02658579f, 0.05713364f, 0.05491410f, 0.10577563f, 
    0.49598339f, 0.37319523f, 0.26768216f, 0.10420036f, 0.17254387f, 0.26735267f, 0.17996050f, 0.15507266f, 
    -0.02395361f, -0.01465217f, -0.01707384f, 0.02999655f, 0.04763556f, 0.19287190f, 0.01659017f, -0.04243433f, 
    0.23933718f, 0.13825241f, 0.07839773f, 0.11941981f, 0.14674748f, -0.12470601f, -0.10899391f, -0.09237956f, 
    -0.33744344f, 0.27918684f, 0.04866886f, 0.13227472f, 0.01189451f, -0.06724013f, 0.13748524f, -0.07596772f, 
    -0.03288641f, -0.03788009f, -0.00291506f, 0.08455512f, 0.23291679f, 0.24763848f, 0.25104296f, 0.03725642f, 
    0.16236509f, 0.24541134f, 0.13399903f, 0.21530908f, -0.08281954f, -0.01965050f, -0.15437594f, -0.04666149f, 
    0.34344542f, -0.13938786f, 0.00504929f, -0.15316941f, 0.21586785f, 0.08321011f, -0.16004753f, -0.08446378f, 
    0.04560522f, -0.07160046f, -0.00261248f, -0.19419037f, -0.16848537f, 0.16883224f, 0.05709362f, 0.11863551f, 
    -0.06990826f, -0.02210775f, -0.00706718f, -0.06055551f, 0.07133373f, 0.08211855f, 0.11419038f, 0.14935938f, 
    -0.02457300f, -0.02002027f, -0.22156394f, -0.06029732f, -0.07940216f, 0.08704931f, 0.11821122f, -0.07043108f, 
    0.01811242f, 0.03735031f, 0.11663930f, 0.13761377f, -0.06496000f, 0.00007229f, -0.19363821f, 0.04121212f, 
    -0.14605625f, 0.23989229f, 0.03808659f, 0.29122549f, -0.11437161f, 0.06110291f, 0.03029468f, 0.06581599f, 
    -0.29816499f, -0.02167727f, 0.17691667f, 0.02232176f, 0.11700555f, -0.02299054f, -0.10714132f, -0.07377230f, 
    -0.09137380f, -0.19969241f, -0.14434569f, -0.02948833f, -0.02787630f, 0.03810259f, 0.09261861f, 0.09665166f, 
    0.05608415f, 0.01830410f, -0.02764599f, -0.09633545f, 0.01135141f, 0.01771212f, 0.02068958f, 0.11967251f, 
    0.07050418f, 0.19372062f, 0.09787991f, 0.16994822f, -0.05410837f, -0.00521005f, -0.09049037f, -0.01654948f, 
    -0.05251748f, 0.04116556f, 0.12701593f, -0.01147523f, 0.14255354f, 0.11822564f, -0.00184425f, 0.29640502f, 
    -0.04490026f, -0.00818196f, -0.03053835f, 0.11976890f, -0.06017869f, -0.08578179f, 0.03404409f, 0.14502269f, 
    0.00513856f, 0.02229697f, -0.04835941f, 0.01570414f, 0.01801476f, 0.01178356f, 0.03847044f, -0.01681805f, 
    0.03353519f, -0.00407372f, -0.01322815f, -0.04779781f, 0.03813678f, -0.04242813f, 0.00573326f, 0.01015992f, 
    -0.02194499f, 0.01230043f, 0.03032338f, 0.04117509f, -0.05875772f, 0.00553400f, 0.02774582f, -0.02730920f, 
    -0.04507867f, 0.00787830f, 0.00867810f, -0.04940420f, -0.05547648f, 0.01676540f, -0.03612340f, 0.04358723f, 
    -0.04795739f, -0.01385348f, -0.03982169f, -0.01863120f, 0.00472809f, -0.00531356f, 0.01408207f, -0.01757316f, 
    -0.01500136f, -0.02181757f, 0.00650213f, 0.01183227f, -0.02108515f, -0.04569493f, -0.00416983f, -0.04856995f, 
    -0.05465143f, 0.03627316f, -0.02074166f, -0.02862456f, -0.00493185f, -0.02672672f, 0.03022405f, 0.00968901f, 
    -0.00291097f, 0.01875361f, -0.00134516f, 0.03849791f, -0.01737199f, 0.03191726f, -0.03532067f, 0.01368643f, 
    0.02465246f, 0.00982948f, 0.02348706f, -0.02837594f, -0.03005456f, 0.02805975f, -0.04943057f, -0.04054875f, 
    -0.03968920f, -0.00038181f, -0.05562852f, -0.00076797f, -0.01073434f, 0.03884618f, -0.02503697f, -0.02793920f, 
    -0.00912756f, -0.04188060f, -0.00435455f, 0.01233211f, -0.04358073f, -0.03491243f, -0.02201302f, 0.03396246f, 
    0.04527283f, -0.01321424f, 0.02844093f, 0.03864417f, -0.00026787f, -0.05967635f, 0.03127995f, 0.01475963f, 
    0.03234228f, -0.05065986f, -0.00309757f, 0.01091492f, 0.02054971f, 0.00999386f, -0.01572757f, -0.02119764f, 
    0.00947956f, 0.01628778f, -0.04300055f, -0.02185930f, -0.04570401f, -0.02256363f, -0.02381359f, 0.00210811f, 
    -0.00132156f, -0.04015353f, 0.03138520f, -0.03610473f, -0.05890365f, -0.02738772f, 0.02567197f, -0.04511729f, 
    0.03850078f, -0.00852029f, -0.04283683f, 0.00504931f, 0.03772188f, -0.00285375f, -0.05824835f, 0.02559654f, 
    -0.02053581f, 0.03007967f, 0.02897339f, 0.01567852f, -0.03461205f, -0.01770823f, -0.01490504f, -0.02744829f, 
    0.00838069f, 0.02660721f, 0.03181143f, 0.03534485f, 0.01059101f, 0.00373752f, -0.01928211f, 0.01764548f, 
    -0.01700515f, -0.04337954f, 0.03179148f, -0.02681465f, -0.02435023f, -0.04615013f, -0.00513891f, 0.01221222f, 
    -0.01833419f, -0.05563451f, -0.03414166f, -0.02869651f, -0.02825891f, 0.00537499f, -0.04232351f, -0.06062853f, 
    0.03448056f, 0.02111029f, -0.00879005f, -0.03570743f, 0.00664580f, -0.01139522f, -0.04962809f, -0.00916253f, 
    -0.05478118f, -0.04043530f, -0.00989572f, 0.01334350f, -0.01741147f, -0.01260835f, 0.03475434f, 0.02863225f, 
    -0.05279750f, 0.02133210f, 0.02835014f, 0.02575962f, -0.00728089f, -0.01372623f, 0.00013283f, 0.00769662f, 
    -0.04154291f, 0.01427361f, -0.00284196f, -0.03871582f, 0.02204699f, -0.03880358f, 0.01266809f, 0.00036336f, 
    0.01057322f, 0.02810717f, 0.01022402f, 0.03128236f, -0.02513203f, 0.00328708f, 0.01734599f, 0.02579736f, 
    0.01755812f, -0.04859557f, -0.04555373f, 0.02171836f, 0.03375504f, -0.01662217f, -0.03922866f, -0.00069233f, 
    -0.04702546f, 0.03883348f, -0.00898412f, 0.00430874f, 0.03152223f, -0.01777311f, -0.02587254f, -0.00488600f, 
    -0.02132869f, 0.00443642f, 0.03324882f, -0.00026880f, 0.03526292f, 0.04079168f, -0.02540896f, -0.02380933f, 
    -0.05463611f, 0.02025614f, -0.01423578f, 0.00158070f, -0.04709965f, 0.02238153f, 0.02680679f, 0.00330597f, 
    0.00905106f, -0.03062022f, -0.01052063f, -0.03211217f, 0.02687991f, 0.00897647f, -0.02074729f, 0.00753283f, 
    0.02844382f, -0.01834412f, 0.01831395f, -0.02666523f, -0.02436882f, -0.05724776f, -0.03696615f, -0.02621562f, 
    0.00022302f, -0.05161650f, -0.03201892f, 0.03203384f, 0.03720433f, -0.01852523f, -0.05090889f, -0.05694971f, 
    0.00722930f, -0.05468489f, 0.00729549f, -0.03087956f, -0.04404410f, 0.01593159f, -0.01006824f, 0.01220969f, 
    0.02619498f, 0.00634965f, 0.01705974f, 0.03662454f, -0.03507393f, 0.00949152f, 0.02623728f, 0.02498805f, 
    -0.01279730f, 0.03205755f, 0.03965232f, -0.04778257f, -0.01766279f, -0.05703114f, -0.03041391f, -0.02288780f, 
    0.03978954f, -0.05271298f, 0.03724731f, -0.01167140f, -0.02876031f, 0.02571334f, -0.02407183f, -0.01762570f, 
    -0.00859710f, -0.04861625f, 0.03230964f, 0.01437124f, 0.02154739f, 0.03695195f, -0.04070340f, -0.04613997f, 
    0.01136748f, -0.02391277f, 0.00923644f, 0.02537270f, 0.03059098f, 0.02622266f, -0.03158598f, 0.02295339f, 
    -0.01365809f, -0.05689924f, -0.00299255f, 0.03675247f, -0.04006820f, 0.00785333f, 0.04163827f, 0.02020514f, 
    0.01322338f, 0.01153854f, -0.05567507f, 0.01055791f, -0.02153697f, -0.03317727f, -0.01414027f, -0.00982633f, 
    -0.00635822f, 0.02230732f, -0.02125907f, 0.02228309f, -0.04671748f, -0.04592621f, 0.00458210f, 0.01591953f, 
    0.04223559f, 0.01837131f, -0.04660293f, 0.00793394f, 0.00370316f, 0.02006284f, 0.03259752f, 0.00858968f, 
    0.01591502f, -0.04288790f, 0.01029520f, -0.04100681f, -0.04697485f, -0.00828270f, -0.03106313f, 0.03987182f, 
    -0.00052054f, -0.00568033f, -0.03003615f, -0.00364549f, -0.04518958f, -0.00045525f, 0.02999167f, -0.00226269f, 
    -0.00828555f, -0.06071942f, 0.01557062f, -0.00258526f, 0.00245835f, 0.03216055f, -0.02725157f, 0.03710480f, 
    0.02260349f, -0.04394056f, -0.04911094f, -0.02299216f, 0.00986366f, 0.02164761f, 0.03932555f, -0.03803185f, 
    -0.03018131f, -0.02402132f, -0.03699977f, 0.02534554f, -0.05716458f, -0.00060958f, -0.00418157f, 0.03616432f, 
    -0.04081718f, -0.03703691f, 0.00385766f, -0.02620036f, -0.03412103f, 0.04066519f, -0.00721228f, -0.05645483f, 
    0.05811579f, 0.09607886f, 0.22341989f, -0.21726035f, -0.17133418f, -0.04048887f, 0.01817301f, -0.01623796f, 
    0.11447784f, 0.15607378f, -0.03779238f, 0.16025382f, 0.37615865f, 0.00982764f, -0.23849425f, -0.04103705f, 
    -0.01218402f, 0.03936414f, -0.06701431f, 0.03207650f, -0.03322331f, 0.15616958f, 0.13171025f, 0.28953001f, 
    0.32710138f, 0.07302838f, -0.16506143f, 0.01571868f, -0.01337564f, 0.05795624f, 0.05049536f, 0.08180027f, 
    0.10180272f, 0.01575210f, 0.34624496f, 0.30001396f, -0.49353814f, -0.30918759f, -0.10739365f, -0.01867317f, 
    0.01501672f, -0.21593861f, -0.20053603f, -0.29682791f, -0.21382596f, -0.10667651f, -0.04487634f, -0.06341664f, 
    -0.37304962f, 0.55972809f, 0.13363534f, -0.03549864f, -0.07337925f, -0.01783510f, 0.05357495f, -0.15982586f, 
    -0.08304809f, -0.01246480f, 0.04577935f, 0.05478667f, -0.35282999f, -0.34359550f, -0.18511327f, 0.33434212f, 
    -0.03783953f, 0.03069739f, 0.01151698f, 0.09433344f, -0.01733947f, -0.00855262f, 0.04382807f, 0.01673353f, 
    0.09080093f, 0.05341450f, -0.04662572f, 0.21444018f, -0.12846927f, 0.07278091f, 0.36035293f, 0.15337145f, 
    0.04759276f, 0.05864807f, 0.12644486f, 0.13534866f, 0.29852760f, 0.13806285f, -0.09161763f, 0.14210117f, 
    -0.21881066f, -0.11488301f, -0.00555993f, -0.10849235f, -0.03960076f, -0.09467912f, -0.07420964f, -0.21529169f, 
    -0.20245375f, -0.08522279f, 0.02999561f, 0.01980271f, -0.03795939f, 0.04251310f, 0.07188521f, -0.01336812f, 
    0.12677495f, 0.36430019f, 0.23952118f, 0.38549098f, -0.13061336f, -0.29693958f, 0.21672696f, -0.19616292f, 
    0.02865632f, 0.06016286f, -0.06748037f, -0.11517099f, -0.08648095f, -0.13314496f, -0.11701685f, -0.11842486f, 
    0.13486229f, -0.05966580f, 0.22528306f, 0.14531685f, -0.01161345f, -0.07845882f, 0.12656437f, 0.04593028f, 
    -0.01500696f, 0.01151245f, 0.17805427f, 0.19976631f, 0.24027433f, 0.18963657f, 0.24557677f, -0.28092179f, 
    -0.22827937f, -0.13207926f, -0.11563329f, 0.05747467f, 0.00404283f, -0.02538835f, 0.04776027f, -0.00593266f, 
    0.29069594f, 0.17002918f, 0.31011888f, -0.20768684f, -0.00663684f, -0.10897546f, -0.05954321f, 0.03747617f, 
    0.18176907f, 0.19970687f, 0.03389302f, 0.26103848f, -0.03609435f, 0.13118671f, -0.09811291f, -0.04423796f, 
    -0.11958089f, -0.03185019f, 0.17223433f, 0.13612716f, -0.02813746f, 0.09153386f, 0.05194720f, 0.14622170f, 
    -0.00542670f, 0.20289113f, -0.09265681f, 0.11989681f, 0.03567890f, 0.08448847f, 0.01628463f, 0.02639554f, 
    0.08372433f, -0.10480084f, 0.06939230f, 0.04947880f, -0.01276387f, 0.01286357f, 0.11419151f, 0.13051960f, 
    0.02736336f, 0.02632299f, 0.03589236f, 0.14166164f, -0.15612055f, -0.07257862f, -0.04788997f, 0.03694085f, 
    -0.35322055f, -0.31162068f, -0.08047008f, 0.11987253f, 0.00575520f, 0.07833458f, 0.19413227f, -0.16294616f, 
    0.01285839f, 0.05294567f, 0.03743190f, 0.06526569f, 0.12744798f, -0.27538708f, -0.05893027f, 0.04690025f, 
    -0.11479198f, -0.11354292f, 0.02341999f, 0.15763250f, -0.13301349f, -0.05997752f, 0.16538753f, 0.00347957f, 
    -0.20119654f, -0.33120155f, 0.15285285f, 0.18069753f, 0.03716346f, 0.06295585f, 0.27662343f, 0.08743484f, 
    -0.05291372f, -0.11560521f, -0.01901843f, -0.05690772f, 0.14921881f, 0.12931477f, 0.08949086f, 0.04357209f, 
    -0.05366658f, 0.00600250f, -0.03260724f, 0.02030273f, -0.07593731f, -0.20209683f, -0.08753540f, -0.09840328f, 
    -0.11886165f, -0.23234022f, -0.02644456f, -0.05447267f, 0.01815341f, -0.05959988f, 0.06535731f, -0.00340693f, 
    -0.12649880f, -0.07498021f, -0.12985381f, -0.03492833f, -0.14463109f, -0.38839561f, 0.27892536f, 0.15864177f, 
    -0.02963971f, -0.00850564f, -0.12328353f, -0.11290283f, -0.18532136f, -0.01966783f, 0.10206499f, -0.00662177f, 
    0.27977112f, -0.17595409f, 0.25255391f, -0.05942699f, 0.04202857f, 0.10812294f, 0.04129982f, 0.07389354f, 
    0.14991443f, 0.30267572f, 0.12230968f, 0.21263359f, -0.20478082f, -0.22160496f, 0.17963155f, 0.00092138f, 
    -0.18021071f, -0.09422842f, 0.04180859f, 0.02497063f, -0.16126575f, -0.04728891f, -0.09523430f, 0.01928339f, 
    -0.19064847f, 0.55340832f, 0.49222422f, 0.17718178f, -0.31943396f, 0.01031315f, 0.31114730f, -0.03957566f, 
    -0.14456405f, 0.05638906f, 0.04699235f, 0.05508991f, 0.19347627f, 0.21307775f, -0.01930239f, 0.06790587f, 
    -0.00013430f, 0.08054827f, -0.03131131f, -0.03817811f, 0.01414806f, 0.06003038f, 0.08736986f, 0.02522226f, 
    0.17159446f, 0.12339184f, -0.04522954f, 0.03812598f, -0.05238015f, -0.11894827f, -0.02151164f, 0.18494426f, 
    -0.00784617f, 0.05129568f, -0.03347502f, -0.07266097f, -0.04865978f, 0.04491479f, 0.03068050f, -0.18754338f, 
    0.21559255f, -0.02040286f, 0.18094407f, 0.18910660f, -0.02813674f, 0.06750843f, 0.03085392f, -0.04043460f, 
    0.06538957f, -0.02478566f, -0.22536673f, 0.02683131f, -0.06995061f, 0.10492096f, 0.08296689f, 0.10151197f, 
    0.13894477f, 0.34188285f, 0.25860283f, 0.29381165f, 0.12660737f, 0.15857027f, 0.00969382f, -0.01928494f, 
    -0.20861569f, -0.26501417f, -0.00972407f, -0.11541285f, -0.15097286f, -0.04589883f, -0.08072147f, -0.20438010f, 
    0.19524299f, 0.16373585f, -0.04360345f, 0.00347377f, -0.00816976f, 0.00729902f, -0.10836206f, 0.03861803f, 
    0.03544381f, 0.08558030f, -0.13584849f, 0.08675787f, 0.12778759f, 0.17297046f, 0.42506990f, 0.02437920f, 
    -0.05434866f, -0.00703856f, -0.05556490f, -0.08267263f, 0.07357589f, 0.11134352f, -0.09371991f, -0.00440718f, 
    -0.61280715f, -0.02894541f, 0.23702803f, -0.22805744f, -0.18262899f, -0.06972503f, -0.25610417f, -0.15162838f, 
    -0.07588325f, -0.03736209f, -0.10360809f, 0.06588982f, 0.30270231f, 0.03257786f, -0.04277041f, 0.24886487f, 
    -0.00197716f, 0.07400286f, -0.01490290f, 0.04393390f, 0.08040277f, 0.17071331f, 0.01875597f, 0.27503550f, 
    0.14502124f, 0.07117063f, 0.02169272f, -0.03351754f, -0.03323408f, 0.16273358f, -0.02711323f, 0.01976294f, 
    0.16569480f, 0.15169790f, 0.20203513f, 0.22905000f, -0.02849155f, -0.08928814f, -0.10796463f, 0.08986747f, 
    -0.01195075f, -0.05285647f, -0.01709439f, 0.11733905f, -0.12953828f, -0.01227760f, -0.07966463f, -0.04213982f, 
    -0.01154462f, 0.42973137f, -0.05432481f, -0.11369679f, 0.10579487f, -0.00066444f, 0.03709380f, -0.01023533f, 
    -0.04770066f, -0.01799290f, 0.07512545f, 0.09841468f, 0.02263439f, -0.05495856f, -0.12754107f, 0.00125084f, 
    -0.10474268f, -0.06301156f, -0.06479163f, 0.00956511f, -0.06232558f, 0.09161794f, 0.04382748f, 0.09246822f, 
    0.11894730f, 0.09729703f, -0.14009000f, 0.39694247f, -0.07925001f, 0.04291067f, 0.20292954f, -0.00518450f, 
    0.18382391f, 0.13827460f, 0.00225886f, 0.28831723f, -0.10666382f, 0.18169536f, -0.09694606f, 0.14431202f, 
    -0.01477389f, 0.05810495f, 0.10235309f, -0.10248699f, -0.05027547f, 0.00917795f, -0.23662832f, -0.25637606f, 
    -0.07971455f, 0.00894155f, 0.00925574f, 0.12275539f, 0.06764929f, 0.12516612f, 0.00493326f, -0.13150641f, 
    0.09591313f, 0.31738836f, 0.05616609f, 0.35856953f, -0.22365744f, -0.12356900f, 0.01306744f, -0.08412413f, 
    0.08434661f, 0.09674528f, -0.16147937f, -0.05706073f, 0.08851028f, -0.24201925f, -0.04067953f, -0.13358407f, 
    0.42956766f, -0.16295974f, 0.31602186f, 0.15041052f, -0.11569772f, -0.09169491f, 0.19375673f, -0.13850196f, 
    0.11738911f, -0.02609578f, 0.04396613f, 0.06864875f, -0.13362980f, -0.17401497f, 0.00150754f, -0.18357548f, 
    -0.07309002f, -0.11480360f, -0.30787447f, -0.13107942f, -0.07387965f, -0.08996110f, 0.01795040f, -0.09355038f, 
    0.28976044f, 0.13826717f, 0.17814401f, -0.16341594f, 0.09216618f, -0.22996157f, -0.17116344f, 0.04248049f, 
    -0.07944429f, 0.12965734f, -0.07393267f, -0.02822962f, 0.07382956f, 0.14826851f, 0.01037688f, 0.01596163f, 
    -0.07821732f, -0.02986732f, 0.04056486f, -0.06255575f, -0.05352024f, -0.04028229f, -0.02887317f, 0.13693964f, 
    -0.19287404f, -0.02913008f, -0.19664451f, -0.07178660f, -0.20049138f, 0.20964655f, 0.02791177f, 0.00059490f, 
    0.03451054f, -0.10167851f, 0.04042676f, 0.04345710f, 0.06386348f, -0.25335154f, 0.17308179f, 0.19719622f, 
    0.05883013f, 0.09024970f, -0.08265921f, 0.02152882f, 0.00725341f, 0.01971454f, 0.05115826f, -0.00162624f, 
    -0.12720397f, -0.03370817f, 0.05029684f, -0.07603496f, -0.08847512f, 0.11131187f, 0.19028164f, -0.00580875f, 
    0.09661323f, 0.15336311f, 0.10763640f, 0.20090994f, 0.25817427f, 0.13883330f, 0.12423963f, 0.19613037f, 
    0.08961966f, 0.14911729f, 0.02726842f, 0.00500442f, -0.09067199f, -0.26923141f, -0.04271664f, 0.06441563f, 
    0.00133443f, -0.28127274f, 0.20349564f, 0.00974387f, 0.14732674f, -0.00784554f, 0.05419710f, -0.22164775f, 
    0.23926069f, -0.15576279f, 0.06521901f, 0.15634188f, 0.13383129f, -0.19393829f, 0.15316145f, 0.06306255f, 
    0.02309565f, -0.06328062f, -0.09206092f, -0.16788989f, -0.06178743f, -0.01765764f, -0.04477521f, 0.09693360f, 
    0.04089562f, -0.13243574f, -0.00792830f, -0.09135590f, -0.00443077f, 0.03718294f, 0.00394353f, -0.08456670f, 
    -0.01072451f, -0.09225482f, -0.00844757f, 0.02537997f, 0.36762220f, 0.00231890f, 0.23422049f, 0.32104182f, 
    -0.01837104f, 0.04858977f, -0.07882188f, -0.03892610f, 0.00301287f, 0.04654675f, 0.02720708f, -0.02871681f, 
    0.25244302f, -0.19388485f, 0.08632943f, -0.03583627f, 0.07054746f, 0.01607929f, -0.14377983f, -0.08554193f, 
    0.11466061f, 0.12247630f, -0.14470977f, 0.30995303f, 0.02004173f, 0.00343525f, 0.20847867f, 0.20884819f, 
    0.06351261f, -0.00807189f, 0.11561254f, -0.20660228f, -0.17470865f, 0.00267378f, -0.14119278f, 0.06169377f, 
    0.03435830f, 0.50933915f, 0.52761167f, 0.36470464f, 0.01054963f, 0.14617425f, 0.26395264f, -0.13709806f, 
    0.11797925f, 0.15754692f, 0.00502942f, 0.13792287f, 0.01805752f, 0.11595103f, -0.19542316f, -0.12250290f, 
    0.03826405f, -0.13643727f, -0.23513573f, -0.01336732f, -0.22664894f, -0.00299868f, 0.08305811f, -0.07598957f, 
    0.55877292f, 0.27576420f, -0.10031622f, 0.13374229f, -0.10462301f, -0.14836664f, 0.08493640f, 0.13455580f, 
    0.07056389f, 0.10406424f, -0.11718351f, -0.07642496f, 0.11006446f, -0.19247302f, -0.32209826f, 0.14125666f, 
    0.01936482f, -0.06924360f, 0.08476332f, 0.30433071f, 0.12293144f, -0.09752391f, -0.07552370f, -0.00302922f, 
    -0.03500818f, 0.03074262f, 0.00438988f, 0.07954227f, -0.08795742f, 0.00423190f, -0.08390395f, -0.09757538f, 
    0.13898520f, 0.23836933f, 0.17409547f, 0.42343175f, -0.28358352f, 0.00276196f, 0.07059322f, 0.12365616f, 
    0.02493512f, -0.07182693f, 0.08627786f, -0.06642704f, -0.39743066f, -0.04640139f, -0.04930913f, -0.26774308f, 
    0.02716726f, -0.15197220f, -0.05990395f, -0.19920929f, 0.02845419f, -0.03793107f, -0.21126807f, -0.16186894f, 
    -0.07434933f, 0.00871390f, -0.17591935f, 0.07338399f, -0.27812016f, -0.10373208f, 0.23976141f, -0.19706522f, 
    -0.01322684f, -0.01648520f, -0.08504186f, 0.26297539f, 0.02002016f, -0.03925959f, -0.17476375f, 0.00098211f, 
    -0.03028994f, -0.04818715f, -0.02796630f, 0.03576054f, 0.01892022f, -0.03777657f, -0.04675998f, 0.01569518f, 
    0.00807114f, -0.04344242f, -0.04483881f, -0.01185539f, 0.02237117f, 0.01457111f, -0.02287287f, 0.00927769f, 
    -0.03685341f, 0.03670335f, -0.00681250f, 0.01251373f, -0.00672964f, -0.05094231f, -0.03698912f, 0.04138509f, 
    -0.05825030f, 0.02462827f, 0.03700865f, -0.04389726f, -0.00995073f, 0.01924678f, 0.02652901f, 0.02117611f, 
    0.02341363f, 0.02510609f, 0.02931867f, 0.01478875f, -0.04348922f, -0.01544817f, 0.02752771f, -0.03825619f, 
    0.00235419f, 0.01715267f, -0.03960861f, -0.04000625f, 0.04182445f, 0.02922102f, 0.03432311f, -0.05860499f, 
    -0.03744447f, -0.00120493f, -0.04482935f, 0.03782810f, 0.00407634f, -0.03520273f, 0.00516507f, -0.00055154f, 
    0.01768355f, 0.01181388f, -0.02610660f, 0.03024648f, -0.00524267f, 0.01355392f, -0.00621518f, -0.02464358f, 
    0.03015841f, 0.04092416f, 0.03358695f, 0.03309010f, -0.04336745f, -0.03924822f, 0.01889037f, 0.00405546f, 
    -0.02404621f, 0.00288674f, -0.00892667f, -0.00566520f, -0.03954628f, -0.03889837f, 0.02941559f, -0.05117003f, 
    0.00231182f, -0.05165068f, -0.01587615f, -0.03298015f, 0.01829130f, -0.01398041f, 0.02643674f, -0.02324953f, 
    -0.02758925f, -0.05468750f, -0.02623792f, 0.04590569f, -0.01457421f, 0.04250158f, 0.03619452f, 0.00284560f, 
    0.03785970f, 0.03261616f, -0.02084484f, 0.00697390f, -0.01454913f, 0.03519554f, 0.01159266f, -0.03024025f, 
    -0.04722963f, 0.00421347f, -0.03967566f, 0.01338109f, -0.01103284f, -0.04185065f, 0.01168229f, -0.03105134f, 
    -0.03523981f, 0.02883693f, -0.03775718f, -0.05446950f, -0.05038527f, -0.02751267f, -0.00690140f, 0.02205231f, 
    0.00128258f, -0.04662530f, -0.04457282f, -0.00757660f, 0.02276578f, -0.05363076f, -0.00315562f, -0.02712580f, 
    0.02100517f, -0.01621120f, -0.04534354f, -0.04587301f, -0.04957358f, 0.05340097f, 0.04248551f, 0.04615993f, 
    0.03514161f, -0.01570401f, 0.02388622f, 0.01504897f, -0.03437470f, -0.03569885f, 0.00618066f, -0.00359124f, 
    -0.04134427f, -0.00473023f, -0.02325778f, -0.04564961f, -0.01262763f, -0.02582346f, -0.02783370f, -0.03780804f, 
    0.02495253f, 0.00814792f, 0.02739949f, 0.02941031f, 0.02214268f, 0.03359869f, -0.05164757f, -0.04132435f, 
    0.03695417f, 0.04661947f, -0.03745973f, 0.03872991f, -0.02344236f, 0.03936278f, 0.01791960f, -0.02083083f, 
    0.03260324f, -0.03789594f, -0.04338520f, 0.00159592f, -0.04233309f, -0.03176305f, -0.01071536f, -0.02410566f, 
    0.01747880f, -0.05540423f, 0.00725265f, -0.00997621f, -0.02891315f, -0.01627864f, 0.03019941f, -0.01378920f, 
    0.03265607f, -0.00241140f, -0.00123345f, -0.00153987f, 0.03764633f, -0.03853890f, 0.02652035f, -0.02074962f, 
    -0.02165843f, 0.00064041f, -0.03174918f, -0.05215191f, 0.01651718f, 0.03491692f, -0.00335443f, -0.04466615f, 
    0.02663692f, -0.02350073f, -0.03664853f, -0.01953304f, -0.02578659f, 0.03058177f, 0.03943265f, -0.02304403f, 
    0.00623069f, -0.03244348f, -0.03322861f, 0.05403303f, 0.03020913f, -0.03908861f, -0.05649708f, -0.03219977f, 
    -0.02039193f, -0.01284621f, -0.00430094f, 0.02457751f, -0.05281743f, -0.00745713f, -0.04919908f, 0.04653740f, 
    -0.01511609f, 0.04207584f, 0.00782470f, -0.05698975f, 0.00799391f, -0.03312567f, 0.00337130f, -0.04226658f, 
    0.00488064f, -0.01641396f, 0.04736956f, 0.00365477f, -0.05576544f, -0.01010988f, 0.01346235f, 0.03892974f, 
    0.01866779f, 0.02812712f, 0.03073126f, 0.03621590f, 0.03499915f, -0.05593506f, 0.01118106f, 0.03868373f, 
    -0.03722338f, 0.00393542f, 0.00019687f, -0.00540368f, -0.02113677f, -0.01233560f, -0.03187202f, 0.03524373f, 
    0.03657268f, 0.03194974f, -0.01996686f, -0.03315530f, -0.05145795f, 0.00184809f, -0.05335924f, 0.03890742f, 
    0.00984590f, -0.04102845f, 0.01051088f, -0.01069310f, -0.03581196f, -0.03073155f, -0.01376202f, 0.01987094f, 
    0.03878979f, 0.03894241f, 0.01028680f, -0.00605830f, 0.02951468f, -0.03003491f, -0.05469364f, -0.02502790f, 
    -0.05320102f, -0.00742814f, 0.03379700f, -0.05341467f, -0.00490276f, 0.00234007f, -0.04989415f, 0.03970079f, 
    -0.05628467f, -0.03918200f, -0.00592233f, 0.04665184f, 0.01226809f, 0.03659077f, -0.00728308f, -0.04225080f, 
    -0.00929582f, -0.05062204f, -0.01124665f, -0.00953937f, -0.01844632f, -0.02106707f, -0.04083955f, -0.00346320f, 
    -0.01811692f, 0.03241107f, -0.00853012f, 0.04153979f, -0.03686626f, -0.02339784f, 0.01829051f, -0.02721633f, 
    -0.00331764f, -0.04734205f, -0.02005965f, -0.00651937f, -0.00874059f, 0.03299222f, 0.02066933f, -0.05267954f, 
    -0.03672301f, -0.03050265f, -0.05319869f, -0.01213241f, 0.01831128f, -0.00303059f, 0.01468752f, 0.01338982f, 
    -0.01649946f, -0.01027816f, -0.04944768f, 0.01737685f, 0.04001876f, -0.00860677f, -0.03356559f, -0.03935225f, 
    -0.04270998f, 0.00792300f, -0.01828658f, -0.03259450f, 0.01982493f, -0.03718114f, -0.00297469f, -0.03060727f, 
    -0.05786363f, -0.01437649f, -0.02185044f, 0.03996402f, 0.03806966f, 0.00314252f, -0.04784025f, 0.03458993f, 
    0.02184850f, -0.01934738f, -0.05194727f, -0.02360777f, -0.04628734f, 0.01719927f, -0.01048501f, -0.00610198f, 
    -0.01476134f, -0.02240102f, 0.02739985f, 0.00341692f, -0.02384484f, 0.01460086f, 0.02678088f, 0.00887759f, 
    -0.00401888f, -0.01674775f, 0.00810513f, -0.00421497f, -0.02184280f, 0.03356620f, 0.01617056f, -0.02520852f, 
    -0.04775709f, 0.02053367f, 0.01976934f, 0.00937303f, 0.00463284f, -0.01388855f, -0.02622769f, -0.03076160f, 
    -0.02513509f, 0.02995488f, -0.03978266f, -0.05007988f, 0.02916760f, -0.00029375f, -0.02682655f, -0.01722429f, 
    -0.05472191f, 0.02585925f, -0.04806929f, -0.01535074f, -0.00430401f, 0.00162902f, -0.02241862f, 0.01113118f, 
    0.00921964f, -0.04445694f, -0.03096167f, -0.01696248f, -0.01410316f, -0.01763886f, -0.02765622f, -0.03998167f, 
    -0.04847292f, -0.02504334f, 0.00126971f, -0.03376809f, 0.04038695f, -0.01198197f, -0.02759651f, 0.02735532f, 
    0.01222104f, 0.01456144f, -0.05542134f, -0.04437603f, -0.05288662f, -0.00765625f, 0.01624551f, -0.03840557f, 
    -0.05489182f, 0.03326220f, -0.01517244f, -0.04230521f, -0.05623809f, -0.04533514f, -0.02721919f, 0.03972722f, 
    0.03221797f, -0.01227436f, 0.00973936f, -0.04164387f, 0.02069687f, 0.03156858f, -0.01804364f, 0.02962225f, 
    -0.04160162f, -0.03324379f, -0.03396848f, 0.04344551f, 0.02928450f, -0.02471161f, 0.02340939f, 0.03263710f, 
    0.03922106f, -0.00507028f, -0.05615430f, 0.00383787f, -0.00355804f, -0.05231468f, -0.01519811f, -0.03854682f, 
    -0.04449398f, -0.04537373f, 0.00747272f, 0.02630655f, -0.02746154f, -0.00138474f, -0.05637654f, -0.02210806f, 
    -0.02023592f, -0.05038503f, 0.00021093f, 0.03888189f, 0.00171600f, -0.03376101f, 0.03708298f, 0.03522454f, 
    -0.01071903f, 0.03572387f, -0.05430816f, 0.01650906f, 0.00356564f, -0.02566971f, -0.03877094f, 0.03515392f, 
    0.03443641f, -0.04243552f, -0.02051861f, -0.04572906f, -0.01483266f, -0.00263703f, -0.04783938f, -0.02800336f, 
    -0.04838339f, -0.04772959f, -0.04306860f, 0.04220747f, 0.02023198f, 0.01875686f, 0.01157441f, -0.04435727f, 
    -0.03964238f, -0.05590971f, 0.03015893f, 0.03488502f, -0.03273149f, -0.00675702f, -0.05592494f, 0.00627475f, 
    0.02642184f, 0.01818896f, 0.02042137f, -0.05198796f, -0.04808871f, -0.03132620f, 0.04186213f, -0.03527205f, 
    -0.00491656f, 0.00974536f, -0.02621794f, -0.05023702f, 0.03432905f, 0.01622178f, -0.00987952f, -0.00363412f, 
    -0.02303083f, 0.00621548f, 0.02575835f, 0.02212454f, -0.00428596f, -0.00009184f, 0.00352281f, -0.00919194f, 
    -0.02256703f, 0.00390813f, 0.03645283f, -0.03201555f, 0.04198271f, -0.04262172f, -0.00840110f, 0.03202252f, 
    -0.00245342f, -0.04033759f, -0.05361024f, -0.04554144f, 0.00952533f, -0.02224266f, -0.01668057f, -0.01841966f, 
    0.03095915f, -0.01002085f, 0.04036345f, -0.01903761f, -0.03156403f, 0.01384806f, 0.01636731f, -0.05071400f, 
    -0.02924318f, 0.02602287f, 0.04262843f, -0.01567604f, -0.04987989f, -0.05424868f, 0.04278583f, 0.03126847f, 
    -0.03699231f, 0.03935333f, -0.01034244f, -0.00931491f, 0.03204436f, 0.00306006f, 0.01629154f, -0.00467781f, 
    -0.01562294f, 0.01276725f, -0.03602523f, -0.02383747f, -0.00733941f, 0.04000340f, 0.00867811f, -0.02409089f, 
    -0.02109961f, 0.00228578f, 0.00830184f, 0.02476111f, -0.01126416f, 0.02409098f, -0.02263206f, 0.01545378f, 
    -0.01957688f, -0.00473645f, -0.00920385f, 0.03200639f, 0.00254196f, -0.04474965f, -0.02044542f, 0.00536568f, 
    -0.02330102f, -0.02858621f, 0.01908953f, -0.04378041f, -0.04720116f, -0.01411546f, -0.02444283f, 0.02097006f, 
    -0.00549370f, 0.03691858f, -0.04834097f, -0.01212020f, -0.02283916f, -0.03944328f, -0.00448384f, -0.04593309f, 
    -0.01136012f, -0.05021000f, 0.03361015f, -0.00380939f, 0.00938014f, -0.01351428f, -0.03726725f, -0.04525916f, 
    0.04274728f, 0.01190641f, -0.04776160f, -0.02312894f, 0.03254141f, -0.03391476f, -0.00490918f, -0.01255848f, 
    -0.02507195f, -0.02315416f, -0.04375615f, -0.03491383f, -0.02522741f, 0.01515542f, 0.04379477f, 0.00319938f, 
    -0.03384229f, 0.00462223f, -0.05472938f, 0.01737118f, -0.04043127f, 0.04492369f, -0.02774424f, -0.05285128f, 
    -0.03563586f, -0.00523170f, -0.00297007f, 0.02883605f, -0.05310600f, 0.01208628f, -0.03024956f, -0.02096471f, 
    -0.02084301f, -0.05127490f, -0.02446141f, -0.01854948f, 0.03052649f, -0.05031003f, 0.03093330f, 0.00716667f, 
    -0.00399235f, 0.00434780f, 0.01869187f, 0.00176091f, -0.03442355f, -0.05230434f, 0.00449406f, 0.01069924f, 
    -0.01661068f, -0.02777130f, -0.00051976f, -0.00542473f, 0.01847070f, 0.01113743f, -0.03585283f, -0.00341334f, 
    -0.01217738f, 0.01769498f, 0.05477154f, 0.04022390f, -0.01686586f, -0.02113130f, -0.02406201f, 0.03856141f, 
    0.01292948f, 0.00508859f, 0.02318418f, -0.01407357f, 0.03750410f, -0.02927283f, 0.03433444f, 0.01415402f, 
    -0.01619394f, -0.00074545f, -0.01910526f, 0.01151763f, -0.00370447f, 0.04214555f, -0.01333035f, 0.00555289f, 
    0.03469937f, 0.00988342f, 0.00943981f, -0.02750700f, -0.03795961f, -0.01810467f, 0.00348711f, -0.02563200f, 
    0.01815896f, -0.04095511f, -0.01901220f, 0.03556150f, -0.02294165f, 0.03522162f, 0.04338291f, 0.03359555f, 
    -0.04654425f, -0.05135366f, 0.04354675f, -0.02107820f, -0.02584589f, 0.01982622f, -0.00397132f, -0.02901863f, 
    -0.01598303f, -0.02746034f, 0.03280181f, 0.02353894f, 0.03247676f, -0.03586126f, -0.01292028f, 0.00954739f, 
    -0.00080703f, 0.03811239f, 0.03931294f, 0.03062742f, -0.01148304f, 0.04071774f, 0.00779436f, 0.00104538f, 
    -0.05433187f, 0.03302858f, 0.01711683f, 0.04386244f, -0.01945456f, 0.04427725f, 0.00263310f, -0.02621958f, 
    0.00588040f, 0.01338960f, 0.02247616f, -0.01141894f, -0.02044398f, -0.02099420f, -0.00009298f, -0.01524291f, 
    0.02631020f, -0.03845965f, -0.03674889f, -0.01228327f, -0.04335479f, 0.04145453f, -0.01314867f, -0.04330720f, 
    0.00763333f, 0.02639384f, 0.01288440f, -0.02099629f, 0.01706326f, -0.04385890f, -0.03612899f, -0.02209323f, 
    -0.45856953f, -0.14135578f, -0.05625595f, 0.02437575f, -0.06161388f, -0.01000881f, -0.09740099f, -0.08056438f, 
    -0.07569584f, 0.10171437f, 0.06035959f, 0.07270943f, -0.10011230f, 0.13899282f, 0.15549853f, 0.46521547f, 
    0.02612366f, 0.12622736f, 0.06620128f, 0.06576706f, 0.08313560f, -0.03716245f, 0.09237676f, 0.14306720f, 
    -0.23934704f, 0.21099809f, 0.10268503f, 0.14245708f, -0.01770739f, 0.01907436f, -0.07953800f, 0.17757519f, 
    0.04617798f, 0.08906296f, -0.03465169f, 0.03473727f, 0.33900672f, 0.14042592f, -0.05604137f, 0.04264648f, 
    -0.03980367f, -0.04784856f, 0.05140444f, 0.23021401f, 0.02451884f, 0.06930178f, 0.03220273f, 0.02875314f, 
    -0.02995858f, 0.13899028f, 0.03078927f, 0.09007972f, 0.00831641f, -0.05887136f, 0.08499318f, 0.14794391f, 
    0.09450858f, 0.07518052f, 0.00679315f, 0.07196416f, 0.00436528f, 0.08837059f, -0.04894796f, 0.00569897f, 
    0.02112441f, 0.12409499f, -0.13393596f, 0.23048791f, -0.16715243f, 0.09242955f, 0.02433219f, 0.08708568f, 
    0.00668577f, 0.19210301f, 0.17509916f, 0.22295827f, 0.24115591f, 0.15114635f, 0.06794129f, -0.14654419f, 
    -0.04515259f, 0.01480180f, -0.05676875f, 0.26047921f, -0.25210699f, 0.05521137f, -0.00065044f, 0.04719532f, 
    0.03463788f, 0.05663859f, 0.08490174f, -0.08667029f, -0.13943328f, -0.04543248f, -0.08823358f, -0.23177929f, 
    -0.03914145f, 0.12515679f, 0.05336246f, 0.03080076f, 0.01105714f, -0.05907156f, -0.03783517f, 0.05842320f, 
    0.03851787f, 0.22174008f, -0.02166746f, 0.22345880f, 0.07694554f, -0.04038060f, 0.09267517f, 0.13973649f, 
    0.04272702f, 0.03759872f, 0.01006577f, -0.11849473f, 0.08896213f, 0.01776442f, 0.00524647f, -0.07172736f, 
    0.36554235f, 0.39133096f, 0.05559168f, -0.04804671f, 0.07841428f, 0.02192127f, -0.08894156f, -0.04194297f, 
    -0.04657646f, 0.02668271f, -0.05663209f, 0.02033328f, -0.04774457f, -0.48778096f, -0.37353498f, 0.03196007f, 
    -0.12581021f, -0.15613298f, -0.00899912f, -0.09479902f, 0.07454779f, 0.02058011f, -0.00260845f, 0.04360060f, 
    -0.07766529f, -0.06121425f, -0.21029401f, -0.16776992f, 0.04869807f, -0.10351562f, 0.07859971f, -0.09513251f, 
    0.07341309f, 0.04058557f, -0.06506322f, -0.13984834f, 0.08313123f, 0.26558074f, 0.01995974f, -0.01184820f, 
    -0.07031681f, -0.14996390f, -0.04638712f, -0.03035961f, -0.00648269f, -0.12461702f, -0.12386847f, 0.00542638f, 
    -0.02843587f, 0.07772663f, -0.05137652f, -0.10494082f, -0.11824137f, -0.21127936f, -0.10863124f, 0.12308574f, 
    -0.09195867f, 0.04312144f, -0.14355691f, -0.12707642f, 0.46987218f, 0.03420800f, 0.26928988f, 0.25651094f, 
    0.20171939f, 0.09286392f, 0.05586953f, 0.05835306f, -0.00275536f, 0.01220618f, -0.02832411f, -0.07927568f, 
    -0.11448612f, 0.05651898f, -0.02839788f, -0.04947124f, 0.01449813f, -0.01446369f, 0.04327923f, 0.20663168f, 
    -0.02108683f, 0.02367249f, 0.05210250f, 0.12471340f, 0.37484315f, 0.37926039f, 0.40435573f, 0.28657496f, 
    0.09584360f, 0.01359437f, 0.04450898f, -0.14046861f, -0.07438108f, -0.12206243f, -0.03442832f, 0.02306242f, 
    0.09115733f, 0.10109840f, 0.29442459f, -0.00164361f, 0.12331170f, 0.10037048f, -0.27145693f, -0.04855011f, 
    0.05902430f, -0.04126266f, -0.01669055f, 0.07135534f, -0.03579161f, -0.34847122f, -0.07722399f, -0.01007376f, 
    0.02345722f, 0.08113243f, -0.10323624f, -0.05833864f, 0.03088243f, 0.02780618f, 0.03337635f, 0.01711087f, 
    -0.05041118f, -0.05462403f, 0.04690912f, -0.01347645f, -0.12330988f, 0.10551337f, -0.00559703f, 0.11110967f, 
    -0.03231036f, -0.01523426f, 0.04502659f, -0.02253472f, 0.41144577f, 0.20282324f, 0.10714223f, 0.14152357f, 
    -0.07531901f, 0.09407151f, 0.03066637f, 0.19187023f, -0.04685245f, -0.05801602f, -0.04012274f, 0.04013979f, 
    0.26916358f, -0.12071273f, -0.05380736f, -0.02092988f, -0.01777073f, -0.04640061f, 0.05742709f, -0.09626988f, 
    0.08548147f, -0.06813715f, -0.01640152f, 0.36593568f, 0.10288459f, 0.11778440f, 0.19197026f, 0.13240622f, 
    0.07258476f, -0.06994782f, 0.05855424f, -0.04461408f, -0.05559346f, 0.03830012f, -0.04867020f, -0.00696128f, 
    0.15094355f, 0.32358211f, 0.37033585f, 0.37479988f, 0.03072452f, -0.09020655f, 0.11861686f, -0.00437827f, 
    0.00815203f, 0.13132940f, -0.09657916f, 0.03772534f, -0.34516212f, -0.15852585f, -0.20274557f, -0.03193457f, 
    -0.18205310f, -0.00959478f, -0.05938665f, -0.12771074f, -0.07967054f, -0.06967644f, 0.05858176f, -0.15774581f, 
    0.15549783f, 0.39530557f, 0.14251713f, 0.20599432f, 0.15024041f, -0.12586665f, -0.02239137f, 0.02536529f, 
    -0.08892484f, 0.08714174f, -0.03880619f, -0.11206173f, 0.21971484f, -0.43203759f, 0.06094115f, 0.28080827f, 
    0.07371452f, -0.08435307f, 0.03461864f, 0.13601314f, -0.11140409f, 0.15821840f, 0.04728506f, -0.13574174f, 
    -0.10781644f, 0.08614634f, -0.01941708f, -0.01451489f, -0.03801220f, -0.04172267f, -0.05351920f, -0.12588556f, 
    0.09338896f, 0.13105990f, 0.00527041f, 0.37618646f, -0.19733010f, 0.04066321f, 0.13645180f, 0.19339913f, 
    0.08409769f, 0.02225146f, 0.06242437f, -0.05088889f, -0.24677752f, -0.10313492f, 0.04704170f, -0.17991911f, 
    -0.32686114f, -0.32329684f, -0.06244541f, -0.03113983f, -0.00225311f, 0.05050540f, -0.04004874f, -0.12628712f, 
    -0.13277052f, -0.00360149f, 0.02020754f, -0.05836977f, -0.30019066f, -0.27522305f, -0.20505297f, -0.01094269f, 
    -0.14411978f, 0.07968632f, 0.12503797f, 0.13024284f, -0.01324394f, -0.15479350f, -0.03469332f, -0.06549844f, 
    0.12348732f, -0.19626302f, -0.11636439f, -0.08532980f, -0.12692252f, -0.08188153f, -0.10846796f, -0.05760489f, 
    0.11964816f, 0.01865918f, 0.10875276f, -0.08123770f, -0.15003106f, -0.14187296f, 0.17375766f, 0.05332660f, 
    -0.03786661f, 0.04499293f, -0.00764907f, 0.05361614f, 0.11639245f, -0.12957655f, 0.03305333f, 0.34783399f, 
    -0.21385491f, -0.14952289f, 0.07964072f, 0.14357585f, -0.16532080f, -0.03200223f, -0.10910683f, 0.03382428f, 
    -0.11291023f, -0.11880867f, -0.16395509f, 0.29603660f, 0.11310614f, 0.38411441f, 0.31474915f, 0.30953908f, 
    0.21884266f, 0.13604316f, 0.04037836f, 0.07126494f, 0.00217037f, -0.06084247f, -0.04645725f, -0.06291072f, 
    0.10433452f, 0.25809482f, 0.13206913f, 0.37748176f, 0.25457641f, 0.20430659f, 0.09351672f, 0.22460219f, 
    0.12911926f, -0.05080109f, 0.02382187f, 0.05818734f, -0.07733527f, 0.11296743f, 0.35774529f, 0.11801227f, 
    0.06498079f, 0.15856802f, -0.03275007f, 0.14414428f, -0.03492042f, 0.00933448f, 0.09628161f, 0.17918816f, 
    -0.15705860f, 0.00845976f, 0.14729875f, 0.28385279f, 0.05772507f, 0.08682952f, 0.12534502f, 0.04980143f, 
    0.03164497f, 0.01084158f, -0.02011262f, 0.31152654f, 0.00459349f, -0.08892890f, 0.10125561f, -0.01399613f, 
    0.01984425f, 0.04112873f, -0.07000640f, 0.06919321f, -0.13086863f, -0.07480045f, -0.24354318f, -0.36091742f, 
    0.18363866f, -0.07678092f, 0.05041027f, 0.02390905f, 0.02486425f, 0.10704040f, -0.09615910f, -0.18564650f, 
    0.21316680f, 0.06453360f, 0.12006922f, 0.13889001f, 0.07916846f, 0.44405398f, 0.22589236f, 0.31900677f, 
    0.19080989f, 0.20358373f, 0.04889853f, 0.14845519f, -0.00252432f, -0.05956104f, -0.09214136f, -0.13483711f, 
    0.27145612f, -0.14965017f, 0.00571455f, 0.01951081f, 0.08177498f, -0.08134879f, -0.02468674f, -0.09624299f, 
    0.13116217f, 0.04482612f, -0.02632575f, -0.10022444f, 0.24962789f, -0.23371081f, -0.33634183f, 0.09705296f, 
    -0.03894800f, 0.11885116f, -0.01756123f, -0.04101338f, 0.22505923f, -0.06660987f, 0.02988506f, -0.14061229f, 
    0.54470950f, 0.10718174f, -0.41521704f, -0.18648563f, 0.07833680f, -0.03620214f, 0.04284912f, -0.07040528f, 
    0.11866987f, 0.08195686f, 0.04164433f, 0.00855624f, 0.16208921f, -0.15627667f, 0.08505850f, -0.13963483f, 
    -0.03499527f, 0.05058545f, -0.04681627f, 0.01587084f, 0.03527884f, 0.02415843f, -0.00597485f, 0.01274647f, 
    0.20165764f, -0.17273231f, -0.15100433f, -0.34289896f, 0.01695819f, 0.00438785f, 0.16596252f, -0.02289077f, 
    0.02617696f, -0.09781375f, -0.16178878f, -0.17622873f, -0.20016815f, 0.00657366f, -0.09207743f, 0.01158331f, 
    0.11948992f, -0.10346716f, -0.08160858f, 0.05827489f, 0.00536559f, -0.04808177f, -0.00056782f, 0.15046182f, 
    0.05231840f, 0.19340003f, 0.20761058f, 0.13213286f, -0.00971252f, 0.09486859f, 0.07295263f, 0.07091347f, 
    0.09891739f, -0.00007496f, 0.17492165f, 0.19047755f, 0.16757867f, 0.01622391f, 0.06028173f, -0.02441330f, 
    0.01509693f, -0.02636515f, -0.05472141f, 0.04668198f, -0.08477147f, 0.01912644f, -0.02366245f, -0.11355597f, 
    -0.18546270f, 0.07938682f, 0.23832351f, 0.02296312f, 0.02874114f, -0.14232595f, -0.14441305f, 0.01450360f, 
    0.08744208f, 0.03752580f, 0.02806036f, 0.07472956f, 0.07460350f, -0.21450225f, -0.06897946f, 0.07551280f, 
    0.21060717f, -0.08990744f, -0.13593595f, 0.02341399f, 0.06175527f, 0.02565573f, -0.04417262f, 0.09481316f, 
    -0.26811394f, 0.06423878f, 0.17425972f, -0.03010907f, 0.04288366f, -0.03320290f, -0.02635330f, 0.03785303f, 
    -0.01838462f, 0.00975752f, 0.02316603f, 0.07095309f, 0.16026916f, 0.23562540f, 0.18770137f, 0.25654635f, 
    0.23100671f, 0.13189033f, -0.03249962f, 0.02544352f, 0.05314829f, 0.04155999f, 0.02486869f, 0.00525881f, 
    -0.00878851f, -0.03884508f, -0.16902819f, 0.01006746f, 0.01755230f, -0.05458779f, -0.03184714f, 0.01353334f, 
    0.11899273f, -0.09101753f, 0.12902910f, 0.27807283f, -0.00149457f, 0.14757347f, 0.07159463f, 0.11927285f, 
    0.06481066f, -0.01625885f, 0.03943023f, -0.09886320f, -0.06601579f, 0.02065654f, -0.01392421f, -0.03923251f, 
    0.10031724f, 0.32349187f, 0.46935737f, 0.11870003f, 0.20982984f, 0.11895931f, 0.10990506f, -0.10915240f, 
    0.07635657f, -0.05323942f, 0.06531177f, 0.16704287f, -0.09969962f, -0.16395420f, -0.24741893f, 0.06079355f, 
    0.11657871f, -0.10394337f, -0.10308141f, -0.11538532f, 0.02270556f, 0.00845521f, 0.07293924f, 0.02451532f, 
    0.14585873f, -0.03312552f, 0.00083318f, 0.02264080f, 0.05284238f, -0.00896995f, -0.00847658f, 0.07445434f, 
    0.09549689f, 0.14175040f, -0.10310620f, -0.06089818f, 0.21731442f, -0.11408742f, -0.07762112f, -0.16476658f, 
    0.02882581f, -0.07192120f, 0.07337357f, 0.16113999f, -0.01098087f, -0.02980733f, -0.06320932f, 0.11426813f, 
    0.12878731f, -0.11148678f, -0.00211385f, 0.11253984f, -0.03121749f, 0.08825504f, 0.01350466f, -0.07800847f, 
    0.21677823f, 0.04689615f, 0.05965585f, 0.22807764f, -0.12288651f, 0.00999258f, 0.09991106f, 0.06776479f, 
    0.12172406f, 0.06778749f, 0.02965382f, 0.02128304f, -0.26833567f, -0.24104248f, -0.15750308f, -0.21041651f, 
    -0.08269155f, -0.23935944f, 0.00342899f, 0.00728877f, -0.00736091f, -0.01508314f, -0.13753448f, -0.05749680f, 
    0.02282148f, 0.01763343f, -0.23334445f, -0.03684936f, 0.15469222f, -0.16811128f, 0.11664385f, -0.13501510f, 
    0.06010714f, -0.04263809f, 0.01400472f, 0.15296842f, -0.01092603f, -0.02190219f, -0.08364005f, -0.12884447f, 
    0.36286214f, 0.12133415f, 0.23788010f, -0.06017827f, 0.06167709f, -0.09581767f, 0.18717881f, -0.03079496f, 
    0.21028362f, 0.05441177f, 0.13015558f, 0.09250893f, -0.33321464f, -0.24704611f, -0.02457358f, 0.31810787f, 
    0.17025171f, -0.04364476f, -0.17729338f, -0.13822599f, -0.00135672f, -0.18612254f, 0.12154859f, 0.13142389f, 
    -0.21452548f, 0.00420153f, -0.12068519f, 0.30593506f, 0.06780343f, -0.13787226f, 0.04230868f, 0.00370629f, 
    0.20716195f, 0.11573887f, 0.39812112f, 0.30526987f, -0.04437592f, 0.05100062f, 0.28963748f, 0.11881813f, 
    -0.08155221f, -0.01261108f, 0.01580514f, 0.08204197f, -0.02402818f, -0.09385040f, -0.11043302f, -0.09239275f, 
    -0.24816987f, -0.13864692f, 0.13101462f, 0.02710726f, -0.01742918f, -0.09462459f, 0.08182515f, 0.03910654f, 
    0.05643906f, 0.03014168f, 0.03368280f, -0.04151670f, -0.23197559f, -0.18939006f, 0.00146494f, 0.19356152f, 
    -0.02339134f, 0.00256998f, 0.05245896f, 0.22449510f, 0.04166514f, 0.10542910f, 0.15918495f, 0.16736519f, 
    -0.10813296f, 0.01478824f, 0.03607742f, -0.07094184f, -0.05916582f, -0.15908191f, -0.06884400f, -0.25044638f, 
    0.28610438f, 0.09347037f, 0.17279102f, 0.18714869f, 0.10566989f, -0.20186548f, -0.03890957f, 0.16466989f, 
    0.11206347f, 0.01985287f, -0.02386720f, 0.01744238f, -0.11130456f, -0.10977935f, -0.11265621f, -0.17941979f, 
    0.11157089f, -0.13870715f, 0.16882253f, 0.04192599f, 0.03208660f, 0.05454596f, -0.06449775f, -0.18780145f, 
    0.03129540f, 0.02230854f, -0.08793105f, 0.03392208f, 0.13594484f, 0.33658460f, 0.23494299f, 0.01444084f, 
    0.06041126f, 0.05320622f, -0.07205551f, 0.12829167f, -0.09851505f, -0.11111309f, -0.08826125f, -0.04968239f, 
    0.10924026f, -0.16067231f, 0.20255654f, 0.00499928f, -0.07768643f, -0.03054473f, 0.07063575f, 0.06319710f, 
    -0.12100907f, -0.04240257f, 0.22527707f, 0.17288031f, 0.36145324f, -0.12381464f, 0.15748949f, -0.37519732f, 
    -0.04684993f, -0.07763577f, 0.05417956f, -0.09303796f, 0.03453982f, 0.00363773f, -0.03401150f, -0.14459707f, 
    0.32625762f, 0.24028845f, -0.08149277f, -0.39100572f, -0.09103793f, -0.03515003f, 0.05759366f, 0.11982772f, 
    0.06688251f, 0.22997177f, -0.07600779f, 0.23284765f, 0.02245335f, -0.18985061f, 0.18118145f, 0.01767289f, 
    -0.01404171f, -0.06552092f, 0.05562417f, 0.11494645f, 0.14354873f, 0.15738560f, 0.18388730f, -0.04900795f, 
    0.33872026f, -0.29629087f, -0.16302475f, -0.05554584f, 0.02840687f, 0.09802972f, -0.08663332f, -0.00897934f, 
    0.05618994f, -0.15708612f, 0.09429600f, -0.02097721f, 0.09947572f, 0.15554804f, -0.07751413f, -0.05063514f, 
    0.22918651f, -0.12728925f, -0.02386139f, 0.00587426f, 0.07946028f, -0.07518929f, 0.03403667f, 0.10616245f, 
    -0.21237552f, 0.06629250f, 0.07768694f, 0.08379953f, -0.05653447f, -0.09993707f, 0.01641405f, 0.08087981f, 
    0.21654646f, 0.23848972f, 0.16819023f, -0.08533967f, -0.03812213f, -0.02992648f, 0.08407730f, 0.18607427f, 
    0.08913307f, -0.18410395f, -0.01893363f, 0.00512493f, -0.07468118f, -0.15808275f, 0.08577405f, -0.07142218f, 
    -0.28269595f, -0.05265544f, 0.04737750f, 0.14956327f, -0.23433495f, -0.04791328f, -0.21836817f, 0.11092643f, 
    0.12646462f, -0.01171130f, -0.03359145f, 0.16182317f, 0.08631480f, -0.03352955f, -0.07206884f, 0.05233267f, 
    0.07242393f, 0.12529190f, -0.00351846f, -0.00743561f, 0.10427650f, 0.14375624f, -0.05181921f, -0.05501422f, 
    -0.26492319f, -0.06831501f, 0.16250747f, 0.08761431f, -0.23512194f, -0.08397544f, -0.15040031f, -0.05212609f, 
    0.07322192f, 0.03236903f, -0.03879790f, 0.00023078f, -0.22739744f, 0.07632501f, 0.12854908f, 0.22066705f, 
    -0.03959130f, -0.10923849f, -0.00529463f, -0.01647772f, 0.24945325f, 0.08195483f, 0.09455840f, -0.07726449f, 
    -0.01926958f, 0.15853758f, -0.02489898f, -0.26009634f, 0.01095303f, 0.09656876f, -0.03180218f, -0.12062081f, 
    0.27707833f, 0.17291395f, 0.12246670f, 0.11892777f, -0.06348275f, 0.03585852f, 0.26895431f, -0.02863416f, 
    0.01316897f, -0.17247388f, -0.07635551f, -0.05590718f, -0.11050830f, 0.00107491f, -0.01493058f, -0.04808909f, 
    0.14719541f, 0.08131330f, 0.36369857f, -0.05880382f, -0.21295887f, -0.24940851f, -0.06897146f, -0.25804588f, 
    0.01164651f, 0.05263600f, 0.07697699f, 0.06616606f, 0.38763630f, -0.06408729f, -0.04433759f, 0.04147831f, 
    -0.00012450f, -0.02909919f, 0.07461886f, 0.00512714f, 0.00055933f, -0.01172976f, 0.17045182f, 0.34265801f, 
    -0.19787265f, -0.13980654f, 0.13890427f, 0.26266369f, 0.06679960f, -0.08693413f, -0.11430280f, 0.03337358f, 
    0.10268951f, -0.01840283f, 0.13163118f, 0.28344348f, -0.06434707f, -0.00446136f, 0.20103937f, -0.23754245f, 
    0.15117627f, 0.15198791f, -0.01386761f, -0.00345890f, 0.12948497f, -0.08386413f, -0.08816569f, 0.02375090f, 
    0.24487776f, 0.18281204f, 0.02780361f, -0.13968158f, 0.04611115f, 0.09505545f, -0.00104708f, -0.10055724f, 
    0.19501266f, 0.18938470f, 0.16578731f, 0.09133963f, 0.08434254f, -0.13611440f, 0.04718334f, 0.12488849f, 
    0.21902044f, -0.00330629f, -0.10145438f, 0.02282881f, -0.11220098f, -0.17796850f, -0.06040601f, -0.31363770f, 
    0.35888726f, 0.03943774f, 0.15250552f, 0.22296628f, -0.00650663f, -0.05407723f, -0.10382213f, -0.06892829f, 
    0.01228820f, -0.05539421f, -0.10852594f, 0.04320192f, 0.29425532f, 0.06102917f, 0.21815094f, 0.27146912f, 
    0.05207225f, -0.04473682f, 0.01551118f, -0.06791292f, -0.06541626f, 0.13653886f, -0.09648424f, -0.17856982f, 
    0.01134562f, 0.03368997f, 0.00542404f, -0.02786409f, -0.02287589f, 0.03084999f, 0.00600263f, -0.01631114f, 
    -0.05983273f, -0.00931718f, -0.04006675f, 0.01706066f, -0.00345791f, -0.05606802f, 0.02569196f, -0.04414120f, 
    -0.05764038f, -0.04697433f, -0.04819250f, 0.03815730f, -0.03383817f, -0.03337889f, -0.03714474f, -0.03356611f, 
    0.01917291f, -0.04402259f, 0.03605578f, -0.02168905f, -0.00310295f, -0.04482197f, -0.03648103f, 0.00451809f, 
    0.01279281f, -0.00537901f, -0.04521743f, -0.04052969f, 0.01260241f, -0.03101556f, -0.02542065f, 0.00018744f, 
    0.02102735f, -0.00905904f, -0.01062493f, -0.01978406f, -0.02670207f, -0.04784985f, 0.00611228f, -0.02279153f, 
    0.02058668f, 0.02947338f, 0.02837987f, 0.02240873f, 0.02666685f, -0.00381283f, -0.03015020f, -0.05351404f, 
    0.00689079f, -0.01437016f, 0.02501222f, -0.04130100f, 0.01821529f, 0.00166084f, 0.03259954f, -0.03125743f, 
    -0.04609887f, -0.02817674f, -0.00041589f, -0.00092963f, -0.03229538f, 0.00611684f, 0.01427282f, -0.03420527f, 
    0.01306101f, -0.05547098f, -0.00218662f, -0.00575681f, 0.02613873f, -0.03774609f, 0.04102217f, 0.02539242f, 
    -0.03060581f, 0.03752951f, -0.00059858f, 0.02494684f, -0.00277637f, 0.03300276f, -0.00887034f, -0.03567085f, 
    -0.01947751f, -0.05897140f, -0.02174648f, 0.02837616f, -0.04148887f, -0.03485669f, -0.01060512f, -0.00751943f, 
    0.00671502f, 0.01380884f, -0.03131917f, 0.03495068f, 0.00020866f, -0.05526075f, -0.03518093f, -0.02080153f, 
    -0.02834215f, 0.00324612f, -0.02666249f, -0.00578481f, -0.00566476f, 0.00379618f, -0.01039452f, -0.05475488f, 
    -0.05092169f, -0.03661721f, 0.01500598f, -0.01293683f, -0.01023760f, -0.03794067f, -0.05061828f, -0.04846345f, 
    0.03042492f, -0.01092603f, -0.01609020f, 0.02423042f, -0.00950472f, -0.04347084f, -0.05286151f, -0.05260742f, 
    0.00197334f, -0.05320672f, -0.00427584f, 0.01653198f, 0.02382503f, -0.05251214f, -0.00303523f, -0.01761757f, 
    -0.04988226f, -0.01679468f, 0.00317747f, 0.03424331f, 0.02735070f, 0.00189711f, 0.02216681f, -0.03523903f, 
    0.01399114f, -0.04379945f, -0.03252551f, 0.00799659f, 0.01608791f, 0.01102611f, -0.03099573f, -0.02757198f, 
    0.01697843f, -0.05413045f, 0.01201591f, -0.01885363f, -0.00412228f, -0.01545400f, -0.00113908f, -0.05528190f, 
    -0.01322932f, 0.03592546f, 0.00991799f, 0.03277527f, 0.00255195f, 0.01276123f, 0.01431612f, 0.01417851f, 
    0.01874787f, -0.03335667f, -0.02211205f, 0.00521191f, -0.00678798f, 0.03716549f, -0.02444392f, -0.04406612f, 
    -0.03377610f, -0.05147993f, 0.02348225f, 0.00699597f, 0.02835017f, -0.01078149f, -0.04419649f, 0.02806655f, 
    -0.04048645f, 0.00363503f, 0.02647927f, -0.00055591f, 0.02234968f, -0.00713533f, 0.00784001f, -0.03137316f, 
    0.02764444f, -0.03837061f, 0.01940333f, 0.02844980f, 0.01003210f, 0.03981699f, -0.05392246f, -0.04676630f, 
    -0.01216405f, -0.00520456f, 0.00921823f, -0.05820470f, -0.00307903f, -0.05075305f, 0.03227605f, -0.04358497f, 
    -0.04847858f, 0.01135199f, 0.00848050f, 0.03053204f, -0.01474866f, -0.01678726f, -0.00277437f, -0.03225087f, 
    -0.00475201f, -0.01334473f, -0.01923017f, -0.03301610f, 0.03853087f, -0.04884961f, -0.02007494f, -0.05486711f, 
    0.02149693f, -0.05190993f, 0.04278659f, 0.01974668f, 0.03399093f, 0.01373597f, 0.01784000f, -0.03586501f, 
    -0.02563496f, -0.01082769f, -0.02089230f, 0.01886665f, 0.02194733f, 0.01597675f, -0.02836206f, -0.02292167f, 
    0.01712519f, -0.00612148f, -0.02032308f, 0.00251404f, -0.03527524f, -0.05853622f, 0.00975336f, -0.00833249f, 
    -0.02461780f, 0.00073370f, -0.05805109f, 0.03768180f, -0.06010575f, -0.00949634f, -0.03109747f, -0.03383963f, 
    -0.06024416f, 0.00457287f, -0.00019459f, 0.01890141f, -0.02100160f, 0.01954476f, -0.01768212f, -0.01680362f, 
    0.01545696f, 0.03754635f, -0.04914799f, -0.03118088f, -0.03851597f, 0.03453900f, -0.00186455f, -0.03591961f, 
    -0.01087178f, -0.00469275f, 0.00355678f, 0.00364825f, 0.03022355f, -0.02397630f, 0.01404701f, -0.02071791f, 
    0.00711473f, -0.00528746f, -0.00480646f, -0.02393667f, 0.02750731f, 0.00277752f, -0.04730509f, -0.01057534f, 
    -0.05262274f, -0.00641242f, -0.02359514f, 0.00400501f, -0.04442496f, 0.00047386f, -0.03232075f, -0.04343091f, 
    0.01988009f, -0.03952891f, -0.00211201f, -0.04476115f, 0.00568879f, 0.02604700f, -0.02901742f, -0.00799988f, 
    -0.05175411f, 0.00239416f, 0.00079518f, 0.00023537f, -0.02233944f, -0.00599863f, 0.01647716f, -0.02953361f, 
    0.01537480f, -0.01954359f, -0.02426681f, 0.01802210f, -0.01722136f, -0.03216813f, 0.03692562f, 0.03230122f, 
    -0.05826643f, 0.03627607f, 0.00640960f, 0.00745561f, -0.00902336f, -0.03302306f, 0.03656486f, 0.02965344f, 
    0.03365282f, -0.02472707f, 0.02288183f, -0.00742912f, 0.01808325f, -0.02431271f, -0.02475058f, 0.02075063f, 
    -0.04503028f, -0.00735455f, -0.03247971f, 0.03398307f, -0.04521641f, -0.03319843f, 0.00854795f, -0.00104621f, 
    -0.06035936f, -0.01257301f, 0.02245759f, 0.01099937f, 0.00967759f, 0.00922095f, 0.03607748f, -0.00767419f, 
    -0.04116478f, -0.00653564f, -0.00552433f, 0.02193880f, 0.00394973f, 0.00602904f, -0.01010703f, -0.00733333f, 
    0.04040598f, -0.00606376f, -0.04898803f, -0.05011602f, -0.02015165f, -0.01555661f, -0.05229756f, 0.04116518f, 
    -0.00793358f, -0.01901735f, 0.02361451f, 0.01775856f, 0.00446592f, -0.03606055f, -0.04645399f, 0.01716317f, 
    0.03800901f, 0.01068257f, 0.01338298f, -0.05587843f, 0.02073149f, -0.02490885f, 0.02977285f, -0.00715171f, 
    0.03418783f, -0.02255144f, 0.01893503f, -0.01760327f, -0.03538663f, -0.00258587f, -0.01206396f, 0.03204840f, 
    0.03446851f, -0.02458944f, -0.01821134f, -0.04243440f, 0.03558137f, -0.01151296f, -0.05701601f, -0.02696010f, 
    -0.01656140f, 0.01616193f, 0.03552707f, 0.01370110f, -0.01909329f, -0.03180747f, -0.05054110f, 0.01842484f, 
    0.03875059f, -0.02013659f, 0.00474287f, 0.02644006f, -0.05215694f, 0.02007579f, -0.02844574f, -0.03590788f, 
    0.01873229f, 0.02241013f, 0.02174634f, 0.03939348f, -0.02477844f, 0.03693709f, -0.00863505f, -0.03763224f, 
    0.04617862f, -0.00498512f, 0.01317296f, 0.03308623f, -0.00058757f, -0.03431645f, -0.00762813f, -0.04321234f, 
    0.03817608f, -0.01312287f, 0.03474792f, 0.02194267f, -0.04509481f, -0.01412425f, -0.03520668f, -0.01209458f, 
    -0.00548041f, 0.01444127f, -0.01049606f, 0.04351791f, -0.00555806f, 0.00344160f, 0.01945642f, -0.05049957f, 
    -0.01529519f, 0.00824507f, 0.03382328f, 0.04249458f, -0.03236212f, -0.02954413f, -0.00242134f, -0.04808009f, 
    -0.03128529f, -0.00429610f, -0.02306747f, -0.03630570f, -0.02506277f, -0.04050172f, 0.01862087f, 0.00080643f, 
    -0.03713456f, 0.01376232f, -0.00898598f, 0.04080505f, 0.01799359f, 0.00660462f, 0.03844090f, 0.04134525f, 
    -0.05386488f, 0.01709665f, 0.01833809f, 0.00174697f, 0.01233760f, 0.01818175f, -0.02898296f, 0.00171510f, 
    0.00479350f, -0.05126498f, -0.01971145f, -0.02077359f, -0.04536885f, 0.00236185f, 0.02265516f, 0.00888908f, 
    0.04007297f, -0.01131979f, 0.00156744f, -0.04366108f, -0.00650239f, 0.02077216f, -0.00018648f, -0.00688406f, 
    0.04340394f, -0.04013093f, -0.02597368f, 0.01122144f, 0.03945354f, 0.00097826f, 0.02857067f, -0.04726857f, 
    -0.01190235f, 0.01891737f, 0.01665085f, 0.01721751f, -0.03520355f, 0.02785648f, 0.02759387f, 0.02861672f, 
    -0.05175332f, -0.03766821f, 0.03790833f, -0.01031990f, 0.02086766f, -0.05531545f, -0.02343768f, -0.02588475f, 
    -0.01873509f, -0.05163398f, 0.04097320f, -0.05121851f, -0.01607871f, 0.00204888f, -0.03872243f, 0.01638576f, 
    0.02381195f, -0.00899205f, -0.01245513f, 0.04440446f, 0.02777220f, 0.03857022f, -0.02892102f, -0.02997646f, 
    -0.04343186f, -0.02766808f, -0.03745015f, 0.01936881f, -0.01349816f, -0.01430340f, -0.05275037f, 0.01765703f, 
    -0.01495831f, 0.00494081f, -0.05096100f, -0.03970981f, -0.03599084f, -0.01367132f, 0.03994912f, 0.01456957f, 
    0.03197872f, 0.01805161f, -0.01349917f, 0.03119589f, 0.02977417f, -0.05547740f, 0.01257697f, -0.01915613f, 
    -0.02566062f, -0.04508527f, 0.03433653f, -0.01723216f, -0.04159751f, -0.02624150f, 0.02590755f, -0.00354830f, 
    0.01439049f, -0.03974986f, -0.03693350f, -0.05018922f, 0.01430868f, 0.00519136f, 0.00471319f, -0.03086188f, 
    -0.04406440f, -0.02483457f, 0.00581458f, -0.04025862f, -0.03494138f, 0.02853223f, -0.01797220f, 0.01121140f, 
    -0.03832923f, -0.05595757f, 0.03533925f, -0.01215896f, -0.00626969f, 0.02537693f, -0.02936003f, -0.04412040f, 
    0.02783361f, 0.03324922f, -0.02689742f, -0.02885409f, 0.00122684f, -0.00089756f, 0.03472336f, -0.03653601f, 
    -0.00485832f, -0.01981329f, -0.00250000f, 0.03945605f, -0.02337659f, -0.05329462f, 0.00662440f, 0.01405026f, 
    -0.00833024f, -0.04086991f, -0.04253386f, 0.03369659f, 0.01703292f, -0.01644503f, 0.01213798f, 0.01204013f, 
    -0.02858793f, -0.00237537f, 0.02334841f, -0.02307889f, -0.01578564f, 0.01031748f, 0.01720400f, -0.01229022f, 
    0.01251324f, 0.02970908f, -0.00886090f, -0.04313706f, -0.00099554f, 0.04956780f, -0.00768300f, -0.01567298f, 
    0.03672563f, 0.03052490f, 0.04273658f, 0.02539321f, 0.05569575f, -0.02869176f, 0.01118342f, 0.00923669f, 
    -0.04145997f, -0.05386666f, -0.01514105f, -0.00121208f, -0.05465813f, -0.01685504f, -0.03582383f, 0.02421495f, 
    -0.01985784f, -0.04240823f, -0.04481062f, -0.04922100f, 0.00174857f, -0.04317323f, -0.05064953f, 0.00473647f, 
    -0.00986527f, -0.05234831f, -0.00560425f, -0.02651524f, 0.03466264f, -0.02203866f, 0.03350743f, -0.04684252f, 
    -0.04292651f, 0.05301056f, -0.03667712f, 0.03942834f, -0.02833816f, 0.01280563f, 0.04159362f, 0.01124749f, 
    0.00107903f, -0.00771368f, -0.03936964f, 0.02318881f, -0.03026203f, 0.00584120f, 0.00981991f, 0.03999865f, 
    0.01268571f, -0.04748305f, -0.03168109f, -0.03549282f, -0.02933659f, -0.03272252f, -0.03400342f, 0.03846933f, 
    0.03323760f, -0.00357404f, -0.00642171f, 0.01901731f, -0.01231628f, 0.01409213f, -0.05583844f, 0.00316099f, 
    -0.04954828f, -0.03664603f, -0.03194834f, 0.03201354f, -0.05329940f, -0.04099490f, 0.01430218f, 0.03572376f, 
    0.02343215f, -0.00070773f, 0.02484560f, -0.04756388f, -0.04326965f, 0.01210486f, -0.01655158f, -0.03489690f, 
    -0.02082702f, 0.04013177f, -0.02251333f, -0.01969923f, 0.03524771f, -0.02503328f, -0.02168979f, -0.02919467f, 
    -0.03042815f, 0.01402752f, -0.03065807f, -0.04713200f, -0.02274791f, -0.03810528f, -0.05680608f, 0.01675649f, 
    0.01220076f, -0.00301404f, -0.00260697f, 0.01369329f, -0.03595485f, -0.01435474f, -0.01183234f, -0.02712133f, 
    -0.00561614f, -0.00542323f, 0.03704811f, -0.05020150f, -0.05221058f, -0.00869279f, -0.04893728f, 0.02158829f, 
    0.03774881f, 0.03378372f, 0.02907871f, 0.03805323f, 0.01027629f, -0.00973621f, -0.04856534f, 0.04441044f, 
    -0.00023240f, -0.04977947f, -0.05244867f, -0.01309267f, 0.03630942f, 0.03845067f, 0.02584637f, -0.02096159f, 
    -0.04857691f, -0.05471518f, -0.05214382f, -0.02567614f, -0.01960689f, 0.00193887f, 0.02041315f, 0.00279555f, 
    0.05627256f, -0.01433451f, -0.22578202f, 0.35436431f, 0.00050432f, -0.07371209f, 0.01221637f, 0.21637401f, 
    0.01710254f, 0.16477567f, 0.12948805f, -0.11564606f, 0.31074023f, -0.28455168f, 0.07974826f, -0.01763281f, 
    0.11384764f, 0.10856827f, -0.05781195f, 0.05083123f, 0.24114944f, -0.08572496f, 0.14973307f, 0.09338995f, 
    0.18591838f, 0.11644682f, -0.02200384f, 0.12945805f, 0.07850148f, -0.00812921f, 0.17228489f, 0.09444379f, 
    -0.13623494f, 0.12147176f, 0.12556200f, 0.07816031f, 0.21161680f, 0.16336495f, 0.12013917f, -0.00041431f, 
    0.07370092f, 0.16353035f, 0.15958945f, 0.11819215f, 0.07026377f, -0.07865715f, -0.10192174f, -0.11156420f, 
    0.18392341f, 0.00451005f, 0.37051156f, 0.33706453f, -0.01967224f, 0.18010277f, 0.27133855f, 0.13651353f, 
    0.14983894f, 0.01053966f, -0.01299003f, 0.15896802f, 0.20678772f, -0.00228229f, 0.25708729f, 0.22187243f, 
    -0.06418841f, 0.18003775f, -0.14159802f, 0.11831295f, -0.00715285f, 0.04351366f, 0.07232326f, -0.01581121f, 
    0.13335316f, -0.20609789f, -0.04999876f, -0.21672463f, 0.19455484f, 0.09159798f, 0.05833956f, 0.24136899f, 
    0.14168760f, 0.10806948f, 0.10680760f, 0.14184363f, -0.18609090f, -0.11948639f, 0.13018692f, -0.15995586f, 
    0.09402958f, -0.26863408f, -0.16135830f, -0.26074308f, -0.26510251f, -0.21867962f, -0.06079121f, -0.21037735f, 
    0.06950480f, -0.21973632f, 0.08226255f, 0.11326542f, -0.11583562f, 0.00503358f, 0.10917750f, 0.04109054f, 
    0.27062112f, 0.06482685f, 0.10483287f, 0.04463267f, 0.08365240f, 0.44943723f, 0.00986230f, 0.49116299f, 
    0.04741854f, 0.00406521f, 0.12307397f, 0.09058847f, -0.10556205f, -0.00694950f, -0.07576559f, -0.17210694f, 
    -0.40540683f, 0.23353533f, -0.46415135f, -0.24849191f, 0.05808177f, -0.12295389f, 0.00571622f, -0.11394770f, 
    -0.11445383f, -0.05616541f, 0.03867008f, -0.01882333f, -0.22627458f, 0.05895803f, -0.36285439f, 0.24937619f, 
    0.08365484f, 0.04177910f, 0.04186982f, 0.01603387f, 0.18724510f, -0.09750771f, 0.14903040f, 0.00913104f, 
    -0.38131976f, 0.29003066f, -0.19158418f, 0.29044387f, -0.04071321f, -0.02439336f, 0.23690878f, 0.06506160f, 
    0.09412520f, 0.01292167f, 0.18443337f, 0.06618417f, -0.02118386f, -0.25101167f, 0.14881456f, 0.10851292f, 
    -0.02511017f, -0.17946531f, -0.06645370f, -0.09145118f, 0.05048345f, 0.17789614f, -0.09301116f, -0.23119865f, 
    -0.12359985f, -0.40842187f, 0.19236098f, -0.31341335f, 0.10860770f, -0.13285744f, 0.01390017f, -0.18518792f, 
    0.00025466f, -0.07132181f, -0.26302540f, -0.16175948f, 0.46412623f, -0.15321173f, -0.46054575f, -0.14412425f, 
    -0.04157450f, -0.06172045f, 0.03667761f, -0.09624480f, 0.04379166f, -0.17396182f, 0.00296323f, 0.15731514f, 
    0.10405815f, 0.16208015f, 0.19797301f, 0.31186852f, 0.03978635f, -0.03492366f, 0.10590389f, 0.17014600f, 
    -0.01725730f, 0.04047100f, 0.02120203f, -0.20108181f, 0.37816033f, -0.18407652f, 0.07257414f, 0.04364160f, 
    0.08917652f, -0.06006466f, -0.10568983f, -0.15081118f, 0.19562839f, -0.00198138f, -0.04981280f, -0.02259894f, 
    -0.05358591f, 0.35830340f, -0.11518473f, -0.03070371f, 0.08959030f, 0.10577480f, 0.06641634f, 0.22911158f, 
    -0.10985141f, 0.01660178f, -0.03145187f, 0.21278347f, 0.02012660f, -0.17719010f, -0.00641151f, -0.21617225f, 
    -0.06804155f, 0.15049833f, 0.03700984f, 0.14603405f, 0.09851781f, -0.02028341f, 0.00294293f, -0.11789984f, 
    -0.05150516f, 0.18890534f, -0.03495432f, -0.05332788f, 0.03477723f, -0.06907678f, -0.09387332f, 0.12809077f, 
    -0.02694209f, 0.04715504f, 0.13031907f, 0.06843239f, 0.08683161f, 0.13301304f, -0.15025871f, 0.05688227f, 
    -0.01243598f, 0.05912087f, -0.04809846f, 0.01576201f, 0.15400849f, 0.01223864f, -0.04079441f, 0.05249825f, 
    0.00812662f, 0.06882322f, -0.14895891f, 0.11815082f, -0.04902163f, 0.02343384f, -0.02191692f, -0.04758376f, 
    0.10509031f, -0.03047602f, 0.08247674f, 0.03033000f, 0.04693523f, 0.11010625f, -0.22675540f, 0.06963351f, 
    0.04758040f, -0.04946915f, 0.00699040f, 0.05090593f, 0.02497554f, 0.09857390f, 0.21352978f, 0.08974700f, 
    -0.07291578f, -0.45606157f, -0.32974979f, 0.10561500f, 0.07524501f, -0.04459153f, 0.07858765f, 0.10055599f, 
    0.01970441f, -0.00895358f, 0.04707060f, 0.12270892f, 0.11811499f, -0.32926148f, 0.13323975f, -0.23900838f, 
    -0.11379555f, -0.07403352f, 0.17411375f, -0.07084482f, 0.10650180f, 0.01314381f, -0.00927408f, 0.05200709f, 
    0.23351742f, -0.14702402f, -0.09717307f, -0.13446771f, 0.09983202f, -0.03524664f, -0.05059221f, -0.19464906f, 
    -0.10676897f, -0.02967172f, 0.07108691f, -0.17689174f, 0.21818437f, 0.23846340f, 0.09317056f, 0.05046080f, 
    0.17590517f, -0.00925049f, -0.09240975f, -0.07547586f, 0.06760057f, -0.01810002f, 0.01028680f, -0.06725698f, 
    -0.00745098f, -0.01369048f, 0.01416806f, 0.10381509f, -0.11932628f, -0.00981363f, 0.14321083f, 0.03433294f, 
    0.09394758f, 0.01963686f, 0.24602966f, 0.07416313f, 0.15865542f, 0.14595990f, 0.13502719f, -0.03261790f, 
    0.14039761f, -0.10509240f, -0.09191091f, -0.00725167f, -0.13743737f, -0.19065078f, -0.17048928f, -0.26289704f, 
    -0.04134033f, -0.31987771f, 0.29584143f, -0.20819582f, 0.03607697f, -0.00123835f, -0.12276376f, -0.20188379f, 
    0.16557357f, -0.05885595f, 0.14242281f, -0.00652064f, 0.12650920f, -0.22073562f, 0.13685854f, 0.01802114f, 
    -0.18725745f, 0.14590779f, 0.00493465f, -0.35340729f, -0.08369494f, 0.12961727f, 0.07873119f, 0.07064293f, 
    0.02472742f, -0.12640524f, 0.17192136f, 0.06460465f, 0.12849043f, 0.07587805f, 0.10952160f, -0.04499042f, 
    0.14518052f, -0.01238752f, 0.04354106f, 0.20622684f, 0.02297777f, -0.01139375f, -0.08592156f, -0.20090023f, 
    0.13568127f, 0.06583658f, 0.07502575f, 0.04526899f, -0.20111498f, 0.01087319f, -0.01570094f, -0.20492756f, 
    0.05766691f, 0.14526647f, 0.00217765f, -0.12618160f, -0.07886797f, -0.11136292f, 0.04931035f, 0.02162153f, 
    0.02829598f, -0.11344778f, 0.08655331f, -0.15844704f, 0.17991647f, -0.00920035f, -0.10736623f, -0.04849915f, 
    0.00919521f, 0.24892303f, 0.08409299f, 0.08745434f, -0.15464899f, -0.01893334f, 0.00161843f, -0.02090339f, 
    0.10329369f, 0.12231433f, -0.06689090f, -0.16063172f, -0.07803215f, -0.10996408f, 0.09445032f, 0.12760712f, 
    -0.12974429f, -0.01496674f, -0.07788168f, -0.18333767f, 0.26609588f, 0.18505174f, 0.09811357f, -0.18944600f, 
    -0.00742033f, -0.08092321f, 0.18798481f, 0.04936704f, 0.06695206f, -0.01442450f, 0.01425586f, 0.11524715f, 
    0.16627315f, 0.17045817f, -0.20726234f, -0.14093007f, 0.09016836f, 0.10210203f, 0.14126517f, 0.04850394f, 
    -0.00294849f, -0.11182681f, 0.01072758f, -0.05234612f, 0.04124756f, 0.10710617f, 0.07147911f, -0.03876281f, 
    0.06623775f, -0.05417022f, -0.16270974f, -0.18828885f, -0.03665832f, 0.05822406f, 0.00843026f, 0.09826510f, 
    -0.06234056f, -0.28572384f, -0.10760302f, -0.02277970f, -0.05645675f, 0.07402622f, 0.02981463f, -0.04827660f, 
    -0.13005131f, -0.04153875f, -0.09267084f, -0.18825151f, 0.14125203f, 0.03742670f, -0.08641087f, -0.08050759f, 
    -0.06255846f, -0.00986824f, 0.02608572f, 0.11896878f, -0.19888496f, 0.10260141f, -0.01073695f, 0.07919976f, 
    0.54735029f, -0.19121419f, -0.21991393f, 0.02419374f, -0.06460007f, -0.06209211f, 0.04429604f, -0.11485253f, 
    0.13761173f, -0.03156866f, 0.11166961f, -0.08700883f, -0.11394746f, 0.12239761f, -0.09222454f, 0.29684329f, 
    0.04161729f, -0.07921908f, -0.05175811f, -0.11050338f, 0.01439221f, 0.03832156f, -0.02664801f, -0.00403927f, 
    0.00056006f, 0.00602740f, 0.23714197f, 0.28713235f, -0.11200601f, -0.01805427f, -0.14942808f, 0.03112900f, 
    0.00903010f, 0.03766968f, 0.20595030f, 0.11023642f, 0.08171274f, -0.10897817f, -0.16251384f, -0.05622309f, 
    0.08297551f, 0.11817084f, 0.21286374f, 0.04496721f, 0.07752409f, 0.20676586f, 0.05479778f, 0.21118128f, 
    0.23692738f, -0.03028982f, -0.12565421f, -0.17383026f, 0.05981797f, 0.20365199f, 0.04823689f, -0.04407185f, 
    -0.00843215f, 0.10918059f, 0.13051176f, -0.00921100f, 0.06954627f, -0.06702161f, -0.35220876f, -0.14399666f, 
    0.01476539f, 0.05946484f, 0.04782379f, 0.04188414f, -0.00426430f, -0.05717132f, -0.09772619f, -0.08821218f, 
    0.27745605f, 0.12829612f, 0.03077186f, -0.04053767f, 0.01978667f, -0.00952823f, 0.00945356f, -0.08604711f, 
    -0.03861786f, 0.02354626f, 0.11062131f, 0.07327400f, -0.01785612f, -0.28191593f, 0.05762611f, -0.21495456f, 
    -0.07714640f, 0.04688022f, 0.07154633f, 0.01333465f, 0.16717568f, 0.02087263f, 0.13725519f, -0.00628642f, 
    0.43559057f, 0.13836461f, -0.12024870f, -0.02963035f, 0.09349957f, -0.09347935f, 0.16362205f, -0.09496287f, 
    -0.05385802f, -0.10459542f, -0.02587260f, 0.09297021f, 0.11303413f, 0.07240546f, 0.18071657f, 0.12919880f, 
    -0.04311851f, 0.02630559f, -0.02988707f, -0.03939608f, 0.03429658f, 0.07631767f, -0.01579272f, 0.04080583f, 
    0.45965040f, 0.39467815f, -0.00794431f, -0.10411614f, 0.26654834f, -0.01249546f, 0.04891038f, -0.02758447f, 
    -0.05673328f, -0.06139035f, -0.08048414f, 0.16946457f, -0.19235474f, -0.02724580f, 0.04178708f, -0.11320697f, 
    0.22426902f, 0.25463608f, 0.04393259f, 0.16843909f, 0.11258170f, 0.00912133f, 0.06862564f, -0.06531736f, 
    -0.26120675f, -0.13874832f, 0.12855580f, 0.04344847f, 0.05030539f, 0.18127836f, -0.06496079f, 0.21853223f, 
    -0.18242781f, 0.06761143f, -0.09710840f, -0.10568498f, 0.39624557f, 0.13723345f, -0.03615313f, 0.05783239f, 
    0.08145046f, 0.18122929f, 0.17474765f, -0.02492872f, -0.04481413f, -0.13312404f, 0.08522440f, 0.15362252f, 
    0.44997004f, -0.26362008f, -0.25089514f, -0.02887728f, 0.28574327f, 0.22032346f, -0.03520213f, -0.07394760f, 
    0.09794133f, 0.08259193f, 0.04346430f, 0.00580494f, -0.07652522f, 0.00480496f, 0.11555710f, -0.05020750f, 
    -0.02277001f, -0.03304262f, -0.01783698f, 0.01413156f, 0.06647369f, -0.17260380f, 0.17849748f, 0.04272682f, 
    -0.02516390f, -0.21894383f, -0.40492380f, -0.24316117f, -0.06286982f, 0.03929829f, 0.21219613f, 0.01004544f, 
    0.04050390f, -0.00517317f, 0.03965595f, 0.06069292f, 0.02775681f, 0.08785129f, -0.35297567f, 0.11922036f, 
    0.00995858f, -0.08147824f, 0.25199315f, -0.13797168f, 0.06006483f, 0.10736492f, -0.07695547f, 0.18990253f, 
    -0.05983255f, -0.08649797f, 0.10563222f, 0.12660636f, 0.04687827f, 0.12161898f, 0.01567482f, 0.14193605f, 
    -0.18222694f, -0.19755541f, -0.05581693f, -0.23328364f, 0.08908576f, 0.12038393f, -0.02138687f, -0.04053526f, 
    -0.07685487f, -0.18466398f, -0.02304673f, -0.16464612f, 0.05119595f, 0.11651814f, -0.03361501f, 0.08045085f, 
    0.28807339f, 0.24544647f, 0.21975042f, 0.01012297f, 0.01422395f, 0.04941168f, -0.10095856f, -0.04003473f, 
    -0.01172233f, 0.06494205f, 0.11394370f, 0.14055873f, 0.01736936f, 0.01448617f, 0.27212241f, 0.14614132f, 
    0.08888872f, -0.06528093f, -0.10859045f, -0.03875372f, -0.04857055f, 0.04573533f, 0.00138317f, -0.01880780f, 
    0.17626847f, 0.04345917f, -0.28090850f, 0.15507919f, 0.00256594f, 0.11522871f, 0.04480722f, 0.10157532f, 
    0.10415433f, 0.12532547f, 0.11776797f, -0.01331738f, 0.05929036f, 0.10138647f, 0.31422374f, 0.16545710f, 
    -0.08324005f, 0.05387497f, 0.03902894f, 0.05342957f, 0.31389204f, -0.01804117f, 0.10611287f, 0.22187206f, 
    0.07734621f, -0.31767341f, 0.17944261f, 0.35013244f, 0.17510958f, -0.17903157f, 0.08832151f, 0.02561699f, 
    0.35578370f, 0.03657337f, 0.08861484f, 0.21056660f, 0.14900929f, 0.19800755f, -0.26901922f, -0.41270354f, 
    0.04303761f, 0.02092989f, 0.01772999f, -0.20478453f, -0.02713058f, -0.17339496f, -0.10905601f, -0.05844332f, 
    0.33159685f, -0.00451550f, 0.09473462f, -0.08415803f, -0.02582869f, -0.02295114f, 0.18176141f, 0.06429144f, 
    0.09454700f, -0.07218384f, -0.09680744f, -0.02832353f, 0.20443475f, -0.00904342f, 0.24367613f, -0.23229226f, 
    0.04501994f, 0.04596690f, -0.17698619f, -0.12392099f, 0.12294045f, -0.01449249f, 0.04019407f, 0.17865126f, 
    0.00790921f, 0.21554844f, 0.20408720f, -0.02655603f, 0.09686892f, 0.17888476f, 0.01363072f, 0.08953439f, 
    0.06862527f, 0.06370761f, 0.26971725f, 0.13270806f, -0.22772793f, -0.19096321f, -0.00735401f, 0.10784919f, 
    0.17829652f, -0.10617816f, -0.12370184f, -0.14344527f, -0.20297338f, -0.20200646f, -0.08728577f, -0.35183206f, 
    0.17122573f, -0.09926239f, 0.02910428f, -0.02790206f, 0.04338877f, -0.01203504f, 0.04540816f, 0.04042573f, 
    0.29360801f, 0.05250951f, 0.35256588f, 0.23588692f, -0.01066477f, 0.26867452f, -0.48286983f, -0.25172737f, 
    -0.01586288f, -0.06836189f, 0.13342716f, -0.08277456f, -0.04173218f, 0.07985478f, -0.12658326f, -0.19418405f, 
    -0.13674854f, -0.22185700f, 0.03651935f, -0.18302613f, -0.08864309f, -0.23964268f, -0.13285847f, 0.06548923f, 
    0.07551631f, 0.12767793f, -0.05777933f, 0.07405125f, -0.18690345f, -0.15726058f, -0.18630344f, 0.07238750f, 
    0.27259508f, 0.05681432f, 0.07931803f, 0.04151762f, -0.11693835f, -0.08211333f, -0.09971751f, 0.09593590f, 
    -0.36252174f, 0.13030973f, -0.11727103f, 0.06550020f, -0.11138955f, 0.07702422f, -0.02602784f, 0.03873197f, 
    0.12618852f, 0.07094284f, 0.16075832f, 0.05836507f, 0.12627408f, 0.09555126f, 0.10767122f, 0.04872495f, 
    0.21655650f, -0.11983898f, -0.04597871f, -0.04245273f, 0.09298770f, 0.03800324f, 0.12734123f, -0.02644955f, 
    0.15156022f, -0.09683721f, 0.32369119f, -0.30342436f, -0.00805467f, -0.17255440f, 0.14271832f, -0.06879792f, 
    0.20598957f, 0.18802427f, -0.29068273f, -0.06962772f, -0.31620964f, -0.02536875f, -0.00977461f, 0.01173880f, 
    -0.07362965f, 0.07564953f, 0.15553546f, 0.03586805f, -0.00055979f, -0.03232467f, -0.05028105f, 0.05779203f, 
    0.22732031f, 0.04844782f, -0.05159175f, -0.20736580f, 0.06741992f, -0.04370787f, -0.06104476f, -0.06577978f, 
    0.07304832f, -0.03922936f, 0.05721800f, 0.03316082f, 0.20301373f, 0.00286414f, 0.32571679f, 0.04380974f, 
    -0.08108737f, -0.04493379f, -0.16770995f, -0.16965027f, -0.02244709f, -0.04326275f, -0.07994352f, -0.12141093f, 
    0.35508421f, -0.19377518f, -0.01947927f, -0.18024985f, -0.00423774f, 0.17499417f, 0.11164868f, 0.15229258f, 
    -0.00357306f, 0.03446437f, -0.01362657f, 0.11543512f, 0.01264980f, -0.19537126f, -0.08395164f, 0.05835068f, 
    -0.04325828f, 0.07566855f, 0.06679427f, 0.05114601f, 0.09391587f, -0.05006073f, 0.01864904f, -0.05027105f, 
    0.15449290f, 0.09598181f, -0.06181363f, -0.20828137f, 0.06043469f, 0.01852907f, -0.01052631f, 0.10403143f, 
    0.05084669f, -0.00808605f, 0.07745370f, -0.04930776f, 0.18378617f, 0.15049779f, -0.17470346f, -0.39300185f, 
    -0.03015750f, 0.03113810f, -0.06208242f, -0.16168709f, 0.01757400f, -0.11349001f, -0.07824867f, 0.11971845f, 
    -0.35230199f, 0.32156295f, -0.16021736f, 0.10290358f, -0.01206462f, 0.06956501f, 0.11386648f, -0.01589598f, 
    0.29383558f, 0.14057113f, 0.23251231f, 0.17839494f, -0.07692917f, -0.01323264f, -0.16969435f, -0.14041877f, 
    -0.01168250f, -0.01633780f, 0.03382067f, 0.05330518f, -0.03693299f, -0.16890952f, 0.08511628f, -0.07261609f, 
    0.15244511f, 0.00773353f, -0.03948446f, -0.17315266f, -0.04065411f, 0.04670115f, -0.04454177f, 0.05546923f, 
    -0.08126509f, -0.05600356f, 0.17470075f, 0.09913447f, 0.09514852f, -0.04344783f, 0.09840012f, 0.10159153f, 
    0.05323573f, 0.05299586f, 0.20457134f, -0.07016943f, 0.10669873f, 0.04669691f, 0.09309379f, 0.04929111f, 
    0.18161453f, 0.21904020f, 0.54835504f, 0.28145656f, 0.07709028f, -0.08870901f, -0.09857538f, -0.01816129f, 
    -0.05346869f, 0.02041900f, 0.08641294f, -0.01727675f, -0.39553550f, -0.11298627f, -0.29223111f, -0.32504553f, 
    0.07920640f, -0.07205317f, -0.07176965f, 0.20020993f, -0.04489952f, 0.04466220f, -0.03335178f, 0.10818379f, 
    -0.08698704f, 0.07238003f, 0.03466818f, 0.19727635f, -0.04305625f, -0.04536568f, 0.06686939f, 0.01011361f, 
    0.02613588f, 0.08869138f, 0.25781497f, 0.21535511f, 0.00858512f, -0.07285546f, 0.03782709f, -0.12467585f, 
    0.32606658f, -0.01329293f, 0.04454768f, -0.08667472f, -0.14841552f, -0.45235473f, -0.29180962f, -0.40402403f, 
    0.09118249f, -0.19384056f, 0.14208657f, 0.32702708f, 0.00267131f, 0.06669656f, -0.02729422f, -0.05126225f, 
    0.12331186f, -0.12257035f, 0.14914411f, -0.02090322f, 0.09340982f, -0.01066462f, -0.18277025f, 0.03972896f, 
    -0.03024900f, 0.14637645f, 0.02044789f, -0.17998780f, 0.03863642f, -0.18533593f, -0.01804194f, 0.08104432f, 
    0.04054853f, 0.05682517f, 0.34622779f, -0.06458907f, -0.03186015f, -0.01238223f, 0.03584707f, 0.02426651f, 
    -0.09800460f, 0.15279154f, 0.06549227f, 0.18499969f, 0.18958381f, 0.05825737f, -0.14366041f, 0.23825842f, 
    0.12590578f, 0.12780337f, 0.07437905f, -0.01421308f, 0.01666419f, 0.15149634f, 0.13193657f, 0.03873614f, 
    0.08139502f, 0.34333795f, 0.09947294f, -0.13614991f, 0.11695438f, 0.12536579f, 0.16181898f, 0.15829849f, 
    0.17664623f, 0.15220572f, 0.16795845f, 0.12985080f, 0.04029681f, -0.04434723f, -0.12297791f, 0.02773052f, 
    -0.18919967f, -0.08300370f, -0.13264190f, 0.01274023f, -0.03983390f, -0.02496201f, -0.03892750f, -0.01460444f, 
    0.04673537f, 0.02948320f, 0.08574989f, -0.05398488f, -0.10409328f, -0.00392554f, 0.02529211f, -0.06787373f, 
    0.04945530f, -0.01307554f, -0.05829087f, -0.01196358f, -0.02957803f, 0.08711778f, -0.43037391f, 0.15077786f, 
    0.03980492f, 0.07416294f, -0.01667931f, 0.09014603f, 0.02644297f, 0.17452505f, 0.05660358f, -0.05440583f, 
    0.14506708f, -0.02802062f, 0.11936255f, -0.05180011f, 0.22952121f, 0.15429913f, 0.05758340f, -0.13027300f, 
    -0.02299681f, 0.17264457f, 0.11585894f, 0.12465521f, 0.02684730f, 0.11634266f, -0.10837135f, 0.02930886f, 
    0.02921853f, 0.00396622f, 0.05123519f, -0.02473225f, -0.18189721f, -0.23540670f, 0.06144006f, -0.18542981f, 
    -0.33312204f, 0.17593487f, -0.04207354f, 0.18399388f, -0.06126427f, -0.05972228f, 0.05201742f, 0.08321869f, 
    0.00662270f, 0.30401060f, -0.14624044f, 0.25766641f, 0.29708278f, -0.16731474f, 0.19823557f, -0.08932416f, 
    0.05430161f, -0.02035250f, -0.13608378f, 0.07473048f, 0.00535440f, -0.08648973f, -0.02319787f, -0.16002868f, 
    -0.20184051f, 0.36769387f, -0.30216730f, 0.32653415f, 0.06423964f, 0.09172839f, -0.00035959f, -0.02454694f, 
    -0.08953998f, -0.05551226f, 0.00678142f, 0.18299508f, 0.22503522f, 0.03332873f, 0.47992334f, -0.28298348f, 
    -0.18018176f, -0.15427971f, -0.07968038f, 0.03671286f, -0.16062883f, 0.02999633f, 0.02968688f, 0.03075543f, 
    -0.16886386f, -0.16385396f, 0.18796827f, 0.01921081f, -0.09870067f, -0.05729206f, 0.03944365f, 0.00315217f, 
    -0.04581293f, 0.04674546f, -0.06351521f, 0.03883505f, -0.19532461f, 0.08981512f, 0.07567307f, 0.10168958f, 
    -0.01913793f, -0.03681964f, 0.02714676f, 0.12834588f, -0.11976559f, -0.05084521f, -0.05079419f, 0.02276581f, 
    -0.22950083f, 0.25575081f, -0.15137720f, 0.39840895f, -0.11151522f, -0.06982336f, -0.08865534f, 0.22549702f, 
    -0.07288443f, -0.01174694f, 0.13220179f, 0.03879249f, 0.56146395f, -0.09537408f, 0.28375557f, 0.12205885f, 
    0.19981065f, 0.24585754f, 0.07543875f, 0.00223207f, -0.13045780f, -0.02273927f, -0.07408763f, -0.09096137f, 
    -0.28256190f, -0.08330921f, -0.03288244f, 0.00228307f, -0.04134359f, -0.08211096f, -0.05468794f, 0.15732250f, 
    -0.00264812f, 0.14838247f, -0.04842261f, -0.00734177f, -0.08275402f, 0.48928404f, 0.00622556f, 0.15003981f, 
    0.29286432f, 0.01151694f, 0.03058206f, -0.13032496f, -0.12401547f, -0.00887698f, -0.16863351f, 0.04755845f, 
    -0.05865635f, 0.27904710f, -0.19932178f, 0.41228947f, 0.10893562f, 0.08969015f, 0.02375964f, -0.10683236f, 
    -0.03154047f, 0.00803342f, 0.00075040f, 0.04449554f, -0.18218064f, 0.05077121f, -0.30544204f, -0.03392000f, 
    -0.05512080f, 0.08424781f, 0.02876995f, 0.04520016f, -0.08143526f, 0.12056365f, 0.07394831f, -0.10523438f, 
    -0.01605624f, -0.08057345f, -0.15293522f, 0.22478510f, -0.06487695f, 0.03942167f, -0.01249136f, -0.09716170f, 
    -0.10167674f, -0.07651732f, 0.02286363f, -0.14606869f, 0.09321889f, 0.13189675f, -0.07970364f, 0.04520729f, 
    -0.20065854f, -0.07931527f, 0.04814601f, -0.11330777f, -0.03569179f, 0.00484740f, -0.01433094f, 0.05310591f, 
    0.35849744f, -0.10207526f, 0.00820780f, -0.06242128f, -0.06243378f, 0.10313790f, 0.03474152f, -0.03020519f, 
    -0.10392944f, 0.05497527f, -0.01488267f, 0.17760970f, 0.11520343f, -0.13555343f, -0.00448331f, -0.04870107f, 
    0.05703903f, 0.09772483f, -0.14411063f, 0.12367655f, -0.04398367f, -0.03023383f, 0.02517919f, -0.02723888f, 
    -0.03488592f, 0.04448360f, -0.11063402f, 0.31851691f, -0.10400231f, -0.03604387f, -0.01043328f, -0.01963371f, 
    0.01069842f, 0.06425299f, -0.11858610f, 0.06641924f, 0.02664684f, 0.26636732f, -0.09799051f, -0.09527539f, 
    -0.14790711f, -0.06987988f, 0.13192156f, -0.19372569f, 0.16556865f, 0.00470111f, -0.04138634f, -0.17063648f, 
    -0.19646500f, 0.43272668f, 0.02085226f, 0.19234240f, 0.18306501f, 0.01513591f, -0.11116604f, 0.00942236f, 
    -0.08338851f, 0.09491062f, 0.00365280f, -0.10747007f, 0.22396939f, -0.26553497f, 0.46562612f, 0.22191924f, 
    0.03012204f, 0.20035094f, -0.20468666f, 0.09862542f, 0.14643994f, 0.08822586f, -0.03545774f, -0.13482618f, 
    -0.03458777f, 0.13445735f, 0.12431999f, -0.18667175f, -0.01081587f, -0.00098662f, -0.11962933f, -0.09068150f, 
    0.04916102f, 0.12319560f, 0.11439245f, 0.30671665f, 0.13412355f, 0.21776927f, -0.22210440f, 0.13385455f, 
    0.10632037f, -0.07991210f, -0.17334875f, 0.18553761f, -0.25142056f, 0.06747767f, 0.01403442f, -0.15730894f, 
    -0.07749977f, 0.19003861f, -0.14485173f, 0.08273254f, -0.05520694f, 0.00847324f, 0.08171184f, 0.05689898f, 
    -0.18407895f, 0.10964777f, 0.07468969f, 0.02700410f, -0.06583067f, -0.24031463f, 0.14496504f, 0.31204337f, 
    -0.13858655f, 0.07099924f, 0.03060007f, -0.03864621f, -0.21291813f, -0.06693847f, -0.02353149f, 0.13082871f, 
    -0.03887336f, -0.04472911f, 0.00046826f, -0.01538712f, -0.01171423f, -0.03330816f, 0.01072730f, 0.01883229f, 
    0.01541923f, -0.03662161f, -0.01061586f, -0.01545960f, 0.02895488f, 0.01654169f, 0.03958210f, -0.03322137f, 
    -0.01043366f, 0.00823829f, -0.04240960f, -0.02372610f, -0.05544134f, -0.00850365f, -0.05828801f, -0.03019457f, 
    -0.01740123f, -0.00112175f, 0.02035141f, 0.03558214f, -0.04433184f, 0.01742984f, -0.02518792f, 0.01206530f, 
    0.01036998f, -0.02690405f, -0.02650831f, -0.03153056f, 0.02661642f, -0.05257931f, 0.03640638f, -0.03701169f, 
    0.00950633f, 0.00889772f, -0.03440869f, -0.02612422f, -0.03761238f, 0.03635218f, -0.04864878f, -0.04374079f, 
    -0.00062886f, -0.03439278f, 0.03594463f, -0.05126798f, -0.03211437f, -0.02115251f, 0.04605977f, -0.05030046f, 
    0.02714698f, -0.04740501f, -0.00709994f, 0.01426345f, -0.01326474f, 0.03573133f, 0.03773697f, 0.03107542f, 
    0.01710153f, -0.03198135f, 0.01363413f, 0.00926579f, 0.03709368f, -0.02027466f, -0.01392421f, 0.02689159f, 
    -0.04938326f, -0.01115891f, -0.02633901f, -0.00162919f, -0.05277019f, -0.05586936f, -0.04448641f, -0.01174622f, 
    0.01258115f, -0.00831384f, -0.04484838f, -0.03397516f, -0.00904235f, -0.02840358f, -0.05144766f, -0.04662948f, 
    -0.01906193f, 0.01622730f, 0.00602253f, -0.03502578f, -0.03850018f, -0.04450985f, -0.02836056f, -0.04517821f, 
    0.01914078f, 0.01840580f, 0.00601650f, -0.05568793f, -0.02381472f, 0.03771749f, -0.03177523f, -0.05431908f, 
    0.00705214f, -0.05258842f, 0.01772954f, 0.01535824f, 0.04210963f, -0.04733291f, -0.00493620f, -0.04992137f, 
    0.04097488f, -0.02485145f, -0.03186765f, -0.04308061f, -0.00130357f, -0.00703396f, 0.01364208f, 0.00550471f, 
    -0.03074365f, 0.02486300f, -0.04393850f, 0.02076562f, 0.01727974f, -0.04198000f, 0.02978582f, -0.00230411f, 
    -0.04735731f, 0.00642613f, 0.01413356f, 0.00083184f, 0.00911544f, -0.05122937f, -0.01883603f, 0.02588332f, 
    0.05102008f, -0.00988947f, -0.03534228f, -0.04099678f, 0.01389201f, 0.02059039f, 0.02209027f, 0.00268296f, 
    0.02739485f, -0.03450638f, -0.03218434f, 0.03486095f, -0.05458422f, -0.04265584f, -0.02391333f, 0.03389081f, 
    0.03867407f, 0.03264330f, 0.00515562f, 0.03634218f, 0.02292367f, -0.01927288f, 0.01308380f, -0.04412683f, 
    0.01801302f, -0.01691022f, 0.02005279f, 0.00910553f, 0.02020549f, -0.05304297f, -0.02070518f, -0.04167075f, 
    0.04237189f, 0.01351008f, -0.04984359f, 0.02433927f, 0.02352806f, -0.05246968f, -0.01814603f, -0.02262745f, 
    0.00924000f, -0.00556244f, -0.05699404f, -0.00457794f, -0.01559376f, -0.00428535f, -0.00864529f, -0.01208282f, 
    -0.03831730f, -0.02944910f, -0.00522011f, 0.03441101f, 0.02673474f, -0.03136349f, 0.00233426f, -0.01284818f, 
    0.02004484f, -0.05915045f, 0.04102341f, -0.01225232f, 0.03551940f, -0.03192968f, 0.04049021f, 0.02525011f, 
    -0.00941308f, 0.03586206f, 0.03081869f, 0.00801405f, -0.02614794f, 0.02496356f, -0.01988933f, -0.01893391f, 
    0.03052918f, -0.02373103f, 0.04083300f, 0.03429079f, -0.03702031f, 0.01541093f, -0.01269846f, 0.00932644f, 
    0.03642705f, -0.01060773f, 0.03696672f, -0.05126343f, 0.04006387f, -0.04457254f, -0.00225353f, 0.03928185f, 
    -0.03287569f, -0.02985844f, -0.01023831f, 0.03222481f, -0.04020183f, -0.00274550f, 0.05551624f, 0.00979847f, 
    0.01989696f, 0.04399550f, -0.03561687f, 0.03768444f, -0.01761460f, 0.04383390f, -0.01388498f, -0.00681122f, 
    0.02246173f, 0.00734534f, 0.03483844f, 0.03947648f, 0.01598073f, -0.01800967f, 0.02196502f, 0.00063749f, 
    -0.05285184f, 0.00928466f, 0.03958011f, -0.03248257f, -0.00141784f, 0.02427397f, -0.03975556f, 0.03961671f, 
    -0.05373054f, -0.05594594f, -0.04435229f, 0.01393685f, -0.03085969f, 0.03952882f, 0.00570666f, -0.00792061f, 
    0.02098481f, -0.02049387f, 0.01213248f, -0.01696549f, 0.00910804f, 0.00637104f, 0.01980146f, 0.01765907f, 
    -0.00001927f, -0.04735569f, -0.05479268f, -0.05709575f, -0.02518305f, -0.02791544f, -0.05400260f, -0.02374109f, 
    -0.00428482f, -0.04463658f, -0.02999287f, -0.00169830f, -0.04401504f, 0.03059999f, -0.02045337f, 0.03813650f, 
    0.00984390f, -0.02712160f, 0.00392549f, 0.00667127f, -0.03814352f, -0.00557379f, -0.01254671f, -0.00410980f, 
    -0.03781607f, -0.01003934f, -0.05773225f, 0.04200724f, 0.04864898f, -0.04088091f, 0.01877815f, -0.02579356f, 
    0.00134599f, -0.03344082f, 0.00596040f, 0.04211770f, -0.02586220f, 0.00294662f, -0.04825353f, -0.04188460f, 
    -0.02012166f, -0.02303002f, 0.03747758f, 0.03438402f, -0.04201299f, 0.02498273f, 0.00055787f, -0.00233065f, 
    0.02291584f, -0.05392386f, 0.01542579f, 0.03091349f, 0.02624890f, -0.04423561f, 0.00673623f, -0.00846952f, 
    -0.04923881f, -0.05295141f, -0.03756065f, 0.03370248f, -0.02226353f, -0.04335967f, -0.05143982f, 0.03713425f, 
    -0.04104938f, -0.04800319f, -0.00108547f, -0.05137067f, -0.05340405f, 0.02510587f, 0.00889622f, -0.00843585f, 
    0.03640520f, -0.02154067f, 0.00613020f, 0.02129221f, 0.02810630f, 0.03541478f, -0.03523175f, 0.04165395f, 
    0.00057813f, -0.02148627f, -0.03734546f, -0.05387526f, 0.02049522f, -0.00650847f, -0.05704806f, -0.05712453f, 
    -0.03867686f, -0.02724006f, -0.00280541f, -0.02730115f, 0.01703659f, 0.00591694f, -0.00699394f, -0.05561685f, 
    0.00295037f, -0.02707618f, -0.04728085f, -0.01663568f, -0.02124302f, -0.01138946f, 0.00382794f, -0.02455476f, 
    0.02395744f, 0.04530588f, 0.01706234f, -0.05952585f, -0.02102124f, 0.00967870f, -0.01066051f, 0.02311572f, 
    -0.27320406f, 0.12455274f, -0.23052043f, 0.38483641f, 0.06316486f, 0.11626089f, -0.04633789f, -0.00407072f, 
    -0.05391220f, -0.03202252f, 0.10846636f, -0.19074947f, 0.07549523f, -0.17127535f, 0.21861461f, 0.09623250f, 
    0.00922430f, -0.09051403f, -0.08695210f, 0.06825951f, 0.25320959f, 0.06992964f, 0.17994089f, 0.06218158f, 
    0.13873135f, -0.23462044f, -0.08306230f, -0.00010795f, -0.06506181f, -0.09890533f, -0.03296582f, 0.00269658f, 
    -0.01640612f, 0.15609963f, 0.01774379f, -0.05524446f, 0.03592920f, 0.07981958f, 0.06516630f, -0.04051663f, 
    0.16491792f, 0.07506616f, 0.14222282f, -0.03321813f, 0.13039373f, 0.01962619f, -0.03876057f, -0.06660610f, 
    0.10643186f, 0.10550250f, 0.52067435f, 0.40602434f, 0.06236295f, 0.07650400f, 0.12967576f, 0.18049169f, 
    -0.03348572f, -0.02445538f, -0.18442327f, -0.09310893f, 0.11305998f, -0.00723049f, 0.33916181f, 0.16334094f, 
    0.04198179f, 0.04637955f, 0.01959514f, -0.06014730f, 0.02449532f, -0.09373441f, -0.06115447f, 0.11042596f, 
    -0.12578951f, -0.18910374f, -0.02778788f, 0.05194878f, -0.08753246f, -0.08551128f, 0.12262332f, 0.22844549f, 
    -0.04877253f, -0.08882875f, 0.07681455f, 0.09185305f, -0.06268573f, -0.19769402f, -0.03295623f, 0.03999955f, 
    0.06059540f, 0.08808959f, -0.05250227f, -0.04220907f, 0.05880095f, -0.00864846f, 0.07116202f, 0.13894744f, 
    -0.14279284f, -0.10631774f, 0.02324791f, 0.01763743f, 0.01503213f, -0.03189658f, -0.01778192f, -0.09398930f, 
    0.24391353f, -0.08420203f, 0.11402982f, -0.14563432f, -0.25019234f, 0.15664896f, 0.19511801f, 0.31815606f, 
    0.09036463f, 0.15247142f, 0.00565187f, 0.06036143f, 0.19394255f, -0.01729612f, -0.01807840f, -0.02595861f, 
    -0.58907199f, 0.29603156f, 0.12210505f, -0.29084322f, -0.04766663f, -0.04182926f, 0.02450641f, 0.10080260f, 
    0.01888663f, 0.13024455f, -0.08068384f, -0.01247746f, -0.28255561f, -0.00060936f, 0.18130615f, 0.11352288f, 
    0.03281186f, 0.07692325f, -0.02301075f, -0.06017042f, 0.05625122f, -0.09910494f, 0.04960544f, -0.04218652f, 
    -0.43069467f, 0.36586961f, -0.13477708f, 0.09672067f, 0.05928481f, 0.05044942f, -0.09404824f, -0.07148644f, 
    0.02110487f, -0.07569532f, 0.08673402f, -0.02370847f, 0.32429796f, -0.08623023f, 0.16065174f, 0.20625587f, 
    0.00541043f, 0.04721238f, 0.01516784f, -0.09716617f, 0.24883294f, -0.01964642f, 0.01323468f, -0.09103090f, 
    -0.35718122f, -0.06041400f, 0.16022287f, 0.03852758f, 0.10245448f, -0.03664429f, 0.04096743f, 0.07571443f, 
    0.26472065f, -0.03917225f, -0.17330773f, 0.03938105f, 0.12437004f, 0.03341353f, 0.00072946f, 0.21231288f, 
    -0.09124766f, -0.08697435f, 0.24592897f, 0.19142498f, 0.13005744f, -0.03676110f, -0.00317367f, 0.04888591f, 
    0.03957236f, 0.11293322f, 0.04158167f, 0.20736168f, 0.08898512f, 0.06414587f, 0.09311750f, 0.08452106f, 
    -0.00856173f, 0.00923919f, 0.02576980f, -0.04755237f, 0.10293362f, -0.13623184f, 0.09203476f, 0.30546972f, 
    0.11270097f, 0.10455328f, -0.09177574f, -0.06053407f, 0.14865276f, -0.00215658f, -0.08415813f, 0.20374200f, 
    -0.25555035f, 0.10732362f, 0.13827120f, -0.07979533f, -0.11912329f, 0.05792803f, 0.07677265f, 0.28279683f, 
    -0.15103231f, 0.01884966f, -0.04671514f, -0.05111589f, -0.12508816f, -0.09648719f, -0.10834470f, -0.10564374f, 
    0.05439021f, 0.01662311f, -0.00806500f, 0.02512393f, 0.13869092f, 0.05776563f, 0.09508449f, 0.08536197f, 
    -0.24375507f, 0.02128936f, 0.07904863f, 0.05360238f, -0.07400504f, -0.06015296f, 0.01503185f, 0.08101223f, 
    0.01320550f, 0.02686913f, 0.02570884f, 0.06311019f, 0.19345875f, -0.00687160f, -0.08914316f, 0.17947775f, 
    -0.11357589f, 0.04132427f, 0.02018142f, 0.04890462f, 0.07709542f, 0.02253214f, -0.19992283f, 0.05614712f, 
    0.01373432f, 0.29375041f, -0.17513092f, 0.17576705f, 0.07475892f, 0.02697485f, 0.11011770f, -0.09496213f, 
    0.23183626f, 0.13568999f, 0.02293371f, 0.14129701f, -0.18732832f, -0.05895238f, -0.08053113f, 0.12755255f, 
    -0.16294043f, -0.12782991f, 0.03949159f, -0.04520676f, 0.02263054f, 0.04572656f, 0.06924661f, -0.01820115f, 
    -0.45624182f, -0.19452573f, 0.03742744f, 0.08238326f, -0.15985011f, -0.17451970f, 0.14116929f, 0.18819365f, 
    -0.15019569f, -0.20019984f, -0.13868655f, 0.03083554f, 0.16116744f, -0.23933762f, 0.04558936f, -0.08031759f, 
    0.00701992f, -0.03392487f, -0.05403411f, 0.06447611f, -0.13900490f, 0.04037641f, -0.18682976f, 0.21083041f, 
    0.40870255f, -0.15794729f, 0.12092458f, -0.04040876f, -0.04060893f, -0.07023749f, 0.00904414f, 0.05576983f, 
    0.13691381f, -0.04354737f, 0.02255033f, -0.03093280f, -0.11118238f, 0.14743507f, 0.14740986f, 0.13176674f, 
    0.00095583f, 0.06540839f, -0.17089829f, -0.01358684f, 0.06326641f, -0.02169793f, 0.08496363f, 0.00623500f, 
    0.00150745f, -0.06117783f, -0.12052979f, 0.08517115f, -0.04473913f, 0.02176423f, 0.04643097f, -0.15454334f, 
    0.18329740f, -0.02083280f, 0.03913890f, -0.01217342f, 0.25295556f, -0.06683981f, 0.05333316f, -0.08196720f, 
    0.13157484f, 0.12567656f, -0.06361942f, 0.07578689f, 0.03259947f, -0.05684431f, 0.10772981f, 0.00383364f, 
    -0.14962262f, -0.15912253f, 0.10273308f, -0.05878422f, -0.03056468f, -0.03385389f, 0.00576698f, -0.03571245f, 
    0.10900741f, -0.07959736f, -0.06916613f, 0.10219598f, -0.12890023f, 0.11991466f, -0.00177501f, -0.17988105f, 
    -0.00332208f, -0.00400860f, -0.00726207f, -0.15246631f, 0.00807784f, -0.02017160f, -0.00634695f, 0.17430094f, 
    -0.00877779f, -0.02729630f, 0.01608637f, 0.01545485f, 0.03330743f, -0.02436469f, -0.00289532f, 0.00696364f, 
    0.00445755f, -0.03251924f, -0.04448922f, 0.01858018f, -0.01810581f, 0.03029769f, -0.04129669f, -0.00206530f, 
    -0.01447847f, -0.03314264f, 0.01561761f, -0.00969053f, -0.00967259f, 0.05097009f, 0.01798083f, -0.04310793f, 
    0.00271154f, 0.02028375f, -0.02353936f, -0.01028932f, -0.05219402f, -0.03475323f, -0.02230104f, 0.01993201f, 
    -0.01661048f, 0.02151959f, -0.03168868f, 0.00079171f, 0.03021347f, -0.04084430f, 0.03910838f, -0.00582228f, 
    -0.00876929f, -0.01728950f, -0.00329204f, -0.00702170f, -0.00271642f, -0.02474870f, -0.04510230f, -0.02272931f, 
    -0.05770599f, 0.03805757f, 0.03059994f, 0.01789627f, 0.01024274f, 0.01131536f, -0.02449322f, 0.00222428f, 
    -0.05675835f, -0.05367113f, -0.03412407f, 0.04941442f, 0.03622709f, -0.01138830f, 0.00680781f, -0.05548312f, 
    -0.04458597f, -0.00743108f, 0.01902153f, 0.03919183f, 0.03231911f, 0.00685602f, -0.00105503f, 0.03512636f, 
    0.03548847f, -0.00829427f, 0.00823448f, -0.05379584f, -0.03997044f, -0.03581684f, -0.03216160f, -0.00809398f, 
    -0.01157569f, -0.02746710f, 0.00626453f, -0.03478328f, -0.03482602f, 0.02788816f, 0.00340789f, 0.03238924f, 
    -0.03488903f, 0.04214900f, 0.03962465f, 0.01726236f, -0.03352342f, -0.01352063f, -0.01337880f, -0.03538258f, 
    -0.04962430f, -0.00706781f, -0.00885099f, -0.02980082f, 0.04813176f, -0.01341336f, -0.00184956f, 0.01048025f, 
    0.02262191f, -0.00545884f, 0.04006720f, 0.03539948f, -0.00939212f, -0.03920414f, 0.01900288f, -0.02056217f, 
    -0.04884606f, 0.02428009f, 0.05085076f, -0.00794917f, 0.04044655f, -0.02844049f, -0.00439681f, -0.02365485f, 
    0.01612574f, -0.02904554f, 0.04476872f, -0.05102142f, 0.02683042f, -0.00330742f, 0.00593891f, -0.00802537f, 
    -0.00198613f, 0.01070124f, -0.03723589f, -0.03658525f, -0.03685596f, 0.00728062f, -0.01724905f, 0.04548151f, 
    -0.03803356f, -0.03546070f, 0.02498317f, -0.03012160f, 0.00239526f, -0.00246103f, -0.02124918f, -0.00518497f, 
    -0.00495182f, 0.02063280f, -0.03766006f, -0.03677874f, 0.01934664f, 0.00503394f, 0.02376341f, 0.05664730f, 
    0.00300064f, -0.02676021f, 0.01142795f, -0.03895363f, -0.00927185f, -0.01110775f, -0.04471628f, -0.00385099f, 
    0.00162719f, -0.03429103f, -0.00686550f, -0.00261078f, -0.02970678f, -0.01613737f, 0.01222066f, 0.02425868f, 
    0.04466982f, -0.03111231f, 0.01547001f, -0.03965607f, -0.04714814f, -0.02886251f, 0.00528896f, 0.00114872f, 
    0.03291395f, 0.01173512f, 0.01142157f, -0.05768786f, 0.00460458f, 0.01157934f, -0.01313539f, 0.00213592f, 
    -0.01065853f, 0.00225658f, -0.00908369f, -0.02122639f, -0.05457154f, -0.01840195f, 0.02858442f, 0.02635648f, 
    -0.03667226f, 0.04393784f, -0.05764366f, 0.04138076f, -0.04345358f, 0.03314498f, 0.03105216f, -0.03504380f, 
    0.02865190f, -0.04126950f, -0.01579281f, 0.03012944f, -0.01230240f, -0.04281184f, -0.01033500f, -0.02009349f, 
    -0.04131655f, -0.01698734f, -0.01873957f, -0.02255251f, -0.01797839f, -0.01262234f, 0.01194042f, -0.00481966f, 
    0.02046197f, -0.00510378f, -0.05251079f, 0.02683347f, 0.00472503f, -0.02918927f, 0.01034417f, -0.02764923f, 
    0.00559891f, -0.02207503f, -0.01286102f, -0.03225290f, -0.01900454f, 0.03188661f, -0.03888594f, -0.04802004f, 
    0.01470142f, 0.03470650f, -0.02187551f, -0.02589173f, -0.02393896f, 0.02814127f, 0.02152160f, 0.03173332f, 
    0.00941424f, -0.02558879f, -0.03714572f, -0.04957202f, 0.01696498f, 0.00280043f, 0.02331834f, -0.01212040f, 
    -0.00924277f, -0.01640999f, -0.01192600f, 0.02423494f, 0.02738316f, 0.03403507f, -0.00665061f, -0.02820786f, 
    0.00376631f, -0.04534901f, 0.01524158f, 0.02823170f, -0.02037745f, -0.03617003f, -0.05360211f, 0.02873394f, 
    0.04594642f, -0.01533023f, -0.03417862f, -0.01985411f, 0.02937367f, -0.03732032f, 0.00598179f, -0.01376805f, 
    0.00023632f, 0.04044796f, 0.02417222f, 0.01384769f, 0.01867085f, 0.03162413f, -0.01678356f, -0.04982788f, 
    0.03755044f, 0.01260926f, -0.02163125f, -0.05850276f, 0.04302867f, -0.03614322f, 0.00637637f, 0.03689942f, 
    0.02724133f, 0.02944278f, -0.05128864f, 0.02582100f, -0.02945175f, 0.00800358f, -0.02543791f, 0.02297505f, 
    -0.04610260f, -0.03834751f, 0.02616172f, -0.03741324f, 0.00449475f, -0.02542749f, 0.03255533f, -0.00030472f, 
    0.03251450f, -0.01073968f, -0.05516693f, -0.04592418f, 0.04115979f, -0.01148673f, 0.01788741f, -0.01644753f, 
    -0.01013962f, 0.00613514f, -0.00014009f, -0.01319832f, -0.04441953f, 0.00795533f, -0.05577042f, 0.03202395f, 
    -0.00562382f, -0.04491323f, 0.00453608f, -0.04497746f, 0.04144464f, 0.00554522f, -0.02941970f, -0.05221605f, 
    0.03467057f, 0.04876012f, -0.02315548f, -0.00260020f, -0.04501260f, 0.03653705f, -0.04152115f, -0.04042004f, 
    0.05388065f, -0.04054064f, -0.02413398f, 0.00465593f, -0.02799479f, -0.04207739f, 0.03780336f, -0.03118979f, 
    -0.03987022f, 0.03876235f, -0.05498842f, 0.00216071f, 0.03602391f, -0.02615288f, -0.02121676f, -0.05337885f, 
    -0.02355705f, -0.05745855f, -0.00212207f, 0.01412640f, -0.01963838f, -0.03395976f, 0.03669525f, -0.05712307f, 
    -0.00089807f, -0.04817228f, 0.01317276f, 0.00693326f, -0.02592958f, -0.00546893f, 0.01309442f, -0.01614100f, 
    -0.01364776f, 0.02677543f, -0.04685393f, -0.03105764f, 0.04461108f, 0.00626835f, 0.00677922f, 0.04434708f, 
    0.03141220f, 0.00934139f, -0.04792618f, -0.03497338f, -0.05380269f, -0.01541784f, -0.01457359f, -0.02372715f, 
    -0.34464148f, 0.06796942f, 0.26571661f, 0.13306803f, 0.04833479f, -0.05092179f, 0.09543030f, -0.01025190f, 
    0.01310254f, -0.06619167f, -0.16040640f, 0.17090507f, 0.12812786f, 0.02354595f, -0.18549290f, 0.10532832f, 
    0.10535391f, 0.02868634f, 0.03342674f, -0.18611696f, -0.16747731f, -0.09229932f, -0.06481507f, -0.12266794f, 
    0.03305200f, 0.43779349f, -0.13190345f, 0.02940442f, 0.07003382f, 0.01892641f, -0.01337256f, -0.05623996f, 
    0.03603074f, 0.03979831f, 0.10959499f, -0.12094469f, 0.12748326f, -0.20829915f, -0.04592202f, 0.15687928f, 
    -0.15371129f, 0.15682252f, 0.09519884f, 0.35990128f, -0.04766895f, 0.06971105f, 0.09093451f, -0.00963973f, 
    -0.18992676f, -0.21374235f, -0.10960757f, -0.07593000f, -0.09381188f, -0.02049282f, 0.04811449f, 0.02987798f, 
    -0.09314062f, 0.00178647f, -0.02702611f, -0.05979859f, -0.00327620f, 0.02712659f, -0.24497311f, 0.09214469f, 
    0.01265472f, 0.02223183f, 0.15269354f, 0.21606062f, 0.08187220f, 0.07286461f, 0.03093528f, -0.06081055f, 
    0.06387924f, -0.04004000f, -0.19488919f, -0.07310827f, 0.20358856f, -0.06986649f, -0.03892321f, -0.21310544f, 
    0.11086175f, 0.06243090f, -0.11528844f, 0.03969799f, -0.18552080f, 0.25456828f, -0.09045348f, -0.08341644f, 
    0.01912623f, -0.08342022f, 0.05275935f, -0.17195404f, 0.03962644f, 0.04458536f, 0.10116117f, -0.03611208f, 
    -0.11581882f, 0.01751348f, -0.00363209f, 0.08426312f, -0.16014156f, -0.02947187f, 0.00572589f, 0.01576111f, 
    -0.10075241f, 0.10496271f, -0.15451123f, -0.12167720f, 0.08826720f, -0.10694150f, 0.05490231f, 0.08214448f, 
    -0.05185733f, -0.11028786f, 0.09260393f, 0.07003016f, -0.09030854f, 0.09148703f, 0.04151812f, 0.09196584f, 
    0.50266457f, 0.25760081f, 0.16666387f, 0.11091302f, -0.00598658f, 0.08107538f, -0.03528513f, -0.11683663f, 
    0.00806004f, -0.01605957f, 0.18500122f, 0.08536687f, -0.42889071f, 0.02351936f, -0.14749667f, 0.10130336f, 
    -0.02982090f, -0.21736969f, 0.11216795f, -0.08374346f, -0.00876501f, 0.08214360f, -0.07294817f, 0.04732644f, 
    -0.20422858f, -0.03211081f, 0.43918887f, 0.25223252f, -0.05945857f, -0.01788433f, 0.01817581f, 0.10749786f, 
    -0.07005247f, -0.05482945f, -0.07737622f, -0.00196650f, -0.16506717f, 0.07864255f, -0.04824179f, 0.07962666f, 
    0.01135165f, -0.14545538f, 0.07433800f, 0.11875063f, -0.05255798f, 0.25498325f, -0.06127883f, 0.20628586f, 
    0.08722711f, -0.13481966f, -0.09645663f, -0.12432198f, 0.00903288f, 0.06978448f, -0.43213892f, 0.05548894f, 
    -0.19120991f, -0.00363809f, 0.25321713f, -0.04878904f, 0.77224922f, -0.02962201f, -0.16077088f, -0.01645256f, 
    0.11935785f, 0.06758131f, 0.01841133f, -0.10047174f, 0.04928523f, -0.02094646f, -0.05071865f, -0.00730714f, 
    -0.18680646f, -0.07745103f, -0.08073436f, 0.08024948f, 0.18065378f, -0.01424687f, 0.06574588f, 0.18208599f, 
    -0.06065274f, 0.16279700f, -0.04155676f, 0.02192811f, 0.38690796f, -0.02266469f, 0.04301129f, -0.02980516f, 
    -0.04593457f, 0.05028011f, 0.10578491f, -0.11834954f, 0.09801505f, 0.09104750f, 0.00642936f, 0.12799890f, 
    0.06999215f, 0.18121476f, -0.02070311f, 0.02282133f, -0.00966461f, -0.02312652f, -0.01450890f, 0.01311988f, 
    0.07673882f, -0.18737939f, -0.06376442f, 0.02597064f, -0.08732745f, -0.06650715f, 0.05107640f, -0.21906687f, 
    -0.33724064f, 0.15115315f, -0.11066479f, -0.28584912f, -0.04596587f, 0.12979960f, 0.02052000f, -0.02279036f, 
    0.15465358f, -0.02426060f, -0.08301800f, -0.03127610f, -0.01798183f, 0.05002182f, -0.00665312f, 0.11801026f, 
    -0.00064343f, 0.00053879f, -0.09783004f, -0.00408529f, -0.15223543f, -0.08533990f, 0.02531816f, 0.02577698f, 
    0.02555787f, 0.13690358f, -0.09507222f, 0.17075187f, -0.12505327f, 0.06732357f, 0.07918489f, -0.00179756f, 
    0.04154963f, -0.21751690f, 0.28665403f, 0.06301562f, -0.08744169f, 0.04548037f, -0.06601048f, 0.10715844f, 
    -0.13246854f, 0.08906444f, -0.29164523f, 0.02232687f, 0.26839957f, -0.04031280f, 0.01782568f, 0.03397068f, 
    0.06160629f, 0.02507587f, 0.10495325f, 0.07257626f, 0.01613298f, -0.05620150f, 0.06096652f, 0.10568032f, 
    0.14611121f, -0.34234953f, -0.14536574f, 0.20380665f, 0.14570433f, -0.03610618f, 0.04887271f, -0.05186959f, 
    0.00753541f, 0.10563931f, 0.00041946f, -0.11048348f, 0.01862066f, -0.07463975f, -0.01618914f, -0.19065817f, 
    -0.06542538f, -0.01174172f, -0.03586634f, -0.05576594f, 0.07154867f, -0.15536430f, 0.03855394f, -0.13365394f, 
    0.21953300f, -0.13349162f, -0.19861358f, 0.04258783f, 0.13994257f, 0.00379948f, 0.05683873f, -0.09983964f, 
    -0.01509030f, -0.04173437f, -0.01357495f, 0.19066402f, 0.12863381f, -0.15000032f, -0.10884208f, 0.45320967f, 
    0.07163402f, 0.06706888f, 0.23798238f, -0.19167179f, 0.12137052f, 0.09404606f, -0.15370041f, -0.05062791f, 
    -0.20711534f, 0.09456530f, 0.12057537f, 0.00349377f, 0.03959997f, -0.08858687f, -0.01094662f, -0.02615643f, 
    -0.05676892f, 0.03507861f, -0.08564539f, -0.11916813f, 0.05708205f, 0.15518385f, 0.02183579f, 0.15368216f, 
    -0.04859515f, -0.12882768f, 0.04241874f, -0.20919134f, 0.09597988f, 0.20203340f, 0.09720339f, 0.07250249f, 
    0.01439925f, 0.15845035f, 0.20366940f, -0.15401290f, 0.02436274f, -0.07861598f, -0.14952560f, -0.26023644f, 
    0.05403527f, 0.17704073f, -0.01089438f, -0.01177957f, -0.22111346f, -0.02880099f, 0.00057881f, 0.24706742f, 
    -0.14420035f, -0.04378232f, 0.04226352f, -0.05205490f, -0.06647754f, 0.19467336f, -0.05321341f, -0.01269311f, 
    -0.03940529f, 0.02751531f, 0.02702610f, 0.03887029f, -0.05713245f, 0.01140885f, -0.00083993f, 0.00886147f, 
    0.01071449f, -0.05508257f, -0.02895622f, -0.02757891f, -0.02975252f, -0.05442157f, -0.06017625f, 0.00505839f, 
    0.00498682f, -0.02038593f, -0.01461492f, -0.00066827f, 0.00406486f, 0.00489940f, 0.03295991f, -0.00869564f, 
    0.00856999f, -0.05812222f, 0.01881768f, 0.02957290f, -0.02870979f, -0.04446758f, -0.02239801f, 0.01667349f, 
    -0.05973632f, -0.04540632f, 0.01972299f, -0.03579241f, -0.01977525f, 0.04193195f, 0.03339012f, -0.02712090f, 
    0.03337958f, -0.02332157f, -0.05428808f, 0.04037313f, -0.02575553f, 0.03256584f, -0.02644124f, 0.00402217f, 
    -0.01091208f, -0.00304741f, -0.02305855f, 0.02131598f, 0.02996378f, 0.00783533f, 0.02920515f, -0.02429872f, 
    0.00887652f, -0.03672042f, -0.00952543f, 0.00468849f, -0.03889859f, 0.04023542f, -0.01765063f, -0.02240190f, 
    -0.00691203f, 0.00009951f, -0.00669460f, -0.00239660f, -0.02996105f, -0.05337764f, 0.04262317f, -0.01369106f, 
    -0.01869542f, 0.00663723f, -0.03993899f, 0.01958503f, 0.02975848f, 0.00874983f, -0.05748780f, 0.03189281f, 
    0.01702999f, 0.00550567f, -0.03488432f, -0.02324685f, 0.02515106f, 0.00776642f, 0.03661694f, 0.03154054f, 
    -0.00341327f, -0.02634538f, -0.03703742f, 0.03589035f, -0.04802568f, -0.05084035f, 0.00918998f, -0.02184988f, 
    0.03963168f, -0.05347307f, -0.05010291f, 0.01683033f, -0.05569417f, -0.00930126f, 0.01385146f, -0.05948800f, 
    -0.02760812f, 0.02396035f, -0.02997955f, -0.00082886f, 0.02324307f, 0.02036265f, -0.01259428f, 0.02537288f, 
    -0.05445958f, 0.00778229f, 0.04060765f, 0.00757152f, 0.01279302f, -0.02531992f, 0.00666177f, 0.00447281f, 
    -0.03808773f, -0.00682503f, -0.01731263f, -0.01867276f, 0.03773917f, -0.02768934f, 0.00389976f, 0.03641022f, 
    -0.02367181f, -0.02493415f, -0.05029448f, -0.00246890f, 0.01333101f, 0.04042163f, 0.01971726f, -0.05363989f, 
    -0.00529120f, 0.00589151f, 0.04135742f, -0.03331380f, -0.02022870f, -0.05368223f, 0.00915941f, 0.02953365f, 
    -0.00416945f, -0.04033790f, 0.00631567f, 0.01367781f, -0.01661159f, -0.03335080f, -0.04049021f, 0.02155608f, 
    0.01116590f, -0.00684958f, -0.01797598f, -0.01130298f, -0.00255983f, -0.03922552f, 0.03543144f, -0.05335041f, 
    0.01103035f, -0.02119401f, -0.02201121f, -0.03152828f, -0.00236710f, 0.01996961f, 0.02683997f, -0.02281143f, 
    -0.01509844f, 0.01938234f, 0.01970705f, -0.04357512f, 0.00639049f, -0.00025427f, -0.03129717f, 0.02465914f, 
    -0.05246273f, -0.00009757f, -0.04023470f, -0.04170330f, -0.00679704f, -0.04972515f, 0.02278562f, 0.01258466f, 
    -0.03722497f, -0.01367748f, -0.02245103f, -0.03005449f, 0.00327644f, -0.00967892f, -0.04871809f, -0.00331968f, 
    0.03928769f, -0.03673153f, -0.02436204f, 0.03952657f, 0.02655347f, 0.01222215f, -0.01421807f, -0.00678325f, 
    -0.02011402f, 0.01726284f, -0.05378056f, 0.01233501f, -0.00663807f, -0.05799598f, -0.02520128f, -0.02351853f, 
    0.02488983f, -0.01716306f, -0.01748845f, -0.05652389f, 0.02949387f, 0.01982678f, 0.00396928f, 0.02227595f, 
    0.02902612f, 0.02738187f, 0.01876264f, -0.01845189f, -0.01129646f, -0.05934758f, -0.04283401f, -0.04823248f, 
    0.03280681f, 0.02834107f, 0.04024063f, 0.01141749f, 0.00648869f, 0.03372337f, -0.04289488f, -0.04792092f, 
    -0.05496131f, -0.04764868f, 0.00892132f, 0.00551990f, -0.05300308f, -0.03213231f, 0.01050999f, -0.03190335f, 
    0.01257635f, 0.00937776f, 0.00480184f, -0.01504402f, -0.02157525f, -0.00072474f, 0.00376797f, -0.02246304f, 
    0.02054475f, -0.05228095f, -0.00951435f, 0.00573373f, 0.01120103f, -0.04058807f, -0.01006016f, 0.02316916f, 
    -0.00847950f, -0.04460110f, 0.01138193f, -0.03826623f, 0.01556308f, -0.03069511f, -0.00499908f, -0.05023165f, 
    -0.03929641f, 0.03568274f, 0.02291629f, -0.03814877f, -0.04555669f, -0.00531354f, 0.01873144f, 0.02714194f, 
    -0.00689814f, 0.02084057f, 0.00533671f, -0.05158814f, -0.03965010f, -0.05794387f, 0.02289083f, 0.02850481f, 
    0.02997340f, -0.04345524f, -0.02249678f, -0.05044165f, 0.00791855f, -0.02315102f, 0.01284698f, -0.00140704f, 
    0.00415731f, -0.02241186f, 0.03739978f, 0.02394934f, 0.00967166f, 0.03656724f, -0.04046270f, 0.03319118f, 
    -0.03831619f, -0.05180739f, -0.01717074f, -0.00678057f, -0.05228561f, 0.01119946f, 0.03417785f, 0.00136642f, 
    0.04088641f, -0.01968219f, 0.03516566f, 0.00036455f, -0.02260902f, -0.04954187f, 0.02198002f, -0.00424244f, 
    0.02767206f, -0.02622032f, -0.05350288f, -0.01356163f, 0.04145542f, -0.03905603f, 0.02381731f, -0.00698232f, 
    -0.05303496f, 0.00879026f, 0.01764906f, 0.03744023f, 0.00047222f, -0.05371218f, -0.01090202f, 0.04116213f, 
    -0.03504262f, -0.02793708f, -0.04120156f, 0.00732198f, 0.04329670f, -0.00901218f, -0.02009436f, 0.04017730f, 
    -0.02493853f, -0.03063194f, -0.01199336f, -0.02792335f, -0.03278772f, 0.02598891f, -0.03928347f, 0.01503171f, 
    -0.03479622f, -0.04497500f, -0.04070534f, -0.05049005f, -0.02164330f, -0.02658886f, -0.01979411f, 0.00918783f, 
    -0.00051594f, 0.02328195f, -0.01865311f, 0.02822196f, -0.01628757f, 0.04065482f, -0.01968714f, -0.02146606f, 
    -0.03443657f, -0.00038130f, 0.03657228f, 0.00554319f, -0.00613579f, -0.01053254f, 0.00862482f, -0.00443366f, 
    -0.01431843f, -0.03601712f, -0.03306198f, -0.01776906f, 0.01480473f, -0.02785058f, 0.03037795f, -0.02487523f, 
    -0.00218390f, 0.00663569f, -0.00138983f, 0.03350361f, -0.01260051f, -0.05582193f, -0.04540319f, 0.04066812f, 
    0.01817360f, -0.01970604f, 0.01715381f, 0.03360575f, 0.03774776f, 0.00488760f, 0.01486112f, -0.03632125f, 
    0.03112468f, -0.04254485f, -0.01729343f, 0.03027471f, -0.01830726f, -0.00335341f, 0.02358466f, 0.02889892f, 
    -0.03975744f, -0.05007567f, -0.05056218f, -0.01450068f, 0.00026537f, -0.03963906f, -0.02737396f, -0.00934028f, 
    -0.04811030f, 0.00900675f, -0.03122284f, 0.03982830f, 0.00466477f, 0.02582603f, -0.01951458f, 0.01478797f, 
    -0.01906033f, 0.03835193f, -0.01869559f, -0.02782701f, -0.00798981f, 0.00277677f, -0.00736308f, -0.05376223f, 
    0.02600966f, 0.01992530f, -0.04019326f, -0.05147751f, 0.01792436f, 0.00643339f, 0.00499779f, 0.02905821f, 
    0.03063103f, -0.01757873f, 0.03325434f, -0.01580571f, -0.03852029f, -0.01404118f, -0.03554128f, -0.04148849f, 
    -0.00052631f, -0.02076016f, 0.01459622f, 0.03377547f, -0.05561683f, 0.02990259f, 0.04322963f, -0.02553293f, 
    -0.03165741f, -0.05225803f, -0.04806350f, 0.02018131f, 0.02692997f, 0.00428069f, -0.05196477f, -0.01384192f, 
    0.02578760f, 0.02790009f, 0.03521850f, -0.01998833f, -0.03509667f, 0.03769176f, -0.02407089f, -0.03711606f, 
    0.03891099f, -0.05272333f, 0.01771306f, -0.00060643f, -0.05007105f, 0.04062002f, -0.03065985f, -0.01683492f, 
    0.01152985f, -0.01523139f, 0.03358539f, -0.04526049f, -0.00343486f, -0.04778149f, 0.02404447f, -0.05366671f, 
    -0.05742925f, 0.03320066f, -0.01542464f, -0.01740106f, -0.05398387f, -0.02718062f, 0.00177399f, 0.02141854f, 
    -0.00559706f, -0.04282636f, 0.02575126f, 0.01958999f, -0.03089666f, 0.02150900f, -0.03198924f, -0.00024411f, 
    -0.03291710f, -0.04823917f, -0.02733283f, -0.01101703f, -0.02706445f, -0.05721378f, 0.00418314f, -0.02233138f, 
    -0.03726575f, -0.04752751f, -0.00147266f, 0.00228366f, 0.00137833f, 0.03831246f, 0.03618509f, 0.02821893f, 
    0.04097839f, 0.00029454f, -0.00330778f, -0.01150016f, 0.02456186f, 0.03670160f, 0.03919644f, 0.01375689f, 
    0.01260776f, -0.05473036f, -0.04610125f, 0.01715271f, -0.01095569f, -0.04772132f, -0.01941158f, -0.02015872f, 
    0.01777372f, -0.03778461f, -0.05387377f, -0.01141907f, -0.03245820f, 0.01253113f, 0.04012661f, -0.02792468f, 
    -0.02811659f, 0.03406053f, 0.04063554f, -0.01604773f, -0.05481624f, -0.00963131f, -0.00038290f, -0.00116055f, 
    -0.01039222f, -0.03808319f, 0.03937150f, -0.02510739f, -0.02599109f, -0.01919167f, 0.01930963f, 0.00584142f, 
    -0.01168144f, 0.00469430f, 0.02092276f, -0.04225326f, -0.04615346f, -0.04465802f, -0.01833825f, -0.05173848f, 
    -0.01891574f, -0.01158105f, -0.02096606f, 0.00132748f, -0.02669083f, 0.00372160f, -0.02591422f, 0.01301364f, 
    0.04198061f, 0.00249968f, 0.04842996f, -0.03287230f, -0.02082557f, 0.03508729f, -0.02298016f, 0.01261961f, 
    -0.05666390f, -0.05071440f, -0.05061005f, -0.02976166f, -0.00661787f, -0.03380717f, -0.01175011f, 0.03234127f, 
    -0.04897516f, 0.01169256f, 0.01652934f, 0.01033076f, -0.04012811f, 0.00978760f, 0.02730726f, 0.00143567f, 
    -0.01638846f, 0.02151285f, -0.01076840f, 0.01827724f, -0.02718020f, -0.01781287f, -0.02090061f, -0.03221352f, 
    0.03708996f, -0.04236765f, 0.01270313f, 0.04097696f, -0.05381128f, 0.02035663f, -0.02520845f, -0.01816893f, 
    -0.01654818f, 0.01243487f, -0.01917465f, 0.04010417f, -0.03898973f, -0.05464084f, -0.00485626f, -0.03355155f, 
    -0.03403289f, -0.02724762f, 0.03557296f, -0.02829645f, 0.00445336f, -0.01001360f, -0.02285144f, -0.00198974f, 
    -0.01898087f, -0.00511797f, -0.04632596f, 0.00298051f, 0.04142424f, -0.02679172f, -0.05403971f, 0.03257069f, 
    0.00096557f, -0.04658326f, 0.02950626f, -0.02110676f, -0.04105505f, 0.02018737f, -0.03179564f, 0.00808901f, 
    0.02021163f, 0.01485267f, 0.04335604f, -0.02479981f, 0.00677422f, -0.01025457f, -0.05185419f, 0.00460385f, 
    -0.01311023f, -0.03477841f, 0.03174538f, -0.02829282f, 0.01234218f, 0.01209533f, -0.05047571f, -0.01734075f, 
    0.01829924f, 0.00004974f, 0.04020225f, -0.04540827f, -0.02363400f, -0.01958430f, -0.00437226f, 0.01353864f, 
    -0.03376078f, -0.01738174f, -0.03810105f, -0.03810780f, -0.03910008f, -0.04766481f, 0.03759004f, -0.02248633f, 
    0.02065206f, 0.04548297f, 0.04134408f, 0.02261153f, -0.01097539f, 0.04071879f, 0.04072871f, -0.03044352f, 
    0.02822898f, 0.01536306f, 0.00007628f, 0.00956940f, 0.02102621f, 0.01632781f, -0.01198252f, -0.03480275f, 
    0.04399776f, 0.01404117f, 0.04286167f, 0.04117342f, -0.00425675f, 0.04420210f, -0.03487144f, 0.02380779f, 
    -0.03836571f, 0.03890934f, 0.01767597f, -0.02589901f, -0.01212328f, 0.00696668f, -0.00462678f, -0.03083621f, 
    0.03284317f, -0.03058916f, 0.04062164f, -0.00797036f, -0.04628218f, -0.05389202f, 0.02693091f, 0.02244000f, 
    0.03613068f, -0.05144414f, -0.04463328f, 0.02025701f, -0.01327938f, -0.01663643f, -0.04258278f, -0.02170818f, 
    0.01555585f, -0.01982780f, 0.02444366f, 0.01148080f, -0.01710998f, 0.02334822f, 0.02337220f, 0.01363752f, 
    -0.05283899f, -0.03872009f, -0.00804689f, 0.04034782f, -0.00106901f, 0.00570807f, -0.00767200f, 0.00387565f, 
    0.01108410f, -0.00533102f, 0.04311905f, -0.01631532f, 0.02665982f, -0.01346746f, -0.03548470f, 0.02482037f, 
    -0.02297907f, 0.02479314f, -0.02920508f, 0.00133145f, -0.00386576f, -0.05150938f, -0.02442273f, 0.00136132f, 
    -0.04999913f, -0.03221195f, -0.03837965f, -0.02874777f, 0.03938771f, 0.01591666f, 0.02304377f, 0.01431851f, 
    -0.02586931f, -0.02311459f, 0.04386242f, 0.03363998f, -0.00368275f, 0.02523117f, -0.00891862f, -0.02450557f, 
    -0.00977639f, 0.01545417f, 0.02000489f, 0.02768354f, 0.03603639f, 0.01660293f, -0.01881762f, -0.05096385f, 
    -0.00814561f, 0.02175206f, -0.03322544f, -0.01772402f, -0.01318068f, 0.03405672f, -0.03187541f, -0.04161744f, 
    0.04557347f, -0.05248309f, -0.01436597f, -0.00234661f, 0.01214137f, -0.03892071f, 0.00347072f, 0.00161222f, 
    -0.00330347f, -0.04688203f, -0.02567803f, 0.03429518f, -0.01312210f, 0.02829056f, -0.02551435f, -0.03819115f, 
    -0.03176126f, 0.02051498f, 0.01210366f, 0.03836831f, -0.02787763f, -0.05557538f, 0.01705324f, -0.02920700f, 
    -0.03784224f, -0.04040153f, 0.03483795f, 0.04346824f, -0.02845690f, -0.00041727f, 0.03744174f, -0.02839001f, 
    -0.00996258f, -0.02502801f, -0.04449202f, 0.02737818f, 0.02667154f, -0.04451245f, 0.01026553f, 0.03867363f, 
    -0.00246488f, -0.01542921f, 0.03888709f, -0.00029628f, -0.04135083f, -0.04989900f, -0.02451700f, -0.00483378f, 
    -0.04208154f, -0.05037223f, -0.01230239f, 0.00952064f, -0.02583708f, -0.01101857f, 0.03144732f, -0.00495319f, 
    -0.03599933f, 0.04724379f, 0.03520005f, 0.01958305f, -0.01910647f, -0.00447055f, -0.01316955f, 0.03615110f, 
    -0.00622363f, -0.01969836f, 0.02042065f, -0.01085438f, 0.02865455f, -0.01191199f, 0.03170693f, 0.01673568f, 
    0.03168911f, -0.04563432f, -0.03942160f, -0.02356103f, 0.02725289f, -0.00572766f, -0.03055018f, -0.02691313f, 
    -0.02999085f, -0.00517839f, 0.01881181f, -0.03240725f, 0.04050080f, 0.04097781f, -0.01902001f, -0.02347843f, 
    -0.00376238f, -0.00609260f, -0.02006979f, 0.03559838f, 0.04425985f, -0.04616384f, -0.03729709f, -0.00852303f, 
    0.00753703f, 0.02070512f, -0.01464012f, -0.01048163f, -0.04911051f, 0.04388643f, -0.02953632f, 0.00062995f, 
    -0.02222840f, 0.03095840f, 0.01314281f, 0.03230193f, 0.03440563f, 0.00125620f, -0.03231268f, -0.03182767f, 
    -0.04281636f, 0.03097460f, 0.01900698f, -0.01728950f, -0.03408436f, 0.00534543f, 0.03861205f, -0.05411561f, 
    0.01236650f, 0.03878153f, -0.03540698f, 0.02326681f, 0.01408308f, 0.03018914f, -0.04507441f, -0.02493641f, 
    -0.01242007f, 0.00267451f, -0.05041841f, 0.01469762f, -0.01071950f, -0.02311886f, -0.03746048f, -0.00714061f, 
    0.00795335f, 0.00277551f, 0.04444264f, -0.03966730f, -0.00238620f, 0.03329170f, 0.02082393f, -0.04672747f, 
    0.01389876f, 0.01640507f, -0.05010318f, 0.01981924f, -0.04113480f, -0.05531131f, -0.01723137f, -0.05390037f, 
    0.04216978f, -0.04642804f, -0.00741431f, -0.05615885f, 0.03594451f, 0.03969123f, -0.03974790f, 0.04994340f, 
    -0.04054288f, -0.01334082f, -0.04664880f, 0.03239004f, -0.03258234f, -0.01978357f, 0.01271110f, -0.01205618f, 
    0.00192629f, -0.03758980f, -0.02368816f, 0.01142034f, -0.01755065f, -0.04533838f, -0.05296250f, -0.01929601f, 
    -0.03042638f, 0.03041380f, 0.01530675f, -0.00906394f, -0.02654531f, -0.02977021f, 0.02841242f, -0.00040504f, 
    0.02659366f, -0.04349257f, 0.03776914f, -0.03909968f, -0.04209501f, -0.04710191f, -0.02100726f, 0.03757273f, 
    -0.04608711f, 0.02744253f, -0.02000037f, 0.01605916f, -0.02751538f, -0.04423809f, -0.02374669f, 0.00637517f, 
    0.02446432f, 0.00302774f, -0.01595319f, 0.03766444f, -0.00664969f, -0.01804828f, -0.04741871f, 0.04525921f, 
    -0.02541942f, -0.04311937f, 0.00407605f, -0.00954238f, -0.04749134f, -0.03566329f, 0.01273815f, -0.00372666f, 
    0.00134557f, -0.02358314f, 0.00936916f, 0.01214639f, -0.05580015f, -0.03833879f, 0.00528340f, 0.03594966f, 
    0.03142019f, -0.00971523f, 0.04027514f, 0.04511500f, -0.01026895f, 0.00164695f, -0.03067919f, -0.00204847f, 
    -0.03510914f, -0.03296320f, 0.02896505f, 0.02478783f, -0.01119162f, 0.02864699f, -0.04349425f, -0.00648791f, 
    -0.02022044f, -0.01404110f, 0.03215995f, 0.02328152f, 0.01136959f, -0.00585881f, 0.02455897f, 0.00645403f, 
    -0.01615186f, 0.00308774f, -0.02368823f, -0.04229889f, 0.02949552f, -0.04528258f, 0.02301142f, -0.02096384f, 
    -0.03272131f, -0.04855359f, -0.05355798f, -0.04168229f, 0.04005447f, -0.03357380f, -0.04894636f, -0.02215628f, 
    -0.05048040f, -0.00046350f, 0.00376345f, -0.04539674f, 0.03592305f, -0.04815255f, 0.00012687f, 0.03561350f, 
    -0.01654181f, -0.00760370f, 0.01587791f, 0.01216380f, -0.02445748f, -0.03874603f, -0.04898392f, 0.03125167f, 
    -0.00755777f, 0.01035065f, -0.02749873f, -0.02583143f, -0.02532648f, 0.01854834f, 0.00527297f, 0.00861152f, 
    -0.03083528f, -0.01345123f, 0.02221315f, -0.03274864f, -0.01156462f, 0.04274469f, -0.04472868f, 0.03759180f, 
    -0.00101303f, -0.01260674f, 0.03127887f, -0.01994045f, -0.01668295f, 0.00618038f, 0.04205586f, 0.01461843f, 
    -0.02924086f, 0.03943738f, 0.02836259f, 0.00993368f, -0.03929960f, -0.03340724f, 0.03947506f, -0.03759561f, 
    -0.02571525f, -0.04587608f, 0.01822012f, 0.03719576f, -0.02873970f, 0.01551086f, -0.00195116f, -0.02925251f, 
    -0.01191264f, -0.02781623f, -0.02184768f, -0.01713445f, 0.01689005f, -0.02709553f, -0.00920682f, -0.00702543f, 
    -0.03163760f, 0.01650061f, -0.01813485f, -0.05093112f, -0.05054593f, -0.01329574f, -0.00824417f, -0.04276004f, 
    -0.04611998f, 0.00532531f, -0.04325563f, -0.01101400f, 0.04157567f, 0.01978185f, 0.02956043f, -0.00884032f, 
    -0.00973349f, -0.00430707f, -0.03685074f, -0.01956987f, 0.02583913f, -0.02080810f, -0.04094864f, 0.00862795f, 
    -0.04489437f, -0.01578352f, -0.04992119f, -0.02652023f, 0.01140918f, -0.02260893f, 0.00059330f, -0.01027622f, 
    -0.01489439f, -0.01602351f, 0.04230872f, 0.04158711f, 0.01382032f, 0.00253676f, 0.00979481f, -0.02083444f, 
    -0.50448924f, -0.16476624f, 0.40346819f, 0.10846879f, -0.00197834f, -0.01314370f, -0.33528602f, -0.19643873f, 
    -0.04959531f, -0.03281444f, -0.02836128f, 0.23064590f, 0.13802251f, 0.23343559f, -0.10767785f, -0.13502437f, 
    0.11253659f, -0.07875837f, -0.02072100f, 0.05925592f, -0.26585728f, 0.03037595f, 0.07571640f, -0.35200733f, 
    0.08547875f, 0.13594462f, -0.05319871f, -0.18457538f, 0.07964757f, 0.04435170f, -0.13387156f, -0.09347061f, 
    -0.08076217f, 0.02298122f, -0.02587056f, -0.27024814f, 0.06341184f, -0.20527245f, -0.00394887f, 0.00281309f, 
    0.22184142f, 0.18256107f, 0.18024001f, 0.16852066f, -0.03266974f, 0.09611304f, -0.01177722f, 0.02042420f, 
    -0.17505983f, 0.37247914f, -0.15026291f, -0.47164527f, -0.07584555f, -0.36622426f, -0.02454065f, 0.17178026f, 
    -0.08971129f, 0.02397631f, -0.02264840f, -0.16484484f, 0.05504835f, 0.15688360f, -0.03128982f, 0.00315251f, 
    0.03485998f, -0.08047318f, 0.22244306f, -0.10859309f, 0.08071744f, -0.08816715f, -0.06860390f, 0.04274315f, 
    0.25752994f, 0.18407679f, -0.21285185f, 0.06022766f, 0.11345875f, -0.07934836f, -0.03987699f, -0.10781746f, 
    -0.12460659f, -0.09005692f, -0.14607869f, -0.04610413f, 0.13542512f, 0.28513464f, -0.00950166f, 0.18013987f, 
    -0.13050525f, 0.10967024f, -0.04056425f, -0.17117524f, 0.02902971f, 0.17391223f, -0.00614328f, 0.34893730f, 
    -0.22597827f, -0.03111484f, -0.09744035f, 0.07352685f, -0.04830807f, 0.04241460f, -0.05991106f, -0.07531638f, 
    0.00381270f, 0.10182644f, -0.18554433f, -0.22883987f, -0.15449597f, -0.32090086f, 0.17709976f, -0.03882366f, 
    0.12422734f, 0.13064034f, -0.18179007f, 0.04854459f, -0.03771577f, 0.12256178f, 0.05154272f, 0.21880533f, 
    0.33258939f, 0.08232562f, 0.25061032f, 0.11278111f, 0.01738871f, -0.11074015f, 0.16376700f, -0.04577616f, 
    0.20260563f, 0.12969206f, 0.09878926f, -0.05787406f, -0.31415451f, 0.10987239f, 0.39624414f, 0.00440083f, 
    -0.15837051f, -0.20685476f, -0.26223311f, -0.18601039f, -0.07285564f, -0.10618369f, 0.03448238f, -0.06397137f, 
    0.17992164f, -0.01390191f, 0.32076088f, 0.25639844f, -0.10552840f, -0.05713157f, -0.34167486f, -0.05731026f, 
    0.08419519f, 0.08159053f, -0.19069210f, -0.04322984f, 0.16834530f, 0.04154529f, -0.32261187f, 0.18240263f, 
    0.01351051f, 0.35601699f, 0.31658641f, 0.10968567f, 0.11059061f, 0.15410870f, 0.05145207f, 0.15000418f, 
    -0.50507474f, 0.16443573f, -0.21499868f, 0.09963522f, 0.08237202f, 0.13286425f, -0.13180260f, 0.05772376f, 
    0.01385400f, 0.13092625f, 0.20186047f, 0.07440176f, 0.23691642f, 0.08331896f, 0.01709849f, 0.08557828f, 
    0.06449429f, -0.02984303f, 0.31020892f, 0.07326504f, 0.05310075f, 0.10776274f, -0.07231848f, -0.11205079f, 
    0.08032653f, 0.02582314f, -0.13340816f, 0.20189758f, 0.09758992f, 0.17744830f, -0.02056085f, -0.06033098f, 
    -0.05456406f, -0.03160247f, -0.11181366f, 0.11790256f, -0.15772837f, -0.36512721f, 0.00485636f, -0.17904660f, 
    0.00729726f, 0.18113412f, 0.10416586f, -0.02394287f, 0.16429938f, -0.01440731f, 0.01662694f, 0.11828077f, 
    0.36534077f, 0.23217185f, 0.16561253f, -0.00188465f, 0.23231275f, -0.14124550f, 0.26532930f, 0.00345005f, 
    0.03457358f, -0.04861088f, -0.08177810f, -0.13288875f, -0.13070254f, 0.06016198f, 0.06111428f, -0.03319636f, 
    -0.27507088f, -0.16008767f, -0.13554837f, -0.31754225f, -0.07796560f, -0.05673114f, 0.05504059f, 0.01229667f, 
    0.34024787f, 0.25386077f, 0.12082070f, 0.02677986f, 0.22322220f, 0.09610777f, 0.17243887f, 0.08842804f, 
    0.00096854f, 0.04645700f, -0.07606208f, 0.04714876f, 0.07319087f, -0.25886413f, 0.21487315f, 0.12270091f, 
    0.25040627f, 0.36236960f, 0.04718692f, 0.11842892f, 0.04925750f, 0.06871021f, -0.02094506f, -0.02392840f, 
    0.12119616f, -0.12127259f, 0.44248196f, 0.04765922f, 0.03411213f, 0.01832192f, -0.11475031f, 0.17669004f, 
    -0.15267259f, 0.01180428f, -0.33401853f, 0.07234595f, 0.29191685f, 0.25307643f, 0.22516625f, 0.19934510f, 
    -0.03776651f, 0.15179339f, 0.28605780f, 0.02722812f, 0.09713563f, -0.09148622f, -0.03484663f, 0.04491967f, 
    0.06792364f, -0.05335526f, -0.05343494f, 0.22473292f, 0.00677071f, 0.08294934f, 0.21184698f, -0.15785338f, 
    0.10137693f, -0.04788136f, -0.11584681f, -0.15628025f, -0.11129550f, 0.28124699f, 0.20268734f, -0.01908983f, 
    0.04352681f, -0.10468154f, -0.25595099f, 0.03010854f, 0.13301003f, 0.04591440f, -0.04434289f, 0.11702144f, 
    0.07301672f, -0.23076119f, -0.48097697f, -0.31661770f, -0.05528202f, -0.00339598f, 0.26242644f, 0.03696575f, 
    0.17583889f, 0.05021565f, -0.04045902f, 0.20061529f, 0.18934217f, 0.16495833f, -0.12638432f, 0.31758261f, 
    -0.15648137f, 0.01592159f, 0.28644970f, -0.02445455f, 0.03623334f, -0.00403337f, 0.04907943f, 0.19057554f, 
    -0.07630701f, -0.21683571f, 0.20167157f, 0.14226817f, 0.06823765f, 0.04368361f, -0.06406208f, -0.01851332f, 
    -0.04816600f, -0.21987335f, -0.19806524f, -0.30814469f, 0.14847261f, 0.21929906f, -0.11732721f, 0.03736409f, 
    -0.19242199f, 0.01810184f, 0.11372542f, -0.16686957f, 0.11192257f, 0.19068234f, 0.21977505f, 0.26397818f, 
    -0.08841964f, 0.41631079f, 0.14101368f, 0.04262312f, -0.10661609f, -0.06821293f, -0.20519882f, -0.13685790f, 
    -0.02361679f, 0.16134158f, 0.03437097f, 0.03035408f, -0.11334006f, 0.22169036f, 0.38104025f, 0.09081446f, 
    -0.08705927f, -0.16195485f, -0.10813244f, 0.04678067f, 0.06577166f, -0.06025613f, -0.09697726f, 0.32289746f, 
    0.34177354f, -0.01437318f, 0.34088933f, -0.15302032f, -0.00262860f, 0.04048315f, 0.19020350f, -0.03964978f, 
    -0.03810928f, 0.04196117f, -0.03114092f, 0.26746178f, -0.21090473f, 0.16564915f, -0.24472672f, -0.08145859f, 
    0.17632066f, -0.07572395f, -0.00484997f, -0.00594572f, -0.13492724f, 0.16153269f, 0.11163117f, -0.04700268f, 
    -0.08807880f, 0.10172144f, -0.14361194f, -0.30322880f, 0.05290098f, 0.01916423f, 0.10709916f, 0.05886368f, 
    0.30980596f, 0.07344281f, 0.20922707f, -0.03404287f, -0.30609891f, -0.20618996f, 0.04422621f, 0.11179503f, 
    -0.08436546f, -0.08501638f, -0.07584727f, -0.14157943f, -0.14486702f, -0.10665228f, -0.07165533f, -0.00351660f, 
    -0.34156886f, -0.07764479f, -0.19748314f, -0.47661540f, -0.03745351f, -0.25843719f, -0.18146120f, -0.15799789f, 
    -0.09483606f, -0.12075850f, -0.07551800f, -0.08715701f, -0.36406288f, 0.08269946f, -0.38362214f, 0.16320577f, 
    0.18023658f, -0.07487693f, 0.31907982f, 0.16474366f, 0.31961259f, 0.10444583f, 0.20308878f, 0.10545337f, 
    -0.02572576f, 0.02101161f, 0.00360934f, -0.12240060f, 0.02393254f, -0.12554382f, -0.17836811f, -0.15368399f, 
    0.03078377f, 0.10954875f, 0.10155084f, -0.09803884f, 0.20760785f, 0.00177447f, -0.07622787f, -0.04866166f, 
    0.00373540f, 0.00401005f, -0.02756899f, -0.01925655f, -0.01429300f, 0.04072470f, 0.11335612f, 0.00189244f, 
    -0.20096292f, 0.09014646f, -0.07331634f, 0.04581839f, -0.07580379f, -0.04369193f, 0.07019328f, 0.07752039f, 
    -0.21049683f, -0.03060877f, -0.14027700f, -0.01864041f, 0.19785057f, -0.40403154f, 0.13012287f, -0.37835619f, 
    0.01711426f, 0.00355338f, -0.14137818f, 0.07558210f, -0.25049159f, -0.02103398f, -0.13132763f, 0.05177077f, 
    0.11637087f, 0.07630081f, 0.14968753f, 0.30915251f, -0.05163784f, -0.01478473f, 0.14133039f, 0.05708154f, 
    0.08396889f, 0.16274066f, 0.25924757f, 0.20952840f, 0.32092503f, 0.06192145f, 0.51674157f, -0.19435625f, 
    -0.13006619f, -0.13776137f, 0.02735914f, 0.04168776f, -0.19452587f, 0.12460537f, -0.01395921f, -0.08177460f, 
    0.36082622f, -0.18115820f, 0.41982552f, -0.06961466f, -0.18612225f, -0.01401053f, -0.02403714f, 0.07088032f, 
    -0.00975606f, 0.14705145f, 0.08082476f, 0.27137566f, -0.14247565f, 0.07211179f, -0.02572495f, 0.13356122f, 
    0.03081429f, 0.22047403f, 0.08637121f, 0.22439398f, 0.07435358f, 0.27798852f, 0.11915666f, 0.17550637f, 
    0.07603247f, 0.20524512f, -0.09695853f, 0.17664500f, -0.04046937f, 0.21827959f, 0.09199531f, 0.15821181f, 
    -0.17081870f, 0.00340749f, 0.29534534f, 0.05990914f, -0.13478915f, 0.09353273f, 0.23837481f, -0.15464233f, 
    0.11002720f, 0.18538712f, 0.01900434f, -0.02667944f, -0.07082076f, -0.00764663f, -0.05574061f, -0.10313994f, 
    -0.11067852f, -0.10408146f, 0.03702078f, 0.05698129f, -0.01813481f, 0.00810702f, -0.11281479f, -0.00586898f, 
    0.05963752f, 0.15200347f, 0.08761411f, 0.14101796f, -0.52639234f, 0.13938184f, -0.20457216f, -0.08849008f, 
    0.00059492f, -0.21608636f, -0.03057151f, 0.06820015f, -0.02989657f, 0.06947423f, -0.11994089f, -0.09272761f, 
    -0.05786682f, 0.02714458f, -0.14798515f, 0.31640971f, -0.10668200f, 0.04160082f, 0.13398707f, -0.02644603f, 
    0.02335605f, -0.03838983f, 0.06714115f, -0.11330067f, -0.05627048f, 0.21886832f, -0.08732412f, 0.08970916f, 
    -0.06090225f, 0.06960130f, 0.05463066f, 0.02117682f, 0.06587067f, 0.15671876f, 0.05819761f, 0.01711264f, 
    0.08633886f, -0.05865698f, 0.04015256f, 0.27295434f, -0.00801728f, 0.08544274f, 0.15588753f, -0.06616891f, 
    -0.02642510f, 0.00754319f, -0.03174607f, -0.01288369f, -0.47405910f, -0.17291035f, 0.09532039f, -0.04443337f, 
    0.01594766f, -0.13017567f, 0.19227062f, 0.08055601f, 0.06774088f, -0.00232739f, -0.01671978f, 0.02286943f, 
    0.13763984f, 0.06833012f, 0.35178003f, -0.05540578f, -0.08378123f, 0.15944432f, 0.02362511f, 0.16753453f, 
    0.03531606f, 0.15071015f, 0.04231788f, -0.02895731f, 0.04612041f, -0.06600971f, 0.24177486f, -0.15189226f, 
    0.01368939f, 0.17434081f, -0.09824345f, 0.25532031f, 0.00015104f, -0.05731426f, -0.10931327f, -0.09684630f, 
    -0.01860944f, 0.08967723f, -0.02699053f, -0.20897163f, -0.06593197f, 0.08127798f, 0.02330580f, 0.07358868f, 
    -0.02895281f, -0.00612291f, -0.02612049f, 0.00253841f, 0.20590654f, 0.26183274f, 0.12130989f, 0.05469839f, 
    0.04686839f, 0.03906792f, 0.02577731f, -0.04219255f, 0.20479707f, 0.10076685f, 0.07111020f, -0.01377171f, 
    -0.50026947f, 0.12572286f, 0.03564020f, 0.09846395f, -0.12357551f, 0.08592263f, 0.02788337f, 0.13801701f, 
    0.03928689f, 0.16119647f, 0.14202632f, -0.06871369f, -0.22863430f, 0.04734195f, 0.32563564f, -0.17332520f, 
    -0.03491993f, 0.27452591f, 0.01719674f, 0.04148199f, 0.10736591f, 0.15080583f, 0.03938138f, 0.09459075f, 
    0.17207414f, -0.03700346f, 0.02699886f, -0.23003162f, 0.07644078f, 0.02445715f, 0.01885743f, 0.09334461f, 
    -0.05988157f, 0.09142298f, -0.01112506f, -0.12413084f, 0.11182662f, 0.03549127f, -0.28009984f, -0.02037602f, 
    0.00826073f, 0.01175488f, -0.13148175f, 0.00423442f, -0.00341232f, 0.15693501f, -0.03007069f, -0.02555618f, 
    0.29853934f, 0.55583674f, -0.10238517f, 0.32187760f, -0.04190372f, 0.04468305f, 0.05706224f, 0.09514274f, 
    0.00248912f, 0.01873587f, 0.08497608f, 0.25447452f, 0.18049586f, 0.24332887f, 0.17870583f, 0.37973282f, 
    -0.07595995f, -0.04032882f, -0.07979087f, -0.06788039f, -0.08633716f, -0.02194205f, 0.13682634f, 0.17483857f, 
    0.45143747f, -0.08310340f, -0.22420838f, 0.00178045f, 0.06559213f, -0.01583528f, 0.10323102f, -0.00660634f, 
    0.06182636f, 0.03560299f, 0.01570550f, -0.01012129f, -0.17744821f, 0.04737906f, 0.17970093f, -0.43023217f, 
    0.08625805f, -0.07233120f, 0.03538863f, 0.13161322f, 0.00197607f, 0.08308075f, 0.06739157f, -0.02742901f, 
    0.11473280f, -0.14556244f, -0.11435310f, -0.22227487f, -0.11316339f, -0.14277665f, 0.18186073f, 0.06510516f, 
    -0.02046235f, -0.03428191f, 0.12765487f, -0.10381363f, -0.19514154f, -0.07694519f, 0.05176513f, -0.05274779f, 
    0.16244611f, 0.06716065f, 0.03726412f, -0.24453475f, 0.02666860f, -0.07504242f, -0.03074318f, -0.01165186f, 
    -0.08885376f, 0.00134875f, 0.07077757f, 0.17613697f, 0.06101213f, 0.09832127f, 0.05003681f, -0.02512183f, 
    -0.08501651f, -0.06581540f, -0.05781883f, -0.02890411f, -0.10009428f, 0.10242386f, 0.07684202f, -0.05992262f, 
    0.04856250f, -0.03969592f, 0.09296449f, -0.09135068f, 0.16742225f, -0.09697230f, -0.06756886f, 0.04976775f, 
    -0.07714319f, -0.00268463f, 0.12370323f, -0.12614404f, -0.03761828f, -0.03854845f, 0.10327566f, 0.14202051f, 
    -0.12442125f, -0.08923885f, 0.07296011f, -0.14128551f, 0.25977141f, -0.28023374f, -0.05805747f, -0.04632598f, 
    0.01554807f, 0.04520654f, -0.04861337f, 0.16117100f, 0.08138977f, -0.03566183f, 0.09640166f, 0.30259293f, 
    -0.12131809f, -0.03397948f, -0.18850920f, 0.05354805f, -0.03597089f, 0.08354210f, -0.00824609f, 0.12182473f, 
    0.02995718f, -0.14099392f, 0.13771504f, -0.11319931f, -0.05637822f, -0.17234614f, 0.11737784f, -0.18457818f, 
    0.14384380f, 0.14349134f, 0.11605410f, 0.12196089f, -0.07511750f, 0.04540122f, 0.00788068f, 0.08465915f, 
    -0.57186860f, 0.36281800f, -0.14798160f, -0.00409053f, 0.02512199f, -0.07717532f, 0.11790661f, 0.12224532f, 
    0.10648247f, 0.16893981f, 0.10679445f, 0.00524516f, -0.19443034f, -0.04770797f, 0.33851889f, -0.14673127f, 
    -0.00701289f, 0.03615079f, -0.16921939f, 0.03076245f, -0.08094061f, -0.01805226f, -0.14926341f, -0.04980307f, 
    -0.01534538f, -0.08250313f, 0.16059977f, 0.11116578f, -0.10044177f, -0.00928978f, -0.23293318f, -0.05964660f, 
    0.05448696f, 0.16912580f, 0.24696946f, 0.20987542f, 0.22201298f, 0.07935361f, 0.12638421f, 0.22039872f, 
    0.15725955f, 0.21190569f, 0.09431981f, 0.11478877f, 0.22111627f, 0.19810446f, 0.16735783f, 0.08707341f, 
    -0.35278058f, 0.24237342f, -0.14593537f, 0.12370975f, 0.19710699f, -0.06659218f, 0.06993356f, -0.01452272f, 
    0.18773930f, -0.00177153f, 0.00299227f, 0.05646893f, -0.15419847f, 0.20029481f, -0.02197285f, 0.02580086f, 
    0.07581919f, -0.01029973f, 0.19730683f, 0.07299558f, -0.01453436f, -0.01707371f, 0.01121213f, 0.15315047f, 
    0.10160345f, 0.03117802f, -0.07389341f, 0.09910798f, -0.03467047f, 0.10943020f, -0.03027834f, -0.16374111f, 
    0.03085051f, -0.11005208f, -0.01516734f, 0.07186939f, -0.48420712f, -0.22127320f, -0.01583510f, -0.13610610f, 
    -0.07696330f, -0.12351275f, -0.03865133f, 0.13954222f, 0.13384701f, 0.33065960f, 0.04091826f, 0.04731374f, 
    -0.03216331f, 0.25985196f, -0.26638460f, 0.10664034f, -0.06994760f, -0.00671512f, 0.31200790f, 0.07340473f, 
    -0.12872966f, 0.06273957f, -0.05029564f, -0.10275271f, -0.37518051f, 0.05308037f, -0.31225100f, -0.16302767f, 
    -0.18701603f, -0.26144758f, -0.05511943f, 0.03359568f, -0.02743472f, -0.01890058f, -0.07050846f, -0.09373061f, 
    -0.06055808f, 0.16595531f, -0.04493884f, 0.13215895f, 0.08336712f, -0.02869373f, 0.09316380f, -0.03014214f, 
    -0.06135295f, 0.01908153f, -0.08915631f, -0.00266717f, -0.19856271f, -0.18055147f, -0.06906910f, -0.21062674f, 
    0.10080370f, -0.02107820f, 0.21269232f, 0.02339152f, 0.08042971f, -0.01001226f, -0.05795609f, 0.01401941f, 
    0.10873693f, 0.29651466f, -0.00440976f, 0.01111942f, 0.04605068f, 0.15933916f, 0.07039971f, 0.21825798f, 
    0.08211155f, 0.16761392f, 0.13714297f, -0.12707636f, -0.09817815f, 0.01869162f, -0.21358219f, -0.02642110f, 
    -0.11593129f, 0.12643018f, -0.07597931f, 0.07035119f, 0.03555729f, -0.04888815f, 0.03430347f, -0.09741460f, 
    -0.14335182f, -0.03532863f, -0.35396275f, -0.21337335f, -0.06286974f, 0.17952667f, -0.04772304f, 0.33134317f, 
    -0.05525880f, -0.14590271f, -0.03714176f, 0.04243363f, 0.03870634f, 0.04890420f, 0.25319728f, 0.06215229f, 
    0.01102173f, -0.02155791f, 0.13695627f, 0.05498425f, 0.22017825f, 0.02151546f, -0.00064661f, 0.19943124f, 
    -0.54955393f, -0.10115803f, 0.12257422f, -0.03055422f, -0.01569076f, 0.12906680f, 0.06452116f, 0.01426440f, 
    0.05645133f, -0.03646424f, 0.19026677f, 0.10120411f, -0.14223583f, 0.22598691f, 0.36706868f, -0.11184684f, 
    0.02996605f, 0.16275364f, -0.03002265f, -0.08438307f, 0.10607076f, 0.03471838f, 0.19513023f, 0.17875858f, 
    0.19868438f, -0.11195238f, -0.03448302f, -0.11967246f, -0.05829624f, 0.06123067f, 0.02191689f, 0.04417892f, 
    -0.02469007f, -0.02007363f, 0.05301523f, -0.23219481f, 0.30562145f, -0.03743500f, -0.18650147f, -0.17112660f, 
    -0.04483047f, 0.16799738f, 0.00336490f, 0.06438973f, 0.14502323f, 0.02740705f, -0.06038028f, 0.23025550f, 
    0.15082370f, 0.30347550f, -0.11715102f, 0.28312886f, -0.04742738f, -0.05092440f, 0.08497775f, 0.21572295f, 
    0.07000427f, -0.10632545f, 0.02947771f, 0.13472891f, 0.23828050f, 0.29798004f, 0.04443190f, 0.05904906f, 
    0.04488221f, -0.13193637f, -0.15249658f, -0.20081289f, 0.07072384f, 0.01768960f, 0.15351096f, 0.16742122f, 
    0.21705258f, -0.07460242f, -0.31636193f, -0.17667919f, -0.04693508f, 0.06796124f, 0.07831870f, 0.08857269f, 
    0.01182141f, -0.06675088f, -0.08118382f, 0.09024689f, -0.32196352f, 0.17647062f, 0.18612646f, 0.08370038f, 
    -0.11545685f, 0.05780178f, 0.02819360f, -0.01165402f, 0.02024243f, -0.06733026f, -0.16035655f, 0.08258606f, 
    -0.37654975f, -0.23197412f, 0.05803386f, 0.29786313f, -0.02587165f, 0.03784785f, -0.04357352f, 0.08632521f, 
    0.17671140f, -0.16978684f, -0.16525754f, 0.12504220f, 0.00311012f, 0.17400135f, 0.02750203f, -0.19859634f, 
    0.02520438f, 0.01887788f, 0.05362028f, -0.10745967f, -0.00531832f, -0.00351586f, -0.00590619f, 0.05489850f, 
    0.08478513f, -0.17390753f, -0.18973550f, -0.14672939f, 0.05686139f, -0.00085491f, -0.05159403f, 0.08532672f, 
    0.05666203f, 0.05182702f, 0.04767485f, -0.08639950f, -0.05913036f, -0.04927355f, 0.27529794f, -0.14885274f, 
    -0.02183904f, -0.09618638f, 0.05501562f, -0.12521493f, 0.19085516f, 0.03439761f, -0.06661083f, -0.19618092f, 
    -0.22484863f, 0.26932028f, 0.23789722f, 0.11257954f, -0.20310216f, 0.00740625f, -0.09464375f, 0.03347503f, 
    0.05602361f, -0.01084773f, 0.07580836f, -0.23049867f, -0.03017922f, 0.06816925f, 0.14825688f, 0.03757451f, 
    0.27787945f, 0.02781860f, 0.00142300f, 0.05309807f, -0.10438615f, 0.04274971f, 0.07256358f, 0.05556326f, 
    0.31128529f, -0.06751300f, -0.00882191f, -0.23840190f, 0.03920588f, 0.03305587f, 0.01787707f, 0.04795206f, 
    -0.00401432f, -0.17348978f, 0.26491249f, 0.04933576f, -0.13711718f, 0.16284294f, -0.34889111f, -0.18194717f, 
    0.00720594f, -0.05986046f, 0.26619729f, -0.10821088f, -0.08033150f, 0.00906541f, 0.00350891f, 0.06604780f, 
    0.78844947f, -0.47393754f, 0.34673002f, -0.12427985f, -0.05125536f, -0.08297145f, -0.03426807f, -0.01812600f, 
    0.19226983f, 0.25883546f, 0.15593138f, -0.04204361f, 0.00810411f, -0.18295357f, -0.44719231f, 0.10822416f, 
    0.01364173f, -0.04974184f, 0.06366763f, -0.03560692f, -0.13027625f, -0.03251772f, -0.07817464f, 0.07734579f, 
    0.47628909f, -0.11048924f, -0.06315693f, -0.39102209f, 0.00664051f, -0.13885634f, 0.11750276f, 0.03435475f, 
    0.16122431f, -0.18931912f, 0.04167100f, 0.15547420f, 0.06119323f, 0.25883132f, 0.14838287f, -0.10982378f, 
    0.10288885f, 0.04923393f, 0.00827160f, 0.17233829f, 0.10102994f, 0.01441502f, -0.19177994f, 0.17513511f, 
    0.60166824f, -0.23173542f, 0.09830835f, -0.25437671f, 0.05300936f, 0.01484575f, 0.13876617f, -0.16420455f, 
    -0.01691657f, 0.04302435f, -0.15610062f, -0.06646559f, -0.86408180f, 0.18304059f, 0.10592194f, -0.10973130f, 
    -0.01873140f, 0.09284058f, -0.00072598f, 0.05871568f, 0.02908475f, 0.09857174f, 0.03325542f, -0.01757500f, 
    0.23978050f, 0.00888986f, 0.10136333f, -0.22604533f, 0.00543776f, 0.13991518f, 0.04979572f, -0.10355115f, 
    0.03334761f, -0.05763499f, -0.08755677f, -0.07299887f, -0.24527648f, 0.17241642f, 0.33168769f, 0.03980077f, 
    -0.21601905f, -0.03616566f, 0.00531060f, 0.18678401f, -0.07992270f, 0.16776517f, 0.21326631f, -0.23604055f, 
    0.27697578f, -0.30503574f, 0.22055802f, -0.26966545f, -0.03799872f, 0.03595900f, -0.18105456f, 0.04915448f, 
    0.10108598f, -0.03080420f, 0.16949183f, -0.05767686f, 0.13075610f, -0.13775742f, 0.04999782f, 0.18780281f, 
    0.02578168f, -0.05501110f, -0.03957941f, -0.03503917f, -0.13624106f, -0.10540195f, -0.04465878f, 0.08734895f, 
    0.19591630f, 0.06280863f, 0.22337826f, -0.14176816f, 0.10647501f, 0.12858270f, 0.08073436f, 0.17164277f, 
    0.07059969f, 0.05220018f, 0.05122093f, -0.00470882f, -0.03076567f, 0.07802474f, 0.09408752f, -0.21816137f, 
    0.13160053f, 0.06254596f, 0.02693403f, 0.02867914f, 0.07840165f, -0.10248475f, -0.08144264f, -0.17871936f, 
    -0.40921339f, 0.10547252f, -0.00796030f, 0.08497844f, 0.06444336f, -0.15653609f, -0.09435040f, 0.18424211f, 
    0.07911441f, 0.05891960f, 0.19793618f, -0.01427674f, -0.08455405f, 0.06690326f, 0.10847042f, -0.12458332f, 
    0.02023837f, 0.03749756f, 0.03281317f, -0.05322859f, -0.00756984f, -0.01191945f, -0.01617100f, -0.17013721f, 
    0.24715523f, 0.22298314f, -0.00216817f, -0.37772030f, 0.09358919f, 0.16420151f, -0.18863291f, 0.09413987f, 
    0.20252736f, -0.08639298f, -0.07973073f, -0.16321798f, -0.03851238f, 0.10594886f, 0.08512585f, 0.22128680f, 
    -0.02632387f, 0.07535384f, 0.03899877f, -0.07305013f, 0.11725327f, 0.02017114f, 0.35236788f, 0.07441090f, 
    -0.20824519f, 0.16542383f, 0.55254459f, 0.21629892f, -0.10207263f, 0.09254592f, 0.01452400f, 0.10980076f, 
    -0.04763293f, 0.06688008f, 0.25155115f, -0.08022179f, -0.27407181f, 0.02425680f, -0.46638745f, -0.37120020f, 
    -0.01968452f, -0.14618929f, 0.39290527f, 0.14551033f, -0.05007134f, -0.05840827f, -0.21991938f, 0.18659174f, 
    0.25917989f, 0.02010007f, -0.09923820f, -0.02822675f, 0.07428641f, 0.00034332f, 0.02365138f, 0.06424674f, 
    -0.11630436f, 0.00265362f, 0.00144076f, -0.02700865f, -0.39032331f, -0.04667190f, 0.12682652f, -0.09447469f, 
    0.09526822f, 0.03687644f, 0.10932107f, -0.01845101f, -0.06777201f, 0.15082705f, -0.01418250f, 0.15302303f, 
    0.13717350f, 0.27364302f, 0.03356472f, 0.24451950f, 0.01544391f, 0.00743951f, -0.01724085f, 0.02942018f, 
    0.05749370f, 0.02643006f, 0.13508886f, 0.08344634f, 0.28627607f, 0.12255294f, -0.34198371f, 0.03355303f, 
    0.05734352f, -0.07065590f, -0.04082456f, 0.01860450f, 0.01510639f, -0.00036577f, 0.00118282f, 0.01038133f, 
    -0.13739127f, -0.28352094f, 0.34927979f, -0.02011191f, 0.05064308f, -0.16541587f, -0.10753123f, 0.00496573f, 
    0.05973412f, 0.15003566f, 0.05068455f, -0.01504429f, -0.16595425f, -0.40530121f, -0.21643834f, 0.19726223f, 
    0.04079564f, 0.00873269f, -0.01724895f, 0.09604602f, -0.07801975f, 0.03676536f, -0.01593130f, -0.07075264f, 
    -0.04905418f, 0.06058312f, -0.12626986f, -0.06803322f, 0.03320637f, 0.05515888f, 0.01949728f, -0.12422331f, 
    -0.26196516f, 0.19249791f, -0.18032277f, 0.30369937f, -0.20913650f, -0.47142246f, -0.05345844f, 0.24314737f, 
    -0.17748192f, -0.07139821f, -0.06645878f, -0.14455311f, -0.02429313f, -0.12710504f, 0.01100927f, 0.00274874f, 
    -0.22102843f, -0.55379575f, -0.32399905f, 0.42044359f, 0.00232593f, -0.18527195f, 0.05851880f, 0.18887858f, 
    -0.06012637f, 0.01378320f, -0.02038472f, 0.05830348f, 0.58060318f, -0.03018571f, -0.17287876f, -0.03360009f, 
    -0.07865350f, 0.04802153f, -0.17902012f, 0.35120744f, -0.20901184f, -0.22570339f, 0.21308950f, 0.22976775f, 
    0.02346682f, -0.18945184f, -0.06315410f, 0.10965350f, -0.08656742f, 0.01358077f, 0.09480624f, 0.13344534f, 
    -0.03975721f, -0.05579849f, 0.19187488f, 0.20478228f, 0.11956365f, 0.02306410f, -0.10271057f, -0.06597391f, 
    -0.08601887f, -0.05194298f, 0.06821597f, 0.00431554f, 0.12609147f, 0.08932275f, -0.07351623f, 0.13744119f, 
    -0.00469219f, -0.05598033f, -0.04279344f, 0.06543893f, 0.03112040f, 0.00031748f, -0.08754495f, 0.03337052f, 
    -0.18979953f, -0.10473616f, -0.19620183f, 0.01686194f, 0.33752501f, 0.08357499f, 0.18093850f, 0.24631926f, 
    -0.31558168f, -0.24973921f, -0.07781767f, 0.01950100f, -0.01077226f, 0.07633916f, 0.00887509f, 0.00978938f, 
    -0.75119340f, -0.45568296f, 0.23237593f, -0.26933196f, -0.08819159f, -0.00308669f, -0.02342506f, -0.00937412f, 
    -0.06153404f, -0.01156473f, -0.29986110f, -0.44514856f, -0.15248047f, -0.11074764f, 0.08298253f, -0.36043575f, 
    0.06576999f, -0.05439835f, 0.13129888f, 0.14862077f, -0.00187328f, 0.03876406f, 0.00370643f, 0.09192264f, 
    -0.37388492f, -0.44362351f, 0.05020015f, -0.30308980f, -0.04502425f, -0.04630773f, -0.04455877f, -0.01787070f, 
    -0.25038865f, 0.31892362f, -0.19712842f, -0.24515814f, -0.31357023f, -0.28163281f, -0.21697888f, -0.01446809f, 
    -0.02187415f, -0.06647786f, 0.11867148f, 0.01646797f, -0.16182478f, -0.40515247f, 0.46926138f, -0.62794280f, 
    -0.09537970f, 0.04473993f, -0.16115421f, 0.10909286f, -0.00691637f, -0.11307373f, -0.02917231f, 0.17333163f, 
    -0.14465538f, 0.27113968f, 0.25022539f, -0.07626734f, 0.22418806f, 0.44267371f, 0.40923661f, -0.14821815f, 
    0.05062305f, -0.05775888f, -0.37427300f, 0.31473565f, -0.14080711f, 0.01460117f, 0.00748689f, -0.11656702f, 
    -0.16401950f, 0.19433889f, -0.16632470f, -0.18054432f, -0.06895297f, -0.02278580f, -0.04444549f, -0.08611578f, 
    0.04752960f, -0.05479821f, 0.17937817f, 0.26778615f, 0.37584195f, -0.31314057f, -0.59033138f, -0.06037102f, 
    0.04594768f, 0.14504118f, 0.00246669f, -0.11741360f, 0.51476318f, -0.49303886f, -0.60412085f, 0.02864912f, 
    -0.09071860f, -0.22181243f, -0.08889253f, 0.01743368f, -0.16239835f, 0.01449138f, 0.06058257f, -0.15088680f, 
    0.01016419f, -0.03841255f, -0.07623938f, 0.15647274f, -0.00332738f, 0.07506097f, 0.06452328f, 0.06109566f, 
    0.07976425f, 0.14732783f, 0.12045513f, 0.08513226f, 0.14367214f, 0.17517816f, 0.27356479f, 0.19940047f, 
    0.06802476f, -0.24942800f, -0.16759588f, -0.17178218f, -0.08529840f, -0.00589585f, 0.07957140f, -0.05024535f, 
    -0.01199934f, -0.00528496f, -0.09662725f, 0.10699017f, -0.43282735f, -0.42139900f, 0.01601890f, 0.06566280f, 
    0.10660541f, -0.02672985f, 0.35816801f, 0.18366995f, -0.22900571f, -0.09201605f, -0.08359434f, -0.02621343f, 
    -0.25505495f, 0.05927197f, 0.00272230f, -0.19808900f, -0.05286764f, -0.09839221f, 0.08653232f, -0.16635613f, 
    -0.22118983f, -0.16542439f, 0.31186745f, 0.05990730f, -0.06370160f, -0.20896196f, -0.20796384f, -0.04833883f, 
    -0.12602484f, 0.00225091f, 0.15530761f, 0.36219406f, -0.06137935f, -0.04984673f, -0.01795581f, 0.07321873f, 
    -0.04121230f, -0.29396734f, 0.27616021f, 0.31036979f, 0.20705254f, 0.07596853f, 0.06499455f, 0.07362802f, 
    -0.20045674f, 0.07763922f, 0.19146544f, -0.08259397f, -0.32257271f, 0.06389660f, -0.17650445f, -0.15070985f, 
    -0.05697103f, 0.04332455f, -0.01649842f, 0.04638528f, 0.00050246f, -0.03403883f, -0.08079991f, 0.02791939f, 
    -0.14709590f, -0.04725775f, -0.18634951f, 0.16540843f, 0.04555894f, 0.16456437f, 0.00536500f, 0.17446223f, 
    0.28465438f, -0.39649719f, -0.35276476f, 0.13044485f, 0.08096046f, -0.09719485f, -0.18986091f, -0.26784599f, 
    -0.42645824f, -0.17983495f, 0.08555207f, 0.05246124f, 0.00055472f, -0.14326134f, 0.04904260f, -0.17554288f, 
    -0.21580148f, -0.05763836f, 0.03208186f, -0.02955397f, -0.03085395f, -0.04808732f, 0.02367982f, 0.00054869f, 
    -0.15193979f, -0.05351256f, -0.00145440f, -0.09066965f, 0.14155047f, -0.31852996f, -0.06622739f, -0.07717564f, 
    -0.11679191f, 0.05526295f, 0.06981836f, -0.01261353f, 0.08132583f, 0.01166337f, 0.08745874f, 0.03441336f, 
    -0.26959175f, -0.23933183f, -0.10982066f, -0.05418964f, 0.04440576f, 0.07268991f, 0.04476586f, 0.05590734f, 
    0.00047568f, 0.02367356f, 0.13133126f, 0.03211771f, -0.16710547f, 0.33421153f, 0.18081160f, -0.42469811f, 
    0.01541601f, -0.00441932f, 0.08348344f, 0.02973649f, 0.05653174f, -0.00391467f, 0.02660074f, 0.00741627f, 
    0.11547448f, 0.00590607f, 0.01732125f, -0.06413961f, 0.05871853f, 0.07027794f, -0.10202852f, -0.05681201f, 
    0.04836093f, -0.18815887f, 0.16159934f, 0.01866278f, 0.06473484f, 0.09305391f, -0.08403946f, 0.28477275f, 
    -0.04456006f, -0.11062174f, -0.23665673f, -0.03809261f, 0.17711717f, -0.12492123f, -0.13390222f, 0.09034181f, 
    -0.12990002f, -0.12481753f, 0.12342369f, 0.07955620f, 0.02656739f, -0.04516121f, -0.33768636f, -0.26619789f, 
    0.02957026f, 0.06682992f, -0.39770362f, 0.19394971f, -0.04926289f, 0.18738438f, 0.29406783f, 0.12871648f, 
    -0.06900696f, 0.02023611f, 0.00927678f, 0.25373906f, -0.01928147f, 0.04585283f, 0.12745705f, 0.02518273f, 
    0.00916756f, -0.34125456f, -0.13415530f, -0.25288504f, 0.08666071f, 0.10683538f, -0.23561680f, 0.20165037f, 
    0.06070933f, 0.14410111f, 0.00653449f, -0.07915674f, -0.17449214f, 0.03477989f, 0.16308695f, 0.25243524f, 
    0.13790733f, 0.27048966f, 0.08500194f, 0.11380236f, 0.01575355f, 0.02435141f, 0.28708151f, -0.00443543f, 
    -0.06329891f, -0.06284952f, 0.12675904f, -0.02831384f, 0.03025910f, -0.11428913f, -0.25054851f, 0.12784399f, 
    0.03853800f, -0.14140154f, -0.31041831f, -0.00628740f, 0.07713871f, 0.06526213f, -0.01793553f, 0.03400929f, 
    0.00249582f, 0.14716211f, 0.11692211f, -0.04894195f, -0.03366768f, -0.06746095f, -0.07636449f, -0.05965481f, 
    0.08391637f, 0.13005629f, 0.02479947f, -0.19641787f, 0.00246271f, -0.06280337f, 0.00156118f, 0.08355799f, 
    -0.03605789f, -0.12293112f, -0.05216340f, -0.16123833f, -0.13108569f, 0.16960904f, -0.23650834f, 0.17056456f, 
    -0.02333914f, -0.08604194f, 0.24480219f, -0.01522162f, -0.11019391f, 0.01737151f, -0.01361040f, 0.03384382f, 
    0.71512604f, 0.00393046f, 0.33026436f, 0.17342639f, -0.02913054f, 0.01078660f, -0.29681802f, 0.01847274f, 
    0.12354980f, 0.09136534f, -0.09427354f, 0.06610420f, 0.50917524f, 0.19818220f, -0.11972777f, 0.21326092f, 
    -0.07076214f, -0.07067654f, 0.04364398f, -0.09389552f, 0.05124383f, 0.04791777f, 0.07867841f, 0.05739393f, 
    0.50049847f, 0.33325425f, -0.10755016f, 0.34988004f, 0.03095883f, -0.06461591f, 0.20773821f, 0.07485058f, 
    0.12590235f, 0.22274847f, 0.00833296f, -0.02119332f, -0.18694963f, -0.03033109f, 0.06679755f, -0.10762527f, 
    -0.28640822f, -0.11869322f, 0.02076094f, -0.03696798f, -0.02410062f, -0.05728681f, 0.29786068f, -0.09742290f, 
    0.19430321f, 0.00836292f, 0.15432914f, -0.19160002f, -0.13522683f, -0.07446128f, 0.20557891f, 0.12427291f, 
    -0.06827942f, 0.20471621f, -0.07189178f, 0.00063840f, -0.22947046f, -0.19954377f, 0.12793986f, -0.23970284f, 
    -0.01427224f, -0.18177074f, -0.06990768f, -0.04193737f, -0.02341295f, -0.00870938f, 0.01896262f, -0.23475273f, 
    -0.07312390f, 0.09771977f, 0.12237016f, 0.13168959f, 0.15759778f, 0.06169156f, 0.02289857f, 0.34869358f, 
    -0.04942371f, -0.03721270f, 0.02415565f, 0.03871479f, 0.50021654f, 0.40942839f, -0.10589425f, -0.21118245f, 
    -0.20859201f, -0.13240547f, 0.04583478f, -0.03051111f, -0.07443558f, 0.04975040f, 0.08380409f, -0.09314979f, 
    -0.18209812f, -0.03602346f, 0.56936038f, -0.17537852f, 0.01665551f, 0.02120516f, -0.28736117f, 0.27142259f, 
    0.02290303f, -0.06960917f, -0.01209392f, -0.09171966f, 0.22396587f, 0.00136997f, 0.17837396f, 0.01236831f, 
    -0.01441607f, 0.00859252f, -0.04676201f, -0.10651682f, 0.07005656f, 0.03300089f, 0.04570697f, 0.04187115f, 
    -0.18998216f, -0.16349332f, 0.30260131f, 0.12071940f, 0.09888436f, 0.12561789f, 0.02939662f, 0.24084906f, 
    -0.02235888f, -0.08452359f, -0.01269889f, -0.11819024f, -0.04295537f, 0.25290906f, 0.09625627f, 0.04636347f, 
    0.05939569f, -0.21383865f, -0.00131545f, 0.13966459f, 0.15393007f, 0.01487274f, 0.05820983f, -0.10378813f, 
    -0.05435630f, 0.12860791f, 0.10069277f, 0.05141522f, -0.09147664f, 0.06506629f, 0.24206161f, -0.12851925f, 
    0.03679725f, -0.21189165f, 0.01341465f, 0.09300382f, -0.14157434f, 0.08110423f, 0.28896442f, -0.03644659f, 
    0.14589037f, -0.04888355f, 0.20681478f, 0.29730713f, -0.06739537f, 0.06832411f, -0.25769791f, -0.02447751f, 
    0.13017139f, 0.06530578f, 0.08474173f, -0.39832193f, -0.16137122f, -0.45551547f, 0.22512157f, 0.05067295f, 
    -0.10113113f, 0.07019851f, -0.02275478f, -0.32485133f, 0.14400017f, 0.08054310f, -0.01220602f, 0.31402856f, 
    -0.10794733f, 0.05712003f, -0.10261303f, -0.13085337f, 0.03213564f, 0.37433022f, 0.07735015f, -0.10015369f, 
    0.60611612f, 0.05671183f, -0.02333150f, -0.11326326f, -0.21725802f, -0.05258829f, -0.09395890f, -0.18331388f, 
    -0.17884347f, -0.01059272f, 0.03365248f, 0.18506426f, -0.27577236f, 0.06885243f, -0.04725880f, -0.00829968f, 
    -0.07409617f, 0.24380155f, 0.03676340f, 0.14034833f, -0.15094925f, 0.26085427f, 0.16012141f, -0.11952191f, 
    -0.14197758f, -0.01100734f, 0.05959789f, -0.08755362f, 0.10757887f, 0.00757825f, 0.09658216f, -0.02078105f, 
    0.08948272f, -0.06566008f, -0.20535097f, -0.01026807f, 0.01348653f, -0.05151115f, 0.17537215f, 0.11065072f, 
    0.04478299f, 0.25519216f, 0.13270415f, -0.11592546f, -0.03024415f, -0.21959937f, 0.03855873f, -0.10793696f, 
    0.10173491f, -0.09926189f, 0.14691111f, 0.00677352f, -0.07550716f, 0.02836944f, -0.03493582f, -0.08173435f, 
    0.02724908f, -0.02867897f, 0.06280211f, -0.21230561f, 0.21121339f, 0.10839294f, 0.09500144f, 0.23989983f, 
    0.00487969f, 0.00683006f, 0.10614083f, 0.08156969f, 0.05321597f, -0.12003963f, 0.04373825f, -0.07228820f, 
    0.03061006f, -0.00031304f, 0.04096211f, -0.00768636f, 0.01994726f, -0.00359545f, 0.00626143f, -0.03006546f, 
    0.03656512f, -0.05111671f, -0.03410789f, 0.02088198f, -0.02827059f, -0.02822003f, 0.00941728f, -0.01836717f, 
    0.00309351f, -0.03550541f, -0.00895470f, -0.00952371f, -0.00491949f, -0.03031865f, -0.05156339f, 0.01843452f, 
    0.00207434f, -0.02998535f, -0.01908106f, 0.01925600f, -0.03049371f, -0.01509049f, -0.03200605f, -0.04861824f, 
    0.02452685f, 0.00711600f, 0.02203250f, -0.01082770f, -0.03734272f, 0.01038581f, 0.00855586f, 0.01787176f, 
    0.04076166f, -0.04071798f, -0.03200425f, -0.03040778f, 0.01684070f, 0.01580290f, -0.04232221f, 0.03960966f, 
    -0.03948702f, 0.03960408f, -0.01934087f, -0.03203921f, -0.03052883f, 0.02514361f, -0.03748244f, 0.00450036f, 
    0.03754368f, 0.02709515f, -0.00176167f, 0.00643701f, -0.02711252f, 0.03766702f, 0.02891959f, -0.03453008f, 
    0.00258452f, -0.03211262f, -0.03551464f, 0.01105716f, -0.03086202f, 0.04319843f, 0.01337119f, -0.05557723f, 
    0.04667215f, -0.03546975f, 0.01251028f, 0.03449124f, 0.00901236f, -0.01684141f, -0.04611798f, 0.02999545f, 
    -0.03308921f, 0.02668693f, -0.02274424f, -0.03040807f, -0.00132811f, -0.05328343f, 0.02733726f, -0.02481284f, 
    -0.04329852f, -0.01816401f, -0.03900561f, -0.02275065f, -0.02896575f, -0.03246557f, -0.00072677f, 0.03921070f, 
    -0.01660360f, -0.01067282f, 0.00840251f, 0.01408081f, -0.00881689f, 0.01703407f, 0.03671221f, -0.05203249f, 
    -0.04656578f, -0.03933829f, 0.04153457f, -0.02442543f, -0.01238102f, 0.01638736f, 0.01129208f, -0.03109551f, 
    0.01208395f, -0.01003829f, -0.01988848f, -0.04394287f, -0.04427383f, -0.05297889f, 0.00537624f, -0.02298326f, 
    0.02937378f, -0.02456254f, 0.01345960f, -0.05342413f, -0.04300959f, 0.03977553f, -0.03609781f, 0.04316918f, 
    -0.00263207f, 0.02591039f, 0.01801247f, 0.00034641f, 0.01615257f, -0.03069327f, -0.04972043f, -0.05274537f, 
    -0.04681262f, 0.01295462f, -0.05773282f, -0.01150537f, -0.00741846f, -0.05529447f, -0.04069748f, -0.02753490f, 
    -0.01475413f, -0.03015873f, 0.04086453f, -0.00974345f, -0.04701149f, -0.02658731f, -0.00796517f, -0.02108602f, 
    -0.01376341f, 0.02469446f, 0.03393990f, 0.01776202f, -0.04660215f, 0.01250025f, -0.01875398f, -0.02452744f, 
    -0.00486442f, -0.00207161f, 0.01820820f, 0.02832130f, 0.00207073f, -0.01687971f, 0.01744532f, -0.01489996f, 
    -0.01002119f, 0.02202816f, 0.01303010f, -0.04205872f, -0.00573779f, -0.01480515f, -0.05688474f, -0.04667558f, 
    -0.00804196f, -0.01794970f, -0.04948779f, -0.01526885f, -0.02412267f, -0.04750739f, 0.00386582f, -0.02357951f, 
    0.00741567f, -0.04824762f, -0.04195134f, -0.04223454f, 0.03445096f, -0.03156949f, -0.04754898f, -0.04749085f, 
    -0.02745796f, -0.02540159f, 0.01178677f, 0.01207157f, -0.04877476f, -0.00948744f, -0.03841368f, 0.02226994f, 
    0.03939962f, 0.01008042f, -0.00630922f, 0.03961640f, -0.00514787f, 0.01860963f, 0.01192346f, 0.00642121f, 
    0.01253642f, 0.04822934f, -0.01344728f, 0.02245578f, 0.02042123f, 0.02964054f, 0.04009358f, 0.04358631f, 
    0.03942988f, 0.00065886f, -0.01050913f, -0.01301935f, 0.04060031f, -0.04106912f, -0.03164754f, 0.00397625f, 
    0.01683077f, -0.00520646f, -0.04599689f, -0.04776658f, 0.04175682f, -0.04319086f, 0.02971606f, 0.03013258f, 
    -0.05045296f, 0.01374965f, -0.04818322f, 0.02145031f, -0.04169709f, -0.03879840f, 0.02173348f, 0.02898694f, 
    -0.00967735f, 0.00506027f, 0.01687742f, 0.00834338f, 0.00034458f, 0.01209806f, 0.03900084f, 0.01002541f, 
    0.03376102f, 0.00519356f, -0.05844510f, -0.03777578f, -0.00842124f, 0.02943907f, -0.03280258f, -0.05487099f, 
    0.01818604f, 0.02498995f, 0.03628534f, -0.03235760f, 0.01690577f, -0.02806552f, -0.04650320f, -0.00654577f, 
    -0.03156134f, 0.03152645f, -0.00687910f, -0.02813917f, -0.00027089f, -0.03542335f, -0.02279109f, -0.02126548f, 
    -0.02175252f, -0.03177755f, 0.04206086f, 0.01658250f, -0.00234197f, -0.03336465f, -0.04148522f, -0.01737254f, 
    0.03220420f, 0.02126988f, -0.03372398f, -0.02316039f, -0.05405320f, -0.04007019f, 0.00708264f, -0.00953252f, 
    -0.05299984f, 0.00583361f, -0.03721588f, -0.00193242f, -0.01326147f, -0.05034458f, -0.05362448f, 0.04776499f, 
    -0.04704633f, 0.03264650f, 0.01746285f, 0.03890746f, -0.02716579f, 0.04090997f, -0.04681116f, 0.01608633f, 
    -0.00390500f, 0.02398697f, -0.01700615f, -0.03550003f, -0.00777031f, 0.01989713f, -0.00878589f, 0.01680130f, 
    -0.05755279f, 0.01787399f, 0.00468359f, 0.00402982f, -0.00915453f, -0.04839577f, -0.00617579f, 0.00662200f, 
    -0.03332800f, -0.02105872f, -0.01165650f, 0.01175720f, -0.02827217f, 0.01805264f, -0.02252969f, -0.00080161f, 
    0.02179785f, 0.00043518f, -0.03738277f, 0.03092358f, -0.05007905f, -0.02991794f, 0.00169422f, -0.05193036f, 
    -0.05156630f, -0.02042343f, -0.01902339f, -0.01681597f, 0.01731966f, -0.03383195f, -0.05291986f, -0.02272994f, 
    0.00853564f, 0.03382258f, 0.03172768f, -0.03199201f, 0.03954050f, -0.03786249f, 0.02068499f, 0.04493905f, 
    -0.02024996f, 0.03099956f, 0.01448417f, -0.04434940f, -0.01145074f, -0.04089672f, 0.03811714f, -0.01054561f, 
    -0.01249293f, 0.00029816f, 0.01653735f, 0.03551328f, 0.00058716f, -0.03314143f, 0.03849478f, -0.03997532f, 
    0.02309359f, -0.01310142f, -0.04947391f, 0.04445627f, -0.00343637f, 0.00727495f, 0.01789781f, -0.00190110f, 
    0.00585325f, 0.02462506f, -0.03027795f, -0.01332848f, 0.03052652f, -0.05042263f, -0.00708996f, -0.03121105f, 
    0.18868974f, 0.00895975f, -0.29896626f, 0.04649512f, -0.05804526f, 0.10071091f, 0.22955564f, -0.04862488f, 
    -0.01442754f, -0.00402368f, 0.03806778f, -0.17193764f, -0.27021325f, 0.08807949f, 0.25773227f, -0.09847853f, 
    -0.06316828f, -0.05251015f, 0.12358902f, 0.10317103f, 0.12512918f, 0.08868422f, 0.00660725f, 0.08771490f, 
    -0.15546095f, 0.12171203f, -0.03331263f, -0.14751193f, -0.30976474f, 0.01213193f, 0.07141303f, 0.20306247f, 
    -0.18986574f, 0.00837557f, -0.07362947f, -0.12202417f, -0.07569706f, -0.03407859f, 0.21187142f, 0.05999706f, 
    0.18078300f, -0.00780351f, -0.04740757f, -0.04451349f, 0.01665877f, 0.04119475f, -0.00060156f, 0.08576496f, 
    -0.18419807f, -0.21993198f, 0.03007775f, 0.66857100f, 0.15049693f, 0.40868154f, -0.00770667f, -0.10548269f, 
    0.04308787f, -0.08458064f, -0.11929887f, -0.07773618f, -0.13188863f, 0.09871536f, -0.08519508f, 0.02186557f, 
    0.19695571f, 0.14980882f, 0.04731996f, 0.14938790f, 0.00349123f, 0.13530010f, 0.04186834f, 0.06324534f, 
    -0.23499554f, -0.11007638f, 0.24946906f, 0.06574807f, -0.06522020f, -0.03556983f, -0.09380387f, 0.03138873f, 
    -0.14805388f, -0.05226457f, 0.06117775f, -0.07168316f, -0.01517004f, -0.34970033f, -0.10782241f, -0.21496122f, 
    0.00760531f, -0.01666170f, 0.03660158f, 0.24411771f, 0.03964692f, -0.01946940f, 0.14653611f, 0.06635229f, 
    -0.08821353f, 0.27032062f, -0.02664220f, -0.04389273f, 0.02605184f, -0.09673034f, -0.00997672f, 0.13245761f, 
    0.04128675f, -0.16865349f, 0.08081580f, -0.04688388f, -0.05880113f, -0.26432300f, 0.13689291f, -0.02193341f, 
    0.10510138f, 0.24354076f, 0.29949528f, 0.07063147f, -0.05914914f, -0.10113781f, 0.05490681f, -0.03616478f, 
    -0.24861793f, 0.58605224f, 0.22913466f, -0.12775953f, 0.05332801f, 0.09429503f, -0.10716429f, -0.00151161f, 
    0.07494166f, 0.25971296f, 0.00781165f, -0.02195078f, -0.00826633f, -0.20639956f, -0.05581878f, -0.08274562f, 
    -0.15109584f, 0.02717032f, 0.02361157f, -0.01291679f, -0.08936838f, 0.02112564f, -0.17220172f, -0.04959994f, 
    0.06419047f, -0.23383540f, 0.19224258f, -0.16129045f, -0.01696752f, -0.06265347f, 0.06818368f, -0.20298855f, 
    0.21310188f, 0.02795510f, 0.22773457f, 0.19788802f, 0.10264907f, 0.39531189f, 0.37209526f, 0.07946122f, 
    0.07109987f, 0.15478948f, -0.10923579f, 0.15844436f, 0.22521688f, 0.07489302f, 0.03078737f, 0.07922730f, 
    0.02530011f, 0.07032859f, -0.02801247f, 0.08314430f, 0.20119098f, -0.22016056f, -0.09698819f, 0.10095873f, 
    0.19078359f, -0.18259864f, -0.30090493f, -0.03588433f, 0.05657055f, 0.31901047f, 0.37323287f, 0.18132322f, 
    0.08299634f, -0.06879874f, 0.00681807f, -0.01775407f, -0.03009328f, 0.09312764f, -0.00503887f, 0.10429154f, 
    -0.17449909f, -0.01311069f, 0.01031849f, 0.08927974f, 0.08708064f, 0.14122222f, -0.03194472f, 0.11355504f, 
    0.04180460f, -0.01065138f, 0.13303460f, 0.13844720f, -0.20047835f, 0.36942312f, 0.06828335f, 0.26977524f, 
    -0.04935791f, -0.19299893f, -0.07955019f, 0.06943355f, 0.05867878f, 0.35159743f, 0.01045577f, 0.06940345f, 
    -0.44426000f, 0.27858725f, -0.17881621f, 0.14037621f, -0.05316878f, 0.10116643f, -0.25081292f, 0.01552926f, 
    -0.13012573f, 0.07858157f, 0.01898119f, -0.10134081f, -0.26697704f, -0.23467931f, -0.31727466f, -0.07921062f, 
    0.11493021f, -0.19397737f, -0.11210331f, 0.02596549f, 0.03446126f, 0.05865053f, -0.02938606f, -0.07774204f, 
    -0.43995318f, -0.12984613f, 0.04962752f, 0.26117268f, -0.05837599f, 0.12260997f, 0.07650601f, 0.02684219f, 
    -0.02028720f, -0.01380574f, 0.10490410f, 0.03548292f, 0.01423328f, 0.14228423f, -0.11797327f, 0.10990649f, 
    -0.06497349f, -0.08324359f, 0.17114004f, 0.18584611f, 0.02897358f, 0.02821239f, -0.06351263f, 0.01781477f, 
    0.38232556f, 0.19430844f, -0.04173798f, 0.04099213f, -0.01780500f, -0.05633639f, 0.19094537f, 0.01854533f, 
    0.18563735f, 0.02967391f, 0.20967051f, -0.00832900f, -0.17892851f, -0.09291791f, -0.12330860f, 0.04400543f, 
    -0.08419430f, 0.01480712f, -0.19011465f, 0.18080169f, 0.13536404f, 0.07992832f, 0.06913595f, -0.07331271f, 
    -0.29968283f, 0.20275021f, -0.06939799f, 0.00449173f, 0.07492357f, -0.00141691f, -0.14317302f, 0.42817461f, 
    0.07910577f, 0.02632652f, -0.11375231f, 0.02399251f, -0.02746674f, 0.00730843f, 0.07834086f, 0.34728566f, 
    -0.07160409f, -0.02537445f, 0.09973942f, 0.01089738f, 0.14808011f, 0.04768329f, -0.13630438f, 0.03773053f, 
    -0.49033117f, 0.34657979f, 0.63934904f, 0.25330189f, 0.01392529f, 0.06154866f, -0.19792214f, 0.03045274f, 
    -0.06463563f, 0.14431308f, 0.19372152f, -0.08762438f, -0.12238849f, -0.24232720f, 0.54397386f, 0.13415264f, 
    0.24148265f, 0.19546364f, 0.07667151f, -0.11113595f, 0.09268945f, 0.18433103f, 0.16720352f, -0.05616368f, 
    0.31979421f, 0.17277110f, -0.03277579f, -0.23127607f, -0.07874905f, -0.04307890f, 0.03355410f, -0.06565754f, 
    0.09945071f, 0.05172590f, -0.08328789f, -0.00715691f, -0.10978056f, -0.17940043f, -0.07761545f, -0.04041515f, 
    0.08744667f, 0.14677502f, -0.07023779f, 0.07378613f, 0.00519969f, 0.01197444f, -0.01466767f, 0.17787245f, 
    -0.11202940f, 0.17458677f, -0.22766754f, 0.35862368f, -0.13601360f, -0.21528299f, 0.21757922f, 0.11701232f, 
    -0.07941765f, -0.10835834f, 0.02598996f, 0.23272929f, 0.20354815f, 0.29133880f, -0.45783615f, 0.05905737f, 
    -0.07830076f, -0.13729021f, -0.02329487f, -0.11634666f, -0.04758786f, -0.00996851f, 0.21156436f, -0.01701059f, 
    -0.06664251f, 0.19942996f, -0.18515724f, -0.00261896f, -0.15081270f, -0.08185677f, 0.11235691f, 0.05169625f, 
    0.20206937f, 0.00175287f, 0.00236500f, -0.06429284f, 0.43361339f, -0.12842703f, 0.09307618f, 0.23057216f, 
    -0.04560578f, 0.07279284f, 0.01414126f, -0.07724452f, 0.04965886f, -0.01160054f, -0.00030460f, 0.21431760f, 
    0.22680281f, 0.22568414f, -0.29905623f, 0.10198626f, -0.03005254f, -0.07185398f, -0.03383343f, 0.02079814f, 
    0.12940325f, 0.02343467f, 0.25497979f, 0.10296506f, -0.34072462f, -0.41117352f, -0.24251391f, -0.13502060f, 
    -0.04519213f, -0.04173405f, -0.09573054f, -0.01115978f, -0.09448118f, 0.01528865f, 0.08103077f, -0.10135916f, 
    -0.29906476f, -0.07142208f, -0.16882944f, 0.06874781f, 0.10894241f, 0.21565858f, -0.05046270f, -0.08396286f, 
    -0.13209420f, -0.01516325f, -0.00773023f, 0.08378210f, -0.13478389f, -0.50729734f, -0.13996436f, -0.07939894f, 
    0.03452323f, 0.17489271f, -0.03946452f, 0.08504514f, 0.10644829f, 0.03917871f, 0.04998263f, -0.09417896f, 
    0.08494561f, 0.07101511f, -0.08610240f, 0.26087654f, -0.06108281f, 0.02201656f, 0.16959745f, 0.23338385f, 
    0.02544545f, 0.01716384f, 0.07729010f, 0.08647332f, -0.05789644f, 0.01366170f, -0.24565704f, -0.04803820f, 
    0.13114019f, -0.20436652f, -0.04785272f, -0.08237255f, -0.04738995f, 0.11054546f, 0.22067527f, -0.09028368f, 
    0.03419058f, -0.07517760f, 0.08454392f, -0.02683085f, -0.00762030f, -0.02242024f, -0.02135256f, 0.15225966f, 
    0.12179378f, 0.07041332f, 0.19650133f, 0.19734029f, -0.41880164f, -0.22363764f, -0.26500621f, -0.05975837f, 
    -0.13262776f, -0.11569666f, 0.12546802f, -0.20315261f, 0.03028134f, -0.01874779f, 0.02287719f, 0.02759990f, 
    0.06426344f, -0.07569689f, 0.49043018f, -0.11124858f, 0.04683769f, 0.03683881f, 0.08258548f, 0.00170672f, 
    0.01245502f, 0.22949676f, 0.40558937f, 0.14118889f, -0.41931483f, -0.07035845f, -0.36842158f, -0.15747249f, 
    -0.06325484f, -0.08362005f, 0.08955228f, 0.04583653f, -0.14035285f, 0.03861989f, -0.13741419f, -0.00782281f, 
    -0.26133111f, 0.15712535f, 0.55583036f, 0.01508178f, -0.06052664f, -0.19095396f, 0.02250405f, 0.03383623f, 
    0.00369762f, 0.10458889f, 0.17674440f, 0.21209940f, -0.07552356f, 0.24055871f, 0.18655474f, 0.00237920f, 
    0.16214260f, -0.07963809f, 0.06097890f, -0.01852842f, 0.10004441f, 0.21679386f, -0.05898796f, 0.16888687f, 
    0.14191046f, -0.09050639f, 0.10183853f, -0.16937533f, 0.41087925f, 0.06144509f, -0.12541860f, -0.15682581f, 
    0.08335847f, -0.04865808f, 0.05625629f, -0.03891898f, 0.26254582f, 0.01236709f, -0.08639914f, 0.17816976f, 
    0.03167992f, 0.01403990f, 0.12430028f, 0.04627723f, 0.09626369f, -0.05528780f, 0.02630146f, 0.19592933f, 
    -0.30821049f, -0.21197002f, -0.22299895f, 0.00294551f, 0.15400469f, 0.07314097f, 0.24347968f, -0.09916091f, 
    0.05421308f, 0.03170923f, 0.07727796f, -0.01547870f, 0.47790787f, -0.42507854f, 0.14237468f, 0.05740244f, 
    -0.06800670f, 0.03755135f, -0.19623926f, 0.07528586f, -0.00999550f, 0.21983688f, 0.29523367f, 0.03903198f, 
    -0.01452054f, -0.43645087f, -0.13256723f, -0.17820057f, -0.07115056f, 0.03857354f, 0.16068946f, 0.06328840f, 
    -0.00319189f, -0.15369724f, -0.02138799f, 0.04425837f, -0.15301412f, -0.17736332f, 0.04973587f, -0.24975695f, 
    -0.08417215f, 0.04759314f, -0.04066272f, -0.09061404f, 0.07631182f, -0.14986295f, -0.03385897f, -0.15592653f, 
    -0.06706007f, -0.23225789f, -0.22509585f, -0.26325363f, -0.00562240f, -0.11854526f, 0.03534159f, 0.21894349f, 
    -0.03094393f, -0.08481289f, 0.00347411f, 0.01685276f, -0.26672474f, -0.36827433f, -0.15240002f, -0.09227693f, 
    -0.07307636f, -0.02882009f, -0.05228219f, 0.15143590f, -0.02018804f, 0.02117059f, 0.08713010f, -0.00449021f, 
    0.14294545f, 0.00119245f, 0.22169726f, 0.16854380f, -0.04546360f, 0.09813379f, 0.02612001f, 0.11762687f, 
    0.26157475f, 0.27742931f, 0.02723359f, 0.03323675f, -0.18528187f, -0.42350930f, -0.24538830f, -0.13208556f, 
    -0.05210390f, -0.02754837f, 0.07088964f, 0.11167415f, -0.00078710f, -0.05631390f, 0.09973479f, 0.06637565f, 
    0.02360916f, 0.14721572f, -0.06977733f, 0.14921181f, 0.09413222f, 0.04345374f, 0.11936664f, 0.17008168f, 
    0.07493763f, 0.04414649f, -0.04204217f, 0.13707103f, 0.28678831f, -0.07519803f, 0.03857248f, 0.06929612f, 
    -0.07386871f, 0.05192240f, -0.00714411f, -0.04365805f, -0.07896707f, -0.10162180f, 0.14150545f, 0.11544988f, 
    0.22193749f, 0.13540885f, 0.55913311f, 0.25072995f, 0.14680572f, 0.04970895f, -0.09630640f, 0.05859251f, 
    0.00732916f, 0.09806973f, 0.03940047f, -0.11354643f, -0.32435089f, -0.04809601f, -0.26973730f, -0.22965711f, 
    0.17398229f, -0.23310535f, 0.46639642f, -0.00384316f, 0.18039349f, 0.07863814f, -0.14817993f, 0.02666535f, 
    0.15450481f, 0.08197635f, -0.27956146f, 0.22486284f, -0.13550264f, -0.12030679f, 0.12760380f, 0.06374553f, 
    0.11752903f, 0.30650511f, 0.09097625f, 0.18060847f, -0.00212213f, -0.11697720f, 0.09892078f, -0.15550962f, 
    0.19055875f, -0.07585890f, -0.13660029f, 0.03066870f, 0.00057054f, 0.02335007f, 0.00319851f, -0.07919900f, 
    0.12817796f, -0.06617836f, -0.02419209f, -0.05408863f, -0.01516925f, -0.05996916f, -0.09437037f, -0.15933314f, 
    0.14386724f, -0.02797397f, 0.06054708f, 0.20608853f, -0.01623716f, 0.27941933f, -0.13805345f, -0.14257726f, 
    -0.04669347f, 0.02116844f, 0.00046504f, -0.13816126f, 0.14246739f, 0.18039438f, 0.01877653f, -0.14100149f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03420973f, 0.17904094f, -0.04375881f, 0.05207140f, -0.00538169f, -0.04882368f, 0.01108445f, 0.00849262f, 
    -0.01324410f, 0.08739180f, 0.00304848f, 0.00004155f, -0.15768328f, 0.03374923f, 0.09273703f, -0.06276301f, 
    -0.04452763f, 0.00432917f, -0.02272233f, 0.02127559f, -0.00551913f, -0.00700470f, -0.03958830f, 0.14249504f, 
    0.15861411f, 0.16417423f, 0.16588071f, -0.14879854f, 0.10659708f, 0.02362898f, 0.18259375f, 0.13386659f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10103293f, 0.28676575f, -0.00615733f, -0.10829070f, 0.28535685f, -0.05933372f, -0.16662686f, 0.18539096f, 
    -0.00974266f, -0.55722958f, -0.10361490f, -0.11141125f, 0.01015500f, 0.29989734f, 0.49841511f, 0.09977829f, 
    -0.11571831f, -0.19481677f, -0.15169783f, -0.13450783f, -0.04641086f, 0.03988035f, -0.01321844f, 0.06693184f, 
    -0.42163676f, -0.32398778f, -0.07314076f, 0.19001086f, -0.45164615f, -0.13710384f, -0.32862034f, -0.27264896f, 
    0.09055891f, 0.27551907f, 0.11158383f, 0.16063967f, 0.10882685f, -0.10160672f, 0.07589543f, -0.03198516f, 
    0.14680767f, 0.13490321f, -0.04078845f, -0.06419433f, -0.58986264f, 0.39678833f, -0.52983207f, -0.39335850f, 
    -0.06212933f, -0.45985824f, -0.07339763f, 0.13087235f, -0.12127688f, 0.11813214f, -0.03889447f, 0.19417781f, 
    0.15039174f, -0.27526134f, 0.24435417f, -0.05956739f, 0.14206843f, -0.12481689f, -0.21340241f, -0.27700153f, 
    0.02570072f, -0.17628576f, 0.16623043f, 0.38591579f, 0.61744070f, 0.04866746f, 0.14107762f, 0.14092542f, 
    -0.03178822f, 0.04597669f, 0.15848999f, 0.14930692f, -0.68566489f, -0.65591276f, 0.01333942f, -0.16145054f, 
    0.07838888f, 0.20855024f, -0.08780862f, -0.32587472f, 0.06711307f, 0.17063893f, -0.03705643f, 0.35033813f, 
    -0.08880938f, -0.10323074f, 0.09993557f, 0.09097949f, -0.20600107f, 0.15600525f, 0.01488448f, 0.06409637f, 
    -0.06317493f, -0.19236872f, 0.14058043f, -0.02952924f, 0.19111589f, -0.09126956f, 0.16349427f, 0.21949281f, 
    0.12683292f, 0.05464551f, -0.02007788f, 0.08996078f, 0.28486377f, 0.10125956f, -0.52102089f, 0.28002524f, 
    -0.08819193f, 0.11068323f, -0.05629553f, 0.52085489f, -0.06497458f, 0.14108011f, -0.02025934f, 0.09978596f, 
    -0.25485581f, -0.14460690f, -0.99507308f, -0.27185878f, -0.38435891f, -0.08657869f, 0.11461828f, -0.07200606f, 
    0.04466271f, 0.07805777f, 0.12426510f, -0.23626260f, 0.29883820f, 0.10520075f, -0.13265111f, 0.17808238f, 
    0.34241679f, 0.13361299f, -0.06516451f, 0.07645786f, 0.11419167f, -0.33099145f, -0.03331318f, -0.07083747f, 
    -0.07452688f, 0.23922899f, -0.02726779f, -0.50095785f, -0.10878212f, -0.02479747f, 0.07608841f, -0.45482951f, 
    -0.34984997f, -0.37556615f, -0.17644118f, 0.09075408f, 0.19427668f, -0.12521385f, 0.17499402f, -0.76912045f, 
    0.16281524f, 0.17585427f, -0.11714105f, -0.62263703f, -0.56158775f, 0.03070442f, -0.02460233f, -0.18058634f, 
    0.16661656f, 0.00739497f, 0.00497088f, -0.08798642f, 0.09592453f, 0.17968018f, 0.14710543f, -0.65799117f, 
    -0.11453326f, 0.23961888f, -0.15128675f, -0.46611199f, -0.09010588f, -0.01212436f, 0.11624336f, 0.02189179f, 
    -0.15846027f, 0.39067906f, 0.34988210f, -0.34152648f, -0.07853427f, 0.16096471f, 0.18515375f, -0.33848718f, 
    -0.05591203f, -0.84926343f, -0.14054473f, 0.34682623f, 0.02503152f, 0.00394848f, 0.12441298f, -0.33838663f, 
    -0.08156321f, 0.01056802f, -0.11342242f, 0.01101537f, -0.49383083f, -0.33432439f, 0.03432862f, 0.06441517f, 
    0.11192878f, -0.28199255f, -0.01373311f, -0.55472928f, 0.13058396f, -0.02536053f, -0.15831231f, -0.67264873f, 
    0.16937394f, 0.35104051f, 0.32198545f, -0.28071675f, -0.25210747f, -0.08033778f, 0.48428807f, 0.39165020f, 
    0.14435180f, -0.28603119f, -0.02244406f, 0.17513910f, 0.12314253f, -0.01310450f, -0.08547620f, -0.67484510f, 
    0.09576023f, -0.05462701f, 0.10193887f, -0.11850030f, 0.70683485f, 0.01089891f, 0.01370242f, -0.48435184f, 
    -0.09606174f, 0.22447397f, 0.02747311f, 0.10855095f, 0.12532577f, -0.04626638f, 0.15384783f, 0.16824271f, 
    -0.37098208f, -0.19280221f, -0.26731282f, -0.19024964f, 0.39050347f, 0.01400517f, -0.56510031f, 0.23535697f, 
    0.07954878f, 0.15845200f, 0.09353507f, -0.02295024f, -0.20244043f, -0.02230306f, 0.09581197f, -0.67220443f, 
    -0.94307995f, -0.14327675f, 0.13724954f, 0.13039957f, -0.26893267f, 0.46760020f, -0.44815442f, -0.28167659f, 
    -0.02309967f, 0.23960792f, 0.09925163f, 0.59980440f, 0.15181208f, 0.10579623f, -0.07959803f, 0.32375205f, 
    0.14380318f, 0.20759003f, -0.22143485f, 0.09241695f, -0.43257287f, -0.15224589f, -0.07234304f, 0.26488984f, 
    0.07893775f, -0.11597610f, -0.00558280f, -0.11818303f, -0.09642229f, 0.00618307f, 0.08342357f, 0.11931780f, 
    -0.06124990f, 0.39625540f, -0.09440367f, 0.03008090f, 0.18368669f, -0.38109758f, 0.54399216f, -0.08413430f, 
    0.12213399f, -0.01279237f, 0.04500727f, 0.22736825f, 0.02475568f, 0.11487300f, -0.00911894f, -0.85504568f, 
    -0.26925027f, -0.46502271f, 0.16724631f, -0.42346129f, 0.14577241f, -0.04879031f, -0.00148073f, 0.25498024f, 
    -0.15976456f, 0.17721331f, -0.09428828f, -0.37182173f, -0.31322420f, -0.07529395f, 0.02288368f, 0.12107190f, 
    -0.28371409f, -0.37154442f, -0.01512759f, 0.12228338f, -0.41316095f, -0.55914319f, -0.59986073f, 0.38542095f, 
    -0.16231713f, -0.00057433f, 0.04425452f, 0.20945299f, -0.13270015f, -0.01072290f, -0.02591942f, 0.11753067f, 
    0.17450793f, 0.05321045f, -0.20523338f, -0.52437764f, 0.20169526f, -0.01115883f, 0.52450234f, -0.15926538f, 
    -0.10859890f, 0.06613893f, 0.13784720f, 0.18393877f, -0.52404416f, -0.08739252f, 0.13954413f, -0.27971259f, 
    -0.24658863f, 0.34100834f, -0.16019127f, 0.03586575f, 0.01045137f, -0.25453082f, -0.01610143f, 0.65947288f, 
    0.00602402f, -0.00699630f, -0.05995030f, -0.41388491f, -0.01306673f, 0.01587602f, -0.11746773f, -0.15964100f, 
    0.44203603f, 0.31537339f, -0.55296326f, -0.07098117f, -0.24877073f, -0.09542915f, -0.01297192f, -0.35445318f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.13419321f, -0.06140132f, 0.25105646f, -0.19782603f, 0.19128941f, 0.19867079f, 0.05051930f, 0.13943209f, 
    0.34924480f, -0.05502088f, -0.24693395f, -0.11322293f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
