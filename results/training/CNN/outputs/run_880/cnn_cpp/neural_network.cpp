#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.62633616f, -0.46498296f, -0.46236527f, -0.20280306f, -0.24192202f, -0.18068416f, -0.10474478f, -0.01340281f, 
    0.04056435f, -0.38589740f, 0.33347863f, 0.63774276f, 0.22596787f, -0.01521088f, 0.38471135f, 0.02240738f, 
    0.13332886f, -0.08158570f, -0.46566075f, -0.39559281f, -0.00625785f, 0.34669197f, 0.06722498f, -0.44871336f, 
    0.21554419f, 0.14682841f, 0.09908507f, -0.82729441f, -0.09622147f, 0.10658994f, 0.32996690f, 0.31544265f, 
    0.23686381f, -0.15556829f, -0.01905052f, 0.27166682f, -0.07054955f, 0.16498543f, -0.16877358f, -0.19282572f, 
    -0.12692750f, -0.20284317f, 0.38160652f, 0.12209237f, 0.62122369f, -0.38133329f, -0.39741537f, -0.26377976f, 
    -0.17723764f, 0.51777887f, -0.36081967f, -0.15386899f, -0.21368206f, -0.16235414f, -0.37419847f, -0.73135543f, 
    -0.30593067f, -0.47514176f, -0.13058490f, 0.31071946f, -0.04070892f, 0.19268295f, 0.27473393f, 0.60581917f, 
    0.05027099f, 0.36824656f, -0.19749756f, 0.26884064f, -0.46483037f, -0.20600469f, -0.19710486f, 0.13065535f, 
    -0.47524470f, 0.34681302f, -0.37310314f, 0.54157245f, -0.15700100f, -0.47263756f, 0.12669177f, -0.00130931f, 
    -0.15151291f, 0.50728589f, 0.38816020f, 0.64563978f, 0.07888080f, -0.27919659f, 0.44558725f, -0.08155485f, 
    0.06906444f, 0.10557803f, -0.02849716f, -0.45411065f, -0.47058174f, -0.08825815f, 0.42128006f, 0.35573786f, 
    -0.20806593f, 0.26881006f, -0.20518848f, 0.57996523f, 0.34867886f, -0.13580418f, -0.68140101f, -0.43385810f, 
    -0.34800762f, 0.14728040f, 0.13580185f, 0.20876588f, -0.30256754f, -0.04675185f, 0.37094063f, -0.34747043f, 
    -0.42312202f, 0.29007849f, 0.29935011f, -0.12139339f, 0.16966322f, 0.51215953f, 0.61956650f, -0.46859935f, 
    0.32904401f, 0.36922088f, -0.14119790f, 0.18204647f, 0.09218886f, 0.04361971f, -0.08231436f, 0.01393939f, 
    0.10485472f, 0.45201316f, 0.23446827f, 0.13686405f, -0.29957822f, -0.24812599f, -0.54777312f, 0.55530810f, 
    0.17162025f, 0.16373841f, 0.01259064f, -0.12627330f, -0.10397303f, 0.18736602f, 0.29812449f, -0.32912031f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.20105867f, -0.03947499f, -0.12022737f, -0.26855117f, -0.04215997f, 0.06422747f, -0.26481780f, -0.38800851f, 
    -0.11577608f, 0.11677272f, -0.44506243f, 0.22020853f, 0.26949465f, -0.34601024f, 0.01984442f, -0.20027030f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.51128626f, 0.02166857f, 0.12534741f, 0.10048763f, -0.00899229f, -0.10768595f, 0.05924153f, 0.20767532f, 
    0.04738819f, 0.04605424f, -0.08709329f, -0.04203060f, -0.16369613f, 0.07677553f, 0.04950119f, -0.02988982f, 
    -0.23952061f, -0.01229153f, 0.06545961f, -0.10187596f, 0.02440799f, 0.23038769f, 0.08408669f, 0.08832446f, 
    -0.20580146f, -0.06958251f, -0.07679331f, 0.12526077f, -0.17312582f, 0.15246366f, 0.07409127f, -0.02620596f, 
    -0.03832103f, 0.04341585f, 0.05576806f, -0.07214373f, -0.15851989f, -0.07302343f, 0.01668612f, 0.15350224f, 
    0.15142313f, -0.09163546f, -0.26622102f, -0.20097719f, 0.05255634f, 0.29856136f, 0.10960827f, 0.00979954f, 
    -0.03701341f, -0.11363763f, 0.06360718f, -0.05139558f, 0.12373836f, 0.13564529f, 0.29073638f, -0.14970717f, 
    0.25586092f, -0.03542469f, 0.10517123f, -0.19144009f, 0.08667174f, 0.02179799f, -0.06226701f, 0.37854680f, 
    -0.05800922f, 0.03944086f, 0.01134664f, 0.02975313f, 0.09895824f, -0.25006467f, -0.03966282f, 0.07140564f, 
    -0.01548745f, 0.03008031f, -0.06322572f, -0.02340445f, -0.04200561f, 0.06392787f, -0.02202237f, 0.07701061f, 
    -0.00229120f, -0.00357250f, 0.16088764f, 0.11460511f, -0.02739940f, 0.03590804f, -0.04363186f, 0.04471554f, 
    -0.06940903f, -0.14170036f, 0.19171043f, 0.29418930f, 0.32340726f, -0.10700007f, 0.04950815f, -0.20086217f, 
    0.03515194f, -0.11272166f, 0.10331851f, -0.00675774f, -0.07357156f, -0.14365608f, 0.03099266f, -0.12187261f, 
    -0.17083398f, -0.01571230f, 0.01182016f, -0.05104684f, -0.08920376f, -0.23653561f, -0.20152612f, -0.10805511f, 
    -0.00415059f, -0.05857905f, -0.03538220f, -0.12258349f, -0.05132269f, 0.17468284f, 0.22463045f, 0.11573565f, 
    0.03514591f, 0.02990359f, 0.01519565f, -0.03992980f, -0.11164992f, 0.00045165f, 0.07414062f, -0.09227537f, 
    0.15852548f, 0.04666531f, 0.13567787f, 0.23504433f, 0.00366973f, 0.11245615f, 0.02846080f, 0.13165490f, 
    -0.05720957f, 0.08029606f, 0.15384398f, 0.16317382f, -0.11328623f, 0.01166295f, 0.05754102f, 0.03492882f, 
    -0.00115137f, -0.06975865f, 0.03472777f, 0.05788216f, 0.03350960f, -0.04277953f, -0.03920747f, -0.02974239f, 
    -0.01919680f, 0.01231358f, 0.03159903f, 0.06918445f, 0.05968016f, 0.00146295f, -0.01060475f, -0.04860749f, 
    -0.06220677f, -0.05801360f, -0.06276423f, -0.02024046f, -0.08534377f, -0.01290439f, -0.02125893f, 0.06271394f, 
    -0.03246164f, -0.07532620f, 0.04162741f, -0.08547458f, 0.03896301f, 0.02638655f, -0.04447977f, 0.05455958f, 
    -0.01624025f, -0.06750003f, -0.03040380f, -0.04027733f, -0.05140304f, -0.07167988f, -0.00112942f, 0.04193661f, 
    -0.03892041f, -0.04405790f, -0.04730538f, 0.06724405f, -0.08141866f, 0.06743840f, -0.07542810f, 0.07239913f, 
    -0.00366785f, -0.08156902f, -0.08493598f, -0.02107292f, 0.04839499f, -0.02730963f, -0.00843706f, -0.05301224f, 
    -0.06598528f, 0.01156297f, -0.08608542f, -0.01208924f, 0.04362815f, -0.02423438f, -0.03953944f, 0.04218055f, 
    0.06862767f, -0.07854515f, -0.05605137f, 0.03104280f, 0.01350459f, 0.00463085f, -0.03260626f, -0.04328396f, 
    -0.05143546f, -0.00315276f, -0.08090633f, -0.01703870f, -0.04873247f, 0.00519000f, -0.05947437f, -0.03819528f, 
    0.00871801f, -0.08217365f, -0.04808540f, -0.01144406f, -0.07944223f, -0.06196924f, 0.06689487f, 0.04672128f, 
    -0.06834218f, 0.07369325f, 0.07335570f, -0.07167000f, 0.04380045f, -0.00063250f, -0.07391714f, 0.04525898f, 
    -0.02208586f, -0.02664279f, 0.07481673f, 0.06515121f, -0.06338805f, 0.02986370f, -0.08527566f, -0.05325773f, 
    0.04626817f, 0.06354106f, -0.02575314f, -0.01168120f, -0.08728431f, 0.05669224f, -0.00374717f, 0.01189867f, 
    0.07145257f, 0.00754578f, 0.01532931f, -0.02553611f, -0.08206955f, -0.00653401f, -0.07834734f, -0.03916241f, 
    0.00358856f, -0.02800468f, -0.04256826f, -0.06681675f, 0.00527863f, -0.06622467f, -0.02138281f, -0.04702986f, 
    0.06342386f, -0.00074858f, -0.04447144f, 0.03291788f, -0.03812622f, 0.01953487f, 0.03146922f, 0.00769282f, 
    0.04891711f, -0.03976579f, -0.08731800f, -0.04112883f, 0.06705082f, 0.06625169f, -0.04964532f, 0.06200999f, 
    -0.04665741f, -0.02522601f, -0.14014824f, -0.00894243f, 0.14861284f, -0.06737259f, 0.01218394f, -0.09758009f, 
    0.02545613f, 0.05275552f, 0.03159547f, 0.10979681f, 0.01021707f, -0.09126043f, -0.01970403f, -0.10629039f, 
    0.02648021f, 0.00027078f, -0.22505015f, -0.23537460f, -0.08746216f, 0.10765554f, 0.06135758f, 0.09050699f, 
    0.07749513f, 0.08939911f, 0.08509391f, -0.54548478f, -0.03136548f, -0.36480206f, 0.03102869f, -0.05338840f, 
    -0.03549982f, 0.08736648f, 0.05929102f, 0.04461041f, 0.04234302f, -0.03473356f, 0.16098696f, 0.03810894f, 
    -0.08331215f, -0.02441822f, 0.06578689f, 0.00020942f, 0.21593076f, -0.20872878f, -0.00091897f, -0.15053107f, 
    0.06780908f, 0.09374800f, 0.02668604f, -0.04204950f, -0.11358973f, -0.13894880f, -0.33556956f, -0.33239973f, 
    0.29320261f, 0.15593590f, 0.02320386f, 0.04978768f, 0.11303104f, 0.05762016f, 0.16987295f, -0.20706785f, 
    -0.07601270f, 0.20474501f, -0.04550099f, 0.13948512f, 0.17709616f, -0.02347298f, 0.01076903f, 0.18557133f, 
    0.08149727f, -0.00463443f, -0.06409528f, 0.00528579f, 0.07442966f, -0.18623838f, 0.09125254f, -0.06134070f, 
    -0.11428783f, -0.18506582f, 0.21747197f, 0.23253694f, 0.08080801f, 0.19394822f, -0.04917220f, 0.10299759f, 
    -0.01252861f, 0.11782405f, -0.19023727f, 0.03614099f, -0.21843757f, -0.01961313f, 0.04152410f, 0.08622592f, 
    0.06735887f, -0.00375567f, -0.23138624f, 0.11348795f, 0.11844130f, 0.02847244f, -0.22890648f, -0.09637094f, 
    0.02990589f, -0.09652556f, -0.13400896f, 0.15293886f, 0.17275895f, -0.08630098f, -0.17246304f, -0.03075348f, 
    0.09972911f, -0.19248982f, 0.01865724f, 0.03344805f, 0.03532173f, -0.10391689f, -0.15586793f, -0.02504667f, 
    -0.12346797f, 0.14292486f, -0.05775795f, -0.02865089f, -0.21191539f, -0.07308962f, 0.19798994f, 0.00397179f, 
    0.01037105f, 0.01207193f, 0.08699979f, -0.06789363f, 0.10753752f, 0.06509846f, -0.08072189f, -0.15509503f, 
    0.16126667f, 0.15065600f, 0.02925056f, 0.22085348f, 0.01588853f, -0.07691535f, 0.03595470f, -0.02358213f, 
    0.01081815f, 0.12843722f, 0.04916573f, -0.15617725f, -0.25291133f, -0.24687943f, -0.07307915f, 0.17445728f, 
    0.13396366f, -0.21299182f, -0.03576710f, 0.06743740f, 0.13977872f, -0.14663583f, 0.08904779f, 0.02436826f, 
    0.00284288f, 0.01225615f, 0.26805577f, 0.12836297f, -0.04185339f, -0.08800765f, -0.17697626f, -0.05114367f, 
    -0.06644370f, 0.06414834f, -0.09469558f, 0.09372714f, 0.12539735f, -0.18216465f, -0.01708495f, 0.05369965f, 
    0.05040949f, 0.17013058f, -0.06993670f, -0.20436119f, 0.00688478f, 0.11124773f, -0.04588788f, -0.07898653f, 
    -0.01831081f, -0.12426038f, -0.24050547f, 0.06087280f, 0.02871764f, 0.33744431f, 0.05226984f, 0.22648549f, 
    0.02438290f, 0.00081605f, 0.06115819f, -0.04098498f, -0.05824335f, -0.07474624f, 0.11387543f, 0.28245959f, 
    0.17749609f, 0.00387603f, -0.15425259f, 0.06418823f, 0.01495962f, 0.08392759f, -0.06717908f, -0.34742141f, 
    0.00144683f, 0.19454138f, -0.01256869f, 0.07586684f, -0.07333254f, 0.11015438f, 0.00391460f, 0.04072462f, 
    0.09768301f, 0.03747053f, -0.17267123f, -0.07352791f, 0.10072365f, -0.11455472f, 0.11561426f, 0.09419110f, 
    0.06067052f, -0.18417978f, 0.09521578f, 0.21543658f, -0.08613168f, 0.05173302f, -0.07235685f, 0.03285500f, 
    0.14283475f, -0.03003656f, 0.24468023f, 0.03963928f, -0.00097827f, -0.05706850f, 0.08952161f, 0.19124967f, 
    0.00417078f, 0.12372132f, 0.05999779f, -0.26268938f, -0.11741289f, -0.01373656f, 0.00883996f, 0.11868671f, 
    -0.11662884f, 0.01612912f, 0.05782991f, -0.01679360f, 0.28859505f, -0.24768874f, 0.03703392f, -0.08645708f, 
    0.03464667f, 0.00639346f, -0.12256743f, -0.05175740f, -0.02354145f, -0.24366935f, -0.00474966f, -0.19868407f, 
    0.14598297f, -0.04074270f, -0.13175473f, 0.02284565f, 0.00474687f, 0.00482007f, 0.02893522f, -0.18013941f, 
    0.10949943f, -0.01858655f, -0.04878068f, 0.20668846f, 0.00114089f, -0.00980854f, 0.10739259f, -0.39616075f, 
    0.02083499f, -0.09898677f, 0.07969517f, -0.13777673f, -0.05058756f, 0.06942148f, 0.08955099f, 0.13098578f, 
    -0.01355555f, 0.01128940f, -0.04663190f, 0.02928896f, 0.02073786f, -0.00465590f, -0.01351207f, -0.07298903f, 
    -0.04445926f, -0.08730004f, 0.05992491f, 0.01074851f, -0.02949208f, -0.03650531f, -0.07786350f, 0.02005039f, 
    -0.07047645f, -0.01137729f, -0.02520005f, 0.04680987f, -0.02768352f, -0.06928018f, -0.07106698f, 0.05898219f, 
    -0.00630081f, 0.01236231f, 0.00577839f, -0.05043454f, -0.03164933f, -0.00724006f, -0.04516694f, -0.03959993f, 
    0.07146836f, -0.04765566f, -0.07644884f, -0.06984995f, -0.00979559f, -0.04495539f, 0.03370538f, -0.03891592f, 
    -0.01578963f, -0.06132378f, -0.06793662f, -0.06884322f, -0.03567405f, 0.02321815f, 0.04873900f, -0.01588698f, 
    -0.03810544f, -0.00018142f, 0.06587454f, -0.07299995f, 0.03875827f, -0.03288621f, 0.00027625f, -0.03030941f, 
    0.01970140f, -0.08150493f, -0.03536072f, -0.06432213f, 0.02187629f, -0.00686170f, -0.04356044f, 0.05833067f, 
    0.05731749f, 0.05562371f, 0.02402052f, -0.06032558f, -0.03204640f, 0.05681438f, -0.02181344f, -0.06133632f, 
    -0.02799952f, 0.06398074f, -0.06213618f, 0.02149094f, -0.05180131f, -0.05177676f, 0.00666821f, -0.09160421f, 
    -0.04163608f, -0.07385127f, 0.04086756f, -0.05522301f, -0.07925152f, 0.00150530f, -0.07635271f, -0.06752079f, 
    0.06288049f, 0.06512196f, 0.01956868f, 0.05056423f, -0.09155355f, -0.00441639f, -0.06333713f, -0.07673807f, 
    0.03320725f, 0.07051837f, -0.05703889f, -0.06091363f, 0.01584098f, -0.08283516f, 0.05987902f, 0.03478361f, 
    0.01519440f, 0.04355740f, 0.03555331f, -0.04393236f, 0.06820099f, -0.08248796f, 0.00278628f, 0.02695617f, 
    -0.07933190f, -0.03881294f, -0.07761859f, 0.00349295f, -0.07889985f, -0.00043947f, 0.00913126f, -0.06488388f, 
    -0.03714169f, -0.03498797f, -0.08190776f, -0.01639566f, 0.04727370f, 0.04983724f, 0.02411050f, -0.06020704f, 
    -0.05425374f, 0.02396796f, -0.05252935f, -0.07577511f, -0.04169161f, -0.03365046f, -0.01221996f, 0.04792986f, 
    0.03092081f, 0.02806696f, -0.02597183f, -0.00774833f, 0.01567274f, -0.05069420f, 0.03144349f, -0.00764051f, 
    -0.00823349f, 0.06901513f, -0.07631253f, -0.07236888f, -0.08909978f, -0.07649276f, -0.07719013f, 0.03111105f, 
    0.06817119f, -0.08309794f, -0.04154483f, -0.04002225f, -0.03805351f, -0.00883561f, 0.05649874f, -0.08234970f, 
    -0.04854209f, -0.00091723f, -0.06896867f, -0.00756235f, 0.04298624f, 0.05800859f, 0.01103292f, -0.02632326f, 
    -0.00395092f, 0.03777596f, 0.04214739f, 0.04988812f, -0.05112725f, -0.00910351f, 0.06229376f, -0.05906585f, 
    -0.06643159f, -0.02213207f, 0.06415852f, 0.00823870f, -0.02050865f, 0.01887653f, -0.07064722f, -0.08662873f, 
    -0.06219042f, -0.04050405f, 0.04328395f, -0.03795711f, -0.02885096f, -0.04900323f, -0.03562822f, 0.01149529f, 
    -0.06728396f, -0.00762790f, 0.03020805f, 0.02044709f, -0.06754702f, 0.03463456f, 0.01932329f, -0.07705321f, 
    -0.04063921f, 0.00509699f, 0.01963799f, 0.05479158f, 0.05345876f, 0.03473173f, 0.04850404f, 0.00454880f, 
    0.03650098f, -0.05922393f, -0.05171223f, 0.00224990f, 0.03219029f, -0.00579585f, -0.05079782f, -0.02453341f, 
    0.01804836f, -0.08301425f, -0.09233189f, 0.06706320f, -0.05353070f, -0.04887075f, 0.06601550f, -0.08334579f, 
    0.00969572f, -0.02125031f, 0.05954737f, -0.05765840f, -0.06264619f, 0.04983643f, -0.07539626f, -0.07552669f, 
    -0.02517362f, -0.04063891f, -0.07582729f, 0.01491701f, 0.06887779f, 0.02723611f, -0.01473533f, -0.06578794f, 
    -0.02881707f, 0.00347877f, 0.06925949f, 0.00169292f, -0.07863177f, -0.01392606f, 0.00664558f, 0.04159577f, 
    -0.09784101f, -0.09138761f, 0.04251868f, -0.09946430f, 0.01202134f, 0.05600195f, -0.02042687f, -0.00384304f, 
    -0.00197931f, -0.09560180f, 0.02893807f, -0.04216128f, -0.09997737f, -0.00945331f, -0.08266889f, -0.03739564f, 
    0.01044903f, -0.07654389f, -0.02177630f, -0.06128949f, 0.04920034f, 0.04486164f, 0.05270073f, -0.03910560f, 
    -0.02738392f, -0.05763318f, 0.04492687f, 0.05723520f, 0.03974789f, 0.02482353f, -0.03383536f, 0.03812059f, 
    -0.04732700f, -0.01725817f, -0.02042825f, -0.05867689f, 0.04180872f, -0.08151425f, 0.02927622f, 0.03220266f, 
    -0.05102126f, -0.10880016f, -0.12779033f, 0.06444351f, -0.08768006f, -0.01185858f, 0.07953076f, 0.03912883f, 
    -0.10040729f, -0.04827897f, 0.00246640f, 0.07025168f, -0.07336126f, -0.04452095f, 0.06561933f, -0.02151826f, 
    -0.07544494f, 0.02018304f, 0.05506054f, -0.07388584f, 0.00054547f, 0.03019697f, -0.03726776f, 0.00206980f, 
    -0.00784456f, 0.06372017f, -0.04622540f, -0.10391514f, -0.03225688f, -0.01904640f, -0.08801764f, -0.00592777f, 
    0.06152538f, -0.07586077f, -0.06732070f, 0.05530548f, -0.07708103f, -0.05026603f, -0.08594357f, -0.10583405f, 
    -0.02081893f, 0.00887378f, 0.00763511f, 0.04149666f, -0.04527130f, -0.02081919f, -0.03541462f, -0.09863902f, 
    -0.03459644f, 0.00527391f, -0.02291832f, -0.08994927f, 0.04212714f, 0.01679609f, -0.01510530f, -0.03807423f, 
    -0.00360801f, 0.03586344f, -0.02177989f, 0.00665232f, -0.02285301f, -0.02102977f, -0.04396505f, 0.00213338f, 
    -0.00305520f, -0.08282109f, -0.02380751f, -0.05336889f, -0.03174102f, -0.13297449f, -0.09750906f, -0.02229728f, 
    0.02339396f, -0.05107551f, -0.07327002f, -0.03312486f, -0.07034802f, -0.10839964f, -0.03992563f, 0.05023212f, 
    -0.03713474f, -0.05889694f, -0.09086572f, -0.03726939f, 0.02576404f, -0.03040325f, -0.04024975f, -0.08837122f, 
    -0.10191193f, 0.00615873f, -0.00986103f, 0.00067270f, 0.04156791f, -0.01560805f, -0.00704730f, -0.00543911f, 
    -0.09261155f, -0.04954059f, 0.05119656f, -0.06393896f, -0.07224004f, -0.11400411f, 0.02591293f, -0.08513793f, 
    -0.01430739f, 0.05451004f, -0.06731052f, -0.07802951f, -0.01229009f, 0.00537527f, -0.07807624f, -0.02753615f, 
    -0.08935545f, -0.05207655f, -0.04328218f, -0.08902978f, 0.00968833f, 0.06434984f, -0.04247968f, -0.08217990f, 
    0.03118809f, -0.02947077f, -0.05698293f, -0.11352320f, -0.10992029f, 0.03926782f, -0.03183350f, 0.00680484f, 
    -0.05467756f, -0.01726419f, -0.03035596f, -0.10642803f, -0.06658773f, 0.02959035f, 0.04307169f, 0.00422962f, 
    -0.00678678f, -0.05827865f, -0.01634248f, 0.05140257f, 0.01281353f, -0.06880734f, -0.09123096f, -0.11063284f, 
    0.17066234f, 0.05808317f, 0.02619948f, -0.07804821f, -0.06451626f, -0.05820073f, -0.02874963f, -0.04768945f, 
    -0.11374328f, -0.22552432f, 0.08045592f, -0.16405332f, 0.00766956f, 0.09336400f, -0.02773644f, 0.04422091f, 
    -0.07601976f, 0.10639793f, -0.18371393f, 0.08228035f, 0.06096827f, -0.09437105f, -0.12530497f, 0.07349425f, 
    -0.08913572f, -0.00067892f, -0.05983395f, 0.18914902f, 0.06845335f, -0.05445890f, 0.01969711f, -0.04623951f, 
    -0.06279245f, 0.02099807f, 0.05981108f, 0.16353692f, 0.01990434f, 0.07778338f, 0.00744072f, -0.11255226f, 
    0.00213130f, 0.03973227f, -0.03630222f, 0.12513703f, 0.04853507f, 0.04315602f, 0.16578546f, 0.26314875f, 
    0.01086856f, -0.01399543f, -0.01641895f, -0.16091213f, 0.11370064f, -0.11840323f, 0.20263280f, 0.08125539f, 
    0.20434669f, 0.14198296f, 0.03785842f, 0.01750179f, -0.00964421f, 0.04865351f, 0.01450430f, -0.00082734f, 
    -0.20440969f, -0.11705377f, -0.01683130f, -0.04186840f, 0.08722354f, -0.01760552f, -0.16333947f, -0.14032507f, 
    -0.16214788f, 0.00284679f, -0.13025942f, 0.09385227f, -0.06004431f, 0.04955434f, -0.04297021f, -0.00359919f, 
    0.01966356f, 0.09832431f, 0.03554724f, -0.31029668f, 0.04774360f, -0.00164169f, -0.00557916f, -0.11686999f, 
    -0.03140660f, -0.01187962f, 0.21543474f, -0.26126423f, 0.23438217f, 0.05411419f, 0.27359593f, 0.07268078f, 
    0.02117707f, -0.02494226f, 0.00952660f, 0.05755967f, 0.15413468f, -0.12811320f, -0.15965323f, -0.09424371f, 
    0.01807570f, -0.08784112f, 0.04482993f, 0.03621585f, 0.11828681f, -0.18680820f, -0.10135313f, -0.03701735f, 
    0.01453429f, 0.15541682f, 0.15053245f, 0.02821600f, -0.02366724f, -0.38004512f, 0.23458110f, 0.30831796f, 
    0.12114169f, -0.08559282f, -0.02221138f, 0.17497848f, -0.00906878f, -0.09020508f, 0.29119682f, 0.25349754f, 
    -0.10564721f, 0.10382118f, 0.12154751f, 0.04473683f, 0.06618384f, 0.00241033f, 0.02639350f, -0.34786031f, 
    -0.17468770f, -0.22799297f, -0.14014280f, -0.00055875f, -0.00308389f, 0.27644685f, -0.04923056f, -0.18312880f, 
    -0.06752689f, -0.09752937f, -0.27913910f, -0.02620644f, 0.07956175f, -0.11542991f, -0.03932299f, 0.02647951f, 
    0.08820158f, 0.21622041f, -0.13200711f, 0.05520209f, -0.12432314f, -0.09512113f, 0.02832144f, -0.00183050f, 
    -0.17287438f, 0.00307138f, -0.19319797f, -0.10578816f, -0.15630680f, 0.10233519f, -0.02525918f, -0.00415279f, 
    0.01850359f, 0.05957806f, 0.03030100f, 0.27470076f, -0.04945487f, -0.26804093f, 0.03433801f, 0.01532819f, 
    -0.14193480f, -0.13064203f, -0.03058311f, 0.02552958f, -0.16045232f, -0.07985999f, -0.22439697f, 0.01416262f, 
    0.02473700f, 0.10473680f, -0.01594180f, -0.17717177f, -0.02810925f, 0.01741433f, -0.18674549f, -0.13235997f, 
    0.01279985f, 0.15470463f, 0.06301876f, 0.00955266f, 0.11486384f, -0.15272993f, -0.39789987f, 0.00101107f, 
    -0.02887902f, 0.01331311f, 0.19614807f, 0.16006252f, -0.14272444f, -0.03439942f, -0.05117046f, -0.14895271f, 
    0.11379050f, -0.10575962f, -0.08180068f, 0.05702089f, -0.01390194f, -0.13455977f, 0.05243443f, 0.05208486f, 
    -0.25620243f, -0.26877591f, 0.07207704f, 0.00455790f, -0.04783053f, 0.10724554f, 0.05292875f, -0.11611555f, 
    0.01088301f, 0.07713278f, 0.06680354f, 0.20735201f, -0.04378694f, -0.08987895f, 0.06724326f, 0.06561258f, 
    0.18094625f, -0.02927294f, -0.04742986f, -0.01089083f, -0.16729394f, 0.15083589f, 0.06451457f, -0.09639829f, 
    -0.13377257f, -0.18384305f, 0.06036524f, -0.26117450f, 0.00548672f, 0.14459953f, 0.08631810f, 0.00872528f, 
    0.11772081f, -0.03094856f, 0.16235168f, -0.00819014f, -0.06161127f, 0.06174557f, -0.14292815f, 0.08306753f, 
    -0.09281561f, 0.04780266f, 0.08170345f, 0.05707230f, 0.11736801f, -0.27455130f, 0.10357483f, 0.14006600f, 
    0.00776175f, -0.09817813f, -0.29604310f, -0.04610559f, 0.00278299f, -0.02062492f, 0.20940211f, -0.06372758f, 
    -0.02176282f, 0.17844953f, -0.20870683f, -0.14466336f, 0.39020038f, 0.00031784f, 0.02344767f, 0.11956245f, 
    0.40216836f, 0.10246719f, -0.08457721f, -0.27505654f, 0.10957013f, 0.03591442f, -0.01346136f, 0.14796411f, 
    -0.09748667f, -0.08243833f, -0.01737491f, 0.01092716f, -0.06435023f, -0.00515431f, -0.01321952f, -0.01711130f, 
    -0.06586323f, -0.06972586f, -0.09957106f, 0.02933882f, -0.09788844f, 0.04304040f, 0.00228162f, 0.07650261f, 
    -0.02731239f, -0.01284124f, -0.10619489f, 0.02616362f, -0.08694271f, 0.08251252f, -0.03747473f, 0.01581045f, 
    -0.00586401f, 0.05401090f, -0.08417980f, -0.06712849f, -0.03865023f, 0.00550162f, 0.05285242f, 0.03510661f, 
    -0.02923278f, -0.06306221f, 0.05485432f, 0.00573992f, 0.00880001f, -0.02083551f, 0.01052191f, -0.06964103f, 
    -0.03792906f, 0.01587582f, -0.10553779f, -0.00656115f, 0.05653670f, -0.03369982f, -0.04659656f, -0.00023597f, 
    0.02438332f, -0.05293691f, -0.01834957f, -0.01829610f, 0.03228445f, -0.02907567f, 0.03336578f, -0.02283155f, 
    0.04940025f, -0.05960860f, -0.04928391f, -0.07096223f, 0.07316337f, -0.03921112f, -0.06969603f, -0.01215253f, 
    -0.06588703f, 0.09951692f, 0.00084848f, -0.01386538f, -0.04886749f, -0.01954784f, 0.02733981f, 0.03105799f, 
    0.07038606f, 0.01794189f, -0.02605864f, 0.03296920f, -0.07710805f, -0.07675647f, 0.07198772f, -0.02966100f, 
    0.00946459f, 0.03657590f, -0.06181151f, 0.07629025f, 0.01441076f, -0.09374499f, 0.00003999f, 0.07614485f, 
    -0.06239105f, -0.02933132f, -0.03932368f, -0.10663275f, 0.08854063f, -0.04694040f, -0.02197744f, -0.04276780f, 
    0.07666427f, 0.00385368f, 0.05618402f, 0.03464303f, 0.00847067f, -0.00831793f, 0.00474516f, 0.02778685f, 
    0.04341277f, 0.02956038f, -0.10525323f, -0.02094120f, -0.03053777f, -0.07396596f, -0.01045682f, -0.01037418f, 
    0.03767116f, -0.04874343f, 0.01379340f, -0.06288903f, -0.11006312f, -0.02501135f, -0.10618822f, -0.01942575f, 
    -0.08556652f, 0.01517553f, -0.07059241f, -0.02063987f, 0.05580845f, 0.02891370f, 0.02289389f, -0.01102029f, 
    -0.07535330f, -0.05262082f, 0.00882423f, -0.05894692f, -0.07052729f, -0.04681841f, -0.02914449f, -0.05546516f, 
    0.00116895f, -0.00686263f, -0.06260766f, -0.02603472f, -0.08222017f, -0.06724764f, 0.00473404f, -0.00430916f, 
    0.11075427f, 0.20316243f, 0.30351129f, 0.05621766f, 0.07421041f, 0.04339511f, -0.07466906f, -0.10845463f, 
    -0.08368068f, 0.04188183f, 0.03537471f, 0.01440838f, -0.03955376f, -0.15549183f, -0.11061684f, 0.06328375f, 
    0.06475334f, 0.17473695f, 0.02353077f, -0.32176429f, 0.16765842f, -0.09362588f, -0.26476592f, -0.05744418f, 
    0.05137775f, 0.04188357f, 0.00210640f, 0.27601296f, -0.06341746f, 0.04318659f, -0.05855422f, 0.03505927f, 
    -0.05772892f, -0.03696322f, -0.04974855f, 0.14913577f, 0.05640805f, -0.04560937f, -0.17421915f, 0.06766685f, 
    0.06040702f, 0.01171654f, -0.07494050f, 0.10653913f, 0.19836767f, -0.27104780f, -0.17868583f, -0.02806756f, 
    0.07712440f, 0.00169721f, 0.02524634f, 0.08227997f, -0.15035710f, -0.04644341f, -0.35211965f, -0.03691322f, 
    0.31227475f, -0.06950898f, -0.04124854f, -0.04900244f, -0.05325978f, -0.06745759f, 0.16224471f, -0.19578190f, 
    -0.29794061f, -0.38338688f, 0.16880880f, 0.09906692f, 0.15358242f, 0.08608487f, -0.07496446f, 0.05079087f, 
    -0.54401195f, -0.27977124f, -0.17402938f, 0.11688466f, -0.13978720f, -0.10548360f, -0.00083645f, -0.05533940f, 
    0.10016929f, -0.03738321f, 0.07954276f, 0.07442848f, 0.15723130f, 0.10170740f, -0.02067373f, 0.02587654f, 
    0.05158234f, 0.08754808f, -0.09726782f, 0.17142436f, -0.06898773f, 0.05173892f, 0.01717816f, -0.22750440f, 
    0.18991208f, 0.12814368f, -0.29656985f, 0.07207528f, -0.04069395f, -0.32400140f, -0.11344422f, 0.03528168f, 
    0.07141179f, -0.01180203f, 0.05366009f, 0.03328760f, 0.18593717f, 0.13394584f, 0.05197708f, 0.09017695f, 
    0.07814044f, -0.00625095f, 0.03585174f, 0.09196978f, -0.00461066f, 0.36286998f, 0.30276421f, -0.13864803f, 
    0.03959588f, -0.10590652f, -0.11415214f, 0.00062962f, -0.02953724f, 0.00022530f, 0.12413869f, -0.02965766f, 
    0.00596540f, -0.09686839f, -0.09630469f, 0.00562435f, -0.03085328f, 0.05864606f, -0.05419084f, 0.13719444f, 
    0.07596006f, 0.11926774f, 0.07181372f, 0.08059077f, -0.01194580f, -0.09060618f, -0.01648004f, -0.00186971f, 
    -0.08201186f, -0.34952846f, -0.15221401f, 0.04635007f, 0.09071721f, 0.02005704f, 0.04351737f, -0.00002499f, 
    0.07373380f, 0.45184267f, -0.12143500f, -0.18685566f, -0.18755090f, -0.11515342f, 0.03959497f, -0.01475230f, 
    0.08487685f, -0.02785677f, 0.43529668f, -0.20950164f, -0.06647470f, -0.04335867f, 0.05741759f, -0.11673733f, 
    -0.00442831f, -0.03245435f, -0.07406849f, 0.15760222f, -0.13694379f, -0.12857695f, -0.11977658f, -0.25545779f, 
    -0.08403055f, 0.06645820f, -0.00385643f, -0.03248404f, 0.07145703f, 0.07217845f, -0.06270866f, 0.06672111f, 
    -0.01496730f, 0.01890018f, -0.06656931f, 0.04041090f, -0.13846719f, -0.05448100f, -0.20729904f, -0.09904022f, 
    0.13787234f, 0.02914388f, 0.17607212f, -0.01260109f, 0.04981302f, -0.07437985f, 0.27098078f, 0.06384971f, 
    -0.08608591f, 0.14373434f, -0.01501824f, 0.19686030f, 0.03866249f, -0.05410589f, -0.01349562f, -0.53572178f, 
    0.21334960f, 0.02424870f, -0.04281224f, 0.07465588f, 0.03463310f, 0.07319271f, -0.04809982f, 0.00263868f, 
    0.18596496f, -0.00289795f, 0.10670026f, 0.04731828f, 0.05472929f, -0.04924028f, 0.02838622f, 0.01423935f, 
    0.00528441f, -0.37037605f, 0.30954054f, 0.07826301f, -0.03537191f, 0.30169493f, 0.10310000f, 0.00121418f, 
    -0.03403744f, 0.13158308f, 0.21004172f, 0.08925693f, -0.11556588f, -0.09209695f, -0.10114507f, -0.03315253f, 
    -0.19669187f, -0.07600611f, -0.03705962f, 0.03358143f, 0.37286627f, -0.00716189f, 0.00975485f, 0.00448100f, 
    0.02145375f, -0.12922059f, 0.04674262f, 0.06182658f, 0.09982077f, 0.16104655f, -0.05694021f, -0.06196906f, 
    -0.02349205f, 0.11786867f, -0.03281425f, 0.13669641f, -0.07189530f, 0.17475015f, -0.09495263f, -0.14943846f, 
    0.03168292f, -0.19203067f, 0.10582379f, -0.09683081f, -0.05713217f, -0.09231273f, 0.18445075f, -0.28877556f, 
    -0.08985641f, 0.05271950f, 0.03228276f, -0.07308882f, 0.05831194f, -0.14846748f, 0.00462584f, -0.22336026f, 
    0.21600479f, -0.12404830f, 0.10401595f, 0.18765840f, -0.06888703f, 0.04401921f, 0.13896327f, -0.07618308f, 
    -0.03264168f, -0.05186995f, 0.14982904f, -0.01423021f, -0.05845490f, -0.08398771f, 0.01760787f, 0.00851113f, 
    -0.06919555f, -0.32887396f, -0.02524396f, 0.34479985f, 0.08487673f, -0.02635281f, -0.09214611f, 0.03367843f, 
    -0.14978740f, 0.03430194f, -0.18796125f, -0.14180885f, 0.11303123f, -0.11109604f, 0.03581902f, -0.08010276f, 
    -0.01507630f, 0.03199865f, 0.06713589f, -0.01410062f, 0.08584417f, 0.21301965f, 0.03235266f, 0.09287994f, 
    -0.07868755f, 0.01666423f, 0.10575311f, -0.05015343f, 0.07258636f, -0.12871537f, -0.08566207f, -0.04989578f, 
    -0.08284115f, -0.07014591f, 0.07376420f, -0.14289162f, -0.01559451f, 0.05295097f, -0.17679825f, -0.17476943f, 
    0.08949327f, 0.18179066f, 0.16418822f, -0.06402443f, -0.12903330f, -0.28272179f, -0.19922209f, 0.17259800f, 
    -0.15008900f, -0.00584374f, 0.20125814f, -0.00772530f, -0.11353008f, 0.11708862f, 0.01170356f, 0.12733237f, 
    0.09501559f, -0.17423068f, -0.02607524f, -0.03174329f, -0.00139758f, 0.00519138f, 0.09173550f, 0.07156511f, 
    -0.14827912f, -0.09488248f, 0.08118735f, 0.07651313f, -0.12301511f, -0.04224707f, 0.06231075f, 0.07421847f, 
    0.02311970f, 0.42240477f, 0.18663213f, 0.18059243f, -0.00035691f, -0.18159628f, 0.01298017f, 0.09060034f, 
    0.08634583f, 0.06266157f, 0.09946307f, -0.13222174f, -0.62152410f, 0.01594783f, 0.00647613f, -0.03084176f, 
    -0.03449136f, -0.01160854f, 0.04857128f, 0.20672023f, 0.03572150f, 0.03847212f, 0.08869449f, 0.04289277f, 
    0.11397963f, -0.08410390f, -0.07458447f, 0.13898908f, -0.26482487f, -0.25837606f, -0.20333831f, -0.09683079f, 
    0.02841332f, 0.02643294f, 0.08407371f, 0.01976080f, 0.05355311f, 0.20721142f, 0.14227943f, 0.15586822f, 
    -0.10383979f, 0.16510171f, -0.11513589f, -0.18774520f, 0.03449050f, 0.00964279f, -0.14783584f, 0.07298990f, 
    -0.07638492f, 0.01205796f, -0.01373023f, -0.06576873f, 0.13342156f, 0.01983840f, -0.05215781f, 0.34318212f, 
    -0.03132387f, -0.04795613f, -0.09656265f, -0.15053242f, 0.17562905f, 0.04651222f, 0.01912311f, 0.03842372f, 
    0.00343777f, 0.02899507f, -0.09651515f, 0.13822684f, 0.00339539f, 0.08614262f, -0.13780621f, -0.07799620f, 
    -0.13049197f, 0.21818849f, 0.04503454f, -0.09588616f, 0.03293271f, 0.13303825f, -0.00251993f, -0.02201618f, 
    0.12330596f, -0.00972811f, -0.12995408f, 0.09848468f, -0.04531475f, -0.09147138f, 0.00724356f, 0.01198509f, 
    -0.01826918f, -0.01220281f, -0.01490943f, -0.44743443f, 0.34548694f, 0.03358398f, -0.08059712f, 0.04089485f, 
    -0.03429508f, 0.02481598f, 0.01297066f, -0.01721190f, 0.15169825f, -0.29775447f, -0.36938155f, 0.02620144f, 
    0.04903753f, 0.07537027f, 0.11928464f, -0.01916819f, -0.08671733f, 0.01938673f, -0.02378646f, -0.40460551f, 
    0.01771398f, 0.15218565f, -0.00771525f, -0.01427687f, 0.00353272f, -0.14324017f, 0.21404490f, 0.24489512f, 
    0.04397548f, -0.00605308f, -0.10683436f, 0.05483990f, 0.04729871f, 0.01543777f, 0.12694712f, 0.10647961f, 
    0.01342324f, -0.05832135f, -0.02217479f, -0.08532720f, 0.04654314f, 0.06204929f, 0.08697754f, -0.08492984f, 
    -0.38123465f, -0.26325557f, -0.22394292f, 0.07235926f, 0.01999457f, 0.16075304f, 0.06265917f, 0.02521183f, 
    0.00572140f, 0.25927508f, 0.23743196f, 0.07507522f, 0.16651665f, 0.06832304f, 0.05681073f, 0.07157816f, 
    -0.02607854f, 0.00327560f, 0.31608927f, -0.09019720f, 0.31094179f, -0.01746010f, -0.01962439f, -0.02233762f, 
    0.05717823f, 0.07035811f, 0.19572243f, 0.24718262f, -0.46124950f, -0.03838646f, 0.10884356f, -0.13152066f, 
    0.13372554f, 0.04868024f, -0.13503966f, 0.06550201f, -0.32885474f, 0.12413214f, 0.04250975f, 0.14796574f, 
    -0.00060758f, -0.00433778f, -0.09426038f, -0.14014138f, 0.00453469f, 0.18560442f, -0.43285012f, -0.10465305f, 
    -0.11672612f, -0.10236821f, -0.11123978f, 0.02590545f, -0.01449572f, 0.12164189f, -0.11537076f, 0.09241889f, 
    -0.07987363f, 0.00003032f, 0.12077113f, -0.14249171f, -0.09918495f, 0.13220322f, -0.22222219f, 0.04107437f, 
    -0.26019159f, 0.18881777f, 0.02539549f, -0.20672931f, -0.05765777f, -0.07267496f, 0.15434261f, 0.01942288f, 
    0.16939962f, 0.21436992f, -0.16457841f, -0.00221247f, -0.05185670f, 0.09917042f, 0.19883873f, -0.07123264f, 
    -0.06589103f, -0.17536694f, -0.09638223f, 0.00244666f, 0.10482529f, -0.21251583f, 0.06511008f, 0.05691903f, 
    -0.06472095f, -0.02597944f, -0.11426526f, 0.17748250f, 0.14877416f, -0.20042175f, -0.02398423f, 0.11678996f, 
    -0.12702833f, 0.09920008f, 0.03084910f, 0.11001850f, 0.17142655f, 0.10463099f, -0.03533925f, -0.11777626f, 
    -0.06456581f, 0.01534093f, 0.04549808f, 0.00199818f, 0.09963819f, 0.02745402f, -0.04574918f, -0.14870450f, 
    0.06219943f, -0.03540668f, -0.02861543f, -0.00328288f, -0.01792663f, -0.07106324f, 0.13987559f, 0.05474989f, 
    0.06866507f, 0.14332707f, 0.09256167f, 0.00632745f, -0.14780253f, -0.08170831f, -0.05563010f, 0.00492879f, 
    -0.08477341f, 0.04745820f, 0.10518608f, -0.07696266f, 0.03560693f, 0.03130297f, 0.10751163f, -0.22399299f, 
    -0.10797903f, -0.04823910f, 0.00261626f, 0.09172843f, 0.12583227f, -0.05712428f, 0.01037682f, -0.05558627f, 
    0.61399871f, -0.03250834f, -0.03590705f, -0.05067910f, -0.00188526f, -0.08511430f, 0.04847836f, 0.04712364f, 
    -0.11060353f, -0.38878658f, -0.33558860f, 0.09711359f, 0.11164960f, 0.06952956f, 0.08703836f, -0.00841542f, 
    0.04623624f, -0.03704483f, 0.26255453f, 0.11987843f, -0.03338348f, -0.06203031f, -0.15155868f, -0.00275230f, 
    0.00011220f, 0.13523322f, 0.02248127f, 0.18613735f, 0.06030551f, -0.06513941f, 0.05389602f, 0.12793386f, 
    -0.03189019f, -0.00460809f, -0.02057490f, -0.02910612f, -0.01373517f, 0.14258908f, 0.02376108f, 0.17135841f, 
    0.03951508f, -0.08221731f, -0.14433765f, 0.06674343f, 0.02416190f, -0.06774782f, -0.07732174f, -0.29271296f, 
    -0.05518037f, -0.04155853f, -0.17297262f, -0.03362063f, 0.02573631f, -0.06301112f, -0.13102764f, -0.18553203f, 
    -0.06473362f, -0.00241291f, 0.09004050f, -0.06119800f, -0.07093621f, -0.01614930f, 0.25185913f, -0.17304493f, 
    -0.37456715f, 0.10659794f, 0.08390897f, 0.07408465f, 0.03444123f, 0.06262963f, -0.07496522f, 0.02142435f, 
    0.17580262f, -0.24791048f, 0.03833474f, -0.16324411f, -0.19552821f, 0.05651715f, 0.09287907f, 0.08625405f, 
    -0.07833638f, -0.42552933f, -0.09427071f, -0.04811638f, 0.02466197f, -0.05671920f, 0.14082308f, -0.01974113f, 
    -0.02367079f, -0.04575013f, 0.12285794f, -0.02803093f, 0.07577895f, -0.01296005f, -0.11373419f, -0.12229363f, 
    -0.05259437f, -0.01401890f, -0.08901973f, -0.07009833f, -0.03557706f, 0.02893179f, -0.21331698f, -0.05110681f, 
    -0.04376240f, 0.01894818f, -0.10800552f, 0.13514285f, 0.23931515f, -0.07376877f, 0.21995455f, -0.01771341f, 
    -0.08336136f, -0.02697895f, 0.09171974f, -0.10095390f, -0.03224632f, -0.09998631f, -0.03852462f, 0.17424776f, 
    -0.06373935f, -0.02177115f, -0.06100748f, -0.02110078f, -0.06080071f, -0.00635845f, 0.11054402f, -0.06108846f, 
    0.04939505f, -0.16760343f, 0.01082555f, -0.02548652f, 0.04102623f, 0.15671253f, 0.11585087f, 0.19469500f, 
    -0.31101996f, 0.08904694f, 0.10979629f, 0.05590262f, -0.02755570f, 0.02520398f, -0.12838612f, 0.00673364f, 
    -0.21720591f, -0.13992175f, 0.05749005f, 0.12607464f, -0.12837508f, -0.12158978f, 0.03848539f, -0.02805757f, 
    0.02367371f, -0.10548030f, -0.29105693f, -0.21675797f, 0.02795120f, 0.19266616f, 0.20261152f, 0.11867840f, 
    0.06015681f, -0.03192708f, 0.12204234f, -0.01462508f, 0.01828485f, -0.05640598f, -0.23824726f, -0.10629019f, 
    0.11482868f, 0.15081538f, -0.02802858f, 0.39236808f, -0.07011841f, 0.18870507f, 0.02076844f, -0.04892242f, 
    -0.03402360f, -0.00000011f, 0.07645223f, 0.22655764f, 0.10916960f, -0.08443759f, -0.06686048f, -0.02288573f, 
    0.04313947f, 0.02142758f, 0.06147721f, -0.06185348f, -0.06361768f, -0.15490678f, -0.05086086f, -0.00289006f, 
    0.07462520f, 0.12565990f, -0.03368557f, 0.03619058f, 0.08663853f, 0.18357727f, -0.07956500f, -0.13464966f, 
    -0.09634866f, -0.02810553f, 0.12464054f, 0.05141228f, -0.26270401f, 0.16441917f, -0.22451974f, -0.13764277f, 
    -0.10041422f, 0.03411171f, 0.10684951f, -0.15034865f, -0.01130673f, 0.24249993f, -0.00895359f, 0.05284616f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.18093981f, -0.06333393f, 0.04802158f, 0.15946534f, -0.07818167f, 0.03473587f, -0.00329723f, -0.09041873f, 
    0.24918251f, -0.01168472f, 0.00801963f, 0.16745311f, 0.03568637f, 0.15845278f, 0.06431583f, -0.01089807f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.18315066f, 0.20159167f, -0.17508833f, -0.09461085f, 0.07811421f, 0.05529720f, -0.12295181f, -0.01278902f, 
    0.09206077f, 0.17729321f, -0.26596826f, 0.12835345f, -0.21447685f, -0.04171791f, -0.05230176f, -0.21629566f, 
    0.05876375f, -0.18965489f, 0.24074303f, -0.05405689f, 0.20077178f, 0.05304002f, 0.16152635f, 0.20196265f, 
    0.32773486f, 0.12326033f, -0.56621206f, 0.13987777f, 0.00215072f, 0.27887887f, -0.17601575f, -0.41646060f, 
    0.18749811f, 0.10857569f, 0.38373807f, 0.33304557f, 0.00385270f, -0.20217571f, -0.10276622f, -0.01718287f, 
    0.25506708f, 0.01434600f, -0.25423807f, -0.14846948f, 0.01758899f, 0.22964691f, 0.28033918f, -0.53253156f, 
    0.23391996f, -0.09217384f, 0.54619312f, 0.07888556f, -0.16694638f, -0.09256043f, 0.02066985f, 0.10055106f, 
    -0.36911029f, -0.19506735f, -0.02583514f, 0.24370576f, -0.25647476f, -0.12546268f, -0.37199074f, 0.23616882f, 
    -0.21700749f, 0.01908362f, 0.08498572f, -0.20718458f, 0.03728780f, 0.18447077f, 0.15447447f, 0.01784217f, 
    0.43421802f, -0.25640625f, -0.16427103f, 0.39906475f, 0.02059607f, -0.37501228f, 0.10742823f, -0.18299446f, 
    0.06750235f, 0.18956906f, -0.31568348f, -0.10218278f, -0.06641674f, -0.07443492f, -0.10062429f, -0.14700429f, 
    -0.01085485f, 0.03489339f, 0.16717553f, 0.35477498f, 0.40497950f, -0.22883816f, -0.00541470f, -0.08087822f, 
    -0.17454812f, 0.01884988f, 0.20839064f, -0.33180597f, 0.06171262f, -0.23216313f, -0.24485913f, 0.26118442f, 
    0.12946244f, -0.16698948f, 0.02948062f, -0.31699732f, 0.14751370f, 0.08661598f, -0.27337405f, 0.29960978f, 
    -0.11679041f, 0.05661485f, -0.22368810f, -0.16332686f, 0.08458146f, 0.04588020f, 0.09096834f, -0.07759720f, 
    -0.18833306f, -0.13921148f, 0.13515994f, -0.08048406f, -0.03344437f, -0.16335288f, -0.14968246f, 0.23083434f, 
    -0.19720423f, 0.05242607f, 0.07201538f, 0.30792737f, 0.07920307f, -0.13365433f, -0.19415411f, -0.49913245f, 
    -0.09077691f, 0.01495168f, -0.20220906f, 0.24429075f, 0.27050656f, -0.17348239f, -0.55465657f, 0.10327069f, 
    0.02486622f, 0.24133821f, 0.40369502f, -0.16898668f, 0.21091251f, -0.16372600f, -0.15842250f, 0.44839549f, 
    0.06562450f, -0.21279941f, -0.24370280f, -0.13591450f, -0.19378701f, 0.14535235f, -0.13432673f, -0.05951114f, 
    -0.23437333f, -0.07933902f, 0.05740476f, 0.01802528f, 0.00237387f, 0.00584968f, 0.10590322f, -0.24879985f, 
    0.32667628f, 0.00456202f, 0.33837572f, 0.17731944f, -0.44580126f, 0.00092791f, 0.30769265f, 0.10868660f, 
    -0.36522293f, -0.12047449f, 0.57833081f, -0.21985899f, 0.08335152f, -0.03268567f, -0.10857488f, -0.24409722f, 
    0.28760707f, 0.15340695f, 0.11962099f, 0.30076319f, -0.23515519f, 0.09488804f, -0.23631284f, 0.20610654f, 
    0.02386092f, -0.14997697f, -0.06034337f, -0.03757550f, 0.18666568f, 0.04751813f, -0.17764953f, 0.15813930f, 
    -0.34598103f, 0.24803242f, -0.15339242f, 0.47931477f, -0.25953075f, 0.05363216f, -0.16332653f, 0.23924401f, 
    -0.12415424f, -0.12225071f, -0.03535712f, -0.20276138f, 0.18184388f, 0.08586994f, 0.19104654f, -0.23949349f, 
    -0.07967210f, -0.08966455f, 0.16763306f, -0.21218252f, -0.01885313f, -0.14921167f, -0.00286782f, 0.15670264f, 
    -0.15370198f, -0.19559601f, 0.12934379f, 0.03721172f, 0.13364995f, 0.15556671f, 0.22554941f, 0.16075452f, 
    -0.20266601f, 0.09678244f, 0.05624058f, -0.02416099f, 0.29957142f, -0.00290257f, -0.31970984f, 0.18207267f, 
    0.00702464f, 0.03243177f, -0.05464899f, -0.21881935f, 0.05813256f, 0.04213155f, 0.21481091f, 0.43860039f, 
    -0.37575811f, -0.22548322f, 0.04611828f, 0.15947917f, -0.18043025f, -0.17785719f, 0.18783934f, 0.34506315f, 
    -0.23340967f, 0.24115774f, -0.10697082f, -0.23375300f, 0.10889673f, -0.16357201f, 0.11546442f, 0.01722097f, 
    -0.08722344f, -0.05248854f, -0.24536255f, -0.01171488f, -0.07037389f, -0.21461222f, -0.12436453f, -0.04639417f, 
    0.05556381f, -0.20491770f, 0.09472530f, 0.03060045f, -0.14016733f, 0.12854363f, 0.07619011f, -0.05310676f, 
    -0.06677120f, -0.25342825f, -0.07101715f, 0.08782967f, 0.45066461f, 0.00465134f, -0.09520882f, -0.45236132f, 
    0.00486041f, -0.19681808f, -0.43636388f, -0.15019640f, -0.01453081f, -0.11150288f, -0.13889065f, 0.08458221f, 
    0.05611936f, 0.02041138f, 0.06224157f, 0.25635767f, 0.04192546f, -0.24445187f, 0.46662441f, -0.14645910f, 
    -0.10823723f, 0.07029617f, -0.24407364f, 0.01075406f, -0.12883249f, -0.20923269f, 0.19562632f, -0.21982676f, 
    -0.17264341f, 0.08129573f, 0.04638471f, -0.17453495f, 0.00393089f, 0.04772804f, -0.13647944f, 0.12820832f, 
    0.31168619f, -0.21826038f, 0.09005013f, 0.23791155f, 0.16908234f, -0.13420641f, 0.08916742f, 0.25321996f, 
    -0.08340768f, 0.21042719f, -0.38937792f, -0.03014668f, -0.02676848f, 0.20413370f, -0.20410053f, 0.26709023f, 
    -0.20585933f, 0.01489986f, -0.34853405f, -0.17919162f, 0.11851487f, 0.10174298f, 0.26176444f, 0.31043613f, 
    -0.23969668f, 0.08043142f, 0.26600918f, 0.13487275f, -0.02584389f, 0.34802598f, 0.10947184f, 0.42028826f, 
    -0.18974888f, -0.21866775f, 0.08026513f, -0.21438855f, -0.03237754f, -0.11686528f, -0.03265747f, -0.03913468f, 
    -0.09733093f, 0.10496548f, -0.17109439f, -0.15732169f, -0.04564774f, 0.16538936f, 0.13486761f, -0.06865427f, 
    0.20828882f, -0.16024640f, 0.13082291f, 0.11147995f, -0.00882161f, -0.18483153f, -0.04639740f, 0.20480135f, 
    -0.30756477f, -0.08237852f, -0.06939720f, -0.28533676f, 0.31576240f, -0.13828906f, 0.15654221f, 0.08847564f, 
    0.01976622f, -0.12055698f, 0.06082572f, 0.00220877f, 0.12114254f, 0.17901875f, 0.29265049f, -0.11045942f, 
    -0.12191528f, -0.16987079f, 0.33098996f, -0.22394042f, -0.25056377f, 0.50307637f, 0.24077950f, 0.15409359f, 
    -0.37199524f, -0.05215141f, -0.25348699f, 0.00267664f, -0.21699804f, 0.15949917f, -0.23834033f, 0.18219894f, 
    0.19665717f, -0.22841053f, -0.08748695f, 0.40669182f, 0.02509836f, 0.50294834f, -0.21491578f, -0.17209490f, 
    0.02229562f, 0.05276984f, -0.04125112f, 0.37349191f, 0.08872209f, -0.21144064f, 0.11162823f, -0.38672534f, 
    -0.24246199f, 0.06291287f, -0.18538332f, -0.16593379f, 0.25961292f, 0.24413274f, 0.27898386f, -0.06901596f, 
    0.53664720f, 0.02316060f, -0.26431197f, -0.18071559f, 0.18748139f, 0.01902697f, 0.15180790f, 0.01767375f, 
    -0.20604937f, -0.10201415f, -0.00919875f, 0.11121693f, 0.25742704f, 0.30868080f, -0.43188319f, -0.11472736f, 
    -0.34361646f, 0.17453347f, -0.25372857f, 0.05617519f, -0.24033269f, 0.19284517f, 0.02343534f, 0.37634304f, 
    -0.41859192f, -0.09242015f, 0.13601261f, -0.05717734f, -0.06993054f, 0.21626173f, 0.21822202f, 0.13047808f, 
    0.39763397f, -0.14816403f, -0.10223939f, -0.20760483f, 0.22931623f, -0.02443327f, 0.19158883f, -0.21846451f, 
    0.16967343f, 0.23313560f, 0.44039294f, 0.03015845f, -0.28963208f, 0.38511452f, 0.33372617f, 0.09030309f, 
    -0.20261797f, -0.02805404f, -0.09689620f, -0.16921076f, -0.19550264f, 0.19338486f, 0.19603546f, 0.42431346f, 
    -0.34893727f, -0.10997898f, -0.00402488f, 0.17401254f, 0.37949449f, -0.12545455f, 0.00749687f, 0.17973164f, 
    -0.01458415f, -0.15463090f, 0.24348357f, -0.02394338f, 0.06630186f, 0.21952891f, -0.08684173f, 0.32814240f, 
    -0.48025638f, 0.16268954f, -0.26758969f, 0.32853007f, -0.13432442f, -0.08210982f, 0.04263703f, 0.14186233f, 
    -0.18254980f, 0.21649122f, 0.14068222f, 0.20373045f, 0.23910175f, 0.02203034f, 0.04744152f, 0.31030592f, 
    -0.34614703f, -0.01920846f, -0.10461193f, 0.31919754f, -0.18219857f, -0.04736855f, 0.04814836f, 0.10917647f, 
    0.28274572f, 0.05004877f, 0.11787595f, 0.32402360f, -0.22063684f, -0.19231004f, 0.05455306f, 0.07545810f, 
    -0.09365088f, 0.00773269f, 0.28984231f, -0.20792283f, -0.26631930f, -0.14791316f, 0.05386711f, 0.07640288f, 
    0.05216024f, 0.21413264f, -0.39679649f, 0.09641232f, 0.14690462f, 0.05352096f, 0.09614439f, 0.43553784f, 
    -0.11035051f, -0.20434433f, -0.13816775f, 0.21388863f, -0.06280796f, -0.03489018f, -0.22590370f, -0.11689719f, 
    -0.01781304f, -0.16021457f, -0.10839060f, 0.04631368f, -0.20282266f, -0.12021686f, 0.06032657f, 0.14356603f, 
    0.00618726f, -0.18152870f, -0.62487435f, -0.01457037f, 0.33308154f, 0.21684983f, 0.11036828f, -0.45575547f, 
    0.23479651f, -0.07115865f, -0.32915345f, -0.12304886f, 0.10260221f, -0.12917201f, 0.03814827f, 0.01224598f, 
    0.42837608f, -0.02950512f, 0.29399005f, 0.00338911f, -0.04606910f, -0.06255963f, -0.26233572f, 0.03834795f, 
    -0.51967978f, 0.05190072f, 0.15955871f, -0.29115140f, 0.18282938f, -0.06531735f, -0.04592639f, 0.11505205f, 
    -0.13768007f, -0.15245456f, 0.03079067f, 0.26646745f, 0.05010742f, 0.14248586f, 0.21351103f, 0.18555839f, 
    0.39656514f, -0.20424065f, -0.50085151f, -0.06330512f, 0.23646173f, -0.24509573f, -0.17020512f, 0.40638274f, 
    0.05022855f, 0.21380608f, -0.51098651f, -0.01491844f, 0.36111277f, 0.21187808f, -0.25714737f, -0.40367195f, 
    -0.17595726f, 0.20662135f, 0.24915552f, -0.18431789f, 0.12016058f, -0.10354415f, -0.10821408f, -0.22021280f, 
    0.30543312f, 0.24289581f, 0.01895779f, 0.08325654f, -0.08327078f, -0.67741162f, -0.02845571f, 0.00272570f, 
    0.40638015f, -0.15060323f, -0.02994959f, 0.13880815f, 0.01887756f, -0.05602506f, 0.03493575f, 0.38297790f, 
    -0.19637634f, 0.18970039f, 0.10434244f, -0.03259164f, -0.27164748f, 0.09370020f, -0.26145542f, -0.10952612f, 
    0.26565287f, 0.00352355f, 0.07369322f, -0.08717740f, 0.22360039f, -0.13180014f, 0.25779736f, -0.12817146f, 
    0.13025302f, 0.02619127f, -0.05239963f, -0.24854283f, -0.09821969f, 0.45313936f, 0.38161442f, -0.18241885f, 
    0.28169295f, 0.10747287f, -0.04399927f, 0.05194801f, 0.10704809f, 0.18104976f, 0.22158416f, 0.31900465f, 
    0.10174940f, 0.17559682f, -0.01822523f, -0.05503875f, -0.11072356f, -0.45864379f, 0.30891231f, 0.23454274f, 
    0.08542490f, 0.10236437f, 0.17511418f, -0.07250541f, -0.10293987f, 0.19883867f, -0.11995906f, -0.18348233f, 
    -0.08819412f, 0.09514233f, -0.22191404f, 0.33361444f, 0.14703105f, 0.18955006f, -0.20881973f, 0.11090625f, 
    -0.11969733f, -0.05089889f, -0.05073387f, 0.20423032f, 0.04366544f, -0.22027443f, -0.11400139f, -0.16131774f, 
    -0.02729061f, 0.22907646f, 0.12632094f, 0.38467667f, 0.23328540f, -0.33030757f, -0.33131129f, 0.15605816f, 
    0.20076476f, 0.02213335f, -0.27863750f, -0.19695695f, -0.14706606f, -0.19010919f, 0.11801064f, -0.22942114f, 
    0.12209816f, 0.00251898f, -0.12961887f, -0.18201952f, -0.10726628f, -0.20690447f, 0.05410447f, -0.25640512f, 
    -0.24314810f, -0.04473805f, 0.05366066f, -0.24755599f, 0.10907349f, -0.13728604f, -0.11000815f, -0.03348314f, 
    -0.33345675f, -0.00040540f, -0.26518875f, 0.44451860f, -0.02201507f, 0.14833519f, 0.06640875f, 0.39992356f, 
    -0.45679814f, 0.12706067f, 0.32512709f, -0.19910458f, 0.13019964f, 0.07985850f, 0.03582472f, 0.29201925f, 
    -0.31061065f, 0.01762470f, -0.16458727f, 0.28283837f, 0.34308332f, -0.17931995f, -0.06941314f, -0.20677419f, 
    -0.14111248f, -0.14806853f, -0.03646149f, -0.00969298f, 0.23150031f, 0.23018032f, 0.15810631f, 0.08186102f, 
    -0.02189725f, -0.02853432f, -0.66868430f, 0.08452304f, 0.44289941f, 0.01368413f, 0.08288337f, -0.32997599f, 
    -0.14188637f, -0.15788986f, -0.18773249f, 0.28105357f, -0.13341184f, -0.12658291f, 0.25352940f, 0.21924791f, 
    -0.18956411f, -0.12451507f, -0.28879938f, -0.10507040f, 0.23020425f, 0.18531838f, -0.05011512f, -0.16856615f, 
    0.17948240f, -0.16278556f, -0.38787588f, -0.35706580f, -0.17559290f, -0.02075862f, -0.08525448f, -0.27032027f, 
    -0.01902340f, 0.10864317f, 0.35374239f, 0.21632828f, 0.20207874f, -0.09738011f, -0.13083987f, 0.25197378f, 
    -0.30720475f, -0.02497450f, 0.50313711f, -0.11314896f, -0.18864933f, -0.19439335f, 0.15204611f, 0.30512366f, 
    -0.13741162f, -0.19327088f, -0.03834208f, 0.21471260f, 0.15710901f, -0.23720905f, 0.18026544f, 0.13922893f, 
    -0.11105616f, -0.12478681f, 0.44078824f, 0.33113557f, -0.21427287f, -0.15932055f, 0.24334523f, -0.10334388f, 
    0.28672498f, 0.22819492f, 0.04465292f, -0.19596240f, -0.39528197f, -0.09061833f, 0.23043777f, -0.11285244f, 
    -0.12406502f, -0.21829441f, -0.11739305f, 0.00838693f, -0.23357254f, 0.09095149f, 0.00751038f, -0.09175144f, 
    -0.06172008f, -0.25922158f, 0.35356998f, 0.18983869f, 0.15151994f, 0.21431740f, -0.23264721f, 0.27185813f, 
    0.17325281f, 0.14263454f, 0.42135093f, 0.33334905f, 0.21998468f, 0.15434457f, -0.28425473f, -0.13513984f, 
    0.04447713f, 0.06613336f, 0.10830725f, 0.05075873f, -0.11685013f, -0.25972709f, -0.28228334f, -0.44938877f, 
    0.23913856f, -0.24685231f, 0.13682078f, 0.15284234f, 0.13614696f, 0.16293839f, 0.04076647f, -0.08743412f, 
    0.11628991f, 0.08511153f, -0.18349294f, 0.08088323f, -0.56782335f, -0.37228492f, -0.00952229f, 0.12130520f, 
    0.06477424f, -0.19675374f, -0.01305053f, -0.04851973f, 0.17287266f, 0.07287364f, -0.01181955f, -0.33947772f, 
    -0.15918270f, -0.16621941f, 0.52719045f, -0.16113685f, -0.05362876f, -0.29908240f, 0.23332354f, 0.16788046f, 
    0.15905166f, -0.03063932f, 0.37986898f, 0.15255094f, 0.00019578f, -0.19807567f, -0.01499567f, -0.20800194f, 
    0.06038733f, 0.20578875f, -0.17744476f, -0.04366022f, -0.01380754f, 0.38112459f, 0.27905744f, -0.43887746f, 
    -0.23843814f, -0.01690318f, 0.00262351f, 0.07875566f, -0.05963939f, -0.20679590f, -0.07129024f, -0.19841468f, 
    -0.25030237f, -0.04947930f, 0.45839652f, 0.36746478f, 0.17044772f, 0.41818073f, 0.13126956f, -0.54697543f, 
    -0.17147917f, 0.02442322f, 0.01330799f, -0.24787034f, -0.05084476f, -0.22138554f, 0.10414325f, 0.08606466f, 
    0.53414559f, 0.16574904f, 0.13526772f, 0.16429175f, -0.10596012f, -0.54494298f, 0.28790206f, -0.25008070f, 
    -0.24905856f, -0.07440194f, -0.05701108f, -0.06164232f, -0.23802713f, 0.22049341f, -0.24543494f, 0.19391638f, 
    -0.08785602f, 0.13173816f, -0.20942727f, 0.08492954f, -0.08492200f, -0.22977902f, -0.20632590f, -0.21959773f, 
    -0.28571752f, 0.06211203f, 0.23498364f, 0.09973462f, 0.00481963f, 0.17976910f, 0.00898787f, 0.07499697f, 
    0.20639476f, -0.08542708f, -0.04052175f, 0.41500750f, -0.37479931f, 0.06412812f, -0.05443843f, -0.08298804f, 
    -0.22703642f, -0.11632830f, -0.21930808f, -0.21487981f, 0.09665987f, 0.13330525f, -0.01120681f, 0.21881087f, 
    -0.07398293f, 0.21177882f, -0.23115982f, -0.24215515f, -0.07951221f, -0.04803985f, 0.01622495f, -0.03105202f, 
    0.00228370f, 0.08434081f, 0.24503085f, -0.15427481f, 0.12050876f, 0.00752053f, -0.09768830f, -0.26845413f, 
    -0.38986617f, -0.06976284f, -0.26976189f, 0.47560772f, -0.02861596f, 0.01514412f, 0.20591933f, 0.19626184f, 
    0.22151358f, -0.23710854f, -0.19969921f, -0.38559127f, -0.09626102f, 0.22045565f, -0.25125837f, 0.01454897f, 
    0.00638615f, -0.20685841f, 0.00727819f, 0.36729971f, -0.29042843f, -0.26523533f, 0.22554311f, -0.14236411f, 
    -0.23192205f, 0.17951512f, -0.16816714f, 0.05707626f, -0.16388035f, -0.03585656f, 0.19419414f, 0.18999328f, 
    0.21695024f, -0.00516421f, -0.21903980f, -0.02623053f, 0.19361420f, 0.06094592f, -0.17731780f, -0.11877508f, 
    -0.02723639f, 0.14388400f, -0.14775936f, 0.16759744f, 0.15364961f, 0.17357068f, -0.17165095f, -0.04091442f, 
    -0.32350090f, 0.01346722f, 0.22474076f, -0.07253146f, 0.10024944f, 0.30212167f, 0.29719934f, 0.33115360f, 
    -0.03883751f, 0.09080505f, 0.31444913f, -0.31615773f, 0.21252310f, -0.02677621f, 0.04544282f, -0.21025120f, 
    0.38867769f, -0.15492064f, -0.13000919f, 0.07921590f, 0.25303870f, 0.15014477f, 0.04221412f, 0.32916230f, 
    -0.12226802f, 0.05791210f, -0.25775301f, 0.20200239f, 0.01534519f, 0.15650226f, -0.06753735f, 0.11140739f, 
    0.00969691f, -0.24727175f, 0.29719836f, -0.28660923f, -0.19082363f, 0.31771678f, 0.28281429f, 0.23489179f, 
    0.09921649f, 0.14741963f, -0.34268150f, 0.22204123f, 0.24346094f, 0.16904020f, 0.01042374f, 0.38313302f, 
    -0.26583418f, -0.20666437f, 0.16128211f, 0.02439805f, -0.20886967f, 0.04049343f, 0.06570222f, 0.20901085f, 
    -0.03989383f, 0.05964559f, -0.71787083f, 0.27173752f, -0.06250761f, -0.10143781f, 0.01119623f, 0.20002466f, 
    -0.51977980f, -0.06826946f, -0.07947595f, -0.06611723f, 0.10084142f, 0.01231152f, 0.26599190f, -0.06767758f, 
    -0.15394363f, -0.16563205f, 0.19271332f, -0.07047684f, 0.25759006f, 0.08439572f, -0.04298591f, 0.24595538f, 
    -0.46751425f, -0.16140737f, -0.11545967f, 0.41432363f, -0.22860254f, -0.09368792f, 0.13450211f, 0.22945188f, 
    0.03913661f, -0.09638914f, -0.12039323f, -0.13506459f, 0.20376375f, 0.14126772f, 0.21595165f, -0.18210584f, 
    0.04456786f, -0.20405510f, -0.17520964f, 0.00019879f, -0.09466332f, -0.17923149f, -0.06495962f, 0.12360486f, 
    -0.04100455f, 0.12452751f, -0.04363655f, -0.08517826f, 0.13765778f, -0.05422272f, -0.11109619f, 0.01494891f, 
    0.05008575f, -0.21587417f, 0.10825809f, -0.21351387f, -0.38308799f, 0.46563664f, 0.38125446f, 0.18734969f, 
    -0.15800858f, -0.11406374f, 0.13285805f, 0.37779272f, -0.21872616f, 0.16503249f, -0.02630173f, 0.40082970f, 
    -0.04048293f, -0.19790694f, 0.19303858f, -0.28885859f, -0.00932764f, -0.09256460f, 0.29542485f, -0.22943622f, 
    -0.25142244f, -0.15907933f, -0.13859329f, 0.24535388f, 0.21226603f, 0.12169626f, 0.10849633f, -0.15400811f, 
    0.33874795f, -0.19651435f, 0.45525864f, 0.11477408f, -0.25610194f, 0.31783414f, -0.16626586f, -0.64791745f, 
    0.08404715f, -0.10121822f, -0.10856085f, 0.15804340f, 0.03275447f, -0.22238894f, -0.07419870f, -0.35840639f, 
    0.01829020f, -0.07516364f, 0.26083338f, 0.35159481f, 0.24175517f, 0.21349078f, -0.15824772f, 0.14659114f, 
    -0.15132152f, 0.18158934f, -0.08487179f, 0.06839294f, 0.23893192f, -0.11935624f, 0.18775600f, -0.17100683f, 
    0.16586405f, -0.23137122f, -0.23153165f, -0.12708671f, -0.16564937f, -0.28001893f, 0.12069774f, 0.08125191f, 
    0.48839021f, -0.18957484f, 0.24698316f, -0.03975183f, 0.01690751f, 0.20745239f, -0.00679599f, 0.03718276f, 
    -0.27142745f, 0.12030147f, -0.26730731f, 0.34611860f, 0.04826575f, 0.02423845f, -0.01670356f, -0.12945570f, 
    0.32140002f, -0.09259433f, -0.21176715f, -0.01630949f, -0.14888778f, -0.12869394f, 0.19838762f, 0.17493726f, 
    -0.40989617f, -0.14894779f, 0.13145047f, 0.07539094f, -0.09405493f, 0.15387577f, 0.10256291f, 0.13856739f, 
    0.40592718f, -0.02519599f, -0.26061425f, -0.12974006f, -0.08136064f, -0.21972586f, 0.11488365f, 0.23089096f, 
    0.29413062f, -0.04183473f, -0.08439565f, 0.25184104f, 0.09761082f, -0.13096008f, -0.27969232f, -0.08225357f, 
    0.21488261f, 0.17420205f, 0.07729445f, 0.16825294f, 0.18242700f, -0.19788903f, -0.06731797f, -0.19899552f, 
    0.28694555f, -0.06293387f, -0.21193758f, 0.16536982f, 0.31254363f, -0.08078268f, -0.35404333f, 0.15957126f, 
    -0.09543689f, -0.13567463f, 0.43229160f, -0.01578185f, 0.07649237f, -0.20883347f, 0.11198712f, -0.23098516f, 
    0.03671058f, 0.01264642f, -0.27848393f, 0.34681913f, 0.25013918f, 0.07492520f, -0.42160359f, 0.31351578f, 
    -0.32894814f, 0.00973096f, 0.54410487f, -0.14055420f, 0.05717137f, 0.21673182f, 0.15575697f, -0.08446822f, 
    0.59419960f, -0.25156555f, -0.10969155f, 0.04469417f, 0.22173804f, -0.21188594f, -0.26185334f, 0.22608036f, 
    -0.18747762f, -0.07854584f, -0.12470180f, -0.24511808f, -0.12691793f, -0.16003954f, 0.16585606f, -0.16493949f, 
    -0.00655124f, 0.07492396f, 0.13758391f, -0.23822692f, 0.05586797f, -0.16801170f, 0.09247029f, -0.22588813f, 
    -0.17077802f, 0.22014496f, -0.02979388f, 0.22474889f, 0.02126294f, -0.02321703f, -0.04061827f, 0.15510210f, 
    -0.02419600f, -0.21323305f, 0.05180595f, 0.14841720f, -0.46442902f, -0.16936834f, 0.00482177f, -0.02728273f, 
    -0.11698220f, 0.10525128f, -0.33958942f, -0.10900251f, -0.10713604f, 0.17776221f, -0.13874878f, -0.23630638f, 
    -0.26094824f, -0.21525344f, 0.07825444f, 0.24599174f, 0.22267310f, 0.26405069f, 0.37065795f, -0.24616326f, 
    0.01556745f, 0.07668176f, 0.37309268f, 0.31024784f, -0.21938488f, 0.22695069f, 0.05232293f, -0.01953021f, 
    0.24508786f, -0.02397800f, -0.31392542f, 0.03110818f, -0.40116137f, -0.32887071f, 0.33886245f, -0.49090168f, 
    -0.33089864f, -0.07696593f, 0.25699320f, 0.45425677f, 0.15925950f, -0.20370463f, -0.09012299f, 0.33793515f, 
    0.02309629f, -0.15416913f, -0.21365091f, -0.10481582f, 0.36649305f, -0.27758598f, 0.22847016f, 0.13513091f, 
    0.28712246f, 0.23950283f, -0.07812445f, 0.19861649f, 0.21666738f, -0.03593714f, -0.22532837f, 0.11497190f, 
    -0.10685704f, 0.10853031f, -0.21553233f, 0.13672134f, -0.04502118f, -0.16751960f, -0.07589047f, 0.13039400f, 
    -0.13523927f, -0.09626774f, -0.37207755f, -0.13432828f, 0.00255522f, 0.03852728f, 0.21710713f, 0.12108769f, 
    -0.40520364f, -0.06920987f, 0.06437182f, 0.09863277f, -0.14369799f, 0.15076306f, -0.09590810f, 0.42696393f, 
    0.04431463f, -0.06251477f, -0.02588195f, -0.41953427f, -0.20982522f, 0.13829885f, 0.25983003f, 0.22885297f, 
    0.02797215f, 0.01924405f, -0.21394496f, 0.26665059f, 0.28734380f, 0.13292928f, 0.07362762f, -0.47778866f, 
    0.25350165f, -0.08004552f, 0.07402846f, 0.22914821f, -0.05471894f, -0.05979594f, -0.16791464f, 0.17691970f, 
    0.06419797f, 0.17885162f, -0.24540161f, 0.05972700f, 0.32495645f, -0.30941761f, -0.18970990f, -0.44381809f, 
    -0.61604232f, 0.05130292f, 0.32276502f, -0.00634215f, 0.22775081f, 0.11988610f, 0.08278618f, 0.22539616f, 
    -0.13352595f, -0.04613059f, 0.43818504f, 0.05999182f, 0.12472846f, 0.13688421f, 0.08346102f, 0.01283791f, 
    0.19628914f, -0.19567937f, 0.29373485f, -0.01582798f, 0.07376647f, -0.18577072f, 0.02453664f, 0.36348459f, 
    -0.58287740f, -0.20111519f, -0.06418838f, -0.12413077f, -0.02779425f, 0.22256067f, 0.06147070f, -0.23343706f, 
    -0.21955383f, 0.15963873f, 0.23837548f, 0.46969441f, -0.18641175f, 0.18244658f, 0.13082616f, 0.28287059f, 
    -0.42455602f, 0.18276002f, -0.04903505f, -0.02965198f, 0.31860772f, 0.00275958f, 0.18791366f, 0.07501820f, 
    0.17006145f, 0.14335343f, 0.30312327f, 0.10997989f, 0.18582454f, 0.24158262f, 0.22766711f, -0.32508320f, 
    0.60223681f, -0.05475356f, 0.24347201f, -0.29444829f, 0.53443789f, 0.00016354f, -0.02158880f, -0.40094528f, 
    -0.10227799f, 0.12721419f, -0.17248186f, 0.04601639f, -0.13145442f, -0.01876515f, -0.02748715f, -0.08181834f, 
    -0.52123159f, 0.06707708f, 0.62932611f, -0.04152926f, -0.10948345f, 0.09427209f, 0.38061747f, 0.10509278f, 
    0.15816578f, 0.22198510f, 0.26937279f, -0.58776402f, -0.00487757f, -0.18501177f, -0.09962652f, 0.01298983f, 
    -0.04930809f, 0.13453494f, 0.23462279f, -0.20918146f, 0.15302756f, -0.17328656f, -0.25282532f, 0.07369003f, 
    -0.01373222f, -0.00379696f, -0.13965622f, -0.10679299f, -0.05163535f, 0.04832795f, 0.03346124f, 0.08247489f, 
    -0.10974640f, -0.09654918f, -0.13747674f, -0.09057742f, -0.17329746f, -0.12513563f, -0.19953206f, 0.10816726f, 
    -0.05898406f, -0.16276443f, 0.09281187f, 0.24663810f, -0.09955621f, 0.09801205f, 0.18455489f, -0.09824714f, 
    -0.47147849f, 0.24865796f, -0.16465224f, 0.27748206f, 0.34452280f, -0.29904535f, 0.22100136f, 0.20872772f, 
    -0.01960584f, 0.07064065f, -0.20829442f, 0.09191141f, 0.02370489f, 0.03826516f, -0.09156996f, 0.02979431f, 
    0.18420307f, -0.10680868f, -0.23977965f, 0.31244627f, -0.12392285f, 0.14913778f, -0.31824800f, 0.07194943f, 
    0.23824567f, 0.14828733f, -0.88019603f, 0.05710703f, -0.12145433f, 0.01069417f, -0.09374033f, 0.25497100f, 
    -0.78204381f, 0.19659798f, -0.02665487f, 0.25995442f, -0.33559439f, 0.02723421f, 0.27633631f, 0.09146874f, 
    0.00562358f, 0.20414191f, 0.08802997f, 0.27960759f, -0.11943686f, 0.23481658f, 0.05073963f, 0.01137643f, 
    0.08654322f, 0.11800321f, 0.03599356f, -0.08675799f, -0.07566456f, 0.27454185f, -0.05643772f, -0.16197328f, 
    -0.06296195f, -0.01049159f, 0.25661558f, 0.17392926f, 0.00238231f, -0.20282890f, 0.01568187f, -0.13016088f, 
    0.29341075f, 0.14575559f, -0.31965053f, 0.36097857f, -0.22273546f, -0.07794451f, 0.11182727f, -0.57675725f, 
    -0.21580648f, -0.12418526f, -0.03254765f, -0.22491160f, 0.19450635f, 0.06569567f, -0.19691253f, -0.03650689f, 
    -0.10664731f, -0.04840076f, 0.06642151f, 0.02580246f, -0.00198251f, -0.22477722f, -0.22452098f, 0.10209987f, 
    -0.05828407f, 0.10360459f, -0.36200231f, 0.10509875f, -0.23254140f, -0.07463297f, 0.09215875f, 0.42724505f, 
    -0.12054405f, 0.01098750f, 0.22160938f, -0.21474765f, 0.17464750f, 0.15541817f, -0.10847089f, 0.25029221f, 
    0.41291666f, 0.04531017f, -0.30867690f, 0.00200488f, -0.17689463f, 0.08958936f, -0.08238520f, 0.30942550f, 
    0.06854860f, 0.11892691f, 0.10693854f, -0.18882999f, -0.20578900f, -0.37825969f, -0.16016392f, 0.29005593f, 
    -0.00990390f, -0.19040552f, -0.11768865f, 0.04185643f, -0.06423190f, -0.01706135f, 0.13017055f, 0.14795153f, 
    0.00394194f, -0.14915174f, 0.45029455f, -0.10242026f, -0.06947489f, -0.14067973f, -0.41282520f, 0.23536582f, 
    0.28862515f, -0.07467083f, -0.26508051f, -0.22508115f, 0.00730535f, 0.14645980f, -0.06425460f, -0.18248221f, 
    -0.08655844f, -0.16443641f, 0.47840720f, 0.02695019f, 0.19398689f, 0.03287498f, 0.10877763f, -0.13621891f, 
    -0.26984981f, -0.00037947f, 0.10872727f, -0.10144053f, -0.06289409f, 0.18638389f, 0.06295197f, 0.15502432f, 
    -0.09295440f, -0.09931610f, -0.31653723f, 0.30392349f, 0.37108591f, -0.01128921f, 0.08064860f, -0.14381032f, 
    0.10728737f, -0.22551019f, -0.13016933f, -0.36433989f, 0.19276254f, -0.22604790f, 0.20083682f, 0.12605366f, 
    0.09258711f, -0.01621383f, -0.25990409f, 0.11161298f, 0.17621718f, 0.18453579f, -0.25685024f, -0.07072639f, 
    0.31552848f, 0.06242543f, -0.17690381f, -0.01517099f, -0.20339043f, -0.08785097f, 0.04682377f, -0.25682074f, 
    -0.16395684f, 0.08371690f, 0.30338410f, 0.19865906f, -0.09299188f, 0.47399378f, -0.20747052f, -0.13117656f, 
    -0.32218379f, -0.02947688f, -0.46270466f, 0.31944290f, 0.13376330f, -0.25439590f, -0.18827941f, -0.11108539f, 
    -0.36822364f, -0.25525996f, -0.03255013f, 0.14503616f, 0.44556630f, 0.03747134f, 0.08277687f, 0.56845319f, 
    -0.16753592f, 0.18133451f, -0.13194211f, 0.11937504f, -0.11065412f, -0.10984726f, 0.15463868f, -0.24352407f, 
    0.50477332f, 0.14631431f, -0.16288467f, 0.35024124f, -0.03836892f, -0.38947073f, 0.02931776f, 0.04140934f, 
    -0.20710784f, 0.15726265f, 0.18417771f, 0.15956467f, 0.09179446f, 0.11277337f, -0.05774075f, 0.14390014f, 
    -0.33782929f, -0.11410382f, 0.15955278f, 0.35290769f, -0.23484212f, -0.10005169f, 0.17001112f, 0.17472222f, 
    -0.24653579f, 0.11782327f, 0.26701728f, 0.16861299f, -0.07362904f, -0.18354823f, -0.15515436f, 0.26081827f, 
    -0.33299962f, 0.04708450f, -0.34684619f, 0.07264835f, 0.29129329f, 0.05258495f, 0.29547137f, -0.16699189f, 
    0.32180887f, 0.10656479f, 0.09241589f, -0.11475178f, 0.18086399f, -0.18497607f, -0.14990599f, -0.04247396f, 
    0.05410889f, 0.15172538f, 0.45235935f, -0.31800389f, 0.30709368f, 0.21237108f, 0.03108914f, -0.53697586f, 
    0.32986695f, -0.05692633f, 0.11291443f, -0.25555670f, -0.05332923f, -0.12856916f, 0.28202033f, -0.12572512f, 
    -0.09624114f, -0.19573396f, 0.30039769f, -0.23797694f, 0.25731856f, 0.22075580f, -0.11302921f, -0.03953509f, 
    -0.29804981f, -0.19002092f, -0.30468377f, 0.00409556f, 0.12843227f, -0.11428487f, -0.10145830f, -0.07391067f, 
    0.19780612f, 0.03534828f, 0.37842971f, 0.24847746f, 0.01333069f, 0.51918566f, 0.13880163f, -0.78610182f, 
    -0.09416493f, 0.10132362f, -0.13789958f, 0.32494518f, -0.23998390f, -0.01706857f, 0.06457761f, 0.41861036f, 
    -0.04507098f, 0.03211424f, 0.13476135f, -0.20256934f, -0.13751371f, -0.06469910f, 0.18058094f, 0.10871490f, 
    -0.32656991f, 0.03133014f, 0.49176884f, 0.32678390f, 0.13790691f, 0.05969477f, -0.14371845f, -0.00570259f, 
    0.35500225f, 0.19430666f, -0.14896920f, 0.03488179f, 0.00825689f, -0.17196801f, -0.02932336f, -0.53226489f, 
    0.11382315f, -0.11714461f, -0.18449213f, 0.30466607f, -0.24537656f, 0.01441813f, -0.07622323f, 0.00619850f, 
    0.08588537f, -0.10193662f, -0.01460094f, 0.16427766f, 0.39084706f, -0.32347134f, -0.23830236f, -0.20103933f, 
    0.09065682f, -0.02994302f, -0.07686100f, 0.05666241f, 0.04092589f, 0.12525062f, -0.12059115f, -0.17798659f, 
    0.07456517f, -0.01090286f, -0.53390586f, 0.04750751f, -0.23369439f, 0.24790733f, 0.04403678f, 0.37439507f, 
    -0.05896401f, 0.12740882f, -0.18295144f, -0.05753074f, -0.16662124f, 0.11621066f, -0.07842857f, -0.13551132f, 
    0.36289147f, -0.01727406f, -0.16310002f, 0.15783775f, 0.20716348f, -0.33361837f, 0.16650489f, -0.14556959f, 
    -0.02197664f, -0.03032289f, 0.17593352f, -0.14519335f, -0.07057738f, 0.07179009f, -0.21658821f, -0.54489964f, 
    -0.09700046f, -0.13746211f, 0.42288625f, -0.28337610f, 0.22563744f, 0.00720146f, -0.01361745f, -0.12262958f, 
    -0.27241609f, -0.21357198f, 0.22842143f, -0.02520299f, 0.13042608f, -0.18446869f, 0.08439364f, 0.01371937f, 
    -0.13107297f, -0.07183756f, 0.32259840f, -0.15817545f, 0.25902900f, 0.51434201f, 0.05974967f, -0.39392719f, 
    0.35378176f, 0.14761445f, 0.18775877f, 0.06227042f, -0.07292116f, -0.20526050f, 0.20820044f, -0.09333802f, 
    -0.31693479f, -0.08460683f, 0.29605171f, 0.14861166f, -0.14632246f, 0.14294958f, -0.13443933f, 0.05130152f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.28214917f, 0.00097928f, -0.24927793f, -0.08562212f, -0.00567689f, -0.03508894f, -0.17613569f, -0.05123028f, 
    0.40410551f, 0.19234034f, 0.31393841f, 0.02476154f, 0.11014091f, -0.06955698f, 0.54306453f, 0.10526472f, 
    0.20131201f, 0.19794028f, -0.01672488f, -0.04884531f, -0.18081111f, -0.02632955f, -0.16106737f, 0.35614187f, 
    0.04585634f, -0.05655725f, 0.30122790f, 0.45449516f, -0.00082016f, -0.41152942f, 0.43771234f, 0.03687770f, 
    0.06548538f, -0.18607223f, 0.21337935f, 0.26654407f, 0.58995056f, -0.02889738f, -0.01299360f, 0.32742122f, 
    -0.14835823f, -0.02281762f, -0.55292755f, 0.03719436f, 0.58980155f, -0.19245841f, -0.03740012f, 0.01548237f, 
    0.35450926f, 0.55944514f, 0.30810657f, -0.34145597f, 0.40013137f, -0.00770292f, 0.32688317f, 0.50306547f, 
    -0.09773640f, -0.17122005f, -0.28676492f, -0.08114243f, -0.18420582f, 0.45370153f, -0.00172590f, 0.03746447f, 
    0.39559481f, 0.77161574f, -0.26992854f, -0.42866591f, 0.05606002f, -0.03486473f, 0.38921347f, 0.45264590f, 
    -0.07084493f, 0.21801849f, 0.21121585f, 0.36442637f, -0.35900077f, -0.23256531f, -0.33275285f, -0.25135800f, 
    -0.05348130f, 0.08291088f, -0.11714324f, -0.09444052f, -0.17189151f, 0.44986686f, -0.17664844f, 0.17964099f, 
    0.02983377f, 0.43767926f, 0.47203413f, -0.09844005f, -0.16115990f, 0.01766969f, -0.58700830f, -0.31023961f, 
    -0.27972797f, 0.17056881f, 0.66568995f, -0.18804729f, -0.00278258f, 0.41145688f, -0.08744024f, -0.10543872f, 
    0.28083989f, -0.09153211f, 0.25670969f, -0.57488292f, -0.21092935f, 0.56911922f, -0.01680951f, 0.31257498f, 
    0.18337284f, 0.04658172f, 0.54435688f, -0.30691233f, 0.29233569f, -0.22060950f, 0.11140555f, -0.11621323f, 
    0.33007640f, 0.14061338f, -0.13833076f, 0.61615086f, 0.43408960f, 0.20629114f, 0.02416651f, -0.47848034f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.01234572f, -0.00720555f, 0.06604899f, 0.01698058f, -0.08649371f, 0.05207094f, 0.07466067f, 0.06394108f, 
    0.05263375f, -0.02976913f, -0.03510702f, -0.02235077f, -0.05740216f, 0.01322402f, -0.01215626f, -0.10412157f, 
    0.02134575f, 0.02615745f, -0.05008445f, -0.07184225f, -0.10585263f, -0.08123083f, 0.02832130f, -0.05058370f, 
    0.03708446f, -0.07166679f, 0.05674028f, 0.06656516f, 0.08545389f, 0.04156595f, -0.02050265f, 0.00318503f, 
    -0.02663442f, -0.01070030f, -0.05442068f, -0.01211942f, -0.02639039f, 0.03229505f, -0.00946327f, 0.05977346f, 
    -0.08196890f, -0.04122885f, 0.03333962f, 0.00460685f, -0.03416406f, -0.04271273f, -0.01711696f, 0.02320707f, 
    -0.09777426f, 0.06145357f, 0.03426429f, -0.01920687f, -0.02694686f, -0.03316751f, -0.02621729f, -0.02281325f, 
    -0.03676562f, -0.04281416f, -0.06681107f, -0.02393508f, -0.00341503f, -0.06443414f, 0.00303780f, -0.03642730f, 
    -0.07981907f, 0.06411099f, -0.08420206f, -0.00066201f, -0.06179121f, -0.03986162f, -0.06957851f, -0.03308097f, 
    -0.02915922f, -0.07161309f, -0.10190429f, -0.10410183f, -0.10530952f, 0.02400537f, 0.02899387f, 0.02955748f, 
    0.02704482f, -0.07144892f, -0.06402934f, 0.08503346f, 0.02459463f, 0.04888420f, -0.04795190f, -0.09981100f, 
    -0.07002886f, 0.05545515f, 0.01498482f, -0.08085479f, 0.00100426f, -0.08797923f, -0.03465088f, 0.03059981f, 
    0.04181026f, 0.06341705f, 0.05916166f, -0.02637527f, 0.00303591f, 0.06106058f, -0.03731070f, -0.06650245f, 
    -0.04252560f, 0.08216306f, -0.02758184f, -0.07686407f, -0.04304530f, 0.06182369f, -0.00772373f, 0.00580841f, 
    -0.00729097f, -0.01981656f, 0.04505207f, 0.03728203f, -0.02517535f, -0.04846940f, 0.02863008f, -0.08656904f, 
    -0.01175512f, -0.08565891f, -0.09290891f, -0.03131983f, -0.10073083f, 0.07395956f, -0.07613144f, -0.06281310f, 
    -0.02281091f, 0.04819147f, 0.03320709f, -0.08110043f, -0.08437965f, -0.11299049f, -0.02702388f, 0.04828906f, 
    -0.06349812f, -0.09779258f, -0.06414121f, 0.05678114f, -0.01226012f, -0.07786010f, -0.09246936f, 0.05227709f, 
    0.03969309f, -0.10569030f, 0.02232466f, -0.03665100f, -0.08276019f, -0.10409079f, -0.05592202f, -0.07306821f, 
    0.06364806f, -0.02379619f, -0.09326398f, 0.00219521f, 0.04265917f, 0.00947999f, -0.09145562f, 0.07035298f, 
    0.06709812f, 0.00802768f, -0.07296790f, -0.04581085f, -0.06347511f, -0.03449363f, -0.01137734f, -0.07552332f, 
    -0.01196595f, 0.00331217f, -0.08819734f, 0.03663418f, -0.09861293f, -0.02058514f, 0.08165529f, -0.03191082f, 
    -0.00718873f, 0.01783121f, -0.01809003f, -0.05292479f, 0.02229469f, -0.10917444f, 0.00672227f, -0.07843464f, 
    -0.03757945f, -0.00427935f, -0.01090799f, -0.02073877f, -0.04793343f, 0.03301056f, 0.00986009f, -0.04998421f, 
    -0.05672872f, 0.05677618f, -0.11543427f, 0.03163282f, -0.00275289f, -0.00587480f, 0.02481548f, 0.07267832f, 
    -0.03236172f, -0.01982575f, 0.01114878f, 0.04425511f, -0.03093731f, 0.05797831f, -0.00306856f, -0.07349361f, 
    -0.08117729f, -0.02313242f, -0.09759862f, -0.03801713f, 0.01666064f, 0.04654631f, -0.11499124f, 0.00371757f, 
    0.02051468f, 0.06807522f, -0.05490524f, -0.03404990f, 0.00788432f, -0.01685840f, 0.05166519f, -0.03343685f, 
    -0.02779074f, -0.03798771f, -0.04105612f, -0.00264854f, -0.07718526f, -0.09315792f, -0.00607637f, -0.07756660f, 
    -0.11382929f, -0.07888714f, 0.06194377f, -0.00260581f, -0.05650575f, -0.03485733f, -0.01429689f, -0.07076179f, 
    0.03084801f, 0.04901730f, 0.03830313f, 0.00847253f, -0.02322758f, 0.02442628f, -0.07319716f, 0.00282775f, 
    -0.09118209f, -0.06224648f, 0.04788419f, -0.10174304f, -0.03507463f, 0.09870021f, -0.08701681f, -0.08675569f, 
    0.09861994f, -0.16162463f, -0.21189129f, -0.23204933f, 0.11454565f, 0.07476398f, -0.12402567f, -0.07072093f, 
    -0.00638503f, -0.11471753f, 0.31736878f, -0.54864085f, -0.05418278f, -0.03310742f, 0.04229465f, 0.23129487f, 
    0.07496131f, 0.07955467f, 0.14899278f, 0.03633201f, -0.29315177f, -0.12040254f, -0.03635879f, -0.02554405f, 
    0.19057357f, 0.08678315f, 0.12015354f, 0.16431768f, -0.36835527f, -0.06763657f, 0.16873300f, 0.06094861f, 
    0.04115922f, 0.01045747f, 0.04145116f, 0.01422691f, 0.46941611f, -0.20639756f, -0.17994337f, 0.18251194f, 
    -0.21961252f, -0.11560840f, -0.14562131f, -0.01559112f, 0.22915667f, 0.09197594f, -0.37653488f, -0.14241627f, 
    0.05389552f, 0.23870075f, 0.05761528f, -0.05354933f, 0.14980739f, 0.08560364f, 0.11398914f, 0.46029955f, 
    0.57421362f, -0.23399560f, -0.00862105f, 0.19876142f, 0.05020516f, 0.08194377f, -0.03069863f, -0.15124348f, 
    0.35729650f, 0.25503758f, 0.03963607f, -0.43041381f, 0.28834963f, 0.02764484f, -0.28365934f, 0.23584799f, 
    0.01935357f, 0.23572376f, 0.21340233f, 0.31888807f, 0.10841271f, 0.03237219f, -0.48398119f, -0.09103563f, 
    -0.04076139f, 0.05397490f, -0.57279199f, -0.56612021f, 0.01462006f, 0.34544393f, 0.00146446f, 0.13385728f, 
    0.08431245f, 0.13356033f, -0.12589228f, -0.07221397f, 0.02715096f, 0.12412620f, -0.47859389f, -0.02207727f, 
    -0.35875043f, 0.21470386f, 0.31170711f, 0.06277554f, -0.06578763f, 0.05968146f, -0.61306572f, -0.05322364f, 
    0.12672345f, 0.05539916f, 0.11159004f, -0.52116990f, 0.17308673f, 0.24548607f, -0.16424678f, -0.01643554f, 
    0.20864546f, 0.03073968f, 0.38976535f, -0.14057790f, 0.00756861f, -0.11993650f, -0.06953166f, 0.19649267f, 
    0.31360397f, 0.01352184f, 0.00357551f, 0.19903892f, 0.26846775f, 0.58731586f, 0.10084282f, -0.34599105f, 
    -0.00713873f, -0.24645540f, -0.45141742f, 0.01226493f, 0.03919309f, 0.24298890f, 0.13835253f, 0.01879354f, 
    -0.18163887f, -0.29884100f, 0.02395933f, 0.30756456f, 0.32387650f, 0.03382798f, 0.14248827f, 0.10299820f, 
    -0.07274556f, 0.16367102f, 0.13605595f, -0.07186281f, -0.21641710f, 0.22280185f, -0.05722014f, -0.17561828f, 
    0.10107961f, 0.07763727f, -0.19112574f, 0.21310872f, -0.09651674f, 0.04913218f, 0.00301558f, -0.07668796f, 
    -0.00390927f, 0.03167195f, 0.19190085f, 0.03081136f, 0.26395479f, 0.31193441f, 0.18465599f, 0.83762097f, 
    0.07783938f, -0.08755796f, -0.22665568f, 0.18063600f, 0.18935567f, -0.03882941f, 0.24414246f, 0.44164598f, 
    -0.13124400f, -0.16608721f, 0.44148606f, 0.02249639f, -0.41835627f, 0.25727057f, -0.11677115f, 0.31913581f, 
    0.12938939f, -0.18039320f, 0.05441934f, 0.01548569f, -0.00534063f, 0.09974766f, 0.00266704f, 0.01853517f, 
    0.62106812f, -0.04913267f, -0.02603724f, -0.17944093f, -0.07742137f, -0.04675262f, -0.39568090f, 0.04579952f, 
    -0.01226933f, -0.17365314f, -0.33429849f, 0.14006826f, 0.05059794f, -0.06944264f, -0.01499114f, 0.11075623f, 
    0.10907287f, -0.08312281f, -0.06819597f, -0.04232072f, 0.06457613f, 0.16180162f, 0.05531500f, -0.10356251f, 
    -0.53406936f, -0.12822656f, 0.13366860f, 0.01440754f, -0.15959775f, 0.07850758f, -0.09253173f, -0.45454624f, 
    -0.01519518f, 0.08947323f, 0.48012227f, -0.06714031f, -0.21678323f, 0.09194905f, 0.20072006f, -0.01796736f, 
    0.04303736f, -0.01799815f, -0.02275162f, -0.06177023f, 0.38978401f, 0.31164259f, -0.00595718f, 0.12742597f, 
    0.35464874f, -0.11149849f, 0.02734589f, 0.18405427f, -0.25867844f, 0.13624007f, 0.01742364f, 0.17129752f, 
    -0.20152907f, -0.40881252f, 0.01315495f, 0.09849122f, 0.07657383f, 0.52393109f, 0.14054549f, 0.32251942f, 
    0.07524286f, -0.42306963f, -0.13042501f, -0.48283359f, -0.12338694f, 0.09145358f, -0.13524632f, 0.03693538f, 
    0.08244693f, -0.16109814f, 0.15911838f, 0.00489640f, -0.02212651f, 0.04103786f, 0.06899305f, -0.01465699f, 
    -0.02744959f, -0.09113598f, 0.09619404f, 0.08260908f, -0.17183648f, 0.20631076f, 0.05260448f, 0.05059682f, 
    0.30519515f, -0.00934066f, 0.13681394f, -0.20143482f, 0.60466349f, -0.09036623f, 0.23733971f, 0.06469148f, 
    0.10295282f, -0.08855923f, 0.02188152f, -0.03644008f, -0.27069500f, 0.45600992f, -0.32178363f, -0.14467168f, 
    -0.19334796f, -0.09934949f, -0.23745842f, -0.01247709f, -0.02643248f, 0.04001561f, 0.04750729f, -0.01178719f, 
    -0.19893485f, 0.11318824f, 0.08429053f, 0.14164630f, 0.04461446f, 0.25188228f, -0.20966062f, 0.25544250f, 
    -0.32491270f, -0.06014315f, 0.46743521f, -0.18110763f, -0.06359798f, 0.08915474f, -0.06009747f, -0.04484227f, 
    -0.05273329f, -0.00447106f, 0.23270378f, -0.11973440f, 0.17916305f, 0.20214884f, 0.39980876f, 0.08257462f, 
    0.02621168f, 0.15033163f, 0.10639548f, 0.04976260f, 0.00441841f, -0.01213503f, -0.44684312f, -0.04080075f, 
    -0.45360848f, -0.38242999f, -0.32119620f, -0.30242342f, -0.02362490f, 0.32651478f, 0.14823589f, 0.01643591f, 
    -0.00435421f, -0.13410600f, 0.35240623f, -0.02390588f, -0.40678352f, 0.33585089f, -0.29043433f, 0.19984530f, 
    0.01133171f, 0.71766806f, -0.36974496f, -0.02957382f, 0.05156597f, -0.30029476f, 0.13363895f, -0.01040461f, 
    -0.18956727f, 0.00765855f, 0.29197505f, -0.39278376f, -0.17307609f, 0.15315945f, -0.00341767f, -0.25662234f, 
    0.03958009f, 0.25144142f, -0.21862082f, 0.30151886f, 0.09252539f, 0.11766732f, -0.04181565f, 0.27623874f, 
    0.15566199f, -0.22535121f, -0.15521206f, -0.11144732f, -0.19713929f, 0.10682835f, 0.37923199f, -0.04442257f, 
    -0.02663846f, 0.17519751f, -0.04543317f, 0.35638943f, 0.26882300f, -0.03045259f, 0.38580644f, 0.06953000f, 
    -0.45776504f, 0.07441521f, 0.17850366f, 0.12021308f, 0.09912390f, -0.00296274f, 0.14457604f, -0.00902671f, 
    0.07660098f, 0.06510468f, -0.21382087f, -0.02937949f, -0.02832145f, -0.03751194f, -0.03970537f, -0.01056588f, 
    0.17727061f, 0.16795595f, -0.00986958f, 0.24706446f, -0.27092797f, 0.17795148f, -0.17531884f, -0.06519925f, 
    -0.02584563f, 0.11753117f, -0.12770702f, 0.04119506f, 0.43352062f, -0.06299421f, -0.16367720f, 0.13264292f, 
    0.10120135f, 0.06728198f, 0.00356195f, 0.14948288f, 0.27492663f, 0.10813274f, -0.20769262f, 0.31487304f, 
    0.00411896f, 0.03844828f, 0.45480660f, -0.15809941f, 0.16817394f, 0.05616596f, 0.43232849f, 0.28302759f, 
    0.54103178f, 0.00564390f, -0.09453946f, 0.22440460f, -0.00629409f, 0.27256340f, -0.07492117f, -0.16417521f, 
    0.16829589f, 0.13751385f, 0.01018918f, -0.12269309f, 0.05868325f, 0.04899872f, -0.42295474f, 0.04323874f, 
    0.05415904f, 0.08442046f, -0.09910645f, 0.26830998f, 0.17033860f, 0.03362125f, 0.01880734f, -0.02576037f, 
    0.09548555f, 0.14240278f, -0.19181025f, -0.01374391f, 0.06250386f, -0.04243824f, -0.29517317f, 0.22843063f, 
    -0.17444032f, 0.00367291f, 0.22198449f, -0.01538455f, -0.08897525f, -0.04501757f, 0.07294414f, -0.17198654f, 
    -0.22650015f, -0.08526776f, 0.65103120f, 0.02225398f, -0.12756628f, 0.22860219f, -0.24378817f, 0.04119295f, 
    0.18829319f, -0.00474385f, 0.02244435f, 0.01244171f, 0.49628386f, 0.22418301f, -0.07663533f, -0.06587132f, 
    0.27636322f, -0.03107909f, 0.12627541f, -0.18364169f, -0.03367614f, -0.12315035f, 0.02915551f, -0.15025884f, 
    0.05912407f, 0.18709216f, -0.06784861f, 0.15500543f, 0.11625160f, 0.22195089f, -0.02082611f, 0.18894288f, 
    -0.04533001f, -0.38080353f, 0.05804504f, -0.05214746f, -0.50794250f, -0.08188774f, 0.15798751f, 0.07238536f, 
    -0.47324350f, -0.05353146f, -0.28607166f, -0.39925498f, 0.15670484f, -0.03055661f, -0.07394927f, 0.11707006f, 
    -0.02734804f, -0.13792938f, 0.07709801f, -0.06644104f, 0.11133689f, 0.01621723f, -0.04012697f, 0.07094979f, 
    0.22700094f, -0.04734920f, 0.12518738f, -0.07326359f, 0.23532811f, 0.24664518f, 0.04878376f, 0.15800391f, 
    0.17173451f, 0.35688835f, 0.28368342f, 0.08082680f, -0.56385499f, -0.11540330f, 0.06158795f, -0.29354712f, 
    0.36278343f, 0.12277342f, 0.16740644f, -0.12921834f, -0.32877544f, 0.08454880f, 0.03422232f, 0.50289291f, 
    -0.09056827f, 0.12029529f, -0.66438764f, -0.00516850f, -0.08337493f, -0.19394520f, -0.25196993f, -0.09879649f, 
    -0.22210942f, 0.01029417f, -0.16075279f, -0.51964134f, 0.04810860f, -0.34963760f, 0.09331867f, 0.15223646f, 
    -0.00821296f, -0.66508108f, 0.21747787f, 0.01906793f, 0.23566429f, 0.25858501f, 0.32148924f, 0.11519005f, 
    -0.03688652f, 0.19592537f, 0.19460206f, -0.47661373f, 0.03395764f, -0.01951385f, 0.23375437f, 0.27242938f, 
    -0.10642218f, -0.20794840f, 0.23370154f, 0.19795834f, 0.07620715f, 0.11911181f, 0.12708016f, -0.04269886f, 
    0.05076232f, -0.00697287f, -0.23366246f, -0.11052806f, 0.01462816f, -0.08422587f, 0.61983937f, 0.25388154f, 
    0.10666444f, 0.17372519f, 0.27802610f, 0.06700853f, 0.19511549f, -0.23086718f, 0.65171224f, 0.08042713f, 
    -0.18126920f, 0.05477849f, 0.10203554f, 0.14184719f, -0.49781778f, -0.15014850f, -0.09672298f, -0.33164063f, 
    -0.12392619f, 0.17876138f, -0.45975798f, 0.18855129f, 0.04505356f, 0.07189033f, -0.04483600f, -0.46715501f, 
    0.18306096f, -0.18298265f, -0.04953172f, -0.04268998f, -0.37211433f, -0.98425269f, -0.01511320f, 0.18427487f, 
    0.01014194f, 0.07759923f, -0.05666736f, 0.05231808f, -0.09211640f, -0.25316960f, -0.35900065f, 0.04487582f, 
    -0.33825508f, 0.45030552f, 0.27773768f, -0.06882536f, 0.12614419f, -0.01822693f, -0.03107175f, 0.19852017f, 
    -0.06754506f, -0.17934361f, 0.10609522f, -0.08693796f, -0.08489598f, -0.11422879f, 0.01194131f, 0.09191250f, 
    0.21215105f, -0.01540666f, -0.16856426f, 0.07112110f, -0.34395307f, 0.05505288f, 0.09310918f, 0.10537001f, 
    0.08683217f, -0.03507992f, 0.09186243f, 0.21397573f, 0.22340569f, 0.25837806f, -0.01046255f, -0.18652976f, 
    0.04549069f, -0.05811970f, -0.38789475f, -0.16996054f, 0.14742497f, -0.06556854f, -0.15797427f, 0.44261721f, 
    0.00716451f, 0.09974753f, -0.22024213f, -0.04105317f, 0.24722548f, -0.05039982f, 0.28008467f, 0.77482378f, 
    0.57765794f, -0.07025564f, 0.30083421f, -0.42363608f, -0.08658656f, 0.44406646f, -0.15518640f, 0.05117023f, 
    0.44987786f, 0.08370383f, -0.32137960f, -0.53883284f, 0.02847849f, -0.01247062f, -0.01777298f, 0.31849056f, 
    -0.04509906f, 0.44839296f, 0.09607521f, 0.33505017f, -0.29297349f, 0.04204746f, -0.28273413f, -0.13967083f, 
    -0.10540552f, -0.21078244f, -0.50593263f, -0.37105504f, -0.01443955f, 0.41350913f, 0.01035729f, 0.12793994f, 
    -0.19846700f, 0.11146405f, -0.23073371f, -0.24816483f, -0.11211453f, -0.02319660f, -0.50957245f, -0.28040978f, 
    -0.73624623f, 0.28741160f, 0.03859465f, 0.02377288f, -0.14029421f, 0.18523256f, -0.26154014f, -0.05020009f, 
    0.24856187f, -0.00900871f, -0.00403590f, -0.67766899f, 0.13546987f, 0.08906360f, -0.31092930f, 0.00606456f, 
    0.24484812f, -0.31539309f, 0.23506732f, 0.06005476f, -0.03529706f, -0.52644545f, -0.28331673f, 0.31180212f, 
    0.06549223f, -0.24530357f, -0.19363827f, 0.27013487f, 0.00207614f, 0.01910190f, -0.10084860f, -0.29387301f, 
    -0.10232752f, -0.29591808f, -0.06660739f, -0.37416288f, -0.08425675f, 0.28717798f, -0.11658376f, 0.06854150f, 
    -0.02899909f, -0.41007179f, -0.00089759f, 0.00447134f, 0.20043774f, -0.05769667f, -0.03502689f, 0.06984311f, 
    -0.05259754f, 0.06436342f, 0.33117735f, -0.03514186f, -0.01158171f, 0.21008500f, -0.08687123f, -0.03825645f, 
    -0.05105317f, 0.21874334f, 0.20353325f, 0.04777502f, 0.49745893f, 0.05408722f, 0.07495428f, 0.02654699f, 
    0.15538992f, -0.20811990f, 0.10375043f, 0.06298849f, -0.30084309f, 0.26545528f, 0.07020994f, 0.43131286f, 
    0.04756366f, -0.08820967f, -0.27051684f, -0.05368193f, 0.00291567f, -0.04519610f, 0.49093324f, 0.01361201f, 
    0.09697139f, 0.09114433f, 0.21418662f, 0.12446928f, -0.20937547f, 0.17919970f, -0.26895478f, 0.00466588f, 
    -0.42798203f, 0.05227474f, 0.50734699f, -0.28086063f, -0.01702501f, 0.04103342f, -0.03047360f, 0.31619865f, 
    0.27147815f, -0.29767615f, 0.13676287f, -0.14337488f, 0.12988332f, 0.06342042f, 0.48808587f, 0.06161103f, 
    0.03006058f, 0.01615417f, -0.04367913f, -0.09839409f, 0.00183894f, -0.06151263f, 0.05797517f, 0.07237621f, 
    -0.03281396f, -0.25006452f, -0.01895032f, -0.08073301f, 0.02878244f, 0.22027753f, 0.60815316f, -0.00153200f, 
    0.05320815f, 0.00707867f, 0.25011817f, -0.01493156f, -0.08680490f, 0.11960988f, -0.33782086f, 0.11316096f, 
    -0.08074501f, 0.59902376f, -0.48962626f, -0.01942318f, 0.15354289f, -0.11939306f, 0.42542687f, 0.04634872f, 
    0.07758562f, -0.00436340f, 0.03631211f, -0.13934402f, -0.03735534f, 0.09884984f, 0.06741775f, -0.05551651f, 
    0.22847873f, 0.26490375f, -0.14265944f, 0.22530690f, 0.19126543f, -0.04810045f, -0.08523048f, 0.25538749f, 
    -0.02057733f, -0.38593701f, 0.02725502f, -0.05564525f, -0.07312907f, -0.21403983f, -0.04343342f, -0.03169308f, 
    -0.06401851f, 0.00406316f, -0.01856321f, -0.02545458f, -0.01048628f, -0.02965740f, 0.00816671f, -0.08149143f, 
    0.07447089f, -0.10121616f, -0.07090988f, -0.07659560f, -0.01897020f, 0.00040719f, -0.03423229f, 0.00621460f, 
    -0.07021062f, -0.04263136f, 0.03078565f, 0.08657326f, 0.00384127f, -0.01536263f, -0.07522102f, -0.05729837f, 
    -0.02603021f, -0.09991238f, -0.02225642f, -0.01533615f, -0.03950908f, -0.07816884f, 0.00624177f, -0.12376074f, 
    -0.08628047f, -0.07102646f, -0.08772878f, 0.05637590f, -0.06126498f, -0.00715814f, 0.06121853f, 0.10748221f, 
    -0.10536516f, 0.06998692f, -0.03145939f, -0.10449888f, 0.05613578f, -0.07266860f, -0.02914888f, -0.02846132f, 
    -0.04901643f, 0.04264250f, 0.03610860f, -0.05141018f, -0.09290243f, -0.11578004f, 0.03045811f, -0.16443387f, 
    -0.01054785f, -0.06098920f, -0.09285671f, 0.04424810f, 0.02338821f, -0.10824942f, -0.03617705f, -0.07018946f, 
    0.07499645f, 0.06824607f, -0.06818836f, -0.04806665f, -0.01181739f, -0.05986696f, -0.05658295f, 0.01793454f, 
    -0.05704108f, -0.04089796f, 0.01117493f, -0.08781708f, 0.00706382f, 0.00202540f, -0.02128409f, -0.07688128f, 
    0.03446029f, -0.00760597f, -0.01441171f, -0.06340855f, -0.05127310f, -0.12915047f, -0.04095316f, -0.16190438f, 
    -0.03535109f, 0.02371109f, -0.02076022f, 0.01816176f, 0.05505941f, -0.12079975f, -0.07861108f, -0.04461617f, 
    0.07749802f, -0.03097224f, 0.03956833f, -0.00774604f, -0.12458976f, -0.05281268f, -0.11156281f, -0.06865032f, 
    -0.05722720f, 0.08719388f, -0.04823301f, -0.06674211f, -0.13607726f, 0.07926369f, -0.06658249f, -0.04696538f, 
    -0.04614596f, -0.09161549f, -0.06922040f, 0.00125382f, -0.04962420f, -0.03154995f, -0.05294966f, -0.00722193f, 
    -0.08029448f, -0.01663788f, -0.07910877f, 0.02215173f, 0.00588730f, 0.04518117f, 0.00670003f, -0.11962578f, 
    -0.04998331f, 0.00303873f, -0.42299473f, 0.03703074f, 0.18659770f, -0.00518109f, -0.14867841f, 0.03172730f, 
    -0.41771409f, 0.12670904f, -0.04020634f, 0.35965464f, 0.43055922f, 0.03874157f, 0.10224548f, 0.36758450f, 
    0.04051027f, -0.08966815f, 0.22352460f, -0.01063800f, -0.20346783f, 0.37171230f, -0.05960621f, -0.07067294f, 
    0.06803998f, 0.24773893f, -0.31281495f, 0.09421877f, 0.21920419f, 0.13727377f, 0.30013534f, 0.18003434f, 
    0.06577227f, -0.24294114f, 0.25561410f, -0.19277801f, 0.23435350f, 0.17507312f, -0.12596968f, 0.58921057f, 
    -0.01418009f, -0.26814836f, -0.19201522f, 0.17455852f, 0.05739112f, 0.02732521f, 0.52620703f, -0.31043279f, 
    -0.14514564f, -0.04891442f, 0.23733994f, 0.16194704f, -0.35838136f, 0.12595193f, -0.29982165f, 0.01216426f, 
    -0.16710715f, -0.20543106f, 0.08113296f, -0.18108588f, -0.05789005f, 0.27584794f, 0.04311697f, 0.14116988f, 
    0.44539738f, 0.13106866f, 0.12367383f, -0.01105095f, 0.02361425f, 0.12897073f, 0.17715460f, 0.25377122f, 
    -0.05984626f, -0.03241531f, -0.20889337f, -0.00885552f, 0.10128317f, 0.08355093f, -0.09282364f, 0.11764134f, 
    0.14018865f, -0.20903385f, -0.30844501f, -0.01164939f, -0.01217998f, 0.06023365f, 0.07498693f, -0.55977607f, 
    -0.30139959f, -0.03840531f, 0.38086802f, 0.09932056f, -0.29024518f, 0.00004653f, -0.28349972f, -0.10117141f, 
    -0.12034803f, 0.11257487f, 0.39405790f, 0.08627670f, -0.19829205f, 0.08897699f, 0.12216841f, -0.18285741f, 
    -0.17637725f, 0.02239539f, 0.25556275f, 0.04014862f, -0.07778916f, 0.09989341f, 0.07918847f, 0.16331330f, 
    0.20548357f, -0.05944989f, 0.01421093f, 0.16909362f, -0.10115908f, 0.07692866f, -0.00988682f, 0.17498228f, 
    0.00544546f, -0.55204815f, -0.09307037f, -0.08235478f, 0.06036399f, 0.27820754f, 0.06254685f, -0.02736671f, 
    0.00767982f, 0.30481073f, -0.13786694f, -0.02382376f, 0.19050796f, -0.16858386f, -0.46702942f, 0.06975951f, 
    0.70848632f, 0.19679746f, -0.10768092f, 0.07819463f, -0.07889697f, -0.05244188f, 0.12203083f, -0.20426399f, 
    0.00053619f, 0.11355429f, -0.15422566f, 0.07553528f, -0.09272076f, 0.12068942f, -0.06075134f, 0.18991093f, 
    -0.41656637f, 0.12169069f, -0.05198725f, -0.07853108f, -0.30370495f, -0.78441572f, 0.29727340f, -0.04813397f, 
    -0.00329402f, -0.29503015f, -0.01437003f, 0.31044769f, -0.05215064f, 0.33929372f, 0.35654745f, 0.34410289f, 
    -0.41908455f, -0.25059766f, -0.40384930f, 0.11183324f, 0.19164640f, 0.01570623f, 0.11329890f, 0.25678915f, 
    0.55502450f, 0.33297446f, 0.25193405f, -0.06779788f, -0.01920632f, -0.04145076f, -0.00588393f, -0.05616884f, 
    0.44526178f, -0.05141850f, -0.20717256f, 0.07101575f, -0.03698272f, 0.20342335f, -0.02662943f, -0.19014063f, 
    -0.12724151f, 0.61734116f, -0.39433983f, -0.17477784f, -0.53340769f, -0.38313213f, -0.28689963f, 0.10998477f, 
    0.05476144f, -0.18140598f, 0.00973653f, -0.04847823f, -0.13583320f, -0.02959091f, -0.22997148f, -0.53905946f, 
    -0.05151631f, 0.07062914f, 0.12369552f, 0.20578264f, -0.07987432f, 0.08297515f, 0.10003330f, 0.14920136f, 
    0.23758779f, 0.10259634f, -0.21818003f, 0.11507208f, 0.07663757f, 0.02275067f, -0.28027993f, -0.01342856f, 
    -0.21829085f, 0.20606694f, 0.00893477f, -0.06578173f, 0.00493088f, 0.24956337f, -0.06746967f, -0.24939810f, 
    0.10301100f, -0.06490308f, -0.01917974f, -0.47859538f, -0.53126669f, -0.21364968f, 0.39145264f, 0.13714911f, 
    -0.13557565f, 0.04248151f, 0.36351186f, -0.26487431f, 0.18163677f, -0.49550956f, -0.30910793f, 0.07943042f, 
    -0.05895511f, 0.27649742f, -0.03179244f, 0.34840399f, 0.21843150f, -0.07193495f, -0.13708615f, -0.55602902f, 
    0.02239927f, 0.03684425f, -0.12424436f, -0.00186011f, 0.03768750f, 0.01022629f, 0.08035161f, 0.08653741f, 
    -0.06413346f, 0.07976903f, -0.08449027f, -0.08478972f, -0.01182845f, 0.00784650f, 0.03474373f, 0.00118470f, 
    -0.07084005f, -0.06068993f, 0.00181242f, 0.02044644f, -0.06846002f, -0.00848088f, -0.02706950f, -0.09492601f, 
    -0.09106469f, -0.05085401f, -0.10881803f, -0.02193311f, -0.06331805f, 0.02165680f, 0.06157774f, -0.07084738f, 
    -0.07398500f, -0.01852949f, -0.02731893f, -0.07878688f, 0.01605403f, -0.04692025f, 0.03459387f, -0.04880589f, 
    0.05960712f, -0.12006714f, -0.01036972f, -0.07187517f, -0.08770748f, -0.04252731f, 0.00920617f, 0.04706026f, 
    -0.05207004f, -0.07176273f, 0.02239170f, -0.09280804f, 0.03313330f, 0.01657043f, 0.01910992f, -0.10153947f, 
    -0.02803160f, -0.03756489f, 0.05161702f, -0.00286436f, 0.04543893f, 0.04976259f, -0.06870320f, -0.00613972f, 
    0.00784624f, 0.04308372f, -0.03820645f, -0.13285224f, -0.03746212f, -0.04725482f, 0.02294743f, 0.06450192f, 
    0.00436190f, -0.09504201f, 0.05449494f, -0.01434112f, -0.10628180f, 0.01622223f, -0.01579349f, -0.02840038f, 
    0.03064854f, -0.08257177f, -0.07595717f, 0.00306032f, -0.04043445f, 0.07787874f, -0.07958704f, -0.08721045f, 
    0.03600897f, -0.04727442f, 0.02096464f, -0.01987374f, 0.02509261f, -0.05479938f, 0.05282123f, 0.05265899f, 
    -0.14773348f, 0.04796311f, -0.04314604f, -0.02998168f, -0.03583787f, -0.02165217f, 0.09850815f, -0.11157474f, 
    -0.06641883f, -0.00653681f, 0.03113386f, 0.01041030f, -0.03100127f, -0.09629614f, 0.08570324f, -0.01150768f, 
    0.04895932f, -0.07401562f, -0.04669340f, 0.04178591f, 0.04015474f, -0.03068955f, -0.02792795f, 0.04949204f, 
    -0.11073188f, -0.08985521f, -0.05834567f, 0.00198572f, -0.07055503f, 0.01250059f, -0.04020948f, 0.03692260f, 
    -0.05688513f, -0.09090463f, 0.13228299f, -0.03521312f, 0.08783771f, 0.00377032f, -0.14848596f, -0.02254043f, 
    0.32246977f, 0.04842491f, -0.02255311f, -0.10835364f, -0.32831028f, 0.03686014f, 0.09280684f, -0.04284516f, 
    0.08113591f, 0.16244859f, 0.10338553f, -0.06864762f, -0.05201808f, -0.03842652f, -0.07213651f, 0.21377809f, 
    -0.05104987f, -0.16565438f, 0.20708016f, -0.00941662f, -0.07727150f, -0.12278336f, 0.06423092f, -0.03170610f, 
    -0.00592484f, -0.02994224f, -0.11369589f, 0.02132629f, -0.02337938f, -0.03485411f, -0.14568782f, 0.62753057f, 
    -0.13241275f, 0.06098228f, -0.05570516f, 0.04353013f, 0.21186182f, 0.05756028f, -0.47946143f, 0.08263817f, 
    0.09441081f, 0.13216360f, 0.13581358f, 0.16510510f, 0.28589895f, 0.12214331f, 0.31939757f, -0.08564414f, 
    0.20715414f, 0.09954141f, -0.05756354f, 0.14389509f, 0.06641935f, 0.10987771f, -0.09259374f, -0.06653913f, 
    0.14909962f, 0.16588457f, -0.02668772f, -0.38206193f, -0.07662268f, -0.12264435f, 0.03113686f, 0.06228723f, 
    -0.03197438f, -0.15603101f, 0.22848471f, -0.13661161f, -0.04156532f, 0.06350881f, -0.08494320f, -0.01248380f, 
    -0.10685300f, -0.04341539f, 0.09045975f, 0.02651199f, -0.00361306f, -0.17575869f, 0.12164077f, 0.40999535f, 
    0.16087548f, 0.10551932f, -0.10986257f, 0.06073970f, 0.07933830f, 0.05403483f, -0.00942464f, 0.03568536f, 
    -0.32151884f, 0.30156952f, 0.53121203f, 0.01119715f, 0.03549112f, -0.10304086f, 0.01227488f, 0.05599162f, 
    0.25080758f, -0.01101422f, -0.14290442f, -0.43402874f, -0.27502516f, 0.26979619f, 0.22860801f, -0.00950527f, 
    0.06639409f, 0.00886301f, 0.05550186f, -0.04469824f, 0.18109047f, -0.07497890f, -0.03493496f, -0.23493761f, 
    0.03737215f, 0.34151208f, 0.11386392f, -0.07184574f, 0.09482896f, 0.24643199f, -0.08240129f, 0.02181131f, 
    -0.07771637f, 0.02028026f, -0.32987267f, 0.02138574f, -0.24514100f, -0.02174561f, 0.21540819f, 0.00468991f, 
    0.28375295f, 0.01516580f, -0.00957845f, -0.51477081f, 0.08970566f, -0.01531556f, 0.23115726f, 0.10188324f, 
    -0.05933660f, 0.11839110f, -0.09440171f, -0.00735350f, 0.04360792f, -0.07774438f, 0.00162841f, 0.06022473f, 
    0.01960856f, 0.04209917f, -0.00192934f, 0.19238496f, -0.05817335f, -0.35129926f, 0.36547729f, 0.09057291f, 
    0.13932787f, -0.31814775f, 0.18353851f, 0.21486659f, 0.24899378f, 0.02764835f, 0.19544706f, 0.04414981f, 
    -0.11603561f, -0.44615343f, -0.57908469f, 0.09075912f, 0.19055019f, -0.02781251f, -0.07182754f, -0.18966983f, 
    0.15539157f, 0.25458047f, -0.15972461f, -0.14430302f, -0.01792574f, 0.12107503f, 0.01917179f, 0.29848191f, 
    0.11978932f, -0.31251732f, -0.17020607f, -0.02894051f, -0.04287589f, -0.02061825f, -0.04427619f, -0.25601572f, 
    -0.38497141f, 0.58499813f, -0.00352527f, -0.20019941f, 0.21179086f, 0.02463383f, 0.06730678f, 0.17667547f, 
    -0.04270727f, 0.25291219f, 0.10493774f, 0.23261151f, -0.02541292f, -0.03812685f, -0.40055105f, -0.10061529f, 
    -0.07527082f, 0.08491482f, -0.23585726f, -0.44099730f, -0.08505142f, 0.37690380f, -0.27561086f, -0.24891248f, 
    0.12755831f, -0.02759379f, 0.11178504f, -0.01058576f, 0.09891052f, 0.24251296f, -0.79670066f, 0.05890186f, 
    -0.54305089f, 0.13808706f, 0.17258601f, -0.08111192f, 0.06826342f, 0.25002956f, -0.62099117f, -0.06313621f, 
    0.03504130f, 0.05161854f, 0.34877008f, -0.54517949f, 0.24611782f, 0.06028279f, -0.00080785f, 0.06626752f, 
    0.12756646f, 0.24767727f, 0.28980994f, -0.13188951f, 0.05987704f, -0.17931400f, 0.02938834f, 0.05698117f, 
    0.23000683f, -0.02459275f, 0.16297083f, 0.37791243f, 0.05011367f, 0.51550019f, 0.09855253f, -0.40464249f, 
    0.03441193f, -0.00078665f, 0.12848569f, 0.09632457f, -0.38813356f, 0.03585865f, -0.23336042f, -0.02130276f, 
    -0.23300101f, 0.02870518f, 0.04502221f, -0.04814499f, -0.05991660f, 0.06792788f, 0.12282623f, 0.10362052f, 
    -0.07913911f, 0.06345074f, 0.15242061f, -0.00096475f, -0.02596465f, 0.03958353f, -0.04992338f, 0.13909093f, 
    0.06407042f, -0.49140584f, -0.06852997f, 0.19554123f, 0.02030068f, 0.06819551f, 0.06041085f, 0.05871429f, 
    -0.00346916f, 0.26683345f, 0.14429152f, 0.18361865f, 0.27993870f, -0.04152560f, 0.30413726f, 0.12867035f, 
    0.19519670f, 0.12150016f, -0.01605815f, -0.12454321f, -0.08882376f, -0.03039978f, 0.02624519f, -0.13821833f, 
    0.11237492f, 0.12942244f, 0.25105458f, -0.41378528f, 0.05344185f, -0.09135449f, 0.08833844f, -0.17418888f, 
    0.26119792f, 0.01127910f, -0.28164077f, -0.14851341f, -0.07749056f, -0.09842092f, 0.08823262f, -0.11291841f, 
    0.09151431f, -0.04355797f, -0.01737756f, 0.00748354f, 0.08444643f, 0.12413222f, 0.18584697f, 0.05005588f, 
    -0.08246887f, 0.11810338f, 0.27518880f, -0.14855857f, -0.13681328f, -0.06507783f, -0.07129273f, 0.07983035f, 
    0.10180172f, -0.05278311f, -0.03752277f, -0.18376417f, 0.00004662f, 0.27660689f, -0.06277607f, 0.13898838f, 
    0.01552894f, 0.11989854f, 0.08045082f, -0.00633901f, 0.07816426f, -0.04350242f, 0.01675159f, -0.06323840f, 
    0.22976582f, 0.04433348f, 0.13631740f, 0.02460293f, -0.07023738f, 0.00282098f, 0.20714688f, 0.04070418f, 
    -0.11540835f, 0.00571087f, 0.23804718f, 0.10014303f, 0.37284705f, 0.20348434f, -0.29892230f, 0.09111883f, 
    -0.09342688f, 0.00328347f, -0.03232243f, 0.07729173f, -0.10835798f, 0.06355433f, 0.03865236f, -0.28458941f, 
    0.15589921f, -0.09162760f, 0.08653633f, -0.06066515f, 0.04961709f, -0.25647104f, -0.11043035f, -0.11207186f, 
    -0.06189417f, 0.03311676f, -0.15896305f, 0.11167002f, -0.11474961f, -0.00616416f, -0.08475531f, 0.08592612f, 
    -0.23738381f, -0.18201329f, 0.05981481f, -0.42393768f, 0.40600789f, 0.04485000f, -0.00695176f, 0.05688375f, 
    -0.02363065f, -0.11387319f, -0.09155009f, 0.03018753f, 0.07817436f, 0.22274040f, -0.03801020f, -0.04533757f, 
    0.08535126f, -0.01965408f, 0.00687551f, 0.13879488f, 0.06070509f, 0.18966861f, -0.02694972f, 0.09942683f, 
    0.15443322f, -0.11882622f, 0.20888507f, 0.08221100f, 0.10996046f, 0.00321305f, 0.04722802f, -0.33679771f, 
    -0.02466786f, -0.03729284f, -0.46197984f, 0.00052510f, 0.11580361f, -0.08450733f, 0.23528974f, 0.05249858f, 
    0.06568477f, 0.06782905f, 0.00557243f, -0.05601608f, -0.09062391f, 0.05216071f, -0.06522896f, 0.21926731f, 
    0.15887015f, -0.15581858f, 0.08316935f, -0.21502559f, 0.05999007f, 0.02223787f, -0.11959434f, 0.16168308f, 
    0.11135150f, -0.16473860f, 0.09457324f, 0.11771114f, 0.15624854f, 0.12616868f, -0.23893656f, 0.06559944f, 
    -0.06737054f, 0.20559587f, -0.18034217f, 0.05253661f, 0.19272703f, -0.07695083f, -0.02828340f, 0.09213541f, 
    0.01554443f, 0.06386558f, -0.12511547f, -0.32667527f, -0.00022897f, 0.10428919f, 0.04059342f, -0.17800757f, 
    -0.11733358f, 0.08670946f, 0.25082600f, -0.00541994f, -0.08749197f, -0.04404367f, -0.54179710f, -0.07764432f, 
    -0.17391104f, 0.29344952f, -0.68713653f, 0.00715798f, 0.03254271f, 0.15517198f, -0.29527208f, -0.05588012f, 
    0.05047765f, 0.07288966f, 0.00711618f, 0.05089858f, 0.33809030f, 0.08796220f, 0.02115522f, -0.08974194f, 
    0.24603137f, 0.05557657f, 0.10609964f, 0.01232674f, -0.01526166f, -0.15186211f, 0.00004370f, 0.11885878f, 
    -0.02336668f, -0.24785911f, -0.00937986f, 0.07904234f, 0.06849995f, -0.39768809f, -0.10345190f, 0.04391820f, 
    -0.12391796f, 0.10781498f, -0.13981995f, 0.14022212f, 0.18980244f, 0.23456089f, -0.21594283f, 0.08548172f, 
    0.21868330f, -0.11946767f, 0.13859731f, -0.45219022f, 0.39719939f, 0.07499993f, -0.12029052f, 0.09522747f, 
    0.02522631f, -0.03279563f, 0.20361286f, 0.07869256f, 0.05132871f, 0.04907485f, -0.04538493f, -0.07551105f, 
    -0.04310002f, 0.09974049f, -0.04390227f, -0.02709775f, 0.07261010f, -0.00460607f, 0.18135017f, 0.30223817f, 
    0.15639499f, -0.09179147f, 0.18745296f, -0.04974371f, -0.02178735f, -0.02503582f, -0.12613851f, -0.27726907f, 
    -0.02900402f, -0.19941606f, -0.45232666f, 0.08339261f, 0.26268205f, 0.02774353f, 0.46627378f, 0.31329748f, 
    0.04916934f, -0.09429555f, -0.07087354f, 0.09692025f, -0.18166678f, 0.14467885f, -0.02884662f, 0.22689219f, 
    0.34969482f, -0.04767430f, 0.16369876f, -0.12269815f, 0.05317811f, 0.19291365f, 0.04911856f, 0.49176967f, 
    0.34706533f, -0.23664418f, 0.10156503f, -0.01728196f, -0.03382759f, 0.01220708f, -0.21942089f, 0.26353991f, 
    -0.02593772f, 0.11235633f, -0.14567772f, 0.10805684f, 0.09961432f, 0.02062188f, 0.25933477f, 0.15509400f, 
    0.14127897f, 0.12626000f, 0.09168644f, -0.18700060f, -0.05950850f, 0.03657140f, 0.06370126f, -0.14171977f, 
    -0.00130588f, 0.17849110f, 0.14215194f, 0.06961772f, 0.09091402f, 0.09769309f, -0.57404333f, -0.00952924f, 
    -0.29381171f, 0.32264975f, -0.69851410f, -0.05827190f, 0.32374695f, 0.03014972f, -0.08813853f, -0.07391068f, 
    0.17279916f, 0.05074710f, 0.04139137f, -0.03653157f, 0.23628278f, 0.06109859f, 0.25917754f, -0.09853069f, 
    0.13378720f, 0.25616762f, 0.26941887f, 0.20417976f, -0.03417861f, -0.32498351f, -0.15014537f, 0.11753469f, 
    0.07915176f, -0.34019873f, 0.13848236f, 0.07255462f, 0.15356104f, -0.30665970f, -0.24141496f, 0.03443623f, 
    -0.00139483f, 0.26097965f, -0.05005682f, 0.33474034f, 0.01389674f, -0.08750626f, -0.31118992f, -0.04412601f, 
    0.05426673f, 0.10799535f, 0.08595196f, -0.01937198f, 0.29278368f, -0.07638404f, -0.17531857f, 0.08076915f, 
    -0.01962778f, -0.26834163f, -0.26647857f, 0.04836459f, 0.10939957f, 0.11238598f, 0.03276977f, -0.15455694f, 
    0.18544921f, -0.09334573f, 0.01935625f, 0.35888368f, -0.13221356f, 0.26067570f, -0.25155509f, 0.07997327f, 
    -0.04546191f, 0.05727725f, 0.01595829f, 0.09931398f, 0.44654307f, -0.05484238f, -0.00123143f, 0.14477277f, 
    0.04702032f, 0.27808273f, -0.16373512f, 0.22213212f, 0.10702137f, 0.06611814f, 0.14776915f, 0.44860420f, 
    0.11955859f, 0.09227905f, 0.55865151f, -0.68298692f, 0.13645729f, 0.06049282f, 0.22632556f, 0.37234616f, 
    0.31287298f, 0.02959538f, -0.30538127f, -0.28787950f, -0.03399813f, 0.24315552f, 0.02138854f, 0.25067347f, 
    0.38603428f, -0.11040317f, -0.11658154f, -0.00546946f, 0.11278915f, -0.03744062f, -0.37721437f, 0.16018626f, 
    0.10440339f, 0.34175959f, -0.33121741f, -0.06705769f, 0.16850083f, 0.04503902f, 0.16634169f, 0.03547643f, 
    0.08139185f, 0.15165995f, -0.01667018f, -0.19733071f, -0.00369750f, 0.04596920f, -0.17623229f, 0.08602818f, 
    -0.43293414f, 0.10281724f, 0.44575888f, -0.08575733f, -0.09683754f, -0.53144377f, 0.01339258f, -0.33924192f, 
    -0.32728890f, -0.14938441f, -0.30385154f, 0.05492646f, -0.22218868f, 0.29719988f, -0.17153242f, 0.02667745f, 
    0.18876958f, -0.04605713f, -0.07590375f, -0.00098317f, 0.21980825f, 0.15025021f, -0.37980255f, 0.10503882f, 
    0.27645040f, -0.00912731f, 0.14907914f, -0.15818895f, -0.21510276f, -0.38462844f, -0.00276616f, -0.18855202f, 
    -0.04353607f, -0.03784488f, -0.23970059f, 0.35670364f, 0.05694782f, -0.20225582f, -0.53628737f, 0.23405382f, 
    0.05366076f, 0.33771220f, -0.15241259f, 0.23181148f, 0.01627493f, 0.06794842f, 0.16321272f, 0.06959561f, 
    0.49395263f, -0.04653142f, 0.02035258f, 0.03829613f, 0.23509826f, -0.06860945f, 0.20653524f, 0.02548562f, 
    -0.03980170f, 0.15780452f, -0.04181187f, -0.02612764f, 0.07009123f, -0.03994326f, -0.01042180f, -0.06110867f, 
    -0.31120944f, 0.43042481f, -0.14040120f, 0.25781348f, 0.05838666f, -0.32621378f, 0.25829986f, 0.11741461f, 
    0.11177920f, -0.19676709f, 0.14349672f, 0.04234948f, 0.14913432f, -0.02912423f, 0.07863580f, -0.28614819f, 
    -0.03399451f, -0.37726054f, -0.31574500f, 0.16635260f, 0.46089581f, 0.06277431f, -0.11632542f, -0.22208044f, 
    0.08860351f, 0.15143239f, -0.00983809f, -0.12449382f, -0.01725052f, 0.03728765f, 0.24698576f, -0.00326903f, 
    0.14359668f, -0.12606011f, 0.00110734f, 0.35992527f, -0.03797621f, 0.30502957f, 0.01945097f, -0.06350572f, 
    -0.31686687f, 0.68520916f, -0.19057836f, -0.07428981f, -0.10040227f, 0.06192836f, 0.07580300f, 0.09196354f, 
    0.04022862f, -0.11627211f, -0.01221413f, 0.37062863f, 0.02716109f, -0.04367943f, -0.10799361f, -0.21732233f, 
    0.28001660f, 0.23166533f, 0.10078888f, -0.22385719f, -0.08588259f, 0.11281814f, -0.27646086f, -0.13886993f, 
    0.16844714f, 0.18944219f, 0.24755640f, 0.15788800f, 0.11286471f, 0.06284203f, -0.37163103f, 0.08172687f, 
    -0.41630539f, -0.24409252f, -0.14166668f, 0.06395521f, 0.16311496f, 0.56688714f, -0.32505137f, -0.07600842f, 
    0.23519075f, 0.06223996f, 0.04457978f, -0.37236193f, -0.04149866f, -0.00703428f, 0.24729303f, 0.21045455f, 
    0.15957043f, 0.24175401f, 0.31185141f, 0.01779050f, 0.14248331f, -0.27568981f, -0.18315786f, 0.20432335f, 
    0.05417886f, 0.15747087f, 0.08852013f, 0.11393293f, 0.12617847f, -0.33297652f, -0.11687119f, -0.10952420f, 
    -0.07297096f, -0.30005816f, 0.02773858f, -0.30275095f, -0.13618842f, -0.05940222f, 0.10733056f, -0.00358508f, 
    -0.47211224f, 0.03540570f, 0.20914218f, -0.00380515f, 0.07499772f, 0.02670381f, -0.11580089f, 0.04960011f, 
    -0.04852635f, -0.09219752f, 0.07544741f, 0.04667989f, -0.10210193f, 0.21123560f, 0.04740729f, -0.00040084f, 
    0.35497838f, 0.02486940f, 0.16312265f, -0.26238826f, 0.56866860f, 0.10928126f, 0.01751487f, 0.00703353f, 
    0.02739531f, -0.15303193f, 0.05929626f, 0.05403687f, -0.11450644f, 0.29464552f, -0.09202293f, -0.14887986f, 
    -0.20024988f, 0.26697525f, -0.21567342f, 0.00159577f, -0.16497962f, 0.07808914f, 0.15666293f, -0.43580109f, 
    -0.05966435f, 0.13337073f, -0.21265087f, 0.13440445f, 0.00905955f, 0.08255024f, -0.34535575f, 0.12018531f, 
    -0.47733188f, 0.00474000f, 0.09562609f, -0.22751936f, 0.04635926f, -0.08057567f, -0.11953925f, 0.30114266f, 
    0.02480954f, -0.04200715f, 0.14074558f, 0.23676026f, 0.23329096f, -0.00012199f, 0.26532733f, 0.14180860f, 
    -0.02593367f, 0.38668326f, 0.10802003f, -0.06754658f, -0.03582036f, -0.01448712f, -0.15950297f, 0.04498877f, 
    -0.23788007f, -0.14913534f, -0.28737572f, 0.29511169f, -0.05638241f, -0.02246758f, 0.16463298f, -0.12396301f, 
    0.04175734f, -0.17835771f, 0.39363936f, 0.01490775f, -0.33195275f, 0.18079706f, -0.06978790f, 0.14949131f, 
    0.23173797f, 0.58090299f, -0.15092391f, -0.08822992f, -0.02208084f, -0.29801431f, 0.21606591f, 0.13284405f, 
    -0.15386944f, 0.04403626f, 0.03995286f, 0.06799991f, -0.12793982f, 0.09289189f, 0.05548740f, -0.05409284f, 
    -0.08223127f, 0.06310780f, -0.16049558f, 0.09268273f, 0.15900540f, 0.06768699f, 0.12575969f, 0.09526280f, 
    0.01322255f, -0.25510183f, -0.30099711f, -0.03654739f, -0.20152479f, 0.27541372f, 0.18802440f, -0.17103224f, 
    -0.03930420f, 0.07850950f, -0.13394020f, 0.00932521f, -0.21619980f, -0.13246872f, 0.06649743f, 0.06628566f, 
    0.30230516f, 0.21151529f, 0.06300745f, 0.24779648f, 0.06495385f, 0.04093094f, 0.29605660f, 0.11189488f, 
    -0.04757059f, -0.09374525f, -0.04815423f, -0.02061462f, 0.14009549f, 0.14623530f, 0.08773083f, 0.15555303f, 
    0.19539665f, -0.05162799f, -0.01304199f, 0.09445438f, -0.09366392f, -0.21752301f, 0.24188372f, 0.03717203f, 
    -0.02863818f, -0.10035441f, 0.18480274f, 0.13881029f, 0.14010724f, 0.05666748f, 0.20129859f, 0.09303432f, 
    0.11561188f, 0.04435243f, -0.16626078f, -0.05924092f, -0.03979087f, 0.05518168f, 0.14341526f, -0.29083452f, 
    0.15224889f, 0.28284186f, 0.16244996f, -0.39544478f, 0.04229988f, -0.08421730f, -0.07083533f, 0.06423555f, 
    -0.26638684f, -0.11180604f, -0.32960075f, -0.01007184f, -0.01170765f, 0.02653710f, -0.01447638f, 0.03693998f, 
    -0.14806451f, 0.24963361f, -0.07816956f, 0.08723376f, 0.11706953f, 0.04630864f, 0.41351134f, 0.18939948f, 
    -0.06962357f, 0.17985806f, 0.04472128f, -0.01018547f, -0.11935419f, -0.09090667f, -0.13960898f, 0.02354974f, 
    -0.04642553f, -0.01289499f, 0.10565822f, 0.06737025f, 0.05002896f, 0.34970737f, -0.06918152f, -0.01412952f, 
    -0.01274897f, 0.10717941f, 0.26489425f, 0.08160802f, -0.16534312f, -0.06482148f, 0.14363587f, -0.05624287f, 
    -0.25066864f, -0.18112272f, 0.25757858f, -0.07024768f, -0.13225089f, 0.10758091f, 0.06825439f, -0.04186328f, 
    -0.19612339f, 0.07787263f, 0.18000324f, -0.10522082f, 0.29684898f, -0.03281836f, -0.09329947f, 0.27578664f, 
    0.01830324f, 0.00805158f, 0.07026571f, -0.21402889f, 0.04641765f, -0.13843219f, 0.11220460f, -0.21897012f, 
    0.14944451f, 0.01293720f, -0.04247211f, 0.30539006f, 0.06198869f, -0.02404114f, 0.12425338f, -0.18934736f, 
    0.08778147f, 0.12247001f, 0.00043819f, 0.14316824f, 0.25090986f, -0.10586739f, 0.36710805f, 0.00089231f, 
    -0.34947082f, 0.08648714f, 0.26629353f, 0.22005908f, 0.01774366f, -0.07004609f, -0.00245604f, -0.03666337f, 
    -0.01776901f, -0.03686534f, -0.35310921f, 0.00259151f, -0.03224451f, -0.03512839f, 0.02608770f, -0.06824683f, 
    0.26697183f, 0.33682042f, 0.13845713f, 0.10564159f, -0.12261033f, 0.05782780f, -0.31715322f, 0.00792235f, 
    -0.02519440f, 0.09236865f, -0.11682436f, 0.08546999f, 0.15523294f, -0.07623454f, -0.16367328f, -0.53151125f, 
    0.03880727f, 0.05578176f, 0.03020122f, 0.11191090f, 0.08783493f, 0.07413875f, -0.24519917f, 0.09980464f, 
    -0.01479262f, -0.01753283f, -0.03431427f, -0.15717724f, 0.11309044f, 0.06423707f, 0.22328712f, 0.29535457f, 
    0.04950094f, 0.18119068f, 0.17009112f, 0.41084701f, -0.01614312f, 0.38351360f, -0.01887519f, -0.13457331f, 
    -0.09292472f, 0.18947561f, 0.02195951f, -0.21573584f, 0.21535505f, 0.04601775f, -0.21985534f, -0.13873655f, 
    -0.01967067f, 0.25454786f, -0.06164111f, 0.23328117f, 0.19253440f, -0.04780382f, -0.00910897f, -0.06542276f, 
    -0.09265101f, 0.08424425f, -0.13320585f, 0.24032150f, -0.02389945f, 0.02325197f, -0.08395982f, 0.18366307f, 
    0.00315748f, -0.01658045f, 0.20101574f, -0.10849610f, -0.06166224f, -0.01610680f, 0.05537002f, -0.10697012f, 
    -0.10222878f, -0.01072298f, 0.25340161f, -0.00210724f, -0.07803965f, 0.16251430f, -0.10115651f, 0.14488973f, 
    0.27420345f, 0.02284098f, 0.02878936f, -0.01729995f, 0.07767989f, -0.02080061f, -0.07024375f, -0.00617638f, 
    0.22726642f, 0.08040021f, -0.02248679f, -0.06349684f, -0.05045174f, 0.02133726f, -0.02149634f, 0.15963075f, 
    0.06585729f, 0.37824318f, -0.04600708f, 0.28273669f, -0.09990151f, -0.09730718f, -0.02044177f, 0.17066795f, 
    0.05649122f, -0.25233281f, 0.09482285f, -0.48901209f, -0.26826769f, 0.10067748f, -0.33508533f, 0.06202359f, 
    0.21015622f, -0.36215994f, 0.06397247f, -0.04621154f, -0.37527511f, 0.06402240f, -0.04750129f, 0.01621143f, 
    -0.01174124f, 0.17770027f, 0.12710138f, -0.03673461f, -0.18466060f, -0.03262346f, 0.06503773f, -0.08449398f, 
    0.36490941f, -0.57887667f, 0.11913580f, -0.00247061f, 0.40699700f, 0.26094002f, -0.21432281f, -0.25740930f, 
    -0.22711720f, 0.01127498f, 0.12464202f, -0.16716500f, 0.16943394f, -0.26719519f, 0.12600456f, -0.28979596f, 
    0.01727479f, 0.22516991f, 0.09221604f, -0.07194302f, -0.15458763f, -0.07236106f, -0.38878372f, 0.03214125f, 
    -0.34338480f, -0.09696359f, 0.36344919f, -0.19661030f, -0.09883051f, 0.08304943f, -0.14085838f, -0.29485372f, 
    -0.08946458f, 0.05025413f, 0.05171249f, 0.02898119f, 0.06943633f, -0.33327633f, 0.01617781f, -0.17392142f, 
    0.08771499f, -0.22780830f, 0.28719345f, 0.09496152f, 0.36728799f, 0.01956160f, -0.01489970f, -0.42981610f, 
    0.02680030f, 0.13534898f, 0.19404069f, 0.06839697f, 0.12296598f, -0.01053624f, -0.32433924f, -0.04276316f, 
    -0.13101812f, 0.00472201f, -0.32307160f, -0.07488842f, -0.04912994f, 0.16751626f, 0.04321337f, -0.39825475f, 
    -0.13136482f, -0.34411824f, -0.07565764f, -0.08841262f, -0.08588372f, 0.09366938f, -0.07155462f, -0.06100837f, 
    0.55109924f, 0.48559466f, 0.11087700f, 0.00949371f, -0.33745506f, -0.38185814f, 0.66425174f, 0.12507083f, 
    -0.67244631f, 0.02926131f, 0.19485712f, 0.02560217f, 0.20505907f, 0.22887263f, -0.41725752f, -0.06940441f, 
    0.14942397f, -0.26450974f, -0.33326319f, -0.19699901f, -0.28181151f, 0.43615240f, 0.25943908f, -0.10069122f, 
    0.00458578f, 0.02143783f, 0.10550360f, -0.10679628f, -0.02988591f, 0.66705400f, 0.29365537f, 0.08797900f, 
    -0.03750721f, 0.08383045f, 0.11614808f, -0.21169418f, -0.09179738f, 0.04960622f, 0.04454304f, 0.07936861f, 
    -0.28188202f, 0.03251756f, 0.09513339f, 0.39990139f, -0.27085361f, 0.04243547f, -0.11579984f, -0.15141356f, 
    0.02293907f, 0.12901716f, -0.07953846f, -0.03386522f, -0.01620224f, 0.25125420f, 0.04739239f, -0.07937862f, 
    0.36032698f, 0.01884465f, 0.00299266f, 0.24602072f, 0.00845147f, 0.28403434f, -0.29502755f, -0.46784076f, 
    -0.54847282f, 0.07452219f, -0.19348592f, 0.02460940f, 0.24136715f, -0.06533933f, 0.17679711f, -0.13431180f, 
    0.22934927f, 0.26384497f, 0.33363906f, 0.05555743f, -0.15046924f, 0.03526665f, -0.43880254f, -0.16149820f, 
    -0.01146366f, -0.08334360f, 0.13215284f, -0.32524598f, 0.12981653f, 0.11114924f, -0.06055676f, -0.09859504f, 
    -0.27493230f, 0.19347025f, 0.27145666f, 0.08369301f, 0.08470563f, -0.09947497f, 0.15149374f, -0.43050840f, 
    0.00562730f, -0.01914758f, 0.07377995f, 0.05592203f, 0.42847347f, 0.05865959f, 0.01835993f, -0.48996791f, 
    0.01269782f, 0.35548228f, 0.03156883f, 0.30398479f, 0.14307213f, -0.10491560f, -0.09671670f, 0.11516287f, 
    0.10160837f, -0.03406379f, -0.16650970f, 0.22365542f, -0.06634244f, -0.24160777f, 0.15671462f, -0.13163923f, 
    -0.28944212f, -0.26138252f, -0.20484439f, 0.27785006f, -0.05391370f, 0.02108081f, 0.12503481f, -0.36338744f, 
    0.22968021f, 0.03233387f, -0.03735466f, -0.02075032f, -0.40506312f, -0.03220077f, -0.20829177f, 0.04604857f, 
    -0.08079775f, 0.07218564f, -0.01296363f, 0.50219631f, 0.15948302f, 0.24927045f, -0.29434419f, 0.22606713f, 
    0.20573156f, 0.09064920f, -0.19019976f, -0.36107242f, -0.19423138f, 0.38954261f, 0.23265129f, 0.40121746f, 
    -0.18265826f, 0.03726076f, 0.04484041f, -0.04211308f, 0.07249881f, -0.10703354f, 0.23615614f, 0.06531294f, 
    0.06852091f, 0.02211100f, -0.00964722f, 0.04157561f, -0.12497134f, -0.01526174f, 0.05482709f, -0.02989191f, 
    0.02126254f, -0.03149072f, 0.03611736f, 0.00018582f, -0.08206850f, 0.08748649f, -0.00883964f, 0.01870121f, 
    0.07602738f, -0.04136834f, -0.06266190f, 0.02742767f, -0.01269481f, -0.07773042f, -0.05351655f, -0.09885139f, 
    0.02961447f, 0.00203245f, -0.02441926f, 0.02813859f, 0.02758810f, -0.04683901f, -0.09731489f, -0.09675156f, 
    -0.08093991f, -0.06896046f, 0.04367616f, -0.03867971f, -0.12105583f, -0.07722222f, -0.07204012f, 0.04182645f, 
    -0.05409966f, -0.07780764f, -0.08811212f, -0.08039138f, -0.11629487f, -0.01793772f, -0.07020395f, 0.04219760f, 
    -0.11709549f, -0.09371217f, 0.06828044f, 0.00947942f, -0.01037880f, -0.02066424f, -0.08190136f, 0.04695443f, 
    0.01816832f, 0.01412988f, 0.02985218f, -0.02360566f, 0.04603270f, -0.03470917f, 0.03625615f, 0.01588295f, 
    0.05819892f, 0.00159482f, -0.02494781f, -0.02639806f, -0.10601927f, 0.01358547f, -0.04573550f, 0.00893352f, 
    0.05786735f, 0.00283680f, -0.01178694f, 0.02843486f, -0.07621457f, 0.04773928f, 0.02837225f, -0.08412435f, 
    -0.06886058f, -0.02462512f, 0.01806804f, 0.04554363f, -0.02842749f, -0.04602316f, -0.07173469f, -0.03085626f, 
    -0.06385353f, -0.02756450f, -0.00995566f, -0.00287803f, 0.03112352f, -0.12385398f, 0.03505518f, 0.05564424f, 
    -0.00434474f, 0.05698414f, -0.08609331f, -0.05383986f, -0.01074753f, -0.08916034f, -0.06383894f, -0.10700991f, 
    -0.11244237f, -0.01948966f, -0.07133749f, -0.01595727f, -0.05840810f, -0.11410633f, -0.02990447f, -0.04458895f, 
    -0.00623558f, 0.01994311f, -0.12393954f, -0.00551942f, -0.07866859f, -0.00724928f, -0.07576153f, -0.00050281f, 
    -0.04881975f, -0.10251222f, 0.03986178f, -0.07789365f, -0.05430143f, 0.04072021f, -0.08725300f, -0.08249452f, 
    0.03710615f, 0.08884469f, -0.16370404f, -0.19891569f, 0.15921739f, 0.20360970f, -0.05922905f, -0.02586439f, 
    0.23983914f, -0.02374745f, 0.02436440f, 0.02337539f, 0.20086795f, -0.00620250f, -0.01368690f, 0.26203898f, 
    -0.01706312f, -0.12711489f, 0.23113208f, 0.02419746f, -0.03971159f, 0.23204677f, 0.08372815f, 0.04017340f, 
    -0.14900938f, 0.00364472f, 0.02664847f, -0.00053319f, 0.29846075f, 0.11602283f, 0.37151265f, 0.09540335f, 
    0.16902587f, -0.13589782f, -0.06787247f, 0.11292947f, 0.08284133f, 0.45230043f, -0.11530334f, 0.47807154f, 
    -0.14060540f, 0.18384326f, -0.26842192f, 0.06304886f, 0.11485276f, -0.05601364f, 0.53669918f, 0.27396885f, 
    0.12084347f, -0.02705420f, 0.27203876f, 0.04384488f, -0.16348986f, -0.00553840f, -0.11604514f, -0.29861361f, 
    0.19407490f, -0.03452833f, -0.10441049f, -0.19036703f, -0.05235598f, 0.06769917f, -0.14670905f, 0.42033136f, 
    0.53236336f, -0.00069141f, -0.09330896f, -0.09970900f, -0.23528817f, 0.00180053f, 0.07224523f, 0.31979328f, 
    0.04714062f, 0.01429752f, -0.10870697f, -0.22302718f, 0.00481414f, -0.04429507f, 0.10746112f, 0.16555682f, 
    -0.00804272f, -0.16009359f, 0.03914998f, 0.11924513f, 0.04753315f, -0.11621226f, 0.16642271f, 0.05776236f, 
    -0.13057077f, 0.02006542f, 0.31471992f, 0.26916108f, -0.08678187f, -0.03320291f, -0.16915193f, -0.07452463f, 
    -0.24251050f, 0.23853889f, -0.07665043f, 0.00094293f, 0.04201638f, 0.01043747f, 0.14186729f, -0.22332433f, 
    0.07395957f, -0.06107088f, -0.00098042f, 0.18391532f, 0.09311448f, 0.14464293f, 0.39443952f, 0.08259650f, 
    0.09226939f, -0.07307442f, -0.06072043f, -0.12971467f, 0.19685048f, -0.24551277f, -0.21623756f, -0.07791044f, 
    -0.11883666f, -0.13881472f, -0.12311463f, 0.07034763f, 0.19433087f, -0.16719867f, -0.27224320f, -0.07027900f, 
    0.00382860f, 0.10150797f, -0.02540276f, 0.30177179f, 0.03170662f, 0.04244985f, -0.00640910f, 0.00533589f, 
    0.14242691f, 0.05298400f, 0.04436700f, 0.09358287f, -0.26485735f, 0.06366707f, 0.17806627f, -0.01515471f, 
    -0.05320856f, 0.07079289f, 0.04871815f, 0.03358818f, -0.05008516f, 0.03096489f, -0.01247115f, 0.06844694f, 
    0.00441078f, 0.14206347f, 0.03145396f, -0.02749783f, -0.23316553f, -0.21932241f, 0.07988143f, -0.02503772f, 
    0.10007672f, 0.13806893f, -0.04833867f, 0.06229088f, 0.11149483f, -0.06520759f, -0.09733853f, 0.05659224f, 
    -0.02015300f, -0.11726361f, -0.23807603f, 0.09265450f, 0.24347495f, -0.11070913f, -0.58596170f, 0.18622616f, 
    0.21276623f, 0.11185978f, 0.01665856f, -0.18331255f, 0.15908562f, 0.10032658f, 0.36937848f, 0.10969511f, 
    0.41188842f, 0.04939816f, -0.09704538f, 0.18198574f, -0.08671731f, 0.15639964f, -0.06345141f, -0.15006177f, 
    -0.11145537f, 0.15058784f, -0.06541254f, -0.11928898f, -0.11215828f, 0.04276941f, -0.04084608f, -0.05166533f, 
    -0.04693615f, -0.13943681f, 0.13913967f, 0.11788713f, -0.02444291f, -0.00315374f, 0.02274187f, -0.09784279f, 
    0.08044779f, 0.09796391f, 0.25044802f, 0.11619399f, -0.06318165f, 0.12735766f, -0.05281000f, 0.43056175f, 
    0.03517007f, 0.15974337f, -0.21206413f, -0.03203574f, 0.15198931f, -0.03972929f, -0.14426801f, 0.02302509f, 
    -0.23558246f, -0.13430108f, 0.40051597f, 0.05948475f, 0.18426286f, 0.15281081f, -0.11767574f, -0.01094244f, 
    0.20167689f, -0.05960473f, 0.03315288f, -0.46660709f, 0.05066562f, 0.09809878f, 0.20756119f, 0.07421383f, 
    -0.00499036f, 0.05685861f, 0.18135652f, 0.11677368f, 0.05562818f, -0.20915838f, -0.06856179f, -0.17640999f, 
    0.12100614f, 0.24884725f, -0.00400546f, 0.07567538f, -0.01047815f, -0.17519963f, -0.09680960f, 0.19226028f, 
    -0.12111733f, -0.19632831f, 0.04015724f, -0.06024677f, 0.16397768f, 0.18241718f, -0.01753571f, -0.00523934f, 
    0.28807375f, -0.39664683f, -0.08192412f, -0.30337301f, 0.31056556f, -0.08687271f, -0.07843491f, -0.10270502f, 
    0.06386796f, -0.04274550f, 0.25654405f, -0.03819943f, -0.15617368f, -0.09542470f, -0.04177502f, -0.03614638f, 
    -0.32172525f, -0.11739486f, 0.04754410f, -0.00056393f, 0.05793782f, 0.08696730f, -0.01253446f, 0.13935475f, 
    0.06409189f, -0.27649865f, -0.02287560f, 0.11662308f, -0.17629579f, -0.02441376f, -0.12144955f, -0.48473856f, 
    -0.23501690f, -0.01005978f, -0.37663105f, -0.00992198f, 0.20783812f, -0.00466389f, 0.52807647f, 0.32404193f, 
    0.18209246f, -0.07280127f, -0.03116676f, 0.01617068f, -0.22222258f, -0.01364094f, -0.10202674f, 0.17485552f, 
    0.20550440f, 0.09141945f, 0.18938604f, -0.38288137f, 0.05185244f, -0.01573409f, -0.02550380f, 0.56843525f, 
    0.26406023f, -0.30410078f, 0.00254191f, 0.08377468f, -0.17367332f, -0.03518900f, 0.00236714f, 0.24142505f, 
    -0.02725359f, -0.07696707f, -0.17369787f, -0.05211384f, 0.14699326f, 0.08129909f, 0.29952848f, 0.09046621f, 
    -0.04082444f, 0.07370005f, 0.32853353f, -0.05038974f, 0.07609408f, -0.24808855f, 0.42486617f, -0.10479495f, 
    -0.12610954f, 0.14485569f, 0.04304083f, 0.03006674f, -0.05714860f, -0.19054969f, -0.46142176f, 0.02274504f, 
    0.07655678f, 0.02850194f, -0.41587320f, 0.04710620f, 0.41174430f, 0.04168194f, -0.03158861f, -0.11898963f, 
    0.21071640f, -0.03450100f, -0.38622290f, -0.38882539f, -0.09894833f, 0.07903860f, 0.17471005f, -0.08090327f, 
    0.01386692f, 0.19045077f, 0.06038564f, 0.18440457f, 0.02463733f, -0.10271019f, -0.12694024f, 0.08844227f, 
    -0.16321087f, -0.35469657f, 0.20134334f, 0.01567036f, 0.12309685f, -0.08106075f, -0.18787070f, -0.01218446f, 
    -0.08458640f, -0.02212712f, 0.06002301f, 0.03657845f, -0.07344349f, 0.02296688f, -0.03442915f, -0.05132648f, 
    0.00707608f, -0.07889218f, -0.05439207f, 0.04655412f, -0.07160555f, 0.05874306f, -0.03996536f, -0.01789158f, 
    0.06610344f, 0.00433546f, -0.03470210f, -0.06936740f, -0.06971322f, 0.04916846f, 0.08574713f, -0.03483913f, 
    -0.04915978f, -0.01467910f, 0.03353149f, -0.00769184f, 0.03341353f, -0.04483984f, -0.04943993f, -0.08843356f, 
    0.01258165f, 0.00899704f, -0.03417570f, 0.07304896f, 0.00733893f, -0.03591299f, -0.03749446f, -0.00322008f, 
    0.01158806f, 0.02474595f, 0.07751113f, 0.06585594f, -0.05893829f, -0.07887507f, -0.04503746f, -0.01514873f, 
    0.01344264f, -0.04651825f, -0.06536467f, -0.04149095f, 0.00912609f, -0.05419888f, -0.06683288f, -0.05379902f, 
    0.06987382f, -0.09231562f, -0.08942423f, -0.05041496f, 0.02544657f, -0.02563153f, 0.06283550f, 0.06485742f, 
    -0.08270973f, 0.00918770f, 0.05895632f, 0.00232824f, -0.00066606f, -0.05985408f, -0.03957531f, -0.05896289f, 
    0.01256886f, -0.02487805f, 0.04085096f, 0.05539060f, 0.02099515f, -0.01447559f, 0.05149535f, 0.01223727f, 
    -0.05673200f, -0.09339201f, -0.04295994f, -0.00986738f, 0.05888207f, -0.07784248f, 0.06777854f, -0.06174558f, 
    0.04884533f, 0.04149657f, -0.08045106f, 0.07014152f, 0.05921240f, -0.06175291f, 0.00653199f, 0.04620990f, 
    -0.08374643f, -0.06764680f, -0.04736759f, 0.00644498f, -0.07907165f, -0.04219038f, -0.02122300f, -0.01937516f, 
    0.04200520f, -0.07135317f, -0.04752721f, 0.04523830f, 0.03032026f, -0.07717042f, 0.04633583f, 0.07183692f, 
    -0.07562400f, 0.02466203f, -0.04840425f, -0.06702842f, 0.05875594f, -0.08612590f, -0.08100099f, -0.02471356f, 
    0.00393292f, -0.06753695f, -0.09175653f, -0.05962635f, 0.01278600f, -0.03782872f, -0.09426697f, 0.06279135f, 
    0.00973670f, 0.13479988f, 0.03902254f, 0.09194785f, 0.07426835f, 0.14675713f, 0.30931142f, -0.03744450f, 
    0.11674318f, -0.23808292f, 0.04443954f, -0.28724036f, 0.10895537f, -0.02325844f, 0.03737359f, -0.03417214f, 
    0.07445548f, 0.16131167f, 0.04490509f, -0.02194461f, 0.13669202f, -0.09808910f, 0.03700927f, -0.03568403f, 
    -0.01370535f, 0.28896677f, 0.08202875f, 0.26843020f, -0.36954245f, 0.03515841f, 0.00340567f, -0.01905651f, 
    0.00176745f, -0.05235386f, 0.00545838f, 0.05599297f, 0.30096185f, -0.29869565f, 0.00865661f, -0.08843757f, 
    -0.06162200f, 0.01096590f, 0.11147997f, 0.21356328f, 0.24893636f, -0.01569363f, -0.32954100f, 0.10383682f, 
    0.08125315f, 0.10063333f, 0.22327618f, -0.17058127f, 0.04573226f, 0.14224918f, 0.30959767f, 0.11949997f, 
    0.52972776f, 0.07050286f, 0.17881377f, 0.43282974f, -0.04811278f, 0.06350937f, 0.02047191f, -0.07866229f, 
    -0.01297925f, 0.37603796f, -0.05754849f, -0.29141217f, -0.03788318f, -0.08138643f, -0.31318375f, 0.05337530f, 
    0.08298784f, 0.05293586f, -0.09397601f, 0.39385778f, 0.24411733f, 0.12832402f, 0.16021429f, 0.10245357f, 
    0.25252196f, 0.19727412f, -0.21162203f, -0.45173606f, -0.01726428f, -0.10146552f, -0.10796949f, 0.06839034f, 
    -0.07686722f, 0.04207910f, -0.06889578f, 0.12780045f, 0.22127189f, -0.13845327f, 0.08532286f, 0.05582571f, 
    -0.33232149f, -0.25783175f, 0.26009753f, 0.02925183f, 0.05167726f, 0.34126580f, -0.54419208f, 0.15627675f, 
    0.24509458f, 0.04219816f, 0.01677760f, 0.04706336f, -0.04887532f, 0.17853922f, -0.04193514f, 0.04090768f, 
    0.35409179f, 0.12676769f, 0.19035716f, -0.11314636f, -0.04766673f, -0.00777474f, 0.07742308f, 0.23540293f, 
    -0.01787881f, 0.16075186f, 0.19054233f, 0.16319442f, 0.11745197f, 0.22821163f, -0.12592559f, 0.21556890f, 
    0.08240805f, -0.08154304f, -0.07144172f, -0.06052053f, -0.09562866f, -0.05299345f, -0.03483133f, -0.08409056f, 
    0.05740701f, -0.04314600f, -0.08989286f, -0.09040328f, 0.00172330f, -0.07647081f, -0.01460277f, -0.05934944f, 
    -0.05161537f, -0.07417620f, -0.06962320f, 0.06044660f, -0.06193516f, -0.01816469f, 0.05519451f, 0.03784148f, 
    -0.03415328f, 0.06354113f, 0.07086760f, 0.03636209f, -0.02527458f, -0.12524091f, 0.04667595f, 0.02551552f, 
    -0.02401679f, -0.03467119f, -0.02419926f, -0.01052731f, -0.03966813f, -0.02296081f, -0.07401964f, -0.07047510f, 
    -0.01213068f, -0.08358019f, -0.04971755f, 0.01556579f, 0.01030567f, -0.03152672f, 0.08345685f, 0.03674722f, 
    -0.07138605f, -0.01624539f, -0.10210094f, 0.05148497f, -0.03042276f, -0.02885078f, -0.00431393f, -0.07522943f, 
    0.03250012f, -0.06865686f, 0.08405116f, 0.07525856f, 0.05040278f, -0.05751312f, -0.08662611f, -0.04870753f, 
    0.03246952f, 0.04313082f, -0.01240256f, 0.00643307f, -0.00032249f, -0.07229533f, -0.07153916f, 0.02344856f, 
    -0.03031958f, 0.03271141f, 0.02844116f, -0.08062080f, -0.08494382f, -0.03705921f, -0.09162501f, 0.01586697f, 
    0.04300848f, 0.07486820f, 0.00599934f, 0.04437549f, -0.00210762f, -0.04995672f, 0.06523510f, 0.07383336f, 
    0.05844239f, 0.01090812f, 0.02355030f, -0.01875385f, 0.06470364f, 0.01110532f, -0.10937414f, -0.08864662f, 
    0.02138295f, -0.00271752f, -0.06011704f, 0.03761637f, 0.00853336f, 0.01250615f, 0.02830535f, -0.05573579f, 
    0.03212659f, 0.05690654f, -0.04907566f, -0.03192525f, 0.05938974f, -0.09376711f, 0.00143184f, 0.03861757f, 
    0.04750711f, -0.01248428f, -0.02834619f, 0.07154542f, -0.00550453f, -0.06812564f, -0.05610449f, -0.09400004f, 
    -0.01840631f, 0.07414901f, 0.01907471f, 0.05968909f, -0.08402379f, -0.05257427f, 0.06433014f, -0.06858446f, 
    -0.10200441f, -0.15350260f, -0.08776139f, -0.06471024f, -0.10989373f, 0.18980148f, -0.01454312f, -0.03412236f, 
    0.61127996f, -0.29315677f, -0.07590973f, 0.22629520f, -0.12798022f, -0.08104435f, 0.15616567f, 0.00891142f, 
    0.04409195f, 0.12827861f, 0.23984836f, -0.05770102f, 0.00133313f, 0.09521243f, -0.05277116f, 0.24520621f, 
    -0.23216482f, -0.03769593f, 0.07402029f, -0.02670889f, 0.18875478f, -0.22094738f, 0.33821255f, 0.05876341f, 
    0.10701963f, -0.07748034f, 0.02574995f, 0.17223525f, -0.24770601f, 0.20268457f, 0.23632596f, 0.18952110f, 
    -0.12590104f, -0.15824784f, -0.11563603f, 0.04679408f, 0.05297400f, -0.10859447f, 0.13738431f, 0.13398528f, 
    0.31164697f, 0.13667919f, -0.03614793f, 0.06645667f, -0.07704351f, 0.18965484f, -0.23269287f, -0.35289943f, 
    0.12700537f, -0.13483980f, 0.11248780f, -0.04562709f, -0.02543832f, -0.16011107f, 0.15635602f, 0.26812577f, 
    -0.26225582f, 0.15580709f, 0.08962572f, 0.24299972f, -0.02644396f, -0.10771042f, 0.63738304f, 0.02400581f, 
    0.05827793f, -0.21543092f, 0.00458056f, -0.30180681f, -0.03287045f, 0.00000205f, 0.01344361f, 0.06738218f, 
    -0.05894439f, 0.04446507f, 0.31737620f, 0.03843620f, 0.06155351f, -0.26404566f, 0.12689152f, -0.25770211f, 
    0.15024520f, -0.00621259f, -0.07804588f, 0.03005217f, 0.01756198f, 0.07457753f, -0.34922510f, 0.18843773f, 
    0.12687811f, 0.16296674f, -0.13145347f, 0.00888245f, 0.35894307f, -0.17133337f, -0.01845439f, -0.27363893f, 
    -0.15126279f, 0.02037298f, 0.12559773f, 0.08051043f, -0.37712577f, -0.03118411f, 0.30603155f, 0.03659496f, 
    -0.26138476f, 0.33365276f, 0.01753252f, 0.03015608f, 0.25860524f, -0.20325059f, -0.07040372f, 0.07520024f, 
    -0.04052196f, -0.15159844f, 0.06245143f, -0.03087519f, 0.02040219f, -0.55886137f, -0.13938193f, -0.07680953f, 
    -0.02713894f, 0.00532352f, -0.01689508f, -0.04434507f, -0.09495658f, -0.05723314f, 0.08090495f, -0.06933439f, 
    -0.09013015f, -0.07694795f, -0.15418735f, -0.00924671f, -0.03707687f, 0.03846906f, -0.00286471f, -0.00206156f, 
    -0.02113927f, -0.08465376f, -0.14713375f, 0.03303471f, -0.09295999f, -0.11637932f, -0.07680096f, -0.03300546f, 
    -0.12039522f, -0.07778924f, 0.00828018f, 0.07345898f, -0.12156755f, -0.05189446f, 0.00229429f, -0.05989242f, 
    -0.12688865f, -0.11220606f, -0.00828564f, -0.04211997f, -0.00625749f, -0.06517934f, 0.01464495f, -0.07283168f, 
    -0.10224809f, 0.03292547f, 0.04144173f, 0.00312321f, -0.04446419f, -0.06046557f, -0.05237137f, -0.00159632f, 
    -0.03944489f, -0.00008937f, 0.03696221f, -0.06450596f, -0.01260135f, -0.01217348f, 0.01258936f, 0.02436034f, 
    0.01328912f, -0.10782041f, 0.02569127f, -0.13161512f, -0.07892830f, 0.02309188f, -0.03849060f, 0.04218646f, 
    0.01099715f, 0.03140068f, 0.00941486f, -0.07970644f, -0.02970556f, -0.01893539f, -0.05565267f, 0.04290016f, 
    0.06221837f, -0.07956411f, -0.04206432f, -0.06358083f, -0.08156256f, 0.01400225f, -0.08850437f, -0.09845876f, 
    0.05938979f, 0.00969346f, 0.01802531f, 0.04046298f, 0.04200003f, -0.12081681f, -0.09399863f, -0.14748035f, 
    -0.12359627f, 0.06762663f, 0.05844894f, -0.08758244f, 0.05331365f, -0.00677636f, -0.00670414f, -0.02564125f, 
    -0.09884794f, -0.10317855f, 0.04463201f, 0.05048351f, -0.13551511f, -0.05734897f, 0.07611561f, -0.07515262f, 
    -0.00108866f, -0.01766711f, -0.12585816f, -0.02019323f, -0.00630682f, 0.04188666f, -0.04701672f, -0.08164819f, 
    -0.03746014f, -0.16481403f, -0.11937609f, -0.08041190f, -0.10939343f, -0.02577359f, -0.03680469f, 0.03285046f, 
    -0.07803091f, -0.00915823f, 0.04625667f, 0.03290629f, -0.10568997f, -0.03122261f, 0.04026174f, 0.02453757f, 
    0.03365085f, 0.06326995f, -0.01897655f, -0.05703990f, -0.05063020f, -0.08341598f, 0.03818211f, -0.03035708f, 
    -0.07413533f, -0.04619562f, 0.03580176f, -0.01178727f, -0.03035918f, -0.01478774f, 0.01317867f, 0.04725645f, 
    0.08720910f, -0.02619981f, -0.01669935f, 0.03248206f, 0.03269911f, 0.03451904f, 0.04627217f, 0.01082224f, 
    0.02697068f, 0.07776302f, 0.00366936f, -0.08861859f, -0.06445047f, 0.06723933f, -0.00732027f, -0.00440809f, 
    -0.10422037f, 0.06032658f, -0.01429349f, -0.04465237f, 0.00060446f, -0.07840840f, -0.02164019f, 0.05526305f, 
    -0.10258335f, -0.01342467f, -0.01861429f, -0.04681252f, -0.05511386f, -0.01800834f, -0.02145790f, -0.02891645f, 
    -0.05212107f, -0.07454630f, -0.00789693f, -0.03255557f, 0.04273409f, -0.07934894f, 0.01076193f, 0.02429321f, 
    -0.05931272f, -0.03870883f, -0.03537755f, 0.00656347f, 0.07853954f, -0.07840348f, 0.01220362f, -0.06534955f, 
    -0.00583167f, 0.07827349f, -0.06860321f, 0.00598590f, 0.01333534f, -0.00329584f, -0.01318870f, 0.01347093f, 
    -0.03770426f, 0.02427285f, 0.02610008f, -0.05714391f, -0.02967569f, -0.05337118f, 0.05512156f, -0.00153966f, 
    0.00133706f, -0.04740954f, 0.02434456f, -0.03797992f, 0.02357059f, -0.09300537f, -0.00473966f, 0.06164949f, 
    -0.02544925f, -0.00834729f, 0.06516569f, -0.06999685f, -0.00749959f, -0.04922044f, -0.05100254f, -0.09535158f, 
    -0.05726561f, 0.06643292f, 0.08450821f, 0.03762124f, -0.07760513f, -0.01454980f, -0.08202520f, -0.06538048f, 
    -0.07147162f, 0.02196961f, -0.09862436f, -0.01700591f, 0.08408988f, -0.05109478f, 0.03104028f, -0.02147907f, 
    0.00048909f, -0.09343279f, 0.00009589f, 0.05484994f, -0.07963785f, 0.02289253f, -0.07864915f, 0.04593664f, 
    -0.02656974f, -0.04358691f, -0.08395068f, -0.04788956f, -0.03577136f, -0.05951052f, -0.04340175f, 0.00377426f, 
    -0.04314993f, 0.13973607f, -0.00815162f, 0.47118410f, -0.07626357f, -0.34548855f, 0.09984940f, 0.02425149f, 
    -0.28436750f, 0.25896022f, 0.02363255f, 0.28690135f, 0.25355038f, 0.07136849f, -0.18936592f, -0.06405181f, 
    -0.06637321f, -0.07665871f, -0.25885439f, -0.04210812f, 0.27876925f, -0.15194096f, -0.03102943f, -0.13579953f, 
    -0.00222843f, -0.02475061f, -0.24528664f, -0.10648730f, -0.09873796f, -0.02213426f, -0.19756703f, 0.19072668f, 
    0.23038387f, 0.28314051f, 0.28771800f, -0.11354414f, -0.14651479f, 0.11905071f, 0.10539254f, 0.01765105f, 
    0.29116264f, -0.14078385f, 0.29913098f, 0.06746204f, -0.03155787f, -0.07543321f, 0.03627082f, 0.19580175f, 
    -0.11960912f, 0.02821908f, -0.28886530f, 0.24996679f, 0.23095007f, -0.11891150f, 0.19488017f, 0.50094187f, 
    -0.04138408f, -0.09769007f, 0.16147815f, -0.03737248f, 0.07365808f, 0.12865897f, 0.10446909f, 0.01714237f, 
    -0.27253798f, -0.29878151f, -0.06459650f, 0.00731960f, -0.03096612f, 0.20451334f, -0.02485358f, 0.19016866f, 
    0.07342769f, -0.12938394f, 0.11356848f, 0.10658278f, -0.07999426f, 0.07523108f, 0.22054908f, 0.07763126f, 
    0.07829475f, 0.05126108f, 0.24047497f, -0.24651375f, 0.05821893f, 0.50361711f, -0.62850225f, 0.26061547f, 
    0.14380667f, 0.10042933f, -0.28900361f, -0.02346223f, 0.15249912f, -0.13062981f, 0.26973751f, 0.21293339f, 
    -0.31774274f, -0.26210189f, -0.47266105f, 0.05409546f, 0.03953028f, 0.13276054f, 0.03879487f, 0.09543631f, 
    -0.00947460f, -0.05786768f, 0.00749486f, -0.19179504f, -0.15437117f, -0.48329377f, -0.23645605f, -0.13110819f, 
    0.06612824f, -0.04175927f, 0.07988881f, 0.46250200f, 0.02781954f, -0.12977593f, -0.08882951f, -0.13266130f, 
    0.04146295f, -0.10579598f, -0.02913691f, 0.20246053f, -0.29650947f, 0.04023649f, 0.09927185f, 0.23860402f, 
    0.03377718f, -0.03621583f, 0.01233217f, 0.03195416f, -0.00921518f, 0.01390451f, 0.41240555f, 0.02690790f, 
    -0.04595284f, -0.09067789f, -0.00244656f, 0.24424078f, 0.01253358f, -0.06971857f, 0.12572125f, 0.01664468f, 
    -0.05187052f, 0.13274081f, 0.00506241f, -0.04744509f, 0.06168960f, 0.08326861f, 0.08732960f, 0.01355058f, 
    0.06828186f, 0.28222433f, 0.08951722f, 0.14077246f, 0.18169665f, 0.01727710f, 0.07353792f, -0.09420644f, 
    -0.05213036f, -0.07076462f, -0.03389216f, -0.04143267f, 0.03186590f, 0.22460881f, -0.11788554f, -0.46472102f, 
    -0.09316207f, 0.00353990f, 0.03535861f, 0.15088521f, 0.18234530f, 0.08955684f, 0.18352398f, -0.53386950f, 
    0.15258591f, -0.01852362f, -0.09597638f, -0.00321505f, 0.03335214f, 0.13193172f, -0.03834610f, -0.25832841f, 
    -0.01091818f, 0.15969543f, 0.28574640f, 0.33109176f, 0.10047521f, 0.00941061f, -0.04252175f, -0.05647277f, 
    -0.19098306f, 0.18076831f, 0.06208714f, -0.22445901f, 0.10360924f, -0.05910754f, 0.07268945f, 0.02092633f, 
    0.01001217f, 0.04379700f, 0.00004164f, 0.00629634f, 0.19589090f, 0.00973004f, 0.01650732f, 0.00188328f, 
    -0.08868955f, 0.04093267f, -0.16471441f, 0.05591315f, 0.05104943f, -0.32935193f, 0.24518774f, -0.11665864f, 
    -0.03287553f, -0.05204009f, 0.42304304f, 0.16429855f, -0.02741987f, 0.18854745f, -0.08986216f, -0.04166514f, 
    -0.08491173f, 0.00296172f, -0.06666907f, 0.03517046f, 0.11495336f, 0.01490152f, -0.04264947f, 0.02499216f, 
    -0.02590555f, -0.08529492f, 0.05451331f, 0.16447625f, -0.27293935f, 0.10688049f, 0.23879662f, -0.04428960f, 
    0.22199400f, 0.27593186f, -0.01151600f, -0.08216906f, 0.06674222f, 0.09124187f, 0.11463144f, 0.13125600f, 
    0.04140483f, 0.27136618f, 0.01023440f, -0.00809433f, 0.00548100f, -0.36451450f, 0.09920231f, 0.12634887f, 
    -0.04025619f, -0.23203492f, -0.11496328f, 0.23353115f, 0.01143338f, -0.03171439f, -0.19264702f, 0.00970144f, 
    0.07313745f, 0.16382673f, 0.12668295f, 0.29861367f, -0.01348776f, 0.06461924f, 0.02428446f, 0.25943023f, 
    -0.06991946f, -0.31259111f, 0.12379149f, -0.06856949f, -0.01902138f, -0.02615557f, -0.05252364f, 0.02351793f, 
    -0.10452654f, -0.32078344f, 0.01717041f, -0.54365599f, 0.20147705f, -0.01791530f, 0.04916847f, 0.24108151f, 
    0.26742560f, 0.18257813f, 0.07673881f, -0.21134275f, -0.38351515f, 0.06797007f, -0.56767011f, 0.10651798f, 
    -0.05551904f, -0.19741547f, -0.15883441f, -0.05281731f, 0.03100383f, 0.03573678f, 0.16721906f, 0.08477253f, 
    -0.05463209f, -0.17143700f, 0.06482229f, 0.35428455f, 0.17480807f, 0.03783032f, -0.11119984f, 0.55535531f, 
    -0.02450730f, -0.03731806f, 0.45082846f, -0.20957239f, -0.10568766f, 0.09049542f, -0.06258329f, 0.39638761f, 
    0.06564675f, -0.45329753f, 0.06914497f, 0.09317950f, -0.09228356f, 0.12845652f, 0.45259503f, 0.29470685f, 
    -0.04742601f, 0.15433215f, 0.13523750f, -0.01710352f, -0.11550039f, -0.08197866f, -0.03254050f, 0.05338852f, 
    -0.33012569f, -0.12587316f, 0.23910385f, 0.15116349f, -0.02661350f, 0.45082283f, 0.21405186f, 0.24686606f, 
    0.12486181f, 0.07146224f, 0.03082172f, -0.38857761f, -0.39689696f, 0.32332793f, -0.17498259f, 0.17005984f, 
    -0.21327366f, 0.38611791f, -0.70394188f, 0.02051648f, 0.37031826f, -0.31156006f, 0.16140930f, -0.15105343f, 
    0.05855054f, 0.04975628f, -0.12018745f, -0.45267394f, 0.48075962f, -0.07940540f, -0.02801371f, -0.48432830f, 
    -0.15569651f, -0.00504717f, 0.08162759f, 0.41625533f, 0.17546798f, -0.33819386f, -0.18305694f, 0.41653705f, 
    0.11438163f, -0.28501767f, -0.15753376f, 0.17392081f, -0.09942822f, -0.20964612f, 0.08213083f, 0.02052152f, 
    -0.03085906f, -0.04237738f, -0.09900838f, -0.03964527f, 0.01381602f, -0.04673017f, -0.00050696f, 0.00126960f, 
    0.02640749f, -0.12151294f, -0.05949961f, 0.04563641f, 0.01312619f, 0.08565836f, -0.04372517f, -0.12889363f, 
    -0.06854279f, 0.02255321f, -0.02815731f, -0.03942241f, 0.00065657f, -0.05538239f, -0.01791716f, -0.00019088f, 
    -0.07741238f, -0.06485244f, 0.01267501f, 0.00019989f, -0.09929318f, 0.05374612f, -0.03337241f, 0.06708913f, 
    0.02892265f, 0.04241481f, -0.10387532f, -0.00385412f, -0.04078189f, 0.03116558f, -0.03437810f, 0.07430316f, 
    0.03746096f, 0.01101940f, -0.07413274f, -0.11511631f, 0.02899355f, -0.05602624f, 0.02515871f, -0.00673647f, 
    -0.10800084f, -0.10621787f, -0.07136057f, 0.04371609f, -0.10248870f, -0.05971619f, -0.07134955f, 0.04753299f, 
    -0.01080955f, 0.00581393f, -0.06468094f, 0.02902765f, 0.05011938f, -0.01257693f, 0.02842177f, -0.04230004f, 
    -0.02091669f, 0.01319370f, -0.06206077f, -0.09646367f, -0.03553366f, -0.06094097f, 0.01871528f, -0.07469578f, 
    -0.04212700f, 0.00123522f, 0.02010998f, -0.06943125f, -0.04485048f, -0.00115659f, -0.03898960f, -0.10598119f, 
    -0.11328632f, -0.02629524f, 0.06073596f, 0.03411068f, -0.07143312f, -0.07720986f, -0.08850601f, -0.04695019f, 
    -0.11074618f, -0.01682327f, -0.05839156f, 0.02964896f, -0.06731654f, -0.01036683f, 0.07030380f, 0.02336282f, 
    -0.09696169f, -0.06434074f, 0.06713831f, -0.06521811f, 0.00968076f, -0.01261720f, -0.08211465f, 0.01278479f, 
    -0.02651401f, 0.07095221f, 0.02972766f, 0.04832496f, 0.02320852f, -0.09966852f, 0.05089178f, -0.05721787f, 
    -0.05342970f, 0.03494945f, 0.02740419f, -0.00231868f, -0.08657464f, 0.02422288f, 0.03217500f, -0.11569352f, 
    -0.01706562f, -0.10131145f, -0.05350748f, -0.05166629f, -0.10875845f, -0.04340829f, -0.00796372f, -0.04596933f, 
    -0.05961270f, 0.05701590f, -0.05514081f, -0.06254442f, -0.03916073f, -0.08001749f, -0.08487715f, 0.00913670f, 
    -0.05259215f, 0.04698649f, -0.01098694f, 0.00143620f, -0.05834745f, 0.04209872f, -0.02177097f, -0.07595980f, 
    -0.03883917f, -0.02492704f, 0.07726981f, -0.01222942f, -0.06055333f, -0.06746716f, 0.03140628f, 0.00325198f, 
    0.03343112f, -0.08279124f, 0.06253058f, 0.04265749f, -0.05609817f, 0.05230354f, 0.05964915f, -0.00015480f, 
    -0.07860491f, -0.04467246f, 0.01214555f, 0.01266608f, 0.05726539f, -0.06346183f, -0.01635952f, 0.06020791f, 
    0.03282615f, 0.01459246f, -0.00902009f, 0.02259171f, -0.06492063f, -0.08387094f, 0.02291068f, 0.04728637f, 
    -0.06994770f, -0.02532490f, -0.04537759f, -0.06954779f, -0.00141314f, -0.04651766f, 0.06290909f, -0.06818659f, 
    0.07124660f, -0.01384895f, -0.03321869f, -0.03907928f, -0.00958127f, -0.06365704f, 0.05588521f, -0.08888957f, 
    -0.05271400f, -0.01791059f, -0.05162230f, -0.05573318f, -0.04961777f, 0.04721379f, 0.04225076f, -0.02077575f, 
    0.07491030f, -0.06771040f, -0.04632992f, 0.05422242f, -0.08930583f, 0.08474242f, -0.10110904f, -0.03341643f, 
    -0.08063497f, -0.06729330f, -0.01637259f, -0.03991664f, -0.00560613f, 0.00161005f, -0.08106695f, -0.10114978f, 
    -0.03648377f, -0.10074805f, 0.04807118f, -0.04059557f, 0.02106019f, -0.05168771f, -0.05546146f, -0.02436907f, 
    -0.01915569f, 0.07318153f, 0.07212719f, 0.03381099f, 0.03718659f, 0.04950946f, 0.05992493f, 0.07878342f, 
    -0.06291081f, -0.00532616f, -0.08835486f, -0.00137844f, 0.03160558f, -0.06403970f, 0.02823981f, -0.07183675f, 
    -0.06137550f, -0.02961650f, 0.01778041f, 0.05371749f, -0.06669627f, -0.02003652f, 0.04962179f, 0.07576346f, 
    -0.03857674f, -0.02798184f, 0.03021295f, 0.05284152f, 0.02778670f, -0.04875642f, 0.04510289f, -0.11250390f, 
    0.03108717f, -0.08013567f, 0.03340684f, 0.00117600f, -0.04806241f, -0.09939844f, 0.06736296f, -0.01006681f, 
    0.03634996f, -0.00974755f, -0.06900260f, -0.05105023f, 0.04447338f, -0.01299652f, 0.06227961f, -0.09531319f, 
    0.03974954f, 0.04323178f, -0.06805175f, -0.00003235f, -0.07439001f, -0.05621328f, 0.02486960f, -0.05978348f, 
    -0.02736399f, 0.00912959f, -0.08351637f, 0.03464315f, -0.08198287f, -0.09010256f, 0.06681859f, 0.01082639f, 
    -0.03308294f, 0.07480683f, 0.04188797f, -0.01447231f, -0.02691509f, -0.03668693f, -0.06579456f, -0.04874795f, 
    -0.07621665f, 0.01917772f, -0.05613586f, 0.02050244f, -0.02266471f, -0.05599888f, -0.04750916f, -0.05131609f, 
    0.04125113f, -0.10206071f, 0.04177277f, -0.07326548f, -0.04497867f, -0.06734633f, -0.05497986f, -0.06692914f, 
    -0.01526452f, 0.04356677f, 0.02817253f, 0.07601131f, -0.02033862f, 0.01375030f, -0.08832279f, 0.02653367f, 
    -0.07238517f, 0.02819043f, 0.06712170f, -0.04056575f, -0.00640204f, -0.08442126f, 0.07790036f, 0.06485444f, 
    -0.05805144f, 0.03540936f, -0.01786562f, -0.09956550f, -0.00937631f, -0.01904712f, 0.01742557f, 0.06319626f, 
    -0.08372719f, 0.05803549f, -0.09542686f, -0.04768217f, -0.02279529f, -0.08390266f, -0.06961036f, -0.04441778f, 
    -0.02341455f, 0.06474294f, -0.00316915f, -0.05472057f, -0.04571585f, -0.08851637f, 0.08671627f, -0.01206087f, 
    -0.03262994f, -0.04558593f, -0.00761785f, -0.04591079f, -0.00362405f, 0.05941717f, 0.02357367f, -0.05919363f, 
    0.02232464f, -0.08058288f, -0.07544310f, 0.02974196f, 0.07545754f, 0.04261732f, -0.07321622f, -0.00923927f, 
    0.01586488f, 0.03033769f, 0.05070944f, -0.09312446f, -0.03033738f, -0.01849214f, -0.08727135f, 0.01300380f, 
    -0.01951305f, -0.07846823f, -0.02353246f, -0.06637214f, -0.05953708f, 0.00815388f, -0.06025414f, -0.08053925f, 
    -0.03820821f, -0.01595702f, -0.00157586f, -0.05390425f, 0.06867396f, -0.01088131f, -0.07791919f, -0.05779219f, 
    -0.08163293f, -0.07389615f, -0.02225088f, -0.06488275f, -0.08416662f, -0.02547001f, 0.04146887f, 0.03552814f, 
    0.00093952f, 0.08556236f, 0.05785514f, 0.07866246f, 0.06333765f, -0.05359623f, -0.05287219f, 0.02339126f, 
    0.00636276f, -0.03437385f, -0.04113028f, -0.09716893f, 0.01963107f, 0.00179144f, -0.02874116f, 0.01440846f, 
    -0.05274069f, -0.04192602f, -0.00327848f, -0.03313707f, -0.06363902f, 0.03508302f, -0.04069517f, -0.05560077f, 
    0.03871387f, -0.08500141f, -0.01813655f, 0.03946884f, -0.04134650f, 0.08248030f, -0.04671233f, 0.02904365f, 
    0.06057820f, -0.04287954f, -0.00840308f, -0.05020837f, -0.09047243f, 0.02729620f, 0.02447631f, 0.00958798f, 
    -0.05015888f, 0.00687712f, 0.08001368f, -0.00897894f, -0.00242515f, -0.01917629f, -0.02846288f, -0.08035585f, 
    -0.04398008f, -0.04973095f, 0.04049204f, 0.03251088f, -0.06077139f, 0.01622633f, 0.07623617f, 0.04927343f, 
    -0.03237724f, 0.02467618f, -0.05082458f, -0.06837825f, 0.06744272f, -0.02187594f, -0.01264286f, -0.02268226f, 
    -0.03477466f, -0.03273804f, 0.07258695f, -0.02180714f, -0.08509167f, -0.08327675f, 0.07591213f, 0.05552282f, 
    -0.00222238f, -0.09502109f, -0.04102062f, -0.07787749f, 0.08245990f, 0.01349988f, -0.01623557f, -0.07533807f, 
    -0.05638269f, -0.05385998f, 0.04538446f, -0.04518577f, -0.02342058f, 0.06790939f, -0.05321303f, -0.04586183f, 
    -0.04990899f, 0.05256626f, -0.06072463f, 0.03026170f, 0.08195385f, -0.05337068f, -0.08374786f, -0.00236884f, 
    -0.01882220f, -0.00655856f, 0.03240890f, 0.06204832f, 0.01514986f, -0.01549132f, -0.08585668f, 0.01788566f, 
    0.06265767f, -0.05197218f, -0.06061348f, 0.00543513f, -0.00598103f, 0.02993745f, -0.07188077f, 0.07128459f, 
    0.00575937f, 0.09655087f, 0.05465836f, 0.06790391f, 0.06206081f, 0.19816913f, 0.18174948f, -0.04536185f, 
    -0.06596473f, -0.21375735f, -0.33193672f, 0.03174165f, 0.19257000f, 0.02051618f, 0.07233926f, -0.03970437f, 
    0.01782998f, 0.23001014f, 0.12911814f, -0.03916716f, 0.03876682f, -0.06305208f, -0.02375681f, 0.03512285f, 
    -0.42132017f, 0.19126655f, -0.17776613f, 0.25882658f, -0.28792417f, -0.12510553f, 0.16030407f, 0.07072909f, 
    0.07814761f, 0.05171319f, 0.14811847f, -0.06605697f, 0.10494450f, 0.13634081f, 0.41658923f, 0.17530732f, 
    0.08187027f, -0.26660702f, 0.02477204f, 0.12992626f, 0.27645573f, -0.00973054f, 0.00160530f, 0.65772128f, 
    -0.00583237f, -0.04276916f, 0.16491841f, 0.27887234f, -0.22113754f, -0.03088818f, 0.21982270f, -0.00945792f, 
    0.54280734f, -0.01885289f, 0.41145399f, 0.03877659f, -0.10424914f, -0.02740387f, 0.01496407f, -0.20979568f, 
    0.10596929f, -0.01836755f, -0.22538066f, -0.42044383f, -0.25080889f, -0.07839289f, -0.23314516f, 0.07659584f, 
    -0.02377414f, -0.37408981f, -0.17139493f, 0.18974832f, 0.13076787f, -0.04961064f, 0.23811913f, -0.01014697f, 
    0.38016710f, 0.07998508f, -0.02273411f, -0.42434821f, -0.02720007f, 0.01143453f, -0.03464542f, -0.07307974f, 
    0.01198361f, 0.05102432f, -0.33385363f, 0.04748207f, 0.36267978f, 0.00201834f, -0.34171477f, 0.04579982f, 
    -0.06832541f, -0.16440591f, -0.24933897f, -0.03472074f, 0.05872916f, 0.12829019f, -0.31441921f, -0.05170777f, 
    0.18895857f, 0.07718132f, -0.02702795f, -0.17202947f, -0.37202191f, 0.07566394f, 0.30647075f, 0.14110388f, 
    0.13576767f, 0.03261344f, 0.01764101f, 0.19948161f, -0.04895113f, 0.00816530f, -0.01868167f, 0.26836389f, 
    -0.02662777f, -0.03707232f, 0.35164899f, -0.22356804f, -0.06223698f, 0.18021543f, -0.04203622f, 0.22657101f, 
    -0.00627282f, -0.01390135f, 0.05201182f, -0.04564161f, 0.00695641f, 0.06211031f, -0.00009820f, -0.03748590f, 
    -0.05728609f, -0.07917672f, -0.00125885f, -0.02100665f, -0.05462604f, 0.00216199f, -0.01065584f, 0.07614835f, 
    0.05509052f, -0.02962259f, -0.03925110f, 0.05537826f, -0.08476402f, -0.08929431f, -0.03970284f, 0.06567523f, 
    -0.04314000f, 0.01077669f, -0.05540495f, -0.07249203f, -0.08751941f, -0.08322127f, 0.05428191f, -0.08622262f, 
    0.05719523f, -0.08060398f, 0.04268225f, 0.06287640f, 0.07772572f, -0.06872794f, 0.00543088f, -0.03474278f, 
    -0.02713478f, -0.05178021f, -0.01174496f, -0.07827627f, -0.03850015f, 0.04805437f, 0.04420992f, -0.02119587f, 
    -0.08237923f, -0.05751932f, 0.07898376f, 0.05367595f, -0.05722601f, -0.08721808f, 0.04659059f, -0.06286045f, 
    0.02972864f, -0.07449591f, -0.00680010f, 0.01312220f, 0.08515559f, -0.01862539f, 0.02972846f, 0.06180779f, 
    0.00527525f, -0.00747170f, 0.04618676f, -0.01642496f, -0.01768580f, 0.07362765f, 0.06369939f, 0.03824006f, 
    0.07290325f, 0.04177852f, -0.05863046f, 0.02820170f, 0.03736088f, -0.04788310f, -0.02868052f, -0.02547194f, 
    0.02193228f, -0.02575212f, -0.06821514f, 0.01966656f, -0.05672810f, 0.06382192f, -0.01446879f, -0.06277525f, 
    0.07033215f, -0.08864067f, 0.00485591f, -0.03192752f, 0.02888716f, 0.01831321f, -0.00579001f, -0.01682581f, 
    0.05607802f, -0.07071730f, -0.04381349f, -0.02991434f, -0.02752203f, -0.05548652f, 0.03762173f, 0.06187037f, 
    0.05871150f, 0.02709701f, -0.08967166f, -0.07208430f, 0.04014988f, 0.00472020f, -0.06310305f, 0.01488885f, 
    0.01912015f, 0.02281523f, -0.06780694f, -0.04025629f, 0.06502093f, -0.07686682f, 0.01946024f, -0.09075201f, 
    -0.09860893f, -0.06170356f, 0.04746243f, -0.04200728f, -0.00316523f, -0.01938368f, 0.01487003f, -0.02619002f, 
    -0.00545880f, -0.35926223f, 0.03385304f, -0.38798907f, -0.02785397f, -0.21320620f, 0.12266108f, 0.01186078f, 
    -0.59429926f, -0.14361717f, 0.35946175f, 0.10847216f, -0.00378640f, 0.05769643f, 0.03179633f, 0.08560937f, 
    -0.01807647f, -0.12967743f, 0.06426305f, -0.00875981f, -0.07440151f, 0.38957053f, 0.07138275f, 0.05985230f, 
    0.39146459f, -0.01419827f, 0.05330019f, -0.18814468f, 0.64751548f, 0.07247894f, 0.11444758f, 0.10724966f, 
    0.08132017f, -0.20604903f, -0.00175301f, -0.20229797f, -0.15899983f, 0.22996642f, -0.26502377f, -0.11998522f, 
    -0.13487823f, 0.16918984f, -0.26472220f, -0.10285826f, -0.06878138f, -0.00677929f, 0.08152292f, -0.42924765f, 
    -0.21728279f, 0.08634899f, -0.27854416f, 0.11971620f, 0.18841676f, 0.05034369f, -0.35015962f, 0.37557581f, 
    -0.48854181f, 0.02928372f, 0.23826319f, -0.02624994f, 0.04969073f, -0.03815513f, -0.01481761f, 0.12110465f, 
    -0.03587902f, -0.01548579f, 0.34874266f, 0.26128542f, 0.35390940f, 0.17146669f, 0.37295574f, 0.10824025f, 
    -0.08545195f, 0.33658519f, 0.07750349f, 0.01579590f, -0.07214149f, 0.02183582f, -0.31423709f, 0.10454296f, 
    -0.42410293f, -0.17914630f, -0.17985301f, 0.29926273f, 0.08619680f, 0.28892082f, 0.07353839f, -0.17225064f, 
    0.19429034f, -0.07776945f, 0.49258235f, -0.25858748f, -0.40511096f, 0.25209337f, -0.45175174f, 0.17276980f, 
    0.22073078f, 0.49669185f, -0.38945723f, 0.02995381f, -0.00960729f, -0.29979688f, 0.04845579f, 0.00550622f, 
    -0.23078440f, -0.04862777f, 0.25008464f, 0.16543008f, -0.14257370f, -0.01333954f, -0.10522873f, -0.19466001f, 
    -0.10046961f, 0.17339478f, -0.01444057f, 0.12329414f, 0.07802060f, 0.05291564f, 0.14120874f, 0.10970005f, 
    0.14317334f, -0.22445066f, -0.39923751f, 0.08151615f, -0.04767042f, 0.10948899f, 0.36836216f, -0.30752328f, 
    -0.02791344f, -0.04513927f, -0.08233231f, -0.04010617f, 0.08913781f, -0.04156863f, -0.08007740f, 0.03489763f, 
    0.01914599f, 0.07255545f, -0.15200762f, 0.03704303f, -0.04263353f, 0.02565368f, 0.00312485f, -0.09266904f, 
    -0.00203362f, 0.03855467f, 0.00745055f, -0.08743315f, 0.05384433f, 0.03685935f, -0.00830730f, 0.04207744f, 
    -0.06864607f, 0.08261523f, -0.08341767f, -0.00206066f, -0.07663965f, -0.08016706f, -0.10034638f, -0.07426992f, 
    0.00634942f, 0.05679114f, 0.06085640f, 0.06494897f, -0.04089708f, -0.09366140f, -0.02633961f, -0.01731703f, 
    0.01171040f, 0.00016033f, -0.13001847f, 0.05352471f, 0.01858166f, -0.03925568f, -0.09510992f, -0.06221776f, 
    0.05006147f, -0.02469199f, 0.04649752f, -0.10081226f, -0.11152439f, 0.06159334f, 0.04445428f, -0.02038537f, 
    -0.01771596f, -0.06022980f, 0.02189016f, -0.11610336f, 0.02534536f, -0.00016030f, 0.06574631f, -0.12217531f, 
    -0.04319273f, 0.01346146f, -0.04754347f, -0.07075845f, 0.05381933f, -0.04369754f, 0.03378794f, -0.03946295f, 
    0.01056002f, -0.06370838f, -0.12696984f, -0.00076770f, -0.05673090f, -0.02887591f, -0.03934979f, 0.04604873f, 
    -0.00803936f, -0.00623326f, -0.02441203f, 0.00302065f, 0.02125136f, 0.00495944f, -0.04282478f, -0.01815454f, 
    -0.06619328f, -0.03224914f, 0.04963355f, -0.02482500f, 0.00290322f, 0.00759424f, 0.00184428f, 0.00501596f, 
    -0.02337899f, -0.08151174f, -0.06395339f, -0.08481336f, 0.00532652f, 0.06368374f, -0.11210077f, -0.09760717f, 
    0.01181445f, 0.07418002f, -0.05503039f, 0.00394000f, 0.05741604f, -0.03233624f, 0.04566500f, 0.05251112f, 
    -0.00809396f, -0.08722035f, -0.10206223f, -0.13212086f, -0.03217029f, 0.02428622f, 0.09185456f, -0.06537665f, 
    -0.12706906f, -0.04287711f, -0.05286463f, 0.02861418f, -0.03250148f, -0.02821305f, -0.04218873f, -0.00391503f, 
    0.02443627f, -0.06116544f, -0.43022230f, -0.06181759f, 0.24988794f, 0.19072865f, 0.20223613f, -0.06924468f, 
    -0.26737612f, -0.08804605f, 0.08478661f, 0.28600425f, 0.44553795f, 0.07940938f, -0.09692359f, 0.29729772f, 
    0.02602408f, 0.03040102f, 0.22786833f, -0.06882489f, -0.32521769f, 0.15010147f, -0.05949388f, -0.58159560f, 
    -0.37749457f, 0.28424209f, -0.50673187f, 0.01570452f, 0.20350596f, -0.00078683f, 0.13796829f, 0.18288010f, 
    0.10984039f, -0.27082825f, 0.32840830f, -0.51120043f, 0.19638957f, 0.06286889f, -0.14603256f, 0.06872039f, 
    -0.14871429f, -0.42469934f, -0.24239208f, -0.06786041f, 0.13170747f, -0.00414887f, 0.43855187f, 0.51013434f, 
    -0.26097050f, -0.32738772f, 0.30803698f, 0.21979123f, -0.75401670f, 0.04460175f, -0.08391391f, -0.03653935f, 
    0.28833041f, -0.25138688f, 0.16249248f, 0.24641958f, 0.01410014f, 0.02873934f, -0.07740672f, 0.07678160f, 
    0.53435314f, 0.01679460f, -0.07141975f, -0.16216289f, -0.21499160f, 0.08732228f, -0.00069503f, 0.15047565f, 
    0.00578226f, -0.24523954f, -0.50927621f, 0.27402204f, 0.09978490f, 0.05747748f, -0.05407071f, -0.13622341f, 
    0.21364033f, -0.07894240f, 0.04980704f, -0.04600593f, 0.03015209f, 0.23437117f, 0.15295289f, -0.33721188f, 
    -0.48117876f, -0.12202871f, 0.47219330f, 0.14746350f, 0.00579179f, -0.07923316f, -0.57773745f, -0.31746447f, 
    0.05190816f, -0.17622107f, 0.27352509f, 0.08345337f, -0.06434800f, 0.04877342f, 0.34589297f, -0.19632143f, 
    -0.00311225f, -0.02767499f, 0.08094992f, -0.07914853f, 0.01711350f, 0.03477532f, 0.06621598f, 0.03608183f, 
    0.07068344f, -0.24234256f, 0.01592211f, 0.34653947f, -0.25246805f, 0.13320886f, 0.05506335f, 0.30353534f, 
    -0.09766423f, -0.15463470f, 0.00343669f, -0.49204144f, 0.09555440f, 0.20919582f, -0.04625746f, -0.15294868f, 
    -0.06500641f, 0.01569646f, 0.09035447f, -0.04034548f, 0.03804270f, 0.03966253f, 0.41207027f, 0.04358488f, 
    -0.16541871f, -0.05291079f, 0.12311866f, 0.00512159f, -0.32075962f, 0.01931041f, 0.10967773f, -0.09738048f, 
    -0.02997348f, 0.11100320f, -0.06003902f, -0.03706739f, 0.05745528f, -0.04125336f, -0.03394196f, 0.09757712f, 
    0.06222678f, 0.19463207f, 0.15920323f, 0.06846038f, -0.24780101f, 0.00221158f, -0.03694915f, -0.13070817f, 
    -0.10318888f, 0.14250600f, -0.10012070f, -0.04986780f, 0.05237121f, -0.09538627f, 0.01521871f, -0.16191082f, 
    0.02594234f, 0.13676673f, 0.23169021f, -0.01334835f, 0.27624983f, -0.03564395f, -0.72109699f, 0.11788116f, 
    0.02468141f, 0.04058475f, 0.04308998f, -0.00980862f, 0.12734583f, -0.04331922f, 0.23228244f, -0.10627135f, 
    0.51828235f, 0.07762971f, 0.10574727f, 0.53883755f, -0.01016946f, -0.03041705f, -0.09913493f, -0.35070470f, 
    -0.11261772f, 0.35006887f, -0.04644190f, -0.41595751f, 0.01541138f, 0.04285355f, -0.08882607f, -0.13403390f, 
    0.09417737f, 0.01077759f, 0.19903499f, 0.21016070f, 0.02965553f, 0.06026772f, 0.07997439f, -0.04119460f, 
    -0.03272896f, 0.12654391f, -0.14442249f, -0.30483097f, 0.08183882f, -0.09576172f, -0.06132138f, 0.26760343f, 
    0.07533361f, 0.15489733f, -0.20211232f, 0.07424427f, 0.11738361f, 0.07812272f, 0.03401765f, 0.02015677f, 
    -0.25488731f, 0.05175296f, 0.47455955f, 0.01615654f, -0.02751020f, -0.01497033f, -0.35911074f, 0.12276964f, 
    0.06527082f, 0.01887208f, 0.04251613f, 0.04674492f, -0.31923220f, 0.13948390f, 0.04705939f, 0.00198270f, 
    0.19989561f, 0.07993473f, 0.00023067f, -0.23647042f, 0.02766984f, 0.10345574f, 0.12633599f, 0.03446479f, 
    0.08593349f, 0.38468921f, 0.01077786f, -0.01858108f, -0.01115396f, 0.21857589f, 0.03453735f, 0.10245790f, 
    0.11825433f, 0.10723542f, 0.30388865f, -0.06415316f, 0.01610764f, -0.24901889f, 0.16574749f, 0.03502798f, 
    -0.10031787f, 0.51338089f, 0.24410854f, -0.16422537f, -0.00599989f, 0.05883218f, -0.18168040f, -0.02268823f, 
    -0.01923120f, -0.05913902f, -0.03973337f, 0.04564209f, 0.10997247f, -0.09250475f, -0.03476843f, -0.05266474f, 
    -0.01582118f, -0.18649305f, 0.00945272f, -0.69200611f, 0.10330039f, -0.00306494f, -0.12669437f, 0.05184194f, 
    0.19734260f, 0.27967614f, 0.04342826f, 0.17501828f, -0.44230574f, 0.18810181f, -0.14480849f, 0.21302725f, 
    0.06453738f, -0.05219561f, 0.36940894f, -0.15498218f, -0.25663328f, -0.06599277f, -0.01139359f, 0.38244984f, 
    0.08065581f, 0.08557254f, -0.02360630f, 0.23245196f, 0.28635725f, -0.32943282f, 0.07121941f, 0.21975814f, 
    -0.21630692f, 0.19199988f, 0.15304258f, -0.16846043f, 0.00285333f, 0.23054950f, -0.07051045f, 0.05625664f, 
    0.07612726f, -0.26273155f, -0.02986909f, -0.07612561f, 0.12053347f, 0.05394551f, 0.16419436f, 0.18213691f, 
    0.10938276f, 0.20100662f, 0.22857298f, 0.00624543f, -0.18132150f, 0.08498678f, -0.00998204f, -0.13481955f, 
    -0.18915588f, -0.17477165f, 0.11457413f, 0.05919636f, -0.07905430f, 0.53250545f, -0.04540758f, 0.51140600f, 
    0.18137552f, 0.00813068f, -0.24945521f, -0.09477347f, 0.11136030f, 0.16082025f, 0.55433452f, 0.22880566f, 
    -0.11373422f, 0.24010387f, -0.40728730f, 0.05885028f, -0.02901682f, -0.13682717f, 0.37188733f, 0.12908846f, 
    0.14984339f, -0.02519774f, -0.09477390f, -0.15060514f, -0.07788547f, -0.33501124f, -0.00226615f, -0.23513515f, 
    -0.40629461f, -0.07575730f, 0.13773064f, 0.47399500f, 0.14732018f, -0.24595596f, -0.33085370f, -0.06682613f, 
    0.14852534f, 0.27680910f, -0.02782700f, 0.00213771f, -0.11324122f, -0.05937026f, 0.07727943f, -0.22312310f, 
    0.03140330f, -0.59399486f, -0.26280802f, -0.16243634f, -0.82352859f, 0.16051294f, -0.50244921f, 0.01085651f, 
    0.30173466f, -0.38486412f, -0.00608382f, 0.02672795f, 0.21719867f, -0.03160945f, 0.15383781f, 0.04672489f, 
    -0.02886585f, 0.04139982f, -0.04410896f, -0.06735901f, -0.04139702f, 0.03670056f, -0.00432539f, 0.12666807f, 
    0.45444754f, -0.38933468f, 0.33533898f, 0.27944705f, 0.27991849f, 0.32656711f, -0.10771633f, -0.12860309f, 
    -0.06047516f, 0.21816178f, -0.08971950f, -0.36653632f, 0.20308340f, -0.04646160f, -0.26882240f, -0.48685330f, 
    0.31507045f, 0.17362536f, -0.16695383f, 0.13574073f, 0.12300297f, -0.00783071f, 0.08289227f, 0.04029181f, 
    -0.39141104f, -0.13071610f, 0.35623413f, -0.32418257f, -0.13644989f, 0.19726995f, 0.00294465f, -0.18586884f, 
    -0.12793025f, -0.08656098f, 0.18411317f, -0.40657267f, -0.08679819f, -0.07718243f, 0.01252110f, 0.01230755f, 
    0.10535059f, -0.10599597f, 0.30536616f, -0.39633253f, 0.42850217f, 0.32129288f, 0.10446817f, -0.08033827f, 
    -0.07940328f, 0.14928508f, -0.05381279f, 0.10719663f, 0.17865995f, 0.03032653f, 0.05227983f, 0.26171905f, 
    -0.22374818f, 0.01897089f, -0.14904438f, -0.47537071f, -0.08283366f, 0.18160172f, 0.03954744f, -0.58449441f, 
    -0.33469039f, 0.07090367f, 0.43529990f, -0.35672748f, -0.36000088f, 0.00035191f, 0.01227704f, -0.08112125f, 
    -0.06686744f, 0.55390882f, 0.05698222f, 0.03531416f, -0.04541401f, -0.08334834f, 0.65698522f, -0.03127499f, 
    -0.47280043f, -0.03448842f, 0.17455621f, 0.03369667f, 0.14004080f, 0.31797111f, -0.50055736f, -0.02668525f, 
    0.48038706f, 0.26865318f, -0.37997821f, -0.02849371f, -0.20998228f, 0.14849983f, 0.22244304f, -0.26111466f, 
    0.10872870f, 0.23120274f, -0.01741670f, 0.10157408f, -0.34908921f, 0.20262884f, 0.03600593f, 0.35690671f, 
    -0.06776024f, 0.01960898f, -0.01973761f, -0.07290815f, -0.01714978f, -0.09284369f, -0.00472650f, -0.04604530f, 
    0.05214599f, -0.01322349f, 0.04097735f, -0.08592638f, 0.04006393f, 0.08506939f, -0.02353745f, -0.08410887f, 
    -0.07830647f, -0.01077230f, 0.00495315f, -0.00117185f, -0.07327443f, -0.06850175f, -0.01923980f, -0.04049432f, 
    -0.03928110f, -0.09165059f, -0.07504418f, -0.02992022f, -0.08392473f, 0.00881315f, 0.02261034f, 0.04255869f, 
    0.02486776f, -0.00647405f, -0.05099646f, -0.00335226f, 0.06824020f, 0.01057758f, -0.02777896f, -0.03460053f, 
    0.05979422f, 0.06183635f, 0.00257156f, -0.02567456f, -0.00706340f, 0.03427189f, 0.07685908f, -0.02686336f, 
    0.04085319f, 0.00511582f, -0.06413781f, 0.03927315f, -0.06337602f, 0.00713935f, -0.05075527f, 0.01969586f, 
    0.05969483f, 0.01129990f, -0.02608243f, -0.02193403f, 0.04463560f, 0.03440221f, 0.01971646f, -0.04966876f, 
    -0.07271469f, 0.07644947f, 0.00835698f, -0.06663465f, -0.04625742f, 0.02766463f, -0.08600744f, -0.08596207f, 
    0.06778686f, -0.02032813f, -0.06692892f, -0.03351486f, 0.01150945f, 0.06360075f, 0.08805468f, -0.03843122f, 
    -0.05355711f, 0.06636474f, 0.03423251f, 0.06320938f, -0.08104687f, -0.05230450f, -0.01243891f, 0.04111947f, 
    0.04119797f, -0.06532547f, -0.01224894f, 0.00380931f, -0.04674376f, 0.00307551f, 0.05056810f, 0.02292601f, 
    -0.05196054f, 0.00197206f, 0.07631093f, 0.08484177f, 0.03111684f, 0.03126382f, 0.02710798f, -0.02632115f, 
    -0.09174222f, 0.00660373f, -0.00595673f, 0.03395773f, -0.08273292f, 0.07211256f, -0.09669552f, -0.05332096f, 
    -0.03145175f, 0.02272152f, 0.00496051f, 0.04594577f, 0.06588221f, -0.00813006f, -0.00104684f, -0.03859214f, 
    -0.08256808f, 0.06135354f, -0.04967756f, -0.00191836f, -0.02118715f, 0.06964675f, -0.08906212f, -0.04890900f, 
    -0.07142799f, 0.02379178f, 0.17635134f, -0.17371780f, -0.01328763f, -0.24634030f, 0.16724607f, -0.05316355f, 
    -0.62179857f, -0.08027951f, 0.37234005f, 0.11580551f, -0.11367086f, 0.03592256f, -0.34637031f, -0.02250583f, 
    0.02805795f, -0.18545184f, 0.00549344f, 0.05389858f, 0.04046354f, 0.05477745f, -0.01743281f, -0.12853384f, 
    0.49465957f, -0.08073998f, 0.27567041f, -0.07181707f, -0.05899058f, 0.45312268f, -0.45849541f, -0.17138234f, 
    -0.22313896f, -0.06644563f, -0.16238846f, -0.02072692f, 0.09583256f, -0.07334401f, -0.05697383f, -0.84225684f, 
    0.17453600f, 0.45160156f, 0.07380088f, -0.05452701f, -0.18237711f, 0.02499669f, -0.24080227f, -0.56378853f, 
    -0.12077343f, -0.10328286f, -0.07672768f, -0.29210672f, 0.32731652f, 0.07217918f, -0.02316730f, 0.33369023f, 
    -0.09974318f, 0.27724332f, 0.07813369f, 0.24901271f, -0.05947334f, 0.15843414f, 0.01299375f, -0.01731306f, 
    0.21243821f, -0.19914025f, 0.06281631f, 0.11002273f, 0.24785744f, 0.01505441f, 0.12681733f, -0.24556550f, 
    0.00031325f, 0.50647449f, 0.00385786f, 0.13549741f, 0.12644310f, -0.00619983f, 0.01095372f, 0.09993099f, 
    -0.20026737f, -0.02751367f, -0.11107039f, 0.29465458f, 0.03445147f, -0.02569683f, 0.11027136f, 0.24716215f, 
    -0.14869650f, -0.00307873f, 0.11640817f, -0.04543553f, -0.29965720f, -0.19661134f, -0.19880095f, -0.24527135f, 
    0.08428514f, 0.23527963f, -0.02261721f, -0.04180411f, -0.22287571f, -0.02596039f, 0.17904153f, 0.04911485f, 
    0.05743048f, 0.07342279f, -0.06208967f, 0.09406265f, 0.26984349f, 0.12507266f, -0.39980766f, -0.06972428f, 
    0.21400864f, 0.04722913f, -0.02326156f, -0.28946903f, -0.07452722f, 0.12756330f, 0.00331193f, 0.22100289f, 
    0.05344987f, 0.08910835f, -0.29569715f, 0.26152197f, 0.06938867f, -0.03192385f, 0.06968526f, 0.05192551f, 
    0.02669037f, -0.01918927f, -0.30658326f, -0.09563510f, 0.22793937f, 0.03331074f, 0.26162466f, -0.05967361f, 
    -0.20603459f, 0.01144894f, 0.14484733f, 0.46886894f, -0.05107568f, -0.01250689f, 0.10011180f, 0.24625644f, 
    -0.03055618f, 0.19113405f, -0.27765837f, -0.00000847f, -0.25495911f, 0.21712206f, 0.00110155f, -0.10037574f, 
    0.19672157f, 0.12448085f, -0.32897663f, 0.32111883f, -0.06599654f, 0.10979655f, 0.09811325f, -0.32017368f, 
    -0.36115667f, 0.02851566f, -0.11812439f, -0.06320197f, 0.41239345f, 0.24572879f, -0.02139555f, 0.79251176f, 
    0.04832008f, 0.15586376f, -0.02646685f, 0.15701185f, 0.00517874f, 0.05226611f, -0.19726746f, -0.10548044f, 
    -0.12613380f, -0.05037854f, 0.27753350f, -0.01466024f, -0.01372610f, 0.17373691f, 0.05533286f, 0.33574840f, 
    0.32350466f, -0.07307633f, 0.18173507f, 0.23090841f, -0.02090604f, 0.12287322f, 0.06775279f, -0.50832438f, 
    0.50432009f, 0.19698703f, -0.15756465f, -0.06990690f, 0.03092129f, 0.04954581f, -0.42855862f, -0.14652830f, 
    0.05415142f, 0.11906520f, -0.15381725f, 0.33244053f, -0.03810812f, 0.01685765f, -0.08108857f, 0.02243103f, 
    0.11118267f, -0.07440650f, -0.17557876f, 0.09241216f, -0.01291345f, 0.22350700f, -0.02457180f, -0.24210879f, 
    -0.44911900f, -0.23564029f, -0.03113585f, 0.09385823f, -0.25708064f, 0.23173799f, -0.10967784f, -0.63959503f, 
    0.19456622f, -0.26458910f, 0.93492758f, 0.05766581f, -0.62273991f, 0.03864520f, -0.27691749f, -0.12967716f, 
    0.02672503f, 0.06674888f, 0.00095348f, 0.18456645f, 0.38985708f, 0.31814843f, -0.06756140f, 0.23064902f, 
    0.36237597f, -0.36706817f, -0.07362922f, -0.00813216f, -0.27046871f, 0.35088497f, 0.30080268f, 0.32776171f, 
    -0.27935502f, 0.00930084f, -0.15530594f, -0.18773998f, 0.04595670f, 0.37979239f, 0.27387747f, 0.17778228f, 
    -0.06980249f, -0.09849676f, -0.24121252f, 0.14392549f, -0.09375223f, 0.02472220f, 0.00140407f, 0.00220121f, 
    0.49177653f, -0.43171331f, -0.16525722f, -0.03420781f, -0.11392527f, -0.05298895f, 0.20813969f, 0.02173390f, 
    0.02370178f, -0.03134708f, 0.00928973f, -0.08303029f, -0.04761515f, 0.00790904f, -0.02658260f, 0.04559295f, 
    -0.24658640f, -0.01032755f, 0.10423078f, 0.10501402f, -0.03452693f, -0.29372889f, 0.19941805f, -0.12062319f, 
    -0.14387187f, -0.11634711f, 0.07400107f, 0.16518122f, 0.13573354f, -0.24002840f, 0.18191481f, 0.13130707f, 
    -0.19868678f, -0.24333918f, -0.06953149f, -0.00162587f, 0.12581974f, -0.02419260f, -0.01854268f, -0.13610673f, 
    0.19462422f, 0.08957167f, 0.30663970f, -0.06985529f, 0.01771392f, 0.16084440f, -0.08907056f, 0.15103413f, 
    -0.02299181f, -0.18062879f, -0.33410344f, -0.15888834f, -0.03091898f, -0.32685566f, 0.01900490f, -0.03757073f, 
    -0.10850803f, 0.11858200f, -0.02005716f, 0.06736124f, 0.08259362f, -0.15061101f, 0.20008214f, -0.15899675f, 
    -0.04284516f, -0.29231057f, -0.06805062f, -0.11164728f, -0.04509622f, 0.07874652f, -0.16851524f, -0.11090247f, 
    0.07987919f, 0.17706209f, 0.01453302f, 0.04046743f, -0.07164273f, -0.03173880f, -0.10626455f, -0.20659621f, 
    0.00794286f, 0.00194732f, -0.06064575f, 0.00256035f, 0.06070847f, -0.14716300f, 0.05609944f, 0.03097298f, 
    0.08868258f, -0.13059211f, 0.13914160f, -0.06239668f, 0.12367957f, -0.04218706f, 0.11479763f, -0.16761750f, 
    -0.01171717f, -0.04204486f, 0.06749663f, 0.16038468f, -0.26801622f, 0.04633041f, 0.07610783f, 0.07086761f, 
    -0.00433544f, 0.22543144f, 0.04266160f, -0.40773499f, -0.10246979f, -0.21460362f, -0.06028185f, -0.13314645f, 
    0.03679832f, -0.10883331f, 0.17386079f, 0.03129089f, 0.14516824f, 0.04743031f, -0.15434852f, -0.21447657f, 
    0.06651020f, 0.13254118f, 0.21375427f, 0.09843638f, 0.38325632f, 0.21451987f, 0.03011035f, -0.04366163f, 
    -0.51405305f, -0.18526754f, 0.11580700f, -0.03447746f, 0.31683776f, 0.00298706f, -0.25522259f, 0.11920597f, 
    -0.06066382f, 0.01655288f, 0.22309992f, 0.03051330f, -0.04103907f, -0.04012072f, 0.01549244f, -0.16815092f, 
    -0.23961708f, 0.33922863f, -0.15329233f, -0.02713049f, -0.15892653f, 0.21178630f, -0.16991428f, 0.03326329f, 
    0.08608019f, 0.00774548f, 0.02103852f, -0.15803452f, -0.16390197f, -0.12035861f, -0.03294883f, -0.75049520f, 
    -0.06979799f, -0.06560411f, 0.44519737f, 0.11074645f, 0.02617514f, -0.00704402f, 0.27611381f, 0.01727619f, 
    -0.13991433f, -0.27087191f, -0.07163319f, 0.26186737f, -0.18159194f, -0.01857670f, -0.02804076f, 0.14004201f, 
    0.46196148f, 0.18497030f, 0.45904660f, 0.18021230f, -0.04549844f, 0.04691213f, -0.03694560f, 0.16378957f, 
    0.22945327f, -0.23866117f, -0.13907683f, -0.16908349f, -0.15966900f, -0.08604231f, -0.33687413f, 0.04592615f, 
    0.00006621f, -0.15330558f, -0.10656356f, 0.22111787f, 0.17731768f, 0.02071710f, 0.32141390f, 0.02403099f, 
    0.25557870f, 0.02616996f, -0.22980860f, -0.08699816f, 0.00282880f, -0.32331076f, 0.08221411f, -0.11417761f, 
    -0.08192736f, -0.02450203f, -0.13660742f, 0.05393417f, 0.22993985f, -0.19031671f, 0.29348582f, -0.01027166f, 
    0.06304242f, -0.28412023f, -0.26033476f, 0.03192656f, 0.08896598f, -0.04844427f, 0.03188127f, -0.01347307f, 
    0.22424839f, -0.07001180f, -0.37854162f, 0.36013639f, -0.17152999f, -0.01007750f, 0.14742962f, -0.03203586f, 
    0.02974578f, -0.05739934f, -0.01462691f, 0.22409445f, -0.00542701f, 0.15044245f, -0.02389351f, 0.37995511f, 
    -0.20465249f, 0.12840448f, 0.19842091f, -0.20175828f, 0.02840001f, -0.55464000f, -0.07071146f, 0.16325539f, 
    -0.08590937f, -0.08927998f, 0.03137765f, 0.02652012f, 0.00692239f, 0.03302447f, -0.02740202f, -0.06069640f, 
    -0.01715119f, -0.09393013f, -0.03338501f, -0.14543161f, -0.03998909f, 0.00990110f, -0.06499107f, -0.08726073f, 
    -0.00807774f, 0.03362320f, -0.01258071f, -0.07470462f, -0.06033014f, 0.03304065f, -0.05733457f, -0.10967847f, 
    -0.01022795f, -0.02394839f, -0.08618286f, -0.09101322f, 0.00927092f, -0.11081676f, 0.01593326f, -0.03284713f, 
    0.05767696f, -0.06327841f, -0.06340859f, -0.07692619f, 0.01861452f, -0.05680676f, 0.03861125f, 0.11446907f, 
    0.04728683f, -0.07561987f, 0.06216354f, 0.04517486f, 0.03588521f, -0.07167274f, 0.04118638f, -0.08841480f, 
    -0.12554222f, -0.06992962f, 0.06391821f, 0.02026105f, -0.10935668f, -0.09940424f, 0.00668006f, -0.08218120f, 
    0.07568192f, -0.11064207f, -0.07834487f, 0.07148696f, 0.08837924f, -0.11746114f, -0.00462054f, -0.13066870f, 
    0.08483642f, -0.07745113f, -0.12455894f, -0.17498593f, 0.02135745f, -0.03896216f, 0.01862592f, -0.07649128f, 
    -0.03145730f, 0.06038043f, 0.01369662f, -0.12077238f, -0.05665096f, -0.08279285f, 0.05998004f, 0.00976875f, 
    -0.03603260f, -0.02129861f, -0.08573965f, -0.08062962f, -0.02193608f, 0.04950882f, -0.09234728f, -0.02303519f, 
    0.02600855f, -0.01705390f, -0.09420781f, 0.01071590f, 0.00110386f, -0.03644970f, -0.03176621f, -0.11838184f, 
    -0.05771498f, -0.06190659f, -0.11645520f, -0.04369729f, -0.03247090f, 0.01972545f, 0.07413444f, -0.00775610f, 
    -0.01103440f, 0.06717486f, -0.01243874f, -0.05009855f, 0.01849857f, -0.03156931f, -0.03762148f, 0.01216322f, 
    -0.05758620f, -0.13417719f, -0.10186543f, 0.08143020f, -0.02488159f, -0.08964337f, -0.04035663f, -0.10792193f, 
    -0.04252650f, 0.06888705f, -0.00227538f, -0.01433242f, -0.08254952f, -0.01685805f, 0.00572546f, -0.02922413f, 
    0.02889128f, 0.06156012f, 0.22977377f, -0.04998944f, -0.24121231f, -0.08442049f, 0.43269441f, 0.07705010f, 
    -0.15277418f, 0.27577230f, -0.06942216f, 0.39947870f, -0.29796284f, 0.05166343f, 0.04399114f, 0.02249179f, 
    -0.05119300f, 0.06159781f, -0.08502268f, 0.02268467f, 0.22891223f, -0.02228815f, 0.04698130f, 0.14275731f, 
    0.12793624f, 0.01392218f, 0.10997642f, 0.26593629f, 0.13184233f, 0.16494915f, -0.09732458f, -0.02255698f, 
    -0.10096099f, 0.16468781f, 0.14279318f, 0.05375560f, -0.02308681f, -0.11144707f, 0.35959485f, 0.00644239f, 
    0.41663629f, 0.11415955f, 0.45878744f, -0.09460450f, -0.11637174f, -0.05672419f, -0.23813680f, -0.39133987f, 
    -0.00189296f, 0.14477624f, -0.18453145f, -0.16245821f, 0.15696470f, -0.00316319f, 0.02583276f, -0.20024540f, 
    -0.19349378f, 0.18176235f, 0.08182228f, 0.34645623f, 0.04655685f, -0.23261754f, 0.14350685f, -0.34870806f, 
    -0.32945013f, 0.10944495f, 0.12394537f, -0.03893657f, 0.23350844f, 0.02503090f, 0.41498473f, -0.21378705f, 
    0.05575681f, 0.11964680f, 0.18203700f, 0.04276007f, -0.05872892f, -0.05071374f, 0.08965537f, 0.07546522f, 
    0.05949130f, -0.07777984f, -0.17523536f, -0.02142822f, -0.06247278f, -0.11757435f, 0.09801830f, 0.00027233f, 
    0.04994500f, 0.00464286f, -0.05430940f, 0.15469553f, 0.19994545f, -0.12965630f, 0.38875422f, 0.10701792f, 
    -0.05317272f, -0.14107589f, 0.08542334f, 0.07144118f, -0.12496048f, -0.15483314f, -0.01890170f, 0.14899506f, 
    -0.23232615f, 0.05029244f, 0.19755697f, 0.51721853f, -0.30023780f, -0.03292300f, -0.11078195f, 0.16293167f, 
    -0.01590078f, -0.03342897f, -0.36953345f, -0.11580855f, -0.07039374f, 0.24348241f, 0.11244696f, 0.19482684f, 
    -0.03800992f, 0.25702399f, -0.10502534f, -0.07305305f, -0.11002527f, -0.25515461f, 0.11713278f, 0.19148701f, 
    -0.01020835f, -0.19623964f, -0.38197398f, 0.01240268f, 0.28653479f, 0.04061958f, 0.00533957f, -0.00489520f, 
    0.30092254f, 0.21598826f, 0.33847871f, 0.75144857f, 0.00756496f, 0.01559869f, 0.20148043f, 0.12542328f, 
    -0.07578995f, -0.05840531f, 0.16558820f, 0.05015880f, -0.44836530f, 0.10508069f, -0.01522952f, -0.15871410f, 
    0.13568063f, -0.06491013f, -0.33617768f, -0.01734005f, -0.62298548f, 0.03193986f, 0.01542088f, -0.21458258f, 
    -0.22039035f, -0.20036323f, 0.12311421f, -0.55136466f, 0.48793003f, 0.45649907f, -0.58728975f, 0.67290193f, 
    -0.25108188f, -0.19112386f, 0.43753821f, -0.01822026f, 0.20753995f, 0.01986939f, 0.61682999f, -0.04745437f, 
    -0.44243687f, -0.34635556f, 0.32724771f, 0.08374099f, 0.05615819f, 0.06148293f, 0.05273348f, 0.41443220f, 
    0.13616551f, -0.31762460f, -0.20954865f, 0.38943011f, -0.06812688f, 0.29012457f, -0.08822990f, -0.04187915f, 
    0.79681152f, 0.25431758f, -0.31267652f, 0.02444828f, -0.15395217f, -0.17874531f, -0.25363153f, 0.10343159f, 
    -0.01645624f, -0.09852020f, 0.02412069f, 0.11394256f, -0.10593523f, 0.01093418f, -0.43380126f, -0.23189890f, 
    0.00629919f, 0.01097575f, 0.03820849f, 0.41756970f, 0.00326527f, 0.20337406f, -0.29893446f, 0.04778676f, 
    -0.21879894f, -0.07017649f, -0.05247462f, -0.18853447f, -0.26138023f, 0.17337422f, -0.83199728f, -0.41749921f, 
    0.03603939f, -0.82298374f, 0.78241777f, 0.03626024f, -0.52964938f, 0.22533821f, 0.08438783f, -0.25359216f, 
    -0.03946624f, -0.04888750f, 0.04787369f, 0.69542098f, -0.01920923f, 0.22696584f, -0.17213772f, 0.07728649f, 
    0.04900254f, -0.66974258f, 0.17755845f, -0.31107822f, -0.18546657f, -0.04871960f, 0.19124393f, -0.06232598f, 
    0.06432602f, 0.07682534f, -0.10143157f, 0.10893050f, 0.11748214f, 0.35546115f, 0.13689300f, -0.42904866f, 
    -0.07595847f, 0.50885648f, 0.22282505f, 0.09339905f, 0.33028457f, 0.09458343f, -0.06711179f, -0.05651733f, 
    0.30590144f, 0.16074756f, -0.14574480f, 0.18912417f, 0.25205380f, 0.04518017f, 0.10490356f, -0.14074419f, 
    0.08112894f, 0.31360891f, -0.10347293f, -0.03156247f, -0.04567031f, -0.11076080f, 0.00041373f, 0.02745350f, 
    -0.47119996f, 0.38705516f, -0.02199114f, 0.16934699f, -0.12623008f, -0.38610369f, 0.19156712f, 0.08844345f, 
    -0.06301159f, -0.16437232f, 0.04553498f, 0.31109500f, 0.04561900f, 0.22270578f, 0.04956505f, -0.22703132f, 
    -0.06576236f, -0.00567312f, -0.14535166f, 0.09983169f, 0.07276397f, -0.10890018f, 0.16152020f, 0.72912520f, 
    0.49415129f, 0.20179714f, 0.12897977f, -0.03211918f, -0.04360576f, 0.07578783f, 0.15462156f, -0.19091344f, 
    -0.57073057f, 0.18823051f, 0.05440816f, 0.30618307f, -0.03297783f, 0.20728424f, -0.08175469f, 0.02398400f, 
    0.08922625f, 0.28783467f, -0.37359998f, -0.16890992f, -0.45412445f, -0.31195009f, -0.13128386f, 0.06869235f, 
    -0.02011316f, -0.19811505f, -0.15315562f, -0.00293376f, -0.05629536f, -0.01411241f, 0.22866607f, -0.16110469f, 
    0.19207418f, 0.22920930f, 0.26452345f, 0.21602684f, 0.05336499f, -0.16954742f, -0.04954014f, 0.21853209f, 
    -0.03196407f, 0.09034315f, 0.22015189f, 0.11853261f, 0.34555438f, 0.04954127f, -0.10690569f, -0.05286398f, 
    0.02802321f, -0.39516243f, -0.08306105f, -0.07991745f, 0.01905193f, 0.23758215f, -0.04952584f, 0.03573358f, 
    0.35703570f, 0.01446742f, -0.26978904f, -0.48341051f, 0.01388671f, -0.13755205f, 0.46626225f, 0.26861629f, 
    0.15276250f, -0.01663151f, 0.20630832f, -0.16420753f, 0.24090709f, -0.24428934f, -0.07281732f, 0.01143145f, 
    -0.14600602f, 0.25545374f, 0.07451494f, 0.00785945f, 0.15475103f, -0.29033202f, 0.01291530f, -0.04132674f, 
    0.04295916f, 0.03238035f, 0.08511561f, 0.08272363f, 0.28483284f, -0.02430749f, -0.06425160f, 0.03553524f, 
    -0.36447892f, -0.17834544f, 0.33295047f, 0.07673262f, 0.11124908f, -0.05987076f, -0.21902470f, 0.06281425f, 
    -0.08195427f, -0.13983843f, -0.26195407f, -0.01643499f, 0.00066764f, 0.06562521f, 0.06340536f, -0.13214789f, 
    0.15300545f, 0.44141692f, 0.10011998f, 0.17721242f, -0.04470425f, 0.15543458f, -0.22712311f, -0.02749620f, 
    -0.09984098f, 0.02048675f, -0.13358416f, 0.00583309f, 0.00885098f, -0.06011933f, -0.15643458f, -0.68452895f, 
    0.03193858f, 0.05707343f, -0.00282562f, 0.00334379f, 0.06667911f, -0.07543238f, -0.30792239f, 0.17420195f, 
    -0.16493565f, -0.02397434f, -0.22589564f, -0.15442716f, 0.03394088f, -0.04884487f, 0.07467492f, 0.22552034f, 
    0.11161862f, 0.02895547f, 0.34036234f, 0.48216522f, 0.08282349f, 0.35635656f, -0.03785197f, -0.07665049f, 
    -0.22877221f, 0.17769246f, 0.13968086f, -0.35887191f, 0.22792608f, 0.05196694f, -0.28565589f, -0.16062811f, 
    -0.01613826f, 0.20359996f, -0.12601121f, 0.42852566f, 0.23380633f, 0.08848542f, 0.02984127f, 0.08519290f, 
    0.00183526f, 0.10638412f, -0.24873571f, -0.24483429f, 0.01303316f, -0.07952663f, -0.04035800f, -0.12643068f, 
    -0.08149458f, 0.06832314f, 0.26386577f, 0.04269090f, -0.05675174f, -0.16011892f, -0.02883450f, -0.03133210f, 
    -0.25079691f, 0.11404660f, -0.36098272f, -0.04364152f, 0.04030736f, 0.23962446f, -0.23454168f, 0.12814446f, 
    0.23563781f, 0.07361413f, -0.10463639f, 0.10947641f, 0.14611159f, 0.01955111f, -0.10613327f, -0.03245348f, 
    0.33440813f, 0.18838920f, 0.23175891f, 0.00030620f, -0.18723270f, -0.02429284f, -0.06546709f, 0.48136100f, 
    -0.00165083f, 0.29520556f, 0.01312130f, 0.13702714f, -0.01463910f, -0.11489825f, -0.09349018f, 0.20337987f, 
    0.09806338f, 0.04528188f, 0.03443635f, 0.14535864f, 0.10231561f, 0.30638814f, 0.37849134f, -0.06352334f, 
    -0.19639987f, -0.22299968f, 0.15700573f, -0.19082601f, 0.09469278f, 0.00014059f, 0.06560098f, 0.03763324f, 
    -0.06264523f, 0.10480702f, 0.11982375f, 0.00402120f, 0.03295114f, -0.11063934f, -0.06414204f, 0.05395069f, 
    -0.11930516f, 0.25714770f, 0.07795277f, 0.38941726f, -0.35657051f, 0.15500060f, -0.03797591f, -0.00355744f, 
    0.09376137f, 0.18046694f, 0.07309050f, -0.01905013f, 0.31469393f, -0.27475077f, 0.12918930f, -0.35305691f, 
    0.07227366f, 0.05724188f, 0.12579273f, 0.15487361f, 0.20837206f, 0.02870928f, -0.29889235f, 0.41378912f, 
    0.05194831f, -0.02609448f, 0.03750951f, -0.00195922f, -0.09868117f, 0.16211849f, 0.35127574f, 0.11110399f, 
    0.95485288f, 0.06028156f, 0.26486135f, 0.37841296f, 0.06175090f, 0.01303321f, -0.15682824f, -0.13894282f, 
    0.20462804f, -0.04099463f, -0.08783848f, -0.17969395f, -0.05366397f, 0.00237162f, -0.30706793f, -0.02876739f, 
    0.00910390f, -0.05605348f, -0.15174735f, 0.29290408f, 0.24020468f, 0.01684426f, 0.29526499f, 0.03868084f, 
    0.23001252f, 0.11809027f, -0.11165724f, -0.29224670f, -0.08075543f, -0.06365376f, -0.06948791f, 0.05673466f, 
    -0.16412108f, 0.23829146f, -0.21574704f, 0.20367204f, 0.11936077f, -0.08805700f, -0.04588518f, -0.01588375f, 
    -0.22660460f, -0.12825404f, 0.15196018f, -0.06458193f, 0.02225308f, 0.22654156f, -0.52603060f, 0.07310920f, 
    0.10888285f, -0.02478823f, -0.02496067f, 0.08250824f, 0.25338060f, 0.17736104f, -0.04906774f, -0.05641552f, 
    0.35943690f, -0.01031186f, 0.04287384f, -0.02242386f, -0.05528520f, -0.07363488f, 0.12625019f, 0.15364967f, 
    0.02069238f, 0.01034551f, 0.15436181f, 0.03478299f, 0.05427486f, 0.13234645f, -0.15058257f, 0.28742486f, 
    -0.02824750f, 0.03297822f, -0.04566990f, -0.09667569f, -0.02790978f, -0.05725066f, 0.04606459f, -0.08142176f, 
    -0.00003103f, -0.05015199f, -0.07693256f, 0.01460032f, 0.00128778f, -0.07602897f, -0.03138321f, 0.07289456f, 
    -0.07351457f, 0.02441408f, 0.01568063f, 0.05245942f, -0.00565782f, -0.06426246f, -0.03655526f, -0.07119747f, 
    0.04453506f, -0.00135152f, -0.06495657f, 0.04952790f, -0.10948118f, -0.01398161f, 0.03227922f, 0.00266946f, 
    0.08204845f, -0.02220933f, 0.02506738f, -0.04513247f, 0.04045585f, 0.03933680f, -0.08174638f, 0.05277116f, 
    -0.00794662f, 0.05211057f, -0.01511285f, -0.06429387f, -0.09909053f, 0.01417940f, -0.06560709f, -0.04543639f, 
    -0.03219528f, -0.06673173f, 0.01867990f, 0.04776749f, 0.04162987f, -0.02973563f, -0.12947918f, 0.02572294f, 
    0.06211293f, -0.08522470f, 0.05149518f, -0.08637468f, -0.01256816f, -0.07298501f, 0.08985689f, -0.07369672f, 
    -0.08270277f, -0.03113553f, 0.05071918f, 0.05393575f, -0.00077474f, -0.09094252f, 0.03053201f, -0.07647929f, 
    0.02080886f, 0.00715729f, -0.07336480f, 0.03822492f, 0.01769131f, -0.07474447f, 0.01290805f, -0.00973895f, 
    -0.06871498f, -0.01326416f, -0.00341201f, -0.02332836f, 0.03217659f, 0.04971064f, -0.13063279f, -0.07844684f, 
    -0.01754678f, -0.05825681f, -0.04765615f, 0.04236655f, 0.03411020f, 0.04364103f, 0.07394518f, -0.08793999f, 
    -0.06631225f, -0.00437829f, 0.06387026f, 0.03270793f, 0.05079084f, -0.07479963f, -0.03082062f, -0.09490706f, 
    -0.03341556f, -0.02307203f, -0.09359603f, -0.04659947f, -0.01139602f, 0.04045866f, -0.01280485f, 0.05726935f, 
    -0.07846417f, -0.00160420f, 0.06886251f, -0.04884814f, 0.05371827f, 0.03184600f, 0.05231057f, -0.09038989f, 
    0.03330403f, -0.04876737f, -0.04985124f, -0.03282069f, 0.01974126f, -0.06839480f, -0.04317584f, -0.08993755f, 
    -0.00410059f, 0.01138471f, -0.11242795f, 0.25065559f, -0.09806547f, 0.00994842f, 0.01173155f, 0.03274397f, 
    0.19905357f, 0.04832804f, 0.00990192f, 0.10973362f, 0.12181935f, -0.06367192f, 0.19465682f, 0.12412237f, 
    -0.06858822f, 0.04198417f, 0.11967066f, -0.05414383f, -0.01067132f, 0.10885651f, -0.00681492f, 0.11605711f, 
    -0.00252811f, -0.20195240f, -0.19146839f, -0.04145306f, -0.02927570f, -0.23046781f, 0.17572875f, 0.10678864f, 
    0.14350782f, 0.19312480f, 0.30546865f, -0.08465678f, 0.01988498f, -0.26475918f, -0.00512650f, 1.07148719f, 
    0.07659963f, -0.23964506f, -0.18805975f, -0.04452500f, 0.16930623f, 0.00991300f, 0.14001383f, -0.84632564f, 
    -0.09372024f, 0.03073100f, 0.20050058f, 0.12957361f, 0.08998119f, 0.03859248f, 0.13832037f, 0.05547035f, 
    0.27826476f, -0.18977246f, -0.20776702f, -0.28868425f, 0.05237805f, 0.08892793f, 0.00287022f, 0.03040763f, 
    -0.28963533f, -0.13539408f, 0.00597466f, 0.04861428f, -0.23742460f, 0.14640184f, -0.06695773f, 0.15918761f, 
    0.00394486f, -0.28683650f, 0.16101046f, -0.04775683f, 0.03000300f, -0.06405458f, -0.02634556f, 0.05093618f, 
    -0.05048585f, 0.06334209f, 0.07506432f, -0.06107934f, -0.02362256f, 0.34613258f, -0.19185314f, -0.06495354f, 
    0.17646018f, 0.05968423f, -0.07431432f, -0.20512141f, -0.08560607f, 0.01714471f, 0.11397147f, 0.22955082f, 
    0.10751695f, -0.11187246f, 0.13208705f, -0.06270493f, 0.06266925f, -0.02787152f, -0.03019620f, 0.06491089f, 
    -0.05360304f, -0.02116434f, 0.25096115f, 0.07174564f, -0.08348621f, 0.04008797f, -0.11308737f, -0.09710946f, 
    -0.11941685f, 0.17846407f, 0.05161466f, 0.26341212f, 0.06919178f, 0.00443793f, 0.02982278f, -0.24466155f, 
    0.10812850f, 0.09041496f, 0.06635939f, -0.18821071f, 0.06781887f, 0.09758436f, -0.02238155f, 0.09382327f, 
    0.02436440f, -0.00185048f, -0.06369065f, 0.02596619f, 0.06263667f, -0.08247703f, -0.07012235f, 0.07209669f, 
    0.08409022f, 0.07015703f, -0.11362439f, -0.07782954f, -0.08502091f, -0.05900126f, 0.07476834f, -0.08107162f, 
    -0.08020348f, 0.00445239f, -0.02808693f, 0.01124410f, -0.06276179f, -0.08532614f, 0.06092691f, -0.00657288f, 
    0.02100324f, -0.01622277f, -0.02237283f, -0.01703952f, -0.01753568f, -0.01718597f, -0.08276373f, -0.03448528f, 
    -0.10048292f, -0.08853412f, -0.04643103f, -0.05316143f, -0.02737910f, -0.07274688f, 0.04665575f, -0.01297041f, 
    -0.10307053f, -0.03648615f, 0.00363159f, -0.03398916f, -0.08647563f, -0.00714450f, -0.06274175f, 0.08108093f, 
    -0.01856454f, -0.06475023f, -0.08041299f, -0.01218139f, -0.02714552f, -0.03173327f, -0.10133448f, -0.07419948f, 
    -0.00545267f, -0.07518870f, 0.02415511f, -0.05659373f, -0.01246519f, -0.01975236f, 0.03980579f, 0.02307371f, 
    -0.02398827f, -0.10200346f, 0.03792646f, -0.03657883f, 0.03026916f, -0.08369684f, 0.05693692f, -0.09727554f, 
    -0.00882513f, -0.10214728f, -0.04270751f, -0.09776797f, -0.03834812f, 0.02089304f, -0.05321163f, -0.03952453f, 
    -0.04682386f, 0.00187136f, -0.06368341f, -0.02728280f, -0.02964589f, 0.00343417f, 0.05277907f, -0.09040608f, 
    -0.11909244f, -0.07138908f, 0.05719245f, -0.05302849f, -0.00844582f, -0.02161019f, 0.05020726f, -0.06019733f, 
    -0.01348581f, -0.03137336f, -0.05561939f, -0.07299542f, 0.04666541f, -0.02757279f, -0.05955680f, 0.00837188f, 
    0.02711814f, -0.07905760f, -0.11846417f, -0.05275375f, 0.03936107f, -0.01512519f, -0.03142688f, -0.06831402f, 
    0.05698270f, 0.04890677f, -0.01748556f, 0.06489182f, -0.06735995f, -0.08534536f, -0.03486923f, -0.10432634f, 
    -0.11700510f, 0.01674848f, -0.10648505f, -0.00389355f, -0.00120255f, 0.03057702f, -0.06989901f, -0.03509649f, 
    0.09062816f, -0.08697066f, -0.04635974f, 0.11732081f, -0.15347858f, -0.13242646f, -0.14054008f, -0.01069191f, 
    0.01180043f, 0.19626938f, 0.25060868f, 0.10715004f, 0.05820204f, 0.04940919f, 0.08493634f, 0.25164041f, 
    0.05662031f, -0.18183303f, 0.06910540f, 0.02273323f, 0.02865394f, 0.05899161f, -0.02488615f, 0.15102166f, 
    0.36967608f, -0.36271289f, 0.15685129f, -0.01997362f, -0.08418540f, 0.17281610f, 0.03798542f, 0.14267229f, 
    0.05942952f, 0.13983959f, 0.12734358f, 0.03006805f, 0.01998226f, 0.05249569f, 0.00087530f, 0.01440189f, 
    0.04400276f, 0.23071542f, 0.14771438f, 0.06318907f, 0.00172733f, 0.07587241f, 0.01814309f, -0.05156571f, 
    -0.05482730f, 0.15637036f, -0.16541569f, -0.15380776f, 0.37158388f, -0.04983273f, 0.10385098f, 0.40540370f, 
    0.01858874f, 0.01460993f, -0.17152347f, -0.19443756f, -0.05288708f, 0.12336741f, -0.03176822f, 0.27184212f, 
    0.07646465f, -0.14633064f, 0.06829264f, 0.14831643f, 0.17735021f, 0.02605743f, 0.14808747f, 0.31940487f, 
    0.06670874f, 0.32421213f, 0.22167753f, -0.07754850f, -0.15050280f, -0.04544990f, -0.06755804f, 0.06230873f, 
    -0.13199618f, -0.13816990f, 0.26253137f, 0.01424905f, 0.04914163f, 0.31708854f, -0.04371647f, 0.12487923f, 
    0.01231124f, 0.10216062f, 0.07893565f, -0.02278707f, -0.13348997f, 0.01083989f, 0.23031823f, 0.07224954f, 
    -0.19638424f, 0.20579545f, -0.05909625f, 0.04901905f, -0.06923516f, -0.05548681f, 0.10388936f, 0.02578648f, 
    0.03573581f, -0.04442026f, 0.08502168f, -0.21986276f, 0.40160155f, 0.00268522f, -0.31030595f, -0.06264124f, 
    -0.16024700f, -0.13556649f, 0.12434576f, 0.01746121f, 0.06037749f, -0.06937823f, 0.04028171f, -0.07779945f, 
    0.09624846f, -0.15972871f, -0.20433964f, 0.23440276f, 0.05425495f, 0.15114146f, 0.00409365f, -0.10708447f, 
    0.05786140f, 0.16539522f, -0.04882462f, 0.27172464f, -0.14226215f, 0.22572079f, 0.13263419f, 0.01944845f, 
    0.22303246f, 0.07647619f, -0.13982619f, -0.19365153f, 0.22016205f, -0.02326904f, 0.23625161f, 0.11928950f, 
    -0.06320442f, 0.11310251f, -0.08007577f, 0.02308440f, 0.04735740f, -0.08877845f, -0.06346335f, 0.07210881f, 
    -0.08082481f, -0.18467107f, -0.15974079f, 0.28543898f, -0.21601197f, -0.01810942f, 0.11702950f, 0.25205964f, 
    0.08716039f, 0.32462415f, 0.30227098f, 0.08234051f, 0.39415559f, -0.42820787f, 0.27261499f, 0.28434986f, 
    0.31251916f, -0.06118578f, 0.14260642f, -0.03810616f, 0.06883860f, -0.03819855f, -0.03513934f, 0.07183518f, 
    -0.01973387f, 0.01557800f, 0.30124775f, -0.27674633f, 0.06532819f, -0.03233297f, 0.26021954f, 0.21256372f, 
    0.76602519f, -0.14543378f, -0.15650065f, -0.00341655f, 0.04316781f, -0.09063327f, 0.13520132f, 0.01375782f, 
    0.25836194f, 0.09589854f, -0.18802837f, -0.00346766f, 0.06866199f, 0.18354103f, -0.27189252f, 0.11226323f, 
    -0.00490168f, 0.01375730f, -0.02021091f, 0.00804850f, 0.04786065f, 0.03525002f, 0.02302155f, 0.06944253f, 
    0.35360298f, 0.09418888f, -0.03054476f, -0.49746963f, -0.04714151f, 0.20783964f, -0.27953127f, -0.01439843f, 
    -0.11977542f, 0.20133148f, 0.06662344f, 0.12314080f, 0.21247153f, -0.18071562f, 0.37605339f, -0.03028400f, 
    -0.06391041f, -0.27653503f, 0.28080165f, -0.08453238f, -0.01487569f, 0.18680328f, -0.29500067f, -0.03910353f, 
    0.11410383f, -0.06006457f, 0.15860051f, 0.09505417f, 0.42176747f, 0.12116374f, -0.19711848f, 0.21434905f, 
    0.11485970f, 0.01382679f, 0.14039789f, 0.11639600f, 0.03591623f, -0.02544767f, 0.11911829f, -0.04871928f, 
    0.12600754f, -0.00252027f, 0.06336259f, 0.04946725f, 0.07808831f, 0.17423356f, -0.12386181f, 0.08105493f, 
    0.10686240f, 0.12742251f, 0.06402843f, 0.07705188f, 0.05272258f, -0.06520576f, -0.04527678f, -0.07978757f, 
    0.59813708f, 0.34143987f, 0.19190449f, -0.25307423f, -0.09181152f, -0.03543320f, 0.15311079f, 0.02288214f, 
    0.06556075f, -0.04205482f, 0.04887347f, 0.09057954f, 0.14763993f, -0.02339098f, 0.06090203f, 0.13296485f, 
    0.10652731f, -0.17061721f, 0.22653736f, -0.12334170f, -0.14851075f, -0.05138004f, 0.04174507f, 0.14920333f, 
    0.04926292f, -0.02594241f, 0.07847066f, 0.19506875f, 0.07764381f, -0.19486228f, -0.20815854f, 0.86991465f, 
    -0.08447228f, 0.02066822f, -0.01312656f, -0.08788064f, 0.01629522f, 0.10844596f, -0.30476767f, -0.01591978f, 
    0.19105819f, 0.28246737f, -0.03710510f, -0.01086064f, 0.46428746f, -0.04152558f, 0.15134647f, 0.14776464f, 
    0.24464719f, 0.10136247f, -0.48813134f, 0.09491718f, -0.02158553f, 0.18049851f, -0.08209011f, 0.19814321f, 
    0.14972931f, 0.09085521f, 0.03609550f, -0.13714196f, 0.14056577f, -0.00256133f, 0.07402435f, 0.19106817f, 
    0.08606510f, 0.15667626f, 0.29013065f, -0.03969061f, -0.19618014f, 0.00867208f, -0.02089112f, -0.09674744f, 
    -0.15786250f, 0.03552299f, 0.41203982f, 0.13728940f, -0.07819381f, 0.23453553f, -0.04087747f, 0.62990099f, 
    0.21532862f, 0.15244837f, -0.16072387f, -0.08074149f, 0.08101258f, -0.20438311f, 0.27831900f, 0.08677621f, 
    -0.27372926f, 0.34472531f, -0.02312933f, -0.03785220f, 0.15320286f, 0.15244350f, 0.01600781f, 0.06291135f, 
    0.36205298f, 0.03431484f, 0.09941217f, -0.77482736f, -0.25132924f, -0.06676344f, 0.07179155f, -0.05209244f, 
    -0.20347311f, -0.09138533f, 0.35720244f, -0.08685205f, 0.23397528f, -0.38151234f, -0.22250697f, -0.44612172f, 
    0.21666548f, 0.29357857f, -0.03555609f, 0.36484006f, 0.20427570f, -0.08469371f, -0.29159287f, -0.18584053f, 
    0.05814689f, -0.19729517f, 0.08432020f, -0.08687188f, -0.01691743f, -0.04322980f, 0.40520579f, 0.02013798f, 
    -0.31512517f, -0.00736250f, 0.11723305f, 0.24069604f, -0.33353290f, 0.03224702f, 0.11977401f, -0.14707315f, 
    0.08212216f, 0.12398911f, 0.04903600f, -0.03602083f, 0.02686539f, 0.09593818f, -0.02463968f, 0.11426576f, 
    0.24550001f, -0.00036149f, 0.22661825f, 0.11415466f, -0.00864233f, 0.03781927f, 0.13264012f, -0.03402424f, 
    -0.16924949f, 0.01669960f, -0.21417497f, 0.14643225f, -0.01360621f, 0.06076655f, 0.02802311f, 0.19765042f, 
    0.02819339f, 0.12431648f, 0.06345247f, -0.00373173f, 0.02046444f, -0.05450198f, -0.16914397f, -0.31950685f, 
    -0.07052363f, 0.02637886f, 0.00150187f, -0.07116818f, 0.06358249f, -0.12243162f, 0.08478630f, -0.12598190f, 
    -0.09637643f, 0.11236271f, 0.07838053f, 0.14358430f, 0.06841214f, -0.02723872f, -0.10182218f, -0.30657566f, 
    -0.01386620f, 0.05969268f, 0.16183987f, -0.26479879f, -0.04002862f, 0.08291873f, 0.37738019f, -0.10746831f, 
    0.06406470f, -0.01391913f, 0.08599326f, -0.03738045f, 0.05568855f, 0.06629532f, 0.11200319f, 0.13571139f, 
    -0.19902600f, -0.13562971f, -0.25833932f, -0.05401326f, 0.08461969f, -0.26612645f, 0.20201474f, 0.17897488f, 
    -0.00256034f, -0.03402857f, 0.11514548f, 0.21408756f, -0.03120204f, -0.02376621f, 0.09145051f, 0.05228949f, 
    -0.00869088f, 0.03581025f, 0.47937351f, 0.00128380f, 0.05779417f, -0.09779534f, 0.21176514f, 0.13932227f, 
    0.00294057f, -0.05055428f, 0.00494588f, 0.07725346f, -0.41362309f, 0.25776827f, 0.04394725f, 0.06617992f, 
    0.17242830f, 0.05940525f, -0.22505881f, -0.10885367f, 0.07408614f, 0.13875222f, -0.00394631f, 0.08496586f, 
    0.00925794f, 0.17377383f, 0.04063765f, -0.08947773f, -0.07064176f, -0.20949483f, 0.04496638f, 0.02572368f, 
    -0.01383111f, 0.29306453f, 0.18482320f, -0.26035795f, 0.22549908f, 0.12995721f, -0.28091389f, 0.07041150f, 
    0.41347924f, -0.09753975f, -0.07526187f, 0.05327187f, -0.14717950f, 0.03655342f, 0.03299943f, -0.23125026f, 
    0.07639258f, 0.13282010f, 0.11330619f, -0.06593370f, 0.01857687f, -0.04108256f, -0.03617438f, 0.14440423f, 
    -0.26021191f, 0.26203328f, 0.13834086f, 0.13162248f, 0.00604261f, -0.23678049f, 0.27245849f, -0.02874898f, 
    0.01140367f, -0.50584763f, -0.15275134f, 0.25197026f, -0.23145403f, 0.25530413f, 0.15666631f, -0.45006293f, 
    -0.25435618f, 0.00135332f, -0.49891576f, 0.14179072f, 0.10001027f, -0.01869366f, 0.10280395f, 0.22987089f, 
    0.49712923f, 0.04890340f, -0.00852564f, -0.01404757f, -0.14658763f, -0.02805839f, -0.07648107f, -0.22528550f, 
    -0.57788473f, 0.11525796f, 0.07661712f, 0.05641645f, -0.05695069f, 0.19654612f, 0.03786337f, 0.40760630f, 
    -0.10708717f, 0.27665073f, -0.10285331f, 0.00441486f, -0.13672523f, -0.17048135f, 0.36115372f, 0.11037429f, 
    -0.09631918f, 0.02553088f, -0.11027545f, -0.14558938f, -0.03550394f, 0.05731113f, 0.21445569f, -0.16327964f, 
    -0.05614069f, 0.02669122f, 0.34374762f, 0.48854667f, -0.01011263f, -0.12845466f, 0.31397071f, 0.12174153f, 
    0.07419219f, 0.13612756f, 0.19384080f, 0.13316563f, 0.09625316f, -0.06460328f, -0.27162167f, 0.01014373f, 
    -0.04539093f, 0.02120368f, -0.30035213f, 0.03042151f, 0.38010105f, 0.24628632f, 0.17626192f, -0.11113121f, 
    0.32872596f, 0.04995242f, -0.18732390f, -0.64309734f, -0.07433265f, 0.05137423f, 0.62280142f, 0.07832547f, 
    -0.08892678f, 0.21058799f, 0.13546763f, -0.25263262f, 0.26207328f, -0.34311289f, -0.09738192f, -0.04543098f, 
    -0.03824574f, 0.20333463f, 0.06058635f, 0.17231899f, 0.24726978f, -0.23616083f, -0.09510841f, -0.36140811f, 
    -0.09487695f, 0.02214252f, -0.06972238f, 0.28521699f, -0.11654934f, -0.28299916f, -0.18564692f, -0.00517621f, 
    0.04174576f, 0.30798098f, 0.02997303f, 0.11139246f, 0.36902741f, -0.05003224f, -0.16956498f, 0.24799360f, 
    -0.04772157f, -0.36866480f, -0.14094549f, 0.01823419f, 0.24571310f, 0.09839105f, -0.03376678f, 0.06649099f, 
    0.12814297f, -0.12347486f, -0.14892760f, 0.26744688f, -0.17155987f, 0.17617920f, -0.12669811f, 0.14503236f, 
    0.13701460f, 0.15771687f, 0.26742318f, 0.16876663f, 0.12389860f, -0.16058175f, 0.16911307f, -0.27959821f, 
    0.45705083f, 0.17557631f, 0.25284290f, -0.00643818f, -0.10844985f, -0.04109123f, 0.02863613f, 0.38713714f, 
    0.02510877f, 0.01242641f, 0.10143925f, -0.31780592f, 0.14303465f, -0.20762405f, -0.02193354f, 0.60583061f, 
    -0.23602733f, -0.17675793f, -0.44863030f, 0.04482626f, 0.03357902f, 0.12819149f, -0.08283801f, 0.27092862f, 
    0.60413796f, -0.11809965f, -0.18999127f, -0.38550574f, 0.06336520f, 0.17564724f, 0.12367950f, 0.19092123f, 
    0.11458698f, 0.37941808f, -0.04622665f, -0.15302986f, -0.32934988f, -0.04790230f, 0.26173398f, 0.32616889f, 
    0.16667978f, -0.13318625f, 0.12951368f, -0.37881851f, -0.00549841f, 0.56741691f, -0.53858793f, 0.27691305f, 
    -0.15888692f, 0.17266226f, 0.24498366f, -0.13069470f, -0.17210868f, -0.61827874f, 0.07710735f, -0.29844475f, 
    -1.14686656f, 0.01251195f, -0.12188967f, -0.06947254f, -0.02232413f, 0.32620275f, 0.19399762f, -0.18315960f, 
    -0.00983218f, 0.04771137f, 0.00550958f, -0.09976714f, 0.00478799f, -0.06284729f, -0.31756923f, -0.05875475f, 
    0.25546584f, -0.34200260f, 0.13647190f, -0.04763499f, -0.03474481f, -0.46781439f, -0.15331259f, 0.11071786f, 
    0.09456509f, -0.29636735f, -0.24617077f, 0.49517101f, -0.14440337f, -0.61687708f, -0.78134608f, -0.05576199f, 
    0.03662607f, -0.08105168f, 0.00266626f, -0.40506569f, 0.18071759f, -0.19996834f, 0.19518222f, -0.08496241f, 
    -0.09493417f, -0.05179669f, 0.32395416f, 0.04212320f, 0.15842444f, 0.03131332f, -0.01726055f, -0.04932319f, 
    -0.05852224f, -0.06742527f, -0.17479855f, 0.05943538f, -0.08090891f, 0.22606155f, -0.02492964f, -0.27222922f, 
    0.41768998f, 0.42515644f, 0.05702620f, 0.05183635f, 0.44707042f, 0.05925921f, -0.03772704f, -0.12013145f, 
    -0.02223759f, -0.08039720f, 0.02189791f, -0.01109433f, 0.37645417f, 0.28691697f, -0.13682632f, -0.34875941f, 
    -0.16452037f, -0.13298596f, -0.21292190f, -0.06981572f, -0.01623874f, 0.05558360f, 0.06367635f, -0.34175941f, 
    -0.29444453f, 0.11304510f, -0.07904501f, -0.16979647f, 0.16910703f, 0.08188678f, 0.04847347f, 0.36550474f, 
    -0.49289563f, -0.16076320f, 0.07829951f, 0.52027661f, 0.04188185f, 0.36010239f, -0.02377428f, -0.38991931f, 
    -0.35970625f, 0.59361339f, 0.03259541f, 0.09744078f, 0.48191217f, 0.12828489f, -0.04918993f, -0.17282425f, 
    -0.03693265f, 0.40089875f, 0.24197346f, 0.56613040f, 0.06196528f, 0.07867097f, -0.80576748f, -0.29061306f, 
    -0.15808989f, 0.05409983f, -0.36939752f, 0.13747188f, -0.05716558f, 0.27083847f, -0.26646724f, -0.05897937f, 
    0.14564778f, -0.14161246f, 0.48949090f, -0.23215403f, -0.32308167f, 0.23847239f, -0.32520196f, -0.07348912f, 
    0.30419984f, 0.06881027f, -0.02826851f, 0.05116488f, -0.31032178f, 0.33399466f, -0.24709751f, 0.32213840f, 
    0.09075376f, -0.06198436f, 0.37591085f, 0.09587841f, 0.23490727f, -0.11948378f, -0.37788436f, 0.10260021f, 
    0.25499254f, 0.08195375f, 0.22732157f, -0.06101347f, 0.00382162f, 0.25560385f, 0.08975064f, 0.30066851f, 
    0.24906309f, 0.10914996f, 0.01520197f, 0.15579638f, 0.04723183f, 0.32542863f, 0.38402942f, -0.51302266f, 
    -0.06952862f, -0.10727417f, -0.18451618f, -0.13908146f, 0.12434105f, 0.18411052f, -0.29251206f, 0.00792654f, 
    -0.08008260f, -0.12605886f, 0.08222567f, 0.14407334f, 0.25268042f, -0.08276948f, 0.02346366f, 0.17824362f, 
    0.02259552f, -0.00362250f, 0.21016581f, 0.00964277f, -0.09552461f, 0.29824233f, 0.08207408f, -0.03793786f, 
    0.03763583f, 0.23570165f, -0.13296250f, -0.16838245f, 0.35206217f, 0.01124208f, 0.23771985f, 0.07346593f, 
    0.27805081f, -0.17774287f, 0.08937655f, -0.07327070f, -0.06787866f, 0.42607144f, -0.31683788f, 0.23820731f, 
    -0.13440545f, -0.07799550f, -0.43596682f, 0.06397753f, 0.06399570f, -0.00692696f, 0.56443316f, 0.00333588f, 
    0.16307569f, -0.02526123f, 0.12330465f, 0.28051743f, -0.19300468f, 0.03500765f, -0.28585771f, 0.06079837f, 
    -0.60959154f, -0.13185900f, 0.14356764f, -0.37034196f, 0.05388902f, 0.23695092f, -0.05512163f, 0.42462054f, 
    0.17272472f, -0.21333969f, 0.01656037f, 0.16976683f, -0.13533969f, 0.07223111f, 0.22838080f, 0.23666531f, 
    -0.08188201f, -0.04481855f, -0.10522574f, -0.07377633f, 0.09441283f, -0.02830252f, -0.05454125f, 0.06960922f, 
    -0.11598985f, -0.08887454f, 0.01198836f, 0.10356073f, -0.04049576f, 0.21977371f, 0.21070038f, -0.10173070f, 
    0.06369445f, 0.02610254f, 0.26148698f, 0.14216611f, -0.33362541f, 0.37109542f, -0.35896507f, 0.12032852f, 
    0.00471532f, 0.18972816f, -0.39688098f, 0.08814087f, 0.10372721f, 0.02228589f, 0.15301071f, -0.13289142f, 
    0.08274724f, 0.00806759f, -0.02258250f, -0.12211870f, -0.12284637f, -0.00112373f, 0.23170802f, -0.03787642f, 
    -0.04117701f, 0.13074708f, 0.04541419f, 0.24698541f, 0.13254732f, -0.24604860f, -0.04476343f, 0.24936251f, 
    -0.11945196f, -0.23272270f, 0.01056227f, 0.00869280f, 0.05899594f, -0.27972671f, 0.10437211f, -0.14808825f, 
    -0.05167075f, -0.08181895f, 0.06127017f, -0.02480221f, 0.01587404f, -0.02261010f, -0.07176475f, 0.01089005f, 
    0.00531851f, -0.04259659f, -0.08246062f, -0.00127414f, -0.05134809f, 0.08597096f, 0.03164935f, 0.00010732f, 
    0.02319199f, -0.00399064f, -0.09135106f, 0.06779422f, -0.02959569f, -0.00557576f, -0.02610286f, -0.03896106f, 
    -0.04121294f, -0.00259835f, 0.05547877f, 0.05379428f, -0.07690150f, 0.06330048f, -0.07002745f, 0.04197743f, 
    0.08244141f, -0.06430839f, 0.05677103f, 0.00509091f, -0.02623668f, 0.07388587f, 0.04277161f, -0.08704282f, 
    -0.00501965f, -0.02720633f, 0.01872507f, 0.01564706f, -0.00480686f, 0.08589400f, 0.03889815f, -0.02846779f, 
    0.04133900f, -0.02693562f, 0.02423931f, -0.01803875f, 0.07574882f, 0.00169784f, -0.07763577f, -0.06029207f, 
    0.01326990f, 0.07830931f, -0.03737146f, -0.01179397f, 0.05127059f, 0.06644455f, -0.05946313f, -0.05968095f, 
    0.07080474f, 0.03679058f, -0.00109190f, 0.06115040f, -0.08279016f, 0.01119304f, 0.04178444f, -0.08898894f, 
    0.03487556f, 0.01692540f, -0.06958497f, -0.05694749f, -0.07819003f, -0.04507808f, -0.05567315f, -0.06204420f, 
    0.01204437f, -0.05151817f, 0.07702939f, -0.08467845f, -0.01317814f, -0.00120957f, -0.07441346f, 0.02532443f, 
    -0.06527935f, 0.00651954f, -0.08895571f, -0.05483217f, 0.04812307f, -0.05921164f, -0.08271977f, 0.02505765f, 
    -0.02571250f, 0.02318266f, 0.08522023f, -0.08035819f, 0.05470334f, -0.06260683f, -0.03714284f, -0.04491326f, 
    0.02555846f, 0.00838257f, -0.01543011f, 0.05322957f, -0.01737600f, -0.05519798f, 0.02114359f, -0.09974240f, 
    0.01003270f, 0.01966004f, -0.08538566f, 0.06598487f, -0.06076837f, -0.04219038f, -0.03132222f, 0.01368745f, 
    0.04249999f, -0.00829282f, 0.08361465f, -0.01097048f, 0.01819996f, -0.06604697f, 0.06787734f, 0.06630210f, 
    -0.09223589f, -0.08674913f, -0.13140213f, -0.08872614f, 0.11007825f, 0.11991504f, 0.00195667f, -0.07437705f, 
    -0.51319963f, -0.01939807f, 0.22694203f, 0.21246779f, 0.29615524f, -0.08631158f, -0.19834626f, 0.18001367f, 
    0.04093252f, -0.17858432f, 0.22659048f, -0.05141577f, -0.16356255f, 0.20863332f, 0.05615246f, -0.14603183f, 
    -0.02282533f, 0.21917340f, -0.31324282f, -0.00483340f, 0.29079297f, 0.12446070f, 0.15574333f, 0.07511588f, 
    0.19086486f, -0.16067635f, 0.18649323f, -0.01967160f, 0.04592963f, 0.60594207f, -0.10220646f, -0.07181273f, 
    0.12710188f, -0.11841308f, -0.58927262f, 0.03610828f, 0.02614485f, -0.04437280f, 0.54157043f, 0.36609021f, 
    0.04142486f, -0.06721830f, 0.15116458f, 0.17691381f, -0.03987817f, 0.06011130f, -0.25228530f, 0.23220310f, 
    -0.38856080f, -0.04536898f, 0.20443301f, -0.32490313f, -0.03957199f, 0.20119710f, -0.16907583f, 0.34964627f, 
    0.38140613f, -0.11057158f, -0.06557153f, 0.07838961f, -0.16797613f, 0.18691017f, 0.27922764f, 0.23855084f, 
    0.01867029f, 0.12747088f, -0.21029449f, 0.08684158f, 0.04929069f, 0.01780678f, -0.02967340f, 0.19763897f, 
    0.12364728f, -0.15584181f, -0.13055034f, 0.25584224f, -0.03187565f, 0.36843976f, 0.14815091f, 0.07619019f, 
    -0.17478454f, -0.01895308f, 0.17551596f, 0.09996404f, -0.36891937f, 0.24990372f, -0.36824930f, -0.20469521f, 
    -0.30941594f, 0.21797542f, -0.67008007f, 0.04448156f, 0.04992987f, 0.21890207f, 0.34127659f, -0.10875642f, 
    0.22332029f, -0.03559451f, 0.00309203f, -0.02341343f, 0.21936063f, 0.08021426f, 0.09216983f, -0.02464635f, 
    0.04282369f, 0.04386355f, 0.12784900f, 0.44104221f, -0.00051066f, -0.37475181f, -0.37471548f, 0.35517013f, 
    0.00697068f, -0.21655849f, -0.17018309f, 0.12853044f, 0.04822508f, -0.64167929f, -0.04827549f, -0.25108257f, 
    0.05754299f, 0.34842718f, -0.10767739f, 0.10223722f, 0.12642536f, -0.10364543f, -0.12575111f, 0.04677509f, 
    0.49089712f, 0.16317597f, -0.07740618f, 0.22686577f, 0.06732927f, -0.01051837f, 0.23964979f, 0.06959254f, 
    0.02034983f, 0.31962940f, -0.13295904f, -0.02378994f, 0.04470959f, 0.12795188f, 0.06831203f, -0.08322667f, 
    -0.19401813f, 0.49896026f, -0.04906506f, 0.14505650f, 0.31836283f, -0.50039625f, 0.30264235f, -0.01248025f, 
    0.07245516f, -0.25929502f, 0.09185164f, 0.10281751f, 0.01219017f, 0.25640768f, 0.01660626f, -0.03470504f, 
    -0.12073141f, -0.29471678f, -0.30263475f, 0.20825267f, 0.33198765f, 0.02979279f, 0.06530226f, -0.14463122f, 
    0.18274800f, 0.12003870f, 0.07109869f, 0.23274973f, -0.02243624f, 0.01819615f, 0.13245884f, -0.13109176f, 
    -0.36047032f, -0.08358711f, 0.27408767f, 0.27965003f, 0.00610090f, 0.29949546f, -0.01848716f, -0.09157012f, 
    -0.45606098f, 0.71388209f, -0.18665220f, -0.24590337f, -0.04605519f, -0.11248559f, 0.09888712f, -0.00967322f, 
    -0.00461945f, -0.22634578f, 0.02042379f, 0.28524661f, -0.05352122f, 0.06715299f, -0.07966384f, -0.25034031f, 
    0.11420339f, 0.20130834f, 0.04379689f, 0.22083382f, 0.01592560f, 0.12636638f, -0.10511807f, 0.08314445f, 
    0.10652145f, 0.08687607f, 0.41425645f, 0.04469139f, 0.29431987f, 0.25748208f, -0.14959493f, 0.18731241f, 
    -0.17431201f, -0.12333430f, -0.02939213f, -0.05576918f, 0.07039522f, 0.46801662f, -0.08369789f, -0.01437971f, 
    0.09076238f, -0.07040497f, 0.10831048f, -0.26031661f, -0.40087217f, -0.28346050f, 0.46499291f, 0.20725797f, 
    0.04107200f, 0.20590080f, 0.12466365f, -0.05877292f, 0.11709984f, -0.15073285f, -0.21797127f, 0.21602812f, 
    0.10182721f, 0.34674916f, 0.16327725f, 0.11907351f, -0.03525513f, -0.23726135f, 0.11342505f, -0.10168166f, 
    -0.00251746f, -0.02441069f, -0.10035498f, -0.23012459f, -0.04486044f, 0.02881149f, 0.37349844f, -0.06128316f, 
    -0.31932688f, -0.03966761f, 0.14802311f, -0.52049917f, 0.05397756f, 0.06374268f, 0.11469424f, 0.16560386f, 
    0.06727700f, -0.03644922f, 0.11025869f, -0.02002520f, -0.20114949f, 0.02713690f, -0.02186881f, 0.06883526f, 
    0.14380939f, 0.05013788f, 0.06955077f, 0.17011139f, -0.13816710f, -0.06597790f, 0.21195315f, 0.19556256f, 
    0.17774349f, -0.07520162f, 0.40435296f, 0.05037694f, 0.36311334f, -0.13522512f, 0.03159026f, -0.02056793f, 
    -0.03773063f, -0.18063518f, -0.02926455f, -0.12602408f, 0.14779584f, 0.00683275f, -0.26684645f, -0.24651776f, 
    -0.00145035f, 0.20059030f, -0.14770886f, -0.01467869f, 0.06531478f, -0.08868723f, 0.06063676f, 0.66133440f, 
    0.57277048f, -0.27615622f, -0.03127909f, -0.01270177f, -0.07512077f, 0.16113804f, 0.08526420f, -0.26785037f, 
    -0.05616030f, 0.28530240f, -0.00896541f, -0.36048502f, 0.36774275f, 0.19068918f, -0.02043543f, 0.17431825f, 
    0.08596108f, 0.18624821f, 0.12712809f, 0.34855688f, -0.10356490f, 0.08917648f, -0.43472609f, 0.00625530f, 
    0.01327563f, -0.03563047f, -0.40611944f, -0.41414368f, 0.07550495f, 0.53660613f, -0.04790226f, 0.05555577f, 
    0.06437188f, 0.00568457f, -0.08219174f, -0.06496707f, -0.00062349f, 0.21079604f, -0.48307857f, 0.07903011f, 
    -0.18406148f, 0.12337249f, 0.34049249f, 0.07789110f, 0.04296583f, 0.14979671f, -0.68488497f, 0.03907352f, 
    0.03855361f, -0.01116161f, 0.41433674f, -0.11103382f, 0.26079196f, 0.05224053f, -0.00967628f, -0.00213973f, 
    -0.04205817f, 0.15601997f, 0.17313541f, -0.00964378f, 0.02142961f, 0.12604237f, 0.07139467f, 0.30684784f, 
    0.23598842f, -0.16224207f, 0.09261508f, 0.12300186f, 0.11638919f, 0.57136112f, 0.17371455f, -0.51677400f, 
    -0.01218872f, 0.02721651f, -0.03939880f, 0.04333358f, -0.07209697f, -0.08341268f, 0.00141993f, -0.00664197f, 
    0.06241783f, -0.07201539f, -0.07201132f, -0.09315051f, -0.00835169f, 0.03733647f, -0.00108234f, 0.02064776f, 
    0.01422259f, -0.05639603f, 0.01817424f, -0.01778429f, -0.09534587f, -0.02007425f, 0.07340213f, -0.00372767f, 
    0.04885900f, 0.03881357f, -0.00196686f, 0.00913947f, 0.05483758f, -0.07115343f, -0.08011756f, -0.06836485f, 
    -0.04340741f, -0.10543860f, -0.02486040f, -0.00297378f, -0.00801195f, 0.00851455f, -0.04837592f, 0.00941584f, 
    -0.03796144f, 0.06087386f, -0.05338195f, 0.03198013f, -0.06135315f, 0.07184152f, -0.03650995f, 0.03007866f, 
    0.00306903f, 0.06760213f, 0.00997935f, -0.04089905f, 0.03691464f, 0.00558736f, 0.04482998f, 0.07988895f, 
    -0.07746822f, -0.04265148f, -0.04053210f, -0.03962402f, 0.02516237f, -0.09904698f, -0.04244546f, 0.05739460f, 
    -0.04902330f, -0.03762126f, 0.01730793f, -0.03369434f, -0.03737472f, 0.05946981f, -0.03131111f, -0.08399118f, 
    -0.00553091f, -0.04465401f, -0.02293969f, -0.06576220f, 0.01908201f, -0.08235338f, -0.09002005f, 0.05858866f, 
    0.03955790f, -0.01414678f, 0.05274383f, 0.03965064f, -0.08200529f, 0.02848449f, 0.01398230f, -0.08819846f, 
    -0.03540748f, 0.00040554f, -0.05875473f, 0.05261728f, -0.00138307f, -0.10144172f, 0.01085829f, -0.03464198f, 
    0.04534337f, 0.06454130f, 0.07046952f, -0.02501432f, 0.06007827f, 0.04103860f, 0.02870388f, 0.05500077f, 
    -0.08336630f, 0.04805515f, 0.01274322f, 0.08667649f, -0.03538779f, -0.00389654f, -0.01275919f, -0.09666570f, 
    -0.04636841f, -0.06147094f, 0.06788191f, -0.05337111f, -0.08621029f, -0.00124656f, -0.00654835f, -0.04797343f, 
    -0.08753500f, 0.03462510f, -0.04338968f, -0.02868966f, 0.06729413f, 0.04268294f, 0.07085361f, -0.02107940f, 
    -0.09742068f, -0.14584535f, -0.15126011f, -0.17374499f, -0.39093438f, -0.01042648f, 0.03115026f, -0.06483591f, 
    0.51620138f, -0.19442089f, -0.05954367f, -0.08337078f, 0.17652780f, -0.07014628f, 0.19908421f, 0.21100169f, 
    0.04216528f, -0.04316318f, 0.10800306f, -0.00931238f, 0.02630456f, 0.20970365f, -0.06836660f, 0.20679989f, 
    0.03302867f, -0.03619819f, 0.12800539f, 0.12132409f, 0.16925177f, -0.22476988f, 0.39340189f, 0.19640775f, 
    0.05057041f, -0.19523919f, 0.29286933f, 0.09243498f, 0.11509322f, -0.14570102f, 0.28932443f, 0.44855011f, 
    0.04199020f, -0.19309528f, -0.10763446f, -0.01159286f, 0.03699079f, -0.00789222f, 0.07297806f, -0.78264004f, 
    0.28637451f, 0.29372612f, 0.02314005f, -0.35689124f, 0.02490604f, -0.02640229f, -0.12212821f, 0.00109437f, 
    0.00687277f, -0.24376798f, -0.45994738f, -0.10442647f, -0.06930947f, -0.17776930f, -0.01897747f, 0.04650177f, 
    -0.18013228f, 0.49041435f, 0.07867356f, -0.14067325f, 0.15296525f, 0.13511619f, 0.73721230f, 0.13803303f, 
    0.02960902f, -0.02227502f, 0.16912091f, -0.35834846f, -0.15593293f, 0.01589996f, -0.20709506f, 0.13009396f, 
    -0.02916192f, -0.10259623f, -0.10944533f, -0.25445765f, 0.03946877f, 0.18041763f, 0.12582974f, -0.15700647f, 
    0.16032231f, 0.21384399f, 0.46691987f, 0.12034933f, -0.02673670f, -0.21681622f, -0.21746507f, -0.03005275f, 
    -0.33761296f, 0.12129163f, 0.43672857f, -0.02629561f, 0.10490970f, 0.06474414f, 0.01845719f, -0.31179786f, 
    -0.22637329f, 0.00048250f, 0.41021383f, 0.20236710f, -0.20265473f, 0.16437034f, 0.06281265f, 0.14044249f, 
    -0.08841158f, 0.31006247f, 0.04076355f, -0.12530924f, 0.05408692f, -0.20164724f, 0.00739400f, -0.34792587f, 
    0.22148612f, -0.35813180f, -0.03252117f, 0.23527333f, 0.08239958f, -0.11114678f, -0.29077986f, -0.29061306f, 
    0.01127889f, -0.08653575f, -0.01373538f, 0.03103469f, 0.04113288f, -0.09745120f, 0.01505459f, -0.06840057f, 
    0.03729376f, -0.03784611f, -0.07802296f, -0.03463557f, 0.03988479f, -0.08230989f, -0.02204968f, -0.00405319f, 
    -0.06265236f, -0.06816623f, -0.05387971f, -0.03475108f, -0.00930669f, -0.00886282f, -0.03808012f, 0.03779156f, 
    -0.05279349f, -0.08789512f, 0.03422511f, 0.01900641f, -0.03639920f, -0.02504665f, -0.06650093f, 0.03687315f, 
    -0.07144624f, -0.11569516f, 0.01002584f, 0.01651382f, 0.03487346f, 0.03504502f, -0.10111375f, -0.01293133f, 
    -0.06122450f, -0.09756489f, -0.01168939f, 0.03178042f, -0.10358687f, -0.03439927f, -0.10733218f, 0.01678713f, 
    0.01788473f, -0.06863521f, 0.02725392f, 0.01405736f, -0.06003412f, -0.04679215f, -0.07780816f, -0.01733425f, 
    0.04698280f, 0.02542737f, -0.08166561f, 0.00299358f, 0.04943176f, -0.00500504f, -0.05573346f, -0.09537332f, 
    0.01618750f, -0.02310573f, -0.05561009f, -0.04708858f, 0.01643104f, -0.07106403f, 0.04590578f, -0.07730973f, 
    -0.04678156f, -0.05122982f, -0.07228222f, 0.03779801f, 0.03908106f, 0.00833332f, -0.10367394f, -0.08647600f, 
    -0.02602364f, 0.01132841f, -0.02751911f, 0.01525546f, 0.03162068f, 0.03480433f, -0.01617056f, 0.07155018f, 
    0.01017585f, 0.00640725f, 0.00526795f, -0.09284612f, -0.02040315f, 0.03504473f, -0.03465430f, -0.10591917f, 
    -0.00837733f, -0.00230472f, 0.04409454f, -0.07132513f, 0.03498768f, 0.04998953f, -0.03795991f, -0.06700394f, 
    0.01650436f, -0.04174085f, -0.08162281f, -0.11512968f, 0.08659232f, -0.07293995f, 0.08099784f, -0.12148979f, 
    0.04621011f, 0.02714344f, 0.04538852f, -0.06020015f, 0.04429683f, -0.05397557f, -0.01803341f, -0.05747424f, 
    -0.08625013f, -0.07934608f, -0.02008589f, -0.00149868f, -0.05508099f, -0.04165504f, -0.06977393f, 0.02809138f, 
    -0.05431177f, -0.20695247f, 0.01233144f, -0.10803904f, -0.12686796f, 0.10038088f, -0.02312659f, 0.06509590f, 
    -0.32385871f, -0.32905585f, -0.02359636f, -0.06664462f, 0.15027261f, -0.04924506f, -0.06181621f, 0.11319833f, 
    0.06154311f, -0.17825818f, 0.23707467f, 0.04718070f, 0.15693925f, 0.23764220f, -0.03523913f, 0.03564522f, 
    0.08004072f, 0.14973703f, 0.05073611f, -0.12648706f, 0.36822340f, 0.27792075f, 0.05326912f, 0.05315480f, 
    0.17437568f, -0.02822918f, 0.07528774f, 0.02740940f, -0.05896214f, 0.25638893f, -0.08843472f, 0.37413126f, 
    -0.02436484f, 0.16320284f, -0.03356940f, -0.05680225f, -0.15362510f, 0.00100903f, 0.55544215f, -0.06253311f, 
    0.08865988f, 0.10038517f, -0.06001838f, 0.01135292f, -0.18947193f, -0.01228380f, -0.33875522f, 0.18800057f, 
    -0.44923946f, 0.08786768f, 0.24624325f, -0.27845943f, -0.04260836f, -0.02338539f, -0.07252756f, 0.29229620f, 
    0.33280474f, -0.22771792f, 0.21045813f, 0.25943699f, 0.16820671f, 0.07804475f, 0.35642850f, 0.09561520f, 
    -0.08698107f, 0.17400447f, -0.16039275f, -0.05912160f, 0.10556898f, 0.01751358f, 0.10101973f, 0.24181233f, 
    -0.03777061f, -0.03487225f, 0.10715526f, 0.32032529f, 0.05051427f, 0.18912403f, 0.34287214f, -0.29437643f, 
    0.05298284f, -0.04203635f, 0.38574812f, -0.10919158f, -0.22358863f, 0.06884179f, -0.33050984f, -0.00856788f, 
    0.06986669f, 0.40113202f, -0.53007001f, -0.04210125f, 0.09872364f, -0.04499076f, 0.32272968f, -0.05731938f, 
    -0.13172881f, -0.04404404f, -0.01277216f, 0.16824619f, 0.09807806f, -0.03047862f, -0.03233020f, -0.00637173f, 
    0.10320923f, 0.16198333f, -0.10055848f, 0.30632222f, 0.00363236f, 0.03351521f, 0.03226651f, 0.29650626f, 
    -0.07309755f, -0.46030948f, -0.11663017f, 0.03427930f, 0.01397033f, -0.06265308f, -0.12417646f, -0.15981574f, 
    -0.07649353f, 0.11116994f, -0.17303513f, 0.23778032f, 0.08780531f, 0.17441525f, 0.05361373f, -0.00170730f, 
    0.19476210f, -0.04455797f, -0.14255562f, -0.15907438f, 0.43511674f, -0.01579448f, 0.06810346f, 0.21040757f, 
    -0.07350264f, 0.11582144f, -0.04269594f, -0.01159670f, -0.04709978f, 0.14937717f, -0.05060717f, -0.00965326f, 
    0.02927496f, 0.11898733f, -0.14694424f, 0.28415176f, 0.00698280f, 0.05409713f, 0.06780653f, 0.09416413f, 
    0.09137166f, -0.15678404f, 0.10069678f, 0.04046486f, 0.03829403f, 0.16925092f, 0.00781158f, -0.25046566f, 
    0.05876842f, -0.09809628f, -0.40058264f, 0.11426932f, 0.26863801f, -0.06635623f, 0.41058996f, 0.89477295f, 
    0.23722631f, -0.12246469f, 0.40505415f, -0.12440847f, -0.41174912f, 0.10508052f, 0.01194837f, -0.02992953f, 
    0.10556446f, -0.13110384f, -0.10123739f, -0.43824968f, -0.02191732f, 0.14086473f, -0.17229539f, 0.36652955f, 
    0.44108391f, 0.02657930f, 0.04771253f, -0.06291740f, -0.03998203f, 0.00976900f, -0.19471683f, 0.21700063f, 
    -0.06045425f, 0.03339100f, -0.30051386f, -0.00597627f, 0.16168079f, -0.07788711f, 0.25856403f, 0.05834625f, 
    0.12847485f, -0.02810003f, 0.10091219f, -0.33829260f, -0.07069284f, 0.13934800f, 0.00310983f, -0.14819032f, 
    -0.22126585f, 0.05646433f, 0.39104855f, 0.09202401f, -0.04729153f, -0.06287324f, -0.09161513f, -0.18790668f, 
    -0.53679150f, 0.20004234f, -0.31392926f, 0.06186801f, 0.09905960f, 0.20597441f, -0.03210178f, -0.21289527f, 
    0.10913554f, 0.04657022f, -0.01451048f, 0.16425486f, 0.51768953f, 0.08120547f, 0.19515519f, 0.05524469f, 
    0.27294210f, 0.03376280f, -0.04004339f, 0.05937913f, 0.01255483f, -0.37346298f, -0.08777162f, 0.05842370f, 
    -0.19758742f, -0.07924419f, -0.08120850f, 0.09558353f, 0.06585778f, -0.09305725f, -0.30977353f, 0.15606001f, 
    0.01839354f, -0.03468741f, 0.05668765f, -0.06601623f, -0.03058447f, -0.06949335f, -0.01562938f, 0.00897731f, 
    -0.01890169f, -0.05860485f, 0.01018887f, -0.01046441f, 0.02615264f, -0.07332328f, -0.10056212f, -0.01172201f, 
    0.01790501f, -0.03507131f, 0.02519269f, -0.07303926f, -0.07737319f, -0.02481094f, 0.04422681f, -0.00016721f, 
    0.04617696f, 0.08476716f, -0.08272113f, -0.00966539f, -0.09945887f, -0.00169346f, -0.01281375f, 0.01298515f, 
    -0.04563185f, 0.03385812f, 0.04913453f, -0.07976085f, -0.07696883f, -0.08373747f, 0.00851715f, -0.08813948f, 
    0.02035887f, 0.00382759f, 0.01626322f, -0.00091066f, -0.06838825f, -0.05351238f, -0.08210050f, 0.04434413f, 
    0.01672530f, -0.07188109f, -0.01785187f, -0.02138027f, -0.05838771f, 0.00091774f, -0.00552458f, -0.00108300f, 
    -0.05399459f, 0.00387056f, -0.01872350f, -0.00069559f, 0.00888373f, 0.05886653f, 0.02853131f, -0.07368664f, 
    0.08193597f, 0.05320309f, -0.09009212f, 0.07461990f, 0.02558719f, -0.07970546f, -0.00988346f, -0.04056636f, 
    0.00743324f, -0.00270342f, -0.08362695f, -0.04737366f, -0.03599653f, 0.03585212f, 0.01080656f, -0.02658531f, 
    -0.06018497f, -0.06461894f, 0.03534035f, 0.07995553f, 0.01330383f, -0.08065238f, 0.05749024f, -0.03287571f, 
    -0.01430468f, 0.06297528f, -0.03736817f, -0.03680541f, -0.03867206f, 0.00861979f, 0.02833816f, 0.01976008f, 
    0.07199979f, 0.05773845f, -0.03291088f, 0.04434815f, -0.09729434f, -0.05874268f, -0.00731006f, -0.06328142f, 
    -0.05188830f, 0.08300894f, 0.04478265f, 0.02160570f, -0.00878164f, 0.05770453f, 0.00091314f, -0.09097112f, 
    0.04518100f, -0.05500764f, -0.08776197f, -0.11018888f, -0.10094701f, -0.10418198f, -0.08701350f, -0.05084419f, 
    -0.06905171f, 0.03796751f, -0.09838194f, -0.01162095f, -0.04128126f, -0.07398879f, 0.03899353f, 0.00264346f, 
    -0.03976437f, -0.09645641f, -0.07887094f, -0.20186120f, -0.03801324f, -0.00816632f, -0.04854910f, 0.01756666f, 
    0.07905479f, -0.24534668f, 0.11362045f, 0.15324591f, -0.01025808f, -0.01289228f, 0.03913970f, 0.07400885f, 
    0.06803440f, 0.04927787f, 0.00529452f, 0.02350918f, -0.10082504f, 0.29003951f, -0.05043428f, 0.07152860f, 
    0.10781220f, 0.17802510f, 0.17711009f, 0.00933796f, 0.31626964f, 0.01862602f, 0.31302276f, -0.13678952f, 
    0.01808922f, -0.24889800f, -0.05926183f, 0.10181805f, -0.05684458f, 0.39750022f, -0.13856401f, -0.20862257f, 
    -0.29066235f, 0.02755064f, -0.28152546f, 0.09464690f, 0.11355913f, 0.02852227f, 0.39261466f, -0.27650619f, 
    0.38774067f, 0.01114388f, 0.06864880f, 0.07241511f, -0.08586475f, 0.15120475f, -0.15001947f, -0.37007856f, 
    -0.25207782f, -0.01988341f, 0.13604398f, -0.05033003f, 0.03544576f, 0.07351337f, -0.17223275f, 0.22182380f, 
    -0.12469622f, 0.26845422f, 0.11080212f, 0.09989612f, -0.08531846f, -0.08851383f, 0.25121123f, 0.17075329f, 
    -0.04900649f, 0.10233628f, -0.02299210f, -0.28072044f, 0.11293633f, -0.11305641f, 0.04515648f, 0.01973314f, 
    -0.17435583f, 0.04223396f, -0.03816611f, 0.37401217f, -0.02430327f, -0.28659758f, 0.26998988f, -0.17621674f, 
    0.08468231f, 0.07506968f, 0.60099572f, -0.02803256f, -0.19928302f, 0.20042600f, -0.46486574f, 0.00088837f, 
    -0.03776434f, 0.35799029f, -0.31581765f, 0.03223495f, 0.26137787f, -0.02742816f, 0.11380612f, -0.14424065f, 
    0.03612554f, -0.01934057f, 0.11953319f, -0.04062766f, -0.07078329f, 0.14485665f, 0.35875800f, 0.04886760f, 
    0.07076409f, 0.27252099f, -0.01790331f, -0.06561249f, 0.10085081f, -0.21274768f, 0.08033002f, -0.08643252f, 
    -0.09394911f, 0.04710637f, 0.04027539f, 0.07319447f, 0.06594729f, -0.47628891f, -0.05545789f, -0.07319669f, 
    -0.00485372f, -0.04796602f, 0.04988705f, -0.03534308f, -0.05829195f, -0.01848806f, 0.08441197f, 0.01816066f, 
    0.02986183f, 0.06597979f, -0.09677225f, 0.03038249f, 0.02600838f, 0.05742819f, -0.02447230f, -0.06477446f, 
    0.03673282f, 0.03558948f, -0.07137769f, -0.03446255f, -0.04760403f, -0.04716305f, -0.06912643f, -0.00334141f, 
    -0.05331270f, -0.04500644f, 0.04033032f, -0.08865317f, -0.06643613f, -0.03719886f, -0.01998018f, 0.03591415f, 
    0.04128080f, -0.04345176f, -0.02317036f, -0.08639400f, -0.05458321f, 0.04749348f, 0.02606168f, 0.08053841f, 
    -0.03922781f, -0.02117208f, -0.03713371f, -0.04817834f, 0.02407311f, -0.03531818f, -0.03447574f, -0.06210223f, 
    0.04660182f, 0.03179793f, -0.06230567f, -0.04861515f, -0.00000537f, 0.05881796f, -0.09424850f, 0.06371163f, 
    -0.00284543f, -0.09247746f, 0.07187930f, -0.00502981f, -0.02514926f, 0.04921329f, -0.04310119f, 0.00661622f, 
    -0.00744669f, -0.02016242f, -0.08623706f, -0.02278893f, -0.04700615f, 0.02409401f, 0.06417813f, 0.04668267f, 
    0.00142293f, 0.02417439f, -0.00358629f, 0.04848060f, -0.01223469f, -0.02289094f, -0.05406402f, -0.02724823f, 
    -0.00513202f, 0.04115452f, 0.01758866f, -0.00417894f, -0.01373218f, -0.04390559f, 0.08318346f, -0.10041831f, 
    -0.08228263f, -0.05513998f, -0.08361084f, 0.05250135f, 0.05600170f, 0.00159574f, 0.00530188f, 0.04287235f, 
    0.03529257f, 0.01415342f, -0.07757058f, -0.01155231f, 0.04606896f, -0.06045089f, -0.03175063f, 0.01000557f, 
    -0.05388036f, 0.06807656f, -0.04021296f, -0.06157694f, 0.03519047f, -0.02950761f, 0.07462872f, 0.06127159f, 
    -0.05975577f, 0.05035482f, 0.05810349f, 0.06914687f, -0.04790191f, -0.03831469f, 0.00997736f, -0.06383544f, 
    0.00525409f, 0.01721164f, 0.00653508f, -0.09866259f, -0.05451637f, -0.07190290f, -0.06007229f, 0.02398050f, 
    0.05202121f, 0.14260481f, -0.00094087f, 0.14515603f, 0.08552530f, 0.06809986f, 0.20272852f, -0.07241096f, 
    -0.08205520f, 0.01343376f, 0.09277505f, 0.13406412f, 0.27010909f, -0.05433550f, -0.09309477f, -0.08044278f, 
    0.07656882f, -0.06612684f, -0.18357387f, -0.00648692f, 0.10180298f, 0.15959711f, -0.00898501f, -0.26465392f, 
    0.10711065f, 0.11147261f, -0.02849276f, 0.22050355f, 0.00259081f, 0.37319687f, -0.36772820f, -0.04545008f, 
    -0.11140755f, 0.12045835f, 0.16172837f, 0.00918576f, 0.26776293f, 0.02983082f, 0.07918030f, -0.82827938f, 
    0.35405281f, 0.15832031f, 0.21235959f, 0.03988900f, -0.02312855f, -0.00889493f, 0.13014311f, 0.22997966f, 
    0.08446059f, -0.27543449f, 0.08812803f, -0.29679582f, -0.23587896f, 0.16030757f, -0.02046118f, 0.07784266f, 
    -0.11086461f, 0.04962797f, 0.15266530f, 0.27261406f, 0.05734751f, -0.02971741f, 0.04529660f, 0.01940508f, 
    0.11062416f, -0.11528818f, -0.09736741f, 0.26509559f, 0.24604364f, 0.08246332f, -0.09845974f, -0.15496269f, 
    0.03051258f, 0.15814100f, -0.40167785f, 0.19204040f, 0.15932280f, -0.01491141f, 0.15695955f, 0.21404129f, 
    0.32353380f, 0.12125067f, 0.12907030f, 0.29739344f, 0.02822981f, 0.10829005f, 0.04117066f, -0.18713284f, 
    -0.33173019f, -0.09848715f, 0.34887257f, 0.17275439f, 0.04818445f, -0.12117528f, -0.21065399f, -0.47606999f, 
    0.26962882f, 0.00992365f, -0.42058405f, 0.06933805f, -0.05624817f, 0.20552403f, 0.18936022f, -0.03569160f, 
    0.01661519f, 0.05929295f, -0.16474769f, 0.49776492f, 0.25344872f, -0.05797473f, -0.17673546f, 0.14056894f, 
    0.14060472f, 0.11314069f, 0.07038277f, -0.05678758f, -0.38258037f, 0.17028111f, 0.14701021f, 0.33045757f, 
    -0.21878020f, 0.25464630f, 0.12756434f, 0.17652766f, -0.01482242f, -0.17000359f, -0.00929401f, 0.26323047f, 
    0.00714426f, 0.09413900f, 0.01567921f, -0.00885106f, 0.13212740f, -0.00110022f, 0.03181514f, -0.02408273f, 
    0.19049042f, -0.02633618f, 0.08180755f, 0.34612349f, -0.34146261f, 0.02577600f, 0.00974786f, -0.06323276f, 
    -0.06051936f, 0.01064070f, 0.03995184f, -0.00840114f, -0.06992968f, 0.02280878f, -0.04256463f, 0.06256314f, 
    0.03693530f, 0.17031384f, 0.05664474f, -0.00563961f, 0.00066711f, -0.10032741f, 0.13505229f, -0.17797457f, 
    -0.06028416f, 0.04807810f, -0.26414096f, 0.15362693f, -0.10467210f, -0.07949973f, 0.02767053f, -0.11340459f, 
    0.08203610f, -0.09968387f, 0.07262906f, 0.11712836f, 0.12116303f, -0.04570000f, -0.40105665f, -0.28934461f, 
    0.14326344f, 0.12927578f, -0.06102258f, -0.02474957f, 0.14200462f, -0.00264193f, 0.16237600f, -0.43116736f, 
    0.16979900f, -0.03251337f, -0.02093448f, 0.37805787f, 0.00636484f, 0.14937183f, -0.01861029f, -0.13283120f, 
    -0.32130852f, 0.17901894f, 0.05438111f, -0.24290283f, 0.00194132f, 0.04904450f, 0.33721766f, -0.10688270f, 
    0.01703215f, -0.07071365f, 0.13215187f, -0.05367035f, 0.08525749f, -0.10030839f, -0.04789537f, 0.03311487f, 
    -0.00258889f, 0.01108173f, 0.14433527f, 0.25220293f, -0.00538983f, -0.10524128f, 0.00154282f, 0.23266165f, 
    0.18980479f, -0.00473705f, -0.02684274f, 0.05136983f, 0.06990208f, -0.07491677f, 0.05516868f, 0.08970943f, 
    -0.10076676f, -0.16884847f, 0.40664774f, -0.00942866f, 0.22008137f, 0.00653686f, 0.06714312f, 0.07290778f, 
    0.17278582f, -0.01628379f, -0.05061017f, -0.19274095f, -0.30601224f, -0.05852886f, 0.25702569f, 0.10325982f, 
    -0.01657099f, 0.16942848f, -0.02699216f, 0.01588969f, 0.18799055f, 0.05158577f, -0.00945442f, -0.06335378f, 
    0.08719531f, 0.41543984f, 0.13602328f, -0.12747450f, -0.08616699f, -0.32270890f, -0.00575639f, 0.05521528f, 
    -0.02910730f, -0.00494680f, 0.18030262f, 0.14592834f, -0.10033555f, -0.29172185f, -0.27162874f, 0.07251021f, 
    0.10875086f, 0.27637908f, 0.14985943f, 0.33427823f, 0.03374524f, -0.06039506f, -0.20834076f, 0.04154397f, 
    -0.08071502f, -0.18219061f, -0.01818974f, -0.08053240f, 0.04077504f, -0.11584441f, 0.06425711f, 0.09058533f, 
    -0.07352236f, -0.09166356f, -0.02778468f, -0.72439265f, 0.05920224f, -0.19846126f, -0.15431809f, 0.16564351f, 
    0.22856735f, 0.16764094f, -0.02410545f, 0.01908374f, -0.56782377f, 0.33711365f, -0.27196068f, -0.21002434f, 
    -0.00721344f, -0.02120070f, 0.00751690f, -0.16703033f, -0.04126865f, -0.06094469f, 0.14015774f, 0.31091127f, 
    0.00772990f, -0.05831308f, -0.01841405f, 0.28967467f, 0.35510918f, -0.19791599f, 0.29183999f, 0.48655665f, 
    0.42588192f, 0.05910753f, 0.46163043f, -0.33226287f, -0.03837967f, 0.27012479f, -0.04564307f, 0.19645010f, 
    0.27201828f, -0.32387903f, -0.14831504f, -0.37479749f, -0.22510070f, 0.09427336f, 0.27192861f, 0.35014606f, 
    -0.03726198f, 0.10969774f, 0.28835839f, 0.19151187f, -0.24693666f, 0.00598418f, -0.00870155f, 0.01251411f, 
    -0.47367027f, -0.27449188f, 0.04297526f, 0.01516406f, 0.08413887f, 0.63363719f, -0.02460485f, 0.58203316f, 
    0.14643502f, -0.01661980f, -0.24457367f, -0.21467659f, -0.00793342f, 0.24188596f, 0.16568550f, 0.18220483f, 
    -0.23005532f, 0.36016691f, -0.37194565f, 0.08774157f, 0.12330484f, -0.17412822f, 0.29753095f, 0.13790131f, 
    0.31350395f, -0.06252411f, -0.23122676f, -0.57726038f, 0.04922116f, -0.31464767f, -0.07700101f, -0.42215541f, 
    0.04266840f, -0.19579333f, 0.07124641f, 0.48038343f, 0.16134301f, -0.44721782f, -0.51343238f, 0.29150900f, 
    0.00253485f, 0.13074683f, -0.22094436f, 0.18930519f, -0.12106495f, -0.21751772f, 0.13670643f, -0.12134108f, 
    -0.08288478f, -0.23156607f, 0.01711694f, 0.21608196f, -0.75231266f, -0.26621845f, -0.00788311f, 0.05088489f, 
    -0.23703156f, 0.10815506f, -0.51762617f, -0.43392116f, 0.15812097f, 0.04031647f, -0.10660210f, 0.20978315f, 
    -0.02550326f, -0.19801605f, -0.05715327f, -0.07820307f, 0.16112716f, 0.15999486f, 0.08032853f, 0.04034882f, 
    0.16600455f, -0.20185536f, -0.01595876f, -0.03316743f, 0.37212741f, 0.25067481f, -0.00199395f, 0.24450178f, 
    0.20031990f, 0.33054599f, 0.15468475f, -0.06276355f, -0.22511134f, -0.27208292f, 0.15328500f, -0.00802506f, 
    0.38393331f, 0.12490906f, 0.35751152f, -0.11419792f, -0.39198527f, -0.00877449f, 0.15070227f, 0.39451656f, 
    -0.11870161f, 0.09757563f, -0.28101212f, 0.03654172f, -0.07322339f, -0.18436974f, -0.10394193f, 0.02516424f, 
    -0.13385333f, -0.02391773f, -0.09133806f, -0.38631773f, -0.06029153f, -0.27181906f, 0.01470903f, 0.09724191f, 
    -0.27563968f, -0.50388157f, 0.26467881f, 0.09246347f, 0.32128158f, 0.24117236f, 0.14973745f, 0.09981246f, 
    -0.01458542f, 0.25592482f, 0.05748949f, -0.23743452f, -0.11962699f, -0.02525973f, 0.24131745f, 0.34258401f, 
    0.16651836f, -0.15267169f, 0.01376685f, -0.17088628f, 0.07045134f, 0.35816368f, -0.35534588f, -0.12085980f, 
    -0.00966829f, 0.15281402f, -0.06833889f, -0.06528858f, 0.06299236f, -0.14040583f, 0.52414989f, 0.24050240f, 
    0.05462747f, 0.02307729f, 0.18526059f, 0.03257500f, 0.08836415f, -0.25686279f, 0.22628823f, 0.06749655f, 
    -0.39544407f, -0.01834968f, 0.28824133f, 0.40344280f, -0.12336181f, -0.06742169f, -0.13350169f, -0.33730125f, 
    -0.12715173f, 0.08778290f, -0.61469513f, 0.26948920f, 0.06552225f, 0.16102380f, -0.05878503f, -0.05320271f, 
    0.17843729f, -0.46380258f, -0.01319134f, -0.02183833f, -0.46008104f, -0.68630338f, -0.13626179f, 0.24167478f, 
    -0.01273336f, -0.05966822f, -0.07659519f, -0.11498050f, -0.03773262f, -0.07220896f, 0.03125135f, -0.00048473f, 
    -0.11346090f, 0.04694218f, 0.04355287f, -0.02473733f, -0.03777348f, -0.03210875f, 0.03753023f, -0.01875652f, 
    -0.02689329f, -0.08343096f, -0.06617150f, -0.02703530f, 0.00351204f, 0.03507090f, -0.08449072f, -0.01588224f, 
    -0.01062072f, 0.05611168f, -0.03268961f, -0.05947519f, 0.00214875f, 0.02744051f, -0.05892889f, 0.01038057f, 
    0.01808610f, -0.03266484f, -0.01632416f, -0.00791707f, 0.03894912f, -0.03977409f, -0.02885042f, -0.07478320f, 
    -0.01253431f, 0.02749757f, -0.06647329f, -0.08691613f, -0.01496564f, -0.06203787f, -0.14029445f, 0.01052997f, 
    -0.07905187f, 0.04642604f, -0.09427353f, -0.04396134f, -0.01409832f, -0.00795500f, -0.04112147f, 0.00145844f, 
    0.00490929f, 0.00474005f, 0.01134583f, 0.04665084f, -0.06301457f, -0.00834410f, 0.08916619f, -0.04096272f, 
    0.06942709f, -0.01080101f, -0.11315697f, 0.03460562f, -0.02292499f, -0.04736489f, -0.06452536f, 0.04539439f, 
    0.04026191f, -0.03790760f, -0.09417961f, -0.07920288f, -0.03105129f, -0.07161953f, -0.05887503f, -0.11182801f, 
    -0.09912923f, -0.03315547f, -0.04384999f, -0.04820596f, -0.05563153f, -0.10817974f, -0.07224202f, -0.06965590f, 
    0.03331131f, 0.04506053f, -0.09169445f, 0.03426655f, -0.07054307f, 0.05439168f, -0.04122959f, -0.01629085f, 
    -0.03750093f, -0.04082981f, -0.00614123f, 0.07206857f, -0.04993915f, -0.07925269f, 0.05108002f, -0.11183058f, 
    -0.08699381f, 0.04262254f, -0.05276702f, 0.00797415f, 0.08073363f, -0.00642408f, 0.00832114f, -0.10015500f, 
    0.00185202f, 0.03280622f, 0.04540678f, -0.06920270f, -0.10110059f, -0.04933054f, 0.05242775f, 0.01169830f, 
    0.00730619f, 0.01840422f, -0.09451021f, -0.07880837f, -0.00715758f, -0.06984624f, 0.03781611f, 0.06491137f, 
    -0.01796811f, -0.02850387f, 0.12374472f, -0.01032764f, 0.25687978f, 0.02260135f, 0.13253616f, -0.07263378f, 
    -0.00776383f, 0.23777831f, 0.05155111f, 0.23426151f, -0.52074820f, -0.08416182f, 0.16307451f, -0.21728355f, 
    -0.06050267f, 0.19977620f, -0.06580585f, -0.01917074f, -0.13159354f, 0.00248865f, -0.05243095f, 0.09863289f, 
    0.09419316f, 0.09484055f, 0.16665819f, -0.07903392f, -0.03072808f, 0.01313867f, 0.04626509f, -0.25953799f, 
    -0.13376215f, 0.10309227f, -0.27624530f, 0.13239153f, -0.10121774f, 0.04303835f, -0.01461110f, 0.11376075f, 
    -0.04368104f, 0.07332814f, 0.52435499f, 0.08894434f, 0.03542043f, 0.06989861f, -0.44628888f, 0.00437189f, 
    -0.02054938f, 0.05627323f, 0.12830514f, 0.15497115f, 0.19119003f, 0.14962116f, 0.23375309f, -0.34351319f, 
    0.07365766f, 0.19422646f, 0.09904363f, 0.38569382f, 0.01577748f, -0.04346215f, -0.02043977f, -0.36081946f, 
    -0.19876419f, 0.22410133f, 0.13629471f, -0.18445098f, 0.08983011f, -0.00931957f, 0.05771948f, -0.32401222f, 
    -0.00996197f, 0.00752885f, 0.23816243f, 0.14629805f, 0.04927600f, -0.01164466f, 0.03116997f, -0.09164083f, 
    -0.05308168f, 0.01836004f, 0.07695962f, 0.16164908f, 0.00713876f, -0.28385589f, 0.14494582f, 0.40101665f, 
    0.12413768f, -0.10966197f, -0.19787842f, 0.13842024f, 0.02026844f, 0.12196550f, 0.43702781f, 0.10008852f, 
    -0.06297624f, 0.02120916f, 0.60191137f, 0.07892271f, 0.04921400f, -0.13276820f, 0.10490181f, 0.04792399f, 
    0.11078038f, 0.02373461f, -0.02528475f, -0.06437208f, -0.35527951f, 0.00913807f, 0.07844016f, -0.01250295f, 
    -0.04389346f, -0.05401949f, -0.10541338f, -0.27356318f, 0.15358774f, 0.14852494f, 0.11100215f, -0.01871195f, 
    0.06604888f, 0.42461169f, 0.08563253f, -0.06466679f, -0.02196626f, 0.05260269f, 0.22522902f, 0.07694840f, 
    0.07511519f, 0.17710233f, 0.12738098f, 0.04776045f, -0.14617318f, -0.07444681f, 0.09543967f, 0.05323371f, 
    -0.52719772f, 0.45553979f, -0.07014270f, -0.27631077f, -0.06962869f, 0.06768223f, 0.03132362f, 0.17291111f, 
    0.03833096f, 0.05736629f, 0.11697093f, -0.01988610f, 0.05402382f, -0.00453414f, 0.00047216f, 0.17451213f, 
    -0.00577601f, -0.19709027f, 0.06360901f, -0.07788744f, -0.04666883f, -0.02926909f, 0.32541251f, 0.16801445f, 
    0.20824745f, 0.10542462f, 0.31736794f, 0.17330407f, 0.02916520f, 0.05527182f, 0.16556454f, 0.05768832f, 
    0.13388591f, -0.03814725f, -0.17549284f, -0.13583958f, -0.07747988f, 0.05320433f, 0.24897654f, -0.28159374f, 
    0.09659041f, 0.19533563f, -0.07127509f, -0.06409510f, 0.03561337f, -0.16095163f, 0.01780430f, -0.38961467f, 
    0.24013384f, -0.04247546f, -0.58226550f, -0.28074446f, 0.06800890f, -0.04876420f, 0.05961844f, 0.08008767f, 
    -0.07020060f, -0.01618172f, 0.07654952f, -0.27750888f, 0.06801221f, 0.30616370f, 0.37385181f, 0.29736030f, 
    0.02193716f, 0.01754566f, 0.39748356f, -0.28395921f, -0.16419296f, 0.06005497f, 0.09094232f, 0.12660643f, 
    0.11554085f, -0.13829701f, -0.10021448f, -0.41253754f, -0.01002852f, 0.10089070f, -0.13435359f, 0.17967604f, 
    0.24397609f, 0.18225455f, 0.21820830f, 0.10289264f, 0.15559946f, 0.09480733f, 0.19245672f, 0.17384218f, 
    0.01013326f, 0.09976025f, -0.11906289f, 0.05735566f, 0.02829777f, 0.01620964f, 0.34232986f, 0.15897174f, 
    0.15060285f, 0.02501643f, 0.27240637f, -0.25189495f, 0.17533976f, 0.01125329f, 0.07132635f, -0.00031920f, 
    -0.24817170f, 0.04605391f, -0.02532631f, 0.22635660f, 0.28065404f, 0.08348035f, -0.08163083f, -0.42473114f, 
    0.30542180f, 0.01557098f, 0.03527166f, -0.01504425f, -0.00185335f, -0.27909011f, -0.06670488f, -0.10704292f, 
    0.01972971f, 0.05777033f, 0.05248532f, -0.08221308f, -0.06299591f, -0.09303082f, 0.04665458f, -0.04110700f, 
    0.06295550f, 0.08364542f, 0.02009737f, -0.08964434f, -0.09983414f, 0.06611302f, 0.02392765f, -0.03757059f, 
    0.03505191f, -0.02164209f, -0.01857160f, 0.02530649f, -0.07947206f, -0.09113201f, -0.02278638f, -0.09717441f, 
    -0.11550727f, -0.04786215f, -0.09122171f, 0.05535698f, -0.01739619f, 0.07777122f, -0.08188836f, 0.00176701f, 
    -0.05487926f, 0.01279383f, -0.07227848f, -0.06004843f, 0.05896428f, -0.09061205f, -0.08397489f, -0.03982963f, 
    0.02045118f, -0.05436005f, -0.06573510f, -0.00123364f, -0.08678931f, -0.00270531f, -0.03945073f, -0.07117210f, 
    -0.05347592f, -0.02594510f, -0.05435973f, 0.01416166f, 0.05759791f, -0.07183001f, 0.01129918f, 0.05825258f, 
    0.06810466f, -0.05115276f, 0.05287948f, 0.06818591f, -0.04907649f, 0.03724624f, 0.02439963f, -0.02616198f, 
    -0.06760382f, 0.05833105f, -0.05852597f, 0.05753202f, -0.08012052f, -0.09859700f, 0.00815127f, -0.09428276f, 
    0.03272176f, 0.04002126f, -0.08361589f, 0.06364541f, 0.06818502f, 0.03063982f, -0.02969941f, -0.04969935f, 
    0.04794478f, 0.03710629f, 0.03549397f, -0.07167891f, 0.06085583f, -0.11720910f, -0.07695513f, -0.04869565f, 
    0.02196213f, 0.01045889f, 0.03062640f, -0.03035228f, -0.06459425f, -0.06218437f, 0.04521772f, 0.02156123f, 
    -0.01108958f, -0.01986612f, -0.07611246f, 0.08401777f, -0.03783904f, 0.02536963f, -0.00821776f, -0.03780349f, 
    0.04283464f, -0.04309926f, -0.01274867f, -0.05010513f, 0.05566976f, -0.03771442f, -0.08322604f, -0.04979974f, 
    0.01241404f, -0.09954089f, -0.10539432f, 0.02670871f, -0.01584761f, -0.01889372f, -0.07879954f, -0.09791747f, 
    -0.04125830f, -0.10015151f, 0.02298851f, -0.04524443f, 0.04853144f, -0.02846874f, -0.10070541f, 0.01114786f, 
    0.01690257f, 0.01192052f, -0.18115459f, 0.27411389f, -0.08164456f, 0.06065447f, -0.05279037f, -0.07887567f, 
    -0.12590566f, 0.10703310f, -0.18837324f, -0.05587098f, 0.13786322f, 0.04456177f, 0.28196475f, 0.23586099f, 
    -0.05364136f, -0.02612352f, 0.00709453f, -0.04227461f, 0.08935505f, 0.11186842f, 0.07686787f, 0.13160838f, 
    -0.07649012f, -0.23012894f, -0.26428568f, 0.22300451f, -0.07087142f, -0.09900251f, 0.16001986f, 0.21572833f, 
    0.02909036f, 0.15920918f, 0.31648904f, 0.20027769f, 0.39808199f, -0.09677010f, 0.30065036f, 0.43137234f, 
    0.36008802f, -0.06232952f, 0.02886124f, -0.10650321f, 0.05534440f, 0.04871053f, 0.22721194f, 0.00122037f, 
    0.14899579f, 0.19211997f, 0.40444255f, -0.26642823f, -0.15990147f, 0.13007142f, -0.05706946f, 0.05036374f, 
    -0.13570647f, -0.17072214f, -0.48765084f, -0.15356745f, 0.04586599f, -0.19351400f, 0.08242968f, -0.16811846f, 
    0.10402047f, 0.03248154f, -0.06371826f, 0.09807222f, 0.01464864f, 0.21392699f, -0.13515611f, 0.06556503f, 
    0.06034018f, -0.20278586f, 0.09637456f, -0.07893743f, -0.13789621f, -0.00826215f, -0.01039643f, 0.12893711f, 
    0.29535747f, 0.06250419f, 0.04008696f, -0.31156957f, 0.08443068f, 0.30391446f, -0.43962756f, 0.05472117f, 
    0.00090243f, 0.12955131f, 0.26027134f, -0.07511326f, 0.05689500f, -0.00283705f, 0.26284063f, -0.04254718f, 
    0.07350697f, -0.40836450f, 0.27054468f, 0.03703716f, -0.19667120f, 0.11755661f, -0.02144436f, 0.03862248f, 
    -0.15458849f, -0.02976700f, 0.24988507f, 0.19200633f, 0.65967047f, -0.02476136f, -0.21513095f, 0.11466908f, 
    -0.13317004f, -0.09943245f, -0.04632046f, 0.13384688f, -0.10322686f, 0.09701343f, 0.06462362f, -0.19245687f, 
    0.10290852f, -0.06666861f, 0.04682754f, 0.11743460f, 0.14086099f, 0.34382278f, -0.00236572f, -0.03477776f, 
    0.08380215f, -0.11367317f, -0.09815972f, 0.11019749f, -0.16671135f, 0.07838974f, 0.07318585f, 0.02251799f, 
    0.47439763f, -0.09703536f, 0.01407971f, -0.08728056f, -0.07426101f, -0.06438695f, 0.06065243f, 0.07651117f, 
    -0.03982739f, 0.00237909f, 0.14437307f, 0.07246187f, 0.11572006f, -0.09244894f, 0.08386360f, 0.15774646f, 
    -0.15072082f, 0.07122450f, 0.00086699f, -0.08980256f, 0.00111355f, -0.16386215f, 0.10385498f, 0.15634608f, 
    0.23449852f, 0.20386435f, 0.00717316f, -0.08125350f, -0.05290291f, -0.36886624f, -0.36431578f, 0.42102027f, 
    -0.14924811f, -0.23823395f, -0.14065507f, 0.09871840f, 0.21986741f, -0.03118650f, -0.06711750f, -0.51260597f, 
    -0.17741598f, 0.01301627f, 0.05425012f, -0.01086735f, -0.04731305f, 0.07972431f, 0.32919705f, -0.01502657f, 
    0.40916666f, -0.08044332f, -0.23636378f, -0.41722348f, -0.10855020f, 0.10308075f, -0.06985158f, 0.20857567f, 
    -0.14301161f, -0.15788023f, 0.05613175f, 0.00633551f, -0.02139411f, 0.19702886f, 0.02859023f, 0.19244812f, 
    0.04377279f, -0.17833458f, 0.04332242f, 0.03379834f, 0.07079273f, -0.05828949f, 0.11661855f, 0.11703186f, 
    -0.01049505f, 0.03100582f, 0.30240428f, 0.08944795f, -0.00467804f, 0.40784037f, -0.06802210f, 0.17788418f, 
    0.17671520f, 0.13942510f, -0.22635724f, -0.21246161f, 0.02735325f, 0.02017318f, -0.04162984f, 0.31527704f, 
    0.06213584f, 0.09444002f, 0.32883561f, -0.01371597f, 0.34326839f, -0.06668984f, 0.03135983f, 0.15063165f, 
    0.20215230f, -0.01625019f, 0.06398019f, -0.20674369f, -0.00167868f, 0.03643564f, 0.12289222f, -0.02198472f, 
    -0.08559769f, 0.15015244f, 0.07484004f, 0.36941451f, 0.06075316f, -0.08910763f, -0.06357328f, -0.25140837f, 
    0.11203190f, -0.03997387f, 0.23544036f, -0.16632728f, -0.07205366f, -0.16120511f, -0.10457890f, 0.06313229f, 
    -0.06027801f, 0.08043756f, 0.06016590f, 0.00092581f, 0.12836128f, 0.01587408f, 0.24776922f, -0.00686328f, 
    0.33976665f, -0.18057939f, -0.06411187f, -0.17593271f, -0.10888714f, 0.05414534f, 0.07055055f, -0.14313377f, 
    0.03824971f, 0.13601002f, -0.04350996f, 0.04007665f, 0.08740441f, -0.06067083f, -0.01476841f, 0.02691576f, 
    0.00986562f, 0.22231692f, 0.22829635f, 0.25231385f, -0.13837737f, 0.05102048f, 0.16468455f, 0.04823142f, 
    -0.07237831f, -0.04425292f, -0.07557071f, 0.13970272f, 0.16024393f, -0.34832475f, 0.04361154f, -0.21884327f, 
    -0.05747437f, 0.07053846f, -0.04066590f, 0.20104036f, 0.18538168f, 0.03214595f, -0.31245893f, -0.17520338f, 
    0.08492571f, 0.08364894f, -0.04931910f, -0.08143380f, 0.01783805f, 0.01815157f, 0.17698511f, -0.33974519f, 
    0.26209107f, 0.17114401f, 0.13121086f, 0.34422034f, 0.03936965f, 0.08624788f, -0.02342545f, -0.01684671f, 
    -0.25773501f, 0.31736034f, -0.00083156f, -0.41098085f, -0.09503857f, -0.05486102f, -0.18606500f, 0.02624459f, 
    0.00746373f, -0.06118475f, -0.02648518f, 0.09966225f, 0.11012250f, 0.05765887f, 0.09812431f, -0.06329404f, 
    0.14127716f, 0.07672844f, -0.08231404f, -0.14475030f, 0.04225923f, -0.38103011f, -0.05674101f, 0.04830729f, 
    0.08452304f, 0.19621463f, 0.25537005f, 0.00739418f, 0.11697681f, -0.18566419f, 0.00571400f, 0.05507586f, 
    -0.10300580f, -0.19471370f, 0.33825496f, 0.08529744f, 0.05417559f, 0.25541034f, -0.30092397f, 0.00121044f, 
    0.18723051f, -0.01593894f, -0.03355559f, -0.00518441f, -0.19453794f, 0.14312509f, 0.18084419f, -0.02354993f, 
    0.17517026f, 0.17936608f, 0.08534145f, -0.32520354f, 0.18439639f, -0.11364026f, 0.00684836f, -0.05787676f, 
    0.05215549f, 0.28807691f, 0.13689402f, 0.15118681f, 0.08643366f, -0.18951684f, -0.05919605f, 0.12475692f, 
    -0.01639437f, 0.07784372f, -0.05494915f, -0.01335016f, -0.08278374f, -0.03195632f, -0.03157744f, 0.07427607f, 
    -0.07687864f, -0.05310016f, -0.04300725f, -0.07017826f, -0.00700134f, 0.06461050f, -0.00267432f, -0.05766717f, 
    -0.08586374f, -0.07917849f, -0.02946878f, -0.08497039f, -0.01516589f, -0.00506462f, -0.07506852f, 0.03684749f, 
    -0.01710623f, -0.06890567f, 0.00462142f, -0.00147959f, 0.01129026f, 0.02225109f, -0.00940082f, -0.01584219f, 
    0.02319790f, -0.01109857f, -0.02364251f, 0.03410949f, -0.04634208f, -0.08757296f, 0.06369953f, 0.04385958f, 
    0.05213821f, -0.07407918f, -0.06552701f, 0.02657254f, 0.08570465f, -0.03332372f, -0.00594326f, -0.07154044f, 
    -0.09221895f, -0.07669202f, 0.03515745f, 0.03998418f, -0.02003009f, -0.05929555f, 0.00566676f, -0.03738774f, 
    0.02955009f, -0.08890190f, 0.01441510f, 0.08390668f, 0.05348575f, -0.01417496f, -0.05330674f, -0.05327646f, 
    -0.04296722f, -0.05689780f, 0.04324978f, -0.08121132f, 0.07384039f, 0.02890428f, 0.02686674f, -0.01033716f, 
    0.01174680f, 0.04117937f, -0.05741787f, -0.07248449f, -0.02944196f, 0.08744168f, -0.01834025f, 0.01644796f, 
    -0.07888926f, -0.06865208f, -0.04807856f, -0.04197371f, -0.05098120f, -0.05499410f, 0.00571323f, -0.06515006f, 
    -0.06869372f, -0.07658445f, -0.06983211f, 0.04531926f, -0.01775892f, -0.05190194f, -0.06180911f, 0.04626247f, 
    0.08562366f, -0.04238096f, -0.03217313f, 0.07343055f, 0.03533254f, 0.06709567f, -0.03913013f, 0.02912537f, 
    -0.05599177f, -0.07034859f, 0.04596787f, -0.03228544f, 0.08255338f, 0.00887137f, -0.05673910f, -0.06697145f, 
    0.03694117f, 0.01399671f, 0.08632291f, -0.03588378f, -0.01014788f, -0.08037109f, -0.06589675f, 0.01518241f, 
    -0.00988698f, -0.07673370f, 0.02152185f, -0.02668384f, -0.09202822f, -0.05287094f, -0.00314746f, -0.00693653f, 
    -0.00378502f, 0.09618670f, 0.03547471f, 0.02243320f, -0.28695744f, -0.11142348f, 0.31819886f, -0.08541531f, 
    -0.10389905f, 0.17685780f, -0.27301839f, -0.02641561f, 0.06912653f, -0.06006711f, 0.15967508f, 0.11730406f, 
    -0.03144604f, 0.23432623f, 0.00689536f, -0.08439790f, 0.17225645f, 0.26968211f, -0.07059228f, 0.15167443f, 
    0.13746877f, 0.16771066f, 0.02176336f, 0.33761331f, 0.24899830f, -0.06834407f, 0.27827519f, 0.00518660f, 
    0.07799049f, 0.08337884f, 0.31612012f, 0.30794591f, 0.17964226f, -0.23641849f, 0.46400687f, 0.13813661f, 
    0.29171002f, 0.11993233f, 0.01721429f, -0.11402849f, -0.00610216f, -0.06595739f, 0.20450862f, -0.50727135f, 
    0.10516401f, 0.34967509f, -0.21755742f, -0.33122349f, -0.10711201f, -0.14639519f, -0.15450758f, -0.19668035f, 
    -0.10521169f, -0.08623114f, -0.24438594f, -0.18101873f, -0.01949193f, -0.26000956f, 0.08595836f, -0.32074314f, 
    -0.31658044f, 0.44492146f, 0.09136572f, -0.29721737f, 0.11523096f, 0.19230789f, 0.48969454f, -0.01806845f, 
    -0.11191616f, 0.06469572f, 0.20721987f, -0.08892284f, -0.21411882f, 0.00268665f, 0.05845404f, 0.22388145f, 
    0.24899726f, -0.11573134f, -0.40038672f, -0.38063532f, 0.00122593f, 0.11244733f, -0.05478670f, -0.30372754f, 
    -0.10562173f, 0.08412579f, 0.55802155f, 0.29592499f, 0.12365141f, -0.07513370f, 0.16314141f, 0.00015314f, 
    -0.03378525f, 0.06561805f, 0.46120587f, 0.07705849f, -0.28313065f, 0.05939667f, 0.10373963f, 0.20478058f, 
    -0.26205242f, -0.00761830f, 0.50333154f, 0.48076770f, -0.22198071f, 0.06709218f, 0.01070472f, 0.15963472f, 
    -0.00501826f, 0.02541187f, -0.17391773f, -0.20043300f, 0.09397442f, 0.22506040f, 0.17464831f, -0.02822386f, 
    0.14842902f, -0.13802828f, -0.01397618f, -0.06435457f, -0.13052753f, -0.66892058f, 0.13914625f, -0.12364072f, 
    0.03503060f, 0.05638194f, -0.03133600f, -0.02902092f, 0.06087980f, -0.06274305f, -0.07667976f, 0.02830141f, 
    -0.02095224f, -0.08754992f, 0.02606398f, -0.02073361f, 0.03170536f, 0.00229402f, -0.03012154f, 0.04067592f, 
    -0.04112905f, -0.03644949f, 0.07596856f, -0.06747349f, -0.06333574f, -0.09631381f, 0.06315481f, -0.05300577f, 
    0.05683516f, -0.10448458f, 0.03684822f, 0.03861426f, -0.04200952f, -0.04549899f, 0.04499074f, -0.07449014f, 
    -0.09263632f, 0.01549344f, -0.02822854f, -0.00963324f, -0.00001539f, -0.01929307f, -0.01489049f, -0.02849213f, 
    -0.04799130f, -0.02035168f, 0.04747228f, -0.00170544f, -0.06451485f, 0.00911520f, 0.03640280f, -0.03683080f, 
    0.06803028f, 0.05240117f, 0.03362966f, 0.02860296f, -0.01508764f, -0.08906493f, -0.04594639f, -0.04279524f, 
    -0.06380642f, 0.06284880f, -0.01587774f, 0.07432088f, 0.02461263f, -0.10224417f, -0.06821966f, -0.08770442f, 
    -0.07970389f, 0.00716015f, -0.01197406f, 0.05563531f, -0.04521762f, 0.05932100f, -0.08789554f, -0.06957308f, 
    -0.07148480f, -0.02082906f, -0.04711557f, -0.09017446f, -0.04879088f, 0.01016233f, 0.03645080f, 0.01696603f, 
    -0.09879697f, 0.02313587f, -0.08121348f, 0.03558109f, -0.01098991f, -0.03927885f, -0.02688436f, 0.01502617f, 
    -0.00560859f, 0.00273926f, -0.05569948f, -0.03884323f, 0.05966626f, -0.09089163f, 0.01128204f, 0.04848294f, 
    -0.06137297f, 0.05398278f, -0.09365386f, 0.00877497f, -0.01433795f, 0.02587982f, -0.02179747f, -0.11294065f, 
    -0.06603761f, 0.05717729f, -0.00680358f, -0.05055960f, 0.04711884f, -0.05985479f, -0.05915310f, 0.02323914f, 
    0.06206667f, -0.07688218f, -0.04062570f, -0.00451782f, 0.04220073f, 0.05026039f, 0.00059370f, 0.05612941f, 
    0.01393726f, 0.06384356f, 0.04185508f, -0.08841931f, -0.07851558f, 0.03548639f, -0.04687977f, -0.01382042f, 
    -0.03176365f, -0.06920500f, 0.07034205f, 0.00224610f, 0.06571889f, 0.04199095f, 0.03139894f, -0.01862454f, 
    -0.00394532f, -0.09013459f, 0.02443027f, -0.02920523f, -0.10411889f, 0.04826423f, -0.07870983f, 0.04479976f, 
    0.08039098f, -0.00868552f, -0.03821490f, 0.00421288f, -0.06734284f, 0.02789363f, 0.03559749f, -0.07341769f, 
    0.04975547f, -0.07683414f, -0.08356459f, 0.01076690f, -0.05477794f, 0.03892334f, 0.03546466f, 0.07676297f, 
    0.06005346f, 0.01551730f, -0.08020236f, -0.01078517f, -0.07622354f, -0.08872832f, -0.11604898f, -0.01196446f, 
    -0.09535843f, -0.09454880f, -0.07787254f, 0.03980415f, 0.01107897f, -0.04822455f, -0.03586575f, -0.08862849f, 
    -0.02819275f, -0.05251623f, -0.02685047f, 0.07528944f, -0.09353195f, -0.06494880f, -0.01848650f, -0.02948523f, 
    0.00515891f, 0.04523929f, -0.04108261f, 0.02061231f, -0.01052143f, -0.02505296f, 0.06424211f, 0.04320862f, 
    -0.03593739f, -0.01927850f, 0.00682294f, -0.02637171f, 0.02333291f, -0.07471536f, 0.07138015f, -0.04359667f, 
    -0.03050559f, -0.00372662f, -0.04763287f, -0.01028246f, -0.02966472f, -0.03694912f, 0.05598644f, -0.00916378f, 
    -0.01850109f, -0.02501250f, 0.03572921f, -0.06096936f, 0.05519804f, -0.01975534f, 0.01286419f, -0.07416728f, 
    -0.02682376f, -0.06698619f, 0.06299482f, 0.06079729f, 0.04921311f, -0.05675106f, -0.06109883f, -0.08882763f, 
    -0.08896647f, -0.01515527f, 0.02391069f, -0.03287989f, -0.02617273f, 0.05955637f, -0.05571782f, -0.01674297f, 
    0.01229344f, 0.00687127f, 0.02001709f, -0.01752949f, 0.05133341f, 0.04688512f, -0.07217052f, -0.05718626f, 
    0.02380300f, 0.06177659f, -0.04023878f, -0.09167445f, -0.02409668f, 0.02880772f, -0.00525003f, -0.08272231f, 
    0.04270636f, 0.03368643f, -0.02932074f, -0.03744932f, -0.00452861f, -0.06640808f, 0.01320198f, -0.07721966f, 
    0.06571915f, -0.12679444f, 0.02973827f, -0.03184924f, -0.11049131f, 0.21110648f, 0.19318049f, 0.03775675f, 
    -0.35805711f, -0.05901398f, 0.05137072f, -0.03938011f, 0.19612610f, -0.06868256f, 0.11085244f, 0.09990364f, 
    0.00460189f, -0.02435760f, 0.36771312f, -0.03114269f, 0.07694300f, 0.08394993f, -0.04275270f, 0.12612510f, 
    -0.12510815f, -0.20538436f, -0.19981299f, 0.16679673f, -0.03028750f, 0.14566331f, 0.18241580f, 0.12617488f, 
    0.12618671f, 0.19508986f, 0.27860081f, 0.08040215f, 0.25873470f, -0.07386733f, 0.34622732f, 0.07812175f, 
    0.19765611f, -0.05469963f, 0.30002585f, -0.08311678f, -0.06217464f, -0.01721557f, 0.29509693f, -0.47293246f, 
    -0.14926112f, -0.03336173f, 0.27730834f, -0.02741040f, 0.04365078f, 0.00627952f, -0.19005699f, -0.03530997f, 
    0.28637114f, -0.04412625f, -0.13383244f, -0.15215017f, 0.03897653f, -0.16698785f, 0.01199463f, -0.14515230f, 
    0.12456892f, -0.18711853f, 0.05210984f, 0.01079793f, 0.05084456f, 0.11037561f, 0.00220131f, 0.12581079f, 
    0.00362320f, -0.20377888f, 0.13809510f, -0.04990867f, -0.01778338f, 0.00615215f, -0.05677464f, 0.18088771f, 
    0.21766934f, -0.07537179f, -0.08022664f, -0.41060573f, 0.06299455f, 0.10518308f, -0.18719459f, -0.00917809f, 
    0.04655288f, 0.09579410f, -0.02522030f, 0.08155365f, 0.08954021f, -0.01855357f, 0.27188462f, 0.18385884f, 
    0.20179693f, -0.24174124f, 0.05416572f, 0.02544701f, -0.11237866f, -0.03057007f, -0.04875270f, 0.20971666f, 
    -0.11256349f, -0.04638684f, 0.32387447f, 0.31138381f, -0.03242775f, 0.11765717f, -0.18208185f, 0.12604204f, 
    -0.07182755f, -0.05225897f, -0.05564452f, 0.12331553f, -0.01328983f, 0.18503809f, 0.11275037f, -0.15242772f, 
    0.12079909f, -0.34559438f, 0.15202300f, -0.14188163f, 0.08853623f, 0.30640328f, -0.08927672f, -0.01319641f, 
    0.02151965f, -0.03950002f, -0.06638830f, -0.05148604f, -0.01362745f, 0.04890544f, 0.03619597f, 0.01258042f, 
    0.06669356f, -0.03181756f, 0.01731652f, -0.05358101f, -0.05736536f, 0.07663752f, 0.05007650f, -0.05015205f, 
    -0.04131898f, -0.06741626f, -0.02678212f, 0.06543896f, 0.02141244f, -0.07658897f, -0.00620854f, -0.01439205f, 
    -0.04410610f, -0.08118304f, -0.02480978f, 0.00758045f, 0.04663549f, -0.10680835f, -0.04783318f, -0.05478681f, 
    -0.01515577f, 0.05925003f, -0.05686846f, -0.10387853f, -0.00366106f, -0.02931285f, 0.00632068f, -0.04672080f, 
    -0.00596545f, 0.04458578f, -0.01906131f, -0.03809457f, 0.00745956f, 0.05768630f, 0.04137486f, -0.00203259f, 
    0.02588985f, 0.00301547f, 0.04645127f, 0.02034318f, -0.09166571f, 0.05005622f, -0.01404732f, -0.01732139f, 
    -0.04334918f, 0.05551609f, -0.03183720f, -0.02457325f, -0.01289581f, -0.10870902f, -0.06531200f, 0.03657206f, 
    -0.06980894f, -0.10210720f, 0.00539248f, -0.03074531f, 0.00311981f, -0.09912800f, 0.00366901f, 0.03538453f, 
    0.00084697f, 0.00248608f, -0.04459374f, -0.05376876f, 0.02079592f, 0.00989734f, 0.02992189f, 0.02384924f, 
    -0.00042279f, -0.09394272f, -0.07332279f, -0.04391643f, -0.05015385f, 0.04792388f, -0.02292031f, 0.04481025f, 
    -0.05276855f, -0.07700396f, -0.10601079f, -0.08006773f, 0.00020943f, 0.02515704f, -0.00282836f, 0.02483743f, 
    0.00569547f, -0.07576772f, 0.04688951f, 0.00170466f, -0.07979951f, 0.02301172f, -0.01463471f, -0.09348277f, 
    0.04040555f, 0.00176101f, -0.09936751f, -0.03115832f, -0.03837550f, 0.06077997f, -0.10106660f, -0.06139388f, 
    0.01179727f, -0.01481921f, -0.02954277f, 0.05584678f, 0.02145264f, 0.01712373f, -0.01571488f, -0.03890050f, 
    -0.10846310f, -0.00950679f, -0.05467024f, -0.10349299f, -0.03223554f, -0.08694694f, 0.02309937f, -0.09550027f, 
    0.01651438f, -0.11089678f, -0.25071675f, 0.21652906f, 0.15002120f, -0.00808174f, 0.36948815f, 0.05879054f, 
    -0.56330985f, 0.06246781f, 0.11921757f, 0.62570786f, 0.33000582f, 0.07482218f, -0.05018030f, 0.08169466f, 
    0.02200014f, -0.23869123f, 0.24953456f, -0.03957854f, 0.01425068f, 0.18589787f, 0.01046005f, -0.23603739f, 
    -0.05367930f, 0.31919360f, -0.31453857f, -0.25266299f, 0.28397396f, 0.11220036f, 0.07540947f, 0.05517786f, 
    0.14081596f, -0.32353920f, 0.12288962f, -0.21983212f, -0.10308769f, 0.31034249f, -0.08542711f, 0.02187881f, 
    0.03358069f, -0.27189547f, -0.11055423f, 0.12675367f, 0.02257184f, -0.00632751f, 0.58114755f, -0.18321387f, 
    -0.14267424f, -0.20349832f, -0.03734986f, 0.42656153f, -0.28242680f, 0.13416921f, -0.33266643f, -0.04450281f, 
    -0.55475557f, -0.05012275f, 0.08352282f, 0.06054443f, -0.09134917f, 0.15013890f, -0.10540401f, 0.22520949f, 
    0.25366697f, -0.31765053f, 0.06240718f, 0.42473185f, -0.10448637f, 0.00639122f, 0.24716787f, 0.23652297f, 
    -0.09754021f, -0.06261638f, -0.31282085f, -0.03905042f, 0.14737876f, -0.09099650f, 0.12270303f, 0.05983834f, 
    0.03453669f, -0.10530336f, 0.19730586f, 0.45756283f, 0.08654615f, 0.06121332f, 0.12969336f, -0.22285120f, 
    -0.05257620f, -0.02162691f, 0.20722026f, -0.04856301f, -0.35758388f, 0.23037532f, -0.28761524f, 0.02638769f, 
    0.00842415f, -0.20391685f, 0.01994009f, 0.07975244f, 0.06085252f, 0.18467182f, 0.11128303f, -0.17851436f, 
    -0.00867853f, 0.06325815f, -0.02145329f, -0.04424117f, -0.04877192f, -0.21612045f, 0.13431625f, -0.08432401f, 
    -0.06895217f, 0.00293200f, 0.03192341f, 0.37851667f, -0.00618418f, 0.00797718f, -0.04041628f, 0.25500181f, 
    -0.07161676f, -0.19799125f, -0.14401025f, -0.10454006f, -0.06494960f, -0.25005761f, 0.15772367f, -0.09026644f, 
    -0.06680963f, 0.01586843f, 0.10000028f, -0.14797083f, 0.24617432f, -0.04294742f, 0.26599649f, -0.08800909f, 
    -0.62657982f, 0.04960451f, 0.06879871f, 0.23296356f, 0.13091984f, 0.08380388f, -0.12299338f, -0.07125118f, 
    -0.02807218f, -0.11740375f, -0.06465431f, -0.00334281f, -0.00225533f, 0.25569066f, -0.07727403f, -0.15048322f, 
    0.08082484f, 0.43102065f, 0.00785453f, -0.05464157f, 0.31267262f, 0.30546552f, -0.21851659f, -0.11100799f, 
    0.06858552f, -0.07346908f, -0.12127674f, 0.04456451f, -0.12683798f, 0.31828696f, -0.13372374f, -0.78453541f, 
    -0.11509903f, 0.14386635f, -0.00364031f, 0.12457318f, -0.15952876f, 0.00337383f, 0.33666974f, 0.18423890f, 
    0.08298349f, 0.00224674f, -0.29507804f, 0.29023105f, -0.06073537f, 0.12263042f, -0.18745491f, 0.23243955f, 
    -0.54136741f, 0.14805882f, 0.46223438f, 0.03151347f, -0.09735312f, 0.27949736f, -0.00637041f, 0.07734083f, 
    0.06803171f, -0.28863144f, 0.13515346f, 0.14410955f, 0.15926895f, 0.00709480f, 0.19364294f, -0.01283994f, 
    -0.07816149f, 0.17968912f, -0.06984149f, 0.12092938f, 0.10844126f, -0.05705885f, 0.10431691f, 0.01404618f, 
    -0.00458836f, -0.06984086f, -0.03717649f, 0.41242754f, -0.06245306f, -0.06962215f, 0.43903863f, -0.11331790f, 
    -0.07972533f, -0.17045233f, 0.09252379f, 0.18067618f, -0.09479687f, 0.22055726f, -0.21423657f, 0.08543341f, 
    0.15151580f, 0.21144575f, -0.33126989f, -0.05668706f, 0.14312498f, -0.03027213f, 0.26074859f, 0.02676588f, 
    0.13310644f, -0.08657227f, -0.09990965f, 0.15426198f, 0.00745723f, -0.09779416f, 0.22571124f, -0.03765652f, 
    -0.00865947f, 0.15569668f, -0.11827170f, 0.28396612f, 0.06934925f, 0.18309385f, 0.03574781f, 0.49518019f, 
    -0.05186601f, -0.00101917f, 0.04885821f, -0.15248899f, -0.07037777f, -0.37509501f, 0.16346525f, 0.13610730f, 
    -0.06157939f, -0.19796827f, -0.13819180f, 0.13240999f, -0.83804286f, -0.06737703f, 0.08828121f, -0.03391380f, 
    0.18379815f, -0.05678013f, -0.57324004f, -0.26776049f, 0.40446198f, -0.08148737f, 0.12741123f, 0.30383641f, 
    -0.08354945f, -0.04294702f, -0.25519535f, -0.07398898f, 0.25340128f, 0.43350810f, 0.05724256f, 0.11145163f, 
    0.27175012f, 0.17969249f, -0.00668775f, 0.34488449f, 0.46264529f, 0.26355574f, 0.20828718f, 0.20782402f, 
    0.13939816f, 0.04855887f, 0.15005863f, 0.03615962f, -0.17189226f, -0.07051750f, 0.09952492f, -0.17537962f, 
    0.33022261f, 0.13111220f, 0.16927458f, 0.04926712f, -0.29154941f, -0.03636177f, 0.20514847f, -0.17810178f, 
    -0.07282465f, 0.20945705f, 0.11839061f, 0.00156745f, -0.36015800f, 0.01413831f, -0.46151200f, -0.39938253f, 
    -0.19231345f, 0.05836828f, 0.18355143f, -0.72514445f, 0.03060657f, -0.19932818f, 0.04762490f, 0.18213601f, 
    -0.43549970f, -0.08146696f, 0.19974443f, 0.05037641f, 0.33694166f, 0.19999996f, 0.18045498f, 0.09935785f, 
    0.01941990f, 0.22193000f, -0.07006978f, -0.30401501f, -0.03764553f, 0.07140767f, 0.29029238f, 0.23404604f, 
    0.07343622f, -0.06125579f, -0.05686869f, -0.13174696f, 0.04652269f, 0.08344252f, 0.08058801f, -0.33833075f, 
    -0.15458207f, 0.07581409f, 0.64533854f, -0.03859087f, -0.29150626f, -0.16767323f, 0.47989902f, 0.13554385f, 
    -0.31233281f, 0.13247317f, 0.36046013f, -0.01708214f, 0.03879721f, 0.05284019f, 0.15896146f, -0.02893873f, 
    -0.71875340f, -0.03018793f, 0.33335093f, 0.46074137f, -0.06116341f, 0.05085021f, 0.20078285f, 0.05728323f, 
    0.24102297f, 0.18595341f, -0.84445804f, 0.14901021f, 0.11820915f, 0.17767411f, 0.14329180f, -0.01049600f, 
    0.01210286f, -0.84644717f, -0.22711594f, 0.04046584f, -0.46823555f, -0.16616127f, 0.22630039f, 0.25632465f, 
    -0.00403589f, -0.04526920f, -0.07274092f, -0.07122918f, -0.02427097f, -0.04163828f, -0.08602741f, -0.06884781f, 
    0.05414556f, -0.04566009f, -0.11298031f, -0.02149964f, 0.04002563f, 0.00432900f, 0.00323373f, -0.12189797f, 
    0.00333525f, 0.00562394f, -0.07539401f, 0.05204583f, 0.00643378f, -0.00009019f, 0.02799425f, -0.05894972f, 
    -0.00546330f, 0.01988787f, 0.06255238f, 0.02387537f, 0.03007159f, 0.00856138f, 0.02850837f, 0.01439709f, 
    -0.08898085f, 0.02032981f, -0.03306435f, -0.04646919f, 0.00786168f, 0.05945221f, -0.06382849f, -0.03596335f, 
    -0.07239967f, -0.11077581f, 0.02687913f, -0.06801638f, 0.07373226f, -0.03940645f, -0.03233103f, 0.07890606f, 
    0.03898777f, -0.03870832f, 0.00129914f, 0.03845777f, 0.01971477f, -0.02374717f, 0.03325137f, 0.07378189f, 
    -0.00602824f, -0.08195307f, -0.02652599f, -0.08438399f, -0.01738656f, -0.07301591f, -0.05566853f, -0.04070968f, 
    -0.06756645f, -0.01445100f, -0.04606786f, -0.03050313f, -0.01514928f, 0.02989531f, 0.03318531f, 0.00885256f, 
    0.07590438f, -0.06489344f, 0.02420753f, -0.05772729f, -0.05454670f, 0.03650622f, -0.06978340f, -0.03853352f, 
    -0.00990850f, -0.00833944f, 0.07198764f, -0.06502590f, 0.08470085f, 0.03655086f, -0.06097645f, 0.05767860f, 
    -0.02171182f, -0.06127313f, -0.01015977f, 0.00497374f, 0.07056142f, 0.00843012f, -0.05927044f, -0.04404863f, 
    -0.00776524f, 0.00318751f, 0.07269700f, -0.05505352f, -0.04851564f, -0.00102962f, 0.02076636f, -0.06402686f, 
    -0.07303187f, -0.06864438f, 0.03729827f, -0.02888299f, -0.05202049f, -0.04211948f, 0.02974603f, -0.00420639f, 
    0.03277341f, -0.04369169f, -0.06962299f, -0.06951343f, -0.03767714f, 0.04784107f, -0.04941440f, -0.02181334f, 
    -0.07093823f, 0.05965251f, 0.04768815f, 0.03862609f, -0.08914120f, 0.07635553f, 0.05305425f, 0.02299606f, 
    0.05166113f, -0.05128538f, 0.06166492f, -0.06963962f, 0.03999411f, 0.03083413f, -0.04043817f, -0.02611459f, 
    0.00337564f, -0.07583287f, -0.08468817f, 0.07724866f, -0.04245823f, -0.04931926f, -0.06433778f, 0.06281664f, 
    -0.05040203f, -0.02789925f, 0.10202923f, 0.06656776f, -0.10117380f, -0.07706188f, -0.00684345f, -0.01949582f, 
    -0.05356608f, 0.01588482f, -0.01335945f, 0.02129000f, 0.04400974f, -0.07627007f, 0.03973556f, -0.09813827f, 
    0.05064345f, -0.04333163f, 0.03876873f, -0.00604369f, -0.03728685f, 0.01228923f, 0.01975185f, 0.01634736f, 
    -0.02187936f, 0.06052038f, 0.03263865f, -0.05802269f, -0.05749915f, -0.08134880f, -0.10392401f, -0.05544213f, 
    -0.02369781f, -0.06490549f, -0.05320169f, 0.06986206f, -0.10712605f, -0.08272076f, -0.08169846f, 0.03174724f, 
    -0.08552942f, -0.05814091f, -0.00949915f, 0.00207837f, -0.02188867f, -0.10820464f, -0.07712168f, -0.11528171f, 
    0.09148789f, 0.00836549f, -0.06681693f, -0.00021032f, 0.01754832f, 0.03599724f, -0.05745998f, 0.00163557f, 
    0.08204301f, -0.06368938f, 0.03933053f, -0.01003655f, 0.01658174f, 0.02916274f, -0.04296715f, -0.00814211f, 
    -0.03755111f, 0.00690377f, -0.00342330f, -0.02590548f, -0.06129985f, -0.12297328f, 0.02226936f, -0.03732689f, 
    -0.03925202f, -0.08784910f, -0.07308878f, -0.05080231f, -0.04971843f, -0.09984756f, 0.05920506f, -0.05128356f, 
    0.05269650f, 0.03093454f, -0.02735800f, -0.02195350f, -0.08777872f, 0.03095333f, -0.00653539f, -0.04644339f, 
    -0.08881509f, -0.04894143f, 0.05876792f, 0.00545557f, -0.00442767f, 0.08312482f, 0.08474652f, 0.01375923f, 
    -0.02803526f, 0.01365044f, -0.04800766f, 0.04341293f, -0.00159367f, 0.08227160f, 0.03190486f, -0.05228362f, 
    -0.04869138f, -0.11020925f, 0.00581784f, -0.08932360f, -0.07671081f, -0.00034650f, -0.00365706f, 0.00873211f, 
    -0.03675165f, -0.22884691f, -0.06245214f, -0.12557438f, 0.05167652f, 0.12729190f, 0.25177333f, -0.07497730f, 
    0.51930475f, -0.30648473f, 0.19545870f, -0.32717392f, -0.20476235f, 0.02724447f, 0.02254270f, 0.09455132f, 
    -0.08433969f, -0.06118010f, 0.14583038f, 0.03093664f, 0.01492127f, -0.10684650f, -0.06042647f, 0.15009771f, 
    -0.06301592f, -0.18960814f, 0.07788666f, 0.22056580f, -0.31066710f, 0.11141829f, 0.13318463f, 0.07207310f, 
    0.13369751f, 0.03168544f, 0.26290670f, 0.12087124f, 0.38962924f, -0.24045257f, 0.23304026f, 0.12103193f, 
    0.28846601f, -0.03588956f, 0.43136176f, -0.14159070f, 0.00337625f, 0.05610613f, -0.35151082f, 0.07642664f, 
    0.04836158f, 0.12106451f, -0.02779191f, -0.25560933f, 0.20326945f, -0.07356311f, 0.12108347f, 0.22742866f, 
    0.70736492f, -0.09783783f, -0.11762564f, 0.40414509f, -0.00936834f, -0.05835704f, 0.04026518f, -0.04463146f, 
    -0.00824820f, 0.11520764f, 0.01931113f, -0.45658478f, 0.13868989f, 0.09184655f, -0.01843643f, 0.16637710f, 
    0.07053715f, 0.04568929f, 0.15602016f, 0.10234218f, -0.19743392f, 0.13803151f, -0.13599913f, 0.17772973f, 
    0.02999201f, -0.05488170f, -0.30079481f, -0.51938969f, -0.00553408f, 0.06057098f, -0.17115879f, 0.24749860f, 
    -0.10984836f, 0.14347358f, -0.14964734f, 0.12385574f, -0.01077505f, -0.15835951f, 0.31190571f, -0.05843600f, 
    -0.35143751f, -0.00158262f, 0.35822380f, 0.05808672f, 0.09358437f, 0.02830540f, -0.19135171f, -0.03189117f, 
    0.15787536f, -0.08110223f, 0.07137454f, 0.50731778f, 0.25438970f, 0.28341404f, -0.13615347f, -0.02391422f, 
    -0.08099559f, -0.06790330f, 0.24901626f, -0.08513886f, -0.01634889f, 0.01892628f, 0.03011381f, 0.03538280f, 
    0.15581888f, -0.06152677f, 0.01240934f, 0.11245164f, 0.14130519f, 0.57418680f, -0.24996275f, -0.13560331f, 
    -0.01368174f, 0.04465074f, -0.04822395f, -0.04008844f, 0.08021420f, -0.17576545f, 0.59977299f, -0.01839716f, 
    -0.40096399f, 0.38722804f, -0.06536815f, 0.17375095f, -0.09427874f, -0.01717963f, 0.11437937f, 0.02051386f, 
    -0.05656008f, -0.12728490f, -0.08498055f, -0.06054749f, 0.05545667f, 0.10181066f, 0.04253668f, 0.11167198f, 
    0.02726703f, -0.20131969f, -0.20937601f, 0.06511874f, 0.12249620f, -0.08231566f, 0.21625760f, -0.03436882f, 
    -0.17201088f, -0.17070143f, 0.07552046f, -0.20093758f, 0.18722509f, 0.14289327f, 0.09272137f, -0.03552666f, 
    -0.05171204f, -0.03999576f, 0.07035387f, -0.14328775f, -0.09694671f, -0.07136769f, 0.00865429f, 0.12778468f, 
    0.00261766f, -0.12515315f, -0.11625335f, 0.12978089f, 0.02599974f, -0.16483280f, -0.13554262f, -0.04293695f, 
    0.04341098f, -0.10575370f, -0.29791126f, 0.18073010f, 0.02649242f, -0.04002975f, 0.00626335f, -0.09207439f, 
    -0.04398170f, 0.16208458f, 0.01994667f, 0.26236019f, 0.07157155f, -0.09987337f, 0.01329589f, 0.10905491f, 
    0.08132265f, 0.12660195f, 0.00192416f, -0.16283546f, -0.16288245f, 0.08365130f, -0.09300087f, -0.17298922f, 
    0.01219800f, 0.01257664f, -0.03963518f, 0.20272601f, 0.04106628f, -0.17323124f, -0.20176007f, -0.31762195f, 
    0.10737176f, 0.00714970f, 0.16669290f, 0.00790217f, -0.06888644f, 0.11854663f, -0.08722209f, -0.07043997f, 
    0.11261810f, -0.03968285f, 0.41978365f, -0.01616668f, -0.01316782f, -0.04130403f, -0.02686546f, -0.23439023f, 
    -0.06975686f, -0.07470106f, 0.20737600f, 0.19283836f, 0.24489644f, 0.07210606f, 0.03456534f, 0.07091569f, 
    -0.31541544f, -0.09838267f, -0.16549775f, -0.15595871f, 0.04457195f, 0.04359013f, 0.06169514f, -0.17703456f, 
    0.11928155f, -0.00239744f, -0.13493437f, -0.06844427f, 0.06056301f, -0.16087171f, 0.08169506f, -0.16593608f, 
    -0.06267396f, 0.18732761f, -0.06248711f, 0.14082451f, -0.01465208f, 0.10838969f, -0.19596639f, -0.00146341f, 
    0.30341396f, -0.05420527f, -0.17492539f, 0.10178552f, 0.01144194f, -0.08289475f, 0.12531869f, -0.12736779f, 
    0.00689863f, 0.18091248f, 0.14201388f, -0.04137104f, 0.12570629f, -0.03278097f, 0.04393596f, 0.12311825f, 
    -0.23249653f, -0.04857193f, -0.04550590f, 0.25293627f, -0.26301774f, -0.19590004f, 0.30441263f, -0.11875790f, 
    -0.12897407f, -0.20061632f, 0.12460534f, 0.02820988f, 0.05030871f, 0.25022843f, 0.04408225f, -0.00944785f, 
    0.07749492f, -0.13038540f, -0.48672020f, 0.03695567f, 0.12383907f, -0.05782263f, 0.44825500f, 0.19434476f, 
    0.39744827f, 0.04074506f, 0.04702254f, -0.21983854f, -0.20296285f, 0.11900477f, -0.06232678f, -0.60008687f, 
    -0.56901509f, -0.09345318f, -0.12206266f, -0.18556875f, 0.04385083f, -0.10508934f, 0.07843690f, 0.04321584f, 
    -0.12875688f, 0.12901451f, -0.08097681f, 0.12911560f, -0.27332267f, -0.14264829f, -0.06673904f, 0.06550536f, 
    0.04659626f, -0.28758618f, -0.24170220f, -0.17133784f, 0.04143825f, 0.07466800f, 0.12065231f, -0.00100191f, 
    0.16190290f, 0.14608249f, 0.34111089f, 0.12628737f, 0.06404381f, -0.45442846f, -0.14001390f, -0.39445263f, 
    0.05951406f, 0.11656177f, 0.01248207f, 0.05636895f, 0.14223365f, -0.01069070f, -0.31008992f, -0.01413933f, 
    0.28164601f, -0.29628259f, -0.04766971f, 0.02466471f, 0.17682853f, 0.15520477f, 0.16350129f, -0.01609684f, 
    -0.07780899f, 0.04371745f, 0.09189600f, 0.28480923f, -0.22660175f, -0.01758223f, 0.41850588f, 0.11131350f, 
    -0.06068099f, 0.14369795f, 0.09492059f, -0.29420468f, 0.06110474f, 0.02283588f, 0.13123760f, -0.23455405f, 
    -0.16475625f, 0.03954849f, 0.22352932f, -0.04147781f, 0.18502800f, -0.20063937f, -0.09455681f, -0.06998412f, 
    0.00030199f, 0.49680659f, 0.12526527f, 0.25213221f, 0.29607761f, 0.00746065f, 0.08001728f, -0.02790457f, 
    0.11605984f, -0.00677651f, 0.03635377f, -0.12175063f, 0.10118011f, 0.07819753f, 0.10662824f, -0.04251248f, 
    0.08612433f, 0.11068262f, -0.09903067f, 0.05047226f, 0.15400854f, -0.05287899f, -0.04872198f, -0.09659950f, 
    -0.26218784f, 0.36907318f, -0.11600253f, 0.12079182f, -0.23769076f, -0.16385753f, -0.01134992f, 0.08540511f, 
    0.15763645f, 0.00063247f, 0.07735550f, 0.08389958f, 0.20179951f, -0.10454173f, 0.10666911f, -0.35173056f, 
    -0.03518182f, -0.18059652f, -0.09541303f, 0.14178504f, 0.31012386f, 0.03537870f, -0.28296566f, 0.82978886f, 
    0.15816174f, 0.03315511f, -0.12169680f, -0.08797675f, 0.02974769f, 0.11344072f, 0.39823103f, 0.13131753f, 
    0.45748961f, -0.03426475f, -0.01979168f, 0.30512887f, -0.00508336f, 0.22094131f, 0.04294783f, -0.03947977f, 
    0.01513193f, 0.24614918f, -0.21640277f, -0.30011067f, -0.17510615f, 0.02543665f, -0.36368853f, 0.02996554f, 
    -0.00418107f, -0.16032231f, 0.04597414f, 0.21092658f, 0.02277889f, -0.03657646f, 0.17771456f, -0.09556656f, 
    0.23317876f, 0.18859282f, 0.15396512f, -0.19142610f, -0.02408783f, 0.06745030f, -0.21967521f, 0.21315742f, 
    0.00774206f, 0.19239274f, -0.17370993f, 0.11254883f, 0.18806621f, 0.03113788f, -0.12649882f, -0.07762501f, 
    -0.35539865f, -0.35325691f, -0.03708854f, -0.01673579f, 0.11870869f, 0.38719326f, -0.57498157f, 0.12147225f, 
    0.41211972f, -0.07858503f, -0.02392037f, -0.26020318f, 0.10134283f, -0.06897302f, 0.24428460f, 0.06603052f, 
    0.18888618f, 0.06596602f, 0.22421885f, 0.11048014f, -0.01482395f, -0.21216115f, -0.12594394f, 0.06595884f, 
    0.07628585f, 0.20834440f, 0.20956005f, 0.00020570f, 0.12687597f, -0.05680151f, -0.12468870f, 0.19792689f, 
    -0.08201670f, -0.04597251f, -0.01650490f, 0.00226742f, -0.04090518f, 0.02954535f, 0.00149977f, 0.01887798f, 
    -0.02198578f, 0.00825695f, 0.00582310f, 0.00442280f, -0.09070066f, 0.05986337f, 0.01450944f, -0.06008891f, 
    0.03338436f, 0.05995967f, -0.04656312f, -0.04756470f, -0.07901875f, -0.08267742f, -0.07085249f, -0.07676447f, 
    -0.01544358f, -0.05865471f, -0.09509417f, 0.06671134f, -0.02858026f, 0.01831554f, -0.07811705f, 0.00525805f, 
    0.06394705f, 0.05359580f, -0.10124376f, -0.08316428f, -0.02652434f, 0.04140328f, 0.01995025f, -0.01488222f, 
    -0.10018057f, -0.03925832f, -0.05761850f, -0.04052785f, 0.02719952f, 0.01369577f, -0.00137482f, 0.00487000f, 
    0.07006257f, 0.01296789f, -0.07726382f, 0.03379283f, 0.01602498f, 0.02202888f, -0.05028459f, -0.00848373f, 
    -0.00482389f, -0.07437982f, -0.06528173f, -0.02054763f, 0.02910483f, -0.06732311f, -0.03454704f, 0.02054709f, 
    0.03230128f, 0.01761229f, -0.05705921f, -0.05152870f, -0.04650771f, 0.05626748f, -0.04879376f, 0.05007623f, 
    0.01172940f, 0.02545666f, -0.02115314f, -0.05392069f, -0.08428219f, 0.05802472f, 0.00512430f, -0.06929330f, 
    0.03117757f, -0.10917318f, -0.04598744f, -0.06965398f, -0.02706712f, 0.04241198f, -0.05458979f, 0.04550847f, 
    0.05388546f, -0.00197911f, -0.05100000f, -0.03570677f, -0.09031402f, -0.01289162f, -0.09404547f, -0.07000958f, 
    0.07759535f, -0.08620718f, 0.06784213f, 0.01935630f, 0.01027844f, -0.07197665f, -0.00054844f, 0.03863014f, 
    0.00203424f, -0.05040112f, -0.06890077f, -0.02895232f, 0.04344625f, -0.08141037f, 0.01192487f, -0.05917739f, 
    -0.04239287f, -0.06764281f, -0.08704058f, 0.02808173f, -0.09949037f, -0.07001119f, -0.03593237f, -0.03100189f, 
    0.06661031f, -0.00186400f, 0.02781851f, -0.06491631f, -0.06048591f, 0.04249065f, -0.02256409f, 0.00787374f, 
    -0.05559445f, 0.04673795f, -0.01650142f, -0.08999180f, 0.00663019f, -0.00540343f, -0.07370932f, -0.06515225f, 
    -0.01227157f, 0.07180510f, 0.02633570f, 0.06340764f, 0.05396672f, 0.00599368f, -0.07209792f, -0.06747269f, 
    0.05099554f, -0.03936151f, -0.07353321f, -0.05331595f, -0.00317465f, 0.01329158f, 0.05609384f, 0.03509640f, 
    -0.08185964f, -0.03153784f, -0.03304619f, 0.00463905f, 0.05347608f, -0.01381133f, -0.06026680f, -0.06974451f, 
    -0.08470313f, -0.04164103f, -0.06947755f, -0.03323628f, 0.01187803f, -0.05219734f, -0.08678030f, -0.05497786f, 
    -0.02642506f, 0.06205706f, -0.08719427f, -0.04293728f, 0.03663420f, -0.01413069f, -0.00940602f, 0.08017489f, 
    -0.07718387f, -0.00956633f, -0.04045670f, 0.03569937f, 0.02455119f, 0.06766553f, -0.10165410f, 0.01101436f, 
    0.08418051f, -0.10095615f, 0.03426615f, -0.02885394f, 0.07700675f, 0.01923117f, -0.03955244f, -0.10016545f, 
    -0.01961389f, 0.03183074f, -0.09145988f, 0.01929349f, 0.05025773f, -0.09079190f, 0.01124923f, -0.03014403f, 
    -0.07623906f, -0.06249394f, 0.01883034f, 0.00468352f, -0.09584334f, -0.02776293f, 0.03018323f, -0.07803574f, 
    0.05358482f, -0.10437817f, -0.07536441f, -0.02369258f, 0.07795238f, -0.01650481f, -0.10185106f, -0.04158764f, 
    0.08715236f, -0.03737896f, 0.03234381f, 0.06080377f, -0.02462635f, -0.08975066f, 0.07681357f, -0.08532105f, 
    0.04594297f, -0.07229667f, 0.06848000f, -0.05257346f, 0.04602903f, -0.00302155f, -0.00072566f, 0.05009425f, 
    -0.06393229f, 0.08539019f, -0.04738216f, -0.00703675f, -0.07103422f, 0.04166066f, 0.06198858f, 0.04450933f, 
    -0.03604891f, 0.03304070f, 0.06683739f, -0.02223443f, -0.03367212f, -0.08274116f, -0.05215197f, -0.02253670f, 
    -0.06541855f, -0.04305341f, 0.04898747f, -0.05250521f, -0.07451294f, -0.00535325f, -0.08230831f, 0.03074228f, 
    -0.02065213f, -0.21442114f, -0.17953141f, -0.07605341f, 0.24175075f, 0.26326200f, 0.23717880f, -0.08751128f, 
    -0.86852837f, -0.06106790f, -0.01137035f, 0.09461764f, 0.21737009f, -0.01654109f, -0.04364987f, 0.32749781f, 
    -0.00354009f, -0.07281444f, 0.31108439f, 0.03234081f, 0.01496901f, 0.08167230f, 0.01612018f, 0.01884264f, 
    -0.59146136f, 0.07499457f, -0.43018067f, 0.07529392f, 0.01224413f, 0.06373997f, 0.18842630f, 0.26194599f, 
    0.12090073f, 0.18065128f, 0.41629770f, -0.28049511f, 0.17135815f, 0.05651108f, 0.19854952f, 0.43151164f, 
    0.15962942f, -0.23851712f, 0.33758914f, -0.11289563f, -0.08854591f, -0.01067127f, 0.44793156f, 0.11822747f, 
    -0.49818379f, -0.12468535f, 0.23145871f, 0.37282577f, -0.33212835f, -0.14967433f, -0.26952973f, 0.01471970f, 
    0.30442694f, -0.43321249f, -0.01446304f, 0.16865817f, 0.04568450f, -0.00039711f, 0.19490331f, -0.07615792f, 
    0.51257288f, -0.12957850f, -0.18348093f, 0.10607009f, -0.37354803f, 0.21206613f, 0.03382076f, 0.10390200f, 
    -0.00456764f, -0.38022137f, -0.16655007f, 0.04428098f, -0.17823000f, 0.01724068f, 0.03160127f, 0.06080413f, 
    0.37171540f, -0.02516953f, -0.36655819f, 0.08911634f, -0.04885853f, 0.10733700f, 0.06391571f, -0.37399572f, 
    -0.13683079f, -0.02416581f, 0.02892493f, -0.00194804f, 0.14896747f, -0.04777408f, 0.44252342f, -0.09460710f, 
    0.12937404f, -0.39575171f, 0.28149903f, -0.08306593f, 0.00411012f, -0.05119393f, 0.37332007f, -0.36857003f, 
    -0.17498232f, -0.00712917f, 0.12944239f, 0.42544341f, -0.36267585f, 0.05454315f, 0.03487804f, 0.01092883f, 
    -0.16554257f, -0.12669286f, 0.09475590f, 0.35502863f, -0.18814647f, 0.15086007f, -0.01830946f, 0.04313044f, 
    0.03850511f, -0.58388919f, 0.10315368f, -0.35037217f, 0.09896005f, 0.02477313f, -0.05761523f, -0.03235621f, 
    0.04792163f, 0.00023257f, -0.00823248f, -0.01422092f, -0.02750208f, -0.07545672f, 0.03562925f, 0.06545518f, 
    -0.06992336f, 0.06153944f, 0.07463100f, -0.05554854f, 0.01455235f, -0.02042193f, -0.01563348f, -0.03319322f, 
    0.04186307f, 0.03412402f, 0.04207261f, 0.00818729f, -0.11487623f, 0.00997261f, 0.02285129f, -0.03911068f, 
    -0.08581933f, 0.01266528f, -0.05522815f, 0.03965844f, -0.01390906f, 0.00861949f, 0.03691437f, -0.02780659f, 
    -0.00061161f, 0.00026730f, -0.00178504f, -0.08007392f, 0.00970846f, -0.04892713f, -0.04330668f, -0.07139619f, 
    -0.02572552f, 0.01753400f, -0.03588995f, -0.00360896f, -0.03527388f, -0.06006459f, -0.02164621f, 0.02889457f, 
    -0.00391424f, -0.01310949f, -0.09796791f, 0.02033883f, 0.00916375f, -0.07362639f, -0.12596424f, -0.01750303f, 
    0.03262250f, -0.06898931f, -0.00437473f, -0.10206422f, 0.03623423f, 0.01467342f, -0.05286974f, -0.12992282f, 
    0.03569167f, -0.08131225f, -0.09700605f, 0.02361809f, 0.08082606f, -0.10243279f, -0.06966932f, -0.01774678f, 
    0.04601747f, -0.06745256f, 0.00939784f, -0.08905461f, 0.01820491f, 0.04179547f, -0.09594646f, -0.08732026f, 
    0.00417292f, -0.10472231f, -0.04653860f, -0.00898076f, 0.03500218f, -0.08626464f, 0.02383729f, -0.08215545f, 
    0.03000597f, -0.01274537f, 0.04764194f, 0.00575460f, 0.01036335f, 0.04493960f, -0.06769071f, -0.06779852f, 
    -0.05509185f, 0.03560676f, 0.01721294f, -0.08418883f, 0.03180689f, -0.03882593f, -0.07356190f, -0.04740439f, 
    0.02632662f, 0.05482157f, -0.09330005f, 0.07620049f, 0.03315077f, 0.06497747f, -0.05603899f, -0.09735937f, 
    -0.02231222f, -0.03540029f, -0.05898647f, -0.05400946f, 0.00497618f, -0.08467616f, -0.09515226f, -0.10240433f, 
    -0.01080862f, 0.06296092f, 0.00904885f, -0.06538563f, 0.01533075f, 0.03903793f, -0.04095666f, 0.02097219f, 
    0.01696086f, 0.09704357f, 0.19470593f, -0.19790711f, 0.06197870f, -0.01164913f, 0.07787685f, 0.05262292f, 
    0.37262988f, -0.02869589f, -0.06637985f, 0.15548170f, -0.39375013f, 0.06753043f, 0.15361138f, -0.15147954f, 
    0.00082408f, 0.05269905f, 0.04389581f, -0.02774749f, -0.04255908f, 0.09268921f, 0.01053844f, 0.14863129f, 
    0.05575058f, -0.15946642f, 0.32035685f, -0.02294333f, 0.14699483f, -0.05834191f, 0.07898358f, -0.11857370f, 
    -0.14365716f, -0.18311717f, -0.16373865f, 0.23957425f, -0.00976302f, 0.02889256f, 0.09775761f, 0.07683499f, 
    -0.04178512f, 0.26072311f, 0.15784782f, -0.05284996f, -0.16211869f, -0.04385147f, -0.05146480f, -0.07169768f, 
    0.27770472f, 0.17610416f, -0.18893714f, -0.22739926f, 0.14955322f, -0.12896705f, -0.02896056f, -0.52956575f, 
    0.37593737f, 0.18664715f, -0.34749112f, 0.30239850f, -0.02363596f, -0.19250871f, -0.03193557f, -0.01245758f, 
    -0.15971194f, 0.32626998f, -0.07776571f, -0.08060306f, 0.07032973f, -0.08483936f, 0.40090230f, -0.02381474f, 
    0.01386472f, 0.26121238f, 0.20133896f, -0.36483255f, -0.15516782f, -0.05516931f, -0.00146248f, -0.00126808f, 
    -0.10151037f, -0.02497696f, 0.17583333f, 0.28607151f, 0.08698863f, -0.23056805f, 0.04949525f, 0.08867726f, 
    0.07396305f, 0.02006595f, 0.16499497f, 0.09377649f, -0.05801914f, -0.09766559f, 0.17021543f, 0.05434642f, 
    0.02286387f, 0.01494220f, 0.28575060f, -0.00105011f, 0.12426734f, -0.14767592f, 0.38847369f, 0.02911508f, 
    0.10257086f, -0.00433803f, 0.00710174f, 0.12167750f, -0.11723167f, 0.07092811f, 0.30912414f, 0.05602473f, 
    -0.23895448f, -0.02284394f, 0.09276302f, -0.32943031f, 0.12046220f, -0.03157298f, -0.02556139f, -0.48343039f, 
    0.05583397f, 0.24884318f, -0.03406399f, 0.04212443f, 0.14064872f, -0.52117628f, -0.12027565f, -0.17967936f, 
    -0.00932082f, -0.01739224f, 0.03429501f, 0.07993978f, -0.16600370f, 0.04830174f, -0.04244143f, 0.03031661f, 
    0.47616658f, 0.19842032f, 0.16496705f, 0.05289691f, -0.02263504f, 0.04681102f, 0.13287263f, -0.00447586f, 
    0.00700851f, 0.00700069f, 0.08590747f, -0.01867447f, 0.15157251f, 0.00595097f, -0.07525493f, 0.21148787f, 
    0.03600082f, -0.14894453f, 0.16675413f, 0.02929659f, 0.02897231f, -0.09718844f, 0.30306843f, 0.22475317f, 
    0.27308357f, -0.06301675f, 0.20056707f, 0.09219681f, 0.11687477f, -0.19863597f, 0.17073354f, 0.40235078f, 
    0.03231872f, -0.12637340f, -0.28231871f, 0.01337283f, 0.05918372f, 0.05612745f, 0.02131487f, -0.74248612f, 
    0.08191002f, 0.23413014f, -0.23444913f, -0.14799704f, 0.19198717f, 0.02458621f, -0.02903389f, -0.36637145f, 
    0.28166184f, -0.09407051f, -0.17334884f, -0.13101043f, -0.07228315f, -0.06825385f, 0.00355292f, 0.17350155f, 
    -0.37141064f, 0.28026009f, 0.05209746f, -0.10456383f, 0.09295636f, 0.18705967f, 0.59531701f, 0.17556351f, 
    -0.10031977f, -0.04876683f, 0.35088015f, -0.10504368f, -0.11704522f, -0.03930195f, -0.05101467f, 0.11727627f, 
    -0.12110827f, -0.03213738f, 0.16229473f, -0.05647485f, 0.04940945f, 0.12352832f, -0.09196241f, -0.08722254f, 
    0.32102171f, 0.14615694f, 0.20345357f, 0.01345054f, -0.00411294f, 0.13650715f, -0.09908374f, 0.24667159f, 
    -0.13373810f, 0.17997156f, 0.09703491f, 0.05064866f, 0.23799343f, 0.01423603f, -0.03878453f, 0.02945489f, 
    -0.02737123f, 0.03076657f, 0.28761145f, -0.12409300f, -0.15635505f, 0.01630260f, 0.02716079f, -0.00144928f, 
    -0.16201986f, 0.17751347f, 0.07389041f, -0.01282565f, 0.16409290f, -0.03828279f, -0.02059075f, -0.30381551f, 
    0.31824589f, 0.06625487f, 0.04377047f, 0.05860507f, 0.07170375f, -0.45481601f, -0.21801406f, -0.17051116f, 
    0.00756337f, -0.04741912f, -0.08756807f, -0.01224548f, 0.00595828f, 0.01290457f, -0.07975898f, -0.07398799f, 
    0.01221891f, 0.02097550f, -0.05612226f, -0.08869095f, 0.02900245f, -0.01353325f, 0.01259810f, 0.00473577f, 
    -0.02881449f, 0.05323400f, 0.00425270f, -0.03174283f, -0.06466950f, -0.06607255f, -0.04576898f, -0.07563794f, 
    -0.08487309f, 0.02429584f, 0.06101818f, -0.01664882f, 0.08291934f, -0.06781946f, -0.07926676f, -0.05469448f, 
    -0.04701906f, 0.00263122f, 0.02853316f, -0.02023150f, -0.06744401f, -0.03840623f, -0.01502102f, 0.04273848f, 
    0.05658929f, -0.05324298f, -0.05106582f, 0.07491320f, 0.06402886f, -0.04554673f, -0.03918313f, -0.02838598f, 
    -0.00576110f, -0.00926445f, -0.03882967f, 0.06946750f, -0.04316142f, -0.06826130f, 0.01700506f, 0.06870098f, 
    -0.05291862f, -0.08987038f, 0.02237488f, -0.02846093f, -0.07555946f, -0.00633901f, 0.05780833f, -0.02187489f, 
    0.00440310f, 0.05279964f, -0.06796884f, 0.01118353f, -0.03559409f, 0.05500290f, -0.02225970f, 0.04627344f, 
    0.02475375f, 0.00178509f, -0.04867225f, 0.04150137f, -0.05384521f, -0.03370942f, -0.06837996f, -0.06302404f, 
    -0.00410725f, -0.08230653f, -0.08005067f, -0.05248550f, 0.02498261f, -0.04209128f, -0.05498718f, 0.05379646f, 
    -0.04378821f, 0.04502070f, -0.06740367f, -0.05177151f, 0.07891503f, -0.02160986f, 0.03055749f, -0.08466828f, 
    0.02590564f, 0.05656395f, -0.04661573f, 0.07895913f, -0.03746052f, -0.05344013f, 0.03927578f, -0.06431724f, 
    0.06568860f, -0.04228260f, -0.03700647f, -0.02643699f, -0.01433801f, -0.06270264f, -0.00071237f, 0.03421668f, 
    -0.01788038f, 0.00954576f, 0.00067505f, -0.07509024f, -0.05066791f, 0.07085827f, 0.01538267f, 0.07391085f, 
    0.02532527f, -0.00437867f, -0.02180858f, 0.07508584f, -0.07766413f, -0.00804663f, 0.02090744f, 0.03449700f, 
    -0.07972559f, -0.00523567f, 0.05516062f, -0.08744106f, -0.01245678f, 0.02677101f, 0.01809975f, 0.02641316f, 
    0.01077796f, -0.10425913f, -0.12227421f, 0.02214104f, -0.07166138f, 0.00485138f, -0.01352530f, 0.00741426f, 
    0.03814171f, 0.03283118f, -0.10495789f, -0.07784911f, -0.09490850f, -0.04112607f, -0.01312225f, -0.11658166f, 
    0.03559263f, -0.08714134f, -0.05836989f, -0.04533182f, -0.00141990f, 0.00776740f, 0.02322865f, -0.01264773f, 
    -0.00604955f, -0.03994743f, -0.08925253f, 0.00121271f, -0.02715420f, -0.12403047f, -0.08060265f, -0.01724387f, 
    -0.02022968f, -0.03021825f, -0.06836269f, 0.01434622f, -0.07992218f, 0.02393372f, -0.11119697f, -0.00763668f, 
    -0.11579054f, -0.05327975f, 0.01038963f, -0.02781348f, -0.00630023f, 0.03311478f, 0.05404391f, 0.04566812f, 
    0.05712048f, 0.04974842f, 0.06269871f, -0.11254016f, -0.03927005f, 0.01401172f, -0.03466836f, 0.00589165f, 
    -0.09394192f, 0.00446775f, 0.02500094f, -0.02337800f, 0.00048903f, -0.03393813f, -0.01735651f, -0.06495685f, 
    -0.02300556f, 0.03750275f, -0.03273559f, -0.02375503f, -0.03896184f, -0.06441658f, -0.10972525f, -0.06756262f, 
    0.02146494f, -0.04360222f, -0.03307764f, 0.08024681f, 0.02806608f, 0.01663292f, 0.06893093f, -0.03049731f, 
    0.00459128f, -0.13136894f, -0.13164450f, -0.08573794f, 0.05615759f, 0.02668318f, 0.01876354f, 0.02088890f, 
    -0.06378394f, -0.11283118f, 0.04129240f, -0.03977301f, -0.04449641f, -0.10654136f, 0.05256058f, -0.13006823f, 
    -0.01968701f, 0.06574012f, -0.06948849f, -0.03414528f, -0.04811082f, -0.03696611f, -0.07256007f, -0.10768946f, 
    -0.07692988f, 0.00791800f, 0.04837985f, 0.03065571f, 0.02971771f, -0.09215303f, -0.08279025f, -0.10211262f, 
    0.00100872f, 0.02583836f, -0.07252375f, -0.00059182f, -0.05168765f, -0.01177513f, 0.05308659f, 0.06592376f, 
    0.00195887f, 0.04607128f, -0.17310606f, 0.03646516f, 0.03597782f, 0.18272491f, -0.13639547f, 0.05608890f, 
    0.25557697f, -0.09510058f, 0.24694425f, -0.54390424f, 0.29868659f, 0.03325512f, -0.07474746f, 0.13817984f, 
    0.02136151f, -0.05365486f, 0.05815783f, 0.02909128f, -0.01536522f, 0.06735348f, 0.04749905f, 0.03832059f, 
    -0.04021357f, -0.10012271f, 0.12582305f, 0.04394050f, -0.03914432f, -0.03932628f, 0.20104636f, 0.25061378f, 
    0.12094580f, -0.11737548f, 0.09647764f, 0.08014441f, 0.16473906f, -0.00107698f, -0.09463834f, 0.07743437f, 
    -0.19743687f, -0.05286091f, -0.37073028f, 0.08825924f, 0.21886510f, 0.05583260f, 0.17309998f, 0.06021321f, 
    0.19443078f, -0.05752253f, -0.07243722f, -0.12743294f, -0.08529294f, -0.03913504f, -0.05536988f, 0.21885630f, 
    0.47264490f, -0.14467260f, -0.09533958f, -0.17531820f, 0.03562238f, 0.17074624f, -0.03488435f, 0.50527680f, 
    0.27137470f, -0.00395302f, 0.10305345f, 0.16854078f, 0.15037914f, 0.01899127f, -0.05928336f, 0.39198607f, 
    -0.04339583f, 0.21189539f, -0.04240545f, -0.02314170f, 0.08795516f, -0.05450878f, 0.07475099f, -0.00802002f, 
    0.05674240f, 0.08403508f, 0.11712486f, -0.16376738f, 0.01953430f, 0.08724692f, -0.02865034f, -0.11165110f, 
    -0.09031982f, 0.15821809f, 0.19181198f, -0.03232414f, -0.11873763f, -0.13495168f, -0.47603384f, 0.02232609f, 
    -0.15513423f, 0.29597864f, -0.57590890f, 0.08179109f, 0.17292769f, 0.09097239f, -0.18194780f, -0.12169941f, 
    0.24002013f, -0.02250882f, 0.08908785f, -0.12584680f, 0.37322456f, 0.15881531f, 0.14652036f, -0.00474046f, 
    0.07041093f, 0.08287165f, 0.33266029f, -0.04029861f, 0.02183609f, -0.20730038f, -0.05545034f, -0.15800974f, 
    0.05461462f, -0.30852705f, 0.08158193f, 0.17355332f, 0.23827600f, -0.47340560f, -0.35742530f, -0.08824038f, 
    -0.04436360f, -0.10503501f, -0.04198051f, -0.14045997f, 0.13361381f, 0.31127891f, 0.16603850f, 0.08614638f, 
    0.01938470f, -0.23570079f, -0.04546099f, -0.38225874f, 0.01967397f, -0.06529848f, 0.06251067f, 0.12328217f, 
    -0.07168055f, 0.07148051f, 0.30687767f, 0.01575916f, -0.10596329f, -0.32083595f, 0.03242559f, 0.06251059f, 
    -0.43825746f, 0.00589390f, -0.05164938f, 0.31229407f, -0.41789171f, -0.24291006f, 0.28752795f, 0.13930178f, 
    0.20963748f, 0.01629238f, 0.35204861f, -0.03311073f, 0.34826770f, -0.04956389f, 0.27940169f, 0.46347320f, 
    0.25989011f, -0.23824202f, -0.03973217f, -0.10424612f, 0.22899044f, 0.08601224f, -0.18881069f, 0.31305182f, 
    0.04738349f, 0.18169484f, 0.15619057f, -0.21071889f, -0.04273313f, -0.15900947f, 0.03827186f, 0.13234468f, 
    0.40461439f, -0.19340402f, -0.23817810f, 0.15470514f, 0.01842153f, -0.16324794f, 0.07613051f, -0.16403148f, 
    0.48110947f, 0.26957515f, -0.36237177f, -0.41224453f, -0.16049097f, 0.10694510f, -0.13802791f, 0.14984129f, 
    -0.11195692f, -0.36427969f, 0.17465299f, 0.21294940f, -0.10607229f, 0.16826265f, -0.18581340f, 0.10883513f, 
    0.27595824f, 0.01743757f, -0.39910126f, -0.47263342f, 0.02440432f, 0.15840606f, -0.24446274f, 0.12582903f, 
    -0.09250357f, 0.08849841f, -0.40164781f, 0.14516571f, 0.21025060f, 0.01449589f, 0.02039042f, -0.02679938f, 
    -0.05322830f, -0.73275918f, 0.16613789f, -0.07866770f, 0.09778485f, 0.07792478f, -0.45941171f, -0.12011786f, 
    0.09236874f, -0.05657043f, 0.27164808f, 0.46492931f, -0.05239624f, 0.18463957f, -0.03451571f, 0.08890023f, 
    -0.07856426f, -0.00629720f, 0.11836811f, -0.23527648f, -0.03938830f, 0.12204394f, -0.02261289f, 0.12673388f, 
    0.16689414f, 0.05260929f, 0.19973701f, -0.10708459f, 0.24969420f, 0.44821364f, -0.26046717f, -0.25209332f, 
    -0.02206317f, -0.01469026f, -0.00818455f, 0.05086853f, -0.03016004f, -0.02687052f, -0.07469869f, 0.03899542f, 
    0.04066484f, 0.08222999f, -0.01283760f, -0.01366902f, 0.01745990f, -0.00723918f, -0.06854600f, -0.02445487f, 
    -0.04686793f, -0.09988941f, -0.06597995f, -0.04718420f, 0.02020258f, -0.06582298f, 0.01583533f, -0.10103554f, 
    0.06977136f, -0.00972284f, 0.05768833f, -0.07374467f, -0.03178226f, -0.01787948f, -0.06731159f, 0.02418297f, 
    -0.05711408f, 0.01777428f, 0.03192078f, -0.10146474f, -0.08839115f, -0.07474538f, -0.09314653f, 0.05934918f, 
    0.03090323f, -0.01873868f, 0.08069298f, 0.05106124f, -0.03167587f, 0.01629861f, -0.06574909f, -0.05620863f, 
    0.01344119f, -0.03325949f, -0.00980361f, 0.00719772f, -0.08156992f, 0.01038548f, 0.02782573f, -0.06638157f, 
    0.00994847f, -0.01084189f, 0.02290491f, -0.07448222f, 0.05466309f, 0.04494024f, -0.05630304f, -0.06804509f, 
    0.01445404f, 0.04601062f, -0.03349407f, -0.02444099f, 0.05592154f, -0.03581234f, -0.05685091f, -0.05977476f, 
    -0.05206828f, -0.06784964f, -0.10347605f, 0.02605678f, 0.05082686f, 0.08386343f, -0.06704697f, -0.00147806f, 
    0.02282127f, -0.06450899f, -0.04448597f, 0.05950885f, 0.05043547f, 0.02277889f, -0.10684171f, 0.03791851f, 
    -0.06333587f, -0.05995263f, 0.04213949f, -0.03304064f, -0.10822621f, -0.02433304f, 0.07583211f, -0.01362848f, 
    0.02440074f, -0.05590464f, -0.06703170f, 0.04147565f, -0.01951308f, -0.08800688f, -0.00216910f, -0.07043785f, 
    0.05332133f, 0.04622467f, 0.04574325f, -0.03861386f, -0.07866002f, -0.00298279f, -0.04486156f, 0.00710613f, 
    -0.07984590f, -0.01434198f, 0.01643482f, -0.08199789f, -0.10351855f, -0.08485261f, -0.09164396f, -0.07307318f, 
    -0.02476365f, -0.10687911f, -0.03798700f, 0.04974109f, 0.01864569f, 0.03625626f, -0.04446683f, -0.11610949f, 
    -0.02622230f, -0.03133886f, 0.05410539f, -0.08178072f, -0.03837643f, -0.10504438f, -0.05643270f, -0.06838889f, 
    -0.02920869f, -0.04443102f, -0.04003304f, -0.03543747f, -0.03794656f, -0.00738381f, 0.01852892f, -0.04140354f, 
    0.07021579f, -0.01355058f, 0.04679448f, -0.06183099f, -0.01516279f, -0.00017230f, 0.07684817f, -0.00773134f, 
    0.04786118f, -0.07244817f, 0.02904166f, 0.02377068f, -0.07907463f, 0.04594387f, 0.06179943f, -0.01837492f, 
    -0.04820780f, -0.07309078f, -0.08325667f, -0.04410851f, -0.01633737f, -0.09824009f, 0.01112471f, 0.02381058f, 
    0.03967980f, -0.07458004f, 0.01085510f, -0.03945979f, -0.10476113f, -0.04469636f, -0.05962805f, 0.07743880f, 
    -0.05892383f, -0.06025594f, -0.04590036f, -0.02902649f, -0.07597365f, -0.00485496f, -0.10410831f, 0.03978015f, 
    -0.00725900f, 0.00708558f, -0.06698880f, -0.05213034f, 0.03671804f, 0.02462756f, -0.02776062f, 0.00543367f, 
    0.05997842f, -0.00644032f, -0.02937278f, -0.08131151f, 0.03652092f, -0.01480592f, -0.01179582f, 0.00403019f, 
    -0.06618131f, -0.01509231f, -0.05656216f, 0.01306083f, 0.05689923f, 0.08557700f, -0.08411513f, -0.04225988f, 
    -0.05829522f, -0.01111774f, -0.09145730f, 0.01282015f, 0.02232285f, -0.02896399f, -0.07881199f, 0.02650199f, 
    0.03049624f, 0.02166075f, -0.05233902f, -0.02136666f, -0.19784379f, 0.06802850f, -0.04612862f, 0.07576809f, 
    -0.00841146f, -0.05004973f, 0.03269845f, -0.03294319f, 0.03600427f, 0.01689671f, -0.02214793f, 0.04529500f, 
    0.04271063f, -0.05164630f, 0.04053838f, -0.01417004f, -0.01732745f, 0.07209004f, 0.01437143f, -0.05178580f, 
    -0.05876682f, -0.02599757f, 0.04373826f, 0.02370090f, -0.03218463f, -0.07597090f, 0.02509486f, -0.03893925f, 
    -0.02104122f, -0.03178651f, 0.01168110f, -0.04575379f, 0.00846914f, 0.05370836f, 0.00596953f, -0.02890881f, 
    0.02559232f, 0.24443692f, -0.14399634f, 0.09695631f, 0.05325743f, 0.12119433f, -0.00729896f, 0.05851142f, 
    0.24904899f, 0.12474549f, -0.12282050f, 0.09329664f, 0.47049817f, 0.01187603f, 0.13576412f, 0.11984757f, 
    0.02652647f, -0.06969266f, 0.10140329f, 0.01540163f, 0.08804075f, 0.17744705f, 0.03183053f, -0.02708933f, 
    -0.11351805f, 0.08367140f, -0.01010193f, 0.28039473f, 0.09629023f, -0.09980597f, 0.25170898f, 0.22683918f, 
    0.03629500f, -0.29057270f, 0.10321236f, 0.03576286f, 0.06249177f, 0.11556727f, -0.00259632f, 0.04587099f, 
    -0.10583514f, -0.07571058f, -0.60358155f, 0.22012427f, 0.15672390f, -0.02561899f, 0.58479196f, 0.10915593f, 
    0.12837987f, 0.01566209f, 0.12491862f, -0.11468003f, -0.39076871f, -0.04091063f, -0.20516531f, -0.34918293f, 
    -0.07399639f, 0.00599900f, -0.01445719f, -0.83471477f, 0.03405945f, 0.18095756f, -0.10608929f, 0.43769342f, 
    0.27856347f, 0.09637805f, -0.13330626f, -0.07366221f, -0.39875779f, 0.00196207f, -0.18812741f, 0.32380486f, 
    -0.10604302f, -0.09122062f, -0.31072369f, -0.03965714f, 0.02133304f, 0.05303170f, 0.15912306f, 0.06626265f, 
    0.18265043f, -0.01032653f, 0.12047067f, -0.17833772f, 0.08287812f, -0.16776241f, 0.04379631f, -0.30522084f, 
    -0.24454668f, 0.07031484f, 0.49240974f, 0.11857796f, -0.09725733f, -0.03426022f, -0.02800444f, -0.02776819f, 
    -0.40632296f, -0.10898966f, -0.01761024f, 0.03881533f, 0.21493441f, 0.33246627f, 0.05188171f, -0.14178354f, 
    0.07991663f, 0.06367277f, -0.14821631f, -0.04465558f, 0.41328076f, 0.02080536f, 0.21466246f, 0.11824136f, 
    0.16446927f, -0.01516765f, 0.09343512f, -0.11071108f, 0.05746239f, -0.30039695f, -0.15777007f, -0.10716220f, 
    -0.16840278f, -0.19593006f, -0.20896198f, 0.25565016f, 0.10253202f, -0.30529973f, -0.24754961f, -0.13250944f, 
    0.07748658f, -0.16511580f, -0.14185317f, 0.05680758f, 0.04918646f, 0.20985563f, 0.09230230f, 0.06671706f, 
    -0.32097510f, -0.14830071f, 0.05092262f, -0.24266635f, 0.33099961f, -0.02337064f, -0.04325733f, 0.07032845f, 
    0.01124379f, 0.09934305f, 0.28626618f, 0.00381601f, -0.06399798f, 0.01526974f, 0.04679165f, -0.08587310f, 
    -0.14163540f, -0.11526407f, -0.13281789f, -0.05525066f, 0.07184388f, 0.06893535f, 0.18351969f, 0.23614448f, 
    0.18495697f, 0.13630915f, 0.43832421f, -0.05497093f, 0.08054986f, 0.09480228f, 0.16013131f, 0.04145940f, 
    0.00557977f, -0.21022680f, -0.07610376f, -0.03660410f, 0.03519773f, 0.04409736f, 0.52486342f, -0.47146612f, 
    -0.04833605f, -0.07744537f, 0.19611290f, 0.15590188f, -0.07670403f, 0.03279768f, -0.10062931f, 0.17609799f, 
    0.28702405f, -0.15882379f, -0.09289481f, -0.35903710f, 0.00782598f, -0.02783919f, 0.05494362f, 0.07293119f, 
    0.34803626f, -0.09378189f, 0.03730264f, -0.00655379f, -0.00960186f, 0.17677118f, -0.22501017f, 0.22248012f, 
    -0.01144602f, -0.27762723f, 0.03972086f, -0.05350345f, 0.04523499f, -0.04009396f, -0.16738398f, 0.05143894f, 
    0.09180426f, -0.01155233f, -0.28186136f, -0.33847761f, -0.05598871f, 0.23242529f, -0.10327160f, 0.04603542f, 
    0.02489838f, 0.02685664f, 0.17953074f, 0.15228085f, 0.06924250f, 0.09144446f, -0.04156305f, 0.04320528f, 
    0.19401594f, -0.08796762f, 0.18424070f, 0.07142006f, 0.14833714f, 0.00789916f, -0.00945952f, -0.05322195f, 
    -0.02985061f, 0.06915910f, 0.11568009f, 0.13673529f, 0.01047762f, 0.11715294f, -0.01882919f, 0.00727802f, 
    -0.07552353f, 0.00783603f, 0.13630247f, 0.39169794f, 0.03453481f, 0.04151092f, 0.00128493f, 0.10977844f, 
    0.13325682f, -0.26736382f, 0.18607764f, -0.19682467f, 0.20981039f, 0.31855291f, 0.11471830f, -0.10216572f, 
    0.02426631f, -0.08308899f, 0.06921020f, -0.02994312f, -0.07979263f, -0.09422694f, 0.01347477f, -0.04685305f, 
    -0.03976323f, 0.26787028f, 0.03604533f, -0.26508555f, 0.01713368f, 0.04245321f, 0.15576240f, 0.06482168f, 
    0.06994741f, -0.08092427f, 0.11504930f, -0.05404900f, 0.13907211f, 0.05315189f, -0.07977735f, 0.22086018f, 
    0.06165832f, -0.17744642f, 0.15512833f, -0.10327359f, 0.02663111f, 0.00725920f, 0.21185432f, 0.15257655f, 
    0.09857805f, 0.08361281f, 0.13296475f, 0.05668646f, -0.12473908f, -0.07410297f, 0.02395114f, -0.11371819f, 
    0.15582567f, 0.12635511f, 0.20829070f, -0.15940621f, -0.12202299f, -0.02217181f, -0.07725356f, 0.15606284f, 
    -0.04462206f, 0.19559807f, 0.13905610f, -0.04079885f, 0.11743155f, -0.11622307f, 0.04367977f, -0.06253374f, 
    0.17347327f, -0.00989446f, -0.23957852f, -0.05720690f, -0.01280019f, 0.08004670f, 0.03091757f, 0.10202865f, 
    0.06868242f, -0.10592462f, 0.17375228f, -0.26459602f, 0.27339214f, 0.25927636f, 0.33830836f, 0.20533727f, 
    0.02897423f, 0.15671395f, 0.30874813f, -0.16957413f, -0.09511977f, -0.02955652f, -0.01324218f, 0.07845946f, 
    -0.13778414f, -0.08890864f, 0.02860142f, -0.05591588f, 0.04920833f, 0.28410408f, -0.06410639f, 0.17412888f, 
    0.06604663f, 0.09529769f, -0.10556253f, 0.00845079f, -0.00072295f, 0.04827855f, 0.36773843f, 0.20489314f, 
    -0.30337083f, 0.28662631f, -0.00606370f, 0.03921155f, 0.12646981f, -0.00579415f, 0.42829183f, 0.17903268f, 
    0.05752382f, -0.08495158f, 0.27837187f, -0.30350640f, 0.29260978f, -0.01244639f, -0.10491828f, -0.04741952f, 
    -0.08603454f, 0.01644454f, 0.03077372f, 0.08935561f, 0.21484123f, -0.00566498f, -0.01981447f, -0.43281114f, 
    0.26107371f, 0.12546593f, 0.03392235f, 0.01843651f, -0.08509874f, -0.04410288f, -0.05206012f, -0.10574025f, 
    0.05812634f, -0.06501699f, -0.06332775f, -0.09083100f, -0.06328496f, -0.04685105f, -0.04696979f, 0.02704768f, 
    0.03517424f, 0.03074590f, 0.03084976f, 0.01285046f, -0.01091386f, 0.07863757f, -0.01713726f, 0.01830514f, 
    -0.00970778f, -0.11858720f, 0.03775845f, -0.08227590f, -0.04055708f, -0.10149028f, 0.06286368f, -0.01741325f, 
    -0.11549775f, -0.05564365f, -0.07382879f, 0.00488609f, -0.01902133f, -0.08973745f, 0.01225369f, -0.08676106f, 
    0.00212699f, -0.05498325f, -0.13898198f, -0.01730686f, 0.02520051f, -0.04259405f, -0.01235338f, -0.02126986f, 
    0.03761455f, -0.10315455f, -0.05793392f, 0.02326121f, 0.01945321f, 0.00829734f, -0.12951788f, 0.00604011f, 
    -0.06876846f, -0.08742366f, 0.01280774f, -0.05858519f, 0.03054804f, 0.01393540f, -0.12149625f, 0.02800744f, 
    0.01242134f, -0.08826360f, -0.03632137f, -0.08130129f, 0.08719890f, -0.04380008f, -0.00111158f, -0.00742188f, 
    0.01923680f, -0.07007887f, 0.01190854f, -0.09663588f, 0.00767917f, -0.10622372f, -0.13303059f, 0.02307362f, 
    -0.04867475f, -0.09565540f, -0.06505476f, -0.06859234f, -0.09194849f, -0.01252144f, 0.00195126f, 0.02652466f, 
    0.01414820f, -0.06133382f, -0.07558571f, -0.00858123f, -0.08226635f, 0.02824193f, -0.09994812f, 0.02668032f, 
    -0.02998742f, 0.03952208f, -0.07595634f, 0.03452240f, -0.04827394f, 0.02293998f, 0.00788308f, 0.03867529f, 
    0.08319744f, 0.01523326f, -0.06322159f, -0.07197917f, 0.02038091f, 0.02353770f, 0.05404443f, -0.06401851f, 
    -0.06385414f, 0.08417994f, -0.04099339f, 0.02810454f, 0.05631681f, -0.01248582f, -0.05661742f, 0.02048076f, 
    -0.04089858f, -0.04067205f, -0.05197931f, 0.00051273f, -0.07924339f, -0.09245827f, -0.11213874f, -0.02392171f, 
    -0.09943502f, -0.09341788f, 0.00704696f, -0.10764188f, 0.00844655f, -0.04468098f, -0.09627563f, 0.02202249f, 
    0.05922758f, -0.11401463f, -0.11526832f, 0.17344427f, 0.02750228f, 0.09659673f, -0.00839089f, 0.03439746f, 
    0.16709934f, -0.05334098f, 0.22583130f, -0.42729089f, 0.29686505f, -0.01424592f, 0.01119051f, 0.23455437f, 
    0.03461570f, -0.11878970f, 0.26190963f, -0.03113260f, -0.04136638f, 0.00927052f, -0.02301459f, 0.11398314f, 
    -0.04177722f, -0.24089664f, 0.08116614f, -0.00800767f, -0.31787908f, 0.05027270f, 0.19920419f, 0.14039509f, 
    0.20366980f, 0.03156921f, 0.08296276f, 0.00082966f, 0.37528807f, -0.20606202f, -0.04533129f, 0.59253454f, 
    -0.13018100f, 0.01523558f, -0.30944481f, -0.02407313f, 0.33987910f, -0.05437988f, 0.23285045f, -0.20836231f, 
    0.11315744f, -0.01335824f, 0.04703713f, -0.11259657f, 0.14485849f, 0.00297169f, 0.16325438f, 0.10544192f, 
    0.74011707f, -0.05849624f, -0.48900145f, -0.17491919f, 0.00129442f, 0.01857787f, -0.05326900f, 0.32143137f, 
    0.52905357f, -0.01005683f, 0.08751769f, -0.03039616f, 0.00286061f, 0.05358489f, -0.18045908f, 0.39395326f, 
    -0.00467204f, 0.04846814f, -0.00806860f, -0.00595046f, 0.02464375f, 0.12612753f, -0.01465303f, -0.02409657f, 
    0.07412121f, 0.10057419f, -0.04727250f, -0.31305525f, -0.02937488f, -0.00260505f, -0.10124385f, 0.04170683f, 
    0.03857075f, 0.22186503f, 0.21304896f, -0.15814985f, -0.12678938f, -0.02826685f, -0.16546915f, 0.02829898f, 
    -0.18685307f, 0.04464486f, 0.07065912f, -0.03207447f, 0.15933065f, 0.07806401f, -0.20920590f, -0.01960981f, 
    0.18131207f, 0.01122187f, 0.00811050f, -0.23341958f, 0.22462524f, 0.26775321f, -0.15337080f, -0.07575940f, 
    -0.11342925f, 0.07126795f, 0.41911331f, -0.02527406f, 0.01675686f, -0.23475799f, 0.03814488f, -0.30916500f, 
    0.17405045f, -0.25664705f, 0.01347489f, 0.16734107f, 0.37359032f, -0.10454999f, -0.27703142f, -0.11562026f, 
    0.02227752f, -0.14075595f, -0.00888778f, 0.16836935f, -0.17882872f, -0.17528029f, 0.04941746f, -0.05563302f, 
    -0.14647748f, 0.19321489f, -0.09255571f, -0.15802759f, -0.14351641f, -0.00000716f, 0.32950905f, -0.01816664f, 
    0.01911492f, 0.01852428f, -0.49904731f, -0.04166565f, 0.12125392f, 0.13740198f, -0.06446362f, 0.26909038f, 
    0.11885852f, -0.64151376f, 0.18679430f, -0.46775827f, -0.07832468f, -0.01542452f, 0.05518129f, 0.06178099f, 
    0.05267710f, 0.18733133f, -0.41780904f, -0.40067187f, -0.13405955f, 0.00457198f, -0.41121441f, -0.39294553f, 
    -0.15912914f, -0.02615371f, 0.23475638f, 0.15144441f, -0.02881618f, -0.03119052f, -0.03963918f, -1.10935700f, 
    -0.23927957f, -0.00224809f, 0.00444595f, 0.23791860f, 0.13751797f, 0.21341324f, -0.08323345f, -0.16274366f, 
    -0.26340976f, -0.07069730f, -0.08202782f, -0.06179869f, -0.00716015f, -0.28713688f, -0.02450139f, -0.06687732f, 
    -0.95939696f, -0.25003338f, 0.29550394f, 0.50073212f, 0.10724548f, -0.05383160f, -0.36890504f, 0.02430572f, 
    -0.06147977f, -0.02942401f, -0.00110416f, -0.17008987f, 0.12250385f, 0.00774351f, -0.21853617f, -0.08629377f, 
    -0.36171901f, 0.22207068f, 0.29033846f, 0.47066164f, 0.04201211f, -0.32027775f, -0.26995379f, -0.53147429f, 
    0.35012063f, -0.16231509f, -0.04460990f, -0.79033750f, -0.04701786f, 0.31816074f, 0.04148640f, 0.34815177f, 
    0.29120296f, 0.12883264f, -0.31700552f, -0.01169263f, 0.21067688f, -0.58070940f, -0.49323329f, 0.02387028f, 
    -0.46496809f, 0.01419707f, 0.27275598f, 0.07077005f, 0.27668816f, -0.23741576f, -0.31388408f, -0.24605654f, 
    -0.35776091f, 0.21905828f, -0.10174641f, 0.18299915f, -0.04641259f, 0.10454629f, 0.18495679f, -0.09313876f, 
    -0.01154908f, -0.31750435f, 0.05073326f, 0.12207449f, -0.02935573f, 0.24230194f, 0.32211596f, -0.00066767f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.03855833f, -0.00461494f, 0.47971150f, 0.15537377f, 0.11848985f, 0.30338195f, -0.11508675f, 0.35188237f, 
    0.02277752f, -0.00292992f, 0.17158580f, 0.29041883f, -0.06244432f, 0.35220805f, 0.34158391f, 0.04872576f, 
    0.04499622f, -0.00123010f, 0.20388915f, 0.22742157f, 0.04779026f, 0.27206299f, 0.12015496f, -0.14459175f, 
    -0.08800511f, -0.03535470f, 0.15433246f, 0.21294472f, -0.08175709f, -0.02376197f, 0.12894085f, -0.01880984f, 
    0.05763203f, -0.10018180f, -0.04220928f, -0.23760395f, 0.14787744f, -0.07976561f, -0.08456542f, 0.06791707f, 
    -0.04234299f, 0.05854624f, -0.01450152f, -0.01953997f, 0.05728102f, -0.05700824f, -0.12224516f, 0.20271052f, 
    -0.05350929f, 0.10712644f, -0.08647590f, 0.13047989f, 0.21062189f, 0.08566198f, -0.25098404f, -0.01863451f, 
    -0.03209337f, 0.40415123f, 0.21610452f, -0.09883126f, 0.15258123f, -0.00638353f, 0.07213562f, 0.02575418f, 
    0.20150810f, 0.22979985f, 0.38003281f, 0.16600469f, 0.05516348f, 0.13169824f, 0.13365623f, -0.00494087f, 
    0.00567002f, -0.03281882f, 0.15492110f, 0.34446952f, 0.02948007f, 0.34433419f, -0.05110641f, -0.08186790f, 
    0.20506324f, -0.09413306f, 0.19726986f, 0.00962720f, -0.13356349f, -0.00279297f, 0.02405077f, -0.23662902f, 
    0.06597911f, 0.07574406f, 0.13982026f, -0.07734608f, 0.07207108f, 0.04061833f, 0.24213436f, -0.01889043f, 
    0.20452367f, -0.01820042f, -0.04310745f, -0.00843937f, -0.05743121f, -0.19324413f, -0.21998605f, -0.15147543f, 
    -0.06760722f, -0.08879088f, 0.25177512f, 0.04085298f, 0.18820456f, 0.12286185f, 0.03858585f, -0.08184224f, 
    -0.10007939f, 0.05398773f, 0.07926080f, 0.15948153f, 0.03252475f, -0.09847268f, 0.24807523f, 0.09963240f, 
    -0.08072155f, 0.04826347f, 0.07271362f, -0.00170859f, 0.06787105f, -0.01703381f, 0.39190915f, -0.23450089f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.07359617f, 0.06449397f, 0.20771538f, -0.27963331f, -0.03403753f, 0.04380886f, -0.71542853f, -0.15015171f, 
    -0.01129900f, 0.04912392f, -0.24975789f, -0.17806454f, 0.04246777f, 0.07364149f, 0.32391185f, 0.03295989f, 
    -0.14329749f, -0.06215172f, -0.41197070f, 0.17991386f, -0.16107075f, 0.12536351f, -0.05284341f, -0.22257183f, 
    -0.21485715f, -0.05716838f, -0.12774912f, 0.05715528f, -0.22768494f, 0.06046276f, 0.10164818f, 0.01134303f, 
    0.23688804f, -0.04592949f, 0.03334073f, 0.13465849f, 0.11307292f, 0.01364251f, -0.04620685f, 0.07876673f, 
    -0.04686564f, -0.07381722f, 0.15906614f, -0.01339957f, -0.18333162f, -0.02565860f, -0.52362317f, 0.13202517f, 
    -0.36723536f, -0.41275406f, 0.04042555f, -0.27907926f, -0.29109710f, 0.41997898f, -0.02334354f, -0.01097124f, 
    0.24701376f, -0.48769259f, -0.04069073f, -0.06641914f, 0.14473668f, 0.04537405f, 0.08377455f, 0.03931841f, 
    -0.05057027f, 0.17088842f, -0.04626503f, 0.16560636f, -0.14097382f, -0.52331579f, -0.48529157f, -0.26204637f, 
    0.04088128f, -0.23225348f, 0.06942742f, 0.18934485f, -0.02787239f, 0.33754554f, 0.05412690f, -0.21950966f, 
    -0.33634502f, -0.05239189f, 0.03549337f, -0.01926659f, -0.16227695f, 0.08367737f, -0.07709404f, -1.05710685f, 
    0.01955844f, 0.02281951f, 0.08605209f, 0.05796629f, 0.12459600f, 0.03021896f, 0.11020629f, -0.04798396f, 
    0.29887044f, 0.05789001f, 0.02042561f, 0.14265314f, -0.06287014f, 0.10828669f, -0.17543864f, -0.60276496f, 
    -0.04259143f, 0.02404730f, 0.32589376f, 0.04283443f, 0.13684240f, 0.05656574f, -0.00846053f, 0.00496018f, 
    -0.14254293f, 0.02179698f, 0.02313198f, 0.19191331f, -0.01278372f, -0.03242518f, -0.04466212f, 0.42105365f, 
    -0.11735991f, -0.04753621f, -0.11668131f, 0.00591110f, -0.07064021f, 0.03881748f, 0.09119197f, -0.12008281f, 
    -0.06419716f, 0.00069255f, -0.03355208f, -0.09044753f, -0.03605040f, 0.13745417f, 0.13684016f, -0.74662399f, 
    0.01289138f, -0.03059383f, -0.04034397f, -0.43309733f, 0.00076308f, -0.05594271f, 0.02159077f, -0.19402865f, 
    -0.02144242f, -0.11555830f, -0.09371272f, 0.09420675f, -0.03322777f, 0.01635632f, 0.19181111f, -0.76501852f, 
    0.23760363f, -0.02784346f, -0.48408064f, 0.04490739f, 0.00950548f, 0.05950756f, 0.07965207f, -0.05796856f, 
    -0.03150192f, -0.00965494f, 0.05407203f, 0.14471011f, 0.12195589f, -0.01879620f, 0.01854555f, -0.02849229f, 
    -0.04070275f, 0.02401599f, -0.10982480f, 0.05745792f, 0.05714526f, 0.07898653f, 0.08086675f, 0.13304317f, 
    -0.10990047f, -0.14949924f, 0.01282493f, 0.36262295f, 0.24480595f, -0.15153222f, 0.26974460f, 0.01061530f, 
    0.22634000f, -0.00132977f, 0.02942266f, 0.33233476f, 0.11173963f, 0.03674920f, -0.24125910f, 0.00136446f, 
    -0.04896785f, -0.11551601f, -0.22041187f, 0.15514562f, 0.16424455f, 0.10424054f, 0.17380381f, -0.26847404f, 
    -0.05488722f, -0.54595697f, 0.09384364f, -0.02121515f, -0.05902430f, 0.17698541f, -0.02193984f, 0.02226363f, 
    -0.15861420f, -0.00472088f, 0.02864198f, 0.02442945f, 0.15773293f, 0.14859328f, -0.24688505f, 0.30008560f, 
    -0.04077270f, 0.14765251f, -0.44536126f, -0.11246219f, -0.25446385f, -0.06891564f, 0.08040486f, -0.03726706f, 
    0.24843647f, 0.03421474f, 0.00284588f, -0.32272875f, 0.02541459f, 0.18438736f, 0.24105252f, 0.54770541f, 
    0.04771687f, -0.03917201f, 0.10539964f, 0.24203518f, -0.24707307f, 0.05325879f, 0.05586934f, -0.02047607f, 
    -0.09452499f, 0.03085448f, 0.07921342f, -0.16148357f, -0.08467215f, 0.05234266f, -0.20772786f, -0.59278727f, 
    -0.04608181f, 0.07489000f, -0.30504060f, -0.34615612f, -0.10125408f, -0.04551145f, -0.26680395f, -0.09879494f, 
    0.04472782f, 0.03342543f, -0.45370480f, 0.22451577f, -0.66768968f, 0.01183399f, -0.76273400f, 0.15353815f, 
    0.20207107f, 0.01827433f, 0.22312456f, -0.28345668f, -0.04518833f, -0.28861299f, -0.56349427f, 0.03604679f, 
    0.19701764f, 0.33226350f, 0.06379023f, -0.05273052f, -0.20486833f, -0.51291442f, -0.07447954f, -0.37165707f, 
    -0.00500407f, -0.04235739f, 0.11309849f, -0.20931563f, 0.29151151f, 0.04860732f, -0.00997427f, -0.04543197f, 
    0.08278828f, -0.07460732f, 0.05138554f, -0.35421497f, 0.02624191f, 0.01637211f, -0.03049553f, -0.02824619f, 
    -0.03474103f, 0.01860304f, 0.26527286f, -0.07546888f, -0.37139818f, -0.03704593f, 0.55436546f, -0.05729939f, 
    -0.21676417f, -0.61942512f, 0.01984006f, -0.42075920f, 0.04783476f, -0.17422345f, 0.32273862f, -0.04703351f, 
    -0.02617171f, -0.35514149f, 0.13063824f, 0.11694416f, 0.14890122f, 0.02538278f, -0.04178664f, 0.02713007f, 
    -0.35764575f, 0.04990560f, -0.95996493f, -0.01447846f, -0.05682903f, -0.02399356f, -0.74223787f, 0.21237870f, 
    0.04998861f, 0.35946578f, -0.09449346f, -0.20618725f, -0.02678075f, -0.81255829f, -0.12150254f, 0.22373471f, 
    0.24081086f, -0.02410601f, -0.08262665f, -0.01842111f, 0.21253036f, -0.30051589f, -0.17778589f, -0.89384001f, 
    0.04835212f, -0.26427811f, -0.42609817f, 0.03515663f, 0.13138209f, -0.05966659f, -0.12568401f, -0.06999350f, 
    -0.20768414f, -0.01412529f, -0.02296348f, 0.22066870f, 0.02077152f, 0.28404686f, 0.27051160f, -0.49709374f, 
    0.03257260f, -0.02041920f, -0.09354737f, -0.07248586f, 0.09936658f, 0.10983532f, -0.07495281f, -0.06319501f, 
    0.52967948f, -0.06174827f, -0.26561338f, -0.48933589f, -0.03688803f, 0.01720579f, 0.00429520f, 0.18011805f, 
    -0.07221537f, 0.04224930f, 0.21257961f, 0.23993529f, -0.61324888f, -0.07558423f, -0.02407289f, 0.55414814f, 
    -0.00266629f, -0.05191759f, -0.08129766f, -0.27768457f, 0.11997730f, -0.29011232f, 0.26849541f, 0.30419409f, 
    0.19782943f, -0.08186188f, -0.29972017f, -0.22102928f, 0.10668644f, 0.11979479f, -0.43937451f, 0.02842851f, 
    -0.11940286f, 0.03365572f, -0.01333536f, -0.62895709f, 0.21607207f, 0.01675286f, -0.21786296f, -0.12648880f, 
    -0.57597941f, -0.01838912f, -0.00059432f, -0.05506399f, 0.13890678f, -0.06186476f, -0.53635693f, 0.05044214f, 
    0.08917405f, 0.01582726f, -0.00850297f, -0.32905713f, -0.19749925f, 0.14202133f, 0.02101616f, 0.06727545f, 
    -0.02481063f, -0.01487737f, -0.46443656f, -0.01458605f, 0.13908975f, -0.01531029f, 0.20113601f, -0.20782071f, 
    0.19737287f, -0.34186769f, 0.07044655f, 0.19857652f, -0.40568879f, -0.24321561f, -0.42740270f, 0.00349462f, 
    -0.30514404f, 0.10839373f, -0.67170501f, -0.18634295f, -0.30248037f, 0.06345782f, -0.04240027f, -0.06502806f, 
    0.17565165f, -0.23561317f, 0.22828665f, 0.07430820f, 0.08929861f, 0.11242046f, -0.88255173f, 0.13685291f, 
    -0.02343046f, 0.11607815f, -0.63483965f, -0.01123451f, -0.00321910f, 0.06256464f, 0.01760397f, 0.15018348f, 
    -0.40189862f, -0.04153182f, -0.03815248f, -0.05789113f, -0.41318566f, -0.00689727f, 0.20160513f, -0.12052460f, 
    0.06334052f, -0.00143337f, 0.09578548f, -0.05992742f, -0.10912798f, 0.09063637f, -0.43357736f, -0.01022448f, 
    -0.14299685f, 0.01113863f, 0.04701358f, -0.06350622f, -0.03865430f, -0.07973912f, 0.07678568f, -0.39608896f, 
    0.05270227f, -0.02402923f, 0.08788972f, 0.01127652f, -0.05571043f, -0.49518904f, -0.06007621f, 0.04254002f, 
    -0.36881626f, 0.08589667f, 0.12359583f, 0.06240069f, 0.00654664f, 0.05512187f, 0.05781422f, 0.09771752f, 
    0.03776767f, -0.02782073f, -0.43762118f, -0.08449740f, 0.17466250f, 0.01740959f, 0.06310350f, 0.54380077f, 
    0.04364201f, 0.08259239f, 0.32243884f, 0.18497241f, -0.15560335f, 0.10913602f, -0.09891909f, 0.61841661f, 
    -0.44030869f, -0.08653541f, -0.21774493f, 0.31572369f, 0.03976078f, -0.06247200f, 0.42019075f, 0.01387618f, 
    0.14293528f, 0.00736581f, 0.33279091f, 0.01097045f, -0.34641483f, 0.09234356f, 0.02647077f, 0.12698929f, 
    0.24221067f, 0.00174582f, -0.25342783f, 0.07897812f, -0.20956108f, -0.04099351f, 0.05016243f, 0.00932056f, 
    -0.12609117f, -0.07560300f, -0.06944598f, 0.18201330f, -0.17134556f, 0.13757148f, -0.00690154f, -0.05553373f, 
    -0.05150780f, -0.03379503f, 0.03928730f, -0.06178363f, -0.09541558f, 0.09296323f, -0.45914590f, -0.00015622f, 
    0.05792579f, 0.15561287f, -0.01433642f, 0.22654822f, 0.25382707f, 0.17666802f, -0.21854313f, 0.05889178f, 
    -0.12615059f, -0.57640117f, 0.02966293f, 0.00044701f, 0.06138588f, -0.01518476f, -0.06778321f, 0.02117348f, 
    0.11293961f, 0.18059529f, 0.09810775f, -0.24780720f, -0.04460937f, 0.59847349f, 0.18345939f, -0.26806867f, 
    -0.03574598f, -0.11162914f, -0.08856426f, 0.23340583f, -0.06090206f, -0.11620723f, 0.00553316f, -0.21382545f, 
    0.16435671f, -0.01984502f, -0.29938960f, 0.06288452f, 0.20964760f, -0.07960995f, 0.26058003f, -0.00984514f, 
    0.04718827f, -0.09601664f, -0.16027386f, -0.06019885f, 0.15774477f, -0.04729521f, -0.09062907f, -0.00048248f, 
    -0.32250798f, -0.02913929f, 0.06738915f, -0.14209439f, 0.00665285f, -0.71040243f, -0.24454658f, -0.24980073f, 
    0.03871895f, -0.02237153f, 0.05126398f, -0.40708703f, 0.01558903f, 0.13127370f, -0.02415964f, -0.00912992f, 
    -0.26821607f, -0.03555646f, -0.19843182f, -0.11083975f, -0.07501957f, 0.00760576f, 0.03623378f, 0.13197957f, 
    -0.10448309f, 0.04338236f, -0.03593856f, -0.10212743f, 0.08278876f, -0.01574687f, 0.03014871f, 0.31834775f, 
    0.03155965f, -0.02211822f, -0.56496227f, 0.03381910f, -0.31200251f, 0.06154512f, 0.28244680f, -0.45187092f, 
    -0.02540983f, -0.04365010f, 0.08710475f, 0.39904618f, -0.03540024f, 0.19159102f, -0.70819509f, 0.19341789f, 
    -0.09921482f, -0.26223385f, -0.33289713f, 0.03473680f, -0.32574910f, -0.01339079f, 0.06637685f, 0.06534892f, 
    -0.08485746f, 0.02346371f, 0.17067270f, 0.12442633f, -0.26991782f, -0.02472425f, -0.02721536f, -0.00486424f, 
    0.02335292f, -0.05639070f, 0.05097865f, -0.02926358f, 0.07670846f, -0.06110674f, -0.01065579f, 0.03935618f, 
    0.01932785f, -0.05520545f, -0.01731454f, -0.04585474f, -0.53639221f, 0.07391560f, -0.41478309f, 0.09103486f, 
    0.34014657f, 0.50591302f, -0.04384077f, -0.14445117f, 0.24485813f, -0.05075720f, -0.18575341f, -0.12456998f, 
    0.04703989f, 0.51259649f, 0.14421827f, -0.00307354f, -0.08485913f, 0.01113801f, -0.00483066f, -0.02150261f, 
    -0.31636623f, -0.20187320f, 0.13893157f, 0.15567106f, 0.12801385f, -0.43855774f, -0.20316511f, 0.08131197f, 
    0.07328811f, 0.34439662f, 0.17732719f, -0.80459857f, -0.04545970f, -0.10920666f, 0.03919363f, -0.00013271f, 
    -0.07733772f, -0.02591384f, 0.12154394f, -0.02877492f, -0.20884255f, 0.17717658f, 0.42570832f, 0.15005198f, 
    0.00760572f, 0.20341426f, 0.14417367f, 0.03988685f, -0.07497161f, 0.04460665f, 0.08069015f, -0.05768581f, 
    0.10871668f, -0.07266070f, -0.01501238f, -0.03864539f, -0.04808105f, 0.05308750f, -0.06887674f, 0.36867723f, 
    0.02920094f, -0.00649727f, -0.41733980f, 0.03414181f, 0.08755985f, 0.03161895f, -0.04581679f, 0.02494003f, 
    0.00949493f, 0.04034808f, 0.20613571f, -0.05252409f, -0.04564812f, -0.04713767f, -0.20531361f, -0.55341363f, 
    0.05554234f, -0.08488870f, 0.00936971f, -0.29675221f, 0.12323990f, -0.00951958f, -0.08851141f, -0.59249854f, 
    0.00896084f, -0.04530170f, -0.05836287f, -0.34628034f, 0.29808673f, 0.05298991f, 0.21559416f, -0.21037972f, 
    0.06968232f, 0.04860322f, -0.45716825f, 0.12701575f, 0.10606360f, 0.11210708f, -0.11038808f, -0.35462874f, 
    0.05318902f, 0.26617950f, 0.21441509f, 0.23282327f, 0.10347469f, -0.40380961f, 0.05308814f, 0.35502651f, 
    -0.47496492f, -0.07312727f, 0.15553819f, 0.06173922f, 0.19719309f, -0.02518272f, 0.16196561f, -0.02394695f, 
    0.06278101f, -0.04063911f, 0.05685151f, -0.74244922f, 0.10824274f, -0.38199300f, -0.05506008f, -0.07365373f, 
    -0.00939472f, 0.05270717f, 0.19310196f, 0.06640497f, 0.08491703f, -0.03506381f, -0.65724921f, 0.11375697f, 
    -0.30446252f, 0.57186818f, 0.03673172f, -0.04341744f, -0.91979927f, -0.20132311f, 0.10323160f, -0.13329765f, 
    -0.15921533f, -0.60638052f, 0.24548054f, 0.10006688f, 0.17796533f, 0.06528166f, -0.09123868f, -0.04166222f, 
    -0.27554581f, 0.05673642f, 0.07697576f, -0.07615425f, 0.21333216f, -0.61478043f, -0.03591917f, -0.18424459f, 
    -0.04898628f, -0.47372675f, 0.21523380f, -0.28774908f, 0.05151486f, -0.43568063f, -0.06853706f, -0.15811959f, 
    0.17201354f, 0.00791537f, 0.09195365f, 0.01626179f, 0.02417416f, 0.04375708f, -0.43615931f, 0.01587126f, 
    0.05902630f, 0.02245704f, -0.32368231f, 0.00012880f, -0.53287888f, 0.09633857f, 0.21592145f, -0.08935535f, 
    -0.87313569f, -0.02789433f, -0.03431558f, -0.36127210f, -0.05982975f, -0.55198747f, -0.08887015f, 0.08093181f, 
    0.05445833f, -0.10379588f, -0.09387150f, -0.16141394f, 0.12480453f, 0.23379177f, -0.01937797f, -0.04382006f, 
    -0.80872548f, 0.08266129f, -0.00568520f, 0.01217948f, -0.05188248f, 0.00499212f, 0.23336977f, 0.01490192f, 
    0.03312943f, 0.05540075f, 0.14262055f, -0.22169769f, -0.21476987f, -0.03779069f, 0.10511621f, -0.29502991f, 
    0.03904226f, -0.02920923f, -0.90613532f, -0.06603248f, 0.05266862f, -0.53640294f, 0.25892165f, -0.32473958f, 
    0.06895890f, -0.06093522f, -0.44334921f, -0.18207277f, 0.05161558f, -0.37487322f, -0.47014993f, 0.12452443f, 
    -0.40662205f, -0.36725202f, -0.65365046f, -0.41833264f, -0.03840842f, 0.10558107f, -0.43922535f, -0.05345812f, 
    0.14514770f, 0.08180079f, -0.50627494f, -0.26702431f, -0.09951664f, 0.00052712f, -0.26920021f, -0.01552734f, 
    0.08399457f, -0.05234367f, -0.01720205f, 0.31931955f, -0.32638097f, 0.07731077f, -0.00277531f, 0.00485519f, 
    0.07845811f, -0.00890644f, 0.01382044f, -0.07689896f, 0.01722555f, -0.06131849f, -0.21275499f, -0.15556052f, 
    0.18328272f, -0.24011157f, -0.06092418f, -0.24245207f, -0.03264393f, -0.04557148f, 0.09943691f, 0.07190243f, 
    0.22175372f, -0.25286469f, -0.36805242f, -0.52802521f, -0.36429185f, 0.04089794f, 0.02245052f, 0.05519950f, 
    0.08054545f, 0.08846394f, 0.01875490f, -0.12081448f, -0.66048646f, -0.06099167f, -0.31640545f, -0.13002697f, 
    0.03741647f, -0.05232058f, -0.37742773f, -0.05379691f, -0.06448341f, 0.10212980f, -0.06026422f, 0.00137929f, 
    -0.51681042f, -0.03818203f, -0.57937747f, 0.07759243f, -0.01868409f, 0.02769494f, 0.21438713f, 0.30855712f, 
    0.01286596f, 0.10317381f, 0.10848828f, -0.06119585f, 0.14287975f, 0.01370446f, -0.26119530f, -0.02845178f, 
    0.20832627f, 0.03449458f, 0.05261839f, 0.16837664f, 0.05698071f, 0.04936665f, -0.13843195f, 0.30327219f, 
    0.00542417f, -0.01946002f, 0.06852642f, -0.14348602f, 0.00486771f, -0.24490798f, -0.03313394f, 0.04551187f, 
    0.21449038f, -0.03588623f, 0.11775231f, 0.05690751f, -0.09924649f, 0.00881776f, -0.36826283f, 0.11454609f, 
    -0.03800181f, -0.02283053f, -0.42292884f, 0.01931839f, 0.17977048f, -0.09347454f, -0.40906465f, -0.01048822f, 
    0.00641183f, -0.04030283f, 0.13316678f, 0.28205338f, 0.22793959f, -0.01085028f, -0.18332024f, -0.04107316f, 
    0.03868586f, -0.07681214f, 0.15374331f, -0.36329022f, 0.00030400f, -0.07219016f, -0.08945377f, -0.26566789f, 
    -0.10812483f, -0.54031891f, 0.06370288f, -0.46399152f, 0.24116458f, -0.08457616f, 0.06671879f, 0.39556587f, 
    0.36434880f, -0.00642252f, 0.03156345f, -0.46415082f, -0.44538668f, 0.08284213f, -0.06855504f, -0.03866618f, 
    -0.31086168f, 0.06287669f, -0.04870864f, 0.21894054f, 0.14440730f, -0.36633542f, -0.10906594f, 0.08723813f, 
    -0.06350864f, -0.00711867f, 0.00679978f, -0.07130063f, 0.29278505f, 0.02234055f, 0.16746439f, 0.07897722f, 
    0.46354786f, 0.45240265f, 0.03082623f, 0.31322655f, 0.22230965f, -0.08279666f, 0.01671018f, -0.02251512f, 
    0.31983289f, -0.11158700f, -0.62343657f, 0.02549917f, -0.07244452f, -0.05743550f, -0.63102049f, -0.10849832f, 
    -0.01888029f, -0.41110557f, -0.08222183f, 0.11183171f, -0.66497415f, -0.57318658f, 0.27347681f, 0.03716333f, 
    0.07182807f, -0.14957656f, -0.02440036f, 0.03569077f, -0.07447564f, -0.28065681f, -0.09076128f, 0.06849017f, 
    0.09081358f, 0.06238571f, 0.04308077f, 0.01565329f, 0.16732600f, -0.26073992f, -0.04783402f, -0.05531209f, 
    0.00055418f, 0.13634290f, -0.42754194f, -0.09809055f, -0.24379851f, -0.65882349f, -0.06504805f, -0.06315792f, 
    0.04125126f, 0.05125483f, -0.02374498f, -0.15668465f, 0.04128578f, 0.05552060f, 0.14356898f, -0.00054784f, 
    0.04270291f, -0.02471889f, -0.13795741f, 0.14774945f, -0.65824568f, -0.58249938f, -0.08148533f, 0.04806446f, 
    0.16466509f, 0.03162271f, -0.12288838f, -0.40874100f, 0.02056653f, 0.04314200f, -0.64774787f, 0.30399352f, 
    0.05860890f, -0.03778942f, -0.07732771f, -0.15483400f, -0.20651732f, -0.07462209f, -0.69164443f, 0.23320635f, 
    0.00910118f, -0.00700243f, 0.50217402f, 0.14949824f, -0.80347747f, 0.20349200f, -0.25844514f, -0.10622951f, 
    -0.58560538f, -0.03051543f, 0.33753058f, -0.27379215f, 0.08450511f, 0.05760741f, 0.03936327f, 0.00924434f, 
    -0.15863422f, -0.07930034f, 0.03929925f, 0.04389448f, -0.21528104f, 0.04091923f, 0.10530762f, 0.31579116f, 
    -0.17594288f, 0.04601001f, -0.05853550f, 0.02815290f, -0.21555902f, 0.01360035f, 0.13901140f, -0.11607679f, 
    -0.55993479f, -0.01500839f, -0.01843662f, 0.15726767f, -0.07601020f, -0.62441468f, -0.05008185f, 0.00913665f, 
    0.06271478f, -0.08802419f, -0.04119635f, -0.05072806f, -0.64811587f, -0.11962364f, 0.35073072f, 0.07299799f, 
    0.20554592f, -0.43585360f, -0.00164753f, -0.16941231f, 0.20443214f, -0.34343949f, -0.02478583f, -0.01680422f, 
    -0.09929542f, 0.57953578f, -0.16561176f, 0.09523857f, 0.09871776f, -0.00522713f, 0.10046608f, 0.06268451f, 
    0.16928352f, 0.22357941f, 0.26039487f, -0.01572348f, -0.30940649f, -0.60975033f, 0.25057951f, -0.32454589f, 
    0.01002412f, -0.32419473f, -0.11653624f, 0.25851095f, 0.06930528f, -0.23014946f, -0.08946976f, -0.51090032f, 
    -0.00001047f, -0.02237719f, -0.33235428f, 0.00724756f, -0.35565794f, -0.04804103f, -0.26453978f, -0.20883429f, 
    0.06538156f, 0.00066804f, 0.23395687f, -0.00836375f, 0.13332272f, 0.08646673f, 0.04453784f, -0.09194258f, 
    -0.01346401f, -0.03744531f, -0.05850492f, 0.14151843f, -0.06246948f, -0.16152620f, -0.34060419f, 0.10406379f, 
    -0.00657874f, 0.07715637f, 0.23974732f, -0.12646191f, -0.32657245f, 0.04350864f, 0.03097587f, -0.04901324f, 
    0.50581187f, -0.07870220f, -0.23157242f, 0.03452914f, 0.00050210f, -0.00533638f, 0.01414519f, 0.23982871f, 
    -0.03763472f, -0.08016603f, 0.12699237f, 0.19141372f, 0.16153699f, 0.01240218f, 0.27099565f, -0.40200177f, 
    -0.06043566f, -0.08575110f, -0.07070425f, -0.54662752f, 0.23846740f, -0.33117545f, -0.19290712f, 0.18572795f, 
    0.16678873f, 0.01669911f, 0.11372609f, -0.21232548f, -0.07843348f, -0.21666977f, 0.22378764f, -0.23730765f, 
    0.14126100f, 0.23887037f, -0.49500540f, 0.08503515f, 0.15704361f, -0.04880452f, -0.13784453f, -0.18513572f, 
    -0.20087288f, -0.04645522f, -0.02927907f, -0.10762432f, 0.12504295f, -0.00231964f, -0.16094194f, -0.00336875f, 
    0.14045908f, 0.02748794f, -0.05268794f, 0.11515972f, 0.03851944f, 0.18125618f, 0.04579927f, -0.02270044f, 
    0.03967393f, -0.06287460f, -0.20744520f, 0.04186912f, 0.19933464f, -0.05519670f, -0.73554790f, -0.43754363f, 
    -0.04526270f, -0.31404236f, 0.04684114f, -0.34505802f, -0.30790579f, 0.09413590f, 0.06412990f, 0.06545352f, 
    -0.43355170f, -0.51259452f, -0.29786620f, 0.04946586f, -0.24849960f, -0.07577590f, 0.09349243f, 0.08061256f, 
    -0.09376875f, -0.31256250f, -0.18913229f, -0.09390135f, 0.14633648f, -0.05973906f, 0.35445830f, 0.29530019f, 
    0.04263218f, 0.20576000f, 0.17653120f, 0.18275261f, -0.02933971f, 0.09670314f, -0.06994488f, 0.14565828f, 
    -0.23997827f, -0.04546649f, 0.14250590f, 0.06879634f, -0.45781279f, -0.04877926f, 0.12038404f, -0.31924433f, 
    0.04460850f, -0.34916842f, -0.00164203f, 0.05266329f, -0.29974362f, 0.13928109f, -0.11281238f, -0.00479014f, 
    -0.02986059f, -0.07110713f, 0.03442680f, -0.10825036f, 0.03302358f, 0.22092770f, 0.19321053f, -0.28122133f, 
    -0.05013476f, -0.11318066f, -0.33144855f, -0.28818604f, -0.09070707f, -0.22759859f, -0.00218338f, -0.04228314f, 
    -0.19920959f, -0.06680902f, -0.32796270f, 0.11388290f, -0.05101155f, 0.02437993f, 0.14773664f, -0.36428949f, 
    0.06849856f, -0.00452059f, -0.17442071f, 0.15103066f, -0.04658565f, 0.00021069f, -0.02764949f, -0.04574099f, 
    -0.05304176f, -0.03753385f, -0.24743958f, 0.00311762f, 0.01928913f, -0.04778071f, -0.21697815f, -0.35818225f, 
    0.00899512f, -0.01476631f, 0.14522554f, -0.02657497f, -0.01283030f, -0.26677683f, 0.02820994f, 0.12298059f, 
    0.12185503f, 0.07137646f, 0.26162845f, -0.02744325f, 0.13550103f, 0.16092724f, -0.12160289f, 0.33639812f, 
    -0.00197312f, 0.02245550f, 0.12907006f, -0.21748815f, 0.08764946f, 0.02964818f, -0.21526355f, 0.02567100f, 
    -0.01292306f, 0.03275555f, 0.00321927f, -0.45554209f, 0.01755936f, -0.12914066f, -0.02106293f, 0.02992448f, 
    0.02793136f, -0.04999581f, -0.30994803f, -0.08139298f, 0.16676958f, 0.00818032f, -0.16480672f, -0.22940663f, 
    -0.60712951f, 0.18087374f, 0.01066187f, 0.14296238f, -0.34844196f, 0.05554502f, -0.27632046f, -0.03891473f, 
    -0.03600084f, 0.20224279f, 0.15243632f, -0.16853391f, -0.22678486f, -0.05830169f, -0.04847380f, 0.05261132f, 
    0.07099288f, 0.01376432f, -0.09980986f, -0.12513436f, 0.24555732f, 0.19352853f, -0.03953714f, 0.09459262f, 
    0.06149275f, 0.11851969f, -0.04542774f, -0.07483909f, 0.07576305f, 0.11015996f, 0.01116707f, 0.10357023f, 
    0.21187858f, 0.06600200f, 0.16924335f, 0.02218953f, 0.20477098f, -0.20284469f, -0.82329631f, -0.02507530f, 
    0.02696251f, -0.36642575f, 0.04329728f, 0.00726947f, 0.12900886f, -0.08993983f, -0.08788215f, -0.03171346f, 
    0.12349290f, -0.07512793f, 0.04215819f, -0.02274001f, -0.02120160f, 0.00189516f, -0.13583642f, 0.09562275f, 
    0.01700940f, -0.08585353f, -0.00147949f, 0.17182127f, 0.18961148f, -0.21629623f, 0.05315144f, 0.02428336f, 
    -0.35957852f, 0.03908760f, 0.16667335f, 0.03968662f, 0.03713431f, 0.01897160f, 0.12766114f, -0.02694068f, 
    -0.02996382f, 0.00107212f, 0.31106097f, 0.02695766f, -0.02172531f, -0.02042499f, 0.12111076f, -0.02263222f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.12117781f, -0.17656980f, -0.27297115f, 0.00228173f, 0.06794523f, 0.09457314f, 0.03483999f, -0.40541300f, 
    -0.16365077f, 0.12448350f, -0.20494972f, 0.18285275f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
