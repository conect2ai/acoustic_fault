#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.12566280f, -1.02711058f, -1.04569280f, -0.25464940f, 0.15836847f, 0.39608306f, -0.28983435f, 0.27169058f, 
    0.32314721f, -0.28657454f, 0.95716721f, -0.94670498f, 1.26977873f, -0.44021940f, -0.78993696f, -0.02288483f, 
    0.12992935f, -0.44752082f, -0.14637809f, -1.36577570f, -0.27189592f, -0.67501968f, -0.62878907f, 0.32753271f, 
    -0.46247923f, -0.20804121f, -0.29595691f, 0.16777760f, 1.06910753f, -1.13358903f, -0.29863983f, 0.26401830f, 
    -0.93122512f, -0.10368009f, 0.07423120f, -0.06772827f, 0.86521626f, 0.61023569f, -0.05327862f, -0.45060998f, 
    -0.90420073f, -0.66497952f, -0.62415564f, 0.29117540f, 0.82589072f, 1.17305410f, -1.19209909f, -1.25815403f, 
    0.51269269f, -0.12495623f, -1.03849423f, -0.41076073f, -0.12166500f, -0.10434379f, -1.32025135f, 0.27148759f, 
    -0.41822371f, 0.48991814f, 1.30757999f, -0.36435062f, 0.32714766f, 0.29476371f, 0.67033231f, 0.98517007f, 
    -0.20969738f, 0.72882611f, 0.49974340f, -1.21533358f, 0.60589027f, 0.11982726f, -0.36563367f, -0.48519003f, 
    -0.60186929f, -0.69547236f, -0.68784946f, 0.55219269f, -0.45813394f, 0.48190233f, -0.64532751f, 0.01996744f, 
    -0.70823580f, -0.77968067f, -0.57621717f, -0.69525725f, -0.12039845f, 1.33603728f, -0.13751900f, -0.09580724f, 
    -0.40690285f, -0.41571268f, -0.73395336f, -1.00539625f, -0.88877177f, 0.60072142f, -0.58238727f, -0.04796666f, 
    -0.20172632f, -0.21706049f, -0.07628401f, -1.43326986f, 0.96401411f, -0.81816369f, -0.40506589f, 0.59734684f, 
    0.62121218f, 0.12161297f, -0.46138898f, 0.25826517f, 1.00137484f, 0.58915418f, -1.01425707f, -0.55257750f, 
    0.64980024f, 0.41637558f, 0.16364533f, 0.46353054f, 0.63420469f, -0.29429749f, -0.90772665f, -0.55854487f, 
    -0.37712944f, -0.52871644f, -0.00319997f, 0.92685652f, -0.19376577f, -0.91805404f, -1.35762942f, -0.14273985f, 
    1.04199350f, 0.70054716f, 0.43211126f, 0.67933500f, 0.25880286f, -0.19378659f, -0.17330121f, -0.67132139f, 
    -0.64039272f, -0.18567523f, 0.54908204f, 0.50393498f, 1.39472878f, -0.30498880f, -0.65042138f, 0.03332650f, 
    -0.88673860f, -0.82245839f, -1.05356300f, -0.65782470f, -0.49510121f, 0.32680315f, -0.08700615f, 0.76525402f, 
    0.67469823f, -1.44799554f, 1.08973920f, 0.17262754f, 0.49611086f, 0.92376965f, 0.04776154f, -0.55584389f, 
    -0.37208220f, -0.30582389f, 0.94045198f, 0.78470838f, 0.60096151f, 0.69661540f, 0.42454004f, -0.40195155f, 
    -0.26329553f, -0.71636403f, 0.38718164f, -0.06610887f, 1.08882487f, 1.34767497f, -0.05403109f, -0.56937176f, 
    -0.01692170f, -0.48751152f, -0.08293334f, 0.02460000f, -1.07553983f, -0.96356618f, 0.30994233f, 1.08472121f, 
    0.96859062f, 0.46429017f, -0.00117914f, -0.33632216f, 0.16725495f, -1.09371889f, -0.75197035f, 0.92151260f, 
    -0.38265038f, -0.73366016f, -0.79161483f, -0.60115981f, -0.70189595f, -0.66120821f, 0.38687569f, -0.59838605f, 
    0.04191630f, 0.25906116f, 0.37939921f, 0.60961908f, 0.64254308f, -0.44381243f, 0.91554594f, 1.29925990f, 
    0.76991457f, 0.92880422f, 0.76407081f, 0.46405390f, -0.81045967f, 0.63951111f, 0.69078964f, -0.46434784f, 
    1.34583962f, 1.21827698f, -0.02288416f, -0.55427128f, -0.87359118f, -0.36285698f, 0.55989301f, 0.01149849f, 
    -0.11385349f, 0.79127097f, 0.74322647f, 0.82455516f, 0.66735560f, 0.66951686f, 1.04577327f, -0.64325553f, 
    0.36475831f, 0.30805928f, -0.77757704f, 0.64595687f, 0.27808535f, -1.50793970f, -0.82539696f, -0.14323193f, 
    0.47706294f, 0.45609692f, -0.43649915f, 0.74255341f, -1.23358488f, 0.52437210f, -0.91073942f, -0.36108738f, 
    1.06896329f, 0.23843998f, -0.10230200f, 0.23510267f, 0.63029629f, -0.89805019f, -0.43272093f, -1.11570477f, 
    -0.54643053f, -0.93027973f, 0.10127828f, 0.63589960f, 0.67795575f, -0.12594377f, 1.04870701f, -0.58892643f, 
    -0.37357455f, -1.28923273f, -0.22297890f, -0.22678788f, -0.08674061f, 0.34926698f, -0.48279658f, 0.54193085f, 
    0.56603366f, -0.38983586f, -0.67878443f, -1.27597392f, 0.16538088f, -0.30685514f, -0.12525122f, 0.96287906f, 
    0.99839592f, 0.21063499f, -0.92931408f, 0.63770467f, -0.29781127f, 0.36443549f, 0.18783225f, -0.23835015f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.15623449f, 0.09114224f, -0.31383628f, 0.18465933f, 0.02474543f, 0.16899787f, 0.23042299f, 0.40434003f, 
    -0.39108500f, -0.00362089f, -0.32860914f, 0.39917767f, 0.09687968f, 0.32459033f, 0.22877881f, -0.00863579f, 
    -0.04939684f, -0.13204637f, 0.55368775f, 0.26579341f, 0.16427012f, 0.15037753f, 0.10316592f, 0.02655313f, 
    -0.18277487f, 0.27347913f, 0.16511095f, -0.11222488f, 0.34756887f, 0.02236760f, 0.33607861f, 0.21675208f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.44912332f, -0.26896077f, -0.41622156f, 0.03345655f, 0.01847017f, 0.08291133f, 0.04575766f, 0.17585695f, 
    -0.02961406f, -0.54845679f, 0.03413331f, 0.36990592f, -0.16542435f, -0.00085119f, -0.08252770f, 0.03012267f, 
    0.24987331f, 0.10589302f, 0.64690739f, 0.15753923f, -0.27295098f, -0.21805754f, 0.11669481f, -0.04225091f, 
    -0.07952419f, 0.03050171f, 0.09982616f, -0.10227579f, -0.02025085f, 0.06777891f, -0.09094937f, -0.16908118f, 
    0.20047940f, 0.06522550f, -0.00109139f, 0.05058122f, -0.15020582f, 0.19720241f, -0.19318701f, -0.04179533f, 
    0.00737277f, 0.04385892f, -0.22154598f, -0.01185632f, 0.09750655f, -0.19494276f, -0.15338746f, -0.06705553f, 
    0.15701044f, 0.00670069f, -0.10991155f, 0.03811683f, 0.26972994f, 0.09662447f, 0.66151983f, -0.41916901f, 
    0.18660691f, 0.08706712f, 0.15896581f, -0.11223439f, -0.08773569f, -0.09015193f, -0.25231904f, 0.29954803f, 
    0.05263079f, -0.12626061f, -0.08487874f, -0.10412693f, 0.21866511f, -0.17225239f, 0.04018250f, 0.10440370f, 
    0.10971092f, 0.35502133f, -0.18870813f, 0.03782886f, 0.03888799f, -0.01454573f, 0.10559260f, 0.13659623f, 
    -0.01243291f, 0.13600606f, -0.05512597f, -0.33017859f, 0.20312394f, 0.17925130f, -0.02713063f, -0.13366193f, 
    -0.00999060f, -0.01571663f, -0.26554617f, 0.02997341f, -0.35847002f, 0.11192158f, 0.24715713f, -0.01549805f, 
    0.08452797f, 0.08253870f, -0.02119269f, 0.42114314f, -0.44652528f, -0.07835811f, -0.20707293f, -0.03247632f, 
    0.12533925f, -0.09828157f, 0.08988390f, -0.19982585f, -0.42064139f, 0.01967842f, 0.27970448f, 0.04676288f, 
    -0.18523684f, -0.07984833f, -0.05906873f, -0.07761163f, -0.10662810f, -0.00691901f, -0.01518229f, -0.02348770f, 
    -0.01868575f, 0.18487558f, 0.00613030f, 0.37250829f, 0.04925856f, 0.15868397f, -0.15994592f, -0.14707893f, 
    0.13852398f, 0.16131260f, -0.08939243f, 0.03440434f, 0.09390453f, 0.00060974f, 0.08304395f, 0.30703905f, 
    0.19718821f, -0.57540333f, 0.35315669f, 0.04636853f, 0.11574665f, -0.13894199f, 0.02032253f, 0.04833800f, 
    -0.91595072f, -0.25978658f, -0.35242128f, -0.02610821f, 0.07876043f, -0.09363180f, -0.16444650f, 0.09075301f, 
    0.06541108f, 0.65378875f, -0.40703544f, 0.05563171f, -0.27586174f, 0.00977186f, 0.08394343f, -0.02917229f, 
    -0.00130440f, -0.25085491f, -0.21993928f, 0.04624650f, 0.08783644f, 0.08237084f, -0.01078802f, 0.10164434f, 
    0.14539760f, 0.11878122f, -0.21343587f, -0.06734244f, 0.11925571f, 0.00130742f, -0.00769488f, -0.02440843f, 
    -0.25789374f, -0.00549168f, -0.02634146f, -0.27765885f, 0.16459875f, 0.06966339f, -0.10248339f, 0.29028413f, 
    0.01989134f, 0.12062722f, -0.01268604f, -0.07049241f, -0.04492529f, -0.13793667f, 0.19903351f, 0.07814405f, 
    0.00940579f, -0.09139264f, 0.04426594f, 0.01410751f, 0.15365994f, 0.06189773f, -0.28936085f, -0.10027099f, 
    -0.07347122f, 0.09569591f, 0.06623802f, -0.14009088f, -0.13929343f, -0.02316978f, -0.35422400f, 0.17685464f, 
    0.26753241f, -0.03721713f, 0.00860282f, 0.18469022f, -0.01464031f, 0.00658657f, 0.26604548f, 0.12209725f, 
    0.38139102f, 0.31771922f, 0.17799899f, 0.05665692f, -0.22801551f, 0.18532683f, -0.11536034f, 0.13882849f, 
    0.09500279f, -0.31899846f, -0.11515321f, 0.06925593f, 0.13911848f, 0.22817580f, -0.13901618f, -0.02791562f, 
    0.03098606f, -0.13582498f, -0.07162232f, -0.26793781f, 0.09019075f, -0.05338404f, 0.13362764f, 0.01757570f, 
    0.08772787f, 0.05196966f, 0.24685103f, 0.62424362f, -0.19077213f, -0.34834996f, -0.13500789f, 0.03762769f, 
    -0.12869623f, 0.01057110f, 0.09781336f, 0.11039330f, 0.10651202f, 0.14460655f, -0.36994046f, 0.16412982f, 
    0.06611191f, -0.05204467f, -0.23567092f, -0.04565198f, -0.19889721f, 0.09740663f, -0.06250611f, 0.01177637f, 
    0.06000164f, -0.00793276f, 0.00026181f, -0.01061510f, 0.03252441f, 0.09293035f, -0.03526160f, 0.10212629f, 
    -0.00138812f, 0.01429638f, -0.07295315f, 0.00838708f, -0.04869581f, 0.14658988f, 0.04720633f, 0.03616423f, 
    0.20222163f, 0.07140710f, -0.03998215f, 0.02495746f, -0.05317464f, -0.11386921f, -0.08321698f, 0.09553860f, 
    -0.23684834f, 0.14680681f, 0.53114879f, -0.01872487f, -0.04909243f, 0.07227027f, -0.00187407f, 0.16329287f, 
    0.10338183f, -0.71423572f, -0.35692218f, -0.69770551f, -0.07435448f, -0.08023755f, -0.13895154f, 0.01664407f, 
    -0.03105306f, 0.02888757f, -0.07880763f, -0.05163490f, -0.00038390f, 0.16527295f, -0.03740079f, 0.05288398f, 
    -0.08255922f, 0.24852832f, 0.07916745f, 0.07383942f, -0.14516349f, -1.14583051f, 0.17850149f, -0.15551536f, 
    0.02833796f, -0.00251004f, 0.18439737f, -0.09957884f, -0.09838820f, 0.26046982f, -0.16091110f, -0.09724679f, 
    0.10069415f, -0.12920994f, -0.03678098f, 0.07579669f, -0.10233124f, -0.25022808f, 0.19824724f, -0.25028050f, 
    -0.03150352f, 0.12146603f, -0.08728898f, -0.11155717f, -0.26766917f, -0.04417762f, -0.15168689f, -0.11342206f, 
    -0.14723425f, 0.11120947f, -0.16410971f, 0.02498095f, -0.00842963f, 0.04534265f, 0.08214141f, 0.14182016f, 
    0.39000237f, -0.20774555f, 0.14097737f, 0.00333405f, 0.00414426f, 0.18877539f, 0.02815000f, -0.18187223f, 
    -0.06055635f, -0.15928067f, 0.07730068f, -0.00747892f, 0.04159875f, 0.04680836f, 0.29586110f, 0.00510669f, 
    -0.10778895f, -0.33815786f, 0.09104050f, 0.13109887f, -0.06530644f, 0.10542812f, 0.06955106f, 0.18865880f, 
    -0.27782905f, 0.00425805f, 0.07777439f, 0.08638976f, 0.21430728f, -0.06046261f, -0.03008107f, 0.15749088f, 
    0.17926866f, 0.04205703f, -0.03790097f, 0.22288641f, -0.01903508f, -0.02944843f, 0.02225440f, -0.02158454f, 
    0.05859969f, -0.02385476f, -0.02490196f, 0.05339387f, 0.35683045f, 0.15523629f, -0.32228449f, -0.16143063f, 
    -0.03564487f, 0.03957818f, -0.10538895f, 0.00750032f, -0.13073647f, -0.21224336f, -0.06074287f, 0.22358288f, 
    -0.10510445f, 0.04479154f, 0.07475971f, 0.02514548f, 0.06428213f, 0.29196733f, 0.33435425f, -0.09263363f, 
    0.27061486f, 0.12698019f, 0.03714148f, 0.05836647f, 0.00512538f, 0.08495352f, -0.06437783f, 0.28518891f, 
    -0.09006368f, 0.40567869f, -0.21814805f, -0.10481793f, 0.08140194f, -0.05143427f, 0.17482002f, -0.14413692f, 
    -0.31176525f, 0.15060245f, 0.13939258f, -0.13621795f, -0.09645937f, -0.05006054f, 0.01492744f, 0.10815677f, 
    -0.00800580f, 0.20594838f, 0.23706461f, -0.17145209f, 0.13654843f, -0.04133803f, -0.09192368f, 0.18247578f, 
    0.10479321f, -0.18163046f, -0.05997062f, 0.14555748f, 0.19667090f, -0.10741364f, -0.00093496f, -0.02839898f, 
    0.13863237f, 0.02646933f, 0.07995381f, 0.03701109f, -0.14154436f, 0.46956432f, 0.30670726f, 0.13631554f, 
    0.01646368f, -0.02724373f, -0.15754125f, -0.00256503f, 0.17751038f, -0.05766750f, 0.28991419f, 0.02049919f, 
    0.02396455f, -0.05357274f, 0.02237273f, 0.04673075f, 0.05987233f, -0.51504213f, -0.55159694f, 0.12480993f, 
    0.06583343f, -0.06719948f, 0.10353453f, -0.00870692f, 0.00095178f, 0.27446815f, 0.05182088f, -0.04289200f, 
    -0.23388417f, 0.01454895f, -0.02287240f, 0.12199033f, 0.03579228f, 0.07161972f, -0.18987978f, 0.11261208f, 
    0.31577200f, 0.20036462f, 0.18734428f, -0.09699630f, -0.00750327f, -0.07323639f, -0.12775034f, 0.12716837f, 
    -0.33280835f, -0.01141972f, 0.04830739f, -0.05067571f, -0.07744827f, -0.06719658f, 0.08343640f, 0.19975023f, 
    0.08310703f, 0.35568014f, 0.04199780f, 0.41287482f, -0.06887884f, -0.00155788f, -0.09101248f, 0.12526241f, 
    0.32691258f, 0.01914897f, -0.11868947f, -0.51347172f, -0.48649812f, 0.10131758f, 0.16296501f, -0.23255181f, 
    0.12468243f, -0.00269319f, 0.09385458f, -0.29336762f, -0.05570420f, -0.03897755f, 0.00891546f, -0.04479364f, 
    0.05856670f, 0.06581581f, 0.07025605f, 0.03389046f, -0.25342840f, 0.15927099f, -0.21532767f, 0.04573344f, 
    0.18155672f, -0.03581313f, -0.08050051f, 0.00375960f, -0.02924089f, -0.44722030f, 0.00802447f, -0.73415715f, 
    -0.00002931f, 0.18469287f, -0.04832464f, -0.10325940f, 0.20279613f, -0.06070300f, -0.46937251f, -0.23231010f, 
    0.00151439f, 0.12986411f, -0.06090948f, -0.20243283f, 0.06242162f, 0.02172666f, 0.00775432f, 0.18030196f, 
    0.07013988f, -0.28235716f, 0.02386641f, 0.06020411f, 0.07774825f, 0.06270596f, -0.09694719f, -0.00268209f, 
    0.14256841f, -0.15629081f, -0.12217585f, -0.10304710f, 0.05600134f, 0.05065585f, 0.22516392f, -0.13459530f, 
    0.00655396f, -0.13992590f, 0.19615927f, 0.03375665f, -0.19372670f, -0.05016034f, -0.01660063f, -0.06737822f, 
    -0.05546269f, 0.15917270f, 0.00780044f, -0.41429263f, 0.28587326f, 0.12452867f, -0.31279001f, -0.10880320f, 
    0.06894915f, 0.06454736f, 0.15513688f, -0.19150724f, 0.17991680f, 0.00092820f, -0.07355635f, -0.03754126f, 
    -0.12790674f, -0.02188227f, -0.15147203f, 0.08469521f, -0.12893234f, 0.26250920f, -0.10711209f, -0.07809880f, 
    0.09284936f, -0.23104170f, -0.23932873f, -0.01513558f, -0.07253847f, -0.08166052f, 0.00028604f, 0.30277389f, 
    -0.00313826f, -0.04518586f, -0.03787572f, 0.03270973f, 0.01251882f, 0.03272195f, 0.19780569f, 0.33224231f, 
    -0.26255065f, 0.07259485f, -0.05440987f, 0.09224226f, 0.20923565f, -0.11218499f, -0.02402033f, -0.03858593f, 
    -0.25882730f, -0.02154739f, -0.03591313f, 0.13371429f, 0.03258685f, 0.09521674f, -0.03570787f, 0.04211048f, 
    -0.02500623f, -0.20626883f, -0.27166200f, -0.03794046f, 0.15035525f, 0.34253567f, -0.31359017f, -0.09427839f, 
    0.23972911f, 0.25593054f, 0.23113278f, -0.19326061f, 0.00410720f, 0.08667154f, 0.31943661f, -0.15902185f, 
    -0.02963858f, 0.23988013f, -0.17485215f, -0.34239015f, -0.16226137f, 0.19269058f, -0.12398709f, 0.10243465f, 
    0.08174548f, -0.10986960f, -0.00206223f, 0.21332876f, -0.04772856f, -0.06757867f, -0.01418809f, -0.13579641f, 
    0.00937308f, -0.07688474f, 0.13343365f, -0.06499080f, -0.32892004f, -0.13289383f, -0.07325910f, -0.00263183f, 
    -0.13246538f, 0.04776856f, -0.08597600f, -0.39667925f, -0.13977407f, -0.27519700f, -0.10910389f, 0.25131726f, 
    0.16671711f, -0.01843801f, -0.01937146f, -0.14954159f, 0.16011687f, -0.20087759f, -0.06410158f, 0.28235438f, 
    0.18706070f, -0.30381462f, 0.13968104f, 0.06808689f, -0.09332962f, 0.21378995f, -0.02462218f, 0.15868410f, 
    -0.06989498f, -0.17378275f, -0.06826515f, 0.04953787f, 0.05663759f, -0.05022410f, 0.19336772f, 0.13632695f, 
    -0.15123972f, -0.37647042f, -0.12461295f, 0.04605747f, 0.06319697f, 0.16908823f, 0.21652077f, -0.22661515f, 
    0.03917756f, 0.31152365f, 0.40461460f, 0.27362147f, -0.23921974f, -0.13655359f, -0.00477037f, -0.12356292f, 
    0.06686692f, 0.17554052f, 0.08122140f, 0.03017291f, 0.04173397f, -0.33609363f, -0.08676226f, 0.19356786f, 
    0.11088030f, -0.01626591f, 0.11147807f, 0.01750124f, 0.01729762f, 0.46631339f, -0.26357177f, 0.02779859f, 
    0.14615311f, 0.22077695f, 0.08277456f, -0.04647003f, 0.16219504f, 0.15714730f, 0.02299756f, -0.11506386f, 
    0.10713132f, 0.08046749f, 0.10463744f, 0.12081359f, 0.05131977f, -0.10293898f, -0.13346514f, 0.14172809f, 
    0.19194889f, -0.19762856f, 0.07219191f, 0.05342630f, -0.07787568f, 0.11263712f, 0.13102962f, -0.44726264f, 
    0.02125008f, -0.06998130f, 0.14972061f, -0.04790306f, -0.17965598f, -0.29869348f, -0.16101722f, 0.26176265f, 
    0.16796716f, -0.15782288f, -0.27741635f, 0.18743163f, 0.06803831f, 0.24741848f, 0.03336743f, 0.09390359f, 
    -0.06874597f, 0.33364469f, 0.17986190f, -0.26834121f, -0.07477888f, 0.01250914f, -0.11045551f, 0.12824051f, 
    0.01001833f, 0.01161890f, -0.33343530f, -0.01447930f, 0.10089147f, -0.01921972f, 0.10135660f, 0.16968696f, 
    -0.08148813f, 0.00015150f, -0.10143168f, 0.02776109f, 0.07176241f, 0.10085600f, -0.08335792f, -0.11299825f, 
    -0.08639278f, 0.23506358f, -0.07238615f, -0.41213095f, -0.48042765f, -0.00977400f, -0.11466508f, -0.02417707f, 
    0.11949494f, 0.09863322f, -0.07730283f, 0.09576242f, -0.17128672f, -0.05773968f, 0.18398885f, 0.16537046f, 
    0.04489267f, 0.10618689f, -0.07638656f, -0.14928393f, 0.02451791f, -0.03684213f, 0.29051822f, -0.08486435f, 
    -0.06787517f, 0.18187334f, -0.08245204f, 0.02291706f, 0.03381442f, 0.02626730f, 0.12959878f, 0.01773439f, 
    0.02198380f, -0.06035402f, -0.06368848f, 0.14072381f, 0.18271330f, 0.12805718f, 0.03514317f, -0.11073063f, 
    0.21003346f, -0.10005253f, -0.14376105f, -0.02709743f, -0.00797197f, -0.05220775f, -0.16723917f, -0.11607148f, 
    0.10910124f, 0.11446656f, -0.20229425f, -0.05703130f, 0.02220128f, -0.09870838f, 0.10252867f, 0.20475255f, 
    0.18837069f, 0.19138297f, 0.04014323f, -0.11562054f, 0.03025124f, -0.02314769f, -0.13472986f, 0.07013973f, 
    0.15792318f, -0.08677386f, -0.00087130f, -0.29834470f, -0.19567579f, -0.27216357f, -0.04214029f, -0.10944106f, 
    0.00360316f, 0.22234525f, -0.11478002f, -0.16395733f, 0.10222103f, 0.11601198f, 0.01116916f, -0.03921892f, 
    -0.12805860f, -0.13053513f, 0.15737887f, -0.00245850f, 0.15669967f, -0.37479278f, 0.00127004f, 0.02174976f, 
    -0.03237758f, -0.04243924f, -0.19179834f, 0.10360035f, -0.00687474f, 0.00728909f, 0.02036612f, -0.06542987f, 
    -0.24929568f, 0.05945497f, 0.03465362f, -0.03746954f, 0.07398542f, -0.06308503f, -0.24820410f, 0.11811577f, 
    0.14593311f, 0.15307340f, 0.21836662f, -0.00299105f, 0.03730122f, -0.01234223f, 0.04661360f, -0.25048482f, 
    -0.33633935f, 0.06176475f, 0.14911735f, 0.35705784f, 0.23544766f, 0.32115006f, 0.16859199f, 0.07891993f, 
    -0.06251984f, 0.10773262f, -0.35281849f, 0.03681545f, 0.08477165f, 0.01535434f, -0.20328768f, -0.07640395f, 
    -0.03736844f, -0.19909987f, -0.19024138f, -0.20896594f, 0.01979359f, 0.10153249f, -0.05160676f, -0.00246222f, 
    0.00321762f, 0.05389600f, -0.04928837f, -0.17395908f, -0.27213767f, 0.04983644f, 0.12193792f, -0.02885763f, 
    0.12034748f, 0.03883336f, 0.03405124f, -0.12905130f, 0.17239071f, 0.00976133f, -0.21588793f, 0.06516612f, 
    0.17129242f, 0.15563551f, 0.04095105f, 0.15308034f, -0.10555261f, -0.25493813f, -0.12827185f, -0.02503915f, 
    0.04836917f, 0.00083990f, 0.17649044f, -0.16215576f, -0.00282353f, -0.05857962f, -0.05504750f, -0.34418184f, 
    -0.10871790f, -0.04544691f, -0.02233862f, -0.06446453f, 0.08225939f, 0.05567583f, -0.02036942f, 0.15401828f, 
    -0.15798877f, 0.28035772f, 0.05859818f, 0.30024439f, -0.01812824f, -0.03425126f, 0.15789628f, -0.05884491f, 
    -0.00779129f, 0.00483021f, 0.40287945f, 0.08211394f, 0.20240082f, 0.00658179f, -0.01836352f, 0.08642335f, 
    0.16510336f, 0.13127498f, -0.15678738f, -0.08586261f, -0.12054273f, 0.03854142f, -0.03084737f, 0.16552852f, 
    -0.00631211f, 0.03525850f, 0.03015401f, -0.03576805f, 0.03965772f, 0.04696483f, -0.01656397f, 0.13191374f, 
    -0.11226059f, 0.22061914f, -0.29144609f, 0.23154426f, 0.00387976f, 0.11598532f, 0.25117934f, -0.07571387f, 
    0.25638196f, -0.09308581f, 0.10842216f, -0.26792946f, -0.30683398f, -0.02245410f, 0.11125694f, 0.06634501f, 
    0.11875611f, 0.02494524f, 0.09941216f, 0.17773391f, -0.07272795f, 0.02600866f, -0.12153226f, 0.31040803f, 
    0.04313206f, -0.01628187f, -0.03644645f, 0.04669983f, 0.10892373f, 0.21800175f, -0.13894801f, -0.06333366f, 
    -0.24905249f, 0.01992824f, 0.12450971f, -0.11588908f, 0.02373804f, -0.01591115f, 0.16497758f, 0.06712040f, 
    0.21475363f, 0.23349418f, -0.01600283f, 0.08453971f, 0.12323654f, 0.03430653f, -0.10069860f, -0.72191334f, 
    0.08208550f, -0.10986105f, 0.14887287f, 0.14240164f, 0.01116044f, 0.37519160f, 0.21936586f, 0.05014359f, 
    0.08694286f, -0.20594566f, -0.12110434f, 0.00356031f, 0.15206769f, -0.38201883f, 0.09905632f, 0.02437186f, 
    -0.14307587f, -0.01361592f, 0.07986361f, 0.25926349f, 0.19793126f, 0.09079142f, 0.23490803f, 0.18938084f, 
    -0.01706062f, 0.24455310f, 0.27999163f, 0.13208380f, -0.07045199f, -0.44398874f, -0.01266990f, -0.03609413f, 
    -0.14234859f, 0.05713406f, 0.01891762f, -0.07244958f, -0.43801636f, -0.10814862f, -0.16646928f, -0.08890600f, 
    0.02722494f, 0.05584627f, 0.04701026f, 0.08427670f, 0.19504490f, 0.01823635f, 0.14247464f, -0.19009492f, 
    -0.18247797f, 0.12790929f, 0.17981249f, 0.04760955f, 0.03488861f, 0.13337971f, -0.25627351f, 0.06094125f, 
    -0.12919547f, 0.06848574f, 0.08223471f, -0.08391146f, 0.14248691f, -0.11870491f, 0.22942016f, 0.15824957f, 
    0.06447785f, 0.02610032f, -0.02203153f, -0.06536593f, -0.02470230f, -0.00266882f, 0.19055344f, -0.41103354f, 
    0.10504443f, -0.11121286f, 0.03854330f, 0.20950292f, -0.16421671f, 0.22075383f, 0.07477182f, 0.03323909f, 
    0.05488895f, 0.01850002f, 0.46507800f, -0.05244238f, -0.00775518f, 0.03959261f, 0.01619503f, -0.09309874f, 
    0.11490882f, -0.17352264f, -0.04135280f, -0.09031849f, -0.02181247f, -0.04157110f, -0.07178281f, 0.00331208f, 
    0.14529979f, 0.07819518f, 0.05547135f, -0.02361055f, 0.10455941f, 0.09649704f, 0.20476566f, 0.16432764f, 
    -0.18176502f, -0.16205457f, -0.00876910f, -0.02074248f, 0.23700918f, -0.19612081f, -0.15899995f, -0.10206552f, 
    0.22338061f, 0.03869991f, 0.08191524f, 0.13977478f, 0.25675035f, 0.17436293f, -0.09408448f, -0.15225291f, 
    0.00416494f, -0.14649223f, 0.12662245f, 0.00257659f, -0.03881941f, 0.37285498f, -0.05789622f, 0.02232120f, 
    0.05079918f, -0.02358942f, -0.01787921f, -0.06946620f, -0.13874567f, -0.04680399f, 0.00157352f, -0.29800963f, 
    0.07778511f, 0.05631452f, -0.00756477f, 0.12371026f, -0.15696430f, 0.08106182f, -0.02332002f, 0.28199610f, 
    0.10493708f, 0.09426249f, -0.12957750f, 0.14143436f, -0.00144934f, -0.29305375f, 0.01797753f, 0.03013909f, 
    -0.00101799f, -0.07526639f, 0.08924530f, 0.18441629f, 0.08078875f, -0.05161417f, -0.10214131f, -0.09011508f, 
    -0.00257721f, -0.11006501f, -0.28238690f, 0.18959856f, 0.19298816f, 0.20095848f, -0.34657359f, -0.10675243f, 
    0.08018871f, 0.00430339f, -0.12712935f, 0.12987088f, 0.21708918f, 0.06437128f, 0.11655861f, 0.04639922f, 
    -0.23214640f, -0.07779709f, 0.02027212f, -0.09042180f, -0.45923597f, 0.09596803f, 0.03214379f, 0.07246887f, 
    0.22000672f, -0.10500267f, -0.00615591f, 0.00737896f, 0.38107973f, 0.00842255f, 0.21410656f, -0.07692933f, 
    0.04563366f, 0.05435640f, 0.10329895f, 0.05389021f, -0.00892946f, -0.01910082f, 0.06409863f, -0.00335049f, 
    -0.01745887f, 0.10802200f, 0.15537900f, 0.04925012f, 0.00126126f, 0.03360407f, 0.24830535f, 0.03236993f, 
    0.05647819f, -0.02398574f, -0.07044765f, -0.06314310f, -0.07207597f, 0.06311084f, 0.00755143f, 0.14902490f, 
    -0.17200938f, 0.09257165f, 0.01491818f, 0.04800139f, 0.26967844f, -0.02648757f, 0.05091733f, 0.07139546f, 
    0.10027138f, 0.06568858f, 0.28480217f, -0.14858496f, -0.15320557f, 0.01345409f, -0.01550127f, -0.05018436f, 
    0.07519563f, -0.31356663f, -0.39047939f, -0.08420178f, -0.00985542f, -0.06046819f, 0.06027745f, -0.04813842f, 
    0.01749093f, 0.05444653f, 0.10709478f, 0.16524071f, -0.14350966f, -0.02063972f, -0.20459415f, -0.14159030f, 
    0.00369039f, -0.11118022f, 0.00925725f, -0.00467012f, 0.21575375f, -0.31238052f, -0.12607911f, -0.01112963f, 
    -0.08327067f, -0.19541381f, 0.01211285f, -0.01154913f, 0.21366662f, -0.00711801f, 0.12414390f, -0.06609557f, 
    0.07049823f, -0.05353909f, -0.22431502f, 0.21044822f, 0.07124561f, 0.04904786f, 0.08289782f, -0.22072361f, 
    -0.04884349f, 0.08185185f, 0.21758747f, -0.03403334f, -0.03506398f, 0.05507018f, 0.09070188f, -0.13910499f, 
    0.09676807f, -0.18898474f, 0.17796063f, 0.13543138f, -0.03137571f, -0.03336633f, -0.10116458f, -0.11007071f, 
    0.02216675f, -0.46432334f, -0.09663441f, 0.13288239f, 0.01478338f, -0.07101162f, 0.06395108f, 0.05404394f, 
    -0.01135551f, 0.26103371f, -0.04626354f, -0.11563236f, 0.15048584f, -0.11545184f, -0.18291892f, 0.13545504f, 
    -0.01093746f, 0.07864781f, 0.34031731f, -0.08525056f, -0.11315169f, 0.00296702f, -0.20896831f, 0.11833761f, 
    0.13189828f, -0.12795724f, -0.23859154f, -0.22612435f, -0.41937530f, 0.13307543f, -0.00304570f, -0.12453156f, 
    0.06465148f, 0.16292506f, -0.13310651f, 0.23902597f, 0.01462891f, 0.05884393f, 0.05434568f, 0.01351865f, 
    0.08149588f, -0.16855066f, 0.02454672f, 0.23962177f, 0.36279249f, 0.05421379f, -0.20653501f, 0.16175471f, 
    -0.05641188f, -0.16302633f, -0.16150153f, -0.20192908f, 0.00582407f, -0.06965917f, 0.11309804f, -0.07963103f, 
    -0.10436047f, 0.01687698f, -0.04566159f, 0.00359823f, 0.09732725f, -0.00043086f, -0.13681455f, 0.07409528f, 
    -0.35827950f, -0.15382014f, 0.03089376f, 0.11180234f, 0.06898076f, 0.02133933f, -0.09876978f, 0.00116466f, 
    -0.03860933f, 0.02880712f, -0.09626643f, -0.13748023f, -0.10713393f, -0.02168627f, 0.01867904f, 0.10662257f, 
    -0.05386393f, 0.09764237f, 0.31148300f, 0.31077355f, 0.00111109f, -0.15599377f, 0.23840274f, -0.10219686f, 
    0.09170961f, 0.11064067f, -0.05845524f, 0.12675172f, 0.04224295f, -0.02188977f, 0.08726285f, -0.01080976f, 
    0.07959276f, -0.04502280f, 0.20555742f, 0.27799556f, 0.14192154f, 0.15761842f, -0.08089428f, -0.02563145f, 
    0.12890628f, 0.13614804f, 0.23481767f, 0.08739555f, 0.07940052f, -0.25628927f, -0.00558749f, 0.04236715f, 
    -0.21714947f, -0.03551430f, 0.06305288f, -0.10141715f, 0.02096549f, 0.31771231f, 0.03163272f, 0.02343678f, 
    0.01128462f, -0.09641183f, 0.16175254f, -0.09591417f, -0.20630288f, 0.25482312f, -0.29559669f, 0.05454654f, 
    -0.05118448f, -0.30676827f, -0.11743420f, 0.14306086f, 0.07785949f, 0.04734328f, 0.08793148f, 0.19892950f, 
    -0.10140479f, 0.15118815f, 0.09763468f, 0.02313739f, 0.08270714f, -0.11957759f, 0.11411663f, 0.20251815f, 
    -0.12841260f, -0.35004392f, -0.01435050f, -0.27620581f, -0.05776014f, -0.09849122f, 0.02586647f, -0.08944102f, 
    0.32311198f, 0.21153420f, 0.37184262f, 0.15934412f, -0.02976360f, 0.24423450f, -0.27697727f, -0.09461343f, 
    0.19124731f, -0.04666614f, 0.10833240f, 0.18534997f, 0.12095247f, -0.10885508f, 0.02830810f, -0.18431416f, 
    0.05857929f, 0.20900172f, 0.29249448f, 0.09647885f, 0.29325336f, 0.01808091f, 0.01142688f, 0.11701520f, 
    0.13539542f, 0.09417958f, 0.03931396f, -0.27515474f, -0.07562472f, 0.12720574f, -0.03909088f, 0.05885819f, 
    0.07207058f, -0.05512268f, -0.12327859f, -0.11088628f, -0.12607722f, 0.15844409f, -0.01041654f, 0.09345637f, 
    0.26306424f, -0.10708605f, 0.09404367f, -0.14095952f, -0.11893346f, 0.09289293f, 0.27226231f, -0.04480776f, 
    0.06055997f, -0.04009871f, -0.08254831f, -0.30635345f, -0.01468521f, -0.18311355f, 0.07956969f, -0.25288704f, 
    -0.26080278f, 0.11861809f, -0.04572516f, 0.03941952f, -0.01340295f, 0.10550001f, 0.02758703f, -0.30463302f, 
    -0.04224459f, 0.10694511f, 0.10448698f, 0.00163522f, 0.01427467f, -0.09588981f, -0.10262603f, 0.00539513f, 
    -0.02703167f, 0.23391500f, 0.14779031f, 0.11956790f, 0.07049599f, 0.04624885f, 0.01715407f, -0.02097405f, 
    0.02370078f, -0.35459098f, 0.11154253f, -0.04598456f, 0.15564676f, 0.13407846f, 0.13998859f, -0.24850573f, 
    0.10939126f, 0.08620677f, 0.38737482f, -0.06255963f, 0.01326224f, 0.00882324f, 0.04707382f, 0.19589017f, 
    0.03508027f, -0.05141675f, -0.08258448f, 0.53287876f, -0.01056903f, 0.03924041f, -0.10685276f, 0.08656349f, 
    -0.12176725f, 0.11701540f, -0.08523276f, 0.10917067f, -0.53108793f, -0.12724298f, -0.05151053f, 0.06981377f, 
    0.12412570f, 0.12726095f, -0.14131969f, -0.08655901f, 0.19729590f, -0.19555114f, 0.05035937f, -0.09355929f, 
    -0.05917012f, 0.10291187f, 0.03717653f, 0.02422607f, -0.05792902f, 0.04683828f, 0.21317638f, -0.13808417f, 
    0.00656788f, 0.00583506f, -0.03801320f, -0.02719705f, -0.12384723f, -0.35193881f, -0.23892632f, 0.53914315f, 
    -0.34475091f, -0.03553781f, 0.11976230f, 0.01911974f, 0.02487366f, 0.16689788f, -0.01951965f, 0.19688241f, 
    0.34907529f, 0.45329601f, -0.07326984f, -0.02930404f, -0.12830167f, -0.18025656f, 0.04819311f, 0.30200183f, 
    0.06525709f, -0.11529952f, -0.08904766f, -0.22026655f, 0.17084971f, 0.03322750f, 0.01237351f, 0.19514106f, 
    -0.02385552f, 0.09292893f, -0.07930019f, -0.08922175f, -0.22033319f, -0.06411278f, -0.14809693f, 0.01407115f, 
    -0.01727563f, -0.02931322f, -0.05353808f, -0.13100845f, -0.06974323f, -0.37276378f, -0.05040386f, -0.01337103f, 
    -0.17776184f, 0.25090089f, -0.01732578f, -0.09759178f, 0.00223629f, -0.05562653f, -0.25757694f, -0.05779823f, 
    -0.22446717f, -0.00348395f, 0.09425088f, 0.05620283f, -0.24426116f, 0.08924562f, 0.14240432f, -0.04550232f, 
    0.00821789f, -0.03531222f, -0.03545948f, -0.09472196f, -0.00055843f, -0.17069225f, 0.13628861f, -0.14943311f, 
    -0.28281975f, -0.08523741f, 0.03411723f, 0.00769549f, 0.04235397f, -0.00564279f, -0.06064656f, 0.26587600f, 
    0.23678999f, -0.15088589f, -0.06389139f, -0.10137175f, -0.00177500f, 0.15612011f, 0.03386601f, 0.12189550f, 
    0.00425236f, 0.00135353f, -0.01797514f, -0.05844859f, 0.03952612f, -0.04488634f, -0.00623728f, -0.04939399f, 
    -0.02937163f, -0.01832192f, 0.04789567f, -0.04009862f, 0.01630065f, 0.04927653f, 0.02008480f, 0.00503249f, 
    0.00069508f, -0.02134272f, 0.04742257f, 0.00596353f, 0.00383906f, 0.04510104f, -0.00172853f, -0.03080280f, 
    0.05709657f, 0.00710064f, 0.02579168f, -0.02730379f, 0.04381337f, 0.02261855f, -0.06789693f, 0.03490495f, 
    -0.03189823f, 0.04224645f, 0.01358387f, -0.04281050f, -0.01451354f, 0.02609725f, -0.04328912f, 0.01392842f, 
    -0.05381448f, 0.03764386f, -0.04736447f, -0.06221335f, 0.02186397f, 0.02082828f, -0.00774372f, -0.03013883f, 
    0.02125219f, -0.02831665f, 0.04997139f, 0.01711892f, -0.06417130f, -0.04625804f, -0.01101211f, 0.01245062f, 
    0.00861450f, -0.05700656f, 0.01579818f, -0.00102764f, 0.00819044f, 0.00477759f, 0.04499985f, -0.03709524f, 
    0.05203948f, 0.05072084f, 0.03008484f, 0.01531039f, -0.04889799f, 0.01589841f, -0.00749818f, -0.02209656f, 
    -0.00294968f, 0.04411326f, -0.00683130f, -0.01657527f, -0.01507651f, 0.02242057f, -0.05193560f, -0.05453277f, 
    0.02785508f, 0.02131082f, -0.05973391f, 0.02237607f, -0.00294324f, -0.04643593f, -0.03899152f, 0.04208722f, 
    -0.01927713f, -0.04991912f, 0.05273903f, -0.05049265f, -0.02208813f, -0.03477666f, -0.05854470f, -0.01321830f, 
    0.00960772f, 0.04489745f, -0.05615286f, 0.03312227f, 0.00381184f, 0.00376194f, 0.02834946f, -0.02284110f, 
    -0.06145063f, 0.01375714f, -0.03150789f, -0.03998232f, 0.04479282f, -0.05487572f, -0.04953257f, 0.02313404f, 
    -0.04698393f, 0.02850640f, 0.03266717f, -0.00347994f, -0.00863304f, -0.05515187f, 0.03106441f, -0.03811284f, 
    0.05166405f, 0.02778185f, 0.02311401f, 0.05624263f, -0.04810425f, -0.04849428f, -0.05159922f, -0.04648834f, 
    0.03737615f, -0.01264080f, 0.00386218f, -0.02897607f, 0.00338482f, 0.02420275f, -0.02567118f, -0.00644708f, 
    0.02669919f, 0.04706287f, -0.02671617f, -0.03364910f, -0.02846847f, 0.02132083f, -0.03409114f, -0.02092847f, 
    0.02397118f, -0.04105172f, -0.05489265f, -0.06631467f, -0.04367790f, 0.02338935f, 0.01727123f, 0.04345657f, 
    -0.01696330f, -0.03494272f, 0.00876888f, 0.01398297f, 0.02280991f, 0.04753763f, -0.00451906f, -0.02568877f, 
    -0.04088674f, -0.02435930f, 0.04728026f, -0.03358673f, 0.03155340f, -0.03045373f, 0.05108127f, 0.01247259f, 
    -0.00193512f, 0.05071674f, -0.01289182f, -0.01552715f, -0.01343362f, 0.02562296f, -0.04585072f, -0.00492353f, 
    -0.00348205f, -0.04482011f, -0.03366396f, 0.03139771f, 0.03563476f, 0.00242595f, 0.04659957f, -0.01997655f, 
    -0.05563231f, 0.01869766f, -0.04235484f, 0.02344134f, -0.02437723f, 0.00239361f, 0.01080395f, 0.05330690f, 
    0.03535015f, 0.01276894f, -0.04682859f, -0.05108689f, -0.02682871f, 0.03532009f, 0.00984927f, 0.01179317f, 
    -0.06818499f, 0.01170838f, 0.00377748f, 0.00157131f, -0.01594642f, -0.03041570f, -0.02345944f, 0.01206999f, 
    -0.02208698f, -0.03935553f, -0.04022049f, 0.00420242f, 0.03450282f, -0.04898310f, 0.03963763f, -0.05436574f, 
    0.01739889f, 0.00377502f, 0.04584831f, -0.03247191f, -0.03443960f, 0.04888643f, 0.03241803f, 0.02424771f, 
    0.02441933f, 0.04136610f, -0.04354195f, 0.01553340f, 0.02863417f, 0.04083914f, -0.05219610f, -0.04750759f, 
    -0.05568203f, -0.01306904f, 0.00106374f, -0.02773371f, 0.02522075f, -0.01813171f, 0.03983587f, 0.02320272f, 
    0.00390377f, -0.03097232f, 0.02080725f, 0.02133315f, -0.01356594f, 0.04079242f, -0.00058947f, -0.03838262f, 
    -0.04797123f, -0.00943023f, -0.04691480f, 0.03230337f, -0.05123975f, -0.06191604f, -0.04099207f, 0.00260326f, 
    0.00658175f, -0.05647293f, -0.02473981f, -0.03499323f, 0.03090861f, 0.01117535f, -0.00097167f, 0.03092467f, 
    -0.04439913f, -0.05599722f, -0.01409769f, -0.00974738f, 0.01540554f, -0.06855381f, 0.04005328f, 0.02335484f, 
    -0.00444958f, -0.05974920f, 0.04164666f, -0.04285869f, 0.02695869f, -0.00851703f, -0.00518909f, -0.04726718f, 
    -0.04395350f, -0.04059692f, -0.00874217f, -0.04531001f, -0.00409207f, 0.00886067f, 0.02894906f, 0.04389248f, 
    -0.07622791f, 0.17015478f, -0.02143810f, 0.04315314f, 0.04665932f, -0.08795329f, -0.03699138f, 0.00065467f, 
    -0.12028684f, -0.20026490f, -0.29086801f, -0.24468291f, -0.05947558f, 0.10691620f, -0.03702962f, 0.28130963f, 
    0.03957865f, 0.03521118f, -0.23571655f, 0.12226434f, 0.12456383f, -0.12306283f, 0.07470050f, 0.16586289f, 
    0.22032213f, -0.20887072f, -0.06554089f, -0.05725582f, -0.15307984f, -0.12675667f, 0.10433156f, -0.07477611f, 
    -0.04310822f, -0.15371543f, -0.02434034f, 0.20112377f, -0.15718949f, 0.10927132f, 0.21257180f, -0.08139773f, 
    0.05949528f, -0.13967744f, -0.12346213f, 0.17967626f, 0.03697530f, 0.22980219f, -0.11268470f, -0.27079809f, 
    -0.07624285f, 0.02658405f, 0.03611330f, -0.16179967f, -0.13449273f, 0.07468273f, -0.04088228f, -0.02050157f, 
    -0.29798737f, 0.08468693f, 0.09983122f, -0.11776125f, 0.06975827f, -0.06873851f, -0.06896432f, -0.11120746f, 
    0.10722730f, 0.17870761f, 0.02952829f, -0.03142676f, 0.08518725f, -0.10436161f, 0.01135156f, 0.05093010f, 
    -0.18482853f, -0.07234734f, -0.16932645f, -0.01717448f, 0.05538137f, 0.11657260f, 0.08842371f, -0.17059821f, 
    0.09874142f, 0.04488167f, -0.25667316f, -0.12125650f, 0.12065446f, 0.08861391f, 0.18799663f, -0.06986097f, 
    -0.17737086f, 0.04403741f, -0.10068224f, 0.07271961f, -0.17203510f, 0.12029528f, 0.05849928f, 0.03298013f, 
    -0.01370173f, 0.03537849f, -0.34198600f, 0.25813055f, -0.19044162f, -0.29855120f, -0.02382515f, 0.01875210f, 
    0.21770810f, -0.10322543f, 0.04817131f, -0.03487580f, -0.40897033f, -0.22732782f, -0.17106929f, -0.01891918f, 
    -0.05429438f, -0.08189353f, -0.17156357f, 0.00957018f, 0.12207064f, 0.28155583f, 0.23896375f, -0.00487977f, 
    0.01893239f, -0.15198532f, 0.10651540f, 0.01555123f, 0.04679045f, 0.18044430f, 0.46858740f, -0.38806877f, 
    0.23507544f, 0.19110788f, 0.13255762f, 0.19001128f, -0.04865488f, -0.04950834f, -0.04564299f, 0.38070533f, 
    -0.36146590f, -0.14077349f, 0.17191787f, 0.12553656f, 0.19685061f, -0.03057673f, -0.06529672f, 0.08149882f, 
    -0.16793561f, 0.09982386f, -0.04789019f, 0.04621661f, 0.12479793f, -0.13211277f, 0.19000222f, -0.03771574f, 
    -0.25396830f, 0.47989339f, -0.22220263f, -0.19908363f, 0.08362065f, -0.03412761f, 0.12330032f, 0.02926314f, 
    -0.06262674f, -0.06739103f, 0.14920577f, 0.07332098f, 0.18571313f, 0.01310454f, 0.01133220f, -0.00244805f, 
    0.31595567f, 0.03194689f, 0.04860651f, 0.26322201f, 0.21434104f, 0.27932462f, -0.16997342f, -0.07586800f, 
    -0.24287644f, 0.05685712f, -0.06169101f, 0.01816240f, 0.39538825f, -0.37225547f, 0.03016877f, 0.16909418f, 
    0.06954564f, 0.21493095f, 0.16435114f, 0.11261357f, -0.04556995f, -0.04085763f, 0.06595856f, 0.13054273f, 
    0.05121160f, -0.07396048f, -0.30732489f, -0.06524531f, -0.05455789f, -0.06667965f, -0.04590751f, -0.42177781f, 
    -0.14361869f, -0.00997997f, -0.08851160f, -0.02692300f, -0.00116179f, 0.01088347f, 0.00989435f, -0.22158208f, 
    0.30021292f, -0.01285261f, 0.10409173f, -0.30873820f, 0.13931733f, 0.20752464f, 0.16488142f, 0.05982634f, 
    -0.36239344f, 0.24916482f, 0.22314142f, -0.18615253f, -0.18597634f, -0.34877479f, -0.00741997f, -0.06873842f, 
    0.01341842f, -0.06229248f, 0.05378489f, 0.23239985f, -0.00871305f, 0.11502339f, 0.17691016f, 0.19332132f, 
    0.07583517f, -0.18638538f, -0.26918697f, 0.08174088f, 0.01732429f, -0.07580935f, -0.08771898f, -0.01518556f, 
    0.00488640f, 0.04462831f, 0.16638836f, 0.06170670f, -0.33207366f, -0.04959501f, 0.05350817f, -0.06280283f, 
    -0.07725222f, 0.01047071f, 0.09935758f, 0.05793057f, -0.09820614f, 0.05962779f, -0.07273987f, 0.06271519f, 
    0.10349858f, 0.09372050f, -0.07814556f, -0.01518274f, -0.24782343f, -0.31037411f, 0.01303277f, 0.08376673f, 
    -0.17521448f, -0.00509404f, -0.12459175f, -0.16773936f, 0.13266033f, 0.10068258f, 0.05958704f, 0.30509156f, 
    0.19917321f, -0.05210803f, -0.14172997f, -0.23899363f, 0.06982226f, 0.03236451f, 0.23484810f, -0.19972628f, 
    0.29468364f, 0.22811277f, 0.01633796f, -0.07910910f, -0.04924783f, -0.05173519f, -0.08735953f, 0.09210616f, 
    -0.28944966f, -0.09119001f, -0.18454231f, 0.21046472f, 0.18817969f, 0.17212027f, -0.10777651f, -0.03484293f, 
    -0.01101224f, -0.27934793f, -0.05469885f, 0.07744861f, 0.00484216f, 0.12897258f, 0.02049925f, 0.06126394f, 
    0.01193559f, 0.06052141f, -0.35555074f, -0.01128099f, 0.20880201f, 0.17145325f, 0.16238646f, 0.14094004f, 
    -0.11629191f, 0.04507086f, -0.19576922f, -0.01182445f, -0.24787687f, 0.12783197f, -0.01824218f, 0.00776201f, 
    0.17266247f, -0.13541611f, 0.04383780f, -0.10922388f, 0.09793217f, 0.08833496f, 0.10756578f, -0.13937703f, 
    0.16015594f, -0.15392214f, 0.15419573f, 0.10685527f, 0.17368616f, -0.26463521f, -0.24698448f, -0.30757231f, 
    -0.02437697f, 0.18867832f, -0.17589159f, 0.05877043f, -0.00981824f, 0.16128837f, -0.52401018f, -0.06912698f, 
    -0.14899912f, -0.03334754f, 0.13578135f, -0.01424742f, 0.11055853f, -0.07071064f, 0.16299571f, -0.09000433f, 
    0.21128136f, 0.07938631f, -0.08181839f, 0.17958982f, 0.17548516f, 0.19543175f, 0.07296875f, -0.11800618f, 
    0.12047417f, -0.05176799f, -0.07216065f, 0.01811216f, 0.12828556f, -0.06329811f, 0.08655369f, -0.15517952f, 
    0.24049100f, -0.29323405f, -0.34703413f, -0.39044988f, 0.11347226f, 0.11577854f, 0.23567769f, -0.00137929f, 
    -0.11961249f, -0.19877142f, -0.14978379f, 0.28709126f, -0.17693037f, 0.06046238f, 0.06219509f, -0.05559149f, 
    0.16907957f, -0.01465398f, 0.12132141f, -0.10827862f, -0.08409247f, -0.35990563f, 0.16198830f, 0.09352433f, 
    0.10254321f, 0.00624754f, 0.02438184f, 0.06669832f, 0.10447680f, -0.10209236f, 0.11055113f, -0.16953129f, 
    -0.22238182f, -0.09022388f, -0.23235756f, -0.06957171f, -0.16825294f, -0.06341179f, -0.05380450f, -0.14294222f, 
    0.11741322f, 0.10663297f, 0.17280747f, 0.12869903f, 0.31972799f, 0.04324027f, -0.00140913f, -0.03378806f, 
    -0.18015991f, 0.01040157f, 0.12486409f, -0.01134964f, -0.05714134f, -0.14025724f, -0.02614000f, 0.08132767f, 
    0.08068223f, -0.19492860f, 0.19505802f, 0.05049617f, 0.17209688f, 0.16935658f, -0.34710404f, -0.05519174f, 
    -0.31107277f, -0.01654796f, -0.26559180f, 0.28242955f, 0.15760799f, -0.05193453f, -0.08485689f, -0.01924562f, 
    -0.08978138f, 0.00992753f, 0.08877205f, -0.20073077f, 0.06202816f, 0.14952308f, -0.15256327f, 0.17669365f, 
    0.01247754f, 0.08889546f, 0.09133191f, 0.21966547f, 0.20751160f, 0.13251723f, 0.20627911f, -0.05007449f, 
    0.09905311f, 0.19716366f, -0.02135056f, 0.31056321f, 0.05410665f, 0.16986878f, 0.01431265f, 0.19427148f, 
    0.13784997f, 0.08983397f, 0.02491534f, -0.08346017f, -0.17589854f, -0.12056791f, -0.47583377f, 0.04193924f, 
    0.10076202f, 0.03911442f, 0.04524933f, -0.00643161f, -0.07027119f, 0.00823123f, -0.23717697f, -0.05139218f, 
    0.12149846f, -0.04455267f, -0.08998309f, 0.03031960f, 0.13153574f, 0.07009622f, -0.01852044f, -0.07060979f, 
    -0.27415612f, -0.12728035f, -0.14338890f, -0.11751087f, -0.10106243f, -0.12370698f, 0.04510817f, -0.04924481f, 
    -0.02098334f, 0.33974141f, -0.10900546f, 0.06599506f, -0.01381610f, 0.04112106f, -0.14699300f, -0.13740796f, 
    -0.06865779f, -0.16454105f, 0.09505790f, -0.24371427f, -0.13504067f, -0.16641420f, -0.05547567f, -0.09742261f, 
    -0.00319778f, 0.25341260f, 0.35421351f, 0.27991965f, 0.02866814f, -0.10070895f, 0.13303524f, 0.01843684f, 
    0.06013626f, -0.10339998f, 0.13120809f, -0.15286505f, -0.13159351f, 0.10116961f, 0.14457619f, 0.00596655f, 
    0.06109288f, 0.12822537f, -0.05944668f, -0.37581262f, -0.27279678f, -0.18920520f, -0.23461981f, -0.05189601f, 
    0.05683743f, -0.03457816f, -0.12128618f, 0.01846729f, -0.03075831f, -0.07487477f, -0.01738306f, -0.00996886f, 
    0.18362947f, 0.10357139f, 0.07564633f, 0.24784362f, 0.08749286f, -0.21863438f, 0.00745422f, 0.10770530f, 
    -0.19430855f, -0.02820094f, 0.10649012f, -0.17968629f, 0.12493537f, 0.04602769f, 0.15265946f, 0.07923592f, 
    0.16332741f, 0.17810541f, 0.03304959f, 0.03698536f, -0.09764266f, 0.21183823f, 0.23470962f, 0.20290472f, 
    0.14192438f, 0.22436494f, -0.01629103f, -0.00610116f, 0.02793750f, 0.03414990f, 0.02907430f, -0.04473464f, 
    -0.03645712f, -0.05518530f, 0.00527471f, 0.04511638f, -0.06101051f, 0.05601968f, -0.04034673f, 0.05283551f, 
    0.02861689f, -0.04844303f, -0.01041810f, 0.00760458f, 0.02315640f, -0.01324515f, 0.04407208f, 0.02832402f, 
    -0.02687614f, 0.03552451f, -0.00556189f, -0.00619178f, -0.04510350f, 0.03090669f, -0.03105079f, -0.04562425f, 
    0.04251598f, 0.01130167f, -0.02051686f, -0.01178134f, 0.02111138f, 0.00240419f, -0.03460560f, -0.02866535f, 
    -0.00696536f, 0.00222625f, -0.04348768f, -0.00772222f, -0.00154857f, 0.03616210f, -0.03159929f, 0.04834190f, 
    0.00066621f, -0.01648076f, 0.03898942f, -0.04400478f, -0.01594258f, -0.02415437f, 0.02681251f, -0.05095640f, 
    -0.02517664f, 0.05549521f, -0.05181093f, 0.01751959f, 0.02877195f, -0.02013559f, -0.00989426f, -0.02197620f, 
    0.02591761f, -0.02548127f, 0.03145558f, -0.00994561f, 0.02132267f, -0.04725856f, 0.05421615f, -0.02066488f, 
    -0.02606782f, -0.02956264f, -0.00849541f, 0.01519629f, 0.00215275f, -0.05572359f, 0.04587637f, 0.03327883f, 
    0.05305168f, 0.01995338f, 0.04611479f, -0.02627962f, -0.06410629f, 0.00053643f, -0.03532783f, 0.01760179f, 
    0.02156579f, 0.06646341f, 0.04046211f, -0.02913336f, 0.01691441f, -0.05006841f, -0.04502356f, -0.05720506f, 
    0.00066355f, 0.00382502f, 0.01655586f, -0.03744817f, -0.06269804f, 0.00370633f, -0.00482918f, 0.01801215f, 
    0.01873748f, -0.05641308f, -0.04335829f, -0.00671773f, -0.00466383f, -0.05781787f, 0.01538744f, -0.05777644f, 
    -0.00579974f, 0.00680984f, -0.03449593f, 0.01160228f, -0.01405997f, 0.05085845f, -0.05284431f, -0.06050401f, 
    0.03095338f, 0.04031803f, 0.04711532f, -0.00855437f, -0.04060319f, 0.05173490f, -0.00761802f, -0.02105575f, 
    -0.03318951f, 0.03754148f, -0.05324061f, 0.03036156f, 0.02932471f, -0.02264925f, -0.05655014f, 0.03810704f, 
    -0.01099787f, 0.03017651f, 0.02418700f, -0.03394040f, 0.05299228f, -0.05707080f, -0.00855007f, -0.01123531f, 
    0.01120193f, 0.01762602f, 0.03534565f, 0.00149948f, 0.03409728f, -0.06753716f, -0.05117999f, 0.05017606f, 
    0.00745878f, -0.02270567f, 0.02779370f, 0.00024120f, -0.01286243f, -0.04006318f, 0.01266940f, 0.01345030f, 
    0.03688201f, 0.05204224f, -0.05212390f, -0.04696731f, -0.01946806f, 0.01345427f, -0.03211338f, -0.03011143f, 
    -0.04869657f, -0.03818968f, -0.00464508f, -0.02625100f, 0.03459880f, -0.02253768f, -0.03724591f, -0.02460191f, 
    -0.04882833f, -0.04100236f, -0.02508139f, -0.01339648f, -0.01358578f, 0.02331096f, -0.02617461f, -0.05430645f, 
    -0.00424621f, 0.04128686f, -0.02885558f, -0.04005158f, -0.01107791f, 0.03235875f, 0.02355126f, 0.03007100f, 
    -0.03193464f, 0.03328920f, 0.02691503f, -0.03890960f, -0.01245093f, 0.01860973f, -0.04644093f, -0.02720625f, 
    0.04900904f, 0.04749217f, -0.00493789f, -0.05712454f, -0.04599105f, -0.01781867f, 0.01203439f, 0.01698490f, 
    -0.04912444f, -0.04147075f, -0.02774567f, 0.04084132f, -0.00808138f, -0.00065518f, -0.00017760f, -0.03655547f, 
    0.04267841f, -0.02952597f, 0.04519945f, 0.05312816f, 0.01510216f, 0.02215045f, 0.02660839f, -0.04493890f, 
    0.01132820f, -0.02937625f, -0.04457220f, 0.00474934f, 0.04664550f, -0.03598424f, 0.00381711f, -0.00887180f, 
    -0.02031387f, 0.00669160f, -0.02637237f, 0.03006950f, -0.02645020f, -0.03772042f, 0.03360400f, -0.04094600f, 
    -0.04070161f, 0.02426388f, -0.01708675f, -0.03011701f, -0.02348629f, -0.05650623f, -0.03492210f, -0.01558908f, 
    -0.05263866f, 0.00210814f, 0.00397956f, -0.02867627f, -0.04926215f, 0.01426275f, 0.03198906f, -0.02995909f, 
    -0.00065351f, 0.05423445f, -0.00171101f, -0.05640196f, 0.01287338f, -0.05147281f, 0.05299534f, -0.02966836f, 
    0.02003026f, -0.03329925f, -0.02936418f, 0.05195796f, -0.05636783f, -0.00206752f, 0.02913228f, -0.03377248f, 
    -0.00699313f, -0.03545525f, -0.04574948f, -0.05296378f, 0.05587823f, 0.00483952f, -0.03124886f, -0.04416439f, 
    0.04216713f, 0.05020821f, -0.00800238f, 0.05092846f, 0.05563551f, 0.05247277f, -0.01463674f, 0.00926496f, 
    -0.03798006f, -0.03931180f, -0.04154396f, -0.03511966f, 0.04819098f, -0.01979239f, -0.00761871f, -0.04845391f, 
    -0.03877028f, 0.01450256f, -0.01531299f, -0.04944905f, -0.05971491f, -0.01368916f, -0.06117231f, 0.03922387f, 
    -0.04259810f, -0.03779519f, 0.02647417f, -0.00062756f, -0.02887958f, 0.02887316f, -0.04331797f, -0.03380017f, 
    -0.03207777f, -0.04138820f, -0.04312361f, -0.01244838f, 0.01249593f, -0.03963520f, -0.05840369f, 0.04448090f, 
    -0.01585168f, -0.05755964f, -0.01510716f, 0.00267930f, -0.00586034f, -0.04533048f, -0.05517571f, -0.05446560f, 
    0.04019191f, 0.03347526f, -0.01022553f, 0.04233631f, -0.00234065f, 0.00081365f, -0.05738804f, -0.05509934f, 
    0.03964620f, -0.02311880f, 0.00956318f, 0.05232592f, -0.04931828f, -0.00281594f, -0.02105358f, 0.02592992f, 
    0.04605567f, -0.05447733f, -0.03973758f, 0.05583416f, 0.04500061f, -0.02699346f, -0.01373787f, 0.02204426f, 
    -0.04767226f, 0.01944935f, 0.03577700f, 0.03354195f, -0.04512588f, 0.03129370f, -0.03208150f, 0.03116824f, 
    -0.00852511f, -0.01751420f, 0.03258822f, -0.00097200f, -0.06095289f, -0.02481999f, -0.02174550f, -0.00752893f, 
    -0.03277306f, -0.04513517f, -0.01652266f, -0.05238064f, -0.03829382f, 0.04856718f, -0.00194726f, 0.00857678f, 
    0.01439627f, 0.02426123f, -0.00267098f, -0.02031738f, -0.03817728f, -0.02329502f, 0.04708334f, -0.03930711f, 
    -0.02956053f, 0.03080382f, -0.00067365f, 0.02944980f, -0.05672775f, 0.03946730f, -0.02975212f, 0.01110679f, 
    0.00027703f, 0.03778364f, -0.03083545f, 0.01408304f, 0.03344237f, 0.04913052f, 0.02360844f, 0.04600770f, 
    -0.01762394f, -0.03779298f, -0.03989391f, -0.01262232f, -0.01374005f, -0.00900290f, -0.05303654f, 0.00840015f, 
    0.02018745f, -0.01188808f, -0.05831817f, 0.00244474f, 0.03817744f, 0.00028355f, 0.01595509f, -0.02995125f, 
    0.00032619f, 0.01008926f, 0.01621313f, 0.02483997f, 0.00535559f, -0.02765336f, -0.01522743f, 0.03357938f, 
    0.02225736f, -0.06971665f, 0.02346612f, -0.04479399f, -0.02334682f, 0.02435835f, -0.01516903f, -0.00389987f, 
    -0.02805166f, 0.01821361f, -0.01353579f, -0.01523701f, 0.05029579f, -0.00464112f, -0.00996838f, 0.03434972f, 
    -0.01884687f, 0.05167463f, -0.00769599f, 0.03195114f, -0.06457112f, -0.02661687f, 0.01276287f, 0.04233057f, 
    0.02795254f, -0.00917578f, -0.06785432f, -0.02865457f, 0.02968628f, 0.00904875f, 0.01565082f, 0.02324638f, 
    -0.00575330f, 0.00489480f, -0.01910456f, 0.01137202f, 0.04728673f, -0.05211627f, -0.04617004f, -0.01774857f, 
    0.01198110f, -0.03895811f, -0.05269568f, -0.04746723f, -0.01102763f, 0.02576059f, -0.01754954f, -0.05927316f, 
    0.03599887f, -0.01781478f, 0.00749866f, -0.00152390f, 0.03820675f, 0.00215512f, 0.02129994f, 0.04042094f, 
    0.00185444f, -0.00621170f, -0.05726888f, 0.02951048f, 0.00412474f, -0.01774556f, -0.00314208f, -0.03425070f, 
    -0.06572735f, -0.00283693f, -0.00733905f, 0.01470775f, -0.04133309f, -0.06586821f, 0.00872013f, 0.03753213f, 
    0.04607219f, -0.00206881f, 0.02117689f, 0.03515578f, 0.01861331f, 0.00513065f, -0.04101146f, 0.00244997f, 
    0.00016566f, -0.06124273f, 0.03173491f, -0.03472561f, 0.05247380f, 0.00535027f, -0.06312642f, 0.00254530f, 
    0.03952343f, -0.02241283f, 0.01699715f, 0.00263124f, -0.00920007f, -0.03252873f, 0.01151150f, -0.04700692f, 
    -0.02269192f, 0.01622756f, 0.02448943f, -0.05425854f, 0.03723047f, -0.04995146f, 0.01467674f, -0.03296424f, 
    -0.05338564f, -0.00025065f, 0.03545022f, -0.05568657f, -0.04380256f, 0.04280141f, -0.06172348f, -0.03675560f, 
    0.01991860f, -0.05311883f, -0.00049773f, -0.00671523f, -0.05178514f, 0.00327530f, 0.02122496f, -0.05899790f, 
    0.01018655f, -0.05536058f, -0.04227155f, 0.00109865f, -0.01408643f, -0.03626968f, -0.03021354f, -0.01558676f, 
    -0.05956103f, -0.03683417f, -0.05030248f, 0.00338987f, -0.05740860f, 0.03974544f, -0.00751522f, 0.03857579f, 
    0.00825099f, 0.02485918f, 0.04905654f, -0.04557905f, 0.04326428f, -0.02676813f, 0.02365695f, -0.04343181f, 
    0.00397509f, 0.03357137f, -0.00924466f, -0.03180132f, -0.04330041f, -0.03102412f, -0.02909502f, 0.00928390f, 
    0.01892316f, 0.04774432f, 0.04274776f, -0.02708888f, -0.03838037f, 0.02227795f, -0.02904890f, 0.02124465f, 
    0.01366730f, -0.00587850f, 0.01032528f, -0.01220285f, -0.03441294f, -0.03152276f, -0.01928354f, -0.04482031f, 
    -0.03576855f, -0.03398873f, -0.06881270f, -0.07178382f, 0.01889308f, 0.00431397f, 0.00360785f, 0.00554179f, 
    0.00685502f, -0.03334116f, -0.01377548f, -0.03993020f, 0.04218732f, -0.03084218f, 0.01534587f, -0.02516891f, 
    0.00911102f, 0.05505022f, 0.02508417f, 0.02215255f, -0.06067413f, -0.02388788f, 0.03760805f, -0.03069470f, 
    -0.04635532f, -0.01022841f, -0.03141873f, -0.04830972f, -0.03680133f, 0.04543308f, 0.02622521f, -0.01301754f, 
    0.00915876f, -0.02775064f, -0.03558269f, 0.00744214f, 0.04031031f, 0.00852229f, 0.00662286f, -0.04198236f, 
    0.01540565f, 0.03026890f, 0.01638028f, -0.01184392f, 0.03730788f, 0.03955457f, 0.01174336f, -0.01378769f, 
    -0.05286407f, -0.03788635f, -0.01245687f, -0.04198203f, -0.02494651f, -0.06669775f, -0.05143248f, -0.04620088f, 
    0.00713867f, 0.03561523f, 0.05017347f, 0.02092934f, 0.00805701f, -0.01036775f, 0.03695720f, -0.05365754f, 
    -0.00987418f, -0.03423166f, -0.06279944f, 0.01770013f, 0.02324541f, -0.04022451f, -0.04165481f, 0.06107742f, 
    -0.02111355f, 0.02781572f, 0.03492941f, -0.00785885f, 0.02834341f, -0.06672334f, -0.03680436f, -0.04133467f, 
    0.03537899f, 0.03236578f, 0.02305239f, -0.02419668f, -0.05764427f, -0.01699051f, 0.01697841f, -0.04431849f, 
    -0.03133741f, 0.05307117f, -0.07003186f, 0.00455963f, 0.02397219f, -0.00774643f, -0.04751749f, -0.07405119f, 
    0.03984093f, -0.03942794f, 0.03132011f, -0.03411746f, 0.01001580f, 0.01514237f, -0.03258526f, -0.02344043f, 
    -0.01517199f, 0.03543966f, 0.03555677f, 0.02875814f, -0.01497635f, -0.05841900f, -0.06338582f, -0.04309621f, 
    -0.02773278f, -0.02626608f, -0.00542540f, -0.04827895f, 0.04402766f, -0.03271192f, 0.01677569f, -0.06460758f, 
    0.00920389f, 0.00686166f, -0.00956468f, -0.02517734f, -0.05474653f, 0.01473687f, -0.00467829f, -0.03322672f, 
    -0.04372673f, 0.01745103f, 0.00893267f, 0.00097077f, -0.05505778f, -0.04556020f, -0.03360472f, 0.00885250f, 
    -0.02074186f, -0.00023078f, 0.05262651f, 0.01531613f, -0.03389357f, -0.03204858f, -0.06018360f, -0.04535877f, 
    0.01084303f, -0.05505180f, -0.06948141f, -0.04114279f, -0.04967192f, -0.01119898f, 0.00440916f, -0.02982749f, 
    0.04125376f, 0.05024384f, -0.00867171f, 0.01667159f, 0.02804148f, -0.01562351f, -0.00914616f, -0.05180393f, 
    -0.01987804f, -0.06563083f, -0.02220178f, 0.03219469f, -0.02840722f, 0.00008174f, -0.05964772f, -0.00205844f, 
    0.02475190f, -0.06066371f, 0.00307462f, 0.01015645f, -0.02264569f, -0.02052776f, 0.04857645f, -0.01405515f, 
    -0.04231594f, -0.01719269f, 0.02365053f, 0.03084591f, -0.00048389f, 0.03421839f, -0.05531403f, 0.02527736f, 
    -0.00965127f, 0.02888461f, 0.01057285f, 0.05428676f, -0.03888643f, -0.04269795f, -0.00290740f, 0.04084583f, 
    -0.05244607f, -0.07374952f, -0.03807763f, -0.04198571f, -0.07120855f, 0.00364186f, -0.01219004f, -0.01653733f, 
    0.03083141f, 0.00112807f, -0.01895844f, -0.06788520f, -0.04992609f, -0.05963370f, 0.00129197f, -0.00172781f, 
    -0.05515949f, -0.04438847f, -0.01749633f, -0.06376932f, -0.02916831f, -0.05247231f, 0.05352984f, 0.04635866f, 
    -0.08134551f, 0.03840863f, -0.00283499f, 0.01891189f, 0.02201169f, -0.00840980f, -0.01319813f, 0.04239267f, 
    -0.03230570f, -0.02208993f, -0.03737848f, -0.01155280f, 0.01695279f, -0.06812561f, 0.00199998f, 0.03085697f, 
    -0.04558685f, 0.04538094f, -0.05867964f, 0.04248981f, -0.06888323f, 0.01946162f, 0.03492943f, -0.05278747f, 
    0.01295975f, 0.03741821f, -0.02789921f, -0.03793684f, -0.04822828f, 0.04613142f, -0.04775218f, 0.03219396f, 
    0.03514440f, -0.03935621f, -0.03633251f, 0.03945611f, -0.03348850f, -0.02029677f, 0.02464125f, 0.00797326f, 
    0.00891265f, -0.02749451f, -0.05613333f, 0.03008112f, 0.01306400f, -0.03775337f, 0.04837701f, -0.03689759f, 
    0.00822398f, -0.00396338f, -0.00506528f, -0.02378037f, -0.01517173f, 0.00958361f, -0.01139778f, -0.01329224f, 
    0.00296122f, -0.04515072f, -0.01413151f, -0.04908299f, 0.04626553f, -0.02005188f, 0.00465045f, -0.07825920f, 
    0.20905940f, 0.12494541f, -0.10643228f, 0.04401786f, 0.04377831f, 0.11594895f, 0.10711838f, 0.00457897f, 
    0.13743493f, -0.28944865f, -0.91620499f, -0.28932676f, -0.01092735f, 0.06562265f, -0.06986871f, 0.25828248f, 
    -0.03961267f, 0.06097266f, -0.49946070f, -0.41511375f, 0.49137145f, 0.10376699f, 0.26077130f, 0.16481899f, 
    0.00698936f, 0.08675094f, 0.09312209f, 0.13173443f, -0.20673113f, -0.18318851f, 0.04393417f, 0.11342708f, 
    -0.06987090f, -0.22882830f, -0.07297679f, -0.05909571f, 0.21204831f, -0.00423844f, -0.02416793f, -0.03938317f, 
    -0.25047469f, -0.18353130f, -0.02278128f, -0.03947921f, 0.33051264f, -0.12989081f, -0.77564037f, 0.21499692f, 
    -0.06151357f, 0.22155476f, -0.10810022f, -0.12526949f, 0.08109038f, -0.03368637f, 0.11894254f, 0.05662078f, 
    0.02577321f, -0.03133979f, 0.10188633f, 0.07710247f, -0.00922488f, -0.07608709f, 0.02345069f, -0.23003536f, 
    0.10089197f, -0.03724528f, 0.04460758f, -0.00015740f, 0.18551210f, 0.09800556f, 0.15281396f, -0.04991996f, 
    0.22237261f, -0.04606554f, -0.20457080f, 0.27547416f, -0.16974336f, 0.00311855f, 0.38792655f, 0.12270519f, 
    0.07746433f, 0.51444757f, 0.00543500f, -0.21393843f, 0.04280819f, 0.02653982f, 0.07646330f, 0.10135737f, 
    -0.05533702f, -0.34237313f, 0.19448203f, 0.13918714f, -0.35740787f, 0.19080743f, 0.10443279f, 0.08468168f, 
    0.12047441f, -0.07318383f, -0.09506711f, 0.79505610f, 0.34206268f, -0.67095065f, 0.39090243f, 0.15630831f, 
    0.24166936f, 0.05986098f, -0.04426426f, -0.01208926f, -0.02615907f, -0.25836512f, 0.01460184f, -0.03284225f, 
    -0.27648401f, -0.11001120f, -0.06410384f, 0.01431331f, 0.34966877f, -0.00010752f, -0.02837165f, 0.00508342f, 
    0.11616848f, -0.09772844f, 0.19824612f, 0.01637598f, 0.01195609f, -0.04773958f, -0.29975024f, 0.37872267f, 
    0.23126808f, 0.11740246f, 0.08707154f, -0.21418004f, 0.01156905f, 0.10380960f, -0.03733242f, 0.00813422f, 
    0.37572980f, -0.22144522f, 0.18189515f, -0.18431932f, -0.15616712f, -0.00352720f, -0.16889846f, -0.11392540f, 
    -0.10100784f, -0.09228986f, -0.06286304f, -0.06681487f, -0.04240539f, -0.01438295f, -0.00631365f, -0.18176280f, 
    0.23447202f, 0.26304996f, 0.17376685f, 0.06085473f, -0.09233837f, 0.02748541f, -0.42740977f, 0.19349982f, 
    -0.07335846f, -0.07301082f, 0.20790644f, 0.13609073f, 0.33403444f, -0.26690990f, -0.01878342f, -0.06781396f, 
    0.09783097f, 0.26534480f, 0.10920300f, -0.00154724f, 0.13086662f, -0.04938811f, -0.11852476f, -0.01486607f, 
    -0.05902454f, 0.03014827f, -0.04153636f, -0.02856463f, -0.02972867f, 0.45396450f, 0.14661537f, 0.04038056f, 
    0.15298240f, -0.21972431f, -0.03209308f, 0.14386179f, -0.14109826f, -0.20759968f, -0.08933307f, 0.01374723f, 
    0.05536884f, 0.13283050f, 0.20163400f, 0.11137418f, 0.15559560f, -0.22733609f, -0.15774946f, 0.07015721f, 
    0.11220189f, 0.08177549f, 0.17424616f, -0.17229475f, 0.13569064f, 0.06980333f, -0.20069896f, -0.00245256f, 
    -0.35442221f, 0.18523072f, -0.19953908f, -0.03865831f, -0.01020945f, 0.00239230f, 0.20809305f, -0.00446128f, 
    0.19842209f, 0.01016846f, -0.04002146f, -0.12205812f, -0.36677724f, -0.00255194f, -0.16177148f, -0.09891041f, 
    0.00270480f, 0.23865041f, 0.23656330f, -0.07371502f, -0.20573576f, -0.22594652f, -0.03627950f, 0.16303869f, 
    0.14239275f, 0.11261092f, -0.52164441f, -0.17196728f, -0.18651485f, 0.00897079f, -0.06281874f, 0.33632144f, 
    -0.00800925f, 0.07689497f, 0.20514722f, -1.04292786f, -0.37453029f, -0.52041399f, 0.03157706f, 0.03417556f, 
    0.10481606f, 0.08001316f, 0.17205921f, 0.10776608f, -0.07974349f, -0.53287435f, 0.12179064f, 0.18872459f, 
    0.10413881f, 0.15625246f, 0.07349424f, 0.04868752f, 0.04076421f, -0.01606039f, 0.05000904f, 0.03466552f, 
    0.04253313f, -0.19154273f, -0.02936403f, 0.06850289f, -0.12607495f, 0.10538369f, -0.09875508f, -0.03601065f, 
    -0.09757493f, -0.05415678f, 0.00907589f, 0.01327027f, 0.06064390f, 0.05515982f, 0.26496994f, 0.23025970f, 
    0.23156458f, -0.24361774f, -0.07977290f, -0.21613282f, 0.09073233f, -0.04044687f, 0.13995101f, 0.11956863f, 
    0.02540059f, 0.00858555f, -0.05236593f, -0.04710544f, 0.04439318f, -0.05270372f, -0.03785630f, -0.05644573f, 
    0.02906096f, -0.06075875f, -0.00961205f, -0.04627466f, -0.06054543f, -0.00982062f, 0.00769075f, 0.03689536f, 
    -0.06461821f, 0.03240123f, 0.03349351f, -0.05811260f, -0.04854940f, -0.05221194f, -0.00955687f, 0.01036312f, 
    0.05462047f, 0.00106084f, 0.00642555f, -0.02870074f, -0.06095041f, 0.00370445f, -0.01487963f, 0.00981755f, 
    0.00426620f, 0.03937008f, 0.04796300f, 0.00305102f, 0.04266836f, 0.00747870f, -0.02568661f, -0.01675849f, 
    -0.03363661f, 0.00046117f, 0.01289674f, -0.04217357f, -0.05314462f, -0.05393779f, 0.03948864f, 0.04802896f, 
    0.00423735f, -0.04867313f, -0.04090517f, 0.03658476f, 0.04438329f, 0.00026915f, 0.01485824f, -0.02534661f, 
    0.02734451f, -0.00084216f, 0.00586709f, -0.05834409f, -0.00332880f, -0.04978940f, -0.00980939f, -0.05318289f, 
    0.00200168f, 0.03366682f, -0.05392350f, -0.04272046f, -0.04435495f, -0.05088862f, -0.05754057f, -0.05680995f, 
    -0.04782031f, 0.03542219f, 0.02225794f, -0.05262903f, -0.03223542f, -0.05000320f, -0.02079889f, 0.00292172f, 
    -0.02585103f, -0.00080389f, -0.01294717f, -0.06066923f, 0.02701394f, 0.05077212f, 0.04008040f, 0.00487264f, 
    -0.05340544f, 0.03430675f, -0.02592174f, 0.00588942f, -0.00329524f, -0.04962401f, -0.02751342f, -0.06465876f, 
    -0.00377607f, -0.03513612f, 0.00568494f, -0.01720506f, -0.01236169f, -0.01256244f, 0.04159673f, -0.05321169f, 
    -0.01150075f, 0.04586379f, -0.04958555f, -0.05798894f, 0.01158609f, 0.03670605f, -0.02734515f, 0.04777228f, 
    -0.04314376f, 0.03799862f, -0.04806457f, 0.03431053f, 0.04741893f, -0.04236884f, 0.00479424f, 0.01190185f, 
    -0.04469081f, 0.00323088f, -0.03063281f, 0.00146116f, -0.05158143f, 0.01487374f, 0.03824617f, 0.05157791f, 
    -0.03876098f, 0.04076494f, -0.05358626f, -0.05311227f, -0.06350335f, -0.05338516f, -0.04788435f, -0.01279685f, 
    0.01850128f, 0.05169031f, 0.04744535f, 0.03640250f, -0.04189131f, 0.02476725f, -0.01573924f, -0.04034180f, 
    -0.05164523f, -0.01730891f, -0.00194256f, -0.01140816f, -0.04595334f, 0.03705956f, -0.02106763f, 0.03210919f, 
    0.00896650f, -0.03101322f, 0.02709708f, 0.03530570f, 0.03656955f, -0.05933636f, -0.05214233f, 0.03887585f, 
    -0.05698831f, -0.06041887f, 0.02114608f, -0.02912024f, -0.06322209f, 0.04827586f, 0.04510689f, 0.05144638f, 
    -0.02519272f, 0.02174888f, -0.05544697f, 0.04821337f, -0.05454814f, 0.00801751f, -0.00047456f, -0.01274358f, 
    -0.04055167f, -0.03891603f, 0.02248094f, -0.01511514f, -0.05495999f, 0.02496689f, -0.04990416f, -0.01405536f, 
    -0.00172296f, 0.03862546f, 0.04834107f, 0.02600269f, -0.01726500f, 0.03700426f, 0.04513644f, -0.03502991f, 
    0.03835740f, -0.03350795f, -0.04557754f, 0.04082732f, -0.01503655f, -0.03452123f, -0.06202960f, -0.04853745f, 
    -0.01233166f, -0.02144207f, -0.04686016f, -0.00269444f, -0.05191443f, 0.00927109f, -0.05089946f, 0.00057074f, 
    0.02600577f, 0.01104356f, 0.04808733f, -0.05309154f, -0.02548053f, 0.00662458f, -0.06568705f, -0.00716216f, 
    0.04239392f, 0.03468603f, -0.04339366f, 0.01936919f, 0.02848747f, 0.02345455f, -0.06017983f, -0.03235957f, 
    -0.03792914f, -0.01025254f, -0.00456686f, 0.04660265f, -0.00001155f, -0.00357043f, -0.05127416f, 0.01199032f, 
    -0.04073923f, 0.03910664f, -0.00718588f, -0.00430144f, -0.06233716f, -0.03763607f, 0.03220075f, -0.04871481f, 
    -0.04097548f, 0.02447385f, 0.01371776f, 0.03818012f, -0.01685346f, -0.04244659f, -0.00617406f, -0.06291104f, 
    -0.05525029f, -0.02705226f, -0.03410282f, 0.03809559f, -0.06439999f, 0.02758454f, 0.04427922f, 0.01794746f, 
    -0.03981377f, 0.05027334f, 0.02312010f, 0.01570440f, 0.04831888f, -0.02580727f, -0.04399078f, -0.05805477f, 
    -0.05348254f, 0.04937840f, 0.04457872f, 0.03796610f, 0.00312193f, 0.02197189f, -0.04671209f, 0.00383257f, 
    -0.04360583f, -0.06450032f, 0.01176392f, 0.01220055f, 0.04965853f, 0.02005877f, -0.03353269f, 0.04964337f, 
    -0.05841224f, 0.05239954f, -0.03710574f, 0.02537478f, 0.05098568f, 0.04172078f, -0.00993019f, 0.00889011f, 
    0.30825686f, -0.09086989f, 0.04146226f, -0.29244608f, -0.10807548f, -0.04723475f, 0.16587619f, -0.19538680f, 
    0.06863401f, 0.42339963f, -0.09896765f, -0.16916463f, -0.03220810f, 0.00653686f, -0.06252620f, -0.02936153f, 
    0.07217906f, -0.01004941f, -0.06132350f, 0.03135367f, 0.01455249f, 0.15647767f, -0.09762077f, 0.06115032f, 
    0.13310143f, -0.11957620f, -0.07427128f, 0.15891530f, 0.04441062f, 0.13910446f, 0.05401146f, -0.08300027f, 
    -0.09673886f, -0.12619290f, 0.25036433f, 0.19185923f, 0.12821184f, -0.18926077f, 0.21831560f, 0.06070118f, 
    0.08563416f, -0.16747904f, 0.10838810f, 0.06504203f, -0.11464190f, 0.19415629f, 0.26067024f, 0.01360316f, 
    -0.11146417f, 0.00904260f, -0.15726054f, 0.06599835f, -0.10195844f, 0.21485910f, 0.24473614f, 0.28771746f, 
    -0.02120384f, -0.15461501f, -0.03598982f, -0.14796650f, -0.13562320f, 0.03630758f, -0.02920905f, -0.10962641f, 
    0.09972879f, 0.27239105f, 0.06851817f, 0.17509541f, -0.07108603f, 0.02795347f, 0.08914102f, -0.17634897f, 
    -0.08136173f, -0.19034211f, 0.10160536f, -0.06725147f, -0.00525365f, 0.14546128f, 0.04537787f, -0.05115833f, 
    0.10382273f, 0.06739942f, -0.04422354f, -0.19481622f, -0.13099048f, -0.06923526f, 0.01487547f, 0.04556568f, 
    0.25884527f, 0.10005880f, -0.01921836f, -0.24241501f, -0.03492133f, -0.36309770f, 0.21551523f, 0.04203314f, 
    0.10887485f, -0.11988860f, 0.14439671f, 0.34912446f, 0.11597706f, -0.06694377f, 0.04461494f, 0.08545830f, 
    0.08582042f, 0.07880356f, -0.04491149f, -0.06990446f, -0.20222452f, -0.29528949f, -0.03081884f, 0.10901958f, 
    -0.04833142f, -0.07837668f, -0.15916419f, -0.09675209f, -0.09807964f, 0.02829505f, 0.05089977f, -0.01826571f, 
    -0.16533244f, -0.00905371f, 0.12508154f, -0.24353936f, 0.07755172f, 0.08805218f, 0.06562116f, -0.29740086f, 
    -0.05025395f, -0.08880620f, -0.11808972f, 0.01463705f, 0.09823793f, 0.05148976f, -0.19223742f, 0.09676359f, 
    -0.35445765f, -0.17726372f, -0.12988922f, 0.06308265f, 0.23808654f, -0.04123454f, -0.05526419f, -0.13961136f, 
    0.25250775f, -0.10316249f, 0.00944872f, 0.01972052f, 0.03312206f, -0.03775853f, 0.05985238f, 0.04092607f, 
    0.16307399f, 0.20561226f, 0.15734334f, -0.11244257f, 0.07644879f, -0.11199716f, -0.04499669f, -0.03062873f, 
    0.15680715f, -0.03885008f, -0.21774560f, -0.36280963f, 0.20437655f, 0.09377714f, -0.05273163f, 0.14214301f, 
    -0.13189852f, 0.07857476f, 0.11063297f, 0.10774934f, -0.09836606f, 0.38527802f, 0.16402191f, -0.07745032f, 
    0.05413416f, -0.02254718f, 0.00312284f, -0.08807161f, 0.27333400f, -0.09538815f, -0.16265701f, -0.16078544f, 
    0.02510618f, 0.05113560f, 0.04494651f, -0.01056392f, -0.19883400f, -0.11817890f, -0.01236550f, 0.31578237f, 
    -0.14458804f, -0.14028510f, 0.00242895f, 0.11070085f, -0.11984069f, 0.35103184f, 0.10339958f, -0.00196786f, 
    0.09330743f, 0.29064196f, 0.07471747f, -0.06874499f, -0.34619412f, -0.05314740f, 0.01809346f, -0.40122259f, 
    -0.38967350f, 0.00074997f, 0.11812773f, 0.05844440f, -0.08398229f, -0.08691854f, -0.05689291f, -0.05470244f, 
    -0.00898768f, -0.15145631f, -0.01336234f, 0.23941958f, 0.22884119f, -0.30734995f, -0.12150506f, 0.06050960f, 
    -0.05628429f, -0.87315053f, -0.15016936f, 0.06021719f, 0.06521460f, 0.06465316f, 0.11438965f, -0.01671333f, 
    -0.07051714f, -0.22573875f, 0.12471643f, 0.29663017f, 0.10769425f, 0.03335401f, 0.11251138f, -0.32009733f, 
    -0.04848241f, -0.13147771f, 0.09159231f, -0.04851841f, 0.07081269f, 0.02256849f, -0.25335106f, -0.00671914f, 
    -0.06944680f, -0.06693662f, 0.23921785f, -0.16380773f, 0.24508084f, 0.20786658f, 0.22445519f, 0.11789086f, 
    0.01322451f, -0.12019768f, 0.15925761f, 0.20408140f, 0.09362211f, -0.02329411f, -0.08598738f, 0.10812441f, 
    0.03794966f, 0.17946087f, -0.13836719f, 0.11987504f, 0.23601560f, -0.12956938f, 0.43545884f, 0.07563315f, 
    0.42466861f, 0.10520843f, -0.12167109f, -0.14927109f, 0.00872095f, -0.03850858f, 0.16711441f, -0.18327178f, 
    -0.00523232f, 0.07999731f, 0.17925093f, -0.11345133f, -0.08985022f, 0.12279303f, 0.01357422f, 0.13677792f, 
    0.00225064f, 0.02515105f, -0.03876264f, -0.02946284f, -0.02517098f, 0.00970283f, -0.02469064f, -0.05334286f, 
    -0.02513259f, -0.01186604f, -0.04210240f, 0.00153795f, 0.00007714f, -0.06038086f, 0.04914377f, 0.00420626f, 
    0.01521591f, 0.01085870f, 0.02331256f, -0.06615734f, -0.03097437f, -0.00840128f, -0.04172051f, 0.01929191f, 
    0.02110263f, -0.00426417f, -0.05713808f, -0.03487726f, 0.01684462f, -0.01719899f, -0.02664473f, -0.01464121f, 
    -0.05787912f, 0.00830691f, -0.02749152f, 0.04072365f, -0.05743629f, 0.02935551f, -0.01229945f, 0.03314621f, 
    -0.00039623f, 0.02657455f, -0.05876338f, -0.01622441f, -0.04972031f, -0.00929084f, -0.02676230f, 0.01424008f, 
    -0.03431400f, -0.03511889f, 0.03339369f, -0.01227671f, -0.06385370f, 0.00883941f, 0.02460810f, -0.04267915f, 
    -0.05564983f, -0.01860433f, 0.02699804f, 0.01668333f, -0.00218657f, -0.03801959f, 0.03621718f, -0.04240591f, 
    -0.03471056f, -0.02271521f, -0.02499218f, 0.00476141f, 0.05230448f, -0.04601606f, -0.02515092f, -0.03524471f, 
    0.04527193f, -0.06103081f, -0.00138908f, -0.04106837f, 0.00600488f, -0.01828796f, -0.05487068f, -0.03532497f, 
    -0.00418834f, -0.04301753f, -0.01976026f, -0.00726600f, -0.03972423f, -0.00201000f, -0.03191276f, -0.02460010f, 
    -0.01145894f, 0.01664042f, -0.03364076f, -0.03304410f, 0.00915887f, -0.01232797f, -0.02352195f, 0.04327606f, 
    0.01294114f, -0.02314635f, -0.00637210f, -0.06487291f, -0.04194435f, -0.03040835f, -0.03171957f, 0.04481575f, 
    -0.03777071f, 0.02270060f, -0.03857561f, -0.03778802f, 0.01932306f, -0.01260696f, -0.00588323f, -0.00966970f, 
    -0.01286530f, 0.02805295f, 0.02535950f, -0.04428026f, 0.05129986f, 0.02593821f, -0.02035511f, 0.01941898f, 
    -0.04820225f, -0.01903451f, -0.02237720f, 0.04166609f, -0.00749240f, 0.04207516f, -0.03211436f, -0.00616146f, 
    -0.02697096f, 0.02827251f, 0.02245454f, 0.01122149f, -0.02638094f, 0.01967157f, 0.05012595f, 0.04287146f, 
    0.00650924f, -0.02121734f, 0.04975659f, 0.05694418f, -0.06181860f, -0.03572059f, 0.01166852f, -0.05128148f, 
    0.05153066f, 0.03545698f, 0.02860039f, 0.03105173f, -0.01520722f, -0.03119115f, 0.04005348f, -0.01791592f, 
    -0.05726683f, -0.02019163f, -0.01839828f, -0.02682754f, 0.04792163f, 0.03758748f, 0.05540112f, -0.01482471f, 
    -0.03037778f, -0.00739907f, -0.01835325f, -0.03946386f, -0.06492322f, 0.00421766f, -0.00103787f, 0.03851243f, 
    -0.01928231f, -0.00096566f, -0.04930637f, -0.04496432f, -0.04439069f, 0.04778030f, -0.02555634f, -0.03050024f, 
    0.03329639f, -0.05891273f, 0.01383013f, -0.05763509f, 0.01195758f, 0.01780907f, 0.03930096f, -0.01298151f, 
    -0.03951993f, 0.03245271f, -0.04013003f, -0.04265935f, 0.00732943f, 0.03906400f, 0.04236266f, -0.02592473f, 
    0.04330514f, -0.04848164f, -0.06091635f, 0.05694734f, 0.01333256f, 0.00910693f, 0.04715003f, -0.05011313f, 
    0.01704870f, 0.02868510f, -0.03419136f, -0.06176643f, 0.03078987f, -0.06185452f, -0.04644124f, 0.00575179f, 
    0.01769450f, -0.02297164f, 0.04007449f, -0.05104093f, 0.00120418f, 0.01114908f, 0.04222439f, 0.01597171f, 
    0.01885560f, -0.01898902f, -0.04093054f, -0.04484348f, -0.04547796f, -0.04662453f, -0.01657352f, 0.01667413f, 
    -0.00492575f, -0.04225830f, 0.01689341f, -0.05161616f, 0.02955111f, -0.01635215f, 0.00823822f, 0.04609908f, 
    -0.02256018f, 0.02353959f, 0.03709145f, -0.05567702f, 0.04648343f, -0.00849866f, 0.01069404f, -0.01618714f, 
    -0.00767938f, -0.00207771f, 0.00718568f, 0.01192976f, -0.06049579f, 0.02003007f, -0.02569261f, -0.02914780f, 
    -0.05501558f, -0.05682031f, -0.01675182f, 0.04718998f, -0.02308543f, 0.00203888f, -0.00875586f, -0.02443679f, 
    0.01926278f, -0.01322799f, -0.06417670f, -0.01098644f, -0.01723725f, 0.03589059f, -0.02534562f, 0.01264720f, 
    -0.04961036f, -0.01462119f, 0.04824672f, -0.03075835f, 0.00932448f, -0.04855905f, -0.05554772f, -0.02909577f, 
    0.04770100f, 0.01935124f, 0.04505284f, 0.02886723f, -0.01440058f, -0.02426285f, -0.04207679f, -0.04552130f, 
    0.04188352f, -0.04582000f, -0.04096463f, -0.02062871f, 0.02080623f, -0.05181822f, 0.02591002f, 0.00335182f, 
    -0.02278179f, 0.03200397f, -0.03448040f, -0.04489726f, -0.01272042f, -0.00725444f, 0.01442092f, 0.02849840f, 
    -0.02754945f, 0.01882453f, 0.03053524f, 0.04151987f, -0.01288794f, 0.00560191f, 0.01089768f, -0.05356275f, 
    0.03564351f, -0.06812229f, 0.02135135f, -0.05238475f, -0.03108880f, 0.02695742f, 0.04121649f, -0.00936734f, 
    -0.05309770f, -0.05019010f, 0.01216805f, -0.01552924f, 0.02710022f, 0.04451988f, 0.02992104f, -0.00040332f, 
    -0.02952296f, -0.04997958f, 0.01231672f, 0.00492560f, 0.04236367f, -0.00708092f, -0.05336445f, 0.05196782f, 
    0.02284496f, -0.02025498f, -0.00121361f, 0.01432944f, -0.00097039f, 0.00247012f, 0.01940316f, 0.00824653f, 
    -0.01050427f, -0.03402656f, -0.02944143f, -0.06166866f, 0.01235179f, -0.02101972f, -0.02600325f, -0.04172122f, 
    -0.05862205f, 0.02212544f, 0.03845422f, -0.00698681f, 0.04114662f, -0.05546359f, -0.04009207f, -0.03182292f, 
    0.00355862f, 0.02742222f, -0.03886118f, -0.03099482f, 0.00023487f, -0.04835530f, -0.05396235f, 0.04652416f, 
    0.05827050f, -0.05979615f, -0.01880209f, 0.01551468f, -0.02471028f, 0.02444746f, 0.02121864f, 0.00194808f, 
    0.04203132f, -0.03181894f, -0.02223961f, -0.03038132f, 0.04382251f, 0.01228917f, -0.04768379f, 0.01944010f, 
    0.04032798f, 0.01803773f, 0.00641025f, 0.03974393f, -0.00521070f, 0.02351664f, -0.01052355f, 0.00931499f, 
    -0.00247494f, -0.01633363f, -0.03786376f, -0.05496508f, -0.01946251f, -0.01210171f, 0.04104969f, 0.00146243f, 
    -0.03949523f, 0.02903956f, -0.03768434f, -0.00532104f, -0.06530775f, 0.01731674f, 0.03640336f, -0.01505530f, 
    0.03028463f, -0.01444707f, -0.01733719f, -0.04766246f, 0.03958253f, -0.02651607f, 0.01831619f, 0.04436698f, 
    0.04599904f, 0.03365721f, -0.03115956f, 0.04582479f, -0.03659767f, -0.01965082f, 0.00982887f, -0.05126408f, 
    -0.06466510f, -0.05315774f, -0.03787787f, -0.02823827f, -0.03145367f, -0.00445060f, -0.05319284f, 0.01786792f, 
    0.03774267f, 0.01938049f, -0.05143943f, -0.04523525f, 0.03366951f, -0.00480563f, -0.02154873f, -0.06768107f, 
    0.02291232f, 0.00561453f, -0.00444710f, -0.02560370f, -0.05244653f, 0.04811960f, 0.00107911f, 0.00381261f, 
    -0.01541012f, -0.02914180f, -0.01865767f, -0.05282224f, 0.02565582f, 0.01571724f, -0.05034903f, -0.05462786f, 
    0.00491206f, -0.00773675f, -0.03740066f, -0.01384128f, -0.03565390f, 0.03675301f, -0.00794309f, 0.01097118f, 
    0.02099123f, -0.01823731f, -0.02763181f, -0.02751800f, -0.05597593f, 0.02555641f, -0.00942439f, 0.00141970f, 
    0.00282940f, 0.02354204f, -0.00633310f, 0.04103483f, 0.03865755f, 0.04689324f, -0.02349450f, -0.05780396f, 
    -0.05110487f, -0.02151050f, 0.01971802f, -0.02535423f, -0.00804774f, -0.05247711f, 0.04297396f, 0.00254105f, 
    -0.04639643f, -0.03772953f, -0.02302601f, 0.03381674f, -0.01471010f, -0.03680011f, -0.02528625f, -0.00317657f, 
    0.02137307f, -0.04217029f, -0.04162073f, 0.02430012f, 0.04487524f, -0.00064813f, -0.01611818f, -0.05906133f, 
    -0.03730635f, -0.04833269f, -0.05877596f, 0.03084929f, 0.01823656f, -0.06294703f, 0.00979940f, -0.04367937f, 
    -0.01937092f, -0.04678495f, 0.03600236f, 0.02404349f, -0.04671100f, -0.02889128f, -0.04703699f, -0.04200649f, 
    0.02056718f, -0.00871242f, 0.04294122f, -0.03934168f, -0.06721497f, -0.06108984f, -0.00101293f, 0.03077886f, 
    0.05208084f, -0.04114063f, 0.03043060f, 0.02302725f, -0.03879835f, 0.00616863f, 0.00324229f, -0.02408642f, 
    -0.03376415f, -0.03155177f, -0.00539644f, -0.01224399f, -0.06804358f, -0.04513414f, 0.05581088f, -0.02652458f, 
    -0.02924627f, 0.01059891f, 0.04699392f, 0.01720106f, 0.00546970f, 0.02454402f, -0.06080551f, -0.06432378f, 
    -0.03038816f, -0.02123576f, 0.04496518f, 0.04274333f, -0.00473160f, 0.02746455f, -0.05483519f, -0.00660640f, 
    -0.06725396f, 0.04556694f, -0.02679264f, -0.04670934f, -0.00144263f, -0.02671139f, 0.02541741f, 0.01934583f, 
    -0.05475464f, 0.04142019f, 0.02182751f, -0.05897320f, -0.03423717f, 0.01486290f, -0.02548425f, 0.04759853f, 
    0.03059049f, -0.02528923f, -0.02348665f, -0.01183449f, -0.00456545f, 0.02310104f, -0.04178530f, 0.02664657f, 
    0.49007121f, 0.11902037f, 0.01761232f, -0.14779864f, -0.14623353f, 0.01277985f, -0.00288318f, -0.03701104f, 
    -0.03508535f, -0.15899557f, -0.42394623f, 0.05741860f, -0.00826568f, 0.15114228f, 0.12305603f, -0.00745725f, 
    -0.06253446f, 0.03297672f, 0.28909630f, -0.23864591f, -0.15179002f, -0.07548425f, 0.18850321f, -0.18230809f, 
    -0.01822457f, 0.09557545f, 0.24780115f, 0.16769415f, -0.23039508f, -0.19282815f, 0.02048511f, 0.01977053f, 
    -0.01798991f, -0.05013294f, -0.01973151f, -0.07244848f, -0.30010357f, 0.22189428f, 0.23955157f, 0.22621749f, 
    0.02515737f, 0.10296451f, -0.11354095f, 0.13267052f, -0.16339305f, -0.50466424f, -0.84909797f, 0.15994416f, 
    0.10816633f, 0.12066838f, -0.09447291f, 0.09150404f, 0.01119376f, -0.07573499f, 0.49047774f, 0.26008779f, 
    0.07198135f, 0.02520665f, -0.07146695f, -0.07980210f, 0.07072572f, 0.05057823f, -0.25522184f, -0.76795232f, 
    -0.07538734f, -0.15274182f, -0.08050694f, -0.00183315f, -0.01197820f, -0.03389079f, 0.08394936f, 0.16677529f, 
    0.03975924f, 0.23062652f, 0.27924067f, 0.02193979f, 0.07177631f, -0.27909410f, -0.17064659f, -0.20043501f, 
    -0.15594108f, 0.19434905f, 0.17186072f, 0.00512935f, -0.10947897f, -0.13692087f, -0.05597494f, -0.05459055f, 
    -0.02004069f, -0.04424085f, -0.26593959f, 0.17300811f, 0.21142659f, -0.02317955f, -0.10558992f, -0.11944052f, 
    -0.12963092f, -0.02683192f, 0.08243089f, 0.01483737f, 0.32065794f, -0.27454510f, 0.10149259f, 0.09638246f, 
    -0.04177574f, -0.10113088f, 0.03875533f, 0.04234658f, 0.61262906f, 0.21138841f, 0.00151830f, -0.07494270f, 
    -0.14244890f, 0.24368358f, -0.20765495f, -0.08510504f, 0.09505598f, -0.06794062f, -0.25715041f, 0.22952341f, 
    -0.15017597f, 0.16154745f, -0.12449779f, 0.08037176f, 0.14056493f, 0.11148436f, 0.49965703f, 0.08699249f, 
    -0.06304619f, -0.21263582f, 0.03045463f, 0.08591332f, -0.08751469f, -0.05447842f, 0.18193287f, 0.02462754f, 
    0.37617639f, 0.01508178f, 0.01492695f, -0.16887851f, -0.01909256f, 0.03986818f, -0.18416487f, 0.08667874f, 
    0.51993310f, -0.18925799f, -0.16551505f, 0.04937377f, -0.07438249f, -0.06285496f, -0.00818390f, -0.18510422f, 
    -0.08668819f, 0.64199340f, 0.18615296f, -0.40496978f, -0.21128112f, 0.00801308f, 0.23770200f, -0.10695607f, 
    0.14267577f, 0.19148338f, 0.10940991f, -0.27096355f, 0.01478651f, -0.01879764f, 0.03121685f, 0.03914479f, 
    -0.00400153f, 0.15773074f, 0.32880345f, 0.09006596f, 0.08142813f, -0.52170336f, -0.02705530f, 0.15977971f, 
    0.10266758f, -0.16404775f, 0.12268954f, 0.01215688f, 0.36251956f, 0.13075806f, 0.26510629f, -0.12746793f, 
    -0.09480240f, -0.17935461f, 0.16874608f, -0.13403803f, 0.01420256f, -0.00529063f, -0.57091206f, -0.09391154f, 
    -0.13182864f, -0.08360964f, 0.03245614f, 0.03323588f, 0.00440193f, 0.06715490f, 0.23944908f, 0.08831464f, 
    0.14197990f, -0.02198665f, 0.03109077f, 0.03450084f, 0.05418765f, -0.11549061f, -0.06850837f, 0.13074258f, 
    -0.03686017f, -0.00225596f, 0.14264594f, 0.03769056f, 0.10959775f, 0.20129327f, 0.07478668f, 0.19806339f, 
    -0.02153899f, 0.02778170f, 0.08228841f, -0.02255532f, -0.09404328f, 0.19793330f, 0.08131684f, 0.07007066f, 
    0.04936299f, -0.09678314f, -0.30769965f, -0.16425225f, 0.06803188f, -0.04499769f, 0.26540959f, -0.07701599f, 
    0.03838258f, 0.31216425f, -0.17240515f, -0.19680798f, -0.11440159f, -0.01150941f, 0.12738733f, 0.11214992f, 
    -0.08770496f, 0.06447668f, -0.02201695f, 0.47237560f, 0.06003963f, -0.74746025f, -0.16351455f, -0.30266497f, 
    0.17910965f, -0.06565013f, 0.18239987f, 0.10311234f, 0.12767355f, -0.03217634f, -0.04439252f, 0.17560786f, 
    0.22675143f, 0.02699696f, 0.05443723f, -0.05962440f, -0.19309619f, -0.46974903f, 0.19140309f, -0.15704480f, 
    0.11519957f, 0.12044815f, 0.18044136f, -0.10707782f, 0.05311054f, -0.05570246f, 0.29404992f, -0.00076256f, 
    -0.20568803f, 0.08263414f, -0.05620142f, 0.03763572f, -0.07859109f, -0.12338242f, -0.08581447f, 0.27609438f, 
    0.16165562f, -0.14272672f, -0.13095506f, 0.01020862f, 0.23164175f, -0.19207025f, -0.05912921f, 0.08334171f, 
    0.01953964f, 0.19749250f, -0.19536793f, -0.13989474f, -0.18527929f, -0.29367015f, 0.10485427f, 0.12982219f, 
    -0.00664435f, 0.19586580f, -0.40394557f, 0.02828649f, -0.21973109f, -0.09427633f, -0.01617344f, 0.24061662f, 
    0.12878503f, 0.04332944f, -0.23244083f, 0.40536609f, -0.26712659f, 0.08518727f, -0.22032340f, -0.08310751f, 
    0.14719318f, -0.06300877f, 0.02306870f, 0.15750448f, 0.01119148f, 0.04638005f, -0.06478038f, 0.04989157f, 
    -0.02635429f, -0.05531891f, 0.06094522f, -0.00675800f, 0.10316857f, 0.13325782f, 0.14492834f, -0.01353408f, 
    -0.11223433f, -0.05544543f, 0.14697787f, 0.07193835f, 0.08899012f, 0.14220551f, 0.20954768f, -0.07749231f, 
    -0.09973700f, -0.02894702f, -0.21322364f, 0.03310265f, 0.09723165f, -0.14935341f, 0.29746139f, 0.07302683f, 
    0.17392480f, -0.10252795f, -0.05907886f, -0.12617894f, 0.00790020f, -0.03721733f, 0.00059358f, -0.21762908f, 
    -0.54351568f, -0.03494501f, 0.19002204f, -0.03176032f, 0.23553203f, -0.19088650f, -0.00610540f, 0.18486607f, 
    0.04936957f, 0.03249443f, 0.02222676f, -0.22340348f, 0.05558157f, -0.06401084f, -0.09652098f, 0.19760877f, 
    0.19631822f, -0.00876784f, 0.12617482f, 0.10577333f, -0.23766221f, 0.24923557f, -0.08718886f, -0.06973419f, 
    0.09377645f, -0.18556960f, 0.16448797f, 0.06481530f, -0.10547500f, -0.26185772f, -0.13445236f, 0.00830657f, 
    0.03124373f, 0.17244028f, 0.08126533f, -0.11168665f, 0.05769021f, 0.09617701f, -0.04480470f, -0.01346323f, 
    0.02016611f, -0.01687181f, 0.08947383f, -0.00836563f, -0.52227992f, 0.01021515f, -0.01515311f, 0.14461493f, 
    0.05689364f, 0.08222108f, 0.21139410f, 0.20441104f, 0.17188230f, -0.15667720f, 0.20075792f, -0.37885997f, 
    0.01290589f, -0.05154451f, 0.08666215f, -0.16866976f, 0.05715526f, -0.08760378f, -0.29701990f, 0.13248815f, 
    -0.01270989f, 0.04132889f, 0.05038564f, -0.07585909f, 0.11259087f, 0.23629607f, 0.04690541f, -0.03300499f, 
    0.13384341f, 0.06195109f, -0.32155004f, 0.10690943f, 0.02865546f, -0.18524234f, 0.15163767f, 0.06957047f, 
    -0.07366461f, 0.28849751f, -0.23498110f, -0.13388754f, -0.08497667f, -0.13456289f, 0.10084616f, 0.04675666f, 
    0.19318542f, -0.01301942f, 0.04137428f, -0.04922105f, -0.01560664f, -0.16019143f, -0.33257672f, -0.08929057f, 
    0.04825826f, 0.08182649f, -0.30700305f, -0.03323438f, -0.09419727f, 0.01526633f, 0.16850771f, -0.02900728f, 
    -0.12345362f, -0.02447847f, 0.11676010f, -0.07859261f, -0.05215119f, 0.16469538f, -0.04146123f, 0.06121226f, 
    -0.08716804f, 0.03229831f, -0.07215097f, -0.06668511f, -0.06423564f, 0.34689197f, 0.10985970f, -0.25157997f, 
    -0.02567839f, -0.00555977f, 0.06134965f, 0.11672352f, 0.11828151f, -0.43693888f, 0.15592980f, 0.36576012f, 
    0.11263763f, 0.06032727f, 0.28076065f, 0.01655286f, -0.14060755f, 0.08709636f, 0.08748091f, -0.12012046f, 
    0.06011592f, -0.18313985f, -0.10735226f, -0.15811466f, 0.01924456f, 0.10785218f, -0.07699178f, -0.13096127f, 
    -0.64390695f, -0.33383811f, 0.07185977f, 0.24566957f, 0.01439094f, 0.08808605f, -0.14171615f, 0.19653228f, 
    0.66708630f, -0.08558752f, -0.11040049f, 0.18819563f, -0.00743814f, 0.02695783f, -0.00098915f, 0.10559117f, 
    0.10837811f, -0.53341275f, -0.02406580f, -0.04751775f, 0.08399403f, 0.15259548f, -0.02780253f, 0.14491582f, 
    0.13751124f, -0.03147021f, 0.40087566f, 0.02208843f, -0.11603796f, -0.26864174f, 0.03139519f, -0.05138036f, 
    0.20769206f, 0.00044624f, 0.00359810f, -0.47375205f, 0.13310888f, -0.31802157f, -0.13338564f, -0.11774743f, 
    0.11939916f, -0.00136016f, 0.19460291f, 0.00939741f, 0.16898547f, 0.14660946f, -0.00267129f, -0.01690247f, 
    -0.23570898f, -0.00473025f, 0.17666534f, -0.01183075f, 0.03809709f, 0.46616381f, 0.00033975f, -0.18521351f, 
    0.07720423f, 0.15860227f, -0.04427584f, 0.12327934f, -0.01123730f, -0.14800602f, 0.15361933f, -0.15893951f, 
    0.27363762f, -0.12826499f, 0.08375522f, 0.00680312f, 0.05641602f, -0.07482061f, 0.23548517f, 0.04202808f, 
    -0.34775808f, -0.11394894f, 0.21169397f, -0.01799379f, 0.03247089f, -0.03331113f, 0.00636489f, -0.02106797f, 
    -0.02906403f, 0.08112390f, 0.32432756f, 0.16870689f, 0.22030146f, 0.25397384f, -0.10077958f, 0.14138983f, 
    0.07959055f, 0.12968791f, 0.09775153f, 0.07029667f, -0.05793425f, 0.00956151f, 0.00720186f, 0.04465149f, 
    0.01296679f, -0.13432276f, 0.09362020f, 0.03331820f, 0.15185653f, 0.27505860f, -0.19889890f, -0.06298318f, 
    -0.11844733f, 0.17811455f, -0.15570128f, -0.28696147f, 0.10987386f, 0.32111543f, -0.06068479f, -0.00365809f, 
    -0.09043316f, -0.12768865f, -0.04845430f, -0.38339373f, -0.16128850f, 0.06016092f, 0.08594985f, -0.10058530f, 
    -0.08099640f, 0.07896249f, -0.26409104f, -0.03992666f, -0.29786018f, 0.27387679f, 0.02658474f, 0.07018056f, 
    -0.11343257f, -0.20901342f, 0.13770694f, -0.20702951f, 0.22460365f, -0.16401459f, -0.02298173f, -0.01323208f, 
    0.15567929f, 0.02649277f, -0.07256850f, 0.33954710f, 0.04994296f, 0.07046477f, 0.08344354f, 0.13387004f, 
    -0.06389574f, 0.13595544f, -0.00982060f, 0.06478471f, 0.09810039f, -0.19193582f, 0.05727840f, -0.00671614f, 
    0.13506845f, 0.31537101f, 0.21512759f, -0.11072191f, 0.01168640f, 0.15676607f, 0.05086684f, -0.11682035f, 
    0.04547425f, 0.08696920f, 0.16538605f, 0.14082357f, 0.29751918f, -0.04797585f, 0.01663666f, -0.08262482f, 
    -0.07554031f, -0.02397881f, 0.05476825f, 0.12842365f, 0.43263006f, 0.00966888f, -0.02126719f, 0.20526245f, 
    0.22060490f, 0.01933101f, 0.15576038f, 0.09652080f, -0.28702942f, 0.05440889f, 0.07942101f, 0.02608684f, 
    0.01771062f, -0.04928759f, -0.02096087f, 0.00260662f, -0.26684639f, 0.08921496f, -0.12700821f, -0.07862348f, 
    -0.08344670f, 0.00502056f, 0.02037195f, 0.03038400f, -0.11016394f, 0.04009588f, -0.10524292f, -0.04462479f, 
    0.04808417f, 0.04792891f, -0.00694870f, 0.15249340f, -0.01357293f, -0.17228168f, 0.18302864f, -0.00201325f, 
    -0.05086837f, -0.12453432f, 0.00839674f, -0.07747636f, 0.15426792f, 0.05848573f, 0.01575959f, 0.13346727f, 
    0.07058232f, -0.01732762f, 0.00349543f, 0.11395527f, -0.09066225f, 0.23432536f, -0.05863803f, 0.33517599f, 
    0.00689277f, 0.07797863f, 0.28457591f, 0.09852223f, 0.21875678f, 0.08170173f, 0.01298888f, 0.12271902f, 
    0.00544627f, 0.01684063f, 0.03459932f, 0.14855295f, 0.00724611f, 0.02409527f, 0.03517142f, -0.08148719f, 
    0.12288284f, 0.24527520f, 0.10326745f, 0.10586775f, -0.00546309f, -0.09174346f, -0.12504601f, 0.07941188f, 
    0.11122823f, 0.04520271f, 0.00326969f, -0.15418239f, -0.19472577f, -0.14288494f, -0.09743000f, -0.02016095f, 
    -0.04604035f, 0.09516636f, 0.02899531f, 0.10085951f, 0.16702536f, 0.03393515f, -0.00395661f, 0.16588925f, 
    0.04495836f, 0.09624943f, 0.25497934f, 0.09706561f, 0.04321596f, 0.07871221f, 0.22392359f, -0.28040028f, 
    0.17650701f, 0.00651125f, 0.09924974f, 0.17967895f, -0.03738010f, -0.19656302f, 0.02180930f, 0.03104181f, 
    -0.18389966f, 0.10096057f, -0.06160415f, -0.08680992f, 0.27082506f, 0.06178959f, 0.04758153f, -0.33489892f, 
    -0.03374947f, -0.13809004f, -0.14536743f, -0.02189214f, -0.04376965f, -0.06609415f, 0.20171468f, -0.08592040f, 
    -0.25779697f, -0.06380531f, -0.00312100f, -0.19692752f, -0.09894305f, -0.03993935f, -0.17546867f, 0.12780248f, 
    -0.21385324f, 0.12879476f, -0.16472203f, -0.01296983f, 0.05276979f, -0.07101709f, 0.00531386f, 0.11124939f, 
    -0.02591764f, 0.10997376f, 0.09150300f, 0.10401128f, 0.07491201f, -0.09466385f, 0.01189513f, -0.11704453f, 
    0.07798772f, 0.11037832f, -0.17741583f, 0.15934171f, 0.03104661f, 0.13819899f, 0.23946455f, -0.02305957f, 
    -0.32960236f, -0.13046271f, 0.00912039f, 0.19400650f, -0.19786391f, -0.04916954f, 0.18521762f, -0.26641092f, 
    -0.17018838f, 0.27793509f, -0.16194631f, -0.18246004f, -0.28926629f, -0.15891729f, 0.08934820f, 0.16244851f, 
    -0.06682078f, -0.10019159f, -0.02549626f, -0.07453130f, 0.03931310f, 0.08806908f, -0.18128686f, 0.08532818f, 
    -0.14463031f, -0.04504843f, -0.02811243f, 0.05350646f, 0.01933311f, 0.06602886f, -0.11222258f, -0.27722615f, 
    -0.18615265f, 0.22913791f, 0.02195014f, 0.00715548f, -0.06554577f, -0.10922266f, 0.05429883f, 0.11483977f, 
    -0.36071903f, 0.08040993f, -0.36229280f, -0.05896973f, 0.24036562f, 0.14968954f, -0.05110154f, -0.07588228f, 
    0.13976096f, -0.01067312f, -0.08414909f, -0.04581237f, 0.12446957f, 0.08499179f, -0.05231570f, -0.02563056f, 
    -0.03890152f, 0.15879400f, -0.45214456f, -0.04548715f, -0.10391101f, 0.00290856f, -0.10199053f, -0.14641517f, 
    -0.01242966f, -0.13113979f, 0.14522289f, -0.04833194f, -0.19326803f, 0.37243077f, -0.16552080f, 0.02175643f, 
    -0.01682494f, -0.23262562f, -0.14363723f, 0.12280557f, 0.31199268f, 0.19507390f, -0.02477459f, -0.00487802f, 
    -0.14258492f, -0.05588745f, 0.10249157f, 0.04275875f, 0.35828400f, -0.18578133f, -0.29072952f, -0.66092002f, 
    -0.09408808f, -0.07121922f, -0.25569430f, -0.01891705f, 0.06741149f, 0.15714617f, -0.55003244f, -0.05560836f, 
    0.03124661f, 0.06402142f, -0.07852634f, -0.01017777f, 0.14379556f, -0.01783093f, 0.02655211f, -0.20559023f, 
    0.30227378f, 0.16850033f, 0.12089380f, 0.29136401f, 0.07405974f, 0.20745730f, -0.08842575f, 0.04397065f, 
    -0.10725433f, 0.18105340f, -0.32282928f, -0.13079117f, -0.02830365f, 0.01803964f, 0.00781815f, -0.11111321f, 
    -0.07775607f, -0.19540916f, -0.10984066f, -0.26537371f, -0.04133413f, 0.13832504f, 0.19625153f, -0.05074261f, 
    -0.08472669f, -0.22103415f, -0.04276473f, 0.41862869f, -0.70352083f, -0.08849425f, -0.06885778f, -0.16694750f, 
    0.02147711f, 0.16014141f, 0.16409853f, -0.41909707f, -0.02433783f, -0.04911537f, -0.08478165f, 0.01030735f, 
    0.02410125f, 0.03077235f, 0.01897253f, 0.17318253f, 0.06638827f, -0.08051962f, 0.37743947f, -0.10217206f, 
    0.06455116f, -0.19160154f, 0.14890413f, -0.10219347f, 0.03304848f, -0.04524772f, -0.07590334f, -0.39503798f, 
    0.20896237f, -0.02332764f, -0.03902454f, 0.10810411f, 0.22219619f, 0.02230568f, -0.23441422f, -0.15633734f, 
    0.14292051f, 0.07312031f, -0.08076518f, 0.04402509f, 0.01310896f, -0.11375513f, -0.07510990f, -0.32444632f, 
    0.12443855f, 0.18337919f, 0.03261486f, 0.12298841f, -0.01914477f, -0.08411360f, -0.05137470f, -0.12798244f, 
    -0.24685960f, 0.05109673f, -0.27713355f, 0.00891123f, 0.29578760f, 0.27124509f, -0.15948758f, -0.01599356f, 
    0.19016746f, -0.17326239f, 0.04040819f, -0.05716176f, -0.04799820f, 0.02432901f, -0.16842742f, -0.00702506f, 
    -0.01798620f, -0.05470155f, 0.11960104f, 0.11095640f, 0.23115078f, 0.06943118f, 0.22324826f, 0.02443593f, 
    0.02775700f, 0.26434684f, 0.01150071f, 0.31119573f, 0.12134061f, 0.28185198f, 0.21364775f, 0.20192094f, 
    0.12647723f, 0.18813752f, 0.09367378f, 0.06248910f, -0.52298719f, -0.28360167f, -0.11359283f, 0.00432064f, 
    -0.09134132f, 0.04864161f, -0.03243178f, -0.04326858f, -0.05302668f, -0.02380552f, 0.01375973f, -0.28535992f, 
    -0.04230811f, 0.08087374f, -0.16722776f, 0.04539513f, 0.27039170f, 0.04768403f, -0.24823660f, 0.13370991f, 
    0.01419140f, -0.06740472f, 0.16460299f, 0.00291386f, 0.10013269f, -0.13590972f, 0.08186083f, 0.04434313f, 
    -0.03646870f, 0.23457594f, -0.06837656f, 0.18557762f, -0.01285421f, -0.04905831f, 0.01374047f, 0.08657065f, 
    0.05663134f, 0.01847659f, -0.18477203f, 0.07245789f, 0.10936769f, -0.21136113f, 0.23415421f, -0.16855378f, 
    -0.15187068f, 0.28250760f, 0.34684101f, 0.34293288f, 0.19753341f, 0.13593176f, -0.13982506f, 0.07766023f, 
    0.11859448f, 0.00812203f, 0.09275034f, 0.10115624f, -0.11035274f, 0.03083447f, 0.02480724f, 0.02298412f, 
    0.11354991f, -0.18214257f, -0.00337681f, -0.41360369f, 0.03538725f, -0.07053208f, -0.03655719f, -0.08419649f, 
    0.06136877f, -0.07214596f, -0.12454866f, 0.19786666f, 0.00393852f, 0.19742580f, -0.24498285f, 0.05398747f, 
    -0.17519955f, 0.09046911f, -0.05623853f, -0.00188949f, 0.14390461f, -0.04751326f, -0.12501141f, -0.00767548f, 
    -0.09783422f, 0.04232702f, -0.03110171f, -0.02516864f, -0.19370584f, -0.03044045f, 0.13892382f, 0.17542912f, 
    0.06730421f, 0.02229689f, 0.15477706f, -0.05290239f, 0.02581673f, 0.10456791f, 0.34415182f, 0.20545155f, 
    0.16631275f, 0.11889312f, 0.02018922f, 0.10421665f, 0.05240694f, 0.10017664f, 0.00768073f, -0.03582985f, 
    0.25737485f, 0.27994782f, -0.08732291f, -0.11676252f, -0.11675982f, 0.08186132f, 0.05321643f, 0.23846242f, 
    0.11323796f, 0.06872092f, -0.22229773f, -0.02800453f, 0.14211819f, -0.12890899f, 0.04883613f, 0.08851425f, 
    0.03260665f, -0.12995133f, 0.14941494f, 0.18500546f, 0.00999639f, -0.17638195f, -0.20597826f, 0.12997060f, 
    -0.02537856f, 0.02771595f, 0.01959201f, 0.18328822f, -0.11358099f, -0.27582765f, -0.21172898f, 0.11933638f, 
    0.17141439f, -0.09652424f, -0.17512329f, -0.01711046f, 0.44609746f, -0.12774789f, -0.00981095f, -0.15951204f, 
    -0.07760245f, 0.19253913f, 0.06784669f, -0.28633136f, -0.10770232f, 0.32074174f, 0.20354342f, -0.23612198f, 
    0.03125745f, 0.13482949f, -0.20362723f, -0.28908125f, 0.11085412f, -0.16882594f, 0.02030221f, 0.09493084f, 
    0.12591998f, -0.12820542f, 0.03023632f, 0.16442320f, 0.08987043f, 0.00296836f, -0.17305842f, -0.00229575f, 
    -0.15126805f, -0.02343498f, 0.07314308f, 0.02626396f, 0.05882806f, -0.12140565f, -0.11498712f, 0.04219909f, 
    0.04322317f, 0.10715362f, -0.10541669f, 0.27504683f, 0.12796728f, 0.20473088f, -0.11314387f, 0.08132552f, 
    -0.04503243f, 0.10352966f, 0.18632066f, -0.09155828f, 0.14274624f, 0.03552445f, -0.00143907f, 0.08846095f, 
    0.04621593f, -0.27008241f, 0.06451011f, 0.36329567f, -0.14035743f, -0.07931079f, 0.06684535f, 0.07879906f, 
    0.03279190f, 0.05505653f, -0.00832566f, 0.20049353f, 0.34548178f, -0.33989134f, 0.10990786f, 0.06737278f, 
    0.11787336f, -0.02801917f, -0.11874834f, 0.09332854f, 0.21286902f, -0.02752980f, -0.12221137f, -0.05082142f, 
    -0.24865578f, 0.07688206f, 0.03345809f, 0.11515646f, 0.12871978f, 0.04214114f, 0.02569028f, -0.36854935f, 
    -0.03665076f, 0.02975679f, 0.01968182f, 0.13542031f, 0.00227007f, 0.05947385f, -0.46737584f, 0.06296456f, 
    -0.13435164f, 0.01379811f, -0.00949765f, -0.00275451f, -0.12738317f, 0.16375475f, 0.17179763f, 0.07500079f, 
    0.15689424f, -0.20273870f, 0.18676975f, 0.09341881f, 0.09960347f, -0.01375121f, 0.07287696f, 0.20815851f, 
    -0.11415293f, 0.17276853f, -0.07341454f, -0.09785195f, -0.17981578f, 0.04857981f, 0.00898868f, 0.04432098f, 
    0.00589230f, -0.43919623f, -0.11152412f, -0.06505326f, 0.21683162f, 0.00604154f, -0.07399875f, -0.17130847f, 
    -0.08752211f, 0.29100302f, -0.04959653f, -0.02968318f, 0.02990805f, -0.16609424f, -0.00760268f, 0.02776775f, 
    -0.09159932f, -0.06734647f, -0.01366743f, 0.17547904f, -0.11984378f, -0.01394661f, 0.10920149f, 0.12599203f, 
    -0.13400157f, -0.04974917f, -0.09104218f, 0.06371266f, -0.17423084f, 0.13073881f, 0.04634113f, -0.02978426f, 
    0.11035122f, -0.00554904f, 0.15773094f, 0.29197595f, 0.08580943f, -0.21697876f, 0.30300137f, 0.20580953f, 
    -0.21462351f, -0.04002278f, 0.09511657f, -0.30339193f, 0.12838528f, -0.18004057f, 0.06225091f, -0.02148597f, 
    0.12667280f, 0.10885267f, 0.05120884f, -0.09307493f, 0.19008893f, 0.10144117f, -0.13432002f, -0.11504821f, 
    -0.31382665f, 0.00346477f, -0.10886841f, 0.00677920f, -0.06947542f, -0.02824937f, 0.17536969f, 0.09745748f, 
    0.39251658f, -0.42428032f, 0.04079894f, 0.07641945f, -0.11138519f, 0.07080732f, 0.08725595f, 0.11408228f, 
    -0.13118762f, -0.03410053f, 0.17106086f, -0.18852463f, -0.12161675f, -0.18103421f, 0.00273866f, 0.10593045f, 
    0.08672400f, 0.15858988f, -0.45639339f, -0.18128614f, 0.10352707f, 0.00816600f, -0.01500881f, 0.19644888f, 
    0.03255621f, -0.03469891f, -0.09403992f, -0.16809751f, 0.01377786f, 0.04882306f, 0.03477000f, -0.21824740f, 
    0.10703930f, 0.05658929f, 0.17956156f, 0.08639707f, 0.26266381f, 0.01051315f, -0.06423071f, 0.18881957f, 
    -0.03733341f, 0.06173271f, -0.06766330f, -0.20921925f, -0.07567089f, 0.22937986f, -0.33931351f, -0.14331737f, 
    0.11328234f, 0.21826039f, 0.03632212f, 0.07206361f, -0.12901419f, -0.13952152f, 0.23772646f, -0.14899443f, 
    0.08813373f, -0.00028913f, 0.06859602f, 0.10101804f, -0.18787022f, -0.06515940f, -0.01632469f, 0.22757417f, 
    -0.43285865f, -0.14969467f, 0.06925162f, 0.05865083f, 0.08965777f, 0.01594590f, 0.11505699f, -0.08694291f, 
    0.12062115f, 0.22833471f, 0.09159586f, 0.06819797f, 0.06714761f, 0.06524055f, 0.13949466f, 0.01209033f, 
    -0.16819327f, 0.75963265f, 0.27537602f, 0.02534706f, -0.16852534f, -0.03562956f, -0.16422200f, -0.12276186f, 
    0.08907339f, -0.24007630f, 0.42853418f, 0.31412205f, 0.11558825f, 0.03691927f, -0.46923453f, -0.18763082f, 
    0.07233723f, 0.09255308f, -0.16186580f, 0.06193539f, -0.00482584f, -0.24359447f, -0.10937301f, 0.09725375f, 
    0.00635933f, -0.09891966f, -0.10676570f, -0.04132107f, 0.15084934f, -0.10060883f, -0.08184583f, -0.04764769f, 
    -0.00292485f, -0.09861217f, -0.10265561f, -0.01198518f, 0.00615340f, 0.17068541f, 0.22452798f, -0.13962375f, 
    -0.01069436f, -0.12414932f, -0.07218019f, -0.01499079f, -0.08001236f, 0.19214292f, 0.23162754f, 0.09756795f, 
    0.23444360f, 0.08375361f, 0.12719056f, -0.04485195f, -0.12786792f, 0.18045931f, -0.12664366f, 0.17542639f, 
    -0.42674282f, -0.26714984f, 0.07984958f, -0.09802382f, 0.08920071f, -0.00615506f, -0.16210754f, -0.08557003f, 
    0.25582182f, 0.34949869f, 0.28620103f, -0.05119313f, 0.12441394f, 0.13437220f, -0.24977092f, 0.12914805f, 
    0.09301078f, 0.20544282f, 0.42311302f, 0.18024570f, 0.06459441f, -0.10966535f, 0.15732028f, -0.06374182f, 
    -0.02425556f, -0.00763938f, 0.26422808f, 0.29354233f, 0.06623926f, -0.01096069f, -0.00688900f, 0.33320224f, 
    0.02004509f, 0.14534150f, -0.05680859f, -0.10565156f, -0.00096836f, -0.03501730f, 0.05269232f, -0.04882582f, 
    0.05874850f, -0.08489627f, -0.17088866f, -0.00257153f, -0.14145917f, -0.00742659f, -0.26432005f, -0.00333635f, 
    -0.04048327f, -0.22376315f, -0.18548091f, 0.20626114f, -0.06240075f, 0.12270626f, 0.15696777f, -0.09683789f, 
    0.01077625f, -0.03819801f, -0.10964601f, -0.04777555f, 0.03802406f, -0.14385699f, -0.02735856f, 0.01589102f, 
    -0.01548236f, -0.09133557f, -0.02114716f, -0.17856167f, 0.02438461f, -0.07930338f, 0.31882635f, 0.22796598f, 
    0.19553766f, 0.02607692f, -0.01560195f, 0.10387286f, 0.01073170f, 0.11392806f, 0.08010553f, 0.05116623f, 
    -0.07941976f, 0.29568321f, -0.03415141f, -0.09186997f, -0.07947426f, -0.15293683f, 0.05369232f, 0.11254784f, 
    -0.16291678f, 0.37175518f, 0.26315880f, 0.11896441f, 0.21622413f, 0.10943751f, -0.31923199f, 0.00349737f, 
    0.01705020f, 0.31781751f, 0.06548154f, -0.31551209f, 0.01818213f, 0.08466646f, 0.06809203f, -0.15443239f, 
    0.09258291f, -0.01603854f, -0.12742643f, -0.04451623f, -0.32242075f, -0.20329517f, -0.25257885f, 0.09164929f, 
    -0.04716804f, -0.16730949f, 0.11091018f, -0.24498665f, 0.20510522f, 0.11461501f, 0.09140071f, -0.04250776f, 
    0.00201389f, 0.02047230f, -0.03475165f, 0.19000067f, 0.11389352f, 0.11927617f, 0.23694114f, 0.29860327f, 
    -0.02177580f, -0.04372065f, -0.05876895f, -0.16157967f, -0.08691493f, -0.00577040f, 0.03312293f, 0.01397448f, 
    -0.17894986f, 0.02090673f, 0.01406435f, 0.18129164f, -0.10272043f, -0.20841642f, 0.00761108f, -0.37029350f, 
    -0.38396698f, -0.04967677f, 0.04992903f, 0.11053903f, 0.02422348f, 0.04410959f, 0.10244714f, 0.11542758f, 
    -0.17626122f, -0.45607713f, -0.44778889f, -0.23778915f, 0.06568746f, 0.03588853f, 0.01304641f, 0.00615386f, 
    -0.17888600f, -0.21886349f, -0.17111056f, -0.06889251f, -0.20152938f, -0.07582438f, -0.01452959f, -0.03925861f, 
    0.23148605f, -0.20808518f, -0.56167608f, -0.27307332f, 0.01264305f, -0.04042698f, -0.02161208f, 0.00190726f, 
    -0.23935775f, -0.01122386f, 0.27026546f, 0.27792367f, 0.01974562f, -0.21339223f, -0.07031657f, 0.02615680f, 
    -0.16531762f, -0.09334763f, 0.00541377f, 0.03362734f, 0.14519104f, 0.14773771f, -0.08875564f, -0.11218946f, 
    -0.03771801f, -0.08883474f, -0.10334045f, -0.07588694f, 0.00563793f, 0.19930804f, -0.07286739f, -0.10393383f, 
    -0.18491140f, 0.01580073f, 0.07699040f, 0.00412618f, 0.12718062f, -0.02456529f, -0.10435817f, 0.12845068f, 
    -0.01532898f, 0.01055033f, 0.06293377f, -0.24305943f, -0.06921940f, -0.09307534f, 0.18152228f, -0.34411067f, 
    -0.29826951f, -0.27213451f, 0.00390764f, -0.01739104f, -0.00476778f, -0.07247672f, -0.13962798f, -0.03937124f, 
    0.00207637f, 0.05396663f, -0.03025261f, -0.05405943f, 0.01917060f, -0.00437969f, -0.01500892f, 0.03573703f, 
    0.02646565f, -0.02948183f, 0.01406460f, 0.01275393f, -0.01228174f, 0.02826509f, -0.02316631f, -0.04451645f, 
    0.02580646f, -0.02692168f, 0.04231519f, 0.03500091f, -0.00474170f, -0.04846798f, -0.04613427f, -0.01161608f, 
    -0.00424214f, 0.02078851f, -0.01647699f, -0.04083324f, -0.06217001f, 0.04895649f, 0.04041191f, 0.02117126f, 
    0.00754678f, 0.03980275f, 0.03374203f, -0.01881864f, -0.01584595f, 0.04527098f, 0.02932383f, -0.05885694f, 
    0.01593037f, 0.03708677f, -0.02395141f, -0.03080048f, -0.02310538f, -0.01985884f, -0.00121283f, -0.02624067f, 
    0.04884608f, -0.03694547f, -0.05138161f, 0.02025280f, -0.04436477f, 0.04007214f, 0.02247606f, -0.06224507f, 
    -0.00496739f, -0.01492000f, -0.03828896f, -0.05886193f, 0.04497413f, -0.04957860f, -0.01543856f, -0.03316067f, 
    0.04342904f, -0.04677886f, -0.01088484f, -0.05811348f, -0.04874807f, -0.04685579f, -0.05471788f, 0.03227522f, 
    0.00084557f, -0.04111902f, 0.02642559f, 0.02725400f, 0.02968988f, -0.06124060f, 0.02707068f, 0.03417754f, 
    0.04140300f, -0.05614297f, 0.00891542f, -0.05651810f, -0.03398030f, -0.03741960f, 0.05000236f, -0.03587266f, 
    -0.03695994f, -0.03472847f, -0.00411964f, 0.02708007f, 0.03389740f, 0.03627178f, 0.03403031f, -0.04546905f, 
    0.04878393f, 0.03044156f, -0.01827985f, 0.01638259f, 0.03036602f, 0.02731017f, 0.01142396f, -0.02110055f, 
    0.04118511f, 0.00258029f, -0.05653146f, -0.03877914f, 0.00034574f, -0.01411767f, -0.04957444f, -0.02481818f, 
    0.03540627f, -0.05883348f, 0.03103513f, -0.01024032f, -0.02475384f, 0.03795524f, 0.03795291f, 0.04748302f, 
    0.00266440f, -0.00869994f, 0.03616291f, -0.02378661f, -0.03366346f, 0.04497034f, -0.01044073f, 0.02959830f, 
    -0.02926814f, 0.03572341f, 0.00294666f, 0.02513371f, 0.04581910f, 0.03987584f, 0.03012579f, 0.03971714f, 
    -0.03589474f, -0.03667977f, -0.00977238f, -0.03137005f, 0.00243962f, -0.02128942f, 0.03030155f, 0.02066506f, 
    -0.00144259f, 0.05289475f, -0.02398344f, 0.00539207f, -0.02321104f, -0.05839798f, -0.03423290f, -0.01473392f, 
    -0.02946128f, 0.04851179f, 0.02239348f, 0.03648011f, -0.02651297f, -0.04347076f, -0.01192738f, -0.02230738f, 
    0.00670552f, -0.03015215f, -0.06577800f, 0.02522248f, 0.03864389f, -0.01738044f, 0.04060483f, 0.04247420f, 
    -0.00065290f, -0.00543590f, 0.02979900f, 0.04882879f, -0.02210821f, -0.02572782f, -0.03530581f, -0.00873447f, 
    -0.02814278f, -0.02109369f, -0.03311426f, 0.04174591f, -0.01839937f, -0.06230445f, 0.01769714f, -0.01722756f, 
    -0.04902623f, -0.01520632f, 0.04245705f, -0.03480778f, -0.02098888f, -0.00698461f, -0.00895355f, -0.02207425f, 
    -0.02322217f, 0.03112076f, 0.03845293f, -0.03610030f, 0.00283202f, 0.02657119f, -0.06329261f, 0.00122419f, 
    -0.02535850f, -0.04418241f, -0.06709552f, -0.06554346f, -0.04760263f, 0.01432061f, -0.00373202f, 0.03058080f, 
    0.00029995f, 0.04466546f, 0.02023189f, -0.01720598f, -0.04130322f, -0.04176061f, -0.03513675f, 0.03945650f, 
    -0.00262065f, -0.00920157f, 0.01587835f, 0.04716748f, 0.00902740f, -0.00665219f, -0.01438945f, -0.01519245f, 
    -0.06408372f, -0.05522536f, 0.04521600f, -0.04113790f, 0.00024536f, -0.03294668f, -0.06643954f, -0.02832947f, 
    0.02391583f, -0.03552850f, 0.04481635f, 0.02141043f, 0.02174618f, 0.04268879f, -0.00899921f, -0.02089487f, 
    -0.04255947f, -0.03110193f, -0.00562181f, 0.00716953f, -0.01829620f, 0.03064280f, -0.00564198f, -0.00557173f, 
    0.03122096f, 0.00304348f, -0.02143557f, -0.06018696f, 0.00257890f, 0.00825232f, -0.00728233f, -0.02526927f, 
    -0.02437300f, -0.06141671f, -0.05135104f, 0.04643558f, 0.00596397f, 0.00833298f, -0.03738191f, 0.03433283f, 
    -0.00724446f, -0.06426044f, 0.01782560f, -0.04836856f, 0.01534666f, -0.01617561f, -0.03013022f, 0.03525821f, 
    -0.05106403f, -0.01858083f, 0.00667937f, 0.02184266f, -0.06723352f, -0.01243630f, -0.01588004f, -0.05235745f, 
    -0.04777086f, -0.05514680f, -0.04359530f, -0.02978947f, -0.04368059f, 0.01847383f, -0.03088954f, 0.04472735f, 
    0.08211941f, -0.27884051f, -0.12561417f, -0.12952749f, 0.01224049f, 0.00231681f, -0.04171043f, -0.10413904f, 
    0.17220645f, 0.29522526f, -0.03813695f, 0.07336644f, -0.07612337f, -0.12495943f, 0.18868907f, 0.04493980f, 
    0.14678641f, 0.06734639f, -0.06897376f, -0.12732598f, 0.21804549f, -0.16081777f, 0.15157986f, -0.07026588f, 
    -0.01380511f, -0.16754504f, -0.14169669f, 0.09562542f, 0.12705889f, 0.20351978f, 0.00084762f, 0.00825546f, 
    0.10225525f, 0.12224937f, 0.10827270f, 0.08297782f, -0.12094842f, 0.25964451f, -0.18836881f, 0.03733380f, 
    0.15286203f, -0.12950414f, 0.01823233f, 0.08383087f, 0.06243777f, 0.18974213f, 0.04668794f, -0.23527557f, 
    -0.14993611f, -0.05904445f, -0.08732678f, -0.08267443f, 0.18816075f, 0.05262377f, 0.27884933f, 0.04019650f, 
    0.08856142f, -0.17390931f, -0.08256197f, 0.00938755f, 0.25976166f, 0.09796706f, -0.05246047f, -0.05368317f, 
    0.21084180f, 0.17892563f, 0.05428033f, 0.16445278f, 0.01963156f, -0.03135297f, 0.04029661f, -0.04365202f, 
    -0.19748850f, 0.33801079f, 0.31010282f, 0.08178142f, 0.00379876f, 0.04705975f, 0.15081266f, -0.10975620f, 
    0.29389608f, 0.03619246f, 0.10108522f, 0.07904422f, -0.00254894f, -0.02372176f, 0.17941569f, 0.00917344f, 
    0.22243404f, 0.30796728f, -0.14510672f, -0.04022902f, -0.00322743f, 0.08445905f, -0.09954277f, 0.05794469f, 
    0.03375299f, -0.04444795f, 0.28205228f, 0.18040429f, -0.10954290f, 0.05198513f, -0.11546201f, 0.10069460f, 
    0.11111981f, 0.04770482f, -0.14132792f, 0.03099319f, -0.26890251f, 0.16310464f, -0.05734113f, 0.18745553f, 
    0.03053969f, 0.17148317f, 0.02426660f, 0.13445093f, -0.24482147f, 0.01764099f, -0.00755501f, -0.11330473f, 
    -0.08693662f, 0.10012097f, -0.26330873f, -0.07881507f, 0.07941306f, 0.10186692f, 0.18232751f, 0.11088626f, 
    -0.24283074f, -0.16570137f, 0.15101019f, 0.09418955f, -0.08730764f, 0.01893651f, -0.21743304f, 0.00581172f, 
    0.09956382f, -0.00252254f, -0.05474002f, 0.16954461f, 0.08696812f, 0.03339576f, -0.25550240f, -0.13106094f, 
    0.02706113f, -0.03082233f, -0.17007595f, -0.04567275f, 0.16735475f, 0.17813051f, -0.03898583f, -0.02281241f, 
    -0.00180277f, 0.11808277f, 0.28627694f, 0.01195699f, -0.05160495f, 0.25036225f, 0.07022444f, 0.13220778f, 
    -0.06505311f, -0.04737074f, -0.27120119f, -0.20324290f, -0.12598063f, -0.04203842f, 0.02103512f, 0.08056656f, 
    0.15349990f, 0.12366573f, -0.17233525f, 0.17410506f, 0.06447263f, -0.21957646f, -0.06935266f, 0.11830649f, 
    -0.03919298f, 0.09479178f, -0.18896392f, -0.18717243f, 0.11150894f, -0.07564225f, 0.02605043f, 0.08008078f, 
    -0.09305462f, 0.03240312f, 0.06059195f, 0.19839299f, -0.18327262f, 0.12122390f, 0.00953112f, -0.01272673f, 
    0.09438532f, -0.21220349f, -0.14091711f, 0.05625258f, -0.09021702f, -0.02615877f, 0.11792625f, 0.01760361f, 
    -0.12983271f, 0.00835280f, -0.15289943f, 0.10189766f, -0.00217957f, -0.07665095f, 0.00708355f, -0.48800382f, 
    0.13210313f, 0.03825633f, 0.04023178f, 0.03543596f, 0.06368626f, 0.06585119f, -0.19026805f, 0.01940943f, 
    -0.43610179f, 0.17014804f, -0.04335110f, 0.22569923f, 0.02586843f, -0.00189043f, -0.08897141f, 0.04972322f, 
    0.07755785f, -0.53397536f, -0.00610191f, -0.05423568f, -0.08440696f, 0.04599836f, 0.23309217f, 0.22596198f, 
    -0.11392312f, -0.26700976f, 0.11043825f, -0.02087835f, -0.27952775f, 0.02882534f, 0.15819171f, -0.35473558f, 
    -0.08590899f, 0.05580194f, -0.01255230f, 0.16423565f, 0.14595884f, -0.02741355f, -0.16139504f, 0.14454757f, 
    -0.04461723f, -0.00496271f, -0.06866363f, -0.30295554f, 0.16114928f, 0.15159281f, -0.11895873f, 0.03212744f, 
    0.11850006f, -0.30729073f, -0.32791120f, -0.00148579f, 0.04823388f, -0.25562593f, 0.12730503f, -0.08945478f, 
    -0.00896113f, 0.22013983f, 0.02557273f, -0.13669847f, 0.00748435f, 0.03579944f, 0.12392680f, -0.04987134f, 
    -0.28073081f, 0.19720128f, 0.02614931f, -0.11294248f, -0.01702587f, -0.14948237f, -0.09599688f, -0.38080737f, 
    0.25848433f, 0.16253476f, 0.12342404f, -0.03272833f, 0.03184379f, 0.12742080f, -0.04145666f, -0.09534715f, 
    -0.04331245f, 0.15412258f, -0.25940967f, -0.15153807f, 0.07451431f, 0.03817288f, -0.07086662f, -0.00244896f, 
    -0.24795082f, -0.18706276f, -0.11342924f, -0.02734699f, 0.20003206f, -0.02747035f, 0.01314442f, 0.13001101f, 
    -0.08358037f, 0.05603861f, 0.11220028f, 0.09629256f, -0.58222175f, -0.07509094f, 0.13667293f, 0.06768333f, 
    -0.19271827f, -0.08461861f, -0.13023803f, 0.14716187f, -0.09917015f, 0.06948026f, 0.15569608f, -0.02750588f, 
    0.19714819f, 0.08967351f, 0.02860194f, 0.15535769f, 0.16407470f, 0.24212329f, -0.15254509f, 0.13622770f, 
    -0.00635935f, 0.16223972f, -0.14269468f, -0.05791303f, -0.03892792f, -0.40362710f, -0.08686429f, -0.34916195f, 
    0.29590181f, -0.02175617f, 0.14114390f, -0.14359206f, 0.01716256f, -0.31341663f, -0.17626537f, -0.28980196f, 
    -0.10247838f, -0.35658148f, 0.04008678f, -0.11876950f, 0.04806632f, 0.01260869f, -0.01768715f, 0.05480206f, 
    0.22112478f, 0.09365868f, -0.22355257f, 0.19774641f, 0.26314721f, 0.02362270f, -0.05509677f, 0.12125862f, 
    0.09257156f, 0.15581612f, -0.12264097f, -0.18423486f, -0.04398245f, -0.23438521f, -0.40593633f, -0.02179714f, 
    -0.16592318f, 0.02905543f, -0.07807984f, -0.52319777f, 0.02280983f, -0.01849779f, -0.01213722f, 0.04714181f, 
    0.05653626f, -0.13191414f, 0.02045197f, 0.30638757f, 0.03258802f, -0.18301436f, 0.12771848f, -0.08088669f, 
    -0.13083965f, -0.00663160f, 0.00308757f, -0.24199976f, -0.09640204f, 0.17744435f, 0.05004977f, 0.13415384f, 
    -0.01079641f, 0.03265657f, 0.12791197f, 0.06463481f, 0.11480650f, 0.21348193f, 0.21133570f, -0.18734841f, 
    -0.02763540f, 0.04414053f, 0.03246833f, 0.18105511f, 0.16583176f, -0.03309139f, 0.26027817f, -0.21093476f, 
    -0.19047180f, -0.03745108f, 0.07727692f, 0.21324284f, -0.02948674f, -0.00401460f, -0.12633874f, -0.30611444f, 
    -0.12900257f, 0.02433124f, -0.02982795f, 0.07802635f, 0.11276086f, 0.19733202f, 0.01358260f, -0.26277444f, 
    0.13823175f, -0.10638840f, 0.11942387f, 0.06880506f, -0.21110603f, -0.07945294f, 0.03797043f, 0.03986803f, 
    -0.21662121f, 0.11421560f, -0.24527928f, 0.00209431f, -0.04813554f, -0.03433673f, 0.04176258f, 0.03495321f, 
    -0.16033305f, -0.40326482f, -0.28477636f, -0.18915699f, 0.04927222f, -0.05418006f, -0.27099878f, 0.11804646f, 
    -0.10948132f, 0.10462137f, -0.08250729f, 0.20052074f, -0.02483260f, 0.21160890f, -0.12059045f, 0.02992774f, 
    -0.03222288f, 0.03511237f, -0.01161772f, 0.14354436f, 0.08434826f, -0.15948524f, -0.02663230f, 0.09642974f, 
    0.10063872f, 0.09323821f, -0.14685249f, -0.08317783f, -0.04807678f, -0.27090946f, -0.11587083f, -0.16567515f, 
    -0.00997511f, 0.03227244f, -0.10819420f, 0.05381658f, -0.13099729f, -0.02858650f, -0.35708192f, 0.02272344f, 
    -0.03203313f, 0.04238607f, 0.22257651f, -0.03611306f, 0.10486036f, -0.35048833f, -0.12982993f, 0.01908051f, 
    0.04509951f, -0.19185793f, -0.11281330f, 0.02678465f, 0.06561483f, 0.17154725f, 0.05811976f, 0.28668493f, 
    0.23964052f, -0.09507694f, 0.17894338f, 0.24371393f, 0.08357201f, -0.15062910f, 0.11738596f, 0.08076211f, 
    0.40949416f, 0.25327915f, -0.12965244f, 0.22689739f, -0.01555079f, 0.08233309f, -0.16047710f, -0.13562120f, 
    0.02671655f, 0.13801724f, 0.09782088f, 0.09721597f, 0.12732877f, -0.11096539f, -0.09649856f, -0.13706107f, 
    0.10819554f, 0.11044398f, 0.19378531f, -0.14916776f, -0.15343845f, 0.27510378f, 0.06295416f, 0.14355814f, 
    0.00842096f, 0.02811395f, -0.16382784f, 0.40884107f, 0.08231742f, 0.12408542f, -0.00402976f, -0.06548892f, 
    0.08141620f, 0.34613827f, 0.12222604f, 0.11596555f, 0.16894263f, 0.14962746f, -0.19285572f, 0.12810637f, 
    0.05239841f, 0.14486025f, -0.23488034f, 0.09874371f, -0.16753370f, 0.21054697f, -0.10794393f, -0.30679816f, 
    0.15766752f, 0.03300044f, 0.11634155f, 0.06067287f, 0.11933880f, -0.10915756f, 0.08149116f, -0.14372927f, 
    -0.07755911f, 0.07139044f, 0.07996493f, 0.18992831f, 0.01918998f, -0.02363327f, -0.11194724f, 0.51084721f, 
    0.23474404f, 0.06272611f, 0.13033466f, 0.03169818f, 0.03908459f, -0.14789930f, 0.13241760f, 0.21727265f, 
    -0.02890154f, -0.12731475f, 0.30035877f, 0.12604678f, 0.09654730f, 0.03480157f, -0.00811768f, 0.07883143f, 
    -0.05515538f, -0.01198659f, 0.15739064f, 0.04270899f, -0.24180879f, -0.10774891f, 0.19949257f, 0.04249852f, 
    0.19842942f, 0.07860567f, 0.24428707f, 0.09254919f, 0.36628315f, 0.09564375f, -0.00543665f, -0.24002312f, 
    -0.03127110f, 0.16167685f, 0.11413842f, -0.04906934f, 0.24442485f, 0.14964683f, -0.15868920f, -0.18182510f, 
    -0.00642378f, -0.02871775f, 0.03526192f, -0.07557426f, 0.15903454f, 0.18212603f, 0.01126720f, 0.03867675f, 
    0.16574459f, -0.12382254f, 0.02053936f, 0.00299479f, 0.11906873f, 0.03302383f, 0.16491190f, -0.02038775f, 
    -0.25793999f, -0.12124567f, 0.05789610f, -0.02417919f, 0.22310607f, 0.05826410f, -0.10502041f, 0.05324185f, 
    0.12484328f, -0.04662715f, -0.02798607f, 0.18441676f, 0.08154647f, 0.25620022f, 0.02342607f, -0.16281675f, 
    0.06556466f, -0.11963745f, -0.11523402f, 0.00733835f, -0.21451676f, -0.21283676f, -0.03327249f, -0.06798091f, 
    0.22401014f, 0.29654860f, 0.30802745f, 0.04314119f, 0.08254766f, 0.03315529f, 0.03163318f, -0.15336102f, 
    -0.09129719f, -0.13249250f, 0.16377279f, 0.25240582f, 0.01916766f, -0.06635242f, 0.08993838f, -0.10073545f, 
    0.07814438f, 0.07582344f, -0.07312035f, 0.07930806f, 0.25781521f, 0.03068736f, 0.04474181f, 0.09098973f, 
    -0.03869495f, -0.01003869f, 0.01683063f, -0.19239947f, -0.20443195f, -0.02001379f, 0.04546832f, 0.06009313f, 
    -0.04797567f, -0.01681168f, 0.04675353f, -0.06453582f, -0.11459822f, 0.06491745f, -0.06500370f, -0.07130753f, 
    0.15727748f, -0.17758393f, 0.15734830f, 0.16416912f, -0.02550126f, -0.11453331f, -0.09919230f, 0.08649395f, 
    -0.01352966f, 0.28282952f, -0.12681873f, 0.00787221f, 0.08009215f, -0.00330016f, 0.15550572f, -0.01490114f, 
    -0.30681619f, -0.01609110f, -0.19849749f, 0.07239150f, 0.19892807f, -0.07569399f, -0.04445760f, 0.00260337f, 
    -0.03195310f, 0.00787304f, 0.06791072f, 0.01080723f, -0.07847489f, -0.08765352f, 0.01272104f, -0.04052861f, 
    0.06218720f, -0.11477045f, 0.26400357f, 0.16288103f, -0.01325638f, -0.01581516f, 0.13029768f, 0.09119648f, 
    0.10388048f, 0.15873802f, -0.00639438f, -0.05540118f, -0.00501392f, -0.01339227f, 0.21302995f, 0.03563507f, 
    -0.06122712f, -0.09200653f, 0.04222493f, 0.17604296f, -0.17093322f, 0.07159512f, -0.15907177f, 0.03864647f, 
    -0.09134805f, -0.15769625f, -0.00020220f, 0.12434047f, -0.07550172f, -0.06291195f, -0.05235239f, -0.01983418f, 
    -0.01909588f, 0.01185143f, 0.11417072f, 0.03561439f, 0.04036285f, 0.13742533f, -0.02281198f, 0.14184785f, 
    -0.10672010f, -0.04891496f, 0.13950194f, 0.11693835f, 0.08748400f, 0.07030421f, 0.04641327f, -0.04200627f, 
    0.22259356f, -0.02850350f, 0.03832736f, -0.04479031f, 0.05034429f, 0.00929665f, 0.24812116f, 0.00010966f, 
    -0.17302096f, -0.13498650f, -0.12426371f, 0.06419365f, -0.03332776f, 0.05468715f, -0.13928318f, -0.39813074f, 
    0.17222781f, -0.19260734f, 0.07488603f, 0.03646256f, 0.18642093f, 0.05630132f, 0.00122835f, -0.21699110f, 
    -0.78507197f, 0.16349886f, 0.08773883f, -0.05403037f, 0.15238969f, -0.30330595f, -0.05273223f, 0.14742310f, 
    0.14875446f, 0.01485164f, -0.33624449f, -0.24839596f, 0.13496369f, 0.07989223f, 0.14449142f, -0.01615139f, 
    -0.00064054f, -0.02475350f, 0.33438036f, 0.16313678f, -0.24447368f, -0.24236524f, -0.09720609f, -0.39967719f, 
    -0.04768829f, 0.23854688f, 0.07757987f, 0.17690229f, 0.25184977f, -0.08579906f, -0.21322083f, -0.00143046f, 
    -0.20285332f, 0.05138158f, 0.07019394f, 0.03182771f, 0.32976696f, -0.06848047f, -0.12889531f, -0.27185428f, 
    -0.08415186f, 0.03910120f, -0.01169383f, -0.08176603f, -0.03817886f, 0.26595390f, 0.02414686f, 0.07203465f, 
    0.05304613f, 0.06111300f, -0.15004648f, -0.26639533f, -0.12846507f, 0.13101184f, 0.14071232f, 0.00660327f, 
    -0.27665782f, 0.16840358f, 0.00317981f, 0.03861760f, -0.04349398f, -0.03577705f, 0.07972825f, -0.54525739f, 
    0.16573071f, -0.00415694f, -0.20705786f, 0.04260410f, -0.11880863f, -0.13323337f, -0.00692926f, -0.10169885f, 
    0.07180343f, 0.17820252f, 0.13360080f, 0.01328470f, 0.08971564f, -0.04819912f, -0.06908976f, 0.11971502f, 
    -0.07367400f, -0.03641836f, 0.11611943f, -0.30760333f, 0.02495322f, 0.02212304f, 0.02756338f, -0.09093556f, 
    0.09267674f, 0.03504956f, -0.17541726f, -0.00951779f, 0.04182082f, 0.22796510f, 0.14504540f, -0.15980670f, 
    0.09048703f, 0.09689250f, 0.32170695f, 0.12153068f, -0.23905393f, 0.29969347f, -0.03538886f, -0.05052489f, 
    -0.14314246f, -0.05325406f, -0.11826862f, 0.14611965f, 0.00398099f, -0.25818360f, 0.09055932f, 0.16448976f, 
    0.20836596f, 0.08806024f, 0.09409626f, 0.02206004f, 0.14516148f, -0.14638704f, -0.00986146f, 0.20414916f, 
    0.11242220f, -0.03562538f, 0.12526746f, 0.13416395f, -0.30694687f, 0.09400877f, 0.04355759f, 0.04164062f, 
    -0.10504369f, -0.14645602f, -0.14235196f, 0.09808452f, 0.31053156f, 0.07657335f, 0.11032868f, -1.06499434f, 
    -0.09746849f, 0.06878580f, 0.24868704f, -0.08341532f, -0.12657198f, -0.09458996f, 0.00707266f, -0.04641894f, 
    0.21668343f, 0.18921372f, 0.18195169f, 0.00428226f, -0.09202175f, -0.08917007f, -0.03362005f, 0.03409909f, 
    -0.14605789f, 0.17803757f, 0.04233330f, -0.20217654f, -0.23527461f, 0.12424503f, 0.03874051f, 0.14089993f, 
    0.00689306f, -0.20261188f, 0.11339939f, 0.39477882f, 0.16218184f, 0.09433824f, -0.06213752f, 0.09960917f, 
    -0.27824533f, 0.23175393f, 0.04394083f, -0.18589844f, 0.04969307f, 0.03601851f, -0.03211755f, 0.05039757f, 
    -0.24413085f, 0.03859964f, 0.00812360f, -0.02075750f, -0.12712801f, -0.22690526f, -0.26516584f, 0.03779409f, 
    -0.07785935f, -0.08257978f, 0.10377736f, 0.10931688f, 0.18383987f, -0.12783378f, 0.07867029f, 0.14017867f, 
    0.02381832f, -0.10593645f, 0.03619524f, 0.12735435f, 0.29882303f, 0.11213893f, 0.25529507f, 0.22067693f, 
    -0.04317174f, -0.04683546f, 0.13015176f, 0.05638435f, 0.00417492f, -0.05230347f, 0.13374028f, 0.30768961f, 
    0.21260859f, 0.12669742f, -0.19373298f, 0.29608846f, -0.15578708f, -0.16466230f, 0.03535979f, -0.04914289f, 
    0.21378137f, 0.26674703f, -0.01709661f, 0.04053732f, -0.12821032f, 0.13933036f, -0.03839608f, 0.18948759f, 
    -0.08592580f, 0.19961171f, -0.01832104f, -0.33624598f, 0.00978224f, -0.05103949f, -0.16842583f, 0.05716789f, 
    -0.12817089f, -0.25988740f, -0.39176410f, -0.21465437f, -0.10790980f, 0.20392130f, 0.09914511f, -0.04820037f, 
    -0.08051920f, 0.11374138f, -0.13820916f, -0.66184181f, 0.07899699f, -0.33827245f, 0.11498312f, -0.00475460f, 
    -0.12657928f, -0.07777261f, -0.10982965f, -0.01265026f, 0.30683944f, 0.40631312f, 0.09312565f, -0.00360346f, 
    -0.02637022f, 0.00814618f, -0.09117442f, 0.02481494f, -0.02763380f, -0.26752585f, 0.20891351f, -0.21522257f, 
    -0.11870672f, 0.09516864f, -0.01656725f, -0.11275063f, -0.12109635f, -0.01170279f, 0.36916468f, 0.21902688f, 
    0.04082062f, -0.24901374f, -0.09489910f, -0.22602601f, 0.09563925f, 0.18911923f, 0.12880524f, -0.38809562f, 
    -0.49414369f, -0.17422059f, 0.32935885f, 0.20573974f, 0.11470232f, 0.08248329f, 0.04455621f, 0.16267252f, 
    -0.28454176f, 0.05317844f, 0.01969087f, 0.14241455f, -0.16011758f, 0.03301578f, -0.03847720f, -0.01216293f, 
    0.09311008f, -0.06898087f, -0.23808952f, 0.05373264f, 0.16734524f, -0.00902495f, -0.10429630f, -0.09228283f, 
    0.00696963f, 0.19103140f, 0.37093842f, 0.32013556f, -0.23628803f, -0.05703911f, -0.18051872f, 0.02010448f, 
    0.00681063f, 0.03428685f, 0.13861373f, -0.25297067f, 0.10136940f, -0.28289720f, -0.03398404f, -0.40865767f, 
    -0.15090372f, 0.28150189f, -0.01298975f, 0.22338217f, 0.31736362f, 0.12953490f, -0.13300148f, 0.12223289f, 
    0.05640697f, 0.32454118f, 0.06164128f, 0.04426045f, 0.05095296f, -0.05982066f, -0.08839042f, -0.04698396f, 
    0.07025745f, 0.07468771f, 0.05488312f, -0.18266758f, -0.06955117f, -0.06263789f, -0.04572280f, 0.23848099f, 
    0.00388320f, -0.05792717f, 0.04297511f, 0.04392185f, -0.23953833f, -0.17725824f, -0.02725695f, -0.46066910f, 
    -0.27491382f, 0.06485044f, 0.23822874f, -0.02850806f, 0.06379425f, -0.13654777f, -0.12955900f, 0.03486017f, 
    -0.19199011f, -0.04164732f, 0.36567935f, -0.05055894f, 0.02255874f, -0.09398869f, 0.00041524f, -0.05396121f, 
    -0.05466592f, 0.22675455f, 0.07184479f, -0.05674135f, -0.06212824f, -0.11752888f, 0.07256538f, 0.11248865f, 
    0.01637588f, -0.01969961f, 0.20777060f, -0.27089387f, -0.02359047f, 0.02490703f, 0.14788887f, 0.01961744f, 
    -0.12824930f, 0.06021908f, -0.16673349f, 0.35750881f, 0.02999647f, -0.07448301f, -0.17987534f, 0.02415867f, 
    -0.08478408f, 0.00370021f, -0.08895911f, 0.00135849f, 0.03061051f, -0.07566739f, 0.04542474f, -0.03809233f, 
    0.02217897f, 0.02782264f, 0.12169186f, -0.16244192f, -0.19993518f, 0.27502859f, 0.11354338f, 0.39104348f, 
    -0.08733147f, -0.17513037f, -0.00479815f, -0.02731584f, 0.00599860f, -0.05128196f, -0.19724084f, -0.14972600f, 
    0.26036975f, 0.12750287f, -0.00571331f, 0.13981746f, -0.09915049f, -0.16303420f, -0.01858588f, 0.16942486f, 
    0.02338828f, -0.15918715f, 0.04622338f, 0.30498526f, -0.01166878f, -0.19862561f, 0.08409780f, -0.08173268f, 
    -0.83655608f, -0.40626311f, 0.21079013f, 0.14050981f, 0.02194520f, 0.13499400f, 0.00873788f, 0.06403405f, 
    -0.08010156f, -0.59913653f, -0.20852876f, 0.38443309f, -0.07428842f, -0.01040617f, 0.15455049f, -0.07364959f, 
    0.01764202f, 0.06617963f, -0.60207361f, -0.24243064f, 0.23894842f, 0.06961790f, 0.03712786f, 0.00859684f, 
    -0.10822707f, 0.11628103f, -0.01074427f, -0.47526756f, -0.05055166f, 0.23896882f, -0.00223850f, 0.04590789f, 
    0.10356239f, -0.06296296f, 0.13250545f, 0.16371125f, 0.12225243f, 0.18484622f, -0.05077267f, 0.02706521f, 
    0.02428606f, 0.00007316f, -0.04021825f, -0.24228914f, 0.10502803f, -0.07945568f, -0.10955536f, 0.17897674f, 
    0.15819615f, 0.08207294f, 0.11191630f, -0.12262154f, 0.21860071f, 0.03355649f, -0.00276222f, -0.03611468f, 
    0.00567851f, -0.04055487f, -0.06207059f, 0.08488117f, 0.04624359f, -0.05937356f, -0.01102435f, -0.39220610f, 
    -0.01596954f, 0.25675797f, 0.21835111f, 0.05774692f, 0.03077255f, 0.02596536f, 0.02537619f, 0.21033393f, 
    0.26325768f, -0.03340329f, 0.06372411f, 0.04665589f, 0.01339751f, 0.03024771f, 0.05619164f, -0.28321546f, 
    -0.18056986f, -0.21311305f, -0.05032181f, -0.21055120f, 0.09308687f, -0.10855678f, -0.11267489f, -0.10590851f, 
    -0.03772503f, 0.14240272f, 0.24878953f, 0.02190230f, -0.28097248f, 0.15852332f, -0.19615687f, 0.10662914f, 
    -0.08508466f, 0.02794968f, -0.07098190f, 0.08403413f, 0.28688830f, -0.19633582f, -0.03511264f, 0.13143344f, 
    -0.00360798f, -0.07879307f, 0.12294955f, -0.02811577f, -0.30457848f, -0.36927524f, 0.23973633f, -0.19467555f, 
    -0.08318410f, 0.00773379f, 0.01580573f, -0.04435941f, 0.19408502f, -0.00827911f, -0.03505090f, -0.35196832f, 
    0.11130555f, -0.06887122f, 0.14080648f, 0.04869983f, 0.04970163f, 0.20804909f, 0.25220102f, -0.13396934f, 
    -0.01818629f, -0.18976143f, 0.05337854f, 0.18060295f, 0.02409072f, 0.18174763f, -0.01473611f, 0.52247584f, 
    -0.07042901f, -0.11749741f, 0.13779840f, 0.03007407f, -0.03322260f, -0.00683271f, 0.19330648f, -0.08185539f, 
    -0.08679717f, 0.15905310f, 0.02246429f, 0.02522047f, -0.02077281f, -0.02470642f, -0.07214864f, 0.12768519f, 
    -0.16939478f, 0.10298143f, 0.22262561f, 0.24665909f, -0.02605323f, 0.03693856f, 0.02999895f, 0.06642468f, 
    -0.08921652f, 0.07729010f, -0.24016821f, 0.34554416f, -0.22630784f, 0.07160958f, -0.02939345f, -0.22762923f, 
    0.07007405f, 0.20477785f, -0.12575036f, 0.00174878f, -0.12077674f, 0.10922202f, 0.05877738f, 0.18288539f, 
    -0.09915435f, 0.15553099f, 0.28025296f, -0.11323575f, -0.08849486f, -0.05624914f, -0.30088466f, 0.15785491f, 
    0.00182526f, 0.04096537f, 0.00819218f, -0.01090174f, 0.06965486f, -0.08664975f, -0.04948220f, -0.02355228f, 
    0.00581795f, -0.07054503f, 0.01482359f, 0.13309571f, -0.09652673f, 0.11281741f, -0.09435753f, 0.31639344f, 
    -0.24252772f, -0.12927635f, 0.06821237f, 0.13350901f, 0.04903435f, -0.00948206f, -0.00802872f, 0.16403890f, 
    0.25985134f, -0.24972975f, 0.12444513f, 0.01903917f, -0.12090352f, 0.06871792f, -0.13921781f, -0.22908241f, 
    -0.05495491f, -0.00675567f, 0.03579971f, 0.01986058f, -0.00138141f, 0.02027804f, -0.01829341f, -0.00233883f, 
    -0.03713972f, -0.01182732f, -0.04645197f, -0.05824759f, -0.04171138f, 0.02226102f, -0.04112516f, -0.05941321f, 
    -0.02057322f, 0.03767843f, -0.05479215f, 0.05714833f, 0.02044990f, 0.00135564f, 0.04796384f, 0.02077892f, 
    -0.05804915f, 0.01818832f, -0.03825793f, -0.03219634f, 0.02921302f, 0.00213298f, 0.01934577f, 0.01688107f, 
    -0.05685865f, 0.04550345f, -0.00237007f, 0.03763546f, -0.02922430f, -0.01804531f, -0.03364547f, -0.00598221f, 
    0.00656955f, 0.00550219f, 0.01798226f, 0.03011202f, -0.03676846f, -0.01938714f, -0.05103122f, -0.01327052f, 
    0.02565808f, -0.03841868f, -0.00702619f, -0.05318617f, 0.01276781f, -0.04164589f, -0.04987966f, 0.00837653f, 
    0.04134170f, -0.03437317f, -0.05831217f, -0.04172405f, 0.04287565f, -0.01473003f, -0.05026985f, -0.00025973f, 
    -0.01968359f, -0.03701297f, -0.05156627f, 0.05111592f, 0.04533904f, 0.03745757f, 0.04804562f, -0.03780964f, 
    0.03659835f, -0.04351520f, 0.03595912f, 0.02881402f, 0.04662652f, 0.04475307f, -0.01950879f, -0.04376663f, 
    0.01332544f, 0.04300319f, -0.04840814f, -0.02589637f, 0.00820028f, -0.00937109f, 0.03729944f, -0.04868007f, 
    0.01411216f, 0.01824997f, -0.03562106f, 0.05393747f, -0.00890129f, 0.00486552f, 0.00114837f, -0.02214876f, 
    -0.04268995f, 0.00889907f, -0.00360947f, -0.04230529f, -0.03655303f, -0.03458311f, -0.02576463f, -0.05178101f, 
    0.00904189f, -0.01284026f, -0.04965932f, 0.00682231f, 0.03191328f, -0.05039508f, -0.06042409f, -0.01713926f, 
    -0.01874247f, -0.03750951f, 0.04158352f, -0.02065062f, 0.01103272f, -0.02346590f, -0.01276620f, -0.00883127f, 
    0.02210997f, -0.03330813f, -0.02119248f, -0.05010595f, -0.00582278f, -0.05592887f, -0.03289274f, -0.04983426f, 
    -0.00924803f, 0.02091399f, 0.04057247f, 0.01957973f, 0.00105395f, 0.01048211f, -0.05860903f, -0.04219381f, 
    -0.00015358f, -0.00493057f, -0.02318791f, -0.00125046f, -0.03515072f, 0.03712370f, 0.04470239f, -0.00146632f, 
    -0.05532718f, -0.01240036f, 0.00241070f, -0.01960341f, 0.01562009f, 0.00580290f, 0.05041039f, 0.03110710f, 
    0.04620554f, -0.04178889f, -0.02363014f, -0.01781038f, -0.04319357f, -0.05609915f, 0.02710430f, 0.03614749f, 
    -0.06007087f, 0.04548795f, -0.06257794f, 0.00372661f, -0.04736853f, -0.04026294f, -0.05905284f, 0.01407551f, 
    0.04652327f, 0.04229515f, 0.03302060f, -0.04979160f, -0.04215270f, -0.04395129f, 0.01188413f, -0.00571945f, 
    -0.03515109f, -0.03950876f, 0.04329816f, -0.05997945f, 0.01048286f, 0.05261607f, 0.03684601f, -0.05587366f, 
    0.05039258f, -0.06286574f, -0.05183873f, -0.01709069f, 0.02339231f, 0.01841320f, 0.00876291f, -0.00028261f, 
    0.02122230f, -0.03251394f, 0.01036083f, -0.01851613f, 0.00985669f, 0.00140111f, 0.00373677f, -0.05697977f, 
    -0.02359744f, 0.01987435f, -0.02059396f, -0.03290464f, 0.04086809f, -0.04012512f, -0.00524143f, 0.01636666f, 
    -0.00320265f, -0.04330660f, -0.05422777f, -0.01877736f, -0.01037902f, -0.00312606f, 0.01682584f, 0.03998743f, 
    -0.00606235f, -0.02748113f, 0.01706764f, 0.05163115f, -0.01451628f, 0.00263016f, 0.04151373f, 0.05274323f, 
    -0.06421588f, -0.00114187f, 0.00926497f, -0.05030574f, -0.05532100f, -0.04915380f, 0.03383304f, 0.01486089f, 
    0.02643403f, 0.02328498f, -0.06344903f, -0.00225032f, -0.04011349f, -0.00358807f, 0.02063665f, -0.03926686f, 
    -0.04022882f, -0.04948955f, 0.03204058f, 0.02468277f, -0.05314608f, -0.01175327f, 0.04245078f, 0.03119722f, 
    -0.04528825f, 0.01944952f, -0.02924356f, -0.04029971f, 0.01936152f, -0.04582750f, -0.03849424f, -0.02548290f, 
    0.04573471f, -0.04580165f, 0.03936959f, 0.01785628f, 0.03099886f, -0.03697443f, -0.05002685f, -0.06388938f, 
    -0.01717876f, 0.04390597f, -0.03187605f, -0.02565511f, -0.03740783f, -0.05638608f, 0.05074287f, -0.02907857f, 
    0.03454899f, -0.00419231f, 0.00478461f, 0.01022335f, 0.02287358f, 0.01543613f, -0.03393487f, -0.02025447f, 
    0.02390639f, 0.03683849f, -0.06287965f, 0.01247774f, -0.05958733f, 0.03534458f, -0.05086812f, 0.00798154f, 
    0.02763558f, -0.04494512f, 0.00536073f, 0.01129992f, -0.04087301f, -0.04414610f, -0.06251863f, 0.02889310f, 
    -0.06508677f, 0.01157159f, -0.00101709f, 0.05703023f, 0.00117428f, -0.02718058f, -0.01950366f, -0.06546540f, 
    -0.04459651f, 0.03550959f, 0.03101623f, 0.04123478f, -0.03619013f, -0.02069438f, -0.02939787f, -0.04546483f, 
    -0.02314585f, -0.01527911f, 0.02931707f, 0.03000287f, -0.01866476f, 0.04319700f, 0.04852590f, -0.05904818f, 
    -0.01898919f, -0.04777054f, -0.03415298f, -0.00540228f, -0.02182796f, 0.00067712f, -0.05989534f, 0.03759759f, 
    0.03874431f, 0.03302884f, 0.04576628f, 0.02864925f, 0.01309406f, -0.05681900f, -0.06622554f, -0.05897232f, 
    -0.01161558f, 0.01395354f, 0.01432887f, 0.01186559f, 0.01930822f, -0.04821000f, -0.05327249f, 0.02094412f, 
    -0.05475039f, -0.05523464f, 0.01635994f, 0.01094869f, -0.06373223f, -0.00596560f, 0.00025784f, -0.00303518f, 
    -0.02899889f, -0.05843138f, 0.04350771f, -0.03704385f, -0.05040759f, -0.05078489f, 0.00619288f, -0.05416056f, 
    -0.01223311f, -0.05351308f, -0.00047414f, -0.00126082f, -0.01064775f, 0.04562068f, -0.02211345f, 0.02923209f, 
    -0.05137892f, 0.02635527f, 0.02740688f, -0.05822427f, 0.02088142f, -0.02477689f, 0.01710945f, 0.04203853f, 
    0.04240503f, -0.04479710f, 0.02357227f, -0.04376157f, -0.06035762f, 0.03755974f, -0.01905234f, 0.01037865f, 
    -0.01372584f, 0.03064215f, 0.00917151f, -0.04942762f, 0.01156587f, -0.03680047f, -0.04687807f, 0.02498731f, 
    0.02969001f, -0.06056542f, -0.05521786f, -0.00379839f, 0.03004285f, -0.03799926f, -0.00263887f, 0.04392859f, 
    -0.01894800f, -0.00053515f, -0.05722089f, 0.04832591f, 0.02761653f, -0.01203028f, -0.00388427f, -0.05507115f, 
    0.01765602f, 0.00021023f, -0.03586731f, -0.03576922f, -0.02008470f, 0.00012650f, -0.05535700f, -0.00553112f, 
    -0.03921708f, 0.04676301f, -0.02439045f, -0.03013775f, -0.06311424f, -0.01745529f, 0.02362562f, -0.00753175f, 
    0.04715453f, 0.03422164f, -0.05330831f, -0.00758530f, -0.00637606f, -0.00016555f, -0.05408922f, -0.05122957f, 
    0.02560040f, 0.04275217f, 0.02201374f, -0.00158768f, 0.04645087f, 0.03609595f, -0.06228522f, -0.05382448f, 
    -0.03679492f, -0.05443145f, 0.00652648f, 0.00433160f, -0.02740837f, -0.02575058f, 0.04154889f, -0.03384994f, 
    -0.04647132f, 0.04348992f, -0.05220874f, 0.03993302f, -0.03084176f, -0.05026263f, 0.03870514f, 0.00090744f, 
    -0.05840953f, -0.06640789f, -0.03603695f, -0.01299783f, 0.03958207f, 0.03276147f, -0.00893257f, -0.03843303f, 
    0.03467132f, -0.02740598f, 0.03248455f, 0.04020448f, -0.05823613f, 0.01331710f, 0.02671207f, 0.04492525f, 
    0.02260277f, 0.03855756f, -0.05798309f, 0.00920989f, 0.01522000f, -0.00747434f, -0.06435588f, -0.03123278f, 
    0.03538356f, 0.00776758f, -0.00491184f, 0.00790079f, -0.01131150f, 0.05386994f, -0.06244480f, -0.04365472f, 
    0.00205558f, -0.05032218f, -0.01651942f, 0.02549439f, -0.05742990f, 0.00268346f, 0.02359728f, -0.04313407f, 
    0.04595520f, 0.04865566f, 0.03127955f, -0.03835609f, -0.02123108f, 0.00220246f, 0.01190210f, -0.00503423f, 
    0.01766883f, 0.04567481f, 0.06040945f, 0.01207285f, 0.01005889f, -0.01921304f, 0.00388350f, -0.05371569f, 
    -0.01486859f, 0.03321013f, -0.05531463f, -0.01514282f, -0.04228464f, -0.00309188f, 0.01146550f, 0.04710461f, 
    0.02819720f, 0.00463235f, 0.03852282f, 0.03444964f, 0.02089307f, -0.04035989f, 0.03102885f, 0.00368533f, 
    -0.05627848f, 0.01342975f, 0.01496001f, 0.04368287f, -0.00277746f, -0.04845823f, 0.02141783f, -0.05587221f, 
    -0.04279353f, 0.03836090f, 0.00077707f, -0.03842131f, 0.01542522f, -0.05834669f, -0.01275197f, 0.01778370f, 
    -0.04630362f, -0.05203475f, -0.02507558f, 0.03698892f, -0.01180494f, 0.03109985f, 0.01576230f, -0.03642246f, 
    -0.05720177f, -0.04866555f, 0.00648733f, -0.03058723f, 0.03000114f, -0.05492647f, 0.01404846f, 0.03699531f, 
    -0.01002487f, -0.02325189f, -0.04098368f, -0.03521499f, -0.01525095f, -0.05583812f, -0.03542746f, -0.00260468f, 
    -0.04350567f, -0.06091439f, 0.02870953f, -0.01159351f, -0.05591783f, 0.02746355f, -0.02676701f, -0.01601737f, 
    -0.14011616f, 0.05198620f, 0.43898350f, 0.19243512f, 0.02065466f, -0.03780169f, -0.17624612f, 0.06462808f, 
    0.12461294f, -0.33903426f, -0.17595881f, -0.30989629f, -0.06056932f, -0.12464934f, -0.01740091f, 0.03698771f, 
    -0.13962121f, 0.10902489f, 0.27628365f, 0.21246099f, 0.11342548f, -0.01220011f, -0.20614044f, -0.01216187f, 
    0.11335839f, 0.02497010f, 0.07524441f, 0.05138595f, 0.05614820f, -0.16316919f, 0.18889712f, 0.05962882f, 
    0.00217259f, -0.04196242f, 0.17477332f, -0.00371047f, 0.03813447f, -0.06482770f, -0.21879888f, -0.07938372f, 
    -0.22381644f, -0.16325386f, 0.14629005f, -0.16927974f, -0.08351573f, 0.56807458f, 0.29682514f, 0.29640493f, 
    -0.20276695f, -0.10489720f, 0.07189541f, 0.15258184f, -0.07513209f, 0.09358206f, -0.12952231f, -0.09578028f, 
    0.00994983f, 0.09650477f, 0.08863088f, 0.21371800f, -0.12612617f, -0.24524637f, 0.20172383f, -0.12125625f, 
    0.13059452f, 0.00207269f, 0.07133413f, 0.14278093f, 0.13238190f, 0.11235861f, 0.26787257f, -0.42618266f, 
    0.14949787f, -0.12541556f, -0.10722999f, -0.17500408f, -0.21687375f, -0.11637368f, 0.01891539f, 0.07846286f, 
    0.05710929f, 0.04430595f, -0.16392492f, 0.22249475f, -0.04821614f, -0.21968441f, 0.10488866f, -0.09510925f, 
    -0.15276462f, -0.00713810f, 0.18693982f, 0.01523441f, 0.25826362f, 0.00410885f, -0.27664906f, -0.10487910f, 
    0.02469191f, 0.09156360f, 0.10609761f, -0.23552646f, 0.06613575f, 0.10608901f, -0.10321469f, -0.03657399f, 
    0.07034430f, -0.11720991f, -0.08360150f, 0.01761684f, 0.12675825f, 0.29513046f, -0.02814588f, -0.03418510f, 
    -0.14750862f, -0.14094354f, 0.02059560f, -0.18868126f, 0.10813226f, -0.14076209f, 0.01839043f, 0.22650839f, 
    0.15375914f, -0.04679986f, 0.07471523f, 0.13067001f, 0.01012960f, -0.05027827f, 0.23924521f, -0.03348438f, 
    0.14921866f, 0.19278273f, 0.01634656f, -0.29597262f, -0.01644983f, -0.06853995f, 0.17029446f, 0.12659092f, 
    -0.12245346f, 0.09426388f, 0.07022982f, -0.08644872f, -0.07673462f, 0.00820176f, 0.20408694f, -0.06102513f, 
    -0.39263904f, 0.06946655f, 0.23504941f, -0.15428129f, 0.18388805f, 0.02027790f, -0.04813590f, 0.01866201f, 
    0.05789847f, -0.43220106f, 0.21129295f, -0.17448148f, -0.12905003f, -0.00284742f, -0.21922873f, 0.11437839f, 
    0.16135259f, 0.03103886f, -0.00252854f, -0.04986911f, -0.06611642f, 0.00262605f, 0.12216869f, -0.10207359f, 
    0.04913669f, 0.22835560f, 0.06820308f, -0.51476789f, 0.14001811f, -0.28499523f, 0.16052403f, -0.05804050f, 
    0.05787893f, -0.02111348f, 0.18369254f, 0.19958688f, 0.15527160f, -0.17886241f, 0.09565689f, 0.00688389f, 
    -0.05034533f, -0.23699191f, -0.06420115f, 0.01507282f, 0.05915789f, -0.03212913f, -0.35713696f, -0.00647652f, 
    -0.14060129f, -0.05442765f, -0.04797225f, 0.00945335f, 0.16914722f, 0.19597074f, 0.21746598f, -0.15895051f, 
    0.05298522f, -0.05224451f, -0.08364023f, 0.08208227f, 0.11817905f, 0.00610446f, -0.03096556f, 0.50361907f, 
    0.05487036f, -0.05088197f, 0.22369744f, 0.04246417f, -0.06829506f, -0.03736297f, 0.06783818f, 0.10348389f, 
    -0.28136301f, 0.42407122f, 0.09700356f, -0.00707012f, 0.11662541f, -0.04687716f, -0.10415756f, -0.12040313f, 
    -0.08445133f, 0.14589018f, 0.12681134f, 0.21043302f, 0.21171109f, 0.07391797f, -0.12799346f, 0.22444874f, 
    0.24059391f, 0.10108410f, -0.52446258f, -0.07178108f, -0.48939881f, 0.17657977f, 0.31695393f, -0.07434350f, 
    -0.03998719f, -0.05228185f, -0.04858181f, -0.34933135f, 0.02465378f, -0.05223712f, 0.09925478f, -0.01344906f, 
    -0.13597609f, 0.21903303f, 0.08432644f, 0.08048323f, -0.18188722f, -0.01759784f, -0.16764432f, -0.00893714f, 
    -0.11091486f, 0.04069713f, 0.03010262f, -0.00354706f, -0.00450082f, -0.61085981f, 0.09702171f, -0.27337012f, 
    -0.03525148f, -0.07935723f, -0.05488321f, 0.10419380f, 0.14398918f, 0.14121735f, -0.32855985f, -0.01103934f, 
    -0.43177307f, 0.22576137f, 0.14346904f, 0.11885473f, 0.00632697f, -0.02150194f, 0.24568552f, -0.09357824f, 
    0.05004211f, -0.18182018f, 0.13816676f, 0.07794157f, -0.12776797f, -0.02506317f, -0.21704112f, -0.00947314f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.04494506f, -0.05482362f, -0.04774202f, 0.23295641f, -0.06596476f, -0.04894708f, -0.03640554f, 0.01739879f, 
    0.16352186f, -0.04297520f, 0.03215808f, -0.02910271f, 0.16976891f, -0.01266520f, 0.07766815f, 0.00326241f, 
    -0.01319482f, -0.07202476f, 0.02555000f, 0.02106576f, 0.15389800f, 0.02798938f, -0.26981646f, 0.03505002f, 
    -0.12925081f, 0.07717449f, -0.08506983f, 0.12095502f, 0.10192405f, 0.02909652f, 0.04480400f, 0.12538525f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.33049905f, 0.00493766f, 0.74110770f, -0.01314064f, -0.38869250f, -0.23057179f, 0.09271261f, 0.16508968f, 
    -0.29880702f, 0.16060472f, -0.07588830f, 0.07644925f, 0.56002653f, 0.10306495f, -0.17742823f, -0.02558466f, 
    0.17035042f, 0.12447859f, -0.03003504f, 0.06280654f, -0.64107215f, -0.11573164f, -0.05076426f, 0.15353666f, 
    0.38125658f, -0.50904065f, 0.08134927f, -0.36729091f, -0.54313385f, -0.03800166f, 0.10443261f, -0.15215383f, 
    -0.24367321f, 0.43627235f, -0.29287955f, -0.14474939f, 0.53045189f, -0.30590001f, -0.01383620f, 0.31577438f, 
    0.23871996f, 0.01330922f, -0.08149743f, -0.14754941f, 0.60713547f, -0.00323683f, -0.15354377f, -0.04684157f, 
    0.08479701f, -0.02058189f, -0.40587193f, 0.14578679f, -0.01449241f, 0.47942173f, -0.07765817f, -0.08333761f, 
    -0.05580830f, -0.02006838f, -0.58090597f, -0.04921861f, -0.56865382f, -0.15422082f, 0.00374330f, 0.00276206f, 
    0.19552004f, 0.21790038f, -0.05371116f, -0.45198226f, 0.09208565f, 0.18398646f, 0.02894134f, -0.38859695f, 
    -0.01972606f, -0.13368133f, -0.01826343f, -0.16799638f, -0.17464826f, -0.00196458f, 0.11681870f, 0.13795730f, 
    0.03529492f, 0.95336241f, -0.33275872f, -0.46638319f, -0.24462056f, -0.26395673f, -0.97979671f, 0.11426684f, 
    0.19032909f, 0.02965532f, -0.08713579f, 0.13060901f, 0.08184145f, 0.07578212f, 0.07117297f, -0.39629650f, 
    -0.39233285f, -0.09974628f, 0.36479020f, 0.17001389f, -0.57649988f, -0.38854176f, -0.09768631f, -0.47655439f, 
    -0.47061744f, 0.16250806f, -0.00508262f, 0.14497280f, -0.42441514f, -0.14214492f, 0.57310772f, 0.13810374f, 
    0.12865850f, -0.16871452f, 0.51249349f, -0.13680178f, 0.07632450f, 0.53594559f, 0.42917606f, 0.17063323f, 
    0.13423195f, -0.26948050f, -0.02319548f, -0.19781454f, 0.07964353f, -0.04411603f, -0.16594857f, -0.45384315f, 
    -0.59844571f, -0.01821933f, 0.10410619f, 0.27133918f, -0.25686592f, 0.02037265f, 0.00897520f, 0.29569319f, 
    0.27518195f, -0.12481061f, -0.09722853f, 0.03970125f, -0.15929335f, 0.13129012f, 0.24993119f, 0.09135261f, 
    -0.12266101f, -0.11916876f, -0.38745198f, 0.19668701f, -0.04061963f, -0.48413032f, -0.13106677f, 0.09570776f, 
    0.30697334f, -0.93386692f, 0.31028438f, -0.01034371f, 0.32828221f, 0.05244287f, 0.12537313f, 0.03764480f, 
    -0.01275962f, -0.55848235f, 0.03199688f, 0.31352696f, -1.07836986f, -0.01023336f, -0.12977792f, -0.31308502f, 
    0.48070493f, -0.15429333f, -0.17592692f, -0.00940354f, 0.14487144f, 0.14516023f, -0.54041111f, 0.03697971f, 
    0.15791842f, -0.04238501f, -0.43733308f, 0.46660694f, 0.51275039f, 0.12339289f, 0.48186398f, -0.07798475f, 
    -0.57688165f, 0.13546957f, -0.07994729f, 0.02481797f, -0.42267913f, -0.16009609f, -0.06137644f, -0.17020981f, 
    0.17887472f, -0.73035210f, -0.18891279f, -0.01044727f, 0.06046290f, -0.10472922f, -0.15612717f, 0.62075293f, 
    0.24417023f, 0.04566366f, 0.06552636f, 0.09788401f, -0.21166708f, 0.16898525f, 0.29156825f, 0.03811130f, 
    -0.02904978f, -0.44144443f, -0.15915950f, -0.19977689f, 0.51041168f, -0.20428424f, -0.50969487f, -0.01541766f, 
    0.31468865f, 0.47178361f, -0.40296182f, -0.25931931f, 0.18816006f, 0.05836830f, 0.08979990f, -0.59169596f, 
    -0.01751292f, 0.30110940f, -0.22723493f, -0.36779436f, 0.30984536f, 0.06498701f, 0.09217051f, -0.23607174f, 
    -0.29083663f, -0.07173591f, -0.04799282f, 0.01482384f, -0.35818371f, -0.14786080f, -0.49215987f, -0.08433079f, 
    -0.02691200f, 0.00216530f, 0.17745252f, 0.32682404f, -0.19005319f, -0.11340208f, 0.47382048f, 0.10119851f, 
    0.23153380f, -0.07281431f, 0.73017192f, -0.00376394f, -0.55762959f, -0.01009274f, -0.04348391f, 0.06031845f, 
    -0.21111241f, 0.69726419f, -0.08683411f, -0.37289363f, -0.13183746f, 0.00405428f, -0.16058081f, -0.09983754f, 
    -0.15492745f, -0.09352438f, 0.10862640f, 0.09677836f, 0.13567744f, 0.03761501f, -0.67006344f, 0.11918345f, 
    -0.06338030f, -0.36186972f, 0.23690283f, -0.32194963f, 0.14496705f, 0.46592709f, -0.12815353f, -0.02368704f, 
    -0.57817346f, 0.21405192f, -0.56110686f, 0.46380544f, 0.18933789f, -0.02789520f, -0.16051009f, 0.66012776f, 
    0.67862254f, -0.49767497f, 0.09743071f, -0.08034627f, 0.65378380f, 0.02144967f, -0.11182883f, 0.17484121f, 
    -0.12200852f, 0.12604645f, -0.11620162f, -0.04873803f, -0.32770392f, 0.12871392f, -0.01577863f, -0.10945628f, 
    0.02279845f, -0.22072636f, -0.31464168f, 0.00690489f, -0.35168582f, -0.50683069f, 0.05747665f, -0.09016188f, 
    0.10249847f, 0.13149756f, -0.13373758f, -0.31637019f, 0.44493723f, -0.12608686f, -0.04107713f, 0.73033512f, 
    -0.58381701f, -0.39661443f, -0.64818460f, 0.27372959f, -0.07353470f, -0.52312994f, 0.02316377f, -0.23242328f, 
    -0.40761593f, 0.00454329f, 0.08289265f, 0.10155527f, -0.15931143f, -0.12859146f, 0.13694255f, 0.12486987f, 
    0.06388287f, 0.03342671f, 0.41638345f, 0.09355728f, -0.33464372f, -0.09662014f, -0.54268074f, 0.07354907f, 
    0.00976490f, 0.44790834f, 0.13320038f, 0.98680061f, 0.12884787f, -0.01689213f, -0.17049028f, -0.39066136f, 
    0.00051012f, -0.50947618f, -0.19424163f, 0.17767623f, -0.05458211f, 0.96498448f, -0.03757919f, -0.45502308f, 
    -0.29482096f, -0.06709664f, -0.04594683f, 0.02227640f, 0.07075632f, 0.08874059f, 0.16868973f, 0.01431574f, 
    -0.13733868f, 0.14960527f, 0.53403640f, -0.45006427f, -0.00240529f, 0.21341410f, -0.58808511f, -0.04349413f, 
    -0.13774869f, 0.13270468f, -0.50603890f, -0.21346065f, -0.21333623f, -0.16204928f, -0.14804745f, -0.23843209f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19440427f, 0.10054908f, -0.05387904f, -0.00921401f, 0.04747896f, 0.15336305f, -0.14121845f, -0.19709340f, 
    -0.23092869f, 0.14455791f, 0.00651659f, 0.09321773f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
