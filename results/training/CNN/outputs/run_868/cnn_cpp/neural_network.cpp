#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.28069183f, 0.18396208f, 0.62589169f, 1.17108428f, 0.87927568f, -0.91095442f, 0.22733878f, 0.56684011f, 
    -0.08425917f, 0.50436318f, -0.56913555f, 0.85821056f, 0.35228324f, -0.41222775f, 0.66393989f, 0.44814590f, 
    -0.79589671f, -0.44151261f, 0.91849303f, 1.17391515f, 1.01923835f, 0.27713883f, 1.19868946f, 0.24035895f, 
    -0.24791007f, 0.07764450f, -0.24245332f, 0.83624625f, -0.51339918f, 0.13321927f, -0.90945822f, 0.76257050f, 
    -1.00919175f, -0.41549566f, -0.10862822f, 0.19498572f, -1.03852713f, -1.08256948f, -1.23297918f, 0.50384140f, 
    -0.29279140f, 0.23946656f, -0.36510092f, -0.09528135f, -0.42725199f, 1.10274410f, -0.16465251f, 1.14897072f, 
    0.81559074f, 0.32723111f, 0.13713163f, 0.57987899f, 0.85756266f, 0.79877472f, -1.55129850f, -0.47365233f, 
    -0.72295046f, 0.31606925f, 1.47894490f, 0.39015239f, 0.33084041f, -0.44053078f, -0.31893185f, 0.80755836f, 
    1.11123800f, 0.97152466f, -0.37225074f, -0.51858723f, -0.53688192f, 0.40795738f, -0.11051288f, 0.03932923f, 
    1.45964897f, 0.47635591f, 0.48499894f, 0.25962937f, -0.43396828f, 0.28571591f, -0.14478521f, 0.95817107f, 
    -0.12301002f, 0.85414094f, 0.21922460f, 0.42314160f, -0.81626368f, -0.72272325f, -0.67242283f, -0.17229593f, 
    -0.34946030f, 0.49959093f, -0.24558981f, 0.72463477f, 0.64330989f, -0.18168250f, -0.47895354f, 1.14305496f, 
    -0.12117649f, 0.17162913f, 0.06784097f, 0.69568092f, 0.54316688f, 0.15517533f, -1.25168383f, -0.81276220f, 
    -0.54689735f, 0.06490903f, 0.48215199f, 0.16636188f, 1.13714123f, -0.96432203f, 0.80689996f, -0.60879344f, 
    -0.29401624f, 0.62594134f, -0.18987428f, -0.10415842f, -0.10600638f, -0.70892227f, -0.56483686f, 0.33022556f, 
    -1.07884824f, 0.08319237f, -0.90880406f, 0.35827634f, 0.60405111f, -0.30020192f, 0.68006003f, -0.37388623f, 
    1.10068178f, 0.49592474f, 0.29851657f, -0.35460582f, -0.53246939f, -0.59540230f, -0.45018393f, 0.83429056f, 
    -1.09686816f, -0.11634891f, 0.46107781f, -1.03503120f, -0.71078789f, -0.00698471f, -0.17434013f, 0.68783861f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.21884304f, 0.05755065f, 0.26166180f, -0.04896264f, -0.36091331f, -0.05380886f, 0.37933928f, 0.14309075f, 
    -0.02209747f, 0.48958617f, 0.04629655f, 0.14607008f, -0.10772862f, 0.26468945f, 0.00152556f, 0.05626976f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04315735f, -0.05597547f, -0.16138509f, 0.12944591f, -0.01234998f, -0.12815335f, 0.08511524f, 0.17451943f, 
    0.23480587f, -0.31944767f, -0.12051402f, 0.06978705f, 0.16430704f, 0.14040151f, 0.13933802f, 0.03759944f, 
    0.16624802f, -0.19273020f, 0.46060660f, -0.67019993f, -0.48834297f, 0.14807187f, 0.10884015f, -0.07884650f, 
    -0.24136685f, 0.07062633f, 0.12968801f, -0.12629516f, 0.25441721f, -0.41288722f, 0.02324882f, 0.08965670f, 
    0.30602938f, 0.00257601f, -0.17840429f, -0.18518063f, 0.03498236f, 0.08349057f, -0.33008394f, -0.22470580f, 
    -0.16612552f, -0.12391878f, -0.25648335f, 0.26113820f, -0.05420875f, -0.25045484f, 0.06986186f, 0.29334649f, 
    0.22619173f, -0.14150877f, -0.08480401f, 0.17351483f, -0.03797812f, 0.30345130f, -0.07205138f, 0.03676843f, 
    -0.13458647f, -0.36091924f, 0.08648510f, -0.26649562f, -0.00504317f, -0.02194102f, -0.29977873f, 0.54369313f, 
    -0.34778389f, 0.37080193f, 0.08907553f, -0.03478407f, -0.03971443f, -0.01071822f, 0.02811082f, -0.02696489f, 
    -0.42833906f, -0.54788119f, -0.02716019f, 0.22295432f, 0.17919978f, -0.01006786f, 0.12203895f, 0.01299075f, 
    0.18041061f, 0.49981838f, 0.25876018f, 0.03916484f, 0.17249377f, 0.08367629f, 0.19417526f, 0.00338036f, 
    -0.05665264f, 0.11003277f, -0.31025815f, -0.45358828f, -0.17993741f, 0.16686970f, -0.19201510f, 0.24194083f, 
    -0.02240802f, -0.06764074f, 0.06720877f, 0.61768234f, 0.38882944f, 0.01801365f, 0.18586323f, -0.00162233f, 
    0.04158985f, 0.03435432f, -0.13368973f, 0.24073784f, -0.26566753f, 0.02768402f, -0.05104326f, -0.17854784f, 
    0.04395040f, 0.15886690f, 0.10452114f, 0.15762517f, 0.02452588f, 0.49778160f, -0.04696505f, -0.16259278f, 
    -0.00214242f, 0.03312508f, 0.31614330f, -0.21789497f, 0.15627602f, -0.12172647f, -0.87036276f, -0.08883195f, 
    -0.00688817f, 0.13374174f, 0.25010562f, 0.01493055f, -0.38401937f, -0.20879233f, -0.17751369f, 0.03172379f, 
    -0.04892524f, 0.16650891f, 0.00037763f, -0.12069073f, -0.11977180f, 0.19093648f, -0.11281646f, -0.05566156f, 
    0.28842139f, -0.66056269f, 0.24351214f, -0.05642734f, -0.04964938f, -0.14447550f, -0.04476084f, -0.02072081f, 
    -0.01513545f, -0.66369122f, 0.42734924f, 0.31697401f, 0.08054596f, 0.01624405f, 0.08989765f, 0.03672818f, 
    0.13751085f, -0.08681364f, 0.32311067f, 0.34910893f, -0.12348963f, 0.09479852f, 0.01028140f, 0.15760137f, 
    -0.07925407f, 0.28289470f, -0.06039739f, 0.15980613f, -0.17386797f, -0.55912793f, -0.01356434f, 0.10686045f, 
    0.21877480f, 0.08242320f, 0.07945972f, -0.14308110f, 0.30158514f, 0.22762883f, 0.32934704f, 0.17809880f, 
    0.05617819f, -0.42858669f, -0.09160044f, 0.37398568f, -0.10069172f, -0.37710631f, 0.05802326f, 0.32711002f, 
    -0.14885132f, 0.08004354f, -0.34996471f, 0.10175052f, -0.05112579f, 0.18052365f, 0.67760342f, 0.15924233f, 
    -0.10114535f, 0.03939699f, 0.09655499f, -0.15907544f, 0.10545413f, 0.02519950f, -0.09855567f, -0.16131532f, 
    0.26729342f, -0.12665406f, -0.00945866f, 0.07227239f, 0.02896625f, 0.02623839f, -0.06311215f, 0.18879424f, 
    -0.45954394f, 0.20345317f, 0.17967783f, 0.14443037f, 0.13324608f, 0.10131869f, 0.02012215f, -0.07403223f, 
    0.02868005f, -0.22491273f, -0.23287085f, -0.22584230f, 0.14671263f, -0.07334807f, 0.13216528f, -0.10433280f, 
    -0.10752820f, 0.15320262f, 0.24000029f, 0.14101847f, -0.33188209f, 0.10095984f, -0.17988901f, 0.08428693f, 
    -0.16796514f, 0.05665872f, 0.35571074f, 0.14138409f, -0.12891686f, -0.17607731f, 0.04959707f, -0.06525227f, 
    0.04691640f, -0.14364032f, 0.10644531f, -0.01430094f, -0.77097327f, -0.08982960f, -0.45977813f, 0.39711896f, 
    0.21178786f, -0.01790979f, -0.00645804f, 0.10765695f, 0.04509180f, -0.21669212f, -0.22195514f, -0.82043934f, 
    -0.04579137f, 0.04094709f, -0.02202786f, -0.16662721f, -0.07956835f, -0.01659488f, -0.05176609f, 0.03187514f, 
    0.21200149f, 0.21289700f, 0.09129035f, -0.03706001f, -0.15854381f, 0.16504990f, -0.06466065f, -0.81822813f, 
    -0.21633579f, -0.09297377f, -0.01296661f, 0.00863179f, 0.11531992f, 0.12816985f, 0.04216513f, -0.03083546f, 
    -0.07982773f, 0.06095526f, -0.07069553f, 0.04011800f, 0.03629176f, -0.00276018f, 0.01185565f, -0.00882943f, 
    0.06048710f, -0.04817175f, 0.01772928f, -0.03429877f, -0.03298257f, 0.07181296f, 0.01407860f, -0.00162114f, 
    -0.05282775f, 0.01152180f, 0.06356785f, 0.07208043f, 0.03483311f, 0.04039917f, 0.00848205f, 0.04455107f, 
    0.06490901f, -0.01442576f, -0.02477618f, -0.03257685f, -0.04020463f, -0.05551603f, -0.08598889f, 0.04709496f, 
    -0.03846711f, -0.08159702f, 0.04310564f, -0.04667121f, 0.02841832f, -0.04630551f, -0.00493967f, -0.03733321f, 
    -0.03810345f, -0.07896547f, 0.04918944f, 0.05020779f, -0.07001129f, 0.00216682f, 0.02365266f, -0.08326115f, 
    -0.02224009f, -0.01398924f, 0.03884092f, -0.05200209f, -0.00001419f, -0.07391866f, 0.05885803f, -0.00029727f, 
    -0.05105894f, -0.03075992f, 0.06450733f, -0.06635460f, 0.03110919f, -0.06454104f, -0.08641934f, 0.03779291f, 
    -0.06380352f, -0.02738474f, -0.02601986f, -0.00015726f, -0.05872741f, -0.00275698f, -0.01240426f, 0.03821991f, 
    -0.01727801f, -0.07371765f, 0.04577712f, -0.07701191f, -0.06664526f, 0.01766631f, -0.06355946f, -0.06453220f, 
    -0.06634562f, -0.04819511f, 0.04624559f, -0.07047304f, 0.05916480f, 0.00087345f, 0.05353651f, -0.02395735f, 
    -0.08329917f, -0.06009486f, -0.04770476f, -0.01247978f, 0.07533497f, 0.04076259f, -0.04549869f, 0.03803417f, 
    0.02532465f, 0.06960244f, 0.03973486f, 0.05086927f, 0.01046908f, 0.00486557f, 0.03265764f, 0.07794663f, 
    -0.04134770f, 0.01269033f, 0.02462227f, -0.02089055f, -0.03444320f, 0.02779835f, -0.00974295f, -0.01066437f, 
    -0.08563633f, -0.05886860f, -0.07562149f, 0.02150741f, 0.00185662f, -0.02966366f, -0.03028564f, -0.08532333f, 
    -0.04965785f, -0.06279134f, -0.06527494f, -0.05419833f, -0.02346386f, 0.00584978f, -0.03052223f, -0.02050856f, 
    0.05915000f, -0.03189744f, -0.02113460f, -0.04833855f, -0.05110496f, -0.02649297f, 0.05924516f, -0.05710563f, 
    -0.05447087f, 0.00158384f, -0.03560694f, -0.02218114f, -0.06407005f, -0.00018806f, -0.02309607f, -0.04025329f, 
    -0.16366771f, -0.07342746f, -0.29722825f, 0.29214391f, 0.02426051f, 0.07615142f, -0.05622452f, 0.37238887f, 
    -0.39476204f, -0.24041276f, 0.21277520f, -0.47065744f, 0.13253912f, 0.17946646f, 0.10614531f, -0.02248789f, 
    -0.05193328f, -0.20666634f, -0.27929851f, 0.58562535f, -0.24157448f, 0.20410231f, 0.20183446f, 0.33933845f, 
    0.04733808f, -0.16515757f, -0.12718302f, -0.09861357f, 0.09925138f, 0.33612332f, 0.13599561f, -0.00381194f, 
    0.23106915f, 0.04384809f, -0.10915698f, 0.09533335f, 0.06301959f, -0.19680665f, 0.47998157f, 0.48598358f, 
    0.26684949f, 0.13814336f, -0.03886740f, -0.09340765f, 0.04044178f, -0.13621010f, 0.17345922f, 0.11776274f, 
    0.10220932f, -0.10222282f, 0.23317175f, -0.10705747f, -0.08177450f, -0.29975092f, 0.10889496f, 0.19720732f, 
    0.10515379f, 0.13521336f, 0.17470090f, -0.02731409f, -0.14000258f, 0.30032364f, 0.06319655f, -0.13986696f, 
    0.11474393f, -0.06805173f, 0.06779281f, 0.05701093f, 0.03758196f, 0.00479761f, -0.11782917f, -0.00561112f, 
    -0.38315406f, -0.01342083f, -0.18075465f, -0.11453376f, 0.26632902f, 0.05577586f, 0.05830802f, 0.33342731f, 
    -0.11977259f, 0.33952194f, 0.21818203f, 0.30464834f, -0.10297185f, -0.24051908f, -0.21218614f, 0.01424814f, 
    0.15008219f, -0.23941936f, -0.23800057f, -0.24201776f, -0.34678912f, -0.16315970f, 0.25011477f, 0.08813008f, 
    -0.03335231f, 0.07534493f, 0.31701058f, 0.24608727f, -0.09450921f, 0.00524708f, -0.30002999f, -0.21000703f, 
    -0.18801570f, -0.07430296f, 0.09913298f, -0.02849585f, 0.63046396f, 0.06438252f, -0.30301523f, -0.56700826f, 
    0.09089905f, 0.10554592f, 0.15689866f, 0.03679688f, 0.00383100f, 0.30944097f, 0.04023568f, -0.02957048f, 
    -0.05567946f, 0.05435743f, -0.04456271f, 0.05864491f, -0.07567855f, -0.18280822f, -0.22710502f, 0.05725269f, 
    -0.24373071f, 0.38595146f, 0.39153564f, 0.01251758f, -0.06778081f, -0.16657490f, 0.17422812f, 0.02464605f, 
    -0.54078662f, -0.10150164f, -0.01919570f, -0.30715284f, -0.12871918f, 0.14361441f, 0.17807372f, -0.08174156f, 
    0.02577648f, 0.00608925f, -0.05134465f, 0.04128153f, 0.03913898f, -0.02926768f, 0.00801941f, -0.05786745f, 
    -0.07613471f, 0.00407481f, -0.06900572f, 0.03405220f, 0.00629049f, 0.05230555f, 0.04111078f, -0.06533652f, 
    -0.04591424f, -0.01161905f, 0.02943065f, -0.07491350f, 0.02381996f, 0.05449817f, -0.06455868f, 0.06843559f, 
    0.01350583f, 0.03735182f, -0.01395810f, 0.04052363f, -0.04955827f, -0.02246890f, -0.07484701f, 0.07190953f, 
    -0.08232713f, -0.08402345f, 0.00756803f, 0.03039618f, 0.06373124f, -0.00127558f, -0.07906177f, 0.05768326f, 
    -0.07025293f, -0.08305102f, -0.08110453f, 0.00409599f, -0.08866652f, -0.08610646f, 0.00105044f, 0.07465469f, 
    -0.07590972f, 0.05262757f, -0.05312808f, -0.05445109f, -0.05216317f, -0.05985088f, 0.02764191f, 0.03772509f, 
    0.00019104f, 0.05016821f, -0.04308774f, 0.05770474f, -0.08593363f, 0.00788052f, -0.08326993f, 0.00427818f, 
    0.05276182f, -0.02654991f, 0.04194228f, -0.00876055f, -0.07590273f, -0.05389954f, 0.05742959f, 0.00286018f, 
    0.02057138f, -0.01714638f, 0.03200010f, -0.01448817f, -0.02662381f, -0.04178725f, 0.05730158f, 0.02943398f, 
    -0.05848233f, -0.07923956f, 0.00828129f, -0.06542878f, 0.05567408f, 0.01468706f, -0.01745321f, 0.04521184f, 
    -0.07493728f, 0.02268684f, -0.01444975f, 0.03260867f, -0.08605836f, -0.04566074f, 0.00762163f, -0.00379199f, 
    -0.02826493f, -0.02905186f, -0.08510964f, 0.05574090f, -0.02241861f, -0.06955002f, 0.04527120f, 0.06848206f, 
    -0.05052747f, -0.04837883f, -0.02839166f, -0.05118134f, -0.06235779f, 0.01311553f, -0.07604548f, -0.02538406f, 
    0.04816507f, -0.06951854f, -0.01043050f, -0.00743653f, -0.03243171f, 0.05088211f, -0.06410350f, -0.00528053f, 
    -0.02242509f, 0.04795098f, -0.06788187f, -0.04648582f, -0.03854367f, 0.00434298f, -0.06459428f, 0.03288151f, 
    -0.05444014f, -0.04352084f, 0.04689506f, 0.02767049f, -0.07683873f, 0.02192084f, 0.00527683f, -0.04297378f, 
    -0.00911648f, -0.03462547f, 0.02044383f, 0.03040975f, -0.07805773f, -0.03577041f, -0.06846295f, -0.00109138f, 
    0.20302534f, -0.00152267f, -0.37692490f, -0.25847036f, -0.07162313f, -0.11571179f, -0.10305145f, 0.11362664f, 
    -0.08916728f, -0.02868299f, -0.43406352f, -0.46764901f, 0.13470690f, 0.16203880f, -0.10064843f, 0.08311888f, 
    -0.14009626f, 0.20504481f, 0.16032879f, 0.13376868f, 0.54260200f, 0.06080916f, 0.01666415f, 0.17274703f, 
    0.03864194f, 0.08680955f, 0.06079856f, -0.17645863f, 0.46187794f, 0.22672281f, 0.11853673f, -0.18287805f, 
    -0.20946038f, 0.05414312f, -0.13344866f, 0.10186394f, -0.01716718f, 0.36239079f, -0.18697013f, 0.00065445f, 
    0.05729819f, 0.12519424f, -0.00811440f, 0.17204309f, 0.03999521f, -0.64813763f, -0.47098380f, -0.03291287f, 
    0.11456966f, 0.27946261f, 0.17522363f, -0.00469085f, 0.09763629f, -0.01800438f, -0.11338854f, 0.53461009f, 
    0.17095606f, 0.09804372f, -0.09250616f, -0.05549851f, -0.17653702f, 0.33033463f, 0.36884150f, -0.17603864f, 
    -0.77696836f, 0.23730811f, 0.28010941f, 0.26051167f, 0.05079705f, 0.02516503f, 0.04865076f, -0.09553599f, 
    -0.32830146f, -0.95731735f, 0.07778065f, 0.06439999f, 0.07993554f, -0.14724779f, -0.01770675f, -0.21171723f, 
    -0.13536653f, 0.26246625f, -0.05584710f, 0.04948172f, -0.01462913f, 0.09328444f, -0.10466556f, 0.06852604f, 
    -0.12580852f, 0.05172470f, -0.53604919f, -0.56351364f, -0.13525192f, 0.10334081f, 0.06958819f, 0.10216255f, 
    0.21779421f, -0.19062443f, -0.09035669f, 0.01587119f, -0.46717077f, -0.01874747f, -0.00865313f, 0.14376312f, 
    -0.05772695f, 0.19804193f, -0.08773263f, -0.10661343f, 0.17855671f, 0.33452055f, -0.02057423f, 0.01093223f, 
    0.13422990f, 0.11115273f, -0.12367415f, -0.01280899f, -0.16174960f, -0.35283822f, 0.41179961f, 0.20211869f, 
    -0.07028982f, -0.02392712f, -0.27952006f, -0.06873568f, -0.04806342f, 0.04084561f, -0.21852125f, -0.43267745f, 
    0.05492893f, -0.00549114f, 0.10964500f, 0.05088168f, 0.01066982f, 0.32622555f, 0.15073076f, 0.60370338f, 
    0.15512387f, 0.03001110f, -0.25143266f, 0.02537977f, 0.07670964f, 0.09459486f, 0.03241907f, 0.02410750f, 
    0.41934943f, -0.14563625f, -0.42192668f, -0.01532614f, -0.04297931f, -0.02374474f, 0.03996414f, 0.17364670f, 
    0.23459665f, 0.09209332f, 0.15388814f, -0.16683385f, 0.02621837f, -0.00055982f, -0.19753398f, 0.17781721f, 
    0.21109404f, -0.13091914f, -0.07719626f, 0.33962780f, -0.19620283f, 0.23012823f, -0.01851546f, -0.00434987f, 
    0.13018455f, -0.06016280f, -0.03050995f, -0.07621135f, -0.12570684f, -0.40867177f, -0.11518159f, 0.21909456f, 
    0.05677245f, -0.31238821f, -0.08682351f, -0.10456678f, 0.38894287f, 0.08566260f, 1.10609651f, 0.17524740f, 
    -0.13101953f, -0.08945822f, -0.05228686f, 0.19183856f, 0.15159725f, 0.57022774f, 0.04828058f, 0.02189625f, 
    -0.12289791f, -0.13660012f, 0.13712192f, -0.17479466f, -0.03120906f, 0.14865859f, 0.04404761f, 0.12689638f, 
    0.53993762f, 0.06445600f, -0.17294860f, 0.14151555f, -0.16230360f, -0.00629550f, 0.12808552f, -0.14763622f, 
    0.32100540f, -0.23052195f, -0.22714821f, 0.16375117f, 0.12446058f, 0.00626425f, 0.02163977f, 0.03976376f, 
    0.05319468f, 0.09893835f, 0.00129657f, 0.09160706f, 0.10631622f, -0.07871448f, 0.02145009f, 0.09181459f, 
    -0.47461835f, -0.18414485f, -0.34075344f, -0.71667951f, -0.00397825f, 0.02965911f, 0.00118659f, 0.08933987f, 
    0.05573438f, 0.07567600f, -0.09329849f, -0.25247854f, 0.10610448f, 0.09773936f, 0.22426039f, -0.11682337f, 
    0.00812115f, -0.00570807f, 0.02829313f, -0.55821437f, -0.00973992f, -0.53661019f, 0.05586613f, 0.00995154f, 
    -0.20129232f, 0.17647563f, -0.02635501f, 0.08619877f, -0.55830431f, 0.06248598f, -0.15929262f, 0.11089242f, 
    0.06711450f, -0.03502334f, 0.17177655f, -0.08215091f, 0.27579722f, -0.12477713f, -0.09352099f, -0.09989002f, 
    0.14217149f, 0.02622376f, 0.01390830f, 0.17445172f, -0.09775762f, -0.01932121f, -0.21406673f, -0.00327179f, 
    0.12189719f, -0.02760091f, 0.03533923f, 0.04211593f, -0.08151893f, 0.34007162f, 0.08847211f, -0.01729883f, 
    0.31575426f, -0.03142317f, 0.05228867f, -0.16392696f, -0.05954052f, 0.12781690f, -0.14084682f, -0.20606841f, 
    -0.01009678f, -0.03155129f, -0.01319998f, 0.07401278f, -0.00262872f, -0.01027700f, 0.06269113f, -0.03876887f, 
    -0.02320956f, -0.05499317f, 0.01610277f, -0.05268969f, -0.01891090f, 0.02180817f, 0.00545293f, -0.03685529f, 
    0.00108168f, 0.07344543f, 0.00799780f, -0.05109310f, -0.04690403f, 0.05360420f, -0.03155661f, -0.03634249f, 
    0.00466302f, -0.06888893f, 0.03147858f, 0.04627246f, 0.03736071f, -0.06544345f, 0.02087433f, -0.04740297f, 
    0.03676768f, -0.01564276f, -0.00597928f, -0.04059039f, 0.02312919f, -0.05182998f, -0.10061820f, 0.04889441f, 
    0.00889337f, 0.00461320f, -0.05674035f, 0.01309293f, -0.04170405f, 0.00157855f, 0.01006959f, 0.05375324f, 
    -0.03998624f, -0.08148317f, -0.05750394f, 0.02528362f, 0.03141898f, -0.04185899f, 0.02880618f, 0.00779029f, 
    -0.08783437f, 0.02538665f, 0.03103836f, -0.05532689f, 0.05806658f, -0.01668294f, 0.02980541f, 0.03344067f, 
    -0.04479015f, -0.03353171f, -0.00053026f, -0.07470541f, -0.03105607f, 0.02212803f, -0.06941088f, -0.04636664f, 
    -0.09082378f, -0.08168933f, 0.08061540f, 0.04628341f, -0.02749180f, 0.06391324f, -0.07445547f, 0.00687284f, 
    0.05332248f, -0.04121784f, -0.00269938f, 0.07270519f, -0.03103337f, 0.02439738f, -0.06697160f, -0.02911695f, 
    -0.04413905f, 0.05455092f, 0.05997954f, 0.03739948f, -0.06530459f, 0.00800603f, -0.00996129f, -0.06292258f, 
    0.06937868f, -0.08140796f, -0.02561729f, -0.04296228f, 0.06925897f, -0.08803785f, -0.06767190f, -0.04269658f, 
    -0.08291949f, -0.00816014f, -0.02542464f, -0.06380272f, 0.04495405f, 0.06627241f, 0.01400124f, 0.02417641f, 
    -0.03027843f, 0.00583175f, 0.04724002f, -0.03379098f, -0.06959037f, -0.08055931f, 0.04999002f, -0.01035137f, 
    -0.02074623f, -0.00286363f, -0.03562103f, -0.02289673f, 0.01828369f, 0.01505554f, 0.02494254f, -0.03788444f, 
    -0.00954059f, -0.01789300f, -0.00301808f, -0.03299621f, 0.05429156f, 0.03047263f, -0.06979075f, 0.02499219f, 
    -0.07945467f, -0.07726420f, -0.02945391f, 0.00773574f, 0.06833525f, -0.04740948f, -0.00032841f, -0.05695225f, 
    0.01184236f, -0.02679935f, -0.09635226f, -0.07992514f, 0.01458476f, -0.05951050f, -0.02989672f, -0.02849238f, 
    0.05431195f, -0.06043405f, 0.06197794f, 0.01794517f, 0.01790850f, 0.01040411f, 0.02928769f, -0.06247601f, 
    -0.05220889f, -0.01364000f, 0.06816266f, 0.02132189f, 0.05040238f, -0.03676950f, 0.04407020f, 0.02725098f, 
    0.00448005f, -0.03568254f, 0.03359369f, -0.07654111f, 0.03978102f, -0.02338276f, -0.07510214f, -0.00318548f, 
    -0.07155445f, 0.02138132f, -0.03488909f, -0.03803374f, -0.09369195f, -0.03262135f, -0.08561204f, -0.03473780f, 
    -0.03328525f, -0.01287133f, 0.00015242f, -0.05055783f, -0.00725384f, 0.01981302f, 0.05221856f, -0.04967681f, 
    -0.09237634f, -0.01004172f, -0.00350313f, 0.02487712f, -0.00047764f, -0.00028297f, 0.00874567f, -0.08549790f, 
    -0.02898734f, 0.05863424f, -0.04007928f, -0.06022434f, 0.01171973f, -0.02926297f, 0.01157280f, -0.02261477f, 
    -0.03158117f, 0.03100886f, 0.02375254f, -0.04730337f, 0.00026106f, -0.02107828f, -0.02339928f, 0.00321295f, 
    -0.07668242f, -0.02110218f, 0.03409551f, -0.08443047f, -0.09324806f, 0.02969561f, -0.00632631f, 0.04165651f, 
    0.02073578f, -0.04677957f, -0.07799602f, 0.01864748f, -0.01961192f, 0.01490957f, -0.00238457f, -0.03143363f, 
    -0.00824837f, -0.02773695f, 0.03728817f, -0.01152021f, -0.06331576f, -0.05089524f, 0.02571715f, 0.00558026f, 
    0.02219443f, -0.03165064f, 0.02429529f, 0.02784816f, -0.07643037f, 0.01195758f, -0.09315176f, 0.05117039f, 
    0.05378959f, 0.01357261f, 0.04366256f, 0.03658201f, -0.02820046f, -0.00966677f, -0.07679800f, 0.06242206f, 
    -0.03297804f, -0.08056541f, 0.06094962f, -0.00044468f, -0.08373079f, -0.08491366f, 0.00308611f, -0.08205599f, 
    -0.02462754f, -0.03517850f, -0.09166887f, 0.03255727f, -0.01574043f, -0.06390452f, 0.00077914f, 0.05544924f, 
    -0.07352856f, -0.08864260f, -0.02571045f, 0.02389227f, -0.02677884f, -0.01155984f, -0.00692324f, 0.01262273f, 
    -0.05437700f, 0.05429444f, -0.06993096f, 0.06877822f, 0.02290885f, -0.00444236f, -0.07027230f, 0.05075105f, 
    -0.04009960f, 0.02220353f, -0.02100945f, 0.06600007f, 0.02626126f, -0.04808490f, 0.01809570f, 0.01444945f, 
    0.05231749f, -0.03229032f, -0.01099102f, -0.06956250f, 0.06097791f, 0.04123478f, 0.00473847f, -0.04310647f, 
    -0.08416973f, 0.03470925f, 0.00625366f, -0.04648659f, 0.00162426f, 0.03703168f, -0.06231605f, 0.03146807f, 
    0.03000381f, 0.06053787f, -0.04367023f, 0.02937387f, 0.07287286f, 0.00191787f, 0.07263517f, -0.03033036f, 
    0.04819914f, -0.04795341f, 0.06967916f, -0.04998872f, -0.04291140f, -0.05601257f, -0.02927702f, -0.07435344f, 
    -0.04117262f, 0.03575028f, 0.01929570f, -0.06120330f, -0.06982053f, -0.03555066f, -0.04278708f, 0.05366303f, 
    -0.06723690f, -0.03481473f, -0.04301592f, 0.07522680f, -0.06606468f, 0.04138470f, 0.06028550f, -0.07926265f, 
    -0.04578273f, -0.05033325f, -0.03807675f, -0.00823355f, -0.07470894f, -0.04593252f, 0.00092625f, -0.04739184f, 
    -0.02647295f, -0.07987525f, -0.01762087f, -0.08075521f, -0.06693894f, -0.00309836f, -0.01721949f, 0.04764806f, 
    0.04451373f, -0.04464738f, 0.06304305f, 0.05126822f, -0.06691345f, -0.04929636f, -0.03890528f, 0.01853869f, 
    -0.07976020f, 0.06803503f, 0.03174385f, -0.07886637f, -0.00920582f, -0.01494989f, -0.06023779f, 0.02691209f, 
    0.00714365f, -0.07553592f, 0.04674639f, 0.06567398f, -0.00530756f, -0.04294899f, -0.05103239f, 0.00980360f, 
    0.02358218f, 0.00922365f, 0.00832062f, -0.03677100f, 0.00812451f, -0.01099118f, 0.05788741f, -0.06508242f, 
    -0.03810327f, -0.02577837f, -0.00438750f, 0.02301045f, -0.03040121f, -0.01768114f, 0.00357441f, 0.05691529f, 
    0.02812022f, -0.02066176f, -0.04789140f, -0.07952578f, 0.04916137f, -0.03422169f, 0.01593003f, 0.04049951f, 
    -0.07497258f, -0.04291625f, 0.04726439f, 0.05347858f, -0.04347501f, -0.05967250f, -0.06949728f, 0.06597520f, 
    -0.07370941f, 0.05331752f, -0.00029827f, 0.01265534f, 0.02960057f, -0.06971280f, 0.05746055f, 0.02146254f, 
    0.04518465f, -0.06191392f, -0.06101652f, 0.06184986f, -0.08642416f, -0.04841217f, -0.06745516f, 0.06309868f, 
    -0.02058892f, 0.03027909f, -0.06659185f, 0.00428693f, 0.05561772f, 0.06596100f, -0.06820248f, -0.02443103f, 
    -0.04789386f, 0.01842301f, 0.05580123f, 0.05591990f, -0.04090638f, -0.08621281f, 0.03094069f, 0.00843567f, 
    0.00722333f, -0.07365325f, 0.00066298f, -0.00956677f, -0.08897742f, -0.00319417f, 0.05640395f, -0.05712557f, 
    -0.05269177f, 0.06675617f, 0.03903518f, 0.04788675f, 0.00159313f, 0.06495015f, -0.08093464f, -0.01397035f, 
    -0.00327176f, -0.07737564f, -0.08906930f, -0.01273489f, 0.01319746f, 0.00267792f, -0.02691850f, -0.07877961f, 
    -0.05745179f, -0.10501188f, 0.01379824f, 0.00706890f, -0.04171329f, -0.00767402f, 0.05813430f, 0.05146833f, 
    -0.06429205f, 0.00716685f, -0.04466986f, -0.02314118f, 0.00837353f, -0.00816594f, 0.06322949f, -0.03064334f, 
    -0.01986544f, -0.08869014f, -0.06796288f, -0.01476276f, -0.09541742f, -0.07288692f, 0.06359092f, 0.02101323f, 
    -0.08559348f, 0.07097843f, -0.07977679f, -0.07311539f, -0.02600738f, -0.05727861f, -0.03597467f, 0.06512932f, 
    0.05309694f, -0.06516574f, -0.08017340f, -0.03570949f, 0.01748740f, -0.03708326f, -0.05375047f, -0.05530864f, 
    0.01352717f, -0.03129412f, -0.01386011f, 0.05268907f, -0.09033874f, 0.05907230f, 0.06033673f, -0.02956855f, 
    0.01861206f, -0.03978149f, -0.01350682f, -0.06283233f, -0.04630110f, 0.05176210f, 0.05871999f, 0.02720353f, 
    -0.04336810f, -0.03467197f, -0.06619813f, -0.03097620f, -0.07628618f, 0.00238655f, -0.04941013f, 0.04887129f, 
    -0.08261531f, 0.04130106f, 0.01351557f, -0.05576191f, -0.08262061f, -0.00621137f, -0.03317457f, -0.04627313f, 
    -0.02051532f, 0.02761984f, 0.02056969f, -0.01205218f, -0.06436186f, 0.04893390f, -0.07631021f, 0.00833393f, 
    0.05307031f, 0.03995368f, 0.06014191f, 0.02305134f, -0.00643888f, 0.06405840f, 0.06686488f, -0.03033244f, 
    -0.01454694f, 0.04687760f, 0.04828516f, -0.07586759f, -0.04482146f, -0.08720670f, 0.04507932f, -0.00088277f, 
    -0.05613047f, -0.01299034f, 0.01546071f, 0.02829301f, -0.07253633f, -0.01948672f, -0.00282759f, 0.01528704f, 
    -0.02130225f, -0.41669825f, -0.22693540f, 0.10679114f, -0.00631081f, 0.14236197f, 0.00295823f, 0.10743023f, 
    -0.10182135f, 0.13490881f, 0.41553092f, 0.21170902f, -0.08763590f, -0.32364908f, -0.00325241f, 0.03821165f, 
    0.22477168f, -0.20932063f, -0.44687214f, 0.57817519f, -0.02426116f, 0.06015092f, 0.14559589f, 0.31230426f, 
    0.13525277f, -0.13735345f, -0.11956659f, 0.06016235f, 0.13964230f, -0.39582402f, -0.02382065f, 0.16929480f, 
    0.02074532f, -0.17045371f, -0.12216388f, 0.16539294f, -0.26928538f, -0.32037333f, 0.09447446f, -0.39165840f, 
    -0.19779465f, 0.00646643f, 0.01293061f, 0.01579954f, 0.25133249f, -0.22325611f, -0.48772845f, -0.56063294f, 
    0.14938247f, 0.22938073f, 0.01501371f, -0.28521189f, -0.02178155f, -0.30928051f, 0.53451651f, -0.11317351f, 
    0.10909367f, -0.44586465f, -0.31182277f, 0.10106608f, -0.25063956f, 0.17680056f, 0.32277095f, -0.12969339f, 
    0.32307956f, 0.18480709f, 0.20316115f, -0.18510182f, 0.03291152f, -0.01128629f, 0.02819652f, -0.04582198f, 
    0.03616186f, 0.38581628f, -0.06560940f, 0.08923063f, 0.23442845f, 0.04004324f, -0.22520824f, 0.14804396f, 
    -0.09087749f, -0.14945848f, 0.28474262f, 0.03554052f, 0.34394723f, 0.23669443f, -0.07880778f, 0.16387758f, 
    -0.18937282f, 0.02408227f, 0.14100905f, 0.33693254f, 0.17476723f, -0.40773222f, 0.18171734f, 0.11599195f, 
    0.09990673f, 0.11262961f, -0.16937020f, 0.03679954f, 0.51402014f, -0.27979216f, 0.31762531f, -0.03262862f, 
    -0.20634834f, 0.06074573f, 0.09468328f, -0.29242238f, 0.50922346f, -0.13419014f, 0.05999390f, -0.02532267f, 
    0.03471712f, 0.06551962f, 0.12035717f, -0.03794942f, -0.11829057f, 0.03921403f, -0.05230489f, -0.00361676f, 
    0.23314384f, -0.24367939f, -0.01415189f, -0.01457771f, -0.15322807f, 0.46899316f, -0.04982777f, -0.33716524f, 
    -0.36188871f, 0.35900354f, 0.27262363f, -0.00201285f, -0.05051212f, 0.01708240f, -0.09989106f, 0.00366198f, 
    0.01872565f, -0.07143523f, -0.03346208f, -0.00155551f, -0.06655163f, -0.15784736f, 0.15853466f, -0.16065755f, 
    0.05364103f, -0.00552212f, 0.06316484f, -0.04105518f, -0.05772571f, 0.04322364f, -0.02039294f, -0.04466521f, 
    -0.07022192f, -0.01452059f, -0.06543407f, -0.02509222f, -0.06041444f, -0.01994888f, -0.00487850f, -0.03450140f, 
    -0.09111141f, -0.05741714f, -0.04991186f, -0.00546014f, -0.04593807f, 0.05726190f, 0.07268076f, -0.06526493f, 
    0.06260712f, -0.03080519f, -0.06407158f, -0.01207034f, 0.02393827f, -0.06386316f, -0.02311646f, 0.02788716f, 
    0.02851126f, -0.03261864f, -0.00387807f, 0.01371182f, 0.02017917f, -0.03241216f, 0.02396811f, -0.05306550f, 
    -0.02613322f, 0.07562754f, -0.06808308f, -0.07890526f, -0.01992159f, 0.03656507f, 0.00772280f, 0.02175757f, 
    0.01900517f, 0.05825423f, 0.04541007f, -0.05981720f, -0.06480895f, 0.01943884f, -0.08403265f, -0.02562847f, 
    -0.02491703f, 0.01612975f, -0.04024336f, 0.03141157f, 0.01025135f, -0.04410738f, 0.03396243f, 0.06244877f, 
    -0.08661152f, 0.03751530f, -0.07340704f, -0.05146785f, -0.06604385f, -0.07517605f, -0.01505256f, 0.02699376f, 
    0.01738967f, 0.07303996f, 0.04050456f, -0.04840088f, -0.08086304f, -0.06617439f, 0.07251482f, 0.01929661f, 
    0.06022035f, 0.04173110f, -0.06606563f, -0.04088441f, 0.03792884f, -0.01809448f, -0.00516857f, -0.00607556f, 
    -0.08979490f, -0.06658392f, -0.03271030f, -0.01741646f, 0.00948844f, -0.06990816f, -0.01700437f, 0.03214578f, 
    -0.04497373f, -0.02271657f, -0.05544439f, 0.00115227f, -0.00333773f, -0.03425233f, -0.02193019f, 0.01222869f, 
    0.04244123f, 0.02468176f, -0.06743699f, -0.08188696f, 0.00670392f, -0.08526541f, 0.00107882f, -0.02259156f, 
    0.03897631f, 0.07092831f, 0.04675689f, -0.04540173f, 0.00249499f, -0.04711490f, 0.04372395f, -0.08747552f, 
    0.01722943f, -0.01033559f, -0.04903610f, -0.04867354f, -0.02019819f, -0.07553866f, -0.00470073f, 0.06127901f, 
    0.01182882f, 0.02347180f, 0.06924166f, -0.07507337f, -0.03512644f, 0.02222489f, 0.04627244f, 0.05135905f, 
    -0.05250627f, -0.05726784f, -0.01173769f, 0.02693674f, -0.01270028f, -0.02560116f, -0.08170627f, -0.01911299f, 
    -0.67569619f, -0.36155751f, -0.04511221f, -0.07071409f, 0.11626959f, -0.06277040f, 0.37654221f, 0.05147500f, 
    0.03608890f, 0.41953957f, 0.12236521f, 0.20387354f, 0.08600403f, 0.01418820f, 0.18784933f, 0.23804903f, 
    0.18699062f, 0.23503922f, 0.42041099f, 0.31235313f, 0.30314061f, 0.20598930f, 0.14404008f, 0.21574852f, 
    -0.03150390f, 0.27617437f, 0.01534891f, -0.30808744f, -0.06854443f, -0.32741863f, 0.13148229f, 0.28446579f, 
    0.32335263f, -0.43174481f, -0.21755564f, 0.22202861f, -0.45527187f, 0.32233602f, -0.63427216f, 0.46566138f, 
    0.14640255f, -0.01812096f, 0.15232182f, 0.41832149f, -0.13155411f, 0.00664469f, -0.07286573f, 0.17377143f, 
    -0.32620859f, -0.20023850f, -0.16948959f, 0.25509736f, -0.00182190f, -0.01671534f, -0.18290922f, -0.94041443f, 
    -0.68069607f, 0.29457667f, 0.51507026f, 0.27490386f, 0.04217846f, -0.38600203f, -0.32428986f, 0.20427069f, 
    0.41711143f, 0.32741633f, 0.04720470f, -0.09498597f, -0.04911238f, -0.18064980f, 0.09729479f, 0.02130880f, 
    0.43265972f, 0.49425867f, 0.18610048f, -0.20423852f, -0.12789856f, -0.22614151f, 0.23702507f, 0.20478986f, 
    -0.08260824f, -0.00075863f, 0.43459362f, 0.16049832f, -0.04061242f, 0.13199726f, 0.17389801f, 0.00193958f, 
    -0.04559516f, 0.04873574f, -0.22913516f, 0.08798444f, 0.10328530f, 0.07077552f, -0.07067037f, 0.09100848f, 
    0.23765032f, 0.02145523f, 0.17620715f, 0.51280206f, 0.25271338f, 0.10604414f, -0.12436208f, -0.15185055f, 
    0.20270813f, 0.10301370f, 0.05785818f, 0.24469659f, -0.34700492f, -0.52871346f, -0.28703329f, 0.01679043f, 
    0.11549636f, 0.00329371f, -0.14617269f, -0.06540100f, 0.12032353f, -0.15200652f, 0.02729350f, -0.23737335f, 
    0.05961972f, 0.32559037f, 0.13986193f, 0.12498198f, 0.02822791f, -0.07822575f, 0.27105707f, 0.16030943f, 
    0.16710287f, -0.00771875f, 0.10442103f, -0.31619051f, 0.13042611f, 0.15716104f, 0.18497993f, -0.46217710f, 
    -0.74081516f, -0.26923177f, -0.16666085f, -0.00839134f, -0.04269365f, 0.27984083f, 0.15374477f, 0.02239937f, 
    -0.23329757f, 0.11713693f, -0.50546783f, 0.02922946f, 0.01557677f, 0.00110454f, 0.25816330f, -0.02932999f, 
    0.37739667f, -0.32334098f, -0.24740401f, -0.08246001f, -0.01238187f, 0.18682779f, 0.12087937f, -0.15253022f, 
    0.03284553f, 0.07908811f, -0.44236371f, -0.16339821f, -0.16732244f, -0.08407360f, -0.00435872f, 0.11030001f, 
    -0.00080798f, -0.07567371f, 0.16058338f, -0.43995452f, -0.32370737f, 0.12766494f, 0.12044853f, 0.04339615f, 
    0.08505666f, -0.14381742f, 0.03765702f, -0.24738650f, 0.26894507f, -0.11396991f, 0.46741530f, -0.15662639f, 
    0.03795066f, 0.13826767f, -0.05897999f, -0.04143689f, -0.06748351f, -0.45167378f, -0.27652410f, -0.12397955f, 
    0.36729658f, 0.36603561f, -0.11414876f, 0.00681995f, -0.15791418f, 0.23916005f, 0.34287509f, 0.05907510f, 
    0.05904284f, -0.04575298f, -0.11204894f, 0.06267029f, 0.14945768f, 0.07938334f, 0.06567679f, -1.01890957f, 
    0.25330380f, -0.11355395f, 0.27079254f, 0.06772679f, 0.06851671f, -0.34290427f, -0.00496220f, -0.09374432f, 
    -0.89946955f, -0.31055090f, -0.20705631f, 0.09673604f, 0.00538870f, 0.07343617f, 0.03901224f, 0.00927120f, 
    -0.03673675f, 0.00010334f, 0.17335042f, 0.24226740f, 0.18994014f, 0.17938444f, 0.03777251f, 0.08774941f, 
    -0.03993400f, -0.02258625f, -0.63745910f, -0.18693253f, -0.11031753f, 0.25740740f, 0.07810626f, -0.23714079f, 
    0.09134100f, -0.13089167f, 0.17804201f, 0.17554851f, 0.46778727f, -0.15210183f, 0.13303375f, -0.04548145f, 
    -0.24053584f, -0.19692747f, -0.05988738f, 0.24956128f, -0.15007472f, 0.26056010f, 0.25102723f, -0.14347203f, 
    0.16638601f, -0.10094406f, 0.10684637f, -0.03857885f, 0.06723884f, 0.23690130f, 0.52401370f, 0.02516373f, 
    -0.27673006f, 0.24386869f, 0.02801085f, -0.34200552f, 0.07051970f, 0.04234718f, -0.06093587f, 0.08070751f, 
    -0.13353194f, -0.04549669f, 0.18221541f, -0.01731736f, -0.24338436f, -0.24361922f, -0.03935226f, 0.12840952f, 
    -0.08191307f, -0.21811274f, 0.20020056f, -0.14860716f, -0.14191596f, 0.11385394f, 0.08564373f, 0.06826662f, 
    -0.12630068f, -0.12716469f, 0.29323986f, -0.18685886f, -0.16932431f, -0.06062627f, 0.00714189f, 0.25476670f, 
    0.10453338f, -0.17379418f, -0.04325544f, -0.38207981f, 0.09377351f, 0.22090073f, -0.14182046f, 0.01974201f, 
    0.03914553f, 0.00517675f, -0.17820583f, 0.17812854f, -0.00660797f, -0.21439928f, -0.09266274f, -0.12497493f, 
    0.03919314f, 0.10408480f, 0.13651739f, 0.60491318f, -0.51692843f, 0.02514454f, -0.12827693f, 0.01573267f, 
    0.39714193f, -0.16630939f, -0.13405964f, -0.05443500f, -0.09887580f, 0.10805933f, -0.42652234f, 0.57166052f, 
    0.23415881f, 0.31543514f, 0.32055974f, 0.10052791f, -0.06328975f, 0.14627695f, 0.33367121f, 0.31540939f, 
    0.06595490f, 0.17734030f, -0.18762033f, 0.10605463f, -0.01355649f, 0.12044875f, 0.74316519f, 0.70484763f, 
    -0.17339548f, 0.22765820f, 0.27300736f, -0.06334200f, 0.09225968f, -0.18338431f, 0.00549999f, -0.24795915f, 
    0.31525078f, -0.02712560f, -0.47312993f, -0.16652562f, -0.10364997f, -0.04642886f, 0.20393410f, 0.06533466f, 
    0.47523570f, -0.19804175f, 0.03908144f, -0.02931892f, -0.10797007f, -0.17538120f, -0.15904416f, -0.04653177f, 
    -0.10924544f, 0.26970768f, -0.02387938f, 0.06298730f, -0.11540289f, 0.02105268f, 0.01716312f, -0.21542774f, 
    -0.01271167f, 0.00756007f, -0.69465864f, -0.23700076f, -0.34052595f, 0.03690700f, -0.05437754f, -0.12118767f, 
    -0.18968683f, -0.05984747f, 0.08748734f, -0.18901035f, -0.32800385f, 0.13753203f, -0.36890990f, -0.16059557f, 
    -0.14116643f, 0.05548157f, -0.11271336f, 0.25816786f, -0.08852299f, -0.34472585f, -0.13293822f, 0.01119079f, 
    0.11099692f, 0.10215257f, -0.06030532f, -0.01692836f, -0.06756486f, -0.66038382f, -0.42795798f, 0.27247345f, 
    0.08769363f, 0.04358542f, -0.06681272f, 0.07772930f, 0.13702671f, -0.16252407f, 0.21579309f, -0.03833034f, 
    0.13961786f, -0.19039018f, -0.02064940f, -0.10790558f, 0.19789281f, 0.28110823f, 0.26806548f, -0.24284814f, 
    -0.16358791f, 0.14571010f, -0.06803266f, -0.03481160f, -0.04353615f, -0.01701435f, 0.10611232f, 0.03002865f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.00481356f, 0.05707031f, 0.02680357f, 0.14340211f, 0.01114782f, 0.04414820f, 0.07621676f, 0.06555800f, 
    -0.08175310f, 0.05844670f, 0.00704448f, 0.29360229f, -0.00217295f, 0.38986850f, 0.07393152f, -0.26307562f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.41551420f, -0.20479693f, 0.06699444f, -0.25901419f, 0.06264482f, 0.08915823f, -0.10376253f, -0.01859569f, 
    0.02348712f, 0.18787083f, 0.14617811f, 0.07367810f, -0.16558982f, -0.18844110f, -0.13560492f, 1.09755707f, 
    -0.17773114f, 0.63588274f, 0.17464800f, -0.64736485f, 0.07249274f, -0.06972357f, -0.24986547f, 0.15885882f, 
    -0.21129860f, 0.12072799f, 0.14402764f, -0.10629977f, 0.10609748f, 0.04581698f, -0.00915355f, 0.37900332f, 
    0.21914728f, 0.67717242f, -0.20854931f, -0.06529408f, -0.15651292f, -0.92203611f, -0.17787755f, -0.18579619f, 
    -0.05702418f, 0.08170593f, -0.15295373f, 0.74175256f, 0.21249066f, -0.34164751f, 0.20556697f, -0.47023079f, 
    0.48270196f, -0.31461662f, -0.19408202f, 0.09801411f, -0.10657961f, 0.86857861f, -0.51665723f, -0.07351823f, 
    -0.06274857f, -0.26492628f, 0.17460863f, 0.15579270f, 0.16960965f, -0.60971135f, -0.13880076f, -0.27526101f, 
    -0.50538069f, -0.40930372f, -0.17322291f, 0.21075033f, 0.15072234f, 0.01409238f, 0.14582665f, -0.18932886f, 
    0.09725738f, -0.10847593f, -0.03878264f, 0.30098942f, 0.03821225f, -0.09165404f, 0.10345594f, -0.31874827f, 
    0.01818311f, -0.07150903f, 0.14334854f, -0.14227210f, -0.18418443f, -0.23993608f, -0.01008981f, 0.20974246f, 
    0.11157866f, -0.08554284f, -0.11382982f, -0.68059409f, 0.11064290f, 0.27116093f, -0.12127426f, 0.11042057f, 
    -0.25030518f, -0.50307727f, -0.18516022f, -0.24997802f, 0.15084803f, -0.02147303f, -0.60643303f, 0.12574075f, 
    -0.01660498f, 0.01218086f, 0.20686287f, 0.42101169f, -0.18166961f, 0.44015595f, -0.43514204f, -0.53485107f, 
    -0.71651220f, -0.11839915f, 0.12147681f, 0.38100883f, -0.10921399f, 0.39095679f, 0.54833013f, 0.05995424f, 
    -0.15575348f, 0.07653897f, 0.20429881f, -0.55795372f, 0.01848630f, -0.74421006f, 0.35281530f, 0.36295304f, 
    0.44285586f, 0.03592801f, 0.10118879f, -1.07698381f, 0.15709393f, -0.05910896f, 1.04452360f, 0.22572237f, 
    -0.13883589f, -0.00416470f, 0.18770802f, -0.46803433f, -0.15658602f, 0.12011978f, -0.80089569f, -0.28013638f, 
    -0.38350961f, -0.71609354f, 0.09186472f, -0.04911371f, 0.03156859f, -0.25633737f, 0.37613508f, 0.09698696f, 
    -0.25199744f, 0.07752959f, 0.04631267f, 0.30771840f, 0.05329822f, 0.13794281f, -0.12996218f, -0.30796871f, 
    0.57062650f, 0.49932298f, -0.24453107f, -0.06895021f, 0.09471236f, -0.27811700f, -0.35448146f, 0.02519741f, 
    -0.20884801f, -0.06637527f, 0.11866814f, -0.15365507f, 0.20773271f, -0.35845423f, 0.94250327f, -0.94025683f, 
    0.91033059f, -0.12226816f, 0.14975393f, 0.35289553f, -0.02823290f, 0.30604601f, -0.26355565f, 0.03902821f, 
    -0.11009308f, -0.11424077f, 0.22128506f, 0.00415358f, 0.19456241f, -0.37146050f, -0.93381160f, -0.30916819f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02045486f, 0.35218537f, -0.58028561f, -0.16998158f, 0.39268064f, 0.44709367f, -0.27197394f, -0.97136843f, 
    -0.54347855f, 0.45814043f, 0.45443335f, 0.11027421f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
