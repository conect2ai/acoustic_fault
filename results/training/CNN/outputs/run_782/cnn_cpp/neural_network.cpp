#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.02264726f, -0.03447739f, -0.85196996f, -0.20613696f, -0.09979016f, -0.57559764f, -0.66135514f, 0.23738889f, 
    -0.06996986f, -0.44092152f, -0.48633146f, -0.41079268f, 0.37664071f, -0.23406720f, -0.06686691f, -0.05841461f, 
    -0.11688871f, -0.28659862f, -0.13666971f, -0.08851432f, 0.03131916f, 0.02768710f, -0.03479919f, -0.26680511f, 
    -0.15123819f, -0.70149559f, -0.91753644f, -0.71290296f, -0.36878243f, -0.04440955f, 0.06801464f, -0.33153617f, 
    -0.16863303f, 0.06096449f, -0.10496379f, -0.37940764f, 0.04458323f, -0.03924382f, -0.26942724f, -0.55551416f, 
    0.21911000f, -0.17968652f, 0.01845700f, 0.04182564f, 0.14257225f, 0.13039406f, 0.10702205f, -0.11831217f, 
    0.02800778f, 0.35804230f, 0.30309334f, -0.44841838f, -0.90914667f, -1.17943263f, -0.14812277f, 0.11428878f, 
    0.42046842f, 0.41386414f, 0.04895050f, 0.18374135f, -0.36387414f, 0.05049992f, -0.32206720f, -0.43589330f, 
    -0.22465390f, -0.02927134f, -0.15051812f, 0.25556833f, 0.00066162f, -0.24686438f, -0.13194965f, 0.17798845f, 
    -0.12374666f, -0.08840663f, -0.04868675f, -0.43846393f, -1.20788896f, 0.51893783f, 0.88096511f, -0.34433866f, 
    0.32632780f, 0.52819055f, 0.67796439f, -0.49405131f, -0.53205007f, 0.15171041f, 0.03802110f, 0.04784524f, 
    0.33713078f, 0.19244276f, -0.16304420f, 0.04559229f, -0.13188225f, -0.24267407f, -0.16449015f, -0.11591987f, 
    0.14863309f, -0.01606618f, -0.00110333f, -0.01103026f, 1.02387559f, 0.67604285f, -0.69491673f, 0.17970534f, 
    -0.15484001f, -0.13213083f, 0.51265961f, 0.68398672f, 0.38082984f, 0.39105085f, 0.15121923f, 0.09122778f, 
    0.19027746f, -0.43338057f, 0.25806624f, 0.36337647f, -0.04905884f, -0.10771323f, -0.24452019f, 0.35563955f, 
    -0.01145680f, 0.00887022f, 0.07111168f, 0.05821689f, -0.35368031f, -0.28845894f, -1.00832534f, -0.72010821f, 
    -0.11758114f, -0.10322466f, -0.51175356f, 0.41047642f, -0.24983902f, -0.24688981f, 0.43817571f, 0.52796376f, 
    0.14974298f, -0.02833952f, 0.31612945f, 0.38539210f, -0.02496177f, 0.19808809f, 0.06821104f, 0.16805997f, 
    0.22716033f, 0.07812862f, 0.07809930f, 0.16843018f, -0.00548987f, 0.20736571f, 0.70285082f, 0.23285255f, 
    0.12318689f, 1.26775336f, 0.86315250f, 0.41832411f, -0.17495482f, -0.40071359f, 0.44470564f, 0.09024344f, 
    -0.00919237f, 0.25623581f, 0.09139122f, 0.03055404f, -0.12811339f, -0.13063005f, -0.06729297f, 0.34959874f, 
    -0.10315589f, 0.00323824f, -0.08406096f, -0.00367881f, 0.13595690f, -0.10939039f, -0.01315578f, 0.62823427f, 
    0.61828583f, 0.80045933f, 0.53302878f, 0.57537735f, 0.74005395f, -0.11303069f, -0.14225847f, -0.50196612f, 
    0.01658024f, 0.15598559f, 0.25101963f, -0.31361923f, 0.08795609f, -0.12848961f, 0.13976263f, -0.26901832f, 
    -0.22615299f, -0.00902718f, -0.25533310f, 0.26533264f, 0.04685027f, 0.17359322f, -0.07845455f, 0.26896545f, 
    -0.64856648f, -0.35656375f, -0.49356598f, -0.13102807f, 0.19480579f, -0.41581774f, 0.93913347f, 0.51587945f, 
    -0.18405661f, 0.50525385f, -0.31822774f, -0.31238702f, 0.06383609f, -0.17215034f, 0.16532232f, -0.03911152f, 
    0.32056025f, -0.02842019f, 0.15310727f, 0.00048925f, 0.19027595f, -0.16337584f, -0.35225672f, -0.29235625f, 
    -0.02722656f, 1.08472610f, 0.61232841f, 0.29838163f, 0.32859781f, -0.18150832f, -0.02712928f, -0.40820560f, 
    0.49008304f, 0.42856175f, 0.29904172f, -0.18126731f, -0.10226870f, 0.06469876f, -0.20817043f, 0.05120846f, 
    -0.14757760f, -0.06257759f, -0.36864686f, -0.13800234f, -0.17081662f, -0.16458002f, -0.10853142f, -0.17108464f, 
    -0.20857188f, 0.09040109f, 0.84424585f, 0.44007415f, 0.12166045f, -0.57342607f, 0.29604825f, -0.39420125f, 
    -0.05610128f, 0.16865343f, 0.16267247f, 0.45782498f, -0.11513476f, -0.08818028f, 0.01269674f, 0.29376131f, 
    0.24773891f, 0.16763628f, 0.16840211f, -0.09149132f, 0.35819036f, 0.53550136f, 0.36121756f, 0.44282049f, 
    -0.27209088f, -0.04090812f, 0.05672989f, -0.23135623f, -0.41072375f, -0.70258254f, 0.20995775f, -0.42435944f, 
    0.50338107f, 0.88779324f, -0.85740751f, 0.10041326f, -0.14241086f, 0.00928571f, -0.11047972f, -0.05988656f, 
    0.13064978f, 0.36465657f, -0.08899907f, -0.05795129f, 0.19613977f, -0.00998067f, 0.06449563f, 0.03191512f, 
    -0.03776659f, -0.16281512f, -0.23999734f, 0.02151583f, -0.51550651f, -0.56181782f, -0.26549238f, 0.23595536f, 
    -0.58567786f, 0.28898442f, 0.87327272f, -0.06313007f, 0.41959950f, 0.43218964f, -0.12183049f, -0.04737614f, 
    -0.07440677f, -0.03060498f, -0.03929344f, -0.10132318f, -0.18289723f, 0.10708110f, 0.04581656f, -0.18737227f, 
    0.16108017f, 0.01558340f, 0.24438041f, 0.38874677f, 0.03248993f, -0.90922761f, 0.19476093f, 0.44321918f, 
    -0.28827938f, 0.31476384f, -0.97252142f, 0.14081906f, -0.06195239f, -0.60977995f, -0.69074833f, 0.13046898f, 
    0.07433778f, 0.06725438f, 0.24170418f, 0.24773671f, 0.40370715f, 0.10055010f, 0.03908995f, 0.04139389f, 
    -0.11646177f, 0.06218103f, -0.02461205f, 0.02794910f, -0.00845534f, 0.08727949f, 0.16548461f, -0.50751334f, 
    -0.64130360f, 0.28831789f, 0.63350827f, 0.42792547f, 0.67493534f, 0.47674465f, 0.54612827f, 0.09496658f, 
    0.07682503f, 0.23534565f, -0.44733053f, 0.05676118f, -0.22104697f, 0.01512273f, -0.32122639f, -0.10981002f, 
    -0.00923979f, 0.00224351f, 0.06057063f, -0.13166575f, 0.06252123f, 0.07912163f, -0.11512487f, 0.72913504f, 
    0.30568120f, 0.66167808f, 0.60059774f, 0.44698438f, -0.63221860f, 0.60265076f, -0.08212293f, -0.89386094f, 
    -0.25760219f, -0.08584262f, 0.23260568f, 0.23058030f, 0.62610263f, 0.02144523f, -0.15192100f, 0.28536537f, 
    0.39223826f, 0.18100853f, 0.20656185f, -0.20777144f, 0.03904440f, 0.01675089f, 0.18067062f, 0.12174167f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.20828889f, 0.10187228f, 0.10884346f, 0.29778004f, 0.24806818f, 0.21424460f, -0.08230896f, 0.18365891f, 
    -0.03500525f, 0.21644776f, 0.18438151f, 0.27892655f, 0.01379099f, 0.39111358f, 0.01647396f, -0.15468284f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.08781976f, -0.16976696f, 0.25018677f, -0.08690130f, 0.01528570f, -0.13342857f, -0.08212182f, 0.07530592f, 
    0.06315494f, -0.06639387f, -0.05078732f, -0.07201503f, 0.17720132f, 0.08863564f, -0.06701168f, -0.10527540f, 
    -0.02968795f, 0.18262294f, 0.23764312f, -0.13566446f, -0.00047953f, 0.03787475f, -0.04501585f, -0.03455123f, 
    0.39588726f, 0.05149130f, -0.13400972f, -0.26159608f, 0.06527343f, 0.10950228f, 0.02560222f, 0.03488773f, 
    0.19695380f, -0.17533405f, 0.05933588f, -0.14709859f, -0.44531080f, 0.19512521f, 0.02636221f, 0.31997576f, 
    0.16975899f, 0.12101644f, 0.01845693f, 0.01492348f, 0.00583302f, 0.03016382f, 0.03668262f, -0.03985529f, 
    0.05443998f, -0.00016040f, 0.04764985f, -0.15785770f, -0.03266479f, -0.06331402f, 0.08712561f, -0.07758253f, 
    0.09038366f, 0.09103306f, -0.09193718f, 0.19750763f, -0.18032129f, -0.33925223f, -0.19163044f, 0.04380598f, 
    0.14130887f, -0.08599281f, -0.02041183f, 0.00430871f, -0.00904684f, 0.05593183f, 0.07958297f, 0.28384957f, 
    0.07034663f, -0.29668671f, -0.01168214f, -0.05632125f, 0.08478033f, -0.11885325f, -0.07128439f, -0.10156064f, 
    0.04806627f, 0.00583613f, 0.28404275f, 0.02515199f, 0.08776833f, -0.23669687f, 0.19972046f, 0.22194776f, 
    -0.00337482f, 0.06439336f, 0.01458649f, -0.04044826f, 0.05445167f, 0.08246913f, -0.14668949f, 0.05126495f, 
    0.10278662f, 0.18263976f, -0.26043364f, -0.15551676f, 0.13859028f, 0.13071722f, -0.23963022f, 0.08340634f, 
    0.03778946f, 0.01753759f, 0.02385213f, -0.21903227f, 0.11459467f, -0.11801782f, -0.01749386f, 0.08102243f, 
    0.25738218f, 0.00009456f, -0.04426356f, -0.08337538f, -0.09499139f, -0.19768047f, -0.08100849f, 0.02255030f, 
    0.18854819f, 0.09461370f, 0.15800954f, -0.04641798f, 0.05645273f, 0.00245195f, 0.03614084f, 0.07810072f, 
    0.11408788f, 0.22467098f, 0.15632227f, 0.12514856f, 0.14040835f, -0.08179468f, -0.22926518f, 0.09711625f, 
    0.06045482f, 0.00467982f, 0.01372645f, 0.07984165f, 0.05150494f, 0.06922336f, 0.21501184f, -0.05454297f, 
    0.19180974f, -0.03315524f, -0.32222795f, -0.12932660f, 0.01166702f, -0.09054372f, 0.00434091f, 0.05878779f, 
    0.16168745f, 0.03331595f, 0.07657114f, 0.02073719f, -0.08696043f, 0.20226233f, -0.03757330f, -0.09458124f, 
    0.09052224f, 0.10975851f, 0.04546532f, 0.08224779f, 0.12923944f, 0.02623145f, 0.04483468f, 0.29555151f, 
    0.21416168f, 0.14207444f, 0.00331514f, -0.15339118f, 0.07559471f, -0.02699750f, -0.11382377f, -0.01245656f, 
    0.06251844f, -0.05659005f, -0.20670772f, -0.02779493f, -0.22839457f, -0.01149694f, 0.01516331f, 0.14556517f, 
    -0.15410478f, -0.04641675f, -0.12969278f, 0.04695782f, -0.10811950f, -0.04443881f, 0.22066545f, 0.13211115f, 
    0.04502051f, 0.05915872f, -0.05033727f, -0.02287418f, 0.03694073f, 0.01882788f, 0.06012487f, 0.04564984f, 
    0.05236041f, -0.07410754f, 0.05900935f, 0.01615396f, -0.07142452f, 0.06246526f, 0.02774275f, -0.04397167f, 
    -0.03370976f, -0.05847967f, 0.06147285f, -0.03228949f, -0.01419778f, 0.06260907f, -0.01166314f, -0.04769256f, 
    0.00968555f, 0.05851756f, -0.05134320f, -0.06396762f, -0.05525344f, -0.00008492f, 0.05468569f, -0.03545558f, 
    -0.03263270f, -0.02120394f, 0.00512014f, -0.04837165f, -0.03850455f, -0.01542246f, 0.02945300f, 0.04562427f, 
    -0.05656399f, -0.06526437f, -0.06707694f, -0.00289483f, 0.02201927f, -0.06450187f, -0.05500763f, -0.04545144f, 
    -0.03731588f, -0.01431332f, -0.03372861f, -0.03834327f, -0.02603373f, 0.04764396f, 0.05420857f, 0.05551778f, 
    -0.03262301f, -0.02087150f, -0.01988918f, 0.03089053f, 0.03137330f, -0.06188364f, -0.07517523f, -0.00838688f, 
    0.03036387f, 0.00432225f, -0.00113905f, -0.06985183f, 0.01384111f, -0.01444294f, 0.04423632f, 0.02264055f, 
    -0.05413772f, -0.01698018f, 0.05914296f, 0.01818202f, -0.06940997f, 0.01064176f, -0.03779493f, 0.01827825f, 
    -0.07467584f, -0.04174852f, -0.02980814f, -0.01448723f, -0.01173952f, 0.03108226f, -0.03990541f, 0.04884336f, 
    0.03277087f, 0.04736082f, 0.03283533f, -0.01917006f, 0.02653385f, 0.04391581f, 0.04591409f, -0.06576329f, 
    -0.03659909f, -0.06561919f, 0.01867254f, 0.05896730f, 0.05222558f, -0.02032860f, 0.04305773f, -0.07720523f, 
    0.01712848f, -0.00736272f, 0.03023856f, -0.04214365f, -0.02511033f, -0.05037608f, 0.02401626f, -0.04743940f, 
    -0.05433487f, 0.03938616f, -0.01836172f, -0.04875878f, -0.02960927f, -0.00817232f, -0.07013492f, -0.00859607f, 
    0.04410980f, 0.03139730f, -0.03401322f, -0.07639632f, -0.07550845f, -0.03800470f, -0.00812880f, -0.03180638f, 
    -0.03537041f, -0.00632263f, 0.04905931f, -0.05020433f, -0.07960988f, 0.00185637f, -0.03068245f, 0.04186613f, 
    -0.05234092f, 0.03148737f, -0.03707756f, -0.07222857f, 0.03591914f, -0.02718667f, -0.06689785f, -0.05801498f, 
    -0.01991791f, 0.01253765f, 0.01884927f, 0.02096906f, 0.05014713f, 0.00163438f, -0.00465817f, 0.01155979f, 
    -0.06266055f, -0.01134989f, -0.02287722f, -0.05547754f, -0.05120831f, -0.05734620f, 0.04148049f, -0.07831112f, 
    -0.03153983f, 0.02430252f, -0.02800375f, -0.00571758f, -0.06818310f, 0.05529821f, -0.01245686f, -0.02572407f, 
    -0.02993020f, -0.05536025f, 0.05889823f, 0.05672341f, -0.00631965f, -0.06946908f, 0.04678799f, 0.03347041f, 
    0.04399603f, 0.00849619f, -0.01848195f, -0.03568255f, 0.04965582f, 0.04980422f, -0.04484932f, 0.01755252f, 
    -0.00780914f, 0.03673133f, 0.04152139f, -0.01793173f, 0.05930009f, -0.06224846f, -0.04569722f, -0.06787582f, 
    -0.03329692f, -0.04300679f, 0.04283025f, 0.06776606f, 0.04038453f, -0.04543982f, -0.04616092f, -0.04580335f, 
    -0.06025238f, 0.00333178f, 0.00737787f, 0.05475128f, -0.00328798f, 0.00677091f, 0.05718531f, -0.05877694f, 
    0.04833994f, 0.00727795f, -0.03902629f, 0.05777945f, -0.02458994f, -0.01371953f, -0.04292199f, 0.05318230f, 
    -0.01814348f, 0.06818100f, -0.05006211f, 0.03658079f, -0.01876380f, 0.00814159f, 0.03663705f, -0.05659892f, 
    -0.00277146f, -0.04046560f, -0.05260851f, 0.07132522f, 0.03937495f, -0.06185861f, -0.06600009f, 0.06149722f, 
    -0.05500415f, -0.06234780f, -0.02097702f, -0.01295331f, 0.05091759f, 0.02209586f, -0.06681874f, -0.03545813f, 
    0.00904178f, 0.03622134f, -0.02738970f, -0.05705113f, -0.01802512f, -0.06020736f, -0.06602915f, -0.01495452f, 
    0.01449557f, 0.04137681f, -0.02674265f, 0.02356992f, -0.05870275f, 0.01374022f, -0.06207255f, -0.06623061f, 
    -0.04476474f, 0.03237034f, -0.06589425f, -0.02590041f, -0.07034028f, 0.06617954f, 0.00818168f, -0.05203741f, 
    0.00826680f, 0.02017162f, -0.01545702f, -0.01326614f, -0.05844429f, -0.03067286f, -0.00695777f, -0.01382740f, 
    0.05823851f, -0.02755558f, -0.02724092f, 0.04426328f, -0.04795444f, -0.06404749f, 0.02575145f, -0.03982472f, 
    0.05415900f, 0.02025049f, 0.04949810f, -0.03765398f, -0.06094848f, -0.02140003f, -0.05902014f, -0.01447301f, 
    0.04204588f, 0.07211540f, 0.00135049f, 0.01464034f, -0.05632690f, -0.04115904f, -0.06127713f, -0.05655675f, 
    0.02945115f, 0.03643285f, 0.07102786f, 0.05024683f, -0.06009019f, -0.06982253f, -0.06815629f, -0.01251356f, 
    0.04569315f, 0.03334408f, 0.02547982f, -0.07173375f, 0.00041005f, -0.03800375f, 0.02565090f, 0.06133374f, 
    -0.06765328f, -0.00412161f, 0.02474725f, -0.05466409f, -0.04028527f, 0.05953883f, 0.03750216f, -0.00834671f, 
    -0.04371691f, -0.02791522f, -0.02294816f, -0.02850545f, -0.06042367f, -0.07114363f, 0.02993902f, -0.02148175f, 
    -0.03095919f, 0.02977580f, -0.02024051f, 0.02638515f, -0.04900428f, -0.03287531f, -0.00016749f, 0.03654424f, 
    0.04024655f, 0.00835256f, -0.04229914f, -0.04938675f, 0.02465112f, 0.00494130f, 0.01287124f, 0.00631244f, 
    0.01036697f, -0.06488568f, 0.03707956f, -0.06163073f, -0.02073469f, 0.02734563f, -0.02008785f, 0.06768075f, 
    0.03233163f, 0.04956845f, 0.00334796f, -0.02189138f, 0.00515668f, -0.06834327f, 0.01043199f, 0.00790424f, 
    -0.03733470f, 0.00403853f, -0.04848538f, 0.03965710f, 0.02707737f, 0.06710643f, -0.00106050f, 0.05655060f, 
    0.05493331f, -0.04517530f, 0.05294366f, -0.06678271f, -0.02704792f, -0.04873907f, -0.05865257f, -0.05013306f, 
    0.06757305f, -0.00806919f, -0.04609000f, 0.00649772f, -0.05922956f, 0.00675989f, -0.04182276f, -0.04668219f, 
    -0.10284388f, 0.25134176f, -0.18216011f, 0.28509617f, 0.13674888f, -0.08428099f, 0.10724451f, -0.18595760f, 
    0.06544039f, 0.02625058f, 0.24961968f, 0.02731660f, -0.06042947f, -0.01679287f, -0.40937591f, 0.06211804f, 
    0.02595093f, -0.25612712f, -0.07925513f, -0.08516169f, 0.12401824f, 0.09969503f, 0.06517982f, 0.06559931f, 
    -0.14205451f, -0.01923392f, -0.04555957f, 0.23322968f, -0.08897542f, -0.14838952f, 0.23443866f, -0.06214262f, 
    -0.15021153f, 0.07120577f, 0.00250808f, 0.10159857f, -0.29458940f, 0.24726276f, -0.09123603f, -0.24292527f, 
    0.03057149f, -0.04389023f, -0.09218926f, 0.02822319f, 0.15880352f, 0.06210016f, -0.02874745f, 0.09968676f, 
    -0.30542502f, -0.09928495f, -0.07200284f, 0.00627075f, 0.18577845f, 0.13494672f, 0.09123356f, 0.22070946f, 
    -0.00053503f, 0.04387259f, 0.22910024f, -0.19238301f, -0.16955733f, -0.03923963f, -0.02839636f, 0.15487698f, 
    0.09774921f, -0.01203312f, 0.01132614f, 0.04438278f, 0.08703215f, -0.05259827f, -0.07900757f, -0.29905435f, 
    0.16943830f, -0.00350011f, -0.00910980f, -0.23067886f, 0.03783026f, -0.03412826f, 0.04436494f, 0.20282196f, 
    0.19044296f, 0.01238656f, -0.17241625f, 0.27307054f, 0.12058073f, 0.13708691f, -0.02632016f, -0.33991101f, 
    0.19579223f, -0.07526610f, -0.01722783f, 0.13705648f, 0.14336072f, 0.08389460f, 0.13458723f, 0.09675565f, 
    -0.21952887f, 0.06163470f, -0.13064694f, 0.37624356f, -0.02128913f, -0.07310724f, 0.33818188f, 0.01319898f, 
    0.01958367f, -0.11972233f, 0.16255184f, 0.10562421f, -0.30847448f, 0.19600059f, 0.14564382f, -0.05471602f, 
    0.00185397f, -0.06400798f, 0.06587762f, 0.06390259f, 0.05965281f, 0.05498588f, 0.14269811f, -0.03526068f, 
    0.12379618f, 0.04899346f, 0.23078351f, 0.15237045f, 0.13110627f, 0.13823549f, 0.19998774f, 0.00204068f, 
    0.12403568f, -0.14492621f, -0.02073638f, -0.06260671f, 0.00175721f, -0.26960707f, 0.19148475f, 0.00490603f, 
    0.06837846f, 0.18292752f, 0.08206984f, -0.14324248f, 0.22146922f, -0.08724895f, 0.05189126f, -0.03292586f, 
    -0.16691613f, 0.00798288f, -0.07303394f, -0.04025782f, 0.05851025f, 0.15621966f, -0.09034515f, 0.16112050f, 
    -0.11149669f, 0.08389186f, 0.06773934f, 0.01010589f, 0.12924293f, 0.05127673f, -0.13645217f, 0.08741786f, 
    -0.14019132f, -0.11065003f, 0.03721607f, -0.05663411f, 0.00933633f, -0.06300110f, 0.10339472f, -0.12319237f, 
    -0.38821900f, -0.02194173f, -0.02058385f, -0.07340729f, 0.03891382f, -0.02811207f, 0.31916973f, 0.20599714f, 
    0.10655174f, 0.01933483f, 0.10947001f, -0.06503519f, 0.08819713f, 0.30551633f, 0.07001806f, -0.24727452f, 
    0.15670969f, -0.01045534f, -0.14212842f, 0.08778770f, -0.04622304f, 0.11344337f, -0.24844955f, -0.05448757f, 
    -0.03565367f, 0.00621405f, -0.04448016f, 0.03987202f, -0.04259326f, 0.03346748f, 0.05777356f, -0.06495565f, 
    0.05472587f, -0.06642244f, -0.02988802f, -0.07755926f, 0.04628047f, 0.03349782f, -0.03946459f, -0.02580315f, 
    -0.02966727f, 0.05165293f, -0.07792381f, -0.06717022f, -0.06753185f, -0.05012330f, 0.02093202f, -0.07798913f, 
    -0.00790603f, -0.04906689f, -0.01971839f, -0.02122989f, 0.01129581f, 0.04932772f, -0.03914168f, 0.00627460f, 
    0.02329317f, 0.01206817f, -0.04306860f, 0.01684902f, -0.04812208f, 0.00954028f, 0.01422967f, -0.05653256f, 
    0.04381641f, -0.01256980f, 0.05201792f, 0.02895488f, -0.03241744f, -0.01332398f, 0.04096570f, -0.04624574f, 
    -0.05173020f, 0.00409554f, 0.00237789f, 0.03508683f, -0.03455183f, 0.01617558f, -0.03215633f, 0.03368076f, 
    -0.00735352f, -0.01436925f, -0.01547523f, -0.01701309f, -0.03541055f, 0.05100432f, -0.01810906f, -0.07731634f, 
    -0.04987635f, -0.01163927f, -0.03537490f, 0.01738731f, 0.06174760f, 0.05511831f, 0.02941328f, 0.05252639f, 
    0.06101559f, 0.05522379f, 0.05418902f, -0.00872405f, -0.04705224f, 0.06068154f, 0.03700460f, -0.07288071f, 
    -0.01410644f, -0.00227929f, 0.03273144f, 0.05361210f, -0.01352279f, -0.02011605f, 0.03697986f, 0.00113385f, 
    -0.04397833f, 0.00125626f, -0.03445471f, 0.04634184f, 0.03773097f, -0.03159074f, 0.01792177f, -0.02852178f, 
    -0.07510462f, 0.00328823f, 0.04778305f, 0.06029744f, -0.07792412f, -0.07939029f, 0.06254037f, 0.01117681f, 
    -0.07789636f, -0.07210135f, 0.02395653f, -0.07466117f, -0.02199676f, -0.03560296f, -0.02376512f, 0.03168217f, 
    -0.00662765f, 0.04077867f, -0.02645246f, -0.05249440f, 0.04964842f, 0.03722936f, 0.00634462f, -0.05952572f, 
    0.04698742f, -0.01893942f, -0.07812013f, -0.06197253f, -0.01297583f, -0.00284204f, -0.00738826f, -0.06477015f, 
    0.00724687f, -0.02598528f, -0.02105782f, -0.06351015f, 0.05673347f, -0.02032251f, 0.00101593f, -0.04833014f, 
    0.03980529f, 0.05574671f, 0.04840294f, -0.07702100f, -0.01100712f, -0.02237726f, 0.00936428f, -0.03178140f, 
    -0.01066456f, -0.05518952f, 0.05538107f, 0.00220085f, 0.06517699f, -0.02863354f, 0.00792320f, 0.01393548f, 
    0.03904098f, -0.02930389f, 0.00575045f, -0.04646611f, -0.01316463f, -0.06908574f, -0.04796109f, 0.00681932f, 
    -0.04052695f, 0.01720538f, 0.03224456f, -0.02840274f, -0.07435358f, -0.05993586f, 0.02117835f, 0.03629670f, 
    -0.04673206f, -0.05602785f, -0.05710337f, 0.00869070f, -0.04932641f, 0.04663744f, 0.06030225f, -0.04444828f, 
    -0.04883144f, -0.00508859f, -0.07066681f, 0.05107812f, 0.02263108f, -0.03738767f, -0.07893284f, -0.07662013f, 
    -0.04647042f, -0.05546780f, -0.01420906f, -0.03150873f, 0.04055864f, -0.06320724f, -0.03155414f, -0.04311816f, 
    -0.01316206f, -0.03762982f, 0.06180021f, -0.03610966f, -0.06193780f, 0.03469979f, 0.03324308f, -0.00329170f, 
    -0.00648269f, -0.02299002f, -0.03679944f, -0.01538631f, -0.04250003f, 0.01655990f, -0.00236653f, -0.01038586f, 
    -0.05083599f, 0.03341269f, -0.04457109f, -0.04814605f, -0.04725225f, 0.03440768f, -0.06489474f, -0.07404695f, 
    -0.02809262f, -0.07047161f, 0.03323666f, -0.06700288f, -0.04738213f, -0.01169848f, -0.07799541f, 0.03393941f, 
    -0.02458562f, 0.01993609f, 0.04628082f, -0.07437717f, -0.01676810f, -0.03838700f, -0.07278481f, -0.04275763f, 
    -0.01152292f, -0.03317146f, -0.07232671f, -0.02596860f, -0.03695753f, 0.01833005f, 0.04871851f, -0.03161418f, 
    -0.00863249f, -0.05413849f, -0.07667128f, 0.04689641f, 0.04449228f, -0.02664828f, -0.04477593f, 0.06156875f, 
    -0.01273936f, -0.03184701f, 0.05503902f, 0.03729340f, 0.06151139f, 0.04811859f, 0.05211936f, 0.06187944f, 
    -0.04246438f, -0.07641678f, -0.05088472f, 0.01663142f, 0.00193209f, 0.05809106f, 0.00042011f, 0.02873974f, 
    -0.04378605f, -0.01597715f, -0.06753093f, 0.02795636f, -0.06825399f, -0.01609928f, -0.02599179f, -0.05387796f, 
    0.03976301f, -0.05593948f, 0.00313031f, 0.06116339f, -0.00028976f, -0.02288910f, -0.01165403f, -0.02070106f, 
    -0.01753241f, -0.06496132f, 0.05120176f, -0.03974168f, -0.01425358f, 0.06137822f, -0.05625443f, -0.06237502f, 
    -0.04301078f, -0.00084764f, -0.06987026f, -0.06203157f, 0.00641189f, -0.01376725f, -0.04173891f, -0.05532702f, 
    0.03272878f, -0.00183556f, -0.03021746f, -0.01704053f, 0.05898501f, 0.00408469f, -0.04796010f, 0.06074269f, 
    -0.07009681f, -0.02521528f, 0.01967600f, 0.01997038f, -0.00104776f, -0.06511303f, -0.06447230f, -0.07139487f, 
    -0.00708936f, -0.04906168f, -0.00779061f, -0.00674586f, 0.02735717f, 0.04028888f, -0.05510207f, 0.04140301f, 
    0.05795640f, -0.05100252f, 0.05621850f, 0.02935635f, -0.04970613f, 0.04094013f, -0.01014671f, -0.04601904f, 
    -0.05377926f, -0.00074649f, 0.00186177f, -0.01770390f, -0.06571971f, -0.00537119f, -0.00011305f, 0.06401161f, 
    0.01455808f, 0.06135081f, -0.06864677f, -0.03886138f, -0.05704165f, 0.00185928f, 0.04312431f, 0.03032336f, 
    0.03430087f, -0.04829578f, -0.05504815f, -0.00439820f, 0.02262867f, -0.02443878f, -0.00454286f, -0.03822340f, 
    0.01546811f, 0.03926435f, -0.03006891f, 0.01756248f, -0.02010393f, 0.02966424f, -0.01094617f, 0.00653696f, 
    -0.05372983f, -0.05804227f, 0.00943226f, -0.01778903f, -0.03757725f, -0.07698723f, -0.00644833f, -0.05762859f, 
    0.05984628f, -0.04172247f, -0.02869727f, 0.04894700f, -0.02701177f, 0.03613129f, 0.05569007f, 0.00539220f, 
    -0.03201102f, 0.03823860f, 0.05951983f, -0.06570852f, 0.02403560f, 0.03655379f, -0.06941087f, -0.05098058f, 
    0.45377377f, 0.00166018f, 0.01170913f, 0.06599952f, 0.02874071f, -0.11042926f, 0.10172510f, -0.06935444f, 
    -0.20136163f, 0.15204783f, -0.02297132f, -0.04134166f, 0.13620259f, 0.07921715f, -0.04742145f, 0.25131154f, 
    -0.02065302f, -0.09345707f, 0.05146199f, 0.15409639f, -0.01513615f, 0.20987503f, 0.11705632f, 0.13367566f, 
    -0.02685793f, -0.31460255f, 0.17323028f, -0.04685066f, 0.28089374f, 0.01987448f, 0.11717670f, 0.02795008f, 
    -0.07504267f, 0.12779851f, 0.19068310f, 0.27590039f, -0.34313917f, 0.27404794f, -0.18460630f, -0.20598863f, 
    -0.15366609f, 0.04093551f, -0.09568058f, 0.00030053f, -0.02843630f, -0.02562826f, 0.02929105f, 0.13676384f, 
    0.46222979f, -0.03808724f, 0.03216643f, -0.04678980f, -0.15148464f, -0.02986048f, -0.03334991f, -0.03610748f, 
    -0.01011890f, 0.01849134f, -0.01102528f, -0.10402249f, 0.03482742f, -0.13174118f, -0.20117430f, 0.08346888f, 
    -0.01632222f, -0.03783255f, 0.17140624f, 0.15281804f, -0.10923326f, -0.03733869f, -0.15140761f, -0.18294628f, 
    0.24950877f, 0.08940214f, -0.06155711f, 0.20151672f, -0.07510599f, -0.04996020f, 0.09654228f, 0.10214167f, 
    -0.00352708f, 0.01157438f, -0.07839814f, 0.02281448f, 0.15763272f, 0.11729410f, 0.07245812f, 0.12767732f, 
    -0.04830162f, 0.03350700f, -0.01372179f, 0.06689829f, -0.02001604f, 0.01657670f, -0.01536636f, 0.07229316f, 
    -0.16698419f, 0.02912472f, 0.04187410f, 0.01084807f, 0.00868771f, 0.00062287f, 0.09261131f, -0.13016909f, 
    0.03977944f, -0.00141270f, 0.12507382f, 0.12503153f, 0.38276923f, -0.09747970f, 0.20643218f, 0.03945056f, 
    -0.11358413f, -0.07178685f, 0.22204275f, 0.12312669f, 0.07862548f, 0.12329020f, 0.15299681f, -0.03754522f, 
    0.17814627f, -0.21328668f, 0.00781596f, -0.18908282f, -0.03270596f, -0.09116748f, 0.13028511f, -0.07911658f, 
    -0.07517569f, -0.15159108f, -0.05931464f, -0.02295949f, -0.24030894f, -0.09707885f, 0.02890266f, -0.01012677f, 
    -0.02012051f, 0.02405139f, -0.01200787f, 0.09049357f, 0.05174433f, 0.08685341f, -0.01897592f, -0.05654507f, 
    -0.41673055f, 0.03838347f, -0.11351748f, -0.06623897f, 0.26444331f, -0.11469150f, -0.12681691f, 0.01675122f, 
    0.03243423f, -0.07311607f, 0.04960699f, -0.01434853f, -0.20511816f, 0.15331043f, 0.16130605f, 0.17169535f, 
    -0.00466620f, -0.11465836f, -0.13200608f, 0.00651599f, -0.03898228f, -0.08324322f, -0.08421952f, -0.08973648f, 
    -0.06572860f, 0.06398699f, -0.05694320f, -0.12501726f, 0.15135026f, 0.06208591f, 0.14189634f, -0.08705521f, 
    0.09229023f, 0.08748764f, 0.14490008f, -0.00023571f, -0.19612628f, 0.35113594f, 0.31467277f, 0.07003393f, 
    -0.00045188f, -0.06963491f, -0.08007897f, 0.18760252f, 0.06926326f, -0.04060661f, 0.01525319f, -0.04345680f, 
    -0.27584702f, -0.46652395f, 0.41171211f, -0.10072897f, 0.05828871f, 0.12231086f, 0.08478133f, 0.19524376f, 
    0.09757691f, -0.06418914f, -0.08590917f, 0.12619990f, 0.05959217f, -0.08844613f, 0.22715478f, -0.14456595f, 
    -0.07521232f, -0.10532563f, -0.02420482f, 0.04645663f, -0.13325125f, -0.11861253f, -0.05391097f, 0.03374485f, 
    0.17984799f, 0.10850785f, 0.10025880f, -0.26457754f, -0.18761125f, 0.00115919f, 0.02358762f, 0.21621084f, 
    0.06319914f, 0.01027628f, -0.01542576f, -0.06977928f, 0.59733027f, 0.08004329f, -0.07257370f, 0.46808809f, 
    0.06064117f, 0.05669910f, -0.02722032f, 0.08167451f, 0.03523274f, 0.08585627f, 0.00371247f, -0.02024823f, 
    -0.02860467f, -0.11179940f, -0.14847636f, -0.16077369f, -0.09410022f, 0.03920300f, 0.10592039f, 0.10435732f, 
    0.04724286f, -0.00668054f, 0.23831485f, 0.26024568f, 0.19778080f, -0.34627959f, 0.05898285f, -0.05381236f, 
    -0.09874294f, -0.03991093f, -0.10186794f, -0.00676719f, 0.00793201f, -0.03816902f, 0.09491479f, 0.12128300f, 
    -0.04087606f, 0.04284395f, -0.29056770f, 0.13674870f, 0.06621560f, 0.01796672f, 0.11621397f, -0.10688303f, 
    -0.06480118f, 0.08390701f, 0.09290682f, -0.04459572f, -0.22874813f, -0.08631641f, -0.23824252f, -0.25534075f, 
    0.12644440f, 0.18638308f, 0.04334896f, -0.06748857f, 0.03424476f, -0.06046785f, 0.11196966f, 0.03943265f, 
    0.44640666f, -0.19250922f, -0.13413832f, -0.21442242f, -0.00211514f, 0.02915459f, -0.06234136f, 0.12157920f, 
    0.01155419f, 0.03691430f, -0.09640032f, 0.00279890f, -0.12324168f, -0.40951249f, -0.16981134f, 0.00499241f, 
    0.13041335f, 0.02355767f, 0.13259888f, -0.00386305f, 0.10296217f, -0.16806346f, -0.02689948f, -0.01501260f, 
    -0.14507549f, -0.06558575f, 0.10509445f, -0.08173664f, 0.21842775f, 0.10677702f, 0.05987872f, 0.02519041f, 
    -0.05940066f, -0.00921789f, 0.09741786f, 0.16829169f, 0.35099816f, 0.13556431f, -0.18587908f, -0.01608551f, 
    -0.06657780f, -0.12738442f, 0.18127692f, 0.11524457f, 0.06884931f, -0.00908981f, -0.05395190f, 0.19250682f, 
    0.33268672f, -0.20255122f, 0.06583393f, -0.19214706f, -0.12966965f, -0.11745664f, -0.01989502f, -0.06745964f, 
    0.24106313f, -0.00346891f, 0.09052510f, 0.04337832f, 0.13264498f, 0.15641801f, -0.14427119f, -0.08945370f, 
    0.17978799f, 0.15355571f, 0.16019359f, 0.01217212f, 0.17172605f, 0.02697537f, 0.04680999f, -0.03469042f, 
    0.37939435f, 0.33415484f, -0.11526114f, 0.10145104f, 0.04191524f, 0.25948307f, -0.05680790f, -0.01387220f, 
    0.03810323f, 0.01564847f, -0.00202850f, 0.01947206f, -0.38989952f, 0.01625335f, -0.30082089f, -0.17974657f, 
    0.01292505f, 0.07292277f, 0.06428476f, 0.05079369f, -0.01917954f, 0.00046656f, -0.07697468f, 0.04589004f, 
    -0.03814675f, -0.04726810f, 0.06075171f, -0.06328136f, -0.06380025f, -0.04612486f, -0.01382760f, 0.03954704f, 
    0.03047045f, -0.04451415f, -0.04994654f, -0.00901400f, -0.03231384f, 0.01127290f, -0.01076366f, -0.01076879f, 
    0.07085201f, 0.04155635f, -0.02817087f, -0.00124686f, -0.02378390f, -0.03218994f, -0.06934121f, -0.05868095f, 
    -0.04691964f, -0.06482556f, -0.03508658f, 0.00095772f, -0.00689014f, -0.04969938f, -0.01393568f, 0.01552917f, 
    0.01837381f, -0.00364433f, 0.05956620f, -0.06161760f, -0.00179802f, 0.06946030f, 0.02868726f, 0.00102635f, 
    0.05005835f, -0.04648253f, 0.06650778f, -0.07130679f, -0.01992750f, 0.05653092f, -0.05336003f, -0.02065018f, 
    -0.07016927f, -0.05967471f, -0.06590785f, 0.01236436f, 0.05467922f, 0.06852093f, 0.04517359f, -0.04418135f, 
    0.04672253f, -0.01385923f, -0.05293485f, -0.06894898f, -0.04450978f, 0.01344375f, 0.04403609f, -0.04812418f, 
    -0.01984020f, 0.01472624f, -0.04444136f, 0.00091463f, -0.06214797f, -0.05550975f, 0.06427488f, 0.04208910f, 
    -0.01177825f, -0.05296485f, 0.01753015f, -0.05676877f, -0.05143464f, -0.04834750f, -0.01937906f, -0.06170170f, 
    0.01451867f, -0.04265594f, 0.07211719f, 0.03921776f, 0.07159567f, -0.04599680f, -0.05463518f, -0.02874672f, 
    -0.00846118f, 0.05628705f, -0.05208582f, -0.03581101f, 0.07153945f, -0.06766579f, -0.02152426f, -0.06149230f, 
    -0.07209964f, 0.06887602f, -0.03452677f, -0.06250915f, -0.01854282f, 0.03720255f, 0.04078498f, -0.00772575f, 
    -0.05789387f, 0.02798658f, 0.04241055f, -0.05031770f, 0.02080452f, 0.05227135f, 0.07203522f, -0.00050783f, 
    -0.06263331f, -0.05800982f, 0.02947277f, -0.04242758f, -0.03401027f, 0.05342812f, -0.01706265f, 0.00273103f, 
    -0.03170103f, -0.04229188f, -0.03236515f, -0.03788135f, 0.07153056f, 0.01671567f, -0.01679666f, -0.06130000f, 
    -0.02557341f, 0.06059038f, -0.05278530f, -0.03107392f, 0.03712760f, 0.00706814f, -0.06345233f, -0.03179576f, 
    0.03826968f, 0.06716238f, 0.04130263f, 0.00359792f, -0.00961493f, 0.02210033f, 0.02908703f, -0.07103954f, 
    -0.00267459f, 0.03021270f, 0.01194179f, 0.00446030f, 0.03091741f, 0.06647792f, 0.03584886f, -0.06398121f, 
    -0.06665214f, -0.04002967f, 0.05360148f, -0.03352019f, -0.01475662f, 0.00975719f, -0.06348300f, 0.00114359f, 
    -0.06374981f, -0.01037799f, -0.05314271f, -0.06982579f, -0.03023735f, 0.00334749f, -0.03266980f, -0.06401909f, 
    0.02557936f, 0.00586626f, 0.05691842f, -0.00163530f, 0.04455364f, -0.05439514f, -0.05832927f, -0.02336933f, 
    -0.04390971f, -0.01502959f, 0.00016614f, -0.03506883f, -0.06602501f, -0.02369306f, 0.06859732f, -0.00389784f, 
    -0.01467896f, 0.02804436f, 0.01425279f, -0.05951453f, -0.04143440f, 0.02219518f, 0.06122553f, -0.00106681f, 
    0.04703548f, -0.00485458f, -0.02358896f, -0.07794688f, -0.07474329f, -0.05520803f, 0.03181460f, -0.05742713f, 
    0.03066081f, 0.02591244f, 0.05899376f, -0.07061443f, -0.03143448f, -0.04753321f, -0.03117258f, -0.01970736f, 
    0.03985544f, 0.03007505f, -0.02322128f, -0.02266445f, -0.04027691f, 0.02006273f, -0.02291526f, 0.05851090f, 
    -0.05046662f, 0.01077951f, -0.02814416f, -0.03731763f, -0.03394577f, 0.03667762f, -0.05916842f, -0.07553039f, 
    0.06655817f, 0.02122940f, -0.04850693f, 0.00245999f, -0.04686257f, 0.01707017f, -0.01846583f, -0.04467536f, 
    -0.06893537f, 0.01079873f, 0.01887237f, -0.01118775f, 0.01450533f, -0.01341249f, 0.04356842f, 0.05228665f, 
    -0.00399993f, -0.03001237f, -0.05815518f, 0.03823709f, 0.02477613f, 0.06087475f, -0.00938698f, -0.05243193f, 
    -0.01226089f, -0.03176630f, 0.04233233f, -0.05547956f, 0.01760841f, 0.03767396f, -0.04313728f, -0.04687030f, 
    -0.05548309f, -0.04082862f, -0.01737846f, 0.04127714f, 0.02405842f, 0.00273646f, -0.06973831f, 0.01963410f, 
    -0.04413678f, -0.01678723f, 0.01607691f, -0.00769622f, -0.00487063f, 0.04196515f, 0.00024390f, -0.00933283f, 
    -0.04980393f, 0.03134473f, 0.00640911f, -0.05877694f, 0.02541862f, -0.03841178f, -0.06000872f, -0.06726576f, 
    0.05787330f, -0.02536913f, -0.03622115f, -0.04292750f, 0.05175184f, -0.00694740f, -0.00812301f, -0.05862670f, 
    0.03485392f, 0.00791189f, 0.00636680f, -0.01826631f, -0.05618750f, -0.02781772f, 0.05344384f, 0.00316300f, 
    0.04110816f, -0.07434992f, -0.04845792f, 0.04076153f, -0.05154574f, 0.04561570f, -0.02485313f, 0.02026686f, 
    0.01759490f, 0.01526162f, 0.00491185f, 0.01597767f, 0.02556984f, 0.06208112f, -0.05577138f, 0.04864754f, 
    -0.07589035f, 0.01431842f, -0.06648719f, 0.01326138f, -0.03417853f, -0.04011539f, 0.05551384f, -0.04494892f, 
    -0.04044116f, -0.03316236f, -0.01885760f, -0.02990854f, -0.05589318f, -0.03437214f, 0.05277994f, -0.04212635f, 
    0.04204996f, 0.03368095f, -0.07282141f, 0.03925104f, -0.02782845f, 0.05998255f, -0.03805241f, 0.00588916f, 
    0.06070081f, 0.00563039f, -0.06719664f, -0.06340628f, -0.01504563f, -0.06189802f, -0.00080459f, 0.01195239f, 
    0.04183057f, -0.03738847f, -0.07231948f, 0.02847669f, 0.05505617f, -0.00020630f, 0.04900269f, -0.01129493f, 
    0.00707821f, -0.01096305f, 0.03743069f, -0.06075863f, 0.05366754f, 0.05223245f, 0.05529600f, 0.02105718f, 
    0.05655960f, 0.00220357f, -0.01864419f, -0.02108224f, -0.05877037f, 0.05243047f, 0.04722259f, 0.04208050f, 
    0.00959439f, -0.03640179f, 0.00276311f, 0.04607851f, -0.07231362f, -0.06078816f, -0.03610080f, 0.01838064f, 
    -0.00381084f, -0.04166036f, -0.04264263f, 0.01447105f, 0.02468616f, 0.02357144f, 0.04872649f, -0.08355729f, 
    0.12904823f, 0.74906051f, -0.02581205f, 0.27178586f, -0.01149855f, -0.02950324f, -0.08004410f, -0.00646622f, 
    0.14940313f, 0.07776099f, 0.06013007f, 0.05645613f, 0.03462153f, -0.03604355f, -0.20281295f, 0.01225263f, 
    -0.08009649f, 0.06290869f, 0.14800933f, -0.03652915f, 0.05566728f, -0.01464353f, 0.07215530f, -0.04423367f, 
    -0.19310710f, 0.17049176f, -0.16606726f, 0.17483129f, -0.12656955f, -0.10647906f, 0.17031673f, -0.04368971f, 
    -0.18489823f, 0.04296674f, -0.05679953f, 0.21580938f, -0.32585269f, 0.15028878f, 0.12305867f, -0.04913174f, 
    0.16870655f, -0.00546254f, 0.02146044f, 0.00022673f, -0.06186418f, 0.02800339f, 0.07978387f, 0.08234733f, 
    -0.34625053f, 0.10324623f, -0.01603242f, -0.05886118f, 0.25207338f, 0.11713105f, -0.01619743f, 0.04059161f, 
    0.02183049f, -0.01465679f, -0.00011745f, -0.15787007f, -0.40976831f, 0.06560085f, -0.00036870f, 0.04251994f, 
    0.09659416f, -0.03524190f, -0.03880371f, -0.00374341f, 0.08764488f, -0.05153619f, -0.05501686f, -0.07976745f, 
    0.12808414f, 0.00813948f, -0.12390222f, -0.06737085f, 0.20279804f, 0.04127576f, 0.15478665f, 0.07780442f, 
    0.11906139f, -0.06653713f, -0.22454055f, 0.19717483f, 0.27474743f, -0.04470402f, -0.07981858f, 0.01906762f, 
    0.09444913f, -0.12980494f, -0.03785325f, 0.02125101f, 0.04554014f, 0.15269245f, -0.10141703f, -0.02122092f, 
    -0.35262027f, 0.32401049f, -0.04282633f, 0.10270356f, -0.09948995f, 0.06914359f, 0.18159017f, -0.02103222f, 
    -0.11925995f, -0.01727907f, -0.01860147f, -0.05968293f, 0.26979122f, 0.09934045f, -0.07491829f, -0.06708978f, 
    0.04430847f, -0.04622139f, -0.06316182f, 0.08149088f, 0.08495464f, 0.15321462f, 0.14363404f, -0.08765517f, 
    0.31600505f, -0.01197358f, -0.03103737f, -0.00500911f, -0.04548054f, 0.13447894f, 0.00157462f, -0.05843636f, 
    0.16789201f, -0.08362967f, -0.04882353f, -0.07727727f, 0.01882391f, -0.14178389f, 0.28135106f, -0.06057511f, 
    0.00381559f, 0.04171668f, 0.11624321f, -0.29751885f, 0.14503157f, -0.00456598f, 0.14074457f, -0.00729051f, 
    -0.29880032f, 0.06830862f, 0.00379050f, -0.03032945f, 0.17815749f, 0.07762682f, 0.10549507f, 0.10534231f, 
    -0.05972497f, 0.02188951f, 0.05829124f, -0.11245639f, -0.22490913f, -0.06194840f, 0.14844066f, 0.25219217f, 
    -0.05016086f, -0.20984124f, 0.00219045f, 0.06305372f, -0.05122865f, -0.05265508f, 0.05735850f, 0.02844084f, 
    -0.49849838f, 0.36206514f, -0.00374748f, -0.10186210f, 0.09504569f, -0.02246636f, 0.10594504f, -0.12181396f, 
    0.02029323f, 0.06353454f, 0.09352737f, -0.12543873f, 0.21391493f, -0.11332654f, 0.00597176f, 0.04828379f, 
    0.13680319f, -0.08708018f, -0.00534024f, 0.07416048f, -0.05878866f, -0.01782044f, -0.08715813f, 0.03748033f, 
    0.03261059f, -0.06514350f, 0.02732721f, -0.05501158f, 0.00304487f, -0.04492786f, 0.04175292f, -0.02968426f, 
    0.05236930f, -0.07686034f, -0.06251015f, -0.03675541f, 0.06079503f, -0.06356033f, -0.03588655f, -0.06816407f, 
    -0.05014841f, -0.04717140f, 0.04951501f, -0.05814287f, -0.06381264f, -0.03115858f, -0.04735629f, -0.04464998f, 
    -0.05677901f, -0.07565308f, 0.06098262f, 0.06158825f, 0.00225061f, -0.04339885f, -0.05208344f, -0.05180212f, 
    -0.00341449f, 0.01541846f, 0.01016883f, 0.06193935f, -0.03418260f, 0.03009671f, -0.03760105f, 0.05905168f, 
    0.04892034f, -0.01055068f, -0.03278822f, -0.06810416f, -0.05895858f, -0.03571317f, -0.05904641f, -0.04925870f, 
    0.06414465f, -0.04485276f, -0.00822387f, -0.04840267f, 0.03836346f, -0.05865813f, -0.00760154f, -0.05366740f, 
    0.02701161f, 0.03255523f, 0.05597676f, -0.02617759f, -0.03189321f, 0.01491451f, -0.02235476f, -0.06787018f, 
    -0.05218126f, -0.01194267f, 0.01544043f, -0.02214711f, -0.02349140f, -0.04858107f, -0.00311431f, 0.06521480f, 
    0.01420678f, 0.01449339f, -0.06587209f, 0.02269140f, 0.02017359f, 0.06460157f, 0.04471789f, -0.06504766f, 
    -0.00685853f, -0.06806597f, -0.02631728f, 0.03718507f, 0.00260794f, -0.07674793f, 0.03199592f, 0.02922739f, 
    0.00096442f, -0.05612041f, -0.07335067f, 0.03743012f, -0.06876597f, -0.04197643f, -0.05862829f, 0.03128541f, 
    0.04553216f, -0.05155953f, -0.07717970f, 0.03050736f, -0.01782242f, 0.04003534f, 0.02753726f, 0.03566119f, 
    -0.00593760f, -0.05645065f, -0.01558416f, 0.01090410f, -0.00975433f, 0.05777127f, -0.04423725f, 0.00061277f, 
    -0.07286178f, 0.03906627f, 0.05544613f, -0.03176959f, -0.00051150f, 0.05917906f, 0.00308767f, -0.01820394f, 
    -0.05109781f, -0.07545446f, 0.03088535f, 0.01457047f, -0.01889293f, -0.03723921f, -0.03222711f, 0.06082907f, 
    0.01537336f, -0.04622159f, -0.07085694f, 0.00368071f, 0.00732762f, -0.05294532f, -0.06254318f, -0.03073809f, 
    -0.07180550f, -0.04330721f, -0.01604520f, 0.06232206f, -0.07466338f, 0.02297335f, 0.04575446f, -0.00124903f, 
    0.00543384f, -0.03829433f, -0.04968609f, 0.04498304f, -0.05771979f, -0.00058946f, 0.05868711f, -0.06078012f, 
    -0.07141547f, -0.04757670f, -0.00777202f, -0.01523297f, -0.03347011f, 0.02816990f, 0.04825578f, -0.07274709f, 
    0.01316626f, -0.02288261f, -0.00896575f, -0.07711244f, 0.05350569f, -0.00842688f, 0.03868948f, 0.04467019f, 
    0.05680356f, -0.04583254f, 0.00048240f, 0.02025706f, -0.06363598f, -0.02291046f, 0.03286838f, 0.01803591f, 
    -0.01260960f, 0.02173086f, 0.05463871f, 0.01260644f, 0.01815134f, 0.05479051f, -0.04132297f, 0.02789315f, 
    0.00110391f, -0.06211476f, 0.05073797f, 0.05987883f, -0.05452455f, -0.02266260f, 0.02642248f, 0.04473668f, 
    0.04748261f, 0.07191147f, -0.00378800f, 0.01222736f, 0.01555579f, -0.04732892f, -0.03494972f, 0.04432993f, 
    0.03780005f, -0.03498599f, 0.03938884f, -0.02240371f, 0.01808450f, 0.01199824f, -0.03882575f, -0.03937431f, 
    -0.04662284f, 0.03899456f, 0.06443308f, -0.06120892f, 0.00232796f, 0.02119421f, -0.06563238f, 0.00633524f, 
    -0.06810822f, -0.04618781f, -0.02497631f, 0.00749566f, -0.05633960f, -0.06312604f, -0.02823261f, -0.06054438f, 
    -0.06864449f, -0.02909554f, -0.04584634f, -0.00451032f, -0.00962201f, -0.00998871f, 0.01145216f, 0.00429579f, 
    0.02846142f, -0.06938231f, -0.03848409f, -0.02677081f, -0.03709850f, 0.03571785f, -0.06537084f, -0.00588663f, 
    0.04045708f, -0.05433114f, -0.01505504f, 0.03731643f, -0.01604157f, -0.05327247f, -0.06868061f, -0.04709079f, 
    0.04460249f, -0.00262119f, -0.01535923f, 0.02595226f, -0.04655940f, 0.05590803f, -0.03041135f, -0.00832819f, 
    0.05050341f, 0.03521648f, 0.01096243f, -0.05603848f, 0.05122777f, 0.02462862f, -0.01974707f, -0.03253896f, 
    -0.01061148f, -0.00495819f, -0.06356602f, -0.01505882f, 0.04996915f, -0.03067994f, 0.01334366f, -0.02218153f, 
    0.06172454f, 0.03382223f, -0.06854599f, 0.06481254f, -0.03120231f, -0.04821514f, -0.03348557f, -0.05257535f, 
    0.04757848f, -0.04395808f, -0.01819989f, -0.00159745f, -0.05343768f, -0.04644249f, -0.04065972f, 0.06081770f, 
    0.03207907f, 0.04453835f, 0.01749367f, 0.01770727f, 0.01929904f, 0.04565127f, -0.00972982f, -0.01510534f, 
    -0.01215144f, 0.01966408f, 0.00242490f, -0.03517784f, -0.02539051f, -0.05963019f, 0.06090356f, -0.02123281f, 
    -0.05829918f, 0.00335193f, -0.06875110f, 0.02185414f, -0.02409507f, 0.03881443f, -0.02197983f, -0.04281201f, 
    -0.05931589f, 0.03447359f, -0.01060815f, -0.04398648f, -0.03933405f, 0.00910124f, -0.02127271f, -0.03330098f, 
    -0.06314559f, 0.05299035f, 0.06129780f, -0.04658578f, -0.03912764f, -0.04514841f, 0.04657301f, -0.03187373f, 
    -0.05036541f, -0.04931191f, -0.01829910f, 0.05126087f, -0.04981998f, 0.05726813f, 0.03849289f, -0.02235405f, 
    -0.07131160f, -0.07211263f, -0.02047153f, -0.04887538f, -0.00201636f, -0.04259171f, -0.02298361f, 0.02883359f, 
    0.06452346f, -0.04382852f, 0.00396893f, 0.06372327f, 0.06631387f, 0.04579761f, 0.03905100f, 0.04235620f, 
    -0.05264023f, -0.01028033f, -0.03320066f, 0.02529335f, -0.01327115f, -0.03729223f, 0.00240379f, -0.06046514f, 
    -0.04459148f, 0.04150073f, -0.00257599f, 0.07143204f, 0.06688747f, 0.00262611f, -0.05642862f, 0.05179561f, 
    0.00301635f, 0.04942158f, 0.01023763f, -0.00194984f, 0.02128524f, 0.05772310f, -0.03852584f, -0.03352109f, 
    -0.00111150f, 0.03306700f, -0.05003146f, 0.01747644f, 0.03070750f, -0.00212147f, 0.07198890f, 0.00953536f, 
    -0.45236427f, 0.21245912f, -0.06046425f, -0.13167746f, 0.10096161f, -0.02399634f, 0.01988477f, 0.02482580f, 
    0.06627531f, -0.00864644f, -0.00692549f, -0.00060775f, -0.15365735f, -0.05303960f, 0.02665516f, 0.21900833f, 
    0.09422234f, 0.04340381f, -0.02676007f, -0.04781934f, 0.04190208f, 0.09936966f, -0.16094300f, 0.11653951f, 
    -0.12269758f, 0.11810450f, -0.00046977f, 0.27280495f, -0.25284895f, 0.01883738f, -0.11687485f, 0.23879808f, 
    0.24617925f, 0.06660473f, 0.11014995f, -0.05462627f, 0.15379323f, 0.29657423f, -0.26152232f, -0.10816181f, 
    0.08217684f, -0.03408610f, -0.04805698f, 0.06222613f, -0.02629081f, 0.03567386f, -0.00010904f, 0.11811647f, 
    0.27857164f, 0.33316270f, -0.03496098f, 0.05045554f, 0.34270811f, 0.12426041f, 0.09305230f, -0.15475096f, 
    -0.09217290f, 0.01163693f, 0.00011633f, 0.14301963f, -0.20620623f, -0.18428650f, -0.23894492f, -0.06148262f, 
    -0.14972611f, -0.02299051f, -0.23532477f, -0.06323878f, -0.11227966f, 0.14590418f, 0.01915202f, 0.09432676f, 
    -0.34797472f, 0.11991789f, -0.09865954f, -0.28093782f, 0.19350612f, -0.06701072f, -0.03550366f, 0.01200387f, 
    -0.01847706f, -0.14027669f, 0.02317108f, 0.01981406f, -0.03044723f, 0.18823108f, -0.08575410f, 0.02207901f, 
    0.17906229f, 0.12597568f, -0.11638307f, -0.16561840f, -0.05933723f, 0.00514799f, 0.13649225f, 0.06342327f, 
    0.42789114f, -0.15504964f, -0.07237777f, 0.12823249f, -0.02343644f, -0.18499815f, -0.04694258f, -0.02191750f, 
    -0.18237939f, 0.12588386f, 0.03997006f, -0.10475989f, 0.19627841f, 0.10828081f, 0.00676390f, -0.11419659f, 
    0.17745513f, 0.05131897f, 0.08998610f, -0.13870704f, 0.06298264f, 0.00029726f, -0.04533853f, 0.07946137f, 
    0.01955444f, 0.01639478f, -0.04078784f, 0.36744621f, -0.15716320f, 0.11305277f, -0.05736886f, -0.04623969f, 
    -0.10476488f, 0.14636652f, 0.15279457f, -0.05812076f, -0.38672486f, 0.02400889f, 0.05409597f, 0.11486075f, 
    0.03844443f, 0.01230804f, 0.10752409f, 0.04129433f, -0.04230789f, 0.02196489f, 0.12508573f, 0.07832304f, 
    -0.43928459f, 0.01369385f, -0.02176448f, 0.08180653f, -0.11083747f, 0.04387369f, -0.17859440f, -0.02719770f, 
    0.17897891f, 0.17386580f, -0.03992322f, 0.06445025f, -0.05100492f, -0.13536896f, -0.18983346f, -0.12616648f, 
    0.00503420f, -0.13871339f, 0.08674943f, 0.01963764f, -0.00537728f, 0.01941672f, 0.11950633f, 0.18069886f, 
    0.10232701f, 0.22056404f, -0.07985923f, 0.14543496f, 0.03830603f, 0.01284873f, -0.01233770f, -0.14325048f, 
    0.02400180f, 0.05249124f, -0.11998215f, -0.00062145f, -0.39693329f, -0.06010409f, -0.18536735f, -0.12301283f, 
    0.20990427f, 0.12830001f, 0.06900438f, -0.05850832f, 0.05726504f, -0.10042975f, 0.03922048f, 0.01353865f, 
    -0.19810405f, -0.40978113f, 0.02053280f, -0.22015564f, 0.06796876f, 0.03551544f, -0.04400348f, 0.03530995f, 
    0.02093617f, -0.03760762f, 0.05151298f, -0.06090747f, -0.13092171f, 0.01109434f, 0.16096656f, -0.31563374f, 
    0.05221939f, 0.16383092f, 0.07889202f, 0.20925252f, -0.00408717f, -0.11960941f, 0.10715816f, 0.04369173f, 
    0.12467854f, 0.04367455f, -0.04916058f, -0.44997454f, 0.22120692f, 0.10322510f, 0.01352718f, -0.12063461f, 
    0.22266601f, -0.15989719f, 0.09530002f, 0.00731153f, -0.46322587f, -0.18541080f, 0.12139006f, 0.19695856f, 
    -0.02414996f, -0.04120345f, 0.17370357f, -0.01698328f, 0.12224477f, -0.09589117f, 0.10972605f, 0.03977780f, 
    0.11078131f, -0.02519205f, 0.02541027f, 0.04929674f, -0.18604094f, -0.15468240f, -0.04376710f, -0.07232925f, 
    0.11062055f, 0.11377972f, -0.08859266f, 0.20712221f, -0.05928527f, 0.13575248f, -0.04914695f, -0.00744200f, 
    0.16183548f, 0.06688175f, 0.12747899f, 0.08000482f, 0.01525899f, 0.02029700f, 0.11986347f, 0.20701510f, 
    0.32626581f, -0.33876473f, 0.13868628f, 0.26061997f, -0.18020906f, -0.09400500f, -0.11066010f, 0.00045657f, 
    0.08822357f, 0.06776111f, 0.17510337f, -0.12926713f, 0.23625599f, -0.12462502f, 0.27258539f, 0.24213840f, 
    -0.08300760f, -0.03718147f, 0.06428839f, 0.08393880f, 0.09952672f, 0.02037912f, -0.06450900f, 0.06982826f, 
    -0.07855645f, 0.26135689f, -0.12407537f, -0.08529998f, 0.01316882f, 0.10158066f, -0.11690404f, 0.08410063f, 
    0.21465127f, 0.01279666f, 0.07737724f, -0.01351357f, 0.12845916f, -0.03043288f, 0.11956428f, 0.10429273f, 
    -0.01803556f, -0.04786587f, -0.21040510f, -0.12570338f, -0.10334529f, -0.02984706f, 0.02522405f, 0.14713666f, 
    0.20319863f, 0.05807367f, 0.10854770f, -0.12623082f, -0.02272931f, -0.13640730f, 0.04648249f, 0.13471028f, 
    0.22701958f, 0.12461404f, -0.06541576f, 0.08272967f, 0.39913034f, 0.03655383f, -0.09890306f, 0.01367876f, 
    -0.01950838f, 0.04547978f, -0.08466474f, 0.19658501f, -0.03187461f, 0.05654630f, 0.08177385f, -0.00828252f, 
    0.30788231f, -0.09910540f, -0.22889097f, 0.01491174f, -0.08953038f, -0.11133340f, 0.01491683f, -0.08318456f, 
    -0.08046476f, -0.05180750f, -0.07165523f, 0.04685148f, -0.35799405f, 0.13053657f, -0.04293954f, 0.00813581f, 
    0.02808657f, 0.19527082f, 0.04133295f, 0.00679627f, 0.01154834f, 0.20770285f, -0.00899137f, 0.21635890f, 
    0.37307620f, -0.23449245f, -0.00712172f, -0.18321027f, -0.04446970f, -0.01524329f, -0.12692389f, 0.16047604f, 
    0.04484735f, -0.01169919f, -0.10065362f, 0.16852744f, 0.21587040f, 0.11902910f, -0.07000893f, 0.15535891f, 
    -0.06485938f, -0.07160182f, -0.13060707f, -0.14797840f, 0.05705287f, -0.04932677f, 0.26373094f, -0.01589232f, 
    0.00489393f, 0.06088700f, -0.07633844f, -0.01765219f, -0.01440446f, -0.03550895f, 0.01161814f, -0.04530674f, 
    0.06394298f, -0.06526209f, -0.02623301f, -0.03708892f, 0.01037943f, 0.03529475f, 0.00019828f, -0.05299799f, 
    0.01862946f, 0.06630895f, 0.02618165f, -0.06437371f, -0.03364579f, -0.03697127f, -0.04987783f, 0.01328362f, 
    0.05113869f, -0.06929294f, 0.00926417f, 0.03421778f, 0.00518710f, -0.07475755f, 0.01172747f, -0.07807759f, 
    0.00857555f, -0.06248618f, -0.04104434f, 0.05325643f, -0.03782267f, -0.06263984f, 0.06007554f, -0.04509242f, 
    -0.07150210f, -0.03122056f, -0.01331224f, -0.06028650f, 0.05462580f, -0.01447967f, -0.07396001f, 0.06233322f, 
    0.03942537f, 0.04474618f, -0.04738957f, -0.05077845f, -0.07203066f, 0.00364471f, -0.03872111f, 0.00920356f, 
    -0.01832923f, -0.00090138f, 0.05492786f, -0.07019568f, -0.03827673f, -0.00420888f, 0.04822291f, -0.01920164f, 
    0.05952774f, 0.02071133f, -0.04261098f, 0.03718518f, 0.00195505f, -0.07455245f, 0.05069055f, 0.00894110f, 
    0.00697705f, -0.06671146f, -0.05635584f, 0.06034242f, 0.01842231f, -0.00062977f, 0.05113786f, 0.04932622f, 
    0.05368963f, -0.02855371f, 0.03901776f, 0.01243229f, -0.04595131f, 0.00945017f, 0.05584759f, 0.04256710f, 
    -0.00027758f, -0.02862632f, -0.01462434f, -0.04114793f, -0.03721850f, -0.04734572f, -0.05449370f, 0.04069123f, 
    0.02494068f, -0.05207499f, 0.02356288f, 0.04836656f, -0.06520122f, 0.01737815f, 0.01747599f, 0.02066709f, 
    -0.08105651f, 0.05670609f, 0.02357429f, 0.00153894f, 0.01924932f, -0.05304587f, 0.05526566f, 0.01035178f, 
    0.04059513f, -0.03069196f, 0.06132801f, -0.02714753f, -0.03808382f, 0.04434176f, -0.02275422f, 0.05141528f, 
    0.05285889f, 0.01871099f, 0.06235959f, -0.00795410f, -0.02996533f, 0.00610688f, 0.01436225f, -0.05385640f, 
    0.03786103f, 0.00991818f, 0.00402918f, 0.02538738f, 0.03162604f, -0.02727595f, 0.00069626f, -0.07650299f, 
    -0.01460585f, 0.06096163f, 0.00700208f, -0.06236044f, -0.04261360f, 0.02254299f, -0.01974173f, -0.05765763f, 
    0.03191793f, -0.03652256f, -0.08176326f, -0.06731824f, -0.07609623f, 0.04835789f, -0.00458894f, -0.06890483f, 
    0.02932791f, -0.06967354f, 0.01886519f, -0.02281712f, -0.06118933f, -0.01102827f, -0.02713120f, -0.03456097f, 
    -0.07282544f, -0.05896799f, 0.05889830f, -0.00571761f, 0.02089642f, 0.05098905f, 0.04517939f, -0.02157231f, 
    0.05370075f, 0.05295363f, 0.00012690f, -0.06479770f, 0.04361819f, 0.03144115f, 0.03945428f, -0.04789248f, 
    -0.00092212f, -0.06025904f, -0.06034787f, -0.02449725f, 0.00651190f, 0.01318294f, -0.04103376f, -0.08136751f, 
    -0.05714387f, 0.02910755f, -0.05784269f, 0.05067958f, -0.03818973f, -0.01695077f, -0.04365203f, 0.04258111f, 
    -0.04716786f, -0.08411114f, 0.07024380f, 0.04405644f, -0.05300375f, -0.01024066f, -0.05146737f, 0.04993144f, 
    0.01229889f, -0.06695803f, -0.02985938f, -0.06726798f, 0.02189901f, -0.04879304f, 0.04446165f, 0.02197265f, 
    0.02386511f, -0.05217822f, -0.06347504f, -0.06921639f, -0.00860383f, 0.04351590f, -0.03140182f, -0.00959036f, 
    -0.06745944f, -0.01377424f, -0.00725012f, -0.07654309f, -0.06476194f, 0.00882721f, 0.01110819f, 0.04132558f, 
    -0.06406945f, -0.07367153f, -0.05772292f, -0.04609030f, -0.06938136f, 0.05953332f, -0.03370433f, -0.06521761f, 
    -0.00171558f, -0.06825757f, -0.04692686f, -0.08157454f, 0.03184906f, 0.02367126f, -0.00966472f, 0.05629965f, 
    -0.07829910f, 0.06272725f, -0.04606398f, 0.00319751f, -0.06602239f, -0.06083428f, 0.00525209f, -0.00625981f, 
    0.00464779f, 0.05070749f, -0.03884871f, -0.02695016f, -0.06146961f, -0.01556515f, 0.04859218f, -0.07435365f, 
    -0.05454228f, 0.02837237f, -0.00106708f, -0.07402983f, 0.01652266f, 0.02268831f, -0.01184685f, -0.04074154f, 
    -0.04945780f, -0.02936604f, -0.03158978f, 0.04094583f, 0.05852436f, -0.04779450f, 0.04348148f, -0.08480509f, 
    -0.06929225f, -0.03740226f, 0.04604654f, -0.06565517f, -0.05562852f, -0.01955124f, -0.06916608f, 0.02930405f, 
    -0.04370233f, 0.01811737f, -0.06820562f, 0.01726778f, -0.00570488f, -0.00784560f, 0.05398426f, 0.05034716f, 
    -0.00194504f, -0.02774970f, -0.08096582f, -0.07573216f, -0.01309537f, 0.01253860f, -0.07116910f, -0.04773871f, 
    -0.03742553f, -0.06676652f, -0.02678929f, 0.02044171f, 0.00383725f, 0.01835545f, -0.04745349f, 0.01336094f, 
    0.04290751f, 0.04226875f, 0.02361627f, -0.02838924f, -0.04557497f, -0.07230829f, -0.06800537f, -0.00021508f, 
    -0.08658794f, 0.02214963f, 0.00531594f, -0.01521006f, -0.02999672f, -0.02819299f, 0.04444670f, -0.07080636f, 
    -0.02494784f, 0.01130303f, -0.00019861f, -0.00560008f, -0.01094165f, -0.07063538f, 0.00754751f, -0.04341107f, 
    0.03767470f, 0.02735475f, -0.02542937f, -0.07916519f, 0.06137317f, -0.08000005f, -0.05925866f, -0.03520611f, 
    -0.01737757f, -0.06655944f, -0.00613933f, 0.06656985f, -0.07911166f, 0.01072153f, 0.02665731f, -0.07709652f, 
    -0.05541792f, 0.04407503f, -0.03959188f, 0.01122753f, -0.07060345f, 0.03662078f, 0.01320510f, 0.02974420f, 
    0.05895395f, -0.06577902f, -0.01893937f, -0.03909038f, 0.02714522f, -0.00657272f, 0.03831518f, 0.01199871f, 
    0.03920345f, 0.01185507f, -0.07612217f, 0.03050623f, -0.05930119f, -0.08383663f, 0.03781401f, -0.03635005f, 
    -0.02693651f, -0.07465139f, 0.02521559f, -0.00794818f, 0.05895022f, 0.04506452f, 0.00016758f, -0.03041927f, 
    -0.03245604f, 0.02603061f, -0.03463306f, 0.00734861f, 0.05045906f, -0.06156674f, 0.02197783f, -0.02519946f, 
    0.21474884f, 0.40715268f, 0.23871723f, 0.24739097f, 0.07961659f, -0.13056110f, -0.01945261f, -0.17122254f, 
    -0.01104006f, 0.05655214f, -0.07756480f, -0.04913688f, 0.49751192f, 0.42751539f, -0.02525951f, 0.14553961f, 
    0.18201292f, 0.24194795f, 0.11906995f, -0.11310469f, 0.01571305f, 0.17517939f, 0.17259058f, -0.08292856f, 
    0.28114355f, 0.06457868f, -0.09886830f, 0.38528255f, -0.11488488f, 0.17571102f, 0.05712801f, -0.04877123f, 
    0.06533946f, -0.08396114f, 0.04259977f, -0.11021306f, -0.34847915f, 0.02492913f, 0.02865368f, -0.21017540f, 
    -0.07519266f, -0.05561041f, 0.02068675f, 0.11843672f, -0.02511288f, 0.12060713f, -0.12315169f, -0.05653287f, 
    -0.26327905f, -0.22047763f, 0.06478050f, -0.04626726f, -0.18816869f, 0.08702420f, 0.00629170f, 0.05589701f, 
    0.16314456f, -0.17666116f, -0.17850879f, -0.18995005f, 0.19026130f, 0.04859425f, -0.03525447f, -0.00839589f, 
    0.12504382f, 0.09593959f, 0.01374444f, 0.03824610f, 0.06908982f, 0.19632146f, 0.04417124f, 0.12129585f, 
    -0.35505337f, -0.28244257f, -0.14090371f, -0.22880310f, 0.21399347f, -0.07209302f, 0.16527560f, 0.06806180f, 
    -0.01372119f, -0.21741183f, -0.03844597f, 0.12208526f, -0.13964090f, -0.18520477f, -0.23176137f, -0.06425810f, 
    0.05883123f, -0.01200708f, 0.06389847f, -0.07561498f, -0.08625152f, 0.02483720f, -0.01383979f, 0.10677337f, 
    0.04547903f, 0.22241952f, 0.10123532f, 0.09705061f, 0.00403664f, 0.11685485f, 0.04662576f, -0.00593826f, 
    0.00286727f, 0.01431247f, -0.14976425f, -0.11972701f, -0.11021575f, -0.27435285f, -0.07487090f, -0.05338592f, 
    0.01131326f, 0.10071638f, -0.10002472f, -0.05212332f, -0.04336865f, -0.12638369f, -0.15011634f, -0.10983983f, 
    -0.22837438f, 0.07903276f, 0.11375610f, 0.10168734f, -0.05345816f, -0.09961729f, -0.06986006f, -0.01405010f, 
    0.22467068f, 0.08263600f, -0.05983217f, 0.11424373f, -0.00533519f, 0.00406376f, -0.27016732f, 0.19160418f, 
    0.13630126f, 0.01462927f, 0.02751960f, -0.10244462f, 0.00623143f, -0.10437738f, 0.03041998f, -0.22583300f, 
    -0.00588115f, 0.14944156f, -0.01367076f, 0.13261724f, 0.16703600f, 0.01847494f, 0.13926105f, 0.10401266f, 
    0.16614227f, 0.02440086f, 0.06550027f, 0.06244679f, 0.29659984f, 0.28495035f, 0.23452187f, -0.02866626f, 
    0.04380446f, 0.00942058f, -0.01012455f, 0.06731796f, 0.05202770f, -0.07931069f, 0.10869453f, 0.12494009f, 
    0.09720993f, -0.12647413f, -0.15576841f, -0.14501503f, -0.01338465f, 0.00092026f, 0.02661272f, -0.12963106f, 
    -0.02787880f, -0.00585861f, -0.15353666f, -0.06444932f, -0.18740338f, -0.31950495f, 0.20342857f, 0.02234813f, 
    -0.14011875f, 0.03661129f, 0.06946864f, -0.03673524f, -0.05474925f, 0.13397934f, 0.07353128f, -0.01139766f, 
    -0.08208829f, -0.14584255f, -0.19309959f, 0.07272235f, 0.14158686f, 0.18734694f, 0.06985240f, -0.02507873f, 
    0.08767287f, 0.01277269f, 0.18452691f, 0.06845720f, -0.31934077f, 0.11308487f, -0.04707196f, -0.20408650f, 
    0.06497145f, -0.00136594f, -0.15833765f, -0.08450928f, 0.01234424f, 0.08041882f, 0.11754967f, 0.14115573f, 
    -0.08134939f, -0.10939286f, -0.05042550f, 0.37389508f, 0.03716237f, 0.01321476f, 0.01743590f, -0.05801597f, 
    0.16731548f, -0.02773254f, 0.02908924f, -0.01904802f, 0.26807308f, -0.32131514f, 0.11154678f, -0.31012279f, 
    -0.06912862f, -0.12179057f, 0.03425159f, 0.09021222f, -0.01716056f, -0.03221605f, -0.05334295f, -0.13809994f, 
    0.02266483f, -0.08760601f, 0.03836517f, 0.16546384f, 0.01521960f, -0.09950058f, 0.04843440f, 0.12034595f, 
    0.07193717f, -0.09446058f, 0.09861530f, -0.11188698f, 0.20528857f, 0.16731121f, 0.06896276f, -0.03023406f, 
    0.07537000f, 0.08423975f, 0.13925885f, 0.13571826f, 0.10553455f, 0.02167658f, 0.06699795f, -0.01885789f, 
    -0.03001799f, 0.17300703f, 0.28105304f, -0.42489707f, -0.16312611f, -0.03484627f, -0.00360668f, -0.02723899f, 
    0.11176001f, -0.01258359f, 0.03793089f, -0.02290761f, -0.21237363f, 0.19090955f, 0.01858277f, -0.05388771f, 
    0.03104509f, 0.12203517f, -0.00518042f, 0.10948367f, 0.10625326f, -0.04469461f, 0.08944762f, 0.01579688f, 
    -0.01026122f, -0.38235351f, 0.00732123f, 0.17441778f, -0.03850713f, -0.06282984f, 0.11704966f, 0.01957956f, 
    0.07027768f, -0.02749983f, 0.15940431f, 0.15013097f, -0.60188651f, 0.15937442f, 0.22159715f, 0.06909511f, 
    -0.25640884f, 0.15805934f, 0.04430461f, -0.01936276f, -0.08193213f, 0.07968915f, -0.03946034f, 0.08641642f, 
    -0.32615888f, 0.02721134f, 0.21887387f, 0.34091982f, 0.02430500f, -0.03724550f, 0.08568906f, 0.01738588f, 
    0.12781700f, -0.00912634f, 0.04957505f, -0.18541285f, -0.07700488f, -0.00659099f, 0.06022880f, 0.04166222f, 
    0.08457838f, 0.01782266f, 0.04788820f, 0.02968134f, 0.02266067f, -0.01728339f, 0.02400233f, -0.00049944f, 
    0.21625327f, -0.06379903f, 0.11034709f, 0.10714670f, -0.18989448f, 0.13349485f, 0.03716457f, -0.08979962f, 
    -0.02307837f, 0.07456116f, -0.00557060f, 0.06704655f, 0.39705238f, 0.03828324f, -0.19791546f, -0.08478776f, 
    0.02944254f, 0.12253852f, 0.01192460f, 0.00846241f, -0.04843109f, 0.04312969f, -0.02120090f, 0.02043173f, 
    0.14820461f, -0.38129187f, 0.05633605f, 0.01374965f, -0.15716574f, -0.11983816f, -0.10779595f, 0.14589392f, 
    0.05383676f, -0.05955688f, -0.01472008f, 0.24774310f, 0.06038010f, 0.07327864f, 0.09122565f, -0.12142118f, 
    0.15036239f, 0.06834439f, 0.04163546f, 0.00908982f, 0.06491396f, 0.12651078f, -0.04958854f, -0.12398645f, 
    0.06935442f, 0.04996996f, 0.36708942f, 0.09651110f, 0.10538861f, 0.07976651f, 0.01392587f, 0.06534824f, 
    -0.00229514f, 0.02268992f, 0.02585821f, 0.09282663f, 0.32722425f, 0.04469704f, -0.09603526f, 0.02141935f, 
    -0.00653235f, 0.11654764f, 0.10892215f, -0.32239833f, -0.10372543f, 0.14065552f, 0.09997156f, 0.00852646f, 
    0.39056045f, 0.13091372f, 0.04092497f, 0.10855368f, -0.08375704f, 0.05429958f, 0.04252401f, -0.03454541f, 
    -0.04698847f, -0.02784803f, 0.12419213f, -0.09824330f, 0.20720482f, 0.02247326f, 0.05038805f, 0.30334404f, 
    0.10508970f, 0.12595753f, -0.03129975f, -0.00724590f, -0.00554886f, 0.04468268f, -0.08177725f, -0.08663882f, 
    -0.40632436f, -0.12945378f, -0.01606091f, -0.18501918f, -0.05258685f, 0.09553694f, 0.20076749f, 0.03137578f, 
    0.01483835f, -0.15913396f, 0.06355190f, -0.06801935f, 0.17616102f, -0.13874149f, -0.09029109f, -0.04182072f, 
    -0.04915466f, -0.03943945f, -0.08179194f, -0.09253069f, -0.05787475f, 0.10469759f, 0.03238879f, 0.08773834f, 
    -0.38799515f, -0.03409342f, -0.03043600f, -0.14208993f, 0.06757094f, -0.05061296f, 0.10873818f, -0.17510870f, 
    -0.08565854f, -0.02482346f, -0.07896615f, 0.00760364f, -0.34399515f, -0.33671466f, 0.00606886f, -0.11274441f, 
    -0.00419778f, -0.04760857f, 0.05865658f, -0.09959055f, -0.04840144f, -0.07554156f, 0.04121093f, 0.12148041f, 
    0.25131962f, -0.00774981f, 0.07274387f, -0.11622397f, 0.15885916f, 0.05701490f, -0.07819783f, 0.08112641f, 
    -0.15792881f, 0.07654609f, -0.06297129f, 0.01120139f, -0.22862975f, -0.24140862f, -0.32650715f, 0.02088537f, 
    0.11932234f, 0.07896961f, 0.04758455f, -0.08204644f, -0.07068555f, -0.04642944f, -0.03017733f, 0.02794612f, 
    -0.30838642f, 0.04327371f, 0.04009983f, -0.08456437f, 0.06286352f, 0.05048508f, -0.01106977f, 0.10294225f, 
    0.00025890f, 0.03309815f, 0.18795986f, 0.22492816f, 0.09380718f, -0.03929291f, -0.19511144f, 0.03315550f, 
    0.06618918f, -0.05446230f, 0.14888519f, 0.00079690f, -0.02865636f, -0.02228932f, -0.04731385f, -0.01122027f, 
    0.32931104f, 0.29726028f, 0.03504478f, -0.03975347f, 0.08669022f, -0.04959755f, 0.14134435f, -0.05734682f, 
    0.13829221f, 0.06234417f, 0.11048798f, 0.17264928f, 0.27555579f, 0.17996800f, 0.08963174f, 0.02723476f, 
    0.07283825f, 0.01790367f, -0.00475554f, 0.20664208f, 0.04026499f, -0.01038984f, -0.04592479f, 0.01205992f, 
    0.20492235f, 0.22278216f, 0.02313322f, -0.10971691f, 0.04500864f, 0.10794164f, -0.08433145f, -0.13405214f, 
    -0.04146654f, 0.06654783f, -0.06937678f, -0.09197453f, -0.23927680f, -0.18674167f, 0.21084049f, 0.08849123f, 
    -0.12399282f, 0.12089492f, 0.00775314f, -0.07623714f, -0.13408740f, 0.02445814f, -0.08240340f, 0.01674473f, 
    -0.44976512f, 0.35959682f, -0.26185611f, 0.05900028f, 0.10880855f, -0.03500240f, -0.05354433f, 0.06776769f, 
    0.14052981f, 0.07076815f, 0.04222829f, -0.06947361f, -0.06182867f, 0.12053087f, 0.13964517f, 0.25592214f, 
    -0.06233452f, 0.12823273f, -0.07949501f, -0.13956840f, 0.17022079f, 0.08993079f, -0.17597029f, -0.09710397f, 
    0.15212056f, 0.30551487f, -0.00669382f, 0.45266512f, -0.17426307f, -0.02934881f, -0.01483654f, 0.13768570f, 
    0.12928283f, -0.10192925f, 0.02149233f, -0.12788616f, 0.18216906f, 0.02616641f, -0.00976759f, -0.07092284f, 
    -0.00128305f, 0.02079709f, 0.04308156f, 0.05247410f, 0.08345334f, 0.03158092f, 0.05966843f, 0.00488454f, 
    0.12110771f, 0.29528442f, 0.01325318f, -0.16104999f, 0.20908837f, 0.07383581f, 0.14562899f, -0.12886068f, 
    -0.13304685f, 0.04647229f, -0.11677358f, 0.08075900f, 0.18641828f, 0.04579402f, 0.22847737f, 0.01787815f, 
    0.02936637f, 0.01203739f, -0.10939615f, -0.06973488f, -0.19562042f, 0.00583045f, 0.06401606f, 0.13157819f, 
    -0.19383988f, -0.22152926f, -0.13428918f, -0.36347136f, 0.15359624f, 0.00725123f, -0.09756569f, -0.13687703f, 
    -0.21399723f, -0.00052672f, 0.18318908f, -0.01339399f, 0.22073655f, -0.10904038f, -0.19127442f, -0.13651854f, 
    0.27815026f, -0.00284311f, 0.04536391f, -0.18775964f, 0.06479844f, 0.15240358f, 0.05485155f, 0.05182174f, 
    0.37675381f, -0.05236493f, 0.02603737f, 0.17993985f, 0.05086078f, -0.18808393f, -0.05066255f, 0.00480672f, 
    -0.08943605f, 0.00771929f, -0.02115450f, -0.14683728f, 0.21684478f, 0.33706433f, -0.25902709f, -0.24086192f, 
    0.33587903f, -0.00379344f, -0.09987751f, -0.12938628f, -0.06230383f, 0.01558865f, -0.03680658f, 0.05184944f, 
    0.12872563f, 0.31828958f, 0.09912816f, 0.13256760f, 0.05723364f, -0.01054760f, -0.02842684f, 0.00555978f, 
    0.02877926f, 0.11521256f, 0.08677276f, 0.11893236f, 0.01206946f, -0.01504295f, 0.25688559f, -0.00940424f, 
    -0.07826315f, -0.12200676f, -0.04901156f, 0.03101169f, -0.04689831f, -0.00837044f, -0.06409016f, 0.07361911f, 
    0.10657191f, 0.02788315f, 0.20842363f, 0.15218462f, -0.04719063f, -0.06777576f, 0.08411876f, 0.26630178f, 
    0.04915426f, 0.10481421f, -0.11962403f, -0.02935693f, 0.27256122f, -0.43117324f, -0.25363812f, 0.03614120f, 
    -0.03143224f, 0.03869815f, -0.10807211f, -0.06409462f, -0.01445081f, 0.00836739f, 0.13423549f, 0.15087089f, 
    -0.11902051f, -0.14209424f, 0.11020676f, 0.13908947f, -0.08492947f, -0.00228880f, -0.18932508f, 0.04020296f, 
    -0.03027680f, 0.04489340f, -0.24791972f, 0.01757839f, 0.19369620f, -0.18515697f, -0.60381484f, -0.14135450f, 
    0.19649836f, 0.00303986f, 0.04830370f, -0.02978722f, -0.13114919f, 0.04447744f, 0.06900039f, 0.03353565f, 
    0.04330979f, 0.04163008f, 0.03678470f, 0.01958801f, 0.04108437f, -0.06242461f, -0.02797168f, -0.05558687f, 
    -0.02760538f, -0.03525550f, 0.04957949f, 0.03885122f, -0.02694120f, -0.06864626f, 0.02323866f, -0.04900217f, 
    -0.06202852f, -0.02985988f, -0.05594186f, -0.04746283f, -0.02745014f, -0.05671759f, -0.04522631f, 0.00176929f, 
    -0.05740443f, 0.04197816f, -0.02814158f, -0.06807409f, 0.00559651f, -0.01344269f, 0.06741352f, 0.03474490f, 
    0.02564045f, 0.00192506f, -0.05481046f, -0.05801526f, -0.03048278f, -0.03493495f, -0.03494816f, -0.00787498f, 
    0.05003353f, -0.01269081f, 0.03441753f, -0.01097359f, -0.05956947f, 0.03773227f, 0.04863412f, 0.01755422f, 
    -0.06188280f, -0.02034527f, -0.04107745f, 0.00876424f, 0.06302424f, -0.01939202f, 0.03911514f, 0.04915102f, 
    0.07145932f, 0.04026036f, -0.06499490f, -0.01010113f, -0.06012173f, -0.08018067f, -0.00924469f, -0.04032375f, 
    -0.04434969f, -0.00450472f, -0.05408211f, -0.02754958f, 0.00075067f, 0.02015180f, 0.02454539f, -0.02216031f, 
    -0.05021212f, 0.07074833f, -0.06785497f, -0.04317414f, -0.03205409f, -0.06489132f, -0.06213565f, -0.02762703f, 
    0.04111186f, 0.03867626f, -0.00679725f, -0.00294781f, 0.00931449f, -0.04010179f, -0.05419639f, 0.03557869f, 
    0.01935326f, 0.01021725f, -0.00358040f, 0.03777813f, -0.00492587f, 0.03462049f, -0.02140197f, -0.01096470f, 
    0.00192332f, -0.05970645f, -0.06584208f, -0.02823655f, -0.00287277f, 0.02632091f, 0.01782390f, 0.05777652f, 
    -0.05269970f, 0.05179554f, 0.00343874f, -0.00896999f, -0.07450338f, -0.00568162f, -0.00308266f, 0.05581279f, 
    -0.07886078f, -0.02003239f, -0.02205104f, -0.02038358f, -0.06210240f, 0.01497393f, 0.02071104f, 0.06217398f, 
    0.01821615f, -0.05296391f, -0.02346139f, -0.06251159f, 0.06046294f, -0.00014667f, -0.06391858f, -0.00684649f, 
    -0.06168671f, 0.04635549f, 0.06291433f, 0.00585582f, 0.03359412f, 0.05710647f, -0.05990532f, -0.05152320f, 
    0.06518760f, 0.06388085f, -0.03178620f, -0.01280104f, 0.06048091f, -0.06924969f, 0.00230563f, 0.02344161f, 
    0.04941531f, -0.06417257f, -0.03059101f, -0.02994668f, 0.05327306f, -0.02663469f, -0.04486138f, -0.07723410f, 
    -0.05101768f, 0.03017027f, 0.05197798f, 0.02047428f, -0.05709277f, 0.03953947f, 0.03736262f, -0.06158366f, 
    0.01209963f, -0.02938462f, 0.03099274f, 0.01238558f, -0.02468994f, -0.00069872f, -0.00676182f, -0.05037594f, 
    0.02595198f, 0.04303100f, -0.00015036f, 0.04515668f, 0.00374447f, -0.07211030f, -0.05208837f, 0.00607240f, 
    -0.01913601f, 0.03552993f, -0.06244306f, -0.03022031f, 0.02860120f, -0.00515447f, -0.03583409f, -0.04215230f, 
    0.03688980f, -0.07620173f, 0.00867062f, 0.05600567f, -0.01914140f, 0.00823196f, -0.04623704f, 0.06957105f, 
    -0.22761612f, -0.07624630f, -0.13670591f, 0.15157299f, 0.12967190f, 0.04660443f, 0.12303900f, 0.15628569f, 
    0.03761823f, 0.00100561f, 0.08486737f, 0.13017799f, -0.54649156f, -0.23250680f, -0.15337728f, 0.01363951f, 
    0.14312914f, 0.13290988f, -0.03743398f, -0.14269625f, 0.01077722f, -0.00118934f, -0.01178155f, 0.13731231f, 
    -0.20641674f, 0.11862142f, -0.07615793f, 0.36783722f, -0.02528616f, -0.04640486f, -0.04087352f, 0.32842928f, 
    0.09196970f, 0.09121472f, 0.02640804f, 0.01108036f, 0.29205254f, -0.21187989f, 0.02556754f, -0.47639742f, 
    0.05753781f, 0.00943015f, 0.01718905f, 0.14183861f, -0.01767319f, 0.14261942f, -0.09636076f, -0.06558551f, 
    0.11729850f, 0.16097261f, -0.08412205f, 0.08892017f, 0.20305060f, -0.07581557f, 0.10046060f, -0.01171284f, 
    -0.02494038f, -0.03835492f, 0.11014491f, -0.02873460f, -0.25143769f, -0.18168630f, -0.02148234f, 0.00178643f, 
    0.09596580f, -0.00958850f, -0.16603494f, 0.03481377f, 0.02150553f, -0.10645801f, 0.01818087f, -0.04950587f, 
    -0.01325482f, 0.39364269f, 0.18509245f, -0.40000138f, 0.03702720f, 0.03753922f, -0.07343039f, -0.06549662f, 
    0.10164463f, -0.08935037f, -0.04611026f, 0.01163361f, -0.20898901f, 0.31205750f, 0.10310960f, 0.10611855f, 
    0.22385947f, 0.12011836f, -0.12218554f, -0.03486597f, 0.03526988f, -0.09096563f, 0.08402286f, 0.00460761f, 
    -0.11828235f, -0.30930641f, 0.03549432f, 0.14291622f, -0.05322261f, -0.13786770f, 0.11208250f, -0.01598059f, 
    -0.17107211f, -0.09662248f, 0.05561112f, -0.01355759f, -0.13620770f, 0.16969022f, 0.12476864f, 0.11432701f, 
    0.00811702f, 0.03076353f, 0.00505509f, -0.03133606f, 0.08308347f, 0.03638890f, 0.04169967f, 0.08437928f, 
    -0.09740936f, 0.14247613f, 0.16719031f, 0.19302149f, -0.00355158f, -0.07422027f, -0.03637711f, -0.14111765f, 
    -0.06163289f, -0.05623524f, -0.01986767f, -0.10146604f, -0.31638196f, -0.02920284f, 0.18252175f, -0.05054331f, 
    0.06808057f, 0.11187919f, -0.02366577f, -0.04338780f, 0.15882863f, -0.00164543f, 0.13732916f, 0.04004268f, 
    -0.14234430f, -0.18645059f, 0.15970430f, 0.06330109f, 0.05974028f, 0.06404163f, -0.06852514f, -0.00964180f, 
    -0.05601702f, -0.05453714f, 0.02334842f, 0.07285043f, 0.51709360f, -0.27482474f, -0.27758154f, -0.16822669f, 
    -0.07227174f, -0.01943288f, 0.14176545f, -0.02416677f, -0.04824879f, 0.11266339f, 0.02602662f, 0.00737656f, 
    -0.25575164f, 0.15833171f, -0.00083717f, 0.08477034f, -0.02751948f, -0.10907267f, -0.06109801f, 0.00448608f, 
    0.14232877f, -0.06430716f, 0.04361193f, 0.20547129f, 0.02837934f, 0.04492717f, 0.07298794f, -0.01954856f, 
    0.26536816f, 0.01782326f, 0.00515487f, -0.05822860f, -0.16630921f, 0.02436600f, -0.09330179f, 0.08258875f, 
    -0.04860461f, 0.03299443f, 0.05907547f, 0.00125797f, 0.01129844f, 0.00958406f, -0.01203816f, -0.03777971f, 
    0.01216106f, 0.01365409f, -0.02852060f, 0.00395633f, 0.05762772f, -0.06585374f, -0.05671678f, 0.03755459f, 
    0.04624364f, 0.04578356f, 0.04204521f, -0.07648168f, 0.00823365f, -0.03778606f, -0.03299505f, -0.00597805f, 
    -0.00829282f, -0.01271966f, -0.03165635f, -0.01220651f, -0.06970786f, 0.03387932f, 0.00513861f, 0.05428924f, 
    -0.05527782f, -0.02624290f, 0.03313955f, -0.06035029f, 0.01973934f, -0.02025715f, -0.00716796f, -0.06845053f, 
    -0.03857950f, 0.05185419f, -0.00800043f, -0.00247915f, -0.01948368f, -0.07102808f, -0.07998079f, -0.07211216f, 
    -0.05913968f, 0.04717527f, 0.01374962f, 0.01319961f, 0.05216507f, -0.08009801f, 0.00273826f, -0.00517158f, 
    -0.03346881f, 0.05716683f, -0.00352215f, -0.02685390f, 0.04536952f, -0.04584127f, 0.04668490f, 0.02538615f, 
    -0.06807299f, 0.06140595f, 0.02025892f, -0.00523777f, -0.04953670f, -0.04888703f, -0.03629137f, -0.02423366f, 
    -0.03114387f, -0.05177142f, -0.01535496f, 0.04340376f, -0.06377938f, 0.05804310f, -0.04904213f, -0.01559062f, 
    -0.00118614f, -0.01488559f, 0.06147584f, -0.06136347f, 0.02658403f, 0.01634433f, 0.04326354f, -0.03960504f, 
    0.03048033f, 0.02157151f, 0.05104949f, 0.02017717f, 0.05433517f, 0.04697324f, -0.07415615f, 0.01156562f, 
    -0.00753405f, -0.07648154f, -0.03823832f, -0.06649160f, -0.03303980f, 0.00441177f, -0.02536028f, 0.01076841f, 
    -0.00042444f, -0.06872723f, -0.07020622f, 0.02580011f, -0.03685924f, 0.03901437f, 0.00324340f, -0.03725292f, 
    0.02018509f, -0.07979972f, 0.06681188f, 0.00080041f, 0.06013186f, 0.02221536f, -0.01365701f, -0.05926452f, 
    0.06164334f, 0.02864167f, 0.01909017f, -0.07245790f, -0.05020426f, 0.05962537f, -0.04804942f, 0.01074807f, 
    -0.01337160f, -0.00617521f, 0.00232302f, -0.05064908f, -0.05853621f, -0.07753743f, -0.07943720f, -0.02687179f, 
    -0.03239724f, 0.00968385f, 0.01383133f, 0.05871135f, 0.06959356f, -0.06887222f, 0.04731262f, 0.01811716f, 
    0.05732395f, 0.03074084f, -0.01473018f, -0.03531978f, -0.01066831f, -0.03146336f, -0.05604510f, -0.06725293f, 
    0.00808186f, 0.06361863f, -0.06956460f, 0.05731075f, -0.03943187f, -0.01612750f, -0.05214977f, -0.01394084f, 
    -0.07132620f, 0.02320769f, 0.01749083f, -0.03729409f, 0.00257794f, -0.02650834f, -0.05204147f, -0.01959177f, 
    -0.03776335f, -0.02189939f, 0.00052487f, -0.05454974f, -0.04841155f, -0.05002249f, -0.06431302f, -0.07716027f, 
    0.02255885f, 0.05196593f, 0.00601890f, -0.04269040f, 0.04215276f, 0.05395242f, -0.05061804f, -0.05829967f, 
    -0.00775147f, -0.04525094f, 0.05234363f, 0.06269346f, 0.02144694f, -0.05235792f, 0.01820937f, -0.00948608f, 
    -0.01210083f, -0.02430278f, 0.06431484f, -0.05860745f, 0.01669937f, -0.00606149f, -0.06367172f, -0.01499652f, 
    -0.00860574f, -0.05096597f, -0.03239416f, -0.07094971f, 0.00355633f, -0.02795875f, 0.05643764f, -0.06610087f, 
    -0.01955545f, -0.03278788f, 0.01124654f, 0.02580565f, -0.00171382f, -0.00098102f, -0.00684493f, -0.06735408f, 
    0.00426508f, 0.00472085f, 0.00499737f, -0.07535911f, -0.02584955f, -0.03691768f, 0.04651171f, 0.04565416f, 
    -0.04522964f, 0.06386005f, -0.00885626f, 0.04170997f, -0.04404160f, -0.01163934f, 0.01298986f, 0.01287713f, 
    -0.07033624f, -0.02784953f, -0.06291071f, -0.07087030f, -0.05130716f, -0.05137548f, -0.02937997f, -0.02328096f, 
    -0.05986455f, 0.03200313f, 0.00634222f, -0.06381099f, -0.04972035f, 0.01083852f, -0.01391654f, -0.07528860f, 
    -0.01563867f, 0.01528999f, 0.05095134f, -0.06869923f, -0.01660660f, -0.03109452f, -0.03412015f, 0.02564420f, 
    -0.07619050f, 0.01175994f, -0.07187454f, -0.02943915f, -0.01520140f, -0.01085828f, -0.01316910f, -0.01396685f, 
    0.05409227f, -0.00905407f, -0.07814480f, -0.00209827f, 0.02482464f, 0.03598636f, 0.00607917f, -0.01068479f, 
    -0.02679483f, 0.05127559f, -0.02464275f, -0.05022921f, -0.00620696f, -0.02103264f, -0.07165220f, 0.00201908f, 
    -0.05396543f, -0.06672934f, -0.03961083f, 0.06158335f, -0.01682706f, -0.01588189f, 0.04923536f, -0.02576538f, 
    0.06222196f, -0.04648430f, 0.04518769f, -0.07450886f, -0.03326211f, -0.02722462f, 0.06017684f, -0.04665321f, 
    -0.01248583f, 0.06373458f, 0.04831181f, 0.00689204f, -0.04957509f, -0.05052659f, -0.06314105f, -0.03316235f, 
    -0.05788581f, -0.04019151f, -0.00783458f, -0.06063571f, 0.03348245f, -0.01523037f, 0.04616938f, -0.05604995f, 
    -0.00294705f, -0.02850895f, -0.04884357f, 0.03600221f, 0.00545025f, -0.03000229f, -0.03028685f, -0.01311661f, 
    0.03082995f, -0.07482230f, -0.06608984f, 0.06491724f, 0.06035035f, 0.02680732f, -0.02036716f, 0.02165207f, 
    -0.01020043f, -0.05498233f, 0.03516269f, -0.05252747f, -0.05337340f, -0.06362733f, 0.05862717f, -0.02184595f, 
    0.04355503f, -0.03064266f, 0.00853234f, 0.00693329f, -0.03820663f, -0.03598074f, -0.00342602f, -0.01252062f, 
    0.05952356f, -0.07771017f, -0.00322026f, 0.01805987f, 0.01912210f, 0.03009430f, -0.01128574f, 0.03201234f, 
    0.06115942f, -0.00267627f, 0.01631699f, -0.06045680f, 0.02880592f, 0.03727789f, 0.00206866f, 0.05017493f, 
    -0.06100227f, -0.02899876f, 0.00649979f, -0.01662655f, 0.01429354f, -0.00842251f, -0.05847232f, 0.06193749f, 
    -0.00442164f, -0.06242068f, 0.02233129f, 0.02394964f, -0.02628180f, 0.03748885f, -0.04895771f, 0.04916802f, 
    0.04420279f, -0.03868140f, -0.00036601f, -0.01353261f, 0.00383098f, 0.01435602f, -0.02329816f, 0.03135842f, 
    0.04690064f, -0.18905406f, 0.14347817f, -0.15736568f, 0.04721118f, -0.08489026f, -0.03299146f, 0.08914578f, 
    -0.00847858f, -0.12054812f, -0.03749130f, 0.01283596f, -0.24319001f, -0.13961086f, 0.18842521f, 0.00854600f, 
    0.13191514f, 0.17767298f, -0.00465130f, 0.41761345f, -0.02965130f, -0.05825152f, 0.02937718f, -0.05309260f, 
    -0.12955751f, 0.01553052f, 0.19094029f, -0.38112685f, 0.12983496f, 0.03055106f, 0.00203954f, 0.04372568f, 
    0.14179669f, -0.16169737f, -0.04211406f, 0.08960694f, -0.66003537f, 0.26647913f, -0.07808901f, -0.09688629f, 
    0.00253667f, 0.06374037f, 0.13895622f, 0.10505661f, -0.03663545f, -0.03309148f, 0.10140916f, 0.00386277f, 
    0.57958174f, -0.04187806f, -0.10008838f, -0.05983775f, -0.14096117f, -0.06232045f, -0.05992421f, -0.19730018f, 
    -0.01885926f, 0.21311326f, -0.14384009f, 0.11108116f, -0.36261675f, -0.03478912f, 0.08475420f, 0.01875427f, 
    0.00817286f, -0.11490615f, 0.08671768f, 0.17932501f, 0.02653611f, 0.09103916f, -0.03135684f, 0.32166299f, 
    0.44296530f, -0.24581943f, 0.11879926f, 0.69222796f, -0.00534486f, 0.05664709f, 0.00744006f, 0.09813564f, 
    0.07251162f, 0.04636082f, 0.07644554f, -0.06724812f, -0.00840840f, -0.07387753f, 0.25244242f, 0.51270843f, 
    0.00887722f, 0.01325932f, -0.09879442f, 0.04408076f, 0.17440778f, 0.06557524f, -0.05018346f, -0.04982904f, 
    -0.25190744f, 0.61603665f, 0.00362240f, 0.03238774f, -0.09535272f, 0.20096481f, -0.20405397f, 0.04944952f, 
    0.16088483f, -0.01383337f, -0.09959911f, 0.01616240f, 0.45089853f, -0.34315220f, 0.04520868f, 0.13786960f, 
    0.03872993f, -0.11428072f, -0.02791426f, -0.12091786f, -0.05695541f, 0.00567945f, 0.02643340f, -0.09527078f, 
    0.06178628f, -0.16734520f, 0.00722576f, -0.25567043f, -0.08532628f, -0.12625381f, -0.06867772f, -0.12156186f, 
    0.19083273f, 0.16311103f, 0.17846438f, 0.02928088f, -0.10473158f, 0.13254735f, 0.19070977f, -0.17619915f, 
    -0.17752118f, 0.06273427f, -0.01244921f, 0.15118153f, -0.02689037f, 0.03810265f, 0.10028033f, 0.03366465f, 
    -0.09498821f, 0.12989564f, -0.11276616f, 0.21714698f, 0.11734291f, -0.05421313f, -0.02694341f, 0.15804622f, 
    -0.03938280f, -0.18678808f, -0.13129240f, -0.19422404f, -0.27147216f, 0.17484148f, 0.00336555f, 0.00598555f, 
    0.03023486f, -0.10514565f, -0.08073009f, -0.07206653f, 0.01538263f, 0.15637784f, -0.01675376f, 0.15646541f, 
    0.00977915f, 0.33762708f, -0.01713116f, -0.05002676f, 0.01275639f, -0.07103831f, 0.02451857f, -0.06487129f, 
    0.09780275f, -0.02658389f, 0.01120563f, 0.02609022f, 0.15550387f, 0.14282362f, 0.00661407f, 0.29614061f, 
    -0.03014753f, 0.00957430f, -0.01861448f, -0.11094446f, -0.00973245f, -0.02518425f, 0.31965524f, 0.13001078f, 
    -0.33689991f, -0.04594310f, 0.06652705f, 0.09621505f, -0.05059089f, 0.21896681f, 0.10287034f, 0.10569512f, 
    0.07116322f, -0.01244236f, 0.10808474f, 0.13110478f, -0.04146945f, -0.05129038f, -0.01498768f, -0.10264082f, 
    0.11697043f, -0.07044389f, 0.03636490f, -0.04152038f, -0.07273442f, 0.04968724f, 0.02436782f, 0.04374959f, 
    0.12850539f, 0.18066296f, 0.07674041f, 0.07908447f, -0.03998972f, -0.09877470f, 0.08631132f, -0.02115055f, 
    -0.03251240f, 0.00416444f, -0.12357231f, -0.04769118f, 0.67331421f, -0.13953343f, 0.01774971f, 0.12056857f, 
    0.02990983f, -0.04499438f, 0.00958198f, 0.05163436f, 0.12848020f, 0.10808399f, -0.02446160f, -0.04206951f, 
    -0.68190265f, 0.05724458f, -0.05063509f, 0.06996664f, 0.05656536f, 0.03772304f, 0.06628514f, 0.15686513f, 
    0.08135372f, -0.04379894f, 0.21818161f, 0.06548329f, -0.05159320f, 0.06942211f, 0.08325576f, -0.16701816f, 
    0.02376899f, 0.17172489f, 0.00390285f, -0.04288915f, 0.05346370f, 0.06601455f, 0.09992027f, -0.17947313f, 
    -0.31388992f, 0.29413119f, -0.09577470f, -0.19092339f, -0.06219002f, -0.02494813f, -0.03189446f, -0.05921274f, 
    -0.11232472f, -0.01162977f, -0.04155724f, -0.03177729f, -0.44024208f, 0.21288003f, -0.14648114f, -0.47134677f, 
    0.07508731f, -0.09215011f, -0.04847905f, -0.05088514f, -0.05872859f, 0.03882256f, 0.15719017f, -0.08747969f, 
    0.33701679f, -0.19516635f, 0.12104453f, -0.02246520f, -0.01551023f, 0.01669004f, -0.00104775f, 0.20567651f, 
    -0.04889463f, 0.01118008f, -0.03362713f, 0.24826370f, -0.51246798f, 0.15141436f, 0.00327578f, -0.03126829f, 
    0.01060787f, 0.12900287f, -0.02340541f, 0.00125500f, -0.03692939f, -0.03633911f, 0.02371629f, 0.02472025f, 
    -0.31160429f, 0.02710260f, 0.01171430f, 0.07881780f, 0.14097716f, 0.11914628f, 0.00125365f, 0.01427344f, 
    -0.01714422f, -0.03987761f, -0.00238527f, -0.02363163f, -0.01338351f, 0.15047963f, 0.13590072f, 0.03729649f, 
    0.00323326f, 0.00597487f, 0.04797244f, 0.05068011f, 0.04670558f, -0.03722215f, -0.03519975f, -0.00724355f, 
    0.50589895f, 0.06026827f, 0.35381988f, -0.05509434f, -0.01545221f, 0.07832594f, 0.09467600f, -0.04492905f, 
    0.11532808f, 0.08339041f, 0.19697303f, 0.20195560f, 0.27487969f, -0.31880516f, -0.12767538f, 0.01281983f, 
    -0.05259760f, 0.12333021f, 0.03068025f, 0.03692669f, 0.10803299f, -0.06325695f, -0.04529198f, -0.11368730f, 
    0.10642897f, 0.13179846f, 0.14062569f, 0.17630240f, -0.05735887f, 0.03674539f, -0.09053662f, 0.21056347f, 
    0.05042489f, 0.06044589f, 0.16692084f, -0.04225811f, 0.21905178f, 0.03556715f, -0.22054942f, -0.23795938f, 
    -0.11785936f, -0.08126374f, -0.00399662f, 0.07472805f, -0.05440176f, -0.03185868f, -0.22384414f, -0.06005437f, 
    -0.15645155f, 0.08498573f, -0.08056105f, 0.02559635f, 0.01175899f, 0.12093673f, 0.08432536f, 0.02220479f, 
    0.28687796f, -0.02352546f, 0.13897505f, 0.08122608f, 0.01001742f, 0.07727676f, 0.05279525f, -0.35831565f, 
    -0.14106350f, 0.03686606f, 0.10346529f, -0.07724241f, 0.10855652f, 0.03820170f, 0.04174531f, -0.05469473f, 
    0.13366829f, 0.08952557f, -0.08383476f, -0.02201614f, -0.06932740f, -0.10742609f, 0.13467164f, -0.17107774f, 
    0.08071422f, -0.03723353f, -0.08484941f, -0.12328763f, 0.04861455f, -0.26078862f, 0.33116233f, 0.23079032f, 
    -0.00307244f, -0.05203775f, 0.05976673f, -0.04357930f, 0.08678368f, 0.08880685f, -0.02422346f, -0.05743138f, 
    -0.59517986f, 0.00878381f, -0.07345268f, 0.10582642f, 0.02680068f, 0.04502486f, -0.08914533f, 0.15918463f, 
    0.08213182f, 0.07030454f, 0.07099112f, -0.00665651f, 0.11163877f, 0.38656828f, 0.11222783f, -0.03570258f, 
    -0.00506424f, 0.05967248f, 0.04932677f, -0.01076059f, 0.06936248f, 0.02023805f, 0.13188270f, -0.04274033f, 
    0.18882135f, -0.20724289f, -0.03862000f, -0.00725897f, 0.04121881f, 0.05112843f, -0.14083722f, -0.04742599f, 
    0.03011466f, 0.12161337f, -0.09957609f, -0.12371506f, 0.11691727f, -0.24963440f, 0.01512935f, -0.13149513f, 
    -0.00357544f, -0.12966153f, -0.00916631f, 0.00901977f, 0.16287799f, 0.13903062f, -0.10718455f, -0.04108173f, 
    -0.06632622f, 0.07917432f, 0.14245762f, -0.00974921f, 0.07043246f, 0.17242502f, 0.02611143f, 0.16490267f, 
    0.09314442f, -0.08098527f, -0.00998111f, 0.10663067f, -0.22456600f, 0.21066035f, -0.15281282f, -0.02601779f, 
    0.00137914f, 0.07994068f, -0.10239663f, 0.03406272f, -0.09295847f, -0.01179656f, 0.02953547f, 0.14357588f, 
    -0.04769041f, 0.11486346f, -0.18106338f, 0.02645167f, 0.07137934f, 0.12953961f, 0.06677970f, 0.20906065f, 
    0.14421465f, 0.00174158f, -0.05444962f, 0.09612110f, 0.69253099f, -0.03730237f, -0.02210695f, -0.05944572f, 
    -0.15931524f, -0.04650737f, 0.03376553f, -0.08601692f, 0.04865476f, -0.00178656f, 0.10212129f, -0.00939067f, 
    0.67935270f, 0.12536882f, 0.05714434f, -0.06037715f, -0.11090734f, -0.00837587f, 0.03317136f, 0.04858947f, 
    -0.12595400f, 0.02960512f, 0.08057734f, 0.07540164f, -0.15584654f, -0.11748352f, 0.03402736f, 0.05329147f, 
    0.02556888f, 0.02534235f, -0.01015287f, 0.01916204f, -0.06388883f, 0.04659221f, -0.05541572f, -0.06368516f, 
    0.15796536f, -0.18474935f, 0.14011016f, -0.08283672f, -0.08238613f, -0.11731967f, -0.08159170f, 0.09754226f, 
    -0.03807060f, -0.04179395f, -0.02224018f, 0.07695447f, 0.35314518f, -0.21486190f, -0.08347418f, 0.02113174f, 
    -0.05414494f, -0.00774619f, 0.03187139f, -0.11819263f, 0.02394013f, -0.02859623f, -0.02636930f, -0.07855327f, 
    0.01906778f, 0.00648616f, -0.00563582f, -0.02627022f, -0.02070044f, -0.05720001f, -0.00912293f, 0.05846387f, 
    -0.07163040f, 0.04464176f, 0.01844050f, -0.03559840f, -0.00557825f, -0.01787756f, 0.04345034f, -0.07347210f, 
    -0.06673045f, -0.07398119f, -0.06206425f, 0.04696911f, -0.02790101f, -0.04434859f, -0.05791069f, -0.02579682f, 
    -0.05433137f, 0.05401347f, -0.04171375f, -0.01599484f, 0.03639851f, 0.01393937f, 0.03232361f, 0.04174913f, 
    -0.03590782f, -0.02107484f, 0.03130381f, -0.03347962f, -0.00878619f, -0.05120642f, -0.00989201f, 0.06157782f, 
    0.06326813f, 0.04269588f, -0.04706036f, -0.05693229f, -0.06602477f, 0.03312237f, 0.03866272f, 0.00020616f, 
    0.03944433f, -0.02099747f, 0.05685050f, -0.05762139f, -0.01045344f, 0.03858257f, -0.05179435f, 0.01498686f, 
    0.02822445f, -0.02077162f, -0.05726378f, -0.00391154f, -0.05353374f, -0.04227829f, 0.02488818f, 0.06026535f, 
    0.04808410f, 0.05264118f, 0.01960257f, 0.03364338f, -0.00363703f, -0.03582523f, 0.01656012f, 0.03442969f, 
    -0.02613322f, 0.01609541f, -0.06633359f, -0.04450527f, -0.06777471f, 0.05908458f, 0.04186617f, -0.01933516f, 
    -0.02289341f, 0.06305862f, -0.07266027f, 0.06608639f, 0.02627209f, 0.03399982f, -0.06151012f, 0.01892031f, 
    -0.06638780f, -0.07731529f, -0.07310749f, -0.01959186f, 0.02791429f, -0.07612573f, 0.05076527f, -0.00952424f, 
    -0.07761160f, -0.03485776f, -0.03004220f, -0.00462592f, -0.06826146f, -0.02659910f, 0.00879665f, -0.03869338f, 
    0.05272865f, 0.06258950f, 0.03028492f, 0.05095604f, 0.00687462f, 0.04677666f, -0.07193160f, 0.03058739f, 
    -0.02436553f, 0.05731126f, 0.00841107f, -0.01702294f, -0.02905520f, 0.03352216f, 0.00022186f, -0.05073850f, 
    -0.03270473f, 0.00462156f, -0.07642044f, -0.05881658f, 0.05728570f, 0.00794091f, -0.01655287f, -0.03867896f, 
    -0.04319146f, 0.01629823f, 0.03789050f, 0.05772993f, 0.02084436f, -0.02254892f, 0.06366332f, -0.06348665f, 
    -0.02005857f, -0.07454310f, -0.00414578f, 0.03904369f, -0.05975175f, -0.03878003f, 0.05514729f, -0.05890419f, 
    0.05673525f, -0.02363557f, -0.06764050f, -0.03502773f, -0.04205995f, -0.02800499f, -0.00395200f, -0.05939455f, 
    -0.00201279f, -0.03635919f, -0.04123322f, -0.00345670f, 0.01698012f, -0.04973867f, -0.02344406f, -0.05631844f, 
    -0.01681230f, -0.06192736f, -0.04820624f, 0.01674490f, 0.04731034f, -0.06136543f, -0.03856261f, -0.03254386f, 
    0.02291971f, -0.06825079f, -0.06650157f, -0.04724773f, 0.01760438f, -0.05830580f, 0.00135487f, -0.01919104f, 
    -0.07686702f, -0.04126161f, -0.00857466f, 0.02184411f, -0.04161634f, -0.07031697f, -0.04909869f, -0.06613495f, 
    -0.01937893f, 0.01054396f, 0.03700039f, 0.06587940f, 0.03652934f, 0.04872189f, 0.06607633f, -0.04462528f, 
    -0.04054552f, 0.04886434f, -0.03472945f, -0.06846818f, -0.05229789f, -0.04256379f, 0.02239724f, -0.06973001f, 
    0.01290492f, 0.03311609f, 0.01068384f, 0.04649462f, -0.07325536f, -0.07173103f, -0.02739800f, 0.02565804f, 
    -0.01926311f, 0.03189161f, -0.07122631f, 0.03311787f, -0.07486121f, -0.02525513f, -0.02629983f, -0.02332707f, 
    0.04834978f, -0.04040240f, -0.00444739f, 0.03135729f, 0.00116877f, -0.03148236f, -0.05813096f, -0.06294594f, 
    -0.01535796f, 0.04048912f, 0.00079964f, 0.01374711f, -0.07012659f, 0.04656639f, 0.04123082f, -0.07182592f, 
    -0.03733720f, -0.04789607f, -0.03696074f, 0.06350290f, -0.02946588f, -0.06421822f, -0.07424767f, -0.01158563f, 
    -0.06718844f, 0.00979955f, -0.04622903f, 0.04961077f, 0.05287039f, -0.01482375f, 0.05614161f, -0.07638863f, 
    -0.01742387f, -0.05930990f, -0.00232956f, 0.05744281f, 0.01094757f, -0.00902450f, 0.00747156f, 0.06099588f, 
    0.03412020f, -0.05875291f, 0.01018160f, -0.04200052f, -0.00607942f, -0.04628334f, -0.02776297f, 0.05335287f, 
    -0.00480211f, 0.06229812f, -0.04608523f, -0.04288865f, -0.05974932f, -0.03252209f, 0.03977527f, -0.00712162f, 
    -0.02516178f, -0.00303168f, -0.03804035f, 0.00403384f, -0.00960856f, 0.04523902f, 0.03770711f, 0.05315099f, 
    -0.00785064f, 0.04780040f, 0.00786775f, -0.01328257f, -0.01512359f, -0.04254362f, -0.06003331f, -0.01839253f, 
    -0.03116277f, -0.02435916f, 0.00612585f, -0.00309860f, -0.00050119f, 0.03883525f, -0.01746270f, -0.00121251f, 
    0.01242364f, -0.04795892f, -0.01730415f, -0.05293632f, -0.01818132f, 0.05637635f, -0.00870616f, 0.06011391f, 
    -0.05621491f, 0.01516243f, -0.03088005f, 0.02647687f, -0.06340440f, -0.01861604f, -0.03278628f, 0.05188274f, 
    -0.06432195f, 0.00024062f, 0.02717995f, 0.03536764f, -0.03590903f, -0.07167739f, -0.00486571f, -0.06742661f, 
    -0.03186549f, 0.05548983f, -0.01479815f, -0.05206674f, 0.06040377f, -0.01337657f, 0.02189745f, 0.02783258f, 
    -0.04249404f, 0.03755931f, 0.01211150f, 0.00520651f, 0.05628746f, 0.01713917f, -0.07487158f, -0.00914168f, 
    -0.01757564f, -0.03235367f, -0.04673522f, -0.01775230f, -0.04786385f, 0.01383955f, -0.07007098f, -0.00917475f, 
    0.01349338f, -0.04201235f, 0.02185656f, -0.01793483f, -0.00561917f, -0.07572144f, 0.02530465f, -0.07522794f, 
    0.03155813f, 0.02787560f, -0.03800962f, -0.03805533f, -0.04336063f, -0.00642417f, -0.06454302f, 0.00059443f, 
    -0.01246414f, 0.05060342f, -0.05432020f, 0.05741828f, 0.03954505f, 0.01665120f, -0.05776882f, -0.06713567f, 
    -0.04752525f, 0.03475016f, -0.00531410f, -0.02068708f, -0.05013632f, 0.01645443f, 0.03070333f, 0.03456873f, 
    0.01344484f, -0.02322868f, -0.06037393f, 0.03503758f, -0.03607019f, 0.05107252f, -0.04637891f, 0.04465776f, 
    0.39917216f, 0.10432342f, 0.24575406f, 0.24318865f, -0.00460823f, 0.03609959f, -0.12288059f, -0.08027161f, 
    -0.04616447f, 0.05791483f, 0.01885411f, 0.09585311f, 0.15106288f, 0.02099051f, -0.05170115f, 0.10651708f, 
    0.05441082f, 0.12840408f, -0.00595733f, 0.20139593f, -0.16167520f, 0.02734151f, 0.07588119f, -0.12096948f, 
    -0.12764265f, -0.25522605f, 0.13255490f, -0.13622828f, 0.06404855f, 0.03899989f, -0.01860059f, 0.08134881f, 
    -0.03132228f, -0.02297433f, 0.02944687f, -0.01009170f, -0.37815395f, 0.33769995f, -0.04674301f, -0.09209360f, 
    0.02922473f, 0.02726380f, 0.08358835f, 0.15954752f, -0.15358311f, -0.08209399f, 0.02046055f, 0.10363431f, 
    -0.01485853f, 0.01933183f, -0.02757541f, -0.06148517f, 0.04180513f, 0.13294531f, -0.05473859f, -0.16809624f, 
    0.04305816f, 0.19549936f, -0.08915824f, -0.04294349f, -0.60862070f, -0.01078532f, -0.06440505f, 0.11097638f, 
    -0.05890793f, -0.09296349f, -0.00882776f, 0.05084748f, 0.11732189f, 0.09746775f, -0.21549080f, 0.02999814f, 
    0.02119074f, 0.05381282f, -0.04432840f, -0.02377750f, -0.00430707f, 0.04763032f, 0.12215815f, 0.09731419f, 
    0.02324912f, -0.02371887f, 0.00713084f, 0.12750888f, -0.04136045f, 0.12714407f, 0.15448001f, 0.08599217f, 
    -0.09161963f, 0.05092264f, 0.06922748f, 0.06049434f, 0.02002098f, 0.02088415f, 0.02163761f, 0.11695289f, 
    -0.39150152f, 0.22438775f, 0.05041379f, -0.09560139f, -0.08360603f, 0.15518841f, 0.00882651f, -0.08773965f, 
    -0.04720633f, -0.01368595f, 0.08374856f, 0.02530130f, 0.19050804f, -0.23902738f, -0.06059434f, 0.03901766f, 
    -0.03751893f, 0.19467759f, -0.00347683f, -0.07311751f, 0.18350348f, 0.08541314f, 0.03057015f, 0.04593959f, 
    0.03675609f, -0.12973049f, 0.07537933f, -0.12510400f, -0.02005540f, 0.04109296f, -0.02150495f, -0.09702560f, 
    0.06448321f, 0.07791778f, 0.11886089f, -0.01726091f, -0.52757752f, 0.32536855f, 0.05006826f, 0.06789385f, 
    -0.08198749f, 0.05461428f, 0.07635804f, -0.01640553f, 0.06564403f, 0.07016147f, 0.09255215f, -0.05716310f, 
    -0.23551817f, 0.23094374f, -0.02324887f, 0.08228718f, 0.20293815f, -0.06308358f, -0.03010478f, 0.02994855f, 
    0.12740849f, -0.12432984f, 0.06717329f, -0.10146708f, -0.12260571f, 0.09010804f, 0.36090934f, 0.13678038f, 
    0.04917794f, -0.03734567f, 0.02512060f, 0.05683221f, 0.07650347f, -0.06692945f, 0.05503689f, 0.01817726f, 
    -0.18761876f, 0.21580650f, -0.14347129f, -0.20956726f, 0.03505590f, -0.12651087f, 0.04001584f, -0.23660702f, 
    0.08200839f, 0.07507141f, 0.04668929f, -0.01499171f, -0.12323320f, 0.01962332f, 0.36080137f, 0.09693038f, 
    -0.05712803f, 0.03581543f, 0.04427774f, 0.03440320f, 0.00814719f, -0.00683111f, 0.16196369f, 0.10782155f, 
    0.13162935f, 0.19192150f, -0.10105996f, 0.09459513f, -0.10759707f, 0.11094033f, 0.06025379f, 0.05506228f, 
    0.07326180f, 0.18164684f, -0.00625792f, 0.07062711f, 0.01455754f, 0.24434409f, 0.15776731f, 0.21486205f, 
    0.00591521f, -0.15014744f, -0.15635134f, -0.01242424f, 0.07204357f, -0.14320110f, -0.06325019f, 0.05520015f, 
    -0.13068321f, 0.27286813f, 0.14627704f, 0.30034667f, -0.17929338f, 0.08114430f, -0.15260650f, 0.16107965f, 
    -0.17256366f, 0.11155872f, -0.00240078f, 0.04043732f, 0.24626604f, -0.23833846f, 0.07525954f, -0.14099237f, 
    0.10188743f, -0.11377408f, 0.04319145f, 0.02430592f, 0.06381525f, 0.15487911f, -0.06719266f, 0.08969547f, 
    0.22411418f, -0.13253187f, -0.18888687f, 0.10860450f, 0.06172555f, 0.14906563f, -0.00658781f, 0.05646473f, 
    0.04174443f, -0.04632586f, 0.01625420f, -0.06846509f, 0.41015115f, 0.37384167f, 0.02547629f, 0.01164709f, 
    -0.06472840f, 0.02750046f, 0.09046088f, -0.05938896f, 0.14388160f, -0.03424345f, 0.08742138f, -0.02363418f, 
    0.06179744f, -0.04536159f, -0.16794574f, 0.00264247f, 0.06322885f, -0.07917181f, 0.02780383f, -0.03258500f, 
    0.06515400f, 0.03406183f, 0.01762563f, -0.09820520f, -0.17565808f, -0.08654180f, -0.30045068f, -0.04997327f, 
    0.08084839f, 0.03866095f, -0.09604868f, -0.15982668f, -0.07342780f, -0.14299168f, 0.16498597f, -0.05652950f, 
    -0.11327493f, -0.00823888f, 0.24584229f, 0.22366330f, -0.14108060f, -0.18592814f, 0.06445748f, 0.13705151f, 
    -0.11152173f, 0.08270483f, 0.05786265f, 0.00566010f, 0.01360709f, -0.32090884f, -0.17393501f, -0.14628834f, 
    0.07363270f, 0.08982882f, 0.00466727f, -0.07888796f, 0.17845400f, 0.03771581f, 0.03145662f, 0.18704371f, 
    -0.31799591f, -0.29970324f, -0.21176660f, 0.25017333f, 0.07841840f, 0.05450644f, -0.09174768f, -0.00459545f, 
    0.08657044f, 0.07826439f, 0.02011896f, -0.02776077f, 0.18587519f, -0.01267687f, 0.16615456f, 0.00354811f, 
    0.11385968f, 0.11876616f, 0.19682857f, 0.01826724f, -0.12352119f, 0.04649903f, -0.15395623f, 0.03759294f, 
    -0.21934387f, 0.13354138f, 0.15413605f, 0.27939680f, -0.00219165f, 0.05902740f, 0.07403759f, 0.05145799f, 
    -0.01631745f, -0.03509565f, 0.00443518f, -0.01765532f, -0.01837786f, 0.20356631f, 0.20397852f, -0.05237082f, 
    0.05178421f, 0.01392336f, 0.05231820f, -0.05329524f, -0.07693851f, 0.05554630f, 0.09862987f, 0.02487001f, 
    0.11346465f, -0.02384310f, -0.23605902f, 0.33612588f, 0.13643797f, 0.06087823f, 0.16298717f, -0.01659245f, 
    -0.12118884f, -0.07931569f, 0.18176407f, 0.07877833f, -0.54068708f, -0.36181453f, 0.17374648f, -0.19477977f, 
    0.27132693f, -0.04213810f, -0.07598361f, -0.06621583f, 0.03552463f, -0.02687578f, -0.07055016f, -0.12612200f, 
    0.43154404f, 0.03299765f, 0.09244402f, 0.11785007f, 0.10913965f, 0.00145840f, 0.08777826f, 0.01822128f, 
    -0.00593414f, 0.07833364f, 0.10468006f, 0.07684346f, 0.00346027f, -0.05187775f, -0.13634920f, -0.06504968f, 
    0.02836842f, -0.10037623f, 0.00611180f, 0.15534069f, 0.09458623f, 0.21661143f, 0.08553024f, 0.07904451f, 
    -0.15286598f, -0.14722529f, 0.13558900f, -0.08172540f, 0.34582633f, -0.09820596f, 0.21917427f, -0.12743385f, 
    -0.12667081f, 0.06925873f, 0.04636207f, 0.42201447f, -0.18528205f, 0.06519485f, 0.05373541f, -0.16301751f, 
    -0.20316964f, 0.10551306f, -0.05673128f, -0.01860638f, 0.02676466f, 0.01367991f, 0.05095243f, 0.05240799f, 
    0.16649690f, -0.16858563f, -0.01918982f, 0.05330084f, -0.18644774f, -0.02493258f, -0.08460586f, 0.10129669f, 
    -0.14301635f, 0.07642988f, 0.02240800f, -0.12697060f, -0.09685093f, -0.11197165f, -0.01798657f, 0.04591246f, 
    -0.07421728f, -0.17008354f, 0.23088355f, 0.12106771f, -0.02622048f, -0.05725927f, -0.25943482f, -0.14640102f, 
    0.55588853f, -0.05660157f, 0.11095574f, 0.33386660f, -0.14794214f, 0.14776343f, -0.06621680f, 0.09492729f, 
    0.01549635f, 0.12597407f, -0.30607599f, 0.03699547f, 0.22863735f, -0.06290136f, 0.14744027f, 0.09106062f, 
    -0.09129317f, -0.01044316f, -0.02607490f, 0.23784797f, 0.02159056f, -0.04083227f, -0.05927427f, 0.01600233f, 
    -0.26980820f, 0.12340543f, 0.02388340f, 0.07141167f, -0.05525816f, 0.18917963f, 0.18564224f, -0.01274258f, 
    0.06093202f, -0.05588542f, 0.02536326f, 0.27403429f, 0.29512578f, 0.06681404f, 0.06127725f, 0.04454021f, 
    -0.26827604f, -0.18783167f, 0.16572623f, 0.20226574f, 0.00073601f, 0.16640337f, 0.18095580f, 0.02719836f, 
    0.03450735f, -0.14219241f, 0.03220328f, -0.36446029f, -0.03869411f, 0.01010562f, 0.16077328f, -0.08857405f, 
    -0.03239934f, -0.34213027f, -0.09460478f, 0.07107454f, 0.04753007f, -0.17195325f, 0.18505077f, -0.20117469f, 
    -0.04316254f, 0.00003784f, 0.02909607f, 0.09133153f, 0.12765780f, 0.02022207f, -0.09970453f, -0.03442241f, 
    0.02827356f, 0.00359481f, -0.00284013f, -0.04036648f, 0.05809023f, -0.00505093f, -0.14097510f, 0.07933293f, 
    -0.05279599f, -0.06261011f, 0.10848805f, -0.02127957f, -0.16181965f, 0.20607057f, -0.00731655f, 0.31452215f, 
    -0.01966768f, -0.10822328f, -0.06451464f, 0.04567169f, -0.05843496f, -0.00916207f, -0.15344952f, -0.17748192f, 
    -0.22707023f, 0.06017420f, 0.06960636f, -0.16794391f, -0.00995297f, 0.03091297f, 0.13982745f, 0.05184745f, 
    0.09165988f, 0.04970042f, 0.29207361f, 0.09020828f, 0.30524623f, 0.27774939f, 0.34884265f, 0.01097473f, 
    0.06886391f, 0.02227832f, 0.00204040f, 0.05320898f, -0.08371842f, -0.06932124f, -0.15169680f, -0.07411399f, 
    -0.00686043f, -0.01131952f, 0.02733432f, -0.01632990f, -0.08701099f, -0.11750155f, 0.03255779f, -0.00938576f, 
    -0.03377325f, -0.07745076f, 0.00775880f, -0.06558640f, -0.02969092f, -0.02385658f, -0.02136364f, 0.00138553f, 
    -0.07547890f, -0.07765651f, -0.06424244f, 0.02296380f, -0.03468352f, -0.08432196f, -0.05064645f, -0.02132781f, 
    -0.02133180f, 0.00470184f, -0.10511852f, 0.05855272f, -0.00296710f, -0.07427701f, 0.05360736f, -0.08092338f, 
    -0.04137280f, 0.03133403f, 0.00584280f, -0.10105396f, 0.00467802f, 0.04609475f, 0.02116875f, 0.05993432f, 
    -0.07382409f, -0.02560028f, -0.03132191f, 0.00599153f, -0.06396095f, -0.02636097f, 0.03423512f, -0.07413402f, 
    -0.04246052f, 0.01347284f, 0.04344121f, -0.06291033f, 0.02626201f, 0.05601229f, 0.04350642f, 0.02043447f, 
    -0.03040988f, -0.07235583f, -0.08933978f, -0.05830685f, -0.07464688f, -0.03375602f, -0.06855956f, -0.07627803f, 
    -0.03153974f, -0.07764247f, -0.10410374f, 0.02470965f, 0.04628213f, 0.00267378f, 0.01398994f, -0.02510042f, 
    -0.09027570f, -0.09934740f, -0.06221402f, 0.04274558f, 0.00662822f, 0.00791676f, 0.04967592f, -0.09233212f, 
    -0.04202775f, -0.07555120f, -0.01617030f, 0.03958960f, -0.08156042f, -0.07571353f, -0.08197101f, -0.07559235f, 
    -0.05643604f, 0.01211640f, -0.05968001f, 0.03446682f, -0.04122667f, -0.00306608f, -0.05773102f, 0.04020150f, 
    -0.08563954f, 0.03779428f, 0.03720720f, -0.00704770f, -0.05623937f, 0.01280489f, -0.08609335f, -0.05939484f, 
    0.02222413f, 0.02882746f, 0.03211439f, -0.05730398f, -0.11230443f, -0.12152763f, -0.05821214f, 0.01232357f, 
    0.04986743f, -0.02295813f, -0.06865153f, 0.03239080f, -0.08179874f, -0.08038631f, -0.00868830f, 0.00567498f, 
    0.04553059f, -0.02756024f, 0.02434174f, -0.05240263f, -0.01802108f, -0.00534014f, -0.06979932f, 0.00130632f, 
    0.02631325f, 0.04155377f, 0.00714013f, -0.01566444f, -0.04902134f, 0.01920435f, -0.01035516f, -0.03567562f, 
    -0.01359170f, 0.02037648f, 0.03742935f, 0.04928938f, -0.05592540f, 0.03191207f, -0.04439467f, -0.06844920f, 
    0.04564203f, 0.05665423f, 0.00562193f, -0.05532959f, -0.05738724f, 0.01593522f, 0.00636869f, -0.01734134f, 
    -0.08038594f, 0.05442974f, -0.11812256f, -0.02804073f, 0.02437187f, -0.07130280f, 0.06243693f, 0.03751273f, 
    -0.04810305f, -0.03116009f, 0.01633835f, 0.06675625f, 0.06853496f, -0.08688039f, -0.06032934f, 0.02994323f, 
    -0.06763634f, 0.02147021f, 0.01269898f, -0.00804191f, -0.07624476f, -0.07724919f, -0.00323747f, 0.01282713f, 
    0.04599900f, 0.02840541f, -0.10559520f, -0.03703264f, -0.00117646f, 0.04512297f, 0.01158515f, 0.03744335f, 
    -0.09215525f, -0.02223968f, -0.03378611f, -0.06832206f, -0.03657981f, -0.00172911f, -0.03109546f, 0.02991355f, 
    -0.05393512f, -0.07878679f, -0.01895502f, -0.05001470f, -0.05198505f, -0.07203034f, -0.05972471f, -0.03458444f, 
    -0.07178312f, -0.06102419f, 0.06005670f, 0.02004174f, -0.01696984f, -0.01022200f, -0.03668714f, -0.04183414f, 
    -0.06547578f, -0.07632513f, 0.02405363f, 0.06086515f, 0.01839104f, -0.00446944f, 0.02161042f, 0.03462907f, 
    0.00355575f, 0.03349794f, 0.01655583f, -0.00018066f, 0.03394165f, 0.00664366f, -0.03883239f, 0.00460659f, 
    0.06186955f, -0.00793800f, 0.05942524f, -0.00142010f, -0.01982605f, -0.06106259f, 0.05590855f, 0.04002928f, 
    0.03758805f, 0.04975487f, 0.04146783f, -0.01248955f, 0.02883985f, -0.03811097f, -0.01631235f, -0.04847731f, 
    -0.00474626f, 0.04852133f, 0.03113415f, -0.03843506f, 0.05254243f, -0.03631867f, 0.01620043f, 0.01979101f, 
    -0.07309037f, 0.02297985f, -0.03918493f, -0.00271847f, -0.07600350f, -0.04097756f, -0.04726337f, 0.03432732f, 
    0.06103361f, -0.03300442f, -0.05799259f, -0.03604911f, -0.01116575f, -0.00650242f, -0.06001945f, -0.00761342f, 
    0.05207365f, -0.02215287f, -0.01648208f, -0.01250106f, -0.06239063f, 0.04977556f, -0.05714004f, 0.01440774f, 
    0.02895617f, 0.05263374f, 0.04079306f, 0.03165242f, -0.07119255f, -0.04480624f, -0.04903979f, -0.02528858f, 
    -0.06487647f, 0.03320686f, -0.04488443f, -0.07119733f, -0.07142463f, 0.01039477f, 0.06643273f, 0.05698763f, 
    -0.02921115f, -0.06595522f, -0.03046198f, -0.05070966f, 0.05389366f, -0.07030396f, -0.03890599f, 0.03841612f, 
    -0.06212192f, -0.04889887f, -0.05474499f, 0.00201401f, -0.06703310f, -0.00698379f, -0.07218694f, -0.03058640f, 
    0.04597054f, 0.05107613f, -0.01126540f, -0.07284337f, 0.00529675f, -0.03861362f, -0.04555489f, -0.03853153f, 
    -0.07242038f, 0.01774086f, -0.00861604f, -0.01988990f, 0.05610014f, 0.03883588f, -0.02869894f, -0.03958727f, 
    0.02094700f, -0.01612853f, 0.06092085f, -0.03668765f, -0.06173492f, -0.03781024f, -0.03216757f, 0.02853126f, 
    -0.04579952f, -0.01030351f, -0.04400652f, 0.01857807f, 0.06170722f, -0.03208799f, 0.00210910f, -0.00272412f, 
    0.03419515f, 0.06355017f, 0.04513642f, 0.06318855f, 0.05427291f, -0.05518389f, -0.03517317f, 0.04539350f, 
    -0.02814796f, 0.05295141f, -0.07200179f, -0.06813067f, 0.05500701f, 0.04690563f, -0.04041924f, -0.06439620f, 
    0.04993285f, 0.05732848f, 0.02894954f, 0.05050858f, 0.02605733f, 0.01462489f, 0.04157364f, -0.07443938f, 
    0.05163556f, -0.08173060f, 0.01034573f, 0.02594654f, 0.04747314f, -0.05489204f, 0.02098888f, -0.04666869f, 
    0.02019978f, -0.03460050f, -0.00642928f, 0.03706289f, 0.05735689f, -0.03805883f, 0.00706885f, -0.02882049f, 
    -0.06792379f, -0.00541331f, -0.01134716f, -0.05841675f, -0.06883695f, -0.07084025f, -0.06909180f, -0.03814679f, 
    0.03410125f, 0.04676805f, 0.02871477f, -0.03013453f, -0.03352494f, -0.05475432f, -0.07130178f, -0.03887624f, 
    -0.02460873f, -0.03307396f, -0.06711416f, 0.00690195f, 0.03439214f, 0.00451196f, -0.05166782f, 0.04982293f, 
    0.06363896f, -0.02357267f, 0.06047352f, -0.05523603f, 0.06458306f, -0.02646578f, 0.06434666f, -0.02609874f, 
    0.02748943f, -0.02038733f, 0.02873927f, -0.05993894f, -0.05601306f, 0.03921873f, 0.05358522f, -0.04023572f, 
    -0.01516979f, -0.06795724f, 0.02634456f, 0.02604408f, -0.05385079f, 0.04829015f, 0.01227668f, 0.00157162f, 
    -0.02282573f, -0.03417336f, -0.03521710f, 0.01597677f, -0.07110938f, 0.05329071f, -0.00416005f, 0.06141978f, 
    -0.01418254f, -0.07156389f, 0.02089683f, -0.06493619f, -0.02759893f, 0.03894870f, -0.02694058f, -0.06402352f, 
    0.05837371f, 0.00659098f, 0.04088750f, 0.03821001f, 0.07378276f, -0.00100005f, -0.04554089f, -0.06035752f, 
    -0.05353184f, 0.00799723f, 0.03846160f, -0.03732394f, -0.02287688f, -0.05280340f, -0.06607641f, -0.01573869f, 
    0.04063709f, -0.00041625f, -0.03609349f, -0.01696250f, -0.00184242f, 0.00988034f, 0.02837632f, -0.01793515f, 
    -0.06605957f, 0.06551176f, 0.00024505f, 0.00392302f, -0.03676777f, -0.05669234f, 0.06492338f, -0.01474998f, 
    -0.03050659f, 0.00869842f, -0.06343081f, -0.03262022f, -0.01214128f, -0.05988924f, -0.06755570f, -0.01395003f, 
    0.00411772f, -0.04172095f, 0.00119898f, -0.05034479f, -0.01413329f, 0.04816006f, 0.02177034f, -0.01260397f, 
    -0.03689846f, -0.03767096f, 0.00984669f, 0.05966613f, -0.02943382f, -0.07537761f, 0.02552163f, 0.00451612f, 
    -0.02000949f, 0.03130671f, 0.05885559f, -0.01815706f, -0.06316304f, -0.04563799f, -0.04423881f, -0.01351442f, 
    0.02331407f, -0.01228602f, -0.07444008f, 0.01798176f, -0.00579760f, -0.02588029f, 0.04388298f, 0.01638653f, 
    -0.00814254f, 0.05353918f, 0.01175457f, 0.00175706f, -0.04324911f, -0.01620192f, -0.01150433f, 0.03028406f, 
    -0.03131739f, 0.05606013f, 0.04307995f, -0.05243425f, -0.04610255f, 0.00608441f, -0.06594183f, -0.01004587f, 
    0.00156535f, -0.06721393f, -0.07674906f, 0.06243175f, -0.02588554f, 0.04153812f, -0.07391252f, -0.04442469f, 
    -0.00626036f, 0.00275219f, 0.02692450f, 0.01795641f, 0.00281319f, -0.00231527f, 0.02507388f, -0.06112015f, 
    -0.07296015f, 0.03458298f, -0.04969965f, -0.00682183f, 0.05682889f, -0.04831709f, 0.05345158f, -0.04428956f, 
    0.06379348f, -0.00260891f, 0.06936641f, -0.03994184f, -0.04989176f, -0.06636076f, 0.00330068f, -0.01485716f, 
    0.02517422f, 0.04395287f, 0.04742184f, -0.00640880f, 0.02075917f, 0.03586101f, -0.03136651f, 0.00644727f, 
    0.02593117f, 0.04066983f, -0.01936899f, -0.04610576f, -0.04362030f, -0.05773969f, -0.01102397f, 0.05094670f, 
    -0.01425095f, -0.46625495f, -0.16973792f, -0.40146086f, -0.01360043f, -0.07988064f, -0.00950606f, 0.06608191f, 
    -0.07397325f, -0.07147700f, -0.15979415f, -0.13595158f, -0.31912029f, -0.12999830f, 0.22873504f, 0.00892805f, 
    0.06642704f, 0.05766108f, -0.01723856f, 0.13596098f, -0.05900399f, 0.07673730f, -0.13010357f, -0.00808206f, 
    0.03500667f, -0.07064311f, 0.18818192f, -0.14342164f, 0.27219528f, 0.06635152f, -0.11663435f, 0.00606213f, 
    0.18209818f, -0.16333160f, 0.03487281f, 0.13044475f, 0.11467136f, -0.16791724f, -0.06214925f, -0.07627890f, 
    -0.19787319f, -0.00673357f, 0.10491734f, 0.00899934f, 0.02758308f, 0.07050413f, -0.00017665f, -0.16558726f, 
    0.76215911f, 0.07944677f, 0.02744259f, 0.09278009f, -0.27228630f, -0.28791845f, 0.01589342f, -0.13252546f, 
    -0.09199648f, 0.08345338f, -0.15393578f, 0.02346246f, 0.22905017f, -0.04090627f, 0.15542290f, 0.00281957f, 
    0.01012309f, 0.10033547f, 0.13250014f, 0.15721224f, -0.01649539f, -0.08830991f, -0.03791748f, 0.20621556f, 
    0.22637835f, 0.10147183f, 0.22643200f, 0.43432328f, -0.09958499f, 0.07938029f, -0.09739029f, -0.01734718f, 
    -0.23417261f, 0.17990398f, 0.13517863f, -0.21907283f, 0.19914748f, 0.08413339f, 0.29677814f, 0.31196150f, 
    -0.05033991f, 0.08125246f, -0.01594761f, 0.02865075f, -0.01306033f, -0.00795383f, -0.00479428f, 0.07217883f, 
    0.18390660f, -0.12609185f, 0.08153860f, -0.08345925f, 0.01701191f, 0.14305539f, -0.12649943f, 0.00771505f, 
    0.19192052f, -0.16055992f, 0.05883449f, 0.12433691f, 0.25595382f, 0.29085165f, 0.03075391f, 0.19554846f, 
    -0.01329134f, 0.01740916f, 0.10695224f, 0.00208853f, -0.16388857f, 0.02718724f, -0.05540828f, -0.02198395f, 
    0.10550786f, 0.05458505f, 0.14066714f, -0.18320280f, 0.00552427f, -0.18671200f, 0.06887377f, -0.01270611f, 
    -0.10354445f, 0.00444782f, 0.05319701f, 0.02168918f, -0.01544252f, 0.05919083f, -0.04617010f, -0.21240444f, 
    -0.04027385f, -0.15278320f, -0.18209858f, 0.24754216f, -0.08669833f, 0.06626509f, -0.13860513f, 0.01890000f, 
    0.32120845f, -0.09152482f, 0.04881349f, 0.10626502f, -0.10043577f, 0.01614651f, 0.05108509f, -0.01593764f, 
    -0.12051264f, -0.10498376f, -0.02259556f, 0.03514574f, 0.19367155f, -0.23894568f, -0.35196990f, -0.11522482f, 
    -0.02185192f, 0.19293432f, -0.15261912f, -0.04945350f, -0.08245796f, 0.17526451f, -0.05556763f, 0.08975363f, 
    0.27905342f, -0.18547311f, 0.25265482f, 0.06459012f, -0.16419293f, 0.04325124f, -0.18747880f, 0.00757898f, 
    0.00621239f, 0.00117525f, -0.10790754f, 0.15401144f, 0.56454140f, 0.26274410f, -0.10529625f, 0.18744364f, 
    0.01416884f, 0.08950624f, 0.09365025f, -0.01263356f, -0.03464690f, 0.07265544f, 0.14035568f, 0.06144074f, 
    0.23087402f, -0.00657166f, 0.11644150f, 0.16133185f, -0.24529639f, 0.04698479f, -0.11049572f, -0.21634001f, 
    -0.29001594f, 0.14221364f, -0.13806869f, 0.10076968f, 0.43507424f, 0.31363669f, 0.33636647f, 0.37291479f, 
    0.00155867f, 0.00623166f, 0.02887764f, 0.02668568f, -0.17899066f, 0.08226272f, 0.14072956f, 0.11484336f, 
    0.24109456f, -0.02080580f, 0.26777786f, 0.19827987f, -0.17889799f, 0.18864132f, 0.00418848f, 0.01030651f, 
    0.05407170f, -0.02339213f, 0.07237521f, -0.14635620f, -0.13957755f, -0.01872879f, -0.03799068f, -0.06799938f, 
    -0.12904632f, -0.11437406f, 0.03876219f, 0.15984882f, -0.15121277f, -0.05829187f, 0.02742706f, -0.02221110f, 
    0.22346696f, -0.04584825f, 0.06152938f, -0.03664450f, -0.04959017f, 0.11458638f, 0.04688363f, -0.18022801f, 
    0.08155478f, -0.05021524f, -0.14304800f, -0.00249108f, 0.15634692f, 0.13141599f, 0.03259100f, 0.10220956f, 
    0.00982445f, 0.12124290f, -0.04773458f, 0.03942068f, -0.01727679f, 0.10406538f, -0.14275227f, 0.15328766f, 
    -0.40615603f, -0.01683670f, -0.19095318f, -0.05501936f, 0.00691975f, -0.10893492f, 0.03978533f, 0.16461061f, 
    -0.06527706f, -0.14571577f, 0.13652705f, -0.17646223f, -0.33356205f, 0.14471211f, -0.15734978f, -0.16223554f, 
    -0.10420648f, 0.02821241f, 0.03269693f, 0.06989210f, -0.05869347f, -0.02297835f, 0.04953057f, -0.04775612f, 
    0.05050757f, 0.14457078f, 0.09477197f, 0.07491685f, -0.04506027f, 0.04013667f, 0.01066517f, -0.01151998f, 
    -0.04964351f, 0.05230782f, -0.04317532f, -0.05153564f, -0.08903284f, -0.36528438f, -0.00282104f, -0.01245330f, 
    -0.07662041f, 0.15653299f, -0.04858611f, -0.05848137f, 0.07411688f, -0.00013303f, -0.05356509f, 0.07917361f, 
    -0.02139021f, -0.15885320f, 0.18300141f, 0.09389511f, -0.14411490f, -0.12226778f, -0.11751852f, -0.18513887f, 
    0.10250638f, 0.10064878f, -0.04537937f, -0.02545740f, -0.19456576f, 0.33821744f, 0.02861512f, 0.32906148f, 
    0.01134028f, 0.09228054f, 0.09703817f, 0.20763525f, -0.08216453f, 0.05277537f, -0.02087484f, -0.06930240f, 
    0.04267814f, 0.18527801f, 0.07571796f, 0.21422940f, -0.00824768f, -0.02431582f, 0.06992581f, 0.05352543f, 
    0.07022101f, -0.03256685f, -0.05300833f, -0.01635979f, 0.19876419f, 0.09962215f, 0.23913556f, 0.01296637f, 
    -0.11970036f, -0.02368496f, -0.03099401f, -0.01631986f, -0.02265692f, -0.01106500f, -0.00757732f, 0.03470076f, 
    0.14760506f, -0.24996641f, -0.12308010f, 0.03199633f, 0.14676733f, -0.04612628f, 0.06168082f, 0.03593058f, 
    0.14933559f, -0.06085870f, 0.04008413f, -0.03858335f, -0.22546656f, 0.01260253f, 0.10362487f, -0.17190175f, 
    -0.05661615f, 0.01291818f, -0.08725852f, 0.09254283f, -0.01465363f, -0.03044225f, 0.00766242f, -0.13693932f, 
    -0.08386033f, -0.05302802f, 0.16119701f, 0.13190208f, -0.08060167f, 0.01402402f, 0.13006115f, -0.06407815f, 
    -0.15921569f, 0.03155454f, -0.00798700f, 0.07080873f, 0.31999734f, 0.21521908f, -0.14894684f, 0.02102503f, 
    -0.19829549f, -0.04367794f, 0.06991602f, -0.09849545f, 0.02498616f, -0.12289178f, 0.16169213f, 0.10780850f, 
    0.28194115f, -0.08047249f, -0.11169589f, -0.34865499f, -0.08776819f, 0.03801565f, -0.03330874f, 0.06225771f, 
    0.01553168f, -0.02356586f, 0.09629275f, -0.22863092f, -0.27515897f, 0.15636189f, 0.00175738f, 0.31169122f, 
    0.16796093f, 0.13277344f, 0.06020852f, 0.02969264f, 0.00425795f, -0.06161855f, 0.06865717f, 0.15037374f, 
    -0.30899885f, 0.06590623f, 0.21687986f, 0.01782621f, 0.13669974f, 0.08073416f, 0.06527702f, -0.00444106f, 
    0.13722761f, 0.07742498f, 0.07077989f, 0.12422749f, -0.12154648f, -0.08640350f, -0.28026405f, -0.01899654f, 
    0.08236704f, -0.00300011f, 0.04274173f, 0.12464151f, 0.12139937f, 0.02295709f, 0.10819732f, -0.11212642f, 
    -0.06671274f, 0.03561781f, -0.17334639f, -0.35965526f, -0.01508296f, -0.12606190f, 0.01990726f, -0.06273520f, 
    0.15720823f, -0.07011708f, 0.05108417f, 0.07048945f, 0.20119098f, -0.05377961f, 0.05767786f, -0.29668710f, 
    -0.12426493f, 0.07129634f, 0.06792424f, 0.03892146f, 0.06251375f, -0.07639940f, 0.08309272f, 0.16013226f, 
    -0.06994019f, -0.04618340f, -0.18945198f, -0.13606295f, 0.09738302f, -0.06432991f, 0.01895963f, 0.01611722f, 
    0.03859448f, 0.07537998f, 0.13340780f, -0.14932719f, -0.10851557f, -0.09742370f, -0.00564882f, 0.04107531f, 
    0.14812794f, 0.05446833f, 0.04737574f, 0.02098805f, 0.18730664f, -0.04464765f, 0.01108053f, 0.23183250f, 
    0.21450210f, 0.11227386f, 0.09322400f, 0.22298828f, 0.01618591f, 0.07611179f, -0.05592640f, 0.17239581f, 
    0.05129359f, 0.00522927f, 0.06804848f, 0.13147165f, 0.05192060f, -0.08675107f, -0.29121438f, 0.31886119f, 
    0.01275986f, 0.05779597f, 0.13398945f, -0.01944127f, -0.00926045f, 0.04634873f, 0.07149407f, -0.12634398f, 
    -0.12821630f, -0.07338457f, -0.18073457f, -0.10565089f, 0.01778423f, -0.16395020f, 0.00316987f, -0.02922203f, 
    0.04445161f, 0.08668879f, -0.00716320f, 0.13931920f, -0.39207280f, 0.19965668f, 0.23166424f, -0.02191730f, 
    -0.04652585f, 0.10894553f, -0.00746378f, 0.10758957f, 0.05297581f, -0.07880664f, 0.09040977f, 0.08008211f, 
    0.20081750f, -0.07096222f, -0.08180946f, -0.06989150f, 0.32715854f, -0.06241338f, 0.13839056f, 0.04690127f, 
    0.20621961f, 0.10242496f, -0.09397087f, -0.15934214f, -0.30553767f, -0.01144177f, 0.13495065f, -0.02052513f, 
    -0.06028283f, -0.05786669f, -0.07101645f, 0.03592728f, 0.09741754f, -0.02094493f, 0.02461439f, -0.11282519f, 
    -0.05042192f, 0.02809030f, -0.06857291f, 0.00924238f, -0.02053155f, -0.05707354f, -0.08005773f, 0.00799161f, 
    -0.06777595f, 0.04989523f, 0.00578315f, -0.05847702f, -0.02383151f, 0.01060006f, -0.07056357f, 0.00273817f, 
    0.04636769f, -0.03643424f, -0.01438232f, -0.03085274f, 0.06329564f, 0.02783850f, -0.01412837f, 0.03913394f, 
    -0.05820698f, -0.02442637f, -0.03054417f, -0.05323573f, -0.06627549f, -0.07283206f, -0.05746121f, 0.03183168f, 
    -0.05730760f, -0.02386645f, 0.03837255f, 0.05379169f, 0.00030852f, -0.04110314f, 0.03167151f, -0.07311320f, 
    0.04266385f, -0.07604712f, 0.05314476f, -0.05208336f, -0.07145066f, -0.06829140f, 0.06082491f, -0.06868510f, 
    0.04375369f, -0.07969268f, 0.00168630f, -0.06425591f, 0.03232433f, -0.06580145f, -0.00189941f, 0.05912267f, 
    0.03226648f, 0.04353784f, 0.00732337f, -0.04052195f, -0.07938606f, -0.04331210f, 0.04898329f, 0.01511249f, 
    0.03049337f, -0.01610524f, -0.07385432f, -0.04339876f, 0.05668358f, -0.06577577f, -0.03567046f, 0.02788942f, 
    -0.02649152f, -0.05320812f, -0.06584965f, 0.00415405f, -0.00381001f, -0.00708449f, -0.06853816f, 0.06031684f, 
    0.02365477f, -0.06974097f, -0.07196761f, 0.00054367f, 0.03988647f, 0.00902111f, -0.05645366f, 0.00162459f, 
    0.05204085f, -0.07806494f, -0.08078975f, -0.04599079f, 0.01243146f, 0.02754245f, 0.05943853f, 0.05811756f, 
    0.00399981f, -0.02890384f, -0.08141419f, -0.06481099f, -0.06652488f, 0.07161568f, -0.02749758f, 0.05369548f, 
    -0.02632529f, 0.04702821f, 0.00959380f, -0.01370805f, -0.02083519f, 0.05537128f, -0.08070654f, -0.03931520f, 
    0.04392456f, -0.01248961f, -0.06268644f, 0.04537595f, -0.04087463f, 0.04246139f, -0.01590299f, 0.05078057f, 
    -0.07248618f, 0.05562852f, -0.03559591f, 0.02701654f, -0.03917668f, -0.03830674f, 0.00061176f, -0.08132486f, 
    0.02430731f, -0.04160219f, -0.00806254f, 0.03781393f, 0.04551623f, -0.00966363f, 0.05089733f, -0.04321218f, 
    -0.07215616f, 0.03541014f, -0.02031845f, -0.06279659f, -0.05373318f, -0.03803543f, -0.07264549f, -0.03607929f, 
    -0.05105121f, -0.07783509f, 0.05448188f, -0.07360599f, -0.07751856f, -0.00194171f, -0.02704851f, -0.01746651f, 
    0.01695286f, -0.05030133f, 0.02890310f, 0.02128771f, 0.02251830f, -0.04193379f, 0.05721999f, -0.01819990f, 
    -0.01089466f, 0.01747689f, -0.02374754f, -0.07102221f, -0.05517367f, 0.00829039f, -0.00892270f, -0.02705143f, 
    -0.00697027f, -0.06303298f, -0.00167828f, 0.02542417f, 0.04184274f, -0.07859750f, -0.00350122f, -0.06480428f, 
    0.01877068f, 0.03550315f, 0.01205993f, -0.07055576f, -0.01055280f, -0.02855178f, -0.01489737f, -0.04285348f, 
    -0.02305791f, -0.07270835f, -0.03486671f, -0.00660767f, -0.05491887f, 0.01082592f, 0.00531856f, -0.02978918f, 
    0.22858392f, 0.13150997f, 0.00602697f, -0.00976454f, 0.06386810f, -0.01742998f, 0.12962997f, 0.01661662f, 
    0.06393959f, 0.09039418f, -0.08103449f, 0.09629846f, 0.29668397f, 0.13911642f, -0.11748099f, -0.08793048f, 
    -0.18975340f, -0.13939038f, 0.16074929f, -0.19292291f, 0.00530439f, 0.19677536f, -0.00077185f, -0.00106666f, 
    0.17717689f, -0.04073468f, -0.02749814f, -0.08740973f, 0.19433965f, -0.04392142f, 0.10251530f, -0.04266671f, 
    -0.17198217f, 0.12882929f, 0.10094576f, 0.12018048f, 0.35985553f, 0.01133141f, 0.11785096f, 0.32935077f, 
    -0.05356488f, 0.12162163f, -0.10044392f, -0.19883521f, 0.06539739f, 0.12208854f, 0.09856467f, 0.03168140f, 
    -0.28933135f, 0.19688463f, 0.17913978f, -0.08812963f, -0.02042997f, 0.04377010f, 0.03371477f, 0.19512144f, 
    -0.02031269f, -0.08798905f, 0.19268748f, -0.04047440f, 0.20319360f, 0.06859018f, -0.08845212f, -0.02269328f, 
    -0.01553956f, 0.05176460f, -0.02963926f, -0.13532360f, -0.05452260f, -0.15799911f, 0.03960296f, -0.34641752f, 
    0.08540151f, 0.22242831f, -0.05391264f, -0.15570948f, -0.09275398f, 0.09259205f, -0.10661266f, -0.08855198f, 
    0.01314351f, -0.02492041f, -0.12066709f, 0.01999165f, 0.40533426f, -0.11620083f, -0.12524031f, -0.32467332f, 
    -0.17046627f, -0.12386481f, 0.01024546f, 0.05108906f, -0.12203345f, 0.07957592f, -0.03038172f, 0.01621052f, 
    0.08790029f, -0.14469348f, -0.02452469f, -0.11849968f, 0.18605404f, 0.08846382f, 0.17154042f, 0.14480805f, 
    -0.07744339f, 0.03235448f, -0.05240270f, 0.03065616f, 0.20945571f, 0.38134372f, -0.13930991f, 0.01039971f, 
    0.07516118f, -0.05873845f, 0.10370714f, 0.21927708f, -0.03923906f, -0.03680563f, 0.06875011f, 0.03504600f, 
    0.15711462f, 0.19403310f, -0.14802186f, 0.04615266f, 0.12139213f, 0.12069884f, 0.09977657f, 0.13003936f, 
    -0.18058513f, -0.21180937f, -0.15148936f, 0.17466733f, 0.35224554f, -0.15345517f, -0.16067161f, 0.14278667f, 
    0.07304336f, 0.08722592f, -0.03071962f, -0.05754941f, 0.13282666f, -0.03410757f, -0.05430464f, -0.07517461f, 
    0.24614000f, -0.02229194f, 0.02472185f, -0.22860283f, 0.08117924f, -0.00945857f, -0.02136033f, -0.08459781f, 
    -0.01018896f, 0.16258529f, 0.01383660f, 0.10855251f, -0.16355570f, -0.08223352f, 0.05447807f, 0.08821604f, 
    -0.00847241f, 0.01214008f, 0.06457513f, 0.00082214f, -0.05061625f, -0.08788878f, -0.14579603f, -0.16948505f, 
    0.05998184f, -0.07317568f, 0.15831795f, -0.06115532f, 0.02589483f, 0.15638117f, 0.04090708f, 0.13796076f, 
    -0.09057295f, 0.21987669f, 0.07688960f, -0.15667289f, 0.20143075f, 0.11466008f, -0.03599696f, 0.03428951f, 
    -0.08800404f, -0.11548510f, 0.01120776f, 0.10823018f, -0.00758610f, -0.10675400f, -0.19316527f, -0.11024854f, 
    -0.19437298f, -0.19152591f, -0.05943838f, -0.16028416f, -0.06342404f, 0.17431511f, -0.05741939f, 0.02672835f, 
    -0.07444330f, 0.01081052f, -0.03738254f, -0.04645372f, -0.06396376f, -0.05803059f, 0.41006833f, 0.09604201f, 
    0.30964246f, 0.13903411f, 0.04602292f, 0.41370031f, -0.18371667f, -0.02213635f, -0.13503927f, -0.05194959f, 
    -0.08319093f, 0.07221077f, 0.18915661f, -0.12344991f, 0.16900912f, 0.09015853f, -0.05578301f, 0.12129331f, 
    -0.02219384f, 0.10351319f, -0.11597843f, -0.01392738f, 0.30841368f, 0.08816995f, -0.22276908f, 0.13746083f, 
    -0.08246735f, 0.10836397f, -0.07978147f, 0.03625138f, 0.05013819f, 0.07447267f, 0.02679445f, -0.10739033f, 
    0.07954703f, 0.12233163f, -0.04158733f, -0.01488042f, -0.14650899f, -0.02246548f, 0.04682791f, -0.06473343f, 
    -0.04288156f, 0.10809703f, 0.01400056f, 0.13009647f, -0.01549100f, -0.03427922f, 0.16777541f, 0.02716472f, 
    0.03298705f, 0.34926143f, -0.08948625f, 0.01306674f, -0.11823445f, 0.05094842f, 0.00246356f, 0.13671707f, 
    -0.29997775f, 0.16835667f, 0.03828397f, 0.43835202f, -0.20789590f, 0.00357201f, -0.02153246f, 0.09362415f, 
    -0.21839412f, 0.05772863f, 0.01065061f, -0.19368304f, -0.17227812f, 0.48502886f, 0.02716037f, -0.12165240f, 
    -0.10523032f, 0.01298331f, 0.03148617f, -0.07188395f, 0.04684854f, -0.05357796f, 0.10752767f, -0.07145549f, 
    0.50758749f, 0.00486599f, 0.05198449f, -0.01832746f, -0.05601322f, 0.17591797f, -0.09208909f, 0.08166684f, 
    0.05958317f, -0.01799713f, 0.00500220f, 0.16694777f, 0.00462931f, 0.09047922f, 0.05583007f, 0.05404842f, 
    0.08539146f, -0.07035256f, -0.03869859f, -0.08650600f, 0.03079907f, -0.01163977f, 0.02329663f, -0.06569819f, 
    0.05175499f, 0.01921729f, 0.12303025f, -0.08093074f, 0.02003489f, -0.15215968f, 0.00629880f, -0.04315294f, 
    -0.04362729f, 0.06731781f, -0.06414583f, -0.09896314f, -0.10257465f, 0.25379908f, 0.21112272f, -0.02830422f, 
    -0.14171106f, -0.08410275f, -0.14079848f, 0.11951876f, 0.03575230f, 0.13666973f, -0.14140770f, 0.12794678f, 
    0.25859046f, 0.09757360f, 0.22469343f, 0.05406341f, 0.04676266f, 0.15505657f, -0.06208877f, -0.12044012f, 
    -0.00818413f, 0.05533711f, 0.05582851f, 0.07603567f, 0.16202943f, -0.36139512f, -0.29167640f, -0.15634252f, 
    -0.09695205f, -0.01965786f, -0.15913562f, -0.14669895f, -0.00758931f, 0.16548912f, 0.03590404f, 0.04023082f, 
    0.07407962f, 0.00096827f, 0.15528667f, 0.33918217f, 0.06581736f, 0.19245653f, -0.05480802f, 0.18487100f, 
    0.01323317f, 0.00285534f, 0.05940382f, -0.02157163f, 0.45667118f, 0.30446807f, -0.47747406f, -0.04992549f, 
    -0.14454162f, -0.16087291f, -0.02697796f, -0.00315528f, 0.09450766f, 0.01353106f, -0.06799750f, -0.13490194f, 
    -0.19351429f, -0.20441085f, 0.15433440f, -0.09381342f, -0.02293259f, -0.00761715f, -0.06279173f, -0.01421667f, 
    -0.16361979f, 0.06267270f, -0.19887388f, 0.05104196f, 0.16443487f, 0.00894504f, 0.16022138f, 0.18563229f, 
    0.06279246f, 0.00707014f, 0.06060375f, 0.20061238f, -0.07209285f, 0.07800619f, -0.00566030f, 0.03584396f, 
    0.18156335f, -0.09388810f, 0.07034217f, -0.20410879f, 0.03314369f, 0.09481075f, 0.03335289f, 0.06745811f, 
    -0.05689619f, 0.04144716f, 0.09999986f, -0.10491204f, 0.03920108f, 0.33118671f, -0.36171702f, 0.35974187f, 
    0.07922146f, 0.04549324f, -0.12185848f, -0.13627088f, 0.00854556f, 0.02322328f, 0.03449399f, 0.15587075f, 
    -0.03455425f, 0.09354593f, 0.17464633f, -0.08326034f, 0.01595086f, -0.02101291f, -0.00986660f, 0.06353336f, 
    0.05405617f, 0.05040373f, 0.04080341f, 0.26913780f, -0.07964043f, -0.15819293f, -0.18682674f, 0.10848436f, 
    0.12918851f, 0.29739359f, 0.07418722f, 0.00872837f, -0.06023585f, 0.08813625f, -0.07765062f, -0.08704621f, 
    -0.24488920f, 0.20335034f, -0.21158144f, 0.11823004f, -0.19940618f, -0.01696599f, -0.04797692f, 0.09439480f, 
    -0.09246685f, -0.00966868f, 0.01558808f, -0.10803705f, 0.15009023f, 0.22797059f, 0.02383282f, -0.29067788f, 
    -0.15565971f, 0.00829237f, 0.01230819f, -0.07006314f, -0.09463855f, -0.06411662f, 0.00903996f, 0.14926523f, 
    0.34768963f, 0.01698138f, -0.01584497f, -0.11033969f, 0.09602745f, 0.03004659f, -0.00273867f, 0.02314856f, 
    0.01663073f, 0.01055517f, 0.12305492f, 0.00300244f, 0.02862809f, 0.01453470f, 0.05420693f, 0.01978217f, 
    0.09294377f, -0.11050575f, 0.08625704f, 0.02176485f, 0.15945649f, -0.21546006f, -0.04733155f, -0.00009756f, 
    0.25875682f, 0.05054964f, 0.11704943f, 0.05100017f, 0.03063536f, -0.02245175f, -0.07893016f, -0.00498116f, 
    -0.08596680f, 0.04395598f, -0.05918776f, 0.04054570f, -0.17192386f, 0.09078888f, -0.06289060f, 0.15100379f, 
    0.02926871f, 0.06101209f, 0.00972521f, 0.09189391f, 0.09625519f, 0.09448084f, 0.00263001f, -0.07966933f, 
    -0.15152092f, 0.05077988f, -0.10779835f, -0.02444107f, 0.12900504f, -0.01384486f, -0.14509001f, -0.10622381f, 
    0.07633504f, 0.12248428f, 0.03439194f, 0.14396010f, -0.26458970f, -0.25171572f, -0.10178910f, -0.09650238f, 
    -0.04116767f, 0.15538624f, -0.07660216f, -0.02691506f, 0.08992229f, -0.02321540f, 0.06812157f, 0.02110914f, 
    0.05618859f, 0.11174663f, 0.02288177f, 0.08523461f, 0.15359500f, 0.06971111f, 0.11677381f, 0.04495857f, 
    0.02113121f, 0.09782819f, -0.05582668f, -0.05169130f, 0.00087781f, 0.28956285f, -0.31418553f, -0.06039471f, 
    -0.11304403f, -0.09594345f, -0.11070072f, 0.17090279f, -0.00175118f, -0.01998026f, 0.01219203f, -0.08064060f, 
    0.18640161f, 0.22433548f, 0.00348273f, 0.28348333f, 0.00538267f, 0.13471626f, -0.11677523f, -0.02683749f, 
    0.21180829f, -0.01435828f, 0.17673030f, -0.03234247f, 0.10501102f, 0.05726128f, -0.01866062f, -0.09008600f, 
    0.10376840f, 0.25767559f, 0.06207746f, -0.17201331f, 0.04261286f, 0.00166320f, 0.04126148f, -0.06498812f, 
    0.06034959f, 0.05465933f, -0.22044878f, 0.28879631f, 0.00751574f, 0.00985843f, 0.04328119f, -0.02215905f, 
    0.08189265f, 0.01985169f, -0.05397328f, 0.07387605f, -0.16233489f, -0.20921372f, 0.20148742f, -0.30395210f, 
    -0.01949451f, -0.02524338f, -0.01073966f, 0.09110944f, -0.06350663f, -0.05752474f, 0.04786418f, 0.03822996f, 
    -0.21544108f, 0.20262465f, 0.00241723f, 0.04151130f, 0.14394619f, 0.02453589f, -0.05664458f, 0.02309855f, 
    0.06890936f, 0.07908700f, -0.02342095f, 0.00545351f, -0.48801976f, 0.06741464f, 0.05140300f, 0.04976650f, 
    0.12341068f, -0.04139862f, 0.01018570f, -0.04872230f, 0.09516554f, 0.02224873f, -0.03465790f, -0.01809254f, 
    -0.27362180f, 0.17379990f, 0.15646674f, -0.64365095f, -0.09946295f, -0.05902721f, 0.14205283f, -0.01044616f, 
    0.10868011f, 0.02505432f, 0.03948501f, 0.11864755f, -0.23125720f, 0.15665025f, 0.10596893f, -0.04635066f, 
    0.10521215f, -0.04842221f, -0.00732445f, 0.08240374f, 0.10036226f, 0.12570061f, 0.09225637f, 0.07828790f, 
    -0.23206045f, -0.12382340f, 0.05423946f, -0.14245002f, 0.04545683f, 0.19187677f, -0.01159128f, -0.05836383f, 
    -0.06075389f, -0.04053691f, 0.03143849f, 0.07475247f, -0.16291958f, 0.21574195f, 0.13334295f, 0.02322847f, 
    -0.14054449f, 0.24123296f, -0.10281369f, -0.08884888f, -0.13051315f, 0.08888108f, -0.04932399f, -0.00294196f, 
    -0.15966718f, 0.20412780f, 0.21336195f, -0.00354867f, -0.05972696f, -0.00970951f, -0.07005616f, 0.01590254f, 
    0.09593912f, 0.07004304f, 0.03628663f, -0.08807650f, -0.37498996f, 0.26413080f, 0.10090229f, -0.01323111f, 
    -0.11404487f, 0.03253276f, -0.01777412f, -0.09968152f, -0.02343370f, 0.03833617f, 0.16471981f, -0.11313044f, 
    -0.06790523f, 0.11491633f, 0.12364601f, 0.03562387f, 0.08999080f, 0.17866974f, 0.25442132f, 0.02418786f, 
    -0.07560046f, -0.02189478f, 0.06940159f, -0.08726259f, 0.30179766f, -0.25020424f, 0.14664350f, 0.11858212f, 
    -0.06447201f, -0.03643533f, 0.04103789f, 0.00487606f, -0.00735604f, 0.06835755f, 0.10131403f, 0.05040064f, 
    -0.36008370f, -0.02584296f, -0.03181132f, -0.25648400f, 0.03659101f, -0.05964088f, -0.15527476f, -0.00139502f, 
    -0.02391646f, -0.10615432f, -0.02465794f, 0.00160985f, 0.33361208f, -0.21761476f, 0.22386959f, -0.09518328f, 
    0.00525428f, -0.01909970f, 0.10010292f, -0.05648934f, -0.18324770f, 0.04195222f, 0.09493923f, 0.02299696f, 
    -0.00769181f, -0.07027093f, -0.10159321f, -0.04607870f, 0.03268670f, -0.16954109f, -0.00922980f, 0.11891135f, 
    0.07784101f, -0.09326016f, -0.07851514f, -0.07906768f, 0.03853953f, 0.08999528f, -0.09424413f, -0.17940071f, 
    -0.07312366f, 0.11721820f, 0.07129063f, -0.16810755f, 0.05842486f, 0.08846807f, -0.06735040f, 0.13641323f, 
    0.22381587f, 0.04683280f, -0.23178187f, -0.12380697f, 0.17975597f, 0.13938932f, -0.05402189f, -0.00209873f, 
    0.17750277f, 0.01021358f, 0.09083191f, 0.01596104f, 0.04735257f, -0.18835893f, 0.14929101f, 0.15732613f, 
    0.07007593f, 0.00257358f, 0.14407845f, -0.10505114f, 0.06348701f, 0.10976601f, 0.09665545f, -0.01893823f, 
    0.33865008f, 0.28701010f, 0.16740143f, 0.11327622f, 0.00009246f, -0.14354298f, 0.10065243f, -0.02983720f, 
    -0.03434789f, 0.01016728f, -0.17966202f, 0.17335017f, 0.10385285f, 0.00054945f, -0.08886512f, 0.09440265f, 
    0.01703680f, -0.03063626f, -0.01931739f, 0.00336539f, -0.12514907f, -0.05074127f, 0.19321901f, 0.04603318f, 
    -0.06607370f, -0.11422542f, 0.33016410f, -0.39924666f, 0.05677545f, -0.02383547f, 0.02114625f, -0.19266075f, 
    0.06972936f, 0.03279986f, 0.16966493f, -0.10826096f, 0.26361445f, -0.07678463f, 0.05996807f, 0.12594569f, 
    -0.05527393f, 0.22294417f, 0.09890435f, 0.09267166f, -0.01668026f, 0.09560696f, -0.21972887f, 0.12852865f, 
    0.05176736f, -0.19781299f, -0.16013213f, -0.19064309f, 0.27613658f, 0.01943140f, -0.10820094f, -0.05293635f, 
    0.06961526f, -0.04952877f, -0.05923726f, -0.24542397f, 0.11143012f, 0.39339533f, 0.09056066f, 0.28523648f, 
    0.14880152f, -0.01865129f, 0.00977859f, 0.00708415f, -0.19889179f, -0.14697503f, -0.03766450f, 0.00408904f, 
    0.20853801f, 0.30088916f, 0.02257429f, -0.03072837f, 0.00988779f, -0.08940569f, 0.05025988f, 0.14980125f, 
    -0.04260906f, 0.07035959f, -0.05330569f, 0.00219544f, 0.05771298f, -0.26285923f, -0.33685568f, 0.03805569f, 
    0.04963238f, -0.00555274f, -0.12079035f, 0.01060672f, -0.07094007f, 0.02387524f, 0.12340475f, 0.00730437f, 
    0.09177695f, -0.37651560f, -0.08704434f, -0.04157396f, 0.01421047f, -0.00738437f, 0.16247183f, -0.08031587f, 
    0.08872515f, -0.06616586f, -0.02120591f, 0.00697830f, 0.06821515f, -0.03198151f, -0.10356614f, -0.03078426f, 
    0.03959765f, 0.13633053f, -0.03414703f, 0.02535071f, 0.04322074f, 0.12244055f, -0.00476211f, 0.20881940f, 
    0.09429431f, -0.24799928f, 0.15874888f, -0.10490778f, -0.02349134f, 0.05158162f, -0.20778765f, 0.01288059f, 
    0.05991908f, 0.05141876f, -0.25636104f, 0.00681247f, 0.25045508f, -0.08191758f, 0.05464279f, 0.15738939f, 
    0.06835348f, -0.00015133f, 0.06494150f, -0.01859327f, 0.05067164f, 0.01185785f, 0.19750302f, 0.18382323f, 
    0.04153505f, -0.01168188f, 0.02011791f, 0.00257110f, 0.00289244f, 0.01679347f, -0.01339067f, -0.07849716f, 
    -0.06297868f, 0.03962893f, 0.04371775f, 0.01769842f, 0.05359610f, -0.03256150f, -0.05805188f, 0.05882579f, 
    -0.03612784f, -0.03290251f, -0.00082986f, -0.06315471f, 0.01155964f, -0.02062281f, 0.04832678f, 0.03390667f, 
    0.03467682f, -0.07240585f, -0.06221733f, 0.00173891f, 0.04088057f, 0.01214448f, -0.01833072f, -0.03699154f, 
    -0.02748807f, 0.04404414f, -0.00146840f, -0.00126821f, 0.06219281f, 0.00261244f, -0.06887227f, 0.01330089f, 
    0.03525559f, 0.05220753f, -0.04206274f, -0.00546205f, -0.02047788f, 0.02640425f, -0.06803204f, 0.05090752f, 
    0.03805639f, -0.00434803f, 0.01360505f, -0.00028021f, 0.04293383f, 0.00722691f, -0.06093450f, 0.04782715f, 
    -0.05337361f, -0.03837085f, 0.04159379f, -0.03263177f, 0.05740021f, 0.00434931f, 0.01312076f, -0.05439718f, 
    -0.02876338f, -0.06066070f, 0.01043790f, 0.03932905f, 0.01493937f, -0.02660903f, -0.06552617f, 0.01341404f, 
    0.03541859f, -0.02929714f, -0.01692975f, -0.06293751f, -0.03355321f, -0.03793119f, -0.00402444f, 0.00033170f, 
    -0.04795350f, -0.02121962f, -0.04991595f, 0.02327284f, -0.06454071f, -0.05172683f, -0.06336816f, 0.00800261f, 
    0.04878713f, -0.00403245f, -0.05710106f, 0.05620107f, -0.04301507f, -0.03219764f, -0.05002937f, 0.04306871f, 
    -0.01212177f, 0.05631094f, 0.05458701f, -0.07655764f, 0.00993151f, -0.06152347f, -0.05943837f, -0.00799506f, 
    0.01398774f, 0.05229520f, -0.01706036f, 0.01323865f, 0.02165457f, -0.01576499f, -0.02626916f, -0.07757562f, 
    0.01644912f, -0.03181298f, -0.01088811f, -0.06400145f, 0.01203536f, -0.07883917f, -0.05472808f, -0.07742961f, 
    -0.00452094f, -0.01735038f, 0.02564166f, -0.06260934f, -0.01326793f, 0.01198070f, -0.03556775f, 0.03945714f, 
    -0.07287943f, 0.04841543f, 0.02768653f, -0.04301730f, -0.07995549f, -0.03375295f, -0.03324610f, -0.07364833f, 
    -0.07286973f, 0.04152090f, -0.04717327f, 0.05694617f, 0.00480311f, -0.01677511f, 0.01306426f, -0.03404104f, 
    0.04889536f, -0.03689525f, -0.03721785f, -0.03537039f, 0.04101381f, 0.01894328f, -0.04645402f, -0.06380860f, 
    -0.01604837f, -0.00637657f, 0.05750391f, -0.03898017f, -0.01681817f, -0.02579638f, 0.01712105f, -0.03470884f, 
    -0.06728920f, 0.01855903f, 0.01072407f, 0.04518649f, 0.06024148f, 0.04459706f, -0.05723957f, -0.08116627f, 
    0.02979537f, -0.01810045f, -0.01581018f, -0.07779352f, 0.05197374f, -0.03397822f, 0.03217917f, -0.03845486f, 
    -0.00051100f, -0.04499334f, -0.01177121f, -0.07317815f, -0.05801597f, 0.05005145f, -0.04550823f, -0.07088242f, 
    -0.05743878f, 0.06203091f, -0.04171886f, -0.02972230f, 0.03124727f, -0.05785227f, -0.07402875f, 0.02990242f, 
    -0.03001733f, 0.05868637f, 0.03166138f, -0.02280552f, 0.00001303f, -0.06561675f, -0.04507059f, -0.05296559f, 
    -0.04680413f, -0.00131778f, -0.02817364f, 0.00607409f, -0.01174512f, 0.06084731f, 0.03381351f, -0.04078520f, 
    -0.01491128f, 0.06563379f, -0.07244168f, -0.03881019f, -0.05560954f, -0.03040748f, -0.01913524f, -0.06894210f, 
    -0.05892109f, -0.03804077f, -0.01813211f, 0.04121403f, -0.07559326f, -0.05328369f, 0.02805317f, 0.02605696f, 
    0.01899059f, 0.02610437f, -0.00577352f, -0.03514542f, 0.03034065f, -0.02677595f, 0.06497639f, 0.04886907f, 
    0.02045618f, -0.01046694f, -0.02424379f, 0.05066342f, 0.01557613f, 0.01941848f, -0.05050199f, 0.06108696f, 
    -0.04339897f, -0.04024764f, 0.02198906f, 0.05599847f, 0.03741960f, -0.02714117f, 0.05103121f, 0.01592883f, 
    0.03979830f, -0.03138674f, -0.04068781f, -0.06823745f, -0.04724128f, 0.05947949f, 0.01900704f, -0.06518120f, 
    0.03617943f, 0.04526602f, -0.02349330f, -0.05583810f, 0.05584479f, -0.07181600f, -0.02022361f, -0.02547280f, 
    0.05839678f, -0.00328500f, 0.01759079f, -0.04259222f, -0.04265238f, -0.00235710f, 0.03471024f, 0.00063306f, 
    -0.03957621f, -0.00287335f, -0.06843988f, -0.05342187f, -0.06126655f, -0.00818883f, -0.07621992f, 0.01674733f, 
    -0.05484049f, 0.00731518f, -0.04927403f, 0.06086460f, -0.04686158f, 0.00377731f, -0.01336118f, -0.04745555f, 
    -0.00613232f, 0.06005041f, -0.00049541f, -0.02877713f, -0.07419722f, 0.06218374f, 0.06411055f, -0.03199820f, 
    -0.01267437f, 0.01718919f, -0.01022442f, -0.06496564f, 0.03949557f, 0.04434206f, -0.07159397f, -0.05014742f, 
    -0.05179774f, 0.00468037f, -0.04535823f, 0.00576758f, -0.03205833f, -0.00336539f, -0.05634761f, -0.04346447f, 
    0.05910252f, -0.07222573f, 0.05424159f, 0.00509719f, 0.05816386f, -0.03984406f, 0.05089102f, -0.01164784f, 
    0.01608236f, -0.04016299f, -0.03064870f, -0.07652650f, -0.03948619f, -0.00669318f, -0.06795720f, 0.06325678f, 
    0.05547712f, -0.05488494f, -0.07773506f, 0.02924138f, -0.00749252f, -0.01457942f, 0.00948388f, 0.00431589f, 
    0.06386876f, 0.05187177f, -0.03524191f, -0.01135345f, -0.02193278f, -0.01919460f, 0.06286356f, 0.03503577f, 
    -0.04180238f, -0.00301516f, 0.05549448f, 0.01536017f, -0.06900353f, -0.05584430f, -0.07524252f, 0.02196556f, 
    0.06565095f, 0.04086533f, -0.01558628f, 0.04788494f, -0.01670321f, 0.05861918f, -0.07275413f, -0.00572890f, 
    -0.04691240f, -0.04603952f, -0.02952319f, -0.05884577f, 0.00957598f, -0.02433708f, -0.03963336f, 0.00417857f, 
    -0.07364772f, 0.03101334f, -0.06429540f, -0.05687488f, -0.04124206f, -0.06389978f, 0.01063662f, -0.06113140f, 
    0.05707428f, 0.03999536f, -0.07443105f, -0.07323844f, -0.02155463f, -0.01895326f, -0.00672070f, -0.07246283f, 
    0.08505102f, 0.11377350f, 0.12840460f, 0.03017913f, 0.01530900f, 0.05830935f, 0.08578290f, -0.00783643f, 
    0.12838811f, -0.02545320f, 0.05246349f, -0.06501161f, 0.00354771f, 0.12460610f, -0.00960003f, -0.14513928f, 
    -0.17295031f, -0.02932848f, 0.03333071f, -0.10829829f, 0.02449526f, 0.00198746f, 0.11718186f, -0.03837280f, 
    0.10679171f, 0.07699825f, -0.06194183f, -0.03748824f, -0.09671381f, -0.02307506f, -0.09397552f, -0.11489702f, 
    0.19138461f, -0.08065416f, 0.15037227f, -0.09631538f, -0.35657746f, -0.16112083f, 0.31508544f, 0.04365525f, 
    0.05290016f, -0.03432814f, 0.13855360f, 0.06757181f, 0.04776741f, 0.10144644f, 0.06318158f, 0.05867997f, 
    -0.11735221f, -0.10608606f, -0.05009262f, 0.11390394f, 0.12141938f, 0.07277091f, 0.01106928f, -0.02122612f, 
    0.07287028f, 0.13785815f, -0.03968054f, 0.00833005f, 0.26349491f, 0.22077739f, -0.10934946f, -0.00440652f, 
    0.02192341f, -0.23294342f, 0.03707164f, -0.00080140f, 0.08620263f, 0.08019416f, 0.10998815f, 0.20790961f, 
    0.24648273f, -0.30987489f, 0.01392259f, -0.00054434f, 0.20996620f, 0.06312139f, 0.00021024f, -0.05956945f, 
    0.20505078f, 0.07942940f, 0.14860658f, 0.00375901f, 0.17771697f, -0.44538349f, 0.08579037f, 0.23598938f, 
    0.07067268f, 0.02081063f, -0.07198364f, -0.05506311f, 0.16343035f, 0.06909622f, -0.16544566f, 0.00034077f, 
    -0.25317153f, 0.14846212f, -0.01194617f, 0.01126433f, -0.00248220f, 0.02554002f, -0.06391512f, -0.03552535f, 
    0.13370176f, 0.04398178f, -0.09794930f, -0.26855209f, -0.04470325f, -0.16875876f, -0.06663764f, 0.00901543f, 
    0.09243065f, 0.07124738f, -0.19285786f, -0.01551072f, 0.01533719f, 0.05217137f, 0.03219698f, 0.16676410f, 
    -0.02966685f, 0.04294083f, -0.12214106f, 0.13166805f, -0.01830421f, 0.05911015f, 0.03648103f, 0.09071176f, 
    0.14832750f, 0.16197334f, 0.08520455f, 0.10309709f, 0.44279343f, -0.11559241f, -0.19731121f, 0.07365102f, 
    -0.02759389f, -0.04114177f, 0.11746697f, -0.05684779f, 0.00497363f, -0.00337870f, 0.15661983f, -0.04235322f, 
    0.11867587f, 0.07732075f, -0.26729244f, 0.05562578f, -0.09800591f, -0.23049694f, 0.01353803f, 0.17018071f, 
    0.01592134f, -0.11840920f, -0.02654784f, -0.08375329f, -0.19774926f, 0.37443167f, 0.31072196f, 0.03873820f, 
    0.07212225f, 0.12813069f, 0.07840046f, 0.09787203f, -0.01819943f, 0.01335986f, 0.08312052f, 0.19705513f, 
    0.33796856f, -0.23698659f, -0.12093528f, -0.09540408f, -0.09388275f, -0.16098161f, -0.05015616f, -0.08663078f, 
    0.06006889f, -0.00970713f, -0.15678906f, 0.07264807f, -0.20465162f, -0.35408121f, 0.29303735f, 0.15792005f, 
    0.01901595f, 0.04947516f, -0.08876656f, -0.12189393f, 0.14741875f, 0.03811899f, 0.27675250f, 0.13992338f, 
    -0.04229030f, 0.37681523f, -0.20713505f, -0.07601658f, 0.01073258f, 0.18689831f, 0.10475521f, 0.06137341f, 
    0.21685770f, 0.27493608f, 0.05146385f, 0.03597479f, 0.02517265f, 0.07980967f, 0.05777470f, 0.01944978f, 
    -0.04370944f, -0.07049797f, -0.06667878f, 0.07045839f, 0.12628385f, 0.10148253f, 0.00587947f, 0.07672672f, 
    -0.09003558f, 0.15644246f, -0.00203390f, 0.20118250f, -0.08844908f, -0.09370861f, 0.04275725f, -0.12218994f, 
    -0.11315173f, 0.06510928f, 0.01425395f, -0.06172517f, 0.17328048f, -0.24792072f, 0.31345704f, -0.03207282f, 
    -0.01385697f, 0.02106173f, -0.04824154f, -0.08911546f, 0.21098402f, 0.10403179f, -0.11149946f, -0.00712956f, 
    -0.19908372f, -0.10432253f, -0.03930347f, 0.10320863f, -0.01970697f, -0.00738835f, -0.01552932f, 0.14270762f, 
    0.12360060f, -0.01532946f, 0.00334684f, -0.10882331f, 0.59804630f, 0.47440618f, 0.13161166f, -0.11776468f, 
    -0.09077214f, 0.11906146f, 0.11891843f, 0.03508424f, 0.07862131f, -0.06976436f, 0.14633928f, -0.02865239f, 
    0.16769210f, -0.07772849f, 0.00684224f, 0.23630115f, 0.09893347f, 0.03409761f, -0.08436651f, -0.00433718f, 
    -0.04540306f, 0.10228267f, -0.02314339f, -0.13614482f, 0.12263790f, -0.05365176f, -0.13819186f, -0.14178470f, 
    -0.01256457f, -0.17620419f, -0.16517283f, -0.11200381f, 0.07216410f, 0.03184840f, 0.01937570f, -0.08635284f, 
    0.15582316f, 0.03670548f, 0.18342336f, 0.20598820f, -0.03290090f, -0.09100482f, 0.08045734f, 0.21121599f, 
    0.05799811f, 0.09486612f, -0.05182984f, 0.04809578f, 0.02875550f, 0.13730887f, -0.13250837f, -0.18653652f, 
    -0.01802778f, -0.02686033f, -0.04724687f, 0.09461990f, 0.10357029f, 0.06138513f, 0.11868364f, 0.09167781f, 
    -0.10793490f, 0.09576219f, -0.31654912f, 0.18154663f, -0.04247177f, 0.01256410f, 0.01785566f, 0.05916653f, 
    0.02895881f, 0.06809001f, -0.23255970f, 0.04052893f, 0.51211822f, -0.09914128f, 0.09404254f, 0.00663313f, 
    -0.00800170f, 0.06280450f, -0.01917932f, 0.00921122f, 0.01432354f, 0.00738261f, -0.20891027f, 0.09044619f, 
    0.23720048f, 0.10597600f, 0.10784547f, 0.10241605f, -0.12013627f, 0.00217016f, -0.00192128f, 0.06177580f, 
    -0.11474442f, 0.04819215f, -0.07231462f, 0.01406897f, -0.03563086f, -0.12683515f, -0.00490802f, -0.08598488f, 
    0.05258980f, 0.00117694f, -0.05565106f, -0.04282232f, -0.11288067f, 0.01301810f, -0.05946650f, 0.04091074f, 
    0.18450832f, -0.29326937f, -0.03548257f, 0.13645639f, -0.11736548f, 0.00607788f, 0.05386617f, 0.05775562f, 
    -0.06607654f, 0.01048085f, 0.10820714f, 0.07058601f, 0.16131811f, -0.17650886f, -0.17166509f, 0.01357658f, 
    0.09712707f, -0.01427683f, -0.13058533f, -0.04116801f, 0.11391241f, 0.01269755f, -0.17958051f, -0.09618375f, 
    0.06928556f, 0.51544708f, -0.08139936f, 0.05389702f, -0.06673796f, 0.06852547f, 0.11706464f, 0.06763660f, 
    0.18320516f, 0.10979269f, 0.12320904f, 0.01338729f, -0.02400978f, 0.00058749f, -0.01924139f, 0.19430223f, 
    0.06190829f, -0.25263870f, -0.09703188f, 0.17850608f, 0.15333761f, 0.04036015f, 0.13101467f, -0.04255055f, 
    -0.30919012f, 0.16408989f, 0.08729289f, 0.32561219f, -0.08155901f, -0.08431143f, 0.11149397f, 0.02311799f, 
    -0.16748714f, 0.20514162f, -0.10673699f, 0.20774573f, 0.09990996f, 0.15082841f, -0.06720693f, -0.21004626f, 
    0.00352189f, -0.06070932f, -0.14158268f, 0.07488569f, 0.04314134f, 0.01636000f, -0.10980921f, 0.06413868f, 
    -0.16464648f, -0.17387138f, -0.15445478f, -0.01364346f, 0.08190034f, 0.09254478f, 0.03570103f, 0.19223300f, 
    0.00068249f, 0.04623980f, 0.08208377f, -0.13099703f, 0.04963227f, 0.22883110f, 0.10880692f, -0.02556139f, 
    -0.00906450f, 0.06443468f, -0.04858609f, 0.02403810f, 0.09346228f, -0.04548765f, -0.07347564f, -0.10462103f, 
    0.27743337f, 0.13834135f, -0.13315670f, 0.32232407f, 0.08415810f, 0.09869387f, 0.09104233f, 0.11939778f, 
    0.10612519f, -0.04625288f, -0.18731897f, 0.00990105f, -0.04661515f, -0.01518709f, -0.20746228f, -0.06017893f, 
    0.06232107f, -0.09838035f, -0.05917104f, -0.01441589f, 0.03681903f, 0.03940143f, 0.16485023f, -0.13833813f, 
    -0.12758400f, 0.14820853f, 0.19931641f, 0.27992633f, -0.08451172f, -0.14353722f, 0.25637016f, -0.00126601f, 
    -0.00638308f, -0.05054208f, 0.00292937f, 0.15122108f, 0.06598322f, -0.09586678f, -0.13424392f, -0.20286900f, 
    -0.12334815f, -0.14505513f, 0.04167850f, 0.11520713f, 0.12326083f, 0.11552110f, 0.09499436f, 0.03805547f, 
    -0.09097392f, -0.20835227f, -0.28455392f, -0.00950527f, 0.09767109f, 0.08987616f, 0.06497858f, -0.10564137f, 
    0.01253235f, -0.09706016f, -0.01904377f, -0.00207318f, 0.13726719f, -0.00356288f, 0.37348697f, -0.17150059f, 
    0.00739783f, 0.03062488f, 0.17069311f, -0.16813491f, -0.03886127f, -0.08581255f, -0.08727829f, 0.09709024f, 
    -0.24559531f, 0.15785477f, 0.23022009f, 0.17615576f, 0.05952849f, 0.03357543f, -0.10478042f, 0.20573017f, 
    -0.03051219f, 0.05627672f, -0.02044640f, -0.01475233f, -0.15915051f, 0.06037753f, 0.08830257f, 0.12793311f, 
    0.03589107f, -0.10360950f, -0.03268959f, -0.03529550f, -0.00098109f, -0.01325945f, -0.03803400f, -0.19059600f, 
    -0.27716830f, 0.25028032f, -0.00197474f, 0.17802231f, 0.04087662f, 0.02022344f, 0.28058776f, -0.01255546f, 
    -0.01779699f, 0.11005811f, 0.23177567f, -0.03728678f, -0.07704780f, -0.09940347f, 0.02317811f, -0.07816181f, 
    0.09604684f, 0.01399611f, -0.04572915f, -0.01685621f, 0.01802998f, -0.00763751f, -0.29130688f, 0.00462310f, 
    -0.39465183f, -0.28387803f, -0.22238247f, -0.05466329f, 0.10491344f, -0.08755377f, 0.03182083f, -0.09287374f, 
    -0.11789633f, -0.01616253f, 0.04016703f, 0.00177909f, -0.11943743f, -0.07059464f, -0.11294585f, -0.01730619f, 
    -0.00316037f, 0.04352961f, 0.05625623f, 0.07493837f, 0.11837293f, 0.12579517f, 0.05116913f, 0.19283296f, 
    -0.05424518f, -0.09652462f, 0.00454483f, -0.11658749f, 0.13412501f, -0.01374590f, 0.14511804f, 0.04283240f, 
    0.07344233f, -0.05241901f, 0.09964543f, -0.07058556f, -0.38021994f, 0.26595941f, -0.17670456f, 0.13978845f, 
    0.01985627f, 0.10858560f, -0.12271836f, -0.04178115f, 0.10608971f, -0.02794575f, 0.13914624f, 0.12782480f, 
    0.10128186f, 0.11542484f, 0.06621123f, 0.13309845f, 0.01011568f, 0.02047279f, 0.09399267f, 0.00105234f, 
    0.11173993f, 0.06757344f, 0.07160826f, 0.12035699f, -0.12058704f, -0.17687824f, -0.14566304f, 0.13324864f, 
    0.25378174f, 0.20983338f, 0.06066290f, 0.02673243f, -0.04826082f, -0.00462612f, 0.06866933f, -0.08542915f, 
    0.01105421f, -0.07667482f, 0.05873314f, -0.05280054f, -0.12828973f, -0.12144946f, -0.04294575f, 0.05603211f, 
    0.11157317f, 0.06372084f, 0.16296317f, -0.03029456f, 0.31536952f, 0.38272297f, 0.24275914f, -0.14077090f, 
    0.01980373f, 0.01774708f, 0.10004847f, 0.14508347f, 0.07504343f, -0.04693910f, 0.02099360f, 0.06392119f, 
    0.13298237f, 0.02704800f, -0.25949711f, 0.21644264f, 0.09496805f, -0.04313272f, 0.01921336f, 0.11185770f, 
    0.10651322f, 0.07421679f, 0.13803333f, -0.05285939f, -0.17645238f, 0.34460562f, 0.24842361f, 0.13615657f, 
    0.02626232f, -0.06538258f, -0.05011123f, -0.09500288f, 0.01878410f, -0.09765381f, 0.13720889f, 0.00821387f, 
    0.34362957f, 0.04791548f, 0.24179494f, 0.29032838f, 0.07880849f, -0.12325250f, 0.14541039f, 0.02325795f, 
    0.07486406f, -0.03379622f, -0.09279025f, -0.00874651f, -0.00741350f, -0.16691712f, -0.03652222f, 0.10951255f, 
    0.14086014f, 0.06851231f, 0.08751234f, 0.11999919f, 0.12052190f, 0.04860441f, 0.11947671f, -0.06487936f, 
    -0.04096154f, -0.16651411f, -0.14783919f, 0.05978157f, 0.04032189f, 0.11732755f, -0.02912042f, -0.06340540f, 
    -0.04847167f, 0.14047618f, 0.10949356f, 0.19090460f, -0.06219772f, -0.06942559f, -0.37875760f, -0.09462325f, 
    -0.10072260f, 0.04482184f, 0.05162193f, 0.00585718f, 0.18144333f, 0.07103275f, 0.09726214f, 0.03008433f, 
    0.00021082f, -0.10607293f, 0.05751867f, 0.02065983f, 0.14890596f, -0.03527195f, 0.05187025f, 0.33637145f, 
    0.07737534f, 0.01308918f, -0.13947465f, 0.02807051f, 0.24915397f, 0.54663622f, -0.35884595f, -0.12320258f, 
    0.11389545f, 0.00170104f, -0.12376789f, 0.12806319f, 0.07004333f, 0.09242772f, -0.14302249f, -0.05559132f, 
    0.25601721f, 0.56616819f, 0.01737340f, 0.33699960f, -0.08968879f, 0.07340556f, -0.04254507f, 0.11464591f, 
    0.13942541f, 0.02862430f, 0.12912235f, 0.25958171f, 0.07876243f, 0.02355169f, -0.04679915f, -0.06724353f, 
    0.01498999f, 0.12822768f, 0.20646910f, -0.11175665f, -0.00269832f, -0.02314665f, -0.08097244f, -0.14881855f, 
    -0.02185190f, 0.26852781f, -0.25661060f, 0.02232990f, -0.07088397f, -0.01478611f, 0.08126846f, 0.11427551f, 
    0.00533348f, 0.07032566f, -0.00951453f, 0.10981739f, 0.12362114f, -0.01558001f, 0.17437449f, -0.05353704f, 
    0.11681067f, -0.00855658f, 0.05071653f, 0.02592740f, -0.03828248f, -0.02754520f, 0.05115730f, 0.13165361f, 
    -0.41516352f, 0.35382259f, -0.02580920f, -0.04694282f, 0.19924642f, 0.11226852f, -0.11114600f, 0.00107212f, 
    0.06256066f, 0.01462485f, 0.13149363f, -0.04164793f, -0.67522860f, -0.05488503f, -0.01503965f, -0.02556117f, 
    -0.07470910f, -0.00882609f, -0.00340105f, -0.01323341f, -0.00899213f, -0.08951040f, -0.12792970f, -0.12535611f, 
    -0.18400197f, 0.21897922f, 0.03011767f, -0.37217104f, -0.01560180f, 0.05592170f, 0.08399658f, -0.07489366f, 
    0.06745861f, -0.04502315f, -0.01884106f, 0.11935309f, 0.07243261f, 0.08331628f, -0.05968963f, -0.00727858f, 
    -0.00897868f, -0.12302553f, -0.04205420f, -0.03694903f, -0.04018990f, 0.06913644f, 0.00912398f, 0.05768271f, 
    -0.22300111f, -0.05090907f, 0.05263231f, -0.10507715f, 0.10523741f, 0.11717095f, 0.21315075f, -0.03062873f, 
    -0.00761620f, -0.15364535f, -0.06958371f, 0.11975517f, 0.14178416f, 0.12876230f, -0.00323658f, 0.03539449f, 
    0.02371497f, 0.10401870f, -0.09644073f, 0.02637688f, 0.05323539f, 0.07435659f, -0.01002963f, 0.08420814f, 
    0.11634657f, 0.18266419f, -0.06913854f, -0.14901283f, 0.03207576f, 0.15065119f, -0.11451279f, 0.03329754f, 
    -0.10607628f, -0.12889983f, 0.04471545f, -0.00006358f, -0.23901026f, 0.17238607f, 0.12850223f, -0.03539666f, 
    -0.09645834f, 0.02651710f, 0.03672701f, -0.25665453f, 0.16939621f, -0.09636030f, 0.11083999f, 0.01167547f, 
    -0.09776198f, 0.01939006f, 0.10887806f, -0.17182507f, 0.23670264f, 0.08887710f, 0.18074661f, -0.04615476f, 
    -0.02182885f, -0.09238271f, 0.06065556f, -0.03027291f, -0.02649628f, -0.25120923f, 0.30991656f, 0.13360451f, 
    -0.08361151f, -0.10581759f, 0.04443644f, 0.07055530f, 0.05885281f, -0.05680879f, 0.06083689f, -0.02329043f, 
    -0.30650094f, 0.39947748f, 0.11139520f, -0.07826465f, -0.04140886f, -0.09107303f, 0.01104305f, -0.02229318f, 
    0.00145539f, 0.04777330f, 0.24204674f, -0.10801880f, 0.39623532f, -0.12120089f, 0.10599595f, -0.09250639f, 
    0.01127869f, -0.05948008f, 0.18708116f, 0.06862632f, -0.06839422f, 0.02455493f, 0.00060892f, -0.04866669f, 
    0.57413989f, 0.10390671f, 0.25219300f, 0.35021952f, 0.06787280f, 0.11686509f, 0.15641683f, 0.08850112f, 
    0.07561099f, 0.11713601f, 0.12538706f, 0.19814652f, 0.00483736f, -0.02277229f, -0.05003662f, 0.03876233f, 
    0.24722588f, 0.06172954f, 0.05513269f, 0.19918069f, 0.01638652f, 0.14150310f, 0.41004461f, 0.05371026f, 
    -0.12796687f, -0.25617039f, 0.11212593f, -0.08844183f, 0.07323780f, -0.03011523f, 0.12496684f, 0.25496629f, 
    -0.01800746f, 0.17513569f, 0.01653656f, 0.13997835f, -0.01881200f, 0.03334881f, 0.03162629f, -0.12299520f, 
    0.02641742f, -0.02317528f, -0.05908806f, 0.08989885f, -0.05277542f, -0.06480669f, -0.02590908f, 0.00086944f, 
    -0.23641187f, -0.11214989f, -0.11203817f, -0.16483842f, 0.06269110f, 0.11272738f, 0.02371280f, -0.01502175f, 
    -0.10819152f, 0.04695910f, 0.18970326f, -0.16599002f, -0.60279518f, 0.01773227f, -0.06478349f, -0.04785077f, 
    -0.00412775f, -0.10633548f, 0.08538337f, 0.10399602f, 0.20050170f, 0.14713836f, -0.05764127f, -0.03574873f, 
    0.02044982f, 0.11422934f, 0.08277548f, -0.27028111f, -0.00013353f, 0.07040393f, -0.08567727f, 0.02298609f, 
    0.07571034f, -0.10927505f, -0.13218673f, 0.15887980f, -0.35786495f, 0.16484430f, 0.14574890f, 0.06960271f, 
    0.04059928f, -0.03859834f, -0.07060064f, -0.07542425f, 0.00432175f, -0.13146929f, 0.10922638f, 0.12325448f, 
    -0.48557755f, -0.02843992f, -0.10143871f, -0.25669107f, -0.09978223f, 0.04048970f, 0.12546976f, 0.12460793f, 
    -0.09529841f, -0.00555175f, -0.02287909f, 0.16135585f, -0.05755740f, -0.12578000f, 0.03100273f, -0.02265455f, 
    -0.03280576f, 0.16948615f, 0.11369008f, -0.04619117f, 0.04319198f, 0.09833169f, 0.06118234f, 0.12883654f, 
    -0.02559911f, -0.22882444f, 0.03369168f, -0.17250030f, -0.09362747f, 0.10189444f, 0.03234896f, -0.15862650f, 
    -0.04512100f, -0.01320272f, 0.01639394f, -0.12678014f, -0.30924872f, 0.32219550f, 0.10851135f, -0.12006890f, 
    -0.08033486f, 0.14172269f, 0.07757901f, 0.11837979f, 0.12713657f, 0.07341146f, 0.19218616f, 0.07781686f, 
    -0.09651062f, 0.20147678f, 0.05691262f, -0.28714916f, 0.14008170f, 0.09103081f, 0.01601677f, 0.06055342f, 
    0.06574887f, -0.11255123f, 0.15243146f, -0.09663583f, 0.01384961f, 0.01474560f, 0.20010376f, 0.27804559f, 
    0.03874838f, 0.09490079f, 0.03538381f, -0.05813046f, 0.06770895f, 0.05669595f, -0.04727705f, -0.11187951f, 
    -0.22778186f, 0.17401545f, -0.12851787f, -0.34007865f, 0.13819431f, -0.11980298f, -0.01998061f, -0.08052225f, 
    -0.02080809f, 0.05081433f, 0.21223183f, 0.02719696f, -0.06897755f, 0.02784142f, 0.46611562f, -0.28014821f, 
    -0.01334969f, 0.01585265f, -0.04023591f, -0.13360281f, -0.15917771f, -0.02716501f, -0.10569929f, -0.05472536f, 
    0.14745371f, -0.14827278f, 0.01428492f, -0.19148695f, -0.03468647f, 0.04294550f, 0.11465602f, -0.01328385f, 
    0.05608360f, 0.04572265f, 0.02176478f, 0.00536830f, -0.12354388f, 0.17675975f, 0.08332770f, -0.06942838f, 
    -0.15730651f, -0.03170788f, 0.06287989f, 0.20931545f, 0.04044300f, -0.05694308f, 0.06951903f, 0.01793211f, 
    -0.18639943f, -0.07842181f, 0.04839619f, -0.31267041f, 0.11637145f, 0.12704664f, -0.08723022f, -0.07826399f, 
    0.05320435f, -0.09381628f, 0.13373488f, -0.00881209f, -0.22641657f, -0.16528092f, 0.08058477f, 0.06104659f, 
    -0.03805806f, -0.03857544f, 0.05930837f, -0.00401512f, -0.00104009f, 0.01780082f, 0.10092272f, 0.14249586f, 
    0.30285344f, -0.19373700f, 0.04928950f, 0.19179630f, -0.03731530f, -0.03128978f, -0.15843900f, 0.02830253f, 
    0.03741652f, 0.04268828f, -0.04473488f, 0.04150171f, 0.17760412f, 0.32434139f, -0.08240105f, 0.02340186f, 
    -0.05181142f, -0.05165575f, 0.15824890f, 0.14303821f, 0.12234978f, -0.01703962f, 0.03051156f, 0.13433875f, 
    0.26826915f, -0.22388867f, 0.00681516f, 0.26232752f, -0.08682913f, -0.04493514f, -0.03917582f, 0.04389109f, 
    0.22163191f, 0.06299727f, 0.04989004f, -0.10702369f, 0.04136208f, -0.14852697f, -0.00456368f, 0.11675724f, 
    -0.12104297f, 0.03141350f, -0.03258392f, 0.09052511f, 0.16820112f, -0.11367403f, -0.00173204f, -0.05276414f, 
    -0.21524134f, 0.02941760f, 0.03357461f, 0.04524215f, -0.05892109f, -0.10471819f, 0.04353684f, 0.01590313f, 
    0.15042813f, 0.04224029f, 0.11655464f, 0.04027544f, -0.01870181f, -0.20646362f, 0.07548121f, 0.08182251f, 
    -0.04394865f, -0.03248479f, -0.05113757f, -0.05156493f, 0.09815927f, 0.07048177f, 0.01904327f, 0.17135961f, 
    -0.15654926f, -0.17836492f, -0.17430580f, 0.08231866f, -0.10390431f, 0.01590658f, -0.04746777f, -0.01624835f, 
    0.06190697f, 0.13212964f, -0.12785618f, 0.06828055f, 0.31781036f, 0.00905680f, -0.05019630f, 0.06901091f, 
    0.01187881f, 0.02779352f, 0.06542566f, 0.13226166f, -0.14258417f, -0.00750410f, 0.03787271f, 0.15947086f, 
    -0.04792090f, -0.20214224f, -0.10312162f, 0.13672362f, -0.15504053f, -0.09604907f, -0.03346673f, -0.03192263f, 
    -0.04860253f, -0.16507316f, -0.17117311f, 0.04951611f, -0.34605205f, 0.30962867f, 0.20287307f, -0.08706654f, 
    0.15651357f, 0.12874681f, 0.15882760f, 0.06843763f, -0.05698130f, 0.11719216f, 0.02115016f, 0.05741322f, 
    0.31713915f, -0.42737871f, -0.15723820f, 0.13816817f, -0.00272977f, -0.07324529f, 0.14031017f, 0.00061350f, 
    0.04379018f, -0.10259128f, 0.05013525f, 0.16357332f, -0.35938182f, -0.18582724f, 0.23055515f, 0.01306258f, 
    0.08935477f, 0.01558032f, -0.13956527f, -0.03603652f, 0.24960202f, -0.03790553f, 0.11667751f, -0.13185760f, 
    0.18478185f, -0.18624453f, 0.03158508f, 0.05668503f, 0.17478245f, -0.13736977f, 0.17047346f, 0.02491370f, 
    -0.06491150f, 0.05930837f, -0.06634459f, 0.08173767f, 0.11215200f, 0.04492867f, -0.15473685f, 0.02382610f, 
    -0.20761898f, -0.10041796f, 0.04117879f, -0.17029598f, 0.07983270f, 0.10543408f, -0.01883961f, 0.12071031f, 
    0.26251769f, -0.17580076f, -0.08327711f, -0.03217886f, 0.21753421f, 0.12913990f, 0.02286480f, 0.08928189f, 
    0.01526697f, -0.04150215f, 0.12960774f, 0.13533254f, 0.14575906f, -0.17798294f, 0.15111303f, 0.07111392f, 
    -0.05303589f, 0.16309087f, -0.06537204f, -0.20843968f, 0.00026869f, 0.09051500f, 0.00937226f, 0.01588859f, 
    0.25511923f, 0.02722199f, 0.20528574f, 0.06972212f, -0.05983506f, -0.16074380f, 0.09246662f, -0.02448289f, 
    -0.05100251f, -0.07219976f, -0.06767587f, -0.01407008f, 0.23082383f, -0.10583279f, -0.11851212f, 0.03826519f, 
    -0.03316009f, -0.11522410f, 0.09409373f, 0.05398037f, -0.11184029f, -0.18965173f, 0.00354027f, -0.10684042f, 
    0.14477962f, 0.04574608f, 0.09619862f, -0.39458215f, -0.03911156f, 0.00586096f, 0.01013629f, -0.03724848f, 
    -0.00445122f, -0.07352300f, -0.03010541f, 0.05930840f, 0.37920964f, -0.12360326f, 0.10897711f, 0.09995939f, 
    -0.04082731f, 0.13981712f, 0.11150960f, 0.08876676f, -0.16212949f, -0.05295942f, -0.16455403f, 0.11333608f, 
    -0.07961970f, -0.28981185f, -0.11568308f, -0.12780862f, 0.17933780f, -0.05494376f, 0.08435985f, -0.00911283f, 
    -0.00946544f, 0.00246459f, 0.05147418f, -0.01111694f, 0.15542248f, 0.32816911f, 0.18112543f, 0.14813966f, 
    -0.03471743f, -0.01778981f, 0.11084919f, 0.09070865f, -0.14174056f, 0.03288781f, 0.09775180f, 0.02248560f, 
    0.19790536f, 0.12493564f, 0.21144268f, -0.05845179f, 0.03534959f, -0.03352583f, 0.20330183f, 0.08900307f, 
    -0.12652875f, -0.16345957f, -0.00615068f, 0.12417974f, 0.12558624f, -0.27769390f, -0.33346555f, 0.07319411f, 
    0.21843708f, 0.04074133f, -0.11199241f, 0.10037051f, 0.08198956f, -0.02925024f, -0.03771356f, -0.01508894f, 
    0.02267139f, -0.24061605f, -0.10498977f, -0.13455066f, -0.02400255f, -0.11246472f, 0.11506047f, -0.07902810f, 
    -0.01923625f, 0.05471997f, 0.10661352f, 0.04852185f, 0.23510432f, 0.13281979f, -0.10285735f, -0.01961433f, 
    0.08649390f, 0.12945317f, -0.02743622f, 0.05735392f, -0.04494673f, -0.06390927f, -0.07091568f, 0.03588903f, 
    0.08482227f, -0.30951437f, 0.09937306f, -0.21169806f, -0.01709755f, 0.09046301f, -0.04993044f, 0.04220650f, 
    0.01250087f, 0.12193684f, -0.07521793f, 0.10403502f, 0.12287073f, 0.13489924f, 0.17051908f, 0.08567271f, 
    0.10886307f, 0.05097142f, 0.12247682f, 0.13202165f, -0.08435883f, -0.04767540f, -0.07162423f, 0.00327086f, 
    -0.03588390f, 0.00828416f, -0.02458340f, -0.01835030f, -0.04542268f, 0.00147056f, -0.01224304f, 0.05582999f, 
    0.06076121f, 0.05507419f, 0.05851261f, 0.00128521f, -0.04832238f, -0.05170410f, 0.04796448f, 0.04757228f, 
    -0.01441481f, 0.03409807f, 0.00539070f, 0.05852523f, -0.03128426f, -0.07755430f, -0.04561510f, -0.04464330f, 
    0.00267004f, -0.02397651f, -0.00215095f, -0.06275236f, -0.07330897f, -0.01887396f, -0.05687426f, -0.01206291f, 
    0.01983926f, -0.06341384f, -0.03605090f, -0.00783409f, 0.00036262f, 0.04199904f, 0.05142471f, -0.02041188f, 
    0.02970725f, 0.05408047f, 0.04216028f, 0.03465322f, -0.04117735f, 0.00625473f, -0.04891571f, -0.02770297f, 
    -0.00122126f, -0.00262977f, -0.04573221f, 0.01553255f, -0.06834763f, -0.03121264f, 0.00948340f, -0.01190878f, 
    -0.06403773f, -0.04362411f, 0.02536873f, -0.02317872f, -0.00573174f, -0.02538763f, -0.06925184f, 0.00755571f, 
    -0.07185237f, 0.00747005f, -0.04403767f, 0.03459146f, 0.01968748f, -0.06284206f, -0.07160772f, -0.02131765f, 
    -0.03847641f, 0.02351963f, -0.02598544f, 0.04162956f, 0.03831637f, 0.02872787f, -0.06772175f, 0.02953152f, 
    -0.03882485f, -0.00233846f, -0.06402644f, 0.01206320f, -0.06049997f, 0.00749807f, -0.00901442f, -0.01523430f, 
    -0.01229568f, 0.01396326f, 0.03721416f, -0.06156281f, -0.02804039f, 0.05887710f, 0.02638020f, -0.00266990f, 
    -0.00247286f, -0.06569055f, 0.03364741f, 0.02008793f, 0.05282442f, 0.05436712f, 0.05010289f, -0.03973752f, 
    -0.05946825f, 0.00727078f, -0.02932560f, 0.05401415f, 0.02518333f, 0.02047845f, 0.05525027f, 0.05344031f, 
    -0.06768412f, -0.03217421f, 0.05241398f, -0.03648629f, -0.07521344f, -0.05495675f, 0.00650233f, -0.00634057f, 
    -0.05026753f, -0.01514660f, 0.03263234f, 0.00973333f, -0.07986519f, -0.04845586f, -0.04956454f, -0.02898080f, 
    0.00989528f, -0.03569008f, -0.03149310f, 0.01716647f, -0.05230335f, -0.03228392f, -0.06688540f, 0.03188316f, 
    -0.06422988f, 0.05195447f, -0.04210044f, 0.06075389f, -0.03862090f, -0.03033884f, -0.01216705f, 0.02743306f, 
    -0.06702475f, 0.06412566f, -0.02184776f, 0.03727776f, 0.02211311f, -0.04966722f, 0.05428082f, 0.00623484f, 
    0.00789167f, -0.01569399f, 0.05771834f, -0.00802363f, -0.02873625f, -0.04923132f, -0.01154385f, -0.02117302f, 
    0.01531133f, -0.00883680f, 0.00803366f, 0.06255768f, -0.00381725f, -0.03178076f, -0.02270861f, 0.02430969f, 
    0.03903279f, -0.03347275f, -0.00845602f, -0.02008672f, 0.03219058f, -0.07718828f, 0.02566742f, -0.06037634f, 
    0.01141354f, 0.00385638f, -0.04483234f, 0.00240546f, 0.03682946f, -0.00774751f, -0.01472416f, -0.06792123f, 
    -0.03900625f, 0.03135198f, 0.00595341f, -0.00988454f, -0.05684604f, 0.04644472f, 0.00444988f, -0.05087537f, 
    -0.30693692f, -0.11654259f, 0.00158141f, -0.13824891f, -0.00462751f, -0.07911178f, 0.17899323f, 0.01210109f, 
    -0.06314789f, 0.11430586f, -0.05661596f, -0.07343192f, 0.06276771f, -0.02509702f, 0.05553136f, 0.30041492f, 
    -0.03201667f, -0.02385813f, 0.00410427f, 0.24064738f, 0.11278631f, 0.09275706f, 0.04685150f, 0.08634285f, 
    0.05546004f, -0.02842290f, 0.12287901f, -0.09382490f, 0.02361031f, -0.04713989f, 0.03530530f, 0.04728318f, 
    -0.07751448f, 0.04228619f, 0.07586165f, -0.01538796f, -0.26298776f, 0.40064707f, -0.39757502f, 0.24577907f, 
    0.03524037f, 0.16064999f, -0.17107284f, -0.06878886f, 0.01977815f, 0.06137956f, -0.00843073f, 0.09712311f, 
    0.24867147f, -0.01874821f, 0.04003230f, -0.04726532f, 0.01071254f, -0.01181920f, 0.11028657f, 0.09089375f, 
    -0.05650378f, 0.04507644f, 0.04808076f, 0.04573474f, 0.30964276f, -0.14483297f, -0.10990269f, 0.03209810f, 
    0.07263469f, 0.18986291f, 0.00043104f, 0.10926637f, -0.11945488f, -0.00833690f, 0.00746803f, -0.06697434f, 
    0.07010425f, 0.03389386f, -0.24466543f, 0.45742238f, 0.13221712f, -0.08476197f, 0.00379350f, -0.01023545f, 
    -0.02779121f, 0.01420328f, 0.02645124f, -0.03670094f, 0.26640433f, 0.04187796f, 0.01738460f, -0.17218287f, 
    0.03817563f, -0.09208389f, 0.04275784f, -0.07667352f, -0.11377761f, -0.08032867f, 0.08340538f, 0.08384493f, 
    0.37875926f, 0.24785408f, -0.07059152f, 0.23915406f, -0.10517251f, -0.12466078f, -0.00329032f, 0.05831787f, 
    0.08942404f, 0.13873710f, -0.02144181f, -0.05598599f, 0.24112242f, -0.14008617f, 0.09139797f, -0.02930068f, 
    0.11110635f, -0.22059746f, 0.10203547f, 0.08778610f, 0.09350884f, -0.13481699f, 0.01425492f, -0.10017215f, 
    0.21120542f, -0.14019454f, 0.05672200f, 0.05242046f, 0.18073307f, -0.05899109f, 0.11875265f, -0.11947548f, 
    -0.09549841f, -0.01131724f, -0.16192427f, 0.07152515f, 0.17256208f, -0.16009864f, 0.03311796f, 0.05492123f, 
    0.08499039f, 0.00340646f, 0.18217291f, 0.13947961f, 0.07684246f, 0.08201107f, -0.06050783f, -0.00870830f, 
    -0.20411913f, 0.10683759f, -0.15540534f, 0.03443800f, 0.08040345f, -0.02069655f, -0.20689104f, 0.10500930f, 
    0.00389444f, 0.14671893f, 0.03500064f, -0.01336761f, -0.12112889f, 0.11176092f, -0.34531069f, -0.17370747f, 
    -0.00383715f, -0.08716206f, -0.02639942f, 0.00198034f, 0.09070981f, 0.04998567f, 0.00896158f, 0.07060429f, 
    0.07487676f, 0.17049123f, -0.06643855f, 0.24553634f, 0.05390647f, 0.07299989f, 0.13311116f, 0.02688613f, 
    -0.01430171f, 0.01300017f, 0.02030601f, -0.14003424f, -0.07862630f, 0.37797794f, -0.41838357f, -0.03331521f, 
    0.05764021f, 0.01718249f, -0.10332608f, 0.14254515f, -0.05364979f, -0.08269667f, -0.21822099f, -0.04004752f, 
    0.32554954f, -0.38995540f, 0.31382442f, -0.07676125f, 0.01372654f, 0.01071168f, 0.06302228f, 0.07177282f, 
    -0.07875569f, 0.09691122f, -0.12952808f, 0.17317466f, -0.01228669f, -0.02890471f, 0.16012038f, 0.14533971f, 
    0.11315105f, 0.02114242f, -0.00941315f, 0.11880492f, -0.22621180f, -0.10997987f, 0.08600616f, 0.01789146f, 
    -0.06662185f, -0.17898351f, 0.20653063f, -0.22638179f, 0.06379093f, 0.17430414f, -0.15068407f, 0.18460405f, 
    0.10809850f, 0.01505080f, 0.10305556f, 0.05158275f, 0.58830827f, -0.02611656f, -0.22909956f, 0.02521714f, 
    0.01512071f, 0.05260871f, 0.11096267f, 0.02384632f, -0.04443475f, 0.01062589f, -0.01993919f, 0.00414258f, 
    0.49963403f, -0.12391320f, 0.03884614f, 0.01714313f, -0.19264369f, -0.03874150f, -0.01929907f, 0.07920998f, 
    0.02555447f, -0.04967764f, -0.03790417f, 0.18202315f, -0.01307910f, -0.21975891f, -0.02687346f, -0.06281470f, 
    -0.12733753f, 0.08711835f, -0.05152702f, 0.02070061f, -0.00622784f, 0.01046194f, -0.03154547f, 0.11613762f, 
    -0.11192477f, 0.23990658f, -0.01679604f, 0.17735362f, -0.04419228f, 0.05970019f, 0.01047938f, 0.06228349f, 
    -0.01870766f, 0.03127760f, 0.06588177f, -0.07655074f, -0.38003936f, 0.14252107f, -0.03543052f, 0.18123390f, 
    -0.11823036f, 0.20837067f, -0.00452485f, 0.00304709f, -0.06786299f, -0.08418721f, 0.10936011f, 0.07817911f, 
    0.02766070f, -0.31919014f, -0.02904620f, -0.13887894f, -0.03057125f, -0.07314313f, -0.03514871f, -0.08659158f, 
    -0.05885076f, 0.03328647f, -0.01671312f, 0.11930329f, 0.07590556f, -0.30504602f, 0.11102527f, 0.26540735f, 
    -0.16347864f, 0.03040052f, 0.20299859f, 0.03629145f, 0.13812500f, 0.00952022f, 0.01916822f, 0.05856062f, 
    -0.11214700f, -0.15881225f, 0.06425183f, -0.11885985f, -0.09190393f, 0.06672595f, -0.01734099f, -0.02570470f, 
    -0.09231742f, -0.04237290f, 0.12574770f, 0.02998379f, -0.28409022f, 0.13122879f, -0.05879435f, 0.15267150f, 
    0.10568833f, 0.07866433f, 0.02744929f, 0.17094754f, -0.10474151f, 0.07170793f, -0.04549867f, 0.03711960f, 
    -0.14322804f, -0.11512402f, 0.09415269f, -0.08088503f, 0.02197937f, -0.06847976f, 0.02747242f, -0.22352219f, 
    0.19997148f, -0.03167801f, -0.02023552f, 0.07890292f, 0.05458350f, 0.17611791f, 0.02089759f, -0.03518333f, 
    0.13892016f, 0.06754261f, -0.01915919f, 0.01301734f, 0.15189445f, 0.08457274f, 0.08701567f, -0.02325455f, 
    0.38942075f, 0.05745415f, 0.00099983f, 0.13058780f, 0.14476930f, 0.03292980f, -0.05386496f, -0.07868581f, 
    0.05124573f, 0.04093973f, 0.10452276f, 0.09458656f, -0.54251468f, -0.01576424f, 0.27718580f, 0.00142897f, 
    0.01145945f, 0.01051792f, -0.00371634f, 0.11653364f, 0.13378134f, -0.08297138f, 0.02410275f, -0.07477311f, 
    0.23083410f, 0.45704469f, -0.08876534f, -0.03577678f, -0.11686106f, -0.01257785f, -0.15155761f, 0.13501875f, 
    -0.05396243f, 0.07768970f, -0.20090161f, 0.10992304f, 0.14104019f, 0.06628703f, 0.20936644f, 0.17940880f, 
    -0.03730505f, 0.18160912f, 0.12374762f, 0.12568501f, 0.05053341f, -0.08919280f, -0.11253436f, -0.05776098f, 
    -0.04069835f, 0.05237110f, -0.07280926f, -0.21053886f, 0.14415114f, 0.12446633f, -0.07970326f, 0.15291080f, 
    -0.09992896f, 0.09950126f, 0.00783421f, 0.06481674f, 0.02339781f, 0.10755872f, -0.06589155f, 0.12961656f, 
    0.06276458f, 0.00977913f, 0.08952777f, -0.03496969f, -0.12370524f, 0.07593735f, -0.01027869f, 0.19042151f, 
    0.21006522f, 0.31611034f, 0.09442118f, -0.02677316f, 0.19652694f, -0.05029611f, -0.18517844f, -0.11186938f, 
    -0.04705372f, 0.14539035f, -0.08046094f, 0.11922519f, -0.33644801f, 0.05850991f, 0.05798308f, 0.10724503f, 
    -0.09902558f, -0.03084259f, -0.11081278f, 0.00285728f, -0.05409304f, -0.10903551f, -0.07307684f, 0.00833108f, 
    -0.13221610f, 0.12088577f, 0.12008860f, 0.16791271f, 0.07050729f, 0.08508880f, 0.04695011f, -0.06246017f, 
    -0.00422895f, -0.10907960f, -0.02408696f, -0.06101279f, 0.17948072f, 0.16118774f, -0.05200451f, 0.25389600f, 
    -0.03555654f, 0.06969706f, 0.04179752f, -0.05167830f, -0.11891801f, 0.10578746f, -0.12206271f, -0.02292950f, 
    -0.07273323f, -0.01133588f, 0.13208579f, -0.05066216f, 0.10081883f, 0.04859233f, 0.01199045f, -0.05177408f, 
    -0.00059555f, -0.08710226f, -0.04022685f, -0.15155962f, 0.55978501f, 0.06645127f, -0.09960970f, 0.14707834f, 
    0.12186608f, 0.04099883f, -0.12027356f, -0.02527048f, 0.08457771f, 0.09309753f, 0.05787949f, 0.03913129f, 
    0.43133557f, 0.05002016f, -0.25882962f, -0.06681540f, 0.01615254f, 0.07392784f, -0.17347011f, -0.11772409f, 
    -0.13626947f, 0.04699607f, -0.10107677f, -0.08855764f, -0.22307730f, 0.07579264f, 0.08433268f, 0.00622071f, 
    -0.06781695f, 0.02603488f, 0.00784796f, -0.02222780f, -0.00991241f, 0.07908481f, -0.12381022f, 0.02630111f, 
    -0.33423102f, 0.04164903f, 0.11721572f, 0.10807616f, 0.22400422f, 0.07532281f, 0.15251552f, 0.00611291f, 
    0.03057452f, -0.16584675f, -0.21938740f, -0.06624648f, -0.35717636f, -0.25500414f, 0.38591468f, -0.00258555f, 
    -0.03852438f, -0.10795819f, -0.04607410f, -0.11987016f, 0.00658482f, 0.09221219f, 0.06977595f, 0.12562595f, 
    -0.09880616f, 0.10233139f, -0.01798287f, 0.19568507f, 0.16318217f, 0.03627326f, 0.06974185f, -0.28294882f, 
    -0.08984531f, 0.16304962f, 0.04924216f, -0.15907149f, 0.22986403f, -0.08235968f, -0.15525503f, 0.14349855f, 
    0.15966935f, -0.13870525f, 0.13969366f, -0.03755268f, 0.05680028f, -0.14973433f, 0.07734040f, 0.04535598f, 
    0.16524008f, 0.26531941f, -0.16899198f, 0.11673621f, 0.13254857f, 0.03563401f, 0.09780822f, -0.04615597f, 
    0.11002777f, 0.10423885f, 0.05167440f, 0.07048447f, -0.15655768f, 0.04896120f, -0.07252001f, 0.09101759f, 
    -0.04746788f, -0.30382884f, -0.14477074f, 0.09163862f, 0.13174802f, 0.06829921f, 0.15372171f, -0.02040763f, 
    -0.31705624f, 0.06492841f, 0.04651809f, 0.37251052f, -0.00031535f, -0.01705584f, 0.00848734f, 0.08603496f, 
    -0.12693366f, 0.04998106f, 0.05007087f, 0.08606037f, 0.38330010f, -0.10258698f, 0.13232961f, -0.27514172f, 
    -0.09283324f, 0.02666772f, -0.06226115f, 0.05104624f, 0.02315245f, 0.15267481f, -0.05185942f, 0.13197161f, 
    0.06622663f, -0.22056304f, -0.05168250f, 0.22366990f, 0.06580129f, 0.09481707f, 0.04054796f, 0.21003124f, 
    0.01543063f, -0.12897402f, 0.12555403f, -0.14708200f, 0.45421109f, 0.21179305f, 0.01920998f, -0.07850871f, 
    -0.03873505f, -0.02012704f, 0.04827920f, -0.00680389f, 0.06095852f, -0.11778954f, 0.00514087f, -0.15247218f, 
    0.26390350f, 0.12061419f, 0.07879528f, 0.11951231f, -0.00346624f, -0.03851331f, -0.02097815f, -0.00810030f, 
    0.17654385f, -0.08702292f, -0.10989662f, 0.02122225f, -0.08848613f, 0.06014385f, -0.28090817f, -0.00241033f, 
    0.09677765f, 0.01201697f, -0.11698423f, 0.03798749f, 0.06621211f, -0.14335361f, 0.09720179f, -0.09760465f, 
    0.01074275f, -0.12071575f, 0.12922724f, 0.29680347f, -0.00950644f, -0.20859088f, 0.21015374f, 0.09457871f, 
    -0.05513963f, 0.01183282f, -0.00456966f, 0.09638221f, -0.18241724f, -0.01921937f, -0.02931503f, -0.10413868f, 
    -0.15296844f, -0.04330827f, 0.05898708f, 0.08643267f, 0.16090541f, 0.11483409f, 0.13514601f, -0.01654616f, 
    -0.28426254f, -0.09723429f, -0.19766623f, 0.20733446f, 0.04629202f, 0.16755207f, 0.09749287f, -0.03282693f, 
    -0.09124407f, -0.10487434f, -0.12605098f, -0.11199185f, 0.33090717f, -0.19441086f, 0.22115566f, -0.09687521f, 
    0.22537556f, 0.04265911f, 0.09967671f, -0.03639321f, -0.11169548f, -0.07354160f, -0.09228262f, -0.01298414f, 
    -0.05486587f, -0.09064672f, 0.16002809f, 0.07331470f, -0.07433037f, 0.06423170f, -0.08251115f, 0.07565004f, 
    0.00195317f, -0.03858300f, 0.02482467f, 0.07550481f, 0.01882494f, 0.25412929f, 0.05225292f, -0.06710307f, 
    0.09978232f, -0.03859986f, 0.06384850f, 0.01130520f, -0.05668922f, -0.12785572f, -0.05594417f, -0.17367910f, 
    0.02714621f, -0.26487866f, -0.12162136f, 0.34751573f, -0.03137643f, 0.07298229f, 0.27920005f, -0.01574959f, 
    -0.07916335f, -0.00749033f, 0.25283915f, 0.16020356f, -0.35109752f, -0.10336053f, 0.15004310f, -0.13908659f, 
    0.26712617f, 0.04051786f, -0.04836587f, 0.09056804f, 0.15748903f, 0.03135483f, -0.30199835f, -0.06515360f, 
    0.19776972f, 0.23504756f, 0.00997944f, 0.10799129f, -0.02143375f, 0.02075857f, 0.10341713f, 0.00791910f, 
    0.02739516f, 0.14323854f, 0.07625062f, 0.16064580f, 0.13718639f, -0.12895906f, 0.13404545f, 0.36629066f, 
    0.16665043f, -0.16761486f, 0.05835306f, 0.24716796f, 0.15601011f, 0.13417968f, 0.04564537f, -0.07311015f, 
    -0.04694974f, -0.00849590f, 0.34384227f, 0.13142441f, -0.04406713f, -0.04772834f, 0.21296453f, 0.02391151f, 
    -0.23582679f, 0.06762372f, 0.04039737f, 0.11416344f, 0.24266233f, 0.20360321f, -0.20612848f, 0.12643743f, 
    -0.08468631f, 0.07704044f, -0.29433578f, -0.05464638f, -0.01898895f, 0.00409083f, 0.02916311f, 0.05178713f, 
    -0.12599896f, -0.23548777f, -0.22193599f, -0.30639040f, -0.08580255f, 0.04551011f, 0.08514139f, 0.00048303f, 
    -0.04223766f, -0.04082062f, 0.17616059f, -0.05324055f, 0.32753366f, -0.10112229f, 0.14835665f, -0.08537968f, 
    0.07810473f, 0.20827772f, -0.08822761f, -0.07308906f, -0.18520708f, -0.06360871f, -0.23185229f, -0.01206298f, 
    0.18060967f, 0.04392311f, -0.07890061f, 0.41458690f, 0.04996762f, -0.08575971f, -0.12357833f, 0.09427372f, 
    -0.05230564f, 0.14350389f, -0.15532485f, -0.05207833f, -0.02905923f, -0.16267011f, -0.13004281f, -0.28589389f, 
    0.09195129f, -0.18648469f, -0.23794836f, -0.28726545f, 0.05755222f, 0.07892846f, 0.14518361f, 0.19451350f, 
    0.34179589f, 0.27677295f, -0.06506985f, 0.00525644f, 0.00954891f, 0.12010206f, 0.11928355f, 0.18282391f, 
    -0.10884368f, 0.06156735f, -0.07682148f, 0.16911146f, 0.32336646f, -0.28388765f, -0.44479543f, -0.24459733f, 
    -0.03057225f, -0.09659497f, 0.13144653f, -0.01086227f, 0.24490742f, 0.00066183f, 0.20663825f, 0.01060508f, 
    -0.03483081f, -0.12078886f, -0.25478539f, 0.04142227f, -0.04584560f, -0.06087824f, 0.05091329f, -0.12164930f, 
    -0.19876634f, -0.05666269f, 0.02309042f, 0.11366133f, 0.24749523f, -0.01781193f, -0.04049367f, -0.21322028f, 
    0.18081456f, 0.05736524f, 0.19946529f, 0.16680717f, 0.02665669f, -0.03539645f, -0.29335812f, 0.17722601f, 
    0.08699688f, 0.22615559f, 0.07014845f, -0.04058030f, -0.01016606f, 0.11739367f, -0.00273249f, 0.24745549f, 
    -0.00455923f, 0.05395310f, -0.01325330f, 0.06073195f, -0.05611173f, 0.00848126f, 0.08579957f, 0.16194414f, 
    0.25183144f, -0.04111309f, -0.06764813f, -0.03856161f, -0.10112883f, -0.09017382f, 0.07827286f, -0.09081476f, 
    -0.07326955f, 0.16492201f, -0.13568401f, 0.00036506f, -0.10139436f, 0.04605298f, 0.01550496f, 0.13143119f, 
    0.05251626f, 0.06720629f, 0.21247399f, -0.05359521f, -0.05052040f, 0.04551204f, -0.09256180f, -0.06145661f, 
    -0.03374047f, -0.01834840f, -0.06234170f, -0.09557946f, 0.02631918f, -0.14784239f, -0.15835521f, -0.00269426f, 
    0.08431879f, -0.10243066f, 0.26035050f, 0.08835602f, 0.01506958f, 0.06854466f, 0.06870787f, 0.06536695f, 
    0.18503888f, -0.07027981f, 0.00866183f, -0.06985784f, 0.03696982f, -0.07496517f, -0.04411187f, 0.02071914f, 
    0.16777374f, 0.06768584f, 0.04013796f, 0.05527330f, -0.03145328f, -0.03438204f, 0.13298121f, -0.12459464f, 
    0.08858849f, 0.12614429f, 0.12159197f, -0.05128154f, -0.17866169f, 0.00199225f, 0.08593243f, -0.05160815f, 
    0.04300652f, -0.03586030f, -0.09845923f, -0.02993968f, -0.25204644f, 0.12258320f, 0.04845633f, 0.10881784f, 
    -0.00859671f, 0.09609756f, 0.14477792f, 0.09214073f, 0.04120968f, 0.01749418f, -0.06362823f, -0.12982515f, 
    -0.23673739f, -0.18330659f, -0.21546419f, -0.13412938f, -0.06757981f, -0.00114065f, 0.00974220f, -0.00114233f, 
    0.08758684f, 0.10455873f, -0.09243093f, -0.00543035f, 0.02474472f, -0.04895139f, 0.18630207f, -0.01237534f, 
    0.02960939f, -0.11653487f, -0.02263818f, -0.08936588f, 0.00842577f, 0.10401020f, 0.03771915f, 0.29414278f, 
    0.14922950f, -0.23185472f, -0.07772833f, 0.40766478f, 0.22059242f, 0.01721327f, 0.00800180f, -0.01807507f, 
    -0.13421358f, 0.11675624f, -0.05485091f, -0.05354833f, -0.17160250f, -0.30115053f, 0.08709180f, 0.14429073f, 
    0.17074896f, 0.04397578f, -0.05037643f, -0.12548935f, 0.09970611f, 0.06410684f, -0.00342519f, 0.01661596f, 
    -0.03039138f, 0.49536595f, 0.09913797f, -0.00785823f, -0.15296166f, 0.10757385f, -0.16189373f, -0.01431731f, 
    -0.07021168f, 0.11648822f, -0.06321592f, -0.03023432f, -0.03320894f, -0.34162578f, -0.19909815f, -0.18138513f, 
    0.13211642f, 0.06230280f, -0.07585815f, -0.02942756f, -0.08637113f, -0.00526004f, -0.00239650f, -0.03914258f, 
    -0.20480633f, -0.03399116f, 0.02590641f, -0.23189117f, 0.05708163f, 0.02111524f, 0.07819096f, 0.09748068f, 
    0.22757243f, 0.18269633f, 0.13210355f, 0.11775738f, 0.20804003f, 0.06120618f, -0.04487206f, -0.05640574f, 
    -0.08242404f, -0.06405164f, 0.06671727f, -0.00767258f, 0.08375970f, 0.00144430f, 0.09923426f, 0.05313355f, 
    0.36337650f, 0.40245929f, -0.07196421f, 0.12270395f, 0.01226325f, -0.08550669f, -0.04557286f, 0.26383579f, 
    0.09621423f, -0.02382125f, 0.03611906f, -0.12933838f, 0.11036470f, 0.29892287f, 0.08530403f, 0.12352148f, 
    0.18622921f, -0.03521870f, 0.02814389f, 0.06703585f, 0.00207131f, 0.14091933f, 0.02312284f, 0.18729913f, 
    0.01545621f, 0.40057740f, -0.09879422f, -0.18937154f, -0.11981790f, -0.01587807f, -0.07687231f, -0.08144078f, 
    -0.04422523f, -0.10180220f, -0.04183166f, -0.10994455f, -0.05331657f, -0.10809986f, 0.18480775f, 0.21251249f, 
    -0.09866751f, 0.12454463f, 0.07320638f, -0.12313080f, -0.07164779f, 0.01933718f, 0.17773847f, 0.10509954f, 
    -0.25121233f, 0.02741640f, -0.22190337f, -0.00180070f, 0.00150150f, 0.14298989f, -0.03599729f, -0.14221191f, 
    -0.06751506f, 0.05897473f, -0.02725272f, -0.13963324f, -0.18364693f, 0.09595988f, 0.29831675f, 0.11839245f, 
    0.17904478f, 0.16913843f, -0.09185831f, 0.10681009f, 0.07869227f, -0.05034346f, -0.09220579f, 0.12587641f, 
    -0.05111627f, 0.00717675f, -0.10001475f, 0.28583473f, -0.14275607f, 0.19379783f, -0.16845688f, 0.14716873f, 
    0.18445027f, 0.00173090f, 0.07638095f, -0.14632018f, 0.10981199f, -0.07466952f, -0.08605569f, -0.21981899f, 
    0.07208923f, -0.09295703f, -0.00014879f, 0.10522811f, 0.00763918f, -0.02840030f, 0.01648605f, 0.08664699f, 
    0.23729037f, 0.20515734f, 0.12479998f, 0.08874747f, 0.14091484f, -0.06984469f, -0.02489759f, -0.13036573f, 
    -0.08176373f, 0.08278988f, 0.00426669f, 0.11064132f, -0.06728964f, 0.22592463f, 0.06514323f, 0.08928126f, 
    0.11348481f, 0.13388467f, -0.04499875f, 0.06006648f, 0.00415545f, -0.00773698f, 0.11024369f, 0.05832224f, 
    -0.31042644f, 0.14390087f, 0.18378730f, -0.23007217f, -0.03922004f, -0.18617468f, -0.01302100f, -0.10247348f, 
    0.09691212f, -0.08731196f, 0.17831632f, 0.06294615f, -0.01668739f, 0.37564656f, 0.03948922f, -0.06293408f, 
    0.04693073f, 0.08697208f, -0.12830870f, -0.07365432f, 0.04577256f, -0.00093835f, 0.01299789f, 0.14073983f, 
    0.09088419f, -0.25895497f, 0.05790241f, -0.09945886f, 0.05459375f, -0.09235788f, -0.02107294f, -0.02745350f, 
    0.04593436f, -0.03878850f, 0.13672198f, -0.07600980f, -0.15395485f, 0.23116527f, 0.20443130f, 0.00757692f, 
    0.09322390f, 0.18817794f, -0.13186751f, -0.21721517f, 0.07820163f, -0.07623504f, -0.11177104f, 0.02793300f, 
    0.08705521f, 0.05041913f, 0.01857984f, 0.32882845f, 0.03799865f, -0.08052713f, -0.16835476f, -0.02700005f, 
    0.01968473f, 0.15014406f, -0.08341587f, -0.08766131f, -0.37262109f, 0.10084083f, 0.05866307f, 0.22014950f, 
    0.04926020f, 0.09353360f, 0.01204857f, 0.05119206f, -0.00539359f, 0.13861838f, 0.00835913f, -0.00914615f, 
    -0.29373789f, -0.21167083f, -0.00081067f, 0.16387856f, -0.02373430f, 0.19230828f, 0.17142434f, -0.13730083f, 
    0.13398392f, 0.08936660f, -0.14142445f, 0.14027277f, 0.16454069f, -0.28164524f, 0.03086405f, -0.24834533f, 
    0.00794144f, 0.20843776f, -0.00390227f, -0.08040827f, 0.05745102f, 0.00724528f, 0.20587467f, 0.09906811f, 
    0.05961886f, -0.26930684f, -0.00693636f, 0.12594809f, -0.04020409f, -0.03311777f, -0.00096476f, 0.09255815f, 
    0.09618712f, -0.07853369f, -0.12543924f, 0.11596140f, 0.00372832f, -0.15640862f, -0.12519416f, 0.03440215f, 
    0.00348713f, 0.02951435f, -0.03393738f, -0.13102320f, 0.11515217f, 0.03456514f, 0.06175314f, -0.05500667f, 
    -0.06456738f, 0.44805467f, -0.21274889f, 0.03326934f, -0.01258040f, -0.12682033f, -0.04144296f, 0.00455453f, 
    0.04918994f, 0.10071210f, -0.05740690f, -0.07540675f, -0.14376853f, -0.07960024f, 0.08051420f, 0.10622931f, 
    0.12113506f, 0.06177115f, -0.21619447f, -0.09453186f, 0.03863093f, 0.00512116f, -0.08715910f, -0.11742183f, 
    -0.10112178f, 0.11044170f, -0.04139274f, 0.50946689f, -0.20625861f, -0.00425199f, -0.11295284f, 0.13423412f, 
    0.01680330f, -0.00571009f, -0.03841311f, -0.03388873f, 0.21671303f, -0.03366924f, -0.04109396f, -0.35312495f, 
    -0.03073673f, -0.10212655f, -0.07787913f, 0.13141914f, -0.06184782f, -0.00359001f, -0.14699852f, -0.05833627f, 
    0.33036187f, -0.02427839f, -0.05784085f, -0.04696217f, 0.07277597f, -0.08723342f, 0.05724353f, -0.05196188f, 
    -0.08389295f, -0.05191869f, -0.09212195f, -0.11085320f, 0.06981042f, 0.02960174f, 0.21605098f, -0.08714962f, 
    -0.03024865f, -0.10376970f, -0.11870081f, -0.02297774f, -0.07985640f, -0.01674928f, -0.07012614f, 0.07545734f, 
    -0.03797546f, 0.04706308f, 0.13419302f, -0.17016451f, 0.09887670f, 0.00696370f, -0.02812907f, -0.09247455f, 
    -0.04333144f, -0.15944387f, 0.04731818f, 0.07726512f, -0.12581649f, 0.01456814f, -0.09433183f, 0.12409253f, 
    0.14965190f, -0.04019087f, -0.08329747f, -0.18685874f, -0.07396320f, 0.06399436f, 0.01157189f, 0.06829471f, 
    0.06516702f, -0.10289714f, 0.06475504f, 0.14959888f, 0.00733562f, -0.12899624f, 0.10000081f, -0.10124979f, 
    -0.07880110f, -0.02312848f, -0.06965371f, -0.18164372f, 0.10286820f, 0.03019263f, -0.10264204f, -0.15257196f, 
    0.01491429f, 0.00098423f, -0.00396705f, -0.10119005f, -0.03309407f, 0.04199535f, -0.13579823f, -0.09696262f, 
    -0.13156657f, 0.03000274f, 0.01978699f, 0.08734529f, -0.04492344f, 0.01537589f, -0.01361159f, -0.09265550f, 
    -0.04756202f, 0.00796517f, 0.01369010f, -0.02277562f, -0.23502526f, -0.06789631f, 0.27960825f, -0.12443191f, 
    0.04596470f, -0.06017978f, -0.02021863f, -0.11246784f, -0.05317453f, -0.07080007f, -0.10880272f, -0.02487851f, 
    -0.20067331f, 0.03543767f, 0.12235700f, 0.19075210f, -0.04038701f, 0.07006283f, 0.12076814f, -0.00004204f, 
    -0.01397337f, -0.07828998f, -0.02529202f, -0.00837911f, 0.26585928f, -0.04524674f, -0.02778602f, 0.03808173f, 
    0.03044049f, -0.19524796f, -0.01961556f, -0.03212447f, -0.04838549f, -0.06407117f, -0.04893459f, 0.05344648f, 
    -0.15215798f, 0.05169601f, -0.04525439f, 0.06642907f, -0.17451248f, -0.09597579f, -0.06096792f, -0.13606416f, 
    -0.09676727f, -0.04803035f, 0.01350687f, -0.06541479f, -0.00635922f, -0.09706554f, 0.07870985f, 0.06640393f, 
    0.10096260f, 0.01980263f, 0.05017074f, -0.09785849f, -0.07512884f, -0.02826064f, 0.00155284f, 0.05161337f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.12963912f, -0.02994572f, -0.00880502f, 0.03826815f, -0.00689874f, -0.03536605f, 0.03551135f, 0.04933157f, 
    -0.02401868f, -0.07428720f, -0.06538180f, 0.01616948f, -0.06161726f, 0.13893853f, 0.05131999f, -0.00737291f, 
    -0.08032647f, 0.05710778f, 0.03508354f, 0.12344112f, -0.04051434f, -0.06543656f, 0.08731932f, -0.07837705f, 
    0.04099141f, -0.04215466f, -0.03879097f, 0.06899448f, 0.05392343f, 0.04503892f, 0.07437207f, 0.19216047f, 
    -0.11147666f, -0.04655580f, -0.00410486f, -0.07029441f, -0.15401867f, 0.10970958f, 0.24007516f, -0.06832409f, 
    -0.08631340f, -0.18582095f, 0.08020787f, 0.00203140f, 0.00362689f, -0.01033208f, -0.06308141f, 0.15097654f, 
    -0.06828088f, 0.01574602f, 0.03077886f, 0.04154364f, 0.08609524f, 0.15786760f, -0.03810277f, -0.04289197f, 
    -0.04596008f, 0.03806642f, -0.01429714f, 0.07777256f, 0.03336901f, -0.00213967f, 0.03255273f, -0.09176867f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.13511308f, 0.06309313f, -0.03622834f, 0.02810734f, 0.05465148f, 0.00444648f, 0.10145187f, 0.04495810f, 
    -0.07221568f, -0.04737487f, 0.18647259f, -0.02093599f, 0.05351451f, -0.66321975f, 0.15770267f, -0.00413348f, 
    -0.08041868f, -0.70658529f, -0.63153392f, -0.04980158f, -0.48778853f, -0.12604384f, -0.75743580f, -0.02828460f, 
    -0.11049421f, 0.33728263f, 0.10473372f, 0.19747950f, -0.02269508f, -0.05414549f, 0.16056748f, -0.67891473f, 
    0.26984262f, 0.01952348f, -0.07079644f, -0.08417333f, -0.03441766f, -0.60179180f, 0.00621776f, -0.03733761f, 
    0.16720487f, 0.24791975f, 0.25586084f, -0.39747545f, -0.21442555f, -0.07686929f, 0.10088155f, -0.17859034f, 
    -0.05952786f, 0.10633150f, 0.10948175f, 0.07077613f, 0.11416525f, -0.03733097f, -0.15330783f, 0.08890492f, 
    0.25452030f, -0.10708185f, 0.11849082f, -0.42789668f, 0.33931366f, 0.25002682f, -0.52068466f, -0.48159122f, 
    0.21387756f, -0.11338259f, -0.07613334f, -0.17455791f, 0.04677874f, -0.11697061f, 0.18842508f, -0.00940930f, 
    0.10314530f, 0.06598064f, -0.43530464f, -0.06298660f, -0.03279868f, -0.12001228f, 0.20911872f, -0.06097864f, 
    0.10837077f, -0.15350960f, -0.10534897f, -0.19856168f, -0.19031399f, -0.10730305f, -0.20204091f, 0.00274868f, 
    0.01930462f, 0.11363845f, -0.52663118f, -0.13400728f, -0.06792140f, 0.00997170f, -0.05958965f, -0.07690218f, 
    0.05587109f, -0.04315002f, 0.07704076f, 0.00269233f, 0.27138415f, 0.30096063f, 0.11100609f, -0.02939782f, 
    0.11754021f, 0.10106532f, 0.22455314f, -0.57994521f, 0.23980661f, 0.01414068f, -0.00837988f, -0.03349821f, 
    -0.04810132f, -0.36407065f, 0.19396548f, -0.45617697f, -0.50075591f, 0.26094159f, 0.20183527f, -0.03844183f, 
    0.21391785f, 0.22026505f, 0.11260992f, -0.17513877f, -0.23790811f, -0.16506831f, 0.11514791f, -0.21167985f, 
    -0.14421842f, 0.04544708f, -0.03457573f, 0.19273241f, 0.02320740f, -0.11773262f, -0.00723844f, 0.16777587f, 
    -0.02042836f, -0.06011306f, -0.28805038f, -0.04283441f, -0.11383258f, -0.06567262f, -0.14629667f, -0.10167258f, 
    -0.03185762f, -0.02910025f, 0.23426089f, 0.05772958f, 0.42578387f, -0.02746674f, 0.27134547f, -0.10802899f, 
    0.00193850f, -0.14391109f, 0.24960732f, -0.01498743f, -0.03609652f, -0.00839232f, -0.66350609f, -0.09056269f, 
    0.18430500f, 0.01450072f, -0.02587420f, -0.08677249f, 0.30800739f, -0.47458819f, -0.76294357f, 0.00694372f, 
    0.05442891f, 0.21476181f, -0.22249982f, -0.40199542f, 0.06466997f, -0.10548171f, 0.04063512f, -0.30982634f, 
    0.21351962f, 0.09778749f, 0.16651076f, -0.62745887f, -0.59088814f, -0.27323371f, 0.19594823f, 0.01652029f, 
    0.28777468f, -0.13864771f, -0.51775593f, 0.26054648f, 0.29387599f, 0.12834594f, -0.15918103f, 0.29811442f, 
    -0.00319300f, 0.05625660f, 0.10272761f, -0.35435903f, 0.01274966f, -0.02148778f, 0.09521423f, 0.18047135f, 
    0.09220751f, -0.02440876f, -0.04486454f, -0.05128898f, -0.05680709f, -0.26095390f, -0.19115256f, -0.05745103f, 
    0.01290707f, 0.12458691f, -0.23679501f, 0.28833720f, -0.57766402f, -0.09424327f, -0.25409988f, 0.11192834f, 
    -0.01548575f, -0.04165206f, -0.32082704f, -0.01542843f, -0.02400134f, -0.02562843f, 0.11264202f, 0.24510948f, 
    0.14221998f, 0.04612091f, 0.01601104f, -0.05230005f, -0.40685457f, -0.04761972f, -0.02063923f, -0.11102113f, 
    0.09338196f, -0.56836540f, -0.44827580f, -0.26304474f, -0.09889592f, -0.00816431f, 0.08884590f, 0.19330528f, 
    0.04346763f, 0.19925822f, -0.54410028f, -0.01972913f, 0.26033658f, 0.25677618f, 0.03808732f, -0.00642232f, 
    -0.26937413f, 0.35167879f, 0.01114152f, 0.32941055f, 0.23185264f, 0.26833442f, -0.50751191f, 0.08059586f, 
    -0.30409312f, -0.05330847f, -0.06825200f, 0.29176793f, 0.03620958f, 0.00727136f, 0.26495588f, -0.57971543f, 
    0.02068868f, -0.01152807f, 0.13297631f, 0.03875015f, 0.04212901f, 0.13078979f, -0.11024201f, 0.09832421f, 
    0.03334703f, 0.00083347f, 0.08967261f, -0.40253878f, -0.46258610f, 0.06666569f, 0.09230904f, 0.10519616f, 
    -0.08579475f, 0.21375795f, -0.43625534f, -0.37657246f, -0.12278385f, -0.10479522f, 0.22019516f, 0.05804315f, 
    0.21157241f, 0.02372244f, 0.11157198f, -0.06700754f, -0.12819119f, 0.19217700f, -0.06570734f, -0.11197602f, 
    -0.29546541f, -0.07480613f, -0.03699366f, 0.07010050f, -0.26732758f, -0.04364868f, 0.11318223f, -0.15097749f, 
    -0.08284111f, 0.30265215f, 0.08421876f, -0.09103373f, 0.33345246f, 0.19339247f, -0.11054555f, -0.01901187f, 
    0.10335444f, 0.07382495f, 0.04909677f, 0.27321342f, -0.05314527f, -0.14529191f, 0.11020382f, 0.09091645f, 
    0.35568815f, 0.03602087f, 0.07925569f, 0.01457856f, 0.01431960f, 0.05836597f, 0.10032104f, -0.24166079f, 
    0.09901571f, 0.02478562f, 0.15842035f, 0.01499356f, -0.06787372f, 0.27825305f, 0.05395985f, 0.08172654f, 
    0.01165288f, 0.32320064f, -0.14125787f, 0.09501642f, 0.42433599f, 0.06056478f, 0.24206448f, -0.02572022f, 
    -0.05252276f, 0.20097630f, -0.51118946f, -0.21046540f, -0.01983625f, 0.11118893f, 0.26555422f, -0.65762776f, 
    0.02608501f, -0.00168585f, -0.03197538f, -0.04605233f, -0.02764114f, 0.03967867f, 0.08478299f, 0.03945366f, 
    -0.09865816f, -0.17630701f, -0.04083167f, 0.39248255f, 0.25467363f, 0.04220268f, -0.08591844f, -0.01867487f, 
    -0.59214789f, -0.43286398f, 0.07045282f, 0.24110928f, 0.25403136f, -0.14886494f, 0.13298619f, 0.07767256f, 
    -0.20827301f, -0.03658685f, 0.12224380f, -0.59181529f, -0.53260231f, 0.07702798f, 0.02224748f, 0.07739440f, 
    -0.21624222f, 0.04331461f, -0.01809587f, 0.19147578f, -0.10245099f, 0.09906042f, -0.05641718f, -0.11516865f, 
    -0.10700810f, -0.05550671f, -0.12104347f, -0.01429037f, 0.01268306f, -0.61493993f, 0.05900775f, 0.01203229f, 
    0.06415229f, -0.66023767f, 0.45780244f, -0.08980985f, -0.46762550f, 0.08692109f, 0.19376734f, -0.05507150f, 
    0.01714112f, -0.49333090f, 0.47952816f, 0.39475495f, 0.02269869f, -0.10320003f, -0.12543929f, -0.16369657f, 
    0.18919463f, -0.10772858f, 0.04797691f, -0.00681694f, -0.03509108f, -0.45129380f, 0.07412026f, 0.00210851f, 
    0.31886899f, -0.06592178f, -0.12516186f, 0.32509872f, 0.17572285f, -0.06020238f, 0.03362178f, -0.10607249f, 
    0.06077970f, -0.11686698f, 0.13672183f, 0.20102262f, 0.22514059f, 0.12325878f, 0.20571992f, -0.03840645f, 
    -0.45493716f, -0.00338774f, -0.15990709f, 0.16455717f, -0.66414297f, -0.38348919f, 0.02007521f, -0.21174887f, 
    -0.57904744f, -0.08124476f, -0.06992306f, -0.50887895f, 0.11397284f, 0.10406519f, -0.04370463f, -0.29419082f, 
    0.08582905f, 0.00125842f, -0.11772503f, 0.05006029f, 0.00154862f, 0.08016820f, -0.37658653f, 0.03207532f, 
    0.01342817f, 0.21588753f, -0.01036046f, 0.19438995f, 0.32849938f, -0.02665122f, -0.20690276f, 0.06606624f, 
    -0.10156248f, -0.44904050f, 0.31822133f, 0.10978143f, 0.02510534f, -0.09147459f, 0.06536508f, 0.01378781f, 
    -0.18721929f, 0.02791857f, 0.10045258f, 0.07172786f, 0.13455267f, 0.22835316f, -0.25876951f, 0.11239178f, 
    0.13361679f, 0.18072362f, 0.00387207f, 0.28482351f, -0.14684097f, 0.08690897f, -0.01935747f, -0.20657475f, 
    0.26233578f, 0.12484807f, -0.44383642f, 0.14350000f, 0.16588525f, -0.21978946f, -0.12846951f, 0.03790876f, 
    -0.27979067f, -0.06125525f, 0.16648833f, -0.04504465f, 0.22503452f, 0.02442582f, 0.19071646f, 0.22983477f, 
    0.00767964f, -0.11134033f, -0.01486622f, -0.40863261f, -0.12754086f, -0.06009503f, -0.40573400f, -0.02768406f, 
    -0.08069646f, 0.03048646f, -0.05273898f, 0.06576159f, 0.07338129f, -0.00759114f, 0.21443515f, -0.12396232f, 
    -0.08078950f, -0.37221754f, 0.03120235f, -0.48232377f, 0.34325197f, 0.00102696f, 0.29752198f, -0.08237173f, 
    -0.09697708f, 0.32169229f, -0.05058344f, 0.29706803f, -0.02503558f, -0.04183728f, -0.32921398f, 0.12883461f, 
    -0.33906028f, -0.06049722f, -0.01343233f, -0.04763593f, 0.19852206f, -0.31262678f, -0.37608302f, 0.10980245f, 
    -0.36460564f, 0.22729437f, -0.37580228f, 0.09055444f, 0.16911884f, -0.05251760f, -0.02025538f, 0.10706582f, 
    0.25582317f, -0.00977912f, -0.01459213f, 0.01615196f, -0.49380085f, 0.24212949f, -0.22452374f, -0.06218473f, 
    -0.15556854f, -0.14002366f, 0.21494222f, 0.04755539f, -0.40399224f, 0.05546959f, 0.26392913f, 0.21581756f, 
    -0.09467594f, -0.05507448f, -0.11013190f, 0.07747467f, 0.01942393f, 0.03538724f, 0.00908156f, 0.39536148f, 
    -0.02014314f, 0.01259126f, 0.04424188f, -0.11634091f, -0.03657100f, 0.55906880f, -0.44383174f, 0.03189339f, 
    0.06297071f, 0.05920851f, -0.17100576f, 0.11541333f, 0.13099495f, -0.01817161f, 0.23958996f, 0.09624670f, 
    -0.04023771f, -0.57398230f, 0.38942838f, -0.54335183f, 0.08071569f, -0.04871910f, -0.08495803f, -0.03545593f, 
    -0.26389635f, 0.00791330f, 0.06852017f, -0.09949052f, -0.37265363f, -0.00564024f, 0.14072485f, 0.07480431f, 
    0.19071129f, 0.20823777f, 0.41587803f, -0.08816228f, -0.00942704f, -0.11118131f, -0.00122992f, -0.62040609f, 
    -0.25299427f, 0.03057714f, 0.15201925f, 0.22715817f, -0.04320927f, -0.33413577f, -0.01374509f, -0.12972389f, 
    0.22484973f, 0.24068998f, 0.25099653f, 0.06061311f, -0.04806044f, -0.53623891f, 0.23080258f, 0.09093444f, 
    0.29012683f, 0.08424015f, -0.00276673f, -0.10886827f, -0.07745782f, -0.05575502f, -0.30738479f, 0.36767831f, 
    0.10052504f, 0.08308212f, -0.48896968f, -0.11451846f, -0.10939014f, 0.10417538f, 0.05555923f, -0.00991726f, 
    0.04801599f, 0.27926698f, 0.20367067f, 0.32253656f, -0.05807335f, 0.02069675f, -0.39671651f, 0.09938104f, 
    0.00859694f, -0.24227576f, 0.42325446f, 0.16460066f, -0.12731220f, -0.06657588f, -0.04065840f, 0.10484874f, 
    -0.57627010f, 0.10232627f, -0.08203842f, -0.02909035f, -0.34693471f, 0.31592867f, 0.28656262f, 0.07522695f, 
    -0.29681012f, -0.08643694f, 0.08207278f, -0.02954826f, -0.16489767f, -0.10393259f, -0.00241311f, 0.16775545f, 
    0.01108122f, -0.23269020f, 0.04505090f, -0.55891067f, -0.04918620f, 0.11042057f, -0.24302115f, 0.09811682f, 
    0.02555855f, 0.00404506f, -0.59692997f, -0.09766415f, -0.06291623f, 0.28975505f, 0.12516564f, -0.18066092f, 
    0.06184386f, -0.05742708f, -0.01262833f, 0.27279148f, -0.05653116f, 0.10683290f, 0.02769689f, -0.45420381f, 
    0.12122451f, -0.04917683f, 0.41882980f, -0.08535947f, 0.01650152f, 0.03463098f, -0.04086730f, -0.08326144f, 
    0.07457156f, 0.10289382f, -0.23917422f, -0.06047413f, 0.24049245f, -0.09539500f, -0.38137081f, -0.03234081f, 
    0.05347763f, -0.30507195f, -0.34513682f, 0.31279379f, 0.05126114f, -0.12515128f, -0.12150810f, -0.02539554f, 
    0.03419281f, 0.12273768f, 0.11154931f, 0.01635336f, -0.59618515f, -0.29308093f, 0.22566636f, -0.03045727f, 
    0.35402480f, -0.51584226f, -0.05926009f, -0.11169308f, 0.10912690f, 0.08287302f, 0.06795829f, 0.19654380f, 
    0.30748814f, 0.17251754f, 0.08845221f, 0.11529398f, -0.33203366f, 0.07291649f, 0.09010278f, 0.01306999f, 
    0.12299632f, -0.64690620f, 0.08198527f, 0.15721147f, 0.05973209f, -0.07638988f, -0.10584924f, 0.00191500f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.01379913f, 0.09205940f, -0.13004613f, -0.03267192f, 0.11372897f, -0.01073012f, -0.04336775f, -0.10923656f, 
    -0.02451536f, 0.00943344f, 0.19516940f, -0.01486270f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
