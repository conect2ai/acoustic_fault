#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.14519736f, 1.04717553f, -0.48242217f, -0.30116579f, -0.71005625f, -1.07895947f, 0.13815260f, 0.21073540f, 
    0.03022723f, 1.10411608f, 0.78625202f, 1.17456591f, 0.19872205f, -0.24805513f, -0.12336977f, 0.44810608f, 
    0.61308634f, -0.39057851f, -0.95558625f, -0.95317352f, -0.47038716f, 0.61119115f, 0.07493635f, -0.04887206f, 
    0.46058849f, 0.16056727f, 0.59393561f, -0.73833376f, -0.88205910f, -0.85431451f, -0.80131954f, 0.13590263f, 
    0.49587303f, 0.15418333f, -0.06497289f, 0.10306010f, -0.81037056f, 1.33795905f, 0.77980191f, 0.51318765f, 
    -0.23499663f, -0.47717160f, -0.24403995f, -0.10692677f, 0.35035694f, 1.20389366f, 0.86454582f, 0.03869120f, 
    -0.42417341f, 0.19746175f, 0.73561913f, -0.20045279f, -0.01278134f, 0.02661905f, -0.78723782f, -1.14001846f, 
    0.45902157f, 0.83130652f, 0.78080076f, 0.85989916f, -0.16169690f, -0.28105724f, 0.10525291f, -0.90822232f, 
    -0.39472640f, 0.56638861f, -0.33379725f, 1.05763662f, -0.78948945f, -0.28755331f, 0.09411000f, -0.09584375f, 
    -0.68083340f, 0.01458757f, -0.19388413f, -0.96457189f, 0.32694906f, -0.94667727f, 0.15079769f, -0.01100454f, 
    0.61227697f, 1.35832345f, -0.82425535f, -0.94641203f, -0.38922349f, 0.29096439f, -0.16597268f, -0.15624301f, 
    0.08025748f, 0.52143890f, 0.72776359f, 0.24027480f, 0.95143139f, 0.40020800f, 0.64224291f, 0.33608782f, 
    -0.35056078f, -0.38991192f, -0.01410183f, 0.82263047f, -0.71482474f, 0.05990854f, 0.70756108f, 0.62703663f, 
    0.46073022f, -0.42498943f, 0.16688861f, -0.56603491f, -0.26077005f, -0.94328529f, -0.83864868f, 0.92625272f, 
    -0.22735412f, -0.31627026f, -0.49173567f, -0.01112024f, -0.10471622f, -0.27300069f, -0.88102323f, -0.65925217f, 
    -0.28198156f, -0.26628128f, 0.70771587f, -0.38494921f, -0.16914034f, -0.60848075f, -0.15169045f, -0.92973584f, 
    0.19909386f, -0.94692594f, -0.63902664f, -0.60878950f, 0.00278326f, 0.07163732f, -0.60454196f, -0.88757437f, 
    0.74387604f, 1.00855637f, -1.08451176f, -0.01111817f, 0.64368635f, -0.27471530f, 0.17179646f, 0.20564671f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06247371f, 0.33190906f, 0.27710772f, 0.33984414f, -0.10530335f, 0.46205637f, 0.31487644f, 0.05873991f, 
    0.15697546f, 0.30123594f, -0.01715406f, 0.01240110f, -0.11718483f, 0.24207327f, 0.42022252f, 0.10753700f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00746116f, -0.01795260f, -0.03493384f, -0.00162008f, 0.05194637f, 0.04702748f, -0.02152996f, 0.00410930f, 
    0.02644596f, -0.01170826f, -0.03923957f, -0.02229426f, 0.03860149f, 0.00776775f, 0.01756687f, -0.05375820f, 
    -0.05301499f, 0.04317040f, 0.02338223f, 0.01755970f, -0.03337995f, -0.00129413f, -0.02304932f, 0.04008995f, 
    -0.03853139f, -0.04997361f, 0.00251442f, -0.01600413f, -0.05524711f, -0.01725677f, -0.01104600f, 0.00886360f, 
    0.01988192f, -0.00159024f, 0.00691032f, 0.04580085f, 0.04132047f, -0.01645213f, -0.04192531f, -0.02057931f, 
    0.05541220f, 0.04461875f, 0.02739727f, -0.03802995f, -0.00648693f, 0.03902019f, 0.01593138f, 0.04181889f, 
    -0.00093605f, 0.00533653f, -0.03345889f, 0.03756117f, -0.00454542f, -0.02225230f, -0.01411162f, 0.00707283f, 
    -0.03212519f, -0.02496075f, -0.05006769f, -0.03339215f, -0.05552917f, 0.02086222f, -0.05282324f, 0.02885903f, 
    -0.04343214f, -0.04066811f, -0.03147750f, 0.04361025f, -0.00790929f, 0.01435573f, -0.05489771f, -0.02999105f, 
    -0.00999304f, 0.00765457f, -0.05234441f, -0.03537721f, 0.03042345f, 0.00306450f, -0.05350336f, -0.02618771f, 
    0.02322745f, -0.00511470f, -0.05438053f, 0.04148842f, -0.00325631f, 0.00045701f, 0.00389359f, 0.04442278f, 
    0.01257486f, 0.04177161f, 0.02594426f, -0.03072206f, 0.04478449f, -0.02792174f, 0.04799528f, 0.04356516f, 
    0.00393257f, 0.01975458f, -0.01972614f, 0.02831013f, -0.05356776f, 0.00362864f, -0.02372511f, 0.00382950f, 
    -0.04607553f, -0.04769988f, -0.00829840f, -0.02669550f, -0.05245047f, 0.03419313f, -0.02896702f, 0.04561323f, 
    0.03919703f, 0.03408216f, -0.00390468f, 0.01243206f, 0.00881398f, 0.04977745f, 0.03683871f, -0.04902228f, 
    -0.05150693f, -0.00054366f, -0.00119270f, 0.05418900f, -0.03196611f, -0.04698840f, -0.03638507f, -0.01605378f, 
    0.03523631f, 0.00064421f, 0.01412868f, 0.04461887f, -0.01015982f, 0.05484006f, -0.03850680f, 0.00263993f, 
    -0.01327323f, 0.02598510f, -0.03819948f, 0.05062565f, -0.03143412f, -0.04371173f, -0.03798197f, -0.04758112f, 
    0.03162778f, -0.02904970f, 0.05376234f, -0.01170197f, -0.04434459f, -0.02275063f, -0.02227431f, -0.05065441f, 
    -0.00149529f, -0.02903768f, -0.03210933f, -0.03069413f, -0.02549105f, 0.01963537f, 0.04597960f, -0.00201869f, 
    -0.03738352f, 0.01711654f, -0.00356338f, -0.02089337f, -0.01334069f, -0.04385930f, -0.02048130f, -0.00740810f, 
    0.03762142f, 0.04619984f, 0.03341562f, -0.00800079f, 0.01912394f, -0.03390915f, -0.02120272f, -0.02342919f, 
    -0.00098531f, -0.00152494f, 0.02400986f, 0.01910992f, -0.01681710f, -0.01175940f, -0.02858090f, 0.00576152f, 
    -0.02979037f, -0.04674231f, -0.04279443f, -0.03617771f, 0.02296351f, -0.01886157f, -0.05590036f, -0.02996995f, 
    -0.05496861f, -0.03634501f, -0.01911918f, 0.04619749f, 0.02352281f, 0.02644920f, 0.02650307f, -0.03564950f, 
    -0.04433093f, 0.00473313f, 0.02185349f, 0.00806697f, 0.02775636f, 0.02110214f, 0.04680717f, -0.02110051f, 
    -0.04364040f, -0.03620956f, -0.00377675f, 0.01307175f, 0.01551176f, -0.00306777f, 0.03394087f, 0.03157628f, 
    -0.04044826f, -0.05187465f, 0.04752639f, 0.03814133f, -0.05555536f, 0.01778370f, 0.00974550f, -0.00699865f, 
    -0.02148981f, -0.02499348f, -0.04771297f, -0.01522480f, 0.02412690f, 0.00499022f, 0.00692652f, -0.02665310f, 
    -0.01313638f, -0.00352342f, -0.02696325f, 0.02932129f, 0.00254845f, -0.02928239f, -0.00857528f, -0.02804370f, 
    0.03620945f, -0.00957091f, 0.02558867f, -0.04091884f, 0.05378053f, -0.03453725f, 0.03311201f, -0.00735564f, 
    0.00397952f, 0.00676539f, 0.02146053f, -0.00461158f, 0.01012005f, -0.01826742f, -0.02189194f, 0.04920390f, 
    -0.02869263f, -0.00927240f, -0.04706777f, -0.05005165f, 0.04906415f, -0.03429376f, -0.03120226f, 0.01527227f, 
    -0.02953360f, 0.01655792f, 0.05293025f, 0.01822578f, -0.04694463f, 0.02180352f, 0.05055001f, -0.03163837f, 
    0.02018595f, 0.04673584f, -0.04508873f, -0.04115713f, -0.04110903f, -0.03735406f, -0.02489670f, -0.02438796f, 
    -0.04909893f, -0.02779682f, -0.03766062f, 0.04704728f, -0.04362679f, -0.00870804f, 0.02970608f, -0.04949016f, 
    -0.02815886f, -0.05097344f, -0.04053974f, 0.00716203f, 0.04758858f, -0.02796034f, -0.02633998f, 0.00794632f, 
    0.01190142f, 0.01473095f, 0.03390286f, -0.04103256f, -0.00692352f, 0.02350492f, -0.03155007f, 0.02889784f, 
    0.03614440f, -0.02665182f, 0.03720624f, 0.00888041f, 0.04423906f, -0.05221185f, -0.02581350f, -0.01589394f, 
    -0.02691313f, -0.02043735f, -0.01727291f, -0.01458018f, -0.01578955f, -0.00817160f, -0.04395713f, -0.03761418f, 
    -0.03495201f, -0.12478485f, -0.07568552f, 0.16562444f, 0.27500045f, -0.07130426f, -0.17946729f, -0.01943119f, 
    -0.14781183f, 0.01399130f, -0.07759358f, -0.07962274f, 0.05800488f, 0.09495995f, 0.15006307f, 0.01783148f, 
    0.03586589f, -0.19518645f, 0.08485851f, -0.03604999f, -0.06209994f, -0.05429825f, 0.10016760f, 0.27557126f, 
    0.36538893f, -0.02456517f, -0.02560612f, 0.01406914f, 0.06226007f, -0.00234089f, -0.05106885f, -0.08857080f, 
    -0.00512476f, -0.00569134f, -0.03949608f, -0.06065278f, 0.01676107f, 0.07218248f, -0.15876612f, -0.06212549f, 
    -0.26789337f, 0.00792642f, 0.08798988f, -0.02881698f, 0.05208326f, 0.01900138f, 0.11947917f, 0.05182628f, 
    -0.03276513f, 0.02157905f, 0.00691810f, 0.02833509f, 0.06176417f, -0.02504940f, -0.00069912f, 0.20645206f, 
    0.12396590f, 0.01704030f, 0.08811589f, -0.09712874f, 0.03040659f, 0.05254585f, 0.00269001f, 0.06424319f, 
    0.04469314f, 0.10156516f, -0.01793271f, -0.01991327f, 0.18896821f, 0.11830165f, -0.04359124f, 0.09158958f, 
    0.01285882f, 0.05397509f, -0.07496599f, 0.09182981f, -0.04748668f, 0.13644521f, -0.03217934f, -0.00612044f, 
    -0.05645607f, 0.04186349f, 0.13453351f, 0.13401362f, -0.06366331f, 0.06671709f, -0.12234087f, 0.09033390f, 
    -0.05683677f, -0.03674947f, -0.08208779f, 0.12478554f, 0.02366158f, -0.12164039f, 0.08918047f, 0.02145213f, 
    -0.02649576f, -0.00274733f, 0.15856992f, 0.07253026f, 0.55856699f, 0.03729242f, 0.02033989f, -0.11185885f, 
    0.22451064f, -0.11059391f, -0.07928085f, -0.09493666f, 0.02219503f, 0.03946068f, -0.00159661f, -0.03021172f, 
    0.00903391f, 0.04481264f, -0.09704484f, 0.03995770f, -0.08420599f, 0.06860401f, 0.04354502f, -0.06409777f, 
    -0.32344538f, 0.29658818f, -0.03406617f, -0.01067728f, -0.11263546f, 0.01190276f, 0.03905240f, 0.00958104f, 
    0.04570920f, -0.13282408f, 0.00506691f, 0.05051790f, 0.01382461f, -0.02415398f, -0.00533223f, 0.11344248f, 
    0.03678419f, 0.07617282f, 0.12500781f, 0.05715555f, -0.19466382f, 0.30931613f, 0.04738925f, -0.19216409f, 
    -0.36015800f, 0.02105270f, -0.02417228f, -0.04486331f, 0.02843989f, 0.07758974f, 0.05621125f, 0.04765532f, 
    -0.12755783f, 0.04991616f, -0.06835350f, -0.04687900f, -0.07850654f, -0.04775951f, -0.05838412f, 0.00718137f, 
    -0.17107050f, -0.15244755f, 0.07297336f, 0.01983573f, -0.17175381f, 0.05876340f, -0.06945309f, -0.09005590f, 
    -0.08939286f, 0.12258042f, 0.17918357f, -0.08643996f, 0.15241663f, 0.08908597f, 0.05416197f, -0.13386352f, 
    -0.06388405f, -0.16266409f, -0.04962124f, -0.05735074f, 0.41193217f, -0.11552642f, 0.13616356f, 0.03747026f, 
    0.08134145f, -0.13614374f, -0.11358729f, -0.05328187f, 0.04323041f, 0.05732067f, -0.05140603f, 0.04720235f, 
    -0.08444002f, 0.04830598f, -0.03334639f, -0.08985806f, 0.00730921f, -0.13162947f, 0.05443839f, -0.00410092f, 
    0.38980317f, 0.33720368f, 0.08562529f, 0.07455781f, 0.21596669f, -0.10175394f, -0.14911714f, 0.05421544f, 
    0.10914462f, 0.13675457f, 0.08840708f, 0.02954906f, 0.04693314f, 0.04441956f, 0.02332149f, 0.01841125f, 
    0.06070465f, 0.09466197f, -0.01191837f, 0.12372686f, 0.14649342f, 0.09638110f, 0.17294660f, -0.07841501f, 
    -0.09504198f, -0.00661131f, -0.04705635f, -0.05339190f, -0.04848244f, -0.09382960f, 0.18144464f, 0.03524003f, 
    -0.07747343f, 0.03391839f, -0.13029918f, 0.03801613f, 0.06865809f, -0.07687871f, 0.01444391f, -0.04638386f, 
    -0.02547534f, 0.26121497f, -0.12571172f, 0.18278217f, -0.00926499f, 0.03586676f, 0.07367273f, 0.07850391f, 
    0.03110999f, 0.05862128f, 0.04497466f, -0.02649366f, 0.02135353f, -0.15630436f, 0.05226204f, 0.11635824f, 
    0.10470352f, -0.07180195f, 0.05373901f, 0.02646379f, -0.06604134f, 0.02355019f, 0.13326649f, 0.08270172f, 
    0.03800347f, 0.03653507f, 0.06756731f, 0.00334895f, 0.12100811f, 0.01443133f, 0.01342773f, 0.04381353f, 
    -0.07814325f, -0.01290713f, -0.19180311f, -0.06288943f, 0.03681940f, -0.03872036f, 0.07104832f, -0.14411980f, 
    -0.07490676f, -0.21592228f, 0.09991530f, 0.34221432f, 0.10531271f, 0.12549599f, -0.02585845f, -0.04575375f, 
    0.08484702f, -0.00784198f, -0.03586687f, 0.02842782f, 0.00027618f, -0.00689950f, 0.13212794f, 0.01815262f, 
    -0.14029998f, -0.03006064f, -0.14927043f, 0.00282871f, -0.06320714f, 0.11694321f, -0.28076544f, -0.04906362f, 
    -0.03920363f, -0.03198527f, 0.00409580f, -0.08332673f, -0.09236475f, -0.09479900f, -0.06304346f, -0.13691993f, 
    -0.11631661f, 0.08482708f, 0.01696684f, -0.03391606f, 0.04263034f, 0.03997022f, -0.04028596f, 0.05995939f, 
    0.13566230f, 0.16631892f, -0.17489828f, -0.11147136f, 0.27492136f, 0.01935756f, -0.26154125f, -0.06641161f, 
    0.01192942f, -0.00760194f, 0.06008510f, -0.01706262f, -0.01786532f, 0.20346628f, -0.03333455f, 0.07782803f, 
    -0.10760834f, -0.30448157f, -0.11997091f, -0.10047596f, 0.44123626f, -0.19541143f, -0.11324771f, -0.05136518f, 
    -0.01921830f, 0.07670583f, -0.04757785f, 0.00887034f, -0.05030088f, -0.06196854f, 0.07745122f, -0.03537318f, 
    -0.02206968f, 0.13720231f, 0.08882280f, -0.00926496f, 0.11471754f, -0.02934338f, -0.07521547f, 0.13798246f, 
    0.11335777f, 0.09396430f, 0.00774833f, 0.17611034f, -0.01053838f, 0.10111621f, 0.09300679f, 0.23909716f, 
    0.11035418f, -0.01535947f, 0.01247247f, -0.05411746f, 0.06591331f, -0.00591218f, -0.03765441f, 0.16413142f, 
    0.07441425f, 0.04989187f, 0.08445474f, -0.22185284f, 0.08617525f, 0.14699236f, 0.10710793f, -0.02111774f, 
    -0.00712945f, -0.00640096f, 0.03392278f, -0.02263811f, 0.04110341f, -0.05209690f, -0.04807162f, 0.07512827f, 
    -0.07680770f, 0.03760779f, -0.07411279f, 0.03398954f, 0.02364080f, -0.05504302f, -0.00960728f, 0.09959595f, 
    -0.46721882f, -0.32678923f, 0.04021560f, 0.20118567f, -0.01606753f, 0.07887908f, -0.15665573f, -0.12132887f, 
    -0.18440387f, -0.05433222f, 0.04347336f, -0.15915817f, 0.06747825f, 0.04189938f, 0.14265536f, -0.02659404f, 
    -0.10311420f, -0.01736625f, -0.03253190f, 0.01391486f, -0.02038492f, 0.18889455f, -0.06018310f, -0.13958445f, 
    -0.16038680f, 0.01056490f, 0.02372923f, -0.16273913f, -0.02409576f, -0.01182128f, 0.04036162f, 0.01620876f, 
    0.03653406f, 0.00374702f, 0.04409063f, -0.00078543f, -0.04313868f, 0.08408498f, -0.01265134f, 0.02615672f, 
    -0.29296616f, 0.51082623f, 0.09000831f, 0.11764339f, -0.05660089f, 0.06390004f, 0.13387206f, 0.00180020f, 
    -0.05498597f, -0.04673909f, -0.05955100f, 0.03142295f, -0.01940455f, 0.00814316f, -0.16008648f, -0.11884499f, 
    -0.09351861f, 0.01520145f, -0.04897726f, 0.01012843f, 0.04457385f, 0.23898272f, 0.17469805f, 0.06922024f, 
    0.07337584f, -0.06378664f, -0.02136876f, 0.04803398f, 0.01053945f, 0.06934486f, 0.01951836f, -0.08119221f, 
    -0.04216526f, -0.01814601f, -0.06528219f, -0.05630480f, -0.00836107f, 0.02021869f, -0.05817752f, -0.06564002f, 
    0.20091224f, -0.00089741f, -0.00196777f, -0.02489160f, 0.01699405f, -0.02716250f, -0.07090959f, -0.03129241f, 
    0.04019182f, -0.00473932f, 0.04019659f, -0.00305152f, 0.08024326f, 0.03626519f, -0.09590615f, -0.13061789f, 
    0.06549830f, 0.02275514f, 0.04712160f, -0.04956342f, -0.01967877f, 0.01857447f, 0.05398273f, 0.03499237f, 
    0.19103929f, 0.08617757f, -0.06900573f, -0.05218060f, 0.06509444f, 0.06892221f, 0.00009045f, 0.15658492f, 
    -0.10923148f, 0.03682999f, 0.18045713f, -0.03075173f, 0.15209071f, -0.07248373f, -0.12252034f, -0.00924431f, 
    0.23766728f, -0.12337605f, 0.00144441f, -0.19481288f, -0.01880945f, 0.02603756f, -0.01943982f, 0.01000975f, 
    -0.08003908f, 0.08614527f, 0.08640352f, 0.00314114f, -0.12076963f, 0.16537318f, -0.08061147f, -0.07351393f, 
    -0.10030551f, -0.02579084f, 0.02869178f, 0.00451205f, 0.05891675f, 0.02492685f, -0.05039503f, 0.02533041f, 
    -0.04541612f, -0.05857379f, 0.17271522f, 0.12736106f, -0.15939832f, 0.00764333f, 0.04796872f, -0.03199149f, 
    -0.10022726f, -0.09486766f, -0.19044238f, -0.05432733f, 0.08566356f, -0.02295792f, 0.05308723f, -0.12260450f, 
    0.44372818f, 0.19577695f, 0.12967789f, 0.16171519f, 0.13573065f, 0.15869494f, 0.13534422f, -0.04768123f, 
    -0.04662567f, -0.00623000f, 0.01157968f, -0.09580120f, 0.05535132f, -0.08418515f, -0.22072951f, -0.01764221f, 
    0.00127231f, 0.02509397f, -0.00370921f, -0.04001654f, 0.30489042f, 0.21126503f, 0.06168132f, 0.17018311f, 
    0.02840268f, -0.01350775f, 0.12981844f, -0.05671129f, -0.02254422f, -0.06357220f, 0.03686986f, 0.05974285f, 
    -0.08175617f, 0.00000715f, -0.12966631f, -0.10468752f, -0.04826914f, -0.11130004f, 0.01352241f, -0.01662375f, 
    0.16702892f, -0.03079554f, 0.02412007f, 0.04305864f, 0.19811304f, -0.08152744f, -0.07912637f, 0.08236061f, 
    -0.07850063f, -0.05790242f, -0.03068101f, -0.04077700f, 0.01712491f, 0.13857223f, 0.07740103f, 0.02388302f, 
    -0.09272068f, -0.03137487f, -0.10368896f, 0.05051226f, -0.04591439f, -0.02025036f, -0.15794365f, -0.01687162f, 
    -0.19537143f, -0.16633995f, 0.09816819f, -0.19814436f, -0.02883563f, 0.05243856f, -0.00592095f, -0.03631955f, 
    0.15680961f, 0.07403923f, -0.01468083f, 0.02589871f, 0.06325687f, 0.09055763f, -0.06897365f, 0.15981431f, 
    0.06476694f, -0.09105910f, 0.19640750f, -0.00719376f, 0.16192821f, 0.03934398f, -0.14473239f, -0.03605689f, 
    -0.06455011f, 0.04057416f, 0.03908172f, -0.02428899f, 0.03045498f, -0.11933293f, -0.00291018f, 0.01917347f, 
    0.12485042f, 0.07442154f, 0.01855957f, 0.11468812f, -0.38733050f, -0.26142234f, -0.04538618f, -0.15359807f, 
    0.20644633f, -0.03428916f, -0.03203665f, 0.06660560f, -0.07324672f, -0.12625825f, -0.03216103f, -0.02284282f, 
    0.00866186f, -0.01583389f, 0.02869784f, -0.05996490f, -0.11278032f, -0.06507214f, -0.08391755f, -0.08174758f, 
    -0.10323366f, 0.01862693f, 0.13529794f, 0.02692985f, -0.10137513f, -0.06162426f, 0.05608683f, 0.02263775f, 
    0.00142657f, 0.11427455f, 0.10951404f, 0.01299614f, 0.19106187f, -0.00170325f, 0.15878934f, 0.00595007f, 
    -0.00156511f, 0.08176002f, 0.09351426f, 0.00839585f, 0.30821693f, -0.07277660f, -0.00496423f, 0.20252892f, 
    -0.10596298f, 0.13007961f, 0.16410953f, -0.00339482f, 0.14323968f, 0.08713975f, -0.02084963f, 0.17178553f, 
    0.04230763f, 0.11962928f, 0.04634890f, -0.05625711f, -0.07171028f, 0.03988273f, 0.03449083f, -0.06256820f, 
    -0.09680457f, 0.11136747f, -0.17823021f, -0.01923968f, -0.12117616f, -0.01593425f, -0.13354501f, -0.02319789f, 
    -0.19086461f, -0.00680442f, -0.10660248f, 0.11144900f, -0.04319368f, -0.01267951f, 0.08262625f, -0.07473292f, 
    0.08168940f, 0.09022548f, -0.05512014f, 0.08737931f, 0.16177987f, -0.29074398f, -0.06415168f, -0.29963076f, 
    0.18514033f, -0.20509347f, -0.16444568f, 0.06040855f, -0.07176265f, -0.03906571f, -0.07776625f, -0.06992331f, 
    0.09207052f, -0.05078354f, -0.00419487f, 0.04669130f, 0.04135062f, 0.01633329f, 0.00450104f, -0.00116196f, 
    0.09392132f, 0.41352919f, 0.19331810f, -0.07357687f, -0.03170944f, -0.11535450f, -0.07931840f, 0.05152423f, 
    0.12153523f, -0.04598010f, 0.14962441f, -0.04245266f, -0.01735274f, -0.10359917f, 0.00388617f, -0.06264994f, 
    -0.01044438f, 0.03453046f, 0.08921578f, 0.05289707f, 0.15002348f, 0.18259870f, 0.15257563f, -0.21562839f, 
    -0.18033659f, -0.05186782f, 0.07236106f, 0.10009097f, 0.09164142f, 0.18181565f, -0.00170240f, -0.00266915f, 
    -0.07864377f, 0.01089867f, 0.05400208f, 0.00496151f, -0.03340703f, -0.05097440f, 0.01152694f, -0.05244916f, 
    0.20078808f, -0.04943635f, 0.07681113f, 0.06692401f, -0.29136673f, 0.06927509f, 0.08599426f, 0.00899635f, 
    0.04360837f, 0.06538387f, 0.00330941f, 0.04601401f, 0.08808555f, -0.05227256f, 0.14141344f, -0.02454896f, 
    -0.05646189f, 0.01383112f, -0.05281137f, -0.01068398f, -0.00336135f, -0.00531216f, -0.05866384f, -0.07399285f, 
    -0.14564405f, -0.00009898f, -0.02354278f, 0.07493382f, 0.07380168f, 0.06338962f, -0.09716798f, 0.11950648f, 
    -0.12585494f, 0.03120635f, 0.04109855f, -0.08279236f, -0.01890668f, -0.00310245f, 0.13212927f, 0.06507385f, 
    -0.13189876f, -0.02601566f, 0.11301371f, -0.14783353f, -0.16092317f, -0.06529588f, -0.07139620f, 0.08961396f, 
    -0.12595545f, -0.16515841f, -0.08211185f, 0.02417970f, -0.02929852f, 0.02140554f, -0.17848766f, -0.03121348f, 
    -0.08210282f, 0.03666618f, -0.02889580f, 0.19111758f, -0.16822319f, 0.29094234f, 0.03914761f, -0.06643782f, 
    -0.33707002f, -0.14428371f, -0.06703865f, 0.09462764f, -0.04722169f, -0.12687717f, 0.05127331f, -0.07782388f, 
    0.07216224f, -0.16240409f, 0.01405942f, 0.01491496f, 0.03128502f, -0.03694666f, 0.00538254f, 0.08152346f, 
    -0.09077769f, 0.07172030f, 0.08011597f, 0.36681303f, -0.07962225f, 0.20840344f, 0.05566524f, 0.15341161f, 
    0.25340149f, 0.15756965f, 0.09084415f, -0.00691908f, -0.11080832f, 0.06848403f, 0.13129912f, 0.18654510f, 
    -0.09791198f, 0.06351712f, -0.01524151f, 0.12235278f, 0.21492213f, -0.01570031f, 0.05305270f, 0.36268994f, 
    -0.04520672f, 0.02417106f, 0.15641794f, 0.04367114f, 0.12155428f, 0.01671670f, -0.00867744f, 0.03594246f, 
    0.02453046f, -0.00010838f, -0.07989870f, 0.01185490f, 0.02322719f, -0.01519728f, 0.12868963f, -0.06288961f, 
    0.20927049f, -0.19576526f, 0.21051775f, 0.37620813f, -0.01512857f, 0.11331359f, 0.05631014f, -0.06901000f, 
    0.09502409f, -0.04353597f, -0.07535679f, 0.04863597f, -0.03945318f, 0.09931301f, 0.05510633f, 0.06568266f, 
    0.00457410f, -0.00962161f, 0.01897053f, -0.08097852f, -0.10425685f, 0.13857265f, -0.17307894f, 0.20129710f, 
    0.08262770f, 0.07828271f, 0.05446379f, 0.04404541f, -0.13664795f, -0.13952033f, -0.07307998f, 0.06398969f, 
    -0.11930455f, 0.03350390f, 0.03226246f, -0.06800716f, 0.20119651f, -0.11701709f, -0.07559033f, 0.12668100f, 
    -0.53164852f, -0.21764018f, 0.37435159f, -0.20163685f, -0.16805688f, -0.16752480f, -0.06605879f, -0.00206510f, 
    -0.13211790f, 0.08212789f, -0.03760672f, -0.16159053f, 0.01637902f, -0.00115698f, 0.11467768f, -0.08884470f, 
    -0.02847027f, -0.10824554f, 0.00246858f, -0.00297252f, -0.06870671f, 0.21528131f, 0.48142391f, -0.06514269f, 
    0.04548066f, -0.04066930f, -0.01681804f, 0.11282250f, -0.09950414f, -0.03474189f, -0.10598438f, 0.04315320f, 
    0.04900277f, 0.06194278f, 0.07382124f, 0.00231008f, 0.02700624f, -0.10072936f, 0.00434453f, 0.03239721f, 
    -0.38965341f, -0.01327551f, -0.01738649f, 0.22312562f, 0.04369613f, 0.10496595f, 0.04936333f, -0.05317073f, 
    -0.00299834f, 0.18915243f, -0.01910999f, 0.10321695f, 0.00319048f, -0.03748606f, 0.08387949f, 0.04512627f, 
    0.16488218f, 0.03520736f, 0.05461229f, 0.02215302f, 0.06677983f, -0.04882680f, -0.05296274f, 0.19932161f, 
    0.00329936f, 0.14486490f, 0.30521074f, -0.05918214f, 0.20202641f, 0.08953906f, -0.03912107f, 0.06155761f, 
    -0.08328207f, 0.10154466f, -0.09699219f, -0.06927464f, -0.02136834f, 0.07695314f, 0.05963070f, -0.01430203f, 
    -0.33797204f, 0.12240814f, 0.15953237f, -0.24774615f, -0.08860000f, -0.07198497f, -0.07761826f, -0.10746690f, 
    -0.13108167f, 0.08776164f, -0.13976982f, 0.04960635f, 0.10715431f, -0.04719421f, 0.06781854f, 0.00285044f, 
    -0.06176623f, 0.04630787f, 0.00042640f, -0.02700175f, 0.23490675f, 0.03970861f, 0.19630085f, 0.13002370f, 
    0.06368443f, -0.06929292f, -0.05177407f, 0.00139314f, -0.12373456f, 0.02563270f, 0.04371421f, -0.00191535f, 
    -0.01092793f, -0.05643680f, -0.01328155f, 0.07628841f, -0.00619049f, 0.05180028f, 0.09388044f, 0.00432768f, 
    0.05922207f, 0.38247001f, -0.18680644f, 0.10539158f, 0.08217920f, 0.11958554f, 0.02895087f, 0.00844537f, 
    0.02656985f, 0.09979630f, 0.00015128f, -0.02522807f, -0.00955233f, 0.01663467f, -0.00830081f, 0.13501041f, 
    0.06438011f, 0.00641356f, 0.11740515f, -0.02292336f, -0.00962226f, -0.23681606f, -0.00293771f, -0.24943118f, 
    -0.03764692f, 0.08822615f, 0.01100727f, 0.02787862f, -0.09885934f, 0.09364766f, 0.14002718f, 0.09097376f, 
    -0.09243438f, 0.03703258f, 0.00656194f, -0.04744000f, 0.00594885f, -0.01239632f, -0.12379885f, 0.01245292f, 
    0.19494613f, -0.31406328f, 0.11293475f, 0.11341644f, 0.00906705f, -0.08345763f, 0.00410761f, 0.06387101f, 
    0.04155852f, 0.05136019f, 0.10259391f, 0.12443461f, 0.10427965f, 0.00055390f, 0.14165546f, -0.14442126f, 
    -0.08104754f, -0.13882709f, -0.03858341f, 0.07456443f, -0.03474760f, 0.01538343f, -0.15334028f, 0.02871462f, 
    -0.14041558f, -0.05003677f, 0.07820277f, -0.00303827f, -0.04391356f, -0.03757007f, -0.16364688f, -0.08230668f, 
    -0.02751709f, -0.00383553f, 0.09683686f, -0.00945412f, -0.07801285f, 0.03048008f, -0.00665384f, -0.09431040f, 
    0.43468428f, 0.21138893f, 0.22771619f, 0.17191942f, 0.33192471f, 0.01426592f, 0.08700348f, 0.00672486f, 
    0.05128425f, -0.14221700f, 0.16903855f, 0.16851038f, -0.09992587f, 0.10506385f, -0.09174576f, 0.06341302f, 
    0.12525865f, 0.01297452f, 0.10604890f, 0.02553887f, 0.26455551f, 0.39665237f, 0.11200725f, 0.16529717f, 
    0.11403845f, 0.02505575f, -0.07349709f, 0.00637087f, 0.06214531f, -0.06980997f, 0.15269123f, -0.05157477f, 
    -0.09079917f, 0.10126466f, 0.03498446f, 0.14482285f, 0.09100653f, 0.00471575f, 0.16563867f, -0.07688533f, 
    -0.22891407f, -0.04635224f, 0.22298566f, 0.02372537f, -0.11192796f, 0.15425490f, 0.05984097f, 0.03595125f, 
    -0.00423946f, 0.16167878f, 0.05197733f, 0.10272687f, 0.00500554f, -0.03621806f, 0.06018686f, 0.07237879f, 
    -0.10245827f, -0.01811884f, -0.01882593f, 0.05906245f, -0.07130521f, 0.06455421f, -0.09263576f, 0.13294654f, 
    0.00956720f, -0.01552268f, 0.15094322f, -0.06862246f, 0.04329797f, 0.12924424f, 0.05403175f, 0.02287035f, 
    -0.02479392f, -0.02397101f, -0.02144475f, 0.01601353f, -0.00383686f, 0.01943778f, -0.02084159f, -0.06456965f, 
    0.18616238f, -0.24670048f, -0.01546436f, 0.08143552f, -0.18863003f, -0.03546411f, 0.03013997f, -0.02940950f, 
    0.04935635f, -0.04456225f, 0.00074533f, 0.04295875f, 0.04817760f, 0.05158721f, 0.05906058f, -0.01668467f, 
    0.09192566f, 0.01912017f, -0.12862732f, -0.08598433f, 0.40310308f, -0.31561342f, -0.06527794f, 0.10604206f, 
    -0.14135319f, 0.08436185f, -0.08459418f, -0.08507763f, -0.06872160f, -0.06562061f, -0.03175378f, -0.03937784f, 
    -0.04711599f, -0.02218216f, 0.09365760f, -0.02034957f, -0.01217327f, 0.11742996f, -0.01723840f, -0.03602380f, 
    -0.32347897f, 0.08423682f, -0.39464289f, -0.33687577f, 0.04369758f, -0.03066851f, 0.01323153f, -0.15374362f, 
    0.14722024f, -0.00449833f, 0.08908426f, 0.03614081f, 0.07357524f, -0.12555099f, -0.04904687f, -0.03071378f, 
    -0.04149133f, 0.01233829f, 0.11120444f, 0.10016688f, 0.44482431f, 0.01128058f, -0.16279384f, -0.02622504f, 
    0.02684186f, 0.09782676f, 0.04411314f, 0.10154511f, -0.14457208f, -0.09743474f, -0.15319747f, -0.01333439f, 
    0.03394132f, -0.01689495f, -0.07995772f, -0.02067241f, 0.04732541f, 0.02419055f, 0.02462854f, 0.05222414f, 
    -0.07867235f, -0.13904808f, 0.16071269f, 0.14443740f, 0.08325070f, 0.02636867f, -0.02309337f, 0.03704398f, 
    0.06177068f, 0.02376818f, -0.11174531f, 0.15747207f, 0.04417554f, 0.05780820f, -0.06761231f, -0.08413272f, 
    -0.09213369f, -0.06421584f, -0.00526386f, -0.00078826f, 0.03733808f, 0.05469255f, 0.28523767f, 0.10397048f, 
    0.03546136f, -0.00835880f, 0.05071941f, 0.01863786f, -0.06320540f, 0.01593161f, -0.06517495f, -0.05132223f, 
    0.05388197f, -0.11654262f, 0.17074172f, 0.01319006f, 0.04921370f, 0.09939311f, 0.04733155f, 0.03360760f, 
    0.13998407f, -0.43231568f, 0.00508626f, -0.04795912f, -0.10088313f, 0.00710145f, -0.00713840f, -0.18295126f, 
    0.05647074f, -0.19275604f, 0.21525906f, -0.11480579f, 0.17189738f, 0.14970267f, -0.03258672f, 0.03618340f, 
    -0.09309356f, -0.00690428f, 0.02323232f, -0.04040751f, -0.03140642f, 0.12867358f, -0.06990666f, 0.08987917f, 
    -0.11339550f, 0.10566365f, 0.06559776f, -0.03422339f, -0.06517889f, -0.17453593f, 0.00822705f, 0.02668063f, 
    0.00911395f, -0.04324884f, -0.02237621f, -0.03051564f, -0.02884324f, -0.00745918f, 0.01196860f, -0.05249764f, 
    0.18496150f, -0.12235779f, 0.19348881f, 0.08353540f, 0.15576538f, 0.06945077f, -0.01609858f, 0.02703794f, 
    -0.12281987f, 0.11278219f, -0.00417217f, 0.08820748f, 0.08003712f, 0.03393753f, -0.07572051f, 0.03025911f, 
    -0.06397152f, 0.01157420f, -0.07068384f, -0.02639995f, 0.01492419f, -0.14877690f, 0.18253298f, 0.05035623f, 
    0.28588441f, 0.04348255f, -0.02496825f, 0.01749701f, -0.02173914f, 0.03967126f, 0.03825025f, -0.02997421f, 
    0.05868796f, 0.07159982f, 0.16005717f, -0.05946743f, 0.08402093f, -0.06494543f, 0.12117189f, 0.09290677f, 
    -0.07264172f, 0.00920856f, -0.09734008f, -0.15537947f, 0.07116051f, -0.08719508f, -0.08741683f, -0.05831276f, 
    0.02397322f, -0.09616381f, -0.16013426f, 0.12222982f, -0.08315829f, -0.06645381f, -0.01681770f, 0.03599633f, 
    -0.04541453f, 0.02170418f, 0.04368889f, 0.06378509f, -0.14130874f, 0.44395426f, -0.00615710f, 0.03034155f, 
    -0.16926153f, 0.00165697f, 0.04195738f, -0.03612402f, -0.08446709f, -0.09947538f, 0.01447887f, 0.03774789f, 
    -0.01797984f, -0.03145715f, 0.15127018f, 0.03780852f, 0.04618821f, -0.01800058f, -0.04552317f, 0.06400750f, 
    0.33345026f, -0.07304414f, -0.04123898f, -0.03163238f, 0.13288954f, 0.08512475f, 0.05714015f, 0.04764536f, 
    -0.11161211f, -0.13473952f, -0.05245628f, 0.03644012f, -0.09825329f, 0.03533377f, -0.12596229f, 0.11020992f, 
    -0.01951630f, -0.04231425f, 0.12157561f, -0.10223353f, 0.32413793f, 0.06501529f, -0.26919183f, 0.05165882f, 
    -0.00439939f, -0.06569479f, 0.02645719f, 0.15807249f, -0.02044637f, -0.01613565f, 0.03311659f, 0.10968059f, 
    -0.09439030f, 0.11396407f, 0.02849748f, 0.05523523f, -0.07834461f, 0.09858979f, 0.08094908f, -0.04295359f, 
    0.04601908f, 0.02552998f, 0.25532073f, 0.06052644f, 0.07537919f, 0.06229541f, 0.15510349f, -0.12595110f, 
    -0.01871530f, 0.10746972f, -0.06662346f, 0.04270883f, -0.06179740f, 0.08677993f, -0.06614964f, 0.00125212f, 
    -0.01368115f, 0.01655595f, 0.06327705f, -0.06423571f, -0.03474740f, 0.12397473f, 0.10336877f, -0.01432908f, 
    -0.08632334f, -0.09428346f, 0.03226915f, 0.04065554f, -0.11669788f, 0.01051780f, 0.00179599f, 0.02251817f, 
    0.08615195f, -0.00725494f, 0.07163414f, -0.07015599f, 0.00713041f, 0.05628023f, -0.04322035f, 0.06129179f, 
    -0.12384787f, 0.05923297f, -0.00213745f, -0.26088667f, 0.06196271f, -0.08610523f, 0.06517933f, 0.01004943f, 
    -0.12337689f, 0.04013276f, -0.03243284f, 0.06769627f, 0.01081776f, 0.02570997f, -0.00832924f, -0.00088318f, 
    0.14516504f, 0.03181235f, 0.09552792f, -0.05017406f, 0.23179755f, -0.47180736f, 0.20497355f, -0.11056775f, 
    -0.04617609f, 0.06442518f, 0.07423237f, -0.17045934f, -0.09275034f, 0.04896798f, -0.06386188f, -0.03417872f, 
    0.09777384f, 0.02738536f, 0.00218129f, 0.06172348f, 0.01222141f, -0.02874263f, 0.10438257f, -0.06850687f, 
    -0.17620233f, 0.09179424f, 0.05227566f, -0.20728852f, 0.03806517f, 0.24574453f, 0.15802923f, 0.01534802f, 
    0.19458960f, -0.04465155f, -0.00038617f, 0.21057253f, -0.03105409f, -0.13169889f, -0.09806503f, -0.01364946f, 
    -0.01850533f, 0.34507033f, 0.05731741f, -0.10204070f, -0.50051701f, -0.06596092f, -0.10039770f, -0.17779395f, 
    -0.38619456f, 0.03621970f, -0.02976128f, 0.05026229f, -0.05385193f, -0.05958255f, -0.08955356f, 0.07787800f, 
    0.02713696f, -0.02275185f, -0.05130807f, 0.04021532f, -0.01740393f, -0.08955482f, 0.01308231f, 0.06446893f, 
    0.47132879f, 0.14743952f, 0.05762571f, 0.13102661f, 0.06338852f, -0.04609625f, -0.10944294f, -0.07258380f, 
    0.02931920f, 0.06714132f, -0.03402643f, 0.07154412f, -0.05423015f, 0.05345058f, -0.01584390f, -0.17542675f, 
    -0.10410486f, 0.07163868f, 0.04973141f, 0.10387041f, 0.42439786f, -0.16418757f, 0.22049595f, 0.12243342f, 
    -0.01704121f, -0.06915190f, 0.07003229f, -0.02208578f, -0.12545544f, -0.00836196f, 0.01815733f, -0.09986900f, 
    0.07126153f, -0.04611309f, 0.06520724f, -0.10356119f, -0.04375198f, -0.02284821f, 0.07840593f, 0.04631962f, 
    0.35185617f, 0.11430139f, -0.13451265f, -0.18393734f, 0.02611947f, 0.09656937f, 0.08096202f, -0.00121811f, 
    0.09501497f, 0.03620452f, 0.02681418f, -0.00732981f, -0.03554830f, 0.09753794f, -0.15416954f, 0.11378498f, 
    -0.00220437f, 0.04584615f, -0.16880773f, -0.08535311f, -0.50475639f, -0.27253309f, -0.09078754f, -0.05247767f, 
    -0.16865148f, 0.05174503f, 0.00970207f, 0.15106311f, 0.00363237f, -0.15366626f, -0.06684673f, -0.00268153f, 
    0.04618845f, 0.01155970f, 0.06964901f, 0.01944446f, 0.12674004f, -0.04700981f, -0.10284963f, 0.05505987f, 
    0.67851460f, -0.35094345f, -0.04069963f, 0.10310765f, 0.06382512f, -0.08515925f, -0.05997743f, -0.06183300f, 
    -0.05242316f, 0.06273225f, 0.02103545f, 0.02477738f, 0.04463190f, 0.12696756f, 0.09836617f, -0.08966043f, 
    0.00936146f, -0.05060066f, -0.02012018f, -0.00238267f, 0.42878675f, -0.13729160f, 0.15584008f, 0.25358751f, 
    0.43122029f, 0.09921057f, 0.05782418f, 0.03846177f, 0.01579440f, 0.02618590f, -0.02720019f, 0.03271634f, 
    0.11994857f, 0.07032793f, 0.05790292f, 0.05521614f, -0.00684742f, -0.03632569f, 0.08087076f, 0.08017588f, 
    0.20025408f, 0.17737503f, 0.06409761f, -0.05091925f, 0.22135131f, -0.03447735f, 0.09273058f, 0.04530803f, 
    0.11753589f, -0.11413022f, -0.19126491f, 0.02511615f, -0.16272560f, -0.17001301f, -0.03151301f, 0.15213670f, 
    0.08224612f, 0.15458287f, 0.09794448f, 0.00108701f, 0.03687602f, 0.00733139f, 0.07658616f, 0.03075661f, 
    0.05097716f, 0.00675605f, 0.15231085f, -0.07971967f, 0.01106780f, 0.04868172f, -0.02846914f, -0.07268630f, 
    0.00386725f, -0.00718530f, 0.07876037f, 0.07884626f, 0.01829884f, 0.19859806f, 0.00776280f, 0.06051826f, 
    -0.38298041f, -0.25867358f, -0.00577444f, -0.09463406f, -0.14553918f, -0.00510166f, 0.00835453f, 0.00589742f, 
    -0.05416504f, -0.16156298f, -0.07844710f, -0.06530973f, -0.02546443f, -0.01870523f, -0.02926182f, -0.01085814f, 
    -0.02527951f, -0.01142841f, 0.00242073f, -0.05884184f, 0.00845355f, -0.21480735f, -0.14696793f, -0.05459024f, 
    0.04015080f, 0.01655556f, 0.01146382f, 0.05347081f, 0.13334399f, 0.07668850f, -0.09128152f, 0.01766606f, 
    0.11648424f, 0.06569392f, 0.08336678f, 0.03070278f, -0.03119341f, 0.11447909f, -0.02529525f, 0.07382829f, 
    0.00109041f, 0.00940152f, 0.11038643f, 0.01853126f, 0.22635348f, -0.07407782f, 0.00028825f, -0.03159297f, 
    0.05346611f, 0.04817429f, -0.14470915f, 0.03816353f, -0.05301534f, 0.09043721f, 0.04992341f, -0.03053488f, 
    -0.01459089f, 0.11633834f, 0.04622035f, 0.00547738f, 0.24799393f, -0.29610342f, 0.16131507f, 0.02325653f, 
    0.02994441f, 0.02758573f, 0.05468161f, 0.05598418f, 0.00621890f, -0.06890494f, -0.02176048f, 0.02721782f, 
    0.14324434f, 0.10205483f, 0.10304758f, 0.02739957f, -0.11276469f, -0.05560067f, -0.10446777f, 0.08041364f, 
    0.19106504f, 0.16504049f, 0.04912202f, -0.19440472f, -0.15685385f, -0.06030850f, 0.10158791f, 0.00316576f, 
    -0.09896640f, 0.02980469f, -0.03691781f, -0.05083002f, 0.01884221f, -0.03141436f, -0.23852600f, 0.00411579f, 
    0.08270366f, -0.05640746f, 0.14452723f, -0.05469670f, 0.18390296f, 0.04664902f, 0.08809422f, -0.03818596f, 
    -0.13106236f, 0.10510800f, 0.10158298f, 0.11275362f, -0.03476964f, 0.04912805f, -0.01536116f, 0.05432260f, 
    0.01995332f, -0.00866647f, 0.03755357f, 0.04488917f, 0.11755081f, -0.08826681f, 0.16091053f, 0.00535084f, 
    -0.13366333f, 0.12688024f, 0.13926721f, 0.15609512f, -0.30473810f, -0.15330915f, 0.13286269f, -0.00028977f, 
    0.07425862f, 0.04953298f, -0.06558457f, -0.08376498f, -0.12371515f, 0.14881718f, -0.11961059f, 0.12188987f, 
    0.01606044f, 0.21076007f, 0.00121339f, 0.12343624f, 0.40174061f, 0.20820251f, 0.08493082f, -0.04904883f, 
    -0.12959354f, 0.08206555f, 0.00411871f, 0.09870454f, -0.02961537f, 0.00810154f, -0.01240374f, 0.04521416f, 
    0.03636884f, -0.04657887f, 0.17807108f, 0.06446207f, 0.06816509f, -0.07498872f, 0.04717750f, 0.00519294f, 
    -0.12320241f, -0.31577632f, -0.02355797f, -0.04948006f, 0.12256970f, 0.00436516f, 0.04474106f, 0.00354091f, 
    0.02620976f, -0.03853877f, -0.04163829f, 0.09322541f, -0.03410263f, 0.08911277f, 0.04600816f, -0.09687123f, 
    -0.10501546f, -0.01358031f, -0.08637590f, -0.01978824f, -0.32440493f, 0.17067914f, -0.25926667f, -0.08406391f, 
    0.18456168f, 0.06115590f, 0.05096875f, -0.07618979f, -0.09362761f, -0.09462330f, 0.04155316f, 0.08001801f, 
    0.03743593f, -0.03272055f, -0.04755690f, -0.09969930f, 0.05606113f, -0.04941836f, 0.04708370f, 0.03194052f, 
    -0.12681687f, -0.02811241f, 0.10399494f, 0.06643939f, -0.23552836f, -0.22856160f, 0.05023319f, 0.02071361f, 
    0.05263163f, -0.08370467f, -0.01938329f, -0.10952786f, 0.02231272f, 0.06270635f, -0.06125972f, -0.04032062f, 
    0.04377052f, -0.03830893f, -0.02516799f, 0.03341805f, -0.19611874f, 0.22330415f, 0.03245559f, 0.05730604f, 
    -0.21949469f, 0.01338018f, 0.10401437f, 0.11199853f, 0.02856597f, 0.14271332f, 0.02879859f, 0.02889191f, 
    0.05414357f, -0.11563130f, 0.01263426f, 0.00035567f, 0.07608413f, -0.05627435f, 0.04276642f, 0.08909266f, 
    -0.19526684f, -0.09979822f, -0.08857477f, -0.06643915f, 0.16037644f, 0.09929911f, 0.08563643f, 0.09360052f, 
    0.11461344f, 0.02579607f, -0.05209218f, -0.00234006f, 0.10930008f, -0.00909086f, -0.09828799f, -0.03128582f, 
    -0.00576433f, -0.04224370f, 0.02264485f, -0.08408944f, 0.20169871f, -0.15069161f, 0.02361364f, 0.05199050f, 
    0.16480759f, 0.12038612f, -0.04164957f, 0.02979773f, -0.06155242f, -0.11196537f, -0.03850661f, 0.00069489f, 
    0.11496794f, -0.02372931f, 0.08695909f, 0.07147066f, 0.13913400f, 0.01592042f, -0.03383265f, -0.04235436f, 
    0.08965047f, -0.10511394f, 0.01409546f, -0.02069384f, 0.24893728f, -0.01756203f, -0.06023921f, 0.03293008f, 
    0.01557822f, -0.07964098f, -0.01157050f, 0.16211766f, 0.08523707f, 0.10445984f, -0.09558407f, -0.04789981f, 
    -0.02612212f, 0.05670168f, 0.17567095f, 0.07311654f, -0.33648852f, 0.20284420f, -0.12583190f, 0.02369432f, 
    0.14138792f, 0.06936638f, 0.01347550f, 0.09127697f, -0.03780727f, -0.04588151f, -0.00399677f, 0.00110119f, 
    0.08787898f, 0.06336837f, -0.04180641f, 0.04857530f, 0.05142633f, 0.09613396f, -0.13615571f, -0.03515693f, 
    -0.07765498f, -0.07360347f, 0.05695697f, 0.02757970f, -0.12159332f, 0.11419347f, 0.05788748f, 0.12501025f, 
    -0.04625916f, 0.07464224f, -0.05768085f, 0.02678345f, -0.09156162f, 0.02423711f, 0.03186442f, 0.02277706f, 
    -0.07924089f, -0.18104330f, -0.00802394f, -0.06025798f, -0.39761436f, -0.00110906f, -0.01581938f, 0.06782485f, 
    0.18346496f, 0.10295380f, -0.00772865f, 0.16510811f, 0.00688417f, 0.10558952f, -0.08646794f, -0.13924088f, 
    -0.10825952f, 0.01911063f, 0.19000469f, 0.00812421f, -0.01089866f, 0.10452329f, -0.13494608f, -0.06389270f, 
    -0.01523557f, -0.28112358f, 0.17181003f, -0.09775999f, 0.10267469f, 0.11712130f, 0.02591268f, -0.10247737f, 
    -0.03618424f, 0.03463103f, 0.04483834f, -0.01200703f, 0.10713453f, 0.09495713f, -0.01332998f, 0.02139814f, 
    0.01503499f, 0.06786428f, 0.07262391f, 0.07180954f, 0.01326488f, 0.37952754f, -0.26762483f, -0.09824321f, 
    0.02775730f, 0.06999908f, 0.04716218f, 0.01095976f, -0.02770690f, -0.05057513f, -0.06858623f, -0.02727861f, 
    -0.02982637f, 0.01639500f, 0.14830580f, 0.02246301f, -0.08471872f, 0.10010853f, 0.04697718f, 0.16694699f, 
    0.03349775f, 0.06224049f, -0.26798591f, -0.19571286f, 0.19528362f, -0.06672096f, -0.04769600f, 0.11190035f, 
    0.06461452f, 0.04214260f, 0.06042855f, 0.04111167f, 0.02920176f, 0.02689954f, 0.15983698f, -0.01533230f, 
    0.03180623f, -0.00641712f, 0.08471413f, -0.02243896f, 0.31988096f, -0.22504100f, 0.16764325f, 0.17290638f, 
    0.00670612f, -0.11889705f, 0.04290771f, 0.02489190f, 0.09967410f, 0.02546182f, 0.12075946f, 0.04762112f, 
    0.04289609f, -0.11336164f, 0.01325439f, -0.10707626f, 0.00509130f, -0.07189878f, 0.15170498f, -0.03284792f, 
    -0.04671521f, 0.04384798f, -0.00862812f, 0.00344531f, 0.03861000f, -0.01423273f, 0.05444078f, -0.05062960f, 
    -0.03387400f, -0.02077099f, 0.00812868f, -0.01605828f, -0.05014323f, -0.00994775f, -0.06146756f, -0.05775938f, 
    -0.00827877f, -0.03873282f, -0.00469091f, 0.00391448f, -0.06431995f, 0.00353574f, 0.03681092f, 0.04399418f, 
    0.01552360f, -0.06263064f, -0.00371848f, -0.03977147f, 0.01991547f, 0.01895847f, -0.04198638f, -0.03887084f, 
    0.02630558f, -0.05872824f, -0.00604316f, 0.03823282f, -0.04623219f, 0.04331096f, -0.02548468f, -0.02245893f, 
    0.00628009f, -0.05011619f, -0.06237063f, -0.04955506f, -0.04761974f, 0.00462096f, 0.04385044f, 0.01163081f, 
    -0.01384230f, 0.04080256f, 0.02768377f, -0.04453602f, 0.01521562f, 0.01005791f, -0.03182656f, 0.03828045f, 
    -0.05604301f, 0.04388259f, -0.04675760f, 0.00693934f, 0.01707209f, -0.06146977f, -0.05546870f, -0.01405513f, 
    -0.05126628f, 0.02396112f, -0.00744564f, -0.02666867f, 0.00792206f, 0.01041423f, -0.01704877f, -0.00152121f, 
    -0.04768400f, -0.02986644f, -0.00684440f, -0.02491147f, -0.03821089f, -0.05147573f, 0.04549437f, 0.04107020f, 
    0.04831202f, -0.05798742f, -0.00431619f, -0.02939399f, 0.00227970f, 0.03848786f, 0.02974828f, -0.01754997f, 
    -0.03566264f, -0.03151269f, 0.05166848f, 0.01613025f, -0.01389142f, -0.03708709f, -0.02967916f, -0.03330871f, 
    0.02508917f, -0.04859643f, -0.00936581f, 0.00074900f, 0.02829177f, 0.04067764f, 0.04268304f, 0.03192928f, 
    -0.03500390f, -0.03598581f, -0.04427582f, -0.00411982f, 0.00306606f, -0.04106208f, -0.05815442f, 0.00534142f, 
    -0.00108090f, 0.01564992f, -0.03824234f, 0.01083481f, -0.04399331f, 0.01132002f, -0.00396193f, -0.01174943f, 
    -0.03326838f, -0.00039167f, -0.00218145f, 0.03142266f, -0.01916232f, -0.02491687f, -0.00907493f, 0.01621199f, 
    0.04620900f, -0.03402957f, -0.01001943f, 0.01703429f, -0.02448989f, 0.01689324f, -0.02996695f, 0.03363188f, 
    -0.02591479f, -0.02057301f, 0.04356514f, 0.04183859f, -0.03403990f, 0.00920673f, -0.04655159f, 0.04323675f, 
    -0.03757380f, -0.01601698f, -0.03971842f, -0.04522669f, -0.00115567f, 0.03186703f, -0.01448085f, 0.00752184f, 
    -0.05261048f, 0.02738625f, 0.00656546f, -0.06076067f, -0.04970356f, -0.05320563f, -0.02032557f, 0.01949841f, 
    0.00182945f, 0.01563033f, -0.01218162f, 0.00821792f, 0.01729396f, -0.01447133f, -0.03461234f, -0.06476162f, 
    0.00561462f, -0.00867183f, 0.03118926f, 0.00732359f, -0.00264900f, -0.01669789f, 0.03485283f, -0.02106796f, 
    -0.00347814f, -0.04752032f, 0.01892719f, -0.05457548f, 0.03371786f, 0.00490748f, -0.05483053f, -0.04077335f, 
    0.02332126f, 0.04439766f, -0.03835982f, 0.02618396f, 0.00901513f, 0.01791255f, -0.02901017f, 0.00410030f, 
    -0.03726055f, 0.00539274f, 0.03334840f, -0.05207352f, -0.03519268f, 0.04640185f, 0.00418692f, 0.02730751f, 
    -0.00225666f, 0.01658145f, -0.00742450f, -0.00259618f, -0.02539778f, 0.01167697f, 0.00746003f, -0.04585944f, 
    -0.02356969f, -0.00373683f, -0.04448247f, -0.05388655f, -0.03069813f, -0.05555826f, 0.04124443f, -0.05013574f, 
    -0.04531157f, 0.03197870f, -0.00264717f, -0.02461937f, -0.02743671f, -0.04006467f, -0.00919124f, -0.03933828f, 
    -0.02287029f, 0.03001496f, -0.02042584f, 0.03353846f, -0.05762877f, 0.04713577f, -0.01132665f, 0.04325724f, 
    0.03369267f, -0.06342462f, -0.04657551f, 0.00343089f, -0.06206216f, 0.02794083f, 0.04469953f, 0.03536141f, 
    -0.05960792f, -0.03753879f, -0.04062112f, 0.01688138f, 0.04283015f, 0.01059452f, -0.03138830f, -0.01210669f, 
    -0.00213157f, 0.03587279f, -0.02101754f, 0.01709738f, -0.01923999f, 0.03327387f, -0.04051409f, -0.03079943f, 
    -0.03865510f, -0.06133423f, -0.02577688f, -0.04953748f, 0.00462045f, -0.06676757f, 0.00081407f, -0.04034687f, 
    0.00899984f, -0.04686096f, 0.01088190f, 0.04302230f, -0.03708069f, -0.03061395f, 0.03145172f, 0.04028945f, 
    -0.04386257f, -0.06090403f, 0.03984189f, -0.06158429f, 0.02546516f, -0.03324360f, 0.00301462f, -0.00406406f, 
    -0.03171061f, 0.02654066f, -0.02384096f, 0.04002165f, -0.04285062f, -0.05871086f, -0.06015018f, 0.03325328f, 
    0.02645210f, 0.01963937f, -0.00491670f, -0.05314501f, 0.02688877f, 0.01037699f, 0.01960702f, -0.03500215f, 
    0.02057829f, -0.06341174f, -0.00895722f, -0.05800274f, -0.00833715f, 0.02362252f, -0.00858829f, 0.00333241f, 
    -0.05781678f, 0.03466624f, 0.03593625f, -0.04752146f, -0.05501535f, -0.00062175f, 0.03466897f, 0.01717132f, 
    -0.05686775f, 0.02540785f, 0.03840994f, -0.03001084f, 0.04223989f, -0.02573225f, -0.01377324f, 0.00393472f, 
    0.03800098f, 0.00458273f, 0.03654719f, -0.01111483f, 0.04855210f, 0.01216529f, 0.02763132f, -0.04244961f, 
    -0.03266558f, 0.00161205f, -0.03268295f, 0.02347260f, -0.03233240f, -0.04574462f, -0.02242148f, 0.03870125f, 
    -0.03699885f, -0.02556385f, -0.02302718f, -0.01537367f, -0.04842585f, 0.04124078f, -0.02246877f, 0.04343856f, 
    -0.06210667f, -0.06030892f, -0.00370047f, 0.01576485f, 0.03107899f, -0.04725996f, -0.03698491f, 0.05124392f, 
    0.00795616f, 0.03455493f, -0.05362506f, 0.02523402f, -0.00321590f, -0.04390127f, -0.02394857f, -0.01988698f, 
    0.01274507f, -0.05705163f, 0.04517444f, 0.01379691f, 0.00703326f, -0.00474585f, -0.01689793f, -0.04718726f, 
    -0.04522507f, 0.01858051f, 0.01665962f, -0.04963385f, -0.02656183f, 0.01539694f, 0.00347157f, -0.03964111f, 
    -0.01376963f, -0.00460575f, -0.04486852f, 0.02058819f, -0.05082703f, 0.02270455f, -0.01474478f, 0.04540040f, 
    -0.01024824f, -0.00469656f, -0.04536261f, -0.02481310f, -0.05641933f, 0.02896400f, 0.00320192f, -0.02761034f, 
    -0.02537074f, 0.02543206f, -0.04127745f, 0.04780566f, -0.00528697f, 0.00648842f, -0.06077310f, -0.01348317f, 
    0.03934627f, 0.03723827f, -0.04999908f, -0.05064701f, -0.01706675f, 0.04263384f, -0.02408325f, 0.04339281f, 
    0.04410119f, -0.00055540f, 0.01580988f, -0.02295180f, 0.04906654f, 0.00128930f, 0.02387778f, -0.01445087f, 
    -0.04510844f, 0.03209930f, 0.05172920f, 0.02832163f, 0.04045982f, -0.05035360f, -0.03552065f, 0.00052850f, 
    -0.06000590f, -0.06047618f, -0.01401199f, 0.02173172f, -0.02740855f, -0.02361811f, 0.02577223f, 0.02690652f, 
    -0.05523667f, -0.02500046f, -0.04314023f, 0.00048357f, 0.03632991f, 0.01445403f, 0.01548936f, -0.00413256f, 
    -0.02634402f, 0.00910084f, 0.04198616f, -0.04293607f, -0.05027340f, -0.04432381f, 0.01631381f, 0.02752562f, 
    0.00680823f, -0.05540228f, -0.02596368f, -0.03238039f, 0.01170027f, 0.04837507f, -0.01338787f, -0.04502998f, 
    0.02412741f, -0.02755190f, 0.00849875f, 0.01791265f, -0.00249536f, -0.06112133f, -0.01518772f, -0.01197416f, 
    -0.06008366f, -0.02811282f, -0.00706788f, 0.01620708f, 0.03442954f, 0.03506485f, 0.04212647f, 0.01062404f, 
    -0.01079894f, -0.03439881f, -0.03358598f, 0.00725926f, -0.02780563f, -0.01499410f, -0.02013368f, -0.01340909f, 
    -0.04412034f, 0.04603627f, 0.00426991f, -0.05152027f, -0.03464151f, -0.05817067f, 0.02462813f, -0.05201388f, 
    -0.04455581f, -0.02796222f, -0.03557325f, -0.05737690f, 0.03489950f, -0.01710080f, -0.01651328f, 0.01837851f, 
    0.03367810f, 0.03417023f, -0.01209447f, -0.03369339f, -0.03815375f, 0.01894766f, 0.00598352f, 0.00624563f, 
    0.03227432f, -0.00870228f, -0.04094026f, -0.04596947f, -0.03627917f, -0.05848881f, 0.02217111f, 0.04215823f, 
    -0.03590617f, 0.01439569f, -0.05643145f, -0.00710721f, -0.00755062f, -0.02181320f, 0.01951031f, -0.06289173f, 
    0.03649400f, -0.03630155f, 0.03905073f, 0.03950839f, 0.00521681f, 0.03176444f, -0.04545685f, 0.05114317f, 
    0.02656492f, 0.03084610f, -0.05017006f, -0.02102342f, -0.00629012f, 0.03441034f, 0.04909844f, -0.01434248f, 
    -0.04084749f, -0.04077515f, 0.04241429f, -0.05509962f, 0.03136181f, 0.03584666f, -0.05295067f, -0.02591318f, 
    0.02627083f, 0.01980956f, -0.01599573f, 0.02210487f, -0.00276514f, -0.03050791f, 0.00055348f, 0.05078940f, 
    -0.00836171f, -0.01557178f, 0.00784250f, -0.05359412f, 0.01808521f, -0.02522961f, 0.00185837f, 0.03129545f, 
    -0.00418954f, -0.04855239f, 0.02485950f, 0.01404219f, -0.00558930f, -0.03207928f, 0.02468484f, -0.05226657f, 
    -0.04612571f, -0.02993443f, 0.01866820f, -0.00439788f, 0.00820695f, 0.00999840f, -0.05487998f, -0.04924599f, 
    0.02689979f, 0.05119522f, -0.05601398f, 0.04672036f, -0.06357621f, 0.01705566f, 0.03515762f, -0.00182364f, 
    -0.04811535f, 0.03444679f, 0.00108734f, -0.00251026f, 0.00806200f, 0.00671945f, 0.01969180f, 0.00705980f, 
    -0.04374248f, 0.00535986f, 0.01948243f, -0.03808189f, 0.00639531f, -0.00909144f, 0.04338850f, 0.03145938f, 
    -0.03456835f, 0.03012808f, 0.02565828f, 0.02849652f, 0.04145395f, -0.01244554f, -0.01934313f, -0.01280877f, 
    0.02962338f, -0.02777026f, -0.00543110f, 0.04480199f, -0.03477990f, -0.05829915f, -0.01790589f, -0.01498642f, 
    -0.06214384f, -0.05377923f, 0.03438504f, -0.04670344f, -0.00059501f, 0.05288236f, -0.05741818f, -0.01462760f, 
    0.01765577f, -0.02448119f, -0.04657726f, -0.03107709f, -0.05767363f, -0.00868664f, 0.01157990f, 0.03476404f, 
    -0.01990321f, 0.01099825f, -0.03412332f, -0.00027795f, -0.03669781f, -0.05959871f, -0.03970526f, 0.00038103f, 
    -0.37890515f, -0.00667882f, 0.06433180f, 0.01310315f, -0.22953542f, 0.08713520f, -0.01583618f, 0.07074819f, 
    0.12586343f, -0.11011462f, -0.05155435f, -0.03402977f, -0.00059359f, -0.04352963f, -0.09661664f, -0.14864522f, 
    -0.00238073f, 0.10935228f, -0.00864089f, 0.01044873f, -0.36613101f, 0.02432762f, 0.19868037f, 0.04547518f, 
    -0.23743427f, 0.05273911f, 0.05323003f, 0.04151505f, -0.07435105f, -0.00813964f, -0.01900399f, 0.07119688f, 
    0.10337336f, -0.10574673f, 0.03877714f, 0.00391876f, 0.03220785f, -0.08116229f, -0.09445377f, 0.02519699f, 
    0.22574213f, 0.25326490f, -0.00260458f, 0.18499297f, 0.15650254f, 0.14625415f, -0.02182927f, -0.06349606f, 
    0.01890830f, 0.12228302f, 0.01071072f, -0.03775650f, -0.04763812f, 0.03967486f, -0.11667998f, -0.00722885f, 
    -0.09541620f, 0.02973530f, 0.02283378f, 0.05123643f, 0.60465580f, -0.22276098f, 0.10782293f, 0.15068968f, 
    0.13833798f, 0.10026339f, 0.08321834f, 0.00034214f, -0.06584082f, 0.06781519f, -0.06661446f, -0.07469706f, 
    0.05050255f, -0.03515574f, 0.07411724f, 0.00106848f, 0.15130234f, 0.02419727f, 0.12662151f, -0.02740644f, 
    0.36935943f, 0.08109269f, -0.05345587f, -0.10285043f, -0.18578668f, 0.01078465f, 0.25812072f, -0.00241678f, 
    0.09949172f, 0.13000517f, -0.03919034f, 0.03837781f, 0.00050080f, 0.02919435f, -0.12679335f, 0.08832483f, 
    0.06427068f, -0.10924595f, 0.00097230f, -0.01872839f, -0.25684318f, -0.11796181f, 0.21563524f, 0.15715723f, 
    -0.26697382f, 0.05894373f, 0.01265418f, 0.28222153f, -0.05620167f, -0.02468558f, 0.08670857f, 0.02411097f, 
    -0.07134339f, 0.00111365f, -0.01079995f, -0.00081684f, -0.04091915f, -0.03219369f, -0.08871653f, -0.04927683f, 
    0.38601413f, -0.30864447f, -0.26151836f, 0.05203957f, 0.26703474f, -0.07861172f, -0.01103167f, 0.01838714f, 
    -0.01362221f, 0.16707714f, 0.04221125f, 0.12018812f, 0.06733117f, 0.14241834f, 0.05531325f, 0.05572650f, 
    0.06122129f, -0.06674616f, -0.05866836f, -0.10779016f, 0.07451684f, 0.07207242f, -0.09397467f, 0.01701867f, 
    0.53188622f, 0.03763771f, -0.01459515f, -0.06660982f, 0.00054252f, -0.02319171f, -0.04230025f, -0.08966763f, 
    0.07414115f, 0.02889743f, 0.11451967f, -0.02281618f, 0.16011307f, -0.05914422f, 0.12485237f, 0.12141267f, 
    0.03925129f, 0.21423908f, 0.04364656f, 0.05482627f, 0.13655905f, 0.07899065f, 0.13310245f, 0.02703521f, 
    -0.01444871f, 0.02097468f, -0.08750477f, -0.20737723f, -0.02551318f, -0.09971602f, -0.05002511f, 0.06123227f, 
    0.16483295f, 0.13956627f, 0.08534816f, 0.08794581f, 0.16046457f, 0.08304655f, -0.18134597f, -0.14476719f, 
    -0.01001612f, 0.02043252f, 0.11759445f, -0.05535667f, -0.05075449f, -0.12590127f, -0.01295916f, -0.11582759f, 
    -0.01287087f, -0.01263734f, 0.03127665f, 0.05658177f, 0.05767082f, 0.20092228f, 0.03062316f, 0.00279955f, 
    -0.16619493f, 0.00124592f, -0.04136608f, -0.12542766f, -0.00008649f, 0.10262407f, 0.10517216f, -0.00745104f, 
    0.09570588f, -0.01060249f, 0.00894924f, -0.09016035f, 0.04562175f, 0.04915947f, 0.12612145f, 0.05334603f, 
    -0.02776972f, -0.08840434f, 0.01948820f, -0.12325271f, -0.20387918f, -0.20525178f, -0.00091422f, 0.03707927f, 
    0.04895534f, 0.08596514f, -0.02711603f, 0.05732430f, 0.07492352f, 0.00120301f, -0.00271559f, -0.00623256f, 
    -0.00893341f, 0.08670024f, 0.00621334f, 0.06520043f, -0.09524812f, 0.04692683f, 0.00173899f, 0.03232860f, 
    -0.24805273f, 0.16976278f, -0.13212769f, -0.02502249f, 0.30984432f, -0.01611776f, 0.07211274f, -0.08081604f, 
    -0.01993123f, 0.10862049f, -0.13712499f, 0.03444551f, 0.04201228f, -0.01019285f, -0.11040688f, 0.01178513f, 
    -0.08023322f, 0.08887745f, 0.12431798f, 0.05410890f, 0.02503620f, -0.21619192f, 0.09413569f, 0.04045643f, 
    0.21366580f, 0.06072287f, -0.03781651f, 0.12125471f, -0.01189110f, 0.06343793f, 0.04037128f, 0.08424596f, 
    0.15114570f, 0.07942614f, 0.19196430f, 0.03141235f, 0.06504755f, 0.03370842f, 0.10441929f, 0.07474445f, 
    -0.08141176f, 0.41942745f, -0.04305645f, -0.10855171f, 0.04537200f, 0.00666267f, 0.13905734f, -0.00527395f, 
    -0.08764104f, 0.02734111f, -0.00067148f, 0.02617319f, 0.01484852f, -0.02557145f, -0.05456955f, -0.00418169f, 
    0.06345302f, 0.00735573f, 0.22826828f, 0.06223997f, 0.50179160f, -0.23323300f, 0.05073596f, -0.17969751f, 
    -0.29171324f, 0.03619387f, 0.02004681f, 0.01342556f, -0.11954197f, 0.12525448f, -0.04092722f, -0.04439500f, 
    -0.05480148f, -0.01350629f, 0.03736764f, 0.04698099f, -0.04662133f, -0.00272861f, 0.05590734f, -0.04235387f, 
    -0.18757574f, -0.19879647f, 0.11871567f, -0.47186807f, -0.11059102f, 0.00914276f, 0.09568972f, 0.05730668f, 
    -0.15221064f, -0.03767427f, 0.07372313f, 0.00602707f, 0.11301670f, -0.15858506f, 0.09395198f, -0.09225546f, 
    0.03648967f, -0.00428747f, 0.04074817f, -0.02992055f, 0.19870393f, 0.00807801f, 0.17280015f, -0.03960964f, 
    0.11614961f, 0.01616093f, 0.00017342f, -0.02601282f, -0.02524713f, 0.05395919f, -0.00800892f, -0.01241281f, 
    0.07854133f, 0.01318332f, -0.06509221f, 0.06334474f, 0.04661180f, -0.04139064f, 0.05047817f, 0.07865389f, 
    0.11070045f, 0.10169110f, 0.01528902f, 0.07983891f, -0.09737357f, 0.05556988f, -0.00134336f, -0.01278890f, 
    0.08693334f, 0.19285375f, -0.04732661f, -0.07154822f, 0.01750679f, -0.04661364f, -0.07725626f, 0.01593401f, 
    -0.03883490f, -0.03345053f, 0.11287542f, 0.06403898f, 0.12436026f, -0.01623380f, 0.12311880f, 0.30274689f, 
    -0.21024396f, -0.00215033f, 0.08961254f, 0.00580783f, 0.17740045f, 0.12635104f, -0.05463266f, -0.01173446f, 
    -0.02073606f, 0.01597385f, 0.10006923f, 0.03866217f, -0.03854854f, 0.08869076f, 0.00735729f, -0.05169936f, 
    0.07663186f, 0.16937429f, -0.03586947f, -0.29687589f, 0.22302939f, -0.11052718f, 0.09567259f, 0.01988513f, 
    -0.09650214f, 0.05606068f, 0.09863837f, -0.05441957f, 0.09357560f, 0.16253071f, 0.02571101f, -0.05918414f, 
    -0.05627941f, 0.06611886f, -0.12955533f, -0.04505564f, 0.31529224f, -0.02488421f, 0.05757990f, 0.15997195f, 
    0.11283399f, 0.10839459f, -0.06409138f, 0.08692672f, 0.03710192f, -0.07470073f, 0.05697216f, 0.04815665f, 
    0.04220061f, 0.02155738f, 0.08138199f, -0.04640414f, 0.02856286f, 0.11670960f, 0.03064025f, -0.04467227f, 
    0.19043586f, 0.18066584f, -0.00993896f, 0.05989404f, 0.08501574f, -0.02393221f, 0.02813594f, -0.04655397f, 
    -0.06902528f, 0.15221956f, -0.03462195f, 0.06613019f, -0.05979175f, 0.04445520f, 0.03551288f, 0.12512356f, 
    0.00988898f, -0.06128555f, -0.01389303f, -0.08393639f, -0.09126204f, -0.20949902f, -0.21039127f, -0.20286128f, 
    0.05057853f, -0.14226022f, -0.08195350f, -0.03362340f, -0.12928119f, 0.21656136f, 0.06206041f, 0.03771734f, 
    -0.00413980f, 0.13150930f, 0.11484693f, 0.04857297f, 0.05791065f, -0.02373209f, -0.03712551f, 0.02124869f, 
    0.17101496f, -0.15573622f, -0.12024561f, 0.02068269f, -0.06496349f, 0.04214378f, 0.07537786f, 0.06006553f, 
    0.01328983f, 0.04727929f, 0.07446591f, -0.01679695f, 0.01455664f, -0.01319846f, 0.10130306f, 0.06740163f, 
    0.00768477f, 0.10389042f, -0.06943048f, -0.03608328f, 0.03208565f, -0.07989666f, -0.11515605f, -0.04917787f, 
    -0.33239943f, 0.10861585f, -0.02903942f, 0.04995336f, -0.04099349f, -0.03154290f, 0.02863002f, 0.04034317f, 
    -0.11583710f, -0.04284841f, 0.13785587f, 0.04677043f, -0.06362271f, 0.04844911f, 0.10150746f, 0.04198543f, 
    0.20708996f, 0.18673569f, 0.02647609f, 0.00093047f, 0.15252453f, 0.07092863f, 0.15870148f, -0.09616157f, 
    0.08225817f, -0.07001420f, 0.07837391f, 0.12166688f, -0.00216462f, -0.09940033f, -0.03562185f, -0.01737571f, 
    0.18173482f, 0.08997671f, 0.05170537f, -0.00451463f, 0.37796727f, 0.20001036f, 0.00074543f, 0.08570740f, 
    0.01697092f, 0.16259199f, -0.07834304f, 0.04110915f, 0.01468248f, -0.01633316f, 0.10776527f, 0.06511261f, 
    0.02067530f, 0.04707158f, -0.02291559f, 0.14940001f, -0.02305565f, -0.00002167f, 0.10548423f, 0.03203347f, 
    -0.13985509f, -0.29255018f, 0.25150523f, 0.17166325f, -0.24790230f, 0.08419725f, -0.02109736f, -0.01038557f, 
    -0.01951427f, 0.12497798f, 0.02995784f, -0.05016184f, -0.07667119f, 0.13553232f, 0.08460107f, 0.03195211f, 
    -0.05521742f, -0.02103303f, 0.01450006f, 0.07581884f, -0.15947711f, -0.20173416f, -0.05984832f, 0.27593803f, 
    -0.18393749f, -0.08617917f, -0.05877143f, -0.01433993f, 0.03812117f, 0.08675460f, 0.08034827f, 0.06534138f, 
    0.09764492f, 0.06953123f, 0.03481989f, 0.04930485f, 0.12898347f, -0.00021234f, 0.07578531f, 0.00539164f, 
    -0.16918758f, -0.21000113f, 0.05838457f, -0.09889480f, -0.31083211f, -0.04546734f, 0.11986890f, 0.04534006f, 
    0.05824998f, -0.03720971f, 0.09227000f, -0.01003191f, -0.02321437f, 0.04638322f, -0.07930240f, 0.01609208f, 
    0.11623491f, -0.03503774f, 0.07828448f, 0.00076664f, -0.01926811f, 0.10419416f, 0.03807778f, -0.06371231f, 
    0.04713150f, 0.10642733f, 0.04604000f, 0.00922611f, -0.12363254f, -0.09177162f, -0.08508600f, -0.02435223f, 
    0.04924645f, 0.03997137f, 0.11663489f, 0.16816126f, -0.08112881f, -0.00893352f, -0.01400617f, 0.06646897f, 
    -0.09306955f, 0.15446809f, -0.04641029f, 0.29603317f, -0.14160132f, -0.07576958f, -0.07604418f, -0.13302949f, 
    0.09009753f, -0.03446736f, 0.03927580f, -0.15189354f, -0.09936953f, 0.20543635f, -0.07780026f, -0.03451966f, 
    0.04174992f, -0.08338478f, -0.02948093f, 0.05356220f, 0.19058740f, 0.06423143f, 0.06152075f, 0.05979146f, 
    -0.12372178f, 0.17053956f, 0.00844663f, 0.05309168f, -0.03855882f, 0.01438047f, 0.00870849f, -0.00353003f, 
    0.00059831f, 0.05312119f, 0.15783259f, -0.00591008f, 0.05676515f, -0.02103680f, 0.00055400f, 0.00251578f, 
    -0.28884465f, -0.18377058f, 0.06449745f, -0.06542585f, 0.17014796f, -0.03900515f, 0.08163383f, 0.05207076f, 
    0.02330684f, -0.08456543f, 0.04411905f, 0.00422992f, 0.07069729f, 0.07401266f, 0.04486721f, -0.03637368f, 
    -0.02136471f, 0.03748898f, -0.03302102f, 0.03612256f, -0.28980389f, 0.05410209f, 0.07039058f, -0.15736134f, 
    0.32949993f, 0.11926422f, 0.09889714f, -0.06723381f, -0.03837060f, -0.13869451f, 0.09214021f, 0.11785067f, 
    0.04842067f, -0.01169122f, -0.04817285f, -0.03389672f, 0.09895132f, 0.02067414f, 0.05815816f, -0.03663402f, 
    -0.16849414f, -0.09650919f, 0.08102693f, 0.17917001f, -0.32930183f, -0.07178168f, 0.01332719f, -0.00181184f, 
    0.12229319f, -0.08766398f, -0.02418266f, 0.02007482f, 0.02551584f, -0.04350446f, 0.02537087f, -0.01256157f, 
    0.05092107f, -0.09726141f, 0.09568378f, 0.02534358f, -0.21674176f, 0.10617208f, 0.01476745f, 0.01676221f, 
    -0.31291595f, 0.04448234f, 0.09736321f, -0.00110754f, -0.03688598f, 0.15478487f, 0.06657603f, 0.00779938f, 
    0.01105118f, -0.17926112f, -0.01973941f, 0.07284563f, 0.00333907f, -0.02372943f, 0.03808842f, 0.09825411f, 
    -0.33716625f, -0.11029809f, -0.04559416f, -0.03355880f, 0.26063043f, 0.10398469f, -0.01378501f, 0.11117743f, 
    -0.01384533f, -0.06734395f, 0.03323442f, -0.00213627f, 0.12264132f, 0.03364058f, -0.07907760f, -0.05601014f, 
    -0.08337905f, -0.02523520f, -0.03552438f, -0.06031430f, 0.06210019f, 0.05260134f, 0.01895283f, 0.00983903f, 
    0.12424343f, 0.13545057f, 0.08035197f, 0.02274319f, -0.02808707f, -0.17556345f, -0.05457949f, -0.03420500f, 
    0.02064180f, 0.02607420f, 0.01376281f, 0.05512192f, 0.14802015f, -0.03552406f, 0.01252788f, 0.00106511f, 
    -0.06259702f, 0.02948548f, 0.03375449f, -0.02536236f, 0.09704512f, -0.01412778f, -0.01828199f, -0.03857964f, 
    0.03659911f, -0.06893066f, 0.02936793f, 0.06626400f, 0.12177645f, 0.08279216f, -0.09433449f, -0.05139340f, 
    0.05975371f, -0.06068511f, 0.16722231f, 0.06637498f, -0.11183131f, 0.53761512f, -0.07074408f, -0.02393428f, 
    0.14689216f, 0.08357026f, 0.02781020f, -0.01292781f, -0.07514360f, -0.05812360f, 0.12096769f, -0.06627346f, 
    0.02801633f, 0.05306360f, -0.11388198f, -0.05189185f, 0.13269672f, -0.05456601f, -0.07942864f, -0.06682887f, 
    0.02449618f, 0.00923128f, 0.00671499f, 0.00195725f, -0.13611326f, 0.02329573f, 0.06698501f, 0.06120420f, 
    -0.09029920f, 0.01048269f, 0.03846156f, 0.01075525f, -0.03115469f, 0.07607993f, 0.09478956f, 0.05657102f, 
    -0.06954622f, -0.11305629f, 0.06019313f, -0.03522502f, -0.51917315f, -0.05117897f, -0.03740777f, 0.06912135f, 
    0.02844070f, -0.07533416f, -0.06938615f, 0.07980803f, -0.03483703f, 0.05582584f, 0.00308068f, -0.12319849f, 
    -0.06241579f, 0.06191132f, 0.12174688f, -0.06014632f, 0.04772209f, 0.04586709f, -0.02706237f, -0.12775165f, 
    -0.06257840f, 0.15593664f, 0.15404478f, -0.03536054f, 0.21675414f, 0.00850396f, 0.15830232f, 0.02246252f, 
    -0.03561489f, 0.01581653f, 0.05916934f, 0.01198203f, 0.04870640f, -0.03768698f, 0.02430099f, 0.05419097f, 
    0.03690246f, 0.00381923f, 0.07471504f, -0.04016174f, 0.01816105f, 0.28074417f, 0.00413515f, -0.24175712f, 
    0.29596460f, 0.15343964f, 0.03366138f, 0.06552859f, -0.01045323f, 0.01490182f, -0.04799543f, 0.05228980f, 
    -0.08427919f, -0.02502806f, 0.09154852f, 0.01717458f, 0.00242479f, 0.05604250f, -0.01963720f, 0.08244764f, 
    -0.02636888f, 0.07547950f, -0.14970562f, -0.14638796f, 0.43419489f, 0.10445087f, -0.07684917f, -0.00605212f, 
    0.02649645f, 0.04246392f, 0.03505171f, 0.09316773f, 0.05946150f, -0.00532498f, 0.18766351f, -0.13050456f, 
    -0.06515284f, 0.10649998f, -0.04132306f, 0.05457893f, 0.48442686f, -0.24673690f, 0.17200842f, 0.09690113f, 
    -0.00461520f, -0.15343793f, -0.07975537f, 0.01498698f, 0.04672255f, 0.13171044f, 0.12048126f, 0.04621461f, 
    -0.04240469f, -0.05728528f, 0.03353135f, -0.10110246f, -0.02829074f, 0.00169858f, 0.02160910f, 0.01650339f, 
    0.01644568f, -0.00901270f, -0.03162848f, -0.06146872f, -0.02385750f, -0.01402562f, -0.03172069f, 0.00008349f, 
    -0.02687079f, 0.03451721f, -0.00408777f, -0.06140469f, -0.01362719f, 0.02786161f, 0.04019605f, 0.01162771f, 
    -0.02671914f, -0.01298264f, 0.02902029f, -0.04529728f, -0.05165588f, 0.01911797f, 0.03294538f, -0.01553525f, 
    -0.00935955f, 0.03795603f, 0.03423713f, 0.03569895f, 0.03970955f, -0.04362147f, 0.03158473f, 0.03734932f, 
    0.02268618f, -0.03686051f, 0.04722786f, -0.02600696f, -0.03745330f, 0.04479738f, 0.02945956f, 0.00421485f, 
    -0.02661381f, 0.02129085f, -0.05988376f, -0.03441925f, -0.06187461f, 0.02025978f, 0.03694849f, 0.02980738f, 
    -0.02453140f, -0.01283376f, -0.06180409f, 0.00583253f, -0.03164228f, -0.03656527f, -0.04602375f, 0.02005010f, 
    -0.00648063f, -0.05652720f, 0.02484057f, 0.03188306f, 0.00395181f, -0.04754234f, -0.01296096f, -0.05658282f, 
    -0.06493413f, 0.01070620f, 0.05562653f, -0.02533249f, 0.02453452f, -0.03919372f, 0.02961065f, -0.04702936f, 
    0.02124703f, -0.02877394f, 0.02482953f, -0.00372119f, 0.01041521f, -0.00126133f, 0.02257996f, -0.02729421f, 
    -0.02468638f, 0.00803787f, -0.00063147f, 0.01615401f, 0.02796256f, -0.02692001f, -0.02778367f, -0.04049269f, 
    0.00837589f, 0.02128831f, -0.01789738f, 0.02545927f, 0.03208127f, 0.04480735f, -0.03100487f, 0.03510089f, 
    0.00372558f, 0.00162090f, -0.05059863f, 0.02460919f, -0.04879450f, -0.03076104f, 0.00898668f, -0.05878785f, 
    -0.02910371f, 0.01828239f, 0.03635648f, -0.02249111f, 0.00714827f, -0.04675175f, 0.04652677f, -0.04411482f, 
    -0.04863309f, -0.02763981f, 0.02135556f, -0.06338432f, -0.00535544f, -0.02173917f, 0.04548383f, -0.05367884f, 
    -0.01428614f, -0.06007570f, -0.01515456f, 0.03784935f, -0.02386007f, 0.00494504f, 0.00818309f, 0.01611506f, 
    0.02681750f, -0.00410708f, 0.01719269f, 0.04209335f, -0.06272694f, -0.02575126f, -0.04544951f, -0.01754116f, 
    -0.00314469f, 0.04905603f, 0.03140236f, 0.00201539f, -0.01668829f, -0.06038168f, -0.05694436f, -0.05555249f, 
    0.03941604f, -0.02010388f, 0.03659005f, 0.03166201f, -0.05729693f, -0.00674199f, 0.00635770f, 0.02177701f, 
    -0.03425851f, -0.03458349f, 0.01639835f, -0.00380144f, 0.05346336f, -0.02423999f, -0.01380010f, -0.04856075f, 
    -0.02964276f, -0.04592576f, -0.01622300f, 0.03541644f, 0.03572470f, -0.01316182f, -0.01562949f, -0.04096688f, 
    0.00774167f, -0.01865133f, -0.06313901f, 0.00983162f, 0.04417966f, -0.05223770f, -0.05189526f, -0.02443260f, 
    -0.01397062f, -0.03856657f, 0.02710613f, -0.06022386f, 0.03626142f, -0.00482225f, 0.03060723f, 0.01088371f, 
    0.02736753f, -0.02902220f, -0.04603883f, -0.06295057f, -0.00101432f, -0.03172907f, 0.01067462f, -0.03926494f, 
    0.02561248f, 0.00894728f, -0.03836410f, -0.02628399f, 0.02121698f, -0.03323483f, 0.01403761f, -0.05730489f, 
    0.02206612f, -0.04401428f, 0.03012593f, 0.01361704f, -0.00745892f, -0.02252698f, 0.03905158f, -0.00925285f, 
    0.04371996f, 0.01783665f, -0.02652560f, -0.05897645f, -0.01150033f, 0.00906875f, -0.04464751f, -0.01466504f, 
    0.01349700f, -0.02028143f, 0.02134574f, -0.01934016f, -0.01876004f, -0.01662914f, 0.02126580f, 0.01233108f, 
    0.04539673f, 0.02196861f, 0.01947975f, 0.02343960f, 0.03791365f, 0.04988472f, -0.02384047f, -0.01428230f, 
    -0.02699284f, -0.04820342f, 0.03167202f, 0.04082484f, -0.01718630f, 0.01494849f, 0.00533409f, 0.04201618f, 
    0.03150412f, 0.03620756f, -0.04260522f, -0.05614109f, -0.05624874f, -0.01846936f, 0.00864883f, -0.03224575f, 
    0.02090152f, 0.00166611f, 0.00247257f, 0.05046953f, -0.06169920f, -0.03977825f, -0.01414093f, 0.05312223f, 
    -0.00621278f, 0.00748063f, 0.04718066f, 0.03421852f, -0.01087316f, -0.01607116f, -0.00984078f, 0.00678032f, 
    0.04486321f, -0.05194440f, 0.01261268f, -0.00783337f, 0.01074719f, -0.04524074f, -0.03414678f, -0.02116892f, 
    -0.04291514f, -0.04585074f, -0.04899218f, 0.04818675f, -0.02800532f, 0.00919029f, 0.01182588f, 0.02081334f, 
    -0.05965143f, 0.02442768f, -0.04718955f, 0.02375401f, 0.01144205f, -0.04344966f, 0.01538085f, 0.02524214f, 
    -0.01336787f, -0.05839163f, 0.01920874f, -0.00559013f, 0.03426353f, -0.01698728f, 0.00506294f, -0.04487819f, 
    0.02625041f, -0.03933604f, 0.01851202f, -0.05635634f, 0.02104288f, 0.03993215f, -0.01313284f, -0.00748023f, 
    -0.01983404f, -0.00894624f, 0.00358932f, 0.00209394f, -0.04214632f, -0.06379785f, -0.00121594f, -0.05672367f, 
    0.01043497f, -0.00802438f, 0.00251885f, 0.01911400f, 0.04964304f, 0.01734766f, -0.04008084f, -0.01996248f, 
    -0.01818651f, 0.09731147f, -0.35134366f, -0.22278628f, 0.19730473f, 0.13438897f, -0.09032708f, 0.07342040f, 
    -0.02978164f, 0.04760385f, 0.03859445f, 0.09044429f, -0.05911851f, -0.05602119f, -0.05352894f, 0.05887741f, 
    -0.10336331f, -0.03005105f, -0.09728455f, -0.03704364f, 0.36392310f, 0.40096185f, 0.09742224f, -0.00786329f, 
    -0.14733893f, -0.18311967f, -0.11852679f, -0.07128339f, -0.00995964f, -0.10060911f, -0.04492381f, -0.02354560f, 
    -0.01358239f, 0.09046157f, -0.00503237f, -0.03154515f, 0.04982181f, -0.02943197f, -0.03065978f, 0.05658597f, 
    0.23288980f, -0.07470299f, -0.01992971f, 0.05144708f, -0.06562607f, -0.02678011f, 0.03616124f, 0.11326666f, 
    -0.01336024f, 0.12809904f, 0.05815091f, -0.10977075f, -0.12820129f, -0.05777821f, -0.04779769f, 0.09044394f, 
    0.05413992f, -0.02517874f, 0.01987772f, -0.04603945f, 0.25101054f, 0.04948949f, -0.08944856f, -0.09902885f, 
    -0.05512431f, -0.06260917f, 0.09010555f, 0.04039954f, -0.02743834f, 0.11780903f, 0.09831697f, -0.04648102f, 
    0.04919318f, -0.00595804f, 0.00490341f, 0.11516826f, 0.04576679f, -0.07801746f, -0.01447021f, 0.15409103f, 
    0.18834986f, 0.11618574f, 0.00418172f, 0.11060239f, 0.05566786f, -0.08994016f, 0.04562838f, 0.07742188f, 
    -0.09643298f, -0.01482849f, -0.00910147f, 0.09007768f, -0.01628623f, 0.05849428f, 0.05012284f, 0.13615501f, 
    -0.09348047f, 0.10656650f, 0.01802579f, -0.02912546f, -0.14904107f, 0.40320948f, 0.07036611f, 0.12560357f, 
    -0.04698707f, 0.10718715f, -0.06299021f, 0.08712464f, 0.11976007f, -0.11687865f, -0.09791184f, -0.07479589f, 
    -0.04615116f, 0.11521590f, -0.06013375f, -0.08588810f, -0.04181157f, -0.00247158f, -0.11218931f, -0.01447019f, 
    0.10582397f, -0.03273058f, -0.14591345f, -0.02763881f, -0.12945202f, -0.03821539f, 0.04941819f, -0.05532375f, 
    -0.01097115f, 0.01732102f, -0.00529945f, 0.14225259f, 0.01655915f, 0.00657397f, -0.05077153f, -0.10968357f, 
    -0.06574134f, 0.03163910f, -0.13165639f, 0.03508154f, 0.52719772f, -0.18123075f, -0.15226053f, 0.03142521f, 
    0.26411235f, -0.08772837f, 0.05365585f, 0.06568203f, 0.03326635f, 0.11022498f, -0.07098225f, -0.00457949f, 
    0.12129468f, -0.03206823f, -0.03154082f, 0.04085768f, -0.00958647f, 0.12822968f, 0.00282152f, 0.04244922f, 
    0.28820550f, 0.08121651f, -0.14468175f, -0.11400214f, 0.17068923f, -0.00928900f, -0.05333725f, -0.10139611f, 
    0.02735988f, 0.13594125f, 0.02983131f, -0.01756824f, -0.02343497f, -0.06744715f, 0.02663659f, 0.00051353f, 
    -0.01944329f, 0.15521982f, 0.07095608f, -0.10383630f, -0.01615042f, -0.63521016f, 0.28036025f, -0.03945398f, 
    0.29710844f, 0.11562635f, 0.00061433f, 0.13760388f, 0.07786233f, 0.09074938f, 0.00745033f, 0.13545847f, 
    -0.08842009f, -0.09183140f, -0.08181451f, 0.06056476f, -0.05560375f, 0.04001363f, -0.02365377f, -0.07939264f, 
    -0.03185891f, 0.06017033f, 0.18874903f, 0.05796963f, 0.01382224f, -0.05625478f, -0.05875815f, 0.17848729f, 
    -0.01977850f, 0.05979028f, -0.08305892f, 0.07577193f, -0.02743302f, -0.02542220f, 0.03571316f, -0.00879148f, 
    -0.00124901f, 0.06013094f, -0.01058599f, -0.12320518f, 0.49440175f, -0.36159426f, 0.14304236f, -0.07647224f, 
    0.14543842f, 0.00544134f, 0.01487972f, 0.03861080f, 0.17246093f, -0.00004049f, 0.00371729f, 0.07787786f, 
    -0.11527964f, 0.07933919f, -0.06821322f, 0.02764311f, -0.01564091f, 0.01768491f, -0.01448771f, 0.14459519f, 
    0.32613409f, -0.13457799f, 0.01812075f, -0.27244508f, 0.14200816f, 0.01474176f, -0.06185027f, -0.10604043f, 
    -0.09569380f, 0.02078195f, -0.03663111f, 0.01766846f, 0.07358493f, -0.07144166f, -0.06168573f, -0.11486559f, 
    0.04688720f, -0.04851541f, -0.18787353f, 0.04583880f, 0.08594686f, -0.03744411f, -0.00771211f, -0.06215512f, 
    0.03592105f, -0.02522114f, -0.04096042f, -0.05202271f, -0.00856757f, -0.02057747f, 0.15438350f, -0.03227281f, 
    0.05298965f, 0.08475903f, -0.08680502f, -0.01839681f, -0.05093355f, -0.12974876f, 0.00438606f, 0.02307203f, 
    0.08095745f, -0.02512943f, -0.04138099f, -0.20753483f, 0.07157377f, -0.03077311f, -0.01333753f, -0.01394861f, 
    0.05437060f, 0.04556644f, -0.02754814f, -0.07314147f, -0.00231265f, 0.03969005f, -0.03736039f, 0.08264432f, 
    0.03506313f, 0.00075201f, 0.06417565f, 0.12379213f, 0.00101411f, 0.19952141f, -0.32743788f, -0.18108991f, 
    -0.23885961f, 0.10644391f, 0.04526353f, -0.09857085f, 0.01155154f, 0.01096768f, -0.02597886f, 0.02104020f, 
    0.00412914f, 0.00445809f, -0.09817333f, -0.06856047f, -0.00370347f, 0.00980930f, 0.08764737f, -0.08209690f, 
    0.04355439f, -0.04120842f, 0.02959818f, 0.00602104f, -0.05536505f, -0.04590030f, -0.01137618f, 0.04795989f, 
    0.03052282f, 0.00872992f, -0.01954957f, 0.01175896f, 0.01260252f, -0.03906770f, -0.03400686f, 0.03578692f, 
    0.04480821f, -0.00734175f, -0.04321760f, -0.00479178f, -0.00416068f, -0.01942480f, 0.04842639f, -0.03636400f, 
    -0.00757399f, 0.02858339f, 0.04197215f, -0.01738737f, -0.03521918f, -0.03051027f, -0.04274438f, -0.04018730f, 
    -0.05343425f, -0.00493605f, -0.03229247f, -0.01941713f, 0.03591056f, -0.02692565f, -0.00743696f, -0.02882420f, 
    0.03511442f, -0.04437566f, 0.02566195f, -0.01675435f, -0.05325606f, 0.01944466f, -0.00555924f, -0.04455620f, 
    0.01598891f, 0.02179006f, -0.02065301f, -0.04950220f, 0.00590745f, -0.02110457f, 0.02306777f, -0.03113182f, 
    -0.03148039f, -0.00532856f, -0.00010181f, 0.02919197f, -0.04586915f, -0.04731061f, -0.00112132f, -0.04781367f, 
    0.03947366f, -0.04374343f, -0.00322602f, -0.06171051f, -0.01844738f, 0.00644767f, 0.03881094f, -0.00829129f, 
    0.01829529f, -0.02259626f, 0.04378612f, -0.04817895f, 0.02877784f, 0.02284838f, 0.03776562f, -0.01478256f, 
    -0.04429324f, -0.05422445f, -0.04209895f, -0.04937911f, 0.02094742f, 0.04541248f, -0.06070068f, -0.01309690f, 
    -0.04860118f, -0.03114588f, 0.02127385f, -0.05988188f, -0.00697610f, -0.01007215f, 0.01843287f, -0.05668603f, 
    0.01456894f, -0.00453224f, -0.02572947f, -0.05282360f, -0.00967517f, 0.01436960f, -0.03858743f, -0.02250336f, 
    -0.04854978f, 0.03367302f, 0.01165488f, -0.06119832f, 0.01337732f, 0.03075235f, -0.00184939f, -0.03024975f, 
    0.03004318f, -0.04839342f, -0.02509227f, 0.00534685f, -0.01804125f, -0.04660944f, -0.00265051f, -0.01469278f, 
    -0.05258239f, 0.01920051f, -0.01918659f, 0.04674023f, 0.01085324f, -0.01829973f, -0.04303687f, -0.05833779f, 
    -0.04291349f, 0.04636920f, -0.02166602f, -0.05401530f, -0.01675575f, -0.02014023f, 0.02816083f, 0.02811151f, 
    0.02430289f, 0.00447028f, -0.02327675f, -0.03414537f, 0.03924114f, -0.05772462f, -0.04700754f, -0.04281193f, 
    -0.02580247f, -0.00084323f, 0.01563622f, -0.03367036f, -0.02581845f, -0.03479678f, 0.01944938f, 0.01180686f, 
    -0.01942505f, 0.05402690f, -0.02309877f, -0.00110796f, -0.06180504f, 0.04127394f, -0.05577612f, 0.02257463f, 
    0.02743532f, 0.00070814f, -0.05503819f, 0.01972395f, -0.03161014f, -0.04860481f, -0.03089403f, -0.05655797f, 
    0.00842630f, 0.04061420f, -0.00963082f, -0.01754077f, 0.01996209f, -0.00487377f, 0.02543385f, -0.02605080f, 
    -0.05738634f, 0.03399002f, -0.01981891f, -0.01665440f, 0.00538189f, -0.02259461f, -0.04854743f, -0.02193438f, 
    -0.05303955f, -0.00393343f, -0.05567454f, -0.03785036f, -0.01240750f, 0.02327497f, 0.01982694f, 0.00449313f, 
    -0.03397387f, 0.04823812f, -0.02569755f, -0.02637655f, 0.01572340f, 0.02501830f, 0.03662951f, 0.03929837f, 
    -0.02927275f, 0.01942419f, -0.00321905f, 0.01800030f, 0.01249836f, -0.01654721f, 0.03273808f, 0.04379667f, 
    0.00280203f, -0.00309306f, 0.03482512f, 0.01338979f, 0.01718263f, -0.01524108f, 0.04509230f, 0.02741528f, 
    -0.00584693f, 0.03267959f, 0.00059353f, 0.02720760f, 0.00377322f, -0.01761499f, 0.01617965f, -0.02758843f, 
    0.00751417f, -0.02900157f, 0.04162037f, -0.03867021f, -0.04131327f, 0.03761155f, 0.00666330f, -0.04257027f, 
    -0.02962024f, 0.04141944f, -0.04717584f, 0.00143409f, -0.03366821f, 0.03182330f, 0.01155819f, 0.02685553f, 
    0.02364616f, -0.04930878f, -0.05775560f, 0.03707648f, 0.02850004f, -0.02754195f, 0.00800608f, 0.04842724f, 
    -0.03762246f, -0.02942196f, -0.00147104f, -0.05060261f, -0.05417186f, -0.02110724f, -0.01864573f, 0.01246525f, 
    -0.03384892f, 0.02351620f, -0.03968552f, -0.05561263f, 0.03786220f, 0.01216791f, -0.00364825f, 0.00858783f, 
    0.04476438f, -0.04381568f, 0.00587564f, -0.03020456f, -0.04578946f, -0.05132905f, -0.00951407f, 0.03942269f, 
    -0.05722958f, -0.04627435f, -0.04335362f, -0.00417511f, -0.01239027f, -0.03620191f, 0.01981918f, -0.02556700f, 
    -0.02431037f, -0.01047623f, -0.02017983f, -0.00987543f, 0.02860991f, 0.04872527f, 0.01293387f, -0.06075021f, 
    -0.02229051f, -0.04989719f, -0.05851487f, -0.04601234f, -0.02076311f, 0.00506104f, -0.02830098f, -0.00716197f, 
    -0.05036849f, 0.01061092f, -0.03062187f, -0.00254000f, 0.04732278f, -0.01600880f, -0.00327093f, -0.05859881f, 
    -0.03190310f, -0.06026001f, -0.06165041f, -0.01502453f, -0.04880194f, -0.04341692f, 0.03739837f, 0.01501665f, 
    -0.06083421f, -0.05417284f, 0.00208551f, 0.00122176f, 0.01540689f, -0.03491277f, 0.04394308f, -0.04752668f, 
    -0.01380042f, -0.03955014f, 0.01268132f, -0.01137784f, -0.06111893f, -0.03652305f, -0.03261738f, 0.03742760f, 
    -0.00370131f, -0.04015684f, 0.00126995f, -0.02133835f, 0.02828436f, -0.03673550f, -0.01689238f, 0.03510458f, 
    -0.05832066f, 0.04465494f, -0.04389959f, -0.05684336f, -0.04970345f, 0.00062522f, 0.02454689f, -0.02196643f, 
    0.00845696f, -0.01717661f, -0.00152557f, -0.02794597f, -0.04609079f, 0.02385771f, -0.00917666f, -0.04496484f, 
    0.00347926f, -0.01142165f, 0.00327002f, 0.03532342f, -0.01271305f, -0.03777392f, -0.02595526f, -0.05055873f, 
    -0.06060247f, 0.03171051f, 0.00141828f, -0.04133083f, 0.04366079f, 0.00211653f, -0.05123826f, 0.01188332f, 
    -0.06006652f, 0.03204692f, 0.00722351f, 0.04551812f, 0.02975340f, -0.00864541f, -0.02296413f, -0.05247995f, 
    -0.01996420f, -0.00118873f, 0.02182021f, 0.04840585f, 0.02508282f, 0.00006794f, 0.00440427f, 0.03236694f, 
    0.02712001f, -0.01046709f, -0.00659095f, -0.01212887f, 0.02531195f, -0.04639486f, 0.00500215f, 0.02645923f, 
    -0.02009629f, 0.00511615f, -0.06078502f, -0.03372614f, -0.04867032f, -0.02175546f, -0.05060277f, -0.03619959f, 
    0.03242342f, 0.00184014f, 0.02848123f, 0.02913231f, 0.00817979f, 0.02872494f, 0.01531286f, 0.00054085f, 
    -0.03134080f, -0.05083977f, -0.04552333f, -0.03562227f, -0.01197630f, -0.01276224f, -0.03223582f, -0.03537734f, 
    -0.05216013f, 0.01334026f, -0.04507565f, 0.02353350f, 0.00486228f, -0.03470214f, -0.01399347f, -0.00782572f, 
    -0.00845857f, 0.02557584f, 0.02975623f, -0.01044636f, -0.05793607f, 0.01778868f, 0.00576572f, -0.02927636f, 
    -0.04977262f, 0.02908089f, 0.00305680f, -0.01660308f, -0.02474355f, -0.01856271f, 0.04166632f, -0.05769877f, 
    -0.03255121f, 0.01941144f, 0.02750759f, -0.05155209f, -0.00505497f, -0.06077596f, 0.04864559f, 0.04581646f, 
    -0.05931858f, -0.03644028f, 0.01138706f, 0.00969631f, 0.01455340f, -0.05624194f, 0.01080090f, -0.00467769f, 
    0.04165479f, -0.03916398f, -0.04170156f, -0.02017825f, -0.05450843f, -0.03507507f, -0.00873601f, 0.02816485f, 
    -0.03727998f, 0.02339553f, -0.01579497f, 0.00321382f, -0.02384749f, -0.02681169f, 0.01380536f, 0.04794659f, 
    -0.00801600f, 0.01219159f, -0.00506378f, -0.03031227f, 0.01729644f, 0.00697517f, -0.05867164f, -0.00426354f, 
    0.02344861f, 0.02864695f, -0.00719255f, 0.02279638f, -0.01336661f, -0.03829484f, 0.02740342f, 0.03359238f, 
    0.01952719f, 0.01835030f, 0.02803223f, -0.06108291f, 0.02121275f, -0.02313376f, 0.04488860f, -0.05711427f, 
    0.00837641f, 0.04207837f, -0.05861713f, 0.02924822f, 0.03111996f, -0.04678787f, -0.03862433f, -0.01048537f, 
    -0.01270616f, 0.03036980f, -0.05440143f, -0.00352792f, 0.02639077f, -0.04084900f, 0.01921073f, -0.03102703f, 
    -0.00941059f, -0.01481952f, 0.00314017f, 0.00791414f, -0.00939030f, -0.00681938f, 0.01848501f, 0.01335821f, 
    -0.02472739f, -0.05171792f, -0.05698261f, 0.03029643f, -0.05987073f, 0.00728676f, 0.02710137f, 0.03981471f, 
    0.02301014f, 0.04421413f, -0.00015694f, -0.02034589f, -0.02404104f, -0.00309082f, -0.06064257f, 0.00281601f, 
    0.02886226f, 0.03228074f, -0.01789349f, 0.04986268f, -0.04550003f, -0.01496079f, -0.03600745f, -0.01444091f, 
    0.01958020f, -0.00841227f, 0.03811998f, -0.00714487f, 0.01476148f, -0.05429451f, -0.04447919f, -0.03325847f, 
    0.02211271f, 0.04930624f, 0.02248139f, -0.02899479f, 0.01852676f, -0.05634052f, -0.01238225f, -0.05603508f, 
    -0.03064265f, -0.04054124f, 0.04918298f, -0.01546976f, 0.03490875f, -0.03198440f, -0.04765689f, -0.03267517f, 
    0.01202042f, 0.00906842f, -0.03527280f, 0.00802644f, -0.04153046f, -0.04686069f, 0.02558648f, 0.02140361f, 
    0.00274092f, 0.00553892f, -0.05175349f, 0.04312381f, -0.04076748f, -0.01753526f, 0.01310121f, 0.02545530f, 
    0.00525561f, 0.03274594f, 0.01978375f, 0.02924009f, 0.00667618f, 0.01947246f, -0.01700301f, 0.02236501f, 
    -0.05648860f, -0.04461986f, -0.03928993f, 0.02956999f, -0.04084259f, -0.05624164f, -0.01275080f, -0.02752336f, 
    -0.05634059f, 0.01202219f, 0.02989914f, 0.00930753f, -0.05481746f, -0.04979353f, -0.05351678f, -0.01105285f, 
    -0.02990694f, 0.01333398f, -0.00054919f, 0.02192203f, -0.01051188f, -0.06092224f, 0.04389393f, 0.01019638f, 
    -0.01781851f, 0.02728144f, -0.00115055f, -0.05522026f, -0.00354181f, 0.04379616f, -0.05083061f, -0.00435900f, 
    -0.00891896f, -0.05188857f, -0.04159082f, -0.00574828f, 0.00522292f, -0.04960550f, 0.00171713f, -0.02623936f, 
    0.04338339f, 0.03950256f, -0.05665619f, -0.03739518f, -0.00730623f, -0.05480332f, 0.04100099f, -0.03173035f, 
    -0.06096080f, -0.04380275f, -0.00223371f, -0.03252658f, 0.02932554f, -0.05384092f, 0.01469923f, -0.03653615f, 
    -0.00318146f, 0.00927954f, -0.04524666f, 0.03478211f, -0.01889586f, -0.03426062f, -0.03538794f, -0.05542657f, 
    -0.02682136f, -0.04345590f, -0.04589770f, 0.00477441f, -0.02023013f, -0.00444288f, -0.05204633f, -0.03351445f, 
    0.01682495f, 0.02497679f, -0.05340590f, -0.02559168f, -0.01515202f, -0.02231360f, 0.02193224f, -0.01614510f, 
    0.03679409f, -0.00551936f, 0.00443752f, -0.00511990f, 0.02453992f, 0.01080371f, 0.00370182f, 0.03068530f, 
    -0.04992013f, -0.02699142f, -0.06520341f, 0.03934619f, 0.01973869f, 0.00662668f, -0.06157789f, 0.04227266f, 
    -0.04124799f, 0.00697511f, -0.00937488f, -0.00213402f, 0.02535365f, 0.01024515f, 0.04065633f, -0.00057366f, 
    0.05224419f, -0.02440825f, -0.02557996f, -0.03599377f, 0.04584443f, -0.01122904f, 0.02578121f, -0.01467624f, 
    -0.00647680f, 0.03043662f, -0.02376794f, -0.06505644f, -0.05810749f, -0.04510507f, -0.02909616f, 0.00121890f, 
    0.02645025f, -0.03674228f, 0.02506930f, -0.01713215f, -0.03192292f, -0.03284958f, -0.05921865f, -0.03732365f, 
    -0.01389454f, -0.01892126f, -0.04425400f, 0.02810934f, -0.02395279f, -0.03890190f, -0.01129946f, 0.02614370f, 
    -0.05862814f, 0.03197661f, -0.04804264f, 0.02324761f, 0.00119268f, 0.00946364f, -0.02117552f, 0.01077340f, 
    0.03040144f, 0.01000063f, -0.01077392f, 0.04625726f, -0.02569168f, -0.03002196f, -0.05611156f, 0.01865801f, 
    0.02884059f, -0.00935546f, -0.04371474f, 0.03373379f, 0.03093760f, -0.04818385f, -0.00380494f, 0.00132389f, 
    0.01453021f, -0.01122505f, -0.00681730f, -0.04434488f, -0.03242535f, 0.03980713f, 0.03508046f, 0.04039627f, 
    0.02492506f, -0.05324835f, -0.01758844f, -0.05690126f, -0.06111905f, 0.02853201f, 0.03552527f, -0.01382630f, 
    -0.00183488f, -0.04239800f, 0.03820526f, -0.03506503f, -0.01526454f, 0.00964023f, -0.06213177f, -0.00544056f, 
    0.01286659f, -0.00717669f, -0.00386615f, 0.01014738f, -0.01304434f, -0.04037623f, 0.03120375f, 0.03395557f, 
    -0.00042900f, -0.05860874f, -0.03271949f, -0.06629060f, -0.04544304f, 0.00140442f, 0.00141370f, 0.01567690f, 
    0.03604977f, -0.02757151f, -0.03956436f, 0.03013819f, -0.01915251f, -0.00045300f, -0.02396526f, 0.04447682f, 
    0.02682262f, 0.02110093f, 0.02076185f, -0.01651469f, -0.04030738f, 0.03599965f, -0.06530451f, -0.05327752f, 
    0.01855049f, 0.04019420f, -0.01306032f, -0.02918261f, 0.02011247f, -0.00790388f, -0.05842852f, 0.01238915f, 
    -0.01980340f, -0.00520600f, -0.05650888f, -0.03611835f, 0.03662202f, 0.01066345f, 0.03596979f, -0.05666203f, 
    -0.05393091f, -0.05166304f, -0.00730868f, 0.03258720f, -0.04676110f, -0.04025382f, -0.03244473f, 0.02379767f, 
    -0.03216409f, -0.01636393f, 0.04830513f, 0.04681585f, 0.03745816f, 0.04199237f, -0.03692069f, 0.03879710f, 
    -0.05314977f, -0.00398016f, 0.02117904f, -0.05337547f, 0.00374524f, 0.03792704f, 0.03296589f, 0.01512777f, 
    0.03858561f, -0.04304896f, -0.05342167f, -0.00124902f, -0.03443611f, -0.02408824f, -0.05382593f, -0.02170834f, 
    0.02029896f, -0.06236412f, 0.03114280f, 0.03919921f, -0.06757530f, 0.00128924f, 0.03725724f, -0.02741548f, 
    -0.00718184f, -0.05056654f, -0.04534622f, -0.04860053f, -0.04199595f, -0.02770242f, -0.00261240f, -0.01727258f, 
    0.03666035f, -0.04686998f, 0.03167540f, 0.03297988f, -0.05923484f, 0.00682272f, 0.01751180f, -0.04370022f, 
    0.03661021f, 0.02432430f, -0.00860036f, -0.01869877f, -0.04901310f, 0.00243250f, -0.02117445f, -0.06105322f, 
    -0.01360757f, -0.03870625f, -0.03547575f, -0.05361368f, 0.02950986f, 0.03433685f, -0.03401672f, 0.04354428f, 
    0.01858289f, -0.06516184f, -0.00590658f, -0.05124135f, 0.01704895f, -0.00070645f, 0.03329149f, -0.00070929f, 
    0.01352981f, 0.02577825f, 0.03331666f, -0.04143064f, -0.03071214f, -0.04874098f, -0.02249997f, 0.02696748f, 
    -0.02886187f, -0.05398614f, 0.00928682f, 0.01259682f, -0.03595544f, 0.03573341f, -0.05208677f, -0.05841977f, 
    0.02524669f, -0.00404043f, -0.04092646f, -0.02146706f, 0.01698524f, -0.06178391f, -0.05250416f, -0.04225012f, 
    0.02753311f, 0.00597323f, -0.01405061f, 0.01987618f, 0.03651413f, 0.02662750f, 0.00932383f, -0.01343301f, 
    0.01613385f, -0.04786378f, -0.04814455f, -0.05117792f, -0.02012289f, -0.03390484f, -0.00528727f, 0.01458925f, 
    0.00121277f, -0.02771394f, -0.00374510f, 0.03807432f, -0.02878972f, -0.03821619f, 0.03768977f, 0.04862718f, 
    -0.02947176f, 0.04812596f, -0.01673066f, -0.05873099f, 0.02324873f, -0.03803826f, -0.01884620f, 0.00828851f, 
    0.08045103f, 0.01183035f, -0.22516756f, -0.13185430f, 0.29588658f, 0.01835062f, -0.13293757f, -0.09714592f, 
    0.02986809f, 0.01056712f, 0.05662275f, 0.05816533f, 0.13491964f, 0.05745509f, 0.02174217f, 0.11628320f, 
    -0.03284202f, -0.25732100f, 0.04336894f, -0.05024983f, 0.12447525f, 0.03909104f, -0.30410057f, -0.03299830f, 
    0.01445676f, -0.07211289f, 0.03851414f, 0.02900007f, 0.03017478f, 0.00889578f, 0.05358212f, -0.05597205f, 
    -0.12460370f, 0.18415114f, -0.07820643f, 0.02266107f, 0.03217513f, 0.13733073f, -0.04176033f, 0.08539051f, 
    -0.01837000f, 0.00090617f, 0.13747212f, -0.03058881f, -0.17568955f, -0.11854415f, 0.03637046f, 0.15366666f, 
    -0.04580254f, -0.07987289f, -0.01518032f, 0.02712623f, 0.04026046f, -0.01611587f, 0.04966820f, 0.15302393f, 
    0.18885206f, 0.02848061f, 0.02379472f, -0.04234277f, -0.16073845f, 0.22530775f, 0.28489760f, -0.14581230f, 
    -0.04266516f, -0.00533365f, -0.06692576f, 0.11164148f, 0.04093821f, -0.04234279f, 0.01692704f, -0.05662879f, 
    -0.01347087f, 0.10165295f, 0.01628290f, 0.00029465f, -0.05625087f, -0.00558710f, -0.14673983f, -0.00079731f, 
    -0.39054242f, -0.17530057f, 0.00830497f, -0.03344963f, 0.23248883f, 0.17226361f, -0.21975915f, -0.05658867f, 
    -0.08032527f, 0.02017279f, 0.04390240f, 0.07888000f, 0.05395907f, -0.00635985f, 0.18820910f, 0.10065611f, 
    -0.05714747f, 0.04428565f, -0.06352170f, 0.00511721f, 0.16254616f, 0.18915679f, -0.14854451f, -0.16820805f, 
    0.21511978f, -0.08754462f, 0.09676307f, -0.20101190f, -0.03824355f, -0.09847923f, 0.08693937f, 0.02129002f, 
    0.00246902f, 0.15150587f, -0.03454681f, 0.04087092f, 0.01175315f, 0.06404249f, -0.00173316f, 0.02262512f, 
    -0.02561463f, 0.15218422f, 0.18004128f, 0.06617106f, -0.15699716f, 0.06030551f, 0.11754141f, 0.03543475f, 
    -0.02585449f, -0.11065663f, 0.04767467f, -0.01036471f, -0.06329238f, -0.05088091f, -0.06224804f, -0.04239690f, 
    0.03461398f, 0.07302848f, 0.03359439f, 0.13545458f, 0.10027570f, -0.05937285f, 0.18689233f, 0.14957123f, 
    -0.09620634f, -0.09558854f, 0.07397836f, 0.03913935f, 0.05980612f, 0.11924819f, 0.04377181f, 0.06218136f, 
    0.00901940f, 0.01562535f, -0.05247912f, -0.05415571f, -0.08768817f, 0.01810727f, -0.01865667f, 0.04856378f, 
    0.05352983f, -0.12784085f, -0.02143165f, -0.01271996f, 0.05873779f, -0.04148725f, -0.09033540f, -0.15094234f, 
    0.05022706f, 0.03846980f, -0.01296283f, 0.13575482f, 0.00032884f, -0.01634651f, 0.05204130f, 0.01764878f, 
    -0.03330064f, 0.00249966f, -0.12650524f, -0.02446859f, -0.17262262f, -0.19506638f, 0.24885419f, 0.07061969f, 
    0.27780670f, -0.11986841f, 0.03253229f, 0.09082397f, 0.01701255f, 0.07108651f, 0.08817823f, 0.07730778f, 
    0.02767015f, -0.04116701f, 0.02005939f, 0.02252027f, 0.08384953f, -0.10156676f, 0.00953773f, 0.08448358f, 
    0.31265557f, 0.03537270f, -0.01692236f, 0.06335423f, 0.13803887f, -0.13842079f, -0.06831080f, -0.06698588f, 
    -0.10197910f, 0.04354146f, 0.10286127f, 0.07599337f, 0.04503534f, -0.08052506f, -0.06258212f, -0.05258152f, 
    0.12677976f, 0.12807961f, -0.04151295f, 0.11932787f, 0.48872796f, 0.03589326f, -0.04789795f, -0.04803061f, 
    -0.04812563f, -0.21328636f, 0.06119666f, 0.06493197f, -0.00559554f, -0.09938233f, 0.10136972f, 0.13803908f, 
    -0.04084261f, -0.06515051f, -0.14873530f, -0.03163116f, 0.04283465f, 0.04743895f, 0.08381665f, 0.07623930f, 
    0.48988003f, 0.18563153f, 0.21059154f, 0.05320596f, -0.22550891f, -0.05479942f, -0.07072606f, 0.17952038f, 
    0.03268193f, -0.11948221f, 0.01386106f, 0.01217863f, -0.03040763f, 0.00183095f, -0.06504820f, -0.05208886f, 
    0.09598117f, 0.01944370f, -0.08749369f, -0.07963513f, 0.01920298f, -0.02158836f, 0.21761750f, -0.06717423f, 
    -0.10853741f, -0.04868508f, 0.02677215f, -0.04935016f, -0.01628707f, -0.01226079f, 0.07558142f, -0.04050390f, 
    -0.04244154f, -0.01844087f, -0.14657161f, -0.02339138f, 0.06879885f, -0.10879146f, -0.04178863f, -0.01401393f, 
    0.11916398f, -0.13625562f, 0.10956609f, 0.02870674f, -0.11942272f, 0.00694015f, -0.14579986f, 0.03318634f, 
    -0.08113869f, -0.11386458f, -0.02520235f, -0.02088543f, -0.02782161f, 0.05355727f, 0.04547551f, 0.01547047f, 
    -0.08478804f, 0.02336575f, -0.20658198f, 0.02071832f, -0.29376814f, 0.02858086f, -0.08613718f, -0.06146965f, 
    0.07242278f, 0.22234070f, -0.04526588f, -0.14281115f, -0.06557254f, -0.03861006f, 0.05509225f, 0.05193361f, 
    0.03932933f, 0.13274767f, -0.03072521f, 0.05958802f, 0.11644857f, 0.17528659f, -0.01998376f, 0.15658759f, 
    0.15468031f, 0.08320865f, -0.06694040f, 0.31697384f, -0.27405125f, 0.04896677f, 0.07592624f, -0.09623997f, 
    0.03468640f, -0.20203239f, 0.12367747f, 0.10738669f, -0.00914897f, 0.04732140f, 0.05994337f, -0.04683717f, 
    0.04400225f, 0.21974798f, 0.02119284f, 0.13298722f, -0.17876947f, -0.06234777f, -0.02650271f, 0.06124673f, 
    0.07234841f, 0.20100699f, 0.11334208f, -0.04632502f, -0.01152001f, 0.08301038f, 0.23326136f, 0.07985255f, 
    0.06577796f, 0.08695541f, -0.00166268f, 0.06653816f, -0.11229043f, 0.01284096f, 0.06126528f, -0.05972201f, 
    0.20520836f, 0.29679009f, 0.23031886f, -0.17617063f, 0.22216980f, -0.06941230f, -0.01792470f, 0.04159261f, 
    -0.04676840f, -0.15160511f, 0.02143460f, -0.12659802f, -0.03939447f, -0.01184858f, -0.02092521f, -0.07541598f, 
    -0.13440159f, 0.02745877f, 0.01509075f, 0.05420625f, 0.03088927f, 0.07946549f, 0.18992524f, -0.16732804f, 
    0.19436288f, 0.00497822f, 0.04811194f, 0.01213195f, -0.01663522f, -0.02959073f, 0.04559643f, 0.00488289f, 
    0.03462172f, -0.06741293f, -0.09159856f, -0.07184001f, 0.00721418f, 0.00165450f, -0.00711124f, -0.00087119f, 
    0.18327743f, 0.34326965f, -0.16881703f, 0.07236830f, 0.06068488f, 0.06245640f, 0.17285399f, -0.00847025f, 
    0.18839148f, 0.05990694f, 0.04799822f, 0.07073007f, 0.00491221f, 0.03062229f, -0.04818099f, -0.02925329f, 
    0.05853066f, -0.02714903f, 0.06523395f, 0.04255879f, -0.22162677f, -0.09105641f, -0.01300402f, 0.03298075f, 
    -0.20090912f, 0.19130138f, 0.04049672f, 0.07047968f, -0.03716159f, 0.12890866f, 0.04910969f, 0.06087613f, 
    0.00195087f, -0.01574953f, 0.11508857f, -0.06033202f, 0.10183522f, -0.02953388f, 0.02721072f, 0.00893499f, 
    -0.08494700f, -0.22828311f, 0.01567287f, 0.03964763f, 0.38972902f, -0.18806547f, 0.00498050f, -0.03699574f, 
    0.20382726f, 0.08365801f, 0.05602436f, -0.12989582f, 0.08059447f, 0.03215389f, -0.00450838f, -0.08598319f, 
    0.01250907f, -0.03640002f, -0.06092302f, -0.06863546f, 0.04038921f, 0.13243057f, -0.16290943f, -0.03635089f, 
    -0.04868778f, -0.05773608f, -0.04232740f, 0.03503384f, 0.03457292f, -0.13383080f, 0.03807928f, 0.04460225f, 
    -0.03355862f, -0.00598300f, 0.07566147f, 0.10580598f, -0.00832251f, -0.00131783f, 0.10272137f, -0.01441656f, 
    -0.02386071f, 0.26237556f, 0.05207310f, -0.07227379f, -0.06765973f, 0.11034207f, 0.10200674f, 0.01810545f, 
    0.02157340f, -0.04599793f, 0.09444739f, -0.03440002f, -0.02033987f, 0.09314936f, -0.01427278f, 0.08463927f, 
    0.07263087f, -0.01520083f, 0.10236830f, -0.05321926f, 0.07762029f, 0.40553874f, -0.15769765f, -0.16096486f, 
    -0.06008510f, 0.01500048f, -0.00079623f, 0.04800362f, 0.00423482f, -0.10521507f, 0.13920964f, 0.01111635f, 
    0.09514835f, 0.06365645f, -0.12737720f, 0.06094127f, 0.10758671f, 0.10367765f, 0.07814505f, 0.04977944f, 
    -0.31771746f, 0.06469369f, -0.19179049f, -0.18504857f, -0.21772704f, 0.13266012f, 0.05251494f, -0.07845242f, 
    -0.01217061f, 0.07166555f, -0.09475757f, -0.06248325f, 0.11754247f, -0.01280427f, 0.17669821f, -0.06496459f, 
    -0.02486812f, 0.02199895f, 0.04970261f, 0.00963208f, -0.53666145f, -0.18817359f, 0.06606330f, -0.13073151f, 
    0.03048721f, 0.14164324f, -0.13357937f, 0.00377404f, 0.03538613f, 0.03511723f, -0.03911167f, -0.04313918f, 
    0.06753379f, -0.00320344f, 0.09608613f, -0.16597743f, -0.01500298f, -0.06595805f, -0.08647317f, -0.01995932f, 
    -0.20657173f, -0.03076607f, 0.19237453f, -0.02860116f, 0.25493371f, -0.23011172f, -0.09952752f, -0.03027217f, 
    0.03166227f, -0.11046793f, 0.03727635f, -0.03666448f, -0.05899755f, -0.02339123f, 0.00532001f, -0.00701588f, 
    -0.03266647f, -0.11726972f, 0.09079839f, 0.00243264f, -0.17052890f, 0.04228636f, 0.07136416f, -0.03849993f, 
    0.26698470f, 0.19001788f, -0.10830346f, 0.04621735f, 0.11770446f, -0.04270286f, -0.09352488f, 0.05419919f, 
    -0.04639402f, 0.06618270f, 0.15662928f, 0.03871674f, 0.04831688f, 0.00404012f, 0.09199356f, 0.00581461f, 
    -0.06700919f, 0.24608105f, 0.00518674f, -0.24136116f, 0.17147569f, 0.11733403f, -0.05876421f, 0.04341317f, 
    0.03673023f, 0.03163553f, 0.07199942f, 0.03935200f, -0.02153132f, -0.05205193f, -0.00529852f, -0.03179538f, 
    -0.00261459f, 0.07462919f, 0.09149159f, 0.05476332f, 0.05704116f, 0.09048433f, 0.12805994f, 0.00183176f, 
    0.09175637f, -0.05512140f, -0.03441031f, 0.11936706f, 0.06121235f, 0.04337488f, 0.03868576f, 0.05423934f, 
    -0.12391859f, -0.03915374f, 0.04678655f, 0.02849188f, -0.05201311f, -0.06485881f, -0.04923037f, -0.05584539f, 
    0.48904479f, 0.04233481f, 0.20272756f, 0.26288667f, 0.10326383f, -0.03799057f, 0.04723788f, 0.16220260f, 
    -0.04000183f, 0.22742388f, -0.05283874f, -0.04195873f, -0.04120526f, 0.17102619f, 0.06519862f, 0.11780229f, 
    0.00541482f, -0.23217876f, -0.15831801f, -0.00360030f, 0.09392091f, 0.10243333f, -0.03552280f, 0.05634513f, 
    -0.12081019f, -0.19425997f, -0.05298965f, 0.03648223f, 0.07514511f, 0.13132794f, 0.06051313f, 0.03362460f, 
    -0.02969725f, 0.11738792f, 0.11130518f, 0.10410522f, 0.06728394f, 0.06459351f, -0.01638112f, 0.07275990f, 
    0.02647177f, 0.00472080f, -0.22723770f, -0.08564974f, -0.22109260f, -0.00568667f, 0.01887050f, 0.11316757f, 
    0.07495678f, -0.02995778f, 0.05983623f, -0.01413279f, 0.01722263f, -0.05454790f, 0.08812634f, 0.06518960f, 
    0.13227110f, 0.10905850f, -0.03525936f, -0.08868337f, -0.18328997f, 0.16283283f, -0.35730654f, -0.10328764f, 
    -0.16373828f, -0.00506212f, -0.14721774f, 0.11790604f, 0.05866899f, 0.01443385f, 0.05633610f, -0.00592663f, 
    0.01032098f, 0.05232818f, -0.06763638f, 0.01896468f, -0.03208704f, -0.01687467f, -0.09498084f, 0.10800168f, 
    -0.41011530f, -0.09921109f, 0.12359028f, 0.19273683f, 0.21143150f, -0.09875429f, -0.05641105f, 0.14774580f, 
    -0.16182655f, 0.02987312f, -0.07845620f, 0.04830522f, -0.00427724f, 0.03978156f, 0.13112150f, -0.03915816f, 
    -0.01811391f, -0.01899931f, -0.03249357f, -0.02317554f, 0.13554454f, 0.23327999f, 0.01210718f, -0.01589189f, 
    0.15940158f, -0.06062163f, 0.09497543f, -0.05351645f, -0.00063318f, 0.07132142f, 0.01766124f, 0.01205281f, 
    -0.02002880f, 0.12960161f, -0.00072866f, 0.04039846f, -0.03498622f, 0.01189797f, 0.00411242f, 0.10113200f, 
    -0.35410666f, 0.29164222f, -0.07463196f, -0.15599200f, -0.38204223f, 0.09509566f, 0.12851615f, 0.12061403f, 
    0.10929260f, -0.13116682f, 0.02138173f, 0.10380560f, 0.00220560f, -0.05393761f, 0.05005642f, -0.03695250f, 
    0.03842051f, 0.02064331f, -0.03825109f, 0.04735321f, -0.10708703f, 0.12712510f, -0.06420267f, 0.22449175f, 
    -0.19249456f, 0.07565426f, 0.04504491f, 0.01640485f, 0.10991616f, -0.00873270f, 0.00869383f, 0.02087849f, 
    0.02456553f, -0.21490616f, -0.11593392f, -0.01824928f, -0.09396943f, 0.13111821f, -0.09935811f, 0.02064256f, 
    -0.01708425f, 0.05994161f, -0.01449306f, 0.17177124f, 0.08212983f, 0.09543184f, -0.09580277f, -0.02752878f, 
    0.03170158f, 0.14004080f, 0.03635830f, -0.00248453f, 0.11409752f, 0.06212876f, 0.02656137f, -0.11707398f, 
    0.06946359f, -0.00622387f, -0.03755267f, -0.02927108f, -0.08474151f, -0.48658323f, 0.16708729f, 0.24506007f, 
    0.30007198f, 0.14412086f, -0.10740998f, 0.08027568f, 0.01930265f, 0.18395066f, 0.01470803f, 0.10435236f, 
    0.09112434f, 0.09173927f, -0.02066450f, -0.04960630f, 0.06122872f, -0.10861512f, -0.07484097f, -0.03926390f, 
    -0.03365704f, -0.17738362f, 0.06265450f, 0.09181209f, 0.02478117f, -0.09822446f, -0.02431637f, 0.04863198f, 
    -0.00653970f, 0.08880127f, 0.00524168f, -0.06844642f, 0.00478044f, 0.10389439f, 0.01210595f, 0.01035043f, 
    0.07080878f, 0.06555994f, -0.09322973f, 0.10186566f, 0.10630117f, -0.15504827f, 0.03212198f, 0.00416134f, 
    0.00934108f, -0.00746535f, 0.10103131f, -0.01303290f, 0.00314669f, 0.04308517f, 0.00483924f, -0.02520474f, 
    0.03294848f, -0.04669150f, -0.04256400f, -0.00523107f, 0.02329095f, 0.04534112f, 0.02626504f, 0.04359242f, 
    0.32535169f, 0.00742745f, -0.26068097f, -0.09015429f, -0.26675996f, 0.10833093f, -0.05033666f, 0.05904248f, 
    -0.01020260f, -0.08299883f, 0.08548640f, 0.03057492f, 0.18694963f, -0.03293337f, 0.00467856f, 0.02739321f, 
    0.11125514f, -0.03188898f, -0.14794387f, -0.09843718f, 0.15425208f, 0.14230162f, -0.23353404f, -0.11796575f, 
    -0.10821908f, 0.00642565f, -0.04392444f, -0.02635234f, -0.07112157f, -0.01800618f, -0.04716469f, -0.00479388f, 
    0.02292714f, 0.01226603f, -0.06411748f, 0.04705125f, -0.04269493f, -0.06347150f, 0.00596722f, 0.07936329f, 
    0.09774411f, 0.05686463f, 0.10802391f, 0.33915535f, 0.11174397f, 0.12803023f, -0.13092324f, 0.10303097f, 
    0.10430250f, 0.03483316f, -0.03541191f, -0.11234376f, 0.06210032f, 0.06002608f, 0.11617009f, 0.05757925f, 
    -0.06617102f, -0.04420132f, -0.04898636f, 0.00709818f, -0.32614815f, 0.34843934f, -0.21659063f, 0.06508373f, 
    0.04337629f, -0.06254960f, -0.01378470f, -0.02470495f, 0.18148208f, 0.06359098f, 0.09663536f, -0.02417496f, 
    0.12947613f, 0.06754354f, -0.00220010f, -0.02302452f, -0.00067809f, 0.13002224f, -0.05774160f, 0.08474024f, 
    0.02363661f, -0.03413429f, -0.02132298f, -0.03079752f, 0.02679730f, 0.02206763f, -0.05177877f, -0.02447717f, 
    -0.03946975f, 0.03350020f, -0.02407767f, -0.04076389f, -0.03975080f, -0.01048368f, -0.04332469f, 0.03698409f, 
    -0.02959159f, 0.02373882f, -0.03281229f, -0.03877734f, -0.02949878f, -0.00997725f, 0.02593917f, -0.04986646f, 
    -0.00917409f, -0.04464346f, -0.05509370f, 0.03197921f, -0.00033506f, -0.05397271f, 0.05026870f, 0.02674383f, 
    0.02744285f, -0.05254235f, -0.01526451f, 0.00175096f, 0.03270919f, 0.00883348f, 0.04829442f, 0.01624056f, 
    0.03424824f, 0.03139845f, -0.05669571f, -0.02711753f, 0.01134109f, 0.04223435f, -0.05257862f, 0.00245404f, 
    0.03227391f, -0.03303192f, -0.05448366f, -0.03062143f, 0.03372038f, 0.01238526f, 0.03422956f, 0.02201885f, 
    0.03717458f, -0.00575338f, 0.00217043f, -0.02438365f, -0.02187947f, -0.03050378f, 0.01304163f, -0.03058098f, 
    -0.05000934f, 0.04131350f, -0.04590690f, -0.02632372f, 0.01536298f, 0.04743038f, -0.02248444f, -0.05236105f, 
    -0.04674979f, -0.05968729f, -0.04125756f, 0.04672147f, -0.03117058f, -0.05354421f, 0.03018252f, -0.01607825f, 
    0.03567725f, -0.05189800f, -0.00492365f, -0.00292867f, -0.01326631f, 0.01126424f, 0.01236417f, 0.03673802f, 
    0.03247005f, -0.01750995f, 0.00814126f, 0.02620759f, 0.00006653f, -0.04377613f, -0.03048985f, 0.04524181f, 
    0.04355267f, 0.02650846f, -0.02251290f, 0.03388368f, -0.00314603f, -0.05756240f, -0.03706708f, 0.03792428f, 
    0.02804899f, -0.06073587f, -0.05619355f, -0.01688329f, -0.04970400f, -0.01784410f, 0.04816852f, 0.02900787f, 
    -0.01776776f, -0.04055127f, 0.04479929f, -0.04609558f, -0.00629918f, -0.03883056f, -0.02179842f, 0.01380953f, 
    -0.00792624f, -0.00774980f, -0.01536453f, -0.04978593f, -0.04165871f, -0.01611274f, -0.05981754f, 0.01828077f, 
    0.00454615f, 0.00028888f, 0.03628159f, -0.01007694f, -0.02125158f, 0.04583524f, 0.00875347f, 0.00357567f, 
    0.00583735f, 0.02176861f, 0.03642255f, -0.02077677f, -0.04961584f, -0.03788276f, -0.02172905f, 0.01003923f, 
    -0.03875453f, 0.04332396f, -0.02366580f, -0.00243406f, -0.04428926f, 0.04315447f, -0.05934254f, -0.00277637f, 
    -0.02661170f, 0.01910989f, 0.04648671f, 0.03734970f, -0.05204441f, -0.01420445f, 0.01012129f, -0.04656301f, 
    -0.05740757f, -0.05696218f, 0.04149889f, -0.02823102f, -0.01742212f, -0.04946832f, -0.04134676f, 0.01169703f, 
    0.01117899f, 0.01062105f, 0.00982642f, -0.04565462f, -0.03007124f, -0.00314856f, 0.02865530f, 0.00957126f, 
    0.00718823f, 0.03411035f, 0.00784429f, -0.02879093f, -0.01912920f, 0.04505017f, 0.01590985f, -0.03476275f, 
    -0.02736894f, -0.04754771f, -0.05043888f, 0.00508864f, -0.05454315f, 0.00760769f, 0.00461780f, 0.00662537f, 
    -0.05869580f, 0.00433140f, -0.05865724f, -0.01911825f, 0.02647972f, -0.01482927f, -0.02095433f, -0.01693890f, 
    0.01908296f, -0.02295740f, -0.01906863f, -0.01130905f, -0.03277145f, 0.02592539f, -0.00735312f, 0.00392389f, 
    0.04084740f, -0.06000514f, 0.00570041f, -0.05842036f, -0.05439542f, -0.00915018f, -0.06005839f, -0.00334735f, 
    0.04877856f, 0.00275256f, -0.00653367f, 0.01421055f, 0.03928052f, 0.00095721f, -0.02663204f, -0.00243567f, 
    -0.02888402f, -0.04353610f, -0.00080513f, -0.04143244f, 0.03327961f, -0.04667183f, 0.00940968f, 0.02073718f, 
    -0.00696095f, -0.04134508f, -0.04417827f, -0.03302509f, -0.05632017f, -0.02534095f, 0.03072198f, 0.01878246f, 
    -0.04490501f, 0.04774967f, 0.01422454f, -0.05220975f, -0.01144187f, -0.03035303f, 0.00578189f, 0.00920708f, 
    -0.05817110f, -0.02798292f, -0.02591134f, 0.00112830f, -0.02501300f, -0.01577604f, -0.02418795f, -0.03513186f, 
    -0.02948476f, -0.00859850f, 0.03106053f, 0.02875515f, 0.02137146f, -0.05407127f, -0.00387320f, 0.01938918f, 
    -0.03322352f, 0.00592071f, 0.03096439f, 0.00915846f, 0.00237691f, 0.00644928f, -0.04274584f, 0.04107543f, 
    0.04501136f, 0.04568618f, -0.05702018f, 0.02832422f, -0.02121335f, -0.05300845f, -0.01775512f, 0.02350268f, 
    0.00449750f, 0.00517144f, 0.03702078f, 0.00110802f, 0.03591238f, -0.04030420f, -0.03332886f, -0.03615954f, 
    -0.05308626f, -0.05166775f, -0.00119821f, 0.04444008f, -0.00594779f, -0.04739569f, 0.02708586f, -0.02930314f, 
    -0.05326357f, -0.03871392f, -0.00590235f, 0.04277427f, -0.04780526f, -0.00519559f, -0.06087954f, -0.05251138f, 
    -0.05873246f, -0.02777177f, -0.00665505f, -0.01520366f, 0.04352757f, -0.01825340f, -0.01961690f, -0.03633523f, 
    -0.00417570f, -0.04579008f, 0.02048088f, -0.05831782f, 0.00309659f, 0.03579462f, -0.05521165f, -0.03937354f, 
    0.14813285f, 0.06426189f, -0.06483792f, -0.29628965f, -0.00467832f, -0.00345497f, 0.18417636f, 0.11077265f, 
    0.02419122f, 0.01178744f, 0.06765597f, -0.03726700f, -0.06084068f, -0.06117240f, -0.04405120f, 0.03730039f, 
    0.04101372f, 0.19040278f, 0.02549479f, 0.04367438f, 0.56576139f, 0.08013105f, -0.03635276f, -0.06046832f, 
    0.02152795f, 0.00969492f, 0.01177608f, -0.02391155f, 0.06503714f, -0.04368120f, 0.01768867f, 0.01714414f, 
    0.01743094f, -0.12112951f, 0.03167929f, 0.07346895f, 0.02378400f, -0.00365305f, 0.13593869f, -0.01852764f, 
    0.04057856f, -0.15710764f, -0.04063757f, -0.02295448f, -0.08801170f, 0.05659153f, 0.01150679f, -0.05698991f, 
    0.05595526f, 0.12094857f, -0.04234860f, 0.08189167f, -0.03583256f, 0.11237333f, -0.03220480f, -0.10747912f, 
    -0.04686130f, -0.02333580f, -0.01079298f, -0.01627964f, -0.07256594f, 0.11766557f, -0.20231377f, 0.15839644f, 
    -0.22127999f, -0.11204691f, -0.09278639f, 0.00764436f, -0.06030158f, 0.00701870f, 0.03644734f, -0.05417205f, 
    -0.05216257f, 0.01876824f, 0.16517363f, 0.03301291f, -0.05698191f, 0.01141123f, 0.03509302f, 0.07686539f, 
    0.27323592f, -0.01781499f, 0.12207363f, -0.06393860f, 0.09061915f, -0.20621105f, 0.10743576f, 0.03709223f, 
    0.01370731f, -0.05454573f, 0.14481038f, -0.12895244f, 0.03134923f, 0.13060245f, 0.10965414f, -0.00911283f, 
    -0.00464498f, 0.02392144f, -0.11924107f, 0.04330461f, 0.23891504f, 0.09684929f, -0.17162398f, 0.05082709f, 
    0.16448739f, 0.00080432f, 0.04242611f, -0.00738449f, 0.15440282f, -0.03559538f, -0.01114651f, 0.02017500f, 
    0.10524549f, -0.00693512f, 0.03200855f, 0.02447769f, 0.00635226f, -0.02970114f, -0.02924797f, 0.05780907f, 
    -0.04951897f, 0.00836229f, 0.08818294f, 0.04293475f, -0.09911532f, 0.12119718f, -0.00696732f, -0.02351703f, 
    0.01275071f, 0.12841080f, -0.01375882f, 0.04594968f, -0.00639195f, -0.00268958f, 0.02581281f, -0.04885028f, 
    -0.03814727f, 0.00246540f, 0.00555291f, -0.01239080f, 0.00311045f, -0.18131302f, -0.00419989f, 0.05850253f, 
    0.11748405f, -0.05371880f, -0.13739894f, 0.03574264f, -0.03186803f, 0.07552458f, 0.03449465f, -0.05365589f, 
    0.09361126f, 0.02551370f, 0.09033630f, 0.07568012f, -0.02394803f, 0.03515393f, 0.06833596f, -0.01925481f, 
    -0.02941770f, -0.03060799f, -0.10516719f, -0.03716397f, 0.02229518f, 0.03340344f, -0.01888792f, 0.04034394f, 
    0.07490331f, -0.05861827f, -0.04285789f, 0.05782327f, -0.14029963f, -0.05980233f, -0.07521369f, -0.08178221f, 
    -0.06507162f, 0.07003687f, 0.03315315f, -0.02040307f, -0.18436350f, 0.04890722f, 0.01960623f, 0.05994752f, 
    -0.16012153f, 0.15508187f, -0.04409594f, 0.02105845f, -0.00272152f, 0.06053292f, -0.07660270f, 0.04845681f, 
    -0.06178499f, 0.05818789f, 0.13859567f, 0.07895745f, -0.06367830f, 0.03973775f, 0.01420627f, 0.01719835f, 
    0.11886362f, -0.07739699f, 0.08396304f, 0.03707506f, -0.00436092f, 0.04372988f, 0.05191625f, 0.13733162f, 
    0.00623952f, 0.02440807f, -0.08636580f, 0.04742951f, 0.00583688f, -0.05426954f, -0.11555145f, 0.05338430f, 
    0.15191431f, 0.07127558f, 0.00090839f, -0.07602536f, 0.17629188f, 0.11097847f, -0.22217380f, -0.02521614f, 
    -0.02877657f, 0.06239953f, 0.01890802f, 0.03798876f, 0.07036506f, 0.08194257f, -0.12090936f, 0.06068994f, 
    0.03263120f, 0.07678539f, -0.04282732f, 0.13833942f, 0.00930880f, 0.02054390f, -0.03621716f, 0.01083589f, 
    0.09598798f, -0.40203360f, 0.03016030f, -0.01010078f, -0.12853388f, 0.13296753f, -0.01625135f, -0.01807143f, 
    0.04708874f, 0.03090804f, -0.01546820f, -0.05064580f, -0.11374634f, 0.15508702f, 0.02474723f, 0.05222292f, 
    -0.03581246f, -0.03030126f, -0.05806028f, 0.03696981f, 0.02671414f, 0.03405974f, -0.21202183f, 0.11524339f, 
    -0.26484939f, -0.05713507f, 0.02222095f, 0.01077901f, -0.00211854f, 0.04176793f, 0.00788736f, -0.03310434f, 
    0.15275097f, -0.02510069f, 0.05341919f, 0.10184993f, -0.02686563f, 0.14294879f, -0.04341330f, 0.04698064f, 
    -0.17011504f, -0.15430892f, 0.01971179f, -0.00304363f, -0.09455000f, -0.11168170f, 0.09136541f, 0.08227644f, 
    -0.00120205f, -0.03250154f, 0.10794446f, -0.00611306f, -0.05945448f, 0.04735925f, 0.00666746f, 0.04689740f, 
    0.14668579f, -0.00681160f, 0.10565991f, 0.06626520f, -0.16943797f, 0.08681123f, 0.12464099f, 0.15231051f, 
    0.17734714f, 0.01057584f, 0.09401502f, -0.00227403f, 0.04965621f, -0.07040193f, -0.04261686f, 0.07847340f, 
    0.18608555f, -0.00184947f, 0.03159823f, 0.11829396f, -0.00939353f, -0.11590144f, 0.15716058f, 0.00156906f, 
    -0.08230202f, -0.07989784f, 0.07239577f, 0.03915254f, -0.04518956f, 0.03771813f, -0.07862277f, 0.07068331f, 
    -0.01879212f, 0.08096533f, -0.10571376f, -0.03181065f, 0.04958794f, 0.06673077f, 0.13332438f, 0.00237965f, 
    -0.02670144f, -0.36967266f, -0.08090135f, -0.11350632f, -0.44230515f, 0.12228250f, 0.14614430f, 0.24648577f, 
    -0.05480954f, 0.02654992f, 0.04568591f, -0.03391631f, 0.00046566f, 0.06667750f, 0.00443914f, 0.02415634f, 
    -0.01054655f, 0.14657116f, -0.05975348f, -0.09877427f, 0.16144672f, 0.00533112f, -0.14633164f, -0.02027044f, 
    -0.12438062f, 0.30628347f, -0.13479738f, 0.02039082f, -0.00289239f, 0.12096210f, -0.06742832f, 0.07237163f, 
    -0.03155989f, 0.08669715f, -0.00584583f, -0.02715134f, -0.01089467f, -0.03624090f, -0.08087373f, 0.08820356f, 
    0.19649561f, 0.03619389f, 0.06744663f, 0.11273482f, 0.13441625f, -0.10816062f, 0.22664507f, -0.03987449f, 
    0.13911061f, 0.07426100f, 0.08259719f, 0.12870094f, 0.17438267f, 0.12933296f, -0.06608942f, 0.01581720f, 
    0.04357635f, 0.02393420f, -0.01293216f, -0.00348044f, 0.09611965f, 0.08276899f, -0.10152758f, 0.01007099f, 
    -0.21919982f, -0.06146838f, -0.02810330f, -0.12203141f, 0.08589074f, 0.15059170f, -0.07555672f, -0.05222363f, 
    -0.01176303f, 0.15476252f, -0.02115791f, 0.09300237f, 0.03900721f, -0.09763365f, 0.04684478f, 0.07887353f, 
    -0.02489564f, 0.00402010f, -0.00878017f, -0.10722646f, -0.00732092f, -0.08752847f, 0.17234424f, 0.13081795f, 
    -0.03273794f, 0.06391378f, 0.01459750f, -0.02543010f, -0.12750094f, 0.03030458f, 0.10267289f, -0.08723564f, 
    -0.10156974f, 0.23002398f, -0.00081676f, 0.05382188f, -0.01229719f, 0.02869514f, 0.09080717f, -0.09624207f, 
    0.14773682f, -0.07804517f, -0.27252659f, 0.02274983f, -0.10026897f, -0.02269482f, -0.01418364f, 0.01810747f, 
    -0.04442510f, 0.01658092f, -0.08280712f, 0.11997197f, -0.00490709f, 0.02655054f, 0.04713904f, 0.10542475f, 
    0.03613715f, 0.13825655f, 0.02155710f, 0.05109550f, -0.21766596f, 0.01362023f, -0.28650850f, -0.00449436f, 
    0.08302396f, 0.06386146f, 0.04898243f, -0.05776466f, -0.03765399f, 0.04840750f, 0.09321724f, -0.02170087f, 
    -0.01431756f, -0.03658179f, 0.03030365f, 0.00752309f, 0.05663837f, 0.01180588f, 0.01205103f, 0.06668838f, 
    0.00912730f, 0.12438453f, 0.01432093f, 0.11793745f, -0.01030365f, 0.02220569f, 0.07646840f, 0.01021349f, 
    -0.05103105f, 0.09310709f, 0.03819082f, -0.14923783f, 0.04643245f, 0.00140366f, 0.12929870f, 0.07051716f, 
    0.11285266f, -0.10773090f, -0.11508792f, 0.13693297f, 0.15686092f, -0.38445786f, -0.05399156f, -0.05103205f, 
    0.11636433f, -0.02005565f, 0.02520945f, -0.07210800f, 0.08268671f, -0.10439417f, 0.02353144f, -0.16614275f, 
    0.00782603f, -0.02913057f, 0.04732376f, 0.01675118f, 0.00397572f, -0.09501334f, -0.01055154f, 0.02295522f, 
    0.12943058f, 0.22427867f, 0.03055623f, 0.14703773f, 0.16649668f, 0.01198229f, 0.04242523f, -0.17122234f, 
    -0.08628860f, -0.04522396f, 0.07246005f, -0.07570770f, 0.09227849f, 0.12798685f, 0.09578060f, 0.03684374f, 
    -0.00213598f, 0.02553118f, -0.00679511f, 0.03980972f, 0.34817508f, -0.14424089f, 0.08228774f, 0.03460807f, 
    0.11604387f, 0.02025090f, 0.04659590f, -0.12539980f, -0.10558619f, -0.11722220f, 0.14566791f, 0.05860430f, 
    -0.00774656f, 0.04996400f, -0.06928782f, 0.03731758f, 0.12891696f, 0.01444141f, 0.11341710f, 0.04863933f, 
    -0.04890629f, 0.35662696f, -0.23540793f, -0.19444436f, -0.02369089f, -0.05040792f, 0.03928110f, 0.07303142f, 
    -0.11925104f, 0.07515125f, 0.00736456f, 0.10001563f, 0.11983769f, -0.11135212f, -0.00818511f, -0.03768394f, 
    0.07661780f, -0.01301135f, 0.05724995f, -0.12367205f, -0.13786484f, -0.10145950f, 0.15527077f, -0.21520209f, 
    0.18647058f, 0.06383521f, 0.02139390f, 0.06623777f, 0.03183343f, 0.04656566f, 0.00712200f, 0.01472753f, 
    -0.00591933f, -0.00899610f, 0.05649720f, -0.07908912f, 0.05900586f, -0.05304410f, 0.04471529f, 0.01820070f, 
    0.07948890f, 0.21228324f, 0.22881334f, 0.03819317f, -0.05016721f, 0.08153019f, 0.02480949f, -0.05566615f, 
    0.05913054f, 0.01890554f, -0.07701168f, 0.02233926f, 0.17358543f, -0.00469390f, -0.03424755f, -0.06738537f, 
    -0.09006528f, -0.03042315f, -0.08967052f, 0.04437511f, 0.13025035f, -0.02188477f, -0.05552532f, -0.25264415f, 
    -0.14603247f, 0.06007141f, 0.07832955f, -0.05981129f, -0.15557058f, 0.05197233f, -0.07142702f, 0.01544739f, 
    -0.03449857f, 0.05337390f, 0.07560358f, 0.04443876f, -0.04788971f, 0.23052885f, -0.11687934f, -0.07223731f, 
    0.26738551f, 0.02510268f, 0.14937817f, -0.10775382f, 0.17216694f, -0.01242709f, 0.18335466f, 0.07283864f, 
    0.14086644f, 0.09053944f, 0.02759662f, 0.13648462f, 0.01179038f, -0.01513482f, -0.09716859f, 0.02215498f, 
    0.01437050f, 0.11349680f, 0.12766649f, -0.04008805f, 0.03817056f, -0.22034755f, -0.28964758f, -0.27412552f, 
    -0.28016588f, -0.03524716f, -0.09296608f, 0.03256629f, 0.07380828f, 0.04097947f, -0.03677935f, 0.09774140f, 
    -0.00063949f, -0.03565855f, 0.01975284f, -0.04774244f, -0.01226944f, 0.05562993f, 0.12736343f, 0.08632126f, 
    0.35742903f, 0.06223215f, -0.18413220f, 0.10931126f, -0.16826968f, 0.03543654f, -0.09872452f, -0.08138776f, 
    -0.00346903f, 0.05066040f, -0.06475025f, 0.03735979f, 0.06516740f, 0.02441149f, 0.03465702f, -0.05581380f, 
    -0.02611710f, 0.01777598f, -0.06477405f, -0.07088831f, 0.03776703f, 0.10110641f, -0.02847027f, 0.09508597f, 
    -0.18604417f, -0.13098204f, -0.14941701f, 0.03000924f, -0.02266106f, -0.05714304f, 0.02223892f, -0.01691868f, 
    -0.04342909f, -0.03043042f, 0.18226282f, 0.04792550f, 0.00049802f, -0.05518116f, 0.06431762f, 0.02116776f, 
    -0.05605885f, -0.16398020f, -0.01635066f, -0.08533145f, 0.34683168f, 0.00450059f, -0.12996110f, -0.01931354f, 
    0.07354332f, 0.03026525f, 0.06381910f, -0.12085748f, -0.00972178f, 0.06687418f, 0.00276409f, 0.04529170f, 
    -0.00957935f, 0.09081850f, -0.14215040f, -0.00954999f, -0.21637703f, -0.17097288f, -0.12902030f, -0.07638007f, 
    0.01828385f, -0.06972654f, 0.03131767f, -0.12770393f, 0.06899314f, -0.10769422f, 0.04375852f, -0.00017147f, 
    0.02970715f, 0.00427374f, 0.09758592f, 0.03092673f, 0.08862454f, -0.11018160f, -0.08710019f, 0.11049619f, 
    0.26148829f, 0.08587044f, 0.16807278f, -0.01919842f, -0.18435627f, 0.16559140f, 0.03256133f, -0.01320792f, 
    0.05632662f, 0.05502343f, -0.04896616f, 0.09800275f, 0.01677297f, -0.05149848f, -0.03572559f, -0.00974272f, 
    0.05497163f, 0.01271920f, -0.02004218f, 0.02047557f, -0.08482175f, 0.10674427f, 0.31247285f, 0.21844360f, 
    0.13990630f, -0.06584619f, -0.02011700f, -0.01564775f, 0.14128341f, 0.09569349f, -0.00952317f, 0.02672930f, 
    0.06941933f, 0.02453562f, 0.01884300f, 0.02219802f, 0.00640329f, 0.02237822f, -0.04664562f, 0.11481370f, 
    0.06207988f, -0.04856017f, 0.00323145f, 0.03364444f, 0.26490635f, 0.00780912f, -0.06461375f, 0.07057634f, 
    0.10990650f, 0.01377848f, -0.08729859f, 0.17482813f, -0.13782248f, -0.05514204f, 0.01891407f, 0.09307218f, 
    -0.03195717f, 0.22096919f, -0.01999271f, 0.01760467f, -0.27559823f, 0.10444709f, 0.11359036f, 0.20297806f, 
    0.14139490f, 0.04191224f, 0.13251424f, 0.03810024f, -0.02156643f, 0.11602987f, -0.09907098f, 0.13069956f, 
    0.05018334f, -0.01040015f, 0.10902843f, 0.05962054f, 0.03888251f, 0.10081469f, -0.04985587f, 0.04736277f, 
    -0.18117511f, -0.43286753f, -0.12374444f, -0.05997135f, -0.23869576f, -0.09748518f, 0.02000721f, 0.11325883f, 
    -0.02832873f, -0.05160321f, 0.07183426f, -0.05521489f, -0.01044357f, -0.06557285f, -0.14636238f, 0.05387864f, 
    0.07378555f, 0.00948888f, -0.00312582f, 0.06560465f, 0.05840135f, 0.06266513f, -0.33234799f, 0.00888141f, 
    -0.22964050f, -0.07159010f, 0.10434369f, 0.02170935f, 0.07484764f, 0.11820699f, -0.06570268f, 0.03922056f, 
    0.14779687f, -0.04501421f, -0.01320101f, 0.04077068f, -0.03624478f, 0.05535448f, -0.01875326f, 0.07180410f, 
    0.38944101f, -0.06494540f, -0.08435446f, 0.17079635f, -0.10259262f, 0.07482769f, -0.03840236f, 0.08889041f, 
    0.10421675f, -0.07453442f, -0.01049597f, -0.06863323f, -0.04246885f, 0.17180495f, -0.00143783f, 0.09544559f, 
    -0.08052851f, 0.16032910f, -0.10061934f, 0.02450558f, 0.32643327f, -0.02396531f, -0.08432089f, 0.00995838f, 
    -0.15121144f, -0.11035725f, 0.03005894f, -0.00955972f, -0.00355899f, -0.00253354f, -0.04954519f, -0.07454484f, 
    0.16390818f, 0.07632197f, -0.03449684f, 0.13268594f, -0.01966605f, -0.03404992f, -0.06865302f, 0.08732973f, 
    0.10945731f, 0.02298067f, 0.04407353f, 0.07475579f, -0.13932259f, -0.06431715f, -0.01053565f, 0.05643646f, 
    -0.00957979f, 0.00672289f, 0.03103737f, -0.04186429f, -0.07207645f, -0.05938952f, -0.09782992f, 0.06668889f, 
    0.08027996f, -0.06304102f, 0.06794967f, 0.08656585f, -0.41512516f, 0.10237484f, 0.23858574f, 0.07422785f, 
    0.24063671f, 0.17257865f, -0.00543036f, 0.08931716f, 0.06994494f, 0.00497946f, 0.06605499f, 0.03342345f, 
    0.10747340f, 0.04193741f, 0.02053935f, 0.07101020f, 0.04283347f, -0.02878743f, 0.04881736f, 0.02606834f, 
    0.34052420f, 0.03261744f, 0.14047737f, 0.16156818f, -0.01394218f, 0.07560197f, -0.00618620f, 0.01797045f, 
    -0.01856778f, 0.01187229f, 0.02289310f, 0.12996465f, 0.05590963f, 0.09131319f, 0.12958585f, 0.09060972f, 
    -0.06507732f, -0.23442724f, 0.00901672f, -0.02535016f, -0.08056366f, 0.26087630f, -0.08313700f, 0.08328541f, 
    -0.11890615f, -0.06128542f, -0.02553905f, -0.02321733f, 0.03650050f, 0.10417745f, 0.16856740f, 0.06463888f, 
    -0.00855176f, 0.11116590f, -0.11537165f, 0.09021864f, 0.14421418f, 0.15272185f, -0.05650382f, -0.02741585f, 
    -0.08833293f, 0.09003792f, -0.09067158f, -0.12934913f, -0.19084881f, 0.10213435f, 0.00929885f, 0.15248013f, 
    -0.01579578f, -0.01533541f, 0.04426230f, -0.02877395f, -0.09873564f, 0.01206923f, -0.09603146f, 0.11463796f, 
    0.07276843f, 0.03669120f, -0.00588668f, 0.04227757f, -0.37368825f, 0.00809169f, 0.03002464f, -0.22623679f, 
    0.01127357f, 0.05631942f, -0.03194993f, 0.17929427f, 0.14627372f, -0.03334751f, -0.01025768f, -0.07623754f, 
    0.05118019f, 0.08700427f, 0.01462538f, 0.04095619f, -0.00970851f, -0.06075615f, -0.06406251f, 0.10466183f, 
    -0.20767772f, 0.04568664f, 0.00240826f, -0.02765604f, 0.35491249f, -0.05834391f, -0.06038038f, -0.03581960f, 
    -0.12499579f, 0.10491423f, 0.06249343f, 0.05185401f, 0.03865464f, -0.00631640f, 0.04271732f, 0.01087607f, 
    0.03116589f, 0.03346770f, 0.00784923f, -0.03211332f, -0.03077134f, 0.21218091f, 0.00527782f, 0.20038369f, 
    0.11648154f, 0.03761706f, 0.03343800f, -0.07820583f, 0.04495827f, -0.01403217f, 0.12104946f, 0.03342619f, 
    0.00599633f, 0.24027996f, 0.01607289f, 0.03702081f, 0.05219920f, 0.02193128f, 0.13277057f, -0.02657798f, 
    -0.17602418f, -0.18609028f, -0.02135252f, -0.03033008f, -0.16691749f, -0.05251886f, 0.14563942f, 0.03609567f, 
    0.06769945f, 0.06312334f, -0.01655593f, -0.01571947f, 0.03194250f, -0.00596993f, 0.04251290f, 0.09682257f, 
    0.01339177f, 0.07386997f, -0.04995559f, -0.00541058f, -0.04083297f, -0.17725965f, -0.15469395f, 0.05951820f, 
    -0.08424155f, -0.02876444f, 0.09891006f, 0.00781335f, -0.08105545f, -0.03058636f, 0.07337730f, 0.07087112f, 
    0.10543101f, -0.06840024f, 0.02774826f, 0.01072369f, -0.02373284f, 0.05960458f, -0.08076264f, -0.01702434f, 
    -0.07514389f, 0.14983140f, 0.05810988f, -0.01723992f, 0.08259340f, -0.00861038f, 0.03507252f, 0.05106195f, 
    0.00254780f, -0.02284711f, 0.05544409f, -0.05134443f, -0.00346304f, 0.02189418f, 0.13927014f, 0.03478382f, 
    0.06863004f, -0.03682556f, -0.03491167f, 0.08947007f, -0.26920825f, -0.36720607f, 0.08762145f, -0.02739339f, 
    0.29332113f, -0.04559804f, 0.05019549f, 0.00412003f, 0.05392818f, -0.01382040f, 0.12868360f, 0.00736376f, 
    0.12600535f, 0.04857955f, -0.01292337f, 0.04679663f, 0.04876954f, -0.00677839f, 0.07493231f, 0.11247279f, 
    0.12076221f, 0.21918532f, -0.01596772f, 0.13181870f, -0.00535101f, -0.05603318f, 0.04784359f, -0.20270614f, 
    -0.13582794f, 0.01453576f, -0.05948005f, -0.13600646f, 0.03566164f, -0.04993560f, 0.11946905f, -0.00545938f, 
    0.06568685f, 0.11564905f, -0.02533696f, 0.06550164f, 0.29984820f, -0.17270438f, 0.09673822f, -0.06624576f, 
    0.11783183f, 0.06710730f, 0.03033461f, -0.14766827f, -0.05692183f, -0.03875985f, 0.08839244f, -0.05966471f, 
    0.06929156f, 0.02388889f, -0.05757489f, -0.00659988f, 0.03587018f, 0.08029403f, 0.06452683f, 0.02661129f, 
    0.09676622f, -0.04213671f, -0.08454807f, -0.26825956f, -0.13105239f, -0.01584376f, -0.16529278f, 0.13991398f, 
    -0.12157076f, -0.14488873f, -0.01788040f, 0.04635014f, 0.00552720f, -0.00714692f, -0.02134341f, -0.13016248f, 
    0.01557786f, -0.07811789f, -0.10178497f, -0.14424406f, -0.17090726f, -0.05257102f, 0.07056832f, -0.29014158f, 
    0.13066523f, 0.09279976f, -0.00327492f, 0.01203043f, -0.01412460f, -0.03485735f, 0.00514514f, 0.01190613f, 
    -0.06723680f, 0.08915548f, -0.02097636f, -0.03061724f, 0.05083013f, -0.03161016f, 0.01367815f, 0.04482264f, 
    0.03320705f, 0.15307681f, 0.10312366f, -0.05145580f, -0.06067804f, 0.08286313f, -0.06476665f, 0.05735644f, 
    -0.02346293f, 0.11140831f, -0.02529781f, -0.00354971f, 0.02778038f, -0.01927447f, 0.09776935f, 0.08398959f, 
    0.00206846f, -0.04898422f, -0.03535210f, 0.08886999f, -0.27957755f, 0.13382913f, 0.01248445f, -0.23512073f, 
    0.08493770f, 0.11380321f, 0.00766391f, -0.00527715f, 0.05410838f, 0.11034896f, -0.05926797f, 0.04218128f, 
    0.04478758f, 0.07093794f, -0.00376564f, 0.02399791f, -0.01058764f, 0.13122027f, -0.01784690f, 0.00421547f, 
    0.02473337f, 0.03749921f, 0.01331804f, 0.00078183f, -0.05021330f, 0.01413546f, -0.03242212f, 0.01251991f, 
    -0.03145392f, -0.04809547f, -0.00215753f, 0.02691052f, -0.00470329f, -0.05715013f, -0.04630626f, -0.00177840f, 
    -0.00056599f, 0.03932975f, -0.01260494f, -0.01469098f, -0.01625124f, -0.03772230f, -0.01227460f, -0.01153821f, 
    -0.02037226f, -0.03351285f, -0.01818632f, 0.03851165f, -0.05801167f, 0.02816904f, -0.03277440f, -0.01992331f, 
    -0.05871970f, 0.00525390f, -0.00863944f, -0.02074133f, -0.04012604f, -0.00278258f, -0.02894331f, 0.02758888f, 
    -0.06366953f, -0.01954870f, -0.05985793f, 0.03683484f, -0.03316539f, -0.02223973f, 0.01411943f, -0.04564626f, 
    -0.04818528f, -0.01636351f, 0.02444838f, 0.03707788f, -0.04878327f, 0.01138919f, -0.00376755f, -0.04608425f, 
    -0.02336890f, 0.01738553f, 0.04701762f, -0.03259745f, -0.01842727f, 0.00466427f, -0.03772527f, -0.02890038f, 
    -0.06437117f, 0.03042284f, -0.04561561f, 0.00627270f, -0.06001180f, -0.02302440f, 0.02503586f, -0.05573647f, 
    -0.01395637f, -0.00846345f, -0.02002654f, 0.02458769f, 0.04001479f, 0.04870102f, -0.04800534f, -0.03000144f, 
    0.01713256f, 0.01624070f, 0.00052432f, 0.03020528f, -0.04624757f, 0.04079070f, -0.02507930f, -0.05934893f, 
    0.01526752f, 0.00061656f, -0.03275903f, -0.03939193f, 0.00733883f, 0.03338111f, 0.02264464f, -0.05073177f, 
    -0.01331536f, -0.02190521f, -0.03738102f, -0.01987600f, 0.00672313f, -0.00417359f, 0.04595437f, -0.04835230f, 
    -0.03436919f, 0.04835198f, -0.02845210f, 0.04980490f, 0.00697064f, -0.06565391f, -0.04627126f, -0.02207652f, 
    -0.00846084f, -0.01844440f, -0.05774787f, -0.06086389f, 0.01785830f, 0.01635186f, 0.02406265f, -0.02850280f, 
    -0.04579509f, 0.01956066f, -0.00214504f, 0.00143547f, 0.04167948f, 0.00613322f, -0.01287846f, -0.00988434f, 
    0.02101921f, 0.00506508f, -0.05898415f, -0.03252238f, 0.03416595f, -0.00803734f, -0.03042743f, 0.00050753f, 
    -0.03720904f, -0.02248683f, 0.01059882f, -0.06504340f, -0.04614412f, 0.03665335f, 0.00078422f, 0.00409218f, 
    0.02047797f, 0.04050294f, -0.03984751f, 0.03534652f, 0.01986251f, 0.03750353f, -0.01216780f, 0.03845173f, 
    -0.04503281f, 0.00508723f, -0.03116941f, -0.04478797f, -0.03091911f, 0.00427654f, -0.04100809f, 0.03654881f, 
    -0.02860432f, -0.02399001f, 0.01767838f, -0.01355000f, -0.03159251f, 0.02508564f, -0.02409744f, -0.04804886f, 
    -0.02856817f, 0.00069169f, 0.00704833f, -0.03916152f, 0.02922683f, 0.02004103f, -0.02431465f, -0.02798614f, 
    -0.03168211f, -0.04477458f, 0.02755672f, 0.04294726f, 0.04081149f, 0.00345616f, -0.00458098f, -0.02739913f, 
    -0.00750415f, 0.02783242f, 0.00102791f, 0.04231610f, 0.04657587f, 0.00196191f, 0.03808003f, -0.02600039f, 
    -0.00388534f, -0.00052510f, -0.03730263f, 0.02464488f, 0.00222222f, -0.05387781f, -0.03634958f, 0.00745794f, 
    0.01418743f, -0.03433995f, -0.01306511f, -0.03764100f, -0.01029187f, -0.00180196f, -0.02771572f, -0.00269802f, 
    -0.04640519f, -0.02019602f, -0.01719766f, -0.01056903f, 0.01207869f, 0.02084818f, 0.04699399f, 0.01134135f, 
    0.02178206f, -0.01150475f, 0.03822036f, -0.01039947f, -0.04441640f, 0.02038816f, -0.03188271f, -0.00223754f, 
    -0.00207135f, -0.06322917f, -0.06299174f, 0.05243002f, -0.03482135f, -0.00513104f, -0.01544820f, -0.01540082f, 
    0.02816894f, -0.04954226f, 0.03867717f, -0.04509554f, -0.01567588f, 0.05656425f, -0.02564553f, -0.04307296f, 
    0.03191157f, 0.04372584f, 0.00506865f, 0.02917276f, -0.06141016f, 0.00043104f, 0.02284210f, -0.02825028f, 
    -0.00797146f, 0.04619243f, 0.02393376f, -0.00466469f, -0.04240232f, 0.00508988f, 0.03555428f, 0.00990357f, 
    -0.05056902f, -0.04323504f, -0.03404941f, -0.02439320f, 0.03198889f, -0.02234700f, -0.04343532f, -0.03228401f, 
    0.03713462f, -0.00978860f, 0.03119372f, 0.02486888f, -0.00525019f, -0.04764451f, 0.03306793f, -0.00854599f, 
    -0.05596178f, -0.03084918f, -0.02095764f, 0.02973225f, 0.00495484f, 0.04979921f, 0.03862639f, 0.02588570f, 
    -0.06487974f, 0.01099499f, 0.03432605f, 0.02218917f, 0.02738702f, 0.02722916f, 0.04735828f, 0.04607978f, 
    -0.04692708f, 0.01379532f, 0.01871989f, -0.04823305f, -0.02936509f, -0.01352944f, 0.00135797f, -0.00414576f, 
    -0.05044436f, 0.00611639f, -0.00689962f, -0.03813121f, 0.04443701f, 0.03277266f, -0.04752502f, -0.05523218f, 
    0.00319050f, -0.03601605f, 0.03658863f, 0.04337165f, -0.05559651f, -0.04549593f, -0.04961732f, -0.01854995f, 
    -0.04196586f, 0.04448463f, 0.03396576f, -0.01977853f, -0.03924567f, -0.00342169f, -0.06642942f, 0.02323726f, 
    0.02447028f, -0.00475622f, 0.03555143f, 0.02979878f, -0.00289460f, -0.02187305f, 0.02883429f, -0.05954910f, 
    -0.01976039f, -0.03889813f, -0.00594261f, -0.05610002f, 0.03848463f, 0.03680744f, 0.04950200f, 0.04471263f, 
    -0.01678589f, 0.01186206f, -0.00849037f, 0.00814158f, 0.04003700f, 0.02207940f, 0.01491769f, -0.02823961f, 
    -0.05508937f, -0.01019977f, 0.02655293f, -0.00124956f, 0.03953642f, -0.04439076f, -0.01883591f, 0.03408678f, 
    0.02092445f, 0.00034109f, 0.02138297f, 0.02872606f, 0.04114081f, -0.04467523f, -0.02066509f, -0.05661397f, 
    0.01669267f, 0.03465128f, 0.04375837f, -0.00885445f, 0.00704138f, -0.02513970f, -0.03993374f, 0.04027520f, 
    -0.04067512f, 0.04102121f, 0.00154511f, -0.02666983f, -0.03277448f, -0.03537909f, -0.00163521f, -0.02042701f, 
    0.01799076f, -0.05489781f, -0.02941551f, -0.00992507f, 0.01275337f, -0.02450334f, 0.01057937f, -0.04456021f, 
    -0.02327396f, -0.03694740f, 0.00716447f, 0.03131194f, 0.00287670f, -0.03426065f, -0.05658025f, 0.00378793f, 
    -0.04520318f, -0.06206125f, -0.02505639f, -0.04544907f, 0.01591529f, 0.03427619f, -0.03384768f, 0.03656919f, 
    0.03509727f, -0.02462516f, -0.04001388f, 0.02864091f, -0.02246384f, -0.00890282f, -0.06007802f, 0.03740264f, 
    -0.02251896f, -0.01735128f, 0.00580979f, -0.02404352f, -0.02550322f, -0.01552541f, 0.02471644f, -0.04042185f, 
    -0.00113212f, -0.01652047f, -0.04231475f, 0.04546151f, -0.02581740f, -0.05977781f, 0.01431353f, 0.02855328f, 
    0.02057831f, 0.04443154f, 0.02655090f, -0.02939352f, -0.00973302f, -0.02607349f, 0.03630421f, 0.05009132f, 
    0.03110388f, 0.04464377f, 0.01593503f, -0.02709457f, -0.04919703f, 0.00432470f, -0.00430390f, -0.01850135f, 
    -0.03020113f, 0.01175403f, 0.01775069f, -0.04748097f, -0.03809915f, -0.04886577f, 0.00519031f, -0.03294525f, 
    0.04803924f, 0.04430205f, 0.03664786f, -0.05289117f, -0.02283297f, 0.02885534f, -0.02833486f, 0.04811180f, 
    -0.01220724f, 0.04865783f, 0.04445785f, 0.01579066f, -0.03303029f, 0.01987871f, 0.01684983f, -0.05381751f, 
    -0.01647475f, 0.04924205f, -0.03049215f, -0.00031216f, -0.02819084f, -0.00837767f, -0.01228102f, -0.02709337f, 
    0.03702750f, 0.01823982f, 0.00980409f, -0.02765664f, 0.03070589f, -0.01954888f, -0.05747703f, 0.00464532f, 
    -0.01920452f, -0.04112606f, -0.02586238f, 0.00621572f, -0.06187016f, 0.04385643f, 0.03672998f, 0.01430267f, 
    0.02280870f, -0.02211356f, 0.02768598f, 0.01924948f, -0.03691337f, 0.00258046f, 0.03595044f, -0.02581169f, 
    -0.00642556f, 0.04619725f, 0.00640285f, 0.03113509f, 0.01994803f, -0.03999382f, -0.00816030f, 0.00356104f, 
    -0.03895506f, -0.01364496f, -0.05295218f, 0.04162001f, 0.01615502f, 0.02119626f, -0.00257790f, -0.03398555f, 
    -0.04331530f, -0.00693453f, -0.05423046f, -0.05587188f, -0.00429649f, -0.05277553f, -0.04256030f, -0.03546142f, 
    0.01418922f, -0.01978383f, -0.00189497f, 0.01160763f, 0.04429806f, -0.05206510f, -0.01492332f, 0.00482972f, 
    0.03138973f, 0.04530066f, 0.00713759f, 0.00424986f, -0.00628129f, -0.00512629f, -0.01963177f, -0.05415398f, 
    0.01282939f, -0.01149339f, 0.02247570f, 0.04065304f, -0.05320020f, -0.06112015f, 0.04619444f, -0.00020420f, 
    0.01363952f, 0.03409284f, -0.06016799f, 0.01112038f, -0.02774577f, -0.04078385f, 0.00062123f, -0.05662783f, 
    0.02149673f, 0.01886345f, -0.04231415f, -0.01812231f, 0.04711498f, -0.03009302f, -0.01509768f, -0.02599650f, 
    -0.05966137f, 0.04168684f, -0.04534572f, 0.01497508f, -0.03338702f, 0.02315661f, 0.05077986f, 0.01600694f, 
    -0.03663986f, -0.04068288f, -0.02279848f, -0.06403802f, -0.04430548f, 0.02700979f, 0.02825944f, -0.04092774f, 
    0.04100375f, 0.01492614f, -0.04126184f, 0.03846189f, 0.01479447f, -0.00655692f, 0.04015347f, 0.02013902f, 
    0.04581320f, -0.04186212f, 0.02639733f, -0.02513813f, 0.04844358f, -0.01048384f, -0.03810008f, -0.00322072f, 
    0.04297336f, -0.05218035f, -0.05676673f, 0.00196320f, 0.04249565f, -0.02600635f, 0.04526254f, 0.04032369f, 
    0.03430543f, 0.04215519f, -0.05897772f, 0.01038968f, -0.00046449f, -0.02751848f, -0.03543397f, -0.06126638f, 
    -0.04987866f, -0.05705466f, -0.01939999f, -0.02447256f, -0.03833548f, -0.02326684f, 0.03841905f, 0.02470296f, 
    -0.01800145f, -0.03799247f, 0.01266782f, -0.04061818f, -0.03740653f, 0.03377604f, -0.05730684f, -0.02851485f, 
    -0.01658622f, -0.00119641f, -0.01956690f, -0.01261205f, 0.00874964f, -0.04178298f, -0.04547327f, -0.04797749f, 
    0.04992701f, -0.04560002f, -0.00231488f, 0.02253473f, -0.02106837f, 0.04510265f, 0.01725642f, 0.02911233f, 
    -0.02163488f, 0.01363583f, -0.00224245f, 0.02363988f, 0.01676668f, -0.00167146f, -0.02858169f, 0.00942921f, 
    0.00693936f, 0.00172383f, -0.00934484f, -0.02791330f, -0.00906111f, -0.05568426f, -0.04317099f, -0.02615462f, 
    -0.05857709f, 0.02186326f, 0.04620367f, 0.01389338f, 0.02792187f, 0.00681962f, -0.05344543f, 0.00574444f, 
    -0.03989725f, 0.02821433f, 0.04271317f, 0.02933751f, -0.02749658f, -0.02425968f, 0.00211713f, 0.04644708f, 
    -0.01285700f, 0.02674268f, -0.00241006f, 0.00557413f, -0.01494114f, 0.03820682f, -0.05635341f, 0.03155391f, 
    0.02159336f, 0.00556926f, -0.03865231f, 0.04382542f, 0.00604768f, -0.03793224f, 0.00318039f, -0.03802692f, 
    0.04336221f, 0.02153843f, -0.02671106f, -0.03939997f, 0.00523114f, 0.01443159f, -0.01263312f, -0.00139780f, 
    0.03653886f, 0.00042532f, -0.06521251f, -0.03803534f, -0.04683550f, -0.03427169f, -0.03522740f, 0.03166726f, 
    0.04957968f, -0.04250101f, -0.00666511f, -0.04591292f, -0.04899057f, -0.02447050f, 0.03485589f, -0.06246492f, 
    -0.02420310f, -0.02038689f, -0.01226839f, 0.04412849f, 0.03862678f, 0.04778341f, 0.01999769f, 0.02328197f, 
    -0.03845347f, 0.03974251f, 0.04887910f, 0.03751304f, 0.01291490f, 0.04496239f, 0.04767959f, -0.03041020f, 
    -0.04753631f, -0.00017514f, -0.01750906f, -0.04764431f, -0.04724565f, -0.04830166f, 0.04685865f, 0.03385635f, 
    0.00324165f, 0.01853655f, 0.02710060f, -0.02724698f, 0.04983419f, 0.03507664f, -0.03258674f, -0.00850560f, 
    -0.03219991f, 0.01701031f, -0.01409300f, 0.04146916f, -0.00967941f, 0.03956827f, -0.03891395f, -0.02726772f, 
    -0.04115429f, -0.05569623f, 0.00542609f, -0.05947142f, -0.04653768f, 0.01457867f, -0.05863858f, 0.02462838f, 
    0.01962458f, -0.05331638f, 0.04079426f, -0.03350795f, 0.00618217f, -0.03771769f, 0.01592846f, -0.02218229f, 
    -0.06225926f, 0.00769825f, -0.05857182f, -0.05513186f, -0.06078270f, -0.00595945f, 0.02339107f, -0.03408601f, 
    -0.03876132f, -0.05304299f, 0.01748363f, -0.04403964f, -0.02196817f, -0.05764438f, -0.03939915f, -0.05145004f, 
    0.00439143f, 0.01364246f, 0.03353339f, -0.00721532f, -0.00982789f, 0.02494461f, -0.06154734f, -0.05194088f, 
    -0.03899944f, 0.03849472f, -0.01665576f, -0.05186543f, -0.04478239f, 0.01730329f, 0.03059117f, 0.02478428f, 
    0.02774189f, 0.03979677f, -0.00172819f, 0.03000404f, 0.00179320f, 0.00536578f, -0.05514326f, -0.03280001f, 
    0.01753750f, -0.04626824f, -0.03026508f, 0.00275779f, 0.04250295f, -0.01136390f, -0.03300378f, -0.01442834f, 
    0.02491081f, 0.02793980f, -0.02673143f, 0.01247393f, 0.02570619f, 0.04882821f, -0.04656446f, -0.01396404f, 
    -0.00723163f, 0.02164937f, -0.02831742f, -0.05930104f, 0.01787813f, 0.02887119f, 0.02200253f, 0.04879004f, 
    -0.01706721f, -0.05002955f, 0.02444695f, 0.00541856f, -0.05872312f, -0.05917215f, 0.04330567f, -0.05123224f, 
    0.02462972f, -0.02693977f, 0.01240445f, 0.03300642f, -0.04655935f, 0.05011173f, 0.05021815f, -0.00929034f, 
    -0.02468440f, 0.04383610f, -0.00452251f, 0.04692047f, -0.04837460f, 0.05216997f, 0.03802839f, 0.02161826f, 
    0.05440539f, -0.01468542f, -0.00848258f, 0.00404225f, -0.02410905f, -0.06010145f, 0.04188849f, -0.03183419f, 
    -0.05397728f, -0.06230776f, -0.05624497f, -0.00351650f, 0.04776529f, 0.04734688f, -0.00556506f, 0.01434184f, 
    -0.02588838f, -0.04018400f, 0.03832410f, 0.03179726f, 0.00517190f, 0.03365422f, 0.04203856f, -0.01395825f, 
    -0.05581211f, -0.03297990f, 0.00503149f, -0.02365589f, -0.04465172f, -0.03918048f, -0.02476442f, 0.01816443f, 
    -0.00241274f, -0.05290163f, 0.00366268f, 0.00702748f, 0.05174132f, 0.03036451f, -0.05685082f, 0.04307252f, 
    -0.02658629f, -0.05611224f, -0.03187573f, -0.06153692f, 0.00648920f, 0.01444617f, 0.03200172f, 0.03913852f, 
    0.02920327f, -0.00787056f, -0.03287746f, -0.05676888f, -0.03025056f, 0.03376816f, -0.00829971f, -0.01291082f, 
    0.04009720f, -0.05979926f, -0.01995559f, 0.03568117f, -0.01831971f, 0.01984508f, 0.03028960f, 0.01747915f, 
    -0.04655927f, -0.05964458f, -0.02771595f, -0.05179342f, 0.04878270f, 0.04329077f, -0.03757156f, 0.02701826f, 
    -0.02276021f, 0.00124734f, -0.01834567f, 0.00777422f, -0.05920578f, 0.00193862f, 0.03284628f, 0.01459452f, 
    0.01312533f, -0.05225725f, -0.02893850f, -0.02312494f, 0.02111126f, -0.00200126f, 0.00152677f, 0.00058287f, 
    0.04738965f, 0.02769590f, 0.03657620f, 0.04841838f, 0.04147862f, -0.00246669f, -0.01687341f, 0.04080736f, 
    0.04656848f, -0.03675062f, 0.02213608f, -0.00218097f, 0.00057963f, 0.03703574f, -0.01856756f, 0.00361369f, 
    0.03076673f, 0.01088740f, -0.06194367f, 0.01318389f, -0.01247513f, -0.01810225f, -0.04327526f, -0.05745091f, 
    0.04698448f, 0.00190177f, 0.03935518f, -0.06459228f, -0.04950669f, 0.01899090f, 0.03522293f, -0.00363685f, 
    0.03934642f, 0.00835452f, 0.00787275f, 0.03426677f, 0.01868413f, 0.01232585f, 0.00088813f, -0.00781986f, 
    -0.04424110f, -0.00993075f, -0.02320351f, -0.01535801f, -0.05420740f, -0.00162089f, 0.00356478f, -0.06189565f, 
    0.04985272f, 0.01254811f, -0.02146725f, -0.01015355f, -0.03327781f, 0.01673322f, 0.02633366f, -0.02390578f, 
    -0.05005896f, 0.04252964f, -0.00318903f, -0.01932297f, -0.02409434f, 0.02920270f, 0.03919091f, -0.06030632f, 
    -0.02096216f, 0.02754367f, -0.04170030f, -0.06354471f, 0.02009441f, -0.01625082f, -0.05182855f, 0.00038281f, 
    -0.06698485f, -0.04498605f, 0.01704218f, -0.00709379f, -0.03289261f, -0.01768895f, -0.06560797f, 0.01126412f, 
    0.00627438f, -0.03328193f, -0.00436516f, -0.02002959f, -0.01182101f, -0.01621220f, -0.02253071f, -0.04138950f, 
    -0.02458990f, 0.01630542f, -0.05457667f, -0.02053073f, -0.03370364f, -0.02632382f, -0.06141197f, -0.01198538f, 
    0.00564159f, -0.05645938f, -0.00336632f, 0.03264563f, -0.02826290f, 0.00905570f, -0.02251605f, -0.03367339f, 
    -0.01996721f, 0.03347738f, 0.00173261f, 0.00850925f, -0.05757635f, 0.01503950f, 0.01281859f, -0.00331117f, 
    -0.05355223f, -0.05503938f, 0.02626937f, -0.04566608f, -0.01915102f, -0.01067008f, -0.02788108f, 0.03120472f, 
    0.04291766f, -0.05605912f, -0.01694892f, 0.01898663f, -0.03407506f, -0.00420562f, -0.03182897f, -0.06035798f, 
    -0.03189091f, -0.04389370f, -0.00776657f, -0.01912024f, -0.00264405f, 0.00370064f, -0.04716303f, -0.01022818f, 
    0.00351023f, 0.00500175f, -0.00435197f, 0.03506088f, -0.01909458f, 0.04328485f, -0.00439228f, 0.01257693f, 
    -0.03845080f, 0.04221312f, -0.00569342f, -0.01167317f, 0.04295668f, 0.00953384f, 0.01979017f, 0.02966007f, 
    0.00801046f, 0.02162870f, 0.02476770f, 0.01552248f, -0.00055131f, 0.01489179f, 0.02977499f, -0.04598659f, 
    0.02935687f, 0.00549340f, 0.01481315f, 0.00025017f, -0.06180314f, -0.00883795f, 0.00444274f, -0.04028441f, 
    -0.00073703f, 0.02305505f, 0.03549284f, -0.02807618f, -0.02657921f, -0.06022692f, 0.02048674f, -0.05617690f, 
    0.02177507f, -0.01741115f, -0.03180986f, 0.04270885f, 0.02066082f, 0.03410865f, -0.02127654f, -0.00811291f, 
    0.01149866f, 0.02178538f, -0.06373996f, 0.02454196f, -0.01449704f, 0.01993682f, 0.01908515f, 0.03635600f, 
    0.03952011f, 0.02137056f, -0.02784619f, 0.01261765f, 0.01608834f, -0.04735012f, 0.00525528f, -0.01263882f, 
    -0.00977788f, -0.00189363f, -0.02995083f, -0.04747451f, -0.01106846f, -0.03603842f, -0.01584167f, 0.03228692f, 
    0.03347199f, -0.02039827f, -0.04736900f, -0.00082566f, -0.02142690f, -0.00638904f, -0.06258021f, -0.03816862f, 
    -0.02778990f, -0.02205996f, 0.03704458f, -0.05526660f, 0.01561243f, 0.03575698f, 0.00032088f, 0.04185658f, 
    0.01129234f, -0.03103620f, -0.02252943f, 0.04382554f, -0.00608507f, 0.02310068f, -0.01422822f, 0.01638365f, 
    0.02473686f, -0.02557776f, 0.00942851f, 0.01631192f, 0.03448619f, 0.02944963f, -0.00871252f, -0.03885642f, 
    -0.02794613f, -0.06071511f, -0.00451424f, -0.02315846f, -0.06293697f, -0.04812527f, 0.01909400f, -0.04464141f, 
    0.04356407f, 0.04523221f, 0.04105138f, -0.02130730f, -0.06449195f, -0.01362147f, -0.02950399f, 0.03456355f, 
    0.00423242f, 0.04287045f, 0.00035686f, -0.03522779f, 0.04566674f, -0.03647208f, -0.05146865f, -0.00997002f, 
    0.05136890f, 0.01320125f, 0.00149545f, 0.00901789f, -0.02468308f, -0.03045826f, -0.03823205f, -0.00366276f, 
    -0.00907740f, 0.00505222f, 0.03121280f, -0.04303104f, -0.03781359f, -0.00620364f, 0.00832606f, 0.04907932f, 
    0.02429141f, -0.05231205f, -0.02431256f, -0.01356297f, -0.03625436f, 0.00142341f, 0.02584564f, -0.02059545f, 
    0.00445590f, -0.05231378f, 0.00264227f, 0.02701668f, -0.03037600f, -0.04992030f, -0.06303555f, -0.04917035f, 
    0.01587742f, 0.01529060f, -0.04081341f, -0.04883873f, -0.00044602f, 0.04127218f, 0.01056264f, -0.04350034f, 
    -0.05404315f, -0.00748921f, -0.02760181f, 0.04243082f, 0.03997710f, -0.05553916f, -0.00450730f, -0.04783974f, 
    0.03802421f, -0.02559464f, 0.03997374f, -0.00693542f, -0.01491911f, -0.00442287f, 0.02604383f, -0.05318386f, 
    -0.02479057f, 0.00518501f, 0.03760466f, -0.01852211f, 0.01877318f, -0.05458703f, -0.00075834f, -0.04948408f, 
    0.03131982f, -0.00190535f, -0.01241415f, -0.00906513f, 0.04718145f, -0.03820927f, 0.02037411f, -0.03062933f, 
    -0.01362686f, -0.03267563f, 0.04912779f, 0.04565636f, -0.03931880f, 0.00076629f, 0.04867198f, 0.00913163f, 
    0.01368170f, -0.00247648f, -0.01286636f, 0.03898289f, 0.04852517f, 0.00579883f, 0.00607535f, 0.04317468f, 
    -0.03325066f, -0.03564651f, -0.01594322f, -0.00431381f, 0.02310223f, -0.02908318f, 0.05042873f, 0.00698100f, 
    -0.00301304f, 0.00169018f, -0.02377619f, 0.01072999f, 0.05028906f, -0.03237340f, -0.05974715f, 0.00114339f, 
    -0.05144271f, 0.03313180f, -0.04149456f, 0.03735151f, 0.03375796f, -0.02292752f, -0.03014543f, -0.04464803f, 
    -0.06034624f, 0.02628666f, 0.01032660f, -0.03935415f, -0.04794557f, -0.01204832f, 0.04615045f, 0.04563040f, 
    0.00944125f, -0.02316396f, -0.00748036f, -0.02031295f, -0.04454323f, 0.02728835f, -0.05798611f, -0.01429156f, 
    -0.04451802f, 0.01287543f, 0.01925178f, 0.03495070f, -0.04329792f, -0.01367617f, 0.02318352f, -0.03748325f, 
    0.03548189f, -0.04066131f, -0.04522522f, -0.05098113f, -0.04504103f, 0.02567705f, -0.01097874f, 0.02018149f, 
    0.00870868f, -0.02287540f, -0.01193012f, 0.02412286f, -0.03969667f, 0.01961068f, -0.04032486f, -0.03087253f, 
    -0.02168600f, 0.02214319f, 0.03586390f, 0.02733818f, 0.03421268f, -0.05066135f, -0.04868028f, -0.04576188f, 
    0.02934796f, 0.03630559f, 0.01452224f, 0.02600141f, 0.01320188f, -0.05118344f, 0.01553099f, -0.01001836f, 
    0.00606771f, 0.01739787f, 0.00901635f, -0.01727886f, -0.04858931f, -0.02301856f, -0.04070739f, -0.03250499f, 
    0.03013537f, -0.04431149f, -0.00043537f, 0.00467961f, -0.01721208f, 0.03240438f, 0.01496884f, -0.00693882f, 
    -0.00010409f, 0.03971091f, -0.01040107f, 0.01076213f, -0.04108311f, -0.01670092f, -0.01239948f, -0.01809380f, 
    -0.01486159f, -0.04977217f, -0.01744451f, -0.03847121f, -0.01853975f, 0.02180697f, -0.05588794f, 0.04167527f, 
    -0.00865946f, -0.00150952f, -0.05556238f, -0.01820970f, 0.03870161f, -0.01827484f, -0.05378433f, 0.00144292f, 
    -0.03722337f, -0.04182887f, 0.03700909f, 0.03537536f, -0.03598234f, -0.01782744f, -0.00194187f, -0.01321546f, 
    0.03234288f, -0.01261206f, 0.03577567f, -0.00325520f, -0.00990644f, -0.02445451f, -0.02729114f, 0.01221187f, 
    -0.05863525f, -0.02410480f, -0.01271995f, -0.01278589f, -0.01150241f, -0.01838936f, 0.00680689f, -0.00835419f, 
    -0.05046290f, -0.01152136f, 0.03323133f, -0.01446330f, -0.03701505f, 0.01118024f, -0.00085752f, -0.03439884f, 
    -0.02850259f, -0.03575485f, -0.05125411f, 0.04434820f, -0.01564583f, -0.01913575f, 0.03704289f, -0.01188452f, 
    -0.01603957f, 0.02696319f, -0.01178802f, -0.01422312f, -0.04268934f, -0.01101692f, -0.00543694f, -0.00490071f, 
    -0.01685296f, 0.01878992f, -0.05890979f, -0.03336241f, -0.04370452f, 0.03250387f, 0.00145683f, -0.02137149f, 
    -0.01499942f, -0.02544248f, 0.00090293f, -0.01936231f, -0.03640029f, 0.02941508f, -0.00381762f, -0.04555840f, 
    0.02847783f, 0.00229463f, -0.01982488f, -0.03597092f, 0.04646301f, 0.01372316f, 0.00222742f, -0.01889253f, 
    0.00927541f, -0.00116327f, -0.04653365f, 0.01533399f, -0.03913696f, -0.03002690f, -0.01408113f, 0.02059093f, 
    -0.04876375f, -0.02978019f, 0.04387127f, 0.03147131f, -0.01428687f, 0.04164427f, -0.04104655f, 0.01170015f, 
    -0.02643877f, -0.04034052f, 0.03502036f, -0.03189685f, -0.03874639f, -0.04206385f, -0.03442244f, 0.01185639f, 
    -0.02707325f, 0.04733808f, 0.03485389f, 0.04895588f, 0.03216631f, 0.04017251f, 0.04760046f, -0.02666582f, 
    0.03384284f, -0.06065423f, -0.04409729f, 0.04147050f, 0.00117686f, -0.04781124f, 0.00463081f, 0.01803590f, 
    -0.04847774f, -0.01991061f, 0.01241256f, 0.04681614f, 0.02688559f, 0.03688410f, -0.04014724f, -0.00215215f, 
    -0.04048787f, 0.03019511f, -0.02572796f, 0.03315054f, 0.00093301f, -0.01905213f, -0.05622643f, -0.02050219f, 
    -0.05237007f, -0.03881221f, -0.01315329f, -0.00293970f, 0.01286269f, -0.02227854f, -0.05698341f, 0.05029321f, 
    -0.03364578f, 0.00233319f, 0.00916846f, -0.05843337f, -0.02306454f, -0.04746126f, 0.01352769f, -0.00507993f, 
    0.00877465f, -0.02801181f, 0.02801139f, -0.01934663f, -0.02729536f, -0.01509246f, -0.01744835f, 0.00435868f, 
    -0.05048376f, -0.00793585f, -0.00194687f, -0.01921786f, 0.01717966f, 0.03144040f, 0.00774399f, -0.05791092f, 
    -0.05702987f, -0.00934794f, 0.00103675f, 0.00686695f, -0.04707195f, -0.05143542f, 0.01653397f, 0.04576794f, 
    -0.00913887f, -0.01386334f, 0.03764765f, -0.03935317f, 0.00095837f, -0.01426811f, 0.03109140f, -0.01016823f, 
    -0.04325359f, -0.00899517f, 0.01485453f, 0.00055927f, -0.00202563f, -0.05912907f, 0.02654656f, -0.02622457f, 
    -0.01656788f, -0.04449692f, -0.00409789f, -0.03046562f, 0.04426520f, 0.04748075f, 0.03796588f, 0.02485230f, 
    0.01709663f, 0.00898865f, 0.01426969f, -0.05752183f, 0.04502965f, -0.04598504f, -0.05871747f, -0.02074921f, 
    -0.01637065f, -0.04700994f, -0.05790904f, 0.02223806f, -0.03096266f, -0.03440189f, -0.02560337f, -0.01788568f, 
    -0.00530163f, 0.04177441f, -0.01090252f, 0.01401333f, 0.00159815f, -0.01690797f, -0.04905779f, -0.02746801f, 
    -0.03053682f, -0.00942786f, -0.03042674f, 0.02317639f, 0.03121023f, 0.01446734f, 0.04481920f, 0.04537060f, 
    0.01384605f, -0.04655959f, 0.02736968f, 0.02788998f, -0.00978133f, 0.02860388f, -0.03076736f, 0.00920844f, 
    -0.02815637f, 0.00593304f, -0.04252123f, -0.03665008f, -0.01330252f, 0.03487817f, -0.02244958f, 0.02752784f, 
    -0.02517918f, -0.02774975f, 0.03644121f, 0.00113759f, 0.00334124f, -0.04418503f, 0.01290180f, 0.00831331f, 
    0.04092755f, -0.02786925f, 0.04448258f, 0.03330833f, 0.04337741f, 0.04387153f, 0.01429486f, -0.02041571f, 
    -0.00644858f, 0.01106470f, -0.02571912f, -0.04674245f, -0.00360232f, 0.01033729f, 0.03402418f, 0.00739993f, 
    0.04543708f, 0.01476872f, -0.03857086f, 0.03521259f, -0.02698129f, 0.02802236f, -0.03913615f, -0.01929729f, 
    -0.06010830f, 0.03876675f, 0.03493287f, 0.02602003f, 0.03909370f, 0.03498735f, -0.06259451f, -0.01484682f, 
    -0.00871378f, 0.02575049f, 0.00071596f, -0.02420618f, 0.02373696f, 0.01143529f, -0.02651600f, -0.01209874f, 
    -0.01456951f, -0.00430487f, -0.03192471f, 0.00484999f, -0.01267726f, -0.00074813f, -0.04839415f, -0.02675767f, 
    -0.03205301f, 0.03334158f, 0.00842174f, 0.02436293f, 0.03060930f, 0.00847775f, -0.05166876f, 0.02235599f, 
    -0.04145391f, -0.01720703f, -0.00533781f, 0.03191094f, 0.02294837f, -0.05939985f, -0.03878671f, -0.03357888f, 
    0.04131279f, -0.02292052f, 0.03579666f, -0.04897102f, -0.02514208f, -0.00594328f, 0.03521769f, -0.01556246f, 
    0.00471655f, -0.03041741f, -0.03859452f, -0.05263020f, -0.03644230f, -0.02025082f, -0.04902329f, 0.03213507f, 
    -0.05073391f, -0.00697341f, 0.00781616f, -0.02882924f, -0.01097581f, -0.03819606f, 0.01912844f, 0.00960437f, 
    0.01230093f, -0.00705842f, 0.00497216f, -0.01369943f, -0.04335625f, 0.00544711f, -0.02923123f, 0.03965188f, 
    0.05180611f, -0.01244311f, -0.02970907f, 0.04170217f, -0.00466532f, -0.00548018f, 0.00451328f, 0.03014367f, 
    -0.01001502f, 0.03029150f, -0.05569404f, -0.04094936f, -0.00756591f, 0.04647644f, 0.01690090f, -0.03294887f, 
    -0.05040899f, -0.05676750f, -0.04844640f, 0.03896034f, 0.03847411f, -0.03173304f, -0.00203864f, -0.01926662f, 
    0.00411385f, -0.05508136f, -0.05593576f, -0.05581743f, 0.01318244f, -0.04849049f, 0.03061792f, 0.03833328f, 
    -0.02662247f, 0.03954341f, -0.03369686f, -0.01100106f, -0.03316745f, 0.02032470f, -0.03327399f, -0.04236901f, 
    0.00928669f, 0.03504141f, -0.02122017f, -0.06087081f, 0.01605202f, 0.03877261f, -0.00293232f, 0.02572541f, 
    0.02025877f, -0.04712920f, -0.01208335f, -0.04513106f, -0.01014434f, -0.04746686f, -0.04245006f, -0.03010703f, 
    -0.05031276f, -0.06396159f, 0.03718507f, -0.00737080f, -0.03394790f, 0.04266563f, -0.02339058f, -0.04895476f, 
    -0.02580830f, 0.03120951f, 0.02586759f, -0.05936157f, -0.00459104f, 0.00099284f, 0.01549605f, -0.01752883f, 
    0.01251247f, -0.02313653f, -0.02470050f, -0.05868956f, -0.04475402f, -0.05317192f, 0.01787991f, -0.03907877f, 
    -0.01736132f, -0.00498425f, -0.03936972f, 0.04526055f, 0.04953204f, -0.00597479f, 0.03296776f, -0.02230412f, 
    0.00047085f, -0.05104649f, 0.01200103f, -0.00964638f, -0.05544350f, -0.01522492f, 0.00069192f, 0.02644633f, 
    -0.00567311f, -0.01900569f, -0.00599737f, -0.06339794f, -0.01277935f, 0.00022245f, 0.03885377f, 0.00946803f, 
    -0.04702572f, 0.03726904f, -0.03688944f, -0.02641702f, -0.00902093f, 0.00844819f, -0.01191945f, -0.00540652f, 
    0.04476452f, -0.00773915f, -0.05251677f, 0.02279502f, -0.05857772f, -0.03232154f, 0.02182868f, 0.00138531f, 
    -0.01399421f, 0.02293139f, -0.02265887f, -0.03387081f, -0.02893854f, -0.05663756f, 0.01652575f, 0.02502103f, 
    0.02553613f, 0.02182405f, 0.01059825f, -0.01809828f, -0.06026171f, -0.01138671f, -0.05153032f, 0.01466105f, 
    -0.05533005f, 0.02240102f, 0.01464188f, 0.00773514f, -0.00343814f, 0.02995732f, 0.02162644f, -0.02303385f, 
    -0.04905801f, 0.03890832f, -0.04075826f, 0.04204727f, -0.01859888f, 0.00519344f, -0.05199568f, -0.05391812f, 
    0.03692829f, -0.02478568f, -0.05504120f, -0.03085661f, 0.02028856f, -0.04936340f, -0.04703028f, 0.00567375f, 
    0.09045811f, -0.08612535f, 0.00547429f, 0.40814331f, -0.07355384f, -0.13797107f, -0.01176759f, -0.05050779f, 
    -0.04869489f, -0.17184706f, 0.09477378f, 0.05607137f, 0.09220391f, 0.11262192f, 0.04442947f, 0.00237737f, 
    0.05208737f, 0.04301694f, -0.06771351f, 0.05887237f, 0.02651990f, -0.26852718f, 0.00869682f, -0.04334724f, 
    -0.03480966f, 0.14318119f, 0.04881815f, -0.11306636f, -0.01716019f, 0.15544674f, 0.24938150f, -0.03528125f, 
    0.09470817f, 0.07767057f, 0.03435317f, 0.03038996f, -0.02582224f, -0.05900067f, -0.09171028f, -0.02809710f, 
    0.14577614f, 0.36274263f, 0.13245074f, -0.02270044f, 0.21537535f, 0.07997666f, 0.11181363f, 0.23345335f, 
    0.00865211f, -0.11588030f, 0.00418911f, -0.14451784f, -0.01499135f, 0.09050639f, -0.03695120f, 0.05471919f, 
    -0.10589024f, 0.00239962f, 0.06103683f, -0.05784191f, 0.08634439f, 0.27233985f, 0.15733968f, 0.00640298f, 
    0.22115029f, 0.08466940f, 0.04923512f, -0.02943421f, 0.07587507f, 0.05745758f, -0.00042933f, 0.01527458f, 
    -0.01392019f, -0.02796695f, -0.13296175f, -0.02190973f, -0.00700049f, -0.08045729f, 0.09274122f, -0.08079218f, 
    -0.14144078f, 0.17255311f, -0.08330018f, 0.05703717f, 0.09480131f, -0.04480993f, 0.15156479f, 0.02555869f, 
    0.06652374f, 0.10332885f, -0.02635146f, -0.02474818f, -0.00699785f, -0.07109939f, -0.07104658f, -0.04806412f, 
    0.09641264f, -0.04264311f, 0.03154513f, 0.04333299f, -0.04945334f, -0.02490576f, 0.11644634f, 0.06852793f, 
    -0.29703879f, 0.06648773f, 0.09799864f, 0.04409464f, -0.07901999f, 0.12333602f, 0.09204756f, 0.08301549f, 
    -0.05364015f, -0.02747015f, 0.09618248f, 0.06224249f, 0.04782773f, 0.04268227f, 0.00759421f, -0.08597323f, 
    -0.46300551f, -0.02469469f, -0.17758392f, 0.05385885f, 0.31905207f, -0.01979116f, 0.10294475f, 0.01658366f, 
    0.08440414f, 0.06489234f, -0.01575226f, -0.01875135f, 0.05247689f, 0.08375013f, 0.02374107f, -0.00547178f, 
    0.00419396f, 0.03730885f, -0.07043942f, -0.11617820f, -0.28659135f, 0.25369766f, -0.00395522f, -0.12616739f, 
    -0.04394644f, -0.09111648f, -0.05772066f, -0.03783877f, -0.02050062f, -0.10589431f, 0.03440719f, 0.08080541f, 
    -0.06197257f, 0.06064510f, -0.03132110f, 0.10111432f, 0.01486261f, -0.11771499f, -0.07351626f, -0.12788269f, 
    -0.10261851f, 0.05327319f, 0.09894624f, -0.02980948f, 0.02919774f, 0.09264700f, 0.14619108f, 0.06164986f, 
    -0.00419867f, -0.05084551f, 0.13898532f, -0.16714415f, 0.04076722f, 0.02439626f, -0.01090875f, 0.10039312f, 
    0.09251625f, -0.03651497f, 0.15203661f, -0.05660109f, 0.14851129f, 0.23836514f, -0.16361634f, -0.10778583f, 
    0.09004287f, 0.17777784f, -0.03635212f, -0.01596554f, -0.08109406f, -0.19791926f, 0.09555456f, -0.01493201f, 
    -0.01717335f, 0.01322601f, -0.10101083f, -0.05025707f, 0.16419707f, 0.02855719f, 0.04058499f, -0.03934524f, 
    -0.15722783f, 0.02862980f, -0.23966795f, -0.20834309f, -0.16874307f, 0.09249573f, 0.05215814f, -0.07089683f, 
    0.13101585f, 0.21261962f, 0.03824880f, 0.01785968f, 0.10720906f, -0.08883815f, 0.11344569f, -0.09222559f, 
    -0.00386541f, -0.01787177f, -0.01808506f, -0.09172908f, -0.61325264f, -0.19658691f, 0.08279393f, -0.04168357f, 
    -0.08367821f, 0.16137406f, 0.07604983f, 0.06715523f, -0.14301939f, 0.05593498f, -0.06605440f, -0.07842109f, 
    0.02885327f, -0.05047633f, -0.03590407f, -0.01482751f, 0.04107700f, -0.01395014f, -0.16000256f, -0.05523999f, 
    0.09103854f, 0.07170752f, 0.01428365f, 0.16834077f, 0.18496066f, -0.12279531f, 0.01160118f, 0.07859466f, 
    0.00611963f, -0.21402717f, -0.05602971f, -0.08216937f, 0.12390408f, 0.01842479f, -0.10373706f, -0.04912188f, 
    -0.04223493f, -0.04987022f, 0.07001713f, 0.08574108f, -0.11639994f, 0.08334998f, 0.08012472f, 0.05009584f, 
    0.34546804f, 0.17882396f, -0.06031322f, -0.03014679f, 0.11358470f, -0.06511071f, 0.01932175f, 0.10441185f, 
    -0.00403522f, -0.01220905f, 0.06337952f, 0.05270167f, 0.08574954f, -0.09490865f, 0.16638598f, 0.04601842f, 
    -0.17872596f, 0.11023857f, -0.07971061f, -0.00161918f, 0.30687964f, 0.07909541f, -0.06887028f, -0.00684037f, 
    -0.01047645f, 0.12157233f, 0.04342925f, 0.03509293f, 0.00384372f, -0.00218892f, 0.04882709f, -0.01671433f, 
    -0.08906724f, -0.01370267f, 0.16911143f, 0.03871442f, -0.04962274f, 0.11886316f, 0.04248227f, -0.17963967f, 
    0.05203031f, -0.19616370f, -0.02080469f, -0.03257170f, 0.00509880f, 0.06127700f, -0.07796217f, 0.03892119f, 
    -0.05479781f, 0.01538748f, -0.01933204f, 0.02077485f, -0.01141389f, -0.05093746f, -0.04884037f, 0.03729680f, 
    0.29838586f, 0.17698030f, -0.39150149f, -0.07336769f, 0.16661404f, 0.13644190f, 0.02598171f, 0.05652037f, 
    -0.02624295f, 0.02387880f, -0.02968483f, 0.03082861f, -0.05800159f, 0.05207002f, -0.05249877f, 0.21212341f, 
    -0.04471048f, 0.11651289f, -0.02009877f, 0.03917543f, 0.70613939f, 0.22419329f, -0.21236017f, 0.19832565f, 
    0.13373774f, -0.06056849f, -0.02552461f, 0.03300783f, 0.00171535f, -0.05446975f, -0.02803168f, -0.02908258f, 
    -0.03326447f, -0.03869866f, -0.02805878f, 0.01489144f, -0.08817826f, 0.05986341f, -0.03406305f, 0.01683018f, 
    0.10722233f, -0.21628122f, 0.08776199f, -0.10487307f, 0.01027853f, 0.02173445f, 0.10403466f, -0.00802145f, 
    -0.07509030f, -0.03337872f, -0.01562664f, -0.01898334f, 0.00023394f, 0.03291899f, -0.01402060f, 0.05117496f, 
    -0.05780079f, -0.06462388f, 0.01781738f, -0.11046141f, -0.06862317f, 0.08420285f, -0.05695077f, -0.12691018f, 
    -0.00371900f, -0.13906775f, -0.12007755f, 0.11112983f, -0.12981431f, -0.00342072f, 0.05847650f, -0.09626240f, 
    0.05104080f, -0.03424827f, 0.03733021f, 0.07820895f, -0.01836171f, 0.01325893f, 0.07413195f, 0.14135875f, 
    0.37289548f, -0.13439256f, 0.06505375f, 0.24553789f, -0.08474905f, -0.03866262f, 0.17088157f, 0.07926700f, 
    -0.02622366f, -0.18444651f, -0.00123256f, 0.01337578f, -0.05771567f, 0.14937137f, -0.01687193f, 0.08116014f, 
    0.01295591f, 0.01837524f, 0.02596155f, 0.10459038f, 0.21025424f, 0.45128945f, -0.11165687f, -0.02039942f, 
    0.10454296f, -0.02291416f, 0.04398346f, 0.00307909f, 0.09139472f, 0.00837343f, -0.04592409f, 0.04091247f, 
    0.03927727f, 0.01781417f, -0.03741612f, -0.03884705f, -0.02638653f, 0.07519154f, -0.13526593f, -0.07360959f, 
    -0.28405502f, -0.09964558f, 0.14676191f, -0.10504536f, -0.17557395f, -0.05764707f, 0.10722937f, 0.03708237f, 
    -0.05769728f, 0.03030053f, -0.03013667f, 0.05751690f, 0.00031332f, -0.00225397f, 0.02930572f, -0.05594003f, 
    -0.09864122f, -0.05607430f, -0.04094429f, 0.06430404f, 0.10784009f, 0.11464436f, 0.05562910f, 0.16403125f, 
    -0.01751567f, 0.08974783f, -0.01235732f, 0.04649279f, -0.00978829f, -0.01299082f, -0.08677052f, -0.03622911f, 
    0.18746109f, -0.11754035f, 0.03322178f, -0.04062308f, -0.08042388f, 0.05334760f, 0.11256059f, -0.03517228f, 
    -0.17245628f, 0.17127392f, -0.06174183f, -0.11702087f, -0.01195649f, 0.00987644f, -0.05915942f, -0.18124649f, 
    0.01282248f, 0.05560784f, 0.05465055f, 0.02519994f, -0.05225542f, -0.03442006f, 0.00603621f, 0.00179770f, 
    -0.05179387f, 0.16585656f, 0.01736602f, -0.02212993f, 0.17735951f, -0.18528289f, 0.19701838f, -0.04740601f, 
    0.24703746f, 0.08626527f, -0.10658920f, 0.05828208f, 0.10937712f, 0.13763459f, 0.00181985f, 0.14908800f, 
    0.03267641f, -0.04238075f, -0.01968757f, 0.00783188f, 0.03610146f, 0.00302601f, -0.04420333f, 0.01911782f, 
    -0.02177979f, -0.05855060f, 0.09727079f, -0.02611978f, 0.13417016f, -0.07507527f, -0.14530647f, 0.13639431f, 
    -0.00530270f, 0.14250383f, -0.08293210f, 0.09281313f, 0.03190225f, -0.00444114f, 0.08869074f, 0.04880379f, 
    0.06785000f, -0.02888254f, -0.17343973f, -0.05468173f, 0.18997915f, -0.37048149f, -0.02470665f, -0.24032423f, 
    0.06739476f, -0.01637146f, -0.01946030f, 0.08413761f, 0.02431752f, 0.06221639f, -0.15032928f, 0.06554183f, 
    -0.06052916f, 0.02425026f, -0.03740646f, -0.02323798f, 0.01571891f, -0.08699258f, -0.16991170f, 0.00129249f, 
    0.34509614f, -0.11653052f, -0.01746109f, -0.21689181f, 0.09581428f, -0.12676431f, -0.01942758f, -0.17075250f, 
    0.07659212f, 0.02082738f, -0.00513268f, 0.00727555f, 0.05526805f, 0.06174250f, -0.02021905f, -0.01440469f, 
    0.13957262f, -0.01720590f, -0.06728388f, 0.00918631f, 0.00735873f, 0.09219147f, -0.02951037f, 0.04215524f, 
    -0.08575449f, -0.00579758f, -0.05426333f, 0.01364613f, 0.00909944f, -0.06964388f, 0.06114770f, 0.00975212f, 
    0.04997912f, 0.03178724f, -0.02802031f, 0.04931022f, -0.02484727f, 0.07851832f, 0.08129162f, 0.01787509f, 
    -0.18584244f, 0.13531405f, -0.08122414f, -0.02710027f, 0.18680072f, 0.02936228f, -0.05149196f, 0.06114765f, 
    0.02139863f, 0.01977961f, -0.00048776f, -0.09919900f, -0.01068912f, 0.09734399f, -0.01443898f, 0.03333389f, 
    -0.01209539f, 0.13276674f, 0.11748513f, 0.03080698f, -0.16971087f, 0.14749953f, -0.14044699f, -0.02080062f, 
    0.02421596f, -0.14033802f, 0.09430388f, -0.07211345f, 0.07477563f, -0.03742068f, 0.04121974f, -0.05662641f, 
    0.05160225f, -0.07603090f, -0.04292092f, 0.06424180f, -0.00438941f, -0.11980680f, 0.06426423f, 0.07670143f, 
    0.38409036f, 0.06543320f, -0.06030251f, 0.00983481f, -0.06876986f, 0.13826434f, 0.05180031f, 0.10320894f, 
    -0.06869461f, -0.04327203f, 0.06032557f, -0.08337066f, 0.02408729f, 0.03766161f, 0.11014479f, 0.11687419f, 
    0.00026547f, -0.25139785f, -0.08581316f, -0.03865185f, -0.19212827f, -0.13993020f, -0.03429330f, 0.17646897f, 
    0.17320728f, 0.22265780f, 0.17712903f, 0.02335852f, 0.03348145f, -0.05572112f, 0.01319742f, 0.00660448f, 
    0.10676825f, 0.11226226f, 0.00413301f, 0.04564066f, 0.12118501f, 0.07316196f, -0.03272087f, -0.09338605f, 
    0.07479461f, 0.15911247f, -0.01506645f, -0.05210065f, -0.04156085f, -0.08216926f, -0.05691579f, 0.02979912f, 
    0.04244472f, -0.01779573f, 0.04249508f, -0.09378952f, 0.00875953f, -0.13926607f, -0.08654775f, 0.14707537f, 
    0.01408235f, -0.00752918f, 0.00031715f, 0.17028259f, 0.13396645f, -0.21565202f, 0.04075077f, -0.03072197f, 
    -0.18016511f, -0.09437767f, -0.05206028f, 0.06849910f, 0.00569452f, -0.00328663f, 0.00914430f, -0.01279007f, 
    0.00421638f, 0.01897551f, 0.07343366f, 0.01241303f, 0.03508262f, 0.06618335f, -0.11690872f, 0.17233293f, 
    -0.12671468f, -0.08464912f, -0.17413443f, -0.00078975f, -0.01527658f, 0.06552273f, 0.15208869f, -0.08520351f, 
    0.00047991f, 0.05058618f, -0.00781767f, -0.01629822f, 0.01133111f, 0.00860092f, 0.15077429f, -0.06145978f, 
    0.06796590f, -0.02044328f, 0.06912441f, 0.03253292f, -0.04896202f, -0.12365622f, -0.11564252f, 0.13211732f, 
    0.13799381f, 0.16569492f, 0.03569562f, -0.00263284f, -0.05581145f, 0.01955852f, 0.07072783f, -0.01617848f, 
    -0.00695673f, 0.20840149f, 0.05197298f, -0.04005306f, -0.11972941f, 0.16517103f, 0.07482816f, -0.03557933f, 
    0.16926335f, 0.06272808f, 0.05375380f, 0.00711467f, 0.03660255f, -0.20667371f, -0.08848079f, -0.00624830f, 
    0.05276628f, 0.02172051f, 0.03756940f, 0.00313105f, -0.03647467f, -0.16160455f, 0.12194157f, 0.07108805f, 
    -0.11069794f, 0.01377125f, -0.00106128f, 0.07862911f, -0.09606790f, 0.10967212f, -0.37766972f, 0.09454431f, 
    0.01686480f, -0.01022672f, -0.03752252f, -0.01058481f, -0.03104377f, 0.01004909f, 0.06903545f, -0.11999585f, 
    -0.00604210f, -0.06302787f, 0.03375527f, 0.01688943f, 0.04410652f, -0.02344399f, 0.21175587f, 0.02160783f, 
    0.15254058f, 0.32974818f, -0.15193240f, 0.02462575f, -0.30247745f, 0.09111588f, 0.07728709f, -0.00940645f, 
    -0.08629407f, 0.00334048f, -0.01548499f, -0.03939243f, 0.09524660f, 0.03274864f, -0.00146706f, 0.13064446f, 
    0.09429348f, -0.10272071f, -0.12462172f, 0.14758237f, 0.01847007f, -0.12450311f, -0.00331557f, -0.14903720f, 
    -0.22947729f, -0.01379448f, -0.12153497f, 0.01865955f, 0.07434022f, 0.00602882f, 0.22232249f, -0.02708061f, 
    -0.06814361f, -0.01775798f, 0.08389980f, -0.06631456f, 0.09303609f, -0.15931594f, 0.04339769f, 0.06491858f, 
    -0.23987874f, 0.01149798f, -0.05134979f, -0.05278120f, -0.06108405f, 0.14869776f, 0.10102465f, -0.08688377f, 
    -0.11060350f, -0.00308942f, -0.06131146f, -0.11445677f, 0.11464188f, 0.06431972f, 0.02225803f, -0.11261902f, 
    -0.14251730f, 0.08887478f, -0.00365294f, 0.10013708f, 0.03131559f, 0.05918840f, -0.00573488f, -0.03042564f, 
    0.00744487f, -0.03938932f, -0.01345461f, -0.01280615f, -0.08907691f, -0.06412587f, 0.09904385f, -0.03151692f, 
    0.04200760f, -0.01889690f, 0.06633212f, -0.15740852f, 0.08251294f, -0.01591297f, 0.17804325f, 0.03248793f, 
    -0.08091760f, 0.19236505f, -0.04229776f, -0.09544650f, -0.07008772f, -0.00490379f, -0.13201138f, -0.00541177f, 
    -0.01828228f, 0.04420807f, 0.05201394f, -0.01196466f, 0.02489608f, -0.14498964f, 0.06457219f, -0.04065010f, 
    0.06302473f, -0.11279990f, 0.09046738f, -0.13854866f, -0.07929556f, -0.00127310f, 0.01496810f, 0.00336430f, 
    -0.05081375f, 0.07923035f, -0.04989604f, 0.03782268f, 0.02417430f, 0.03176026f, -0.04037157f, 0.02805564f, 
    -0.05641292f, 0.06644911f, 0.07226476f, -0.06405322f, 0.00940010f, 0.03661266f, -0.04826330f, 0.04444034f, 
    -0.14755780f, 0.30631316f, 0.26722968f, 0.00457161f, -0.04966458f, 0.08310743f, 0.13612548f, 0.01455425f, 
    0.03309581f, -0.01972793f, -0.01814210f, 0.00062116f, 0.08674887f, 0.03663719f, 0.01891841f, -0.00389448f, 
    0.10762621f, 0.09052522f, -0.08661886f, -0.09423997f, 0.01753236f, 0.23885080f, -0.11616798f, -0.11769442f, 
    -0.08862190f, 0.04119564f, 0.15622562f, -0.00230877f, 0.07163509f, -0.11907734f, -0.10015511f, 0.04279757f, 
    -0.05369850f, 0.14121556f, 0.02146607f, 0.11023100f, -0.02565069f, 0.11846773f, -0.02630553f, 0.02600302f, 
    0.09476102f, -0.07127613f, 0.15256824f, 0.24734211f, 0.19381799f, -0.12729567f, -0.05735126f, 0.10099553f, 
    -0.09865123f, 0.02676678f, -0.17346543f, -0.13904603f, -0.05371761f, 0.11093167f, 0.09444336f, -0.05648402f, 
    0.08531185f, -0.03145233f, 0.01256447f, -0.03347844f, -0.22342218f, -0.14940611f, 0.13311833f, 0.22796500f, 
    0.28366262f, -0.08239612f, -0.00681966f, 0.06229990f, 0.09838799f, -0.05208191f, -0.01614870f, -0.04273085f, 
    -0.00229836f, -0.07315915f, 0.00815929f, -0.00406969f, -0.03711773f, -0.02664050f, -0.04180682f, -0.00424322f, 
    -0.27142978f, 0.00042964f, -0.04690282f, 0.02247067f, -0.01239028f, 0.05534012f, 0.08785758f, 0.00853803f, 
    0.06086788f, -0.01695739f, 0.06026018f, 0.07305919f, 0.07491197f, -0.05659892f, 0.07491113f, 0.14679950f, 
    0.10333957f, -0.05779338f, 0.03787662f, -0.00685114f, 0.03413039f, -0.01701573f, -0.23758890f, 0.19208482f, 
    -0.00923311f, 0.10585093f, 0.04395075f, -0.06589985f, 0.18779303f, 0.14397582f, 0.00147081f, 0.01592543f, 
    -0.00207506f, 0.03124039f, -0.10038012f, 0.01987254f, -0.04714735f, 0.13305232f, -0.04963195f, -0.11063275f, 
    -0.04546594f, 0.14056602f, 0.13917753f, 0.18707843f, -0.21747074f, 0.00570876f, -0.02512960f, 0.17176801f, 
    -0.00609884f, -0.04574494f, -0.12351842f, 0.11264881f, -0.08850252f, -0.07315119f, 0.05301912f, -0.00312945f, 
    0.02386223f, 0.01078966f, 0.13036253f, 0.03604347f, 0.50146824f, -0.04733900f, 0.13698198f, -0.08463632f, 
    0.19287232f, -0.11679941f, -0.07204200f, 0.06756940f, -0.02776100f, 0.07186633f, 0.03006901f, -0.05983085f, 
    -0.03602117f, -0.01632171f, -0.03416004f, 0.03057337f, -0.05849459f, 0.09975200f, -0.00535308f, 0.02170811f, 
    -0.35750809f, 0.21630521f, -0.14187346f, -0.07808549f, -0.15685350f, -0.01570021f, 0.02054234f, -0.03326993f, 
    0.08876349f, -0.06758277f, 0.00952222f, -0.04635504f, 0.00931530f, 0.04231769f, -0.00063202f, 0.09935503f, 
    0.05902915f, 0.05483077f, 0.13549945f, -0.02451375f, -0.29238677f, 0.39397311f, 0.09870826f, -0.09592340f, 
    -0.25116357f, 0.08858953f, -0.05372446f, 0.05301279f, 0.08570224f, -0.07055952f, -0.00642075f, -0.03000955f, 
    -0.08008824f, 0.00243843f, -0.12461115f, -0.09576311f, -0.08105767f, -0.01242363f, -0.04445018f, -0.02715299f, 
    -0.16997498f, -0.10453288f, 0.12756532f, 0.16311590f, -0.27038175f, 0.08336797f, -0.04194921f, 0.00065022f, 
    0.00575094f, 0.19776799f, 0.13181983f, -0.04190617f, 0.16134201f, 0.10177761f, 0.02047696f, -0.09383318f, 
    -0.08591338f, -0.13751054f, -0.06599382f, -0.06441758f, 0.47777057f, -0.17178482f, 0.08291741f, 0.05996078f, 
    -0.03984173f, -0.07076001f, -0.08385766f, -0.07922370f, 0.08122339f, 0.01142155f, -0.08336642f, 0.05467018f, 
    -0.01437819f, -0.03600011f, -0.10180310f, -0.03599856f, -0.13183814f, -0.00810277f, -0.05595899f, -0.03148189f, 
    0.09864356f, 0.14013672f, 0.11928108f, -0.02415036f, 0.17250074f, -0.09482148f, -0.09724193f, 0.04246652f, 
    0.11476847f, 0.01304112f, 0.06199047f, 0.04688098f, 0.04771501f, 0.07966400f, 0.02311662f, 0.09115664f, 
    -0.01458689f, 0.07102343f, -0.01290138f, 0.12980923f, -0.05959764f, 0.22131763f, 0.20538686f, -0.02674926f, 
    -0.13581604f, 0.06083940f, -0.03366505f, -0.05366323f, -0.06240524f, -0.02192407f, 0.06927051f, 0.01561064f, 
    -0.03543003f, -0.00518542f, 0.01560914f, 0.05567408f, 0.00129802f, -0.00983458f, -0.03649099f, -0.00314153f, 
    -0.09331960f, 0.16763194f, -0.30856323f, 0.21839818f, -0.07619506f, 0.08266518f, 0.11057906f, 0.05306761f, 
    0.13294122f, 0.12756687f, 0.01336271f, 0.00535296f, 0.08841047f, -0.07958947f, 0.05486738f, 0.05943477f, 
    0.06460366f, -0.03861113f, 0.01483928f, 0.09997986f, -0.01667951f, 0.08905849f, -0.05482771f, 0.14790772f, 
    -0.01840995f, 0.03293921f, 0.04873554f, -0.00404618f, 0.07797039f, 0.12475700f, -0.06693013f, 0.02316192f, 
    -0.06879380f, -0.02472219f, -0.17266071f, -0.07881153f, 0.08954606f, 0.04310109f, 0.13219148f, -0.10378562f, 
    0.01623512f, -0.08793250f, 0.07320514f, 0.46042374f, 0.09676839f, 0.11474951f, 0.02421591f, -0.01858807f, 
    0.06234470f, 0.01094310f, -0.02266855f, -0.01458728f, 0.07817440f, 0.05302950f, 0.00868673f, -0.03615628f, 
    -0.03749689f, 0.05337687f, -0.05599203f, 0.02404498f, -0.03605439f, 0.12011151f, -0.21029277f, 0.11402995f, 
    -0.07203333f, -0.08479338f, -0.10104094f, 0.01892362f, -0.05023991f, -0.07998492f, 0.02134342f, -0.15823363f, 
    -0.17438130f, 0.07787853f, 0.03104210f, -0.06895466f, -0.05590393f, -0.00109942f, 0.00416940f, 0.01125075f, 
    -0.19668370f, -0.18304351f, 0.42460975f, 0.08873561f, 0.13726282f, -0.17553629f, -0.09330760f, -0.00919415f, 
    0.17456141f, 0.07365121f, -0.09292062f, -0.01566058f, -0.01627011f, 0.15671939f, 0.03007125f, -0.05273333f, 
    -0.10093837f, -0.10443537f, 0.04110005f, 0.06551976f, -0.06121836f, -0.14985193f, 0.11142362f, -0.17613778f, 
    -0.18501084f, -0.06087875f, -0.17112082f, -0.03909852f, -0.09332272f, -0.00495856f, -0.14375028f, 0.01220509f, 
    0.02998287f, 0.09115081f, 0.04596128f, -0.04732168f, 0.13167344f, 0.06192656f, 0.01930238f, 0.01550510f, 
    -0.27345246f, -0.09840496f, -0.22876894f, 0.13150263f, -0.14690346f, 0.10415500f, -0.04833326f, 0.06042920f, 
    0.09284666f, 0.02831711f, 0.01876043f, 0.05232216f, 0.05218434f, -0.01650529f, 0.07918313f, -0.04654738f, 
    0.05800134f, -0.02521096f, 0.04511774f, -0.04263865f, -0.17174950f, 0.08874578f, -0.10715177f, -0.03850876f, 
    0.09843789f, 0.17014697f, 0.04373095f, -0.04590135f, 0.06940961f, -0.05244458f, 0.08786876f, 0.11927507f, 
    -0.02203981f, -0.03955475f, 0.17811826f, 0.02378892f, 0.09170127f, -0.00148640f, 0.08186587f, -0.00526608f, 
    -0.48002383f, -0.19700223f, 0.17297845f, -0.04451443f, 0.06623483f, -0.03293663f, -0.14591949f, -0.13343029f, 
    -0.14829233f, -0.00714322f, 0.03100689f, -0.08639240f, 0.04221634f, -0.05946468f, -0.04566454f, 0.06240489f, 
    0.03906229f, 0.05837779f, 0.03255684f, -0.03335768f, 0.03872979f, -0.03763549f, 0.07656398f, -0.05462581f, 
    -0.02513695f, -0.10878217f, 0.10884751f, -0.08796207f, -0.11815665f, 0.01788071f, 0.05545766f, -0.09020385f, 
    -0.10242275f, 0.04454628f, 0.00103388f, 0.19431332f, 0.05600275f, 0.02348185f, -0.02127092f, 0.03769343f, 
    -0.07322426f, 0.15749612f, -0.19018623f, -0.12867829f, -0.30691835f, 0.32589450f, 0.06712013f, 0.02450184f, 
    0.01790575f, -0.10968120f, -0.00409546f, -0.00707224f, 0.02939258f, 0.04662424f, -0.06813957f, 0.07435738f, 
    0.17660287f, 0.03922128f, -0.07600659f, 0.02767954f, -0.14056584f, 0.10934034f, 0.31696755f, 0.01096229f, 
    0.12157562f, 0.03859473f, 0.02947981f, 0.04793160f, 0.08166579f, 0.04352517f, 0.04720782f, 0.02980388f, 
    -0.08475153f, -0.00069694f, -0.02062767f, -0.01757750f, 0.06390058f, 0.03801421f, -0.11685075f, 0.12779281f, 
    -0.10670293f, -0.31845778f, 0.08293153f, 0.10750397f, 0.20773701f, -0.03656698f, -0.07014890f, 0.00478856f, 
    0.09816641f, 0.05821049f, -0.00210998f, 0.21901715f, 0.05957389f, 0.09636156f, 0.00816036f, -0.07428150f, 
    -0.02212122f, 0.03499804f, 0.05281802f, 0.11997838f, -0.21126039f, 0.01611600f, -0.04707745f, 0.16567461f, 
    0.28221396f, -0.01915514f, 0.14006171f, -0.03519952f, -0.06700265f, 0.08135033f, -0.06123065f, 0.01697698f, 
    0.02792149f, 0.02115848f, 0.12852885f, 0.05274006f, -0.01765773f, -0.02798723f, -0.06602467f, 0.03174673f, 
    0.18707328f, -0.10719063f, 0.02677685f, 0.10948166f, 0.03300493f, -0.16792822f, -0.04248253f, -0.11372629f, 
    -0.13595352f, -0.25542137f, 0.10923370f, -0.03515305f, -0.02738577f, 0.05728731f, -0.09895308f, 0.12643020f, 
    0.10005084f, -0.10689121f, -0.04706869f, -0.04185491f, -0.00092983f, 0.14363216f, -0.27890137f, 0.13483846f, 
    -0.23527575f, -0.03553786f, 0.10439651f, 0.01703082f, 0.02706572f, -0.03084399f, 0.08716378f, -0.05123064f, 
    -0.01814263f, 0.03501917f, -0.11726536f, 0.13155220f, 0.04956039f, 0.08043750f, 0.03201903f, -0.00849147f, 
    0.30791113f, 0.21011299f, -0.11163884f, 0.16770698f, -0.10291459f, 0.29610464f, 0.09410375f, 0.16587473f, 
    -0.00873295f, 0.06776109f, 0.08744110f, 0.05998835f, 0.09959703f, -0.01919224f, 0.01597861f, 0.12232878f, 
    -0.01992072f, 0.11957402f, -0.00855449f, 0.09043166f, 0.22032894f, 0.11615343f, -0.17738755f, -0.04669873f, 
    0.10357819f, -0.01454268f, 0.06509414f, 0.01950751f, -0.00474984f, 0.04904412f, 0.07241971f, 0.02729795f, 
    0.04318427f, -0.06689546f, 0.03871239f, 0.02672253f, 0.04143237f, 0.00267375f, -0.00247887f, 0.06288116f, 
    0.25265428f, -0.20159082f, 0.14442447f, 0.22848640f, 0.06589533f, -0.00434709f, 0.02006628f, 0.06314602f, 
    -0.02552735f, 0.06176218f, 0.05411324f, 0.00472523f, 0.07397828f, 0.02612218f, 0.12000376f, -0.07424366f, 
    -0.04303021f, -0.05223286f, -0.03230393f, 0.08888432f, 0.02897058f, -0.23144814f, 0.08886220f, 0.15648946f, 
    -0.08726637f, 0.11224512f, -0.02208690f, -0.10390384f, 0.00710802f, 0.16307527f, 0.10216089f, -0.02260030f, 
    0.12009948f, 0.11252859f, 0.03485956f, 0.02947983f, -0.01713722f, 0.10062791f, 0.07145534f, -0.04100992f, 
    0.06768166f, 0.05998606f, -0.02715082f, 0.43626216f, 0.19486661f, -0.00433623f, -0.04322873f, -0.03875553f, 
    -0.00470267f, 0.05262249f, -0.05685928f, 0.01189525f, 0.03746501f, 0.08781411f, 0.17696343f, 0.03119306f, 
    -0.01991492f, -0.02891864f, 0.13851565f, 0.02541730f, -0.14420997f, 0.15438782f, -0.04457023f, 0.37618405f, 
    0.25325647f, -0.08932894f, -0.10607447f, 0.03650282f, 0.09825096f, 0.02447764f, 0.02000354f, -0.10412126f, 
    -0.06971075f, 0.01124811f, -0.02610834f, -0.05424475f, -0.04390997f, 0.06178360f, -0.08446983f, -0.09273314f, 
    -0.30118969f, -0.06805096f, 0.02005712f, -0.14945793f, -0.02712481f, -0.06191673f, 0.03519039f, 0.10016697f, 
    -0.09310711f, -0.08056884f, 0.00391074f, 0.11814086f, -0.03726225f, 0.02063948f, 0.03910755f, 0.05532435f, 
    0.04563459f, -0.08912547f, -0.03082879f, -0.03615790f, -0.39094758f, 0.19540448f, 0.11205446f, -0.21993235f, 
    0.16971335f, 0.10277119f, -0.09606296f, 0.07665285f, 0.07587874f, 0.07271481f, -0.00629201f, 0.05290882f, 
    0.04103551f, 0.01127426f, -0.02467388f, 0.01053443f, 0.04491394f, -0.01794683f, 0.01305115f, -0.00462873f, 
    0.11361723f, 0.13275689f, 0.26116148f, 0.09722310f, 0.04118202f, 0.06032967f, -0.13481708f, 0.12976339f, 
    0.08271888f, -0.01009191f, -0.06217167f, 0.12928979f, -0.05376085f, -0.04321866f, -0.05699430f, 0.00858679f, 
    0.04475961f, 0.00553850f, 0.16979450f, 0.01802522f, 0.41893819f, 0.12784021f, -0.02971267f, 0.00736196f, 
    0.21424341f, -0.10009248f, -0.03429173f, -0.13312641f, 0.04633273f, 0.07094356f, -0.11335526f, -0.01708344f, 
    -0.03467560f, 0.04001168f, 0.00827182f, 0.00628272f, 0.04703777f, -0.08820086f, 0.02428729f, -0.04999291f, 
    -0.33343765f, -0.10282988f, 0.04803323f, -0.01052821f, -0.12754707f, 0.03550477f, 0.08992831f, 0.07366129f, 
    -0.03330671f, -0.11053279f, -0.02026673f, -0.02235821f, 0.01894343f, 0.02771611f, 0.02866748f, 0.01654521f, 
    0.05237846f, 0.08277206f, 0.02742078f, -0.01283690f, -0.21594763f, 0.17870864f, 0.08678117f, -0.01292714f, 
    -0.35412654f, 0.17904803f, 0.03158947f, -0.02479824f, 0.03271079f, -0.13945273f, -0.05100648f, 0.06710103f, 
    0.05053853f, -0.02919407f, -0.03027051f, -0.04899762f, -0.11290608f, -0.03023179f, 0.04325810f, 0.07450976f, 
    -0.39866081f, 0.02054844f, 0.20292807f, 0.03439913f, -0.10472651f, 0.09399788f, -0.09125219f, -0.00825593f, 
    -0.03720477f, -0.00424302f, 0.02393224f, 0.00333412f, 0.07650285f, 0.10603933f, 0.04438933f, -0.11176583f, 
    -0.13921872f, -0.11287225f, 0.03051787f, -0.01082162f, 0.38687006f, -0.08853523f, 0.11846298f, -0.04937205f, 
    0.23390043f, -0.11888883f, -0.13540488f, -0.02338076f, -0.04599401f, -0.03331400f, -0.01965339f, 0.03432254f, 
    0.02984848f, 0.08530238f, -0.13973124f, -0.02269480f, -0.07114396f, -0.06620047f, 0.03451978f, -0.01108759f, 
    0.28137228f, 0.28742170f, 0.08422109f, 0.27070317f, 0.24786934f, -0.15745270f, -0.15312193f, -0.03874129f, 
    0.03115872f, 0.04728248f, -0.03527672f, -0.07019711f, 0.16106033f, 0.00705582f, 0.15541904f, 0.11016726f, 
    0.09978073f, -0.00503923f, -0.00403694f, 0.07670238f, 0.18466985f, -0.10966978f, 0.16877818f, -0.06306957f, 
    0.10392357f, -0.02897440f, -0.05244479f, -0.05188402f, 0.00040987f, -0.14354739f, -0.00378177f, -0.04447200f, 
    0.00868937f, 0.07793007f, -0.00058419f, -0.05958686f, 0.03624012f, -0.07298648f, -0.13190459f, 0.00316098f, 
    -0.13158044f, 0.21825342f, -0.21529958f, -0.15174921f, -0.04708349f, -0.16819499f, -0.00499196f, 0.12744708f, 
    0.07394622f, -0.05268494f, 0.06029009f, 0.02837206f, -0.02055650f, -0.07223872f, 0.05786981f, 0.03940939f, 
    0.21575841f, 0.03152923f, -0.03189396f, 0.07215940f, -0.23385206f, 0.02548989f, 0.11605359f, -0.16180445f, 
    0.11249913f, 0.15838063f, -0.05520453f, -0.05149621f, 0.02794332f, 0.06702324f, -0.01419330f, 0.00854359f, 
    -0.12948245f, -0.05226865f, -0.08167057f, 0.03538095f, 0.14104021f, 0.02789300f, 0.11556032f, 0.00799614f, 
    -0.00515996f, 0.02396898f, 0.05769126f, 0.15188935f, 0.12867017f, 0.19048133f, -0.05894339f, 0.01240050f, 
    0.01057337f, 0.12237699f, -0.12922081f, 0.11519879f, 0.02571816f, -0.07787102f, 0.10148390f, -0.09995909f, 
    -0.07793104f, 0.05418354f, -0.03965932f, 0.11198568f, -0.14479995f, 0.10952500f, 0.00525959f, -0.00084762f, 
    0.10429348f, 0.04596869f, -0.09667152f, 0.01277698f, 0.01595278f, -0.00416413f, -0.00582892f, -0.07627618f, 
    -0.03506671f, 0.04651338f, -0.01232116f, 0.01794576f, -0.01437359f, 0.03808117f, -0.08092940f, 0.00214577f, 
    0.04224811f, 0.03163327f, 0.05356052f, -0.02220554f, -0.05050256f, 0.01389828f, 0.02219336f, 0.01635180f, 
    -0.03248301f, 0.02627410f, -0.05053725f, -0.01284709f, -0.04786691f, 0.03659657f, 0.04393464f, 0.00329727f, 
    -0.03683919f, 0.03609347f, -0.03938560f, -0.04082502f, 0.03454383f, 0.02230562f, -0.03557396f, 0.00323710f, 
    -0.00244944f, -0.00031350f, -0.02719925f, -0.04671510f, 0.00492970f, -0.04588250f, -0.01564207f, 0.02392273f, 
    -0.04669888f, -0.01638621f, -0.01835774f, 0.01371330f, -0.01683391f, 0.04063480f, -0.01330515f, 0.01751992f, 
    -0.02735039f, -0.03451791f, 0.01764158f, -0.01226518f, -0.04658147f, 0.02673306f, 0.01966942f, 0.03352664f, 
    0.05757779f, -0.00084869f, -0.03591509f, -0.03546124f, -0.03429457f, -0.02435009f, 0.02536740f, -0.02920036f, 
    0.04522999f, 0.02560998f, -0.00023985f, 0.01541129f, 0.02871882f, -0.02283699f, -0.00110438f, 0.01241957f, 
    0.01477766f, -0.02509139f, -0.03717007f, 0.03090112f, -0.01202225f, 0.04486354f, -0.05424641f, 0.01060093f, 
    0.03527531f, 0.01252738f, -0.00820691f, -0.01464311f, -0.04329190f, 0.04264885f, 0.02754402f, 0.02221073f, 
    0.00182179f, 0.02599302f, -0.03539566f, 0.03946880f, -0.04851693f, -0.02546247f, 0.02135303f, 0.01124911f, 
    -0.03364797f, 0.03400400f, -0.01379159f, -0.04240132f, -0.06018999f, -0.00592100f, 0.02562701f, 0.03264176f, 
    0.01343066f, -0.03663747f, 0.02642848f, -0.03189498f, -0.03804159f, -0.03676831f, -0.01747321f, -0.03370453f, 
    0.04642528f, 0.03062586f, 0.01906375f, -0.01392700f, -0.02787854f, 0.02287006f, 0.00863667f, 0.04106601f, 
    -0.00097015f, -0.00800138f, -0.05236524f, 0.01540265f, 0.03868133f, 0.04363639f, 0.01761350f, 0.02410181f, 
    0.05771098f, 0.00324620f, -0.05030992f, -0.03884115f, -0.01725193f, -0.06577222f, -0.00851736f, -0.00627746f, 
    -0.03440245f, -0.01266458f, 0.01320948f, -0.01845463f, 0.04967596f, -0.04902473f, -0.00056983f, -0.05621069f, 
    -0.05235351f, -0.07303224f, 0.03907035f, 0.02918472f, -0.00627983f, 0.01324317f, -0.01179654f, 0.03656579f, 
    0.02320018f, 0.00064678f, 0.04490477f, -0.00208605f, -0.04797783f, -0.03396638f, -0.02507897f, 0.02579300f, 
    0.03335208f, 0.00484298f, -0.03119619f, -0.03866401f, -0.05712834f, -0.00386853f, 0.01185411f, -0.05348019f, 
    0.03423330f, -0.01431253f, 0.00556381f, 0.02317676f, 0.02865933f, -0.02662669f, 0.02938723f, -0.06054993f, 
    -0.01375734f, -0.03768194f, -0.03334222f, 0.02942634f, 0.03146667f, -0.01316769f, -0.01975446f, 0.00400464f, 
    -0.04097173f, -0.04934105f, 0.01121515f, -0.03116682f, -0.01447568f, 0.04866296f, 0.00334849f, -0.04080244f, 
    0.00590981f, -0.03450494f, -0.05725319f, -0.01431804f, -0.02590738f, -0.02334703f, -0.06281028f, -0.06086752f, 
    -0.01261261f, -0.03383413f, 0.01448777f, -0.03701422f, -0.01175568f, 0.03409112f, -0.04663416f, -0.03831719f, 
    -0.02577559f, -0.00630783f, -0.01083945f, -0.01380834f, -0.00174513f, 0.04253127f, -0.04657269f, -0.00538074f, 
    -0.00607649f, -0.05319569f, 0.01281676f, -0.01998771f, 0.05349026f, 0.03862967f, -0.01508519f, -0.03500577f, 
    -0.05695294f, 0.02952983f, 0.03011841f, -0.00400499f, 0.01066438f, 0.02203310f, 0.03764473f, 0.03140743f, 
    0.00841209f, -0.00962588f, 0.01995899f, -0.02228592f, -0.02263029f, -0.04617889f, -0.03384065f, 0.04171823f, 
    -0.01330741f, -0.02819199f, -0.03003830f, 0.00992249f, 0.00184385f, -0.01706056f, -0.03162208f, 0.01718743f, 
    -0.04480293f, 0.03171975f, -0.03405219f, 0.04440234f, 0.02958913f, -0.01667378f, -0.03679737f, 0.03785738f, 
    -0.00079457f, 0.00476972f, -0.01933914f, -0.00059287f, 0.02443261f, -0.02674682f, -0.04195675f, -0.03581452f, 
    0.02914893f, -0.06246838f, -0.03917360f, 0.03644283f, 0.03547854f, -0.00975664f, 0.00661334f, 0.01946567f, 
    -0.00615830f, -0.02964627f, -0.05481640f, -0.00508690f, -0.05616278f, -0.03812620f, -0.01830816f, 0.01991513f, 
    -0.00105507f, 0.03123834f, -0.01321468f, -0.04350388f, -0.01309658f, -0.03584950f, 0.04017943f, -0.00750843f, 
    0.03605254f, -0.02688607f, -0.03922991f, -0.05335464f, 0.03473951f, -0.02344202f, -0.01953479f, -0.00970382f, 
    -0.00080210f, -0.03707472f, 0.01699616f, 0.02898989f, -0.02019438f, 0.01116296f, -0.02891974f, -0.00994905f, 
    0.00485495f, -0.00981092f, 0.01953717f, -0.02477127f, 0.03948938f, -0.00099970f, -0.02357696f, -0.04172942f, 
    -0.01600280f, 0.02052787f, -0.02159147f, 0.03339935f, 0.02818355f, 0.02635198f, -0.01469297f, -0.04903147f, 
    0.02408737f, -0.02888591f, 0.03667467f, -0.00100534f, 0.03901153f, 0.01634661f, 0.00529856f, -0.01538112f, 
    -0.03337451f, -0.01207530f, 0.05130694f, 0.02558480f, -0.04488388f, -0.05023519f, 0.04038127f, -0.03396698f, 
    -0.04368773f, 0.03684487f, 0.05529507f, 0.00287812f, -0.04366167f, -0.02484168f, 0.01654832f, 0.00092844f, 
    0.01042174f, 0.04786177f, -0.00706020f, 0.00379747f, -0.05734968f, -0.04062724f, -0.01013515f, 0.02876872f, 
    0.01388987f, -0.03417008f, -0.04158271f, -0.00204580f, 0.03018715f, -0.00243437f, -0.04989173f, -0.03696095f, 
    -0.01534269f, -0.01619731f, 0.01190085f, 0.03555546f, -0.01817168f, 0.01151490f, -0.03060646f, -0.05168967f, 
    -0.05707226f, -0.05927857f, 0.04056277f, -0.05735425f, 0.01252911f, 0.04867640f, -0.04883020f, -0.03178940f, 
    0.00867340f, 0.03504830f, -0.00122058f, -0.01201145f, 0.04393474f, -0.00570559f, 0.03935498f, 0.00493618f, 
    -0.01273144f, 0.00057045f, 0.00239225f, 0.01191386f, -0.03668689f, 0.01180582f, 0.03691798f, 0.04090865f, 
    0.00906339f, 0.01540406f, -0.04512836f, 0.01596719f, 0.00392560f, -0.00873759f, 0.01733663f, 0.04500964f, 
    -0.00529584f, -0.00862081f, -0.02906838f, -0.01449872f, 0.01297852f, -0.03290677f, -0.01054122f, -0.00103669f, 
    0.02860441f, 0.00205177f, -0.05067708f, 0.02628602f, 0.01678680f, -0.00420394f, 0.03106794f, -0.05070864f, 
    -0.03074475f, -0.06383289f, -0.00338084f, 0.03000990f, 0.01783962f, -0.05468447f, 0.02773795f, -0.03647892f, 
    0.00900433f, -0.02540682f, 0.00336980f, -0.02892657f, 0.03610662f, -0.06313614f, -0.02868013f, 0.00306403f, 
    0.05094779f, -0.04397450f, -0.05087020f, -0.03139136f, -0.04854537f, 0.04317198f, -0.03062502f, 0.03006128f, 
    -0.05167001f, 0.00651838f, 0.02994541f, -0.03062039f, 0.00654200f, 0.01246270f, -0.01888355f, -0.00358301f, 
    -0.04589689f, -0.02609953f, 0.04709093f, -0.01345103f, 0.03059933f, -0.00081256f, 0.01809708f, 0.01879578f, 
    0.03659395f, 0.00138300f, 0.02229350f, 0.03029759f, 0.03503487f, 0.01481339f, -0.03563069f, 0.04363242f, 
    -0.03274883f, 0.01156464f, -0.05638747f, -0.04811999f, -0.03647793f, -0.05871908f, 0.00850465f, -0.03119067f, 
    0.03026636f, 0.00885267f, 0.00506397f, 0.00274124f, 0.05207034f, -0.04930081f, 0.01162907f, -0.01343169f, 
    0.04261142f, -0.05471386f, 0.01411239f, -0.05042456f, 0.00258292f, -0.01140733f, -0.00063159f, 0.01845551f, 
    -0.04089687f, 0.03813669f, 0.01747805f, 0.01983346f, -0.04478080f, -0.05884447f, -0.04210142f, -0.02883806f, 
    -0.00739996f, 0.03865229f, -0.03523487f, -0.01687879f, 0.00325256f, 0.00102076f, -0.00059831f, 0.05284929f, 
    0.06062833f, 0.01193791f, -0.01437671f, -0.03212887f, -0.05962824f, -0.04868970f, 0.03426286f, 0.01177259f, 
    -0.04492969f, 0.00064915f, -0.02718044f, 0.05215731f, -0.03229631f, -0.05461476f, -0.01332248f, 0.04200660f, 
    -0.06188428f, 0.03877633f, 0.04634914f, 0.00458341f, 0.02241151f, 0.04251537f, -0.02876179f, 0.01595628f, 
    -0.04404280f, 0.01023844f, 0.03024029f, -0.05100162f, -0.00447251f, 0.04815583f, 0.04137000f, 0.02703842f, 
    0.03544208f, 0.04572208f, -0.05864849f, 0.04834430f, 0.01643693f, 0.02199841f, -0.05188166f, 0.00409192f, 
    -0.05932732f, -0.01239710f, 0.01975459f, -0.02261123f, -0.03393423f, -0.01576815f, -0.00280206f, 0.00174050f, 
    -0.00520497f, 0.01901611f, 0.01647495f, 0.04696400f, -0.03893834f, -0.00768368f, 0.00227272f, -0.02379802f, 
    -0.03862109f, 0.02322449f, -0.04969638f, -0.03932315f, -0.01903002f, 0.02062150f, -0.00550062f, 0.04109473f, 
    0.00133511f, -0.02338884f, 0.03745155f, 0.01181615f, -0.05091865f, 0.02991419f, -0.01084764f, 0.02973524f, 
    -0.01695303f, 0.00554013f, -0.00071567f, 0.05678413f, -0.04482209f, -0.01857833f, -0.00157790f, 0.00500430f, 
    -0.03570526f, -0.03376415f, 0.01551038f, -0.01295255f, -0.05177736f, -0.02130561f, -0.05190573f, 0.01492401f, 
    0.04285547f, 0.03088957f, 0.00561400f, -0.03756766f, -0.04088891f, 0.05290537f, -0.03519933f, -0.04568319f, 
    -0.01069103f, 0.03160659f, -0.03130046f, 0.01338137f, -0.04911865f, 0.00761117f, -0.04976508f, -0.00026631f, 
    -0.04010861f, -0.04892889f, -0.00856115f, -0.03062636f, -0.01577943f, 0.01298674f, -0.02405815f, 0.00971447f, 
    -0.04620732f, -0.03533931f, -0.05665282f, 0.03299304f, 0.01162586f, 0.04804678f, 0.03608550f, -0.04266204f, 
    0.01625099f, 0.00176267f, -0.00296447f, -0.03442064f, -0.03672625f, 0.03156771f, 0.00348702f, -0.04026424f, 
    -0.03937877f, -0.03731266f, -0.02415583f, -0.00993553f, 0.03909979f, 0.04463573f, 0.02660672f, 0.00744760f, 
    -0.01814148f, 0.01123698f, -0.00017247f, -0.00551320f, -0.04817170f, -0.00560399f, 0.00736733f, -0.04626554f, 
    -0.02276365f, 0.03300485f, 0.03080104f, 0.02428491f, 0.00415894f, 0.02666054f, -0.01801257f, -0.03390147f, 
    -0.03774897f, -0.01234975f, -0.04497594f, -0.05504789f, -0.00976693f, -0.03830028f, 0.03398175f, -0.00738053f, 
    -0.01580240f, -0.01877659f, 0.04827913f, -0.00624253f, 0.05287534f, 0.03637737f, -0.04301022f, -0.04625036f, 
    0.02035681f, -0.04755481f, 0.04321778f, -0.04511096f, -0.00649418f, 0.02280960f, -0.05666546f, 0.02574446f, 
    0.02775033f, -0.02479339f, -0.05295707f, -0.03431100f, 0.00413011f, 0.02546253f, 0.04959333f, -0.05911766f, 
    0.03244778f, 0.00647442f, -0.01418352f, 0.01382987f, 0.00985618f, -0.04998060f, -0.03012629f, -0.04436668f, 
    -0.04163638f, -0.00579436f, -0.01453756f, 0.03518454f, -0.04841628f, -0.05142070f, -0.01577301f, 0.00385063f, 
    0.02288159f, 0.04111145f, -0.00077637f, 0.04745279f, 0.03266354f, -0.01798053f, 0.00412905f, -0.00021891f, 
    -0.01397868f, -0.05396399f, -0.05922629f, 0.01477353f, 0.02502294f, -0.02720072f, -0.04587987f, 0.03976742f, 
    -0.03069479f, 0.02544245f, 0.00884784f, 0.02068314f, 0.03198385f, -0.00520550f, 0.04334305f, 0.00666491f, 
    -0.04877178f, -0.00582392f, -0.00877783f, -0.05226783f, -0.04429374f, 0.00508799f, 0.00566912f, -0.05970101f, 
    -0.03037996f, -0.03022366f, 0.02253854f, 0.02117602f, -0.01621926f, 0.02250297f, -0.03680529f, -0.01012030f, 
    0.00966047f, -0.04850028f, -0.05434976f, -0.04110998f, 0.03736600f, -0.04811292f, -0.04669230f, -0.03836857f, 
    -0.01065377f, 0.02496118f, 0.03300335f, 0.03135057f, -0.00529209f, 0.04756080f, 0.03662546f, 0.02905661f, 
    -0.03827092f, 0.03606668f, -0.01438420f, -0.03373571f, 0.04744904f, -0.03883426f, 0.01466622f, 0.02674296f, 
    -0.00797735f, 0.03865101f, -0.01100974f, 0.02777769f, 0.01377964f, -0.03580723f, -0.03715383f, 0.00460460f, 
    -0.00804122f, 0.01488571f, -0.04181759f, -0.03100268f, 0.02968674f, 0.04021839f, -0.01700243f, -0.04087643f, 
    -0.03641823f, -0.00183682f, 0.04960254f, -0.04290712f, -0.02654758f, -0.02459628f, 0.00164547f, -0.05173839f, 
    -0.04821661f, -0.05974443f, -0.05183914f, 0.01773728f, 0.03805322f, 0.01332114f, -0.01299664f, -0.05383698f, 
    0.01143244f, -0.05383224f, -0.01202840f, -0.02398855f, -0.01931212f, 0.00197644f, -0.00607363f, -0.05555136f, 
    0.03750859f, -0.03756152f, 0.03344474f, 0.03164734f, -0.00483022f, -0.05164157f, 0.03191731f, -0.05548415f, 
    -0.02079400f, -0.05350160f, 0.01691846f, -0.01059848f, 0.05038032f, 0.03585156f, -0.05269353f, -0.02224729f, 
    0.01917930f, 0.02839851f, 0.04540655f, 0.03442046f, 0.04682112f, 0.01302160f, -0.04553895f, 0.04281085f, 
    0.04532344f, -0.00150900f, 0.03645623f, -0.03216406f, -0.00696397f, -0.01737276f, -0.04133419f, 0.03586739f, 
    0.02776110f, -0.02295262f, -0.02688578f, 0.01720490f, 0.02530633f, -0.02302670f, 0.01498726f, -0.02476697f, 
    -0.03645742f, -0.02895819f, -0.04798187f, -0.00814336f, -0.05210037f, 0.00605445f, -0.02565369f, 0.04335429f, 
    0.04649027f, 0.01571150f, -0.01202163f, 0.04067011f, 0.01194131f, -0.05184679f, -0.02457774f, 0.00506954f, 
    -0.00130431f, -0.03278182f, 0.02075454f, -0.03393510f, 0.00417991f, -0.03424860f, -0.05064401f, -0.02601436f, 
    0.03194559f, 0.05257359f, -0.03413469f, 0.01852478f, -0.02608199f, -0.01816504f, 0.03706029f, -0.01658715f, 
    0.03858317f, 0.04698101f, 0.04127349f, 0.01355210f, 0.01894461f, -0.01033612f, -0.03032401f, -0.02810046f, 
    0.01745268f, -0.05920232f, -0.05891347f, -0.00703223f, -0.03450712f, -0.06128974f, 0.03335417f, 0.03422914f, 
    0.01113303f, 0.01360537f, -0.00248842f, 0.02885171f, -0.03810548f, -0.02142000f, -0.01858137f, 0.01515462f, 
    0.04220074f, 0.01803736f, 0.01792538f, 0.02722986f, -0.03782757f, -0.03074729f, -0.00793896f, 0.04938865f, 
    -0.00499464f, 0.01293987f, -0.00950623f, 0.00863120f, 0.01391508f, 0.00311450f, -0.01728328f, -0.01676052f, 
    -0.02791689f, -0.00808144f, -0.05691317f, -0.04839893f, -0.05037057f, 0.00672037f, 0.04694216f, 0.01100018f, 
    -0.02728919f, -0.03999026f, -0.02675961f, 0.04332027f, 0.01247843f, 0.02115669f, 0.01484071f, -0.05137504f, 
    0.04762086f, -0.03287916f, 0.00486955f, 0.02312442f, 0.00579492f, 0.01594893f, -0.01710618f, -0.00073659f, 
    -0.01819626f, 0.01040751f, -0.01256895f, 0.00109020f, -0.01041769f, -0.04226699f, -0.05893894f, 0.02208648f, 
    -0.04984529f, -0.02563341f, 0.04919611f, -0.05808384f, -0.00153116f, 0.03001604f, 0.03410414f, 0.01149696f, 
    0.03581234f, -0.05415489f, -0.02498187f, -0.03985972f, -0.03891446f, -0.01229512f, -0.04541986f, 0.04275382f, 
    -0.04469218f, -0.01685344f, -0.04145950f, -0.06092021f, 0.00841605f, 0.02341315f, -0.00773770f, -0.03701114f, 
    0.01955444f, -0.04321142f, 0.02473842f, 0.02948482f, -0.02734688f, 0.05237500f, -0.01191010f, -0.01681522f, 
    -0.06393698f, 0.00155181f, -0.00240514f, -0.04992302f, 0.01698297f, 0.05999286f, 0.04225288f, -0.02599887f, 
    -0.02974958f, 0.02855488f, -0.02023818f, -0.02273756f, -0.00526539f, 0.02526107f, 0.00839602f, -0.01403185f, 
    0.00562229f, -0.01210861f, 0.01291594f, -0.01609575f, -0.05033530f, -0.00589740f, -0.05440042f, -0.03289247f, 
    0.03682921f, 0.02694520f, -0.04980749f, 0.00056495f, -0.03848414f, -0.02915540f, -0.01954957f, 0.02182739f, 
    -0.01343331f, 0.01336542f, -0.05886130f, 0.02286580f, 0.03507470f, -0.04540470f, 0.01994921f, -0.02449611f, 
    0.04963244f, -0.02044913f, -0.03040067f, 0.03046972f, -0.02861007f, -0.00407995f, 0.03230105f, -0.06431174f, 
    0.00300655f, -0.05484021f, -0.00371908f, -0.04778621f, -0.00264060f, 0.03584007f, 0.00135912f, -0.04589942f, 
    -0.04022388f, -0.02753609f, -0.05278815f, -0.00274510f, -0.03728579f, -0.05333566f, 0.03467949f, -0.02611532f, 
    -0.05444299f, 0.03670528f, -0.04518784f, 0.01954825f, -0.02867860f, 0.04020428f, 0.01928556f, -0.01307492f, 
    -0.00960538f, 0.02161396f, -0.04020615f, -0.04200387f, -0.05447007f, -0.01411674f, -0.02548194f, -0.01080533f, 
    -0.00536634f, -0.00618587f, -0.05221916f, -0.02698217f, -0.01913064f, -0.02784763f, -0.03154211f, -0.00478636f, 
    -0.03706492f, -0.00157121f, 0.04521342f, 0.05079637f, 0.00057076f, -0.06121377f, -0.00057890f, 0.00485344f, 
    -0.04777216f, 0.03061594f, -0.04719085f, -0.00518821f, -0.00100789f, 0.03268936f, 0.00697370f, -0.04343260f, 
    -0.01963648f, -0.00422142f, 0.01323625f, 0.03043810f, 0.02138715f, -0.00174767f, 0.03388253f, 0.01449946f, 
    0.03876269f, -0.04147343f, -0.00833526f, 0.04094495f, -0.01580800f, -0.06661329f, 0.01286285f, 0.00381019f, 
    0.03302744f, -0.04427620f, 0.01196897f, 0.04397836f, -0.01870202f, 0.02789599f, 0.00831302f, 0.00984297f, 
    -0.05799934f, -0.03752134f, 0.03924631f, 0.01148455f, -0.04851615f, 0.00720923f, 0.06006049f, 0.01893750f, 
    -0.06566553f, 0.02826448f, -0.03426224f, 0.04209714f, -0.05532725f, 0.03048440f, -0.06135388f, -0.04419050f, 
    -0.02947869f, 0.02283882f, -0.03455801f, -0.00739958f, -0.01652489f, -0.05959978f, 0.01998984f, 0.02738584f, 
    -0.03053642f, -0.04136017f, 0.03344874f, -0.03571868f, 0.01679086f, -0.00656264f, -0.03585631f, -0.03390737f, 
    0.02348510f, -0.02412379f, -0.00146346f, 0.01643240f, -0.04770967f, 0.02988217f, -0.06023579f, -0.04626155f, 
    0.02426483f, -0.06514276f, -0.01505113f, -0.05968466f, -0.00103386f, 0.04582971f, 0.01366021f, -0.05226066f, 
    0.03984357f, -0.05727294f, -0.01867487f, -0.02315441f, 0.01270402f, -0.05057159f, 0.01005254f, 0.02352199f, 
    0.01025194f, 0.01070427f, -0.00489228f, -0.01050933f, -0.04542327f, -0.03885164f, -0.03898958f, 0.04401514f, 
    -0.00537891f, 0.01375417f, -0.02327076f, -0.04828275f, -0.03497644f, 0.04845112f, -0.02685516f, 0.02963063f, 
    -0.03747389f, 0.03755897f, -0.00041872f, -0.03402732f, -0.04142854f, -0.00995333f, -0.03978666f, -0.05783859f, 
    -0.00913476f, 0.03916822f, -0.04040286f, -0.01307413f, -0.04510739f, 0.01816461f, -0.02438564f, -0.01132343f, 
    -0.01292516f, 0.03014203f, 0.02779129f, -0.01669275f, -0.00149513f, 0.04708367f, -0.01175705f, 0.01216663f, 
    0.04042469f, -0.00539967f, 0.01581808f, -0.03088068f, 0.02280701f, 0.02528906f, 0.02594438f, -0.05954980f, 
    -0.02259428f, 0.05319478f, -0.04026244f, 0.03728034f, -0.01474743f, -0.00708404f, -0.03390942f, 0.03694622f, 
    -0.03440958f, 0.02896666f, -0.01343321f, 0.02781402f, -0.04466376f, -0.00342681f, -0.01536447f, -0.01860953f, 
    0.03747803f, -0.04967827f, -0.02430173f, -0.04664659f, -0.04499614f, 0.01935702f, 0.06010865f, -0.06243536f, 
    0.02648311f, -0.04641334f, -0.02589948f, -0.03396570f, -0.06405337f, -0.03030570f, 0.03682479f, -0.02233762f, 
    0.01530703f, -0.05337840f, -0.00343037f, 0.04049735f, -0.00432638f, -0.04777977f, -0.02221719f, 0.02190675f, 
    0.02871302f, 0.02285065f, -0.01215373f, -0.00175930f, -0.03145519f, -0.05302395f, -0.01702648f, 0.02692843f, 
    -0.03998439f, 0.02317605f, 0.01230944f, -0.00280032f, -0.00401203f, 0.02534029f, 0.02659624f, -0.00647210f, 
    -0.04202601f, -0.04803412f, 0.02169747f, 0.04728058f, 0.00263051f, 0.00271079f, 0.03325454f, -0.04961934f, 
    -0.05015033f, 0.02494758f, 0.02601401f, -0.00591703f, -0.02809090f, 0.02039263f, 0.03544273f, 0.00253207f, 
    -0.36311793f, 0.01994856f, -0.32249257f, -0.32432640f, 0.07726081f, 0.06008674f, -0.04323755f, -0.04844042f, 
    0.07867721f, -0.06834735f, 0.04404344f, 0.13265745f, 0.10395350f, -0.08587775f, -0.06391761f, -0.01294876f, 
    -0.03047176f, 0.15943275f, 0.06544879f, 0.04097947f, 0.26608077f, 0.27798042f, -0.06952140f, -0.05869341f, 
    -0.08089569f, -0.07108121f, -0.00444197f, -0.03746882f, -0.03530127f, -0.07895144f, -0.00742243f, -0.07027689f, 
    -0.07094761f, -0.06874613f, -0.15401916f, -0.10310531f, 0.03438085f, -0.03525157f, 0.05296308f, 0.10179851f, 
    0.11872242f, 0.05882350f, 0.22182922f, 0.06424614f, 0.11242458f, 0.10017676f, 0.07609645f, -0.07938720f, 
    -0.02584898f, 0.20023014f, -0.06109109f, 0.09972929f, -0.03598439f, 0.07426295f, -0.12473085f, -0.02952964f, 
    -0.06791832f, -0.03800724f, -0.01374828f, 0.08379217f, 0.21773960f, 0.08999711f, 0.35994196f, 0.06481502f, 
    0.08062695f, 0.07016156f, 0.04888305f, 0.07434254f, -0.07725042f, 0.14915058f, -0.04853983f, -0.12392911f, 
    0.02592146f, 0.03541441f, 0.11500888f, -0.01798927f, -0.01855755f, 0.02185590f, 0.06455106f, 0.00020219f, 
    0.37425297f, -0.03412545f, 0.06280678f, -0.11372998f, 0.03352189f, 0.00369263f, 0.02784768f, -0.02272996f, 
    0.08243962f, -0.00197648f, 0.02345351f, -0.04212413f, 0.06360270f, 0.10761501f, -0.06021548f, 0.10716375f, 
    -0.03997687f, 0.08918937f, -0.06533361f, -0.07458481f, -0.00316474f, 0.11763489f, -0.02139919f, 0.03006233f, 
    -0.11855100f, 0.05834934f, -0.10297524f, 0.02087565f, 0.05741233f, -0.11960002f, 0.04767066f, 0.05034830f, 
    -0.00336359f, -0.12053979f, -0.02040694f, 0.02314941f, 0.07678454f, -0.10516960f, -0.02851443f, -0.16718499f, 
    0.22175728f, -0.36362246f, 0.09761954f, 0.10942335f, 0.05253825f, 0.08576823f, 0.11950021f, -0.01364718f, 
    -0.14181799f, 0.11264972f, -0.00441049f, 0.07355493f, -0.01957049f, 0.04832197f, 0.09784503f, 0.02999227f, 
    0.08482001f, -0.05951076f, -0.13293546f, -0.06660522f, 0.24479192f, -0.28701836f, 0.20553726f, 0.04840357f, 
    0.22583562f, -0.01490168f, 0.07414369f, 0.08966409f, -0.06860962f, 0.03879568f, 0.01242191f, 0.02720571f, 
    0.02413745f, 0.12370879f, 0.14684314f, -0.06291924f, 0.07852627f, 0.02760657f, 0.10776710f, 0.11204860f, 
    -0.03824006f, -0.08228617f, -0.00001221f, -0.14787364f, 0.21092486f, -0.07089221f, 0.03733961f, 0.00891547f, 
    -0.01929230f, -0.07274225f, -0.06703813f, 0.00977990f, -0.14900509f, -0.07935829f, 0.06054509f, 0.06667936f, 
    0.05692896f, 0.10006647f, 0.11286798f, -0.09311123f, 0.17716797f, 0.08856593f, 0.04943692f, -0.17868952f, 
    0.02639805f, -0.02969412f, 0.09140588f, -0.02146484f, -0.00406221f, -0.10837970f, -0.11431876f, -0.00389031f, 
    -0.03885916f, -0.00369526f, -0.04361375f, 0.07896554f, -0.06749462f, 0.09785601f, 0.16046971f, -0.00143216f, 
    0.22915003f, 0.18185277f, -0.00861393f, 0.07627553f, 0.23014274f, 0.00913696f, -0.00377119f, -0.05994351f, 
    0.03212477f, -0.05990154f, 0.02293302f, -0.01748187f, -0.00935543f, -0.14698367f, 0.11025135f, 0.12143457f, 
    0.15440448f, 0.00333737f, 0.02786409f, -0.15272339f, 0.48056966f, -0.15690707f, 0.02883377f, -0.09844534f, 
    0.03783957f, 0.01614644f, 0.00328552f, 0.07946351f, 0.11452799f, -0.03170694f, -0.10270215f, 0.13313079f, 
    0.00064637f, 0.17387190f, -0.00408037f, 0.06426945f, -0.08710068f, 0.03093985f, 0.02328368f, -0.04565590f, 
    -0.01429456f, -0.13855813f, 0.26688960f, -0.01545656f, 0.17362493f, -0.12645641f, 0.09455571f, -0.10937580f, 
    -0.07448500f, -0.00971973f, -0.07505739f, 0.00890619f, -0.14436726f, 0.08735725f, 0.00195971f, -0.09504679f, 
    -0.02198114f, 0.04006835f, -0.00396244f, 0.09470765f, -0.01839304f, -0.12550589f, 0.25645775f, 0.02311001f, 
    -0.03782934f, -0.05624467f, 0.02988316f, 0.03323108f, 0.00307800f, -0.05169351f, 0.04869027f, 0.01836227f, 
    0.09299099f, 0.07600091f, 0.02991890f, 0.05508642f, 0.00294859f, 0.06889339f, 0.02402206f, -0.04763557f, 
    -0.10387663f, 0.04622911f, -0.09675398f, -0.29487053f, -0.11111485f, -0.05758944f, 0.04674453f, 0.01014519f, 
    -0.11160472f, 0.04083363f, 0.00970375f, -0.03397353f, -0.04638025f, 0.02381379f, -0.08921184f, 0.00483832f, 
    -0.00481564f, 0.07608578f, 0.13236740f, 0.08558249f, 0.18937203f, -0.29148388f, 0.15929359f, -0.25504839f, 
    -0.04768126f, 0.10877752f, -0.05537720f, -0.02118388f, -0.20733979f, 0.01627061f, -0.05336873f, 0.01750259f, 
    -0.04029901f, -0.05864090f, -0.06922402f, 0.07216720f, 0.09528290f, -0.03823585f, 0.03380178f, -0.02181522f, 
    -0.12688401f, -0.15340869f, 0.33138379f, -0.03553512f, -0.34008902f, -0.14183207f, 0.09426619f, 0.07504523f, 
    -0.05410663f, 0.03489664f, -0.05759874f, -0.17120768f, -0.12516968f, -0.05251434f, 0.13981196f, -0.08888560f, 
    0.06436726f, -0.02228985f, 0.01574630f, 0.04936815f, -0.22045432f, -0.01853848f, 0.30079424f, 0.00843435f, 
    0.15576461f, 0.11794889f, 0.18672678f, 0.05019145f, -0.08957376f, 0.06918410f, -0.02668826f, 0.01900586f, 
    0.15208796f, 0.06069579f, 0.11831445f, -0.03149097f, 0.09375415f, 0.00283823f, 0.02358464f, -0.02966426f, 
    -0.27189672f, -0.04452549f, -0.10518234f, 0.02318708f, 0.04444326f, 0.01663224f, -0.07719620f, -0.07678872f, 
    0.09515806f, 0.04340411f, 0.03261501f, 0.06959105f, 0.10376713f, -0.05959134f, 0.09297705f, 0.01484943f, 
    0.07369179f, -0.02704585f, 0.00442044f, 0.19096658f, -0.11269455f, -0.21984133f, -0.17990488f, 0.18226965f, 
    -0.09891826f, 0.01997229f, 0.10784163f, -0.02590989f, 0.13025521f, -0.02087656f, 0.01461783f, 0.13038500f, 
    -0.04758024f, 0.02726929f, 0.02013317f, -0.06953654f, -0.01368150f, 0.12837522f, -0.04031864f, -0.00789706f, 
    -0.15305890f, 0.10757095f, 0.05988082f, -0.26716277f, -0.10894525f, -0.04091777f, 0.05051038f, -0.07278106f, 
    0.05597957f, 0.04344221f, 0.04305582f, 0.04728766f, 0.02752932f, 0.00017917f, 0.05447550f, -0.12828608f, 
    0.07902033f, -0.05161526f, 0.06114862f, -0.02946147f, 0.11704706f, -0.14399287f, 0.11799446f, 0.07853069f, 
    0.14064385f, 0.08772025f, -0.04160663f, 0.08019080f, -0.03785618f, 0.04566015f, 0.08713202f, 0.00163545f, 
    0.02442916f, 0.08496492f, 0.06083279f, 0.01266528f, -0.09745219f, 0.10226600f, 0.14024481f, 0.05303325f, 
    0.23201153f, 0.19469450f, -0.11121730f, 0.00767349f, 0.10470012f, -0.05995731f, -0.07363331f, 0.04179984f, 
    0.02284979f, 0.02344917f, 0.06050346f, -0.05973023f, -0.02110202f, -0.04228687f, 0.02846878f, 0.06918334f, 
    0.03778750f, 0.01387154f, 0.13089743f, -0.01051519f, -0.15380563f, -0.06012522f, -0.23368937f, -0.18109766f, 
    -0.05428210f, -0.00159479f, -0.10725080f, -0.05427245f, -0.07496877f, 0.02864882f, 0.13672476f, -0.05748106f, 
    -0.09519920f, -0.01180892f, -0.00961905f, 0.06923303f, 0.07997306f, -0.01731399f, 0.03198021f, -0.02305454f, 
    0.09683561f, -0.08649058f, -0.02165896f, 0.08934550f, -0.12493967f, 0.03401278f, 0.11181203f, 0.12348047f, 
    -0.03840127f, -0.01927099f, 0.11261362f, 0.05659790f, 0.11450312f, 0.03841405f, 0.02797600f, -0.08215381f, 
    -0.08758996f, -0.18047465f, -0.07621668f, 0.16354059f, -0.08797988f, 0.20289062f, -0.15193023f, 0.10671109f, 
    -0.40496966f, -0.05844890f, 0.03846000f, -0.05040459f, 0.04349000f, -0.01406562f, 0.02763190f, -0.12080355f, 
    0.08138081f, 0.06419555f, 0.11077144f, -0.04285227f, -0.05689840f, -0.07529320f, 0.07177125f, 0.01807187f, 
    0.07670516f, 0.17878439f, 0.07699928f, 0.10439424f, 0.08648204f, 0.17002659f, 0.15516204f, -0.12412776f, 
    0.09426259f, -0.11712310f, 0.04808426f, 0.07393101f, -0.06412861f, 0.13693842f, -0.12581868f, -0.03700947f, 
    -0.00113392f, 0.06225584f, 0.11243709f, 0.08021585f, -0.08515025f, 0.50145417f, 0.00537013f, 0.13155533f, 
    0.03677863f, 0.08940403f, -0.05106382f, 0.01619106f, -0.04171787f, -0.05382043f, 0.12260441f, -0.01214293f, 
    -0.03103966f, 0.07585601f, 0.14322813f, 0.00348829f, -0.03942994f, 0.10620122f, 0.15092684f, -0.00233351f, 
    -0.47198457f, -0.05210575f, 0.01970737f, -0.01329428f, -0.16455863f, 0.16765089f, 0.00708951f, 0.00733924f, 
    0.01512119f, 0.18671577f, 0.13045608f, 0.06634603f, 0.01263865f, 0.02958266f, 0.09016648f, 0.08811412f, 
    -0.07346079f, -0.04080594f, 0.09335509f, 0.03359194f, -0.18278690f, -0.01386228f, -0.25492889f, 0.07584225f, 
    -0.05750119f, -0.01548638f, 0.04435039f, 0.08370202f, -0.00554399f, 0.15673442f, 0.01840007f, 0.02884614f, 
    -0.08230292f, -0.07804184f, 0.10755129f, 0.00360433f, 0.07606024f, 0.06590856f, -0.07292463f, -0.02432367f, 
    0.01507852f, -0.11643016f, 0.09780613f, 0.13614163f, -0.17994207f, -0.00097636f, 0.17069730f, 0.03401848f, 
    0.15162878f, 0.00314286f, 0.07312661f, 0.13378094f, 0.01798764f, 0.03539399f, 0.01634307f, -0.00534585f, 
    0.10832397f, -0.01764053f, -0.06567070f, -0.08822059f, 0.30483165f, -0.06110857f, 0.09541431f, 0.17311056f, 
    0.03117246f, -0.05090618f, 0.05245591f, 0.05697233f, 0.10894313f, -0.10348266f, 0.03170196f, 0.01591858f, 
    0.06472649f, 0.02725005f, 0.12128051f, 0.03819084f, -0.06644602f, 0.01869074f, -0.02326908f, -0.01364443f, 
    -0.10589321f, -0.20982052f, 0.35987532f, -0.02967165f, 0.21686496f, -0.05313512f, 0.10324443f, -0.11980531f, 
    -0.11676541f, 0.02093113f, 0.06497402f, 0.08201025f, -0.01709617f, 0.00502968f, 0.08547169f, 0.04635947f, 
    0.08454122f, 0.38919571f, 0.17710817f, 0.15291037f, -0.06932087f, -0.18625367f, 0.01164715f, -0.19215922f, 
    0.16408382f, -0.14063619f, -0.03141584f, -0.09973656f, -0.16678181f, 0.00729536f, 0.12765442f, 0.05536515f, 
    -0.00187689f, -0.11556391f, -0.01602345f, 0.01223380f, -0.18984845f, -0.15960160f, 0.03254166f, -0.01413127f, 
    0.06614378f, 0.07339788f, 0.00974412f, -0.15666047f, 0.10430475f, 0.09610678f, -0.04821793f, -0.12175386f, 
    0.16339682f, 0.04965201f, -0.00066050f, 0.07511577f, -0.02325484f, 0.04462552f, 0.05500813f, -0.07155417f, 
    -0.03451605f, 0.11213441f, -0.03135002f, -0.02220488f, 0.07948159f, 0.18632039f, -0.17533480f, 0.22859383f, 
    -0.06316373f, 0.00985052f, -0.01095414f, -0.08097462f, -0.02738932f, 0.04317243f, 0.00852508f, -0.00513231f, 
    -0.02288765f, -0.04400375f, 0.03707970f, -0.02807283f, 0.01996296f, 0.09763440f, 0.19533695f, -0.04818669f, 
    0.34443632f, 0.30037868f, 0.05468078f, -0.16855416f, 0.08597429f, -0.14030753f, 0.04775872f, -0.07827491f, 
    0.06238594f, -0.01551130f, 0.01222482f, 0.01613885f, -0.11314074f, 0.12859887f, -0.00141364f, -0.04969041f, 
    0.04302895f, -0.09169799f, -0.14210436f, 0.10866285f, 0.34700748f, -0.25445694f, -0.14201708f, -0.18963759f, 
    0.14130399f, -0.23589933f, -0.03276049f, -0.00387814f, -0.12048806f, -0.02913200f, -0.00686057f, 0.00019448f, 
    0.18089718f, -0.07828236f, 0.11103460f, 0.05526844f, 0.17283322f, -0.25519755f, -0.18080884f, -0.00589867f, 
    0.13196948f, 0.13221051f, 0.05957676f, -0.12551703f, 0.06795068f, 0.07555825f, 0.03699593f, 0.01729821f, 
    0.14608553f, 0.08058774f, 0.06299880f, -0.07385814f, -0.03165785f, 0.08541313f, 0.11163937f, 0.06780136f, 
    0.19423085f, -0.09157403f, 0.07154470f, -0.10434157f, -0.09295911f, 0.08420978f, 0.21115434f, -0.15514712f, 
    -0.17247631f, 0.03822832f, -0.00594945f, -0.08199662f, 0.12714803f, 0.07802917f, 0.02333357f, 0.17894757f, 
    -0.11212318f, 0.11042064f, 0.01368047f, 0.06590684f, -0.00232344f, -0.05616088f, 0.07307212f, 0.04298632f, 
    -0.12470236f, -0.20494466f, -0.06407487f, -0.09211025f, -0.04802039f, 0.01077711f, 0.02704126f, -0.00425314f, 
    0.00829269f, -0.08370503f, 0.01805126f, 0.05262103f, -0.15272458f, -0.05402011f, 0.02886555f, 0.04296465f, 
    -0.01792024f, 0.02265759f, 0.15761343f, -0.02499734f, 0.24803476f, 0.37963429f, -0.13667324f, 0.06749237f, 
    -0.22553188f, 0.01965777f, 0.06554008f, 0.10997180f, -0.14008240f, -0.08396051f, -0.17512880f, 0.01921634f, 
    -0.01475945f, -0.04308213f, 0.01179352f, 0.04988938f, 0.06156216f, 0.07571404f, -0.07987653f, 0.00354355f, 
    0.01283463f, -0.07375901f, -0.17213157f, -0.27912733f, -0.10290907f, -0.05844808f, 0.08760999f, 0.07411199f, 
    -0.02665529f, -0.17193399f, 0.03144823f, 0.05983951f, 0.12162229f, 0.10029717f, -0.01775497f, 0.01079053f, 
    0.19194594f, -0.21926808f, -0.32228673f, -0.03139039f, -0.17677264f, 0.26823506f, -0.18997326f, -0.19515342f, 
    -0.17719668f, 0.05649743f, 0.03105592f, 0.00187771f, -0.08445808f, 0.12344923f, -0.02783097f, -0.01444737f, 
    0.20137423f, 0.11724761f, 0.13721037f, 0.13275620f, 0.05533684f, -0.18183304f, -0.20779553f, -0.03856263f, 
    -0.04244396f, -0.11670814f, 0.09574866f, 0.18807773f, -0.00137430f, 0.04754576f, -0.04168518f, 0.00006637f, 
    0.19745749f, 0.12467517f, 0.01938379f, -0.06632648f, -0.17335804f, 0.09773432f, 0.12736435f, 0.20615675f, 
    0.02117227f, 0.13677840f, -0.02778990f, 0.13154319f, 0.14405374f, -0.08938370f, -0.17994349f, 0.23454373f, 
    -0.11845894f, -0.00414779f, -0.05719827f, -0.04674663f, 0.10056964f, -0.00523520f, -0.06407630f, -0.05231894f, 
    0.13552664f, -0.02604357f, -0.00106345f, 0.05998870f, 0.04435880f, 0.12501562f, 0.16680843f, 0.02149049f, 
    0.09134106f, -0.19387966f, -0.03289445f, 0.26090759f, -0.12147789f, -0.07688434f, -0.04521030f, -0.10803476f, 
    -0.08624662f, 0.00331518f, -0.00464185f, 0.10277313f, -0.12367807f, -0.07416257f, -0.03623730f, 0.01023459f, 
    0.01536673f, -0.03625390f, 0.15239023f, 0.03591148f, -0.06546844f, 0.05446931f, 0.07447736f, 0.37959826f, 
    0.21996015f, -0.02927032f, 0.08515114f, 0.06766424f, -0.05999277f, -0.05167222f, -0.06193497f, -0.01910292f, 
    -0.00616113f, -0.04515842f, -0.01955459f, 0.11053810f, 0.09645140f, -0.30144104f, 0.07403298f, 0.03804751f, 
    0.09903345f, 0.00696749f, 0.21228991f, 0.44254789f, 0.14395955f, -0.07034228f, 0.20524757f, -0.08692049f, 
    -0.04101286f, -0.07732678f, -0.00434160f, 0.08049961f, -0.00576832f, 0.03085550f, -0.02530157f, -0.00836667f, 
    0.03565023f, 0.22893272f, 0.20568888f, 0.06690424f, -0.34852231f, -0.04258832f, -0.14737572f, -0.14644650f, 
    -0.04778276f, -0.04336348f, -0.08494309f, -0.09712680f, 0.00586155f, 0.00725156f, 0.14867744f, -0.00622545f, 
    -0.12317422f, -0.05057317f, -0.10058427f, 0.01743815f, -0.13172854f, -0.00701950f, 0.05318211f, -0.06047376f, 
    -0.06253016f, 0.05550632f, 0.08799828f, -0.14318380f, 0.07676780f, -0.00944100f, -0.02661561f, -0.00745572f, 
    -0.00935381f, -0.11095829f, 0.02742098f, 0.17169140f, -0.03895148f, 0.01690642f, 0.04187000f, -0.06202773f, 
    -0.06011629f, 0.12666760f, -0.11152296f, -0.05682637f, -0.14379965f, 0.14749363f, 0.00950553f, -0.04290279f, 
    0.17285299f, 0.14819549f, 0.03748618f, -0.01041822f, 0.02681554f, 0.07361750f, 0.08522812f, 0.02194745f, 
    0.07189021f, -0.02287799f, -0.06221520f, 0.00760546f, 0.01785821f, -0.06059708f, 0.08757575f, -0.03184035f, 
    0.15999745f, 0.43399024f, -0.00777511f, -0.01990843f, 0.18068613f, 0.03456466f, -0.08928655f, 0.05046542f, 
    0.21602717f, -0.04013814f, -0.01797639f, 0.15261135f, -0.19211139f, 0.00706429f, -0.15356261f, -0.00486186f, 
    0.04174383f, 0.00490769f, -0.00902075f, 0.07274432f, 0.01461823f, -0.19911982f, -0.01060880f, -0.20139988f, 
    0.01015329f, -0.21920434f, -0.04719481f, -0.03769257f, -0.02929890f, 0.08378475f, -0.07600851f, 0.09823110f, 
    0.14246289f, -0.05045580f, 0.11246268f, 0.02471187f, 0.18398042f, -0.20247518f, -0.08752162f, 0.01593935f, 
    -0.10688106f, -0.10352859f, 0.07120733f, -0.10375749f, -0.01918516f, 0.06462337f, -0.06617133f, -0.01234384f, 
    0.14353772f, 0.05465422f, 0.02880333f, -0.03677571f, 0.05748717f, 0.15667969f, 0.07978042f, -0.02778859f, 
    0.08002602f, -0.10631599f, -0.01320172f, -0.13882430f, 0.07507850f, 0.20379297f, 0.12083633f, -0.04729379f, 
    -0.31624681f, 0.16544488f, 0.11597243f, -0.05353977f, 0.09743154f, -0.03162606f, -0.02061624f, 0.09650742f, 
    -0.02271541f, 0.08500367f, -0.02829021f, 0.12740943f, -0.03648271f, -0.00154329f, -0.05454264f, -0.00025383f, 
    -0.15924628f, -0.05694675f, 0.20476153f, 0.00912668f, -0.07211595f, 0.04438443f, 0.11915001f, 0.05797696f, 
    0.00805095f, -0.03955259f, 0.09097251f, 0.05306061f, -0.09161568f, -0.01368615f, -0.01060479f, 0.08247732f, 
    -0.03639374f, 0.01831882f, 0.13590389f, -0.07842209f, 0.21952070f, 0.19533108f, -0.00164520f, 0.00425459f, 
    0.04701452f, -0.09539790f, 0.17360534f, 0.00454986f, -0.00515586f, -0.07443820f, -0.11118738f, 0.06708027f, 
    0.10406932f, -0.01639394f, -0.16281551f, 0.07062503f, 0.03706417f, 0.11705644f, 0.02717109f, -0.01000328f, 
    -0.29793054f, -0.00807917f, -0.09005948f, -0.07555191f, -0.23628552f, -0.10300135f, -0.11730366f, 0.03232690f, 
    0.04544437f, -0.11034822f, -0.03012000f, -0.06362049f, 0.09706697f, 0.01757950f, 0.16890761f, -0.10110591f, 
    0.06220244f, -0.17454438f, -0.11356489f, 0.04749303f, -0.41442302f, -0.02611741f, 0.08466838f, -0.07785202f, 
    -0.04913128f, 0.10460064f, -0.03879087f, -0.02679387f, 0.02632891f, -0.06325149f, -0.06694525f, -0.10368238f, 
    0.09692712f, 0.00217419f, 0.17003329f, -0.03023660f, 0.02934535f, -0.06114061f, -0.23392797f, -0.05491354f, 
    -0.12971358f, -0.00641121f, -0.02665426f, 0.07774162f, 0.23021926f, -0.12032073f, -0.02791751f, 0.18058383f, 
    0.19577055f, -0.08416995f, 0.03495473f, 0.01734927f, -0.01343413f, 0.04978982f, 0.21068540f, 0.05964519f, 
    0.03333018f, 0.08850347f, -0.04368194f, 0.12490340f, 0.02835549f, -0.00877643f, 0.03908699f, 0.05276289f, 
    0.20217469f, 0.16060433f, -0.01788364f, -0.01633403f, 0.09301521f, 0.02441319f, -0.10604492f, 0.00992640f, 
    0.00688708f, -0.02304950f, -0.01274647f, 0.10250260f, 0.00852737f, 0.01117205f, 0.11043774f, -0.03356378f, 
    0.14516777f, -0.03516932f, -0.01184060f, 0.14089964f, 0.11786165f, 0.03195076f, 0.04426717f, -0.04571431f, 
    0.01582183f, 0.05257933f, -0.00267045f, 0.14954379f, -0.08611900f, -0.17168041f, 0.06306355f, 0.11041934f, 
    0.02306720f, 0.07701873f, 0.11931815f, 0.13486293f, -0.06115871f, 0.08710883f, 0.15028724f, 0.23276648f, 
    0.19634219f, 0.04215595f, -0.07825025f, 0.17988780f, -0.05949006f, 0.00319301f, 0.13231485f, 0.03504333f, 
    -0.04914970f, 0.01006567f, 0.01304389f, -0.04553760f, -0.00394620f, -0.19040772f, -0.01290071f, -0.04415538f, 
    -0.27082869f, 0.04751420f, 0.03920679f, -0.19774759f, -0.16191843f, 0.19111013f, -0.04395481f, -0.02821860f, 
    0.04020018f, 0.07014921f, 0.01783791f, -0.01952669f, 0.05500910f, 0.04573735f, 0.02125427f, 0.20664757f, 
    -0.14748721f, -0.05716402f, 0.08477614f, -0.06657079f, 0.00695993f, 0.39303693f, 0.02074442f, 0.03792152f, 
    0.00672332f, 0.02217627f, 0.03578964f, 0.11326237f, -0.00567575f, -0.03417679f, 0.03660597f, 0.08787622f, 
    -0.01337264f, 0.13350905f, -0.02794832f, 0.00511618f, 0.03294000f, 0.06120023f, -0.00964744f, 0.03196255f, 
    -0.06603233f, -0.24123196f, 0.12602475f, -0.12883326f, -0.11000434f, -0.20323816f, -0.00226310f, -0.07570895f, 
    -0.04524948f, -0.01687428f, 0.05038543f, 0.02917528f, -0.00213395f, -0.07340070f, 0.08909432f, 0.03316691f, 
    0.18535644f, 0.09041774f, 0.06039277f, 0.03233211f, -0.21017689f, 0.02111997f, 0.00992952f, -0.30559751f, 
    -0.04884462f, -0.01846804f, 0.00660562f, 0.06262132f, 0.00563128f, -0.07045739f, 0.06392218f, 0.00410795f, 
    0.03147745f, 0.21506992f, -0.01854120f, -0.04066717f, -0.02125900f, -0.01067304f, -0.08852254f, 0.18143505f, 
    -0.23064288f, 0.15685692f, 0.10323092f, 0.09855164f, 0.01752437f, 0.11202725f, -0.24744627f, -0.02344880f, 
    -0.08130342f, 0.04262201f, 0.03173882f, 0.13855615f, -0.00970143f, -0.02609644f, 0.16146965f, 0.03990043f, 
    -0.05474972f, 0.12977213f, 0.02137955f, -0.01620445f, -0.17886750f, 0.26295254f, -0.05707642f, 0.06977475f, 
    0.16715330f, 0.03397583f, 0.03729463f, -0.14258683f, 0.03595382f, 0.00428008f, -0.07170268f, 0.02050654f, 
    0.02086899f, 0.10159563f, -0.06702817f, -0.02352479f, 0.05624687f, -0.00760150f, 0.06762398f, 0.04296710f, 
    0.32629529f, 0.09151149f, 0.23498973f, 0.00231218f, -0.09006777f, -0.03038441f, 0.04293339f, 0.00197640f, 
    0.05531968f, -0.01693850f, 0.10137617f, -0.01732140f, -0.08835032f, -0.08552172f, -0.07777026f, -0.04018990f, 
    0.00726341f, 0.05584136f, 0.14454606f, 0.03207675f, 0.49563810f, -0.43084624f, 0.00253638f, 0.05132413f, 
    -0.17013799f, 0.00617839f, 0.22378705f, 0.10753968f, -0.01920096f, 0.01213246f, 0.10745431f, -0.00595995f, 
    0.00180861f, -0.04607461f, -0.06293663f, 0.00959509f, 0.00327574f, 0.14165357f, 0.02556603f, -0.01216059f, 
    0.30297503f, -0.03157473f, -0.06557508f, -0.07562996f, 0.00813465f, -0.08733677f, -0.12313665f, -0.13317043f, 
    0.09241671f, 0.06672533f, -0.02535585f, 0.15928231f, 0.10543915f, 0.03490345f, 0.01936670f, 0.01711773f, 
    -0.03920251f, -0.09165635f, 0.06012826f, 0.10639837f, -0.25463003f, -0.22186172f, 0.08568124f, 0.06398994f, 
    0.16876502f, -0.16213854f, -0.00896505f, 0.11160993f, 0.12119227f, 0.09052498f, 0.02906843f, -0.04320511f, 
    0.05619891f, 0.03207237f, -0.12652668f, -0.02687741f, 0.00476809f, 0.03927109f, 0.11255711f, 0.14129297f, 
    0.18952057f, 0.07853409f, 0.19846967f, 0.27636203f, 0.17625736f, -0.00597895f, -0.03475304f, 0.01547096f, 
    -0.12963530f, -0.06497841f, -0.04292531f, -0.00109640f, -0.03039839f, 0.06631704f, 0.08426717f, -0.07273980f, 
    0.00375470f, 0.02261560f, 0.00451255f, -0.00753285f, 0.39382362f, 0.04805043f, 0.16782495f, -0.02480965f, 
    0.27176872f, -0.12363665f, 0.02497214f, 0.02153359f, 0.13078102f, -0.04935635f, 0.07177041f, -0.01202799f, 
    -0.02571250f, -0.02165420f, 0.05853656f, -0.06205764f, 0.05768978f, -0.01553923f, 0.08554161f, -0.00938904f, 
    -0.12049498f, -0.02820619f, 0.40717506f, -0.28141522f, -0.09870478f, -0.12687063f, -0.06564476f, 0.01531640f, 
    -0.02259904f, -0.05823746f, 0.06900387f, 0.17439285f, 0.02090996f, -0.02542592f, 0.06961067f, -0.03975707f, 
    0.12055404f, 0.03136742f, 0.00765248f, -0.05817855f, -0.01502308f, 0.08956798f, 0.07661419f, -0.21479660f, 
    -0.02699090f, -0.02565638f, 0.11249758f, -0.05996491f, -0.01927349f, -0.03511473f, -0.03064828f, -0.11034586f, 
    -0.04291269f, 0.05834605f, 0.00220330f, 0.00515991f, -0.16630690f, -0.05016873f, -0.07575603f, 0.01560880f, 
    0.21521236f, -0.17304708f, -0.12702496f, -0.19393863f, -0.21663015f, -0.05910454f, -0.11395036f, 0.05188342f, 
    0.06884001f, -0.14066975f, 0.02215396f, 0.01043710f, 0.01038632f, -0.02588739f, 0.06626727f, 0.03670635f, 
    0.02749495f, 0.01277782f, -0.18204281f, -0.03378668f, 0.07417689f, 0.02152517f, -0.06242117f, 0.11754034f, 
    -0.02468778f, 0.26660532f, -0.02844498f, -0.07005335f, 0.08546414f, 0.07137864f, 0.11543511f, 0.11305686f, 
    0.07535144f, 0.01081796f, 0.04578770f, -0.04756659f, 0.12742262f, 0.07313710f, 0.00135706f, 0.07703685f, 
    -0.05615098f, 0.04986174f, 0.03816624f, -0.05887695f, -0.00932634f, 0.02475396f, 0.04634330f, -0.00288570f, 
    0.03495525f, 0.04249799f, -0.00758922f, 0.05049002f, -0.06622130f, -0.01671660f, -0.02110784f, -0.03327530f, 
    -0.03056213f, -0.00012273f, -0.00131081f, -0.04416416f, -0.01142212f, 0.01117047f, -0.03743666f, 0.00434647f, 
    -0.02990935f, -0.03635221f, 0.04118516f, 0.05094469f, 0.01095429f, -0.04207357f, 0.00174868f, -0.02114855f, 
    0.00414785f, -0.05631446f, 0.01844345f, 0.00477730f, -0.05665876f, 0.01513451f, -0.03332520f, 0.05138253f, 
    0.02705619f, 0.04513329f, -0.00872832f, -0.03943123f, 0.02539278f, -0.02492849f, 0.00956101f, 0.02923815f, 
    -0.00089489f, 0.04216452f, -0.04449273f, -0.03842708f, -0.01044275f, 0.00850116f, -0.02135003f, 0.03442611f, 
    -0.00390261f, -0.06502974f, -0.00960135f, -0.03599001f, -0.00706272f, -0.03557799f, -0.02867410f, 0.01642762f, 
    0.01160366f, -0.02908718f, -0.03971272f, 0.02163912f, 0.02706539f, 0.03168964f, -0.03188461f, -0.01636042f, 
    -0.00392630f, 0.00370041f, 0.05136001f, -0.00301770f, 0.01679960f, -0.02484675f, -0.05329628f, 0.01923943f, 
    -0.00905854f, -0.04239491f, 0.02308466f, 0.04037231f, -0.01784647f, -0.01887127f, -0.00392955f, 0.04981860f, 
    0.00075132f, -0.03986478f, -0.06183427f, 0.02144557f, -0.04920511f, -0.05137019f, 0.02130068f, 0.04188778f, 
    0.00596261f, -0.04320062f, 0.04695024f, -0.06365634f, -0.04922130f, -0.01665656f, -0.01301144f, 0.01579500f, 
    0.04914172f, 0.02521063f, -0.04209533f, -0.04911200f, -0.01377180f, 0.02015289f, 0.04081769f, -0.01940768f, 
    0.00776822f, 0.01739089f, -0.04973786f, 0.04175464f, 0.01958134f, 0.04110443f, -0.02783969f, -0.04940612f, 
    -0.03414125f, -0.01618405f, 0.04296216f, 0.02602273f, 0.02201372f, 0.04867155f, -0.03289350f, -0.04320370f, 
    -0.05115309f, 0.01961390f, 0.04425110f, -0.02874086f, 0.02095049f, 0.04531523f, -0.02405584f, 0.04471276f, 
    -0.00622977f, -0.03284774f, -0.01559975f, 0.00259270f, -0.05814749f, 0.00976455f, -0.05758442f, -0.04845234f, 
    -0.05853521f, 0.01345644f, -0.04013600f, 0.01290653f, -0.00704121f, 0.00055359f, -0.01642434f, -0.01391163f, 
    -0.03823850f, -0.02182795f, 0.01047200f, -0.00364603f, 0.04866017f, -0.05926075f, 0.03066784f, 0.03448984f, 
    0.02332268f, -0.01560926f, -0.03077107f, -0.04463213f, -0.02210649f, -0.00420307f, -0.05382146f, 0.02474461f, 
    -0.02072074f, 0.02100204f, 0.00791057f, -0.03546349f, -0.04628870f, -0.04064094f, 0.03384523f, 0.03721141f, 
    -0.02908976f, -0.04729930f, 0.01406135f, 0.01950062f, -0.03129324f, 0.03497124f, 0.05229143f, 0.03714055f, 
    0.04210888f, -0.01910141f, 0.00587134f, 0.02994645f, 0.01889792f, 0.02179871f, 0.03914336f, -0.00965096f, 
    -0.05830240f, -0.05091822f, -0.03947163f, -0.04860020f, 0.02756622f, 0.02110734f, -0.04767159f, 0.05213257f, 
    -0.04991134f, -0.06232698f, 0.00708117f, 0.00486781f, -0.02804666f, -0.03529707f, -0.05220171f, -0.01913324f, 
    -0.04327250f, -0.05085102f, -0.06063624f, -0.02513433f, 0.00039679f, -0.02021872f, -0.03344029f, 0.02370053f, 
    0.03585518f, -0.00662963f, 0.03997242f, 0.02282077f, -0.04917885f, -0.03354510f, 0.02754421f, -0.03210458f, 
    -0.06255108f, 0.03341470f, -0.04514136f, -0.05213302f, 0.01207818f, -0.02483574f, -0.01104644f, -0.02615824f, 
    -0.00509725f, -0.01872006f, 0.03713039f, -0.00325698f, -0.05394200f, -0.02268572f, -0.01881269f, 0.02889402f, 
    -0.02946305f, 0.04725631f, -0.03327105f, 0.02176546f, 0.00398190f, 0.02579938f, -0.05476289f, 0.04354239f, 
    0.02377465f, -0.05252190f, -0.04902571f, -0.03439672f, -0.01537453f, -0.04930295f, -0.00541686f, -0.00415875f, 
    -0.00927701f, 0.02892626f, -0.04107830f, 0.05158279f, -0.04648419f, -0.04458726f, -0.04682900f, 0.00028609f, 
    0.00696726f, 0.00092764f, -0.02036267f, -0.00431727f, -0.01537337f, 0.04524105f, -0.00613286f, -0.03040306f, 
    0.01582143f, -0.03188498f, -0.02172093f, 0.05374127f, 0.00023511f, -0.02458618f, 0.05066447f, -0.04520258f, 
    -0.06245485f, -0.01412315f, -0.04413582f, -0.04741142f, -0.01986418f, -0.04242285f, -0.05719180f, 0.03356071f, 
    0.04982971f, 0.03566598f, 0.01589209f, -0.00853533f, -0.02612747f, -0.03803805f, 0.04275109f, -0.00074463f, 
    -0.05210940f, 0.03916421f, -0.02753684f, -0.01191142f, 0.02956766f, -0.02445342f, -0.01218023f, 0.03415848f, 
    0.02952665f, -0.06066696f, 0.02199049f, -0.04991639f, -0.00186238f, -0.01662362f, -0.00064685f, 0.01680529f, 
    -0.00911602f, -0.00286963f, -0.04675085f, 0.04083474f, -0.01025138f, -0.02004186f, 0.05323168f, -0.05268335f, 
    -0.01534605f, -0.22751784f, -0.21463306f, -0.24401407f, 0.11043825f, 0.25578436f, 0.07119551f, 0.18165593f, 
    -0.02704397f, 0.01819047f, 0.07451187f, 0.18200161f, 0.11588706f, -0.11365348f, 0.13898836f, 0.07565711f, 
    -0.13478670f, 0.01308887f, -0.08578659f, -0.08908339f, -0.05815482f, 0.23422369f, 0.09614604f, 0.09681705f, 
    0.09348681f, -0.07511055f, -0.08089248f, -0.13273595f, 0.04289968f, -0.02929009f, -0.00032317f, -0.05843414f, 
    0.05776742f, -0.01564635f, -0.16147783f, 0.05869165f, -0.04489723f, 0.01284708f, 0.02426072f, 0.09311083f, 
    0.38774252f, 0.32133222f, -0.03232152f, -0.00523210f, -0.14249763f, 0.04349501f, -0.04032724f, 0.02948426f, 
    0.05771487f, 0.09980751f, 0.03505218f, -0.02443092f, -0.16092764f, -0.03828853f, -0.07696507f, 0.00919912f, 
    -0.08712829f, -0.08965541f, 0.12895648f, 0.03452343f, 0.52096772f, -0.01914540f, -0.13827406f, -0.14420076f, 
    -0.19505616f, -0.09119018f, -0.00766718f, 0.10889808f, 0.03860344f, 0.14434148f, 0.07822561f, -0.00455696f, 
    0.05988961f, 0.03047093f, -0.00006670f, -0.03052858f, -0.08600295f, -0.06668594f, 0.07085082f, 0.02680711f, 
    0.32103789f, 0.28028327f, -0.12147665f, -0.02567243f, 0.42172232f, 0.04223268f, 0.07802682f, 0.07138903f, 
    -0.04398994f, 0.15249890f, -0.00518013f, -0.04916944f, -0.01635137f, 0.11081859f, -0.01965076f, 0.07497550f, 
    -0.02824193f, 0.02628785f, 0.00205697f, -0.06422763f, -0.04797069f, 0.13600564f, 0.10121359f, 0.11371844f, 
    0.14109311f, 0.10300367f, -0.19245163f, 0.05464011f, 0.11609895f, -0.11420622f, -0.06297103f, -0.01624106f, 
    -0.04150053f, 0.00287684f, -0.10835440f, -0.02251468f, 0.02042782f, -0.01950803f, 0.00048086f, -0.07388396f, 
    0.31250826f, 0.08833370f, -0.22365405f, 0.06729078f, -0.06434699f, -0.23014915f, 0.07457942f, -0.09861276f, 
    0.04155500f, -0.00019244f, 0.05490497f, 0.03034503f, -0.13186958f, 0.07339790f, 0.12497567f, -0.05517079f, 
    -0.05595611f, -0.08391364f, -0.06986042f, 0.01355065f, 0.34415892f, -0.20401873f, -0.30264157f, 0.02399603f, 
    0.03897773f, -0.02869393f, 0.08092432f, 0.02411584f, 0.02283593f, 0.03560064f, 0.05893389f, 0.12874980f, 
    0.01739639f, -0.02280224f, -0.02576679f, 0.01312000f, 0.00293037f, -0.14401124f, -0.03933904f, -0.00039825f, 
    0.15941015f, -0.06506111f, -0.20718038f, -0.06889986f, -0.05438582f, 0.02953308f, 0.08749578f, 0.05327667f, 
    0.07242054f, 0.10230474f, -0.00666434f, -0.05290673f, -0.03456858f, -0.04772992f, 0.05644360f, 0.01846849f, 
    0.10586650f, 0.17241640f, -0.02123387f, -0.18949360f, 0.25913945f, -0.70928085f, 0.02841173f, -0.17171688f, 
    -0.01499300f, 0.04844218f, -0.02741966f, 0.08194742f, -0.15021881f, 0.13623619f, -0.04385550f, 0.03846265f, 
    -0.05997167f, -0.02900384f, 0.04403286f, -0.06012213f, -0.01121614f, 0.05917295f, 0.05808930f, 0.05380227f, 
    -0.27797845f, 0.12238801f, 0.08427377f, 0.03741031f, 0.24414894f, -0.03903061f, -0.16341066f, 0.03570386f, 
    0.12600197f, 0.01642050f, -0.06684342f, -0.09589243f, 0.04156385f, -0.11912994f, 0.01945749f, -0.04986025f, 
    0.18188848f, -0.06689309f, -0.08411948f, -0.05704333f, 0.42430612f, -0.17554145f, 0.14571093f, -0.07139327f, 
    0.14671274f, 0.08982629f, 0.00005597f, -0.04575995f, 0.04118189f, 0.02600878f, 0.02056786f, -0.09236332f, 
    -0.00617836f, 0.10286553f, -0.06072494f, 0.07340622f, 0.00525226f, -0.07809766f, 0.00434626f, 0.12166239f, 
    0.25501433f, -0.11202524f, 0.05201851f, -0.16591372f, -0.16992070f, -0.04609174f, -0.06319204f, -0.03143603f, 
    0.04050947f, -0.03756768f, -0.04077399f, 0.05394451f, -0.12302385f, 0.08441250f, 0.03407182f, -0.13358614f, 
    -0.11314569f, -0.07904240f, -0.09147888f, 0.14362825f, 0.14321792f, -0.18838640f, 0.01738314f, -0.03052945f, 
    -0.11196037f, -0.09361742f, -0.05728781f, -0.03943429f, 0.08895734f, 0.00945005f, 0.12617733f, 0.03285151f, 
    0.08877636f, 0.16118369f, -0.05566638f, -0.05213178f, 0.08969267f, -0.15984713f, 0.10494702f, -0.04202086f, 
    0.12111584f, -0.06336254f, 0.04721696f, -0.18060456f, -0.45300680f, 0.01938046f, 0.09335668f, -0.08137586f, 
    0.03427117f, 0.06102278f, 0.03715697f, 0.04107944f, 0.09278058f, 0.00649323f, -0.17094441f, 0.04838557f, 
    -0.04521270f, -0.07957008f, 0.10540009f, 0.06655017f, -0.21371679f, 0.35056120f, -0.30244014f, -0.10470209f, 
    0.01375680f, -0.00761672f, 0.13443266f, -0.09671739f, -0.03839333f, 0.01186255f, -0.07683081f, 0.02769471f, 
    -0.03790253f, -0.06175352f, -0.00332487f, -0.06528583f, 0.08291489f, -0.00037859f, 0.00768145f, 0.02378279f, 
    -0.49909762f, -0.09524202f, 0.39610478f, -0.06237804f, -0.17051710f, -0.12616219f, -0.06064294f, 0.05858099f, 
    -0.13178520f, 0.12715627f, -0.18601815f, -0.14356057f, -0.14829996f, 0.00253919f, 0.04654782f, -0.01871286f, 
    -0.02870679f, 0.05449276f, -0.04669317f, -0.04375024f, 0.07840255f, 0.41973224f, 0.46768862f, 0.00711450f, 
    0.04356815f, -0.10403635f, 0.02438120f, 0.05436826f, 0.00906983f, -0.05596891f, -0.04715411f, 0.04111449f, 
    0.06984358f, -0.04883835f, 0.14354852f, 0.08028514f, 0.09913787f, -0.14362432f, -0.02137343f, 0.04581453f, 
    -0.32280120f, -0.21099941f, -0.09059091f, 0.01706138f, 0.13165206f, 0.10937247f, 0.07860541f, -0.05173721f, 
    0.01989545f, 0.08712912f, 0.01084716f, 0.10895317f, -0.10414995f, 0.01019225f, 0.09625939f, 0.01836775f, 
    0.07899348f, 0.01328283f, 0.06079766f, 0.08010209f, -0.02075346f, -0.03146907f, -0.17233703f, 0.17937896f, 
    0.11281325f, 0.05197200f, 0.23072898f, -0.02447568f, 0.16281031f, 0.08580827f, -0.00510197f, -0.01672832f, 
    -0.00620753f, 0.06646175f, -0.14750829f, 0.04007882f, 0.00135904f, -0.01580632f, 0.10336729f, 0.00193693f, 
    0.04227655f, 0.07350476f, 0.27204594f, -0.02273415f, -0.24927786f, -0.13805589f, 0.05873750f, 0.10917727f, 
    -0.12733932f, 0.06985728f, -0.17401388f, 0.01592636f, -0.01423097f, -0.00057184f, 0.00650191f, 0.10754530f, 
    -0.09177750f, -0.07304197f, 0.01415990f, -0.08738734f, 0.13834704f, 0.27307758f, 0.25850677f, 0.13572666f, 
    -0.02289297f, -0.01713025f, -0.05460861f, 0.07683773f, -0.02207913f, 0.01861184f, -0.00442669f, -0.04546119f, 
    -0.04825584f, -0.06852876f, -0.09193251f, 0.10167962f, 0.00076414f, 0.01252949f, -0.00723274f, -0.11263725f, 
    -0.09789266f, 0.05211693f, -0.23311841f, -0.00665152f, -0.08809606f, 0.20537353f, 0.12265889f, 0.12032638f, 
    -0.06322078f, 0.06600571f, 0.03730807f, 0.04652741f, -0.08586616f, 0.13841319f, -0.02094332f, 0.04282671f, 
    0.03103438f, -0.04103808f, 0.03029604f, -0.11141476f, 0.11881436f, -0.29156762f, -0.00568979f, -0.17916974f, 
    0.08135053f, 0.19726777f, 0.05561556f, 0.05520012f, -0.08484302f, -0.01452428f, -0.02551628f, 0.00966646f, 
    0.00665889f, -0.05175170f, -0.09451450f, -0.07926690f, 0.00840271f, 0.06834551f, 0.01944005f, 0.03105300f, 
    0.15187134f, -0.19667339f, 0.05052504f, 0.15896510f, 0.11688228f, -0.00958609f, -0.09107819f, 0.01367415f, 
    0.02482628f, 0.06215276f, 0.04645365f, -0.00678803f, 0.03277401f, -0.00388533f, 0.01586633f, -0.20349041f, 
    0.00169995f, -0.06302150f, 0.09653820f, -0.02937714f, 0.07356837f, -0.21326962f, -0.12963308f, 0.04352557f, 
    0.00604639f, 0.00219982f, -0.00340017f, -0.05027121f, 0.01170893f, -0.03623592f, -0.22513916f, -0.11180026f, 
    0.03283444f, -0.01035102f, 0.02221323f, 0.03758168f, -0.10417084f, 0.12752083f, -0.06610699f, -0.12747638f, 
    0.17851825f, 0.17134266f, 0.25601333f, 0.17828408f, 0.19979450f, 0.07640403f, 0.05512890f, 0.10405139f, 
    0.16541822f, -0.01239447f, 0.16620038f, 0.16038290f, -0.12425054f, 0.12875082f, 0.08392411f, 0.05973108f, 
    0.07118409f, -0.15238903f, -0.04880435f, -0.02056286f, 0.13029216f, 0.10779643f, 0.18832332f, 0.08990180f, 
    0.14648961f, 0.15622246f, 0.00780648f, -0.00397723f, 0.09892984f, -0.00309900f, 0.04767083f, -0.04378590f, 
    -0.07489242f, 0.17158744f, 0.10469630f, 0.12871104f, 0.02079394f, 0.00873056f, -0.01239571f, -0.00783465f, 
    -0.25184911f, -0.16484644f, -0.01762773f, -0.15606394f, -0.05911821f, 0.12400506f, 0.15657578f, -0.01391094f, 
    -0.01222784f, 0.15826567f, 0.01760557f, 0.09105278f, 0.11025548f, 0.01386333f, 0.12198213f, 0.05766120f, 
    0.01969418f, 0.05968658f, 0.04745081f, 0.04361416f, 0.02107443f, 0.10288243f, -0.15635088f, 0.05836300f, 
    0.09469341f, -0.05381089f, 0.03394856f, -0.00104485f, -0.04681807f, 0.11451560f, 0.10221495f, 0.01684387f, 
    0.08661690f, -0.01390335f, 0.03593280f, 0.04607358f, -0.03787723f, -0.02637725f, 0.02667467f, -0.02091995f, 
    0.12954716f, -0.13558535f, -0.11514024f, 0.14582649f, 0.00239243f, -0.06666539f, 0.00738536f, -0.08012584f, 
    0.04938401f, -0.03476505f, 0.05757971f, 0.04260331f, 0.07131940f, 0.12116082f, 0.09253944f, 0.03877740f, 
    0.04455898f, -0.01309782f, 0.05122844f, -0.01445819f, 0.50340146f, -0.23267865f, -0.13485283f, 0.11396071f, 
    -0.25821131f, -0.06276089f, -0.09518816f, -0.00604305f, 0.01852517f, 0.03141400f, 0.05660585f, -0.03519156f, 
    -0.01678092f, -0.01399741f, 0.08057512f, -0.11172393f, -0.02821471f, 0.10857467f, 0.11981767f, -0.12002643f, 
    0.19659434f, -0.04756299f, 0.42942113f, 0.03017341f, -0.05577657f, -0.23803204f, 0.04643726f, 0.12619427f, 
    -0.04664119f, -0.00816604f, -0.10971045f, -0.06784461f, -0.14911042f, 0.05023717f, -0.01428644f, -0.01514005f, 
    -0.00997067f, 0.26655921f, 0.00677931f, 0.06697130f, 0.55320168f, 0.09050090f, 0.28336740f, -0.06169421f, 
    0.10492055f, -0.12950483f, -0.06180465f, 0.07182776f, 0.12477252f, 0.10560450f, 0.07661558f, 0.01500446f, 
    0.08659369f, -0.10407092f, 0.10996393f, 0.09697966f, -0.03557657f, -0.10810435f, 0.12357849f, 0.06670826f, 
    -0.18016164f, -0.13662519f, -0.11796901f, -0.09566307f, -0.03869221f, 0.19964831f, 0.05982798f, -0.01973485f, 
    0.10690748f, 0.07410374f, 0.02413340f, 0.03038821f, -0.05803641f, 0.00805557f, 0.05939637f, -0.02594461f, 
    -0.06037947f, -0.04725938f, -0.01195386f, -0.11579414f, -0.20130888f, 0.12814213f, -0.34993592f, 0.18098003f, 
    -0.06139502f, 0.08045278f, -0.08710703f, -0.14393082f, 0.11741072f, 0.04841632f, -0.00330738f, 0.07412946f, 
    -0.09838596f, -0.08034694f, -0.03464491f, 0.07734981f, 0.00191905f, 0.01166311f, 0.10851122f, -0.02219152f, 
    0.14220960f, 0.19195439f, 0.28145814f, 0.00792706f, -0.03566457f, -0.29042366f, 0.08948125f, 0.19517472f, 
    -0.01730969f, 0.00119358f, -0.07163011f, -0.07672060f, 0.02587476f, 0.12716402f, -0.04760945f, -0.01049282f, 
    -0.09689189f, 0.02636538f, -0.00889250f, 0.03198283f, 0.27923539f, 0.21524002f, 0.23209794f, 0.08523564f, 
    0.05124053f, -0.07792889f, 0.00627105f, 0.14936975f, 0.08304250f, 0.06120832f, 0.01857031f, 0.01546491f, 
    0.09079924f, -0.10892402f, 0.07971742f, -0.04066224f, 0.07903244f, -0.06240667f, 0.03696352f, 0.00900793f, 
    -0.31645036f, 0.09198645f, -0.13859878f, -0.03691347f, -0.15769032f, 0.23664998f, 0.14806333f, 0.07439640f, 
    0.00374908f, 0.11268547f, -0.00961472f, 0.01709826f, 0.03593767f, 0.04243352f, -0.08154595f, 0.03323723f, 
    0.04778547f, -0.03477049f, -0.06051283f, -0.11636019f, -0.27925286f, 0.01946962f, 0.07751419f, -0.06251988f, 
    -0.10755986f, 0.10247393f, -0.11523058f, 0.03426057f, -0.14450225f, 0.04729557f, -0.03431914f, -0.02929112f, 
    0.03969632f, -0.05026319f, -0.06637579f, 0.14835054f, -0.04126078f, 0.07302516f, -0.08092135f, 0.00219966f, 
    -0.15573516f, -0.23317477f, -0.00549244f, 0.09359750f, 0.00207713f, 0.06419587f, -0.02429881f, -0.00740231f, 
    0.00045597f, 0.03233832f, 0.17373314f, 0.05881880f, 0.02206585f, -0.07452078f, -0.04834487f, -0.13829830f, 
    -0.03081475f, 0.07028631f, 0.17292407f, -0.06583430f, -0.21628743f, -0.12364276f, -0.04578926f, 0.03036530f, 
    -0.08886883f, 0.22380637f, 0.04904272f, 0.08298979f, -0.05064114f, -0.05150878f, -0.10617210f, 0.10183213f, 
    0.11629287f, 0.02324611f, -0.04122016f, 0.02923847f, -0.08975590f, 0.05359260f, -0.07872315f, -0.04132826f, 
    -0.05378619f, 0.06802346f, 0.12038402f, -0.00332942f, -0.03336823f, 0.05608461f, 0.07137182f, 0.24342307f, 
    0.17212616f, 0.09025592f, 0.09717043f, 0.07316164f, -0.02698486f, -0.06420881f, -0.06341949f, 0.07014031f, 
    0.10790809f, -0.11038575f, -0.06591183f, -0.01417610f, -0.28563133f, 0.06755539f, 0.03648553f, 0.10882336f, 
    -0.09135287f, 0.19295779f, 0.06413220f, 0.09954735f, -0.07600174f, 0.09562293f, -0.07209290f, 0.01061811f, 
    0.07925972f, 0.10702536f, -0.04905371f, 0.11653440f, 0.01756540f, -0.00075451f, -0.11487794f, -0.00514559f, 
    0.02208232f, -0.36103290f, -0.09362759f, 0.03573932f, -0.15191504f, 0.18723609f, -0.01512610f, -0.00793489f, 
    0.09448974f, 0.02521800f, -0.00047280f, -0.04058685f, 0.03267068f, 0.09263600f, 0.04938710f, 0.15284494f, 
    -0.01374170f, 0.02937447f, -0.00638498f, 0.25412345f, -0.11905917f, 0.07928855f, -0.23425579f, 0.11756393f, 
    -0.05873785f, 0.00033206f, -0.04193750f, -0.06968698f, 0.00798802f, 0.03244781f, 0.04353531f, -0.03939885f, 
    0.10557999f, -0.05473662f, -0.06038242f, 0.12374918f, 0.05292007f, 0.13185394f, 0.10710278f, 0.00089436f, 
    -0.15228195f, -0.22065099f, -0.05031710f, 0.21822195f, 0.02663318f, -0.00025994f, -0.02041380f, -0.01579815f, 
    0.05915905f, 0.10962243f, 0.09976996f, -0.01477326f, -0.01826194f, 0.04391928f, 0.10422036f, 0.09330699f, 
    0.07191634f, -0.03001432f, 0.17584226f, 0.06802879f, -0.13928474f, 0.13414270f, -0.05126034f, 0.21167183f, 
    0.05461478f, -0.17657495f, 0.05188612f, 0.00814153f, 0.05671963f, 0.05570159f, -0.00730333f, -0.07647086f, 
    0.10970549f, -0.06239668f, -0.05228604f, 0.03751768f, -0.12989545f, -0.07014381f, 0.07613498f, -0.02903645f, 
    0.39689153f, 0.08459330f, -0.33000565f, -0.06453428f, 0.32580826f, 0.26014376f, -0.03162329f, 0.12906311f, 
    -0.06215822f, -0.00943537f, 0.03113213f, 0.08173296f, 0.08430016f, -0.13729520f, -0.05239611f, 0.06667802f, 
    0.11737900f, -0.10364193f, -0.05438372f, -0.01813019f, 0.06153041f, -0.33663854f, -0.23353150f, 0.04333322f, 
    0.17727698f, 0.01922258f, 0.11139587f, 0.00697852f, 0.05726883f, -0.11544661f, -0.01818347f, 0.03604512f, 
    -0.00735480f, -0.02151677f, 0.00835264f, 0.00076062f, -0.00369123f, 0.03488042f, -0.00466086f, 0.04322947f, 
    0.29214633f, 0.16195886f, 0.01143849f, 0.07009522f, -0.11608213f, -0.06229777f, -0.09570108f, 0.03802798f, 
    -0.00893379f, 0.04575746f, -0.00412144f, -0.03104226f, 0.06310483f, -0.05621644f, -0.03461378f, 0.10616510f, 
    0.05119475f, 0.08618367f, 0.06905013f, -0.03098498f, 0.51948988f, -0.05190189f, 0.06006617f, 0.14960121f, 
    -0.25768480f, -0.23219037f, -0.18114580f, 0.04529149f, -0.09100191f, 0.03929476f, 0.00781839f, 0.00359231f, 
    0.01722453f, -0.03006110f, 0.07519218f, 0.01046487f, -0.05816965f, 0.03791927f, -0.00063845f, 0.04268043f, 
    0.13868742f, -0.12861596f, -0.14396989f, 0.27749962f, -0.00422405f, 0.13566460f, 0.16127634f, 0.06041067f, 
    -0.11146616f, -0.09486683f, -0.02644418f, -0.02674029f, -0.01356873f, 0.10989948f, 0.03537805f, 0.04742678f, 
    0.04247358f, -0.00323899f, 0.02944079f, 0.06661699f, 0.03273734f, -0.06800248f, -0.10004756f, -0.20418672f, 
    0.15793918f, 0.06707929f, -0.01894725f, 0.08224318f, 0.10685138f, -0.07608414f, 0.03819760f, -0.00555296f, 
    -0.05978289f, 0.12829040f, 0.00514464f, 0.00608169f, -0.10320093f, 0.23747654f, -0.03394733f, 0.09521355f, 
    0.10360841f, 0.27125806f, 0.20861912f, 0.04141105f, -0.09192141f, -0.07607459f, -0.12737435f, -0.08274022f, 
    0.05500913f, 0.00236949f, 0.00893696f, 0.04062491f, -0.07338088f, -0.06436384f, -0.02866264f, -0.02188268f, 
    -0.10528193f, 0.05232962f, -0.03593827f, 0.05958810f, 0.04236317f, 0.34524161f, 0.01326516f, 0.13948788f, 
    0.08577741f, -0.10851569f, -0.05602596f, -0.00405891f, 0.10234287f, 0.11209867f, -0.01420802f, -0.06582755f, 
    0.09173542f, 0.00874572f, -0.02425798f, -0.05900040f, -0.04380931f, -0.01363062f, 0.11082777f, 0.00039849f, 
    0.05401360f, 0.26442942f, -0.12457865f, 0.03411340f, -0.12035633f, 0.00674563f, 0.00317318f, -0.10250183f, 
    0.01792340f, 0.10254894f, -0.07132178f, -0.08619213f, 0.00359013f, -0.09971681f, -0.06030741f, 0.07726076f, 
    -0.02829768f, 0.18782581f, -0.12140209f, 0.03023358f, 0.21500275f, -0.21615145f, 0.16563810f, -0.00152829f, 
    -0.02049480f, 0.06191834f, -0.07446421f, 0.08711339f, 0.07587608f, 0.13029408f, 0.06930108f, 0.20232622f, 
    -0.09337889f, -0.04786086f, 0.10755414f, -0.01869651f, 0.05345582f, 0.03099124f, 0.04871728f, 0.05912956f, 
    -0.29204941f, -0.29265165f, -0.04437298f, -0.17649171f, -0.07202157f, -0.01109689f, -0.05455179f, 0.14382513f, 
    0.04640724f, 0.07598288f, 0.02614915f, -0.07713594f, 0.00017214f, -0.00259883f, -0.06427493f, -0.00641469f, 
    -0.04406432f, 0.10119268f, -0.05622147f, 0.02933977f, -0.06441992f, -0.14285097f, 0.02096362f, -0.04952745f, 
    -0.21113028f, -0.06377187f, 0.10803743f, 0.05681312f, 0.02915289f, 0.04872672f, -0.02746743f, 0.05938203f, 
    -0.01240915f, -0.14761429f, -0.17999491f, 0.06024747f, 0.00146063f, -0.00981073f, 0.02607460f, 0.08367572f, 
    0.36324051f, 0.17269261f, -0.14375529f, 0.20832765f, 0.09479921f, 0.02856701f, 0.00768571f, -0.10735095f, 
    0.07626900f, 0.08046766f, -0.06875052f, -0.00869890f, 0.01666733f, 0.02777321f, -0.06528292f, 0.01338448f, 
    -0.03636501f, 0.03393216f, -0.00820053f, -0.08395294f, 0.24931669f, -0.08793288f, 0.10281572f, 0.28093436f, 
    -0.23840365f, -0.08869465f, -0.03058400f, 0.03598435f, 0.04179557f, -0.00325162f, 0.02038584f, 0.12974386f, 
    0.02689570f, 0.07275129f, -0.11091902f, 0.01027456f, -0.01069330f, 0.02179561f, -0.01808751f, -0.01615581f, 
    -0.12919687f, 0.13184437f, 0.09320008f, 0.12668103f, 0.10632283f, -0.00794740f, -0.04800282f, -0.05780628f, 
    -0.03433708f, -0.07464407f, -0.00883824f, -0.06490799f, 0.01190160f, 0.08428599f, -0.09694290f, -0.02070470f, 
    0.00476774f, -0.02004814f, 0.01178205f, -0.04821922f, -0.26432398f, 0.30077621f, -0.23286033f, -0.07953102f, 
    -0.04670298f, 0.02441965f, 0.15399234f, 0.00440859f, 0.00112282f, -0.06700829f, -0.07544097f, -0.00500069f, 
    -0.01473847f, 0.13595489f, -0.08294380f, 0.02048126f, 0.11051871f, -0.05534776f, -0.02490366f, 0.07892685f, 
    0.22024225f, -0.14161314f, 0.13276662f, 0.15921599f, -0.11094122f, -0.04139062f, 0.12120257f, 0.05022605f, 
    -0.03815553f, -0.07697099f, 0.05214241f, 0.09831963f, 0.08423849f, 0.00454943f, 0.16402581f, -0.15652746f, 
    0.07439980f, -0.20037934f, 0.01675358f, -0.00848091f, -0.46164671f, -0.15463191f, 0.04041512f, 0.19381236f, 
    0.10929034f, 0.03427060f, 0.03794916f, -0.09493297f, -0.02174574f, 0.10419837f, 0.12036435f, 0.02940060f, 
    -0.04156843f, 0.03145225f, -0.12378933f, 0.06833271f, 0.07010465f, 0.02930888f, -0.00941634f, -0.06747029f, 
    0.07086942f, 0.37999111f, -0.07851817f, -0.03943335f, -0.11775014f, 0.08545110f, -0.01659418f, 0.08854526f, 
    -0.05346615f, -0.00054083f, 0.01564141f, -0.08129241f, 0.02971799f, 0.05110569f, -0.02648757f, 0.13767016f, 
    0.05061293f, 0.03654095f, 0.12658265f, 0.01373520f, 0.00157146f, 0.00294535f, 0.13169503f, -0.02170930f, 
    -0.02601385f, 0.06540976f, -0.01453419f, 0.10008763f, 0.07328364f, 0.12492797f, -0.06427950f, -0.02062930f, 
    0.05965636f, -0.03558859f, 0.04969626f, -0.03066500f, 0.02793188f, 0.07473789f, -0.07733309f, -0.06943430f, 
    -0.08753081f, 0.11759012f, -0.17171033f, -0.14259936f, 0.31827235f, 0.02351699f, 0.06397882f, -0.02166113f, 
    0.01238224f, 0.13807106f, 0.05723571f, -0.01262846f, 0.03782184f, -0.12036622f, -0.02400633f, -0.07711125f, 
    -0.01432606f, -0.03828997f, 0.03601944f, 0.00185373f, 0.16681407f, -0.23127651f, 0.16672595f, 0.09671344f, 
    0.13133022f, -0.04508531f, 0.01643396f, -0.02804493f, -0.08939454f, 0.02027985f, 0.08588129f, -0.00648623f, 
    -0.09154565f, 0.15048836f, 0.00691241f, 0.02591481f, 0.04151176f, 0.10656874f, 0.01956106f, -0.11836902f, 
    -0.11894218f, 0.06730724f, -0.20475052f, -0.00639844f, 0.05620031f, -0.09833002f, -0.03836866f, -0.00317394f, 
    0.04945010f, -0.03506949f, 0.00712493f, 0.01373701f, 0.02603806f, 0.00859361f, 0.11705140f, 0.11199944f, 
    0.16970834f, 0.15621899f, -0.00298101f, -0.06012802f, -0.49560308f, 0.30261752f, -0.23940274f, -0.10889418f, 
    -0.14093474f, -0.12572755f, -0.10605807f, -0.06566364f, -0.02016240f, 0.00714228f, 0.07247192f, -0.00632554f, 
    -0.01269370f, -0.00357607f, 0.02888397f, 0.06171402f, -0.03404914f, -0.01567163f, 0.01648639f, 0.02327337f, 
    -0.11403351f, 0.11976068f, 0.06741917f, -0.00395570f, -0.17552660f, 0.15002151f, 0.12692764f, 0.19543494f, 
    -0.10989219f, 0.07186548f, 0.09124279f, -0.15094760f, 0.03187453f, 0.09356367f, 0.10543769f, 0.06983351f, 
    0.13879912f, -0.05106878f, -0.02545647f, -0.06623296f, 0.19691494f, -0.07275978f, -0.06142424f, -0.17257123f, 
    -0.14214215f, -0.03415276f, 0.04743755f, -0.02643838f, -0.01857233f, -0.10583669f, 0.12693208f, -0.04269341f, 
    0.04434856f, 0.08354272f, 0.09682990f, -0.00193491f, 0.08769148f, -0.05355911f, 0.05952077f, -0.05217567f, 
    -0.01905556f, 0.26076078f, -0.12818590f, -0.01005326f, -0.01714074f, -0.03633529f, 0.10594282f, -0.19168673f, 
    0.15710317f, 0.09755757f, 0.02253184f, -0.06829767f, 0.08594510f, -0.11809551f, 0.10619600f, -0.00286078f, 
    0.15478906f, 0.11915803f, 0.05052936f, 0.12361608f, 0.00280681f, -0.01031969f, 0.05848624f, 0.04141069f, 
    -0.08842081f, 0.01853543f, 0.07500831f, -0.10987142f, -0.12186973f, -0.13256483f, 0.11070219f, -0.00163020f, 
    0.12956209f, -0.02451451f, -0.09635417f, 0.02843352f, 0.05304404f, 0.02600136f, 0.08904262f, -0.02744409f, 
    -0.05631663f, 0.15596569f, -0.23658858f, 0.01133307f, -0.21332225f, -0.09188418f, -0.09490972f, 0.14241666f, 
    -0.02533332f, 0.00274645f, 0.01414050f, 0.03503265f, -0.02394950f, -0.04310227f, -0.01042604f, -0.07574761f, 
    -0.06590283f, -0.09662340f, 0.02072218f, 0.06474376f, -0.23299561f, -0.16076370f, 0.00323604f, -0.09189498f, 
    0.13672818f, 0.08285604f, -0.07754032f, 0.06755965f, 0.02857158f, 0.09961686f, 0.04011867f, 0.06476314f, 
    -0.04740098f, 0.03805895f, 0.00602037f, -0.03605222f, 0.10736119f, 0.00422817f, 0.06730146f, -0.05007647f, 
    -0.09669293f, 0.09561802f, 0.17296086f, 0.12387010f, -0.07224423f, 0.17968051f, -0.03035265f, 0.00950857f, 
    -0.00880196f, 0.06218995f, -0.00162429f, -0.01557244f, 0.04885708f, -0.04490847f, 0.00617254f, -0.09498163f, 
    -0.01547430f, 0.00374276f, -0.04007127f, 0.03941131f, -0.23779452f, 0.17565337f, 0.01477773f, -0.23830611f, 
    0.14093177f, 0.06352567f, 0.02182348f, 0.09610941f, -0.06427989f, -0.04283872f, -0.14118193f, -0.12523445f, 
    -0.08770235f, 0.01233736f, 0.03348166f, 0.07361428f, -0.08215214f, 0.06474467f, -0.09040274f, -0.08212753f, 
    -0.05465712f, -0.18226309f, -0.03646620f, -0.25652212f, -0.09987226f, -0.07447197f, -0.09441898f, 0.05811220f, 
    -0.01733250f, -0.12310813f, 0.05995640f, 0.03517043f, 0.13120833f, -0.07013765f, 0.07827789f, -0.05944334f, 
    -0.01580335f, -0.31003866f, -0.10556117f, -0.06710149f, 0.57687581f, -0.06458601f, 0.16662841f, -0.12659714f, 
    -0.07459386f, 0.06221685f, 0.03858306f, -0.06384784f, -0.11926578f, 0.14167437f, 0.06061918f, -0.04676875f, 
    0.07917822f, 0.06712393f, -0.01941490f, 0.10330031f, 0.16943625f, -0.07588392f, -0.05092460f, 0.09399717f, 
    0.06920046f, 0.16599695f, -0.04595278f, 0.18035863f, -0.08524574f, 0.14047669f, 0.00943092f, 0.15420774f, 
    -0.01428666f, 0.16644111f, -0.00369096f, -0.16863298f, 0.05528348f, 0.06384706f, -0.16585335f, 0.09370952f, 
    0.01555699f, 0.00373117f, 0.07788990f, -0.01594392f, 0.23572539f, 0.12209593f, 0.12177413f, 0.23177545f, 
    -0.18851128f, -0.07835470f, -0.00679187f, 0.04335720f, 0.15175156f, 0.09862756f, 0.00331337f, -0.00146809f, 
    -0.00524225f, 0.03099264f, 0.00662851f, 0.08228724f, -0.00109737f, -0.00369405f, 0.01368968f, -0.03952963f, 
    -0.22830015f, -0.21395382f, -0.13465074f, -0.19060254f, 0.18846495f, -0.08967476f, 0.16466670f, -0.13253306f, 
    -0.20372804f, 0.08052656f, 0.04336184f, -0.21489775f, 0.11357753f, 0.08015071f, 0.11035542f, -0.04436281f, 
    -0.04634786f, -0.05832335f, -0.05195899f, -0.00349550f, 0.13975765f, 0.13831533f, 0.14932737f, 0.11292573f, 
    -0.07447577f, 0.16683556f, 0.01349073f, -0.04948282f, -0.01609080f, -0.02030274f, 0.16963220f, 0.03167780f, 
    -0.10075974f, 0.07577243f, 0.09091543f, 0.00959618f, -0.04443936f, 0.18672618f, 0.00907839f, -0.00180561f, 
    -0.14228910f, 0.36600274f, -0.08312286f, 0.16236076f, 0.11925998f, -0.05927267f, 0.08580466f, -0.06440112f, 
    -0.02197636f, 0.16837269f, -0.00874612f, 0.15313172f, 0.01390120f, -0.03355172f, 0.02246557f, 0.05633494f, 
    -0.00085023f, 0.03467555f, -0.13120057f, 0.00724499f, -0.25450867f, -0.05099031f, -0.25126880f, -0.09424513f, 
    0.23467422f, -0.23473504f, -0.10509259f, -0.11324608f, -0.12565222f, 0.24425814f, 0.08956327f, 0.07477329f, 
    -0.00234757f, 0.09318219f, 0.09373409f, -0.02305321f, 0.17675556f, -0.04129789f, -0.14302364f, -0.12739199f, 
    0.07747573f, -0.14966190f, -0.19261126f, 0.04996519f, 0.02313560f, -0.02737093f, 0.04503014f, 0.07996592f, 
    0.02105440f, 0.10344055f, 0.00320951f, -0.03551822f, 0.04897368f, -0.06457842f, 0.09654573f, -0.07181121f, 
    0.10891981f, 0.04356898f, -0.08629980f, -0.08015978f, -0.12830779f, -0.01483093f, -0.12406655f, -0.01841119f, 
    -0.11067240f, 0.17708124f, -0.04482221f, 0.09014770f, 0.00006311f, -0.03864381f, 0.09096783f, 0.08374072f, 
    -0.12012048f, 0.02355224f, 0.26334840f, 0.02397921f, 0.10718609f, -0.07913232f, -0.04212322f, -0.05406098f, 
    0.29125458f, 0.06983552f, -0.03630507f, -0.20806961f, 0.00785417f, 0.05438396f, 0.20070682f, -0.09251530f, 
    0.00168470f, 0.09823904f, 0.11567347f, 0.00466237f, -0.11272848f, -0.09833638f, -0.08601833f, -0.05460620f, 
    0.04318443f, 0.04000423f, 0.08662290f, -0.04216923f, 0.24246319f, -0.04515153f, -0.03249661f, 0.04455953f, 
    -0.20212242f, 0.08593640f, 0.08489906f, 0.04075016f, -0.07221095f, -0.02673809f, 0.03406249f, 0.04963862f, 
    -0.04683283f, 0.03027282f, -0.10757118f, 0.09712261f, 0.11194903f, -0.00448505f, 0.06742076f, 0.00055197f, 
    0.19996540f, -0.19055298f, 0.12985204f, 0.24833964f, -0.12348129f, 0.18804607f, -0.11019628f, -0.01733539f, 
    -0.05215561f, 0.04939830f, -0.03945388f, -0.10504872f, 0.03041356f, 0.02900878f, -0.06553586f, -0.02844032f, 
    -0.02891001f, -0.06095723f, -0.08769537f, 0.00978435f, -0.07851572f, -0.01176758f, -0.06986295f, 0.29689282f, 
    -0.14076619f, -0.01003821f, -0.03416750f, -0.02008318f, 0.08523538f, 0.06122455f, 0.14952442f, 0.09318863f, 
    0.11481106f, 0.05360584f, 0.00789327f, 0.09817395f, 0.08622981f, -0.15798111f, 0.07672747f, -0.01962548f, 
    -0.33169967f, -0.10974982f, -0.06025951f, -0.08781636f, 0.04139826f, -0.01417918f, -0.01012948f, 0.10126676f, 
    0.07966740f, -0.01518928f, 0.05335851f, 0.00327289f, 0.04990114f, 0.16170253f, -0.06582675f, 0.06590570f, 
    0.07502801f, -0.03582901f, 0.00437694f, -0.00140683f, -0.11527920f, 0.08968662f, -0.10993868f, -0.36264035f, 
    -0.01952034f, -0.08638068f, 0.13224892f, -0.13422441f, -0.00543446f, -0.00981534f, -0.07981355f, -0.00923663f, 
    0.09269342f, 0.06979930f, 0.08491620f, 0.12784693f, -0.02754028f, 0.05922811f, -0.05491021f, 0.13404068f, 
    0.30500579f, -0.05089950f, -0.28056231f, 0.07307512f, 0.01358203f, 0.02788327f, -0.09158507f, -0.11607755f, 
    -0.02178532f, -0.25320703f, 0.14235653f, -0.09913411f, 0.07413909f, -0.08971225f, 0.09816443f, -0.05766376f, 
    0.08962891f, -0.21186511f, -0.08481818f, 0.03026719f, -0.01606825f, -0.39274496f, 0.00008351f, 0.09974311f, 
    0.22060840f, 0.23504043f, 0.22028056f, 0.00135420f, -0.07974415f, -0.05012652f, 0.05545684f, -0.00360819f, 
    -0.02537711f, 0.12318257f, 0.11772030f, -0.00284809f, 0.16510871f, 0.00591649f, -0.03602499f, -0.10485085f, 
    0.01098991f, 0.27233094f, 0.16390580f, 0.13816588f, 0.10507889f, -0.05545444f, -0.09616736f, 0.06585935f, 
    0.04926786f, -0.01004861f, -0.05522484f, -0.04708768f, 0.14966232f, -0.10760720f, -0.11293904f, 0.02971994f, 
    -0.02504386f, -0.03998000f, 0.07437993f, 0.00679460f, 0.24341640f, -0.17375983f, 0.18760352f, 0.14047135f, 
    -0.02074606f, -0.00136225f, -0.00709730f, -0.05767029f, 0.02146156f, -0.02720302f, 0.05577920f, 0.10355626f, 
    0.03994936f, -0.03568383f, -0.08275666f, 0.05896970f, 0.10690631f, 0.09886520f, -0.14335126f, 0.04313845f, 
    -0.03629507f, -0.15244748f, -0.16950464f, 0.20440094f, -0.08303904f, 0.18879338f, 0.17412442f, -0.22605449f, 
    0.01452418f, 0.01408646f, 0.00834510f, 0.00992276f, 0.04572098f, -0.05094698f, 0.10430925f, -0.06897337f, 
    0.05735833f, -0.09482446f, 0.19225110f, 0.04495382f, 0.09105789f, -0.10299180f, -0.04246367f, -0.05012998f, 
    -0.04062448f, 0.11456697f, 0.12161084f, 0.11453064f, -0.07985207f, 0.01805071f, 0.10429803f, -0.04280042f, 
    -0.10876989f, 0.03885614f, 0.06894251f, -0.03948186f, -0.12228184f, 0.25363207f, 0.00437274f, -0.05101963f, 
    -0.06199660f, 0.26143172f, 0.01738532f, 0.04265826f, 0.34121451f, -0.13418272f, -0.05432540f, -0.05519991f, 
    0.05474586f, 0.04053562f, -0.03062948f, -0.01610544f, -0.02673639f, -0.14287868f, 0.00618078f, 0.10881342f, 
    -0.08793698f, 0.04566579f, 0.05338215f, 0.05220124f, -0.30337897f, 0.41474012f, -0.20994312f, -0.00639408f, 
    0.10716315f, -0.08562032f, -0.09498078f, -0.10126335f, -0.03394502f, 0.07556413f, 0.06486303f, -0.03401693f, 
    -0.12203825f, 0.06377499f, 0.09225705f, 0.02861851f, 0.07784320f, -0.07162884f, 0.14605948f, -0.09487393f, 
    -0.08034276f, 0.22888999f, -0.21929328f, 0.02778074f, -0.25365326f, -0.01619673f, 0.09768737f, -0.02587475f, 
    -0.10409380f, 0.01037321f, 0.07757119f, -0.00997591f, 0.14118336f, 0.17450792f, -0.05210794f, -0.01556794f, 
    0.05155655f, -0.11854628f, -0.07000495f, 0.09368623f, 0.07170377f, 0.44918782f, -0.09003712f, -0.14980142f, 
    -0.20523626f, 0.04348826f, -0.09649283f, 0.00045742f, 0.06372986f, -0.01918840f, 0.30193079f, 0.07830435f, 
    -0.13160069f, 0.01777168f, 0.15187004f, -0.05553537f, 0.07550049f, -0.05818662f, 0.04823999f, 0.10466625f, 
    0.01675323f, 0.07848955f, -0.11225288f, -0.25140554f, -0.01548790f, 0.11944047f, 0.21190558f, -0.08009440f, 
    -0.06122563f, -0.00967606f, -0.02544610f, 0.05618851f, -0.06710648f, 0.08420996f, -0.02992924f, -0.11571695f, 
    -0.18751551f, 0.04334351f, 0.03622908f, 0.01636373f, -0.33430767f, 0.12621123f, -0.04031191f, -0.04596650f, 
    -0.23448803f, -0.04871506f, -0.01241777f, 0.03028016f, -0.17631948f, -0.04660481f, 0.01283053f, 0.01285073f, 
    -0.05222539f, -0.07760557f, 0.01859165f, -0.09898853f, 0.06844843f, 0.03098901f, 0.12175472f, -0.05218925f, 
    0.01335220f, 0.25112170f, 0.06307532f, 0.25694209f, 0.05324316f, -0.00347722f, 0.08975497f, -0.08704269f, 
    0.02087213f, 0.10609868f, 0.01652403f, -0.02092448f, 0.04694259f, -0.14308937f, -0.11941811f, -0.04914127f, 
    -0.07085788f, -0.03850086f, 0.15266035f, -0.07156425f, -0.02671238f, 0.00595423f, 0.14027451f, 0.21087553f, 
    0.08748346f, 0.03788576f, -0.00998107f, 0.03666087f, 0.02505965f, 0.04182606f, 0.06077052f, 0.17040949f, 
    -0.09758516f, -0.03755077f, 0.10166030f, -0.02434572f, 0.04878103f, 0.00188654f, 0.00553206f, -0.03323934f, 
    -0.27754638f, 0.16333339f, 0.10773630f, -0.02812411f, 0.21110667f, 0.03112874f, 0.09134908f, -0.06130407f, 
    -0.01534771f, -0.04661113f, 0.00355385f, 0.12331497f, 0.14081138f, 0.07810155f, -0.03255729f, -0.10028619f, 
    -0.03338291f, 0.07554904f, -0.08202729f, -0.06982237f, 0.17101635f, 0.13261257f, -0.16733304f, -0.05609567f, 
    -0.05598205f, -0.05072021f, 0.12123910f, -0.13486370f, 0.01995958f, -0.03194521f, 0.00321463f, 0.02725093f, 
    0.01140498f, 0.13304406f, -0.03217943f, 0.09200291f, 0.03966612f, 0.08437001f, -0.13002168f, 0.12024025f, 
    0.28000754f, 0.19366454f, 0.20748954f, 0.43172827f, 0.03943207f, -0.18850176f, 0.08403658f, -0.01236566f, 
    0.22701983f, 0.15191250f, -0.10762858f, -0.07140318f, -0.11301222f, 0.24460401f, -0.01436124f, 0.02481194f, 
    0.00165530f, 0.01032671f, 0.06435604f, 0.08304565f, -0.14099942f, -0.11775246f, -0.05425618f, 0.06153433f, 
    -0.17115737f, -0.04450666f, -0.02232394f, 0.00995859f, 0.08013291f, 0.03936545f, 0.01631563f, 0.10368373f, 
    -0.07636804f, -0.00834495f, 0.09551607f, 0.02387392f, 0.01443721f, 0.04704039f, 0.08904015f, -0.06024669f, 
    -0.13705826f, -0.08459678f, -0.15730578f, 0.02882633f, 0.05049306f, 0.01375926f, -0.08165935f, 0.05707674f, 
    0.03064912f, -0.07445972f, 0.02099657f, 0.08918946f, 0.06276419f, 0.12320027f, 0.04524564f, -0.07399398f, 
    -0.01687277f, -0.04574995f, -0.12426665f, -0.05270899f, -0.34845662f, 0.13602975f, -0.15984693f, -0.20998839f, 
    0.19027929f, 0.12899601f, -0.04896877f, -0.06584435f, -0.08146996f, -0.14584883f, -0.06164091f, 0.10552795f, 
    -0.05346302f, -0.05248008f, 0.07075665f, -0.03416248f, 0.14691171f, -0.04174192f, 0.06431019f, 0.01771658f, 
    -0.11175597f, -0.17133056f, 0.11045027f, 0.01569261f, -0.04367855f, 0.04427154f, -0.11311784f, 0.03341290f, 
    0.27087149f, -0.02346467f, 0.05000068f, -0.03416375f, -0.08028437f, -0.04397499f, -0.12101232f, 0.00361349f, 
    0.13701722f, -0.06457429f, 0.04970839f, -0.01011377f, -0.23339903f, -0.14159475f, -0.01994017f, 0.00325533f, 
    -0.15468067f, -0.05801713f, 0.10947049f, -0.00042718f, -0.01857578f, 0.04087701f, 0.08464024f, 0.07232207f, 
    -0.04087688f, -0.05240916f, 0.09656543f, 0.10456794f, 0.00814247f, -0.09616780f, -0.04265647f, 0.03145329f, 
    -0.06924596f, -0.19647230f, -0.10210181f, -0.06943436f, -0.07148423f, 0.13088024f, -0.06444080f, 0.07004347f, 
    0.02761271f, -0.04406600f, -0.09334160f, -0.04898320f, 0.14543393f, 0.00513525f, -0.00884285f, 0.03906892f, 
    0.12917010f, 0.06862690f, -0.00546956f, 0.08899703f, -0.20657931f, 0.28954551f, 0.19761883f, 0.19609447f, 
    0.07733206f, 0.27998629f, 0.04725401f, -0.03246183f, 0.11557014f, -0.09246386f, -0.10000075f, -0.01451555f, 
    0.05029018f, -0.05101329f, 0.05403730f, -0.01108689f, 0.01855469f, 0.05391571f, 0.02791398f, 0.15190122f, 
    -0.23958266f, 0.09520665f, 0.20452660f, 0.16700722f, 0.20852761f, -0.00124544f, 0.01315465f, 0.10658987f, 
    -0.03081468f, -0.11972419f, -0.00631368f, 0.15989436f, -0.04261322f, 0.08987286f, -0.05545597f, 0.04041519f, 
    -0.00223283f, -0.01664606f, 0.07783604f, 0.06033882f, -0.05793834f, 0.36158934f, -0.07060304f, 0.26194972f, 
    0.21095982f, 0.02079315f, 0.09549922f, -0.06799222f, -0.04156218f, -0.02481422f, -0.01121426f, 0.02484433f, 
    0.11616926f, 0.03869399f, 0.01674891f, -0.05102758f, 0.01476977f, -0.01553087f, -0.11825525f, 0.01429148f, 
    -0.08482373f, -0.12044851f, -0.00782812f, 0.11840795f, -0.20440780f, -0.02186585f, 0.05990996f, 0.02211119f, 
    -0.03873711f, 0.00672044f, 0.03714820f, -0.07560140f, -0.00872290f, 0.00562978f, 0.04445570f, 0.10592231f, 
    0.03823677f, -0.15289325f, 0.00425367f, 0.02505037f, -0.37561199f, 0.01575324f, -0.15775572f, 0.09200181f, 
    -0.04898684f, -0.02625347f, 0.10470634f, 0.00234652f, -0.01472416f, -0.03246687f, -0.06513655f, -0.09099801f, 
    0.02700247f, 0.07086723f, 0.09392056f, -0.07600018f, -0.03222802f, 0.13551451f, -0.08542137f, 0.00121359f, 
    0.09166482f, 0.24743010f, -0.24637850f, -0.06669977f, 0.09994356f, 0.06849869f, 0.12654190f, 0.06547907f, 
    0.04474183f, -0.05942456f, -0.01815440f, 0.04980081f, 0.00717020f, -0.00990093f, -0.02209495f, 0.12092885f, 
    0.04043433f, 0.10054871f, 0.04630599f, 0.04411629f, 0.13101435f, 0.15284631f, -0.07074842f, -0.20675404f, 
    0.11336755f, 0.04865691f, 0.00166701f, -0.02049089f, -0.04324284f, -0.00178649f, -0.14237842f, -0.00368438f, 
    0.02986424f, -0.13074526f, 0.07436068f, 0.00003619f, -0.02761975f, 0.04239290f, -0.01109252f, 0.15106407f, 
    0.12280326f, 0.23008049f, 0.02957943f, 0.06046938f, 0.26967484f, 0.04859314f, -0.07855091f, 0.07537427f, 
    -0.01017119f, 0.18035625f, 0.01579063f, 0.11351427f, 0.06822379f, -0.02556482f, 0.12837169f, -0.02282240f, 
    0.00702629f, -0.00761061f, -0.02525908f, 0.05767678f, 0.04847788f, -0.18075404f, 0.37463719f, 0.07413767f, 
    0.11331021f, -0.05014436f, 0.01646050f, 0.06536791f, 0.11673532f, 0.15848674f, 0.09982999f, -0.01614267f, 
    0.00711111f, 0.04208777f, 0.02612882f, -0.06688840f, 0.01554123f, -0.06394719f, 0.03716995f, -0.07849020f, 
    -0.05563082f, 0.02643381f, 0.04261126f, 0.01486863f, 0.03634931f, 0.03099423f, 0.00050685f, 0.01448396f, 
    0.04806564f, 0.03320482f, -0.03389429f, 0.01166796f, -0.01533434f, -0.04826197f, -0.03005048f, 0.02687957f, 
    -0.05537948f, 0.03388101f, 0.04614751f, -0.02266950f, 0.00601551f, -0.04859845f, -0.02809001f, 0.03140929f, 
    -0.03008485f, -0.02055324f, 0.01741192f, 0.04309554f, -0.01923605f, 0.02558834f, -0.03158141f, -0.03136791f, 
    0.03230496f, -0.02029641f, 0.02349459f, 0.04282629f, -0.00518713f, 0.04365120f, -0.05940846f, -0.03698826f, 
    -0.01811426f, 0.01255176f, -0.01509962f, -0.02744120f, -0.00486459f, 0.04142435f, -0.03919802f, 0.01732735f, 
    0.03269335f, -0.05197802f, -0.00603105f, 0.02953640f, -0.03640481f, 0.03348631f, -0.03663564f, -0.04413051f, 
    0.03775791f, -0.01228453f, -0.04585769f, -0.03156233f, 0.02346760f, 0.02756143f, -0.02283042f, -0.02011900f, 
    -0.03396983f, 0.00790193f, -0.03764367f, -0.03110439f, 0.03381144f, 0.02753990f, 0.01674748f, -0.02609858f, 
    0.01020332f, -0.04420779f, 0.02335817f, 0.02843081f, 0.00390495f, 0.04285773f, -0.05807187f, 0.04274504f, 
    -0.02475359f, -0.01740455f, -0.03057120f, -0.04732338f, -0.04634384f, -0.02468339f, 0.02069174f, -0.03817443f, 
    -0.05825355f, 0.03386629f, -0.00809843f, -0.01572287f, -0.03650541f, -0.02829435f, 0.02577425f, -0.01826142f, 
    -0.00683279f, -0.00832501f, 0.03284225f, -0.05612157f, -0.01318333f, -0.04360721f, -0.04641192f, -0.01650375f, 
    -0.02312022f, -0.03271374f, 0.00628276f, -0.01077070f, -0.02546427f, -0.03689900f, -0.03856845f, 0.01096317f, 
    -0.01692260f, -0.04979502f, -0.05507886f, 0.00498242f, 0.02414997f, -0.04267217f, -0.02322603f, 0.00702979f, 
    0.02230263f, 0.01561560f, 0.01449576f, -0.01874787f, 0.03396657f, -0.00831303f, 0.00134162f, 0.01131947f, 
    -0.01172149f, -0.05994600f, -0.00022638f, -0.01431682f, -0.00015761f, -0.03054102f, -0.02740085f, 0.04469603f, 
    -0.04398800f, 0.04955061f, -0.03680257f, -0.05068470f, -0.03535291f, 0.04149440f, 0.04345990f, 0.00877430f, 
    0.01831468f, -0.02118537f, 0.02481659f, -0.03038985f, 0.01836387f, -0.02150595f, -0.02510506f, 0.00808327f, 
    -0.00656060f, 0.00744563f, -0.04525114f, -0.03791450f, 0.00027028f, -0.00745915f, -0.04384643f, 0.04046966f, 
    -0.05475054f, 0.03518442f, -0.05682012f, -0.03247332f, 0.04375426f, 0.00922711f, -0.05703593f, 0.01244658f, 
    -0.02243960f, 0.02958854f, 0.05175998f, -0.04908446f, -0.00824252f, -0.01228827f, -0.05412901f, 0.03787704f, 
    -0.02346689f, -0.05339576f, -0.03302274f, 0.04814843f, 0.01677794f, -0.04755274f, -0.05366998f, -0.05588550f, 
    -0.01776955f, 0.00596097f, -0.02793738f, -0.01111425f, -0.01932237f, -0.05111779f, -0.02576427f, -0.03134122f, 
    0.00655579f, -0.05130094f, -0.03498156f, -0.03822584f, -0.00381893f, 0.03402780f, -0.00997779f, -0.02838134f, 
    0.05534621f, -0.01541028f, 0.01398855f, -0.00864390f, -0.02707272f, 0.01799355f, -0.01485179f, -0.02777821f, 
    0.03711283f, -0.01818953f, -0.05377035f, -0.05538882f, -0.05479533f, -0.03588700f, -0.02982698f, 0.00801274f, 
    -0.01997400f, 0.03915728f, -0.00462337f, 0.04694769f, 0.00352434f, 0.03824677f, -0.01585299f, -0.04240479f, 
    -0.01910418f, 0.02524432f, -0.01293061f, -0.02816451f, 0.04062613f, -0.02009519f, 0.02359757f, -0.01161234f, 
    -0.02424894f, 0.04806764f, 0.01206280f, 0.00756211f, 0.02400051f, -0.00257805f, 0.04624321f, -0.01346307f, 
    0.00455858f, -0.03105999f, -0.05808092f, 0.03188898f, -0.02404499f, 0.00713944f, 0.00317300f, -0.04936105f, 
    0.00282700f, 0.04801391f, 0.02168256f, 0.04737287f, 0.03497196f, 0.00707975f, 0.01964764f, -0.03126902f, 
    -0.02115319f, 0.03786181f, 0.04445866f, 0.00791923f, -0.06357541f, 0.02918858f, 0.03646275f, 0.00664753f, 
    -0.00965945f, -0.05354295f, -0.05980407f, 0.01649207f, 0.03029409f, -0.01617729f, -0.02853926f, -0.05613268f, 
    -0.00188670f, 0.05085821f, -0.00230850f, -0.04375812f, 0.03921323f, -0.00797528f, -0.00613147f, -0.05437693f, 
    -0.00825553f, 0.00992168f, -0.04338307f, -0.05266820f, -0.03308713f, 0.04069144f, -0.05309819f, 0.03093391f, 
    0.03445054f, -0.01175616f, -0.03031478f, 0.02843966f, -0.00737784f, 0.00457772f, 0.02363120f, 0.02067274f, 
    0.02532312f, -0.04744479f, 0.00356691f, 0.00193778f, -0.03782298f, -0.01834746f, 0.00061564f, 0.05066321f, 
    -0.01930292f, 0.02634866f, -0.03867778f, -0.05476010f, -0.01082116f, -0.02358701f, -0.02774681f, -0.04318644f, 
    0.02676555f, 0.04279906f, -0.03512695f, -0.05351030f, 0.02461491f, 0.01517486f, -0.05235439f, -0.01800248f, 
    0.01059530f, 0.21474417f, 0.14554240f, -0.04018224f, 0.02188729f, 0.01507790f, 0.12294424f, -0.15187481f, 
    -0.09950054f, 0.00166752f, 0.00564443f, 0.01447148f, 0.04241655f, 0.04847296f, -0.10902499f, 0.15592556f, 
    0.14275602f, 0.20246591f, 0.19334777f, 0.02990330f, 0.20073186f, -0.02764117f, -0.10421228f, -0.29442331f, 
    0.06564207f, 0.23907275f, 0.13453738f, 0.01721846f, -0.28237301f, -0.05737424f, -0.00198381f, 0.03216092f, 
    -0.13610397f, 0.07088022f, -0.06142432f, 0.16896400f, 0.01640833f, -0.04327872f, -0.01429763f, -0.27635038f, 
    0.21468864f, -0.12225632f, 0.17327453f, -0.25545028f, 0.07406495f, -0.16849460f, 0.05029796f, -0.14213537f, 
    0.09172771f, -0.02529508f, -0.05689476f, 0.10642061f, 0.09301302f, -0.11618555f, 0.12625535f, -0.01771801f, 
    -0.08068824f, 0.22878438f, -0.11572578f, 0.01211498f, -0.02930165f, 0.16411248f, -0.03677867f, 0.01944748f, 
    0.10237944f, 0.03196758f, 0.06657772f, -0.03772667f, -0.06928127f, -0.02816530f, -0.02224011f, -0.01832052f, 
    -0.01639921f, -0.01892511f, -0.02013999f, 0.04536911f, 0.04233281f, -0.00084414f, 0.12354629f, 0.07412940f, 
    0.10240951f, 0.19886856f, 0.02672157f, 0.00700630f, 0.00833175f, 0.02677925f, 0.03645616f, -0.19832194f, 
    -0.01331998f, -0.14424515f, -0.01953528f, -0.01032982f, -0.07823825f, -0.01929659f, 0.01320563f, 0.04119066f, 
    0.06171803f, -0.09078540f, -0.18138462f, -0.02849497f, -0.06517342f, -0.07249697f, -0.32230586f, -0.30515969f, 
    -0.03757511f, 0.05489511f, 0.05178114f, -0.01979925f, -0.08800817f, -0.03145222f, 0.04786937f, -0.00912755f, 
    0.19993365f, -0.04976458f, 0.09823642f, 0.08243287f, 0.18455130f, -0.22916362f, -0.17384504f, 0.06616586f, 
    0.29778451f, 0.12347408f, 0.34581912f, -0.17416039f, 0.17092624f, 0.19052403f, -0.06179509f, 0.09495702f, 
    0.11834785f, -0.00012931f, 0.03515291f, -0.19670852f, 0.07370493f, -0.01660528f, -0.12220565f, 0.05525493f, 
    0.12275378f, -0.11771255f, -0.01648653f, -0.08354350f, 0.44385302f, 0.08675829f, 0.31143975f, -0.03472486f, 
    -0.06301141f, 0.02979105f, 0.10600116f, -0.04273535f, 0.10875790f, 0.06776135f, -0.04241538f, 0.16503735f, 
    -0.06500637f, 0.15494817f, 0.04540712f, 0.14757420f, -0.00057852f, -0.03021906f, 0.01890192f, -0.06842935f, 
    0.25128207f, 0.00638215f, -0.12171870f, -0.29190969f, 0.00510556f, 0.01557765f, 0.04918539f, 0.07781772f, 
    0.06388573f, -0.03637139f, -0.04725688f, 0.13451448f, -0.20656434f, 0.05160449f, -0.09598874f, 0.07027501f, 
    -0.05545779f, 0.02250908f, 0.13075541f, 0.02775528f, -0.04355637f, 0.76003027f, -0.09991572f, 0.12790757f, 
    -0.11204387f, 0.10471659f, 0.14291398f, 0.08238135f, -0.05607224f, -0.06161564f, -0.09986715f, -0.04464723f, 
    0.04634217f, 0.05279843f, 0.04195013f, 0.01218497f, 0.08047610f, 0.05348822f, 0.01123100f, 0.14854440f, 
    0.04182328f, -0.20070225f, -0.11427995f, -0.15113105f, -0.20731764f, 0.05577711f, 0.05388609f, 0.04879551f, 
    -0.26819313f, -0.29656619f, 0.01327312f, 0.08201384f, 0.01083146f, 0.06011031f, 0.03057238f, 0.02264402f, 
    0.08345656f, -0.19799668f, -0.34247959f, -0.09545089f, -0.33464697f, 0.30721006f, -0.19659439f, -0.12846616f, 
    -0.04419271f, -0.08075591f, -0.06431288f, -0.00493243f, -0.06908862f, 0.04791119f, -0.01103343f, 0.01820880f, 
    0.11350081f, 0.01966340f, 0.13400659f, 0.08343220f, 0.09929562f, -0.19775786f, -0.26942411f, -0.26627612f, 
    0.03822379f, -0.14561081f, 0.30467561f, 0.14562647f, 0.07637069f, 0.05378092f, -0.02886771f, 0.05776682f, 
    0.11548755f, 0.02231948f, 0.03366894f, -0.02361850f, -0.03206539f, 0.12132414f, 0.11796279f, 0.18675932f, 
    0.08978839f, 0.17827173f, -0.08992397f, -0.01278649f, 0.19282049f, 0.14841606f, -0.18399075f, 0.16890791f, 
    -0.00156476f, -0.04033440f, 0.11177145f, -0.01239651f, 0.03266359f, -0.06929324f, -0.17335919f, -0.10913409f, 
    0.11678606f, 0.00971045f, 0.12453137f, 0.12295800f, -0.04228466f, 0.06879126f, -0.04022598f, 0.12119318f, 
    0.35871896f, -0.13198455f, -0.16524714f, -0.08818810f, 0.12611657f, -0.05299670f, 0.05561025f, 0.06419740f, 
    -0.02219934f, -0.08718590f, -0.09345262f, 0.01512292f, -0.08823859f, -0.10115926f, 0.10991193f, 0.06788245f, 
    0.08847360f, 0.06489117f, 0.02475835f, 0.00700806f, 0.21670058f, 0.02598945f, 0.17476848f, 0.31120569f, 
    0.28564385f, 0.00616610f, 0.08427840f, 0.09686783f, 0.08919568f, -0.12862548f, 0.16245504f, 0.03768548f, 
    -0.05443424f, -0.00415374f, -0.04066703f, 0.09308819f, 0.09553873f, -0.34989613f, -0.06357779f, 0.04913363f, 
    -0.03424668f, 0.01266119f, 0.00574649f, -0.00185040f, -0.03012978f, -0.00002302f, -0.00141097f, -0.00645236f, 
    -0.05361007f, -0.01198153f, -0.00851478f, -0.00558676f, -0.05186281f, 0.01219670f, -0.01756740f, -0.01877014f, 
    0.00820230f, 0.03534004f, 0.01183773f, 0.00910856f, 0.00255561f, -0.01743921f, -0.00870583f, -0.01131968f, 
    -0.03578849f, 0.01344367f, -0.04974116f, -0.04471857f, -0.03311042f, -0.03775213f, 0.04448519f, 0.02667966f, 
    0.04644922f, -0.00082186f, 0.02978765f, 0.04829891f, -0.03848425f, 0.04512180f, -0.05338556f, -0.06372016f, 
    -0.04939534f, -0.05237501f, -0.01934722f, 0.02979470f, 0.01515199f, -0.05216070f, -0.01294219f, -0.03722130f, 
    -0.00411014f, -0.04743682f, -0.00551899f, -0.05616590f, -0.04741109f, 0.03222146f, -0.02202460f, 0.00163744f, 
    0.01259060f, -0.02888214f, -0.04975689f, -0.00220954f, 0.02749967f, -0.02664663f, -0.06590133f, 0.00497803f, 
    0.02825855f, 0.02381791f, 0.01551576f, 0.00210075f, 0.00233454f, -0.05856525f, -0.03704992f, -0.00592012f, 
    -0.06589541f, -0.03985437f, 0.00417356f, 0.03590470f, -0.01589092f, -0.06007038f, -0.00535503f, -0.06091825f, 
    0.04145972f, -0.02391716f, 0.03700835f, 0.02130822f, 0.01049270f, -0.01917308f, -0.01138042f, -0.05160327f, 
    -0.05323884f, 0.00745431f, -0.06036898f, -0.01700085f, 0.03345626f, 0.04073872f, -0.01927388f, -0.02017481f, 
    -0.00490965f, 0.02394021f, -0.04169999f, 0.03299115f, -0.02643427f, -0.02191118f, -0.04477554f, -0.00645179f, 
    -0.05481702f, -0.01629190f, -0.01884300f, 0.00175089f, -0.06677026f, -0.04529729f, -0.02359084f, -0.04644149f, 
    0.01896869f, 0.00868907f, -0.05888624f, 0.01427823f, -0.01206652f, -0.05257490f, 0.03056846f, -0.00267465f, 
    -0.00340711f, 0.01131064f, -0.02953950f, 0.04036778f, -0.02367634f, 0.02030673f, -0.00044384f, 0.02281954f, 
    0.02405948f, 0.00043310f, 0.02338548f, -0.01042735f, 0.04118603f, -0.05220271f, 0.00417251f, 0.00435517f, 
    0.03803818f, 0.00913497f, 0.00492759f, 0.03956127f, 0.01684869f, -0.06551870f, -0.04841322f, -0.00706410f, 
    0.04596263f, -0.02910764f, 0.00468407f, -0.05864414f, -0.02160581f, 0.02742464f, -0.03453761f, 0.04371142f, 
    -0.03740127f, -0.01457486f, 0.02313483f, -0.00465021f, 0.04580636f, -0.05228394f, 0.03049980f, -0.02910838f, 
    -0.01193313f, 0.00542553f, -0.05526673f, -0.04237951f, 0.02100660f, -0.05461563f, 0.02596118f, 0.00354063f, 
    -0.05781028f, 0.02520860f, 0.03284958f, -0.02281470f, -0.05197306f, 0.01782637f, 0.00593932f, -0.01331330f, 
    -0.02099992f, 0.03657422f, -0.03370665f, 0.02853721f, 0.03475163f, 0.02231991f, -0.03791582f, 0.02957575f, 
    0.04189279f, 0.00029285f, -0.04505404f, -0.04979688f, -0.00229938f, -0.06058846f, 0.02066462f, 0.04178299f, 
    -0.03112521f, 0.03021744f, -0.03180557f, 0.03723885f, -0.03566243f, -0.05644064f, 0.04733948f, 0.00657713f, 
    -0.04897733f, 0.05096443f, 0.02701972f, -0.00484694f, -0.04802942f, -0.05080974f, -0.00378772f, 0.01431760f, 
    -0.00698395f, -0.01145853f, -0.05015587f, -0.05221754f, 0.04060974f, -0.00200881f, -0.04017904f, 0.04418757f, 
    0.04567287f, 0.04727011f, -0.01887193f, 0.00077316f, -0.05845992f, -0.00659455f, -0.02452701f, 0.03479662f, 
    -0.00561000f, -0.03560537f, -0.03135637f, -0.00785701f, -0.01098845f, 0.04596255f, 0.00807633f, 0.01414857f, 
    -0.01048291f, -0.04859010f, 0.00131859f, -0.03590357f, 0.02925573f, 0.04067681f, 0.02059807f, -0.00395256f, 
    0.00908493f, -0.00225543f, -0.00038468f, 0.03286945f, 0.02437801f, -0.04325886f, 0.00436489f, -0.05493379f, 
    0.01619807f, -0.05635907f, 0.00368226f, 0.01749499f, -0.05313396f, 0.05250096f, 0.00577140f, 0.04421568f, 
    0.01089751f, 0.01865861f, -0.04412526f, 0.01685890f, -0.03681275f, -0.05153057f, 0.02468928f, -0.05153540f, 
    -0.01642874f, 0.01275384f, -0.06332617f, -0.03912369f, -0.04333835f, 0.00835935f, -0.06093023f, -0.04984200f, 
    0.02093052f, -0.02774856f, -0.01619725f, 0.04721431f, -0.02025061f, 0.03778528f, -0.04466403f, -0.05807818f, 
    0.02345665f, 0.04277873f, -0.06642364f, -0.06364612f, 0.03973768f, 0.03564638f, -0.06020394f, 0.04085615f, 
    -0.02852904f, 0.04648475f, -0.05163752f, -0.05831118f, -0.00072317f, -0.04240238f, 0.03394937f, -0.00752070f, 
    0.00846194f, -0.02123136f, -0.01750777f, -0.04904370f, 0.02958206f, -0.02431140f, 0.01921077f, 0.02019935f, 
    0.00969558f, -0.01606197f, -0.00213008f, 0.04179198f, 0.01588573f, -0.01372256f, 0.00322061f, 0.01249338f, 
    0.00615029f, -0.02289494f, -0.04585624f, -0.02776042f, -0.00012872f, 0.02580219f, -0.01799751f, 0.01139580f, 
    0.03691042f, -0.01928810f, -0.00951746f, -0.04187850f, 0.02614732f, 0.02983611f, 0.03640430f, 0.02039088f, 
    0.01815337f, 0.04709237f, -0.02015771f, 0.04256808f, -0.04509955f, -0.03366965f, 0.03273355f, 0.03757601f, 
    0.05579240f, -0.05039975f, -0.01767746f, -0.03406836f, -0.01091709f, -0.01189170f, 0.00491130f, -0.02136135f, 
    -0.05835184f, 0.03125845f, 0.02774370f, 0.00634186f, -0.04923562f, 0.03481238f, -0.05481461f, -0.03680095f, 
    0.03547409f, -0.02963963f, 0.03414780f, 0.01308392f, -0.00486216f, 0.01413160f, 0.02467027f, -0.01601639f, 
    -0.04126462f, -0.05726787f, 0.02542584f, -0.05424916f, 0.03544577f, 0.04022865f, -0.02458523f, 0.03119862f, 
    0.04774098f, -0.01389668f, -0.02857187f, -0.02490502f, -0.01773628f, 0.04706552f, -0.05327895f, -0.00664270f, 
    -0.02288841f, -0.00619894f, -0.05645478f, -0.03665299f, -0.02161146f, -0.05760407f, 0.04930707f, -0.00333214f, 
    -0.03997939f, 0.04439896f, -0.02889542f, -0.06150923f, -0.01919169f, 0.02509011f, 0.02778969f, 0.03945270f, 
    0.00658996f, -0.03898844f, 0.00094227f, 0.03134611f, -0.01593051f, -0.01202342f, -0.01425249f, 0.00008091f, 
    -0.03935163f, 0.00683286f, -0.01037677f, 0.00327391f, -0.00182722f, -0.05649218f, -0.05170295f, -0.06017780f, 
    0.01179624f, -0.05772560f, -0.04869608f, -0.04490267f, 0.01243804f, 0.01568521f, 0.04091688f, 0.02665260f, 
    0.00884619f, -0.05074638f, -0.02946645f, 0.01854963f, -0.03261710f, -0.03519620f, -0.03580252f, -0.06180229f, 
    0.01296088f, 0.00020639f, -0.04089688f, -0.01926068f, 0.00938669f, -0.03804585f, -0.04005462f, -0.05428206f, 
    -0.04725469f, 0.01738244f, 0.03738340f, -0.03917777f, 0.04225373f, 0.00243241f, -0.01217904f, 0.04852842f, 
    -0.00805573f, -0.00604342f, 0.01401073f, 0.03985284f, -0.00582307f, 0.01900780f, -0.05955451f, -0.02645600f, 
    -0.00871023f, -0.05187761f, -0.05152546f, -0.04140104f, -0.01126004f, -0.05245109f, 0.02370388f, -0.00430749f, 
    0.03744541f, 0.02795352f, -0.01638849f, -0.02212236f, -0.00100756f, -0.00011940f, 0.02048701f, -0.05117242f, 
    0.02290369f, -0.02714858f, 0.04980306f, -0.04633377f, -0.02338643f, -0.02501784f, 0.00280455f, 0.03776155f, 
    -0.04669696f, -0.02626422f, -0.03277221f, -0.01788518f, -0.01423901f, -0.00000348f, 0.01440392f, -0.01247781f, 
    -0.00010950f, 0.03794509f, 0.01833412f, -0.02438713f, 0.02421417f, 0.00230625f, 0.03082491f, 0.04045335f, 
    -0.05072160f, -0.04661853f, 0.02583753f, -0.04446274f, -0.00624373f, -0.00812522f, -0.05010005f, 0.00546824f, 
    -0.02008770f, -0.03882458f, -0.05427691f, 0.02079618f, 0.03229493f, 0.03156551f, 0.03729017f, -0.05919461f, 
    0.00873489f, 0.01356404f, 0.02820938f, 0.03498632f, 0.02844989f, -0.05109051f, 0.04159639f, -0.00009334f, 
    -0.05934548f, -0.03228667f, -0.03945784f, 0.02057743f, -0.03910028f, -0.01821318f, 0.00124056f, 0.00651266f, 
    -0.06148628f, 0.01783425f, -0.00595370f, 0.05410089f, -0.01468425f, -0.04391920f, -0.03007323f, -0.05864771f, 
    0.03205940f, -0.05584764f, 0.01309281f, 0.00427479f, 0.01847016f, 0.02938090f, -0.05150598f, -0.04537361f, 
    0.04643154f, 0.02333775f, 0.05306673f, 0.02405228f, 0.00369464f, 0.00832395f, 0.01257988f, 0.00789412f, 
    -0.03059245f, 0.04615142f, -0.03666345f, -0.00285981f, 0.03262911f, 0.01115927f, -0.00180613f, -0.04472331f, 
    0.00792176f, -0.01939559f, 0.00640955f, -0.00131329f, 0.01751959f, 0.01908613f, 0.03788731f, -0.05113463f, 
    -0.01984258f, 0.01422783f, -0.00380277f, -0.06101198f, -0.04006894f, -0.01842289f, 0.04043898f, -0.03825717f, 
    0.01285047f, -0.04263775f, 0.04865403f, 0.00840340f, -0.02941558f, -0.03555088f, -0.04129706f, 0.04142007f, 
    0.03439949f, 0.01229874f, -0.03511899f, 0.02770965f, 0.02695465f, -0.05716220f, -0.05182865f, 0.01426237f, 
    -0.03787625f, 0.02519385f, 0.02475395f, 0.02254800f, -0.02493509f, -0.02022379f, 0.01406561f, -0.03234237f, 
    -0.00145528f, 0.00529827f, 0.00701987f, -0.01244349f, -0.01143095f, 0.01655879f, 0.01336382f, -0.03506167f, 
    0.03150674f, 0.04213977f, 0.03929811f, 0.02920136f, -0.00810478f, -0.02630089f, -0.00871049f, -0.05402108f, 
    -0.02003140f, 0.01639145f, -0.00698844f, -0.05814243f, 0.00614859f, 0.01528177f, -0.00797244f, 0.01182595f, 
    -0.02140403f, -0.04483169f, 0.01642767f, -0.05979941f, -0.05072784f, -0.03234303f, 0.01498207f, 0.02649429f, 
    0.03765507f, -0.00086984f, 0.02618895f, -0.00485796f, -0.05517206f, -0.04153597f, -0.01048547f, 0.02173877f, 
    0.02332450f, 0.00912046f, -0.05320620f, -0.05784814f, -0.03195040f, -0.05698760f, 0.01474443f, 0.01200149f, 
    -0.03111607f, 0.01634696f, -0.03971299f, -0.02653534f, 0.04616173f, -0.05403798f, 0.00038597f, -0.05225334f, 
    -0.01167754f, -0.02229576f, 0.01049548f, 0.02738916f, -0.01951286f, 0.02465669f, -0.05049708f, 0.00670313f, 
    0.05020104f, 0.00949222f, -0.01093852f, 0.01557587f, 0.00995475f, 0.04443783f, 0.03228713f, -0.05423066f, 
    -0.02669246f, -0.00599748f, 0.01530151f, 0.04644526f, -0.05219050f, 0.04369117f, 0.03466867f, 0.03744008f, 
    -0.05681197f, -0.03099597f, -0.04605601f, -0.01011804f, 0.00768420f, 0.03002505f, 0.01130348f, -0.03304921f, 
    0.03908331f, -0.04788842f, 0.03763569f, -0.03728092f, -0.01774818f, 0.01991273f, 0.05909938f, -0.01456578f, 
    0.00383007f, 0.02991520f, -0.04443330f, 0.03809463f, -0.00866465f, 0.00104034f, 0.04475423f, -0.02842173f, 
    0.04545143f, 0.01220169f, -0.04147704f, -0.06630889f, -0.03661371f, -0.03905354f, -0.04144744f, 0.02844548f, 
    0.03810014f, 0.02180642f, -0.01130936f, -0.03470715f, -0.05167618f, -0.01358129f, 0.04181583f, -0.04363943f, 
    -0.01085729f, -0.02564257f, -0.03899397f, 0.04266788f, 0.03454590f, -0.03063790f, 0.04858481f, -0.04363302f, 
    0.01247787f, 0.01026347f, 0.01938313f, -0.01155538f, -0.03431743f, 0.04267227f, 0.02557341f, 0.05411161f, 
    -0.01614397f, -0.00532478f, 0.02541603f, 0.01234480f, 0.01042956f, -0.04234463f, -0.04360462f, 0.04995425f, 
    0.03722483f, -0.05773209f, -0.05251325f, -0.00006352f, 0.04204525f, -0.02366226f, 0.00300510f, -0.04953668f, 
    -0.05327372f, -0.03278590f, -0.00036560f, -0.04615591f, 0.01067815f, -0.01954115f, -0.00921091f, -0.00475870f, 
    -0.03806449f, -0.01172500f, 0.03856557f, -0.03235102f, -0.00068755f, -0.03857048f, -0.01177020f, -0.02608350f, 
    -0.00737877f, -0.05545616f, 0.04223377f, 0.00230601f, 0.02674275f, -0.01202177f, 0.01279528f, -0.00835813f, 
    0.02877690f, -0.04969352f, 0.03434550f, -0.01250969f, -0.04285084f, -0.04564332f, -0.04268139f, -0.02983085f, 
    0.02264915f, -0.00629152f, -0.00846754f, -0.00528441f, -0.04680701f, 0.05157572f, 0.03853531f, -0.02299943f, 
    -0.03062389f, 0.03454707f, 0.03855788f, 0.04227037f, 0.02491342f, -0.01339306f, 0.00448996f, 0.02126338f, 
    0.05637352f, 0.01421691f, -0.00490230f, 0.05186541f, -0.00989285f, 0.02370342f, 0.01096507f, -0.02122717f, 
    0.03684084f, -0.00871232f, -0.02071518f, -0.01037869f, 0.00745077f, 0.04985549f, 0.01167336f, 0.03216565f, 
    0.05395068f, -0.00211261f, 0.04072965f, 0.01577260f, 0.01620876f, -0.04730979f, -0.03335983f, -0.03691571f, 
    0.01620237f, -0.05440431f, -0.04800893f, -0.03695403f, 0.02888058f, -0.00426002f, -0.04445229f, 0.04310234f, 
    0.02603372f, -0.01775205f, -0.05403936f, 0.00094942f, -0.02434856f, 0.05143166f, -0.05258410f, 0.00323677f, 
    -0.03662769f, 0.00771524f, 0.03297872f, -0.04900484f, -0.05492931f, 0.04211806f, -0.03895567f, -0.00041971f, 
    0.04356949f, -0.00643147f, 0.01157421f, -0.03095812f, -0.03568749f, 0.02224515f, -0.02785783f, -0.04194410f, 
    0.02823965f, 0.04293361f, 0.02059455f, -0.05546831f, -0.01515355f, -0.04510427f, 0.02433464f, -0.04850384f, 
    -0.05018371f, 0.02414383f, -0.00111298f, -0.05222142f, -0.01333702f, -0.03767870f, -0.00139519f, 0.02871313f, 
    0.02155445f, -0.05754178f, -0.04529905f, -0.05960300f, 0.01997714f, -0.05392916f, 0.04473032f, -0.05842461f, 
    0.00655152f, -0.01082788f, -0.04884128f, -0.05868658f, -0.05964361f, -0.00319608f, -0.00493417f, -0.05303155f, 
    0.00843516f, -0.02404439f, 0.04172938f, 0.03205509f, -0.02900324f, -0.04002396f, 0.03880619f, -0.02165025f, 
    0.02495172f, -0.01056307f, -0.05404076f, 0.00047581f, 0.02483439f, -0.04613932f, -0.05855091f, 0.04634191f, 
    0.00240789f, -0.03848634f, 0.01105990f, -0.00009341f, 0.04856165f, -0.03926970f, -0.01123063f, -0.00972110f, 
    0.01199147f, -0.05120523f, -0.04175916f, -0.03464645f, 0.01004038f, 0.00784260f, 0.04808389f, 0.05021370f, 
    -0.01977986f, -0.01117974f, 0.00596506f, -0.02553348f, -0.00935803f, -0.05207295f, -0.04520571f, 0.04770264f, 
    -0.01578710f, -0.00352139f, -0.03435642f, -0.03421777f, -0.01305478f, -0.03280843f, 0.00303858f, -0.04382261f, 
    0.02183547f, 0.02354623f, 0.00074745f, 0.00709880f, 0.02440205f, -0.01864413f, -0.04535748f, -0.01707564f, 
    0.02194632f, -0.00054478f, -0.02090193f, 0.01725730f, -0.01751587f, 0.00389378f, -0.01846729f, 0.00716662f, 
    0.00239781f, 0.03840684f, -0.04688499f, -0.01701937f, -0.00910265f, 0.04651408f, -0.01357607f, 0.03764060f, 
    0.00542162f, -0.03910007f, 0.00334456f, 0.02452392f, 0.02644365f, -0.00777036f, -0.01966874f, 0.04057650f, 
    0.21242639f, -0.01368571f, -0.12311003f, 0.16035265f, 0.00385124f, 0.09910046f, 0.17941576f, -0.04417745f, 
    -0.10178423f, -0.10709930f, 0.08837229f, 0.11673844f, 0.03673600f, -0.02213829f, 0.09149917f, -0.02341941f, 
    0.03001839f, 0.32003173f, 0.01402842f, 0.01242757f, 0.05038282f, 0.05624093f, -0.07681445f, 0.17565447f, 
    0.23796606f, -0.04752767f, -0.04602607f, -0.10468962f, 0.07321040f, 0.07450204f, 0.16606303f, -0.05119269f, 
    0.00082815f, -0.03158342f, -0.10477475f, -0.03816523f, -0.15827146f, 0.01574432f, 0.02857609f, 0.00006252f, 
    0.22887518f, 0.16466755f, 0.15621705f, -0.23053028f, 0.10646758f, 0.04524082f, 0.08496068f, 0.00122143f, 
    -0.03225091f, -0.12818111f, 0.03150654f, -0.04377775f, -0.05704667f, 0.07309412f, -0.04695898f, -0.06722374f, 
    -0.15697092f, 0.03317658f, 0.00829180f, -0.00443813f, -0.02319441f, 0.23344044f, 0.03938597f, -0.13770239f, 
    0.08501029f, -0.00066308f, -0.07745329f, -0.02831609f, -0.02640851f, 0.04541765f, 0.02749648f, -0.07890457f, 
    0.04425300f, 0.06572248f, -0.00263670f, 0.05092634f, -0.04309983f, -0.00363919f, 0.08185208f, -0.05886796f, 
    0.41385549f, 0.38933596f, 0.01757342f, -0.01241462f, 0.27184197f, -0.15252179f, 0.14192745f, 0.18852852f, 
    0.11390437f, -0.01520544f, 0.03665670f, 0.12477595f, -0.03388731f, -0.01603132f, -0.08400291f, -0.00539370f, 
    -0.03467199f, 0.00830271f, 0.03578456f, 0.03308145f, 0.09177589f, 0.05421830f, -0.03746432f, 0.05833449f, 
    0.04902306f, 0.00953816f, -0.04366218f, -0.01730655f, 0.07821775f, 0.08103567f, -0.05948383f, 0.08191484f, 
    0.05651292f, 0.00024087f, -0.04073373f, -0.01042587f, 0.16119695f, -0.02665647f, -0.02981570f, -0.09915090f, 
    -0.22213346f, -0.33677322f, 0.08895747f, 0.05037551f, 0.19282404f, -0.09570828f, 0.03792410f, -0.05587918f, 
    0.10531920f, -0.00573270f, 0.00167723f, -0.03290686f, -0.05188382f, 0.09199224f, 0.04794458f, -0.03499557f, 
    0.06637769f, 0.02429247f, -0.02737681f, -0.09264609f, -0.00899763f, 0.06855284f, -0.07022800f, -0.10025783f, 
    -0.28721887f, 0.00545878f, -0.01334168f, 0.07121353f, -0.02958492f, -0.11858391f, -0.01724764f, 0.10564476f, 
    0.07389938f, 0.05382774f, 0.02843640f, 0.11221562f, -0.10766152f, -0.04049703f, 0.08089191f, 0.03383416f, 
    -0.22819608f, 0.02405835f, 0.09538633f, -0.11483200f, -0.16306049f, 0.14411558f, 0.09558757f, 0.07566237f, 
    -0.05461402f, -0.04153656f, 0.08514765f, -0.11393499f, -0.07591044f, -0.02211713f, 0.06912323f, 0.02415987f, 
    -0.04225836f, -0.02695927f, 0.10647395f, -0.17814426f, 0.41807234f, -0.03686789f, 0.06650987f, -0.20417689f, 
    -0.08652607f, 0.04552596f, -0.05043835f, -0.02688640f, -0.05618036f, -0.05237593f, 0.05119304f, 0.00093557f, 
    0.06220143f, 0.03546387f, -0.12616022f, 0.06104046f, -0.01084225f, 0.16462113f, 0.11938509f, 0.02940608f, 
    -0.23644796f, 0.14691840f, -0.09854510f, -0.00129106f, -0.02301506f, 0.00116760f, -0.07370374f, 0.02932751f, 
    0.24505642f, 0.17025167f, -0.15818934f, -0.05660823f, 0.18392830f, -0.11131442f, 0.10648450f, -0.02596016f, 
    0.17767155f, -0.04837009f, -0.09972852f, -0.06990056f, -0.18227549f, -0.35153532f, 0.21316996f, -0.12988269f, 
    0.14734070f, 0.14253823f, 0.00697221f, -0.08898544f, 0.07868310f, 0.08864733f, -0.14642477f, -0.01947055f, 
    0.04232506f, -0.01090572f, -0.03303857f, -0.03570649f, -0.02295120f, -0.13693185f, -0.21184424f, 0.03374272f, 
    -0.11116765f, -0.27481934f, -0.08736167f, -0.09206149f, 0.10184541f, -0.16553193f, -0.05724868f, -0.01727058f, 
    0.09373329f, -0.18932195f, -0.07493883f, -0.01209711f, -0.05109828f, 0.07619611f, 0.17594126f, -0.08044232f, 
    0.07276481f, -0.03370386f, -0.03287292f, 0.15455188f, -0.19723472f, -0.13509148f, 0.11628291f, -0.07799041f, 
    0.07303321f, 0.07672539f, -0.05456310f, 0.00507132f, 0.09577200f, -0.00184860f, 0.02403431f, 0.06551909f, 
    0.12112339f, 0.05301379f, -0.01284298f, 0.11984397f, 0.02760844f, -0.01422572f, 0.12564839f, 0.02673768f, 
    -0.08571471f, 0.11080327f, -0.08016247f, -0.04478022f, -0.09192507f, 0.06229246f, -0.03416312f, 0.01421725f, 
    0.03298986f, 0.05980031f, 0.02512292f, 0.03754112f, -0.03026004f, -0.13064472f, -0.05444620f, -0.00002390f, 
    -0.07850595f, 0.08761592f, 0.18397996f, 0.01843278f, -0.19268173f, 0.24090083f, 0.00551202f, -0.07673091f, 
    0.25653046f, -0.03913880f, -0.02718208f, 0.17832989f, -0.03703158f, 0.00863978f, -0.05053217f, -0.02072462f, 
    -0.16714166f, -0.04329865f, -0.04594839f, -0.04724806f, -0.01638834f, -0.06591739f, -0.00858174f, -0.05058971f, 
    0.07270779f, 0.08531050f, -0.08478911f, 0.07053360f, -0.24401511f, 0.11016554f, 0.03843397f, 0.03108682f, 
    0.04771076f, 0.00977342f, -0.06621762f, -0.11760479f, -0.01021488f, 0.12253109f, 0.00607105f, 0.07537166f, 
    0.01527824f, -0.26762849f, -0.21746036f, -0.11066443f, -0.10382917f, 0.22641636f, 0.03528729f, 0.12460183f, 
    -0.15732278f, 0.21500090f, 0.12403248f, 0.19084284f, 0.01281917f, -0.08145604f, -0.01140334f, 0.06469072f, 
    0.16017295f, 0.12145519f, 0.08121484f, 0.03777746f, 0.12936239f, 0.06770288f, -0.07474155f, -0.10718508f, 
    0.05637438f, -0.14765696f, 0.04372381f, -0.13358463f, 0.01228448f, -0.08040705f, 0.05532731f, 0.04839322f, 
    -0.00280029f, 0.02322551f, 0.01975609f, -0.11900193f, 0.07499814f, -0.05139356f, 0.07312217f, 0.10989678f, 
    0.12127870f, -0.00498548f, 0.08052272f, 0.02466601f, 0.03048740f, -0.24497692f, -0.06389762f, -0.22468647f, 
    0.15596944f, -0.04277214f, 0.05168092f, 0.00113246f, -0.01272261f, -0.06558387f, 0.11688737f, 0.15447521f, 
    0.09764702f, 0.19042568f, 0.02614562f, 0.00488299f, 0.04837664f, 0.01201911f, -0.20742768f, 0.13853422f, 
    -0.29635632f, 0.02376168f, -0.18741319f, 0.14573522f, -0.36231345f, 0.11203632f, 0.05069808f, -0.00781335f, 
    -0.19667415f, 0.03356894f, -0.08323445f, 0.04882048f, 0.05163699f, -0.14195700f, 0.11357950f, 0.08195584f, 
    0.12381541f, 0.04312177f, -0.02201094f, 0.02326702f, -0.21101473f, 0.16239063f, -0.05169582f, 0.05386584f, 
    -0.17347814f, 0.28401226f, 0.09466251f, 0.08182563f, -0.00920265f, -0.01661315f, 0.05746072f, -0.02871582f, 
    -0.04625190f, 0.07161225f, -0.03791638f, 0.00294991f, -0.04200190f, 0.15502933f, 0.12757528f, 0.01034591f, 
    -0.00018254f, 0.04158150f, -0.00475258f, -0.09770665f, 0.04357526f, -0.19264430f, -0.04286792f, 0.06167146f, 
    0.04863613f, -0.03481712f, 0.14687824f, 0.06490535f, -0.02922079f, -0.04962302f, 0.04362587f, -0.01480686f, 
    -0.09469891f, 0.04108916f, -0.08185115f, 0.01128487f, 0.29982981f, -0.19493975f, -0.31397846f, 0.04730482f, 
    0.01490844f, -0.01506607f, 0.08154541f, -0.03585945f, -0.04191151f, -0.01437038f, -0.00671071f, -0.07128816f, 
    0.00950372f, -0.11031316f, -0.09353796f, -0.01388913f, 0.11000702f, 0.01378574f, 0.09194247f, -0.11966580f, 
    0.38307995f, 0.08872247f, -0.20848194f, 0.09560207f, -0.01028088f, -0.06680922f, -0.00902503f, -0.04150654f, 
    0.04434825f, 0.09662409f, 0.03366802f, -0.08508314f, 0.20908378f, 0.14680395f, -0.01962226f, -0.00406637f, 
    0.09063867f, -0.17456453f, 0.06476543f, 0.18901886f, -0.28838986f, -0.28088900f, 0.04232609f, -0.17520025f, 
    0.13307528f, 0.00400145f, -0.06381443f, 0.01115403f, 0.10854007f, -0.06577241f, 0.17651905f, -0.07347225f, 
    0.04480873f, 0.05179604f, 0.01075264f, 0.00441743f, 0.14035809f, -0.02423215f, -0.07034365f, 0.05687501f, 
    -0.19332092f, 0.07224551f, 0.14284618f, -0.03782355f, -0.25628781f, 0.12331787f, 0.06967831f, -0.02872673f, 
    -0.18288492f, 0.06630896f, -0.02277245f, 0.01140832f, 0.00459990f, 0.10781018f, 0.01905042f, 0.02672561f, 
    -0.24003465f, 0.12553720f, 0.07161799f, -0.07301057f, -0.12681857f, -0.16444564f, 0.13935959f, 0.00193583f, 
    0.07797416f, -0.07911136f, 0.07552992f, -0.14616033f, 0.03160604f, -0.03755459f, 0.10098363f, -0.07577276f, 
    -0.04469599f, -0.05483736f, 0.12138709f, -0.07102460f, 0.03591069f, 0.04673986f, 0.13241297f, -0.11289679f, 
    -0.17889248f, 0.04669730f, 0.10896959f, -0.21954671f, -0.01574876f, 0.02255332f, 0.04042972f, -0.11934231f, 
    0.01178836f, -0.05295759f, 0.11732499f, 0.19756277f, 0.15721740f, -0.06215901f, 0.00067479f, -0.05902965f, 
    0.09471916f, -0.14052540f, 0.05464223f, -0.19680366f, -0.07264502f, 0.09455039f, -0.03346566f, -0.16359873f, 
    0.22311303f, 0.07433633f, -0.01888977f, 0.00979893f, 0.03120802f, 0.01351836f, 0.03532444f, 0.06863004f, 
    -0.23158629f, 0.09533796f, 0.08130963f, -0.09065953f, -0.02898399f, -0.00614042f, -0.10838377f, 0.13065425f, 
    0.03590978f, 0.10028024f, -0.06307963f, -0.14921811f, 0.16783763f, 0.07058321f, 0.02271884f, 0.03727647f, 
    0.03948729f, -0.06455969f, 0.02582459f, -0.00576286f, 0.11620579f, 0.12218227f, 0.18586238f, -0.02937244f, 
    0.07966573f, 0.02405312f, -0.16985349f, 0.05125140f, 0.21602248f, 0.08542196f, -0.34107575f, -0.12924409f, 
    -0.29275927f, -0.00548252f, 0.13744639f, -0.06943311f, -0.01582115f, -0.01609497f, 0.00038226f, 0.11927158f, 
    0.00282479f, 0.07013058f, -0.02582218f, -0.04257227f, 0.08127684f, 0.16677269f, -0.20550543f, 0.04706953f, 
    0.27921617f, 0.27788052f, -0.18460594f, 0.24844681f, -0.00467381f, 0.01823875f, 0.13127925f, 0.05465323f, 
    0.19661272f, 0.14321616f, -0.11373357f, -0.17234541f, -0.17945696f, 0.14026578f, 0.01441163f, 0.09542721f, 
    0.07195874f, 0.02190777f, 0.07149386f, 0.02818371f, 0.15471567f, 0.06877572f, -0.08686039f, 0.40241298f, 
    0.11157309f, -0.03025470f, 0.08548485f, 0.11248633f, 0.07705851f, -0.09688307f, -0.10671078f, 0.04551756f, 
    0.02779519f, -0.05988295f, 0.08434589f, -0.01891805f, 0.08685905f, 0.11689638f, -0.03344403f, -0.15520026f, 
    -0.14549008f, -0.27457979f, -0.19139798f, -0.15311094f, -0.00747805f, -0.06883730f, -0.04038762f, -0.04164327f, 
    0.08045580f, -0.07874095f, -0.01423927f, 0.05588472f, 0.03332543f, 0.00772008f, 0.07794684f, -0.06991274f, 
    -0.01811787f, -0.08354669f, -0.12949684f, 0.05265590f, -0.37307805f, -0.19803420f, -0.14842528f, -0.20887847f, 
    0.07492243f, 0.06722959f, -0.14696167f, 0.05634972f, -0.08842915f, 0.00165159f, -0.01535372f, -0.01846348f, 
    -0.01731208f, -0.00773536f, 0.16093031f, 0.06350338f, 0.11998171f, 0.14410888f, -0.05721284f, 0.17508647f, 
    0.39664105f, -0.35513848f, 0.19691712f, 0.24480857f, -0.19879720f, -0.00574990f, 0.13315165f, 0.00996317f, 
    0.19489077f, -0.12615503f, 0.07359654f, 0.00890638f, -0.05314096f, -0.00082301f, 0.01679579f, 0.09093041f, 
    0.11467355f, -0.10421254f, 0.07221711f, 0.01790852f, 0.00075134f, 0.08887918f, -0.04397877f, 0.13975094f, 
    -0.01344211f, 0.01787713f, 0.11753265f, 0.02732869f, 0.00701967f, 0.03164915f, 0.05018583f, 0.07880080f, 
    -0.08391384f, 0.09557310f, -0.02242736f, -0.04280622f, -0.11736979f, 0.01332805f, 0.05589357f, 0.03399690f, 
    -0.00167075f, -0.43815216f, -0.04428459f, -0.10528659f, -0.30410776f, 0.10246265f, -0.02767828f, 0.08061282f, 
    -0.05524786f, 0.04738129f, -0.03003858f, 0.01453270f, 0.07484648f, -0.06081729f, 0.01106350f, 0.07648867f, 
    -0.03676588f, -0.00439369f, -0.02167280f, 0.05066247f, -0.14801069f, 0.19374506f, -0.09585752f, 0.24137650f, 
    0.16240062f, 0.20933704f, -0.02299897f, -0.01024835f, 0.07776341f, -0.10880113f, -0.07996525f, -0.11600210f, 
    0.10601388f, -0.06575010f, 0.10674530f, -0.06691747f, 0.05814333f, 0.02067790f, 0.18458450f, 0.09442377f, 
    -0.28518730f, 0.37256017f, 0.04794899f, 0.07901595f, 0.11833119f, 0.01809684f, 0.02586840f, -0.05672903f, 
    -0.02997908f, -0.06649481f, -0.11162660f, 0.04593914f, -0.02908876f, 0.12361575f, -0.08985976f, 0.07230391f, 
    0.01107634f, 0.03581562f, 0.06430548f, 0.15801919f, -0.04431438f, 0.10696214f, 0.08269803f, 0.09237506f, 
    0.04815442f, 0.06676871f, -0.08237437f, -0.04115310f, -0.00968447f, 0.09850612f, 0.14226887f, -0.04910048f, 
    0.15372656f, 0.05393424f, -0.00645338f, 0.09719060f, -0.02010848f, 0.02917552f, -0.12632872f, 0.06675178f, 
    -0.12495178f, -0.07603686f, 0.00277292f, 0.17408176f, 0.02607730f, -0.04671620f, -0.03848498f, 0.01803384f, 
    -0.08129062f, -0.03371361f, -0.04413654f, 0.03981849f, 0.04253015f, 0.04245563f, 0.03811822f, 0.24638018f, 
    -0.12466396f, -0.08872326f, -0.04505422f, 0.00391629f, -0.07526583f, -0.17115352f, -0.22858839f, -0.00750717f, 
    0.12862080f, -0.00487838f, 0.03626132f, -0.00024249f, 0.02541829f, -0.01043108f, -0.02589654f, 0.04314838f, 
    -0.04402299f, 0.08765852f, 0.15470658f, -0.08590206f, -0.02138110f, 0.07657549f, -0.00429681f, 0.02614432f, 
    -0.14227198f, 0.08352880f, -0.31434968f, -0.39267200f, 0.07467462f, -0.06973008f, 0.07005279f, -0.12269221f, 
    0.09154681f, 0.10338492f, 0.09779023f, 0.05119588f, 0.00389646f, -0.08576235f, -0.01095917f, -0.07360172f, 
    0.11625695f, 0.10223593f, 0.12747189f, -0.07594325f, -0.13202322f, 0.03934284f, -0.07545845f, -0.22817941f, 
    -0.02812464f, -0.00512364f, -0.03546034f, 0.13238145f, -0.05495004f, 0.06788369f, -0.10289567f, -0.01141828f, 
    -0.01870348f, -0.02700086f, 0.18797512f, 0.03551386f, 0.07098307f, 0.16152695f, -0.07239282f, 0.13794996f, 
    -0.16114886f, 0.36632022f, 0.09529202f, -0.04987751f, 0.23756412f, 0.09634047f, 0.10644551f, 0.01665897f, 
    0.01490073f, 0.11798149f, -0.04536002f, -0.09416810f, 0.04572193f, 0.00489948f, 0.11278939f, -0.02316858f, 
    0.08997852f, 0.13797063f, 0.07019853f, -0.00267734f, 0.14204432f, -0.14255901f, 0.09798577f, 0.06150612f, 
    0.01394447f, -0.01214402f, 0.04965993f, 0.03399954f, 0.16557384f, 0.04227551f, 0.06638578f, 0.03688879f, 
    -0.01238726f, -0.00077035f, -0.00667440f, 0.01380244f, -0.06765548f, -0.07299402f, 0.03546983f, -0.07401372f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.05045662f, -0.05342251f, -0.02849844f, -0.04221204f, 0.01326239f, -0.07577174f, -0.01586750f, -0.03183539f, 
    -0.01363785f, -0.03028901f, 0.09791510f, 0.05621134f, 0.02104922f, -0.05717613f, -0.01840676f, 0.03611468f, 
    0.02446516f, 0.04490469f, 0.01291101f, 0.02462054f, 0.09400561f, -0.03352742f, -0.00487519f, 0.09461259f, 
    -0.03536515f, 0.08334452f, 0.01948584f, 0.01499894f, -0.02780020f, -0.02236863f, -0.00125341f, -0.02003993f, 
    0.09646729f, -0.00967148f, 0.03797293f, 0.03004428f, 0.09756017f, -0.04545131f, 0.00744051f, 0.04278602f, 
    -0.04731617f, 0.00514226f, -0.05893175f, 0.01388398f, 0.01474411f, 0.00119596f, -0.01701131f, -0.00577711f, 
    0.04884501f, -0.05487996f, 0.05899945f, 0.02922272f, 0.10279606f, 0.09088723f, 0.06902561f, -0.05143832f, 
    -0.04355088f, -0.06276930f, -0.05697893f, -0.02926900f, -0.02898450f, -0.05030936f, 0.06231925f, 0.02846778f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06038854f, 0.22971675f, 0.11250527f, 0.16967423f, 0.10553361f, -0.27853233f, -0.43226153f, -0.09116139f, 
    -0.08946230f, -0.02831284f, -0.66330147f, 0.07500482f, -0.39158249f, -0.13179514f, 0.05774339f, -0.06947576f, 
    0.06373837f, -0.05767933f, 0.34773371f, -0.52300662f, 0.29386330f, -0.04364581f, 0.12596852f, -0.25571996f, 
    0.26291597f, 0.04579641f, 0.05865812f, -0.01448030f, 0.04794685f, 0.04966441f, 0.11528478f, -0.07313550f, 
    -0.42652848f, 0.11588525f, -0.29630995f, 0.20553268f, 0.19998169f, 0.22773635f, 0.08673854f, -0.11677770f, 
    0.05554373f, -0.07641550f, -0.06835210f, -0.05694661f, 0.36108762f, 0.16057901f, 0.21791233f, -0.13069229f, 
    0.03617401f, 0.04163045f, 0.20213357f, -0.04588987f, -0.17930353f, -0.11878788f, -0.51567060f, 0.00300404f, 
    0.07992169f, 0.16940182f, 0.01062005f, 0.01711250f, 0.09022085f, 0.03301433f, -0.43622535f, -0.29270300f, 
    0.10041414f, 0.22414722f, 0.18454282f, -0.07412957f, 0.09443347f, 0.04333687f, -0.16781440f, -0.31897151f, 
    0.05798462f, -0.11409734f, 0.11749181f, 0.20314512f, -0.42797109f, 0.06045404f, 0.38958627f, -0.07357197f, 
    0.11690808f, -0.06994143f, 0.10615096f, -0.39099142f, 0.10781928f, -0.10870291f, -0.02045188f, 0.30821890f, 
    -0.16155879f, 0.09826772f, -0.09126744f, 0.00393627f, -0.11722961f, -0.08099844f, -0.03937312f, -0.02806837f, 
    -0.04936344f, 0.11180393f, 0.05374125f, 0.15150924f, 0.02909430f, 0.07128759f, -0.05027468f, -0.06175689f, 
    0.05640637f, 0.07084461f, 0.15322538f, -0.05362394f, -0.27112919f, -0.59452671f, -0.16077048f, 0.12184839f, 
    0.46179119f, 0.10172069f, 0.06758858f, 0.11921954f, 0.21795450f, 0.34683990f, -0.03588863f, -0.20514654f, 
    0.09127993f, -0.99875134f, 0.05761921f, 0.04821156f, 0.10994943f, -0.02239089f, -0.01824746f, -0.12907198f, 
    -0.01426156f, -0.12292960f, -0.20383643f, 0.35042661f, 0.04255838f, -0.13795561f, 0.28037205f, -0.02802012f, 
    -0.05664846f, 0.11285233f, 0.16146804f, 0.18932736f, -0.27631387f, 0.04634294f, 0.27365008f, -0.02519191f, 
    -0.04041281f, 0.08080057f, -0.33907387f, 0.21527351f, -0.28373966f, -0.03593636f, 0.05405778f, -0.27780539f, 
    -0.32701999f, -0.34651986f, 0.10968795f, -0.08175284f, 0.01995455f, 0.02518126f, 0.04479880f, 0.00623912f, 
    -0.19066922f, 0.07459517f, 0.22608514f, -0.01174478f, -0.79472560f, -0.48864248f, 0.08640555f, 0.05970898f, 
    0.04074337f, 0.04329230f, 0.04667249f, 0.15693559f, 0.18208730f, -0.08704580f, 0.15938109f, -0.11390766f, 
    0.28396034f, 0.10182791f, -0.03431397f, 0.29459947f, -0.38423634f, -0.07145697f, 0.10343473f, -0.56599140f, 
    0.07054948f, 0.18873525f, -0.01871935f, 0.10672126f, -0.03428967f, 0.12268840f, 0.22920817f, -0.32886770f, 
    -0.02273771f, -0.01811999f, -0.25628111f, 0.09099775f, -0.61016130f, -0.01642848f, 0.25404805f, -0.40508395f, 
    0.01073970f, -0.07196696f, 0.11357918f, -0.15461487f, -0.23575981f, 0.08062866f, -0.52243477f, -0.09857155f, 
    -0.13094933f, -0.07703371f, -0.07366815f, 0.09163779f, -0.01266908f, 0.07515980f, 0.02559702f, -0.05155293f, 
    0.27123499f, -0.17235073f, -0.01562679f, 0.08974618f, -0.08716130f, -0.08055470f, -0.00390793f, -0.04754959f, 
    -0.11510783f, 0.15212479f, 0.17949775f, 0.14308380f, -0.03161038f, 0.15826254f, -0.01430758f, 0.08197166f, 
    0.00357930f, -0.07503094f, -0.12629153f, -0.05829516f, 0.29470059f, 0.20686737f, -0.59747088f, -0.01345577f, 
    -0.09319527f, -0.63555247f, -0.17524929f, 0.34297270f, 0.14476451f, -0.47757089f, 0.11208314f, 0.27192846f, 
    0.02475695f, 0.06795375f, -0.12548484f, 0.09487299f, 0.08617675f, 0.17462519f, -0.50375962f, 0.41429901f, 
    -0.04645151f, 0.10809805f, -0.31673408f, 0.06436870f, 0.11481127f, -0.26052997f, -0.24834301f, 0.02903610f, 
    0.05559406f, -0.04675963f, 0.13265912f, 0.08326559f, 0.08907466f, -0.10372175f, -0.64403862f, 0.00346154f, 
    0.03486214f, -0.03672343f, -0.40023565f, 0.28303280f, -0.13363834f, -0.12339131f, -0.09835556f, 0.00214463f, 
    -0.23082063f, -0.09846177f, 0.07216958f, 0.00705463f, -0.07029714f, -0.00748311f, -0.06770255f, -0.09846245f, 
    0.33537200f, -0.32969111f, -0.08895013f, 0.23282140f, 0.03137200f, 0.15885827f, 0.10164642f, -0.01354934f, 
    -0.08810738f, -0.09031343f, -0.08880121f, 0.18807039f, 0.31290632f, 0.29408741f, -0.39021865f, -0.08916395f, 
    -0.10805133f, 0.07162590f, 0.17204566f, -0.29486412f, 0.32453808f, 0.00119136f, 0.04254271f, 0.09884194f, 
    -0.05402683f, -0.03832265f, 0.08885545f, -0.04969804f, 0.11745473f, 0.28987861f, -0.27251878f, -0.20452189f, 
    -0.00013305f, 0.20413747f, 0.20169127f, -0.03125714f, 0.12328006f, -0.12133898f, -0.63718134f, 0.20300132f, 
    -0.10760569f, 0.04608310f, -0.11742261f, -0.19673872f, 0.29688886f, -0.01090281f, -0.07530629f, 0.05535270f, 
    0.00882079f, -0.11650739f, -0.02530307f, -0.16938336f, 0.27283478f, -0.10705116f, -0.12524498f, 0.13604309f, 
    -0.36018065f, 0.00574877f, 0.03407153f, 0.04155593f, 0.08506149f, -0.05582976f, 0.08468254f, 0.00883803f, 
    -0.12971166f, 0.03418165f, 0.07707708f, 0.30768582f, 0.17216940f, 0.21401247f, -0.03728130f, 0.10568577f, 
    -0.02229839f, 0.11679675f, -0.36654380f, 0.16467708f, -0.51086402f, -0.20179777f, 0.10407728f, -0.01807882f, 
    -0.63953638f, 0.19746614f, 0.08198500f, -0.17763004f, -0.11556292f, -0.20839073f, 0.02395794f, 0.21250857f, 
    0.09828478f, -0.18952587f, 0.09479053f, 0.00914071f, 0.09075514f, -0.37150985f, 0.37589499f, 0.23338009f, 
    0.06204075f, -0.42631513f, -0.77295500f, -0.84711760f, -0.17944916f, -0.10272459f, 0.37370402f, 0.19384310f, 
    0.10795308f, -0.01615781f, 0.27923745f, -0.16844085f, 0.11718828f, -0.02838957f, 0.39345601f, 0.03486419f, 
    0.08224773f, 0.07814109f, -0.12272829f, 0.25348452f, 0.00354815f, -0.03848921f, -0.08793706f, 0.12270009f, 
    -0.12596726f, 0.20333973f, -0.01025796f, -0.07640408f, 0.05272159f, -0.09271317f, 0.04561812f, 0.09390907f, 
    -0.02200307f, 0.17272013f, -0.17464390f, -0.35914063f, -0.12818961f, 0.21709558f, -0.10122982f, -0.02794089f, 
    0.09982623f, 0.10904065f, 0.31062290f, -0.20897010f, -0.19666588f, 0.19945286f, 0.23195623f, -0.06467474f, 
    0.26343879f, 0.10708643f, -0.03326213f, -0.43223658f, -0.16795263f, -0.51697600f, -0.61217141f, 0.17347054f, 
    0.11158372f, -0.09689514f, -0.05907384f, -0.05568090f, 0.10096269f, 0.35282919f, 0.03648124f, 0.20753691f, 
    -0.07843950f, 0.17894225f, 0.35133079f, 0.23083366f, 0.03797403f, 0.25658572f, 0.25303996f, -0.15126665f, 
    -0.03730297f, -0.08016647f, 0.21426672f, -0.25426883f, 0.26908359f, 0.05960805f, -0.08312479f, -0.11824197f, 
    0.01961396f, -0.07678377f, 0.14761378f, 0.00189774f, -0.53624719f, -0.07585011f, -0.42078069f, -0.03408598f, 
    -0.03907879f, -0.49139607f, -0.09171585f, -0.05797404f, 0.06888092f, -0.07641656f, -0.06815034f, 0.02344410f, 
    0.09238988f, -0.13937595f, -0.36042541f, 0.04147311f, 0.17927118f, 0.00305079f, -0.00751881f, -0.01940786f, 
    0.04561218f, -0.04596927f, 0.26123041f, -0.33812425f, 0.09954507f, 0.17297110f, 0.15426119f, -0.09976114f, 
    -0.34690422f, -0.10581300f, -0.63750350f, 0.09425117f, -0.33131778f, -0.20283173f, 0.09365656f, 0.11014385f, 
    -0.04743977f, 0.23962808f, -0.03420649f, -0.09003385f, -0.00078841f, -0.20389578f, -0.26842919f, -0.39752778f, 
    -0.08729416f, 0.03392420f, -0.20320417f, -0.12517464f, 0.05874972f, 0.42311829f, -0.29416853f, -0.13243617f, 
    -0.09762012f, 0.12214045f, -0.29699045f, 0.23978393f, 0.03909449f, 0.00645295f, -0.31565678f, 0.06714473f, 
    -0.10177086f, -0.02380920f, 0.32293582f, 0.17981105f, -0.44889921f, -0.01128371f, 0.05777196f, 0.10540615f, 
    -0.29490423f, 0.19201522f, -0.09125762f, 0.00871118f, 0.03983417f, -0.06404796f, -0.07042594f, -0.02699209f, 
    -0.22088952f, -0.01261356f, 0.28319880f, -0.37372217f, -0.31246987f, 0.18652816f, 0.01604094f, -0.13329512f, 
    -0.08427995f, 0.06470373f, 0.27644596f, 0.18034804f, -0.43499509f, -0.41941720f, 0.33332503f, -0.05918621f, 
    -0.16518928f, -0.31286705f, -0.45752573f, -0.22848016f, 0.11116868f, 0.10269693f, 0.19874245f, -0.14758889f, 
    -0.05176928f, 0.10310920f, 0.09768265f, -0.03238408f, -0.00069018f, 0.04316079f, 0.09123225f, 0.07167154f, 
    0.03871840f, -0.58143413f, 0.01529752f, -0.10937563f, 0.21963607f, 0.36777174f, 0.28221187f, 0.26372260f, 
    -0.07746854f, 0.05100138f, 0.24396384f, 0.16741851f, 0.05467845f, 0.07062616f, -0.14622399f, -0.02534922f, 
    0.01926155f, -0.01103132f, -0.22424422f, -0.23019361f, -0.17962758f, -0.02857348f, 0.14960980f, -0.13067721f, 
    0.25072864f, -0.20596157f, 0.10342326f, -0.12394118f, -0.06261272f, -0.00380361f, 0.11041197f, 0.10775012f, 
    -0.26222897f, -0.31226400f, -0.20882708f, -0.37912658f, 0.25610533f, -0.55876499f, -0.04776619f, 0.05438167f, 
    0.08112977f, -0.06215479f, 0.15932289f, 0.21909876f, 0.19246832f, -0.23448926f, -0.09740675f, -0.02844574f, 
    -0.26135820f, 0.17542727f, 0.14400522f, -0.27289945f, -0.37190095f, 0.17111270f, -0.17202520f, 0.15050937f, 
    -0.01399021f, 0.13942556f, 0.11759195f, 0.10638610f, -0.05141283f, -0.52872258f, -0.20955026f, -0.00556855f, 
    0.00187586f, -0.30127370f, 0.16697286f, 0.15067421f, -0.12871815f, -0.47750652f, 0.26895559f, -0.23933162f, 
    -0.01600433f, 0.06863010f, 0.07428467f, -0.04152874f, -0.10741154f, -0.03296298f, 0.03001472f, 0.00674841f, 
    0.01962835f, 0.09166873f, 0.19061410f, 0.19411744f, 0.20328194f, -0.03845999f, -0.28565496f, 0.31846988f, 
    0.24632180f, 0.24405971f, -0.08870061f, 0.06274331f, -0.02689946f, 0.03105023f, 0.00760265f, 0.09543549f, 
    0.14227884f, -0.70272392f, 0.25478271f, -0.30134654f, 0.20179735f, -0.35028177f, 0.11161764f, 0.09064095f, 
    0.03805332f, 0.01131753f, -0.41322032f, 0.02687636f, -0.29495752f, 0.01098195f, 0.15104392f, 0.08501446f, 
    0.14485292f, -0.41980416f, -0.49152160f, 0.12593390f, 0.30336148f, 0.07877187f, 0.08628120f, 0.08256248f, 
    0.10676910f, -0.06571465f, 0.02748908f, -0.03263454f, -0.08597050f, -0.25981146f, 0.25032198f, -0.42011088f, 
    -0.06997226f, -0.27144140f, 0.38418618f, -0.29226509f, -0.54645258f, 0.11732799f, -0.28197357f, 0.31640321f, 
    -0.05282001f, -0.04000805f, -0.16448854f, -0.10271724f, 0.24676350f, -0.04480077f, 0.16862643f, -0.01018038f, 
    -0.10367887f, 0.01808033f, 0.02988230f, 0.24445748f, 0.18514431f, 0.11363591f, 0.15845940f, -0.53007907f, 
    0.12333053f, 0.00189645f, -0.01101990f, -0.04801708f, 0.03008035f, -0.11099382f, -0.12646033f, 0.07109328f, 
    0.34257588f, 0.52742529f, -0.05057091f, -0.32534531f, -0.08861798f, -0.15055381f, -0.04442627f, -0.09279242f, 
    0.03578625f, 0.04251322f, -0.06280448f, -0.36964059f, -0.06180736f, -0.09593882f, -0.35786641f, 0.00417479f, 
    -0.16427222f, -0.35599142f, 0.21611935f, 0.18361357f, -0.21670108f, 0.34396738f, 0.11051474f, 0.10939819f, 
    -0.06368709f, 0.13947757f, 0.02629174f, -0.11659388f, 0.01667751f, 0.20034964f, -0.03483609f, 0.03155908f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.04144422f, 0.08303484f, -0.13363695f, -0.03056433f, -0.03626759f, 0.09493952f, -0.02133026f, -0.02132421f, 
    -0.03536122f, 0.10622295f, 0.18473858f, -0.00347508f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
