#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.19921620f, -0.83531868f, -0.71015024f, -0.56166631f, 0.08035009f, -0.14500758f, -0.24234313f, -0.19366394f, 
    -0.22365405f, 0.29495573f, 0.19045727f, -0.11464322f, -0.14773826f, -0.41651285f, -0.05223882f, 0.18580163f, 
    0.05563354f, -0.15116906f, 0.23648265f, -0.38970894f, 0.00800020f, -0.46874526f, 0.31389874f, 0.17844751f, 
    0.33822957f, 0.11402771f, 0.51390058f, 0.60367543f, 0.51601583f, 0.16958286f, -0.36389953f, 0.50246298f, 
    0.27956635f, 0.40772960f, 0.63002241f, -0.62087584f, -0.01351129f, -0.23157500f, -0.52275598f, -0.01688521f, 
    -0.29023582f, 0.00617811f, -0.18478471f, -0.15970352f, -0.13094196f, -0.25914490f, 0.04890690f, -0.01454691f, 
    0.15474202f, -0.01955681f, 0.38823196f, 0.50136292f, -0.66169947f, 0.09923601f, -0.46365249f, -0.56992573f, 
    0.01174804f, -0.18941899f, 0.08424655f, -0.50885576f, -0.23207979f, -0.22239685f, 0.00358246f, -0.03882601f, 
    0.21704587f, 0.09208277f, -0.40201926f, 0.22543514f, -0.21386036f, 0.06137324f, 0.36774728f, -0.23496802f, 
    0.06003769f, -0.03443412f, 0.01697546f, 0.68042868f, -0.13935965f, -0.45973828f, 0.32084274f, -0.38302985f, 
    0.45070487f, -0.08863396f, -0.12948106f, 0.07939121f, 0.13890404f, 0.15409535f, 0.48612869f, -0.31033006f, 
    0.20530495f, 0.06414153f, 0.24215162f, 0.04180733f, -0.12987116f, 0.30991396f, -0.07731603f, -0.40690646f, 
    -0.18391687f, -0.10609799f, 0.27755260f, -0.26848209f, 0.55521846f, -0.70241451f, -0.65126222f, -0.21050397f, 
    0.45961523f, 0.76898587f, 0.56168228f, 0.24713422f, 0.54643029f, 0.32465416f, -0.20226133f, -0.04833552f, 
    -0.23713113f, 0.12623180f, -0.23969872f, -0.02214066f, -0.09057757f, 0.10896062f, -0.08849794f, 0.04431422f, 
    0.11782486f, -0.24657081f, -0.24195650f, -0.01122466f, -0.10366817f, -0.65588707f, 0.79323685f, -0.13618040f, 
    0.70073265f, -0.86696178f, 0.03380289f, 0.27912343f, -0.72388923f, 0.10601100f, -0.44759065f, 0.34873906f, 
    0.00138646f, 0.12990689f, -0.18366888f, 0.32906598f, -0.31315824f, 0.01981931f, 0.14625235f, 0.21492180f, 
    -0.05344887f, -0.21193807f, -0.39074865f, 0.33181867f, -0.13138914f, 0.17014949f, 0.32734290f, -0.27282232f, 
    0.05567045f, 0.90132880f, 0.43819171f, 0.01724946f, 0.31110808f, -0.11749096f, -0.35691333f, -0.07987241f, 
    -0.12100292f, -0.25961125f, -0.37386915f, 0.19639316f, 0.37895018f, 0.23933408f, -0.28813234f, 0.49934664f, 
    0.11515176f, 0.49997360f, 0.03988016f, -0.24072392f, 0.19055477f, -0.39367443f, -0.47774470f, 0.36411977f, 
    -0.48625591f, -0.10670003f, -0.32805243f, -0.46307904f, 0.50912380f, 0.68354726f, -0.01713661f, -0.25163546f, 
    -0.35876629f, -0.35756004f, 0.19227535f, -0.51851732f, -0.24096222f, 0.23937540f, -0.22470281f, -0.02581026f, 
    -0.20967031f, 0.17533387f, -0.13553320f, -0.18289617f, -0.15278111f, 0.11184940f, 0.15120339f, 0.14544542f, 
    1.15269339f, 0.18277174f, -0.11951450f, 0.96170413f, 0.77634549f, -0.45480537f, -0.14006637f, 0.19740973f, 
    -0.06902973f, 0.12542425f, -0.08985139f, -0.11046953f, 0.03219646f, -0.35429448f, 0.24819493f, -0.00808016f, 
    -0.11579732f, 0.11126512f, -0.07787447f, -0.09737531f, 0.25182450f, 0.15345950f, -0.01352335f, -0.19214360f, 
    0.20902702f, -0.26787964f, -0.00585868f, 0.31245410f, -0.07786370f, 0.56205457f, -0.58645219f, 0.74781597f, 
    0.45987487f, -0.68178439f, -0.41397277f, 0.37807947f, -0.06067409f, 0.14138311f, -0.27170926f, -0.08261973f, 
    -0.28046608f, -0.45185363f, 0.02589504f, -0.05191823f, -0.49759948f, -0.00012638f, -0.04473738f, -0.00600940f, 
    0.18754847f, 0.06801985f, 0.10928754f, 1.02948451f, 0.15074258f, -0.33219072f, 0.58260554f, 0.01886898f, 
    -0.02000329f, -0.06106630f, -0.70109361f, -0.45909464f, 0.27108145f, -0.09818883f, 0.12510084f, 0.42648745f, 
    -0.23923396f, 0.06431574f, 0.17855212f, -0.09551212f, -0.08006418f, 0.15022150f, -0.25283593f, 0.02660891f, 
    0.24055301f, -0.05774374f, 0.05354946f, 0.75711012f, 0.66255796f, 0.69153392f, 0.71036702f, 0.46906090f, 
    -0.17163852f, -0.24150401f, -0.65286344f, -0.14157622f, 0.17328021f, -0.12968560f, 0.46774974f, 0.33105522f, 
    0.19697198f, -0.20628780f, 0.21997401f, -0.10867763f, 0.11839715f, -0.01046603f, -0.11831310f, 0.10196283f, 
    -0.23772579f, 0.04475365f, -0.02762370f, -0.15556441f, -0.68991756f, 0.09381425f, -0.47742423f, -0.75509667f, 
    -0.66560376f, 0.50909883f, 0.21163647f, -0.35750306f, 0.25363919f, 0.57577789f, -0.16326378f, 0.02042309f, 
    -0.04533844f, -0.09214605f, -0.29360023f, 0.29342031f, 0.27914131f, 0.24024251f, 0.14192910f, 0.24469775f, 
    -0.03687667f, -0.27958602f, -0.12646072f, -0.35134521f, 0.24457553f, -0.14699994f, 0.50584048f, 0.44466928f, 
    -0.44044477f, -0.22953999f, -0.63672853f, -0.24526608f, -0.69998330f, -0.61017638f, -0.47173604f, 0.38316584f, 
    0.57183272f, 0.23305009f, 0.10058663f, 0.31659487f, 0.25679198f, -0.16272609f, 0.00810083f, 0.24967518f, 
    -0.06113409f, 0.17398430f, 0.05124072f, -0.08742925f, 0.28594816f, 0.08619890f, -1.38259208f, 1.02084041f, 
    0.45147046f, -0.55960745f, -0.40260410f, 0.36215010f, 0.69122666f, -0.24755548f, 0.50703537f, -0.14397606f, 
    -0.24596499f, -0.18991329f, 0.04782369f, -0.21137181f, 0.07474849f, 0.13855782f, -0.08275588f, -0.03227475f, 
    -0.07351964f, -0.02985684f, 0.30704504f, 0.20910788f, 0.09025612f, 0.22872685f, 0.41293162f, -0.26832557f, 
    -0.98813921f, 0.10234056f, 0.23803954f, 0.71899736f, -0.77321059f, 0.67254239f, -0.00765883f, -0.18540262f, 
    -0.16949528f, 0.45236111f, 0.15246400f, -0.30228269f, 0.10794204f, 0.33622274f, -0.19034073f, 0.15681899f, 
    -0.30073968f, -0.15884778f, 0.30790710f, 0.14214790f, 0.15234722f, 0.24732101f, 0.09595940f, 0.06348479f, 
    0.77690089f, 0.24647413f, 0.81027740f, 0.77852374f, 0.31872198f, 0.69618309f, -0.34093606f, -0.51323998f, 
    -0.24836791f, -0.24100541f, 0.48331612f, 0.21854720f, -0.28548500f, 0.02733856f, -0.11970739f, 0.34395418f, 
    -0.30177170f, 0.08673488f, -0.02070228f, -0.01668133f, 0.16335337f, 0.13206425f, 0.28062031f, -0.03833980f, 
    0.37109160f, 0.54188401f, 0.89810723f, 0.44054744f, 0.54008281f, -0.32605514f, -0.28195277f, 0.48878372f, 
    -0.37958515f, 0.06169574f, 0.46809471f, 0.32268882f, 0.05743500f, -0.04977944f, 0.07317813f, 0.12775466f, 
    0.02299679f, -0.25401559f, 0.23093913f, 0.18576415f, 0.00680527f, -0.04342403f, 0.31404263f, 0.23549785f, 
    -0.16522054f, 0.13324538f, -0.70987928f, -0.21139228f, -0.38186681f, -0.34012145f, -0.29665455f, -0.41302973f, 
    0.68593192f, 0.51723111f, -0.12470440f, 0.53557193f, -0.45510575f, 0.28815600f, -0.02640248f, -0.40854993f, 
    -0.09148601f, -0.23177232f, -0.11761981f, 0.05319348f, 0.27610508f, 0.01668184f, -0.03183891f, 0.19186510f, 
    -0.17736121f, -0.28243032f, -0.09803198f, 0.58317083f, 0.20227477f, -0.66948473f, -0.66225582f, 0.09390247f, 
    -0.34565344f, 0.55273658f, -0.26238143f, 0.24753946f, -0.23527569f, 0.25959861f, 0.18913855f, -0.16426769f, 
    0.18257824f, 0.10335413f, -0.08646524f, 0.15672319f, -0.12045880f, 0.00089078f, 0.17302032f, 0.08225308f, 
    0.10118717f, -0.15250084f, -0.08058938f, 0.34946051f, -0.72014654f, -0.55196321f, 0.03584789f, 0.57994634f, 
    -0.16774493f, -0.66199583f, 0.37879771f, 0.68226248f, -0.33166388f, -0.41104361f, -0.24006182f, -0.00181329f, 
    0.20719250f, 0.25151163f, 0.37512010f, 0.25547877f, 0.18646425f, 0.24310683f, -0.25283113f, 0.10708216f, 
    0.34923834f, 0.01693585f, -0.16088222f, 0.32603344f, 0.14826620f, 0.83292985f, -0.92059594f, -0.40058541f, 
    -0.10012244f, 0.04259825f, 0.55796176f, -0.19227292f, -0.08713420f, 0.30796105f, -0.05943161f, -0.42564830f, 
    0.13995035f, -0.10048620f, 0.24331971f, 0.08012519f, -0.06340034f, -0.18331829f, -0.11000744f, 0.21392184f, 
    0.04962485f, -0.03949986f, 0.40415838f, 0.24175246f, 0.01483294f, -0.06982918f, 0.56096262f, -0.05240340f, 
    -0.27138743f, 0.58749396f, 0.75937039f, 0.36372557f, -0.14304677f, 0.21861291f, -0.02353131f, 0.50051343f, 
    -0.38435802f, -0.43862107f, 0.15342556f, -0.12802562f, 0.00943386f, 0.20643757f, -0.14380457f, 0.19835183f, 
    -0.06727381f, 0.05422748f, 0.43176988f, 0.14160731f, -0.13680679f, 0.18126036f, -0.43081400f, -0.56966352f, 
    0.49012509f, -0.20361733f, -0.61588264f, -0.34553227f, 0.36267373f, -0.20795535f, -0.20780301f, -0.25886673f, 
    -0.65586138f, -0.03801318f, 0.52756363f, 0.05369770f, 0.38650820f, -0.18347433f, -0.33698112f, 0.12373124f, 
    -0.50553179f, -0.45690677f, 0.33127561f, -0.00417525f, -0.06607299f, 0.18216436f, 0.23666283f, -0.08592301f, 
    -0.36665466f, 0.25356057f, -0.38250652f, -0.69659919f, -0.02630398f, -0.33101213f, -0.16406532f, -0.19745713f, 
    -0.62354517f, 0.00875022f, -0.16369592f, 0.42175767f, 0.22248551f, 0.15739614f, 0.17916887f, -0.05922922f, 
    0.12508947f, 0.15316777f, 0.29912743f, -0.11027277f, 0.29302505f, 0.03045898f, 0.07688005f, 0.40371934f, 
    -0.11322913f, -0.18498911f, 0.54926109f, 0.22385865f, -0.01686185f, 0.15705323f, -0.62445903f, 0.29326862f, 
    -0.04528722f, -0.34732172f, -0.59994626f, -0.21467887f, 0.14893772f, -0.15255477f, 0.13763788f, 0.41789243f, 
    0.30067316f, 0.21965064f, 0.34745181f, -0.05551837f, -0.34434876f, 0.16639028f, 0.16031209f, 0.14550419f, 
    0.30507094f, 0.05388020f, -0.84096467f, 0.49825996f, 0.44257084f, -0.52685386f, 0.00192701f, 0.54940146f, 
    0.43750054f, 0.19396120f, 0.62425596f, 0.66700113f, -0.14957413f, 0.19428121f, -0.13242276f, -0.15260550f, 
    -0.26677948f, 0.04345573f, 0.06645603f, -0.26005787f, 0.09789260f, 0.04677211f, -0.30579957f, 0.31155708f, 
    -0.17660038f, 0.40189153f, -0.13641527f, -0.87355739f, -0.03419130f, 0.01962738f, -0.63214529f, -0.59767926f, 
    0.07604700f, -0.51796293f, -0.04585918f, 0.55490446f, 0.32272086f, -0.10302811f, -0.18619442f, 0.14129284f, 
    0.10763143f, -0.08793841f, 0.05255985f, 0.07125118f, -0.16977049f, 0.36017936f, -0.42989895f, 0.30171263f, 
    0.22887696f, 0.32484618f, 0.46301472f, 0.33685061f, -0.42911446f, -0.73410296f, -0.75948572f, -0.46160215f, 
    -0.51114351f, -0.32300621f, 0.71298146f, 0.21901979f, 0.12028596f, 0.50662732f, -0.08056895f, -0.10078229f, 
    0.03598310f, -0.11027158f, 0.20454554f, -0.08169708f, -0.00678185f, 0.04722081f, -0.20113274f, -0.10606081f, 
    0.14641327f, 0.08290432f, 0.22057196f, 0.21218318f, 0.27142337f, 0.03487961f, 0.18706124f, 0.69474512f, 
    -0.05849308f, -1.04961503f, -0.31274793f, -0.66062927f, 0.55496842f, -0.05922297f, -0.09306156f, 0.26633906f, 
    0.44016969f, -0.32847735f, -0.02126152f, -0.04226862f, -0.35105965f, 0.23738895f, -0.02971100f, -0.12176742f, 
    -0.19819297f, -0.03105950f, 0.06193448f, -0.01269217f, 0.19133238f, 0.05960288f, 0.93259835f, 0.68152267f, 
    0.41497090f, -0.40293685f, -0.74547046f, -0.24754368f, -0.31194293f, 0.41467899f, 0.37042096f, 0.62071222f, 
    0.08077199f, 0.11500406f, -0.11035673f, -0.18755876f, 0.01581633f, 0.15158959f, 0.31736711f, -0.08185315f, 
    -0.16604699f, -0.31402659f, -0.09440649f, -0.28878617f, 0.15846774f, -0.15240994f, 0.26324826f, -0.31147888f, 
    0.54839826f, -0.49526483f, -0.67280793f, -0.53464466f, 0.42194325f, -0.40208507f, 0.27331257f, 0.55340117f, 
    0.18235716f, -0.31314030f, -0.10252018f, -0.49459940f, -0.27409357f, -0.31247264f, 0.14944950f, 0.22855613f, 
    -0.48975199f, 0.24563326f, 0.17709601f, 0.03307499f, -0.24952616f, 0.16660668f, -0.21761517f, -0.22349706f, 
    0.47159103f, 0.25846958f, -0.74066812f, -0.40134788f, 0.02261052f, -0.45685977f, -0.14211927f, 0.22395933f, 
    0.08451172f, -0.22845994f, -0.24406025f, -0.14156237f, 0.46062317f, -0.28150550f, -0.07206344f, 0.27271232f, 
    -0.35192105f, 0.24260736f, 0.32892823f, 0.05373809f, -0.07444613f, 0.32424569f, -0.19583815f, -0.28321642f, 
    0.07508157f, -0.48655161f, -0.50417346f, -0.47944379f, -0.13562910f, -0.43565249f, -0.12497522f, -0.19567786f, 
    0.04876961f, 0.47070089f, 0.15131719f, -0.26608592f, -0.33700889f, 0.21237487f, -0.13406406f, -0.35611477f, 
    -0.38391253f, -0.24152564f, 0.07657366f, -0.06536292f, -0.25511852f, 0.06663594f, 0.29234728f, -0.20747803f, 
    -0.12466997f, 0.18386638f, -0.36038527f, -0.16426395f, 0.46189627f, 0.53322738f, 0.28066194f, -0.11592152f, 
    0.24566546f, -0.50833911f, -0.07152524f, 0.05021486f, -0.19611867f, 0.06684736f, 0.57785285f, -0.03353050f, 
    0.17676783f, -0.02043494f, 0.25055057f, 0.23478816f, 0.23326132f, 0.37238795f, -0.16728613f, -0.09307142f, 
    -0.22581008f, -0.17609197f, -0.06627996f, 0.10621975f, -0.58726460f, 0.23811844f, 0.68809867f, 0.32202703f, 
    -0.47591072f, -0.01093532f, -0.53928590f, -0.67188281f, -0.23086661f, 0.38738200f, 0.27910933f, 0.41253173f, 
    -0.08462088f, -0.27524331f, -0.41785017f, 0.43468809f, 0.35046592f, -0.22531076f, -0.21654406f, -0.28707963f, 
    -0.28210428f, -0.02632148f, -0.01251260f, 0.23094596f, -0.39066774f, -0.01964918f, 0.08141851f, -0.47115606f, 
    0.25328752f, 0.67290372f, 0.51004136f, -0.18115625f, 0.50428408f, 0.61700112f, 0.30837548f, -0.38588378f, 
    -0.32539940f, -0.14305003f, 0.08867513f, -0.44770306f, 0.21498922f, -0.37966973f, 0.27097714f, 0.08057129f, 
    -0.26242152f, 0.20167547f, -0.07447431f, -0.36444181f, -0.20063624f, -0.51224220f, -0.56315696f, -0.55905437f, 
    -0.16958198f, 0.14660008f, -0.73974633f, 0.14051887f, 0.49071208f, -0.58888745f, 0.03005303f, 0.26802051f, 
    -0.02521505f, 0.18732725f, 0.44457656f, -0.23809639f, -0.10143372f, -0.23046584f, -0.30216610f, -0.21077763f, 
    -0.09788754f, -0.15102953f, -0.22619869f, 0.38521403f, -0.12287728f, -0.01102450f, 0.07211461f, -0.92173451f, 
    0.37833703f, 0.09286077f, -0.51167792f, 0.68229854f, -0.77518922f, 0.36855006f, -0.26117676f, 0.15512362f, 
    0.28962451f, -0.34943455f, 0.27396005f, 0.37904400f, 0.10836052f, -0.04605305f, 0.08150493f, -0.00391054f, 
    0.06318887f, 0.24619542f, 0.04012346f, 0.22567557f, 0.14991426f, 0.15185642f, -0.36513132f, 0.75118911f, 
    0.80274475f, 0.07411962f, -0.29616192f, 0.07760979f, 0.07580768f, 0.29048899f, -0.02951698f, 0.46271652f, 
    0.38487312f, 0.21473324f, 0.38671032f, -0.09826993f, -0.39543054f, -0.14298236f, -0.05365893f, -0.36176395f, 
    -0.35394058f, 0.06441016f, -0.41396075f, -0.35131177f, 0.35705617f, -0.05160283f, 0.05642457f, 0.21970844f, 
    0.82931429f, -0.03009588f, -0.37106669f, -0.18893777f, -0.38811004f, -0.30126286f, -0.61388564f, -0.19298974f, 
    -0.45177236f, -0.30332959f, -0.40549526f, -0.33438948f, -0.27220327f, -0.12003713f, -0.28945968f, 0.13521788f, 
    -0.14992788f, -0.10508753f, -0.20137788f, 0.12782687f, -0.42892355f, 0.26699251f, 0.21480435f, -0.41403401f, 
    -0.10968909f, -0.45308930f, -0.90951896f, -0.77868044f, -0.43919849f, -0.31586879f, 0.04895685f, 0.53231251f, 
    -0.06879804f, -0.32718474f, 0.06753930f, -0.10703606f, 0.27807605f, 0.33431008f, 0.32750824f, 0.29044193f, 
    -0.22404489f, 0.20036352f, 0.17624110f, -0.05010431f, 0.05858527f, 0.16111632f, -0.14951383f, -0.51521623f, 
    -0.13566621f, -0.27688137f, -0.06155013f, -0.41160473f, 0.41161591f, 0.38825312f, -0.29640380f, -0.94050300f, 
    -0.40997088f, -0.46672752f, 0.05902610f, 0.16399156f, -0.15877150f, 0.06591181f, -0.58798474f, -0.22499290f, 
    -0.01944024f, -0.14948033f, 0.11259723f, 0.38438621f, -0.10457680f, 0.22764525f, 0.02666782f, 0.11983650f, 
    -0.20847578f, -0.26949775f, -0.04589724f, -0.47487423f, 0.75028718f, -0.76438510f, -0.50378239f, 0.31193784f, 
    0.00731647f, 0.22841357f, 0.52676469f, 0.29350308f, -0.79485661f, -0.06156873f, -0.24301408f, -0.18441547f, 
    0.35895607f, -0.03775395f, -0.01391517f, -0.32661998f, 0.11302108f, -0.20093624f, -0.02874320f, 0.22775455f, 
    0.01320555f, -0.16104154f, 0.16222255f, 0.14087403f, -0.04031374f, 0.58630812f, 0.47713426f, 0.41575277f, 
    0.39132214f, -0.96203655f, 0.43504706f, 0.04057667f, -0.57540399f, 0.22718155f, 0.26221794f, 0.31498101f, 
    -0.18021677f, -0.18963507f, 0.42031616f, 0.08528183f, 0.15032515f, 0.20979330f, 0.20471282f, -0.14054257f, 
    0.16055292f, -0.00905648f, 0.23475102f, 0.29715592f, -0.04831356f, -0.68341672f, -0.06761872f, -0.46596515f, 
    -0.07792746f, -0.58723778f, 0.47412127f, 0.67060030f, -0.43464464f, -0.00492737f, 0.38022304f, 0.12605862f, 
    -0.06107825f, -0.01603290f, 0.07354757f, 0.55415684f, 0.01655854f, -0.45429355f, 0.44470403f, 0.21786901f, 
    0.03601227f, 0.34790897f, -0.44351700f, 0.04992099f, 0.18746933f, -0.05690279f, 0.32602763f, -0.04947094f, 
    -0.51878041f, -0.82536745f, -0.58006275f, 0.47326744f, 0.70767272f, -0.09161273f, 0.17957488f, 0.47585294f, 
    -0.27470455f, -0.37725681f, -0.42408338f, -0.33926961f, -0.33307871f, -0.05095053f, -0.08889279f, -0.05326606f, 
    -0.39177951f, -0.27602860f, -0.01554922f, -0.10092629f, 0.05784381f, -0.11398195f, 0.02015299f, 0.26229572f, 
    0.67553669f, 0.86240280f, 0.61707187f, 0.51214391f, 0.73323321f, 0.16170564f, -0.30290845f, 0.21758279f, 
    -0.08607109f, -0.19581904f, 0.07295183f, -0.19359189f, 0.32217523f, -0.40708926f, -0.03296800f, 0.20803741f, 
    0.08207180f, -0.21107258f, -0.06581982f, 0.15093404f, 0.24213359f, -0.29918331f, -0.21131898f, 0.43606216f, 
    1.01747346f, -0.07589702f, -0.28350320f, 0.70136201f, 0.07262395f, -0.48544362f, -0.44642887f, 0.20739141f, 
    0.27655581f, -0.00913422f, -0.15786406f, -0.10915884f, -0.04183501f, 0.08825592f, -0.32070398f, 0.24746674f, 
    0.23490846f, -0.03587682f, -0.39268473f, 0.14263532f, -0.48566756f, -0.19332668f, -0.18232007f, -0.26120844f, 
    -0.10321757f, -0.17495134f, -0.99503350f, 0.39289287f, 0.36295447f, -0.29947922f, 0.19819334f, -0.02108143f, 
    0.71023941f, 0.17001022f, -0.38792211f, -0.01486907f, -0.55239707f, 0.02105757f, 0.16032216f, 0.28847858f, 
    0.06167816f, 0.06096629f, -0.38762212f, -0.14808764f, 0.24997261f, -0.41857916f, 0.09668259f, 0.46894950f, 
    -0.22161570f, -0.00797027f, 0.20639707f, -0.83577049f, -0.43181634f, 0.54957509f, 0.74662185f, 0.06739757f, 
    0.66454226f, -0.27989572f, 0.27445537f, -0.04837891f, 0.16939834f, 0.20521247f, -0.01308907f, 0.09969093f, 
    0.07275296f, -0.41133273f, -0.33969456f, -0.54180259f, -0.34878138f, -0.43732995f, -0.17334764f, -0.00112307f, 
    0.28181753f, 0.14937744f, 0.31288299f, 0.97481811f, 0.37033904f, 0.01073233f, 0.89110070f, 0.76706570f, 
    0.55524921f, 0.51945984f, 0.06233168f, 0.10940786f, -0.05571445f, -0.27654451f, -0.18163338f, -0.07052685f, 
    0.00543413f, -0.28414649f, 0.11767238f, 0.04170544f, -0.05234160f, -0.16226667f, 0.03568210f, 0.17192855f, 
    -0.14091124f, 0.09246900f, 0.22798669f, 0.27575624f, -0.46519306f, -1.41374147f, -0.11154124f, 0.55873889f, 
    -0.24993859f, 0.44591537f, 1.02080989f, 0.22416237f, -0.27089208f, 0.22439222f, -0.22604968f, -0.11384886f, 
    -0.33233628f, 0.15508987f, 0.03141560f, -0.18085034f, -0.04247212f, -0.34377566f, -0.01930464f, -0.25697899f, 
    0.09536843f, -0.01930175f, -0.22428271f, 0.23072141f, -0.20558712f, -0.77651024f, -0.43880740f, -0.02615754f, 
    0.38391057f, 0.08868320f, -0.68022662f, 0.47614247f, 0.63688338f, 0.08667208f, 0.23090258f, -0.03107488f, 
    -0.33904988f, 0.19445121f, -0.29612845f, -0.13773687f, -0.09882686f, 0.24342524f, 0.37590060f, 0.16899902f, 
    -0.31211221f, 0.18829189f, 0.23023143f, -0.35944149f, -0.03301537f, -0.31699398f, 0.18051265f, 0.37470427f, 
    -0.38661680f, -0.72545069f, 0.39316580f, 0.61472565f, -0.77721101f, -0.21522976f, -0.01883375f, -0.42282596f, 
    0.22746918f, 0.22949633f, 0.26367471f, 0.05059405f, -0.30773130f, -0.14266019f, 0.10900906f, 0.21266431f, 
    0.31695375f, 0.40743861f, -0.14750046f, 0.13312967f, 0.00876293f, -0.32225898f, 0.29438636f, -0.47202381f, 
    -0.65017807f, -0.28875208f, 0.65011412f, -0.12746957f, -0.04699864f, -0.58111000f, -0.41821876f, 0.18300173f, 
    -0.49014154f, 0.29575092f, 0.25088519f, -0.48074868f, -0.01190953f, -0.13201457f, 0.22814000f, 0.23364365f, 
    0.06885692f, 0.10429768f, 0.31792375f, -0.09793088f, -0.07081390f, 0.22068477f, -0.19374508f, 0.21686728f, 
    0.31953427f, 0.53255731f, 0.39725205f, 0.11053089f, -0.44948378f, -0.46811530f, -0.68589580f, -0.48483974f, 
    -0.63430452f, -0.24900848f, 0.25132871f, -0.47724494f, 0.17243192f, -0.01789984f, -0.20944498f, -0.33716461f, 
    -0.51459128f, -0.08665635f, 0.15420966f, -0.40972680f, 0.21348497f, 0.31433639f, 0.07795279f, -0.02838819f, 
    0.03132654f, -0.62780899f, -0.11174189f, 0.69537395f, -0.01714951f, -0.77620041f, -0.26994002f, 0.23893242f, 
    0.15439312f, -0.36176303f, -0.10576388f, 0.15718846f, 0.57025731f, -0.43914777f, 0.33365068f, -0.08078471f, 
    0.21908319f, -0.22706404f, -0.16712297f, 0.03782837f, -0.29562658f, -0.17761955f, 0.07123087f, -0.02662926f, 
    -0.11571038f, 0.10384182f, 0.98885047f, 0.00414464f, 0.34012920f, 0.72502989f, 0.82788914f, 0.07178827f, 
    -0.10077406f, -0.12334325f, 0.05192516f, -0.12680817f, -0.09244668f, 0.32519931f, -0.22597156f, 0.34329134f, 
    0.02871217f, -0.04991485f, 0.06920779f, 0.46273747f, 0.24826072f, 0.15106513f, -0.16412716f, 0.24706055f, 
    0.21498902f, 0.16626905f, 0.21741149f, 0.74578559f, 0.52246559f, -0.86533982f, -0.51791304f, 0.12148211f, 
    -0.04313089f, 0.39175642f, 0.37190109f, 0.38308084f, 0.48195928f, -0.24939492f, -0.38072836f, -0.02890409f, 
    -0.49630606f, -0.42575264f, -0.22183955f, 0.18832424f, -0.07769569f, -0.07535908f, 0.18910328f, -0.23613985f, 
    -0.19107504f, -0.42489424f, -0.21423797f, -0.18055877f, 0.35732651f, 0.84845060f, -0.78703547f, 0.73640901f, 
    -0.37502381f, 0.49273977f, 0.19471157f, -0.24734454f, -0.25388360f, -0.44279352f, -0.07584512f, -0.10334354f, 
    -0.00070594f, -0.08896093f, 0.04192921f, -0.06817513f, -0.03530142f, 0.35125723f, 0.25605562f, 0.18136893f, 
    -0.11171091f, -0.22622137f, -0.25764447f, -0.16148962f, -0.09476399f, 0.91325796f, 0.39240882f, -0.08535913f, 
    0.44194719f, -0.65119547f, 0.03749657f, -0.01635299f, 0.22072357f, 0.65225899f, 0.08866367f, -0.23567760f, 
    0.06761418f, 0.29336846f, -0.17448799f, -0.15132706f, 0.04548449f, -0.44005439f, 0.08340272f, 0.19222774f, 
    0.12012519f, -0.14253424f, -0.28246316f, 0.34839657f, -0.23066397f, -0.09426733f, -1.17874491f, -0.35434908f, 
    0.64697725f, 0.15851456f, 0.53105241f, 0.77396673f, 0.21549910f, 0.53440237f, -0.06644028f, -0.51625723f, 
    0.21010010f, -0.06660718f, 0.32945412f, 0.08886188f, 0.05047275f, -0.03277916f, 0.08767314f, -0.15169650f, 
    -0.29032850f, 0.18576162f, 0.02085329f, 0.19914436f, -0.10546365f, -0.15514266f, 0.04494458f, -0.60865206f, 
    -0.50470591f, -0.34571853f, 0.19686975f, -0.05637610f, -0.37253976f, -0.05379277f, -0.08384554f, 0.13826904f, 
    -0.08308605f, 0.11221973f, 0.49964741f, -0.15493564f, -0.10084292f, -0.33940813f, -0.38374609f, 0.29271469f, 
    0.15601915f, 0.38548478f, -0.18610898f, -0.28224766f, 0.18523927f, 0.36055285f, -0.09474768f, -0.17641748f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17470779f, 0.06523829f, 0.09833480f, 0.19111216f, -0.00450337f, -0.00031421f, 0.06675940f, 0.10814073f, 
    -0.08105216f, 0.22339007f, 0.20706597f, 0.02655941f, 0.02516343f, 0.15765589f, -0.00056600f, 0.05344544f, 
    0.10216646f, 0.14750613f, 0.13342400f, 0.24061102f, 0.16339414f, 0.24204162f, -0.03955886f, 0.01485893f, 
    0.24963357f, 0.12193519f, 0.03086481f, -0.07995798f, 0.33312789f, 0.16283770f, 0.12634051f, -0.06438614f, 
    0.22020008f, 0.22131522f, 0.15300870f, 0.08316354f, 0.02846274f, 0.21213877f, 0.24558450f, -0.01186106f, 
    -0.07093653f, 0.32403886f, -0.09668007f, 0.10451997f, 0.30339345f, 0.23856045f, -0.12225731f, 0.25869170f, 
    -0.18301277f, 0.02728126f, 0.26779252f, 0.28471762f, 0.31939769f, 0.01004775f, 0.22977409f, 0.16462670f, 
    -0.05660643f, 0.25250018f, 0.10239468f, -0.00986390f, -0.02503800f, 0.17254956f, 0.31282860f, 0.23735675f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12258252f, -0.34487903f, 0.09768048f, -0.13064536f, 0.02588870f, -0.11848480f, 0.00135316f, 0.05391561f, 
    -0.06780865f, -0.00900372f, -0.03706539f, -0.08914988f, 0.01973054f, -0.01509610f, -0.03357853f, 0.15807348f, 
    -0.19111612f, -0.14057216f, 0.00120076f, -0.15143523f, -0.01059278f, -0.00649863f, 0.05231880f, 0.05347257f, 
    -0.15434380f, 0.09953447f, 0.00481397f, -0.06493185f, -0.15799916f, -0.05656638f, -0.04599969f, -0.11909990f, 
    -0.00166742f, 0.07476143f, 0.03511762f, -0.04969770f, 0.08642151f, -0.19814633f, -0.01644007f, -0.02985582f, 
    -0.06078998f, -0.05190123f, -0.09565578f, -0.01771007f, -0.04258481f, -0.02711539f, -0.00976121f, -0.00555775f, 
    0.10989247f, 0.21538013f, 0.09492473f, -0.00912503f, 0.09209703f, 0.06574768f, 0.12086447f, -0.01043878f, 
    -0.05682087f, 0.03386218f, -0.01566798f, 0.02768974f, 0.21939984f, 0.18188010f, -0.11024408f, 0.01764515f, 
    -0.01361358f, -0.02686772f, 0.04246392f, -0.02619912f, 0.06889728f, 0.09753595f, -0.07281697f, 0.02371630f, 
    0.04274831f, 0.11768254f, -0.15618899f, 0.22821121f, -0.23022042f, 0.13114065f, -0.09355106f, 0.02118039f, 
    0.06539029f, -0.17125168f, 0.08494502f, -0.06176607f, -0.07823993f, 0.09393238f, 0.10045369f, -0.25130197f, 
    -0.04749862f, 0.03011157f, -0.12653658f, -0.00097323f, 0.02517369f, 0.03457275f, 0.07117529f, 0.06040480f, 
    0.28830874f, -0.03485140f, -0.02373455f, 0.23519515f, -0.18790610f, 0.04045162f, -0.03945987f, 0.07565586f, 
    -0.10308070f, 0.10736848f, 0.03189483f, -0.03279949f, -0.13504799f, 0.06675764f, -0.06436521f, -0.08548275f, 
    -0.12617460f, -0.16578567f, -0.02976720f, -0.06219717f, -0.04740868f, 0.00187093f, 0.01445600f, 0.05765834f, 
    -0.04177395f, 0.07058837f, 0.08827023f, -0.34068173f, -0.03491561f, -0.04012620f, -0.07186866f, 0.10687733f, 
    0.03626150f, -0.02069902f, -0.04093448f, -0.16519414f, 0.16132656f, -0.08468711f, -0.02340923f, 0.06937925f, 
    -0.06522737f, -0.05399421f, 0.01882810f, 0.07496016f, -0.05087526f, 0.03375329f, -0.05228013f, 0.04436384f, 
    0.47620848f, -0.02663745f, -0.10688160f, -0.30062917f, 0.09448659f, -0.07042274f, -0.03147063f, -0.01818514f, 
    0.12285285f, -0.00202911f, -0.04132527f, 0.03923251f, -0.32945248f, 0.14804362f, 0.11543404f, 0.06445973f, 
    -0.03098743f, 0.11104856f, -0.01742984f, 0.01825357f, -0.00724652f, 0.05282335f, 0.01681726f, 0.00631589f, 
    0.62070274f, 0.10986427f, 0.28391162f, -0.03070579f, -0.03123992f, 0.03277836f, 0.06522202f, -0.01448455f, 
    -0.04472529f, -0.01923024f, -0.06418797f, -0.00441330f, 0.03792140f, 0.06640085f, -0.10742992f, 0.07178324f, 
    -0.02023379f, 0.04379342f, -0.08965439f, 0.02855814f, 0.01060491f, 0.03780843f, -0.04866444f, 0.13167521f, 
    0.12005466f, -0.11906540f, -0.07250075f, 0.03214449f, -0.15993088f, -0.02291937f, -0.02659663f, 0.03708962f, 
    0.01543490f, -0.05358741f, -0.06708337f, -0.09117970f, 0.05486755f, 0.11346887f, -0.08883204f, 0.09737644f, 
    -0.04337310f, 0.06990405f, -0.00792938f, -0.12664160f, -0.09350975f, 0.03748028f, -0.09070019f, -0.06852330f, 
    0.08943880f, 0.01819197f, -0.03067029f, -0.31037253f, 0.01526703f, -0.05249206f, 0.03332099f, -0.01189555f, 
    0.01028317f, -0.16523190f, -0.02487112f, 0.08479114f, -0.34601703f, 0.02308631f, 0.07714912f, -0.26335996f, 
    -0.09663972f, 0.00344187f, 0.00691558f, 0.01177267f, 0.02508087f, -0.04562674f, 0.00135483f, 0.01891092f, 
    -0.12602104f, 0.13389292f, -0.18569320f, 0.17673895f, 0.03796845f, -0.01365317f, -0.00930788f, 0.04011229f, 
    0.05090883f, 0.01099952f, -0.05421576f, -0.03157091f, 0.21180856f, -0.18384305f, 0.02956347f, -0.01547577f, 
    0.07775227f, -0.10890569f, 0.01455576f, -0.10202482f, -0.11623529f, -0.00423103f, 0.03098706f, -0.04558088f, 
    0.12145506f, -0.09128998f, 0.12058873f, 0.31368783f, -0.04215042f, 0.11151503f, 0.02072613f, -0.05647757f, 
    -0.03823666f, 0.08224969f, 0.03746207f, 0.04957200f, -0.21949656f, 0.14328995f, 0.11047612f, -0.14077064f, 
    0.07197375f, 0.13695097f, 0.09901867f, -0.07586762f, 0.01668525f, -0.05371290f, -0.04661905f, -0.02751637f, 
    -0.37830615f, -0.06331934f, 0.03355699f, 0.02883890f, -0.02295552f, 0.04320304f, 0.05140407f, -0.03672232f, 
    -0.10238039f, 0.00559459f, -0.15440090f, -0.02264692f, -0.13171202f, 0.16631013f, -0.06523585f, 0.05447498f, 
    0.00606062f, -0.09419851f, -0.01059070f, 0.00574538f, -0.13019492f, 0.02372604f, -0.07473263f, -0.13030919f, 
    0.29470319f, 0.02842300f, 0.11390681f, 0.00417328f, -0.15212779f, 0.05532582f, 0.07208426f, -0.14287250f, 
    -0.05364197f, -0.00652359f, -0.13985498f, 0.00498434f, 0.21389470f, -0.00351302f, -0.18211240f, -0.10893914f, 
    0.02906530f, 0.07797223f, -0.02053685f, 0.05300281f, 0.08781965f, 0.15069033f, -0.04683947f, -0.03156833f, 
    -0.01880606f, 0.01837181f, -0.04895072f, -0.33847550f, 0.03014525f, -0.02672534f, 0.05025494f, 0.02383073f, 
    0.01028823f, 0.00531409f, -0.06277305f, 0.10127758f, -0.25610268f, -0.01847151f, -0.01913903f, 0.25411338f, 
    -0.13377629f, 0.05576572f, 0.01964140f, -0.25689003f, -0.14243606f, -0.06466676f, -0.04111410f, -0.01520889f, 
    -0.13433219f, -0.10787740f, -0.03634922f, -0.23878117f, -0.04330483f, -0.04558562f, 0.00571651f, -0.03327553f, 
    -0.05920190f, -0.01543376f, 0.02064852f, -0.05946083f, 0.19420393f, -0.01285065f, -0.01012534f, -0.15811729f, 
    -0.06236003f, -0.03833586f, 0.10713323f, -0.02722748f, -0.08337253f, -0.06473726f, 0.05337112f, -0.05923524f, 
    -0.15417990f, -0.01373972f, 0.03524204f, -0.16458812f, -0.10771421f, -0.09893955f, 0.09242792f, -0.00266167f, 
    -0.00566804f, -0.12071672f, 0.01777290f, -0.01088471f, 0.04979707f, 0.02194314f, -0.24907003f, -0.07963070f, 
    0.04272277f, -0.00464067f, 0.04530131f, 0.03771728f, -0.03039677f, -0.12116215f, -0.05246347f, 0.01431718f, 
    -0.05995158f, -0.05144813f, -0.03571250f, 0.14278568f, -0.12912408f, 0.00581268f, 0.02201645f, -0.02825847f, 
    0.03625157f, 0.02439764f, -0.07366033f, 0.08686207f, 0.10721096f, -0.06078528f, -0.15932381f, 0.09707357f, 
    -0.04556523f, -0.13628733f, 0.10823754f, -0.09288688f, -0.06601135f, 0.07236616f, -0.15125921f, 0.04735467f, 
    0.14703642f, -0.03874858f, 0.22303943f, -0.04572507f, 0.03090094f, 0.20573431f, 0.02198460f, -0.14165708f, 
    0.02118998f, 0.10227112f, 0.02687747f, 0.14917186f, -0.32284993f, 0.12118156f, -0.15183207f, 0.09727054f, 
    -0.08004813f, -0.04474388f, -0.05857527f, 0.03929098f, 0.05629950f, 0.12625323f, -0.02338389f, -0.06837065f, 
    0.02614815f, -0.17600270f, -0.02583588f, 0.07330669f, 0.09940126f, 0.06046043f, -0.06158829f, -0.03876946f, 
    -0.18385875f, 0.05974218f, -0.09505001f, 0.03722367f, 0.13005127f, 0.00385771f, 0.02159398f, -0.16095902f, 
    0.02361972f, 0.02191896f, -0.05659802f, 0.14472027f, -0.04550780f, -0.02722090f, 0.08619450f, -0.08543564f, 
    0.06578539f, -0.09823846f, 0.14586498f, 0.03747931f, 0.01309386f, 0.00232117f, -0.10183996f, 0.12417211f, 
    -0.15886135f, -0.07694261f, 0.03496347f, -0.04754038f, -0.28120974f, -0.11072645f, 0.06659020f, -0.12587783f, 
    -0.03839714f, -0.08466279f, -0.02706216f, -0.03819212f, 0.00660237f, -0.06858911f, -0.06613939f, 0.08448698f, 
    0.13452685f, -0.28713846f, -0.14606877f, 0.19449681f, -0.03230607f, 0.01355766f, -0.04745493f, -0.04975963f, 
    0.07121594f, 0.10282277f, -0.06618664f, 0.09615365f, -0.03567395f, 0.20655642f, 0.06570794f, -0.23675105f, 
    -0.09621477f, -0.03790062f, 0.06482565f, 0.02573724f, 0.00718566f, 0.09165717f, -0.08806316f, 0.04215778f, 
    -0.00857798f, 0.00529657f, -0.07303943f, 0.05082304f, 0.04004193f, -0.00953049f, 0.00846147f, -0.14378913f, 
    0.04558406f, -0.01700820f, 0.00090266f, 0.01381892f, 0.26525509f, 0.05797208f, -0.02613571f, -0.19476758f, 
    0.06985428f, -0.02476361f, 0.04356757f, -0.01381334f, 0.09892181f, -0.08509593f, 0.05196024f, -0.00199821f, 
    0.17232235f, 0.06728332f, 0.10041349f, -0.24808331f, 0.02845514f, 0.06356085f, 0.04878631f, 0.00871776f, 
    -0.07151080f, 0.12043403f, 0.08162074f, 0.01317256f, -0.08646668f, -0.02787354f, -0.00176539f, 0.10955743f, 
    -0.04976723f, -0.20375119f, 0.07608177f, -0.00003090f, -0.05745355f, 0.04679603f, -0.11674755f, 0.02801125f, 
    0.18811567f, -0.14932616f, -0.05459207f, 0.31823209f, -0.07711218f, 0.12282577f, -0.11786901f, 0.14256857f, 
    0.00689898f, 0.04368442f, -0.04057958f, -0.03238232f, -0.05835807f, -0.09007058f, -0.09375145f, 0.13834549f, 
    -0.13634020f, 0.09941386f, -0.04194856f, 0.02984276f, 0.07262023f, -0.05105154f, 0.04049287f, -0.08291589f, 
    -0.10727062f, 0.02827926f, 0.01463600f, 0.17528880f, -0.09084106f, -0.07810735f, -0.09344176f, -0.13300908f, 
    -0.13399100f, 0.16376586f, 0.04197235f, -0.04800786f, 0.02281765f, 0.02857018f, -0.00386920f, 0.24752101f, 
    -0.13537815f, -0.02092661f, 0.03443843f, 0.09114766f, -0.05758904f, 0.06946400f, 0.01580445f, -0.06874412f, 
    -0.14967525f, 0.13090383f, 0.07175282f, 0.00673247f, -0.02032542f, 0.00604403f, -0.04530219f, 0.03939070f, 
    0.04963211f, -0.06513502f, -0.07097378f, -0.06050001f, -0.22149055f, 0.23570085f, -0.04519461f, 0.09337079f, 
    -0.02294671f, 0.07820276f, -0.02458714f, 0.09727800f, 0.01550575f, -0.09710459f, -0.03538468f, 0.15063734f, 
    -0.05721696f, -0.27962512f, 0.14971212f, -0.21850647f, -0.06148519f, 0.03728794f, 0.06417302f, -0.01891290f, 
    0.10330647f, 0.01880361f, -0.00946354f, 0.04645259f, -0.18988580f, -0.21028955f, -0.21028277f, 0.18573587f, 
    0.02341169f, -0.02951876f, 0.00495547f, 0.07965062f, 0.00542621f, -0.00943116f, 0.00303434f, -0.03792435f, 
    0.00569301f, 0.16737579f, 0.07555585f, -0.07424337f, -0.00376684f, 0.04701668f, -0.05334481f, -0.03764704f, 
    -0.04848684f, 0.00369102f, 0.04003023f, -0.00385542f, -0.38152525f, 0.00773194f, 0.04964987f, 0.22672011f, 
    -0.01516957f, 0.07615338f, 0.03962302f, 0.00645719f, 0.01757668f, 0.07324769f, 0.05278086f, -0.04871022f, 
    0.26937458f, -0.07975979f, -0.07887152f, 0.12071460f, -0.12333553f, -0.08572997f, -0.01335035f, 0.03548144f, 
    -0.04461183f, 0.04593611f, -0.03063245f, -0.06506850f, -0.06156243f, 0.09182928f, -0.00311322f, -0.25078693f, 
    -0.02652736f, 0.08912179f, -0.00751255f, 0.12105916f, 0.02248818f, 0.08755679f, -0.04264344f, 0.02207410f, 
    0.07361507f, 0.10588953f, 0.03390120f, -0.22629847f, -0.34766418f, -0.00569120f, 0.00443726f, 0.05133097f, 
    0.04898452f, 0.01086014f, 0.06953148f, 0.09629733f, 0.05843887f, 0.05251412f, -0.21686658f, 0.15543501f, 
    0.03519332f, 0.01050095f, -0.09836122f, 0.03871338f, -0.00107829f, -0.04649060f, -0.00982902f, -0.00163339f, 
    -0.20637150f, -0.04131415f, 0.12205444f, 0.03221321f, -0.05079140f, 0.05463833f, -0.02867298f, 0.00878067f, 
    -0.02081968f, -0.12698486f, 0.09416091f, -0.06080009f, -0.14490594f, -0.03902608f, -0.10600664f, -0.02211214f, 
    0.00848305f, -0.05549809f, 0.10416330f, 0.06915437f, -0.00663983f, -0.00497733f, -0.08163719f, -0.02026545f, 
    0.25829676f, 0.04606843f, 0.02391208f, -0.10360580f, -0.08963706f, 0.05960261f, -0.03202720f, -0.03384265f, 
    -0.04238307f, -0.13135783f, -0.04205907f, 0.10668464f, 0.20108803f, 0.11353294f, 0.05925280f, 0.16092581f, 
    0.03270815f, 0.12610282f, 0.10964093f, 0.00740963f, -0.02725762f, -0.04682155f, 0.02948491f, -0.20185165f, 
    0.07829031f, -0.07518503f, -0.06378961f, -0.13008535f, -0.10942616f, 0.09225888f, -0.00103133f, 0.21157831f, 
    -0.02913002f, -0.02336843f, -0.00899092f, 0.18847182f, 0.19743274f, -0.11825702f, 0.01408744f, 0.08884322f, 
    0.03996291f, 0.05413658f, -0.02879843f, -0.23318352f, 0.00635399f, 0.03756755f, -0.12027000f, 0.14387524f, 
    0.28692761f, -0.31499943f, 0.04614769f, -0.12174696f, 0.11566320f, 0.03208049f, -0.16030324f, 0.06773873f, 
    0.00049480f, 0.04856923f, -0.02885074f, 0.03107099f, -0.20702469f, -0.26370490f, -0.31932989f, -0.02010426f, 
    -0.03378146f, 0.02352862f, -0.02197649f, 0.09103296f, 0.05836883f, -0.06811931f, 0.03904169f, 0.08458662f, 
    0.16199230f, -0.14128762f, -0.04688247f, 0.13657859f, 0.07934768f, -0.02579381f, -0.01180289f, 0.07855795f, 
    -0.11096431f, 0.14168704f, -0.00130060f, 0.10129846f, 0.13354345f, -0.00634359f, -0.14124262f, -0.08122730f, 
    0.00100591f, 0.04932823f, 0.03135534f, -0.05509061f, -0.10095241f, -0.01722271f, -0.12443101f, -0.00753459f, 
    0.06901532f, -0.14376684f, 0.12427915f, 0.34659794f, -0.06847563f, 0.00218658f, -0.04297319f, 0.04210690f, 
    0.00523044f, 0.05599444f, -0.14928091f, 0.01102864f, -0.01801642f, 0.12514071f, 0.01382969f, -0.06362364f, 
    -0.02151405f, 0.11713735f, -0.01523310f, 0.04868655f, -0.01770327f, -0.03238677f, -0.09250691f, -0.04395852f, 
    0.09224608f, 0.23225622f, -0.05454066f, -0.13383396f, 0.03863500f, 0.03375621f, 0.08101331f, -0.06181380f, 
    -0.03621167f, 0.04671337f, 0.04297451f, 0.06833939f, 0.22067310f, 0.09895677f, 0.07152181f, 0.15016370f, 
    -0.04328130f, -0.03287135f, -0.04931633f, -0.01360985f, 0.15014131f, -0.13697359f, -0.00039170f, 0.02515183f, 
    -0.35885307f, -0.07172264f, 0.09248506f, -0.25052738f, -0.00011800f, -0.05839191f, 0.11940116f, 0.11696241f, 
    0.06764420f, 0.11216649f, -0.01717820f, -0.01839628f, -0.28082174f, -0.10722486f, -0.08663771f, -0.16033126f, 
    -0.00849998f, 0.00789072f, 0.05214986f, 0.02915803f, 0.19273022f, 0.17467071f, -0.00522651f, 0.00399450f, 
    -0.70119601f, -0.07289083f, -0.12386999f, -0.12634104f, -0.07850113f, -0.01700430f, -0.05403903f, 0.08347061f, 
    0.13373861f, -0.01171674f, 0.03622915f, 0.01471561f, 0.00313778f, -0.20088202f, 0.03427880f, 0.07873707f, 
    -0.01756078f, 0.05509005f, -0.05850176f, -0.06016393f, 0.02089137f, -0.00745528f, 0.03134480f, -0.04378812f, 
    0.06203813f, -0.05074829f, 0.30058685f, 0.08640251f, -0.07359891f, 0.01173407f, 0.05072913f, 0.03841435f, 
    -0.09412480f, 0.01958699f, 0.02842892f, -0.02149227f, 0.23732726f, 0.01385256f, 0.05781974f, 0.02768971f, 
    -0.11453801f, -0.15246311f, 0.11156880f, 0.03516237f, 0.00865262f, -0.04008201f, -0.02354045f, 0.12243409f, 
    0.06402202f, -0.01197755f, -0.07433043f, -0.17296985f, 0.12373703f, -0.03800834f, 0.02876035f, -0.01758283f, 
    0.04212281f, 0.09346477f, -0.08798432f, -0.02375248f, 0.24197821f, -0.13055137f, -0.14335977f, -0.13772598f, 
    0.03056102f, -0.08379988f, -0.02807916f, 0.08239985f, -0.03798817f, 0.03307800f, 0.00852334f, 0.01720298f, 
    -0.17570512f, 0.01875762f, -0.09524383f, 0.18058513f, -0.10338555f, 0.01675403f, -0.13961025f, -0.05292540f, 
    -0.03338396f, -0.04073449f, 0.11889783f, 0.06172520f, 0.24272111f, -0.28212112f, 0.14601132f, -0.15580119f, 
    -0.05182157f, -0.03316377f, -0.00591110f, -0.03411325f, -0.02145638f, 0.00508876f, 0.00481850f, 0.08797489f, 
    0.09389151f, -0.00040621f, -0.03828162f, 0.11911730f, -0.12466450f, 0.04651082f, -0.09054320f, 0.03372081f, 
    0.18765399f, 0.13933802f, 0.02565789f, 0.08664437f, -0.27751413f, -0.07791112f, -0.00401391f, -0.16926968f, 
    -0.04205147f, -0.10238885f, 0.09301896f, -0.00754100f, -0.04962248f, 0.08534085f, -0.04251770f, -0.24894641f, 
    0.01602160f, 0.09041131f, 0.03345813f, -0.27590373f, 0.01754960f, -0.03523709f, 0.02650543f, 0.07444730f, 
    0.09933411f, 0.08774900f, 0.09557544f, -0.04194042f, -0.12714665f, 0.07499777f, -0.10569903f, -0.05051971f, 
    -0.07383312f, 0.10152684f, 0.01456078f, 0.03111957f, 0.07205121f, 0.03337452f, -0.06418332f, 0.08833596f, 
    -0.27266625f, 0.06723330f, -0.05020332f, -0.02247662f, 0.10410284f, 0.02317217f, -0.04987710f, -0.04263686f, 
    -0.00853185f, 0.11578949f, 0.04075399f, -0.06135032f, -0.23512679f, -0.07301366f, 0.08388346f, -0.06635281f, 
    0.06320733f, -0.07925404f, -0.00331884f, 0.10272370f, 0.11430799f, -0.12323752f, -0.11367081f, 0.05168654f, 
    0.23371549f, -0.12291563f, -0.19216067f, -0.08909148f, 0.02058522f, -0.00561152f, 0.02306311f, 0.02891552f, 
    0.00775477f, -0.04966208f, 0.04167891f, 0.02254043f, -0.41584533f, 0.02390009f, -0.13637277f, 0.06625623f, 
    -0.07698619f, 0.05925195f, -0.05547521f, 0.01589362f, 0.00339603f, 0.10539962f, 0.03237681f, -0.00436435f, 
    0.13308541f, 0.12862943f, -0.08356102f, -0.15586437f, -0.05229450f, -0.07897003f, -0.11265220f, -0.00408183f, 
    -0.10329705f, -0.02871446f, 0.10556205f, -0.11328946f, -0.32834870f, -0.15725373f, 0.00779864f, -0.22137998f, 
    0.01305952f, -0.10133032f, 0.00579612f, 0.03353671f, 0.18529613f, 0.18317641f, -0.08669180f, -0.01458624f, 
    0.06969266f, -0.17329702f, 0.03280088f, -0.17388816f, 0.10271966f, -0.07363424f, -0.00847995f, -0.04389007f, 
    -0.05781216f, -0.05373118f, 0.03376045f, 0.06310409f, -0.08216020f, -0.00610807f, -0.00141600f, -0.08004924f, 
    0.01538412f, -0.01330067f, -0.02766626f, 0.09226567f, 0.01830178f, -0.03912918f, 0.00718377f, -0.07862186f, 
    0.05490268f, -0.06133105f, -0.08253912f, -0.02091252f, 0.01400572f, 0.01206399f, -0.11607689f, -0.11941472f, 
    -0.04733465f, -0.07858166f, 0.10795481f, 0.00107386f, -0.20363452f, -0.13122372f, -0.10481148f, 0.00051510f, 
    -0.00069062f, 0.04260534f, -0.08668721f, 0.03344185f, 0.06103216f, -0.22131671f, 0.18029471f, -0.10409365f, 
    -0.09837265f, -0.01273192f, -0.00846613f, -0.01018307f, 0.02747174f, -0.13593194f, -0.12552163f, 0.04835640f, 
    0.04485995f, 0.06215055f, -0.06130049f, -0.17429800f, 0.17892474f, -0.15233485f, -0.01688923f, 0.03718384f, 
    -0.00662617f, -0.05365083f, -0.07375439f, 0.03360199f, -0.13893159f, -0.20992461f, -0.08559708f, -0.05403063f, 
    -0.19893582f, 0.19535640f, -0.02242490f, 0.11805800f, 0.03813802f, -0.03811333f, 0.08638781f, -0.10244573f, 
    0.16639726f, 0.01892979f, 0.03409588f, -0.05945463f, 0.18539251f, 0.08997888f, 0.10589758f, 0.13103916f, 
    -0.01095899f, -0.04741487f, 0.04884629f, 0.04529459f, 0.02835470f, -0.19012186f, -0.04302223f, 0.05759611f, 
    0.12082380f, -0.01876252f, -0.11450423f, -0.34560147f, 0.04625428f, -0.11020140f, 0.10840531f, 0.01134843f, 
    0.00689655f, -0.04217608f, -0.06737168f, -0.07718874f, 0.18529670f, 0.05679895f, -0.06793980f, 0.07491971f, 
    0.08767720f, 0.01616819f, 0.10208220f, 0.08918479f, 0.00833660f, 0.04660176f, 0.04669749f, -0.02847341f, 
    -0.25489429f, -0.04565025f, -0.31354791f, -0.04486156f, 0.07254862f, 0.00797294f, -0.04119395f, -0.08980811f, 
    -0.07246678f, -0.06706148f, 0.06081790f, -0.03655468f, -0.13385642f, -0.14683093f, -0.17341888f, -0.16227318f, 
    0.03768396f, 0.06602401f, -0.02432925f, 0.03952359f, 0.10411060f, -0.09443179f, 0.02444437f, -0.05724767f, 
    -0.08010550f, 0.10581711f, -0.01756923f, 0.05942658f, -0.04162629f, 0.03649710f, -0.03254125f, 0.07688443f, 
    0.00790607f, 0.05219334f, 0.04045148f, 0.05734830f, -0.02583703f, 0.00220163f, -0.07580288f, -0.00764265f, 
    0.00058011f, -0.08880607f, -0.03847357f, 0.03516790f, -0.08708675f, 0.07227504f, -0.09895681f, 0.12508145f, 
    0.07368634f, -0.07721127f, 0.02991979f, -0.16226633f, 0.00444121f, -0.08511151f, -0.06321770f, -0.00320054f, 
    0.00468910f, -0.08508714f, -0.05948205f, -0.04617703f, 0.29559439f, 0.02717537f, 0.16153279f, 0.10735987f, 
    -0.17240340f, 0.06578002f, -0.00219580f, 0.00355439f, -0.02054624f, -0.01420856f, 0.15429473f, -0.05099635f, 
    0.19619656f, -0.06895016f, -0.01788681f, 0.00172854f, 0.01346298f, -0.12675135f, -0.14073008f, -0.05058824f, 
    0.00333482f, 0.03140845f, -0.01893708f, -0.01838162f, -0.22264549f, 0.20037289f, -0.04420440f, 0.00109493f, 
    -0.04910174f, -0.01769107f, -0.03170233f, -0.02459549f, 0.05881540f, 0.04081061f, -0.07692743f, 0.08579610f, 
    0.14963835f, -0.23967332f, 0.01036149f, 0.05541849f, 0.01532405f, 0.14050941f, -0.03134125f, 0.07060530f, 
    -0.01735369f, -0.09301490f, -0.13858145f, -0.02193667f, 0.20283285f, 0.00266264f, 0.05383105f, 0.17961314f, 
    -0.08944512f, 0.08744426f, -0.03551532f, 0.03678682f, -0.04201442f, 0.01435173f, -0.03947012f, 0.06958820f, 
    0.21693845f, -0.03971878f, -0.21032828f, 0.14594756f, -0.03700797f, 0.02500533f, 0.01527219f, -0.12172107f, 
    0.02757928f, -0.02142772f, -0.05950443f, 0.09416807f, 0.18511908f, 0.06106727f, -0.06654110f, -0.03544635f, 
    0.11090744f, -0.05252303f, -0.19658075f, 0.08037845f, 0.00942921f, -0.04548191f, -0.03155030f, 0.01917471f, 
    0.06690431f, -0.23016350f, 0.11277978f, -0.14491963f, -0.02192712f, -0.02505179f, -0.02478104f, -0.00041735f, 
    -0.08314273f, 0.01307221f, 0.10355025f, 0.06303232f, -0.05438436f, 0.07658127f, -0.27009717f, 0.01966373f, 
    0.08376667f, 0.04235560f, 0.01304614f, 0.08159537f, -0.10018229f, -0.01052203f, 0.04589004f, 0.14256085f, 
    -0.20687990f, -0.03000201f, -0.14406441f, -0.05526210f, -0.03309755f, 0.09195285f, 0.14737435f, 0.13017006f, 
    -0.04050009f, 0.05121630f, -0.04609529f, 0.01836263f, -0.38949010f, 0.03811742f, -0.26198098f, -0.01081810f, 
    -0.11035950f, 0.05037960f, -0.03110087f, -0.06293433f, -0.05889078f, -0.04582363f, -0.20198089f, 0.02110973f, 
    0.14666568f, 0.00844068f, 0.07236025f, 0.24060109f, 0.01606861f, -0.06840351f, -0.07621702f, 0.01374205f, 
    0.00698093f, -0.03470717f, -0.01227968f, 0.04727669f, 0.31942472f, -0.08091307f, 0.11888783f, -0.13668649f, 
    0.14062671f, -0.08162951f, -0.13024448f, -0.11453871f, -0.01296515f, -0.10177239f, -0.06235444f, -0.07549292f, 
    0.06809641f, -0.19548689f, -0.05821779f, 0.09666077f, 0.15848313f, -0.00330673f, -0.10705612f, 0.07114516f, 
    -0.04035223f, -0.00295493f, -0.08497939f, -0.03072003f, 0.24998906f, -0.08289075f, -0.00488302f, 0.12268791f, 
    -0.01365979f, -0.13158463f, 0.02386795f, 0.08713377f, 0.04940886f, -0.00749567f, 0.05143866f, 0.10819960f, 
    -0.01036740f, 0.20094271f, -0.11238494f, 0.07016835f, -0.03556897f, 0.03464676f, 0.02017330f, 0.01804609f, 
    -0.05503744f, 0.05582409f, -0.07948998f, -0.09622748f, 0.05425276f, -0.07354070f, -0.12647976f, 0.12537359f, 
    -0.00346347f, -0.11785119f, -0.03219728f, 0.00449391f, -0.05737351f, -0.18938811f, 0.08220097f, 0.05782568f, 
    -0.07843801f, -0.27420491f, 0.11492533f, 0.06500953f, -0.07962552f, 0.03224132f, -0.08711608f, -0.01733100f, 
    -0.04975012f, 0.01274482f, -0.00063737f, -0.02296542f, 0.10639348f, 0.00350766f, -0.10630981f, -0.02473808f, 
    0.02069479f, 0.08844359f, 0.00841605f, 0.03812853f, -0.06210786f, 0.08722389f, -0.01068765f, -0.03059055f, 
    -0.03580155f, -0.13863096f, -0.18417692f, -0.12489253f, 0.00678449f, 0.00190221f, -0.01613232f, -0.06875850f, 
    0.06087238f, 0.08089694f, -0.05048405f, -0.04193770f, -0.09201890f, -0.03791302f, 0.02272030f, -0.11619631f, 
    -0.09437425f, -0.00276654f, 0.05663835f, 0.11357035f, 0.01030769f, -0.08188225f, 0.01688446f, -0.07162076f, 
    -0.03343102f, 0.01923502f, 0.10837990f, 0.13839829f, -0.00861919f, 0.01045971f, 0.04109255f, 0.14433666f, 
    -0.03364337f, -0.05798767f, -0.06356882f, -0.03306891f, 0.19836143f, 0.02822013f, -0.25618327f, -0.25171703f, 
    0.10658599f, -0.04755342f, -0.03801877f, -0.09662785f, -0.07059810f, 0.00851490f, -0.06229286f, -0.05976359f, 
    0.00741150f, -0.18612024f, 0.05371108f, -0.14851943f, 0.05676930f, 0.04565110f, -0.11836869f, 0.07885829f, 
    -0.02585343f, -0.13641761f, -0.01736214f, -0.07061098f, -0.15456767f, 0.01542913f, 0.06415003f, -0.13072215f, 
    -0.04960139f, -0.12743959f, -0.10873589f, -0.02802774f, 0.02016563f, -0.01964980f, 0.05659966f, -0.03956232f, 
    0.14504682f, 0.15968759f, -0.04635131f, -0.17583872f, 0.18591812f, -0.03486433f, 0.04347475f, -0.03618500f, 
    0.03883044f, 0.07352025f, 0.05885036f, -0.01273288f, 0.31088725f, 0.02491876f, -0.09485478f, 0.01248044f, 
    0.19756785f, 0.01366064f, 0.02361629f, -0.06534746f, -0.00385069f, -0.00785803f, 0.00159863f, -0.05911911f, 
    0.05177326f, 0.03266901f, -0.00049733f, 0.03775661f, 0.12094901f, 0.05398823f, 0.01516104f, -0.15801774f, 
    -0.03713580f, 0.09736477f, -0.04344471f, 0.01203493f, 0.02515103f, 0.06504227f, -0.06539208f, 0.09038011f, 
    0.00668104f, 0.09001753f, -0.01143335f, -0.01856017f, -0.03858100f, 0.07782446f, -0.01346963f, -0.11670917f, 
    0.22489589f, 0.01923331f, 0.09469911f, 0.16629006f, 0.00663457f, -0.00811917f, 0.01259597f, 0.02773148f, 
    -0.05571860f, 0.07808713f, 0.08084903f, -0.14794213f, 0.04424418f, 0.05581147f, -0.08142959f, -0.21823582f, 
    0.02972621f, 0.09971311f, 0.02025384f, 0.02085559f, -0.01066191f, -0.08184388f, -0.03024260f, -0.24264744f, 
    0.29759955f, -0.00454068f, -0.14998487f, -0.07480714f, -0.01266405f, -0.01555396f, -0.02316907f, -0.00916798f, 
    -0.03215901f, -0.02966088f, 0.04723166f, 0.02049522f, 0.41717568f, -0.04714763f, -0.06742885f, -0.03986259f, 
    -0.02759170f, 0.11095571f, -0.05178472f, -0.03654229f, 0.06541026f, -0.07786417f, 0.10002811f, 0.02472354f, 
    0.07730611f, -0.08347801f, -0.02442257f, 0.00937752f, 0.07094582f, 0.06077950f, -0.00219607f, 0.01526255f, 
    0.01139874f, 0.02642161f, 0.01478876f, -0.05222003f, 0.07993565f, 0.02664906f, 0.05171730f, -0.14855562f, 
    -0.02488886f, 0.06216965f, -0.01683486f, -0.03923551f, 0.00540134f, -0.08012807f, 0.00450059f, 0.00478330f, 
    0.27025262f, 0.11713688f, -0.06155654f, 0.19911040f, -0.15471478f, -0.02727651f, 0.04137524f, 0.04498944f, 
    -0.03190741f, -0.04156235f, 0.01612550f, 0.00592660f, 0.00498626f, -0.02286135f, -0.03486916f, -0.16402744f, 
    -0.04446865f, -0.09110153f, 0.08281823f, -0.08604953f, -0.06885106f, -0.09402989f, 0.04711074f, -0.01266802f, 
    0.46171987f, 0.01968682f, -0.26794118f, 0.01653284f, -0.07374284f, -0.00674272f, 0.02937244f, 0.02652333f, 
    0.03871196f, 0.03265148f, 0.01309812f, -0.09633008f, -0.39782164f, -0.02172410f, -0.00466300f, 0.03252726f, 
    -0.00839509f, -0.01173207f, 0.04773135f, 0.03569831f, -0.03150778f, -0.09617037f, -0.07213488f, -0.02639116f, 
    -0.14021447f, -0.09271245f, 0.09621000f, 0.01786761f, 0.08273567f, -0.02942706f, -0.02003250f, -0.09084997f, 
    0.06047668f, -0.06911506f, 0.03016820f, -0.05538848f, -0.05804038f, 0.18489882f, -0.04205290f, -0.31286344f, 
    -0.05411451f, -0.04014255f, -0.02998172f, -0.08599241f, -0.08508517f, 0.03435059f, -0.02964785f, -0.09514912f, 
    -0.06555147f, -0.00156126f, -0.10440929f, -0.25644943f, -0.03456836f, 0.01859944f, -0.00116576f, 0.05940286f, 
    -0.11396610f, -0.10239487f, -0.03785291f, -0.01901747f, 0.02878657f, 0.05061776f, -0.19745287f, -0.18315941f, 
    0.04337431f, -0.06019448f, -0.03636622f, -0.01916421f, -0.00631639f, 0.04365942f, -0.01689022f, -0.03078924f, 
    0.37178558f, 0.04098989f, -0.00744642f, 0.06855792f, -0.17625833f, 0.03368032f, 0.06700189f, 0.07997008f, 
    -0.11884553f, 0.06697772f, -0.01114518f, -0.03493841f, 0.01599424f, 0.11775327f, 0.01843556f, 0.14448413f, 
    -0.04124463f, 0.02846591f, -0.14634904f, 0.03987098f, -0.10025050f, 0.00509366f, 0.05559230f, 0.06375095f, 
    0.23945503f, -0.01002226f, 0.18817103f, 0.27367103f, -0.11051082f, -0.09398073f, -0.10401785f, 0.01415158f, 
    -0.02069636f, -0.02858209f, -0.02049632f, -0.01995976f, -0.33920714f, -0.02757225f, 0.00086215f, -0.16573480f, 
    -0.19202054f, 0.03550605f, 0.02993514f, -0.03698970f, -0.02902310f, -0.03843053f, 0.05973008f, 0.01195749f, 
    -0.19227514f, 0.04392272f, 0.09306070f, -0.02463270f, -0.03334018f, -0.02512321f, 0.10209910f, 0.06986251f, 
    -0.09709750f, -0.00199187f, -0.02056859f, -0.09606694f, 0.04060845f, 0.03396884f, 0.05095771f, 0.11625844f, 
    0.02472679f, 0.07719702f, -0.01056900f, 0.04039139f, -0.05704691f, -0.09389283f, 0.11637000f, -0.03250547f, 
    -0.13494895f, 0.03345288f, -0.12791884f, -0.02434888f, 0.01939706f, 0.04093564f, 0.03364077f, -0.00750287f, 
    0.01163016f, 0.04702372f, -0.01370274f, -0.05062827f, -0.00000374f, 0.01892932f, -0.16705960f, 0.17820652f, 
    -0.09392523f, -0.04375679f, 0.03582201f, 0.01482090f, 0.06443907f, 0.08418426f, -0.00565420f, -0.06298336f, 
    0.08634607f, -0.08163896f, 0.01399005f, 0.13411337f, -0.06824993f, 0.07534163f, 0.01612187f, -0.00773429f, 
    0.00789358f, -0.08613341f, -0.09022496f, 0.04302761f, 0.25222966f, -0.10995016f, -0.11904921f, 0.09632522f, 
    0.00609703f, -0.00237316f, -0.04885241f, 0.06777811f, -0.14628179f, 0.11212128f, -0.14671896f, -0.07878481f, 
    0.20186441f, 0.02298542f, 0.16670072f, 0.06228142f, -0.04711870f, 0.05170866f, 0.01031233f, 0.02266921f, 
    -0.09352040f, 0.05954761f, -0.02636857f, -0.01932672f, 0.38485605f, 0.04945011f, -0.30738375f, 0.08102426f, 
    -0.04063615f, 0.11576677f, -0.06566957f, -0.08509555f, -0.00337109f, 0.09096245f, 0.00718789f, 0.08355536f, 
    -0.33225998f, 0.07961109f, 0.08110043f, -0.13848715f, -0.16780414f, 0.01431405f, -0.18538009f, -0.07039765f, 
    -0.10677243f, -0.12797581f, -0.06913041f, -0.15908040f, 0.22613934f, 0.10468722f, 0.01501664f, -0.09116669f, 
    -0.03732092f, -0.01651564f, 0.02847683f, -0.00870190f, 0.02429280f, 0.04558477f, 0.17553809f, 0.01210538f, 
    -0.27137312f, -0.12680742f, -0.12799869f, -0.17317083f, 0.04238724f, -0.00920423f, 0.01582948f, -0.06035801f, 
    0.00919728f, 0.04427265f, -0.03726788f, -0.02971393f, 0.26134467f, 0.01552733f, 0.03136808f, -0.03942451f, 
    -0.17038456f, -0.10432720f, -0.01117995f, 0.06450400f, 0.01863864f, -0.07323838f, -0.06363072f, -0.05041935f, 
    0.00130708f, -0.05401047f, -0.05524759f, -0.01086439f, -0.08372786f, 0.02993787f, 0.05251997f, 0.02355118f, 
    0.00672295f, 0.07578587f, -0.04564159f, 0.10454848f, -0.20630249f, 0.04064989f, -0.22532988f, -0.02243421f, 
    -0.10595258f, -0.01007609f, 0.01137164f, -0.02467921f, -0.00080380f, 0.01072934f, -0.01430498f, 0.01559059f, 
    0.23560302f, 0.00683277f, -0.08787626f, -0.03577838f, 0.10062295f, 0.02368212f, -0.00049102f, -0.03188437f, 
    -0.13184047f, -0.01428351f, 0.05887605f, -0.10564391f, 0.23996836f, -0.00601399f, 0.08595823f, 0.00762714f, 
    -0.04326296f, -0.07937552f, 0.01661485f, 0.08444344f, 0.03038887f, -0.04894746f, -0.01273798f, -0.14222199f, 
    0.09635647f, -0.06653258f, 0.15732121f, 0.11937935f, 0.01410128f, 0.01733571f, 0.05029377f, 0.05110031f, 
    -0.01552714f, 0.04272205f, 0.08600891f, -0.00315110f, 0.09912547f, -0.15512839f, 0.05156891f, 0.10465295f, 
    0.05712042f, 0.04055114f, 0.01954788f, -0.10478237f, 0.02952247f, 0.08003595f, -0.02590096f, 0.05970783f, 
    -0.11739491f, 0.04809801f, -0.20605846f, -0.01069440f, 0.04682438f, 0.08077869f, -0.04098818f, 0.12575735f, 
    -0.04508246f, 0.03767054f, -0.07420436f, -0.16820079f, 0.11118984f, 0.00476244f, -0.07004638f, -0.04836184f, 
    -0.03655904f, -0.04611472f, -0.08422534f, 0.14488289f, 0.04598712f, -0.03519495f, 0.10469281f, -0.09689111f, 
    0.14124118f, -0.21897253f, 0.09819399f, -0.10130058f, -0.00155556f, 0.03969324f, -0.08958813f, -0.08149345f, 
    0.00310128f, -0.00351650f, 0.03230973f, -0.03695479f, 0.03320143f, -0.19930266f, 0.06172517f, -0.02684555f, 
    0.07996311f, -0.02326319f, 0.01857297f, 0.03953104f, 0.00764564f, 0.08904999f, 0.01419857f, -0.00855274f, 
    0.25081432f, -0.24498597f, 0.13975661f, -0.08948576f, -0.10528115f, -0.08125768f, 0.02715021f, 0.00326643f, 
    0.16344419f, 0.02452136f, 0.05044264f, -0.09461173f, 0.31051588f, -0.12315559f, -0.19440524f, 0.16872574f, 
    -0.06530680f, 0.08069064f, 0.12115601f, 0.07616040f, -0.07819926f, 0.03133019f, -0.04739669f, -0.02271086f, 
    -0.29532737f, -0.04558304f, 0.02722416f, -0.07885703f, 0.07917950f, -0.12531102f, -0.00374926f, -0.09237298f, 
    -0.12718831f, 0.06133840f, -0.01179210f, -0.13585700f, -0.06418263f, -0.33653811f, -0.22062376f, -0.09204775f, 
    -0.07016902f, -0.05602677f, -0.08284782f, -0.01353822f, -0.00095417f, 0.02189323f, 0.05414242f, -0.06167924f, 
    -0.31098717f, -0.02785454f, -0.20308791f, -0.20168142f, 0.02731143f, 0.03235205f, -0.01918283f, -0.07900059f, 
    0.00722838f, 0.09319541f, -0.08059733f, 0.02399106f, 0.19576567f, -0.00362733f, -0.12556988f, -0.14140567f, 
    -0.10076716f, 0.04078666f, -0.05128808f, 0.04983983f, 0.03993660f, -0.07049669f, -0.02450154f, -0.10774842f, 
    -0.06289451f, 0.09006574f, -0.00694008f, -0.05998909f, 0.06486116f, 0.05966132f, -0.02228857f, 0.03020515f, 
    -0.09013188f, 0.01361230f, 0.00583966f, -0.03420926f, 0.00774629f, -0.02570621f, 0.02087145f, -0.08294805f, 
    -0.05053627f, -0.01196098f, 0.10935256f, 0.11715179f, -0.05443836f, 0.01572416f, -0.08074063f, 0.01454083f, 
    0.19088842f, -0.16409187f, 0.04050210f, -0.17604205f, 0.00106035f, -0.01129878f, 0.04405927f, -0.04455223f, 
    -0.03101220f, -0.01291086f, -0.03454961f, 0.02430091f, 0.04771781f, 0.07163883f, -0.06509650f, -0.04349023f, 
    -0.10835766f, 0.01025332f, 0.05096165f, 0.09751365f, -0.14931063f, 0.00351324f, -0.01568507f, -0.04787887f, 
    0.16719523f, -0.04751714f, 0.05938968f, 0.05974088f, -0.14318407f, -0.03810347f, 0.04826592f, -0.05119670f, 
    0.07011390f, -0.02912552f, -0.09343585f, -0.01851338f, 0.06577720f, -0.19957213f, -0.01991337f, 0.01481291f, 
    -0.12463430f, -0.07532672f, -0.01756603f, -0.04103684f, -0.05716246f, 0.00412245f, -0.02661749f, 0.01909261f, 
    0.10367032f, 0.01934894f, -0.06243360f, 0.03835881f, -0.07247052f, 0.02408180f, -0.08946637f, -0.01087482f, 
    0.05423785f, 0.11298802f, -0.04569037f, -0.03579682f, -0.53318059f, -0.13572076f, -0.15638183f, -0.13105518f, 
    -0.15302859f, 0.06402296f, -0.05564469f, -0.02739479f, -0.02181706f, -0.05445964f, 0.06236289f, 0.02685981f, 
    0.25536925f, 0.07139395f, 0.01256747f, -0.13610794f, 0.00001848f, 0.02647065f, 0.04047379f, -0.03684478f, 
    -0.04163175f, 0.03878942f, 0.13646431f, -0.06501741f, 0.10056536f, -0.21935166f, -0.13947424f, 0.02567804f, 
    -0.07098768f, 0.02354497f, 0.02881830f, 0.06088243f, 0.04204318f, -0.03648308f, -0.00846905f, 0.01840722f, 
    -0.09051621f, 0.09324349f, -0.16622029f, -0.10446827f, -0.02738669f, 0.00642294f, 0.04863594f, -0.10044190f, 
    -0.07604558f, 0.01207327f, 0.08475585f, -0.08712400f, 0.08926108f, 0.22003846f, -0.06902216f, -0.02698730f, 
    0.05359321f, 0.05514202f, -0.00427745f, 0.15706800f, -0.03855252f, 0.04154162f, -0.09154855f, -0.04442546f, 
    -0.28031990f, -0.19880664f, 0.22780468f, 0.05709225f, 0.00508979f, 0.05804651f, 0.04871276f, -0.05017934f, 
    0.06472738f, -0.15279040f, 0.13339755f, -0.05712231f, -0.00954090f, -0.08689027f, -0.00153264f, 0.07825732f, 
    -0.03552609f, 0.05228872f, 0.05039984f, -0.02556302f, -0.15221791f, -0.01711419f, 0.06169844f, 0.09874155f, 
    0.20231356f, -0.30578989f, 0.06412220f, -0.03051390f, 0.00285056f, 0.13590907f, -0.03196446f, -0.08274322f, 
    0.06541990f, -0.11740850f, 0.07005654f, -0.13126513f, -0.40789950f, 0.17519636f, 0.26428154f, 0.06754846f, 
    0.12589656f, -0.02348792f, 0.04817825f, 0.01064389f, 0.01986444f, 0.06807567f, -0.07776242f, 0.05710952f, 
    0.22971320f, -0.11847187f, 0.15945102f, -0.03209209f, -0.04306871f, 0.00610149f, -0.11601911f, 0.10041688f, 
    0.09253822f, -0.09428170f, -0.07103549f, -0.01652460f, -0.12871122f, -0.36872196f, -0.15047579f, 0.26304042f, 
    0.01917419f, 0.05209292f, 0.08391613f, -0.07056815f, 0.02677695f, -0.03357940f, -0.12264588f, 0.03226893f, 
    -0.17967114f, 0.07661092f, -0.05888586f, -0.20638876f, -0.12235302f, -0.03685172f, -0.03770670f, 0.03460936f, 
    -0.09455521f, -0.10578712f, -0.05187621f, 0.05284275f, -0.05845058f, 0.15080759f, 0.11178595f, 0.08385078f, 
    0.06166810f, 0.04321208f, 0.03391508f, 0.07170501f, -0.04985527f, -0.03231948f, 0.00321191f, -0.16475122f, 
    -0.05137507f, 0.37169242f, 0.06555127f, -0.15720128f, 0.03086480f, 0.03546911f, 0.02158170f, 0.07620288f, 
    0.02639398f, -0.01137378f, 0.01129329f, -0.00268193f, -0.04016520f, 0.13745518f, 0.13886070f, 0.20617393f, 
    -0.09651240f, 0.08038188f, -0.09263075f, -0.05789809f, -0.09197314f, -0.00745646f, 0.00048710f, -0.04123345f, 
    -0.12675186f, -0.45216772f, -0.26760441f, 0.31135017f, -0.01321596f, 0.01221532f, -0.12559396f, 0.02590157f, 
    -0.01402597f, -0.08228695f, -0.07863192f, -0.03447085f, -0.42163646f, -0.21332808f, -0.15237650f, -0.01200877f, 
    -0.05671262f, 0.01793489f, -0.08134934f, -0.00811765f, 0.02036889f, -0.13020363f, -0.03812505f, -0.05632701f, 
    -0.16166562f, 0.14881834f, 0.03494426f, -0.20401649f, -0.05905752f, 0.04959672f, 0.02319728f, 0.02805128f, 
    -0.02617828f, -0.00135294f, -0.01349948f, 0.06079388f, 0.12793274f, -0.01735226f, 0.07287925f, 0.02639308f, 
    -0.08045576f, -0.03987780f, 0.10647030f, -0.00977927f, -0.08767007f, 0.06826830f, -0.05790355f, 0.04771215f, 
    0.07191619f, 0.08868571f, 0.11582931f, -0.01956517f, 0.04810926f, -0.17966937f, 0.03530597f, -0.05625901f, 
    -0.09827266f, -0.07805320f, -0.09615756f, 0.07178464f, 0.07787716f, 0.06162763f, -0.00546816f, 0.04371966f, 
    0.03584170f, 0.14491458f, -0.02511152f, 0.07064724f, 0.01043452f, -0.07890179f, 0.05419910f, 0.02436139f, 
    -0.14269808f, -0.01240516f, -0.18191344f, 0.13688597f, -0.04312184f, 0.03412525f, 0.02847595f, -0.23610877f, 
    -0.05336658f, 0.03991114f, 0.03628837f, -0.01695084f, 0.31053072f, 0.13189493f, 0.12520181f, -0.06021637f, 
    -0.01897371f, -0.04736181f, -0.03456036f, 0.08694683f, 0.03359546f, 0.01722141f, 0.02855777f, -0.06481954f, 
    0.06794721f, 0.06108972f, 0.04638182f, 0.03042447f, -0.04241574f, 0.02720472f, -0.00692703f, -0.09201294f, 
    0.01075008f, 0.07790945f, -0.05257451f, 0.04309454f, -0.18284632f, 0.07747497f, 0.14135310f, -0.01750423f, 
    0.06248014f, -0.03894994f, -0.02130827f, -0.05063673f, -0.08853799f, -0.01679475f, -0.01568279f, -0.05725621f, 
    -0.25408947f, 0.04055951f, -0.00159834f, -0.24638636f, -0.06101397f, -0.08464332f, -0.13489272f, 0.10879961f, 
    0.05598217f, -0.11100932f, 0.01849834f, -0.03474824f, 0.00505118f, 0.09751707f, 0.07040568f, -0.17969215f, 
    -0.07864495f, -0.05061347f, 0.05896442f, -0.05929848f, -0.03968450f, -0.03079683f, -0.04709600f, -0.01729495f, 
    0.07577405f, -0.03485722f, -0.02763289f, 0.01479382f, -0.13127087f, -0.03245274f, 0.01480925f, -0.00839508f, 
    -0.03910907f, -0.00901780f, -0.02236344f, 0.03246571f, -0.02983086f, -0.10450427f, 0.02079220f, -0.00530807f, 
    -0.02176063f, -0.07841922f, 0.09643700f, 0.03803320f, -0.11724626f, 0.01723527f, -0.02780706f, 0.01225755f, 
    -0.05437922f, -0.22489378f, -0.21259350f, 0.02440681f, -0.12751879f, 0.04015128f, -0.00597586f, 0.06101905f, 
    -0.04062361f, 0.07886478f, -0.11603838f, 0.00156943f, -0.15735732f, 0.01308923f, -0.02819699f, -0.08656874f, 
    -0.07672045f, 0.10826426f, 0.04715646f, 0.10617251f, 0.04757405f, 0.03197842f, -0.00441127f, 0.01454091f, 
    0.15379143f, -0.00318781f, 0.03761825f, -0.00704988f, -0.03345397f, 0.04005180f, 0.06903956f, 0.05180705f, 
    -0.00367659f, 0.06613234f, -0.04310803f, 0.05366858f, 0.13078082f, 0.05599632f, 0.03852483f, 0.00866821f, 
    -0.13918407f, -0.06009568f, 0.10215460f, -0.00138176f, -0.05387869f, 0.02567071f, 0.02830245f, 0.03993471f, 
    -0.32453811f, -0.04332088f, 0.05574120f, 0.16065316f, -0.00503646f, -0.02410905f, 0.11830103f, -0.00936366f, 
    -0.04375442f, -0.03272673f, -0.16409640f, 0.03058469f, -0.06041576f, 0.00110052f, 0.15751818f, 0.21281455f, 
    -0.00185617f, 0.05605760f, 0.04648190f, 0.05721064f, -0.04037068f, 0.11841700f, -0.14765778f, -0.00551551f, 
    -0.14094591f, 0.03426508f, -0.07347947f, -0.14317302f, -0.02558696f, -0.01450672f, -0.14661780f, 0.06110016f, 
    0.16413608f, -0.15296982f, 0.09775646f, -0.02416537f, 0.00833981f, 0.05910406f, 0.18071635f, -0.05023947f, 
    -0.03559171f, -0.03728733f, 0.00185471f, 0.02824055f, -0.07913293f, 0.07744951f, -0.04235033f, 0.04382273f, 
    0.27141818f, 0.03032510f, -0.09806845f, -0.09357211f, 0.00757120f, 0.20385343f, -0.00724879f, 0.05503254f, 
    -0.02955743f, -0.02394452f, 0.01369097f, 0.04603707f, -0.27027389f, -0.37161970f, -0.20428839f, -0.14819698f, 
    -0.00721263f, 0.02777025f, -0.02966168f, 0.03496101f, -0.08848775f, 0.16259266f, 0.00622439f, 0.05404614f, 
    0.25373733f, -0.12937158f, 0.08816433f, -0.00885888f, -0.10854671f, 0.14561042f, -0.01999877f, 0.05045919f, 
    0.08255140f, 0.05096978f, -0.01586996f, 0.03979167f, -0.04661572f, -0.09737814f, -0.13140714f, -0.06114229f, 
    -0.09516400f, -0.07322779f, 0.06383777f, 0.00698914f, -0.01987627f, -0.00065571f, -0.05791755f, 0.16767384f, 
    0.01613294f, 0.24261028f, 0.09392225f, 0.15120248f, 0.06559715f, 0.04693709f, -0.01775332f, 0.02898190f, 
    -0.05931799f, 0.07377326f, -0.07503546f, 0.00759803f, 0.07347816f, 0.20731539f, 0.00942349f, -0.02557526f, 
    -0.02771144f, -0.05116866f, 0.15038007f, -0.00273622f, -0.11207382f, 0.01160339f, 0.03129258f, -0.06787705f, 
    -0.58422011f, -0.01031604f, 0.13068220f, 0.15855965f, -0.01873699f, 0.00341555f, -0.06852330f, -0.02397026f, 
    -0.03677608f, 0.01596468f, -0.05636957f, -0.02467431f, -0.17031892f, 0.07628474f, -0.04745278f, -0.22543551f, 
    0.01343376f, -0.08592614f, -0.07937476f, -0.03349275f, -0.04302107f, -0.06798331f, 0.00558259f, 0.07570523f, 
    -0.17633791f, -0.07322475f, 0.03304838f, 0.04335773f, -0.03696396f, 0.04639814f, 0.05788650f, -0.03739052f, 
    -0.03859394f, 0.00554309f, -0.00113560f, -0.01800219f, 0.07751527f, -0.49033305f, -0.36450052f, 0.06789208f, 
    -0.11934314f, -0.06336378f, 0.05146574f, -0.01759596f, -0.00033361f, 0.06440660f, -0.13581616f, -0.02973602f, 
    0.34115213f, -0.12007495f, 0.09384423f, 0.06302994f, -0.09180886f, 0.06693508f, 0.14445442f, -0.00934660f, 
    0.05111855f, -0.04114202f, 0.00211051f, 0.01233898f, 0.21371485f, -0.00616644f, 0.01927355f, -0.03901209f, 
    0.00390470f, 0.02352192f, -0.04750485f, -0.03408648f, -0.03931435f, -0.03138931f, 0.12379275f, 0.00268376f, 
    0.10285707f, 0.19050825f, -0.02253570f, 0.08577395f, -0.00597062f, 0.06613770f, -0.01042875f, -0.04021973f, 
    -0.01493396f, 0.08991010f, 0.03899934f, 0.03674319f, -0.42278144f, -0.38238800f, -0.21458955f, -0.06608084f, 
    -0.07828672f, -0.08223063f, -0.01849679f, -0.02090895f, 0.00529479f, -0.02110340f, 0.04308168f, 0.03405577f, 
    0.10019974f, -0.11166307f, -0.00792105f, -0.05266147f, -0.03459640f, -0.05128902f, 0.06300762f, 0.05797709f, 
    0.01419666f, -0.03412172f, 0.02744752f, -0.06686305f, -0.18460447f, 0.11598877f, 0.05813376f, -0.07690620f, 
    -0.09013259f, -0.08010594f, 0.11363564f, 0.05170528f, -0.14460939f, 0.06679283f, -0.04508561f, -0.02050025f, 
    0.20153503f, 0.09694644f, -0.00300654f, 0.08794720f, -0.09343982f, 0.00527478f, -0.04483821f, 0.06488486f, 
    0.05774159f, 0.03843791f, -0.18683155f, 0.00659502f, 0.13013241f, -0.04237903f, -0.00513548f, 0.10600907f, 
    -0.00920641f, -0.11161456f, 0.05863656f, -0.00597094f, -0.05908177f, 0.05527338f, 0.05327515f, -0.16838472f, 
    0.12961829f, -0.16952559f, 0.00309690f, 0.15740262f, 0.04194276f, 0.05410172f, -0.18421328f, -0.01971220f, 
    0.04271756f, 0.02554501f, 0.02640436f, 0.01167592f, -0.06482517f, 0.20410009f, 0.18010914f, -0.03977404f, 
    0.02732393f, -0.04799425f, 0.02562467f, -0.00332872f, -0.01078755f, -0.04412885f, -0.01253604f, 0.16397010f, 
    -0.41599935f, -0.20289545f, 0.05790088f, 0.12668602f, -0.01056619f, 0.04505999f, -0.01250754f, -0.03909031f, 
    0.03233993f, -0.15826988f, 0.02927751f, 0.02837573f, -0.12137336f, 0.00362239f, 0.05774485f, 0.02947156f, 
    -0.09995513f, -0.04745001f, -0.06665088f, -0.05088082f, -0.01690785f, 0.09798261f, -0.00784667f, 0.07850040f, 
    0.28882343f, -0.00830696f, -0.13965836f, 0.16872965f, 0.00414313f, 0.05514418f, 0.12342104f, 0.05288389f, 
    0.01261631f, -0.01250557f, 0.08937796f, 0.12824994f, 0.13451242f, -0.33489287f, -0.12615570f, -0.12372973f, 
    -0.04659865f, -0.01260698f, -0.09324440f, 0.04079317f, 0.04395458f, 0.09120918f, -0.09861609f, 0.07356072f, 
    0.03342284f, 0.03279496f, 0.00256598f, 0.04410412f, 0.01548017f, -0.10249003f, -0.01173765f, -0.03217703f, 
    0.05834346f, 0.00984905f, 0.02615573f, -0.00717798f, -0.06223015f, 0.13863778f, 0.00200772f, 0.02142182f, 
    -0.09201644f, 0.01497829f, -0.04134422f, 0.16184998f, 0.00309764f, 0.02015143f, 0.03711633f, 0.01668513f, 
    -0.15239266f, 0.02622884f, -0.00402673f, 0.12101750f, 0.14832599f, -0.08049602f, 0.12233033f, 0.03515388f, 
    -0.09465323f, 0.08587167f, 0.05420902f, -0.10924933f, -0.12942480f, 0.13869123f, 0.10423640f, 0.06829512f, 
    0.03094585f, -0.02932288f, -0.00889084f, 0.12719263f, 0.02270427f, 0.03894356f, -0.00199558f, -0.03751286f, 
    0.12240342f, -0.01048408f, 0.00765027f, -0.07146834f, 0.09221482f, -0.08748116f, 0.00386690f, -0.17258188f, 
    0.01430050f, -0.03571725f, -0.04859205f, -0.06766188f, -0.04155808f, 0.17302108f, -0.00291091f, 0.11059381f, 
    -0.02921960f, 0.05332046f, 0.05776873f, -0.01621132f, -0.00442990f, -0.05374575f, -0.00336485f, 0.00200525f, 
    -0.43898317f, -0.05620713f, -0.00557150f, 0.20851707f, 0.01611475f, -0.05132640f, 0.13063832f, -0.15532853f, 
    -0.04552820f, -0.08984210f, 0.14049408f, 0.01079649f, -0.22633034f, -0.18448411f, 0.13598520f, -0.28150854f, 
    0.11612258f, 0.15366901f, -0.00552418f, -0.11604672f, -0.03367960f, 0.07044171f, -0.04290199f, -0.16875264f, 
    0.01432832f, 0.05951674f, -0.02054470f, -0.18825498f, 0.13010189f, 0.08764206f, 0.12170903f, -0.07816515f, 
    0.00990420f, -0.02695521f, 0.02238297f, 0.02142736f, -0.39750016f, 0.09606067f, 0.26045227f, 0.02742251f, 
    0.05879959f, -0.03847175f, 0.03227459f, -0.08609275f, 0.07538632f, -0.00579388f, 0.01025343f, 0.02643656f, 
    0.33794427f, -0.05371498f, 0.14237060f, 0.13075158f, -0.02856602f, -0.07439186f, 0.08895119f, -0.07468936f, 
    0.08817527f, 0.00776473f, -0.00443232f, -0.00511835f, -0.18964808f, 0.06274900f, -0.01424962f, -0.02920084f, 
    -0.04804491f, -0.02275665f, -0.01309373f, -0.06158128f, -0.10251290f, -0.08453630f, 0.06744587f, -0.01457832f, 
    -0.05493583f, 0.04700957f, 0.04995334f, -0.03019396f, -0.07039350f, 0.01588442f, -0.00959393f, 0.03336376f, 
    -0.09119947f, -0.03579682f, 0.02053879f, -0.05789243f, -0.18687284f, -0.05318248f, 0.12362378f, 0.11981132f, 
    -0.10764326f, 0.00249994f, 0.03849320f, 0.05627325f, -0.01375538f, -0.00966563f, 0.00257192f, -0.00034398f, 
    0.00255002f, -0.11169048f, 0.11426876f, 0.28335062f, 0.00048811f, -0.03705770f, 0.04781480f, 0.06781389f, 
    -0.11726645f, 0.09870867f, 0.04347069f, 0.10326633f, -0.25151148f, -0.16607648f, 0.14325388f, 0.04820992f, 
    -0.02946482f, 0.02247134f, 0.03824778f, -0.12663619f, 0.05884619f, -0.09233332f, -0.00870140f, 0.01937704f, 
    0.19207306f, 0.19383916f, -0.20539564f, -0.15009031f, 0.06394095f, -0.09747211f, 0.10301098f, -0.10439444f, 
    -0.00934836f, 0.00353961f, -0.16429450f, -0.02706229f, -0.56855947f, 0.03020720f, -0.03873023f, -0.06232266f, 
    0.04305268f, -0.15217426f, -0.01552179f, 0.01540113f, -0.06798197f, -0.11510684f, 0.01743075f, 0.01790371f, 
    -0.22012435f, 0.21003586f, 0.20529535f, -0.07348561f, -0.04460629f, -0.05752124f, -0.07362001f, -0.02543083f, 
    0.06816297f, -0.13131675f, 0.00590833f, -0.10940389f, -0.39796287f, -0.05767071f, 0.02584231f, -0.01334738f, 
    -0.01596651f, 0.00303555f, -0.04056081f, 0.00822685f, 0.04894706f, -0.04073287f, -0.11121552f, -0.09848371f, 
    -0.29455808f, 0.09459043f, 0.22890966f, 0.15757619f, -0.09428377f, 0.06390309f, -0.03806920f, -0.02993669f, 
    0.05312995f, 0.01695977f, 0.06598941f, 0.00161450f, 0.04097199f, -0.05271802f, 0.08203052f, -0.11300600f, 
    -0.00275169f, -0.02899412f, -0.04534000f, 0.07426535f, 0.08305455f, -0.03470589f, -0.02164794f, -0.07774743f, 
    -0.22217260f, -0.08464454f, -0.00809295f, -0.04546241f, -0.01829355f, -0.00536256f, 0.00397859f, 0.02951557f, 
    -0.16261235f, -0.09470220f, -0.06913219f, 0.03471419f, -0.20330319f, 0.21176238f, -0.07731120f, 0.06604475f, 
    -0.00018931f, 0.03852894f, -0.04488023f, 0.04107065f, -0.04456316f, -0.01551844f, -0.05087879f, -0.00556734f, 
    0.20904692f, -0.05011848f, -0.22237954f, 0.04216750f, -0.03401347f, 0.02970527f, 0.05275695f, 0.00704660f, 
    -0.02450611f, -0.04862852f, -0.04337048f, -0.06362916f, 0.13160342f, 0.06056537f, -0.05283279f, -0.14786671f, 
    0.12655756f, 0.00039035f, 0.06074469f, 0.01338178f, -0.04977611f, 0.01421861f, 0.07803927f, 0.03190785f, 
    0.04363453f, 0.01624195f, 0.07406892f, 0.12983581f, 0.03968816f, -0.13135280f, -0.01767750f, 0.00204706f, 
    0.07423460f, -0.03669610f, -0.05422749f, -0.02747805f, -0.02441580f, 0.02196945f, 0.23596805f, 0.01836723f, 
    0.09409259f, -0.04610702f, 0.04700440f, -0.07977428f, 0.07863341f, 0.06973363f, 0.03684154f, -0.04379393f, 
    0.23704746f, 0.05437973f, -0.05634008f, 0.05314837f, 0.06170283f, 0.00372868f, -0.12627845f, 0.07015995f, 
    -0.04427476f, 0.00052330f, 0.04996651f, -0.02480193f, 0.44363782f, -0.03687224f, -0.01195481f, 0.03383667f, 
    0.13148418f, -0.00583376f, 0.03579709f, 0.08015016f, -0.04974457f, -0.05533647f, -0.04434923f, -0.07883272f, 
    -0.32331246f, 0.00064911f, 0.06396287f, 0.11544871f, 0.02492308f, -0.01234811f, 0.00023587f, 0.10733923f, 
    -0.01105717f, -0.11284220f, -0.01368128f, -0.03093507f, 0.13843836f, -0.36313319f, 0.00401001f, -0.25477222f, 
    -0.02856114f, 0.08507970f, -0.05807488f, 0.00674762f, 0.10739779f, 0.01159099f, 0.04137354f, 0.07141858f, 
    -0.13961104f, -0.32252181f, 0.07994229f, -0.13132839f, -0.07916199f, 0.09300018f, 0.02971727f, -0.02684918f, 
    0.02986260f, 0.08340342f, 0.03021224f, 0.03895267f, 0.23529421f, -0.05857759f, 0.07565337f, 0.12696140f, 
    -0.00942178f, 0.06164166f, 0.04905284f, -0.00464546f, 0.05256952f, -0.01565836f, 0.07852705f, 0.11800246f, 
    0.14916049f, 0.01586398f, -0.02459737f, 0.05095050f, -0.05580804f, 0.02904420f, 0.01010832f, -0.16177732f, 
    -0.04058014f, 0.05233535f, -0.03489690f, -0.09538966f, -0.03219631f, -0.05232633f, -0.05844425f, 0.07097441f, 
    0.06248441f, 0.04312379f, 0.04481427f, 0.06721820f, -0.00862611f, 0.02519110f, 0.00227784f, 0.03995153f, 
    -0.22070129f, -0.00615280f, -0.07442161f, -0.08951568f, 0.00662148f, 0.01801242f, 0.08395856f, 0.03749941f, 
    0.13670023f, -0.02685972f, -0.04978274f, 0.03367373f, -0.19165143f, -0.05514799f, 0.13551201f, -0.05193398f, 
    0.00542696f, -0.10685508f, -0.10337391f, -0.09724811f, 0.03921998f, 0.01892811f, -0.09987316f, 0.01466618f, 
    0.01379707f, 0.11031412f, -0.10246311f, 0.10435066f, -0.01196324f, 0.01152799f, 0.13222541f, 0.10342751f, 
    -0.08717958f, -0.03720780f, -0.00272552f, 0.07636544f, -0.15334088f, 0.03488515f, -0.02511699f, 0.02421968f, 
    0.16815306f, -0.02238791f, 0.16456515f, 0.01784755f, -0.09983488f, -0.01423946f, -0.04040662f, 0.08537129f, 
    -0.00829627f, -0.01607468f, 0.05895921f, -0.11829772f, 0.01065714f, -0.00886828f, -0.11607936f, 0.02193911f, 
    -0.10366172f, 0.03560500f, -0.10747435f, 0.05251269f, -0.24974149f, -0.10176856f, -0.00623816f, -0.05109277f, 
    -0.15074350f, -0.04579378f, 0.01230312f, 0.03377002f, -0.05857181f, 0.00095457f, 0.00605813f, -0.04577076f, 
    0.03606817f, 0.07371882f, 0.04862975f, 0.11322547f, -0.07449036f, 0.01519579f, 0.09140649f, -0.03799652f, 
    -0.01541580f, 0.13221633f, 0.11074910f, 0.13255914f, -0.14605829f, 0.11844762f, 0.18747956f, 0.16512108f, 
    0.06444450f, -0.02083867f, 0.07227524f, 0.09838097f, 0.12157814f, 0.00528664f, -0.01982782f, -0.01584809f, 
    -0.00999829f, -0.10100884f, 0.04035741f, 0.12308021f, 0.01238606f, 0.10921515f, 0.00266697f, -0.05262643f, 
    0.11008784f, -0.08486138f, 0.02682267f, 0.02927956f, 0.34013900f, -0.06110660f, -0.28174114f, -0.23867007f, 
    -0.09246003f, -0.04350495f, 0.06105472f, -0.14933354f, 0.00833732f, -0.15225965f, 0.13351783f, 0.05908634f, 
    -0.25229734f, 0.02101195f, 0.10387505f, 0.17451853f, -0.14203514f, -0.09624891f, -0.03686963f, 0.02490581f, 
    0.04756564f, -0.01486263f, -0.09105965f, -0.14227502f, -0.30969614f, -0.02284711f, 0.06604238f, -0.00478701f, 
    -0.02427793f, -0.01511511f, -0.11743795f, 0.03195632f, 0.00779804f, -0.00569593f, -0.03720419f, -0.01676315f, 
    -0.51680535f, -0.16609605f, 0.15185632f, 0.13418704f, 0.00772305f, -0.06376504f, 0.03522011f, 0.02148332f, 
    0.05839972f, 0.00040033f, -0.00260833f, 0.07089731f, -0.00083754f, 0.20141904f, -0.13139592f, 0.02731542f, 
    -0.08374102f, -0.04194397f, 0.06226600f, 0.11753686f, 0.06701893f, -0.06384224f, -0.00628210f, 0.03226499f, 
    0.02706104f, -0.08747910f, -0.11749557f, 0.10388053f, -0.04717887f, 0.08503671f, 0.10146600f, 0.01585097f, 
    -0.06695428f, 0.02215410f, 0.04216412f, 0.01159010f, -0.21986030f, -0.09222373f, -0.06682996f, -0.04395172f, 
    -0.00206177f, 0.02076664f, -0.11902142f, 0.05920042f, 0.06813626f, -0.13533780f, -0.04404219f, 0.01959326f, 
    -0.10864451f, 0.20180845f, -0.05634204f, -0.13392137f, 0.03571228f, -0.13638481f, 0.03817172f, 0.06762366f, 
    -0.08249145f, -0.05689539f, 0.02498602f, 0.04653291f, 0.35664204f, 0.08693875f, -0.12047917f, -0.07396021f, 
    -0.04692839f, -0.06059266f, 0.01580133f, 0.09820197f, -0.12680121f, 0.02835374f, 0.05573647f, 0.07299238f, 
    -0.80093092f, 0.18116617f, -0.03877680f, -0.00805632f, -0.00489815f, -0.01206601f, -0.00059103f, 0.07241930f, 
    0.03842572f, 0.00467593f, 0.01159620f, 0.06083982f, -0.30175412f, -0.03009317f, 0.01330890f, 0.05411657f, 
    -0.01965773f, 0.14362642f, 0.07622156f, -0.05313833f, 0.01886543f, 0.05750566f, 0.10502871f, 0.00475435f, 
    -0.09241802f, -0.10209244f, -0.16473944f, 0.00343253f, -0.01509711f, -0.03442491f, 0.08290923f, 0.01160537f, 
    0.03792215f, -0.09722167f, 0.09436869f, -0.09976826f, 0.06023149f, 0.09417337f, 0.09511895f, 0.01250194f, 
    -0.08891200f, 0.04664269f, -0.01672721f, 0.08161632f, 0.08964740f, -0.18126029f, -0.08292689f, 0.03894609f, 
    -0.24367854f, -0.05909169f, 0.18473575f, 0.07533791f, -0.04375743f, -0.07280799f, -0.00018724f, -0.08788345f, 
    0.09238727f, -0.07704990f, -0.05814091f, 0.01362455f, 0.24501762f, -0.03367561f, 0.07188758f, -0.24589841f, 
    0.12155978f, -0.01053318f, -0.00211797f, -0.02771212f, -0.09816013f, -0.01318554f, -0.04978208f, -0.00863387f, 
    0.03712685f, 0.04990879f, 0.08771171f, 0.10800453f, 0.02979933f, -0.05512371f, 0.02163544f, 0.01397887f, 
    0.02680900f, 0.03697214f, -0.06881545f, 0.03461826f, 0.01972110f, -0.30935577f, 0.01619839f, 0.19230540f, 
    -0.07293546f, 0.08212341f, 0.09117257f, 0.07094360f, -0.08653235f, 0.00284052f, 0.05666528f, 0.01436689f, 
    0.13682064f, 0.19802916f, -0.03063877f, -0.16795819f, 0.05631298f, 0.05278431f, 0.10430733f, 0.00788343f, 
    -0.00684081f, -0.06231410f, 0.03234213f, -0.12957299f, -0.06684543f, 0.00663812f, 0.03035150f, -0.13406368f, 
    -0.00048774f, -0.05544463f, 0.02077016f, -0.11537009f, -0.04381953f, -0.04393066f, -0.00139913f, -0.08381211f, 
    0.00437977f, 0.25014395f, -0.32551864f, -0.33634496f, 0.06648953f, -0.07631363f, 0.05656587f, 0.00375045f, 
    -0.00613994f, -0.01108511f, 0.13022777f, 0.01432367f, 0.10635682f, 0.06467584f, 0.03017141f, 0.05396342f, 
    0.07540985f, 0.12143140f, -0.06183178f, 0.03309894f, 0.06066857f, 0.11812865f, 0.02822651f, 0.00162371f, 
    -0.14230430f, -0.09134565f, -0.09444209f, -0.02600706f, 0.06440819f, 0.12252107f, -0.04923540f, 0.12563518f, 
    0.17961630f, -0.04229856f, -0.10445924f, 0.00182826f, 0.03281328f, 0.04080466f, 0.00672047f, -0.09452662f, 
    -0.05859862f, 0.00973849f, -0.08804711f, -0.00950271f, 0.02400504f, 0.00630061f, -0.03330928f, -0.06620639f, 
    0.09042855f, -0.03856872f, 0.07487699f, 0.07642999f, 0.08067951f, 0.03314693f, 0.01433188f, 0.03375882f, 
    -0.00159403f, -0.04853711f, -0.05809976f, -0.13867167f, -0.15524861f, 0.02886454f, -0.05621091f, -0.06412778f, 
    0.09856463f, -0.00715838f, 0.00403605f, 0.01145225f, -0.09277212f, -0.00284608f, 0.02506945f, -0.09372552f, 
    -0.03923310f, 0.11425756f, -0.00479368f, -0.19048603f, 0.00183232f, 0.02160153f, -0.20665036f, -0.10838973f, 
    0.15081793f, 0.03471664f, -0.11310979f, -0.03873287f, 0.00980692f, 0.26424915f, 0.26661101f, 0.10120686f, 
    -0.09490157f, -0.08785819f, -0.01606298f, -0.00613212f, -0.11027402f, -0.15939902f, 0.06377918f, -0.11691936f, 
    -0.11594497f, 0.19177720f, 0.04348012f, -0.03487449f, 0.05682262f, -0.04107302f, 0.00918215f, -0.14832503f, 
    0.04947203f, 0.19246340f, -0.12098239f, -0.00236061f, -0.06962904f, -0.02927012f, -0.12649621f, 0.14521085f, 
    0.00350823f, 0.03282741f, 0.02362296f, 0.03486614f, 0.05522048f, -0.03581579f, 0.02199744f, -0.10186398f, 
    -0.07802786f, -0.07681461f, -0.00871041f, -0.31145793f, -0.03186981f, 0.02957419f, -0.05944071f, 0.06100257f, 
    0.03789978f, -0.02961868f, 0.02487798f, 0.02414759f, -0.04496009f, -0.00606194f, 0.08837669f, 0.06012157f, 
    0.00375189f, -0.04784705f, 0.07753583f, -0.00184202f, -0.01484967f, -0.02317514f, -0.04148089f, -0.09054709f, 
    -0.08863642f, -0.08759622f, 0.15623258f, 0.40351170f, -0.21302690f, -0.04553154f, 0.11775669f, -0.04822736f, 
    0.00840018f, -0.04557877f, 0.05254881f, 0.21863116f, 0.07169919f, -0.06122905f, 0.10159332f, 0.00847253f, 
    0.04691849f, -0.05102234f, 0.08125356f, 0.00603833f, -0.06882927f, 0.07025443f, 0.06096141f, 0.17332532f, 
    0.06058076f, -0.13619493f, -0.13788092f, -0.05588961f, 0.08375894f, 0.16245933f, -0.18740036f, -0.18291935f, 
    0.02042912f, -0.12325968f, 0.11580574f, 0.00662022f, 0.05685027f, 0.12100838f, 0.09508827f, 0.15216729f, 
    -0.12396987f, -0.13207392f, -0.02304795f, 0.04300628f, -0.19241808f, 0.00098207f, 0.08365279f, 0.22390322f, 
    -0.29078862f, -0.22244550f, 0.16606773f, 0.25804701f, 0.06209615f, 0.01372727f, -0.09952782f, -0.09281059f, 
    0.06723757f, 0.05097136f, 0.07189572f, -0.05582026f, -0.26402706f, 0.03401553f, 0.04200672f, -0.24795671f, 
    0.14110352f, 0.05067457f, 0.07365105f, 0.04949231f, -0.04769286f, 0.09908193f, -0.16432507f, 0.08634111f, 
    -0.01460677f, -0.10346636f, -0.03929509f, 0.23785150f, 0.00790928f, 0.13691075f, 0.00554914f, 0.07909945f, 
    0.04309295f, 0.06983744f, -0.01072276f, 0.14276753f, -0.06143936f, -0.03485429f, 0.03281408f, 0.01702734f, 
    0.04772548f, 0.00361754f, -0.04315994f, 0.04641584f, 0.04416957f, -0.00639958f, 0.15802191f, 0.06651650f, 
    -0.15208626f, -0.07972030f, -0.33650488f, -0.01905954f, 0.07654884f, 0.02066437f, 0.01090482f, 0.02516674f, 
    0.01554395f, -0.07128135f, 0.05858964f, -0.02564365f, 0.00227050f, -0.04609364f, 0.06267503f, 0.00971413f, 
    -0.07332309f, -0.00609712f, 0.10053992f, 0.03584730f, -0.07326656f, 0.01616567f, -0.06326213f, 0.05755391f, 
    -0.10026561f, -0.04500248f, -0.06525772f, -0.18247317f, 0.14474483f, 0.04152771f, 0.04988672f, 0.11174444f, 
    0.14430623f, 0.05666125f, -0.00550271f, -0.06949189f, -0.15778656f, -0.05309031f, -0.14718908f, 0.01541993f, 
    -0.09227780f, -0.00276184f, 0.01389744f, 0.02877795f, 0.12483661f, 0.05190475f, 0.08777746f, -0.02334460f, 
    0.07907356f, 0.04811378f, 0.22845979f, -0.47275126f, 0.11459806f, -0.14378925f, -0.09532595f, 0.05561889f, 
    0.03485416f, 0.00201504f, -0.11594634f, -0.11846371f, -0.31621337f, -0.22754116f, 0.19621825f, 0.24637792f, 
    -0.08165685f, -0.00218259f, -0.02918507f, 0.06424978f, -0.05933369f, 0.04413813f, 0.05057994f, 0.14316536f, 
    -0.10518087f, -0.08334638f, 0.04452280f, 0.06520210f, 0.04752661f, -0.01677032f, -0.03029012f, 0.03689827f, 
    0.03754803f, -0.00143684f, 0.06705504f, 0.02624084f, 0.21334673f, -0.03665973f, 0.04992185f, 0.09812314f, 
    -0.01401506f, 0.08496301f, -0.01048172f, 0.11404749f, 0.13434054f, -0.03656015f, 0.08993404f, 0.03818203f, 
    -0.02024001f, -0.07714804f, 0.04404137f, -0.00738957f, 0.12526330f, -0.17116418f, 0.01497545f, -0.13818449f, 
    0.02802875f, -0.11174800f, -0.08702609f, 0.02070503f, -0.16573137f, -0.09621210f, -0.22696817f, 0.15082110f, 
    0.11718498f, 0.05393634f, 0.01453332f, -0.13799681f, 0.03904990f, 0.00470445f, 0.01814400f, 0.10631679f, 
    -0.42166400f, -0.09843445f, -0.23703875f, -0.05057688f, 0.07063137f, 0.08467288f, 0.01795980f, 0.07912233f, 
    0.07310418f, 0.06401891f, -0.03287122f, 0.04531461f, -0.02670527f, 0.09413321f, -0.09531233f, 0.03042589f, 
    0.03477687f, -0.11106325f, 0.03553897f, 0.21071139f, 0.05183363f, -0.09835785f, -0.06390667f, 0.01815345f, 
    0.25392729f, 0.07737004f, -0.07361147f, -0.01186946f, 0.03177823f, 0.04380447f, 0.07059213f, -0.02778058f, 
    0.04050717f, -0.07317785f, -0.02375845f, 0.14826128f, 0.27913219f, -0.02276535f, -0.01303563f, 0.02420881f, 
    0.16462699f, -0.09097629f, -0.12464441f, -0.09176712f, -0.22147182f, 0.06862200f, -0.11789981f, -0.03700453f, 
    -0.01496470f, -0.07005107f, 0.04478827f, -0.04767468f, -0.02856630f, -0.01161546f, -0.07407086f, 0.05358059f, 
    -0.03800317f, 0.02201607f, 0.05044887f, 0.02071638f, -0.07543109f, -0.22337590f, -0.18423277f, 0.12802579f, 
    0.06123667f, 0.13019715f, -0.07782313f, 0.01247205f, -0.07819533f, -0.06846391f, 0.03578170f, -0.07685458f, 
    0.02515737f, 0.13963954f, 0.00211448f, -0.13414966f, 0.08627801f, -0.01026989f, -0.00164932f, -0.02431344f, 
    -0.06120802f, 0.08824534f, 0.17559466f, 0.07857727f, -0.00209619f, 0.08985058f, 0.20536546f, 0.01024234f, 
    -0.01155843f, 0.07691157f, 0.11570685f, 0.06228913f, -0.08953654f, -0.20372443f, 0.16951719f, 0.15288649f, 
    0.12499760f, 0.00045273f, -0.01872676f, -0.07167926f, 0.04578898f, -0.07621497f, -0.00308578f, -0.19565754f, 
    -0.09965995f, -0.03515975f, -0.15247357f, 0.00720225f, -0.16977501f, -0.34024173f, -0.06704660f, -0.03516874f, 
    -0.01400010f, -0.10376745f, -0.01684179f, -0.03671898f, 0.06515381f, -0.00507903f, 0.10653695f, 0.12686683f, 
    -0.11823291f, -0.34188125f, -0.15036875f, 0.07629892f, 0.07442373f, -0.02382099f, -0.08072328f, 0.06116396f, 
    0.15043938f, -0.02805652f, 0.19919795f, 0.01040449f, 0.13077079f, -0.19699328f, -0.03684092f, -0.03817068f, 
    0.01235968f, -0.06570780f, 0.04893196f, -0.06287600f, -0.08330195f, -0.18757419f, -0.10544030f, -0.05485440f, 
    -0.05113000f, 0.03375719f, 0.03493273f, 0.01407901f, -0.09310345f, -0.11648379f, 0.09086002f, 0.08283295f, 
    0.02645152f, 0.04088295f, 0.05822128f, 0.00271220f, -0.61249942f, -0.18439499f, -0.21410948f, -0.04065345f, 
    0.05198341f, 0.06524825f, -0.12955377f, -0.00927372f, 0.05855610f, 0.11129366f, 0.11935319f, 0.06214611f, 
    -0.10085474f, 0.12498623f, 0.04943834f, 0.01327009f, 0.01846567f, -0.01342292f, 0.01481632f, 0.21671665f, 
    0.01211078f, 0.09829288f, 0.13267256f, -0.04709547f, 0.01345162f, 0.05866289f, 0.18945445f, 0.06914037f, 
    0.00887905f, 0.04324364f, -0.07536220f, -0.01648051f, 0.17921895f, 0.18357597f, -0.10027146f, -0.00135409f, 
    0.10629202f, 0.02226292f, -0.00230239f, -0.17059007f, -0.05099097f, 0.05973351f, 0.05710062f, 0.01945213f, 
    0.03330941f, -0.10984316f, 0.03344643f, 0.11066468f, -0.35645360f, -0.04012278f, -0.15289854f, -0.03702519f, 
    0.09451525f, -0.00013276f, 0.08923902f, -0.02583411f, 0.12363841f, -0.08283465f, 0.12743276f, -0.09727341f, 
    0.30197728f, -0.13940254f, -0.34402746f, -0.04757484f, -0.01778457f, 0.10584312f, -0.08430642f, -0.05591862f, 
    0.01716575f, -0.04161437f, -0.17367600f, -0.07830139f, -0.04207283f, 0.00300123f, 0.21153444f, 0.10598066f, 
    0.10214335f, 0.05531598f, 0.00335116f, -0.03693357f, 0.03239715f, 0.00634192f, -0.11546592f, 0.12132384f, 
    -0.05231344f, 0.07383248f, -0.01468581f, -0.01167128f, -0.07306504f, 0.02257360f, -0.06591168f, -0.14511541f, 
    -0.08717079f, -0.05075885f, -0.02252678f, 0.05832292f, -0.19271128f, -0.06295954f, -0.10546776f, 0.11762153f, 
    0.03885397f, 0.10704450f, 0.21137965f, -0.17556328f, -0.09658866f, 0.11432583f, -0.09464953f, -0.05539791f, 
    -0.26328504f, 0.06833348f, 0.05132354f, -0.26839364f, -0.08577088f, 0.08015148f, 0.03737724f, 0.09219933f, 
    0.02753131f, -0.10283706f, -0.00444260f, 0.00977152f, 0.03105108f, 0.04547135f, 0.17472421f, -0.04051431f, 
    -0.07737067f, 0.01967745f, 0.01884461f, -0.09044475f, 0.19026247f, -0.01399454f, -0.14278325f, 0.06476860f, 
    -0.39191735f, 0.22434676f, -0.08611170f, -0.19718061f, 0.03015827f, 0.00506187f, 0.00145271f, 0.08355768f, 
    -0.17028293f, -0.03968292f, 0.03460471f, -0.22124244f, -0.13391897f, -0.01576773f, -0.05663602f, -0.18054609f, 
    0.05035571f, 0.02635520f, -0.12832473f, 0.02623151f, 0.09975047f, -0.18192188f, -0.00925905f, -0.28373882f, 
    -0.14531340f, 0.08470082f, -0.00157426f, -0.07000630f, -0.01458460f, -0.07442940f, 0.00483734f, 0.05245493f, 
    -0.07580722f, -0.04745899f, -0.00871758f, 0.07345172f, -0.11250007f, 0.03297894f, -0.04145904f, -0.21497121f, 
    0.02631754f, -0.01702630f, 0.05715658f, -0.13817738f, 0.10396448f, 0.12761220f, -0.00651774f, 0.14793631f, 
    0.05022174f, 0.05796910f, 0.09213722f, 0.18732144f, 0.01045399f, -0.11648540f, 0.05641935f, 0.04120545f, 
    -0.00341324f, -0.07074752f, 0.01541911f, -0.05991092f, -0.02851416f, 0.02019507f, -0.04935546f, 0.04916202f, 
    -0.07048713f, -0.06958394f, -0.12167756f, 0.03659662f, 0.10284141f, -0.04198448f, -0.04067075f, 0.10767771f, 
    -0.04818122f, 0.02851010f, 0.02784344f, -0.10337411f, -0.04188672f, 0.03178292f, 0.06688554f, -0.04544036f, 
    0.01962671f, 0.09602351f, 0.16330971f, 0.16507296f, 0.17654261f, 0.07094905f, -0.02042911f, -0.04532074f, 
    -0.16935058f, 0.00437666f, -0.30273062f, -0.08558252f, -0.09784041f, -0.05103403f, 0.01221339f, -0.03305956f, 
    -0.13258620f, 0.28695253f, 0.08313254f, -0.14048247f, -0.04112970f, 0.10277825f, -0.05484003f, -0.06397937f, 
    -0.00592256f, 0.03650795f, 0.13314734f, -0.03537904f, 0.25200203f, 0.16356255f, -0.01336811f, 0.02695087f, 
    -0.06858293f, -0.14254615f, 0.01331966f, -0.13792248f, -0.09764574f, 0.02740590f, -0.02455248f, -0.08348180f, 
    -0.40678570f, -0.21876179f, 0.23664998f, -0.01149803f, 0.07261515f, 0.04581687f, 0.03396963f, -0.05949495f, 
    -0.00994920f, 0.03801108f, -0.01785123f, 0.07956787f, -0.10867440f, -0.06531945f, -0.13901594f, -0.18831301f, 
    0.11753346f, 0.02338623f, -0.02809345f, -0.03342127f, 0.05155477f, 0.02518216f, 0.00063778f, 0.04457154f, 
    -0.11446512f, -0.08989806f, -0.25387362f, -0.42900494f, 0.00482102f, 0.02655711f, -0.15211986f, -0.10223557f, 
    0.07858940f, -0.03519630f, 0.07182015f, -0.02752344f, -0.08264833f, 0.11631823f, 0.12852705f, -0.05055587f, 
    0.04997909f, -0.04534451f, 0.03288629f, 0.01336334f, -0.09954841f, -0.04317243f, 0.09889390f, 0.14693792f, 
    -0.11793920f, 0.00135386f, -0.07657076f, 0.19528762f, 0.11310244f, -0.02396548f, -0.00271627f, 0.02866234f, 
    -0.01999534f, -0.04899472f, 0.09224269f, 0.11562435f, 0.04743031f, 0.08249043f, 0.02942155f, 0.00657302f, 
    0.02652899f, 0.06398249f, -0.07715310f, -0.00523970f, 0.10095165f, 0.09954400f, -0.01998350f, -0.13026300f, 
    -0.22374552f, -0.26703376f, 0.02766381f, -0.10785103f, -0.06172397f, 0.00544606f, 0.03339142f, 0.13184936f, 
    -0.02122010f, 0.01877334f, 0.04642110f, 0.07113178f, 0.31991318f, -0.04225465f, 0.40473008f, 0.22487059f, 
    0.03576968f, -0.11689028f, 0.04671818f, -0.05569986f, 0.09424420f, -0.00614524f, -0.08471657f, 0.11492259f, 
    0.16574457f, -0.01663450f, 0.13822725f, -0.28746295f, -0.13755092f, -0.05409185f, -0.02983322f, 0.15895449f, 
    -0.10442985f, -0.04893286f, -0.03059744f, 0.02845280f, 0.23711519f, -0.10957520f, -0.08966438f, -0.11388438f, 
    0.01381974f, 0.04559841f, -0.08248939f, -0.05552716f, -0.07766665f, 0.03118186f, -0.09434907f, 0.10145687f, 
    0.11126135f, 0.33366930f, 0.11628325f, -0.27775297f, -0.09955909f, 0.12633459f, 0.08096845f, 0.06885507f, 
    -0.14281915f, 0.01254787f, 0.06970827f, 0.02836152f, 0.20199634f, -0.10058059f, 0.00905276f, -0.00124914f, 
    -0.04308023f, -0.04528872f, 0.06640766f, 0.13450506f, 0.10295254f, -0.02694286f, 0.01270829f, 0.11818209f, 
    -0.01019553f, 0.03282071f, -0.09276579f, -0.10385395f, 0.09582454f, -0.02401020f, -0.03669912f, 0.01707016f, 
    0.02194320f, 0.04949817f, -0.05211396f, -0.16263588f, -0.02248253f, 0.27070615f, 0.07854360f, -0.20770413f, 
    -0.07848097f, 0.10126465f, 0.01683853f, 0.03517342f, 0.03814559f, -0.08705732f, -0.05991483f, -0.04432367f, 
    -0.09223008f, -0.13132350f, -0.42404634f, 0.10830151f, -0.15426216f, -0.07539169f, 0.09624830f, 0.01791946f, 
    0.01313312f, 0.02856928f, -0.08273329f, 0.06372049f, -0.04609711f, -0.15154220f, -0.05865048f, 0.01485591f, 
    0.04061669f, 0.13871707f, -0.07555208f, 0.00611292f, -0.03124720f, -0.10065684f, -0.16348805f, -0.11944910f, 
    0.31561583f, -0.14467101f, -0.01988660f, 0.16421391f, 0.03814890f, -0.00964653f, 0.06547687f, 0.02434028f, 
    -0.15127222f, -0.04058650f, -0.11039353f, -0.12022559f, 0.50747907f, 0.11491020f, -0.02996814f, 0.03966198f, 
    -0.01932742f, 0.02476633f, -0.02519272f, 0.01126450f, -0.05105407f, -0.05798365f, 0.08308176f, -0.05449687f, 
    0.00035501f, 0.13366844f, -0.03868490f, -0.20908119f, -0.06113925f, 0.04641530f, -0.06362151f, -0.03552634f, 
    -0.00714093f, 0.00172677f, 0.04359970f, -0.04156936f, -0.06109769f, 0.22889982f, 0.04710096f, 0.03736348f, 
    -0.11556384f, 0.10625473f, -0.00275323f, 0.02906453f, 0.04641682f, 0.09413193f, -0.11444791f, -0.11925612f, 
    -0.14889444f, -0.27228776f, -0.04187826f, -0.09428788f, -0.02075485f, -0.02643373f, 0.04210226f, -0.07549126f, 
    0.00853823f, -0.06045920f, 0.03971546f, 0.11312448f, -0.25569400f, 0.01310451f, -0.05345387f, 0.17646244f, 
    0.12308968f, -0.01913210f, -0.01700410f, -0.00395923f, 0.03895831f, -0.13170753f, 0.05451237f, -0.13780318f, 
    -0.10764618f, -0.17426634f, 0.13973641f, -0.14915997f, -0.02365458f, 0.01580258f, 0.10357012f, -0.09909863f, 
    -0.05216220f, -0.02824878f, -0.00319465f, -0.06051139f, -0.00116844f, -0.12489124f, -0.08504067f, -0.16009030f, 
    0.02393513f, -0.00451352f, 0.00055491f, -0.03368109f, 0.04358421f, -0.01745898f, -0.03202303f, -0.06805459f, 
    0.02536668f, 0.04383688f, 0.09232122f, -0.18441351f, -0.15593830f, 0.06539892f, 0.14848284f, 0.02188992f, 
    -0.14237748f, -0.01417074f, 0.02853911f, 0.02816477f, 0.29648408f, -0.08669960f, -0.06552871f, 0.08125060f, 
    -0.05381317f, 0.10089248f, -0.07703029f, -0.10857444f, -0.05687681f, -0.15387700f, -0.04471035f, 0.15696362f, 
    -0.11045603f, -0.01724039f, -0.14521560f, 0.02418097f, -0.05499033f, 0.00585487f, -0.04604010f, 0.00265840f, 
    -0.10152119f, 0.04396043f, 0.05300298f, -0.02190833f, -0.07238199f, -0.05889997f, -0.06149608f, -0.05627105f, 
    0.10751124f, -0.04879854f, 0.08200319f, -0.07370639f, -0.10894538f, 0.09123643f, -0.16509099f, 0.07193142f, 
    0.01433835f, -0.08357955f, -0.11691301f, 0.12945122f, -0.13518605f, 0.05575325f, 0.08031273f, 0.00315890f, 
    -0.02626145f, 0.09908921f, 0.06916109f, 0.11509421f, -0.18268079f, -0.00101537f, -0.07466757f, -0.03022826f, 
    -0.21061802f, -0.03662161f, -0.10278367f, -0.12447724f, -0.22712220f, 0.09234085f, 0.07743105f, -0.21790877f, 
    -0.00707245f, -0.05887895f, -0.08496827f, -0.25722802f, -0.03030678f, 0.02371625f, 0.04783751f, -0.27637866f, 
    -0.06975439f, -0.04575985f, 0.08562651f, 0.00451859f, -0.18647484f, -0.10846251f, 0.15002334f, 0.10047392f, 
    0.05691034f, -0.05807488f, 0.09278680f, 0.06043780f, -0.03973054f, -0.01947621f, -0.12560055f, -0.07114426f, 
    -0.33218005f, 0.08597188f, -0.01630107f, 0.33696526f, 0.04269970f, 0.05886360f, -0.03539494f, 0.03310030f, 
    0.09101536f, 0.08635860f, 0.03161321f, -0.18880227f, -0.17527406f, 0.05854760f, -0.13301890f, 0.12411866f, 
    -0.08947422f, 0.06743185f, 0.05297159f, -0.00017744f, 0.06967425f, -0.04275795f, 0.15706544f, 0.02070278f, 
    -0.01026451f, -0.04865404f, -0.01783477f, 0.06765465f, -0.06960216f, 0.07719792f, 0.04018074f, 0.11885104f, 
    0.14144170f, -0.10486671f, -0.01497878f, 0.02908427f, -0.04791310f, 0.04209803f, 0.14522362f, -0.28592023f, 
    -0.00249578f, -0.01214537f, 0.03477985f, -0.12967338f, -0.03581894f, 0.05687045f, -0.02830271f, 0.14916018f, 
    0.18326321f, -0.00978481f, 0.00467264f, -0.04548471f, -0.05628502f, 0.00497194f, 0.11508448f, 0.00677972f, 
    0.06947702f, -0.02701971f, 0.02741149f, -0.12759027f, 0.30981579f, -0.02144757f, -0.07539152f, -0.20495269f, 
    -0.10682400f, 0.06676450f, 0.01640764f, 0.05786342f, 0.08826447f, 0.08919305f, -0.17681903f, -0.11964830f, 
    -0.08075548f, -0.00329709f, -0.12339648f, 0.04768660f, -0.16015968f, 0.01507124f, 0.03428235f, 0.12108633f, 
    0.00314426f, 0.06828613f, 0.14288020f, 0.02412361f, -0.05681052f, 0.15480451f, -0.12840508f, -0.22520311f, 
    -0.00513150f, 0.04614814f, 0.08212763f, -0.06634075f, 0.07976344f, -0.11729445f, 0.09305687f, 0.00164918f, 
    -0.21196581f, -0.12894727f, 0.00357099f, 0.02388009f, 0.02948104f, 0.08071084f, 0.05249860f, 0.04890810f, 
    -0.04785926f, -0.09852692f, -0.15145434f, -0.00827494f, -0.55764759f, 0.16378379f, -0.14284435f, 0.23137097f, 
    0.07624754f, -0.05575605f, 0.06405823f, 0.09394121f, -0.03890075f, 0.22365449f, 0.10415866f, 0.15632167f, 
    -0.15125707f, -0.12130926f, -0.27668327f, 0.04783359f, 0.05361148f, 0.01933854f, -0.17315184f, 0.09514754f, 
    0.08228821f, -0.03873074f, 0.03588462f, 0.03342874f, -0.09522429f, -0.10058071f, -0.03817728f, -0.11752263f, 
    0.01093797f, 0.03489117f, 0.06096533f, -0.00984874f, -0.05338952f, -0.01695291f, 0.03425252f, 0.10790020f, 
    0.09916008f, 0.03457547f, -0.13682498f, -0.16997752f, -0.00030692f, 0.01636479f, 0.15361035f, -0.09259018f, 
    -0.13665836f, -0.04665691f, -0.10648685f, -0.05951711f, -0.10948736f, -0.06734968f, 0.03150206f, 0.21963990f, 
    0.16496463f, -0.06272232f, -0.10277613f, -0.14891694f, -0.02283576f, -0.05354169f, -0.09399366f, 0.01808798f, 
    0.03010115f, 0.00544160f, 0.06240878f, -0.09548970f, 0.10616750f, -0.03654420f, 0.08056822f, 0.01051441f, 
    -0.03318398f, 0.06354450f, -0.14387876f, 0.12000804f, 0.14014170f, -0.04997727f, -0.01942181f, 0.01997201f, 
    -0.07497398f, -0.01916687f, -0.07917698f, -0.05651819f, -0.01675246f, 0.06262834f, -0.01741154f, -0.03953645f, 
    -0.09961259f, 0.03286538f, -0.09836819f, 0.11547629f, -0.07375450f, 0.04515570f, 0.01075331f, -0.03101153f, 
    -0.05837100f, 0.12715779f, 0.05245921f, 0.06164084f, 0.00480635f, 0.15564926f, 0.00159658f, -0.15452616f, 
    -0.08505359f, -0.04812095f, 0.08295389f, 0.05020596f, 0.02746717f, -0.02859063f, 0.10348009f, -0.08257901f, 
    0.02685779f, 0.21015926f, 0.10087027f, -0.18067831f, 0.04493469f, 0.10798509f, -0.01058159f, 0.01091540f, 
    -0.02744005f, -0.00146499f, -0.02865577f, -0.07400095f, 0.01657085f, -0.20673943f, 0.03867157f, -0.14386368f, 
    0.08128197f, 0.02165894f, -0.01063173f, -0.01161241f, 0.06676289f, -0.13732146f, -0.00512114f, 0.00373011f, 
    0.30244210f, -0.15788680f, 0.05422679f, -0.06853691f, -0.01667357f, -0.04725772f, 0.08287960f, -0.02578621f, 
    0.03501291f, 0.00573985f, 0.13918898f, 0.01916864f, -0.19099048f, 0.01828843f, 0.12314783f, -0.09932683f, 
    -0.00653885f, -0.03853344f, 0.02430046f, 0.05593146f, -0.09386115f, 0.00729669f, 0.05650885f, -0.03514276f, 
    0.31191656f, -0.40081593f, 0.09832701f, -0.15675460f, -0.05588408f, 0.08842660f, 0.11595718f, -0.03088696f, 
    0.03879066f, 0.04448257f, 0.13557732f, 0.05797890f, -0.10057417f, -0.46618342f, 0.08338978f, -0.20794815f, 
    0.00685853f, -0.03188590f, 0.19695552f, -0.04811089f, -0.02569514f, 0.04698924f, -0.03662116f, 0.20815602f, 
    0.05271127f, -0.16859089f, -0.23424891f, 0.07308554f, 0.00459389f, 0.12413307f, -0.00833514f, -0.13034618f, 
    0.08432419f, -0.02391629f, -0.13338797f, 0.00031106f, -0.00526623f, 0.10592637f, -0.08695967f, -0.13046157f, 
    0.03213322f, -0.04851574f, 0.01312139f, -0.03850788f, -0.03314472f, -0.12576717f, 0.00824823f, -0.16643785f, 
    -0.06705280f, 0.00141907f, -0.07069033f, -0.06705455f, 0.04749671f, 0.00897953f, -0.15295176f, 0.05615324f, 
    0.00933735f, 0.00113163f, -0.04985758f, 0.09782390f, -0.00504058f, -0.05179964f, -0.04471670f, -0.01839505f, 
    0.01592315f, 0.00338151f, 0.06251104f, -0.04283762f, -0.02975845f, 0.05127671f, 0.19652262f, -0.12618124f, 
    0.12131298f, 0.10648698f, 0.18472636f, -0.39011145f, -0.04694049f, 0.03374052f, 0.00840369f, -0.00227827f, 
    -0.05091693f, -0.00523769f, -0.20944709f, -0.10550708f, -0.51987064f, -0.03311994f, -0.13320673f, 0.10551433f, 
    0.11973221f, -0.09224979f, 0.09112923f, 0.01656227f, 0.14999542f, -0.00224696f, 0.03034474f, 0.05518986f, 
    0.19681016f, -0.05388514f, 0.04230620f, 0.35195822f, -0.08224901f, -0.10476251f, 0.02999317f, 0.07190432f, 
    0.05211833f, -0.03681193f, -0.03641874f, -0.03325472f, -0.37775895f, 0.04284078f, 0.17421003f, 0.13610592f, 
    0.04320460f, 0.19659601f, 0.08581124f, 0.08133219f, -0.04383403f, 0.09636616f, -0.05534552f, 0.08722781f, 
    0.20170029f, -0.40758154f, -0.08217969f, 0.18574242f, -0.08133312f, 0.04246030f, -0.00128735f, 0.07656053f, 
    0.07873487f, 0.01052205f, -0.07915930f, -0.08131102f, 0.08391406f, 0.03732309f, 0.06246745f, -0.01295878f, 
    0.07029954f, 0.13302527f, 0.05404839f, 0.04782538f, 0.00474688f, 0.06127795f, -0.04099077f, -0.01249224f, 
    0.03317177f, 0.13079822f, 0.11100999f, 0.09032360f, 0.06046373f, -0.00506779f, 0.04686679f, -0.05297543f, 
    -0.00045475f, 0.00567642f, -0.08657494f, -0.13964868f, -0.07825352f, -0.10179063f, -0.08185077f, -0.18195522f, 
    0.03472511f, 0.00988503f, -0.09968543f, -0.05339707f, -0.01771751f, -0.01882786f, -0.11407792f, -0.03807076f, 
    -0.02616488f, 0.04003036f, -0.01398412f, 0.06027973f, -0.01701032f, -0.09638502f, 0.00198604f, -0.04541360f, 
    -0.03672812f, -0.08689323f, 0.02251120f, -0.04955677f, -0.13205601f, 0.08567116f, -0.03697720f, -0.07985210f, 
    -0.12268303f, 0.04583703f, -0.06060649f, 0.05658387f, -0.05705546f, -0.03214881f, -0.03228113f, -0.11324980f, 
    0.01314231f, 0.06005665f, -0.00456975f, -0.03201405f, -0.06803058f, 0.02320996f, 0.00581336f, -0.14066294f, 
    -0.02624535f, 0.07968794f, -0.03123069f, -0.08767760f, -0.17213726f, -0.09578701f, 0.03105476f, 0.11847462f, 
    -0.02294764f, -0.10313972f, 0.01797649f, 0.04453195f, -0.12705182f, 0.03594949f, 0.04171396f, 0.01416827f, 
    0.01598981f, -0.04094267f, 0.01609616f, -0.09666473f, -0.13806033f, -0.03285948f, 0.05270815f, -0.00208921f, 
    -0.01840682f, -0.02856140f, 0.01156415f, -0.05288002f, 0.09367541f, 0.10998205f, -0.03311467f, 0.13623244f, 
    -0.10260317f, 0.02093870f, 0.02744387f, 0.05263028f, 0.00518593f, 0.02823207f, -0.05083985f, 0.03109528f, 
    -0.17315136f, 0.07801835f, -0.08541869f, -0.09559470f, -0.03721606f, 0.00392025f, -0.00206005f, -0.05305425f, 
    -0.00931640f, -0.08807869f, 0.06711891f, -0.09744646f, 0.19018514f, -0.38212207f, 0.04583678f, 0.12202799f, 
    -0.05020862f, 0.00386216f, -0.06696972f, -0.12478252f, -0.00274485f, -0.02859065f, -0.02295164f, -0.08989200f, 
    -0.11666294f, -0.10640734f, 0.10616252f, 0.10365671f, 0.02599062f, -0.05718680f, -0.05743548f, -0.02878510f, 
    -0.01979949f, -0.00192424f, -0.09059799f, -0.10215507f, -0.34763044f, -0.04550029f, -0.13611655f, -0.12563996f, 
    -0.03675861f, -0.00449926f, -0.03437046f, -0.04249435f, -0.09531613f, 0.03251508f, 0.03953053f, -0.15454054f, 
    0.02897967f, 0.19195773f, 0.08296914f, 0.25022441f, 0.18861324f, 0.04129969f, 0.10729305f, -0.03026693f, 
    -0.00056498f, 0.00649127f, -0.02708802f, -0.04202344f, 0.19684364f, -0.11790277f, 0.01794125f, 0.11398561f, 
    -0.08648156f, -0.05414575f, -0.11525252f, -0.05431240f, -0.02840861f, -0.00173482f, 0.02542169f, -0.06661942f, 
    0.10376310f, 0.01771206f, 0.04140037f, 0.02015530f, 0.09705970f, 0.00069526f, 0.00612567f, 0.01259554f, 
    -0.05802278f, 0.00895144f, -0.01407754f, 0.02218916f, 0.09524948f, -0.31041607f, 0.06185037f, -0.04887156f, 
    -0.09690072f, 0.05490860f, -0.07548414f, 0.03279160f, -0.09727234f, 0.04019888f, -0.04471815f, 0.06348833f, 
    -0.29519406f, 0.07151721f, -0.19254844f, -0.06934938f, -0.06288419f, -0.03669457f, -0.00665880f, -0.04969577f, 
    -0.06465692f, 0.02870981f, -0.03015401f, -0.00760903f, -0.04264420f, -0.08166010f, -0.10444799f, -0.16104500f, 
    -0.02410629f, 0.06579548f, -0.05256938f, 0.00968110f, -0.07116133f, -0.01827003f, 0.01774881f, -0.00074728f, 
    0.17168866f, 0.05149901f, 0.17816488f, 0.09141866f, 0.10989422f, 0.08676536f, -0.00911761f, -0.11276530f, 
    -0.01612339f, 0.02178485f, -0.02641113f, -0.02983340f, -0.11194655f, -0.06086547f, -0.09543037f, 0.09098733f, 
    0.00012550f, 0.02683519f, 0.00136321f, -0.03029921f, 0.00106226f, -0.05954274f, 0.00619621f, -0.02141100f, 
    0.26358336f, -0.26668155f, 0.10729433f, -0.08175090f, -0.02581580f, 0.04814863f, 0.00962156f, -0.04345720f, 
    -0.01274288f, 0.10811736f, -0.05568753f, 0.01366603f, 0.04690653f, 0.07926553f, -0.02940555f, 0.02833221f, 
    -0.12013113f, 0.06350406f, 0.05768098f, -0.06360300f, -0.03628603f, -0.01281803f, -0.07413177f, -0.06641508f, 
    -0.00928175f, 0.07118569f, -0.04970024f, -0.13111322f, 0.02676895f, -0.02472824f, -0.00106317f, -0.07258938f, 
    -0.06515678f, -0.11757979f, -0.06285981f, -0.00316052f, 0.15998185f, 0.15158141f, 0.03660334f, 0.17973913f, 
    0.04946787f, -0.06346982f, -0.01528429f, -0.01093998f, -0.00207269f, -0.02310168f, -0.05560165f, 0.02365009f, 
    0.13807599f, 0.07532167f, 0.14230882f, 0.09157795f, -0.02448049f, -0.05856596f, -0.10492296f, -0.06373722f, 
    0.02753538f, -0.05103193f, -0.01221107f, -0.02589500f, 0.12632424f, -0.22551332f, 0.12155697f, 0.02658449f, 
    0.02033794f, -0.05734402f, -0.05378957f, -0.09926769f, 0.03908086f, 0.04491804f, -0.01466825f, 0.01666156f, 
    -0.12492362f, 0.10598829f, -0.04307971f, -0.04162989f, 0.04759170f, 0.08435766f, 0.08622718f, -0.01547088f, 
    0.07047024f, -0.00752894f, 0.00599516f, -0.02273619f, 0.03839514f, 0.16021140f, 0.10016852f, 0.21913829f, 
    0.18022648f, 0.11010244f, 0.07728288f, -0.00170492f, 0.03455523f, 0.04129231f, 0.03420361f, -0.11991058f, 
    0.08258409f, 0.15875117f, 0.19572906f, 0.11828849f, 0.03523635f, 0.01995098f, 0.02572223f, -0.00896256f, 
    -0.06164818f, -0.00701426f, 0.00463613f, -0.03371113f, 0.19425741f, -0.06633313f, -0.01371261f, 0.14678586f, 
    0.03430637f, -0.03115052f, -0.02869123f, -0.05341969f, -0.08037847f, 0.03473003f, 0.01556441f, -0.07859521f, 
    -0.12878695f, -0.03298660f, -0.14359216f, -0.16935259f, 0.02041264f, 0.01545833f, -0.01681887f, 0.04197703f, 
    0.01221653f, 0.03340644f, -0.03888744f, -0.05321677f, 0.16901708f, 0.15715335f, 0.01234995f, 0.17492591f, 
    0.04557750f, 0.04329431f, 0.00982847f, 0.02465917f, 0.04106029f, -0.08238374f, -0.00815879f, -0.03001991f, 
    0.06573779f, 0.07340460f, 0.03449556f, 0.12952249f, 0.03115232f, -0.04124738f, -0.06150099f, -0.06176985f, 
    -0.02128974f, 0.03117245f, -0.05600377f, -0.03151175f, 0.00836151f, 0.16766952f, 0.07983456f, 0.08957343f, 
    0.06484465f, 0.05160450f, 0.08827928f, -0.06877684f, -0.04132924f, 0.02166337f, -0.01939333f, -0.04839693f, 
    -0.05869919f, -0.05576679f, -0.03517216f, -0.11004558f, 0.04134797f, -0.01300304f, -0.02639677f, 0.00133038f, 
    -0.06529528f, 0.03553110f, -0.01122951f, -0.07252978f, 0.01900556f, -0.07677674f, 0.01436948f, 0.00010670f, 
    -0.14635016f, -0.06982055f, -0.02894582f, -0.09068178f, 0.00130689f, 0.04432958f, -0.09641384f, -0.07555289f, 
    -0.16604079f, 0.14642376f, -0.02897116f, -0.07816975f, -0.01892046f, 0.05346120f, -0.02214173f, -0.08425798f, 
    0.03758072f, -0.01047270f, 0.03291244f, 0.04434608f, 0.15997320f, -0.13905147f, 0.18595076f, 0.02953598f, 
    -0.03829871f, 0.06496628f, -0.11619551f, 0.00773101f, -0.02499094f, -0.04049326f, -0.11847929f, 0.02314089f, 
    0.00798129f, -0.00442860f, -0.03124061f, 0.06208942f, -0.05887083f, -0.11301109f, -0.02772164f, -0.01499763f, 
    -0.04793251f, -0.07685721f, -0.07427313f, -0.06454941f, -0.20378578f, -0.01654896f, -0.08331211f, -0.04143187f, 
    0.04824921f, -0.00678826f, -0.05516826f, -0.07924785f, 0.05231472f, 0.02214861f, 0.01838584f, -0.08627129f, 
    0.00132016f, 0.07401962f, 0.01440775f, 0.19682933f, -0.06994067f, -0.02010394f, -0.01993868f, 0.00538100f, 
    -0.07618949f, -0.03129489f, -0.03881721f, -0.02013852f, 0.02874676f, 0.17436171f, 0.12160192f, 0.02896130f, 
    -0.02630935f, 0.10781385f, -0.00931481f, -0.06603988f, -0.01914964f, -0.04809738f, -0.07856767f, -0.01727978f, 
    0.23135455f, -0.05167187f, 0.04861059f, 0.07137839f, 0.02070322f, -0.03568750f, 0.03057167f, -0.03365807f, 
    -0.10659587f, -0.02445434f, -0.03419458f, -0.04794744f, -0.06776024f, 0.13881457f, -0.01899705f, 0.12356020f, 
    0.05746698f, -0.02164167f, -0.04341713f, -0.02879322f, -0.12111084f, -0.07180557f, -0.01688545f, -0.00415180f, 
    0.09011918f, -0.27998444f, 0.00177154f, -0.10661045f, -0.02156007f, -0.06728023f, -0.01602681f, -0.07823581f, 
    -0.01262580f, 0.02774696f, 0.03067006f, -0.01620818f, 0.08229534f, 0.08982458f, 0.02073911f, 0.07344849f, 
    0.03382761f, -0.02879651f, 0.06422870f, -0.00719608f, -0.05092100f, -0.00499276f, 0.04086611f, 0.02417043f, 
    -0.00454469f, 0.16150649f, -0.00543168f, 0.06599213f, -0.02810791f, -0.00020702f, -0.09021297f, 0.03540102f, 
    0.04875087f, 0.05718103f, 0.00872685f, 0.00229244f, -0.30897996f, 0.05290869f, -0.04016018f, -0.15411074f, 
    0.01142608f, -0.02266382f, 0.00570005f, -0.10392647f, -0.04921124f, 0.06416433f, -0.03184769f, 0.02621373f, 
    0.05701511f, 0.20341277f, -0.11685718f, -0.14621671f, -0.08632284f, 0.08498558f, 0.00740184f, -0.01404297f, 
    -0.10432497f, -0.06161426f, -0.00008332f, -0.11598083f, 0.13202043f, -0.01745095f, -0.00394634f, -0.09423613f, 
    -0.06269273f, -0.02923829f, -0.05277620f, 0.02059933f, 0.07515070f, 0.01116508f, -0.03706115f, 0.00977924f, 
    -0.11159547f, -0.03631950f, 0.01546917f, -0.12463817f, -0.07596452f, -0.05626142f, -0.05990953f, -0.03888781f, 
    -0.04152759f, -0.03161672f, -0.08270144f, -0.01487083f, -0.18814571f, 0.10619196f, 0.01914635f, -0.11346713f, 
    -0.04542521f, -0.03574111f, -0.05404136f, -0.12670733f, -0.04169464f, -0.01806036f, -0.01731197f, -0.10831445f, 
    0.03905006f, 0.07346511f, 0.15661891f, -0.04681965f, -0.02623239f, -0.03225810f, -0.01610179f, 0.04976448f, 
    -0.06073780f, 0.03624587f, -0.09006958f, -0.01162379f, 0.14900620f, -0.16606279f, 0.11952235f, -0.13834390f, 
    0.08806726f, 0.01339064f, 0.03151900f, -0.12952040f, 0.01689688f, 0.11453541f, 0.04558474f, 0.01296500f, 
    0.09296200f, 0.17049244f, -0.14577408f, 0.11400342f, 0.06968845f, -0.05498992f, -0.04774908f, 0.07284737f, 
    -0.02887810f, 0.01419283f, -0.04058093f, 0.00672050f, 0.04450241f, 0.09322487f, 0.16293120f, 0.10371245f, 
    -0.02438449f, 0.02463737f, -0.03450351f, 0.00258177f, -0.04510489f, -0.02135643f, -0.01338050f, -0.08890983f, 
    0.00064625f, -0.10648380f, -0.08356425f, 0.12953146f, -0.04763937f, -0.18200882f, -0.03174411f, -0.03133583f, 
    -0.09832130f, -0.01025312f, -0.04668372f, -0.01028259f, 0.14238229f, -0.10774962f, 0.09461793f, 0.08668827f, 
    0.09903924f, 0.01819932f, 0.06665169f, 0.01997333f, -0.03092264f, -0.08403797f, 0.00674809f, -0.03207118f, 
    -0.15850705f, -0.05589673f, -0.15030153f, -0.02954162f, 0.01351991f, -0.00001921f, 0.01850195f, -0.03268797f, 
    -0.10574436f, -0.00679007f, -0.00147618f, -0.15416725f, 0.14151363f, 0.05294445f, -0.09944434f, 0.03091610f, 
    -0.03101890f, -0.00316274f, 0.01162881f, -0.04427787f, -0.01940354f, 0.09536007f, -0.10742424f, -0.06562431f, 
    -0.28595790f, 0.19830239f, 0.11127417f, 0.07080998f, -0.22715138f, -0.06288823f, 0.06128474f, 0.01810316f, 
    0.00960416f, 0.03290355f, 0.01127164f, -0.04042172f, -0.03327138f, 0.09224416f, -0.09612473f, -0.17972642f, 
    -0.09769495f, 0.03644041f, -0.00450457f, -0.05374449f, -0.02764015f, -0.00767880f, 0.00109708f, -0.14503823f, 
    0.02692399f, -0.19823767f, -0.00095498f, -0.09410724f, -0.00341564f, -0.06328493f, -0.02845190f, -0.01666718f, 
    -0.00805502f, -0.01167222f, -0.03772388f, -0.01940839f, 0.04370813f, -0.01457748f, 0.13867484f, 0.02580824f, 
    0.01567580f, 0.05766127f, -0.00096274f, 0.00226863f, -0.07728737f, 0.00432362f, -0.01675395f, -0.09692053f, 
    -0.26838821f, 0.08499633f, -0.01643112f, -0.14758807f, -0.02254403f, -0.02134735f, -0.02013065f, -0.07448251f, 
    0.03032144f, -0.00140966f, 0.00632695f, 0.13072318f, 0.17353232f, -0.07057194f, -0.07968595f, 0.12951958f, 
    0.13473049f, -0.13761944f, -0.02232247f, -0.09650159f, 0.03122613f, -0.03408413f, -0.23077920f, -0.02975530f, 
    -0.10157777f, -0.05490508f, -0.20765747f, -0.25307623f, 0.06469051f, -0.12143987f, -0.14828086f, 0.05264261f, 
    -0.00565620f, 0.02718070f, 0.06961665f, -0.15820985f, 0.07541107f, 0.11097495f, -0.04969756f, -0.07670104f, 
    -0.05094165f, -0.04661871f, 0.03935964f, -0.05462201f, 0.00916999f, -0.01082729f, 0.06857611f, 0.07439989f, 
    0.01415434f, 0.12802812f, 0.16950570f, 0.12786379f, -0.18618511f, 0.01901313f, -0.08135069f, -0.06450869f, 
    0.00296345f, -0.09970897f, -0.06108131f, 0.01423741f, 0.23873685f, -0.25860971f, -0.20400630f, -0.15920538f, 
    -0.06536638f, -0.10633127f, -0.11947159f, -0.09847219f, 0.09886246f, 0.00772817f, -0.01296440f, 0.08887319f, 
    0.00780012f, -0.09078666f, -0.09070040f, 0.17260557f, -0.02685831f, -0.15515770f, 0.06525563f, -0.07114436f, 
    0.03001211f, 0.06509738f, -0.00570152f, 0.02398680f, 0.16119939f, 0.00233166f, -0.09720972f, -0.26989856f, 
    -0.09285497f, -0.06581831f, 0.15073605f, 0.05721789f, -0.05851187f, -0.05597018f, -0.02814995f, -0.03957675f, 
    -0.09576698f, -0.11954758f, 0.08445612f, 0.18705185f, 0.14650252f, -0.04397350f, 0.00219873f, -0.02369617f, 
    0.04110157f, 0.01312289f, -0.07178850f, -0.02937837f, 0.11009999f, -0.05467580f, 0.02134576f, -0.03842262f, 
    0.04527714f, -0.02625181f, 0.00199264f, -0.16673517f, -0.00078287f, -0.01533364f, 0.03984313f, -0.00063025f, 
    0.05867825f, 0.06643420f, -0.20935389f, 0.10287714f, 0.12135997f, 0.02634234f, -0.08718109f, 0.02003631f, 
    0.01162669f, 0.00257442f, 0.09187666f, -0.07300112f, -0.01402586f, -0.25450492f, -0.04243330f, 0.10101049f, 
    0.07800589f, 0.00297256f, -0.02881575f, -0.06640273f, -0.06815165f, -0.00586708f, 0.14262033f, -0.11186183f, 
    -0.11105444f, 0.09767237f, 0.03429107f, 0.05898555f, -0.04148676f, -0.07139098f, -0.07967204f, -0.04221855f, 
    0.04505773f, -0.04206513f, 0.04701676f, 0.10954327f, 0.20077486f, 0.10052327f, -0.19468041f, -0.17515373f, 
    -0.07470197f, -0.10055603f, 0.04506266f, -0.07043667f, 0.04316905f, 0.09902592f, 0.04081831f, 0.11266676f, 
    0.07950275f, 0.05938790f, -0.15880765f, -0.02056190f, -0.03480892f, 0.02917285f, -0.09504227f, 0.06775057f, 
    0.06736936f, 0.00241072f, 0.01137272f, 0.01968035f, -0.25436306f, -0.02092213f, -0.04359981f, -0.05240986f, 
    0.03174731f, -0.07908998f, -0.01573583f, 0.00711567f, 0.08422165f, 0.08176088f, -0.14399311f, 0.05614113f, 
    -0.03670534f, 0.10566895f, 0.09437270f, 0.11961816f, 0.13948365f, 0.11647281f, -0.00957575f, -0.02850987f, 
    0.02625607f, -0.01393569f, -0.08864137f, 0.07921571f, 0.17359692f, 0.00440407f, -0.18355197f, 0.16597459f, 
    0.13468529f, -0.00957351f, 0.03349233f, -0.00308116f, 0.07606227f, 0.09099487f, 0.11380915f, -0.02232449f, 
    0.00349790f, -0.02117678f, 0.05467878f, 0.21523637f, -0.05830495f, -0.05478118f, -0.05985620f, -0.00975379f, 
    -0.00746537f, 0.00893748f, -0.02314362f, -0.03214672f, 0.06210640f, 0.18615662f, -0.16501659f, -0.05334812f, 
    0.00402569f, 0.12196344f, -0.18767458f, -0.02872439f, 0.11314870f, 0.03856752f, 0.01637699f, 0.07117716f, 
    0.01250196f, -0.11720406f, 0.08986707f, -0.05231469f, -0.00665554f, 0.03283257f, -0.00860174f, -0.04090516f, 
    0.05095878f, 0.10645125f, 0.03213448f, 0.01043182f, -0.08133764f, 0.16194700f, 0.08545116f, -0.12991761f, 
    -0.09534606f, 0.00058835f, -0.01425759f, 0.08450957f, 0.09607973f, 0.05561979f, 0.00397158f, -0.11404616f, 
    0.03899484f, -0.03588863f, 0.04618759f, 0.14856215f, 0.04014980f, -0.07442956f, 0.01883422f, 0.06515500f, 
    0.06720214f, -0.03529377f, 0.02370138f, -0.09469088f, 0.05567291f, 0.07618728f, -0.13939992f, -0.18249652f, 
    0.03478438f, -0.10307894f, 0.02236786f, -0.06872213f, 0.07601675f, 0.06221373f, 0.01147628f, 0.06788471f, 
    -0.04938852f, 0.15372652f, -0.15742362f, -0.01978868f, 0.00624359f, -0.03595760f, 0.10579322f, -0.07227666f, 
    -0.00615361f, 0.01205110f, 0.06322753f, 0.05867305f, -0.13583727f, -0.14222293f, -0.09907876f, -0.06316818f, 
    -0.01005603f, -0.00357560f, 0.01970985f, -0.00023648f, 0.07052888f, 0.00271235f, 0.05269359f, 0.14681222f, 
    0.17452599f, 0.01460952f, 0.01440905f, 0.11799724f, -0.00502626f, -0.15815441f, 0.04468203f, -0.03137606f, 
    0.08508697f, -0.18705964f, -0.07397145f, 0.01669494f, -0.08289513f, -0.09159571f, 0.15649056f, 0.12414994f, 
    -0.04539054f, 0.03452467f, 0.13920766f, 0.01487711f, 0.00767551f, -0.11898475f, 0.11336618f, 0.06060248f, 
    -0.13884869f, 0.10379551f, 0.13789845f, 0.02418860f, -0.04270564f, 0.01861276f, -0.03601135f, -0.00702411f, 
    -0.02257718f, 0.05200876f, -0.03250026f, -0.00598579f, 0.09849992f, -0.02268561f, -0.02379311f, -0.16273864f, 
    0.08578088f, -0.06693533f, 0.06161259f, -0.00076478f, -0.01345784f, -0.19073395f, -0.09986766f, 0.09815980f, 
    0.04609359f, 0.13319199f, -0.18728508f, -0.06508318f, 0.09824465f, -0.02184724f, -0.11744514f, -0.02439681f, 
    -0.00201908f, -0.10067400f, -0.12197988f, 0.12458705f, -0.05807093f, 0.10383905f, -0.07587437f, -0.08616223f, 
    -0.06820662f, -0.06785218f, -0.00295585f, -0.00412409f, -0.00693298f, -0.08839355f, -0.12311292f, -0.05161857f, 
    -0.19394526f, 0.08013742f, -0.18445918f, -0.17307593f, -0.04314454f, -0.02969618f, -0.21101300f, 0.11562210f, 
    0.06042207f, 0.00831335f, 0.12248316f, -0.04137662f, -0.15698342f, -0.01977445f, 0.22537774f, -0.01068109f, 
    0.00114090f, 0.06978779f, -0.15458116f, 0.10836271f, -0.04296090f, -0.11263687f, 0.01059403f, -0.19542909f, 
    -0.07405353f, -0.06607514f, -0.01130689f, 0.00195918f, 0.05282270f, -0.12754568f, -0.06038627f, 0.02076354f, 
    -0.02577316f, 0.04025309f, -0.05313286f, -0.02935597f, -0.17317066f, -0.17330541f, -0.20532686f, -0.08954616f, 
    0.03640610f, 0.00606887f, 0.03556877f, -0.05506700f, 0.02492219f, -0.12431634f, 0.06439765f, 0.04486768f, 
    0.08976908f, -0.01242915f, -0.03757817f, 0.09391403f, 0.04722036f, -0.07149241f, -0.11230640f, 0.08472890f, 
    0.02934840f, 0.00646620f, 0.00558599f, -0.13456328f, -0.14776236f, -0.01911549f, 0.12652107f, -0.20566027f, 
    0.02760349f, 0.07014635f, 0.04071762f, -0.09426164f, -0.08495910f, -0.02214987f, 0.15958728f, 0.06950267f, 
    -0.03691903f, 0.05852677f, 0.13046013f, -0.17990863f, -0.14347118f, -0.12936163f, 0.09396794f, 0.07222165f, 
    0.01499315f, 0.06261536f, 0.11635689f, 0.06177448f, 0.22407641f, 0.17871536f, -0.15833469f, 0.08709151f, 
    0.11196164f, 0.03912475f, -0.02218118f, -0.03310774f, -0.15562652f, 0.00062900f, -0.05483202f, 0.09402224f, 
    -0.14830437f, -0.11933549f, -0.08408187f, -0.15607788f, -0.01962011f, 0.03974569f, -0.14280711f, -0.02572525f, 
    0.10430315f, -0.05467353f, -0.07679358f, -0.17524120f, -0.08596963f, 0.05403191f, 0.07540205f, -0.13794214f, 
    -0.04767382f, 0.02671121f, -0.05764913f, -0.08630776f, -0.00392419f, -0.02768953f, 0.05206287f, -0.07330563f, 
    -0.15395591f, -0.19272992f, -0.02856889f, -0.31088045f, -0.00887618f, 0.01428753f, -0.17086639f, 0.04211942f, 
    0.10803205f, 0.05275194f, -0.01712509f, 0.06634491f, -0.20078196f, 0.00238684f, -0.07763760f, -0.20534267f, 
    -0.02721571f, 0.01314082f, -0.22483742f, 0.08215451f, -0.09540351f, 0.01048141f, 0.09904341f, 0.03182692f, 
    0.06103940f, 0.03756367f, -0.04064318f, 0.11310558f, 0.08946022f, -0.06361774f, 0.01105936f, -0.04249907f, 
    0.05087516f, -0.00740031f, 0.00122131f, 0.05958129f, 0.07665020f, 0.00821966f, 0.10140542f, 0.07026116f, 
    -0.03672645f, 0.03448011f, 0.00817457f, -0.01544766f, -0.13652107f, 0.04276861f, 0.06487496f, 0.00961616f, 
    0.01860118f, 0.16836390f, -0.05662020f, -0.02244045f, -0.02049325f, 0.00650921f, -0.01241713f, -0.09063287f, 
    -0.01172334f, -0.02847569f, -0.04724937f, -0.01820456f, 0.13674825f, 0.04073846f, 0.03094995f, 0.16046822f, 
    0.05892837f, -0.01963466f, -0.11706764f, -0.04392371f, 0.11720488f, -0.11367426f, 0.16508904f, -0.04566048f, 
    -0.25627774f, -0.18095475f, 0.08107837f, -0.05044929f, 0.07119592f, -0.13042438f, -0.01317519f, 0.00241697f, 
    0.02325915f, 0.03230474f, -0.04436468f, 0.07957359f, -0.13753456f, -0.12110338f, 0.14024130f, -0.13721067f, 
    -0.02454797f, -0.09770964f, 0.06316749f, -0.13461384f, -0.15882388f, 0.03853852f, 0.03285618f, -0.01751699f, 
    -0.01560227f, 0.02311403f, 0.04865269f, 0.07894931f, 0.01792256f, 0.05653040f, 0.03226268f, -0.12138528f, 
    -0.07798037f, -0.02543138f, 0.01531823f, -0.04219661f, 0.27121925f, -0.04314144f, 0.09452519f, 0.17928591f, 
    0.07469422f, 0.01374351f, -0.03209678f, -0.06966508f, -0.02082430f, -0.04059387f, 0.07293927f, 0.05454654f, 
    -0.01735484f, -0.16127051f, 0.11178170f, 0.05026478f, -0.08671214f, -0.03434965f, 0.06295937f, 0.05661416f, 
    0.02101645f, -0.02108121f, -0.14619577f, -0.09638265f, -0.04245587f, -0.08365130f, 0.19230397f, 0.03521219f, 
    -0.05849959f, -0.10068861f, -0.08229247f, -0.05306756f, 0.08638576f, -0.08629423f, -0.00039077f, -0.11186873f, 
    -0.18963498f, 0.23128086f, -0.06504947f, -0.09331990f, -0.10031973f, 0.03257118f, -0.17506920f, 0.03956798f, 
    0.10705695f, -0.00999804f, 0.08700712f, 0.10180461f, -0.15317693f, -0.24345887f, 0.16525275f, -0.28211585f, 
    -0.18269713f, -0.02732267f, -0.03589643f, -0.11638013f, -0.05122648f, 0.07202322f, -0.08958013f, 0.17446467f, 
    -0.18128519f, -0.16668741f, -0.22065593f, -0.10941825f, 0.01452810f, -0.03524765f, 0.04142183f, 0.04756062f, 
    0.04007857f, 0.03557238f, 0.09568635f, -0.04283557f, 0.03758692f, -0.31520319f, -0.02146815f, -0.09106459f, 
    0.07048402f, 0.05097558f, -0.04310026f, -0.11296488f, 0.01829130f, -0.01430173f, 0.02718265f, 0.06487758f, 
    -0.10255811f, -0.08951390f, 0.10329148f, 0.15224497f, 0.06998753f, 0.05942380f, -0.00130603f, -0.10845384f, 
    0.00640571f, 0.00582761f, 0.09786311f, 0.10874941f, -0.05947400f, 0.20751573f, -0.07576208f, 0.03307492f, 
    -0.02263020f, 0.08201215f, -0.10678213f, -0.16641712f, 0.02666051f, 0.07286709f, 0.11296123f, -0.01131181f, 
    0.25104567f, -0.06719268f, -0.13667475f, -0.00987592f, -0.03821688f, -0.09293001f, -0.18989861f, -0.16343206f, 
    -0.01351789f, -0.00905390f, 0.08247903f, -0.05497945f, 0.12197239f, -0.00844267f, 0.02063071f, 0.01618377f, 
    0.07207332f, -0.09453709f, -0.02818744f, -0.06326109f, -0.00747149f, 0.08836575f, 0.05530098f, 0.03911501f, 
    0.00899076f, -0.09412204f, 0.11412788f, 0.04429884f, -0.02006626f, -0.05591801f, -0.05693184f, -0.09569716f, 
    -0.06777895f, 0.00466012f, -0.03501932f, -0.01252126f, -0.18411715f, -0.09714507f, 0.01442641f, -0.10222146f, 
    -0.05456335f, -0.01774410f, -0.02594340f, -0.01645778f, 0.06881924f, -0.04976308f, -0.07444178f, 0.07890324f, 
    0.05359564f, -0.01130605f, -0.17538004f, 0.15249357f, 0.00403043f, -0.02094680f, 0.04756578f, 0.02399504f, 
    -0.08950645f, 0.08039904f, 0.07508735f, 0.02423770f, 0.16018079f, -0.25007251f, 0.16986853f, 0.02336478f, 
    0.11787283f, -0.01696169f, 0.03781047f, -0.07856657f, 0.02784369f, -0.05687456f, 0.02865206f, 0.09769386f, 
    -0.13434507f, -0.05713037f, 0.20507723f, 0.02957032f, -0.03179196f, -0.02984956f, 0.07072341f, -0.00679690f, 
    0.05841004f, 0.01221650f, 0.03919166f, -0.00050726f, -0.08968999f, 0.13415885f, 0.07735495f, -0.08443266f, 
    -0.03215259f, 0.03723228f, 0.07487958f, 0.19095063f, 0.04197244f, 0.10518396f, 0.11254996f, -0.00578451f, 
    -0.02419500f, 0.35454100f, -0.12730980f, 0.12526055f, 0.11594171f, 0.09816843f, -0.04291506f, 0.08739371f, 
    0.00815083f, 0.02358476f, 0.02588427f, -0.00192876f, -0.27165139f, 0.10400207f, -0.13195750f, 0.05315688f, 
    -0.01899943f, 0.17986080f, 0.06763940f, 0.00954922f, -0.14955167f, -0.03283749f, -0.00116637f, -0.06603859f, 
    -0.07580208f, 0.18788628f, -0.18130010f, 0.03817702f, -0.03631735f, -0.00853295f, 0.09855293f, -0.00332359f, 
    0.03949123f, -0.13589931f, 0.01715833f, -0.02609475f, -0.10962946f, 0.17106907f, -0.05950868f, 0.14020382f, 
    0.13073190f, -0.09992930f, -0.07922933f, 0.03945768f, -0.02392813f, -0.09867626f, 0.04289665f, 0.11111046f, 
    -0.47436428f, -0.04941030f, -0.23845355f, -0.19402871f, 0.11886574f, -0.17288478f, 0.01853342f, -0.13573591f, 
    -0.00645573f, -0.01459846f, 0.04856886f, -0.05893812f, 0.04533500f, -0.16621286f, -0.23103806f, 0.02214821f, 
    0.00865099f, 0.12037753f, -0.07557273f, 0.04554317f, -0.01929706f, 0.12230805f, 0.01256454f, 0.00215992f, 
    0.04708911f, -0.20938548f, -0.13508853f, -0.30021277f, -0.09823702f, 0.06481303f, -0.05506995f, -0.00687594f, 
    0.00245903f, -0.03725740f, -0.08595527f, -0.03187623f, -0.30679780f, 0.18410346f, 0.07704027f, -0.36005688f, 
    0.04518297f, 0.06035220f, -0.05674213f, -0.01638601f, -0.09075534f, 0.07999957f, -0.01735423f, -0.07650531f, 
    -0.36179826f, -0.36159894f, 0.20884630f, -0.19725363f, 0.09384853f, 0.06480452f, -0.03181468f, 0.09360971f, 
    -0.03194196f, -0.10657835f, -0.05927831f, 0.01403796f, 0.01354892f, -0.07225674f, 0.02950743f, -0.23658006f, 
    -0.00876392f, 0.01267582f, -0.08728771f, -0.07042007f, 0.01417637f, -0.02242529f, -0.04052624f, -0.08753769f, 
    0.05328136f, -0.32126054f, 0.19853278f, -0.04925469f, 0.02228817f, -0.05999861f, -0.00430240f, -0.07331448f, 
    -0.09412515f, -0.08574130f, 0.11283556f, 0.09280631f, -0.08717008f, -0.21715680f, -0.07972291f, 0.03118707f, 
    -0.09080558f, -0.00838812f, 0.10623131f, -0.11747263f, 0.08365101f, -0.14868145f, 0.11380046f, -0.03231659f, 
    0.08058262f, 0.31216848f, -0.14191075f, -0.50834507f, 0.12290912f, -0.10499208f, -0.00789669f, -0.02019681f, 
    -0.20251793f, 0.02826635f, -0.01679724f, -0.22519985f, -0.00422789f, -0.03468244f, 0.13887593f, -0.03511645f, 
    -0.00089741f, 0.02880688f, 0.00212757f, -0.00750244f, -0.09665421f, -0.02173583f, -0.01647574f, 0.04474987f, 
    0.18730621f, -0.46497411f, -0.03630844f, 0.00825861f, 0.01061217f, 0.02600677f, 0.00371213f, -0.00548266f, 
    -0.12836550f, 0.04099235f, 0.02326541f, -0.09804329f, -0.13376343f, 0.08928379f, 0.05215830f, 0.06535427f, 
    0.02340568f, 0.03735999f, -0.07121117f, -0.03360674f, -0.05705707f, 0.07627354f, -0.01942728f, -0.00310820f, 
    0.24732542f, 0.00701698f, -0.11594412f, 0.10978568f, 0.03082267f, -0.02463479f, 0.04147656f, 0.03792990f, 
    -0.03330110f, -0.02968572f, -0.17338522f, -0.00500466f, 0.12609316f, 0.25633153f, 0.00718659f, 0.11644319f, 
    0.08988600f, -0.01979934f, -0.01333392f, -0.03408553f, -0.06586543f, -0.04041911f, 0.04854091f, 0.09411433f, 
    -0.13240132f, 0.18601599f, -0.10882663f, -0.08062986f, 0.06179802f, 0.06541283f, -0.03574303f, 0.04881103f, 
    -0.04232945f, 0.00059746f, 0.09421075f, 0.01522106f, -0.25773311f, -0.18323846f, -0.02862366f, 0.13900165f, 
    0.03191948f, -0.04211246f, -0.20745732f, 0.13145360f, 0.07693593f, 0.09339943f, 0.05723646f, -0.04800333f, 
    0.07470274f, -0.20183291f, -0.01708805f, 0.03236264f, 0.05971743f, 0.03278483f, 0.00833804f, -0.05523411f, 
    0.01131851f, -0.07449105f, -0.07970012f, 0.06194298f, 0.11088692f, -0.15520507f, -0.06864325f, 0.10546838f, 
    -0.10545162f, 0.04803619f, -0.07527077f, -0.06380935f, -0.09631167f, -0.07479526f, -0.01173558f, -0.21337226f, 
    -0.11896095f, -0.41481614f, 0.06176200f, -0.08610577f, 0.08824511f, 0.03344927f, 0.03090708f, 0.09171297f, 
    0.00694955f, -0.07486046f, 0.17515513f, -0.05013563f, -0.16544926f, -0.19141591f, 0.09508012f, -0.17503498f, 
    0.10212108f, -0.08057711f, 0.02516833f, 0.09634797f, 0.07287635f, -0.07271458f, 0.04239341f, 0.11935010f, 
    -0.22133146f, -0.18500923f, 0.06621854f, 0.00930129f, -0.00883646f, -0.09849367f, -0.09673726f, 0.00051012f, 
    -0.00327296f, 0.05447499f, -0.10623600f, 0.00477766f, 0.31900671f, 0.17069782f, 0.16208863f, 0.02700182f, 
    -0.00423317f, -0.06841892f, 0.00490643f, -0.09708123f, -0.06249381f, 0.04688183f, 0.08835320f, -0.03403904f, 
    0.29106772f, -0.03572528f, 0.23001042f, 0.12509215f, -0.00009173f, -0.00010601f, 0.02671893f, 0.01791612f, 
    0.04747351f, 0.02411230f, 0.02600925f, -0.05846107f, -0.17164890f, -0.12308280f, 0.09371141f, -0.09801298f, 
    -0.05627588f, 0.05105140f, -0.03915240f, 0.14839245f, 0.01312679f, -0.00511947f, 0.01625050f, 0.06761398f, 
    -0.12674303f, -0.14188918f, 0.08410323f, 0.10870539f, -0.04148841f, 0.03900674f, 0.07772263f, 0.05029715f, 
    0.01114972f, 0.17038308f, -0.10826001f, -0.05494537f, -0.05901412f, -0.04806206f, 0.05033619f, 0.00355583f, 
    0.02380504f, -0.13569355f, -0.04864643f, -0.07519785f, 0.08620342f, 0.08563439f, -0.08734297f, 0.04368613f, 
    0.16338880f, 0.07939455f, 0.10297014f, -0.18124086f, -0.05260635f, -0.02762091f, -0.00774798f, 0.09844978f, 
    -0.02831679f, 0.01753163f, -0.08386530f, -0.03138808f, -0.10469937f, 0.23376228f, -0.14610827f, -0.20935126f, 
    -0.03118103f, -0.06827372f, -0.02564339f, 0.15597312f, -0.03486583f, 0.15656739f, 0.00410066f, 0.02907147f, 
    -0.26703706f, -0.15169451f, 0.06809004f, -0.08588079f, 0.05481652f, 0.12338897f, -0.02710759f, -0.07143606f, 
    0.06994493f, -0.08490606f, 0.13115355f, 0.05716666f, -0.09216359f, -0.28657421f, -0.01328412f, 0.15012620f, 
    -0.15838267f, 0.01063571f, -0.04091918f, 0.03166183f, 0.01346032f, 0.16932105f, -0.04729399f, -0.10467886f, 
    0.42507187f, 0.17538838f, -0.05042414f, -0.19155809f, -0.01951477f, -0.00987975f, 0.01738149f, 0.05298384f, 
    -0.08865315f, -0.00350263f, 0.01387873f, -0.01116709f, 0.17957935f, 0.17760025f, 0.14172114f, -0.01527912f, 
    -0.01041634f, 0.06225701f, -0.11474407f, -0.14698881f, 0.06221035f, 0.14442907f, -0.00663233f, -0.01066547f, 
    -0.06749845f, 0.06485963f, 0.05231270f, -0.04757076f, -0.03556278f, 0.05099165f, 0.05885990f, -0.06801216f, 
    -0.13490498f, -0.11516045f, 0.01882219f, 0.06342796f, -0.05628457f, -0.29235184f, -0.02387644f, 0.08943453f, 
    0.03167598f, 0.04599698f, -0.04237524f, -0.08757637f, -0.09984431f, -0.01853870f, -0.23413382f, -0.06393138f, 
    0.03114644f, -0.12315451f, 0.11105505f, -0.14734617f, -0.10953624f, -0.00209398f, -0.01453403f, -0.03203656f, 
    -0.01326477f, -0.09193736f, 0.00207503f, -0.02215013f, -0.06332652f, -0.33120349f, 0.13639289f, 0.19688275f, 
    -0.01475040f, 0.03315070f, 0.07297249f, 0.20616165f, -0.09753709f, 0.05829679f, 0.01572714f, -0.04194913f, 
    0.11661510f, -0.22947864f, 0.08476512f, -0.09198836f, 0.06347948f, 0.06003902f, -0.11491442f, -0.09323056f, 
    0.02018007f, -0.02098410f, 0.13535951f, -0.17365678f, -0.22127482f, -0.16254094f, 0.11246901f, -0.00126586f, 
    0.02455869f, 0.05959312f, 0.12645739f, -0.08898924f, 0.08919965f, -0.03665196f, -0.12794016f, 0.09481734f, 
    -0.13132221f, 0.13095346f, 0.08159321f, 0.06399592f, 0.05556672f, -0.03427163f, -0.06874546f, 0.04248066f, 
    0.08413360f, -0.01677389f, 0.10233249f, 0.03614548f, -0.18932320f, 0.18778810f, -0.01359833f, -0.22105990f, 
    0.10414212f, 0.00815898f, -0.02204699f, -0.02295573f, -0.10417704f, 0.07574032f, -0.02163034f, -0.07911035f, 
    -0.19290103f, 0.01341445f, 0.18968476f, -0.03456254f, 0.05369435f, -0.10538895f, 0.02476721f, -0.02102875f, 
    0.12450497f, -0.06412334f, 0.06027202f, 0.07736441f, 0.49616170f, 0.17818390f, -0.04234454f, 0.06118642f, 
    0.01844896f, -0.13754781f, 0.02096563f, 0.11367830f, -0.12181247f, -0.06618848f, 0.03214240f, 0.01451820f, 
    -0.30408680f, 0.26015490f, -0.22131978f, 0.06784641f, 0.03169632f, -0.03587188f, -0.09943797f, -0.03049997f, 
    0.05653469f, 0.10820049f, -0.00770010f, 0.08855303f, -0.39611581f, 0.27031103f, -0.23380585f, -0.11428925f, 
    0.05149941f, -0.02247310f, 0.00808643f, -0.01797357f, -0.05473640f, -0.09176704f, 0.02391572f, -0.06982216f, 
    0.22786136f, -0.12293050f, -0.06394675f, -0.07019878f, 0.10347580f, 0.04048793f, -0.03626599f, -0.09282066f, 
    0.06662965f, 0.03581007f, -0.08806620f, 0.11179417f, 0.27941293f, -0.12358318f, 0.12237991f, 0.23420140f, 
    -0.06356006f, 0.05225629f, 0.04344324f, 0.01017482f, -0.12281448f, 0.00781910f, 0.07065633f, 0.01335213f, 
    -0.11225167f, 0.10725820f, 0.09144731f, -0.08911266f, -0.04524188f, -0.06005924f, 0.01536028f, 0.08420800f, 
    -0.00080199f, 0.07051636f, -0.08448795f, -0.06539697f, -0.01631115f, -0.07476421f, -0.00146397f, 0.22181751f, 
    -0.01549024f, 0.04466880f, 0.02346129f, -0.04114781f, 0.06533214f, 0.07238101f, 0.06420138f, -0.08167612f, 
    0.03116696f, -0.05327779f, -0.00610723f, -0.21400760f, 0.00278144f, 0.02770643f, -0.06466736f, -0.00365163f, 
    -0.03228758f, -0.00767007f, -0.03994227f, 0.04560175f, 0.04142917f, -0.08416112f, 0.06622531f, 0.07524478f, 
    -0.05578028f, -0.06799595f, 0.00437378f, 0.01561048f, 0.01599381f, 0.05262534f, 0.05403323f, 0.05656913f, 
    -0.06608226f, 0.27115509f, -0.20962337f, -0.27091104f, 0.03550959f, -0.07446504f, 0.06104352f, -0.01417943f, 
    -0.06199665f, -0.07836968f, -0.08770876f, -0.14562963f, -0.03515028f, 0.12537389f, 0.10306548f, 0.03167325f, 
    -0.00829675f, 0.06838217f, 0.15243219f, 0.14382061f, -0.03189138f, 0.11237983f, 0.04845166f, 0.06133474f, 
    -0.50563920f, -0.01194074f, 0.05749025f, -0.10687850f, 0.06583054f, -0.03051482f, 0.09445430f, -0.07348764f, 
    -0.01242006f, 0.06521421f, -0.11235414f, 0.10070398f, -0.02967722f, 0.07839228f, 0.02550282f, -0.07009565f, 
    -0.05005342f, 0.09169775f, 0.05046858f, 0.08488856f, 0.10950035f, -0.02319450f, 0.01839326f, -0.02150069f, 
    0.25496176f, 0.10635173f, -0.23185551f, 0.01922971f, 0.09121170f, 0.00414850f, -0.05039848f, 0.03564142f, 
    0.05380683f, -0.01629747f, -0.09150282f, 0.07567932f, -0.11773939f, -0.13254969f, 0.01934002f, 0.21127333f, 
    -0.00017555f, 0.06592941f, -0.06068635f, -0.07155469f, 0.00593642f, 0.02526396f, 0.02506344f, -0.04454019f, 
    0.02826727f, -0.07889242f, 0.00345685f, -0.02043404f, 0.01772070f, 0.02155246f, 0.02859076f, -0.06265303f, 
    0.03581256f, -0.12737198f, -0.02697716f, 0.04796032f, -0.32550985f, -0.04967384f, -0.14061882f, -0.03657284f, 
    0.01421031f, 0.05309175f, -0.04554797f, -0.05293056f, -0.00610050f, 0.00958958f, -0.09615234f, -0.04265449f, 
    -0.08481745f, -0.16287728f, 0.17572147f, 0.13704608f, -0.01766491f, 0.02582003f, -0.08799294f, 0.00520715f, 
    0.00173928f, 0.02120168f, 0.00839288f, 0.13101278f, -0.20225796f, -0.08200786f, -0.08485397f, 0.07742544f, 
    0.10461836f, -0.00676029f, 0.05047533f, -0.06986302f, -0.00959285f, 0.01228970f, 0.04689542f, 0.12416381f, 
    0.11301374f, -0.01752769f, -0.00717986f, -0.01555753f, -0.06778686f, -0.10104689f, -0.00940057f, 0.08054450f, 
    -0.02584277f, -0.15939283f, -0.07525344f, -0.04171980f, -0.24948825f, 0.01759679f, 0.02005604f, 0.13977402f, 
    0.10709395f, -0.03650195f, -0.04482521f, -0.00671731f, 0.04641971f, 0.05756874f, 0.10840297f, 0.07899548f, 
    -0.13708206f, -0.08538325f, -0.07361235f, 0.13403054f, -0.04765203f, -0.19756962f, -0.13349159f, 0.00950528f, 
    -0.07509206f, 0.12156983f, -0.08900739f, 0.03165125f, 0.10961499f, 0.03082262f, 0.02683265f, -0.04875826f, 
    -0.02123479f, 0.07309105f, -0.03505301f, -0.00018778f, 0.10117359f, -0.02393239f, 0.06328395f, -0.11044573f, 
    -0.52493739f, -0.28400102f, -0.18710387f, -0.06838640f, -0.06663979f, -0.10249493f, -0.01815349f, 0.04901599f, 
    0.00380668f, 0.04217726f, -0.04492301f, 0.12128136f, 0.11980101f, 0.17227316f, -0.12608874f, -0.02567917f, 
    -0.07121485f, 0.11064251f, -0.00095841f, 0.03524229f, -0.02514784f, -0.08852878f, -0.08237616f, -0.02209392f, 
    -0.18755868f, -0.03829013f, -0.11230613f, -0.13672416f, 0.15892759f, 0.00057422f, 0.08049123f, -0.01423987f, 
    0.05387542f, 0.11364429f, 0.01574460f, 0.02503127f, -0.22686857f, -0.27907759f, 0.00753968f, -0.27070126f, 
    0.08541666f, -0.05456822f, -0.05140624f, -0.01652277f, 0.04983320f, 0.10995826f, 0.09250835f, -0.00169468f, 
    0.10013868f, 0.13149814f, -0.09102888f, -0.02277486f, -0.12169109f, -0.03274329f, -0.08791493f, -0.07222849f, 
    -0.02652500f, 0.00811320f, 0.05404129f, -0.08553202f, 0.16388717f, 0.14733391f, -0.06376920f, -0.08379817f, 
    0.04169180f, 0.01578370f, 0.00420152f, 0.03875494f, -0.00841538f, 0.02243849f, -0.01242756f, 0.07748044f, 
    -0.20016627f, 0.00318822f, -0.16277687f, -0.06150256f, 0.09160933f, -0.00742909f, -0.08723309f, -0.00952655f, 
    0.03106709f, 0.05861295f, -0.03094774f, 0.03982262f, 0.15690331f, 0.09551721f, -0.05077723f, 0.03514767f, 
    -0.00235913f, 0.00835774f, -0.00817132f, 0.05324063f, 0.04262084f, 0.04014086f, -0.06886886f, 0.04422087f, 
    -0.37444320f, -0.11664691f, -0.01778849f, -0.22461466f, 0.06081120f, 0.06229426f, 0.01986134f, 0.01955384f, 
    0.11150644f, -0.01126002f, 0.06152499f, 0.09788191f, -0.35209876f, -0.17148846f, -0.09935892f, 0.05871124f, 
    0.04138755f, -0.03576827f, 0.02847499f, 0.00231968f, 0.04468156f, 0.08737719f, 0.04677633f, 0.03658214f, 
    0.12940060f, -0.00705979f, -0.04032477f, -0.03208269f, -0.07658143f, -0.07585923f, -0.03507533f, 0.03170107f, 
    0.08856340f, 0.02871246f, -0.02275426f, -0.05884141f, -0.02969252f, -0.11994427f, 0.07525089f, 0.06175363f, 
    0.04666274f, 0.07918093f, -0.01469144f, 0.01364654f, 0.10500728f, 0.09374888f, 0.01227214f, 0.01204834f, 
    0.01621443f, -0.07730376f, -0.11697140f, 0.12275822f, -0.01574411f, 0.15429591f, -0.03052175f, 0.03612171f, 
    0.02256252f, 0.10013366f, 0.10338511f, 0.03032748f, -0.17470150f, -0.13047360f, 0.03782462f, 0.14142726f, 
    -0.01224827f, 0.04086883f, 0.04176148f, -0.03913904f, 0.04003004f, 0.15136965f, 0.00238669f, -0.00326139f, 
    -0.11265126f, -0.15789355f, -0.16015987f, -0.01333547f, 0.04825593f, -0.13144010f, -0.00688606f, 0.10026382f, 
    -0.03593964f, 0.02951163f, 0.01347502f, 0.11063820f, 0.09017934f, -0.05611610f, -0.16075537f, 0.01862873f, 
    -0.02229278f, 0.01296753f, 0.05527634f, 0.00663612f, 0.04063249f, 0.08156703f, -0.02601106f, -0.02431882f, 
    0.21492833f, -0.02000944f, -0.12747233f, -0.03632838f, 0.02660974f, 0.18172441f, -0.02425691f, 0.01758099f, 
    0.02149156f, 0.11445151f, 0.02045618f, -0.03149160f, -0.11878077f, 0.04177016f, 0.00042653f, -0.02886654f, 
    -0.03535195f, 0.07567597f, -0.01924452f, 0.09134395f, 0.04009885f, -0.00316056f, 0.04615688f, 0.13675988f, 
    -0.11645910f, 0.11779410f, -0.08301833f, -0.05368001f, -0.01826785f, -0.13714428f, -0.07789829f, -0.08666152f, 
    0.09083226f, 0.02190710f, 0.03709991f, 0.10743865f, -0.01216507f, 0.06238741f, -0.05081328f, 0.00199865f, 
    -0.03161161f, 0.08733978f, 0.03012945f, -0.12155987f, 0.07998892f, 0.04429477f, 0.04703594f, -0.04595055f, 
    0.22495008f, -0.00338920f, -0.02483208f, -0.04604458f, -0.04195389f, -0.02819052f, 0.04994443f, 0.00719975f, 
    0.10996459f, 0.08875705f, -0.00523675f, 0.04330396f, -0.09248763f, 0.19725144f, 0.05499751f, 0.05073002f, 
    0.10728963f, 0.13716817f, 0.01599417f, -0.05282329f, 0.00387532f, 0.07102126f, -0.01641804f, -0.02617448f, 
    -0.42011419f, -0.07687059f, 0.10864518f, 0.12191115f, 0.12414294f, 0.02942781f, -0.00144769f, -0.10075305f, 
    0.05816375f, -0.05835743f, -0.04677352f, 0.10649648f, -0.16085003f, -0.09561596f, 0.03790231f, -0.06023869f, 
    -0.02445930f, -0.10412294f, 0.06262019f, -0.08281647f, -0.00005771f, -0.01730046f, -0.21373928f, -0.09288590f, 
    -0.04132972f, -0.09278747f, 0.13215590f, 0.03312354f, 0.09763982f, 0.08924736f, 0.02578502f, -0.04230440f, 
    -0.08210109f, -0.02228891f, 0.10461115f, -0.04844509f, 0.11826131f, 0.05378313f, 0.03058748f, -0.05667807f, 
    -0.02888780f, 0.03733359f, -0.02278673f, -0.00044659f, 0.04578319f, -0.03841003f, -0.00129787f, -0.12511031f, 
    0.02005531f, 0.14229460f, -0.11461446f, -0.00471001f, 0.03479105f, -0.00246275f, -0.09064022f, 0.01225254f, 
    0.00275806f, 0.04781997f, 0.12920853f, 0.02596855f, 0.21076536f, 0.14196455f, 0.06772667f, -0.06309443f, 
    0.00357319f, 0.12365779f, 0.02592623f, 0.03634526f, -0.02974207f, -0.03147089f, 0.17512737f, -0.10465888f, 
    0.11048953f, 0.07889691f, -0.15380122f, 0.08541232f, 0.06075462f, -0.17547271f, 0.01256609f, -0.05478259f, 
    -0.01155637f, 0.02645525f, -0.13241532f, 0.03402769f, 0.27610552f, 0.15820162f, -0.06280833f, -0.05080594f, 
    0.07098604f, 0.08091589f, -0.00108637f, 0.01467840f, 0.06550217f, -0.00826392f, -0.06938796f, -0.00948592f, 
    -0.06728708f, -0.02649391f, 0.02135867f, 0.26382202f, -0.08367547f, -0.02545875f, 0.14291634f, -0.14499484f, 
    0.01628598f, 0.21435519f, 0.12294202f, 0.06804729f, -0.30535603f, -0.32301921f, -0.01659086f, 0.08406416f, 
    -0.03409724f, 0.00482956f, -0.03271981f, -0.10041470f, 0.12735938f, -0.17892084f, -0.18255460f, 0.02831736f, 
    -0.33967093f, -0.11741893f, 0.19502348f, 0.01212437f, 0.10038476f, 0.03628019f, -0.05044892f, -0.16479789f, 
    -0.00296700f, -0.03026259f, -0.11489614f, -0.07735826f, 0.26796195f, 0.03059787f, -0.09528372f, -0.03696667f, 
    -0.10564544f, -0.06172006f, 0.03707932f, -0.04689571f, -0.08295304f, 0.05465161f, 0.03706380f, -0.09137729f, 
    0.03511199f, 0.11584421f, 0.15209723f, 0.06757513f, -0.02191589f, -0.10220166f, -0.06409916f, -0.05447543f, 
    -0.05545435f, 0.07399737f, 0.04357106f, -0.02430951f, 0.16404146f, -0.28674054f, 0.05499147f, 0.03282208f, 
    -0.01332971f, 0.01611292f, -0.03106725f, -0.01700609f, 0.07899017f, 0.13314094f, -0.04445504f, 0.00790578f, 
    -0.24961217f, 0.14881758f, -0.08998302f, -0.04699944f, 0.02974305f, 0.08050244f, -0.02909737f, 0.04556665f, 
    0.00148786f, -0.02229317f, 0.09814006f, 0.11166962f, 0.20030379f, 0.08293597f, -0.11183847f, 0.10484327f, 
    -0.03801183f, 0.00164677f, 0.01139416f, 0.01607527f, -0.00092292f, 0.13207041f, 0.06956100f, 0.03426358f, 
    0.07242272f, -0.02775545f, -0.07393058f, -0.04081320f, -0.13028881f, -0.00949338f, 0.05652249f, -0.00872196f, 
    0.09264801f, -0.24391918f, -0.12940660f, -0.09877114f, -0.54455966f, -0.19653109f, -0.20145278f, -0.31036881f, 
    0.11323860f, 0.03100498f, -0.12541586f, 0.01191713f, 0.07432635f, -0.10026313f, 0.03582014f, 0.05635124f, 
    -0.61294156f, -0.39961722f, -0.09429260f, -0.04119501f, 0.10741401f, -0.13766730f, -0.01711698f, -0.14728782f, 
    -0.04743469f, -0.08856439f, -0.14112258f, 0.05808082f, 0.03422051f, -0.08970777f, 0.05165956f, 0.03798348f, 
    -0.07288836f, -0.11269522f, 0.09140055f, -0.02365084f, 0.02671650f, 0.13765182f, -0.04668629f, 0.05949683f, 
    0.14605449f, -0.01152595f, -0.07189806f, 0.19296880f, -0.01391114f, -0.01105218f, 0.00445171f, 0.05994128f, 
    0.03758971f, -0.03929649f, -0.12643290f, -0.04196199f, -0.24803598f, -0.13362530f, -0.21865547f, -0.14642999f, 
    0.01398595f, 0.04276197f, 0.00917298f, -0.01841064f, 0.04316530f, 0.01721906f, 0.02786428f, 0.06203348f, 
    0.33662558f, 0.06571328f, -0.06487956f, 0.17428392f, -0.05010339f, -0.13664916f, 0.00188582f, 0.01591353f, 
    -0.04346900f, 0.00336808f, -0.06683920f, -0.03484784f, 0.07215226f, -0.04059869f, -0.06403303f, -0.05589177f, 
    0.05783039f, -0.01367966f, -0.11466131f, -0.08501502f, 0.00952449f, 0.03773954f, 0.12446418f, -0.01947048f, 
    0.00595725f, 0.06259694f, 0.05738436f, -0.06806075f, 0.12334088f, 0.05914225f, 0.06578811f, 0.08807664f, 
    0.02745054f, -0.02747325f, 0.08511421f, 0.00499246f, 0.20894894f, 0.15023175f, 0.07761584f, 0.06106481f, 
    -0.00539603f, 0.00018054f, 0.11901158f, 0.05982841f, 0.05594682f, 0.04058563f, -0.10888978f, 0.11091733f, 
    -0.07990941f, 0.26885727f, 0.21620333f, -0.09225619f, 0.10579547f, 0.04226562f, 0.06894954f, 0.03017081f, 
    -0.06521722f, 0.00024031f, -0.00436217f, -0.02481426f, -0.03274919f, 0.04278047f, -0.01348439f, 0.06130969f, 
    -0.01970634f, 0.05021999f, 0.04534286f, 0.06392379f, -0.06834771f, 0.00913866f, 0.00376617f, -0.11231631f, 
    -0.32253218f, -0.33031815f, -0.11092673f, -0.18125522f, -0.10116425f, 0.01643479f, 0.01949218f, 0.09015054f, 
    -0.01587954f, 0.15688840f, 0.11543503f, 0.01123324f, -0.16941172f, -0.30407307f, -0.27592489f, -0.01919461f, 
    -0.02224478f, 0.04974655f, 0.01510768f, -0.09232095f, 0.00973396f, -0.23023163f, -0.08032264f, -0.17811239f, 
    -0.41741785f, -0.42832193f, -0.02643263f, -0.06236741f, -0.01582336f, -0.04830377f, -0.19926797f, -0.11549549f, 
    0.00246318f, 0.03360029f, -0.09244497f, -0.08250691f, -0.61943281f, -0.37502834f, 0.08724839f, -0.07301015f, 
    0.08868489f, -0.02429317f, 0.06993110f, -0.12130956f, 0.09706240f, 0.02016276f, 0.00704766f, 0.11880103f, 
    0.06376602f, 0.22619231f, -0.03029719f, -0.09179425f, 0.05186053f, -0.02789349f, 0.05608822f, 0.10603029f, 
    0.03974234f, -0.02674351f, -0.01270915f, 0.01718199f, 0.22291233f, 0.04774657f, 0.05201939f, -0.02178367f, 
    0.03873901f, -0.06672464f, 0.06804597f, 0.01393069f, 0.04218145f, -0.06884275f, 0.06161545f, 0.01193217f, 
    0.09149525f, 0.06455317f, -0.05690634f, 0.10827771f, -0.08014170f, -0.14758332f, 0.01747572f, -0.01385336f, 
    -0.08777986f, 0.07379647f, 0.05770231f, 0.04101241f, -0.14933844f, -0.06651311f, -0.17419779f, -0.29345736f, 
    0.00633945f, -0.10333194f, 0.07248375f, 0.14729467f, 0.05186059f, -0.00951971f, 0.00069220f, -0.01990801f, 
    -0.06328397f, 0.23023057f, -0.04451732f, 0.09056306f, 0.01827297f, 0.04774037f, 0.02054539f, 0.02013741f, 
    -0.00686287f, 0.04693977f, -0.13010372f, -0.01644461f, 0.02888549f, -0.12309913f, 0.08974852f, -0.10020789f, 
    0.06899888f, -0.06774146f, -0.04216581f, -0.00087021f, -0.03655804f, 0.02602557f, -0.08310984f, -0.06450067f, 
    -0.05302506f, -0.25158611f, -0.13013954f, -0.11423834f, -0.01965000f, -0.02260495f, 0.12173873f, 0.10377870f, 
    -0.07451577f, 0.05742157f, -0.09728692f, -0.03354619f, 0.13816191f, -0.25290009f, -0.09763636f, -0.04874688f, 
    -0.02346498f, -0.06398129f, -0.05904039f, -0.01195744f, -0.00278265f, 0.01976675f, 0.03014190f, 0.10842634f, 
    0.00345642f, -0.11671980f, 0.02386656f, -0.00064511f, 0.08826054f, 0.04924073f, -0.02459840f, -0.08723186f, 
    -0.02509981f, -0.24938726f, -0.01527270f, 0.06018432f, -0.22016264f, -0.38091728f, -0.02485520f, 0.12697776f, 
    -0.02702988f, -0.06263065f, 0.02774602f, 0.00747568f, 0.04658765f, 0.04576278f, 0.02399168f, -0.06140001f, 
    -0.27554455f, 0.24985263f, -0.12825544f, -0.03054379f, 0.13320209f, -0.02105878f, 0.09227314f, -0.03195732f, 
    0.05861960f, -0.08366574f, -0.05367959f, 0.02716995f, -0.31256336f, -0.07496978f, -0.02569691f, -0.06585132f, 
    0.04515308f, 0.02348649f, 0.02788755f, 0.00614459f, -0.02090121f, 0.07820994f, 0.05869240f, 0.00296575f, 
    0.12808308f, -0.13595662f, -0.07186555f, 0.22544661f, 0.07658494f, 0.01856523f, 0.01774167f, 0.00306285f, 
    0.01837266f, 0.00159467f, 0.11035832f, 0.06044807f, 0.30491969f, 0.04562936f, -0.29504782f, -0.02053799f, 
    0.01513117f, -0.08375572f, -0.05363017f, 0.02974960f, 0.00867232f, 0.03909897f, 0.05578301f, 0.06115665f, 
    0.14233665f, -0.04646676f, -0.15716584f, 0.04279873f, -0.16266511f, 0.01415314f, -0.04623480f, -0.17288326f, 
    -0.00922212f, -0.08509820f, -0.17722948f, -0.15987591f, 0.22373994f, -0.11624064f, -0.07591942f, 0.17572926f, 
    -0.00627516f, -0.11646125f, -0.00453323f, 0.07054152f, 0.08233082f, -0.02591053f, -0.01393519f, -0.07802965f, 
    -0.17467700f, 0.04288055f, -0.06455383f, 0.01328133f, -0.08271185f, 0.02509535f, -0.04460194f, 0.03828655f, 
    -0.02902893f, 0.03528348f, 0.04744703f, 0.09358935f, -0.11289933f, 0.20109580f, -0.01060406f, -0.01138404f, 
    0.05317899f, -0.08606140f, 0.02411477f, 0.07942308f, -0.04719308f, -0.02386080f, 0.08611245f, -0.06106112f, 
    0.44854870f, -0.39411435f, -0.14620462f, -0.06181556f, 0.04126581f, -0.15053700f, -0.03470566f, -0.01656834f, 
    -0.01779633f, -0.03105058f, 0.02883964f, 0.03580134f, 0.50728375f, 0.03559168f, -0.07542318f, -0.03067785f, 
    0.03027182f, -0.02145748f, -0.00181094f, 0.02436790f, -0.01502006f, -0.05957357f, 0.00574234f, 0.06090709f, 
    -0.19809562f, 0.16722341f, -0.02284677f, 0.12949796f, -0.07844166f, 0.02257394f, -0.04945894f, 0.03508469f, 
    -0.03443105f, 0.06178246f, -0.00791429f, -0.03028103f, 0.11942700f, 0.09161235f, -0.00414070f, 0.13687046f, 
    -0.02890793f, 0.05638374f, 0.06531915f, -0.02261412f, 0.07122733f, 0.08867415f, 0.06617022f, 0.01720368f, 
    -0.27602655f, 0.22556069f, 0.10153364f, -0.08374439f, -0.05363004f, 0.01118408f, -0.10825488f, -0.08498828f, 
    -0.01421117f, -0.03659138f, 0.01422707f, -0.00558445f, 0.02786701f, -0.13751279f, 0.05386121f, 0.00330640f, 
    0.13748753f, -0.08447114f, -0.15443221f, 0.11386836f, -0.04035316f, -0.00517889f, -0.04795107f, 0.08334877f, 
    -0.12315834f, -0.09262913f, -0.03495552f, -0.00928139f, 0.02633898f, 0.03060576f, 0.04291992f, -0.02270183f, 
    -0.05799530f, -0.06441513f, 0.05265519f, 0.01742717f, -0.14226417f, -0.06390651f, -0.03516579f, 0.10539591f, 
    -0.03400196f, 0.06264666f, -0.06442824f, -0.05628902f, -0.01147925f, -0.12133514f, -0.06862422f, 0.04397271f, 
    0.01951963f, 0.03113101f, -0.15489091f, 0.07724714f, -0.05633265f, -0.06485838f, -0.01397334f, 0.12578785f, 
    -0.02272737f, -0.07300176f, -0.04835237f, -0.07036696f, 0.07583340f, 0.02826371f, -0.01194182f, 0.05325921f, 
    -0.07686161f, -0.07702900f, 0.07531117f, 0.07060700f, -0.06462462f, -0.07360374f, -0.05442919f, -0.04253818f, 
    -0.41763097f, -0.03979345f, -0.01786480f, -0.08028798f, 0.02176696f, 0.13743368f, 0.01975662f, 0.12534818f, 
    0.04627613f, 0.00570623f, -0.12376262f, -0.12289418f, -0.00876951f, 0.05456695f, 0.01906740f, -0.17816390f, 
    -0.20553687f, 0.09827741f, -0.02133931f, -0.07140765f, -0.07268918f, 0.09437443f, -0.11875337f, 0.01427153f, 
    -0.00923281f, 0.12970082f, 0.00739317f, 0.10768735f, -0.02318151f, -0.04030343f, -0.06863909f, -0.02775098f, 
    -0.03126412f, 0.02110962f, 0.02562771f, -0.13100095f, 0.15019847f, 0.03605500f, 0.06109039f, -0.18716396f, 
    0.03889535f, 0.03817533f, -0.19728036f, -0.05715811f, 0.04541648f, 0.02791959f, 0.10051086f, -0.08222581f, 
    0.23973103f, 0.17400619f, 0.03319370f, -0.06879909f, -0.00365564f, -0.05339253f, -0.06942131f, 0.05261551f, 
    -0.00732601f, 0.10093366f, -0.02120884f, 0.02061776f, -0.09042630f, 0.03798462f, -0.03194273f, -0.04279437f, 
    -0.03399170f, 0.05666135f, -0.08033989f, -0.14195822f, -0.07600438f, -0.06553493f, 0.02708075f, -0.01727889f, 
    -0.06840714f, 0.25516948f, -0.17338625f, 0.22553140f, 0.05176611f, -0.02992336f, -0.06952556f, -0.14281751f, 
    0.03925260f, 0.02286650f, -0.02449319f, -0.00471473f, 0.03966445f, 0.07343567f, -0.04945295f, -0.10631863f, 
    -0.10654559f, -0.06676587f, 0.00035097f, -0.08811159f, 0.12752552f, 0.05254885f, 0.02266024f, 0.04039879f, 
    -0.05611968f, -0.04744137f, 0.05952241f, 0.08529978f, 0.01109662f, -0.03493204f, 0.00811435f, -0.04241382f, 
    0.02187067f, -0.07689980f, -0.10674916f, -0.01922792f, -0.17349766f, -0.00442462f, -0.08841960f, 0.05612155f, 
    0.21978642f, -0.13315561f, -0.04467431f, -0.07446559f, 0.04285445f, 0.05912073f, 0.02186113f, 0.02803025f, 
    -0.04123887f, -0.28514633f, -0.05492778f, 0.06603663f, -0.00633537f, 0.10485019f, 0.10760876f, 0.10749176f, 
    -0.05544532f, -0.03875300f, -0.02034136f, -0.04480262f, -0.26516557f, 0.19877090f, -0.08013622f, -0.00449137f, 
    0.11158020f, 0.04639464f, 0.07825460f, 0.08350512f, 0.03820050f, 0.01567068f, 0.04177686f, -0.02511376f, 
    0.04938458f, -0.02034054f, -0.01342153f, 0.04066485f, 0.01195458f, -0.01070544f, -0.03104657f, 0.12283909f, 
    0.03742275f, -0.13996446f, -0.05467921f, -0.01671086f, 0.19308080f, 0.07842806f, -0.00013185f, -0.08948101f, 
    0.03746538f, 0.15336837f, -0.08730073f, -0.01827941f, 0.17161359f, -0.00804485f, 0.11013699f, -0.00705832f, 
    0.05595284f, 0.19054838f, -0.04562381f, -0.00072468f, 0.07900122f, -0.10608403f, -0.01703969f, -0.13442533f, 
    -0.01634642f, -0.04832786f, 0.02513120f, -0.04711396f, 0.16324748f, -0.01146293f, 0.01177703f, 0.05631438f, 
    0.02344473f, 0.08781901f, 0.03083598f, -0.09011919f, -0.06532328f, -0.08133002f, 0.05170689f, -0.03209994f, 
    0.01931205f, 0.03575623f, 0.03989514f, -0.31317675f, -0.00164613f, -0.00019862f, -0.06465963f, -0.04213398f, 
    0.00815265f, -0.13504367f, -0.05875334f, 0.03557159f, -0.14320548f, 0.01582063f, 0.17910980f, 0.11091217f, 
    0.06442965f, 0.13492389f, -0.00602855f, 0.03846649f, -0.04300361f, -0.06747052f, 0.04843271f, 0.11838260f, 
    0.19711453f, 0.05285638f, -0.11278827f, 0.02630401f, 0.07523366f, -0.03089146f, 0.08356818f, 0.12464796f, 
    -0.05005437f, -0.00723831f, -0.02393596f, -0.08766888f, 0.14222123f, -0.11781983f, -0.08717891f, 0.17346790f, 
    -0.14732300f, 0.15930031f, -0.10356881f, 0.06707659f, -0.06445926f, -0.04849964f, -0.09934296f, -0.07785372f, 
    0.01136377f, -0.13962564f, -0.12729384f, -0.00823011f, 0.09035468f, -0.05731112f, 0.05429449f, -0.01960006f, 
    -0.07268197f, 0.05451375f, 0.14724034f, -0.00495951f, 0.14767674f, -0.27828363f, -0.02522734f, -0.17752926f, 
    -0.03101308f, 0.01470825f, -0.03537073f, 0.01108272f, -0.01675262f, 0.03560042f, -0.01615859f, -0.01679404f, 
    -0.16128360f, 0.25005931f, -0.05249421f, -0.27644283f, 0.04729262f, -0.01993053f, -0.00605647f, 0.10067809f, 
    0.05056924f, 0.09561415f, 0.06440700f, -0.01412181f, -0.19891702f, 0.06794787f, 0.22447574f, -0.02393641f, 
    0.09147284f, -0.11602198f, -0.04313162f, 0.06001971f, 0.05460809f, -0.10047246f, 0.06748646f, -0.08144686f, 
    -0.18201517f, -0.11879314f, 0.04243076f, 0.02119712f, 0.09964546f, -0.04736584f, 0.01330084f, 0.07464064f, 
    0.03108934f, 0.08236121f, 0.06977551f, 0.04292486f, -0.00836919f, -0.31347319f, 0.02826166f, -0.16955705f, 
    0.08353195f, 0.01907535f, 0.03927866f, -0.07017444f, -0.02247438f, 0.01641053f, -0.05317618f, -0.05025706f, 
    -0.24810506f, -0.05608851f, 0.06860130f, 0.09769548f, 0.10447719f, 0.03557978f, -0.02483246f, -0.06258264f, 
    0.01428524f, -0.00510382f, 0.04332295f, 0.13838291f, -0.33190480f, 0.19129512f, -0.11685593f, -0.04738422f, 
    -0.08164001f, -0.07496274f, 0.01350716f, -0.16520241f, -0.00664122f, 0.05363835f, -0.01438247f, -0.09746110f, 
    0.13263698f, -0.17216845f, 0.02631219f, 0.38345718f, 0.08280057f, 0.04942016f, -0.00747887f, -0.10630414f, 
    0.03426882f, 0.05086338f, -0.01006013f, -0.06413838f, 0.05191366f, -0.00587754f, 0.00840659f, -0.28358528f, 
    0.05289089f, -0.08898313f, -0.04592913f, -0.01666549f, -0.05734099f, -0.08160924f, 0.05329617f, -0.07833956f, 
    0.48909265f, 0.08167852f, -0.13915120f, -0.03293175f, -0.04763449f, -0.05303035f, 0.00092721f, -0.04946661f, 
    0.12708147f, 0.06126288f, 0.03114025f, -0.12347348f, 0.11487240f, 0.23301341f, 0.08813303f, 0.06331442f, 
    -0.05962142f, 0.04338732f, 0.04585856f, 0.00334003f, 0.06778498f, 0.07438736f, 0.12442151f, 0.03531476f, 
    0.05286606f, -0.16214034f, -0.12425818f, 0.04343055f, 0.07835706f, 0.00878040f, -0.01060058f, -0.04980793f, 
    0.00216013f, 0.01632507f, -0.10671841f, -0.00873145f, -0.18736903f, 0.13814071f, -0.07748996f, 0.07180033f, 
    0.07242654f, 0.03625773f, 0.12246007f, -0.02522737f, 0.16070278f, 0.10071581f, 0.03844156f, 0.10093417f, 
    -0.00954638f, -0.29754564f, -0.12448810f, 0.00225697f, 0.10294793f, 0.01057133f, -0.03294325f, -0.03760977f, 
    -0.02864687f, -0.01049364f, -0.02427431f, -0.02146645f, -0.18681006f, 0.09774075f, 0.04043387f, -0.07616009f, 
    0.03387520f, -0.00051479f, -0.20124356f, 0.04416280f, -0.00549833f, -0.07170635f, -0.04757074f, -0.10471052f, 
    -0.20494194f, -0.08688466f, 0.21421039f, -0.06998478f, 0.02208218f, 0.02238884f, -0.03678631f, 0.01285748f, 
    -0.03721939f, 0.02296690f, 0.06695565f, 0.12070624f, -0.00509303f, 0.10358835f, -0.06078452f, -0.17382309f, 
    -0.01055056f, -0.07730667f, -0.06192904f, -0.20977786f, 0.02813808f, 0.06715006f, -0.00746196f, -0.03758204f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04249519f, 0.00348452f, -0.01796172f, -0.02679906f, 0.00764642f, 0.01331544f, -0.02366329f, -0.04768506f, 
    -0.01372130f, -0.01751553f, 0.03661183f, 0.03554861f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
