#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.27308524f, -0.57984501f, 0.18689410f, -0.32549453f, 0.84750831f, 0.40197349f, 0.28761801f, 0.31524485f, 
    -0.02292924f, -0.30847681f, -0.11823900f, -0.27932546f, -0.41119680f, -0.18502869f, -0.20733137f, 0.23058571f, 
    0.11390420f, -0.13791066f, -0.00274860f, 0.00571550f, -0.10371173f, -0.05536806f, 0.07910989f, 0.00096369f, 
    -0.22901662f, 0.63201320f, 0.41378543f, -0.82793039f, 0.06947870f, -0.68977040f, 0.40829539f, 0.56082982f, 
    0.21229145f, 0.63386464f, -0.16399121f, 0.23352572f, 0.40221995f, -0.00025093f, 0.05094124f, 0.02083530f, 
    0.27679384f, -0.03971641f, 0.19291550f, 0.29293978f, 0.03759637f, 0.12083602f, 0.05464628f, 0.09843199f, 
    -0.00845412f, 0.17221066f, 0.14378126f, -0.35727850f, 0.47598413f, 0.20535205f, 0.26742917f, 0.30882880f, 
    -0.17727652f, 0.55270553f, -0.25955334f, -0.27799472f, 0.32484013f, -0.14323549f, 0.05164118f, 0.50222123f, 
    -0.28194928f, 0.01967342f, 0.27807233f, 0.15411451f, -0.43643552f, -0.19857302f, -0.00049850f, -0.15105557f, 
    0.07360110f, -0.39562440f, 0.10972453f, -0.26407558f, -0.95204026f, -0.22014914f, 0.38632467f, 0.34812108f, 
    -0.99133062f, 0.37131140f, 0.07332331f, -0.26586211f, -0.13936551f, 0.30045778f, 0.02633084f, -0.21357609f, 
    -0.23256725f, 0.02519158f, -0.10996205f, -0.00952863f, -0.24879995f, 0.10791444f, -0.31874990f, -0.40532535f, 
    -0.29160467f, -0.32946122f, 0.03232748f, -0.11737368f, -0.31968674f, 0.19157352f, 0.03777237f, -0.12796171f, 
    0.20075312f, -0.69642943f, 0.18694299f, -0.63444239f, -1.04358923f, 0.13549986f, 0.19277550f, 0.41950801f, 
    0.42191580f, 0.20227845f, -0.03837174f, 0.13061181f, -0.27634197f, 0.10207169f, 0.10470966f, -0.11987883f, 
    -0.02952278f, 0.00087830f, 0.31182843f, -0.07686237f, 0.13096799f, -0.89175749f, -0.51185429f, 0.00746420f, 
    -0.19693024f, -0.26831588f, -0.63608348f, -0.01781026f, 0.59487712f, -0.03693252f, 0.12198695f, -0.10936048f, 
    0.15973222f, 0.31531817f, -0.22384086f, -0.25010523f, 0.15660961f, 0.08782882f, 0.12413999f, -0.05315880f, 
    -0.26363435f, -0.05616914f, -0.18293640f, 0.26932263f, -0.00815048f, 0.05762152f, -0.64811403f, -0.81584209f, 
    0.00467062f, 0.59530169f, 0.35146153f, 0.51560861f, 0.67925799f, 0.28059223f, -0.13236196f, 0.06617911f, 
    -0.05329096f, 0.45908543f, 0.35256091f, 0.18266231f, 0.07923428f, -0.41410610f, -0.05277219f, 0.14243980f, 
    0.16629280f, -0.08389883f, 0.05486568f, -0.11189289f, -0.01644332f, -0.04593562f, -0.13916697f, -0.62089300f, 
    -0.59228969f, -0.61723179f, -0.02779431f, -0.43870351f, -0.08114422f, -0.41691267f, -0.17234345f, 0.52657628f, 
    0.23505005f, 0.15148625f, 0.23224214f, 0.06000371f, -0.29379565f, -0.35753879f, -0.17542429f, 0.35321897f, 
    0.29939428f, -0.06865969f, -0.21424972f, -0.00435049f, 0.09771159f, 0.00014424f, 0.14447466f, -0.05334235f, 
    0.78464848f, -0.30910382f, -0.56442702f, -0.20930433f, -0.09583763f, -0.45593518f, -0.44311827f, -0.18959449f, 
    0.32799342f, -0.40099135f, -0.40382805f, -0.24723883f, 0.37995017f, -0.01266417f, -0.03743746f, 0.23821521f, 
    -0.18332641f, 0.08029260f, 0.05179337f, -0.02962208f, 0.19339386f, 0.14110030f, 0.08014666f, 0.24148254f, 
    0.21400920f, -0.97373205f, 0.27625328f, -0.49780354f, -0.37564361f, -0.06034058f, 0.44720986f, 0.73588300f, 
    0.28000957f, 0.57827407f, 0.57148921f, 0.09241506f, 0.03033289f, 0.14780512f, 0.11189029f, 0.13787869f, 
    0.28982610f, 0.10921218f, -0.13400474f, 0.11534538f, -0.13935678f, -0.11938420f, -0.06041081f, -0.18238412f, 
    -0.06611462f, -0.17190756f, 0.60324317f, 0.79808569f, 0.91868156f, 0.60065514f, 0.29798952f, -0.30276680f, 
    0.17054380f, -0.34206396f, -0.37753841f, -0.24391371f, 0.26538634f, -0.01477719f, -0.07212771f, 0.45910662f, 
    -0.11087264f, 0.10444587f, -0.31140149f, -0.10080217f, 0.10365111f, -0.06313090f, -0.15189120f, 0.27477250f, 
    0.02239252f, 0.10419427f, 0.06038585f, -0.33858484f, 0.27584136f, 0.99418509f, 0.40331569f, 0.20048660f, 
    0.43547246f, 0.16562469f, 0.22636533f, -0.20978136f, 0.04938731f, 0.09922402f, 0.06193614f, 0.24296427f, 
    0.48652956f, 0.24468689f, -0.14399123f, 0.09915114f, -0.24126902f, -0.21823767f, 0.21844552f, -0.04633736f, 
    0.26308143f, 0.18379152f, 0.04573952f, 0.20142399f, 0.09704126f, -0.33553600f, -0.48852035f, -0.51274461f, 
    -0.55603856f, 0.13158776f, 0.54333031f, 0.04448289f, 0.28802529f, 0.24371985f, 0.02733676f, -0.29572240f, 
    -0.42913458f, -0.24772011f, 0.05276162f, -0.16533613f, 0.15241253f, -0.05715468f, 0.02743557f, -0.06102753f, 
    0.03162348f, 0.16445608f, 0.14716703f, -0.17694430f, 0.19010751f, 0.59766948f, 0.25833803f, -0.38777760f, 
    0.57883805f, 0.66828942f, 0.15959249f, -0.31126520f, -0.78325653f, -0.12296075f, 0.15348732f, 0.07823873f, 
    0.25400409f, 0.02990949f, 0.23128472f, -0.04528752f, -0.01464462f, -0.06079253f, 0.09419797f, 0.14275813f, 
    -0.08550172f, 0.01249388f, 0.05904036f, -0.16632323f, -0.07694836f, 0.11361567f, 0.98942477f, 0.04376503f, 
    0.39396963f, 0.97078902f, 0.49219626f, 0.34300208f, 0.06479713f, -0.19868559f, 0.39987600f, -0.12617770f, 
    -0.31350830f, 0.15015949f, -0.19614749f, 0.07166316f, -0.16428304f, 0.15798287f, 0.30917320f, -0.05251353f, 
    0.01906787f, 0.02982548f, 0.00073921f, 0.02811752f, 0.18335685f, -0.05124473f, 0.19994290f, 0.47219795f, 
    0.19832967f, -0.04783607f, 0.63201720f, 0.45303541f, 0.24160179f, 0.15353410f, 0.58266991f, 0.65261561f, 
    -0.40254134f, -0.45574048f, -0.18849461f, -0.07944079f, -0.16980612f, -0.10544871f, -0.41875607f, -0.10376811f, 
    0.14475173f, 0.00321774f, 0.14707020f, 0.06148906f, -0.39153758f, -0.22477674f, 0.10191935f, 0.04553057f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.24606597f, 0.38807508f, 0.06037843f, 0.04365207f, 0.24112871f, -0.03814797f, 0.24790718f, 0.23737372f, 
    0.16214287f, -0.24310559f, -0.04585304f, 0.01596385f, -0.01896928f, 0.08866527f, 0.24307300f, 0.02082932f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00394986f, 0.06699432f, 0.12526533f, -0.23094770f, 0.04084668f, 0.10883621f, -0.15828475f, -0.10697790f, 
    0.05593929f, 0.04377954f, -0.18124579f, -0.01319024f, 0.19297265f, -0.03736018f, -0.06907632f, -0.03645438f, 
    -0.06229713f, -0.09728198f, -0.08785050f, 0.12200651f, -0.12095824f, 0.05392540f, 0.04666075f, 0.09885246f, 
    -0.30162752f, 0.38322240f, 0.18525982f, 0.14243723f, 0.18327700f, 0.01314273f, -0.22287811f, -0.15141556f, 
    0.10164922f, -0.00339799f, 0.22372982f, -0.20090590f, 0.49791071f, -0.17118590f, -0.17080426f, -0.16110438f, 
    0.02139851f, 0.01606441f, -0.05284970f, -0.08401111f, 0.00804413f, 0.05949345f, -0.00072044f, -0.06238811f, 
    0.33588693f, 0.08192912f, -0.27927461f, -0.27171057f, -0.04455875f, -0.09928326f, 0.18943371f, 0.04392730f, 
    -0.04244900f, 0.04907313f, 0.04769814f, 0.09644273f, -0.27850744f, -0.14231598f, -0.18668938f, 0.13986126f, 
    0.01485856f, -0.02780132f, 0.18477291f, -0.05204273f, 0.09972616f, -0.06775079f, 0.02845119f, 0.08472079f, 
    0.31084594f, -0.09047061f, -0.21808831f, 0.18553904f, 0.11985105f, -0.11670601f, -0.22880523f, 0.03753145f, 
    -0.10740916f, -0.19003364f, 0.02534801f, 0.17415193f, -0.52520090f, -0.34038523f, -0.19892740f, -0.16558667f, 
    0.07364354f, 0.03192183f, 0.13124152f, -0.06600821f, 0.08240939f, 0.05999655f, -0.06987961f, 0.05321077f, 
    -0.58957350f, 0.14786924f, 0.11547612f, -0.23583579f, -0.13423322f, -0.04238405f, 0.05373591f, -0.02619541f, 
    -0.05871709f, 0.04353028f, 0.09576743f, -0.09465961f, -0.00599736f, 0.06954550f, -0.06697006f, -0.10222661f, 
    0.11730327f, 0.07240223f, 0.03551548f, 0.14786519f, 0.04607500f, 0.02442934f, -0.01412182f, -0.09609923f, 
    0.40888521f, 0.15708424f, -0.11780680f, 0.15145586f, -0.02733455f, 0.10274071f, 0.01663198f, -0.01792000f, 
    0.15515754f, 0.10750911f, 0.04261218f, 0.11385932f, 0.07041404f, 0.11557750f, 0.19001873f, 0.17621209f, 
    -0.13589011f, 0.15634130f, 0.03491002f, 0.02011967f, 0.05808348f, 0.12967135f, 0.09857239f, 0.04826972f, 
    0.13073096f, -0.11763542f, 0.09604359f, -0.16326723f, -0.03118419f, 0.00702981f, -0.04940999f, 0.05142523f, 
    0.09180889f, -0.05846796f, -0.08827636f, -0.16054431f, 0.15803511f, -0.20064418f, 0.16087911f, 0.22580981f, 
    -0.06072064f, -0.09842265f, -0.06313480f, -0.09158930f, 0.06517781f, 0.23508902f, 0.01875092f, 0.03447497f, 
    0.29449931f, -0.11819000f, 0.00813336f, 0.38843575f, -0.02137679f, 0.05256230f, -0.10953391f, -0.14893469f, 
    0.04970913f, 0.06548457f, -0.08213970f, 0.05836374f, 0.08108195f, 0.22797775f, -0.18787216f, 0.30086401f, 
    0.14521831f, 0.00737720f, -0.08606379f, 0.06131554f, -0.00202673f, 0.02629732f, 0.03687276f, -0.13645536f, 
    -0.07566668f, 0.47444323f, 0.18922639f, 0.16162993f, 0.17470351f, -0.08821397f, -0.04022587f, 0.03485205f, 
    -0.14127794f, -0.03758570f, -0.20982604f, 0.03530741f, -0.13192496f, 0.53388453f, 0.08408297f, 0.11990709f, 
    0.08313308f, -0.05375950f, 0.15443003f, -0.02445379f, 0.03772187f, 0.09715813f, 0.10497916f, -0.00640315f, 
    -0.14296135f, 0.12588623f, 0.06180947f, 0.07136092f, -0.06911367f, -0.05685771f, 0.06243892f, 0.03763473f, 
    0.16443399f, 0.03544685f, 0.00003898f, 0.19095388f, 0.35794461f, 0.15246370f, 0.05869720f, -0.26799193f, 
    0.22229302f, 0.03242001f, 0.08257208f, -0.16753200f, 0.04255709f, -0.05934980f, -0.06304605f, -0.00759764f, 
    0.50185657f, -0.03022233f, -0.27340266f, -0.03111877f, -0.00378154f, 0.01546674f, 0.06028156f, -0.03895919f, 
    -0.13690342f, -0.07588667f, 0.11712822f, 0.03798731f, -0.05510843f, -0.02519196f, -0.25979322f, 0.11828382f, 
    0.20637077f, 0.25435305f, 0.12681019f, -0.14622207f, 0.11752427f, 0.06070157f, -0.02283645f, -0.03083459f, 
    0.24464208f, -0.19914371f, 0.08653424f, -0.11422758f, -0.02070021f, 0.13355683f, 0.11916683f, 0.03118483f, 
    0.13522649f, -0.04220336f, 0.06144704f, 0.05405626f, -0.17479663f, 0.03146513f, 0.00821683f, -0.04007664f, 
    -0.03442220f, -0.10241631f, -0.01920553f, -0.13126637f, 0.16543992f, 0.16049802f, -0.05270020f, -0.12196973f, 
    -0.47809160f, 0.29729718f, -0.00988449f, -0.04683137f, 0.08356297f, 0.00539888f, -0.03904081f, 0.14987846f, 
    0.10027652f, -0.08447368f, 0.20803897f, 0.11145373f, 0.22322159f, -0.16052054f, 0.12722063f, 0.01447177f, 
    -0.09827318f, 0.01695240f, 0.07156023f, 0.11440854f, -0.15675549f, -0.04239522f, -0.04486055f, -0.09103461f, 
    0.37210348f, 0.39170322f, -0.24733463f, -0.09755494f, 0.05136451f, 0.13851108f, -0.09238276f, -0.05569003f, 
    -0.02295578f, 0.12493256f, -0.10393963f, 0.28113383f, 0.22001162f, -0.09326772f, 0.16426069f, 0.12004258f, 
    -0.05185124f, 0.12348896f, 0.05184757f, 0.08785253f, 0.06606045f, 0.07167854f, -0.09778754f, 0.04585534f, 
    0.16910008f, 0.11364325f, 0.03301885f, 0.16759275f, 0.12408954f, 0.07004138f, 0.07178245f, -0.16334574f, 
    0.04212106f, -0.07028255f, 0.11421690f, -0.08072591f, -0.06782921f, 0.21332800f, 0.10206703f, -0.20732233f, 
    0.04394307f, -0.05132545f, 0.10833300f, -0.03643132f, 0.13406351f, 0.08795308f, 0.25359485f, 0.11198907f, 
    -0.31022438f, 0.06489854f, 0.03423974f, -0.29082978f, 0.16263004f, 0.04217947f, 0.07113238f, -0.02855005f, 
    0.13455848f, 0.11273300f, -0.00948805f, -0.01877869f, -0.31732684f, 0.24407059f, 0.17437246f, -0.25271535f, 
    -0.03001608f, 0.18486439f, -0.05313063f, 0.10325669f, -0.09353070f, -0.02026666f, 0.05641746f, -0.03301885f, 
    0.11370217f, -0.25147459f, -0.00053401f, -0.03844282f, -0.04470057f, 0.25419399f, 0.06671631f, 0.18697558f, 
    0.08263882f, 0.11867914f, 0.24308069f, 0.04027425f, 0.03149984f, -0.12529890f, 0.12184250f, -0.19768476f, 
    -0.10779494f, 0.02950093f, 0.08831015f, -0.01249792f, 0.01656778f, 0.09883196f, 0.00213380f, -0.12264404f, 
    0.14144000f, -0.14286290f, -0.18157446f, -0.11483315f, -0.03259590f, 0.08448083f, 0.19062953f, -0.07261402f, 
    -0.19795242f, 0.17550331f, -0.17199074f, -0.12935351f, 0.16811235f, -0.14858590f, -0.04802091f, 0.26643646f, 
    -0.11273026f, -0.01093077f, -0.01507319f, 0.23554301f, 0.12383292f, 0.01820103f, 0.00002477f, 0.02408901f, 
    -0.54489410f, -0.20014079f, 0.45840454f, 0.09668737f, 0.05920948f, -0.03781876f, -0.07677604f, -0.02905161f, 
    0.02177925f, -0.03016199f, -0.21904412f, 0.06094960f, 0.27770081f, 0.08001520f, 0.10947295f, 0.19749086f, 
    0.04491677f, -0.11235606f, 0.02194005f, 0.17611311f, -0.13962798f, 0.01918195f, -0.11004702f, 0.01759232f, 
    -0.23782341f, 0.29025245f, -0.05168842f, -0.18242657f, 0.04200191f, -0.04849206f, 0.08065882f, 0.14653790f, 
    0.02017214f, 0.12305497f, -0.13277622f, -0.05373568f, 0.26710451f, 0.04430056f, -0.18224300f, 0.25025967f, 
    0.10656964f, 0.17917097f, -0.04561504f, 0.11541513f, -0.12053389f, 0.11825225f, 0.04209482f, -0.00968416f, 
    0.37767804f, -0.06334953f, -0.06645416f, 0.18577965f, -0.00099225f, 0.01446031f, 0.01995141f, -0.08762364f, 
    -0.11236086f, 0.00566752f, 0.06075503f, -0.09971776f, 0.32203093f, 0.15971614f, -0.04765629f, -0.03172791f, 
    0.06033212f, 0.13665114f, 0.07421052f, -0.10536677f, 0.17449036f, 0.08437461f, 0.06155260f, 0.11852126f, 
    -0.29033962f, 0.02797046f, 0.29442966f, -0.03177784f, -0.22044350f, -0.23267339f, 0.13433182f, 0.18452531f, 
    0.03241152f, 0.05186817f, 0.11573336f, -0.19434787f, -0.24881290f, 0.20017855f, -0.11778187f, 0.00187177f, 
    -0.04979747f, -0.05340158f, 0.07627420f, -0.11122364f, -0.04797963f, -0.14832263f, 0.15883040f, 0.10710882f, 
    -0.23982517f, -0.04365310f, 0.17706665f, 0.03266057f, 0.02808155f, -0.01052560f, 0.05538861f, 0.00098997f, 
    -0.11391842f, -0.00680290f, 0.11623913f, 0.29903185f, 0.01824172f, 0.13920096f, 0.16087419f, -0.07191072f, 
    -0.09969409f, 0.08727584f, -0.07657299f, 0.03767178f, -0.14448804f, -0.13444802f, -0.06581115f, -0.04344542f, 
    0.10878880f, 0.20798400f, -0.18328431f, 0.15163058f, -0.12336076f, 0.12072342f, 0.03028679f, 0.14940761f, 
    -0.17396539f, -0.08295994f, -0.02667158f, -0.12423678f, 0.15125875f, 0.15170464f, -0.06418266f, 0.26890743f, 
    -0.05075877f, 0.03781316f, 0.19682319f, -0.14085850f, 0.07427388f, 0.01079090f, 0.00799923f, 0.34787524f, 
    0.30332115f, -0.00934649f, -0.06475872f, 0.08635060f, 0.01158734f, 0.03488543f, -0.09806349f, 0.03442869f, 
    -0.15908356f, -0.02813477f, 0.12358190f, 0.08995382f, -0.22322351f, -0.23746656f, 0.23522435f, 0.08324294f, 
    0.07724770f, 0.21895041f, -0.03671771f, 0.27537197f, 0.04129487f, -0.04425982f, 0.00454623f, 0.01486351f, 
    0.36053762f, 0.08007594f, -0.12253930f, -0.06028378f, -0.02011091f, 0.16410691f, 0.16536421f, 0.15505606f, 
    0.16493519f, 0.18369712f, -0.01747981f, 0.02561091f, 0.02483048f, 0.02669845f, 0.12180963f, 0.30960929f, 
    0.01066105f, 0.03398462f, 0.09824983f, 0.13824603f, 0.15573175f, 0.00422569f, 0.29319808f, -0.01757676f, 
    -0.09251851f, 0.21498260f, -0.08815648f, -0.17202315f, 0.13303603f, 0.12181349f, 0.11300833f, 0.08342669f, 
    0.17233589f, 0.14606979f, 0.10583562f, -0.08821973f, 0.01750067f, 0.08948963f, -0.05644693f, -0.13901593f, 
    0.11639631f, 0.02174493f, 0.07881932f, 0.11345949f, -0.14600343f, -0.00359213f, -0.01616474f, 0.12045430f, 
    0.40529069f, -0.04688431f, -0.14134227f, 0.30499217f, 0.11991405f, -0.07736544f, -0.06511557f, 0.06865964f, 
    0.09674323f, -0.09665025f, 0.06153269f, 0.10023332f, -0.16357325f, -0.05166172f, 0.05931005f, -0.06107420f, 
    0.09520288f, -0.11455439f, 0.11583865f, 0.03572822f, -0.00002483f, 0.04789673f, -0.05995989f, 0.02444824f, 
    -0.22547518f, -0.24594973f, 0.21806848f, -0.02815255f, 0.03177753f, 0.07266422f, 0.03525638f, 0.12058234f, 
    -0.00529829f, 0.08086493f, 0.08079270f, -0.01001020f, 0.20035626f, -0.27919012f, -0.26615456f, -0.12429480f, 
    -0.01735248f, 0.09421225f, 0.06387522f, 0.20213662f, -0.09986219f, 0.01572092f, 0.06337470f, 0.03350301f, 
    -0.19581699f, 0.04573041f, 0.14642824f, -0.49984863f, 0.09971534f, 0.01184045f, -0.06444722f, -0.07487617f, 
    0.07996350f, -0.08469649f, -0.00784023f, 0.07201442f, 0.08153700f, -0.11388966f, -0.11421432f, -0.11275525f, 
    0.03733001f, 0.00317506f, -0.04112955f, -0.08104438f, 0.06240302f, 0.11209249f, 0.07475107f, 0.03263787f, 
    0.18017599f, -0.13198893f, -0.11991370f, -0.26878974f, 0.05857622f, -0.02487829f, -0.02053025f, 0.11409244f, 
    0.08782653f, 0.05639263f, 0.14347723f, 0.05189877f, -0.20320381f, 0.43537933f, -0.13151324f, -0.19942783f, 
    -0.02201726f, 0.10714439f, 0.02480750f, -0.07574464f, 0.12556031f, 0.12222861f, 0.12552021f, 0.07501238f, 
    -0.29949260f, 0.05339905f, -0.00034259f, -0.27849489f, 0.06391352f, -0.02113655f, 0.07104323f, -0.15717775f, 
    -0.00883216f, -0.00055988f, 0.12148677f, -0.04906223f, -0.30700031f, -0.10987847f, -0.21651642f, 0.15664081f, 
    0.06408818f, -0.09524725f, -0.12328896f, -0.14184482f, 0.15221220f, 0.09467547f, -0.03071712f, 0.25343001f, 
    -0.23665182f, -0.17759754f, 0.26774290f, 0.04950910f, -0.17386407f, 0.02504752f, -0.04863622f, 0.02754235f, 
    0.04422920f, 0.06247712f, 0.06952872f, -0.14880359f, 0.36367840f, -0.03066741f, -0.20012601f, -0.09207600f, 
    0.03323328f, -0.10531390f, 0.05413371f, -0.01836140f, 0.00104682f, 0.11806722f, -0.09041805f, 0.08043856f, 
    -0.16059290f, -0.08232472f, 0.03737758f, -0.00317926f, 0.06231301f, -0.06927179f, 0.03152138f, -0.01857924f, 
    -0.02920098f, -0.03214404f, 0.09636296f, -0.18154964f, 0.16816796f, 0.03006801f, 0.05397688f, 0.00966330f, 
    -0.01340257f, 0.02126332f, 0.11441956f, 0.01502186f, -0.07633717f, 0.02116350f, -0.05988120f, 0.09687798f, 
    0.08248035f, 0.07469904f, 0.01528067f, -0.02592116f, 0.08959807f, -0.05992637f, -0.01795882f, 0.01249951f, 
    -0.11814872f, -0.01316104f, -0.01185305f, -0.12040796f, -0.02590618f, 0.23407510f, 0.18962505f, 0.18486898f, 
    -0.23497300f, -0.01985452f, -0.10933082f, 0.10563730f, 0.06961925f, 0.12371077f, 0.03297887f, -0.12277456f, 
    0.09279514f, -0.01268569f, -0.09535635f, 0.09676092f, -0.06877985f, 0.02136501f, 0.12166866f, -0.03672425f, 
    0.06403980f, 0.03153182f, -0.05960277f, 0.02527457f, 0.44769347f, 0.13815582f, 0.00754176f, -0.15006074f, 
    0.03942462f, -0.07223428f, -0.03648195f, 0.01805151f, 0.07307839f, -0.01004780f, 0.00456529f, -0.01465658f, 
    0.06993444f, 0.04221536f, 0.19557171f, -0.03821283f, 0.16389675f, -0.00314991f, 0.03177095f, -0.02434319f, 
    0.03888639f, 0.06560222f, -0.10415870f, -0.01310520f, 0.30851710f, 0.53086936f, 0.05830618f, -0.07466220f, 
    -0.05903116f, 0.10691437f, 0.01459594f, -0.02171116f, -0.07566056f, -0.01130322f, -0.04070431f, -0.05555189f, 
    0.32080117f, -0.13296099f, -0.23860994f, 0.09457299f, -0.16758323f, 0.06147231f, -0.09260333f, 0.03312772f, 
    -0.03206358f, -0.12412044f, 0.15859918f, -0.14858319f, -0.18349087f, -0.13580844f, 0.08048964f, 0.02426452f, 
    -0.02894463f, 0.06873253f, 0.19812940f, -0.06873225f, 0.09875796f, -0.00032873f, 0.03639195f, -0.07742117f, 
    0.39838418f, 0.12454099f, 0.14291069f, -0.00508208f, -0.01884130f, -0.13242948f, 0.04463034f, -0.20269519f, 
    0.13104817f, 0.13502844f, 0.00909717f, 0.03188583f, 0.21468231f, -0.35852310f, 0.04878673f, 0.29849786f, 
    0.08300146f, -0.08370598f, 0.07268331f, -0.03728479f, 0.01286629f, 0.06200856f, -0.03886127f, -0.10877910f, 
    0.09418254f, -0.30712667f, -0.09706084f, 0.17022300f, -0.13744144f, -0.01421777f, -0.02015896f, 0.02012713f, 
    0.04659048f, 0.10915144f, 0.00093123f, 0.06099240f, 0.09463190f, -0.07346515f, -0.16852352f, -0.13128684f, 
    -0.05906960f, 0.11126406f, 0.03168738f, 0.12712516f, 0.01943794f, -0.07539272f, 0.04754743f, 0.01553558f, 
    -0.31002808f, -0.10086918f, 0.26247606f, -0.20612349f, 0.04344415f, 0.05639024f, -0.11205076f, -0.06711155f, 
    0.14795892f, 0.05476123f, -0.04788564f, 0.06452089f, 0.33784917f, -0.23639537f, -0.16670656f, -0.35816687f, 
    -0.02709519f, 0.01972927f, -0.00307569f, -0.01325930f, -0.18461208f, 0.02138259f, -0.07899769f, 0.08664589f, 
    -0.26265305f, 0.02253748f, 0.09708283f, 0.05971206f, 0.15964618f, 0.06270194f, -0.03221114f, -0.11787923f, 
    -0.05532388f, 0.05286991f, -0.01212640f, -0.05049095f, -0.27519390f, -0.08550611f, -0.01523623f, 0.18912849f, 
    0.20773675f, -0.00616792f, 0.08074479f, 0.12186384f, 0.09749224f, -0.03426132f, -0.02023208f, -0.10947025f, 
    -0.30717400f, 0.03133751f, 0.33975005f, -0.12723461f, 0.02204357f, -0.13569777f, -0.06227525f, -0.06080133f, 
    0.18720336f, 0.11653821f, 0.04837825f, 0.05508472f, -0.20051886f, 0.04427015f, -0.04110705f, 0.00973379f, 
    0.03027195f, -0.04073061f, -0.03600024f, 0.22311419f, 0.16469575f, -0.00837414f, 0.04036969f, 0.03665829f, 
    -0.50531977f, 0.21031398f, -0.13207437f, -0.12270430f, 0.12008042f, 0.03686810f, -0.08224332f, 0.04670620f, 
    -0.07302579f, -0.00327073f, 0.03568032f, 0.14156494f, 0.25339311f, -0.05949745f, -0.26446304f, 0.03839089f, 
    0.19043432f, 0.19011664f, 0.04806758f, 0.17057385f, 0.15959367f, -0.05809364f, 0.03811710f, 0.16684517f, 
    0.18657129f, -0.15932494f, 0.10659190f, 0.02434351f, 0.01785255f, 0.14615700f, 0.04641907f, -0.17550376f, 
    0.08151776f, 0.10108927f, -0.07823636f, -0.08868247f, -0.13199386f, 0.30627647f, 0.05637727f, -0.37700349f, 
    0.00537257f, 0.15144290f, 0.08562018f, 0.06738340f, 0.10931628f, 0.01387976f, -0.05634694f, 0.10310767f, 
    0.22052430f, 0.01753247f, 0.03708941f, 0.17628381f, 0.01435209f, -0.11844926f, 0.08005647f, -0.01590722f, 
    0.09286474f, -0.00851755f, 0.12864625f, -0.06269442f, -0.34855545f, 0.06717896f, 0.15224516f, -0.05837677f, 
    -0.01038315f, 0.13927861f, 0.12546542f, -0.14089540f, -0.02395220f, -0.22790742f, 0.02274035f, 0.08970705f, 
    0.03956901f, -0.08605184f, -0.03645483f, -0.28322443f, -0.06983518f, 0.18043798f, 0.06550576f, 0.18439476f, 
    0.01366710f, 0.03776193f, 0.01688098f, -0.00765215f, 0.43911198f, -0.37407297f, 0.23967950f, 0.00234669f, 
    -0.01929491f, 0.09747745f, 0.02727996f, -0.12583140f, 0.07635938f, -0.00734400f, -0.08534049f, 0.09558521f, 
    0.39155012f, -0.22691822f, -0.14069222f, 0.48428881f, -0.03336165f, -0.04985023f, -0.18749699f, -0.15683097f, 
    -0.08210718f, -0.03707018f, -0.03348343f, 0.12389309f, 0.14772113f, -0.00459846f, 0.01323309f, 0.04425391f, 
    0.04770681f, 0.01650174f, -0.14660861f, -0.02834252f, 0.15108779f, -0.07836942f, 0.02589089f, 0.08025425f, 
    0.00656873f, -0.08164573f, 0.03477952f, -0.08051616f, -0.03576591f, 0.04912074f, 0.00674068f, -0.02739850f, 
    -0.04468120f, 0.03819920f, -0.05208341f, -0.03902489f, 0.01818045f, 0.05421796f, -0.00615893f, -0.03431591f, 
    -0.02230124f, 0.06273459f, 0.00723208f, -0.02218030f, 0.03512298f, -0.01361699f, 0.03964222f, -0.00866757f, 
    -0.01265927f, 0.04495065f, 0.00966081f, -0.06892633f, -0.07148398f, -0.03079461f, 0.04796435f, -0.06379299f, 
    -0.04658302f, 0.00588442f, -0.01995727f, 0.06043731f, -0.03274130f, 0.03288702f, 0.01602687f, -0.07728423f, 
    -0.03277083f, 0.01610834f, -0.05473854f, -0.05669325f, -0.03460392f, -0.04878315f, 0.01735241f, -0.05220427f, 
    -0.03156010f, -0.01405730f, -0.00463598f, 0.03526744f, -0.07176504f, -0.07435840f, 0.05626640f, 0.02631991f, 
    0.04505626f, -0.07028887f, 0.03897341f, -0.03637668f, -0.07757486f, -0.02471642f, -0.06205031f, 0.03539360f, 
    0.05639321f, 0.03043463f, 0.00682164f, -0.01518852f, -0.06355850f, 0.03918278f, 0.01873223f, -0.06383285f, 
    -0.04102579f, -0.02730247f, 0.06307627f, -0.06147921f, -0.03155029f, -0.06016665f, 0.05003892f, -0.07939371f, 
    -0.07919057f, -0.02186954f, -0.05071225f, -0.02729242f, 0.03464453f, 0.01516595f, 0.02728622f, -0.01998882f, 
    0.01211928f, 0.00538423f, -0.03239654f, 0.03244317f, 0.01430281f, 0.03738541f, -0.06367959f, -0.01556068f, 
    -0.00989258f, -0.04954642f, -0.03202248f, 0.03706435f, -0.03477226f, -0.00296343f, -0.07023319f, -0.03223177f, 
    -0.01563654f, 0.02991767f, -0.05877430f, 0.02749984f, 0.00697191f, 0.05034576f, 0.06226621f, -0.02341032f, 
    -0.06748082f, -0.02828967f, -0.00154818f, 0.03435176f, 0.05248095f, 0.01825047f, 0.00807737f, -0.05828133f, 
    -0.00737276f, -0.04677379f, -0.00140120f, -0.01981681f, -0.06093795f, 0.01962404f, 0.04199381f, 0.04505457f, 
    -0.02607640f, 0.01672134f, 0.00684331f, 0.05823329f, -0.02747340f, -0.04159506f, 0.02231518f, 0.05633425f, 
    0.01738818f, 0.06350140f, -0.06459700f, 0.04250496f, -0.00999182f, -0.02018977f, -0.03076520f, 0.02657652f, 
    -0.06276355f, -0.05188160f, -0.00664345f, -0.00868333f, 0.03014618f, 0.00497768f, 0.05211956f, -0.08156399f, 
    -0.04324575f, -0.06917797f, 0.05213955f, 0.04957855f, 0.00800042f, -0.03551354f, 0.01082956f, -0.02154749f, 
    -0.00235119f, -0.01172090f, -0.01896717f, 0.05225400f, -0.05330870f, 0.04215714f, 0.02318031f, 0.00260917f, 
    0.04947264f, -0.01261558f, -0.01746078f, 0.00660658f, -0.01894773f, 0.00489622f, 0.02335789f, 0.02021709f, 
    -0.06212492f, -0.02028926f, -0.06966443f, -0.02168496f, 0.02420689f, 0.01292094f, 0.05005220f, 0.06432566f, 
    0.03669816f, -0.04015025f, 0.00137750f, -0.07587910f, 0.04353125f, -0.03270266f, -0.01030506f, -0.03506915f, 
    -0.35981521f, -0.28751922f, 0.14678317f, 0.12410662f, -0.11513392f, -0.05837899f, 0.14258835f, 0.19619815f, 
    0.16035078f, 0.02794095f, 0.12706053f, -0.03685655f, -0.08420624f, 0.11551921f, -0.18310179f, 0.01077057f, 
    0.18053932f, 0.02366666f, 0.01523165f, -0.10804833f, -0.02281614f, 0.03614435f, -0.12635304f, 0.05261750f, 
    -0.08201420f, -0.14111522f, 0.25279599f, -0.00417437f, 0.02879594f, -0.01377483f, -0.02876931f, -0.06388946f, 
    -0.02960151f, -0.03462900f, 0.05292375f, 0.02768541f, -0.34876090f, 0.31987262f, 0.00478919f, -0.13752306f, 
    0.05800293f, 0.01213749f, 0.11414588f, -0.01447011f, -0.02881096f, 0.01014747f, -0.02548873f, 0.06095055f, 
    -0.04852209f, -0.08340957f, 0.12976758f, 0.34404901f, 0.15111798f, -0.01892433f, 0.08484398f, -0.00715507f, 
    -0.02658449f, -0.10139556f, -0.01135288f, 0.08470339f, -0.47510403f, 0.20557907f, 0.06268454f, -0.26170188f, 
    -0.18638255f, -0.05087745f, -0.01686769f, -0.00998003f, 0.00895797f, 0.16746837f, 0.10939202f, -0.11557030f, 
    -0.27922934f, 0.09420073f, 0.11685023f, -0.08241631f, 0.05374419f, 0.10817637f, 0.03226762f, 0.01315035f, 
    0.01896005f, 0.15335493f, 0.06077274f, 0.14033297f, 0.38034606f, 0.11443622f, -0.12135097f, -0.10796149f, 
    -0.14945816f, 0.02087397f, -0.02142253f, -0.00516077f, 0.15966004f, 0.14356524f, 0.01828415f, -0.03119051f, 
    0.14444156f, 0.29570574f, 0.08255705f, -0.01947585f, 0.12657304f, -0.03103442f, 0.06498086f, -0.12375589f, 
    0.01102567f, 0.01389925f, -0.04563864f, -0.09525539f, -0.36792374f, 0.05967154f, 0.00911036f, -0.05090080f, 
    -0.14392315f, -0.05842916f, -0.06224504f, 0.03436267f, -0.03737858f, 0.02256147f, 0.06008017f, 0.02107723f, 
    0.27814507f, -0.14565268f, 0.05271983f, 0.18070540f, 0.09081375f, -0.02965290f, 0.04454907f, 0.07811783f, 
    0.05802337f, 0.05412972f, 0.11560212f, -0.14703724f, -0.14331418f, -0.22999169f, 0.17171824f, 0.05587576f, 
    0.07530876f, -0.11308658f, 0.11315604f, -0.09771129f, -0.04268422f, -0.05316857f, 0.14044350f, -0.03820843f, 
    -0.23225862f, 0.07087764f, 0.09360109f, 0.07319479f, -0.13526392f, -0.02871197f, 0.02178892f, -0.19893844f, 
    -0.07218718f, 0.08697291f, 0.03836703f, -0.08204497f, 0.40173757f, -0.16942713f, 0.01255052f, 0.36700380f, 
    0.02046579f, 0.04572645f, 0.04799775f, 0.00750756f, 0.03990187f, -0.08466985f, -0.03050568f, 0.04599711f, 
    0.15487966f, -0.01708139f, 0.14536792f, -0.01057893f, 0.04571263f, -0.01505417f, -0.01061069f, 0.13726938f, 
    0.05379351f, 0.05891013f, -0.06225091f, 0.03172835f, 0.10942923f, -0.20436560f, 0.24019682f, -0.32028961f, 
    -0.03031298f, 0.03935894f, 0.09968248f, 0.05842550f, 0.11209726f, -0.02504354f, 0.05070100f, -0.00691136f, 
    -0.02998697f, 0.06048776f, -0.00506179f, 0.01560027f, -0.04226530f, -0.02542447f, -0.04389063f, -0.07446769f, 
    -0.06362833f, -0.00416428f, -0.03188396f, -0.07677674f, -0.00575846f, -0.05444648f, -0.06166721f, 0.05461394f, 
    -0.01784054f, 0.03887626f, -0.01892913f, 0.01845342f, -0.04513089f, -0.03948689f, -0.02355389f, -0.03363337f, 
    -0.02401736f, 0.05210519f, -0.00188392f, -0.04598046f, -0.01516900f, -0.00214468f, -0.03019128f, -0.00018515f, 
    0.03871250f, -0.04720421f, -0.01051365f, -0.07729758f, -0.00246263f, 0.02876729f, 0.03181839f, -0.02444093f, 
    0.01278745f, -0.05109529f, 0.00364413f, -0.03866216f, 0.01582496f, -0.05851097f, -0.04433654f, -0.06387840f, 
    0.02487470f, -0.03427378f, -0.06547264f, -0.02293068f, 0.01297356f, -0.07203809f, 0.03736787f, 0.04860857f, 
    -0.05505912f, -0.02304937f, -0.06229737f, 0.01368024f, -0.03108732f, -0.06025251f, -0.02988357f, 0.02279031f, 
    -0.04865165f, -0.06010795f, -0.00250777f, 0.03169845f, -0.06188463f, 0.01019700f, -0.02542526f, 0.05858971f, 
    0.03053775f, -0.03025937f, -0.07597788f, 0.04793087f, 0.04802918f, 0.02393073f, -0.03875086f, -0.03469982f, 
    -0.04425060f, -0.02963020f, 0.01904469f, 0.02570747f, 0.03266151f, -0.05460231f, 0.03642057f, -0.01789888f, 
    -0.01107860f, -0.04270924f, -0.03929687f, 0.00517104f, -0.07162113f, -0.06756268f, 0.04254750f, 0.04062982f, 
    0.05471019f, -0.00408145f, 0.03287802f, 0.02635728f, 0.04309949f, -0.00073618f, 0.01811808f, -0.02432587f, 
    -0.01311428f, -0.03582474f, 0.05923304f, 0.02560192f, 0.04566037f, 0.05094091f, 0.00191291f, -0.00746440f, 
    0.02411199f, -0.06676402f, 0.02115827f, -0.04839417f, 0.05046907f, -0.03177070f, -0.03877803f, 0.04515851f, 
    0.01997423f, 0.03511852f, -0.07977039f, -0.04446969f, 0.01573284f, -0.05432816f, -0.04553721f, 0.04206366f, 
    -0.01883554f, 0.01491166f, -0.04274382f, -0.02182130f, -0.02269761f, 0.01810296f, 0.03144411f, 0.01835066f, 
    -0.04196268f, -0.07389609f, -0.02412039f, 0.05413965f, 0.01327114f, -0.01285821f, -0.07025080f, -0.02509137f, 
    0.00950234f, 0.02191067f, -0.04331119f, 0.04556511f, -0.04057470f, -0.07490628f, -0.03549835f, -0.01235564f, 
    0.05343562f, 0.05919506f, -0.06735198f, -0.05903252f, -0.00486829f, -0.00521553f, -0.05933336f, 0.00572173f, 
    -0.05153141f, -0.06080484f, -0.00197591f, 0.05212801f, -0.00112801f, 0.02409049f, 0.02400215f, 0.06246822f, 
    -0.07660612f, -0.06221876f, 0.05708611f, -0.02653869f, 0.05220727f, -0.05310808f, -0.05564383f, -0.01509443f, 
    0.00663440f, 0.04707594f, 0.00242319f, -0.01404026f, -0.06365488f, -0.00783489f, 0.04359386f, -0.02311553f, 
    0.05739249f, -0.03082690f, 0.03331622f, 0.05564574f, -0.04545347f, -0.04427853f, 0.04525291f, -0.03693907f, 
    -0.07576542f, -0.04998253f, -0.01295560f, 0.05173751f, -0.00848031f, -0.07301923f, 0.06279107f, 0.04535693f, 
    -0.06978220f, 0.00921135f, -0.03351016f, 0.03155687f, -0.02625426f, 0.02880011f, 0.02923794f, 0.05516718f, 
    0.06410175f, 0.03567277f, 0.06554153f, 0.01603736f, 0.03194071f, 0.04616649f, 0.04255042f, 0.05796440f, 
    -0.06147965f, -0.02435496f, 0.05456463f, -0.00398262f, -0.04540057f, 0.05279798f, -0.07193682f, -0.06371380f, 
    0.00376427f, -0.01361859f, -0.04101831f, 0.03111469f, -0.06397555f, 0.02736248f, 0.00314441f, -0.07296667f, 
    0.05644673f, -0.05214183f, -0.02922868f, -0.01125822f, -0.01893317f, 0.04914476f, 0.01878050f, 0.06607403f, 
    -0.05966922f, -0.01830822f, -0.07014769f, 0.05717999f, -0.04832866f, -0.02737154f, -0.01131098f, -0.02276246f, 
    0.05385334f, -0.00316255f, -0.05761492f, -0.02464400f, 0.00267032f, 0.00293555f, 0.02267864f, 0.01823615f, 
    0.03470979f, 0.01732420f, 0.05669888f, -0.06368276f, 0.05513992f, -0.01700368f, -0.01754091f, 0.05577600f, 
    -0.03120242f, -0.05698589f, 0.02864651f, -0.00454549f, -0.03598902f, 0.02441098f, 0.06596214f, -0.07486241f, 
    -0.05389331f, -0.07213978f, -0.05543980f, 0.02858000f, -0.05821364f, -0.05704604f, -0.05552059f, 0.00509594f, 
    -0.03744711f, 0.00023096f, -0.00796327f, 0.01912971f, 0.04751256f, -0.03677776f, -0.01207161f, -0.07410494f, 
    -0.04563148f, -0.06338834f, 0.04385650f, -0.05402752f, -0.01671474f, 0.05791907f, -0.04715699f, 0.02465488f, 
    -0.03173012f, -0.06860604f, -0.03649829f, 0.05652917f, -0.05080882f, 0.06003156f, -0.03682612f, 0.02274058f, 
    -0.06418156f, -0.01431862f, -0.01259656f, -0.03070524f, -0.02540755f, -0.07089374f, 0.04914852f, -0.06424873f, 
    -0.04412868f, -0.05374617f, -0.05267328f, -0.00155264f, 0.05569851f, -0.07123524f, -0.05605677f, -0.05659420f, 
    0.01436923f, -0.01496488f, -0.05123201f, -0.01875218f, -0.07102677f, -0.00841873f, 0.05303188f, 0.05581560f, 
    -0.06934109f, -0.04406089f, 0.00218491f, 0.06245732f, 0.04862881f, 0.03869360f, -0.06041930f, -0.01310465f, 
    -0.04621439f, 0.05942969f, 0.01348860f, 0.03161818f, 0.04055640f, -0.05445087f, 0.00618148f, 0.04538864f, 
    0.02682197f, 0.06515227f, -0.04865766f, -0.06142736f, -0.00790820f, 0.02265253f, -0.04817526f, -0.06959836f, 
    -0.04597748f, 0.02916682f, 0.07061064f, -0.07114538f, -0.05219841f, -0.04624052f, -0.03505778f, 0.02291507f, 
    -0.05091240f, 0.01058258f, 0.03188687f, -0.01109998f, -0.06083364f, 0.02047918f, -0.06691106f, -0.04750402f, 
    0.06544117f, -0.05681874f, -0.05201080f, -0.07269119f, 0.05729245f, -0.05569480f, -0.00769436f, -0.02070391f, 
    0.04382059f, 0.03605016f, 0.01947968f, -0.02718943f, -0.03602577f, -0.00468703f, -0.03981788f, 0.00883088f, 
    -0.00902509f, -0.07808485f, 0.04828437f, 0.05712406f, 0.00307604f, -0.00217659f, -0.07095759f, 0.05536666f, 
    -0.04866293f, 0.04994659f, -0.07036630f, -0.06775403f, 0.06564865f, -0.03701098f, 0.05131229f, 0.06991481f, 
    0.03173885f, -0.02235265f, 0.02627175f, 0.04115067f, 0.02779886f, -0.04429077f, -0.05062893f, -0.04587610f, 
    -0.02707378f, 0.01099158f, -0.01794364f, 0.01090500f, -0.03002401f, -0.07145765f, -0.08278751f, 0.01213634f, 
    -0.07314826f, 0.01391763f, 0.00327728f, -0.04262593f, -0.02264769f, -0.06541225f, 0.02457689f, -0.05571463f, 
    -0.01469371f, 0.04351842f, -0.01278451f, 0.00477574f, 0.00143712f, 0.04288886f, -0.05342401f, -0.01287772f, 
    -0.01014753f, 0.06903209f, -0.07121043f, -0.01000145f, 0.01978350f, 0.02650620f, 0.05382418f, -0.05493700f, 
    -0.01642545f, 0.03942315f, -0.06252625f, -0.06525460f, 0.03675564f, 0.03648172f, -0.07842353f, 0.01904706f, 
    -0.07934649f, -0.04436145f, -0.02621545f, -0.03719869f, 0.03360393f, -0.04893216f, 0.05963842f, -0.03991133f, 
    0.01450085f, -0.02967732f, -0.01827953f, 0.06247767f, 0.05328774f, -0.02124095f, -0.05007741f, -0.03503612f, 
    0.05562336f, -0.03361027f, -0.04026478f, -0.03651380f, -0.06323430f, -0.03626716f, -0.00438962f, 0.02558960f, 
    0.02413719f, -0.02452313f, 0.05854979f, 0.03803775f, 0.01003357f, -0.02593970f, -0.02827106f, -0.07127388f, 
    -0.00801081f, 0.04252320f, -0.00180931f, -0.04303831f, -0.07727421f, 0.02952339f, 0.00680336f, -0.00463258f, 
    -0.00080862f, 0.05703168f, 0.00216294f, -0.05347427f, -0.01184117f, 0.05598655f, -0.07753477f, -0.05578092f, 
    -0.03304248f, -0.02656482f, -0.01976959f, 0.02186501f, -0.05753223f, -0.07555071f, -0.00797752f, 0.02836221f, 
    -0.01242540f, 0.02398866f, -0.04706082f, -0.00322205f, -0.03045165f, -0.05857169f, -0.08069560f, 0.01308293f, 
    0.01524019f, 0.03635776f, -0.05367808f, 0.01630400f, -0.02075235f, -0.06801708f, -0.01103471f, 0.00288997f, 
    0.00404091f, -0.01770423f, -0.02158131f, -0.00462725f, -0.06197418f, 0.00053684f, -0.06844371f, -0.05103384f, 
    0.03405750f, 0.04547890f, -0.02469771f, 0.00051565f, -0.08027170f, -0.05463845f, -0.07330599f, -0.05823072f, 
    0.00972722f, -0.01598839f, 0.02711413f, -0.00466920f, -0.00462696f, 0.03442043f, 0.00853499f, 0.06054768f, 
    -0.05448885f, 0.04304743f, -0.03415615f, -0.07983682f, 0.05875426f, -0.01967847f, 0.03929362f, 0.01889731f, 
    0.01908416f, -0.02698460f, 0.05951720f, 0.02745452f, -0.04749855f, -0.01730744f, -0.07488567f, -0.02944699f, 
    0.02684883f, 0.02841770f, 0.05078230f, -0.01902500f, -0.06736244f, -0.04440979f, -0.05091465f, -0.03101889f, 
    -0.01675672f, -0.05468296f, -0.05086554f, -0.04947727f, 0.01976879f, 0.06385665f, -0.05557958f, -0.06895698f, 
    -0.09583551f, 0.00075876f, 0.02989501f, -0.08782843f, 0.10128390f, 0.10968188f, 0.08743364f, 0.01096473f, 
    0.00830937f, -0.06826618f, 0.08238353f, -0.18671760f, -0.25425670f, 0.07184580f, 0.20484672f, -0.34468549f, 
    0.13331141f, 0.06209594f, 0.09451537f, 0.03790135f, 0.05764255f, 0.07827282f, 0.11493309f, -0.17753664f, 
    0.10760015f, -0.06823955f, -0.17361642f, -0.13129593f, -0.02443610f, 0.05570500f, 0.03238352f, 0.09073959f, 
    -0.00011268f, 0.25916111f, -0.13734846f, -0.05827167f, 0.11100460f, -0.00207651f, -0.20774750f, 0.33698758f, 
    0.11502644f, -0.04437681f, 0.06221171f, 0.19672130f, 0.02540394f, -0.03667459f, 0.10865718f, 0.08338564f, 
    -0.15015729f, -0.07881686f, 0.31018507f, 0.03406172f, 0.13380159f, 0.05045137f, -0.14984858f, 0.11654501f, 
    0.00344692f, -0.01179926f, -0.10681534f, 0.08674212f, 0.10539836f, 0.27336904f, -0.08064047f, 0.18400690f, 
    -0.02292645f, 0.07832225f, 0.08150605f, 0.09036726f, -0.02982862f, 0.08966284f, -0.00640456f, -0.06243811f, 
    -0.19023721f, 0.27760670f, -0.13047282f, -0.15156741f, -0.00682700f, -0.11966286f, 0.09879176f, 0.08783820f, 
    0.02912579f, -0.02247395f, 0.06161197f, 0.05308243f, 0.41917354f, -0.05696569f, -0.22367933f, 0.16026548f, 
    0.02579593f, 0.13542940f, 0.07627668f, 0.24752569f, -0.08564386f, 0.10074580f, -0.07396812f, 0.00281990f, 
    0.02172787f, 0.04542882f, 0.12542386f, 0.17090522f, 0.09859128f, -0.05899873f, -0.08629091f, -0.04097995f, 
    -0.00302679f, 0.13536055f, 0.02403852f, -0.02374146f, 0.59854114f, 0.26051605f, -0.00640484f, -0.10748051f, 
    0.13071413f, 0.00316937f, 0.09661929f, 0.12600665f, -0.06207848f, -0.06960363f, -0.02645639f, -0.03541285f, 
    -0.16756721f, 0.06035864f, -0.03853172f, -0.15825345f, -0.10700533f, -0.10166577f, -0.09449491f, 0.02662213f, 
    0.01733333f, -0.01468872f, 0.07872104f, -0.17295362f, -0.44703844f, 0.21525957f, -0.11656854f, -0.02845870f, 
    0.09632329f, 0.13574331f, -0.05687296f, -0.00527795f, -0.05360152f, 0.00679742f, 0.03476590f, 0.20240232f, 
    -0.15118881f, -0.19656882f, 0.23641875f, -0.03903476f, 0.07459879f, -0.01115677f, 0.12320939f, -0.04825073f, 
    -0.07446536f, 0.05490931f, 0.00294550f, 0.27244383f, 0.05462712f, 0.06872424f, 0.18544129f, 0.13784173f, 
    0.12315762f, -0.08637522f, 0.12986150f, -0.09469236f, -0.06792474f, -0.00697535f, 0.04190205f, 0.13425174f, 
    -0.12772565f, -0.10236630f, -0.30723977f, 0.04202189f, 0.19755074f, -0.04366177f, 0.00441013f, 0.06592873f, 
    0.08806074f, 0.09626925f, -0.02197490f, 0.03177795f, -0.03520119f, 0.08310918f, -0.16410799f, -0.09837144f, 
    0.09206146f, 0.00169925f, 0.06789547f, -0.18956341f, 0.13987352f, 0.09137116f, 0.14824744f, 0.27618003f, 
    -0.19408958f, 0.13299908f, -0.18106107f, 0.14847922f, 0.29925740f, -0.14844099f, -0.14363018f, -0.24569717f, 
    -0.09485363f, -0.22130507f, -0.03136691f, 0.11233512f, 0.08696380f, 0.22921377f, 0.17162451f, -0.05854594f, 
    -0.07120915f, -0.08075110f, 0.09953771f, 0.07052622f, 0.08303784f, -0.13571520f, 0.06149221f, 0.12319175f, 
    0.11329370f, 0.18917325f, 0.04472740f, 0.02795285f, 0.17445159f, -0.05376742f, -0.12546532f, 0.24484564f, 
    0.06483332f, 0.01793055f, -0.07976235f, 0.04317107f, -0.30775684f, -0.23224971f, -0.19025722f, -0.06614201f, 
    0.08255064f, -0.12754400f, -0.00657339f, -0.00031389f, 0.02758728f, 0.08435134f, -0.15713289f, -0.01088797f, 
    0.11425937f, -0.10122127f, -0.35376218f, -0.14472930f, 0.10029398f, -0.07357609f, 0.12555332f, -0.12466580f, 
    0.06528251f, 0.07464155f, 0.20223860f, 0.04743199f, 0.02743777f, -0.05067905f, 0.03211216f, 0.06168136f, 
    -0.25708839f, 0.13772991f, -0.11266001f, -0.18544953f, 0.01194511f, -0.01769965f, 0.18513916f, 0.09338741f, 
    0.20962287f, -0.03106409f, 0.04243821f, 0.33018604f, -0.12647323f, -0.07183488f, -0.07472737f, -0.12959105f, 
    -0.06770326f, 0.02853202f, 0.10543362f, -0.04497369f, -0.44252911f, -0.14957622f, 0.41701421f, 0.00495317f, 
    -0.34073415f, -0.19043620f, -0.06304128f, 0.20375907f, -0.04302860f, 0.04609153f, 0.00389659f, 0.04768710f, 
    -0.47547382f, -0.30993414f, -0.27495125f, -0.01964574f, -0.09106300f, 0.05894084f, -0.13676350f, 0.05583422f, 
    0.27926973f, 0.02213071f, -0.00201707f, 0.19188131f, 0.27308258f, 0.13300300f, 0.09198831f, 0.17857170f, 
    -0.05426222f, -0.31161639f, -0.13695011f, 0.09165422f, -0.07871346f, -0.16405354f, 0.18359967f, -0.01547625f, 
    -0.12772648f, -0.06557621f, -0.29962471f, 0.04809307f, 0.25273147f, 0.06709377f, -0.03163039f, -0.08100031f, 
    0.09520369f, 0.09903891f, 0.02582106f, 0.06849485f, 0.56124544f, 0.20052953f, -0.03553303f, 0.00801991f, 
    0.10883057f, -0.04219060f, -0.07805101f, 0.08319785f, 0.03960048f, 0.09516533f, -0.06560821f, -0.04303243f, 
    0.04691586f, 0.18810971f, 0.27250174f, -0.06820610f, -0.14309035f, 0.06002632f, -0.24342436f, 0.12180484f, 
    0.06682014f, -0.03237066f, -0.14116246f, -0.01158447f, -0.30166045f, -0.11705011f, -0.07689944f, 0.07865576f, 
    0.21894215f, -0.09610505f, 0.07128822f, -0.02880857f, 0.13846058f, 0.10094249f, 0.15753590f, 0.04031191f, 
    -0.00628382f, -0.00954415f, 0.02206082f, 0.06623129f, 0.27245533f, -0.11887570f, 0.08594365f, -0.15433609f, 
    0.07152391f, -0.05609219f, -0.04031823f, 0.12215664f, 0.20683597f, 0.01076058f, -0.10443743f, 0.03958073f, 
    0.22632900f, -0.10149143f, 0.05211072f, -0.04095831f, -0.08485199f, 0.08210397f, 0.11011557f, -0.02762935f, 
    0.03757584f, 0.42395565f, -0.07827064f, -0.07693601f, 0.05196631f, -0.07818802f, 0.08063540f, -0.11866639f, 
    0.19001141f, -0.10617442f, -0.22700877f, 0.06099137f, 0.19754253f, 0.12806195f, -0.05978727f, -0.18880929f, 
    -0.02406910f, -0.00039388f, 0.06137790f, -0.07965513f, 0.08567598f, 0.03818719f, 0.03848287f, 0.16105951f, 
    -0.30611628f, -0.14275549f, 0.03024312f, 0.10630646f, 0.03303094f, -0.20536549f, -0.02546058f, -0.04318939f, 
    0.01401479f, -0.16743025f, 0.03984350f, 0.05017626f, -0.12306319f, 0.00475799f, 0.14244176f, -0.14519444f, 
    0.15490265f, 0.04412103f, -0.04870218f, -0.05604906f, -0.01358481f, -0.05510072f, -0.04469301f, -0.02421500f, 
    0.16327365f, 0.03945738f, 0.27733877f, 0.23063867f, -0.16869578f, -0.08512304f, -0.05666590f, 0.00700992f, 
    0.02924449f, 0.00870206f, 0.17425473f, 0.30502611f, 0.12902015f, -0.31562513f, 0.02083136f, -0.11505129f, 
    0.14594389f, 0.19084121f, 0.17193210f, -0.01862275f, 0.15114981f, -0.04675319f, 0.03329714f, 0.12743202f, 
    -0.68508261f, 0.21830849f, -0.01116724f, -0.25007161f, 0.02442123f, 0.16266237f, -0.05498053f, 0.06116054f, 
    -0.18974753f, -0.13171948f, 0.18073314f, -0.20686463f, -0.09964225f, -0.09637036f, -0.10788110f, 0.29771394f, 
    0.17224482f, 0.27947271f, -0.05839869f, 0.10308982f, 0.11490257f, -0.07841487f, 0.15536149f, 0.02522548f, 
    0.25486580f, -0.14774516f, 0.13947377f, 0.18610995f, 0.06932412f, -0.00230716f, -0.00942374f, 0.06692281f, 
    -0.02402722f, -0.14339554f, 0.16849671f, 0.12233399f, -0.48569697f, 0.12342548f, 0.01410252f, -0.18607722f, 
    0.17782393f, -0.08478805f, -0.08469290f, -0.28795129f, 0.22061358f, 0.00778671f, 0.11370117f, -0.06582805f, 
    -0.20475286f, -0.02070865f, 0.22493038f, 0.17289758f, -0.09376077f, -0.03869004f, 0.02434221f, -0.02453787f, 
    -0.14018500f, -0.04977999f, 0.03051286f, 0.18514606f, -0.30357367f, 0.11448491f, 0.09552344f, -0.02689306f, 
    0.06831165f, 0.04360319f, 0.19751243f, 0.05633187f, -0.00722257f, -0.00487810f, -0.19453464f, 0.04131025f, 
    -0.00317576f, -0.19013299f, -0.19736320f, 0.11297317f, 0.16954565f, 0.26790372f, 0.04244144f, 0.13369560f, 
    0.05044587f, -0.05263710f, -0.17260984f, 0.16247360f, 0.04000945f, -0.09735829f, -0.01362800f, -0.18775488f, 
    -0.18202843f, -0.12173969f, 0.15562616f, -0.00641130f, -0.10388856f, -0.06592662f, 0.23656473f, 0.11346596f, 
    -0.19013689f, 0.01688000f, -0.08237258f, 0.07662176f, 0.18589684f, -0.13328387f, 0.08203936f, 0.04290686f, 
    0.01639496f, 0.08236902f, 0.04948704f, 0.24250132f, 0.26884434f, 0.12263970f, 0.16114545f, -0.22300172f, 
    -0.10274881f, -0.02678460f, -0.09478920f, -0.16293024f, -0.23431602f, 0.09470144f, -0.05225806f, -0.12722482f, 
    -0.07484126f, -0.17635870f, -0.04623888f, 0.13572803f, -0.14784576f, 0.05801014f, 0.06649411f, 0.05006015f, 
    0.00765681f, 0.07369769f, 0.06370634f, -0.02998820f, -0.05897718f, 0.11502481f, -0.04530776f, 0.21701090f, 
    -0.13455951f, -0.08037413f, 0.04421378f, -0.06451068f, -0.00804308f, 0.09374031f, 0.01232945f, -0.04852761f, 
    0.02664533f, -0.30548573f, 0.19001213f, -0.02318450f, -0.13900557f, 0.05585997f, -0.04653453f, 0.05907123f, 
    0.02760263f, -0.14655787f, -0.13765326f, 0.22229840f, 0.18423553f, 0.15795241f, 0.23208885f, -0.22209878f, 
    -0.00408451f, 0.07533628f, 0.02584299f, 0.08998162f, 0.04739852f, 0.12313173f, -0.07567616f, 0.02237180f, 
    0.18152195f, 0.03388962f, 0.08732432f, 0.22722040f, -0.05603622f, -0.02547811f, -0.04629195f, 0.06167923f, 
    -0.03748396f, -0.03378018f, -0.09355222f, 0.09908991f, 0.20290722f, 0.10525054f, 0.29376382f, -0.11748169f, 
    0.07653561f, 0.16030155f, 0.05826952f, -0.11703133f, 0.04837395f, 0.08707464f, 0.11922471f, -0.04361031f, 
    0.08001153f, 0.01307383f, 0.13920800f, -0.22494243f, -0.14345400f, -0.01354863f, 0.04554787f, 0.03364942f, 
    0.02465991f, 0.10626470f, -0.07046640f, -0.05631494f, 0.22999151f, 0.27896157f, 0.21757768f, 0.09934368f, 
    -0.03481409f, 0.08675392f, 0.08019367f, -0.00974583f, -0.04660235f, 0.02150093f, 0.08696625f, -0.13453498f, 
    0.36046329f, 0.26056617f, -0.04281888f, 0.24219823f, 0.02466113f, 0.05772081f, 0.03879125f, -0.16457301f, 
    0.00077918f, 0.01037924f, -0.01585273f, 0.06303480f, -0.45460838f, 0.06650006f, 0.11579621f, 0.01029252f, 
    0.03790249f, -0.05871683f, 0.04996590f, 0.04577440f, -0.13111573f, 0.00114976f, -0.01777927f, 0.21855283f, 
    -0.24131458f, -0.40114507f, 0.07584523f, 0.15319431f, 0.02811474f, -0.04519122f, 0.05616645f, -0.02613596f, 
    -0.16729732f, -0.05583218f, 0.04620290f, 0.06974507f, 0.04893320f, -0.30523679f, -0.01958117f, -0.23372875f, 
    0.07296553f, -0.20359556f, -0.03979892f, 0.00770619f, 0.01156731f, 0.13175848f, 0.06550653f, 0.04864731f, 
    -0.06571528f, 0.33338180f, 0.05814965f, 0.26041269f, 0.03016865f, 0.12789287f, 0.02537015f, -0.04231062f, 
    0.03223626f, 0.08944902f, 0.04949006f, -0.00820141f, -0.18814729f, 0.04633201f, -0.14281654f, 0.02491370f, 
    0.02935386f, 0.05881571f, 0.09612104f, 0.06623063f, -0.15129925f, -0.06575605f, -0.03869663f, -0.02370845f, 
    -0.10587525f, 0.10809326f, 0.24006243f, -0.15798552f, -0.06720565f, 0.01611514f, 0.03876762f, -0.01845596f, 
    -0.14938085f, -0.02951582f, -0.04961868f, 0.02462798f, 0.31436601f, -0.11080106f, 0.27205116f, -0.30828145f, 
    -0.04829058f, -0.06170601f, 0.13426635f, -0.03692400f, 0.06313807f, 0.01907020f, 0.11840965f, 0.01818813f, 
    0.25153187f, -0.09359749f, -0.51194906f, -0.16510116f, 0.13937967f, -0.00498156f, 0.07931121f, -0.12015936f, 
    -0.00328775f, -0.11309543f, 0.24359696f, -0.08389910f, -0.15979819f, -0.02144559f, 0.12683882f, -0.07611350f, 
    -0.00894823f, -0.07967269f, 0.00000610f, -0.03421544f, 0.06462875f, 0.07080714f, 0.03333385f, -0.11851835f, 
    0.21886660f, -0.11297252f, -0.18667310f, -0.27083972f, -0.07132207f, 0.01019893f, -0.17033583f, 0.07226199f, 
    -0.06969384f, 0.05954120f, -0.11975184f, 0.04344411f, -0.28898877f, -0.09428043f, -0.06516228f, 0.03988615f, 
    -0.13092563f, 0.04091655f, 0.02084662f, 0.19179514f, -0.03796113f, 0.13843672f, -0.01839214f, 0.03939870f, 
    0.04146097f, -0.21864840f, 0.06696927f, 0.08378606f, -0.08444669f, 0.00055199f, -0.05171230f, 0.00947545f, 
    0.01719195f, 0.09477904f, -0.00807749f, -0.05190407f, 0.41094717f, 0.16140954f, 0.23360153f, 0.21906954f, 
    0.18686901f, 0.07268480f, -0.01076821f, 0.14956698f, -0.13579759f, 0.01600263f, -0.03199903f, 0.02001451f, 
    -0.27274039f, 0.36899856f, 0.12445762f, -0.09402983f, 0.04364525f, -0.08351692f, 0.05520174f, -0.00935639f, 
    -0.13340566f, -0.04465748f, -0.04985675f, -0.13212875f, -0.11617151f, 0.09455889f, 0.19338875f, 0.32414487f, 
    0.06097071f, 0.15296264f, 0.10370003f, 0.15612550f, -0.15071194f, -0.00406523f, -0.00490581f, -0.12063708f, 
    0.36824921f, 0.21204157f, -0.31580696f, 0.22430931f, -0.14049646f, -0.09935239f, -0.05879522f, -0.04848150f, 
    -0.07224660f, 0.13463867f, -0.05782975f, 0.02733535f, 0.02216362f, 0.01990621f, 0.00118944f, 0.30900669f, 
    0.24919300f, -0.02794301f, -0.00978154f, 0.23016585f, 0.07047231f, 0.03554565f, 0.10069738f, -0.07125615f, 
    -0.12342233f, -0.23258066f, 0.02162554f, 0.22888422f, 0.11647863f, -0.04244983f, 0.04213823f, -0.06224939f, 
    0.06652845f, 0.01120973f, 0.03305144f, 0.00077669f, 0.21390817f, 0.11950789f, -0.23075269f, -0.33993572f, 
    0.07127616f, -0.19048762f, -0.22250824f, -0.08613042f, 0.03075145f, 0.10638420f, -0.13085982f, 0.21935470f, 
    -0.13405854f, 0.25881904f, 0.30752179f, 0.31636882f, 0.03446871f, 0.07770197f, -0.02674094f, 0.19691223f, 
    -0.24509506f, 0.03913278f, 0.11313366f, 0.03436899f, -0.56134593f, 0.19636708f, -0.11300933f, -0.02062815f, 
    0.10841275f, -0.04411117f, -0.05864487f, -0.01214634f, -0.10652789f, -0.04771419f, -0.04556552f, 0.03888245f, 
    0.14887525f, 0.30639553f, -0.09907868f, -0.05602255f, 0.14779839f, 0.03112320f, 0.04054957f, -0.04067915f, 
    -0.04848739f, -0.04684978f, -0.06142999f, 0.02233114f, 0.38231903f, -0.02591426f, -0.17358597f, -0.01213829f, 
    0.14608060f, -0.18001646f, 0.00732436f, -0.04860777f, 0.07123473f, -0.03164009f, 0.06801233f, 0.09585196f, 
    0.20498383f, -0.05606734f, -0.03508348f, 0.06020615f, 0.08493067f, 0.15761486f, -0.15892348f, 0.05222748f, 
    -0.11467595f, 0.00140000f, -0.18554203f, 0.22003119f, 0.22841986f, -0.32149068f, 0.08602791f, 0.05158829f, 
    -0.13896726f, -0.08901248f, 0.07743631f, 0.11518798f, -0.04092265f, -0.00550267f, 0.06787422f, 0.09152883f, 
    -0.11371327f, 0.17817880f, 0.02093999f, 0.09759935f, -0.00295243f, -0.00913062f, -0.03798576f, 0.02259498f, 
    0.00407446f, 0.04878800f, 0.10593001f, -0.06017721f, 0.60270637f, -0.17912182f, 0.00703844f, 0.05532779f, 
    -0.16428098f, 0.05110481f, -0.07411743f, 0.00441987f, -0.00428216f, 0.05954021f, 0.05774856f, 0.02253118f, 
    0.00732322f, 0.10906973f, -0.09497539f, -0.15683755f, -0.05593251f, 0.15825182f, 0.04966773f, -0.06939732f, 
    0.10725151f, 0.11794771f, -0.00265094f, -0.14683330f, 0.30087861f, -0.17192997f, -0.12724817f, 0.14892547f, 
    0.11479019f, -0.08579971f, 0.08541591f, 0.01022615f, 0.01965855f, -0.15664658f, -0.02212599f, 0.21163961f, 
    0.45900947f, -0.06049734f, 0.01489635f, 0.10619920f, -0.01454297f, -0.04363479f, -0.10755642f, 0.16335897f, 
    -0.02929962f, -0.07685714f, -0.02627951f, -0.07089783f, -0.29901981f, 0.03632900f, 0.06888370f, 0.06707581f, 
    0.23282655f, -0.09890878f, 0.00135727f, -0.16480111f, -0.09859452f, -0.13500844f, 0.02967965f, 0.11555289f, 
    -0.13528591f, -0.33854297f, -0.05496013f, -0.11484734f, -0.13592117f, 0.05433358f, 0.07903177f, 0.04495778f, 
    -0.04201806f, -0.05744204f, 0.08345671f, 0.03486346f, 0.16752294f, -0.04752709f, -0.11615232f, 0.05041405f, 
    -0.03202785f, -0.01121879f, -0.05915801f, -0.06384415f, 0.05809366f, 0.05531336f, -0.00488475f, 0.02170518f, 
    -0.13814570f, 0.23994197f, 0.22808678f, -0.12220690f, -0.13951339f, 0.08517621f, 0.13895983f, -0.03358775f, 
    -0.11769222f, 0.01132841f, 0.01745886f, 0.05362006f, 0.09904332f, 0.18423051f, 0.06493902f, 0.04581998f, 
    -0.04989320f, 0.10068209f, 0.02071405f, 0.05736629f, -0.05747327f, 0.09398843f, -0.01675886f, 0.00675083f, 
    0.17826538f, -0.06670919f, -0.06237440f, 0.02126521f, 0.07052967f, -0.08312632f, -0.06134478f, 0.09744824f, 
    0.18023354f, -0.10797210f, 0.01356851f, -0.03586047f, -0.04218196f, 0.01585405f, 0.00407969f, -0.39760721f, 
    0.06781007f, -0.04142062f, -0.19936348f, 0.11635356f, -0.03429740f, 0.00680509f, 0.09644026f, -0.06162560f, 
    -0.02065660f, 0.12440992f, 0.10813238f, 0.00606448f, -0.08406489f, 0.09714379f, -0.00394479f, 0.07682205f, 
    0.01039510f, -0.09423450f, 0.06678887f, -0.11012322f, -0.27690458f, 0.27694774f, -0.11633930f, 0.29526186f, 
    -0.05271712f, -0.01310547f, -0.08381858f, 0.06264958f, 0.04978675f, -0.01295821f, -0.04913380f, 0.11847536f, 
    -0.00757058f, -0.02829079f, -0.05238008f, -0.00989715f, 0.00758127f, -0.03324956f, -0.04059653f, -0.03997838f, 
    0.04782899f, 0.04746099f, 0.00048330f, -0.03057484f, -0.06191685f, -0.06488878f, -0.00833029f, -0.04566370f, 
    0.01488098f, -0.00313451f, -0.05201281f, 0.02782536f, -0.05178737f, 0.04439187f, 0.03915792f, -0.02186146f, 
    -0.06195267f, -0.02134520f, -0.02761050f, 0.01234855f, -0.07955578f, -0.04172789f, 0.04109799f, 0.01891322f, 
    0.03281604f, 0.05920826f, -0.00774095f, 0.01968607f, 0.01812968f, 0.02334299f, -0.03378115f, -0.06145374f, 
    -0.06001494f, 0.06071516f, -0.06552046f, -0.06744472f, -0.02055288f, 0.02027218f, -0.03285528f, -0.02183754f, 
    -0.00090640f, 0.02687020f, -0.06225577f, -0.00888798f, 0.06924582f, 0.00981430f, 0.00959756f, 0.00179051f, 
    -0.03303440f, 0.06458147f, -0.04761753f, -0.07250530f, 0.04384296f, -0.06325104f, -0.02939857f, -0.00514235f, 
    -0.02949026f, -0.02271512f, -0.03845674f, 0.05251502f, 0.06740273f, -0.02545702f, -0.03076125f, -0.02979249f, 
    0.06682640f, 0.01279037f, 0.03603689f, -0.04322235f, -0.05401687f, 0.01109225f, -0.07619159f, 0.05056483f, 
    0.04442599f, 0.04932496f, -0.06266762f, -0.01390248f, 0.02951051f, -0.01707301f, -0.01301682f, 0.05881800f, 
    -0.01710067f, 0.01843648f, 0.00815818f, -0.06102882f, -0.06668235f, -0.06888484f, 0.03519655f, -0.02305304f, 
    -0.05182130f, 0.02909913f, -0.04142565f, 0.04203859f, -0.06754562f, -0.02276809f, 0.02174745f, 0.03943576f, 
    -0.07319438f, 0.02459900f, -0.03073053f, 0.01422284f, 0.01747758f, 0.05467381f, -0.02807356f, -0.07578582f, 
    -0.01757661f, -0.01993265f, -0.03018801f, 0.01952072f, 0.06397474f, 0.05376587f, -0.07180504f, -0.00696836f, 
    -0.02624507f, 0.00068144f, 0.00825632f, 0.02320979f, -0.07702771f, 0.00649351f, 0.03524510f, -0.05417835f, 
    0.00693275f, 0.04768322f, -0.04589753f, -0.02171335f, -0.01935229f, 0.01169994f, -0.04250860f, 0.07000107f, 
    0.00036369f, -0.05030099f, 0.05234381f, 0.01448184f, -0.05093658f, 0.02824195f, 0.01045885f, -0.02199799f, 
    -0.00085616f, -0.05559026f, -0.01622132f, 0.00937155f, -0.04210784f, 0.03297175f, -0.05316886f, 0.02701764f, 
    0.03666672f, -0.06247117f, 0.06110587f, -0.01555412f, 0.07619199f, -0.05117172f, -0.02913380f, -0.05338837f, 
    0.00588239f, -0.05727344f, 0.03026533f, -0.05127347f, 0.03346619f, -0.04950884f, 0.03761201f, -0.02226213f, 
    0.03953495f, 0.02782451f, -0.02787726f, -0.02045638f, 0.04934720f, -0.05143546f, -0.02304189f, 0.01976015f, 
    0.04301658f, -0.05855160f, -0.04815377f, 0.01892660f, -0.04938743f, -0.03595123f, 0.02452987f, 0.02999167f, 
    -0.04461418f, 0.06513519f, -0.05410837f, -0.00677638f, -0.01228143f, 0.04101412f, 0.00483408f, 0.00941853f, 
    -0.11941344f, -0.12935701f, 0.02049066f, 0.09458041f, -0.08508287f, -0.00113367f, -0.07159033f, 0.05724476f, 
    -0.10105436f, -0.03436107f, 0.08792078f, -0.01599187f, -0.03159751f, -0.36680466f, 0.11458214f, -0.04525253f, 
    0.03977033f, 0.17506896f, 0.00589653f, 0.12251650f, 0.04322197f, 0.02590325f, 0.06171791f, 0.07180092f, 
    -0.01631274f, 0.06237449f, 0.12185867f, -0.04104020f, 0.07512794f, 0.03735363f, 0.12983812f, 0.23490055f, 
    -0.00149253f, -0.01728853f, 0.03055024f, 0.04412409f, -0.06743579f, 0.15859671f, 0.11191382f, 0.04997465f, 
    0.13597073f, 0.07927462f, 0.08709936f, 0.13555518f, -0.14658064f, -0.02565033f, -0.10347290f, 0.04264065f, 
    0.11268114f, 0.30896509f, 0.03688776f, -0.01316843f, 0.33021688f, 0.06508086f, 0.05248576f, 0.14694789f, 
    -0.00584431f, 0.11610553f, 0.07526052f, 0.03470203f, -0.16355999f, 0.34016946f, 0.18627898f, -0.31339169f, 
    -0.11246952f, 0.00310967f, -0.14424409f, 0.01256062f, -0.11847240f, -0.03407018f, 0.03328485f, 0.04655444f, 
    0.35123682f, 0.11796403f, -0.22453894f, -0.01183295f, -0.11414388f, -0.12500177f, -0.00891720f, 0.06013157f, 
    0.05131787f, -0.09542148f, 0.10599078f, -0.04289893f, 0.25703600f, 0.04812125f, 0.31404310f, -0.04773299f, 
    -0.06015927f, -0.19922550f, 0.14638314f, -0.01082188f, -0.12006394f, -0.05216229f, 0.12733105f, 0.12902158f, 
    -0.02279848f, -0.05343017f, 0.27873990f, 0.24354385f, 0.06662232f, 0.09810531f, -0.01079113f, -0.04894882f, 
    -0.01177701f, 0.07344627f, -0.00992935f, 0.10999873f, -0.04410517f, 0.33335763f, -0.09525825f, -0.15289715f, 
    -0.13083695f, 0.04351274f, 0.08117296f, 0.09168097f, -0.23026387f, -0.23032162f, -0.07125668f, 0.08364217f, 
    -0.30468002f, -0.26414016f, 0.05770056f, -0.09889128f, 0.08364950f, 0.17564180f, -0.09611990f, 0.02498264f, 
    0.06828765f, -0.13493977f, 0.13409837f, -0.00010551f, -0.37786970f, -0.35904753f, 0.02717995f, -0.12354513f, 
    0.14740945f, -0.00467143f, 0.19078855f, 0.11271314f, 0.07826317f, 0.04179063f, 0.00762005f, -0.02609949f, 
    0.31034148f, -0.12427378f, -0.04088869f, 0.00286055f, -0.17022960f, -0.03954251f, 0.07929973f, -0.14594246f, 
    0.01648165f, 0.05652729f, -0.08224300f, 0.00623914f, 0.16784349f, -0.17821750f, -0.21436262f, 0.31564489f, 
    0.28466746f, 0.02609108f, 0.08196238f, -0.09955407f, 0.03997958f, -0.03430431f, 0.22494142f, -0.03905132f, 
    -0.34748212f, -0.45872265f, 0.01136907f, -0.27798983f, 0.09560260f, -0.09103204f, 0.05121691f, -0.08165891f, 
    0.08352385f, 0.08683394f, 0.09016058f, 0.15345854f, -0.09061176f, -0.43546531f, -0.19403906f, -0.43020368f, 
    -0.10062565f, -0.08483480f, 0.00315602f, 0.07427775f, 0.09649228f, 0.00164265f, 0.07826292f, -0.02680689f, 
    -0.10698979f, -0.30565229f, 0.27573717f, 0.20309632f, 0.01250959f, -0.02006947f, -0.07190829f, 0.12244388f, 
    -0.05559224f, 0.07757790f, -0.20958744f, 0.12107128f, 0.12414451f, -0.25691921f, -0.11317357f, 0.12888716f, 
    0.12051310f, 0.01670365f, 0.00145380f, 0.08713283f, 0.06316397f, 0.02590904f, -0.01786686f, 0.18225731f, 
    -0.31429183f, 0.02669213f, 0.17361110f, 0.21191677f, -0.01101267f, -0.08485192f, 0.07229301f, 0.03684461f, 
    -0.03924705f, -0.05927446f, 0.21371530f, 0.04081487f, 0.31488630f, 0.17805178f, 0.05398607f, -0.02741813f, 
    0.12287214f, 0.01429741f, -0.02423135f, -0.10217246f, -0.03695470f, -0.06290612f, -0.15468571f, 0.13042921f, 
    0.06573603f, 0.17258224f, -0.09959514f, 0.08847901f, 0.24248762f, 0.09789581f, 0.01467004f, 0.13461462f, 
    -0.01442492f, -0.01523388f, 0.06861131f, -0.03802180f, -0.31711707f, 0.09494355f, -0.04287717f, -0.23696443f, 
    -0.03345859f, -0.01584929f, 0.04556931f, 0.05134847f, 0.11147423f, 0.08914442f, 0.04672124f, -0.00566351f, 
    0.43855587f, -0.05537463f, -0.09124693f, 0.08727103f, 0.09671007f, 0.08227327f, -0.10468458f, 0.14902425f, 
    -0.00324660f, -0.01898200f, 0.03560339f, -0.03503822f, 0.14685582f, 0.22881649f, -0.00741860f, -0.15107019f, 
    0.00195814f, -0.14002429f, 0.04029024f, -0.14722587f, 0.07963087f, -0.02282542f, 0.12107610f, 0.16397062f, 
    -0.08574162f, -0.16222565f, 0.17684545f, 0.05836450f, 0.12257786f, 0.06338961f, 0.14963147f, 0.01743898f, 
    0.03388575f, 0.05809678f, 0.08257072f, 0.03419117f, -0.19241689f, 0.00875994f, -0.07486290f, -0.13538547f, 
    -0.06888709f, -0.02616508f, 0.01965790f, 0.01711671f, -0.10978889f, 0.02734143f, -0.08998089f, -0.05886630f, 
    0.20166799f, 0.14185734f, 0.19164470f, -0.15787083f, -0.09741451f, -0.03535457f, 0.08837755f, -0.00976655f, 
    0.06324857f, 0.05005608f, 0.01928652f, 0.07794347f, -0.17392194f, -0.22499393f, 0.24006841f, 0.09191766f, 
    -0.03075893f, -0.03269754f, 0.12883022f, 0.17689419f, 0.03014994f, 0.04535856f, 0.04045532f, -0.14543468f, 
    0.27383739f, -0.11274365f, -0.16004610f, -0.06663542f, -0.02083197f, -0.21514416f, 0.11003791f, -0.22643998f, 
    0.22411126f, -0.04840261f, -0.03043460f, -0.16307791f, 0.29555705f, -0.20182203f, -0.04588886f, -0.05007248f, 
    0.15088296f, 0.00307778f, -0.07960492f, 0.08942884f, 0.07947411f, 0.04775447f, 0.04921402f, -0.06057418f, 
    -0.01947327f, -0.25827000f, 0.17165722f, -0.25873917f, -0.16739947f, 0.06371859f, 0.00606802f, 0.02089327f, 
    0.13786481f, 0.04294688f, 0.10711288f, 0.00726853f, -0.28716043f, -0.07054324f, 0.08247456f, -0.11801270f, 
    -0.08849310f, 0.01525174f, -0.04641911f, 0.16084798f, 0.05057881f, -0.07091747f, -0.06306418f, -0.16270502f, 
    0.04520781f, -0.20436627f, -0.27254859f, 0.06817169f, 0.25464895f, -0.07843997f, -0.01188428f, 0.06567319f, 
    -0.22869974f, -0.07458239f, 0.01742607f, 0.13065046f, -0.27337950f, -0.25412977f, 0.16115601f, 0.09913450f, 
    0.02291568f, 0.04095859f, 0.00590295f, 0.05612791f, 0.07919687f, 0.08918082f, 0.04035680f, -0.05470928f, 
    0.12438765f, 0.12127136f, -0.13422684f, -0.05651585f, 0.04089590f, 0.05409335f, 0.01797378f, 0.19694684f, 
    -0.03479793f, 0.17132191f, -0.01649478f, 0.06219832f, 0.21518625f, 0.07193269f, 0.03443494f, -0.04354844f, 
    0.00665160f, 0.10268975f, 0.02604114f, 0.20440078f, 0.11601582f, 0.01219730f, -0.02345080f, -0.06518956f, 
    0.05716543f, 0.18079844f, -0.25482914f, -0.24426328f, 0.18374547f, 0.00700722f, 0.03963229f, -0.05387109f, 
    -0.01026297f, 0.01168442f, 0.00866012f, -0.06277025f, 0.14821473f, 0.18052343f, -0.01500362f, -0.01699747f, 
    -0.03866676f, 0.07077803f, 0.08025362f, 0.02235537f, -0.00760856f, -0.05435819f, -0.06083212f, 0.03562857f, 
    0.40236232f, -0.03708345f, 0.12986185f, 0.18016352f, -0.00675748f, -0.01679554f, -0.02546105f, 0.10553823f, 
    0.10792670f, -0.00836314f, -0.11692543f, -0.05209716f, -0.09378909f, -0.01005566f, 0.33186474f, 0.07947568f, 
    -0.03357170f, -0.00972197f, 0.10188704f, -0.03792556f, -0.03897221f, 0.07621107f, 0.09507181f, 0.05969306f, 
    -0.29365093f, 0.04271620f, -0.21371102f, 0.01120118f, -0.13472356f, -0.10682500f, 0.06647816f, 0.02228964f, 
    0.00675956f, 0.11095937f, 0.06576320f, 0.15001054f, 0.23965630f, -0.08381787f, -0.16572222f, 0.31166983f, 
    -0.11321788f, 0.00608980f, 0.18160152f, 0.23137964f, -0.13663003f, 0.11563323f, 0.00383497f, -0.02168415f, 
    -0.46882650f, 0.17110221f, 0.08693520f, 0.00355886f, 0.19622393f, 0.09209964f, 0.06025378f, -0.14460991f, 
    0.05156412f, 0.11726998f, -0.10638522f, 0.08221094f, 0.13018392f, 0.04897322f, -0.17976673f, -0.09073053f, 
    0.05977341f, -0.13154149f, -0.25798622f, 0.12707013f, 0.10176261f, 0.03593802f, -0.00527458f, -0.05047576f, 
    0.00697019f, -0.11608475f, 0.22127686f, 0.25834247f, -0.00952964f, -0.10543586f, 0.05944489f, 0.02695396f, 
    -0.03236124f, -0.00973686f, 0.19443759f, 0.06828761f, -0.12388048f, 0.02281023f, -0.04073199f, -0.08069967f, 
    0.10880093f, 0.06036077f, -0.02882140f, 0.03437638f, 0.08493520f, -0.08948795f, 0.04982636f, 0.06274401f, 
    -0.23539498f, 0.00869071f, 0.22269189f, -0.19067052f, 0.03677427f, 0.03858358f, -0.04678372f, 0.09806521f, 
    -0.00233501f, 0.10513581f, 0.06969803f, -0.06895784f, -0.46817613f, -0.05153619f, -0.22550604f, 0.11740599f, 
    0.10774720f, -0.16755944f, -0.05278309f, 0.18194778f, -0.06808721f, -0.03925313f, -0.02894438f, 0.04119113f, 
    0.23755375f, -0.03728618f, -0.23900546f, 0.06680097f, 0.22957332f, -0.10396758f, -0.00666960f, -0.04774453f, 
    0.01876189f, -0.01375717f, 0.11665572f, 0.07574094f, -0.47297329f, -0.05080328f, 0.13153602f, 0.27024144f, 
    0.06778173f, 0.13822426f, -0.02110261f, 0.02086180f, 0.11514246f, -0.00167008f, 0.00398723f, -0.11628965f, 
    0.25895715f, -0.08830646f, -0.02701852f, 0.01157391f, 0.02618964f, 0.03996897f, -0.02917660f, 0.02854829f, 
    0.07943047f, -0.01237381f, 0.06373663f, 0.21103099f, -0.45499575f, 0.33379307f, 0.00634196f, -0.16917381f, 
    0.13801591f, -0.02655155f, 0.10825240f, 0.10107284f, 0.14589068f, 0.03831078f, 0.08603580f, 0.04543654f, 
    0.04622937f, -0.11183557f, -0.11134790f, 0.17511620f, -0.01349478f, 0.00809383f, 0.06725031f, 0.11054357f, 
    0.03078902f, 0.12610476f, 0.05525813f, 0.07512394f, -0.09206404f, 0.11632104f, 0.11690073f, -0.27536452f, 
    0.16366927f, 0.03723310f, 0.09826626f, 0.07994684f, -0.10016741f, 0.01974437f, 0.12250407f, 0.00156315f, 
    -0.17885922f, 0.01993534f, 0.05981681f, 0.01133856f, 0.10142294f, 0.10812702f, 0.00648909f, 0.01350875f, 
    0.09269363f, 0.11120810f, 0.04499650f, 0.02272001f, 0.01205681f, 0.13039692f, 0.06834104f, 0.04138800f, 
    -0.02474804f, -0.03901700f, 0.07587954f, 0.03721217f, 0.08313258f, 0.04370450f, 0.02347008f, -0.03561040f, 
    0.14041279f, 0.26575187f, -0.14376885f, 0.14681134f, -0.10512046f, -0.04662396f, -0.04896539f, -0.02386104f, 
    -0.04288865f, 0.05184292f, -0.02019837f, -0.03932820f, -0.52859414f, -0.45143178f, -0.07173441f, 0.02640313f, 
    0.11505336f, -0.07661767f, 0.03321485f, 0.20682709f, 0.03811458f, 0.02541777f, 0.09846208f, 0.02362242f, 
    0.00086771f, 0.08863003f, 0.23979050f, 0.01199357f, 0.17877597f, 0.00363240f, 0.08443890f, -0.05907463f, 
    0.08163109f, -0.02417438f, -0.02673723f, 0.13910542f, 0.30856645f, -0.16647261f, -0.13676661f, -0.08664571f, 
    0.16401571f, -0.15992646f, -0.16132765f, 0.02083895f, -0.02140908f, 0.04885573f, 0.00322287f, 0.02806439f, 
    -0.27376238f, 0.05282691f, -0.11976934f, 0.16103230f, -0.00891049f, 0.02878664f, -0.00625515f, 0.00840431f, 
    -0.07702306f, 0.11345561f, 0.10406043f, 0.01370013f, -0.15700565f, 0.42484164f, -0.25792745f, -0.00682098f, 
    0.06303753f, -0.04359138f, 0.00615635f, 0.02112536f, 0.10545363f, -0.09932365f, -0.04108910f, 0.05325820f, 
    -0.03082413f, 0.34825391f, 0.22240809f, -0.45418450f, 0.08842671f, -0.00427809f, 0.01692984f, -0.02812525f, 
    0.06809832f, -0.11173791f, 0.07088340f, 0.03008405f, 0.09321640f, -0.11619449f, 0.18596725f, -0.20613131f, 
    -0.01161310f, -0.02488473f, 0.01835930f, -0.05408720f, 0.01591127f, 0.03367402f, 0.06270093f, -0.00018168f, 
    -0.01085367f, 0.10142561f, -0.02635163f, -0.10962459f, -0.11015011f, 0.04277480f, -0.08523362f, -0.09996665f, 
    -0.05244113f, -0.06524395f, 0.03920422f, -0.04933408f, 0.01094812f, 0.00809587f, 0.04913823f, -0.26273954f, 
    -0.17066570f, -0.06583107f, 0.05169784f, 0.01460191f, 0.16608988f, -0.01626452f, 0.23090930f, 0.08728470f, 
    0.06575529f, 0.12482844f, -0.20513426f, -0.11597226f, -0.02076681f, 0.02605515f, 0.00152858f, 0.21504308f, 
    0.00191831f, 0.15488137f, -0.02589630f, -0.11400568f, 0.36401030f, -0.20787883f, 0.08973614f, 0.11070882f, 
    0.03374036f, 0.08034819f, 0.00589817f, 0.16135539f, -0.14699331f, 0.02962836f, -0.14725979f, -0.04679078f, 
    0.17985827f, 0.12939103f, -0.00753225f, -0.18272938f, 0.10974195f, -0.00689216f, 0.01167544f, 0.03777047f, 
    0.08872801f, 0.05153847f, 0.05100178f, -0.10286865f, 0.63121271f, -0.05370067f, 0.28881842f, 0.20318970f, 
    0.08729331f, 0.09442829f, -0.00961498f, 0.05599096f, 0.08453557f, -0.07297262f, -0.02522743f, 0.03739294f, 
    0.15263727f, 0.03873691f, -0.00441470f, 0.07195841f, -0.21564226f, -0.10517116f, 0.02464844f, 0.02316919f, 
    -0.07570679f, -0.05439414f, -0.01142668f, -0.13625193f, 0.01856393f, -0.05273157f, 0.34224480f, 0.26144654f, 
    0.11451915f, 0.09061995f, 0.00121674f, 0.14205940f, -0.01078438f, -0.06785489f, 0.06885640f, -0.03385983f, 
    -0.03369319f, -0.24282703f, 0.08597343f, 0.06677115f, 0.01716536f, 0.09731593f, -0.08257703f, -0.02087807f, 
    0.01706449f, 0.12734962f, 0.10555340f, 0.17061043f, 0.55411702f, 0.40000233f, 0.05966554f, 0.25420016f, 
    -0.01760229f, -0.13912730f, -0.06189328f, -0.00183267f, -0.07651188f, -0.04412605f, 0.01402951f, 0.01843035f, 
    -0.59223437f, -0.18623382f, -0.22519496f, -0.01135627f, -0.12288606f, 0.06539715f, 0.00161704f, -0.10320789f, 
    -0.03304608f, -0.06404070f, 0.07224888f, -0.09291042f, -0.24286601f, 0.20064765f, -0.15932383f, -0.07388201f, 
    -0.03096963f, 0.11838423f, -0.00736910f, 0.07026602f, 0.19463882f, 0.13860430f, 0.02854175f, 0.16285397f, 
    0.14941812f, 0.15009059f, 0.37275103f, 0.22922021f, 0.07330205f, 0.16681084f, 0.10525108f, 0.06019820f, 
    0.00308000f, 0.02732301f, -0.08023808f, 0.13975695f, -0.14478329f, -0.14644037f, 0.15349013f, 0.02715774f, 
    0.07183633f, -0.08580009f, -0.02483617f, -0.02038007f, 0.00959096f, 0.03781182f, 0.12475996f, 0.01146712f, 
    -0.35275468f, -0.23218857f, -0.22333458f, 0.23392864f, -0.00865207f, -0.06576489f, 0.03529209f, -0.03794589f, 
    0.05504153f, -0.01195366f, -0.02013765f, 0.05277556f, 0.08981535f, 0.02396818f, -0.21267770f, 0.18286851f, 
    -0.01844687f, -0.15072407f, -0.12298016f, -0.04150785f, -0.03829099f, 0.15305817f, 0.07099278f, 0.11683600f, 
    0.01870341f, -0.02261165f, 0.05441744f, -0.01747440f, 0.01858762f, -0.00459056f, 0.03203648f, -0.04897765f, 
    -0.05358760f, -0.01099413f, -0.05681353f, -0.06268092f, -0.03099512f, -0.07847632f, 0.02090404f, -0.01252637f, 
    0.02476820f, 0.05332452f, -0.07783914f, 0.05908350f, 0.03357443f, -0.02378367f, -0.02223887f, 0.04545836f, 
    0.00027460f, 0.00323728f, -0.07138927f, -0.01578998f, -0.07847375f, -0.01211564f, -0.03331275f, -0.00156144f, 
    -0.07721140f, -0.01779702f, -0.06641680f, 0.03484474f, 0.06050908f, -0.01016781f, -0.06500906f, -0.06331483f, 
    0.02711170f, 0.03472001f, 0.06277484f, -0.04703139f, -0.05921803f, 0.04281360f, -0.06714766f, -0.06323642f, 
    -0.00684165f, -0.04644837f, 0.00600141f, 0.03505984f, 0.05706966f, -0.00271520f, 0.02474377f, 0.02634926f, 
    -0.03608591f, 0.00860887f, 0.00662734f, 0.00901547f, 0.01531828f, -0.02040204f, 0.02301707f, -0.07101547f, 
    -0.07697225f, -0.02893578f, 0.02163996f, -0.02105333f, -0.06937787f, 0.02642359f, -0.04469233f, -0.06803872f, 
    -0.05151353f, 0.06517065f, 0.03002757f, -0.07893334f, 0.00019309f, 0.02966979f, 0.04835330f, -0.07955498f, 
    0.00613864f, 0.04913722f, -0.03946663f, 0.05641358f, 0.02007752f, 0.01994088f, 0.05125182f, -0.01179232f, 
    -0.05409237f, -0.01925782f, 0.02636765f, -0.05788473f, -0.00118462f, -0.05462369f, -0.06249195f, 0.05155598f, 
    -0.00138149f, 0.03977849f, 0.03778642f, -0.07792000f, -0.03248489f, -0.00493073f, -0.04333169f, -0.00359078f, 
    0.05933175f, -0.04557292f, -0.06639124f, -0.04323787f, 0.02709807f, -0.02344806f, 0.04789550f, 0.06051848f, 
    -0.06972783f, 0.05160900f, -0.07335608f, -0.07796592f, -0.04506946f, -0.00006429f, -0.02308773f, 0.01896047f, 
    -0.05545071f, -0.03014357f, -0.06307675f, -0.01533051f, 0.00895609f, 0.01095343f, -0.07882765f, 0.03798081f, 
    -0.02493735f, -0.07775609f, 0.03810501f, -0.07464179f, 0.04548694f, -0.01696275f, -0.05777022f, -0.03796961f, 
    0.02466722f, -0.00870138f, 0.02801667f, 0.05566116f, 0.06003478f, 0.02638373f, 0.00602457f, -0.02705058f, 
    -0.03200089f, 0.01924552f, 0.05350395f, -0.01667308f, 0.05332585f, -0.05607479f, -0.06419394f, 0.02225651f, 
    0.02193447f, 0.02502738f, -0.06946859f, 0.05740945f, 0.01581797f, -0.06587955f, -0.05713831f, -0.05154874f, 
    0.02889105f, -0.05474207f, -0.06629503f, -0.05525722f, -0.06557864f, -0.07996114f, -0.00079880f, 0.00856893f, 
    -0.06856189f, 0.04989443f, -0.00429196f, -0.02467619f, -0.01342198f, 0.02448368f, 0.04858076f, -0.04663768f, 
    0.03087027f, 0.03561207f, 0.02561462f, -0.07204217f, -0.01917035f, -0.03056626f, 0.00225107f, -0.04890120f, 
    -0.02891799f, -0.03075078f, -0.00960089f, 0.03823874f, 0.04130064f, 0.05384891f, -0.06291322f, 0.01888037f, 
    -0.05434867f, 0.28860506f, 0.17046623f, 0.08324413f, 0.03856071f, -0.06250919f, 0.01563613f, 0.06195297f, 
    0.22924723f, 0.12654635f, -0.01794192f, 0.12963992f, 0.11271315f, 0.12293629f, -0.07038046f, -0.00101641f, 
    -0.01911648f, 0.06038240f, 0.01091043f, -0.04126378f, -0.18749753f, -0.07828277f, -0.01987914f, 0.11443582f, 
    0.06901387f, 0.07884457f, 0.10346841f, 0.24059355f, 0.03072500f, 0.00858097f, 0.08198649f, -0.13461947f, 
    0.10057693f, 0.04611898f, 0.02240839f, 0.12033970f, -0.10703608f, -0.09453199f, 0.05046988f, 0.06959126f, 
    0.15199241f, 0.07288644f, 0.20893736f, 0.07625234f, 0.22592185f, 0.20744425f, 0.19772685f, 0.04330142f, 
    -0.24590832f, -0.05029413f, 0.18636315f, 0.13901724f, -0.07888056f, 0.11009133f, -0.09251780f, -0.03345672f, 
    0.09242839f, 0.03910595f, 0.00758634f, 0.13490261f, -0.03395576f, -0.54429406f, -0.22306937f, 0.09732554f, 
    0.04360870f, -0.11501363f, 0.07582770f, 0.16569048f, -0.08013884f, 0.08128063f, 0.10511266f, 0.19237301f, 
    -0.34912795f, -0.05266328f, 0.02622522f, -0.17205937f, 0.19663633f, 0.03257666f, -0.10170567f, 0.02689580f, 
    -0.06981791f, 0.08414833f, 0.01945610f, 0.02267390f, -0.15464503f, -0.31810281f, -0.27248842f, 0.01260808f, 
    0.05807264f, 0.03333831f, -0.03445901f, 0.05984600f, 0.02936046f, 0.11705671f, 0.06500858f, 0.21579798f, 
    -0.10975292f, -0.15822063f, 0.10642242f, -0.02737635f, -0.06177771f, 0.03980117f, 0.15380910f, -0.04512386f, 
    0.00297791f, -0.21745746f, -0.07839627f, 0.05820220f, -0.26638544f, -0.31093052f, -0.05980633f, -0.07230515f, 
    -0.05447869f, -0.06751634f, -0.01169858f, -0.09183895f, 0.32141227f, 0.03009647f, 0.20350941f, 0.01217883f, 
    0.09354378f, 0.35094565f, 0.41418585f, 0.16908243f, 0.18421100f, -0.02565477f, 0.01820943f, 0.01666328f, 
    -0.09759071f, -0.01428544f, 0.06511307f, 0.16464660f, 0.19222850f, 0.15539512f, 0.16150446f, 0.11420316f, 
    -0.09440873f, 0.04705115f, -0.07466508f, -0.11308569f, -0.10123800f, -0.10985129f, -0.01185189f, -0.06967509f, 
    -0.35390115f, -0.28980768f, -0.21331352f, -0.13980140f, 0.01758967f, 0.17403266f, -0.07862186f, 0.08157587f, 
    -0.00465041f, -0.18869838f, 0.06988952f, 0.09436467f, 0.28073865f, 0.09459199f, 0.18343097f, -0.14159980f, 
    -0.19985086f, 0.18118374f, 0.10414904f, 0.03807080f, 0.01983304f, 0.00027627f, 0.03297336f, 0.12251681f, 
    0.23392124f, 0.29422843f, 0.06718160f, 0.23467539f, 0.09690294f, -0.09113353f, -0.03819439f, 0.03283426f, 
    0.09133553f, 0.07425983f, -0.03715499f, -0.00957638f, -0.09993804f, 0.22447903f, 0.24009281f, 0.05438382f, 
    -0.04072754f, 0.05265031f, 0.13496822f, -0.11732949f, -0.05851247f, 0.05915880f, 0.02181545f, 0.03385608f, 
    0.11162798f, -0.29523587f, 0.13290223f, -0.12213514f, -0.09012359f, 0.12390174f, -0.16043530f, -0.00351040f, 
    0.13422288f, 0.07845745f, 0.00341957f, 0.11856523f, 0.33533302f, -0.35885054f, -0.16409372f, 0.04326446f, 
    -0.10778057f, -0.11182088f, -0.03614525f, -0.05937768f, -0.01529220f, 0.01093905f, 0.01633447f, 0.12639838f, 
    -0.08107799f, 0.17512290f, 0.02227941f, -0.04804894f, 0.05387027f, 0.02084625f, -0.00692615f, -0.13467607f, 
    -0.00866178f, 0.12570544f, 0.21921951f, -0.14432868f, 0.10970692f, -0.21822089f, 0.02126643f, 0.19457020f, 
    -0.06471117f, 0.00470994f, -0.09825173f, 0.02234615f, 0.06610650f, 0.04605129f, 0.05095775f, -0.01803658f, 
    -0.20016865f, 0.15019554f, -0.02483695f, -0.20201910f, -0.00785921f, 0.04844935f, 0.15896988f, -0.00128859f, 
    0.08701168f, 0.10706338f, -0.10339266f, -0.00820364f, 0.01949943f, -0.16552030f, 0.11104889f, 0.10244326f, 
    -0.20953374f, -0.18696362f, 0.02049127f, 0.07966916f, 0.05524343f, -0.13865325f, -0.04364168f, 0.05758409f, 
    0.33986795f, -0.11728831f, -0.08904526f, 0.27964273f, -0.05304594f, -0.03767879f, -0.02805753f, 0.16570283f, 
    0.02213020f, 0.00453304f, -0.04859071f, 0.06811579f, -0.14149225f, -0.07162680f, 0.08662838f, -0.04982417f, 
    0.06798731f, -0.03577879f, 0.03446168f, -0.00739422f, 0.03480598f, 0.01418813f, 0.02682457f, 0.11979391f, 
    -0.11896426f, -0.26596236f, 0.01681038f, -0.37796333f, -0.04310835f, 0.12196299f, 0.08750165f, 0.11255567f, 
    -0.01665102f, 0.05653821f, -0.02256396f, -0.08096258f, 0.12608042f, 0.11505685f, -0.05175541f, 0.09460327f, 
    -0.03180837f, 0.09879304f, 0.01454636f, 0.03937241f, 0.09416859f, 0.11493069f, 0.11557794f, 0.01630190f, 
    -0.01593902f, 0.09920906f, 0.03786309f, -0.02118129f, -0.05404234f, 0.02235231f, 0.08531906f, 0.05788859f, 
    -0.06875329f, 0.12266679f, 0.16975893f, -0.05810929f, 0.05908921f, 0.16489355f, -0.05234202f, 0.12675771f, 
    -0.14005631f, 0.11749639f, -0.01971736f, -0.06661920f, -0.02842555f, 0.06453913f, 0.16253540f, -0.07567047f, 
    0.08644346f, -0.08704301f, 0.00049688f, -0.13220420f, -0.09851819f, -0.09078075f, -0.06605002f, 0.08432854f, 
    0.09502538f, 0.06204443f, -0.04109657f, -0.00452762f, 0.12028532f, -0.20649765f, 0.10869347f, 0.05662255f, 
    -0.00257147f, 0.05552335f, -0.17084689f, 0.17815754f, 0.07084192f, -0.02997465f, -0.01835483f, -0.13935627f, 
    0.38762948f, 0.00310347f, 0.06826525f, 0.32054448f, -0.18281180f, 0.07713360f, -0.04304976f, 0.01271722f, 
    -0.07784659f, -0.06537834f, 0.07591135f, -0.08586506f, 0.03400782f, 0.06037777f, -0.13989709f, 0.37019268f, 
    0.00480602f, -0.08076707f, -0.07134712f, 0.09813122f, -0.03914336f, 0.07887721f, 0.06233540f, 0.07863621f, 
    0.01555117f, 0.31915903f, 0.05798940f, 0.18771744f, -0.22192933f, 0.10856589f, -0.10184141f, 0.02341432f, 
    0.01209510f, 0.11462808f, 0.09197927f, 0.05792380f, 0.54512358f, 0.40810171f, -0.44410512f, 0.20422301f, 
    -0.03591023f, -0.21686901f, 0.14563210f, 0.12033148f, -0.15576617f, -0.08254424f, 0.05721884f, 0.09929463f, 
    -0.09335802f, -0.24507146f, 0.24444720f, 0.12617873f, -0.12041537f, 0.05641391f, 0.15848398f, 0.03611289f, 
    0.03285512f, -0.04827594f, -0.02458245f, 0.04473495f, 0.38023451f, 0.01500841f, 0.31766075f, -0.30579254f, 
    -0.00439434f, -0.03992726f, 0.16846545f, -0.13829957f, 0.05995936f, 0.01949818f, 0.32706434f, -0.16462363f, 
    0.18867238f, 0.00034583f, -0.05287150f, -0.19904025f, -0.01454677f, 0.00620767f, -0.17317474f, 0.04502505f, 
    -0.09207866f, -0.13329719f, 0.00774002f, -0.09472249f, 0.30298120f, -0.47927898f, 0.23983219f, 0.22375314f, 
    0.22712356f, 0.08934074f, -0.09106657f, -0.02382629f, 0.00988895f, 0.03667352f, -0.01472472f, 0.11383961f, 
    0.36659122f, -0.48033652f, 0.18737377f, 0.03658840f, -0.09036387f, 0.08339192f, 0.07209471f, 0.01665957f, 
    -0.01136072f, -0.00508652f, -0.07175369f, -0.04011074f, -0.15934159f, 0.03069936f, 0.25013763f, -0.08580196f, 
    0.00338675f, -0.08478071f, -0.07095292f, -0.06656255f, -0.18925630f, 0.22203842f, -0.05304772f, -0.01206420f, 
    -0.09433735f, 0.07864003f, -0.02859951f, -0.19208215f, -0.17903922f, 0.05543077f, 0.02737603f, 0.02135456f, 
    0.07387246f, -0.17028640f, -0.03898880f, 0.13958260f, 0.05977666f, 0.07969651f, 0.10716549f, -0.02603783f, 
    0.02796623f, 0.10769153f, 0.03204260f, 0.03043502f, 0.05601268f, -0.12509935f, 0.10822007f, 0.16205475f, 
    0.23161399f, -0.17552464f, -0.26575476f, 0.18601733f, 0.02521308f, 0.21533872f, -0.01995738f, -0.04609664f, 
    -0.11400538f, -0.09322451f, -0.04343357f, 0.05046947f, 0.39491409f, -0.43977201f, -0.09639864f, -0.05793440f, 
    -0.11391715f, -0.00432052f, -0.08982442f, -0.01130383f, 0.03492723f, 0.02420663f, -0.13255799f, -0.09884347f, 
    0.40779299f, 0.43967149f, -0.11121748f, 0.04701575f, 0.09304854f, 0.45475498f, -0.02243639f, -0.01592425f, 
    0.04681292f, -0.07436043f, 0.16668464f, 0.11388071f, -0.15258598f, 0.12288991f, 0.03283335f, -0.02323397f, 
    -0.03599712f, -0.03887108f, 0.05182031f, -0.16395998f, -0.07141931f, 0.00456303f, -0.08129391f, -0.09264773f, 
    -0.04905552f, -0.16263245f, 0.20554107f, 0.11501614f, -0.05940383f, -0.10839586f, -0.08074535f, -0.11012514f, 
    -0.07466081f, 0.08739351f, 0.08099825f, -0.20431878f, 0.14334737f, 0.04316940f, 0.15216511f, -0.18342851f, 
    -0.08829816f, -0.04239234f, 0.11333299f, -0.10036215f, 0.04801219f, -0.01806670f, 0.09720363f, 0.02485118f, 
    -0.02382008f, 0.02923861f, -0.12713136f, -0.03854359f, -0.17478471f, -0.01964224f, 0.05904014f, -0.11649822f, 
    0.16826776f, -0.00700032f, 0.08090480f, 0.02712547f, 0.37123463f, 0.01967979f, -0.22498196f, -0.00633363f, 
    -0.07688509f, -0.04770323f, -0.04875888f, -0.04346005f, 0.00206085f, -0.17643939f, -0.00170001f, 0.13682950f, 
    -0.01622915f, -0.17099349f, 0.20123230f, -0.01176169f, 0.07549319f, 0.01663027f, -0.00962696f, 0.04093216f, 
    -0.03791988f, -0.15321665f, 0.12806447f, -0.00110757f, -0.38726741f, 0.04112441f, 0.22127678f, -0.20238853f, 
    0.00073315f, -0.02425030f, 0.20009691f, 0.06670981f, -0.03956281f, 0.10504881f, -0.10907185f, 0.04361058f, 
    0.02835650f, 0.04346478f, 0.18705645f, -0.03111016f, -0.14461309f, -0.02196472f, -0.04808347f, -0.08655659f, 
    0.08346358f, 0.00376777f, 0.01874779f, 0.15785907f, 0.20777601f, -0.23537350f, 0.35352331f, -0.04132310f, 
    -0.08938838f, -0.04903233f, -0.00301315f, -0.05226121f, 0.02470217f, 0.01611270f, 0.01660568f, 0.16680627f, 
    -0.28511199f, 0.03928039f, 0.10965037f, -0.12254634f, -0.06875291f, 0.07651357f, -0.03670846f, 0.07407704f, 
    0.02067008f, 0.13734116f, 0.06190868f, -0.08536410f, -0.09997059f, 0.03314007f, 0.22405206f, 0.14880355f, 
    -0.09679556f, 0.13126002f, -0.06934173f, 0.10231175f, 0.06370988f, 0.00039861f, 0.10401079f, 0.12914431f, 
    0.21955064f, -0.01513223f, 0.06973483f, 0.01426575f, -0.05828131f, 0.07851209f, -0.01127631f, 0.00725946f, 
    0.14461896f, -0.11120538f, -0.02466696f, 0.04594551f, -0.50111204f, 0.25199157f, 0.18547305f, 0.09826499f, 
    -0.05896466f, -0.28356060f, -0.04061290f, -0.07677365f, 0.18291408f, -0.10452163f, 0.06978264f, 0.13754702f, 
    -0.51866144f, -0.44489968f, 0.12602937f, 0.44523612f, 0.18430209f, 0.11028267f, 0.10222828f, 0.04804442f, 
    -0.07240051f, -0.05584906f, 0.18334958f, 0.10540102f, 0.10852879f, -0.06773775f, 0.02861901f, -0.15549082f, 
    0.08702133f, 0.02908449f, -0.01129521f, 0.01293317f, 0.09876398f, -0.05397241f, -0.05131619f, -0.03312340f, 
    -0.12719518f, 0.17377691f, 0.08206887f, 0.18222146f, -0.04821307f, 0.22663476f, 0.01334494f, 0.09745611f, 
    -0.06308922f, 0.01895351f, -0.13994060f, 0.00376079f, -0.00504781f, -0.12997845f, 0.04387913f, 0.20949419f, 
    -0.07954057f, 0.09863280f, 0.00754574f, -0.04413857f, -0.06102074f, -0.14240019f, -0.06380259f, 0.05744468f, 
    0.06716645f, -0.06115514f, 0.19715160f, 0.29934785f, 0.07225833f, -0.15119521f, 0.01117352f, -0.11096395f, 
    0.05524899f, 0.02880590f, -0.00480067f, 0.18568304f, 0.45887089f, -0.25714901f, 0.09326953f, -0.13634509f, 
    0.01878845f, -0.12211204f, 0.07379673f, -0.03205213f, -0.09586383f, 0.07492688f, 0.13098955f, -0.14188068f, 
    0.01652884f, 0.03012537f, -0.07720818f, -0.05612786f, -0.06218620f, 0.00728098f, -0.05057536f, -0.07240783f, 
    -0.02518204f, 0.06469849f, 0.03504308f, -0.07156105f, 0.03745192f, -0.04591745f, 0.01387342f, 0.03557973f, 
    0.03302293f, 0.03919213f, -0.07815982f, 0.02744326f, -0.06962501f, -0.05430622f, 0.05834138f, -0.03578271f, 
    -0.02846077f, -0.07759077f, 0.00216778f, 0.04870109f, 0.03205938f, -0.06534234f, 0.05757396f, 0.03129968f, 
    -0.07079933f, 0.04806817f, -0.05129563f, 0.02891295f, 0.02636389f, 0.03444918f, 0.01610312f, 0.05507873f, 
    0.01829724f, 0.06525598f, 0.00080514f, 0.00363843f, -0.03421175f, -0.04680824f, 0.00234175f, -0.07324409f, 
    -0.05822166f, -0.02352445f, -0.04583327f, -0.04429710f, -0.06331092f, -0.06098774f, -0.05689627f, 0.05382136f, 
    -0.02155891f, -0.07725979f, -0.03436819f, -0.04811757f, -0.00758592f, 0.06358622f, -0.07271758f, -0.01338049f, 
    -0.00716078f, 0.01281366f, -0.07642349f, -0.05001760f, 0.04549094f, -0.02180039f, -0.02925293f, 0.05438838f, 
    0.01062450f, 0.03601987f, -0.06085135f, -0.00909305f, 0.03555128f, -0.07312800f, 0.00197886f, -0.01399759f, 
    0.04285325f, -0.03770984f, -0.01747205f, -0.07511219f, 0.01750379f, 0.01395859f, 0.00126875f, 0.05829272f, 
    -0.06305599f, -0.07028528f, 0.02572407f, -0.00567218f, -0.04884282f, 0.06399159f, 0.00661363f, -0.06878766f, 
    -0.05617556f, -0.01256877f, -0.04865597f, -0.06158243f, -0.02681968f, -0.02373809f, 0.02827671f, -0.06319048f, 
    0.02622482f, -0.07389355f, 0.01516827f, -0.04096564f, -0.00755493f, -0.02762942f, -0.03223188f, 0.00664048f, 
    -0.06240749f, -0.04529855f, -0.04543400f, 0.00955849f, -0.01032128f, -0.03367250f, -0.06653031f, -0.04759121f, 
    -0.04462313f, 0.00851471f, 0.02716091f, 0.05066362f, -0.06351964f, 0.05824700f, 0.02163512f, -0.04981846f, 
    -0.06846432f, 0.04605918f, 0.04700207f, 0.03079870f, -0.08090544f, 0.03310065f, 0.02510836f, -0.01951247f, 
    -0.00563898f, -0.03158980f, -0.01298681f, 0.04665735f, -0.05950841f, -0.01128971f, -0.07014432f, 0.06181823f, 
    0.04963209f, -0.05327403f, 0.04433539f, 0.00609570f, 0.02342157f, 0.05479595f, 0.03973993f, 0.04145705f, 
    -0.06315026f, -0.06846341f, 0.05775296f, 0.02299970f, -0.02322934f, -0.08185991f, -0.03534216f, -0.05303276f, 
    -0.04436629f, -0.01208619f, 0.00908467f, -0.00332312f, -0.02939479f, 0.00387165f, 0.04918888f, 0.01286365f, 
    -0.04724532f, -0.07397322f, 0.03218627f, 0.05911129f, 0.02770776f, 0.06030147f, 0.00651087f, -0.06382898f, 
    0.03353457f, 0.03806202f, -0.00042982f, 0.05066209f, -0.03203700f, 0.02210831f, 0.03784629f, -0.06695924f, 
    0.06126269f, 0.01860199f, -0.06245537f, -0.06589439f, 0.01226016f, 0.02017841f, -0.04908528f, -0.03525570f, 
    0.14489779f, -0.28061125f, -0.18932872f, -0.01504173f, 0.17965625f, 0.06185248f, 0.08715909f, 0.14323980f, 
    0.03827705f, 0.00119828f, 0.23844017f, 0.18105406f, 0.07108861f, 0.00321786f, -0.07326838f, 0.21898526f, 
    0.07123824f, 0.03413238f, 0.06365319f, -0.03663335f, -0.03156131f, 0.00627677f, -0.03008921f, -0.22356993f, 
    0.22890812f, -0.17732930f, -0.05360491f, -0.00552326f, 0.01178398f, -0.00367253f, 0.07892797f, 0.06318349f, 
    -0.12242711f, 0.04905980f, -0.06011585f, 0.13116413f, -0.21057791f, -0.03055165f, -0.00728239f, -0.06546655f, 
    -0.12910472f, -0.03950086f, 0.02515304f, 0.15214559f, 0.22241057f, 0.08215527f, 0.11093256f, -0.04393918f, 
    -0.25966728f, -0.15089469f, 0.07637503f, 0.04886299f, -0.16814493f, -0.02386785f, -0.01968128f, -0.01277035f, 
    -0.02630883f, -0.00825535f, -0.20778550f, -0.04196013f, -0.10490686f, 0.15256564f, -0.09294292f, 0.14409417f, 
    -0.04517746f, 0.06454575f, -0.07447272f, 0.05217364f, -0.13296138f, 0.08373903f, -0.06097532f, 0.03894780f, 
    -0.11109336f, 0.06149313f, 0.17209195f, -0.08279952f, 0.01108781f, 0.07650472f, 0.12927088f, 0.10281590f, 
    0.03646359f, 0.08166950f, -0.13697977f, 0.08404922f, 0.02650429f, 0.14111890f, -0.03016532f, 0.15058441f, 
    -0.07232247f, 0.09807628f, 0.01520983f, -0.00807903f, -0.07369226f, 0.24656582f, 0.04525686f, -0.00820393f, 
    0.16643119f, 0.29743716f, -0.45415032f, 0.02199229f, -0.13816079f, -0.15670152f, 0.01845098f, -0.14725989f, 
    -0.06847362f, -0.00979695f, 0.00611978f, 0.00481487f, 0.03037144f, -0.20475142f, -0.02939309f, 0.28486845f, 
    0.03320500f, 0.13042697f, 0.15246122f, 0.19301495f, 0.12142783f, 0.10394587f, -0.04008655f, 0.02176161f, 
    0.22257966f, 0.14341652f, 0.17995140f, 0.15348999f, 0.17256385f, -0.09892478f, 0.07909040f, 0.02178092f, 
    0.09140057f, 0.05171880f, 0.01150667f, -0.03628635f, 0.55556458f, 0.00594085f, -0.16548453f, -0.00747830f, 
    -0.08953673f, -0.23956008f, -0.17843632f, -0.00325719f, -0.15179959f, -0.10666329f, 0.08471215f, -0.08255786f, 
    -0.16050333f, 0.21199869f, 0.01522437f, 0.17970012f, -0.02297027f, -0.11352073f, -0.02561585f, 0.11006565f, 
    -0.26421520f, 0.05919254f, 0.26326120f, 0.06250183f, -0.02825534f, 0.19534372f, 0.02190840f, 0.00076485f, 
    0.07078061f, 0.02887196f, -0.06308232f, -0.06801262f, 0.00418896f, -0.01366041f, -0.16388398f, -0.11258826f, 
    0.33721918f, 0.29536831f, 0.27369472f, -0.01607850f, 0.09103039f, 0.03358714f, -0.05980778f, 0.13972606f, 
    -0.10562516f, -0.04230055f, -0.01838022f, -0.15066554f, -0.10877262f, -0.06717981f, 0.01419366f, 0.11955980f, 
    0.09580332f, 0.02889098f, 0.23856086f, -0.01947849f, 0.10315727f, -0.03119629f, 0.05377148f, 0.11695901f, 
    -0.14047861f, 0.37001517f, 0.18455392f, 0.07349420f, 0.06241342f, -0.11230356f, 0.06299981f, -0.01667936f, 
    0.00445473f, -0.05968941f, 0.27199915f, -0.16543578f, -0.42085820f, 0.55680317f, 0.10717328f, -0.12932220f, 
    0.17758317f, 0.18401212f, 0.10349348f, -0.03976240f, -0.01487922f, -0.03979026f, 0.04877403f, -0.10880122f, 
    0.17563602f, -0.09850522f, 0.03594248f, -0.04319451f, -0.09895081f, 0.10460867f, 0.02362925f, 0.02340782f, 
    0.09846408f, 0.07911361f, -0.20985781f, 0.18001333f, -0.18068556f, 0.26532310f, 0.03648932f, -0.02977532f, 
    0.14330176f, -0.06204805f, 0.18189248f, 0.02143938f, 0.07716162f, 0.11149697f, 0.26041427f, -0.01953903f, 
    0.13570873f, -0.11341749f, 0.11096615f, 0.23920892f, 0.04915985f, 0.03195064f, 0.03345551f, 0.05075625f, 
    -0.11493807f, -0.03082780f, -0.07651707f, 0.05679318f, -0.16809672f, 0.12747699f, -0.07963655f, 0.02216576f, 
    0.14133641f, 0.14633034f, 0.09339090f, 0.00804813f, -0.06916094f, 0.16872706f, 0.10845250f, -0.10356248f, 
    -0.38476083f, -0.00169590f, 0.00950956f, -0.12950025f, 0.10980593f, 0.02306849f, 0.12397705f, -0.09048118f, 
    0.00174776f, 0.01523001f, -0.00900998f, 0.15556349f, 0.11802036f, 0.05208676f, -0.13404545f, -0.18574089f, 
    -0.09995479f, -0.04761688f, 0.00858866f, 0.16319486f, 0.01369609f, 0.26499891f, -0.08376084f, -0.11696738f, 
    -0.09293493f, 0.48952898f, 0.10511748f, 0.07062938f, 0.13531487f, -0.08235816f, -0.10085290f, 0.01897986f, 
    0.00726662f, 0.00709177f, 0.01848312f, 0.00908853f, 0.11322173f, -0.12593001f, 0.10640217f, -0.14795117f, 
    -0.00242212f, 0.00338569f, 0.08301532f, 0.11304312f, -0.15225492f, -0.02180404f, -0.06427751f, 0.05901226f, 
    0.35100475f, 0.16548525f, -0.21934828f, -0.11888907f, 0.11568221f, 0.01385018f, -0.14409545f, -0.01757581f, 
    -0.01361565f, 0.01007330f, 0.01615801f, 0.00396573f, -0.03563663f, -0.14331694f, -0.03930902f, -0.02750408f, 
    0.13218088f, -0.00384041f, -0.05765606f, -0.01824263f, -0.00124080f, -0.00727309f, -0.01245098f, 0.15058829f, 
    -0.19920237f, 0.08843735f, 0.01221851f, -0.03795406f, 0.02794435f, 0.02671196f, 0.16428779f, -0.05593134f, 
    -0.00897946f, 0.03005710f, 0.02420782f, 0.11018591f, 0.05117226f, 0.38837790f, 0.03974536f, 0.14177515f, 
    -0.07253796f, 0.01338081f, 0.26937962f, -0.02265212f, -0.07868905f, 0.08448182f, 0.01232646f, 0.15102661f, 
    -0.13395987f, 0.04268634f, -0.10444898f, -0.08823546f, 0.27700570f, -0.09586426f, 0.04849987f, 0.01461966f, 
    0.04790090f, 0.08839213f, -0.04839296f, -0.01926934f, -0.04648416f, -0.03629241f, 0.19500788f, -0.27362248f, 
    0.02755771f, 0.08608089f, 0.06419862f, -0.12102538f, 0.08002736f, 0.02757790f, 0.08288870f, 0.19328821f, 
    0.14994307f, -0.11566714f, 0.07038624f, 0.00585197f, 0.16810775f, -0.07132344f, 0.06688132f, 0.06747721f, 
    0.11531392f, 0.11733121f, -0.23225319f, 0.11539906f, 0.22535497f, -0.42622390f, -0.00747288f, 0.04458988f, 
    0.11332662f, -0.03134764f, -0.08710493f, 0.00423275f, 0.07878788f, 0.05269772f, -0.02875388f, 0.20817783f, 
    -0.24662715f, 0.20087987f, -0.02255253f, 0.08884018f, 0.20911857f, -0.04664411f, -0.01199429f, -0.06857497f, 
    -0.08162618f, -0.08704513f, 0.31863686f, -0.00136233f, -0.24590832f, -0.02964927f, -0.15673830f, 0.07018292f, 
    0.05186351f, -0.00261073f, -0.13455950f, -0.00723971f, -0.15019238f, -0.02330753f, -0.16907097f, -0.00345440f, 
    -0.25477821f, 0.04439586f, 0.00007476f, -0.07884259f, 0.03731169f, 0.03623572f, 0.10373148f, 0.04569233f, 
    0.18136171f, 0.14900598f, 0.14925602f, 0.10229095f, -0.26563671f, -0.04354948f, -0.06200858f, -0.16013981f, 
    -0.16045658f, -0.00070208f, 0.00669159f, 0.07416039f, 0.16684559f, -0.06944700f, 0.05465358f, 0.08346294f, 
    0.03254680f, 0.25558081f, -0.20092058f, 0.22684191f, 0.19777933f, 0.07721788f, -0.05084946f, 0.19185035f, 
    0.01882796f, -0.04116574f, 0.06939071f, -0.05803951f, -0.03199996f, -0.03733243f, -0.03890235f, 0.02137195f, 
    0.13694376f, 0.08505949f, 0.06065108f, -0.02003183f, 0.09988466f, -0.14873357f, 0.08157356f, 0.25547338f, 
    -0.06825874f, -0.34070322f, 0.20371908f, -0.09469816f, 0.02701136f, 0.11227965f, 0.03575758f, 0.14455740f, 
    0.05628528f, 0.04411642f, 0.05271869f, 0.03129691f, -0.21926583f, 0.05155513f, -0.12963676f, -0.08919407f, 
    -0.02218172f, 0.04042231f, -0.04636279f, -0.01360367f, 0.12946518f, 0.05174840f, 0.07198017f, -0.03967012f, 
    0.24781109f, 0.09494686f, 0.27480042f, 0.15226917f, 0.00699372f, 0.04630684f, 0.10835968f, -0.02361792f, 
    0.09624941f, -0.00087251f, 0.07487996f, 0.06707581f, -0.07272902f, 0.15096374f, 0.18798845f, 0.11877731f, 
    -0.03672609f, 0.09843171f, 0.09585591f, 0.20051311f, 0.00355089f, 0.03680974f, 0.10517000f, -0.09072539f, 
    0.09827293f, -0.24689567f, -0.19439127f, -0.14170437f, 0.05376395f, -0.06192424f, -0.06521002f, 0.11723824f, 
    0.09190729f, 0.03543457f, -0.07802520f, -0.18481277f, 0.33169416f, -0.49572438f, 0.09403159f, 0.11029237f, 
    0.08048348f, -0.00752217f, -0.06332313f, 0.04724423f, 0.22063315f, 0.01152168f, 0.14694884f, 0.05271214f, 
    0.31096983f, -0.01484244f, 0.11667396f, 0.15548794f, -0.05440353f, -0.00957957f, -0.02494560f, 0.05952641f, 
    0.16868742f, 0.01463178f, 0.13479543f, 0.15872435f, -0.01267516f, -0.02888793f, -0.17548917f, 0.16559769f, 
    0.09417372f, 0.03294340f, -0.10984486f, 0.09891542f, -0.00726687f, -0.00436057f, 0.00906932f, -0.14752883f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.07526371f, 0.02502024f, -0.10900642f, 0.06078097f, -0.00442577f, -0.03389427f, -0.02072776f, 0.11455497f, 
    -0.04828486f, -0.02919460f, -0.01722568f, 0.06927831f, 0.03515697f, 0.04189036f, -0.01274689f, -0.05770625f, 
    -0.03780836f, 0.00341147f, 0.15815555f, 0.10068449f, 0.16128469f, 0.09047107f, 0.01716376f, -0.05851041f, 
    0.07722125f, -0.08631700f, -0.18360028f, -0.01579555f, 0.02234129f, 0.02988213f, 0.03107085f, 0.12797002f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.33646125f, 0.18008962f, -0.28482568f, 0.41251308f, -0.10993150f, -0.59710187f, 0.06853282f, -0.35698044f, 
    -0.13954648f, 0.16363581f, 0.14650056f, -0.13359350f, 0.42636743f, 0.22035909f, 0.05486811f, 0.23391052f, 
    0.16332194f, -0.13135022f, 0.18479727f, -0.00275208f, 0.31176406f, 0.13429277f, 0.33070543f, 0.08774768f, 
    -0.03077001f, 0.27462435f, 0.41213429f, 0.27290949f, -0.02350227f, -0.24372658f, -0.13638259f, -0.00768228f, 
    0.25382224f, -0.06084105f, 0.23726358f, 0.26412240f, 0.21814021f, 0.36328372f, -0.17499301f, -0.05807432f, 
    0.12739846f, 0.10721958f, -0.05236004f, 0.10727299f, -0.72069693f, -0.22777300f, -0.27357128f, -0.16195785f, 
    0.21397339f, -0.06336945f, -0.04584103f, 0.01601640f, -0.00738601f, -0.31585494f, -0.10510071f, 0.04868066f, 
    0.35673466f, 0.30249590f, 0.26787594f, -0.02415266f, 0.09781522f, 0.06324367f, 0.04530261f, 0.23231383f, 
    0.46209252f, 0.18563084f, -0.10684476f, -0.17494482f, 0.29754284f, 0.26931140f, 0.04509427f, 0.12580575f, 
    -0.13942190f, -0.12960403f, -0.13592355f, -0.02710027f, -0.23491764f, -0.06091401f, -0.07687902f, -0.14415795f, 
    0.07940906f, 0.10876098f, 0.10829136f, 0.37037531f, -0.10242724f, -0.05537469f, -0.20474519f, 0.17690653f, 
    0.13751550f, 0.20567513f, -0.01386154f, -0.18433030f, 0.03955346f, -0.05948249f, -0.16424751f, 0.35539678f, 
    0.12955232f, -0.04077802f, 0.25292528f, 0.06583130f, -0.02619893f, 0.36961997f, 0.08889983f, -0.22128361f, 
    -0.03467024f, 0.13973297f, 0.02997728f, 0.51586086f, 0.51930469f, 0.21665525f, -0.50930142f, 0.27811578f, 
    -0.20032839f, -0.14494716f, -0.22465852f, -0.51451951f, -0.14091988f, -0.19282052f, 0.36868042f, -0.09080397f, 
    0.05319224f, 0.04364461f, -0.09375267f, -0.37480241f, -0.11310883f, 0.17923893f, 0.17207855f, 0.00574400f, 
    -0.10035171f, -0.13082841f, -0.31177920f, 0.08000529f, 0.26298082f, 0.11949045f, 0.15536121f, 0.36147782f, 
    -0.02477226f, 0.07247154f, 0.06534375f, -0.12224418f, 0.26919833f, -0.58155233f, 0.27329046f, 0.17272921f, 
    -0.27882782f, -0.02828500f, 0.44548979f, 0.05887869f, -0.10856690f, 0.30417398f, -0.27254269f, 0.02281391f, 
    -0.13104486f, -0.03090602f, 0.36247984f, 0.30861476f, -0.16272254f, 0.28505459f, -0.00375816f, 0.05863049f, 
    -0.49607971f, -0.05058051f, 0.25708526f, -0.01734321f, 0.28786927f, 0.11066262f, 0.08098872f, -0.15940408f, 
    -0.03969797f, -0.14326394f, -0.12949809f, 0.07581589f, 0.04801765f, 0.18806121f, 0.31034654f, 0.15300289f, 
    0.01081473f, 0.09234763f, 0.44031793f, 0.06470965f, 0.10467372f, -0.41049299f, 0.23116334f, 0.02705823f, 
    -0.24998359f, -0.13637249f, 0.41634819f, 0.11850946f, -0.02992897f, 0.13755305f, -0.24060278f, -0.08624160f, 
    -0.13662300f, 0.23160368f, -0.32728663f, 0.15480129f, -0.32537162f, -0.15794939f, -0.16720174f, 0.20804566f, 
    -0.11202879f, -0.11843082f, 0.06014708f, -0.11747665f, 0.18185030f, 0.09030072f, -0.31197256f, 0.11193563f, 
    -0.24583171f, -0.08660780f, -0.27561709f, -0.12785651f, 0.06811149f, 0.48147300f, -0.49286690f, 0.02089316f, 
    0.31287485f, -0.06199203f, 0.22528177f, 0.04590374f, -0.14457646f, 0.42423347f, 0.33859724f, 0.24208480f, 
    -0.00335655f, 0.11087062f, -0.13735685f, -0.20029238f, -0.09746934f, 0.13796023f, -0.16247424f, -0.12412494f, 
    0.00351068f, -0.05541407f, -0.14184247f, -0.09764240f, -0.15932573f, 0.01535987f, -0.05341458f, -0.11194707f, 
    -0.02912851f, 0.10152664f, 0.11851386f, -0.18425107f, -0.01601068f, 0.03405608f, -0.08553769f, 0.05564838f, 
    -0.12466345f, -0.13503003f, -0.11103283f, -0.00501322f, -0.01574735f, 0.01721184f, 0.01452277f, -0.06816602f, 
    -0.00120898f, 0.25776392f, -0.23573342f, -0.22546229f, 0.00300153f, 0.18004438f, -0.06438597f, 0.18999954f, 
    -0.15847418f, -0.12835231f, -0.16000251f, 0.20697106f, 0.35611358f, 0.10672732f, -0.22240900f, -0.06526345f, 
    -0.12837270f, -0.12200546f, 0.13123472f, -0.11495350f, 0.18822965f, -0.40861008f, 0.28970653f, 0.09005212f, 
    0.16005108f, -0.02033005f, 0.28175765f, 0.31672645f, 0.01679115f, 0.08145376f, 0.16827953f, -0.25490007f, 
    0.45112759f, 0.06718905f, 0.05433280f, -0.03928701f, 0.21541758f, 0.25724086f, -0.08737236f, -0.08948445f, 
    0.08453806f, 0.10050118f, 0.07941776f, 0.31047767f, 0.13676259f, 0.13918425f, -0.25524864f, 0.10482871f, 
    0.22998819f, -0.05425776f, 0.25809944f, -0.04659405f, 0.03295182f, -0.44119054f, 0.28805554f, -0.05663656f, 
    -0.02660639f, 0.24030748f, -0.25993934f, -0.08477116f, -0.06902058f, -0.29256541f, -0.12104295f, 0.34854385f, 
    -0.07642692f, 0.39766529f, 0.06689770f, 0.29322553f, -0.01734386f, -0.51468980f, -0.09939830f, -0.15065517f, 
    0.07727151f, -0.08097254f, 0.05985907f, 0.41078639f, 0.08935495f, -0.33930108f, 0.05884667f, 0.33714220f, 
    0.12291594f, 0.07143774f, 0.01557695f, 0.27605149f, 0.25824070f, 0.21918155f, -0.01196845f, -0.05960203f, 
    -0.26308566f, -0.26312345f, -0.13068704f, -0.60051590f, 0.02957983f, -0.00707934f, 0.20132232f, 0.05358615f, 
    0.10429685f, 0.16597439f, 0.06519470f, -0.11435236f, -0.03786324f, -0.24592741f, -0.03910373f, 0.22458822f, 
    0.00073051f, 0.07701711f, -0.07541063f, -0.26186943f, -0.06053863f, 0.04118662f, 0.03962139f, -0.30431771f, 
    0.14673251f, 0.17367910f, -0.05099513f, 0.04473752f, -0.20877491f, -0.31773016f, 0.04532454f, -0.17224906f, 
    -0.11691152f, 0.20349383f, 0.02187340f, 0.17676090f, -0.07714686f, -0.21300691f, -0.05253750f, 0.04818562f, 
    -0.51450813f, -0.06850741f, 0.38501152f, 0.42903742f, -0.26461911f, -0.32444873f, -0.02575509f, -0.03449894f, 
    0.15063383f, 0.06348114f, 0.01940275f, 0.39460221f, -0.10030061f, -0.17468549f, 0.18916877f, -0.12376089f, 
    0.15820108f, -0.09022383f, 0.25021461f, -0.02067291f, 0.36924538f, 0.15292282f, -0.00706096f, -0.14814381f, 
    0.17585048f, 0.13862793f, -0.02192501f, -0.19542746f, -0.05389914f, 0.18729204f, 0.15354602f, -0.20541731f, 
    0.10444495f, -0.02521196f, 0.04334209f, 0.11734787f, 0.12533854f, 0.22282730f, 0.13001603f, 0.22005126f, 
    -0.08080872f, -0.03109401f, -0.16293065f, -0.02434210f, -0.08152935f, -0.33472785f, -0.08319188f, -0.11405580f, 
    -0.14268883f, 0.11457394f, 0.29017088f, 0.13939331f, 0.07436729f, 0.00344557f, -0.08360678f, 0.01243509f, 
    0.11261956f, 0.24651812f, 0.06712794f, -0.03672967f, 0.07826997f, -0.03151285f, -0.09988845f, 0.39504403f, 
    -0.44797304f, 0.12681112f, 0.10247011f, -0.19053012f, -0.12493604f, 0.05855226f, -0.15611409f, 0.06787166f, 
    -0.15915646f, -0.06535434f, -0.10636060f, -0.04160288f, 0.49954554f, 0.29280502f, 0.10860711f, 0.09560722f, 
    -0.25342757f, -0.01556058f, -0.10501432f, 0.05320287f, 0.30464426f, 0.45365176f, -0.04613357f, 0.08374688f, 
    0.08250030f, -0.30993852f, -0.16478136f, 0.22830907f, 0.09040579f, 0.02033981f, 0.01258656f, -0.01789630f, 
    -0.16301365f, -0.24003862f, 0.19517089f, 0.03182532f, 0.26379925f, 0.22812474f, -0.15449557f, 0.25257981f, 
    0.01200173f, 0.16175690f, -0.17142446f, 0.17036761f, -0.01300217f, 0.12705190f, 0.20053692f, 0.38018680f, 
    -0.12652107f, 0.00496636f, 0.52173263f, 0.01930268f, -0.20456441f, 0.09073154f, 0.32702044f, -0.13140760f, 
    -0.24591254f, 0.03903577f, 0.14703748f, 0.24862488f, 0.01541011f, 0.01344948f, 0.12141424f, -0.13340677f, 
    -0.15715826f, -0.14360963f, 0.10610804f, 0.23599508f, 0.06632335f, 0.51826030f, 0.12404252f, 0.06924019f, 
    0.08447924f, -0.14297426f, -0.05275991f, 0.05170772f, 0.05482304f, 0.47443253f, -0.10266200f, -0.28080267f, 
    -0.01701650f, 0.06021541f, 0.19807343f, 0.33208463f, -0.20934692f, -0.00194017f, 0.12178566f, 0.16216448f, 
    0.09686486f, 0.15449518f, -0.28105780f, 0.41358995f, 0.01241568f, -0.34951159f, -0.09661187f, 0.47983149f, 
    0.10639257f, -0.12981260f, 0.02919900f, -0.04539731f, -0.02163910f, -0.04816997f, 0.04215778f, 0.07712633f, 
    -0.16449676f, -0.10282375f, -0.17409937f, 0.08905109f, -0.03515391f, -0.13912149f, -0.20160598f, -0.18380907f, 
    -0.03655284f, 0.13242264f, -0.21707767f, -0.14470370f, -0.00128696f, -0.00463629f, -0.07022494f, 0.01551988f, 
    0.03404680f, 0.06429530f, -0.22827941f, -0.05093385f, 0.00422040f, 0.08150513f, 0.00480964f, -0.17519316f, 
    0.29531452f, 0.07104401f, -0.08726273f, 0.19694713f, -0.20412906f, -0.18674442f, -0.06702912f, -0.23692125f, 
    -0.08062161f, 0.07809552f, 0.09222137f, -0.21717751f, 0.24555828f, -0.14066461f, -0.07934886f, 0.30342963f, 
    0.27981353f, -0.11080699f, -0.21494432f, 0.10451507f, 0.37578812f, 0.24575275f, 0.16765304f, 0.14779919f, 
    -0.07286887f, 0.16356173f, 0.01962931f, -0.15626571f, -0.12251948f, 0.32290849f, -0.20553261f, 0.08674724f, 
    0.02404344f, -0.16951531f, -0.04865665f, -0.04618213f, 0.03954859f, -0.01415654f, 0.05417293f, -0.06868301f, 
    0.16261384f, 0.09833557f, -0.13505587f, 0.03699914f, -0.07451674f, 0.05593852f, -0.11982738f, -0.11371729f, 
    0.03012655f, 0.10247365f, 0.04880056f, 0.15316904f, -0.03968691f, 0.07381129f, -0.14872091f, -0.14176527f, 
    -0.04685391f, 0.11008240f, 0.14721482f, 0.01733299f, -0.17539050f, 0.00111096f, -0.16791107f, -0.07304912f, 
    -0.56909776f, -0.34574530f, 0.40962854f, -0.03145346f, -0.25296682f, 0.08924472f, 0.15654808f, -0.02793425f, 
    0.06601709f, -0.08895706f, 0.13083743f, 0.13143741f, 0.04674539f, -0.02979852f, 0.35076872f, 0.44350091f, 
    -0.09217756f, 0.05571316f, -0.07421330f, -0.29522818f, 0.12474685f, 0.27995259f, 0.14075544f, -0.07600582f, 
    0.11462499f, 0.04360589f, 0.03351707f, 0.39359069f, -0.01636382f, 0.21912900f, -0.04387655f, -0.21750279f, 
    -0.55770290f, 0.20209451f, 0.12854183f, 0.11229863f, -0.09898823f, -0.06449954f, 0.01061847f, 0.27083552f, 
    -0.10680353f, 0.16473633f, 0.11507840f, 0.18794449f, -0.15215981f, 0.36436915f, 0.36289364f, 0.26734546f, 
    -0.06391896f, -0.06518827f, -0.01492925f, -0.00802779f, -0.03666725f, 0.52723461f, -0.11129282f, -0.06339044f, 
    0.13622656f, -0.32169980f, -0.17829426f, -0.12199745f, 0.15749736f, 0.09023718f, 0.28175521f, -0.22752100f, 
    -0.24791989f, -0.11718529f, 0.32867783f, -0.30131435f, -0.34280679f, 0.44117278f, -0.10340596f, 0.13411139f, 
    0.06583150f, -0.00155347f, -0.16206101f, 0.03378571f, -0.29528975f, 0.55209661f, 0.11936928f, 0.05448951f, 
    0.23146969f, 0.13457687f, -0.16234376f, 0.05160415f, -0.08901478f, -0.04215422f, -0.17303261f, -0.03428376f, 
    0.24888176f, 0.12510449f, 0.00013016f, 0.33309016f, 0.05295118f, 0.25668585f, -0.25307190f, 0.33371097f, 
    -0.17441365f, 0.05581237f, 0.37046036f, 0.44717595f, -0.28223914f, 0.25581291f, -0.08682919f, -0.15829937f, 
    0.07166625f, 0.13992715f, 0.10623188f, 0.01205582f, -0.39475164f, -0.09280791f, -0.16878101f, 0.14279491f, 
    0.20257306f, 0.02392767f, -0.28297442f, -0.09105844f, -0.19129749f, 0.24210666f, -0.31995094f, -0.01234715f, 
    0.32581773f, 0.22191800f, -0.16128813f, -0.30873722f, -0.14664192f, 0.41065311f, 0.13209258f, 0.09378623f, 
    -0.23491848f, 0.30847552f, 0.23022357f, -0.11285346f, 0.25864169f, 0.09293184f, 0.14323348f, 0.36989567f, 
    0.05538995f, 0.15925404f, -0.12999016f, 0.31653070f, -0.62204951f, -0.10530657f, -0.00091915f, -0.26558483f, 
    -0.23154701f, -0.01351988f, 0.20420572f, 0.34263653f, -0.31089985f, -0.11424395f, -0.23339790f, -0.06993093f, 
    0.19280900f, -0.19180314f, 0.44763133f, -0.18670142f, -0.17108408f, -0.00313496f, 0.40621787f, -0.13937332f, 
    -0.27185911f, 0.28617704f, -0.39946648f, 0.03334910f, 0.14711909f, -0.23190688f, -0.09816812f, 0.39624983f, 
    -0.03550358f, 0.16197725f, -0.05143877f, 0.00246596f, -0.03835509f, -0.20626692f, 0.21733041f, -0.34464586f, 
    -0.30060750f, 0.07320984f, 0.45302919f, 0.20134850f, 0.29592752f, 0.26636136f, -0.09482401f, -0.13692653f, 
    -0.24658066f, -0.05079189f, -0.09054755f, -0.03563627f, 0.12876402f, 0.05472446f, 0.29428694f, 0.03627257f, 
    0.16101708f, 0.00728068f, 0.26234543f, -0.32625955f, 0.25733522f, 0.64009768f, 0.12338245f, 0.12967405f, 
    0.09128329f, 0.08479057f, -0.03774239f, 0.13348316f, 0.18782659f, 0.15836284f, 0.04728801f, 0.37824282f, 
    -0.16107300f, 0.09354044f, -0.36752740f, -0.15312694f, -0.01680108f, -0.14379770f, -0.12964353f, -0.03441699f, 
    -0.10616552f, 0.15398526f, -0.31408739f, 0.15395650f, -0.08170408f, 0.36585978f, 0.02699408f, 0.04732234f, 
    0.41725370f, 0.09540545f, 0.21817571f, -0.33388934f, 0.25351650f, -0.17233837f, 0.12536910f, 0.16456006f, 
    0.10926252f, -0.15549044f, 0.02378460f, -0.14823511f, -0.39658770f, -0.68067390f, 0.03236056f, -0.03709396f, 
    0.33624926f, 0.06785213f, -0.41897321f, 0.23098293f, 0.23335870f, -0.24635881f, 0.06068041f, 0.14551142f, 
    0.08404879f, 0.39606333f, 0.25237629f, -0.12144222f, -0.10190762f, 0.41910219f, -0.21929806f, 0.04823092f, 
    0.32973915f, 0.00929559f, -0.18871284f, -0.00128675f, -0.35610488f, -0.15478185f, -0.17095621f, -0.08337620f, 
    -0.04919416f, -0.04672022f, -0.01377530f, -0.19433071f, 0.28281409f, 0.59091002f, -0.15062042f, -0.06365836f, 
    0.23928620f, -0.04798115f, -0.44551107f, 0.11038934f, -0.28884754f, 0.24226838f, -0.46005780f, -0.00521603f, 
    0.29243505f, 0.02471733f, -0.17210093f, -0.07629933f, -0.02895210f, 0.03367366f, -0.08949580f, 0.20000504f, 
    0.21230985f, 0.38876083f, -0.12716210f, -0.22020197f, 0.17059737f, -0.29303902f, 0.14776136f, -0.17035942f, 
    -0.06291985f, -0.16005597f, 0.02294213f, -0.20582908f, 0.64233178f, 0.70278770f, 0.38646460f, -0.00476510f, 
    0.11981634f, -0.14520179f, -0.28108007f, 0.01093187f, -0.24763678f, -0.23681147f, 0.31394705f, 0.10108589f, 
    0.19970226f, -0.08602728f, 0.57100642f, 0.35767975f, -0.06241314f, -0.29256663f, 0.08440138f, -0.14700481f, 
    0.01317965f, 0.10925142f, -0.10559724f, 0.24146338f, -0.05746764f, -0.01912826f, -0.02074826f, -0.02544987f, 
    0.13226642f, 0.13553731f, -0.11631564f, 0.12049543f, 0.20990433f, 0.17409463f, -0.19329213f, -0.11757747f, 
    0.32878947f, -0.15834764f, 0.38122523f, 0.29555473f, 0.52842969f, 0.01673063f, 0.27831435f, 0.17068484f, 
    0.12075106f, -0.14983852f, -0.35224575f, -0.19541821f, 0.16674212f, -0.29066756f, -0.10095220f, 0.26860404f, 
    0.05163133f, -0.21147074f, -0.02035102f, -0.27031714f, 0.31449288f, 0.80703801f, 0.09176371f, 0.41099721f, 
    -0.04465399f, 0.12064063f, 0.08510467f, 0.09373123f, -0.31886014f, 0.25898924f, 0.14219606f, 0.11298160f, 
    -0.43095389f, -0.05107160f, 0.00198111f, 0.05054436f, -0.12228052f, -0.06224944f, -0.04366799f, -0.07418278f, 
    0.10501177f, -0.03232818f, -0.30286470f, 0.13334909f, -0.05101420f, -0.15664987f, 0.15356471f, 0.34944481f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.11254442f, 0.13241640f, 0.11402906f, 0.10938060f, 0.21453010f, 0.09235381f, 0.27483574f, 0.09278341f, 
    0.00236304f, 0.18402755f, 0.25954291f, -0.19890505f, 0.12417382f, 0.28539318f, 0.29782212f, 0.07254743f, 
    0.33236682f, -0.17696153f, -0.11072489f, -0.15428448f, -0.12568618f, 0.09040297f, 0.05943964f, -0.08378163f, 
    0.07370421f, 0.16981235f, -0.06832749f, -0.12906943f, 0.09665143f, 0.07098114f, 0.31989461f, 0.13471310f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.41051805f, 0.28062335f, 0.05063336f, 0.53255135f, -0.64599365f, -0.70475137f, -0.32484031f, 0.08787932f, 
    0.07584606f, 0.32141459f, -0.15722181f, 0.30092934f, -0.05717577f, 0.00790258f, -0.61126369f, 0.08692382f, 
    0.11191451f, -0.05924438f, -0.38133785f, 0.07489827f, -0.28002223f, -0.10033917f, -0.07549410f, 0.06414031f, 
    0.37026143f, -0.36679131f, 0.22896764f, 0.14746521f, -0.70239013f, -0.09745301f, -0.32077029f, 0.27857548f, 
    -0.08942328f, 0.17472072f, 0.24582940f, -0.16657035f, 0.15342072f, 0.40839720f, -0.07828091f, -0.15242968f, 
    -0.30646530f, 0.29897934f, -0.20583425f, -0.12025867f, -0.41073096f, 0.23059444f, -0.37455034f, 0.14684348f, 
    0.10788696f, 0.13110757f, 0.24750432f, 0.10512437f, 0.04632320f, -0.59049159f, 0.26289159f, 0.11062162f, 
    -0.42394596f, -0.47162390f, 0.03540033f, 0.06039144f, 0.21882746f, -0.26625121f, 0.13111129f, 0.06539842f, 
    0.22370245f, 0.03933164f, -0.02373667f, 0.15320668f, -0.44826868f, -0.08732573f, -0.34317192f, 0.01569094f, 
    0.39210317f, 0.30959210f, 0.32226288f, 0.21685749f, 0.03520903f, -0.17082058f, -0.22194342f, -0.35007143f, 
    -0.56271350f, -0.06408069f, 0.17068335f, 0.09485788f, -0.54146677f, -0.34670031f, -0.37043869f, -0.29376039f, 
    -0.13936543f, -0.18768534f, 0.03988135f, 0.21898702f, -0.67805666f, 0.23528899f, 0.24280448f, -0.50955671f, 
    -0.14893320f, 0.11803100f, -0.10901478f, -0.23368244f, 0.21173161f, 0.08846377f, -0.75493753f, 0.03795195f, 
    0.17927504f, 0.03085802f, -0.42360938f, -0.31643745f, -0.02487858f, 0.01438845f, -0.00315620f, 0.23738556f, 
    0.26303777f, -0.01821896f, -0.56117839f, -0.13661292f, 0.15577565f, 0.02520558f, 0.07548796f, -0.34756395f, 
    0.17498539f, -0.03936096f, -0.15914074f, -0.72800845f, -0.62518972f, -0.15204772f, -0.02888137f, 0.34986368f, 
    -0.19976147f, -0.26930520f, -0.29519391f, 0.26366875f, -0.24201971f, -0.42134333f, 0.08016088f, -0.12575719f, 
    -0.05381919f, -0.09568625f, -0.11293047f, -0.03015146f, 0.08688685f, -0.16477215f, 0.33109894f, -0.06681949f, 
    -0.01122713f, -0.00169102f, -0.00823687f, 0.08522983f, 0.43251047f, 0.21101153f, 0.32146031f, 0.09646267f, 
    -0.30846795f, -0.14780530f, 0.35887346f, 0.15338419f, -0.78593969f, -0.39424974f, -0.01340765f, 0.26107135f, 
    -0.14842638f, -0.10123931f, 0.04084712f, -0.06875948f, -0.30728602f, 0.22581065f, 0.30083677f, -0.02892338f, 
    0.05507795f, -0.08642557f, -0.09263422f, -0.31167620f, -0.30812493f, -0.10603748f, 0.10878558f, -0.28630391f, 
    0.11959632f, 0.09569417f, -0.15254115f, 0.10566303f, -0.48948887f, 0.11081663f, 0.24350393f, -0.05458995f, 
    0.12013483f, -0.11153720f, 0.01737886f, -0.46450716f, 0.46145976f, 0.34832779f, 0.06187341f, 0.12575608f, 
    0.02515944f, 0.20304382f, 0.04124387f, -0.93503118f, 0.04445152f, 0.18592724f, 0.32314116f, -0.06390437f, 
    -0.21448182f, -0.65008390f, 0.02484249f, -0.12448382f, 0.31309798f, 0.05840753f, -0.07362031f, -0.54461694f, 
    -0.23144014f, 0.11010960f, 0.03406102f, -0.16199449f, -0.22947930f, 0.10834237f, 0.04782991f, 0.37319973f, 
    0.24163446f, 0.06525145f, -0.72393125f, 0.27565974f, -0.07938948f, -0.26327950f, -0.03358687f, -0.53756630f, 
    0.13486259f, -0.52787316f, -0.24909528f, -0.07863870f, 0.06695411f, 0.14238839f, -0.40295303f, 0.10785937f, 
    -0.11950696f, -0.23799117f, 0.08514902f, 0.09555391f, -0.24001227f, -0.57080513f, 0.02755264f, 0.31799820f, 
    -0.64683890f, 0.04628618f, -0.14428800f, 0.08788115f, 0.21388264f, 0.28354931f, -0.01240859f, -0.20914879f, 
    0.08649212f, -0.12922740f, 0.02486292f, 0.02641607f, -0.31723279f, 0.37416577f, -0.63715523f, -0.06500071f, 
    0.49648619f, -0.16333768f, 0.00370255f, -0.39028594f, 0.36084175f, -0.39079508f, 0.35599869f, -0.17148279f, 
    0.25773823f, -0.00331507f, -0.59626472f, 0.18943228f, -0.74547994f, 0.04688913f, 0.00488941f, -0.07438069f, 
    0.02679415f, -0.02662591f, 0.11597041f, 0.03786376f, -0.12394843f, -0.37183684f, -0.23162140f, -0.48990858f, 
    -0.37136987f, -0.00065868f, -0.13337685f, -0.15485246f, -0.10390081f, 0.46633708f, -0.24940658f, -0.06622274f, 
    0.24282295f, -0.13665599f, -0.52061725f, 0.37315741f, -0.26992607f, -0.02515784f, 0.20055783f, -0.10854414f, 
    -0.15818217f, -0.18403392f, 0.35912248f, -0.14367256f, 0.38728738f, -0.22774474f, 0.00795691f, -0.13040902f, 
    -0.40563649f, 0.01738475f, 0.12900120f, 0.14507750f, 0.21128388f, 0.21359448f, -0.44077915f, 0.31902722f, 
    -0.26835465f, -0.27972692f, -0.37721097f, -0.77601820f, -0.00705489f, -0.21757467f, 0.05561730f, -0.73423105f, 
    0.22907105f, -0.32369158f, 0.00312358f, -0.21705614f, -0.23992160f, 0.08332208f, -0.69073623f, -0.09682178f, 
    -0.10499319f, 0.38956937f, 0.26761240f, -0.08428863f, -0.00774682f, 0.02734856f, -0.04875764f, 0.20281902f, 
    0.38438866f, 0.07879353f, -0.13486578f, -0.10995593f, -0.51293468f, -0.01047606f, -0.51623434f, -0.90478504f, 
    -0.06230375f, 0.25703019f, -0.80480337f, -0.62176794f, -1.21946394f, -0.11663914f, 0.44166845f, -0.07992919f, 
    -0.39461002f, -0.21729997f, 0.18353152f, -0.12395199f, 0.50326598f, -0.58929640f, 0.15310140f, 0.01302362f, 
    -0.03134508f, -0.23461822f, 0.39418170f, -0.08682391f, -0.23528951f, 0.18877642f, 0.09777995f, 0.00017494f, 
    -0.28146222f, -0.19318941f, -0.10997924f, -0.12766159f, -0.45956096f, 0.17992042f, -0.53358257f, -0.20328236f, 
    0.31061688f, 0.46960199f, 0.11525004f, -0.06565146f, -1.12386382f, -0.44781032f, -0.11160453f, 0.28609160f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.14186704f, 0.07625389f, -0.11736000f, -0.01082052f, 0.11671557f, 0.15712355f, -0.02964892f, 0.03207128f, 
    0.08817366f, -0.02932674f, -0.05759110f, -0.03729114f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
