#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.51673573f, 0.23097683f, 0.97960335f, 1.06474638f, 0.49218678f, -0.19900672f, -0.27436879f, -0.36643463f, 
    -0.17338879f, -0.74826181f, 0.13740999f, 0.31670648f, -0.72066790f, -0.10767764f, -0.01985903f, 0.18896748f, 
    -0.37005523f, 0.30500451f, 0.17802945f, 0.16919282f, -0.14639677f, -0.20584355f, 0.17541617f, -0.26014543f, 
    -0.45255756f, -0.39295399f, -1.36376119f, -0.80302149f, -0.18321487f, -0.20933926f, 0.20975998f, 1.08683026f, 
    0.12774661f, -0.37269759f, 0.46866915f, -0.14698558f, -0.27332205f, -0.61632073f, -0.08067897f, 0.06982423f, 
    -0.16094394f, 0.19107713f, 0.00373946f, 0.03892775f, -0.13428806f, -0.21727405f, 0.03523181f, -0.16576926f, 
    -0.08100343f, -0.19361198f, 0.54896057f, -0.28948572f, -0.64169347f, -1.12923765f, -0.43074742f, -0.05675500f, 
    -0.27063596f, 0.57985741f, 0.12100557f, -0.43302312f, 0.30019403f, -0.30342287f, -0.09943677f, 0.27960876f, 
    0.19842309f, -0.01145818f, 0.31570557f, -0.48955584f, 0.39359447f, 0.66800094f, 0.22147350f, -0.30374277f, 
    0.37125224f, -0.21336804f, 0.00145891f, -0.00174114f, -0.40456399f, -0.64695477f, -0.49482435f, 0.06958975f, 
    -0.03890267f, -0.66901517f, -1.13823903f, -0.38285536f, 0.49529585f, 0.00836153f, 0.58906281f, -0.14168262f, 
    -0.02057512f, 0.35562462f, 0.03678281f, -0.00771309f, 0.41853169f, 0.01438885f, 0.24089518f, 0.02290410f, 
    0.29825148f, -0.08050232f, -0.36894584f, 0.45340383f, -1.05388308f, -0.94352585f, -0.79164517f, -0.08301412f, 
    0.73664874f, -0.32200781f, 1.20859683f, 0.42495957f, -0.00626683f, 0.30598202f, 0.00481399f, 0.07480741f, 
    0.18292692f, -0.03178031f, 0.17989857f, -0.02423626f, -0.43427250f, -0.47459242f, -0.12203256f, -0.14277278f, 
    0.30111346f, 0.11582306f, 0.02010002f, 0.29794094f, -0.02858195f, -0.92974991f, -0.17625105f, -0.08167783f, 
    -0.38164678f, -0.36627093f, -0.51570934f, 0.32730484f, -0.06046442f, -0.01874833f, -0.95358545f, -0.31800538f, 
    0.72900450f, -0.48089147f, 0.37369004f, -0.02970587f, -0.48927897f, 0.14780249f, -0.17782207f, -0.48512727f, 
    -0.01909974f, 0.04883936f, -0.09737111f, 0.39826635f, 0.26222751f, 0.10788140f, 1.25563562f, -1.37470186f, 
    0.47670555f, 0.77246398f, -0.10708860f, 0.25860751f, -0.19442302f, -0.14340617f, 0.45762566f, 0.18687823f, 
    -0.18326278f, -0.21312445f, -0.40962797f, 0.06937227f, -0.05590279f, 0.33523411f, -0.15345891f, -0.47137892f, 
    0.32801038f, 0.14909516f, 0.00931444f, -0.00798726f, 0.29526427f, 0.32575819f, 0.43940461f, -0.61286479f, 
    -0.19660762f, -0.14627372f, 0.80879110f, -0.47187829f, 1.06124508f, 0.86968970f, 0.50098139f, 0.50380975f, 
    0.28201020f, -0.41915891f, 0.06889080f, 0.24679716f, -0.43547907f, -0.47272223f, -0.14145733f, -0.09723303f, 
    -0.04079141f, -0.54269958f, 0.20274176f, -0.08246840f, 0.08607529f, 0.10719398f, 0.12691773f, -0.05655500f, 
    -0.36029503f, -0.21343306f, -1.31031799f, -0.86332923f, -0.07066102f, -0.80959094f, 0.53794074f, 0.95166683f, 
    -0.59515035f, 0.40178025f, 0.56994128f, 0.25091323f, 0.51988089f, -0.20928530f, 0.35691288f, 0.00808308f, 
    0.06834597f, -0.01715186f, 0.07643977f, -0.24886647f, -0.05623044f, -0.03981324f, -0.16283262f, -0.26645046f, 
    -0.02010734f, 0.56457555f, -0.79253590f, -0.73866779f, -0.35248175f, 0.37998417f, -0.75023365f, 0.13669837f, 
    -0.15841986f, -0.24909176f, 0.40687019f, -0.26981348f, -0.17533256f, -0.06494623f, 0.24246688f, 0.01182306f, 
    -0.88981664f, -0.11129214f, -0.60450840f, -0.24724300f, -0.39430434f, -0.26106951f, -0.40391442f, 0.14156990f, 
    -0.18093190f, -0.41657373f, 1.12618899f, 0.76069492f, -0.23411094f, -0.63092035f, -0.65725416f, 0.46929911f, 
    0.31097451f, -0.42162725f, 0.55593789f, 0.50937730f, 0.23021668f, -0.07657997f, -0.29954302f, 0.06727917f, 
    0.51662755f, 0.04297267f, -0.12662274f, -0.34999824f, -0.06687596f, 0.50024056f, -0.62184125f, 0.25785023f, 
    -0.43413830f, 0.12293016f, 0.04739177f, 0.95406973f, 0.83065933f, -0.14651321f, 0.68600410f, 1.19530666f, 
    0.56178743f, 0.44022408f, 0.32145724f, 0.14495540f, 0.44776475f, 0.15514483f, -0.35727617f, 0.41993511f, 
    -0.27897432f, -0.37920579f, 0.19664647f, -0.20954773f, 0.13101201f, 0.02980966f, -0.26230797f, 0.29581472f, 
    -0.30070511f, 0.28390792f, 0.30574003f, 0.22767760f, 0.92220461f, 0.88078129f, 0.67843133f, 0.10068457f, 
    0.57266641f, -0.87280989f, -0.42072794f, -0.51888847f, -0.37137073f, -0.45334622f, 0.52930868f, 0.18321401f, 
    0.14672996f, 0.51929390f, -0.44373626f, -0.11966926f, 0.18337934f, 0.08959927f, 0.11041228f, -0.17533042f, 
    -0.26552045f, 0.06799058f, 0.49201569f, 0.30761862f, -0.14059605f, 0.93471038f, 0.65129125f, 0.78233778f, 
    1.16364610f, 0.64528912f, 0.55174613f, 0.11410139f, 0.06993155f, -0.43153629f, 0.30033195f, -0.34566137f, 
    -0.52057892f, -0.23391950f, -0.13376512f, -0.02612733f, -0.40988401f, -0.13179666f, 0.46201447f, -0.04059119f, 
    -0.06097298f, 0.16788842f, 0.22970879f, -0.47016078f, -0.00547306f, 0.26191571f, 0.03894500f, 0.35883033f, 
    -0.15604414f, 0.38134769f, 1.13102400f, 0.35941347f, 0.32942861f, 0.70722103f, 0.03727827f, -0.22656907f, 
    -0.23249641f, -0.19992231f, -0.26944798f, 0.01038631f, 0.27307993f, 0.26162207f, 0.37313727f, 0.25979799f, 
    -0.21704352f, 0.39993638f, -0.34345394f, 0.27910650f, -0.15832397f, 0.76574326f, -0.19724993f, -0.84599423f, 
    1.28653443f, 0.73406184f, -0.71434033f, -0.29197311f, -0.98127002f, 0.92919374f, -0.13915588f, -0.17041673f, 
    -0.30237573f, -0.03572438f, 0.33209234f, -0.33454332f, -0.07498856f, 0.43257061f, 0.13763390f, -0.06692629f, 
    0.25603393f, -0.11907943f, -0.24281441f, 0.13470733f, 0.08850404f, 0.03405757f, 0.20913056f, 0.22571893f, 
    -1.02686322f, -0.27848542f, 0.39039224f, -0.13282947f, 0.18254966f, -0.90973485f, -0.30983734f, -0.42507768f, 
    -0.96687877f, 0.21622545f, -0.42585310f, 0.30406487f, -0.32062697f, -0.50869370f, 0.03906047f, 0.08256982f, 
    -0.08251828f, -0.01065706f, -0.40487593f, -0.47288725f, -0.18819775f, -0.01722046f, -0.03292104f, 0.28744420f, 
    0.05049741f, -0.16130425f, -0.91834211f, -0.19296648f, 0.66046524f, -0.53472257f, 0.21768294f, -0.95643353f, 
    0.26089182f, 0.17469393f, -0.89728802f, -0.55133432f, -0.60454601f, -0.13029246f, -0.33507779f, 0.04211403f, 
    -0.12680028f, 0.21936916f, -0.17334378f, 0.13087060f, 0.48924837f, 0.34060547f, 0.38279659f, 0.44159403f, 
    -0.25157151f, -0.12437162f, -0.44467536f, 0.74393398f, -0.91375899f, -0.91118991f, -0.26245320f, 0.49863625f, 
    -0.94358027f, -0.44786012f, -0.37728080f, -0.78007162f, 0.02114779f, 0.33525547f, 0.42623770f, 0.13862425f, 
    -0.24906558f, -0.26927665f, 0.23018298f, -0.14265022f, 0.05585634f, 0.01278439f, -0.01979233f, 0.23792760f, 
    0.43901166f, 0.13954955f, 0.28951690f, 0.97940195f, 1.03947341f, 0.96241355f, 0.31895319f, 0.39197347f, 
    -0.28416961f, 0.21915205f, -0.11036509f, 0.04377517f, -0.05910439f, 0.08472401f, 0.19770713f, 0.02564282f, 
    0.23729314f, 0.41509914f, 0.41243127f, 0.29322165f, 0.08603116f, 0.24137510f, 0.47013623f, 0.15036681f, 
    0.12161832f, -0.09856947f, -0.03125665f, 0.55480951f, 0.43998966f, -1.17615032f, 0.19834431f, 0.86769760f, 
    -0.80713713f, 0.42825690f, 0.31132090f, 0.18646874f, -0.67591006f, 0.10675731f, 0.40395355f, 0.22149931f, 
    -0.10402209f, 0.07490897f, 0.23380783f, -0.26878166f, -0.38833645f, 0.04430880f, -0.19830428f, -0.27849892f, 
    -0.01959678f, 0.37052172f, 0.28024054f, 0.32596922f, 0.03375385f, -0.11793745f, 1.07229114f, -0.67320687f, 
    -0.13447073f, -0.89136827f, 1.11462033f, 0.20401491f, -0.60311705f, 0.57800078f, 0.39145675f, -0.00167371f, 
    -0.14461936f, -0.23591438f, -0.08503085f, -0.28224072f, 0.14758533f, 0.00272461f, -0.23100784f, 0.03961190f, 
    0.13443291f, 0.20488355f, -0.34066865f, -0.17841101f, -0.36393401f, 0.19061019f, 0.56192654f, 0.63115752f, 
    1.03204620f, 0.25228903f, 0.15568884f, 0.72185481f, 0.41699135f, -0.18305415f, -0.32585698f, 0.58275640f, 
    0.07982109f, 0.16258228f, -0.39566457f, -0.00619226f, 0.04970798f, 0.28203061f, -0.45079154f, -0.47109258f, 
    -0.21419214f, -0.02980417f, -0.32233140f, 0.22820261f, -0.12855287f, -0.15998717f, 0.29148874f, 1.33428788f, 
    0.87393719f, -0.90968049f, 0.29210156f, -0.65750843f, -0.59109390f, 0.14121553f, 0.38720223f, 0.13981421f, 
    0.10158577f, -0.12091240f, 0.17684335f, 0.14278710f, 0.03651092f, 0.19115835f, -0.14570235f, -0.32759508f, 
    0.08722188f, 0.00305360f, 0.08102225f, 0.39983231f, 0.02301398f, -0.08205774f, 0.00015534f, -0.05931969f, 
    0.01825360f, 0.21571249f, 0.65641141f, 0.28648967f, 0.82184726f, 0.63540953f, -0.88062769f, -0.94925761f, 
    -1.08346069f, 0.22346474f, 0.27486774f, 0.62123257f, 0.38764256f, 0.24042550f, -0.05538621f, 0.07304987f, 
    -0.28627142f, 0.17303288f, 0.21174906f, 0.32863325f, 0.67506838f, -0.11366444f, -0.16165051f, -0.11309645f, 
    0.01295385f, 0.91201925f, -0.71001232f, -0.87808871f, -0.74070805f, -0.27804834f, 0.48742819f, 0.23695923f, 
    0.21081893f, 0.26277629f, 0.34781516f, 0.18944687f, 0.28053102f, -0.37164772f, 0.26928797f, -0.04703638f, 
    0.28540924f, 0.23283131f, 0.24963725f, 0.24889000f, 0.51150674f, 0.29195139f, 0.02219219f, 0.21132307f, 
    0.08654127f, -0.51129031f, 1.00641859f, 0.83469886f, 0.09949990f, -0.52593273f, -0.78856301f, 0.30266756f, 
    -0.30271766f, -0.03082655f, -0.39744547f, 0.23469353f, 0.52039772f, 0.02174473f, 0.30181739f, 0.37258559f, 
    -0.52835464f, -0.20709431f, -0.19601750f, 0.04932770f, 0.24760234f, 0.04229517f, 0.22722071f, 0.36356843f, 
    0.07318781f, -0.29855758f, -0.11675739f, 1.11295962f, 0.45350748f, -0.25372538f, 0.64465517f, 0.53079236f, 
    -0.08841822f, -1.01334059f, 0.33826277f, 0.67856389f, 0.69898117f, -0.38357854f, -0.42026728f, -0.10685579f, 
    -0.50754005f, 0.01879151f, 0.21115880f, -0.10446924f, -0.05926489f, -0.22963217f, 0.16105485f, 0.55436689f, 
    -0.09586348f, 0.35644349f, -0.01907022f, 0.13917781f, -0.43681210f, -0.63041157f, -0.52393931f, -0.27171475f, 
    -0.55497938f, 0.70739406f, 1.14856911f, 0.29360557f, 0.50524551f, 0.61036193f, -0.37692466f, -0.31362349f, 
    -0.26400393f, -0.71273082f, -0.02441218f, -0.27778658f, 0.09368457f, 0.20838375f, 0.14105135f, -0.23326489f, 
    -0.06519815f, -0.27636650f, 0.11006325f, -0.17638351f, 0.27166736f, 1.10904670f, -0.25997317f, 0.51606733f, 
    -0.63455212f, 0.15286765f, 0.13686840f, 0.11982160f, 0.34869847f, 0.52305645f, 0.51425612f, -0.05044712f, 
    0.48599425f, -0.31850940f, -0.01198425f, -0.10996292f, 0.05429995f, -0.24701928f, -0.47764045f, -0.46924421f, 
    -0.18629555f, -0.14083156f, -0.06218685f, -0.13606144f, -0.11707246f, -0.45776558f, 0.96755195f, -1.42931342f, 
    0.06935533f, 1.08910096f, 0.63400078f, -1.19756722f, 0.82898581f, 0.50385487f, -0.31919375f, 0.14724252f, 
    0.14259981f, 0.17725070f, -0.20280226f, 0.05629842f, 0.17031974f, -0.23712227f, 0.30414546f, 0.04394419f, 
    0.09987506f, -0.23810150f, -0.01030784f, 0.03841964f, -0.17682610f, -0.06261116f, 0.06789576f, -1.54270053f, 
    1.36921442f, -0.03862021f, -0.30857745f, 0.35183039f, 0.25505608f, 1.13239479f, -0.46411884f, -0.03629498f, 
    0.43662727f, -0.43054405f, 0.06429738f, 0.51990962f, -0.52543408f, 0.05409905f, 0.05711832f, -0.22667018f, 
    0.00058893f, -0.11082099f, -0.34859768f, -0.07289511f, 0.05622369f, 0.08471493f, 0.16256182f, 0.13620032f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.24066952f, 0.39996508f, 0.31553614f, 0.37515229f, 0.02178301f, 0.34837806f, -0.00948091f, 0.07843566f, 
    0.48420417f, 0.14491338f, 0.31501815f, 0.03545907f, 0.12136914f, 0.24075155f, 0.16114673f, 0.01978664f, 
    0.16830376f, 0.15862480f, 0.36596996f, 0.08803974f, 0.25884247f, -0.05735241f, 0.29006234f, 0.20369308f, 
    0.20891917f, 0.34715366f, 0.07809822f, 0.20960924f, 0.01906952f, 0.29318005f, 0.01589622f, -0.21371122f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.07047170f, 0.09101159f, -0.17727156f, 0.10806181f, -0.20640336f, 0.06815909f, -0.05120902f, 0.05449740f, 
    0.06251434f, -0.11693028f, -0.13204454f, -0.17765105f, -0.11637076f, 0.03137231f, 0.21797498f, -0.28629670f, 
    0.06059587f, 0.04105480f, -0.10393752f, 0.00454755f, 0.03299834f, 0.00390662f, 0.10119104f, 0.06106691f, 
    -0.21693188f, -0.03735927f, -0.13602854f, -0.42402399f, -0.00635424f, 0.05353739f, 0.16925207f, -0.04957229f, 
    -0.04950983f, -0.11365438f, 0.07925268f, -0.00123092f, -0.11507238f, -0.36327076f, 0.23109102f, 0.02437451f, 
    -0.05837707f, 0.05400179f, 0.18672328f, -0.02525075f, -0.09984872f, -0.02301017f, -0.03909410f, -0.02740712f, 
    -0.21137799f, 0.46830553f, 0.03146800f, -0.25038198f, 0.03852440f, 0.01009605f, -0.11152171f, 0.02152260f, 
    0.04034680f, 0.11742827f, -0.02937191f, -0.02783053f, -0.48768458f, 0.07792466f, 0.02488123f, -0.11410594f, 
    0.19014564f, 0.16359867f, -0.01527316f, -0.09856375f, 0.03173646f, -0.01089090f, 0.05799233f, -0.28336266f, 
    0.31283835f, -0.39239112f, -0.02455015f, 0.47687382f, 0.30444053f, -0.15641634f, 0.04672540f, 0.03349779f, 
    -0.08802040f, 0.12211619f, 0.06868986f, -0.11759030f, 0.21492465f, 0.31708816f, -0.08176614f, 0.06354987f, 
    0.12365733f, 0.08871467f, -0.14050958f, -0.05448048f, -0.04601221f, 0.05561370f, -0.03592969f, 0.02280994f, 
    -0.59510082f, 0.09204590f, -0.11873420f, -0.15407592f, 0.00967623f, -0.17781585f, -0.03732663f, -0.07128002f, 
    -0.03323467f, -0.06753089f, -0.12932801f, 0.11042322f, -0.03894123f, -0.15839960f, 0.13836111f, -0.10354174f, 
    0.03524832f, 0.00866322f, 0.05233837f, -0.12930985f, -0.20389295f, 0.01496513f, -0.05380559f, -0.07865199f, 
    0.04222625f, -0.27086323f, 0.00882867f, -0.30809036f, -0.19094379f, 0.00482243f, 0.02995257f, 0.17267586f, 
    -0.04023086f, -0.03975996f, -0.03360662f, 0.13614507f, 0.02424424f, -0.07884873f, 0.19470759f, 0.12038204f, 
    -0.17049137f, -0.00476434f, -0.04179569f, 0.15576231f, -0.17975077f, 0.13955155f, 0.19990538f, -0.14292622f, 
    0.31634516f, 0.11563027f, 0.05133243f, -0.18266110f, -0.17074041f, -0.09253053f, -0.10033042f, 0.05927820f, 
    0.14291573f, -0.05883668f, 0.05980762f, -0.13126726f, 0.23628935f, 0.08170410f, -0.09950396f, 0.25265673f, 
    -0.30910957f, -0.06125585f, 0.03217475f, 0.09410171f, -0.10168997f, 0.08712910f, -0.12131442f, -0.12187767f, 
    0.00841257f, 0.12379500f, 0.11532160f, 0.01431197f, -0.05273577f, 0.12416568f, -0.06471572f, -0.02336898f, 
    -0.01046411f, -0.11556735f, -0.10018951f, -0.07985575f, -0.27192503f, 0.19685179f, 0.13690881f, -0.22721225f, 
    0.14760447f, 0.01241176f, 0.00254261f, -0.07271830f, -0.07304627f, -0.00355607f, -0.00147610f, -0.05196415f, 
    -0.74596363f, -0.16175352f, -0.13421124f, 0.36524510f, -0.02615165f, -0.03748038f, -0.21874893f, 0.00569236f, 
    -0.00480685f, 0.07811221f, 0.01359236f, 0.08077317f, 0.01766219f, -0.23370866f, -0.09754868f, 0.36011967f, 
    0.12620939f, 0.02043687f, 0.01908452f, -0.05196178f, -0.09046166f, -0.16394651f, 0.05143127f, 0.01632871f, 
    -0.24407427f, -0.15577774f, 0.04758874f, -0.00447256f, 0.00097222f, -0.03176477f, 0.01463419f, -0.04766564f, 
    0.10893817f, -0.12686309f, -0.08224058f, 0.02678676f, 0.00377987f, -0.01045905f, -0.03848339f, -0.22782937f, 
    -0.18419489f, -0.05692700f, 0.04560116f, 0.09661223f, 0.04600138f, 0.03007622f, -0.08114589f, 0.02482207f, 
    -0.06752023f, 0.07058226f, -0.20708059f, 0.12120298f, -0.11964604f, -0.00218149f, -0.00047729f, -0.05617184f, 
    0.03441744f, 0.13474599f, 0.00714590f, 0.02566934f, 0.68290681f, 0.06976674f, -0.08108246f, 0.00635481f, 
    -0.14956816f, -0.07533275f, 0.12073299f, -0.13700785f, 0.03392314f, 0.01268009f, -0.07009014f, 0.10657340f, 
    0.00330557f, 0.02049087f, 0.16444317f, 0.02579868f, -0.18176907f, -0.12073746f, 0.08404422f, 0.13051260f, 
    0.03220009f, -0.03493650f, 0.05803453f, -0.06426844f, -0.18469051f, 0.03716478f, 0.05098632f, -0.18921764f, 
    -0.24072029f, -0.06689548f, -0.18821228f, -0.01449022f, -0.12934411f, 0.04024635f, 0.09461808f, 0.13672911f, 
    -0.18784975f, -0.05019440f, 0.23708783f, -0.06993765f, -0.04819314f, -0.14117061f, -0.00812461f, -0.17929257f, 
    -0.03202376f, -0.07330977f, -0.09078168f, -0.11155863f, 0.15825821f, -0.03408272f, 0.02173807f, -0.47833523f, 
    -0.01934971f, 0.00591287f, 0.00902049f, -0.16931032f, -0.18471318f, -0.10755396f, 0.13154861f, -0.03559446f, 
    -0.22224039f, 0.17433819f, 0.06525369f, -0.43806872f, 0.03420042f, 0.07784589f, -0.00262704f, 0.01019934f, 
    -0.05770154f, 0.01907096f, -0.11577161f, 0.11614654f, 0.21406308f, -0.17162265f, 0.15829127f, 0.40500301f, 
    -0.09210407f, 0.08832433f, -0.05884092f, 0.06550928f, -0.03723013f, -0.00971975f, 0.06071406f, -0.11760750f, 
    0.30429280f, 0.31335089f, 0.11588836f, -0.24426305f, 0.12615322f, 0.14712109f, 0.14510924f, -0.02868994f, 
    -0.01152041f, 0.02193956f, 0.02582500f, 0.18507499f, 0.20002677f, -0.18306315f, -0.16556531f, -0.21927023f, 
    -0.08335149f, -0.11466706f, -0.03224736f, 0.15529114f, -0.17790890f, 0.07366364f, 0.08840110f, -0.01034765f, 
    0.24837187f, -0.01767953f, -0.07016563f, 0.44366395f, -0.23703793f, -0.09591760f, 0.13853899f, -0.10653488f, 
    0.05579578f, -0.01798078f, -0.09062120f, -0.04601450f, 0.68396050f, -0.04715148f, 0.33116728f, 0.02113023f, 
    -0.07764586f, -0.02886291f, 0.07938275f, -0.18807629f, 0.19223905f, -0.03544641f, -0.15273458f, -0.02517670f, 
    -0.06209707f, -0.06614443f, 0.07562605f, 0.20571369f, 0.10610235f, -0.07862161f, 0.00905211f, 0.04092970f, 
    -0.19976883f, -0.15453833f, -0.05026050f, 0.27799726f, 0.36718896f, -0.10998052f, -0.14148587f, -0.01981998f, 
    0.00971620f, 0.03232595f, 0.05807913f, -0.08877864f, 0.12944430f, 0.05788741f, -0.20961505f, -0.14063795f, 
    0.14708732f, -0.27810442f, 0.16229692f, -0.26922876f, -0.02164206f, 0.02442278f, -0.01869481f, 0.14339128f, 
    -0.27742612f, 0.15428747f, -0.04795083f, 0.02528584f, 0.01007058f, -0.02767490f, -0.08417229f, -0.10689537f, 
    0.03275549f, -0.07624643f, -0.10181249f, 0.28257656f, -0.00832462f, 0.08718619f, 0.13258511f, 0.06957702f, 
    0.29586509f, -0.06822614f, -0.10283812f, -0.19689059f, 0.00514433f, 0.13355511f, 0.02665815f, -0.05119401f, 
    0.05323125f, 0.05364708f, -0.09619803f, 0.01742307f, -0.29359141f, -0.12714648f, -0.21384215f, -0.00344183f, 
    -0.10523561f, -0.03840422f, 0.00842939f, 0.07567132f, -0.07390887f, -0.14220221f, -0.13133153f, 0.03030217f, 
    0.32857227f, -0.09564394f, 0.04316613f, -0.02995317f, -0.14910012f, 0.04443212f, 0.09748505f, -0.01631197f, 
    -0.00950650f, 0.05438693f, -0.02973631f, -0.06093500f, -0.32518631f, -0.04747843f, -0.05559798f, 0.18267068f, 
    0.00407531f, 0.11445502f, -0.08235609f, -0.06055731f, 0.11989295f, 0.01964392f, 0.11227866f, 0.06891799f, 
    0.49788043f, -0.02385000f, 0.07650518f, -0.13285598f, -0.03094518f, -0.05993703f, -0.08723716f, 0.06415633f, 
    -0.03273388f, -0.07963266f, 0.07407466f, -0.09176545f, 0.29392830f, -0.15827568f, 0.15706828f, -0.10148798f, 
    -0.11598887f, -0.17453361f, -0.13397917f, -0.01158424f, -0.09026375f, 0.00434472f, -0.15022485f, -0.27129349f, 
    0.24514922f, -0.09202417f, 0.04733725f, -0.14675656f, 0.06055187f, -0.16004920f, -0.15853889f, -0.17831214f, 
    -0.31963328f, 0.10958311f, 0.03603146f, 0.01817865f, 0.37244868f, 0.07033646f, 0.08508834f, 0.09813424f, 
    -0.21903218f, 0.04255626f, -0.15225619f, 0.08951955f, -0.05470932f, 0.09724992f, -0.15695803f, 0.01202959f, 
    0.03408267f, -0.02665231f, -0.02273655f, 0.09708030f, -0.02918034f, -0.12595426f, 0.17240180f, 0.00560811f, 
    -0.01526573f, -0.00526312f, 0.06407221f, 0.06132731f, 0.37053549f, -0.00158974f, 0.01366206f, 0.29748613f, 
    -0.21855257f, 0.02841681f, 0.13845544f, 0.03134553f, -0.00337709f, -0.05222054f, 0.12544601f, 0.05431589f, 
    0.11295194f, 0.05460764f, -0.06947042f, 0.21013384f, -0.03050422f, 0.13440213f, -0.13282636f, 0.15177074f, 
    0.10896874f, 0.24171884f, 0.01457083f, 0.12462409f, -0.74116433f, 0.14094259f, -0.52638900f, -0.41433787f, 
    -0.06223003f, 0.10490586f, 0.07208177f, -0.01793025f, 0.11925085f, -0.01639040f, -0.10000332f, 0.12401655f, 
    -0.00624259f, -0.08848873f, -0.05135644f, -0.24969341f, 0.06146182f, 0.03477248f, -0.11183459f, 0.02954667f, 
    -0.10950241f, -0.14536133f, -0.20147780f, -0.10701340f, -0.65173554f, 0.05560106f, 0.05455779f, 0.06917359f, 
    -0.15929492f, -0.16560924f, -0.06175149f, 0.00473618f, 0.17882213f, 0.14743972f, -0.07232889f, 0.02734657f, 
    -0.20409258f, -0.30356398f, -0.07400772f, -0.58553100f, 0.12838116f, -0.01829384f, 0.26440978f, -0.05074433f, 
    0.06974513f, 0.14153099f, 0.22372591f, -0.22634359f, 0.33879915f, 0.03242991f, 0.05482087f, 0.21095264f, 
    -0.07096458f, -0.12222074f, 0.05237931f, -0.01320665f, -0.02896658f, 0.06821252f, 0.01886223f, 0.07652232f, 
    -0.19953087f, -0.10602316f, -0.12892570f, 0.27397445f, 0.01332714f, 0.07344820f, 0.07427172f, -0.03247567f, 
    -0.00668920f, -0.20013551f, -0.15918678f, 0.14978507f, -0.51328242f, -0.26220709f, 0.03417666f, -0.14161417f, 
    0.05322598f, -0.07076405f, -0.13507967f, 0.02739652f, 0.03035031f, 0.08854607f, -0.00859805f, -0.08686806f, 
    0.23421486f, 0.02734357f, 0.10196493f, -0.02755215f, -0.11785962f, 0.02061782f, 0.07432538f, -0.10928447f, 
    -0.06342530f, -0.13631038f, -0.17699188f, -0.19397880f, 0.45941693f, -0.28368849f, 0.05316295f, -0.09268626f, 
    -0.01704833f, 0.00920523f, -0.01094099f, 0.20158567f, -0.09297438f, -0.01471077f, -0.16623197f, 0.23462488f, 
    0.04792882f, 0.00634837f, 0.01818460f, -0.10046113f, -0.21529022f, 0.16441528f, -0.13427511f, -0.04479086f, 
    0.13178991f, 0.13956808f, 0.04727236f, -0.01958780f, 0.31549713f, -0.56256735f, 0.17255543f, -0.32263368f, 
    -0.01898298f, 0.05861500f, 0.08179294f, 0.09146683f, 0.12241229f, 0.06681255f, -0.04135233f, 0.03630441f, 
    0.13210960f, 0.03615378f, 0.16037993f, -0.09131086f, -0.20180692f, -0.13631749f, 0.04980621f, -0.01062742f, 
    -0.02426752f, -0.01098514f, 0.14772801f, -0.12311755f, 0.29585114f, -0.03092608f, 0.23320860f, 0.18663050f, 
    -0.25312686f, -0.03335326f, -0.01255804f, 0.07989682f, 0.08824573f, -0.13256975f, -0.11837103f, 0.01944394f, 
    0.01897614f, -0.29266158f, -0.10465433f, -0.10271492f, 0.08642613f, -0.05884042f, -0.10885450f, 0.03543534f, 
    0.10635319f, 0.07149331f, -0.05774176f, -0.13454726f, 0.29558983f, 0.03029393f, 0.21384405f, -0.02274220f, 
    0.00080488f, 0.02638649f, 0.01547423f, -0.09546107f, 0.01710954f, -0.01793914f, -0.16151392f, -0.19646722f, 
    0.01514001f, -0.36996514f, 0.15189254f, 0.28386486f, -0.18505590f, 0.21200718f, -0.19405572f, 0.03944386f, 
    0.01979201f, 0.02493204f, 0.05245899f, 0.00611769f, -0.55334729f, 0.25744796f, -0.17977650f, -0.21250300f, 
    0.05600475f, 0.06971986f, -0.07608552f, -0.12425288f, 0.09680013f, -0.09159128f, 0.26315966f, -0.04434138f, 
    0.04400422f, 0.05445596f, -0.17706248f, 0.08986256f, 0.00543957f, 0.06254470f, -0.15222903f, -0.07026348f, 
    -0.11916859f, -0.06842079f, 0.00327540f, -0.14597180f, 0.15967216f, -0.22653989f, 0.24823852f, 0.16408756f, 
    -0.09820868f, -0.03468853f, -0.04826431f, 0.01619005f, 0.03934954f, -0.00670861f, 0.04905935f, -0.01739805f, 
    -0.32714337f, 0.00001508f, -0.05308203f, 0.19166470f, -0.08255418f, -0.07123180f, 0.07070678f, 0.03181046f, 
    -0.13555527f, -0.14569184f, -0.03100923f, -0.01278626f, -0.27512398f, -0.38309142f, 0.20728649f, -0.38364434f, 
    -0.08285332f, -0.01835030f, 0.12829280f, 0.09485440f, -0.06233339f, -0.01348803f, 0.05072671f, -0.01887046f, 
    0.43590930f, -0.12590247f, 0.11756669f, 0.11480646f, -0.09620159f, 0.03667730f, -0.10877431f, -0.18443216f, 
    0.12507513f, -0.12103008f, 0.07623733f, 0.09984126f, 0.29094401f, 0.21141693f, -0.43229532f, -0.40347663f, 
    -0.19118215f, 0.08881382f, -0.11870710f, -0.12127853f, 0.03548329f, -0.04484421f, 0.00926123f, -0.18543375f, 
    -0.60623324f, 0.00825139f, -0.26513410f, -0.09774432f, -0.08937155f, 0.00032160f, -0.06996504f, 0.08332103f, 
    -0.13174757f, 0.03063777f, 0.11702793f, -0.04563060f, 0.30953696f, 0.04674005f, 0.17577218f, 0.05596739f, 
    -0.04129070f, 0.02514685f, -0.16087276f, 0.02920640f, 0.00627663f, 0.07266934f, -0.10871293f, -0.06392179f, 
    0.30496079f, 0.18894163f, 0.03862279f, 0.28475982f, -0.09136465f, -0.13923891f, 0.01684756f, -0.03459939f, 
    -0.03477520f, 0.05913561f, -0.01534683f, -0.22227855f, 0.22283411f, -0.14303015f, -0.11150548f, -0.06567432f, 
    -0.01774933f, 0.01444407f, -0.01270673f, -0.06768790f, -0.05342146f, 0.02326488f, -0.20116402f, -0.06678464f, 
    0.06628931f, -0.10788240f, 0.19014777f, -0.11761387f, 0.08738407f, -0.01988000f, 0.07637054f, 0.09757444f, 
    -0.14800850f, -0.04422250f, 0.02182670f, -0.14376773f, 0.22163273f, -0.09372584f, 0.05720682f, -0.08606929f, 
    0.21753520f, -0.10069571f, 0.09619880f, -0.17863195f, 0.00083012f, 0.11066414f, -0.03805785f, 0.09918372f, 
    -0.07583656f, 0.31710771f, -0.05042735f, -0.08708913f, 0.08436333f, 0.09163433f, 0.07873576f, -0.18405946f, 
    -0.25187099f, 0.09198184f, 0.00268973f, -0.18353552f, -0.22645079f, 0.02073990f, 0.04097436f, -0.07307366f, 
    0.27749497f, -0.00081168f, 0.02119896f, 0.01374526f, 0.12631646f, -0.04915391f, -0.02512100f, 0.05324080f, 
    -0.27204582f, -0.13379468f, -0.24716558f, 0.02222572f, -0.07794767f, -0.02273818f, 0.04916589f, -0.15675287f, 
    0.11891528f, -0.24360448f, 0.09944423f, 0.01514253f, 0.36699289f, 0.08386397f, -0.56479508f, -0.37843338f, 
    -0.03730257f, 0.14442737f, 0.00201653f, 0.09447153f, 0.06086571f, -0.13604783f, 0.03135980f, -0.16920513f, 
    0.56640136f, -0.46896902f, -0.30653670f, -0.17727688f, -0.05326920f, -0.02545571f, -0.08212834f, 0.04857514f, 
    0.06893510f, 0.08517779f, 0.14118846f, -0.23663868f, -0.36612055f, -0.14532746f, -0.36904937f, -0.10997099f, 
    -0.14949983f, 0.03198983f, -0.02859478f, -0.12991472f, -0.01789015f, -0.14065565f, -0.00737133f, 0.00800113f, 
    -0.67740935f, -0.10214175f, -0.02716846f, -0.67755401f, 0.09985919f, -0.15263087f, -0.15339494f, -0.01343269f, 
    -0.14665022f, 0.06198809f, -0.08871230f, -0.12203024f, 0.09449968f, 0.02342575f, -0.11887566f, -0.12738208f, 
    0.10765411f, 0.09448037f, 0.07519050f, -0.01508565f, -0.02678830f, -0.03388657f, -0.01433602f, -0.02153951f, 
    -0.00234368f, -0.06108704f, 0.13955335f, -0.18988544f, -0.08021030f, -0.01314531f, -0.08360300f, 0.01243423f, 
    0.04001167f, -0.00094451f, 0.02876014f, -0.07916705f, 0.33572042f, -0.09019995f, 0.06812055f, -0.02343004f, 
    0.15334642f, 0.12952822f, 0.12626438f, -0.00462839f, 0.00337708f, 0.07120111f, 0.12490211f, 0.02349949f, 
    -0.02214818f, -0.10505274f, -0.02906093f, -0.06202652f, 0.06775813f, -0.00797602f, 0.03259090f, 0.03932225f, 
    0.02102458f, 0.04037480f, 0.08621729f, -0.04676187f, 0.16012393f, 0.05004998f, -0.03350938f, -0.20297107f, 
    0.02793661f, -0.07883566f, 0.15293589f, -0.14476663f, -0.06633950f, -0.02332612f, 0.16196056f, -0.18337661f, 
    0.05028157f, 0.01835226f, -0.00934477f, -0.04908479f, 0.04416296f, -0.04961391f, 0.04517199f, 0.08564543f, 
    0.07681852f, 0.02443323f, -0.12805317f, -0.17548995f, -0.05511154f, 0.00115282f, 0.15894999f, 0.09389388f, 
    -0.15179573f, -0.05355031f, 0.03833919f, 0.01887443f, -0.09296828f, -0.21151222f, -0.11415013f, -0.01577167f, 
    -0.26113319f, 0.11325677f, 0.05313599f, -0.09259992f, 0.08163207f, -0.01770135f, 0.12585992f, -0.00309173f, 
    -0.02114012f, -0.06381814f, -0.14686193f, -0.02810528f, -0.06283142f, 0.13365410f, -0.01309924f, -0.01500247f, 
    0.05354517f, 0.05701674f, 0.06061514f, 0.04745165f, -0.08833748f, -0.04143833f, 0.05576020f, -0.06363602f, 
    0.33474332f, 0.10596840f, 0.21553960f, 0.41229853f, -0.11581302f, -0.16361202f, 0.09997080f, 0.20149575f, 
    0.04688558f, 0.01627089f, -0.02173945f, -0.04640528f, -0.25081033f, 0.16722308f, -0.01201420f, -0.12844415f, 
    0.06179088f, -0.09414450f, 0.10342316f, 0.16519396f, -0.04629075f, -0.05984277f, 0.14592530f, -0.03509213f, 
    0.67801040f, -0.00411983f, -0.09612972f, -0.21442799f, 0.11500598f, -0.01484320f, 0.02074336f, 0.04753473f, 
    -0.09325720f, 0.00342780f, -0.06121146f, -0.03759428f, 0.47009343f, -0.10623510f, -0.11329967f, -0.19223963f, 
    -0.02198021f, 0.07827789f, -0.04584597f, 0.21466555f, 0.02586682f, 0.15997633f, 0.01674560f, 0.09486254f, 
    -0.24680291f, -0.19108561f, 0.00003286f, 0.26379114f, 0.01744370f, 0.01689625f, -0.02389116f, 0.00575174f, 
    0.09855933f, -0.06975244f, 0.12242942f, -0.07659961f, 0.09658188f, -0.20055905f, -0.02108998f, 0.03422219f, 
    -0.21090843f, -0.05314226f, 0.11108483f, 0.00752397f, -0.07185089f, -0.06594718f, 0.08484538f, 0.01712698f, 
    0.11904383f, -0.28499687f, -0.09249990f, -0.12662964f, -0.16842292f, 0.07096183f, -0.00322753f, 0.15303673f, 
    -0.02742954f, -0.01741850f, 0.12160245f, 0.02440703f, 0.04938886f, 0.31785923f, 0.09078287f, 0.17557411f, 
    -0.04554597f, 0.09984528f, -0.04068984f, -0.16213661f, -0.03686592f, -0.06226751f, 0.04296589f, -0.03924121f, 
    0.08349904f, 0.29624084f, -0.02475857f, 0.17495161f, 0.02468519f, -0.21305606f, -0.01164136f, -0.15076813f, 
    -0.11392339f, 0.05527892f, -0.19181877f, -0.02949966f, 0.12449755f, 0.33852538f, 0.21049151f, 0.06038909f, 
    -0.09818838f, -0.06046594f, -0.11421153f, 0.03491827f, -0.08728709f, 0.05142422f, -0.02824840f, 0.18351266f, 
    0.04766538f, -0.01568425f, -0.12326894f, -0.02480897f, -0.11725783f, 0.07506587f, -0.06160470f, 0.02090556f, 
    0.10094824f, -0.05882813f, 0.03558275f, -0.22978787f, -0.13384494f, -0.00614575f, -0.13851844f, -0.23418406f, 
    -0.01204974f, -0.25625542f, 0.00299262f, 0.16916274f, -0.14020105f, -0.01738549f, 0.06855644f, -0.24852130f, 
    0.00384736f, -0.29693812f, -0.02714643f, -0.14005059f, -0.02119936f, -0.12141171f, 0.00880614f, -0.06168505f, 
    0.00061919f, 0.09804247f, -0.04500243f, 0.12569731f, 0.03394918f, 0.22403754f, 0.09882901f, 0.20243104f, 
    0.04381296f, 0.11153024f, -0.08850847f, 0.11170042f, 0.02607009f, 0.03089697f, 0.15707724f, 0.00781632f, 
    -0.19236119f, 0.02987127f, -0.08815438f, -0.16182782f, -0.10757110f, -0.04805885f, 0.05208626f, 0.30607712f, 
    0.06957519f, 0.07811866f, 0.06071970f, 0.00716602f, -0.43208328f, -0.20871988f, -0.30493474f, -0.30725005f, 
    -0.07788821f, 0.06622412f, -0.17018026f, -0.01108899f, -0.05751072f, 0.02743407f, 0.00889696f, 0.03171783f, 
    -0.15975140f, -0.27739629f, 0.11271910f, 0.15933384f, -0.08245454f, 0.16577411f, 0.07554109f, 0.11748749f, 
    -0.02188425f, -0.07303703f, 0.04351858f, -0.21533340f, -0.33679092f, -0.78865319f, -0.27018657f, 0.14524992f, 
    -0.17806439f, -0.03170215f, 0.00013512f, -0.14847113f, 0.05104863f, -0.09725913f, 0.12359702f, 0.04443942f, 
    -0.48262250f, -0.18100709f, -0.03946849f, 0.10183184f, -0.12543267f, -0.08036542f, 0.07098649f, -0.15441477f, 
    -0.04527199f, -0.02268408f, -0.01761396f, 0.06754433f, -0.32482630f, 0.44869697f, 0.21584393f, -0.06197967f, 
    0.12259711f, 0.04154129f, 0.00084119f, 0.08798321f, -0.09809908f, -0.00036050f, 0.04272044f, -0.04033392f, 
    0.07822369f, 0.35208488f, 0.19744226f, 0.06885530f, 0.13856517f, -0.04129904f, -0.16156834f, -0.11410692f, 
    0.02085534f, 0.16249089f, 0.14665799f, 0.06757072f, 0.34974939f, -0.02763162f, 0.01212384f, 0.22593810f, 
    -0.14617296f, -0.01593093f, -0.08185441f, 0.05763699f, 0.01366363f, 0.04774214f, 0.08771186f, -0.01638471f, 
    0.42661506f, 0.20986629f, 0.08203755f, 0.07191621f, -0.00507701f, -0.00524237f, -0.14393808f, 0.08478650f, 
    0.02893170f, 0.06689367f, -0.17632601f, -0.17533873f, -0.34831062f, -0.34781519f, -0.23338579f, -0.00457746f, 
    -0.11817011f, -0.10479620f, 0.10451365f, 0.02270813f, -0.01267276f, -0.14266251f, -0.10252556f, -0.08048036f, 
    0.24569982f, -0.16554680f, -0.07273331f, -0.13682450f, 0.02348492f, 0.06412519f, 0.03876425f, 0.03950757f, 
    0.17717113f, 0.06565358f, -0.08015680f, -0.11753169f, 0.21316388f, 0.33445865f, -0.14419408f, -0.00995681f, 
    -0.03248345f, 0.21622907f, 0.10865485f, 0.08939152f, -0.07717194f, -0.12570946f, -0.03157455f, -0.11839129f, 
    -0.60884166f, -0.39008263f, -0.26216969f, 0.11933284f, -0.05568357f, -0.08150366f, -0.02496205f, -0.05466598f, 
    -0.01225197f, -0.07817344f, 0.10734702f, -0.03632110f, 0.45160535f, -0.94164157f, -0.09141313f, -0.11775861f, 
    -0.08421993f, 0.01102971f, -0.02950179f, 0.03046583f, 0.07629037f, 0.07215957f, 0.07372438f, 0.04574816f, 
    0.22775866f, -0.11439962f, 0.12405639f, 0.51265204f, 0.13449946f, 0.28636137f, 0.12058900f, -0.07968106f, 
    -0.03855063f, -0.04050100f, -0.22588095f, -0.02514308f, -0.02775548f, -0.10309672f, -0.15099470f, -0.01471958f, 
    -0.12857723f, -0.05405468f, 0.03428223f, -0.01680503f, -0.03170580f, -0.13822353f, 0.01794325f, 0.11440443f, 
    -0.06898435f, -0.10853516f, -0.19168255f, 0.11209758f, -0.11719407f, -0.03368137f, -0.14529112f, 0.02468459f, 
    -0.00114291f, 0.04755352f, -0.11278782f, 0.08063573f, 0.10393027f, -0.03636096f, -0.41344786f, 0.12398041f, 
    0.02278659f, 0.08529914f, 0.07094078f, -0.19447985f, -0.03351093f, 0.01811594f, -0.04923612f, 0.02361307f, 
    -0.21488959f, -0.09800357f, -0.07007118f, -0.22996411f, -0.18540338f, -0.10467269f, 0.04926082f, -0.01969350f, 
    -0.07355488f, -0.04285592f, 0.13455839f, -0.04882080f, -0.02898068f, -0.10421091f, -0.21321267f, 0.00561222f, 
    0.00755123f, -0.00297709f, 0.13404401f, 0.08926617f, -0.04214343f, 0.17395397f, 0.09149019f, 0.05642111f, 
    -0.75054282f, 0.16351454f, 0.35769317f, 0.08350724f, 0.08326127f, 0.23246883f, 0.12928820f, -0.00545820f, 
    -0.01347179f, -0.02332676f, -0.04787811f, 0.09389734f, 0.13076106f, 0.41627529f, 0.09971416f, -0.07882286f, 
    -0.09613515f, -0.09652491f, -0.10977277f, 0.18481082f, -0.00712504f, 0.00001550f, -0.19683427f, 0.06470886f, 
    -0.07961508f, 0.01088991f, 0.20977207f, -0.07147878f, 0.09335833f, -0.01551424f, 0.08197135f, 0.10369601f, 
    0.19217165f, -0.12957799f, -0.09056541f, -0.04336894f, -0.89411139f, 0.24311908f, 0.01126970f, 0.18660982f, 
    0.02621706f, 0.06405030f, 0.14162365f, 0.10336414f, -0.01494820f, 0.09978074f, 0.01501394f, 0.12945592f, 
    0.15424897f, 0.16396020f, -0.04619458f, 0.02376653f, -0.06022748f, 0.00820848f, 0.01815074f, -0.05447987f, 
    0.24382697f, -0.10849959f, 0.00882057f, -0.09088998f, -0.12099005f, -0.15262942f, 0.26768154f, 0.30663374f, 
    0.06098362f, -0.03446394f, 0.06896032f, 0.03686288f, 0.13272010f, -0.15203097f, -0.12687890f, 0.02307653f, 
    -0.46141914f, 0.11215746f, -0.18400563f, -0.14506884f, 0.01984591f, -0.03597263f, 0.05503179f, -0.07866587f, 
    -0.08368384f, -0.25148892f, 0.20569740f, 0.05581982f, 0.08733285f, 0.09500888f, 0.22544830f, -0.39096513f, 
    0.18287431f, -0.14164652f, 0.07429419f, 0.21230367f, -0.08489926f, 0.04573864f, 0.02001789f, 0.15896051f, 
    -0.18954688f, 0.53122354f, 0.17614613f, 0.05333670f, 0.04521737f, -0.04011383f, 0.09787057f, -0.10637954f, 
    -0.00541184f, -0.15079093f, -0.09919444f, -0.08443393f, -0.35317141f, -0.10840815f, -0.09052283f, 0.05782336f, 
    0.15752847f, 0.08673708f, -0.08789035f, 0.00600953f, 0.04310860f, -0.01061845f, -0.02082512f, -0.13446605f, 
    0.05390111f, 0.04648496f, -0.01490604f, 0.15625466f, 0.00737027f, 0.21141724f, 0.09046128f, 0.01878264f, 
    0.05010253f, 0.05010212f, -0.05050923f, 0.14549573f, -0.10771284f, -0.03716934f, -0.06583662f, 0.02784372f, 
    0.33403718f, -0.17144261f, -0.00138222f, 0.15653418f, -0.09284786f, -0.00197195f, 0.06663061f, 0.06089830f, 
    -0.10138305f, -0.14205131f, -0.00710961f, 0.03005069f, -0.07368197f, 0.07727231f, -0.01332136f, 0.02090286f, 
    -0.04267894f, -0.11649366f, 0.01396084f, 0.08301651f, 0.40806109f, -0.13371859f, -0.33889988f, 0.09915385f, 
    -0.21419151f, -0.10196988f, -0.00286931f, 0.08715130f, -0.04448712f, -0.10237934f, 0.01670654f, -0.00586103f, 
    -0.38127503f, -0.19852193f, 0.23422262f, 0.13500462f, 0.03939728f, -0.07771876f, -0.09318563f, -0.00976370f, 
    0.08825131f, -0.00295632f, -0.23777866f, -0.10157637f, 0.15953295f, 0.22916894f, 0.09519829f, 0.05456699f, 
    0.03149329f, 0.01352371f, 0.06002406f, 0.11603195f, 0.07172102f, 0.11127005f, 0.04169602f, 0.18656150f, 
    0.45843598f, -0.12050325f, -0.33871230f, -0.03288255f, -0.03719807f, -0.08881842f, 0.00701926f, -0.01343873f, 
    -0.18339430f, -0.02185476f, 0.09156346f, -0.02776170f, -0.11049882f, 0.02207427f, 0.32973209f, -0.02584523f, 
    -0.19583768f, -0.09385319f, 0.09081217f, -0.16330880f, 0.07498269f, -0.03021842f, -0.07173508f, -0.10814852f, 
    -0.09334462f, -0.15382886f, 0.33355156f, 0.03642444f, -0.03557771f, -0.08465078f, -0.05014850f, 0.00643596f, 
    -0.03175252f, 0.11453268f, 0.07988026f, 0.10532688f, 0.00418786f, 0.22556922f, -0.28887898f, -0.10302135f, 
    0.12123641f, 0.31227526f, -0.07223506f, 0.03358581f, -0.07973778f, -0.12751080f, 0.09770320f, 0.10274401f, 
    0.11486443f, -0.17400458f, -0.06900028f, -0.04082216f, 0.04920160f, 0.06354246f, 0.06514914f, 0.15228957f, 
    -0.12563886f, 0.02542730f, 0.06923684f, -0.00631721f, -0.22359489f, 0.02149493f, 0.10424173f, 0.07928503f, 
    -0.22977760f, -0.19973631f, 0.02840558f, 0.06780103f, 0.15036327f, -0.00059601f, 0.07400732f, -0.14500855f, 
    -0.67151475f, 0.14621036f, 0.07048722f, -0.48272121f, -0.04105191f, -0.17102587f, -0.07498583f, 0.02423793f, 
    -0.07208313f, -0.06327634f, -0.12749249f, 0.07804754f, -0.13946599f, -0.09364364f, 0.06175575f, 0.14069477f, 
    -0.01811102f, -0.12395345f, 0.15001731f, 0.13592851f, -0.18746769f, -0.01210051f, 0.08096411f, -0.14653708f, 
    -0.23468138f, 0.15744108f, -0.05817598f, -0.10483705f, -0.00545194f, -0.07148273f, -0.14691961f, 0.17904289f, 
    -0.01692543f, 0.00473469f, 0.01568735f, -0.06851516f, 0.10540119f, -0.37551811f, -0.04133016f, -0.11547130f, 
    -0.10091973f, -0.19521159f, -0.03161954f, -0.40261093f, 0.05735418f, 0.04333877f, -0.09788162f, -0.18412828f, 
    -0.53420252f, -0.18098645f, 0.09294397f, 0.11323581f, 0.02866709f, 0.03431455f, -0.20092653f, 0.04536520f, 
    0.07930980f, -0.13233626f, -0.01030840f, 0.06311576f, -0.11081041f, 0.13397330f, 0.13014431f, 0.24251990f, 
    0.07948858f, 0.03313175f, -0.02624019f, -0.04317906f, 0.10328602f, -0.00169366f, 0.03749812f, -0.11554942f, 
    -0.21741378f, -0.24439445f, 0.17743194f, -0.07385509f, -0.05996806f, 0.04656458f, 0.07109310f, -0.01923771f, 
    -0.03721327f, -0.15458657f, -0.01374635f, -0.14177851f, 0.26038316f, -0.30229622f, 0.06903709f, 0.18995439f, 
    -0.01031957f, -0.00779413f, 0.17434181f, -0.30947623f, -0.04257489f, 0.12435479f, -0.03674560f, 0.04277657f, 
    -0.70413220f, -0.08609988f, 0.18858203f, 0.28594100f, 0.02001081f, -0.08056652f, 0.07172165f, -0.03173217f, 
    -0.13626201f, 0.08357988f, 0.13673599f, 0.08223815f, -0.27439854f, -0.12770055f, 0.07941093f, -0.21019827f, 
    0.12110288f, 0.12376226f, 0.05270039f, 0.12965076f, 0.01267436f, 0.15466526f, 0.15455285f, 0.26803288f, 
    -0.44780046f, 0.32194623f, -0.07575879f, -0.20284037f, 0.11807400f, -0.05642075f, -0.04388412f, -0.01380316f, 
    -0.00871685f, 0.06302422f, -0.04002023f, 0.01172176f, -0.17065555f, 0.34353378f, 0.01189718f, -0.16907696f, 
    -0.03808797f, 0.02004941f, 0.13440350f, 0.03542738f, 0.03430508f, -0.00751462f, -0.12483508f, 0.01923797f, 
    0.03142211f, 0.05071174f, -0.03779559f, 0.13586865f, -0.13065515f, -0.00335863f, -0.10406194f, -0.05891384f, 
    -0.05512522f, 0.14822961f, 0.12168282f, 0.02311699f, -0.32633734f, 0.25930876f, -0.45150530f, -0.14494519f, 
    0.22623172f, 0.03492116f, -0.18998596f, 0.00890408f, -0.03619527f, -0.07178383f, -0.20374554f, 0.01999950f, 
    -0.10617162f, -0.20163238f, -0.08684886f, 0.09355731f, 0.25083554f, -0.05846521f, -0.06928097f, 0.03107385f, 
    0.19418366f, 0.30941316f, -0.15675244f, -0.08051988f, -0.30082282f, -0.02614248f, -0.20726328f, 0.03238814f, 
    -0.12744863f, -0.00312776f, -0.09276544f, 0.06102439f, -0.02162042f, 0.10144907f, 0.23249340f, 0.08754392f, 
    -0.61345178f, -0.02954042f, -0.14671382f, -0.46364957f, 0.05175095f, 0.07685432f, 0.15401044f, 0.09627766f, 
    0.02711496f, 0.16881011f, -0.09517330f, -0.08812723f, -0.05512690f, -0.16462053f, -0.12237639f, 0.31428856f, 
    0.15759435f, -0.05718229f, 0.06650908f, 0.18290265f, 0.01065146f, -0.02514724f, -0.15176274f, 0.10712365f, 
    -0.31802991f, 0.02893912f, -0.33639640f, 0.16754214f, -0.08346710f, -0.03320438f, 0.02925534f, 0.03417266f, 
    0.19151808f, 0.09041472f, -0.23582944f, 0.17141072f, -0.07681342f, 0.15665129f, 0.02491589f, -0.25461006f, 
    -0.11226198f, -0.07752542f, 0.12190484f, -0.12300953f, -0.14067970f, -0.06565635f, -0.04360422f, -0.19394851f, 
    -0.70340824f, -0.22191505f, -0.13598080f, 0.02057029f, 0.09527171f, 0.04931276f, -0.06273209f, -0.07761299f, 
    0.06580688f, 0.06658611f, 0.02271349f, 0.17269680f, -0.15209450f, -0.11748970f, 0.04668223f, -0.11595857f, 
    0.02955288f, 0.20328373f, 0.02435488f, -0.02774051f, -0.09926777f, -0.19995861f, 0.13086130f, -0.06762619f, 
    0.26281229f, -0.07464246f, -0.28491640f, -0.05312217f, -0.04006593f, -0.08450588f, 0.02363351f, -0.38861808f, 
    -0.19933958f, 0.09075078f, -0.02505423f, -0.14162222f, -0.18490814f, 0.07874749f, 0.34145927f, -0.15955751f, 
    -0.08452984f, 0.01096450f, 0.12257491f, -0.04530982f, 0.38059092f, -0.19478156f, -0.14507380f, 0.04507937f, 
    0.07573836f, -0.07475232f, 0.06865331f, 0.24876028f, -0.28612930f, -0.09996264f, 0.09724832f, 0.01342807f, 
    -0.14739349f, -0.31092662f, -0.02058135f, 0.29583362f, 0.16887896f, -0.00662489f, 0.26450837f, -0.05068817f, 
    -0.11581815f, 0.25451040f, -0.17786467f, -0.02186478f, -0.00139928f, 0.01857848f, -0.01431458f, -0.14764178f, 
    0.02605131f, 0.17507435f, 0.34649846f, -0.11631870f, 0.06895702f, -0.17284076f, 0.26206335f, -0.20748554f, 
    0.16558118f, 0.01945840f, -0.03308083f, 0.21674471f, 0.02425487f, -0.20889062f, 0.03490919f, 0.27856094f, 
    -0.21806884f, -0.10540035f, -0.20053124f, 0.11094252f, 0.15890545f, 0.19126688f, 0.09899645f, 0.11668912f, 
    0.27841797f, 0.21303529f, -0.08699315f, 0.18561204f, 0.05316071f, -0.03113306f, 0.23021752f, 0.05464218f, 
    -0.04219864f, -0.09329939f, 0.02912690f, -0.06474609f, 0.02806067f, -0.03672061f, -0.20653483f, -0.11232375f, 
    0.06364062f, 0.00553009f, 0.29435974f, 0.11822847f, -0.17111763f, 0.20612258f, -0.04343913f, -0.23722646f, 
    -0.29659396f, -0.05574723f, 0.22279070f, 0.44562474f, -0.10570966f, 0.12363528f, -0.04554234f, 0.02521113f, 
    -0.09020045f, -0.14014512f, 0.02118439f, 0.20990619f, 0.17091583f, 0.02080436f, 0.23242109f, 0.00333487f, 
    0.08259603f, 0.26504314f, 0.08536325f, -0.02205791f, -0.01498554f, 0.13294253f, 0.15585099f, 0.21979509f, 
    -0.11989399f, 0.07336665f, 0.00822223f, -0.00526393f, -0.04550008f, 0.00421558f, 0.07835229f, 0.15348727f, 
    0.07982360f, -0.11593933f, 0.14999363f, -0.21637352f, 0.24922603f, 0.06030944f, -0.12438440f, -0.09516907f, 
    -0.02386499f, 0.07579519f, -0.20734246f, -0.18974736f, -0.01387265f, -0.02800230f, 0.08657136f, -0.12713741f, 
    0.01821939f, -0.04404950f, 0.16428572f, 0.18453427f, -0.01865995f, 0.18464230f, 0.08782256f, 0.03942734f, 
    -0.13589048f, 0.13321961f, -0.16376661f, 0.14318402f, 0.15216862f, 0.12960616f, 0.10695903f, 0.03899245f, 
    -0.03624998f, 0.00994843f, -0.02080103f, -0.00100416f, -0.10674075f, -0.04515252f, 0.11503811f, -0.19524756f, 
    0.11396036f, -0.11729465f, 0.04801466f, 0.11994858f, -0.05003848f, 0.07832301f, 0.17448400f, 0.11812814f, 
    -0.23913750f, 0.14552985f, 0.16230682f, 0.16309564f, -0.20295732f, -0.26291585f, -0.15737316f, 0.01236043f, 
    0.04584489f, -0.12549666f, -0.05861921f, -0.01502804f, 0.12421174f, 0.10079229f, -0.09151024f, 0.08987656f, 
    -0.03043903f, 0.25353646f, 0.08241052f, 0.22028832f, 0.03147063f, -0.22490944f, 0.00772830f, 0.18659182f, 
    0.19711410f, 0.00597678f, 0.11610498f, 0.03028350f, 0.14973153f, -0.02635821f, -0.06993259f, -0.32397881f, 
    0.02810231f, -0.10987284f, -0.12160991f, 0.02105320f, 0.06406023f, -0.01320193f, -0.14187987f, -0.02660956f, 
    -0.01635483f, 0.18810581f, -0.28019181f, -0.10376015f, 0.09638746f, 0.15568243f, 0.02075709f, -0.18365525f, 
    0.07143905f, -0.22201800f, -0.08532116f, -0.15566237f, -0.06273928f, 0.12724531f, 0.10620606f, 0.16365027f, 
    -0.05280398f, -0.15915377f, 0.03374133f, -0.30972943f, 0.05724981f, -0.24591345f, -0.21052726f, -0.12448846f, 
    -0.41826180f, 0.18434097f, 0.05446782f, -0.16057947f, -0.09024327f, -0.06924670f, -0.07680842f, -0.00727527f, 
    0.04479744f, -0.13932306f, 0.03091248f, -0.02637014f, -0.58352083f, -0.33711770f, 0.14476439f, 0.16085567f, 
    0.00837146f, 0.04482174f, 0.16064844f, -0.23386815f, 0.00264337f, 0.04982330f, 0.06717342f, -0.09905779f, 
    0.15540883f, 0.23525812f, 0.12813500f, -0.62455893f, 0.15618457f, 0.12466862f, 0.04245376f, 0.15128578f, 
    -0.09056065f, 0.01097611f, -0.11201021f, -0.01878718f, 0.13990824f, -0.43866873f, 0.03009277f, -0.24610205f, 
    -0.04392406f, 0.16238275f, 0.03752575f, 0.08324569f, -0.03630952f, 0.08822708f, 0.12646501f, 0.14233026f, 
    -0.38478088f, -0.17510815f, -0.40898171f, 0.04034731f, 0.05525650f, -0.01534449f, 0.07615259f, -0.17122106f, 
    0.08201584f, -0.11233677f, -0.07002164f, -0.00263469f, -0.18083321f, 0.00797664f, -0.28684053f, -0.25724286f, 
    -0.02360420f, -0.04495751f, 0.04284197f, -0.03132262f, 0.03261133f, -0.02480462f, -0.11671943f, -0.05785786f, 
    0.02982646f, -0.26731297f, 0.13383502f, 0.17684820f, 0.02526864f, 0.12536581f, -0.05561041f, -0.08439869f, 
    0.13820420f, -0.25334221f, 0.18265519f, 0.12712425f, 0.07340243f, -0.16116288f, -0.02494646f, -0.03803029f, 
    -0.09072917f, 0.05436071f, -0.05387139f, -0.21749720f, -0.06520972f, 0.01818940f, 0.10833731f, -0.03703237f, 
    0.25173122f, -0.11556043f, 0.14460427f, -0.13226435f, -0.21960790f, 0.07755198f, -0.08747737f, -0.03255584f, 
    -0.02448742f, 0.00152801f, 0.14779802f, -0.08197782f, 0.23677567f, -0.39262226f, 0.13895905f, -0.03082035f, 
    -0.15742624f, 0.03082289f, 0.06024621f, 0.00346151f, 0.02836983f, -0.04394688f, 0.15739831f, 0.23734468f, 
    -0.50637358f, -0.01775022f, -0.14662507f, -0.01843728f, 0.03714782f, -0.05914219f, 0.03849003f, -0.00915260f, 
    0.18403864f, -0.18800630f, 0.05245927f, -0.12834281f, 0.05618333f, 0.09889436f, 0.02267258f, -0.34576958f, 
    -0.16583446f, -0.11763610f, 0.04748607f, -0.17571887f, 0.19067608f, -0.12390141f, 0.02375613f, 0.26424369f, 
    -0.30468532f, 0.05620098f, -0.23111667f, 0.34345469f, -0.03920176f, 0.08640070f, 0.07330345f, 0.17326853f, 
    0.16642891f, -0.05252024f, -0.08903734f, -0.20181096f, -0.33031687f, 0.11099721f, 0.06602442f, -0.21838802f, 
    0.07308417f, -0.14361238f, 0.08738950f, 0.10249666f, -0.14843832f, 0.17976439f, 0.16237307f, 0.02421774f, 
    -0.09378380f, 0.27569926f, 0.07528499f, -0.28404734f, 0.10599095f, 0.04886389f, -0.08003733f, 0.07455635f, 
    0.00605808f, 0.32161713f, -0.04991792f, -0.06317027f, 0.08163265f, 0.19096161f, 0.11946697f, -0.39629838f, 
    -0.03847301f, -0.09325059f, 0.01019561f, 0.04304586f, 0.04927538f, -0.05723477f, 0.02773813f, 0.08694392f, 
    -0.25765422f, -0.04960663f, 0.22577171f, -0.31274787f, 0.01106358f, 0.03234576f, -0.12754403f, 0.14637044f, 
    0.14590336f, 0.08251683f, -0.08077255f, -0.23012203f, -0.05482636f, -0.27041996f, -0.01904571f, 0.02760288f, 
    0.19729407f, -0.14970909f, 0.05180512f, 0.00263603f, -0.11980634f, -0.05784768f, -0.15318397f, -0.14245415f, 
    -0.25725198f, -0.09178766f, -0.37091178f, -0.16650306f, -0.03360046f, 0.04164429f, 0.04723904f, 0.02460305f, 
    0.10772324f, 0.00281938f, 0.00506736f, 0.13284126f, -0.11993985f, 0.04448272f, 0.04111340f, -0.16645950f, 
    -0.01062178f, -0.03405856f, -0.08265886f, -0.07454836f, 0.06442123f, -0.14599490f, -0.05034469f, 0.17379805f, 
    0.14670864f, -0.08365248f, -0.18502137f, 0.15760215f, -0.10920749f, -0.18748666f, -0.17507213f, -0.09010126f, 
    -0.02935880f, -0.13265616f, -0.10025622f, 0.03585747f, -0.17566738f, 0.34719759f, 0.23926359f, -0.13298008f, 
    -0.10060520f, -0.03886076f, -0.10857999f, -0.02244798f, 0.16441151f, -0.13693851f, -0.00776828f, -0.43143335f, 
    0.35215196f, -0.19390176f, 0.27257112f, -0.11204772f, 0.06862868f, -0.18206035f, 0.08793366f, -0.10766783f, 
    -0.09689998f, 0.07131033f, 0.02709321f, 0.02094883f, 0.04540763f, 0.11104763f, -0.04573362f, 0.45640802f, 
    0.05366696f, 0.07316539f, 0.07489143f, 0.03132077f, 0.00532008f, -0.01952873f, 0.03729735f, 0.05028309f, 
    -0.12366717f, 0.22729166f, 0.01637183f, 0.17997098f, -0.10400750f, -0.11779958f, 0.09868561f, 0.11469128f, 
    0.02988390f, 0.02246857f, 0.12821113f, -0.09473719f, -0.28293407f, 0.09706825f, 0.05867197f, 0.18549754f, 
    -0.03017686f, 0.01126154f, 0.00298617f, -0.02076772f, -0.06498792f, 0.01247066f, -0.00607602f, -0.05412353f, 
    0.16582213f, 0.13485272f, 0.12892678f, -0.22501330f, 0.05199736f, 0.02111010f, 0.00559728f, -0.12435913f, 
    0.10687570f, -0.23541807f, -0.08379395f, -0.15794535f, -0.14957473f, 0.09010267f, -0.12536748f, -0.06624955f, 
    0.11869790f, 0.02429372f, -0.00591684f, 0.12333920f, 0.06530815f, -0.04454669f, -0.08968220f, -0.24997437f, 
    -0.06695482f, -0.11679717f, -0.23830955f, 0.37872532f, 0.06664769f, 0.25732356f, -0.09480947f, 0.02153819f, 
    -0.00057853f, 0.06380323f, -0.14776555f, -0.01592918f, -0.66569030f, 0.28273514f, 0.20325208f, -0.40443766f, 
    -0.09459306f, 0.12912138f, 0.14280997f, 0.10548867f, -0.07754438f, -0.04030244f, 0.09057665f, -0.08591828f, 
    -0.11937515f, -0.48355055f, -0.18253036f, -0.24845222f, -0.11756784f, 0.08373617f, -0.06369858f, -0.13293104f, 
    -0.08636791f, 0.03759733f, 0.04020238f, 0.27048203f, -0.16702616f, -0.02337090f, 0.08937861f, 0.32828107f, 
    0.02942939f, -0.02092966f, -0.15194756f, 0.04304178f, -0.01945837f, 0.02608626f, 0.08487847f, 0.31249079f, 
    0.84667647f, -0.05100495f, 0.24300355f, -0.06987616f, 0.08056285f, 0.03397718f, 0.16052416f, 0.08668591f, 
    -0.07940782f, 0.12765296f, -0.04608704f, 0.01477503f, 0.00897131f, -0.04418202f, -0.20969327f, 0.13953924f, 
    -0.09448765f, 0.04468199f, 0.13675095f, 0.05155547f, -0.09398064f, 0.10146348f, -0.20550600f, 0.14219296f, 
    -0.06040593f, -0.06577611f, -0.01722608f, 0.01727075f, -0.14356774f, 0.04187569f, 0.04196823f, -0.14921291f, 
    -0.09029431f, 0.03073071f, -0.04245887f, -0.20878595f, 0.04854119f, 0.33804092f, 0.30828527f, 0.14052781f, 
    -0.03254649f, 0.10539837f, 0.03515639f, 0.04094067f, -0.03950878f, -0.01426395f, 0.02559287f, -0.03189550f, 
    0.05118546f, 0.24205922f, -0.01887852f, 0.15491395f, -0.01958273f, -0.03244837f, -0.14173204f, -0.05798056f, 
    0.05844205f, -0.03685855f, -0.08399549f, -0.09471434f, -0.00071503f, 0.03940660f, -0.02650223f, 0.13306397f, 
    -0.01104525f, -0.16389246f, -0.10867600f, -0.00607112f, 0.09697533f, -0.06233440f, -0.02543692f, -0.11479589f, 
    -0.11390272f, -0.16942571f, 0.26211512f, 0.10193580f, -0.00034186f, 0.03760863f, 0.05442784f, 0.04509598f, 
    0.02356473f, 0.05224613f, 0.02223011f, 0.10724711f, 0.24363154f, -0.04194080f, 0.21109647f, 0.10639565f, 
    0.01815481f, 0.06858507f, -0.09220035f, -0.05432642f, -0.07931632f, -0.01015147f, 0.06090751f, 0.00620814f, 
    0.02629486f, 0.23824258f, -0.29305667f, -0.08270158f, -0.06792759f, 0.02990018f, -0.05442870f, -0.12027001f, 
    -0.13413650f, -0.01820298f, -0.18221299f, -0.13997446f, 0.07739124f, 0.08702914f, 0.08080426f, 0.06208086f, 
    0.07974603f, -0.17125121f, -0.03553014f, 0.00103522f, 0.00864880f, 0.07769325f, -0.03612870f, -0.09920251f, 
    0.30374032f, 0.08532519f, 0.24631816f, 0.08929760f, -0.05638367f, -0.02041852f, -0.04181438f, -0.09692773f, 
    0.00402873f, -0.07784789f, -0.07717100f, -0.04672588f, 0.09300706f, -0.05281944f, 0.05422730f, -0.02047255f, 
    -0.17707230f, 0.03977316f, 0.03344782f, 0.00112852f, -0.15792485f, -0.00891308f, -0.07544386f, 0.05991150f, 
    -0.18020666f, 0.10595943f, -0.38422126f, 0.05933638f, 0.05428389f, 0.04484665f, -0.19107425f, 0.03069451f, 
    0.04390990f, 0.00619671f, -0.05679231f, -0.06718176f, -0.36538535f, 0.30815104f, 0.18395950f, 0.00961712f, 
    0.01447419f, -0.05865381f, -0.02841707f, -0.04525806f, -0.05184641f, -0.14252919f, -0.14307329f, -0.15726458f, 
    -0.23984323f, -0.20110053f, -0.22264458f, 0.06299387f, -0.00226036f, -0.05538415f, -0.05773104f, -0.02421193f, 
    -0.04378576f, -0.05175100f, 0.05388764f, 0.00678090f, -0.29391342f, 0.09992665f, -0.07516123f, -0.20208575f, 
    -0.16902541f, -0.06770544f, 0.00054486f, -0.11526583f, 0.00283968f, 0.00131997f, -0.04963055f, 0.01784138f, 
    -0.13014157f, -0.02320445f, -0.05261320f, -0.11025555f, -0.05510798f, -0.07338435f, -0.08432539f, -0.05732518f, 
    0.11871140f, -0.04520424f, -0.05074624f, -0.01794237f, 0.54012203f, -0.12216827f, 0.36282399f, 0.25160986f, 
    0.19679481f, -0.05051512f, -0.11070950f, -0.02205823f, -0.11552238f, -0.01208965f, -0.01905633f, 0.03910314f, 
    0.15553820f, -0.09693452f, 0.20551181f, 0.15057246f, 0.04459793f, -0.05173941f, -0.09821852f, -0.07308330f, 
    0.08578225f, 0.10476974f, -0.06809691f, -0.14399666f, 0.16061917f, 0.24541332f, 0.17516854f, 0.26017505f, 
    0.03780471f, 0.04078558f, -0.00281406f, 0.05867507f, -0.09415848f, 0.02907258f, -0.08830016f, -0.09051446f, 
    0.23086503f, 0.29235873f, 0.06821811f, 0.39249650f, -0.00112294f, -0.24505432f, -0.07300398f, 0.00801997f, 
    -0.02920925f, 0.10050438f, -0.04459241f, 0.03269635f, -0.28799388f, -0.21446016f, -0.10720394f, -0.08780648f, 
    0.02297137f, 0.00107657f, -0.07586920f, -0.01072322f, -0.00599617f, -0.07278056f, 0.00597229f, -0.03575025f, 
    0.23231122f, 0.16949841f, -0.02137021f, -0.03990291f, -0.15810369f, 0.06570780f, -0.06432356f, 0.10653312f, 
    -0.06125879f, 0.05898220f, -0.09233534f, -0.10679189f, -0.38479802f, 0.18301684f, 0.03322507f, -0.01013642f, 
    -0.02211274f, -0.15675320f, 0.02083227f, 0.00363271f, 0.07752649f, 0.01213213f, -0.07679032f, -0.06579330f, 
    0.02724707f, -0.30032903f, -0.07510000f, -0.17741336f, -0.02017491f, -0.00165762f, -0.04170255f, -0.06191652f, 
    -0.03794352f, -0.08149916f, -0.16966479f, 0.09946930f, -0.41220355f, 0.28221387f, -0.30981299f, -0.16663666f, 
    -0.12297503f, 0.13122869f, -0.11671696f, -0.02567052f, -0.02889867f, -0.00543668f, 0.17660253f, -0.00923936f, 
    -0.33660486f, -0.07254472f, -0.35476112f, -0.12530960f, 0.01589443f, -0.21631853f, -0.00331697f, -0.07242227f, 
    0.00606268f, -0.02444390f, -0.03781633f, -0.03798104f, -0.12361864f, 0.26934797f, -0.00583477f, 0.10606449f, 
    -0.01051645f, 0.11344771f, -0.17282145f, -0.16215715f, -0.03030292f, 0.06052685f, 0.00007150f, -0.18661048f, 
    -0.30621284f, -0.21278593f, -0.09462304f, -0.16537273f, -0.04199081f, -0.08159253f, 0.10024390f, -0.00800760f, 
    -0.13597229f, -0.03362667f, -0.06505051f, -0.02924759f, 0.03525567f, 0.20375931f, -0.12572396f, -0.29537430f, 
    0.08004216f, 0.04342747f, -0.13675885f, -0.06578938f, -0.08385510f, -0.05570820f, 0.04177192f, 0.01373450f, 
    0.10754684f, 0.32973486f, 0.20425403f, 0.07308044f, 0.00921345f, 0.05941518f, 0.10662165f, -0.00237970f, 
    0.02904344f, 0.11611929f, 0.04673477f, -0.08147841f, -0.20154245f, -0.30738547f, -0.31752995f, 0.03517316f, 
    -0.16463265f, 0.03715655f, -0.01045186f, -0.06303366f, 0.03768064f, -0.07408433f, 0.08808175f, -0.01928889f, 
    0.49792323f, -0.04266462f, -0.06028349f, -0.30077490f, -0.15067565f, 0.11292941f, 0.03539522f, -0.18265426f, 
    -0.08456152f, 0.08622149f, -0.03730544f, -0.06225296f, -0.06416576f, -0.09186633f, 0.13432494f, 0.11243527f, 
    0.16148974f, -0.08601122f, -0.11273095f, 0.06696833f, -0.05177890f, 0.11095275f, 0.05449242f, 0.01239579f, 
    -0.18702666f, -0.20468129f, -0.05057308f, 0.17771590f, -0.05274840f, -0.07254731f, -0.06922502f, -0.15149260f, 
    -0.06533344f, 0.11745276f, -0.00677152f, 0.09240077f, -0.36333221f, 0.00733377f, 0.14832427f, 0.00568380f, 
    0.03237916f, -0.12160442f, -0.15722193f, 0.01403018f, 0.01034112f, -0.13788037f, -0.16309763f, -0.06263074f, 
    -0.07964843f, 0.23676568f, -0.00071759f, -0.26786888f, -0.06060947f, 0.13062201f, -0.11820820f, -0.00468696f, 
    0.06615753f, 0.02438669f, -0.06887144f, 0.08582289f, -0.21853699f, 0.17740002f, -0.15381135f, -0.33958337f, 
    -0.08865976f, -0.09146163f, -0.17461665f, -0.11995716f, -0.06187384f, -0.02071779f, 0.12849289f, 0.11764088f, 
    -0.17079644f, -0.01797349f, 0.17054807f, 0.25264439f, 0.02127825f, 0.02572369f, -0.05774543f, -0.17395255f, 
    0.05032803f, -0.01485696f, -0.05265947f, 0.01248874f, 0.00375542f, -0.23106077f, -0.12996507f, -0.46638548f, 
    0.06065013f, 0.06520840f, 0.08108378f, -0.13927621f, 0.09019160f, 0.04356815f, -0.16506818f, 0.10910688f, 
    -0.03559596f, 0.03100590f, 0.26465264f, -0.02738540f, -0.08595223f, 0.05235332f, 0.05432979f, 0.02643661f, 
    0.10035031f, -0.02455495f, 0.09343575f, 0.13485186f, 0.28053886f, -0.19609295f, 0.17867284f, -0.02508933f, 
    -0.22653176f, -0.11321241f, 0.07043437f, -0.06027587f, 0.00359003f, -0.11054704f, -0.03535993f, -0.01424519f, 
    0.02499441f, 0.19669867f, -0.04921769f, 0.03680279f, -0.02185128f, -0.02151631f, -0.02364486f, -0.10517954f, 
    -0.18039131f, 0.01812437f, 0.18342307f, 0.11346770f, -0.39397126f, 0.19411977f, -0.02079336f, -0.33752820f, 
    0.08769504f, -0.00253473f, -0.15337886f, -0.02357661f, -0.05126780f, -0.01568425f, -0.15338229f, -0.29009676f, 
    0.15124983f, 0.29073182f, -0.25174657f, 0.02410540f, 0.01603213f, 0.00142623f, -0.06954324f, -0.11391101f, 
    -0.09974036f, -0.02046611f, -0.10675871f, 0.07069919f, 0.25861686f, 0.06239179f, -0.04160555f, 0.22703174f, 
    0.16924375f, 0.04750575f, -0.12500893f, -0.17773652f, -0.04906423f, -0.09647532f, 0.11990964f, -0.02681297f, 
    -0.11303905f, -0.19266143f, -0.34544742f, -0.03505692f, 0.18186246f, 0.14095083f, 0.08077842f, -0.06254282f, 
    0.06041045f, 0.06534997f, 0.05632932f, 0.05277707f, 0.12057970f, -0.01026699f, 0.07890656f, 0.28656769f, 
    0.15807372f, -0.08544698f, -0.05123011f, 0.00582384f, 0.01823583f, -0.04432054f, 0.21673246f, -0.22778864f, 
    0.05590931f, -0.00950390f, 0.00886614f, 0.19930080f, -0.06221691f, -0.17142814f, 0.02133936f, -0.10437547f, 
    -0.08414855f, 0.05497019f, -0.01434412f, 0.17240432f, 0.05458556f, -0.05862133f, -0.25034192f, -0.25414282f, 
    -0.09367150f, 0.01145930f, -0.11159203f, -0.06824032f, -0.04340322f, 0.06817231f, 0.05179925f, 0.08747628f, 
    -0.14687425f, -0.40529332f, -0.24140757f, -0.29160073f, -0.02959802f, 0.02390030f, 0.20042916f, -0.22948262f, 
    0.04077697f, 0.05499213f, -0.05495351f, 0.06440970f, -0.46337765f, -0.16017562f, 0.01380792f, -0.29684290f, 
    0.01165863f, -0.13542941f, 0.03241658f, 0.17939758f, 0.14575188f, 0.15611738f, -0.08826087f, -0.10375606f, 
    -0.34089276f, 0.47650793f, -0.18737914f, -0.36167276f, 0.07461199f, 0.02059303f, -0.15826923f, 0.01169346f, 
    0.16416530f, -0.12693246f, 0.14136863f, 0.02103698f, 0.01234345f, -0.18531953f, 0.00741753f, 0.15340348f, 
    0.09434044f, 0.08421944f, -0.09602997f, -0.04730372f, -0.03374844f, 0.15433601f, 0.07874878f, 0.12681885f, 
    0.24286027f, 0.06824152f, -0.05980166f, -0.09539254f, 0.09217168f, -0.09845515f, 0.04796329f, -0.03754197f, 
    0.05282544f, 0.06200871f, 0.02311192f, -0.06607574f, 0.22250909f, 0.26451126f, -0.37669542f, 0.07324643f, 
    0.03922257f, 0.09656324f, -0.35313877f, 0.00328694f, 0.01137698f, -0.08168875f, 0.08571427f, 0.19262783f, 
    0.13450047f, 0.12767881f, -0.15199611f, 0.20692949f, 0.07949819f, -0.01577076f, -0.12030891f, -0.04229998f, 
    -0.02566297f, 0.00947372f, -0.14492509f, 0.03788503f, 0.08814172f, 0.04653751f, -0.37406725f, -0.07676459f, 
    0.15190527f, -0.11114567f, -0.11095725f, 0.11209244f, 0.18764961f, 0.03991801f, 0.03573130f, -0.13381264f, 
    0.08992518f, -0.04443184f, -0.08644691f, -0.01439375f, -0.11524008f, -0.06055205f, -0.00862010f, -0.05431484f, 
    0.12536161f, 0.04013637f, 0.06764790f, -0.14606999f, -0.22657792f, 0.40852502f, 0.05287753f, 0.19134167f, 
    -0.37668636f, 0.09856333f, -0.00193167f, -0.10458291f, 0.10056696f, -0.03605265f, 0.02568501f, 0.12577516f, 
    0.22244678f, 0.19727822f, -0.34531635f, -0.02384015f, -0.00551939f, 0.04497732f, -0.12841694f, 0.05615492f, 
    0.00921674f, 0.14662234f, 0.12186576f, 0.00031139f, -0.06536031f, -0.16589154f, -0.00883475f, -0.02511669f, 
    0.15352602f, -0.07799701f, -0.08801345f, -0.00507031f, 0.03728854f, 0.12627985f, -0.24875277f, -0.20535517f, 
    0.07734773f, -0.00956510f, 0.14151433f, 0.13805149f, -0.16666783f, 0.00429511f, 0.02905437f, -0.04531359f, 
    -0.01448598f, -0.16963118f, -0.26940367f, -0.21232435f, 0.18476106f, 0.09181935f, -0.09033772f, 0.01476432f, 
    0.04845220f, 0.04521187f, -0.02025400f, -0.08782347f, 0.08430744f, 0.03381776f, -0.17612466f, 0.02079635f, 
    -0.04751765f, 0.00307300f, -0.20972219f, -0.01724180f, 0.11952901f, -0.13500658f, -0.07231050f, 0.14355022f, 
    0.11852091f, -0.13194828f, 0.01917048f, 0.11593509f, 0.10356836f, 0.19074626f, -0.26056930f, 0.20141205f, 
    -0.06929161f, 0.01073578f, -0.12758641f, -0.14441602f, -0.01789552f, -0.09531667f, -0.07982918f, -0.05213986f, 
    -0.08792873f, 0.05822313f, 0.01763794f, -0.17437129f, 0.02619636f, -0.15743253f, 0.02237392f, 0.05068135f, 
    0.10753932f, 0.09401413f, 0.03534901f, -0.07506933f, -0.03891916f, -0.34082660f, -0.15502368f, -0.03141559f, 
    0.09607578f, -0.08675041f, -0.01210337f, -0.02479934f, 0.14433265f, -0.01239941f, 0.08674663f, -0.07587916f, 
    0.09486918f, -0.03994925f, 0.13609427f, 0.30748272f, -0.15420535f, 0.09794915f, -0.14891508f, 0.27369827f, 
    -0.11237700f, -0.33248976f, 0.05775424f, -0.06399801f, -0.15908331f, 0.02727603f, 0.02471292f, -0.15768500f, 
    0.11064950f, 0.17155221f, -0.01672931f, -0.18413727f, -0.00741166f, 0.04850043f, -0.13962172f, -0.15283416f, 
    0.31304434f, -0.46152768f, -0.09683401f, 0.22376454f, 0.05779340f, -0.10689624f, -0.22497335f, 0.02932673f, 
    -0.02425392f, 0.03060532f, -0.07842575f, -0.14721304f, -0.03763560f, -0.23349829f, 0.10303729f, 0.39176637f, 
    -0.15457985f, 0.08986742f, 0.07910619f, 0.00453740f, -0.03959372f, -0.00633054f, 0.06823304f, 0.10215221f, 
    0.35306004f, -0.11115053f, -0.04950435f, -0.47314039f, 0.07208107f, -0.01609794f, -0.01835590f, 0.05250316f, 
    -0.18734157f, -0.23549354f, 0.05073426f, 0.04597412f, 0.02546996f, 0.12086860f, -0.01884681f, 0.17420430f, 
    0.17820764f, -0.03910033f, -0.08928298f, 0.08168525f, -0.06371510f, 0.23267914f, -0.04426103f, 0.14112660f, 
    0.01521441f, -0.51322001f, -0.17877923f, 0.07221092f, -0.05087467f, -0.03487059f, 0.04759929f, 0.10439561f, 
    0.00910297f, 0.20530362f, -0.09613325f, -0.10792511f, -0.60406971f, 0.08628742f, -0.13072671f, 0.44564137f, 
    -0.08497645f, 0.15824315f, 0.00416157f, 0.10376024f, -0.06231811f, 0.12071884f, 0.06647415f, 0.13290730f, 
    -0.05800594f, 0.40670180f, 0.37473714f, 0.16013026f, 0.13493890f, 0.01255549f, -0.03737058f, 0.17255597f, 
    0.21596210f, -0.13860387f, 0.07323807f, -0.02452692f, -0.27679980f, 0.13955991f, -0.17283587f, -0.08633479f, 
    0.03373602f, 0.07068809f, -0.00239750f, -0.04210459f, -0.07564609f, 0.02386378f, -0.01747327f, -0.21685061f, 
    -0.07189699f, -0.11734639f, -0.02728201f, -0.40895718f, -0.04453776f, 0.12988186f, -0.19110827f, -0.02518195f, 
    0.00182526f, -0.04539313f, -0.05862023f, -0.04576431f, -0.39736086f, 0.08699533f, -0.32056564f, -0.08912686f, 
    0.19349122f, 0.03230977f, 0.11802026f, -0.07162051f, -0.14489140f, -0.10169146f, -0.19965856f, -0.08148327f, 
    0.11586068f, 0.13313311f, -0.43100575f, 0.02742757f, 0.03963667f, 0.03914127f, 0.02882562f, 0.02463691f, 
    -0.09179758f, -0.19511232f, 0.08907121f, -0.13542478f, 0.45510378f, -0.70296901f, 0.17226738f, -0.02119722f, 
    0.02928159f, 0.11616168f, -0.02096257f, 0.01934267f, -0.19052312f, -0.01544474f, 0.10006499f, -0.08344366f, 
    -0.01331022f, -0.15639067f, -0.05706338f, -0.17224629f, 0.08838211f, 0.12888919f, -0.01635827f, -0.16578595f, 
    0.05106477f, -0.13425441f, 0.02579236f, -0.07394686f, 0.25398573f, 0.07478873f, 0.05577657f, 0.03796309f, 
    0.01620135f, -0.06910906f, -0.09846792f, -0.20654155f, -0.18556255f, -0.12729961f, 0.07928431f, 0.02270313f, 
    -0.35067609f, -0.19643117f, 0.15758115f, -0.01977903f, -0.02054124f, 0.07265396f, -0.13673435f, 0.07734714f, 
    -0.01011922f, -0.11235939f, -0.11366141f, 0.05476402f, 0.04618521f, -0.06628861f, 0.05356367f, -0.11867493f, 
    0.22065614f, 0.12829003f, -0.12533776f, -0.08172767f, -0.25089076f, -0.06225697f, -0.15627046f, -0.11629971f, 
    0.09002737f, 0.11871748f, -0.26864675f, -0.07557606f, -0.02649947f, 0.17078213f, -0.07998733f, -0.06359843f, 
    0.01659355f, 0.18420956f, 0.10698959f, 0.15248829f, -0.59049392f, 0.09325806f, 0.41615483f, -0.24319881f, 
    -0.08285698f, -0.09505515f, 0.13555869f, 0.05542116f, 0.00730839f, 0.04942657f, -0.03909202f, 0.08599320f, 
    -0.07798293f, 0.14758375f, 0.11710928f, -0.21058184f, 0.26437667f, 0.06595052f, -0.15937997f, -0.14733632f, 
    0.15432097f, -0.00525335f, 0.06294356f, 0.04359688f, -0.40677238f, 0.17897828f, 0.31061155f, 0.13634282f, 
    0.15153307f, 0.11167993f, 0.24001220f, 0.02512168f, 0.00270543f, -0.13427787f, -0.12184294f, 0.15610686f, 
    -0.24483128f, 0.48560253f, -0.22598654f, -0.57328200f, 0.00636318f, 0.03468668f, 0.00376276f, 0.10574161f, 
    -0.19037469f, 0.16663459f, -0.09488798f, -0.02558445f, -0.06753300f, 0.26232594f, -0.06367956f, 0.19526161f, 
    0.09040564f, 0.13487792f, -0.03201924f, 0.12996480f, -0.11506366f, -0.09422021f, 0.13699143f, 0.01573494f, 
    0.14873813f, 0.13719365f, 0.22340763f, -0.08730717f, 0.07615585f, 0.10878506f, 0.09438490f, -0.20550033f, 
    -0.09084062f, 0.08148111f, -0.00005804f, -0.06348005f, -0.18911007f, 0.13035563f, -0.07272616f, -0.07797722f, 
    -0.06666338f, -0.02406099f, -0.12759499f, -0.19837305f, 0.01156172f, -0.08183371f, 0.19710827f, 0.04886305f, 
    -0.22640842f, -0.11635055f, 0.03151627f, 0.02873940f, 0.27342820f, 0.00793139f, -0.02609320f, 0.05667395f, 
    0.04654440f, 0.10272241f, 0.03973443f, 0.10303556f, 0.25917751f, 0.12187952f, -0.10399296f, 0.06930616f, 
    -0.02594598f, -0.01395250f, -0.03830839f, 0.03397528f, 0.02196407f, 0.03752098f, 0.04572823f, -0.05450460f, 
    -0.36104664f, -0.03214175f, -0.17043139f, -0.07666379f, 0.08265378f, -0.21433930f, 0.09603790f, -0.05109562f, 
    -0.05001550f, -0.01231165f, 0.09009257f, 0.10978661f, 0.73257357f, -0.60497546f, 0.24538198f, -0.17203957f, 
    0.06628263f, 0.08951206f, -0.02552288f, -0.05156924f, -0.00548891f, -0.12939145f, -0.01293463f, 0.05624596f, 
    -0.40677556f, 0.20496465f, 0.05566233f, -0.22286563f, 0.02390098f, -0.12843394f, -0.01269290f, 0.04575825f, 
    -0.01364354f, 0.05314634f, -0.09294462f, 0.17172417f, 0.37900740f, 0.15518041f, -0.12579332f, 0.01832821f, 
    -0.13611959f, -0.10757471f, -0.00971775f, 0.07357448f, 0.03543727f, -0.12197877f, -0.19514963f, -0.09254258f, 
    0.21415132f, -0.05207064f, 0.32240933f, -0.09860814f, 0.15874393f, 0.01801578f, -0.01147828f, -0.06312168f, 
    0.05492976f, 0.26500449f, -0.07212684f, -0.00202565f, 0.30779257f, 0.09876788f, -0.10910176f, -0.02485507f, 
    0.20693932f, 0.00731965f, 0.00952253f, 0.07575161f, 0.05243894f, 0.11574727f, 0.11087969f, 0.04221896f, 
    0.43335280f, -0.06189169f, -0.15978019f, 0.02397802f, -0.19508269f, -0.04721091f, 0.06917387f, -0.00607744f, 
    -0.03413409f, 0.04096454f, -0.14579970f, -0.06912974f, 0.16907109f, 0.05997329f, -0.13679959f, -0.08790239f, 
    0.10179842f, 0.07228375f, 0.21039809f, -0.09524552f, 0.13684569f, 0.07253575f, -0.03145279f, -0.14191492f, 
    -0.42956209f, -0.50814074f, 0.28034508f, 0.03467525f, -0.02941989f, 0.01167893f, 0.16330329f, -0.00837179f, 
    0.25046846f, 0.25460222f, 0.01963841f, 0.24396707f, 0.22805843f, 0.12047920f, -0.15211742f, 0.02683599f, 
    -0.13429704f, -0.01008192f, 0.02275946f, 0.02364482f, 0.07709797f, -0.14075682f, 0.08410569f, 0.16544876f, 
    0.13583662f, 0.22467488f, 0.12559122f, -0.09272452f, -0.16483773f, 0.22822613f, -0.04165501f, 0.18030705f, 
    -0.08730871f, -0.14246339f, 0.09336010f, -0.00299443f, 0.19298016f, -0.10617097f, 0.01268213f, 0.02442161f, 
    0.01046974f, 0.04907200f, 0.08699781f, 0.13831626f, -0.05207769f, -0.19598907f, -0.26278231f, -0.21042506f, 
    -0.46270010f, -0.36858308f, 0.02810394f, 0.07423602f, 0.06161887f, 0.10521935f, 0.16491318f, -0.15165307f, 
    0.16984098f, -0.07354948f, -0.07466410f, 0.13694832f, -0.27373883f, -0.32502621f, -0.36335418f, -0.13048048f, 
    0.04136499f, 0.04451662f, 0.06892794f, 0.05889649f, 0.21340866f, -0.08944303f, 0.02045016f, 0.25207651f, 
    -0.11433081f, 0.00870792f, -0.06286617f, -0.34436291f, 0.07505695f, 0.03332907f, 0.00892328f, 0.00946235f, 
    -0.03982942f, 0.11114368f, 0.10608714f, -0.04006215f, -0.63624454f, -0.15453666f, -0.20393325f, -0.37273309f, 
    0.12704524f, -0.01690265f, -0.05772751f, 0.04027419f, -0.08026619f, 0.00498581f, -0.01285317f, -0.02694523f, 
    0.01265126f, -0.20314871f, -0.13683578f, -0.08504278f, -0.04859100f, -0.04517736f, -0.02208254f, 0.16258608f, 
    0.05085392f, 0.09126703f, 0.03874886f, 0.13762298f, -0.48256895f, -0.05656735f, -0.25742441f, 0.00227672f, 
    -0.09883805f, 0.11297971f, 0.07133162f, -0.13569310f, 0.03084339f, 0.04061500f, -0.08921149f, 0.10777345f, 
    0.31817710f, 0.19391394f, -0.05860551f, -0.06351098f, -0.02962284f, 0.17942648f, 0.01597290f, 0.05205423f, 
    0.05838837f, -0.03159311f, -0.13958265f, 0.02330102f, -0.08370371f, -0.10032303f, 0.14380686f, -0.06743960f, 
    -0.05379275f, -0.01588463f, 0.06498577f, -0.14190312f, 0.10191895f, 0.21612160f, -0.01807007f, 0.05916099f, 
    0.15167704f, 0.06604829f, -0.06408138f, -0.13512594f, 0.23255958f, 0.16218106f, 0.17864150f, -0.08236669f, 
    -0.01166478f, 0.14872192f, 0.04012595f, 0.04232090f, -0.80116034f, -0.36147061f, -0.04985100f, -0.22140136f, 
    0.06607829f, 0.05241603f, -0.09292074f, 0.03279937f, 0.06945509f, 0.11687918f, 0.06808849f, 0.21203907f, 
    -0.08472021f, 0.06125605f, 0.12723711f, 0.39637133f, 0.03186326f, 0.04296632f, 0.15038353f, -0.00922312f, 
    0.06669354f, 0.14096984f, 0.09567481f, 0.15623657f, -0.31650421f, -0.29928383f, -0.13809229f, -0.04326827f, 
    -0.04933039f, -0.07700491f, -0.03479705f, 0.01280592f, 0.16370744f, -0.05377712f, 0.06671295f, 0.07564364f, 
    -0.36888880f, -0.04495822f, -0.11759817f, -0.22256826f, 0.04304315f, 0.09621979f, -0.01384188f, -0.09369572f, 
    0.01128967f, -0.10431232f, -0.10790977f, 0.13588375f, -0.92282063f, -0.26502725f, 0.16587302f, 0.19681081f, 
    0.13247736f, 0.01528106f, -0.07236455f, 0.01587010f, 0.11698166f, 0.05341373f, -0.00696256f, 0.03104343f, 
    0.20606086f, 0.04675647f, 0.12357023f, -0.10991539f, -0.00513519f, -0.16323234f, -0.02116608f, 0.15320715f, 
    -0.02734658f, 0.04662394f, 0.25759906f, 0.09932227f, -0.02228922f, -0.03890885f, 0.11678934f, 0.05591100f, 
    0.07772186f, -0.07007471f, -0.00503774f, -0.03837708f, 0.10722788f, 0.00860065f, 0.10642775f, 0.10456905f, 
    -0.60543680f, -0.33610639f, -0.07535861f, 0.02190310f, 0.11994015f, -0.09259598f, 0.02422913f, 0.05046348f, 
    -0.00829630f, -0.00278862f, 0.13478935f, -0.02772161f, -0.73871934f, -0.68796891f, -0.04503220f, -0.05521915f, 
    0.08274291f, 0.04006451f, 0.04043047f, 0.10643735f, 0.15864496f, 0.00987205f, -0.07626993f, 0.23857412f, 
    0.30282593f, 0.11020051f, -0.14875206f, -0.04734601f, -0.21537553f, -0.06688389f, -0.02574905f, -0.01048193f, 
    0.06370794f, -0.07476275f, -0.05644939f, -0.19745126f, -0.18900810f, -0.15133756f, 0.05903459f, 0.11914434f, 
    0.03014726f, 0.07124432f, 0.04518526f, -0.17283982f, 0.05015974f, -0.29381874f, -0.09862401f, -0.09540619f, 
    -0.28617358f, -0.24609073f, -0.23872526f, 0.08127623f, -0.08938055f, 0.01666055f, -0.21068501f, 0.13159545f, 
    -0.17952320f, 0.04188856f, 0.03907236f, -0.19201361f, -0.52552813f, 0.11576027f, -0.35290134f, -0.04001639f, 
    0.09335080f, -0.06339093f, -0.11586205f, -0.18262623f, 0.08978362f, -0.00112425f, 0.09569286f, -0.25144261f, 
    0.41602379f, -0.27706543f, -0.18340318f, -0.08336823f, -0.02011426f, 0.07544533f, -0.05005845f, -0.02112295f, 
    0.04011640f, -0.10040466f, 0.08732928f, -0.08742808f, 0.16601732f, -0.12971905f, -0.01871913f, 0.10548299f, 
    0.01539130f, -0.01109878f, 0.04975307f, -0.03128989f, -0.04654795f, -0.08328311f, 0.05703447f, -0.05543517f, 
    -0.06527247f, 0.25672650f, 0.06592794f, 0.13944609f, 0.09166768f, 0.00535506f, -0.00591512f, -0.15011500f, 
    -0.10280162f, 0.03020961f, 0.11807104f, -0.01452515f, 0.53555393f, -0.14212652f, -0.28438118f, 0.13263035f, 
    -0.01702528f, -0.10599028f, -0.05070360f, -0.11974159f, -0.08828509f, -0.05068433f, -0.10257637f, -0.17666253f, 
    -0.24592981f, 0.01969320f, 0.08272877f, 0.02027222f, 0.10167308f, -0.05685116f, 0.12866251f, 0.00990664f, 
    0.02815856f, 0.05112199f, 0.23959924f, -0.07483301f, -0.13367589f, 0.21803810f, 0.04836506f, 0.06713559f, 
    -0.06791753f, -0.00097391f, -0.03449582f, -0.09205285f, 0.06297425f, 0.04820118f, 0.05905072f, -0.22177003f, 
    -0.26682970f, -0.06012973f, 0.08424521f, -0.12504800f, 0.13612230f, 0.05979018f, -0.21924703f, 0.15436295f, 
    -0.16096233f, -0.02349937f, 0.04338123f, 0.12389353f, -0.41047636f, -0.24398424f, 0.03606370f, -0.20668653f, 
    0.01718337f, 0.02130117f, 0.05003190f, -0.00749459f, 0.07299913f, -0.07733975f, -0.24512827f, -0.00377664f, 
    -0.17863709f, 0.18151851f, -0.04468488f, 0.00812411f, 0.19351457f, -0.00803042f, 0.10796473f, -0.16101284f, 
    -0.10411192f, 0.06593618f, -0.05811741f, -0.22359782f, 0.15040322f, 0.13578765f, -0.48084432f, 0.00811069f, 
    0.11482463f, -0.33589846f, 0.06208698f, -0.06083163f, 0.27542269f, 0.17307904f, 0.14220692f, 0.21615373f, 
    0.13025691f, -0.22432816f, 0.19915864f, 0.14639862f, 0.04324378f, 0.04730840f, 0.01106607f, -0.02004260f, 
    0.04209637f, 0.12340739f, 0.03666728f, 0.07431152f, -0.21357226f, -0.42670646f, -0.30683267f, 0.00127917f, 
    0.15540300f, 0.08286082f, 0.02900290f, -0.00634858f, -0.06736077f, 0.01351994f, -0.10388831f, 0.16319931f, 
    0.52848077f, 0.11233882f, -0.53666192f, 0.19697945f, 0.04817716f, 0.05709065f, -0.06553979f, -0.16268344f, 
    0.08959321f, 0.10962445f, 0.02244921f, -0.04559348f, 0.01604148f, -0.34292531f, -0.15999843f, -0.31815675f, 
    0.02417662f, -0.16753677f, -0.01581955f, -0.06255833f, 0.07484648f, -0.05215304f, -0.12874651f, -0.06366962f, 
    -0.10578313f, 0.04153276f, 0.15274237f, 0.01285097f, 0.17279147f, 0.01916364f, -0.03986813f, 0.01813912f, 
    -0.19660884f, -0.07299439f, -0.03086201f, -0.04348496f, 0.27469566f, 0.14674495f, -0.11157879f, 0.20685467f, 
    -0.11245731f, -0.10649110f, 0.07839609f, 0.08137418f, -0.03259510f, -0.01279273f, 0.15408492f, 0.05661006f, 
    -0.18551923f, 0.01350013f, -0.23518316f, -0.08298132f, -0.24756880f, -0.02522324f, 0.18637419f, 0.19100070f, 
    -0.02526220f, -0.02135077f, -0.06333268f, -0.02591002f, 0.07081736f, -0.20934202f, 0.28965271f, -0.20210640f, 
    0.04241874f, -0.07090088f, -0.06233148f, 0.02968957f, 0.15292647f, -0.34691420f, 0.05820591f, 0.02649643f, 
    0.02775205f, -0.24761595f, -0.17071609f, 0.25234145f, -0.01999528f, 0.21848281f, 0.07913145f, -0.18464759f, 
    0.20236185f, 0.05000928f, -0.16880243f, 0.02321548f, 0.33739862f, 0.09545811f, -0.27805829f, 0.05256631f, 
    -0.05777323f, -0.13437511f, 0.03869654f, -0.05087889f, -0.12980036f, -0.10688817f, -0.10456958f, -0.00410685f, 
    -0.07962465f, -0.16898538f, 0.08814923f, 0.20510685f, 0.22153428f, 0.00855915f, -0.15952247f, -0.08428914f, 
    -0.09799609f, -0.01087438f, 0.04074530f, -0.08831529f, -0.13088770f, -0.30316830f, -0.14722103f, -0.06700207f, 
    -0.00697926f, -0.05810034f, -0.10594324f, 0.00770266f, -0.02831660f, -0.06106466f, -0.09209616f, 0.13643931f, 
    0.50945067f, -0.24129392f, -0.19012840f, -0.05627478f, -0.03151621f, 0.01395259f, 0.13388370f, -0.02735222f, 
    0.00130605f, 0.07028700f, 0.20154808f, 0.00173227f, 0.00677006f, 0.52007741f, -0.15190087f, 0.06598579f, 
    0.20386513f, 0.06720112f, -0.03838915f, 0.07135178f, 0.14141993f, 0.03294544f, -0.02827466f, 0.06281878f, 
    0.25615957f, -0.29086661f, -0.20462662f, 0.25734749f, 0.11999187f, -0.13172482f, 0.13047557f, 0.14486490f, 
    0.00512262f, -0.08502799f, 0.00925381f, 0.03739471f, 0.13105358f, -0.02022354f, -0.10089219f, -0.03490447f, 
    -0.00176978f, -0.17500830f, -0.00019531f, -0.10323629f, -0.20589273f, -0.02850724f, -0.25223371f, -0.10036357f, 
    0.60102564f, -0.30086526f, -0.22228803f, 0.11828984f, 0.16919582f, -0.06080502f, -0.10202143f, -0.01553108f, 
    0.14128725f, 0.08184100f, -0.05373083f, 0.06427281f, -0.04844600f, 0.39104626f, -0.21815224f, -0.26063567f, 
    0.10352103f, 0.01423362f, 0.02006961f, 0.21376014f, 0.04691519f, -0.03935621f, 0.02737172f, 0.06299814f, 
    -0.16012239f, -0.10285764f, -0.05522064f, -0.03111134f, -0.16053426f, -0.01808597f, 0.02462964f, 0.26436749f, 
    -0.10252167f, 0.04642286f, -0.05214795f, -0.16557792f, -0.20980442f, -0.01358387f, -0.05239458f, -0.12304217f, 
    0.01352483f, -0.02268261f, 0.05600595f, 0.15372722f, 0.05390169f, 0.06042762f, 0.14029527f, -0.03774480f, 
    -0.57126921f, 0.20097178f, -0.20725374f, -0.22464523f, 0.24622779f, -0.04931041f, 0.06211876f, -0.00255730f, 
    0.02026890f, 0.02353439f, -0.11782789f, 0.02517924f, -0.40671787f, -0.06920557f, -0.04772310f, 0.16185029f, 
    -0.02622303f, -0.00341048f, -0.18091482f, 0.18937691f, -0.14938430f, 0.03694665f, 0.02801707f, 0.04668295f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.04780481f, 0.03507916f, -0.02628230f, 0.04352031f, 0.04945999f, 0.02051757f, 0.00037563f, -0.05246740f, 
    -0.01448620f, -0.03180318f, 0.10599944f, 0.04749129f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
