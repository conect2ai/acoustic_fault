#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.13903341f, -0.60775977f, -0.23145701f, -0.47304109f, -0.63597393f, -0.09558282f, -0.47228149f, 0.24719602f, 
    0.14105289f, 0.74332327f, 0.57453793f, 0.45141533f, 0.11757714f, -0.24597302f, 0.05317197f, -0.39880934f, 
    0.05237315f, -0.27563956f, 0.23715538f, -0.13352694f, -0.21317190f, -0.25971001f, -0.42497626f, -0.55645490f, 
    0.44302326f, -0.07420656f, -0.03410871f, -0.13639034f, -0.63856632f, -0.51791501f, 0.16254260f, 0.64204097f, 
    0.86139178f, -0.01565364f, 0.01980382f, 0.38551217f, 0.46230039f, 0.56145424f, 0.68530124f, 0.13243236f, 
    0.33022761f, -0.14730750f, 0.18972163f, 0.27716714f, -0.01160634f, -0.70547879f, 0.51307625f, -0.02841869f, 
    0.20418830f, 0.53764671f, -0.10409602f, -0.28771678f, -0.47790861f, -0.29133984f, 0.14338715f, 0.45360959f, 
    0.37265462f, 0.51479357f, 0.61827332f, 0.04013914f, -0.16464342f, 0.38850299f, -0.06191031f, 0.11991875f, 
    0.52226055f, -0.80269575f, -0.26834995f, -0.62725604f, -0.23595385f, 0.23297063f, -0.16596289f, 0.49933514f, 
    -0.42796978f, 0.99167252f, -0.36995089f, 0.61560279f, -0.28115994f, -0.55811381f, 0.21604367f, -0.04192980f, 
    -0.42688721f, 0.51974803f, 0.04345166f, 0.64177078f, 0.59795570f, 0.39511767f, -0.05811873f, -0.22775854f, 
    -0.19960283f, 0.04233100f, -0.20505685f, -0.36474574f, -0.07318570f, -0.40425897f, 0.68167204f, -0.39062992f, 
    -0.01124624f, -0.21952096f, -0.57361788f, 0.63328195f, 0.00372914f, -0.35569352f, 0.54203224f, 0.34116119f, 
    0.08498974f, -0.10501388f, 0.25769216f, -0.38759339f, -0.19470666f, 0.50758773f, 0.45455846f, -0.77125859f, 
    0.11893206f, 0.13382645f, 0.28471836f, 0.36965507f, -0.31635365f, 0.35289660f, 0.46677443f, 0.79212159f, 
    -0.56197375f, -0.51813090f, -0.55690050f, 0.06003613f, -0.09513196f, -0.00983290f, 0.45124227f, 0.45850101f, 
    0.08261946f, -0.45597234f, -0.50920314f, 0.56748194f, 0.01964013f, 0.22044554f, 0.27285272f, 0.29023522f, 
    -0.26334465f, 0.69639927f, 0.48824069f, -0.87252599f, 0.53267252f, 0.29545560f, -0.23105815f, -0.09009204f, 
    0.10065387f, -0.21431533f, -0.46757582f, 0.18785909f, -0.54485333f, 0.21862774f, -0.36792484f, -0.38688159f, 
    -0.17712770f, -0.17037812f, -0.51224500f, -0.53733265f, -0.08105125f, 0.83300036f, -0.53023964f, 0.01705384f, 
    0.36920261f, -0.16037716f, -0.48902211f, -0.75331515f, -0.62438154f, 0.31462321f, -0.04411266f, -0.40739506f, 
    0.28211871f, -0.28655803f, 0.21294202f, -0.64709115f, -0.70933080f, -0.55732578f, -0.34660137f, -0.37115261f, 
    0.13612096f, 0.00898055f, 0.41513163f, 0.32420579f, -0.45636731f, -0.72111470f, -0.37192827f, -0.49366513f, 
    -0.24871315f, 0.75220948f, 0.01377346f, -0.24264079f, -0.12791367f, -0.17071508f, -0.69199067f, 0.03670260f, 
    0.48693001f, 0.49201155f, 0.59143442f, -0.32285097f, -0.16336176f, -0.30371699f, 0.60427535f, 0.64113104f, 
    0.20744522f, -0.42705816f, 0.38607037f, -0.40164778f, -0.32353640f, 0.20837095f, 0.26682898f, 0.20877390f, 
    -0.29904684f, -0.09473763f, -0.65850288f, -0.11384299f, -0.39248917f, 0.33730224f, 0.35825956f, 0.08075660f, 
    0.37428394f, -0.40176624f, -0.33229065f, -0.64124840f, 0.43984076f, -0.01106101f, -0.07898528f, 0.32122269f, 
    0.46785882f, 0.73936266f, -0.59932745f, -0.39445037f, -0.33858231f, -0.38109934f, -0.30063084f, -0.41088292f, 
    -0.44043353f, 0.08580512f, -0.10165328f, 0.52365106f, 0.79123724f, 0.28462592f, 0.13524601f, 0.34081364f, 
    0.25675222f, 0.25046432f, 0.28427336f, -0.51791829f, 0.15076125f, -0.36720401f, 0.40116861f, 0.67612296f, 
    0.32286188f, 0.31724885f, 0.29833826f, 0.11652426f, 0.50951272f, 0.55628073f, 0.48236191f, -0.10568394f, 
    0.08405029f, 0.43819758f, -0.21165641f, -0.44413149f, -0.35407099f, 0.52409410f, -0.32414842f, -0.73294884f, 
    -0.40463904f, -0.22585544f, -0.73403352f, 0.00167372f, 0.27826476f, -0.15518661f, 0.60998154f, 0.48768124f, 
    0.12666456f, 0.12004916f, -0.41250846f, -0.37437692f, 0.41033062f, -0.07530139f, 0.47382772f, 0.64215910f, 
    0.70192695f, -0.41715145f, 0.26035479f, 0.27291086f, -0.17668658f, 0.05191851f, -0.10663280f, -0.07709248f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.01192875f, -0.00716301f, 0.16112483f, -0.24869855f, 0.23692851f, -0.00766925f, -0.26290613f, -0.25722578f, 
    0.01561666f, 0.19040436f, -0.20018785f, -0.25139326f, 0.12826593f, -0.08741087f, -0.08143406f, -0.13766894f, 
    -0.26121438f, -0.04799846f, -0.07372992f, 0.01159321f, -0.11352672f, -0.03820475f, -0.04770900f, 0.16451585f, 
    -0.09324632f, -0.09841285f, 0.08712163f, -0.09982011f, 0.26548675f, -0.17583753f, -0.28276560f, 0.29669625f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.25053251f, 0.08877011f, 0.03238165f, -0.18391541f, 0.07651344f, -0.00583248f, -0.03757625f, 0.15173021f, 
    0.05224892f, 0.15140446f, 0.06201968f, 0.03121360f, -0.07461328f, -0.15962239f, 0.06463411f, 0.11462020f, 
    -0.02584452f, -0.02312493f, 0.13873662f, 0.11896500f, 0.02121318f, -0.09403735f, -0.09128347f, 0.11912451f, 
    0.13848925f, -0.08281036f, 0.04729539f, 0.20992087f, -0.03587300f, 0.11055231f, 0.00436730f, 0.30508715f, 
    -0.07196956f, 0.16708960f, -0.04324209f, -0.04525579f, -0.07915469f, -0.08262280f, -0.11283799f, 0.05275593f, 
    -0.01503784f, 0.10373815f, 0.16289365f, -0.00943555f, 0.03304166f, -0.30169833f, -0.03122308f, -0.00294412f, 
    0.08537370f, 0.21684602f, -0.12674893f, -0.03962315f, 0.07792410f, 0.18358545f, 0.08930337f, -0.04134288f, 
    -0.14714013f, 0.11773424f, -0.04492776f, 0.00245573f, 0.27452728f, -0.04403993f, -0.01834050f, -0.02053735f, 
    0.20611604f, 0.11236659f, -0.01774671f, 0.13568248f, -0.03288217f, -0.03743155f, 0.11863808f, -0.09233936f, 
    -0.62261474f, 0.21133839f, -0.06060687f, 0.17202993f, 0.05051048f, -0.05165005f, -0.12202268f, 0.06506370f, 
    -0.05977929f, 0.02639507f, -0.18044229f, -0.21045999f, 0.18993528f, 0.11799210f, 0.01701233f, -0.00313463f, 
    0.03342202f, -0.01126402f, 0.23469149f, 0.21833572f, 0.16428700f, 0.27612817f, 0.18082906f, -0.14854664f, 
    -0.03114153f, -0.15230232f, -0.19945624f, 0.10684942f, -0.09701334f, -0.11769792f, 0.28175345f, 0.11456757f, 
    0.02814885f, -0.06991828f, 0.02459133f, -0.06410263f, 0.02810054f, -0.16510271f, -0.08055221f, 0.01448266f, 
    0.00905206f, -0.02985905f, 0.05424421f, 0.11037687f, 0.28848431f, -0.17619523f, 0.07194635f, -0.18484008f, 
    -0.04813627f, -0.17593305f, 0.04488338f, -0.08536675f, -0.05190371f, 0.05089885f, 0.00641625f, -0.06917087f, 
    0.00287894f, 0.05732721f, -0.09044991f, -0.09992892f, -0.08003590f, 0.00686659f, -0.09831054f, -0.20141855f, 
    0.06305466f, -0.35101652f, 0.01680064f, 0.13931350f, -0.06578643f, -0.00762419f, 0.30176690f, 0.02522207f, 
    0.44070840f, 0.20824212f, -0.01864904f, 0.13975286f, 0.07675176f, 0.08497856f, -0.03963197f, -0.03769858f, 
    -0.07408739f, -0.05986274f, 0.14140362f, 0.12682006f, 0.14008547f, 0.00245459f, 0.02145990f, 0.14835058f, 
    -0.05567638f, -0.19194715f, 0.43209326f, 0.22881179f, 0.23315069f, -0.04640092f, 0.11081403f, 0.19153023f, 
    0.06605404f, -0.02134511f, -0.02839405f, 0.25100088f, 0.13818474f, 0.20819952f, -0.10556664f, 0.14665848f, 
    0.21796601f, 0.15414572f, 0.09174981f, 0.04703741f, 0.34513053f, 0.02262454f, -0.00873144f, 0.01232603f, 
    0.04062241f, 0.12001684f, 0.01896261f, 0.00745331f, 0.06204657f, 0.14803624f, 0.01901348f, 0.02255460f, 
    0.22046730f, 0.15981397f, -0.04910113f, -0.06555884f, -0.03164727f, 0.09550746f, -0.02327239f, -0.12409838f, 
    0.16851436f, -0.04106495f, 0.06813997f, 0.07004507f, 0.14640999f, 0.10975283f, -0.06039630f, 0.12861955f, 
    0.06363120f, 0.00125033f, 0.01366473f, -0.03080266f, -0.12748814f, -0.11759988f, -0.04128013f, 0.03199953f, 
    0.00141576f, -0.07512948f, 0.21024886f, 0.09353051f, 0.00538574f, -0.08879276f, -0.23680675f, -0.10049957f, 
    -0.05726664f, 0.31791523f, -0.04918162f, -0.03856041f, -0.24209450f, -0.11284898f, 0.05842822f, -0.08498462f, 
    0.11244985f, -0.02343598f, -0.03724218f, -0.00297146f, -0.11853870f, 0.15602294f, -0.00083487f, -0.14109188f, 
    0.05659986f, 0.04215034f, 0.00924382f, 0.08362544f, -0.18852036f, 0.02473219f, -0.01205076f, 0.14410384f, 
    0.00093802f, 0.15734890f, -0.02533996f, 0.06261445f, -0.02663318f, 0.05989386f, -0.01690764f, 0.10532613f, 
    -0.07033574f, 0.02083813f, 0.17584576f, 0.04233610f, 0.14973642f, 0.14837901f, -0.06447444f, -0.02058538f, 
    -0.01597506f, -0.07316924f, 0.05902718f, 0.00021114f, 0.05239234f, 0.02265926f, -0.16174948f, 0.21655478f, 
    -0.05236153f, -0.03056963f, -0.12330151f, -0.14042109f, -0.07284879f, 0.03603779f, 0.03659388f, -0.02533636f, 
    0.16962530f, 0.12587358f, 0.24942625f, 0.12097529f, -0.03296964f, 0.10153858f, 0.09434207f, -0.06719361f, 
    -0.06741596f, 0.04815345f, -0.08387478f, 0.14648399f, 0.14164113f, 0.11072404f, -0.09789654f, -0.15233400f, 
    -0.02928928f, -0.02121558f, 0.08606777f, -0.10789356f, -0.06739110f, -0.01065916f, -0.02498323f, -0.10645089f, 
    0.02915412f, 0.00889628f, 0.08150945f, -0.06040848f, -0.18525377f, 0.13270335f, 0.04956127f, 0.03401497f, 
    0.08153015f, -0.00607490f, -0.03030666f, -0.08623701f, -0.03969924f, -0.07644216f, -0.05468267f, -0.00764990f, 
    0.04376311f, -0.02071383f, -0.03671655f, 0.03345431f, 0.09442317f, 0.05389537f, 0.09492532f, -0.03762678f, 
    0.00758686f, 0.00232695f, -0.01887957f, 0.05062410f, -0.00944374f, -0.29094708f, -0.05954855f, 0.00801724f, 
    0.15519083f, 0.13095470f, -0.22947121f, 0.00757308f, -0.03531623f, -0.09565295f, -0.02879117f, 0.21672121f, 
    0.18720157f, -0.10398822f, -0.02727557f, -0.06409477f, -0.16281545f, 0.06836504f, -0.00376453f, -0.17843664f, 
    -0.11227708f, 0.03778493f, 0.01026439f, 0.14484432f, -0.01596008f, 0.05732126f, -0.08926401f, 0.08687153f, 
    -0.22524375f, -0.34991604f, -0.14324848f, 0.10051491f, 0.11505378f, -0.01583963f, -0.10271724f, -0.14793806f, 
    -0.00889519f, -0.07243319f, 0.00087806f, 0.14739396f, -0.01291225f, -0.06889367f, -0.06090572f, 0.04867812f, 
    0.18363184f, -0.04134326f, 0.13869300f, -0.16631694f, -0.12793688f, 0.10889192f, 0.17902991f, 0.15156770f, 
    0.11181010f, 0.18416329f, -0.25848627f, 0.03133510f, -0.21331730f, -0.00826764f, -0.20699421f, -0.05767147f, 
    -0.05584107f, -0.04170534f, 0.00177027f, 0.10721713f, 0.06185758f, 0.11677739f, -0.29730314f, 0.09544381f, 
    -0.17794222f, 0.00252797f, 0.08616486f, -0.01263965f, 0.09982143f, 0.12918791f, 0.08515597f, -0.19921371f, 
    -0.04328356f, -0.03948214f, 0.11900509f, -0.06796264f, -0.06195559f, 0.06455774f, 0.09661243f, 0.11621249f, 
    -0.14093620f, 0.12750316f, -0.18649171f, 0.07545388f, 0.07293031f, -0.13093632f, 0.31244946f, -0.10106938f, 
    0.28221402f, 0.20032857f, -0.10376397f, -0.01049238f, 0.00183914f, -0.04995567f, -0.02284416f, -0.01284428f, 
    -0.11079006f, 0.02704146f, -0.19215417f, 0.02626965f, -0.10894742f, 0.12584938f, -0.10534752f, 0.02712559f, 
    0.10903871f, 0.02422435f, -0.30870783f, -0.16658497f, -0.03565866f, 0.16651869f, 0.28356707f, -0.03077229f, 
    -0.04234733f, -0.01246142f, 0.02359483f, 0.13216144f, -0.15227120f, -0.00789813f, 0.11764035f, 0.06043107f, 
    0.08551971f, 0.08470873f, 0.03375065f, -0.01736716f, 0.08490196f, -0.03006169f, -0.02990048f, -0.00930867f, 
    0.08619797f, 0.03462522f, 0.01762510f, 0.04994231f, 0.05668617f, 0.00734670f, 0.07955562f, 0.20027637f, 
    -0.20873152f, 0.13599056f, -0.02841337f, -0.00736738f, 0.06321025f, 0.17353377f, 0.02561542f, -0.11216900f, 
    0.05502437f, -0.07210966f, -0.21509461f, -0.00976990f, -0.00531987f, -0.01499887f, 0.19728351f, 0.07965116f, 
    -0.07822040f, -0.05711676f, 0.05752477f, 0.09798447f, -0.12498821f, 0.05336018f, 0.07320846f, 0.22764006f, 
    0.04382199f, -0.10405180f, 0.16082700f, 0.02925101f, -0.07944444f, -0.01731435f, 0.07016647f, -0.04890436f, 
    0.01691482f, 0.03032340f, 0.08593932f, -0.01484955f, 0.05046640f, -0.03960020f, 0.00330493f, -0.04712658f, 
    0.05158146f, -0.23575912f, -0.10351897f, 0.00067781f, 0.23353475f, 0.08468232f, 0.09656071f, -0.04227916f, 
    0.12883683f, -0.23907748f, 0.05026295f, 0.06517572f, 0.01902732f, -0.02043993f, 0.01856109f, -0.15865782f, 
    0.05844789f, 0.12057718f, -0.01725816f, -0.11374214f, -0.03032174f, 0.03529027f, -0.00112942f, -0.01136631f, 
    -0.02680214f, -0.05808102f, 0.05182103f, -0.00526736f, 0.01090558f, 0.05065415f, 0.03384413f, -0.03321349f, 
    -0.00788476f, 0.07870337f, -0.02847404f, 0.13607654f, -0.08344305f, -0.04789270f, 0.17827812f, -0.04400943f, 
    0.04725227f, 0.13011537f, 0.01164020f, 0.07549384f, -0.01925378f, -0.12995809f, -0.14831348f, -0.11970257f, 
    -0.06204949f, 0.00615635f, 0.01790846f, 0.00039711f, 0.01465700f, -0.11320978f, 0.09119874f, 0.00463146f, 
    -0.10786958f, 0.19225653f, -0.04120499f, -0.07458253f, -0.05975531f, -0.13366306f, 0.03667093f, 0.10555746f, 
    -0.06956593f, 0.07326602f, -0.18912648f, -0.02913707f, 0.16964369f, 0.24005336f, -0.04972056f, -0.04444089f, 
    0.01704427f, 0.13930586f, 0.08855299f, 0.19239743f, -0.03058979f, -0.16194904f, -0.04773880f, 0.03806341f, 
    0.01209826f, 0.13000073f, 0.10699407f, -0.00614367f, -0.08227441f, -0.06335951f, 0.16777605f, 0.04725423f, 
    0.07980601f, -0.04766262f, -0.00774476f, -0.13297306f, -0.26384604f, -0.22291884f, 0.29920566f, 0.01281564f, 
    0.08856001f, -0.00481563f, -0.09109782f, -0.13588655f, 0.18421403f, 0.15335332f, 0.08014040f, -0.07140943f, 
    -0.08201542f, -0.07376690f, 0.04062643f, 0.03188051f, -0.08732827f, -0.00838345f, -0.36023664f, -0.15996668f, 
    0.02091738f, 0.04588737f, 0.02703824f, -0.08188020f, 0.02738940f, 0.00415322f, 0.08299607f, 0.02296201f, 
    -0.09654327f, -0.16366318f, 0.13202569f, -0.18844694f, -0.09619930f, -0.01075417f, -0.07862931f, -0.05009616f, 
    -0.08828922f, 0.14743331f, 0.07214136f, 0.09668250f, -0.02017071f, -0.11912482f, -0.23494254f, 0.04365484f, 
    -0.21575645f, -0.17354317f, 0.03258458f, 0.00484082f, 0.04276518f, -0.02235281f, -0.00161864f, -0.05008446f, 
    0.15045488f, 0.06325331f, 0.00094765f, -0.02226607f, -0.00476575f, 0.09098935f, 0.05085356f, 0.02912183f, 
    0.04707218f, 0.01165494f, 0.01194334f, -0.24472615f, -0.22391184f, -0.10791972f, 0.23007189f, 0.09568691f, 
    0.24173935f, -0.08598688f, -0.08238641f, -0.24032189f, -0.09337629f, -0.07912952f, -0.00846016f, -0.00760219f, 
    0.05468791f, -0.03094164f, -0.07265147f, 0.13736400f, -0.12493134f, -0.14130937f, -0.01825606f, 0.00114050f, 
    0.04015121f, 0.01128792f, 0.00510217f, -0.02305640f, 0.03706308f, 0.12663928f, 0.18528384f, 0.11348773f, 
    -0.02521712f, -0.09782542f, 0.03943115f, 0.00339318f, -0.00089493f, 0.05703649f, 0.05279273f, 0.08881079f, 
    0.09071282f, -0.01479197f, 0.06163748f, 0.27271849f, 0.09897747f, 0.06466751f, 0.22412200f, 0.31215239f, 
    0.15408674f, 0.05512297f, -0.01613177f, -0.04135486f, 0.18489254f, 0.05542821f, 0.03631198f, -0.00016509f, 
    -0.07100063f, 0.14179561f, 0.16380133f, -0.13420177f, 0.09381945f, -0.08752193f, -0.09357034f, -0.05626740f, 
    -0.07486481f, -0.15711920f, -0.24953049f, -0.38677019f, 0.11668306f, 0.11092038f, 0.15768819f, 0.05615315f, 
    -0.28075904f, -0.11510504f, -0.24652918f, 0.12549859f, -0.16979261f, -0.00217897f, 0.02427894f, 0.03689411f, 
    0.02161808f, -0.10389696f, -0.11059226f, -0.31055197f, 0.28160402f, -0.20431095f, -0.00607971f, -0.00005496f, 
    -0.10852464f, -0.09316480f, -0.06047004f, -0.13250194f, 0.10961207f, 0.14204898f, -0.13729997f, 0.07474940f, 
    0.03506660f, 0.08438437f, -0.09317458f, 0.08746632f, -0.13242553f, 0.21765435f, 0.05683077f, -0.42416814f, 
    0.15660428f, -0.02609713f, 0.03806641f, 0.04155825f, -0.22766480f, -0.08527038f, 0.30798599f, 0.13726367f, 
    -0.04831508f, 0.02681210f, -0.12728611f, 0.08053619f, -0.02266126f, -0.00135146f, 0.09428476f, 0.09574644f, 
    -0.06018306f, 0.07744980f, 0.02619662f, 0.01375870f, 0.03483641f, 0.01176030f, -0.12704183f, -0.09121734f, 
    -0.08371852f, 0.03285816f, 0.06334022f, -0.14012532f, -0.07111897f, -0.10674819f, -0.01988937f, -0.12726659f, 
    -0.05737622f, 0.12208533f, 0.02107963f, -0.17789237f, -0.00901778f, -0.00491721f, 0.27123690f, -0.18543065f, 
    -0.00863177f, -0.10330164f, 0.13634872f, -0.00110407f, -0.03791786f, -0.06933148f, 0.01172077f, 0.12825575f, 
    0.00987417f, -0.03435449f, -0.04097534f, -0.12711582f, -0.50086296f, 0.11821702f, 0.05376530f, 0.00133353f, 
    -0.23293300f, 0.06744024f, -0.04847432f, -0.06476328f, 0.06977553f, 0.16523916f, 0.15237448f, 0.07233070f, 
    -0.01480248f, 0.00333356f, -0.12059989f, -0.03598483f, 0.00941860f, 0.11343034f, -0.15108338f, -0.11458575f, 
    0.01308738f, 0.15721618f, 0.09799867f, 0.12195046f, -0.15959352f, 0.00992146f, 0.04090782f, 0.12455286f, 
    0.01034490f, 0.13600375f, 0.00938516f, 0.04987621f, -0.05668345f, 0.14991462f, 0.01683839f, -0.03901902f, 
    0.20402531f, 0.21259375f, -0.04826999f, -0.04591812f, -0.00068507f, -0.00543094f, 0.02055558f, 0.04302420f, 
    0.05723806f, -0.12183096f, 0.16391820f, -0.03659995f, -0.04948919f, -0.06110067f, -0.04287494f, 0.02322321f, 
    0.11935463f, 0.05534555f, 0.14556669f, 0.15314287f, -0.04699843f, 0.12897162f, 0.09096561f, -0.02996729f, 
    -0.11048726f, -0.20239219f, 0.06208693f, 0.06452169f, 0.14018302f, 0.02115891f, 0.14487088f, -0.03830575f, 
    0.00488704f, -0.02569198f, 0.15270479f, -0.15164433f, 0.15102772f, -0.14785677f, -0.14764941f, -0.07337348f, 
    0.09520792f, 0.10691457f, -0.03949356f, -0.04777563f, 0.02207933f, 0.19777207f, 0.08543505f, 0.20434339f, 
    -0.02616011f, -0.01458852f, -0.05728557f, -0.03892116f, -0.06134917f, 0.63797361f, 0.12832484f, 0.22553368f, 
    0.07650910f, 0.03445993f, -0.02714997f, 0.21704151f, -0.02363272f, 0.12521265f, -0.18911684f, -0.02825806f, 
    0.18065166f, 0.05401953f, 0.03117065f, -0.01107886f, -0.01058280f, -0.08590323f, -0.02026978f, -0.12214475f, 
    0.08872734f, 0.00761770f, -0.05816142f, -0.00611114f, -0.06714166f, -0.05980472f, -0.05438355f, 0.05532027f, 
    0.09232060f, -0.03070421f, 0.09478706f, 0.02920697f, 0.03859474f, -0.01799011f, -0.03300940f, 0.13971864f, 
    -0.05004081f, 0.14732566f, 0.08306105f, 0.02032402f, 0.06176478f, 0.11396490f, 0.02471619f, -0.01751085f, 
    0.04594342f, 0.04010341f, -0.17502697f, 0.14935304f, -0.09128344f, 0.08231517f, -0.07598221f, 0.14210001f, 
    -0.05104458f, -0.08110942f, -0.00494477f, 0.21661134f, -0.03770206f, -0.01305229f, -0.14764486f, -0.05913574f, 
    0.01551289f, -0.04658693f, -0.15147616f, -0.03192901f, -0.11489075f, 0.09173739f, -0.01785763f, 0.01450337f, 
    -0.04044647f, -0.00291178f, 0.00189960f, 0.02949139f, 0.04550686f, 0.00065363f, 0.18956712f, 0.12093288f, 
    -0.06536181f, 0.02824529f, -0.11204167f, -0.10297216f, -0.07071677f, 0.06542051f, 0.02120419f, 0.12547222f, 
    -0.03496473f, -0.07222559f, -0.15443732f, 0.00855156f, -0.06240351f, 0.07135802f, -0.03988076f, -0.27691224f, 
    -0.02048846f, -0.13572359f, 0.09065331f, 0.12912758f, -0.09112161f, 0.07218406f, -0.16764416f, -0.21228625f, 
    0.07907884f, -0.10390759f, 0.06974983f, 0.07002241f, -0.07304421f, -0.24528340f, 0.07840236f, -0.00680618f, 
    0.18830140f, -0.36123815f, 0.11664889f, 0.10073119f, 0.13060009f, 0.00042207f, 0.09950706f, -0.15397993f, 
    -0.08346864f, -0.05830088f, -0.30349767f, 0.02775256f, -0.02535104f, 0.06404620f, 0.05556897f, -0.09183092f, 
    -0.09020085f, -0.08574082f, 0.03215904f, -0.30950296f, -0.06285929f, -0.15601729f, 0.06361361f, 0.13314570f, 
    -0.02338947f, 0.03127728f, 0.05713652f, 0.09597183f, -0.30489293f, 0.08415320f, -0.14667237f, 0.00745698f, 
    0.10893714f, -0.04065534f, 0.09462905f, -0.14736661f, 0.04524754f, -0.01873773f, 0.20064007f, -0.09425089f, 
    0.00668960f, -0.10723329f, 0.11186124f, 0.14399996f, 0.01146452f, -0.07939152f, -0.07664554f, 0.11348242f, 
    -0.00051127f, -0.02358464f, 0.07902792f, 0.11519275f, -0.12282816f, 0.02534781f, 0.03197476f, -0.08782514f, 
    0.08115168f, 0.04158095f, -0.10995527f, -0.01513894f, 0.05708212f, 0.01625160f, 0.02945040f, 0.09513946f, 
    -0.27359506f, 0.08470744f, -0.11191217f, -0.06488954f, -0.05917439f, 0.03544935f, -0.06743741f, 0.02258360f, 
    0.08868438f, 0.08491583f, -0.21046074f, 0.10768572f, -0.01379432f, 0.02281380f, -0.12663791f, -0.08231024f, 
    -0.03412621f, 0.02999963f, -0.28278276f, 0.01975944f, 0.17066413f, 0.10826001f, 0.03848122f, -0.08904915f, 
    -0.06582870f, -0.14120637f, -0.13257299f, 0.25606596f, 0.13568449f, 0.03258555f, 0.12548274f, 0.07491469f, 
    -0.05226550f, -0.06609726f, -0.07351325f, 0.11027101f, -0.00387647f, 0.10485704f, 0.08609565f, -0.15069710f, 
    -0.00285322f, -0.01588694f, 0.03924311f, 0.15554936f, -0.14468117f, -0.05093196f, -0.08003141f, 0.22290134f, 
    -0.10195076f, 0.00168996f, -0.04710076f, 0.02350444f, 0.02306859f, 0.15361713f, -0.08091375f, 0.14469935f, 
    0.05372896f, -0.18796913f, -0.05708325f, -0.09963005f, -0.04192981f, -0.08669802f, 0.09715441f, -0.08186857f, 
    -0.00611182f, -0.00503744f, -0.15658900f, -0.01463298f, 0.05314063f, 0.00149136f, -0.05210373f, 0.00476829f, 
    0.10303137f, -0.09928217f, 0.02362150f, -0.06835935f, -0.17445672f, -0.21086530f, -0.19772194f, 0.09986129f, 
    0.05710888f, -0.06856585f, -0.01474459f, -0.04132967f, -0.10309456f, -0.09822468f, 0.13696171f, 0.05856055f, 
    -0.15319408f, 0.02045660f, -0.14756462f, 0.04813110f, -0.06275847f, 0.06900664f, -0.09476735f, -0.03477051f, 
    -0.15479422f, 0.00078372f, 0.01654653f, 0.25127783f, -0.07964391f, -0.04401095f, -0.02724597f, 0.07202942f, 
    0.03122876f, 0.05734595f, 0.05762179f, 0.02193162f, -0.04784172f, 0.02155179f, 0.10017244f, 0.00597478f, 
    0.00723919f, 0.13743553f, 0.06603059f, -0.07027728f, 0.04170377f, -0.00755192f, 0.07449496f, 0.00582773f, 
    -0.00578628f, 0.04516572f, 0.00664784f, -0.06406223f, 0.01730793f, -0.01691626f, -0.20936391f, 0.00578076f, 
    -0.08973186f, -0.00125401f, -0.01847927f, -0.01394735f, 0.02856105f, 0.07182696f, 0.16730370f, -0.05633745f, 
    0.02076756f, 0.00091851f, -0.00216977f, 0.13748905f, -0.14329819f, -0.07191539f, 0.10410483f, 0.11083662f, 
    -0.15707263f, -0.01459068f, -0.18191667f, 0.16422710f, -0.13224241f, -0.04804352f, 0.01200837f, 0.10610302f, 
    0.01009732f, 0.08764286f, -0.09628124f, 0.00595689f, 0.11650168f, -0.10257065f, 0.05720330f, 0.05190651f, 
    0.09850676f, 0.13464989f, 0.04909657f, 0.12368454f, 0.16864195f, 0.11908610f, -0.07374492f, 0.02252714f, 
    0.06664555f, -0.10446285f, -0.02850373f, -0.13895838f, -0.07668517f, -0.15949532f, 0.11277156f, 0.02748629f, 
    0.09543294f, -0.00026157f, 0.04848081f, 0.01047691f, -0.04113603f, 0.10159370f, -0.03402310f, -0.03903778f, 
    0.07461090f, 0.01367000f, -0.00685807f, -0.02487350f, -0.10675038f, -0.02953020f, -0.20291060f, -0.04814781f, 
    -0.00422500f, -0.03389335f, 0.09126503f, -0.03728136f, -0.02599393f, -0.17596394f, -0.13401231f, -0.14096586f, 
    -0.06026502f, -0.00001059f, 0.08715612f, -0.13816595f, -0.05297443f, 0.06504334f, -0.16241254f, 0.11063221f, 
    -0.19618176f, -0.07860222f, 0.05537253f, 0.04666107f, -0.06784595f, 0.03639534f, -0.00486179f, 0.12499759f, 
    0.03927019f, 0.16012058f, -0.05087860f, -0.01789165f, 0.00825361f, -0.14397049f, 0.12774107f, -0.09703603f, 
    -0.01022221f, 0.09139097f, 0.04340144f, 0.24112214f, 0.03557903f, -0.05549056f, 0.02024163f, 0.08996429f, 
    -0.02754690f, -0.03991200f, 0.06925813f, -0.03298399f, 0.22492673f, -0.04956654f, -0.08083283f, 0.09829552f, 
    0.05050215f, 0.03974518f, 0.01477226f, 0.13207553f, -0.07434991f, 0.08389121f, -0.06053779f, 0.05690077f, 
    -0.08085636f, 0.00693177f, 0.16432552f, -0.01804766f, 0.21814817f, -0.04143354f, 0.02342557f, 0.07755250f, 
    -0.09235504f, -0.12770417f, 0.13360970f, 0.02174410f, 0.16773224f, 0.29716218f, 0.11331812f, 0.09168040f, 
    -0.05395116f, 0.06610332f, 0.02288143f, 0.15608564f, 0.16124119f, -0.06284572f, -0.12078738f, 0.01708411f, 
    0.05010639f, -0.04749094f, 0.11821328f, 0.10775666f, -0.01688208f, 0.00769627f, 0.03831467f, -0.18737803f, 
    -0.10163958f, 0.11955711f, -0.16428423f, -0.00152249f, -0.15476035f, -0.12155904f, -0.06176975f, 0.04830480f, 
    -0.16523039f, 0.03012839f, 0.06107849f, 0.12297691f, 0.00509779f, -0.18389824f, -0.05779098f, -0.14794548f, 
    0.10649502f, 0.02427706f, -0.09393688f, -0.06312530f, 0.05304841f, -0.12026042f, -0.07607269f, -0.09110483f, 
    -0.06168241f, 0.06039703f, 0.01884784f, 0.12090224f, 0.05624225f, 0.06180169f, 0.01482507f, -0.04326040f, 
    0.01334222f, -0.05510621f, -0.02429542f, 0.21047613f, -0.02502553f, -0.04841353f, 0.00117009f, -0.05633989f, 
    0.13248895f, 0.07955664f, 0.01609029f, 0.06340124f, 0.08716954f, -0.08483611f, -0.03861177f, -0.10718685f, 
    0.11863784f, 0.01071772f, 0.05599355f, -0.06613419f, -0.05094381f, -0.15836267f, -0.09992203f, 0.07282481f, 
    -0.09042932f, -0.12904942f, -0.05118378f, -0.17972662f, 0.12033535f, 0.11339617f, -0.17872716f, 0.20100909f, 
    -0.01722052f, 0.01024726f, -0.12974687f, -0.03439780f, -0.06367118f, 0.02793371f, -0.02514621f, 0.05589095f, 
    0.10068230f, -0.01521644f, 0.04076836f, 0.05468057f, -0.00778876f, 0.10123773f, 0.07798032f, 0.05235978f, 
    0.04641111f, 0.12780869f, -0.13927558f, 0.10214468f, 0.00402039f, 0.15033992f, 0.08876567f, 0.08194798f, 
    -0.07571667f, 0.19631636f, 0.10447651f, -0.01326853f, 0.00305597f, 0.09049977f, -0.01100321f, 0.03241447f, 
    -0.00725197f, -0.05604893f, 0.11509367f, 0.00057861f, -0.08776329f, -0.10819007f, -0.00091120f, -0.06933602f, 
    0.08197179f, -0.02605016f, 0.00438281f, 0.05868755f, 0.22420438f, 0.11679671f, -0.01711505f, 0.14382984f, 
    -0.19809793f, -0.06962488f, 0.14840870f, 0.03744709f, 0.18837522f, 0.00705640f, -0.12688288f, -0.08121071f, 
    0.10593301f, -0.03298524f, 0.11356805f, -0.06933444f, -0.02426009f, -0.24233985f, -0.24424371f, -0.23282598f, 
    -0.07340435f, 0.04971320f, 0.08392479f, 0.00434569f, -0.05779547f, -0.05913576f, 0.28772357f, 0.01970346f, 
    -0.04999392f, -0.00848869f, -0.17564346f, 0.06270474f, -0.04055865f, -0.02092680f, -0.06659327f, -0.06789956f, 
    0.22333440f, -0.22582036f, -0.01913276f, -0.03662119f, 0.03925416f, -0.09432120f, 0.20748678f, 0.03728547f, 
    -0.07391454f, -0.17305394f, -0.19776317f, 0.02223674f, -0.02824232f, 0.08755690f, -0.06947771f, -0.06867754f, 
    0.12774763f, -0.14778712f, 0.00160494f, 0.09064709f, -0.08184945f, 0.04125609f, -0.01717532f, 0.08688143f, 
    -0.09928490f, 0.03245985f, -0.27070168f, -0.10199922f, -0.16747123f, -0.04046606f, 0.04570701f, -0.00151628f, 
    0.08577155f, 0.01169192f, 0.10869033f, 0.00726006f, -0.08602274f, 0.05519968f, -0.02076069f, 0.02748702f, 
    -0.16294688f, -0.07728810f, 0.06591813f, -0.02827735f, 0.19449426f, -0.09393242f, 0.01503730f, -0.04686523f, 
    -0.09687638f, -0.10898189f, 0.05694126f, 0.00289061f, 0.02363954f, 0.35325909f, 0.12781526f, -0.10137943f, 
    0.03939896f, 0.05759646f, 0.08547415f, 0.03145205f, -0.18126863f, -0.26763377f, 0.02874267f, 0.12512805f, 
    0.17430095f, 0.19106850f, -0.05501412f, 0.09589524f, 0.01246025f, -0.02146901f, 0.01301844f, 0.13363928f, 
    0.24960649f, 0.09506002f, -0.06416593f, 0.05948793f, -0.13588485f, 0.02868034f, 0.09265830f, 0.03348817f, 
    0.06367993f, -0.05593222f, 0.18085115f, -0.01837160f, -0.02178438f, -0.03463619f, 0.02919496f, 0.02644254f, 
    -0.06558814f, -0.04885677f, -0.07891656f, -0.09415535f, -0.07271172f, -0.01073217f, -0.07771478f, 0.07725620f, 
    0.04417449f, 0.08697497f, 0.09251386f, 0.04527286f, 0.16443339f, -0.27173150f, -0.12607221f, -0.10822204f, 
    0.08587356f, 0.03257366f, 0.11367723f, -0.08261166f, 0.12659298f, 0.00201670f, -0.04075757f, -0.16370237f, 
    -0.16942507f, -0.08642630f, 0.00089090f, 0.03479724f, -0.19056399f, 0.04640404f, 0.22619389f, -0.12815939f, 
    -0.04701709f, -0.05465446f, -0.15873298f, 0.06532675f, 0.06256253f, 0.03570538f, 0.08786482f, 0.11148383f, 
    -0.04513752f, 0.07680371f, 0.00291948f, -0.07223220f, 0.05549786f, -0.10364934f, 0.05045053f, 0.12006373f, 
    0.01333812f, -0.10055778f, 0.05585130f, 0.09898189f, 0.02688812f, -0.05062610f, -0.18640366f, 0.13003768f, 
    0.03750597f, -0.13584919f, 0.01325029f, -0.03126614f, -0.08264454f, -0.06787652f, -0.00984986f, -0.08579978f, 
    -0.00931233f, 0.00821784f, 0.14877424f, 0.05110254f, 0.08251669f, -0.05602856f, -0.12673686f, -0.02616801f, 
    -0.01824915f, -0.00703520f, 0.06751327f, -0.08884548f, 0.09057255f, 0.12418856f, 0.04986206f, 0.13210087f, 
    0.14728251f, 0.00803143f, 0.16773689f, 0.11074616f, 0.00267114f, -0.11521344f, 0.06060459f, 0.06198628f, 
    -0.05977227f, 0.03209501f, 0.12190770f, 0.02606503f, -0.05368926f, 0.04151771f, -0.03701617f, -0.09256797f, 
    -0.08489700f, -0.10592899f, 0.12624232f, -0.11692768f, 0.12514539f, 0.08278134f, 0.05858591f, -0.00058153f, 
    -0.01800689f, 0.00792734f, -0.04983347f, -0.00094240f, -0.01704580f, 0.06888734f, 0.07523166f, -0.14784941f, 
    -0.11729310f, -0.13468739f, -0.11573029f, -0.02210302f, -0.00603642f, 0.05517270f, 0.19375494f, 0.08375531f, 
    -0.08126231f, 0.06735243f, 0.06456277f, 0.05844366f, -0.04153843f, -0.06076499f, -0.03691568f, 0.10265332f, 
    0.07317574f, -0.07483354f, 0.07270414f, -0.05628120f, 0.00581013f, -0.07749519f, 0.07057446f, 0.10025683f, 
    0.14946869f, -0.11660054f, -0.09185260f, -0.12240434f, -0.24038719f, -0.03853273f, 0.06485640f, 0.08040445f, 
    -0.09854918f, 0.21563572f, 0.14020854f, -0.06705821f, 0.00100253f, 0.02501816f, 0.06672768f, -0.07701025f, 
    0.05494163f, 0.03954121f, -0.00470587f, 0.07718900f, -0.12660159f, 0.05936943f, -0.09332474f, -0.01584406f, 
    -0.01911094f, 0.05966813f, 0.03529669f, -0.28284469f, -0.13063839f, 0.08670834f, 0.06388524f, 0.15337920f, 
    0.05261001f, -0.01912750f, 0.00415387f, 0.07973338f, 0.26409659f, -0.06526400f, -0.26540092f, -0.06804358f, 
    -0.02666996f, 0.11266522f, -0.04509614f, 0.00989304f, 0.10426697f, -0.28197667f, -0.07525043f, -0.14644901f, 
    0.09254906f, -0.02167526f, 0.12456857f, -0.18432872f, -0.09218193f, 0.05737927f, 0.01077989f, -0.30317199f, 
    -0.08138906f, 0.03771207f, 0.07210597f, 0.05773254f, -0.02848562f, -0.08127154f, 0.13827604f, -0.03401737f, 
    -0.01372334f, -0.16485995f, 0.13748106f, 0.06594107f, -0.06083868f, -0.03945588f, 0.05490569f, 0.02368919f, 
    0.00595057f, -0.03131471f, -0.08008775f, 0.08394734f, 0.07825177f, 0.03716387f, 0.02646746f, -0.00301666f, 
    -0.15854810f, -0.11219080f, -0.16951133f, -0.24445009f, 0.05840855f, 0.14328818f, 0.09210379f, 0.05172785f, 
    -0.08179033f, 0.06073707f, -0.09444333f, -0.00706509f, 0.12888514f, 0.06342006f, -0.01806173f, 0.17112356f, 
    -0.08792527f, 0.20424560f, -0.09246410f, -0.34562826f, 0.00654405f, 0.02805315f, 0.03193118f, -0.00019643f, 
    0.06229148f, -0.12747751f, 0.01322424f, -0.00839658f, 0.31345665f, 0.16121693f, -0.13373996f, -0.04048537f, 
    -0.05986482f, -0.00741093f, 0.01592709f, 0.10896742f, 0.12930459f, 0.41910198f, 0.23648198f, -0.26440778f, 
    0.02389641f, -0.13994040f, 0.04560054f, 0.08743332f, 0.15470812f, -0.01078950f, 0.01845542f, 0.01991489f, 
    -0.23666249f, 0.03421863f, 0.13577624f, 0.00322338f, 0.16853057f, -0.04168608f, -0.15810074f, 0.04999697f, 
    -0.19868903f, -0.16446471f, -0.04161588f, -0.04465774f, -0.02118096f, 0.02613768f, -0.08748723f, -0.10066157f, 
    0.21057145f, -0.08139039f, 0.23097923f, -0.01113354f, -0.00245796f, 0.02320716f, -0.03008781f, -0.06841505f, 
    -0.10294713f, -0.00035479f, -0.03108567f, 0.13985366f, 0.04793711f, -0.05581232f, 0.03411158f, -0.06430332f, 
    -0.01076193f, 0.01827422f, 0.06871463f, -0.04345976f, 0.24310175f, -0.10399588f, -0.10245313f, -0.03370110f, 
    0.00307144f, 0.03042285f, 0.09777085f, 0.11943195f, 0.08599833f, 0.14720769f, -0.02600037f, 0.02676143f, 
    0.03141904f, 0.08315799f, 0.04958732f, -0.03479003f, -0.04583860f, 0.00025767f, 0.03305691f, 0.00507093f, 
    0.06797042f, -0.01600455f, -0.09459943f, -0.01894790f, 0.02558833f, -0.28423655f, -0.11748000f, 0.11407300f, 
    0.03772751f, 0.07287557f, 0.12112743f, -0.07241814f, 0.11477552f, -0.06184841f, 0.17565890f, 0.24189965f, 
    -0.00781247f, -0.12700547f, -0.07164361f, 0.09788650f, -0.08861079f, -0.16957633f, -0.02150707f, -0.06421978f, 
    0.06442012f, -0.09689937f, 0.07047228f, 0.07100239f, 0.06380390f, 0.09010305f, 0.05494059f, -0.08318439f, 
    -0.15121150f, -0.03364849f, -0.02766431f, -0.10533053f, 0.18852760f, 0.16677558f, 0.05343834f, 0.03246626f, 
    -0.08657873f, 0.19187003f, 0.05483662f, 0.15547293f, -0.05031808f, -0.14626706f, -0.05593570f, 0.13776661f, 
    0.13229471f, -0.09653534f, 0.17455287f, -0.11127315f, -0.10565355f, -0.05795307f, -0.00374449f, 0.07546235f, 
    0.13344115f, 0.05481261f, 0.11022516f, -0.17034158f, -0.06238892f, 0.16040300f, 0.02949386f, 0.24640080f, 
    0.12898441f, -0.10070499f, 0.02776629f, 0.12245453f, 0.14757721f, 0.14006118f, -0.18928538f, -0.10478234f, 
    0.03112893f, 0.11402046f, -0.02898199f, -0.07585307f, 0.11643749f, 0.01456333f, -0.07644771f, -0.13673832f, 
    0.01911630f, 0.01118906f, 0.03022365f, 0.05481182f, 0.05254496f, -0.08287653f, 0.28537142f, -0.07460096f, 
    -0.06501476f, 0.10539704f, -0.18614827f, 0.07358835f, 0.04889240f, 0.08092764f, -0.20498927f, 0.08984175f, 
    -0.07598901f, 0.11479818f, 0.06517155f, 0.00987582f, 0.02001794f, -0.05898660f, -0.09949666f, 0.07605265f, 
    0.18596877f, 0.05696663f, -0.06097473f, 0.04702887f, -0.02212169f, 0.05100529f, -0.02833026f, -0.07555106f, 
    -0.08121470f, 0.16402943f, 0.09300223f, 0.05444112f, 0.06858501f, 0.00479348f, -0.00756206f, 0.01078200f, 
    -0.12895401f, -0.12688112f, 0.07115258f, -0.05863905f, -0.10762987f, -0.09569701f, -0.02841844f, -0.06108532f, 
    -0.09079402f, -0.03578076f, -0.07071161f, 0.05976875f, -0.12782088f, 0.25426853f, -0.11902934f, -0.03226325f, 
    0.04979081f, 0.05569238f, 0.05473354f, 0.00198952f, 0.09569606f, -0.10849603f, -0.08283290f, 0.01920697f, 
    0.03026287f, 0.11583010f, 0.00083691f, -0.05094070f, -0.10783377f, -0.08376845f, -0.04440505f, -0.10654666f, 
    0.19111884f, -0.03139941f, 0.05883104f, 0.04761182f, -0.04136129f, 0.14155987f, 0.17161873f, -0.05202418f, 
    -0.08629292f, -0.08801606f, -0.03772221f, 0.15974995f, 0.00665789f, 0.04792714f, -0.12005902f, 0.02339795f, 
    -0.01201348f, 0.07826837f, 0.11269412f, 0.11588597f, 0.03457783f, -0.00270720f, -0.10515063f, 0.13290995f, 
    -0.22349103f, 0.05604847f, -0.20870112f, 0.02261288f, -0.18901718f, -0.06174128f, 0.07957758f, 0.09377922f, 
    -0.00517901f, 0.11265370f, 0.00173245f, -0.14278491f, 0.10617942f, -0.13114877f, 0.16620040f, -0.04068713f, 
    0.00127230f, -0.06873693f, 0.12512369f, -0.06352624f, 0.14990985f, 0.03727220f, 0.01717279f, -0.02598364f, 
    0.05412510f, 0.10268946f, 0.07668121f, -0.01329629f, 0.06669442f, 0.27928641f, -0.19790183f, 0.08175945f, 
    -0.03216228f, -0.07226138f, -0.05756384f, 0.03916787f, -0.03524245f, 0.05111588f, -0.10121606f, -0.07308068f, 
    -0.07510862f, -0.18392256f, -0.01567923f, 0.11817039f, 0.08152562f, -0.06182103f, 0.01238192f, -0.35693476f, 
    -0.01923263f, -0.06078999f, -0.05318944f, -0.00550263f, -0.05646384f, -0.00710283f, -0.22747715f, 0.01136156f, 
    -0.06599938f, 0.10996661f, 0.01861409f, -0.05953606f, -0.01043597f, -0.05164644f, -0.00690431f, -0.07157212f, 
    0.03760980f, -0.30390435f, -0.02877321f, 0.08788596f, -0.00465773f, -0.05279893f, 0.05088923f, -0.07518560f, 
    0.19229484f, 0.16380329f, 0.29247358f, 0.09149980f, 0.03373500f, 0.06976987f, -0.05623500f, -0.06836233f, 
    0.06306032f, -0.15888123f, -0.08630203f, 0.28391129f, 0.06201426f, 0.00897267f, 0.01842779f, 0.06261975f, 
    0.11531290f, 0.07378510f, -0.38570648f, -0.06525150f, 0.29825589f, 0.14872546f, 0.09212402f, -0.07382338f, 
    0.06156608f, -0.01733641f, 0.20083599f, 0.09876309f, -0.06167359f, 0.23491904f, 0.00189071f, 0.03811362f, 
    0.14662363f, -0.02964452f, -0.01735987f, -0.04524411f, 0.11502825f, -0.21997809f, 0.08990683f, -0.02470402f, 
    0.08071236f, 0.04948216f, -0.02199955f, -0.00904362f, 0.16500989f, -0.03946787f, 0.04385501f, 0.17844139f, 
    -0.02055472f, 0.10637174f, 0.01860299f, -0.04457190f, 0.00137125f, 0.08884435f, -0.08597042f, -0.04551461f, 
    -0.13431911f, 0.04751348f, -0.04096696f, -0.09831937f, 0.04641137f, 0.03039165f, -0.09986003f, 0.04448344f, 
    0.02414319f, -0.14809135f, -0.07025264f, 0.15244040f, 0.01657433f, -0.04887943f, -0.10748068f, -0.01639078f, 
    0.17556959f, -0.03625307f, -0.00820238f, -0.10456729f, 0.06934488f, 0.04535313f, -0.02267740f, -0.08673866f, 
    0.00820058f, 0.31241488f, 0.04330081f, 0.11152105f, -0.00822616f, -0.11435898f, -0.03349459f, 0.03582035f, 
    0.15790424f, -0.03503754f, 0.04584906f, 0.14784062f, 0.07080503f, -0.03441248f, -0.03295960f, -0.01679982f, 
    -0.15283300f, -0.05787162f, -0.07443748f, -0.02240536f, -0.07591767f, 0.19071010f, -0.04422833f, -0.13064465f, 
    -0.09009671f, -0.01170282f, 0.03625483f, 0.07912625f, 0.07412449f, 0.07650001f, -0.02188435f, -0.09805817f, 
    0.00032724f, 0.07508252f, 0.00184986f, -0.05378681f, -0.02377441f, 0.13542120f, -0.02468528f, -0.20522209f, 
    -0.03074150f, 0.01855352f, 0.03641434f, -0.07985408f, 0.03166525f, 0.04366963f, -0.26068130f, 0.08899792f, 
    0.04329602f, -0.10174213f, 0.03288751f, -0.21316764f, -0.08232403f, -0.03552663f, -0.03700350f, -0.04441117f, 
    0.23895803f, 0.23404081f, -0.02731504f, -0.04626902f, -0.07828163f, -0.00729607f, 0.09220294f, 0.05414748f, 
    -0.03853354f, 0.03157848f, -0.02579832f, -0.06404001f, 0.02272754f, 0.03410209f, -0.00507491f, 0.03770310f, 
    -0.04787709f, -0.02260419f, 0.00975741f, 0.03114637f, -0.03369436f, -0.05884228f, 0.02954248f, -0.05105597f, 
    -0.03947790f, -0.05604934f, 0.02883446f, -0.06692646f, 0.02781175f, -0.05787919f, 0.00524471f, -0.01309277f, 
    -0.02746444f, -0.01741763f, -0.00296223f, 0.02044469f, 0.03943520f, -0.02428664f, -0.02832708f, 0.01853620f, 
    0.00453556f, -0.06578572f, -0.03418153f, 0.04038310f, -0.01126147f, -0.05852478f, 0.04973252f, -0.04548655f, 
    -0.08617786f, -0.02884415f, -0.02405917f, -0.00287661f, 0.04461366f, 0.01443614f, 0.05540917f, -0.01767427f, 
    -0.03876799f, -0.06644101f, -0.06087764f, -0.00003083f, 0.00480894f, 0.04289043f, -0.01291447f, -0.00037097f, 
    -0.04149700f, 0.03444443f, -0.00362316f, 0.01048205f, -0.06806789f, -0.05451051f, 0.02782132f, 0.00404644f, 
    -0.01640866f, 0.02912694f, -0.02927433f, 0.02776558f, -0.01296070f, -0.03262730f, -0.06786300f, -0.07784522f, 
    -0.02984576f, 0.03222018f, -0.00529066f, 0.03192315f, -0.05918911f, -0.07502747f, -0.01393500f, -0.05254511f, 
    -0.05111454f, 0.01897822f, -0.04567245f, 0.00742767f, 0.00094515f, 0.02084342f, -0.01110926f, -0.08156781f, 
    0.00614935f, -0.01693561f, -0.02309775f, 0.04015246f, -0.07115793f, -0.05636724f, -0.02562973f, -0.05936410f, 
    0.00297398f, 0.01147323f, 0.03139681f, -0.01782215f, -0.00001760f, 0.00330127f, 0.02632975f, 0.00151671f, 
    -0.02876806f, 0.00819363f, -0.06938367f, -0.01393706f, 0.00274021f, -0.01958114f, 0.02121283f, -0.02651908f, 
    -0.00504343f, -0.04057420f, -0.06809904f, 0.03092464f, 0.02030675f, -0.05870385f, -0.03853661f, -0.00675973f, 
    -0.05629484f, -0.09941248f, -0.06810480f, -0.05400131f, -0.03620826f, 0.04364360f, -0.00584473f, -0.06846703f, 
    0.00270023f, -0.03176995f, -0.03781449f, -0.07644725f, 0.03229793f, -0.02628478f, 0.01618629f, 0.03153176f, 
    -0.07148357f, -0.02154812f, -0.05758258f, 0.00653941f, -0.02121658f, 0.00617572f, 0.03446025f, -0.01039851f, 
    -0.05289955f, -0.02818284f, -0.02867175f, -0.02808423f, -0.07730354f, -0.01925607f, -0.05835965f, -0.03870302f, 
    0.01991501f, -0.02655594f, 0.00437419f, 0.00608764f, -0.01676400f, 0.01378412f, -0.03064883f, -0.03015215f, 
    -0.03991620f, 0.04816789f, 0.04169335f, 0.03123309f, -0.07266241f, 0.02736165f, -0.06203998f, -0.03123233f, 
    -0.07026463f, -0.03585523f, 0.01112627f, -0.07471070f, 0.02892561f, -0.06855770f, -0.01799470f, -0.03111232f, 
    0.00765342f, -0.06866313f, -0.03886259f, -0.05796972f, -0.00410651f, 0.02050113f, -0.00773122f, 0.04025581f, 
    0.02234470f, 0.02447106f, 0.01258024f, -0.00951160f, -0.03099152f, 0.02185699f, -0.01511869f, -0.05642381f, 
    -0.06797103f, -0.03686285f, -0.00638313f, -0.05306621f, -0.06139785f, -0.01959190f, -0.01689190f, 0.02676612f, 
    -0.00348935f, -0.03742352f, -0.06301308f, -0.06649926f, -0.03770665f, -0.05835208f, -0.00923006f, 0.02552333f, 
    0.02079171f, -0.07333452f, -0.05868460f, -0.02486696f, -0.02478961f, -0.06545287f, -0.00382702f, 0.02691666f, 
    0.01796455f, 0.01953699f, -0.02214700f, -0.05706595f, 0.00126368f, -0.05315084f, -0.03211373f, 0.02629348f, 
    0.00843601f, -0.04339645f, -0.00557542f, -0.05141624f, -0.00149073f, 0.01134253f, 0.02126396f, -0.07129180f, 
    0.03917545f, -0.08131433f, -0.00826423f, 0.03243199f, -0.07275120f, 0.00590139f, -0.00001297f, -0.05066576f, 
    -0.07959881f, -0.05423000f, 0.01359215f, -0.03928073f, -0.05955210f, 0.01127863f, -0.02559205f, -0.02821966f, 
    -0.01840134f, -0.03926580f, -0.04189325f, -0.01409545f, -0.01200521f, 0.00566636f, -0.05237762f, -0.04637517f, 
    -0.00732798f, 0.01852611f, 0.02889888f, 0.00553370f, -0.02835855f, -0.04931163f, -0.01697362f, 0.02340686f, 
    0.01109619f, -0.04609706f, -0.03808232f, 0.01704214f, -0.04915809f, -0.05958188f, -0.01978432f, -0.05547398f, 
    0.02038688f, -0.04858921f, -0.04191482f, -0.01991479f, -0.06768829f, -0.05609239f, -0.04215366f, -0.04545889f, 
    0.00959558f, -0.03201595f, -0.04302026f, -0.04380877f, -0.00318863f, 0.03549614f, -0.03137849f, -0.04531340f, 
    0.19097246f, 0.19789872f, 0.00318750f, -0.07757238f, 0.00371547f, -0.01184288f, 0.05006136f, 0.21166229f, 
    -0.09252477f, -0.41280061f, -0.54306203f, -0.01745142f, 0.06245068f, 0.07559798f, 0.09879011f, -0.18229583f, 
    0.03973735f, 0.04426325f, 0.16046630f, -0.01016927f, 0.05461359f, -0.01452665f, 0.06825413f, 0.16058438f, 
    -0.04929171f, -0.01671500f, -0.03409933f, 0.21875228f, 0.13619502f, -0.12686183f, 0.05215036f, -0.10974699f, 
    -0.11213253f, 0.00116552f, 0.13062699f, 0.06901360f, -0.25624898f, -0.25930497f, -0.08284985f, 0.08246151f, 
    0.07086190f, -0.00142562f, 0.02132084f, 0.00502515f, 0.04681053f, -0.10828625f, -0.10334229f, -0.07126114f, 
    -0.00942276f, 0.01007487f, -0.01923103f, -0.02791714f, -0.06139818f, 0.00432059f, -0.12557302f, 0.10841401f, 
    -0.21664278f, 0.00339828f, -0.01719528f, 0.11392037f, 0.10354917f, -0.04888258f, 0.03196709f, 0.38568506f, 
    0.04380238f, 0.01803482f, -0.01258961f, 0.01791524f, 0.07722050f, 0.03258127f, -0.06606422f, 0.05895913f, 
    0.49501386f, -0.22520782f, 0.02340131f, -0.00632116f, 0.00016335f, -0.05272188f, 0.05353448f, -0.02442730f, 
    -0.16345267f, -0.38240573f, -0.13620768f, 0.00303910f, -0.00355024f, -0.01174937f, -0.00741515f, 0.08841875f, 
    -0.08510651f, 0.20552896f, 0.00947651f, 0.10515670f, 0.07676218f, -0.14991754f, -0.05114295f, 0.10826569f, 
    0.08592275f, 0.06711227f, -0.14940576f, -0.07649816f, -0.05000328f, -0.12755387f, -0.17823157f, -0.03789816f, 
    0.05610738f, 0.00363919f, -0.14065024f, 0.04736697f, 0.00977421f, 0.08239701f, 0.03947360f, -0.01572988f, 
    -0.06473369f, -0.00787989f, -0.00706679f, -0.01490323f, -0.04808555f, 0.07490760f, -0.12620078f, 0.24732777f, 
    0.19759585f, -0.02528396f, 0.11719517f, -0.06155676f, -0.09529274f, -0.09162831f, -0.11042909f, -0.24239039f, 
    -0.14492889f, -0.08435969f, -0.07607103f, 0.11148921f, 0.02083054f, -0.05039949f, 0.03741283f, -0.25627810f, 
    -0.40986213f, -0.07825690f, 0.27747875f, 0.14476964f, 0.11258519f, -0.11659096f, 0.00545327f, 0.02330545f, 
    0.00083463f, 0.10438339f, -0.00455791f, 0.04232866f, 0.13014501f, -0.00328796f, -0.08044423f, -0.04010058f, 
    -0.01450161f, 0.19943543f, 0.04165881f, -0.01060938f, 0.00343579f, -0.16382606f, -0.14322743f, 0.08678734f, 
    0.11693146f, -0.11616517f, -0.02232778f, 0.06426755f, -0.12621248f, -0.10427628f, 0.00206900f, 0.16589676f, 
    -0.04394494f, 0.08131099f, 0.06605688f, -0.03483228f, 0.13641933f, -0.01948520f, 0.00142396f, -0.14018981f, 
    -0.02784602f, -0.04783142f, 0.10781075f, 0.11049487f, -0.16494064f, 0.08220604f, -0.02882696f, -0.03879554f, 
    -0.06468578f, -0.01795224f, 0.09509937f, 0.12821370f, 0.12915117f, 0.25468460f, 0.14511795f, 0.03785073f, 
    0.16446514f, 0.05170360f, -0.08038091f, 0.03588560f, 0.17396115f, 0.08528104f, -0.27584770f, -0.30140740f, 
    -0.05047567f, 0.00525346f, 0.13245595f, 0.00813090f, 0.05533230f, -0.11944488f, 0.03366936f, -0.00608230f, 
    0.01899662f, 0.00206480f, 0.09536449f, -0.09304912f, -0.00926478f, 0.04922765f, -0.00852419f, 0.00927521f, 
    -0.05930184f, 0.03060086f, -0.11376286f, -0.03667627f, -0.09441916f, -0.04680162f, 0.18486728f, 0.11149743f, 
    0.07871782f, 0.07214322f, 0.36355779f, -0.01230827f, 0.00487300f, 0.08171446f, 0.01733184f, -0.03663399f, 
    -0.04946307f, -0.11538789f, -0.24161841f, -0.05435371f, -0.08620857f, 0.21872395f, -0.10224420f, -0.00391898f, 
    -0.02486468f, 0.06412546f, -0.00669189f, 0.09684040f, 0.06805742f, 0.06983255f, -0.06963491f, 0.04580292f, 
    -0.11528245f, 0.03888028f, 0.03004242f, -0.03384142f, -0.12325995f, -0.26739907f, 0.11357687f, 0.09075531f, 
    0.02543338f, 0.03247446f, -0.10127768f, -0.04889059f, 0.03634210f, 0.05546536f, 0.09430481f, 0.00500903f, 
    0.03234766f, -0.00198376f, 0.05145263f, -0.08850247f, -0.05865201f, -0.09456372f, -0.11362772f, -0.18007058f, 
    0.14375740f, 0.11858954f, -0.02676147f, 0.12034483f, 0.04520627f, -0.10370941f, 0.01551689f, -0.11107823f, 
    -0.06129980f, -0.13632125f, -0.04602720f, 0.07304715f, -0.01160987f, -0.00285771f, 0.03519030f, 0.07759184f, 
    0.28595769f, 0.16561626f, 0.19971049f, -0.10205367f, -0.03711896f, -0.06814197f, -0.00062483f, -0.03688350f, 
    0.01801975f, -0.08738010f, 0.07774549f, 0.07494302f, -0.04984967f, -0.08821920f, 0.05887260f, 0.00528081f, 
    -0.07904003f, -0.03450632f, -0.12344807f, 0.08357226f, -0.17753072f, -0.12277751f, 0.06184227f, -0.02827991f, 
    -0.00858233f, -0.10769031f, -0.04201719f, -0.01270988f, -0.15153579f, -0.09151267f, 0.04309603f, -0.07471547f, 
    0.01018779f, 0.11968945f, 0.02895105f, 0.00085310f, -0.26282963f, 0.11799905f, 0.12455782f, 0.06062735f, 
    -0.13208213f, 0.18247922f, 0.06024150f, 0.02884630f, 0.09889581f, 0.27612069f, 0.07913507f, -0.00687451f, 
    0.05086807f, -0.02428262f, 0.05636746f, -0.00102246f, -0.14265609f, 0.10984224f, -0.12618427f, -0.01853359f, 
    -0.08290064f, -0.02099441f, -0.09584751f, 0.08138117f, 0.14181408f, 0.18794349f, -0.05265064f, 0.09957115f, 
    0.02520850f, -0.09268320f, -0.21369416f, 0.26131779f, -0.08579886f, 0.06577740f, 0.01875616f, 0.05687544f, 
    0.27890432f, 0.06710301f, -0.03790151f, -0.10197373f, 0.07427600f, -0.07160448f, 0.07323687f, -0.13940158f, 
    -0.04676219f, -0.05500901f, -0.00846191f, -0.04462879f, 0.08681048f, -0.23578769f, 0.05360759f, 0.05094633f, 
    -0.02477353f, 0.03199066f, -0.08062140f, 0.10788141f, 0.12488896f, 0.18555038f, -0.14401503f, -0.05054442f, 
    -0.06177524f, -0.12783554f, 0.02854944f, -0.17153756f, -0.01891649f, -0.18238583f, -0.06608275f, 0.05397188f, 
    0.09546673f, -0.09199023f, 0.02260668f, -0.06864548f, -0.14242217f, 0.08092029f, 0.02149920f, -0.00864956f, 
    0.06708586f, -0.14969327f, 0.00822134f, -0.00247367f, 0.09002966f, -0.07647932f, 0.01193485f, 0.01422476f, 
    -0.00370744f, -0.05163010f, -0.04820143f, 0.09158088f, 0.02724581f, 0.12370814f, -0.01035517f, -0.11637324f, 
    -0.08983313f, 0.01849555f, 0.05999559f, -0.20538165f, 0.00949784f, 0.03583843f, -0.08583327f, 0.10750014f, 
    -0.04757869f, 0.02688445f, -0.06422120f, 0.08891524f, 0.05978109f, -0.09939081f, -0.13535574f, 0.00641120f, 
    0.00324949f, 0.02669842f, 0.19808486f, -0.10121424f, 0.12012369f, -0.10905162f, 0.03518270f, -0.01886631f, 
    -0.02158540f, -0.03813319f, 0.10166899f, 0.14402148f, 0.05238320f, -0.02039371f, -0.01622295f, 0.05092128f, 
    -0.03428733f, 0.00842742f, -0.15126202f, 0.13158014f, 0.08106232f, -0.02154482f, -0.01001690f, 0.10450403f, 
    0.06460860f, -0.01060290f, -0.13620311f, 0.09041964f, -0.08163942f, 0.16400906f, 0.02639152f, -0.08300304f, 
    0.04778246f, -0.04079513f, -0.06000943f, 0.02600147f, 0.12128177f, -0.18256043f, 0.23381776f, -0.05324078f, 
    0.07406860f, -0.06004249f, 0.13943340f, -0.00661316f, 0.08306758f, 0.03281048f, -0.22052491f, -0.08101711f, 
    0.05075055f, 0.03351124f, 0.11208180f, 0.10753746f, 0.04835341f, -0.06590912f, -0.24741754f, 0.04990681f, 
    0.00983685f, 0.07750218f, 0.06094438f, 0.03275082f, -0.00730729f, 0.01275455f, -0.02463236f, -0.05731117f, 
    0.07924472f, 0.01641984f, -0.05092480f, 0.02014653f, 0.01085971f, -0.05591914f, 0.04263161f, 0.05604332f, 
    -0.03894661f, 0.04867902f, 0.01862681f, 0.05294223f, 0.05182734f, -0.10082640f, -0.09684551f, -0.08475653f, 
    0.04181150f, -0.00098223f, 0.05370053f, 0.21926020f, -0.10091257f, 0.03560913f, -0.13661958f, 0.06419397f, 
    0.00470974f, 0.02236314f, 0.03733212f, -0.17702459f, 0.06857004f, 0.07838429f, -0.02150449f, 0.04525107f, 
    0.04054697f, 0.05363007f, 0.01043310f, -0.04699004f, 0.12830117f, -0.18394554f, 0.00866587f, -0.06510192f, 
    -0.05344956f, 0.13595133f, 0.03788132f, -0.08890092f, -0.13944261f, -0.03365459f, 0.13962926f, -0.06864638f, 
    0.01463591f, 0.06949702f, 0.08290293f, -0.09090816f, -0.02209879f, -0.02701096f, 0.18995900f, 0.01725683f, 
    -0.16981697f, -0.09418482f, 0.05220940f, -0.13391322f, -0.01106685f, 0.10258650f, -0.26222059f, 0.10175592f, 
    -0.25627148f, -0.06419989f, 0.08659983f, -0.13271894f, -0.09054714f, -0.05835253f, 0.15311074f, -0.04427992f, 
    0.06322055f, -0.07941616f, 0.03214562f, -0.06858948f, -0.03002550f, 0.09299732f, -0.08233596f, -0.11877088f, 
    0.03104331f, 0.00711519f, -0.02348594f, 0.05220782f, 0.03315314f, 0.00391157f, 0.04955637f, -0.03847151f, 
    0.03760736f, -0.00225942f, -0.02623697f, -0.06471286f, -0.03686061f, 0.01115153f, 0.05001204f, -0.02912637f, 
    -0.01415207f, -0.00080719f, -0.01661321f, 0.02257757f, -0.01510045f, -0.01546953f, 0.01116529f, -0.06380382f, 
    0.04373219f, -0.02368928f, 0.04095698f, 0.01362263f, -0.06212664f, 0.00250069f, 0.02768717f, 0.01189721f, 
    -0.01405756f, 0.04019302f, 0.01955915f, -0.04639937f, 0.04914647f, -0.04168069f, 0.00647272f, 0.00122838f, 
    -0.04580750f, 0.02830667f, 0.02371202f, 0.02157017f, -0.02609586f, -0.00119891f, -0.02457523f, -0.02112027f, 
    -0.02417649f, -0.02373196f, -0.05237231f, -0.05469624f, -0.01181255f, 0.04630402f, -0.03707805f, 0.04051442f, 
    0.00143718f, -0.01877699f, 0.03198900f, 0.02129898f, -0.02332945f, 0.02192388f, -0.05966374f, -0.01281497f, 
    0.03168330f, 0.01255128f, 0.04914636f, -0.00816002f, 0.04555075f, 0.02411241f, 0.02856483f, -0.00050558f, 
    0.03609829f, -0.02400445f, -0.04955491f, -0.04463287f, -0.01135951f, -0.03691404f, -0.01360012f, 0.00221958f, 
    -0.04650716f, 0.04354631f, 0.01977244f, 0.01823100f, -0.02966228f, -0.03157292f, -0.00363845f, 0.04768927f, 
    -0.01536256f, 0.02053367f, 0.03805425f, 0.01096735f, -0.01730359f, 0.01878689f, -0.02327084f, -0.02026189f, 
    -0.02248774f, 0.02552399f, 0.00681464f, 0.03413162f, 0.04731583f, -0.00475014f, -0.04954403f, -0.05072634f, 
    0.04127752f, -0.01623200f, 0.03431162f, 0.03119924f, -0.01838867f, 0.03940378f, 0.00505997f, 0.04308798f, 
    -0.00281167f, 0.03013966f, -0.04446306f, -0.04111938f, 0.00190026f, 0.00071651f, -0.04208492f, 0.01371474f, 
    -0.02632269f, -0.02024332f, 0.02929808f, 0.00566328f, 0.00090768f, 0.03610811f, -0.00793328f, -0.02200695f, 
    0.04656161f, -0.04919230f, -0.01583591f, -0.05803237f, -0.01262230f, -0.02900153f, 0.00863756f, -0.04835094f, 
    -0.03616475f, -0.05799026f, -0.06173166f, -0.06709301f, -0.05601572f, -0.01073644f, -0.01168646f, -0.04146959f, 
    0.02793429f, -0.05867725f, 0.01865381f, -0.04578216f, 0.00424716f, -0.00432327f, -0.04791652f, 0.03625003f, 
    0.04667977f, -0.01876754f, 0.01409605f, 0.02238390f, -0.01060037f, 0.02663550f, -0.01684212f, 0.05373374f, 
    -0.04652497f, 0.03774156f, -0.05198665f, -0.02164890f, 0.03927988f, -0.06005182f, -0.06131494f, -0.00250670f, 
    0.01751702f, -0.01976066f, -0.05475747f, -0.05242520f, -0.01105548f, 0.03055034f, 0.03791106f, -0.03106875f, 
    -0.01483596f, -0.00524209f, 0.02745393f, -0.01887647f, -0.04578299f, -0.06102101f, -0.05900881f, -0.01024058f, 
    -0.05487150f, -0.04721513f, 0.02024598f, -0.02453514f, -0.06529969f, -0.01217961f, 0.02238365f, -0.03497347f, 
    -0.00143259f, -0.05225896f, -0.03734813f, 0.02703670f, -0.04221441f, -0.03241798f, -0.05892519f, 0.01926627f, 
    -0.01809169f, -0.01176585f, 0.01014923f, 0.00567338f, -0.00187340f, 0.04580421f, -0.03562354f, -0.06117716f, 
    -0.01095475f, -0.06503163f, 0.02962198f, -0.02982292f, 0.01489938f, -0.02076489f, -0.00795304f, -0.06049761f, 
    -0.05698733f, 0.01956214f, 0.04978717f, -0.05103396f, 0.00162435f, 0.02179166f, -0.03734112f, 0.01774460f, 
    -0.04159068f, 0.01889534f, -0.06217533f, 0.00477147f, -0.03581626f, -0.05902953f, 0.04844378f, 0.02302337f, 
    0.02560735f, -0.04100941f, 0.04506049f, -0.05451633f, 0.02586553f, -0.05724214f, 0.01742297f, 0.01211774f, 
    0.01047608f, -0.01904549f, -0.02818805f, -0.02580649f, -0.04577067f, -0.05246602f, 0.02484031f, 0.02880727f, 
    -0.01423621f, -0.01275789f, 0.04625814f, -0.05054365f, -0.05239968f, -0.02478906f, -0.05696251f, -0.05756119f, 
    0.02831564f, -0.00418690f, -0.04642947f, -0.00211301f, -0.00450477f, 0.02449441f, -0.04263807f, 0.00764351f, 
    -0.00006629f, 0.00987733f, 0.03601506f, 0.02426812f, -0.04145246f, -0.05729996f, -0.05862249f, -0.03465987f, 
    0.04209709f, -0.01942482f, -0.02166167f, -0.04941811f, 0.03877755f, -0.03148703f, -0.01623294f, 0.01739525f, 
    -0.03146747f, -0.02551364f, -0.03837858f, 0.03398861f, 0.01868812f, -0.05577337f, -0.00643117f, 0.00964753f, 
    -0.00572280f, -0.00949453f, -0.23155396f, 0.03901199f, -0.11235392f, 0.05309712f, 0.12035975f, 0.02728456f, 
    0.02354552f, -0.06441087f, 0.16511226f, 0.06527534f, 0.15289578f, 0.05422616f, -0.10342330f, 0.01214160f, 
    0.07379548f, 0.10713831f, 0.03825007f, -0.07574817f, -0.25336772f, -0.11103030f, 0.02586340f, -0.08597486f, 
    -0.03155635f, 0.10281617f, 0.07172380f, -0.24844217f, -0.04662681f, 0.10956545f, -0.04512132f, -0.13254903f, 
    -0.05175156f, -0.05597552f, 0.02106056f, -0.05686535f, 0.19661133f, 0.03076015f, 0.09667767f, -0.05331491f, 
    0.05447510f, -0.11426623f, 0.02949723f, -0.00996325f, 0.03199308f, -0.31752110f, -0.11543807f, -0.03241166f, 
    -0.15547775f, 0.00028566f, 0.02011122f, -0.17578548f, 0.14434512f, 0.04248776f, -0.03273171f, -0.20623051f, 
    0.08113466f, 0.01617497f, 0.00548549f, 0.03125178f, 0.00115833f, -0.04090223f, -0.01191359f, -0.14583275f, 
    0.09084340f, 0.00094938f, -0.00149359f, 0.11201304f, 0.16559909f, 0.10598273f, 0.13978010f, 0.06088270f, 
    0.12445374f, -0.17321044f, 0.14107747f, -0.04517492f, 0.05741706f, -0.04845415f, 0.05115739f, -0.11025134f, 
    -0.00040565f, -0.09459740f, -0.03194855f, -0.01067762f, -0.06070332f, 0.14430727f, 0.05150880f, 0.15212046f, 
    -0.09038843f, 0.04206214f, -0.28640532f, 0.02572782f, -0.04723819f, 0.01096475f, 0.02197921f, 0.32594597f, 
    0.03523561f, 0.08498239f, -0.10421137f, 0.04941426f, 0.03177641f, 0.00433904f, 0.09494410f, 0.02372520f, 
    -0.03869133f, -0.11224518f, -0.08594633f, -0.04429528f, 0.25346372f, -0.06534354f, 0.10282521f, 0.01489372f, 
    0.06587353f, -0.02573285f, 0.00495349f, 0.06828054f, 0.08070713f, 0.21723282f, 0.29979026f, -0.06119426f, 
    0.05941347f, -0.02540199f, 0.01248154f, 0.10844606f, -0.12792732f, -0.14563024f, -0.05310888f, -0.00206243f, 
    0.10138667f, 0.12838721f, 0.04101260f, -0.07217538f, 0.09738089f, -0.16510761f, -0.01066960f, 0.11705796f, 
    -0.19228061f, 0.07452960f, 0.10170145f, 0.10142402f, 0.07529067f, 0.01734576f, -0.05440357f, -0.12323789f, 
    0.05051969f, -0.04994308f, -0.03061851f, -0.08531576f, 0.09014601f, -0.03285992f, -0.10118124f, -0.15369177f, 
    0.00806755f, 0.01283385f, 0.17776649f, -0.09687880f, -0.03633414f, 0.04562747f, 0.07412231f, 0.02068363f, 
    -0.01386980f, 0.00166220f, 0.17772780f, -0.18234771f, 0.03747857f, -0.11534590f, -0.08655596f, -0.04784361f, 
    -0.13215144f, 0.15845171f, 0.04773014f, -0.03078032f, 0.05708747f, -0.22963241f, 0.01414014f, -0.00998794f, 
    -0.03427760f, 0.08495741f, -0.03380268f, 0.05391080f, -0.41570994f, 0.08002271f, 0.07654249f, -0.00345162f, 
    0.03364696f, 0.04615355f, -0.15907758f, -0.03650304f, 0.02739939f, -0.25244671f, -0.04067788f, -0.04467163f, 
    -0.12478337f, -0.01518452f, -0.05933619f, -0.03105675f, 0.09841745f, -0.02425530f, -0.03532929f, 0.24075004f, 
    0.10577055f, 0.07677689f, 0.06584787f, -0.07101934f, -0.04631234f, -0.11791682f, -0.00693842f, 0.12374177f, 
    0.11087962f, -0.25013417f, 0.12210879f, 0.04628191f, 0.13466065f, 0.03904562f, 0.02849937f, -0.08453333f, 
    -0.19369511f, 0.11669672f, -0.04946525f, 0.03695534f, -0.06299806f, 0.10636593f, 0.06412395f, -0.00214914f, 
    -0.04458130f, -0.01666757f, 0.17762797f, -0.17114770f, -0.05658877f, 0.10571881f, -0.06318134f, 0.09128213f, 
    0.04708026f, 0.09725711f, 0.25905734f, -0.03076879f, -0.03187263f, -0.06388153f, 0.02859720f, -0.08017293f, 
    0.10047622f, 0.00543935f, 0.01843269f, -0.19016704f, -0.00273496f, 0.07944883f, -0.11663731f, 0.00078812f, 
    0.00474776f, 0.02109713f, 0.07576708f, 0.03354751f, 0.07818566f, 0.02973489f, -0.09375686f, -0.03080504f, 
    0.02156982f, -0.08929859f, -0.03142123f, -0.10355309f, -0.08137157f, -0.10876276f, 0.18918556f, -0.42312208f, 
    -0.03350315f, 0.04506581f, -0.06213795f, -0.14253752f, 0.02820415f, -0.00554221f, 0.24270956f, 0.06919128f, 
    -0.09052774f, 0.13927972f, -0.04450220f, -0.04757385f, 0.12771495f, -0.06192496f, -0.01380642f, 0.12315632f, 
    0.17775775f, 0.05672810f, 0.09920076f, 0.05857144f, -0.11734242f, 0.00287627f, -0.07604275f, 0.05904889f, 
    0.11885317f, 0.07162198f, -0.00606402f, -0.11940703f, -0.12873672f, 0.12617436f, 0.04287648f, -0.05052434f, 
    0.08524314f, -0.30589414f, 0.18324558f, 0.28469372f, 0.10947780f, 0.08219320f, 0.01464936f, 0.23544551f, 
    -0.01606837f, 0.14064406f, 0.07871585f, 0.10921369f, -0.02016280f, -0.01669596f, -0.01938643f, 0.02030981f, 
    -0.05962782f, -0.01753768f, 0.11611763f, -0.19919147f, -0.32123518f, -0.01385011f, -0.01618197f, -0.01322650f, 
    -0.05288392f, 0.08285826f, -0.00117052f, -0.02063213f, -0.11482716f, 0.09171911f, 0.27459544f, -0.02065185f, 
    0.10862221f, 0.00486446f, -0.04061368f, 0.04010331f, 0.16317856f, 0.19437589f, 0.02315560f, 0.15028782f, 
    -0.00648921f, 0.02652927f, -0.04342106f, 0.02472843f, -0.15341917f, 0.05452283f, -0.00348018f, -0.15194421f, 
    0.19090091f, 0.06534730f, 0.12147937f, 0.12648520f, -0.06812663f, -0.03232196f, -0.08172749f, -0.08136185f, 
    -0.17695682f, 0.18311776f, -0.09741332f, -0.06765724f, -0.09634591f, 0.07187105f, -0.01564890f, -0.03471333f, 
    0.21037625f, -0.05747189f, 0.04486365f, -0.10317535f, -0.06924618f, -0.06292694f, 0.02267552f, 0.11288492f, 
    0.01501890f, -0.10917116f, 0.09904375f, 0.14831589f, 0.15178111f, 0.06938113f, 0.04349384f, -0.01530613f, 
    -0.00046833f, 0.10634623f, 0.08505827f, -0.13791177f, -0.14424142f, -0.00396971f, 0.16867435f, 0.05191104f, 
    -0.05205401f, -0.11906102f, -0.14118822f, -0.50361019f, -0.08702578f, -0.09743368f, 0.05113355f, 0.05760125f, 
    0.02149613f, -0.07476543f, 0.01540595f, 0.01995871f, 0.04941471f, 0.08445327f, -0.03651419f, -0.05187160f, 
    0.02051785f, 0.06313072f, 0.04578054f, 0.05460072f, 0.01606163f, 0.15958941f, 0.25432354f, 0.17753884f, 
    -0.04050657f, -0.11578776f, 0.16287735f, -0.00106838f, 0.07523233f, 0.07527709f, -0.21310012f, 0.08430681f, 
    0.04344948f, -0.17669907f, 0.02315341f, -0.22778718f, 0.10952407f, -0.07136740f, 0.09636370f, -0.41382042f, 
    -0.01957688f, 0.02921391f, 0.17849049f, 0.11666825f, 0.13298807f, -0.13760638f, -0.10345760f, -0.00335189f, 
    -0.14398725f, -0.13580053f, 0.09859022f, -0.12253304f, 0.10913330f, 0.02015835f, 0.03574580f, -0.04436265f, 
    0.25079769f, -0.01717829f, -0.28460482f, 0.02750244f, 0.16087340f, 0.02631091f, 0.03268541f, -0.04338492f, 
    -0.13051875f, -0.04971058f, -0.17748050f, 0.08008026f, -0.10481968f, -0.02185795f, 0.03480448f, 0.02698951f, 
    0.08058903f, 0.02791132f, -0.02332125f, -0.14247304f, -0.04316801f, 0.03250131f, 0.16514628f, 0.20319870f, 
    0.10759740f, 0.16948818f, 0.03009540f, 0.06032110f, -0.28588980f, -0.21922275f, -0.02251866f, 0.09675941f, 
    0.06294820f, 0.00241831f, 0.15887351f, -0.04729250f, -0.11388765f, -0.06440677f, -0.08035903f, -0.05771817f, 
    0.06680559f, -0.02679816f, -0.01964612f, -0.16724256f, 0.07771123f, 0.06338444f, -0.11309810f, 0.19409718f, 
    0.15763396f, 0.08344907f, 0.13720345f, 0.12184444f, -0.03767715f, -0.10585003f, 0.17891805f, 0.12877877f, 
    0.10065169f, 0.00034720f, 0.03096400f, -0.04389529f, 0.09320898f, 0.04608453f, 0.04761672f, -0.10077865f, 
    -0.10727675f, -0.06826559f, -0.17915241f, -0.00654249f, -0.05936593f, -0.01269746f, 0.00969598f, -0.24341364f, 
    0.09946285f, -0.06635305f, -0.27949050f, -0.04854536f, -0.05132059f, 0.03018461f, -0.00468881f, -0.09791200f, 
    -0.13854928f, 0.05713280f, 0.18270916f, -0.05173057f, 0.10190614f, 0.13284756f, -0.03808314f, 0.04036035f, 
    0.01785212f, 0.06772156f, -0.01205575f, -0.28718850f, -0.03728680f, -0.05347371f, 0.05357229f, -0.07947129f, 
    -0.10370432f, 0.17823119f, -0.14751579f, -0.12721086f, -0.02847543f, 0.19623062f, 0.22952674f, 0.05655176f, 
    0.12824541f, 0.18640481f, 0.20893684f, -0.01023866f, 0.12679642f, 0.08253103f, -0.12365926f, -0.07050246f, 
    -0.10720322f, -0.00055177f, 0.02972832f, -0.10524051f, 0.09537204f, -0.10139426f, 0.04802771f, 0.03875668f, 
    -0.13611068f, -0.07257112f, -0.13166203f, -0.06289955f, 0.09223318f, -0.11279868f, 0.04296903f, -0.22135131f, 
    0.08029197f, 0.02381377f, 0.06676138f, 0.15797453f, -0.07610499f, -0.00404379f, -0.11532566f, -0.01726824f, 
    -0.06622376f, 0.08967058f, 0.07897616f, 0.04161552f, 0.13726638f, -0.02687261f, -0.15268980f, 0.22720285f, 
    0.13776426f, 0.07337024f, 0.13259941f, 0.07581656f, -0.16964088f, 0.13175115f, 0.02191644f, 0.06625877f, 
    -0.02036143f, 0.01583324f, -0.05618903f, 0.00556683f, 0.07649871f, 0.09533852f, 0.10842869f, -0.02498444f, 
    0.02873982f, 0.16954063f, 0.07237581f, -0.20350440f, -0.32625327f, 0.09224214f, 0.03053935f, 0.03315220f, 
    -0.01767584f, 0.02487167f, -0.12947264f, -0.05239862f, 0.14990123f, 0.16004035f, 0.04123984f, 0.12432851f, 
    -0.02184993f, 0.02554519f, 0.03064218f, -0.10004071f, 0.01851210f, -0.01048421f, 0.21188998f, 0.04358432f, 
    0.00498097f, 0.03875752f, -0.04354780f, 0.17432010f, 0.06642950f, -0.05658296f, -0.01673874f, -0.00168472f, 
    0.13257664f, 0.16633615f, -0.05980068f, 0.04754424f, -0.11889013f, -0.19801101f, 0.05560512f, -0.08417869f, 
    0.01364547f, 0.23930238f, -0.05097853f, -0.12083933f, -0.15883823f, -0.09798436f, 0.08769126f, 0.05364003f, 
    -0.13538940f, 0.03967696f, 0.04055788f, -0.03106688f, 0.12965791f, -0.12273198f, 0.03879892f, 0.11549863f, 
    -0.02900848f, 0.18642507f, 0.15750772f, 0.16505256f, 0.00657835f, -0.15012994f, 0.14062984f, 0.07540181f, 
    -0.01417671f, 0.07511625f, -0.18069866f, -0.12335037f, -0.11485878f, -0.02286997f, 0.27792948f, 0.12749174f, 
    0.05101753f, -0.18670593f, 0.16965000f, -0.01322751f, -0.21199949f, -0.02315905f, 0.21167721f, -0.17639080f, 
    -0.08795083f, -0.02240822f, -0.11025376f, 0.05232377f, 0.00928098f, 0.01672529f, -0.05537518f, 0.04943365f, 
    -0.07153831f, -0.03110676f, 0.05653155f, 0.01216247f, 0.13232236f, 0.10633206f, 0.09929523f, -0.00087758f, 
    -0.06445520f, 0.05697075f, -0.03406038f, 0.05736133f, 0.02516192f, -0.04715962f, 0.18934242f, 0.11156196f, 
    0.07953256f, -0.11864836f, -0.00723937f, 0.01262395f, -0.09045829f, 0.11696464f, 0.17207006f, -0.37031233f, 
    -0.10084931f, 0.11597113f, -0.08006071f, -0.04752709f, 0.23260039f, 0.08118495f, -0.11854463f, -0.01002954f, 
    -0.16705856f, 0.23127383f, -0.04129006f, 0.08359850f, -0.14721331f, -0.06725615f, 0.12951976f, -0.00342270f, 
    0.09960764f, -0.34984890f, -0.27610523f, 0.03889781f, 0.07015808f, 0.17312346f, 0.17010105f, -0.09496475f, 
    -0.26630554f, -0.00485864f, -0.35504270f, 0.05665056f, 0.09335779f, -0.00334600f, 0.10560288f, -0.10133047f, 
    0.04288377f, 0.07259790f, -0.02204646f, -0.26616114f, -0.04077604f, 0.11477389f, 0.15693529f, 0.18717456f, 
    -0.09820362f, 0.16279651f, 0.14305964f, 0.29656708f, -0.33309832f, -0.14758104f, -0.11824181f, 0.23961771f, 
    -0.00584279f, 0.13982430f, 0.09439722f, -0.07693877f, 0.04596257f, 0.01004472f, -0.08284362f, -0.04387544f, 
    0.03083012f, 0.00704825f, 0.15867084f, 0.06581250f, -0.21485274f, -0.12268857f, 0.17879009f, 0.04668922f, 
    -0.08343873f, -0.06477389f, 0.02278851f, -0.04654425f, -0.00686222f, -0.01352148f, 0.08608867f, -0.03441221f, 
    0.08667103f, 0.06646204f, 0.03081577f, 0.00236261f, 0.04306350f, 0.08504477f, 0.10016976f, 0.18311733f, 
    -0.08234955f, -0.07152104f, 0.15016992f, 0.08818625f, -0.11204005f, -0.10299796f, -0.06518071f, 0.06759346f, 
    0.06870124f, -0.21452114f, -0.03482762f, 0.04025374f, 0.00856209f, 0.21464077f, -0.15093665f, 0.11051434f, 
    -0.02848386f, 0.01428988f, 0.00262645f, -0.00831026f, 0.10880244f, 0.05273989f, 0.07529958f, 0.12490124f, 
    -0.03999674f, -0.02281716f, -0.01126358f, -0.26546648f, -0.09885107f, 0.09123719f, 0.07387829f, 0.09436321f, 
    -0.00114550f, -0.01724588f, -0.05498917f, 0.05894048f, 0.18165767f, 0.05873258f, 0.19288921f, 0.03518414f, 
    0.00269884f, 0.11416351f, 0.14512894f, 0.03089245f, -0.02754883f, -0.20701036f, 0.00208956f, 0.05375124f, 
    -0.03755809f, 0.11168545f, -0.04130881f, -0.08605278f, 0.11028536f, 0.02473573f, 0.08978396f, -0.06111291f, 
    -0.14716212f, -0.23084268f, -0.04998964f, -0.06688102f, 0.07001180f, 0.04341281f, 0.03029223f, 0.18374062f, 
    -0.13842924f, 0.00874011f, -0.01691276f, 0.09308018f, 0.01900559f, -0.04689956f, 0.01766999f, 0.11514389f, 
    -0.21398082f, 0.10089949f, -0.04079197f, 0.05431608f, -0.02525523f, 0.14266892f, 0.00324457f, -0.05149741f, 
    0.05855558f, -0.11276621f, -0.04187221f, -0.03582072f, 0.14114946f, 0.10408344f, -0.09513208f, -0.13286105f, 
    0.10746618f, -0.01041654f, -0.17229800f, -0.08143705f, 0.01263351f, -0.09345351f, 0.10346480f, 0.08344986f, 
    0.06194196f, 0.16608995f, -0.04501699f, -0.19841219f, 0.01279719f, 0.25513634f, -0.05904027f, -0.04145233f, 
    0.02678690f, -0.00285436f, 0.13473116f, -0.01144705f, 0.11321668f, 0.04359685f, -0.04492252f, 0.09595922f, 
    0.01984320f, -0.01514757f, -0.00911975f, 0.00568712f, 0.10259263f, -0.01376686f, -0.18164882f, -0.08422834f, 
    0.11044426f, -0.22188906f, -0.04245117f, 0.04295571f, -0.05541170f, 0.02783310f, 0.32501474f, 0.15677325f, 
    -0.01074896f, -0.18584549f, -0.17901631f, 0.01304161f, 0.03257908f, 0.09751187f, -0.10974376f, -0.22700690f, 
    0.16838518f, -0.34911886f, -0.09147796f, 0.06138593f, 0.06795480f, -0.10265253f, 0.02691200f, 0.00643207f, 
    -0.31057954f, -0.09044269f, -0.54217613f, 0.05748830f, 0.03462582f, -0.04213215f, 0.12217094f, -0.02899957f, 
    0.06699882f, 0.02373127f, 0.19435370f, 0.10299220f, -0.13706236f, -0.10909327f, -0.02835727f, 0.09151344f, 
    -0.10189394f, 0.13872668f, -0.25464088f, -0.19564517f, -0.13119559f, -0.04102911f, 0.11309907f, 0.07314622f, 
    0.09719166f, -0.06061427f, 0.03597944f, -0.03424822f, 0.08841138f, -0.18116434f, 0.10465951f, -0.15078159f, 
    -0.19718346f, -0.02986825f, 0.06465188f, 0.16299249f, 0.19464451f, -0.13751951f, -0.06271083f, -0.09173864f, 
    0.06064099f, -0.02036092f, 0.10270295f, -0.14101791f, 0.05057229f, -0.19763035f, -0.40649828f, -0.18959503f, 
    0.21624288f, 0.04637320f, -0.00294594f, 0.05361527f, -0.07802430f, -0.12098140f, 0.17390214f, -0.03104878f, 
    0.16938788f, 0.14243111f, 0.17020014f, 0.04445333f, 0.06788796f, 0.01175413f, 0.09395081f, 0.23710479f, 
    0.29960373f, 0.00264402f, 0.05575255f, -0.05514944f, 0.06627264f, 0.07617386f, 0.07784077f, 0.04168777f, 
    0.11179849f, -0.08606534f, -0.14409053f, -0.07924631f, -0.01359181f, 0.12801944f, 0.13717440f, 0.01640807f, 
    -0.02024162f, -0.19071548f, 0.07149676f, 0.01253431f, 0.02179078f, -0.03001318f, -0.03465313f, 0.14646079f, 
    0.03689968f, 0.13268775f, -0.39662561f, 0.03571164f, 0.41757339f, -0.05554906f, -0.04125838f, 0.19213311f, 
    -0.03314808f, 0.15803829f, -0.01857860f, -0.44894552f, 0.03436514f, 0.25103995f, -0.04544895f, -0.08417228f, 
    0.06783862f, 0.01481303f, 0.04564403f, 0.01625129f, -0.12765396f, -0.08001605f, 0.23770252f, -0.09064650f, 
    -0.06057918f, 0.00315142f, -0.09330484f, 0.06080566f, -0.04256326f, 0.10623214f, 0.01600164f, 0.16469465f, 
    -0.04246822f, 0.08524920f, -0.09584289f, 0.07826462f, 0.05174156f, -0.10621653f, 0.14180909f, -0.09165503f, 
    -0.17431872f, 0.09104389f, 0.03700977f, 0.02866693f, -0.02388777f, -0.03146661f, 0.04200809f, 0.09725235f, 
    -0.03908043f, -0.05004710f, -0.02422742f, 0.05184402f, 0.15462917f, -0.05827332f, 0.14479508f, -0.01233282f, 
    0.08282229f, 0.16016719f, -0.02055613f, 0.09484002f, -0.05039936f, 0.02085433f, 0.02082648f, -0.00490891f, 
    0.15044050f, 0.07787289f, -0.02620799f, -0.01420171f, 0.10859841f, 0.00423813f, 0.04977736f, 0.01245957f, 
    -0.06891396f, -0.11744737f, 0.23866574f, 0.06788012f, 0.20328407f, -0.00044479f, -0.01751558f, -0.07774597f, 
    0.07706375f, 0.14831932f, 0.13346371f, 0.07505182f, 0.00848586f, 0.01337139f, -0.14888310f, -0.07504074f, 
    -0.05112296f, 0.00117980f, 0.09295776f, 0.12907000f, 0.08412724f, -0.03775416f, 0.15332323f, 0.09570992f, 
    0.03871240f, -0.00895392f, 0.05567642f, -0.02169494f, 0.09248400f, 0.16126540f, 0.29740775f, -0.02009237f, 
    0.02164266f, 0.04541291f, -0.06338098f, -0.08328965f, 0.04157425f, -0.10116079f, -0.14207056f, 0.12295427f, 
    -0.13072790f, 0.08420932f, 0.17738317f, 0.06443473f, 0.03969796f, -0.10202150f, 0.07390581f, 0.05905594f, 
    0.06350439f, -0.05575446f, 0.11674690f, 0.06013479f, 0.00854696f, 0.03790252f, 0.00149566f, 0.12530355f, 
    0.14350806f, -0.11137047f, 0.09243746f, -0.03141226f, -0.11508332f, -0.03919284f, 0.15152952f, -0.08760875f, 
    0.00520611f, -0.24242561f, -0.00662477f, 0.09822728f, 0.06741313f, -0.00824308f, 0.08512951f, 0.00834640f, 
    0.05531925f, 0.00318455f, -0.03034101f, -0.19534558f, -0.05830431f, -0.07697373f, -0.06885615f, -0.08679231f, 
    -0.04224590f, -0.02339101f, -0.11358851f, 0.10911685f, -0.06972796f, 0.20523153f, -0.08204772f, -0.02433462f, 
    -0.05726522f, 0.13185580f, 0.12979591f, -0.00365647f, 0.18060841f, -0.02455151f, 0.07608400f, 0.10019805f, 
    0.02109678f, 0.13450718f, -0.02835805f, -0.01971119f, -0.09290566f, 0.30775529f, -0.08160038f, -0.08097083f, 
    -0.09015625f, -0.10017065f, 0.06449203f, 0.03412851f, -0.05362348f, -0.06182515f, 0.12088577f, 0.07176031f, 
    -0.07971454f, -0.03757218f, -0.02089280f, 0.03924511f, -0.05629074f, 0.03756985f, -0.05610219f, 0.16091721f, 
    0.19366719f, -0.02042709f, -0.04665506f, 0.18023466f, -0.12644905f, -0.00393433f, -0.12447046f, 0.10095892f, 
    -0.10625087f, -0.18200840f, 0.13453808f, -0.13397026f, -0.13632748f, -0.00134679f, 0.09576733f, -0.04000103f, 
    -0.14822838f, -0.02521907f, 0.07243826f, -0.30144182f, 0.03310943f, 0.11417960f, 0.00173651f, -0.10449436f, 
    -0.01408209f, -0.09573431f, 0.03069731f, 0.15082462f, 0.22249715f, -0.07140687f, -0.00620848f, -0.19233082f, 
    -0.01950657f, 0.01243058f, -0.30628538f, -0.06189973f, -0.13131993f, 0.01902470f, -0.03637947f, 0.06360333f, 
    -0.00207252f, -0.12846625f, -0.01593686f, 0.05442172f, -0.05536032f, 0.00556574f, 0.28474173f, -0.04286575f, 
    0.02328151f, -0.01793091f, -0.06698211f, 0.07251818f, -0.06414859f, -0.03890107f, -0.14806981f, 0.19814198f, 
    0.07702473f, 0.02461523f, 0.08701404f, -0.07227939f, 0.03561141f, 0.00613365f, -0.16753885f, -0.03910060f, 
    -0.02719905f, -0.00973464f, 0.12593776f, -0.06555255f, -0.15400268f, -0.09108863f, 0.11199301f, -0.23707691f, 
    -0.20466164f, -0.12633410f, -0.12746544f, -0.01759863f, 0.09115741f, -0.08127804f, 0.03649572f, -0.09302218f, 
    0.14897038f, 0.25757411f, 0.33241108f, 0.06710533f, 0.05016249f, 0.01000475f, 0.01569223f, -0.11564495f, 
    0.03100009f, 0.01556812f, 0.08403677f, 0.23020250f, -0.08915765f, -0.09997514f, 0.06322147f, -0.14210494f, 
    -0.00231248f, -0.13569954f, -0.14432271f, -0.10055171f, 0.29749420f, 0.01712754f, -0.02475106f, -0.05411543f, 
    -0.05468145f, 0.02560372f, 0.04611278f, -0.13097426f, -0.12521859f, 0.17962292f, 0.02996128f, -0.06871449f, 
    0.05976346f, 0.03770718f, 0.09810077f, -0.08924516f, -0.04283698f, 0.01496080f, 0.13673753f, 0.10613421f, 
    0.07765125f, -0.17783688f, -0.06008257f, -0.02721526f, 0.02457608f, 0.03964084f, 0.04792367f, 0.17397402f, 
    -0.10997722f, 0.15551981f, -0.09128644f, -0.10308618f, 0.03934943f, -0.09889110f, -0.05904310f, -0.13206977f, 
    -0.00832769f, -0.01383496f, 0.12523919f, 0.01289739f, 0.02600335f, 0.13654575f, -0.05072578f, 0.00556575f, 
    -0.16826992f, -0.05507757f, -0.17023042f, 0.01096905f, -0.12832260f, -0.14184387f, -0.01741605f, -0.04985191f, 
    -0.03641234f, -0.10280190f, 0.02090693f, -0.04771282f, 0.08624379f, 0.00784732f, -0.01002357f, 0.06968162f, 
    0.05479678f, 0.17993347f, -0.03941801f, -0.03354305f, 0.10750282f, 0.00229429f, -0.05048344f, -0.01591470f, 
    -0.12102610f, 0.08371601f, 0.12241806f, 0.08662735f, 0.18651627f, 0.04119352f, 0.03731988f, 0.13408740f, 
    -0.05885322f, 0.00448863f, 0.04627760f, 0.01887474f, 0.04156652f, 0.08241010f, -0.05816684f, -0.29703042f, 
    -0.04758605f, 0.10731561f, 0.19876236f, 0.18868010f, -0.17054945f, 0.00888480f, 0.02874980f, 0.03857854f, 
    -0.06047080f, 0.04656627f, -0.03228864f, 0.00257034f, -0.15729663f, 0.08746542f, -0.26183710f, -0.00764266f, 
    -0.10084715f, -0.13636853f, -0.14617284f, -0.12100226f, 0.03806327f, -0.08458067f, -0.08965389f, 0.11938673f, 
    0.25802937f, 0.04546245f, 0.06281949f, 0.05078346f, -0.08814773f, 0.08097657f, -0.02654184f, 0.02051575f, 
    0.19123130f, 0.06776891f, 0.01559402f, -0.02187516f, -0.03848944f, -0.13098593f, 0.01351502f, -0.07839599f, 
    -0.00382110f, 0.02116517f, -0.05888982f, -0.01790142f, -0.01833276f, -0.03887684f, 0.01461790f, 0.01633043f, 
    -0.02560085f, -0.05170751f, 0.04467919f, 0.00838143f, 0.01094027f, -0.03615043f, -0.05267328f, -0.02600480f, 
    -0.04473448f, 0.02712233f, -0.03977218f, -0.02459281f, 0.00279018f, -0.06517165f, -0.03771422f, 0.03787456f, 
    -0.01873227f, 0.00331539f, -0.05798519f, -0.02996073f, -0.00635142f, 0.00424909f, 0.02024787f, 0.02651289f, 
    -0.05988368f, 0.03651468f, -0.03165188f, 0.00881064f, -0.01138967f, 0.03330329f, -0.03354120f, -0.05438289f, 
    -0.06030460f, 0.01694374f, 0.01553040f, 0.00632282f, -0.04151347f, -0.04472619f, -0.06097745f, -0.01065855f, 
    0.02391641f, -0.03677446f, 0.03678901f, -0.06067869f, 0.00286712f, 0.00331129f, -0.00497053f, -0.05806879f, 
    0.05526162f, 0.02351857f, -0.03233536f, 0.05057696f, -0.00264151f, 0.01995394f, -0.04751681f, -0.06283888f, 
    0.04596432f, 0.02949419f, 0.03733994f, 0.04644041f, 0.05222131f, -0.03969489f, 0.04427299f, 0.04850707f, 
    0.00229273f, 0.00501425f, -0.06244951f, -0.05016869f, 0.01259951f, 0.00983891f, 0.04749976f, -0.00289635f, 
    -0.04173542f, -0.05060093f, -0.02674742f, 0.02021311f, -0.01216407f, 0.04419616f, -0.00236431f, -0.02947219f, 
    0.04157012f, -0.03915625f, -0.02011715f, 0.02076689f, -0.06262036f, -0.01614301f, 0.01767147f, 0.01586432f, 
    0.00878241f, -0.00829120f, 0.01715809f, 0.02506494f, -0.00166532f, 0.04781565f, 0.02356411f, -0.00901324f, 
    -0.03134317f, -0.01314334f, -0.00441579f, -0.06287552f, -0.03917625f, 0.00395184f, 0.03116123f, 0.01435669f, 
    0.02316167f, -0.03868590f, 0.03288864f, -0.05615444f, -0.05860665f, -0.02409315f, 0.04696834f, -0.03664707f, 
    -0.01339389f, 0.02037849f, 0.03888979f, 0.01278216f, 0.02208338f, 0.03952342f, -0.05142047f, -0.01256198f, 
    0.01961271f, -0.04917548f, 0.04892915f, -0.01280138f, -0.03478970f, 0.01286936f, -0.04322075f, 0.00843188f, 
    -0.00971964f, 0.02930133f, 0.04930802f, -0.02220751f, -0.02155739f, -0.05661360f, -0.00399906f, 0.02945410f, 
    0.00115605f, 0.01871107f, -0.07373632f, 0.01007620f, -0.01586281f, 0.04413272f, -0.04045423f, 0.04186119f, 
    0.03491656f, -0.04325416f, 0.00061447f, 0.01843021f, -0.02396255f, 0.01066450f, 0.02134452f, 0.04370469f, 
    0.04573488f, -0.02701683f, 0.00921048f, 0.02098452f, 0.00963312f, -0.01552664f, 0.01308454f, 0.00724139f, 
    -0.03881121f, -0.05871385f, -0.00269353f, -0.02263458f, 0.02844339f, -0.04971260f, -0.03871270f, -0.01612641f, 
    -0.03662563f, -0.03261905f, 0.03567961f, 0.02466689f, -0.01647481f, -0.07020112f, 0.02573352f, 0.00960224f, 
    -0.06349044f, -0.05252955f, 0.00591538f, 0.00664510f, -0.01902603f, 0.00414377f, 0.01040445f, 0.01793648f, 
    -0.02817355f, -0.03857983f, 0.00323411f, -0.02706774f, -0.05687992f, -0.02275567f, -0.05380987f, -0.04672831f, 
    -0.04695313f, -0.04989664f, 0.00614630f, -0.02861655f, 0.00858655f, -0.02687481f, 0.01465404f, 0.01051312f, 
    0.01415667f, -0.03277307f, 0.01370074f, -0.03791424f, 0.01126613f, 0.05229514f, -0.03836798f, -0.03429254f, 
    0.00781212f, 0.00188788f, -0.04192379f, -0.03469299f, -0.01509355f, -0.04907548f, 0.04838164f, -0.03800537f, 
    -0.06279448f, 0.02813516f, -0.01228642f, 0.00906003f, -0.00117876f, -0.01541642f, 0.00603661f, -0.04402535f, 
    0.03633919f, -0.01480427f, 0.02339534f, -0.05405458f, 0.04502691f, -0.03231148f, -0.00085008f, 0.01863055f, 
    0.03326793f, -0.00677784f, 0.02559134f, 0.02646356f, 0.03404648f, 0.05317806f, 0.01507164f, -0.05271976f, 
    0.02448524f, -0.02999099f, 0.04221783f, -0.05076749f, -0.01729469f, 0.01856831f, -0.01946011f, -0.02355725f, 
    0.03245797f, 0.04245164f, -0.05869012f, 0.03416114f, -0.05531351f, 0.04467919f, 0.02990291f, -0.03463857f, 
    -0.05949783f, -0.01616617f, -0.03049589f, 0.00695933f, -0.01223806f, -0.06553560f, -0.02039798f, -0.00122419f, 
    -0.02017425f, -0.01818499f, -0.00455036f, -0.05237763f, -0.02689847f, 0.00648594f, -0.00816563f, 0.00542072f, 
    0.02268607f, -0.05557204f, -0.03050841f, -0.04178351f, 0.04907007f, -0.00623769f, 0.01567479f, -0.04058208f, 
    0.02358755f, -0.32219094f, -0.14139283f, 0.09532747f, 0.07014923f, 0.16490704f, -0.04556120f, 0.09108132f, 
    0.13556895f, -0.15201333f, -0.04478766f, 0.05388698f, 0.04015388f, -0.01129606f, 0.14114483f, -0.11851881f, 
    0.03532737f, 0.08739413f, 0.06514169f, -0.18606967f, 0.15302600f, -0.13976753f, 0.02346481f, 0.01374020f, 
    0.14479326f, 0.19247216f, 0.04005166f, 0.38584399f, 0.24697600f, 0.14361253f, -0.17102684f, 0.04112860f, 
    0.01921563f, 0.04231035f, -0.01151459f, 0.02991733f, -0.15897295f, -0.08698861f, -0.17796391f, 0.01858828f, 
    0.14999299f, 0.11246370f, 0.02852065f, 0.01645390f, 0.03145588f, 0.15825631f, 0.05686221f, -0.22627068f, 
    -0.06507849f, -0.00618539f, 0.01095073f, -0.04501044f, -0.09203299f, -0.09857086f, 0.13120221f, -0.15726011f, 
    0.00087197f, -0.18983951f, -0.04311060f, -0.09348080f, 0.03450483f, 0.17392932f, 0.05604410f, 0.02310892f, 
    -0.16934972f, -0.20423140f, -0.02057797f, 0.07718045f, -0.05514530f, -0.07851833f, -0.08224204f, -0.08485112f, 
    -0.03688119f, -0.13661171f, -0.07497633f, -0.02060458f, 0.11016565f, 0.05824437f, 0.12248521f, -0.01681767f, 
    0.04566281f, -0.19586737f, 0.01171847f, 0.03395417f, 0.02423694f, 0.07825895f, -0.14317062f, 0.04817108f, 
    0.00988415f, -0.04202244f, 0.14138108f, -0.07617578f, -0.35257217f, 0.06264273f, 0.05481109f, 0.01445519f, 
    -0.15386511f, -0.05294549f, 0.00967342f, 0.06940413f, -0.17782852f, 0.01991515f, -0.09641072f, -0.13390264f, 
    0.03975356f, 0.05557014f, 0.04575494f, -0.04946588f, 0.16929600f, 0.00903517f, -0.14312851f, -0.03456470f, 
    -0.03017685f, 0.01382174f, -0.13567866f, 0.02814086f, -0.04349706f, -0.06521888f, 0.07194713f, -0.16978598f, 
    0.09006847f, 0.05625718f, -0.02958127f, -0.15211686f, -0.07168863f, -0.06842032f, -0.31424764f, 0.07974044f, 
    -0.05588594f, -0.02580922f, -0.09668907f, 0.07746926f, 0.07781497f, -0.01372654f, 0.01814499f, -0.42111111f, 
    0.17912360f, -0.01537217f, 0.01424237f, -0.03390763f, 0.02008725f, -0.07116951f, -0.01800435f, 0.07279174f, 
    -0.31547916f, -0.11151554f, 0.02567212f, 0.11231065f, 0.07386794f, -0.07008767f, -0.11750584f, -0.04688084f, 
    -0.03898503f, 0.22784048f, -0.20999713f, -0.00369745f, -0.13689917f, 0.07751189f, 0.03615834f, 0.08434007f, 
    -0.02042482f, -0.06619829f, -0.03844467f, 0.21156143f, 0.14459167f, -0.06626061f, 0.06388054f, 0.03788247f, 
    0.18437076f, 0.03471545f, -0.10266928f, 0.32292920f, -0.06236146f, 0.06153641f, -0.07960255f, -0.08109665f, 
    0.04103985f, -0.06226346f, -0.03634132f, -0.05189685f, 0.28547698f, 0.02228797f, -0.09498340f, 0.09518196f, 
    -0.03520658f, -0.11361156f, -0.02866601f, 0.06924551f, 0.04736406f, 0.21776482f, 0.31502673f, 0.17635022f, 
    -0.00766678f, -0.10832784f, -0.13911518f, -0.00383527f, 0.02660237f, -0.00467675f, -0.02536815f, 0.10351403f, 
    -0.02287737f, 0.05274639f, 0.04177482f, 0.15616006f, -0.07026877f, -0.03388604f, -0.12492593f, 0.36345351f, 
    0.06294291f, -0.03774297f, 0.16242267f, -0.07367583f, 0.04631918f, -0.05650271f, 0.06253180f, 0.00467800f, 
    0.43065608f, 0.00961378f, -0.10167708f, 0.06667551f, 0.02253772f, 0.12563890f, -0.03212159f, -0.04703395f, 
    -0.03897605f, -0.51743811f, -0.43716958f, 0.02200415f, 0.01451973f, 0.12245788f, 0.17825039f, 0.06177768f, 
    0.01489587f, -0.08083613f, 0.15643856f, 0.08711077f, -0.10775811f, -0.16034873f, 0.08145888f, -0.08788466f, 
    0.04679461f, -0.02699063f, 0.09429361f, 0.26383761f, 0.16011736f, 0.18495286f, -0.05938076f, -0.00698933f, 
    0.01006353f, 0.06407686f, 0.10714146f, -0.08801533f, -0.08683708f, -0.05418861f, -0.12278046f, 0.01561395f, 
    -0.06323849f, 0.03346709f, -0.01017975f, 0.02701436f, 0.02169921f, 0.10041659f, -0.14892359f, -0.05556244f, 
    0.08213630f, -0.06729308f, 0.05458198f, -0.03562108f, -0.07415000f, -0.08320551f, -0.21243477f, -0.17693204f, 
    0.15724230f, 0.08329812f, 0.03849342f, 0.07571305f, 0.06902476f, 0.03275238f, 0.00770129f, 0.20837466f, 
    -0.18200421f, -0.03534523f, -0.10700906f, 0.01036735f, 0.00636796f, 0.06997538f, 0.06528598f, 0.07993275f, 
    0.04777276f, 0.07703036f, -0.04100969f, 0.01423028f, -0.09382492f, 0.09666299f, 0.19282773f, -0.07217081f, 
    0.01000538f, -0.17311901f, -0.28086370f, 0.28484720f, 0.09875731f, 0.05330545f, -0.14150511f, 0.05104701f, 
    -0.14670284f, -0.01439096f, 0.20072649f, -0.08405896f, -0.14776610f, -0.05192816f, 0.04989287f, 0.03365638f, 
    0.00461699f, 0.00058573f, 0.07559037f, 0.19656186f, 0.12378749f, 0.02521009f, 0.16486882f, 0.06308705f, 
    0.03615045f, 0.08089107f, -0.01089103f, -0.09433473f, -0.17255238f, -0.18634352f, 0.20787409f, -0.04317940f, 
    0.06284613f, 0.12478703f, -0.04429168f, -0.00185854f, -0.08229692f, 0.00748682f, -0.15468952f, -0.03999282f, 
    -0.18533193f, -0.15556200f, 0.00911215f, 0.10463642f, 0.11044462f, 0.06390196f, 0.03470617f, -0.12196118f, 
    -0.03366164f, -0.13926381f, -0.04462696f, 0.05508424f, -0.17374620f, 0.20996065f, -0.04000529f, 0.35845965f, 
    -0.34439567f, -0.44963199f, 0.01293968f, 0.11688128f, 0.14765690f, 0.06162569f, 0.03637745f, -0.02071319f, 
    0.23650694f, -0.23982640f, -0.17577396f, 0.12282351f, -0.24280964f, 0.07683531f, 0.16757365f, 0.12900446f, 
    0.13659726f, -0.17832097f, 0.02694128f, 0.07640720f, -0.07456575f, 0.19844441f, -0.14110729f, -0.00749857f, 
    0.16107364f, -0.06304699f, -0.19101401f, -0.01728329f, -0.08579832f, 0.00823951f, 0.20538214f, 0.14482643f, 
    -0.12657438f, 0.10873070f, -0.10273420f, 0.21733081f, -0.26893717f, 0.11768664f, 0.10641294f, -0.14753789f, 
    -0.04424407f, -0.18873671f, 0.00138088f, 0.12135948f, -0.21033281f, -0.08321825f, 0.06418516f, 0.06821460f, 
    -0.04259452f, -0.02212349f, 0.00268468f, -0.07751240f, 0.03911129f, -0.19195955f, -0.36184511f, 0.31035855f, 
    0.20131992f, 0.10586935f, 0.00731388f, -0.01845760f, -0.19818453f, -0.02846834f, -0.11993727f, -0.37347946f, 
    -0.06104258f, 0.12312336f, 0.12744635f, -0.05649032f, -0.07150860f, 0.04078320f, 0.06192647f, 0.07257051f, 
    0.09214842f, 0.17184414f, -0.06660146f, 0.01845733f, -0.06880040f, -0.03602392f, -0.08938228f, 0.00717551f, 
    -0.15499476f, -0.11556319f, -0.10131672f, -0.08891843f, 0.03636567f, 0.09446023f, -0.06703158f, -0.17159343f, 
    0.00118911f, 0.26141474f, 0.08800095f, -0.10965201f, -0.02154828f, -0.00085266f, -0.00928915f, -0.21665542f, 
    0.15566356f, 0.15209383f, -0.08281494f, 0.42687988f, -0.21842931f, -0.19430508f, -0.02117940f, 0.10204193f, 
    0.04048745f, -0.01921983f, -0.07471237f, -0.07201829f, 0.33597767f, 0.06328992f, 0.16231835f, -0.16483787f, 
    -0.13734600f, 0.13154987f, 0.10400218f, 0.11055759f, -0.21116972f, 0.33465412f, -0.17977969f, 0.05204487f, 
    -0.03869919f, -0.20633037f, 0.02634139f, -0.12249339f, 0.08904123f, -0.01678031f, 0.18107463f, -0.18799078f, 
    0.03299429f, 0.11761933f, -0.13570024f, 0.20571534f, 0.12963916f, -0.12621303f, -0.20675963f, -0.29197919f, 
    0.13694304f, -0.12017612f, -0.11243318f, 0.15301178f, 0.11639956f, -0.00232792f, -0.03097926f, 0.14242995f, 
    -0.12830441f, -0.17729460f, -0.02635861f, 0.12687546f, 0.08621648f, -0.06468129f, 0.02154334f, 0.19997360f, 
    0.11329889f, -0.04844302f, -0.05479513f, 0.04195469f, -0.21625513f, -0.08774173f, 0.14294472f, 0.13840662f, 
    0.13378280f, 0.18041076f, 0.02508080f, -0.05583607f, -0.04304609f, -0.03003351f, 0.01776295f, 0.22380656f, 
    -0.16728611f, 0.04599031f, 0.02986046f, 0.00705397f, 0.01101315f, -0.08340483f, 0.07055559f, -0.01087845f, 
    0.08483350f, 0.06257654f, -0.05850198f, -0.12438259f, 0.04813561f, 0.07554594f, -0.17440104f, 0.09217620f, 
    0.16355424f, 0.08208384f, 0.06153557f, 0.08665886f, 0.04885159f, 0.00832105f, 0.15875691f, 0.03048419f, 
    -0.18040463f, 0.05807048f, -0.00435466f, -0.09677506f, 0.09959986f, 0.44873509f, 0.05500585f, -0.27603203f, 
    -0.08661518f, -0.17235574f, 0.11483984f, -0.10674204f, 0.01452302f, 0.21669911f, 0.05518017f, -0.34446421f, 
    0.19953555f, -0.00401758f, 0.25978166f, -0.02959002f, -0.07168010f, 0.08871112f, -0.05437474f, 0.09164157f, 
    -0.05656397f, 0.11103507f, 0.05318884f, -0.14040405f, -0.06375662f, -0.02254285f, 0.10507870f, -0.03479222f, 
    -0.05694398f, -0.01351146f, -0.05868106f, 0.01175417f, 0.01151606f, 0.05631614f, -0.00247914f, -0.00257427f, 
    -0.01850082f, 0.02959077f, 0.01298125f, 0.02307405f, -0.06284057f, 0.00604720f, -0.03106122f, -0.04889217f, 
    -0.06386440f, 0.01012653f, 0.02396393f, 0.03204696f, 0.02550502f, -0.03020919f, 0.01754614f, 0.04199669f, 
    -0.02581103f, 0.01387719f, -0.05193286f, -0.03642608f, -0.06003322f, -0.05240358f, -0.01219295f, 0.01286402f, 
    -0.04778055f, 0.01886378f, -0.04292776f, 0.04062298f, 0.02484351f, -0.03269901f, 0.03843758f, 0.01034436f, 
    -0.00713632f, -0.07094557f, -0.06173392f, 0.00000418f, -0.07626372f, -0.05234385f, 0.04115761f, -0.02424397f, 
    0.02850918f, 0.00180854f, 0.03385199f, -0.02293630f, -0.01504740f, -0.00155586f, 0.00645649f, -0.05954651f, 
    0.02435441f, -0.06525956f, -0.01900023f, -0.02867460f, -0.06550171f, 0.03001194f, 0.02290480f, 0.03106257f, 
    0.03400173f, -0.04649939f, -0.01100881f, 0.02001063f, 0.01942076f, -0.02449725f, 0.02383185f, 0.07247878f, 
    0.00755277f, -0.06273436f, -0.06113871f, 0.02719581f, 0.01295849f, 0.00431048f, 0.01270667f, -0.05214350f, 
    0.04860541f, 0.00380887f, 0.03271000f, -0.04649130f, 0.00555586f, -0.01229435f, -0.06043246f, -0.06254135f, 
    0.01229045f, -0.03439835f, 0.01503839f, -0.01799991f, -0.00048697f, -0.02899581f, -0.01387985f, -0.05131983f, 
    0.04951984f, 0.00840969f, 0.01026110f, -0.05763192f, -0.01245100f, -0.05331027f, -0.08161385f, -0.02910502f, 
    0.01637153f, -0.07540884f, 0.04742053f, 0.00847338f, -0.02050786f, -0.03977664f, 0.01306836f, 0.00853980f, 
    -0.06014990f, -0.01621431f, -0.04858265f, 0.01556381f, 0.04002602f, -0.02344876f, 0.05706284f, 0.02380013f, 
    0.01901187f, -0.03599102f, 0.07067961f, 0.04405066f, -0.05281010f, 0.01399776f, 0.03353241f, -0.02698389f, 
    -0.05220774f, -0.02255319f, -0.04003542f, -0.06408255f, 0.04360862f, 0.00331042f, 0.05714032f, -0.03230589f, 
    -0.01704476f, -0.03204484f, 0.04017182f, 0.00360674f, -0.03226481f, -0.00648895f, 0.00564398f, -0.03014285f, 
    -0.02656076f, 0.00205848f, -0.04292718f, 0.05618028f, -0.03711351f, 0.00512539f, -0.02631797f, 0.00545672f, 
    -0.03526151f, -0.02680870f, -0.03974875f, -0.08638187f, -0.02445441f, 0.03457556f, 0.02267634f, 0.02214124f, 
    0.05453813f, 0.02874360f, -0.06110024f, 0.01189122f, 0.02261683f, -0.04565245f, 0.05128622f, -0.00371784f, 
    -0.03014815f, 0.00853211f, 0.03157222f, -0.04551531f, -0.05974629f, -0.06089336f, 0.05111063f, 0.01425304f, 
    0.04421357f, 0.02447401f, -0.00415054f, -0.00277511f, 0.01333917f, -0.00250598f, -0.07015736f, 0.03106957f, 
    0.00481140f, -0.03502923f, 0.02046279f, -0.02477505f, -0.00643296f, -0.02921247f, 0.04131323f, -0.03069805f, 
    -0.05383113f, -0.04263134f, -0.00160629f, -0.00961335f, -0.00122401f, 0.02349055f, -0.02197483f, 0.02356872f, 
    -0.01817935f, -0.04338773f, 0.05360797f, -0.02944426f, -0.08298008f, 0.02412207f, -0.08372487f, -0.06854643f, 
    0.00829087f, 0.01418664f, -0.05340388f, -0.06325327f, 0.02960843f, 0.00166912f, 0.00260041f, 0.00415396f, 
    -0.04201100f, -0.03638684f, -0.00745753f, -0.07995222f, -0.05986648f, 0.00288112f, -0.02920802f, -0.02385474f, 
    -0.01399602f, 0.04236550f, -0.01498312f, -0.08043499f, -0.00783734f, 0.01885526f, 0.04081056f, -0.04631563f, 
    0.02107364f, 0.00935555f, -0.01803143f, -0.00919103f, -0.01768088f, -0.06241472f, -0.04877300f, -0.04055029f, 
    0.03349840f, -0.05628549f, -0.03680194f, -0.04445895f, -0.05991071f, -0.07082518f, -0.08184417f, -0.08949431f, 
    -0.07956303f, 0.02225899f, -0.00382498f, -0.00875092f, -0.01098347f, 0.04534658f, 0.01409210f, 0.00691243f, 
    -0.05231250f, -0.01575841f, -0.00943938f, -0.03683532f, 0.00894293f, 0.01151858f, -0.05432408f, -0.00070743f, 
    -0.03192877f, -0.01573240f, 0.05101426f, -0.04911733f, 0.03145672f, -0.00732271f, -0.08374282f, -0.01465020f, 
    -0.06199984f, -0.03456588f, -0.06207721f, 0.02799612f, 0.01151514f, -0.04306902f, -0.04750376f, -0.03138340f, 
    0.03005953f, -0.04741981f, -0.06213706f, -0.03616127f, 0.00332352f, -0.04061629f, 0.01535693f, 0.00446003f, 
    0.16263001f, 0.08777541f, -0.10056269f, -0.01252527f, -0.01500209f, -0.23221402f, 0.03445388f, 0.18500160f, 
    0.04753953f, -0.06829896f, -0.27353725f, -0.01629106f, 0.18072429f, 0.16045976f, 0.03417461f, 0.04970336f, 
    0.00458613f, 0.05410022f, 0.07424981f, -0.03088544f, 0.02296013f, 0.02342938f, -0.08413504f, -0.08005849f, 
    -0.15114133f, 0.06969024f, -0.02404927f, 0.02933394f, -0.00047528f, 0.05236411f, -0.09473433f, -0.05921814f, 
    -0.09987418f, 0.08751817f, 0.01213163f, -0.09230912f, 0.05841629f, -0.11070396f, -0.08955666f, 0.01456174f, 
    0.00085126f, 0.02786533f, 0.05392509f, 0.06319425f, -0.11109705f, 0.09538905f, 0.06724951f, 0.05798240f, 
    -0.10391220f, -0.09981716f, 0.11376827f, -0.16127895f, 0.03386975f, 0.00382074f, -0.14447774f, -0.11219105f, 
    -0.02668861f, -0.01868884f, -0.04349418f, 0.09168902f, 0.02773784f, 0.05624733f, -0.14810091f, 0.30081505f, 
    0.19637400f, -0.00069787f, 0.04545124f, -0.12174472f, -0.14245319f, -0.00416239f, 0.12370789f, -0.02392748f, 
    0.48742914f, -0.06877445f, 0.08084394f, 0.02172227f, -0.01475616f, 0.03780279f, 0.02815579f, 0.08637600f, 
    0.06313483f, -0.38984659f, -0.20146351f, -0.05169354f, -0.02921758f, 0.17390330f, 0.11528148f, -0.03081557f, 
    0.05171649f, -0.09339114f, -0.29012391f, 0.10218240f, 0.19496845f, 0.00798281f, -0.10322236f, 0.10319709f, 
    -0.16818555f, 0.01057813f, 0.24049629f, -0.23417664f, 0.27497810f, 0.05348043f, -0.06421185f, 0.02403800f, 
    0.07313013f, -0.04533268f, -0.04683416f, -0.12968929f, 0.23730093f, 0.10404573f, 0.11632165f, 0.02842726f, 
    0.03122887f, -0.03229851f, 0.11671459f, -0.04707180f, -0.09919911f, 0.19746719f, -0.01368599f, -0.06323209f, 
    0.13728344f, 0.07292828f, -0.05498158f, 0.09222186f, 0.01435282f, 0.09676318f, 0.02689338f, 0.02006643f, 
    -0.23494883f, 0.04108676f, 0.04952683f, 0.07624409f, 0.07527434f, 0.03593640f, -0.17706701f, 0.02281641f, 
    -0.16138385f, -0.13320374f, -0.04880762f, 0.20921896f, -0.01849826f, -0.06840660f, -0.03217233f, -0.06630886f, 
    0.08905661f, 0.01118153f, 0.08204927f, -0.28966212f, -0.08803025f, 0.09099156f, -0.06936086f, -0.03783789f, 
    -0.08502157f, -0.02319300f, 0.09970097f, -0.03778782f, -0.04453920f, -0.00309780f, -0.09907673f, -0.03007549f, 
    -0.05074025f, 0.13093166f, -0.13045752f, -0.05239232f, -0.06860382f, -0.12565455f, 0.01137757f, 0.00355656f, 
    -0.14076772f, 0.02046163f, -0.04264000f, 0.14813763f, -0.05732040f, -0.24708863f, -0.00955253f, -0.14369667f, 
    -0.11973515f, 0.00121983f, -0.02038968f, 0.00290092f, -0.03007858f, 0.09832898f, -0.26703182f, -0.15849440f, 
    0.09001045f, 0.04904724f, 0.01910325f, -0.03443316f, 0.03149531f, -0.14339335f, 0.06737950f, -0.01696223f, 
    -0.20065688f, -0.10135241f, 0.12548169f, 0.00589447f, -0.08418205f, 0.14200673f, -0.08643104f, 0.07409964f, 
    -0.01520734f, 0.08023094f, 0.08651900f, -0.11148157f, -0.00056073f, -0.06627398f, 0.00944224f, 0.02184475f, 
    0.05352972f, 0.01162916f, 0.05532585f, -0.05411720f, -0.06417618f, 0.08883881f, 0.07691377f, 0.08338413f, 
    -0.00990540f, 0.12608919f, -0.08497799f, -0.09817215f, 0.15867637f, -0.05585556f, 0.12269072f, 0.12076918f, 
    -0.03122666f, 0.15742891f, 0.36420709f, -0.11432791f, -0.06554206f, -0.11677167f, -0.02553038f, 0.07678162f, 
    0.07548175f, 0.09991410f, 0.08170323f, 0.01293039f, -0.02852179f, 0.07911777f, -0.03124449f, 0.22764204f, 
    -0.00363051f, -0.03846294f, -0.13462959f, 0.09435314f, -0.03194883f, 0.14215598f, 0.00038191f, 0.00104067f, 
    -0.02799079f, -0.11920809f, 0.07667887f, 0.03370354f, -0.07802717f, -0.24875304f, -0.09384147f, 0.11037403f, 
    0.17446996f, 0.08420005f, 0.09838374f, -0.10024616f, -0.12473135f, 0.04113175f, 0.17130208f, -0.13176550f, 
    -0.11612921f, 0.03746601f, -0.20647916f, 0.05584091f, -0.00811903f, 0.04610182f, 0.15127400f, 0.04928572f, 
    0.18919627f, 0.07150662f, -0.19277418f, 0.03734792f, -0.14642364f, 0.16558038f, -0.06106795f, 0.19398631f, 
    -0.13210845f, 0.00991092f, 0.06949112f, 0.09996048f, 0.03177929f, 0.01081335f, 0.00222495f, -0.04839276f, 
    0.18049696f, -0.03205992f, 0.12897135f, 0.05747607f, -0.03759848f, -0.02025533f, 0.02570145f, 0.08043981f, 
    0.07296748f, -0.35164598f, -0.07610283f, 0.06847432f, 0.07460945f, -0.04883296f, 0.06067814f, -0.00843664f, 
    0.06945720f, -0.09050705f, 0.12673049f, -0.02745477f, 0.07303857f, 0.01406978f, 0.08135747f, 0.03265912f, 
    -0.00458359f, 0.00096663f, 0.11501589f, 0.17724644f, -0.06957475f, -0.20885210f, -0.03884242f, -0.11014576f, 
    -0.02101415f, -0.05257156f, 0.14748272f, -0.03454038f, -0.33962893f, -0.03024146f, 0.04620637f, -0.04119660f, 
    0.00571484f, 0.10331558f, -0.05828945f, 0.05056563f, -0.08126892f, 0.14917113f, 0.07391375f, -0.17550996f, 
    0.03074819f, 0.11387715f, 0.00400391f, -0.02551708f, 0.23045725f, 0.08275328f, -0.27840620f, 0.05555397f, 
    -0.11084439f, 0.03692871f, 0.01514937f, 0.07769151f, -0.11585604f, 0.07809974f, -0.33354366f, 0.21409200f, 
    -0.10031453f, -0.07478716f, 0.05107356f, 0.10299646f, -0.03921195f, -0.08120637f, 0.25984672f, -0.00725216f, 
    0.22235341f, 0.13047615f, 0.07604173f, 0.04550323f, 0.03199284f, 0.05629434f, 0.03797708f, 0.12096437f, 
    0.06321810f, -0.01195299f, 0.08999416f, -0.09803665f, 0.17433293f, -0.07632136f, 0.05283391f, -0.00843205f, 
    0.09426624f, 0.05955235f, -0.01533215f, 0.09091149f, 0.02927303f, 0.00928572f, -0.04819582f, -0.01645930f, 
    -0.04550624f, -0.06385391f, 0.01078103f, -0.01474710f, -0.04581169f, -0.06917384f, -0.15366510f, 0.03108682f, 
    0.00927448f, -0.05528101f, 0.02029720f, -0.18904306f, -0.07034690f, 0.19556876f, 0.13888563f, -0.02792851f, 
    -0.12252919f, -0.12655598f, 0.04708112f, 0.07531830f, 0.00452513f, -0.02773227f, -0.14272046f, 0.30504751f, 
    0.18202592f, -0.09031507f, -0.09605122f, 0.04728964f, 0.05225734f, 0.18167752f, -0.02529288f, -0.33530608f, 
    -0.13437182f, 0.06908102f, 0.02939977f, -0.10587791f, 0.03841747f, 0.06198603f, -0.08309411f, -0.02435764f, 
    0.01806215f, 0.05396964f, 0.03818227f, 0.13173056f, -0.06551459f, -0.02906898f, 0.07001691f, -0.02345238f, 
    -0.18994226f, -0.19696286f, 0.04047204f, 0.06038703f, 0.08748298f, 0.03000922f, -0.17932299f, 0.04426878f, 
    0.14883997f, 0.30280939f, 0.09304002f, 0.05031736f, -0.04516000f, -0.01809510f, -0.09337851f, -0.02867638f, 
    -0.03587776f, -0.11601990f, 0.09705336f, -0.16321325f, 0.04734791f, -0.11416274f, -0.00162199f, 0.15962297f, 
    -0.08008984f, -0.11481401f, 0.11664762f, 0.01889827f, -0.05525673f, -0.07004729f, 0.16904876f, 0.02638467f, 
    0.04265163f, -0.02470625f, 0.10352484f, -0.14251435f, 0.03763062f, -0.15402956f, -0.05218117f, 0.04832002f, 
    -0.01831288f, 0.05387181f, 0.02040070f, -0.03703982f, 0.13276450f, 0.23682810f, -0.21138057f, -0.05884547f, 
    0.04548487f, 0.21256506f, -0.02569784f, -0.00797048f, 0.04746590f, 0.06997401f, -0.40852267f, 0.04777160f, 
    0.07858524f, 0.05667938f, 0.20920172f, -0.00566002f, 0.03648712f, -0.06427405f, -0.02827032f, 0.04228711f, 
    -0.05409168f, 0.01166402f, 0.06746098f, 0.06158086f, -0.11077080f, 0.13683316f, -0.01481351f, 0.01304374f, 
    -0.08869763f, -0.02351414f, 0.03118010f, 0.05000224f, 0.06835254f, 0.02849407f, 0.11779554f, -0.06179964f, 
    -0.16195153f, -0.07986031f, 0.13573708f, 0.22496630f, 0.08230194f, 0.00432966f, -0.16628204f, 0.10804133f, 
    -0.11894166f, 0.08257333f, -0.19223079f, -0.24429527f, -0.03276164f, 0.21717465f, 0.01190017f, -0.00183979f, 
    0.03557388f, -0.04328510f, -0.12010001f, 0.09688985f, 0.09896114f, -0.05468518f, 0.13238424f, 0.05570525f, 
    -0.05365703f, 0.14023501f, -0.04157028f, -0.15622456f, -0.01797082f, 0.07161041f, 0.10881121f, 0.09367789f, 
    -0.08404724f, -0.01747781f, 0.06444489f, 0.04888158f, -0.01897456f, 0.02630607f, -0.18130021f, 0.32207325f, 
    0.07993338f, -0.13622385f, -0.03467493f, 0.04123294f, -0.02468768f, 0.15997718f, -0.46062174f, -0.16737536f, 
    -0.20351107f, 0.00863883f, 0.02437662f, 0.01583248f, -0.21643075f, -0.00043640f, -0.06499119f, -0.22456054f, 
    0.11995281f, -0.06130482f, 0.09942507f, 0.01093089f, 0.00852487f, 0.01029638f, -0.01599329f, -0.05704501f, 
    -0.13149098f, -0.05493199f, -0.05388508f, -0.19746085f, 0.23000382f, -0.07055890f, 0.05284671f, 0.00244680f, 
    0.05344173f, 0.00918074f, 0.09699336f, 0.06868420f, -0.06470725f, 0.06614441f, -0.06937935f, -0.10090053f, 
    -0.02540076f, 0.04428026f, -0.03345636f, 0.08104002f, -0.02605706f, -0.04590352f, -0.05671712f, 0.13578907f, 
    0.04575689f, 0.05581908f, 0.13428013f, 0.16380756f, -0.07252064f, -0.34774262f, 0.12714572f, 0.11754934f, 
    -0.05221600f, 0.02447238f, -0.16811655f, -0.13660158f, 0.13187522f, 0.02090084f, 0.22047564f, 0.00883409f, 
    0.04015580f, 0.04738109f, -0.00545316f, -0.04254427f, 0.01976965f, 0.25414816f, 0.01309157f, -0.08901702f, 
    0.05173929f, -0.04533959f, -0.00034871f, 0.11544447f, 0.12061397f, -0.03841355f, -0.07043835f, 0.06936379f, 
    0.14081605f, 0.03611387f, -0.08848641f, 0.01668738f, 0.00494574f, 0.07309753f, -0.09480561f, -0.12102167f, 
    -0.11336371f, -0.02257772f, 0.07120598f, 0.10213803f, -0.06844462f, -0.15981291f, -0.12130520f, 0.09901080f, 
    -0.06314658f, -0.07684283f, 0.01575411f, 0.00682232f, 0.04597937f, -0.04919760f, -0.06185887f, 0.10084572f, 
    0.00970737f, -0.01055923f, -0.02128234f, 0.19705179f, -0.00375177f, 0.01066260f, 0.17014416f, 0.17697829f, 
    0.03711250f, 0.00326721f, -0.13681152f, -0.31221953f, -0.21231927f, 0.10647925f, 0.03247630f, 0.06066405f, 
    0.11510330f, -0.08477189f, -0.14509834f, -0.08808322f, 0.07944307f, -0.10695852f, 0.07621093f, -0.11678578f, 
    -0.01206248f, 0.13855316f, 0.03838238f, 0.05238096f, -0.01914440f, -0.10120638f, 0.07922261f, -0.08917311f, 
    0.02669911f, -0.07171740f, 0.00389168f, 0.06684691f, -0.01279818f, 0.05325286f, 0.08539709f, 0.12864287f, 
    -0.16061990f, -0.15126991f, -0.04635026f, -0.12365038f, 0.02866354f, 0.24003944f, -0.19181462f, -0.06600487f, 
    0.08629348f, -0.06145218f, 0.01675689f, -0.06726512f, -0.15793513f, 0.14711097f, 0.02785940f, 0.16329460f, 
    0.02702342f, -0.11925056f, 0.03116962f, -0.03367423f, 0.22664843f, -0.05233253f, 0.04150145f, -0.06465243f, 
    0.01101091f, 0.18304820f, -0.06349225f, -0.04902764f, 0.09364761f, 0.00442193f, -0.01638448f, 0.06767075f, 
    0.06251842f, -0.21929204f, -0.15117244f, -0.43728107f, 0.11120971f, 0.03986623f, -0.05123561f, -0.04403064f, 
    0.01118815f, -0.03743493f, 0.10040391f, 0.02948059f, -0.03433329f, 0.13561180f, 0.03125146f, -0.10849899f, 
    -0.05349487f, -0.02719689f, 0.00007282f, -0.20011161f, -0.12821443f, -0.25152692f, -0.20442484f, 0.06330094f, 
    -0.10800672f, 0.00986312f, 0.01035016f, 0.07085140f, 0.21255733f, 0.26087207f, -0.21534000f, -0.16886243f, 
    -0.00429367f, 0.02917004f, 0.00383044f, 0.01235299f, 0.09095957f, 0.53946799f, 0.15262966f, -0.18099718f, 
    -0.00729669f, 0.09420165f, 0.09962365f, 0.01749291f, -0.03110555f, 0.04811265f, 0.08547526f, 0.05824951f, 
    0.08877716f, -0.18311948f, 0.06183832f, 0.02485172f, -0.12328014f, 0.09320377f, -0.02813766f, -0.17622046f, 
    -0.04194071f, 0.05192968f, 0.01711750f, 0.13989419f, 0.05416711f, 0.05772909f, -0.01281927f, 0.04186481f, 
    -0.34476459f, -0.21075468f, -0.01453728f, 0.02979300f, 0.12392846f, -0.12487595f, -0.02610254f, -0.00235310f, 
    -0.10032373f, 0.11664441f, 0.08432680f, -0.04051479f, -0.12415351f, 0.08340304f, -0.11417650f, -0.05985330f, 
    -0.01727896f, 0.01271476f, -0.05112180f, 0.03155849f, 0.19920994f, 0.03485302f, 0.15358141f, 0.04238018f, 
    0.01477051f, -0.02518091f, -0.11455864f, 0.20705855f, -0.06322864f, -0.05914510f, 0.18092151f, 0.02657471f, 
    -0.08530599f, 0.06432721f, -0.07231497f, -0.11943310f, -0.02404860f, 0.02490691f, 0.22386158f, -0.10703073f, 
    0.10096953f, -0.06546380f, 0.12659763f, 0.06726904f, -0.12042277f, 0.03862659f, -0.00340103f, 0.02326344f, 
    -0.03086779f, 0.06811206f, -0.15778387f, 0.02645379f, 0.07137005f, 0.08126006f, -0.04104883f, 0.05680898f, 
    0.21944985f, -0.13390265f, 0.01810516f, -0.08632852f, -0.12133426f, 0.08004060f, -0.07732049f, -0.09462669f, 
    0.13859844f, 0.14892095f, 0.03633531f, 0.08779245f, 0.13507427f, 0.04595321f, 0.08834556f, -0.03757359f, 
    -0.00478515f, -0.01093287f, -0.04726921f, -0.01211636f, -0.00472803f, -0.00465478f, 0.00563515f, 0.02185960f, 
    0.01413783f, 0.00796241f, -0.01094564f, 0.04773300f, 0.02756010f, 0.05063313f, 0.00877262f, -0.05635349f, 
    -0.00387423f, -0.06365640f, -0.04410923f, -0.00751869f, -0.03380805f, 0.04205213f, -0.06727668f, 0.01784998f, 
    -0.01178947f, 0.01016103f, -0.03826459f, -0.01962851f, 0.03779641f, 0.00277318f, -0.00667100f, 0.04270609f, 
    -0.04022937f, -0.02663136f, 0.02950338f, 0.00976122f, -0.02062070f, -0.04448386f, 0.01359637f, -0.06016578f, 
    -0.04715867f, -0.05254582f, 0.02608009f, 0.03317754f, -0.02836317f, -0.05493589f, 0.04134029f, -0.00353624f, 
    0.02894792f, 0.00263317f, -0.02866191f, -0.03971387f, 0.02516541f, -0.07225543f, -0.01958390f, -0.05350086f, 
    -0.02408398f, 0.01681461f, 0.00150734f, -0.05980103f, -0.02950692f, 0.05315867f, 0.04003718f, -0.01517980f, 
    0.04385395f, 0.02690559f, -0.05051193f, 0.01961210f, 0.04981352f, -0.05150548f, 0.02565085f, 0.01468335f, 
    -0.05209587f, -0.01843197f, -0.05922545f, 0.02451703f, -0.04916959f, -0.06659964f, -0.03243833f, 0.03360338f, 
    0.04001346f, -0.04039790f, 0.05201523f, -0.00451686f, -0.04019769f, 0.04717756f, -0.03297864f, -0.03690775f, 
    -0.00128337f, -0.03085130f, 0.00113278f, -0.01199342f, -0.01825249f, 0.03771648f, 0.02273040f, 0.03474408f, 
    -0.02298435f, 0.04251994f, -0.02581772f, 0.04891559f, 0.03067246f, 0.01195244f, 0.03143829f, -0.00423213f, 
    0.02957518f, -0.02328635f, 0.05035517f, -0.06654414f, -0.03155144f, -0.02130562f, 0.00020173f, -0.02362217f, 
    0.05102173f, -0.01982588f, -0.04778341f, 0.03262401f, -0.03823952f, -0.01748044f, -0.01052687f, 0.05793916f, 
    0.03720039f, 0.02019216f, -0.06300007f, -0.05457238f, 0.02535358f, -0.04744903f, 0.04517275f, -0.00654270f, 
    0.03440474f, -0.05158300f, 0.00953268f, -0.04042728f, -0.00867261f, 0.04579649f, -0.06398652f, -0.06170319f, 
    -0.04633464f, 0.03345682f, 0.00536487f, -0.04692924f, 0.02800971f, -0.06372249f, 0.04319817f, -0.03251916f, 
    -0.03115892f, -0.03776075f, 0.01482419f, 0.04262386f, 0.01367165f, 0.00870437f, -0.01112978f, -0.00184645f, 
    0.02994484f, -0.03535307f, 0.03755387f, -0.05652597f, -0.06453158f, -0.06540100f, 0.01018964f, 0.01966445f, 
    0.02508487f, -0.05046099f, 0.04586645f, -0.03004944f, 0.03545130f, -0.04638207f, 0.02947543f, 0.04361207f, 
    0.04875707f, -0.00974171f, -0.00238230f, -0.00247973f, -0.04824622f, 0.00404137f, 0.02751650f, -0.04568526f, 
    0.04187878f, 0.01848624f, -0.00171083f, 0.03422444f, -0.02990255f, 0.01011849f, -0.03761047f, -0.05671110f, 
    0.01624209f, -0.06504989f, -0.00352798f, -0.01263262f, 0.04239964f, 0.05063217f, -0.04317746f, 0.03588187f, 
    -0.03042123f, -0.00890328f, -0.06635599f, 0.01607954f, 0.03255672f, 0.00914071f, -0.02857772f, -0.00258239f, 
    0.01743009f, -0.03398299f, 0.03712956f, -0.04638794f, -0.04168263f, -0.01207757f, -0.05302028f, -0.02598711f, 
    0.02173694f, -0.04323019f, -0.06915990f, -0.01764399f, -0.05383374f, -0.01403319f, -0.06682675f, 0.04628004f, 
    -0.04115098f, 0.00765714f, -0.05649422f, 0.01348565f, 0.03483452f, 0.02373840f, 0.04434504f, 0.00418967f, 
    0.03420740f, 0.01535578f, -0.00358618f, -0.01855778f, -0.05442844f, -0.01051788f, -0.01830926f, -0.03880958f, 
    -0.06622301f, 0.01170613f, -0.04165271f, 0.01264392f, -0.05280320f, 0.03169937f, -0.01966300f, 0.03601721f, 
    0.02003204f, -0.03663385f, 0.04819955f, 0.03169832f, 0.03633357f, -0.05679922f, 0.02131466f, -0.05000415f, 
    0.03655042f, 0.02281462f, -0.06237112f, -0.00079693f, -0.05378279f, -0.06591982f, 0.00311016f, 0.01589342f, 
    -0.00836050f, -0.01133108f, 0.00986408f, -0.00247116f, -0.00071968f, -0.06043255f, 0.01151417f, -0.02350562f, 
    0.04069651f, 0.00824193f, 0.00496027f, -0.04785415f, -0.00374044f, -0.06056525f, -0.00863388f, 0.01373007f, 
    0.02540539f, 0.02819715f, -0.02318014f, 0.02808904f, -0.01762687f, -0.01629588f, 0.01040054f, -0.05241078f, 
    -0.03566254f, 0.02532322f, 0.03181133f, -0.02019842f, -0.01249020f, 0.01608320f, -0.05455453f, -0.00712009f, 
    -0.23824340f, 0.10634951f, 0.04998420f, -0.11082608f, 0.11552674f, -0.07080402f, 0.11558843f, 0.10379502f, 
    -0.11198925f, 0.16700570f, 0.03517539f, 0.10657370f, -0.07601737f, -0.14444010f, -0.12292224f, 0.06504647f, 
    -0.01645963f, 0.07350436f, -0.08426088f, 0.12818462f, 0.10832944f, 0.07621630f, 0.13485833f, 0.02952773f, 
    0.11601966f, -0.00862141f, -0.07348051f, 0.35264987f, -0.10584574f, -0.13463011f, 0.01770280f, 0.04521240f, 
    -0.04631301f, -0.00190678f, -0.10753556f, -0.05712199f, 0.12514509f, 0.05813565f, 0.04416032f, 0.03896317f, 
    -0.15612103f, 0.06235492f, 0.11788266f, 0.10250442f, 0.12827739f, 0.05041651f, 0.19118623f, -0.01700399f, 
    0.11693553f, -0.01495295f, -0.27800506f, 0.08975685f, 0.04676942f, 0.00184412f, 0.01588475f, 0.05157756f, 
    -0.17561351f, -0.00402255f, -0.26084846f, -0.06021968f, 0.02292865f, 0.20496611f, 0.14402466f, -0.32957080f, 
    0.07208589f, 0.03162785f, -0.02721566f, 0.08197093f, -0.09102463f, -0.04800111f, 0.06462206f, 0.04101984f, 
    -0.23577562f, -0.02811967f, -0.08252284f, 0.17313322f, 0.21027936f, -0.07859769f, 0.15012817f, -0.11873936f, 
    -0.05839673f, 0.07092207f, -0.00001494f, -0.01533735f, 0.10043535f, 0.04847210f, -0.03569878f, 0.26501468f, 
    0.17624752f, 0.14668015f, -0.15741143f, -0.21089195f, 0.10916775f, 0.02802803f, -0.02722361f, 0.12682633f, 
    -0.02489031f, -0.15575595f, -0.09022939f, 0.09202424f, 0.04581071f, -0.13132164f, -0.03339285f, -0.22985269f, 
    0.03085502f, 0.05048037f, -0.03530009f, 0.14262551f, -0.04862822f, -0.09519169f, -0.18622087f, 0.05434396f, 
    0.09480661f, -0.00704386f, 0.03096901f, 0.08739689f, 0.13593970f, -0.15872821f, -0.16899960f, 0.06699014f, 
    -0.00658983f, -0.11240875f, -0.21032614f, -0.06564635f, -0.00264447f, 0.19833069f, -0.13516939f, -0.10132159f, 
    -0.08672293f, -0.03644988f, 0.02106095f, -0.04322511f, -0.04109430f, 0.11359867f, 0.07752557f, -0.07061063f, 
    0.04626538f, -0.02151462f, 0.15779555f, -0.14127487f, -0.22089140f, 0.07065064f, 0.03254791f, 0.05795716f, 
    0.02546102f, -0.04162911f, 0.01772799f, 0.19933821f, 0.09688169f, -0.03900140f, -0.14812876f, 0.08607266f, 
    -0.09263546f, -0.06225833f, -0.05872343f, 0.07782879f, -0.03119799f, 0.08685794f, 0.08350748f, -0.11172497f, 
    -0.15701725f, -0.02509084f, 0.27332842f, -0.08708575f, 0.05741256f, 0.12616387f, 0.01529857f, 0.05794443f, 
    0.09048257f, 0.01917224f, -0.04948944f, 0.03342952f, 0.09152514f, 0.13964994f, 0.07238902f, -0.03235560f, 
    0.09767320f, 0.13172707f, 0.09806296f, -0.06495204f, -0.05775907f, -0.05641780f, 0.04983345f, 0.12735824f, 
    -0.02052308f, -0.09008756f, 0.08112253f, -0.08625773f, 0.07755822f, 0.35210460f, 0.12056975f, 0.01855828f, 
    -0.09623680f, -0.05360691f, -0.06053872f, 0.08793857f, 0.02241688f, 0.04280774f, 0.02993083f, -0.04041830f, 
    0.03897626f, 0.08686963f, 0.03542006f, 0.16024144f, 0.00697521f, 0.06241568f, 0.06864476f, -0.37688339f, 
    -0.19180538f, 0.02914939f, -0.04262736f, 0.19089590f, 0.04835243f, -0.02506999f, -0.11373151f, 0.04761560f, 
    -0.26430735f, -0.03196905f, -0.19772105f, 0.01277168f, 0.06341507f, 0.13665876f, -0.11803557f, -0.06716582f, 
    0.06520617f, -0.29751346f, -0.05823574f, 0.04701942f, 0.07269650f, 0.20534961f, -0.08109482f, -0.04844975f, 
    -0.03015401f, -0.01721385f, -0.02262244f, 0.13274650f, -0.07865068f, 0.12455285f, 0.14529361f, 0.01754634f, 
    0.06257565f, -0.01529848f, 0.13406192f, 0.11059126f, 0.09184053f, -0.10842729f, 0.01609057f, 0.00299643f, 
    -0.00784266f, 0.07735256f, 0.02369962f, 0.13257828f, 0.19165093f, 0.04946319f, 0.13560657f, -0.16218072f, 
    -0.10623558f, -0.25207326f, 0.13075048f, 0.23104556f, 0.10703747f, -0.45865437f, 0.01728163f, 0.03951322f, 
    -0.15837140f, 0.20760748f, 0.15428948f, 0.07510077f, -0.07762802f, -0.00684676f, -0.10702349f, 0.15343088f, 
    -0.00011991f, -0.13613886f, -0.04079115f, -0.08937749f, -0.19525479f, 0.02771268f, -0.01811319f, -0.03284680f, 
    0.17109010f, 0.00277829f, 0.00209578f, -0.00678480f, 0.03659796f, -0.11795170f, 0.17042327f, -0.02206887f, 
    -0.00105498f, 0.00291925f, -0.01345503f, -0.01404394f, 0.02948227f, -0.02588351f, -0.01608085f, -0.00862732f, 
    -0.03275603f, 0.04535077f, -0.04108968f, -0.01078558f, -0.04132931f, -0.04397311f, -0.04852126f, -0.05607950f, 
    0.01369703f, 0.00772364f, -0.05781015f, 0.05273097f, -0.06442852f, 0.04325200f, 0.00965825f, 0.04927533f, 
    0.03551028f, 0.00547497f, 0.01543222f, 0.01339974f, 0.00514109f, -0.03624967f, -0.03808925f, 0.03841834f, 
    -0.01184460f, 0.01333744f, -0.04116458f, -0.00004965f, 0.01885705f, -0.02845347f, -0.03940460f, -0.00837518f, 
    -0.05427681f, 0.04925708f, -0.04183339f, -0.05349425f, 0.01042520f, 0.03360244f, 0.01428016f, -0.05573751f, 
    0.02288698f, -0.00928602f, -0.01053806f, -0.05917355f, 0.03967782f, -0.01833597f, -0.05315029f, 0.04322301f, 
    -0.00374009f, 0.05448522f, -0.06658164f, -0.05378725f, -0.02124817f, 0.01184550f, -0.02065415f, -0.01514205f, 
    0.01316434f, 0.02065479f, -0.06164114f, -0.00803796f, 0.01970200f, -0.05509316f, -0.06265232f, -0.00711044f, 
    -0.01888021f, -0.05323948f, -0.03523390f, 0.03252268f, -0.04869366f, -0.02327950f, -0.06589613f, 0.05116414f, 
    -0.05861418f, 0.03836922f, 0.01948937f, -0.01869549f, -0.03706832f, -0.04670789f, 0.05425850f, 0.01295050f, 
    0.02444684f, 0.03912278f, 0.02542122f, 0.04997141f, 0.04264102f, -0.00932324f, -0.02830476f, 0.04878744f, 
    0.02396711f, -0.05026044f, -0.02221830f, -0.04658652f, -0.01801901f, -0.05593663f, -0.00319309f, -0.06188647f, 
    -0.04982139f, 0.01657643f, -0.00777605f, -0.00193177f, 0.02021633f, -0.03411243f, 0.02885452f, -0.02811912f, 
    0.00610742f, -0.04542015f, -0.03407395f, -0.05447746f, 0.00108951f, 0.00506953f, 0.02616655f, 0.01633393f, 
    0.03005784f, -0.06268376f, 0.00017266f, 0.01948678f, 0.03703115f, 0.01273011f, -0.05995848f, 0.04521684f, 
    0.04318201f, 0.04444136f, -0.00423576f, 0.01992648f, -0.03061398f, -0.04082739f, -0.03025364f, 0.01728685f, 
    -0.03212437f, -0.05381512f, -0.04024447f, -0.02218317f, 0.01098804f, -0.05357089f, 0.02212082f, 0.01341093f, 
    0.03602064f, 0.02675570f, -0.03020441f, -0.03137061f, 0.02180858f, 0.01895009f, 0.05094152f, 0.01787822f, 
    -0.00779334f, -0.04889502f, -0.03923537f, -0.06435538f, 0.02780521f, -0.03458120f, -0.04267354f, -0.03206103f, 
    -0.02073280f, -0.00894762f, -0.02301196f, -0.00142953f, 0.03735412f, -0.06540717f, 0.00119247f, -0.06505390f, 
    0.04332532f, -0.04759067f, 0.04706088f, 0.04656846f, 0.00146657f, -0.01721754f, 0.00978946f, 0.01662519f, 
    0.02118749f, -0.01367793f, -0.02877367f, 0.03105492f, -0.04989095f, -0.04750030f, -0.01475049f, 0.01374887f, 
    -0.05492345f, -0.05884856f, -0.01838126f, 0.02756870f, 0.03301606f, -0.01500959f, 0.01821980f, -0.02208226f, 
    -0.03195095f, 0.01526060f, -0.01145385f, -0.00418843f, -0.01767723f, -0.05299180f, -0.03752797f, -0.04498363f, 
    -0.05400311f, 0.03001173f, -0.06246585f, 0.00834477f, 0.01289509f, -0.03715785f, -0.02675011f, 0.00705417f, 
    -0.02990796f, -0.03176922f, -0.04086892f, 0.02673138f, -0.02932768f, -0.05758016f, 0.00777252f, -0.02025001f, 
    0.04394915f, 0.00164953f, 0.02439114f, 0.01847082f, 0.02046202f, -0.01673405f, -0.02240430f, 0.01522204f, 
    -0.02475040f, -0.02535773f, 0.04083353f, -0.04089482f, -0.04830379f, -0.03396178f, 0.00926895f, 0.03022811f, 
    -0.02773086f, -0.03020865f, -0.04731281f, 0.03013070f, -0.00549655f, -0.04676710f, 0.02015917f, -0.02777430f, 
    0.05058761f, -0.02548946f, 0.04799899f, 0.00164295f, 0.04536159f, 0.00011002f, -0.01582565f, -0.05195450f, 
    0.02823001f, -0.03114605f, 0.01877827f, -0.03255887f, -0.05394237f, -0.04213418f, 0.01819703f, 0.02320727f, 
    -0.00245671f, -0.04220781f, -0.05206573f, -0.00091626f, -0.01073860f, 0.04578024f, -0.05794035f, -0.06208228f, 
    0.02091857f, 0.02647751f, -0.05630559f, 0.03492643f, 0.03402321f, 0.01033260f, -0.04213888f, 0.04566073f, 
    0.04542292f, -0.02623366f, 0.00230362f, 0.02362514f, 0.03322692f, 0.04693960f, 0.02810545f, 0.03067629f, 
    -0.02276421f, 0.01277285f, -0.00168133f, 0.00246853f, 0.00641894f, -0.00701836f, -0.02173950f, -0.04855487f, 
    -0.08822241f, 0.15086509f, 0.04140270f, -0.00980436f, -0.08090103f, -0.00735198f, 0.06923334f, -0.04730191f, 
    0.00075212f, -0.00466568f, 0.00708483f, -0.05188839f, -0.00414394f, 0.19975820f, -0.01392761f, -0.08920638f, 
    0.02252622f, -0.07881270f, -0.00033436f, 0.04653382f, -0.06502188f, -0.08958998f, -0.05315797f, -0.18090492f, 
    0.05569845f, -0.01114973f, 0.03721197f, -0.00012788f, 0.02447346f, 0.10904916f, 0.01337941f, 0.06591390f, 
    0.10748746f, 0.02104709f, -0.03743271f, -0.06518568f, 0.14130072f, -0.16002813f, -0.18779472f, 0.14975287f, 
    0.05955920f, 0.02073930f, 0.02677834f, -0.05373533f, 0.03183573f, -0.07782163f, 0.02757218f, 0.15107051f, 
    -0.06995805f, -0.12028474f, 0.06694636f, -0.06409875f, 0.06095545f, -0.01530381f, 0.20971210f, -0.04223310f, 
    -0.03769730f, -0.03086310f, 0.10235433f, 0.05826863f, -0.00148314f, 0.05868094f, -0.16788073f, -0.05093989f, 
    0.26677096f, -0.14311829f, 0.05845581f, -0.21541634f, -0.13733286f, -0.18961681f, 0.13723113f, 0.05492852f, 
    -0.10701888f, 0.18623140f, -0.17318183f, -0.01040490f, 0.04603667f, 0.03731415f, 0.02691445f, -0.01897727f, 
    0.13960363f, 0.00894114f, 0.10555550f, -0.10913537f, -0.04932730f, 0.05411221f, 0.01467635f, -0.01985317f, 
    -0.17569534f, -0.19389342f, 0.08533011f, 0.00004007f, 0.01186437f, -0.03660262f, -0.07696222f, 0.03894977f, 
    -0.04251165f, -0.07915884f, 0.19591887f, 0.11440305f, 0.13382772f, -0.03809754f, 0.02895009f, 0.13483289f, 
    0.04435961f, -0.00282740f, 0.10762477f, -0.09462868f, 0.03542454f, 0.05015248f, -0.01564192f, -0.00847963f, 
    0.09641773f, -0.04642321f, 0.12282802f, 0.01196485f, -0.12628792f, -0.15149996f, -0.09805647f, -0.22485258f, 
    0.16843666f, 0.02468748f, -0.17526236f, 0.05964903f, 0.04695438f, 0.03664759f, -0.04003902f, -0.06173063f, 
    -0.21287012f, 0.01987845f, 0.09536125f, 0.02804216f, 0.18983786f, -0.02444572f, -0.16829942f, -0.06136404f, 
    0.01940170f, -0.03343395f, 0.03441799f, 0.02104662f, -0.05604489f, -0.00446069f, -0.15991090f, -0.16905801f, 
    0.21692194f, -0.00987417f, 0.22787653f, -0.00300256f, -0.08504353f, 0.07456484f, -0.23837952f, 0.01848412f, 
    0.22043912f, 0.02613601f, 0.17899804f, 0.09351127f, -0.07690619f, 0.05037668f, -0.01859259f, 0.01290719f, 
    0.00807233f, 0.06040334f, -0.10658598f, -0.08579992f, 0.20068228f, 0.03191249f, -0.04807311f, 0.14833121f, 
    -0.02632356f, -0.04913383f, -0.04233506f, -0.10217019f, 0.07240965f, 0.25593916f, 0.10772266f, 0.07304888f, 
    -0.05542196f, -0.04558558f, -0.01047703f, -0.11388444f, -0.09774111f, -0.09918052f, 0.18615215f, -0.24952333f, 
    0.30357942f, 0.02078740f, -0.08100418f, 0.09365190f, 0.13097593f, 0.04172882f, -0.04401867f, -0.01604548f, 
    -0.14876892f, -0.07291821f, 0.14022590f, -0.04638463f, 0.02661127f, 0.16782908f, -0.03149178f, -0.05347342f, 
    -0.11016749f, 0.00515700f, -0.07915370f, -0.16539480f, -0.08304752f, -0.01114801f, 0.02058515f, -0.03413766f, 
    0.16907425f, -0.10876089f, 0.09006348f, -0.01935072f, -0.08711028f, -0.02016957f, -0.03027627f, -0.03203142f, 
    0.07461704f, 0.12406400f, 0.00328461f, -0.05347471f, -0.02613261f, 0.12366486f, -0.04373264f, 0.08105636f, 
    -0.01740842f, 0.11832767f, 0.21165788f, 0.17866106f, -0.06979184f, -0.04169207f, -0.03773539f, 0.06160215f, 
    0.06723464f, 0.15524173f, -0.02488877f, 0.09438060f, 0.14100528f, 0.01615185f, 0.12144430f, 0.06543316f, 
    -0.03611968f, -0.11231674f, 0.07843941f, -0.05302533f, 0.02960125f, 0.04121948f, -0.03014420f, -0.10938749f, 
    0.07811208f, -0.15192768f, 0.03582648f, -0.04950299f, 0.01326117f, -0.01814584f, 0.03414421f, 0.10559123f, 
    0.08508715f, 0.00930062f, 0.05088165f, -0.00148898f, -0.12511969f, 0.11004325f, 0.37995660f, 0.07518279f, 
    -0.07817190f, -0.04617130f, -0.16641158f, 0.13078663f, 0.01040344f, 0.02376948f, 0.04949661f, 0.04664930f, 
    0.02769922f, -0.08502842f, 0.01157514f, -0.14723276f, 0.08259456f, -0.09170333f, 0.10677262f, 0.17234126f, 
    -0.01732104f, -0.11496367f, 0.03052954f, 0.04925703f, 0.06081268f, 0.00139121f, 0.03476466f, -0.01863707f, 
    0.03485157f, -0.10822808f, -0.06223077f, 0.09149779f, 0.11372158f, 0.00649225f, 0.14919195f, -0.09774908f, 
    0.04685086f, 0.23874478f, 0.17977266f, 0.14098825f, -0.00128350f, 0.04435764f, -0.17872910f, 0.00223626f, 
    0.04914518f, 0.12629908f, 0.19589998f, -0.01418217f, -0.23282078f, -0.04705216f, -0.07820010f, -0.00019632f, 
    0.12503815f, -0.12304075f, -0.10344998f, -0.07565587f, -0.19334228f, -0.01110520f, 0.13518816f, -0.06812293f, 
    0.03361809f, 0.02904395f, -0.22776403f, 0.03535430f, 0.01972072f, 0.17406312f, -0.04522426f, 0.05398277f, 
    -0.07866957f, -0.09715258f, 0.04565884f, 0.13669609f, 0.09498880f, -0.60416776f, -0.16106887f, 0.10454126f, 
    -0.01134504f, -0.01695894f, 0.06166676f, -0.00406240f, -0.02490680f, 0.24627031f, 0.14792015f, -0.04841534f, 
    -0.19455980f, -0.00544672f, -0.03266331f, -0.10886334f, 0.22353087f, 0.16838346f, 0.03786257f, -0.15098391f, 
    0.18656988f, -0.16445607f, 0.04818876f, 0.00153793f, -0.03502273f, 0.01819945f, 0.00962014f, 0.08428549f, 
    -0.26688397f, 0.07068373f, -0.06701317f, -0.08129100f, -0.10330587f, 0.04123909f, -0.03640082f, 0.09249896f, 
    0.02383924f, -0.06588975f, -0.08246230f, -0.16325520f, 0.07024574f, -0.08994418f, 0.09015325f, 0.03751590f, 
    0.10330875f, -0.03569581f, -0.20283262f, -0.11663409f, 0.18765040f, 0.11735658f, -0.16431680f, -0.04754897f, 
    -0.18958281f, 0.06635387f, 0.07824508f, 0.41044137f, 0.00447511f, 0.08567151f, -0.06218624f, 0.02772516f, 
    0.00755126f, -0.04250361f, 0.15351911f, -0.01390754f, -0.17006588f, 0.06553868f, -0.15559618f, 0.01759785f, 
    -0.05673308f, -0.10143735f, 0.03800680f, 0.08506614f, -0.22206865f, -0.12930697f, 0.06851265f, -0.16254354f, 
    0.06513507f, -0.09019212f, -0.18056527f, 0.20136201f, 0.14750555f, 0.00530469f, -0.19528154f, 0.06581791f, 
    -0.17454697f, -0.03921823f, 0.04717563f, -0.06070710f, 0.11419071f, -0.02042493f, 0.01909848f, -0.03873264f, 
    -0.10295210f, -0.17784686f, -0.08994226f, -0.02641920f, 0.15239774f, 0.05190279f, -0.06639907f, -0.05422125f, 
    0.26710564f, -0.16479971f, -0.04266281f, 0.00905069f, -0.05185530f, -0.12605195f, -0.00562682f, 0.13055293f, 
    0.16235057f, -0.01554230f, -0.18953006f, 0.30593076f, 0.12695229f, -0.03062628f, -0.16451527f, -0.22610344f, 
    0.04369748f, 0.08794350f, -0.15957022f, -0.05767890f, 0.28372991f, 0.09193204f, 0.00910412f, -0.00896804f, 
    -0.10074086f, -0.18968560f, 0.01305694f, -0.05369393f, 0.06799272f, 0.35288066f, 0.05901642f, -0.02507523f, 
    -0.04413076f, -0.12569635f, -0.03483881f, -0.16887586f, -0.12100583f, -0.22521509f, 0.02510500f, -0.01964314f, 
    -0.02693434f, -0.04023975f, 0.01981193f, 0.26275587f, 0.13373084f, -0.05505809f, -0.30171174f, 0.04139028f, 
    0.06149985f, -0.03865888f, -0.06486193f, -0.14739545f, 0.11860123f, 0.15017304f, 0.07200927f, 0.10540458f, 
    0.14089757f, 0.08260416f, -0.09956860f, -0.13119924f, 0.21094300f, -0.00728630f, -0.02342599f, 0.07349736f, 
    -0.10236249f, -0.18383951f, -0.03510476f, 0.04233556f, 0.12080151f, 0.09453487f, -0.00717664f, -0.07077675f, 
    0.13824441f, -0.12155572f, 0.15888484f, -0.14327398f, 0.13197778f, 0.09580033f, -0.10259087f, -0.17568143f, 
    0.11559737f, 0.42316264f, 0.06027170f, 0.05283104f, -0.05313874f, -0.13403766f, 0.00477722f, 0.11887076f, 
    0.01747142f, 0.13856633f, -0.03522737f, 0.19712648f, -0.15738630f, -0.02934528f, 0.04193805f, -0.05001842f, 
    -0.01179268f, -0.00737587f, -0.13353564f, -0.12049646f, -0.10025515f, 0.14143072f, 0.19249168f, -0.07365190f, 
    0.02083024f, -0.13466324f, 0.04005175f, -0.08684183f, 0.02812188f, 0.13451524f, 0.08541166f, -0.01657864f, 
    -0.06087130f, -0.01162325f, 0.13815437f, -0.03073027f, 0.10008271f, 0.15948033f, 0.03863078f, -0.26458412f, 
    0.16559793f, -0.10905583f, 0.00446561f, 0.03060847f, -0.05045530f, 0.07384756f, 0.06747616f, 0.15572183f, 
    -0.10466183f, -0.00019087f, -0.13829575f, -0.09349856f, 0.01774556f, -0.07799850f, -0.22508429f, 0.25523108f, 
    0.24962683f, 0.19834173f, -0.00338382f, -0.15716766f, -0.06307822f, 0.08539103f, -0.01587224f, -0.13153692f, 
    0.17727146f, 0.00163568f, 0.06840796f, 0.05930475f, 0.06845146f, 0.04704037f, -0.13345583f, -0.04514453f, 
    -0.15736625f, 0.07647731f, 0.12120657f, 0.05567748f, 0.01992947f, 0.12581721f, 0.10052069f, -0.12336718f, 
    0.03092441f, 0.14656776f, 0.10396528f, 0.04713490f, -0.12908408f, 0.03537976f, 0.03332017f, 0.03342802f, 
    0.06712820f, -0.04484352f, -0.10133388f, 0.01344713f, -0.00117734f, 0.08813200f, -0.13208628f, 0.04933516f, 
    -0.04936435f, 0.04949665f, -0.02758541f, -0.01141331f, 0.30592728f, -0.00652784f, 0.01316797f, -0.03626664f, 
    0.03934282f, 0.08737712f, 0.09484118f, 0.00024063f, 0.07200609f, -0.19861419f, -0.14366731f, -0.00432244f, 
    -0.10448270f, 0.00863054f, -0.13252704f, -0.13995780f, 0.02044085f, -0.16964248f, 0.14871010f, -0.04363729f, 
    0.11634377f, 0.13882226f, 0.02034450f, 0.02310693f, 0.04949733f, 0.13086464f, 0.02358684f, 0.16755545f, 
    -0.16909581f, -0.11071891f, 0.07654975f, 0.08296732f, 0.13517861f, 0.00480769f, -0.11349114f, -0.17323746f, 
    0.11193683f, -0.29177055f, 0.10116591f, 0.03471018f, -0.09714951f, 0.09779788f, 0.04190737f, 0.08620165f, 
    0.11233094f, -0.16760212f, -0.02403505f, 0.04737773f, -0.06763212f, 0.08976548f, -0.05742442f, -0.03955160f, 
    0.05618591f, 0.10252529f, 0.00740370f, -0.00259693f, -0.07423564f, 0.02723172f, -0.02461047f, 0.07242334f, 
    -0.08069316f, 0.02689550f, -0.13288781f, -0.15938954f, -0.14227536f, -0.04359450f, -0.00665477f, 0.08613347f, 
    -0.01867723f, 0.03056039f, 0.05417897f, 0.08837914f, 0.25101388f, -0.05549341f, -0.03706734f, 0.05791938f, 
    0.00917454f, 0.05698620f, 0.06196589f, 0.04391460f, 0.04721910f, 0.34324792f, 0.13644803f, -0.03066780f, 
    -0.05797001f, -0.03233300f, 0.15697247f, 0.02815811f, -0.07355268f, -0.06177052f, 0.04871703f, 0.15336555f, 
    -0.16506743f, -0.06585719f, 0.00446374f, 0.08130219f, 0.07198005f, 0.05652168f, 0.08652551f, -0.18147098f, 
    0.10157532f, 0.09468092f, 0.10751240f, 0.00245283f, 0.10917760f, 0.14256471f, 0.05713069f, 0.11794502f, 
    -0.07515367f, -0.03013737f, -0.04440109f, 0.01091356f, 0.07678786f, -0.06200980f, -0.13003954f, -0.31608030f, 
    -0.01425451f, 0.05146251f, -0.20669830f, -0.04702404f, -0.06397473f, 0.10204446f, 0.06833699f, 0.04661730f, 
    -0.12707418f, -0.01854074f, -0.05396660f, 0.08713692f, -0.08656590f, -0.12631299f, 0.10066439f, 0.00014737f, 
    0.14693393f, 0.11610748f, -0.12346753f, 0.19401583f, 0.09654945f, -0.25885731f, -0.08339062f, 0.05990105f, 
    0.00330317f, -0.08150904f, 0.11174604f, -0.15338074f, 0.08672120f, 0.09677549f, -0.18154098f, 0.06774085f, 
    0.06989870f, -0.05494144f, -0.18610993f, 0.02122007f, -0.06719556f, -0.22380520f, -0.16871274f, -0.12289439f, 
    -0.20223065f, 0.07100946f, -0.12979180f, -0.17550434f, -0.07146605f, -0.08988495f, 0.19416299f, 0.13312301f, 
    0.00396086f, 0.20776102f, -0.04805595f, 0.06528601f, -0.06025070f, -0.08554611f, 0.08861712f, 0.07504023f, 
    0.11055595f, -0.03415811f, 0.10121154f, -0.04399305f, 0.00392645f, -0.06533897f, 0.07829987f, 0.02046837f, 
    0.09075782f, 0.05368112f, 0.11437905f, 0.18328357f, -0.05799292f, 0.05265066f, -0.14625773f, 0.00480229f, 
    0.02604798f, -0.25409144f, 0.19551539f, -0.14076985f, 0.14820002f, 0.03241263f, 0.09961236f, -0.08778352f, 
    -0.04430673f, -0.01096264f, 0.18179639f, -0.01735916f, 0.08189224f, -0.03169695f, -0.00918492f, -0.01416792f, 
    0.12153331f, 0.08397360f, 0.09455726f, -0.17244270f, 0.12907253f, 0.16975603f, -0.13155271f, 0.02321848f, 
    -0.11215059f, 0.03331873f, 0.08804631f, -0.03717051f, 0.05496319f, -0.03459906f, 0.08046168f, 0.04633730f, 
    0.00050711f, -0.01495561f, -0.03480241f, 0.01685463f, 0.10082262f, 0.06554186f, 0.13221164f, -0.14818591f, 
    -0.01437046f, -0.11946351f, 0.09258781f, -0.17511243f, -0.01452464f, -0.01386590f, 0.22216687f, -0.10339257f, 
    -0.15586631f, 0.00476659f, 0.03161436f, 0.02730424f, 0.05680418f, 0.05378466f, 0.00345239f, 0.17064127f, 
    -0.29616228f, 0.11602402f, 0.06988231f, 0.02942984f, -0.07420241f, -0.00499790f, 0.19790830f, 0.09463497f, 
    0.02346280f, -0.04773590f, 0.02962708f, -0.06364754f, -0.03200630f, 0.02177932f, 0.03583369f, -0.02471953f, 
    0.04833179f, 0.02040094f, 0.00989568f, 0.02413255f, 0.01919941f, 0.00601696f, 0.04275884f, -0.06557822f, 
    -0.00766637f, 0.04950937f, -0.06027023f, 0.04903653f, 0.04458097f, 0.01931600f, 0.01988776f, -0.01284302f, 
    -0.06044611f, -0.00381974f, -0.04156442f, 0.04228995f, -0.02655687f, 0.03046279f, -0.01214968f, -0.05974069f, 
    0.05845994f, 0.01274504f, 0.03664574f, -0.00288281f, -0.01478841f, 0.02068061f, -0.04465533f, -0.02433504f, 
    -0.04050571f, 0.00947890f, -0.05421102f, 0.03060243f, -0.00485391f, -0.00535358f, 0.01217179f, 0.01093338f, 
    -0.05721588f, -0.02097928f, 0.00958985f, -0.04836369f, -0.00486734f, 0.04295617f, -0.04134069f, -0.04003704f, 
    0.03074712f, -0.02783242f, -0.00551550f, -0.03113580f, 0.05024431f, -0.01863968f, 0.03685104f, 0.01178648f, 
    -0.04614417f, 0.04852395f, 0.03787164f, -0.03465688f, 0.00540314f, 0.02381401f, 0.03720076f, 0.03527298f, 
    0.04217725f, -0.03112419f, -0.05162400f, 0.03837825f, 0.05164015f, 0.00725677f, -0.05832207f, 0.04077457f, 
    0.01772723f, -0.03009506f, 0.02533384f, -0.04560967f, 0.00100429f, -0.05886426f, -0.04846377f, -0.03167145f, 
    0.01668306f, -0.01374102f, -0.00004602f, -0.00795349f, -0.01314641f, -0.03538526f, -0.01724265f, -0.05916069f, 
    0.00863974f, -0.00103564f, 0.03100450f, -0.01397530f, 0.03422815f, -0.05889149f, 0.02322241f, -0.00412490f, 
    0.01126921f, -0.06443481f, 0.01193892f, 0.05633821f, -0.05934632f, 0.03198760f, -0.06185478f, -0.03204416f, 
    0.00754678f, 0.04477642f, -0.01601647f, -0.00023985f, 0.03460442f, -0.03195000f, -0.00965176f, -0.00082275f, 
    -0.06282193f, -0.05032943f, 0.03554958f, -0.02451648f, 0.01022902f, -0.01319261f, 0.03706399f, -0.01557899f, 
    -0.02022536f, -0.02024102f, 0.04096886f, -0.04748648f, -0.06271853f, 0.03970038f, -0.00402821f, 0.00283906f, 
    -0.04357478f, -0.03057979f, 0.01180007f, -0.02356105f, -0.05000377f, -0.05116271f, 0.04624607f, -0.00021131f, 
    -0.02466678f, 0.03561202f, -0.05614719f, 0.00584083f, -0.01946733f, -0.02579421f, 0.00616940f, 0.04594310f, 
    -0.00536655f, -0.01167829f, -0.05694012f, 0.04387640f, -0.01312710f, 0.03584810f, 0.03646604f, -0.04305992f, 
    -0.06268939f, -0.05854581f, -0.03818606f, -0.00774297f, -0.05903796f, 0.00124896f, 0.03319556f, -0.06539291f, 
    0.00316964f, -0.01687078f, -0.00519908f, -0.00517576f, 0.03602038f, 0.02023069f, -0.01835083f, -0.01082021f, 
    -0.05468945f, 0.02468442f, 0.03828422f, 0.04304239f, 0.01351286f, 0.00764828f, 0.04029822f, -0.06935567f, 
    -0.03918758f, -0.06752355f, -0.01820809f, 0.01549462f, -0.00307296f, -0.01027867f, -0.03315172f, -0.03630195f, 
    -0.02861257f, -0.03847200f, -0.00899626f, -0.06320397f, -0.02144835f, 0.05071161f, -0.01752240f, -0.01857771f, 
    0.00155629f, 0.03580581f, 0.02666325f, -0.05843103f, 0.03758179f, -0.04848439f, -0.04543349f, -0.04776768f, 
    0.02683982f, -0.04010478f, -0.00516142f, -0.05802466f, -0.01282643f, -0.02162610f, 0.00817604f, 0.03252389f, 
    0.04605912f, -0.05604434f, 0.00043517f, 0.00976865f, -0.03664219f, -0.05539210f, 0.02553604f, -0.04469660f, 
    0.03494155f, -0.02914236f, -0.02363470f, -0.00063462f, -0.02241109f, 0.00888105f, -0.01673407f, -0.00938766f, 
    -0.05840576f, -0.05899193f, -0.03548279f, -0.05727689f, -0.00383896f, 0.01507391f, -0.04094139f, -0.05172502f, 
    0.00074150f, -0.06345575f, 0.05385576f, -0.00885275f, 0.03859857f, -0.03964978f, 0.04345068f, -0.00360961f, 
    0.00161664f, 0.02720226f, -0.03392440f, -0.02525397f, -0.05256472f, 0.02627348f, 0.00074668f, 0.01718455f, 
    0.02686187f, 0.04700318f, -0.00621881f, -0.03378959f, -0.00392796f, -0.01342916f, 0.00818174f, 0.01453460f, 
    -0.05784470f, -0.01243455f, -0.00790345f, 0.01855448f, -0.00484392f, -0.01642554f, 0.02175030f, -0.01275248f, 
    0.06183510f, -0.05608119f, -0.01273336f, -0.03161245f, 0.03080619f, -0.02773851f, -0.04307135f, 0.04357884f, 
    -0.05418800f, 0.02135607f, -0.00846691f, 0.04282262f, -0.03474228f, -0.02636901f, -0.00876956f, -0.04624075f, 
    -0.02837692f, -0.16182406f, -0.08720211f, 0.10610666f, -0.00291843f, -0.14389181f, 0.24182968f, 0.14356077f, 
    -0.08101751f, 0.10469300f, 0.08170266f, -0.00854641f, 0.00056255f, 0.04892605f, 0.00349352f, 0.12127792f, 
    0.09711014f, 0.04283131f, -0.02742619f, 0.21536337f, -0.08146771f, 0.22992496f, 0.13912541f, -0.05162228f, 
    0.06298228f, -0.04371571f, -0.03781316f, 0.14379251f, 0.02453955f, -0.05085072f, 0.19825162f, 0.01505337f, 
    0.04770850f, -0.14546669f, -0.14081629f, 0.10256737f, 0.06934038f, 0.07440469f, -0.17073041f, 0.05352805f, 
    -0.00026304f, 0.21865089f, 0.16485646f, 0.00836882f, 0.03398208f, 0.30632567f, 0.28470296f, -0.18011402f, 
    -0.19196004f, 0.07733008f, 0.15501209f, -0.08671053f, -0.05201850f, -0.13835928f, -0.24021165f, -0.18612115f, 
    -0.38334179f, 0.19406505f, 0.13716643f, 0.13169746f, 0.23409280f, -0.03816147f, -0.06361765f, 0.00033626f, 
    -0.20864353f, -0.16165124f, -0.13052398f, 0.27972010f, -0.04260677f, -0.06477515f, 0.03008747f, -0.29462171f, 
    0.44450495f, 0.24333978f, -0.05521565f, -0.14390567f, -0.02351307f, 0.02124996f, 0.11265169f, 0.07973763f, 
    0.06172483f, 0.13337894f, -0.00530500f, -0.34973359f, 0.00493480f, 0.11662988f, -0.04563405f, 0.10909548f, 
    0.03628618f, 0.01434965f, -0.35759547f, -0.19881724f, 0.08975115f, 0.17460284f, -0.12564304f, 0.12286940f, 
    -0.27340183f, 0.17830035f, 0.07707889f, 0.00138060f, 0.13329741f, 0.10150050f, 0.22109216f, 0.16437690f, 
    0.09772592f, 0.16217437f, 0.14659773f, -0.06488273f, -0.01920344f, 0.16623913f, 0.09009750f, -0.02726404f, 
    0.15427358f, 0.03604865f, 0.09285346f, 0.07576023f, 0.06904697f, 0.01149777f, 0.13602500f, 0.08965737f, 
    -0.00287913f, -0.04777773f, -0.29272836f, 0.00376612f, 0.26801187f, 0.05740311f, -0.02493276f, -0.13593049f, 
    -0.27335152f, -0.13985036f, 0.07482848f, 0.00881080f, -0.01489227f, 0.11885528f, 0.01200581f, 0.05182400f, 
    -0.05954390f, -0.38141483f, 0.03576062f, 0.12416203f, 0.10072576f, 0.13355257f, -0.05078313f, -0.06181791f, 
    0.32895765f, -0.38827133f, 0.11564261f, -0.20601135f, -0.32059574f, 0.01010054f, 0.04055714f, 0.26448959f, 
    0.04467608f, -0.37368026f, 0.17037715f, 0.26530829f, 0.18226543f, -0.05443737f, 0.08567118f, -0.09432372f, 
    0.07931279f, 0.16263843f, -0.13397165f, -0.06384397f, 0.08483165f, 0.21020210f, -0.00373779f, -0.06119274f, 
    0.08960535f, 0.06437523f, -0.15365650f, 0.00360885f, -0.12617439f, 0.01058564f, 0.21025766f, -0.09253255f, 
    0.03133888f, 0.03350089f, -0.14846775f, -0.04005054f, 0.12575163f, -0.23803292f, -0.08782332f, 0.11316804f, 
    0.22764330f, -0.03905681f, 0.01318669f, 0.18480563f, 0.03185688f, 0.11466093f, -0.02567446f, -0.12381953f, 
    0.04516448f, 0.01724178f, 0.07059596f, -0.16671948f, -0.02531739f, 0.14333598f, -0.02279108f, 0.19243333f, 
    0.04189507f, -0.00385215f, 0.09940466f, 0.11663729f, 0.09700608f, -0.13436836f, 0.06145338f, -0.25735733f, 
    0.11893066f, -0.09732972f, -0.00748327f, 0.00749273f, 0.11030883f, 0.04575713f, -0.16725095f, 0.12933111f, 
    -0.03055421f, -0.00902290f, -0.04317530f, 0.11867809f, 0.09349951f, 0.02301150f, -0.00961034f, -0.39596504f, 
    -0.15042996f, 0.27107799f, 0.05112652f, 0.15283033f, -0.08892208f, -0.12984963f, -0.19629174f, 0.27906984f, 
    0.28645355f, 0.11090102f, 0.08281136f, 0.04925626f, -0.18908349f, 0.02056308f, 0.08289839f, 0.12231814f, 
    0.00370936f, -0.04036375f, 0.11603756f, 0.13107166f, 0.21012859f, -0.00266061f, 0.25792095f, 0.09142666f, 
    0.07325651f, -0.10718775f, -0.18893096f, 0.13881809f, -0.00036044f, -0.06617773f, -0.20975874f, 0.01928883f, 
    -0.02566498f, 0.03862540f, 0.21023510f, 0.25101650f, 0.09193787f, 0.02906415f, 0.19043288f, 0.02821228f, 
    0.15857393f, -0.03133256f, -0.09763377f, 0.12784398f, 0.10674141f, 0.09166844f, -0.02400861f, 0.04536034f, 
    -0.07496649f, 0.08632594f, 0.09764719f, -0.36927059f, -0.13153169f, -0.15608002f, -0.12870143f, 0.13536970f, 
    0.05855988f, -0.16976748f, 0.06903165f, -0.02807587f, 0.05184454f, 0.15877059f, 0.04255872f, -0.07274754f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.16805086f, 0.01081516f, 0.07836465f, 0.05400602f, 0.10469958f, 0.06332931f, -0.01976743f, -0.04212491f, 
    -0.04411981f, 0.09945929f, -0.03380844f, 0.04243957f, -0.03493384f, 0.05379711f, 0.07037809f, 0.01552945f, 
    -0.06041758f, -0.06582354f, 0.05520577f, 0.04441480f, 0.01962771f, 0.02908407f, 0.10720936f, 0.12361451f, 
    -0.05260668f, 0.15762848f, 0.03887542f, -0.00121657f, 0.04106124f, -0.00022312f, -0.06121541f, 0.08509507f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.12101667f, 0.07597416f, -0.00014421f, 0.06205917f, 0.12698612f, 0.15106820f, -0.15710224f, -0.08396520f, 
    0.01116122f, -0.15632947f, 0.03778771f, 0.08980962f, -0.00258668f, 0.08069625f, -0.07708041f, -0.07430533f, 
    -0.14778697f, 0.02421379f, -0.15800992f, -0.01026366f, 0.03793025f, 0.04095776f, -0.05484961f, -0.02555035f, 
    -0.09349556f, -0.11644059f, -0.15923536f, 0.01319470f, -0.17302309f, -0.06891161f, -0.16668282f, 0.03853562f, 
    -0.01651470f, 0.04035089f, 0.14013033f, 0.53124183f, 0.21387376f, -0.20281820f, -0.40950072f, -0.26983190f, 
    0.10198764f, 0.02999586f, 0.25719371f, 0.01761892f, -0.30109784f, 0.16600573f, 0.21148533f, 0.01010481f, 
    -0.47043046f, -0.15199652f, -0.20507845f, 0.21451710f, -0.01908814f, -0.13197567f, 0.24338408f, 0.12568296f, 
    -0.08740778f, 0.35883424f, 0.11942101f, -0.05011476f, -0.01562155f, -0.17229658f, 0.06552423f, 0.30946797f, 
    0.02166438f, -0.09215464f, -0.26952884f, 0.19466926f, -0.02154931f, -0.39694074f, -0.09199008f, -0.04715534f, 
    0.01114883f, 0.02726892f, 0.20083033f, -0.10867065f, 0.02116250f, 0.42123985f, 0.26845691f, -0.06920048f, 
    0.15971634f, 0.05268397f, -0.08863258f, -0.05595925f, 0.03508839f, -0.05931161f, 0.15118498f, -0.42074388f, 
    -0.08431085f, 0.28664684f, 0.13320450f, 0.03145623f, -0.25579324f, 0.01161322f, -0.05789679f, 0.16644073f, 
    -0.13909356f, -0.07339069f, -0.11667465f, -0.18583386f, -0.11464451f, -0.15902129f, 0.13710569f, 0.12849796f, 
    -0.07154311f, 0.10930434f, -0.09709767f, 0.00563853f, 0.05266317f, -0.16069838f, 0.00150686f, -0.01069695f, 
    -0.11578766f, -0.09805182f, -0.11307475f, -0.05930685f, 0.09164274f, -0.17752270f, -0.13082826f, 0.10743465f, 
    0.07858748f, 0.13002327f, 0.11371648f, -0.13701853f, -0.11455158f, -0.03703315f, 0.04493881f, -0.11301055f, 
    0.07988957f, 0.46224499f, 0.37248173f, 0.18725866f, -0.17080030f, 0.23974355f, 0.01932057f, -0.34915456f, 
    -0.10552438f, -0.38871169f, -0.22381978f, -0.07776530f, 0.20636021f, 0.26446587f, 0.38937902f, 0.17329547f, 
    -0.60449022f, 0.09395485f, 0.20072387f, -0.00310872f, 0.08427502f, -0.11643381f, 0.10562733f, 0.27852625f, 
    -0.01140933f, 0.17125754f, 0.01660578f, -0.03479718f, 0.21566978f, 0.28692067f, 0.05384766f, 0.17711532f, 
    -0.10480046f, 0.28545862f, 0.17956840f, -0.04433773f, 0.15502688f, -0.00666044f, -0.09951070f, -0.48350897f, 
    -0.13177207f, 0.48602062f, 0.35314935f, -0.06248276f, 0.12867507f, 0.19089621f, 0.25286812f, -0.15389778f, 
    -0.18076606f, -0.04718849f, 0.05497747f, 0.05441339f, 0.21530718f, -0.03129832f, 0.34191528f, -0.08675280f, 
    -0.09345052f, 0.20516315f, 0.14773236f, -0.23375101f, -0.26517832f, 0.27202600f, -0.15272222f, -0.20797934f, 
    -0.16304965f, -0.17777143f, -0.01302413f, -0.01519118f, 0.21640348f, 0.13347617f, -0.08770274f, 0.41149175f, 
    -0.14984670f, -0.26683003f, 0.07436734f, 0.08133936f, 0.29037896f, -0.05167083f, 0.08987908f, 0.16250312f, 
    0.16345875f, 0.08064592f, 0.36331910f, -0.00900548f, 0.15906934f, 0.15909091f, 0.06572802f, -0.07379341f, 
    0.02385736f, -0.16372205f, 0.14959152f, -0.13143654f, 0.00021776f, -0.13845217f, 0.11243895f, -0.01118868f, 
    -0.16953298f, 0.01714416f, -0.16453756f, 0.02491343f, 0.00915353f, -0.02307723f, -0.13874793f, -0.01872985f, 
    -0.05451794f, 0.02202260f, 0.04935900f, -0.13269351f, -0.11245061f, -0.13712530f, 0.09122381f, 0.08467655f, 
    0.12226850f, -0.03400589f, -0.14721183f, 0.03425803f, -0.11470953f, 0.05792203f, 0.00634524f, 0.09664272f, 
    -0.01044062f, -0.12371340f, 0.11837545f, 0.03957918f, -0.16180068f, -0.08096449f, 0.03692203f, -0.13955653f, 
    0.08435176f, -0.34503844f, 0.17741561f, -0.42224219f, -0.12663697f, 0.02687212f, 0.41326606f, 0.44916221f, 
    -0.09739185f, -0.28249794f, 0.05523597f, -0.07628980f, 0.26809999f, -0.03890767f, -0.12880102f, 0.10053240f, 
    0.26229301f, 0.02660786f, -0.36179674f, 0.39282086f, -0.06414679f, -0.01076419f, -0.01324220f, -0.00584192f, 
    -0.12109639f, 0.02734528f, 0.09141156f, 0.25062177f, 0.49527645f, -0.18736354f, 0.00888699f, 0.15069856f, 
    -0.09329507f, 0.02072017f, -0.08175513f, -0.39445451f, -0.02496012f, 0.08742604f, -0.00111668f, 0.03788978f, 
    0.15591782f, 0.51595563f, 0.23843484f, 0.06808119f, 0.27951470f, 0.02511974f, -0.19523253f, 0.41883555f, 
    0.27369383f, -0.14994624f, -0.11865068f, 0.30170646f, 0.03324375f, 0.15181349f, 0.20205970f, -0.20506066f, 
    -0.07691386f, 0.00879347f, -0.10828372f, 0.02265383f, -0.06644831f, -0.02180374f, -0.04975732f, -0.09448002f, 
    0.32579526f, -0.27193293f, -0.03393692f, 0.09120710f, 0.30122763f, 0.04924325f, 0.28757682f, 0.30760384f, 
    0.00775135f, -0.04588747f, 0.22333987f, 0.04030590f, -0.10030591f, -0.04539393f, 0.01785171f, -0.07315041f, 
    0.17447107f, -0.06798971f, -0.31598198f, -0.13798019f, -0.07751512f, 0.28248417f, 0.32933265f, 0.19332173f, 
    0.09930412f, 0.15220356f, 0.07921760f, 0.15820006f, 0.30047026f, -0.06979337f, -0.01448833f, 0.23862264f, 
    -0.15894417f, 0.13201316f, 0.31366715f, 0.05680302f, -0.14958525f, 0.12856744f, 0.12082240f, 0.09120233f, 
    -0.15193908f, -0.17749766f, -0.08957858f, -0.09053322f, 0.23494405f, 0.01146001f, 0.04179959f, -0.04949958f, 
    -0.13924372f, -0.15792368f, 0.12112382f, 0.00582315f, -0.05617677f, 0.07041607f, 0.16640291f, 0.10106588f, 
    0.12230279f, -0.23085777f, 0.05892835f, 0.17914829f, 0.22095495f, 0.03154645f, 0.04733068f, -0.10879955f, 
    0.26409134f, 0.22891347f, 0.26921222f, -0.28298411f, 0.00666849f, 0.10753288f, -0.09377727f, -0.02646417f, 
    -0.05459619f, -0.18563206f, -0.12486477f, -0.10925255f, -0.12744921f, -0.02824368f, 0.30912182f, 0.31888896f, 
    -0.51348877f, -0.05387248f, 0.26962766f, -0.03679281f, 0.07324141f, -0.35066220f, -0.27475485f, 0.10598212f, 
    -0.15560652f, 0.29309237f, 0.09888074f, 0.02141058f, 0.24114914f, 0.05183164f, -0.15989052f, -0.06019199f, 
    0.06025258f, 0.30854949f, -0.16688970f, -0.30080289f, -0.19345789f, 0.20737410f, 0.19778696f, -0.24282131f, 
    -0.14325263f, 0.22004071f, -0.30778146f, 0.01473344f, 0.10655252f, -0.23638561f, 0.02596023f, 0.30282664f, 
    -0.18988918f, -0.13361506f, 0.51321656f, -0.13358878f, 0.10750679f, -0.16152900f, 0.02613327f, -0.21272860f, 
    0.12771291f, -0.03272663f, 0.14047617f, -0.20326607f, -0.16780147f, 0.31053507f, 0.05339239f, 0.10198170f, 
    -0.14747328f, 0.00072680f, -0.17227532f, -0.04979121f, -0.15064110f, -0.12077908f, 0.12159755f, 0.15039578f, 
    0.16842024f, -0.03762970f, 0.09161313f, 0.06177238f, 0.15648134f, -0.05971485f, 0.01396820f, -0.15112564f, 
    0.14517319f, 0.08785289f, 0.09669541f, -0.09821510f, -0.16327013f, 0.16817111f, -0.14111762f, -0.08324692f, 
    -0.13680740f, -0.13518679f, -0.09517614f, -0.14099240f, 0.12464955f, -0.15460490f, 0.06771382f, -0.16985819f, 
    0.18771505f, 0.03438368f, -0.01997294f, -0.07634911f, -0.19976373f, -0.18419886f, 0.13305609f, -0.56437629f, 
    0.06874177f, 0.45128086f, -0.09635121f, 0.17101640f, 0.31363171f, 0.45394295f, 0.13275881f, 0.07834585f, 
    -0.28658676f, -0.09824636f, 0.02055550f, 0.01840711f, 0.06476504f, -0.15301691f, 0.10847840f, -0.52239108f, 
    -0.11389986f, 0.03112747f, 0.15186340f, -0.22820984f, -0.13772084f, 0.28458789f, 0.00540672f, -0.06483090f, 
    0.29208893f, 0.27328256f, 0.18096806f, -0.34887376f, 0.18224192f, 0.28979442f, 0.06042128f, 0.06466718f, 
    -0.15596512f, -0.01441437f, -0.04242766f, 0.00523871f, 0.00099385f, -0.07584683f, -0.06537312f, 0.38518271f, 
    0.12609524f, 0.15236877f, -0.33074409f, 0.49208415f, 0.01914987f, -0.48020551f, -0.05963565f, 0.18125702f, 
    0.09664584f, 0.12978499f, -0.07929084f, 0.24194856f, 0.20510706f, -0.16222119f, 0.06561346f, -0.24567375f, 
    -0.02526917f, -0.34575081f, -0.11016127f, -0.06667876f, -0.24950011f, -0.02770421f, 0.35056323f, -0.13525946f, 
    0.03144558f, 0.29613248f, 0.07106046f, 0.03416088f, 0.26532960f, 0.43726456f, 0.09907413f, -0.19710714f, 
    0.26673868f, -0.07707708f, -0.01870004f, 0.25534874f, -0.16030957f, 0.40860409f, 0.40873697f, -0.39939103f, 
    -0.08863114f, -0.35636097f, -0.07733560f, -0.02752607f, -0.27539662f, 0.19523396f, -0.05997097f, 0.14677383f, 
    -0.16990495f, 0.08186331f, 0.19713596f, -0.26693332f, -0.44703019f, 0.00272964f, 0.28391910f, -0.09837279f, 
    -0.11189429f, -0.08110233f, -0.12059293f, 0.08065911f, 0.44391376f, 0.17056400f, 0.16002789f, 0.03500040f, 
    -0.36110213f, -0.17695861f, -0.30644950f, 0.29310295f, 0.06988060f, 0.32560670f, 0.07790417f, 0.00431511f, 
    -0.09551741f, -0.32607096f, -0.12587519f, 0.33625492f, 0.28872839f, 0.26092535f, -0.16997507f, 0.08828779f, 
    0.37605649f, 0.03025501f, 0.02825475f, 0.12174859f, 0.14931828f, -0.29759666f, 0.25872430f, -0.37973487f, 
    -0.16579728f, 0.07263317f, -0.23283434f, -0.14561680f, 0.16622408f, 0.25936869f, 0.17795081f, -0.15318768f, 
    -0.08370855f, -0.11786279f, -0.50906068f, -0.39314854f, 0.11203924f, 0.26143464f, -0.23564628f, 0.25062332f, 
    -0.04970143f, -0.01628406f, 0.07043330f, 0.01209772f, -0.06132625f, 0.16651542f, -0.05968395f, 0.22910768f, 
    0.21952249f, -0.30650803f, -0.26984400f, 0.29808402f, 0.35185358f, -0.20965838f, -0.03116743f, 0.13716905f, 
    0.15863302f, 0.09039957f, 0.31497356f, 0.08310953f, -0.11600734f, 0.32566172f, 0.06544419f, -0.24796841f, 
    0.35113642f, -0.07410805f, -0.23348524f, 0.01938853f, 0.10846327f, 0.02769760f, 0.30486113f, 0.12058195f, 
    -0.13939169f, 0.22278160f, 0.15068898f, -0.03089385f, 0.04341048f, -0.12355684f, -0.02984015f, 0.22916593f, 
    -0.14757760f, 0.03761429f, -0.12308145f, -0.17193399f, 0.11081929f, -0.01188237f, 0.10909906f, -0.07559022f, 
    -0.06644897f, -0.10438088f, -0.08308092f, 0.13558096f, -0.14689410f, 0.00011067f, -0.14012125f, -0.15974078f, 
    0.00133326f, 0.02233701f, 0.11219434f, 0.13804820f, -0.07347030f, -0.08066618f, 0.02193207f, -0.01328648f, 
    -0.07827970f, -0.05668632f, -0.03961827f, -0.12886800f, -0.17367165f, -0.00657312f, -0.01477477f, 0.06858747f, 
    -0.04642357f, 0.02813448f, 0.07201405f, -0.01871698f, -0.16415776f, 0.04248543f, 0.07929082f, -0.19465324f, 
    0.16398861f, -0.14509454f, -0.03322767f, -0.16797885f, 0.01075656f, -0.17321011f, -0.04359593f, -0.04228456f, 
    0.17618172f, -0.12543742f, -0.13709077f, -0.08646731f, 0.15471065f, -0.00411906f, -0.05854009f, 0.02838796f, 
    0.05467190f, -0.14699453f, -0.13717395f, -0.17209400f, -0.15890412f, -0.14245647f, -0.12871373f, 0.03342058f, 
    0.08180328f, 0.08459518f, 0.02122133f, -0.18717431f, -0.15655881f, 0.34574902f, 0.20615675f, 0.35123852f, 
    0.09190264f, 0.13032757f, -0.32262453f, -0.01230332f, 0.38427889f, -0.12260123f, -0.14251594f, 0.15884303f, 
    -0.07424080f, -0.02777129f, 0.34426427f, 0.18444116f, 0.00900595f, 0.36067352f, 0.02522574f, -0.13774681f, 
    -0.07618560f, -0.18063387f, -0.14183247f, 0.23114488f, 0.15781792f, 0.10692643f, -0.08871273f, -0.17601061f, 
    -0.13913488f, -0.21253973f, -0.07227397f, 0.12332574f, -0.17347610f, 0.14029685f, 0.30663502f, 0.23905066f, 
    0.12189878f, -0.24067627f, -0.44100913f, -0.06522857f, -0.05703546f, -0.11313467f, 0.14041938f, 0.22545335f, 
    -0.22245404f, -0.10913353f, 0.41450351f, -0.29549599f, 0.17625931f, 0.27240661f, -0.06190747f, -0.19747579f, 
    0.05571126f, 0.21211661f, -0.12842916f, 0.34373403f, 0.14930734f, 0.13455807f, 0.01642687f, 0.19065981f, 
    -0.01381449f, -0.10334575f, -0.30568719f, -0.10611261f, 0.04363266f, 0.16977125f, 0.35863867f, 0.36983952f, 
    0.00580788f, 0.27404520f, 0.10149515f, 0.02478354f, 0.19976400f, -0.07345803f, -0.07750175f, 0.14383219f, 
    0.57282370f, -0.05908482f, 0.39163631f, -0.16470404f, -0.02230515f, 0.28802162f, 0.48572713f, -0.39950067f, 
    0.01222974f, -0.00080711f, 0.07352859f, -0.20140429f, -0.08697362f, -0.00048850f, 0.07436416f, -0.00658113f, 
    -0.08757867f, 0.04851965f, -0.19808909f, -0.08188491f, -0.31583828f, 0.28097269f, 0.24101309f, -0.12256218f, 
    0.11213548f, 0.18176335f, -0.44955051f, 0.00490186f, 0.32835278f, -0.29605719f, -0.01340729f, 0.26527765f, 
    0.22504650f, -0.02688659f, 0.29123107f, 0.05118728f, 0.10628444f, 0.28652146f, -0.10868564f, -0.21091703f, 
    0.05922365f, -0.13094439f, 0.04993806f, 0.19009283f, -0.22260518f, 0.23956452f, -0.00592401f, 0.10639486f, 
    0.23912138f, 0.34505662f, -0.24172516f, 0.17297137f, 0.24401043f, -0.05441436f, -0.12812780f, -0.20570169f, 
    -0.04109521f, 0.23259288f, 0.01543938f, 0.08140438f, -0.27626455f, -0.27327490f, 0.06005193f, 0.17439713f, 
    -0.63987690f, -0.11739022f, 0.27971011f, 0.04272471f, -0.14764319f, -0.18113957f, -0.03803897f, 0.05235800f, 
    -0.10356463f, 0.22159210f, -0.00080863f, -0.07775807f, -0.30030274f, 0.01073344f, 0.08756299f, -0.13116576f, 
    0.15227817f, -0.34108254f, -0.35640565f, -0.28061154f, -0.06618813f, 0.18798850f, 0.29873931f, 0.23344636f, 
    -0.12904862f, 0.33904347f, 0.12389074f, 0.11911049f, -0.21221474f, -0.18085738f, -0.30913910f, 0.09479320f, 
    0.16432056f, -0.00944188f, 0.09158263f, 0.00585269f, 0.05868591f, 0.30860838f, 0.38288838f, 0.07883920f, 
    -0.03609331f, 0.13034604f, -0.15551402f, -0.02497340f, 0.04345178f, -0.04708481f, 0.07632642f, 0.13041270f, 
    0.02286161f, 0.06455232f, -0.06154171f, -0.05931176f, 0.10409451f, 0.01458305f, -0.14778917f, 0.11876892f, 
    0.15560059f, 0.04593459f, -0.03970155f, 0.04387449f, 0.00340896f, -0.17474969f, -0.18382046f, -0.17438795f, 
    0.06631641f, -0.04902058f, -0.08420908f, -0.00750367f, 0.13144980f, -0.00062586f, -0.14350447f, -0.05145129f, 
    -0.01557294f, -0.05392699f, -0.03977035f, 0.04376582f, -0.04946487f, -0.15360667f, -0.11158268f, -0.01653121f, 
    -0.13439016f, -0.03187031f, -0.26049119f, 0.33860672f, 0.24169436f, -0.03955669f, -0.25986442f, 0.10302644f, 
    -0.05463509f, 0.19497608f, 0.09674637f, 0.03765987f, -0.37036109f, -0.29503044f, 0.05625144f, 0.36540577f, 
    0.17164251f, -0.15370634f, -0.00944398f, 0.30403879f, 0.00004473f, 0.18235952f, -0.13738592f, 0.14151631f, 
    0.05030532f, 0.39566225f, 0.06081959f, 0.11148455f, -0.01549120f, -0.16061743f, -0.06537066f, 0.19724526f, 
    -0.10014487f, 0.12466218f, -0.14419493f, -0.17077817f, -0.09774663f, 0.04224927f, 0.00245196f, -0.14772592f, 
    -0.15928006f, -0.11229642f, 0.08414610f, 0.09046155f, -0.13873108f, -0.12930967f, -0.14239414f, -0.14020859f, 
    0.03880665f, -0.02632654f, -0.09919906f, -0.17020659f, 0.06475237f, -0.15010105f, 0.05449257f, 0.10079949f, 
    0.14646915f, -0.04044114f, -0.09841201f, -0.01127565f, 0.12655124f, 0.08733445f, 0.11076063f, -0.01904551f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.14496514f, 0.10534735f, -0.07937614f, -0.12136375f, -0.00345272f, 0.12010325f, 0.15346476f, 0.06020540f, 
    0.13551858f, -0.10924589f, 0.04550453f, -0.10337953f, -0.03414939f, 0.18549807f, -0.15496437f, 0.05545868f, 
    -0.03296459f, 0.02864537f, -0.06948555f, 0.25068957f, 0.25100893f, 0.06813571f, 0.10664948f, 0.03118424f, 
    0.03944957f, 0.21899225f, 0.11837319f, 0.22910503f, 0.00625789f, 0.06279587f, -0.08341505f, -0.12771671f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.08914143f, 0.29446056f, 0.44135827f, 0.07363434f, -0.17535770f, -0.12655380f, -0.08189920f, -0.02385234f, 
    0.44351098f, 0.25151989f, 0.21151851f, -0.35077578f, -0.20808159f, -0.48280114f, 0.15032457f, 0.00549656f, 
    0.06215777f, 0.21628010f, 0.02688097f, 0.28842983f, 0.34131694f, -0.11577193f, -0.11274024f, -0.16813654f, 
    0.03902235f, 0.10209097f, -0.01397674f, -0.37183252f, 0.07963362f, -0.06171295f, 0.14812584f, 0.16884828f, 
    -0.05688588f, 0.06865516f, 0.05931692f, 0.02426729f, -0.02974931f, -0.08758967f, -0.14908287f, -0.03502519f, 
    0.03120684f, 0.05374768f, -0.06399418f, 0.13218531f, -0.00956951f, -0.05103471f, 0.00846633f, -0.08416010f, 
    -0.15358633f, 0.09020651f, -0.11535598f, 0.02387676f, -0.13080303f, -0.16480665f, 0.00913651f, -0.02955999f, 
    -0.21321052f, -0.06123773f, -0.16306406f, 0.13242067f, 0.12969439f, -0.09785590f, -0.12330810f, 0.06323966f, 
    -0.09900952f, 0.41799781f, 0.59375721f, -0.14576386f, 0.00293031f, -0.15715602f, 0.16818032f, 0.13015385f, 
    0.22102398f, -0.05045285f, 0.23500790f, -0.29008093f, -0.22200702f, -0.61409694f, 0.04438870f, -0.12977833f, 
    -0.01986639f, 0.30324200f, 0.03670649f, 0.08871461f, 0.14789458f, -0.06014983f, 0.04215975f, -0.26888901f, 
    0.12456480f, 0.04734970f, -0.42403880f, -0.16851342f, 0.05289336f, -0.09324057f, 0.18472166f, 0.04352998f, 
    0.10120044f, -0.16980347f, 0.16026148f, -0.08165613f, -0.14143154f, -0.23517835f, 0.28502777f, -0.11897954f, 
    0.25975001f, -0.26418921f, 0.20886177f, -0.20011911f, 0.25872687f, -0.18973517f, -0.06337033f, -0.22177815f, 
    0.23878285f, 0.03835614f, -0.66331136f, -0.04256468f, 0.26209131f, -0.13029283f, -0.18060318f, 0.05240259f, 
    -0.09316199f, 0.25589913f, -0.33375818f, 0.13756955f, 0.28778934f, -0.06716975f, 0.04637532f, -0.11250513f, 
    -0.07262165f, -0.02381990f, -0.14553022f, 0.10127501f, -0.13717584f, -0.10371161f, -0.03939886f, 0.10720051f, 
    0.03075420f, -0.17610726f, -0.14859995f, 0.00225668f, 0.08577794f, -0.05524376f, -0.12904762f, -0.14506891f, 
    0.06489588f, -0.14205116f, -0.10348879f, 0.14064291f, 0.07644621f, -0.13687748f, 0.03522153f, -0.06280176f, 
    -0.10908053f, -0.07169949f, 0.16822648f, 0.04632655f, 0.04270064f, 0.05791033f, 0.05347824f, -0.02175879f, 
    -0.04208268f, 0.01860382f, 0.02955423f, 0.06011504f, 0.20864721f, 0.42516461f, -0.19827256f, 0.04780032f, 
    0.20265891f, 0.33799061f, -0.19861419f, 0.12619002f, 0.01780334f, 0.14950882f, 0.03504707f, 0.54224730f, 
    0.07151311f, 0.32023558f, 0.83478475f, 0.01081038f, 0.01267759f, -0.08567730f, 0.11911572f, 0.14730436f, 
    -0.06276824f, -0.16547908f, 0.25202996f, -0.44942254f, -0.18255016f, -0.14548478f, 0.03348229f, 0.13226324f, 
    0.13511388f, 0.11890903f, 0.09507773f, 0.02025533f, 0.07256179f, -0.19094805f, 0.44381002f, 0.08332967f, 
    -0.04533046f, 0.06346021f, -0.00422186f, -0.12787999f, 0.24498057f, 0.46409941f, -0.17305376f, -0.24473169f, 
    0.10181259f, -0.23721403f, -0.39520136f, -0.38353112f, -0.01289187f, 0.06886768f, 0.07116005f, 0.35471508f, 
    0.46892744f, 0.54063767f, 0.28862211f, 0.38179553f, 0.13377172f, 0.01647249f, 0.30772883f, 0.05275338f, 
    0.06925937f, 0.41732347f, 0.19330257f, 0.04104282f, 0.41793996f, -0.30852753f, 0.17884983f, 0.12514912f, 
    0.17832035f, -0.54128623f, 0.10235691f, 0.43286696f, 0.19337092f, -0.24128999f, -0.03086319f, -0.35368529f, 
    -0.18609995f, -0.06712809f, 0.44418278f, 0.31268924f, 0.02841566f, 0.12469008f, 0.07541604f, -0.00299973f, 
    0.32597589f, -0.25564981f, -0.03991649f, -0.28780407f, -0.33325803f, -0.02478808f, 0.11708958f, 0.15950704f, 
    -0.09184407f, 0.08968446f, 0.48979360f, -0.16861911f, -0.14130028f, 0.11497238f, -0.34572703f, -0.03418333f, 
    0.42196253f, 0.10187467f, 0.02117068f, -0.27991304f, -0.02537513f, -0.02737706f, -0.05064112f, 0.42818862f, 
    0.34024701f, 0.14333491f, -0.00694377f, 0.37540975f, 0.27719498f, 0.14364126f, -0.02868445f, -0.13525859f, 
    -0.21019235f, 0.10394760f, 0.05044910f, -0.03379533f, 0.13129295f, 0.16926274f, -0.41377887f, -0.09543486f, 
    0.02295326f, -0.10599683f, 0.25603974f, -0.05255394f, 0.21476699f, 0.17885980f, 0.19522841f, -0.01006534f, 
    -0.16518025f, 0.22718459f, -0.06081492f, 0.33535802f, -0.29430532f, 0.35211045f, -0.12286074f, 0.59727120f, 
    -0.20495850f, 0.61426163f, 0.49287421f, -0.01934299f, -0.04135299f, -0.17812124f, -0.16304453f, 0.13721564f, 
    0.11946893f, 0.20945379f, 0.39998379f, -0.28587490f, 0.04521421f, -0.06223596f, -0.33269259f, 0.03966870f, 
    0.11410277f, 0.22436254f, 0.20201789f, 0.06426550f, 0.03889276f, 0.75947595f, -0.13531415f, 0.15417840f, 
    -0.40888146f, 0.46695194f, 0.03171039f, -0.13723548f, 0.04739736f, 0.54424870f, 0.06888685f, 0.54132265f, 
    0.23968826f, 0.21183316f, -0.09078514f, 0.15934366f, -0.17853595f, 0.04603075f, -0.07347500f, -0.12959191f, 
    -0.26315144f, 0.15141556f, 0.11654916f, 0.61214870f, 0.02873926f, 0.05133579f, -0.00376506f, -0.03081411f, 
    -0.12333377f, -0.27747631f, -0.50180054f, 0.14538512f, -0.27514380f, -0.14228448f, -0.18591990f, 0.16986480f, 
    0.27145925f, 0.32432854f, 0.24907506f, -0.23958676f, -0.27910799f, 0.23042330f, 0.16503614f, 0.09296183f, 
    0.09107956f, 0.27326384f, -0.24024306f, 0.25097355f, 0.21049085f, -0.14989614f, 0.05282458f, 0.30754811f, 
    -0.24954484f, 0.34201783f, -0.02091826f, 0.08968260f, 0.54697788f, 0.10693616f, -0.07875465f, -0.15238167f, 
    -0.10764524f, 0.27638274f, 0.42673212f, 0.08744507f, 0.14512995f, 0.00176547f, 0.24307664f, -0.12594268f, 
    0.12827650f, -0.05038253f, 0.24736245f, -0.00971423f, -0.22894280f, -0.28833887f, 0.12809156f, 0.06658106f, 
    -0.56784666f, 0.13778648f, -0.18275887f, 0.11471792f, 0.36171013f, 0.08715505f, 0.14204761f, -0.16245402f, 
    0.00465274f, 0.26184282f, -0.12699956f, -0.10092758f, 0.03326651f, 0.02819928f, 0.21609674f, 0.12304778f, 
    -0.04479970f, -0.14882161f, -0.28765622f, -0.07107942f, 0.20398809f, 0.08946888f, 0.07556154f, -0.09165655f, 
    0.53072751f, 0.46453422f, -0.05601203f, 0.29505226f, 0.33283457f, 0.07892113f, 0.07878274f, 0.26700071f, 
    0.86147726f, -0.15623775f, 0.40564355f, -0.19498275f, -0.10261869f, -0.19174105f, -0.02729422f, 0.14698797f, 
    -0.30494425f, -0.13966860f, -0.12849769f, -0.13315921f, -0.22069500f, 0.05805733f, -0.23675700f, -0.06316295f, 
    -0.14496581f, -0.27038580f, 0.09554855f, 0.06159294f, -0.21469134f, 0.19610924f, -0.04249534f, 0.01598066f, 
    0.00496803f, 0.45659333f, 0.18295738f, -0.04604305f, -0.10498135f, 0.28586164f, 0.17461361f, 0.23899822f, 
    0.05242578f, 0.15583643f, -0.44856447f, 0.12841783f, -0.04315146f, 0.04639803f, 0.00435950f, 0.14269742f, 
    -0.10929047f, 0.59660321f, -0.13584183f, 0.08625925f, 0.43708286f, 0.18927403f, -0.08914307f, -0.09628717f, 
    0.10834205f, 0.09212720f, -0.45995098f, -0.11240117f, 0.05630711f, 0.06597020f, 0.25096768f, -0.09498570f, 
    0.09679759f, -0.06822017f, 0.18359922f, 0.24376458f, 0.28180861f, 0.17158437f, -0.10886263f, -0.24009062f, 
    0.08556564f, -0.32304931f, -0.18309543f, -0.18252586f, -0.15978087f, 0.16445026f, 0.08468954f, 0.19773619f, 
    -0.08878870f, 0.21274218f, 0.04427101f, 0.20884611f, 0.13691552f, -0.07466249f, 0.03150490f, -0.05858153f, 
    -0.10678270f, 0.17266910f, -0.04997061f, 0.09338270f, -0.17686708f, 0.04976490f, 0.11556601f, -0.15647177f, 
    0.29813099f, 0.48852533f, 0.20338970f, -0.23513022f, -0.45986679f, -0.21163654f, 0.17638610f, -0.42430720f, 
    -0.01704973f, 0.37004727f, 0.03116867f, -0.02624580f, 0.18819724f, -0.19318120f, -0.13212888f, 0.25090292f, 
    0.13721642f, 0.35311916f, -0.15860298f, -0.08676922f, 0.42256778f, -0.07982894f, 0.59231246f, 0.10866617f, 
    -0.00554060f, -0.46952870f, 0.08936714f, 0.04339606f, 0.00922432f, -0.70396543f, -0.05708059f, 0.06652094f, 
    0.34570763f, -0.33872679f, 0.11538956f, -0.26333728f, 0.19542073f, 0.29837677f, 0.11432914f, -0.01065598f, 
    -0.01221578f, -0.14868854f, 0.16284303f, 0.24954091f, 0.02151556f, -0.16883151f, 0.13262060f, 0.18735805f, 
    0.41222498f, 0.01149951f, 0.70726705f, -0.19937491f, -0.11751147f, -0.17566763f, 0.10667484f, 0.00785071f, 
    0.00025079f, 0.24377981f, 0.46001524f, -0.08930817f, 0.13406394f, 0.55025041f, 0.13717711f, -0.09682754f, 
    -0.61429149f, 0.03031334f, 0.06324000f, -0.14583239f, 0.07829691f, 0.40342149f, -0.13711268f, 0.43121612f, 
    -0.38348150f, 0.01501063f, -0.50746638f, 0.17100433f, 0.27232271f, 0.12987496f, -0.05242057f, -0.08782726f, 
    -0.05695611f, 0.18553263f, 0.10807918f, 0.50851840f, -0.15876791f, 0.08241293f, 0.27177286f, -0.12590054f, 
    -0.12890288f, -0.02633481f, 0.26307347f, 0.04752756f, 0.20676358f, 0.40124434f, 0.07837544f, -0.11499797f, 
    -0.08585376f, 0.25842762f, -0.18268555f, -0.16699061f, 0.27521253f, 0.48077384f, 0.03397076f, 0.38579184f, 
    0.34756491f, -0.21568473f, -0.25528613f, 0.02177763f, -0.12831730f, -0.08453507f, 0.14026603f, -0.01939845f, 
    -0.02973177f, -0.11753071f, 0.12003681f, 0.21743074f, -0.40729687f, -0.07703683f, 0.06389087f, 0.15840887f, 
    0.02307430f, -0.19217260f, -0.07412338f, 0.04336242f, -0.09753644f, -0.30883148f, -0.15905668f, 0.10541156f, 
    0.48069504f, 0.33122262f, 0.20876864f, 0.32421723f, -0.16331510f, -0.06141969f, -0.01211627f, 0.01523585f, 
    0.08995599f, 0.28321356f, 0.47524917f, 0.01764903f, -0.10880839f, 0.06640124f, 0.14987236f, 0.25001353f, 
    0.25830090f, 0.06244355f, 0.23094670f, -0.48896328f, 0.15402469f, -0.00282599f, 0.10820841f, -0.14627403f, 
    -0.06591622f, -0.27092290f, -0.10802473f, 0.06951214f, 0.23215067f, 0.04317503f, -0.02618470f, -0.16299576f, 
    0.37637869f, -0.10916884f, 0.05502928f, 0.42460749f, 0.35841098f, 0.06406609f, -0.06431638f, 0.08929233f, 
    0.06220548f, 0.03850226f, 0.42480716f, 0.01984475f, -0.23619008f, 0.16079731f, -0.01240456f, 0.24645759f, 
    0.22583082f, 0.21418436f, 0.18351874f, -0.15287571f, -0.01335918f, 0.15254425f, -0.48347020f, 0.00494315f, 
    -0.03846654f, 0.00835535f, -0.15715325f, -0.00315723f, 0.31055552f, -0.11844795f, -0.15857795f, -0.05874053f, 
    0.07894079f, -0.26140308f, 0.20476207f, 0.25567549f, 0.24815339f, -0.03519165f, -0.12573060f, 0.11305949f, 
    0.08441068f, 0.04427453f, 0.19105783f, 0.39063641f, 0.04357693f, -0.12941472f, -0.15120584f, 0.08209816f, 
    0.11262926f, -0.02886159f, -0.28468779f, -0.30739972f, -0.25925118f, 0.12886977f, -0.65576273f, -0.14596829f, 
    0.15959960f, 0.33781052f, -0.45967537f, 0.19931790f, 0.44747496f, -0.06694828f, 0.06438603f, 0.12240909f, 
    0.26657158f, -0.24675991f, 0.16183127f, 0.22759607f, 0.43299729f, -0.32719705f, -0.09898476f, -0.17478654f, 
    0.15914610f, -0.08770833f, 0.23975067f, 0.42052999f, 0.09781318f, -0.09537530f, 0.00946800f, 0.06295607f, 
    -0.05581446f, -0.53459609f, -0.43108633f, 0.01148596f, -0.21910785f, 0.13396932f, -0.12123731f, -0.09614726f, 
    0.02148745f, -0.11665162f, -0.27277482f, -0.09091245f, 0.10128005f, -0.02928351f, -0.02236908f, -0.12099318f, 
    -0.10094624f, -0.20066065f, 0.25822210f, 0.20463657f, 0.12573159f, 0.19930279f, 0.11795305f, 0.12909073f, 
    -0.20132041f, -0.06684437f, 0.00185436f, 0.30466706f, 0.17298111f, -0.05518030f, -0.07650253f, 0.03085474f, 
    0.08350637f, 0.01800152f, -0.34333557f, -0.05620341f, 0.27589244f, 0.12874934f, -0.30000225f, 0.00351753f, 
    0.06652500f, 0.44122481f, 0.41550732f, 0.04303576f, 0.17885838f, -0.01174845f, 0.05806207f, -0.01448717f, 
    -0.03686590f, -0.45575351f, 0.19948636f, -0.18394876f, 0.33701217f, -0.04545540f, 0.00490067f, 0.09906702f, 
    0.21025822f, -0.27925652f, -0.50475073f, 0.11807283f, 0.31150189f, -0.12742685f, -0.14501339f, -0.36303425f, 
    0.11279465f, -0.16281196f, -0.57310033f, 0.48782778f, -0.10990105f, -0.00283996f, 0.13454647f, -0.04794406f, 
    0.07651664f, -0.14202213f, -0.05947561f, 0.11056288f, -0.01302680f, -0.05171796f, -0.12288186f, -0.15328775f, 
    -0.06581239f, -0.02188355f, 0.03057128f, -0.10779851f, 0.05165316f, 0.05320430f, -0.08111230f, -0.09591737f, 
    0.10043029f, -0.04562712f, 0.09626492f, -0.18069023f, -0.13710938f, -0.15172227f, -0.03593447f, 0.10962677f, 
    -0.20710799f, 0.02441702f, -0.00296738f, -0.09374947f, -0.06895462f, -0.12825735f, -0.06562131f, 0.00215115f, 
    0.09210882f, 0.17730598f, -0.49352092f, -0.18017128f, 0.26691678f, -0.28407815f, -0.18104273f, 0.05965137f, 
    0.03067366f, -0.38707888f, 0.14793691f, 0.14687577f, 0.45204550f, 0.43931827f, -0.04212150f, -0.34150437f, 
    0.48711914f, -0.54809552f, -0.24249323f, 0.03813911f, -0.19638063f, -0.04377209f, -0.04237768f, 0.09908686f, 
    0.33136758f, -0.11774543f, 0.09186900f, 0.60377359f, 0.28027430f, -0.04121061f, 0.51521808f, 0.03444044f, 
    0.02654086f, -0.11240979f, 0.42825332f, -0.15442015f, 0.21257925f, 0.33117989f, 0.08767995f, 0.01155776f, 
    -0.20320506f, -0.16255531f, -0.14093128f, 0.12238199f, -0.16101106f, 0.54416615f, -0.16298544f, 0.59746069f, 
    -0.68047464f, 0.62099165f, -0.00500517f, 0.20875426f, -0.03502953f, 0.04925192f, 0.07300928f, 0.27222905f, 
    0.28693140f, 0.34448731f, 0.63923985f, -0.13454533f, 0.01644390f, -0.03663672f, -0.41530639f, 0.08314176f, 
    0.05140069f, -0.06644381f, -0.07313875f, 0.10093120f, -0.03622680f, 0.01422228f, 0.00522659f, 0.07575867f, 
    0.08134171f, -0.02522521f, -0.17648114f, 0.03018871f, -0.00156999f, -0.12407208f, -0.07664647f, -0.09339518f, 
    0.05125504f, 0.09901538f, 0.11421821f, 0.02390445f, -0.15016976f, -0.04253622f, 0.06207213f, -0.08953995f, 
    0.14144686f, -0.03823284f, -0.16822098f, -0.11938781f, -0.12850009f, 0.14009351f, -0.12991376f, -0.15803193f, 
    -0.07029077f, -0.24657197f, 0.10090786f, 0.06922444f, 0.10646466f, -0.07293031f, 0.34195629f, 0.09594436f, 
    0.32644674f, 0.36894959f, 0.06867881f, 0.36775163f, 0.03328219f, -0.03987203f, 0.12722985f, -0.03944539f, 
    0.11860924f, 0.36206120f, 0.35637745f, -0.22835635f, -0.01705105f, 0.13948728f, -0.01809008f, 0.23177099f, 
    -0.05316573f, 0.49822897f, 0.12689798f, -0.37037581f, 0.26436791f, 0.04006539f, -0.49663812f, 0.16411427f, 
    0.15021038f, -0.10737633f, -0.18387200f, 0.04529252f, -0.15887828f, 0.01420460f, -0.03652056f, -0.01554650f, 
    -0.11746560f, 0.07988897f, -0.11386029f, -0.14657173f, -0.12151855f, 0.02341815f, 0.12486926f, 0.08087103f, 
    0.14741720f, -0.04990200f, -0.08962521f, 0.12859268f, 0.13298595f, -0.06555612f, 0.14080763f, 0.02278274f, 
    -0.09529869f, 0.11854638f, -0.06625733f, -0.13418782f, -0.15405132f, -0.07082555f, -0.04375048f, -0.12311073f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.07848358f, -0.15013850f, 0.06317356f, -0.03614672f, 0.04995772f, 0.03159347f, 0.19816442f, 0.17379691f, 
    0.10007022f, -0.09135820f, 0.04414441f, -0.19230378f, 0.15975909f, 0.13471837f, -0.08348396f, 0.03439496f, 
    0.12379320f, -0.16442272f, 0.21667716f, -0.15125327f, 0.10395867f, 0.17043851f, 0.06429584f, 0.15910487f, 
    0.09715902f, 0.30014700f, -0.07031584f, 0.21569420f, 0.23685835f, 0.03861524f, 0.11429855f, -0.16284135f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.08027875f, -0.00249986f, 0.24879420f, -0.02763784f, 0.12518220f, -0.33593577f, 0.17407486f, 0.13252062f, 
    -0.12860870f, -0.76833677f, -0.04072914f, -0.21994877f, 0.20485529f, -0.65804756f, -0.36006615f, -0.14625312f, 
    0.18029130f, -0.53935790f, 0.26837102f, -0.51878780f, -0.48357975f, -0.56734681f, -0.18558595f, 0.16094750f, 
    0.06990837f, 0.34982276f, 0.11778734f, 0.33886462f, -0.54541910f, 0.16912936f, -0.59105915f, -0.13879360f, 
    -0.47854769f, 0.10900167f, -0.45573175f, 0.39215636f, -0.09221286f, -0.03207210f, 0.03455852f, -0.08118393f, 
    -0.15464410f, -0.34770015f, 0.19836366f, 0.15316123f, -0.25840998f, 0.40306398f, 0.15889455f, 0.09173634f, 
    -0.31984994f, -0.32154840f, 0.13834657f, 0.47872466f, -0.51037341f, -0.08772596f, 0.11783327f, 0.27940685f, 
    -0.11886138f, 0.20275959f, -0.03410611f, 0.28366491f, -0.41714764f, -0.12527315f, -0.19752643f, -0.01124229f, 
    -0.70476663f, -0.15545140f, -0.54737741f, -0.34622878f, -0.09407812f, -0.14510295f, 0.46369469f, 0.18196869f, 
    -0.89339781f, 0.15423477f, -0.41074663f, -0.51765257f, -0.04016079f, -0.61138105f, -0.42868173f, 0.37592268f, 
    -0.10293980f, 0.45463291f, 0.20199759f, -0.20832869f, -0.01209694f, 0.18025947f, 0.08436689f, -0.20057094f, 
    -0.10053708f, -0.29126695f, -0.11283124f, 0.18376434f, 0.51231605f, -0.03839026f, 0.04869420f, -0.17380413f, 
    0.25284883f, 0.01572881f, 0.14301930f, -0.55125391f, -0.17658083f, 0.20932028f, -0.25660434f, -0.60061145f, 
    0.08198159f, 0.24696492f, 0.16110089f, 0.19382773f, 0.18477724f, -0.40795714f, 0.14261688f, -0.30520445f, 
    0.35219884f, -0.55344164f, 0.18174778f, -0.23040724f, 0.19797985f, -0.41882429f, -0.61878932f, -0.53755903f, 
    -0.29142445f, -0.61329824f, -0.09024198f, -0.77137440f, 0.04197162f, 0.12899753f, -0.04601433f, 0.08774421f, 
    0.18830939f, 0.03349198f, 0.35104915f, 0.11798121f, -0.09944966f, -0.13179438f, 0.06435689f, 0.05796766f, 
    0.12773758f, -0.03902749f, -0.43786523f, -0.18806484f, 0.21815649f, -0.14160040f, -0.18439899f, -0.39266860f, 
    0.08992749f, 0.02152638f, -0.03360700f, -0.40357554f, -0.00550970f, -0.16844736f, -0.10334957f, -0.14488183f, 
    -0.17936373f, 0.22539684f, -0.05524233f, -0.24656257f, 0.04299715f, 0.16392121f, 0.12529662f, -0.18346912f, 
    -0.03982403f, 0.01795147f, 0.05794714f, -0.27934507f, 0.06590905f, -0.03382473f, -0.35586265f, 0.07932569f, 
    0.18829764f, -0.11345508f, 0.28678980f, -0.31592777f, 0.04736188f, -0.33435354f, -0.26426885f, -0.81588638f, 
    -0.48773184f, 0.38131434f, 0.39489418f, 0.41599002f, -0.51232946f, -0.31400228f, 0.16617599f, 0.07585982f, 
    -0.06407598f, 0.34457958f, -0.03362713f, -0.16898827f, 0.18547989f, 0.03310591f, -0.73235542f, 0.13913946f, 
    -0.04484376f, -0.09839740f, 0.07943788f, -1.10523367f, 0.10249323f, 0.18595034f, -0.50808024f, 0.15489739f, 
    0.10692602f, 0.23807770f, 0.00027161f, -0.66510171f, -0.03813322f, 0.28723317f, -0.58444124f, -0.43961051f, 
    -0.18011935f, -0.45596558f, -0.09746450f, -0.37510830f, -0.14093070f, 0.22087264f, 0.33796245f, 0.30577886f, 
    0.09275942f, -0.11573723f, 0.04421800f, -0.46180108f, 0.07177670f, -0.04047140f, 0.12958033f, -0.19792791f, 
    0.26128972f, 0.12317833f, 0.08447301f, 0.60519433f, 0.08347503f, -0.60661972f, 0.10603862f, -0.48562860f, 
    0.19511676f, -0.63924086f, -0.39988950f, 0.35044807f, -0.09764194f, 0.01180791f, 0.28414300f, -0.07387126f, 
    0.12023490f, 0.24065265f, -0.32351211f, -0.05642586f, 0.19185749f, -0.19036518f, -0.09928342f, -0.41657874f, 
    -0.02898417f, -0.09697208f, -0.22863695f, -0.12259007f, -0.67076373f, 0.04616829f, -0.02696535f, 0.06461841f, 
    -0.19765185f, 0.05366371f, -0.44717252f, -0.14796376f, 0.05854361f, 0.22814225f, 0.26165426f, -0.04519815f, 
    -0.17930582f, 0.02502069f, 0.00092293f, -0.45499983f, -0.78190869f, 0.51182032f, -0.41312259f, -0.22281067f, 
    -0.08066390f, 0.22359253f, -0.52931648f, 0.51944888f, 0.28221029f, 0.21942873f, -0.33793163f, -0.17505223f, 
    -0.85945910f, -0.40751138f, -0.08170626f, 0.26824811f, -0.25072873f, -0.05146665f, 0.06023965f, 0.05501678f, 
    0.14072347f, 0.02654016f, 0.09201393f, -0.09551124f, -0.09699365f, -0.08028067f, -0.21846470f, 0.19503735f, 
    0.01045913f, -0.61338872f, -0.77936906f, -0.09531793f, -0.03128797f, 0.03085680f, -0.51637208f, 0.10016498f, 
    -0.11829107f, 0.26292714f, -0.52862412f, -0.71449471f, 0.11902273f, 0.18971351f, 0.32430142f, 0.30975351f, 
    0.12168644f, 0.06263800f, -0.10590252f, 0.23079239f, -0.68948412f, -0.15626094f, -0.14463629f, -0.09783666f, 
    -0.25763410f, 0.16104773f, -0.42751306f, 0.02327608f, 0.14633380f, -0.10526121f, 0.26769736f, -0.87999797f, 
    0.09128046f, -0.00648094f, 0.38207155f, -0.00403611f, -0.17248639f, -0.14541325f, 0.30591750f, 0.13863622f, 
    -0.15810190f, -0.52594155f, 0.21267729f, 0.27668184f, -0.14067882f, 0.24607563f, -0.20744701f, -0.72335982f, 
    0.21729544f, -0.06037052f, 0.10367562f, -0.09184030f, 0.29976434f, -0.06206264f, 0.12941955f, -0.10228416f, 
    -0.14075881f, 0.01092877f, -0.34316167f, -0.35186031f, -0.10805030f, 0.02594381f, -0.21698126f, -0.18159291f, 
    0.18068539f, 0.21785073f, -0.04036467f, 0.22287403f, -0.21780197f, -0.04564122f, -0.11985192f, -0.20707552f, 
    -0.09859687f, 0.33872434f, -0.22181392f, -0.48483193f, 0.24445592f, 0.16210689f, 0.10990537f, -0.13916086f, 
    0.17297891f, -0.56887192f, 0.00025367f, -0.03317245f, 0.27661625f, -0.14496242f, 0.13884586f, 0.12299829f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.11872571f, 0.04202789f, 0.15586624f, -0.12262971f, 0.02210649f, -0.06187043f, 0.11025713f, -0.24683665f, 
    -0.33109048f, -0.03558296f, 0.11566983f, -0.08984642f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
