#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.40312383f, 0.75481582f, -0.11964241f, -0.24088909f, -0.32989872f, -0.79985708f, 0.09068249f, -0.17356452f, 
    -0.11916970f, 0.80670601f, 0.54193455f, 0.67346197f, 0.23288882f, 0.12677361f, 0.37611631f, -0.36474434f, 
    0.24822797f, 0.30850416f, 0.74812073f, 0.08592973f, 0.25829706f, -0.24815898f, -0.74914378f, 0.11885310f, 
    0.26272538f, 0.59178913f, -0.08636827f, -0.99492264f, 0.39481068f, 0.78384548f, 0.11949734f, 0.43940547f, 
    -0.44382766f, 0.06429845f, 0.20105262f, 0.03129414f, -0.93848509f, 0.27585143f, 0.14592494f, 0.23975889f, 
    0.07518948f, 0.30274293f, -0.24907444f, -0.53235269f, 0.17897336f, -0.02127278f, -0.36698300f, -0.24155176f, 
    0.78254080f, 0.81580621f, 0.56981152f, -0.31953841f, -0.07202125f, 0.06840673f, -0.63574588f, -0.59963208f, 
    -0.38655290f, 0.22324029f, 1.02214611f, -0.09588952f, 0.11223948f, -0.20105572f, -0.19401281f, -0.83972311f, 
    -0.31136006f, -0.35532275f, -0.42095530f, -0.46881405f, 0.31692657f, -0.13056850f, 0.55531782f, 0.11947176f, 
    -0.29012725f, 0.09385175f, -0.52897412f, -0.12226157f, 0.41537225f, -0.40784001f, -0.08554293f, -0.77225399f, 
    -0.23003709f, -0.82369465f, -0.79751021f, -0.51861107f, 0.06766505f, -0.41384053f, -0.04227155f, 0.08536426f, 
    -0.09759825f, -0.05038698f, 0.67462379f, 0.80315810f, -0.63159662f, -0.23885109f, 0.49508995f, 0.17191941f, 
    0.20120424f, -0.17397229f, -0.11806874f, 0.79339510f, 0.85458398f, 0.76171285f, -0.34741470f, 0.00896208f, 
    -0.55653548f, -0.10210055f, -0.22449195f, -0.01770894f, 0.41460443f, -0.32206285f, 0.92150605f, 0.93495995f, 
    0.21645205f, -0.41872391f, 0.18135560f, 0.14339130f, 0.13964218f, 0.31443226f, -0.72877234f, 0.06862202f, 
    -0.80875850f, -0.02020091f, 0.16643175f, 0.35961527f, 0.30941454f, 0.47740635f, 0.79437286f, -0.29163462f, 
    -0.57493466f, -0.42069581f, -0.14429130f, -0.41386318f, -0.23778877f, -0.28214887f, 0.41532817f, 0.26968527f, 
    0.36648217f, -0.00642874f, 0.40903577f, -0.39963058f, -0.33549371f, 0.56266218f, 0.12188877f, 0.30414349f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.37664741f, 0.30614385f, -0.42854810f, -0.27862972f, -0.02552648f, -0.04678285f, -0.22265780f, -0.00538957f, 
    0.15368487f, -0.09647276f, -0.21017870f, 0.15720388f, -0.11940438f, 0.08823682f, 0.33721605f, 0.44011971f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.06223636f, -0.02845506f, -0.03986635f, 0.00077711f, -0.09018053f, -0.08859982f, -0.09309928f, -0.01478479f, 
    -0.01335033f, -0.04256387f, 0.00493268f, 0.04316790f, 0.01449764f, -0.03910543f, 0.02398320f, -0.01740813f, 
    -0.06464020f, -0.05114242f, -0.03079228f, -0.05776186f, -0.02933185f, -0.05833520f, -0.02521270f, 0.06046868f, 
    0.02419957f, 0.06988192f, 0.05280652f, 0.03354525f, -0.09751804f, -0.07847419f, 0.04944808f, 0.06862407f, 
    0.07282053f, 0.02641430f, -0.00803171f, -0.01871263f, 0.01090598f, -0.01543726f, -0.02046289f, 0.04073210f, 
    0.00065698f, -0.01850624f, 0.03468224f, 0.04638065f, 0.00759145f, -0.06427798f, -0.07171586f, -0.07807539f, 
    -0.09132797f, 0.01382466f, -0.02799770f, -0.04798676f, -0.01327048f, -0.06355206f, -0.08838753f, -0.02471719f, 
    0.04543296f, -0.00650074f, -0.07450218f, 0.05170672f, -0.05155973f, -0.03690623f, 0.03184304f, -0.03364420f, 
    0.02580543f, 0.04432267f, 0.02582041f, 0.00436031f, 0.06719460f, 0.05949720f, 0.00020355f, -0.09256162f, 
    0.04796124f, 0.06095215f, 0.06408028f, -0.01253981f, -0.07228771f, -0.07294880f, -0.00801145f, -0.01758740f, 
    -0.06038040f, 0.02606328f, -0.05290002f, -0.07237404f, 0.00895706f, -0.08932354f, 0.04110253f, 0.02009273f, 
    0.02961896f, -0.03597480f, 0.03717754f, 0.03664672f, 0.06814039f, -0.09001148f, 0.03704184f, -0.05351594f, 
    -0.02135813f, 0.06489449f, -0.09002881f, -0.03188627f, -0.06028088f, -0.01703969f, 0.04141582f, -0.01857167f, 
    -0.00410896f, 0.05470364f, -0.03026197f, 0.02005674f, -0.02729522f, -0.02819577f, -0.03681437f, -0.08883934f, 
    0.03422140f, 0.03775006f, -0.06567361f, 0.06690470f, -0.03668737f, 0.03253447f, -0.08454390f, 0.05374295f, 
    0.04499106f, -0.00638849f, 0.05299035f, -0.03040355f, -0.01215192f, 0.01940800f, -0.05501328f, -0.03599866f, 
    -0.06442218f, 0.05189949f, -0.08808307f, -0.00582732f, 0.03299610f, 0.02338635f, -0.04073203f, 0.05250569f, 
    -0.04712282f, -0.04965664f, -0.00886716f, -0.05622184f, 0.03979714f, -0.04508976f, -0.07234702f, -0.00992597f, 
    0.06017027f, 0.00324507f, -0.09331612f, 0.00574613f, 0.07032990f, -0.05341296f, -0.05699199f, -0.04291874f, 
    0.00377198f, 0.07320306f, 0.04916055f, 0.00543757f, -0.08331770f, -0.04173688f, -0.05947364f, 0.03814221f, 
    0.05934234f, -0.05125299f, 0.04005093f, 0.00562881f, 0.05090069f, -0.00721738f, 0.05003385f, 0.02474819f, 
    -0.00267388f, 0.04006392f, 0.05109063f, -0.02479617f, -0.04493374f, -0.08614156f, 0.07062283f, -0.06921080f, 
    -0.05796800f, 0.02481917f, -0.06467926f, 0.03926208f, 0.00563262f, 0.03162530f, -0.02586709f, -0.00851610f, 
    -0.04081604f, -0.08378339f, -0.02061515f, 0.03241177f, 0.04530185f, -0.04033393f, -0.01570787f, -0.05998227f, 
    0.00150897f, -0.03867824f, -0.07286593f, -0.07644599f, 0.02603075f, 0.00945082f, 0.00973148f, -0.02779201f, 
    0.07606274f, -0.05784364f, -0.01289080f, 0.06324728f, 0.03172245f, -0.08618779f, -0.08395433f, 0.08116252f, 
    0.03997333f, -0.03886820f, 0.04482731f, -0.04593867f, -0.04459872f, -0.01519264f, 0.02228242f, -0.02497870f, 
    -0.06695510f, -0.08276109f, -0.01522699f, -0.07063579f, 0.01352789f, 0.03730787f, 0.00818119f, 0.06694977f, 
    -0.00416459f, -0.00389833f, -0.08058578f, -0.08509114f, -0.00587827f, 0.02052503f, 0.06956606f, -0.05965751f, 
    -0.06672042f, -0.05334540f, 0.06416301f, 0.04720313f, 0.02485751f, -0.07370627f, -0.07593018f, -0.05195358f, 
    -0.00757480f, -0.01234812f, -0.00212617f, -0.01891378f, 0.05137501f, -0.05811523f, 0.00372332f, -0.05000567f, 
    -0.04707787f, 0.03117222f, -0.02677651f, -0.08320576f, -0.01427978f, 0.03607710f, 0.04829187f, -0.02500635f, 
    -0.06969315f, 0.01002280f, 0.05751288f, -0.03358247f, -0.08343037f, 0.00560351f, 0.06083511f, 0.04999403f, 
    -0.07411920f, -0.02882804f, -0.01645805f, 0.03450071f, -0.09262479f, 0.00772387f, 0.01796917f, 0.04088446f, 
    -0.01956434f, -0.06592095f, 0.04704517f, 0.02560733f, -0.00828240f, 0.01970722f, -0.08791229f, 0.02085711f, 
    -0.07251680f, -0.07551868f, 0.04935847f, 0.05415526f, 0.01024005f, 0.05096649f, -0.01745264f, -0.08132784f, 
    -0.03958449f, -0.00581115f, 0.03647703f, 0.06696144f, -0.06634569f, 0.04465686f, 0.02272630f, 0.02503651f, 
    -0.08792580f, -0.00940860f, -0.03031320f, -0.04207566f, 0.07019238f, -0.01993130f, -0.04598757f, 0.06289423f, 
    -0.06830160f, -0.01362527f, -0.02860615f, -0.05573084f, -0.04024602f, -0.08534069f, 0.04193398f, 0.03889297f, 
    0.03884448f, 0.07618944f, -0.03719649f, -0.00865440f, 0.01253757f, 0.03970270f, -0.08603392f, -0.04176670f, 
    -0.01379173f, -0.01755738f, -0.05814892f, -0.02475871f, -0.02028629f, -0.05326656f, -0.01669650f, -0.02729443f, 
    -0.05960818f, -0.03712320f, -0.02216785f, 0.03870610f, 0.04865038f, -0.02791516f, -0.07117406f, -0.07657819f, 
    0.03507838f, -0.03755107f, 0.02349407f, -0.00175877f, -0.08829792f, -0.04642812f, -0.01372243f, -0.03977717f, 
    -0.06792590f, -0.07390349f, 0.00272036f, 0.00643468f, 0.03216686f, -0.00264271f, -0.04041705f, 0.02027871f, 
    0.04456751f, 0.03344486f, -0.03242570f, -0.08095419f, -0.03368351f, -0.02797490f, 0.03910594f, 0.06941752f, 
    0.02982352f, 0.06126087f, 0.06091287f, 0.04646812f, -0.05412855f, -0.05237009f, -0.05739024f, 0.02869331f, 
    0.01056781f, -0.05668230f, 0.03718657f, 0.03141630f, -0.04597565f, 0.05332806f, 0.03950765f, 0.01035732f, 
    -0.04713528f, -0.04543548f, 0.05378617f, 0.01789835f, 0.07029975f, -0.00703657f, -0.03610591f, -0.00996282f, 
    0.07272377f, 0.00655499f, -0.06529482f, -0.00515765f, -0.03314560f, -0.05919629f, 0.03137283f, 0.02912796f, 
    -0.03211100f, -0.02829150f, 0.05559701f, -0.03479216f, 0.01170971f, -0.00449404f, -0.07130232f, 0.06019730f, 
    -0.02854383f, 0.04274913f, 0.04548714f, -0.00241599f, -0.01348784f, -0.04670598f, -0.04603317f, 0.06916418f, 
    -0.06454910f, 0.03471997f, 0.01951809f, 0.01920347f, -0.02766156f, -0.07567000f, -0.07671300f, -0.04722015f, 
    -0.07073810f, -0.07914442f, -0.03721583f, 0.00784686f, 0.02936518f, -0.05512634f, -0.00040081f, 0.04872987f, 
    -0.02323314f, -0.01094270f, -0.00045844f, 0.02415765f, -0.08528041f, -0.08534415f, 0.06778125f, -0.07009779f, 
    0.03982158f, 0.02172709f, 0.00809998f, -0.03820772f, 0.02044034f, -0.03062753f, -0.12576284f, -0.10617769f, 
    0.03309600f, -0.04770593f, 0.02391364f, -0.10603887f, -0.04494274f, -0.06102634f, -0.00298875f, -0.10397588f, 
    0.05128789f, -0.13468705f, -0.05254935f, -0.02514978f, 0.01457792f, -0.10204779f, 0.00099412f, -0.06398126f, 
    -0.01788772f, 0.01440629f, -0.08816744f, -0.04784153f, 0.02391136f, -0.06280702f, -0.08403549f, -0.07923841f, 
    -0.02182620f, -0.02332183f, -0.06269658f, -0.08717557f, 0.00623285f, -0.05391520f, -0.05437097f, -0.03658950f, 
    -0.05541868f, 0.02531498f, -0.00021028f, -0.07014664f, -0.01652483f, 0.04132130f, -0.09958847f, -0.10176473f, 
    -0.00793870f, -0.05671536f, -0.01545968f, 0.02774017f, -0.05833104f, 0.03326317f, -0.00319420f, 0.04631236f, 
    -0.09239379f, -0.10737570f, 0.03530948f, -0.01560307f, -0.08755911f, -0.03654835f, 0.02066083f, -0.01399419f, 
    -0.02839468f, -0.08441259f, 0.05361187f, 0.01071579f, -0.08961529f, -0.00029467f, 0.04201018f, -0.12096563f, 
    -0.09786291f, -0.11279307f, -0.04007975f, 0.05234312f, -0.02323251f, -0.09463388f, -0.11008277f, 0.05385923f, 
    -0.09066420f, -0.07713494f, -0.00007798f, -0.05097194f, 0.00366775f, -0.10433695f, 0.04559906f, 0.03286603f, 
    -0.01931062f, 0.00829778f, -0.09072282f, 0.01880084f, -0.13139586f, -0.04952444f, -0.00217531f, 0.03434160f, 
    -0.06363248f, 0.04335881f, -0.06651708f, 0.04110397f, -0.03308416f, -0.06706931f, 0.02532311f, -0.03721880f, 
    0.00544987f, -0.06506014f, -0.02454852f, 0.00745862f, 0.01305102f, 0.04051642f, -0.07174754f, 0.03346126f, 
    -0.07840239f, -0.04777250f, 0.00735399f, -0.12865055f, -0.00168197f, -0.09318632f, -0.08071475f, -0.07761212f, 
    -0.10001235f, -0.11749585f, -0.04595483f, -0.11170053f, -0.08375797f, -0.01812482f, -0.01539391f, -0.02350426f, 
    -0.05101172f, 0.03323376f, -0.11055044f, -0.11225019f, -0.05824792f, -0.08588534f, 0.02918163f, -0.09931066f, 
    -0.11481422f, -0.08897095f, -0.02533931f, -0.00672438f, -0.05249522f, -0.12162280f, -0.11942235f, -0.12360858f, 
    -0.25181761f, 0.00892516f, -0.16985619f, 0.01778963f, -0.02671597f, -0.19946985f, 0.00172971f, -0.10503241f, 
    0.02550942f, 0.18490823f, 0.04268488f, 0.12332905f, -0.00868205f, 0.09564609f, 0.16433094f, -0.03378388f, 
    0.13406299f, 0.08293470f, -0.46696356f, 0.19951750f, -0.17636392f, -0.04658384f, -0.06306934f, 0.00573292f, 
    -0.01007697f, 0.08747235f, 0.06267394f, 0.68062973f, -0.09402447f, -0.29763913f, -0.15082522f, 0.10631651f, 
    -0.02846331f, 0.03266697f, 0.10709792f, 0.00761795f, 0.05082841f, 0.01114076f, -0.21961698f, 0.01873423f, 
    0.09435921f, 0.04486387f, -0.15007663f, -0.04064060f, 0.08188858f, 0.15048145f, 0.01372196f, 0.24715932f, 
    -0.06168527f, -0.09435070f, 0.06670585f, 0.04814019f, -0.18416780f, 0.14165747f, 0.06944579f, 0.40909529f, 
    0.51248515f, -0.03978574f, 0.18810554f, 0.04129982f, -0.04110269f, 0.08010311f, 0.05281281f, 0.34697199f, 
    -0.19993068f, 0.07294243f, -0.00995843f, 0.17180793f, 0.06170320f, 0.00662955f, 0.07806613f, 0.01041902f, 
    -0.19006491f, 0.22081250f, 0.29742241f, 0.03523764f, 0.00847057f, 0.00492520f, -0.05140432f, -0.04208411f, 
    0.01124493f, -0.06374964f, 0.21312477f, 0.19003101f, 0.29823375f, -0.04613962f, -0.05032048f, 0.07204501f, 
    -0.07936407f, 0.01289651f, -0.18301196f, 0.07414511f, 0.11576231f, -0.10658518f, -0.08579325f, 0.10204075f, 
    0.10803376f, -0.04420204f, 0.08071261f, -0.13232344f, 0.05128283f, 0.06475053f, -0.11968964f, -0.03570734f, 
    0.07929336f, 0.03032804f, 0.00492425f, -0.02211103f, -0.00801007f, -0.33256218f, -0.06811039f, 0.21874066f, 
    -0.07740855f, -0.09271888f, 0.10192988f, 0.06924505f, -0.05705133f, 0.52123016f, 0.09274453f, 0.02227822f, 
    -0.18830377f, -0.18292344f, -0.11661100f, -0.13449429f, -0.10355183f, -0.10553232f, 0.12736899f, -0.02449372f, 
    0.00509262f, 0.13626149f, -0.08722652f, -0.05548327f, -0.19237386f, 0.10838316f, -0.09249870f, -0.45064956f, 
    -0.14685562f, -0.03331307f, -0.01963883f, -0.11998994f, -0.10736099f, -0.15853609f, -0.05173181f, -0.28287014f, 
    -0.06362376f, -0.03454778f, 0.04015460f, 0.06116608f, -0.04659199f, 0.04145596f, -0.00070341f, -0.08441003f, 
    -0.01405872f, -0.06187662f, -0.02798870f, -0.03616622f, 0.00630698f, 0.03983468f, -0.06436825f, -0.04026916f, 
    -0.00072212f, -0.02872456f, 0.02782820f, -0.02897027f, 0.04693217f, -0.00423002f, -0.04493730f, -0.06181310f, 
    -0.08785824f, -0.05334997f, -0.05004864f, -0.07319033f, 0.05786455f, 0.03074466f, -0.05182756f, -0.01719441f, 
    -0.05789029f, 0.00793020f, 0.00442589f, 0.06990922f, -0.08419329f, 0.00578519f, -0.04092930f, 0.00379760f, 
    0.02778617f, -0.07710527f, -0.03257923f, -0.02418034f, -0.04963933f, -0.09960818f, -0.04507764f, 0.06123621f, 
    0.00503208f, 0.01067054f, -0.03859171f, -0.06731173f, -0.07534502f, 0.06442297f, 0.01309615f, 0.00388351f, 
    0.04682997f, -0.07330415f, 0.02521374f, 0.01901580f, -0.05994203f, -0.04179955f, -0.08084192f, 0.00352619f, 
    0.01178222f, -0.00779551f, 0.02912971f, -0.06928312f, 0.02094220f, 0.03975749f, 0.00195202f, -0.04579968f, 
    -0.01693950f, -0.04881333f, 0.03250679f, 0.00652002f, -0.09465525f, -0.07895678f, -0.03983197f, -0.04156593f, 
    -0.04160017f, -0.08705802f, -0.07882652f, 0.05788575f, -0.08752952f, 0.05781628f, 0.02146923f, -0.05046296f, 
    0.06472100f, 0.05374921f, -0.05612919f, 0.06145459f, -0.01249629f, -0.01786313f, -0.08856551f, -0.03633176f, 
    0.00841987f, -0.06398632f, -0.07843491f, 0.01282721f, 0.02597530f, 0.04013109f, 0.04109495f, -0.03164105f, 
    0.02481062f, 0.02997253f, -0.07284600f, -0.03937630f, -0.01781919f, -0.08542880f, 0.04973729f, -0.01484796f, 
    -0.00714208f, 0.07063925f, -0.06035489f, -0.03638100f, -0.02816689f, 0.04867902f, -0.07491938f, -0.01601222f, 
    -0.04560205f, -0.00639569f, -0.03431314f, 0.00898269f, -0.06301562f, 0.02283499f, 0.05796175f, 0.00076109f, 
    0.00002255f, -0.09158901f, -0.04473479f, -0.07323761f, -0.08996243f, 0.06235205f, 0.01995873f, 0.05046649f, 
    0.04724349f, 0.04801801f, 0.04244018f, -0.00812436f, 0.06791387f, -0.08898586f, -0.05357951f, -0.01161471f, 
    -0.05591735f, -0.09177657f, -0.09004246f, -0.08983880f, -0.03925080f, -0.10078913f, -0.02316765f, 0.01102388f, 
    0.04004611f, -0.03969195f, 0.05433528f, -0.06317756f, -0.00247718f, 0.04377014f, -0.09469472f, -0.10073075f, 
    -0.02629232f, -0.03263945f, -0.04210166f, 0.05006926f, 0.00627132f, -0.09144278f, -0.06355470f, -0.08803877f, 
    0.06094196f, -0.03400481f, 0.06232518f, -0.02093382f, 0.01282192f, -0.02746372f, -0.09165186f, -0.02364239f, 
    -0.07859471f, 0.04923456f, -0.08499792f, 0.00331288f, 0.05171160f, -0.06021325f, -0.00174000f, 0.05362204f, 
    -0.08007534f, -0.04628702f, -0.05096656f, -0.06342835f, -0.08942082f, 0.04865041f, -0.02629798f, 0.00116589f, 
    0.02515919f, -0.09575420f, -0.08014546f, -0.07508839f, -0.05497966f, -0.06984247f, 0.05840803f, -0.02273850f, 
    0.02180703f, 0.00312847f, -0.03752809f, -0.05151760f, 0.05691444f, -0.07627308f, 0.05303260f, -0.05787631f, 
    0.04368536f, -0.07141116f, 0.00389515f, 0.03310511f, -0.01594804f, 0.01603923f, -0.04567852f, -0.04481408f, 
    -0.02005358f, -0.07106747f, -0.01612089f, -0.00619984f, -0.08939125f, -0.07435577f, -0.01055447f, -0.07914329f, 
    -0.04089835f, 0.03061067f, 0.00142223f, 0.01038307f, 0.04420905f, -0.04364210f, 0.05802370f, -0.09007178f, 
    -0.06466359f, -0.06254296f, -0.04349261f, -0.02412427f, -0.05266936f, 0.01919726f, -0.01828242f, -0.08125918f, 
    0.06115879f, 0.02988099f, 0.02650177f, -0.06244799f, -0.05019663f, -0.05061625f, -0.00916977f, -0.00676863f, 
    -0.00999392f, -0.01427808f, -0.04263906f, -0.02310452f, 0.01908073f, -0.03142222f, -0.06214771f, 0.03141892f, 
    0.04434042f, -0.06473636f, -0.02248671f, -0.02975322f, -0.09658850f, -0.09909762f, 0.02872767f, -0.02952127f, 
    -0.02599939f, 0.04675740f, 0.04722529f, 0.03076181f, -0.06034097f, -0.07196068f, -0.07617538f, -0.06792647f, 
    -0.10023195f, -0.05880328f, -0.02128145f, -0.05489267f, -0.09681020f, -0.08184285f, 0.04227167f, -0.01381360f, 
    -0.04495335f, -0.00266324f, 0.03042195f, 0.00763711f, -0.08075944f, 0.04046766f, -0.06540550f, -0.02262907f, 
    -0.06454994f, -0.34263402f, -0.33114925f, -0.08887900f, 0.11131951f, 0.04251054f, 0.09286052f, 0.13575691f, 
    0.02989750f, 0.16194326f, 0.20943327f, -0.11233926f, 0.17422132f, 0.03291678f, -0.01878798f, 0.16594471f, 
    0.12817600f, -0.03671500f, 0.08681467f, -0.00344051f, 0.13820697f, -0.14777295f, -0.53631878f, -0.09344953f, 
    0.00187412f, -0.18308817f, 0.16206655f, -0.30548087f, -0.08125641f, 0.26603889f, -0.01845145f, 0.04878984f, 
    0.01907737f, -0.12906919f, -0.08243287f, 0.02455731f, 0.03382931f, 0.51238096f, -0.08471897f, 0.19132793f, 
    -0.09154670f, -0.29926822f, 0.10701730f, 0.07292346f, 0.07872172f, 0.02666406f, 0.30519161f, -0.30453640f, 
    -0.03103848f, 0.18072501f, -0.07938851f, 0.18864170f, 0.12117069f, 0.13296723f, 0.28897169f, -0.06149700f, 
    -0.16256766f, -0.06031578f, 0.24870160f, 0.13025141f, -0.19942677f, -0.11414560f, -0.28307495f, -0.69213486f, 
    -0.16235201f, -0.34775653f, 0.07918422f, 0.04837790f, 0.06925925f, -0.09356529f, -0.05169598f, 0.03991772f, 
    0.47982687f, -0.12731375f, -0.03455000f, 0.10505001f, 0.18285373f, 0.11560965f, 0.25547829f, 0.01519041f, 
    -0.07787571f, -0.29619655f, 0.45258787f, -0.23044221f, -0.03441902f, 0.01562490f, 0.12845607f, -0.07337577f, 
    0.08956389f, 0.08155268f, -0.00366436f, -0.03039869f, -0.06846235f, -0.10828599f, 0.04333572f, -0.15987013f, 
    -0.22150071f, -0.00783582f, 0.13213134f, 0.25386012f, 0.24500661f, 0.09414154f, 0.14349963f, -0.04328880f, 
    -0.02363295f, -0.08361398f, 0.13194929f, 0.17002805f, -0.19549128f, -0.21532020f, 0.33524439f, -0.13264477f, 
    -0.01016394f, -0.26393160f, 0.02044416f, 0.04792738f, 0.04932957f, -0.07346296f, -0.28957894f, -0.09837613f, 
    -0.01282592f, 0.21963036f, -0.05395454f, 0.10204803f, 0.00533630f, 0.00244887f, 0.02376014f, -0.38220456f, 
    0.14629978f, -0.04760568f, 0.11226813f, 0.10950871f, -0.02089232f, 0.00379916f, 0.04034470f, -0.18307407f, 
    -0.13410124f, 0.34863213f, -0.03371948f, 0.12257662f, -0.03589401f, 0.02899090f, -0.06999990f, 0.02424257f, 
    0.08291576f, -0.19103521f, 0.03615562f, 0.09938662f, 0.09274219f, 0.21025021f, -0.17001458f, 0.07713427f, 
    0.06823377f, -0.23137596f, 0.17077169f, 0.16178069f, 0.03853549f, 0.08379982f, -0.10729272f, -0.10083913f, 
    0.08663669f, 0.04528870f, 0.30956542f, 0.23983455f, -0.11578425f, -0.42243746f, 0.04411579f, -0.04352535f, 
    -0.11557756f, 0.13443734f, -0.01563404f, -0.14118646f, -0.40143687f, 0.02007873f, -0.01116742f, 0.01517109f, 
    -0.10613523f, -0.01334990f, -0.01591153f, -0.00976763f, 0.25752217f, -0.29850996f, 0.07238745f, -0.04775931f, 
    -0.02700152f, -0.01404742f, 0.10508546f, 0.00033517f, 0.22675098f, 0.16504343f, 0.10409819f, 0.06609355f, 
    0.19625673f, -0.09807547f, -0.11682405f, 0.12541668f, -0.08848803f, -0.01050009f, -0.76845235f, -0.43916324f, 
    -0.21783432f, 0.14283043f, 0.24119620f, -0.06852928f, 0.03885020f, -0.20708361f, -0.15568279f, -0.40699542f, 
    -0.38018641f, -0.01841287f, 0.19062269f, 0.29712343f, -0.04444128f, 0.01651742f, -0.01292986f, -0.15997164f, 
    0.04542366f, -0.17711978f, 0.03368257f, -0.06360332f, 0.01649436f, 0.04818569f, 0.02772145f, 0.22795288f, 
    0.16164348f, -0.31291685f, -0.12176961f, 0.14060102f, 0.11758987f, 0.09953118f, 0.01997117f, 0.06382722f, 
    0.10201912f, 0.09107096f, -0.29852811f, -0.15790355f, 0.35139310f, -0.12026135f, -0.34923217f, 0.04061872f, 
    0.00147690f, -0.00412305f, 0.08737077f, 0.17379923f, -0.03798329f, 0.18897519f, 0.07779667f, 0.02133887f, 
    -0.05691175f, -0.00898626f, 0.03693331f, 0.00943634f, 0.21512322f, 0.13527788f, -0.59107828f, 0.04095167f, 
    -0.10484067f, -0.08253174f, 0.04115694f, -0.10467277f, 0.28162622f, -0.03770373f, 0.01648301f, 0.10084858f, 
    -0.05810092f, -0.00102837f, -0.17982155f, 0.02488839f, -0.10860556f, 0.04862624f, -0.30313781f, 0.15158564f, 
    -0.05484362f, -0.07172129f, -0.05398607f, -0.02275874f, 0.04596604f, 0.10268972f, -0.00139063f, -0.02871474f, 
    0.18901016f, 0.18519832f, 0.12761055f, 0.18275651f, -0.03208587f, -0.08464597f, 0.10763027f, -0.00533006f, 
    0.72131044f, 0.15027310f, 0.19931012f, 0.12453721f, 0.03497953f, -0.04866587f, -0.11552492f, 0.17325839f, 
    -0.01800194f, -0.41923526f, -0.24222212f, -0.53186375f, 0.07726553f, 0.22599991f, 0.36263999f, 0.03408105f, 
    -0.03776024f, -0.23577657f, -0.40167019f, -0.14254510f, -0.18795745f, 0.03554414f, -0.10971530f, -0.04479982f, 
    -0.18275720f, -0.04825620f, -0.20306093f, -0.39231771f, 0.23383135f, -0.32431370f, -0.01911177f, -0.11097191f, 
    0.03631450f, 0.11822035f, -0.18406396f, -0.07097252f, -0.13264608f, -0.21747619f, -0.08187024f, 0.06300453f, 
    0.05385535f, 0.19800584f, 0.14256662f, -0.11262549f, -0.02482813f, 0.25248551f, 0.00306715f, 0.14117616f, 
    0.07958934f, 0.15342931f, 0.13199458f, 0.19349931f, 0.02185741f, -0.19031504f, 0.20020163f, 0.07321826f, 
    0.12712441f, -0.26142579f, -0.24042135f, 0.07795407f, 0.01137151f, 0.04256357f, 0.23796682f, -0.03471103f, 
    -0.00795108f, -0.22386040f, -0.20407079f, 0.02951057f, -0.05312462f, 0.00859764f, -0.00734087f, 0.00519014f, 
    -0.01628016f, 0.34269631f, 0.17568058f, 0.08800413f, 0.03232681f, 0.26177064f, -0.05510163f, 0.13718048f, 
    0.13106476f, -0.08617139f, -0.25902921f, -0.16299070f, -0.02908599f, -0.23340856f, -0.34036118f, 0.08330663f, 
    -0.29165086f, 0.03950988f, -0.30623549f, 0.15042713f, -0.07884964f, -0.19827440f, 0.05570325f, -0.06184952f, 
    -0.17057708f, -0.04860305f, -0.02436153f, -0.27630678f, 0.04872634f, -0.01790145f, 0.20481162f, 0.07769093f, 
    -0.01237091f, 0.09670983f, 0.06547938f, 0.01840045f, -0.10095219f, -0.08283980f, -0.41141638f, 0.01106582f, 
    0.02417646f, 0.16173214f, 0.05198739f, 0.15186195f, -0.00028494f, 0.06961494f, -0.02319223f, -0.16273305f, 
    -0.16763385f, 0.19499017f, -0.20344701f, -0.00712770f, 0.03041784f, -0.00521993f, 0.11923908f, 0.06968997f, 
    0.34795117f, 0.08979061f, 0.18727514f, 0.21478209f, 0.29025093f, 0.18466702f, -0.03317899f, -0.11055641f, 
    0.33183673f, -0.12810372f, 0.12085132f, -0.23250654f, -0.05080307f, -0.14829591f, 0.29354343f, 0.09415121f, 
    0.40800202f, 0.05993035f, -0.01738043f, 0.02971635f, 0.06799854f, 0.17467149f, -0.20358369f, 0.08100460f, 
    -0.04367537f, 0.04086931f, -0.07475979f, 0.13074902f, 0.16188450f, -0.02350883f, -0.24206555f, 0.12815498f, 
    0.04116942f, 0.28136832f, -0.43177792f, -0.45307899f, 0.03383154f, 0.02945899f, -0.13750954f, -0.09590483f, 
    -0.05650342f, -0.01721272f, 0.07890634f, -0.31060407f, -0.06398211f, -0.26997423f, -0.05422001f, -0.01175591f, 
    -0.13968115f, -0.03990255f, -0.03089336f, 0.18680602f, -0.00282094f, 0.24268462f, -0.30110219f, -0.16447897f, 
    0.09787808f, 0.16669704f, -0.06468207f, -0.01040296f, -0.11159849f, 0.38844782f, 0.14968514f, 0.23746173f, 
    0.00266240f, 0.08110182f, -0.20193361f, 0.16583416f, 0.16633645f, 0.02088770f, 0.10493685f, 0.06940479f, 
    -0.25522283f, -0.06144836f, -0.01673470f, 0.15200862f, 0.09571503f, -0.15544854f, -0.11303389f, 0.02661112f, 
    -0.10121819f, -0.01981491f, 0.18456669f, -0.13088296f, -0.02762479f, 0.06937095f, 0.07107778f, 0.01055517f, 
    -0.11542381f, -0.21256097f, -0.21671720f, 0.18221286f, 0.09999013f, 0.01493516f, -0.02299514f, -0.00242385f, 
    -0.20640367f, -0.19750783f, 0.36711261f, 0.20605163f, 0.03702052f, -0.00896854f, 0.03155795f, -0.14101334f, 
    0.14820832f, -0.02655800f, -0.07714048f, -0.56227231f, -0.20107272f, -0.10530436f, -0.04107709f, 0.02011928f, 
    -0.10132951f, -0.00133184f, 0.13760468f, -0.27546948f, -0.04696720f, 0.31096551f, 0.23340292f, 0.15783693f, 
    0.19007631f, -0.15708636f, 0.04750811f, -0.01680593f, -0.36746213f, -0.10655781f, 0.17128676f, 0.20291284f, 
    0.02366170f, -0.13145573f, 0.07514597f, 0.16607291f, 0.00063200f, -0.01794993f, 0.09313158f, 0.10726095f, 
    0.05242722f, -0.16098660f, 0.01188957f, 0.10240212f, 0.12500598f, 0.12672828f, -0.02714325f, -0.17824359f, 
    -0.10764331f, 0.09315798f, 0.09085611f, 0.19205041f, -0.04861020f, -0.26282439f, -0.12422474f, 0.08903872f, 
    0.20295599f, 0.04567871f, 0.06080667f, 0.04437769f, -0.05638433f, 0.12675630f, -0.15618679f, 0.17623748f, 
    0.05084522f, -0.03874718f, -0.07091856f, -0.00565614f, -0.01646797f, -0.06908312f, -0.02764430f, -0.07603414f, 
    0.06897108f, -0.03518054f, 0.03210398f, 0.06743050f, -0.06897442f, -0.01975921f, -0.04443912f, -0.05815988f, 
    -0.03380452f, 0.04212198f, -0.07292187f, -0.08758441f, -0.02698301f, 0.00548422f, -0.01121982f, -0.01174792f, 
    -0.00270293f, -0.01652595f, -0.00674072f, -0.05439793f, -0.00508070f, -0.08755223f, 0.03106411f, -0.02474096f, 
    -0.04415904f, 0.08063366f, 0.03870589f, -0.02156201f, -0.05607413f, 0.05940117f, 0.03313921f, 0.06159093f, 
    0.02530883f, 0.05814376f, -0.01104487f, 0.00465092f, 0.04894730f, -0.01494917f, -0.07028263f, -0.05975671f, 
    -0.06177959f, -0.00482088f, -0.08300027f, -0.05966385f, -0.07875075f, 0.02751832f, -0.00555554f, 0.01481792f, 
    -0.04235874f, 0.06846084f, -0.00766633f, 0.03882742f, -0.05239389f, -0.07256497f, -0.07430924f, 0.04892739f, 
    0.02042739f, 0.04984923f, -0.00714271f, 0.01434921f, 0.04184336f, -0.09991336f, 0.00066003f, 0.01551869f, 
    -0.03739286f, 0.06053240f, -0.06139592f, -0.03102896f, -0.00084298f, -0.06416356f, -0.04548048f, -0.06858940f, 
    0.02908473f, -0.01679080f, 0.05382720f, -0.04482456f, 0.00258049f, 0.06809197f, 0.04852408f, -0.04144080f, 
    0.02729355f, -0.06193918f, -0.08314055f, 0.05423100f, 0.03508095f, 0.05228925f, -0.08629822f, -0.08320605f, 
    0.00022413f, -0.08435752f, -0.05984273f, 0.02462350f, 0.04585249f, -0.03709657f, 0.05978719f, 0.02721724f, 
    0.03681961f, -0.01103625f, -0.02273295f, -0.00896965f, 0.01130234f, -0.02365908f, 0.01320415f, 0.02824514f, 
    -0.02252539f, -0.04560994f, -0.06501347f, 0.06393231f, -0.04610853f, -0.00151513f, -0.04160873f, -0.07423520f, 
    -0.01644067f, -0.03040355f, 0.04063884f, 0.02686363f, 0.05456654f, -0.04295853f, -0.01604095f, -0.05836691f, 
    0.05714603f, -0.08032971f, 0.00874714f, -0.04433234f, -0.00856167f, 0.06137345f, 0.01202396f, 0.04583944f, 
    0.05899448f, 0.05107672f, -0.00858472f, -0.01916537f, -0.07904297f, 0.03915627f, -0.08257749f, -0.09470028f, 
    0.37703776f, -0.13721448f, 0.28238112f, 0.12613478f, 0.06557486f, -0.00273822f, 0.13074815f, -0.02641993f, 
    0.16759883f, -0.36682025f, -0.26470521f, 0.14388658f, 0.04270944f, -0.05988691f, 0.11750403f, 0.19251433f, 
    0.02514684f, 0.04107077f, -0.12452637f, -0.65554869f, -0.04696209f, 0.02427796f, 0.04471198f, 0.04173438f, 
    -0.10417699f, -0.01488521f, -0.41139844f, 0.52288902f, -0.15858324f, 0.06935294f, 0.10244446f, -0.22951876f, 
    0.06525306f, -0.15341820f, 0.05012066f, 0.08246911f, -0.20344083f, -0.11320186f, 0.02454546f, 0.09438318f, 
    -0.09638692f, 0.02214849f, -0.11671222f, -0.12602560f, 0.03506292f, 0.02806523f, 0.00275484f, -0.09115951f, 
    -0.07865124f, 0.17901760f, -0.06870642f, 0.06146509f, 0.13648239f, -0.04250445f, -0.00808311f, 0.43172750f, 
    0.28718975f, 0.01026778f, -0.06236237f, -0.08906922f, -0.07987920f, 0.09761091f, 0.07511552f, -0.18301272f, 
    0.25068676f, -0.03395212f, -0.03952548f, -0.23396707f, -0.33842370f, -0.10973409f, -0.08808593f, 0.04718193f, 
    -0.15248710f, 0.27742967f, -0.18263383f, 0.04152200f, 0.07725905f, -0.05532140f, 0.08585057f, -0.04007173f, 
    -0.09747140f, 0.13689767f, 0.22791195f, -0.14197370f, -0.02122827f, -0.05631873f, 0.01927539f, 0.06792325f, 
    0.02777898f, 0.05499448f, -0.04197263f, -0.11764027f, -0.35673282f, -0.04370021f, 0.06053587f, -0.18070744f, 
    -0.16360901f, 0.19064826f, -0.01993427f, 0.02674419f, -0.66171873f, 0.02647104f, 0.05192183f, 0.09062081f, 
    0.15074325f, -0.04862778f, -0.05134398f, 0.11014244f, -0.36144394f, -0.12495029f, -0.26899832f, -0.05761988f, 
    -0.04453090f, 0.12624027f, -0.03637210f, 0.04020592f, 0.04820889f, 0.04416838f, 0.02218347f, -0.02224604f, 
    -0.12395461f, -0.15205735f, -0.12507269f, 0.07373451f, 0.09253653f, 0.07216521f, 0.44066373f, 0.20514795f, 
    -0.06591437f, 0.00519790f, 0.15277845f, 0.05240078f, 0.05817619f, -0.21117049f, -0.00514596f, 0.52455884f, 
    -0.08642447f, 0.04251036f, -0.01069117f, -0.07228483f, 0.02602477f, -0.07046715f, 0.17901023f, -0.03306964f, 
    0.06402204f, 0.11603045f, -0.14797719f, 0.07033379f, 0.05267506f, -0.01050586f, 0.06570323f, 0.06766751f, 
    0.11935341f, 0.03904871f, 0.09033317f, -0.13008210f, 0.23074153f, 0.13358127f, 0.15440536f, 0.03749491f, 
    0.15587686f, -0.13593534f, -0.06341165f, -0.38153243f, -0.25051755f, -0.11462500f, 0.05365922f, -0.23214041f, 
    0.12492948f, 0.23284650f, -0.14396380f, 0.10629635f, 0.21293522f, -0.02821983f, -0.10992564f, -0.10520539f, 
    0.01493899f, -0.06097548f, -0.05621770f, -0.03132416f, -0.17410983f, -0.16301362f, 0.07735769f, 0.05886880f, 
    -0.09821441f, 0.12924935f, -0.23045194f, -0.07036815f, -0.09372614f, -0.14893480f, -0.02206669f, 0.23421501f, 
    0.24533482f, 0.20786320f, 0.21276236f, -0.01886039f, -0.17969581f, -0.00437886f, -0.21980909f, 0.08043399f, 
    0.21173379f, 0.18067273f, -0.14854501f, 0.03963370f, -0.26272103f, -0.00541019f, 0.28315726f, -0.22080494f, 
    0.07196931f, -0.01024080f, -0.02274945f, 0.19448327f, 0.04731778f, 0.06796743f, -0.16935371f, 0.03971512f, 
    0.00493397f, -0.03903595f, -0.00320141f, -0.19984303f, 0.01441001f, 0.02078616f, -0.16516118f, 0.09775010f, 
    0.05996142f, 0.27384117f, -0.12235986f, 0.02736682f, -0.05588623f, 0.09200106f, -0.16935183f, 0.02739088f, 
    0.08005209f, 0.11230044f, -0.11977463f, 0.18361743f, -0.05910522f, -0.10113563f, 0.08967805f, 0.04003311f, 
    0.13684225f, -0.07642938f, -0.15934485f, 0.58122897f, 0.23955971f, -0.04113895f, 0.12609324f, 0.07619722f, 
    0.01855374f, 0.05831265f, 0.11808217f, 0.08107739f, 0.13071407f, -0.41239005f, -0.42549568f, 0.05417258f, 
    -0.01271251f, 0.22612153f, -0.05254238f, -0.02085330f, -0.03535670f, -0.38247949f, -0.05594529f, -0.25218457f, 
    -0.06616176f, -0.02443521f, 0.02646036f, 0.06516223f, 0.02056110f, -0.28835860f, 0.42631936f, 0.25533411f, 
    -0.01239815f, -0.04002823f, -0.06476793f, -0.10692809f, 0.12306010f, 0.10978889f, 0.00815305f, 0.19153233f, 
    -0.10675588f, 0.10770758f, 0.06934166f, -0.01808980f, 0.00836581f, -0.02426452f, 0.06478142f, -0.00049131f, 
    0.26329145f, -0.00066552f, 0.00458356f, 0.08848578f, 0.05092176f, 0.02769665f, -0.02303418f, 0.13879286f, 
    0.01267968f, -0.49355704f, 0.34136456f, 0.29949188f, -0.12944685f, 0.24088947f, 0.05098143f, 0.13239728f, 
    0.07100639f, -0.01499968f, -0.12709644f, 0.29482168f, 0.22109438f, -0.20954384f, -0.05064003f, -0.12407243f, 
    -0.02980230f, 0.17883103f, -0.15413286f, 0.26857740f, -0.42584485f, 0.11734073f, 0.21934468f, -0.14300105f, 
    0.04189127f, -0.11573405f, -0.07263678f, 0.06717540f, 0.31106028f, -0.34779751f, -0.23095143f, -0.11149360f, 
    0.03075191f, 0.09997231f, -0.00105114f, 0.06772237f, -0.03726183f, 0.10168451f, -0.41071093f, -0.18020506f, 
    0.19040218f, -0.04893066f, 0.21994849f, -0.02499772f, -0.17502190f, -0.02252064f, 0.15795791f, -0.17176290f, 
    -0.36770543f, -0.11428325f, -0.04376734f, -0.00461002f, -0.08104353f, -0.11090466f, 0.11581832f, -0.40666699f, 
    -0.27088773f, -0.18414356f, 0.17669173f, 0.14898340f, 0.08526988f, -0.10372640f, -0.02524422f, 0.13668691f, 
    -0.24263562f, 0.03780972f, 0.11376283f, 0.04728756f, 0.05577234f, -0.08486121f, 0.01194239f, 0.09014694f, 
    0.07046058f, -0.25066438f, 0.19526519f, -0.05794209f, -0.06929841f, -0.11320539f, 0.07352411f, 0.01610014f, 
    -0.01066003f, -0.10753106f, -0.78974086f, 0.26856107f, 0.06771132f, -0.02698717f, 0.09236706f, -0.01068280f, 
    0.02008613f, 0.02054063f, 0.00232850f, -0.06757531f, 0.23653126f, 0.54883295f, 0.08006912f, 0.02303795f, 
    0.05044496f, 0.12679805f, 0.05434084f, -0.01999566f, -0.11164513f, -0.28215048f, -0.00406807f, -0.03692103f, 
    -0.12835132f, 0.07470434f, 0.09949254f, 0.07733395f, 0.12112311f, 0.13822043f, 0.09785240f, 0.18070579f, 
    0.07443123f, -0.08114436f, 0.05040905f, 0.12495945f, -0.07173827f, 0.00378387f, 0.06116983f, -0.37578773f, 
    -0.28375176f, 0.11793570f, 0.00179632f, 0.04228374f, 0.12391657f, -0.02222268f, -0.10613189f, 0.13027099f, 
    0.00130246f, -0.06584130f, -0.09865251f, 0.08106760f, 0.04762684f, -0.05204839f, -0.00855602f, 0.15757291f, 
    -0.08516107f, -0.30395779f, -0.51017195f, 0.01753945f, 0.08276828f, 0.02542122f, 0.14749779f, 0.13615637f, 
    -0.12849654f, -0.06735305f, 0.10878412f, 0.08874553f, 0.08452523f, -0.02559258f, 0.06465874f, -0.02373945f, 
    0.07158213f, 0.15534869f, -0.33475429f, 0.33816582f, -0.06886803f, 0.17476739f, 0.20860246f, 0.18687148f, 
    0.02369336f, -0.02931376f, -0.23243769f, 0.19690587f, 0.01086944f, -0.26757565f, 0.07115646f, 0.01759686f, 
    0.07707810f, 0.00107455f, 0.00673687f, 0.07151111f, 0.25104582f, 0.24523650f, 0.10924971f, -0.19757195f, 
    -0.11594057f, -0.11874671f, -0.12937398f, 0.07775556f, 0.03595898f, 0.15178657f, 0.14103059f, 0.13446553f, 
    -0.13651569f, -0.30871975f, -0.05415504f, 0.01463070f, 0.14445798f, 0.05185684f, 0.06717274f, -0.26025006f, 
    0.16568211f, -0.13360965f, -0.24894893f, 0.06255466f, 0.00668706f, -0.24145325f, -0.03403447f, -0.31560591f, 
    -0.20590959f, 0.10983472f, -0.23715352f, -0.17621982f, -0.01883186f, 0.09976423f, -0.09915429f, 0.02723869f, 
    -0.16684188f, -0.23531909f, -0.22424057f, 0.23848455f, 0.01889735f, -0.17299661f, 0.02029909f, -0.08509381f, 
    0.11977248f, -0.39099044f, -0.09412532f, 0.57429165f, -0.12373584f, 0.04354447f, -0.02433278f, -0.10638326f, 
    0.22242904f, 0.12069695f, 0.31818694f, -0.03915471f, -0.09316060f, 0.11049522f, 0.07711697f, -0.04003982f, 
    -0.20980462f, 0.13792419f, 0.00604057f, -0.02706981f, 0.10516016f, -0.08137948f, 0.13557747f, 0.06707251f, 
    0.10039586f, -0.05770371f, 0.03864236f, 0.07174754f, 0.03000630f, -0.38251513f, 0.23138028f, -0.30902722f, 
    0.01734777f, -0.05772870f, -0.02401962f, 0.13937493f, 0.03076842f, 0.61458117f, 0.13490665f, 0.00562573f, 
    0.10173965f, 0.05719411f, -0.05106703f, -0.17810671f, 0.02970666f, 0.22160849f, 0.03933292f, 0.09790987f, 
    -0.08818791f, -0.09521585f, -0.03085657f, -0.08823548f, 0.06266583f, -0.03202481f, -0.22969820f, 0.18083248f, 
    0.22449383f, 0.09994291f, 0.20532663f, -0.03300042f, 0.01188882f, -0.05300197f, 0.05906558f, 0.09746850f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03418001f, 0.06113705f, -0.06720074f, -0.09008165f, -0.22024019f, -0.05575840f, -0.09684584f, 0.24150695f, 
    0.26008534f, 0.25248933f, 0.24225043f, -0.02500781f, -0.07333583f, 0.15457679f, 0.12135199f, 0.03967668f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.21785028f, -0.07426773f, 0.14673015f, -0.07926214f, 0.20835970f, -0.16240914f, -0.21295899f, -0.15509410f, 
    -0.42595741f, 0.49135554f, -0.08597763f, -0.10393235f, 0.05742437f, 0.20434789f, 0.27974069f, -0.15246382f, 
    -0.08788056f, 0.02886908f, 0.03117978f, 0.11021229f, -0.29908371f, 0.15821627f, 0.03970977f, 0.02941108f, 
    0.03077516f, 0.30701107f, 0.33002585f, 0.09904657f, -0.50101674f, -0.06001550f, -0.20522040f, 0.28760621f, 
    0.22766656f, -0.21462336f, -0.02762601f, 0.01896026f, -0.11952712f, 0.06981827f, -0.05842922f, 0.18947060f, 
    0.05292179f, -0.33631697f, -0.32135147f, 0.04584119f, -0.09707472f, 0.24569874f, -0.00146144f, 0.40628195f, 
    -0.14702895f, -0.03975639f, 0.15556476f, 0.20422271f, -0.07741129f, -0.04770035f, -0.04634053f, -0.08960615f, 
    0.19418868f, -0.23818088f, -0.13149910f, -0.02479112f, 0.13610560f, -0.17172691f, -0.22753517f, -0.17778312f, 
    -0.12858877f, -0.08457457f, 0.02879365f, -0.04245305f, 0.34887677f, -0.22976270f, -0.04182464f, -0.15248485f, 
    -0.47929108f, 0.36056009f, -0.19426705f, 0.22887154f, -0.08599099f, 0.36216623f, 0.34472510f, -0.22939049f, 
    -0.01472147f, 0.22225139f, 0.16263556f, 0.16127598f, -0.26906562f, -0.20586450f, 0.16363402f, -0.03927558f, 
    -0.09500842f, 0.09393928f, -0.56387764f, 0.22436811f, -0.21854700f, 0.71509486f, 0.18244174f, 0.32894093f, 
    -0.07935084f, 0.03768241f, -0.16842474f, -0.04791420f, -0.40129617f, -0.19311596f, 0.02711278f, 0.22042930f, 
    0.02648905f, 0.05748823f, -0.60772097f, -0.20171304f, -0.75519222f, 0.09320613f, 0.44018355f, 0.12711753f, 
    -0.15521036f, 0.12051147f, 0.02761212f, 0.00122307f, 0.02445483f, 0.08213863f, 0.16811085f, 0.34072000f, 
    0.30276459f, 0.08164011f, 0.17107457f, 0.08473451f, 0.16128393f, -0.03864110f, -0.32708898f, -1.06495810f, 
    -0.10833471f, 0.00856995f, 0.04927580f, 0.01446133f, -0.46658546f, -0.02817610f, -0.22929646f, 0.31601086f, 
    0.32253280f, -0.41969553f, 0.54626477f, 0.03534262f, 0.21347104f, -0.22243783f, 0.17861432f, -0.02876337f, 
    -0.17136635f, 0.08332074f, 0.15613824f, 0.11766192f, 0.33359188f, 0.16783115f, -0.05285046f, 0.57111204f, 
    0.08043706f, -0.13942303f, 0.34799507f, -0.05003561f, -0.63562709f, -0.45902285f, -0.01679263f, 0.32690594f, 
    -0.12612198f, 0.18398027f, 0.05202052f, -0.21115495f, 0.00411969f, -0.22152229f, 0.16830309f, -0.31512362f, 
    0.32928279f, -0.17296797f, -0.20108198f, -0.25424516f, -0.35363472f, 0.64905959f, 0.35170445f, 0.03985486f, 
    0.09913129f, -0.06627765f, 0.21840315f, 0.18969063f, 0.09392085f, -0.10890590f, 0.05043283f, 0.24974360f, 
    0.42793342f, -0.22305366f, -0.41203561f, 0.13952260f, 0.04279833f, 0.24901280f, 0.41496038f, -0.27318257f, 
    -0.15431572f, -0.00583158f, 0.07724099f, 0.13904662f, -0.09443118f, -0.05320777f, -0.12676041f, 0.28122884f, 
    -0.18061449f, -0.24509011f, 0.37447107f, -0.09820817f, -0.15445496f, 0.24005853f, -0.27261817f, 0.06781923f, 
    -0.15843971f, -0.10530753f, -0.24097589f, 0.19322969f, -0.12989107f, 0.18600500f, 0.14172746f, 0.11174373f, 
    0.63478041f, -0.28016895f, -0.28386119f, 0.05330354f, 0.12770198f, -0.08130282f, 0.09509844f, 0.21765770f, 
    0.03792378f, 0.05320640f, 0.07816920f, 0.15225227f, -0.21959490f, -0.14597836f, -0.13418400f, -0.16132724f, 
    -0.25603181f, -0.15323280f, 0.30451256f, 0.18410853f, -0.08302855f, -0.01301163f, -0.24258071f, 0.41135761f, 
    0.11463349f, -0.03863158f, -0.03907853f, -0.16880436f, 0.52501464f, 0.20358108f, -0.05417059f, -0.05562229f, 
    -0.48081160f, 0.54668611f, 0.17442164f, -0.02666254f, 0.09448161f, -0.11375693f, -0.14822336f, 0.13180199f, 
    -0.14709687f, -0.14888880f, 0.16492519f, -0.03899866f, -0.17358044f, -0.21063738f, -0.16895290f, -0.25741580f, 
    0.21920964f, 0.30073431f, 0.31994599f, -0.04974860f, 0.45797321f, 0.00131812f, -0.54752576f, 0.35539129f, 
    0.00450703f, 0.05105186f, 0.02045078f, -0.12682052f, -0.23173356f, 0.12686606f, 0.11010889f, 0.02889104f, 
    0.22221543f, 0.13279147f, 0.61706519f, -0.13664465f, 0.25653824f, -0.29117790f, 0.16419627f, 0.16718104f, 
    -0.15738156f, 0.05573235f, -0.04715267f, -0.06474870f, 0.80243766f, -0.01170173f, 0.03167061f, 0.13185979f, 
    0.08365535f, -0.33980885f, -0.45456624f, 0.09249155f, 0.23712316f, 0.29293039f, -0.48246390f, 0.25022763f, 
    0.11886966f, -0.17668445f, -0.17998850f, -0.16359213f, 0.37887445f, -0.12987795f, -0.19895004f, -0.55985278f, 
    -0.88894248f, -0.06729965f, -0.15520029f, -0.15403718f, 0.69333035f, 0.34265366f, -0.04591018f, 0.09986800f, 
    0.00636218f, 0.06047366f, 0.12987855f, 0.06706442f, -0.18217649f, -0.22296742f, -0.12992752f, -0.15297151f, 
    -0.02181905f, -0.04023678f, 0.01671494f, -0.13953161f, 0.06877369f, -0.16313349f, -0.03464067f, -0.08899006f, 
    -0.11634055f, -0.07797274f, -0.12195998f, 0.07759179f, -0.06245286f, -0.13893446f, -0.03863439f, 0.36594644f, 
    -0.33386081f, -0.12628606f, 0.19566911f, 0.16318098f, 0.28240022f, 0.27588186f, -0.53415954f, -0.04256854f, 
    -0.18034475f, 0.08291922f, -0.01644283f, 0.02759262f, -0.39649537f, -0.09048448f, 0.08308028f, 0.20830409f, 
    0.06709822f, -0.07081243f, 0.43842524f, 0.08369281f, 0.07850880f, 0.05750439f, 0.24898188f, -0.39688298f, 
    -0.04213049f, -0.05001898f, 0.16177872f, 0.12760817f, -0.12789668f, -0.18949270f, 0.05697073f, 0.20035271f, 
    0.35389474f, 0.20828171f, 0.14411306f, -0.15523054f, -0.28101349f, -0.14785312f, 0.07856937f, 0.06514454f, 
    -0.01088368f, -0.21856605f, -0.10519215f, 0.06632795f, -0.24885234f, 0.06178751f, 0.15365955f, -0.12103932f, 
    0.54550612f, -0.00744610f, 0.18958294f, -0.14592353f, 0.07867060f, 0.00856921f, 0.32167357f, -0.50943571f, 
    -0.14571574f, 0.05627572f, -0.09589002f, 0.05683712f, -0.23097429f, 0.23286125f, 0.14872411f, 0.23003130f, 
    -0.07645031f, 0.05879327f, -0.25620875f, 0.14100623f, 0.14924832f, 0.18969147f, 0.57607603f, -0.25150332f, 
    -0.21730578f, -0.08308144f, -0.10575552f, -0.01876363f, -0.41205218f, -0.11621664f, -0.17362933f, -0.07544774f, 
    -0.45874611f, 0.53508776f, -0.03301927f, 0.02351836f, 0.35453817f, 0.20535137f, 0.36921710f, -0.16666944f, 
    0.06320681f, -0.18985775f, -0.11144450f, -0.00076798f, -0.00537644f, 0.02438928f, 0.08961193f, -0.36025423f, 
    0.75510526f, 0.11884757f, -0.04975892f, 0.20231348f, -0.02755766f, -0.19580033f, 0.21010423f, -0.02873177f, 
    -0.11375660f, 0.06887797f, 0.15448582f, 0.22081055f, 0.27603397f, 0.06293964f, -0.14229797f, -0.00725458f, 
    -0.24589497f, 0.54388797f, -0.01710680f, 0.05146908f, -0.05519869f, 0.09729178f, 0.42765564f, -0.19852957f, 
    -0.05004481f, -0.15402988f, 0.16031209f, -0.25793156f, -0.42770419f, 0.13096693f, 0.17496794f, -0.05639467f, 
    0.42171419f, -0.43923691f, 0.56887537f, -0.11444202f, 0.27151456f, 0.23646446f, 0.19986720f, 0.28696814f, 
    -0.09056232f, -0.08555872f, -0.03764236f, -0.13737908f, -0.06350593f, 0.10738233f, 0.20838502f, 0.01483774f, 
    0.17035642f, -0.21187380f, -0.21304563f, 0.09206988f, -0.07562475f, -0.03402439f, -0.15844850f, -0.07042405f, 
    0.15270764f, -0.13948630f, 0.10779482f, -0.15523358f, -0.24952401f, -0.12107455f, 0.05777650f, 0.41724619f, 
    0.13429424f, 0.06107815f, 0.49577391f, -0.01549400f, -0.21254744f, -0.19569291f, -0.12419944f, 0.18759064f, 
    0.14524069f, -0.09572408f, -0.07419413f, -0.08527556f, -0.42742199f, -0.14840899f, 0.15584350f, 0.35952097f, 
    -0.39316976f, -0.00397001f, -0.48167783f, 0.09816223f, 0.38525569f, 0.36546355f, 0.29179010f, -0.11416274f, 
    -0.10435796f, 0.16255093f, -0.19256324f, -0.12673295f, -0.10995120f, 0.03855777f, 0.23218060f, -0.03222567f, 
    0.05737072f, -0.05287448f, -0.03778800f, 0.06468862f, -0.19778332f, -0.13052902f, -0.15099242f, 0.05703577f, 
    -0.13226435f, -0.07523513f, -0.15869862f, 0.08055837f, -0.29606953f, -0.26732123f, 0.02051017f, 0.22413491f, 
    0.45786911f, -0.45272759f, -0.09953743f, 0.00002835f, -0.04171346f, 0.03015557f, 0.35287091f, 0.21574719f, 
    -0.01372308f, 0.03081007f, 0.01141993f, 0.14713261f, 0.52859640f, 0.00961307f, -0.11396134f, 0.38411599f, 
    -0.27208921f, 0.10812464f, -0.00172565f, 0.21093069f, -0.36925164f, 0.07695141f, 0.19073935f, -0.22148526f, 
    0.08079178f, -0.11152005f, -0.00556192f, 0.15944508f, 0.08674269f, -0.10682388f, 0.12442292f, -0.57039988f, 
    0.31367043f, 0.60455489f, 0.05831277f, 0.15956172f, -0.02756947f, 0.08331388f, -0.08247663f, 0.38747147f, 
    0.10744313f, -0.25105783f, 0.12920929f, 0.11200296f, 0.18760973f, -0.01404864f, -0.15967922f, -0.62679750f, 
    -0.25603119f, 0.33748376f, 0.35474506f, -0.05915133f, 0.70153880f, -0.49607044f, -0.12690264f, -0.13555557f, 
    -0.17552906f, 0.14453465f, -0.23004644f, -0.21145171f, 0.40567705f, -0.14415891f, 0.25947097f, -0.39364383f, 
    0.13567176f, 0.18219793f, 0.26617524f, 0.16452491f, 0.17761862f, -0.12903419f, -0.05288189f, 0.26901057f, 
    -0.09967050f, -0.15344554f, 0.10518289f, -0.00929267f, 0.40787014f, -0.00116244f, 0.18662307f, -0.01463970f, 
    0.37861827f, -0.13136330f, 0.17326061f, 0.10946947f, 0.19301492f, 0.15633023f, -0.26826197f, -0.86049139f, 
    0.07945349f, -0.17461362f, 0.15033576f, 0.00129416f, 0.35498917f, -0.21378708f, 0.03670396f, -0.31218717f, 
    -0.13042885f, -0.24992035f, -0.36348414f, 0.09328292f, 0.30348146f, 0.51771969f, 0.24940702f, 0.07668148f, 
    0.05228722f, 0.20520762f, -0.14140564f, -0.00873269f, -0.08959536f, 0.05337664f, 0.10704588f, -0.37882704f, 
    -0.56322914f, 0.36935902f, 0.36940944f, -0.21487521f, 0.28939039f, -0.07889123f, 0.12766756f, 0.45327950f, 
    -0.17198488f, 0.00039813f, 0.04902217f, 0.21107936f, -0.31601429f, -0.04338431f, -0.20892090f, 0.01947309f, 
    -0.65076923f, 0.24824318f, 0.33825573f, -0.13572554f, 0.34939811f, 0.13753733f, 0.43445495f, -0.35912338f, 
    0.00426683f, 0.08244801f, -0.12743832f, -0.11384892f, 0.34619269f, 0.23525031f, -0.09234691f, 0.20938186f, 
    -0.09769318f, -0.13197139f, -0.34089065f, 0.18260239f, 0.42129996f, -0.21107663f, 0.47425315f, -0.30405936f, 
    -0.17744082f, 0.10052328f, 0.17855743f, -0.07926269f, -0.18566053f, 0.01808830f, -0.12860221f, -0.18449621f, 
    -0.22297825f, -0.01113403f, -0.03862201f, 0.08057084f, 0.01518719f, -0.23676996f, 0.16582511f, -0.09763033f, 
    0.17927422f, -0.05204069f, -0.01598628f, 0.19683260f, -0.29958150f, 0.20653324f, 0.12515414f, 0.27320933f, 
    -0.18942672f, 0.08797480f, 0.16107558f, 0.12506917f, -0.28422979f, -0.00381195f, 0.20760623f, 0.21606033f, 
    0.14956394f, -0.07460483f, 0.04341763f, 0.12929779f, -0.07693256f, 0.08452707f, -0.16836098f, 0.62192363f, 
    0.01672320f, -0.01742104f, -0.17127489f, 0.14645934f, -0.67139673f, 0.05981072f, -0.22579992f, 0.39684564f, 
    -0.17009825f, -0.11429988f, 0.10491097f, -0.13636532f, -0.06582287f, -0.03526543f, -0.22736235f, -0.24625561f, 
    -0.05777236f, 0.20868114f, 0.11415003f, -0.02202960f, -0.08687016f, 0.09896459f, -0.22842401f, 0.61580020f, 
    -0.01905997f, -0.17553630f, 0.04742309f, 0.08122434f, -0.27143830f, -0.25157309f, -0.11961991f, 0.31124085f, 
    0.10591505f, 0.10370918f, 0.40862674f, 0.00152122f, -0.12616751f, -0.21953644f, 0.15430351f, 0.24298736f, 
    -0.00686491f, 0.07940161f, 0.03541370f, -0.24322625f, -0.25298470f, 0.15053478f, -0.02089962f, -0.14395879f, 
    -0.16258653f, -0.10630465f, 0.00978189f, 0.17723973f, -0.06327787f, -0.05000276f, 0.07045225f, -0.12636411f, 
    0.07445768f, -0.20433612f, 0.02710829f, 0.02658883f, 0.18368758f, -0.22884753f, -0.24359109f, 0.35914207f, 
    0.00059679f, -0.00799250f, 0.35523376f, -0.21928558f, -0.46690524f, -0.00978980f, 0.01156960f, -0.46426719f, 
    0.00792198f, 0.13324068f, 0.00361440f, 0.21222395f, 0.23620650f, -0.12181980f, -0.21070337f, -0.29776242f, 
    0.14030553f, 0.09484512f, -0.27998507f, -0.21624012f, -0.12405013f, 0.06076171f, 0.40562156f, 0.03787429f, 
    -0.15630604f, -0.20339185f, 0.16842261f, 0.19338050f, -0.18697117f, -0.18640068f, -0.06707284f, -0.29682198f, 
    -0.46845937f, 0.09747948f, 0.23459016f, 0.22471645f, -0.01650515f, 0.52313560f, -0.11137149f, 0.25121015f, 
    -0.09776069f, 0.12689233f, -0.15837432f, -0.17380491f, 0.52565116f, 0.21111289f, -0.23297495f, -0.42033568f, 
    -0.34044090f, -0.28479853f, 0.13175240f, 0.02540693f, 0.79976964f, -0.15743390f, 0.17178455f, -0.15611063f, 
    -0.21462053f, -0.09354612f, 0.21755257f, -0.06948794f, -0.11688989f, 0.03971821f, 0.08638591f, 0.04406763f, 
    0.33629835f, 0.11588360f, -0.53770393f, -0.17117169f, -0.16230580f, 0.33835718f, 0.33225414f, -0.20037916f, 
    0.04858000f, -0.14967354f, 0.10148973f, -0.16369380f, -0.21365468f, 0.12818336f, 0.03171187f, 0.40633893f, 
    -0.13420841f, -0.56146324f, -0.16112846f, 0.12774271f, 0.37217906f, 0.43272993f, 0.31161955f, -0.23055968f, 
    0.03535557f, 0.24271390f, 0.01657212f, -0.11169082f, -0.18287504f, 0.04160073f, 0.09288350f, -0.20027402f, 
    -0.06289595f, -0.23532826f, -0.18975911f, -0.06773558f, -0.03384453f, -0.10083202f, -0.01252317f, -0.02596718f, 
    0.12778902f, -0.17194095f, 0.08823124f, -0.07974456f, -0.46183565f, -0.00731615f, -0.15352264f, -0.44882214f, 
    0.13549724f, 0.67228377f, -0.06077913f, 0.22547458f, 0.19239675f, 0.47656831f, -0.15605406f, -0.23788458f, 
    0.04557980f, 0.22784971f, 0.05798849f, 0.19262025f, 0.17996982f, 0.05049562f, 0.01483724f, 0.12982041f, 
    0.16155916f, 0.00015299f, 0.29882571f, -0.10833880f, -0.05817462f, -0.08752327f, -0.33105192f, 0.36435544f, 
    -0.15937066f, 0.08662795f, 0.15481281f, -0.21408933f, 0.59840602f, -0.21893801f, -0.11940184f, 0.23797770f, 
    0.29097474f, 0.11206087f, -0.15185949f, 0.02076409f, 0.13061439f, -0.16285145f, 0.07520320f, -0.19391909f, 
    -0.10168799f, 0.10622237f, 0.23206042f, -0.05106386f, 0.44878387f, 0.19020309f, -0.06194308f, -0.34156454f, 
    0.09944338f, 0.36568734f, -0.61196810f, 0.13881516f, -0.56197429f, 0.48507151f, 0.19539662f, 0.16291749f, 
    0.22958228f, 0.18976066f, -0.08434281f, -0.22366646f, 0.02738544f, 0.18403691f, -0.18018579f, 0.06896696f, 
    0.17082892f, -0.22212435f, -0.05059586f, 0.06321663f, -0.18286495f, -0.14214684f, -0.19187383f, -0.17117210f, 
    -0.21190596f, 0.23007876f, 0.20691529f, 0.04464204f, -0.16401607f, -0.22399671f, 0.12638856f, 0.32312533f, 
    -0.22346002f, 0.35520041f, -0.42530319f, 0.05736300f, 0.24146381f, 0.49424508f, -0.51108617f, -0.33875477f, 
    -0.10171313f, -0.05295331f, -0.22753349f, -0.12465317f, 0.47477639f, 0.16813675f, 0.03656176f, 0.21285208f, 
    0.34541717f, 0.27574041f, -0.02961411f, -0.00333932f, -0.31615296f, -0.04782902f, -0.31623384f, 0.16076654f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.31107619f, 0.67479241f, 0.48541561f, -0.07203195f, 0.09940962f, 0.23823619f, 0.33804074f, 0.14322184f, 
    0.29617396f, -0.01886430f, 0.52647960f, 0.47435519f, 0.38628021f, -0.05211631f, 0.25431749f, -0.27374673f, 
    -0.11393327f, 0.01316698f, -0.04668852f, -0.33576912f, 0.04873719f, 0.08215406f, 0.70906365f, 0.46191788f, 
    0.18409303f, 0.19759406f, 0.04581365f, 0.52996832f, -0.10968114f, 0.27044266f, 0.04211666f, 0.18284042f, 
    0.01990245f, -0.18112618f, -0.13647372f, 0.43140867f, 0.20114549f, 0.03326451f, -0.05120745f, -0.00592226f, 
    -0.26521841f, -0.07208384f, 0.09484781f, 0.01472740f, 0.06081629f, -0.05981232f, 0.23164392f, 0.24533565f, 
    -0.16849320f, 0.19686359f, 0.59225833f, -0.23810402f, 0.36891010f, -0.09939540f, 0.43306014f, 0.08145114f, 
    0.08444506f, 0.72280157f, 0.41533548f, 0.35895970f, 0.14324450f, -0.25149840f, 0.43502134f, -0.06172763f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.10859884f, 0.08104288f, 0.02937981f, -0.15177825f, 0.09618020f, 0.00550508f, 0.15602590f, 0.28418103f, 
    -0.21303041f, 0.25196418f, -0.27603427f, 0.03083747f, 0.05140459f, -0.10717127f, -0.28410107f, 0.04181311f, 
    -0.11904256f, -0.02968957f, -0.02440717f, -0.84533852f, -0.07958286f, 0.14053816f, -0.15285149f, 0.08764789f, 
    -0.58249968f, 0.00241018f, -0.10073008f, -0.28207061f, 0.09840763f, -0.27259219f, -0.12115090f, 0.02167469f, 
    0.12850924f, -0.05115743f, -0.24033882f, 0.29956254f, -0.23002459f, 0.06752329f, -0.28965634f, 0.25111485f, 
    -0.31950441f, -0.09328286f, 0.02615927f, 0.31640226f, -0.12142830f, 0.16200379f, 0.40315568f, -0.11519991f, 
    0.01939141f, 0.02481990f, 0.12949263f, 0.00198874f, -0.54000974f, -0.46654686f, 0.03321431f, 0.04388873f, 
    0.02571596f, -0.13114569f, 0.02032543f, 0.08484363f, -0.02033862f, 0.01934026f, 0.72125745f, 0.10701665f, 
    -0.36984438f, 0.42624423f, 0.01469843f, 0.03867917f, -0.30389619f, -0.20333987f, -0.11677331f, -0.00449505f, 
    0.26154858f, 0.16151838f, -0.00950025f, 0.22809233f, 0.10061225f, 0.05939024f, -0.07089809f, -0.26791534f, 
    -0.06689980f, 0.07799128f, 0.00176818f, 0.92524898f, -0.02130538f, 0.21403459f, 0.22578850f, 0.05794724f, 
    0.07638285f, 0.08811890f, -0.35279530f, 0.20425090f, -0.12407910f, 0.11234444f, -0.06198150f, 0.15126109f, 
    -0.05952862f, 0.03379396f, 0.05964829f, 0.14722945f, -0.27411339f, 0.63885677f, -0.17368032f, -0.65597183f, 
    -0.24242993f, -0.31095144f, -0.33728993f, -0.07381573f, -0.10312206f, 0.11794490f, 0.20953894f, -0.36081666f, 
    0.15533718f, 0.06536084f, 0.26995796f, 0.06913880f, -0.30313045f, 0.63688087f, -0.11799358f, 0.22473727f, 
    0.04886472f, -1.02165222f, 0.05449966f, 0.14149159f, -0.52641827f, -0.02534811f, 0.20201504f, -0.08378007f, 
    0.10263610f, 0.10668692f, 0.13386549f, -0.01070964f, -0.05748055f, 0.10467096f, -0.19029255f, -1.42230928f, 
    -0.44493255f, -0.05009059f, 0.19631357f, -0.18739831f, -0.00501257f, 0.17596151f, -0.49955270f, 0.21537974f, 
    0.19801456f, -0.14301941f, 0.36814767f, -1.24962556f, -0.05369081f, -0.56514180f, -0.75872165f, 0.05840318f, 
    -1.72135115f, -0.58543676f, -0.55411398f, 0.00028762f, -0.19116628f, -0.03462426f, -0.05454730f, 0.03564760f, 
    -0.44051304f, 0.12037753f, -0.22593898f, -0.03058339f, 0.37351334f, -0.19763942f, 0.29664609f, -1.29890525f, 
    -0.08663484f, 0.01051089f, -0.48135760f, -1.10815847f, 0.08141287f, 0.02665114f, 0.10295788f, 0.41160682f, 
    -0.03617826f, 0.01462200f, -0.35541859f, -0.14684504f, -0.11128050f, -1.68108904f, 0.01005738f, -0.65295345f, 
    0.04569724f, -0.49584907f, 0.36899769f, -0.04435092f, 0.49835575f, 0.00023649f, -1.04243374f, 0.44074458f, 
    0.25142580f, -1.16052759f, -0.28423110f, -0.04945273f, 0.02875261f, -0.32483634f, -1.85650527f, -0.25627598f, 
    -0.10392524f, 0.24807151f, -0.76568669f, -0.28687611f, -0.36477914f, -0.12786463f, -0.29394665f, 0.12245251f, 
    0.29731500f, 0.12794410f, -0.44527650f, 0.17779224f, -0.03339874f, -0.31213793f, -0.03824631f, -0.28176925f, 
    0.10620083f, 0.09339670f, 0.47236177f, -0.26007661f, 0.15131588f, -0.01838158f, 0.07205251f, -0.20628880f, 
    0.31726065f, -0.00308551f, -0.40490875f, -0.42981169f, 0.11490352f, 0.22189224f, 0.00736141f, -0.52989697f, 
    -0.02249469f, 0.40288976f, 0.26054779f, 0.18923187f, -0.01993416f, -0.13620831f, 0.47347921f, -0.03240767f, 
    -0.04567593f, -0.01058398f, -0.77012700f, 0.15754537f, 0.01903172f, 0.12831259f, -0.24358824f, -0.11027229f, 
    -0.10608825f, 0.52811086f, -0.29187551f, -0.03975473f, -0.51835835f, 0.01266638f, 0.20138694f, -0.44486049f, 
    0.07997650f, 0.03766448f, -0.15704209f, -0.12867452f, 0.21138868f, 0.11175647f, -0.60808480f, 0.24726489f, 
    -0.26460364f, 0.09037334f, 0.27866700f, 0.04352412f, -0.10676880f, -0.45068201f, -0.39646006f, 0.03700030f, 
    -0.02502742f, 0.08107445f, -0.18451653f, -0.30871052f, 0.09352032f, -0.66199386f, 0.00459801f, -0.03815857f, 
    0.06883942f, -0.11743600f, 0.01036055f, 0.11475923f, 0.09086165f, 0.00609457f, 0.06142376f, -0.13877086f, 
    -0.30708659f, 0.07188036f, -0.34708112f, 0.02243630f, 0.11730315f, -0.85846168f, 0.17064434f, 0.12912004f, 
    0.17482486f, -0.13748823f, 0.05963859f, -0.15096374f, 0.01450283f, 0.02904150f, 0.02784508f, -0.09519356f, 
    -0.16241597f, 0.10398101f, 0.22382765f, 0.11731718f, 0.13061084f, 0.06232543f, 0.00917904f, -0.06406987f, 
    0.07727365f, 0.42109409f, -0.16271847f, -0.05434423f, 0.36399838f, 0.06108071f, -0.04392815f, -0.10157610f, 
    -0.18630248f, 0.13559982f, 0.13745905f, 0.04135875f, -0.01649421f, -0.15182558f, 0.19443356f, 0.48664573f, 
    0.15545478f, -0.00172103f, -0.03518529f, 0.18090771f, 0.19382502f, -0.03339507f, -0.16104153f, -0.42934325f, 
    -0.69190639f, 0.05090052f, 0.05338935f, 0.14639443f, 0.07894794f, -0.14509903f, 0.30894452f, 0.11346856f, 
    0.42738307f, 0.11201569f, -0.13177015f, 0.29101837f, -0.03540400f, 0.08566281f, 0.05115199f, -0.02141667f, 
    -0.11801323f, 0.02228105f, -0.03856244f, 0.05432775f, -0.14861299f, -0.42682466f, -0.20986287f, 0.72536361f, 
    -0.22427253f, -0.27023911f, 0.04357446f, 0.20685135f, -0.04685215f, -0.04578129f, -0.03354386f, 0.23424906f, 
    -0.05679176f, -0.11359761f, 0.20002885f, -0.33085534f, 0.13039711f, 0.19194950f, 0.19587699f, 0.09399192f, 
    -0.04781027f, -0.98992801f, 0.07473635f, 0.22260676f, -0.14224035f, -0.10981770f, -0.80886698f, -0.14095981f, 
    0.11436814f, -0.57369828f, -0.04542659f, -0.14875358f, 0.11207002f, 0.17607684f, 0.17729104f, -0.45479146f, 
    0.09863289f, -0.32972714f, 0.30889273f, 0.35770822f, -0.36345187f, -0.01294335f, -0.63409293f, -0.47136188f, 
    -0.34670347f, 0.06150314f, -0.45207861f, -0.95320594f, -0.07984857f, -0.38233230f, 0.11307237f, 0.04955288f, 
    0.17700820f, 0.38418218f, 0.20558944f, 0.08514483f, 0.19314373f, 0.00748372f, 0.01589894f, -0.13940041f, 
    0.29264605f, 0.06580776f, 0.06750041f, 0.02107413f, -0.07754904f, -0.48287490f, -0.15316142f, -0.98519951f, 
    0.14889622f, -0.17442369f, 0.26912686f, 0.34812409f, 0.08734370f, 0.14492451f, -0.40606779f, -0.61508799f, 
    0.07656921f, -0.06176256f, 0.08758999f, 0.30742571f, -0.36365706f, -1.42264891f, 0.29672572f, 0.22932298f, 
    0.05161336f, -0.40878642f, -0.45762259f, -0.02155068f, 0.27621400f, 0.02528317f, -0.83332515f, -0.52195430f, 
    0.12435911f, -1.01558745f, 0.36014509f, -0.08385640f, 0.00746892f, -0.91132158f, -0.27786282f, 0.77236819f, 
    -0.68556887f, 0.29823449f, -0.82989329f, -0.28852066f, -0.41779998f, 0.08305406f, -0.46417466f, 0.36615017f, 
    -0.02176769f, -0.24213783f, 0.49580982f, 0.29546249f, -0.05656706f, -0.00669118f, -0.89006293f, -0.52098089f, 
    -0.66315097f, -0.66184211f, -0.03310901f, -0.36842537f, 0.06309711f, -0.64611435f, 0.01976625f, -0.53786415f, 
    -0.46656352f, -0.06506050f, 0.29039884f, 0.11829846f, -0.20361733f, 0.27184781f, 0.18872015f, 0.42280442f, 
    0.12683578f, 0.16565302f, -0.02299013f, 0.09734926f, -0.06523282f, -0.34925893f, 0.37131912f, -0.18893251f, 
    -0.45333099f, -0.05439303f, -0.18141077f, 0.09514467f, -0.30190384f, 0.32688096f, -0.48243067f, -0.25201631f, 
    0.07680103f, -0.20181690f, -0.06700882f, 0.30029047f, -0.20006120f, 0.00192420f, -0.00287474f, 0.53368455f, 
    -0.95894849f, 0.28064793f, 0.24352209f, -0.09723259f, -0.98343647f, -0.08697752f, -1.16918099f, 0.23730369f, 
    0.42851472f, 0.16939788f, -0.23036499f, -0.23192437f, 0.31764153f, 0.16066881f, 0.39787129f, -0.46485302f, 
    0.61026984f, 0.27458447f, 0.17599930f, -0.48310754f, 0.05965561f, 0.58009028f, 0.05323087f, -0.07549444f, 
    -0.55377632f, -0.46359548f, -0.63726753f, -0.40045378f, -0.70900029f, 0.40459949f, 0.05138484f, 0.28249839f, 
    -0.28008977f, -0.08040251f, 0.15709300f, -0.67457020f, -0.15040565f, -0.47892597f, 0.10654936f, 0.29431030f, 
    -0.15291153f, 0.12207209f, -0.36987272f, 0.12658277f, -0.12724036f, 0.16035466f, -0.16872451f, 0.30604848f, 
    0.26453561f, 0.06306923f, -0.24389049f, -0.74733818f, 0.12248597f, 0.14540347f, -0.55343258f, 0.20565204f, 
    0.01097873f, -0.43081695f, 0.22641964f, -0.57736480f, -0.56516337f, 0.04708448f, -0.41703820f, -0.21830219f, 
    0.02269894f, -0.02171251f, 0.17454340f, 0.00440896f, -0.04785864f, 0.31218526f, 0.75850296f, -0.74736851f, 
    0.04842498f, -0.77349669f, 0.32066762f, 0.21477093f, -0.15870781f, 0.15394863f, 0.10309934f, -0.13109905f, 
    0.03220604f, -0.03892352f, 0.15685855f, -0.53363872f, -0.05207570f, -0.33990893f, -0.00132323f, 0.05019908f, 
    0.39633819f, 0.07472079f, 0.10092757f, 0.24886599f, -0.02242789f, -0.02970170f, -0.00001136f, -0.17452770f, 
    0.10988587f, -0.09788562f, -0.09171499f, -0.32406235f, 0.18601473f, 0.27384061f, -0.04958062f, 0.04843337f, 
    0.02496447f, -0.63192278f, -0.16831081f, -0.16444336f, 0.09281418f, -0.00245690f, 0.11441673f, -0.07377187f, 
    -0.12039477f, -0.04259446f, -0.18972901f, 0.05163160f, -0.33585891f, 0.08730282f, 0.26975453f, -0.08577634f, 
    -0.05152112f, 0.26058796f, -0.04735426f, -0.06755025f, 0.36839223f, 0.09318985f, -0.04283151f, -0.21646167f, 
    0.06515945f, 0.44092536f, -1.34382129f, 0.09591608f, 0.09921976f, -0.46757138f, -1.70859575f, -0.61832380f, 
    0.04980240f, 0.12456205f, -0.49498218f, -0.91214299f, 0.00207354f, -0.09901222f, -0.26689085f, 0.19527389f, 
    0.38925076f, 0.30073833f, -1.00949395f, -0.08310466f, -0.07673836f, -0.22760990f, 0.12989494f, 0.20996466f, 
    -0.36193773f, -0.28635603f, 0.14619653f, -0.01285985f, 0.14992233f, -0.03191737f, 0.03226518f, 0.22734609f, 
    -0.54074520f, 0.06917417f, -0.64007574f, 0.06717330f, 0.22880127f, 0.30105188f, 0.15468352f, -0.57794887f, 
    -0.52366322f, 0.47924849f, 0.26791057f, -0.41258806f, 0.09191716f, 0.15883730f, -1.38357437f, 0.31500775f, 
    0.29258671f, 0.07715444f, 0.15652636f, -0.13705340f, 0.14724672f, -0.10807918f, -0.60476106f, -0.83374673f, 
    -0.05513665f, 0.28822634f, 0.14801939f, -0.27692309f, -0.07535910f, 0.03375484f, -0.29381976f, 0.10543700f, 
    0.13135204f, -0.36130646f, -0.03379058f, 0.12408591f, 0.24019057f, 0.37333590f, -0.55096167f, -0.73157740f, 
    -0.18734436f, -0.71908820f, 0.23400134f, -0.16180064f, 0.16730390f, -0.06212693f, 0.21159332f, -0.00878680f, 
    -0.02662188f, -0.29427943f, 0.13999094f, 0.00528738f, 0.02439214f, 0.09125439f, -0.03696202f, -0.26581156f, 
    -0.17908195f, 0.11812263f, 0.16518277f, -0.61194712f, -0.04249840f, -0.06746903f, -0.05729618f, -0.25927329f, 
    0.37334883f, -0.07402608f, -0.11538404f, 0.07795668f, -0.14662792f, -1.22020972f, -0.26577839f, -0.39736292f, 
    0.30553538f, 0.06961375f, 0.12407509f, -0.09393158f, -0.07268685f, 0.12079409f, -0.66906130f, 0.07661721f, 
    -0.10756075f, 0.07217284f, -0.08604717f, -0.18367793f, 0.42327699f, -0.71356887f, 0.29870343f, 0.37439665f, 
    0.08719690f, 0.10618167f, -0.24283320f, -0.46162796f, 0.25786939f, 0.08726301f, 0.42996368f, -0.37562871f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.10921182f, 0.09929001f, 0.04606361f, -0.27213758f, 0.19036551f, 0.20463265f, -0.19679812f, -0.38153058f, 
    -0.11505946f, -0.03886767f, -0.00788026f, 0.08022763f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
