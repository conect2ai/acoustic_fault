#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.63186502f, -0.61995375f, -0.42800090f, 0.51335585f, 0.66480458f, 0.14071573f, -0.16297291f, -0.04108077f, 
    -0.21017747f, 0.68625784f, 0.73008412f, -0.41651967f, 0.69290912f, -0.10374681f, 0.04913627f, 0.31614697f, 
    0.09361514f, 0.03032992f, -0.33836654f, -0.21107858f, -0.39578855f, 0.54381931f, -0.34447253f, -0.74756384f, 
    -0.03415732f, -0.43501773f, -0.33617648f, 0.65450782f, 0.52847463f, 0.84960878f, -0.01064855f, -0.18061337f, 
    -0.06710750f, 0.33256626f, 0.04038815f, -0.32853428f, -0.82609588f, -0.19117711f, -0.23896079f, 0.32001296f, 
    0.48801145f, -0.39709130f, 0.16803755f, 0.51588750f, -0.13317691f, 0.52788359f, 0.67098588f, -0.24536335f, 
    -0.44269386f, -0.07547069f, -0.71258193f, 0.26111633f, 0.31079599f, 0.22636867f, -0.82711726f, -0.61073959f, 
    -0.54387575f, 0.16094835f, 0.03014713f, 0.81236112f, 0.43434200f, 0.33301145f, 0.34000850f, -0.76781058f, 
    -0.30763233f, -0.64770681f, 0.44087335f, -0.05863213f, 0.45559499f, -0.43901348f, -0.41192007f, -0.01588183f, 
    -0.86664182f, 0.29416269f, 0.22505835f, 0.60121804f, 0.82122993f, 0.09932648f, -0.02163341f, -0.29535389f, 
    -0.12038263f, 0.45985812f, 0.67810571f, 0.73229343f, -0.51661634f, 0.19422992f, -0.56113088f, -0.04539479f, 
    -0.28597307f, 0.08177771f, 0.65280038f, -0.68233240f, -0.49064481f, -0.56377482f, -0.47771153f, -0.10467464f, 
    -0.22654679f, -0.26206651f, 0.43137926f, -0.66360760f, -0.46492720f, 0.75025308f, -0.42154568f, -0.34237787f, 
    -0.02592958f, 0.27452722f, -0.00221117f, 0.55245072f, 0.23077355f, 0.18326163f, -0.58149278f, 0.48527074f, 
    -0.65676826f, -0.21453942f, -0.18500589f, 0.02779715f, 0.52903646f, 0.28772268f, 0.57842922f, 0.33500326f, 
    -0.27760720f, 0.35147417f, 0.69522792f, -0.31938395f, 0.55575788f, 0.49530336f, 0.51811391f, 0.39605576f, 
    0.54557782f, 0.34454024f, 0.12064723f, 0.62778276f, -0.30599928f, -0.47531629f, -0.44076166f, 0.69554627f, 
    0.60527009f, -0.00178943f, 0.22960903f, 0.54620236f, 0.08347028f, 0.13937047f, 0.24699067f, 0.04051024f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06068794f, -0.17062086f, -0.16049805f, 0.09119724f, 0.22113121f, -0.19319797f, 0.09811210f, -0.18196626f, 
    -0.01608011f, -0.09797290f, 0.25696683f, 0.20302145f, -0.11739948f, -0.16048004f, 0.02507091f, 0.35342336f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.36502847f, 0.14202197f, 0.29213652f, 0.03225755f, 0.01843163f, 0.19465145f, -0.08301017f, -0.02309056f, 
    -0.07635419f, 0.25731713f, -0.20787475f, 0.15086235f, 0.08175714f, -0.25561431f, -0.03811444f, -0.03518980f, 
    -0.01515099f, -0.25438365f, 0.01942272f, -0.08993059f, -0.08106769f, 0.11153718f, 0.06343568f, 0.15363011f, 
    -0.20052625f, -0.06628679f, 0.23144981f, 0.06145184f, -0.08133273f, -0.32936084f, 0.10382766f, 0.06973273f, 
    -0.07675144f, 0.13136545f, -0.00092748f, 0.16755445f, 0.12952445f, 0.16869491f, 0.23223396f, 0.05340647f, 
    0.18228942f, 0.11049455f, -0.09803066f, 0.02641964f, 0.04370353f, -0.17028028f, 0.03168920f, -0.01633149f, 
    -0.15342905f, -0.07211979f, -0.34757656f, 0.12211755f, 0.13428782f, -0.11654062f, 0.08701231f, -0.14892951f, 
    0.20381057f, 0.17447068f, 0.19740999f, -0.05752225f, 0.04968611f, -0.13550393f, -0.20358898f, 0.02989528f, 
    -0.35697761f, 0.07099251f, 0.19695705f, 0.05370058f, 0.09060787f, 0.00503302f, -0.03683134f, 0.35473117f, 
    -0.17176335f, -0.15021567f, 0.09697260f, -0.01952324f, 0.06602005f, 0.27527532f, -0.03197061f, 0.04361109f, 
    0.05345819f, 0.29539651f, -0.03699227f, 0.04534359f, 0.02352339f, -0.26789638f, 0.00265512f, 0.09330670f, 
    -0.07991616f, 0.06804764f, 0.13481791f, 0.32653591f, 0.07225616f, -0.27975121f, 0.18717434f, 0.00478473f, 
    0.22237605f, 0.25346148f, -0.06112389f, -0.17764722f, 0.08718568f, -0.26089588f, 0.05578649f, -0.15035550f, 
    -0.11470062f, 0.21078475f, 0.05176790f, -0.09229255f, 0.10759176f, -0.05119972f, -0.01409779f, 0.12163967f, 
    -0.02313655f, 0.12697043f, 0.16552445f, -0.09917113f, -0.00148770f, -0.25946832f, -0.15076186f, -0.07219587f, 
    -0.01332327f, 0.28974062f, -0.08268925f, -0.11771821f, -0.14847286f, -0.50876546f, -0.10240431f, -0.21715897f, 
    -0.11642214f, -0.00802644f, 0.14981148f, 0.17051356f, 0.03325072f, 0.14656638f, -0.40719849f, 0.18836780f, 
    -0.01221131f, -0.07768183f, 0.20685540f, 0.08445387f, 0.09700238f, 0.11574464f, 0.01466256f, -0.25401142f, 
    -0.01221153f, 0.05002660f, 0.04377933f, -0.01183336f, -0.01626222f, -0.07860219f, 0.04413323f, 0.00658680f, 
    -0.03543176f, -0.01498751f, -0.02598742f, -0.01536682f, 0.01702501f, 0.03865795f, 0.05706974f, 0.02466575f, 
    -0.05606189f, -0.02236110f, 0.00670587f, -0.00781055f, -0.06114125f, -0.08066653f, -0.01439857f, 0.02968596f, 
    -0.01933478f, 0.04458351f, -0.03120750f, 0.00060002f, -0.07042938f, -0.08838648f, -0.01941391f, -0.08369236f, 
    0.00443939f, 0.04786100f, 0.02052890f, -0.05269183f, -0.06172065f, -0.05818560f, -0.02938879f, -0.03004419f, 
    -0.05826716f, 0.04392754f, 0.01561279f, -0.05756365f, -0.05206550f, 0.05767474f, 0.01015710f, -0.03438452f, 
    -0.05770395f, -0.00678105f, -0.00350925f, 0.06318838f, 0.06717805f, -0.07223747f, -0.02572700f, 0.02229339f, 
    -0.00595331f, -0.05779611f, -0.04141897f, 0.03079719f, 0.07436415f, 0.06259723f, 0.02967671f, -0.01829465f, 
    -0.04216028f, -0.02050389f, 0.03922753f, -0.01798518f, -0.05656958f, 0.03453514f, -0.06950383f, -0.07511874f, 
    -0.01762368f, 0.04573545f, -0.08928316f, -0.09159613f, -0.04047173f, -0.04305068f, -0.08318726f, -0.05041051f, 
    -0.01644429f, -0.08330756f, -0.05041867f, -0.00313337f, -0.06962192f, 0.05073760f, 0.01574474f, 0.00805045f, 
    0.02157336f, 0.05183513f, -0.04626295f, 0.06184611f, 0.06477231f, 0.06021188f, -0.04609502f, -0.08428906f, 
    -0.05517602f, -0.00520932f, -0.05405044f, 0.01793889f, -0.00560067f, -0.06683209f, -0.00802794f, 0.05147839f, 
    -0.07896187f, 0.02490347f, 0.07120515f, -0.08202574f, -0.08902125f, -0.06952545f, 0.04486437f, -0.07712692f, 
    0.04973181f, -0.08281352f, -0.01160174f, -0.00051245f, 0.05092986f, -0.09090266f, -0.01721717f, -0.04806260f, 
    0.06060734f, 0.04188359f, 0.01644036f, 0.02938312f, -0.09062652f, 0.06656685f, -0.02212105f, -0.00769011f, 
    -0.07509862f, 0.05647118f, -0.03060871f, -0.06111661f, 0.02016332f, -0.05112042f, -0.06301523f, 0.06629808f, 
    0.01038075f, 0.01435720f, -0.06418535f, 0.03540215f, 0.04489092f, 0.00627806f, 0.03345966f, -0.02492204f, 
    -0.10620648f, 0.07041994f, -0.17946343f, 0.02573373f, 0.08259355f, -0.26054165f, 0.02192520f, 0.08204086f, 
    0.11623957f, 0.31503704f, 0.50004685f, 0.20313098f, -0.03811195f, -0.12806830f, -0.09094376f, -0.19097473f, 
    0.04336052f, -0.00293370f, 0.13982189f, 0.30732468f, -0.02801248f, 0.04749796f, 0.04693400f, 0.08348096f, 
    -0.09854104f, -0.04915730f, -0.19845273f, -0.20485905f, -0.22488359f, -0.03031446f, -0.22496496f, -0.00927015f, 
    -0.16676469f, -0.02042294f, -0.04871004f, 0.15882277f, 0.05899056f, 0.17880572f, 0.19586402f, 0.04859325f, 
    0.01059046f, 0.05431725f, 0.01004377f, 0.14846908f, -0.12922721f, -0.06976596f, 0.01320340f, -0.36721256f, 
    -0.13931833f, -0.14432158f, -0.04566374f, -0.18253602f, -0.12784499f, -0.27694228f, -0.01289833f, 0.09355187f, 
    0.14679886f, 0.01044544f, -0.05712904f, 0.10465012f, -0.11356842f, 0.00220981f, -0.04317854f, 0.33018830f, 
    0.16147931f, 0.20748141f, 0.13387810f, 0.24836263f, 0.14188604f, 0.05504856f, 0.19670248f, 0.16493687f, 
    0.05667883f, 0.07933869f, 0.18726720f, 0.05047351f, 0.06500454f, 0.00451853f, 0.06989931f, 0.09241074f, 
    0.18983422f, -0.29492950f, -0.33891258f, -0.02038886f, 0.10170266f, -0.01857586f, 0.17348836f, -0.00302063f, 
    -0.08224512f, 0.02435635f, 0.38915303f, 0.18950786f, -0.16589038f, -0.11024170f, -0.19335966f, -0.11470285f, 
    0.03409653f, 0.00564119f, 0.14882828f, -0.00522655f, -0.40330502f, 0.04050712f, -0.12003741f, -0.16945025f, 
    -0.09382153f, -0.08408342f, -0.08584027f, -0.11171122f, 0.52172035f, 0.07689294f, 0.14955921f, -0.07747944f, 
    -0.22041050f, 0.06567380f, 0.03447370f, -0.15787709f, -0.06589875f, -0.26998228f, 0.15241481f, -0.38322029f, 
    0.13096039f, -0.06261160f, 0.01714794f, 0.06661306f, -0.02944336f, -0.11848116f, 0.12045763f, -0.05049487f, 
    -0.22308977f, -0.02189909f, 0.05740505f, 0.13828301f, 0.22381113f, 0.05496706f, 0.07636091f, 0.15304774f, 
    -0.33418313f, 0.15182391f, -0.03559615f, -0.17848785f, -0.23610054f, -0.00714621f, -0.00255781f, -0.06045398f, 
    0.15871291f, -0.48464853f, -0.17911348f, -0.06645484f, 0.13488536f, -0.14677152f, 0.10911030f, 0.14091758f, 
    -0.17125902f, -0.17062242f, -0.64795327f, 0.16098420f, -0.11279240f, 0.00777115f, 0.11015501f, -0.01764488f, 
    -0.05897353f, -0.03479230f, -0.17098895f, -0.07407133f, -0.34007889f, -0.09487244f, 0.01053380f, -0.07341893f, 
    0.00196781f, 0.16086042f, 0.07906350f, 0.07114883f, 0.00414920f, 0.21228088f, -0.10804708f, -0.15881163f, 
    0.09606385f, -0.05856756f, 0.16370606f, -0.06257119f, 0.20341752f, -0.31057131f, -0.11499269f, -0.13704395f, 
    0.04757678f, 0.05872558f, -0.01366400f, 0.12078649f, -0.06946252f, 0.42878690f, -0.13008735f, -0.18828258f, 
    -0.05207668f, 0.01098066f, 0.09921890f, -0.23138988f, 0.04020213f, 0.06826248f, 0.29400405f, 0.18557967f, 
    -0.10739537f, 0.08763381f, 0.02655763f, 0.16000547f, -0.01717941f, -0.15233679f, -0.00325847f, 0.15138923f, 
    0.43714103f, -0.23467405f, 0.22716278f, -0.22748454f, -0.14806950f, 0.07012238f, 0.08170201f, 0.10897096f, 
    0.07117219f, 0.13863491f, 0.09906572f, 0.05617732f, -0.03595192f, -0.03755561f, -0.06561550f, 0.01306510f, 
    -0.03165482f, 0.25665453f, 0.11552864f, -0.19832832f, -0.15939590f, 0.02766501f, 0.04480380f, 0.02216945f, 
    -0.09235877f, -0.00091574f, -0.05914985f, -0.36842847f, 0.01553944f, 0.09469054f, 0.15318958f, 0.10592261f, 
    -0.05422519f, 0.13015433f, 0.02925462f, -0.28791621f, 0.06081315f, 0.02353024f, 0.13602035f, -0.05675332f, 
    0.13316150f, -0.10778496f, 0.00067980f, 0.03314459f, -0.46018198f, -0.01955089f, -0.19376741f, 0.05870599f, 
    0.11536123f, -0.13145137f, 0.07594055f, 0.03413609f, 0.21744671f, -0.03112864f, 0.37271154f, -0.27111459f, 
    0.00568697f, -0.11990697f, -0.13013613f, 0.02164698f, -0.08084130f, 0.02971968f, -0.11855476f, 0.13211021f, 
    -0.17388085f, -0.01283778f, 0.14088176f, 0.09926461f, 0.05044803f, 0.10201766f, -0.20798874f, 0.38643566f, 
    0.29189488f, 0.16418104f, -0.06815474f, -0.11489192f, 0.00974566f, -0.07972237f, -0.01253602f, 0.11173458f, 
    0.05890685f, -0.10395045f, 0.24896233f, 0.08280058f, 0.10544395f, -0.17051631f, 0.00257995f, 0.06588020f, 
    0.10125054f, 0.10397898f, -0.16807261f, -0.04983433f, -0.01582957f, 0.04551557f, -0.06418055f, -0.06410826f, 
    -0.14328365f, -0.06736162f, -0.07159439f, 0.15222350f, -0.10766928f, 0.03345646f, 0.04298888f, 0.22092448f, 
    0.04219121f, 0.11146950f, -0.10736012f, -0.25279531f, -0.26339343f, 0.22476141f, 0.06136605f, -0.04594572f, 
    -0.06490024f, -0.19945528f, -0.01878291f, 0.06803913f, -0.02928124f, 0.11790738f, -0.00442833f, -0.20966797f, 
    -0.08751337f, 0.02467610f, 0.08186313f, 0.04558890f, 0.00885563f, -0.01665637f, -0.77720720f, -0.06555130f, 
    0.04931068f, 0.08176963f, 0.00061314f, -0.01095844f, -0.05749938f, 0.05530649f, 0.03364543f, 0.54560405f, 
    0.08047047f, 0.07205122f, -0.03657029f, -0.00175391f, 0.01784755f, 0.18428159f, 0.03235499f, -0.04082251f, 
    0.34475404f, -0.11748237f, 0.04034923f, -0.16186996f, 0.02984929f, 0.01574376f, -0.03070059f, -0.12650949f, 
    -0.01901750f, 0.07328601f, 0.02821011f, -0.10985423f, 0.09642795f, 0.06038487f, 0.08814317f, -0.06624125f, 
    -0.02458484f, -0.25718397f, -0.06688236f, 0.14238411f, -0.01150264f, -0.02962744f, 0.07781144f, 0.05712677f, 
    0.08391485f, 0.16315815f, 0.06057482f, -0.32812688f, -0.32664454f, 0.23025560f, 0.14509629f, 0.08637848f, 
    -0.01572497f, -0.12108900f, 0.06728180f, -0.57906806f, 0.18641162f, -0.15088342f, -0.03683432f, -0.16085960f, 
    -0.06827236f, -0.06815881f, 0.01808622f, 0.04315547f, -0.20615000f, -0.35237810f, 0.04997574f, 0.08381808f, 
    -0.01681697f, -0.02400666f, 0.11164238f, -0.02351060f, -0.05774055f, -0.15202349f, 0.23887345f, -0.11046618f, 
    0.08770623f, -0.11044956f, 0.01289789f, 0.17988525f, 0.00956245f, -0.01554254f, 0.26292542f, 0.07564939f, 
    -0.04893297f, 0.03774427f, 0.08047888f, -0.18447194f, 0.03205025f, 0.18179914f, 0.05915182f, 0.00767450f, 
    0.06127976f, 0.14202473f, 0.05893470f, -0.09634206f, -0.06924490f, -0.13302746f, 0.01365376f, -0.09435153f, 
    -0.03560904f, -0.42094040f, -0.17887747f, 0.08595977f, 0.03529226f, 0.01658813f, -0.02636781f, -0.15097600f, 
    0.06522281f, -0.08808390f, -0.00383202f, -0.33259654f, -0.17202905f, 0.05842972f, -0.01312739f, 0.04613509f, 
    -0.06022553f, 0.08410876f, 0.03045975f, 0.01408923f, 0.12926878f, -0.17188138f, 0.03799637f, -0.21443239f, 
    -0.00295460f, 0.03240377f, 0.22089316f, -0.29418004f, 0.16814421f, 0.57060462f, -0.04510816f, -0.05961084f, 
    0.06687275f, 0.06935704f, 0.19020636f, -0.14001617f, 0.24912260f, 0.19211607f, -0.22929694f, -0.08833057f, 
    0.09393373f, 0.03558059f, 0.04619383f, 0.03951529f, -0.07783584f, 0.03315936f, -0.04746945f, -0.06979589f, 
    0.16576962f, 0.04744237f, 0.13133539f, -0.02098770f, 0.00573611f, -0.03649797f, -0.19170271f, -0.27070904f, 
    -0.10282265f, 0.07856065f, 0.07708186f, 0.02034743f, 0.04126535f, -0.01956375f, -0.11026420f, -0.10153928f, 
    -0.08677606f, 0.02475424f, -0.17468175f, -0.15820377f, -0.14189853f, -0.08511227f, 0.09197219f, 0.20199835f, 
    0.33070776f, -0.22582832f, -0.02228717f, 0.01942543f, 0.02608353f, 0.08678547f, -0.03863416f, 0.02171208f, 
    0.09631214f, 0.32730931f, 0.51848549f, 0.45400965f, -0.00736417f, 0.07225201f, 0.03499713f, 0.02074088f, 
    -0.14035612f, -0.07694110f, -0.00317341f, -0.16423944f, -0.10971337f, 0.01526059f, -0.01666930f, 0.03011163f, 
    0.10071976f, 0.02915989f, -0.07721198f, 0.06101049f, -0.29275915f, 0.12937854f, -0.00449679f, -0.10947729f, 
    -0.11265744f, -0.12797372f, -0.04336512f, -0.08096146f, 0.17883860f, -0.24307451f, -0.07464166f, -0.09665825f, 
    -0.01100470f, 0.06242162f, 0.01297537f, -0.01233963f, -0.09538893f, -0.38134781f, 0.12487039f, 0.06992184f, 
    -0.02000658f, 0.01275417f, 0.13955131f, 0.13177711f, -0.18727612f, 0.00868544f, -0.26984179f, 0.18121314f, 
    -0.02556955f, 0.19786797f, -0.01221284f, 0.15340343f, 0.12469027f, -0.15689372f, 0.03302081f, -0.27590504f, 
    0.09758891f, -0.10232275f, -0.09294723f, -0.01720037f, 0.21503438f, -0.06143967f, -0.09595022f, 0.09968117f, 
    0.12526053f, -0.04531036f, -0.25147194f, 0.11555958f, -0.16730589f, 0.05486909f, 0.10458183f, 0.06824677f, 
    0.05697405f, -0.09774833f, 0.14525267f, 0.24109261f, -0.08619177f, -0.07512682f, -0.11579667f, -0.07061876f, 
    -0.08660162f, -0.14585115f, -0.33005959f, 0.19735935f, -0.02405663f, -0.03681311f, -0.00926745f, 0.01218739f, 
    0.29016507f, 0.38601661f, 0.10453357f, -0.02158027f, 0.14205416f, 0.19552152f, 0.06992649f, 0.18615645f, 
    0.19349226f, -0.00058650f, 0.04382383f, 0.18313475f, -0.51409477f, -0.34159195f, -0.20706378f, 0.06794546f, 
    0.12377296f, -0.03250612f, 0.02373582f, -0.12443077f, 0.02448060f, 0.18054502f, -0.17187275f, -0.03068743f, 
    -0.18499884f, -0.16252159f, 0.05866640f, -0.04804564f, 0.02004620f, -0.04703195f, -0.42335662f, -0.21306917f, 
    -0.36680207f, 0.17885379f, 0.22649005f, -0.03676639f, -0.03297902f, 0.03765757f, -0.12781151f, -0.02838673f, 
    -0.02291251f, 0.04538845f, -0.04231900f, 0.04683542f, -0.03866826f, 0.11512199f, -0.12774369f, 0.04708313f, 
    0.19101161f, -0.35778609f, -0.20291604f, 0.02716324f, 0.21360210f, 0.02776113f, -0.00743302f, 0.02682527f, 
    0.00846917f, 0.07771664f, 0.12225946f, 0.20031831f, 0.05232482f, 0.14683887f, 0.06628717f, -0.12077204f, 
    -0.02108550f, 0.08545120f, -0.04786654f, 0.11371349f, -0.17600155f, -0.03814909f, -0.05424417f, 0.05385831f, 
    -0.06766322f, 0.09817114f, 0.06140544f, -0.06097503f, -0.27277073f, -0.24746154f, -0.00729744f, -0.07297450f, 
    0.02860980f, 0.01357768f, 0.13247715f, 0.08483049f, -0.14252415f, -0.21512781f, 0.08480996f, 0.07487408f, 
    -0.16685796f, 0.02750373f, 0.07865728f, -0.16136077f, 0.08316246f, -0.13034604f, -0.09430265f, 0.22864643f, 
    0.02736053f, 0.09767406f, -0.01837807f, -0.01107564f, -0.01229643f, -0.01956759f, 0.22134863f, 0.22793970f, 
    0.02636697f, 0.09757218f, -0.09297574f, 0.12594149f, 0.05552495f, 0.10235056f, 0.06416545f, -0.22267209f, 
    0.26865900f, 0.25930083f, 0.12839194f, 0.01459117f, -0.07752629f, 0.01497195f, 0.06888160f, -0.00932813f, 
    0.00074866f, 0.00125601f, -0.01907046f, -0.05270369f, -0.08108129f, 0.05333871f, 0.06068199f, -0.08800384f, 
    -0.05591660f, 0.00355948f, -0.02357010f, -0.08457289f, 0.02342141f, -0.09456838f, -0.02625473f, -0.01380714f, 
    -0.04821171f, 0.01847641f, 0.04091204f, -0.05500661f, -0.03439639f, 0.03160030f, 0.05393670f, -0.07038270f, 
    -0.05437678f, 0.05161208f, 0.03082757f, 0.02808220f, -0.04618692f, -0.01812998f, 0.02964429f, 0.04914135f, 
    0.02796228f, 0.01438071f, -0.01690003f, -0.04714910f, -0.01392455f, -0.04755779f, 0.00332979f, 0.02466333f, 
    -0.06614008f, 0.04079174f, -0.03784043f, -0.04964818f, -0.00288791f, 0.02738569f, -0.07603654f, 0.03857362f, 
    -0.05347913f, -0.04154844f, 0.06264144f, 0.01654125f, 0.07345451f, 0.06423698f, -0.07122858f, -0.06743976f, 
    0.01740890f, -0.08397592f, 0.02996830f, 0.03152523f, 0.03162485f, 0.04023685f, 0.04042014f, -0.00214389f, 
    -0.02414967f, 0.03481187f, 0.03534615f, -0.09280577f, 0.05341793f, -0.00224039f, 0.03122831f, 0.04778982f, 
    -0.08554517f, 0.04343074f, -0.04770339f, -0.08056107f, 0.05761266f, -0.05811081f, 0.05824476f, 0.05731926f, 
    -0.03038460f, 0.05853150f, 0.00953355f, -0.02709867f, 0.07247644f, -0.04408474f, -0.03933251f, -0.04251042f, 
    0.01243781f, 0.03546653f, 0.05600968f, -0.04025741f, -0.01721596f, -0.04702542f, -0.09231915f, -0.03132465f, 
    0.02741966f, 0.05441299f, -0.02704239f, 0.06157278f, -0.06124638f, -0.09635299f, -0.03539796f, -0.01939566f, 
    -0.01626365f, -0.06234665f, 0.00030836f, -0.05677453f, -0.06204208f, 0.00194772f, -0.00460277f, 0.01185482f, 
    -0.09030680f, -0.02904240f, 0.04808275f, -0.04058624f, -0.07135519f, -0.08326340f, 0.00867817f, -0.01968970f, 
    0.02032443f, -0.00734646f, -0.02356189f, -0.06671920f, -0.07950193f, -0.02230160f, -0.07432430f, -0.07604345f, 
    -0.06896596f, 0.04757932f, -0.03866250f, 0.04759413f, 0.00238306f, -0.02190729f, 0.02059788f, 0.01470617f, 
    -0.07877976f, 0.01663435f, -0.01845418f, 0.02061206f, -0.00661694f, 0.05880657f, -0.05230285f, -0.03652013f, 
    0.04587536f, 0.08608872f, 0.15390359f, -0.10436858f, -0.06246217f, -0.00263509f, 0.10894475f, -0.13467620f, 
    -0.01214863f, 0.27289569f, -0.28547564f, -0.05688278f, -0.12827371f, 0.11746959f, 0.06248600f, 0.00693850f, 
    -0.18983644f, -0.02961722f, -0.21773937f, -0.48410985f, 0.00113312f, -0.01682579f, 0.06919448f, -0.13369067f, 
    0.02479557f, -0.00775653f, 0.18108429f, 0.14751774f, 0.07882223f, -0.03539432f, 0.12663761f, 0.06761838f, 
    0.04706763f, -0.06321897f, 0.00060912f, 0.03413290f, 0.33241770f, -0.22798249f, -0.02450940f, -0.26538244f, 
    -0.08658830f, -0.06952404f, -0.20493290f, 0.16313863f, 0.02860385f, 0.17419384f, 0.18716186f, -0.21665144f, 
    0.12888177f, 0.02195737f, -0.01466616f, 0.07500985f, -0.03117095f, -0.15832527f, 0.13290647f, 0.08484247f, 
    0.26837549f, -0.09269224f, 0.00529195f, 0.00199069f, -0.07308983f, -0.01441242f, 0.05308533f, -0.12629050f, 
    -0.04630240f, 0.14404392f, 0.01972038f, -0.12710887f, 0.16414139f, 0.02331065f, -0.02456166f, 0.03651938f, 
    0.58968514f, 0.02314818f, -0.19259089f, -0.11643993f, -0.07778743f, -0.00780204f, -0.02404171f, -0.00413685f, 
    0.13339013f, -0.23176537f, 0.35385025f, -0.12899107f, -0.00336206f, 0.09624181f, 0.09765693f, 0.03868863f, 
    0.01171008f, 0.17712463f, 0.18043548f, 0.01758861f, -0.20694508f, 0.08542789f, 0.05462509f, 0.07546098f, 
    0.08129895f, -0.08652657f, 0.12733079f, 0.14610592f, -0.04638214f, -0.24839485f, 0.04687048f, -0.08000545f, 
    0.00900267f, -0.20939378f, -0.06032859f, -0.11281025f, -0.41095990f, 0.20350607f, 0.02248351f, 0.13349839f, 
    -0.14877738f, -0.20761235f, -0.19747356f, 0.22595559f, -0.10022978f, -0.19155893f, 0.11560987f, 0.19451101f, 
    0.00680860f, 0.11743934f, 0.13313791f, -0.14189973f, 0.09018595f, 0.10426639f, -0.41333443f, -0.05662481f, 
    -0.08544917f, -0.00354698f, 0.09036355f, 0.18317370f, 0.08477703f, 0.06750050f, 0.02022155f, 0.08800796f, 
    -0.02160216f, 0.07086747f, -0.19738476f, -0.06428552f, 0.09777434f, 0.09317277f, -0.04526568f, -0.02510180f, 
    0.00387420f, -0.00404307f, -0.05744958f, 0.04131581f, 0.03670375f, -0.01546826f, -0.11104231f, 0.18416530f, 
    -0.07770374f, 0.34480050f, -0.09739866f, 0.13424602f, 0.18559946f, 0.04405875f, -0.11513940f, 0.15896493f, 
    0.07307003f, 0.14252087f, -0.40989834f, -0.09176157f, -0.46750537f, -0.04194278f, -0.04933146f, 0.03866461f, 
    0.03961364f, -0.05502453f, -0.07556421f, 0.41423878f, -0.16724829f, 0.12759095f, 0.25236592f, 0.07280608f, 
    0.01387823f, -0.11222679f, 0.06828673f, -0.01414478f, -0.40715709f, -0.02275831f, -0.10926661f, -0.09425078f, 
    0.01402067f, 0.05205368f, -0.04479627f, -0.12461881f, 0.09353451f, 0.47886485f, -0.06389731f, -0.14842325f, 
    0.10496233f, -0.12995754f, -0.16068986f, -0.00229491f, 0.12974505f, -0.02357946f, -0.06798593f, 0.20852037f, 
    -0.05399425f, 0.05855099f, -0.12412528f, 0.20051463f, 0.11923939f, 0.03954212f, 0.00974514f, -0.04839106f, 
    0.19877923f, 0.19543362f, -0.20308928f, 0.17156926f, 0.00182534f, -0.13159709f, -0.00023910f, -0.24701880f, 
    -0.30435595f, 0.00335118f, 0.08434512f, -0.19663623f, -0.01272298f, -0.13971077f, -0.21111448f, 0.18388963f, 
    -0.07763899f, 0.10219358f, -0.17676505f, -0.11454124f, 0.29116663f, -0.01291110f, 0.17959371f, 0.09091729f, 
    0.03377364f, 0.05606990f, 0.14009275f, 0.06183169f, -0.29031056f, 0.14599447f, -0.11454944f, -0.00832042f, 
    0.04102983f, -0.01131000f, 0.09955551f, -0.23482609f, 0.31045172f, -0.24470802f, 0.15609102f, -0.11695628f, 
    0.09859461f, -0.12564383f, 0.06757381f, -0.04222092f, 0.18445118f, 0.08237121f, -0.03718114f, 0.36303496f, 
    0.00280169f, -0.05973870f, 0.02774445f, 0.02008068f, 0.02015415f, -0.02013231f, -0.05297114f, 0.18201342f, 
    -0.01066747f, -0.15576066f, -0.04627179f, -0.01988823f, 0.06713852f, -0.00870120f, 0.10178167f, 0.03478433f, 
    -0.01752787f, -0.02701834f, 0.18177235f, -0.06440923f, -0.11621002f, -0.00946061f, 0.01044557f, -0.14367242f, 
    -0.19688167f, 0.08417927f, 0.01870739f, 0.06774378f, -0.11558755f, 0.17107300f, 0.13231675f, 0.13520052f, 
    -0.23895350f, -0.11728917f, 0.19559930f, -0.03295106f, -0.03537682f, -0.06620830f, 0.08493756f, 0.12384634f, 
    0.00120161f, -0.42398140f, 0.05184718f, -0.04640980f, 0.04932935f, -0.04007598f, 0.05708392f, 0.18947117f, 
    0.14154206f, 0.04080225f, -0.04727696f, 0.13378038f, 0.14198229f, 0.06485359f, -0.15669426f, 0.43365985f, 
    -0.17152771f, -0.07023048f, -0.00248911f, 0.01446470f, 0.20155050f, -0.14724460f, -0.07808751f, 0.10567042f, 
    0.00333265f, 0.03494542f, 0.08885312f, 0.07064918f, -0.01302727f, 0.10740288f, -0.01760737f, -0.01919456f, 
    -0.01963262f, 0.14729002f, 0.09710995f, 0.19791834f, 0.16940430f, -0.77552140f, 0.11897277f, 0.09535278f, 
    -0.16480477f, -0.14517622f, -0.21818589f, 0.00631998f, 0.16411588f, 0.04658211f, 0.06695871f, 0.13995717f, 
    0.04740853f, 0.13666357f, 0.16092187f, 0.18371207f, 0.29077870f, -0.02358821f, -0.05546835f, 0.30949926f, 
    0.26438329f, 0.25416338f, 0.05750923f, -0.11301538f, 0.04100310f, -0.04168303f, -0.04965666f, 0.05160986f, 
    0.27199244f, 0.34149948f, -0.00588160f, 0.04060690f, 0.07767802f, 0.07318983f, -0.05444406f, -0.05247175f, 
    0.04899859f, -0.18206172f, -0.03249682f, 0.13662998f, -0.03629877f, 0.03655447f, -0.10345928f, 0.04285457f, 
    0.01423759f, -0.10544366f, 0.26873529f, 0.18377198f, -0.33420748f, -0.10592130f, 0.12811311f, -0.08042503f, 
    -0.10493690f, 0.23087758f, -0.09843337f, 0.21637200f, -0.22155946f, -0.18042369f, -0.13370593f, -0.08482583f, 
    -0.10146893f, -0.06777984f, 0.18605135f, -0.00912496f, 0.13015272f, 0.20491034f, -0.19674782f, -0.11689197f, 
    0.18699156f, -0.15431494f, -0.13190685f, 0.09415671f, -0.14370714f, -0.09894278f, -0.00810356f, -0.35915980f, 
    0.07986080f, -0.15953970f, -0.07876212f, -0.07700707f, 0.08426040f, -0.00162982f, 0.36546353f, -0.18423748f, 
    -0.30311128f, -0.08347882f, -0.07288390f, 0.10332685f, 0.00893910f, -0.12687568f, -0.13160399f, -0.17082199f, 
    0.14463477f, -0.01240054f, 0.11874982f, -0.16375832f, 0.07569053f, 0.12121660f, 0.10180404f, 0.02845273f, 
    -0.05632485f, -0.04117883f, -0.06299131f, -0.00036570f, -0.05832038f, -0.05217436f, -0.02725571f, -0.03037616f, 
    0.00614260f, 0.02787231f, 0.07609101f, -0.05163232f, 0.01259909f, -0.04189277f, -0.05907106f, -0.00207703f, 
    -0.00716984f, 0.01672039f, 0.05166693f, -0.01712239f, 0.05146069f, 0.04903911f, -0.07396503f, -0.00085262f, 
    -0.05074480f, -0.07513972f, 0.05728533f, 0.02814214f, 0.00954286f, -0.04284263f, 0.01725077f, 0.07250468f, 
    -0.05112242f, -0.06318462f, -0.02433250f, -0.01263407f, 0.03605543f, 0.03817300f, -0.08348109f, -0.04162654f, 
    -0.02201759f, 0.02898543f, -0.07084119f, 0.03825654f, -0.04079342f, -0.06007659f, 0.05861374f, 0.02826132f, 
    -0.00705029f, -0.06133806f, 0.05305725f, -0.02287977f, 0.05432962f, 0.07554378f, 0.00239167f, -0.06256907f, 
    0.01335021f, -0.01563923f, -0.00601721f, 0.05963232f, 0.04032739f, -0.06254493f, -0.04944098f, -0.02747799f, 
    -0.07104356f, -0.06379356f, -0.01131758f, -0.07862303f, -0.04532557f, 0.07512829f, -0.01999984f, -0.05963053f, 
    -0.08941416f, 0.00303759f, 0.03935437f, -0.03467913f, -0.03457769f, 0.06744967f, 0.04391300f, 0.01534876f, 
    -0.02843112f, 0.02994556f, 0.01249097f, -0.06876722f, 0.07163786f, -0.00064123f, 0.03439967f, -0.05629306f, 
    -0.08239778f, 0.07148657f, 0.05986323f, -0.06958206f, -0.01285809f, -0.08999014f, 0.01470144f, 0.05611448f, 
    -0.05729831f, 0.03259497f, 0.06197760f, 0.04780817f, -0.00249872f, 0.05571187f, -0.03552375f, 0.02234717f, 
    0.07048985f, -0.05308713f, 0.01040359f, -0.08379699f, 0.02195099f, 0.01992880f, -0.04522938f, 0.05062945f, 
    0.00981183f, -0.03958211f, -0.06656250f, 0.04323748f, -0.01773213f, 0.03652032f, 0.02040314f, 0.02632636f, 
    0.06980097f, -0.00513607f, -0.00712547f, 0.06865115f, -0.08152620f, -0.01100659f, 0.05886583f, -0.06910634f, 
    0.03413671f, -0.08111659f, 0.01921011f, -0.00335598f, -0.08611348f, -0.04718715f, -0.01856322f, -0.08361929f, 
    -0.05583277f, -0.04784090f, -0.02707211f, -0.08364063f, -0.01051764f, -0.02174324f, -0.02500037f, -0.00892140f, 
    0.27580988f, -0.35571262f, -0.29633176f, 0.03203895f, 0.03685826f, -0.10784485f, 0.14216714f, 0.01036680f, 
    0.07939643f, -0.10915951f, -0.04311273f, -0.05284100f, 0.00275742f, -0.06630498f, 0.14824395f, -0.03991243f, 
    -0.16435702f, -0.14715195f, -0.06815675f, -0.12290058f, 0.04608846f, 0.06951911f, 0.04470832f, 0.03252922f, 
    0.11642028f, -0.06920914f, -0.31357074f, 0.01848162f, -0.04230963f, 0.32476950f, -0.27097398f, -0.04957840f, 
    0.07462130f, -0.00699405f, 0.18340337f, 0.08145077f, -0.21118400f, 0.12058271f, -0.14693804f, 0.11641664f, 
    0.08180276f, -0.08891404f, -0.10437639f, -0.04217492f, 0.03906172f, -0.09849136f, -0.10785946f, 0.08226421f, 
    0.00786955f, -0.03608809f, 0.10434424f, -0.06736385f, 0.00508793f, 0.02058829f, 0.00455877f, -0.04214391f, 
    -0.11876262f, -0.09677684f, 0.03753000f, 0.18220204f, 0.18588704f, 0.12065872f, 0.05799622f, -0.12155208f, 
    0.06396128f, -0.19207889f, 0.08650725f, 0.02179738f, -0.11886582f, 0.04290637f, -0.13850361f, -0.05361961f, 
    0.02755472f, 0.28957295f, 0.03430540f, 0.18232176f, -0.05040473f, -0.17055123f, 0.00715173f, 0.11328015f, 
    0.09605058f, 0.08184315f, 0.05624207f, 0.01056129f, -0.14846146f, 0.01260799f, 0.03146434f, -0.07848831f, 
    0.03653470f, 0.23664139f, -0.61281180f, -0.03359671f, 0.18730444f, -0.05687549f, 0.14031765f, -0.06384717f, 
    0.10660735f, -0.03162802f, 0.08772884f, -0.24472441f, -0.23773403f, 0.22639582f, 0.12711403f, -0.01121155f, 
    -0.16645333f, -0.09593363f, -0.00677217f, 0.19758207f, -0.38944921f, -0.08742998f, 0.12754267f, -0.13658257f, 
    0.16072500f, -0.18053211f, -0.07436950f, -0.00199535f, 0.00280066f, 0.23682263f, 0.05547001f, -0.23000962f, 
    0.06692763f, -0.02798680f, -0.29590499f, -0.01048630f, 0.12421660f, 0.07644279f, 0.06386192f, 0.16616288f, 
    0.30313542f, 0.03301667f, -0.22718821f, -0.29691038f, 0.22406955f, 0.14084260f, 0.04314985f, 0.14982873f, 
    0.21526456f, -0.07646465f, -0.03829516f, 0.01696295f, -0.04459891f, 0.01761186f, -0.02010429f, 0.12657212f, 
    -0.11113328f, -0.21247791f, -0.02954377f, 0.05178971f, -0.12991701f, -0.02002349f, -0.09759296f, -0.02125095f, 
    0.14204583f, 0.37167099f, 0.10267889f, 0.19586845f, -0.13556708f, -0.01457857f, -0.18902075f, 0.11954083f, 
    -0.05701805f, 0.15770487f, 0.10999075f, 0.00751457f, -0.13180947f, 0.01536372f, -0.04399657f, -0.06370982f, 
    -0.13355257f, -0.06897470f, -0.15939309f, 0.44814876f, 0.16656607f, -0.01042489f, 0.03510283f, -0.01547834f, 
    -0.02426018f, 0.15278502f, -0.04657421f, -0.05476984f, -0.23453750f, -0.19644557f, 0.16629493f, 0.06085816f, 
    -0.05060269f, 0.10092579f, -0.02785404f, -0.06613432f, -0.16730738f, 0.19421563f, 0.07964111f, -0.23489821f, 
    0.13263060f, 0.11434452f, 0.15471341f, 0.07174487f, 0.09253373f, -0.05856424f, -0.10327779f, -0.01943910f, 
    0.12360088f, -0.02089249f, 0.13395010f, 0.04066852f, 0.07601242f, -0.03250804f, -0.05005476f, -0.28472307f, 
    -0.08914142f, 0.10898009f, -0.04292994f, 0.12276642f, -0.10799336f, -0.04749478f, -0.10567745f, 0.10512260f, 
    -0.80271232f, -0.34598526f, -0.11295053f, 0.14586341f, -0.02379358f, -0.06221998f, -0.00587517f, 0.06083704f, 
    0.09190322f, 0.22645636f, 0.31452626f, -0.25062612f, -0.05411534f, 0.02855905f, 0.05300822f, 0.00776646f, 
    -0.02796029f, -0.08625831f, 0.19919594f, -0.02145510f, -0.03749058f, 0.02092786f, -0.02358527f, 0.03547959f, 
    0.11537804f, -0.05157891f, -0.04985893f, -0.12514688f, 0.06119615f, -0.09672035f, 0.08017109f, -0.04325576f, 
    -0.00336280f, -0.01690343f, -0.09769562f, -0.03087326f, 0.05642474f, 0.04099276f, -0.13495839f, 0.06621429f, 
    -0.02965214f, 0.04175631f, -0.12551731f, 0.00889512f, 0.10859714f, 0.16800536f, 0.15326884f, 0.19062540f, 
    0.07690621f, -0.22992207f, -0.08490092f, 0.00925926f, -0.09601043f, 0.04775734f, 0.16291036f, -0.09022170f, 
    0.13674316f, 0.04885302f, 0.03564458f, -0.00107582f, 0.00208105f, -0.13578184f, 0.10602803f, 0.47115752f, 
    0.19286169f, 0.09935621f, -0.21921872f, -0.11837444f, -0.10727209f, -0.05561434f, -0.01416571f, -0.05042220f, 
    0.01169314f, 0.05720882f, -0.08166949f, 0.06896009f, -0.06297979f, 0.06145990f, -0.02216704f, 0.04118593f, 
    -0.07583521f, 0.03870187f, 0.04998468f, -0.01357311f, -0.00685400f, -0.04531298f, -0.02050212f, -0.04089733f, 
    -0.00681629f, 0.00231100f, 0.01813044f, -0.01842198f, 0.04358542f, 0.02591260f, -0.00246303f, -0.03649077f, 
    0.02376795f, -0.07252935f, -0.03427379f, 0.03334826f, -0.01237121f, -0.02549240f, -0.08710454f, 0.05304335f, 
    0.01407816f, 0.01418103f, -0.05673037f, -0.02659721f, -0.09411595f, -0.02159187f, 0.03437660f, -0.03735290f, 
    0.01064106f, -0.05849292f, -0.02430802f, -0.04146991f, -0.05493791f, -0.01605369f, 0.06210956f, -0.00339877f, 
    -0.05426262f, 0.06862054f, -0.05078479f, 0.05448149f, 0.04377938f, 0.05704317f, 0.02696277f, 0.04329504f, 
    -0.00276433f, 0.04963460f, -0.06891479f, -0.07676242f, -0.03788505f, -0.06212897f, -0.04225557f, 0.03085483f, 
    0.02703656f, 0.06224014f, 0.03445367f, 0.00779252f, 0.00651328f, 0.02395090f, -0.06458774f, 0.05664321f, 
    -0.02426349f, -0.05922782f, -0.03035762f, 0.00795121f, 0.03023508f, -0.00280186f, 0.01204604f, -0.06912614f, 
    -0.00172702f, 0.02209846f, -0.08168361f, -0.06975424f, -0.03844596f, -0.04354621f, -0.02443299f, -0.03400239f, 
    -0.08813996f, -0.06397682f, -0.01397267f, 0.00729668f, -0.04827787f, 0.03157905f, -0.05163785f, 0.00084991f, 
    -0.04934534f, -0.05948365f, -0.07960954f, 0.06331034f, -0.03525409f, 0.03290253f, -0.07935213f, 0.05690285f, 
    -0.07200655f, -0.07910319f, -0.02989396f, -0.02728462f, -0.02625159f, 0.05667894f, -0.08828527f, -0.08320367f, 
    0.04290983f, -0.04556382f, 0.01374335f, -0.00151501f, -0.09167755f, -0.04038594f, -0.03752953f, -0.08808057f, 
    -0.04440688f, 0.00669351f, -0.05736753f, -0.03059036f, 0.00828773f, 0.00121029f, -0.06423196f, -0.01934570f, 
    0.00285311f, -0.00429493f, 0.01756627f, -0.03911580f, -0.05507455f, 0.01652037f, -0.02459157f, -0.00206501f, 
    -0.06692407f, 0.03466611f, 0.01721924f, -0.00387624f, 0.01029337f, 0.03940519f, -0.09421846f, -0.03616417f, 
    0.21409576f, 0.02151956f, -0.21998551f, -0.02631146f, 0.11357167f, -0.12269084f, -0.00575094f, 0.09826171f, 
    0.09533928f, -0.41318342f, -0.23569199f, -0.26939440f, 0.01546289f, 0.00301085f, -0.06151946f, -0.11667801f, 
    -0.07403699f, -0.14321823f, 0.21191952f, -0.03718736f, 0.02924341f, -0.16571909f, 0.20407586f, 0.02959386f, 
    -0.02869597f, -0.11688242f, 0.04468640f, -0.29348376f, -0.41918299f, -0.03412716f, -0.06017146f, 0.06116835f, 
    0.13101341f, 0.19654040f, 0.11985614f, 0.00738105f, 0.09427869f, 0.08783123f, -0.15222836f, -0.04922340f, 
    0.01078259f, 0.08995185f, 0.14199574f, 0.04867991f, 0.01606453f, -0.04493446f, -0.18850119f, 0.09234101f, 
    0.15247439f, -0.09870767f, -0.01122082f, -0.17396413f, -0.08153819f, 0.17178640f, 0.25033048f, 0.06838349f, 
    0.14213461f, -0.07654184f, 0.09147453f, -0.15535189f, 0.03513095f, 0.27197057f, -0.13222459f, 0.15606676f, 
    0.13466679f, -0.15302362f, -0.05994896f, -0.05358770f, 0.17851259f, -0.00057623f, 0.14425501f, -0.14502415f, 
    0.27780333f, 0.05971162f, -0.14479357f, 0.05264735f, -0.19071700f, -0.15197006f, 0.05292946f, 0.17142048f, 
    -0.05625304f, 0.07081893f, -0.25919452f, 0.33940709f, 0.13470703f, 0.06755219f, 0.17082025f, -0.22001676f, 
    -0.08994213f, 0.05463041f, -0.05667790f, 0.09506647f, 0.06447623f, 0.05745261f, 0.06817376f, 0.27795041f, 
    0.13326772f, -0.02424458f, 0.07302839f, 0.23304768f, 0.21771641f, 0.11715263f, -0.13803232f, -0.13102883f, 
    -0.13315906f, -0.05733868f, 0.06326738f, -0.03601470f, 0.31815389f, -0.22799993f, 0.17434545f, -0.01406054f, 
    -0.10342383f, 0.02525745f, 0.07732718f, 0.09371014f, 0.23833109f, -0.37282610f, -0.29235721f, -0.10473280f, 
    0.12874439f, 0.04655625f, 0.04879855f, 0.06112976f, 0.11712737f, 0.01442703f, -0.42827153f, -0.30510464f, 
    -0.09431665f, 0.05387529f, 0.24149297f, 0.05811889f, -0.02531218f, -0.07012226f, -0.02620880f, -0.41517392f, 
    -0.20012370f, -0.30683821f, -0.10146946f, 0.10596100f, -0.11794672f, 0.10224366f, 0.05237907f, 0.09871192f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.25284344f, 0.02996511f, -0.34631222f, 0.06385740f, 0.20325655f, 0.09735709f, 0.18393096f, 0.05869952f, 
    -0.25002906f, 0.18083861f, -0.12464719f, -0.05366357f, 0.12649995f, 0.21393611f, 0.02021082f, 0.17562720f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.18928050f, -0.10148077f, -0.09787305f, -0.09773660f, -0.12364632f, -0.02970915f, 0.10840912f, -0.04481477f, 
    0.42317960f, 0.43590975f, 0.00164760f, 0.13812153f, -0.41505519f, 0.06555779f, 0.16032369f, 0.20692533f, 
    0.19146539f, -0.11868857f, 0.05766544f, -0.49950686f, -0.53135270f, -0.17115335f, 0.37267330f, 0.03022474f, 
    -0.03269061f, 0.33878186f, -0.32935312f, -0.12382703f, 0.26392293f, 0.16574781f, -0.13012654f, 0.01361980f, 
    0.03907097f, -0.22233480f, 0.20501153f, 0.22176506f, -0.80693585f, 0.06229328f, 0.25645530f, 0.18171503f, 
    0.38238528f, -0.01956530f, -0.20925556f, -0.06544400f, -0.23024075f, 0.42873359f, -0.20544177f, -0.00917064f, 
    -0.29281348f, 0.03681463f, 0.83156627f, 0.25525895f, 0.18564917f, 0.01477402f, -0.34922889f, 0.01546478f, 
    -0.13791661f, 0.60115588f, -0.05359331f, -0.20843057f, -0.18416795f, -0.30975014f, 0.10631084f, 0.24959236f, 
    0.34055772f, 0.24059471f, 0.50582582f, -0.55615246f, 0.38941133f, 0.41651642f, -0.51539266f, -0.11491491f, 
    -0.14345858f, -0.03868849f, 0.09915636f, 0.18331987f, -0.51049566f, -0.41337115f, 0.05478007f, 0.11629053f, 
    0.00224967f, 0.17075554f, -0.27549219f, -0.15316431f, -0.46997446f, 0.36495963f, 0.18718244f, 0.22026972f, 
    0.12494692f, 0.28039750f, 0.00910717f, -0.23729947f, -0.24138741f, 0.03565939f, 0.09685577f, 0.29771328f, 
    0.14463213f, -0.17668399f, -0.14070302f, -0.36944130f, 0.19741961f, -0.35533604f, 0.37870640f, -0.20672674f, 
    -0.37598866f, -0.42136818f, -0.00782192f, 0.20225421f, 0.01724408f, 0.05206174f, 0.07664369f, 0.42330372f, 
    -0.25307468f, -0.15505271f, 0.17028728f, -0.04904102f, 0.53008240f, -0.01947225f, 0.18171960f, -0.07533939f, 
    -0.10088129f, 0.31087828f, -0.08512764f, 0.02001936f, -0.03576190f, 0.23054959f, 0.21075137f, -0.08620397f, 
    0.41203427f, -0.17423607f, -0.02658897f, -0.32258207f, -0.07787436f, -0.32764515f, -0.11019675f, -0.23543774f, 
    0.41744247f, 0.35819018f, -0.22362077f, -0.16884482f, -0.22075005f, 0.32268676f, 0.17437412f, 0.20458148f, 
    -0.07964650f, 0.10439495f, 0.31772500f, -0.07871506f, -0.03652042f, 0.33026406f, -1.01499271f, -0.16338845f, 
    -0.16590013f, 0.34683833f, 0.30255026f, 0.05210943f, -0.65113890f, 0.16565834f, -0.11582562f, 0.32133374f, 
    0.16968480f, -0.19237508f, 0.25830668f, -0.06224553f, -0.21541585f, 0.09800654f, -0.12464403f, 0.10882913f, 
    0.36242622f, -0.29062933f, 0.11117642f, -0.21692677f, -0.00159323f, 0.23516153f, -0.05748625f, 0.08928435f, 
    0.20372848f, 0.06848899f, -0.19664735f, 0.30713046f, 0.11274602f, -0.35706183f, 0.37556696f, -0.19826105f, 
    0.21502028f, 0.21171387f, -0.04571563f, 0.02509412f, -0.09957311f, 0.17093442f, -0.06716342f, -0.16193582f, 
    0.13531761f, -0.24009410f, 0.46429995f, -0.04398566f, 0.17746577f, -0.09875751f, -0.82495761f, 0.03842163f, 
    -0.03356024f, 0.12373101f, 0.41642427f, -0.01744649f, -0.45227319f, -0.54792976f, 0.21151567f, 0.05487397f, 
    0.08750977f, -0.04572782f, -0.43145043f, -0.25352341f, -0.12130450f, -0.12073839f, -0.15343353f, 0.23550232f, 
    0.28208414f, 0.24337180f, 0.10002941f, -0.00781693f, -0.26525712f, 0.34420973f, -0.24568677f, 0.30452311f, 
    -0.12248722f, -0.04669243f, 0.14131755f, -0.21223441f, -0.18070564f, -0.24284333f, 0.03403214f, 0.20852140f, 
    -0.14547852f, -0.16267166f, -0.24280533f, 0.03150719f, 0.10619360f, -0.19621673f, 0.22360229f, 0.07154906f, 
    -0.05186180f, -0.04531795f, 0.30456057f, 0.29019517f, -0.26598880f, -0.09947493f, 0.56382322f, -0.20149112f, 
    0.03178315f, -0.10703745f, 0.36508033f, -0.04893073f, -0.20196614f, 0.25773662f, -0.00374645f, -0.38171124f, 
    0.18611427f, -0.21064141f, 0.09127738f, 0.25928444f, 0.26794577f, 0.41148043f, -0.09918843f, 0.17959933f, 
    -0.41776520f, -0.00694968f, 0.04899377f, -0.18025777f, 0.37877607f, -0.23246825f, 0.17753369f, 0.14278777f, 
    -0.27088597f, 0.00418160f, -0.11865402f, -0.02784188f, 0.39696038f, -0.45280167f, -0.07588914f, 0.09257638f, 
    -0.00947808f, 0.29228303f, 0.01447231f, -0.08786111f, 0.43728009f, 0.06761892f, 0.06591547f, -0.03316199f, 
    -0.05754789f, 0.01266164f, 0.51473516f, -0.42527574f, -0.14520735f, 0.39553753f, -0.09702767f, 0.05463666f, 
    0.50468653f, -0.17767729f, -0.12582621f, -0.09734201f, -0.06841674f, -0.17079492f, 0.08521867f, 0.35551724f, 
    -0.15507951f, 0.05888883f, 0.24140789f, -0.08797229f, 0.32609254f, -0.25446403f, -0.13441773f, 0.10494391f, 
    0.08044523f, -0.24154067f, 0.28249729f, -0.16382317f, -0.02316585f, -0.27124697f, -0.09178036f, 0.60461950f, 
    -0.12498002f, 0.18765326f, 0.33068034f, -0.07859798f, 0.04904212f, 0.03520008f, 0.13545108f, 0.02008784f, 
    -0.16480246f, -0.20254622f, 0.37808073f, -0.12809606f, -0.34566632f, -0.07589962f, 0.14221220f, 0.39434519f, 
    0.25757939f, -0.16449058f, -0.38753080f, 0.09155484f, -0.40726730f, -0.62281299f, 0.41398451f, 0.13391459f, 
    0.45248321f, 0.06901390f, -0.11710551f, -0.00118615f, -0.39278850f, 0.36731377f, -0.06271870f, 0.23871568f, 
    -0.14254373f, -0.10778155f, -0.15305938f, 0.31554776f, -0.06576033f, -0.18616368f, 0.09629068f, -0.20917308f, 
    0.05026095f, 0.18111244f, 0.13391428f, 0.12431116f, 0.11129656f, 0.35615575f, 0.19777180f, -0.04643194f, 
    0.44079959f, 0.14395037f, -0.10037175f, 0.00067360f, 0.11215550f, -0.10781796f, -0.27900010f, 0.16291323f, 
    0.27018330f, 0.19141376f, -0.08064421f, -0.09754281f, -0.19089757f, -0.12364241f, 0.18585210f, 0.18497258f, 
    0.39512640f, 0.12454267f, -0.12819311f, -0.29091501f, -0.32632953f, 0.43424705f, -0.11873157f, -0.11688623f, 
    0.43222207f, 0.03806269f, 0.03094079f, -0.22114706f, -0.18904710f, 0.14230910f, -0.11976083f, 0.14679538f, 
    0.15976478f, -0.17391358f, 0.17279765f, -0.08776215f, -0.41590753f, -0.20382400f, 0.27782464f, 0.10081422f, 
    0.19164544f, -0.25704530f, 0.34669513f, -0.06557120f, 0.12176409f, 0.02293716f, 0.10977599f, -0.31473413f, 
    0.09007081f, 0.23714930f, -0.21581036f, -0.01385370f, 0.15679291f, -0.26046386f, -0.11294597f, -0.01531100f, 
    -0.20960699f, -0.18496002f, -0.26170897f, -0.09624329f, -0.01452366f, -0.26761553f, -0.13310382f, 0.10727436f, 
    -0.31776044f, -0.05510442f, -0.60072696f, -0.00776535f, 0.45501480f, 0.01225595f, 0.15832072f, 0.19527213f, 
    0.54641235f, -0.07869463f, 0.00058041f, -0.23946911f, 0.24111219f, 0.07096335f, 0.08803058f, 0.13676499f, 
    0.20792207f, 0.09488396f, 0.40238705f, 0.20101728f, -0.07770576f, -0.17110223f, 0.27598625f, 0.15882237f, 
    -0.50886315f, -0.09738144f, 0.27485478f, -0.01318700f, 0.19695914f, -0.24663179f, -0.18253231f, -0.00424733f, 
    -0.18992403f, 0.05766252f, 0.20011896f, 0.32711130f, 0.01740023f, 0.52131176f, -0.00425772f, 0.24380255f, 
    -0.17269573f, -0.09430039f, 0.35350364f, 0.16043264f, 0.22035585f, -0.31628680f, 0.13885500f, 0.17797868f, 
    0.13933417f, -0.16847719f, 0.15360071f, 0.23760994f, 0.18380788f, 0.00281476f, 0.37105784f, 0.19270317f, 
    -0.40015215f, 0.06917747f, 0.12026952f, -0.20278585f, 0.31374684f, -0.22406188f, 0.07825499f, -0.42406133f, 
    0.24951544f, -0.04347878f, -0.03959426f, -0.18594687f, 0.03528396f, -0.18289512f, 0.09913820f, 0.02746744f, 
    -0.09422270f, 0.32809982f, -0.41450280f, -0.04264951f, 0.13714160f, 0.11786316f, -0.14077954f, 0.12684302f, 
    0.09804194f, 0.11912897f, -0.06789777f, 0.39386827f, 0.35512316f, 0.16510643f, -0.15996027f, -0.13324307f, 
    -0.34391725f, 0.41207582f, -0.18739758f, -0.02638113f, 0.13704067f, 0.38373062f, -0.10281824f, -0.10937500f, 
    0.37333232f, 0.22427984f, -0.05424753f, 0.12438744f, -0.03474618f, 0.02105961f, -0.31223613f, 0.02151824f, 
    0.19686258f, 0.10768406f, -0.13985118f, 0.11217912f, -0.30687600f, 0.17376398f, 0.12065271f, 0.39456823f, 
    0.07707600f, 0.23600221f, 0.48539174f, -0.45108059f, 0.04169033f, 0.09738123f, -0.02991585f, 0.03157520f, 
    0.29934818f, -0.29936865f, -0.50399280f, 0.04712331f, 0.02027505f, 0.32216990f, 0.24094357f, 0.39645883f, 
    0.47504675f, -0.13682362f, -0.00178941f, 0.34096444f, -0.20997272f, -0.24819805f, -0.23785691f, 0.13949224f, 
    -0.07983055f, 0.23726362f, 0.10802480f, 0.24770251f, -0.65013659f, 0.36110950f, -0.11474624f, -0.06350248f, 
    0.55731690f, -0.10626622f, -0.01235436f, -0.09294725f, -0.69515800f, -0.08330177f, -0.14086851f, 0.05217185f, 
    0.39776075f, 0.02183241f, 0.04588711f, 0.12213826f, -0.37076598f, 0.09329670f, 0.17632696f, 0.12248712f, 
    -0.23267744f, 0.14680812f, 0.07508354f, -0.19923149f, 0.16071862f, -0.22297096f, -0.19406594f, 0.06793223f, 
    0.06793331f, -0.22327794f, -0.24476977f, -0.24224678f, -0.11933424f, -0.22362556f, -0.07302818f, 0.17215286f, 
    0.04776398f, -0.01584491f, -0.24142304f, -0.48605928f, -0.35196388f, 0.58540696f, 0.38267630f, -0.03934008f, 
    0.43529356f, -0.37160447f, -0.27332231f, 0.09936643f, -0.06093909f, -0.26210469f, 0.03290382f, 0.04060140f, 
    -0.12192564f, -0.10660985f, -0.08535848f, 0.51306790f, 0.31456590f, 0.30784732f, -0.05832313f, -0.14534108f, 
    -0.26592991f, -0.21646887f, 0.26612294f, 0.00349528f, 0.01521252f, -0.15294789f, 0.22157776f, -0.10577145f, 
    0.32518587f, 0.06997701f, 0.16644448f, 0.20106529f, -0.35213602f, 0.49433285f, 0.13184020f, -0.10462490f, 
    0.14010102f, -0.32275423f, 0.00983095f, -0.06291198f, 0.13598393f, -0.07233799f, 0.01133058f, -0.07992898f, 
    0.09669113f, 0.09827453f, 0.19092716f, -0.16545768f, 0.34350696f, 0.37063128f, -0.04658156f, 0.09731969f, 
    -0.36683407f, 0.22568098f, -0.11653415f, 0.12203306f, 0.13926788f, 0.19391024f, 0.18704212f, 0.44455221f, 
    0.12780295f, 0.02274187f, 0.20897254f, -0.25819770f, -0.29935664f, 0.12510766f, 0.19988112f, -0.20336752f, 
    0.14141072f, -0.04565747f, 0.37029627f, -0.19959222f, -0.39534444f, -0.05997946f, -0.01313925f, 0.11804611f, 
    0.44959632f, 0.11513783f, 0.23371173f, -0.08124655f, -0.17159466f, -0.52662432f, -0.05241136f, 0.21469313f, 
    0.29849753f, 0.12226886f, -0.03421667f, -0.04664533f, -0.73052812f, 0.53635103f, 0.13961877f, -0.05406864f, 
    -0.42121699f, -0.10160318f, -0.90989953f, -0.12745793f, -0.03469281f, -0.02041894f, 0.33250830f, -0.16769940f, 
    -0.18306683f, 0.34173989f, 0.35141492f, -0.20384362f, -0.05930884f, 0.02243100f, 0.13401932f, -0.06408983f, 
    0.26781663f, -0.14718416f, -0.13517357f, 0.38720480f, 0.04991591f, 0.08301312f, 0.21066688f, -0.15232763f, 
    -0.32791218f, 0.20475501f, -0.15868706f, -0.14544117f, -0.05553333f, 0.32945445f, -0.14725555f, -0.08150669f, 
    0.31724921f, 0.20975812f, 0.16271837f, 0.24494769f, 0.37844834f, -0.56371450f, -0.15078032f, 0.00728344f, 
    0.11684229f, 0.20589001f, -0.18430755f, 0.15050192f, 0.44073156f, -0.03265413f, -0.02368286f, -0.36381310f, 
    -0.23356998f, 0.08068863f, 0.05770155f, 0.20095068f, -0.24013308f, -0.15998137f, 0.11484177f, -0.06703293f, 
    -0.05939230f, -0.07182961f, -0.12121961f, 0.15539867f, -0.13555494f, -0.06081085f, -0.09921202f, -0.02214196f, 
    -0.06418273f, -0.23503402f, 0.41223180f, -0.18594263f, 0.38711497f, 0.38632533f, -0.15562001f, -0.01561195f, 
    -0.23558408f, 0.40098634f, -0.18727022f, 0.14242764f, 0.16957317f, 0.18810712f, -0.11204348f, 0.03359438f, 
    -0.32007232f, 0.05129471f, -0.20002756f, 0.38349426f, 0.50617439f, 0.00399439f, -0.08172109f, -0.18182361f, 
    0.37781298f, 0.20624202f, -0.01642565f, 0.13338420f, -0.13926047f, 0.37314078f, -0.03793013f, -0.14190388f, 
    0.19456613f, -0.12435386f, 0.14555828f, -0.30737320f, 0.15196130f, 0.31823325f, 0.04348248f, 0.18582544f, 
    -0.29352295f, -0.41278216f, 0.46184105f, 0.09977979f, -0.07771277f, -0.09038485f, 0.02028447f, -0.03254225f, 
    0.05245281f, 0.06261117f, -0.68032056f, -0.14685670f, 0.09588177f, -0.34779879f, -0.38796350f, -0.05825819f, 
    0.05861424f, -0.03822251f, 0.24142638f, -0.19256565f, 0.05985493f, -0.02557039f, -0.01782221f, 0.32069990f, 
    -0.30863166f, 0.15959555f, -0.24189857f, 0.44008958f, -0.15715881f, -0.02145982f, 0.08357310f, -0.00175163f, 
    0.48013288f, -0.37194982f, -0.23447467f, 0.17865866f, 0.24625716f, 0.05381443f, -0.23457491f, 0.23287059f, 
    -0.15652293f, -0.10138699f, 0.01801655f, -0.20542482f, -0.22885388f, 0.14738521f, -0.07604618f, 0.12384912f, 
    -0.24806851f, 0.04499206f, -0.21063702f, 0.12667418f, 0.09365436f, -0.13231267f, 0.18526015f, 0.06553304f, 
    -0.24998377f, 0.00833622f, 0.12202352f, -0.09582996f, -0.33475763f, -0.50625271f, -0.37683499f, -0.14692749f, 
    0.16266465f, 0.08374427f, 0.17637423f, 0.05734849f, -0.28193018f, 0.04713942f, 0.04724014f, 0.41517350f, 
    -0.04320562f, 0.14498501f, -0.83028716f, 0.45732734f, -0.19018875f, -0.12356389f, 0.07446339f, 0.12728085f, 
    0.07327916f, 0.26594019f, -0.24396281f, 0.08061317f, 0.45201293f, 0.19213866f, -0.08104610f, -1.01548743f, 
    -0.13900451f, -0.16460627f, -0.16346188f, 0.32181209f, -0.30121532f, 0.00563734f, -0.07652890f, -0.17391886f, 
    -0.33352169f, -0.07777847f, 0.12660958f, -0.00727054f, 0.15063274f, 0.29542547f, 0.24010417f, 0.35299653f, 
    -0.05732945f, -0.11996337f, 0.06308167f, 0.48942900f, -0.23338829f, -0.09290475f, -0.22753245f, -0.10292429f, 
    0.59071088f, -0.27983728f, 0.27609989f, -0.10420851f, 0.08969102f, 0.23170795f, 0.20852114f, -0.21306309f, 
    -0.27491704f, 0.12067312f, -0.60891825f, -0.87036622f, -0.14821477f, 0.14647938f, 0.06778609f, -0.25570697f, 
    0.32011637f, 0.17103370f, -0.38560045f, 0.21026266f, 0.44054219f, 0.35798731f, -0.17755654f, 0.25102907f, 
    -0.13062866f, -0.13774914f, -0.40723410f, 0.44865423f, -0.25800383f, -0.07634309f, -0.20232034f, -0.21696252f, 
    -0.03097387f, -0.24535273f, 0.35620689f, 0.23772579f, 0.17141706f, 0.12427175f, 0.00159036f, 0.20251760f, 
    -0.10575910f, 0.13606469f, 0.24784708f, -0.09626416f, 0.17850216f, -0.35651848f, 0.18744263f, 0.05751161f, 
    -0.11612123f, -0.48067260f, 0.51004493f, -0.15211357f, 0.12781917f, -0.45231164f, -0.20618136f, 0.46226767f, 
    0.17341436f, -0.19178733f, -1.02859044f, 0.18898560f, -0.01858194f, 0.01160335f, 0.07570014f, 0.07648590f, 
    0.18357691f, 0.02111178f, -0.29363000f, -0.04121023f, -0.25091851f, 0.50273019f, 0.00149134f, 0.41493857f, 
    0.09186427f, 0.16383673f, 0.44178545f, -0.15025119f, 0.39697647f, -0.24737127f, 0.45062676f, -0.09566191f, 
    -0.08051945f, 0.16062832f, 0.14424402f, 0.09528324f, 0.14557524f, 0.15658048f, 0.17643626f, -0.54999083f, 
    -0.00180939f, 0.01484596f, -0.08850913f, 0.09027553f, -0.31948122f, 0.52084208f, -0.31855819f, -0.17455952f, 
    0.26976392f, -0.02844280f, 0.03393576f, -0.21823432f, 0.04343409f, 0.06573299f, -0.19046028f, 0.36479935f, 
    -0.16638014f, -0.04879967f, -0.12319241f, -0.45943487f, 0.10739870f, 0.38798782f, 0.07221256f, -0.00038333f, 
    -0.07784770f, 0.42916447f, -0.05149930f, -0.16770010f, -0.02190872f, -0.01765043f, -0.20221204f, 0.51685613f, 
    0.36703140f, -0.15921746f, -0.24297358f, -0.10576411f, -0.02795674f, -0.17242853f, -0.31116092f, -0.17057557f, 
    0.19290015f, 0.27014112f, -0.19685715f, 0.22371569f, -0.00531498f, 0.23178379f, -0.05566253f, 0.36879835f, 
    0.16235141f, 0.06772685f, 0.52885967f, -0.15380722f, 0.07926932f, 0.23286571f, -0.31630298f, -0.17891410f, 
    0.18658441f, -0.04640866f, 0.30531928f, 0.24783856f, -0.03636255f, -0.35125771f, 0.12560831f, 0.00336837f, 
    0.41492823f, -0.10273205f, 0.10298346f, -0.20078561f, 0.19990098f, -0.19238743f, -0.33519119f, 0.18436308f, 
    -0.11446413f, -0.29246253f, 0.57993048f, 0.16264562f, -0.10950046f, -0.26503563f, -0.03673354f, -0.02991395f, 
    -0.05023884f, -0.12958045f, 0.16740906f, 0.03773912f, 0.09850438f, -0.36441234f, 0.34979865f, 0.21591337f, 
    0.03178225f, -0.11568012f, 0.31509835f, -0.20979030f, -0.10457294f, 0.20746531f, -0.16005535f, -0.26408342f, 
    -0.00085934f, 0.00136763f, -0.55945104f, 0.26904637f, 0.30649585f, 0.19732915f, -0.01108913f, 0.18979363f, 
    0.40597823f, -0.21609816f, 0.08625738f, -0.20444986f, 0.47737405f, -0.61198080f, 0.20668809f, -0.06451502f, 
    0.17095080f, -0.15050283f, 0.05975071f, 0.08897022f, 0.31496391f, 0.67378813f, -0.23997119f, -0.19094609f, 
    -0.37566116f, 0.17479643f, 0.10772735f, 0.06044560f, -0.13096288f, -0.01728557f, 0.03267794f, 0.09870551f, 
    -0.10469619f, -0.12725559f, -0.24719861f, -0.21578506f, 0.20055936f, 0.06280641f, 0.04826561f, 0.04724026f, 
    -0.13230380f, -0.08425397f, -0.07157665f, 0.17002133f, -0.09335233f, 0.04480498f, 0.14644670f, -0.22754872f, 
    -0.01044211f, -0.10832158f, 0.21413332f, 0.14960207f, 0.08592841f, -0.10774876f, 0.30523106f, -0.11610906f, 
    0.04237070f, 0.05773823f, 0.08901069f, 0.13889629f, -0.27544495f, 0.42612231f, -0.17812262f, -0.38003522f, 
    -0.20025750f, 0.08710337f, -0.15175755f, 0.18985160f, 0.10017027f, -0.16141336f, 0.03445644f, 0.09288982f, 
    0.01116926f, -0.23582315f, -0.24230909f, -0.24126521f, -0.23892710f, -0.14458397f, -0.24444690f, 0.17100342f, 
    0.04671643f, 0.14073254f, -0.39480174f, 0.04462604f, 0.31374788f, 0.02665761f, -0.44661307f, 0.00651217f, 
    0.12351622f, 0.53105623f, -0.17630409f, -0.16959621f, -0.04622083f, -0.16286831f, -0.03490676f, 0.36845371f, 
    0.21265697f, 0.15722358f, 0.52400666f, -0.30439416f, -0.33048347f, -0.85600084f, -0.55309021f, -0.10647716f, 
    -0.14891000f, 0.41493997f, 0.55804765f, 0.14383529f, -0.44619402f, 0.01287152f, -0.19442379f, -0.12871251f, 
    -0.13237551f, 0.07485625f, 0.41213533f, 0.12668768f, -0.43680355f, 0.18476497f, 0.31984144f, -0.07928330f, 
    0.14519514f, -0.15000714f, 0.33157945f, 0.06461967f, -0.14548586f, 0.09531765f, 0.19755001f, -0.12320109f, 
    0.38437822f, -0.07069325f, -0.26524261f, 0.27817810f, -0.31345019f, 0.41328642f, 0.28900647f, -0.08494586f, 
    -0.28701028f, -0.15583631f, -0.00913799f, -0.13056004f, 0.20000404f, -0.12309603f, -0.08060536f, 0.27482200f, 
    0.31973657f, 0.16129619f, 0.19459189f, 0.40308514f, -0.37177223f, 0.21026374f, 0.23006451f, 0.19688746f, 
    0.35046703f, -0.39709437f, 0.39920092f, -0.12970759f, -0.10504526f, -0.20604326f, 0.16164546f, 0.05222627f, 
    0.48491716f, 0.14871423f, -0.01692142f, 0.37961128f, -0.00624593f, 0.25328121f, -0.64498007f, -0.05102472f, 
    0.13562801f, 0.14610352f, -0.29258767f, -0.03604919f, 0.16520636f, -0.49952003f, 0.14683008f, 0.19326018f, 
    0.38086319f, -0.03822382f, -0.10427204f, -0.07386343f, -0.40065658f, 0.52958393f, 0.18674849f, 0.11861295f, 
    0.32208872f, 0.01684184f, -0.01140853f, 0.23430164f, -0.29022840f, -0.03683663f, 0.03788612f, -0.13795571f, 
    -0.18711884f, 0.22217645f, -0.06835054f, 0.27038956f, 0.32045543f, 0.12066482f, 0.19985534f, 0.10375530f, 
    -0.31163028f, 0.43336478f, -0.26640043f, 0.08076092f, 0.03132517f, 0.35423064f, -0.05624514f, 0.16163214f, 
    0.16745740f, 0.02258233f, 0.39255843f, -0.77536488f, 0.27493241f, 0.05608169f, -0.16137329f, 0.04669640f, 
    -0.01952339f, 0.08081313f, -0.02332194f, 0.20888068f, -0.11888625f, 0.51151234f, -0.18592127f, -0.08623850f, 
    0.20358649f, 0.10045661f, -0.30468607f, -0.01766770f, 0.10413044f, -0.12617585f, -0.09641529f, 0.20527379f, 
    -0.02930471f, 0.35112050f, -0.24253331f, 0.03217591f, 0.00367510f, 0.39336595f, 0.00411088f, 0.08033060f, 
    -0.07060206f, -0.21476448f, 0.10055193f, -0.03232551f, -0.01053530f, -0.15477502f, -0.00289777f, -0.21847680f, 
    -0.17923674f, -0.04088184f, -0.19028407f, 0.13062075f, -0.08740920f, 0.02969161f, -0.08325642f, -0.18751803f, 
    -0.29044402f, -0.22025909f, -0.18888453f, 0.38971946f, -0.22853261f, 0.29179844f, 0.28764048f, 0.19595160f, 
    -0.51380306f, 0.21822944f, 0.20945372f, 0.10184649f, 0.17917818f, -0.34164566f, 0.08235232f, 0.32096252f, 
    -0.02485313f, 0.15573128f, -0.15339014f, 0.02655987f, -0.12995705f, -0.04852032f, 0.07263121f, 0.17228942f, 
    0.11858176f, -0.23392437f, -0.18642730f, -0.07578702f, -0.13149272f, -0.06430806f, -0.24498811f, 0.00203028f, 
    0.02664249f, 0.02530053f, -0.00028353f, -0.07964018f, -0.24063973f, -0.22305883f, -0.19176546f, -0.09842625f, 
    -0.03143736f, 0.05547624f, -0.11826647f, -0.19532436f, -0.24966219f, -0.06154477f, 0.12792343f, 0.03245095f, 
    0.40685251f, -0.10756482f, -0.02791245f, 0.14032172f, -0.43625066f, 0.52020121f, 0.00653438f, 0.24472249f, 
    -0.16011059f, 0.13450941f, -0.14355220f, -0.23236375f, -0.61683768f, 0.23035719f, 0.19452630f, -0.11096358f, 
    0.18706147f, 0.21788299f, -0.62560886f, 0.34464264f, 0.11687492f, -0.38951236f, -0.61970586f, -0.13457018f, 
    -0.13156000f, 0.27514437f, 0.03030753f, -0.06488749f, -0.33582404f, 0.28107408f, 0.03956434f, 0.40195441f, 
    0.41344619f, -0.15856449f, -0.48006970f, 0.55795962f, 0.18484169f, -0.04303766f, -0.14175974f, -0.20711899f, 
    0.23157151f, -0.17405427f, -0.06753553f, 0.06084488f, -0.00515792f, 0.03278429f, -0.19771764f, -0.20181081f, 
    -0.07323132f, 0.06862739f, -0.08730477f, 0.10220869f, 0.13677721f, 0.00094062f, 0.09671558f, 0.20390587f, 
    -0.21548711f, -0.16982558f, -0.15168619f, 0.12127438f, -0.26701197f, -0.01739927f, -0.05142784f, -0.11761851f, 
    -0.17897211f, -0.14253548f, -0.16602109f, 0.02451828f, 0.18368410f, 0.26213038f, -0.27033129f, -0.10355762f, 
    0.26975596f, 0.09153272f, 0.14518386f, -0.04008216f, -0.16186155f, 0.39657423f, 0.22980601f, 0.30674478f, 
    0.15651551f, 0.00560806f, -0.18706088f, -0.26207215f, 0.49717245f, -0.38157180f, -0.25531372f, 0.02648116f, 
    -0.28633898f, 0.19838890f, -0.12111331f, 0.16549961f, 0.38394770f, 0.24765913f, 0.17868382f, 0.25982550f, 
    -0.20427132f, -0.17781636f, -0.15563057f, 0.12357714f, 0.22652659f, 0.33570912f, 0.26708725f, 0.22885451f, 
    -0.10679126f, 0.46454495f, -0.27646634f, 0.09546304f, -0.06700266f, 0.07840382f, -0.16501337f, 0.28201935f, 
    0.04634253f, -0.03531835f, -0.45688993f, 0.19971719f, 0.46527448f, -0.02568034f, -0.00449520f, 0.20005584f, 
    0.36132079f, -0.17238209f, -0.12665617f, 0.19341166f, 0.36476097f, -0.47391331f, -0.04617377f, 0.03337965f, 
    -0.03933042f, 0.22676724f, 0.02563360f, -0.05500970f, -0.20877473f, -0.10020778f, -0.17327113f, -0.00371537f, 
    -0.22679961f, -0.01666626f, 0.19506077f, 0.13715079f, -0.18778896f, -0.16364807f, 0.16348284f, -0.25491357f, 
    -0.04771717f, -0.09358284f, -0.01768179f, 0.30233061f, 0.23137216f, -0.51237965f, 0.18847077f, -0.03934094f, 
    0.11075777f, 0.15956521f, 0.24868849f, -0.18486963f, 0.26846331f, 0.24245609f, -0.20198724f, -0.30956137f, 
    -0.18187086f, 0.13641697f, 0.06074362f, -0.05427802f, -0.09797029f, 0.18364067f, -0.13581412f, -0.01551135f, 
    0.04899756f, -0.13930666f, -0.18841957f, -0.20408177f, 0.04251762f, -0.02467572f, -0.24530184f, -0.00965443f, 
    0.29624698f, 0.12064941f, 0.12187132f, -0.03060124f, -0.28110269f, 0.14036067f, -0.40230712f, 0.07792475f, 
    -0.17440929f, -0.23477298f, 0.34719959f, 0.10527337f, -0.09351443f, -0.42505285f, 0.17365059f, 0.30784369f, 
    0.15387747f, 0.14367078f, 0.58593482f, 0.04546513f, 0.15566424f, 0.31961387f, 0.17243622f, 0.22161728f, 
    -0.50091267f, -0.02684336f, -0.07504601f, 0.00826895f, -0.02296892f, 0.19020575f, -0.11342347f, -0.12571719f, 
    -0.21861659f, -0.17535855f, -0.20878306f, -0.47511044f, 0.09392922f, -0.22723192f, 0.22374128f, 0.20850089f, 
    0.03080724f, 0.29903352f, 0.08486705f, 0.00642916f, 0.24591342f, 0.16699325f, 0.10584204f, 0.18904872f, 
    -0.00073356f, 0.11221522f, 0.12473196f, 0.00833260f, -0.18423010f, -0.21881866f, -0.16947266f, -0.24768965f, 
    -0.16182944f, -0.06203751f, -0.03627424f, 0.07237837f, 0.15449609f, -0.18783423f, -0.16533104f, -0.23485944f, 
    0.21226041f, -0.15932173f, -0.45970526f, 0.60449660f, -0.18934438f, 0.14654122f, -0.06788081f, -0.04800344f, 
    -0.38102546f, -0.13453893f, 0.42974713f, -0.06082603f, 0.06456947f, 0.16173886f, 0.16250715f, -0.26868659f, 
    0.44575813f, -0.19171000f, 0.41284049f, 0.58383048f, -0.31133968f, 0.20666690f, 0.21492040f, -0.12600060f, 
    0.10451538f, -0.27283198f, 0.25453421f, -0.15767962f, -0.06280520f, -0.21448289f, 0.14443845f, -0.25548586f, 
    0.08218780f, -0.02485225f, -0.12777667f, -0.30672932f, -0.05337999f, 0.32205990f, 0.38381794f, 0.14800206f, 
    0.37995464f, 0.15077932f, 0.21719433f, -0.02661730f, -0.01750931f, 0.01558352f, -0.14274827f, -0.51702756f, 
    -0.16027108f, 0.06624335f, 0.03637542f, 0.01712777f, 0.14569996f, -0.18726097f, 0.47142947f, 0.20852384f, 
    -0.33675420f, 0.37678236f, 0.16469625f, -0.20193803f, 0.34309098f, 0.14175527f, -0.00508538f, -0.37790433f, 
    -0.13236585f, 0.22405440f, 0.22257785f, -0.06250215f, 0.29028088f, -0.09859857f, -0.22332458f, -0.20481394f, 
    0.17855763f, -0.14953819f, 0.39089337f, 0.11778381f, 0.47881278f, -0.52842063f, -0.22364910f, -0.05714280f, 
    -0.08773935f, -0.17162439f, 0.15141058f, 0.42475891f, -0.11046692f, -0.10203536f, 0.23503703f, -0.00411164f, 
    -0.14513904f, -0.07468912f, 0.43776530f, 0.14287648f, 0.04254261f, 0.24095605f, -0.21846381f, -0.25019661f, 
    0.29364559f, 0.23591195f, -0.34860459f, -0.18341553f, -0.21532863f, 0.41041538f, -0.18780611f, 0.01246468f, 
    -0.38012964f, 0.11678866f, -0.04034255f, -0.08988980f, -0.13186198f, 0.29893282f, 0.06698984f, 0.32062936f, 
    0.10030279f, -0.25677741f, -0.67208892f, -0.04211404f, 0.34844556f, 0.04942825f, -0.35954759f, -0.01730756f, 
    0.55330426f, -0.23044282f, 0.09958138f, -0.16176823f, 0.22418196f, -0.08655790f, 0.14361630f, 0.16644502f, 
    0.28623217f, 0.16076903f, -0.00870999f, 0.43700805f, 0.12913372f, -0.22840318f, 0.19376847f, -0.15852058f, 
    -0.22316371f, 0.28434089f, -0.09871645f, 0.15126644f, 0.36158502f, -0.26606756f, -0.09956240f, -0.39087361f, 
    -0.02850328f, -0.06565598f, 0.02991159f, 0.29024759f, 0.46235403f, 0.31661406f, 0.09681918f, 0.03662171f, 
    -0.32659313f, 0.01559758f, 0.01559555f, -0.07513508f, 0.11718849f, -0.04547077f, -0.12078691f, 0.13883609f, 
    -0.41743445f, -0.18392861f, 0.14601091f, 0.18176877f, 0.09090110f, 0.32533979f, 0.24746910f, -0.10352896f, 
    -0.46067983f, 0.23492153f, -0.07006097f, -0.02023491f, 0.10782491f, 0.22620966f, 0.15548792f, 0.18901515f, 
    0.03026720f, -0.08056254f, 0.15925637f, 0.19957447f, -0.09734797f, -0.26995483f, -0.24259076f, 0.19802366f, 
    0.18832454f, -0.24349502f, 0.49889681f, -0.19684440f, 0.13476336f, -0.47481790f, 0.02003364f, 0.31509763f, 
    0.01413688f, 0.09833920f, 0.20515780f, 0.42409673f, -0.03128111f, 0.16528305f, 0.23330893f, -0.07139936f, 
    -0.39059541f, 0.41645798f, 0.01157977f, 0.11609450f, -0.38605320f, 0.25883269f, -0.10443395f, -0.34904248f, 
    0.39086291f, 0.21002005f, -0.33906865f, 0.33591062f, -0.30291045f, -0.36851841f, -0.20858759f, 0.06209659f, 
    -0.11451168f, 0.24902362f, -0.00110983f, -0.03358984f, -0.26589453f, 0.17552119f, 0.13578327f, 0.00372506f, 
    0.46438128f, -0.20224759f, -0.16491894f, -0.27006727f, -0.41334879f, -0.14863294f, -0.22353326f, 0.03893387f, 
    0.06987499f, 0.06542358f, -0.26741302f, 0.21607634f, -0.13840306f, 0.33901849f, -0.12584680f, 0.37090889f, 
    -0.33878538f, 0.13465233f, -0.33927628f, 0.36919320f, -0.10553856f, -0.30799195f, -0.02921677f, -0.17406417f, 
    0.29392913f, 0.05979795f, 0.16110411f, -0.18789673f, 0.19567172f, -0.16609041f, 0.06628776f, 0.43135417f, 
    0.47922379f, 0.02765074f, 0.14689076f, 0.15352565f, -0.21079868f, 0.07910461f, -0.13605058f, 0.20034966f, 
    -0.00997883f, -0.24765892f, 0.40192047f, 0.17413215f, 0.02187768f, -0.36458260f, -0.18937534f, 0.12599365f, 
    -0.05079691f, 0.19998470f, 0.55699211f, -0.12709942f, 0.00505853f, 0.27328622f, 0.36142227f, -0.11146924f, 
    0.12539387f, 0.14556997f, 0.31905782f, 0.04216476f, -0.09740352f, -0.10850274f, -0.01714830f, -0.30468193f, 
    0.37159804f, -0.11824980f, 0.21589732f, 0.36543682f, 0.09757521f, 0.31673461f, 0.10770152f, 0.14502637f, 
    -0.22122918f, 0.30589440f, -0.15962723f, 0.07846758f, 0.05121555f, -0.01624123f, 0.13058311f, -0.36621070f, 
    -0.07495812f, -0.10957929f, 0.01020991f, 0.13876955f, -0.47387394f, 0.17243731f, 0.17287752f, 0.20217645f, 
    -0.13034706f, -0.47080845f, -0.03110099f, 0.24012829f, 0.30094850f, -0.26562184f, -0.02073727f, 0.50348115f, 
    0.17880765f, 0.09529281f, 0.13456623f, 0.29013410f, -0.18315493f, -0.71493512f, -0.25343621f, -0.01647088f, 
    0.41878405f, -0.29408360f, 0.54111212f, 0.17393124f, -0.45466900f, 0.42767391f, -0.09843040f, 0.04729116f, 
    0.05287559f, -0.22199380f, 0.13468163f, -0.18981241f, 0.26400021f, -0.31922922f, 0.10862485f, -0.23250850f, 
    0.09183765f, -0.28626415f, 0.39915395f, -0.23959810f, 0.24962664f, -0.24414827f, 0.08721458f, -0.23575437f, 
    -0.20740698f, 0.11981060f, -0.88286078f, 0.24787040f, 0.24284749f, -0.10319971f, 0.03277682f, 0.18106160f, 
    0.31557074f, -0.20613587f, -0.09394898f, -0.15888314f, -0.18802275f, 0.35953647f, 0.21483746f, 0.47955561f, 
    -0.19073302f, -0.20683965f, 0.25843200f, -0.02452111f, 0.28094855f, 0.00393707f, -0.34729522f, -0.17883639f, 
    -0.04352514f, 0.51928997f, -0.11418928f, 0.18964905f, 0.08237711f, 0.33721274f, -0.21038902f, -0.45718879f, 
    0.42371258f, 0.01696127f, 0.05550095f, 0.29007730f, -0.23828407f, -0.34954759f, -0.08972245f, -0.12551083f, 
    0.38264441f, 0.08680233f, 0.03728008f, -0.17743506f, -0.71866280f, 0.12021944f, -0.05150299f, -0.14285925f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.22927873f, 0.32323691f, 0.32548669f, -0.32567942f, 0.56378543f, 0.45463002f, 0.19680673f, 0.17321242f, 
    -0.00675563f, -0.08230999f, -0.28804570f, 0.44090629f, -0.45762306f, 0.39115891f, -0.21515530f, -0.24017689f, 
    0.33143330f, 0.46019840f, -0.58171606f, 0.13419329f, 0.49907961f, -0.07214259f, 0.05350434f, 0.36113653f, 
    0.12204763f, 0.10623913f, 0.01643631f, -0.58172268f, 0.55209613f, -0.15124947f, 0.36850926f, 0.36454874f, 
    -0.12398122f, 0.27101168f, -0.10861851f, -0.25352818f, 0.36073169f, -0.02419651f, -0.50078154f, -0.10228377f, 
    0.49224499f, -0.00165801f, 0.08636132f, -0.20851538f, 0.00952476f, 0.48334789f, -0.23484123f, -0.19129734f, 
    -0.10296984f, -0.40982053f, 0.23389484f, 0.39910367f, -0.46675256f, -0.14221486f, -0.40500593f, 0.68238062f, 
    0.26819739f, -0.30216900f, -0.46181685f, 0.31509528f, 0.15616791f, -0.47739151f, 0.14221835f, -0.16337904f, 
    0.64633477f, 0.54286915f, -0.18081868f, 0.35848776f, -0.03463938f, -0.42752436f, 0.15604660f, 0.05397143f, 
    0.30294243f, -0.18840726f, 0.52579206f, -0.21367905f, -0.09529862f, 0.54864711f, -0.02672251f, 0.10632876f, 
    0.43219608f, 0.23941013f, 0.34141698f, 0.11647765f, -0.20418239f, 0.31560874f, 0.16174373f, -0.13347414f, 
    0.35723221f, -0.04669032f, -0.32167611f, -0.05339451f, -0.36684135f, 0.36435914f, 0.25199866f, 0.13896908f, 
    -0.16025847f, 0.11598212f, -0.25471261f, 0.35452783f, 0.15120369f, 0.40200990f, -0.14908242f, 0.04716917f, 
    0.02955623f, 0.19340234f, -0.03601522f, 0.32497045f, -0.37698781f, 0.64792573f, -0.26483062f, 0.10646141f, 
    0.05811189f, -0.17226288f, 0.13606860f, -0.13610996f, 0.39403906f, 0.41468191f, -0.01565055f, -0.01773265f, 
    -0.37272346f, -0.00731536f, -0.19891521f, -0.31120059f, 0.01873552f, -0.21551649f, 0.38623658f, 0.15459347f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.54798728f, -0.34999630f, -0.47864202f, 0.01129235f, -1.07747900f, -0.28345257f, 0.09086075f, -0.38544747f, 
    -0.58043903f, -1.00585353f, 0.05310665f, -0.01324967f, -1.12166810f, -0.41914484f, 0.05123725f, -0.02085796f, 
    0.24195515f, -0.00358595f, -0.65384758f, 0.10238878f, -0.04717597f, -1.01585007f, -0.08027392f, 0.16053888f, 
    -0.17329200f, 0.08145871f, 0.00596308f, -0.06083602f, 0.19894575f, 0.15397371f, 0.14102027f, -0.25035957f, 
    -0.16215296f, 0.00664270f, -0.24804050f, -0.38622323f, -0.08502181f, 0.03166243f, 0.33943036f, 0.20740831f, 
    0.12528248f, -0.23641711f, -0.13468395f, -0.56899393f, 0.24202453f, -0.12860595f, 0.25385702f, -0.03955435f, 
    -0.25000522f, -0.03810035f, -0.02686739f, 0.15967113f, 0.03378045f, -0.06503526f, -0.67456830f, -0.03791069f, 
    0.03824050f, 0.26973823f, 0.20469107f, 0.18728334f, 0.34252882f, -0.90832078f, -0.00106779f, -0.01880030f, 
    -0.36511496f, -0.04945008f, 0.18774489f, 0.58572626f, -0.03761135f, 0.31484392f, -0.04334254f, 0.00846821f, 
    -0.20456257f, -0.04332215f, 0.10814513f, -0.59920019f, -0.04983543f, 0.04870260f, 0.09775370f, 0.46208504f, 
    -0.11129555f, -0.28645107f, -0.39864123f, -0.28300714f, 0.05363457f, 0.13409363f, -0.01382167f, 0.02961839f, 
    -0.35924593f, 0.38566804f, 0.06138640f, -0.00408906f, -0.27596956f, -0.05214078f, -0.47997388f, 0.25669804f, 
    0.06670841f, 0.06554605f, 0.08429317f, 0.33775765f, -0.11905678f, -0.18755989f, 0.02929901f, 0.05360842f, 
    0.22321942f, -0.03356435f, -0.15524417f, 0.35265666f, 0.03126378f, -0.20946284f, 0.16824168f, 0.10499438f, 
    0.07341665f, -0.28805399f, 0.34474435f, -0.63078809f, -0.08655613f, -0.28719968f, 0.17975767f, 0.28178164f, 
    -0.08367066f, -0.08332208f, 0.02641843f, 0.15368906f, 0.25516233f, -0.44784215f, -0.32292497f, -0.26112562f, 
    -0.19361122f, -0.56712544f, -0.08349574f, 0.47761518f, 0.48278788f, -0.18815804f, -0.64802241f, 0.02977604f, 
    -0.59702533f, 0.36665609f, -0.03696880f, 0.04847781f, 0.15197097f, -0.19216847f, -0.00959070f, 0.11681429f, 
    0.13449405f, -0.01231514f, 0.75404382f, 0.00032571f, -0.10377419f, -0.22769424f, 0.10402282f, -0.37570104f, 
    -0.42592812f, -0.09608423f, -0.01708107f, -0.21049823f, 0.07915129f, 0.08048397f, 0.11395435f, -0.06305287f, 
    0.17913993f, -0.25720990f, 0.89159757f, 0.02480409f, -0.93972325f, -0.02799767f, 0.13002579f, 0.25783947f, 
    -0.07371489f, -0.06249726f, -0.25613216f, -0.62133926f, 0.07190745f, 0.13818786f, 0.05768156f, 0.09721848f, 
    -0.01403658f, 0.06550576f, -0.25604498f, 0.15531044f, 0.23920022f, -0.11068890f, -0.78834319f, 0.14157620f, 
    0.25978154f, 0.12950578f, -0.29623067f, 0.23447102f, -0.25168180f, 0.05541681f, 0.06265055f, -0.07736958f, 
    -0.30625808f, -0.22500345f, -0.08981274f, -0.15176804f, 0.11351284f, -0.14659517f, 0.02858009f, -0.07933429f, 
    0.05878055f, -0.02419723f, -0.09296009f, -0.40085879f, 0.12357974f, 0.02731690f, 0.02406035f, -0.18219170f, 
    -0.28728279f, 0.14922996f, 0.17191675f, -0.00432550f, 0.02046268f, 0.12178995f, 0.04507219f, -0.01038622f, 
    -0.21467623f, 0.06337015f, 0.26401624f, 0.06879457f, -0.06055978f, 0.03409304f, -0.09341924f, 0.00722771f, 
    -0.00978512f, 0.07206473f, -0.04670496f, -0.25858483f, 0.03840384f, -0.17155311f, -0.13670725f, 0.55800384f, 
    0.01282211f, -0.23995601f, 0.06283548f, -0.03082487f, 0.16682874f, -0.00465030f, -0.04203839f, 0.14255311f, 
    0.15818219f, 0.19985321f, -0.00816241f, 0.20677562f, 0.11973158f, -0.37904653f, 0.09422663f, -0.10728584f, 
    -0.10031763f, 0.07740283f, 0.18974863f, -0.44588703f, -0.04175024f, 0.24444453f, 0.08339245f, -0.42252403f, 
    0.21176504f, -0.12878501f, 0.23223673f, -0.66196895f, -0.93617189f, 0.10096733f, -0.80419183f, -0.03692208f, 
    0.12198488f, -0.41991413f, 0.16490678f, 0.09704934f, -0.42835179f, 0.21341462f, -0.07899518f, 0.14277092f, 
    -0.60499692f, -0.18636866f, -0.20564774f, -0.52669609f, -0.63894206f, 0.40229192f, 0.03653410f, 0.04884952f, 
    0.11662938f, 0.09509739f, -0.01814813f, 0.34142938f, -0.62426209f, -0.17612042f, -0.32203731f, -0.14492388f, 
    -0.19435187f, 0.10886743f, -0.79406160f, 0.37306806f, 0.42605624f, -0.04798653f, -0.40295693f, -0.20704617f, 
    -0.12213488f, -0.67767465f, 0.08695006f, 0.38417557f, 0.15425493f, -0.07469960f, -0.03567025f, -0.09671542f, 
    -0.51400250f, 0.27777728f, -0.23359682f, -0.01864641f, 0.27659416f, -0.01390577f, -0.33435115f, -0.30080131f, 
    -0.18421452f, 0.51256335f, 0.48228726f, -0.01102200f, -0.21839961f, 0.40884969f, -0.09620316f, 0.17551397f, 
    -0.49038380f, -0.02843621f, 0.01480838f, 0.01136475f, 0.11506399f, 0.14507897f, -0.45011017f, 0.03941028f, 
    0.04260832f, 0.01787102f, -0.39114216f, -0.23619819f, 0.04362899f, -0.33632782f, 0.06778213f, 0.17612623f, 
    0.09785458f, -0.21686029f, -0.27410233f, 0.02414539f, 0.00831398f, -0.44452935f, -0.07435837f, 0.04521146f, 
    -0.02504585f, 0.19525529f, 0.38071302f, 0.01821804f, 0.11987430f, -0.74451143f, -0.25925153f, 0.03564784f, 
    0.06731645f, 0.06763732f, 0.04664631f, 0.31063089f, -0.66137701f, -0.07094209f, -0.08741581f, -0.22845960f, 
    -0.01933787f, 0.16416363f, -0.30497450f, 0.20211977f, 0.04333394f, -0.28710300f, 0.29308891f, -0.14694063f, 
    -0.65021968f, -0.39982337f, 0.11642002f, -0.16900119f, 0.30104873f, 0.09906562f, 0.23815452f, 0.02051829f, 
    -0.02252469f, -0.13462467f, -0.37937632f, 0.73169792f, 0.09075332f, 0.48022410f, -0.07969375f, 0.44082576f, 
    0.02490962f, 0.03404615f, -0.08887354f, 0.19149600f, 0.52068907f, 0.11001761f, -0.10278403f, -0.02921071f, 
    0.09927455f, 0.23381169f, -0.00100397f, -0.21879397f, 0.13615462f, -0.04675924f, 0.01482442f, -0.47168335f, 
    0.14728676f, 0.02678341f, 0.18123849f, 0.03477768f, 0.10058789f, -0.35110059f, -0.11940547f, 0.05824857f, 
    0.17857282f, -0.30181402f, -0.06572543f, 0.21505927f, -0.04989317f, 0.04320871f, -0.07223732f, 0.12274744f, 
    -0.22273266f, 0.14789060f, 0.07018290f, -0.06523747f, 0.08263192f, 0.05899870f, -1.24521506f, -0.30446103f, 
    0.04832717f, 0.12668146f, -0.06439356f, -0.00874486f, 0.25927141f, -0.04797743f, -0.14277045f, -0.08404160f, 
    0.11098541f, -0.00553260f, -0.08983050f, -0.31736296f, 0.48979169f, 0.04115547f, -0.39859125f, -0.17567478f, 
    0.01733890f, -0.10087921f, 0.31513298f, -0.12107871f, -0.09826296f, 0.09631336f, -0.10687466f, 0.19944718f, 
    0.21838740f, 0.09782086f, 0.15731426f, 0.02473144f, -0.34987921f, -0.16443346f, 0.05922888f, 0.04413938f, 
    -0.30375776f, -0.03462332f, 0.22946958f, 0.02572554f, -0.17066398f, -0.02777496f, -0.01126019f, 0.24657859f, 
    0.04363471f, -0.03692440f, -0.03681039f, -0.02273376f, 0.01530244f, 0.12849785f, 0.05408123f, -0.00134037f, 
    0.19208187f, -0.16172870f, -0.33014357f, -0.06591544f, 0.01551544f, 0.01419359f, 0.24698791f, -0.53504467f, 
    -0.07192653f, -0.22382623f, -0.06245745f, 0.22271797f, -0.01971135f, -0.10390866f, 0.01154389f, -2.12787342f, 
    -0.17822121f, -0.30265713f, 0.07704715f, -0.04795500f, -0.62002623f, 0.14757472f, -0.30313009f, -0.42982012f, 
    -0.03995514f, 0.15120849f, -0.07218929f, -0.97816467f, -0.22072025f, 0.13851056f, 0.00379203f, 0.02052072f, 
    -0.15046608f, -0.09103834f, 0.02393208f, -0.42355555f, -0.23744972f, -0.03203329f, -0.49919111f, 0.03402373f, 
    -0.02628335f, -0.18377072f, -0.13970298f, -1.10204756f, 0.07750951f, 0.05804030f, 0.23037262f, -0.13480151f, 
    0.03011836f, -0.54058129f, 0.02088387f, -0.03009360f, -1.04573262f, 0.17448542f, 0.08508252f, -0.02118177f, 
    0.05228508f, 0.08442906f, -0.06567488f, 0.08268891f, 0.16658519f, -0.06725065f, -0.07515998f, 0.09150597f, 
    0.16355154f, 0.04020305f, 0.04717378f, 0.08267622f, -0.04990374f, -0.01840075f, 0.02274248f, -0.09389483f, 
    -0.12698473f, -0.00798494f, -0.22532541f, -0.40888345f, 0.23299827f, 0.04107220f, 0.15631390f, 0.03807790f, 
    0.10684232f, -0.05206728f, 0.15266007f, -0.07086635f, -0.57170188f, -0.01469560f, -0.05294567f, -0.04191826f, 
    0.01484307f, 0.31479937f, 0.36246893f, -0.00866521f, -0.10764872f, 0.04032677f, -0.18989739f, -0.21553122f, 
    -0.16454518f, -0.09673628f, -0.53007394f, -0.11625413f, 0.15924159f, -0.65138233f, 0.08988482f, 0.06233948f, 
    0.07455024f, -0.00021418f, 0.18876226f, 0.30599877f, 0.01086505f, 0.03615582f, 0.15411478f, -0.06893361f, 
    -0.00897916f, -0.04450992f, 0.00891878f, -0.52438158f, 0.04291618f, -0.00212493f, 0.04188130f, -0.13263075f, 
    0.19854204f, -0.10290053f, 0.42217129f, -0.05882809f, 0.07739943f, -0.14860077f, 0.01631952f, -0.01162440f, 
    0.22380762f, -0.66407365f, -0.10396916f, -0.08096570f, -0.04447370f, 0.01558530f, -0.18415463f, 0.21981871f, 
    -0.08556680f, -0.06465636f, -0.03555782f, 0.09916583f, 0.01569061f, 0.04540145f, -0.11874668f, -0.49603701f, 
    0.00416376f, 0.20122622f, -0.11247602f, 0.12374450f, -0.13120782f, 0.19865121f, 0.14776762f, -0.03525595f, 
    -0.02497269f, -0.36954954f, 0.03384302f, -0.01736580f, -0.14373608f, 0.02807093f, -0.16014832f, 0.09967110f, 
    0.07410496f, -0.02829618f, -0.17888737f, -0.15962756f, 0.23741451f, -0.02612663f, 0.59566104f, 0.02811809f, 
    0.15475947f, 0.31158462f, 0.30894336f, 0.40308380f, -0.41880378f, 0.18484837f, 0.14819926f, 0.01472322f, 
    -0.30825570f, 0.48461822f, -0.21156842f, 0.12535702f, 0.64881009f, -0.16356780f, -0.02844646f, 0.11727659f, 
    0.11784504f, 0.19348316f, -0.64877689f, 0.07968921f, 0.17814676f, 0.13268407f, -0.02431147f, -0.27370122f, 
    -0.27407226f, 0.14444938f, -0.05504752f, -0.31950259f, 0.23080446f, 0.07748894f, 0.22415167f, 0.04131188f, 
    -0.06903272f, -0.43191284f, -0.58577335f, -0.98804945f, -0.43889052f, -0.05077267f, -0.51782292f, 0.00462778f, 
    0.00585925f, -0.00123399f, 0.06153041f, -1.02900410f, 0.02142493f, 0.12520023f, -0.09129474f, 0.03368159f, 
    -0.03959738f, -0.03780014f, 0.10337770f, 0.25378329f, -0.74349988f, 0.08332507f, -0.04615000f, 0.57160735f, 
    -0.04870385f, -0.35896039f, -0.42778668f, -0.08900575f, 0.38498792f, -0.48967046f, 0.12475244f, -0.08222394f, 
    0.02625589f, -0.10000231f, -0.01719186f, -0.22376734f, 0.12688985f, -0.50595158f, 0.02062691f, -0.08877666f, 
    0.05657044f, 0.04592013f, 0.16195740f, -0.11959632f, 0.08701076f, 0.11649005f, 0.06080692f, 0.12551564f, 
    -0.00131557f, 0.11554038f, -0.86846727f, -0.11339748f, 0.01910160f, 0.29879865f, -0.07889168f, 0.04576789f, 
    -0.30811226f, -0.18844384f, -0.26101366f, -0.05552498f, -0.44421187f, -0.08236690f, 0.02725185f, -0.14808151f, 
    0.02846526f, 0.05937847f, 0.06790960f, -0.00152655f, 0.02147163f, 0.08357418f, -0.05219569f, -0.25660637f, 
    0.04707500f, 0.06458001f, 0.19689199f, -0.13238777f, 0.06598560f, -0.10504945f, -0.30162594f, 0.14319347f, 
    0.02047886f, 0.13081120f, 0.06272056f, 0.08474134f, -0.34199962f, -0.54925889f, -0.07879618f, -0.08230078f, 
    0.12621558f, 0.04135179f, -0.01748281f, -0.74455994f, 0.09532713f, -0.51406008f, 0.28376967f, -0.69899797f, 
    -0.06246971f, 0.04712596f, 0.10054328f, -0.25383186f, -0.33161598f, 0.26615480f, -0.00646007f, -0.00644377f, 
    -0.16480555f, -0.95130700f, -0.02133139f, 0.01052127f, -0.39575946f, 0.04232404f, 0.05524284f, 0.04824850f, 
    0.19463988f, -0.54172605f, -0.92904830f, -0.74155712f, -0.07399317f, -0.10931715f, 0.01375199f, -0.22617450f, 
    0.12509751f, -0.03532715f, -0.06596418f, -0.18785733f, 0.03974000f, 0.09280300f, 0.03531920f, 0.02537989f, 
    0.14155561f, 0.03617190f, 0.46773061f, -0.24645856f, 0.06386354f, 0.00215640f, -0.95659447f, 0.12412249f, 
    0.12872924f, 0.15106919f, 0.07860196f, -0.41654873f, 0.13875544f, 0.12626672f, -0.89041036f, -0.05212914f, 
    0.13878049f, -0.09844452f, 0.07160258f, -0.25535083f, -0.50017321f, 0.03711439f, -0.78352743f, -0.69454312f, 
    0.16393204f, -0.09194370f, -0.62253225f, 0.06269304f, -0.99991226f, 0.03016796f, -0.03048123f, 0.24803609f, 
    0.08455501f, -0.01053002f, -0.28194782f, -0.92228574f, -0.07635503f, 0.00432111f, 0.27478987f, -0.08482476f, 
    -0.03682476f, -0.04067354f, -0.27026033f, -1.60167849f, 0.07370339f, 0.20582616f, 0.09828070f, -0.02189546f, 
    0.25041154f, 0.13742529f, -0.13502218f, 0.02998910f, 0.06022365f, 0.21584910f, 0.01855327f, 0.00144423f, 
    0.30254674f, -0.16280384f, -0.08506135f, 0.07640744f, -0.08187228f, -0.21062514f, 0.07928633f, -0.36428124f, 
    -0.00048084f, -0.10660164f, -0.05812892f, -0.59093928f, 0.13825259f, -0.11564229f, 0.06689458f, 0.08048613f, 
    0.12864973f, 0.09324436f, -0.05016695f, -0.66642499f, -0.02793385f, 0.28480759f, -0.06341609f, -0.03134145f, 
    0.09164128f, 0.15676594f, -0.60805720f, 0.07009795f, 0.14921132f, 0.32498300f, -0.37708080f, -0.02171066f, 
    0.07141890f, 0.09201793f, -0.57282692f, -0.87706786f, -0.41806382f, -0.18526928f, -0.39899868f, -0.23875505f, 
    -0.19969812f, -0.34426701f, 0.15398075f, 0.12163202f, 0.18597873f, -0.35844547f, -0.01907691f, -0.17352390f, 
    -0.06766243f, 0.31080130f, 0.22298120f, -0.36293408f, 0.47091898f, -0.46832973f, 0.05044034f, 0.07585713f, 
    -0.08356007f, -0.09267307f, 0.41463903f, 0.09194031f, 0.10075032f, 0.08617862f, -0.24450681f, -0.35291716f, 
    -0.07118408f, 0.09875418f, 0.04042328f, 0.21926655f, -0.07183977f, 0.12404055f, -0.21409908f, -0.46559471f, 
    -0.35409087f, -0.35088223f, 0.17893723f, 0.15976034f, -0.42241207f, -0.05330529f, 0.23672128f, -0.26536053f, 
    -0.12027913f, 0.03571829f, 0.18850003f, 0.38001946f, -0.93636072f, -0.40049767f, -0.07193423f, -0.11912811f, 
    0.08698837f, -0.07112598f, 0.10875589f, -0.42110407f, 0.23611796f, 0.00091894f, 0.72037560f, -1.29963827f, 
    -0.32710007f, 0.30079272f, 0.08751252f, -0.24452911f, 0.16837770f, 0.17039105f, -0.04188107f, 0.13469088f, 
    -0.11763223f, -0.61011028f, 0.22165713f, 0.03577130f, 0.06190161f, 0.29427332f, -0.12794331f, -0.02847046f, 
    -0.09352857f, -0.00541158f, -0.55852419f, 0.44502458f, 0.23368806f, -0.39912719f, 0.10225119f, -0.31870413f, 
    -0.37233678f, -0.41547933f, 0.00961400f, -0.54708236f, -0.05792783f, -0.19655870f, -0.07346343f, -0.04849873f, 
    -0.87989378f, -0.34508699f, -0.58871520f, -0.04285062f, 0.09170873f, -0.20455244f, -0.41469598f, 0.11698561f, 
    -0.07305200f, -0.19771400f, -0.06681255f, -0.03856770f, 0.01078672f, -0.06967955f, -0.06826288f, -0.14050376f, 
    0.01440165f, 0.27267674f, 0.31949008f, 0.17274919f, 0.16713461f, -0.59267825f, -0.06376766f, -0.14642815f, 
    -0.11114071f, -0.03425518f, 0.01113631f, 0.26619363f, -1.43274331f, -0.65850806f, -0.29737023f, 0.11786838f, 
    0.35649258f, -0.37425750f, 0.34447378f, 0.47348553f, 0.17892222f, 0.19369629f, 0.44925138f, -0.01237135f, 
    0.00891113f, 0.17966013f, -0.72312999f, 0.42429271f, 0.15237601f, -0.24496815f, 0.23600970f, 0.36498317f, 
    0.07842383f, 0.05839420f, -0.57403213f, 0.07906240f, -0.44060159f, -0.01536252f, 0.07956085f, -0.02122232f, 
    -0.07895046f, 0.47775063f, -0.28763968f, 0.04598630f, -0.35076228f, -0.18806225f, 0.06663165f, 0.06122271f, 
    -0.60400605f, -0.35727108f, 0.03083516f, -0.00144549f, -0.11785620f, -0.26539513f, 0.12575354f, 0.20352548f, 
    0.23200057f, -0.10520819f, -0.51608652f, 0.17043181f, -0.76705897f, 0.00795980f, -0.04796144f, -0.21468705f, 
    -0.63888842f, 0.11442398f, -0.98689735f, 0.37367827f, 0.03850695f, 0.04317666f, 0.26995817f, 0.04376094f, 
    0.33675542f, 0.13716659f, -0.18154642f, -0.18671858f, -0.31667429f, -0.05408806f, 0.00821094f, -0.31199422f, 
    -0.20742428f, -0.67627454f, -0.02520823f, -0.69916219f, 0.12404167f, -0.43700653f, 0.29133314f, -0.61930996f, 
    0.15467250f, -0.05383120f, -0.19639950f, -0.60313386f, 0.06977192f, -0.13536306f, -0.09407777f, -0.03450218f, 
    0.09409810f, -0.01767461f, 0.05823942f, 0.25367302f, -0.59356546f, -0.46324357f, -0.76681560f, -0.19957946f, 
    -0.65549636f, 0.27205414f, 0.36346686f, 0.18875499f, 0.03481364f, -0.11367978f, 0.02970834f, 0.04854997f, 
    -0.45983300f, 0.19489656f, -0.24448167f, -0.05357163f, -0.17945927f, 0.39745772f, 0.19683211f, 0.01442474f, 
    0.00793196f, 0.15822025f, -0.01253163f, -0.30693239f, 0.21007355f, 0.24208787f, 0.01265874f, -0.71925712f, 
    -0.75994509f, 0.08807305f, 0.24897644f, -0.10475022f, -0.10319509f, -0.43124971f, -0.25420323f, 0.16812344f, 
    0.03925891f, 0.19605429f, -0.69924659f, 0.10192548f, -0.02015737f, -0.41050434f, -0.20148958f, -1.01009595f, 
    0.08763616f, 0.06558159f, 0.15941007f, -0.08393431f, 0.07654431f, -0.21947852f, 0.48261288f, 0.20266140f, 
    0.05457836f, 0.39979154f, 0.29551631f, -0.05432591f, -0.51329690f, 0.02048428f, 0.24407424f, -0.07814928f, 
    0.15586300f, -0.23918696f, 0.08779102f, 0.16095614f, 0.22327423f, 0.06605827f, 0.08530699f, 0.17262654f, 
    -0.13223134f, -0.15458906f, 0.33522242f, 0.30365348f, 0.19974804f, 0.30839512f, 0.03981673f, 0.01890046f, 
    0.12776051f, 0.15768312f, -0.07876966f, -0.82315385f, 0.09969081f, -0.37781015f, 0.12183277f, 0.19671270f, 
    -0.10359780f, 0.01178287f, 0.42766055f, -0.24584284f, 0.19544464f, -0.05557343f, -0.41895142f, -0.32431388f, 
    0.09109798f, -0.14720422f, 0.13508201f, 0.18779241f, -0.53744733f, 0.16065486f, 0.18605223f, -0.06713837f, 
    -0.22521761f, -0.47944036f, -0.03931979f, -0.22243167f, -0.52276397f, -0.03443677f, -0.29213288f, 0.70663202f, 
    -0.08722641f, 0.12522487f, 0.17033336f, 0.05993738f, -0.00242085f, -0.28961790f, 0.15208854f, -0.12148484f, 
    -0.11345065f, 0.06564312f, -0.19739464f, -0.18827237f, 0.07410545f, -0.92407960f, -0.30642918f, -0.04638066f, 
    0.15395999f, -0.05893593f, -0.62631458f, -0.39469880f, 0.06414345f, 0.08189590f, 0.15297146f, -0.26710784f, 
    0.16213684f, -0.04547290f, 0.11653381f, 0.05103329f, -0.04024667f, -0.37464690f, -0.07149390f, -0.02745508f, 
    -0.04704721f, -0.78712445f, -0.04246253f, -0.02502367f, -0.31808755f, 0.09287754f, -0.21581794f, -0.36403990f, 
    -0.04673573f, 0.11784467f, -0.08804982f, -0.32958081f, 0.04705894f, 0.10183198f, -0.04171832f, 0.01278593f, 
    0.14876601f, 0.17015068f, -0.08660243f, -0.58992785f, 0.01729767f, -0.08421347f, -0.48748013f, 0.18347883f, 
    -0.37050599f, -0.33494827f, 0.00604760f, -0.03594394f, -0.00399947f, 0.08771803f, -0.11081342f, 0.06169842f, 
    0.00906897f, 0.07606184f, -0.81792778f, -0.13256757f, -0.00953435f, -0.43751365f, -0.53056908f, 0.06791544f, 
    0.08644070f, -0.03429731f, -0.39942956f, -0.30816782f, 0.11844567f, 0.20724948f, -0.13460042f, 0.00235990f, 
    0.10124002f, 0.10961045f, -0.11778233f, -0.06086273f, 0.04428187f, 0.37547490f, 0.00540429f, -0.52991998f, 
    -0.03442874f, 0.25803277f, -0.20231128f, 0.32366088f, 0.08130522f, 0.29297251f, -0.03651236f, 0.08831563f, 
    0.00557261f, -0.29047319f, 0.10560361f, 0.30555165f, -0.12200169f, -0.15755914f, -0.51556373f, 0.05196259f, 
    -0.13444515f, 0.10146070f, -0.29151300f, -0.08093563f, 0.01850414f, -0.05205474f, 0.93675762f, -0.05050694f, 
    -0.32957044f, 0.08156831f, -0.06690698f, -0.10695647f, -0.50488621f, -0.06754428f, -0.59741032f, -0.02420914f, 
    -0.03901302f, 0.01523967f, -0.12452748f, 0.50783354f, 0.08072474f, -0.03026713f, 0.07585909f, -0.07478675f, 
    0.20147125f, -0.40373001f, 0.32473895f, 0.21464911f, 0.19563554f, 0.40557259f, -0.40779030f, 0.07407103f, 
    0.35346103f, 0.14437136f, -0.21617085f, 0.10633156f, -0.23625518f, -0.33900741f, -0.08107536f, -0.06985244f, 
    -0.26402882f, 0.06626407f, 0.34972507f, 0.36435807f, -0.52872747f, -0.05193178f, -0.23607290f, -0.17783578f, 
    -0.31800407f, 0.07876018f, 0.02824759f, 0.05867024f, 0.07035256f, 0.06796978f, -0.03164791f, -0.04309019f, 
    -0.67107880f, 0.50626671f, -0.60216296f, -0.06369853f, 0.19621958f, 0.31620425f, 0.09044018f, 0.00327135f, 
    -0.08741464f, -0.14122012f, -0.06739955f, 0.04455962f, -0.46440014f, 0.30546731f, -0.07205414f, -0.72955829f, 
    -0.68919021f, -0.59488207f, -0.53512657f, 0.16904342f, -0.46509361f, 0.23106922f, 0.33467484f, -0.62590849f, 
    -0.11370193f, -0.04962321f, 0.16931443f, -0.47742590f, 0.09731787f, 0.26720428f, 0.33312285f, -0.11097050f, 
    -0.67539805f, -0.63977075f, -0.12641712f, 0.23619343f, -0.16220602f, 0.52508152f, -0.03753319f, -0.08222714f, 
    0.08302126f, 0.15999077f, -0.05185961f, -0.05908153f, -0.48096737f, -0.00936007f, -1.04816365f, -0.09286834f, 
    0.21845205f, 0.29729965f, -0.05779418f, 0.00177957f, -0.25814831f, 0.11555582f, -0.03684114f, -0.24615715f, 
    0.03564055f, -0.43897817f, -0.52903330f, -0.27559409f, -0.39527711f, -0.03157152f, -0.07156930f, 0.18846814f, 
    0.19599453f, -0.47255290f, -0.05300624f, 0.08646461f, -0.24000736f, -0.14027393f, -0.19292851f, 0.09937456f, 
    0.12997605f, 0.16320910f, -0.52336907f, 0.68397588f, 0.20403898f, -0.06330658f, -1.37725878f, -0.19452798f, 
    -0.10506605f, 0.11352367f, -0.14800681f, 0.43048969f, -0.42102739f, 0.14733173f, 0.12709849f, -0.04722461f, 
    0.14487034f, -0.11285850f, -0.48532706f, -0.05862303f, 0.15305088f, 0.04717674f, -0.16713151f, -1.22872508f, 
    -0.14456986f, -0.20854905f, 0.06974491f, -0.27073878f, -0.62221038f, 0.22260116f, -0.17477959f, 0.03934565f, 
    0.00397855f, 0.15546080f, -0.16409127f, -0.07129394f, -0.34747630f, 0.56120437f, 0.19328381f, -0.02193754f, 
    -0.12984914f, -0.06812496f, 0.21618095f, 0.37514347f, -0.40818864f, -0.02937653f, -0.13048844f, 0.27668166f, 
    0.07486290f, 0.12656088f, 0.00547874f, 0.08492556f, 0.08475080f, -0.02292545f, -0.05732995f, 0.01451614f, 
    0.52963084f, 0.34260792f, 0.30372360f, -0.07740206f, 0.05028700f, 0.05790734f, 0.15347022f, 0.33094615f, 
    -0.07478588f, -0.14063545f, -0.04506375f, -0.18234639f, 0.09828293f, -0.13367741f, -0.11371904f, -0.65908355f, 
    -0.06726325f, -0.04971429f, -0.36413193f, -0.52257979f, -0.31987241f, 0.11273044f, 0.20557986f, -0.07124558f, 
    -0.04140357f, -0.05440375f, -0.25967190f, 0.14607994f, 0.26406389f, 0.26740623f, -0.03266216f, -0.05422580f, 
    -0.20780988f, 0.09135480f, 0.15362512f, -0.02590632f, -0.27994025f, -0.41645110f, -0.66630387f, 0.38869232f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.03049382f, -0.03210418f, -0.23181711f, 0.09340811f, 0.26099980f, 0.23639457f, -0.04338211f, -0.60579288f, 
    -0.12181618f, 0.02794152f, 0.09972687f, -0.23474686f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
