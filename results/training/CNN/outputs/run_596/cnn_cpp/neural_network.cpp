#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.30413091f, -0.39516076f, 0.39292839f, -0.55482417f, -0.66120070f, 0.69244993f, 0.44303510f, 0.61369610f, 
    0.65527987f, 0.39730847f, -0.12616271f, 0.01218047f, -0.71132976f, 0.08714800f, 0.01152801f, 0.01900960f, 
    0.05627661f, 0.06511960f, -0.12597136f, 0.15586376f, -0.03349340f, 0.13496986f, 0.10508709f, -0.10311170f, 
    -0.20309475f, 0.91288555f, -0.09036513f, 0.98305577f, 0.12597869f, 1.04450083f, 0.55707175f, -0.12732342f, 
    -0.19385067f, -0.37860256f, -0.58095282f, 0.23870908f, 0.32571307f, -0.03766222f, 0.24099840f, 0.29086345f, 
    0.43455032f, 0.30072021f, 0.29185185f, 0.29860756f, 0.18621209f, 0.29220694f, 0.33337453f, 0.22730710f, 
    0.05099072f, 0.23854426f, 0.29249471f, 1.32234883f, 0.94715899f, 0.18863750f, 0.47826436f, 0.41060227f, 
    -0.52070498f, -0.26518887f, -0.79061013f, 0.24225622f, -0.26099899f, -0.28368497f, -0.18073237f, -0.22519979f, 
    0.07336377f, 0.17871660f, 0.17998007f, 0.08631594f, 0.29110235f, -0.05410527f, 0.46181270f, 0.08556281f, 
    -0.08225391f, 0.08850768f, 0.17750901f, 1.27466476f, -0.48410994f, 0.61728609f, 0.43254399f, 0.88492548f, 
    0.32898736f, 0.41052693f, 0.25805306f, 0.23002319f, 0.39144421f, -0.54795045f, -0.17346059f, -0.33247286f, 
    0.10243288f, -0.17599033f, -0.26874483f, -0.17648092f, 0.21127987f, 0.37491325f, -0.12015451f, -0.08561573f, 
    0.28443807f, -0.22676292f, -0.30522984f, 0.01536635f, 1.34520614f, 0.57353330f, 0.77851045f, 0.92961293f, 
    0.60377294f, -0.18383771f, 0.43538436f, -0.30114752f, -0.16296947f, 0.29579529f, 0.39297152f, 0.47659317f, 
    0.03694811f, 0.02610020f, -0.37619084f, -0.08478968f, -0.42079118f, -0.23558399f, 0.33325854f, -0.27376017f, 
    0.09672176f, 0.20557366f, 0.22989206f, 0.10346324f, -0.00544497f, -1.74665618f, 0.03319926f, 0.56365031f, 
    0.58724439f, -0.63213253f, 0.44152957f, 1.11241055f, -0.20804396f, 0.15444382f, 0.25660822f, -0.24530546f, 
    -0.14227423f, 0.21808784f, -0.11716229f, -0.09585459f, 0.01744661f, 0.07124991f, -0.15092175f, -0.06970412f, 
    0.17432663f, 0.23227419f, 0.40628117f, 0.12762029f, -0.07671399f, 0.14179495f, -0.78000796f, -0.48694670f, 
    -0.81583440f, 0.87394178f, 0.76081407f, 0.23106545f, 0.73211896f, -0.59972602f, 0.33982372f, -0.22402331f, 
    0.14733635f, 0.23644067f, -0.04529427f, -0.06892800f, 0.29928571f, 0.08968139f, 0.30022651f, 0.24638650f, 
    0.24605286f, -0.35129669f, 0.02332716f, 0.03861531f, -0.34133419f, 0.04962487f, 0.00349598f, -0.81717950f, 
    -0.76695037f, -0.46546409f, -0.10956209f, -0.61920214f, 0.56296247f, 1.11413324f, -0.02509724f, 0.12816864f, 
    0.68224633f, -0.49792835f, -0.40786758f, 0.05978877f, -0.50158811f, -0.26648602f, -0.40066284f, -0.28366071f, 
    0.43681863f, -0.16956452f, -0.22166185f, -0.03717425f, -0.22830102f, 0.19315310f, -0.16706756f, 0.00396219f, 
    0.69500363f, 0.28169614f, 1.08801341f, 0.75992358f, 0.16073067f, 0.62398416f, 0.03780695f, 0.21123430f, 
    0.50923449f, 0.13769157f, -0.54426283f, 0.36284733f, -0.06105403f, 0.24839978f, -0.45409277f, 0.09751247f, 
    -0.16552165f, -0.37001213f, -0.53811872f, -0.28322539f, -0.01830868f, -0.59888214f, -0.20828331f, -0.18374673f, 
    -0.46602276f, -0.95501024f, -0.98962444f, 0.89661700f, 0.75329536f, 0.18736406f, 0.95516211f, 0.67645681f, 
    0.16656809f, -0.01296620f, -0.83261746f, -0.24223246f, 0.25509453f, -0.15579414f, 0.59275508f, 0.40319297f, 
    -0.06339186f, 0.01989205f, -0.25741455f, -0.26179713f, -0.23294845f, -0.12541957f, 0.02305039f, 0.06687648f, 
    0.03757571f, 0.02967824f, 0.77006215f, -1.16035104f, -0.76962441f, -0.68289399f, 0.65960932f, 0.96041775f, 
    0.00414945f, 0.21171519f, 0.35665968f, -0.06767779f, -0.23182315f, 0.16312052f, -0.11664625f, 0.41139138f, 
    -0.10858763f, -0.01872785f, -0.31865907f, -0.12357026f, 0.09307881f, -0.06008064f, 0.20961800f, -0.04886112f, 
    0.14210808f, 0.07228512f, 0.24393667f, 0.07518490f, 0.40802965f, 1.15197706f, 1.08200979f, 0.10863245f, 
    -0.97754657f, 0.24197301f, -0.59076482f, -0.80657113f, -0.59376091f, 0.50829768f, 0.05782983f, -0.63773751f, 
    0.07767729f, 0.24859276f, -0.02953403f, -0.25878966f, -0.11905033f, -0.10389508f, 0.00134516f, 0.01590939f, 
    0.18852472f, 0.40337700f, 0.12842259f, -0.15846542f, 0.12553737f, 0.71376216f, -0.74419963f, -0.34768987f, 
    -0.56681406f, 0.53845900f, 0.74500531f, -1.00424862f, -0.05779474f, 0.32331991f, 0.09535807f, 0.14076075f, 
    -0.63638365f, -0.13802624f, -0.16484848f, 0.07251512f, -0.09467140f, -0.06212197f, 0.03076259f, -0.09486869f, 
    -0.09396978f, 0.12628101f, -0.09690099f, -0.12952933f, 0.30230236f, -0.59926528f, -0.49542975f, -0.37007421f, 
    -0.69410086f, -0.39007458f, -0.38812837f, 0.77297968f, -0.22883348f, 0.01081528f, -0.54497117f, -0.53260726f, 
    0.21949978f, -0.33991054f, 0.27537498f, 0.46457225f, 0.02427479f, 0.07946276f, 0.07641270f, 0.18493441f, 
    -0.22920881f, 0.44308949f, 0.40098339f, -0.42469081f, -0.24950761f, -0.13816759f, 0.79353303f, -0.16674539f, 
    -0.73221022f, 1.51832438f, 0.53133547f, 0.96537763f, 0.49198321f, -0.51782238f, -0.08705791f, -0.14710575f, 
    -0.31516793f, -0.24009046f, -0.02086384f, -0.17859198f, -0.17285666f, -0.26615554f, 0.06668526f, -0.00700840f, 
    -0.09753604f, -0.17443353f, 0.02392416f, -0.44862524f, 0.06005452f, -0.29259500f, -0.19525962f, -0.57900482f, 
    0.74447644f, 0.18350846f, -0.15786432f, 0.51228195f, -0.46997300f, 1.27591705f, 0.36393031f, -0.20883454f, 
    0.82805389f, -0.78998959f, 0.36107874f, 0.27178511f, -0.54429841f, 0.54030299f, 0.17547438f, -0.10446888f, 
    0.02799289f, 0.26026833f, -0.09913837f, -0.03805849f, 0.12217788f, 0.39372554f, 0.23311366f, 0.21030149f, 
    -0.36210236f, -1.28282535f, 0.23541634f, 1.01594913f, 0.13511325f, -1.03801179f, 0.31571150f, -0.44665515f, 
    -0.16165647f, 0.59947687f, 0.14635850f, 0.40013963f, 0.24565005f, 0.06782278f, -0.35406521f, -0.11593717f, 
    0.03447621f, 0.19532514f, 0.05381982f, 0.07153954f, -0.06890568f, -0.03585429f, -0.06823841f, 0.51317281f, 
    -0.10501820f, 1.38879716f, 0.68436825f, -0.72154373f, 1.08912277f, 0.33755499f, 0.03466689f, 0.10815648f, 
    0.10827558f, 0.79777229f, 0.29596904f, -0.18629639f, -0.00648586f, 0.26994660f, -0.30783141f, 0.04376721f, 
    -0.00763541f, -0.34190822f, -0.01464144f, -0.25925049f, 0.31534687f, 0.21311000f, -0.25183967f, 0.48671508f, 
    -0.00527936f, 0.15599702f, 0.50571722f, 0.27300960f, 0.02642970f, 0.93879175f, -0.91337889f, 0.25340152f, 
    -0.12691118f, 0.13457456f, 0.38823920f, 0.29902300f, -0.12348852f, 0.33670121f, 0.27533451f, -0.35271561f, 
    0.25704184f, 0.12404597f, -0.36317974f, 0.29578307f, 0.39808589f, 0.32717237f, 0.28140253f, 0.22425418f, 
    0.28134048f, -0.42190233f, -0.50985020f, -0.75606006f, -1.52834082f, -0.68975711f, -0.19765447f, 0.17854325f, 
    -0.16070144f, 0.62186527f, 0.61743784f, -0.38183862f, 0.46434215f, 0.13937995f, -0.30921364f, -0.15034725f, 
    -0.21185091f, 0.23993091f, -0.09412581f, -0.19422133f, -0.14463022f, -0.18473849f, -0.24849276f, 0.05210958f, 
    -0.10880214f, -0.22966705f, -0.01893451f, 0.10158684f, -0.57220691f, 0.13396022f, 0.28197634f, -1.05218124f, 
    -0.17514597f, 0.45248976f, -0.12647352f, -0.46378750f, -0.27343944f, -0.21037756f, -0.02447361f, 0.21799818f, 
    0.30058083f, 0.26400799f, -0.24047591f, -0.08174005f, 0.49180108f, 0.49034396f, 0.23086488f, -0.73749042f, 
    -0.19309005f, 0.06496748f, 0.18460770f, 0.23878571f, 0.42229137f, 0.94446379f, 0.39409527f, -0.05182696f, 
    1.10630322f, 0.84953403f, 0.05493798f, 0.52962428f, 0.56453639f, 0.51573706f, 0.24425641f, -0.21477437f, 
    0.03413183f, 0.52375543f, 0.11441758f, 0.12943999f, 0.23660423f, -0.05301797f, 0.07872074f, -0.30056763f, 
    -0.13090044f, 0.38278970f, -0.12558906f, -0.34088889f, 0.24790902f, 0.14845996f, -1.16896176f, 0.99753845f, 
    -0.44104898f, -0.63660264f, -0.86596632f, 0.98312610f, -0.37194902f, -0.11492229f, 0.49405292f, 0.68982744f, 
    -0.26098171f, -0.58699608f, -0.24968433f, 0.31945175f, 0.33031440f, 0.12596627f, 0.14765181f, -0.01589060f, 
    0.22964621f, 0.20362736f, 0.12441502f, -0.08489919f, 0.03919907f, 0.00346957f, 0.34338942f, -0.29204932f, 
    -0.83734071f, -0.24330013f, 0.06072341f, -0.52149332f, -0.49980792f, -0.23548312f, 0.26117420f, 0.39490169f, 
    -0.70474827f, 0.51399642f, -0.09420267f, -0.11970302f, -0.06305058f, -0.09901184f, 0.48334238f, 0.18843167f, 
    -0.04326305f, -0.58459610f, 0.55771059f, -0.20028573f, -0.21498732f, 0.04146155f, 0.16582303f, 0.51219326f, 
    -1.20930159f, 0.25755984f, 0.01496526f, 0.05907653f, 0.41307607f, 0.19610009f, 0.13894160f, 0.47678468f, 
    0.33282617f, 0.20446566f, -0.02513771f, 0.02152372f, -0.42668691f, -0.21008527f, -0.11698747f, -0.11300390f, 
    -0.23992737f, -0.34253588f, 0.12709163f, -0.06122391f, 0.64417422f, 0.84429014f, 0.31278828f, 0.39833716f, 
    -0.47551256f, 0.52992833f, -0.96019810f, -0.75065589f, 0.02125301f, -0.56548560f, -0.70770276f, 0.93760645f, 
    0.91483778f, 0.23436408f, 0.63960081f, -0.21347348f, 0.36012906f, -0.26577908f, -0.38451552f, 0.27683920f, 
    0.01588108f, 0.05637417f, -0.22668611f, 0.13156641f, -0.25778005f, 0.02947669f, -0.35509890f, 0.15786187f, 
    -0.30996791f, 0.07052536f, -0.11229099f, 0.68761384f, -0.31463337f, -1.11612499f, -0.47477475f, 0.79291868f, 
    -0.97714359f, -0.47766224f, -0.77195168f, -1.00713480f, -0.15458384f, 0.67306334f, 0.42222154f, 0.12940815f, 
    -0.27804914f, 0.01990044f, -0.26784673f, 0.01947086f, -0.23777132f, 0.32649714f, -0.03907610f, -0.13977930f, 
    0.32313600f, 0.36548948f, -0.09252097f, 0.41186249f, -0.04248325f, 0.35672450f, 1.16835189f, 1.01479614f, 
    0.00230955f, -0.68664765f, -0.69509888f, -0.23697725f, 0.33162323f, 0.47827265f, 0.11596796f, -0.22695738f, 
    0.38614455f, -0.17766184f, 0.19535843f, 0.09238899f, 0.37555847f, -0.21958508f, 0.41942173f, 0.18584661f, 
    -0.38331321f, 0.08145344f, -0.29252508f, -0.16124366f, -0.83472961f, 0.40947589f, 0.53740036f, -0.45337510f, 
    -0.33170214f, 0.68121308f, -0.93840909f, -0.67438757f, -0.69506234f, 0.15885326f, -0.30326456f, -0.07197027f, 
    -0.61411411f, 0.04319050f, -0.41703075f, -0.56858325f, -0.33981180f, 0.21939875f, -0.35775194f, -0.33361673f, 
    -0.10969345f, 0.17986995f, -0.12461773f, 0.00207302f, -0.08855169f, -0.59668463f, -0.84269691f, -0.75725526f, 
    -0.54783994f, -0.64270782f, -0.16811435f, -0.08394027f, 0.02755675f, 0.34013480f, 0.69760954f, 0.15486671f, 
    0.12754387f, -0.04860050f, 0.27241126f, -0.23276545f, -0.20129675f, 0.16205610f, 0.30552080f, 0.24507746f, 
    0.53022206f, 0.19899008f, 0.34247950f, -0.34066403f, 0.26194575f, 0.35283124f, -0.47385085f, -0.83913726f, 
    0.63397974f, 1.04676378f, -0.26271379f, -0.04445785f, -0.11792858f, 0.55904716f, -0.21178018f, -0.66867381f, 
    0.36709780f, -0.28835139f, -0.00149022f, 0.35693794f, 0.30925831f, -0.03760507f, 0.72740799f, 0.58306384f, 
    0.02165425f, 0.04112598f, 0.05688975f, -0.21854572f, -0.37157232f, 0.02837781f, -0.17227134f, -1.09178901f, 
    -0.78878117f, 0.11708685f, -0.54950249f, -0.41867232f, -0.28942090f, -0.16058938f, 0.89809823f, -0.49255547f, 
    -0.11255419f, 0.42970493f, 0.54446810f, 0.49247217f, 0.40235001f, 0.02859188f, -0.64276767f, 0.06126538f, 
    -0.35794640f, -0.77408665f, -0.11088774f, 0.05253418f, -0.06765793f, 0.09664575f, 0.31654954f, -0.17617652f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.29048118f, 0.14559612f, 0.16381897f, 0.05769699f, 0.19972380f, 0.06893034f, 0.13576493f, 0.05987334f, 
    0.20482980f, 0.35916221f, 0.37942100f, 0.38705105f, 0.11256251f, 0.31680244f, 0.28797761f, 0.18834272f, 
    0.33162573f, 0.18870042f, 0.16124967f, 0.22737187f, 0.01300267f, 0.14597525f, -0.02752702f, 0.23192519f, 
    0.25289527f, 0.03560979f, 0.61602265f, 0.13725366f, -0.01742617f, 0.26168481f, 0.28884494f, 0.23965770f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18075903f, -0.02874848f, 0.00940729f, -0.22126247f, -0.07238321f, -0.04363088f, -0.10699356f, -0.01564033f, 
    -0.18449488f, 0.01396482f, 0.01029948f, 0.01220192f, 0.16615519f, -0.08181843f, -0.07773137f, -0.25163025f, 
    -0.23183991f, 0.08795688f, 0.02565362f, -0.03765239f, 0.01780512f, 0.02474313f, 0.12568215f, -0.06067796f, 
    -0.11392391f, 0.17501843f, 0.05224798f, -0.09730027f, -0.11394498f, -0.24552581f, 0.07372055f, -0.06901609f, 
    0.06519689f, -0.10328554f, -0.21371913f, -0.02172035f, 0.34416896f, -0.25680646f, -0.05586466f, 0.12963045f, 
    -0.14558880f, -0.03035307f, 0.12692355f, 0.04961488f, -0.15275881f, 0.06526434f, -0.18500766f, -0.03545206f, 
    0.32598233f, -0.00343093f, -0.02851871f, 0.13803519f, -0.16590545f, -0.15254442f, -0.07132249f, 0.17135704f, 
    -0.10194608f, 0.06272963f, 0.00610114f, -0.09065510f, 0.55846560f, 0.30292478f, 0.33747083f, 0.17956743f, 
    -0.08870168f, -0.02236445f, -0.03378863f, -0.10647465f, 0.08943613f, -0.06727858f, -0.05949050f, -0.04290055f, 
    -0.21396111f, 0.15855889f, 0.18885785f, 0.08658162f, 0.04966271f, -0.06469394f, -0.03453696f, -0.06163873f, 
    0.05457961f, -0.01237953f, -0.05347379f, 0.14564469f, 0.48236269f, 0.20689836f, 0.15443400f, -0.16175820f, 
    0.09864955f, -0.01383309f, 0.11498597f, 0.13706490f, 0.03278692f, -0.06790408f, -0.05359899f, 0.00790488f, 
    0.16269130f, -0.03704293f, -0.34403488f, 0.24267635f, -0.03122110f, -0.03944809f, 0.18139297f, 0.07982378f, 
    0.00579388f, 0.05615294f, -0.06771565f, -0.08946948f, -0.50571692f, 0.17036135f, 0.09224238f, 0.24504912f, 
    -0.03363737f, 0.06355803f, 0.09011253f, 0.05996817f, 0.01153099f, -0.02299874f, 0.07476369f, -0.09279703f, 
    0.11892335f, -0.02268449f, 0.01856029f, -0.26745045f, 0.09529614f, -0.14013119f, 0.02983572f, -0.00447180f, 
    0.00683647f, -0.01185997f, 0.03891641f, -0.02540641f, 0.09525657f, 0.14617907f, -0.28056362f, 0.18992347f, 
    -0.06134169f, -0.01372470f, -0.01501921f, -0.14523675f, -0.06961480f, -0.01015567f, 0.01426412f, -0.05923599f, 
    0.38408658f, 0.00398532f, 0.22797315f, -0.28932196f, -0.15512863f, 0.03833703f, 0.16142701f, -0.01918649f, 
    0.00438553f, 0.09613227f, 0.00391981f, 0.05492559f, -0.32911432f, -0.03563944f, 0.13992101f, -0.08473054f, 
    0.02789040f, 0.05440975f, -0.01813248f, 0.10245403f, -0.01455563f, -0.02933408f, -0.00996216f, 0.01186435f, 
    0.00985849f, -0.06295072f, -0.03008660f, 0.52737045f, -0.13797945f, 0.00990592f, -0.18196259f, 0.00164760f, 
    -0.02981703f, 0.10277773f, -0.17676781f, -0.00536887f, -0.05314839f, -0.04018529f, 0.02283328f, -0.16315195f, 
    0.03955632f, -0.13811801f, 0.00187175f, -0.13635211f, 0.03402997f, -0.07062958f, 0.00464967f, 0.15901677f, 
    0.01078175f, -0.19422881f, -0.46047068f, 0.37300307f, -0.06333253f, -0.11596980f, -0.01464631f, 0.01581842f, 
    0.01421118f, -0.07586743f, -0.05133190f, 0.02004282f, 0.17097455f, 0.10898609f, -0.12537241f, 0.22795901f, 
    -0.26560095f, 0.13406679f, -0.01717917f, 0.08627433f, -0.12914607f, 0.05317759f, -0.00681676f, -0.05518309f, 
    -0.12864003f, 0.11805591f, -0.39306501f, 0.09689140f, -0.00169040f, 0.11237280f, -0.09426043f, -0.13481130f, 
    -0.06203766f, -0.06103204f, 0.09170800f, -0.02642994f, -0.29444507f, 0.12430246f, -0.07642857f, -0.30769148f, 
    0.11738753f, -0.02315579f, -0.07382331f, 0.01364477f, -0.02419025f, -0.05099959f, -0.11264949f, 0.04004629f, 
    -0.21558832f, -0.09379140f, 0.18909942f, -0.34915376f, -0.04446983f, -0.03795640f, 0.02262834f, -0.07719115f, 
    0.17958507f, 0.08196922f, -0.07556252f, -0.07004665f, -0.00421989f, 0.09017224f, -0.22125615f, 0.27334383f, 
    -0.06805576f, 0.05072037f, 0.18121387f, -0.02419890f, -0.07882576f, 0.05332410f, 0.21019763f, 0.03839867f, 
    0.79000151f, 0.00397061f, -0.30820018f, -0.09533641f, 0.06222066f, 0.02391420f, 0.08142205f, -0.00740473f, 
    0.13388157f, -0.04560696f, 0.00384028f, 0.08896041f, -0.05081935f, -0.13252515f, -0.23787397f, 0.08480555f, 
    -0.11024404f, 0.10790968f, -0.03281127f, -0.07087012f, 0.06857041f, 0.08842878f, -0.12607454f, -0.09827130f, 
    -0.00436837f, -0.00356673f, 0.14382964f, 0.09712182f, 0.07297299f, 0.08303920f, -0.00944356f, -0.15318747f, 
    -0.10546160f, -0.10845370f, -0.05270686f, -0.00550546f, -0.23225150f, -0.22761768f, -0.14607200f, -0.16802500f, 
    0.14500330f, -0.07581114f, 0.14785606f, -0.20386225f, 0.07979566f, -0.03368714f, 0.09912205f, -0.00119975f, 
    -0.57718796f, 0.09289001f, 0.21573468f, -0.16710995f, -0.08884664f, 0.05490468f, 0.04992151f, -0.11029054f, 
    -0.10262707f, -0.17899942f, -0.20750004f, -0.02017358f, 0.19949935f, -0.14990741f, 0.01149414f, 0.27740824f, 
    -0.19413455f, 0.02996275f, -0.00595344f, -0.10024589f, 0.13685030f, 0.01517406f, -0.16514082f, -0.11873292f, 
    -0.47951832f, 0.15357171f, 0.17225868f, 0.04742800f, -0.06747542f, -0.01677960f, 0.11195952f, -0.18339638f, 
    -0.13871795f, 0.17731011f, 0.02897459f, -0.01968521f, -0.12074967f, -0.26270986f, -0.33330268f, -0.34205264f, 
    0.06729700f, -0.09931463f, 0.13208026f, 0.14896536f, -0.09395258f, -0.11051167f, -0.10127560f, 0.00828256f, 
    -0.16647342f, 0.05168105f, -0.28272736f, 0.31128842f, 0.06175476f, 0.10415103f, 0.17078428f, 0.01059287f, 
    0.03749981f, -0.09810378f, -0.01265849f, -0.03607841f, -0.48499322f, -0.09263513f, -0.10361706f, 0.09433178f, 
    -0.07404307f, 0.13770644f, -0.17646049f, -0.14355524f, 0.01949564f, 0.07096493f, 0.09218056f, -0.00266925f, 
    0.40417519f, -0.14838427f, 0.08071877f, -0.11073250f, 0.11040886f, -0.13189316f, 0.04775107f, -0.04627297f, 
    -0.01761038f, 0.06683173f, 0.04736191f, -0.16851199f, -0.01366573f, 0.01945669f, 0.16032581f, 0.04110367f, 
    -0.12624507f, -0.06868207f, -0.02861365f, 0.03241345f, 0.14857736f, -0.03260045f, -0.03509005f, 0.08447209f, 
    0.39068913f, 0.01723997f, -0.00237380f, 0.03686624f, -0.21829690f, 0.03206602f, 0.11249281f, -0.04589762f, 
    0.00614940f, -0.02525449f, 0.11656706f, 0.11279386f, 0.52756482f, -0.17143047f, 0.05232479f, 0.13617171f, 
    0.03561316f, 0.01692689f, -0.07392015f, 0.01997999f, 0.14041123f, -0.03233075f, 0.03365012f, -0.08572195f, 
    0.22346403f, -0.04964924f, 0.23333792f, 0.37939554f, -0.07670899f, 0.07645452f, 0.05112715f, -0.02656644f, 
    0.07927801f, 0.03755616f, -0.06656619f, 0.02759419f, -0.64963579f, -0.10912608f, -0.18407904f, 0.01868559f, 
    0.07492480f, -0.04251600f, 0.07409484f, -0.02274625f, 0.00732140f, 0.16844456f, 0.01140745f, -0.03030688f, 
    0.26666358f, 0.03333879f, -0.34062317f, -0.03327407f, 0.13220032f, 0.10231716f, -0.15627231f, 0.09235854f, 
    -0.13381441f, -0.02735815f, 0.06323588f, 0.01736442f, -0.01715563f, -0.13297135f, -0.18341601f, -0.04410769f, 
    0.02321574f, -0.07717571f, -0.12641299f, -0.04283346f, 0.02199712f, -0.01205874f, -0.02322808f, -0.02695002f, 
    0.24617513f, 0.18987060f, 0.10938380f, 0.13588606f, -0.23661251f, -0.02525355f, 0.03781175f, -0.05828152f, 
    0.06195401f, -0.37355176f, 0.02377427f, -0.14457527f, 0.08829658f, 0.14926477f, -0.15085149f, 0.08906815f, 
    -0.18032408f, 0.06737595f, 0.04761918f, -0.06597710f, -0.16488756f, 0.10127871f, 0.00659309f, 0.12108082f, 
    0.39576274f, -0.56706464f, 0.18645859f, -0.31281465f, 0.02468581f, 0.08052740f, -0.09966091f, 0.07560816f, 
    -0.09049668f, 0.01772824f, -0.06987718f, 0.10943788f, -0.22785388f, -0.13902886f, -0.00224378f, 0.15318953f, 
    -0.12940814f, 0.02020307f, 0.05731971f, 0.03662847f, 0.05458041f, -0.10103373f, -0.04281665f, 0.02826942f, 
    -0.23317343f, -0.13113499f, -0.35625625f, -0.36550379f, -0.02472311f, -0.18977083f, -0.01190438f, -0.15614292f, 
    0.04097891f, -0.03370678f, -0.02684567f, -0.14449078f, 0.03044800f, -0.00710937f, -0.14855668f, 0.01599745f, 
    -0.08257081f, -0.05886541f, -0.04278894f, -0.08971352f, 0.06351984f, 0.12610364f, -0.18253656f, -0.13000667f, 
    0.08124715f, -0.49637470f, -0.16999874f, 0.08101067f, 0.10663572f, 0.10256381f, -0.07727316f, 0.03646115f, 
    -0.03149645f, 0.08535805f, 0.10247289f, -0.11265203f, -0.03113344f, 0.27443439f, 0.04763767f, -0.18455087f, 
    0.18704766f, 0.09161231f, -0.11381409f, 0.00489883f, 0.13282301f, -0.00385133f, 0.08813494f, -0.13085407f, 
    -0.28023708f, -0.06970554f, -0.14416790f, 0.13252577f, -0.11846044f, -0.00372494f, -0.02651579f, -0.04467250f, 
    -0.02926935f, -0.11556947f, 0.05063742f, 0.02911950f, 0.33651134f, -0.13700718f, 0.16520502f, 0.29305652f, 
    -0.06949324f, -0.09634745f, -0.00828046f, 0.09816742f, -0.12647897f, 0.08020267f, -0.10285565f, 0.18889229f, 
    -0.05046372f, -0.08742986f, 0.05254364f, 0.23346396f, 0.08194409f, -0.19307314f, 0.02216323f, 0.00902874f, 
    0.00936074f, 0.02588010f, 0.02121790f, 0.15544440f, 0.47009486f, 0.01782867f, -0.02559702f, 0.08270517f, 
    0.00221462f, 0.00924063f, -0.06194591f, 0.05525308f, 0.10879511f, -0.04275507f, -0.17746750f, 0.05245347f, 
    -0.06831061f, 0.04545422f, -0.10052282f, -0.05009902f, -0.08227158f, -0.10265434f, 0.08898467f, 0.06398672f, 
    0.04130479f, -0.10729577f, 0.06402619f, -0.06843168f, 0.21304236f, 0.04787290f, 0.05202000f, 0.23452675f, 
    -0.09664470f, 0.11700138f, -0.30290356f, -0.01291518f, -0.01403942f, -0.01074612f, -0.08648925f, -0.05862286f, 
    -0.82662535f, -0.11560516f, 0.21684083f, -0.33428076f, 0.04846773f, -0.06679011f, 0.08441713f, 0.02952012f, 
    0.11775310f, 0.15036230f, -0.08495203f, -0.15930177f, -0.11924654f, 0.07500879f, -0.03763083f, 0.05338401f, 
    -0.07062207f, 0.00233625f, -0.05111305f, 0.18260644f, -0.10214815f, -0.04476579f, 0.09427699f, 0.21922641f, 
    -0.14189997f, 0.15681955f, -0.16542716f, -0.01288117f, 0.17825373f, 0.04816463f, -0.04173333f, -0.00960995f, 
    0.27733830f, 0.07824853f, -0.03004420f, -0.02737904f, 0.30201101f, -0.26898360f, 0.07558005f, -0.17267188f, 
    -0.04997038f, 0.08350366f, -0.16076490f, 0.06397008f, -0.13045353f, 0.07533168f, -0.07045536f, 0.00264694f, 
    -0.16325347f, -0.34825966f, -0.07381150f, -0.42664561f, -0.08018661f, -0.06057524f, 0.13149154f, -0.06769810f, 
    0.04993605f, 0.18128063f, 0.13421237f, -0.14067703f, -0.03219656f, -0.13894339f, 0.09205130f, -0.00728387f, 
    0.05161941f, -0.05975581f, -0.07531931f, -0.01151858f, -0.06068072f, -0.03929241f, 0.08496068f, -0.00303583f, 
    0.02268655f, -0.08165730f, -0.36058876f, -0.26407880f, -0.00874867f, -0.01643022f, -0.04606206f, -0.04975966f, 
    -0.06268785f, -0.04001443f, -0.13973548f, -0.32683480f, 0.07862278f, -0.03362153f, -0.00157243f, -0.10461528f, 
    0.04609364f, 0.04898631f, 0.01723368f, 0.11473943f, 0.08561588f, 0.06334887f, 0.11895919f, 0.07433469f, 
    -0.47087982f, 0.22576495f, -0.13696527f, 0.22848883f, 0.07309548f, -0.03672029f, -0.15829654f, -0.13823453f, 
    0.03963474f, -0.02558086f, 0.04699765f, 0.10268611f, 0.05512703f, 0.08263903f, -0.02920871f, 0.07763495f, 
    -0.03527754f, -0.02075079f, -0.01511663f, 0.15393345f, 0.06215740f, -0.26544979f, -0.06729264f, -0.16346402f, 
    -0.12185605f, 0.10660992f, 0.07511850f, 0.06637780f, -0.05966049f, -0.18020013f, 0.11314859f, 0.10713750f, 
    -0.07484823f, -0.14783582f, 0.08581728f, -0.00784075f, -0.14376059f, -0.05382363f, -0.00389864f, -0.04657223f, 
    0.20678936f, 0.02401752f, -0.04915552f, -0.13523987f, -0.00817777f, -0.24027100f, -0.08333115f, 0.02497670f, 
    -0.02403236f, -0.27011520f, -0.08073408f, 0.00536838f, 0.05083444f, -0.03534636f, 0.08877334f, -0.09344529f, 
    -0.00689701f, 0.12675758f, -0.12317105f, -0.07794998f, -0.44780248f, 0.13672552f, 0.08900050f, -0.20051278f, 
    0.18030854f, 0.11647578f, 0.09151729f, 0.18654542f, -0.00780308f, -0.04031333f, -0.06374299f, 0.06477788f, 
    0.03090750f, 0.24482715f, 0.01769515f, 0.00613485f, 0.06021964f, 0.14170951f, 0.02340754f, 0.01502833f, 
    -0.09033153f, 0.07879312f, 0.09287324f, -0.09833670f, 0.48988006f, -0.11146319f, 0.02929883f, -0.16035318f, 
    -0.09065686f, -0.03816598f, -0.04089491f, 0.09757616f, -0.05999671f, 0.08713967f, 0.06195663f, -0.08054160f, 
    0.26146194f, -0.43555725f, 0.19435708f, -0.16452923f, -0.05407997f, -0.00032517f, -0.05849246f, 0.02178340f, 
    0.04053501f, -0.03300880f, -0.08964349f, -0.04407760f, 0.34953231f, -0.06631162f, 0.17582607f, 0.16311018f, 
    -0.07781991f, -0.13986795f, -0.03949306f, 0.11609067f, -0.05459507f, 0.05187649f, 0.07553056f, 0.07452537f, 
    -0.13589565f, -0.01923200f, -0.13456537f, 0.01296844f, 0.12455872f, 0.07341156f, 0.05010571f, -0.00130693f, 
    -0.00193229f, 0.22860198f, -0.00701063f, -0.16938993f, 0.39270890f, -0.20283918f, -0.10672866f, -0.12765619f, 
    -0.21728653f, 0.05137299f, -0.09744283f, -0.04333876f, 0.19723305f, 0.02244333f, -0.16581321f, -0.05445114f, 
    -0.42193741f, 0.03539734f, 0.06502120f, 0.11185849f, -0.03900719f, 0.06191241f, 0.00226567f, 0.04593479f, 
    -0.16574247f, -0.10988339f, -0.19460338f, 0.03221414f, 0.21204498f, 0.16995108f, -0.38720793f, -0.06426533f, 
    0.08378711f, 0.07121604f, -0.20753749f, -0.07437004f, 0.00339969f, -0.03131000f, -0.02949860f, -0.07672549f, 
    0.25631213f, -0.32926154f, 0.07311879f, -0.30786428f, -0.02537658f, 0.00215767f, 0.01053112f, -0.09048571f, 
    -0.05390221f, -0.16072266f, 0.06407332f, 0.02665715f, 0.08077461f, 0.14505462f, -0.21598935f, -0.26349494f, 
    -0.28534344f, -0.09385294f, 0.03171391f, 0.10087339f, 0.03488612f, -0.10247669f, -0.11929964f, -0.02278588f, 
    -0.20420021f, -0.54975557f, -0.02693267f, -0.22405265f, 0.08380424f, 0.05662683f, -0.11813820f, 0.09335566f, 
    0.08042010f, -0.07487977f, -0.08243717f, 0.09064770f, 0.30793029f, -0.12933964f, -0.08936010f, -0.04426133f, 
    -0.08352935f, 0.03474165f, -0.09889862f, 0.04062160f, 0.00557583f, 0.06638576f, 0.05247214f, -0.03697101f, 
    0.57805818f, -0.20824499f, -0.15485287f, -0.07435079f, -0.26351860f, 0.13712335f, -0.05421444f, -0.03291116f, 
    -0.04146340f, 0.09178951f, -0.01539762f, -0.14973937f, 0.39025974f, -0.05753470f, -0.16410445f, -0.04267780f, 
    0.02798760f, -0.04752768f, 0.10128318f, -0.02317830f, -0.10769915f, 0.04152070f, 0.08296776f, 0.00572375f, 
    -0.15348905f, -0.00050048f, 0.15345219f, -0.13186803f, -0.15458012f, 0.10814665f, -0.02564886f, -0.02974044f, 
    -0.01957715f, -0.25079641f, 0.00426757f, -0.04194359f, 0.35838640f, 0.00529013f, 0.00995412f, 0.29120040f, 
    -0.17442921f, -0.02984392f, -0.02179362f, 0.06205327f, 0.09467401f, 0.08412687f, 0.04136449f, 0.00220063f, 
    -0.10360739f, -0.11223844f, -0.13736756f, -0.21075226f, -0.00732867f, -0.14038603f, -0.07488857f, -0.04888776f, 
    -0.16653511f, 0.12753798f, -0.01389026f, -0.02502153f, 0.02174216f, 0.05194357f, -0.02656130f, 0.00056079f, 
    0.16803233f, 0.01979055f, 0.06395309f, -0.04910127f, -0.09041720f, -0.06099225f, 0.08593920f, -0.03217839f, 
    0.20830128f, 0.35219124f, 0.00136116f, 0.04956143f, 0.01881768f, -0.02782956f, 0.09044095f, 0.05444473f, 
    -0.09140950f, 0.02081404f, 0.07151462f, 0.01141439f, -0.04514621f, -0.20790200f, -0.18276247f, -0.08242445f, 
    -0.05608697f, -0.08404706f, -0.08444478f, 0.05161580f, -0.01326183f, 0.04500240f, 0.00033833f, -0.16137850f, 
    0.31528395f, -0.05960309f, -0.01489250f, 0.09949102f, -0.22217138f, 0.13114516f, -0.09829543f, -0.13588022f, 
    0.03287962f, -0.06550683f, 0.06228803f, 0.05967265f, 0.41276357f, 0.00477440f, 0.04123003f, 0.29777312f, 
    -0.20496464f, -0.17996728f, 0.19158727f, 0.18158178f, -0.00575329f, 0.02848929f, 0.05698942f, 0.04242397f, 
    -0.65938050f, -0.04999854f, -0.01898028f, -0.50845838f, 0.08617022f, 0.04181063f, -0.01964784f, -0.00650136f, 
    -0.12165641f, 0.06620508f, -0.10735416f, -0.15148228f, 0.13460028f, -0.27544791f, -0.23570000f, 0.23732997f, 
    0.10111755f, 0.07561701f, -0.03320830f, -0.07654206f, -0.12550448f, -0.05492757f, 0.03937921f, 0.04521740f, 
    0.03104728f, -0.10882112f, -0.24495342f, -0.47120860f, -0.02286799f, -0.04335554f, 0.00305452f, -0.00964728f, 
    0.06398439f, 0.07973012f, -0.01474112f, 0.02918117f, 0.05070657f, 0.01833065f, 0.19281137f, 0.14770864f, 
    -0.10227651f, -0.16362604f, -0.07776844f, 0.03308307f, -0.04202192f, -0.05594509f, -0.03300102f, -0.04139335f, 
    0.22152640f, -0.01214916f, -0.19021155f, 0.10989914f, -0.18486711f, 0.17281635f, -0.10573772f, 0.04723273f, 
    0.11595126f, -0.18093257f, -0.01099891f, -0.03661570f, 0.23851800f, 0.16174020f, -0.07281969f, -0.15908948f, 
    -0.10602836f, 0.08902355f, -0.14032151f, 0.03659291f, 0.06079246f, -0.02608467f, 0.00013451f, -0.16858858f, 
    -0.33836034f, -0.28739619f, -0.31095830f, -0.04212829f, -0.06602275f, 0.07787312f, -0.08258366f, 0.20075026f, 
    -0.05076378f, 0.15486647f, -0.05755194f, -0.08011952f, -0.53556234f, -0.34490722f, 0.11812777f, 0.18572050f, 
    0.02703858f, 0.07997126f, -0.04532055f, 0.04772722f, -0.09413135f, -0.26894569f, -0.06283049f, -0.06071535f, 
    0.20231090f, -0.52370751f, -0.29819649f, 0.36475572f, -0.16219264f, -0.02185427f, 0.07768633f, 0.03000690f, 
    0.05950241f, -0.14670964f, 0.04308232f, 0.07684776f, -0.55480772f, -0.16299251f, -0.10719886f, -0.18721625f, 
    -0.12559338f, 0.02108078f, 0.01846410f, -0.16883646f, -0.06787167f, 0.01688832f, 0.06143333f, 0.02958982f, 
    -0.61777896f, -0.55855954f, -0.10410614f, 0.06317835f, -0.14313689f, 0.06083169f, -0.04215775f, 0.05133329f, 
    -0.02501728f, 0.06977122f, 0.01702292f, 0.00662883f, -0.40060532f, 0.26837236f, 0.11790637f, 0.07108374f, 
    0.06014160f, -0.13862810f, -0.07306524f, 0.23348947f, 0.03858146f, -0.16704240f, 0.03410089f, 0.01301816f, 
    -0.04655115f, 0.06932258f, -0.17622890f, -0.04962031f, 0.02565775f, -0.10464264f, 0.19348131f, 0.04413404f, 
    0.01132193f, -0.05590867f, 0.00696264f, -0.10226636f, -0.27970362f, -0.08057031f, -0.00277357f, -0.22972980f, 
    -0.07803030f, -0.02095746f, 0.07670626f, 0.04183769f, 0.02842908f, -0.05939055f, -0.01985900f, -0.07868340f, 
    -0.15198570f, -0.48060334f, -0.36127135f, -0.02167108f, -0.09994573f, -0.13578606f, 0.14720851f, 0.03897386f, 
    0.10341195f, 0.12729287f, -0.11988998f, 0.18909085f, -0.05923196f, -0.06308836f, -0.00425091f, 0.13105285f, 
    0.02642155f, -0.07994922f, -0.07339723f, 0.06172182f, -0.08347980f, -0.03676511f, 0.01544170f, 0.02242427f, 
    0.00038592f, 0.13319077f, -0.28271115f, 0.17727914f, -0.02739077f, 0.11029477f, 0.08492425f, -0.06131324f, 
    -0.06488013f, -0.00004203f, 0.15961386f, -0.06941361f, -0.74904388f, 0.10200932f, 0.06677312f, 0.13198861f, 
    0.04861598f, 0.01544428f, -0.21048661f, 0.06242979f, -0.00769420f, -0.07424404f, 0.05807533f, -0.10177612f, 
    0.16971400f, 0.03723609f, 0.02022004f, 0.05423125f, -0.13630949f, 0.15670303f, -0.00868354f, -0.02911886f, 
    -0.06618702f, -0.05136883f, -0.01818503f, 0.04929771f, 0.00209893f, 0.21758020f, 0.03124701f, 0.05398198f, 
    -0.09944499f, -0.04491882f, 0.09149124f, -0.02978058f, -0.09725198f, 0.02374432f, 0.05423814f, 0.27111143f, 
    0.29510826f, -0.41743919f, 0.08792628f, 0.25703904f, 0.05804773f, 0.10131935f, 0.20395765f, 0.07898648f, 
    0.11038025f, -0.04782536f, 0.08340073f, 0.06755491f, -0.86862880f, 0.22448555f, -0.03857335f, -0.03287434f, 
    0.10168284f, -0.05030470f, -0.09799062f, 0.10606442f, 0.04082667f, -0.08833579f, -0.19514163f, 0.14952955f, 
    -0.27507216f, 0.15186390f, 0.19404648f, 0.16868183f, 0.11911821f, 0.00642384f, -0.03503831f, -0.05470276f, 
    -0.06645524f, 0.08931115f, -0.18480252f, 0.08472145f, 0.36095220f, -0.06393371f, -0.29255894f, -0.28621319f, 
    -0.05872634f, -0.03442020f, 0.11001902f, -0.04758610f, 0.05382404f, -0.09360440f, -0.08888321f, -0.07760750f, 
    0.09031521f, -0.13781022f, -0.15856062f, -0.10037681f, 0.00797761f, 0.04648964f, -0.18929510f, -0.01330121f, 
    0.09134519f, 0.01704006f, -0.15186870f, 0.10581374f, 0.27477714f, -0.17694482f, 0.09333134f, 0.10989323f, 
    -0.01518025f, -0.09652693f, 0.04043401f, 0.04152795f, 0.00512675f, 0.12849706f, 0.08836426f, -0.03857894f, 
    0.29461765f, -0.02527214f, 0.17891276f, -0.23243158f, -0.02389798f, -0.12633757f, -0.03791612f, 0.12022528f, 
    0.01943220f, 0.07115416f, -0.14777347f, 0.02353221f, -0.31263062f, -0.38838470f, -0.16798447f, -0.23616804f, 
    -0.10405532f, -0.20930716f, 0.12049647f, -0.15451972f, -0.13612229f, -0.05089561f, 0.08220673f, -0.08200485f, 
    0.07508472f, 0.35584027f, -0.07610478f, -0.28895172f, 0.07006177f, -0.01930451f, 0.02353277f, 0.12268478f, 
    -0.06603774f, -0.09063632f, -0.04078681f, 0.06238140f, 0.27744183f, -0.15094402f, -0.00371248f, 0.00661967f, 
    -0.00039242f, -0.31831846f, -0.02022821f, -0.09256307f, -0.08038314f, 0.04980359f, 0.17889211f, -0.10650647f, 
    -0.15839209f, 0.40447435f, 0.03736751f, -0.00588273f, -0.03550365f, -0.07967613f, -0.03283340f, 0.10301865f, 
    0.13096730f, 0.01040728f, 0.07762206f, -0.06220111f, -0.00313149f, -0.21485876f, -0.07708555f, 0.10322414f, 
    0.07516712f, 0.03745925f, -0.05635188f, -0.14396146f, -0.10322583f, 0.00798441f, 0.02103237f, 0.04116340f, 
    0.34011149f, 0.03267650f, 0.14045046f, 0.11045435f, 0.05566112f, 0.05411093f, -0.03318566f, 0.14665027f, 
    0.04632611f, -0.01323122f, -0.22652750f, -0.14531487f, 0.08286009f, -0.02807944f, 0.04771255f, 0.43473846f, 
    0.06457595f, 0.23078078f, 0.09056880f, -0.12666266f, 0.07491942f, 0.09133093f, -0.05797523f, -0.19965567f, 
    0.48237041f, 0.22523867f, 0.11992593f, 0.15867555f, 0.12069443f, 0.00301921f, 0.01286610f, 0.24089029f, 
    0.05427395f, 0.07128133f, 0.04327624f, 0.14659745f, -0.02158609f, -0.09149469f, -0.07692774f, -0.31130418f, 
    -0.11557869f, -0.13776669f, -0.08959724f, -0.01932786f, 0.04085952f, -0.11598422f, 0.02500978f, 0.13511312f, 
    -0.06291448f, -0.11109085f, 0.23133789f, -0.03250590f, -0.02182991f, -0.00027013f, 0.22470103f, -0.04043429f, 
    -0.14860259f, 0.00294263f, 0.01225442f, -0.00813003f, 0.40385705f, 0.11298520f, 0.18288951f, -0.17366527f, 
    -0.07371748f, -0.04752251f, -0.11095119f, 0.02163275f, 0.01179662f, 0.08071286f, 0.06716135f, 0.13728125f, 
    -0.51456815f, 0.04770459f, 0.29636657f, 0.00615604f, 0.02042063f, 0.11898986f, -0.09573900f, 0.02138632f, 
    0.08871997f, 0.00936185f, 0.10648619f, 0.21018933f, -0.12225723f, 0.03478855f, 0.22693843f, -0.02575490f, 
    0.07849361f, -0.07518014f, -0.03540693f, 0.01507516f, 0.12141364f, -0.16663297f, -0.03391768f, -0.23156959f, 
    -0.02982988f, 0.13468787f, 0.05891274f, 0.18059170f, -0.11169042f, 0.04775528f, -0.05215092f, 0.09894334f, 
    0.05623139f, 0.08229638f, 0.08355756f, -0.03350641f, -0.15837605f, 0.27525508f, -0.21230453f, 0.00487133f, 
    0.08874664f, 0.01406402f, 0.12411702f, 0.08144219f, -0.01316830f, 0.05603808f, -0.08230203f, -0.00637897f, 
    -0.18032701f, 0.11832759f, 0.03329345f, -0.08387851f, -0.04237154f, -0.11856380f, 0.00734644f, 0.10554068f, 
    0.05024360f, -0.10534418f, -0.09942342f, -0.04896418f, -0.22424555f, 0.11884089f, -0.19171713f, -0.23256496f, 
    0.08982404f, 0.04306912f, -0.03539190f, -0.00490722f, 0.06272844f, -0.02958474f, -0.05589683f, 0.00961190f, 
    -0.29901698f, -0.00963401f, 0.03003757f, -0.13737334f, -0.12860867f, 0.03687414f, -0.07415686f, -0.05517312f, 
    0.16898456f, 0.04364782f, -0.08164224f, -0.06950364f, -0.92729330f, -0.06965216f, 0.10636757f, 0.20938765f, 
    -0.02209320f, -0.05290080f, -0.09473295f, -0.01674734f, -0.00629864f, 0.15373851f, 0.02142322f, 0.10497849f, 
    -0.11869252f, 0.07460715f, -0.07148267f, -0.03004031f, -0.07913759f, 0.04240339f, 0.11762687f, 0.25368568f, 
    -0.08449426f, 0.15643628f, 0.02199098f, 0.22601180f, -0.37832597f, 0.40001562f, -0.26489815f, -0.60102099f, 
    -0.07250405f, -0.12854967f, 0.08682391f, 0.20556675f, -0.04642333f, -0.08020423f, -0.00029453f, 0.06249563f, 
    -0.28643042f, 0.00121561f, -0.30295971f, 0.08108306f, 0.02512065f, -0.19175525f, 0.03399504f, -0.18567097f, 
    -0.01526716f, -0.20341749f, 0.01302846f, 0.02232071f, -0.41291529f, -0.04347864f, 0.31533885f, 0.10118463f, 
    -0.00482639f, 0.08981458f, -0.01354107f, -0.01733003f, -0.02082851f, 0.06360364f, -0.02190435f, -0.04197172f, 
    -0.40429810f, -0.06622921f, 0.16775589f, 0.03886952f, 0.02980304f, -0.07860819f, 0.04417069f, 0.03485108f, 
    -0.06331699f, 0.08237668f, -0.02899791f, -0.04191681f, -0.05615798f, 0.12573433f, 0.24468227f, -0.10064090f, 
    -0.00493962f, -0.10682877f, 0.04166424f, 0.13560042f, 0.03178550f, 0.02014516f, -0.07003471f, 0.01496987f, 
    0.42341265f, 0.32358944f, -0.36613941f, -0.16487341f, 0.07931518f, 0.01805970f, 0.12588289f, 0.10362419f, 
    -0.10577350f, -0.12670620f, 0.00338684f, 0.08858192f, -0.33908316f, 0.13285297f, 0.09161399f, -0.04578962f, 
    -0.19401777f, -0.22770877f, 0.02700434f, -0.03201072f, -0.13117629f, -0.05046367f, -0.12125551f, -0.03231843f, 
    -0.45121822f, -0.00901394f, 0.13866590f, 0.03134345f, 0.03951641f, 0.04494443f, -0.11231472f, 0.05580492f, 
    -0.07308915f, -0.01504539f, 0.03396460f, -0.04493023f, 0.29986653f, -0.22515656f, 0.00080204f, 0.14501198f, 
    -0.01653803f, -0.00165689f, 0.01322274f, -0.14897883f, -0.04455555f, 0.00376051f, -0.09911905f, -0.11736582f, 
    -0.16382723f, -0.07820673f, -0.04988010f, -0.20158833f, -0.08555460f, 0.03255830f, 0.06104726f, 0.09797837f, 
    0.11382166f, -0.16272709f, -0.11445122f, -0.16970584f, -0.63131583f, 0.12328597f, -0.13853945f, 0.16160519f, 
    -0.00029835f, 0.00332900f, 0.01116745f, 0.12561990f, 0.02776999f, -0.12718204f, 0.03725061f, 0.08476380f, 
    0.25962347f, 0.11894045f, 0.19675533f, -0.23759565f, 0.02869729f, 0.07472298f, 0.08088525f, 0.13314022f, 
    0.07215391f, -0.00742199f, -0.21666887f, 0.00674417f, 0.41173556f, -0.16457023f, -0.20935766f, 0.06654601f, 
    -0.19919480f, -0.08528208f, 0.02790450f, 0.06969456f, 0.05644411f, 0.11756455f, -0.04095959f, -0.01987998f, 
    0.46521601f, -0.27759740f, 0.03382951f, 0.19739737f, 0.10882934f, -0.01832483f, 0.04995806f, -0.02195821f, 
    0.00346467f, -0.08244524f, 0.06933999f, 0.02085315f, -0.02291272f, 0.09795330f, 0.01254747f, -0.00744356f, 
    0.08005222f, -0.11708092f, 0.01191711f, 0.00553951f, -0.06850401f, 0.03990916f, 0.04809936f, -0.05156578f, 
    0.31464538f, 0.20967765f, -0.11552223f, -0.10508260f, -0.01852651f, 0.18612662f, 0.09442721f, 0.01640924f, 
    -0.10407430f, -0.05361534f, 0.20095150f, -0.05526644f, -0.62383068f, 0.20175949f, 0.11670645f, 0.07317386f, 
    -0.02880787f, 0.14232793f, -0.01668328f, 0.10378969f, -0.13034724f, 0.09313636f, 0.04484655f, 0.09020496f, 
    -0.06391671f, 0.04378363f, 0.06864473f, -0.09857309f, 0.02329735f, 0.11502746f, 0.02389251f, 0.02106864f, 
    -0.12574714f, -0.08106915f, 0.08830446f, 0.03953032f, -0.28178731f, 0.04849190f, 0.11682145f, 0.06191135f, 
    -0.20998147f, 0.08994593f, 0.01619491f, -0.01743188f, -0.08901539f, 0.06366497f, -0.13449372f, -0.00949849f, 
    0.27487838f, -0.10619821f, 0.08462118f, -0.09254268f, -0.05441624f, 0.11127125f, -0.20098355f, 0.06658638f, 
    0.08663689f, -0.10736382f, -0.02923501f, 0.21622525f, 0.04553743f, 0.07918662f, 0.19313973f, 0.32930759f, 
    0.04857213f, 0.05073602f, -0.10053795f, 0.36904097f, -0.06658871f, 0.01356719f, 0.15310369f, -0.00665996f, 
    -0.28333887f, 0.03923099f, -0.03170761f, -0.32374275f, -0.02998624f, 0.03613718f, -0.05687355f, 0.09113423f, 
    -0.12241147f, 0.00436351f, -0.09638761f, 0.07486472f, 0.06401099f, -0.06470491f, 0.00462648f, -0.26801613f, 
    0.22125435f, 0.01967644f, 0.01141728f, 0.03446694f, -0.12479772f, -0.02184354f, -0.01681126f, 0.13180487f, 
    0.05604598f, 0.08110750f, -0.20425275f, 0.05958182f, -0.13646947f, -0.19603115f, 0.04734503f, -0.14556663f, 
    0.06987914f, 0.03153254f, -0.05391243f, 0.05929787f, 0.19135293f, 0.05708737f, 0.17013523f, 0.17979643f, 
    0.03716102f, 0.12071742f, 0.02484986f, 0.06760736f, 0.01103601f, 0.09505513f, 0.14455257f, 0.30786848f, 
    -0.18071562f, -0.09612566f, 0.17509755f, 0.06949887f, 0.06249950f, -0.00757252f, 0.05956179f, 0.02063581f, 
    -0.04767086f, 0.29720968f, 0.04397040f, 0.13796924f, -0.01632541f, 0.10140717f, 0.31707704f, -0.02732631f, 
    0.01442499f, -0.07006531f, -0.19273140f, -0.01012793f, 0.03812595f, -0.05832526f, 0.05351923f, -0.02710693f, 
    -0.21646735f, -0.19431269f, 0.20606257f, -0.01032083f, 0.02528649f, -0.07114485f, 0.10451189f, -0.05178447f, 
    0.04275997f, -0.19306675f, -0.00848393f, 0.03841789f, -0.57764679f, -0.07472454f, -0.02247725f, -0.04478609f, 
    0.13163745f, -0.04521721f, 0.02142616f, -0.03544389f, -0.03634908f, -0.03603557f, -0.01767061f, 0.06273070f, 
    -0.59486485f, -0.00619335f, 0.19097079f, -0.48106873f, 0.08397257f, 0.04702218f, -0.03230255f, -0.14716363f, 
    0.04378403f, -0.00370565f, 0.15236682f, -0.01213664f, -0.19596183f, 0.08144557f, -0.31551453f, -0.08076858f, 
    0.15291907f, 0.04751068f, 0.10459990f, -0.09230134f, -0.09592837f, -0.32951444f, 0.14027557f, -0.31500599f, 
    0.01401591f, 0.05073928f, 0.19118994f, 0.25899804f, 0.16199459f, -0.01698173f, -0.19512165f, -0.02090247f, 
    -0.16016193f, -0.04834882f, -0.17844480f, -0.11816827f, -0.67374897f, 0.11936066f, 0.27105084f, 0.15010843f, 
    -0.01465467f, 0.10604849f, 0.06011390f, 0.03277848f, 0.01268174f, 0.02455108f, -0.05678502f, -0.01309823f, 
    -0.30295250f, 0.10292493f, -0.10822812f, -0.10032032f, -0.01230655f, 0.10788274f, -0.02037461f, 0.05738615f, 
    0.20111592f, -0.06182642f, -0.03118343f, -0.02225925f, 0.25218806f, 0.00164511f, -0.02032997f, 0.08221070f, 
    -0.06144194f, -0.06480846f, -0.09189197f, 0.06079113f, -0.08817184f, 0.06816678f, -0.07032624f, 0.09523497f, 
    0.15830094f, -0.25537777f, -0.27730888f, -0.07733072f, 0.00275056f, 0.08784184f, -0.23285353f, 0.10953025f, 
    -0.05875780f, -0.09757396f, -0.07654659f, -0.00240143f, -0.03408292f, -0.24225254f, -0.14856325f, 0.01431288f, 
    0.24907404f, 0.13652709f, -0.08423291f, 0.20104122f, 0.09216470f, 0.11245275f, 0.05517801f, -0.09664613f, 
    -0.08228078f, 0.28807747f, 0.45150435f, -0.42424548f, -0.13051438f, -0.12549599f, 0.05173481f, -0.03160318f, 
    0.11862737f, -0.01859774f, 0.02454381f, -0.08764461f, -0.10494569f, -0.18305893f, -0.02945462f, -0.33506456f, 
    -0.26970038f, 0.09398615f, 0.13344947f, -0.09969483f, 0.09566312f, -0.04882991f, 0.01740346f, 0.15193669f, 
    -0.00476745f, 0.10204884f, 0.11962653f, -0.13202125f, 0.14094864f, -0.11870680f, 0.05991524f, 0.12220200f, 
    0.09201232f, 0.11480385f, 0.16133858f, -0.04237807f, 0.06983592f, 0.01699680f, 0.05066278f, -0.34175044f, 
    -0.12039728f, -0.07461397f, 0.02814548f, -0.04073163f, 0.03144955f, -0.08990830f, -0.16004553f, -0.05072108f, 
    0.43738681f, 0.09081561f, 0.04536061f, -0.24880210f, 0.17306399f, -0.15222658f, -0.09433133f, 0.05021465f, 
    -0.07266591f, 0.13176283f, 0.07080976f, -0.11139268f, -0.65882868f, 0.09863368f, -0.29842865f, -0.33081466f, 
    0.14485845f, 0.14094648f, 0.09309343f, -0.15434009f, -0.22936612f, 0.00232545f, -0.12651339f, -0.05364660f, 
    -0.25279087f, -0.08233844f, 0.12386318f, 0.22023998f, 0.11024331f, 0.05174707f, 0.07739596f, -0.11051203f, 
    0.10225260f, -0.29342297f, 0.16866954f, 0.15913808f, -0.10699747f, 0.13376415f, 0.38164097f, -0.33779275f, 
    0.07509782f, 0.02459764f, 0.05529378f, 0.01556038f, 0.07906119f, -0.09161980f, -0.02978345f, 0.08829323f, 
    -0.16530164f, 0.04324986f, 0.14341040f, -0.01613111f, 0.11002155f, 0.04678085f, -0.10999385f, -0.29296970f, 
    0.03525026f, 0.08259547f, 0.20924111f, -0.01408109f, -0.22899701f, -0.11855979f, -0.12680788f, 0.12594755f, 
    0.01830780f, 0.10891467f, 0.05972241f, -0.10172202f, 0.17957671f, -0.11368703f, -0.21987079f, 0.19138658f, 
    -0.20661095f, -0.12098452f, 0.08051255f, -0.07381439f, -0.04292712f, -0.08437763f, 0.16456454f, 0.14851686f, 
    0.12445688f, 0.08829753f, -0.31686977f, -0.12447893f, 0.08383965f, 0.10079037f, -0.16184698f, -0.05201862f, 
    0.07307684f, -0.05088782f, -0.11377766f, -0.11697754f, 0.13746294f, -0.07191027f, -0.22440471f, -0.19273551f, 
    -0.25193524f, -0.10599183f, 0.23463301f, 0.27430379f, -0.10735095f, -0.10080048f, -0.07492770f, -0.03211347f, 
    0.00283855f, -0.14673723f, 0.11176351f, 0.05317608f, 0.13951713f, 0.03135059f, -0.17726876f, -0.08922233f, 
    0.21871728f, 0.10597944f, 0.04285833f, 0.13939184f, 0.07178453f, 0.07036000f, 0.11339217f, 0.24704854f, 
    -0.10923459f, 0.23045185f, 0.11176062f, 0.30987856f, 0.09414134f, 0.03428154f, 0.03794176f, 0.13070527f, 
    0.02782539f, -0.06342821f, 0.03837156f, -0.25363946f, -0.18155813f, -0.11170182f, -0.32513776f, 0.21196184f, 
    0.13822187f, 0.10993224f, 0.01966165f, -0.20832536f, 0.03931545f, 0.06442269f, 0.07356804f, 0.11367950f, 
    -0.09886685f, -0.05813023f, -0.04538250f, -0.15392010f, 0.11631241f, -0.00141319f, -0.18084560f, 0.15848002f, 
    0.02640456f, -0.00962502f, 0.14611170f, 0.03629423f, -0.56654674f, -0.61568880f, -0.23889263f, 0.22737196f, 
    0.09231699f, -0.26023859f, 0.08348390f, 0.11418243f, -0.06309216f, 0.17526521f, -0.06185066f, 0.19652024f, 
    -0.35300976f, -0.13774247f, -0.24148440f, 0.32911509f, 0.07776526f, 0.03952747f, 0.02649418f, 0.04242337f, 
    -0.01718450f, -0.11580917f, -0.00007738f, -0.04916985f, 0.12801643f, 0.11677735f, 0.02485646f, 0.03009293f, 
    0.02978499f, 0.02573937f, -0.07712531f, 0.03928106f, -0.08276626f, 0.02639239f, -0.04243167f, -0.25408393f, 
    -0.10030303f, 0.33548418f, -0.01271495f, -0.25474346f, 0.22467868f, 0.11838593f, 0.10290761f, 0.01496577f, 
    -0.05973312f, -0.17439114f, 0.00342405f, -0.14038680f, 0.14100465f, -0.06275767f, 0.23116198f, -0.14447162f, 
    -0.12096418f, -0.00982508f, -0.01286685f, 0.04949296f, -0.18486412f, -0.10868210f, -0.04318820f, 0.12910436f, 
    0.18066657f, 0.26962438f, 0.13456827f, -0.40259740f, -0.19423343f, 0.03403127f, -0.09720863f, 0.05510814f, 
    -0.06437591f, 0.18368319f, 0.12948053f, 0.09030387f, 0.50365329f, -0.47237632f, 0.11489502f, 0.06056036f, 
    0.00095381f, 0.13194551f, 0.06585813f, -0.02084662f, -0.12537238f, -0.03090740f, 0.09466566f, -0.12325282f, 
    0.06403578f, -0.04122498f, -0.15049131f, 0.27608401f, -0.04836326f, 0.17603344f, -0.04214298f, 0.19054100f, 
    -0.02150561f, 0.03388537f, -0.10688054f, -0.05319448f, 0.06039698f, -0.22352001f, -0.06159092f, -0.41780221f, 
    -0.11986212f, -0.07341064f, -0.12083215f, -0.06849764f, 0.02557143f, 0.16852142f, 0.04476745f, 0.41507065f, 
    -0.25141886f, 0.12629262f, 0.12594178f, -0.03714337f, -0.30954853f, 0.05267672f, 0.15196069f, 0.06285095f, 
    0.01723132f, 0.05207180f, 0.13895594f, 0.24633662f, 0.29890415f, -0.63968331f, 0.02090547f, -0.10677591f, 
    0.08008076f, -0.00185937f, -0.08628643f, -0.11510993f, 0.05308768f, -0.00403294f, 0.01078532f, -0.21208368f, 
    -0.00082051f, -0.11078288f, 0.05850155f, -0.15925573f, -0.01438145f, -0.09543578f, 0.10478517f, -0.04366320f, 
    0.02888330f, 0.04633691f, 0.03565947f, -0.01185263f, 0.21384808f, 0.10055735f, 0.08067887f, -0.52941161f, 
    0.16116470f, -0.00375227f, 0.14589484f, 0.08500645f, -0.04486943f, 0.06521815f, -0.00529196f, 0.05652450f, 
    0.05607594f, 0.09657664f, -0.13972472f, 0.36135167f, 0.07318209f, 0.10668761f, 0.15010118f, 0.12923048f, 
    -0.12861082f, 0.07192145f, -0.01376026f, -0.00327834f, 0.03380957f, -0.11402223f, -0.23878257f, -0.01325343f, 
    0.05329663f, 0.10125614f, 0.01388650f, -0.14206557f, -0.09728003f, -0.05494808f, 0.16558842f, -0.02221732f, 
    -0.01799867f, -0.20922254f, -0.00352709f, -0.17666273f, -0.15221851f, 0.01532367f, -0.10032969f, 0.13680948f, 
    0.11872657f, 0.03291791f, -0.11096025f, 0.02721911f, -0.34306070f, -0.11762022f, 0.08709564f, 0.31560570f, 
    -0.03783341f, 0.18989262f, -0.09598220f, 0.00164595f, -0.10656415f, -0.08495387f, -0.08973830f, 0.02378866f, 
    0.28262874f, -0.01164001f, -0.02348829f, 0.11931727f, 0.04033292f, 0.14617801f, -0.01587722f, -0.23641588f, 
    -0.00518993f, 0.00614211f, -0.08628729f, -0.05464756f, -0.69175237f, 0.27350354f, 0.18889809f, -0.08108818f, 
    0.00143832f, 0.19930720f, -0.05938148f, 0.02740792f, -0.01538376f, 0.06349434f, 0.09957395f, 0.01532054f, 
    0.05347239f, 0.02538485f, 0.32994655f, 0.20651078f, -0.18146572f, 0.21268439f, 0.00482279f, -0.02028375f, 
    0.07983965f, -0.01125141f, -0.17544264f, -0.07072762f, 0.00154556f, -0.38057807f, 0.16228543f, -0.15493223f, 
    -0.02964177f, -0.06783143f, 0.00512142f, -0.05731228f, 0.06488245f, -0.00606160f, 0.21195391f, 0.25739744f, 
    0.14458732f, 0.00038611f, -0.38607049f, 0.10767390f, -0.09560090f, -0.28126055f, -0.06373291f, -0.02853909f, 
    -0.17918302f, 0.10144990f, -0.18630935f, -0.06908891f, -0.20829704f, 0.00265435f, 0.27824685f, -0.16092841f, 
    -0.08438765f, 0.08950973f, 0.03212934f, 0.10164566f, -0.04940163f, 0.07120764f, 0.22599472f, -0.13569778f, 
    0.15191935f, 0.02217934f, -0.11208194f, 0.34933916f, -0.23449415f, 0.11529950f, 0.00589650f, 0.18763976f, 
    -0.22952877f, -0.06902274f, -0.03019632f, -0.18159196f, -0.16427086f, -0.00123497f, -0.35404497f, -0.03584711f, 
    0.03353856f, -0.10766634f, -0.10953204f, -0.10998324f, 0.04895473f, -0.12160018f, 0.05077762f, -0.21050382f, 
    0.31053665f, -0.10677660f, -0.03179325f, -0.00171568f, -0.02832252f, -0.03484727f, -0.01352336f, -0.03238750f, 
    -0.26106179f, 0.07561482f, -0.06411226f, 0.03877015f, -0.04885081f, -0.38900712f, 0.19897643f, -0.25272951f, 
    -0.04110017f, 0.02589810f, 0.00445346f, -0.01363146f, 0.03875239f, -0.07344902f, 0.22329348f, -0.03283846f, 
    0.29215133f, -0.15778604f, -0.29833931f, 0.28018838f, 0.05778361f, 0.06161547f, -0.09447444f, -0.04457678f, 
    -0.02098404f, -0.16298789f, -0.17073010f, 0.12104844f, 0.32275537f, 0.25864825f, 0.20244764f, -0.57196480f, 
    -0.31930086f, 0.05080761f, 0.07714927f, -0.08582214f, -0.00157411f, -0.16737084f, -0.12942120f, -0.07596844f, 
    0.09857289f, -0.07659721f, 0.03624271f, 0.06886466f, -0.02752123f, -0.10143986f, 0.17202501f, -0.03809701f, 
    0.11115970f, 0.13211329f, 0.03290089f, 0.23806639f, -0.46399197f, -0.05802960f, -0.30793220f, -0.12939619f, 
    -0.21227060f, -0.14256987f, 0.18457972f, -0.30313063f, -0.06001700f, 0.08091718f, -0.13008253f, -0.11206786f, 
    0.20102476f, -0.22754426f, 0.20266086f, -0.32853097f, -0.00205241f, 0.06804697f, 0.17269291f, 0.13763832f, 
    0.15780583f, 0.04816041f, -0.24664794f, -0.01101704f, -0.02646968f, -0.13681027f, -0.09805169f, 0.00808248f, 
    -0.12670480f, 0.15032688f, -0.02363953f, -0.02856698f, -0.03907521f, -0.08005891f, 0.01764636f, 0.12425446f, 
    -0.16957161f, -0.08096685f, -0.20552176f, -0.06613199f, -0.15821832f, -0.08302110f, -0.11292291f, 0.10173569f, 
    0.08684084f, -0.01866654f, -0.01730362f, -0.10343511f, -0.13354465f, -0.11926657f, -0.27768961f, 0.06902077f, 
    -0.03790691f, -0.02555757f, 0.06555236f, -0.06147205f, 0.04714411f, -0.01286517f, 0.02505622f, -0.11057711f, 
    -0.23495242f, -0.03668976f, -0.07830568f, -0.05431191f, 0.06488362f, -0.00896611f, 0.04034376f, -0.06935556f, 
    -0.04611631f, 0.02109000f, -0.03283122f, 0.24070385f, 0.03353333f, -0.03268296f, -0.31767842f, 0.03804640f, 
    -0.17207374f, 0.02067777f, 0.06015147f, -0.13959479f, -0.04622276f, 0.00044522f, 0.01937399f, -0.08650544f, 
    -0.13031729f, -0.00578284f, -0.22793137f, -0.14984307f, -0.02627922f, 0.02908953f, -0.10484627f, -0.09855616f, 
    -0.17333271f, -0.14363964f, -0.04208265f, -0.04450423f, 0.16564725f, -0.07060936f, 0.04331392f, -0.04935994f, 
    0.16861029f, -0.01936638f, -0.01511162f, -0.04399785f, -0.02236053f, 0.02147255f, 0.03114787f, 0.01651637f, 
    -0.44967964f, -0.03126281f, 0.31684890f, -0.28491768f, 0.02571342f, -0.06547722f, 0.03726454f, 0.03795992f, 
    -0.05388522f, -0.09968914f, 0.01332419f, -0.05215306f, -0.00324410f, 0.30950177f, 0.20540054f, 0.15170847f, 
    0.10241479f, 0.11189937f, 0.06028600f, -0.02531264f, -0.06612306f, 0.09593172f, 0.01013622f, -0.03269444f, 
    -0.00761130f, -0.02777881f, -0.13026169f, -0.28302875f, 0.02117641f, 0.07620097f, 0.03780618f, -0.16170846f, 
    0.02370935f, -0.05680104f, -0.04050256f, -0.10740706f, 0.07675988f, -0.22435383f, 0.13810219f, -0.10825020f, 
    -0.03871149f, -0.11491957f, -0.07146796f, -0.08835196f, 0.01944386f, -0.06193698f, -0.00902935f, -0.05965722f, 
    0.11228070f, 0.02667296f, -0.16711794f, 0.03721414f, -0.06772102f, 0.06078362f, -0.04331790f, -0.10966652f, 
    -0.02111888f, 0.00284887f, -0.12082462f, -0.10013986f, 0.17754352f, -0.51190656f, -0.02934880f, -0.00297300f, 
    -0.16283385f, -0.11924314f, 0.00599510f, -0.05783706f, -0.12167443f, 0.02291604f, 0.05508129f, 0.02849479f, 
    -0.15067680f, 0.24430439f, -0.04219962f, 0.18430661f, 0.02493605f, -0.08233042f, 0.08127810f, 0.08089788f, 
    0.07627505f, -0.08761933f, -0.08087888f, 0.02581860f, 0.04587681f, 0.06446486f, 0.13251066f, 0.17500718f, 
    0.12486880f, 0.04271204f, 0.08519273f, -0.09231460f, -0.10600975f, -0.18307669f, -0.11984814f, -0.04615903f, 
    -0.28149503f, 0.38020733f, 0.10370065f, -0.23754027f, -0.20209064f, 0.02705683f, 0.01921678f, -0.16508764f, 
    -0.08616398f, -0.03868608f, -0.21192560f, -0.20063451f, 0.32844821f, -0.28238338f, 0.02201143f, 0.11089610f, 
    -0.02848316f, 0.06804071f, -0.00325135f, 0.00298383f, -0.01072944f, -0.10545880f, 0.06177575f, -0.01343410f, 
    0.27507749f, -0.04496938f, 0.08528125f, -0.45069617f, -0.16200000f, 0.07683704f, 0.03645687f, -0.06066594f, 
    -0.05900921f, -0.03826499f, -0.12260365f, -0.14747532f, -0.51385689f, 0.27160823f, 0.06081623f, -0.16280140f, 
    0.08104779f, 0.09583981f, -0.03101194f, -0.03103161f, -0.07686125f, -0.06525452f, -0.00165761f, -0.11022997f, 
    -0.01154568f, 0.17995040f, -0.05713586f, -0.19692767f, -0.10003634f, -0.04206115f, -0.01988165f, -0.08291218f, 
    -0.04986636f, -0.16291627f, 0.05605247f, -0.12811325f, 0.03263389f, 0.00371584f, 0.23858096f, 0.13541988f, 
    0.00791713f, 0.09125867f, 0.01806591f, -0.02139327f, -0.03129205f, 0.03085312f, -0.07306904f, -0.05861686f, 
    0.10455574f, 0.23631440f, 0.15837859f, 0.29108012f, 0.21682441f, 0.03104453f, 0.08661743f, 0.07851996f, 
    0.04467488f, 0.05443414f, 0.06112137f, -0.14505044f, -0.06696569f, 0.19147852f, -0.10407435f, -0.12588575f, 
    -0.00050155f, 0.05128878f, -0.05829287f, -0.15516984f, 0.02723579f, -0.14386198f, -0.02554117f, -0.10524998f, 
    -0.05872211f, 0.21058017f, -0.19683783f, 0.37196466f, 0.15832616f, 0.07438858f, 0.03325300f, 0.09007120f, 
    -0.03558511f, -0.01220117f, 0.03164751f, -0.00386370f, 0.16729763f, 0.25039768f, 0.15285152f, 0.07580432f, 
    0.01056905f, 0.02734367f, -0.03623423f, -0.00808774f, -0.08195633f, -0.00095758f, -0.06882120f, -0.17275980f, 
    -0.17734461f, -0.24387957f, 0.10418981f, -0.17343107f, 0.08139887f, -0.04056202f, 0.06791057f, -0.04948752f, 
    -0.12899859f, 0.04357465f, 0.05844936f, -0.06365606f, 0.23042455f, 0.07818124f, 0.20265362f, -0.00716064f, 
    -0.13430928f, 0.07231969f, 0.04203455f, 0.00798478f, -0.07734710f, 0.07817098f, -0.11331262f, 0.05762329f, 
    0.07894991f, 0.18673654f, -0.01916790f, 0.34515157f, -0.05261536f, -0.19109209f, -0.12311404f, 0.01215591f, 
    -0.21989539f, -0.03385043f, -0.03203629f, -0.14218272f, -0.56705964f, 0.05545126f, -0.19598502f, -0.14563604f, 
    -0.08508934f, 0.01327642f, -0.02112104f, -0.17040472f, -0.09112395f, -0.02825844f, -0.02266043f, -0.15145946f, 
    0.14132203f, 0.07518014f, 0.10033464f, 0.24147984f, 0.17408787f, -0.07987798f, 0.08493286f, -0.17918113f, 
    -0.16628252f, 0.01932592f, -0.12226504f, -0.18163230f, 0.04357438f, 0.28557768f, 0.19397905f, 0.22788496f, 
    0.22496304f, 0.14868583f, 0.12322608f, -0.09464289f, -0.03275398f, 0.03113559f, -0.02960894f, -0.08680020f, 
    0.25386024f, -0.16200081f, 0.05708696f, 0.05275284f, -0.07045354f, -0.07617460f, -0.00577122f, -0.07320356f, 
    0.02318801f, -0.00492857f, 0.02175551f, -0.14538759f, 0.17899723f, 0.00229228f, 0.10617357f, 0.25619972f, 
    0.10310312f, 0.02419175f, 0.08335643f, -0.08739146f, -0.06858304f, 0.02666314f, -0.10902585f, 0.09906243f, 
    0.34537309f, 0.30936229f, -0.08750962f, -0.01084944f, -0.17598228f, -0.05839042f, 0.01482713f, -0.08809368f, 
    0.16628562f, -0.09359568f, -0.11657089f, -0.02294900f, -0.05891539f, 0.09926564f, -0.13942720f, 0.05938782f, 
    -0.05631593f, 0.02756401f, 0.02025260f, -0.07151613f, 0.10507701f, 0.11232934f, 0.01433749f, 0.10210297f, 
    -0.14049003f, -0.18079339f, -0.02557361f, 0.04306228f, 0.05333751f, -0.08017653f, -0.05770596f, 0.01821579f, 
    0.15945639f, 0.05591674f, 0.10971767f, -0.08930887f, 0.14087859f, 0.15778247f, 0.16841596f, 0.19247428f, 
    0.06881360f, -0.07911512f, -0.06022765f, -0.09165674f, 0.02663290f, -0.02397487f, 0.13855767f, -0.26396579f, 
    0.10973486f, -0.16247092f, -0.11494200f, 0.13362238f, 0.25586894f, 0.04574461f, 0.06919549f, -0.09861523f, 
    -0.15216795f, 0.00016068f, 0.04221857f, 0.11948127f, 0.06675158f, -0.21956640f, 0.08410703f, 0.00358096f, 
    -0.04726997f, -0.13240181f, 0.03026281f, 0.03118703f, 0.01793007f, -0.11448824f, -0.14590605f, 0.10227863f, 
    -0.16484684f, -0.06420005f, -0.03937507f, 0.00785041f, -0.22616406f, -0.12112033f, -0.18292621f, 0.02120021f, 
    0.08273260f, -0.03291705f, -0.05436854f, 0.15200149f, 0.01397160f, -0.19668102f, 0.17269570f, 0.00695221f, 
    -0.08890092f, -0.15530139f, 0.12247168f, -0.13439436f, 0.05132633f, -0.15538226f, -0.11600113f, -0.31393972f, 
    0.16867672f, -0.16567765f, 0.24477489f, 0.08517580f, 0.08250804f, 0.01572674f, -0.10461260f, -0.09801181f, 
    -0.11030887f, 0.02334137f, -0.00710441f, -0.04848151f, -0.00889475f, -0.32543403f, 0.09054362f, -0.05788885f, 
    -0.02150327f, 0.01624092f, -0.06594060f, -0.11917063f, -0.12727052f, 0.07565047f, -0.14674567f, -0.01547532f, 
    -0.23491934f, 0.15534073f, 0.15159868f, 0.00734542f, -0.18642507f, 0.13321511f, 0.01623914f, 0.00070876f, 
    -0.05195421f, -0.03805142f, 0.03732635f, -0.15029226f, -0.02653010f, -0.35941815f, -0.17222537f, 0.14122379f, 
    0.01160651f, -0.12442279f, 0.04101372f, 0.05015647f, 0.15547135f, 0.15546769f, -0.21147788f, 0.24261564f, 
    0.10854474f, 0.27257842f, -0.51691806f, -0.04603397f, 0.01793093f, -0.05286120f, -0.15965125f, 0.02686449f, 
    -0.01751922f, -0.18438342f, -0.05455633f, 0.11214152f, -0.18026733f, -0.15494002f, -0.07146084f, -0.35540166f, 
    -0.00740089f, 0.05290226f, -0.31762055f, 0.08992877f, 0.06158400f, -0.02435477f, 0.01731806f, -0.13414872f, 
    0.21527386f, -0.07761130f, 0.10303410f, 0.14663380f, 0.03938160f, -0.16089229f, -0.00398413f, -0.05605075f, 
    0.08810378f, -0.09327778f, -0.06031797f, -0.06802514f, 0.38654548f, 0.17969431f, -0.07578420f, 0.16135778f, 
    0.00431545f, -0.02692478f, 0.00420254f, -0.24593012f, -0.14111720f, 0.08008534f, -0.00381937f, 0.00323328f, 
    -0.10135090f, -0.06644089f, 0.16045037f, -0.05357765f, -0.11234194f, -0.08267520f, 0.01186894f, -0.11315818f, 
    0.03473726f, -0.09365981f, 0.11556867f, 0.08099224f, 0.15025948f, -0.21887989f, 0.06300583f, 0.06110942f, 
    0.16915777f, -0.02308404f, -0.11047877f, -0.04814774f, -0.01834745f, 0.04879136f, -0.04602579f, -0.14238039f, 
    0.32431823f, -0.14908335f, -0.11417333f, 0.08534366f, 0.20564325f, -0.17819636f, -0.18430597f, 0.03724574f, 
    0.04377857f, 0.27587157f, 0.04443556f, -0.12423839f, -0.28552809f, -0.05647893f, 0.27249596f, -0.00025162f, 
    -0.01375564f, -0.05269727f, -0.08986239f, -0.12582850f, 0.02939209f, 0.06358811f, -0.18838848f, -0.16476724f, 
    -0.16247962f, 0.15771995f, -0.15502051f, -0.09414430f, 0.00149560f, 0.03010067f, 0.11758521f, -0.25624952f, 
    -0.06795807f, -0.06641560f, 0.18471931f, -0.00190080f, 0.38869560f, -0.00541495f, 0.16095652f, 0.11915530f, 
    0.01662387f, 0.04890809f, 0.01045795f, -0.00096293f, -0.00569520f, -0.04686286f, 0.01121734f, -0.04673378f, 
    -0.10932718f, 0.05643013f, 0.04828659f, -0.11852748f, -0.15459466f, -0.06672246f, -0.13525407f, -0.13681456f, 
    0.03734189f, 0.01411326f, 0.02437344f, 0.02527048f, -0.24803306f, -0.03506415f, 0.24159384f, -0.25299650f, 
    -0.04050094f, 0.07107020f, -0.05390262f, 0.00336162f, -0.16306053f, 0.05103387f, -0.14191538f, 0.08957948f, 
    -0.07931878f, -0.29999131f, -0.00217967f, 0.21771069f, -0.00478011f, -0.00414135f, 0.07643557f, 0.09020913f, 
    0.12297535f, -0.20316096f, -0.21321806f, 0.01283784f, -0.17736182f, 0.30710915f, -0.05409450f, 0.04624643f, 
    -0.02084469f, -0.11650608f, -0.08793174f, 0.17876643f, 0.11395166f, 0.11518885f, -0.11384640f, 0.17748699f, 
    0.13421541f, 0.39967075f, -0.37121433f, -0.35681301f, -0.03046081f, -0.12752092f, 0.05492020f, 0.06655892f, 
    0.21063724f, -0.02737887f, 0.08434381f, 0.00809374f, -0.34941682f, -0.22364959f, 0.05206490f, 0.15278038f, 
    0.07886972f, -0.05120381f, -0.04570716f, -0.03201426f, 0.03814336f, 0.16523921f, 0.07808475f, 0.03463639f, 
    -0.40428570f, -0.36107370f, -0.11168884f, -0.47003213f, 0.03422577f, -0.05235635f, -0.04725112f, 0.04103220f, 
    -0.00924458f, -0.16460766f, 0.07145396f, -0.20015080f, -0.19495527f, -0.02144135f, 0.21954317f, 0.09959525f, 
    -0.07389572f, 0.14487444f, -0.04687563f, -0.03714399f, 0.13756962f, -0.04517616f, 0.00089962f, 0.04527014f, 
    -0.03885940f, -0.34747991f, 0.08874896f, -0.05662024f, -0.09637570f, -0.29091108f, 0.04154497f, 0.05466170f, 
    -0.08167827f, 0.10535342f, 0.09536891f, 0.14134243f, 0.01961325f, -0.04134920f, 0.26187846f, -0.16830015f, 
    0.10843040f, 0.01378997f, 0.19916691f, -0.11839107f, 0.15748411f, 0.09378469f, 0.06960563f, -0.02724613f, 
    0.40035683f, 0.25324783f, 0.00813807f, 0.21010318f, 0.01963598f, 0.21428768f, -0.00025596f, 0.19804820f, 
    -0.02156221f, 0.08784198f, 0.02697939f, 0.02092214f, 0.18418327f, 0.33474997f, -0.50487864f, -0.40712529f, 
    0.16471280f, -0.10559885f, 0.05649982f, -0.02413133f, -0.21648881f, -0.04307655f, -0.12393313f, -0.08677538f, 
    0.05975525f, -0.08878648f, -0.00698397f, -0.22652251f, -0.03804595f, 0.08384421f, -0.17072684f, 0.05140051f, 
    -0.26298791f, -0.06940643f, -0.15555122f, -0.05582368f, -0.06807561f, 0.23734605f, -0.32291597f, -0.03000996f, 
    -0.03453293f, -0.05547683f, 0.04543399f, -0.01166215f, -0.18292466f, 0.04624975f, -0.07967608f, 0.08878551f, 
    -0.49904358f, 0.25977412f, -0.13836528f, -0.24833196f, -0.00253195f, -0.00429434f, 0.08950521f, -0.11284614f, 
    -0.18401097f, -0.01922439f, 0.00961312f, -0.08897154f, 0.29719555f, -0.00987717f, -0.06160393f, 0.14946647f, 
    -0.09069741f, 0.00563127f, -0.03937595f, -0.12099183f, -0.10324232f, 0.07180105f, -0.07123780f, 0.06353068f, 
    0.01093487f, -0.12874354f, -0.07768806f, 0.33572641f, 0.11837308f, 0.05084075f, 0.07900175f, -0.13385636f, 
    0.00672009f, 0.22200501f, -0.10987832f, -0.17071183f, -0.05485303f, -0.29977819f, 0.12598595f, 0.05904756f, 
    0.10699721f, 0.08713599f, 0.07691269f, 0.05265744f, 0.05774103f, 0.24050185f, -0.04438024f, 0.06388877f, 
    -0.00883513f, 0.12816902f, 0.06388526f, -0.20746255f, 0.10415810f, -0.01536731f, -0.10440544f, -0.03891478f, 
    0.07203801f, 0.00871336f, 0.06110944f, 0.11083620f, 0.51643974f, 0.15477890f, -0.26271281f, 0.24121881f, 
    0.24353735f, -0.03440157f, -0.01343429f, 0.06645060f, 0.01597538f, -0.07313187f, -0.00951242f, 0.20610639f, 
    0.14124589f, 0.47228757f, 0.00921754f, 0.38308966f, 0.14205463f, 0.04137029f, -0.12547305f, 0.04016517f, 
    0.09603190f, 0.00104272f, 0.17767774f, 0.04319747f, -0.02631860f, 0.03260625f, -0.12175053f, -0.15029074f, 
    -0.11268244f, -0.00200994f, -0.04154970f, 0.00307312f, -0.01011662f, -0.05280967f, 0.02027872f, 0.00013950f, 
    -0.53218889f, 0.01835088f, 0.39601666f, 0.11401015f, 0.11348311f, 0.10345213f, -0.11326685f, -0.11329585f, 
    0.12424445f, 0.20046921f, 0.14817022f, -0.02630325f, -0.29339221f, -0.21046749f, -0.08121141f, 0.35608312f, 
    0.05408176f, -0.06062311f, 0.03095939f, -0.23801486f, -0.04390496f, -0.23288772f, -0.13027085f, 0.12334232f, 
    -0.54385996f, 0.37146950f, -0.28247771f, -0.00012668f, 0.15763280f, -0.02664300f, 0.09199850f, -0.03910497f, 
    -0.11651656f, -0.03421056f, 0.04752634f, 0.05984706f, 0.60491192f, -0.73838425f, 0.17339571f, 0.00304610f, 
    0.25484750f, -0.14041586f, -0.01370424f, -0.14056082f, -0.03884813f, 0.02105363f, 0.01179680f, -0.24182272f, 
    -0.21671575f, -0.07224619f, 0.18876019f, -0.29863387f, -0.00449901f, 0.04249575f, 0.01726782f, -0.03445464f, 
    -0.15220889f, 0.14521945f, -0.20538709f, 0.05365443f, -0.61249793f, 0.27487874f, -0.02139750f, -0.12817042f, 
    0.08889783f, 0.01336866f, -0.00877080f, -0.20460363f, 0.13849506f, -0.16305096f, 0.23960823f, 0.15629862f, 
    -0.26663050f, 0.18646842f, -0.06932642f, -0.00875786f, -0.08693722f, 0.07826984f, 0.31359327f, -0.08336126f, 
    -0.11324164f, -0.00251842f, -0.12059413f, -0.04992215f, 0.18742058f, -0.15180326f, -0.16296062f, 0.00164328f, 
    -0.03857090f, 0.01951737f, 0.03597522f, -0.02851538f, 0.13841629f, 0.07812675f, 0.11889283f, -0.13011062f, 
    -0.21290228f, -0.20645963f, 0.13353407f, -0.18825032f, 0.33270368f, 0.19835886f, -0.18287164f, 0.03830691f, 
    -0.10572911f, 0.09977417f, 0.16896021f, 0.04391221f, -0.33556637f, 0.05379535f, -0.24099416f, 0.02282759f, 
    0.14781821f, -0.08822853f, -0.00896042f, -0.06344578f, 0.06502032f, -0.07345419f, -0.06512698f, 0.27507001f, 
    -0.57638299f, -0.28309950f, 0.19574299f, -0.27758104f, -0.11255058f, -0.15785164f, 0.15648723f, 0.09363109f, 
    0.03698288f, -0.30236229f, 0.01555860f, 0.14696708f, 0.29829711f, 0.06676678f, 0.17016613f, 0.26824847f, 
    0.03703335f, -0.03278201f, 0.10507277f, 0.03358929f, -0.01706886f, 0.02749631f, 0.00543880f, -0.01164545f, 
    -0.09056991f, -0.30356559f, 0.00020469f, 0.04914241f, -0.08916205f, -0.09528205f, -0.19257270f, -0.13215560f, 
    -0.08705095f, -0.05655525f, 0.24848722f, 0.04706069f, -0.34719220f, 0.01659410f, -0.31783703f, 0.10316326f, 
    0.12487886f, -0.01962655f, 0.14083497f, -0.05174569f, -0.06259198f, 0.03751630f, -0.02370027f, -0.01091035f, 
    -0.22858445f, -0.06604308f, 0.15627787f, -0.08903504f, 0.09241199f, 0.03695484f, -0.12942712f, 0.10073352f, 
    0.13547255f, 0.06835984f, 0.19819492f, 0.07187764f, -0.45883656f, 0.37321070f, 0.09630911f, -0.32080865f, 
    0.15648046f, -0.17505272f, -0.07944863f, 0.07763462f, 0.12495744f, 0.00744697f, -0.11989464f, -0.07895789f, 
    -0.35923800f, -0.11919831f, 0.00800415f, -0.33613762f, -0.05308093f, -0.10088044f, -0.00203539f, -0.08366504f, 
    -0.09423063f, -0.03731848f, 0.20224471f, 0.12452392f, -0.16558865f, -0.51482797f, 0.10236635f, -0.21444713f, 
    0.13532355f, 0.00919707f, 0.06848501f, -0.06426180f, -0.20992486f, -0.04305435f, -0.23978820f, -0.03345204f, 
    0.54409623f, 0.13964418f, -0.22078091f, 0.03299529f, -0.09127248f, -0.08231218f, 0.07076063f, 0.01952021f, 
    0.12040626f, -0.12516740f, -0.08536775f, -0.19235677f, 0.00897796f, -0.10954973f, -0.07662211f, 0.08157793f, 
    0.00951985f, -0.13782807f, 0.02342891f, -0.13957559f, -0.01450944f, 0.04540002f, -0.03854541f, -0.03173593f, 
    -0.23675919f, -0.18252641f, 0.09196576f, 0.07040761f, 0.03469142f, 0.15847334f, 0.17203514f, -0.21936843f, 
    0.11826733f, 0.06246154f, -0.06295086f, 0.01055129f, -0.41837606f, -0.13082728f, -0.09577060f, -0.23951685f, 
    0.03721731f, -0.08065704f, -0.01143216f, 0.17906627f, -0.02850334f, 0.20742355f, 0.15971617f, 0.24580494f, 
    -0.89438248f, 0.23808968f, -0.11193928f, -0.26578283f, 0.25865638f, 0.00541013f, -0.13620698f, -0.02772285f, 
    0.15462646f, -0.03544799f, -0.00623073f, 0.04714636f, -0.60363317f, -0.39193431f, -0.04169436f, -0.14283858f, 
    -0.09481352f, 0.04767609f, 0.02340893f, -0.08550463f, 0.11313456f, 0.07509781f, 0.02219912f, -0.23763229f, 
    -0.47507110f, -0.53143340f, -0.10202207f, -0.23071299f, 0.17419606f, 0.10266195f, 0.00372139f, -0.06776673f, 
    0.18654938f, 0.02774460f, 0.01024750f, 0.03299543f, 0.05806125f, 0.11694542f, -0.34698457f, 0.02927131f, 
    -0.21182729f, -0.02957900f, 0.05118452f, -0.02137825f, 0.00084773f, -0.02793638f, 0.10587656f, 0.00985482f, 
    0.37018517f, 0.06291031f, -0.17907137f, 0.32566804f, -0.05595471f, -0.18097937f, -0.05919312f, 0.16868620f, 
    -0.08099333f, -0.06401888f, -0.06286874f, 0.02885150f, 0.51285583f, 0.25231171f, -0.18503089f, 0.20028132f, 
    -0.18901883f, -0.19307749f, 0.00807353f, -0.06331615f, 0.05794308f, -0.05789366f, -0.00519074f, -0.22480939f, 
    -0.79003561f, -0.22855456f, -0.10885395f, -0.25617996f, 0.17537147f, 0.01294188f, -0.26150677f, -0.17172724f, 
    -0.11424931f, -0.30383325f, -0.15118131f, -0.19204907f, -0.03983340f, 0.04888457f, -0.09040718f, 0.08462574f, 
    0.03370168f, -0.03629531f, 0.07519899f, 0.03379384f, 0.20323937f, -0.05595592f, 0.05808059f, -0.21379893f, 
    0.07871021f, -0.00381714f, 0.20923202f, 0.21489540f, -0.02373246f, -0.07528233f, 0.10808671f, 0.17935023f, 
    -0.04187473f, 0.05005446f, -0.00790188f, 0.00841553f, -0.26076996f, 0.35512194f, 0.08073857f, -0.09061448f, 
    0.03142156f, 0.03610272f, 0.23321243f, 0.09606699f, 0.09797120f, -0.03746299f, 0.04562349f, 0.09944882f, 
    -0.16942455f, -0.10889117f, -0.14975198f, 0.16887578f, -0.01253276f, -0.12101962f, 0.00448687f, 0.01581693f, 
    0.13731898f, -0.10263094f, 0.01836625f, -0.03112422f, 0.30695340f, -0.13356288f, -0.14462623f, -0.07781964f, 
    -0.08146545f, -0.07243815f, 0.14575723f, 0.01027469f, -0.08170217f, 0.15499824f, 0.03809659f, -0.19202815f, 
    -0.04799804f, 0.06641542f, -0.08559562f, 0.02756564f, -0.02143166f, -0.21451837f, -0.10162015f, 0.05376579f, 
    -0.01104678f, -0.07546722f, -0.03132573f, -0.11371911f, -0.13043192f, 0.15010978f, -0.09302272f, -0.01399192f, 
    -0.16552208f, 0.15665855f, 0.02471703f, 0.06283741f, 0.13724846f, 0.27139661f, 0.22075188f, -0.02495090f, 
    0.43501386f, 0.08896538f, -0.05740591f, 0.04932792f, 0.04945306f, 0.07734562f, -0.04177475f, -0.00096033f, 
    0.09846429f, -0.03171036f, 0.06820453f, 0.19391388f, -0.90291935f, -0.69086838f, -0.30229327f, -0.02714900f, 
    0.11087052f, 0.05928693f, -0.00979137f, 0.02992710f, 0.16012780f, 0.01004213f, 0.01752388f, 0.21944676f, 
    -0.36344346f, -0.25320137f, -0.01374643f, 0.09513161f, 0.05393493f, -0.15564221f, 0.06216622f, -0.06087616f, 
    0.13429256f, 0.25310215f, 0.06659719f, 0.27569118f, 0.29543257f, 0.05596637f, -0.06329840f, -0.04603925f, 
    -0.16852906f, -0.10297332f, -0.13100374f, 0.04423063f, -0.12032133f, -0.07167226f, -0.24881823f, -0.00605281f, 
    -0.20575559f, 0.05949824f, -0.27054247f, 0.02135098f, -0.00777081f, 0.03614335f, -0.12630562f, -0.06579981f, 
    -0.05132683f, -0.04432139f, 0.24728735f, 0.00078967f, -0.24717419f, -0.23416917f, -0.32891950f, -0.09712003f, 
    0.00354972f, -0.08176020f, -0.06562487f, 0.16474569f, -0.00449815f, 0.06736840f, -0.00507613f, 0.13821974f, 
    -0.14475526f, -0.15123540f, -0.12071980f, 0.06399427f, -0.05604633f, 0.06768008f, 0.07273614f, -0.06955411f, 
    -0.09306753f, 0.22662506f, -0.06614126f, 0.08068628f, 0.09536739f, 0.03457161f, 0.22089113f, -0.23597719f, 
    0.12888244f, 0.16858669f, 0.10052007f, -0.00941272f, 0.05452056f, -0.01475030f, 0.08775329f, 0.28595680f, 
    0.14647743f, -0.06375651f, -0.17976969f, -0.14518709f, 0.13121758f, -0.11842245f, 0.09961585f, 0.05999880f, 
    -0.00287115f, 0.14695486f, 0.02257588f, 0.10899368f, 0.15630966f, -0.07040790f, -0.00273516f, -0.12439734f, 
    -0.08119936f, 0.07594644f, 0.01022423f, 0.01393086f, 0.08878738f, -0.15674247f, -0.13963263f, -0.05837459f, 
    0.24928628f, -0.12829615f, -0.11358729f, -0.08422519f, 0.23983502f, 0.16337338f, 0.01526986f, -0.09851024f, 
    0.08611259f, 0.11490602f, 0.10102788f, 0.06617543f, 0.11489856f, 0.03674947f, -0.16126202f, -0.19180088f, 
    -0.02824952f, -0.27694389f, -0.12635316f, 0.00214589f, -0.02958245f, -0.04973715f, 0.14962758f, 0.09112372f, 
    -0.27926826f, 0.14331342f, -0.03615067f, 0.13411842f, 0.15026771f, -0.02436349f, -0.03260621f, 0.01655274f, 
    -0.09670897f, -0.20692402f, -0.14237586f, -0.19676752f, 0.27576900f, 0.05834588f, -0.13012412f, -0.09720618f, 
    -0.09615339f, -0.02486484f, -0.09581841f, -0.10812246f, 0.15384352f, 0.15198343f, 0.09235779f, 0.02932331f, 
    -0.12895878f, 0.02801899f, -0.10175555f, 0.07749741f, 0.02794123f, -0.02607446f, -0.07177504f, -0.05522367f, 
    -0.17200811f, 0.19179393f, 0.17042775f, 0.10701700f, -0.03182882f, 0.21685216f, -0.05375405f, -0.07590156f, 
    -0.00785526f, 0.11640167f, 0.26984274f, -0.01045046f, 0.06477939f, -0.09235971f, 0.01715939f, -0.12002921f, 
    -0.41455662f, -0.23649086f, 0.10648520f, -0.31577036f, 0.11808755f, 0.00980366f, -0.01848171f, 0.18122689f, 
    -0.09441955f, -0.05298611f, -0.02334633f, 0.04938897f, 0.27463913f, -0.23634614f, -0.09940208f, 0.29802182f, 
    -0.02388043f, 0.00888368f, 0.02219216f, -0.05737608f, -0.03670357f, 0.04731143f, -0.11050560f, -0.16041000f, 
    0.51628399f, -0.14938620f, -0.16204439f, -0.09177502f, -0.02738778f, -0.00810882f, -0.03271696f, 0.08196970f, 
    0.06104381f, -0.06865046f, -0.03644296f, -0.19504742f, -0.55505526f, -0.30836996f, -0.32561892f, -0.30329978f, 
    -0.01020501f, -0.08318037f, 0.05797207f, 0.06210458f, 0.14391398f, 0.08590154f, 0.02595693f, 0.14480786f, 
    0.58517540f, 0.05653828f, -0.50547743f, -0.01410224f, 0.16455141f, -0.14894517f, -0.01486785f, 0.02221182f, 
    0.03132372f, -0.04114477f, 0.00711875f, 0.02564453f, -0.32255721f, 0.09100554f, 0.25191683f, -0.05724420f, 
    0.02827545f, 0.10729190f, -0.06252566f, 0.03666682f, -0.00431498f, 0.03695289f, -0.06252301f, 0.05912899f, 
    0.34931391f, 0.06261522f, 0.16614957f, 0.08066672f, -0.00696232f, -0.13679154f, 0.11261617f, -0.04358459f, 
    -0.08829465f, -0.07985543f, 0.18652213f, -0.05382096f, -0.06853545f, -0.15651743f, -0.07291981f, -0.03481160f, 
    0.03698700f, 0.11161004f, -0.06212310f, 0.06419697f, 0.03907145f, -0.07646544f, -0.16365021f, -0.10441959f, 
    0.05429387f, -0.25660571f, -0.08377478f, -0.46548146f, -0.01191696f, 0.06568232f, -0.09969762f, 0.08555414f, 
    0.12442980f, 0.08960340f, 0.05662185f, 0.00542118f, -0.17082746f, -0.17949449f, 0.38494551f, -0.08869535f, 
    0.00223751f, 0.04795152f, -0.11433459f, -0.04022187f, -0.00087103f, 0.05419524f, 0.17060539f, 0.23616818f, 
    0.03602440f, -0.26745215f, 0.00207770f, 0.11080483f, 0.03528988f, -0.05470078f, -0.00878234f, 0.02936050f, 
    -0.02808670f, 0.17535418f, -0.04275841f, 0.06830389f, 0.59569633f, -0.25414509f, -0.09534416f, -0.09634627f, 
    0.09753059f, -0.10052321f, -0.09636528f, 0.06876023f, -0.04818142f, -0.01803283f, 0.07065196f, 0.05040835f, 
    0.25463900f, -0.11092032f, -0.14230767f, 0.10488225f, 0.01349341f, -0.00889057f, 0.09808456f, -0.09559121f, 
    0.04642809f, 0.00127687f, 0.02381772f, 0.02154647f, 0.05484960f, 0.16636671f, 0.05941993f, 0.09676623f, 
    -0.13857843f, 0.00588438f, -0.01836405f, -0.12476057f, -0.04836669f, -0.10502145f, 0.15599453f, 0.09343615f, 
    0.09094078f, -0.36484495f, 0.27730554f, -0.07593781f, 0.09639651f, 0.07298715f, 0.06194929f, -0.08711936f, 
    -0.01206577f, 0.01609619f, 0.00657996f, 0.07320423f, -0.22464931f, 0.22430496f, -0.13159157f, 0.15945980f, 
    0.13910659f, -0.09691721f, -0.00733134f, 0.27304712f, -0.18112318f, -0.00005769f, -0.03702610f, -0.22865148f, 
    -0.42105228f, 0.30515665f, -0.15826085f, -0.15145646f, 0.15622054f, -0.00951837f, 0.03837146f, 0.03907442f, 
    -0.02991410f, -0.05130936f, -0.02180006f, 0.04524424f, -0.23295958f, 0.15010034f, -0.07306138f, -0.03432284f, 
    0.15877615f, 0.09036252f, 0.01017714f, 0.17034425f, 0.15592529f, 0.01846792f, 0.05744735f, -0.06483804f, 
    0.00472523f, 0.05187619f, 0.06795097f, -0.03352837f, 0.20114125f, 0.11218625f, -0.07283285f, -0.00039371f, 
    -0.00637194f, -0.19862813f, -0.05386865f, 0.11256040f, -0.30918938f, 0.19009326f, -0.00124391f, -0.03428006f, 
    0.10086313f, 0.12514110f, 0.17189056f, -0.05537955f, 0.05576863f, 0.01413434f, 0.15118711f, -0.01346309f, 
    0.08113346f, -0.30307442f, -0.13796404f, 0.39453575f, -0.24831617f, 0.18984912f, 0.02918856f, -0.06067529f, 
    0.00606216f, 0.14976111f, -0.08710307f, -0.03859074f, -0.53362888f, -0.03761990f, 0.05931901f, -0.16982971f, 
    0.07576989f, -0.02066803f, 0.01395980f, 0.06712479f, 0.03880743f, 0.08052836f, -0.20686185f, 0.04135058f, 
    -0.19438088f, -0.15706819f, -0.02674545f, 0.10677940f, -0.19830662f, 0.14047305f, -0.29492310f, -0.13171804f, 
    -0.03469787f, -0.11464532f, -0.07362144f, 0.00866477f, -0.13756332f, 0.05999254f, 0.24430881f, -0.20785332f, 
    -0.00971298f, 0.00820045f, -0.02240890f, 0.05472507f, -0.08682494f, -0.16237818f, 0.00662701f, -0.25818053f, 
    -0.42717969f, 0.12046057f, 0.07618026f, -0.09033442f, -0.09035473f, 0.11261012f, 0.00409795f, 0.02075270f, 
    -0.14468643f, -0.09840843f, 0.04446821f, -0.04458280f, -0.32509717f, 0.38803783f, -0.07018123f, 0.20159546f, 
    0.08560569f, -0.05654029f, 0.10480648f, -0.02052851f, 0.07860075f, 0.03333301f, 0.16164091f, 0.05454610f, 
    0.04385677f, -0.03885811f, -0.29841262f, 0.30449790f, 0.14916545f, 0.03985271f, 0.12086622f, 0.05936286f, 
    -0.08460715f, 0.02429787f, -0.14093034f, 0.03598871f, 0.20628986f, -0.18919978f, -0.10430598f, -0.12110900f, 
    0.03979474f, -0.10329332f, 0.08502293f, 0.14231956f, -0.12163877f, -0.02503770f, 0.03791662f, 0.06874440f, 
    0.13839234f, -0.39669627f, -0.02507276f, 0.08548885f, -0.20004654f, 0.17506982f, -0.00845796f, -0.17600019f, 
    0.19050659f, 0.09388387f, 0.02557083f, 0.01724961f, 0.18249029f, 0.09089231f, -0.05250924f, -0.08393127f, 
    -0.02392687f, -0.08380550f, -0.12264257f, -0.13400449f, -0.01353497f, -0.08593094f, -0.31531224f, -0.16871423f, 
    -0.36263368f, 0.07443494f, 0.20722023f, -0.07723424f, -0.02995528f, 0.05604182f, -0.15037103f, -0.10688754f, 
    0.02274316f, -0.11963028f, -0.00744949f, -0.10520653f, -0.56463593f, 0.18792151f, 0.06672007f, -0.00391492f, 
    -0.06603865f, 0.05241054f, -0.04750006f, -0.08532172f, 0.13141143f, 0.05049221f, 0.14933351f, -0.14927527f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.11233637f, 0.08297291f, -0.02319525f, -0.01893061f, -0.02928541f, 0.00240295f, 0.05712420f, -0.15790203f, 
    0.00383018f, 0.00389797f, 0.17276631f, 0.08568778f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
