#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.93317854f, 0.07981126f, 0.26930434f, 0.17414595f, 0.10883272f, 0.36546606f, 0.53675067f, 0.35251632f, 
    0.00516685f, -0.27213585f, 0.32805857f, 0.18080673f, -0.06701827f, -0.29697701f, 0.02899618f, 0.03054708f, 
    -0.11337245f, 0.01737898f, -0.11181135f, -0.32151407f, 0.23537667f, 0.26115280f, -0.00330544f, -0.31844658f, 
    0.00903185f, 0.93355703f, 0.91786849f, 0.14057405f, -0.03977388f, -0.64625466f, -0.48532909f, -0.39692941f, 
    0.05097559f, 0.29843438f, 0.24507250f, 0.10051215f, 0.00825133f, -0.12053665f, 0.01896552f, -0.12563235f, 
    -0.09802047f, 0.26939356f, -0.31698763f, 0.01414314f, -0.47881052f, -0.31186697f, 0.29365453f, -0.40832749f, 
    -0.09119726f, -0.53467709f, -1.08730030f, -0.19356847f, 0.23584308f, -0.56036133f, -0.14300412f, -0.14342010f, 
    0.05226086f, 0.32893971f, -0.22883749f, -0.02014096f, 0.62844890f, 0.28963292f, -0.14683154f, 0.18407017f, 
    -0.17764853f, -0.18887255f, -0.52013820f, -0.19884790f, -0.10992682f, -0.31918150f, -0.15493827f, 0.43848279f, 
    0.23774077f, -0.30480438f, -0.24468483f, -0.92013687f, -1.11029673f, -0.12179166f, 1.00358629f, 0.66045970f, 
    0.64835578f, -0.66195899f, -0.84903216f, -0.46887755f, -0.25115767f, -0.39095512f, 0.01355498f, -0.32879055f, 
    0.36787990f, -0.67187214f, 0.02209269f, -0.02357356f, 0.22633111f, 0.12774599f, -0.07818071f, -0.09135126f, 
    -0.15186514f, -0.14445183f, -0.02263051f, -0.10225666f, 0.92667693f, -0.59919065f, -0.41481161f, -0.02673818f, 
    0.15231501f, -0.17412286f, 0.19994044f, 0.33417764f, -0.11128154f, -0.03858783f, -0.10160548f, 0.00759047f, 
    -0.26945290f, 0.42375040f, -0.02467748f, -0.10660349f, -0.18279329f, 0.01142643f, 0.22448260f, 0.12304252f, 
    0.18860063f, -0.17154169f, 0.17736112f, 0.36800110f, 0.24055132f, 0.24814045f, -0.47830716f, 0.03233924f, 
    0.29978132f, -0.20080319f, 0.57665730f, -0.34916648f, 0.46261641f, 0.38455632f, 0.04412201f, -0.13991494f, 
    -0.15591337f, -0.08377174f, -0.19502336f, -0.32701999f, 0.01490370f, 0.04026433f, -0.23056035f, -0.21235439f, 
    0.00142685f, -0.48525006f, -0.11836043f, 0.07370996f, 0.29656744f, 0.42219341f, -0.60760987f, -0.16718861f, 
    0.18469380f, -0.02310160f, 0.14949188f, 0.26228672f, 0.27293646f, -0.24211255f, 0.47518766f, 0.26448122f, 
    -0.38222730f, 0.24130233f, 0.44227535f, -0.18249109f, -0.13737203f, -0.35651389f, -0.31880844f, 0.30586472f, 
    0.17747334f, 0.58458292f, 0.01608395f, -0.08158591f, -0.10941284f, 0.22683984f, -0.20412135f, -0.24191719f, 
    -0.59650284f, -0.61062282f, 0.09136358f, -0.41323471f, -0.45771715f, -0.69871092f, -0.60792077f, -0.00748826f, 
    -0.18158443f, 0.00353820f, -0.20065284f, 0.09351519f, 0.54095906f, -0.30243814f, -0.18161410f, 0.04558332f, 
    -0.17929666f, -0.04678171f, -0.45567861f, -0.28836307f, -0.11269513f, -0.22241437f, -0.38824996f, -0.31602225f, 
    0.41087875f, 1.11454308f, 0.57964295f, -0.61494690f, 0.17390563f, -0.57433426f, -0.24316481f, 0.13666944f, 
    -0.01420176f, -0.54110712f, -0.38804686f, 0.01353675f, 0.49418566f, -0.17788176f, -0.33613917f, 0.14734794f, 
    -0.12125596f, 0.12864968f, 0.22868258f, -0.26880664f, -0.22866087f, 0.10325488f, -0.06251603f, 0.03338717f, 
    0.20052962f, -0.41699299f, -0.03796535f, -0.13097066f, 0.15916510f, -0.13058883f, 0.31614178f, 0.17308253f, 
    -0.21610308f, -0.34304914f, -0.11230136f, 0.39898562f, -0.29477373f, 0.28671202f, -0.47685504f, 0.22882143f, 
    -0.25046444f, -0.17119420f, -0.20127952f, 0.43745691f, -0.26488271f, 0.18634488f, -0.05857786f, -0.23743881f, 
    0.22490342f, 0.66005814f, -0.19842313f, 0.37583673f, -0.67460197f, -0.29359671f, 0.02252305f, -0.18435186f, 
    -0.08323443f, 0.25902376f, 0.56288368f, 0.01218787f, 0.04625944f, -0.13100490f, -0.20494311f, 0.49775431f, 
    -0.37912968f, -0.40103939f, -0.36958697f, -0.06908735f, 0.12378111f, -0.38437170f, 0.20595588f, 0.44999841f, 
    0.17288123f, 0.18054813f, 0.33408108f, -1.08883321f, -0.57746297f, -0.60719401f, -0.49257505f, -0.27157965f, 
    0.73513275f, 0.06113367f, 0.38476562f, 0.40939054f, 0.90841490f, 0.22827576f, 0.08934974f, 0.14964440f, 
    0.07529498f, 0.13825996f, 0.00912934f, 0.14146040f, -0.13481767f, -0.15439139f, -0.16856571f, 0.00018566f, 
    -0.00578854f, 0.03160366f, 0.02231323f, -0.06346306f, -1.21285212f, -0.12995665f, -0.39407387f, -1.03895974f, 
    -0.44296595f, 0.42713824f, 0.08782808f, -0.13179643f, 0.15291058f, 0.41640562f, -0.46296069f, -0.49397248f, 
    -0.53234011f, -0.42475703f, -0.00431795f, 0.00518889f, 0.11098157f, 0.01395956f, 0.30804518f, 0.13068716f, 
    -0.01812094f, -0.18869840f, -0.07872166f, 0.24379478f, -0.12836611f, 0.37969500f, -0.04563068f, -0.54292440f, 
    -0.42107782f, -0.85046375f, -0.23640268f, -0.09639043f, 0.29365698f, -0.50894374f, -0.33622310f, -0.25456932f, 
    -0.31994706f, 0.23616050f, -0.07056569f, 0.00053822f, 0.18180616f, 0.15141997f, 0.20768756f, -0.21750008f, 
    -0.15181971f, 0.28442311f, 0.18980603f, -0.10712186f, 0.21196637f, 0.54737741f, -0.63700789f, 0.01476060f, 
    0.30864263f, 0.71845669f, 0.23684527f, 0.41936383f, -0.26002458f, 0.01427610f, -0.19130647f, 0.23114295f, 
    -0.19060619f, 0.38252708f, -0.27505863f, 0.14569736f, -0.11836393f, -0.38699377f, -0.34102762f, 0.11658597f, 
    0.12831031f, 0.36504337f, -0.29440644f, 0.23496576f, 0.30361506f, -0.14211659f, -0.11207400f, 0.99531603f, 
    -0.87080783f, -1.05525148f, -0.63555849f, -0.84260750f, 0.51934457f, 0.67227048f, -0.08138123f, 0.08119401f, 
    -0.10898661f, 0.19780238f, 0.62476754f, -0.02912690f, -0.41112292f, -0.31569052f, -0.22255853f, -0.03203664f, 
    0.28422314f, -0.02122887f, 0.19657426f, -0.04799095f, -0.08608524f, 0.00769977f, 0.21716617f, -0.28792781f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.11690524f, 0.42840511f, 0.37924924f, 0.00858991f, 0.17515169f, 0.33751336f, 0.05884231f, -0.26274264f, 
    0.14708148f, 0.37593043f, 0.12688966f, 0.24413134f, -0.10657205f, 0.04234982f, 0.21353111f, 0.51531732f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.18190305f, -0.03374155f, 0.03207904f, 0.10994347f, -0.00334651f, -0.10538644f, 0.00939812f, -0.02916687f, 
    0.08257098f, -0.07029335f, 0.05511419f, 0.06873035f, 0.19451481f, -0.05022074f, -0.28338596f, 0.14877513f, 
    -0.01871988f, 0.01127916f, 0.06342880f, 0.05526492f, 0.15348580f, -0.00831500f, 0.17168038f, -0.12938756f, 
    0.05520443f, 0.10846446f, 0.15549292f, 0.04304730f, 0.19429950f, -0.08003943f, -0.00149752f, 0.05141731f, 
    0.13204718f, -0.06707633f, 0.07222883f, -0.01429872f, -0.26327607f, 0.36621574f, 0.12858592f, -0.06264091f, 
    0.00100252f, 0.14937532f, -0.09923091f, 0.06751464f, -0.14526355f, 0.08431789f, -0.01619018f, 0.02182386f, 
    -0.04363527f, -0.00277082f, -0.09391129f, -0.06140492f, -0.07240824f, 0.12014624f, 0.11488868f, -0.15802348f, 
    0.21350688f, 0.19013123f, 0.00708404f, 0.09223840f, 0.15561795f, -0.00924698f, 0.16001302f, -0.04331909f, 
    0.04975960f, 0.00915699f, -0.07421465f, -0.00536592f, -0.07352802f, -0.14686768f, 0.00259748f, 0.11164940f, 
    0.08104447f, 0.07520448f, 0.03240768f, -0.21037871f, -0.10290606f, 0.13243406f, -0.25036690f, 0.00567151f, 
    0.08854976f, -0.05260611f, 0.02263812f, -0.10000605f, -0.11682674f, -0.03439931f, 0.07741085f, 0.07325196f, 
    -0.16203731f, 0.22246258f, 0.03151851f, 0.05783117f, -0.01117775f, -0.04936810f, -0.16170524f, 0.05106416f, 
    -0.32853219f, 0.31161922f, -0.66728109f, 0.39469081f, 0.11296298f, 0.14630541f, -0.06164147f, -0.06199779f, 
    0.04547466f, 0.15310436f, -0.02844403f, 0.12831579f, 0.11441499f, -0.10244776f, 0.28315452f, 0.11874837f, 
    -0.19320472f, 0.07808568f, 0.04687546f, -0.00946526f, 0.10528322f, 0.03389762f, 0.05062243f, 0.13453472f, 
    0.21437426f, 0.22789979f, 0.03683013f, 0.20600820f, -0.16410242f, -0.02348180f, 0.13707615f, -0.14872706f, 
    -0.00188142f, 0.13387343f, 0.16315614f, 0.21808656f, 0.33778116f, -0.31743288f, -0.08669598f, -0.43084681f, 
    0.14199486f, -0.04624425f, -0.13013834f, -0.05668913f, -0.05360484f, 0.06515335f, 0.14114201f, -0.02966113f, 
    -0.14608903f, -0.13340311f, -0.24277829f, -0.12661190f, 0.00739158f, -0.21728297f, -0.05072161f, 0.15036240f, 
    -0.00690920f, -0.08827734f, -0.09957920f, 0.00883131f, -0.07527591f, -0.17381729f, -0.32980981f, 0.08078637f, 
    0.23602472f, 0.05575697f, 0.08763187f, 0.23305155f, -0.00030848f, 0.09416728f, 0.06882723f, 0.10961015f, 
    0.02873645f, -0.12306179f, 0.14060748f, 0.08814508f, -0.00637022f, 0.02536430f, -0.08461636f, 0.05632807f, 
    0.15862940f, 0.05145661f, -0.07636716f, -0.13848679f, -0.03013975f, -0.16183800f, -0.02474900f, -0.11953090f, 
    0.06147039f, 0.15759957f, 0.01633630f, -0.08782428f, 0.04005503f, -0.11021500f, 0.12960863f, -0.04088168f, 
    0.03632405f, -0.06138845f, -0.03024576f, 0.04602779f, -0.01261119f, -0.07366078f, -0.04233846f, 0.05552361f, 
    0.01247218f, -0.07813700f, 0.05050103f, -0.00412800f, -0.05200576f, -0.00793631f, -0.02863676f, 0.02978809f, 
    0.00577788f, -0.02164054f, -0.07443747f, 0.06268617f, 0.05011735f, 0.03873460f, -0.03704106f, -0.02119987f, 
    -0.02874046f, 0.01393069f, 0.00185779f, 0.01188570f, 0.05301832f, 0.03502533f, -0.06512614f, -0.07581973f, 
    -0.06840425f, -0.06608605f, 0.01317393f, -0.00231435f, -0.06077520f, -0.03521481f, -0.02791611f, 0.00140800f, 
    -0.02784631f, -0.04902983f, -0.07978594f, -0.01301795f, 0.02201230f, 0.05586528f, 0.05265985f, -0.01885657f, 
    -0.00270837f, 0.01590461f, -0.06541800f, 0.00565350f, 0.03538046f, -0.06857496f, -0.01879245f, -0.07800013f, 
    -0.04737778f, -0.01725823f, -0.02033908f, 0.03672589f, -0.04217537f, 0.01886243f, -0.03922758f, 0.01487141f, 
    -0.04157226f, 0.05121648f, 0.02970828f, 0.04102078f, 0.05116734f, 0.01845372f, 0.05265578f, -0.03532247f, 
    -0.06656306f, 0.02711711f, 0.06355081f, 0.03136001f, 0.00701825f, -0.05500971f, 0.00293245f, 0.02006039f, 
    -0.01485304f, -0.00010333f, 0.06148546f, -0.04012281f, -0.05624952f, 0.06285851f, -0.05384275f, 0.01409814f, 
    -0.04255940f, -0.05919600f, -0.01096800f, 0.03552838f, 0.04483936f, -0.06827492f, 0.05605727f, -0.04259399f, 
    -0.05411671f, -0.06247910f, -0.00289336f, -0.07418038f, 0.03396870f, -0.02996103f, -0.05497057f, -0.01473827f, 
    -0.02544250f, 0.02686466f, 0.05770227f, -0.07360890f, -0.00502098f, -0.04979996f, 0.00009838f, -0.06787573f, 
    0.03136158f, 0.00405570f, -0.07083973f, -0.05024879f, -0.03894624f, -0.04445556f, 0.04382994f, -0.04651431f, 
    0.03807678f, -0.05937105f, 0.06787481f, 0.00947393f, -0.07274014f, -0.03979815f, -0.02500598f, -0.04522619f, 
    -0.01044170f, 0.05283176f, -0.00361372f, 0.02163309f, -0.05791356f, -0.06060104f, 0.00189889f, 0.06217002f, 
    0.02108822f, -0.04200406f, -0.00780291f, -0.02832488f, 0.06557789f, -0.00014325f, 0.05845782f, -0.05916660f, 
    0.01206087f, -0.06024215f, 0.01519365f, 0.04119102f, -0.03433282f, 0.04260397f, 0.00865074f, -0.06897007f, 
    0.03483219f, 0.02811987f, -0.07197482f, 0.01215454f, -0.01066059f, -0.06850292f, 0.04853565f, 0.01335491f, 
    0.04491717f, -0.00868573f, 0.05834160f, 0.04306313f, 0.01269444f, -0.02728706f, -0.01079240f, 0.00851443f, 
    0.02809999f, 0.00700640f, -0.05735912f, -0.04162642f, -0.00106944f, -0.04433303f, -0.00397459f, 0.00299678f, 
    -0.04172377f, 0.05384932f, -0.05048511f, -0.02288740f, -0.01186780f, -0.06227801f, -0.02350824f, -0.04663015f, 
    0.02922760f, -0.06981067f, -0.01545685f, -0.00971586f, -0.05079923f, 0.00360605f, -0.05485961f, 0.03860119f, 
    0.43224862f, -0.07210527f, 0.14946587f, -0.04215088f, -0.10900109f, 0.00205725f, 0.02534761f, -0.04133245f, 
    0.02926628f, -0.08792911f, -0.07584267f, -0.02366899f, 0.59138793f, 0.11917631f, -0.30174646f, -0.08742618f, 
    0.02907836f, 0.01020631f, 0.09027455f, 0.15241313f, 0.06122079f, -0.03775819f, 0.11138616f, -0.01391368f, 
    -0.29172134f, 0.16912344f, 0.18525007f, 0.04926213f, -0.00249235f, -0.04890707f, -0.02733657f, 0.12854357f, 
    0.00825514f, -0.11500685f, 0.01601598f, 0.20258351f, -0.02738286f, -0.52526826f, 0.02012417f, 0.05436554f, 
    0.06358529f, 0.05263581f, -0.01127772f, 0.20885499f, 0.13334933f, 0.06721304f, -0.02615009f, 0.02471182f, 
    0.16515312f, -0.02811193f, -0.03468376f, -0.08972504f, -0.01403912f, 0.01964977f, 0.07712444f, 0.18883581f, 
    -0.02100768f, 0.03710969f, -0.01814771f, 0.01954538f, 0.35715073f, 0.06729898f, -0.15158428f, 0.18372688f, 
    -0.02022741f, 0.04266160f, 0.12184128f, 0.10299451f, 0.08300065f, 0.12823097f, 0.02682241f, -0.10490420f, 
    -0.15203398f, 0.07572225f, 0.17847103f, 0.01408090f, -0.16301508f, -0.11326902f, -0.03217281f, -0.08023050f, 
    -0.08561642f, -0.02821427f, -0.08360530f, 0.26405400f, -0.03304413f, 0.22402582f, 0.09591115f, 0.06455103f, 
    -0.11565392f, -0.10075579f, 0.08196647f, 0.07386240f, 0.13459717f, 0.14696479f, 0.05447274f, -0.00407808f, 
    -0.03617530f, 0.16129054f, -0.63969976f, -0.17681964f, 0.18929279f, -0.02232945f, 0.16625039f, -0.07136048f, 
    -0.03075228f, -0.03599919f, -0.06101816f, 0.08024178f, 0.07024357f, -0.05862796f, 0.14727573f, 0.02178930f, 
    0.08077049f, 0.04599245f, 0.17608106f, 0.09642707f, 0.11420614f, 0.07857542f, 0.01569304f, 0.00273452f, 
    -0.06236054f, 0.28722513f, 0.15515278f, -0.29465941f, -0.14946052f, -0.22450180f, 0.30597508f, 0.07270673f, 
    0.05910268f, 0.04197798f, -0.09310415f, -0.07140130f, 0.18192348f, 0.36908603f, 0.18139622f, -0.09904660f, 
    -0.15875190f, -0.20977075f, -0.13804863f, -0.04333143f, 0.01563159f, 0.00114170f, 0.21103206f, -0.00900891f, 
    -0.22583370f, 0.07243916f, 0.09330053f, -0.11990980f, -0.05977789f, -0.01353013f, -0.00534722f, -0.02885601f, 
    0.03150539f, 0.02321178f, -0.05865423f, -0.20419207f, 0.12747580f, 0.21528935f, 0.02864048f, -0.22984888f, 
    0.07356431f, -0.15169397f, 0.16042404f, 0.13949889f, -0.06700256f, 0.01136309f, -0.02324783f, -0.03467384f, 
    0.02033111f, -0.19782230f, 0.08782671f, 0.21083811f, -0.03362511f, 0.15178587f, 0.01219152f, -0.08440028f, 
    0.00116398f, 0.03777334f, 0.00886036f, 0.07941544f, 0.28056031f, 0.13141580f, 0.46293920f, -0.34521514f, 
    0.06700881f, -0.07792681f, 0.01487562f, 0.16177706f, -0.06039391f, -0.07557239f, -0.18560056f, -0.08124959f, 
    -0.01181350f, 0.21180724f, 0.03956532f, -0.26288855f, -0.27642488f, -0.21696015f, -0.09628734f, -0.04913436f, 
    -0.03384894f, 0.00173327f, 0.01192362f, -0.09413088f, -0.02470674f, 0.04336645f, 0.49232250f, -0.03683851f, 
    0.17553507f, 0.00154803f, -0.14372328f, -0.07040978f, 0.03108216f, -0.03758011f, 0.06501420f, 0.17348298f, 
    0.02150990f, -0.05740086f, -0.11655441f, 0.17536956f, 0.00779431f, 0.02093903f, 0.01819265f, 0.11895464f, 
    0.04949882f, 0.04814533f, 0.11206611f, 0.13538413f, -0.10086411f, -0.46253577f, 0.30064690f, 0.02638599f, 
    0.11903415f, -0.05761985f, 0.03813941f, 0.10390061f, 0.05993146f, -0.09635793f, -0.00162507f, 0.02935044f, 
    0.20839441f, -0.07606701f, 0.14329790f, -0.01660932f, -0.05344236f, 0.29170513f, 0.02219304f, 0.18365285f, 
    -0.18143840f, -0.04028431f, 0.12189943f, 0.14770918f, 0.09055427f, 0.13545407f, -0.11838751f, 0.07510531f, 
    0.10456847f, -0.00769634f, 0.09554237f, -0.04406404f, 0.16492006f, 0.13677326f, -0.06322891f, -0.09708488f, 
    0.09886721f, 0.10338590f, -0.26759571f, -0.02068195f, -0.07170043f, -0.02186558f, 0.26181328f, -0.00430165f, 
    -0.03205720f, 0.15208846f, -0.06508731f, -0.02464751f, -0.21644369f, 0.05140207f, -0.02720160f, 0.13502406f, 
    -0.07721807f, -0.13333452f, 0.15838924f, 0.01226117f, 0.01071290f, -0.09058071f, 0.01217634f, -0.06128486f, 
    0.48801652f, 0.15938006f, 0.51761538f, -0.28504622f, 0.05422541f, -0.07190375f, 0.00767692f, -0.01337376f, 
    -0.10722774f, -0.04055047f, 0.06150863f, -0.03526723f, -0.05696345f, 0.06858283f, -0.09107570f, 0.09410383f, 
    0.13088264f, 0.12162013f, -0.06458277f, 0.18560642f, -0.01784139f, 0.20271727f, 0.01812997f, -0.07477073f, 
    -0.32643944f, 0.02096984f, 0.09247551f, -0.18762486f, 0.01281016f, -0.09237406f, -0.07608111f, 0.20753695f, 
    -0.02669402f, -0.02079570f, -0.04181778f, 0.09341402f, 0.12642179f, 0.19291005f, -0.20468177f, 0.07355202f, 
    -0.15936399f, -0.09663394f, 0.05931894f, -0.03785169f, 0.01669214f, -0.03705386f, -0.08864184f, -0.02789805f, 
    -0.14760821f, 0.01018212f, 0.17507713f, 0.09777901f, -0.09598152f, 0.07604311f, -0.00162993f, -0.00903824f, 
    0.05569901f, 0.05484718f, -0.12386899f, -0.15021068f, -0.07235736f, 0.13598739f, 0.24113083f, -0.12664534f, 
    -0.08650617f, 0.04319989f, -0.02920706f, 0.07440912f, -0.02304738f, -0.13827933f, -0.14547466f, 0.02529330f, 
    0.04106411f, 0.35003972f, -0.37800854f, -0.37957346f, -0.03355326f, -0.10944720f, 0.08508977f, -0.11848953f, 
    -0.07694787f, 0.11240945f, 0.03470782f, 0.04207989f, -0.01546340f, 0.08023304f, 0.19915190f, 0.15336432f, 
    -0.04205254f, -0.18911701f, 0.15325347f, 0.14263833f, 0.13880004f, 0.03740996f, -0.12482925f, 0.04604646f, 
    -0.06128080f, -0.05768989f, 0.02267452f, -0.06426384f, 0.00467640f, -0.01008120f, -0.00836336f, -0.02136773f, 
    -0.06284036f, 0.02217918f, -0.06384240f, -0.05104555f, -0.07361162f, -0.00848486f, 0.03345675f, 0.05525645f, 
    0.01539453f, 0.01788727f, -0.04010533f, -0.00291372f, 0.03464777f, -0.05235469f, -0.01627920f, 0.00621915f, 
    0.00366904f, -0.00976366f, -0.01755686f, 0.02403734f, -0.05338975f, 0.04084245f, -0.01296275f, -0.00394277f, 
    -0.00060598f, -0.02851016f, 0.04293601f, -0.02968456f, -0.03556843f, 0.02105230f, -0.03194417f, 0.02351774f, 
    -0.06890666f, 0.06427603f, 0.05773561f, -0.00333955f, 0.03561499f, -0.07654011f, 0.02865490f, 0.01127544f, 
    -0.03193790f, -0.00270276f, -0.05233252f, 0.02803475f, 0.01325884f, -0.02753779f, -0.04272022f, -0.00503245f, 
    0.01834299f, -0.05036557f, -0.06086269f, -0.02089774f, 0.01109226f, -0.05662497f, -0.05758927f, -0.04929102f, 
    0.02839557f, -0.06185533f, -0.02310925f, -0.02905566f, -0.02087543f, -0.04016843f, 0.01243143f, 0.04544589f, 
    -0.01301499f, -0.07852890f, -0.07646546f, -0.01543638f, -0.00955457f, -0.05417685f, 0.04301375f, -0.02761484f, 
    0.04429332f, 0.05301722f, -0.02321046f, -0.00633739f, -0.02620825f, -0.02441431f, -0.04926225f, 0.01069147f, 
    -0.06881288f, -0.01424413f, 0.03495569f, 0.04277251f, -0.01554915f, 0.00458793f, -0.05768693f, 0.03656377f, 
    0.01174749f, 0.00501680f, -0.03198065f, 0.02040780f, -0.03952425f, -0.02154593f, -0.03693999f, 0.00820620f, 
    -0.02784964f, 0.05623081f, -0.08073327f, 0.02079229f, 0.01611803f, 0.05616118f, -0.03799202f, 0.02489861f, 
    -0.05277330f, 0.01144585f, 0.03898712f, -0.04470806f, -0.06143399f, -0.01851559f, -0.00451964f, -0.01582048f, 
    0.02272153f, -0.06481304f, -0.02216885f, -0.07048672f, 0.04109672f, -0.03011672f, -0.03235281f, 0.04124642f, 
    -0.04979104f, 0.01573953f, -0.07205101f, 0.05449104f, 0.05453556f, 0.04988141f, -0.00971191f, -0.05368381f, 
    -0.05328083f, -0.02903968f, -0.00632201f, -0.07244121f, -0.02556298f, 0.00212874f, -0.03404732f, -0.02031514f, 
    -0.01986532f, 0.02693333f, 0.06644246f, 0.04500501f, -0.00202598f, -0.06136735f, -0.06706612f, 0.00204190f, 
    -0.00601270f, -0.00649559f, -0.02069603f, 0.05692323f, 0.01754282f, 0.05882800f, -0.03054474f, -0.03093201f, 
    -0.07515480f, -0.01942120f, 0.01525235f, 0.04844911f, 0.04096408f, -0.07027858f, 0.03093826f, -0.05250970f, 
    0.06172570f, 0.04563496f, -0.02687125f, -0.07715899f, -0.04930243f, 0.05618388f, 0.00262923f, 0.00025618f, 
    0.01311865f, -0.02644168f, -0.07669699f, 0.01511251f, 0.00567990f, -0.03480053f, 0.00194717f, 0.02969112f, 
    -0.04909048f, -0.03535369f, 0.01375926f, 0.05364847f, -0.00801048f, -0.03591827f, -0.02139419f, -0.00083702f, 
    0.21459261f, 0.12380692f, 0.17195307f, 0.10460353f, -0.21140151f, -0.08746658f, -0.13005550f, -0.16291356f, 
    -0.01772476f, 0.20732197f, -0.20380326f, -0.03532453f, -0.35976538f, 0.14741354f, 0.41290841f, 0.01321162f, 
    -0.02282420f, -0.09302539f, -0.18027970f, 0.04199893f, 0.16486339f, 0.00647061f, -0.01008453f, 0.01758502f, 
    -0.02029375f, -0.18550463f, -0.16417450f, 0.07572574f, 0.03248421f, 0.11023922f, -0.07421701f, 0.23592244f, 
    0.09515296f, 0.13936588f, -0.01547107f, -0.00572156f, -0.21186498f, 0.10895051f, -0.16393942f, -0.12889761f, 
    0.09269455f, -0.08720656f, 0.10485342f, 0.05684689f, 0.11533030f, -0.13312139f, -0.00019230f, -0.00740235f, 
    0.10046941f, 0.10560571f, 0.03033762f, 0.01485279f, 0.18034594f, -0.08550333f, 0.13272496f, -0.26965645f, 
    -0.08482423f, -0.03888831f, 0.12611634f, -0.02150696f, 0.22727825f, 0.39873740f, 0.06106237f, -0.19697870f, 
    -0.04359963f, -0.02213255f, 0.11891627f, -0.03428967f, 0.06941968f, 0.11120807f, -0.15130244f, 0.03736891f, 
    0.05179004f, -0.07844119f, -0.21123753f, -0.10209007f, -0.06661224f, 0.01283754f, -0.11765254f, -0.15829808f, 
    0.12180924f, -0.00176908f, 0.03565774f, 0.13801235f, -0.10500097f, -0.08483934f, -0.10141888f, -0.05090213f, 
    0.06313236f, -0.11001697f, 0.01353430f, 0.20148124f, -0.10437071f, -0.04958348f, 0.14372215f, -0.05194918f, 
    0.06391633f, 0.01835615f, 0.11903468f, 0.12359288f, -0.15626565f, -0.22718136f, 0.09870515f, -0.16616087f, 
    0.06561028f, 0.03619706f, 0.05210027f, -0.06776080f, -0.10530832f, -0.18330160f, -0.19839391f, -0.13249885f, 
    -0.03624027f, 0.19069983f, -0.03023894f, 0.16743170f, 0.18814901f, 0.02861800f, 0.19426937f, 0.03411562f, 
    -0.21512668f, -0.03091413f, 0.02379050f, 0.09330115f, 0.13911992f, 0.01397984f, 0.19398682f, -0.01173855f, 
    0.01679885f, 0.04269034f, 0.20581391f, 0.11407817f, 0.33555946f, -0.21717210f, -0.08314575f, -0.08821267f, 
    -0.07968691f, 0.06768140f, -0.01093715f, -0.15862167f, -0.17933314f, 0.08364040f, 0.00853659f, 0.04382870f, 
    0.38819671f, 0.03098361f, 0.10367087f, 0.03863354f, 0.09872915f, 0.09144747f, -0.11055031f, -0.04767904f, 
    -0.04376459f, -0.06826614f, -0.03597815f, -0.05327744f, 0.01688885f, -0.11995899f, -0.01206980f, -0.00802645f, 
    -0.00537762f, 0.13943876f, 0.11344685f, -0.10919742f, -0.03790018f, 0.12126227f, -0.02007192f, 0.03181133f, 
    0.29486609f, 0.22774489f, -0.02154400f, -0.25167671f, -0.12912230f, -0.22276366f, -0.14797145f, 0.00952164f, 
    -0.14283575f, -0.03904516f, 0.10050276f, -0.03255558f, 0.11152592f, 0.03496346f, -0.08346707f, 0.09376255f, 
    -0.06484143f, 0.14269096f, 0.27607042f, 0.01592546f, 0.16522805f, -0.04983044f, -0.06992791f, 0.14296497f, 
    -0.15272939f, 0.06890045f, 0.02191602f, 0.06826295f, -0.24051844f, -0.11825772f, -0.14255644f, -0.06515846f, 
    -0.06131708f, 0.05178529f, -0.05490205f, -0.07747574f, -0.24676816f, 0.09581224f, 0.54163080f, -0.06055825f, 
    -0.06597269f, -0.10535498f, -0.10369845f, 0.08061988f, 0.00974485f, 0.04305303f, -0.02017548f, -0.06088963f, 
    0.11257754f, -0.10244321f, -0.08914072f, 0.03792136f, 0.14221242f, 0.08329590f, 0.03016421f, 0.25763735f, 
    0.02562912f, 0.17323458f, 0.02659190f, -0.01551701f, -0.20641416f, 0.28359258f, -0.27944484f, 0.07614407f, 
    0.05185850f, -0.03093173f, 0.17534988f, 0.01008059f, 0.16985406f, -0.06469011f, -0.03409278f, 0.05853556f, 
    -0.13170779f, 0.04776031f, 0.06222235f, 0.06759427f, 0.03299889f, -0.00069195f, 0.01972728f, -0.07028274f, 
    -0.14408530f, 0.08085209f, 0.21515930f, 0.00873227f, 0.09383290f, 0.32299161f, 0.10324983f, -0.08509704f, 
    -0.00477167f, -0.06211076f, 0.09339800f, -0.13519686f, 0.01318598f, -0.00501362f, -0.06162191f, 0.28142098f, 
    0.00295518f, -0.16154194f, -0.17973948f, -0.00571669f, 0.01371786f, 0.03272691f, -0.14781266f, -0.17498098f, 
    0.11667065f, -0.05773908f, 0.13607615f, -0.02410592f, -0.09172916f, -0.15780516f, -0.20987587f, 0.05342096f, 
    0.02562612f, -0.17876108f, -0.07665028f, 0.07719422f, 0.01311380f, -0.03251649f, 0.09615603f, -0.10674682f, 
    0.21255025f, -0.06340431f, 0.27387249f, 0.02930116f, -0.06568462f, -0.04041651f, 0.00396554f, -0.15809013f, 
    -0.00238608f, 0.01856772f, 0.09615055f, 0.07509725f, -0.10830420f, -0.10721698f, -0.05401261f, 0.05434572f, 
    0.00216700f, 0.28846288f, 0.06642819f, 0.12025956f, 0.36956507f, 0.06807246f, 0.37031356f, 0.19960316f, 
    0.12841468f, -0.07640625f, -0.00338248f, 0.09000660f, 0.03653268f, 0.00817933f, 0.11420005f, 0.03226444f, 
    0.05196496f, 0.19669151f, 0.24271858f, 0.08844511f, 0.02101250f, -0.35236853f, -0.19361214f, -0.06299546f, 
    -0.02352156f, -0.01239734f, -0.01156687f, -0.09339725f, -0.14788532f, 0.04938076f, 0.00351713f, -0.04998844f, 
    0.40054744f, 0.09609878f, 0.15114123f, 0.01471908f, 0.03614270f, 0.03193133f, 0.08410181f, 0.06201721f, 
    0.03746192f, -0.01281385f, 0.07357472f, -0.10940536f, 0.02292403f, -0.08171008f, -0.00089938f, 0.09252864f, 
    0.06156037f, 0.18054672f, 0.12994871f, 0.00342935f, -0.06287079f, 0.17540091f, 0.07246785f, 0.00460930f, 
    -0.05074544f, 0.38191071f, -0.19139102f, -0.33296469f, -0.14659110f, -0.15525058f, -0.13379081f, 0.12088815f, 
    -0.04594506f, 0.06223180f, 0.09677330f, -0.15422189f, 0.08251657f, -0.00500711f, -0.02992722f, 0.17579286f, 
    -0.02705372f, 0.18068767f, 0.06463791f, 0.12116083f, -0.01675967f, 0.05172246f, 0.03856146f, -0.00129454f, 
    0.11140059f, -0.02644743f, 0.21966995f, -0.08456270f, -0.21100673f, -0.02669035f, -0.08131351f, -0.09517281f, 
    -0.10115701f, 0.01320337f, -0.01319384f, 0.15305184f, -0.00047080f, 0.46992934f, -0.06795056f, -0.07789336f, 
    0.11011896f, -0.09392505f, 0.15897743f, 0.05004902f, -0.04014648f, -0.07767390f, 0.00231297f, 0.05729696f, 
    -0.24324639f, 0.02673373f, -0.11909156f, 0.04756618f, -0.04216950f, -0.07858523f, -0.04856096f, 0.11620729f, 
    0.07902832f, 0.09976245f, -0.13648878f, 0.15180479f, -0.01037126f, -0.27444723f, -0.15718447f, -0.05643740f, 
    0.05923972f, 0.02358490f, -0.03330442f, -0.02037454f, 0.18690754f, 0.01116010f, -0.07042463f, 0.09176951f, 
    0.33613572f, -0.09072566f, 0.05669624f, -0.10895097f, 0.20997572f, 0.02934902f, -0.06261484f, 0.01701958f, 
    -0.07088945f, -0.09830640f, 0.08880716f, -0.00166855f, 0.32428023f, 0.33626950f, -0.10854881f, 0.20826939f, 
    -0.04977667f, -0.14858441f, 0.06968547f, -0.03866703f, 0.16478507f, 0.09308254f, -0.01835617f, 0.05425029f, 
    -0.19781755f, 0.11370232f, -0.08234068f, -0.11865710f, -0.05060584f, -0.04937569f, 0.03788525f, -0.11446023f, 
    0.08924828f, -0.09120698f, -0.14586411f, 0.10920585f, -0.15363561f, 0.16009454f, -0.12861530f, 0.02152295f, 
    0.01354953f, -0.11986393f, 0.19937816f, 0.22341596f, -0.03596693f, 0.07784498f, 0.01740240f, -0.12519418f, 
    -0.17826848f, 0.02671542f, -0.40325859f, 0.02432518f, 0.17984401f, -0.11576565f, 0.22949739f, -0.01401516f, 
    -0.02333689f, -0.06232914f, 0.01135938f, 0.09185039f, 0.16149789f, -0.15969367f, -0.18084276f, 0.09481005f, 
    -0.01964108f, 0.12236812f, 0.01892196f, 0.15588509f, 0.27446511f, 0.01972828f, 0.16150182f, -0.03060561f, 
    -0.14172721f, 0.05779775f, 0.10760086f, -0.10563855f, 0.09662534f, -0.16341047f, 0.20626405f, 0.11261410f, 
    -0.05497459f, 0.00530405f, -0.02923329f, 0.22568466f, 0.25610685f, 0.19902675f, -0.20606378f, 0.01843723f, 
    -0.06896418f, -0.06989855f, -0.04879649f, -0.19121449f, -0.02571393f, 0.03060636f, 0.03416198f, 0.03025178f, 
    0.02425129f, 0.02842109f, 0.00349076f, -0.06815682f, -0.07611234f, 0.00107454f, -0.07376780f, -0.11773925f, 
    0.14357407f, -0.00538863f, -0.03816341f, -0.16416861f, 0.07757895f, -0.01657438f, 0.15995446f, -0.13299555f, 
    0.10471957f, 0.00447414f, 0.11341526f, 0.11540996f, -0.09320594f, 0.05637952f, -0.00410614f, -0.01815473f, 
    0.16230509f, -0.20917986f, 0.01025491f, -0.17566805f, -0.08419005f, 0.03027818f, 0.02187661f, -0.16928098f, 
    -0.14586820f, 0.04434704f, 0.07387066f, 0.16101348f, 0.23305210f, -0.05143284f, 0.34687772f, -0.04915827f, 
    0.03603878f, 0.00247332f, -0.00359466f, 0.08205426f, 0.08811339f, -0.13627669f, -0.06785919f, 0.10975423f, 
    -0.64314413f, -0.01342975f, 0.15340206f, -0.10649039f, -0.03909506f, 0.01354485f, -0.06278051f, -0.05187104f, 
    0.01291534f, -0.03089579f, 0.17781040f, 0.21086745f, -0.50766391f, 0.18746147f, -0.18918329f, 0.09225469f, 
    -0.06646930f, -0.05758685f, 0.07420357f, -0.15521334f, 0.02382364f, 0.16670351f, 0.02149950f, 0.14854881f, 
    0.23633227f, -0.03145799f, -0.03192778f, -0.00151519f, 0.13035527f, 0.09974619f, 0.12147439f, 0.00834708f, 
    0.07479127f, 0.09037188f, -0.05665397f, -0.03106434f, -0.06022396f, 0.48607728f, -0.15972134f, 0.24681303f, 
    -0.17126578f, 0.17073105f, -0.09459992f, -0.09051523f, 0.02815136f, 0.10687633f, 0.08998301f, 0.06675949f, 
    -0.23412192f, -0.24979135f, 0.03095120f, -0.15231073f, 0.06555514f, -0.15707867f, -0.19488010f, 0.09691484f, 
    0.04073485f, -0.11169145f, 0.02351357f, -0.00337989f, -0.21892269f, 0.15922755f, 0.25451815f, 0.13582881f, 
    0.03481602f, -0.04186500f, -0.07074025f, 0.04552021f, 0.04163685f, 0.04254015f, 0.13674742f, 0.03026961f, 
    -0.15338844f, -0.05574913f, -0.13716081f, -0.17958532f, 0.12468585f, -0.13157246f, -0.03401921f, -0.02038905f, 
    -0.00299272f, -0.08095624f, -0.01906532f, -0.13159120f, 0.04476771f, 0.00687187f, -0.12725115f, 0.09724027f, 
    0.19112898f, 0.09291636f, -0.08998256f, 0.03993277f, 0.10422581f, 0.10434195f, -0.05241189f, 0.07060163f, 
    -0.12756662f, 0.02307630f, 0.60084671f, 0.31621385f, -0.04342578f, 0.03150316f, 0.18193330f, 0.05605746f, 
    -0.03870512f, -0.04117092f, 0.06377397f, 0.06107089f, 0.02489103f, 0.03538538f, 0.06902138f, 0.36431244f, 
    -0.03743016f, -0.01930374f, -0.07602894f, 0.04333994f, 0.03708588f, 0.02000356f, 0.19757022f, -0.08127856f, 
    0.50525391f, 0.04647394f, 0.09410859f, 0.20409401f, -0.06913884f, 0.05116972f, -0.02678945f, 0.01736075f, 
    0.21309103f, 0.26946819f, 0.12656671f, 0.20342149f, -0.06739827f, -0.20251502f, -0.02803428f, 0.10813439f, 
    0.11747339f, 0.05729659f, 0.04449100f, 0.06217824f, -0.02826177f, 0.02342771f, -0.07328743f, 0.00176527f, 
    0.33521602f, -0.20235614f, -0.17350306f, 0.26609752f, 0.05263364f, -0.16868117f, 0.07487322f, -0.01416980f, 
    -0.03418073f, 0.04264382f, 0.03669713f, -0.00170815f, -0.15170987f, -0.28298879f, 0.15525527f, 0.56600410f, 
    -0.15328927f, 0.12195860f, -0.03291401f, 0.00470000f, 0.10483984f, -0.06728247f, 0.01540997f, 0.13204637f, 
    -0.12104421f, 0.09062281f, -0.10088884f, -0.11757480f, 0.03500905f, -0.09515572f, -0.09689312f, -0.07417520f, 
    0.00021253f, -0.02743612f, -0.09610181f, 0.09334829f, -0.47934669f, -0.21708544f, 0.19995336f, 0.34315887f, 
    0.15509447f, 0.07468039f, -0.16505703f, 0.09007876f, -0.17324546f, -0.18413927f, 0.05333561f, 0.06610179f, 
    -0.33590412f, -0.14120953f, -0.14965546f, -0.27665037f, 0.09404342f, -0.17979820f, -0.05875096f, -0.06634920f, 
    0.08918763f, -0.02032718f, 0.07966270f, 0.06542894f, 0.12808572f, 0.02339631f, -0.28851914f, -0.06568945f, 
    -0.15907209f, -0.13753614f, -0.02897625f, -0.17655562f, 0.01021836f, 0.02431257f, 0.02288423f, 0.07949641f, 
    0.22132185f, 0.14918193f, 0.26920599f, 0.14510527f, -0.02314533f, 0.01835220f, 0.17479776f, 0.08074962f, 
    0.15088513f, 0.02086636f, 0.07840835f, -0.11271252f, -0.30659899f, 0.24152760f, 0.15943766f, 0.13839920f, 
    0.04523117f, 0.07268376f, -0.09331899f, -0.06354556f, -0.10778476f, -0.07611369f, 0.01383046f, 0.04355330f, 
    -0.09856678f, -0.05469613f, 0.06920996f, -0.06115504f, -0.20302425f, -0.02635371f, -0.21962230f, 0.09000143f, 
    0.19934136f, 0.02146989f, -0.02420148f, 0.07136527f, -0.19564092f, -0.04522539f, 0.07263324f, 0.15571864f, 
    0.05710898f, 0.00077130f, -0.09914727f, 0.10931990f, 0.09765382f, 0.05629120f, 0.11162791f, 0.11789394f, 
    -0.09828062f, 0.00758289f, 0.01068722f, 0.02985907f, -0.01898081f, -0.06375231f, -0.02894051f, -0.04883009f, 
    -0.05073373f, 0.11338110f, 0.10254335f, -0.14349525f, -0.10701272f, 0.11436401f, 0.11470746f, 0.10310838f, 
    0.00248710f, 0.14606337f, 0.00836255f, -0.22057231f, 0.07861096f, 0.07409371f, -0.05850879f, 0.00276832f, 
    0.16343527f, 0.06870936f, 0.40674213f, -0.27114922f, -0.20364478f, 0.10630579f, 0.00345250f, -0.10807760f, 
    -0.08182251f, 0.04340419f, 0.04805332f, -0.06073663f, 0.06273391f, 0.08164181f, 0.25093389f, 0.21149582f, 
    -0.01324694f, -0.05333707f, 0.04652527f, 0.18496689f, -0.15822482f, 0.19926123f, 0.18782474f, 0.03212095f, 
    0.12561676f, 0.26058245f, -0.09492879f, -0.09917112f, -0.35389462f, -0.08813662f, -0.06691615f, -0.02167472f, 
    0.15101860f, 0.15962344f, -0.08054028f, -0.01968370f, -0.04345816f, 0.27788574f, 0.20476173f, 0.23570913f, 
    0.04280281f, -0.09319261f, 0.06071530f, 0.19164045f, 0.17078108f, -0.02942943f, -0.07138751f, -0.10132712f, 
    -0.29594541f, -0.12624876f, 0.04426897f, 0.29594392f, -0.06423118f, -0.17582826f, -0.00972555f, 0.06486540f, 
    -0.02867410f, 0.13359086f, -0.07572106f, 0.03091705f, -0.06521111f, -0.04222995f, 0.25928727f, 0.26823765f, 
    0.00908004f, 0.14674106f, -0.04595819f, 0.03845970f, 0.06871111f, -0.11474274f, 0.15712851f, 0.03957465f, 
    -0.21036689f, -0.07848681f, -0.32067156f, -0.03508471f, -0.06944380f, -0.07531129f, 0.01064786f, -0.06835023f, 
    0.01789615f, -0.05580083f, -0.10872998f, 0.07604344f, -0.28002945f, 0.10338477f, 0.24125376f, 0.14204659f, 
    -0.05989106f, -0.06260353f, -0.03850170f, 0.07466745f, -0.01054630f, -0.05867808f, 0.01763689f, -0.14535525f, 
    0.00016987f, 0.05731058f, -0.02702455f, -0.01742843f, -0.07086071f, -0.05569187f, 0.05834281f, 0.00600458f, 
    -0.04776250f, 0.00699537f, 0.02112393f, -0.06807385f, -0.01703526f, -0.07617598f, 0.06177993f, -0.04628555f, 
    -0.01549739f, -0.03248620f, -0.07550576f, 0.01123797f, -0.05822878f, -0.02484221f, -0.01501533f, 0.02555154f, 
    -0.01676669f, -0.06899233f, -0.01403537f, -0.01207434f, 0.03398165f, -0.06578586f, 0.04213542f, -0.02382822f, 
    -0.04462013f, 0.01830744f, 0.01876747f, 0.05332469f, 0.00439644f, -0.00231526f, 0.04514692f, 0.01161161f, 
    -0.04431209f, -0.03230393f, 0.03330110f, 0.03588073f, 0.02620539f, -0.02271187f, -0.04338202f, -0.02030780f, 
    -0.06249090f, -0.05300426f, 0.00393471f, 0.03569059f, -0.03864058f, 0.01660938f, 0.02646867f, -0.02869094f, 
    0.00631694f, 0.01812212f, 0.00013439f, 0.00586683f, 0.01821350f, -0.00976457f, -0.02048961f, 0.05020007f, 
    0.05768820f, -0.04213615f, -0.02223101f, 0.03432551f, -0.07682969f, -0.07676569f, -0.03268822f, -0.08340058f, 
    0.01708923f, 0.00660083f, -0.04842177f, -0.04945832f, 0.03337055f, -0.04616972f, 0.04225754f, 0.05262217f, 
    0.04014857f, 0.03412660f, -0.02675820f, -0.02201198f, -0.04065150f, 0.03057168f, 0.05910354f, -0.04624235f, 
    0.03285217f, -0.02934432f, -0.01017838f, 0.02009276f, 0.02247489f, -0.00486607f, -0.01999741f, -0.01569705f, 
    -0.06223736f, -0.04541171f, 0.05947812f, 0.05563233f, 0.05655362f, 0.02428709f, -0.04980341f, -0.02010135f, 
    -0.00543106f, -0.04754271f, -0.06248448f, 0.02581397f, -0.05440719f, -0.02359616f, -0.01820216f, 0.04465496f, 
    -0.01717211f, 0.00346607f, -0.01108201f, -0.05571036f, 0.04813064f, -0.01160045f, 0.05888679f, -0.03930803f, 
    -0.06303096f, -0.07214265f, -0.03858570f, 0.04862553f, 0.00637491f, -0.04262248f, -0.04574079f, 0.00870215f, 
    -0.00833596f, -0.07308982f, -0.01524459f, 0.03138566f, -0.02235354f, -0.01854965f, 0.03141829f, 0.04496482f, 
    0.04240174f, 0.04450487f, 0.00272055f, 0.05356266f, -0.04539153f, -0.00610762f, 0.00837977f, -0.08196764f, 
    -0.00465175f, -0.03894032f, -0.01092324f, -0.05383080f, -0.03958172f, -0.01267392f, 0.01803498f, -0.00421940f, 
    -0.05886013f, -0.03671069f, -0.06710712f, 0.03409286f, -0.05763080f, -0.02765717f, 0.01569696f, 0.00845655f, 
    -0.07306210f, -0.07715586f, -0.01556487f, 0.03224597f, -0.03333968f, 0.04886256f, -0.04484953f, -0.05894705f, 
    -0.06466950f, -0.00361721f, 0.01879824f, -0.03415300f, -0.00920560f, 0.00240701f, -0.03069056f, -0.00078687f, 
    -0.04049434f, 0.03885886f, -0.03100077f, -0.05485969f, 0.00263523f, 0.02422872f, -0.00741957f, -0.03503193f, 
    -0.06499507f, -0.05850157f, 0.03211500f, 0.05289293f, -0.07051434f, 0.03145075f, -0.02141722f, -0.06026254f, 
    0.00834466f, -0.06682359f, 0.02280883f, -0.07542744f, -0.05073262f, 0.00338935f, -0.06969754f, 0.03583179f, 
    -0.02800810f, 0.05441969f, 0.06520616f, 0.06681719f, 0.04082049f, 0.02523793f, -0.06515802f, 0.04257301f, 
    -0.04052864f, 0.03198561f, 0.05068361f, 0.05645723f, 0.05387885f, -0.03491251f, -0.01565489f, 0.04049860f, 
    0.02725087f, 0.05665706f, 0.03545934f, 0.06301404f, -0.02378741f, -0.03469988f, -0.07039627f, 0.04070771f, 
    -0.07967557f, -0.05166228f, -0.00474717f, -0.07102444f, 0.01199909f, -0.00224064f, 0.03206734f, 0.04502207f, 
    0.01790690f, 0.03855465f, -0.03022061f, -0.00601734f, -0.03625476f, -0.04007828f, 0.02384149f, -0.04715224f, 
    0.02711372f, 0.05534635f, -0.02819890f, 0.01117715f, -0.04779483f, -0.06215028f, -0.07107759f, 0.02348942f, 
    -0.01518288f, -0.07243413f, 0.04864265f, 0.00416632f, -0.06839285f, -0.05724533f, -0.04302403f, 0.02634995f, 
    -0.06511109f, 0.06015290f, 0.02320454f, -0.05523369f, 0.03524483f, 0.01929170f, 0.00662948f, -0.05035590f, 
    -0.03871346f, 0.00650286f, -0.01834550f, -0.06291058f, 0.05265865f, 0.00878562f, -0.07562304f, -0.02079249f, 
    -0.00259328f, -0.05384582f, -0.02364680f, -0.00982430f, 0.00497435f, -0.04496752f, -0.05812315f, -0.03812509f, 
    -0.01558504f, -0.07313200f, 0.05520678f, 0.01065237f, 0.03393729f, -0.05262088f, 0.03898340f, -0.04580352f, 
    -0.00939526f, -0.01488415f, 0.05203744f, 0.04897100f, 0.01936903f, -0.06799532f, -0.07442106f, -0.02036584f, 
    0.03997447f, -0.02480171f, -0.03519281f, -0.03364529f, -0.03105168f, -0.01624989f, 0.02765220f, -0.02929425f, 
    0.05304295f, -0.07649085f, 0.04841579f, -0.06563125f, -0.01064074f, 0.02439550f, 0.00769038f, -0.01233957f, 
    -0.05607900f, -0.03424031f, -0.06565887f, -0.00053969f, -0.06912223f, 0.00426122f, 0.05948504f, 0.01275948f, 
    -0.05573156f, 0.01490837f, -0.02893904f, 0.01949857f, 0.02842784f, -0.04535491f, 0.00079388f, -0.06948405f, 
    -0.06119842f, -0.00109319f, 0.02382905f, -0.05990171f, -0.01418116f, 0.06092015f, 0.03684499f, -0.00043852f, 
    0.00211754f, -0.06309006f, -0.07389144f, -0.00263517f, 0.05524421f, 0.05175729f, 0.02701334f, 0.04711720f, 
    0.06439752f, 0.05803844f, -0.06034637f, -0.06498110f, -0.00370846f, -0.05244835f, 0.05034705f, 0.05974781f, 
    -0.01392077f, 0.04005886f, -0.06383619f, 0.06396507f, 0.00937829f, -0.04855075f, 0.04290583f, -0.01403302f, 
    0.01776012f, -0.07984111f, 0.01682999f, -0.07790329f, -0.01340219f, 0.05795909f, -0.05827541f, -0.02601177f, 
    -0.02053064f, 0.03312905f, -0.03313823f, -0.00166848f, -0.00632485f, -0.05767190f, -0.00071335f, 0.03581962f, 
    0.00509588f, -0.05044172f, -0.07309639f, -0.00737339f, -0.08040926f, -0.06157856f, -0.04913059f, -0.07865896f, 
    0.04039128f, 0.03293140f, 0.01884427f, 0.27049774f, -0.11477815f, 0.12833819f, -0.12400043f, 0.05757860f, 
    -0.09475876f, -0.03038012f, -0.02258326f, 0.06654914f, -0.14999580f, 0.16457942f, 0.32120502f, 0.10353734f, 
    0.13505086f, 0.03241015f, -0.07313171f, -0.06459153f, -0.25186580f, -0.14740665f, -0.04134908f, -0.01059920f, 
    0.00157754f, -0.05306232f, -0.14448015f, -0.10885289f, -0.00582730f, 0.13950731f, 0.03454953f, 0.02553703f, 
    -0.07034196f, 0.13674779f, -0.11095784f, -0.06658167f, 0.27893543f, 0.32056060f, -0.48560467f, -0.12141218f, 
    0.11808317f, -0.08835008f, 0.31323525f, -0.06384834f, 0.02637688f, -0.09183035f, 0.07747302f, -0.03229699f, 
    -0.07672817f, -0.10324153f, -0.19996834f, -0.04991065f, 0.06280588f, -0.01213417f, -0.18360789f, 0.09411010f, 
    -0.00877885f, 0.01296719f, 0.05708217f, -0.07105738f, 0.13225013f, 0.09172385f, 0.15433584f, 0.26650476f, 
    -0.09454040f, -0.07563984f, 0.04843833f, -0.05254239f, -0.00510100f, -0.13321070f, -0.08038131f, 0.23107694f, 
    -0.16799873f, -0.16271204f, 0.07055022f, 0.09652847f, 0.01708701f, -0.04410613f, -0.02465564f, -0.10310564f, 
    0.05112462f, 0.01731317f, 0.14743263f, -0.05105302f, 0.27916440f, 0.20695809f, -0.01308646f, -0.28888971f, 
    0.44727626f, -0.03206724f, -0.13128835f, 0.02508018f, -0.04462250f, -0.06327306f, 0.07843554f, -0.01639845f, 
    0.30534095f, -0.06571601f, 0.49939629f, 0.30469200f, 0.26753056f, 0.01991851f, -0.06219567f, 0.11600193f, 
    -0.01256579f, 0.08301596f, 0.01538479f, 0.06277812f, -0.04148105f, 0.07117783f, -0.35786405f, -0.04049731f, 
    0.09577627f, 0.10250393f, 0.07458306f, 0.13990097f, 0.19126596f, -0.05365437f, -0.00833656f, 0.06663889f, 
    0.04002440f, -0.25859621f, 0.12575901f, 0.05031599f, 0.25814104f, 0.23181258f, -0.07175653f, 0.05794517f, 
    0.05570350f, -0.09487736f, 0.09578805f, 0.09424157f, -0.46404818f, -0.12538829f, -0.12926817f, -0.01208968f, 
    -0.05822617f, 0.00992902f, -0.08384062f, -0.14803049f, -0.17736641f, 0.07836691f, -0.02336190f, -0.06571814f, 
    0.33123770f, 0.38548020f, 0.04262061f, -0.14564277f, 0.21034640f, 0.20487490f, 0.12313727f, -0.13207877f, 
    -0.08794882f, 0.00430718f, -0.04905736f, -0.00639704f, 0.22408287f, -0.06611716f, -0.03215113f, 0.02755939f, 
    -0.00509463f, 0.16924042f, -0.26189306f, 0.04206065f, -0.02713495f, -0.01674422f, -0.04143112f, -0.02779163f, 
    0.01596444f, 0.12275191f, -0.06618051f, 0.12209959f, -0.02843951f, -0.10524954f, -0.03596588f, 0.05752024f, 
    -0.08705735f, -0.08799504f, -0.05437563f, -0.25225472f, 0.36644629f, -0.13091280f, -0.19250900f, 0.03938409f, 
    0.29515359f, 0.12419086f, 0.02574667f, 0.17140429f, -0.00837593f, 0.07928219f, 0.06759792f, 0.07461497f, 
    -0.02302623f, -0.00867312f, -0.05576555f, -0.01843608f, -0.03948541f, 0.00203579f, 0.05213276f, 0.06461298f, 
    -0.06232084f, -0.00297528f, -0.01566339f, -0.03595626f, -0.06939530f, -0.06981896f, -0.01595732f, -0.01749650f, 
    0.02841567f, 0.02161375f, -0.03332018f, -0.02177425f, 0.01152932f, -0.06291939f, 0.06836107f, 0.03943371f, 
    -0.04981423f, 0.04660270f, -0.05527184f, 0.01809063f, 0.03207447f, -0.06176969f, 0.05355810f, 0.00800461f, 
    -0.05433287f, -0.06572653f, -0.03715343f, 0.06590620f, 0.07178693f, 0.05518916f, 0.01117443f, 0.01817868f, 
    -0.01579336f, -0.00305059f, 0.04354068f, 0.01023911f, -0.05501735f, -0.03592105f, 0.06839528f, -0.03781063f, 
    -0.04631377f, 0.06968419f, -0.05260076f, 0.06399155f, -0.07116532f, 0.00144232f, 0.04141795f, -0.04172210f, 
    -0.06698249f, 0.02799502f, -0.06089706f, 0.03615190f, -0.01798633f, -0.05635788f, -0.01413353f, -0.00976632f, 
    -0.02314704f, -0.02174966f, -0.03444720f, 0.02096981f, 0.02340665f, -0.00081791f, 0.07103730f, -0.05822990f, 
    -0.06879086f, -0.00105778f, -0.01888749f, 0.06659559f, -0.04055014f, -0.02337700f, 0.03916645f, 0.06298006f, 
    -0.01449861f, 0.00459668f, -0.06428646f, 0.00478875f, -0.06715365f, 0.03226482f, -0.07036138f, -0.05028920f, 
    0.01076548f, -0.04340354f, 0.00722450f, 0.02713196f, 0.02030300f, 0.00987463f, 0.03620429f, -0.03805122f, 
    -0.01210051f, -0.01980902f, 0.05965419f, 0.05277627f, -0.05969987f, -0.00050417f, 0.02358309f, -0.04794527f, 
    0.03602925f, -0.02841211f, 0.00632133f, 0.06170177f, 0.01203988f, -0.03439231f, -0.03795420f, -0.05277384f, 
    -0.02266848f, 0.01575816f, -0.06871151f, -0.01884221f, -0.03136497f, -0.01350671f, 0.00222563f, -0.00397677f, 
    -0.04082615f, -0.00244029f, -0.04063372f, -0.04598735f, 0.00287624f, -0.06472951f, -0.04962002f, 0.05447302f, 
    0.06794335f, -0.02224535f, -0.07149848f, -0.02219808f, -0.06734895f, 0.03646790f, -0.03348214f, -0.06690903f, 
    -0.01543238f, -0.01499419f, -0.03595473f, 0.06436093f, -0.00956947f, 0.02100085f, 0.03582283f, -0.01146193f, 
    -0.05967674f, -0.02789594f, -0.00263821f, 0.04122545f, 0.05397680f, -0.03246185f, 0.05321679f, 0.01973281f, 
    -0.03606812f, -0.06080170f, -0.00990865f, 0.02035971f, 0.02208831f, -0.04812732f, -0.04183931f, 0.03014691f, 
    0.01399834f, -0.03587218f, -0.03004515f, -0.01779040f, 0.02472456f, 0.01486647f, 0.01843733f, -0.02158243f, 
    0.02852263f, -0.00714697f, 0.00165358f, -0.06239872f, -0.07149068f, 0.04754884f, -0.03336393f, 0.06839469f, 
    0.04590682f, -0.04902885f, 0.03939250f, 0.00719900f, 0.00261394f, 0.00655107f, 0.01578347f, -0.03106769f, 
    0.03544317f, 0.00055768f, -0.04859559f, 0.00003366f, -0.01430818f, 0.02579961f, -0.02200636f, 0.04922084f, 
    -0.31349668f, -0.39523163f, -0.43432486f, -0.17572059f, -0.13255109f, 0.14450221f, 0.04076778f, 0.02322576f, 
    -0.07962485f, 0.11129490f, -0.18054286f, -0.12465068f, -0.44727844f, -0.58819312f, 0.23512937f, -0.08271947f, 
    0.01237653f, -0.07535915f, -0.05295500f, 0.04686118f, -0.00280037f, -0.06375120f, -0.03824898f, 0.07500304f, 
    -0.02321296f, 0.09750525f, 0.00263318f, 0.09606994f, -0.03355914f, 0.12945439f, -0.15830334f, -0.06526428f, 
    -0.13476911f, -0.03150428f, 0.05905972f, 0.16656148f, 0.38951218f, -0.11501689f, 0.16484284f, -0.02474604f, 
    0.18309470f, -0.06582540f, 0.21654445f, 0.13434413f, 0.13551037f, 0.05807998f, -0.02086318f, 0.12073201f, 
    0.21840398f, 0.13145605f, -0.28262922f, -0.17249474f, 0.21263680f, 0.12642913f, 0.17702404f, -0.28915161f, 
    -0.11142945f, 0.00320117f, 0.00045303f, -0.02211771f, 0.14045323f, -0.06356697f, -0.15083924f, -0.22597021f, 
    -0.02190894f, -0.08893952f, 0.12177520f, 0.07768640f, -0.10275862f, -0.00310108f, -0.03889536f, -0.09054838f, 
    -0.01121071f, -0.11805002f, -0.38316342f, -0.18355557f, 0.12349045f, 0.03734618f, 0.16436373f, -0.14510271f, 
    0.02918871f, -0.05384948f, -0.23577030f, -0.03972827f, 0.27077025f, 0.13450995f, 0.20339368f, 0.21216606f, 
    0.07112182f, 0.02158569f, 0.17949593f, 0.24864553f, -0.00952853f, -0.14225072f, 0.06430148f, 0.08838192f, 
    -0.12169934f, -0.27277061f, -0.29567787f, -0.09903602f, 0.16516012f, -0.01122463f, 0.08964594f, -0.01083353f, 
    0.00841408f, -0.02510421f, -0.17971644f, -0.08087643f, -0.19433819f, 0.09282902f, -0.25690421f, -0.21738943f, 
    0.05351895f, -0.18979757f, -0.02045487f, -0.14923468f, 0.07904512f, -0.11060344f, -0.27687383f, -0.05383005f, 
    -0.22023684f, -0.24647962f, 0.08170722f, 0.26631665f, 0.16137457f, 0.00563320f, -0.11871805f, 0.21841426f, 
    -0.05675900f, -0.09032712f, -0.01852896f, 0.13976094f, 0.18179815f, -0.16494307f, -0.16850598f, -0.08710928f, 
    0.03041096f, 0.22650604f, -0.09020668f, -0.17681444f, -0.06921730f, 0.08005079f, 0.01033851f, 0.08203495f, 
    0.48785776f, 0.33110636f, 0.30913112f, 0.10042707f, 0.08110743f, 0.29845518f, -0.02627451f, -0.07345523f, 
    0.09638906f, -0.09582838f, 0.03143011f, 0.06217411f, 0.23462726f, 0.13398381f, 0.12221737f, 0.10683767f, 
    0.06783876f, -0.09922041f, 0.10458244f, -0.12558228f, -0.17069070f, 0.08198706f, -0.11974405f, -0.00413888f, 
    -0.10047962f, -0.54750192f, -0.03777611f, -0.58339161f, 0.17734651f, -0.09894122f, -0.08735853f, 0.00664477f, 
    -0.11140028f, -0.08998740f, -0.01113351f, -0.06224270f, 0.36448798f, 0.14338085f, -0.22212128f, 0.21643509f, 
    0.13737716f, 0.18248083f, 0.20597617f, 0.08161255f, 0.09982681f, 0.02237974f, -0.12772168f, 0.30554470f, 
    0.26997694f, -0.07553401f, -0.13929039f, 0.13481431f, -0.17865551f, -0.17320929f, -0.09784287f, 0.03435229f, 
    -0.01030465f, -0.03795729f, 0.03604912f, 0.09376695f, 0.25613937f, -0.25830877f, 0.14839892f, 0.08924574f, 
    0.17069221f, 0.03079860f, 0.06107039f, 0.03366378f, -0.02337532f, -0.20623790f, -0.06413651f, -0.20946218f, 
    -0.16030745f, 0.08162886f, 0.02214219f, -0.02489722f, -0.02777939f, -0.05282383f, 0.06881841f, 0.05550061f, 
    0.00656054f, 0.01206749f, -0.14160129f, -0.05134102f, 0.16413866f, -0.05750670f, 0.16571839f, -0.22548504f, 
    0.14289035f, -0.06852656f, 0.02981425f, 0.07136154f, 0.07362635f, -0.07346874f, -0.09985468f, -0.12353837f, 
    0.09413077f, -0.01180354f, -0.07336810f, -0.02756729f, -0.01002729f, 0.21648428f, -0.04695270f, 0.00175462f, 
    0.10258335f, 0.18341261f, -0.02288225f, 0.06229660f, 0.38297707f, -0.19864355f, -0.12433816f, 0.16874772f, 
    -0.04692806f, 0.08141757f, 0.01570511f, 0.01718791f, 0.29660848f, -0.01360207f, -0.27890107f, 0.32659137f, 
    -0.13456044f, -0.13804048f, 0.06798892f, -0.02038468f, -0.19582057f, -0.02996165f, -0.16282614f, -0.00928513f, 
    0.07696385f, 0.14571910f, 0.21795410f, -0.07508647f, 0.07589207f, 0.25960618f, 0.18757473f, -0.10652182f, 
    0.09130030f, -0.05872566f, 0.05869637f, 0.05718156f, -0.03235133f, -0.23853876f, -0.14779234f, -0.16704239f, 
    -0.01746366f, 0.07201567f, -0.34904072f, 0.06879906f, -0.00783477f, 0.16603909f, 0.07474396f, -0.12591314f, 
    0.03049660f, 0.04467385f, 0.01524596f, 0.06704389f, 0.00980126f, 0.01899907f, 0.12231771f, 0.02320646f, 
    -0.00846546f, 0.22277161f, 0.18170597f, 0.18748759f, 0.26605409f, 0.19017978f, -0.05714582f, 0.27982408f, 
    -0.24744713f, 0.00889268f, 0.06791234f, -0.12837946f, -0.11459406f, 0.16844073f, 0.07774819f, 0.01671152f, 
    -0.01753132f, 0.08762256f, 0.05255666f, -0.04169498f, -0.55865234f, 0.02130730f, -0.21399808f, -0.18200095f, 
    -0.09489465f, -0.14943285f, -0.16277628f, 0.05636928f, 0.08883856f, -0.03747777f, 0.03957626f, -0.12954478f, 
    -0.18378989f, 0.26488635f, 0.23054288f, -0.20113094f, 0.08412211f, 0.06884286f, 0.10681023f, 0.12863976f, 
    0.02886573f, 0.07310171f, -0.13446763f, -0.08979566f, 0.20098026f, 0.23968342f, 0.14529809f, -0.18876421f, 
    0.24487546f, 0.24849123f, 0.03472383f, 0.08259700f, -0.06399935f, -0.00243464f, 0.06346529f, 0.05176832f, 
    0.06116436f, -0.16577385f, -0.09248980f, 0.10070896f, -0.17453240f, -0.13671827f, 0.02072049f, 0.00221925f, 
    0.08132766f, 0.16600405f, 0.07353110f, -0.14870547f, 0.28111678f, -0.01550410f, -0.16473293f, -0.33997214f, 
    -0.04543332f, -0.00518966f, 0.07892546f, 0.10081347f, 0.01997447f, -0.10554955f, 0.05630996f, -0.06000727f, 
    -0.01594802f, -0.03990397f, 0.01880851f, 0.03541300f, 0.05802298f, -0.05773969f, 0.03465449f, -0.03224871f, 
    -0.02619824f, 0.04803577f, -0.06072520f, 0.02368228f, -0.02880960f, -0.05771367f, 0.00282334f, 0.01216089f, 
    0.06395968f, 0.02639624f, 0.03897370f, -0.03766454f, 0.01372774f, -0.05822162f, 0.02191136f, -0.02265012f, 
    -0.01827491f, -0.01424573f, 0.05381126f, 0.06718548f, 0.04728921f, 0.01208208f, -0.04678691f, -0.01778981f, 
    -0.02061459f, -0.03991307f, 0.03023357f, -0.04687493f, 0.02550182f, -0.06277692f, -0.01163698f, 0.03540134f, 
    -0.04674268f, 0.00968423f, 0.01989446f, -0.05216315f, -0.04183222f, 0.03554729f, 0.04543870f, -0.06244130f, 
    -0.07763705f, -0.04415081f, 0.02005362f, -0.04117917f, 0.02074893f, 0.03374671f, 0.00467810f, -0.02057983f, 
    0.05174626f, 0.04923448f, -0.05557971f, -0.06022674f, -0.01890007f, -0.06647456f, 0.03189569f, -0.05409593f, 
    0.04548772f, 0.01753519f, 0.06356984f, 0.05614754f, -0.07266603f, -0.04947295f, -0.06629738f, 0.04348700f, 
    -0.02081085f, -0.07250424f, 0.04441686f, 0.05102709f, 0.02410392f, -0.01783832f, 0.00626854f, -0.03785631f, 
    0.07055318f, 0.03849097f, -0.01341904f, 0.01814163f, -0.05062386f, 0.06426308f, -0.03582675f, -0.05915684f, 
    -0.03623859f, -0.06414212f, -0.06394155f, -0.03916753f, -0.03559550f, -0.06064379f, 0.00259240f, -0.02386187f, 
    -0.05256581f, 0.02352426f, 0.06036877f, -0.04447969f, -0.03188238f, -0.08095594f, -0.07619431f, -0.06957888f, 
    -0.00098960f, 0.00402152f, 0.03944911f, -0.00288198f, -0.03727522f, 0.05783903f, -0.06078279f, -0.04209013f, 
    0.00051554f, -0.04027245f, -0.02207171f, -0.07235747f, 0.03164627f, 0.01747655f, 0.01682147f, 0.01773284f, 
    -0.04299599f, 0.05025461f, 0.03770714f, 0.04100613f, -0.04816864f, 0.06603470f, -0.07355026f, -0.01971213f, 
    -0.04025300f, 0.01437410f, -0.03408989f, -0.05085575f, -0.03926589f, 0.06365856f, -0.05993691f, -0.04912372f, 
    -0.02130028f, -0.04884175f, 0.02021746f, -0.02591258f, 0.01901167f, -0.06350033f, -0.05373052f, -0.00018757f, 
    -0.03231379f, 0.06814891f, -0.07079444f, -0.00243408f, 0.04690441f, -0.03926556f, 0.00376689f, 0.05728848f, 
    -0.04715711f, 0.00730568f, -0.00619894f, -0.07077905f, 0.06406406f, 0.01013255f, -0.01957778f, -0.01097718f, 
    -0.00599159f, -0.06221605f, -0.03969119f, 0.05293187f, -0.05900106f, -0.04546278f, 0.02026295f, -0.01341385f, 
    -0.06300727f, 0.04274741f, -0.03398864f, -0.03784966f, 0.00799640f, 0.01474739f, 0.02436798f, -0.00288321f, 
    -0.00506069f, -0.01989044f, -0.01144084f, 0.05069122f, -0.07317147f, -0.07477266f, -0.01244526f, -0.02204369f, 
    0.02825611f, 0.00941724f, 0.02095833f, 0.01946332f, 0.06267402f, 0.06613471f, -0.04403158f, 0.03423663f, 
    -0.06957404f, -0.27106622f, -0.32044399f, -0.19572559f, 0.05892567f, 0.10812402f, -0.07316385f, -0.01323540f, 
    0.02612107f, 0.09420837f, -0.08122831f, -0.00324354f, -0.28909081f, -0.56333917f, -0.04078525f, -0.07286116f, 
    0.07904027f, -0.01587633f, -0.16634917f, 0.03386813f, -0.00624601f, 0.06725984f, -0.13755357f, -0.19373620f, 
    -0.07654458f, 0.08342563f, 0.00229237f, -0.01248335f, 0.05022556f, 0.07165549f, -0.00026269f, -0.11074549f, 
    -0.19630651f, -0.03488419f, -0.02885380f, -0.10208549f, 0.41923141f, -0.20517242f, 0.41201705f, -0.02938581f, 
    -0.04362135f, -0.15752426f, -0.01381369f, 0.00399788f, 0.03103938f, -0.04464512f, -0.21046473f, -0.07874729f, 
    0.15443449f, 0.06094429f, -0.09326091f, -0.00226636f, 0.12691811f, 0.15994810f, 0.10337432f, -0.03923419f, 
    -0.01995762f, 0.06660981f, -0.04250742f, 0.05166105f, 0.07522651f, -0.38492924f, -0.18634638f, 0.02567347f, 
    -0.01315664f, 0.03754506f, 0.03902188f, 0.02344557f, -0.06207909f, -0.13877372f, -0.29167300f, 0.04516939f, 
    -0.02021402f, -0.10014645f, -0.05653131f, -0.08035390f, 0.10460238f, 0.09120195f, 0.08655132f, 0.06258013f, 
    -0.01398506f, -0.02088819f, -0.14207466f, 0.09182067f, 0.47486913f, 0.28421474f, 0.27804190f, 0.14619163f, 
    0.09239493f, -0.02952662f, -0.00130300f, 0.14409004f, -0.09856480f, -0.18235655f, -0.16679414f, -0.05441917f, 
    0.04710029f, -0.01088813f, -0.17087020f, 0.03940220f, -0.04457081f, -0.03318659f, -0.22139326f, -0.07771357f, 
    0.04086857f, 0.02142243f, -0.02752129f, 0.05750337f, -0.07123265f, 0.21847160f, -0.02176538f, 0.00934664f, 
    -0.05753545f, -0.06849436f, 0.09808572f, -0.06799746f, -0.02638985f, 0.09954537f, -0.06177188f, -0.02348182f, 
    -0.09300786f, -0.07732296f, 0.16764538f, 0.25094351f, 0.22201374f, 0.10611126f, -0.05280355f, 0.16912550f, 
    0.07555296f, -0.04010572f, 0.04329722f, 0.09885262f, 0.00770641f, 0.09644090f, 0.02349444f, -0.05928370f, 
    0.00829982f, 0.16076678f, 0.00877604f, -0.01667870f, 0.02207238f, -0.01133126f, 0.16132280f, 0.05130865f, 
    0.21037777f, 0.43142614f, 0.34131563f, -0.06326425f, -0.08937280f, 0.21467748f, 0.07963829f, 0.06605399f, 
    0.04208446f, -0.07323039f, -0.08330815f, 0.05612479f, 0.39012012f, 0.32440680f, 0.31687528f, 0.13193952f, 
    0.07202811f, -0.12056500f, -0.00484667f, 0.02048484f, -0.06581442f, -0.01216247f, 0.08690813f, -0.02689261f, 
    -0.15502091f, -0.37407193f, -0.18972249f, -0.09017879f, 0.04690586f, 0.00078018f, -0.06869500f, 0.02274325f, 
    -0.07291871f, -0.02289204f, 0.03990361f, -0.03412747f, 0.42744815f, 0.21531491f, -0.19484469f, 0.11022516f, 
    0.06175296f, 0.04137145f, 0.04152648f, -0.06935894f, -0.01312848f, -0.06806389f, 0.01155152f, -0.02147391f, 
    -0.03949899f, 0.04434607f, 0.05075588f, -0.04051285f, -0.04099077f, 0.02809772f, 0.04678675f, -0.05515864f, 
    0.02469064f, -0.00525415f, 0.00456724f, 0.03476280f, 0.00670763f, 0.03662303f, -0.05119417f, 0.03837788f, 
    0.05841522f, -0.00115152f, 0.02291696f, -0.02075308f, 0.00975165f, -0.05009557f, -0.05815555f, 0.05336604f, 
    0.02789871f, -0.00611585f, 0.04439145f, 0.02321995f, 0.01026368f, 0.06315071f, -0.05481031f, -0.02937960f, 
    0.03198263f, -0.07522554f, 0.00201187f, -0.07654659f, -0.01131394f, -0.07378294f, 0.02522855f, 0.03740922f, 
    -0.01666947f, -0.05590155f, -0.01043463f, -0.07430418f, -0.04786296f, -0.03961410f, -0.06040718f, 0.00991281f, 
    0.03578225f, -0.03588634f, 0.01999882f, -0.05162836f, 0.05245498f, -0.00183901f, 0.01813567f, -0.06374408f, 
    0.01906594f, -0.07271504f, -0.02752382f, 0.05761950f, 0.00736777f, 0.02296840f, 0.04809082f, -0.04914921f, 
    -0.01377637f, -0.05955129f, -0.07652236f, -0.05630838f, -0.03191208f, 0.01046252f, -0.00236298f, -0.04099079f, 
    -0.04185513f, 0.00307473f, -0.00826495f, -0.04077249f, -0.01005012f, -0.06190170f, -0.04051421f, -0.00118088f, 
    0.05840997f, -0.02909149f, 0.01009840f, -0.06273933f, -0.06051537f, -0.00926523f, -0.00180114f, -0.04555846f, 
    -0.05084775f, -0.02176152f, 0.04403718f, -0.00718142f, -0.06034226f, 0.02234996f, 0.00334977f, 0.06384105f, 
    0.02170031f, -0.03700999f, -0.01082777f, 0.04366061f, 0.02280642f, -0.01282725f, -0.02962621f, 0.05431430f, 
    0.04835252f, -0.05482819f, -0.07516065f, -0.01484478f, -0.04879418f, -0.07058394f, 0.05397778f, -0.06811110f, 
    -0.05456595f, 0.06757375f, 0.00961366f, 0.05555731f, 0.05842489f, 0.04107542f, 0.04684002f, -0.01051977f, 
    -0.04665862f, -0.02813768f, 0.01367967f, -0.06671081f, 0.01205869f, -0.02394009f, -0.02597913f, -0.00493180f, 
    0.02602728f, 0.07082190f, 0.04916826f, -0.04225380f, -0.06683587f, -0.04609163f, -0.06729174f, -0.00518382f, 
    0.02086557f, -0.03963910f, 0.01187983f, -0.06702079f, -0.04550562f, -0.07535402f, -0.01022060f, 0.01093119f, 
    0.05649104f, -0.00532036f, -0.05972865f, 0.06332214f, -0.06503507f, -0.02630883f, 0.02968630f, -0.03264768f, 
    -0.04182401f, 0.01599868f, 0.02410724f, 0.01610291f, 0.04353543f, -0.05526352f, -0.01554416f, -0.00216294f, 
    0.04104917f, 0.03144691f, 0.03264855f, -0.06903332f, 0.00768265f, 0.05477098f, -0.05336061f, -0.03056170f, 
    -0.06545426f, 0.01850637f, -0.07420418f, -0.05168213f, -0.00066122f, 0.05851999f, -0.01271915f, 0.06121410f, 
    -0.07483038f, 0.04654451f, -0.04898282f, -0.06985119f, -0.01359525f, -0.02794665f, -0.03432002f, -0.03137580f, 
    0.00132822f, 0.04413051f, 0.01801096f, 0.06019078f, -0.00375737f, -0.04377852f, 0.02094460f, -0.06818733f, 
    -0.23250426f, 0.11193307f, 0.11354528f, 0.01334966f, 0.02245387f, -0.00299125f, 0.14108528f, -0.01071213f, 
    -0.05099840f, -0.06250305f, 0.13954075f, 0.06984120f, 0.36370680f, 0.14232999f, -0.35711941f, 0.02947804f, 
    -0.09358700f, -0.06118165f, 0.12145671f, -0.02862355f, -0.23068988f, 0.08973136f, -0.01932348f, -0.23700087f, 
    -0.11464960f, -0.10104321f, 0.20473433f, -0.26820144f, -0.15044457f, 0.00810043f, 0.15101689f, 0.05638587f, 
    0.05051804f, 0.01811507f, 0.16604085f, 0.12051333f, -0.07444736f, 0.28433236f, -0.07978132f, 0.22421128f, 
    0.09088929f, 0.12913498f, 0.09933976f, -0.23301393f, 0.00288253f, -0.04456631f, 0.15072989f, 0.10244114f, 
    -0.07302609f, -0.09574089f, 0.03528387f, -0.06727175f, 0.04600319f, 0.11764679f, -0.15866122f, 0.23070103f, 
    0.13325822f, 0.02887977f, 0.03910916f, 0.01645087f, -0.09370768f, -0.00704128f, 0.31035486f, 0.29560733f, 
    0.00399825f, -0.15476055f, -0.21450619f, -0.10479510f, 0.14868039f, -0.07464635f, -0.01298160f, 0.33671921f, 
    -0.10342629f, 0.00158900f, 0.15440294f, -0.11075449f, 0.02487362f, -0.04760669f, 0.15148367f, -0.05918373f, 
    0.20822062f, 0.18524474f, 0.13871999f, 0.04983779f, -0.04518052f, 0.21824665f, -0.01732864f, 0.03817147f, 
    -0.02667517f, 0.05427469f, 0.04038823f, -0.10042892f, 0.04775001f, 0.09178440f, -0.09352020f, -0.01630499f, 
    0.19012129f, -0.07352503f, 0.23913746f, 0.03357431f, 0.29738653f, 0.34806553f, 0.25140792f, 0.11731410f, 
    -0.08721935f, -0.03628631f, -0.12952340f, 0.07490876f, 0.00694651f, 0.08299187f, 0.27089259f, 0.38786256f, 
    0.12486174f, 0.05847589f, 0.13203222f, -0.02610644f, 0.05514200f, 0.08078563f, 0.03544863f, 0.05182007f, 
    0.03170763f, 0.23893060f, 0.00464464f, -0.24423911f, -0.03720605f, 0.05171387f, -0.09327769f, 0.08405241f, 
    0.10449012f, 0.09086139f, 0.11638090f, 0.13297407f, -0.56150591f, 0.15516126f, -0.14402807f, -0.12347871f, 
    -0.00182347f, -0.14410307f, -0.02445357f, 0.06363370f, 0.15800944f, 0.12298562f, 0.01084555f, -0.20298693f, 
    -0.13272479f, -0.19910723f, -0.41370434f, -0.02030597f, 0.08941240f, -0.04526585f, 0.10412740f, 0.01809734f, 
    -0.06986308f, -0.03596232f, -0.04968701f, -0.04240110f, -0.13068785f, -0.13342288f, 0.17218855f, 0.16234463f, 
    0.05563932f, 0.05186416f, -0.04587926f, 0.16927139f, -0.02638536f, -0.24495129f, 0.07909115f, 0.07864223f, 
    -0.06751798f, -0.14124742f, -0.03437007f, 0.27325574f, 0.03967351f, 0.09208747f, -0.02094043f, -0.11798875f, 
    0.09453826f, -0.12412885f, -0.10933226f, 0.11607137f, -0.18049753f, -0.10074367f, 0.01274142f, 0.43553627f, 
    0.02882488f, 0.11432692f, -0.01966722f, 0.13870259f, -0.16460003f, -0.08890352f, 0.08515412f, -0.11003781f, 
    -0.29778412f, 0.04035832f, -0.05175957f, -0.14552255f, -0.04453618f, -0.08983132f, -0.06278239f, -0.01230438f, 
    -0.06464478f, -0.09449793f, -0.00736322f, -0.03806939f, -0.11226415f, 0.16091909f, -0.12068934f, -0.02137758f, 
    -0.03508917f, -0.23325267f, -0.02183639f, -0.05683904f, -0.17088826f, -0.04432758f, -0.21952154f, 0.10860605f, 
    0.35113540f, 0.10766999f, 0.16791010f, -0.13621406f, -0.04195464f, -0.03462701f, 0.17383492f, 0.11694685f, 
    -0.01423920f, -0.03053981f, -0.07357166f, 0.14278616f, -0.02792492f, 0.14108497f, 0.00554695f, 0.05987245f, 
    0.03687154f, 0.05958285f, -0.03390115f, -0.28020045f, -0.07455044f, -0.04969462f, -0.05603754f, 0.08957550f, 
    -0.23231308f, 0.04195667f, 0.09897612f, -0.10207108f, -0.10746244f, -0.01274760f, -0.23653616f, 0.03997847f, 
    0.05992889f, 0.01419015f, -0.00453429f, 0.09120667f, -0.20322546f, 0.23285760f, 0.14720413f, 0.10947409f, 
    0.01214052f, 0.01302115f, -0.05985237f, 0.02504392f, 0.09407075f, -0.06085103f, 0.10412264f, 0.20217204f, 
    -0.08477930f, 0.03878779f, 0.06091108f, 0.04388397f, 0.03693211f, -0.23817019f, 0.11545520f, -0.04688765f, 
    -0.03845866f, 0.15935621f, -0.06324244f, -0.15357569f, -0.09522375f, 0.08251031f, -0.04183299f, 0.07165862f, 
    -0.08756266f, 0.21019414f, 0.12325225f, -0.15273514f, 0.01340095f, 0.08920635f, 0.02338920f, 0.04336264f, 
    0.05944103f, -0.28578046f, 0.34653622f, -0.27061191f, -0.12028883f, 0.23071766f, 0.24468620f, -0.04232186f, 
    -0.00515650f, 0.04373216f, 0.09038974f, -0.02173960f, 0.00511549f, 0.02372262f, 0.03594038f, 0.14727062f, 
    0.19019906f, 0.01865853f, -0.03781648f, 0.19770961f, -0.01821458f, 0.02896659f, 0.25649357f, 0.01560773f, 
    -0.28780138f, 0.32697248f, -0.27056202f, -0.10111479f, -0.09319139f, 0.08620254f, 0.03264770f, 0.15129648f, 
    0.02238254f, 0.21961416f, -0.05751612f, 0.16588455f, -0.14746997f, 0.16929115f, 0.10820647f, 0.04158638f, 
    -0.03974090f, -0.02633291f, 0.07157307f, 0.10689450f, -0.04150413f, 0.12548752f, -0.02290612f, 0.11244524f, 
    0.00641704f, -0.10822219f, -0.05528099f, 0.43670639f, -0.01757232f, 0.08830607f, -0.10951021f, 0.06242220f, 
    -0.03386116f, 0.02315114f, 0.01599151f, -0.08121923f, -0.25440547f, -0.20726053f, 0.16139492f, 0.10504852f, 
    0.07467522f, 0.19664490f, 0.11626288f, 0.06922173f, 0.09388339f, 0.02635861f, 0.04406188f, 0.17070702f, 
    -0.04180806f, 0.01824280f, -0.08712738f, -0.02122358f, -0.05743365f, -0.01790224f, 0.04857882f, -0.02908401f, 
    -0.06037198f, -0.07609551f, -0.02468834f, -0.06208840f, -0.27391982f, 0.09337685f, 0.07623758f, 0.40798068f, 
    0.02396534f, -0.06129743f, 0.03369161f, 0.08638090f, 0.04536787f, 0.10738351f, -0.05570972f, 0.03182871f, 
    0.39416376f, -0.17688969f, -0.20756188f, 0.29444283f, -0.25921437f, -0.36805093f, -0.23526788f, -0.03887703f, 
    0.12834652f, 0.03748965f, -0.10723425f, 0.07496896f, -0.36917493f, -0.07286921f, 0.00495293f, 0.19120258f, 
    -0.26478434f, -0.09472761f, -0.19865471f, -0.22919925f, 0.06928144f, 0.01992235f, -0.06783478f, 0.27122656f, 
    0.39987129f, 0.46388730f, 0.05432380f, 0.17710912f, 0.11206096f, 0.12179572f, 0.04999380f, 0.06509123f, 
    0.16931459f, 0.04414508f, 0.01238484f, -0.01824779f, 0.17171620f, 0.33393437f, -0.14072122f, -0.25347534f, 
    -0.02725623f, 0.15906921f, 0.10963767f, 0.18773767f, 0.14164147f, -0.10195838f, 0.07230112f, -0.07247612f, 
    -0.05307944f, 0.10530338f, -0.23056902f, 0.11393212f, -0.22675620f, -0.04831699f, -0.03301778f, -0.15370539f, 
    0.13568191f, -0.00935151f, -0.24511488f, -0.20946148f, 0.24052398f, 0.11477474f, 0.00743916f, 0.06919517f, 
    -0.17988195f, 0.12920122f, -0.05514234f, -0.34800720f, -0.01063441f, -0.23204629f, -0.05660023f, -0.07409419f, 
    0.11778172f, -0.11576286f, 0.03818465f, 0.28565735f, 0.01227631f, -0.17811364f, -0.36914700f, -0.08644483f, 
    0.01635755f, 0.16078466f, 0.31684747f, -0.17678487f, -0.01430060f, 0.16786098f, 0.04746627f, -0.14517654f, 
    0.20178029f, 0.04835504f, -0.07985025f, 0.00397700f, 0.04846469f, 0.02548725f, 0.05751682f, 0.07845886f, 
    -0.01469016f, -0.11937148f, 0.00600194f, 0.31904846f, -0.16166949f, -0.08758561f, -0.04524875f, -0.13092063f, 
    0.00641414f, 0.00373597f, 0.03851513f, -0.32586348f, 0.12337289f, -0.08452825f, 0.06082378f, -0.16523653f, 
    0.16773057f, 0.25442106f, 0.01890568f, 0.08741298f, -0.13630013f, -0.17079204f, -0.05344535f, 0.08335330f, 
    -0.01469222f, -0.01952875f, -0.06860907f, 0.11998759f, -0.13747013f, 0.19809046f, 0.10172974f, -0.44368973f, 
    0.08276121f, -0.29493830f, -0.20886274f, -0.36014265f, 0.32265016f, 0.10085198f, 0.41471952f, 0.24695247f, 
    -0.07811176f, -0.18997769f, -0.18787308f, -0.18665148f, 0.13535722f, 0.02791147f, 0.05569145f, 0.26661983f, 
    -0.10938074f, 0.25788775f, 0.31383258f, 0.04958200f, 0.03597108f, 0.04961236f, -0.14576206f, 0.09638242f, 
    -0.01265687f, 0.15823825f, -0.09458543f, -0.09601006f, 0.26457891f, -0.06751011f, -0.23229998f, 0.07621964f, 
    0.12562306f, 0.38545114f, 0.16403235f, -0.02139541f, 0.10235290f, 0.06832617f, 0.07149336f, -0.18556347f, 
    -0.16170667f, 0.03943440f, 0.16382809f, 0.17194180f, 0.03937704f, -0.08677151f, 0.01299968f, -0.09162670f, 
    0.12776054f, 0.02767143f, 0.02036598f, -0.22481455f, 0.30237290f, 0.12032334f, 0.04238264f, -0.44146064f, 
    0.02883414f, -0.08086122f, -0.06562407f, 0.02514634f, 0.05959294f, -0.00827616f, 0.08822380f, 0.09470964f, 
    -0.14413640f, 0.09273322f, 0.07826987f, -0.00027224f, 0.00644873f, -0.02076496f, -0.01400878f, 0.12167884f, 
    0.14486855f, 0.09638810f, 0.03308427f, -0.18656956f, -0.35235178f, 0.23226981f, -0.11261336f, -0.18514967f, 
    -0.14678177f, -0.09614901f, 0.10453963f, -0.10869762f, 0.06574088f, 0.03307561f, -0.05560754f, 0.28705350f, 
    0.41782117f, 0.05106367f, 0.08867893f, 0.28508204f, -0.03392930f, -0.15341192f, 0.05977577f, -0.16047244f, 
    -0.05939321f, -0.12464019f, -0.03955006f, 0.18210819f, -0.34087661f, 0.14026199f, -0.15477750f, 0.45863482f, 
    -0.08348268f, 0.10149498f, -0.11479320f, -0.09313966f, -0.12566608f, -0.00559153f, -0.06159100f, 0.02140074f, 
    -0.11431206f, 0.08129331f, 0.10954382f, 0.03510318f, -0.10386493f, 0.16634239f, -0.02969442f, 0.08835669f, 
    -0.07633515f, -0.02832230f, 0.11502772f, -0.00917869f, -0.32991114f, 0.19700053f, 0.05619970f, -0.09964700f, 
    0.10026462f, -0.03219021f, 0.00946716f, 0.02636198f, -0.12339813f, -0.12493819f, 0.07861394f, -0.29178882f, 
    0.08189051f, 0.21427256f, 0.00409231f, 0.00917057f, 0.09420375f, -0.04168105f, 0.04408632f, -0.02056489f, 
    0.00030178f, 0.00922363f, 0.08801729f, -0.00840383f, -0.24404548f, -0.09607355f, -0.13900726f, 0.29653430f, 
    0.03840452f, 0.05157178f, 0.05422422f, -0.00719926f, -0.10786372f, 0.11977226f, 0.10468576f, -0.02696634f, 
    0.00073177f, -0.19397338f, 0.35462445f, -0.21882097f, -0.15305403f, -0.05240956f, 0.14974284f, -0.00829197f, 
    0.10422022f, 0.00416751f, 0.03528181f, -0.09884137f, 0.12495077f, -0.09185445f, -0.05612589f, 0.07972094f, 
    0.10392690f, 0.22058484f, -0.13921188f, 0.03887838f, -0.11814889f, -0.09476035f, 0.02893638f, -0.00850275f, 
    0.47051439f, 0.00061841f, -0.30990109f, 0.12482689f, 0.29806799f, 0.04142148f, 0.07555931f, -0.03126318f, 
    0.11006667f, 0.01821193f, -0.06800848f, 0.12731259f, 0.82210463f, 0.22005808f, 0.20934249f, 0.24839285f, 
    0.08020899f, -0.06254062f, -0.00479211f, -0.08010273f, -0.04017397f, 0.01062233f, 0.00720769f, 0.32507941f, 
    0.35196611f, -0.22675279f, 0.00136063f, 0.30254567f, -0.08997843f, -0.13620540f, -0.15537480f, 0.09315986f, 
    -0.07553789f, 0.06486239f, -0.06022170f, -0.00943331f, -0.09777816f, -0.14217333f, 0.04299343f, 0.17377590f, 
    -0.28961459f, -0.09928896f, 0.08993933f, -0.09883671f, -0.02952780f, 0.01628556f, -0.08747515f, 0.00975287f, 
    -0.11016200f, 0.13790855f, -0.02586794f, -0.07141206f, 0.02373898f, 0.17442860f, 0.12283566f, -0.11517020f, 
    0.08916254f, 0.07376295f, 0.01687720f, -0.06681617f, -0.46091965f, 0.00249322f, 0.29641044f, 0.23003006f, 
    0.06225312f, -0.17839703f, -0.00222002f, 0.10060259f, 0.05857090f, 0.16857214f, 0.15437901f, 0.12584649f, 
    0.11398192f, -0.10992776f, -0.14230022f, 0.18247847f, -0.01730484f, 0.08785224f, -0.07656239f, -0.02049941f, 
    -0.14882733f, -0.00062215f, 0.06068182f, 0.03801110f, -0.01925036f, -0.30510768f, 0.30743051f, 0.19988063f, 
    0.17353168f, 0.14039367f, -0.02397030f, 0.01541369f, -0.03966386f, 0.05876407f, 0.04899272f, 0.05942509f, 
    -0.06545904f, 0.00880102f, 0.00056686f, -0.06826483f, -0.15337531f, 0.11529981f, 0.12466348f, -0.03637673f, 
    0.11124317f, 0.12312293f, 0.13655424f, -0.15151975f, 0.29186422f, 0.01978283f, -0.06135885f, -0.18351865f, 
    0.05828445f, -0.18310577f, 0.20473345f, 0.07712022f, 0.12999438f, -0.01881708f, 0.09561503f, -0.07298823f, 
    0.01247085f, 0.06735890f, -0.07797527f, 0.14261818f, -0.09531444f, -0.06615380f, -0.07013606f, -0.05171204f, 
    -0.02997787f, -0.11072556f, -0.09359899f, -0.13228135f, 0.05348843f, -0.12218669f, -0.05172604f, 0.11717138f, 
    -0.00881814f, 0.00548594f, 0.01408246f, 0.02331083f, 0.03257404f, 0.02086323f, -0.18252446f, 0.15437709f, 
    -0.12221319f, -0.11766872f, 0.03753222f, 0.18285885f, 0.05489551f, 0.03870763f, 0.04273356f, -0.04528541f, 
    -0.14814253f, 0.13611767f, 0.13062963f, -0.02639286f, 0.24715215f, 0.07785349f, 0.14863275f, -0.26824629f, 
    0.06495649f, -0.17812151f, -0.19054905f, -0.08868950f, 0.07425530f, -0.11415790f, 0.05878989f, -0.03040632f, 
    0.39352509f, -0.09881859f, 0.21802180f, -0.07913616f, 0.11208091f, 0.08981911f, -0.08957043f, 0.04743509f, 
    -0.07104462f, 0.04349169f, -0.03522246f, 0.06848764f, -0.17792852f, 0.23230442f, -0.12716979f, -0.05726100f, 
    0.13184164f, 0.13301581f, 0.07321126f, -0.00315976f, -0.00265606f, 0.01435099f, -0.20037475f, -0.05496456f, 
    -0.31797782f, -0.32327306f, 0.17060085f, -0.00663161f, -0.00797571f, 0.32346788f, -0.29062253f, 0.02913613f, 
    -0.07031634f, -0.11526328f, 0.04188245f, -0.17189585f, -0.58432078f, -0.09025846f, -0.09971328f, 0.10729121f, 
    -0.02721506f, 0.04081733f, 0.12026026f, 0.09015381f, -0.12641811f, 0.05099336f, 0.04878695f, -0.02022042f, 
    -0.00974933f, 0.29822829f, 0.22533515f, -0.26873636f, 0.03092472f, 0.20215353f, 0.23911192f, -0.00546578f, 
    -0.03715935f, -0.06165598f, 0.03142181f, 0.16136400f, 0.23050137f, 0.23515843f, 0.12488414f, -0.27372962f, 
    0.11298062f, 0.11567210f, -0.08045944f, 0.02339774f, -0.04198245f, -0.08429284f, -0.00269235f, -0.03541728f, 
    -0.10838402f, 0.14948705f, -0.05719934f, 0.14021236f, 0.03806663f, -0.00104942f, 0.03421845f, 0.08194698f, 
    -0.08253513f, 0.09282770f, 0.07388615f, -0.10494546f, 0.23165746f, -0.03363392f, -0.46593612f, -0.15862565f, 
    0.01958944f, 0.10787361f, 0.09677438f, 0.07135432f, 0.04131247f, 0.06550704f, 0.10785609f, -0.00036017f, 
    -0.08600550f, 0.03037304f, -0.08730940f, -0.05345082f, 0.04142733f, -0.07042830f, -0.03244359f, -0.07769312f, 
    0.06411517f, -0.06313500f, -0.05662587f, 0.01313788f, 0.03743087f, -0.06453911f, -0.07511444f, -0.04487552f, 
    -0.04034366f, -0.04666455f, -0.06730933f, -0.00058548f, -0.06331873f, 0.03797235f, -0.01635815f, -0.09502007f, 
    -0.00581513f, -0.06140669f, 0.02860149f, 0.01939094f, 0.01202067f, -0.06840959f, -0.07175501f, 0.01228475f, 
    -0.07551177f, 0.04632862f, -0.00401331f, -0.07013304f, 0.04295865f, 0.05458523f, -0.06477319f, -0.00959590f, 
    -0.01567879f, -0.01383636f, -0.05159416f, -0.02415643f, 0.04820488f, 0.00744814f, -0.05027559f, -0.06953356f, 
    -0.02351811f, -0.00688814f, -0.06352971f, -0.08002506f, -0.04580270f, -0.04320711f, 0.03440693f, 0.01992268f, 
    -0.03525545f, 0.01810509f, -0.02205593f, -0.03811630f, 0.02874818f, 0.04588782f, 0.03149965f, 0.01290056f, 
    0.04748741f, 0.00820244f, -0.01759408f, 0.00672975f, -0.05821092f, -0.02090779f, 0.03364189f, 0.03874259f, 
    -0.04420153f, -0.03600805f, 0.00258171f, -0.00969384f, -0.06261802f, 0.04946659f, -0.00201230f, 0.00036469f, 
    -0.02042157f, -0.06428242f, -0.06997246f, 0.01794345f, -0.04531740f, -0.02306150f, 0.00659937f, -0.05743467f, 
    0.06897628f, 0.04227711f, -0.06325255f, 0.00695803f, -0.04909451f, 0.01331565f, 0.02305876f, 0.01922293f, 
    -0.02694324f, -0.08622824f, -0.00472824f, -0.01219906f, 0.05165711f, 0.03913665f, -0.00199235f, 0.01345080f, 
    -0.00833068f, -0.04615931f, -0.08361248f, 0.04558664f, 0.01054581f, 0.00723433f, -0.02208764f, 0.00201590f, 
    -0.07572193f, 0.02988797f, -0.00696280f, 0.00548584f, -0.00322246f, 0.04281227f, 0.03232580f, 0.00272234f, 
    0.03990433f, -0.05413042f, 0.01469943f, -0.04308540f, 0.01174433f, 0.04736493f, -0.07391586f, -0.05007336f, 
    0.05729827f, -0.00298550f, 0.03715273f, -0.00369292f, -0.05261253f, -0.01854887f, -0.02155145f, -0.05374441f, 
    -0.06837089f, -0.06087994f, 0.00166712f, 0.00225635f, 0.01454438f, -0.01280989f, 0.01389400f, -0.00943942f, 
    -0.00986281f, -0.04386868f, 0.06672543f, -0.05799761f, 0.04881698f, -0.06823405f, -0.04033737f, 0.06374209f, 
    -0.03935349f, -0.05688566f, 0.03899406f, -0.00380169f, -0.05739154f, -0.02760879f, -0.07621244f, -0.08259981f, 
    -0.02930496f, 0.02260151f, 0.00900943f, 0.03404338f, -0.07790953f, -0.00885041f, 0.05388946f, -0.01481796f, 
    -0.04816726f, -0.01102217f, 0.02429012f, -0.06919363f, 0.06193688f, 0.02597293f, -0.01590463f, -0.07208837f, 
    0.05869208f, 0.02609440f, 0.03039221f, -0.08147001f, -0.02261576f, 0.04378196f, -0.06461845f, -0.00388707f, 
    -0.06519877f, 0.00029070f, 0.00914890f, -0.00070292f, 0.03293837f, -0.04922674f, 0.04712882f, -0.00235182f, 
    0.03071840f, 0.01267475f, -0.15935369f, 0.06607107f, 0.01094671f, -0.09219358f, -0.12900853f, -0.06496226f, 
    0.01410013f, 0.05204033f, -0.03845550f, -0.02795640f, 0.11003298f, 0.00284932f, 0.40552789f, 0.10435436f, 
    0.05720273f, 0.05354758f, -0.05938663f, -0.02118302f, 0.18762043f, -0.04948012f, 0.08551273f, 0.23575078f, 
    0.03633253f, 0.10081629f, -0.06933458f, 0.07568107f, -0.04607337f, 0.08805858f, -0.10842291f, 0.17589457f, 
    0.18208891f, 0.17339385f, 0.29089132f, -0.05003465f, -0.05634748f, -0.17839225f, -0.07790344f, -0.26352844f, 
    0.10680248f, -0.16452904f, 0.13612084f, 0.36409515f, -0.03250320f, -0.01821306f, 0.22862592f, 0.08983229f, 
    -0.13239437f, -0.05891049f, -0.01894183f, 0.01608446f, 0.32661548f, -0.05802391f, 0.31405452f, -0.04642502f, 
    -0.20172329f, 0.04229161f, 0.04701719f, -0.02912519f, 0.16208051f, 0.08043251f, 0.21556555f, -0.11209277f, 
    -0.09569997f, -0.05347487f, -0.07065175f, 0.01275649f, 0.00118596f, 0.27731627f, 0.05571273f, 0.09982193f, 
    0.02082167f, 0.01396501f, -0.10057770f, 0.07197467f, 0.01465328f, 0.14031035f, -0.11348353f, 0.02873517f, 
    0.14108081f, 0.12343432f, 0.09074467f, 0.25100809f, -0.11850630f, -0.39846036f, -0.11409514f, -0.12307828f, 
    -0.06569647f, -0.09512408f, -0.00655651f, 0.01611460f, 0.02772290f, -0.09381081f, 0.21533407f, 0.19888334f, 
    -0.12312179f, -0.11613782f, 0.10921571f, -0.01071627f, -0.01977847f, -0.07539759f, -0.11606541f, 0.06522474f, 
    0.06049964f, 0.06098537f, -0.03591832f, 0.00682638f, -0.09054279f, 0.14371021f, -0.08283459f, -0.30162168f, 
    0.18686835f, 0.16534045f, 0.15410578f, 0.27295265f, -0.00867129f, -0.04300934f, 0.06427065f, -0.11018962f, 
    0.00956415f, -0.26799902f, -0.05601236f, 0.03430495f, 0.14113769f, -0.06155098f, -0.03539891f, 0.00927184f, 
    -0.01989687f, 0.06052513f, 0.12386350f, -0.03099642f, 0.25556239f, 0.04322469f, 0.10804667f, 0.18496670f, 
    -0.19155246f, -0.12153231f, -0.09373992f, -0.04556188f, -0.02320852f, -0.04486847f, 0.14580309f, 0.14837869f, 
    -0.08441759f, -0.10387097f, 0.06239317f, -0.08464908f, -0.25146413f, -0.07913066f, -0.02665337f, 0.13125961f, 
    -0.07911924f, -0.18246268f, 0.03073711f, 0.23899682f, -0.27952087f, 0.02092057f, -0.33617541f, -0.28539094f, 
    -0.09739009f, -0.01885037f, 0.04066758f, 0.05112655f, -0.02456901f, -0.00456292f, -0.16881232f, -0.06674422f, 
    0.05498706f, 0.31121209f, -0.08764188f, -0.07010494f, -0.09043554f, -0.02678169f, -0.13250062f, 0.06974722f, 
    -0.09614847f, -0.10418123f, 0.09715082f, -0.20739788f, -0.19856249f, 0.20355907f, 0.05062652f, -0.17672445f, 
    -0.18225586f, 0.09223848f, 0.21852449f, 0.06271641f, -0.04762442f, -0.00561177f, -0.03555376f, -0.03067821f, 
    0.29476881f, -0.04860823f, 0.21515514f, -0.02089356f, -0.05532004f, 0.01736906f, 0.10905889f, -0.12491288f, 
    -0.03902958f, -0.06810845f, -0.16370533f, 0.08369866f, 0.28035262f, 0.16769284f, -0.24143596f, -0.07461408f, 
    -0.01388186f, -0.03473384f, 0.09901377f, -0.01132559f, 0.08191297f, -0.02003110f, 0.10460618f, 0.32353690f, 
    -0.33581918f, 0.14620753f, 0.30157888f, 0.00519842f, -0.04004496f, -0.01693610f, -0.09286004f, -0.02066623f, 
    0.04544634f, 0.09681498f, 0.19483280f, 0.17633854f, 0.21871552f, -0.58762062f, 0.21386176f, 0.00524576f, 
    0.07333337f, 0.11863143f, -0.00152307f, 0.07654298f, 0.12470200f, -0.00410363f, -0.05107963f, -0.03420486f, 
    0.41967431f, -0.02131884f, -0.11735335f, -0.08407956f, 0.11301650f, 0.03440727f, -0.02661236f, -0.10617898f, 
    -0.01716162f, -0.19099380f, 0.00572189f, -0.02638443f, 0.36115831f, 0.16296995f, -0.16134816f, 0.13026349f, 
    0.03126645f, -0.10754240f, -0.03438076f, -0.05564353f, 0.00075049f, 0.16550310f, 0.04560420f, -0.06416399f, 
    -0.06942253f, 0.17656581f, -0.04123285f, 0.19864175f, -0.12171451f, -0.12434191f, 0.10695591f, 0.06951526f, 
    0.07565197f, -0.02650288f, -0.10486799f, 0.04622391f, 0.05102002f, 0.20271887f, 0.18604997f, 0.04987441f, 
    0.02259460f, 0.05357056f, 0.07076049f, -0.03760620f, -0.02448446f, 0.03071659f, 0.10860839f, 0.07807038f, 
    -0.05554194f, 0.00611621f, -0.46641931f, -0.23622128f, 0.09159168f, 0.08241794f, 0.14515945f, -0.15820508f, 
    -0.01155183f, -0.11959457f, -0.09577402f, -0.02855240f, 0.04261204f, 0.03906581f, -0.05888570f, 0.05974417f, 
    0.12831677f, -0.09204043f, 0.04138215f, 0.00878963f, -0.07267013f, 0.04205886f, -0.11483649f, -0.06583117f, 
    -0.30243972f, 0.17556348f, 0.05675729f, -0.03749048f, 0.01768325f, -0.03753088f, -0.08119321f, 0.04767282f, 
    -0.05549214f, -0.13101594f, -0.08119138f, 0.04582890f, 0.23075816f, 0.57014215f, 0.09882724f, 0.05472783f, 
    -0.15522932f, -0.03918077f, 0.02322662f, -0.04237573f, 0.13979734f, 0.00258660f, 0.08449103f, 0.12038426f, 
    -0.29453659f, 0.08267566f, 0.12057436f, 0.02113193f, -0.04744517f, 0.07605375f, -0.01636557f, -0.09233448f, 
    -0.11102274f, -0.05553410f, -0.02484254f, -0.08710416f, 0.03957324f, 0.09716517f, -0.00482415f, -0.17651752f, 
    0.06490619f, -0.08813350f, 0.06473757f, 0.04052378f, -0.15085828f, -0.08138606f, -0.12211157f, -0.23625973f, 
    0.16820487f, -0.31517565f, 0.08274045f, 0.16649711f, 0.17553413f, 0.00630010f, 0.12509254f, -0.24151407f, 
    0.02854033f, 0.05621818f, -0.04603908f, 0.17438652f, 0.28510848f, 0.20224833f, 0.29741061f, -0.20635299f, 
    0.08267297f, -0.00508708f, -0.04355444f, -0.04170225f, 0.03084649f, 0.01382929f, 0.05798408f, -0.01264858f, 
    -0.03205537f, -0.02461007f, -0.04380696f, -0.00212305f, 0.01256737f, -0.01738359f, -0.04119100f, -0.00940468f, 
    -0.05302725f, 0.06178934f, -0.03905546f, -0.01010611f, 0.04022203f, -0.00173041f, -0.01130101f, -0.00237304f, 
    0.03872304f, 0.03353599f, 0.00948378f, -0.07650398f, 0.03339060f, -0.00228096f, -0.00464718f, 0.06043804f, 
    -0.06622088f, 0.03309215f, -0.00637923f, -0.02712827f, -0.07339785f, -0.06199560f, -0.07765525f, -0.03184550f, 
    0.00389087f, -0.01503173f, -0.05860345f, 0.03163863f, 0.02557793f, -0.03736302f, -0.05861377f, 0.03928580f, 
    -0.02972754f, 0.01345336f, 0.05368404f, -0.06121551f, 0.01676554f, -0.00364572f, -0.07156488f, 0.03231684f, 
    -0.05863923f, 0.00069292f, 0.04738357f, 0.04227192f, -0.02919675f, -0.05645917f, -0.04923782f, 0.01883409f, 
    -0.04274169f, -0.01514004f, -0.01227413f, 0.01390659f, 0.06099578f, 0.00070979f, -0.05030792f, -0.04374474f, 
    0.03404458f, 0.05254517f, -0.02797553f, 0.01849998f, -0.01629254f, -0.02011799f, 0.00664891f, 0.00362697f, 
    0.03775012f, 0.04353402f, -0.06608546f, -0.03596037f, 0.00608814f, -0.04220281f, -0.02278813f, -0.06902532f, 
    0.01744995f, 0.03978885f, -0.06698689f, 0.04295294f, 0.03118227f, 0.06585599f, 0.01222968f, 0.02457394f, 
    0.03998620f, -0.04498961f, -0.03702883f, -0.01763631f, -0.06933103f, 0.01496257f, -0.02294996f, 0.02253971f, 
    -0.02303572f, -0.01777231f, 0.05026080f, -0.03805105f, 0.05246023f, -0.01759298f, -0.05332812f, 0.04466953f, 
    -0.06055741f, 0.06117839f, -0.05686459f, 0.04130322f, 0.00971138f, 0.00929329f, -0.01470663f, -0.01418270f, 
    -0.06127676f, -0.01558531f, -0.06585897f, -0.07512610f, -0.04672179f, 0.04672536f, -0.01261917f, 0.03250203f, 
    -0.05830279f, -0.00839274f, -0.05371977f, -0.02880100f, 0.02073643f, 0.03565329f, 0.00302364f, -0.06750160f, 
    0.00054500f, 0.00675979f, -0.02587071f, 0.00121001f, -0.05063048f, 0.00209284f, -0.06018284f, -0.07000212f, 
    0.05495909f, -0.02943665f, 0.02781254f, 0.05664057f, 0.00368826f, -0.05698411f, -0.00262040f, 0.03712145f, 
    0.06088270f, -0.07323976f, 0.02027182f, 0.02630905f, -0.03107529f, -0.03713910f, -0.04072019f, -0.03636606f, 
    -0.04917628f, -0.03033579f, 0.03195944f, -0.01146039f, -0.02317731f, -0.00814025f, -0.04769129f, 0.02823954f, 
    0.01536284f, 0.02747910f, -0.02016491f, -0.06369346f, -0.02701553f, -0.04423837f, -0.01454361f, 0.01035688f, 
    0.04783672f, 0.02300617f, 0.01401404f, -0.01674217f, -0.01967049f, -0.05534735f, 0.04900854f, -0.00527161f, 
    -0.01079576f, 0.06471540f, -0.06003015f, -0.04780924f, 0.00352488f, -0.06227985f, -0.03719808f, -0.07277919f, 
    -0.05647946f, -0.04718842f, -0.02903640f, -0.04668776f, 0.01799079f, 0.04168130f, -0.02742137f, 0.06094941f, 
    0.32589135f, 0.19918317f, 0.09606571f, 0.01361972f, -0.24997386f, -0.01128145f, -0.06741998f, -0.00916090f, 
    -0.07522283f, 0.04568843f, -0.03974688f, -0.05622867f, -0.05752760f, 0.01249464f, 0.47306967f, -0.07891853f, 
    -0.09997062f, -0.06577251f, -0.10244360f, 0.05347316f, -0.09823935f, 0.03895833f, -0.02080910f, 0.05190900f, 
    0.16395983f, -0.37909219f, -0.22832294f, 0.02050603f, -0.01924233f, -0.06209610f, 0.04698465f, 0.17986539f, 
    -0.07622265f, 0.01092800f, -0.23276652f, 0.11546580f, -0.28770167f, 0.02153048f, -0.21564750f, 0.27785471f, 
    0.05661548f, 0.03672142f, 0.05032313f, 0.05927736f, 0.00168039f, -0.22473565f, -0.08612265f, 0.10154902f, 
    0.21595125f, 0.16020885f, -0.02523056f, 0.00064067f, 0.02803735f, 0.10170317f, -0.07696539f, 0.08327655f, 
    -0.16626941f, -0.02510977f, 0.13503286f, -0.08215938f, -0.02215523f, 0.14533985f, 0.03999942f, 0.24096143f, 
    0.02230239f, -0.00100057f, 0.12106542f, -0.11385953f, -0.07243802f, -0.10712785f, -0.22512232f, -0.16109559f, 
    0.01768204f, 0.08673653f, -0.08493119f, -0.25995341f, 0.10558946f, -0.14996837f, 0.10632211f, -0.16186090f, 
    -0.05623386f, 0.06039870f, -0.18657729f, -0.12318230f, -0.09583307f, 0.08256042f, -0.16416661f, 0.24285375f, 
    0.09200794f, -0.05543016f, 0.01084299f, 0.20448774f, -0.09651554f, 0.03405761f, 0.04552651f, -0.18261549f, 
    0.68078166f, 0.06537972f, 0.65209967f, -0.18004096f, -0.19031644f, -0.20481439f, -0.07216761f, 0.02941949f, 
    -0.01076301f, -0.01125182f, 0.03279348f, 0.10244694f, -0.14514597f, 0.09866683f, -0.06926433f, 0.08316384f, 
    0.04557695f, 0.18240745f, -0.01410396f, 0.11464288f, 0.15252525f, 0.14824122f, 0.17265908f, 0.00574809f, 
    0.07903127f, 0.02165540f, 0.09889150f, 0.02610991f, 0.02556627f, 0.18898951f, 0.21550560f, 0.26440695f, 
    -0.01393646f, 0.07217378f, 0.03099936f, 0.06452589f, 0.41063344f, -0.13002831f, -0.40029657f, -0.30599281f, 
    0.06213555f, -0.04904205f, -0.07194169f, -0.12807606f, -0.16555968f, 0.07962019f, -0.00572021f, -0.01158717f, 
    0.54518574f, -0.01289927f, 0.07612344f, -0.04186008f, 0.06784834f, 0.01283457f, -0.10328931f, 0.00059548f, 
    -0.05836407f, 0.10200280f, -0.12355631f, -0.19718371f, 0.12249558f, 0.02945537f, 0.29750875f, 0.20767613f, 
    -0.18983452f, 0.15470390f, 0.14001526f, 0.05609993f, -0.03637653f, 0.03681372f, -0.03494537f, -0.08404437f, 
    0.00935183f, 0.32958817f, -0.04968488f, -0.15483342f, -0.07329480f, 0.03284474f, 0.01341190f, -0.01435980f, 
    -0.09927611f, 0.13570127f, -0.12141819f, -0.16542104f, 0.09098083f, -0.12659903f, -0.29396692f, 0.39229214f, 
    -0.00477840f, -0.15164718f, 0.20617907f, 0.09936903f, 0.10685486f, 0.14641504f, -0.11143253f, 0.06161511f, 
    -0.27877596f, 0.00484609f, 0.02943358f, 0.14022991f, -0.19616200f, -0.13111715f, -0.20848921f, -0.06150073f, 
    -0.13654467f, 0.01909230f, 0.04907694f, 0.20816654f, -0.11366995f, 0.35373962f, 0.03236328f, 0.16635248f, 
    0.21720959f, 0.05509811f, -0.02528629f, 0.07484157f, -0.10164763f, 0.01700949f, 0.06690648f, -0.18555510f, 
    -0.18294874f, 0.11252649f, -0.18434966f, 0.00650033f, 0.13185352f, 0.12611462f, 0.15060401f, 0.08912811f, 
    0.13541649f, 0.11879793f, -0.09055297f, -0.05178632f, 0.09942637f, 0.18648759f, -0.13000384f, -0.34513104f, 
    0.02612985f, -0.04672882f, 0.08678787f, 0.11525212f, 0.05096418f, -0.08082751f, -0.13333182f, 0.01130235f, 
    -0.03329026f, -0.24424425f, 0.01504651f, -0.15349944f, -0.02202350f, -0.03981857f, -0.07279577f, 0.09368006f, 
    0.22996271f, 0.11886825f, 0.12272825f, -0.06636652f, 0.20739791f, 0.07109051f, 0.11477776f, 0.29727411f, 
    -0.08896695f, -0.12708284f, 0.02389115f, -0.16621651f, 0.20877421f, 0.03694752f, -0.07104725f, 0.33104330f, 
    -0.22162175f, -0.37345710f, 0.01776020f, 0.18324739f, -0.11041149f, 0.02627865f, -0.26930952f, 0.02158267f, 
    0.16540696f, -0.03054195f, 0.36363056f, 0.07270388f, 0.03109699f, 0.10757924f, 0.08153642f, -0.23142958f, 
    0.06131229f, -0.14716804f, -0.01870431f, 0.06277983f, 0.00591842f, -0.08066130f, -0.05741125f, -0.15757579f, 
    -0.28690070f, 0.17494255f, -0.23092282f, 0.36710289f, 0.21592502f, 0.01755056f, 0.08271343f, 0.03319028f, 
    -0.04468013f, 0.01310596f, -0.01746318f, 0.09674863f, 0.12671068f, -0.21157703f, -0.10024382f, -0.06371711f, 
    -0.10878737f, 0.17504738f, 0.15892141f, 0.15472504f, 0.36364257f, 0.08813899f, 0.04161161f, 0.14958480f, 
    -0.08766245f, -0.05258862f, -0.09996607f, -0.25985712f, -0.02292277f, 0.07310379f, -0.03656224f, -0.24972674f, 
    -0.01379122f, 0.12596293f, 0.09203997f, 0.03233403f, -0.49864152f, -0.26195678f, -0.11454152f, 0.04992751f, 
    -0.13764156f, -0.06613540f, -0.12790874f, -0.01432088f, 0.11983943f, 0.02729090f, -0.00163261f, -0.10351009f, 
    -0.21561237f, 0.31699300f, 0.10103671f, -0.13309546f, 0.05921897f, -0.07996963f, 0.19340929f, 0.05932176f, 
    0.07886287f, -0.06214453f, -0.08925319f, -0.15301281f, 0.06934104f, 0.14943482f, -0.01511406f, -0.17630659f, 
    0.13739720f, 0.12557094f, -0.08647931f, 0.13469365f, 0.00380472f, 0.12818040f, 0.17704888f, 0.16163070f, 
    0.07302634f, -0.23779398f, -0.10254562f, -0.10880297f, -0.21797369f, -0.07954624f, -0.19962373f, 0.01909389f, 
    0.15209015f, 0.01707261f, 0.02335515f, -0.00605059f, 0.16936074f, -0.10437293f, 0.28617987f, -0.36134532f, 
    0.03435091f, 0.21933037f, 0.04744418f, 0.20061111f, -0.09536198f, -0.09270028f, 0.06648636f, -0.03546657f, 
    -0.00658503f, -0.23095903f, -0.09792827f, 0.01335181f, -0.04694627f, 0.00397370f, 0.06037722f, 0.02865794f, 
    -0.13533048f, -0.29280826f, -0.00589775f, -0.14358325f, 0.33706301f, -0.04740709f, -0.14167899f, -0.07366268f, 
    -0.02824094f, 0.00380792f, 0.07000686f, -0.02850179f, -0.18387000f, 0.14922900f, -0.11400028f, 0.12706484f, 
    0.06941643f, 0.14974934f, 0.38280573f, -0.31695157f, -0.19808197f, -0.02900068f, 0.13110580f, 0.00292970f, 
    -0.08067662f, 0.00135513f, 0.01981474f, 0.13915375f, -0.03044379f, 0.06829928f, -0.50071603f, 0.30323240f, 
    0.12988065f, 0.18575129f, 0.09104801f, -0.20561685f, 0.05131052f, 0.02292428f, 0.16621211f, 0.08821072f, 
    -0.03693428f, 0.18856978f, -0.12238918f, 0.07019448f, -0.13559873f, 0.12034729f, -0.17647074f, 0.08527847f, 
    0.06309684f, -0.05850900f, -0.10902014f, -0.18615250f, -0.00158561f, 0.11303223f, 0.15459833f, 0.25288904f, 
    0.01471707f, 0.11787509f, 0.02976378f, -0.07900506f, 0.08350683f, -0.08361425f, 0.04315428f, 0.14944772f, 
    -0.13094567f, 0.11370271f, 0.19528975f, 0.00168020f, -0.05614424f, -0.22290707f, 0.15148100f, -0.12007174f, 
    -0.05126061f, 0.14120933f, -0.00203664f, -0.11787064f, -0.02323394f, 0.32066748f, -0.27063751f, -0.16713440f, 
    0.13060601f, 0.11011578f, 0.13646877f, -0.10959465f, -0.07973495f, 0.22385618f, 0.02233015f, 0.19583693f, 
    0.24700475f, -0.57442892f, 0.18684860f, -0.33615729f, -0.06434376f, -0.00260334f, 0.15048267f, 0.11966744f, 
    -0.13291392f, -0.01450802f, -0.20977615f, 0.06742407f, -0.11553428f, 0.01488141f, 0.19016200f, 0.09455755f, 
    0.27376300f, 0.01262933f, 0.00961179f, 0.00548499f, -0.09030294f, -0.06906667f, -0.01994677f, -0.06426060f, 
    -0.04215598f, 0.17001218f, -0.09767880f, -0.15719229f, -0.07971259f, -0.02915231f, 0.05470227f, 0.13425714f, 
    0.07999754f, -0.11737026f, -0.16480505f, -0.06621871f, -0.28823325f, 0.38744828f, 0.39139056f, 0.03014637f, 
    -0.10956674f, -0.02842374f, -0.08349961f, -0.04433342f, -0.11337683f, 0.15711161f, 0.14969069f, -0.09808144f, 
    0.03258162f, -0.06325925f, -0.03929283f, -0.12888816f, 0.09496595f, 0.31568131f, -0.08853466f, -0.08855299f, 
    -0.06329973f, 0.01877101f, -0.01994261f, -0.21879797f, 0.18420738f, -0.14009807f, 0.04850932f, -0.07230067f, 
    -0.05367554f, 0.11141787f, 0.06133321f, -0.01568928f, 0.10496711f, -0.11184327f, -0.04949561f, -0.03715777f, 
    -0.32515958f, -0.01510121f, -0.09151547f, 0.29045263f, 0.04189056f, 0.10279477f, 0.18917757f, -0.02543302f, 
    0.03197857f, -0.00139769f, -0.12167051f, -0.17991622f, 0.15980095f, 0.28799474f, -0.15564768f, 0.31481043f, 
    0.17620507f, -0.02018138f, -0.03062126f, 0.16447009f, 0.07174756f, 0.11669763f, -0.04215680f, -0.00530931f, 
    -0.10363507f, 0.04139485f, 0.10670774f, -0.03015671f, 0.01609026f, -0.05975976f, 0.04174538f, -0.12661539f, 
    -0.05160430f, -0.06724371f, -0.12883404f, 0.03120026f, 0.13885655f, 0.43688497f, -0.24641325f, -0.08746857f, 
    0.08584978f, 0.05696851f, 0.09653255f, -0.04096093f, 0.01189274f, -0.11603969f, 0.17052692f, 0.11136296f, 
    -0.20104687f, 0.10979547f, -0.12125526f, -0.02410545f, 0.05554780f, 0.04418110f, -0.07553506f, 0.04652730f, 
    0.14327571f, -0.01352611f, 0.13911986f, 0.17078704f, -0.11860808f, -0.54278809f, -0.28856900f, -0.16248244f, 
    -0.01837467f, 0.16385542f, 0.06163539f, 0.12544006f, 0.08572442f, 0.10799920f, 0.11027073f, 0.11516690f, 
    0.02211620f, -0.12469146f, -0.11114939f, -0.08290235f, 0.24614535f, -0.07672571f, 0.31664953f, -0.02413190f, 
    -0.08080070f, -0.10395242f, 0.06287938f, 0.02886646f, 0.21096924f, 0.25345916f, 0.19635205f, -0.07392363f, 
    0.12691079f, -0.10276815f, -0.00673680f, 0.06222045f, -0.08724610f, 0.03741526f, 0.40847838f, 0.03783353f, 
    0.06029518f, 0.14255160f, -0.06162599f, -0.03092051f, 0.04829868f, 0.10596137f, -0.08095309f, -0.00515660f, 
    0.05672076f, -0.16030155f, 0.03535930f, 0.27916595f, -0.30072376f, -0.42463267f, -0.15327813f, -0.14596480f, 
    -0.07099073f, 0.04431299f, 0.17400652f, 0.28709432f, -0.10494318f, 0.09392735f, -0.10859729f, 0.04147196f, 
    -0.76005816f, 0.25797990f, -0.68634742f, 0.14719746f, 0.31744200f, 0.06149161f, 0.13899332f, 0.00553257f, 
    -0.04850499f, 0.02299070f, -0.18741587f, 0.04268384f, 0.21862867f, -0.17890124f, -0.07397431f, -0.24440663f, 
    0.08448588f, -0.14869837f, 0.31047830f, 0.11031161f, 0.11804605f, -0.05740486f, -0.09525575f, -0.00150131f, 
    0.26818457f, -0.21341087f, 0.04436663f, 0.06435238f, 0.19293243f, -0.19732022f, 0.14756082f, 0.01953186f, 
    -0.01608300f, 0.09675313f, 0.06616098f, 0.16416498f, 0.46116823f, 0.27351987f, 0.31538361f, -0.00236764f, 
    -0.01888366f, -0.12845455f, -0.09046779f, -0.25473681f, 0.01019116f, 0.12606259f, 0.09890026f, 0.12966612f, 
    -0.31277806f, -0.37053144f, -0.41632447f, -0.15580107f, 0.03158390f, -0.08900043f, 0.10429666f, -0.00006050f, 
    0.08423029f, -0.10297812f, 0.10569777f, 0.10174269f, -0.56557524f, -0.12669453f, -0.49882248f, -0.32663199f, 
    0.08691739f, -0.40295735f, 0.12584262f, 0.10840864f, 0.06213243f, 0.07792143f, -0.10085587f, -0.04644073f, 
    0.09294479f, -0.08749594f, 0.06227676f, -0.06212698f, 0.10394271f, 0.11877379f, -0.11052790f, -0.01336668f, 
    0.09949445f, -0.04772181f, 0.07212143f, -0.03369316f, -0.26212093f, 0.06853599f, 0.45387882f, -0.16863565f, 
    0.04071143f, 0.12035826f, 0.01495084f, -0.02384669f, 0.01446320f, 0.06892480f, 0.12543759f, 0.12947591f, 
    0.11111400f, -0.01506905f, -0.15837672f, -0.03279470f, 0.31754977f, -0.28323045f, -0.13136141f, 0.12179227f, 
    0.08043294f, 0.04944149f, 0.06346436f, 0.03634245f, 0.21350299f, -0.17640220f, -0.15702963f, 0.24168548f, 
    -0.23834644f, -0.04917130f, 0.08307313f, -0.27280730f, 0.22290893f, 0.01538848f, 0.11542007f, 0.28052130f, 
    0.30171296f, 0.17638385f, -0.02649650f, 0.10651949f, 0.18283743f, -0.14594118f, 0.14449330f, 0.00199815f, 
    0.37351131f, -0.00602017f, 0.05318007f, 0.00442704f, 0.52327323f, 0.17629004f, 0.49124745f, -0.26851246f, 
    0.08349891f, 0.27285707f, -0.05315736f, 0.03188907f, -0.14438440f, 0.09214501f, 0.22393732f, 0.10709976f, 
    -0.29832590f, -0.11398966f, -0.26006222f, -0.19619884f, 0.21199235f, -0.21895514f, 0.11156013f, -0.19181702f, 
    -0.15070820f, -0.00627433f, -0.37614369f, -0.29620644f, 0.07094621f, -0.20001230f, 0.07417071f, -0.03365792f, 
    -0.19551697f, -0.02169667f, -0.00047245f, 0.03989081f, -0.13291998f, 0.11485698f, 0.20166928f, -0.09838308f, 
    0.19963537f, 0.14873056f, 0.07871621f, -0.45308748f, -0.19409965f, 0.03153931f, -0.12968174f, -0.08261307f, 
    -0.01925069f, 0.11489171f, 0.16106910f, -0.01506486f, 0.34755361f, 0.08045843f, 0.23629430f, -0.09880473f, 
    0.21106143f, 0.14326859f, 0.04443437f, 0.16880825f, 0.10381902f, -0.06099603f, -0.00959087f, 0.21721603f, 
    -0.52249366f, 0.43591905f, -0.36787602f, 0.39763215f, 0.14162943f, -0.00322035f, -0.05217572f, 0.01881435f, 
    -0.14315927f, -0.19303089f, 0.00951310f, -0.27659744f, 0.05031556f, 0.19921261f, 0.27296028f, -0.14941700f, 
    0.03060128f, 0.10236840f, -0.21275145f, -0.10537599f, -0.41060957f, -0.35790837f, -0.32267851f, -0.19818024f, 
    0.04454860f, -0.12721375f, 0.01276276f, 0.02854341f, 0.19661555f, -0.01450935f, 0.02120779f, -0.26569480f, 
    -0.21295075f, -0.10602091f, -0.09618443f, -0.40963563f, 0.42696548f, -0.23586723f, -0.03241739f, -0.17159791f, 
    -0.17721990f, 0.01264731f, -0.09727413f, 0.06063661f, 0.26596192f, 0.16077182f, 0.03680835f, 0.12466790f, 
    -0.12896520f, 0.07641376f, -0.15875986f, -0.09926438f, 0.19562766f, 0.16352543f, 0.09593140f, 0.27861360f, 
    0.04263716f, 0.08313582f, -0.07322874f, 0.24539568f, -0.04429249f, 0.14597145f, -0.15186150f, 0.19880611f, 
    0.27891859f, 0.04002576f, 0.21963206f, 0.27996016f, -0.34874466f, -0.13945429f, -0.11400688f, -0.00591017f, 
    0.14501205f, -0.09332212f, 0.38895127f, -0.15359843f, -0.07321130f, 0.06910992f, -0.17779961f, -0.38150200f, 
    0.08660613f, -0.06923345f, 0.20084506f, 0.11236688f, -0.01763912f, -0.23254026f, -0.13034870f, 0.07019170f, 
    0.04911344f, 0.03185266f, -0.03733085f, 0.05487658f, -0.21286790f, -0.11666047f, -0.03350544f, -0.00260887f, 
    0.02456435f, 0.06259295f, 0.01563445f, -0.06514538f, -0.02252660f, -0.00068834f, 0.06620221f, 0.00274172f, 
    -0.04684832f, -0.06531545f, 0.02670451f, -0.02398832f, -0.06319124f, -0.03181449f, 0.05495202f, -0.04490778f, 
    0.02517219f, 0.05877446f, 0.00521176f, -0.02837438f, -0.02523997f, -0.06512064f, -0.03362227f, 0.04400540f, 
    -0.02221287f, 0.01389535f, -0.05003479f, 0.06097807f, 0.05151390f, -0.04078300f, 0.02591389f, -0.05370767f, 
    0.01238078f, -0.02490981f, 0.02744868f, -0.01066967f, -0.07812500f, -0.00621173f, -0.03543665f, 0.03488792f, 
    -0.07046796f, 0.01042725f, -0.05079770f, 0.03698016f, 0.03529090f, -0.04340036f, -0.03678884f, -0.06970757f, 
    -0.00314992f, 0.02011285f, -0.06975845f, 0.00059883f, -0.01491753f, 0.00814488f, -0.03813758f, 0.04775891f, 
    0.01184035f, 0.03541951f, -0.01494827f, -0.01252133f, 0.00834153f, 0.02848268f, -0.00982402f, -0.05582903f, 
    -0.02340729f, -0.04816727f, -0.06889065f, 0.02305724f, -0.01526018f, -0.05183867f, -0.03146036f, -0.04700324f, 
    -0.01506831f, -0.01523468f, -0.00192416f, -0.07554833f, -0.03810222f, 0.03508780f, 0.02768484f, 0.05124039f, 
    -0.03208653f, 0.05476745f, 0.02100221f, 0.06277129f, -0.02573135f, -0.04276459f, -0.06612147f, 0.01193080f, 
    -0.03296360f, 0.04575096f, 0.05899312f, 0.02559456f, 0.05719922f, -0.06962609f, 0.02925018f, -0.02670319f, 
    0.01712271f, 0.01403461f, 0.03984052f, -0.00540728f, -0.02721703f, 0.01348420f, -0.05921249f, 0.01493122f, 
    0.00661512f, 0.01785571f, -0.06157897f, -0.04057002f, 0.02963990f, -0.03175672f, 0.01352660f, 0.02882952f, 
    -0.06695119f, -0.00594650f, -0.05113053f, -0.07879731f, -0.04227070f, -0.02794607f, -0.02923262f, -0.01494748f, 
    -0.06848400f, 0.00733801f, -0.06036523f, -0.02348823f, 0.03130438f, 0.04390798f, 0.00656201f, -0.04953197f, 
    0.03966464f, -0.05851193f, -0.02738096f, 0.05196761f, 0.00775672f, -0.02722326f, -0.01035535f, -0.01895449f, 
    -0.05062686f, 0.01179964f, 0.01272961f, 0.05779830f, -0.05354768f, -0.00218115f, -0.07275564f, 0.00385651f, 
    -0.07352406f, -0.07213899f, 0.05467031f, -0.02229387f, 0.03487608f, -0.07138487f, -0.03435643f, 0.02628557f, 
    0.00779611f, 0.05030311f, 0.06989726f, -0.06993499f, -0.04198663f, 0.06312550f, -0.04825018f, 0.05825441f, 
    0.01440708f, 0.02545255f, 0.01754691f, -0.05180375f, 0.01961588f, -0.05527590f, -0.02754485f, -0.01191755f, 
    -0.03754907f, 0.05858911f, 0.01634393f, 0.03149232f, 0.01141851f, -0.03500821f, 0.05747991f, 0.02451491f, 
    -0.02410023f, -0.05816980f, -0.04698035f, 0.00185311f, -0.07670882f, -0.05113992f, -0.04185134f, 0.01514828f, 
    -0.02159304f, -0.01573614f, 0.02918619f, -0.02127826f, 0.04434966f, -0.03366321f, -0.05366599f, -0.03412885f, 
    0.03004771f, -0.00752260f, 0.01807534f, -0.06935377f, 0.00429394f, -0.00235938f, 0.03787225f, 0.02008416f, 
    -0.08088899f, -0.08167584f, 0.00877714f, -0.07953026f, -0.06226479f, -0.08053803f, -0.02390170f, -0.05059662f, 
    0.04848339f, 0.02657541f, 0.00378796f, -0.04469341f, -0.03068282f, 0.03369430f, 0.03574872f, -0.02774154f, 
    0.05624522f, 0.04797765f, 0.05719997f, -0.07439359f, 0.04945300f, -0.04242029f, -0.05164872f, 0.04043490f, 
    -0.07117311f, 0.03345459f, -0.02352579f, -0.03900406f, 0.03147486f, -0.03735713f, -0.04548869f, -0.03727526f, 
    -0.03906313f, 0.00373588f, 0.04722705f, -0.05683790f, -0.07772486f, 0.05074449f, -0.08278946f, 0.03608736f, 
    -0.06984734f, 0.01599178f, -0.04624445f, -0.00606650f, -0.06520909f, -0.03914069f, 0.05323556f, 0.02369280f, 
    -0.08882786f, 0.00860517f, 0.04902790f, 0.05967913f, -0.00821848f, 0.05246124f, -0.02812127f, -0.05624189f, 
    -0.01891714f, 0.00995844f, -0.04548870f, -0.08430222f, -0.07846281f, -0.01852936f, 0.03619383f, 0.03927701f, 
    -0.08777599f, -0.01172477f, -0.00759976f, -0.01333712f, 0.02364043f, 0.04937985f, -0.05144365f, -0.00706015f, 
    -0.00239321f, -0.02326810f, -0.06462681f, -0.01735168f, -0.00396906f, 0.05064203f, -0.02058303f, -0.02570249f, 
    0.06172595f, -0.00824503f, -0.07482447f, -0.05423707f, -0.06722736f, -0.04322504f, 0.04924487f, -0.01642325f, 
    -0.00805143f, -0.06955278f, -0.05793056f, -0.02503200f, -0.07249881f, -0.00772833f, -0.03619597f, 0.04363642f, 
    -0.00229890f, 0.01898519f, -0.06599088f, 0.02221315f, -0.05142889f, -0.05406205f, -0.00860835f, 0.02542918f, 
    0.00876262f, 0.04425763f, -0.01509736f, 0.04426605f, -0.03437152f, -0.06128361f, 0.01083891f, -0.06174296f, 
    0.04264929f, -0.00335564f, -0.05186612f, -0.01268213f, -0.04312667f, 0.01993574f, -0.00234584f, 0.03235296f, 
    0.01475228f, 0.06855654f, -0.08785087f, -0.05432280f, -0.08249318f, 0.04406031f, 0.02486047f, -0.03381062f, 
    0.02655246f, -0.05188539f, 0.02787219f, -0.08567633f, 0.04454242f, -0.07621828f, -0.00261024f, -0.05283694f, 
    -0.05071528f, 0.05420127f, -0.01832941f, 0.03005384f, -0.01261074f, 0.04081223f, -0.05596996f, -0.03019876f, 
    -0.07363259f, 0.00781001f, 0.03533829f, -0.04871292f, 0.05585418f, -0.05625350f, 0.03392015f, -0.04274498f, 
    -0.03618894f, 0.02148418f, -0.04628363f, -0.01110984f, -0.06759401f, 0.02512789f, 0.02549404f, 0.02976250f, 
    0.02400212f, -0.01878476f, -0.05118603f, -0.08408783f, 0.01767490f, -0.02540450f, -0.02846126f, 0.00535840f, 
    -0.06712312f, 0.01790079f, -0.07667273f, 0.02375886f, 0.02520520f, -0.08121438f, 0.03240729f, -0.05481805f, 
    0.05183465f, -0.05747291f, -0.07704434f, 0.02341897f, -0.07484482f, -0.07855864f, 0.03335561f, -0.00909024f, 
    -0.06443959f, -0.08462980f, 0.02352236f, 0.19002745f, -0.15059248f, -0.18424478f, -0.14319439f, -0.10547175f, 
    0.01836630f, -0.05471701f, -0.01082968f, 0.20933674f, -0.27844614f, 0.08716937f, -0.18440574f, 0.17925946f, 
    0.06290781f, 0.04493231f, 0.04173058f, 0.01388348f, 0.01541389f, -0.17022771f, -0.17710456f, -0.11991550f, 
    0.22310100f, 0.34874958f, -0.17032151f, 0.23756129f, 0.16825463f, 0.01015527f, 0.04884461f, 0.12677529f, 
    0.07196057f, 0.01398589f, -0.15711965f, -0.04458865f, 0.27696359f, 0.42870420f, 0.00534111f, -0.38699901f, 
    0.02568529f, 0.12997338f, -0.03556118f, 0.11419423f, 0.06364487f, -0.07771268f, -0.09265511f, -0.15196812f, 
    0.00174757f, -0.23689185f, -0.06018515f, -0.16477841f, -0.11476238f, -0.01885196f, -0.04466897f, -0.04431050f, 
    0.17317384f, 0.25224438f, 0.09048589f, 0.04306293f, 0.22320059f, 0.06826591f, 0.08045517f, 0.11323201f, 
    -0.16933480f, -0.03202799f, 0.00433386f, -0.12283544f, 0.13266318f, -0.11628883f, -0.02284978f, 0.08146282f, 
    -0.00303211f, -0.12057225f, -0.02809958f, 0.07167993f, -0.09507363f, -0.17006120f, -0.16162561f, -0.02745917f, 
    0.13393244f, -0.08920275f, 0.41540861f, -0.05424359f, 0.15185426f, 0.19202465f, 0.24792199f, -0.05346014f, 
    0.11619705f, 0.17175750f, 0.05739083f, 0.16796196f, -0.05673516f, -0.09026361f, 0.04220896f, -0.12371092f, 
    -0.28478703f, 0.26095253f, -0.38984966f, 0.55317497f, 0.14736354f, 0.03321016f, 0.15409559f, 0.13816793f, 
    0.06447573f, 0.00766400f, 0.05560876f, -0.04885365f, 0.10397624f, -0.04241125f, -0.03236704f, 0.00777765f, 
    -0.11340803f, 0.31242466f, -0.01274977f, 0.25289214f, 0.17875600f, 0.11974660f, 0.15969039f, 0.13757779f, 
    -0.10367104f, -0.02083690f, -0.03682670f, 0.02064831f, -0.07357357f, 0.22601922f, 0.08224940f, -0.30745560f, 
    0.04698050f, 0.12559706f, 0.10929345f, 0.13648696f, 0.05583607f, -0.19932620f, -0.10898271f, 0.01555415f, 
    0.00237870f, -0.00813410f, -0.15553480f, -0.07017457f, 0.07707677f, -0.07383732f, 0.03476331f, 0.05232373f, 
    -0.27830866f, 0.33946821f, 0.01871381f, -0.06060915f, 0.00650220f, -0.18752760f, 0.09747308f, 0.10998400f, 
    0.08709528f, 0.00515828f, -0.07815605f, -0.09288343f, 0.07569076f, 0.00989626f, -0.04439125f, 0.11710357f, 
    0.23236139f, 0.27290863f, -0.01007638f, 0.22957392f, -0.07570624f, 0.10063700f, 0.12284493f, 0.23657633f, 
    0.10399399f, -0.24456988f, 0.06781354f, -0.07960154f, -0.04161127f, -0.10235411f, -0.09400053f, -0.02861118f, 
    -0.01585957f, 0.08374738f, -0.01261716f, -0.07130265f, 0.25670299f, -0.18701553f, 0.09047672f, -0.36473477f, 
    0.00744530f, 0.11048020f, 0.00514785f, 0.11587220f, 0.00293835f, -0.02793650f, 0.10819294f, -0.10422614f, 
    0.18751130f, -0.10747409f, -0.08818289f, 0.01070226f, 0.04199623f, 0.07446099f, -0.09696718f, 0.04461217f, 
    0.00146962f, -0.14778067f, 0.10313765f, -0.14543284f, 0.51905477f, -0.17769703f, 0.08363856f, -0.03580502f, 
    -0.15205386f, -0.12981771f, 0.09097577f, 0.00983666f, 0.05211475f, 0.02509449f, 0.08595084f, 0.04342560f, 
    0.03873553f, -0.14072619f, 0.37125957f, 0.21740626f, -0.11788262f, -0.04326994f, -0.00405650f, -0.00338256f, 
    0.06389218f, 0.02174554f, 0.24204515f, 0.06913535f, -0.59879524f, 0.11945792f, 0.04689292f, 0.71155226f, 
    0.14419273f, 0.05157521f, -0.00304037f, -0.03332388f, -0.16965607f, 0.05233581f, 0.14339018f, 0.11279476f, 
    0.01669801f, 0.04325574f, 0.06121646f, -0.01779330f, 0.10076641f, 0.13292351f, -0.11703434f, 0.22132027f, 
    -0.13041687f, -0.07416768f, -0.06380656f, -0.13450818f, -0.05042821f, -0.05747919f, 0.02762748f, 0.05704398f, 
    0.10596185f, -0.01873701f, -0.08181700f, 0.03478209f, -0.08322778f, -0.03326439f, -0.09802377f, 0.02611237f, 
    -0.29919478f, -0.11649527f, 0.10272509f, -0.11465850f, 0.06918078f, 0.06600647f, 0.01808649f, -0.05678469f, 
    0.01399018f, 0.31426513f, -0.10494536f, 0.01617080f, -0.23852324f, 0.00062344f, -0.01834195f, 0.26856545f, 
    0.00629633f, -0.08656293f, -0.16070825f, -0.10913698f, 0.17856216f, 0.20641300f, 0.12558722f, 0.09766749f, 
    0.63668627f, -0.02255445f, 0.53073645f, -0.37672400f, -0.05320773f, 0.13128716f, 0.00607789f, -0.02417765f, 
    -0.03911177f, -0.08893412f, -0.05696426f, -0.07136019f, -0.17690553f, 0.19944403f, 0.20369825f, 0.25047252f, 
    0.04928141f, 0.12672371f, 0.12718728f, 0.05722589f, -0.06145645f, 0.13080952f, -0.08884165f, 0.04754274f, 
    0.20006283f, 0.04943104f, 0.08848026f, 0.13787918f, -0.12968665f, -0.15944387f, -0.13366593f, 0.19344501f, 
    0.11328269f, 0.03154768f, 0.08903050f, -0.14593667f, -0.27894172f, 0.21172632f, 0.07599976f, 0.09036935f, 
    0.01391227f, -0.16437034f, 0.02343138f, -0.03944479f, -0.00587460f, -0.01859943f, 0.08328281f, 0.07339631f, 
    0.04262552f, -0.20349446f, 0.09622255f, 0.12057635f, -0.00139569f, -0.07809734f, -0.13753408f, 0.07125957f, 
    -0.07619530f, 0.00287771f, -0.05956447f, -0.03997824f, 0.16369244f, 0.01990223f, 0.18137558f, 0.08101425f, 
    -0.09865005f, -0.01927609f, 0.07681385f, -0.03394765f, 0.07605001f, -0.13274452f, -0.07366293f, -0.16245346f, 
    -0.14968017f, 0.14025287f, -0.16582468f, 0.26322144f, 0.03529515f, 0.13633081f, -0.08493520f, 0.02176405f, 
    0.02507184f, 0.05252870f, -0.06884268f, 0.05104419f, -0.10165817f, 0.32675233f, 0.26626807f, 0.07067869f, 
    0.02518107f, -0.14738363f, 0.01512768f, 0.00393012f, -0.08575886f, 0.17045036f, 0.01245307f, -0.10338970f, 
    -0.15197949f, -0.37823901f, -0.16069323f, 0.13774359f, 0.07410554f, 0.10467136f, -0.07481918f, 0.00803834f, 
    0.10425803f, -0.03265949f, 0.08891061f, 0.14268315f, -0.26438001f, -0.06903582f, -0.59340930f, 0.22252013f, 
    -0.24779294f, 0.14914748f, -0.05785868f, -0.25691217f, -0.01402351f, 0.00746558f, 0.09411800f, 0.17750996f, 
    0.04337607f, 0.29068491f, 0.04978523f, 0.19837129f, 0.05550059f, -0.09571004f, 0.05035990f, -0.13387831f, 
    0.04711535f, -0.02359951f, -0.04400010f, -0.03786011f, 0.33003214f, 0.00547629f, 0.37570602f, -0.09889034f, 
    -0.11219094f, 0.23234889f, -0.03604840f, 0.12062525f, -0.01275786f, 0.03500730f, 0.07120851f, -0.11766778f, 
    0.12608698f, -0.45092934f, -0.20545164f, -0.18486977f, 0.02363273f, 0.00960676f, -0.07858453f, -0.04723394f, 
    0.11359782f, 0.05474332f, -0.31890908f, -0.12842005f, 0.00503773f, -0.23226726f, -0.04037777f, 0.21107262f, 
    0.09990909f, -0.09743094f, -0.08339491f, 0.01242050f, -0.09862281f, -0.02443947f, 0.04115247f, -0.21410801f, 
    -0.20488906f, -0.11403168f, 0.03509833f, -0.06261603f, -0.06998243f, -0.07610629f, -0.22349271f, 0.08497512f, 
    -0.11857496f, -0.09517026f, 0.19140905f, -0.02403305f, 0.29225484f, 0.26660582f, 0.27079463f, 0.02083748f, 
    0.16092351f, -0.01892564f, -0.05768299f, 0.10124979f, -0.01808563f, -0.03357219f, -0.05157031f, 0.00045012f, 
    -0.32501036f, 0.22427742f, -0.51669437f, 0.31973895f, 0.05953882f, -0.00061390f, -0.07192226f, 0.12337499f, 
    0.13606705f, -0.09832103f, -0.00624811f, -0.22459464f, 0.19422337f, 0.11133514f, 0.16230555f, 0.03253858f, 
    0.05319598f, 0.17499940f, 0.08006277f, 0.00738131f, -0.16864184f, -0.02273766f, -0.23164743f, 0.05244439f, 
    0.31383193f, -0.04497004f, 0.12921312f, 0.07855670f, 0.00220961f, 0.20327665f, 0.07914656f, -0.28684190f, 
    0.20641690f, -0.22916712f, -0.15514304f, -0.03712333f, 0.15661497f, 0.05760632f, 0.16302134f, 0.07341860f, 
    -0.00564598f, -0.08667695f, -0.02878473f, -0.03738746f, 0.02061267f, 0.04210940f, 0.10059966f, 0.07388204f, 
    -0.18994027f, 0.06227544f, 0.03061883f, 0.00813253f, -0.03284648f, -0.05425500f, 0.04262441f, 0.12345391f, 
    -0.13359533f, -0.08903907f, 0.02937930f, 0.13675013f, 0.12434001f, 0.27851275f, -0.10616370f, 0.09449036f, 
    0.07283076f, 0.08729987f, -0.01229152f, 0.09598034f, -0.04080449f, -0.07550266f, 0.09483461f, 0.06683700f, 
    -0.17762785f, -0.57913554f, 0.23647867f, 0.21505685f, 0.20744908f, 0.15603369f, -0.01765923f, -0.22363976f, 
    0.20359959f, 0.05338020f, 0.03835642f, 0.04840012f, 0.15153088f, -0.13858144f, 0.30041069f, -0.52241385f, 
    0.09065525f, 0.01979459f, -0.16876958f, 0.13796860f, -0.19439204f, -0.12103780f, 0.08246145f, -0.01702834f, 
    -0.20310685f, -0.26681283f, -0.20091222f, -0.23824534f, -0.16244039f, 0.07768021f, -0.10069931f, 0.05359133f, 
    0.05350826f, 0.04463097f, -0.06032507f, -0.07891984f, -0.56323260f, -0.18254243f, 0.17020185f, 0.02252923f, 
    -0.01658162f, 0.00702883f, -0.23841012f, -0.07506722f, 0.08549798f, 0.02137114f, -0.05297673f, 0.36014473f, 
    0.21840522f, 0.18870477f, 0.07218555f, 0.33300629f, 0.06301155f, 0.07555921f, -0.13607152f, -0.09793743f, 
    0.02592437f, 0.00188248f, 0.14282872f, 0.13747916f, 0.00187184f, -0.25199857f, 0.32318249f, 0.00310803f, 
    0.05510382f, 0.07592355f, -0.01966427f, 0.17560896f, 0.04499198f, 0.00292724f, 0.06992856f, 0.05894889f, 
    0.34048554f, -0.07064429f, -0.09160533f, -0.01620105f, 0.05655728f, 0.08944115f, 0.07356673f, -0.12362631f, 
    -0.39809617f, -0.19796374f, 0.00080658f, -0.21672978f, 0.12594223f, 0.20957969f, -0.15375558f, 0.07181088f, 
    0.11863949f, -0.00526678f, 0.15513432f, -0.10343555f, -0.23297876f, 0.10600819f, -0.08427433f, -0.23305924f, 
    -0.21994837f, -0.02305866f, -0.29265130f, -0.02407213f, 0.01919420f, -0.00241871f, 0.10708283f, -0.01651978f, 
    -0.04288042f, -0.05854561f, -0.11127698f, -0.16206422f, 0.06852225f, 0.04930186f, 0.03162978f, 0.17521505f, 
    0.01298479f, -0.05515598f, 0.00554059f, 0.15228581f, 0.06448296f, -0.07204833f, 0.26209310f, 0.15204586f, 
    0.08276857f, -0.33633810f, 0.05664850f, -0.03986022f, 0.14979085f, 0.00717211f, -0.01459424f, 0.08716683f, 
    -0.00674892f, -0.05890231f, 0.15304099f, -0.11764815f, 0.06219884f, 0.20809063f, -0.26403025f, -0.06136531f, 
    0.05676027f, 0.03006715f, -0.23140341f, 0.13058913f, -0.20598929f, -0.09552564f, -0.24505606f, -0.29255328f, 
    0.17193009f, -0.14766125f, 0.19145478f, 0.22225869f, 0.03333616f, 0.07954749f, -0.06067855f, 0.09561832f, 
    -0.17945337f, -0.28318518f, -0.04177601f, -0.21350969f, 0.59087503f, 0.15754142f, 0.13639580f, 0.34247351f, 
    -0.06758886f, 0.09413680f, -0.07143777f, -0.20877744f, -0.02949799f, -0.00932426f, 0.06361117f, 0.22473440f, 
    0.37856111f, 0.29433271f, 0.50543344f, 0.14631003f, -0.11468112f, 0.08743441f, -0.10757891f, -0.08343921f, 
    0.05762410f, 0.02348353f, 0.05991638f, -0.06129462f, 0.23135301f, 0.14900742f, 0.23401938f, 0.13791066f, 
    -0.02896750f, 0.16841452f, 0.25263885f, -0.05600749f, -0.01713446f, 0.03526273f, -0.19747826f, -0.28707054f, 
    -0.23460788f, -0.05176331f, -0.28397566f, -0.51147401f, 0.22390838f, -0.15982874f, -0.03271588f, 0.01667912f, 
    -0.01810868f, -0.04817294f, -0.01632343f, 0.06388199f, 0.25938252f, 0.25357011f, 0.21066505f, -0.01704124f, 
    0.07455668f, -0.12250928f, 0.05290544f, 0.13573587f, 0.23165391f, 0.07372545f, -0.11703386f, 0.23882858f, 
    0.20036618f, 0.05677198f, 0.16755155f, 0.13697459f, -0.27399647f, 0.08967984f, -0.08429982f, 0.08142303f, 
    -0.15434951f, -0.09663924f, 0.10261540f, 0.03464507f, -0.01391544f, 0.13440146f, 0.23180050f, -0.10879964f, 
    -0.02805511f, -0.09568085f, 0.06489840f, 0.07123514f, -0.26454580f, -0.08217248f, 0.00821513f, -0.06819199f, 
    -0.06014147f, -0.27301463f, -0.05161477f, 0.02883795f, -0.06623841f, 0.00106359f, 0.01890827f, 0.02393907f, 
    -0.15727453f, 0.08747805f, -0.11113335f, 0.08651605f, -0.14444940f, 0.29986745f, -0.47509900f, 0.24080832f, 
    0.13323791f, -0.03878599f, 0.10173851f, -0.10961910f, 0.07743276f, -0.03719723f, 0.07415442f, 0.05970809f, 
    0.16011554f, 0.09132255f, -0.05456796f, 0.01654539f, 0.09888457f, -0.03945390f, -0.11732449f, 0.19656421f, 
    -0.24022774f, 0.02124750f, 0.05626291f, 0.00651364f, 0.13290709f, 0.16886483f, 0.16112038f, 0.21425407f, 
    -0.05077637f, -0.20303102f, -0.02791398f, -0.05660671f, 0.01203957f, -0.16962117f, -0.01477376f, -0.07987572f, 
    -0.19776200f, -0.03832151f, -0.05408321f, -0.20790644f, 0.01561132f, 0.06523330f, -0.12089196f, -0.20413837f, 
    0.00130701f, -0.06345031f, -0.12248790f, 0.07582784f, 0.00402432f, 0.20191374f, -0.29122382f, -0.04782391f, 
    0.18899021f, -0.12113054f, -0.03968295f, 0.16475575f, -0.14750730f, 0.00384032f, 0.15293670f, -0.17717962f, 
    0.36430997f, 0.01706821f, 0.24159978f, 0.05362402f, 0.07152925f, -0.00533649f, 0.00755348f, 0.06377131f, 
    -0.11361955f, 0.10114251f, 0.07364849f, 0.11658486f, -0.01690651f, -0.06251341f, -0.08808351f, 0.18947907f, 
    -0.00263359f, 0.22966363f, 0.08247029f, 0.05703656f, 0.23548667f, -0.12132830f, 0.09842689f, 0.07629000f, 
    0.33870453f, -0.15890266f, 0.14926648f, 0.06317095f, 0.16539352f, 0.10737136f, 0.20367575f, 0.14399466f, 
    -0.01607395f, 0.11729930f, 0.06159132f, 0.11135207f, 0.07247963f, -0.19677839f, -0.24298313f, -0.23457776f, 
    -0.03194923f, -0.05219844f, -0.18838859f, -0.25730273f, -0.11939828f, 0.09366961f, 0.09611087f, -0.14395922f, 
    0.63600552f, 0.17852822f, -0.00928203f, -0.31145668f, 0.05629161f, 0.09204341f, 0.00871869f, -0.02642331f, 
    0.02501505f, 0.03125184f, 0.07448410f, -0.02178625f, 0.16802849f, 0.02521971f, 0.06487392f, 0.14074473f, 
    -0.09858006f, 0.05126515f, -0.00882091f, 0.06533687f, -0.06410221f, 0.02232597f, -0.13196704f, -0.05451971f, 
    -0.12121404f, 0.15122560f, 0.05078905f, -0.04724602f, -0.04103429f, 0.12078383f, -0.08008802f, -0.00159134f, 
    0.00365994f, 0.07083614f, -0.04241817f, -0.13461611f, 0.20225297f, -0.25313172f, -0.07420779f, 0.08548892f, 
    0.08293197f, 0.02507473f, 0.07964996f, 0.16334613f, 0.07334293f, 0.15007916f, -0.04110004f, 0.00610350f, 
    0.29169703f, 0.03088884f, 0.19985498f, 0.07069968f, -0.31429589f, -0.16272527f, -0.09018750f, -0.11030144f, 
    -0.08042817f, -0.06710135f, -0.15601771f, -0.04952814f, 0.11179706f, 0.15318142f, 0.40271825f, -0.14349854f, 
    -0.03675900f, -0.07207316f, -0.00897811f, 0.00551727f, -0.04138098f, -0.01203293f, -0.11084150f, 0.17529073f, 
    -0.08905911f, 0.05990355f, 0.17362902f, -0.18521878f, -0.09210458f, 0.09673849f, 0.00232035f, 0.21680041f, 
    -0.10829884f, 0.19815560f, 0.00367214f, 0.16073683f, -0.10520642f, -0.11610340f, -0.38324958f, -0.14408407f, 
    0.17741992f, -0.10755195f, 0.07597047f, 0.01262009f, 0.21269624f, -0.13742317f, -0.07383499f, -0.02338677f, 
    0.19502224f, 0.43091208f, 0.12075179f, 0.07305137f, 0.06032617f, 0.05596369f, -0.00069468f, -0.05919649f, 
    -0.13204791f, -0.16144757f, 0.15546572f, 0.06275723f, 0.27798975f, 0.45882854f, -0.09418971f, -0.01611262f, 
    -0.04851039f, -0.03895097f, 0.01982271f, -0.18558472f, 0.08028022f, 0.01834017f, -0.01746878f, 0.16645053f, 
    -0.00386948f, -0.02814245f, 0.06382872f, 0.03924942f, 0.01800728f, -0.10436524f, 0.16674823f, -0.11450947f, 
    0.10998307f, 0.08029979f, -0.04944392f, 0.03348162f, -0.16359454f, 0.06905954f, -0.25370175f, -0.09257257f, 
    -0.13708057f, -0.06195481f, 0.08773326f, -0.13677835f, 0.01628131f, 0.09897828f, 0.14589448f, 0.01724266f, 
    0.25645599f, -0.56264478f, 0.14087531f, -0.31339058f, -0.18250380f, -0.15667877f, 0.18764205f, -0.16994764f, 
    -0.09298901f, 0.07474642f, -0.05431356f, 0.02151472f, 0.02267602f, -0.20489201f, -0.00938348f, -0.09637192f, 
    0.16139521f, 0.12980177f, 0.11963400f, 0.11047097f, 0.13451326f, -0.07013624f, 0.27399442f, 0.04090763f, 
    -0.46227023f, 0.24493867f, -0.13122533f, -0.17996523f, 0.13328373f, -0.01550573f, 0.13883743f, 0.08116069f, 
    -0.10877872f, 0.14187446f, -0.07022804f, 0.05973572f, -0.21596603f, 0.17253283f, 0.12034074f, 0.02164226f, 
    -0.20946878f, -0.04156089f, -0.00603643f, -0.08328548f, -0.01652730f, 0.15436098f, 0.19248842f, 0.07887680f, 
    0.05427060f, 0.14261673f, 0.21350223f, 0.04096861f, 0.06770360f, 0.17306201f, -0.05128946f, -0.11794226f, 
    -0.12935382f, -0.13327485f, -0.11004774f, -0.38761410f, 0.06036334f, -0.01766022f, 0.15670994f, -0.37097031f, 
    -0.08280047f, 0.16167237f, 0.19903328f, -0.12887195f, -0.10477275f, -0.00021389f, -0.15302195f, -0.17148995f, 
    0.00183368f, 0.24154109f, -0.12479250f, 0.10295522f, -0.14360535f, -0.05472674f, 0.07892647f, 0.12929152f, 
    -0.14691362f, 0.05737952f, 0.01291208f, -0.09500537f, 0.30338159f, 0.40440127f, 0.03612915f, 0.19324040f, 
    0.10361803f, 0.06201676f, 0.09923051f, 0.08090147f, 0.11289024f, 0.04886421f, -0.00789102f, 0.09380367f, 
    -0.30819494f, -0.18474106f, -0.18643445f, -0.11509158f, 0.14718927f, -0.18085311f, -0.14397411f, -0.19483471f, 
    0.07795752f, -0.10781968f, -0.04915748f, 0.01888667f, 0.12629817f, 0.03847864f, -0.16768326f, 0.02009109f, 
    0.06763630f, -0.08007206f, -0.06506482f, -0.14358406f, 0.21136343f, 0.12194500f, 0.00608797f, -0.04671963f, 
    0.07057544f, 0.13849057f, 0.34044197f, -0.03359038f, 0.07605001f, 0.07221576f, 0.07655818f, 0.05398581f, 
    0.17182934f, 0.03081650f, 0.30876517f, -0.00444823f, -0.19165871f, 0.11391596f, 0.34553736f, 0.10969103f, 
    0.00549718f, 0.06337991f, 0.04379891f, -0.08052469f, -0.03487847f, 0.01697653f, -0.05036651f, -0.00401901f, 
    -0.19099721f, -0.14941218f, 0.04751095f, -0.09488197f, -0.15538424f, 0.11485315f, -0.04124526f, -0.19381170f, 
    0.21089999f, 0.00124210f, -0.11351790f, -0.10826340f, -0.02039902f, 0.05625953f, 0.07949400f, -0.02987145f, 
    -0.05878328f, 0.04925814f, -0.06757426f, 0.03770188f, -0.04823314f, -0.08342022f, 0.00464632f, 0.19208683f, 
    -0.16871199f, -0.24345115f, 0.07211940f, 0.17859961f, -0.10665177f, -0.11030187f, 0.00446845f, 0.05217136f, 
    -0.01550540f, 0.08108403f, 0.13356693f, 0.06080792f, -0.12119750f, -0.02997694f, 0.16461992f, 0.07457090f, 
    -0.17615493f, 0.16548052f, 0.08991536f, -0.13430680f, 0.15411457f, 0.08964422f, 0.05216664f, 0.17614953f, 
    -0.02980569f, -0.15221544f, 0.03313661f, -0.26208830f, -0.09909768f, 0.24034575f, 0.01645915f, -0.13985364f, 
    -0.05776964f, -0.14570020f, -0.01675483f, -0.16076383f, -0.07899423f, -0.02364559f, 0.08100903f, 0.03946255f, 
    0.15811640f, -0.00134589f, 0.18857384f, 0.09029193f, 0.02606889f, 0.14940774f, 0.01837412f, -0.00005811f, 
    -0.01443300f, 0.14141536f, -0.12505244f, -0.00261005f, -0.22073114f, 0.00400764f, -0.18405968f, 0.00035244f, 
    -0.03706631f, -0.00206753f, 0.02150066f, -0.00019097f, -0.31201062f, 0.13047759f, 0.26742977f, 0.18563561f, 
    -0.01148417f, -0.00913711f, 0.09552370f, 0.17431994f, 0.13445868f, -0.00635618f, 0.07432529f, 0.05669267f, 
    -0.31623855f, -0.07309958f, 0.11416819f, 0.23323005f, -0.02274235f, -0.12298734f, 0.04536973f, -0.08895569f, 
    -0.02756006f, 0.00529444f, -0.00309151f, -0.05049393f, -0.07642505f, -0.00152412f, 0.06714601f, 0.00732648f, 
    0.17364317f, 0.06754429f, 0.06970356f, 0.10674990f, 0.05424525f, 0.00627747f, 0.09880465f, 0.00451953f, 
    -0.05437713f, -0.09680362f, -0.26869026f, 0.08614922f, -0.00589950f, -0.24754448f, -0.13452971f, -0.05736038f, 
    -0.12575093f, -0.15091531f, -0.09514996f, 0.05167111f, -0.18437688f, 0.35475394f, 0.25565219f, 0.06646610f, 
    0.02885000f, 0.16645370f, -0.11786334f, -0.09464322f, 0.13899510f, -0.09944735f, 0.02901179f, 0.04427737f, 
    0.30167550f, 0.23145944f, 0.19774434f, 0.08784313f, -0.08998480f, 0.00647957f, -0.09173093f, -0.03121617f, 
    0.08324879f, -0.00005823f, -0.04837108f, 0.05188547f, 0.11782166f, 0.01074904f, 0.24683803f, 0.09037514f, 
    0.03215917f, -0.00710755f, 0.05906326f, 0.09784349f, 0.09477313f, 0.09689552f, 0.15633829f, 0.13327579f, 
    -0.27556893f, -0.48648259f, -0.38998032f, 0.05141661f, -0.05305305f, -0.09268189f, 0.04546162f, 0.10070949f, 
    0.21720389f, 0.26854953f, 0.10174557f, -0.07212509f, -0.06497173f, -0.28695664f, -0.09004053f, -0.24564415f, 
    0.14203222f, 0.15631106f, -0.06749118f, 0.06516039f, 0.07897318f, -0.06849868f, -0.03068067f, -0.07903458f, 
    0.09571296f, 0.01786316f, -0.01209896f, -0.04297946f, 0.05202352f, -0.09248465f, -0.09981465f, 0.02947598f, 
    -0.03472374f, 0.00584716f, -0.15241404f, 0.00017777f, 0.20490536f, -0.08084126f, 0.08985083f, 0.26911649f, 
    -0.10783460f, 0.00251976f, -0.04706299f, -0.04462210f, 0.01330308f, 0.00235401f, -0.15530355f, -0.07587038f, 
    -0.00205354f, -0.08835732f, 0.07100857f, -0.04810658f, -0.09771494f, -0.05190032f, -0.00421217f, 0.03646395f, 
    0.01195363f, 0.07171196f, -0.00639283f, 0.03290571f, 0.02364304f, -0.19942223f, -0.09655386f, -0.34040093f, 
    0.20767736f, -0.02562916f, 0.11919139f, 0.17968582f, 0.05810224f, -0.06461482f, 0.12884358f, 0.05226586f, 
    0.63169229f, 0.42476693f, 0.32863140f, 0.16950200f, -0.07830629f, -0.14797269f, -0.00175744f, -0.04136011f, 
    -0.02311724f, -0.00895155f, 0.06982902f, -0.03535649f, -0.05979393f, 0.09448425f, -0.13911399f, 0.05180185f, 
    -0.02741295f, 0.40142331f, -0.07700981f, -0.01240341f, 0.00162719f, 0.08405405f, -0.02143439f, -0.01962097f, 
    0.02612273f, 0.12093956f, 0.11612336f, -0.09370915f, 0.03375163f, -0.01664734f, 0.06652140f, -0.02235018f, 
    0.01913348f, -0.02261457f, 0.03833364f, -0.03976440f, -0.03569489f, -0.17103630f, -0.27824798f, -0.14652784f, 
    -0.11347830f, -0.01804109f, 0.03143469f, 0.03809263f, 0.10978614f, -0.09807836f, -0.01912096f, -0.24785869f, 
    -0.09390769f, -0.18597701f, -0.38274184f, -0.53701240f, -0.22358052f, -0.19393675f, -0.08859311f, 0.15889786f, 
    -0.09114307f, -0.02618269f, -0.03955996f, -0.13133304f, -0.10106787f, -0.15325862f, -0.22375420f, -0.08687059f, 
    -0.05251179f, 0.08671822f, -0.13003771f, 0.16745088f, -0.09002104f, 0.00260157f, -0.00089819f, -0.06092037f, 
    0.26109052f, 0.19295901f, 0.09397174f, 0.21251535f, 0.02126274f, -0.02764429f, 0.01479170f, -0.00252546f, 
    0.03036991f, -0.00585568f, 0.03138268f, 0.01944927f, 0.13677455f, -0.55892873f, -0.20027086f, -0.46559241f, 
    0.03466057f, -0.00288328f, 0.03879757f, -0.01169107f, -0.02996421f, 0.01972161f, -0.05279054f, 0.05117597f, 
    -0.10684113f, -0.55882144f, -0.28432590f, -0.12175234f, -0.01903832f, -0.04314338f, 0.07239094f, 0.03426085f, 
    -0.08195383f, -0.09135843f, -0.04368694f, 0.12940437f, -0.11009663f, -0.23885840f, -0.43039382f, -0.11351964f, 
    0.11240888f, -0.00098750f, -0.07344429f, -0.14047919f, 0.09671527f, -0.00830756f, -0.06932871f, -0.03402146f, 
    -0.19212003f, 0.24574468f, 0.19642028f, 0.30345634f, 0.09703416f, -0.05570674f, 0.00551547f, 0.04325344f, 
    0.05190339f, -0.09026493f, 0.00129104f, 0.01190136f, 0.12678997f, -0.22344530f, 0.50990808f, -0.17668706f, 
    -0.02993029f, 0.12342734f, 0.01104163f, 0.31510645f, 0.22936587f, -0.05171852f, -0.05071674f, -0.02152380f, 
    0.29981926f, -0.24681710f, -0.05740102f, -0.17158827f, 0.13826582f, 0.23929933f, 0.11512405f, 0.09165220f, 
    0.11248057f, 0.06078043f, -0.10111545f, 0.02565864f, 0.18831897f, -0.08038702f, -0.11150125f, 0.12602952f, 
    -0.02377076f, -0.07953644f, 0.01638805f, -0.05262020f, -0.13659096f, -0.05783745f, -0.10734248f, -0.21087174f, 
    -0.24028739f, -0.22389096f, -0.03839324f, -0.06773487f, 0.02887330f, -0.05380183f, -0.13766268f, 0.13647075f, 
    0.02351943f, 0.03923608f, 0.08759248f, 0.07574160f, 0.16295274f, 0.31748131f, 0.25611162f, 0.18511382f, 
    0.04887193f, -0.01020558f, -0.02142445f, 0.14300458f, 0.15664521f, 0.05572768f, -0.07651611f, 0.03389538f, 
    -0.36404198f, -0.01674808f, -0.71242797f, 0.29211715f, 0.09454350f, -0.03661541f, 0.16201597f, -0.02191787f, 
    0.17303334f, -0.17710768f, -0.11791110f, -0.03823227f, 0.23407660f, 0.10569206f, 0.00944930f, 0.07110576f, 
    0.05383293f, 0.16863318f, 0.12866184f, -0.01244248f, 0.06575838f, 0.03192705f, -0.07292494f, -0.00196948f, 
    0.03403257f, 0.02392287f, 0.09284671f, -0.01581051f, -0.04018413f, -0.04495321f, 0.22546184f, 0.01406206f, 
    -0.02071130f, -0.20293902f, -0.11987677f, 0.02471267f, 0.12283497f, 0.12461021f, 0.18227579f, 0.12828411f, 
    0.02742758f, -0.02936575f, 0.00093023f, 0.05387689f, 0.02304427f, -0.11827078f, 0.13856833f, 0.04293196f, 
    -0.23850358f, 0.18159562f, 0.11363041f, -0.00829707f, 0.03648781f, -0.11090014f, 0.02451447f, 0.12885697f, 
    0.03986505f, 0.06758142f, -0.04649583f, -0.01884926f, 0.19735126f, 0.42122871f, 0.07130106f, 0.01568603f, 
    0.14248021f, -0.03189309f, 0.24760509f, 0.14283963f, 0.07683149f, -0.04976681f, -0.02410494f, -0.10441752f, 
    -0.26019856f, -0.62545484f, 0.02404121f, -0.02583335f, 0.14765486f, 0.09210882f, 0.03352850f, -0.06285469f, 
    0.08509424f, -0.08013909f, -0.02344521f, 0.14444304f, 0.36303502f, 0.07339463f, 0.38018575f, -0.21106878f, 
    0.12405998f, 0.19706690f, 0.07588479f, 0.09475690f, -0.07335906f, -0.13916488f, -0.01425276f, 0.00358470f, 
    -0.20130236f, -0.00681520f, 0.01636614f, -0.00353257f, 0.03035614f, 0.13144381f, 0.03713981f, -0.01486407f, 
    0.05906552f, -0.01609787f, 0.09264155f, 0.07721205f, 0.05584543f, 0.13325055f, -0.24465288f, -0.00516793f, 
    0.08841779f, 0.07293350f, -0.11608382f, -0.06076644f, -0.12056596f, -0.11707950f, 0.09784220f, -0.06818590f, 
    0.09712340f, 0.04378556f, -0.11192764f, -0.07266514f, 0.07542409f, 0.12643352f, -0.03648223f, -0.03335936f, 
    0.02885607f, 0.01563517f, 0.08946873f, 0.20612289f, 0.29364175f, 0.07295453f, -0.02657342f, -0.43389609f, 
    0.13707408f, -0.21558355f, -0.05270307f, -0.00336992f, 0.08116636f, 0.20185533f, 0.04962539f, 0.03647927f, 
    -0.13272323f, -0.04847295f, 0.03732168f, 0.03480474f, -0.02484560f, 0.08817228f, 0.11662541f, 0.03937173f, 
    0.14092022f, 0.02419817f, -0.04149373f, -0.04224963f, -0.13009383f, -0.09628062f, 0.35084343f, 0.10459097f, 
    -0.08382632f, -0.09918620f, -0.20263377f, -0.08949155f, 0.22405790f, 0.08004553f, 0.14177261f, 0.23461418f, 
    0.07838777f, -0.03896363f, -0.01431991f, 0.00640132f, -0.03519693f, 0.09511691f, 0.09680513f, 0.00422752f, 
    0.19550486f, -0.01231157f, 0.27957061f, -0.00842598f, 0.10693995f, -0.07496529f, 0.04931921f, -0.24399167f, 
    0.01242748f, -0.06109812f, -0.48445776f, -0.19189742f, -0.08646464f, -0.19946973f, -0.21229012f, -0.06553093f, 
    -0.12674338f, 0.11049236f, 0.12777370f, 0.17605706f, 0.33430541f, 0.19242574f, -0.08024970f, 0.20175330f, 
    0.04140537f, 0.01655413f, -0.04451201f, -0.06834298f, 0.03976183f, 0.01862721f, 0.09182896f, 0.00029717f, 
    0.12957840f, -0.14430267f, 0.08628361f, 0.03143336f, -0.10671613f, -0.09457037f, -0.19802621f, -0.09518545f, 
    -0.06416949f, -0.01105591f, -0.01799535f, -0.10638941f, -0.03084994f, 0.00411902f, 0.03955315f, -0.02491627f, 
    -0.06879620f, -0.04707456f, 0.04933317f, -0.08389259f, -0.36522329f, 0.08681489f, 0.09522970f, 0.19829783f, 
    0.01716960f, 0.06320668f, 0.10843234f, 0.06981440f, 0.18340278f, 0.02419545f, -0.01534086f, -0.16357128f, 
    -0.36655524f, 0.01420407f, -0.05118754f, -0.06979964f, -0.01354302f, -0.12572199f, 0.30937338f, -0.05066151f, 
    -0.08559215f, 0.01853018f, 0.00073644f, -0.08806325f, 0.03420356f, 0.09777956f, 0.08735592f, 0.05500966f, 
    0.14039034f, -0.06697878f, 0.02634080f, 0.29527885f, -0.06793534f, -0.12274618f, -0.05983217f, -0.10583073f, 
    0.00433961f, 0.00318410f, -0.01524286f, 0.01853893f, 0.03398730f, -0.02636159f, 0.05429976f, 0.02483064f, 
    0.14747015f, -0.10511514f, 0.00697210f, 0.10566533f, -0.20201561f, -0.06413350f, 0.01246257f, 0.09989861f, 
    0.22608425f, 0.24659884f, 0.07662116f, 0.12713155f, -0.13495465f, -0.26452243f, -0.01971355f, -0.11359702f, 
    -0.01073613f, -0.19790754f, -0.29445815f, 0.13283044f, -0.00804949f, 0.21097417f, 0.00074823f, -0.00979645f, 
    0.09028438f, 0.06338035f, 0.18694752f, 0.00357470f, 0.30432227f, -0.12970479f, -0.08741996f, 0.09058154f, 
    -0.00531365f, 0.06841602f, 0.14360617f, 0.09524037f, -0.04582316f, 0.00578390f, 0.13702050f, -0.13146049f, 
    -0.19184592f, 0.06927679f, 0.07752275f, 0.13291503f, 0.05765466f, 0.06713200f, 0.00356592f, -0.01195918f, 
    0.13033608f, -0.04413959f, 0.13341261f, -0.02804623f, 0.23768739f, 0.08188809f, 0.11086466f, 0.21622463f, 
    0.07851263f, -0.04368569f, 0.09931096f, 0.11162963f, -0.03033027f, 0.05322934f, 0.09985770f, 0.06850602f, 
    -0.02118631f, -0.33172670f, -0.19616148f, -0.01212994f, 0.06468158f, -0.07391298f, 0.02675149f, 0.14310433f, 
    0.12472025f, 0.05842225f, -0.29691517f, -0.01441593f, -0.04763889f, -0.25343749f, 0.07871742f, 0.17631866f, 
    0.07277638f, -0.14998211f, -0.08350024f, -0.03213213f, 0.03948458f, 0.15345067f, 0.07929128f, 0.13961481f, 
    -0.37873393f, -0.52139848f, 0.06770267f, -0.11200528f, 0.14833754f, 0.19243737f, -0.20077772f, -0.02444829f, 
    0.00564496f, -0.02906325f, 0.04456647f, 0.12431089f, 0.36813211f, 0.14621054f, 0.23305850f, 0.02196798f, 
    0.20300569f, -0.01171946f, -0.05750953f, 0.16171595f, 0.00116608f, -0.04053414f, 0.01509588f, 0.05352140f, 
    0.19885157f, 0.41693613f, -0.17010209f, 0.22248760f, 0.28012666f, -0.04720120f, -0.23430336f, 0.09454898f, 
    -0.02980620f, -0.02086912f, -0.16893841f, 0.02707225f, 0.06143029f, 0.13154447f, 0.01600555f, 0.02414762f, 
    -0.05155260f, -0.03640052f, 0.16963717f, 0.00529743f, 0.10053997f, -0.08173708f, -0.19586174f, 0.05334320f, 
    0.26033476f, -0.31562144f, 0.07807002f, -0.00606743f, -0.00124058f, 0.05226015f, -0.31019303f, -0.29858112f, 
    0.05047254f, 0.05536419f, 0.02208107f, -0.11379336f, -0.53647125f, -0.15579590f, -0.10373589f, -0.10909276f, 
    0.04558401f, -0.07839072f, -0.20527150f, -0.15379196f, -0.02269160f, 0.02891504f, 0.14452964f, -0.01640123f, 
    -0.07610355f, 0.18848737f, 0.06943033f, -0.34686881f, 0.11890256f, -0.07348090f, 0.30027211f, 0.23204111f, 
    -0.10894289f, -0.07905747f, -0.05886492f, 0.26357976f, 0.13465406f, 0.28324586f, -0.05210911f, -0.03018893f, 
    0.06742945f, -0.17748892f, -0.13248219f, 0.16299854f, -0.04967929f, -0.03689685f, 0.13923658f, -0.13818397f, 
    -0.25179997f, -0.38634664f, -0.01391788f, 0.11952557f, -0.02866791f, 0.16950192f, -0.11461055f, -0.01872274f, 
    0.24445128f, 0.03289662f, -0.02068996f, -0.00376106f, 0.21674882f, -0.09210396f, 0.14665149f, -0.35964918f, 
    -0.00107289f, 0.19148678f, -0.01117431f, 0.03792267f, -0.23448506f, -0.03212076f, 0.05477053f, -0.16004933f, 
    0.04890096f, -0.06720906f, -0.01378178f, -0.00703506f, 0.03315018f, 0.03395386f, 0.06653892f, -0.00478693f, 
    -0.00999625f, -0.05377919f, -0.06332845f, 0.02201058f, 0.02977290f, -0.05353731f, -0.04052788f, 0.04646700f, 
    -0.03468944f, -0.01128073f, 0.03071040f, -0.01780642f, 0.04028890f, -0.03361877f, -0.02561297f, -0.02316183f, 
    -0.01541757f, 0.03710375f, 0.05133780f, 0.01681029f, -0.03644178f, -0.03703885f, 0.04599316f, -0.01871204f, 
    -0.04334232f, 0.01409284f, 0.02175516f, -0.03072208f, 0.04197549f, -0.03870609f, -0.03189109f, 0.05525569f, 
    0.05377143f, -0.04122984f, -0.00846797f, 0.04800386f, 0.00036206f, -0.04664778f, -0.02341141f, -0.02961956f, 
    -0.04321529f, -0.04827224f, -0.00941663f, -0.01481354f, -0.01061801f, -0.04089885f, 0.02926387f, 0.00872429f, 
    0.02557185f, -0.02376783f, 0.06201798f, 0.04585050f, 0.05584190f, -0.06037908f, 0.01978795f, -0.04284040f, 
    -0.02012968f, 0.01660736f, -0.02206276f, 0.04827405f, -0.02767650f, 0.04362167f, -0.02923578f, -0.04381627f, 
    -0.07078442f, 0.00153158f, -0.02953016f, -0.02799236f, -0.03574782f, 0.00485229f, 0.05471728f, 0.03594071f, 
    0.04818422f, 0.05147019f, 0.04783996f, -0.06888239f, 0.03126367f, -0.06008743f, 0.05210155f, -0.03505923f, 
    0.04479350f, -0.04022352f, 0.04546532f, -0.01300591f, 0.04502309f, -0.06962157f, 0.03877195f, -0.03349538f, 
    0.00972705f, -0.02153030f, 0.00753830f, 0.01401267f, 0.04443386f, -0.04368586f, -0.04666003f, -0.04732646f, 
    -0.05573840f, -0.07386377f, -0.00844487f, -0.06795657f, -0.03460013f, 0.06474129f, -0.00562387f, -0.02966042f, 
    0.04134034f, -0.06711145f, -0.02929482f, -0.02904530f, 0.01238657f, -0.05734904f, 0.05376085f, -0.01251645f, 
    0.01630315f, -0.07215902f, 0.01992746f, -0.05841873f, 0.05700801f, -0.03572467f, 0.00984865f, -0.06991677f, 
    -0.02545789f, -0.02419439f, 0.03601412f, -0.02948388f, 0.04567741f, 0.04246392f, 0.03133970f, 0.03814622f, 
    -0.00154368f, 0.01083207f, -0.02179826f, -0.06231440f, -0.01791131f, -0.01447772f, -0.06665986f, 0.06249815f, 
    -0.03512970f, -0.04322094f, -0.03716291f, -0.07183057f, 0.00131542f, -0.03357451f, -0.05368523f, 0.01638932f, 
    -0.05854784f, -0.00577061f, 0.05780311f, 0.00087400f, -0.03696802f, 0.04771227f, 0.02566273f, 0.02266781f, 
    -0.02172311f, -0.00824845f, 0.05443319f, -0.05729754f, -0.04323288f, 0.01956506f, -0.02537847f, -0.06228757f, 
    -0.03287945f, -0.04492529f, 0.01523966f, -0.01924513f, 0.01238586f, -0.06323101f, 0.05192941f, 0.02698144f, 
    -0.05879691f, -0.04128408f, -0.01809368f, -0.01913357f, -0.03238096f, -0.05728708f, -0.07175606f, -0.02368024f, 
    -0.00051758f, 0.06273849f, -0.05686197f, 0.01474712f, 0.01210462f, 0.03004640f, 0.04141406f, -0.04824337f, 
    0.31951416f, 0.09046131f, 0.20937112f, 0.29643777f, 0.01590621f, -0.00331977f, -0.03795920f, -0.04842725f, 
    0.09581472f, 0.07727699f, 0.00147924f, 0.13746299f, -0.03712149f, -0.01288136f, 0.06496362f, 0.12459176f, 
    -0.08790237f, 0.02591215f, 0.07855609f, 0.07534053f, 0.24204224f, 0.27895057f, 0.08725833f, 0.31597599f, 
    -0.33520651f, -0.22635038f, -0.06606967f, -0.56997025f, -0.17122458f, -0.17312145f, -0.06838986f, 0.01870648f, 
    0.12678726f, 0.13195500f, 0.16545236f, -0.08847751f, 0.07206137f, -0.05583360f, -0.74356234f, -0.33364719f, 
    -0.10369071f, 0.41429842f, -0.20898794f, 0.14801298f, -0.19084948f, -0.09134065f, 0.02960134f, -0.18179405f, 
    0.19490011f, 0.07705722f, -0.05259384f, 0.09021088f, 0.06708945f, -0.17599578f, 0.06895185f, -0.10843715f, 
    -0.04884305f, -0.12877107f, 0.10484565f, -0.15362467f, 0.06253447f, 0.03801016f, -0.05849196f, 0.08692788f, 
    -0.08052012f, -0.08246347f, -0.03783451f, -0.02264484f, 0.03425571f, 0.08236141f, 0.04244978f, -0.17948867f, 
    -0.01080495f, 0.08508883f, 0.06097715f, 0.19962162f, -0.07546303f, 0.04663613f, 0.09394037f, 0.01771234f, 
    0.00490076f, 0.01100237f, -0.10845514f, 0.02759696f, -0.50019574f, -0.32031709f, -0.42635059f, -0.12884636f, 
    0.10461754f, 0.34393436f, 0.10730274f, -0.03453744f, 0.13003734f, 0.04623394f, -0.01122374f, 0.05048852f, 
    0.38011783f, 0.01483655f, 0.07854016f, 0.12891212f, -0.19656345f, -0.03976222f, 0.17524815f, -0.07045802f, 
    -0.04837435f, 0.01850970f, 0.08600461f, 0.02468423f, 0.03480056f, -0.01153483f, -0.05592975f, 0.05126593f, 
    -0.18213889f, -0.18388779f, 0.19778065f, -0.10300857f, -0.12983117f, 0.01552180f, -0.00705431f, -0.15283450f, 
    -0.04427360f, 0.25192815f, 0.10790814f, 0.05419203f, 0.04965993f, -0.06767672f, -0.14421034f, -0.26650730f, 
    -0.11557485f, 0.05222868f, 0.15913007f, -0.12025032f, 0.10783068f, 0.13098821f, 0.07093943f, -0.23804660f, 
    -0.11139990f, -0.11323337f, -0.02377991f, -0.05991454f, 0.01132584f, 0.07835972f, 0.08982528f, 0.17338330f, 
    -0.06901319f, -0.21699305f, -0.48167154f, -0.44923079f, -0.02115601f, -0.16865423f, -0.08195350f, 0.08960193f, 
    -0.32376301f, -0.11915995f, -0.16954966f, -0.09078690f, 0.11017194f, -0.33250877f, -0.24938150f, -0.06586106f, 
    0.18646443f, -0.00614757f, -0.05812762f, 0.09599898f, -0.29215896f, -0.10366220f, -0.18392490f, -0.13840669f, 
    0.10636259f, 0.08722994f, 0.14877348f, 0.25819123f, -0.04404240f, 0.11733091f, 0.00888360f, 0.05517916f, 
    0.13944277f, 0.00031609f, 0.05861719f, 0.02195026f, 0.37465340f, -0.38117054f, -0.21526881f, -0.37828818f, 
    0.09088333f, -0.01289736f, -0.17765921f, -0.16378251f, 0.06110958f, 0.13806219f, 0.13244890f, -0.18634507f, 
    -0.01514147f, 0.03481219f, -0.04973160f, 0.02507645f, -0.15053342f, -0.03824722f, 0.02889749f, -0.03469765f, 
    -0.07468722f, 0.00262962f, -0.00183936f, 0.07281289f, -0.01576384f, -0.19574368f, 0.33201915f, 0.08269893f, 
    -0.00081266f, 0.08460830f, -0.10768740f, 0.02952207f, 0.05234101f, 0.04207614f, 0.10535907f, -0.10206152f, 
    0.17172815f, -0.12436771f, -0.06526223f, -0.17937413f, 0.06339706f, 0.18873116f, -0.03806464f, 0.24327937f, 
    0.05530146f, 0.10338693f, -0.04207400f, -0.05463027f, 0.30249521f, 0.31569180f, -0.00524628f, -0.17855173f, 
    0.11453815f, -0.09636084f, 0.10546655f, -0.06007984f, -0.05657164f, -0.12397112f, 0.05134501f, 0.05900353f, 
    -0.03557655f, 0.10127312f, -0.12811315f, 0.04257676f, -0.15154429f, 0.11684725f, 0.10891221f, -0.15490240f, 
    -0.03060893f, 0.01101072f, -0.01724275f, -0.00865428f, 0.08408434f, -0.11716582f, 0.18603034f, 0.07104113f, 
    -0.07157426f, 0.06211437f, 0.03378215f, -0.00876991f, 0.15172094f, 0.10468145f, 0.03619631f, 0.30952954f, 
    0.15187240f, -0.02284567f, -0.04981079f, -0.05071363f, -0.03019694f, 0.02549946f, -0.01455820f, -0.09380829f, 
    0.00064964f, 0.04673887f, 0.10505967f, -0.21247606f, 0.20264630f, 0.01649862f, -0.02030158f, -0.15509611f, 
    0.09257488f, 0.14421026f, -0.00955152f, -0.00740031f, 0.01848108f, -0.10304604f, -0.17660530f, 0.04949696f, 
    0.19786493f, 0.03027414f, 0.34062150f, 0.19495846f, -0.03726281f, 0.08760857f, -0.17990965f, -0.07071569f, 
    -0.07341328f, 0.05017294f, 0.04891167f, 0.15697590f, -0.08992002f, 0.09970285f, 0.05229834f, 0.07879744f, 
    -0.00528351f, -0.04840837f, 0.11984731f, -0.14419259f, -0.06355985f, -0.07867876f, 0.07423463f, 0.02472745f, 
    -0.05429475f, -0.03145729f, 0.05888096f, 0.11118744f, -0.06283285f, 0.21433771f, -0.06968787f, -0.07110672f, 
    -0.02535597f, 0.09081278f, -0.08110262f, -0.00472899f, -0.09830131f, -0.15677455f, -0.32022703f, -0.30267301f, 
    -0.07320675f, 0.10108150f, 0.04580772f, 0.11870795f, -0.03381801f, 0.21011439f, -0.02242573f, -0.28097230f, 
    0.18434460f, 0.18420658f, -0.09984456f, -0.18373078f, 0.14941907f, 0.11882040f, -0.00659867f, 0.08133660f, 
    -0.03538089f, -0.04423945f, -0.13212909f, -0.04040071f, 0.16512664f, 0.01027592f, 0.14585726f, 0.13028823f, 
    0.18454744f, 0.18213429f, -0.03958999f, 0.15727213f, -0.11766877f, 0.04491392f, -0.05456834f, -0.06857172f, 
    0.00702070f, 0.19701791f, -0.04676395f, -0.16485342f, -0.06306707f, -0.14136487f, -0.07968069f, -0.00228603f, 
    -0.06742997f, 0.04305830f, 0.00913493f, -0.17880137f, 0.11984736f, -0.03697462f, -0.63452756f, 0.45154148f, 
    -0.02434245f, 0.09692079f, 0.14377125f, 0.10506565f, -0.05501281f, -0.02246020f, 0.04685453f, 0.00860573f, 
    -0.13803744f, 0.23454049f, 0.25293022f, -0.15998247f, -0.07312579f, 0.00770999f, -0.01535541f, 0.05186557f, 
    -0.00247204f, 0.09011625f, 0.02797519f, -0.00074463f, -0.44873658f, 0.28872946f, 0.21388078f, -0.11561503f, 
    0.05729133f, -0.00912240f, -0.13266228f, -0.09362043f, -0.01093429f, 0.02901951f, -0.16264737f, 0.28104964f, 
    0.12614766f, 0.02029594f, -0.05507582f, 0.25660044f, -0.04450339f, -0.04863527f, -0.04262890f, 0.06176838f, 
    0.07552029f, 0.02243453f, 0.14590326f, 0.07900293f, -0.22677569f, -0.43142027f, 0.13859320f, 0.05081571f, 
    0.02841870f, -0.03474575f, 0.11531576f, 0.03877776f, -0.04436228f, -0.08419213f, -0.00558566f, -0.02311588f, 
    0.16339600f, -0.03782380f, 0.10772733f, 0.01489543f, 0.08700091f, 0.13733883f, 0.10292695f, 0.04006602f, 
    -0.09117093f, -0.08613484f, 0.11198459f, 0.05429014f, 0.04546086f, 0.31700608f, -0.23996188f, 0.03630430f, 
    0.08603916f, -0.06274758f, -0.06014808f, -0.15728411f, -0.06256545f, 0.02408729f, -0.02155201f, -0.07386532f, 
    0.15647131f, 0.08714503f, -0.06611626f, 0.16458435f, 0.05629209f, 0.00083468f, 0.17708308f, 0.16599226f, 
    0.11815842f, 0.13077267f, 0.03138812f, 0.10253567f, -0.31480458f, -0.06884810f, 0.00571049f, 0.20026907f, 
    -0.07052101f, -0.14785787f, 0.17363325f, 0.04159737f, -0.01588609f, -0.04053828f, 0.07961025f, -0.03507987f, 
    0.34078595f, 0.01601180f, 0.49371547f, -0.24356660f, 0.12782274f, 0.04308121f, -0.07432377f, -0.00613630f, 
    -0.06718541f, -0.10713597f, 0.12500170f, -0.17007074f, 0.08951308f, -0.09052786f, -0.14950037f, -0.09876940f, 
    0.19162837f, 0.03832218f, -0.04284903f, 0.16959132f, -0.04920913f, 0.05569485f, 0.09718394f, -0.13122854f, 
    -0.11920440f, -0.01194056f, 0.03498934f, -0.06949329f, 0.10523026f, 0.07016451f, -0.12945935f, 0.15990420f, 
    -0.17995363f, -0.10319991f, 0.00569320f, 0.08160047f, 0.21912295f, 0.25805232f, 0.00369844f, 0.26344144f, 
    -0.08550710f, -0.04071303f, 0.02412261f, -0.00589649f, 0.01495311f, -0.03811629f, 0.01986763f, 0.20874563f, 
    0.10841653f, -0.01678902f, 0.33461115f, 0.33280262f, -0.13516766f, -0.01041683f, -0.01382716f, -0.13057986f, 
    0.02244043f, -0.16166052f, -0.14135598f, -0.12547648f, -0.11185520f, -0.02573990f, 0.15154637f, -0.12160788f, 
    -0.22761911f, -0.01449214f, 0.00307474f, -0.21353015f, -0.05931067f, -0.15447378f, -0.18254557f, -0.19895259f, 
    0.14413370f, 0.40145046f, -0.27348322f, -0.18681504f, -0.00889567f, -0.09488565f, 0.09180244f, 0.00238398f, 
    -0.08864991f, 0.07616052f, 0.06277066f, 0.23532100f, 0.13465214f, 0.36089015f, 0.35749435f, 0.09774223f, 
    0.00357592f, -0.00867545f, 0.12505755f, -0.00320128f, 0.07748379f, -0.03188600f, -0.04864271f, -0.02907494f, 
    -0.12501587f, 0.02484661f, -0.09398984f, -0.04273839f, 0.15307771f, 0.02179220f, -0.06377906f, -0.03723419f, 
    0.09961782f, -0.08102474f, -0.04025574f, -0.12291296f, 0.49641421f, -0.09513318f, -0.15306380f, -0.00141280f, 
    -0.05830973f, 0.06535059f, 0.01083903f, -0.07718194f, 0.04490011f, 0.08763481f, 0.12625052f, -0.18696634f, 
    -0.07291498f, -0.10743822f, 0.25307950f, 0.02315659f, -0.06540485f, -0.07878227f, -0.04160180f, -0.24520475f, 
    0.12448396f, -0.08187617f, 0.15188448f, -0.13100612f, -0.27401590f, 0.07351270f, 0.23131001f, 0.31614643f, 
    -0.10506852f, 0.05771033f, -0.10740638f, -0.05029547f, -0.27458793f, 0.07433472f, 0.06996737f, 0.02751381f, 
    -0.15120569f, -0.18426722f, -0.02001793f, 0.03235099f, 0.03963497f, 0.01188013f, -0.02959329f, 0.09067667f, 
    0.03123200f, -0.07373025f, -0.20859790f, -0.03411371f, -0.18072037f, -0.28381488f, 0.07363820f, 0.08837346f, 
    0.00637070f, -0.12811211f, -0.17289925f, 0.07455234f, -0.15491471f, 0.03552525f, 0.05313526f, -0.04356305f, 
    -0.18498574f, -0.10861216f, 0.12074608f, -0.13491403f, 0.00095485f, 0.01135017f, -0.05641362f, -0.04465922f, 
    0.07657728f, 0.14663883f, -0.09314615f, 0.07229308f, -0.09723116f, -0.10984760f, 0.11291314f, 0.22108448f, 
    -0.10218635f, -0.09409917f, -0.14848205f, -0.29957274f, 0.14842273f, 0.05737689f, -0.07997161f, -0.02358717f, 
    0.33068117f, 0.05061894f, 0.35651988f, -0.16057524f, -0.07041359f, 0.27815229f, -0.01797209f, 0.07646580f, 
    -0.12795430f, -0.15954505f, -0.05527763f, -0.21680376f, -0.12278424f, 0.15591624f, 0.11766195f, 0.20896491f, 
    -0.08637655f, -0.20340206f, 0.07194106f, -0.09762385f, -0.14221731f, 0.10364696f, -0.11726944f, -0.08865688f, 
    0.24004616f, -0.17550795f, -0.05372622f, 0.07622898f, -0.18544449f, -0.19093472f, -0.31185478f, 0.03327993f, 
    0.08653338f, 0.08295314f, 0.14269328f, -0.17232890f, -0.38950023f, 0.00176300f, 0.01770531f, -0.01248466f, 
    0.02592651f, -0.17671426f, 0.02971143f, 0.18369211f, -0.00371027f, -0.06019725f, 0.05417993f, 0.05290233f, 
    -0.16177437f, -0.17081369f, -0.03612968f, 0.14615753f, -0.05881030f, -0.20045771f, 0.02123643f, 0.11049646f, 
    -0.06975511f, 0.02206981f, -0.08371007f, 0.10629161f, 0.06004187f, 0.10782284f, 0.16812551f, 0.13891619f, 
    -0.02375290f, -0.20041654f, -0.17764449f, 0.05388631f, 0.01640003f, -0.15323618f, -0.01709731f, -0.20614366f, 
    -0.08753975f, 0.05365266f, -0.12363238f, 0.25091034f, 0.05820510f, 0.00541360f, -0.05000661f, 0.00888194f, 
    -0.05099816f, -0.07153178f, -0.02691345f, 0.04809659f, -0.30606040f, 0.02134713f, 0.03550855f, 0.09911126f, 
    0.03218149f, 0.11136519f, -0.14670117f, -0.07850125f, -0.21717626f, -0.10049104f, -0.04919330f, -0.10475316f, 
    -0.06043874f, 0.11600995f, -0.01114771f, -0.19920376f, -0.04938524f, -0.31968641f, -0.21293473f, -0.08540785f, 
    0.01012251f, 0.01462371f, -0.09141982f, -0.13128641f, 0.19913459f, 0.04164111f, 0.34216976f, 0.02409634f, 
    -0.01995787f, -0.01775114f, -0.08504552f, 0.08712236f, 0.25695822f, 0.04169539f, 0.06337864f, -0.09093165f, 
    0.19867344f, -0.05038611f, 0.06871937f, 0.27868167f, 0.21699969f, -0.04042022f, -0.07049419f, 0.15332520f, 
    0.12699102f, -0.02949818f, 0.20487826f, -0.05167266f, -0.47785267f, 0.13161640f, 0.22600335f, 0.08706641f, 
    -0.07526039f, 0.01918225f, 0.14853315f, 0.10795234f, -0.03868009f, 0.01085971f, 0.03394666f, 0.00979330f, 
    -0.19296652f, -0.02809694f, 0.08641584f, 0.01995614f, -0.05327406f, -0.02170441f, 0.07768705f, -0.13641007f, 
    -0.09635244f, 0.17001440f, 0.16304901f, 0.05544454f, 0.07352732f, 0.14685327f, 0.13996337f, -0.16412091f, 
    -0.01280501f, 0.02198935f, -0.11027869f, -0.03074500f, 0.08273479f, 0.15248950f, -0.02072890f, 0.19699891f, 
    0.00646514f, -0.10747657f, -0.06882349f, 0.00318744f, 0.02137988f, 0.13261794f, -0.14818636f, 0.02611792f, 
    0.13765945f, 0.01841582f, 0.19531509f, 0.16741568f, -0.33749235f, -0.19885954f, 0.01241420f, 0.17039983f, 
    -0.11206429f, -0.08833290f, -0.10949998f, -0.12291990f, 0.13953273f, 0.04418286f, 0.00109176f, -0.09738071f, 
    0.16565534f, 0.07066706f, 0.46456811f, -0.06464435f, -0.11393671f, -0.00453522f, -0.11562449f, -0.01368384f, 
    -0.04363533f, 0.10380197f, -0.02375311f, 0.05299168f, -0.06193175f, 0.00164402f, 0.25189266f, 0.08526500f, 
    -0.05139623f, 0.07332626f, 0.10427558f, 0.11046840f, 0.05790557f, 0.13977407f, 0.23506844f, 0.07672978f, 
    0.06619702f, -0.06523505f, -0.19214134f, -0.10139231f, -0.13734464f, -0.15679996f, -0.03562143f, -0.19704722f, 
    -0.01214064f, 0.11231760f, 0.14888506f, 0.00247854f, -0.01984824f, -0.28060710f, 0.01644918f, 0.01401989f, 
    -0.00600702f, -0.12102131f, -0.04602804f, 0.13112299f, 0.05365897f, -0.01544415f, -0.02580403f, 0.14598578f, 
    -0.11208852f, -0.02544751f, 0.12684311f, 0.17147547f, -0.01998664f, -0.12198664f, 0.17553984f, 0.14989372f, 
    -0.06694893f, -0.09850463f, -0.09277166f, 0.02791292f, -0.19759475f, -0.02244982f, -0.03380235f, 0.05260884f, 
    0.07820205f, 0.09737582f, 0.08492505f, -0.04516349f, 0.07271513f, -0.03064147f, 0.01807555f, 0.00236809f, 
    -0.05987035f, 0.37460768f, -0.33123174f, -0.21130426f, -0.17966275f, -0.08795070f, -0.08932128f, 0.19749886f, 
    0.09589194f, -0.09990043f, 0.12452114f, -0.07129459f, -0.31129524f, 0.12927787f, 0.16190602f, -0.04671548f, 
    -0.07771084f, 0.12814941f, 0.24643458f, 0.09894882f, 0.04664563f, -0.02632214f, 0.08789782f, -0.01825740f, 
    -0.07767808f, -0.03813501f, 0.01010115f, -0.02322198f, 0.02298547f, -0.03926883f, 0.05920065f, -0.04499346f, 
    -0.05840065f, 0.05119128f, -0.02120689f, -0.03526936f, 0.05106221f, 0.04007697f, 0.03696362f, 0.00252430f, 
    0.00868827f, -0.04116782f, -0.04222266f, -0.02375883f, -0.02842342f, -0.06997761f, -0.04918125f, -0.00092152f, 
    -0.05004882f, 0.02196775f, -0.00540871f, -0.07708006f, -0.01240540f, -0.02247813f, 0.05213832f, -0.01525924f, 
    -0.07689651f, 0.02780706f, 0.01075144f, 0.00641848f, -0.04729797f, 0.06232896f, -0.03635515f, -0.01088064f, 
    0.04193687f, -0.03528596f, -0.02011022f, 0.00070899f, 0.03507882f, 0.05646333f, -0.05172687f, -0.02373635f, 
    -0.07241531f, -0.05543720f, 0.03246193f, -0.07218068f, -0.01563663f, 0.03526514f, 0.05223703f, 0.01418454f, 
    0.04306411f, -0.06145216f, 0.04219687f, 0.01826147f, -0.05997841f, 0.04152812f, -0.05744093f, -0.03521329f, 
    0.01069397f, -0.02235579f, 0.06274350f, -0.05739105f, -0.02630456f, -0.05915904f, -0.04181164f, -0.06473517f, 
    0.04369134f, 0.01107788f, -0.05261614f, 0.04924128f, 0.04985353f, 0.00437113f, 0.04394598f, -0.04471435f, 
    -0.03459935f, 0.02681466f, 0.02335882f, 0.02185257f, 0.04496719f, 0.05203586f, 0.01829373f, -0.03821133f, 
    -0.00801245f, -0.06024852f, -0.03976466f, -0.04475205f, 0.02093780f, 0.02338826f, 0.02663344f, -0.06550696f, 
    -0.05649945f, -0.06050970f, 0.00423373f, 0.01633411f, 0.00997027f, 0.04996468f, -0.07328800f, -0.00689054f, 
    -0.02332152f, 0.01372741f, -0.02551438f, -0.05206757f, 0.01689244f, -0.06590968f, -0.02827211f, -0.00429739f, 
    -0.04136958f, 0.04973908f, 0.06470668f, 0.04646185f, 0.01688962f, -0.05988972f, -0.03162485f, -0.03346978f, 
    -0.03841686f, 0.00535102f, -0.00206768f, 0.04429219f, 0.01920949f, -0.00161035f, 0.01521484f, -0.03873193f, 
    -0.00194609f, 0.04762997f, -0.01719020f, 0.04478979f, -0.01847054f, -0.02837486f, -0.05612862f, -0.04431262f, 
    -0.05175900f, -0.00162677f, 0.04313708f, -0.06790467f, -0.02974788f, -0.07060672f, -0.06957880f, 0.04004898f, 
    0.00561671f, 0.03124848f, -0.07038417f, -0.00960786f, -0.03928905f, 0.01115176f, -0.06644551f, -0.02431872f, 
    -0.05209698f, 0.02040501f, 0.03696541f, 0.03039982f, -0.01227753f, 0.01315980f, -0.00350434f, 0.02210448f, 
    0.05609463f, -0.05926677f, -0.06149916f, -0.07035521f, 0.02819604f, 0.03123416f, 0.00158610f, 0.02058663f, 
    0.01116425f, 0.05563540f, 0.05870565f, 0.04853166f, 0.03625039f, -0.05011265f, -0.03794308f, -0.04100877f, 
    -0.03797631f, 0.00188171f, -0.05577674f, -0.04248921f, -0.07626961f, 0.03529384f, 0.01784515f, -0.04405182f, 
    0.01555808f, 0.05521917f, 0.05139394f, -0.05264375f, 0.03126507f, -0.04253044f, 0.01878982f, -0.05654562f, 
    -0.15116042f, -0.02650762f, -0.20478527f, 0.09108751f, -0.09816663f, -0.07221652f, -0.05016947f, -0.14496864f, 
    -0.06997792f, -0.00950659f, -0.00772748f, 0.12474819f, -0.01024833f, -0.05967192f, 0.05697064f, 0.17049795f, 
    0.07345837f, 0.07191964f, -0.03842364f, 0.02849684f, -0.06378716f, 0.02262420f, 0.00183587f, -0.11143374f, 
    0.02143757f, 0.17967688f, -0.07832015f, -0.12050161f, 0.07992975f, 0.28623518f, -0.01549833f, 0.06160624f, 
    0.11533713f, 0.21125203f, 0.12516022f, -0.16991447f, 0.35697505f, 0.40615150f, -0.12951621f, -0.31095764f, 
    0.02734829f, -0.03804372f, 0.21190785f, -0.12242307f, 0.04439124f, 0.13394324f, 0.04299103f, -0.02850215f, 
    -0.10952002f, 0.04209175f, -0.09919064f, 0.11860275f, -0.05399162f, -0.19858019f, -0.01514919f, -0.14258745f, 
    0.16466366f, -0.00811886f, -0.08526898f, 0.04927574f, 0.13635772f, 0.09050671f, 0.16121773f, -0.13377845f, 
    -0.03015320f, 0.06122738f, -0.03161133f, -0.05378545f, 0.17122488f, 0.08034549f, 0.05299028f, 0.40966275f, 
    -0.08312108f, -0.12429500f, -0.01290051f, 0.06028971f, -0.02262946f, 0.05097189f, -0.09126617f, 0.04681426f, 
    0.00945087f, 0.05334384f, -0.02131566f, -0.08294127f, 0.22199786f, -0.00304344f, -0.02803880f, -0.22477232f, 
    0.07538615f, 0.01892069f, 0.00149390f, -0.08978491f, -0.03962887f, -0.21352197f, -0.13515908f, -0.07993525f, 
    -0.17238253f, -0.09062807f, -0.17821422f, 0.19897950f, 0.19972578f, 0.12792949f, -0.16926400f, 0.04644868f, 
    -0.12388007f, 0.16923486f, -0.12133577f, 0.11876553f, -0.03751628f, 0.06245855f, 0.11028270f, -0.07327592f, 
    0.05686400f, -0.17302792f, 0.06433955f, 0.01007926f, 0.08143642f, 0.10582166f, 0.11591551f, 0.04784033f, 
    -0.19986597f, -0.01686326f, 0.19214955f, 0.18223201f, -0.00264186f, 0.10419148f, -0.10761800f, -0.09549120f, 
    -0.06128503f, 0.12923509f, 0.15074562f, 0.09216515f, -0.65641981f, -0.19780175f, 0.05134878f, -0.02724973f, 
    0.08565620f, 0.15735966f, 0.02754975f, 0.10481947f, -0.01011815f, 0.02988200f, 0.03948757f, -0.02633684f, 
    0.01707200f, 0.16154374f, -0.04703621f, -0.08390058f, 0.16260141f, 0.16673145f, 0.12466208f, -0.02361922f, 
    -0.04026551f, -0.08340473f, 0.04311809f, 0.16927695f, 0.14710879f, 0.01417075f, -0.06088781f, 0.02083746f, 
    0.34776017f, 0.05775968f, -0.01365585f, 0.06255508f, -0.01259634f, 0.06479855f, 0.01178554f, 0.16235976f, 
    -0.05964985f, -0.01951948f, -0.00001797f, 0.04725192f, -0.03188784f, -0.26605761f, -0.08675126f, 0.10754319f, 
    -0.02338420f, -0.08653830f, 0.03742770f, -0.06485745f, 0.10088958f, 0.15476611f, -0.28942120f, 0.13800406f, 
    0.11638173f, 0.31539926f, -0.07184634f, -0.00322771f, 0.10485747f, -0.06171903f, 0.02788281f, 0.04457294f, 
    -0.04720382f, 0.33518803f, 0.06635785f, -0.10517088f, -0.00558863f, 0.08782344f, 0.08618923f, -0.07005215f, 
    0.01076595f, 0.02817643f, 0.02345175f, 0.00487472f, 0.11715418f, -0.00716833f, 0.37012756f, 0.10261995f, 
    0.02155596f, 0.04662662f, -0.07858989f, 0.07930870f, -0.00314922f, 0.16931532f, 0.27045640f, -0.05032592f, 
    0.05908633f, -0.49027956f, -0.30300131f, -0.02170305f, 0.04537105f, 0.12749161f, -0.00980489f, -0.03601316f, 
    0.13415003f, 0.13306147f, 0.09064202f, 0.05457637f, 0.74184728f, -0.18480889f, 0.38510200f, -0.23901772f, 
    0.03813041f, -0.23879814f, 0.16988190f, 0.00900862f, 0.01726163f, 0.04087165f, -0.00484208f, 0.15655884f, 
    -0.10951607f, -0.02813441f, 0.05130697f, 0.03771517f, -0.02226556f, 0.34938639f, 0.16147354f, -0.08494179f, 
    0.01033764f, 0.00735265f, -0.04573680f, 0.02736655f, -0.08165957f, -0.18966784f, 0.06621913f, -0.00126354f, 
    -0.00194660f, -0.08306178f, -0.00989809f, -0.05531346f, 0.18875886f, 0.13820523f, 0.01088123f, 0.21130084f, 
    0.26528355f, -0.00522700f, -0.10317425f, -0.15270925f, -0.02482861f, 0.13392353f, 0.09214371f, -0.05220492f, 
    0.10075766f, 0.11799168f, -0.05544172f, -0.09491321f, 0.39320478f, -0.21286207f, 0.10536574f, -0.13807888f, 
    0.10204590f, 0.02992165f, -0.02508559f, -0.21013521f, 0.08101965f, -0.06900068f, -0.01961255f, 0.10741144f, 
    0.39689061f, 0.16960727f, 0.47140732f, 0.03746826f, 0.10735372f, 0.11041330f, -0.28701413f, 0.09480751f, 
    0.02183549f, 0.16075860f, 0.02836170f, -0.04564996f, 0.04762510f, 0.13336146f, -0.13796790f, -0.16366515f, 
    0.11787341f, -0.17622723f, 0.08275939f, 0.06107440f, -0.05989855f, -0.10526604f, -0.15444399f, -0.03338150f, 
    -0.07206374f, -0.31130421f, 0.00111164f, 0.03914230f, -0.01012004f, 0.05579202f, -0.15533200f, 0.11490893f, 
    -0.02520594f, 0.09201467f, -0.04936159f, 0.21610950f, -0.29040560f, -0.21274342f, -0.43934053f, -0.34151313f, 
    0.02350628f, 0.04749902f, 0.02966572f, 0.22407140f, 0.17093849f, 0.11350082f, -0.00422502f, -0.04389197f, 
    0.02524244f, 0.08775868f, -0.24698110f, -0.12418420f, 0.04561152f, 0.04075766f, 0.11224290f, -0.02455617f, 
    -0.04196253f, -0.10983726f, -0.02437289f, 0.20615917f, -0.05642838f, 0.05881182f, -0.08662740f, -0.00341797f, 
    0.17599472f, -0.10516517f, -0.14523198f, 0.14671898f, 0.01055458f, 0.05514787f, -0.09471355f, -0.04779500f, 
    0.10616513f, 0.20782571f, -0.01246064f, -0.12580009f, 0.01831203f, -0.12035194f, 0.08628643f, 0.03662042f, 
    0.05897563f, 0.02785816f, 0.08068190f, 0.01021716f, -0.27295038f, -0.27736926f, -0.56669009f, 0.47976851f, 
    -0.08787675f, 0.10056545f, 0.28152668f, -0.02604402f, -0.09684438f, -0.08043108f, 0.16181661f, 0.02208289f, 
    0.14170149f, 0.05309607f, 0.07474657f, 0.02198981f, -0.11963404f, 0.07588466f, 0.03809989f, 0.14318591f, 
    0.02091634f, -0.03845268f, 0.12882908f, -0.02274217f, 0.28874460f, 0.07496078f, 0.17308979f, -0.09697112f, 
    -0.21148831f, -0.00888346f, 0.01704718f, -0.00390781f, 0.11596797f, 0.24923390f, 0.22902091f, 0.08403352f, 
    -0.09968969f, -0.10858458f, 0.25468183f, 0.05018317f, -0.13762824f, -0.07128520f, -0.27478737f, -0.01174180f, 
    -0.00380148f, 0.10309196f, 0.11086185f, 0.10179405f, -0.38732842f, 0.04183995f, -0.40090206f, 0.43268958f, 
    0.14134346f, 0.11795796f, 0.18276301f, 0.02032799f, -0.05153248f, 0.19037744f, 0.17606297f, 0.04955950f, 
    -0.09211598f, 0.14287108f, -0.05671556f, 0.18506184f, 0.03757271f, -0.13675849f, 0.07873455f, 0.07431182f, 
    -0.28669327f, -0.22694366f, -0.03708232f, -0.16490935f, -0.16160390f, 0.18766995f, 0.18964337f, -0.05565542f, 
    0.04103133f, -0.11470734f, -0.04986043f, -0.02661077f, -0.04396870f, 0.27707952f, 0.31955653f, 0.00756720f, 
    -0.15913296f, 0.00161663f, 0.12181613f, -0.05816844f, 0.07497467f, 0.03485448f, 0.07941712f, -0.04885627f, 
    -0.00491642f, 0.05867020f, -0.08153401f, 0.15732472f, -0.12489868f, -0.29377085f, -0.16332813f, 0.07661620f, 
    0.03807831f, -0.11012482f, 0.07950634f, 0.10349637f, 0.07378746f, 0.26627558f, 0.09773178f, 0.13918780f, 
    0.38924369f, -0.15733571f, 0.53863144f, -0.27142447f, -0.08199843f, -0.06286507f, 0.00905764f, 0.02531790f, 
    -0.07608464f, -0.00882459f, -0.04581952f, 0.02481504f, -0.11676244f, 0.01840083f, -0.01617547f, 0.11647655f, 
    0.02899441f, -0.12183439f, 0.12619647f, -0.19982921f, -0.08715109f, -0.19134176f, -0.01171419f, -0.15148178f, 
    0.29907227f, -0.12720947f, 0.03073785f, 0.19669902f, 0.10084484f, -0.26405621f, -0.04653128f, 0.13397884f, 
    0.08256143f, 0.04369013f, 0.08268697f, -0.00439717f, -0.03411862f, 0.10595867f, 0.28012517f, 0.20742767f, 
    0.02612363f, -0.10040234f, -0.04389987f, -0.11685830f, -0.23685661f, -0.00380734f, 0.00885783f, -0.06471591f, 
    0.40540361f, -0.25883341f, -0.03540206f, -0.02385820f, 0.05764055f, 0.04423052f, 0.01600842f, -0.12994473f, 
    -0.12234639f, -0.08137780f, 0.03113019f, 0.00532478f, -0.07892317f, -0.19362901f, -0.08040867f, -0.06986770f, 
    -0.20394447f, -0.11332961f, 0.11128326f, -0.30664039f, 0.04564037f, -0.12017602f, -0.27628204f, -0.16186355f, 
    -0.12074628f, 0.45102525f, -0.12729664f, 0.18332590f, 0.06842515f, 0.13317472f, -0.05717769f, 0.14360763f, 
    -0.05548413f, -0.03346881f, 0.09835365f, -0.08766681f, -0.16138951f, 0.31786120f, 0.17323086f, 0.09807670f, 
    -0.03315710f, 0.05821356f, 0.06724355f, 0.02040043f, -0.07958648f, 0.12843943f, -0.10905652f, 0.14419650f, 
    -0.07541212f, 0.19569896f, -0.00157233f, -0.22397922f, 0.29239595f, -0.06535886f, 0.04489658f, -0.27868357f, 
    -0.03270662f, -0.19464152f, 0.02482624f, -0.21953140f, 0.34321645f, -0.02157106f, -0.09866065f, 0.07096831f, 
    -0.13552123f, 0.17838052f, 0.05484583f, -0.25837195f, 0.04245516f, 0.34614852f, 0.23220846f, 0.33777845f, 
    0.19617133f, 0.08624277f, 0.28406829f, 0.00727565f, -0.23701982f, -0.09425497f, -0.07388201f, -0.17093985f, 
    0.20644778f, 0.08968894f, 0.30371657f, 0.08466896f, 0.01560580f, -0.09254393f, 0.21394439f, 0.20823425f, 
    0.16914605f, 0.13237387f, -0.02212138f, 0.04000142f, -0.10578375f, 0.22053699f, 0.18890153f, 0.16951080f, 
    -0.31130269f, -0.24029845f, -0.10145929f, -0.07938540f, 0.07828388f, -0.04947051f, 0.08788956f, 0.00255085f, 
    -0.05930561f, -0.30828938f, -0.37043256f, -0.36740506f, -0.09593981f, -0.04049844f, 0.18461539f, 0.05405290f, 
    0.04599456f, 0.01336575f, -0.15699565f, 0.19390568f, -0.11281785f, 0.31639209f, 0.31863144f, -0.03854223f, 
    0.16616276f, 0.32883176f, -0.01042687f, -0.32177654f, 0.10721608f, -0.03301442f, 0.19718236f, 0.00109054f, 
    0.07154292f, 0.06228781f, -0.19311044f, 0.06896974f, 0.05022119f, -0.21485911f, 0.11523630f, 0.24094823f, 
    0.11482570f, 0.19901003f, 0.06955320f, 0.04713396f, 0.13532779f, 0.19510120f, 0.03260208f, 0.19395161f, 
    0.24781924f, 0.25123197f, 0.37905663f, -0.15707019f, 0.14592786f, 0.22324033f, -0.06039044f, 0.00323019f, 
    -0.29017282f, -0.16784394f, -0.13243322f, -0.34759271f, -0.09436788f, 0.25235090f, 0.31452057f, 0.12710044f, 
    0.10306856f, -0.30329877f, -0.13505879f, -0.14781547f, -0.44936779f, -0.18281710f, -0.22390758f, -0.45751479f, 
    0.13423026f, 0.04560075f, 0.07641241f, 0.29989156f, 0.09440451f, -0.17223191f, -0.38577539f, 0.06798162f, 
    0.00896521f, -0.00425102f, 0.02783426f, -0.30648014f, 0.27990597f, 0.33469325f, 0.36160207f, 0.16227332f, 
    -0.11494438f, 0.04170186f, 0.11105333f, 0.08735116f, 0.15222605f, 0.08639520f, -0.08903960f, 0.08842114f, 
    0.04823510f, -0.29544091f, -0.17880949f, 0.17431694f, 0.06203855f, 0.24223618f, 0.19276835f, 0.19142443f, 
    -0.18561433f, -0.24597849f, 0.06250611f, 0.24633858f, -0.21124500f, -0.07147258f, -0.01256534f, 0.26848021f, 
    0.00202421f, -0.34956366f, 0.03889024f, 0.00075010f, -0.09171701f, -0.41624177f, -0.15456223f, -0.34892765f, 
    -0.05898298f, 0.23572014f, -0.00638910f, 0.05342199f, 0.12013016f, 0.01713926f, -0.14804628f, -0.21084303f, 
    0.03079407f, -0.15213276f, -0.06293543f, 0.20418671f, -0.34216210f, 0.28645059f, 0.13720721f, 0.43754750f, 
    -0.01214845f, 0.08130989f, 0.09409650f, -0.04897983f, -0.10206816f, -0.00846243f, -0.16728638f, 0.02768896f, 
    0.01732903f, 0.11770944f, 0.08296022f, -0.03432545f, 0.22907057f, -0.13943459f, -0.06273109f, -0.34616202f, 
    -0.00004026f, -0.07465510f, -0.08624051f, -0.09631769f, -0.34451312f, 0.11086431f, 0.07917932f, 0.29941162f, 
    -0.35074136f, -0.00944237f, -0.05212425f, -0.40832523f, -0.03283416f, -0.01856758f, 0.18881395f, 0.45412946f, 
    0.39367670f, 0.25331876f, -0.08532209f, 0.34910351f, 0.04447060f, -0.03220209f, 0.00309609f, -0.10085312f, 
    0.14418407f, 0.11165529f, 0.00038055f, 0.02687926f, 0.43938559f, 0.20456129f, 0.29354128f, -0.22270474f, 
    0.04213652f, 0.34073472f, 0.11876091f, 0.21744533f, -0.07838050f, 0.25413704f, 0.15996192f, 0.05098066f, 
    -0.37967923f, -0.27128157f, -0.37839061f, -0.39211383f, 0.22760943f, -0.26577812f, 0.09378900f, -0.23445188f, 
    -0.23241886f, -0.10260379f, -0.41479343f, -0.42090288f, -0.05712692f, -0.15141027f, 0.21109748f, 0.09147901f, 
    -0.04247443f, -0.15657468f, -0.13886702f, -0.12635045f, -0.19700630f, 0.03251123f, 0.05951469f, -0.15859120f, 
    0.32919380f, 0.26118830f, -0.31755391f, -0.35287124f, -0.07166982f, -0.19344601f, -0.10014599f, -0.08375656f, 
    -0.01248346f, 0.13169679f, 0.04791185f, -0.06678364f, 0.29360905f, -0.03167169f, 0.19691293f, 0.18356235f, 
    0.11067772f, 0.23062806f, 0.03782047f, 0.26785699f, 0.05762977f, 0.05310910f, 0.09480445f, 0.26039040f, 
    -0.25963116f, 0.40466803f, 0.16201541f, 0.44189239f, 0.01191171f, -0.04441399f, -0.07857884f, 0.17158759f, 
    -0.22103646f, -0.12645039f, 0.09543306f, -0.41572449f, 0.10091114f, 0.18083572f, -0.13397834f, -0.11547960f, 
    0.07030209f, -0.08881588f, -0.19906029f, 0.07348735f, -0.46208566f, -0.24120803f, -0.14228441f, -0.47086874f, 
    0.06935313f, -0.12110942f, -0.08853297f, 0.36093611f, 0.11669669f, 0.19364323f, -0.11221084f, -0.29981381f, 
    -0.15112340f, -0.10502934f, -0.17823535f, -0.29054844f, 0.63357544f, -0.18137482f, 0.23462863f, 0.29250127f, 
    0.01911435f, 0.01184250f, -0.20239203f, -0.44343629f, 0.25812399f, 0.15334193f, -0.00048154f, 0.27613866f, 
    0.19057204f, -0.09295712f, -0.17824897f, -0.00489594f, 0.13628836f, 0.19347320f, 0.02975455f, 0.15546434f, 
    0.07950310f, -0.05557190f, 0.14278175f, 0.24663618f, -0.06035612f, -0.08442412f, -0.25511634f, 0.27033320f, 
    -0.00369858f, -0.02755942f, 0.16355205f, 0.30641621f, -0.22980911f, -0.11146241f, -0.19815624f, -0.09142493f, 
    0.21206512f, 0.13492399f, 0.34815642f, -0.33552021f, 0.16495086f, 0.02656555f, -0.16099262f, -0.24279581f, 
    0.09153532f, -0.08967975f, -0.03216812f, 0.00289139f, -0.22705801f, -0.17596069f, -0.12341262f, 0.30647838f, 
    0.03006171f, -0.11264975f, 0.05502848f, 0.06803525f, 0.07625814f, 0.01276615f, -0.09393544f, 0.07543255f, 
    -0.00268169f, -0.26311162f, -0.34110770f, -0.06451202f, -0.10979326f, 0.02052370f, 0.03619844f, 0.15738301f, 
    -0.07156909f, -0.02626211f, 0.05077238f, 0.03761525f, -0.63892937f, -0.44707212f, -0.06596076f, -0.26984316f, 
    0.06642718f, 0.09144825f, -0.07225220f, 0.17197734f, -0.16288148f, 0.05972062f, -0.15277089f, -0.16129075f, 
    0.21992926f, 0.17811908f, -0.01015427f, -0.06513057f, -0.08061930f, -0.08728725f, -0.01163582f, 0.08943363f, 
    -0.26172358f, -0.21738943f, -0.30846545f, -0.15174693f, 0.22570279f, 0.09966917f, -0.39444011f, -0.05328003f, 
    0.05572854f, -0.02960031f, 0.02473659f, -0.09088761f, 0.05938856f, -0.20818730f, -0.18688661f, -0.09750710f, 
    0.17782831f, 0.15904507f, 0.03988251f, 0.16957924f, -0.02934269f, -0.00489589f, 0.03185276f, -0.05007955f, 
    -0.06862237f, 0.06999127f, 0.02417336f, -0.01334902f, 0.13633105f, 0.13059874f, 0.01038442f, 0.14948195f, 
    -0.09505388f, 0.02777340f, 0.15222399f, -0.03239627f, 0.00406772f, 0.04458847f, -0.16678086f, 0.07151653f, 
    -0.03743440f, 0.04779383f, 0.11927253f, 0.06156046f, 0.11109161f, -0.07000868f, 0.07455145f, -0.01193426f, 
    -0.16130981f, 0.07448086f, 0.16833605f, 0.00424555f, 0.20636375f, 0.24933432f, -0.04242912f, -0.10336108f, 
    0.14226453f, 0.00972291f, 0.06665559f, 0.12716351f, -0.11523558f, -0.14734165f, -0.13359571f, -0.19746611f, 
    -0.39559692f, -0.75472015f, 0.02125082f, -0.07460268f, -0.07408558f, -0.02556635f, -0.14489427f, -0.02984432f, 
    -0.06017086f, 0.10294298f, 0.13263457f, 0.09025925f, 0.10738037f, 0.23033762f, 0.01071344f, 0.05415155f, 
    0.04264754f, 0.11271808f, -0.09461097f, -0.02016515f, 0.03127715f, 0.14758623f, 0.04025657f, 0.03140465f, 
    -0.04455035f, 0.16310978f, 0.25022677f, -0.13041465f, -0.01483742f, 0.17689633f, 0.09645241f, 0.03930101f, 
    0.05888883f, 0.10183154f, -0.08283529f, -0.21990027f, 0.12698482f, 0.16133951f, 0.09344675f, 0.03077822f, 
    -0.02213356f, 0.16040277f, 0.01165825f, 0.00008427f, -0.18544847f, 0.05229758f, -0.01938504f, -0.10278961f, 
    0.23071373f, 0.31773439f, 0.17076555f, -0.02482177f, 0.08996006f, 0.39785612f, -0.08164824f, -0.04561327f, 
    0.04096373f, 0.06908656f, 0.00122343f, -0.17098439f, 0.28174523f, 0.05806613f, 0.23060706f, 0.01252374f, 
    -0.01101081f, 0.23342793f, 0.23579217f, -0.05913248f, -0.03228031f, 0.07760582f, -0.01481880f, -0.01036715f, 
    -0.21733321f, -0.03867839f, -0.10042817f, 0.03238950f, -0.02282661f, 0.02635936f, 0.01446578f, 0.03635249f, 
    -0.14360254f, 0.20549932f, 0.11869644f, -0.04548451f, 0.45390987f, 0.00863271f, -0.28729776f, 0.04070753f, 
    0.09880334f, 0.01089891f, -0.01910153f, 0.06955430f, -0.04736565f, -0.05698304f, -0.07663316f, 0.03361101f, 
    0.24306862f, 0.04176668f, 0.15520547f, 0.10980919f, 0.02523728f, 0.02381352f, 0.00353261f, 0.01475926f, 
    0.07158089f, 0.04988399f, 0.02609389f, -0.02354372f, 0.10162123f, -0.07108945f, 0.35081059f, 0.18586163f, 
    0.04869775f, -0.02921137f, 0.05491992f, -0.00505650f, 0.03485241f, 0.16257535f, -0.17829496f, -0.06164817f, 
    -0.57765645f, -0.29652789f, -0.17040293f, -0.09580275f, -0.00079553f, 0.01769118f, 0.09722322f, 0.09883924f, 
    -0.10372227f, 0.01853601f, 0.19174695f, 0.10738974f, 0.11293984f, -0.14592238f, -0.24537700f, -0.08720051f, 
    0.10814862f, -0.03521393f, -0.25557604f, 0.00014807f, 0.11963785f, -0.04453657f, -0.07218853f, -0.01586356f, 
    -0.00673672f, 0.10206817f, 0.10061345f, 0.04280870f, 0.06127689f, -0.07338808f, -0.06990715f, 0.05134452f, 
    0.08549109f, 0.01021500f, 0.01222181f, -0.02922994f, 0.04139798f, -0.04390960f, -0.17998400f, -0.00761198f, 
    -0.07945308f, -0.02659996f, -0.00761164f, 0.07089252f, 0.11377107f, 0.00171690f, -0.17891929f, -0.15310539f, 
    -0.00747710f, -0.00274944f, 0.00058243f, 0.13227962f, 0.09065300f, 0.00684594f, 0.02911220f, -0.05294525f, 
    0.08551859f, 0.11184283f, 0.03961013f, 0.15599142f, 0.14772682f, -0.12029029f, -0.03068824f, -0.11188488f, 
    0.18719599f, -0.02684660f, -0.08844789f, -0.12884457f, 0.00317037f, -0.16674042f, 0.13135216f, 0.01253533f, 
    0.49203816f, 0.18063758f, 0.40537095f, -0.13945588f, -0.12943313f, -0.10197891f, 0.22983730f, -0.06887428f, 
    -0.00345097f, -0.02878612f, 0.00793418f, 0.04654063f, -0.03332456f, -0.04049546f, -0.22263679f, 0.12851249f, 
    0.01380536f, 0.39401224f, -0.09361635f, 0.21163744f, 0.13004687f, 0.04772557f, 0.03147839f, -0.08428874f, 
    -0.49762872f, 0.18407248f, -0.20202018f, -0.28722453f, 0.03517715f, -0.10519453f, -0.04951017f, 0.03417401f, 
    0.03676881f, 0.15181667f, 0.11504725f, -0.01964346f, -0.40899679f, -0.05937986f, -0.08363523f, 0.11311706f, 
    -0.01254634f, 0.10138770f, 0.00664959f, 0.02629704f, -0.05416255f, -0.28222513f, -0.02692330f, 0.19729427f, 
    0.10777145f, 0.07640944f, 0.07517992f, -0.12043870f, -0.20322387f, -0.22197282f, -0.05236812f, 0.01361318f, 
    -0.08939545f, 0.01710491f, 0.04885564f, 0.03168859f, 0.05625909f, 0.12829110f, 0.04741580f, -0.27893475f, 
    -0.03797062f, -0.01239561f, -0.23107757f, 0.05918182f, -0.00727731f, -0.03787101f, -0.00450646f, 0.06612784f, 
    0.09339136f, 0.11128245f, 0.04155352f, 0.13673535f, -0.08295076f, 0.12200753f, 0.04863425f, -0.02343997f, 
    -0.08067966f, -0.05780526f, 0.12069588f, -0.05752548f, 0.26984537f, -0.22266965f, 0.07189745f, -0.34801817f, 
    0.24081932f, 0.06705119f, 0.01179974f, 0.16176639f, 0.06758878f, -0.01136594f, -0.02915300f, 0.13533899f, 
    -0.35049236f, 0.13181809f, 0.17337675f, -0.12391131f, -0.04854847f, -0.07433152f, -0.01178512f, -0.06839231f, 
    0.07930873f, 0.07354669f, 0.06699351f, 0.03119648f, -0.14962320f, 0.34195393f, 0.12501894f, -0.15408561f, 
    -0.07650410f, -0.01698583f, -0.09376346f, -0.04641837f, 0.06528510f, 0.04233984f, 0.06584799f, -0.02843552f, 
    0.08707236f, -0.16938294f, -0.08658382f, 0.27058333f, 0.17642848f, -0.04692068f, -0.07627760f, 0.08678207f, 
    0.20850983f, 0.09261284f, 0.13851736f, 0.08078945f, -0.35870311f, 0.13082680f, 0.11546477f, 0.18749075f, 
    0.00961675f, 0.01843049f, 0.01820282f, 0.07792955f, -0.03214159f, 0.09235632f, 0.01502499f, 0.06657305f, 
    -0.02924046f, -0.21771055f, 0.04677545f, -0.09900334f, 0.21975639f, 0.04687668f, 0.28303567f, -0.02691302f, 
    -0.10747879f, -0.05541822f, 0.14013830f, 0.06569687f, -0.09107168f, 0.13978092f, 0.22853765f, -0.20456421f, 
    0.05996946f, -0.10505649f, -0.01315464f, -0.08313541f, -0.00688486f, 0.06194577f, 0.04948482f, 0.01088527f, 
    0.03392405f, -0.04683477f, -0.25709063f, -0.17404665f, 0.00207482f, 0.08994026f, 0.00497128f, -0.06054273f, 
    0.21116208f, -0.04105614f, 0.08093550f, 0.06082296f, -0.17619339f, -0.30380347f, -0.07965018f, 0.27192953f, 
    0.00233065f, -0.08942860f, -0.10380065f, 0.11288955f, 0.13115831f, 0.13443497f, 0.07668791f, -0.08116425f, 
    0.01167728f, 0.18754743f, 0.38279882f, 0.08268216f, -0.03605750f, -0.02744847f, 0.02826779f, 0.07136170f, 
    -0.00961456f, -0.04639184f, 0.03578774f, -0.10114457f, -0.00061669f, 0.02783213f, -0.00075593f, 0.12405461f, 
    -0.06309723f, 0.07457487f, 0.12622693f, 0.08029944f, 0.13061218f, 0.01843997f, 0.20451148f, 0.06445165f, 
    0.41136211f, -0.15392320f, -0.04281433f, 0.17933965f, 0.01653472f, -0.20511194f, 0.05760299f, -0.03618151f, 
    0.06929300f, 0.12529097f, 0.16213594f, 0.17882386f, 0.25588673f, -0.41933334f, -0.16069391f, 0.01342057f, 
    0.07751811f, -0.07034234f, -0.05015985f, -0.07032644f, 0.03706471f, -0.03206428f, -0.11750728f, -0.00754417f, 
    0.16613570f, -0.20994234f, -0.08002448f, 0.10802690f, 0.07167694f, -0.16921470f, 0.11444230f, 0.01114468f, 
    0.05515933f, -0.04052966f, 0.04199213f, 0.14156401f, -0.12714778f, -0.07127424f, -0.06472122f, 0.21146859f, 
    -0.09348042f, -0.05210839f, 0.01001410f, 0.06604819f, 0.01883460f, 0.11890359f, -0.10696727f, -0.05827648f, 
    0.08874785f, 0.22744776f, -0.06109497f, -0.34637958f, 0.01593932f, 0.03759359f, -0.11813106f, 0.06913699f, 
    0.12829243f, -0.04694379f, 0.07502402f, 0.01616745f, -0.34543377f, -0.01011655f, 0.31248668f, 0.23243581f, 
    -0.15800895f, -0.01151795f, 0.12417109f, 0.08049252f, -0.04282574f, -0.03238918f, -0.06513682f, -0.05950101f, 
    -0.03872091f, -0.10991193f, 0.06911788f, -0.06067570f, 0.04148555f, -0.11873122f, -0.04817338f, -0.09811337f, 
    0.09070157f, -0.08916628f, 0.10259838f, 0.04722835f, 0.28892061f, 0.16520593f, -0.54359066f, 0.12812093f, 
    0.01022825f, 0.08390854f, 0.09122809f, -0.08005210f, -0.01622787f, -0.08387154f, -0.09470823f, -0.00210014f, 
    0.00422959f, 0.35037500f, 0.23309828f, 0.00761932f, 0.18112513f, -0.06588142f, 0.07586189f, -0.05400177f, 
    0.20323171f, -0.09468280f, 0.10175985f, -0.15270147f, -0.27249521f, -0.04170719f, 0.24111754f, -0.06064886f, 
    -0.05228643f, 0.16284068f, -0.14324199f, 0.13993803f, -0.06248130f, 0.07182956f, 0.05984499f, -0.05140867f, 
    -0.13932092f, -0.18503340f, 0.02042902f, -0.14699678f, -0.15169993f, -0.14588431f, -0.19037500f, 0.03273196f, 
    0.22761747f, 0.14819986f, -0.05149899f, 0.08822335f, 0.03389394f, 0.09190663f, -0.03655544f, -0.01738498f, 
    0.04177190f, 0.00886494f, -0.01044936f, -0.11059850f, 0.09311347f, -0.21856253f, 0.16139007f, 0.14246154f, 
    -0.01298374f, -0.07164140f, 0.00472050f, 0.06837410f, -0.01832298f, -0.04764693f, -0.18360688f, 0.10767061f, 
    0.05333680f, 0.00369096f, 0.05088214f, -0.05070188f, -0.23027840f, 0.11341177f, 0.13607796f, 0.08184748f, 
    -0.11947963f, 0.08505806f, 0.14693594f, -0.08124481f, 0.06937300f, 0.05702556f, -0.06595524f, 0.03755979f, 
    -0.38083002f, 0.16362660f, -0.63525832f, 0.23713467f, 0.10838685f, 0.11209898f, 0.15990464f, 0.04049191f, 
    -0.00181495f, 0.04623464f, -0.02675610f, 0.02844188f, 0.13577761f, -0.20877746f, 0.30802795f, -0.12660609f, 
    -0.07009303f, 0.02444126f, 0.04353577f, 0.07998875f, 0.05071273f, -0.00501131f, 0.11753198f, 0.14560260f, 
    -0.00891548f, 0.09209272f, -0.18752517f, -0.14217134f, -0.08242767f, -0.01173301f, 0.05103733f, -0.13387276f, 
    -0.01145411f, 0.13722430f, 0.00624028f, 0.14321986f, -0.08905949f, 0.14520206f, 0.28018117f, 0.07180530f, 
    -0.05918220f, -0.03500303f, 0.00027798f, -0.08025040f, 0.08457355f, -0.06353578f, 0.02539381f, 0.08372606f, 
    -0.65250909f, -0.17494114f, -0.07951010f, 0.05159522f, 0.04297078f, -0.14748228f, 0.02675352f, 0.24229322f, 
    0.02431490f, 0.08693574f, 0.02810384f, -0.05562836f, -0.14521915f, 0.02545292f, -0.17653099f, -0.14799534f, 
    0.04418883f, 0.09804871f, 0.05306892f, 0.00662593f, 0.05151473f, -0.04894454f, 0.06505594f, 0.14365807f, 
    0.00593130f, -0.25122803f, 0.02713658f, 0.05288987f, 0.06203149f, -0.01146879f, -0.09218642f, 0.04243818f, 
    0.15674467f, -0.15509149f, -0.03626732f, 0.01070038f, -0.10813615f, 0.22683100f, 0.56548804f, -0.29043990f, 
    0.00998401f, 0.11776059f, -0.03167873f, -0.01072758f, 0.09784427f, 0.04963834f, 0.05752442f, -0.08956075f, 
    -0.18625619f, -0.09802031f, 0.06171451f, -0.08048651f, -0.11846562f, -0.11616128f, -0.17959282f, -0.14172611f, 
    0.01499392f, 0.13348942f, 0.08272609f, 0.08040253f, -0.25992468f, -0.00418085f, 0.22513868f, -0.13834395f, 
    -0.04494804f, -0.15806995f, -0.07585405f, 0.03526835f, 0.09377234f, -0.00745168f, -0.06746048f, -0.23874737f, 
    -0.01153796f, -0.18499982f, -0.08847924f, 0.16683383f, 0.19597769f, 0.04712068f, -0.12684052f, 0.13676739f, 
    -0.09344897f, -0.00094925f, -0.13335852f, -0.07361961f, -0.18440242f, 0.47936949f, -0.20718479f, 0.16697359f, 
    -0.06793488f, 0.02483326f, 0.06027250f, -0.01904205f, -0.16042523f, -0.02063834f, -0.13414808f, -0.05371191f, 
    -0.11265436f, 0.05610886f, -0.00372481f, 0.02735649f, 0.11601484f, -0.04582598f, 0.06391286f, 0.02978104f, 
    0.02939706f, 0.21749040f, 0.32574859f, 0.08958105f, 0.01874117f, 0.22308667f, 0.15547745f, -0.16189606f, 
    -0.14334314f, -0.03096763f, -0.00793342f, 0.02139672f, -0.00475902f, -0.02406497f, -0.12413188f, 0.20584700f, 
    -0.38511533f, -0.32382342f, -0.11013473f, -0.29744190f, -0.05352910f, 0.07465852f, -0.09187935f, -0.18745677f, 
    0.18667597f, -0.04592403f, 0.08747039f, 0.21431985f, 0.04232768f, -0.11265571f, -0.09694561f, 0.10697586f, 
    -0.03081007f, -0.13818325f, -0.13417582f, 0.10282615f, -0.16308577f, -0.04015444f, -0.06637390f, -0.21302317f, 
    -0.22388907f, -0.03861097f, 0.09098142f, 0.02781876f, -0.14996958f, -0.10205684f, 0.03072677f, -0.04022988f, 
    0.07219868f, 0.04532210f, 0.03037337f, 0.07138999f, 0.01147158f, -0.08052396f, 0.09218907f, 0.11802632f, 
    -0.10561986f, 0.09716320f, 0.20600361f, 0.09239408f, 0.37579423f, 0.19865410f, 0.23610453f, 0.22401026f, 
    0.18313864f, 0.05387461f, 0.12509584f, 0.27871016f, 0.00931860f, -0.01631697f, -0.03881728f, -0.02730143f, 
    -0.10191597f, 0.06382419f, 0.26380333f, 0.06902873f, -0.37386599f, -0.61590976f, -0.20257431f, -0.16954312f, 
    0.05026462f, -0.08093779f, -0.02030735f, -0.03920885f, -0.10724647f, 0.07348067f, 0.06002121f, 0.03547128f, 
    0.34610572f, 0.15594274f, 0.10844363f, 0.15169710f, 0.09132592f, -0.11510567f, 0.07688680f, -0.08960412f, 
    -0.05557917f, -0.05759424f, 0.03048395f, -0.02326572f, 0.07283746f, 0.00312631f, 0.15104358f, 0.31356898f, 
    0.09373418f, 0.21017884f, 0.05293898f, 0.07158107f, -0.00431020f, 0.19315708f, 0.03648021f, 0.13059872f, 
    -0.14226370f, 0.00195297f, -0.19240026f, -0.30371121f, -0.19311345f, -0.03370764f, -0.22612336f, 0.12478229f, 
    -0.01745168f, 0.04464237f, 0.07634944f, -0.02328603f, 0.04791783f, -0.13080634f, 0.04713745f, 0.16991505f, 
    0.02362280f, 0.22999881f, 0.12548934f, 0.01762968f, 0.10359410f, 0.11413024f, 0.03517670f, 0.03087398f, 
    0.13586038f, -0.18978687f, 0.00931540f, 0.11682452f, 0.09644490f, 0.07075694f, 0.00946078f, 0.13962120f, 
    0.00770866f, -0.12045258f, 0.15929806f, 0.04350557f, 0.68560767f, 0.09496162f, -0.22348084f, 0.06205493f, 
    0.11870966f, 0.05881146f, 0.18015464f, 0.00670345f, 0.11717372f, 0.03254873f, 0.15094772f, -0.10879987f, 
    -0.33711112f, 0.02258875f, 0.26895684f, 0.25896600f, 0.09457054f, -0.13001873f, 0.00175498f, 0.01114590f, 
    0.10613176f, 0.00434741f, 0.19333692f, 0.11097928f, -0.35340235f, -0.16421665f, 0.26697290f, 0.35832492f, 
    0.02401674f, 0.13506113f, -0.04795709f, 0.11159803f, 0.01624557f, 0.10881666f, 0.05670169f, 0.02542780f, 
    0.05887850f, -0.33611399f, 0.02841925f, -0.02088088f, 0.10479402f, 0.14604382f, -0.00319303f, 0.20623910f, 
    0.10363159f, 0.06770362f, -0.12324310f, -0.06824257f, 0.01932928f, -0.06498493f, 0.00302772f, 0.29515696f, 
    0.11948761f, 0.00711796f, -0.13197967f, -0.02792345f, 0.14035057f, -0.02086172f, 0.01269493f, -0.00660315f, 
    -0.26523703f, -0.19887902f, 0.15180087f, -0.02551254f, -0.01099565f, 0.23305991f, -0.24368083f, -0.03947609f, 
    0.04722644f, 0.04642568f, 0.08998325f, 0.19517148f, -0.20355010f, -0.02353359f, 0.19572416f, 0.13728416f, 
    -0.11314358f, -0.03754423f, -0.00000646f, -0.04800815f, 0.13843305f, 0.06028723f, -0.04313800f, -0.07152781f, 
    0.09810325f, 0.33536425f, -0.29256979f, -0.03781067f, 0.19600907f, 0.22946727f, 0.08084804f, 0.04907025f, 
    -0.02038863f, -0.10357555f, -0.07903151f, -0.08206279f, 0.00102961f, 0.04021370f, 0.34057903f, 0.25270894f, 
    -0.05823176f, 0.10024726f, 0.17114618f, -0.00933635f, 0.16282284f, 0.12003008f, -0.06059139f, 0.23191175f, 
    0.18517813f, -0.01028803f, -0.01023120f, -0.20077871f, -0.18901075f, -0.21725890f, -0.01148861f, -0.22544643f, 
    -0.04486423f, 0.04132516f, 0.04596019f, -0.07134695f, -0.38166720f, 0.18146792f, 0.23246492f, 0.10967564f, 
    -0.08176653f, -0.26872140f, -0.02297114f, 0.00298316f, 0.12593149f, -0.10054311f, 0.11893775f, 0.11797936f, 
    -0.43774867f, -0.03380144f, -0.00047087f, -0.12749830f, -0.01304283f, -0.31566787f, 0.15682743f, 0.10510974f, 
    -0.01900737f, 0.05467709f, 0.01323153f, 0.00623321f, 0.09136893f, 0.26556772f, -0.00529969f, -0.11517272f, 
    -0.03399034f, -0.10884918f, 0.02961909f, 0.19155987f, 0.07504182f, -0.11727072f, -0.00823335f, -0.03822010f, 
    -0.27536842f, -0.26474920f, -0.07189936f, 0.32462257f, 0.00690626f, 0.23501521f, 0.00524503f, -0.05594902f, 
    0.34234601f, 0.05054927f, -0.04371843f, 0.03421729f, 0.03211775f, 0.07981770f, 0.41000476f, -0.44721064f, 
    -0.00835099f, 0.15378512f, -0.04818576f, 0.10496534f, -0.07603250f, -0.00001865f, 0.11948184f, -0.06829336f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.06278876f, 0.01307488f, 0.10492089f, 0.09506685f, 0.00705438f, 0.05693411f, 0.18411067f, 0.09780808f, 
    -0.02327549f, 0.15691783f, 0.00587183f, -0.03022491f, 0.13182619f, -0.02406936f, -0.09744733f, 0.19847025f, 
    -0.01570845f, -0.10609432f, -0.00054478f, 0.03795820f, 0.02281229f, 0.18479620f, -0.03647424f, 0.13082936f, 
    0.00368932f, 0.13433652f, 0.11894459f, -0.06979190f, -0.05368119f, 0.19095136f, 0.07541063f, 0.13813725f, 
    -0.06943113f, -0.00365573f, 0.04156189f, 0.13471936f, 0.16215879f, 0.07819806f, 0.02119697f, -0.11141831f, 
    0.28220165f, 0.24553616f, 0.09198589f, 0.05440128f, -0.02436133f, 0.08435117f, 0.02539681f, 0.17622459f, 
    -0.04142780f, 0.08819208f, -0.08873381f, 0.26256922f, -0.06358135f, 0.08400609f, 0.02033311f, 0.07047371f, 
    -0.01768109f, -0.09437707f, -0.18924928f, 0.16751915f, 0.11549245f, 0.12392018f, 0.04439414f, 0.18479899f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.32433999f, -0.03408863f, -0.28652132f, -0.44424498f, -0.04412767f, -0.09641594f, -0.18155421f, -0.24479552f, 
    -0.17800167f, -0.25895840f, 0.07073263f, 0.08649518f, 0.27214417f, -0.01255906f, 0.28764454f, -0.04660106f, 
    -0.11065742f, 0.21838731f, -0.01554840f, -0.10781021f, -0.08610831f, 0.22493434f, -0.09782388f, 0.28413075f, 
    -0.13193345f, 0.08754409f, -0.04250535f, -0.01672438f, -0.10711985f, -0.10136432f, 0.18460907f, -0.29141551f, 
    0.28999874f, -0.04701268f, -0.04126104f, 0.07742652f, -0.32647789f, 0.22680123f, 0.11729383f, 0.10764273f, 
    -0.04372368f, -0.16917552f, -0.11868742f, -0.00979299f, 0.06425635f, 0.11344931f, -0.01056443f, -0.26234537f, 
    0.14665636f, -0.41605023f, -0.21686140f, -0.56753564f, -0.04999900f, 0.24191549f, 0.09783454f, -0.21716917f, 
    0.01201279f, 0.37074819f, 0.36401293f, 0.05878737f, -0.69353592f, -0.29684031f, -0.16173030f, -0.51017070f, 
    -0.05717668f, -0.00037152f, 0.08190086f, 0.13435231f, 0.05116752f, 0.28153989f, 0.17789853f, 0.24598147f, 
    -0.29610363f, -0.24340709f, -0.08986624f, -0.04159830f, 0.09177495f, 0.11745216f, 0.30724460f, 0.24498041f, 
    -0.08891328f, 0.13331971f, 0.06765806f, -0.10759918f, -0.05867679f, 0.01394591f, -0.25184768f, 0.13583958f, 
    -0.12356626f, 0.00812193f, 0.16389330f, 0.04935953f, 0.33940753f, 0.06190508f, 0.04569104f, -0.28242394f, 
    -0.63032359f, 0.02888809f, 0.05444800f, 0.02522641f, 0.02426121f, -0.23683740f, 0.26212877f, 0.22148496f, 
    0.28914893f, -0.03605359f, 0.16243757f, 0.12685484f, -0.34895971f, -0.21715602f, -0.09481925f, 0.60136563f, 
    0.05751665f, 0.02041083f, -0.28316867f, -0.08052333f, -0.03093015f, -0.00818070f, -0.03612719f, -0.03794066f, 
    -0.78592485f, -0.76048517f, 0.29234481f, 0.17038432f, -0.18223459f, -0.22084326f, 0.18099628f, -0.12432057f, 
    -0.48210153f, -0.10859957f, -0.10015111f, 0.25178686f, -0.09640896f, 0.15538636f, 0.15152062f, -0.22566256f, 
    -0.14991787f, 0.19649152f, 0.06873234f, -0.11758041f, -0.09850018f, -0.04594979f, -0.65987402f, -0.24450524f, 
    -0.02810751f, -0.46306747f, 0.04175760f, -0.44669113f, 0.12084259f, 0.45816913f, 0.19148695f, 0.10682632f, 
    0.02116144f, 0.20093448f, -0.09706258f, -0.13073094f, -0.28910121f, -0.00435633f, 0.05984103f, -0.12764426f, 
    -0.31916109f, 0.07433308f, -0.10123966f, -0.01827056f, 0.03508238f, -0.09872022f, 0.29861641f, -0.56987941f, 
    0.33636957f, 0.21259873f, -0.22354972f, -0.07439996f, -0.02590085f, -0.65363473f, -0.05630056f, -0.29374430f, 
    -0.21722345f, 0.51636153f, -0.16532129f, 0.29564923f, 0.04017650f, -0.02710951f, -0.19685772f, 0.16246900f, 
    0.00188137f, -0.04348999f, -0.14247164f, 0.17070173f, -0.04404159f, 0.17251462f, -0.35899019f, -0.11485757f, 
    0.17348233f, -0.06879508f, -0.74175006f, -0.32281822f, 0.12292830f, 0.18893991f, 0.27829063f, -0.43185523f, 
    0.22698671f, 0.02557272f, -0.10356905f, 0.11222678f, -0.01447016f, 0.02117442f, 0.13802736f, -0.67660934f, 
    0.10816745f, 0.03486270f, -0.03648851f, -0.06221632f, 0.00830420f, 0.04901210f, 0.28553015f, -0.09252763f, 
    0.00748968f, 0.10277406f, -0.74153328f, -0.02502284f, 0.19916326f, -0.42834270f, -0.04147984f, -0.07594654f, 
    0.01191084f, 0.05722025f, -0.07387859f, -0.09891903f, 0.15840353f, -0.08460882f, 0.18185569f, 0.12949948f, 
    -0.31624669f, 0.06557232f, -0.47141981f, -0.09427732f, -0.31523472f, -0.11015174f, 0.04658512f, -0.26514876f, 
    0.06776291f, -0.10968976f, 0.22386202f, 0.07331849f, -0.06726410f, 0.00445327f, 0.01781670f, 0.29897502f, 
    0.20750400f, 0.32237190f, -0.06945279f, -0.84342754f, 0.36156771f, -0.44460472f, 0.28622749f, -0.31450829f, 
    0.02900398f, -0.12142349f, 0.00550832f, 0.10478754f, 0.10886287f, -0.59530091f, -0.43789595f, -0.08121981f, 
    0.00447775f, 0.19981918f, 0.10982711f, -0.06362209f, -0.25154671f, 0.08296829f, 0.06731423f, -0.17587252f, 
    -0.09304678f, 0.13466795f, -0.10260105f, 0.04461503f, 0.05557020f, 0.01599111f, 0.02099347f, -0.00572364f, 
    0.07715687f, -0.76629430f, 0.32150772f, -0.02722395f, -0.20065077f, -0.34163436f, 0.01463309f, -0.39890078f, 
    0.10734060f, -0.02457469f, 0.05249795f, -0.06518025f, 0.09577016f, 0.25201192f, 0.21495274f, -0.42040694f, 
    -0.35975975f, 0.18267916f, 0.19122055f, 0.18612550f, -0.07084776f, -0.08712795f, -0.01919153f, -0.33804780f, 
    -0.05637604f, 0.06978980f, 0.20349051f, -0.22636919f, -0.08440372f, -0.18059908f, 0.11699141f, -0.30921257f, 
    0.25325221f, 0.23564251f, -0.34461847f, 0.19906726f, -0.16901027f, 0.07400225f, -0.25523797f, 0.00415895f, 
    0.22575609f, -0.09639041f, -0.01754269f, -0.27202773f, -0.01728326f, -0.13846673f, 0.05896350f, -0.10813045f, 
    -0.13430437f, 0.03494096f, 0.09896626f, -0.04044882f, 0.04209195f, 0.06127001f, -0.06919236f, 0.26295778f, 
    0.10597192f, 0.08222631f, -0.03945624f, 0.04536539f, -0.12575038f, 0.09757690f, -0.36668262f, 0.11907714f, 
    0.05057351f, 0.08239825f, -0.04418435f, -0.07321370f, -0.43496832f, 0.29649177f, -0.07160460f, -0.05303313f, 
    0.03206806f, -0.08408285f, 0.11423216f, 0.24346788f, 0.01181466f, 0.14716390f, -0.17722066f, -0.14784232f, 
    -0.16999918f, 0.16058831f, -0.05688657f, 0.15147117f, 0.23475172f, 0.36542964f, 0.05060508f, -0.67797899f, 
    0.05081173f, -0.38575283f, 0.12256252f, 0.05070002f, 0.11391096f, 0.24344212f, 0.00170593f, -0.50040179f, 
    -0.49046031f, -0.37208587f, -0.08664906f, -0.06781852f, -0.11733876f, 0.18349570f, 0.20387726f, 0.25224045f, 
    0.05477769f, 0.10193416f, 0.26053140f, -0.10408125f, -0.08654574f, -0.19052052f, -0.17388880f, -0.00662349f, 
    -0.37241128f, 0.06715240f, 0.02805219f, -0.00089894f, -0.50633627f, -0.03378527f, -0.25074255f, -0.18305627f, 
    -0.12389473f, -0.43297365f, -0.06284057f, 0.30263591f, 0.10049798f, -0.49806580f, -0.07049505f, -0.20818809f, 
    0.06678192f, 0.11401781f, 0.35504198f, -0.02983722f, -0.62024790f, -0.25063062f, 0.39116564f, 0.22109056f, 
    -0.19324338f, -0.01114247f, -0.07726686f, -0.81714332f, 0.20744039f, -0.63908201f, -0.96514034f, -0.39527524f, 
    0.34437335f, 0.31748274f, -0.28975025f, -0.46361622f, -0.00476109f, -0.25178969f, 0.02098646f, 0.05499748f, 
    -0.13940647f, -0.14264381f, 0.18272214f, 0.09665151f, -0.04356213f, 0.05211575f, -0.15509710f, 0.31755877f, 
    0.44533432f, -0.58616084f, -0.31883311f, -0.00452032f, -0.09990228f, 0.15896037f, -0.79527414f, 0.17972776f, 
    0.29919687f, -0.05354135f, 0.06240259f, 0.19104278f, -0.11310415f, 0.17473447f, 0.12554677f, 0.01047586f, 
    -0.34510756f, -0.40293452f, 0.02152198f, 0.10388054f, -0.65087557f, 0.00897948f, -0.48025662f, 0.04656241f, 
    -0.13920893f, -0.22399580f, 0.01200554f, -0.35404220f, -0.18572813f, -0.25270250f, 0.20221651f, -0.27545688f, 
    -0.06397270f, 0.22720574f, -0.25965175f, -0.01544479f, 0.18875235f, 0.02768371f, -0.61336237f, 0.11963432f, 
    0.61133695f, 0.11110219f, 0.05254541f, 0.11783662f, -0.36618707f, -0.13337052f, -0.53691941f, -0.08100351f, 
    -0.22910474f, -0.55913353f, 0.02949569f, -0.27945513f, -0.09148926f, -0.04667030f, -0.00877337f, -0.14648506f, 
    0.07856080f, -0.17325675f, -0.40026385f, 0.30075297f, -0.01629101f, -0.36914694f, 0.17365529f, -0.47859722f, 
    -0.02888400f, 0.52834970f, -0.18242203f, -0.11065312f, 0.21447545f, 0.02372564f, -0.19050947f, -0.16344434f, 
    -0.10764105f, 0.04237277f, -0.23187861f, 0.12172026f, 0.09100692f, 0.24863872f, 0.29414281f, 0.33069435f, 
    0.43657604f, -0.04528906f, 0.10018303f, 0.11000545f, 0.19399813f, 0.05235468f, -0.09094219f, -0.20444751f, 
    0.08253574f, -0.33345595f, -0.09641248f, 0.22294749f, 0.21588233f, -0.73925287f, -0.10167916f, -0.18217459f, 
    0.07134858f, 0.01050287f, -0.25332847f, -0.02600414f, -0.12316979f, 0.37185088f, -0.29787594f, 0.03953891f, 
    -0.46878833f, -0.03832691f, -0.03648347f, 0.22635224f, -0.60391104f, -0.55150396f, -0.69522107f, -0.01179506f, 
    0.02899982f, 0.01302341f, -0.10825651f, -0.63977724f, 0.35689488f, -0.69527024f, -0.01125600f, 0.04563405f, 
    0.13098855f, 0.22305508f, -0.40709093f, -0.00620922f, -0.10502516f, 0.25897160f, 0.22808537f, -0.28197634f, 
    -0.40744871f, -0.00720848f, -0.27193189f, -0.08727202f, 0.28186351f, -0.17896231f, 0.20967226f, -0.45830503f, 
    -0.02888424f, -0.06424940f, 0.28765231f, -0.17381167f, 0.04836138f, -0.12372892f, -0.23586632f, 0.40961266f, 
    -0.11952302f, -0.38889313f, 0.09852378f, -0.09092446f, -0.22959338f, -0.07451297f, 0.13040893f, -0.47974232f, 
    0.02117196f, -0.18737626f, -0.00728392f, -0.20412777f, -0.40503448f, -0.03421602f, 0.11537792f, -0.40194875f, 
    -0.06242052f, 0.03741711f, 0.33291647f, -0.04503828f, -0.42562285f, 0.14535297f, -0.11495700f, 0.35997778f, 
    -0.00260208f, 0.01633520f, 0.05565094f, -0.12658229f, -0.05779251f, 0.44000399f, 0.11917546f, 0.21810542f, 
    -0.20918238f, -0.17811094f, 0.01195217f, 0.35140067f, -0.15927656f, 0.51136577f, -0.09425141f, 0.15093693f, 
    -0.75355422f, 0.03626904f, -0.21358655f, -0.22085968f, -0.05498695f, -0.54644644f, -0.58646113f, 0.18505308f, 
    0.00971942f, 0.10959751f, -0.50880814f, -0.14977239f, 0.08394617f, 0.18413743f, -0.08772683f, 0.22658990f, 
    0.30266777f, 0.04431536f, -0.00546734f, -0.17474775f, 0.06044200f, -0.16913401f, 0.14792342f, 0.03752949f, 
    0.24719563f, 0.35769525f, -0.04727511f, -0.07022418f, 0.00737795f, -0.11547777f, -0.70483905f, -0.07148829f, 
    -0.05376642f, -0.36905283f, 0.04622294f, 0.40064466f, 0.29768103f, 0.07876673f, 0.28849167f, -0.49956617f, 
    0.05950682f, -0.41015181f, -0.50398684f, 0.07077424f, 0.43732983f, 0.00482474f, 0.38061523f, -0.37388480f, 
    -0.56556344f, 0.05444895f, -0.01470364f, 0.09965923f, 0.26252696f, -0.00908976f, -0.24717019f, 0.40989143f, 
    0.16865852f, -0.01311376f, -0.66895342f, -0.08628934f, -0.26519021f, -0.47519422f, 0.04308315f, -0.44213745f, 
    -0.01872287f, -0.25497022f, -0.08445555f, -0.04134302f, 0.03000646f, -0.25377852f, -0.48449895f, 0.05696424f, 
    -0.47460121f, -0.52532333f, 0.29499328f, -0.64611679f, -0.08567221f, 0.19156355f, 0.17646195f, 0.04784702f, 
    -0.59375125f, -0.08639716f, -0.07088012f, 0.34306535f, -0.11172747f, -0.24319467f, 0.11732768f, -0.25926098f, 
    -0.07548754f, 0.02079033f, -0.04606329f, -0.02145280f, 0.25993413f, 0.01771159f, -0.32910833f, 0.04539564f, 
    -0.07184858f, -0.07722977f, 0.09472137f, 0.20326720f, -0.15206632f, -0.56250238f, -0.02806981f, 0.27423728f, 
    -0.08870977f, 0.14015560f, -0.42589274f, 0.05443634f, 0.34580609f, -0.02090992f, 0.07836992f, -0.18140540f, 
    -0.30046177f, -0.12375434f, 0.06551246f, -0.59317249f, 0.40060902f, -0.38735780f, -0.10723949f, 0.40762988f, 
    -0.07411027f, -0.30727956f, -0.07141421f, -0.48989329f, 0.13683699f, 0.63379514f, 0.08912934f, -0.39621025f, 
    0.07343654f, 0.17844692f, 0.39952338f, 0.06873378f, -0.03694620f, -0.32107884f, 0.27458563f, 0.38383722f, 
    0.19754694f, -0.40387100f, -0.44766521f, -0.04274786f, 0.13614330f, -0.68293279f, -0.44991720f, 0.15570977f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.06632446f, -0.01187396f, 0.02854908f, -0.14471099f, -0.13141039f, -0.03029397f, 0.11199696f, 0.05706229f, 
    0.12851486f, 0.01411065f, -0.03743427f, 0.02919212f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
