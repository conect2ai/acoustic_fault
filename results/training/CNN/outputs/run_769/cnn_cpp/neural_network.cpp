#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.40756118f, 0.35381496f, 0.32890844f, -0.53165483f, -0.55114722f, 0.82368416f, 0.21979398f, 0.10252994f, 
    -0.15234025f, -0.42256001f, -0.87808174f, -0.72896743f, -0.30739266f, 0.31535134f, 0.01087580f, 0.26835725f, 
    0.14328775f, 0.19908531f, 0.79448438f, 0.61786294f, 0.41228184f, 0.01746991f, -0.46425164f, -0.31089801f, 
    0.34783891f, 0.28660437f, 0.14473020f, -0.53058004f, 0.36552098f, 0.55577886f, 0.33141431f, -0.43941665f, 
    -0.24536961f, 0.07343742f, 0.09030106f, 0.49369913f, -0.61969590f, 0.74109983f, 0.09526868f, -0.01885605f, 
    -0.20573552f, -0.34091204f, 0.16122569f, 0.01829564f, -0.24070548f, 0.60964835f, 0.46769550f, 0.28660846f, 
    -0.67842710f, 0.41142693f, -0.50643551f, -0.34584859f, -0.25962195f, 0.09079747f, -0.00674125f, 0.11964757f, 
    -0.40947348f, 0.66588575f, -0.18785089f, 0.51431310f, -0.48667991f, -0.11995728f, -0.28667879f, -0.62197751f, 
    -0.62485498f, -0.09187389f, 0.68284404f, 0.62006241f, 0.45196381f, -0.06491664f, -0.28085369f, -0.14475642f, 
    -0.18991663f, -0.01222242f, 0.06481799f, -0.70277417f, 0.66862452f, -0.84116703f, -0.02866951f, 0.23317432f, 
    0.05808847f, 0.77263474f, 0.31560880f, 0.62148327f, 0.48741287f, 0.40558454f, 0.13841417f, -0.19898276f, 
    0.36582804f, 0.03195111f, -0.17303540f, 0.69831121f, 0.44183114f, 0.14383315f, 0.60296071f, 0.47830269f, 
    -0.10291708f, -0.30923462f, -0.42839569f, 0.06449166f, 0.10190503f, -0.11452780f, -0.63744175f, -1.05558515f, 
    -0.67988557f, -0.37338734f, -0.03954230f, 0.21386532f, 0.66808206f, -0.79399580f, -0.67392272f, -0.44208890f, 
    0.10868122f, -0.26698083f, -0.35657817f, 0.05016080f, 0.13183121f, -0.53730989f, 0.29310709f, -0.49516889f, 
    -0.12889642f, 0.70620042f, -0.31640288f, -0.03731995f, -0.21322103f, -0.56542885f, 0.30724686f, -0.53915447f, 
    0.59317821f, 0.64353991f, -0.57015300f, 0.48871973f, 0.18746823f, -0.28621736f, -0.06836743f, 0.08616062f, 
    0.61932832f, -0.78782630f, 0.24343321f, -0.24592325f, -0.31834528f, 0.24594279f, 0.08950558f, 0.41495064f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.37416038f, 0.00045128f, 0.25581002f, -0.39133081f, -0.00791167f, 0.12622973f, -0.16239507f, 0.17015602f, 
    -0.02432636f, -0.22571491f, -0.04958324f, 0.14015049f, -0.11473487f, -0.05506788f, 0.03884355f, -0.14512624f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.03370199f, -0.13814160f, -0.00329139f, 0.11197420f, 0.03176714f, -0.04026233f, 0.11440908f, -0.03104864f, 
    -0.00106569f, -0.08722546f, 0.21728493f, 0.18576026f, -0.03826680f, -0.06911458f, 0.16417013f, 0.08315422f, 
    0.00827374f, 0.16959204f, 0.21894261f, 0.14245726f, 0.01280884f, 0.05680376f, 0.03769292f, -0.04615783f, 
    0.00360149f, -0.03154077f, -0.00875968f, -0.06022849f, -0.15039556f, 0.10081340f, 0.04908980f, 0.00529770f, 
    -0.23921770f, -0.10580594f, -0.02799476f, 0.03963884f, -0.26242352f, -0.11086316f, -0.03936789f, -0.08102541f, 
    0.03594488f, 0.05877868f, -0.03344632f, -0.05285769f, -0.01238959f, -0.12838197f, -0.18069912f, -0.23045038f, 
    0.12923102f, 0.19406924f, -0.09796663f, -0.09764028f, -0.11120474f, -0.03863150f, 0.08156136f, -0.19885090f, 
    -0.14702249f, -0.20554160f, -0.00089622f, 0.00834916f, -0.03360838f, -0.04186896f, -0.01031909f, 0.15328476f, 
    -0.08766694f, 0.29652235f, -0.13488261f, -0.09690194f, -0.01859664f, 0.07306485f, -0.03688634f, -0.17791913f, 
    -0.24409920f, -0.35939524f, -0.19006214f, 0.09383619f, 0.16691744f, -0.06301446f, 0.02070539f, -0.01179112f, 
    0.01531230f, 0.11940684f, 0.03581953f, 0.15367685f, 0.22346812f, 0.02484739f, -0.04222861f, 0.00828299f, 
    0.08027250f, -0.00382181f, 0.06737763f, 0.17841779f, 0.21151289f, 0.14297995f, -0.06509906f, -0.01102741f, 
    -0.01726407f, -0.00448154f, 0.06781432f, -0.25694647f, -0.44830099f, 0.08030275f, -0.06617682f, -0.02029464f, 
    -0.02573484f, 0.12301024f, 0.00434145f, 0.18323183f, 0.03692859f, 0.62026775f, 0.01577061f, -0.08771603f, 
    -0.03568658f, 0.10127621f, -0.00804236f, -0.05465249f, -0.18844853f, 0.15864818f, 0.08713540f, -0.42685845f, 
    0.03966299f, -0.00223437f, 0.20770380f, 0.11496436f, -0.18055078f, -0.13229376f, -0.13498683f, 0.21581647f, 
    0.22039488f, 0.15402353f, -0.06306506f, 0.04564400f, 0.01163370f, 0.02638311f, -0.00353219f, 0.01342592f, 
    0.12536658f, -0.29393536f, 0.00476734f, -0.10194408f, 0.14656562f, -0.06239013f, 0.02417218f, 0.06832933f, 
    -0.00492515f, -0.03502841f, -0.01618821f, 0.04418959f, 0.07705112f, 0.03686857f, -0.00940528f, 0.02228179f, 
    0.00222061f, -0.04863288f, -0.00142657f, -0.07738689f, -0.00035807f, -0.07389420f, -0.04486471f, -0.08113697f, 
    -0.07804925f, -0.03447468f, 0.03657662f, 0.05218428f, -0.05644410f, -0.06540244f, -0.05572819f, -0.02853809f, 
    -0.07641016f, -0.03083359f, -0.01386858f, -0.03977473f, 0.07647669f, -0.04014117f, 0.08234398f, -0.03817630f, 
    -0.06645197f, -0.06379551f, -0.04971144f, 0.07485878f, -0.06361941f, -0.02383946f, -0.02165484f, 0.04040552f, 
    0.00584181f, 0.01179158f, 0.03044865f, -0.06139954f, 0.05978203f, -0.06368213f, -0.03506748f, -0.06366978f, 
    -0.00783501f, 0.03737809f, -0.05512642f, -0.08770644f, -0.01041557f, -0.04236436f, -0.05362605f, 0.01406628f, 
    -0.07318136f, -0.00404035f, 0.05202558f, -0.01988473f, 0.04927890f, -0.07749657f, -0.06651111f, 0.05042743f, 
    -0.01136486f, 0.00943869f, -0.08515341f, 0.04243300f, -0.02808543f, -0.06890704f, 0.03018420f, -0.04956487f, 
    0.04006337f, -0.03674858f, -0.02303511f, -0.08161276f, 0.02116842f, -0.02772560f, -0.05328766f, 0.00595551f, 
    0.04211914f, 0.07650309f, -0.06190031f, -0.07562818f, -0.05987135f, -0.03877389f, -0.06335931f, 0.06118060f, 
    -0.03804472f, -0.07277858f, 0.00339395f, 0.02836309f, -0.05532902f, -0.02810694f, 0.05120803f, -0.04974692f, 
    -0.06138394f, -0.05370792f, -0.07146688f, 0.06259307f, 0.07773567f, -0.00578601f, 0.04554345f, 0.03123643f, 
    -0.07227471f, -0.05168414f, -0.03895146f, 0.03087421f, 0.00266155f, 0.07206529f, 0.07500033f, -0.00652694f, 
    0.05421191f, 0.03960400f, -0.01945126f, -0.03929499f, -0.02191089f, -0.02446507f, -0.04479249f, 0.04548726f, 
    -0.03893379f, 0.07153261f, 0.02304908f, 0.00686614f, 0.06276978f, 0.01593250f, -0.04581175f, -0.02650562f, 
    -0.02243407f, 0.07041883f, 0.00500713f, -0.03153034f, -0.04043100f, 0.04284709f, -0.00123121f, -0.07434407f, 
    -0.00625173f, 0.06041298f, -0.02476124f, 0.04437378f, -0.05906610f, -0.02109085f, -0.01653558f, -0.07199942f, 
    0.50919914f, 0.17359051f, -0.16812110f, 0.06156337f, 0.03465619f, 0.12289633f, -0.01866496f, -0.07690652f, 
    0.20756787f, 0.11652496f, 0.23729092f, -0.44276425f, -0.07027013f, 0.16699184f, 0.17888936f, 0.14373483f, 
    -0.13842578f, -0.02029267f, 0.47517854f, 0.13040863f, -0.07200915f, 0.28847530f, 0.07160155f, 0.19756459f, 
    0.12905517f, -0.02491409f, 0.27259231f, -0.24974503f, -0.41999376f, -0.01450952f, -0.16318932f, 0.00150783f, 
    -0.03483649f, -0.17372683f, 0.01690459f, -0.08981657f, -0.22505595f, -0.43655840f, -0.07660697f, -0.07359935f, 
    -0.13258305f, 0.31322211f, -0.06867953f, -0.24176750f, -0.05774609f, 0.31842497f, 0.54804879f, -0.22860874f, 
    0.02888238f, 0.01836666f, 0.25093767f, -0.02669347f, -0.02768742f, 0.19723043f, -0.10683776f, -0.05954584f, 
    0.01540456f, -0.03107514f, 0.06081844f, -0.36173654f, -0.08209495f, 0.05225810f, -0.21084857f, -0.43390778f, 
    -0.07495520f, -0.01393059f, -0.26856282f, 0.19093724f, -0.09464670f, -0.07882459f, -0.11914665f, -0.15101527f, 
    0.10176173f, 0.24922857f, -0.30013099f, -0.06112805f, 0.10787223f, 0.25963408f, 0.12558794f, 0.07038125f, 
    0.00269944f, 0.15657434f, -0.15122743f, -0.03814985f, 0.12727752f, -0.06817557f, -0.22253762f, -0.05723943f, 
    0.18459962f, -0.02012259f, -0.04456524f, -0.35430285f, -0.10117815f, 0.18403484f, -0.03964898f, -0.09417282f, 
    -0.10399883f, 0.14163193f, 0.10837750f, 0.18965764f, 0.18915197f, -0.38946378f, 0.07794350f, 0.05855052f, 
    0.12494231f, -0.01664446f, -0.08704429f, -0.31588468f, 0.00515546f, 0.19164744f, 0.00450336f, 0.25646347f, 
    -0.33653292f, -0.08141803f, 0.00516814f, 0.07153109f, -0.12604769f, -0.05313065f, -0.23123913f, 0.00413661f, 
    0.06108008f, 0.08733844f, -0.22258143f, -0.13162625f, -0.11006916f, -0.17313983f, -0.14987013f, 0.01355616f, 
    0.34023893f, 0.15090281f, 0.00493038f, -0.00000550f, 0.05587982f, 0.13307571f, 0.11087301f, 0.20511504f, 
    -0.03830981f, 0.17630397f, 0.12681147f, 0.00142167f, 0.09009593f, 0.17533921f, 0.18707310f, 0.11328775f, 
    0.11145273f, -0.21542430f, -0.25065875f, -0.35996923f, 0.08495085f, -0.17447163f, -0.03459584f, 0.14815457f, 
    -0.16401909f, -0.55381519f, 0.35701358f, -0.17669803f, 0.43673792f, -0.12188829f, 0.12588041f, -0.08611810f, 
    -0.07641498f, 0.17362103f, 0.18991725f, 0.18964373f, 0.18355820f, -0.18850510f, 0.10688446f, -0.03015190f, 
    -0.03247223f, -0.09310258f, 0.21342988f, -0.45043951f, 0.05267177f, 0.07061957f, 0.06788863f, 0.10388843f, 
    -0.05832402f, -0.07427914f, -0.00807158f, -0.11654495f, 0.03182473f, 0.02343669f, 0.02326071f, -0.17528212f, 
    0.00624190f, -0.03044462f, -0.07772729f, 0.12450823f, 0.00455595f, -0.11962328f, 0.13179973f, 0.03646823f, 
    -0.17440739f, 0.35963625f, 0.01376838f, 0.12696719f, -0.04280018f, 0.14329274f, 0.34040949f, -0.14862236f, 
    -0.08536468f, 0.17371908f, -0.00266406f, 0.12679309f, -0.03151435f, 0.09150773f, -0.00373823f, -0.06037928f, 
    0.22369125f, 0.05769265f, 0.35219261f, 0.02629853f, -0.04731103f, -0.07745129f, 0.09618751f, 0.15429740f, 
    -0.21305393f, -0.07531737f, 0.19965102f, 0.05935832f, 0.07959057f, 0.15225933f, 0.03063811f, -0.01245331f, 
    -0.04293006f, -0.19244023f, 0.26396298f, 0.05351579f, 0.04133744f, 0.24190804f, -0.01970982f, -0.08993092f, 
    0.03454029f, 0.16219319f, 0.18522798f, 0.11187712f, -0.09865483f, -0.02933149f, -0.01109685f, 0.11825228f, 
    0.29701960f, 0.17145714f, 0.08021157f, 0.21423468f, -0.19028598f, 0.05309953f, -0.28244016f, 0.00449424f, 
    -0.00655385f, 0.24059707f, 0.18601155f, 0.08240468f, 0.17070460f, -0.01306188f, 0.05484441f, -0.18026505f, 
    -0.42747623f, -0.03052908f, 0.03540656f, 0.07157253f, -0.09769108f, 0.43281412f, 0.06734005f, -0.02660896f, 
    0.24002551f, 0.04945582f, 0.20674880f, -0.12435350f, 0.09818211f, 0.06197546f, -0.18098004f, -0.09176893f, 
    -0.15755586f, 0.05538234f, 0.24186705f, 0.05134736f, -0.10081290f, -0.01828399f, -0.19229136f, 0.04071785f, 
    0.09011175f, 0.08528046f, -0.01365385f, -0.15395930f, -0.11395817f, 0.01793800f, -0.18418510f, -0.01304096f, 
    0.03746955f, 0.10335807f, -0.05163151f, 0.02210753f, -0.07346723f, -0.10981943f, 0.01217609f, -0.17788897f, 
    0.17267692f, 0.16306227f, 0.22796245f, 0.31167626f, 0.02817425f, 0.08080786f, 0.18706891f, 0.00914231f, 
    0.17165273f, -0.07015841f, -0.40100303f, -0.05993968f, 0.03084910f, -0.07080991f, -0.08933972f, -0.04854210f, 
    -0.09264483f, 0.02660319f, 0.07142814f, -0.11307653f, -0.16182904f, -0.29162896f, -0.08622526f, -0.14365253f, 
    0.04136002f, -0.02492965f, 0.14727208f, 0.07735299f, 0.03672204f, -0.08108974f, -0.09889339f, 0.36826664f, 
    -0.08674581f, 0.06918586f, -0.04242794f, -0.12880000f, -0.00073080f, -0.09093907f, -0.12693492f, 0.24078201f, 
    0.02062699f, -0.13005827f, 0.20369457f, -0.24328944f, 0.12580609f, -0.11655326f, 0.38715619f, -0.10264074f, 
    0.09546088f, 0.02735347f, -0.03023350f, -0.09017779f, -0.01413470f, -0.01040436f, 0.07008392f, 0.03634633f, 
    0.18691486f, 0.15161049f, 0.13636471f, 0.04744080f, 0.01780234f, 0.07786709f, 0.05727233f, 0.01756036f, 
    -0.23029767f, -0.06323811f, 0.28880146f, 0.07812675f, 0.04401436f, 0.01975188f, -0.15559992f, -0.11812692f, 
    -0.09879027f, -0.16066620f, -0.22580290f, 0.05628568f, 0.06012959f, -0.07643359f, 0.03536402f, -0.01238120f, 
    0.15705359f, 0.10922680f, 0.09005294f, -0.20445368f, 0.00574449f, -0.19635063f, -0.00879281f, -0.16221444f, 
    0.02400489f, 0.14350615f, 0.10572878f, 0.01770917f, -0.11462419f, -0.00834289f, -0.17144194f, -0.09440359f, 
    -0.08684842f, 0.01141490f, 0.00709763f, -0.09945324f, 0.17092204f, 0.21772309f, 0.17784704f, 0.03976996f, 
    0.08867546f, 0.08797381f, -0.16453820f, 0.04983513f, -0.09811947f, 0.03994214f, 0.16306783f, 0.20728061f, 
    0.18481831f, 0.14647977f, -0.05710014f, 0.05315403f, -0.31468382f, -0.16392186f, 0.14598970f, 0.08996347f, 
    0.08381706f, -0.15881345f, -0.15807797f, -0.01690151f, 0.18457206f, -0.05963873f, 0.05532505f, -0.36936876f, 
    0.17984653f, 0.13105953f, -0.07311159f, 0.11982901f, -0.04593447f, 0.33718422f, -0.05290623f, -0.06704797f, 
    -0.64818364f, -0.00439566f, -0.33441398f, -0.01731474f, -0.00725692f, 0.06067214f, 0.04664234f, -0.03306573f, 
    0.11089535f, 0.58552289f, -0.14135599f, 0.21147631f, -0.17257711f, 0.01367928f, -0.17322969f, 0.06260645f, 
    0.02903986f, -0.03627108f, -0.16587423f, 0.04786028f, -0.01250889f, 0.07660440f, 0.19797647f, 0.09309932f, 
    -0.12481730f, 0.10317408f, 0.01093173f, 0.08672241f, 0.24474038f, -0.46710745f, -0.06278738f, 0.00696786f, 
    -0.15170734f, 0.04281599f, 0.06511246f, 0.09507350f, 0.03940225f, -0.14302729f, -0.31786311f, 0.03537719f, 
    0.04382420f, 0.07417186f, -0.10273756f, 0.01090190f, 0.07907055f, 0.06181167f, 0.15532953f, 0.06179165f, 
    0.05594819f, 0.07282732f, 0.09803651f, -0.03194991f, -0.11183518f, -0.02381546f, -0.18762493f, 0.04452148f, 
    0.04994555f, 0.07337008f, -0.00149508f, -0.13921519f, 0.06967133f, -0.02618210f, -0.04859253f, 0.61722791f, 
    0.13839418f, 0.06494119f, -0.05041888f, 0.05659891f, -0.15800774f, 0.09580828f, 0.07957112f, -0.08877214f, 
    0.10724328f, 0.19494303f, -0.33797723f, -0.10807458f, -0.01336087f, 0.12253127f, 0.05877800f, 0.16839853f, 
    -0.13974015f, -0.42176312f, -0.14943613f, -0.05015396f, 0.03708647f, 0.19032733f, -0.00016492f, -0.00580166f, 
    0.05628940f, 0.15687156f, 0.22237033f, 0.00318785f, -0.06551786f, 0.02409207f, -0.00854477f, 0.10053167f, 
    -0.00166425f, 0.06199407f, 0.05761577f, -0.23522146f, 0.12707233f, 0.09410813f, 0.23439589f, 0.14179051f, 
    0.19072519f, -0.23956315f, 0.14780144f, 0.08989988f, -0.18275142f, -0.42915514f, -0.26807511f, -0.04686670f, 
    0.04459184f, 0.12608749f, -0.14592148f, -0.17389649f, 0.01790520f, 0.04692673f, -0.20210305f, -0.25474027f, 
    0.22883987f, 0.01465872f, 0.17400871f, 0.14551768f, 0.06733942f, 0.05444060f, -0.53442454f, 0.23600346f, 
    0.04701021f, 0.10435070f, 0.03401151f, -0.11627334f, -0.10561702f, -0.05656923f, 0.09617175f, -0.05753166f, 
    -0.14129244f, -0.04121257f, 0.03127591f, -0.04311461f, 0.02335382f, -0.14699067f, -0.07134106f, 0.00760220f, 
    -0.11916481f, -0.48470464f, 0.05653238f, -0.02238270f, -0.06140577f, 0.06276049f, -0.02136207f, 0.03384370f, 
    -0.01505256f, -0.01071501f, 0.18100731f, -0.10454064f, -0.13619033f, -0.20327002f, -0.18968044f, -0.02064702f, 
    0.14955758f, -0.11875658f, -0.07324230f, -0.46062240f, -0.06030316f, 0.05222832f, -0.03663641f, 0.21158953f, 
    -0.02091016f, -0.02505906f, 0.00060761f, -0.09448293f, 0.00756421f, -0.13045433f, 0.11676373f, -0.10594218f, 
    -0.13308790f, 0.06441399f, 0.05321291f, 0.16571264f, 0.38065627f, 0.11705258f, 0.07105323f, 0.05413948f, 
    -0.17149314f, -0.06157043f, 0.00441591f, 0.04761852f, -0.04578152f, -0.32620537f, -0.10484353f, 0.07655754f, 
    0.18615989f, 0.01045874f, 0.14375900f, -0.07245030f, -0.14214982f, -0.04957381f, 0.16537341f, 0.02160450f, 
    0.20258205f, 0.10548572f, 0.14703853f, 0.00798884f, -0.06906749f, -0.11740180f, 0.05373146f, 0.31528875f, 
    0.33996364f, 0.01693737f, -0.08077776f, 0.04437090f, -0.13201749f, 0.13092828f, 0.24084257f, 0.20859516f, 
    -0.19014254f, 0.06566826f, 0.16480194f, -0.06858639f, 0.17113441f, 0.07004202f, 0.00413740f, -0.07037904f, 
    0.10975955f, -0.37233561f, -0.10857968f, -0.04777160f, -0.02889346f, -0.04380060f, 0.04149772f, 0.00791906f, 
    -0.01615206f, -0.03601905f, -0.48947549f, -0.09296422f, -0.00573223f, 0.12520108f, -0.03760594f, -0.14614052f, 
    0.06853841f, -0.07756921f, -0.08641642f, 0.37304184f, 0.07500362f, 0.17221393f, 0.04262345f, 0.14047679f, 
    0.06947429f, 0.01787061f, 0.01316603f, 0.10760038f, 0.03320707f, 0.07958354f, 0.06733369f, -0.10638812f, 
    -0.03170771f, 0.13394575f, 0.00146003f, 0.00018368f, -0.08588091f, 0.03427986f, -0.06602307f, -0.24169385f, 
    0.11604311f, 0.07963702f, 0.00988532f, -0.10535522f, -0.19485253f, -0.18343566f, -0.08893056f, -0.07745007f, 
    -0.03287921f, 0.10742705f, 0.16653168f, 0.01925306f, -0.01793744f, 0.05881463f, 0.08281954f, 0.24813432f, 
    0.02319464f, -0.07397211f, -0.09204498f, 0.07344258f, -0.13205694f, -0.05491755f, 0.07373013f, 0.01121090f, 
    -0.08164572f, -0.02990463f, -0.38182786f, 0.02173246f, -0.08934805f, -0.12374175f, -0.02038331f, 0.08130831f, 
    0.29512286f, -0.03192647f, 0.31234419f, -0.12793934f, 0.13120870f, -0.02382100f, 0.03962391f, -0.16507520f, 
    -0.07587898f, 0.12451154f, 0.33613664f, -0.03191274f, 0.19209908f, -0.07699709f, -0.19225453f, -0.06608916f, 
    0.14405887f, -0.02919186f, -0.02502563f, -0.51486123f, 0.04515244f, 0.10285062f, -0.07798241f, 0.05977225f, 
    -0.04136535f, -0.17703177f, 0.15478423f, -0.11049207f, 0.06096811f, 0.09663674f, -0.04851814f, -0.16181055f, 
    0.11726262f, 0.23248903f, -0.13854471f, -0.00301905f, 0.17844704f, 0.20445476f, 0.06231009f, -0.07915250f, 
    0.10010008f, -0.07762850f, -0.05691849f, -0.19766991f, -0.15532647f, 0.09612645f, 0.32575288f, -0.01688232f, 
    0.02650229f, 0.01855608f, 0.00333887f, 0.15989910f, -0.01946569f, 0.09287575f, -0.08525876f, -0.11835302f, 
    0.42470464f, 0.14259870f, 0.01290308f, 0.12391093f, -0.19177146f, 0.01282920f, -0.13650185f, -0.10843845f, 
    -0.17631273f, -0.21183680f, -0.29524136f, 0.11516923f, 0.02689188f, -0.10472889f, 0.03876148f, 0.01634928f, 
    0.01641889f, 0.18615638f, -0.22887820f, 0.06511274f, -0.06828344f, -0.16268833f, -0.10113851f, -0.02994947f, 
    0.08265756f, 0.21826595f, -0.07743554f, 0.00015058f, 0.16114347f, 0.04166431f, -0.11329063f, -0.14208965f, 
    -0.09628477f, 0.01780668f, -0.01616349f, -0.04373021f, -0.18626408f, -0.00598717f, 0.08779876f, -0.04535779f, 
    -0.15974335f, 0.02376638f, 0.06789733f, 0.05140316f, 0.12473598f, -0.38145095f, 0.12624390f, -0.00995870f, 
    -0.00089605f, 0.10527930f, 0.00062035f, -0.03706245f, -0.13713230f, 0.50000679f, -0.03256093f, -0.14055835f, 
    -0.20667778f, -0.02975029f, -0.01191017f, 0.03858976f, -0.00613984f, -0.02582281f, 0.17214845f, 0.00549106f, 
    0.10477641f, -0.13066222f, 0.01799492f, 0.05274072f, -0.01399643f, -0.12632233f, -0.03625730f, 0.18799728f, 
    -0.00371384f, -0.04370995f, 0.12538083f, 0.06925983f, -0.11354714f, -0.12161375f, -0.00956388f, 0.04264525f, 
    -0.02207161f, 0.20787440f, -0.12850644f, -0.09145568f, -0.07499271f, 0.05797148f, 0.05252032f, 0.02311644f, 
    -0.09440175f, -0.09686340f, 0.10833813f, 0.37478864f, -0.02348724f, 0.00102020f, -0.05067558f, -0.04198508f, 
    0.10297047f, -0.10540271f, -0.24782397f, 0.12957895f, -0.13144019f, -0.11837641f, 0.11243489f, -0.23784591f, 
    -0.15446045f, 0.12837695f, -0.20440474f, 0.00546004f, -0.05357040f, -0.56674635f, -0.23085563f, 0.00085263f, 
    0.32597470f, 0.12822402f, -0.01384194f, 0.09686518f, -0.23384351f, -0.08567834f, -0.27209562f, 0.01005398f, 
    -0.02503264f, -0.04535507f, 0.07786120f, 0.11484547f, -0.09061430f, 0.03717642f, 0.10893094f, -0.23270811f, 
    -0.14062352f, 0.28812829f, -0.15831248f, 0.12850878f, -0.18982995f, 0.02992601f, 0.37948173f, 0.04535954f, 
    -0.09742681f, -0.19822603f, 0.15379053f, -0.01965852f, -0.02154870f, -0.17932750f, 0.06530740f, 0.19290280f, 
    -0.08750501f, 0.24060601f, -0.00619456f, -0.16355859f, 0.06647581f, 0.04611622f, 0.10144495f, 0.13182859f, 
    -0.10382386f, 0.00663871f, 0.18724841f, 0.12845916f, 0.03470588f, 0.15729339f, 0.05607832f, -0.15460035f, 
    0.08996373f, 0.23432848f, -0.04230976f, -0.18148617f, 0.04624525f, 0.14635649f, 0.10331231f, -0.03043272f, 
    -0.00784545f, -0.15422668f, 0.06493779f, 0.06739756f, 0.07289213f, -0.09260040f, -0.08828557f, 0.00911341f, 
    0.05055235f, -0.09836759f, -0.17322241f, -0.05250803f, 0.06817716f, -0.11913777f, 0.13552439f, -0.12847003f, 
    -0.22686546f, 0.03441311f, -0.21005028f, 0.18827981f, 0.26067132f, -0.20213680f, 0.45265844f, -0.03941996f, 
    -0.08635565f, 0.14904648f, -0.06970261f, -0.04888411f, 0.10491177f, 0.00903705f, 0.34263393f, 0.04051206f, 
    0.15349723f, 0.06019789f, -0.11988654f, -0.03983863f, 0.17103799f, 0.11925266f, 0.01424114f, -0.01310166f, 
    -0.20359103f, -0.22978178f, 0.15002167f, -0.04858909f, -0.18591797f, 0.05981903f, -0.17373002f, -0.27102503f, 
    0.24106506f, 0.02022992f, 0.15387428f, -0.12610810f, 0.05626479f, -0.18134107f, 0.11770150f, 0.02699189f, 
    -0.13033541f, 0.18289803f, 0.01117444f, -0.07604934f, -0.05404440f, 0.16828330f, -0.18384527f, -0.05746795f, 
    0.10552640f, -0.29404455f, -0.13924281f, -0.45351434f, -0.04502114f, 0.02782810f, 0.06465545f, 0.13523296f, 
    0.10465660f, -0.08299676f, 0.04655148f, 0.04395796f, 0.21041146f, 0.05177829f, -0.12949587f, 0.24470550f, 
    0.09408191f, -0.07525849f, 0.02348521f, -0.11047545f, -0.24634418f, 0.21484138f, 0.06087151f, -0.11709523f, 
    0.04049977f, -0.05006386f, 0.23329854f, 0.12300403f, -0.03256018f, -0.31612724f, -0.03627231f, 0.18983181f, 
    0.17756262f, 0.07006343f, -0.08335806f, -0.02800803f, 0.06341937f, 0.21766804f, 0.09960660f, -0.11062699f, 
    -0.02051511f, 0.11731678f, 0.07259930f, -0.24092932f, 0.23908246f, 0.03363279f, 0.07414052f, 0.07999749f, 
    -0.26751253f, -0.00956403f, -0.16806285f, 0.01065354f, 0.18918847f, -0.10305103f, -0.16801645f, -0.10893316f, 
    0.10693167f, -0.41218066f, -0.15392856f, -0.01758415f, -0.12084652f, 0.06586774f, -0.10586033f, -0.00928433f, 
    0.20294601f, -0.13679767f, 0.15403962f, 0.10367487f, 0.03130272f, 0.27833939f, 0.08849891f, 0.03155524f, 
    0.01900660f, 0.01893668f, 0.01110945f, 0.24226213f, -0.11656842f, -0.02601295f, -0.20137431f, -0.04996487f, 
    0.15497363f, -0.06701229f, 0.06817105f, 0.20954752f, -0.02879366f, -0.12214492f, 0.01990844f, -0.10148601f, 
    0.26161283f, 0.14883669f, 0.07908248f, 0.28864911f, 0.11913659f, 0.13484025f, 0.01828590f, -0.11232284f, 
    0.24341375f, 0.12022500f, 0.01671564f, 0.15035392f, -0.46697074f, -0.78416151f, -0.06246498f, -0.05434104f, 
    0.08620656f, 0.01203704f, -0.20689134f, -0.05297752f, -0.18755330f, -0.14690724f, -0.24926139f, -0.43116596f, 
    -0.08789352f, -0.04854344f, -0.07612202f, 0.12652023f, -0.02991122f, -0.08074405f, -0.32557702f, -0.08339626f, 
    0.37334380f, -0.00696368f, 0.07389555f, -0.23497865f, -0.07238601f, -0.03752198f, -0.04896867f, -0.01868234f, 
    -0.23955829f, -0.01533559f, 0.02473820f, 0.17053054f, 0.02046745f, -0.05624089f, -0.08265095f, -0.01688117f, 
    -0.07318145f, -0.03846854f, 0.01120266f, -0.04639316f, -0.05789267f, -0.09661387f, -0.09767376f, 0.05234468f, 
    -0.05756140f, 0.03186572f, -0.07758884f, -0.05666981f, -0.05018631f, 0.03794990f, -0.00940699f, 0.07257639f, 
    -0.04468476f, 0.07735433f, 0.01384563f, 0.02935026f, -0.04407596f, -0.10040963f, -0.07846039f, -0.01578718f, 
    -0.04303900f, -0.06375309f, 0.01284429f, -0.05234008f, -0.01410833f, -0.04762429f, 0.07702620f, -0.03402027f, 
    0.07651419f, -0.09006250f, 0.05823705f, -0.02312975f, -0.02200700f, -0.01806335f, -0.04760341f, -0.03089795f, 
    -0.07354250f, -0.03689854f, -0.02098024f, 0.06072569f, 0.07116590f, 0.00221638f, -0.00830020f, 0.03691859f, 
    -0.09747183f, -0.00993900f, -0.07269609f, 0.04405848f, -0.01196126f, 0.01639284f, -0.06792294f, -0.00809214f, 
    0.05159318f, -0.07627843f, -0.11499150f, -0.09431309f, 0.01145385f, -0.07525006f, -0.02351384f, -0.09669603f, 
    -0.00738947f, -0.05542777f, -0.04098279f, -0.03750709f, -0.03350655f, -0.00029681f, -0.06573783f, 0.02531756f, 
    -0.04062480f, -0.07119747f, -0.06905236f, 0.00424262f, 0.01409383f, -0.03887784f, 0.03676658f, -0.03232504f, 
    -0.10596643f, 0.02387617f, 0.06157939f, 0.03016873f, -0.06023394f, 0.04991791f, -0.09844472f, -0.07822321f, 
    0.04219725f, -0.02614269f, -0.02260536f, -0.07892355f, -0.06007868f, -0.09230787f, -0.04752503f, -0.09309573f, 
    -0.02241450f, -0.04478388f, 0.00464454f, -0.03013858f, -0.02729254f, -0.08536173f, 0.03337036f, 0.07904787f, 
    0.02067673f, -0.05925827f, 0.05848419f, -0.02581413f, -0.02515986f, 0.02607965f, -0.05453561f, 0.00413601f, 
    -0.01134563f, 0.01657542f, 0.09337234f, -0.06153454f, -0.10990664f, 0.05179697f, 0.09081189f, -0.06141761f, 
    -0.00528760f, -0.02403930f, -0.08891557f, -0.07783482f, -0.08692816f, -0.08203093f, -0.08220028f, 0.04695832f, 
    -0.05479633f, -0.02993244f, -0.08751462f, -0.05466118f, 0.04002772f, -0.00713702f, -0.07229989f, -0.01037976f, 
    0.01504886f, -0.04676545f, -0.07166576f, -0.09579177f, -0.05748541f, -0.03226508f, -0.06647030f, -0.00749638f, 
    0.07100870f, 0.01135342f, 0.08409702f, -0.04629731f, 0.16169906f, 0.15310806f, -0.00447097f, 0.03438858f, 
    0.14191408f, -0.32123461f, 0.06641276f, 0.20787516f, 0.04916783f, -0.12993303f, 0.12241926f, -0.08334588f, 
    -0.00313517f, 0.07389131f, 0.02629247f, 0.36680877f, -0.08146804f, -0.16440743f, 0.12042481f, 0.00419666f, 
    -0.06615507f, 0.00588629f, 0.16435592f, -0.07900374f, 0.11295310f, -0.14056750f, 0.02740409f, -0.01986677f, 
    -0.02970894f, 0.04575148f, -0.25521260f, 0.05103055f, -0.53689653f, -0.45335329f, -0.12859601f, 0.21670099f, 
    0.14197657f, -0.00304297f, -0.06535558f, -0.01534626f, -0.05479901f, -0.03232273f, -0.15067360f, -0.19922650f, 
    -0.05759046f, -0.00881603f, 0.08553121f, 0.02548976f, 0.04376331f, 0.02903157f, -0.09607867f, -0.14320023f, 
    0.11004388f, 0.09684893f, -0.00768586f, -0.03959668f, 0.04462699f, -0.02285493f, 0.00457094f, 0.16416310f, 
    -0.40589815f, -0.03262804f, -0.11587712f, -0.17900604f, -0.02262346f, 0.00193533f, 0.06124897f, -0.03952116f, 
    -0.23859216f, -0.23625366f, -0.05929329f, 0.05029522f, -0.01874835f, 0.07668473f, -0.03992661f, 0.03932771f, 
    0.01272866f, 0.14106220f, 0.10690478f, -0.09562898f, 0.04106472f, 0.08206072f, -0.19911353f, 0.12358601f, 
    0.14613047f, -0.05252957f, -0.14872524f, -0.10227092f, 0.12103701f, 0.06914692f, -0.17876528f, 0.06474023f, 
    0.07752746f, 0.03622526f, -0.00624699f, -0.08978199f, 0.09460904f, -0.14355293f, -0.00256583f, 0.18226746f, 
    0.15509430f, -0.00901404f, 0.18203898f, -0.05810390f, 0.09734167f, 0.20816015f, 0.01594708f, 0.09001860f, 
    0.04749781f, -0.27226859f, 0.04077408f, -0.01208241f, -0.03958786f, -0.13855770f, -0.28588620f, -0.48053160f, 
    0.13625342f, 0.06817547f, -0.21767929f, 0.09216931f, 0.08996769f, 0.24989101f, 0.50804013f, 0.33264089f, 
    0.05637366f, 0.04882877f, 0.15157701f, 0.12317037f, -0.09792748f, -0.10191931f, 0.15035677f, -0.42001846f, 
    0.21231771f, -0.20342797f, 0.20237993f, 0.03986424f, -0.00243974f, -0.17092323f, -0.09250034f, 0.10848838f, 
    -0.14495248f, 0.14175980f, 0.33280426f, -0.04121772f, -0.00939802f, -0.08654875f, 0.11821413f, 0.22602820f, 
    0.16379452f, -0.25584221f, 0.05072694f, -0.18759635f, 0.20226803f, 0.21095842f, 0.09099145f, -0.13695729f, 
    -0.13776955f, -0.22644500f, 0.43231702f, 0.15694937f, 0.17124926f, -0.22285070f, -0.21810018f, 0.05104991f, 
    -0.05264110f, 0.10127047f, -0.12847596f, -0.11360843f, -0.11769076f, -0.35074955f, 0.04907244f, -0.12573771f, 
    0.00167500f, 0.04715292f, 0.01200328f, 0.08754072f, -0.21641071f, -0.12815610f, 0.07825261f, 0.02515867f, 
    0.07321982f, 0.04140733f, -0.05918361f, -0.03443832f, 0.04784871f, 0.14418884f, 0.24742691f, 0.18238153f, 
    -0.09949089f, -0.12261906f, 0.04030853f, -0.05955209f, 0.11888418f, 0.05886858f, -0.18620440f, 0.23807108f, 
    0.24377042f, 0.24269897f, -0.10077472f, 0.25534284f, 0.22824250f, -0.12242407f, 0.04864095f, 0.15963519f, 
    -0.30315506f, -0.38116798f, 0.22534278f, 0.12908891f, 0.08733892f, 0.02220777f, -0.12605113f, -0.20168482f, 
    -0.27765295f, -0.04864497f, -0.16253735f, -0.07548130f, 0.07674865f, 0.26336294f, 0.04940972f, -0.08805197f, 
    -0.10035402f, -0.10153257f, -0.11511726f, 0.02347988f, 0.02935232f, -0.15571050f, -0.20808944f, 0.12452611f, 
    -0.01412254f, 0.06437528f, 0.37510517f, -0.18450980f, 0.12211901f, -0.01525901f, -0.00298048f, 0.07641467f, 
    0.04704647f, -0.05190706f, -0.01867954f, 0.09285975f, 0.06333599f, 0.06219150f, 0.12597373f, 0.10609271f, 
    0.25189534f, -0.09681555f, 0.20811290f, 0.23162733f, -0.04323067f, -0.15846457f, -0.29867217f, -0.13811606f, 
    0.07781044f, 0.05436050f, -0.14738628f, -0.04234014f, 0.04466913f, -0.03887815f, -0.26119801f, 0.06625581f, 
    0.01843703f, 0.00379994f, -0.34084496f, 0.02716284f, 0.07786853f, -0.06223871f, 0.31554326f, -0.24455009f, 
    0.05893707f, -0.03439331f, 0.07205474f, 0.14213116f, 0.06297155f, 0.12738197f, 0.01879412f, -0.10218614f, 
    -0.00588931f, 0.27631488f, -0.04605568f, -0.06923053f, -0.30744663f, -0.00963616f, 0.01344395f, -0.06756910f, 
    0.08338247f, -0.14760080f, -0.09188622f, -0.09992470f, 0.16643620f, 0.15546136f, 0.08221103f, -0.02757188f, 
    0.15284714f, -0.07469157f, -0.12453678f, 0.00477679f, 0.08315923f, -0.18793428f, -0.13274692f, -0.25029027f, 
    -0.04845078f, 0.00932997f, -0.05309741f, -0.16580427f, 0.04898245f, 0.03978086f, -0.06107752f, 0.11296693f, 
    0.07402758f, 0.02097200f, 0.06452591f, 0.00011769f, -0.29368681f, 0.24277794f, -0.01115651f, -0.11610415f, 
    0.10939309f, 0.00146751f, 0.06939615f, -0.07950906f, 0.37441921f, 0.10249771f, 0.00180980f, -0.07335567f, 
    -0.06392625f, 0.01570849f, -0.06345885f, -0.04785065f, -0.00292100f, 0.04726938f, 0.06469367f, 0.04818638f, 
    0.09474580f, 0.00721742f, -0.12995687f, 0.09791368f, -0.05762692f, -0.05721758f, -0.31223392f, -0.25160867f, 
    0.01020295f, 0.18595935f, -0.08418933f, 0.07520961f, -0.10213861f, 0.18551117f, -0.08207040f, -0.20535623f, 
    -0.04594104f, 0.07018898f, 0.04607971f, -0.02545445f, -0.09100080f, 0.09644918f, 0.07798772f, 0.07386949f, 
    -0.12284592f, 0.07325902f, 0.11086956f, 0.09068451f, -0.06551588f, -0.20504335f, 0.02073375f, -0.06809583f, 
    0.04193640f, -0.29186895f, -0.34727073f, -0.21970044f, -0.08014544f, 0.07858093f, 0.17245720f, 0.10317015f, 
    0.07560594f, -0.01714768f, -0.23700857f, 0.30168438f, 0.08121020f, 0.18761057f, 0.00448208f, 0.32800612f, 
    0.04570157f, -0.07175081f, -0.13455901f, 0.15982307f, -0.04885187f, 0.10994641f, 0.11915663f, 0.12290679f, 
    0.00266301f, 0.02258074f, 0.17404643f, -0.12973787f, 0.08776457f, -0.23204216f, 0.22776306f, -0.31655633f, 
    0.01881754f, -0.02394698f, 0.18809232f, -0.00596744f, 0.11340338f, -0.00800248f, 0.04190576f, 0.03631283f, 
    -0.40019494f, -0.18421757f, -0.00127583f, -0.01126491f, 0.07924151f, 0.20047313f, 0.03196942f, 0.06554935f, 
    -0.32999158f, 0.16258836f, 0.13629234f, 0.12083245f, -0.02532470f, 0.02306226f, -0.11371103f, -0.10578687f, 
    -0.02190233f, 0.19369271f, 0.00512602f, -0.01905633f, -0.10058211f, -0.05521118f, -0.07829918f, -0.03626541f, 
    -0.19344470f, -0.12490458f, -0.03496869f, -0.13170156f, 0.13252190f, 0.08198008f, 0.02309470f, -0.14789857f, 
    -0.31631437f, 0.10330475f, -0.13721006f, -0.00720214f, -0.15950990f, 0.11017911f, 0.13640885f, -0.17764297f, 
    0.05742924f, 0.02128563f, -0.06474186f, 0.10829021f, 0.18342519f, 0.22326908f, 0.03523788f, -0.12308142f, 
    -0.16091909f, -0.00320383f, -0.07287294f, 0.33092582f, 0.30901214f, 0.06210021f, -0.12057532f, -0.19467483f, 
    0.20342764f, -0.10221599f, -0.00834575f, -0.19588949f, 0.51337743f, 0.26214099f, 0.02535710f, -0.20264031f, 
    0.03990326f, 0.18738100f, -0.00974054f, 0.23220186f, -0.00287631f, 0.01940339f, 0.13584645f, -0.09794605f, 
    0.15286791f, -0.30258036f, -0.08363424f, 0.00150515f, 0.02456205f, 0.04009717f, 0.16410375f, -0.22425036f, 
    0.27751821f, -0.00626414f, -0.03843821f, 0.21604252f, -0.33236021f, -0.09499696f, -0.11926952f, -0.06851067f, 
    -0.30655271f, 0.25663483f, -0.26650938f, -0.03914127f, 0.04197014f, -0.02395104f, -0.15977795f, -0.12433656f, 
    0.14736336f, 0.20851004f, 0.12602445f, -0.14660038f, -0.20117478f, -0.13678047f, 0.07686833f, 0.20561574f, 
    -0.00518081f, -0.06829014f, 0.11451894f, -0.14116132f, 0.34296656f, 0.26561281f, 0.04196114f, 0.03868005f, 
    -0.02598453f, 0.03383797f, 0.25337183f, 0.09243857f, -0.22554722f, 0.07964601f, 0.15237722f, 0.23374839f, 
    0.01591709f, -0.08236116f, -0.23262927f, 0.14868516f, 0.06213361f, -0.08595879f, 0.27813828f, 0.11860465f, 
    0.00076504f, 0.12346566f, 0.02949981f, 0.07622043f, 0.10782313f, 0.13554862f, 0.20455582f, 0.05877796f, 
    -0.19482735f, -0.00445934f, 0.02372243f, 0.10487585f, 0.02690371f, 0.05324760f, -0.13736977f, 0.04485515f, 
    0.00677645f, 0.01880338f, 0.01150735f, -0.14716741f, 0.18717855f, 0.02653294f, -0.00723527f, -0.08999244f, 
    0.05965095f, 0.01877159f, 0.17580643f, 0.05828452f, -0.10665204f, -0.22344297f, -0.10650988f, 0.26043653f, 
    -0.26766464f, 0.01042484f, 0.08677177f, -0.06822165f, 0.11518718f, -0.01263647f, -0.01052210f, 0.03169866f, 
    -0.37675971f, -0.03791252f, 0.06811463f, 0.01476492f, -0.01036597f, 0.05143076f, -0.10129751f, 0.29743740f, 
    -0.05421177f, 0.17797185f, -0.02445609f, 0.17005029f, -0.00735364f, -0.00706074f, 0.20104313f, -0.00174268f, 
    -0.02894119f, -0.08513287f, -0.01328882f, 0.29811823f, 0.01439416f, -0.07465525f, 0.08434903f, 0.03442257f, 
    0.07884347f, -0.01608325f, 0.10099143f, 0.52562636f, -0.19376945f, 0.14942473f, 0.00600408f, -0.23489982f, 
    -0.19062634f, -0.03891710f, 0.01999012f, 0.08842460f, 0.21786182f, -0.18519485f, -0.00713877f, 0.11329053f, 
    0.03720760f, 0.19811937f, -0.09982536f, 0.07269525f, 0.08428888f, -0.01846693f, 0.34919092f, 0.05111524f, 
    0.05677987f, -0.00899971f, -0.03522289f, -0.08016829f, 0.04265991f, -0.19632892f, -0.13234445f, -0.23876250f, 
    0.14530572f, 0.09906036f, 0.15723814f, -0.20486888f, -0.03985366f, -0.31970230f, -0.02252463f, 0.23945272f, 
    -0.34212327f, -0.15867941f, -0.08665619f, -0.14934523f, -0.06177183f, 0.14335904f, -0.10348849f, -0.01007794f, 
    0.20601147f, 0.03190265f, -0.16410893f, 0.16249788f, 0.17166150f, 0.26192111f, -0.14963715f, -0.09350637f, 
    0.04552246f, -0.69287854f, 0.52971643f, 0.23806489f, 0.05313635f, -0.00718669f, 0.19800605f, 0.05848426f, 
    0.08989345f, -0.13687506f, 0.10430805f, 0.05072207f, 0.18429987f, 0.18128645f, 0.01966237f, -0.02783073f, 
    0.11630874f, -0.18907301f, 0.10784495f, -0.27897078f, 0.25002888f, -0.02647143f, 0.04043035f, 0.05848208f, 
    0.02446047f, 0.20002888f, 0.05283954f, 0.01522079f, 0.06534220f, -0.10283408f, -0.13741283f, 0.06670772f, 
    -0.08400608f, -0.04098149f, -0.12703590f, -0.00416474f, 0.03268398f, -0.17311522f, -0.27828866f, -0.11280716f, 
    -0.12900633f, 0.11766129f, 0.08339649f, -0.14134933f, -0.06154665f, -0.06847696f, -0.33873194f, 0.13808879f, 
    0.13261096f, 0.14258955f, 0.02127266f, 0.17336684f, -0.00214772f, -0.10261010f, -0.03140277f, 0.16021179f, 
    0.03713953f, -0.10586588f, 0.13507019f, -0.03699183f, -0.35520303f, -0.01360472f, -0.03057626f, -0.02481565f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.13460290f, -0.05430023f, 0.03917648f, 0.08611152f, 0.09172280f, 0.15850091f, 0.17480718f, 0.01975928f, 
    -0.06193511f, 0.14420351f, 0.01131542f, 0.16009173f, 0.12728232f, 0.13957471f, 0.19732031f, 0.18201026f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.03818665f, 0.08251474f, 0.14305657f, -0.08678070f, 0.64457345f, 0.42486206f, 0.32157651f, -0.33899790f, 
    -0.31276339f, 0.28880346f, -0.13810284f, 0.18331839f, -0.02108787f, -0.15778111f, -0.22348759f, 0.00716127f, 
    -0.15877774f, -0.16365018f, 0.06601424f, -0.08899958f, 0.20782422f, -0.59976721f, -0.08587737f, 0.29251707f, 
    0.53478473f, -0.40140060f, -0.14754769f, 0.09143873f, 0.13373390f, -0.23254859f, 0.21321152f, -0.18436342f, 
    0.06601920f, -0.18245046f, 0.03944065f, -0.02501619f, -0.01835426f, -0.34806392f, 0.10359225f, 0.44096881f, 
    0.20100701f, 0.30663922f, 0.12507850f, 0.86224240f, 0.34172016f, -0.23358177f, -0.23432057f, -0.33568820f, 
    -0.10726637f, 0.10746273f, 0.01663124f, 0.15532939f, -0.34807190f, -0.61255091f, -0.01329888f, -0.04491749f, 
    0.00639646f, -0.23088144f, -0.10347915f, 0.34830758f, 0.55396640f, 0.06298466f, 0.32006702f, -0.18012041f, 
    0.36914620f, -0.24262986f, -0.20530632f, 0.37415761f, -0.33291778f, -0.27024132f, -0.37361267f, 0.36146900f, 
    -0.14982688f, -0.10087036f, 0.04271625f, 0.39786303f, 0.38984650f, 0.11773653f, 0.15513900f, 0.11240245f, 
    0.09325393f, 0.08493930f, 0.01218859f, -0.16500671f, 0.00943357f, 0.07829636f, 0.02267141f, -0.07476667f, 
    -0.16311733f, -0.21764760f, -0.00210232f, -0.24999914f, -0.23180042f, 0.11497036f, 0.04081395f, -0.08047526f, 
    0.33284140f, -0.18230550f, -0.22046608f, -0.12870812f, 0.24147160f, -0.25763714f, -0.21459758f, 0.21807203f, 
    -0.08483403f, -0.32069275f, 0.17850935f, 0.16912769f, 0.45605269f, -0.56827486f, -0.11459392f, 0.01176057f, 
    -0.14211392f, 0.21746808f, 0.25322250f, -0.06783707f, -0.19017433f, 0.48054641f, -0.41122141f, -0.01531857f, 
    0.23879853f, -0.85038501f, -0.05705902f, 0.23171769f, 0.13307679f, -0.17098959f, 0.28761014f, -0.11713442f, 
    -0.23364536f, 0.00805339f, -0.04365345f, 0.21273239f, -0.33156785f, -0.34681189f, 0.47501695f, -0.25067481f, 
    -0.38593560f, 0.01962945f, -0.02094797f, -0.53957105f, 0.10457174f, 0.28356311f, 0.35797504f, 0.38805863f, 
    0.48801920f, 0.17770892f, 0.02559629f, 0.16288312f, 0.30885381f, 0.15198778f, 0.07903492f, 0.51267517f, 
    0.49088836f, -0.29545712f, -0.10024527f, -0.37965840f, -0.08311252f, -0.07915232f, 0.29613337f, -0.38954169f, 
    0.18216239f, 0.00918522f, -0.13573769f, 0.30950233f, 0.17525929f, -0.07930662f, 0.48114809f, 0.66316766f, 
    0.15129468f, 0.32249287f, -0.13584314f, -0.49301302f, -0.44607148f, -0.05119056f, 0.18253350f, -0.29044390f, 
    0.01073535f, -0.16044341f, -0.30780125f, 0.15381724f, 0.40829596f, 0.14619854f, 0.38160276f, 0.19501625f, 
    0.28998923f, -0.24899423f, -0.10411565f, -0.14915796f, -0.42897290f, 0.32109201f, 0.45373648f, -0.23470898f, 
    -0.39714602f, -0.16549438f, 0.35398576f, -0.36989528f, -0.15451884f, 0.32574379f, 0.58615625f, 0.19906870f, 
    -0.49944127f, 0.00449719f, -0.21356843f, 0.29820585f, -0.14679717f, 0.26848659f, 0.20728934f, 0.01534647f, 
    -0.18544701f, 0.17362018f, -0.14931539f, 0.29807404f, 0.61862326f, -0.12176529f, -0.43484312f, -0.10091257f, 
    0.22551037f, 0.49340299f, -0.12975225f, 0.22310232f, 0.66580117f, -0.16937056f, -0.31492904f, 0.06800311f, 
    0.56383002f, -0.22053075f, 0.40070492f, -0.37650675f, -0.17747670f, 0.30506620f, 0.25345626f, -0.15448003f, 
    -0.29285184f, -0.05508647f, 0.26858357f, -0.10101865f, 0.06727240f, -0.29535708f, 0.22855091f, 0.09618602f, 
    -0.51741296f, -0.21922597f, 0.23517431f, 0.22890581f, -0.16346769f, 0.00670983f, -0.27662826f, -0.14480184f, 
    -0.33838719f, 0.18443404f, 0.20838609f, -0.48582649f, 0.10733440f, -0.12130973f, 0.31879416f, 0.26082981f, 
    0.10236210f, -0.06238481f, 0.05024341f, 0.10067365f, -0.07122868f, -0.14809823f, -0.10358285f, -0.08032127f, 
    0.17995517f, 0.04416769f, -0.14100665f, 0.40692440f, -0.07240555f, -0.19240417f, -0.05903884f, -0.21811472f, 
    -0.19123486f, 0.22316384f, -0.14967403f, 0.00688985f, -0.21448129f, -0.02267796f, 0.05439624f, 0.03449237f, 
    -0.04276481f, -0.23703593f, 0.20276147f, -0.19423801f, 0.15612173f, -0.10582370f, -0.17775452f, 0.10383072f, 
    -0.39296994f, -0.22508477f, 0.41047055f, 0.08402554f, -0.01954373f, -0.29527721f, 0.43738565f, -0.57329565f, 
    0.43054137f, -0.07343923f, -0.23825598f, -0.45272601f, 0.06916365f, -0.14764486f, 0.10591150f, 0.26342627f, 
    -0.51383722f, -0.13145389f, -0.37009346f, -0.02331530f, 0.06825596f, 0.26238608f, -0.26653722f, -0.22102988f, 
    0.37316170f, -0.18738236f, -0.02023324f, -0.03323829f, 0.48145708f, -0.01455702f, 0.38029960f, 0.63858110f, 
    0.34488890f, -0.09540544f, 0.44309038f, -0.25647381f, 0.18034464f, 0.40384507f, -0.04279074f, -0.58354139f, 
    -0.53388208f, 0.19860737f, 0.17071268f, 0.19836149f, -0.01420665f, -0.14853723f, 0.03329513f, 0.35297596f, 
    0.29321799f, 0.12159386f, 0.42358726f, -0.13272382f, 0.19113873f, 0.44815719f, -0.12515025f, 0.25568712f, 
    -0.20394892f, 0.26398724f, -0.12994716f, 0.57241333f, 0.06874088f, -0.42086485f, -0.22195786f, 0.15024596f, 
    -0.18509653f, -0.14837432f, 0.18298477f, -0.07714018f, -0.30548310f, -0.04362383f, 0.01571403f, -0.10412057f, 
    0.32334355f, -0.53924972f, 0.00314612f, 0.05127960f, -0.01781933f, 0.53801608f, 0.49096987f, 0.18819545f, 
    0.57796854f, 0.01694484f, 0.03382169f, 0.02848595f, 0.17712131f, 0.06790412f, 0.38672426f, 0.38375968f, 
    -0.02035938f, -0.12335297f, -0.04160917f, 0.17196463f, -0.02345339f, 0.43301934f, 0.01798631f, -0.38286421f, 
    0.20994341f, -0.24267593f, -0.07211544f, 0.18256724f, 0.25195065f, 0.03709811f, -0.40963423f, 0.54845071f, 
    -0.11238299f, 0.30342862f, 0.04176024f, 0.22230384f, 0.33306792f, -0.39666417f, -0.07503292f, 0.05130304f, 
    0.07999713f, 0.04193501f, -0.04120746f, 0.02633533f, 0.09587835f, -0.00120802f, 0.35401759f, -0.82591516f, 
    0.78253764f, -0.51518023f, 0.24582341f, 0.27109390f, -0.40608120f, 0.28793189f, 0.25898814f, -0.18600051f, 
    0.12029531f, -0.20373389f, -0.32645848f, -0.26226023f, -0.09700657f, 0.60283566f, -0.21623951f, 0.53903896f, 
    -0.19486028f, 0.32086813f, 0.16649307f, 0.21366028f, -0.15473032f, -0.17902267f, 0.24851455f, 0.22155544f, 
    0.10183116f, -0.21052182f, 0.29693383f, 0.35562557f, 0.18342035f, -0.04495849f, 0.20395134f, -0.38805720f, 
    -0.34368345f, 0.38253215f, 0.03187348f, -0.40128317f, -0.23491953f, -0.01566006f, -0.04926053f, -0.07248694f, 
    -0.02172449f, 0.23286417f, 0.08225965f, -0.20144978f, -0.23060265f, -0.02542210f, 0.17391497f, 0.08101159f, 
    -0.01005694f, -0.24781415f, -0.10595158f, -0.02931342f, -0.24619240f, 0.13249066f, 0.00322556f, -0.20814037f, 
    -0.25313523f, 0.13556662f, 0.40469888f, 0.04188955f, -0.26044941f, 0.11133587f, -0.25529221f, 0.34418982f, 
    -0.19967045f, -0.69141805f, 0.14496595f, 0.04159857f, 0.18887468f, 0.28739691f, 0.23300299f, 0.14316761f, 
    0.18685865f, 0.17724983f, 0.72482377f, 0.53566533f, 0.10901415f, 0.02875051f, 0.37957379f, 0.57608712f, 
    -0.53450137f, -0.11270469f, -0.01238393f, -0.13803196f, -0.09506665f, 0.14130251f, 0.46422738f, -0.22664124f, 
    -0.12861532f, 0.24044845f, 0.16415358f, -0.19685090f, -0.19835299f, -0.14528143f, 0.23452270f, 0.22219250f, 
    -0.20923644f, -0.21585074f, -0.10761884f, 0.07963899f, -0.12559077f, 0.06274480f, -0.21747664f, -0.02765137f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.19552378f, -0.19677281f, 0.30885056f, 0.10773448f, -0.07141723f, 0.18848774f, -0.09379940f, -0.13175960f, 
    0.14326805f, -0.10081486f, 0.01660575f, 0.05582478f, 0.03039990f, 0.35361955f, 0.01675616f, 0.48440504f, 
    0.00494959f, -0.07455343f, -0.15436251f, 0.51579970f, 0.22156297f, 0.23015389f, 0.13408785f, 0.12570915f, 
    0.37367120f, 0.23755683f, 0.07277076f, -0.14046897f, -0.17129937f, 0.44794232f, 0.48353341f, -0.05369151f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.02433429f, 0.10330513f, 0.73951781f, 0.38200545f, 0.13082744f, 0.14794803f, 0.74421263f, -0.02139377f, 
    -0.25549147f, 0.41119534f, 0.19157118f, 0.00464111f, -0.31210691f, 0.48714972f, -0.13123992f, -0.25028363f, 
    0.23615690f, -0.11123927f, 0.14835879f, -0.21808444f, -0.05589177f, 0.20507412f, -0.28734088f, 0.16297947f, 
    0.14861529f, -0.08936889f, -0.77102202f, 0.00301549f, 0.10454041f, -0.01086042f, 0.11662085f, 0.06519702f, 
    0.40586209f, -0.07326668f, 0.19485892f, -0.10483728f, -0.30312297f, 0.14959846f, 0.32601893f, -0.94186085f, 
    0.50597847f, -0.48230448f, -0.09155502f, 0.16500533f, 0.39939415f, 0.23340783f, 0.17598933f, 0.16866574f, 
    0.33127084f, -0.03632774f, 0.45411277f, 0.30516130f, 0.26689836f, -0.02984232f, 0.15092979f, -0.07743915f, 
    -0.13664292f, 0.42066383f, -0.07023312f, -0.00825411f, -0.16358599f, 0.01781105f, -0.14263542f, 0.08595257f, 
    0.03716110f, -0.15322714f, 0.10263848f, 0.05465752f, 0.04300176f, 0.06361660f, 0.08323328f, -0.05253676f, 
    0.08376233f, -0.11824540f, -0.15378338f, 0.05495533f, 0.11996542f, -0.04886783f, -0.11185201f, -0.00466049f, 
    -0.07637294f, 0.01880335f, -0.08032344f, 0.04272551f, -0.10247528f, -0.17162326f, 0.02484098f, -0.18591614f, 
    -0.11530726f, -0.03979692f, 0.03280849f, -0.02009387f, 0.09911927f, -0.18498284f, -0.06044922f, 0.09513322f, 
    -0.14241010f, -0.00440352f, -0.07637183f, -0.13801138f, 0.07609656f, 0.14451754f, 0.00173840f, -0.07710148f, 
    -0.11001024f, 0.13258389f, 0.06168632f, -0.09894405f, 0.04756614f, -0.14521275f, 0.07554348f, 0.09907649f, 
    0.05720394f, -0.14686546f, -0.09197064f, -0.15252733f, -0.05509815f, 0.05919711f, 0.13493530f, -0.07118296f, 
    0.05311220f, 0.06453954f, 0.09690063f, -0.02587236f, -0.07537964f, -0.12740722f, -0.12865445f, -0.06998335f, 
    0.59557343f, -0.31753758f, -0.02716126f, -0.62447047f, -0.15144531f, 0.08428207f, -0.17405786f, 0.55972415f, 
    -0.29469475f, -0.33520809f, 0.00514589f, -0.05725656f, 0.58343798f, 0.09175573f, 0.20739226f, 0.09345308f, 
    -0.22133967f, -0.03663094f, -0.39480475f, -0.16002198f, 0.40991849f, 0.35768935f, -0.40082952f, -0.08180963f, 
    0.11892112f, -0.09104221f, 0.80737275f, 0.18739222f, -0.10981049f, -0.11701147f, 0.06694970f, 0.01943395f, 
    -0.35878778f, -0.19660099f, 0.46462610f, 0.79399747f, 0.78800911f, 0.18774651f, -0.35179189f, 0.50030142f, 
    0.17910144f, -0.09067959f, -0.21376599f, 0.05676334f, -0.73339361f, 0.13800770f, -0.38976175f, 0.24243952f, 
    0.10218392f, -0.02239395f, -0.22403303f, 0.41394678f, -0.18556255f, -0.03155589f, 0.30237910f, 0.06173362f, 
    0.43980849f, 0.04865685f, 0.01911141f, -0.20648687f, 0.13195385f, 0.32001188f, -0.00711214f, -0.01865721f, 
    0.14400132f, -0.31265366f, -0.32178235f, -0.07663680f, 0.11171255f, 0.05288163f, -0.43687382f, -0.26645213f, 
    0.34502071f, -0.08595895f, -0.36502597f, 0.23067497f, 0.22062410f, 0.11302383f, -0.14871278f, 0.40989989f, 
    0.31806305f, -0.09857734f, 0.16991811f, 0.80386621f, -0.09863509f, 0.01875139f, 0.37329096f, -0.40917456f, 
    -0.13288122f, 0.40982252f, 0.39520246f, -0.14915091f, -0.05261646f, 0.16456796f, 0.07478362f, -0.16329204f, 
    -0.07368518f, 0.03942116f, -0.90030092f, -0.12126059f, -0.10824788f, -0.01906809f, -0.86129820f, 0.14173584f, 
    0.29340044f, 0.21789683f, 0.08021148f, 0.18248622f, 0.69205195f, -0.36578974f, 0.24486452f, 0.12421420f, 
    -0.14516537f, -0.04300439f, -0.04932879f, 0.02610474f, 0.21834263f, -0.12890941f, 0.58934432f, 0.29533234f, 
    -0.37213597f, 0.71853220f, 0.45365903f, 0.04718411f, 0.14103062f, 0.07793818f, 0.09186771f, -0.09974395f, 
    0.06426195f, 0.12654883f, 0.29154450f, -0.13098846f, 0.11541623f, 0.10004324f, 0.30690181f, 0.53157240f, 
    -0.16413984f, 0.21155514f, -0.10208659f, 0.14901309f, 0.21007311f, -0.02939353f, 0.09825417f, -0.51739323f, 
    -0.03859740f, -0.16028100f, -0.44067058f, 0.20510063f, -0.02345389f, 0.24101940f, 0.19883375f, 0.25118276f, 
    0.13220780f, 0.78951252f, 1.01596415f, -0.47573504f, -0.15045606f, 0.03864784f, 0.02303303f, -0.00073258f, 
    0.06189714f, -0.19309475f, -0.22680728f, 0.11227033f, -0.04890235f, 0.03172893f, -0.28144985f, -0.76034665f, 
    0.63785517f, -0.03342552f, 0.44161975f, 0.32437879f, -0.47432607f, 0.08969812f, 0.08078004f, 0.21368000f, 
    -0.29062366f, 0.14700995f, 0.22922902f, -0.11219914f, 0.14965288f, -0.14821805f, -0.08019895f, 0.00113429f, 
    0.07515226f, 0.18095200f, -0.20117548f, 0.75385392f, -0.07244365f, -0.32079965f, 0.35710350f, -0.03937405f, 
    0.46337318f, -0.12922660f, -0.34445882f, -0.45333958f, -0.03973532f, 0.04646133f, 0.00168447f, 0.38286144f, 
    0.04321825f, -0.16473234f, -0.07390524f, -0.38232589f, -0.21434839f, 0.29275131f, 0.41758877f, 0.32216880f, 
    -0.21650910f, -0.06019133f, -0.06893428f, 0.10738973f, 0.28946754f, 0.38020927f, -0.22292282f, 0.10837956f, 
    0.36098823f, -0.63079470f, 0.46581957f, 0.24995002f, -0.14396727f, 0.14243589f, 0.28173232f, 0.12104132f, 
    0.17022389f, 0.06816155f, 0.34878090f, 0.27816194f, 0.26379499f, 0.03061915f, 0.41097680f, -0.34644413f, 
    0.06741676f, 0.20207098f, 0.32662818f, -0.23947150f, -0.50354654f, 0.36190572f, 0.07138012f, 0.00180056f, 
    -0.01703661f, 0.06477857f, 0.15223554f, -0.49981558f, 0.15892231f, 0.10889869f, -0.34421790f, 0.06016372f, 
    0.09964796f, -0.27909759f, -0.63478261f, 0.62777066f, 0.11089990f, -0.06158884f, 0.17287382f, -0.08001128f, 
    0.41260019f, 0.00313232f, 0.52009135f, -0.08052664f, -0.04289653f, -0.06697275f, 0.35988879f, -0.80786175f, 
    -0.07085993f, -0.17669678f, 0.00003721f, 0.01994751f, 0.66351426f, 0.16228415f, 0.09138408f, -0.23748322f, 
    0.09255772f, -0.03563166f, -0.16477054f, -0.38883853f, 0.12461903f, 0.28828511f, -0.24277259f, 0.31333432f, 
    -0.02278368f, -0.10695864f, 0.14242885f, -0.11664059f, 0.16631472f, 0.17219321f, 0.21148996f, 0.10203126f, 
    -0.02201453f, 0.19536017f, -0.81515843f, -0.33327758f, -0.22634858f, 0.17587423f, -0.55173165f, 0.26331076f, 
    0.18842559f, 0.43544024f, 0.48083240f, 0.78033066f, 0.32384130f, -0.36592317f, 0.08395297f, 0.04578274f, 
    -0.14788215f, -0.09739028f, 0.07855173f, 0.00129097f, -0.00485005f, -0.42095861f, 0.36736858f, 0.21181120f, 
    -0.38170573f, 0.68188214f, 0.34071696f, 0.36372608f, -0.04155428f, -0.11386465f, 0.18180776f, 0.16876327f, 
    -0.35038689f, -0.04934563f, 0.09581755f, 0.89350027f, 0.17011927f, 0.18752614f, -0.39535624f, -0.10180549f, 
    0.58629018f, -0.25619075f, -0.28853640f, -0.21851154f, -0.10356901f, 0.21579088f, 0.04113809f, 0.59032863f, 
    -0.01179761f, -0.10031837f, 0.26574618f, 0.37524751f, -0.03357705f, -0.35027894f, 0.50231862f, -0.09817315f, 
    0.01642729f, -0.03996671f, -1.20282900f, -0.03685597f, 0.13251148f, 0.31481659f, 0.15309927f, 0.15056325f, 
    0.12469507f, 0.51707512f, 0.55313677f, 0.00113195f, -0.31878212f, -0.07282910f, 0.60240006f, 0.43888694f, 
    -0.01884983f, 0.03522563f, -0.00850270f, -0.01869179f, 0.36278576f, 0.06235157f, 0.20340994f, -0.05754903f, 
    0.02458886f, 0.07878449f, 0.24448445f, -0.52183193f, 0.07182624f, 0.25572091f, -0.14589052f, 0.14944130f, 
    -0.03007940f, 0.23002936f, -0.79614359f, 0.15876286f, 0.12844922f, -0.23316729f, 0.20802984f, -0.05877395f, 
    -0.13168651f, -0.19730935f, 0.51220131f, 0.38723999f, 0.53767616f, -0.04392352f, 0.03721038f, -0.31063047f, 
    -0.15689173f, 0.32712337f, 0.38850409f, 0.37846640f, -0.84783840f, 0.53439993f, -0.35642588f, -0.19219880f, 
    -0.06864917f, -0.11677355f, -0.46953294f, 0.24829903f, -0.08351048f, -0.15857990f, -0.14158008f, 0.19520645f, 
    0.64895129f, -0.14277492f, 0.15923834f, -0.18550539f, 0.07673506f, -0.29507869f, 0.16813141f, 0.10813025f, 
    0.16011839f, 0.60239786f, 0.09534670f, 0.16728455f, -0.19209242f, 0.02716934f, 0.25000331f, 0.19077328f, 
    0.01330014f, 0.22161421f, -0.08055630f, 0.15570667f, 0.36408207f, -0.19998866f, 0.43579504f, -0.55084246f, 
    0.03580097f, -0.12463786f, 0.53423983f, -0.24522816f, 0.01367811f, -0.18680210f, 0.56177437f, 0.46844158f, 
    -0.38251588f, 0.71164912f, -0.75989491f, 0.04546941f, 0.08852642f, -0.03425330f, 0.21699490f, 0.01960855f, 
    0.22369850f, -0.00546217f, 0.30557683f, 0.34346449f, -0.09034200f, -0.00467566f, 0.10650295f, 0.52396649f, 
    -0.21684404f, -0.15378764f, -0.77831841f, -0.11933186f, 0.00402867f, 0.22981778f, 0.05123408f, -0.47248617f, 
    0.22632578f, 0.12713121f, 0.09996805f, 0.42647773f, 0.36788988f, 0.16024977f, 0.37861264f, -0.14497790f, 
    -0.00103151f, 0.81620574f, 0.17413037f, -0.25562710f, 0.14341070f, 0.08336852f, 0.08348260f, -0.12972467f, 
    -0.22549383f, -0.05461430f, -0.70719081f, -0.09480222f, 0.01319288f, -0.00023690f, -0.30092126f, 0.45000052f, 
    0.56367254f, -0.13038090f, -0.07908969f, -0.28650978f, 0.23893647f, -0.15152176f, 0.17666923f, 0.84550571f, 
    -0.06549484f, -0.14900015f, 0.21189626f, 0.33181673f, 0.28109953f, 0.06227266f, 0.43784973f, -0.09996941f, 
    0.01503889f, -0.40162110f, -0.41405773f, 0.13955717f, 0.09397440f, 0.54631037f, 0.23775281f, -0.10722326f, 
    -0.27474591f, 0.14630389f, -0.26046064f, 0.34259573f, 0.02593759f, -0.03054730f, -0.38811114f, -0.20787434f, 
    0.30694479f, 0.32247242f, 0.40070322f, 0.36534858f, 0.01560449f, 0.04626354f, -0.38894802f, 0.24628741f, 
    -0.17043321f, 0.00564178f, 0.47358167f, 0.51589841f, -0.17102936f, -0.35192356f, 0.22651462f, -0.19137360f, 
    -0.22746225f, 0.34749264f, -0.41063669f, 0.07517405f, 0.00838195f, 0.27107897f, 0.21111421f, -0.07112666f, 
    0.16718827f, 0.33751333f, 0.66739440f, -0.13170105f, -0.20667332f, -0.05374499f, 0.24484146f, -0.52035290f, 
    -0.06708782f, 0.41582808f, 0.35727963f, 0.68946344f, 0.60056180f, -0.08768206f, -0.48411438f, -0.22423932f, 
    -0.07934479f, -0.03752203f, -0.32309625f, 0.02692671f, -0.33111987f, -0.16746122f, 0.02924339f, 0.38740018f, 
    0.19224107f, 0.04082526f, 0.52726161f, 0.09456906f, 0.05810181f, -0.05531548f, 0.14570275f, 0.00494616f, 
    -0.21730267f, 0.07408807f, -0.10287911f, 0.03234578f, 0.05740191f, 0.02355267f, -0.10050842f, -0.17264041f, 
    -0.16721866f, -0.16663766f, 0.05591819f, -0.00027225f, 0.10220384f, -0.04602052f, 0.10149804f, 0.00761016f, 
    -0.04174314f, -0.02008398f, 0.01066434f, 0.01021615f, -0.07857130f, 0.06254979f, -0.11235111f, 0.04649419f, 
    0.04982019f, -0.11722389f, -0.07815047f, 0.01250431f, -0.11140556f, -0.00505390f, -0.06962916f, -0.06089569f, 
    0.59098643f, -0.56227738f, -0.10139833f, -0.33906165f, -0.13472617f, 0.11401386f, -0.09763262f, 0.28169695f, 
    -0.19729856f, 0.14686902f, -0.11044225f, 0.05701832f, -0.73586136f, 0.72052681f, -0.14432144f, 0.36093414f, 
    -0.07624380f, 0.08366518f, -0.01413823f, 0.52614099f, 0.18818833f, 0.25547215f, -0.42322904f, -0.01439585f, 
    0.46876088f, -0.06548087f, 0.62324464f, 0.09931080f, -0.09482472f, -0.33685452f, -0.01025220f, 0.16486758f, 
    -0.13336027f, -0.34657216f, -0.48094645f, 0.07191546f, 0.28583577f, -0.04872942f, 0.18140669f, 1.06149101f, 
    -0.11235964f, 0.26244581f, -0.43943438f, -0.31665948f, -0.48113438f, -0.14855753f, 0.56174839f, 0.09108714f, 
    0.03862814f, -0.01942268f, -0.10880407f, -0.28957146f, 0.41072947f, 0.24922504f, 0.19665676f, 0.06719717f, 
    0.20482552f, 0.12212625f, -0.10374714f, 0.09139801f, -0.04386899f, 0.50940436f, 0.17422257f, -0.15746033f, 
    0.11923106f, 0.08186313f, 0.09062698f, -0.15802002f, 0.08333890f, 0.02852782f, -0.10226735f, 0.06088902f, 
    -0.01680204f, -0.09363912f, -0.04239593f, -0.06859500f, 0.10847010f, -0.02884786f, 0.13607350f, -0.02832634f, 
    0.06893579f, 0.16573443f, -0.14123988f, -0.11432602f, 0.05064167f, -0.18063201f, -0.20627914f, -0.04398959f, 
    -0.17501053f, 0.14486584f, -0.13468120f, 0.12668240f, -0.08674353f, 0.10617642f, -0.11473430f, -0.01436053f, 
    0.06295437f, -0.20742212f, -0.41515353f, 0.03945491f, 0.00284889f, 0.04486311f, -0.38907966f, 0.67703938f, 
    0.28742281f, -0.13759832f, -0.01300051f, -0.37644544f, 0.36802006f, 0.11080179f, 0.08786176f, 0.75917274f, 
    -0.31704229f, 0.13543271f, 0.31364620f, 0.38627225f, -0.15509714f, 0.18697321f, 0.12333445f, -0.31445900f, 
    0.23660974f, -0.58103663f, -0.42222559f, 0.08255635f, -0.07136652f, 0.66097838f, 0.25915587f, 0.00376135f, 
    0.12119133f, -0.01215382f, -0.02954642f, -0.11309122f, -0.19587201f, -0.04129325f, 0.10889679f, -0.04338038f, 
    0.02604082f, 0.10964288f, -0.15161508f, -0.15758978f, -0.17638952f, -0.02985032f, -0.08214781f, 0.01457158f, 
    0.03842067f, 0.02050394f, 0.03953391f, 0.09645459f, -0.19366324f, 0.05271840f, -0.08695082f, 0.01434130f, 
    -0.15675686f, -0.07184124f, 0.11178686f, -0.21522997f, -0.02562939f, -0.11739254f, 0.04299841f, -0.06979851f, 
    -0.30800191f, 0.48963663f, 0.43135932f, 0.28230113f, 0.24408448f, -0.12717037f, 0.43842173f, 0.31725872f, 
    -0.15953845f, 0.32122612f, 0.25995746f, 0.19581424f, 0.09769522f, -0.17385724f, -0.02614175f, -0.30317181f, 
    -0.17735954f, 0.14213555f, -0.07262678f, -0.58561558f, -0.33079070f, 0.03185527f, 0.24026667f, 0.22356060f, 
    0.08971861f, 0.06851459f, -0.52089471f, 0.01139623f, 0.06468106f, 0.26994708f, 0.27653500f, 0.06521335f, 
    0.20346555f, -0.03253337f, -0.05012094f, -0.51422697f, -0.06220990f, 0.06775565f, 0.23711737f, -0.08994164f, 
    -0.07775895f, 0.17222364f, 0.18404759f, 0.03180523f, 0.87001872f, -0.38245434f, 0.41973251f, -0.21789186f, 
    -0.23879007f, 0.03346321f, -0.02641933f, -0.42959881f, 0.27745721f, 0.43701988f, -0.00608709f, 0.31498569f, 
    -0.08333646f, 0.19131438f, 0.76729923f, 0.25189054f, -0.01331113f, 0.08295235f, 0.17902584f, -0.04464394f, 
    0.22324394f, 0.42428452f, -0.25512314f, -0.31268799f, -0.39991412f, 0.06597222f, 0.97807300f, 0.30433828f, 
    0.07380009f, 0.43515295f, 0.41708854f, 0.19575667f, 0.15490928f, -0.15127993f, 0.32855457f, -0.17257917f, 
    -0.01233295f, 0.14487362f, 0.42118245f, 0.10452177f, -0.09066870f, -0.09024704f, -0.03775615f, -0.02111690f, 
    -0.00866226f, 0.28520733f, -0.17912073f, 0.09190278f, 0.07711952f, -0.48690015f, -0.01298298f, 0.10253318f, 
    0.06384291f, -0.15816988f, -0.04944263f, 0.11964387f, 0.00203805f, 0.02273592f, 0.08247316f, 0.02758537f, 
    -0.06117406f, -0.04667216f, 0.08337720f, -0.07883415f, -0.12320087f, -0.21143340f, 0.07168312f, -0.08716002f, 
    0.14456934f, -0.16307585f, 0.00529133f, 0.10470868f, -0.19770007f, 0.07101375f, -0.11396024f, 0.03664527f, 
    0.06044699f, -0.13461407f, -0.11372656f, 0.20785691f, 0.02771737f, 0.02642381f, -0.18585177f, 0.16993099f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.19799948f, 0.03361395f, 0.04125104f, 0.10888613f, 0.33095205f, 0.24225467f, 0.42598101f, 0.15221272f, 
    0.05394061f, -0.05673109f, 0.12867655f, 0.24543968f, 0.40458977f, 0.06429978f, 0.26412880f, 0.04072198f, 
    0.09604602f, -0.02997762f, 0.21185018f, 0.26643789f, 0.32010531f, 0.32056591f, -0.20984957f, 0.23446070f, 
    -0.14423169f, 0.09001775f, 0.28908822f, -0.10487363f, 0.10408309f, 0.08946524f, -0.64378846f, -0.11332510f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.17216340f, -0.27302793f, -0.01583432f, -0.10012245f, -0.29910108f, 0.22138536f, 0.02849367f, -0.19459291f, 
    0.03841767f, -0.13323365f, -0.10426479f, -0.01387841f, 0.08099879f, 0.00259258f, -0.16645525f, -0.09950780f, 
    0.40081382f, -0.53171188f, -0.51522166f, -0.08588324f, 0.26676863f, 0.58862919f, 0.05977001f, 0.10828261f, 
    -0.34247246f, 0.16601568f, 0.13992621f, 0.00080934f, 0.26935819f, -0.18199982f, -0.85628909f, -0.05249776f, 
    -0.03251032f, 0.02925289f, 0.09487682f, -0.01434699f, 0.44282022f, 0.13182905f, -0.03590411f, -0.36539590f, 
    0.20936918f, -0.33050016f, 0.15084940f, 0.02288392f, 0.37469813f, -0.29791901f, -0.18862858f, -0.00723057f, 
    0.12887955f, -0.07763033f, 0.05930831f, -0.22627799f, -0.33999291f, 0.10742532f, -0.14045106f, 0.25680569f, 
    0.00246484f, 0.05815599f, 0.02087580f, -0.16953892f, -0.12678073f, 0.26396331f, 0.27408800f, -0.18146190f, 
    -0.57601678f, -0.43657985f, 0.02020555f, -0.11189721f, 0.26288909f, 0.11580252f, 0.11880904f, 0.40723732f, 
    0.40076208f, -0.79038960f, 0.24877781f, -0.86106569f, -0.58783251f, 0.06931522f, -0.34811127f, -0.30148119f, 
    -0.33937156f, -0.21103179f, 0.18891749f, 0.28829011f, -0.25070733f, -0.50001079f, -0.12435231f, 0.30514738f, 
    0.39586905f, 0.16397902f, 0.23740503f, 0.03378641f, -0.62173021f, 0.11543798f, -0.65087640f, -0.12199721f, 
    -0.65064669f, 0.33085617f, 0.11859336f, 0.16326170f, -0.05952475f, -0.28337330f, 0.12935103f, 0.44830447f, 
    -0.01643385f, 0.20423295f, -0.42604521f, -0.25953656f, 0.08241873f, 0.30389044f, -0.04980361f, -0.14291674f, 
    -0.58359486f, 0.24720383f, -0.23352461f, -0.02613483f, 0.27233696f, 0.27262506f, -0.03514054f, -1.14952242f, 
    -0.60569471f, 0.11751622f, -0.22576064f, -0.05206683f, 0.06030554f, 0.27601945f, -0.16082355f, 0.17548434f, 
    -0.12595868f, 0.00128629f, -0.11983221f, -0.01058624f, -0.65035772f, 0.31581366f, 0.24103847f, 0.12593256f, 
    -0.01927696f, 0.20633493f, -0.13003393f, 0.00543607f, -0.38458934f, 0.20228623f, 0.12113141f, -0.56139958f, 
    0.21445704f, -0.23275720f, 0.07335658f, 0.01939450f, 0.14067101f, -0.15841688f, 0.00064269f, 0.09660625f, 
    0.13125284f, -0.07541025f, -0.11749548f, -0.05439090f, -0.11031842f, -0.31631222f, -0.38179064f, 0.09932363f, 
    0.02164149f, -0.01390533f, 0.01927400f, 0.11443027f, 0.26608893f, 0.07947253f, -0.12621778f, -0.83808172f, 
    -0.62574428f, 0.31346047f, 0.25935951f, 0.41901618f, -0.08529417f, -0.05988325f, 0.09139396f, 0.07953493f, 
    0.10882369f, -0.73269939f, -0.35367009f, 0.17325139f, -0.05734472f, -0.18669230f, -0.09185611f, 0.32914209f, 
    -0.01822664f, -0.10082032f, 0.21866876f, -0.08424319f, -0.26804268f, -0.29892191f, 0.62363648f, -0.14272988f, 
    -0.15688609f, 0.34284455f, -0.06717782f, 0.11334796f, -0.33657342f, 0.02681933f, 0.31455591f, -0.50853169f, 
    -0.35749051f, 0.06236408f, 0.20301516f, -0.05892693f, -0.11570895f, -0.68308330f, 0.40043336f, -0.13325036f, 
    -0.33731666f, -0.28842816f, -0.01026578f, 0.40332219f, 0.10539331f, -0.77811605f, 0.12934679f, 0.07325679f, 
    0.01118274f, 0.04127831f, 0.44155604f, -0.09576324f, -0.71772218f, -0.29456031f, -1.26414537f, 0.02242925f, 
    0.09989498f, 0.04328506f, -0.07491412f, -0.02288498f, -0.20398581f, -0.24340561f, -0.17132278f, -0.29308903f, 
    -0.12429626f, 0.35809386f, -0.56363726f, 0.17735741f, -0.38567123f, 0.24423255f, -1.11289895f, 0.14970921f, 
    0.14487238f, 0.25513422f, -0.56581050f, -1.12438786f, 0.22546791f, 0.28784835f, -0.01820533f, 0.27353612f, 
    -0.48308411f, 0.05772472f, -0.74040425f, -0.06922722f, 0.11861695f, 0.03870058f, 0.55160028f, -0.15160374f, 
    0.36013764f, -0.53909868f, 0.14999823f, -0.08431459f, -0.03542821f, -0.09762775f, -1.05002964f, -0.36102268f, 
    0.14293218f, -0.20526917f, 0.25090936f, 0.46538642f, 0.42333755f, -0.64816868f, -0.56969839f, 0.30346733f, 
    0.13386917f, 0.25567079f, -0.06166553f, -0.47864434f, -1.00758755f, -0.09572200f, -0.02137360f, -0.21129332f, 
    0.39692128f, 0.04453114f, -0.25629947f, 0.07939654f, 0.44573519f, 0.33114752f, 0.03158192f, -0.09269121f, 
    0.18518828f, -0.03658335f, 0.00527046f, 0.12400768f, -0.49975386f, 0.43292946f, 0.06743810f, -0.38728878f, 
    0.09027351f, -0.44870961f, -0.25331065f, -0.01224407f, -0.22019732f, -0.25034672f, 0.38191724f, 0.21144050f, 
    0.10148056f, 0.15821260f, 0.58628291f, -0.16059010f, 0.12049153f, -0.19935751f, -0.14015113f, -0.04424045f, 
    -0.01513417f, 0.10292432f, 0.07787035f, -0.12729333f, 0.04566815f, -0.78252715f, -0.03684565f, 0.00357000f, 
    -0.21885557f, 0.23473158f, 0.03851483f, -0.07240446f, 0.44643196f, -1.02548003f, 0.10600444f, 0.21188328f, 
    0.00350110f, -0.07837265f, -0.04286053f, -0.03875055f, 0.19123970f, 0.17448963f, -0.51071012f, 0.24763091f, 
    -1.11171257f, 0.29789603f, 0.22977586f, 0.01702066f, -0.01157361f, 0.11249574f, 0.00976272f, 0.00020805f, 
    -0.14160612f, -0.13817823f, 0.00455230f, 0.03459613f, -0.13244566f, 0.32486430f, 0.04350178f, 0.12534197f, 
    -0.11482240f, -0.34368700f, 0.14884911f, -0.11256704f, -0.32912356f, -0.07619283f, -0.17462519f, 0.20138377f, 
    -0.29340371f, -0.03396998f, -0.04360137f, 0.13352382f, -0.15581159f, 0.18165669f, 0.22129560f, 0.14576466f, 
    -0.50666457f, 0.17447993f, -0.50036490f, 0.34491530f, 0.11591198f, -0.24113755f, -0.09255966f, -0.80756098f, 
    0.38499188f, -0.12903284f, 0.30007339f, -0.00253641f, 0.42797324f, 0.13077262f, -0.47217163f, -0.01874993f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.12586094f, 0.11740027f, -0.24229613f, -0.23123194f, -0.04709394f, 0.00517114f, 0.03789254f, -0.36670998f, 
    -0.34731966f, 0.11514180f, 0.21738833f, -0.18591541f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
