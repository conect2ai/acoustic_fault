#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.94078332f, -0.55807281f, 0.80878317f, 0.48647368f, 0.16097923f, 0.03215071f, -0.05834886f, 0.12873572f, 
    0.23575781f, -0.72074717f, 0.39408413f, 0.31125706f, 0.55276716f, 0.53453457f, 0.05503628f, -0.09871822f, 
    -0.43832359f, -0.08939516f, -0.88709956f, -0.93300986f, -0.54104584f, 0.32455274f, -0.12536834f, 0.16253801f, 
    0.21701604f, -0.01630935f, 0.21027045f, 0.31785822f, -0.34202835f, -0.35039538f, -0.77660495f, 0.30697140f, 
    0.56874776f, 0.12387750f, 0.12274757f, 0.61263984f, -0.53194588f, -0.02981969f, 0.09928888f, 0.54365492f, 
    0.54237306f, -0.46282810f, -0.07822351f, 0.42637163f, -0.33455780f, 0.29353622f, -1.11928678f, -0.28713346f, 
    -0.46255493f, -0.33021256f, 0.14632434f, -0.30390957f, 0.09508067f, -0.10770927f, 0.84647501f, 0.65270883f, 
    0.19642945f, -0.41326520f, 0.45596898f, -0.30739722f, 0.08451592f, -0.05934402f, 0.00021293f, 0.69717461f, 
    0.58225369f, 0.37655059f, 0.56419528f, -0.28991491f, 0.34531730f, 0.31702489f, 0.47293413f, -0.01371196f, 
    -0.96017116f, -0.57521975f, -0.84792721f, 0.09402940f, 0.65663791f, 0.77521592f, -0.00552356f, -0.19888641f, 
    -0.22725251f, 0.09705866f, 0.53845382f, 0.73071325f, -0.58125025f, -0.22489393f, -0.72241753f, 0.05898153f, 
    -0.24648201f, -0.19641206f, 0.76968086f, 0.05415505f, 0.24003443f, -0.46838239f, -0.77579552f, -0.57020968f, 
    0.11209200f, 0.35458526f, 0.11436735f, 0.62334025f, 0.60824919f, 0.77077156f, 0.23549265f, -0.17265658f, 
    -0.17548391f, -0.02832028f, -0.33986795f, 0.02240162f, -0.57195038f, 0.93997920f, -0.25421929f, 0.47815895f, 
    -0.14450978f, -0.19662444f, 0.14771724f, -0.23321894f, -0.27461866f, 0.40729278f, 0.21142659f, -0.67252874f, 
    -0.13840029f, -0.74055797f, 0.08736002f, -0.36343977f, -0.04829613f, 0.28541356f, -0.74167758f, 0.49761644f, 
    -0.40496552f, -0.43302637f, -0.14805074f, -0.32235020f, -0.24354437f, 0.38169044f, 0.18388523f, -0.49788547f, 
    -0.09212262f, -0.03270974f, -0.17274162f, -0.10884796f, 0.24217215f, 0.49724445f, 0.55885953f, -0.60071230f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16241841f, -0.22717361f, 0.00603236f, -0.37658560f, -0.40099910f, 0.17695059f, -0.35025311f, 0.00241629f, 
    0.27370846f, -0.08698989f, -0.10998155f, 0.21569273f, -0.28518194f, 0.00767773f, 0.22421463f, -0.09396674f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.07307027f, -0.00325285f, -0.01654855f, 0.06113937f, -0.02845202f, -0.06320712f, -0.08708138f, 0.05205112f, 
    -0.02103660f, -0.06266152f, -0.09192468f, 0.00712834f, 0.00440620f, -0.00108338f, -0.09366145f, -0.02980147f, 
    -0.01700368f, 0.01517007f, -0.05347412f, 0.05041238f, -0.00432283f, -0.04840440f, 0.01201771f, 0.07144020f, 
    -0.07531058f, -0.04224754f, 0.05862693f, -0.00125300f, -0.00904765f, -0.07972814f, -0.08318216f, -0.06136289f, 
    -0.03469266f, -0.00460253f, -0.01974994f, 0.03549853f, 0.02689712f, -0.03115431f, 0.02781373f, -0.08718855f, 
    -0.03836317f, -0.09200774f, 0.03452110f, -0.04447019f, -0.00948771f, -0.03067457f, -0.05212549f, -0.07111917f, 
    0.03268784f, -0.05480056f, 0.07064307f, -0.00173636f, -0.01021870f, -0.06939856f, -0.00974677f, -0.09371740f, 
    0.02764112f, -0.03338077f, -0.03241196f, -0.02991649f, -0.00401773f, 0.06552687f, -0.00947168f, -0.06464954f, 
    -0.03576086f, 0.00408012f, 0.05203723f, 0.04824489f, 0.01878738f, -0.00503761f, -0.02625879f, 0.03586312f, 
    -0.04914670f, 0.05645392f, 0.06476087f, 0.03940517f, 0.04557470f, 0.01250976f, -0.00342465f, 0.01661733f, 
    0.01375480f, -0.03997187f, 0.03226708f, -0.06652918f, -0.04814334f, -0.07408442f, -0.02049804f, -0.08168578f, 
    -0.09108816f, -0.06709462f, -0.08564822f, -0.05829163f, -0.06228631f, -0.06150939f, 0.00411510f, 0.06854096f, 
    -0.03346629f, -0.07112333f, 0.00793184f, -0.00697907f, -0.07679970f, 0.02387731f, 0.04537462f, -0.00625440f, 
    -0.03533095f, 0.00828055f, 0.02096410f, -0.04326924f, 0.02160203f, -0.06021494f, 0.05557692f, 0.01986351f, 
    -0.00875424f, -0.01443185f, -0.01228090f, -0.03538684f, -0.07646855f, 0.06917184f, -0.06187548f, -0.04512956f, 
    -0.08768754f, -0.01695111f, 0.01928250f, -0.03998660f, 0.05709585f, 0.01596856f, 0.04624703f, 0.07103676f, 
    -0.00647507f, 0.03471468f, 0.00969813f, 0.02608864f, -0.01131489f, -0.08353305f, -0.07360066f, -0.02889469f, 
    -0.06678321f, 0.05606732f, -0.05237917f, -0.01083305f, -0.08026985f, 0.03393477f, -0.01051365f, 0.03107915f, 
    0.02419131f, -0.20925812f, -0.05493677f, -0.13348331f, -0.03271570f, -0.01062329f, -0.02218526f, 0.13892430f, 
    0.20203052f, -0.64195096f, -0.42388037f, -0.21724586f, -0.01754228f, 0.07627685f, -0.04991608f, 0.02502168f, 
    0.06326360f, 0.11314172f, 0.08297716f, -0.08958191f, 0.08336549f, -0.10019156f, 0.06906554f, 0.00065361f, 
    -0.11253757f, -0.02601880f, -0.03513350f, 0.00182027f, -0.05477288f, -0.04473018f, -0.07741693f, 0.01078313f, 
    0.09725265f, 0.05615973f, -0.02970784f, -0.05088767f, -0.19817737f, -0.23550947f, -0.09311443f, 0.07777351f, 
    0.04300795f, -0.01337846f, 0.08394693f, -0.03802274f, -0.06851287f, 0.25112757f, -0.09626917f, -0.15450504f, 
    -0.02852944f, -0.10086296f, 0.04512064f, -0.09011247f, 0.02522909f, 0.32473314f, 0.46126354f, 0.17959473f, 
    0.09033449f, 0.05346775f, -0.14684065f, 0.07822244f, -0.04730566f, -0.18325505f, 0.10876101f, 0.36140600f, 
    0.10003606f, 0.08099810f, 0.02964338f, -0.05995559f, -0.00826338f, 0.14631703f, 0.08030571f, -0.08580800f, 
    -0.45355424f, -0.09877206f, 0.24894655f, 0.05109831f, -0.01961319f, 0.08035688f, -0.05969874f, 0.07457172f, 
    -0.03598367f, -0.09353786f, 0.23739696f, -0.22818907f, 0.09091163f, 0.10176469f, 0.01929331f, 0.08134236f, 
    0.07242866f, -0.06850675f, 0.29135731f, 0.13856368f, -0.17556977f, 0.04064780f, 0.04819261f, -0.07020408f, 
    0.20583856f, 0.00802354f, -0.13604823f, 0.35891056f, 0.23815911f, 0.08050159f, -0.00557785f, -0.24276766f, 
    0.03362359f, 0.02602308f, -0.03690566f, -0.03833241f, -0.51279271f, 0.02575504f, 0.09202053f, 0.10585774f, 
    0.00374343f, 0.04379235f, -0.09407585f, -0.01322331f, -0.04819819f, 0.01595495f, 0.05272913f, -0.07835206f, 
    0.05696002f, -0.02128362f, 0.11485537f, -0.03169721f, -0.09970781f, 0.06979074f, -0.40418372f, 0.08544185f, 
    0.05854903f, 0.06477359f, 0.06094719f, 0.03343869f, 0.02465338f, -0.07159369f, -0.10805796f, -0.21174137f, 
    0.07147790f, 0.00115315f, -0.05001008f, 0.12496116f, -0.16699339f, 0.11117996f, -0.03346915f, -0.05996170f, 
    -0.33894935f, -0.10256863f, -0.00638054f, 0.07395506f, -0.05470171f, -0.09727188f, -0.02883846f, -0.09876768f, 
    0.03518385f, 0.49772733f, 0.16307156f, 0.08517472f, 0.03718459f, 0.08214193f, -0.08804092f, 0.22521475f, 
    0.04687993f, 0.06577840f, 0.05503631f, 0.07534631f, 0.13795751f, 0.18580773f, -0.08072297f, -0.05209064f, 
    0.01979141f, 0.10787885f, -0.11259443f, -0.29518229f, -0.05061221f, -0.25444612f, 0.07939144f, 0.07553453f, 
    0.12723202f, -0.26058897f, 0.09942733f, 0.11225158f, 0.04988339f, -0.20453984f, -0.04023377f, -0.13771972f, 
    -0.08894464f, 0.00086551f, -0.02901255f, 0.10261917f, 0.02498923f, -0.20518328f, -0.11926579f, -0.06018669f, 
    -0.01926829f, -0.21607271f, -0.07253125f, -0.03149024f, -0.13698377f, -0.17674728f, 0.16192220f, 0.17408992f, 
    0.23032235f, -0.00179189f, 0.13342530f, 0.02114699f, -0.05463850f, 0.02125043f, -0.23263682f, -0.11432327f, 
    -0.06731136f, 0.12322456f, -0.04935768f, -0.12458456f, -0.03796201f, -0.09600118f, -0.05530709f, -0.03220660f, 
    -0.29997581f, 0.12756130f, -0.19160883f, 0.11400077f, 0.08722727f, 0.19450915f, -0.01791237f, -0.01603123f, 
    0.16883317f, 0.03973069f, 0.12174425f, 0.26077804f, 0.12208397f, -0.11427180f, 0.02379185f, 0.06458675f, 
    -0.03539243f, 0.05911262f, -0.19560644f, -0.29540992f, 0.33576968f, -0.15087865f, -0.01937454f, 0.11766397f, 
    0.07719536f, 0.11163837f, 0.12016977f, 0.19589826f, 0.24154165f, 0.44619766f, -0.09769976f, 0.12469077f, 
    -0.24371716f, 0.11654819f, 0.05794122f, 0.17222476f, 0.46120894f, -0.09648801f, -0.24604586f, 0.05028804f, 
    -0.22128388f, 0.22002152f, -0.01010218f, 0.22655429f, -0.00829146f, 0.04390556f, -0.36333114f, 0.03411186f, 
    -0.02038219f, 0.01168674f, 0.09953823f, 0.04262959f, -0.05770577f, -0.03935056f, -0.36733654f, 0.00976726f, 
    0.09621406f, 0.17313966f, -0.07722677f, 0.04270879f, 0.09760181f, -0.08382859f, 0.00211672f, -0.09637191f, 
    0.00318171f, -0.38212210f, 0.02826306f, -0.03972083f, 0.11566409f, -0.06425533f, 0.09505671f, -0.07047418f, 
    0.03752180f, -0.02503706f, 0.26288623f, -0.22668852f, -0.10333902f, 0.02442231f, 0.14311662f, 0.10530923f, 
    0.05385625f, 0.02898358f, 0.06902575f, 0.23503631f, -0.04945868f, 0.01148916f, -0.28607464f, 0.21929185f, 
    0.11704507f, 0.08483378f, -0.36367258f, 0.16009210f, -0.01016934f, 0.13504618f, 0.07659619f, 0.11574259f, 
    0.00668523f, -0.00326531f, -0.11463371f, -0.05138931f, -0.11070178f, 0.20080192f, -0.01289624f, -0.07215774f, 
    -0.10845526f, -0.19055381f, 0.34987435f, 0.24972244f, -0.20680438f, 0.10200993f, 0.09618153f, 0.10640645f, 
    0.21552719f, 0.04325313f, 0.10562790f, -0.15456468f, -0.09471830f, -0.26118153f, 0.08241944f, 0.05858235f, 
    0.15177482f, 0.05264213f, -0.06059909f, -0.02679038f, -0.07719789f, -0.05921587f, 0.15671346f, -0.18549322f, 
    -0.12696511f, -0.18130890f, 0.00437545f, -0.04532516f, -0.04186716f, 0.04145094f, 0.02601747f, 0.33677453f, 
    0.30052540f, 0.12696669f, -0.14679371f, -0.18128140f, -0.08603497f, -0.16552840f, 0.11098028f, 0.22034106f, 
    0.04901966f, 0.14388777f, -0.26129767f, 0.07994614f, 0.04895962f, -0.09124437f, 0.03965913f, -0.11704265f, 
    -0.28793624f, 0.03599500f, -0.00727511f, 0.28481132f, -0.02996580f, 0.05556472f, 0.10963911f, -0.05249834f, 
    0.15357409f, 0.06286847f, -0.03838003f, 0.12864223f, 0.11409324f, -0.20672673f, 0.12155724f, 0.20839852f, 
    -0.11802614f, 0.07777510f, 0.16842301f, 0.12081752f, -0.02451214f, 0.12167747f, 0.07231954f, -0.03022013f, 
    -0.21509515f, 0.03898191f, 0.01660922f, -0.02838508f, -0.29928184f, -0.25319251f, -0.16105534f, 0.00733826f, 
    0.12600371f, 0.12231645f, 0.00085699f, -0.15251419f, -0.15260178f, -0.15977657f, 0.20330878f, 0.15692249f, 
    0.08437464f, -0.09863027f, 0.10079633f, -0.02861407f, 0.00322430f, -0.01893855f, -0.19614811f, -0.33116248f, 
    -0.11422510f, 0.17935671f, 0.12413622f, 0.06868100f, -0.08221131f, -0.00561350f, -0.07770953f, -0.46576414f, 
    -0.08992915f, -0.16907954f, -0.07030160f, 0.08771945f, 0.05305593f, 0.08248161f, 0.12301196f, -0.02518285f, 
    0.10050894f, 0.02585278f, 0.04370383f, -0.06023882f, 0.06648839f, -0.03422648f, -0.06320427f, -0.10641043f, 
    0.09369939f, 0.21474323f, -0.17091423f, -0.21613695f, -0.03573107f, 0.00130771f, 0.15919273f, 0.20466866f, 
    -0.07739169f, -0.06983293f, -0.34896934f, -0.36200386f, -0.14629264f, 0.01726366f, 0.08682325f, 0.00273791f, 
    -0.12085176f, 0.10912679f, -0.09944363f, -0.19547123f, -0.41596818f, -0.13142192f, -0.03517565f, 0.01088747f, 
    -0.05836274f, 0.01220635f, -0.31806192f, 0.04802326f, -0.30291286f, -0.24905196f, -0.18726236f, 0.07798699f, 
    0.08086813f, -0.02370045f, -0.10021396f, -0.04476560f, -0.07421685f, 0.03584148f, -0.01421852f, -0.22219647f, 
    -0.00837896f, -0.06837825f, -0.19392538f, 0.11528507f, 0.13852386f, 0.16975436f, -0.34560397f, 0.17779447f, 
    0.19964054f, 0.05135753f, -0.06305368f, 0.09595071f, -0.14842714f, 0.08035525f, 0.04922387f, -0.12931550f, 
    0.18532141f, 0.29833582f, -0.03010977f, 0.08412129f, 0.04516434f, -0.00295398f, 0.07043450f, -0.16816846f, 
    0.15565293f, -0.12845932f, -0.36399367f, 0.12312992f, -0.01966404f, 0.04220092f, 0.07998179f, -0.14446682f, 
    0.04647963f, 0.16967092f, 0.10917137f, 0.25787497f, -0.09227336f, 0.19580036f, -0.06644660f, 0.14034994f, 
    0.03067195f, 0.09280714f, 0.21944265f, 0.19176576f, -0.29895306f, -0.24405850f, 0.19757542f, 0.04337977f, 
    0.08359563f, -0.01729809f, 0.11974518f, 0.11686754f, 0.21218142f, 0.34925878f, 0.27202979f, 0.16404165f, 
    0.10037876f, 0.23949279f, -0.07950454f, 0.08477844f, -0.17554316f, -0.05645148f, -0.02143858f, 0.00816600f, 
    0.07727422f, -0.04398335f, 0.01071465f, -0.21281695f, -0.00412352f, -0.16979416f, -0.06900473f, 0.19986355f, 
    -0.05893113f, 0.01717260f, -0.18634143f, -0.12195918f, 0.09399705f, 0.08750051f, 0.20561339f, -0.16863972f, 
    -0.22088526f, -0.04308112f, 0.11476301f, 0.13078280f, -0.07743406f, 0.14018528f, 0.30789495f, -0.23559226f, 
    0.07030484f, -0.23906654f, 0.03605371f, 0.05322046f, -0.20261155f, 0.15061067f, -0.07157688f, -0.13577659f, 
    0.07167047f, 0.29890719f, -0.03164231f, 0.08493512f, -0.07866552f, -0.12979804f, 0.16075231f, 0.11443545f, 
    0.14806530f, 0.17738149f, -0.13592044f, -0.02485317f, -0.06124034f, -0.14384408f, 0.03499702f, 0.02969539f, 
    0.18889910f, 0.20264716f, -0.16857547f, 0.10814075f, 0.64714497f, -0.12895538f, -0.11728079f, -0.15969685f, 
    -0.19105645f, 0.12768963f, 0.30436969f, 0.00915182f, 0.08155335f, 0.10794317f, 0.03169098f, -0.06727950f, 
    -0.04432707f, 0.02498010f, -0.11723303f, 0.22656399f, 0.07949048f, 0.00709959f, -0.25597131f, -0.05475601f, 
    -0.15437515f, 0.17720547f, 0.15715972f, -0.08110777f, -0.11320411f, 0.02247212f, 0.27244577f, -0.02690256f, 
    0.24843766f, -0.04133724f, 0.01645515f, -0.03710294f, -0.11091360f, -0.15031368f, -0.21464001f, -0.10787793f, 
    -0.51678526f, 0.14524694f, 0.00115357f, 0.08114520f, -0.04043695f, -0.02636004f, -0.05274769f, 0.04599310f, 
    0.24523717f, 0.08326568f, 0.06493735f, 0.03270781f, -0.10225647f, 0.01008784f, 0.01527875f, 0.09788607f, 
    0.08379307f, -0.05946689f, 0.31549442f, -0.08891835f, 0.02751631f, -0.14626102f, -0.10538819f, -0.04107109f, 
    0.00914001f, -0.34480235f, -0.38043401f, -0.17883180f, 0.18424705f, 0.11281329f, 0.17913318f, 0.00298803f, 
    0.01011456f, 0.14658475f, 0.23279437f, -0.03981303f, -0.36366239f, 0.05329829f, 0.03840378f, -0.01484502f, 
    0.08935477f, 0.11862402f, -0.16420802f, -0.01288808f, 0.24529620f, 0.11032952f, 0.21352157f, 0.13541242f, 
    -0.15066677f, -0.07450531f, 0.01189271f, 0.01440457f, -0.44105187f, 0.00445523f, -0.40485722f, 0.00647683f, 
    -0.10983542f, -0.07937513f, -0.02299479f, -0.05876648f, 0.13173816f, -0.13615410f, 0.06025928f, -0.08672277f, 
    0.09557113f, 0.05421425f, 0.09078157f, -0.00114885f, 0.05056562f, -0.12925866f, -0.40833572f, -0.22665685f, 
    -0.16399409f, 0.06020707f, 0.07725564f, 0.05733869f, -0.03441408f, 0.16653661f, -0.07031981f, 0.01992550f, 
    -0.13234159f, -0.32723758f, 0.03852658f, 0.01327918f, -0.12641984f, -0.05003720f, -0.00970879f, -0.02182015f, 
    -0.03064703f, 0.03653688f, -0.00328621f, -0.02451261f, -0.07125421f, -0.07160223f, -0.07864442f, -0.00286547f, 
    0.00027271f, 0.03402388f, -0.07397710f, 0.07390670f, -0.02422933f, -0.03725642f, -0.04633752f, 0.02037001f, 
    -0.03915484f, -0.08879644f, -0.04775931f, 0.01374963f, -0.04232715f, 0.03115080f, -0.07389873f, -0.00687412f, 
    0.01031462f, -0.03878745f, -0.06684536f, 0.00729323f, 0.01974802f, -0.09649620f, 0.01139871f, 0.04872886f, 
    -0.07619662f, -0.06417523f, 0.07142153f, 0.05351395f, 0.03289410f, -0.08614860f, -0.04679175f, -0.00174235f, 
    0.03565333f, -0.04824674f, 0.03773519f, 0.06500410f, 0.02208129f, -0.05056656f, 0.02181576f, 0.06670389f, 
    -0.00872024f, -0.06974110f, -0.00264198f, -0.01229724f, -0.05035980f, -0.00945798f, -0.07236021f, 0.05083417f, 
    -0.07068866f, 0.03415529f, 0.06636522f, 0.02576825f, -0.08381480f, 0.01751646f, -0.05379404f, -0.08108187f, 
    0.02822634f, -0.05085589f, 0.04269940f, 0.03886959f, 0.05542210f, -0.00215213f, 0.02824097f, -0.03474889f, 
    0.05272433f, 0.00161114f, -0.06289374f, 0.03753415f, -0.07898773f, -0.08150274f, -0.02616185f, -0.01361127f, 
    0.01583792f, 0.06040011f, -0.00694981f, -0.04239193f, 0.06119591f, -0.07063295f, 0.03121296f, -0.04047913f, 
    0.02927690f, -0.07682779f, -0.04167446f, 0.05873102f, -0.00650841f, -0.06427288f, 0.05080111f, -0.05769322f, 
    0.04340687f, -0.06549631f, 0.01614596f, -0.03293345f, 0.06225003f, 0.02942672f, 0.06713737f, -0.08401025f, 
    0.07564669f, -0.04661469f, 0.00159898f, -0.05542367f, -0.02319459f, -0.06551701f, 0.02693692f, -0.05271874f, 
    -0.04215993f, -0.06834659f, -0.06368932f, 0.02336254f, 0.03753595f, 0.01390786f, 0.04399585f, 0.03445911f, 
    -0.07930142f, -0.04992717f, 0.04452889f, 0.00818482f, 0.02518691f, 0.05946920f, 0.03820937f, -0.05636252f, 
    -0.05702895f, -0.00735143f, -0.05763493f, -0.03244603f, -0.07988231f, -0.08373436f, -0.07931160f, -0.04145605f, 
    -0.08742315f, -0.06916483f, 0.05745389f, 0.07198451f, 0.07369399f, 0.01025609f, -0.06689262f, -0.01392021f, 
    -0.50227976f, -0.12992489f, 0.03296578f, 0.10956942f, 0.14844351f, 0.14748320f, 0.13824196f, 0.11363710f, 
    -0.13592461f, -0.50138509f, 0.00928657f, -0.14069219f, 0.03281615f, 0.21884400f, 0.10492792f, -0.17317420f, 
    0.06393042f, -0.08779991f, 0.00840218f, 0.06123582f, -0.21248491f, -0.11014715f, 0.15971471f, 0.12998047f, 
    0.20465919f, 0.03238393f, 0.20309053f, -0.33028641f, -0.05647236f, 0.02965218f, 0.15328208f, -0.08689951f, 
    0.09513268f, 0.21483904f, -0.03938137f, -0.23178691f, -0.12329375f, -0.09143598f, 0.23400572f, -0.02636649f, 
    -0.14252898f, 0.09066447f, -0.05073718f, -0.12389331f, 0.04713361f, 0.12181592f, 0.13315728f, -0.17740075f, 
    -0.16771664f, -0.19310716f, -0.03420746f, 0.03598308f, 0.15382111f, 0.06034978f, 0.33863300f, 0.36218414f, 
    -0.02211237f, 0.01454263f, 0.09395944f, 0.04158954f, 0.04370408f, 0.02713272f, 0.04217476f, 0.39182556f, 
    -0.33092219f, 0.02145373f, 0.29453376f, -0.04157056f, -0.00533158f, 0.13398051f, -0.02960528f, 0.05221638f, 
    -0.21923548f, 0.06783879f, -0.01698303f, 0.03781036f, 0.05465493f, -0.00789803f, -0.09918526f, 0.02799246f, 
    -0.08868828f, 0.50889951f, 0.04077155f, -0.07501875f, 0.06171430f, 0.11190914f, -0.13925280f, 0.14772996f, 
    0.07398510f, 0.02883079f, 0.27119762f, 0.09628606f, -0.28446299f, -0.02600704f, -0.23828094f, 0.02796233f, 
    0.00864884f, 0.14716619f, -0.02329703f, 0.37871900f, 0.02803813f, 0.01667503f, 0.10231826f, -0.14670466f, 
    -0.05057361f, -0.03760852f, 0.08411891f, 0.27036974f, -0.01050687f, -0.38632661f, -0.03539060f, -0.18404354f, 
    -0.05872848f, -0.07784029f, 0.06827048f, -0.04287350f, -0.00047981f, 0.04272258f, 0.16428734f, 0.04930451f, 
    0.09109448f, -0.00485212f, -0.11644668f, 0.04608913f, 0.02089597f, 0.14355327f, -0.23249064f, 0.13461697f, 
    -0.05074185f, -0.11046857f, -0.00170638f, 0.08979612f, 0.01363197f, -0.05477130f, 0.00667036f, -0.15028262f, 
    0.09221356f, -0.30987605f, 0.12859707f, 0.05990092f, -0.01645143f, -0.10826147f, 0.08880579f, 0.15314293f, 
    -0.04601093f, -0.03519007f, 0.04548218f, -0.02639799f, 0.04128349f, -0.01351052f, 0.01873545f, -0.01944644f, 
    0.01942582f, -0.07941445f, 0.04422408f, -0.10429391f, -0.04456796f, -0.11217300f, -0.07970823f, -0.03351572f, 
    -0.06937184f, -0.04693626f, -0.01895145f, -0.07868914f, -0.01981097f, 0.05053908f, -0.08755553f, -0.08060020f, 
    -0.02869151f, -0.04267885f, -0.08815239f, 0.05329713f, -0.05037537f, -0.09995447f, -0.11262938f, -0.05819267f, 
    0.03971734f, -0.07786746f, -0.09748879f, 0.06135216f, 0.02919489f, -0.05547449f, -0.04633012f, -0.01164826f, 
    -0.00730318f, -0.08912807f, 0.00825727f, -0.07268091f, -0.04306891f, 0.02883106f, -0.05185003f, 0.06380222f, 
    -0.01523883f, -0.07495747f, -0.02251682f, 0.03292805f, -0.02760472f, -0.10522514f, 0.03255617f, 0.02843648f, 
    0.02839593f, 0.03986300f, 0.02975854f, -0.09553017f, -0.04368889f, 0.03456881f, -0.03923463f, -0.07470936f, 
    -0.06422801f, -0.05478218f, -0.09478135f, -0.09412547f, -0.01316344f, 0.05723374f, 0.05643496f, -0.09867375f, 
    -0.07426106f, 0.04417200f, -0.05016750f, -0.03762486f, 0.00565795f, 0.01086226f, -0.05710123f, -0.00275880f, 
    -0.06704915f, 0.01289734f, 0.01277196f, -0.10153726f, -0.02549124f, 0.03337746f, -0.05086116f, -0.09134120f, 
    -0.04124594f, -0.01538617f, 0.00077977f, 0.03985696f, 0.04661737f, -0.11206879f, -0.02421706f, 0.03906995f, 
    -0.01876392f, -0.06588908f, -0.04371225f, 0.04100053f, 0.01114297f, -0.05903053f, -0.06019895f, 0.03283747f, 
    -0.06674906f, 0.01125592f, 0.00895566f, -0.09855649f, -0.01051423f, 0.00187737f, 0.00693457f, -0.08625086f, 
    -0.04101239f, 0.03239318f, -0.07659952f, -0.08921348f, 0.02207362f, 0.04192057f, -0.10105589f, 0.02038971f, 
    -0.03637034f, 0.00404944f, 0.04011067f, -0.00914748f, -0.05453961f, 0.04312405f, -0.00714700f, 0.01202233f, 
    -0.07508349f, -0.05645721f, -0.04476700f, -0.01012825f, -0.00120731f, 0.00488854f, 0.02103085f, -0.04139503f, 
    -0.01343798f, -0.00808338f, -0.11802799f, -0.01483539f, 0.02463600f, -0.01800701f, 0.03481283f, -0.00500110f, 
    -0.06255475f, -0.12980662f, -0.40044948f, -0.14790998f, -0.04075053f, 0.10900339f, -0.13145593f, -0.00697020f, 
    -0.21957013f, -0.20213726f, 0.18407425f, 0.10632423f, 0.08343300f, 0.10420892f, 0.18723762f, -0.07238577f, 
    0.23832595f, 0.12770627f, -0.23263349f, 0.02075291f, 0.46366182f, 0.26076102f, 0.15239105f, 0.09707285f, 
    -0.04110818f, 0.20828103f, 0.02534245f, 0.19484399f, -0.01055281f, -0.04013690f, -0.06192020f, 0.05962698f, 
    -0.05269745f, -0.03384382f, -0.09132516f, -0.07687649f, -0.11667752f, -0.01216007f, 0.23113017f, 0.17238690f, 
    -0.01416486f, -0.07419393f, -0.08069787f, 0.04832845f, -0.04204727f, 0.37237912f, -0.05695636f, 0.19979656f, 
    -0.04338807f, -0.15183313f, 0.00322446f, -0.01116501f, -0.05470979f, -0.10301194f, -0.02829050f, 0.04424265f, 
    -0.02204595f, 0.06797342f, -0.05247618f, -0.05195656f, 0.05119161f, -0.03349825f, 0.10198264f, 0.09191618f, 
    0.31172881f, 0.15808064f, -0.01288110f, -0.00831296f, -0.08835016f, -0.11612739f, 0.10010564f, -0.17915213f, 
    0.16083620f, -0.13830926f, 0.29253674f, 0.21594064f, 0.20838511f, -0.01438288f, -0.06431039f, -0.00956341f, 
    0.22794555f, 0.01509455f, -0.12632692f, -0.08348227f, 0.02186754f, -0.10349026f, -0.00954768f, -0.12801884f, 
    0.10477170f, -0.03345598f, 0.14714138f, 0.16145509f, -0.50934917f, -0.15453544f, -0.14386897f, -0.24934553f, 
    0.07688732f, -0.03758707f, -0.02909083f, 0.02601879f, 0.11011414f, -0.19700718f, 0.04377530f, -0.00272583f, 
    0.04877634f, -0.08388518f, 0.01873001f, 0.00525094f, -0.44125956f, -0.09017017f, 0.15061072f, 0.04626345f, 
    -0.05985688f, 0.08420263f, -0.05675702f, 0.10589564f, 0.07522417f, 0.40732262f, 0.01796376f, 0.18697636f, 
    0.07178716f, -0.21587609f, -0.15733613f, -0.03083882f, 0.23814693f, 0.02658726f, -0.27564576f, -0.09023853f, 
    0.18121603f, 0.02271933f, -0.20704588f, 0.07869030f, 0.02817543f, -0.00081037f, -0.18353409f, -0.09397921f, 
    -0.13291827f, -0.18853389f, 0.08588749f, 0.10898197f, -0.02688704f, 0.06980775f, -0.09398010f, -0.11840433f, 
    -0.26402962f, -0.32956994f, 0.21213771f, -0.00587131f, 0.11734343f, 0.05501882f, 0.22672220f, 0.03939098f, 
    0.18646698f, -0.08907306f, -0.02813762f, 0.01853773f, -0.05909840f, -0.02595506f, 0.12424524f, 0.04931448f, 
    0.09942630f, -0.13906717f, 0.07287563f, 0.18715268f, -0.09491208f, -0.26420939f, -0.06061224f, -0.04060386f, 
    -0.04424019f, 0.30482820f, 0.01200134f, -0.18258236f, -0.16494142f, -0.12130666f, 0.04353980f, -0.08345455f, 
    -0.00090740f, 0.12880138f, 0.33732009f, -0.04867845f, -0.00139576f, -0.01087681f, -0.17630228f, -0.12648256f, 
    -0.23194113f, 0.00042423f, 0.11570282f, -0.06442305f, 0.08341831f, -0.02059602f, 0.02809497f, -0.16988136f, 
    -0.05966188f, -0.07368594f, 0.01517534f, 0.02787302f, -0.01362106f, -0.05209598f, -0.03861166f, -0.33936259f, 
    -0.20339602f, 0.08156265f, 0.06339811f, -0.09693544f, 0.00166920f, -0.04985758f, -0.03163043f, -0.50833458f, 
    -0.39060453f, -0.19616286f, 0.06146100f, 0.11059577f, 0.00179276f, 0.13735339f, 0.16938296f, -0.05883390f, 
    0.22330427f, 0.20105450f, 0.07356541f, -0.06216013f, -0.03741273f, -0.16564140f, 0.04058320f, 0.15180008f, 
    0.02229173f, 0.06641177f, -0.20392297f, 0.28667173f, 0.16179396f, 0.06632109f, 0.15792365f, -0.14535071f, 
    -0.04142714f, 0.05992462f, 0.47376871f, 0.07578208f, 0.22737393f, 0.01926932f, -0.01806074f, 0.03953148f, 
    0.07652477f, 0.14456514f, -0.04959753f, -0.66233009f, -0.29078791f, -0.04054692f, 0.22438897f, 0.12307506f, 
    0.11807390f, -0.15044720f, -0.00810659f, 0.16690384f, 0.21886612f, -0.20820250f, 0.03758976f, 0.08587520f, 
    -0.09869590f, -0.20581399f, -0.02246745f, -0.23011471f, -0.00489523f, 0.26152074f, 0.10245163f, 0.18775579f, 
    -0.14851516f, -0.06610639f, 0.08031134f, 0.05108668f, -0.08930084f, 0.09577052f, 0.23454371f, -0.02201917f, 
    0.04998917f, -0.09611133f, -0.18889564f, -0.01642996f, 0.03711619f, -0.08588928f, 0.15739821f, -0.13413668f, 
    -0.00055392f, 0.08907556f, -0.01231708f, 0.09547469f, -0.18751822f, 0.25175601f, -0.00007804f, -0.09439200f, 
    -0.56393862f, -0.07965337f, 0.10051302f, 0.01171963f, 0.11689994f, 0.07702914f, 0.11488228f, 0.08628368f, 
    -0.17873967f, 0.59241301f, 0.22111823f, 0.00942650f, -0.07106044f, -0.24110225f, 0.07284395f, -0.01016474f, 
    0.11728150f, -0.07843111f, -0.05457345f, -0.20943153f, 0.04269164f, -0.29734918f, -0.18167634f, -0.18689169f, 
    0.16549160f, 0.06370182f, -0.08547853f, 0.40954450f, 0.12715310f, -0.13108113f, -0.11222716f, 0.04247442f, 
    0.21776827f, -0.22828935f, 0.11158329f, -0.13606523f, 0.39299595f, -0.15396786f, -0.06299988f, -0.10573571f, 
    0.10666793f, -0.28774160f, -0.00255610f, 0.20196681f, -0.01069565f, 0.44349039f, 0.05928723f, -0.29860091f, 
    -0.15328804f, 0.07504383f, -0.14966518f, 0.01559446f, -0.08736026f, -0.03260794f, 0.18415451f, 0.30160668f, 
    -0.03294893f, 0.01179747f, -0.10962711f, 0.09877720f, 0.05718330f, -0.23945893f, 0.04983580f, -0.07493683f, 
    -0.01570823f, 0.13638093f, 0.06880675f, 0.07097562f, 0.23485486f, -0.15881105f, -0.06102872f, -0.11298679f, 
    0.08479249f, 0.04457721f, 0.04554238f, -0.35506395f, -0.00368352f, -0.07359327f, -0.10382273f, -0.11534405f, 
    0.07288691f, 0.31280416f, -0.05043693f, -0.04752315f, 0.09486563f, 0.10380252f, 0.03888335f, 0.00910041f, 
    0.00301054f, -0.10361402f, -0.02556754f, 0.38644779f, 0.09780174f, 0.12133277f, -0.04020076f, 0.09136768f, 
    -0.07855536f, 0.18569396f, -0.03409193f, -0.03336117f, -0.17168027f, 0.14138392f, 0.10751469f, 0.07116310f, 
    0.11649991f, 0.00728500f, 0.21624695f, -0.19003269f, 0.17120686f, -0.09027353f, 0.06509697f, -0.02198901f, 
    0.09891526f, 0.08758953f, -0.02820119f, -0.09685810f, 0.10632834f, -0.30949143f, -0.21321693f, 0.05688497f, 
    -0.11914124f, 0.17824395f, -0.07296755f, -0.06615525f, 0.16380104f, -0.01506196f, -0.11728274f, -0.14435807f, 
    0.02566252f, -0.09511764f, -0.02826474f, -0.06974526f, 0.14143148f, -0.05964540f, 0.08935658f, 0.07975141f, 
    -0.08265866f, 0.11246584f, -0.08214022f, -0.10870178f, -0.11951113f, -0.15341818f, 0.12442829f, -0.00128360f, 
    -0.48218891f, -0.11576294f, 0.21336840f, -0.13410354f, 0.08879786f, -0.00614855f, 0.05516946f, 0.02551100f, 
    0.22383399f, -0.01308954f, 0.27265832f, -0.06659751f, -0.01106261f, 0.14014040f, -0.08420555f, 0.01086733f, 
    0.07773444f, -0.11842860f, 0.14531249f, 0.20037653f, 0.07459876f, -0.00532775f, -0.04572505f, 0.00122344f, 
    -0.05242013f, 0.01680304f, -0.01932599f, 0.24731426f, -0.05269988f, -0.25475901f, 0.03761341f, -0.14363137f, 
    0.16902389f, 0.01560738f, -0.19388069f, 0.03148537f, 0.04360824f, -0.47351179f, -0.04593759f, 0.10480301f, 
    0.13019417f, -0.05407685f, 0.07514181f, 0.12600200f, 0.25074703f, -0.23339804f, -0.23024976f, -0.00510680f, 
    0.07920846f, 0.11613195f, 0.06641698f, 0.01128757f, 0.12741123f, -0.06101282f, 0.26779634f, -0.13686538f, 
    0.02702669f, -0.07401841f, -0.02637708f, 0.07929154f, -0.13270989f, 0.00317633f, -0.09483754f, -0.27519217f, 
    -0.11979496f, 0.04158700f, 0.02145617f, 0.15685239f, 0.10118520f, 0.12777525f, -0.03751140f, 0.04626677f, 
    0.55963629f, -0.03821637f, -0.18611102f, 0.04885921f, -0.00268806f, -0.00098532f, 0.17870884f, -0.03280253f, 
    0.02768221f, 0.04295077f, 0.35948509f, -0.40088761f, -0.05092233f, 0.03043582f, 0.06365915f, -0.14223315f, 
    0.02125057f, -0.09899116f, -0.27149856f, 0.26680389f, 0.11289734f, 0.02367383f, 0.04252120f, 0.04008686f, 
    -0.07366460f, 0.01108120f, 0.06914612f, -0.20561455f, -0.18581644f, 0.09769548f, 0.10111412f, 0.18230227f, 
    0.07915815f, -0.10400721f, -0.08422107f, 0.00800258f, 0.10712351f, -0.22927171f, -0.37036887f, -0.03035524f, 
    0.16489813f, -0.01920688f, 0.02898576f, -0.02257262f, -0.09416676f, -0.50813186f, -0.40683874f, 0.14070486f, 
    0.01988245f, -0.09669176f, 0.05765839f, -0.03011841f, -0.09057891f, 0.12570082f, -0.00829960f, -0.08776777f, 
    -0.38873762f, 0.07958803f, 0.10332909f, 0.27294591f, -0.05743597f, 0.06920709f, -0.10005368f, -0.20602776f, 
    -0.06149884f, -0.17293037f, -0.12337525f, -0.07252398f, 0.05542354f, 0.02695031f, 0.17319931f, -0.01786307f, 
    0.49126151f, -0.01041867f, 0.21538050f, -0.06442645f, 0.10496639f, 0.01565374f, 0.08439857f, -0.06177881f, 
    0.00114792f, 0.30670735f, 0.03877536f, 0.12980892f, -0.04242093f, -0.17669359f, 0.02369459f, -0.11047110f, 
    0.03176934f, 0.05144899f, 0.23223215f, -0.08257517f, -0.09854028f, -0.12636158f, -0.01908361f, 0.08561450f, 
    0.05378849f, -0.17786777f, 0.00576511f, -0.07948994f, -0.07117481f, 0.23885021f, -0.13159166f, -0.05598588f, 
    0.06149991f, -0.05534485f, -0.12534511f, -0.17838286f, 0.04286753f, 0.07268992f, 0.13485509f, -0.06372113f, 
    0.02585719f, 0.15649107f, 0.01877020f, -0.17898777f, 0.09270585f, 0.00356607f, -0.05317727f, 0.00910890f, 
    0.10729433f, 0.09370738f, 0.06594175f, 0.06220768f, -0.02373866f, 0.27193025f, 0.40187579f, 0.19760047f, 
    -0.37054688f, -0.03134469f, -0.19100501f, -0.02253761f, 0.01424891f, -0.03425844f, 0.00255332f, 0.02643120f, 
    0.29706833f, -0.11112025f, -0.15962809f, -0.06819369f, -0.11467150f, -0.13645548f, 0.00656595f, -0.14694859f, 
    0.24097043f, -0.07338219f, -0.31663147f, 0.08442963f, -0.17332076f, 0.10844449f, 0.08436444f, 0.13227564f, 
    0.03568999f, -0.29027879f, -0.22884132f, -0.03737786f, 0.03519109f, -0.03074202f, -0.03296622f, 0.18052134f, 
    0.03901065f, 0.07455705f, 0.35012794f, 0.13408634f, -0.19521108f, 0.09252417f, 0.02952999f, -0.00072390f, 
    0.10084945f, 0.10320114f, -0.01581948f, 0.02672106f, 0.14252453f, 0.15005730f, -0.18481062f, -0.11766524f, 
    -0.04693534f, 0.19394463f, 0.12821427f, 0.00388906f, -0.26274645f, -0.33672351f, -0.41382018f, -0.13213958f, 
    -0.02773095f, 0.08031067f, -0.09932413f, -0.06142671f, -0.05858036f, 0.03539523f, 0.02600468f, 0.00524374f, 
    -0.07829519f, -0.02549345f, 0.02365600f, 0.13670728f, 0.13068630f, -0.09375059f, -0.05862435f, -0.20265567f, 
    -0.21695326f, 0.10949619f, -0.09877602f, -0.05525236f, -0.04618939f, 0.07772075f, -0.01425473f, -0.41173413f, 
    -0.05004231f, 0.18608925f, -0.25928417f, 0.04411555f, 0.06878620f, -0.22234026f, -0.12768868f, -0.25892699f, 
    0.06586660f, 0.12305024f, -0.41360345f, 0.05078758f, 0.13294369f, 0.16989237f, -0.01212360f, 0.16074266f, 
    0.10506278f, 0.39669722f, 0.02830464f, 0.03705484f, 0.08244987f, -0.06213892f, 0.14392075f, 0.10447875f, 
    -0.08798085f, -0.02679024f, -0.08069935f, 0.05149873f, -0.12329464f, 0.12700179f, 0.06379373f, -0.03184034f, 
    0.12717259f, -0.14875840f, 0.05542757f, -0.23367131f, -0.10003952f, -0.87458807f, 0.02332160f, -0.01726841f, 
    -0.13422102f, -0.05061400f, -0.27260029f, -0.34509796f, -0.24951835f, -0.05691264f, 0.14077635f, 0.08580559f, 
    -0.09839883f, -0.11284466f, 0.06017313f, 0.12578726f, 0.06804342f, 0.10708825f, -0.17668079f, 0.08582695f, 
    -0.27807230f, 0.14759368f, 0.00380993f, 0.14256081f, -0.04085670f, 0.20977899f, -0.27639136f, 0.06806573f, 
    0.08594850f, -0.11963503f, -0.04760624f, 0.04561172f, 0.12310831f, 0.06122840f, 0.06191623f, -0.20062570f, 
    -0.08391611f, -0.15652522f, -0.09980241f, 0.29732698f, -0.23242067f, 0.01217664f, -0.13321456f, -0.13082969f, 
    0.18224967f, 0.05945712f, 0.02052422f, -0.00204626f, 0.18337746f, 0.16151945f, -0.14539579f, -0.03258293f, 
    -0.01304203f, -0.07252312f, 0.03135429f, -0.10806101f, -0.01988365f, -0.03298700f, -0.18509223f, 0.05850051f, 
    -0.01519348f, 0.09553983f, -0.09100709f, -0.00761358f, 0.09623967f, -0.34978998f, -0.02878841f, -0.20159855f, 
    -0.07017760f, 0.07035656f, -0.07249032f, 0.10768998f, 0.11328931f, 0.10931108f, -0.10480917f, 0.06165577f, 
    0.19523871f, 0.14819834f, -0.01311857f, 0.11035813f, 0.55123162f, 0.08807603f, -0.00510844f, -0.18920633f, 
    0.09562577f, 0.04521818f, -0.00653955f, 0.14448085f, 0.01848464f, -0.02288499f, -0.08712598f, -0.07016669f, 
    -0.05180617f, 0.03032252f, 0.02161687f, -0.11507473f, 0.13415098f, 0.13059683f, 0.10805494f, 0.00684913f, 
    0.30672178f, 0.05582292f, 0.05673562f, -0.10945516f, 0.12549077f, -0.07779818f, 0.14149940f, -0.07430432f, 
    -0.35829079f, 0.09289075f, 0.05281824f, 0.19775495f, -0.01243483f, 0.08103088f, 0.15262794f, 0.10919349f, 
    -0.13321194f, 0.00153248f, -0.38449299f, -0.01658450f, 0.00563873f, 0.07294986f, 0.01856788f, 0.03082713f, 
    -0.04515022f, -0.00041146f, 0.01146987f, -0.07787105f, 0.07386176f, 0.10995326f, 0.06490280f, 0.03563154f, 
    -0.03857828f, 0.16711400f, 0.11392835f, 0.02274140f, 0.18486345f, 0.02622689f, -0.04432874f, -0.08157706f, 
    -0.25169238f, 0.00865032f, -0.04007526f, -0.03660509f, -0.12020749f, 0.07494909f, -0.37403992f, 0.01347802f, 
    -0.24341172f, 0.19777852f, 0.09633552f, -0.00782119f, 0.27508515f, 0.09575461f, 0.02625616f, 0.04908874f, 
    -0.09682984f, 0.08645059f, -0.24694918f, -0.12109948f, 0.04015147f, 0.28675181f, -0.14845377f, 0.24657947f, 
    -0.22075948f, 0.10986014f, -0.10739654f, -0.19281936f, 0.05165707f, 0.11762588f, -0.28685033f, 0.12567520f, 
    -0.22195503f, 0.09296665f, 0.03707049f, -0.12213195f, -0.04817953f, 0.10194107f, 0.00291972f, -0.48714533f, 
    -0.12639490f, 0.06063301f, -0.09333204f, -0.05174906f, 0.18337801f, -0.31987232f, 0.17498954f, -0.27692947f, 
    -0.03001133f, -0.02135598f, 0.09261852f, 0.10648187f, 0.12617011f, 0.09700792f, 0.15396886f, 0.08011276f, 
    0.11345713f, 0.16165149f, -0.00935588f, 0.26763067f, 0.27971730f, -0.08098678f, 0.13612455f, -0.08790062f, 
    0.03050487f, -0.07322063f, 0.10953954f, -0.28184298f, -0.09164263f, 0.00539026f, 0.14428814f, -0.18365085f, 
    -0.15054509f, -0.01670170f, -0.05188175f, 0.13317025f, -0.26208812f, 0.15857010f, 0.07644316f, -0.05919982f, 
    0.27308959f, -0.13441791f, 0.01740096f, -0.08543320f, 0.65894562f, 0.27423009f, -0.11287569f, -0.10322810f, 
    0.11477303f, 0.03220045f, -0.20467289f, 0.09577019f, 0.09105613f, 0.26826257f, 0.08707095f, -0.10404701f, 
    -0.06845550f, -0.00688078f, -0.05181569f, 0.06491372f, -0.04643981f, 0.04443746f, 0.16523033f, -0.12526621f, 
    0.01932096f, 0.00393357f, -0.04348716f, -0.02127451f, 0.04337972f, 0.08034167f, 0.18759593f, -0.10393220f, 
    0.08020698f, 0.08001997f, -0.25290227f, 0.10236870f, -0.36100489f, -0.15266347f, 0.09229469f, -0.06941541f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.00739809f, 0.04782628f, 0.10127730f, 0.08157447f, 0.15736546f, 0.11463814f, -0.09213989f, 0.21969321f, 
    0.00580747f, -0.33861178f, 0.05196038f, -0.18105988f, 0.29040816f, 0.06795076f, 0.06336100f, -0.14046051f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.14607012f, -0.14302520f, -0.08425982f, 0.14134058f, 0.00944642f, -0.25031111f, 0.10116816f, 0.14000854f, 
    -0.19726482f, -0.26599970f, -0.01758281f, -0.27135843f, -0.24034168f, -0.05382348f, -0.25277340f, -0.06446584f, 
    -0.12352206f, 0.17879587f, 0.34671858f, -0.31064296f, 0.25382987f, -0.01084449f, 0.05414705f, -0.29438388f, 
    0.09600108f, 0.65414530f, -0.19554225f, 0.14022864f, -0.26068783f, -0.22671029f, 0.33944705f, 0.33620587f, 
    0.13926029f, 0.34434450f, 0.03634976f, 0.39076602f, 0.18522024f, 0.32610247f, -0.04632391f, 0.29415941f, 
    0.05862464f, 0.02196429f, -0.05685507f, -0.20152126f, -0.21694183f, 0.24896577f, 0.07225236f, -0.43445113f, 
    0.11364913f, -0.15773909f, -0.09331248f, -0.38935131f, -0.29475862f, 0.13716455f, -0.19261323f, 0.20904925f, 
    0.00987845f, 0.05251339f, 0.43726262f, -0.30542219f, 0.54103178f, -0.42048365f, 0.09616487f, 0.32445034f, 
    0.00657110f, 0.11494116f, 0.05602095f, 0.40692452f, 0.11955456f, -0.23666570f, -0.02169064f, 0.02146672f, 
    -0.14521301f, -0.71979564f, -0.43748778f, 0.37192073f, -0.45741516f, 0.16998528f, -0.05627149f, -0.29638258f, 
    0.24056259f, 0.07598305f, 0.10800540f, 0.38293597f, 0.40825605f, 0.29743940f, 0.02591941f, -0.19833492f, 
    -0.14336796f, 0.17584258f, -0.28785896f, -0.31947908f, 0.08122125f, -0.25694764f, 0.21415327f, -0.27475831f, 
    0.11861014f, -0.07713581f, 0.03849483f, -0.01831006f, -0.06677128f, 0.44354036f, -0.00335111f, -0.19372624f, 
    0.03931097f, 0.08891512f, 0.09872234f, 0.16198477f, 0.46443781f, 0.34707239f, -0.41239274f, -0.22234368f, 
    -0.15286554f, -0.46292582f, 0.12359276f, 0.31044951f, -0.37649980f, 0.17800547f, 0.19237028f, -0.10928907f, 
    -0.11441872f, -0.14497654f, -0.46747220f, -0.12825514f, 0.50329095f, 0.78092611f, 0.34380943f, -0.12021241f, 
    0.05311180f, -0.03365977f, -0.18139425f, 0.31077045f, 0.23242022f, 0.30779558f, 0.20085122f, -0.19890462f, 
    -0.03554444f, 0.03170190f, 0.29207647f, 0.13662606f, -0.29422125f, -0.42915601f, 0.15254064f, -0.48549819f, 
    0.15253666f, 0.15152068f, -0.10977045f, -0.00094291f, 0.16353722f, -0.03199920f, -0.18786177f, -0.38808510f, 
    0.01727251f, -0.01714857f, 0.35583654f, -0.01513069f, 0.55478621f, -0.05632478f, -0.07552973f, -0.49087819f, 
    -0.23635411f, -0.33407012f, -0.00499346f, 0.06560495f, 0.26591411f, 0.42056817f, -0.06088375f, 0.24405093f, 
    0.14109112f, -0.22826122f, 0.23600309f, -0.27225545f, -0.05550233f, -0.41727179f, -0.20466970f, -0.60837626f, 
    0.02663837f, 0.02120339f, -0.13185470f, -0.23772958f, -0.42869070f, 0.58242351f, 0.09908713f, 0.33208799f, 
    0.05920045f, -0.28118372f, 0.31918132f, 0.17962758f, -0.52976465f, -0.11656908f, 0.18119588f, -0.36972764f, 
    -0.24035966f, 0.23257573f, 0.02176619f, 0.04312924f, -0.13479064f, -0.07025822f, 0.08228721f, -0.21240412f, 
    -0.02219288f, -0.55340183f, 0.26680425f, 0.26305786f, -0.02134092f, 0.29019666f, 0.07001449f, 0.19798994f, 
    -0.12966481f, 0.34166083f, -0.12458235f, -0.15282583f, 0.44808277f, -0.31003159f, 0.07799190f, 0.21242036f, 
    0.17626268f, 0.58187747f, -0.27754170f, 0.30928332f, -0.18547913f, 0.05078162f, 0.23779753f, -0.09593440f, 
    0.15806587f, -0.44887185f, 0.30561227f, -0.02365033f, -0.16270572f, 0.02516036f, 0.09021454f, -0.21073493f, 
    0.00687712f, 0.25640461f, 0.46870935f, -0.31897041f, 0.13300653f, -0.32621086f, 0.07722989f, 0.46965581f, 
    0.20693964f, -0.29682612f, 0.20394503f, -0.31743824f, -0.14399220f, 0.23261249f, 0.05998354f, -0.20329101f, 
    0.13844511f, 0.43555006f, 0.42300385f, -0.01186780f, -0.10138915f, -0.07258423f, -0.08968787f, 0.45384109f, 
    -0.22937340f, -0.19449021f, -0.41083455f, 0.17973427f, 0.39675516f, -0.19194646f, -0.05115241f, -0.10268048f, 
    0.13009241f, 0.26941746f, 0.41304848f, -0.14197008f, -0.15092425f, -0.32463402f, 0.20433585f, 0.30048275f, 
    0.23550339f, 0.21091127f, -0.03607808f, -0.27153349f, 0.00421940f, 0.08552078f, 0.05918626f, 0.02532603f, 
    -0.08478150f, -0.29718921f, 0.12395934f, 0.42542699f, -0.25761542f, 0.25548032f, 0.09542557f, 0.15501240f, 
    0.07847237f, -0.04854893f, 0.02890130f, -0.09675970f, 0.42806014f, -0.41447446f, -0.03471758f, 0.04952702f, 
    0.13036345f, 0.54577041f, -0.22340332f, 0.21941915f, -0.19115524f, 0.03906018f, 0.23741373f, 0.26525104f, 
    -0.22783847f, -0.34889168f, -0.25420260f, 0.44618934f, 0.01360648f, -0.19424348f, -0.16373521f, 0.47903061f, 
    0.19040580f, 0.15312947f, 0.09655886f, 0.05613758f, 0.33893207f, 0.33092245f, -0.32875448f, -0.09935751f, 
    0.12225735f, -0.22109511f, 0.08975426f, -0.50255156f, 0.05418050f, 0.40684572f, -0.19409117f, -0.12522587f, 
    -0.07725108f, -0.40853247f, 0.18986274f, 0.19495220f, -0.17636733f, 0.02237685f, 0.30440712f, 0.49629956f, 
    0.01992612f, -0.81944340f, 0.21548004f, 0.37241033f, 0.14852861f, -0.16171077f, 0.15138295f, -0.28819084f, 
    -0.17914787f, 0.50862038f, 0.11640108f, 0.02589808f, 0.26859373f, -0.33219555f, -0.25119168f, 0.48750898f, 
    0.20953970f, -0.57932019f, 0.14734232f, 0.19613706f, -0.15193450f, 0.41789520f, 0.09273367f, -0.06066439f, 
    -0.17804939f, 0.18540099f, 0.25871143f, 0.14960997f, -0.34733081f, -0.19487347f, -0.09991637f, 0.04926867f, 
    -0.16033457f, 0.21902131f, 0.13838366f, -0.08674750f, -0.04685684f, -0.40152681f, -0.00440539f, 0.38689056f, 
    -0.22258036f, 0.37511748f, 0.27409846f, 0.11919872f, -0.29865578f, -0.46001750f, 0.06912546f, 0.27541852f, 
    0.10251153f, -0.01895804f, 0.07633648f, 0.54574841f, -0.16876939f, 0.04944226f, 0.00996054f, -0.28900149f, 
    -0.00711239f, -0.65791541f, -0.12237377f, 0.59447205f, -0.16853184f, 0.18043701f, -0.16867967f, 0.11475199f, 
    0.12282397f, -0.01193886f, -0.30961499f, 0.00200309f, -0.18467502f, -0.36205006f, 0.24587342f, 0.27227816f, 
    -0.20037051f, 0.18935038f, 0.14424434f, 0.45533893f, -0.34604883f, 0.28112927f, 0.24849449f, 0.19216910f, 
    -0.05142833f, 0.00759643f, -0.26354128f, 0.36263418f, 0.43594441f, 0.19480938f, -0.19286470f, -0.36169147f, 
    -0.09238618f, 0.67229140f, -0.28487042f, 0.16402681f, -0.05613770f, 0.33109996f, 0.01361803f, 0.00949579f, 
    0.08078358f, 0.30867139f, 0.26146802f, -0.03985823f, -0.25423270f, 0.33607510f, -0.03402102f, -0.08976705f, 
    -0.08436733f, -0.19850221f, 0.28885221f, -0.13539845f, -0.69961601f, 0.23406671f, 0.15022029f, 0.16588442f, 
    0.23903328f, 0.09623005f, -0.13856806f, -0.09423893f, 0.07924025f, 0.02959120f, 0.23192789f, -0.05582563f, 
    0.22171746f, -0.04357187f, -0.10772489f, -0.02109294f, -0.19982903f, -0.07064774f, -0.23053271f, 0.13284679f, 
    -0.16848771f, 0.51141769f, -0.12877303f, -0.12444372f, 0.14380333f, -0.00679526f, -0.07979001f, 0.29034975f, 
    0.22909303f, -0.44222397f, 0.20322157f, 0.19143794f, 0.49537656f, 0.14526585f, -0.43165711f, 0.12345076f, 
    0.07429737f, -0.19467889f, -0.35363123f, 0.05406315f, -0.35079589f, -0.03556186f, -0.02325995f, -0.06558295f, 
    0.02314265f, 0.07325734f, 0.42803729f, -0.48714918f, -0.59271163f, -0.39937803f, 0.32972869f, 0.45260233f, 
    -0.19554789f, -0.43334186f, -0.17372286f, 0.14984678f, 0.36463654f, -0.23522808f, -0.11173132f, -0.12758796f, 
    0.10504628f, 0.05385701f, -0.37868464f, 0.16257966f, 0.61854041f, 0.29312441f, 0.50213414f, -0.26339012f, 
    -0.24342124f, 0.02192197f, -0.02306731f, 0.44857067f, 0.23952706f, -0.50435734f, 0.19103500f, 0.34165257f, 
    -0.07977290f, 0.37255326f, -0.27222455f, -0.11280500f, 0.30004713f, 0.20377451f, -0.25134104f, -0.22872783f, 
    0.18621042f, 0.50769901f, -0.10841215f, -0.12115587f, 0.49258789f, 0.06225438f, 0.14406876f, 0.13073476f, 
    0.13157798f, -0.27908662f, 0.14245261f, -0.13953860f, -0.47851810f, -0.25887296f, 0.15923999f, -0.07526061f, 
    0.15434165f, 0.57446289f, -0.49479231f, -0.29139629f, 0.10287099f, 0.39982325f, -0.00231467f, 0.09835725f, 
    -0.24166813f, 0.24784254f, -0.10934439f, 0.28033081f, -0.43134898f, 0.18720192f, 0.09758722f, 0.05224219f, 
    0.03659705f, -0.07149541f, 0.25435165f, -0.28259516f, -0.03664997f, -0.10220402f, 0.04455838f, -0.13695934f, 
    0.14131570f, -0.28529590f, 0.01816974f, 0.35019842f, 0.69868046f, 0.16419336f, 0.09972405f, 0.19930428f, 
    -0.01772637f, -0.15956779f, -0.15475368f, 0.20246735f, -0.43101072f, 0.46061903f, -0.05932983f, 0.40723762f, 
    0.00319760f, -0.39292285f, 0.33550930f, 0.35982329f, 0.56147546f, 0.07124851f, -0.43118826f, 0.22826700f, 
    0.20917928f, 0.15861423f, 0.35921392f, -0.26001987f, -0.15873811f, -0.14793067f, -0.16858692f, 0.29169905f, 
    -0.10811774f, -0.27370825f, -0.16415264f, 0.37839648f, 0.49530217f, -0.14879841f, -0.06851346f, 0.15567246f, 
    0.07040720f, -0.30733591f, 0.34516644f, -0.14762165f, -0.01825738f, 0.04497845f, -0.13361645f, -0.20739509f, 
    0.24610095f, 0.05235565f, 0.11669955f, -0.41395608f, 0.52961886f, 0.23606783f, 0.02367691f, 0.23285989f, 
    0.23206419f, 0.30937988f, -0.15155673f, 0.08051280f, 0.16539942f, 0.15831900f, 0.00303896f, 0.18337362f, 
    0.23814076f, 0.04047053f, -0.28427908f, -0.15463628f, 0.53954172f, -0.08920788f, -0.04363697f, -0.12255215f, 
    -0.09980092f, -0.43460259f, 0.44816941f, -0.31745291f, -0.24327324f, -0.27271143f, -0.12621512f, 0.38649920f, 
    -0.21758153f, -0.35001704f, 0.23130237f, -0.25110957f, 0.01297992f, 0.27110010f, 0.22376531f, 0.02352422f, 
    -0.07198697f, -0.13398135f, -0.14468296f, -0.08094319f, 0.47791398f, -0.52460909f, 0.16793554f, 0.36695999f, 
    -0.09532294f, -0.31637153f, -0.16597211f, 0.23237948f, -0.14232644f, 0.14718282f, 0.35716674f, 0.12619127f, 
    -0.10212418f, -0.03020393f, -0.13986254f, 0.06067497f, -0.50518101f, 0.21704884f, -0.04925228f, 0.14810745f, 
    0.25538215f, 0.07740788f, 0.37572205f, 0.41629648f, 0.24823731f, 0.03814403f, -0.17226914f, -0.13236475f, 
    0.16504736f, -0.60261726f, 0.10944841f, 0.12668073f, 0.21201444f, 0.17840447f, -0.11427616f, -0.23444135f, 
    -0.01274081f, 0.25662771f, -0.37797880f, -0.22152843f, 0.11293633f, 0.28800932f, 0.53641623f, -0.02882318f, 
    0.13968280f, 0.07595883f, -0.32633641f, 0.19143972f, 0.40699247f, -0.16092183f, 0.16071659f, 0.36819673f, 
    -0.21804214f, 0.11363740f, -0.25017738f, -0.25584555f, 0.18745831f, -0.06044137f, -0.31342304f, -0.02959429f, 
    -0.08795992f, -0.52242810f, 0.35764271f, -0.21722700f, 0.01889855f, -0.22111532f, -0.24058662f, 0.44376513f, 
    0.24225849f, -0.63335204f, 0.06350110f, -0.03804894f, 0.48985711f, 0.01789386f, -0.02043120f, 0.33698773f, 
    0.15201272f, 0.03169236f, -0.34397852f, 0.29860130f, -0.49165791f, 0.04558385f, 0.09079409f, 0.04755210f, 
    0.18848613f, 0.54005456f, -0.00503303f, 0.03225316f, 0.31283793f, 0.62037522f, -0.01338746f, 0.06537794f, 
    -0.04855686f, 0.12399150f, 0.13664079f, -0.05915434f, -0.18611085f, -0.24874979f, -0.17637567f, -0.18370587f, 
    -0.11229745f, 0.06502824f, -0.16827047f, -0.13022575f, 0.09736796f, 0.17426531f, -0.17478746f, -0.24634273f, 
    -0.06412639f, -0.36033294f, -0.22856288f, 0.51040578f, 0.26800677f, 0.34823874f, 0.20921780f, 0.16391328f, 
    0.04879065f, -0.23898068f, 0.18243706f, -0.25555921f, 0.31983969f, 0.00543293f, -0.20431532f, -0.28174683f, 
    -0.14987108f, 0.74990314f, -0.25307143f, -0.04429956f, 0.17547901f, 0.19237272f, -0.21461953f, -0.14165287f, 
    -0.03355758f, 0.32996491f, -0.29358670f, 0.55988759f, 0.18930256f, -0.43780708f, -0.02757918f, 0.41124642f, 
    0.09311005f, -0.54778588f, -0.07256959f, -0.37734070f, 0.10516974f, -0.93538684f, -0.13189334f, -0.10843987f, 
    -0.10936287f, 0.07300216f, 0.29661617f, -0.22300768f, 0.19071589f, 0.56605166f, 0.33301580f, 0.41611052f, 
    -0.09011790f, 0.07379538f, 0.27211553f, 0.44170010f, 0.50421953f, 0.42535350f, -0.19560312f, -0.25997949f, 
    -0.13434131f, -0.25693285f, -0.42998526f, -0.23460992f, 0.13907938f, -0.19018766f, 0.38691273f, -0.15805769f, 
    -0.19305488f, 0.12872107f, 0.26522261f, 0.22219732f, 0.04979894f, 0.47441489f, -0.18082455f, -0.20492622f, 
    0.01331403f, 0.69870466f, -0.27927127f, -0.31395182f, -0.27262169f, 0.23758684f, 0.51288694f, -0.29956505f, 
    -0.23539948f, -0.33694258f, 0.31607431f, 0.37679276f, -0.30369940f, -0.05819784f, -0.04519154f, 0.30369237f, 
    -0.06494221f, -0.12430485f, 0.07210701f, -0.11007795f, -0.03528652f, 0.18241717f, -0.07005724f, -0.22607036f, 
    0.21826828f, -0.32339421f, 0.13274525f, 0.02692660f, -0.31873351f, 0.51667690f, 0.14053771f, -0.09603477f, 
    -0.13327125f, 0.20174275f, -0.18336156f, 0.32319164f, -0.09020133f, 0.53289056f, 0.09059612f, -0.00144927f, 
    0.09797233f, -0.56571138f, 0.07064095f, 0.11056435f, 0.13894211f, 0.11502461f, 0.15067525f, 0.39047903f, 
    0.02103237f, -0.34827960f, -0.14652641f, 0.02638221f, -0.06666951f, -0.34664369f, 0.12407367f, 0.10832541f, 
    -0.20738392f, 0.08583435f, -0.00691479f, -0.50866586f, -0.00157905f, 0.15008272f, -0.05079199f, 0.22590895f, 
    -0.19112892f, -0.30997241f, 0.00646711f, 0.08689021f, 0.13954213f, -0.21184957f, 0.26226047f, 0.17901914f, 
    -0.13104582f, -0.17519908f, 0.37642914f, -0.16997235f, 0.36194000f, -0.39479765f, 0.23362048f, 0.09847575f, 
    0.16138013f, -0.25552195f, 0.06876536f, -0.35162914f, 0.13384630f, 0.18904367f, -0.09462721f, 0.34484518f, 
    -0.13986465f, 0.25077355f, 0.19186744f, -0.02317733f, 0.19486120f, -0.19463336f, 0.01511032f, -0.08516461f, 
    0.16451290f, -0.30395761f, 0.55410576f, 0.21462016f, 0.19303070f, -0.63537717f, -0.46100327f, -0.23955932f, 
    -0.18289325f, 0.12212591f, 0.32035813f, -0.02864469f, 0.02733460f, -0.19393536f, 0.17860238f, 0.10155840f, 
    0.03257775f, -0.19867764f, 0.51254708f, -0.03878035f, -0.32993406f, -0.25734511f, 0.34697676f, -0.06236564f, 
    0.08021574f, -0.12214773f, -0.12420414f, -0.01809254f, 0.08469993f, -0.23308177f, -0.15776779f, 0.02047698f, 
    0.18023656f, 0.06263995f, -0.18345536f, -0.13533644f, -0.12427524f, 0.20732103f, -0.22721611f, -0.19888701f, 
    0.17020929f, 0.15742399f, 0.28943500f, -0.01621735f, 0.35608304f, -0.28819194f, 0.11331743f, 0.28606054f, 
    -0.19149582f, -0.16022070f, 0.05950203f, -0.34799296f, -0.60473531f, -0.07344311f, 0.37734702f, -0.16011682f, 
    -0.12394020f, 0.52953166f, 0.01667808f, -0.00434351f, 0.13654327f, -0.30245084f, -0.12135777f, -0.16704452f, 
    -0.14026536f, -0.29593486f, 0.08366364f, 0.32906270f, 0.52283800f, 0.23959908f, -0.35120511f, -0.07648114f, 
    -0.17333731f, -0.16629274f, 0.26790282f, 0.17128383f, 0.26620501f, -0.42673716f, 0.07102735f, 0.35451379f, 
    -0.22169442f, -0.25206932f, -0.29076210f, -0.27638793f, 0.03924409f, 0.10491525f, 0.12776957f, -0.02772043f, 
    0.18849413f, 0.17841208f, 0.02333840f, -0.13590695f, 0.37546471f, -0.14481871f, 0.17032617f, -0.27081612f, 
    0.23356381f, -0.09071290f, -0.13510665f, 0.17222914f, 0.46431467f, -0.15587200f, 0.43427098f, 0.10665924f, 
    -0.13878281f, 0.40729046f, 0.39388001f, -0.11037739f, 0.28669575f, -0.39520475f, -0.18772237f, 0.25550225f, 
    -0.11257857f, 0.02037197f, -0.32583901f, -0.42539495f, -0.12112621f, 0.24011995f, 0.29534718f, -0.32678151f, 
    -0.00393755f, 0.29333851f, 0.03202360f, -0.25998628f, 0.08845881f, -0.49912560f, 0.24695121f, 0.12909801f, 
    0.05010600f, -0.32452083f, 0.31161955f, 0.45526993f, -0.23412868f, 0.13079815f, 0.19216427f, 0.06930424f, 
    -0.06606796f, -0.07117738f, -0.12658781f, -0.19546874f, 0.04258806f, -0.16393857f, 0.24391842f, -0.12769784f, 
    0.13723418f, 0.03281129f, 0.06743325f, -0.04694944f, -0.31421858f, -0.03884712f, -0.17930527f, 0.13566491f, 
    -0.15526694f, 0.10146050f, 0.17950447f, 0.39468029f, 0.04725802f, 0.11978128f, -0.06135897f, -0.15964407f, 
    -0.20853093f, -0.17468058f, -0.26272821f, -0.17083560f, 0.54381722f, 0.46063551f, 0.43501279f, -0.30545762f, 
    0.01092866f, 0.50841618f, 0.33438709f, 0.07595262f, 0.38098252f, 0.35010079f, 0.17417590f, 0.12679932f, 
    -0.05330576f, -0.24850298f, -0.21326861f, -0.44137776f, -0.66672927f, -0.01965432f, 0.01466082f, -0.13057348f, 
    0.16229521f, -0.09730748f, -0.16515148f, 0.36958626f, -0.19312076f, 0.14309123f, -0.08222934f, -0.01259983f, 
    -0.00042496f, 0.47408968f, -0.37157112f, -0.06430236f, -0.74143207f, 0.08724056f, -0.13258620f, -0.05651744f, 
    0.12199245f, -0.01101361f, 0.22151636f, -0.25953838f, -0.25476265f, -0.56482852f, 0.24743095f, 0.42048183f, 
    0.10846373f, -0.23010054f, 0.12295988f, 0.30184227f, 0.07763260f, 0.43527779f, 0.12003691f, 0.27428889f, 
    -0.15189987f, 0.04025244f, 0.02159130f, 0.13912980f, -0.07905952f, 0.46011388f, 0.22280720f, -0.32292855f, 
    -0.05570494f, 0.76140267f, 0.05711970f, -0.27982432f, 0.15396234f, -0.13161121f, -0.50879389f, 0.26463640f, 
    -0.17858154f, 0.12922621f, 0.23783475f, 0.15626734f, -0.06160422f, -0.20022616f, -0.19815569f, 0.27486464f, 
    -0.10805543f, -0.11386727f, -0.09044128f, 0.05032394f, -0.08575314f, -0.15497540f, 0.23168564f, -0.30291867f, 
    -0.15660563f, 0.15603410f, -0.01640395f, -0.41541758f, -0.25354293f, 0.58921099f, -0.19748509f, 0.00582840f, 
    -0.14862354f, -0.02759639f, 0.39147469f, 0.22308615f, 0.17785765f, -0.19400157f, -0.08266436f, 0.59827435f, 
    -0.07123699f, 0.34430337f, -0.31954008f, 0.08673920f, -0.23443408f, 0.02098910f, -0.14636640f, 0.35324773f, 
    -0.14082977f, -0.16789244f, 0.05350358f, 0.44144765f, 0.48736647f, 0.13450000f, 0.08647332f, -0.15176181f, 
    -0.20705533f, 0.27628762f, -0.28528538f, -0.43851992f, -0.28383383f, 0.40486234f, 0.23450603f, 0.24361655f, 
    0.06765023f, 0.40210104f, 0.02494168f, -0.06795312f, 0.10760678f, -0.00769079f, 0.25254601f, 0.13146767f, 
    0.10612267f, 0.12401774f, 0.47346342f, 0.47404659f, 0.35207170f, 0.38904294f, -0.03941118f, -0.29521745f, 
    0.04275221f, 0.02771905f, -0.31294110f, -0.25311127f, -0.28723648f, 0.36670724f, 0.30424592f, -0.22239703f, 
    -0.06115407f, -0.16620038f, 0.24603446f, -0.22846654f, -0.17711729f, -0.18325219f, 0.06818897f, -0.15852848f, 
    0.21878053f, -0.24255778f, 0.20449120f, 0.17689884f, 0.14431514f, -0.21121043f, 0.29432559f, 0.42732334f, 
    -0.03902945f, 0.29174560f, -0.05689480f, 0.12792124f, -0.33882961f, -0.35769072f, -0.07164529f, 0.22698081f, 
    -0.06635533f, 0.05022346f, -0.17571117f, -0.07955533f, -0.39891738f, 0.59851539f, 0.36878026f, -0.01234505f, 
    0.21621512f, 0.29659945f, -0.19277889f, 0.02444418f, -0.12053715f, 0.45434517f, 0.02272291f, 0.24704470f, 
    -0.09347736f, -0.31646129f, 0.34678853f, -0.03837406f, -0.06445856f, 0.06063987f, 0.07594606f, -0.00320025f, 
    -0.21723655f, 0.10026196f, 0.29408798f, -0.39625216f, -0.25706324f, 0.33983332f, 0.04036254f, 0.09851341f, 
    0.09033382f, 0.00381174f, 0.19395350f, -0.17306282f, -0.19034314f, -0.02889646f, -0.07961437f, 0.49138853f, 
    0.05144217f, -0.35100028f, -0.13698071f, 0.16308439f, 0.26897475f, -0.07636195f, 0.14977430f, -0.24231917f, 
    0.07445461f, 0.46044067f, -0.34299144f, 0.13857940f, 0.31504619f, 0.55983043f, 0.25770888f, -0.15567069f, 
    -0.12138367f, 0.07932054f, 0.13347438f, 0.22033772f, -0.22852828f, 0.24026954f, -0.01238345f, -0.02528665f, 
    -0.20444123f, -0.29655573f, -0.11918430f, 0.15176882f, 0.71929479f, 0.23615007f, -0.09722139f, -0.36963651f, 
    0.23484674f, 0.09077086f, -0.11027464f, -0.09449290f, 0.16304804f, -0.06532957f, -0.05050964f, 0.29392087f, 
    0.18222439f, -0.26428843f, 0.46852031f, -0.31964052f, -0.29936802f, 0.27853230f, 0.26160717f, 0.10403378f, 
    0.12232989f, -0.05621618f, -0.21912259f, 0.00045910f, -0.07577673f, 0.05379936f, -0.20731783f, 0.01812109f, 
    -0.18565336f, 0.02289709f, -0.23507461f, -0.03202486f, -0.04002708f, -0.22424623f, 0.02734151f, -0.01835686f, 
    -0.14205654f, -0.25290748f, 0.35961884f, 0.44102538f, -0.38830379f, 0.30562893f, 0.06825108f, -0.11301368f, 
    -0.17956543f, -0.12550364f, 0.00256678f, -0.08728358f, 0.60409796f, 0.41215739f, -0.02292730f, -0.25396645f, 
    -0.00199039f, 0.52940524f, 0.33947527f, -0.15815212f, -0.11278842f, 0.29763138f, -0.13000619f, -0.30304068f, 
    0.01522465f, 0.38657209f, -0.33719265f, 0.41359627f, 0.13863915f, -0.06656782f, 0.31934917f, -0.23695746f, 
    0.21184278f, -0.27127472f, -0.04569969f, -0.17316897f, -0.04050723f, 0.01597373f, -0.23282222f, -0.15057027f, 
    -0.03694588f, -0.22017278f, 0.15653318f, -0.06615739f, 0.02752834f, -0.05254424f, 0.05157915f, -0.27149668f, 
    0.04075301f, 0.26852348f, 0.14374535f, 0.27979112f, 0.42162976f, 0.31004107f, -0.06744596f, 0.12220751f, 
    0.09736610f, 0.39737725f, -0.36266616f, -0.23006964f, -0.21283761f, 0.03660415f, -0.07803595f, -0.24401008f, 
    -0.06217381f, 0.35561088f, 0.22856525f, -0.49920806f, -0.32493788f, 0.45738542f, -0.06195241f, -0.17386439f, 
    -0.02103832f, 0.67378449f, -0.12774518f, -0.28093132f, 0.16094287f, -0.30378914f, -0.04186819f, 0.20117134f, 
    0.03304509f, 0.72138178f, 0.00446988f, -0.02450891f, 0.25438106f, -0.39014283f, 0.10350037f, 0.20788938f, 
    -0.21906269f, 0.21534021f, 0.03662302f, 0.44726506f, -0.42221212f, -0.46680415f, -0.08967606f, 0.19231135f, 
    -0.06067538f, -0.44573557f, -0.27107581f, -0.04469660f, 0.15577547f, -0.13034415f, 0.18555290f, 0.22655818f, 
    0.24452136f, 0.31403968f, 0.26037332f, -0.12812109f, -0.23606184f, 0.42569873f, 0.03627060f, 0.26800194f, 
    0.20045581f, 0.65298313f, -0.39361504f, 0.21136960f, 0.33974227f, 0.04430860f, 0.02182563f, 0.40785623f, 
    0.07896619f, -0.28112039f, 0.08226831f, 0.30988127f, 0.15281244f, -0.05885154f, -0.29850608f, 0.12044066f, 
    -0.18759283f, 0.05052459f, 0.08702308f, -0.06448817f, 0.03954789f, -0.02345052f, 0.00313625f, -0.11543280f, 
    0.03302461f, -0.03051028f, -0.19509473f, -0.02176571f, 0.00746772f, -0.15773350f, -0.03065935f, -0.09292224f, 
    0.21262783f, -0.00810087f, 0.05029795f, -0.21890786f, 0.25512534f, 0.37123582f, -0.03886255f, -0.18244919f, 
    0.05491513f, -0.57482165f, 0.35586989f, 0.00453385f, -0.38810503f, 0.19499156f, 0.01363358f, 0.38237429f, 
    0.19467878f, 0.69400251f, 0.09310265f, -0.24306926f, -0.09555903f, 0.09129493f, -0.01374016f, 0.13308911f, 
    0.20799787f, 0.27173150f, 0.14898811f, 0.30222717f, -0.59293282f, -0.33811355f, 0.24241079f, 0.28386542f, 
    -0.06520753f, -0.32292745f, 0.16291472f, 0.22344452f, -0.19386856f, 0.26138228f, -0.11857930f, -0.18739258f, 
    0.01356860f, -0.42696655f, 0.40045866f, -0.39765519f, 0.60111129f, 0.17885073f, 0.06089859f, 0.07534685f, 
    0.03278675f, 0.27096614f, -0.07607186f, -0.08755260f, -0.54887521f, 0.51603043f, 0.09437313f, -0.05256273f, 
    -0.00019591f, 0.27056637f, 0.21619897f, 0.34339684f, 0.04193179f, 0.00304673f, -0.41448471f, 0.05789766f, 
    0.15349725f, -0.37627506f, 0.21619789f, -0.07192302f, 0.28986138f, -0.26557991f, -0.13421783f, -0.04378737f, 
    -0.06823888f, -0.10345531f, -0.16310199f, 0.00268158f, 0.29995209f, -0.05579601f, 0.32212353f, -0.10214628f, 
    -0.10558751f, 0.39442521f, -0.23904854f, 0.01229133f, 0.34279376f, 0.12463222f, 0.07908552f, 0.15621218f, 
    -0.04650027f, -0.30975106f, -0.31426129f, -0.25627089f, 0.52796310f, 0.22740814f, 0.00697408f, 0.12421441f, 
    -0.10277566f, -0.09335361f, 0.25480473f, 0.10334282f, 0.40405083f, -0.34518641f, -0.21724004f, 0.27381364f, 
    0.14131936f, -0.20628092f, -0.11370979f, -0.40053883f, 0.01072144f, -0.13107736f, -0.35387501f, 0.04053515f, 
    0.01585534f, 0.26927289f, -0.13973452f, 0.13141087f, 0.05484098f, -0.21341361f, 0.10514656f, -0.22907369f, 
    0.18090168f, -0.10616719f, 0.03383129f, -0.23989628f, -0.10328198f, -0.14086495f, -0.12499671f, 0.19998801f, 
    0.10211821f, 0.39608544f, 0.05490226f, -0.15150790f, 0.31315976f, -0.14782502f, 0.04557975f, 0.16354197f, 
    0.03565253f, 0.33391029f, -0.18048869f, -0.30368343f, 0.07292221f, -0.13334897f, 0.09924786f, -0.09896043f, 
    0.07028201f, 0.07115239f, -0.13189033f, 0.16257642f, 0.03867532f, 0.56965011f, -0.17643426f, 0.31811380f, 
    -0.20529111f, -0.11632621f, 0.27560654f, -0.21682486f, 0.05629931f, -0.20195942f, -0.44360894f, 0.14741674f, 
    -0.16634819f, -0.16093808f, 0.07975065f, 0.34107542f, 0.31189904f, 0.13498217f, -0.09789848f, 0.45765334f, 
    0.18200722f, -0.16667566f, -0.10593788f, -0.22374575f, -0.20529602f, -0.58190125f, -0.31742337f, 0.11488032f, 
    0.21268651f, 0.07789027f, 0.38779411f, 0.21235733f, 0.24782598f, 0.22881941f, -0.09191906f, -0.04235328f, 
    -0.00821829f, -0.52430511f, 0.22233067f, -0.16707209f, -0.04879189f, -0.94703484f, -0.30462298f, -0.80470109f, 
    -0.14237750f, 0.19582583f, -0.31094903f, -0.50946003f, -0.26311204f, 0.04364901f, 0.06935956f, 0.48713842f, 
    -0.01776934f, 0.02127568f, 0.00942693f, -0.25037456f, -0.37635797f, 0.33323056f, 0.30688378f, 0.30012375f, 
    -0.16996139f, -0.04127747f, 0.24596038f, 0.38943776f, -0.02044682f, 0.15810525f, -0.10993741f, -0.00850986f, 
    -0.12659603f, 0.02934182f, -0.22999740f, 0.07761240f, 0.45271128f, 0.26027164f, 0.29638186f, -0.38893747f, 
    0.05556798f, -0.18301016f, 0.14089806f, -0.11766877f, 0.10833371f, 0.16846180f, -0.14173837f, 0.06930790f, 
    -0.04608081f, -0.29762161f, -0.02870893f, -0.17701814f, 0.60437530f, -0.06682300f, -0.17346430f, 0.32685858f, 
    -0.08489397f, 0.25461274f, -0.20556776f, 0.12101032f, 0.30121931f, -0.34894061f, 0.23746836f, 0.39269909f, 
    -0.17820220f, -0.52799100f, 0.18902558f, -0.15270348f, 0.22860174f, -0.14752859f, -0.10531019f, 0.28386903f, 
    0.20254453f, -0.10861307f, 0.36409590f, 0.04023274f, 0.05999223f, 0.14959848f, -0.13554201f, 0.20409892f, 
    0.13545580f, -0.23147207f, 0.01959813f, -0.17807519f, 0.06236170f, -0.32128286f, -0.17774279f, 0.00932347f, 
    0.09267205f, 0.68176001f, -0.37260839f, 0.30008930f, 0.53235739f, 0.03756854f, -0.20371683f, -0.20560019f, 
    -0.21627502f, -0.43323323f, 0.20575331f, -0.24687675f, 0.06881678f, 0.28439975f, -0.16878457f, 0.01205349f, 
    0.07329015f, -0.31342602f, 0.22169830f, 0.23610182f, -0.10425152f, -0.03826435f, 0.14332384f, 0.05147180f, 
    0.09876055f, -0.00276888f, -0.07267443f, 0.35767430f, -0.00485777f, 0.41050559f, 0.20240913f, -0.20480217f, 
    0.19194821f, 0.03055907f, 0.41114330f, -0.08818616f, 0.19681218f, -0.39938256f, 0.06897441f, 0.34858033f, 
    -0.10162953f, 0.38659614f, -0.13839819f, -0.17747280f, -0.39387307f, 0.05812925f, 0.14228661f, -0.04862409f, 
    0.12866393f, -0.54328048f, 0.35925406f, 0.16538180f, 0.28228593f, -0.39321369f, 0.09710979f, -0.18709706f, 
    -0.01169993f, 0.03795301f, -0.04697939f, -0.12854728f, 0.32896766f, -0.07909534f, 0.47938782f, 0.08593648f, 
    -0.05397030f, -0.33465120f, -0.30015492f, -0.17567085f, 0.16197409f, -0.01298565f, 0.22317871f, -0.23238012f, 
    0.20202371f, 0.68115872f, 0.50135458f, -0.28070948f, 0.27042058f, -0.60237783f, 0.22335915f, 0.22727437f, 
    0.08559628f, 0.40011948f, 0.05943419f, -0.14852299f, 0.09733454f, 0.04258000f, -0.08003987f, 0.34838799f, 
    0.05828042f, -0.15464920f, -0.05355636f, 0.18290618f, 0.23236188f, 0.23230727f, -0.02346747f, -0.13280092f, 
    -0.24354865f, -0.46838167f, 0.13252491f, 0.14908297f, -0.27543238f, -0.36366680f, 0.19709682f, 0.29719272f, 
    0.09397803f, 0.38413745f, 0.14821178f, 0.03533505f, -0.06294241f, 0.06728578f, -0.11327329f, -0.05526486f, 
    0.14099382f, 0.85165197f, -0.42285433f, -0.61441505f, -0.12519968f, -0.02991879f, 0.02873305f, 0.09806065f, 
    0.23553431f, 0.13678555f, 0.09090833f, 0.32097808f, 0.00379473f, -0.03360118f, 0.31034184f, 0.45598525f, 
    -0.05387862f, -0.79068589f, -0.26487571f, 0.11638191f, 0.08970294f, -0.02020265f, -0.14008635f, 0.14540567f, 
    0.06082618f, 0.47031602f, 0.18643028f, -0.55276561f, 0.18769521f, -0.74064201f, 0.04833062f, -0.06134292f, 
    0.11933072f, 0.52498573f, -0.21547820f, 0.35145679f, 0.30040091f, 0.28054407f, 0.02162816f, 0.32592523f, 
    0.13544562f, 0.14784898f, -0.18071385f, 0.24100284f, -0.09266824f, 0.14135337f, -0.20429237f, -0.22385624f, 
    0.16032635f, 0.12470926f, 0.09146237f, -0.43647447f, 0.36164257f, -0.31376559f, 0.09625009f, 0.35166821f, 
    0.00360825f, 0.06460002f, 0.14663309f, 0.24783500f, -0.30221227f, -0.50684732f, 0.21244919f, 0.30022395f, 
    -0.15879402f, -0.12621225f, 0.20082363f, 0.17849419f, 0.38550097f, -0.30190414f, -0.20414591f, 0.05865721f, 
    -0.15158112f, -0.63196820f, -0.54305089f, -0.13294114f, 0.55750579f, -0.23119389f, 0.14353937f, 0.08835378f, 
    -0.25210238f, 0.13072816f, -0.11489395f, 0.26432186f, 0.14800748f, -0.40857404f, -0.14909108f, -0.04168770f, 
    -0.00878643f, 0.08511749f, -0.03775113f, 0.34481770f, 0.49664450f, 0.42775652f, 0.18790433f, -0.32297924f, 
    0.04628519f, 0.01386996f, 0.06193974f, -0.16813822f, -0.27427894f, 0.30546802f, -0.05147279f, 0.37200135f, 
    -0.17401247f, -0.50087225f, 0.63119370f, -0.17191537f, 0.01327563f, 0.35564962f, -0.40008771f, 0.11119602f, 
    -0.14654276f, -0.37199184f, 0.46604148f, -0.24390900f, -0.34493795f, 0.13990384f, -0.13176404f, -0.29309890f, 
    -0.05270047f, 0.17236035f, 0.26336578f, 0.16197488f, -0.01314463f, -0.11387376f, 0.43875888f, -0.03050181f, 
    0.05547832f, 0.25951141f, 0.05241008f, 0.18018605f, -0.18897754f, 0.63752484f, 0.17445605f, 0.42114905f, 
    0.16666614f, -0.15661408f, -0.38691750f, -0.56663811f, -0.22215338f, 0.55317831f, -0.09405541f, -0.26483500f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19757861f, -0.16502304f, -0.17370246f, 0.22798419f, 0.36276853f, 0.27023500f, -0.28435609f, 0.08464640f, 
    0.50088167f, 0.20991857f, 0.16500726f, -0.29529893f, -0.07166527f, -0.34698462f, 0.23653318f, -0.03343340f, 
    -0.56322443f, -0.20587517f, -0.23327203f, 0.26909542f, -0.11759881f, -0.73036534f, -0.08685521f, 0.00503014f, 
    -0.30482689f, 0.28113154f, -0.33268583f, 0.05588133f, -0.14282037f, -0.19662651f, 0.13247885f, 0.54868102f, 
    0.07790045f, 0.45853803f, 0.09114719f, -0.26435891f, -0.13063468f, -0.30678812f, 0.11774185f, 0.48224014f, 
    0.62176269f, 0.21204875f, -0.07532886f, 0.28782800f, 0.35464796f, 0.47314468f, -0.03022709f, 0.18771261f, 
    0.26035762f, 0.07780671f, -0.31719330f, 0.08943798f, 0.07368585f, 0.60681140f, 0.06524653f, 0.07616690f, 
    0.33354366f, -0.08535758f, -0.10429858f, 0.47415456f, 0.11270750f, 0.40124848f, -0.36912975f, 0.53022724f, 
    0.40289688f, 0.31565833f, 0.26244330f, -0.13351244f, 0.79294330f, -0.27338722f, 0.23565309f, -0.12028129f, 
    -0.66592896f, 0.62541425f, 0.32471776f, 0.16466354f, 0.10995480f, -0.01482252f, 0.39326724f, -0.10529898f, 
    0.42782792f, 0.23932806f, 0.01387839f, 0.08787156f, 0.37650582f, -0.14898381f, 0.57619715f, -0.04457583f, 
    0.08290763f, -0.04142584f, 0.04519475f, 0.07836989f, -0.24627046f, -0.29263633f, 0.00934994f, -0.20414317f, 
    -0.01041913f, 0.54502940f, 0.16279042f, -0.00428167f, -0.19853757f, 0.19416533f, -0.06869828f, 0.50621969f, 
    0.20885973f, -0.21637242f, 0.10267820f, 0.24466771f, 0.05000794f, -0.00519130f, 0.20815787f, 0.01760783f, 
    0.26716909f, -0.14553420f, -0.18812293f, 0.02840323f, 0.03824965f, -0.07097921f, 0.19231661f, 0.25898418f, 
    0.38064525f, -0.10010506f, 0.04546747f, 0.00996448f, 0.13879573f, -0.04681175f, 0.15574586f, 0.39562577f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.07016790f, -0.00820753f, -0.04514787f, -0.41942015f, -0.72347176f, 0.09092911f, 0.01597966f, 0.48202625f, 
    -0.06759875f, 0.22190470f, -0.02147423f, 0.39431307f, 0.07125923f, -0.22392428f, 0.14201631f, -0.10817453f, 
    -0.48277140f, -0.27546185f, 0.06094192f, 0.05454057f, -0.05704338f, -0.04328195f, 0.06782631f, -0.14138845f, 
    -0.84713817f, 0.13902812f, 0.08810239f, 0.19379070f, 0.01487379f, -0.50496179f, 0.27294582f, 0.41810870f, 
    0.07410171f, -0.39881486f, -0.62041366f, 0.08499848f, -0.18357904f, -0.19471601f, 0.19094796f, -0.48805636f, 
    0.28716087f, 0.00409206f, -0.02194664f, 0.37430108f, -0.47102439f, 0.04738034f, 0.18596256f, 0.03952693f, 
    -0.11518174f, -0.74362195f, 0.27376944f, -0.00585501f, 0.24975437f, 0.27102974f, 0.30223450f, -0.04754594f, 
    -0.28349245f, -0.11681623f, 0.43337199f, 0.13958547f, 0.01467432f, 0.14584854f, 0.05011327f, 0.06841642f, 
    0.01419654f, 0.10749778f, -0.01866257f, -0.02675146f, 0.16625637f, -0.12433301f, 0.11226813f, 0.22240855f, 
    -0.99662852f, 0.17287025f, -0.39236990f, -0.13231066f, -0.16187593f, 0.22178504f, 0.16968367f, 0.37462258f, 
    -0.20825249f, -0.22564703f, 0.40126699f, 0.13610208f, 0.01631263f, 0.00654001f, 0.27802566f, 0.06699695f, 
    -0.06457867f, -0.12853502f, -0.86920893f, -0.48778552f, 0.05811768f, -0.85248417f, -0.05336184f, -0.00510350f, 
    -0.18064438f, 0.26227427f, -0.41111359f, 0.08182732f, -0.34698519f, -0.54301828f, 0.06650098f, -0.11174907f, 
    -0.58987260f, -0.79172915f, 0.44929710f, -0.00560462f, 0.14489059f, -0.21225831f, -0.35605383f, -0.06435688f, 
    -0.99928671f, 0.23209541f, 0.14136972f, 0.23871426f, -0.47024155f, -0.13986857f, 0.21468908f, -0.61655462f, 
    -0.42548442f, -0.22588222f, -0.26962802f, -0.25379753f, 0.15125956f, -0.04467145f, 0.38369375f, 0.17927445f, 
    -0.09517509f, -0.25311306f, -0.02934210f, 0.11747897f, 0.26222759f, 0.07203027f, 0.22075801f, 0.21595022f, 
    -0.44433975f, 0.04136965f, -0.15362239f, 0.25730476f, -0.07903865f, -0.49964398f, -0.06650814f, 0.14910170f, 
    -0.24570881f, -0.17169984f, -0.18084271f, 0.14618649f, -0.40772489f, -0.03586182f, -0.21680576f, -0.38078594f, 
    -0.15188049f, -0.45241126f, 0.02376868f, -0.17026697f, -0.00061745f, 0.18193790f, -0.97326171f, 0.18716952f, 
    0.03688473f, -0.13780598f, -0.65805554f, 0.15132038f, 0.06425636f, 0.07038490f, 0.26531935f, 0.26070029f, 
    0.09969724f, 0.03894458f, -0.18079048f, 0.07759140f, 0.06442829f, 0.21835721f, 0.08398747f, -0.03250229f, 
    0.15529864f, -0.08852202f, -0.66181874f, 0.18384148f, -0.12558323f, 0.00346549f, -0.06379794f, -0.06372088f, 
    -0.00854576f, 0.06009943f, -0.29979998f, -0.34417215f, -0.07740273f, -0.23832309f, 0.20458846f, 0.13996629f, 
    0.06824829f, 0.01409073f, -0.18972416f, -0.00468477f, 0.14378439f, -0.14811175f, 0.19124691f, 0.01495583f, 
    0.68448436f, -0.05213400f, -0.07121052f, 0.05897977f, -0.12973203f, 0.07437202f, -0.04898644f, -0.01149687f, 
    -0.05680435f, 0.25276017f, 0.07332432f, 0.18835564f, -0.03229871f, 0.04337554f, 0.21419768f, -0.00234330f, 
    0.07838324f, 0.01946689f, 0.51398093f, -0.42073032f, -0.15976037f, -0.05718810f, 0.01938800f, -0.64655834f, 
    -0.31038773f, 0.28461930f, 0.35432264f, 0.16456033f, 0.35983157f, -0.33768505f, -0.04695137f, -0.00507307f, 
    -0.02033846f, -0.22552450f, -0.37839082f, -0.06110720f, 0.09965792f, 0.43812168f, 0.03474412f, 0.03320220f, 
    0.19983284f, -0.04908256f, -0.28908214f, 0.08806339f, 0.09849904f, 0.09767128f, -0.31342599f, -0.27898291f, 
    -0.49404651f, -0.03821722f, -0.49537304f, 0.62110525f, 0.10126203f, 0.19817227f, -0.12221189f, 0.08679146f, 
    0.00730608f, -0.05410528f, -0.12680304f, -0.33430588f, -0.40052631f, -0.18326022f, 0.19507429f, 0.23480108f, 
    -0.00908573f, -0.46369514f, 0.35197771f, -0.64003569f, 0.08688372f, -0.11851839f, -0.92202884f, -0.90066922f, 
    -0.86121756f, 0.21270497f, -0.03484248f, 0.02761546f, -0.14367606f, -0.23037869f, -0.16438600f, -0.20674558f, 
    0.18151703f, 0.23828727f, 0.20969467f, -0.76481450f, 0.01695297f, 0.18204501f, -1.04017317f, 0.26235154f, 
    -0.01121354f, -0.20344564f, 0.22867492f, 0.25974134f, 0.27021036f, 0.30065432f, -0.65269411f, 0.09078933f, 
    -0.54667658f, 0.10800789f, 0.35526139f, 0.12792042f, -0.30811170f, 0.00053905f, 0.35090235f, -0.03097573f, 
    -0.24397375f, 0.59753299f, -1.55525744f, -0.13109703f, -0.27671057f, -0.25167638f, 0.28154868f, -0.14381881f, 
    0.09921915f, -0.73207468f, 0.05453047f, -0.49392843f, -0.05679067f, -0.65599608f, 0.22744110f, -0.61810672f, 
    0.20772058f, -0.39790443f, 0.14583610f, -0.03243560f, 0.06871986f, -0.45515731f, -0.41010979f, 0.22474444f, 
    -1.00552988f, 0.02264462f, 0.16094819f, 0.36832464f, 0.16688462f, -0.23032975f, 0.11407250f, -0.05346414f, 
    -0.04059267f, -0.58338314f, 0.27251777f, 0.21265717f, -0.41913843f, -0.05244798f, 0.04781570f, 0.35489213f, 
    -0.06453393f, -0.33228612f, -0.19501863f, 0.08651377f, -1.07045615f, 0.24584951f, -0.01693345f, -0.56400079f, 
    0.00966876f, -0.24873330f, 0.30862364f, -0.14956379f, 0.11640864f, -0.36500394f, 0.06363048f, -0.34284049f, 
    -0.33782947f, -0.24817087f, 0.14405547f, -0.38924405f, 0.06634867f, -0.04444162f, -0.18757498f, -0.30140737f, 
    -0.30621514f, 0.16517010f, -0.68130481f, -0.25892508f, -0.31931132f, 0.12743157f, -0.34958023f, 0.42892456f, 
    -0.30819777f, 0.16372707f, -0.14257894f, -0.32410428f, 0.30644566f, -0.09636784f, -0.00992931f, -0.78964639f, 
    0.06882271f, -0.08369310f, -0.42035747f, 0.17558298f, 0.46114245f, -0.35429007f, -0.00742859f, -0.56075805f, 
    -0.34534717f, -0.53518045f, -0.28908268f, 0.07742485f, 0.21531227f, -0.70508760f, 0.15262806f, 0.10487462f, 
    -0.01048578f, 0.26784581f, 0.03146726f, -0.30808234f, 0.48676986f, -0.04363313f, 0.07670497f, 0.05917336f, 
    0.48804173f, 0.09806015f, -0.48859796f, 0.28109321f, -0.03272593f, 0.28915879f, 0.46905929f, -0.30671227f, 
    -0.68139803f, 0.03415200f, -0.22879490f, 0.17108990f, 0.10327221f, 0.11656911f, 0.13497166f, -1.00123596f, 
    0.18450224f, 0.17911170f, -0.07344145f, -0.07073820f, -1.64772773f, 0.27368978f, -0.30747175f, 0.03324481f, 
    -0.16897637f, -0.16921280f, 0.55727851f, -0.15769245f, -0.56005836f, -0.22052200f, -0.16813336f, 0.08678605f, 
    0.15370448f, 0.28533179f, 0.08178257f, 0.21048246f, -0.04362291f, 0.01984251f, 0.16481330f, -0.32667661f, 
    0.03130391f, -0.53875560f, 0.24128458f, 0.05459277f, -0.47039694f, -0.04022089f, -0.47616738f, 0.24560684f, 
    -0.31706852f, -0.28163683f, 0.27061769f, -0.10093603f, 0.00231274f, -0.37518930f, 0.21533647f, 0.02374714f, 
    0.08832378f, 0.21675876f, -0.49293742f, -0.29003903f, 0.16410688f, 0.00760126f, -0.26248455f, -0.44800693f, 
    -0.03404898f, -0.52334338f, -0.29609141f, 0.03486420f, 0.05649605f, 0.13198864f, 0.01731663f, 0.58674657f, 
    0.02053704f, 0.19000533f, -0.06603580f, -0.60024011f, -0.19562310f, -0.60875005f, 0.00199122f, -0.31580344f, 
    0.00297726f, 0.11698258f, -1.08413219f, 0.27531227f, -0.48446926f, 0.17614414f, 0.21907777f, 0.14731131f, 
    0.18442070f, -0.17268725f, -0.24120949f, -0.04916873f, 0.04996779f, -0.19204856f, -0.09671053f, 0.17570746f, 
    -0.08789977f, -0.30209631f, 0.17080267f, -0.32078353f, -0.53846729f, 0.34582970f, 0.13960174f, -2.19592977f, 
    -0.08642154f, 0.30930433f, -0.08874281f, 0.21240424f, 0.85206681f, 0.11099295f, -0.34497088f, -0.06607006f, 
    0.03490171f, -0.20882985f, -0.02399779f, -0.38226742f, 0.03000602f, -0.16772716f, 0.08968331f, -0.04578448f, 
    -0.20020376f, -0.07787447f, -0.01183796f, -0.63938248f, 0.33325872f, -0.52047336f, -0.03704751f, 0.02154715f, 
    0.58816659f, -0.03165499f, -0.21045914f, 0.16270746f, -0.03061462f, -0.31650510f, -0.91601551f, -0.05086307f, 
    -0.23518625f, 0.10612466f, -0.49382144f, 0.10257803f, -0.32045007f, 0.02087268f, 0.03339849f, -0.07065502f, 
    0.23269866f, 0.05238947f, -0.31733048f, 0.08326048f, -0.53274208f, 0.01837947f, -0.52421498f, 0.02277640f, 
    -0.53205466f, 0.07818774f, -0.03873340f, 0.16303842f, 0.11333492f, -0.00203779f, 0.01474231f, 0.08057506f, 
    0.29181916f, 0.04465405f, -0.64892763f, 0.24625085f, 0.00629254f, 0.20589077f, -0.41225645f, 0.00918965f, 
    0.17025262f, 0.12023135f, 0.14072824f, -0.07577527f, 0.06030403f, 0.19905448f, 0.35457450f, 0.02019095f, 
    -0.41887009f, 0.15903628f, 0.11564322f, -0.16668123f, 0.08278364f, 0.14501193f, 0.13985734f, -0.25845757f, 
    -0.07235583f, 0.19060017f, -0.18783928f, -0.16040000f, 0.01059289f, -0.01705862f, -0.11176181f, 0.28703257f, 
    0.03760473f, 0.03872167f, 0.49776423f, 0.09768105f, -0.31413230f, -0.45511290f, 0.02017727f, 0.00610562f, 
    0.16252667f, -0.11099602f, -0.32468116f, -0.12348440f, -0.26881665f, -0.55225796f, -0.08852044f, 0.14731961f, 
    -0.28370994f, -0.20874284f, -0.47511643f, -0.37539187f, -0.00554036f, -0.00411173f, -0.14485918f, 0.02797319f, 
    -0.76258534f, -0.03377787f, 0.15551555f, 0.06981590f, 0.11301652f, 0.05023357f, -0.15996113f, 0.08308046f, 
    -0.50356591f, -0.15050496f, 0.22397858f, -0.12292436f, -0.10386591f, -0.27526474f, 0.21462694f, -0.08135597f, 
    -0.03666374f, -0.05090630f, 0.00017417f, 0.15640189f, 0.28166372f, 0.21270792f, -0.62895280f, -0.33336976f, 
    0.33458108f, -0.49458739f, 0.10709594f, 0.14188579f, -0.38495547f, -0.18511915f, 0.17615017f, 0.03782718f, 
    0.47156918f, -0.31128901f, -0.00008688f, 0.21460341f, -0.40315935f, 0.32082793f, 0.01946151f, -0.07402761f, 
    -0.68255991f, -0.24866039f, 0.13711798f, -0.64466864f, -0.01454686f, -0.21452004f, 0.02781061f, 0.13688959f, 
    0.23118745f, 0.10824671f, -0.01802985f, -0.26565111f, -0.24268807f, -0.24054298f, -0.06736650f, 0.19578953f, 
    -0.15798171f, 0.10621680f, 0.07800844f, 0.13241774f, 0.31211218f, 0.04869898f, -0.26839164f, 0.03496080f, 
    0.29177818f, -0.04696581f, 0.70021725f, 0.20331587f, -0.05183428f, 0.05675972f, -0.25107318f, 0.23844586f, 
    -0.16142501f, -0.00514851f, -0.24043025f, -0.02434774f, -0.08200654f, 0.09078525f, -0.18385820f, 0.20834637f, 
    0.02604867f, 0.04459064f, -0.29214793f, -0.03872769f, 0.03999229f, 0.11375332f, -0.02057161f, -0.59557927f, 
    0.04533939f, 0.12230098f, -0.35445923f, -0.03501726f, -0.50968969f, 0.09242683f, -0.04763667f, -0.47719193f, 
    -0.11540124f, -0.59501618f, 0.06914324f, 0.01273017f, -0.06669082f, 0.03630201f, -0.06664766f, -0.21376878f, 
    -0.07904520f, 0.15157470f, -0.53369850f, -0.07084469f, -0.01368103f, -0.02507108f, 0.06545158f, -0.09122971f, 
    -0.25042176f, -0.03260408f, -0.15861078f, 0.00121560f, 0.00196345f, 0.39790425f, -0.04111324f, 0.10298187f, 
    0.02467379f, 0.26948741f, -0.06128437f, -1.02510405f, -0.02673720f, -0.01860422f, 0.05344147f, 0.05938454f, 
    0.23335321f, -0.06355989f, 0.01582250f, 0.08596873f, 0.54286420f, -0.09366459f, 0.10001595f, -0.73131019f, 
    0.42109245f, 0.07891355f, 0.01166575f, 0.21926130f, 0.00303280f, -0.53271508f, -0.22141439f, 0.15777680f, 
    -0.07638142f, 0.02816888f, 0.09478927f, -0.73634279f, -0.43642923f, -0.05278470f, -0.28738332f, -0.63049614f, 
    -0.35394946f, 0.08310576f, -0.56453526f, 0.28242478f, 0.16396452f, 0.20490733f, -0.53989267f, -0.50212872f, 
    -0.05223519f, 0.01233411f, 0.20519328f, -0.04162592f, 0.16801131f, -0.50934488f, -0.16038725f, 0.27353743f, 
    -1.06812668f, 0.15280673f, -0.08283748f, -0.04981927f, 0.05523058f, 0.04468279f, 0.16780393f, -0.17957480f, 
    0.19887160f, 0.09206674f, -0.24471250f, -0.08491750f, -0.22599642f, 0.14530449f, -0.40350097f, -0.06486055f, 
    -0.07221555f, 0.15457216f, -0.14702633f, -0.31619415f, -0.03667172f, -0.14779206f, -0.20226744f, -0.08668547f, 
    -0.38856307f, 0.11927295f, -0.35017505f, -0.05787905f, -0.17141052f, -0.02621962f, -0.36299738f, -0.10589466f, 
    -0.04747069f, 0.22604933f, -0.15678410f, 0.22948968f, -0.05565469f, 0.24861431f, 0.18026981f, 0.13800202f, 
    -0.04334714f, 0.24209017f, 0.22560738f, -0.05115959f, -0.10086595f, 0.13944881f, 0.08081577f, 0.15873654f, 
    -0.36118346f, 0.22090253f, -0.29848161f, 0.00622143f, -0.39987940f, -0.00282709f, -0.07616986f, 0.13119604f, 
    -0.14836961f, -0.29878893f, -0.23181520f, -0.25888634f, 0.08983591f, 0.08343978f, -0.29846048f, 0.06605049f, 
    0.03936823f, 0.00736155f, -0.57833171f, 0.41310483f, -0.28955519f, 0.17309760f, 0.00923790f, 0.57000053f, 
    0.19971257f, -0.41926584f, -0.29549655f, -0.18497898f, -0.09992567f, 0.05206069f, 0.02476294f, 0.14482282f, 
    -0.18298492f, 0.13593398f, -1.27800906f, -0.54781407f, -0.04871832f, -0.38070962f, 0.10611528f, 0.04004978f, 
    -0.05803621f, 0.00707208f, 0.23441346f, 0.00524854f, -1.08550751f, 0.11080820f, -0.02534033f, -0.08948030f, 
    -1.27965844f, 0.13755053f, 0.20316978f, 0.00132616f, 0.12811983f, -0.04647377f, -0.51138073f, -0.28613037f, 
    -0.07066398f, 0.37633872f, -0.22348906f, 0.00657249f, -0.04392694f, 0.03017150f, 0.10246311f, -0.29642469f, 
    -0.30862099f, -0.26487109f, 0.48225203f, 0.09270198f, -0.11405358f, 0.21543793f, 0.19651377f, 0.26018023f, 
    0.24855025f, -0.16443628f, 0.15752487f, -0.47567889f, 0.11795530f, 0.34096694f, 0.16052036f, 0.14903975f, 
    -0.08189740f, -0.12584092f, 0.25761575f, -0.01032876f, -0.01078801f, -0.29333320f, 0.36215842f, -0.55493200f, 
    -0.29397997f, -0.76158285f, 0.55768776f, 0.15608530f, -0.20125817f, -0.02286109f, 0.06332688f, -0.41387910f, 
    -0.46970186f, -0.54618067f, -0.10487003f, -0.01987153f, 0.21713050f, -0.14360380f, 0.16479138f, 0.02988933f, 
    -0.06553877f, 0.30394799f, 0.34155098f, 0.04521422f, 0.13118148f, -0.58389539f, 0.02374499f, -0.18907103f, 
    -0.42613161f, 0.07031857f, 0.23491338f, -0.25397402f, 0.06797907f, -0.55392253f, -0.06035459f, -0.95518738f, 
    -0.06941807f, -0.77765948f, -0.12362490f, -0.03490443f, -0.59942943f, -0.01412765f, 0.58559531f, -0.07659200f, 
    0.33075273f, -0.54806608f, 0.09397414f, -0.69405234f, 0.07979176f, 0.04419550f, 0.05215001f, 0.24097909f, 
    -0.61450833f, 0.17156404f, -0.04677618f, -0.10682888f, -0.54517806f, 0.06011920f, -0.38870364f, 0.18314210f, 
    -0.08385955f, 0.27427477f, 0.31371868f, 0.08519005f, 0.00797275f, -0.30433065f, -0.08128022f, -0.09799530f, 
    0.10852684f, -0.25326863f, 0.13193920f, -0.04326678f, -0.22923338f, -0.36380774f, -0.05065460f, -0.12992342f, 
    -0.17370582f, -0.05388355f, -0.17901932f, 0.09408275f, -0.23347768f, 0.05817541f, -0.23143339f, 0.06105988f, 
    -1.01987314f, -0.25338051f, 0.05173353f, -0.03973338f, 0.22362599f, -0.29687366f, 0.03911802f, -0.01919937f, 
    0.03190996f, -0.06804245f, 0.04501120f, -0.01325162f, -0.39001769f, -0.52505440f, 0.09783825f, 0.59858441f, 
    -0.05361987f, -0.45104900f, 0.27844298f, -0.51891160f, -0.47138879f, 0.04576597f, 0.12790713f, 0.02591595f, 
    0.13742068f, -0.10792426f, 0.54839456f, 0.47116315f, 0.02682360f, -0.76133502f, -0.22193581f, -0.34988886f, 
    0.02469391f, 0.07043952f, -0.63162851f, -0.15588105f, -0.18371250f, 0.03821329f, 0.26486602f, -0.37359393f, 
    0.41570082f, -0.38741142f, 0.06597616f, 0.35478285f, 0.05210799f, -0.16069880f, -0.22176845f, -0.77360106f, 
    -0.05322767f, -0.00983647f, 0.26138359f, -0.18517557f, 0.18813124f, -0.19888450f, -0.06398603f, -0.05547083f, 
    -0.60272503f, -1.04397368f, 0.02521424f, -0.09392269f, 0.01535630f, -0.29063597f, -0.11603514f, 0.05986553f, 
    0.31020904f, -0.20165697f, -0.70266306f, 0.15987268f, 0.16617559f, 0.21399549f, 0.21338251f, -0.01373598f, 
    -0.10197141f, -0.30595729f, -0.04653174f, -0.19420363f, -0.01191765f, -0.12675244f, -0.31990278f, -0.67626756f, 
    -0.59089404f, -0.38205877f, -0.60947841f, 0.01383609f, -0.01643273f, 0.33188227f, -0.51541114f, -0.75196010f, 
    -0.07076087f, 0.03387691f, 0.05319839f, -0.00816517f, 0.12884298f, 0.28022933f, -0.23536004f, 0.15160105f, 
    0.21964227f, -0.19948153f, -0.21256366f, 0.21964078f, -0.14658907f, -0.03560796f, 0.19549276f, 0.10618154f, 
    0.05976607f, 0.23915024f, -0.24668223f, -0.22352470f, -0.53192204f, 0.05929050f, 0.02405709f, 0.09995580f, 
    -0.05741168f, 0.18667842f, 0.18105523f, 0.02761869f, 0.01489111f, 0.02592754f, -0.13297147f, -0.35012731f, 
    0.34354663f, 0.23102981f, 0.14664659f, 0.00022188f, 0.11220337f, 0.12340303f, -0.49574032f, 0.17919149f, 
    0.07885855f, 0.09239279f, -0.30940884f, -0.34698200f, -0.63482922f, 0.00979013f, -0.47914076f, -0.06097188f, 
    -0.06762120f, 0.19844706f, -0.56035101f, -0.35478914f, -0.23026897f, 0.18305081f, -0.16026174f, 0.35281983f, 
    0.07913918f, 0.16258928f, 0.19025452f, -0.36798352f, 0.04941823f, 0.13340068f, -0.37987119f, -0.07382014f, 
    0.21668504f, 0.39360178f, -0.88321561f, -1.23753703f, 0.12544656f, 0.17936845f, -0.01721952f, -0.17302458f, 
    0.59652114f, 0.16550906f, 0.10521895f, -0.04896015f, -0.32029915f, 0.30742383f, -0.14024763f, -0.03464786f, 
    0.22347413f, 0.13756593f, 0.21072404f, 0.14176077f, -0.02418534f, -0.25888959f, -0.30815199f, 0.07542529f, 
    -0.04562628f, 0.28061613f, 0.41316825f, -0.75005525f, -0.62150097f, -0.60489982f, -0.33681190f, 0.11413322f, 
    -0.73052883f, 0.08782046f, -0.56164080f, 0.10483526f, -0.05458652f, -1.10625410f, -0.11084006f, -0.03800861f, 
    -0.14347485f, 0.19455770f, -0.80551678f, 0.09865212f, 0.21343932f, -0.33047241f, -0.00192507f, -0.56685597f, 
    -0.08229177f, -0.42139944f, -0.89834011f, -0.01300983f, -0.02280057f, 0.09632966f, -0.04650458f, -0.08748876f, 
    0.12717199f, 0.16439384f, 0.11596657f, 0.01022880f, 0.05305532f, 0.19876435f, -0.73792881f, -0.29319239f, 
    0.08830167f, -0.02477893f, -0.21026637f, 0.05151162f, -0.02246050f, 0.10055959f, -0.31237260f, 0.03805613f, 
    0.12489165f, -0.35886642f, 0.07841343f, -0.34842795f, 0.19454803f, -0.07642677f, -0.25950241f, 0.05634256f, 
    -0.03781655f, 0.12727867f, -0.18962607f, 0.10475635f, 0.13233586f, 0.04764046f, -0.04744041f, -0.11033239f, 
    0.13495682f, -0.06808019f, -0.42718369f, -0.50971574f, 0.13460572f, -0.69112349f, 0.08123349f, 0.21722113f, 
    -0.06377046f, -0.45483056f, -0.28277576f, -0.08310230f, -0.03843510f, -0.76653808f, -0.11293148f, -0.40030274f, 
    0.38369155f, -0.11030132f, -0.10036319f, -0.23898594f, 0.55706155f, 0.04107298f, -0.33245528f, 0.25120690f, 
    0.40534121f, 0.13182433f, 0.03233786f, -0.61737239f, 0.03692837f, -0.64345056f, -0.08363571f, 0.18548967f, 
    -0.02146835f, -0.51624739f, -0.19604519f, 0.31851998f, -0.07352924f, -0.17131850f, 0.24728602f, -0.42672095f, 
    0.20430154f, 0.90122700f, -0.48061302f, -0.11602415f, 0.01931535f, -1.44643569f, -0.01226771f, 0.03834581f, 
    -0.37306225f, -0.01457536f, -0.40116537f, 0.21525660f, -0.13281791f, -0.56944120f, 0.06536335f, 0.07757627f, 
    0.11756641f, 0.12880619f, -0.79611385f, -0.03131350f, -0.07742518f, 0.22459044f, 0.12899974f, -0.07637873f, 
    -0.19118963f, -0.06864882f, -0.03910311f, 0.08584698f, 0.32663301f, -0.05264974f, -0.08731017f, 0.15927960f, 
    0.21247333f, -0.32225034f, 0.24512678f, -0.46421245f, 0.03969745f, 0.20955920f, 0.18473393f, -0.06534286f, 
    0.31084144f, -0.00335543f, -1.17553747f, -0.50218797f, -0.60407627f, 0.21772489f, -0.04321698f, -0.02834303f, 
    0.06521478f, -0.31571242f, 0.53816831f, 0.17308967f, -0.02815524f, -0.17000069f, 0.33224130f, -0.34626037f, 
    -0.12669511f, -0.85586250f, 0.07018104f, -0.09202924f, -0.12322631f, -0.54488522f, -0.07960383f, 0.00133130f, 
    -0.65935582f, 0.05109477f, 0.28669941f, 0.08627851f, 0.17247882f, -1.04494572f, 0.10929679f, -0.43478534f, 
    0.14268199f, 0.12383032f, -0.49765429f, 0.28098586f, 0.08760653f, -0.05419458f, 0.20843281f, -0.47273961f, 
    -0.06295240f, -0.71775419f, -0.07704206f, -0.03717379f, -0.18022352f, 0.07996402f, 0.03756268f, -0.30588698f, 
    -0.02457177f, 0.30421197f, 0.31885555f, 0.14407401f, -0.01628261f, -0.23839626f, -0.07887131f, -0.03185245f, 
    0.32957804f, 0.02973211f, 0.40642500f, 0.20288491f, -0.15278885f, 0.16126961f, 0.05632172f, 0.10820788f, 
    0.26737800f, -0.18719667f, -0.43298376f, -0.25034750f, 0.13074152f, -0.05061603f, 0.31192014f, 0.09812402f, 
    0.67881078f, -0.07185254f, -0.08177336f, -0.03157230f, -0.03221111f, 0.22011670f, 0.03169714f, -0.29518396f, 
    -0.01338904f, -0.22841722f, 0.02863264f, -0.09967308f, -0.74202210f, -0.71542513f, -0.01679965f, -0.14987555f, 
    0.13638425f, -0.37323159f, 0.27067810f, 0.34970590f, -0.27772528f, 0.03158837f, -0.30340022f, -0.30238950f, 
    -0.94384027f, 0.06210206f, 0.07959154f, 0.39087841f, -0.21217100f, 0.48533502f, 0.10818043f, 0.24754383f, 
    -0.21281882f, 0.22984508f, -0.35995752f, -0.02123460f, -0.01762981f, 0.09440594f, -0.79308903f, -0.47406945f, 
    0.18832564f, 0.00169837f, 0.22886005f, -0.24226572f, 0.17107816f, 0.08797184f, -0.19134121f, -0.12986058f, 
    0.12994972f, 0.22379611f, 0.18849199f, -0.64589465f, 0.17769228f, 0.11253545f, 0.14851998f, -0.05486386f, 
    -0.11782114f, -0.12409558f, -0.61543107f, -0.80758184f, -0.31247756f, 0.17068423f, -0.02181770f, 0.03147591f, 
    0.13938996f, 0.13520350f, 0.04253317f, -0.06006109f, -0.03731273f, -0.00039152f, -0.57234120f, 0.16126128f, 
    -0.47047099f, -0.07549147f, 0.07422493f, -0.03467100f, -0.28370532f, -0.01791172f, -0.75467587f, 0.36712068f, 
    0.19004205f, 0.01088073f, -0.03075361f, 0.17330025f, 0.22457141f, -0.53082222f, -0.28343511f, 0.16701281f, 
    0.05696347f, -0.05003821f, -0.22892927f, -0.23195677f, 0.06305879f, -0.04146301f, -0.22043480f, -0.24822469f, 
    0.05539712f, -0.11352053f, -0.36892495f, 0.20590858f, 0.13528453f, 0.21854182f, 0.06115888f, -0.34047407f, 
    0.01079553f, -0.30934352f, -0.04757875f, -1.38099933f, -0.00095886f, 0.60958838f, -0.05816679f, -0.00829213f, 
    0.12743096f, 0.18265456f, 0.59546912f, 0.47272855f, -0.19580725f, -0.13418241f, -0.00403103f, -0.00608832f, 
    -0.76362044f, -0.02057039f, 0.28405955f, -0.35836932f, -0.53155696f, 0.12288656f, 0.31658259f, 0.18491448f, 
    -0.43637630f, 0.08105076f, 0.17453954f, -0.81689018f, -0.03972431f, 0.19765991f, -0.13023567f, -0.11450785f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.10630231f, -0.04935407f, -0.10917051f, -0.23753014f, 0.23795693f, 0.19452845f, -0.12034875f, -0.47434941f, 
    -0.26122689f, 0.01650936f, 0.40125710f, -0.18928973f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
