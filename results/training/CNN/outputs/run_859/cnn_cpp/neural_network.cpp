#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.07329448f, 0.03306146f, -0.50607246f, -0.15770802f, -0.31795520f, 0.29020333f, -0.58699995f, -0.29761097f, 
    -0.24085201f, 0.17119038f, 0.30307624f, -0.15460300f, 0.05208105f, 0.02127632f, 0.01050788f, -0.03226218f, 
    -0.00180512f, -0.17385846f, -0.20331761f, 0.44440377f, 0.19696523f, -0.22901244f, -0.31179205f, 0.35175279f, 
    -0.46768063f, 0.34240821f, -0.62348348f, 0.43011120f, 0.37640351f, 0.47838333f, 0.19945541f, -0.00994155f, 
    0.34877175f, -0.26599503f, 0.20121618f, 0.05370612f, -0.31595185f, -0.26881695f, 0.16343485f, 0.05882762f, 
    0.16043167f, 0.23134866f, -0.12587008f, 0.34496161f, 0.06351758f, 0.18090951f, 0.17347273f, 0.08355018f, 
    0.07211778f, 0.18119231f, -0.36612776f, -0.50522566f, -0.37816614f, 0.21499939f, 0.10697812f, -0.40396681f, 
    0.02072774f, -0.33223274f, 0.46222475f, -0.15457496f, 0.36395934f, -0.26626584f, 0.13695519f, 0.08398312f, 
    -0.34546462f, -0.12674108f, 0.25103033f, 0.45075327f, 0.26985291f, -0.24350339f, -0.23988718f, 0.02941612f, 
    0.01970911f, 0.05675961f, 0.18634161f, -0.59481853f, -0.46425143f, 0.31710261f, 0.35257941f, -0.52360952f, 
    -0.03875289f, -0.23175357f, 0.12552434f, 0.14973730f, 0.02243786f, 0.41329437f, 0.22880666f, -0.40132669f, 
    -0.12288338f, 0.03989496f, 0.30158558f, -0.04834631f, -0.24867639f, 0.18269174f, -0.10262036f, 0.11411241f, 
    0.09207035f, 0.21691899f, 0.21405631f, 0.19420736f, -0.12068115f, 0.09531832f, 0.30744278f, -0.44357759f, 
    -0.39926845f, -0.39834005f, 0.50927198f, -0.13964580f, 0.26483405f, -0.40607738f, -0.21420719f, 0.32394481f, 
    -0.24462718f, -0.02112393f, 0.01575528f, -0.10324806f, -0.22499299f, 0.37523532f, 0.15505691f, 0.05470730f, 
    0.16221693f, 0.01743461f, -0.25718606f, -0.15944514f, -0.18983555f, -0.20078708f, -0.42686525f, 0.17715347f, 
    -0.40386352f, -0.33891022f, -0.05647587f, -0.50528342f, 0.01179163f, -0.53905612f, -0.49482900f, -0.26779535f, 
    0.23680739f, -0.06194734f, -0.17138723f, 0.18692560f, 0.18345962f, 0.25940010f, -0.00507112f, 0.15693478f, 
    0.14824107f, 0.08269759f, -0.05835209f, 0.28377846f, 0.07276229f, 0.25044966f, -0.83988243f, -0.22071987f, 
    -0.12956940f, -0.02611512f, -0.34303755f, 0.48992673f, 0.60186231f, -0.17812577f, 0.33679348f, 0.05662221f, 
    -0.28621402f, -0.48923147f, 0.29293489f, -0.25183892f, 0.27043861f, -0.17395619f, -0.03556478f, -0.16148610f, 
    -0.17574744f, -0.15477145f, 0.03859703f, -0.12637830f, 0.03459666f, -0.00559856f, -0.16060893f, -0.33809796f, 
    -0.58171433f, -0.06156198f, 0.46370286f, 0.08974187f, -0.20578852f, -0.56453496f, 0.14678738f, -0.45704690f, 
    -0.23692879f, 0.24011898f, 0.17159325f, 0.35858563f, 0.16422403f, 0.20682682f, 0.15252160f, 0.18845254f, 
    -0.08084086f, -0.03157254f, 0.39112848f, -0.07128058f, 0.17058404f, 0.23502493f, -0.09930765f, -0.12632143f, 
    -0.47200653f, -0.45630711f, -0.04678481f, 0.48430437f, 0.41798201f, 0.18902148f, 0.06988087f, -0.42353892f, 
    0.29502907f, -0.23522533f, 0.17698441f, 0.23534077f, 0.05633516f, 0.11183603f, -0.01879957f, 0.10564049f, 
    0.04715137f, 0.38122630f, 0.25025794f, 0.12573396f, -0.19929005f, 0.19318779f, -0.54915535f, -0.22706565f, 
    0.24958238f, -0.67903423f, -0.12492581f, -0.55412406f, -0.43467262f, 0.21513596f, -0.09988878f, 0.67986447f, 
    0.20686011f, 0.33868930f, 0.51698190f, -0.24307422f, 0.15106741f, 0.38718286f, -0.15685208f, -0.10302922f, 
    -0.02819949f, -0.17527118f, 0.09893635f, -0.18358526f, -0.36484560f, 0.06618320f, 0.01378766f, -0.10698316f, 
    0.09009535f, 0.01486391f, 0.03178072f, -0.01443121f, -0.18863440f, -0.28272003f, -0.06523600f, 0.14715403f, 
    0.54417551f, -0.56387013f, -0.34251174f, -0.00197298f, 0.26204199f, -0.17432517f, -0.18498133f, -0.29687551f, 
    -0.16290186f, 0.00497642f, -0.23419024f, -0.18945885f, 0.21687859f, -0.25172237f, -0.04145614f, 0.00324775f, 
    -0.20323178f, -0.16690253f, 0.38629383f, -0.23399495f, -0.45617750f, -0.37241334f, -0.22528625f, -0.15246798f, 
    -0.05980688f, 0.08135602f, -0.18164903f, 0.50506580f, 0.19477554f, 0.03194790f, -0.05117192f, -0.23601000f, 
    0.11730966f, -0.38596779f, -0.13368353f, 0.25289458f, 0.00611510f, 0.28618693f, 0.36546117f, 0.27304441f, 
    0.18603998f, -0.21196318f, -0.00159923f, 0.08388738f, 0.63925618f, -0.90400004f, 0.39811310f, 0.47479627f, 
    0.39407438f, -0.33147752f, -0.00212875f, 0.13664311f, 0.11033586f, 0.27996734f, 0.10082791f, 0.00721582f, 
    -0.17297347f, 0.12355303f, 0.11214928f, -0.11964409f, -0.10837525f, 0.01804132f, -0.07503105f, -0.11573149f, 
    -0.12929216f, 0.07990868f, -0.05526429f, -0.32704642f, 0.08502030f, 0.38190913f, 0.74792922f, 0.68589437f, 
    0.14410971f, -0.46742392f, -0.49040833f, -0.44603086f, -0.13422705f, -0.51181155f, 0.47791356f, 0.11356647f, 
    0.08787550f, -0.40327835f, 0.16324836f, 0.09874667f, -0.14789614f, -0.11368801f, 0.08381552f, -0.25871536f, 
    0.10046157f, 0.21581374f, 0.15163857f, -0.01632088f, 0.07680195f, 0.11996303f, -0.32463807f, -0.32152745f, 
    0.03246494f, 0.03810020f, 0.17330058f, -0.36672041f, 0.19041561f, 0.41375831f, -0.06435454f, 0.13778390f, 
    0.08194594f, 0.11383592f, 0.24753223f, -0.14511321f, 0.39415824f, 0.00005594f, 0.21691996f, -0.29566363f, 
    0.09911871f, 0.17204040f, 0.04495532f, -0.43514991f, 0.26839867f, 0.29498702f, 0.51925492f, 0.04826596f, 
    0.48677638f, 0.67416352f, 0.23590194f, 0.25021398f, 0.43549469f, -0.03561488f, 0.34679335f, -0.02282800f, 
    0.39278123f, -0.07963626f, 0.17267597f, 0.40124813f, -0.19133300f, -0.37898198f, 0.01158856f, -0.21635383f, 
    0.14951499f, -0.06017830f, -0.16828489f, -0.09997854f, -0.28921053f, 0.18021247f, 0.14709008f, -0.15960389f, 
    -0.23922859f, -0.35362512f, -0.42968288f, -0.30910555f, -0.07286338f, -0.06891276f, 0.42268351f, 0.50335497f, 
    -0.21950352f, 0.04319926f, 0.29063347f, 0.03588461f, 0.08939495f, 0.09102207f, 0.20477405f, -0.15008341f, 
    -0.01699161f, -0.32290068f, -0.20211090f, -0.10584971f, -0.21916696f, 0.13706636f, -0.03090152f, -0.35536921f, 
    0.11087728f, 0.56651098f, -0.14062801f, -0.42737430f, -0.24497515f, -0.32291758f, 0.21065004f, 0.67833054f, 
    -0.02084842f, 0.28973615f, 0.27212349f, -0.13230763f, 0.06332911f, -0.43937454f, 0.10143909f, 0.12191214f, 
    -0.10865071f, -0.36590248f, 0.08412858f, 0.16198814f, 0.11532532f, -0.14638658f, 0.29586810f, 0.38757125f, 
    -0.00415791f, -0.22177467f, 0.35715196f, 0.34519035f, 0.35202199f, 0.44884062f, 0.22001825f, 0.13166812f, 
    0.39783192f, 0.31004888f, 0.42333576f, 0.51748413f, -0.28282106f, 0.08245667f, -0.28245744f, 0.15082851f, 
    -0.47480142f, -0.22821663f, 0.15064785f, -0.15552787f, -0.26015195f, -0.23516135f, 0.24217492f, -0.04546465f, 
    -0.14692514f, -0.06270044f, 0.14968543f, 0.01516224f, -0.42568448f, -0.12640509f, 0.71598691f, 0.05797737f, 
    0.03776355f, 0.21270484f, 0.46858725f, 0.35717431f, 0.04008221f, 0.08913331f, -0.44948456f, -0.10873195f, 
    -0.06766272f, -0.13098927f, 0.11790524f, -0.28025505f, -0.02861263f, -0.31280497f, 0.17888923f, 0.06791683f, 
    0.34432802f, 0.09297922f, -0.06502369f, -0.10699480f, -0.56091917f, -0.11159128f, -0.78138298f, -0.02230974f, 
    0.46419832f, -0.62221557f, 0.84727830f, 0.59590310f, -0.01642324f, 0.38792977f, 0.20477563f, -0.18590118f, 
    0.22062296f, -0.22196820f, 0.35109621f, 0.21859090f, 0.06718821f, -0.24678338f, -0.01425430f, -0.14489059f, 
    0.25918332f, 0.21723418f, -0.16774614f, 0.35715359f, -0.06915188f, -0.01070861f, 0.62815613f, 0.04711521f, 
    -0.06513333f, 0.34762511f, -0.65592110f, -0.41636166f, -0.25599253f, 0.00904292f, -0.20572448f, 0.25453258f, 
    0.08460475f, 0.10127112f, 0.39169329f, -0.06666477f, -0.15594593f, 0.05968133f, 0.28413895f, -0.17700142f, 
    -0.35111746f, 0.01162393f, -0.20035578f, -0.32562885f, 0.23280282f, 0.30428818f, 0.69101858f, -0.41859472f, 
    0.05881369f, -0.40175495f, 0.44514552f, -0.49298519f, 0.28702778f, -0.16289324f, -0.37085035f, 0.08269767f, 
    0.01600171f, 0.08618858f, -0.19528584f, -0.21539062f, 0.22827744f, -0.07377540f, -0.26470870f, 0.12108998f, 
    -0.20640875f, 0.01669949f, -0.44449908f, -0.38089272f, -0.10145846f, -0.09605011f, -0.25065750f, 0.10143785f, 
    -0.21171306f, -0.48058659f, -0.65010166f, -0.06898137f, -0.14246081f, 0.13463196f, 0.26288542f, 0.09646529f, 
    -0.32409325f, -0.45969459f, -0.04558806f, -0.28382125f, -0.00875456f, -0.32154381f, -0.06309128f, 0.14926730f, 
    0.09030958f, -0.07270958f, 0.27325141f, -0.28935263f, -0.15206967f, -0.27041513f, 0.18092881f, -0.22545782f, 
    0.43834439f, 0.45951971f, -0.22186233f, 0.83434790f, 0.76403099f, 0.33696190f, -0.33265460f, -0.47258872f, 
    0.25926957f, 0.03209517f, -0.01609662f, 0.22340164f, 0.17004937f, 0.07032598f, -0.02937624f, 0.04857539f, 
    -0.04227808f, 0.11796352f, -0.05219223f, 0.09960341f, -0.10481373f, 0.08010342f, 0.27393469f, -0.02088664f, 
    -0.03864867f, 0.94138491f, -0.09726677f, -0.83808607f, 0.69018656f, 0.08435825f, -0.46711013f, 0.25985774f, 
    -0.11541751f, 0.36865118f, -0.16475111f, 0.06780799f, -0.17804341f, 0.08639154f, -0.01864382f, -0.03370753f, 
    0.15476114f, -0.03227824f, -0.19731688f, 0.03515166f, 0.38722506f, -0.00553630f, 0.13316663f, 0.08493350f, 
    0.07090873f, 0.32424423f, 0.17958122f, 0.64442831f, 0.54581541f, 0.26342586f, -0.03813416f, -0.29268953f, 
    0.37694094f, -0.12775998f, 0.02248967f, -0.05723008f, -0.11290579f, -0.02770786f, 0.19555056f, 0.20723557f, 
    0.25252226f, 0.08540585f, -0.31306997f, -0.01350349f, -0.07754271f, 0.15274580f, -0.14906362f, 0.23406465f, 
    -0.16136062f, 0.22745177f, -0.00273514f, 0.81288177f, 0.10171872f, 0.37016866f, 0.46984354f, 0.19968496f, 
    -0.18518661f, 0.01912513f, -0.17620876f, 0.21610528f, -0.13514847f, 0.24105878f, 0.26120436f, -0.16732946f, 
    -0.11537430f, -0.14542241f, -0.25397119f, 0.05086211f, 0.29098505f, -0.03733977f, -0.27314690f, 0.29747546f, 
    0.29627040f, -0.12243269f, 0.08430686f, 0.07701278f, 0.44013679f, 0.02522614f, 0.71862280f, 0.49055445f, 
    0.22505765f, 0.36456898f, 0.09531628f, -0.33825853f, -0.48188198f, 0.05077662f, 0.38261145f, 0.30624607f, 
    -0.09314254f, -0.08060622f, 0.12598927f, -0.22268605f, 0.24074930f, -0.14431532f, 0.00489069f, 0.05123688f, 
    0.06682361f, 0.17175713f, 0.19242436f, 0.09777718f, 0.23564458f, 0.12036023f, -0.54346913f, 0.25099117f, 
    0.52399772f, 0.33231837f, -0.16614993f, -0.21255341f, 0.22696984f, 0.34429240f, -0.29477903f, 0.16806760f, 
    -0.43814749f, -0.37421161f, -0.00378771f, 0.01592851f, 0.31024632f, -0.03211726f, 0.28448772f, -0.06319121f, 
    0.08908692f, 0.06445289f, -0.33358395f, 0.05080403f, -0.15491827f, -0.32745019f, -0.04151961f, 0.25492364f, 
    -0.44815078f, -0.52008885f, -0.10880540f, 0.06455692f, -0.22464000f, -0.39673027f, -0.35234466f, -0.41717169f, 
    0.15984142f, -0.05927549f, 0.29556751f, 0.17858444f, 0.11005141f, 0.33583650f, -0.12657915f, -0.23243953f, 
    -0.14962377f, 0.15297042f, -0.11539230f, 0.11000036f, 0.18919910f, -0.26418415f, 0.04553903f, 0.01877237f, 
    -0.22669148f, -0.60573190f, 0.34454688f, 0.14419800f, -0.15702209f, -0.36014524f, 0.17117542f, -0.31758770f, 
    -0.36626527f, -0.33921099f, -0.13519840f, -0.00899773f, 0.18943542f, -0.09843143f, 0.26692232f, -0.27782592f, 
    -0.52693707f, -0.34233928f, -0.30341846f, -0.26903373f, 0.20901795f, 0.25745794f, 0.24441043f, 0.14158674f, 
    -0.26720876f, -0.35375315f, -0.52591175f, -0.32099831f, -0.44344535f, 0.15352261f, -0.31360495f, -0.15077995f, 
    -0.06588748f, 0.18010890f, -0.18535784f, 0.26262161f, -0.17999044f, 0.06677708f, 0.16549477f, -0.10388665f, 
    0.24748205f, -0.15465747f, -0.00100619f, 0.09873657f, -0.04517474f, 0.16587260f, 0.20528799f, 0.04408939f, 
    0.23758550f, -0.33631653f, 0.27358446f, -0.45749596f, -0.33257547f, -0.03208597f, -0.10470764f, -0.55834854f, 
    0.04642337f, 0.51886541f, -0.33253130f, -0.13314047f, 0.29731753f, -0.15389237f, 0.12810981f, 0.16850293f, 
    0.09457911f, 0.27096248f, -0.24543779f, -0.17165500f, -0.07063869f, -0.26190478f, -0.08596428f, 0.32372537f, 
    0.04953216f, -0.05557445f, -0.55804050f, 0.51264805f, -0.18832819f, -0.44351155f, -0.29904470f, 0.46221364f, 
    0.65964788f, -0.01623988f, 0.31849882f, 0.27744561f, 0.35579816f, -0.13971733f, 0.11112516f, -0.19138588f, 
    0.30920458f, 0.21074140f, 0.07085443f, 0.12535000f, 0.12155779f, 0.07408467f, 0.17284833f, 0.02882805f, 
    -0.13817297f, 0.03025658f, 0.20575459f, -0.38601288f, -0.35601565f, -0.49478614f, -0.31418416f, -0.04887356f, 
    0.43465307f, 0.05309974f, 0.09684504f, 0.52116311f, 0.20989200f, -0.22821230f, -0.01577925f, -0.02536511f, 
    -0.07557810f, 0.11189409f, 0.10809908f, 0.26084360f, -0.02302706f, 0.21558516f, -0.27027917f, 0.47911862f, 
    -0.15083176f, 0.43969545f, 0.02656045f, 0.02819636f, -0.26321971f, -0.50487089f, -0.43549690f, -0.19714797f, 
    0.21155302f, 0.12878889f, 0.73388457f, -0.36108974f, 0.38245472f, 0.40400887f, 0.12114429f, -0.09890824f, 
    -0.38245225f, -0.05624299f, -0.33055258f, 0.17304191f, 0.16955018f, -0.28660604f, -0.05033417f, 0.07992771f, 
    -0.03642986f, 0.09424604f, -0.03055599f, 0.10697898f, -0.39977834f, 0.47331491f, 0.44527602f, 0.52081573f, 
    0.49567103f, 0.11335326f, -0.63172638f, -0.39024332f, -0.33791214f, 0.37522891f, -0.42129374f, 0.03313394f, 
    -0.06971335f, 0.01358369f, 0.16329500f, 0.07792915f, 0.27894399f, 0.00818102f, -0.13651372f, 0.10135522f, 
    0.07849011f, 0.15407762f, 0.04853261f, 0.21567899f, -0.17003478f, -0.03460921f, 0.80574900f, -0.60125929f, 
    0.18811046f, -0.40952778f, 0.20722027f, 0.50110394f, -0.16754954f, -0.53127784f, -0.46111676f, -0.27285743f, 
    -0.09289528f, 0.09858537f, -0.10537777f, 0.48265743f, -0.00524762f, -0.19623351f, 0.09662400f, -0.26717204f, 
    0.34770733f, -0.12648797f, 0.19093567f, 0.01916888f, -0.29040638f, -0.20969485f, 0.10806877f, 0.64353412f, 
    0.16118960f, 0.36540905f, 0.23890895f, 0.24571344f, -0.22751911f, -0.08084545f, 0.19246912f, -0.26574188f, 
    -0.30906120f, -0.22200149f, 0.00385773f, -0.17335556f, 0.47502360f, 0.09763893f, -0.02761923f, 0.13776262f, 
    0.43646166f, 0.00204929f, -0.12009129f, -0.21211654f, -0.26007727f, -0.10317265f, -0.04932867f, 0.10281187f, 
    -0.24999714f, -0.52277225f, -0.60198265f, -0.47277719f, -0.16154410f, 0.31943408f, 0.43026704f, 0.35109729f, 
    0.01456976f, 0.44340321f, -0.18452857f, -0.16846493f, -0.26578373f, -0.33647221f, 0.15641691f, -0.18325913f, 
    0.07435206f, -0.04105062f, 0.25037247f, -0.00236833f, -0.27171278f, -0.09817705f, -0.19886999f, -0.22866336f, 
    -0.11171190f, 0.57260340f, 0.32275572f, -0.43585750f, 0.46298176f, -0.34372312f, 0.04012883f, 0.36905456f, 
    0.45878714f, 0.02481505f, 0.34663653f, 0.10583198f, -0.02010343f, -0.05378998f, -0.30129021f, -0.33084723f, 
    -0.04888782f, -0.37417749f, 0.18620963f, -0.06878971f, 0.20688534f, 0.34471479f, 0.18266526f, -0.12136587f, 
    0.15389256f, -0.32326719f, 0.00179458f, 0.70584452f, -0.27232313f, -0.03994118f, -0.23881206f, 0.36387807f, 
    -0.36282882f, -0.63030070f, -0.52262431f, -0.07014550f, -0.02956224f, 0.05849052f, 0.32301369f, 0.39759415f, 
    -0.22894174f, -0.26717979f, -0.20739822f, 0.07954275f, -0.07413103f, -0.17894796f, -0.24012366f, -0.04863629f, 
    0.27207246f, -0.27851290f, -0.01607062f, 0.61479694f, 0.45729136f, 0.19500503f, 0.12354896f, 0.30491835f, 
    0.26486674f, 0.28305054f, -0.27897817f, -0.00677853f, 0.32098475f, 0.18783720f, -0.07427865f, -0.17710297f, 
    0.01169497f, -0.09548794f, 0.21720280f, 0.12818539f, 0.19321388f, -0.26446882f, -0.23365444f, -0.00571936f, 
    -0.18713351f, -0.17936786f, -0.17888591f, 0.31225550f, -0.71970284f, 0.02510723f, 0.04314417f, -0.01445555f, 
    -0.21229921f, 0.71904659f, 0.34019539f, -0.31715098f, 0.53325516f, 0.54603344f, 0.41222352f, -0.14840414f, 
    0.23798464f, -0.15131471f, -0.23012488f, 0.31820390f, -0.09456518f, 0.09683280f, 0.13896218f, -0.11592703f, 
    -0.18660679f, -0.31863227f, -0.19302376f, 0.22960234f, -0.03182955f, 0.13453372f, 0.17248008f, -0.59064025f, 
    -0.95427573f, 0.47197884f, 0.24333619f, -0.12524061f, 0.30370709f, 0.05371801f, 0.07332837f, -0.23842974f, 
    0.14890616f, 0.17092882f, 0.08156033f, -0.11371652f, 0.14564940f, -0.21220915f, -0.21788834f, -0.03992528f, 
    0.05813453f, -0.15464447f, 0.04303002f, 0.18327050f, -0.26353055f, 0.16099602f, -0.26453716f, -0.51529902f, 
    0.36333105f, 0.39356759f, -0.24273890f, 0.03677123f, 0.27909681f, -0.07180887f, -0.18324395f, -0.55773014f, 
    0.14078750f, 0.16915321f, 0.08937173f, 0.34479445f, -0.05048296f, 0.21027748f, 0.39739454f, 0.31277224f, 
    -0.22919074f, -0.10525940f, -0.22221930f, -0.33026785f, -0.32522207f, -0.05222985f, -0.06629261f, -0.58607310f, 
    0.49378160f, -0.09794336f, -0.14507173f, 0.32726774f, 0.08118988f, -0.10819700f, 0.32271612f, 0.37014374f, 
    0.46742013f, 0.19879723f, -0.23001038f, -0.29409170f, -0.21806175f, 0.06527843f, 0.04503642f, 0.29972553f, 
    -0.51339918f, 0.13372552f, -0.06646537f, 0.11834399f, 0.07184427f, 0.27372813f, 0.04949242f, 0.16353950f, 
    0.10063536f, 0.42826948f, 0.31734714f, 0.32850990f, 0.16226360f, -0.43244401f, -0.14184415f, 0.30404204f, 
    -0.49366972f, -0.53492159f, -0.30890563f, 0.03851671f, 0.10432402f, 0.52139699f, 0.04212891f, 0.23758668f, 
    0.05684433f, 0.15661231f, 0.20721586f, 0.07450159f, -0.15058023f, 0.02392711f, -0.25279522f, 0.13430679f, 
    -0.05727298f, 0.27414259f, 0.37555963f, 0.13312489f, 0.30195275f, -0.15453121f, -0.35096994f, -0.08108356f, 
    -0.53483307f, -0.20214969f, 0.00193049f, -0.09194139f, -0.31050101f, -0.34886742f, 0.09433545f, -0.18274951f, 
    -0.16112818f, 0.25090557f, -0.17259330f, 0.24832173f, -0.18760307f, -0.08812834f, 0.42483932f, 0.22184654f, 
    0.17100626f, -0.35084277f, -0.10241689f, 0.59898233f, -0.14651836f, -0.72565782f, -0.03671019f, 0.40192303f, 
    -0.06528104f, -0.66384023f, -0.31896034f, -0.12774806f, -0.06440355f, 0.34645936f, -0.03993119f, 0.05732115f, 
    0.06174114f, -0.22256233f, 0.26296785f, -0.31296083f, -0.07179040f, 0.30743060f, 0.12562285f, 0.14757240f, 
    0.33946675f, 0.13893615f, -0.44383463f, 0.57316440f, 0.34921706f, -0.07361212f, -0.14200956f, -0.41427714f, 
    -0.64323902f, -0.88987637f, -0.21063721f, 0.08126491f, 0.08392500f, 0.14048120f, -0.02265911f, 0.24511398f, 
    0.03434435f, -0.37646145f, -0.27950421f, 0.17088200f, -0.33346799f, 0.10880873f, -0.33171517f, 0.22877808f, 
    -0.10463598f, 0.12375674f, 0.02848194f, 0.14559473f, -0.25459728f, -0.74428970f, 0.20322771f, 0.44224751f, 
    -0.53979337f, -0.16634098f, 0.30160350f, 0.37108073f, -0.06244216f, -0.04047657f, -0.20735355f, -0.13058226f, 
    -0.36355719f, 0.56212705f, 0.20973931f, -0.04379626f, 0.02261496f, -0.17876582f, -0.03860796f, 0.03433472f, 
    -0.03913623f, 0.24260493f, -0.21329598f, 0.08476909f, -0.16286118f, 0.74110800f, -0.03076055f, -0.44993901f, 
    -0.61791676f, 0.20155376f, 0.27885830f, -0.57733226f, 0.32419851f, 0.40298104f, -0.09886437f, -0.22956297f, 
    -0.34737778f, 0.00895353f, 0.03280936f, 0.24210002f, 0.04140950f, 0.20044868f, -0.42121679f, 0.25544029f, 
    0.08723523f, -0.01210674f, 0.05587435f, 0.15463150f, -0.12352443f, -0.18774313f, 0.14399680f, -0.27513376f, 
    0.60846996f, 0.83026487f, 0.07386042f, -0.02035489f, 0.31126592f, -0.03391260f, 0.31705487f, 0.35192648f, 
    -0.30648023f, -0.01906481f, -0.10845141f, -0.20288178f, -0.05160010f, -0.37125024f, 0.10953027f, -0.15720381f, 
    0.19800529f, -0.04920052f, 0.02008188f, 0.22885278f, -0.25408301f, -0.06847882f, -0.05195109f, 0.70934927f, 
    0.61990154f, 0.04906006f, -0.00217185f, -0.46337217f, -0.17256641f, 0.11611247f, 0.43356848f, 0.16938005f, 
    0.63321525f, -0.02262081f, -0.02361769f, 0.15482676f, -0.19847895f, 0.04307764f, 0.28026068f, 0.14319836f, 
    -0.23969799f, 0.18071854f, -0.11200459f, -0.18723334f, -0.25406232f, -0.02253214f, -0.14463948f, -0.07969643f, 
    -0.67547280f, -0.80351782f, -0.29306340f, 0.37344116f, 0.03554111f, 0.56530589f, 0.60450882f, 0.06875427f, 
    0.11420642f, -0.54165930f, -0.20866318f, -0.28490978f, -0.34845674f, 0.17555280f, 0.10262677f, 0.08893134f, 
    0.35228893f, -0.23488809f, -0.14500150f, 0.14108838f, -0.18097706f, 0.01679193f, 0.20719223f, 0.11023454f, 
    -0.20115909f, 0.47394058f, 0.24448815f, 0.26706889f, -0.05654379f, 0.15314643f, -0.01479245f, -0.40367395f, 
    0.07966436f, -0.11900391f, -0.11917316f, -0.33819795f, -0.22730547f, 0.20259690f, -0.28833497f, 0.05007822f, 
    -0.39816928f, 0.02356204f, -0.26514754f, -0.42167738f, -0.39393732f, 0.14387034f, -0.10995958f, 0.27846712f, 
    -0.03607004f, 0.03270099f, -0.68511307f, -0.31969017f, 0.18192863f, -0.14950594f, 0.34093881f, 0.12642744f, 
    0.36767235f, 0.44951856f, -0.09615207f, 0.12539712f, -0.01602557f, -0.12711976f, -0.06498691f, -0.19193679f, 
    -0.32656994f, 0.03281095f, -0.18462373f, 0.27284905f, 0.05326154f, 0.24060777f, -0.28625754f, -0.15874620f, 
    -0.13340379f, 0.05422106f, -0.21031703f, 0.27579743f, 0.79093212f, 0.39081740f, -0.29322404f, 0.20894906f, 
    -0.80150014f, 0.44151929f, -0.13421935f, -0.39304492f, 0.11102502f, 0.12572294f, -0.02763353f, 0.05924398f, 
    -0.13668802f, 0.14305079f, 0.27902526f, 0.13059579f, -0.07072086f, 0.13847348f, -0.25003400f, -0.00413206f, 
    0.00839485f, -0.13639657f, -0.16144051f, 0.25347781f, -0.32738110f, 0.02273523f, 0.25793535f, -0.47287947f, 
    0.60276550f, -0.34868231f, -0.15281425f, 0.10698556f, -0.66527861f, -0.23331080f, 0.20495641f, 0.21965428f, 
    0.27264491f, -0.10433564f, 0.22559065f, 0.10332201f, 0.27131081f, 0.08939276f, -0.22282158f, 0.14657050f, 
    -0.05330130f, 0.02142085f, 0.32384431f, 0.29068086f, -0.18089688f, 0.24637692f, 0.78040344f, -0.54864377f, 
    0.31546062f, -0.51329356f, 0.66831398f, 0.03528735f, -0.37745956f, 0.04041299f, -0.41833770f, 0.47280771f, 
    0.18578425f, -0.22135514f, 0.20524684f, -0.10106551f, -0.05932688f, -0.10546666f, 0.12643626f, 0.09221454f, 
    0.04386247f, 0.24459447f, 0.09413707f, -0.34071842f, -0.10836490f, -0.10418450f, 0.58360821f, 0.39306709f, 
    0.18234308f, 0.56542283f, 0.55066073f, 0.30376065f, -0.37898251f, -0.28954488f, -0.42604119f, -0.09154028f, 
    -0.32465118f, 0.03115863f, 0.14876938f, 0.15390080f, -0.10798050f, 0.05786503f, -0.04778907f, 0.28548458f, 
    0.17171310f, -0.13691406f, 0.19265160f, 0.04143474f, -0.08126287f, -0.27491558f, 0.12391451f, -0.26522446f, 
    0.72649539f, -0.05080546f, -0.04570856f, 0.32718965f, -0.63505900f, -0.00157206f, -0.03357720f, -0.71028227f, 
    -0.09787735f, 0.31372982f, 0.08864059f, 0.26171994f, 0.14359947f, 0.01702459f, -0.10554607f, -0.14506714f, 
    -0.27274638f, 0.03831139f, -0.06193030f, 0.19619440f, -0.02602441f, 0.19799964f, 0.26336408f, 0.12329835f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.23152532f, 0.20938881f, 0.13491537f, 0.19994113f, 0.01961739f, 0.02731753f, 0.05230621f, 0.24492262f, 
    0.24874718f, 0.12793551f, 0.15656437f, 0.22750296f, -0.03349031f, 0.24011728f, 0.10613108f, 0.21477336f, 
    0.19196609f, -0.04312650f, 0.07848383f, 0.01566641f, 0.11387269f, -0.02716354f, 0.09536152f, -0.04724066f, 
    -0.04759884f, 0.12463138f, 0.03922896f, 0.03250604f, 0.28341764f, 0.00556777f, 0.01502774f, -0.06432688f, 
    0.18153603f, -0.01586575f, 0.10276465f, 0.05507682f, 0.14005201f, -0.08640902f, 0.13938811f, 0.01907048f, 
    -0.11453319f, 0.13126865f, 0.18889605f, 0.15290801f, -0.01733400f, -0.01142166f, 0.08818492f, 0.21208258f, 
    0.12117795f, 0.00166320f, 0.17034231f, 0.37003967f, 0.23658574f, 0.07002767f, -0.01385154f, 0.15063891f, 
    0.19370814f, -0.09284432f, 0.07873937f, 0.06707852f, 0.14104700f, 0.15632188f, -0.06424931f, 0.23902069f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.02018124f, 0.02872273f, 0.02785349f, 0.02902615f, -0.00897524f, 0.01456539f, 0.00969643f, -0.02149965f, 
    -0.03102280f, -0.01400565f, 0.00213383f, 0.02866033f, 0.01202689f, 0.02832479f, -0.01941784f, -0.03344003f, 
    -0.03257270f, 0.01688910f, -0.02065989f, -0.02506003f, -0.02648837f, 0.01025901f, -0.04091153f, -0.01138411f, 
    0.02817787f, 0.01078821f, -0.03910506f, 0.03430656f, -0.00233349f, -0.00448502f, -0.02041894f, 0.00871877f, 
    -0.00623286f, 0.00882207f, 0.00634904f, -0.00953135f, -0.01893214f, -0.00353617f, -0.03822294f, -0.03271700f, 
    0.02413615f, 0.02248082f, 0.02026389f, 0.01801511f, -0.02717447f, 0.00175505f, -0.03814902f, -0.01203340f, 
    0.00068530f, -0.00963316f, 0.01555718f, -0.02652674f, 0.00535141f, 0.02936729f, -0.04153734f, -0.01520794f, 
    -0.04041909f, 0.02282702f, -0.00369475f, 0.00494905f, -0.00632330f, -0.01892269f, 0.03661171f, 0.03955280f, 
    0.04007270f, -0.01377555f, -0.03308159f, 0.02826170f, 0.00309313f, -0.03052169f, 0.01266451f, -0.03898618f, 
    0.00426301f, -0.00121702f, -0.00811905f, -0.02721369f, 0.01854596f, -0.02644720f, 0.01245165f, -0.02278770f, 
    0.01273492f, -0.02342795f, -0.02546174f, -0.01844420f, 0.00829560f, -0.02921082f, 0.02057569f, 0.02382179f, 
    -0.01016193f, -0.02074796f, -0.00022521f, -0.02460773f, -0.02257374f, 0.01726325f, -0.02055055f, 0.00021627f, 
    -0.04091018f, -0.00596469f, -0.01789536f, 0.02465260f, 0.02075727f, 0.00340983f, -0.00351212f, -0.00173063f, 
    0.00165876f, -0.01955526f, -0.02178851f, 0.01141182f, 0.02506419f, -0.03848980f, -0.00161672f, 0.01879336f, 
    -0.00475719f, -0.00894711f, -0.01027654f, 0.00021378f, -0.02768842f, -0.00081173f, 0.00001535f, 0.03972843f, 
    0.02024793f, 0.03387123f, 0.02430410f, -0.03505837f, 0.00450598f, 0.01829838f, 0.02809022f, -0.01944203f, 
    0.02067410f, -0.03217788f, -0.02768804f, -0.02214256f, 0.01108522f, 0.02666637f, -0.01822292f, -0.02957407f, 
    0.00216851f, 0.03330952f, -0.00130775f, -0.00939747f, -0.03543543f, 0.02109875f, 0.02378579f, -0.03253132f, 
    0.01538771f, 0.02314593f, -0.01439984f, -0.00294016f, -0.03212254f, 0.01302333f, 0.00595484f, -0.02108399f, 
    -0.01476804f, -0.02617690f, 0.01532597f, -0.00095190f, -0.02425414f, 0.03189356f, -0.03677999f, -0.04061753f, 
    0.01109459f, -0.00669502f, -0.02212659f, -0.02781852f, -0.01154658f, -0.01402167f, 0.01059832f, 0.00903308f, 
    -0.03315354f, 0.01122413f, -0.04061759f, 0.01451394f, 0.00079091f, 0.00387378f, -0.01547498f, -0.01772006f, 
    0.00231834f, -0.04178537f, -0.02299733f, -0.01840695f, -0.01597957f, -0.01263239f, 0.00497781f, 0.02378717f, 
    -0.00757600f, -0.04138876f, -0.03738463f, -0.01853230f, -0.02750354f, -0.02290670f, -0.01240278f, 0.00155938f, 
    0.02902333f, 0.01641267f, 0.00893984f, 0.00604234f, -0.01924244f, -0.02755032f, -0.03244350f, -0.03712896f, 
    -0.00778026f, 0.02013194f, 0.00470019f, -0.02530745f, -0.03523555f, 0.00006011f, -0.03947446f, -0.03162576f, 
    0.03626979f, -0.01124268f, 0.01741627f, -0.03140149f, -0.02336303f, 0.01049541f, -0.00562433f, 0.01484379f, 
    0.02741838f, -0.03458981f, 0.00695635f, 0.00173858f, 0.02735113f, 0.02797645f, 0.01231687f, 0.00330015f, 
    0.00707901f, 0.04200260f, -0.00185375f, 0.01604285f, -0.02058265f, 0.02483905f, 0.02423512f, -0.03049015f, 
    -0.01228708f, 0.00417272f, -0.01305238f, 0.00606934f, 0.00654832f, 0.01925316f, -0.00488653f, -0.01162288f, 
    -0.02873240f, -0.01229797f, -0.01622136f, 0.01689249f, 0.02331436f, -0.01819658f, -0.04184243f, -0.03801982f, 
    0.01410797f, -0.01138955f, 0.01625408f, -0.00217303f, -0.00191286f, -0.02009604f, -0.03930548f, -0.01140620f, 
    0.01173604f, -0.02858674f, 0.01463229f, -0.01711094f, -0.00837543f, 0.00246050f, -0.03654401f, -0.02489573f, 
    -0.00702313f, -0.03636546f, -0.02947633f, 0.01923146f, 0.00150083f, 0.01214183f, -0.03637836f, -0.00736745f, 
    -0.01424857f, 0.02252964f, -0.03196229f, -0.03501391f, 0.01979301f, -0.00894992f, -0.01357774f, -0.02141714f, 
    0.02765668f, -0.02418527f, 0.02761601f, -0.01523456f, -0.00791437f, 0.00659990f, 0.00671495f, -0.01919493f, 
    -0.01089822f, -0.01213046f, -0.00798138f, -0.02188442f, -0.01706308f, 0.02340607f, 0.02649126f, 0.02942520f, 
    0.01576197f, -0.03799128f, 0.01361599f, -0.00849434f, -0.03315752f, -0.00570414f, 0.01860851f, -0.02855189f, 
    -0.00094070f, -0.00841110f, 0.02153633f, -0.03919449f, 0.00411136f, -0.00021430f, -0.01779581f, -0.03298864f, 
    -0.00518548f, -0.03231177f, 0.02891401f, -0.03269947f, -0.02691247f, 0.02453169f, -0.03249374f, 0.01799439f, 
    0.02759056f, -0.00563003f, 0.01023160f, -0.03523134f, -0.02189132f, 0.00409803f, -0.02782654f, 0.00047082f, 
    -0.02525168f, 0.00919428f, -0.02819967f, 0.01109341f, -0.00750453f, 0.01771613f, -0.02434010f, 0.01060985f, 
    0.02028190f, -0.02593422f, -0.03560338f, 0.00777793f, 0.00168447f, -0.01425029f, 0.00695312f, -0.04087256f, 
    0.03504100f, -0.00419730f, 0.02329490f, -0.01421509f, 0.02240250f, -0.02371185f, -0.04121085f, -0.01093116f, 
    0.01704333f, -0.01830989f, -0.00520656f, -0.02540062f, 0.01052605f, 0.00455150f, -0.03108694f, 0.01711352f, 
    -0.01200690f, -0.03495603f, -0.02547267f, -0.01481673f, -0.00319769f, 0.02448760f, -0.00487098f, 0.02389950f, 
    -0.01433634f, -0.00388170f, -0.00084229f, -0.01259093f, -0.00591021f, 0.04103153f, 0.00317929f, -0.00040529f, 
    0.01176499f, -0.02702431f, -0.02560787f, 0.00810148f, -0.04086262f, -0.00204651f, -0.01649286f, 0.02932566f, 
    0.01728022f, -0.03910561f, 0.02629203f, 0.01865805f, 0.00852442f, 0.01304820f, 0.02323782f, 0.01023407f, 
    -0.00108770f, -0.04136831f, -0.02669167f, -0.01700253f, -0.02585196f, 0.00279408f, 0.02861087f, 0.02479911f, 
    -0.02130105f, -0.02915024f, -0.03041397f, 0.02493911f, 0.01055388f, 0.00267062f, -0.01959393f, -0.00993381f, 
    0.00775478f, 0.00669651f, -0.00297374f, 0.02688674f, -0.01321965f, 0.01317905f, 0.00437817f, -0.00363358f, 
    -0.00357153f, -0.00709712f, -0.01540675f, -0.01508150f, -0.03544272f, -0.02428017f, 0.00665556f, -0.01274262f, 
    -0.02039018f, -0.02794633f, 0.00192924f, 0.02564967f, 0.02431878f, -0.03226274f, -0.03432542f, -0.04187701f, 
    0.00568999f, 0.01425260f, 0.03344687f, 0.02697622f, 0.00946026f, -0.01346525f, 0.01808825f, -0.01223947f, 
    0.00845068f, 0.01693358f, -0.03390693f, -0.02006348f, -0.00343780f, 0.01178262f, 0.00606685f, 0.02971042f, 
    0.02902647f, 0.00860006f, -0.00779803f, 0.00040245f, 0.00054022f, 0.01856392f, 0.01084291f, -0.03999694f, 
    -0.03714850f, -0.03772363f, 0.00412379f, 0.01963770f, -0.01866888f, 0.01286302f, -0.01392289f, 0.01579831f, 
    0.03903716f, -0.02751005f, 0.00894988f, -0.01935283f, 0.03267422f, 0.02096237f, -0.02338571f, -0.00725118f, 
    0.02643355f, 0.00515318f, 0.01644538f, -0.01781470f, 0.01730691f, -0.03471926f, -0.00997642f, -0.02858644f, 
    -0.03236066f, -0.02325359f, -0.02113771f, -0.00609621f, 0.01306039f, 0.02432908f, -0.00219183f, -0.01252681f, 
    0.00175082f, -0.00778278f, -0.02419890f, 0.01839199f, 0.02504618f, 0.01656985f, 0.01096962f, 0.01771880f, 
    0.01492621f, -0.03669611f, -0.02354882f, -0.02145938f, -0.03572210f, 0.01023629f, -0.02605928f, -0.00736009f, 
    0.00979480f, 0.02250227f, -0.03798671f, -0.03442191f, -0.00178166f, 0.02400055f, -0.01601764f, -0.00646241f, 
    0.02051918f, -0.00004345f, -0.00589410f, -0.04017611f, 0.01556905f, 0.01975870f, -0.01428993f, 0.00399500f, 
    -0.03324518f, -0.00357377f, -0.01112135f, -0.01411033f, 0.04012889f, 0.00252035f, -0.01384061f, 0.00514233f, 
    -0.00161638f, 0.01800399f, -0.01082641f, -0.04129341f, -0.00602657f, -0.02063277f, -0.03358062f, -0.00385198f, 
    -0.02249413f, 0.00561544f, -0.03674482f, 0.01684810f, -0.00479108f, -0.03533030f, 0.04104464f, -0.02721491f, 
    -0.00801992f, -0.03737702f, -0.01893465f, 0.02796413f, -0.02379709f, 0.01865635f, 0.00267578f, 0.01929428f, 
    -0.00619647f, -0.04035228f, -0.00812559f, 0.01522248f, 0.02739841f, 0.00556267f, 0.01155885f, -0.00629282f, 
    0.00108002f, -0.01233335f, -0.00016855f, 0.00109584f, -0.03780872f, 0.00032505f, -0.00300000f, 0.01731854f, 
    -0.03197113f, 0.01844309f, -0.03935580f, -0.00884936f, -0.02421314f, -0.02314025f, -0.03405610f, 0.01591188f, 
    0.02316442f, 0.03144050f, 0.02162564f, -0.01604163f, -0.03390205f, -0.02490972f, -0.00289388f, -0.02795694f, 
    0.02823082f, 0.01313444f, 0.00616499f, -0.03047281f, -0.01419675f, 0.03828131f, 0.00945350f, 0.02399999f, 
    -0.00315559f, -0.02346232f, -0.00506415f, 0.01921092f, 0.03580363f, 0.02238364f, -0.02568660f, -0.01942419f, 
    0.01642609f, -0.01498827f, -0.00925157f, -0.03970706f, -0.00689975f, 0.03464105f, 0.02555638f, 0.01285873f, 
    -0.04104650f, 0.00539602f, -0.00848163f, -0.02943311f, -0.03566521f, 0.00596983f, 0.01794281f, -0.00629689f, 
    -0.01355871f, 0.02516386f, -0.01215560f, 0.01199550f, 0.00628919f, -0.03927787f, -0.03087351f, 0.00192573f, 
    0.01627243f, 0.00079488f, -0.03078543f, 0.00690849f, -0.00745614f, -0.03220158f, -0.02338202f, 0.00587035f, 
    -0.00957659f, 0.00258472f, 0.02497760f, -0.00403420f, -0.02038021f, 0.02852514f, -0.01206087f, -0.03049063f, 
    0.02526084f, 0.02941184f, 0.01487797f, -0.03665081f, -0.02972425f, 0.02951302f, -0.01451104f, 0.00187093f, 
    0.01020071f, -0.02527555f, 0.00724236f, 0.00081488f, -0.00595890f, 0.01500148f, -0.03790103f, -0.01692132f, 
    -0.00703455f, -0.03005508f, -0.02950481f, -0.01232635f, 0.01741262f, -0.01816402f, 0.01837992f, -0.00740906f, 
    0.02152298f, -0.03569970f, 0.00634504f, -0.01949319f, 0.00119861f, 0.01650705f, 0.00319542f, -0.00424084f, 
    -0.02904415f, -0.04186679f, 0.02249826f, -0.02621683f, 0.03983212f, -0.02362935f, 0.00050309f, -0.02642017f, 
    0.00016878f, 0.00592661f, -0.00717494f, 0.03352461f, 0.01970156f, -0.02403758f, 0.01525171f, -0.01043553f, 
    -0.04114766f, 0.01336229f, 0.00938412f, -0.00138483f, 0.01155087f, -0.00080612f, -0.02030994f, -0.00459815f, 
    -0.03195296f, -0.02089033f, -0.01378465f, 0.01127396f, -0.00660569f, 0.00699535f, 0.01161511f, -0.02452968f, 
    -0.04203534f, -0.03392041f, 0.00116343f, -0.03604915f, -0.02383307f, 0.01665253f, -0.01662055f, -0.03803097f, 
    0.01327830f, 0.00434091f, 0.02975216f, -0.03568327f, 0.01665479f, 0.00753934f, -0.03201107f, -0.02065616f, 
    0.02240844f, -0.01276186f, 0.01525163f, 0.01416226f, -0.01083248f, -0.02863646f, 0.02227912f, -0.03792222f, 
    0.00931519f, -0.03634887f, -0.01561818f, -0.00498907f, 0.00889044f, 0.02763099f, -0.03731381f, -0.04101656f, 
    -0.03140227f, 0.00097143f, 0.00840346f, 0.01894094f, 0.01032350f, 0.00541392f, -0.00035864f, -0.02174331f, 
    -0.02506913f, -0.00821092f, 0.01973976f, -0.00989808f, -0.01881058f, 0.00914248f, 0.01967834f, -0.04046811f, 
    0.02047853f, -0.02165140f, 0.00737569f, -0.03976465f, 0.00390521f, 0.00302997f, 0.00389056f, -0.03527084f, 
    0.02388094f, 0.01250463f, 0.00126313f, -0.00999631f, 0.01749622f, -0.01085025f, -0.00159244f, -0.01855112f, 
    0.13200994f, 0.14384457f, -0.05287488f, 0.08910117f, -0.04262989f, -0.04860448f, 0.07593590f, 0.11555539f, 
    0.05255380f, 0.08277593f, -0.01332781f, 0.02514002f, -0.27470189f, 0.11662821f, 0.05671069f, 0.08845944f, 
    -0.01306491f, -0.07524618f, -0.07270585f, 0.02461960f, 0.05037970f, 0.00389490f, 0.04734744f, 0.04561872f, 
    -0.12751952f, -0.06129058f, -0.03376332f, -0.05804837f, -0.00912319f, 0.08196942f, 0.01641258f, -0.09238910f, 
    0.06104080f, -0.09082947f, 0.04408878f, 0.05139426f, -0.08078954f, -0.23399220f, 0.12366803f, -0.29610157f, 
    0.04573132f, -0.00690666f, -0.03911309f, 0.00119693f, 0.00799683f, -0.02527652f, -0.09904484f, 0.10892560f, 
    0.24717414f, 0.18900558f, 0.02807621f, -0.22275086f, -0.04469893f, 0.09573410f, 0.01940270f, 0.04608480f, 
    -0.02699798f, 0.04441252f, 0.07421865f, 0.03989219f, 0.04694421f, -0.12117825f, -0.04429022f, -0.09164969f, 
    -0.01681844f, -0.01818090f, -0.05248665f, 0.05838863f, 0.13352934f, 0.05429138f, -0.03465879f, -0.00802784f, 
    -0.31470573f, -0.11430676f, -0.08659228f, -0.08551008f, -0.07002687f, 0.05451935f, 0.10663284f, 0.03932543f, 
    0.01932692f, -0.00730001f, -0.07348899f, -0.10284038f, -0.00080405f, -0.22541068f, -0.02543676f, -0.12471096f, 
    -0.02877059f, -0.05562557f, 0.04150366f, -0.01835466f, 0.05700941f, 0.05872794f, 0.11461654f, 0.09616755f, 
    -0.12189801f, -0.12336545f, 0.14615819f, -0.05701250f, -0.08366126f, 0.03014487f, -0.07587849f, 0.10338466f, 
    -0.00466479f, -0.09000522f, 0.12669332f, 0.00530140f, -0.21380906f, 0.17597869f, 0.10306804f, 0.21938123f, 
    -0.04902812f, 0.01324788f, 0.08033106f, -0.15475149f, 0.02190079f, -0.02168894f, 0.11891674f, -0.00477710f, 
    -0.03262648f, -0.00317470f, -0.05226006f, 0.02987095f, 0.01848286f, -0.02671036f, 0.04893045f, 0.06006077f, 
    -0.08576118f, -0.10751899f, 0.05034028f, 0.03111398f, 0.04496239f, 0.03650036f, 0.10217551f, 0.12388980f, 
    -0.10185449f, -0.03697791f, -0.10032224f, 0.01055456f, 0.06105058f, -0.06098010f, -0.06671773f, -0.00470356f, 
    -0.39824998f, 0.22418986f, 0.12699601f, 0.09693101f, 0.04153641f, 0.08142016f, -0.15581696f, -0.02550643f, 
    0.12340233f, -0.10709318f, 0.06891330f, -0.05375861f, -0.07104101f, -0.14742209f, -0.09676292f, 0.02371070f, 
    0.02519878f, 0.05203257f, 0.03830071f, 0.05717240f, 0.10716035f, 0.01763190f, 0.00942377f, -0.01332649f, 
    0.02579179f, -0.07051998f, 0.03626833f, -0.00520269f, -0.05537660f, 0.03448025f, 0.01910509f, 0.01998957f, 
    -0.05874962f, -0.02501168f, -0.05577751f, 0.04561800f, 0.13214394f, 0.00827934f, -0.01349014f, 0.03094108f, 
    0.08928152f, -0.00989666f, -0.06630201f, 0.10493255f, -0.01114795f, 0.01722604f, 0.00146225f, 0.00752708f, 
    0.01966135f, 0.01566508f, 0.08968104f, -0.05871716f, 0.11678699f, 0.11562596f, 0.06345825f, -0.00821020f, 
    0.04813502f, -0.00253773f, -0.01534822f, 0.08206680f, 0.13570367f, 0.21637154f, 0.02013140f, -0.00687650f, 
    0.10728042f, -0.10199492f, 0.05450910f, -0.02046955f, 0.04391890f, 0.01325188f, -0.00346234f, 0.01503771f, 
    0.25191352f, -0.02964052f, -0.10151610f, 0.05595533f, 0.02882048f, 0.08548378f, -0.08195955f, 0.06472100f, 
    0.02233305f, -0.10377096f, -0.03647285f, 0.04021575f, 0.12827948f, -0.24171388f, 0.02369327f, -0.05916684f, 
    0.09656134f, -0.06404405f, 0.01525888f, 0.02535280f, -0.02651370f, 0.02519820f, -0.05833661f, -0.07661708f, 
    -0.10496449f, 0.00776588f, 0.10942245f, 0.09081645f, -0.07377659f, -0.02482125f, 0.07012070f, -0.05492765f, 
    0.02392983f, 0.03896463f, -0.08674983f, 0.00090523f, 0.05023686f, 0.07447777f, -0.22986849f, 0.12791155f, 
    0.08472011f, -0.01698104f, -0.00576288f, 0.03645428f, 0.09821092f, -0.04264049f, 0.08427352f, 0.05756594f, 
    -0.19544174f, 0.14648403f, 0.02734240f, -0.00951406f, -0.00017593f, 0.20914422f, 0.03951724f, -0.17690356f, 
    0.08056035f, 0.08907522f, 0.07954197f, -0.05902014f, -0.11275921f, -0.11457872f, -0.02011203f, -0.11117792f, 
    -0.04799251f, -0.05632286f, 0.16245709f, -0.01083990f, 0.04904770f, 0.09368122f, 0.02514550f, 0.01073039f, 
    0.31422436f, -0.31716448f, 0.03692213f, 0.23312967f, 0.07307211f, 0.02399132f, -0.04345768f, -0.03109590f, 
    0.08152310f, -0.01135626f, 0.01491131f, 0.00178476f, 0.18869692f, -0.08464171f, 0.01537001f, -0.08857012f, 
    0.02115287f, -0.01030516f, 0.06467339f, -0.07069669f, 0.00901357f, -0.03381161f, -0.09570238f, 0.01333335f, 
    -0.06305995f, 0.04031410f, -0.14939657f, 0.10792534f, 0.05969978f, -0.08736432f, -0.03765099f, -0.06173680f, 
    0.02891004f, 0.08209161f, 0.06637694f, -0.01032690f, 0.03476275f, -0.23281652f, 0.11230823f, 0.14491962f, 
    0.10067862f, 0.07838587f, -0.02264330f, 0.06565874f, -0.00663724f, -0.09871615f, 0.07984964f, 0.04308631f, 
    -0.02254927f, -0.06995422f, 0.12349833f, 0.17203270f, 0.02796135f, 0.08327217f, 0.04707484f, -0.03387931f, 
    0.09187437f, 0.03628084f, -0.08953866f, -0.03128714f, -0.21264008f, -0.10810495f, 0.05924733f, 0.00322981f, 
    0.12854160f, -0.00384374f, -0.09936176f, 0.04903559f, -0.07725158f, 0.10477666f, 0.04090616f, -0.01861255f, 
    0.10653078f, 0.26865214f, -0.12436037f, -0.11576284f, 0.07863145f, -0.14690527f, -0.02800357f, 0.00026085f, 
    0.05922630f, 0.13099094f, 0.15214083f, -0.02254909f, 0.20840417f, 0.09242155f, -0.10594813f, -0.06458347f, 
    0.05203645f, -0.02196301f, 0.07877238f, -0.03544270f, 0.02083958f, -0.02980248f, -0.12341675f, 0.11083643f, 
    -0.06561511f, 0.10969950f, 0.04314787f, 0.04893140f, 0.11479094f, 0.02068380f, 0.04948113f, 0.04364755f, 
    0.05197912f, 0.02970734f, -0.00940998f, 0.10143431f, 0.22172926f, 0.09504178f, -0.10620894f, -0.23102722f, 
    0.08969050f, 0.04729912f, 0.00484672f, -0.02939343f, -0.00000293f, -0.00462795f, -0.12899177f, 0.10601213f, 
    -0.13462985f, 0.34289682f, 0.03690467f, 0.03229852f, -0.04386247f, -0.06931373f, 0.00297940f, -0.02428842f, 
    0.01156577f, 0.01298281f, -0.04844920f, 0.05257878f, -0.03432194f, 0.01445951f, 0.13893947f, 0.16307829f, 
    -0.00840929f, 0.06051471f, 0.17864034f, -0.13681602f, -0.03716968f, -0.06578942f, -0.02444791f, -0.08928534f, 
    0.02730203f, 0.17001435f, -0.02086253f, 0.13666280f, -0.08325074f, -0.11282772f, 0.02848233f, -0.01398324f, 
    0.07509605f, -0.10094555f, -0.10618418f, 0.01811632f, 0.07915601f, -0.11398976f, -0.02747733f, 0.20819119f, 
    0.13618772f, 0.06359061f, 0.02202802f, 0.02110997f, -0.00380761f, 0.03792136f, 0.04402445f, 0.03083367f, 
    -0.18552288f, -0.04637468f, 0.22086339f, 0.18880934f, 0.04957713f, 0.06379310f, -0.04188029f, 0.03364522f, 
    0.08204846f, -0.02211961f, 0.02681453f, -0.12194189f, -0.13144864f, -0.05698336f, 0.13259782f, 0.11960211f, 
    0.09152647f, 0.14699085f, -0.03254037f, -0.03406421f, -0.10110545f, -0.09980031f, 0.18718995f, 0.04259156f, 
    -0.17761309f, -0.01089909f, 0.09234834f, 0.17213781f, -0.00133091f, -0.01590555f, -0.08347967f, -0.06289002f, 
    -0.05752191f, 0.03519972f, 0.06083021f, -0.02140146f, 0.34825903f, -0.04146486f, -0.09684999f, -0.02638600f, 
    0.02695868f, -0.02588462f, -0.02012814f, 0.10486911f, 0.09532557f, 0.06492776f, -0.02656464f, -0.11648049f, 
    0.13574192f, 0.00037684f, -0.10548913f, 0.01493099f, 0.05258026f, 0.04564343f, 0.02657773f, -0.00041400f, 
    0.05669828f, -0.02695035f, 0.12472130f, -0.01688495f, 0.16089505f, -0.02961280f, 0.00524784f, 0.06862299f, 
    0.01759207f, 0.09033533f, -0.03692428f, -0.06284782f, -0.05928652f, -0.11387543f, 0.03711557f, 0.16733406f, 
    -0.15816604f, 0.09919529f, 0.10361957f, 0.07194209f, 0.00501271f, 0.09037674f, 0.00399400f, 0.05711764f, 
    -0.04434587f, -0.10799708f, 0.03645609f, 0.03056199f, -0.05432032f, 0.17309226f, -0.08957020f, 0.14892817f, 
    0.09696669f, 0.00941540f, -0.06896609f, -0.07600597f, -0.12220462f, -0.06807606f, 0.00735451f, 0.06139390f, 
    -0.14753367f, -0.25245962f, 0.03859770f, -0.13585189f, -0.00848587f, -0.03250153f, -0.04803173f, 0.02894134f, 
    -0.09030774f, 0.00444235f, 0.00476678f, 0.04687601f, 0.12007342f, 0.12906161f, -0.02898712f, 0.12635502f, 
    0.01211508f, 0.01368833f, -0.02366528f, -0.03765769f, 0.03702961f, -0.04186781f, -0.14481606f, -0.01446095f, 
    -0.11390547f, -0.19041358f, 0.06237606f, 0.12406251f, 0.09085292f, 0.04924225f, 0.06361005f, -0.01348399f, 
    -0.02340372f, 0.01741274f, 0.11242479f, 0.05588425f, -0.04259371f, -0.09394558f, 0.00354676f, 0.13342632f, 
    -0.00483968f, -0.02812271f, 0.07081626f, 0.08861151f, 0.01596360f, -0.02672687f, -0.02843554f, -0.04441295f, 
    0.22485347f, 0.15850812f, -0.00120620f, -0.06012200f, 0.02019409f, -0.09871707f, 0.08821955f, 0.07948779f, 
    0.08850156f, 0.07428297f, -0.04415962f, -0.04675977f, -0.03890672f, 0.03615979f, -0.13731939f, -0.06993075f, 
    0.10582162f, -0.00164197f, -0.05291603f, -0.03525566f, 0.11320503f, 0.04266135f, 0.01172243f, 0.12022703f, 
    -0.08170049f, -0.05257189f, 0.07893987f, -0.19755273f, 0.04492789f, 0.01166276f, -0.13180003f, 0.16402708f, 
    -0.04285835f, 0.05420588f, 0.05078758f, -0.02138871f, -0.18342851f, 0.05403606f, -0.03149404f, 0.00227026f, 
    0.05189510f, 0.00824080f, 0.01396578f, -0.14475185f, 0.07768413f, 0.04696507f, -0.07959504f, -0.00793030f, 
    0.05778958f, 0.07813613f, 0.03823450f, -0.00009510f, 0.00568951f, 0.00516316f, -0.10877189f, 0.13626085f, 
    0.05480091f, 0.07600918f, 0.09166206f, -0.09358194f, 0.25617296f, 0.04041829f, -0.12763953f, -0.01612866f, 
    -0.00961008f, 0.07764600f, -0.05742275f, -0.07088162f, -0.16221853f, 0.10479503f, -0.03823604f, 0.11016433f, 
    -0.23369718f, -0.14750987f, 0.02656076f, -0.10130271f, -0.10287341f, -0.12647620f, 0.08407363f, -0.07829700f, 
    0.00122586f, 0.07215232f, -0.08191788f, 0.05655941f, 0.07145061f, -0.08630733f, 0.09343811f, 0.09256375f, 
    0.04373948f, -0.03783568f, -0.07951322f, 0.01035047f, 0.16379873f, 0.05657367f, -0.09015825f, -0.10392413f, 
    -0.01734967f, 0.06409010f, 0.17001651f, 0.03538245f, -0.10948286f, -0.11168981f, 0.00799317f, -0.01816896f, 
    0.05501447f, 0.02980541f, 0.03654000f, -0.08690633f, -0.27842611f, 0.22479230f, -0.07653102f, 0.04165138f, 
    -0.02759193f, 0.01592107f, 0.07258867f, -0.05671883f, -0.04949667f, 0.03231471f, 0.06243606f, 0.09419066f, 
    -0.05364883f, 0.00599267f, 0.17394945f, 0.05674029f, 0.01317297f, -0.15115026f, 0.01272724f, -0.10018566f, 
    0.05834648f, 0.06372714f, 0.00406428f, -0.01225644f, 0.31053531f, 0.13378368f, -0.14560325f, -0.12707131f, 
    -0.02490423f, -0.09198550f, -0.05413508f, -0.00598997f, 0.03623918f, -0.07513759f, 0.10095180f, 0.07115591f, 
    0.14722930f, -0.16738620f, 0.09425006f, 0.29985890f, 0.07852002f, 0.03589970f, 0.04615229f, -0.05378459f, 
    0.11297788f, -0.06165442f, 0.19652657f, 0.05559783f, -0.07507217f, 0.30282170f, 0.04840012f, 0.10816129f, 
    0.04044364f, -0.03555037f, 0.05531527f, -0.00398128f, 0.07699579f, 0.03397005f, 0.03421335f, 0.03517256f, 
    -0.19682641f, -0.11421493f, 0.02225573f, -0.02293439f, 0.06726148f, 0.02738907f, -0.00828777f, -0.01664882f, 
    -0.01512864f, -0.01560845f, 0.03950211f, -0.05510633f, 0.24251531f, 0.05336583f, 0.04697087f, -0.04163780f, 
    0.11515076f, 0.04148849f, 0.01408056f, -0.02485760f, -0.03869525f, -0.04282159f, -0.04029925f, -0.03131390f, 
    -0.08035659f, 0.01915001f, 0.00584147f, 0.03482974f, 0.02065178f, -0.01828582f, -0.00856579f, 0.05100860f, 
    -0.02737185f, -0.00509430f, 0.00151505f, 0.02614836f, 0.06693560f, 0.02788055f, -0.12881294f, 0.19020115f, 
    -0.05211539f, 0.02599972f, 0.01160808f, -0.00294055f, 0.06552061f, 0.08305100f, 0.00710876f, -0.12981595f, 
    -0.10385133f, -0.12627183f, 0.05575249f, 0.18872538f, 0.09104313f, -0.03045145f, -0.03285493f, -0.06360374f, 
    0.11452001f, 0.01612569f, 0.01431903f, -0.08304986f, -0.19225542f, 0.03873453f, 0.11905139f, 0.12780064f, 
    0.02563204f, -0.01617611f, -0.04378907f, -0.01202566f, -0.06627580f, -0.01991249f, 0.00473077f, -0.01012318f, 
    0.08448275f, 0.12200981f, 0.14783087f, 0.07545962f, 0.05262503f, 0.12975538f, -0.00367005f, 0.06060791f, 
    0.04159458f, -0.01371180f, 0.06782625f, 0.04340818f, -0.20627949f, -0.06597912f, -0.02058084f, 0.12496315f, 
    0.12153061f, 0.10268825f, -0.11008634f, 0.03476275f, 0.05688975f, -0.07756117f, -0.05292206f, -0.04152774f, 
    -0.08128716f, 0.03851623f, -0.00726292f, -0.02957219f, 0.07320532f, 0.02464819f, 0.01898848f, -0.09542357f, 
    0.08633353f, 0.11690445f, 0.00180320f, -0.06734607f, 0.03097635f, -0.07557144f, -0.06472819f, -0.12679076f, 
    0.07774092f, 0.11846478f, 0.01956142f, 0.08173246f, 0.01696159f, -0.00126895f, -0.05509697f, 0.02780182f, 
    -0.07317105f, 0.02494396f, 0.12901862f, -0.11412538f, -0.02677224f, 0.13442473f, -0.02191636f, -0.04741827f, 
    0.07437103f, 0.10490613f, 0.01231079f, -0.05001633f, -0.05479055f, -0.06982122f, -0.03687636f, 0.06579067f, 
    0.10483783f, 0.06650253f, 0.17879656f, -0.00082482f, -0.09417382f, 0.01331069f, 0.00078914f, -0.01741170f, 
    0.31050503f, -0.10838154f, -0.02390980f, 0.04195053f, -0.03418365f, -0.01254049f, 0.09647447f, -0.00473549f, 
    -0.08615045f, 0.06736502f, -0.00431821f, 0.06666544f, 0.17085814f, 0.02569981f, -0.02303455f, -0.05842534f, 
    -0.05204558f, -0.01894593f, -0.01791332f, -0.11188892f, -0.06896494f, 0.05432472f, -0.01576986f, 0.03923875f, 
    -0.10583330f, -0.03703821f, -0.09360479f, -0.04076753f, 0.11651415f, 0.05325639f, 0.08271261f, -0.00567157f, 
    0.03007858f, 0.04346351f, -0.00292424f, -0.07253475f, -0.00816625f, 0.02329528f, 0.11772813f, 0.06734510f, 
    -0.09229543f, 0.00268652f, 0.08763503f, -0.00747291f, -0.02481825f, -0.02228816f, -0.03722288f, -0.03412896f, 
    -0.23595317f, -0.05176212f, -0.10439973f, 0.07911021f, 0.12024118f, 0.07667089f, 0.00215179f, 0.04076006f, 
    -0.01422181f, 0.01444639f, 0.08466360f, 0.00656836f, -0.18486188f, -0.00397447f, 0.01980194f, 0.02308721f, 
    0.03591413f, 0.05399441f, -0.01947332f, -0.01226738f, -0.03869248f, 0.03286628f, -0.01566146f, -0.02836841f, 
    -0.00320437f, 0.15014900f, 0.18653056f, 0.04563628f, 0.05076250f, -0.12634160f, 0.02747786f, 0.00445622f, 
    -0.04999721f, 0.09473537f, 0.06935898f, -0.04548854f, -0.17451437f, 0.30116242f, -0.04861291f, 0.05762685f, 
    -0.07228765f, 0.17350525f, 0.01437159f, -0.04599829f, 0.03043068f, -0.10092542f, 0.05374589f, 0.03146622f, 
    -0.21472575f, 0.02878045f, -0.02414556f, -0.11546783f, 0.03529046f, 0.03106538f, 0.05241030f, -0.00291059f, 
    -0.03249474f, -0.10098650f, 0.10659466f, 0.06126613f, -0.11840512f, -0.05564566f, 0.15870033f, -0.01062880f, 
    -0.15030999f, -0.05124757f, 0.01312398f, -0.06735142f, -0.02443001f, -0.03735975f, 0.06554119f, 0.05709555f, 
    0.11960152f, -0.06095270f, 0.03980182f, -0.05822809f, -0.07182254f, -0.09669617f, -0.00527752f, 0.05558874f, 
    -0.07500798f, -0.03724525f, -0.02462676f, 0.11538840f, 0.07145853f, 0.13383122f, 0.04317586f, 0.06415491f, 
    0.07958181f, 0.10532361f, -0.11849768f, 0.00896304f, -0.01791058f, 0.06165798f, -0.06276076f, 0.05937989f, 
    -0.18655401f, 0.34147525f, 0.14868736f, -0.17720149f, -0.08314839f, 0.07548494f, 0.02621327f, 0.06774973f, 
    -0.06977223f, -0.00238863f, 0.01935653f, 0.09438115f, -0.08189712f, 0.32738128f, 0.03177495f, 0.08893976f, 
    -0.05336041f, -0.01876071f, -0.03488977f, 0.04079598f, -0.02226629f, -0.05227916f, 0.10252836f, -0.06630207f, 
    0.28393358f, 0.08011466f, 0.14234866f, 0.01462522f, 0.00466908f, 0.11014372f, 0.08641500f, 0.01137552f, 
    -0.00169398f, -0.07607846f, -0.04752415f, -0.08419810f, 0.18661657f, 0.30860254f, -0.12608601f, 0.06329845f, 
    -0.05159886f, -0.12056182f, 0.02129180f, -0.03193783f, 0.01177127f, -0.00328446f, -0.06943718f, -0.02509678f, 
    0.17496802f, 0.17915206f, -0.04610654f, 0.00463815f, -0.03910895f, -0.03035516f, -0.03091757f, -0.00626669f, 
    -0.04695508f, -0.08691948f, -0.00113500f, 0.04018975f, 0.27891114f, 0.14161210f, -0.13972259f, 0.09727789f, 
    -0.08788121f, 0.03522398f, 0.03774507f, -0.14683917f, 0.16304415f, -0.15512143f, -0.01731441f, 0.03915497f, 
    -0.29873231f, -0.14705144f, 0.16783252f, 0.17529571f, -0.13444002f, 0.14488591f, 0.08266788f, 0.02154360f, 
    0.00709125f, -0.05630331f, -0.04222317f, 0.04987150f, -0.34134802f, -0.00303928f, 0.07126927f, -0.00726976f, 
    -0.03999522f, 0.14541867f, 0.02759575f, 0.06112726f, -0.04300950f, 0.07523415f, 0.13624661f, -0.00795590f, 
    -0.06716734f, -0.09710663f, -0.00440800f, 0.01755136f, 0.02393874f, -0.02297415f, -0.00079857f, 0.09097736f, 
    -0.05761905f, -0.03198524f, -0.02371502f, -0.05703044f, -0.07615422f, -0.05404566f, 0.11689071f, 0.24800104f, 
    -0.00881789f, 0.01989996f, 0.07709924f, 0.01801463f, 0.01226396f, 0.05913526f, 0.08011044f, -0.00781952f, 
    0.05521178f, -0.16947760f, 0.08447582f, 0.02889353f, 0.06514170f, 0.06125130f, 0.07600974f, -0.05418634f, 
    0.10838430f, -0.05288973f, 0.07975785f, 0.03589373f, -0.04557834f, -0.04920423f, -0.01936585f, -0.03297568f, 
    0.12273820f, 0.11178716f, -0.02621279f, 0.10740811f, 0.00234705f, -0.01751379f, -0.02221350f, 0.09541953f, 
    -0.12299266f, -0.00829279f, 0.16478755f, -0.06649783f, 0.13557251f, 0.16679871f, -0.02044682f, 0.02568049f, 
    -0.11315873f, 0.02109527f, 0.09209213f, 0.02226043f, 0.05372210f, 0.08546277f, -0.03591807f, 0.04724372f, 
    -0.07578211f, 0.02391023f, -0.01694047f, -0.06662482f, 0.03281090f, 0.02806774f, -0.01393199f, 0.03286403f, 
    0.12683408f, 0.12330367f, -0.15391900f, -0.19952974f, 0.01901894f, -0.05470939f, 0.01889974f, 0.04134423f, 
    0.04628646f, 0.03539965f, 0.02308892f, 0.08677369f, 0.32297966f, 0.21391051f, -0.07818891f, -0.01124606f, 
    -0.09649716f, -0.06078218f, 0.06964536f, 0.03016444f, 0.06141510f, 0.07509867f, -0.00551236f, -0.03595949f, 
    -0.05066068f, 0.17489970f, -0.07951370f, -0.06806560f, 0.18034485f, 0.04508569f, 0.04216327f, -0.01094647f, 
    0.04741418f, -0.00688019f, 0.02261192f, 0.11000305f, -0.10892020f, 0.34952208f, 0.18298832f, -0.02331020f, 
    -0.08057809f, -0.02927945f, 0.00765503f, -0.04837562f, -0.14158286f, -0.02196153f, 0.00328829f, -0.04048590f, 
    -0.15872438f, 0.13484003f, 0.19276190f, -0.02114887f, -0.12022226f, -0.01150507f, 0.07493743f, -0.00508963f, 
    -0.08183160f, 0.03729711f, -0.11469557f, 0.03251273f, 0.00196084f, 0.20103630f, 0.06016869f, -0.00396509f, 
    0.03363482f, -0.03531322f, 0.05583021f, 0.13961437f, 0.04063920f, 0.12149803f, -0.06341602f, -0.06922717f, 
    0.15746126f, -0.00898501f, -0.07889518f, -0.04503518f, 0.08675117f, -0.00206065f, 0.01540875f, -0.07425456f, 
    0.13075151f, 0.11570805f, -0.01323914f, -0.07419893f, 0.12502174f, -0.13072345f, 0.09362236f, -0.19032903f, 
    -0.04203683f, 0.07910245f, 0.10167165f, 0.03459166f, 0.16343635f, 0.07012708f, 0.01605037f, -0.03160679f, 
    0.06658047f, 0.13135093f, 0.01343148f, 0.02839573f, 0.05373764f, -0.00396479f, 0.00678836f, 0.05818980f, 
    0.15675402f, 0.03478056f, 0.02302092f, -0.02195274f, 0.17619734f, -0.15710469f, 0.05037908f, -0.02101162f, 
    -0.01861358f, -0.00670823f, 0.06502287f, -0.02167004f, -0.10239865f, 0.03330638f, 0.12776047f, -0.02096302f, 
    0.22783473f, 0.18457446f, -0.01306965f, -0.10070670f, -0.12803973f, -0.03077492f, -0.07467163f, 0.04596289f, 
    -0.00598047f, -0.02041171f, -0.02025175f, -0.04178148f, 0.08131503f, 0.09643864f, -0.04792605f, -0.02024663f, 
    -0.00298475f, 0.05653265f, -0.08748697f, -0.06353074f, 0.02593998f, 0.07718886f, -0.02207817f, 0.16985905f, 
    -0.24019049f, -0.10612680f, 0.15567918f, -0.00329143f, -0.03994196f, 0.06333496f, 0.10819128f, -0.05166800f, 
    -0.01873018f, -0.12354317f, 0.02053297f, 0.09055436f, -0.03850713f, -0.03369616f, 0.10681400f, 0.00149617f, 
    -0.10926861f, -0.01437410f, 0.10306770f, 0.03370421f, -0.05146645f, -0.06777540f, 0.05751604f, -0.06480739f, 
    -0.17529379f, 0.15947883f, -0.06541651f, 0.09150546f, 0.06622073f, 0.03755654f, 0.03138880f, -0.02338003f, 
    0.03795177f, -0.09218663f, 0.00043186f, -0.02366478f, 0.33977038f, 0.06548538f, 0.02965649f, -0.11406434f, 
    0.05977326f, 0.02626264f, -0.04312424f, 0.08439583f, 0.01840342f, -0.02053933f, 0.08242134f, 0.06407925f, 
    0.14719923f, 0.11302752f, 0.04241825f, 0.20042674f, 0.02507558f, -0.00338522f, 0.08048841f, -0.03380292f, 
    -0.15207495f, -0.05074110f, -0.05411586f, 0.03959420f, 0.13677059f, 0.01706619f, 0.07056887f, -0.08411849f, 
    -0.01819129f, -0.00334639f, 0.13780154f, 0.09997683f, 0.10078499f, 0.00763682f, 0.13381203f, -0.09452748f, 
    -0.14859396f, 0.18971699f, 0.05590938f, -0.06489003f, 0.11208559f, 0.13771172f, -0.00315285f, 0.06331080f, 
    0.03431102f, -0.04318789f, 0.01990048f, -0.00546464f, 0.07351304f, 0.07931038f, -0.11086068f, 0.05570618f, 
    0.00787415f, 0.02551571f, 0.00446707f, 0.00304935f, -0.12491782f, -0.03188556f, 0.12455820f, 0.04374115f, 
    0.05516579f, -0.04399646f, -0.13217306f, -0.01495862f, 0.04519008f, 0.10613463f, 0.04020333f, -0.05412542f, 
    0.00956267f, 0.00837026f, 0.04350566f, -0.02371262f, 0.25483575f, -0.14984421f, 0.17733586f, -0.07759128f, 
    0.01288197f, 0.08322483f, -0.02003832f, 0.01026542f, 0.02106210f, -0.04873463f, -0.00785817f, -0.12764344f, 
    -0.08443475f, -0.12578592f, -0.04294151f, 0.05180604f, -0.08719026f, 0.05886591f, 0.01578630f, 0.03407339f, 
    -0.03450639f, -0.03278124f, 0.07364285f, 0.07887085f, -0.18637620f, 0.23560099f, 0.10466529f, 0.05020476f, 
    -0.00089762f, 0.17146890f, 0.03441935f, -0.01584118f, -0.00288629f, 0.01374102f, -0.01191768f, -0.01877302f, 
    -0.05881136f, 0.31067732f, 0.00501579f, -0.04083984f, -0.02369168f, 0.03447405f, 0.05467885f, 0.05117168f, 
    -0.05693059f, 0.08587508f, -0.04328704f, 0.04177010f, 0.00284563f, -0.32228026f, 0.08781746f, 0.06168964f, 
    -0.09017434f, -0.05049676f, -0.01265303f, 0.04463565f, -0.04165376f, -0.06670310f, 0.03913236f, -0.01720861f, 
    0.00541393f, -0.00911911f, 0.00808940f, 0.02608554f, 0.02657682f, -0.02242336f, -0.02035204f, -0.03407857f, 
    -0.00121146f, 0.02136843f, 0.01227732f, -0.02661664f, -0.00352240f, -0.03152371f, 0.01534037f, 0.00369346f, 
    -0.03344315f, 0.00419294f, 0.01200922f, -0.02851501f, -0.03794065f, -0.00088632f, 0.00531825f, -0.03271409f, 
    0.00066384f, 0.03377042f, -0.00162856f, -0.02989503f, -0.02526104f, 0.00493935f, -0.02539316f, 0.00451717f, 
    0.00082212f, 0.03000294f, -0.03832773f, -0.00944209f, 0.02365092f, 0.00078895f, 0.00593981f, -0.01330017f, 
    -0.01532361f, 0.01012806f, 0.02112041f, 0.02982383f, 0.00684193f, 0.01497816f, -0.00694661f, -0.03355329f, 
    -0.02955634f, -0.00598481f, -0.02260763f, -0.01742556f, 0.01328173f, -0.02005031f, -0.04151901f, -0.00061621f, 
    -0.02348605f, -0.03645471f, -0.03773919f, -0.01089158f, 0.01867628f, -0.00221879f, -0.02718368f, 0.01087719f, 
    -0.01731434f, -0.00089361f, -0.02207192f, 0.00583628f, -0.03197492f, 0.02416199f, -0.00234553f, 0.03357834f, 
    -0.01148583f, 0.00574190f, 0.02329010f, 0.02720386f, 0.00355174f, -0.00381669f, -0.02031005f, -0.03887287f, 
    -0.03733155f, -0.00087687f, -0.01158455f, 0.00652220f, 0.02177115f, -0.03356254f, -0.01554670f, 0.00256012f, 
    -0.03349261f, -0.02757233f, 0.00198436f, -0.00922873f, -0.02277797f, 0.01182094f, -0.01391907f, -0.03701414f, 
    0.02277654f, -0.00220655f, -0.00395299f, 0.01123768f, 0.00548050f, -0.03643724f, -0.00751051f, -0.00194231f, 
    -0.00334965f, -0.01654402f, 0.00639844f, 0.01153334f, 0.01592161f, -0.00372164f, 0.00891084f, -0.00395576f, 
    -0.00599902f, 0.02233270f, -0.01697852f, -0.03644054f, -0.00029396f, 0.00589506f, 0.00971834f, 0.00346258f, 
    -0.01919376f, -0.01371867f, -0.02903926f, 0.02111063f, 0.02632650f, -0.02351704f, -0.02831506f, -0.02025003f, 
    0.00039620f, 0.00765504f, -0.01400289f, 0.01388329f, 0.00549302f, 0.01699411f, -0.03722654f, -0.00880955f, 
    -0.03178682f, 0.02164310f, -0.03523128f, -0.03369104f, 0.01191900f, 0.02562673f, -0.02070133f, -0.00224582f, 
    0.00804311f, 0.00457287f, -0.04515512f, -0.00126044f, -0.02288841f, -0.01282335f, 0.02154484f, -0.04035202f, 
    -0.04048903f, 0.01976909f, -0.01894900f, 0.01303428f, 0.02412748f, -0.01099416f, 0.00649720f, -0.02023596f, 
    -0.00005930f, -0.01577483f, -0.03026143f, -0.00171670f, -0.03733002f, 0.03060533f, 0.02058697f, 0.00963367f, 
    -0.03188305f, 0.02329073f, 0.01176246f, 0.00140652f, 0.00447832f, 0.01305625f, -0.00323578f, 0.02296278f, 
    -0.00278903f, -0.03221698f, 0.02796855f, 0.02224755f, -0.03487159f, -0.03561630f, -0.01735377f, -0.00961092f, 
    -0.01805155f, -0.00601435f, 0.02075851f, 0.01347980f, -0.03642049f, -0.02829999f, -0.00150267f, -0.00365834f, 
    -0.02629150f, -0.01385702f, 0.03158073f, -0.03726018f, 0.01414382f, -0.03794954f, 0.00390742f, 0.01401895f, 
    -0.02046860f, 0.00300584f, -0.01181379f, 0.01641002f, 0.01809156f, 0.02414407f, 0.01168439f, -0.01393948f, 
    -0.03583034f, -0.00036700f, 0.02725929f, -0.03537371f, -0.02371922f, -0.00016728f, -0.02150658f, -0.00134741f, 
    0.01473876f, -0.04320405f, -0.02283190f, -0.03419850f, -0.01981495f, -0.01429298f, -0.04112275f, -0.02328122f, 
    0.02451635f, -0.00219607f, -0.02454902f, 0.01541447f, 0.02201913f, 0.00654965f, -0.03680794f, -0.00882856f, 
    0.01788747f, -0.03183251f, -0.00444808f, -0.02712976f, 0.00716257f, -0.01438319f, -0.01215691f, 0.00881335f, 
    0.00490341f, 0.01644065f, -0.02172419f, -0.03829376f, -0.03268326f, 0.00587355f, 0.00831864f, -0.01115878f, 
    0.02382733f, -0.04137203f, -0.01245644f, -0.00062940f, 0.01694338f, -0.00150893f, 0.01578017f, 0.00529775f, 
    -0.04373344f, -0.02599875f, 0.00141493f, -0.03475064f, 0.02060117f, 0.00696548f, 0.01645610f, 0.00904747f, 
    -0.00618502f, -0.00508685f, -0.00384254f, -0.01694005f, -0.03998252f, -0.03065683f, 0.01069783f, -0.01287289f, 
    -0.03680265f, 0.01673552f, -0.01239408f, -0.02394833f, -0.00901158f, 0.02465347f, -0.03623062f, -0.03435687f, 
    -0.00897037f, 0.01412658f, -0.02963604f, -0.04029369f, -0.00362417f, -0.01003142f, -0.01806011f, 0.01644039f, 
    -0.02396573f, -0.00357952f, -0.01796552f, -0.01565061f, -0.03280867f, 0.01054228f, 0.02131689f, -0.00432075f, 
    -0.01505586f, 0.01887588f, 0.02698275f, 0.00428213f, -0.00946186f, 0.00292300f, -0.03110770f, 0.02169409f, 
    0.01939801f, -0.03870134f, -0.00554051f, -0.00981853f, -0.03294744f, -0.03536041f, 0.01424240f, -0.01300654f, 
    -0.02008521f, -0.03773507f, -0.01302037f, -0.02085214f, 0.00127932f, 0.01558905f, -0.01864208f, -0.01147574f, 
    -0.04421737f, 0.01061000f, 0.01943298f, 0.01233385f, -0.01592265f, 0.00584530f, -0.02701552f, -0.02859508f, 
    -0.00805659f, 0.02702648f, 0.01890213f, -0.00309688f, -0.01161474f, 0.00608891f, 0.00230301f, 0.01087263f, 
    -0.00986916f, -0.03306794f, -0.01331646f, 0.02251181f, 0.01180025f, -0.03728547f, -0.01366419f, 0.00579529f, 
    0.00797652f, -0.03378081f, -0.01996080f, 0.02726427f, 0.01120294f, -0.00755485f, 0.01592776f, -0.01647190f, 
    0.02818165f, -0.00316567f, 0.00857487f, 0.00973175f, -0.02809381f, -0.03867841f, 0.01933309f, -0.02683583f, 
    0.01108841f, 0.00434704f, 0.00401104f, -0.03550639f, -0.00196453f, -0.00635485f, -0.04213390f, 0.02263051f, 
    -0.00393535f, 0.02336668f, 0.01894439f, -0.01323430f, 0.00615692f, -0.03159293f, -0.02106211f, -0.02168020f, 
    -0.01434348f, -0.03591608f, 0.00403584f, -0.01385925f, 0.00707870f, -0.00424975f, 0.01267883f, 0.00884951f, 
    0.00402756f, -0.02963546f, 0.02949459f, -0.03617362f, 0.01788735f, 0.00062305f, -0.01918449f, 0.01596623f, 
    -0.00832022f, 0.00421296f, 0.02730485f, 0.02577674f, -0.03140336f, -0.03143780f, -0.03437396f, -0.03864390f, 
    -0.01783845f, 0.01357196f, -0.04279415f, 0.00737853f, -0.03298302f, -0.00377823f, 0.00945975f, -0.00081507f, 
    0.00649308f, 0.00705115f, 0.02200232f, -0.01708229f, -0.00510791f, -0.01621246f, -0.03799738f, -0.02866650f, 
    0.02049023f, 0.02645407f, -0.01940861f, 0.01432257f, -0.03624206f, -0.01033918f, -0.00246871f, 0.01612083f, 
    -0.01249213f, 0.00803143f, -0.03663073f, 0.00983612f, 0.01663634f, -0.02130273f, 0.03238023f, -0.00992883f, 
    -0.02354304f, 0.02991651f, 0.00134538f, -0.03495168f, -0.01238048f, 0.02978557f, -0.01973808f, 0.02307042f, 
    0.00208941f, -0.02182559f, 0.03009022f, -0.02794765f, 0.01322328f, 0.01658743f, 0.01091663f, 0.00488627f, 
    -0.02738971f, -0.02661559f, 0.00172858f, -0.02955241f, -0.03818648f, 0.03094672f, -0.02381143f, -0.03692798f, 
    -0.03437394f, -0.00843901f, 0.02631595f, -0.00895109f, 0.00908350f, 0.03108047f, 0.01304394f, 0.02196863f, 
    -0.01050164f, -0.02457624f, 0.00932149f, -0.03389910f, -0.00191587f, -0.03539334f, 0.02524965f, -0.02344280f, 
    -0.00079267f, -0.00306451f, 0.02122167f, 0.02560397f, -0.01346744f, -0.00432867f, -0.01872944f, -0.00805194f, 
    -0.02553219f, 0.03444719f, 0.02001269f, -0.01662089f, 0.01373958f, 0.01971813f, -0.01915109f, -0.01318089f, 
    -0.03449132f, -0.01047779f, -0.02090971f, 0.02103698f, -0.00752652f, -0.01220682f, 0.01600013f, -0.01012163f, 
    0.01156543f, -0.03593283f, 0.00149440f, -0.03439450f, 0.01305689f, 0.02977171f, -0.03438605f, -0.01118508f, 
    -0.02313212f, 0.02173188f, -0.00679085f, 0.02713262f, 0.01275026f, -0.02367688f, -0.04118883f, 0.01205266f, 
    0.03004815f, 0.00767614f, -0.01755910f, 0.02078477f, -0.02637961f, 0.02269522f, -0.03850620f, -0.02387096f, 
    0.00086703f, -0.00513363f, -0.00458432f, -0.02880767f, 0.00172820f, -0.03701518f, -0.02535897f, 0.02351395f, 
    0.00115358f, -0.01037021f, -0.02973845f, -0.04259469f, 0.01267220f, 0.00979118f, -0.04005693f, 0.00143161f, 
    -0.00435021f, -0.03217696f, 0.02695678f, -0.01673696f, -0.01622161f, -0.00696275f, -0.00092672f, 0.01212048f, 
    -0.03200949f, 0.00728391f, 0.01525180f, -0.03435546f, -0.04173118f, 0.01796894f, -0.01467697f, -0.01223557f, 
    -0.00414881f, 0.00151235f, -0.00510193f, -0.03865334f, -0.00858255f, -0.00320737f, -0.03169441f, -0.00356629f, 
    0.00336954f, 0.00470877f, 0.02915899f, -0.01707618f, -0.03359177f, -0.01439545f, -0.01271946f, -0.01687262f, 
    0.01388440f, -0.01940134f, -0.00477068f, -0.00897309f, -0.03714335f, 0.00505190f, 0.00255741f, -0.01612176f, 
    0.02275036f, -0.01650715f, -0.00468207f, -0.03047385f, -0.00296804f, 0.00605068f, 0.00539751f, 0.02778299f, 
    -0.00400895f, 0.01746961f, -0.03359684f, -0.00930445f, -0.01677147f, 0.02357530f, -0.03646173f, 0.00452019f, 
    -0.00349219f, 0.02538440f, -0.01116777f, -0.03168707f, 0.01216222f, 0.02639462f, -0.00635081f, 0.02030081f, 
    0.01433323f, 0.02602125f, -0.03811114f, -0.01877409f, -0.02906360f, -0.00564108f, -0.04076391f, 0.00646742f, 
    0.00025786f, -0.03624162f, -0.03382255f, -0.01152332f, -0.00466976f, 0.00183480f, 0.00059312f, -0.03873544f, 
    0.00098185f, 0.01172467f, -0.00331025f, -0.04070411f, -0.03248405f, 0.00249734f, 0.02754369f, 0.02489963f, 
    -0.00119051f, -0.00257078f, 0.01765008f, 0.01291289f, -0.01768339f, 0.00195059f, -0.02716428f, -0.03322338f, 
    0.01970611f, -0.01491580f, -0.00816472f, -0.04183851f, 0.00202930f, -0.02331672f, -0.04256095f, -0.04014698f, 
    -0.01017364f, 0.03089410f, -0.02703403f, -0.02532671f, -0.01196824f, -0.01789460f, -0.01622398f, 0.02328409f, 
    0.02695045f, -0.02210273f, -0.00205324f, -0.00176907f, -0.01594008f, -0.02691852f, -0.03312964f, 0.03089049f, 
    -0.03706553f, -0.01262334f, -0.00532255f, 0.01594214f, -0.01006668f, -0.01471539f, -0.04014647f, -0.01477716f, 
    -0.01898726f, 0.02567276f, -0.03185019f, -0.01868796f, -0.02724822f, 0.02359696f, -0.01163785f, -0.02324814f, 
    -0.02360114f, -0.02706776f, 0.01055715f, 0.01759186f, 0.02608606f, -0.02724467f, -0.03105716f, 0.00656896f, 
    0.00805771f, 0.02064331f, -0.03185299f, -0.03966511f, 0.03217498f, -0.00171020f, 0.01953642f, 0.01231026f, 
    -0.00007826f, -0.01121802f, -0.02177547f, 0.01185653f, -0.03381921f, -0.01388968f, -0.00295355f, -0.01437840f, 
    -0.00820449f, -0.01693594f, -0.01893082f, -0.00597036f, 0.02306843f, 0.01849207f, 0.03219038f, 0.00800647f, 
    0.00150933f, -0.02566268f, -0.00702386f, -0.01359588f, -0.00876321f, -0.00994201f, -0.00072353f, -0.01480157f, 
    0.00622134f, -0.00929463f, 0.00610499f, 0.00080097f, -0.02438739f, -0.02977113f, 0.02721160f, -0.02397629f, 
    -0.01957659f, 0.00661164f, -0.00484120f, 0.02672072f, -0.01787669f, -0.01876217f, 0.00283486f, -0.00429841f, 
    -0.04109403f, -0.01678981f, 0.02603370f, -0.04403584f, 0.01500692f, -0.01740102f, -0.04295522f, 0.02647083f, 
    -0.02169018f, -0.04021594f, -0.03224081f, 0.00550600f, 0.00637649f, -0.02781065f, 0.00166196f, -0.03681932f, 
    0.02739324f, -0.00694718f, 0.00372990f, 0.02170538f, -0.00717990f, -0.03573495f, 0.02230157f, -0.03852442f, 
    -0.01934644f, -0.00604152f, 0.02312040f, 0.01086199f, 0.01558751f, 0.00064616f, -0.01732949f, 0.00464720f, 
    -0.01936465f, 0.00243505f, -0.01184919f, 0.00765221f, 0.01239554f, -0.02012415f, -0.01210099f, -0.03200769f, 
    -0.01618766f, 0.01398488f, -0.04052089f, -0.00436451f, 0.02471290f, -0.00490282f, 0.01760255f, -0.04046277f, 
    0.00143975f, -0.02270665f, 0.00973377f, 0.00735468f, -0.02743673f, 0.00114735f, -0.02526162f, -0.02246635f, 
    -0.00574532f, 0.01169535f, 0.00882269f, 0.00809153f, 0.03004586f, -0.00763722f, -0.02865314f, -0.03733838f, 
    -0.02320886f, 0.02041438f, -0.00871896f, 0.00891740f, 0.00716837f, 0.00634166f, -0.02133023f, 0.01385245f, 
    -0.00353041f, -0.00053435f, 0.00545836f, 0.02327616f, -0.03660360f, 0.01164251f, -0.02167381f, -0.04044657f, 
    -0.03646019f, -0.01129622f, 0.00541340f, 0.01052297f, 0.01169395f, -0.03177523f, 0.01230636f, 0.00589238f, 
    0.01530567f, -0.00204055f, -0.03241397f, 0.01089752f, 0.00541170f, 0.00452371f, -0.01407360f, -0.03827588f, 
    -0.03442142f, 0.01580793f, -0.03355041f, 0.01407130f, -0.02136918f, -0.01412290f, -0.03705211f, 0.01953084f, 
    -0.02577716f, 0.00777126f, -0.01458678f, -0.00541317f, 0.02028539f, -0.00702347f, -0.03125082f, 0.02181910f, 
    0.01467121f, -0.00962298f, -0.00684855f, 0.00361482f, -0.03677644f, -0.03499888f, -0.01654466f, -0.02724729f, 
    -0.03143767f, 0.03033284f, -0.03756696f, -0.00113112f, -0.03725150f, 0.00698720f, 0.02867381f, -0.03117777f, 
    -0.02816428f, -0.01989106f, -0.04061406f, 0.01975948f, -0.03386092f, -0.01772360f, -0.03990680f, 0.01023377f, 
    0.02378492f, -0.00110092f, 0.00561976f, 0.03021354f, -0.00555574f, -0.02838380f, 0.02430299f, -0.03525811f, 
    -0.00551422f, 0.01019303f, 0.02309427f, -0.03712953f, 0.01994983f, -0.03033242f, 0.02659394f, -0.01458752f, 
    -0.01836833f, 0.00635623f, -0.04111948f, -0.03605736f, -0.00142819f, -0.00246914f, 0.01490598f, 0.02993807f, 
    -0.03717251f, 0.02271294f, 0.00755779f, 0.00617368f, 0.00290384f, 0.00870631f, 0.02253953f, 0.00533198f, 
    -0.03282376f, -0.02038031f, -0.02610104f, -0.01370896f, 0.01723741f, 0.01233980f, -0.01239897f, -0.03436788f, 
    -0.01559124f, -0.02508278f, 0.02509048f, 0.00372972f, 0.00893265f, 0.02757251f, -0.01382465f, 0.02410099f, 
    -0.00224098f, -0.01368604f, 0.00042880f, -0.02266776f, 0.00282416f, -0.03511298f, -0.00084471f, 0.02589586f, 
    -0.03712107f, -0.02830469f, -0.03603088f, -0.00124073f, -0.00543294f, -0.00888565f, -0.04078772f, -0.00059466f, 
    0.02056206f, -0.00478844f, -0.01706753f, -0.01831426f, 0.02279458f, 0.01312358f, -0.01216529f, -0.03878171f, 
    -0.02304131f, -0.02401400f, -0.00752784f, 0.03333201f, -0.00057585f, 0.02734429f, 0.02615341f, -0.00004538f, 
    0.01977476f, -0.02221347f, 0.00999563f, 0.00702741f, 0.02136474f, -0.03460604f, -0.01893242f, -0.01781077f, 
    0.02351790f, 0.00498792f, 0.02900221f, -0.03607705f, 0.02930116f, -0.00320020f, -0.02510404f, -0.02692682f, 
    -0.01191315f, 0.01965282f, -0.00289540f, -0.03283911f, 0.00873169f, -0.03079618f, -0.01755493f, 0.01295774f, 
    0.00811632f, -0.03341102f, -0.03907121f, 0.00209999f, -0.02523658f, 0.00494576f, -0.03053623f, -0.00094461f, 
    0.02960276f, -0.00077644f, 0.01299011f, -0.03460230f, 0.02826890f, -0.01085533f, 0.01646196f, 0.01335199f, 
    0.00232348f, -0.03837691f, 0.00785452f, 0.00761920f, 0.03464348f, 0.03183418f, -0.04089274f, 0.00604834f, 
    0.02745781f, -0.01631603f, -0.02683690f, 0.01304257f, -0.00133542f, -0.02591280f, -0.03997977f, 0.00829866f, 
    0.00762768f, -0.03960709f, -0.02368954f, -0.00598178f, -0.00902447f, -0.02191743f, -0.00321568f, -0.03075635f, 
    -0.03721144f, -0.04090011f, 0.02347180f, -0.03241800f, -0.00666635f, -0.03516142f, 0.01927506f, 0.00506651f, 
    0.00980532f, 0.00602910f, 0.00006332f, -0.01183930f, -0.00824807f, 0.01420602f, -0.04118576f, -0.00461778f, 
    0.01879509f, -0.02027109f, 0.01391623f, -0.02236455f, 0.00284632f, 0.00195649f, -0.00729871f, -0.00891138f, 
    -0.01931659f, -0.01223347f, 0.01973756f, -0.02959892f, -0.01113830f, -0.01890745f, -0.04025678f, 0.01763777f, 
    -0.02447782f, -0.01123131f, -0.02942634f, 0.02442284f, 0.02670604f, -0.02741769f, 0.02557527f, -0.00574527f, 
    0.01889295f, -0.01215741f, -0.02191634f, -0.00952770f, -0.03040584f, -0.01587337f, 0.00279914f, -0.03423917f, 
    -0.03043527f, -0.00594998f, -0.00649083f, -0.01227701f, 0.02047189f, 0.02422774f, -0.00151715f, -0.00231905f, 
    -0.02142770f, -0.03814309f, 0.00375904f, 0.01483514f, 0.00644414f, -0.03403120f, -0.02807075f, -0.01576836f, 
    0.00434107f, 0.03114592f, -0.01642179f, 0.01217486f, 0.00689615f, -0.01695990f, 0.01482925f, -0.03026463f, 
    -0.01037403f, -0.03309921f, 0.02580630f, 0.01731911f, -0.02617941f, -0.01286003f, 0.01287586f, -0.02140491f, 
    -0.00498178f, 0.00930204f, -0.02972337f, -0.00409009f, -0.02116785f, 0.00122409f, 0.01111645f, -0.01280625f, 
    -0.01465796f, -0.04082242f, -0.03975917f, 0.00568095f, -0.03207305f, -0.02493625f, -0.03546907f, 0.01155543f, 
    0.03040718f, 0.00736184f, 0.03002182f, -0.01584512f, -0.03273451f, -0.02902665f, 0.01622321f, 0.00787761f, 
    0.02776496f, -0.01787488f, -0.02722388f, -0.00643501f, -0.02325090f, 0.01183600f, -0.01155513f, -0.03807476f, 
    -0.01816317f, 0.01971495f, 0.01656496f, -0.03244825f, -0.03596101f, 0.00780528f, 0.00713265f, -0.03663190f, 
    -0.01303414f, -0.03757670f, -0.03443226f, -0.00623440f, 0.00195571f, 0.02216472f, -0.02584641f, -0.03565315f, 
    0.02470425f, 0.00845424f, -0.03320584f, 0.00606841f, 0.00398017f, 0.00590748f, -0.03415746f, 0.01302254f, 
    0.01299374f, 0.02720430f, 0.02053118f, -0.01292237f, 0.00866076f, -0.01463673f, -0.00863686f, 0.00833001f, 
    -0.01223393f, 0.00066015f, 0.01839730f, 0.01268461f, -0.03755131f, 0.00589999f, 0.02932976f, -0.00725640f, 
    -0.01805038f, -0.00711671f, 0.01908681f, -0.00096274f, -0.00626509f, -0.01079362f, 0.02727607f, -0.02708866f, 
    0.00984698f, 0.02679332f, -0.03926357f, 0.01222655f, 0.00880338f, -0.02234850f, 0.02476513f, -0.03292415f, 
    0.00964006f, 0.00316511f, 0.01028851f, -0.01901495f, 0.02704292f, 0.00948352f, 0.02860959f, 0.02171157f, 
    0.01228602f, -0.03940758f, -0.01766021f, 0.01370619f, -0.03464404f, -0.00570563f, -0.00219493f, -0.00623084f, 
    -0.00046982f, -0.03673349f, 0.01137722f, -0.00622174f, -0.03386162f, 0.01391691f, -0.03772015f, -0.04057363f, 
    -0.00091275f, -0.00738481f, 0.01098415f, -0.02261161f, -0.00436273f, -0.00838885f, 0.01794427f, -0.01796198f, 
    -0.02423435f, 0.02036496f, -0.00856051f, -0.03946452f, -0.01300986f, 0.00381043f, 0.01922145f, 0.00570176f, 
    -0.03914319f, -0.00496813f, 0.01537242f, 0.02279303f, -0.02864345f, -0.00741684f, 0.02451620f, -0.02753274f, 
    -0.00678680f, 0.01351812f, -0.00687872f, -0.02023370f, -0.00427521f, 0.00367133f, -0.02404945f, 0.02646517f, 
    -0.00688404f, -0.00521134f, -0.01027999f, -0.00457052f, -0.02753385f, -0.02915248f, 0.00138505f, 0.01013306f, 
    -0.04071130f, -0.00302194f, 0.00764931f, 0.01790285f, 0.02649038f, -0.00220650f, -0.02162591f, -0.00142306f, 
    0.01236051f, -0.00774331f, 0.00341366f, 0.03063665f, 0.01117659f, -0.02037628f, -0.02698926f, -0.02786993f, 
    0.01775263f, 0.03459768f, 0.03071508f, -0.03423119f, -0.01478072f, 0.01324467f, 0.02056743f, -0.01632684f, 
    -0.02995964f, -0.01871992f, -0.00310141f, -0.01934533f, 0.01046579f, 0.00817261f, 0.01365974f, -0.03545368f, 
    0.01854404f, 0.02146315f, 0.01859246f, 0.00495079f, 0.02558228f, -0.02549031f, 0.01726495f, -0.01927706f, 
    -0.01347591f, -0.03832188f, -0.02954688f, 0.01665732f, -0.01274157f, 0.01639621f, -0.02573474f, 0.01560483f, 
    -0.01839301f, 0.01231519f, 0.00905817f, -0.01571884f, 0.01380485f, 0.02365381f, -0.03172795f, 0.00736577f, 
    -0.00793200f, -0.02954226f, -0.02644131f, -0.01480699f, -0.00658727f, 0.02142237f, 0.01037260f, -0.02354819f, 
    0.00106553f, -0.03764774f, -0.03964795f, 0.02983082f, 0.02171564f, -0.02394735f, -0.01537559f, -0.03560140f, 
    0.02430679f, 0.00983815f, -0.01401633f, -0.02469659f, -0.02755798f, -0.03130870f, 0.00287888f, -0.01969344f, 
    0.00009599f, -0.00216647f, 0.01189225f, -0.01491982f, 0.01488222f, -0.02771479f, 0.02939372f, -0.01607562f, 
    0.01825955f, 0.00008710f, -0.00250883f, -0.00079534f, 0.00936456f, 0.02298524f, 0.01073655f, -0.01479378f, 
    -0.03622759f, -0.02321121f, 0.02922850f, -0.01999756f, -0.02496552f, 0.00373824f, -0.00527561f, -0.01416904f, 
    -0.00406295f, -0.00145316f, 0.00975608f, -0.02469857f, 0.01885273f, -0.02468438f, 0.01130293f, -0.03379309f, 
    0.01960688f, -0.02882080f, 0.01398337f, -0.00364198f, -0.00564013f, 0.01445333f, -0.00663035f, -0.02469910f, 
    -0.02633839f, 0.00218412f, -0.00563513f, -0.03095042f, 0.02858254f, -0.02190948f, -0.03002976f, -0.02025309f, 
    -0.03484389f, 0.02077079f, 0.00242688f, -0.02405861f, 0.01382740f, -0.01005307f, -0.01373665f, -0.00054942f, 
    -0.01850561f, -0.00156252f, -0.03691477f, 0.01372979f, 0.01822329f, 0.01934718f, -0.03850451f, -0.03978722f, 
    -0.01183683f, 0.02790984f, -0.00921955f, -0.02888519f, 0.00456535f, -0.00701526f, -0.02033282f, -0.00637271f, 
    0.02157131f, -0.00718855f, -0.02884893f, -0.02531827f, -0.00678677f, -0.02897528f, -0.02260309f, -0.02610516f, 
    -0.00320151f, -0.03549964f, 0.02132834f, 0.02192408f, -0.03853223f, 0.01599641f, 0.00078851f, -0.01528189f, 
    0.00561651f, 0.02176031f, -0.02065053f, 0.02633233f, -0.01783102f, -0.02365987f, -0.03034692f, -0.01082064f, 
    -0.02087040f, 0.01344171f, -0.03644546f, 0.00000551f, 0.01388384f, -0.00275417f, -0.00073020f, -0.02311485f, 
    -0.01160457f, 0.00671817f, 0.02066688f, 0.00874472f, -0.01548926f, 0.00242526f, -0.03803149f, 0.01100440f, 
    -0.03181631f, 0.00510489f, -0.00448056f, 0.01462664f, 0.00021244f, -0.02021186f, -0.02957001f, -0.00274516f, 
    0.02771937f, -0.00913845f, -0.00155294f, 0.01365487f, 0.02537231f, -0.01689784f, -0.02527577f, 0.01988358f, 
    -0.03849647f, -0.01071942f, -0.03459124f, -0.00883711f, 0.00381174f, 0.02073694f, -0.03078823f, -0.00804051f, 
    -0.01327751f, -0.01279972f, 0.01076710f, -0.02923522f, -0.02142595f, -0.00318748f, -0.02515402f, -0.01459296f, 
    0.01512057f, 0.02389153f, -0.02911702f, -0.00586346f, -0.02999647f, -0.00681207f, -0.02342119f, -0.01431648f, 
    0.02237296f, 0.01322936f, -0.02184738f, -0.00340872f, -0.00041678f, 0.01335811f, -0.00088718f, 0.01471730f, 
    -0.01010911f, 0.02642243f, -0.04033672f, -0.02575750f, 0.02384225f, -0.00303540f, -0.02357005f, -0.02135299f, 
    0.01676085f, 0.00469833f, -0.03748376f, 0.02021191f, 0.02266687f, -0.01193479f, 0.00225790f, 0.00354911f, 
    -0.02210180f, -0.01256297f, -0.01099558f, -0.03408493f, -0.01546460f, 0.01104149f, -0.00122763f, 0.02488575f, 
    0.02458099f, -0.01375937f, 0.01239490f, -0.00929929f, -0.02265629f, -0.03631464f, 0.01731312f, 0.02049907f, 
    -0.01155846f, -0.01177835f, -0.00888737f, -0.03537882f, -0.01224080f, -0.03904001f, -0.01164420f, -0.03009999f, 
    0.02772014f, -0.02488129f, -0.01743660f, -0.02095991f, 0.00855531f, 0.00767827f, 0.02214883f, -0.04069647f, 
    -0.02867916f, -0.02955600f, 0.02966256f, -0.01232496f, -0.03809629f, 0.00107449f, -0.01024609f, 0.00423610f, 
    -0.01296167f, -0.03444167f, -0.03350495f, -0.01795222f, 0.02942543f, 0.02418886f, -0.01029984f, 0.01225942f, 
    0.00667509f, -0.03996108f, 0.02328133f, -0.02589312f, 0.00039126f, -0.03599284f, 0.01152803f, 0.02607372f, 
    0.02533878f, -0.02199080f, -0.00311602f, 0.00534154f, 0.00003816f, -0.03700553f, 0.00319561f, -0.03065665f, 
    0.01334903f, -0.01648623f, -0.00663367f, 0.02391263f, -0.00256520f, 0.00156973f, 0.01582206f, -0.01245742f, 
    -0.02258931f, 0.02623447f, 0.01262258f, -0.03760268f, 0.00577387f, 0.00279171f, -0.02966493f, 0.02371181f, 
    -0.01596701f, 0.01676077f, -0.03834921f, 0.01208650f, -0.02455627f, -0.02119359f, 0.01411805f, 0.02707873f, 
    -0.01867118f, 0.02782935f, -0.00460481f, 0.00907599f, -0.02561935f, -0.03702806f, -0.03392416f, 0.00436342f, 
    -0.01725139f, 0.02139921f, 0.01404477f, -0.00139250f, -0.01565720f, 0.02030989f, 0.01844181f, 0.02753366f, 
    -0.00748442f, -0.04070931f, 0.02692252f, 0.00480305f, -0.01739133f, 0.00055717f, -0.00643594f, -0.01366671f, 
    -0.01192487f, 0.00232631f, -0.01377903f, 0.01394621f, 0.00447879f, 0.00569567f, 0.02246902f, -0.01581177f, 
    0.00514174f, 0.00021236f, -0.04301943f, -0.01579703f, -0.00502405f, -0.02394925f, 0.02201927f, 0.00803890f, 
    0.01329781f, 0.02924327f, -0.03361908f, 0.00195337f, 0.00557060f, 0.02438462f, -0.02753640f, 0.01211027f, 
    -0.02036732f, -0.00149444f, 0.00904596f, -0.02355957f, -0.01763653f, 0.01542654f, 0.02031022f, -0.00542031f, 
    0.00928415f, -0.03873885f, -0.02036736f, -0.01345265f, -0.01339083f, 0.01685246f, 0.01242173f, -0.01688603f, 
    0.02289158f, -0.01815640f, 0.01751938f, 0.00450998f, -0.04103319f, 0.00660025f, 0.00102596f, -0.01881134f, 
    -0.02180672f, 0.00431555f, 0.01731343f, -0.02399059f, 0.02034757f, -0.02952580f, -0.03412655f, 0.02330464f, 
    -0.04399258f, -0.00253825f, -0.03827236f, -0.00985582f, 0.00167387f, 0.02103494f, -0.02566550f, -0.02539138f, 
    0.02298918f, -0.02889188f, 0.00678514f, -0.01937778f, -0.04484256f, 0.00165004f, -0.03694260f, 0.00585152f, 
    0.01028007f, 0.01564395f, 0.02743509f, 0.03774153f, 0.00759218f, -0.00585846f, -0.00820110f, 0.02089811f, 
    0.00049765f, -0.00016536f, 0.00345279f, 0.03399366f, -0.03300740f, -0.00474368f, 0.00397822f, -0.03307438f, 
    0.00144719f, -0.02203141f, -0.02874867f, -0.00504859f, 0.00911781f, -0.03638769f, 0.00309585f, -0.01621230f, 
    0.01435480f, -0.02092771f, 0.00838364f, 0.02231354f, 0.01784922f, 0.02404656f, -0.02564034f, 0.03267493f, 
    0.01505641f, -0.03679736f, -0.03889735f, -0.02576885f, -0.00161658f, 0.00020002f, -0.02015637f, -0.01454018f, 
    -0.04147796f, -0.03704690f, 0.02325749f, -0.03352108f, 0.03108733f, -0.01180242f, 0.00928519f, -0.00529551f, 
    0.01019419f, -0.02729559f, -0.03613257f, -0.04107961f, -0.01013898f, -0.02151589f, -0.01528197f, 0.01651300f, 
    -0.01760957f, 0.02052637f, -0.01019001f, 0.01113437f, 0.01645381f, -0.00216187f, 0.01738328f, 0.00825454f, 
    -0.02576675f, -0.00509038f, -0.02974109f, -0.00859814f, 0.00597870f, -0.02569477f, -0.02381556f, 0.03235541f, 
    -0.00477898f, 0.01103919f, -0.03771189f, -0.02126355f, 0.02508576f, -0.01195234f, 0.03041868f, -0.00448432f, 
    -0.01513768f, 0.02565512f, -0.00109520f, -0.03749924f, 0.00301641f, 0.02353292f, 0.02473309f, -0.02080606f, 
    -0.00319558f, -0.03565967f, -0.01904892f, -0.00136631f, -0.00252506f, -0.01288562f, -0.00844696f, -0.03055731f, 
    -0.04151670f, -0.00303828f, 0.01968067f, 0.00985709f, -0.01416819f, 0.00715953f, 0.02733729f, 0.03216662f, 
    -0.01083374f, 0.00304561f, -0.03601820f, -0.02737249f, -0.02624081f, -0.03089839f, -0.01215558f, 0.03558653f, 
    -0.02510752f, -0.03783172f, -0.00247125f, -0.00581683f, -0.01804355f, 0.01645296f, -0.00819927f, 0.00548788f, 
    0.02155970f, 0.02041311f, -0.04371200f, -0.02528626f, 0.00183725f, -0.03340464f, -0.01238171f, 0.00633464f, 
    0.01921000f, -0.01458602f, 0.00364846f, 0.01374849f, 0.00555800f, -0.02193597f, 0.00599574f, -0.03331929f, 
    -0.02856090f, 0.02111114f, 0.01891714f, 0.02203138f, -0.03341222f, -0.02380856f, 0.01066336f, 0.02524884f, 
    -0.01191981f, -0.02196483f, -0.04644452f, -0.00941372f, -0.02076444f, -0.03342342f, -0.03246193f, 0.01711920f, 
    -0.00129239f, -0.03093952f, -0.02741258f, -0.02112610f, -0.03012655f, -0.03369792f, -0.02360258f, -0.02961668f, 
    -0.00545030f, -0.00350438f, 0.00673698f, -0.02674745f, -0.01044970f, -0.04448523f, -0.00521931f, -0.01269324f, 
    -0.00642984f, -0.02967045f, 0.02018470f, 0.00924341f, -0.01032970f, 0.01426270f, 0.01940060f, -0.03179500f, 
    -0.03826271f, -0.02278703f, 0.00176513f, -0.04130937f, -0.04088359f, 0.01026376f, 0.00979538f, 0.00448608f, 
    -0.00778146f, 0.00899096f, -0.02396959f, 0.00086477f, 0.02038356f, -0.00670913f, 0.01614594f, -0.00813455f, 
    -0.01854274f, -0.04557679f, -0.02334326f, -0.01659206f, 0.00650783f, -0.01762986f, 0.00687944f, -0.04459148f, 
    -0.03301855f, 0.00083549f, -0.00802497f, 0.02349558f, -0.00479038f, -0.01637393f, -0.01980303f, 0.02563642f, 
    -0.03935476f, 0.01549234f, 0.00591449f, -0.00010713f, 0.00075468f, -0.01357421f, -0.03829948f, -0.00258617f, 
    0.01625121f, -0.03248530f, -0.02215384f, 0.02296260f, -0.01271738f, 0.01332527f, -0.02035969f, -0.02390478f, 
    0.02230301f, -0.02978171f, -0.01510023f, 0.00798376f, -0.01286095f, 0.01610558f, -0.04105309f, 0.01090902f, 
    -0.01921451f, -0.04517392f, -0.01133659f, 0.01353319f, -0.03728456f, -0.01810377f, 0.00225809f, 0.01475002f, 
    0.02142135f, -0.03917044f, -0.02176555f, 0.00034416f, 0.02733633f, 0.00758601f, -0.01829900f, 0.01394514f, 
    -0.01376364f, 0.00637822f, -0.00371725f, -0.03012771f, 0.01109474f, 0.02122154f, -0.03217385f, -0.03491559f, 
    -0.02685717f, -0.03735370f, -0.02369350f, 0.01873780f, 0.02222394f, -0.00028432f, -0.01879381f, -0.00411906f, 
    0.01855559f, 0.00459266f, -0.02608130f, -0.04146364f, -0.03543619f, 0.02789740f, 0.02122825f, 0.00987607f, 
    0.01813559f, -0.04305869f, 0.01264231f, 0.01646994f, -0.02866428f, 0.00307907f, 0.01867111f, -0.00820069f, 
    -0.00598516f, -0.00070028f, 0.02474119f, 0.02463488f, -0.00881515f, -0.03050253f, 0.00251483f, -0.01211083f, 
    -0.00884676f, -0.02938588f, 0.00731088f, 0.01586913f, 0.02019900f, -0.00879886f, -0.00263128f, 0.02240195f, 
    -0.01045233f, -0.01369080f, 0.02826606f, -0.03305529f, -0.01161520f, 0.02254760f, -0.03448072f, -0.01013590f, 
    -0.03215953f, 0.02639874f, 0.01657501f, -0.00396551f, -0.01568164f, -0.00407080f, 0.00421632f, 0.01944105f, 
    0.00393694f, -0.03082262f, 0.00445390f, 0.01284929f, -0.00932024f, -0.02936813f, -0.00372804f, -0.00029711f, 
    0.00226574f, 0.00382983f, -0.01096967f, -0.02644396f, -0.01281953f, -0.02238123f, 0.02535740f, -0.00902604f, 
    -0.01864417f, 0.01110919f, -0.02868922f, -0.00574259f, -0.04008624f, -0.02195399f, -0.02427551f, 0.00691553f, 
    -0.03108454f, -0.04015838f, -0.02247748f, 0.00375424f, -0.02428101f, -0.02844343f, 0.00100076f, -0.01466518f, 
    0.00159325f, 0.00455242f, -0.00244695f, 0.00911603f, -0.03102856f, 0.01810043f, 0.01655924f, 0.02468583f, 
    -0.02800656f, -0.00163574f, -0.03975589f, -0.03054697f, 0.01730645f, -0.00976483f, -0.02371927f, 0.02037994f, 
    0.02920048f, -0.03535609f, 0.01743117f, -0.03082853f, -0.03571280f, -0.00709355f, -0.02711160f, -0.02470535f, 
    -0.02168257f, -0.02648578f, 0.03050796f, -0.03670568f, -0.01635122f, 0.02445813f, 0.00986510f, -0.03695029f, 
    0.00433085f, -0.02735307f, -0.02929104f, 0.00744425f, 0.03242746f, 0.01458545f, 0.03106713f, -0.00813226f, 
    0.00556165f, 0.00612835f, 0.01482902f, -0.00457659f, -0.00141996f, -0.00462353f, -0.00225215f, 0.01959012f, 
    -0.00137622f, -0.04331914f, -0.01376118f, 0.00002223f, -0.00689186f, 0.02782676f, -0.00602102f, 0.01162953f, 
    0.01688802f, -0.01856628f, 0.01279555f, 0.00428096f, 0.02596062f, -0.01255723f, -0.01526107f, -0.04166943f, 
    0.00589985f, 0.01635322f, -0.00255183f, -0.04266585f, 0.00925373f, -0.02921688f, -0.01620860f, -0.03426609f, 
    -0.03714492f, 0.01406284f, -0.00456375f, 0.02479699f, -0.02579548f, 0.00731945f, -0.00018751f, 0.01655744f, 
    -0.03572494f, -0.00053273f, -0.04255663f, -0.00238789f, -0.02151431f, -0.02910527f, -0.01581653f, 0.01658785f, 
    0.01017047f, 0.01601682f, 0.02886327f, 0.00915622f, 0.00595731f, 0.01189044f, 0.01975022f, 0.02293764f, 
    -0.03225196f, 0.02780671f, -0.00995582f, -0.03156780f, -0.00969295f, 0.01084558f, 0.02385668f, -0.02453801f, 
    0.02487671f, -0.00475213f, 0.01088422f, 0.01360323f, -0.01995480f, 0.03139503f, 0.01180512f, 0.00354068f, 
    0.01287916f, 0.00581082f, 0.01668667f, -0.01130553f, 0.02024432f, -0.01508826f, -0.00553381f, -0.00048527f, 
    -0.02368313f, 0.02443796f, -0.04099666f, 0.00186916f, -0.01167095f, -0.03721266f, -0.02863716f, 0.01661322f, 
    0.02373772f, -0.01401422f, -0.00566988f, -0.00392766f, 0.00690048f, 0.01301751f, 0.02584207f, -0.02717485f, 
    -0.04615125f, 0.01180143f, 0.02104585f, 0.00692594f, 0.02492136f, 0.01764250f, -0.02311376f, -0.00930380f, 
    0.01077004f, 0.01398840f, 0.01437585f, -0.03549698f, -0.02731302f, -0.01775725f, 0.00324240f, -0.03845470f, 
    -0.01260501f, -0.03151470f, -0.00803221f, -0.01818640f, -0.02711078f, -0.01058201f, 0.02412740f, 0.01051030f, 
    -0.00558621f, -0.00784154f, -0.03527563f, 0.00888638f, 0.01547224f, -0.03995644f, -0.03022278f, 0.02659576f, 
    0.02617717f, 0.01455557f, -0.01714592f, -0.00174473f, 0.00565540f, 0.00178673f, -0.03391867f, -0.03607627f, 
    -0.03054918f, 0.02304704f, -0.02575143f, 0.00770955f, 0.01966061f, -0.00656444f, -0.02723146f, -0.03842232f, 
    -0.01393373f, -0.00540742f, -0.01474795f, 0.02441796f, -0.04070618f, -0.03522761f, -0.04530218f, -0.00716675f, 
    0.01853500f, 0.01897911f, -0.03266371f, -0.00306240f, -0.02782905f, -0.01812617f, 0.03068130f, -0.03489128f, 
    -0.00905677f, -0.03534181f, -0.00561357f, -0.00889890f, 0.00586448f, -0.00357261f, 0.02627452f, 0.01497251f, 
    -0.00436592f, 0.01483849f, -0.00241574f, -0.01808169f, 0.03079164f, -0.00043731f, 0.02081496f, 0.02019583f, 
    -0.02853308f, 0.02932244f, 0.02922174f, -0.02238058f, -0.01922329f, -0.03430702f, -0.02216662f, 0.00075800f, 
    -0.04630152f, -0.00630364f, 0.01966522f, -0.01755015f, -0.03956005f, -0.03951803f, 0.01218230f, -0.04318952f, 
    -0.03023207f, -0.02287561f, -0.01870419f, 0.00600498f, 0.01749233f, -0.00985498f, -0.03983265f, -0.02939651f, 
    -0.00889479f, -0.00352638f, -0.04050840f, -0.02223195f, 0.01597883f, -0.03931721f, 0.00578193f, -0.00270389f, 
    -0.03359795f, -0.02947938f, 0.02460013f, -0.00486015f, -0.01007592f, 0.02969725f, -0.03330267f, 0.01919406f, 
    -0.03794621f, -0.04055517f, -0.04458581f, -0.01473269f, -0.02496029f, -0.01349624f, 0.01925440f, -0.02809419f, 
    -0.00479923f, -0.02768678f, -0.02443837f, 0.02276231f, 0.00401248f, -0.03083227f, -0.01361365f, 0.00672150f, 
    -0.03361410f, -0.02630628f, 0.00509708f, 0.02491529f, 0.00785713f, 0.00036027f, 0.00887387f, -0.02727168f, 
    0.00938169f, -0.01838657f, 0.02730129f, 0.00258144f, 0.00676776f, -0.00818238f, 0.01563074f, -0.00936618f, 
    0.03307254f, -0.02360068f, -0.03705012f, -0.02023951f, -0.03886108f, 0.02514271f, -0.03914855f, -0.03399907f, 
    -0.04169613f, 0.00894783f, -0.01365225f, -0.02754240f, -0.01911007f, -0.01217610f, 0.00783750f, 0.00062226f, 
    0.00998380f, 0.00831362f, -0.00667135f, 0.01345830f, -0.01661009f, -0.02099405f, -0.03264900f, -0.02227039f, 
    0.00609111f, -0.01289423f, 0.01339314f, 0.02871408f, 0.01446965f, -0.03100417f, 0.01056549f, -0.03314494f, 
    -0.04261014f, -0.01057613f, -0.03704488f, -0.02354922f, -0.01694039f, -0.00994092f, -0.02537037f, -0.00311745f, 
    -0.03904456f, -0.03400897f, 0.01072110f, -0.03702761f, -0.04175928f, 0.00555399f, 0.00815861f, -0.00085742f, 
    -0.02676386f, -0.01300881f, 0.00118064f, -0.01982522f, 0.00236520f, 0.01142219f, -0.03009071f, 0.00008858f, 
    0.02557270f, -0.01009848f, 0.00677443f, -0.02911264f, -0.03321959f, -0.03635189f, -0.01777066f, -0.01276717f, 
    0.00501205f, -0.02288584f, -0.03110607f, 0.02174851f, -0.03808280f, 0.02161052f, 0.00435447f, 0.02032651f, 
    -0.01348436f, 0.01013435f, 0.01871393f, 0.03184648f, 0.02349849f, 0.02494363f, 0.01260374f, 0.01826122f, 
    -0.01929958f, 0.03926246f, 0.00596282f, 0.01111673f, -0.03217086f, 0.01492864f, -0.01992764f, 0.00114096f, 
    -0.01440830f, -0.01890050f, -0.02945820f, 0.02299586f, 0.00397143f, 0.00545908f, -0.01007474f, -0.03402419f, 
    0.01509009f, 0.01111752f, 0.00081450f, -0.03822551f, 0.01977638f, -0.02952895f, -0.00973621f, -0.00746777f, 
    0.02821095f, -0.04369894f, 0.01194336f, -0.02863106f, -0.03832240f, 0.02542883f, 0.02116838f, 0.01670705f, 
    -0.04120224f, 0.01885293f, 0.01775600f, -0.04357028f, 0.01307598f, 0.01230767f, -0.00426159f, 0.02413233f, 
    0.01454638f, 0.01693092f, 0.01881563f, -0.02565856f, -0.01370127f, 0.01111665f, -0.02304858f, -0.01229568f, 
    -0.01317401f, 0.00289579f, 0.02851975f, -0.01272470f, -0.01013706f, 0.02135969f, -0.00328921f, -0.02932103f, 
    -0.00492955f, -0.04238326f, -0.02131677f, 0.01868921f, 0.01183495f, 0.01189415f, -0.02813426f, -0.03394422f, 
    0.01500721f, 0.01654809f, -0.01838320f, 0.01669072f, -0.03710124f, 0.00043241f, 0.01980362f, 0.02246548f, 
    -0.02279836f, -0.02994427f, -0.00148741f, -0.03033026f, -0.02214771f, 0.01119491f, -0.02836989f, 0.00636130f, 
    0.02564959f, -0.03999120f, 0.01620097f, 0.01169208f, -0.01900582f, -0.02039999f, -0.01709449f, -0.00712172f, 
    -0.03086533f, -0.03509181f, -0.00420380f, -0.04247744f, -0.00294415f, 0.02807913f, 0.01451166f, -0.01356870f, 
    0.01102555f, -0.03657790f, 0.02273346f, -0.00116339f, 0.02943933f, -0.01283523f, 0.02852171f, 0.00835012f, 
    -0.01637623f, -0.02295274f, 0.02562859f, -0.00587618f, 0.00289573f, -0.02175429f, -0.01379133f, -0.02444209f, 
    -0.02296296f, 0.02535515f, 0.01404442f, -0.00153701f, -0.00449537f, 0.01608377f, -0.04136898f, 0.02398194f, 
    0.00875475f, 0.00532570f, -0.01390753f, 0.00146660f, 0.00877924f, 0.02345808f, -0.02130346f, 0.02266234f, 
    -0.00813112f, -0.01891286f, 0.00807791f, -0.04118502f, 0.00785999f, 0.00229872f, -0.02594055f, 0.00857673f, 
    0.00602706f, -0.03824864f, 0.00512564f, -0.03108968f, -0.01214723f, -0.01313305f, -0.00301877f, -0.02078487f, 
    0.00492231f, -0.01929424f, 0.00668211f, -0.00183886f, -0.03496085f, -0.03968666f, -0.01392314f, -0.03557808f, 
    0.01970988f, -0.00319488f, -0.01012953f, 0.02086849f, -0.01142043f, -0.00440933f, -0.00309437f, 0.00895255f, 
    0.02643624f, 0.01780979f, -0.03087029f, -0.03063368f, 0.00029515f, -0.04312525f, -0.02251003f, 0.00802902f, 
    -0.03510846f, -0.00486109f, -0.03285200f, 0.00841991f, 0.02271816f, -0.00450749f, -0.00001515f, 0.00433553f, 
    -0.03025212f, 0.01950244f, -0.00602097f, -0.00306076f, -0.00779452f, -0.02101358f, 0.00302692f, -0.00011864f, 
    -0.02389160f, -0.03360862f, 0.02244900f, 0.01772121f, -0.01479344f, -0.02933338f, -0.03159550f, 0.00573279f, 
    -0.00147072f, -0.01353764f, -0.02471454f, 0.02351330f, 0.02515276f, -0.01459825f, -0.00058289f, -0.04131157f, 
    -0.02937327f, -0.00955645f, 0.01865748f, -0.03936287f, 0.00041780f, -0.02471030f, 0.00163500f, -0.01546776f, 
    -0.01401494f, -0.03223151f, -0.00596467f, -0.02336704f, -0.01860526f, -0.01679066f, -0.03337594f, -0.02085349f, 
    -0.01242139f, -0.01384324f, -0.01275498f, 0.02638991f, 0.01890748f, -0.02820066f, 0.00927078f, -0.03269364f, 
    -0.02018144f, -0.00089763f, -0.02404150f, 0.02607561f, -0.03259530f, -0.01414453f, 0.00386964f, -0.01646689f, 
    -0.00000500f, 0.02323275f, -0.01389494f, -0.01989238f, 0.01816921f, -0.01517592f, 0.00163454f, 0.01334018f, 
    -0.04249199f, 0.00174396f, 0.02664184f, 0.02378616f, -0.00559122f, -0.02417612f, 0.00870250f, -0.01995418f, 
    0.01186836f, -0.03952585f, 0.00369154f, 0.00345718f, -0.00463064f, 0.00030242f, -0.00458306f, -0.01402478f, 
    0.00364711f, 0.02546930f, -0.02499825f, -0.02248604f, -0.04117693f, 0.01840151f, 0.01753592f, -0.01115154f, 
    0.02392219f, -0.03703565f, 0.02083621f, -0.03988271f, -0.03543755f, -0.01541837f, 0.00056815f, 0.01618319f, 
    -0.01153021f, -0.00942692f, 0.02156085f, -0.03375207f, 0.02229241f, -0.01096452f, -0.01019372f, -0.00224098f, 
    -0.02912266f, 0.00365774f, -0.02911406f, 0.00274325f, 0.02808573f, -0.00294397f, 0.00259451f, 0.01386921f, 
    0.00126941f, -0.03805124f, -0.03416974f, -0.03443760f, -0.03599210f, -0.02054675f, -0.03040278f, 0.01122900f, 
    -0.04010017f, 0.00857560f, 0.02521918f, -0.02112123f, -0.03310161f, -0.04383146f, 0.00039043f, 0.02355915f, 
    0.02549012f, -0.01049708f, -0.01576486f, -0.04399817f, -0.01660392f, 0.02771967f, 0.02039043f, 0.00436089f, 
    0.00866532f, -0.01541473f, -0.01682956f, -0.01719278f, 0.01415147f, 0.02091908f, -0.02416299f, -0.00715479f, 
    0.02409973f, -0.02355230f, -0.00231602f, -0.03000280f, 0.00469502f, -0.02316775f, -0.00873194f, 0.01006241f, 
    0.00407401f, -0.01598000f, -0.00424941f, -0.04241496f, 0.02001622f, 0.02603097f, 0.00327879f, -0.01413221f, 
    0.01834285f, -0.03765946f, 0.02187618f, 0.02421349f, 0.00433108f, 0.00884641f, 0.00530015f, -0.01564785f, 
    -0.02148377f, 0.00896911f, -0.03601347f, 0.00551212f, 0.01169272f, 0.01806862f, 0.00794414f, 0.02723753f, 
    0.02125807f, -0.02155216f, 0.01446957f, -0.00881091f, 0.02131873f, 0.03440619f, 0.02952190f, -0.01649181f, 
    -0.00064588f, -0.04113496f, -0.02122655f, -0.02933176f, 0.02731727f, -0.00647981f, -0.02679902f, 0.00696707f, 
    0.01972439f, 0.01437611f, -0.02305349f, -0.00087327f, -0.03500640f, 0.00915034f, 0.01159682f, -0.01160823f, 
    -0.01706395f, -0.02419157f, -0.02312930f, -0.02556491f, -0.01649889f, 0.02762485f, -0.01502756f, 0.01834996f, 
    -0.00049359f, 0.01465177f, -0.01071147f, -0.01219207f, -0.03302591f, -0.00379432f, -0.01716737f, 0.00500702f, 
    -0.03547624f, -0.01888857f, -0.03023949f, 0.01839127f, 0.01463336f, 0.01875931f, -0.00758973f, 0.02619427f, 
    0.01216632f, -0.00718154f, -0.02021678f, -0.00754265f, 0.00485298f, -0.02699380f, -0.03504581f, -0.00011257f, 
    -0.01625126f, 0.00626767f, -0.02840183f, 0.00346776f, 0.01904945f, 0.02872243f, -0.03473781f, -0.04336368f, 
    -0.01636187f, 0.01829206f, -0.00966576f, 0.00874909f, 0.00222349f, -0.01336552f, 0.00304574f, -0.02431172f, 
    0.00295967f, 0.00144093f, -0.02976375f, 0.01853460f, -0.02483311f, -0.02187596f, 0.01487727f, 0.01069903f, 
    -0.02330050f, -0.01096864f, -0.00724724f, -0.01632478f, -0.02164818f, -0.00146251f, 0.02771349f, -0.02212682f, 
    0.01561953f, -0.03334693f, -0.02485309f, -0.02789101f, 0.01095137f, -0.00742324f, -0.00501904f, -0.00156477f, 
    -0.04130724f, 0.02399615f, 0.02436167f, -0.00064576f, 0.01549828f, -0.03259489f, 0.02639944f, -0.02347308f, 
    -0.03006558f, -0.01347399f, -0.03776842f, -0.00376428f, -0.02022813f, -0.02768076f, 0.00181371f, -0.02459018f, 
    -0.01123979f, -0.03018069f, -0.03487744f, 0.00705074f, -0.04051727f, -0.01590085f, -0.02435221f, 0.00199728f, 
    0.01320965f, -0.03557355f, -0.04103744f, 0.02527777f, -0.03529100f, -0.03945411f, 0.02810971f, 0.02149563f, 
    0.00155773f, 0.02078675f, -0.00014519f, 0.02084581f, -0.02152207f, -0.04216468f, -0.00011467f, -0.03145907f, 
    0.01564776f, -0.02646365f, -0.04287010f, 0.02220518f, 0.02211908f, -0.00766541f, -0.03976317f, -0.00957031f, 
    0.00677903f, 0.00052932f, -0.00383670f, 0.00151183f, -0.03452778f, 0.01120833f, 0.00899130f, -0.00659985f, 
    -0.01969685f, 0.02484245f, -0.02752334f, -0.00692418f, -0.01143431f, 0.01388118f, 0.01729123f, -0.00331736f, 
    -0.02044110f, -0.01622104f, 0.02406638f, 0.01101997f, -0.01552052f, 0.01779662f, 0.00722987f, -0.00387399f, 
    -0.03279548f, -0.04228639f, 0.00582938f, -0.01104593f, -0.01931852f, -0.00477241f, 0.00911867f, 0.02079597f, 
    -0.02523200f, -0.02680134f, -0.03089074f, 0.02112651f, -0.01667944f, -0.01565133f, -0.00424179f, 0.02001751f, 
    0.01097543f, -0.01085300f, -0.00892515f, -0.00324580f, -0.01548345f, -0.01042033f, 0.01034232f, -0.04027947f, 
    -0.01800891f, 0.00156008f, 0.01354802f, 0.01291455f, -0.04091136f, 0.02803951f, 0.01644680f, -0.02206255f, 
    -0.00295236f, -0.00298083f, 0.01668502f, -0.03590389f, -0.01934341f, 0.02263981f, -0.03700760f, -0.02294728f, 
    -0.00734803f, 0.03608904f, -0.04309436f, -0.02678272f, 0.02321710f, -0.03548535f, 0.00453258f, 0.01856893f, 
    -0.02833572f, -0.01546133f, -0.00924702f, 0.02788940f, -0.03026848f, 0.02125488f, 0.00172033f, -0.03465179f, 
    -0.03843314f, 0.01913372f, -0.01786582f, 0.01380575f, 0.00743852f, 0.00531520f, -0.01428676f, -0.02629703f, 
    -0.02289086f, -0.04244651f, -0.02034402f, 0.00653968f, -0.03403100f, -0.00422082f, -0.00448805f, -0.00371025f, 
    -0.03445457f, 0.00445775f, -0.00590198f, -0.00379691f, 0.03094021f, 0.02307918f, 0.03624650f, -0.00465710f, 
    -0.01077695f, -0.01594765f, 0.02608406f, 0.01751619f, 0.00570331f, -0.02724130f, -0.00366548f, 0.01488422f, 
    0.01915646f, 0.00696880f, -0.04184847f, -0.00020868f, -0.03513816f, 0.01425243f, -0.03149125f, -0.03181886f, 
    0.01231877f, 0.01085800f, 0.00655330f, 0.02280331f, 0.01992254f, -0.01918062f, -0.02194459f, 0.01206462f, 
    -0.01234817f, -0.03738971f, -0.01907129f, -0.00573230f, 0.02627757f, -0.04006669f, -0.02542709f, -0.01521948f, 
    -0.00357397f, 0.01885989f, -0.02994734f, -0.00883828f, -0.02835499f, -0.01036998f, 0.02009480f, -0.01102535f, 
    -0.03769201f, 0.00534972f, 0.01572482f, -0.01713507f, 0.02278358f, -0.03570926f, 0.01117669f, 0.00413849f, 
    -0.01283909f, 0.02560796f, -0.02315119f, -0.02645209f, 0.02316016f, -0.01446208f, -0.02381595f, 0.02752773f, 
    0.01232677f, -0.01388242f, -0.01556025f, -0.02583720f, -0.03944254f, 0.01224089f, -0.01878503f, -0.00570110f, 
    0.02282946f, 0.01968877f, 0.01937862f, -0.03749149f, 0.00484595f, -0.02080666f, 0.00015106f, -0.02368084f, 
    0.00961080f, -0.03205031f, -0.00376766f, 0.01175843f, -0.03892615f, -0.02788094f, -0.02956148f, 0.01821882f, 
    -0.12261291f, 0.08037085f, 0.03978140f, -0.05356620f, 0.07800208f, 0.11994278f, -0.01587651f, -0.03115727f, 
    -0.01477243f, -0.04558931f, 0.01786453f, -0.05571583f, 0.26118764f, 0.07104173f, -0.01349884f, -0.14507349f, 
    0.08759690f, 0.06041509f, -0.00720643f, -0.08190800f, -0.07285094f, -0.06481580f, -0.06123940f, -0.10562477f, 
    -0.06261627f, 0.04165126f, 0.01979043f, 0.09475128f, -0.04517982f, 0.04283567f, 0.02210255f, 0.04458614f, 
    0.05428725f, 0.08841377f, -0.04223787f, 0.02449036f, 0.13490377f, -0.08965032f, 0.02740541f, 0.04506637f, 
    -0.08868643f, 0.07134234f, -0.09576850f, 0.06295348f, 0.01805372f, 0.00064835f, 0.04177400f, -0.14183055f, 
    0.03302913f, 0.14532173f, 0.11159147f, 0.01836952f, 0.05749801f, 0.06906229f, 0.03134865f, -0.07776490f, 
    0.06404810f, -0.00449425f, 0.02493545f, -0.01390878f, 0.00649333f, 0.08500656f, 0.07126068f, -0.00219961f, 
    0.01923193f, -0.01793319f, -0.02664017f, 0.00958804f, -0.07020710f, -0.10210242f, 0.00359221f, 0.10140234f, 
    -0.06358947f, 0.10679710f, 0.15904248f, 0.15457222f, 0.15603581f, 0.12585540f, -0.06969570f, 0.12751529f, 
    0.03714182f, 0.01082720f, 0.08015575f, 0.18720162f, -0.15679809f, -0.08545487f, 0.04944186f, 0.14204870f, 
    0.04928225f, 0.11181445f, -0.07909880f, 0.06300247f, -0.01201548f, -0.08391334f, -0.10616403f, -0.17719613f, 
    -0.12080668f, -0.02180270f, 0.16141163f, 0.06323607f, 0.05314075f, 0.00348649f, 0.07902922f, -0.11117212f, 
    0.05016100f, 0.02502611f, -0.10581663f, -0.07019611f, 0.02315432f, 0.06161202f, 0.16124873f, 0.17114525f, 
    0.08283769f, 0.12048046f, 0.02787173f, 0.02602150f, -0.01619510f, -0.01190985f, -0.12187377f, 0.06762162f, 
    -0.12815477f, 0.08543009f, 0.14914173f, -0.04538254f, 0.06159437f, 0.09728050f, -0.00921179f, -0.02805354f, 
    0.02572035f, 0.14059421f, 0.08776525f, 0.01961957f, -0.04504018f, 0.18155247f, 0.13668355f, 0.16814613f, 
    0.08782892f, 0.03547671f, 0.08615460f, 0.06089844f, -0.15536915f, -0.01773999f, 0.02031121f, 0.04852745f, 
    0.29251757f, 0.18026046f, 0.00783277f, -0.00819718f, 0.08757082f, 0.06448762f, 0.14326160f, -0.01379455f, 
    -0.04358772f, 0.10881532f, -0.03490262f, 0.12052952f, 0.22087817f, -0.17599210f, -0.02136277f, -0.08551308f, 
    -0.07355995f, 0.08073092f, 0.03422270f, -0.08981385f, 0.01227061f, 0.04856649f, -0.02440958f, 0.07694098f, 
    -0.06109202f, 0.01594500f, -0.06135438f, 0.06641153f, 0.07855987f, -0.10194761f, 0.04633065f, 0.04584626f, 
    -0.08037470f, -0.05226492f, -0.04803672f, -0.10146868f, 0.16745676f, 0.15429845f, 0.03087368f, 0.18285704f, 
    -0.04360354f, 0.02513705f, 0.16764884f, 0.07800995f, -0.03954407f, 0.08590401f, -0.03522034f, 0.06453282f, 
    -0.04479566f, 0.00017392f, 0.06277875f, 0.18882295f, 0.14385849f, 0.08573464f, -0.00002117f, 0.03856130f, 
    -0.05318541f, 0.02543003f, 0.09806692f, 0.06759214f, -0.08672573f, 0.29983839f, 0.17648610f, 0.13609143f, 
    0.10270877f, 0.08330277f, -0.12732431f, 0.03816844f, -0.05769371f, 0.00307303f, 0.00301585f, 0.06293527f, 
    0.02713665f, 0.16414042f, 0.17810977f, 0.15498032f, 0.06244033f, -0.03029462f, 0.12299822f, 0.03482730f, 
    -0.08125427f, 0.16382262f, 0.13923188f, 0.08131326f, -0.04003496f, 0.22578676f, 0.01854416f, 0.08688915f, 
    -0.09365021f, 0.21893036f, 0.03203084f, -0.00477912f, 0.02388090f, -0.04608605f, 0.03341465f, -0.01909862f, 
    -0.05839607f, 0.03335392f, 0.06051313f, 0.06607263f, 0.03546606f, 0.01119607f, 0.03149426f, -0.08352905f, 
    -0.02656152f, -0.12149426f, 0.06113404f, 0.01782756f, -0.12712380f, -0.14881767f, 0.17635424f, 0.06841306f, 
    -0.10893964f, -0.03143696f, 0.00520850f, 0.02785546f, 0.10116701f, 0.08894192f, 0.05329103f, -0.00274638f, 
    0.13198477f, -0.04354062f, -0.02545946f, -0.08289302f, 0.04515842f, 0.01390434f, -0.00694780f, 0.12467782f, 
    -0.03527107f, 0.04271547f, 0.14957182f, 0.18407264f, -0.00415859f, 0.20084141f, 0.13339247f, 0.20484762f, 
    0.09796093f, 0.03015821f, -0.02036302f, 0.09367618f, 0.02100504f, 0.14720547f, 0.04876119f, 0.10039324f, 
    -0.04631406f, 0.33550188f, 0.23159331f, 0.08345450f, -0.07325467f, 0.13909127f, 0.01991733f, 0.02482006f, 
    0.02630298f, -0.06835277f, -0.00712132f, -0.00521095f, 0.15528519f, 0.45183626f, -0.04724958f, -0.10800868f, 
    0.02735492f, -0.05469838f, 0.00265461f, -0.05015549f, -0.07036303f, -0.01524728f, 0.06553495f, -0.08877994f, 
    0.30857158f, 0.14606251f, 0.00580152f, 0.08797026f, 0.07148369f, 0.07798316f, 0.05026795f, 0.02121805f, 
    -0.06449876f, -0.00721891f, -0.07968823f, -0.10360555f, 0.31049350f, 0.19092374f, -0.09026908f, 0.10815343f, 
    0.04024063f, -0.09560264f, 0.04710710f, 0.03342394f, 0.05938149f, 0.03790058f, -0.09054141f, -0.02136271f, 
    0.15470378f, 0.04231219f, -0.06398035f, -0.06747488f, 0.00877017f, -0.10101642f, -0.04827765f, 0.01035710f, 
    -0.01418110f, -0.15816534f, -0.08669063f, -0.05009889f, 0.27560928f, -0.03274805f, 0.04397089f, 0.02990631f, 
    -0.07414505f, 0.14982846f, 0.07076156f, -0.02246073f, 0.18904330f, -0.05668696f, -0.00368451f, 0.11229632f, 
    -0.07093245f, 0.00959650f, 0.16456226f, 0.16585578f, -0.06282629f, 0.02666397f, 0.09647117f, 0.06730562f, 
    0.08270153f, -0.00555635f, 0.06271184f, 0.00031057f, -0.21833219f, 0.08727452f, 0.01721166f, -0.00435151f, 
    0.03158887f, 0.01572745f, -0.06496330f, 0.12705180f, -0.05229861f, 0.12395762f, 0.20365928f, 0.09142478f, 
    0.12581123f, 0.06085038f, 0.13393444f, 0.11194056f, -0.00816792f, -0.00983511f, -0.04080848f, 0.08658243f, 
    -0.01917819f, -0.08727624f, -0.02165700f, -0.04278132f, 0.07665375f, 0.09973906f, -0.04381669f, 0.19035213f, 
    -0.04639269f, 0.01977400f, -0.02763808f, 0.10414848f, 0.07239258f, 0.01338058f, 0.12786308f, 0.03197913f, 
    0.00017445f, -0.02304056f, 0.17530732f, 0.09222463f, 0.07154212f, 0.02792553f, 0.08159959f, 0.01534130f, 
    -0.02801167f, -0.14388749f, 0.02244495f, -0.02723710f, -0.01980382f, 0.08134945f, 0.08836789f, 0.10727922f, 
    0.06879772f, 0.01012891f, -0.00340788f, 0.13815203f, -0.07520372f, -0.11627278f, -0.02469888f, 0.06639712f, 
    -0.21688381f, 0.11126561f, 0.25200903f, 0.07742114f, 0.10075301f, 0.13324849f, 0.02263152f, 0.07685463f, 
    -0.08877192f, 0.00277491f, 0.17418961f, 0.05885222f, 0.08693594f, -0.05775419f, -0.07409926f, 0.21497162f, 
    -0.07237501f, 0.13755910f, 0.01816686f, -0.09370788f, 0.10613012f, 0.05633109f, 0.01250369f, -0.04761052f, 
    0.16942303f, 0.21290889f, -0.12425924f, -0.20681717f, 0.10643385f, 0.02204431f, 0.01278103f, 0.04189948f, 
    0.02268914f, 0.03093238f, 0.01566198f, 0.09775718f, 0.35548738f, 0.19471754f, -0.00230621f, 0.07959335f, 
    -0.00827705f, 0.06203336f, 0.06842752f, 0.02627299f, 0.07422771f, 0.00208751f, -0.04176975f, -0.05069962f, 
    -0.11987652f, 0.16958331f, 0.17492625f, 0.19139822f, 0.18836084f, 0.08235004f, 0.08794186f, 0.06636349f, 
    0.00693371f, 0.02865477f, 0.13137574f, 0.08292530f, 0.05831590f, 0.29948732f, 0.16895548f, 0.06798729f, 
    0.01277150f, 0.09210631f, 0.07074343f, -0.00439476f, -0.15877086f, 0.01511227f, 0.06887960f, -0.06328529f, 
    -0.06865765f, 0.10991646f, 0.11615703f, -0.05905646f, -0.09989170f, 0.05757521f, 0.01752792f, 0.02453075f, 
    -0.03193574f, 0.12351779f, 0.00383909f, 0.13457213f, 0.09947851f, 0.20970467f, 0.04562949f, 0.00555721f, 
    0.03832398f, -0.05519350f, 0.10915487f, 0.11375766f, -0.03308586f, 0.12843968f, 0.01846176f, -0.13247173f, 
    0.11976910f, 0.06862815f, 0.09361355f, 0.01283109f, 0.08258386f, 0.02050607f, 0.02101668f, 0.05171322f, 
    0.04160716f, 0.14688542f, 0.08587315f, -0.09452189f, 0.16718808f, -0.06331666f, -0.04861353f, 0.12313937f, 
    0.02758648f, -0.04154665f, 0.07712997f, 0.01823033f, 0.11967101f, 0.02876164f, 0.04181401f, -0.10163586f, 
    0.11122021f, 0.06580242f, 0.09575635f, 0.01433593f, 0.05163492f, -0.03210615f, 0.03642758f, 0.09574375f, 
    0.08953377f, 0.06635670f, -0.04686337f, -0.07726571f, 0.28193012f, -0.10434955f, -0.00036395f, 0.05528248f, 
    -0.05737629f, -0.04055724f, 0.01237644f, 0.01031230f, -0.10187978f, -0.09619354f, 0.19080280f, -0.07316893f, 
    0.13431969f, 0.12843071f, 0.01656249f, 0.05163471f, -0.09513824f, -0.03335711f, 0.08732961f, -0.03475522f, 
    0.02530028f, 0.00538828f, -0.11270135f, -0.05006490f, 0.12035164f, 0.04781725f, -0.10264328f, 0.01374471f, 
    -0.00027442f, 0.15678295f, -0.13006003f, -0.01442266f, 0.03139863f, 0.02892621f, 0.05169775f, 0.11940966f, 
    0.08027240f, -0.00425445f, 0.09011655f, -0.04735514f, -0.03691238f, 0.05508024f, 0.05992352f, -0.00090205f, 
    -0.04256935f, -0.09257707f, 0.07375834f, 0.03486089f, 0.02850720f, -0.07067627f, -0.09603775f, 0.02282935f, 
    -0.16487005f, 0.01465982f, 0.05724367f, -0.00473956f, 0.05772248f, 0.11890911f, -0.00968206f, -0.04008040f, 
    -0.09163233f, 0.18910071f, 0.11674241f, -0.07773297f, 0.01815503f, 0.14430605f, 0.05080698f, 0.02980448f, 
    0.01763790f, -0.08044936f, -0.06976689f, 0.07119585f, 0.32990420f, 0.22647434f, -0.16076161f, -0.05088444f, 
    -0.01784480f, 0.08584873f, 0.00445477f, 0.07960694f, -0.02611254f, -0.04685830f, 0.07179230f, 0.09650388f, 
    0.08841480f, 0.25465772f, 0.02715354f, 0.15320408f, 0.03569728f, 0.14940554f, 0.12058038f, 0.00952911f, 
    -0.05576035f, -0.00212851f, 0.00539252f, 0.12709025f, 0.19355671f, 0.04648281f, 0.03632566f, -0.12067565f, 
    -0.07067718f, 0.00209397f, 0.13763322f, 0.14084412f, 0.08965641f, 0.04441697f, 0.08932403f, -0.11416001f, 
    -0.15188003f, 0.14947261f, 0.10013203f, 0.01783162f, 0.01925521f, 0.09059709f, -0.04112836f, 0.11469375f, 
    0.00359384f, -0.13399802f, 0.07877442f, 0.09044281f, 0.16998439f, 0.07662451f, -0.12484942f, 0.05534858f, 
    0.08046618f, 0.03269718f, 0.01198491f, 0.05589362f, -0.03335891f, 0.10663498f, 0.12458499f, 0.19298466f, 
    0.08926691f, 0.00206506f, -0.03371991f, 0.12264387f, 0.08267101f, 0.13473704f, 0.08165029f, 0.03172915f, 
    -0.00007423f, 0.05669735f, 0.15959372f, -0.01455379f, 0.18716863f, -0.18216185f, 0.08272900f, 0.11059561f, 
    -0.03652574f, 0.02421696f, 0.03939885f, -0.00885300f, -0.00526058f, -0.08987579f, -0.02210683f, -0.15453248f, 
    -0.03510577f, -0.17420407f, -0.00213086f, 0.12960970f, 0.00175414f, 0.01240424f, -0.02668984f, 0.01405750f, 
    -0.03131373f, -0.08685753f, -0.05906405f, -0.00734780f, 0.02544389f, 0.23697445f, 0.04952468f, 0.05135255f, 
    0.01551031f, 0.03638669f, 0.13720986f, -0.08851344f, -0.05520967f, -0.04963547f, -0.04111612f, -0.05806230f, 
    0.00244772f, 0.36193803f, -0.06761187f, 0.14119154f, 0.03135771f, 0.11408076f, 0.06487025f, 0.02292856f, 
    0.02287349f, 0.04149177f, -0.09048364f, 0.05748921f, -0.00484466f, -0.32574746f, 0.07271910f, 0.07907026f, 
    -0.00983662f, -0.03864906f, -0.00997519f, -0.03765585f, -0.08518013f, -0.03932581f, -0.02796600f, -0.03847675f, 
    -0.02396307f, 0.00945273f, 0.03745670f, 0.02817786f, -0.01662121f, 0.01811035f, 0.10465301f, -0.01099277f, 
    -0.00190055f, 0.06421342f, 0.06536821f, -0.04549583f, -0.04231254f, 0.21037479f, 0.11665434f, 0.24762364f, 
    -0.01387295f, 0.01524376f, -0.09086583f, 0.03534208f, 0.11470719f, 0.08079667f, -0.00161661f, 0.01078434f, 
    -0.12817387f, -0.11685053f, -0.08216332f, 0.03799727f, 0.12155692f, 0.02435492f, 0.01442392f, 0.13652001f, 
    0.03933229f, 0.00328624f, 0.01768429f, 0.09133257f, -0.21658777f, -0.06708381f, -0.02386886f, 0.01423003f, 
    -0.03574444f, -0.01807454f, 0.07657783f, 0.04402828f, 0.01031467f, -0.01043367f, -0.12868242f, 0.12132978f, 
    -0.06904507f, -0.06700268f, -0.03819417f, -0.04348224f, 0.05836699f, -0.05314038f, 0.02690306f, 0.07499149f, 
    0.06803807f, 0.01362454f, 0.00256381f, 0.01823169f, -0.11125477f, -0.09580324f, 0.08331771f, -0.06251335f, 
    0.06455209f, 0.13697372f, 0.05741801f, 0.04613401f, 0.10563736f, 0.12481643f, 0.10503180f, 0.09383307f, 
    0.00093376f, 0.08282627f, -0.05593958f, -0.08129644f, -0.06279331f, 0.04806631f, 0.01063470f, -0.02418154f, 
    0.03107792f, -0.00255161f, -0.03857661f, -0.09118225f, -0.07892965f, -0.14193214f, -0.04005790f, 0.05326757f, 
    0.04181705f, -0.01344986f, 0.01393551f, -0.02509649f, 0.01599494f, 0.05980230f, 0.13337436f, 0.12727742f, 
    -0.01322488f, -0.02676981f, -0.18239768f, -0.08655706f, 0.07222181f, 0.04804608f, -0.09939306f, 0.04819361f, 
    0.01640100f, 0.09261435f, 0.10555677f, 0.06949382f, 0.04275748f, 0.07142881f, -0.07730310f, -0.16173242f, 
    0.00558644f, 0.00743818f, -0.02843843f, 0.01205483f, -0.00588283f, 0.04003478f, 0.07480036f, 0.00204356f, 
    -0.10435017f, 0.00076066f, -0.14383127f, -0.14619799f, 0.00324855f, 0.05598775f, 0.03064113f, 0.11087004f, 
    0.05306989f, -0.12768911f, 0.02393777f, -0.00153230f, -0.04228772f, -0.10684351f, -0.15777546f, 0.05831653f, 
    0.03976888f, -0.01280161f, 0.04666185f, 0.13313633f, 0.10168219f, 0.05644336f, 0.07955354f, 0.05226828f, 
    -0.02645638f, -0.12391736f, 0.30713773f, 0.30506271f, -0.04492362f, 0.09244753f, -0.06498051f, -0.05572268f, 
    0.11099540f, 0.02394208f, 0.08252943f, -0.10431972f, -0.37772328f, 0.10913576f, -0.03046131f, 0.08622422f, 
    0.01511059f, 0.04102017f, 0.04238337f, 0.02460125f, -0.00785488f, -0.00294859f, -0.00080951f, 0.00361055f, 
    -0.01187684f, -0.18052198f, 0.01710785f, 0.05355097f, -0.06450044f, -0.00076559f, -0.05986388f, -0.01695216f, 
    0.01070158f, 0.05102925f, 0.03910038f, 0.10690025f, 0.17382795f, 0.02649437f, 0.14857827f, 0.20894128f, 
    -0.06480011f, -0.07521626f, -0.02498276f, -0.03977634f, -0.02423202f, 0.00012645f, 0.10302597f, -0.00841612f, 
    -0.07453297f, -0.02044802f, -0.10814787f, -0.02760437f, 0.01320533f, 0.02624529f, 0.07753519f, 0.09990948f, 
    -0.01152754f, -0.10184614f, -0.02198760f, 0.02570824f, 0.24968749f, -0.18401483f, -0.04175975f, -0.11380300f, 
    0.03540153f, -0.07597312f, 0.10416482f, -0.08897625f, -0.06837780f, 0.04737654f, -0.04970273f, 0.02466311f, 
    0.29010969f, 0.12678121f, 0.15255874f, 0.24873771f, -0.04322153f, 0.02414829f, -0.02694806f, 0.05825911f, 
    -0.02681196f, -0.10385812f, 0.02382503f, -0.04165998f, -0.00723749f, -0.00573987f, -0.11071309f, 0.22341764f, 
    -0.03626609f, 0.05065501f, 0.06293446f, -0.02787225f, 0.02809777f, 0.04727251f, -0.02881079f, 0.13335705f, 
    -0.07263353f, 0.00695106f, -0.09784314f, -0.08193624f, -0.07326385f, 0.08523963f, 0.05100739f, -0.00560371f, 
    0.12817340f, 0.05527489f, 0.02649038f, 0.11459383f, -0.08378364f, 0.18706755f, -0.08441512f, -0.00566451f, 
    -0.11246870f, 0.13383240f, -0.08504423f, -0.03467736f, -0.06894927f, -0.13949481f, 0.10186415f, 0.04760084f, 
    0.03852001f, 0.04807157f, 0.23465306f, -0.08355151f, 0.03293661f, 0.06906597f, -0.00938974f, 0.01790043f, 
    0.01549228f, 0.02262996f, -0.07571453f, -0.00317834f, -0.01816063f, -0.06768118f, -0.01771512f, -0.18907915f, 
    0.04479811f, 0.05980149f, -0.00382264f, -0.11298086f, 0.05652608f, 0.02338812f, 0.01873263f, 0.00104199f, 
    0.07753549f, -0.18618117f, 0.07908689f, -0.01162894f, -0.17126688f, -0.02371529f, -0.00862030f, -0.06279920f, 
    0.00909084f, 0.05944113f, 0.03761444f, 0.06740355f, 0.23022087f, -0.23219246f, 0.07395779f, 0.24448715f, 
    -0.15136376f, 0.07863647f, -0.04726692f, 0.00424330f, -0.04855132f, 0.04009728f, 0.00828352f, 0.08029788f, 
    -0.07617901f, 0.18863036f, 0.17942747f, 0.08675811f, 0.00033151f, -0.05066466f, 0.10387608f, -0.00146279f, 
    0.02606304f, 0.09797144f, 0.04200839f, 0.00995424f, -0.02351737f, -0.05248934f, 0.15509100f, 0.37285390f, 
    -0.04959290f, 0.03558208f, -0.01072708f, 0.08996439f, -0.01675892f, 0.00458950f, 0.01826624f, 0.04428384f, 
    -0.20132750f, 0.22480829f, 0.23039716f, 0.14870358f, -0.02095566f, 0.04542276f, 0.00270187f, 0.04691320f, 
    -0.08153110f, 0.03602054f, 0.08105401f, -0.01201891f, -0.05453620f, 0.06622269f, -0.10984063f, 0.21682777f, 
    0.17201591f, -0.02753701f, -0.00772857f, 0.01680930f, 0.03077920f, 0.11789081f, -0.04012467f, 0.05731932f, 
    -0.12662493f, 0.08988845f, 0.03284954f, -0.11052885f, -0.06701586f, 0.00466024f, 0.14618157f, -0.03005750f, 
    0.00203829f, 0.09272389f, 0.01587966f, 0.06298885f, 0.05771520f, -0.08685022f, -0.01754040f, -0.09696072f, 
    -0.04650794f, 0.07971247f, 0.13152233f, 0.03237783f, 0.00918019f, -0.04882079f, -0.16911994f, -0.01673929f, 
    -0.21820091f, -0.03265047f, -0.01901038f, -0.06115123f, 0.07622050f, 0.00562810f, 0.10940208f, 0.01309380f, 
    -0.01574091f, 0.04712932f, 0.04590088f, 0.09656031f, -0.09104854f, -0.06695502f, 0.10747312f, -0.13400930f, 
    0.05256539f, -0.00588824f, 0.14738609f, -0.09067041f, -0.02670223f, 0.02108312f, 0.01323187f, 0.14664304f, 
    0.03094452f, 0.03863886f, -0.12744224f, -0.06817393f, -0.04803479f, -0.01578587f, -0.05735321f, -0.13335334f, 
    0.18788742f, 0.10729513f, 0.07430053f, 0.09208151f, 0.02670174f, -0.09233209f, -0.04603903f, -0.14673904f, 
    0.04089759f, 0.04377842f, 0.04439760f, -0.03957722f, 0.15821382f, 0.06837202f, -0.03184666f, 0.08282896f, 
    0.15953028f, -0.09406292f, -0.09321104f, -0.00838227f, 0.05518531f, -0.02756185f, -0.05164690f, -0.04275419f, 
    0.16109952f, -0.02771454f, -0.09087536f, -0.04264971f, -0.09902580f, 0.06021617f, 0.19972979f, 0.31373021f, 
    0.08924765f, -0.07128830f, 0.05944776f, 0.03178080f, -0.02820969f, 0.10003007f, -0.00732543f, 0.15786459f, 
    0.11835258f, 0.13142194f, 0.32221052f, -0.13426590f, 0.05406102f, -0.00596447f, -0.11215807f, 0.07466239f, 
    0.06195016f, -0.00730679f, 0.09460038f, 0.00391157f, 0.14524701f, 0.07950769f, 0.01374314f, 0.24547003f, 
    0.02572198f, 0.06415412f, -0.02730494f, 0.01608866f, -0.04541687f, 0.00505803f, 0.08573018f, 0.05733966f, 
    -0.01429451f, 0.10854615f, -0.05581500f, -0.10835257f, 0.09321903f, -0.01329653f, -0.15888894f, -0.00830544f, 
    0.11121882f, 0.01986628f, 0.05625214f, 0.10341361f, 0.21426329f, 0.02177150f, 0.03026336f, 0.13682167f, 
    -0.11617650f, -0.04299840f, -0.04928078f, 0.05830871f, 0.00841505f, -0.01556434f, -0.03336833f, 0.02441355f, 
    -0.03358306f, 0.12889801f, 0.02794530f, -0.12085105f, -0.02231944f, 0.03784616f, 0.01786786f, 0.03873244f, 
    -0.01586609f, -0.08033247f, -0.02816629f, -0.06714486f, 0.07539269f, 0.03311660f, 0.11811448f, 0.21418774f, 
    -0.01304051f, 0.09936664f, -0.04564893f, -0.00258917f, 0.01048030f, -0.10170354f, -0.06679673f, 0.08063142f, 
    -0.06230735f, -0.00921625f, -0.07893895f, 0.03134164f, 0.05988177f, -0.00354266f, -0.01389551f, -0.09714196f, 
    -0.00285692f, 0.03213118f, 0.01840854f, 0.08099420f, -0.00171028f, 0.03872352f, 0.06042651f, -0.42117357f, 
    -0.11204826f, 0.12539591f, 0.04918937f, 0.06398287f, -0.05401390f, -0.01728232f, 0.02574529f, 0.10408519f, 
    -0.14701243f, -0.01514716f, -0.09975468f, -0.03230183f, 0.04163159f, 0.06890780f, 0.05631602f, -0.01407918f, 
    0.08959897f, -0.02370526f, 0.08226749f, 0.16060048f, 0.20600514f, 0.06210162f, 0.12937337f, 0.06985643f, 
    0.07318799f, 0.01702830f, 0.11359922f, -0.10767490f, 0.03811859f, 0.09119311f, -0.02488169f, 0.10746748f, 
    0.09659451f, 0.02955419f, -0.00787004f, 0.03753296f, 0.10388415f, 0.00284090f, -0.00071493f, 0.00594178f, 
    -0.08281428f, 0.12180971f, 0.12268966f, 0.03696377f, -0.27965075f, 0.01593843f, 0.16672951f, 0.17232282f, 
    -0.00696149f, -0.05850879f, 0.16470154f, 0.12369736f, 0.07337548f, 0.11453490f, 0.00467006f, 0.01694200f, 
    -0.25423646f, 0.00073871f, 0.07550195f, -0.20312737f, 0.09048452f, -0.02059572f, 0.15790132f, 0.04048105f, 
    0.03633374f, 0.08364686f, 0.00449628f, -0.02419213f, -0.12873399f, -0.16599289f, 0.24523632f, 0.02936208f, 
    0.01027368f, -0.02328680f, 0.09500924f, 0.08465827f, -0.06229351f, -0.12395460f, 0.01930779f, 0.01467500f, 
    -0.15105875f, -0.06373315f, -0.16701566f, 0.11647893f, -0.01131152f, 0.04391466f, -0.01891035f, 0.07049112f, 
    0.00783910f, 0.06311262f, 0.05707411f, -0.05070940f, -0.07778314f, -0.22003810f, 0.19238918f, -0.24962348f, 
    -0.02631792f, 0.03804367f, 0.09227465f, -0.08810359f, -0.00558736f, 0.09197529f, 0.02617436f, -0.05602245f, 
    0.20816094f, 0.06724270f, 0.14411469f, 0.43953112f, -0.12858768f, 0.01695827f, 0.01798432f, 0.00365663f, 
    -0.01023010f, -0.03113783f, 0.07693117f, -0.13932468f, 0.24557951f, -0.07672229f, -0.00059373f, 0.07024775f, 
    0.05076632f, 0.00062778f, -0.08771476f, -0.01352059f, -0.11958712f, -0.02066620f, 0.09521066f, 0.04705955f, 
    -0.08652685f, 0.04803334f, -0.18111621f, -0.09910993f, 0.01505788f, 0.07600614f, 0.06025710f, 0.01340414f, 
    0.14562461f, 0.14339080f, -0.06670919f, 0.00783079f, 0.09711181f, -0.00807180f, 0.19896178f, 0.12123335f, 
    -0.01356774f, 0.00975351f, 0.04957774f, 0.04034246f, 0.01873484f, -0.15764406f, -0.05839539f, -0.15764838f, 
    0.07399236f, -0.10680817f, 0.04070387f, -0.16120884f, -0.01931989f, -0.08750430f, -0.02120393f, -0.03853234f, 
    0.01290025f, 0.02387333f, -0.04663843f, 0.09556425f, -0.30933732f, 0.28279814f, 0.03997601f, -0.17913471f, 
    -0.01380758f, 0.06488369f, -0.02076053f, -0.00864978f, 0.12356789f, -0.01336244f, 0.11893446f, 0.08396674f, 
    -0.06757002f, 0.11484858f, 0.08617667f, -0.10979924f, 0.04741412f, 0.03699006f, 0.05083040f, 0.01661029f, 
    0.11078323f, 0.06901828f, 0.10206018f, 0.11809978f, 0.04729818f, 0.01078381f, -0.13233203f, -0.00923036f, 
    0.03884899f, 0.07626612f, -0.02595544f, 0.21642455f, 0.02670772f, -0.01384742f, 0.00418151f, 0.00978834f, 
    0.16288701f, -0.05582485f, 0.30427429f, 0.12378517f, -0.08841346f, 0.01531477f, 0.01057081f, 0.05323721f, 
    0.07270147f, -0.02002270f, 0.05604338f, 0.06483034f, -0.11049736f, 0.20525464f, 0.03797131f, -0.02315648f, 
    -0.06196755f, -0.01483230f, 0.02811512f, 0.01539386f, 0.10353833f, 0.15122357f, 0.04401680f, 0.06216783f, 
    -0.23142074f, 0.05172861f, 0.14340916f, -0.16775565f, 0.03197883f, 0.09254929f, 0.05401448f, -0.00265327f, 
    -0.02321327f, 0.05529677f, -0.00129340f, 0.16201045f, 0.15007165f, 0.02116033f, -0.24199162f, 0.01836622f, 
    0.03392612f, 0.01103923f, 0.02077196f, 0.06663149f, 0.01809777f, -0.00926693f, 0.12596053f, 0.06309568f, 
    0.13087593f, -0.23671493f, -0.00199258f, 0.15378298f, 0.06839366f, -0.00759953f, 0.00904482f, 0.12959751f, 
    -0.03615773f, 0.10074185f, -0.00277661f, 0.02651771f, 0.18144870f, 0.04025590f, 0.02404734f, 0.15147902f, 
    0.05784251f, 0.01153730f, 0.08084536f, 0.03550276f, 0.05472070f, 0.03821297f, 0.08953378f, 0.06570462f, 
    -0.00388663f, -0.08549667f, -0.03699965f, -0.11221541f, -0.01560643f, 0.01646712f, 0.11252671f, -0.02323266f, 
    -0.08414756f, -0.07264487f, 0.05166479f, 0.00674806f, 0.06478614f, 0.13279302f, -0.13362767f, -0.21154138f, 
    0.14057155f, 0.12490415f, 0.10022653f, -0.02385309f, -0.01921358f, 0.05180240f, 0.06672841f, 0.04432031f, 
    0.30669743f, 0.10909507f, 0.12114014f, 0.12405702f, 0.10811137f, -0.09678956f, -0.02102484f, -0.02954586f, 
    0.02278844f, 0.00699000f, 0.00595902f, 0.12623796f, 0.28402027f, 0.16809246f, -0.12600960f, -0.07297803f, 
    -0.02968238f, 0.02160458f, 0.06227995f, 0.00832333f, -0.05123828f, 0.10714206f, -0.06936887f, -0.00235737f, 
    0.10284964f, 0.00815444f, -0.01996196f, 0.20775796f, -0.04632656f, -0.03034501f, 0.03300193f, 0.03288538f, 
    -0.10300741f, -0.02652342f, -0.05037351f, 0.14071041f, 0.42365256f, -0.09866919f, 0.04531719f, 0.24892232f, 
    -0.05564860f, -0.02168586f, -0.00440464f, 0.18875343f, 0.06286703f, -0.07068747f, 0.01349647f, -0.08687250f, 
    0.06710515f, 0.12866525f, 0.09523199f, -0.01236532f, 0.02150958f, 0.00934577f, -0.10396237f, -0.01023838f, 
    0.06559312f, 0.11821654f, -0.04676267f, 0.06686822f, -0.10706272f, -0.13341965f, 0.15464869f, 0.07679368f, 
    0.06654557f, 0.07181162f, -0.02363650f, 0.13249545f, 0.02949419f, -0.01853731f, 0.07509585f, 0.03603010f, 
    -0.02225587f, -0.03552500f, -0.15306532f, -0.05464739f, 0.00715919f, -0.05891303f, 0.01892850f, -0.00281237f, 
    -0.06248752f, 0.08695921f, 0.01064221f, 0.00329811f, -0.17411804f, 0.00716494f, 0.18605676f, -0.12427631f, 
    0.05938037f, 0.05723516f, 0.03429180f, -0.06656045f, -0.01352925f, -0.01405052f, 0.04992611f, 0.05069103f, 
    0.29919410f, -0.02187437f, -0.01686290f, 0.09358051f, 0.05483715f, -0.08611672f, -0.11112482f, 0.02201591f, 
    0.08662306f, 0.03325149f, 0.07839844f, 0.03152319f, 0.18409260f, 0.11502120f, -0.05779672f, -0.10973682f, 
    0.02237870f, 0.04233145f, -0.06180684f, -0.07449081f, -0.00987114f, 0.01883543f, 0.01731626f, -0.12779328f, 
    0.20896523f, 0.05833302f, 0.13591890f, 0.02108979f, -0.10265621f, -0.03900908f, -0.01850550f, 0.05806927f, 
    0.00023407f, 0.09820636f, 0.00928047f, -0.06166089f, -0.04776420f, 0.10946822f, 0.09927180f, 0.10645197f, 
    -0.12383737f, 0.07587793f, 0.08182534f, 0.08976983f, 0.14818211f, -0.06854385f, 0.00075825f, -0.00910701f, 
    0.04178027f, -0.05218156f, -0.12853208f, -0.02425429f, 0.01141155f, 0.03540228f, 0.12970556f, -0.09878643f, 
    0.02405040f, 0.03574826f, 0.04939830f, 0.03683589f, 0.11343064f, 0.07430194f, -0.07511866f, 0.17158462f, 
    -0.00226696f, 0.01462864f, -0.11238208f, 0.12823160f, -0.03897502f, 0.11222456f, 0.05437814f, 0.05327741f, 
    0.59562874f, -0.22355753f, 0.03135784f, 0.09956054f, 0.01297475f, 0.01531765f, -0.07902303f, 0.06009551f, 
    0.05068976f, 0.10091792f, 0.04640165f, 0.05025763f, 0.02456729f, -0.12596774f, 0.02663253f, -0.25881612f, 
    0.06065199f, 0.00852209f, 0.01718649f, -0.01518528f, -0.04246148f, 0.08004996f, 0.05265062f, -0.04157809f, 
    0.01991677f, -0.19669196f, -0.16742840f, -0.05055097f, 0.10588080f, -0.12686586f, -0.01884250f, 0.03501687f, 
    0.08004311f, -0.04117868f, 0.04913849f, -0.07894021f, -0.09489407f, 0.10512912f, -0.02972169f, -0.00993511f, 
    0.02342356f, 0.17039081f, -0.03022521f, 0.05217202f, -0.00269422f, -0.14103194f, 0.06424222f, -0.02688523f, 
    -0.06176509f, 0.11174433f, -0.09848458f, 0.00509925f, 0.07824273f, -0.06949998f, -0.00725567f, -0.00502040f, 
    -0.00356914f, 0.07533333f, 0.07331005f, -0.07467707f, -0.23546231f, -0.05117883f, -0.02758705f, 0.10252757f, 
    0.05586466f, 0.03326229f, 0.00435099f, 0.13153671f, 0.00933878f, 0.14486541f, 0.07311585f, 0.20141271f, 
    -0.03967975f, -0.16142808f, -0.06740694f, -0.08163765f, 0.03089011f, 0.15218499f, -0.05915707f, -0.05347246f, 
    -0.01779969f, 0.00196193f, 0.00430618f, 0.16468668f, -0.12321471f, 0.14613487f, 0.00940613f, -0.05718456f, 
    0.01320509f, -0.03480309f, -0.02965302f, -0.08241613f, -0.05106993f, 0.05153377f, 0.07320590f, -0.01387685f, 
    -0.11763309f, 0.18623918f, -0.08195332f, -0.23382506f, 0.10515789f, 0.03529171f, -0.02456034f, 0.00336657f, 
    0.02338690f, 0.05277645f, 0.09138743f, 0.12075400f, 0.00713433f, -0.08174214f, -0.01228311f, 0.09187745f, 
    0.03548774f, -0.05378776f, 0.04683517f, 0.10861228f, 0.00122662f, 0.10650348f, 0.02491619f, -0.02280541f, 
    -0.21808060f, 0.01112968f, 0.05884507f, -0.24471636f, 0.06393562f, 0.12441093f, 0.06110181f, 0.03178582f, 
    0.03199506f, -0.13862522f, -0.06232464f, -0.02193064f, -0.00402362f, -0.14587030f, 0.02352642f, 0.14026430f, 
    0.00053408f, 0.11384366f, -0.10950919f, -0.06306180f, 0.05581005f, 0.08454097f, 0.01709859f, -0.03282746f, 
    -0.02697081f, -0.06718155f, 0.16194716f, -0.03605166f, 0.04678176f, 0.04367974f, 0.02766290f, 0.01082091f, 
    -0.00359627f, -0.00102308f, -0.02674908f, 0.08229451f, -0.22402205f, -0.03224842f, -0.02255701f, -0.04986792f, 
    0.07684395f, 0.03132455f, -0.07202470f, 0.14050342f, -0.00893030f, -0.08402897f, 0.08983102f, -0.08072217f, 
    0.33162665f, 0.03535097f, 0.12200569f, 0.07057245f, 0.09115002f, 0.02387610f, 0.01067700f, 0.14826995f, 
    -0.06641109f, -0.02772645f, 0.07750545f, 0.05544585f, -0.02824309f, 0.11939975f, 0.07610860f, 0.21853079f, 
    0.06588008f, -0.06619703f, -0.05348502f, 0.06373062f, 0.08553017f, 0.06173179f, 0.03670708f, 0.08463395f, 
    0.09100123f, -0.14324374f, 0.10929348f, 0.07872989f, -0.00392783f, 0.04639836f, 0.03098652f, 0.02061517f, 
    0.10547888f, 0.04421841f, 0.03817604f, 0.03955229f, -0.21218479f, -0.09430744f, 0.03021945f, -0.17927940f, 
    0.00237816f, -0.04585788f, -0.08583107f, 0.02922771f, 0.03797337f, -0.00287131f, 0.04165754f, -0.10303264f, 
    -0.23363470f, 0.16539228f, -0.12161353f, -0.12065467f, 0.07621205f, 0.04185799f, 0.02960215f, -0.03041134f, 
    -0.10164587f, 0.07500906f, 0.00932658f, 0.05749885f, -0.14270255f, -0.01752194f, -0.19598630f, -0.04790556f, 
    0.07708210f, -0.00013198f, -0.04440033f, -0.02119092f, 0.09365924f, 0.07386211f, -0.12032083f, 0.01123376f, 
    0.17580982f, 0.02950352f, 0.20358840f, 0.06197406f, -0.06435231f, 0.04683124f, 0.18407106f, 0.16187917f, 
    -0.04887177f, 0.01621479f, -0.05819509f, -0.05212803f, -0.01218763f, -0.05621294f, 0.00238559f, 0.07110617f, 
    0.08591222f, -0.00539087f, 0.11221262f, 0.00001597f, -0.01386455f, -0.05826637f, 0.10682826f, 0.13820374f, 
    -0.23421651f, 0.07919974f, -0.11021374f, -0.19457366f, 0.09089152f, -0.00154627f, 0.01602434f, -0.02627680f, 
    0.06453304f, 0.06584679f, -0.01920209f, -0.06173947f, -0.10479478f, -0.04900187f, 0.00289572f, -0.08678867f, 
    0.09783458f, -0.08051109f, -0.04405520f, -0.07271522f, 0.06537963f, 0.02666525f, 0.08403221f, 0.02479989f, 
    0.12686163f, 0.02688638f, 0.09224309f, 0.14389840f, 0.02761617f, -0.06669908f, 0.02392385f, 0.12552503f, 
    -0.03724352f, 0.05489925f, -0.01032656f, 0.02650245f, -0.11690755f, 0.22497584f, 0.04106215f, 0.11823684f, 
    -0.01590732f, 0.00957859f, -0.08136968f, 0.20544840f, 0.00003309f, 0.02914492f, 0.01531892f, 0.00188212f, 
    0.34415290f, 0.06569211f, -0.17117389f, 0.04179683f, -0.00953544f, -0.02907542f, 0.02691237f, -0.03346915f, 
    0.02649178f, 0.02931571f, -0.06214297f, -0.01130798f, 0.06079307f, -0.00776559f, 0.01847816f, 0.02453427f, 
    0.02392105f, 0.04091547f, -0.06164467f, -0.03658866f, 0.08180624f, 0.04055250f, 0.08475291f, 0.09035087f, 
    -0.05554698f, -0.00178514f, -0.20495430f, -0.07733177f, 0.01551980f, 0.05933462f, -0.02949193f, 0.01601313f, 
    0.03651528f, 0.06051057f, -0.03543976f, 0.01991787f, -0.14487918f, 0.01804549f, 0.03532052f, -0.12454815f, 
    -0.05248001f, -0.11885951f, -0.02059796f, -0.09473098f, 0.00764522f, -0.03438645f, 0.10859233f, -0.06381540f, 
    -0.22491202f, 0.04586877f, -0.10838921f, -0.17026079f, 0.07624329f, 0.06006672f, 0.01933383f, -0.10352123f, 
    0.02599503f, -0.00885683f, 0.04373757f, 0.04827239f, -0.18105178f, 0.12092549f, 0.23253392f, -0.15801960f, 
    0.03522433f, -0.04971222f, 0.08956401f, 0.02537562f, -0.04365059f, 0.13001527f, 0.01457439f, 0.03744394f, 
    0.37629011f, -0.01815550f, -0.02530769f, 0.10858894f, -0.01175665f, 0.00748662f, 0.07368319f, -0.04475987f, 
    0.07277431f, 0.12746434f, -0.00447475f, -0.00074033f, -0.18683009f, 0.08498752f, 0.06490620f, 0.11173325f, 
    -0.01703780f, 0.03085003f, 0.04517977f, 0.18411149f, -0.01164725f, -0.04270324f, -0.01805803f, 0.04141701f, 
    -0.17842183f, -0.15129998f, -0.06112641f, -0.00916311f, 0.12037878f, 0.07778984f, -0.01125504f, -0.09219422f, 
    0.03781411f, -0.00514661f, -0.05889628f, 0.12852082f, -0.10025141f, -0.01682317f, -0.02151374f, 0.09373634f, 
    0.04821969f, 0.00228281f, 0.01580212f, 0.01371292f, 0.07882909f, -0.11318453f, 0.01021359f, 0.05722452f, 
    0.28240573f, -0.07796984f, 0.05793152f, 0.24187447f, -0.05895846f, -0.02930194f, -0.06787937f, 0.02196494f, 
    0.01081296f, -0.07449368f, 0.03859805f, 0.06006129f, -0.14906734f, 0.03139492f, 0.00294399f, -0.15067886f, 
    0.10214333f, 0.07074593f, 0.04898205f, -0.00528586f, 0.00894500f, 0.01209534f, 0.05121141f, 0.10354736f, 
    0.16720307f, 0.00476400f, 0.01923453f, 0.16986306f, 0.04712569f, -0.01034413f, 0.00649311f, 0.07844463f, 
    0.03827787f, -0.04784108f, 0.01923154f, 0.01323575f, 0.29833668f, -0.18127082f, -0.02081621f, -0.05774290f, 
    0.02323277f, -0.04340406f, -0.13813338f, -0.01702304f, 0.02164015f, 0.04477762f, -0.02932374f, 0.03010419f, 
    0.38524473f, 0.02494022f, -0.22095898f, -0.24682124f, 0.02002046f, 0.07488583f, -0.02665652f, 0.02750497f, 
    0.02744949f, -0.04852187f, 0.09375015f, -0.07116246f, -0.14856394f, -0.12463283f, 0.12565400f, -0.02611788f, 
    0.05337351f, -0.03979251f, 0.12727255f, -0.03211632f, 0.08080130f, 0.07241631f, -0.03285449f, 0.05087809f, 
    -0.26484454f, 0.04708193f, -0.13029166f, -0.21196721f, 0.10614190f, -0.06833996f, -0.10215196f, -0.04201404f, 
    -0.02272229f, 0.06241799f, -0.07521234f, -0.08942419f, 0.29534623f, 0.11431079f, -0.17822206f, -0.20534615f, 
    0.08958311f, 0.10138047f, 0.01208420f, -0.04685736f, 0.07176886f, 0.10339306f, 0.02076671f, 0.01482304f, 
    -0.05196314f, 0.09105464f, 0.04310762f, -0.02782879f, -0.04711100f, -0.09223231f, -0.01777909f, 0.00663313f, 
    0.04695962f, 0.03818482f, 0.07357873f, -0.00703333f, 0.03760386f, 0.05877705f, 0.11901249f, 0.14650741f, 
    -0.04221452f, -0.02873706f, -0.01272407f, 0.06291070f, 0.03913026f, 0.01781568f, -0.12269819f, 0.05105450f, 
    0.00626013f, -0.08346552f, 0.02684882f, -0.11436846f, 0.01475239f, -0.05035076f, -0.08120383f, -0.05945288f, 
    -0.05839516f, -0.04634265f, 0.06452357f, 0.03722622f, -0.17129174f, 0.12364043f, 0.04252940f, -0.08308044f, 
    0.06087301f, -0.00740557f, 0.05447483f, -0.03383115f, -0.07417209f, -0.01325797f, -0.00368711f, 0.14182162f, 
    0.05276112f, -0.22381984f, -0.11707926f, 0.17545281f, 0.00475853f, -0.11280037f, -0.04936387f, 0.12198647f, 
    0.04070594f, 0.02816034f, 0.02189479f, 0.06504673f, -0.12735918f, -0.00400667f, 0.01805615f, 0.01358314f, 
    -0.10429496f, -0.00980418f, 0.02076328f, -0.03006323f, 0.07983932f, 0.09696492f, -0.04856274f, 0.02387497f, 
    -0.27117819f, -0.03284331f, -0.01416715f, -0.02061788f, -0.08949933f, 0.01344046f, 0.01318341f, -0.00280153f, 
    -0.02976582f, 0.10994618f, -0.04943610f, -0.03877619f, -0.21094680f, 0.06709083f, 0.03418467f, -0.06833073f, 
    -0.03869779f, -0.12905681f, 0.08064023f, 0.02559618f, -0.01687948f, 0.08747377f, 0.07615896f, 0.14233923f, 
    0.20604818f, 0.09957443f, -0.09475703f, -0.06511757f, 0.08673623f, -0.00433534f, -0.19176632f, 0.00866307f, 
    -0.10468110f, 0.04560657f, 0.15066548f, 0.00958807f, -0.09577188f, -0.16405046f, -0.00313022f, -0.11490506f, 
    0.03758168f, 0.05972900f, -0.03587452f, 0.07540908f, -0.00416909f, -0.00861609f, 0.07046398f, 0.05582476f, 
    0.08463079f, -0.11452501f, -0.37470677f, 0.03407727f, 0.07118484f, -0.09904678f, -0.03057932f, 0.06988132f, 
    0.01244592f, -0.09443356f, 0.05130285f, -0.01174686f, 0.04593008f, -0.08482460f, -0.07315265f, -0.08055047f, 
    0.03123874f, 0.07390574f, -0.03457345f, -0.04244145f, 0.03574326f, 0.11845601f, -0.03730355f, 0.04889915f, 
    0.06104493f, -0.05462587f, 0.23698398f, -0.12395336f, -0.01934003f, 0.00986277f, -0.03003410f, -0.00051553f, 
    0.12673871f, -0.10003119f, 0.15970948f, -0.02639193f, 0.09338660f, 0.12295699f, -0.13364571f, -0.03794776f, 
    0.06914344f, -0.05592618f, 0.05928523f, 0.12951519f, 0.03918310f, -0.01465994f, 0.08942708f, -0.08865329f, 
    0.06910900f, -0.11358358f, 0.14835292f, -0.01414324f, -0.00712500f, 0.04479789f, 0.00036112f, -0.13261233f, 
    0.02440577f, 0.02510367f, 0.01068479f, -0.01916796f, 0.27147549f, -0.00245071f, 0.13125445f, 0.07754862f, 
    0.16439843f, 0.04572631f, 0.00891592f, -0.00854892f, 0.09639648f, 0.03091104f, 0.10022462f, 0.03460681f, 
    -0.00729153f, -0.04141602f, 0.00529875f, -0.01428805f, 0.05527145f, -0.05859088f, 0.05196737f, -0.03425153f, 
    0.04896941f, -0.00532141f, 0.12264863f, -0.06930218f, 0.35593608f, -0.19208173f, -0.13829452f, 0.02019363f, 
    0.03740756f, -0.12138049f, -0.04822095f, -0.04095856f, 0.00201211f, 0.00002503f, -0.09696573f, 0.02942299f, 
    0.16894200f, 0.09112426f, 0.10169762f, 0.04916367f, -0.00958671f, 0.02711207f, -0.01649779f, 0.02064671f, 
    0.17386329f, -0.09577891f, -0.04363004f, -0.02583841f, -0.01226053f, -0.09249274f, 0.18187943f, 0.05591853f, 
    0.08704776f, -0.12959629f, 0.02645707f, 0.00423874f, 0.02828389f, 0.01882860f, -0.00764483f, 0.16676880f, 
    -0.01907104f, -0.05090965f, 0.02251675f, -0.01818374f, 0.00998025f, -0.02520244f, 0.05557381f, 0.00639727f, 
    0.01984929f, 0.05905375f, 0.03992813f, 0.03460965f, 0.05709778f, 0.04546790f, -0.04925654f, -0.04693710f, 
    0.06894104f, 0.08026081f, -0.08738437f, 0.11947089f, 0.01483624f, -0.13655287f, 0.00451592f, 0.00657566f, 
    0.08762367f, 0.18842834f, -0.03270052f, 0.06925704f, 0.09003133f, -0.00930356f, 0.10738826f, 0.00195747f, 
    -0.04431471f, 0.02849093f, -0.05442545f, 0.11054049f, 0.11788466f, -0.17484879f, -0.05295017f, -0.10516632f, 
    0.07296069f, -0.03687110f, -0.03772850f, -0.05883143f, 0.12209535f, 0.02078832f, 0.00315329f, 0.11284193f, 
    -0.16572344f, -0.09994953f, -0.11295632f, -0.08726209f, 0.08437170f, -0.06676090f, -0.01335948f, -0.02396239f, 
    0.05302014f, 0.14468944f, 0.00263665f, -0.05677800f, 0.02677680f, -0.19505242f, 0.10454055f, -0.01502588f, 
    -0.04119411f, 0.04232647f, -0.07435842f, -0.09592526f, -0.08694591f, 0.01515649f, -0.07066639f, 0.11741275f, 
    0.20401932f, 0.01721219f, 0.19093186f, 0.10186175f, 0.04497067f, -0.06967779f, 0.01063333f, 0.01497457f, 
    0.02831458f, 0.03134238f, 0.04673956f, 0.10563824f, 0.04334841f, -0.08617674f, 0.14647512f, 0.10940912f, 
    0.00798862f, 0.06892567f, -0.02581937f, -0.00021852f, 0.05051582f, -0.14262661f, 0.12888959f, 0.05239005f, 
    0.07461002f, 0.00412970f, 0.09824228f, 0.10613266f, -0.03771471f, 0.10615785f, 0.07569600f, 0.03782241f, 
    -0.06350422f, 0.10345279f, 0.08031049f, -0.04677523f, -0.15545590f, 0.10503406f, 0.04694190f, -0.07474200f, 
    0.07579347f, -0.06682616f, 0.02642500f, -0.06017016f, -0.10187435f, 0.16130650f, 0.00079326f, -0.01127582f, 
    0.10433316f, 0.13832678f, -0.02127320f, 0.07798941f, 0.07434103f, 0.11866429f, 0.01723243f, -0.00418685f, 
    -0.10849287f, 0.06501833f, -0.04276139f, 0.02895316f, -0.17759971f, 0.03545498f, -0.06585139f, -0.19310652f, 
    0.03405891f, 0.06926680f, 0.10725221f, 0.01562067f, -0.03798681f, -0.06300443f, -0.22187929f, 0.01602342f, 
    -0.15663461f, 0.17574415f, 0.07385974f, 0.00158261f, 0.03525956f, 0.04218534f, -0.03433463f, -0.01002267f, 
    -0.00558006f, 0.09332997f, 0.04423479f, 0.06541986f, -0.20948064f, -0.06913263f, 0.11726216f, -0.01694207f, 
    -0.03013962f, -0.03886488f, 0.05675756f, -0.00337296f, 0.01867322f, 0.07499228f, -0.14886265f, 0.05810426f, 
    -0.27950540f, -0.12366765f, -0.23334298f, 0.02377237f, -0.05061843f, 0.02025793f, -0.10428578f, -0.03008772f, 
    0.04384302f, 0.07560579f, 0.04615274f, -0.02561066f, -0.06587336f, -0.06933516f, -0.04455903f, -0.17681724f, 
    0.01713489f, -0.05518552f, -0.06356001f, -0.14571039f, 0.13567387f, 0.08462549f, 0.02294239f, 0.01118675f, 
    0.16528647f, -0.08534162f, -0.20872688f, 0.01012241f, 0.07013625f, -0.07330003f, -0.07642852f, -0.07872402f, 
    0.07048205f, -0.05422747f, -0.14154927f, -0.03897936f, 0.13229956f, -0.05005796f, 0.07338367f, -0.09554047f, 
    0.06646821f, -0.04120500f, 0.06003071f, 0.07567030f, -0.00318938f, 0.00277412f, 0.01703129f, 0.22355007f, 
    0.27670643f, -0.03639051f, -0.00732206f, 0.23846400f, -0.06870135f, 0.09291271f, -0.00335530f, 0.08129097f, 
    -0.07781918f, -0.03091535f, 0.00915799f, -0.00823663f, 0.04125134f, -0.11837289f, 0.07621562f, 0.06849732f, 
    0.05887355f, 0.07101606f, -0.03999233f, -0.02018309f, 0.04755888f, -0.11004225f, 0.04657505f, 0.06221570f, 
    0.05190200f, -0.01774548f, -0.12872712f, -0.14039807f, 0.02414846f, 0.03289009f, -0.20220624f, -0.03875995f, 
    -0.02535652f, 0.10329932f, 0.01851222f, -0.06669469f, 0.14736933f, 0.01310033f, 0.03182838f, 0.13022409f, 
    0.09060188f, -0.07331499f, 0.03698860f, 0.12775719f, 0.13154535f, 0.03631364f, -0.15941882f, 0.20074353f, 
    0.08004223f, -0.18616350f, -0.10644788f, 0.12831952f, 0.03431441f, -0.03770291f, 0.00153149f, 0.03259355f, 
    0.04927665f, -0.08416867f, 0.03415048f, -0.02935910f, 0.14340104f, 0.16790868f, -0.02613772f, 0.12363571f, 
    0.07222682f, 0.09069386f, -0.04871225f, -0.05257950f, 0.01092618f, -0.04584397f, 0.00182650f, 0.06164728f, 
    -0.46890998f, -0.17544892f, -0.03182633f, 0.01243655f, -0.03975133f, 0.03826775f, -0.00885289f, -0.01560249f, 
    -0.04285163f, -0.08051437f, -0.02598354f, 0.11786459f, -0.08436302f, 0.05290889f, 0.17388757f, -0.13187736f, 
    0.00495807f, 0.06259558f, -0.01211061f, 0.03118750f, -0.06881308f, 0.03895617f, 0.00957300f, 0.14164543f, 
    -0.14142126f, -0.02241114f, -0.02594275f, -0.00981206f, -0.03913093f, 0.07232453f, -0.08055545f, -0.03028600f, 
    0.04018466f, -0.10080902f, 0.14930485f, 0.04567924f, -0.25699320f, -0.02177364f, 0.03608675f, 0.05175774f, 
    0.05410676f, -0.01371805f, 0.01461782f, 0.05700662f, 0.09585228f, -0.02357925f, -0.12450856f, 0.07069755f, 
    -0.00816841f, -0.15410097f, 0.01189459f, -0.07544297f, 0.10821752f, 0.04721380f, -0.00399491f, 0.02619934f, 
    0.00480800f, 0.09978350f, 0.00356187f, 0.04897634f, 0.07836248f, -0.04873670f, 0.00688923f, 0.02002666f, 
    0.00166984f, -0.07738705f, 0.15511338f, 0.09096693f, -0.03321841f, 0.06123613f, -0.03606389f, -0.07630407f, 
    -0.04107528f, 0.00161614f, -0.08158797f, 0.13009058f, 0.01298799f, 0.01551030f, -0.01799673f, 0.11885756f, 
    0.05054070f, 0.06248549f, 0.02439706f, 0.03733632f, 0.19807237f, 0.07672217f, -0.08205792f, 0.02698475f, 
    0.10388561f, -0.03125449f, 0.02206363f, 0.14618710f, 0.00473181f, -0.07740862f, 0.02212209f, 0.11271288f, 
    0.01709144f, -0.01260005f, -0.02723791f, 0.07757740f, 0.02674005f, -0.09022517f, 0.00723500f, 0.00761989f, 
    -0.01748560f, 0.12521181f, 0.10427051f, -0.08641712f, -0.03655469f, -0.00607276f, 0.05836748f, -0.03691026f, 
    -0.03735449f, -0.10090505f, 0.03101451f, -0.04712331f, -0.03504445f, 0.00239351f, -0.10297658f, -0.06613840f, 
    0.12054903f, -0.08813255f, 0.25374922f, -0.03993619f, -0.02333439f, -0.04709097f, 0.01071969f, 0.02329988f, 
    0.10929183f, 0.06922980f, 0.17839547f, -0.17763934f, 0.36370522f, 0.13713057f, -0.02030443f, 0.15420559f, 
    0.09008936f, -0.02135505f, -0.11936319f, -0.04401039f, -0.05251980f, 0.03902916f, -0.03918215f, 0.06252661f, 
    0.20832968f, 0.03245710f, -0.04270416f, 0.00928478f, 0.00896650f, 0.04501349f, 0.06622771f, -0.08935411f, 
    0.00869250f, 0.16433834f, -0.00777579f, -0.04564515f, -0.05098796f, 0.07947062f, -0.02190807f, 0.09665129f, 
    0.00229941f, 0.04519115f, 0.11059355f, 0.12325239f, 0.11821236f, -0.07078332f, -0.03873953f, -0.13597697f, 
    0.07494022f, -0.12149096f, -0.03336471f, 0.03332742f, 0.03562987f, 0.00832638f, -0.03716811f, -0.03517912f, 
    -0.07806922f, -0.00334824f, -0.11079600f, 0.06168963f, 0.05169830f, 0.10050044f, -0.05599283f, 0.07707464f, 
    0.07287003f, 0.05609413f, -0.02809986f, 0.03397556f, 0.05048775f, 0.09497237f, 0.09186920f, 0.18686903f, 
    -0.03297546f, 0.04566808f, 0.12214974f, -0.12935318f, -0.01153306f, 0.06873306f, 0.08902945f, 0.08411805f, 
    0.01492791f, 0.06325791f, 0.05611035f, 0.06613197f, 0.18539150f, -0.24087419f, 0.04882864f, 0.11066219f, 
    0.08798782f, 0.07993765f, -0.12765859f, 0.14532745f, 0.00256313f, 0.01308928f, 0.02318690f, -0.05478210f, 
    0.04969550f, -0.01421135f, 0.05522644f, -0.01867550f, -0.03078822f, 0.03465152f, -0.02548587f, 0.07216233f, 
    0.06385586f, -0.01930318f, 0.11171719f, -0.05684481f, 0.02771404f, 0.04115771f, -0.05880575f, -0.01412801f, 
    -0.00183307f, 0.04687689f, 0.05542018f, 0.06725235f, 0.03781906f, 0.13245127f, 0.08240712f, 0.01476162f, 
    0.02103764f, 0.02308515f, -0.01036944f, -0.03754028f, -0.00216681f, 0.02757598f, 0.01542226f, -0.02724125f, 
    0.00827353f, -0.01046248f, -0.03277301f, 0.01731186f, -0.03755957f, -0.01791549f, -0.00308586f, -0.02545261f, 
    -0.04024783f, 0.02136060f, -0.03377804f, 0.01542138f, -0.01447228f, -0.00793433f, 0.02033238f, -0.00525365f, 
    -0.03347421f, 0.00223117f, 0.03869575f, 0.02308997f, -0.00123352f, -0.03395010f, 0.02001357f, -0.03139938f, 
    0.01864720f, 0.00293857f, -0.03835279f, -0.02817330f, -0.03150420f, 0.02339761f, -0.02474880f, -0.00933477f, 
    -0.02825935f, -0.00176904f, -0.02000743f, -0.03614257f, 0.03206061f, -0.01860115f, -0.03367807f, -0.02615890f, 
    -0.03595169f, -0.01684764f, -0.03075435f, -0.00191806f, -0.01926317f, -0.02947870f, -0.02718937f, 0.00828524f, 
    -0.03459495f, 0.01448234f, -0.02862930f, -0.03624587f, 0.01947264f, -0.04283451f, -0.03503588f, 0.03253393f, 
    -0.02017364f, 0.01154887f, -0.02624156f, -0.02582639f, 0.03591152f, -0.03546897f, -0.01452071f, -0.01263528f, 
    -0.01709105f, -0.03729682f, -0.01129276f, -0.01910280f, 0.02059668f, 0.02114972f, -0.01007371f, 0.00010239f, 
    -0.00713779f, -0.00067793f, 0.02672919f, -0.01613950f, -0.01680795f, -0.03083622f, -0.03159119f, 0.01267515f, 
    -0.00346077f, -0.01392282f, -0.03130074f, 0.00107658f, -0.02820921f, -0.02971740f, -0.00382509f, 0.00546684f, 
    0.00739760f, -0.00241750f, 0.01668971f, -0.00616756f, -0.00777150f, -0.01390459f, -0.01560377f, 0.00641309f, 
    0.00203177f, -0.00812804f, 0.00023874f, -0.03168066f, -0.02128093f, 0.01511880f, -0.00514559f, -0.03025904f, 
    -0.01175605f, -0.02398592f, 0.00102372f, -0.03337825f, 0.02621858f, -0.01846246f, -0.01722702f, -0.00683423f, 
    0.01049845f, 0.01104340f, -0.02436489f, -0.02273580f, -0.02782756f, 0.03199597f, -0.03699675f, -0.03648776f, 
    0.02892640f, -0.00539712f, -0.01964802f, 0.01117997f, 0.02879086f, 0.00956570f, 0.01941296f, 0.00806120f, 
    -0.01455516f, 0.02300746f, 0.02607791f, 0.01796595f, 0.03380753f, 0.00608286f, -0.01861324f, -0.00264056f, 
    -0.00870573f, 0.01427112f, -0.01039575f, 0.01598102f, -0.00025174f, 0.02977286f, -0.00635201f, 0.00873558f, 
    -0.00815844f, 0.01256583f, -0.02573344f, -0.03386457f, 0.02639490f, -0.03674836f, -0.00735225f, -0.01249172f, 
    -0.03458615f, 0.01563843f, 0.02160078f, 0.00985643f, 0.02140844f, 0.02013778f, 0.01371913f, 0.00085903f, 
    0.00063454f, -0.02547452f, -0.00460598f, -0.01572620f, 0.00021454f, -0.03372221f, -0.01348378f, 0.03037660f, 
    -0.04246332f, 0.00405642f, 0.01296400f, 0.01304238f, 0.01941693f, -0.04313103f, 0.01932911f, 0.03193248f, 
    -0.02992389f, -0.03236931f, -0.02487427f, 0.02107965f, 0.00062663f, -0.02733483f, -0.00219333f, -0.01970031f, 
    0.01636628f, -0.03780615f, -0.00585373f, 0.01280420f, -0.02220702f, 0.00678936f, 0.01985527f, -0.00207502f, 
    -0.01160961f, -0.00003124f, -0.01897019f, 0.03023316f, -0.02559591f, -0.03733525f, 0.00284746f, 0.02040809f, 
    -0.02892546f, 0.03054393f, -0.01172530f, -0.02547611f, -0.01586038f, -0.01951434f, -0.02853207f, 0.01207332f, 
    0.02969806f, -0.00768969f, -0.02817465f, -0.01998914f, -0.03789690f, -0.00967631f, -0.00887070f, 0.01867757f, 
    0.02824406f, -0.03074707f, -0.00272186f, 0.00704936f, -0.00333850f, -0.03211210f, -0.00805558f, -0.00800350f, 
    0.01427804f, 0.02613797f, 0.02357552f, 0.01956771f, 0.02330598f, -0.03596360f, 0.01195382f, -0.01328134f, 
    -0.00843087f, -0.01874992f, -0.03643074f, 0.00405913f, -0.00740304f, -0.01815947f, -0.01184151f, -0.00090617f, 
    0.00145124f, -0.01087079f, -0.00409963f, -0.03643038f, 0.02729820f, -0.02282007f, 0.02541427f, 0.00385202f, 
    -0.02193888f, -0.01275601f, -0.00547124f, -0.01787282f, -0.00712326f, -0.02846047f, 0.02751120f, -0.03554863f, 
    -0.03651265f, 0.01307415f, -0.00616831f, 0.00985544f, -0.01637860f, -0.02594729f, -0.02919959f, 0.00645858f, 
    -0.02268020f, 0.01520317f, 0.02356067f, 0.02139332f, -0.01185427f, 0.01561491f, 0.01098422f, 0.01894784f, 
    -0.00386996f, 0.03136104f, -0.01015357f, 0.00392367f, -0.00603937f, 0.03308863f, -0.03809689f, -0.03517311f, 
    -0.04087855f, 0.03008294f, -0.01600830f, 0.00337100f, -0.00859698f, -0.03386406f, -0.02367689f, -0.03182265f, 
    -0.03558256f, 0.00784187f, -0.02105377f, -0.03331861f, -0.04160790f, 0.01907200f, 0.02409840f, -0.00309148f, 
    0.00323542f, -0.03544436f, 0.02380083f, 0.01834195f, 0.03019056f, -0.02654894f, 0.01416308f, -0.01178273f, 
    -0.03849818f, 0.01439320f, 0.01680409f, 0.01097242f, -0.00178944f, 0.01172131f, -0.02464752f, 0.03190354f, 
    0.02689587f, 0.00599014f, -0.00601815f, -0.00897397f, 0.01179651f, -0.03424956f, 0.01983981f, -0.02030691f, 
    -0.01094795f, -0.01602683f, -0.01126347f, -0.01914233f, -0.02125778f, -0.00156427f, 0.03192459f, 0.02304139f, 
    -0.04359293f, -0.02018548f, -0.00085309f, 0.00628476f, 0.00156015f, 0.02526723f, 0.00192373f, -0.03318347f, 
    -0.04465218f, -0.03356892f, -0.00310143f, 0.00530633f, 0.02234673f, -0.01523839f, 0.02924426f, 0.02080427f, 
    -0.03611448f, 0.01742276f, 0.02960663f, 0.00417304f, 0.00249841f, -0.00227025f, -0.03679513f, 0.02454767f, 
    -0.01414545f, -0.01501611f, 0.02815457f, 0.00812076f, -0.00299310f, 0.01091230f, 0.00160904f, 0.01312597f, 
    -0.02168304f, -0.02635233f, 0.03171204f, 0.01497959f, 0.01050344f, -0.03272853f, 0.01143706f, 0.00346223f, 
    0.00362196f, -0.00748023f, 0.01145343f, -0.01242172f, -0.01435281f, 0.03138471f, 0.02446987f, -0.00107091f, 
    0.01067855f, 0.03438349f, -0.02281729f, 0.01844160f, -0.01429536f, 0.02365207f, -0.03488399f, 0.00503056f, 
    0.01606879f, -0.01009709f, 0.00242574f, -0.02062787f, -0.01998905f, -0.01264411f, 0.01584143f, -0.01161790f, 
    -0.01179814f, -0.03230089f, 0.02513842f, -0.02996824f, -0.03885441f, 0.01681281f, -0.01100794f, -0.00181549f, 
    -0.02933398f, -0.03227896f, -0.01005392f, -0.03751274f, -0.01791652f, 0.01965803f, -0.04346507f, -0.01187208f, 
    0.03080624f, -0.02248490f, 0.00391853f, 0.02203451f, -0.00498629f, 0.02304208f, -0.01725012f, -0.00229343f, 
    -0.00154100f, -0.02798489f, -0.01581530f, -0.01922163f, -0.01799130f, -0.00625898f, -0.01005081f, -0.03757701f, 
    0.00732321f, 0.00076260f, -0.03471515f, 0.00304927f, -0.02156887f, 0.02827678f, -0.02719252f, -0.01845282f, 
    -0.03948726f, 0.00205259f, -0.01919550f, -0.02562464f, 0.00190879f, -0.01347222f, 0.03556588f, 0.00612651f, 
    -0.00274359f, -0.02373283f, 0.00023149f, -0.02097999f, 0.02635387f, 0.01968716f, 0.01867362f, -0.00817259f, 
    -0.03500573f, -0.01247037f, -0.01586653f, -0.00788719f, -0.03712146f, -0.01480466f, 0.01734332f, 0.02488363f, 
    -0.00500730f, -0.01738688f, 0.00906862f, -0.04052218f, -0.01951565f, 0.01853567f, -0.03374002f, 0.00621783f, 
    0.02382462f, 0.00239581f, -0.01012498f, -0.00443248f, -0.02703623f, -0.00029258f, -0.00158010f, 0.01935757f, 
    -0.03340708f, 0.01969560f, -0.02204964f, -0.01035899f, 0.02564020f, -0.03538343f, -0.00043208f, -0.04322175f, 
    -0.03261531f, 0.02725133f, -0.02997236f, -0.03537009f, 0.01810224f, -0.01094133f, 0.02620724f, 0.02939413f, 
    0.02439275f, -0.01130843f, 0.02369517f, -0.01716829f, 0.01640958f, 0.02338192f, 0.00771301f, 0.00167381f, 
    -0.02683432f, 0.01628181f, -0.00746874f, 0.03359712f, -0.02673906f, 0.02093813f, -0.04017047f, -0.00006617f, 
    -0.00731953f, 0.00529943f, 0.02739250f, -0.00084678f, 0.01083662f, 0.00715609f, 0.00227720f, -0.01658987f, 
    -0.02520654f, -0.02349208f, -0.03683656f, -0.03078855f, 0.01603634f, -0.02796256f, -0.02471154f, -0.00296069f, 
    0.02780325f, 0.01442404f, -0.00661824f, 0.00054350f, -0.02170557f, -0.04133796f, -0.00992491f, -0.00147872f, 
    0.00119739f, 0.01169439f, 0.01614982f, 0.01276940f, -0.03444814f, 0.02511671f, 0.02706559f, 0.02457023f, 
    -0.00039781f, -0.00427994f, -0.02767698f, 0.02991592f, 0.00631939f, -0.03641561f, -0.00901598f, 0.02635497f, 
    -0.03661478f, -0.03517684f, 0.00948683f, 0.03540871f, 0.01512762f, -0.01089278f, -0.03040705f, -0.03591642f, 
    -0.01358342f, -0.02076791f, 0.00129302f, -0.02398378f, -0.03798245f, -0.00025352f, 0.02361672f, -0.03111294f, 
    -0.03587624f, 0.01143042f, -0.03921589f, -0.01085920f, 0.02529527f, 0.03099762f, 0.02858252f, 0.00109095f, 
    -0.00030387f, 0.01700177f, 0.00029988f, -0.02361543f, -0.04269819f, 0.00035130f, -0.00774678f, -0.00021546f, 
    0.02302243f, -0.00202132f, 0.00813734f, -0.00127754f, 0.02912798f, 0.00093448f, 0.01901348f, -0.03669443f, 
    -0.02180337f, 0.02412993f, 0.02776656f, -0.04045764f, -0.00599642f, 0.02238424f, 0.02477327f, 0.03172412f, 
    -0.02298560f, 0.02242510f, -0.02991723f, -0.02533330f, -0.03018710f, 0.03115023f, 0.01647251f, -0.03280162f, 
    -0.02216373f, -0.02422529f, 0.01430081f, 0.02133710f, -0.00841219f, 0.02173349f, 0.02257052f, -0.01758454f, 
    -0.00802020f, -0.01998903f, 0.01561958f, -0.03001787f, -0.03656710f, -0.03635321f, -0.02334429f, 0.01289992f, 
    -0.03317806f, -0.03122466f, 0.03192098f, -0.02779715f, 0.02208391f, 0.01467458f, -0.02440962f, 0.01697686f, 
    0.02821838f, 0.00148208f, 0.01215732f, -0.01315716f, 0.01791542f, 0.01116477f, 0.02372009f, 0.03021161f, 
    -0.00984507f, -0.02499481f, -0.00012847f, -0.02418244f, 0.01898407f, -0.02929321f, -0.01569987f, 0.00585943f, 
    0.02718232f, 0.00488697f, 0.00996150f, 0.01690341f, -0.03674874f, -0.00807457f, -0.02893509f, 0.02534331f, 
    -0.03402005f, -0.03593727f, 0.00988799f, -0.03533702f, -0.03261282f, -0.00175947f, -0.00242720f, 0.02639918f, 
    -0.02331017f, -0.04063056f, -0.03356551f, -0.03176472f, 0.01545319f, -0.01801900f, 0.01779520f, 0.01907705f, 
    0.01927953f, -0.00932466f, 0.00497339f, 0.01692114f, -0.02807502f, 0.01621545f, 0.00444596f, -0.03767125f, 
    -0.00517128f, 0.00119374f, 0.01273940f, -0.01802631f, 0.01444773f, 0.00631171f, 0.02460551f, -0.03676539f, 
    0.02108213f, 0.00613965f, 0.02041506f, 0.02718091f, 0.00610464f, 0.01027807f, -0.02900597f, 0.00415737f, 
    0.00172137f, 0.00308070f, -0.00885795f, -0.04050296f, -0.01761410f, 0.00438664f, -0.03964518f, -0.03323487f, 
    -0.03085348f, 0.01833540f, 0.02296569f, -0.03602610f, -0.03600327f, -0.01685196f, 0.00231339f, 0.00486661f, 
    -0.00016480f, 0.00838035f, -0.03790312f, -0.00580174f, -0.01520875f, -0.00539033f, 0.02292036f, -0.01710228f, 
    0.00271686f, -0.03116746f, -0.01000177f, -0.01987416f, -0.01836909f, -0.01944546f, -0.02549228f, -0.01011431f, 
    -0.01659874f, 0.03541858f, -0.00964365f, 0.00111128f, 0.02751717f, 0.01987411f, -0.03678834f, 0.01108906f, 
    0.00990998f, -0.02759866f, 0.00689829f, -0.03068970f, 0.01515770f, -0.01736227f, -0.03649552f, -0.01296024f, 
    0.01324233f, -0.01455099f, 0.02955645f, -0.03193146f, -0.03305591f, 0.01392553f, -0.01504976f, -0.03372630f, 
    -0.00554271f, -0.03022049f, 0.01786140f, -0.01904665f, -0.01010606f, -0.03013417f, -0.03037982f, -0.00273948f, 
    0.00219200f, -0.04289715f, 0.02319794f, -0.03753981f, 0.00357630f, -0.03235474f, 0.00029778f, 0.00687751f, 
    -0.00674583f, 0.01048591f, 0.01679433f, -0.02755201f, -0.01187685f, 0.00993625f, -0.02965523f, -0.01737404f, 
    0.01142931f, 0.01208083f, -0.00503391f, -0.00106878f, 0.02597124f, 0.00615555f, 0.00847680f, -0.02956675f, 
    0.01210764f, -0.02636233f, -0.01117648f, -0.00126474f, 0.02334782f, -0.00642988f, 0.00651357f, -0.03138719f, 
    0.00715741f, -0.02271081f, -0.02419012f, -0.00319140f, 0.00834161f, -0.01393170f, -0.01525905f, -0.01599185f, 
    -0.00643055f, -0.01994798f, 0.01611422f, -0.02591680f, -0.00411252f, 0.02209989f, -0.03311218f, -0.02105467f, 
    -0.00642098f, 0.02277356f, -0.03644450f, -0.03275300f, -0.01000400f, -0.02716924f, -0.00359303f, 0.01812185f, 
    0.01249639f, 0.02313130f, 0.02326255f, -0.00699413f, -0.00410576f, 0.01648363f, 0.01704998f, -0.00866654f, 
    0.02962377f, 0.01663165f, -0.01994946f, -0.01708024f, 0.00334778f, -0.02792484f, -0.02460165f, -0.00090765f, 
    0.01309593f, -0.01741420f, -0.02452928f, -0.00241835f, 0.00868733f, -0.01430876f, 0.00377609f, -0.01073825f, 
    -0.02371019f, 0.00193460f, -0.02912407f, -0.04027006f, 0.02555734f, 0.01347654f, -0.01703620f, 0.00557483f, 
    0.00449778f, 0.00457513f, -0.01306844f, 0.01296940f, 0.00275697f, 0.01679439f, 0.02555965f, -0.02281784f, 
    -0.01748516f, -0.00535682f, 0.01164414f, -0.01076417f, 0.02204144f, -0.03844811f, 0.00941977f, -0.03301439f, 
    0.02906375f, -0.02415879f, 0.00135841f, -0.01578860f, -0.00339174f, 0.02521053f, -0.02239894f, 0.01602216f, 
    0.02169280f, -0.02378737f, 0.01141246f, 0.02981639f, -0.01391834f, -0.00793248f, 0.00452309f, -0.01569432f, 
    -0.01202070f, 0.00486553f, 0.00228213f, -0.03484173f, -0.03152004f, -0.03414880f, -0.01595826f, 0.01625957f, 
    -0.01900939f, 0.02007207f, 0.00600895f, 0.02002369f, 0.02331614f, -0.01195766f, -0.00070455f, -0.02350224f, 
    -0.03581954f, 0.02740590f, 0.00139282f, 0.00658256f, -0.03638544f, -0.03376058f, -0.01702195f, -0.02104552f, 
    0.00946135f, 0.01847808f, 0.01187569f, 0.01097960f, -0.03710043f, 0.00443695f, -0.00463077f, 0.00702959f, 
    -0.01255201f, -0.00114649f, 0.00044589f, 0.02278411f, 0.02304187f, -0.03797112f, 0.02402662f, 0.02533802f, 
    0.03407429f, -0.02413955f, -0.02159587f, -0.01010943f, -0.03937801f, -0.02231970f, -0.02160254f, -0.02412137f, 
    0.01147017f, 0.02788210f, 0.01363055f, 0.01747407f, 0.00970072f, -0.01363107f, 0.02016947f, 0.02619223f, 
    0.02621827f, -0.02400301f, -0.01584493f, -0.00956408f, -0.02042065f, 0.00126365f, -0.00986747f, -0.01159748f, 
    0.01284283f, -0.03190631f, -0.02344333f, 0.02127308f, 0.02811974f, 0.02757985f, -0.00112556f, 0.02880750f, 
    -0.00860267f, 0.02202362f, 0.01748221f, 0.00279587f, -0.01737491f, 0.02226594f, 0.00330138f, 0.02530554f, 
    -0.03532489f, -0.03369343f, 0.00004306f, -0.01846030f, 0.01219533f, 0.01349287f, 0.00375712f, -0.00880449f, 
    -0.01517033f, 0.02609531f, 0.02667167f, -0.02742602f, -0.00665383f, 0.02380859f, 0.02436142f, -0.01055174f, 
    0.00752622f, -0.00618800f, -0.02214799f, 0.02241825f, 0.02902439f, 0.00365112f, 0.02485046f, -0.02636323f, 
    0.03053564f, -0.02764429f, -0.03804220f, -0.01495854f, -0.01818760f, 0.01389442f, 0.00085707f, -0.01742335f, 
    -0.01766136f, 0.03516577f, -0.00254094f, 0.01710257f, -0.01708070f, -0.03561206f, 0.01410769f, 0.01319716f, 
    0.00490941f, 0.04180251f, 0.02265765f, 0.01457744f, -0.03001619f, 0.00610164f, 0.01694594f, 0.00814545f, 
    -0.00789849f, -0.01454124f, 0.02955037f, 0.02858778f, -0.00165796f, 0.01696326f, 0.00431954f, 0.02127907f, 
    0.01644214f, 0.01146440f, 0.01279996f, -0.04266613f, 0.03063665f, 0.01958064f, -0.01150567f, 0.01064080f, 
    -0.00096891f, -0.00810028f, -0.02940738f, -0.03519984f, 0.01772635f, 0.00608739f, 0.01302394f, 0.02483620f, 
    -0.00581339f, 0.01959727f, 0.02711797f, -0.01161755f, -0.02729857f, 0.01328732f, -0.01933025f, -0.01496888f, 
    0.00329468f, -0.04106537f, 0.00688407f, 0.03020395f, 0.02740817f, -0.00954832f, -0.03593885f, -0.00494890f, 
    0.00564937f, 0.00452143f, 0.00831628f, -0.01512472f, -0.01625784f, -0.01026997f, 0.01304573f, -0.02191312f, 
    0.00978673f, 0.00129411f, 0.01380906f, -0.00415598f, -0.01937083f, -0.01740715f, -0.02789203f, 0.00694914f, 
    -0.01071661f, -0.02835662f, -0.03582346f, 0.02323174f, -0.01245697f, 0.00381100f, 0.03235993f, -0.03181099f, 
    -0.01283610f, -0.01396311f, -0.00260021f, 0.00294576f, 0.00920272f, -0.04265788f, 0.01278988f, -0.00495436f, 
    0.03756482f, -0.01777884f, -0.01432386f, -0.03293982f, 0.03794153f, 0.02253918f, 0.02106272f, 0.00135820f, 
    -0.02226990f, 0.03138865f, 0.00537882f, -0.01589438f, -0.01652021f, -0.02536343f, -0.04036513f, -0.04153507f, 
    -0.00566434f, -0.00559496f, 0.04009578f, 0.01286696f, -0.01603851f, 0.00662917f, 0.00063390f, -0.01219100f, 
    0.00778427f, 0.00728464f, -0.00082997f, -0.01877385f, 0.02576062f, 0.03358414f, -0.03702036f, 0.02283701f, 
    0.01406110f, -0.01522284f, 0.00692208f, 0.00089305f, -0.03323421f, -0.03409128f, -0.02057864f, -0.03246489f, 
    -0.04003670f, 0.00160247f, -0.03420880f, -0.02835977f, -0.01626742f, -0.01175411f, -0.03098158f, -0.01545955f, 
    -0.03615218f, -0.03857312f, -0.02165336f, 0.01878180f, 0.00593875f, -0.03710593f, 0.03112651f, 0.01500773f, 
    -0.01360045f, -0.03566031f, -0.01802811f, 0.01080037f, -0.03516855f, -0.02415507f, -0.02884854f, -0.00128530f, 
    -0.03926152f, 0.01033642f, -0.03180885f, 0.02157536f, 0.00103823f, 0.00227395f, 0.02196777f, -0.01783771f, 
    -0.03235210f, 0.01953737f, 0.02955711f, -0.00243432f, -0.02244403f, 0.00427284f, 0.02068905f, 0.00386957f, 
    0.00659243f, -0.00362038f, -0.02398530f, -0.01116933f, -0.02075881f, -0.00392259f, -0.02151125f, -0.02801484f, 
    0.01094085f, -0.02306630f, 0.00918207f, -0.03404934f, 0.01131940f, -0.03008548f, 0.01029174f, 0.00241321f, 
    -0.00129752f, -0.01989410f, -0.03514045f, -0.01337873f, 0.00454938f, 0.01255177f, 0.00874003f, -0.02828787f, 
    0.01133085f, -0.00872371f, -0.02377193f, 0.00252833f, -0.00009202f, 0.01718653f, 0.02771731f, 0.00405725f, 
    -0.00633767f, -0.01123465f, 0.00224357f, -0.03061662f, 0.00788398f, -0.02910770f, -0.00539954f, -0.01936733f, 
    0.01897362f, -0.01244958f, -0.03206800f, -0.03572539f, -0.00905793f, -0.02759342f, -0.00879588f, 0.01134691f, 
    -0.02570136f, -0.02158799f, -0.01912855f, 0.02071886f, -0.02933865f, 0.00560881f, -0.04155150f, 0.01246945f, 
    -0.00491133f, -0.00219621f, 0.01840282f, -0.00468424f, -0.02886542f, -0.01635239f, -0.03505490f, -0.02026422f, 
    0.01525045f, -0.04004800f, -0.00841394f, 0.02255212f, -0.01947818f, 0.00815983f, 0.03186901f, -0.03113126f, 
    -0.02129955f, -0.01327881f, -0.00127262f, 0.03088513f, -0.03160540f, 0.01135959f, -0.03675145f, -0.04013143f, 
    -0.02865485f, 0.01058368f, 0.00473720f, 0.00745721f, 0.00055028f, 0.02610608f, 0.02142240f, -0.01289248f, 
    -0.01530497f, 0.02019356f, -0.01993300f, -0.02615349f, 0.00353493f, -0.01936725f, -0.01950245f, 0.01487312f, 
    -0.02373625f, -0.02630091f, -0.02970929f, 0.00812686f, 0.00866861f, 0.03396276f, 0.00208523f, 0.01460459f, 
    -0.02589664f, 0.02767974f, -0.01142798f, -0.01433585f, -0.04077416f, 0.02915691f, 0.02766080f, 0.01558611f, 
    0.01928499f, -0.03036818f, -0.03329636f, 0.00036706f, -0.03806428f, 0.00755626f, -0.02445757f, -0.02006084f, 
    -0.01418375f, -0.02695801f, 0.01660120f, 0.01040597f, -0.03655891f, 0.02410674f, -0.02980900f, -0.04251685f, 
    -0.01506563f, 0.03054826f, -0.03318352f, 0.02814962f, 0.00635840f, -0.03256350f, 0.01704942f, 0.02811903f, 
    -0.01267132f, -0.00118129f, -0.01174283f, 0.01287059f, -0.02472979f, 0.00935950f, 0.01074715f, -0.02600987f, 
    -0.00133124f, -0.04029412f, 0.02398585f, -0.01924033f, 0.02697488f, 0.01039070f, -0.00845386f, 0.00326967f, 
    -0.03000541f, -0.03501800f, 0.02927057f, -0.02642508f, -0.01098547f, 0.01187806f, 0.00294706f, 0.00271732f, 
    0.02815861f, -0.03296421f, -0.01001891f, 0.01822764f, -0.00909791f, -0.01159103f, -0.03095804f, 0.02383792f, 
    -0.00454753f, -0.00840483f, 0.00492659f, 0.01767449f, -0.00575533f, -0.02211343f, -0.04288999f, 0.01371441f, 
    -0.00520186f, 0.02860243f, 0.00554307f, -0.02026941f, -0.00491589f, -0.00246525f, -0.00139148f, -0.02473210f, 
    -0.00768668f, -0.02424828f, -0.00971209f, 0.00450960f, -0.02920965f, 0.02747804f, -0.01127386f, -0.02509730f, 
    -0.02560056f, 0.02028212f, 0.00466105f, 0.00634694f, 0.02195478f, -0.03039777f, 0.01191739f, 0.02607653f, 
    -0.01217960f, -0.03905027f, 0.02239792f, 0.02165558f, 0.01285030f, -0.00071203f, 0.01639757f, 0.02226537f, 
    0.01435817f, -0.00153722f, -0.00310714f, -0.01320460f, 0.02708273f, -0.03287759f, 0.03328467f, 0.00393587f, 
    -0.03758881f, 0.02560836f, -0.00883254f, -0.00100946f, 0.01270810f, 0.02203528f, -0.01063213f, -0.00983861f, 
    -0.03832208f, -0.00185959f, 0.01877744f, -0.03448373f, -0.02154023f, -0.04042757f, -0.01059331f, -0.02419234f, 
    0.02081081f, -0.02932208f, 0.02442904f, 0.02787360f, -0.01830657f, 0.00642591f, -0.01587268f, 0.01214503f, 
    -0.00868587f, 0.01887619f, -0.03379650f, 0.00793702f, 0.00835305f, 0.02535390f, 0.01608974f, -0.01353686f, 
    0.02772277f, -0.03312726f, -0.00719997f, 0.02504528f, -0.00473610f, -0.02407521f, 0.03534551f, -0.02831707f, 
    -0.00420299f, 0.01878246f, 0.02830379f, 0.02076528f, -0.01591922f, 0.01346068f, -0.03738690f, 0.02910000f, 
    -0.02649486f, -0.00952882f, 0.00810446f, -0.00046688f, 0.01514436f, 0.00568058f, 0.02088759f, 0.02395350f, 
    0.01783343f, 0.02902526f, -0.02802971f, -0.02565721f, -0.02768807f, -0.02230076f, -0.03759018f, 0.02764408f, 
    0.01081135f, 0.00437294f, -0.03884388f, 0.02837675f, -0.00165408f, -0.00390910f, -0.01190306f, -0.01631321f, 
    0.00270010f, -0.00289338f, 0.01718586f, -0.01150523f, 0.00270096f, -0.03356008f, -0.01601034f, -0.02274766f, 
    -0.01629875f, 0.00637052f, -0.03522513f, -0.02528138f, -0.01923096f, -0.02679823f, -0.02474049f, -0.00005326f, 
    -0.03001978f, -0.00648368f, 0.01064950f, 0.02257601f, 0.03665083f, 0.02602931f, -0.02517829f, 0.03541248f, 
    -0.03549942f, 0.02962977f, -0.01140422f, -0.02172694f, -0.03746913f, -0.03412836f, -0.03564673f, 0.00203138f, 
    -0.02092648f, -0.00743041f, -0.01426919f, -0.01313689f, 0.00172698f, 0.01886595f, -0.00248561f, 0.02378695f, 
    -0.00424210f, -0.01687244f, -0.03638611f, -0.01120874f, -0.02139492f, -0.00355650f, -0.00434106f, -0.03657936f, 
    0.02745082f, -0.00552989f, -0.00785965f, 0.01325595f, -0.00588041f, -0.02646085f, 0.02418208f, 0.02539945f, 
    0.01894390f, 0.01975740f, -0.03939640f, -0.02299264f, 0.03178800f, -0.02423056f, -0.02355919f, -0.01288667f, 
    -0.00211252f, 0.00020337f, 0.02340392f, 0.01692383f, 0.02517935f, 0.02284145f, 0.02595209f, 0.02311683f, 
    0.01080431f, -0.03493647f, -0.00184676f, 0.02431166f, -0.02784429f, -0.02202146f, -0.00410245f, 0.02040909f, 
    0.00692554f, 0.00495315f, 0.00533749f, -0.00472221f, -0.01204755f, -0.03826017f, 0.01545880f, -0.03826105f, 
    0.03985304f, -0.02837589f, 0.00656068f, -0.00198627f, 0.02170200f, 0.02056794f, -0.03439010f, -0.00686019f, 
    -0.00653406f, -0.02376495f, 0.00894033f, 0.01757946f, -0.01616358f, -0.01549612f, -0.01466588f, 0.02887598f, 
    -0.00126487f, 0.01961835f, -0.03373695f, -0.01942749f, -0.00451394f, 0.01658172f, -0.00323154f, -0.02576709f, 
    -0.01894567f, 0.03055641f, -0.03613978f, 0.01300800f, 0.02371887f, 0.01235894f, -0.00249118f, -0.03309564f, 
    0.01545667f, 0.02112179f, -0.02976891f, -0.00285120f, -0.02120437f, -0.02497393f, -0.03014238f, -0.02973407f, 
    0.01391010f, -0.04101845f, 0.02589203f, -0.03853296f, -0.00556402f, -0.00648660f, 0.02927446f, 0.00856447f, 
    -0.01766940f, -0.03598989f, 0.02581536f, 0.02643931f, 0.02821031f, -0.00877306f, -0.01694615f, -0.00900684f, 
    0.00709210f, 0.00383020f, -0.03668348f, 0.01872335f, 0.02142495f, 0.02000962f, -0.02479843f, 0.02555144f, 
    0.00599594f, 0.01812592f, 0.03241133f, -0.02714019f, -0.02412415f, -0.00074127f, -0.01505394f, -0.01833252f, 
    0.02516310f, 0.01332926f, -0.01440501f, -0.02487828f, -0.01884050f, 0.02162784f, -0.00296633f, 0.00811344f, 
    0.00294280f, 0.01118664f, -0.03460044f, -0.01739428f, -0.02361514f, -0.00125647f, 0.01457172f, -0.00888279f, 
    -0.04312845f, -0.00033324f, 0.03757311f, 0.00034783f, 0.02839921f, -0.01686117f, -0.02022252f, -0.04038038f, 
    0.01436108f, -0.03977361f, -0.02622535f, -0.01170506f, -0.00276799f, -0.00695604f, -0.00610041f, -0.02800632f, 
    -0.00416731f, 0.00533454f, 0.00962142f, -0.01550625f, 0.01260389f, 0.02324232f, 0.00042828f, -0.01556859f, 
    0.01077592f, 0.02879725f, -0.02991936f, 0.01397220f, 0.00716457f, -0.00248379f, 0.00780408f, 0.00273469f, 
    -0.02721023f, 0.01059509f, -0.00919934f, -0.00405305f, -0.01925836f, -0.00602199f, 0.01932297f, -0.03844738f, 
    -0.01701507f, -0.03657275f, 0.00145544f, 0.02557913f, -0.03070457f, 0.02526085f, -0.00285867f, -0.03235916f, 
    -0.01366553f, -0.02535662f, 0.00911521f, 0.01660747f, -0.02759277f, -0.00394796f, 0.02230966f, -0.03040416f, 
    -0.01783447f, -0.01572532f, -0.01361045f, -0.00101982f, 0.02532458f, -0.03340439f, -0.01789369f, 0.00468303f, 
    0.00209784f, 0.02183858f, -0.03677811f, -0.01899082f, -0.01634152f, -0.02613583f, 0.02739752f, 0.00238493f, 
    0.03198135f, 0.00559572f, 0.02751620f, -0.02967100f, 0.01625880f, 0.01654640f, 0.02173423f, -0.00020016f, 
    0.01048220f, -0.03442495f, -0.02948892f, -0.01301047f, -0.00917745f, 0.02524337f, 0.02677221f, -0.02122200f, 
    0.02510453f, -0.00334224f, 0.03220509f, -0.01974891f, 0.01606523f, 0.01764750f, -0.03473048f, -0.04073918f, 
    -0.02325083f, 0.00645857f, -0.00245343f, 0.01097827f, -0.03482063f, -0.00049376f, 0.01999555f, 0.01702869f, 
    -0.00774995f, 0.00994158f, -0.03712754f, -0.01482060f, 0.01234770f, 0.01366335f, 0.02924606f, 0.03019540f, 
    -0.00167942f, -0.03088791f, 0.01580698f, 0.00109296f, -0.03733279f, -0.01157860f, 0.01804701f, -0.02006337f, 
    0.02403762f, 0.00594763f, -0.01309078f, -0.02324357f, 0.00517683f, 0.03776425f, -0.03744675f, -0.03243561f, 
    0.00729071f, -0.02238486f, -0.02386543f, 0.01609134f, -0.01123100f, 0.01914582f, 0.00706917f, -0.01597531f, 
    -0.00096598f, -0.02225114f, 0.02564489f, -0.02671384f, -0.03821854f, 0.00733539f, 0.01204553f, 0.01089103f, 
    0.02771214f, 0.00800402f, -0.01634266f, -0.03093919f, 0.02654232f, -0.02312753f, 0.02993226f, -0.00940958f, 
    -0.00400663f, 0.00247710f, -0.04264898f, -0.01147594f, 0.01311290f, 0.01678697f, -0.02476782f, 0.00326224f, 
    0.01896908f, 0.01809093f, -0.01458541f, 0.01073315f, 0.00517018f, -0.01410587f, 0.02737266f, 0.00906335f, 
    0.02534746f, -0.03460886f, 0.01691022f, 0.00608066f, -0.01451855f, -0.01718597f, -0.04120595f, -0.01211000f, 
    -0.02308694f, -0.02555855f, -0.03316123f, 0.00699876f, -0.01220397f, -0.03015276f, 0.01360818f, 0.04380720f, 
    -0.00183518f, 0.01317808f, 0.00533334f, 0.00354878f, 0.03079712f, -0.02261346f, 0.02117937f, 0.00430962f, 
    0.01160298f, 0.02425961f, 0.01125721f, 0.01081552f, -0.00987224f, 0.02870308f, -0.03135155f, -0.00744519f, 
    -0.00646760f, -0.01591778f, -0.04167062f, -0.03281254f, -0.00428999f, -0.03977632f, -0.03837166f, -0.02401390f, 
    -0.02085811f, -0.00815730f, -0.04356418f, 0.00923032f, 0.01233856f, -0.02902293f, 0.00796613f, 0.01194948f, 
    0.02457899f, -0.01803479f, -0.00388266f, 0.02511633f, 0.02572442f, 0.00088911f, 0.02391366f, -0.03015538f, 
    0.02027979f, 0.02882635f, 0.03205231f, -0.02190091f, 0.00710669f, -0.03577538f, 0.00915624f, -0.02493647f, 
    0.01543429f, 0.01603286f, 0.02216594f, 0.01438000f, -0.00334937f, -0.02699773f, -0.03252799f, 0.00772560f, 
    0.02571818f, -0.02207108f, 0.00592468f, -0.01377657f, -0.03352086f, -0.02280614f, 0.02234061f, -0.04216513f, 
    0.00118674f, 0.00960454f, -0.01050904f, 0.00323554f, 0.01727446f, 0.00314607f, 0.02608843f, -0.02540764f, 
    -0.04194995f, 0.02141438f, -0.03537167f, 0.02889090f, -0.02680601f, -0.00366253f, -0.01965995f, 0.01354167f, 
    -0.02393703f, -0.00324897f, 0.03178259f, 0.03160683f, 0.00661871f, -0.01177434f, 0.00890771f, -0.00107571f, 
    0.02282999f, 0.01409220f, 0.02576776f, 0.00361346f, -0.00810268f, 0.00323224f, -0.00385304f, -0.02431962f, 
    -0.01100582f, -0.00637442f, 0.00308711f, 0.02668263f, -0.02785180f, 0.01484736f, 0.03183523f, 0.03474319f, 
    -0.01930902f, -0.02155100f, -0.02470651f, 0.01359092f, 0.01548800f, -0.01322851f, -0.01385252f, 0.00931081f, 
    -0.03478878f, 0.00741136f, 0.01605180f, -0.01521013f, 0.00365829f, -0.01402416f, -0.03423294f, 0.00825933f, 
    0.03284901f, 0.01985718f, -0.01152769f, 0.00389834f, -0.01412447f, 0.00111030f, -0.02416861f, 0.03608227f, 
    0.02241068f, -0.03986464f, 0.02139055f, 0.01073288f, 0.01915292f, -0.03209745f, 0.01058896f, -0.02377280f, 
    0.02431390f, -0.03479743f, 0.00460477f, -0.01532313f, -0.03166582f, 0.00861628f, -0.01188937f, -0.00922232f, 
    -0.00802350f, 0.01218386f, 0.01541514f, 0.02859762f, -0.03500962f, 0.00816930f, -0.00157685f, -0.03689691f, 
    0.01434047f, -0.03705643f, -0.00727882f, 0.02082128f, 0.00845889f, 0.03204919f, -0.03792093f, -0.00370818f, 
    -0.01049557f, -0.02925834f, -0.04297201f, 0.01489410f, 0.00693196f, -0.00899478f, -0.01947825f, -0.02951622f, 
    0.02716734f, -0.01103040f, -0.02529367f, -0.03315224f, -0.02036590f, -0.01486504f, -0.00207164f, -0.02090237f, 
    0.02828123f, 0.01572844f, 0.01407291f, -0.00698183f, -0.01965052f, -0.04297755f, -0.01504115f, 0.01267662f, 
    0.00500599f, 0.00727337f, -0.03340799f, 0.02210934f, -0.02239336f, -0.02786463f, 0.01227930f, 0.02857870f, 
    -0.00088672f, -0.02638400f, -0.03401162f, 0.01351488f, -0.01060491f, 0.00495598f, 0.00923230f, -0.00437806f, 
    0.00050788f, -0.02385440f, 0.02527314f, 0.00831457f, -0.01589209f, 0.03429960f, -0.01117114f, -0.02150166f, 
    0.02358593f, -0.02269678f, -0.02458331f, 0.00774999f, -0.00983374f, -0.00029992f, 0.01550580f, 0.01721732f, 
    0.01575833f, 0.00077712f, -0.01391802f, -0.03803508f, 0.00075929f, 0.02770106f, 0.02749818f, 0.02082662f, 
    -0.00091150f, -0.00450744f, 0.00462811f, 0.00694628f, 0.01842388f, -0.00108787f, -0.02125663f, 0.01506708f, 
    -0.03297577f, 0.02642383f, -0.01430499f, -0.03527866f, 0.02632556f, 0.01706025f, -0.01854586f, 0.01231459f, 
    0.02723368f, 0.02262560f, 0.02997757f, 0.00070576f, -0.00480519f, -0.03140882f, 0.02224641f, -0.00172901f, 
    -0.03351304f, 0.00380829f, -0.03127413f, -0.01100832f, -0.01065099f, 0.01922481f, -0.00049047f, 0.01731993f, 
    0.02337967f, 0.00134063f, -0.00558131f, 0.00317392f, -0.03018284f, 0.02223565f, 0.01428940f, -0.01570776f, 
    -0.01189449f, -0.00856159f, -0.02679264f, -0.04016417f, -0.04072239f, -0.00024548f, -0.00099510f, -0.00726954f, 
    -0.03357945f, -0.01940830f, 0.02298606f, -0.02896213f, 0.00354720f, 0.04589239f, -0.03183378f, -0.01060844f, 
    -0.02981178f, -0.03447033f, 0.01083611f, -0.03461402f, -0.01855219f, 0.01879350f, 0.04420524f, -0.01425528f, 
    0.00373682f, -0.03631558f, 0.01561626f, 0.00162871f, 0.01540739f, -0.02005665f, 0.01661539f, 0.01216865f, 
    0.01463110f, -0.01571485f, 0.00836753f, 0.00977148f, 0.02908252f, 0.00409814f, -0.02738711f, -0.01956909f, 
    -0.03565241f, -0.02938096f, -0.01810503f, -0.02660589f, -0.00082739f, -0.01719654f, -0.01924080f, -0.02483305f, 
    0.01754924f, 0.01689573f, 0.02044063f, 0.01222482f, 0.02677155f, 0.00803803f, -0.00356115f, 0.01516621f, 
    -0.02119878f, -0.01346848f, 0.02963968f, -0.03899011f, 0.00909953f, -0.00601764f, -0.01093616f, 0.01219252f, 
    0.02380489f, -0.03176309f, -0.01532494f, -0.00036066f, 0.00696487f, -0.00962227f, 0.01538568f, 0.00541122f, 
    -0.01502692f, -0.02998939f, -0.02772257f, 0.02890695f, 0.01633804f, -0.02286083f, 0.00152280f, -0.02095033f, 
    -0.02104856f, -0.00899532f, 0.00801898f, 0.02001671f, 0.01422077f, -0.02624256f, 0.00869283f, -0.02594829f, 
    0.02205725f, -0.02785453f, -0.01613208f, 0.02008848f, -0.01247446f, 0.02620035f, -0.00060956f, -0.00981580f, 
    0.01226223f, -0.01118552f, -0.01670516f, 0.01197198f, -0.02657413f, -0.01967748f, -0.01159851f, -0.01067900f, 
    0.02915470f, -0.01447676f, 0.00091274f, 0.02732178f, 0.00816910f, 0.03000113f, -0.02523867f, -0.01499015f, 
    -0.01779586f, 0.01224447f, -0.02154041f, -0.01748916f, 0.02436832f, -0.03190836f, -0.01467522f, -0.00911823f, 
    0.02973480f, -0.03155512f, 0.00120743f, -0.00908765f, 0.01175037f, -0.00729113f, -0.01493491f, -0.01297315f, 
    0.02673179f, 0.01056928f, 0.02428565f, 0.01575154f, 0.01801060f, 0.02358589f, -0.02383996f, -0.00114553f, 
    0.02549127f, -0.02574638f, -0.01114455f, 0.02236355f, 0.00604153f, -0.02236104f, -0.02710348f, 0.02954802f, 
    0.02143378f, 0.02422454f, -0.03319320f, 0.00807023f, -0.03653247f, 0.00022691f, -0.00257046f, -0.00098971f, 
    -0.03730667f, -0.00219839f, -0.02507115f, -0.00032486f, 0.02152298f, 0.00663639f, -0.01531691f, 0.02803548f, 
    0.01899318f, -0.03829573f, 0.02908806f, -0.00482071f, -0.03221132f, -0.02442858f, 0.01271710f, 0.01822339f, 
    0.03099536f, 0.00999716f, 0.02904837f, 0.02437851f, 0.00076885f, -0.03154745f, 0.00124069f, 0.01106348f, 
    -0.00633024f, -0.00292208f, 0.01209185f, 0.00687403f, -0.03526947f, -0.02696576f, 0.00757372f, -0.03454434f, 
    0.00354338f, -0.03058400f, 0.01060679f, 0.02240490f, -0.01853538f, -0.03636112f, 0.01002446f, -0.00361540f, 
    -0.00363808f, -0.04209177f, -0.02306203f, 0.01779202f, -0.01193043f, 0.02504048f, -0.01958445f, -0.02077786f, 
    -0.02025185f, 0.02064942f, -0.02460825f, -0.01453130f, -0.01592856f, 0.02925153f, 0.00911047f, -0.01920277f, 
    0.02397664f, 0.01528063f, 0.03803053f, 0.00468681f, -0.02494735f, 0.01132085f, -0.00021478f, -0.03860117f, 
    -0.00847518f, -0.02812943f, 0.01544436f, 0.01709365f, -0.03785899f, -0.01114001f, 0.00960566f, -0.00555207f, 
    0.01569769f, 0.02568341f, -0.02610887f, 0.01542976f, -0.02603664f, 0.00505657f, -0.03843065f, -0.03095346f, 
    0.01562491f, 0.01952317f, 0.02185682f, 0.00529047f, -0.01049294f, 0.00856092f, 0.02236631f, -0.03869574f, 
    0.02545275f, 0.02283368f, -0.03484315f, -0.02380727f, 0.00145366f, 0.00402157f, 0.00572555f, 0.00704501f, 
    -0.01012633f, -0.02523874f, 0.01515473f, -0.02472821f, 0.01013121f, -0.00837171f, -0.00814260f, -0.03180775f, 
    -0.02340053f, 0.00473770f, -0.00219806f, -0.03820936f, -0.03493818f, -0.03726234f, 0.00004154f, 0.02856899f, 
    -0.01783616f, 0.02426010f, -0.00911275f, -0.03669732f, -0.00267578f, 0.00548378f, 0.02292424f, -0.03052198f, 
    0.00766204f, -0.02246777f, -0.02497085f, -0.01672852f, -0.01352813f, 0.01622947f, -0.01365389f, -0.01008145f, 
    0.00367287f, -0.02170176f, -0.01464433f, -0.01067201f, 0.01200179f, -0.00612884f, -0.02100890f, -0.03471331f, 
    -0.02380357f, 0.00630684f, -0.04314320f, 0.02293672f, 0.00527440f, -0.01516995f, -0.00402491f, 0.00867998f, 
    -0.02265880f, 0.01540724f, 0.02044458f, 0.01579013f, 0.01582083f, -0.01943170f, -0.00337118f, -0.00288596f, 
    -0.01618819f, 0.02638164f, -0.01563672f, 0.00197651f, 0.01326059f, 0.00270917f, -0.03670842f, -0.00035330f, 
    -0.00220393f, -0.02083565f, -0.03043011f, 0.01215244f, 0.02266067f, 0.02626480f, -0.02939305f, -0.00843053f, 
    -0.00077560f, -0.03339057f, -0.00020102f, -0.03978572f, 0.01724936f, -0.03268038f, -0.01621101f, -0.01812309f, 
    -0.04062487f, -0.00218120f, -0.00090253f, 0.02290720f, 0.00983294f, 0.00496430f, -0.03663007f, -0.03745673f, 
    0.02176387f, 0.01329009f, -0.02265223f, -0.00658827f, 0.01185607f, -0.00588335f, 0.01940893f, -0.03472222f, 
    -0.02492938f, -0.03529494f, 0.02525940f, -0.01530193f, 0.01782755f, -0.00196896f, -0.00501295f, 0.00950991f, 
    -0.01838211f, -0.02791405f, 0.01901692f, 0.00362302f, 0.02313054f, -0.03591413f, 0.00411563f, -0.04337293f, 
    -0.03300059f, 0.01084263f, -0.01584758f, 0.02360025f, -0.02854671f, -0.01189247f, 0.02695429f, -0.03975640f, 
    0.03218847f, -0.01725296f, -0.01255089f, -0.02462845f, -0.03492254f, 0.01026009f, 0.02028134f, -0.03556398f, 
    -0.02471094f, -0.04346129f, -0.02708172f, 0.00069111f, -0.03207636f, 0.01824083f, 0.01334127f, 0.01909327f, 
    0.01164060f, 0.00368456f, 0.02106320f, 0.02357516f, 0.00376557f, 0.00398564f, -0.03714463f, -0.02329294f, 
    0.02154382f, 0.00589330f, -0.00543284f, -0.04011844f, 0.02893926f, -0.00515551f, -0.02716381f, -0.01796657f, 
    0.01714865f, 0.01152404f, -0.01650536f, 0.00550805f, -0.04462134f, -0.01784640f, 0.01226455f, -0.03317790f, 
    -0.00220407f, -0.00139664f, -0.03505780f, 0.02748905f, -0.02503804f, -0.04211080f, 0.02334984f, -0.01945049f, 
    -0.00447646f, -0.03572635f, 0.02846809f, 0.00560628f, -0.03073198f, -0.01398226f, 0.00170349f, 0.01645484f, 
    -0.00077634f, -0.01611650f, 0.00154346f, 0.02491342f, 0.01766712f, -0.03718907f, -0.01102084f, -0.01884130f, 
    -0.00036911f, -0.04149474f, -0.03441681f, -0.00463768f, -0.00618069f, 0.02072382f, 0.03357212f, 0.00677308f, 
    -0.00287093f, -0.02040265f, -0.03531492f, 0.01868526f, 0.02353274f, 0.00633512f, -0.04082492f, 0.02035017f, 
    -0.03025545f, -0.00648806f, -0.00521732f, -0.04161276f, 0.01586258f, -0.03564904f, -0.01418522f, -0.01463195f, 
    0.01533001f, -0.01092374f, -0.00139348f, 0.00675393f, -0.00631370f, 0.00346119f, -0.00249113f, -0.03725290f, 
    0.01760178f, -0.00371009f, -0.04152988f, 0.00109234f, -0.02732059f, -0.02810260f, -0.01229646f, 0.03091427f, 
    -0.04571082f, -0.00984816f, -0.02129965f, -0.02435366f, -0.01740896f, -0.00269246f, -0.01271602f, -0.03430615f, 
    0.00929948f, 0.01028395f, 0.03594224f, -0.02146108f, -0.03315825f, -0.03439361f, -0.01571294f, 0.03938974f, 
    -0.03237471f, 0.00646862f, 0.01598526f, -0.00826846f, -0.00316180f, -0.01092277f, -0.02664798f, 0.01243597f, 
    -0.00757383f, -0.02880074f, -0.03963163f, -0.00263953f, 0.01421364f, -0.02767066f, 0.01133816f, 0.03720925f, 
    -0.01577040f, 0.02216045f, -0.02186064f, -0.02296158f, 0.00586348f, 0.00428393f, -0.00949230f, -0.02099290f, 
    -0.02130631f, 0.00115881f, 0.02860785f, 0.03409493f, -0.03696829f, -0.00251036f, -0.03936872f, -0.00859937f, 
    0.01865852f, 0.01659356f, 0.02111297f, -0.00377342f, 0.00357140f, 0.02215232f, 0.02104621f, 0.03378336f, 
    -0.02977064f, -0.01064484f, -0.03697064f, -0.00991828f, 0.00034333f, -0.00134568f, -0.00578667f, -0.03967060f, 
    -0.02444194f, -0.02539507f, -0.01965605f, 0.01544341f, 0.02578370f, -0.03254827f, -0.00287561f, -0.03571438f, 
    -0.04296601f, 0.01641275f, -0.02397342f, -0.04133257f, -0.03729527f, 0.01212498f, 0.01007425f, -0.02902864f, 
    -0.02572318f, -0.01515959f, -0.01161791f, 0.00378783f, 0.00135835f, 0.00045896f, 0.01483841f, 0.03062433f, 
    0.01203554f, -0.02035391f, 0.02643419f, -0.00506115f, 0.02011392f, -0.02529540f, 0.01063425f, -0.00552497f, 
    0.02367838f, 0.02337148f, 0.01018475f, -0.02807626f, 0.02594426f, -0.01355842f, -0.00954938f, -0.03979663f, 
    -0.01494874f, -0.02771978f, 0.02665545f, -0.01177283f, -0.02354279f, 0.02014437f, 0.01805749f, -0.01244526f, 
    0.01592882f, 0.01423139f, 0.01646443f, 0.02494257f, -0.02960947f, -0.00027835f, 0.00914850f, -0.00105791f, 
    -0.02155705f, -0.01236889f, -0.02930272f, 0.02745937f, 0.02807460f, -0.02605994f, 0.03003926f, 0.00978569f, 
    0.00046021f, 0.02552571f, -0.03206515f, -0.00959849f, -0.01616437f, 0.02402216f, -0.01078202f, -0.00116085f, 
    -0.01773809f, -0.00736217f, -0.02370416f, -0.03918945f, -0.03789302f, 0.00861791f, -0.01730825f, -0.03112178f, 
    0.01459684f, -0.02944858f, 0.02067013f, -0.04091189f, 0.02359175f, 0.00729187f, 0.00424810f, -0.04036642f, 
    0.00451465f, 0.02574791f, 0.00748981f, 0.01503980f, 0.02664971f, 0.01585524f, -0.04368268f, -0.02478197f, 
    -0.00136457f, 0.02800549f, -0.03779583f, -0.01347323f, -0.00813119f, -0.02650142f, -0.02939972f, -0.00162698f, 
    0.00827868f, -0.02744781f, 0.01783752f, -0.01286938f, -0.01639129f, -0.01451424f, -0.00805758f, 0.03017061f, 
    0.02539190f, -0.01761806f, -0.02915929f, 0.02562776f, -0.01690818f, -0.00770543f, -0.00235441f, 0.02010582f, 
    0.02503892f, 0.02399520f, -0.03596714f, -0.02985864f, 0.02132633f, 0.01936947f, -0.00791107f, -0.00769141f, 
    -0.02768614f, -0.01635291f, -0.04315441f, -0.00393527f, 0.00663879f, 0.02970791f, 0.00719271f, 0.00512268f, 
    -0.00411281f, -0.03500122f, 0.01940033f, -0.00229496f, 0.02216048f, -0.03277906f, -0.00602779f, 0.02113512f, 
    0.02033179f, 0.00012033f, -0.03493257f, -0.01315412f, -0.03645363f, -0.02534873f, -0.00789164f, 0.01827283f, 
    -0.01240612f, 0.00335563f, 0.00830180f, -0.02308870f, -0.03886215f, -0.03085362f, -0.00645298f, -0.03481550f, 
    0.00221598f, -0.03778755f, -0.01997758f, -0.02374110f, 0.01539210f, -0.02297959f, -0.02715819f, -0.00563321f, 
    0.01439823f, -0.02598903f, -0.02402907f, -0.01454982f, -0.01291558f, -0.01072042f, 0.01328781f, 0.02077843f, 
    0.01776010f, 0.00364637f, -0.01807750f, 0.00398498f, -0.02565617f, 0.00048103f, 0.02821888f, 0.02679636f, 
    0.01867470f, -0.01900078f, 0.02160271f, -0.01717901f, -0.03409513f, -0.03902361f, -0.00264481f, 0.01244074f, 
    0.00545448f, -0.01450589f, -0.03882726f, -0.00226044f, 0.00035832f, -0.02650987f, -0.00871907f, -0.01014297f, 
    0.01545529f, -0.02474512f, 0.02256979f, 0.01708397f, 0.01417715f, -0.01912321f, -0.03399708f, -0.00938243f, 
    -0.03897933f, -0.03995783f, 0.02626769f, 0.00604503f, -0.04046471f, -0.01731299f, -0.04316891f, 0.00579912f, 
    -0.01776017f, -0.01833881f, -0.02289763f, 0.02944167f, 0.03159266f, -0.00399982f, 0.00789929f, -0.01394320f, 
    -0.03723162f, -0.01886836f, -0.04058687f, 0.02613113f, -0.01529624f, 0.02051300f, 0.00375546f, -0.02494727f, 
    -0.01834183f, 0.01212501f, 0.00556447f, -0.00214552f, -0.01333625f, -0.01889753f, -0.00592871f, -0.01228087f, 
    0.01948260f, -0.03390510f, 0.00374935f, 0.00541302f, 0.02313303f, -0.02436857f, 0.02804764f, -0.01869245f, 
    0.00381310f, -0.01701135f, 0.00166917f, 0.00545144f, -0.01201990f, 0.01157155f, -0.01307413f, -0.02455103f, 
    0.02970176f, -0.00508409f, -0.03876279f, -0.02645140f, 0.02255161f, -0.03183321f, 0.00175007f, -0.01259871f, 
    -0.00012276f, 0.00653406f, 0.00147603f, -0.02827628f, 0.01809766f, 0.02495938f, -0.00618418f, -0.00013143f, 
    -0.01177843f, 0.02723587f, 0.01990329f, -0.00181663f, -0.00671070f, 0.00246311f, 0.00224783f, 0.02852506f, 
    0.01964275f, -0.02590609f, -0.01340305f, 0.00315054f, -0.02554050f, 0.02112715f, 0.00636439f, 0.00025954f, 
    -0.00590793f, -0.01573962f, -0.00141406f, 0.02129019f, 0.00936639f, -0.01892794f, 0.02031357f, -0.00541552f, 
    -0.01586065f, -0.00161854f, -0.03024937f, -0.03369347f, 0.01658336f, 0.00617157f, -0.02935906f, 0.00535872f, 
    -0.00109177f, 0.02312701f, 0.01396774f, 0.01545694f, 0.00706804f, -0.01755774f, -0.00430226f, -0.02113872f, 
    -0.00352012f, -0.03522341f, 0.03024631f, 0.02344078f, 0.03208041f, -0.03149359f, -0.01633202f, -0.03330611f, 
    -0.03676541f, -0.01964738f, 0.00083182f, 0.00479015f, 0.00520308f, -0.00568100f, 0.02978292f, -0.00872532f, 
    0.02770735f, 0.02602397f, -0.03603725f, 0.02209171f, -0.00146612f, -0.01433131f, 0.01237049f, -0.01026688f, 
    -0.02329428f, 0.01092756f, 0.02057937f, -0.01060679f, 0.01937526f, 0.02296959f, 0.02400654f, 0.02210019f, 
    -0.00215088f, -0.00886144f, -0.01091283f, -0.00419516f, -0.02557231f, -0.02432259f, -0.02453247f, -0.01313328f, 
    0.01914189f, -0.02643261f, -0.01223852f, -0.03010257f, -0.01927953f, -0.00391980f, -0.02960350f, -0.02745143f, 
    0.01531032f, 0.03242835f, 0.02386921f, 0.02668189f, 0.02452835f, -0.03400221f, -0.03532518f, -0.01585416f, 
    0.01201981f, -0.02989226f, -0.00420042f, -0.02723972f, -0.02947592f, 0.01281695f, 0.02136590f, -0.00896114f, 
    -0.04297411f, -0.04054016f, -0.01364978f, -0.03601225f, 0.02079958f, -0.03918248f, -0.04489068f, -0.00916982f, 
    -0.03798364f, 0.02199990f, -0.00665215f, -0.04258689f, -0.00341194f, 0.01824918f, 0.02496203f, 0.00509450f, 
    0.01167251f, -0.00372783f, 0.01688972f, -0.00823736f, 0.01502692f, -0.04121602f, -0.01551609f, 0.03550793f, 
    -0.01666592f, 0.00961744f, 0.01951860f, 0.02052874f, -0.00165475f, 0.00640845f, -0.00856869f, 0.01448207f, 
    -0.02008987f, -0.00979329f, 0.01691894f, -0.02952478f, -0.04022985f, -0.00604643f, 0.02498999f, -0.01795420f, 
    -0.03398135f, 0.01314535f, -0.01638113f, 0.02590686f, 0.00463191f, 0.01366269f, 0.00680634f, -0.02146564f, 
    -0.00880588f, -0.03646788f, 0.01731578f, -0.02257873f, -0.01784134f, 0.00082838f, -0.03433664f, 0.01287042f, 
    -0.03270749f, -0.03264252f, 0.01786777f, -0.02006766f, -0.03627240f, -0.03390431f, -0.03606115f, -0.03234262f, 
    -0.03130971f, -0.00159833f, -0.03075314f, 0.03552462f, -0.00537289f, -0.02655349f, -0.02552195f, -0.00334681f, 
    -0.01509877f, -0.03589598f, -0.00726440f, -0.02383666f, -0.00181748f, -0.02333592f, 0.02984903f, -0.00334058f, 
    0.01807253f, 0.00667118f, -0.01185970f, 0.01150623f, -0.01530593f, -0.03615394f, -0.02889734f, -0.03742119f, 
    0.19362175f, 0.01087622f, -0.01635863f, 0.14068660f, 0.11914252f, 0.03061848f, 0.05777461f, 0.07495730f, 
    0.01912075f, 0.01200538f, 0.05576376f, -0.00714246f, -0.06615680f, -0.01775597f, -0.03589461f, -0.12048449f, 
    0.12980245f, 0.06107710f, 0.01557228f, -0.05529525f, 0.01292377f, -0.03570758f, 0.13040617f, -0.05901001f, 
    0.06416833f, 0.20334752f, 0.02957007f, 0.17690130f, 0.07367527f, 0.03730410f, 0.14298035f, 0.02362837f, 
    0.05801313f, 0.03380911f, -0.01051152f, 0.01999924f, 0.12825085f, 0.03835073f, 0.08120603f, 0.00085299f, 
    0.04515628f, 0.06560799f, -0.05334299f, 0.07875828f, 0.03617721f, 0.09401610f, 0.06955574f, -0.04673652f, 
    0.00191544f, 0.20991351f, 0.27844977f, 0.03829660f, 0.00776478f, 0.16806769f, 0.01503584f, 0.05101292f, 
    0.11882701f, 0.08527478f, 0.03593772f, 0.13258636f, 0.34794593f, -0.00311752f, 0.05901802f, 0.21760580f, 
    0.09643395f, -0.00990291f, 0.05178518f, 0.00197992f, -0.08065569f, -0.09429625f, -0.05742901f, 0.02579061f, 
    -0.20813893f, 0.03942579f, -0.06965875f, 0.05826223f, 0.12747861f, -0.02807217f, 0.12861332f, 0.11154890f, 
    0.12593925f, 0.01883366f, 0.03391309f, 0.03693185f, 0.08176180f, 0.03248483f, 0.03739271f, 0.11834680f, 
    0.13125286f, 0.02254646f, 0.00834010f, 0.08744204f, 0.05295744f, 0.06030875f, -0.04227219f, -0.04956225f, 
    -0.20626266f, 0.13337722f, 0.05040994f, -0.00821494f, 0.15545627f, -0.01177238f, 0.15763387f, -0.01560345f, 
    0.12627488f, 0.05864485f, -0.03282164f, 0.04067972f, -0.11738425f, 0.11524575f, 0.01452949f, -0.01153951f, 
    0.02463681f, -0.01373354f, 0.09167177f, -0.01962246f, 0.05410754f, 0.02416598f, -0.04787643f, 0.04421265f, 
    -0.11114274f, 0.05929956f, 0.29835641f, 0.09125526f, -0.02439583f, 0.07851569f, 0.04190721f, 0.04768857f, 
    0.04011818f, 0.10061580f, 0.09440115f, 0.07345184f, 0.07957710f, 0.09456919f, 0.08127234f, 0.02978067f, 
    0.04361665f, 0.04672476f, 0.06839386f, 0.06108882f, -0.06814934f, -0.03808305f, 0.00033857f, 0.00374839f, 
    -0.20806511f, 0.12482077f, -0.10989831f, 0.05171921f, 0.05457610f, 0.01910888f, 0.04062835f, -0.04156097f, 
    0.09016653f, 0.02891968f, -0.07869978f, 0.04548307f, 0.09590220f, -0.28440237f, 0.18647642f, 0.10921851f, 
    0.01628129f, 0.10289650f, -0.00373468f, -0.01408577f, -0.00772790f, 0.06696352f, -0.01858486f, 0.07571541f, 
    -0.17548971f, 0.14009188f, -0.14037573f, -0.06315482f, 0.05485706f, -0.06460385f, 0.18825310f, 0.07805111f, 
    -0.08404231f, -0.07282274f, 0.03906041f, 0.05301291f, -0.32050970f, -0.08536250f, -0.17120981f, -0.09896501f, 
    0.11652149f, 0.01031985f, 0.00835597f, 0.10630755f, 0.02549349f, -0.02472821f, -0.05865512f, 0.03906263f, 
    0.03593615f, -0.01126837f, -0.03851845f, 0.05586881f, 0.08842392f, 0.08296020f, 0.01717094f, 0.07171624f, 
    -0.02808869f, 0.04517191f, -0.01781190f, 0.18951960f, -0.35143909f, 0.22086422f, 0.05188641f, 0.02791500f, 
    0.06145633f, 0.13052467f, -0.05999706f, 0.08181895f, 0.07805505f, 0.04802709f, 0.11513964f, 0.04661424f, 
    -0.18151468f, -0.03668764f, -0.14218448f, -0.08219415f, 0.10510987f, 0.04370218f, -0.02997805f, -0.05083299f, 
    -0.05419040f, 0.06724928f, 0.05698840f, 0.11813059f, 0.07955427f, 0.08867598f, -0.05490060f, -0.16875879f, 
    0.02921178f, 0.01720249f, 0.08797311f, 0.03164066f, -0.00748647f, 0.03033941f, 0.00587956f, -0.09914206f, 
    -0.09499041f, -0.05605772f, -0.08602819f, -0.00454098f, 0.02527951f, -0.07318415f, 0.05753433f, -0.01106275f, 
    -0.04319265f, 0.06472676f, -0.05431088f, 0.03760923f, 0.07390904f, -0.13389724f, 0.14616172f, 0.11466905f, 
    -0.06935834f, -0.08901134f, 0.08957440f, -0.03210088f, 0.06154729f, 0.07979202f, -0.03866731f, -0.08273266f, 
    -0.22478729f, 0.05946411f, 0.13931215f, 0.11961526f, 0.00152323f, 0.16319242f, 0.05317562f, 0.04560687f, 
    0.13569142f, 0.05935296f, 0.17594875f, -0.00182558f, 0.01848358f, -0.00472696f, 0.24011694f, 0.28693318f, 
    -0.06500895f, -0.01987072f, 0.13737853f, 0.19633386f, 0.05252427f, 0.09830265f, 0.03373331f, 0.03858726f, 
    0.08876358f, 0.01909020f, -0.10372356f, 0.06565428f, 0.02960720f, 0.07954744f, 0.02723594f, 0.09022829f, 
    0.02029294f, -0.17175528f, 0.01045629f, 0.09853494f, -0.03531835f, 0.26528481f, 0.03165260f, -0.16959441f, 
    0.10797687f, 0.00369578f, 0.09302911f, -0.12490542f, 0.02573435f, -0.08440690f, -0.01132327f, -0.03943508f, 
    -0.26238775f, -0.13467416f, -0.10300520f, -0.07524487f, 0.05190261f, 0.01635188f, -0.07581066f, 0.07755630f, 
    0.08162512f, -0.07857887f, 0.01466360f, 0.06459471f, -0.05948455f, -0.17746645f, -0.03371657f, -0.02837114f, 
    0.05799616f, 0.03427665f, 0.02537924f, -0.02027255f, 0.03052549f, 0.11472639f, -0.10383391f, -0.04687374f, 
    -0.19437559f, -0.12677941f, -0.06728205f, -0.03617007f, 0.07095230f, -0.02637019f, -0.05534922f, -0.01162486f, 
    0.05039233f, -0.05203860f, -0.06819417f, 0.04143281f, 0.16183345f, 0.02182130f, 0.15710887f, 0.11198348f, 
    0.02675873f, 0.01313582f, 0.08484352f, 0.04666367f, 0.20163366f, -0.00079949f, 0.10004181f, -0.03415964f, 
    0.22148614f, -0.01188164f, 0.19565660f, 0.17492820f, -0.09529344f, -0.03656279f, 0.04724732f, 0.13725565f, 
    0.05655602f, 0.06507412f, 0.08923070f, 0.01122939f, 0.26642558f, 0.10700739f, 0.04230940f, 0.28270507f, 
    -0.04485136f, -0.03673692f, 0.01030313f, 0.18308701f, -0.01888093f, 0.08156551f, 0.11846642f, 0.16996363f, 
    0.16827603f, -0.05567090f, -0.05352547f, 0.09490737f, 0.00673572f, 0.11952521f, -0.00810880f, 0.12284020f, 
    0.07707524f, 0.02625381f, 0.01507392f, 0.09239504f, 0.29509097f, 0.06512929f, 0.05694281f, 0.20152810f, 
    -0.11526666f, 0.05428958f, -0.07827304f, 0.07855549f, 0.05255606f, 0.01609866f, 0.10526878f, 0.02206750f, 
    -0.23057307f, 0.02957729f, 0.15537812f, -0.14259474f, 0.11930914f, 0.03323008f, 0.05212362f, 0.01717102f, 
    0.08300798f, -0.00472894f, 0.00630684f, 0.01191798f, 0.01672229f, 0.04101361f, -0.02886724f, -0.01135391f, 
    0.06823401f, 0.05477670f, 0.09544481f, 0.05517536f, -0.00489838f, 0.02055064f, 0.08690477f, 0.02252669f, 
    -0.29698041f, 0.20157282f, -0.07219739f, 0.03782862f, 0.05199207f, 0.04494803f, 0.11376586f, 0.12408715f, 
    -0.04390951f, 0.09043970f, 0.18049411f, -0.01422897f, 0.01484311f, -0.15637939f, 0.09663946f, 0.15011486f, 
    0.05808599f, 0.09788179f, -0.00672839f, -0.13713501f, 0.07584558f, -0.00457586f, 0.05808094f, -0.05743295f, 
    0.05234499f, 0.14576831f, 0.04038883f, 0.21787606f, 0.08775450f, 0.07770430f, 0.06274337f, 0.03262626f, 
    0.08189908f, -0.00325997f, 0.01238134f, 0.17711854f, 0.02946281f, -0.10795142f, 0.18882456f, -0.11014687f, 
    0.00010141f, 0.06754097f, 0.06472928f, 0.05385855f, -0.00088289f, 0.00850739f, 0.14919950f, -0.00997120f, 
    -0.21323913f, -0.05972968f, -0.03146641f, 0.05722893f, 0.00505843f, 0.04026874f, 0.11366926f, 0.00443300f, 
    0.03006397f, -0.03477592f, 0.14400715f, 0.09200316f, -0.09957596f, -0.11880279f, -0.04064234f, -0.16018161f, 
    0.01267969f, 0.17171365f, -0.05451008f, -0.06397108f, -0.04970638f, 0.07513823f, 0.03376341f, -0.09778897f, 
    0.15770024f, -0.04436792f, 0.14454594f, 0.14986953f, -0.06951094f, 0.11284803f, -0.00617929f, 0.11622869f, 
    -0.05687494f, 0.07060923f, 0.12917399f, 0.12913482f, -0.27553391f, -0.07459573f, -0.13193141f, -0.04274347f, 
    -0.04164127f, 0.04071662f, -0.01435818f, -0.04018863f, 0.03550928f, 0.07860329f, 0.07764488f, 0.00704050f, 
    -0.12931038f, 0.17975788f, 0.03836280f, -0.13561255f, 0.20690060f, 0.03772268f, -0.00039446f, 0.01885344f, 
    0.13058572f, 0.00468963f, 0.13115256f, -0.05449833f, 0.09640295f, -0.08175245f, -0.11809970f, 0.13875599f, 
    -0.04716912f, -0.04955783f, -0.06505980f, 0.01863792f, 0.11616585f, 0.03938861f, 0.06684010f, -0.05303772f, 
    0.01308144f, 0.04417926f, 0.17274834f, 0.02913727f, 0.12561551f, -0.05000444f, -0.03095225f, 0.21260549f, 
    -0.00701421f, 0.08648156f, -0.02251066f, 0.04161097f, 0.08855918f, 0.03035333f, -0.13613197f, -0.12159590f, 
    -0.00586531f, -0.01552984f, -0.09929706f, 0.06284382f, -0.01601184f, 0.05390693f, 0.10204466f, -0.00013043f, 
    0.11130742f, -0.16703887f, 0.23346710f, 0.07604797f, -0.05552676f, -0.01217940f, 0.10931268f, 0.01116706f, 
    0.06417733f, -0.06538278f, 0.08506492f, 0.01136259f, -0.12796341f, -0.04111545f, 0.09342523f, 0.18706889f, 
    0.01215537f, 0.17565000f, -0.13094486f, 0.04490687f, 0.13762993f, -0.13254446f, -0.00599279f, 0.09713125f, 
    0.27175581f, -0.05445359f, 0.19887443f, 0.20368767f, -0.11034544f, 0.00460745f, -0.08031753f, 0.03933031f, 
    0.10592972f, -0.02266992f, -0.05865809f, 0.09183989f, 0.15767156f, -0.09868800f, 0.00268867f, 0.19052275f, 
    -0.02418704f, 0.06552324f, 0.11694197f, -0.09855425f, 0.12407293f, 0.08698767f, -0.03117604f, 0.08289122f, 
    -0.04199889f, 0.04028464f, 0.14361745f, -0.07123692f, 0.08979565f, 0.11182405f, 0.06672846f, 0.10409920f, 
    0.04703683f, -0.08006897f, 0.02794798f, 0.16317381f, 0.19135086f, 0.02773317f, -0.00673217f, 0.12551874f, 
    -0.05982384f, 0.13830248f, -0.10721119f, 0.11656506f, 0.12797913f, 0.04100644f, 0.01030016f, 0.09018940f, 
    -0.17702374f, 0.14813687f, -0.08723191f, -0.10224912f, 0.03771228f, -0.07650921f, 0.03928163f, 0.07258151f, 
    -0.00519639f, -0.00274418f, 0.01355456f, 0.12814473f, -0.09749920f, -0.33082575f, -0.01410305f, -0.10480944f, 
    -0.04565351f, 0.18521824f, 0.01811600f, -0.02386243f, 0.09620728f, 0.07225267f, 0.07000310f, 0.00281906f, 
    -0.19806755f, 0.05684054f, -0.07985207f, 0.16010930f, 0.02689403f, -0.10400910f, 0.09993509f, 0.10530079f, 
    0.00436946f, -0.12423660f, 0.08737782f, 0.08020981f, 0.20415747f, -0.19219753f, -0.05016509f, 0.09649186f, 
    0.01220530f, 0.07337498f, -0.12392630f, 0.02034032f, 0.04023165f, 0.08154664f, 0.00898326f, 0.11965214f, 
    -0.06549887f, 0.10834800f, 0.05845768f, 0.01620556f, 0.09996177f, 0.02542380f, 0.03540241f, 0.09269463f, 
    0.12286640f, 0.10360128f, 0.09648097f, 0.00985457f, -0.32125613f, -0.26270980f, 0.07605653f, 0.07516149f, 
    0.00321514f, -0.01965606f, 0.00417223f, 0.03982024f, -0.01039322f, 0.04284182f, 0.04102825f, -0.04731616f, 
    -0.08241726f, -0.05145940f, 0.07860694f, 0.19231291f, 0.06099689f, -0.06239568f, -0.07942858f, -0.03946253f, 
    0.06271661f, 0.05399973f, -0.01444760f, -0.04670812f, 0.00480469f, 0.31504178f, 0.07810709f, -0.11457853f, 
    -0.01988289f, 0.10865153f, 0.11440759f, -0.06689818f, -0.00899250f, 0.03233273f, 0.08481522f, -0.03766534f, 
    0.05697229f, -0.01352467f, -0.18333378f, 0.18553507f, -0.00038234f, 0.06927851f, -0.00564294f, -0.05753161f, 
    -0.01421103f, -0.06941977f, -0.01202501f, 0.14440466f, -0.01304556f, -0.15612231f, 0.14968312f, 0.01849830f, 
    -0.04006224f, -0.02000744f, -0.04780941f, 0.05131717f, 0.00562694f, -0.07937730f, -0.04968721f, 0.05825268f, 
    -0.00226323f, -0.17664625f, 0.10926423f, -0.01709070f, 0.02705979f, -0.03090348f, 0.00257082f, -0.03105007f, 
    -0.00632709f, 0.01198178f, 0.04982557f, -0.09560635f, 0.05666306f, 0.06770123f, 0.13845883f, 0.14629716f, 
    0.03282545f, 0.00041553f, -0.04270489f, 0.00502720f, 0.09089734f, 0.04021382f, -0.08010399f, 0.06382629f, 
    -0.04899500f, -0.00503480f, -0.08037497f, -0.03966977f, 0.04721236f, 0.01990582f, -0.04859287f, 0.08014715f, 
    0.03141452f, -0.05877851f, 0.01198783f, 0.04864407f, -0.28984553f, 0.04558836f, -0.14975823f, 0.13812670f, 
    -0.04870221f, -0.00995750f, 0.06762185f, 0.06655756f, 0.04827340f, 0.00574080f, -0.01841148f, 0.09431899f, 
    -0.22794332f, -0.07069195f, -0.11726053f, 0.09353157f, 0.07354707f, -0.03777939f, -0.04521954f, 0.10875306f, 
    0.07600264f, 0.00747363f, -0.04787425f, 0.00187539f, -0.32886484f, -0.02215171f, 0.05658823f, 0.08812888f, 
    -0.03840133f, 0.01084772f, 0.01070545f, 0.04370717f, 0.09750815f, 0.11082283f, 0.03033052f, -0.01013897f, 
    0.02053712f, 0.04912384f, 0.03285396f, -0.06152168f, -0.02070393f, 0.12402491f, -0.02039284f, 0.05487708f, 
    -0.05719211f, 0.02129963f, -0.03237975f, 0.00010679f, -0.20266619f, -0.00927583f, -0.03492442f, 0.04058433f, 
    0.09659927f, 0.03913168f, -0.00172978f, 0.01761262f, 0.05526327f, 0.00615433f, 0.02054929f, 0.11680603f, 
    0.08364388f, -0.01415738f, -0.09288076f, -0.06149724f, 0.09412488f, 0.05708753f, -0.01657676f, 0.04619292f, 
    0.01232072f, 0.05444933f, 0.07213208f, -0.00830154f, 0.08455749f, 0.04245602f, -0.13105913f, -0.24747814f, 
    0.12150704f, 0.14189819f, 0.00417264f, 0.11744766f, -0.04219297f, 0.01016677f, 0.01346410f, 0.02034910f, 
    0.03241496f, -0.14942022f, -0.11494144f, -0.14536174f, -0.01732171f, -0.00836564f, 0.04361661f, 0.02201559f, 
    -0.01526357f, -0.07664431f, 0.07033214f, -0.05715841f, 0.03046540f, -0.14699671f, -0.11482108f, -0.02100243f, 
    0.08851271f, -0.01250193f, 0.11745646f, 0.05050381f, 0.05923263f, 0.06665214f, -0.07253246f, 0.06389309f, 
    0.14053367f, -0.20553936f, 0.06500281f, 0.20613387f, 0.00916899f, 0.02818046f, -0.03707124f, -0.03853409f, 
    0.00774753f, 0.01724799f, 0.08367931f, 0.01139223f, 0.10330299f, 0.24208750f, -0.15457140f, -0.02396287f, 
    -0.11197705f, -0.01378156f, 0.00520559f, 0.01691948f, -0.05615028f, -0.02085278f, 0.02500592f, -0.00019811f, 
    -0.04993775f, -0.03865513f, -0.03038102f, -0.01776588f, 0.10457737f, 0.07785946f, -0.04100602f, -0.01507168f, 
    0.04171905f, 0.07107443f, 0.01252825f, 0.03903126f, 0.09175657f, 0.01794069f, 0.16990739f, 0.09371468f, 
    0.00746423f, 0.01907993f, 0.03698722f, -0.04976488f, 0.04255912f, 0.02376186f, 0.03931179f, -0.00988409f, 
    -0.19431894f, -0.05322887f, -0.11940382f, 0.00466131f, 0.07490592f, 0.01801248f, 0.02698398f, 0.02664866f, 
    -0.01621267f, -0.00474601f, 0.02066016f, -0.04704303f, 0.23829149f, -0.30428281f, 0.00507347f, -0.10368653f, 
    0.07830925f, -0.10673518f, 0.07567800f, 0.00138489f, -0.10110073f, -0.01602475f, -0.04769956f, -0.00464559f, 
    0.21795763f, 0.08130784f, 0.14006767f, 0.13089494f, 0.03891596f, -0.00995506f, -0.02784017f, 0.05132779f, 
    0.08584295f, -0.01658600f, -0.03796781f, -0.04715202f, -0.27901283f, 0.17904705f, -0.04452395f, 0.19518113f, 
    0.00688128f, 0.13028687f, 0.02627042f, -0.06548640f, 0.10709244f, 0.01521443f, 0.00942446f, 0.12625280f, 
    -0.22950420f, 0.26610926f, -0.08787604f, -0.14025711f, 0.08100483f, 0.07485018f, 0.02679411f, 0.00699293f, 
    0.01923174f, -0.02819768f, 0.05924935f, 0.05446712f, -0.04523703f, 0.15094563f, 0.01470488f, 0.06766822f, 
    -0.08329398f, 0.06954121f, 0.00120131f, -0.00009205f, -0.09910086f, -0.09584347f, 0.05252137f, 0.08442403f, 
    0.18037410f, 0.01290949f, 0.05870542f, -0.03960410f, -0.02547629f, -0.05292683f, 0.02681575f, 0.03716070f, 
    -0.05563462f, -0.02106537f, -0.06545929f, -0.00956867f, 0.06569073f, 0.00833130f, -0.04946695f, -0.15529533f, 
    0.06765259f, 0.05207741f, -0.07437670f, -0.09245303f, -0.03736421f, 0.04010563f, -0.04962756f, 0.00838850f, 
    0.02998072f, -0.11716893f, 0.08776783f, -0.02760683f, -0.04138552f, -0.01946600f, 0.01888868f, -0.01782003f, 
    0.03264333f, 0.09897495f, 0.03603819f, 0.08347294f, 0.11535446f, -0.14754678f, 0.12992623f, 0.24031611f, 
    -0.01859333f, -0.05058265f, -0.03933850f, 0.02751051f, 0.01527941f, 0.05565860f, 0.04011239f, 0.05535398f, 
    0.28995562f, 0.07958521f, 0.12434491f, 0.04353292f, -0.06528525f, 0.04084015f, 0.09067833f, 0.01322826f, 
    0.01886740f, 0.07606735f, -0.02646536f, -0.07369937f, 0.15854399f, 0.10482588f, -0.07576757f, 0.26082709f, 
    -0.08449774f, -0.04082173f, -0.04584900f, -0.01880013f, 0.09327494f, -0.04880612f, -0.00939537f, 0.02524670f, 
    0.23565166f, 0.10116523f, 0.16126794f, 0.16975206f, -0.09759611f, 0.04153217f, 0.06605875f, -0.01690608f, 
    -0.03649597f, 0.10280655f, 0.07629106f, 0.03995209f, -0.02968148f, 0.14250205f, -0.21156082f, 0.14891365f, 
    0.01553184f, 0.01752113f, -0.05593844f, -0.04061808f, 0.04917512f, -0.03522518f, -0.04813610f, 0.00716517f, 
    -0.23285483f, -0.11012673f, 0.04407141f, -0.00296118f, -0.04725907f, 0.07409234f, 0.09372579f, -0.01812901f, 
    -0.01693274f, 0.06031001f, -0.00362878f, 0.08095692f, -0.16608126f, 0.00078390f, -0.01276570f, -0.08023859f, 
    -0.02298337f, 0.09196448f, 0.11006813f, 0.02225673f, -0.02871769f, 0.01168245f, 0.01676592f, 0.00835748f, 
    -0.21735413f, -0.06145423f, -0.02020713f, -0.05970146f, 0.05389326f, -0.00616414f, 0.06620687f, 0.01925654f, 
    -0.03522651f, -0.01319730f, 0.04925882f, 0.00116426f, -0.15626706f, -0.07717191f, 0.16159548f, -0.00269356f, 
    0.03568146f, -0.02031508f, 0.15911387f, -0.05382726f, -0.01162953f, 0.06449888f, -0.02708524f, -0.00144234f, 
    0.15991995f, -0.14174512f, -0.07140201f, -0.13426994f, -0.05650594f, 0.03554191f, -0.03838183f, -0.07698143f, 
    0.16851003f, -0.00307243f, 0.05117472f, 0.06628723f, 0.10745876f, -0.05933312f, -0.07370564f, -0.15877362f, 
    0.09015417f, 0.11854728f, -0.00472707f, 0.04482964f, 0.13360405f, 0.02976378f, -0.05200788f, 0.04817475f, 
    0.21836472f, -0.10220841f, 0.02261745f, -0.08606877f, 0.12196553f, 0.03616934f, 0.01568183f, -0.07195955f, 
    0.04154391f, 0.04724444f, -0.11554611f, -0.05412577f, 0.24440423f, 0.12931952f, -0.07635847f, 0.15000784f, 
    -0.08807059f, -0.05627426f, 0.06616975f, 0.03741539f, 0.01773560f, 0.01314060f, -0.03577168f, 0.15420389f, 
    0.18869375f, -0.07439929f, 0.12706621f, -0.08753397f, 0.00273918f, -0.05145126f, 0.02840837f, 0.00426451f, 
    0.04519320f, 0.08501238f, 0.03208653f, -0.05166917f, 0.25646541f, 0.10094552f, -0.07553651f, 0.16287620f, 
    -0.01143431f, -0.02445220f, -0.03151423f, -0.01976149f, -0.01483244f, -0.01206962f, 0.02595102f, 0.09372777f, 
    0.12745979f, 0.06645454f, -0.09045778f, -0.19798198f, 0.14318970f, -0.00143971f, -0.05154819f, -0.01065052f, 
    0.02801453f, 0.02292354f, -0.00183071f, 0.05834213f, 0.14292569f, 0.23002373f, 0.04497479f, 0.10920915f, 
    -0.07510298f, -0.04610601f, -0.02058057f, 0.09554104f, 0.00118593f, 0.02671964f, -0.02819530f, 0.04389587f, 
    -0.07335437f, 0.09176193f, 0.00519093f, -0.04797041f, -0.05712114f, -0.01776642f, 0.08559749f, 0.01177352f, 
    -0.02646210f, -0.05218768f, -0.02752680f, -0.01316840f, 0.26940462f, 0.00321464f, 0.09218971f, 0.08401266f, 
    0.03242690f, -0.00702087f, 0.03922997f, 0.06320801f, 0.06326201f, 0.05682022f, -0.07452046f, -0.00193022f, 
    0.11869584f, -0.10221232f, -0.06037083f, -0.03703408f, 0.00468994f, 0.07062256f, 0.05402939f, -0.09653976f, 
    0.07776121f, -0.05550777f, -0.03875228f, -0.03327899f, 0.11279418f, -0.09484242f, 0.22308743f, -0.40749255f, 
    0.03525452f, 0.03708827f, 0.11476532f, -0.00143074f, -0.02419966f, 0.06451496f, 0.01417131f, 0.09036899f, 
    -0.23846196f, 0.08661286f, -0.04951415f, 0.06190717f, 0.00433213f, 0.07820240f, 0.02021917f, -0.06937952f, 
    0.13208401f, -0.03806807f, 0.06766590f, 0.06531494f, 0.16248740f, 0.03789152f, 0.11745384f, 0.01844978f, 
    0.06243645f, 0.08267814f, 0.13376279f, -0.04491730f, 0.01071818f, 0.12329923f, -0.03877905f, -0.01849606f, 
    0.18478952f, 0.15032914f, -0.04148750f, 0.00106434f, -0.00015049f, 0.07984761f, -0.09072394f, 0.02562719f, 
    -0.05958495f, 0.01190096f, 0.04636958f, 0.04253679f, 0.15310793f, 0.04464042f, 0.00900330f, 0.03088227f, 
    -0.02105860f, -0.08028162f, 0.07581031f, 0.03352245f, -0.00030279f, 0.12516546f, -0.05147733f, 0.04021488f, 
    -0.22354475f, -0.00011914f, 0.11018963f, -0.15779120f, 0.03110194f, 0.02654134f, 0.14823729f, 0.01617038f, 
    -0.06663782f, 0.04679001f, 0.06369013f, -0.00782553f, 0.01528764f, 0.02641168f, 0.16516291f, -0.04326791f, 
    0.01754594f, -0.05582875f, 0.02572400f, 0.12183457f, -0.04025693f, -0.14569603f, 0.06021839f, -0.02835699f, 
    -0.26972786f, 0.06605401f, -0.21419454f, 0.18106081f, 0.01508852f, 0.06331404f, -0.02293453f, 0.02645196f, 
    0.02507573f, 0.02093712f, 0.05580284f, -0.04698019f, 0.13080083f, -0.07279821f, 0.19798191f, -0.21702239f, 
    0.09202925f, -0.10072261f, 0.12268738f, -0.09312298f, -0.06171697f, 0.01947433f, 0.08406662f, -0.03284811f, 
    0.19900180f, 0.05278620f, 0.03918523f, 0.38148350f, -0.12897673f, 0.02796907f, 0.01412455f, -0.01053776f, 
    0.03042505f, 0.05970955f, 0.07195233f, -0.05881196f, 0.36962911f, 0.12016159f, 0.01287098f, -0.06875068f, 
    0.02525088f, -0.08676748f, 0.05031309f, 0.03357427f, -0.06225351f, 0.05096471f, 0.01177699f, 0.02652185f, 
    -0.13496266f, 0.24854898f, 0.07401668f, -0.11654005f, 0.14552812f, 0.22488987f, 0.00641812f, -0.00749411f, 
    0.08410595f, 0.13918065f, -0.04820678f, -0.03848081f, 0.11861937f, 0.04990448f, 0.06377709f, 0.05905641f, 
    -0.13132639f, -0.07700254f, 0.10300650f, 0.07302228f, -0.04861901f, -0.09496330f, -0.00889957f, -0.17639995f, 
    -0.00509991f, 0.01135916f, -0.03575973f, -0.15670899f, 0.03101601f, 0.06160261f, -0.02516130f, -0.03992351f, 
    -0.05140214f, -0.01661487f, -0.06947736f, 0.00765608f, 0.11318234f, 0.22873558f, -0.02117371f, -0.17068307f, 
    -0.03456875f, 0.09132002f, 0.03032210f, 0.03454355f, 0.11509449f, 0.00598018f, 0.05973995f, 0.08179035f, 
    -0.09036082f, 0.03700396f, 0.06741937f, -0.07799857f, 0.02004147f, 0.06468628f, 0.04158898f, 0.07937905f, 
    -0.01749296f, 0.04309291f, 0.07482401f, 0.09840305f, -0.01010705f, -0.08893313f, -0.03607468f, -0.05784857f, 
    0.02559528f, 0.09867167f, -0.07569877f, 0.05523726f, 0.02275436f, 0.00824257f, -0.03667694f, 0.02472774f, 
    0.23738600f, -0.02850655f, 0.13557047f, 0.12886728f, -0.05556153f, -0.02370067f, 0.06003392f, 0.08238558f, 
    0.01180708f, 0.07874344f, 0.00048316f, 0.05482627f, -0.02881650f, -0.00467090f, 0.06586793f, 0.09948800f, 
    -0.05007764f, 0.00212995f, 0.03628618f, 0.05981336f, 0.01784756f, 0.00977811f, 0.03491839f, 0.01886385f, 
    0.00359747f, -0.03716046f, -0.02820153f, -0.02444155f, -0.03492508f, -0.02968006f, -0.00270879f, 0.01581259f, 
    -0.02422380f, -0.02686433f, -0.01771183f, 0.02000147f, -0.00700007f, -0.02161850f, 0.01285323f, -0.03173264f, 
    0.02804659f, -0.03683677f, -0.02245718f, 0.02270196f, 0.02104052f, 0.01345693f, 0.01927987f, -0.03897738f, 
    -0.02710828f, -0.00772063f, 0.00836176f, -0.01406616f, -0.01632504f, 0.00823461f, 0.00587395f, 0.00385561f, 
    0.00077345f, -0.03277267f, -0.01199139f, 0.00352123f, -0.01143908f, 0.02411296f, -0.00946995f, 0.00307126f, 
    -0.01688432f, -0.04281387f, -0.03051442f, 0.02118426f, 0.01417614f, -0.03008830f, 0.01213043f, -0.01912719f, 
    -0.02814875f, -0.02064595f, 0.02496248f, -0.02603617f, -0.00352506f, -0.01560883f, 0.00927409f, -0.02418397f, 
    -0.04147524f, 0.00792558f, -0.00698011f, -0.03440319f, 0.01267513f, 0.01396701f, 0.00406090f, 0.00984927f, 
    0.01898258f, -0.03310361f, -0.03034835f, 0.01672523f, -0.01436848f, -0.01633733f, 0.01749241f, 0.01897473f, 
    -0.01892570f, 0.01225685f, 0.01934089f, 0.01920756f, 0.01012215f, 0.01570107f, -0.00586586f, 0.02039330f, 
    0.01495707f, 0.00253029f, 0.01881090f, -0.00272053f, -0.02469189f, 0.02358267f, 0.02491291f, -0.02054006f, 
    -0.03244538f, -0.01466106f, 0.02310330f, -0.00336895f, 0.02166544f, -0.00275563f, -0.01589187f, 0.00772739f, 
    0.00037665f, -0.01445437f, -0.03303287f, -0.02827819f, 0.00275413f, -0.02393250f, -0.01320009f, -0.00105394f, 
    -0.00623772f, 0.01125167f, -0.01476504f, 0.01662443f, 0.00077197f, 0.00717755f, 0.00515454f, 0.01732018f, 
    -0.03329185f, 0.02920149f, 0.01271390f, 0.02499970f, 0.01706381f, -0.02690118f, -0.01471674f, 0.00602228f, 
    -0.01719436f, -0.02003513f, 0.00181940f, 0.01302041f, -0.03010139f, -0.01667044f, -0.03046492f, -0.03359343f, 
    -0.00104121f, -0.03641376f, 0.00662901f, -0.03601727f, 0.02414152f, -0.00404925f, -0.01443870f, 0.01205970f, 
    -0.01342656f, -0.00351284f, 0.01515754f, -0.01681953f, -0.01180354f, -0.00422731f, -0.01578535f, 0.02545761f, 
    0.00837926f, 0.00394380f, -0.01338478f, -0.01541649f, 0.02757872f, 0.02282403f, -0.01550569f, -0.01626178f, 
    -0.04444422f, -0.01050089f, -0.00638870f, 0.03103614f, 0.00113929f, -0.03221295f, -0.01334916f, 0.00216463f, 
    0.00111149f, -0.00961811f, -0.02638236f, -0.02747014f, 0.02743318f, -0.03274178f, 0.01050214f, -0.02605320f, 
    -0.03575253f, -0.04215642f, 0.00507297f, -0.00961325f, -0.02114625f, 0.01774009f, -0.00173810f, -0.02502108f, 
    0.00041319f, -0.03882271f, -0.04090473f, -0.00089828f, 0.02528671f, -0.03144780f, 0.01042895f, -0.02593100f, 
    -0.01303648f, -0.03848286f, -0.02881397f, -0.04112412f, -0.00526117f, 0.00972223f, -0.03861005f, -0.03890319f, 
    0.00836782f, 0.00931338f, -0.00416216f, -0.01326560f, 0.02339528f, 0.02570517f, -0.00979601f, -0.02533583f, 
    -0.03502238f, -0.03254417f, 0.01165725f, 0.00271294f, -0.01876495f, 0.00427265f, 0.01929369f, 0.01071237f, 
    -0.00029358f, 0.02634250f, 0.02206950f, 0.02810453f, 0.00087724f, 0.02403434f, 0.00876795f, -0.02739526f, 
    -0.00529710f, 0.00847984f, -0.02254129f, -0.03940750f, 0.02261951f, -0.02900062f, -0.02629361f, 0.02867444f, 
    -0.00411013f, -0.00845277f, 0.01850003f, 0.01741856f, -0.02447234f, -0.02292859f, 0.00511149f, 0.01318319f, 
    -0.03471911f, -0.02988118f, 0.00044467f, 0.02172476f, 0.01178288f, -0.00897609f, 0.00766169f, 0.00553660f, 
    0.01782807f, -0.02108482f, 0.00687305f, 0.00940221f, -0.02169672f, -0.00762054f, 0.02077179f, -0.03509657f, 
    0.01511128f, -0.00246908f, 0.00845361f, 0.00764203f, 0.02575883f, 0.01166922f, 0.00530560f, -0.01796995f, 
    0.01193355f, 0.02958994f, -0.01703124f, 0.02302050f, -0.00744015f, 0.02289050f, 0.00252832f, -0.02118613f, 
    0.02302179f, -0.00764945f, -0.04208391f, 0.01778741f, -0.03408145f, 0.01926991f, -0.03017907f, -0.03792079f, 
    -0.02233426f, 0.02034274f, 0.00405786f, 0.00922365f, -0.00823315f, 0.01304126f, -0.02992371f, -0.02829789f, 
    0.03192251f, -0.00671827f, 0.02610895f, -0.00631660f, -0.00444883f, 0.01763296f, 0.00282505f, -0.02627868f, 
    0.02649225f, 0.01854783f, 0.00653118f, 0.03097736f, -0.04211090f, -0.02691166f, 0.01979953f, -0.02809465f, 
    -0.02479807f, -0.01560205f, -0.04229191f, 0.01487684f, 0.01846144f, -0.02996042f, -0.01985359f, -0.02641176f, 
    -0.01036177f, -0.00630652f, 0.00232572f, -0.01554468f, 0.00570107f, -0.00723278f, -0.00180289f, -0.01023585f, 
    0.01877975f, 0.02894842f, -0.03341816f, 0.02502553f, -0.03136216f, -0.02807273f, 0.01810491f, -0.00743920f, 
    0.00393044f, -0.03527310f, -0.00407064f, 0.00889734f, 0.02515444f, -0.03741244f, -0.00251661f, -0.03182886f, 
    0.00051901f, 0.01160942f, 0.02302645f, -0.02146449f, -0.02360865f, 0.01720496f, -0.02260821f, -0.00851710f, 
    0.00563085f, 0.01942628f, -0.00126268f, 0.02792575f, -0.00966007f, -0.03105559f, 0.00735811f, -0.02169665f, 
    -0.02139799f, 0.00464992f, -0.02099567f, 0.02587686f, -0.04062010f, -0.03666740f, 0.02725276f, -0.01766347f, 
    -0.03019486f, 0.00737458f, -0.02085424f, 0.02403270f, -0.02814271f, -0.03928598f, 0.01451143f, -0.02293837f, 
    -0.02870395f, 0.00080738f, -0.01593518f, 0.00210856f, -0.00120787f, 0.00082264f, -0.04098091f, -0.02717461f, 
    0.01859381f, -0.04100743f, -0.01942262f, -0.00434922f, -0.03290571f, 0.02526319f, -0.03751202f, -0.01786873f, 
    -0.03213318f, 0.02069745f, 0.00756745f, -0.02262722f, -0.02703873f, 0.00657880f, -0.03886171f, 0.00104027f, 
    -0.01264255f, 0.02205805f, -0.00231759f, -0.03622375f, 0.00042513f, 0.00269506f, -0.01186472f, 0.02742027f, 
    -0.02255162f, 0.00215271f, 0.00721081f, -0.02095006f, 0.02145237f, 0.02960815f, -0.04090457f, 0.02416277f, 
    -0.04081867f, 0.02621180f, 0.00728087f, -0.03071980f, -0.03076850f, 0.00357920f, -0.04145968f, -0.04411536f, 
    0.00945867f, 0.01693752f, -0.00109738f, -0.03976286f, 0.00384553f, 0.01793772f, 0.00640056f, 0.03464563f, 
    -0.02862270f, -0.00516265f, -0.02235697f, -0.02965648f, 0.02577624f, 0.02804911f, -0.00186362f, -0.04019735f, 
    -0.00388763f, -0.00425551f, 0.00049182f, 0.02148222f, 0.01896455f, 0.02772091f, 0.01942075f, -0.01302917f, 
    -0.02972277f, 0.01499353f, -0.04032865f, -0.03721825f, -0.02216256f, 0.02110854f, -0.02714315f, -0.00745048f, 
    -0.02574589f, -0.01053941f, -0.03143965f, 0.01951849f, 0.02609276f, 0.02982643f, -0.04101178f, -0.04301244f, 
    0.00730426f, -0.03504644f, 0.03094930f, -0.00269340f, 0.00425094f, 0.01712114f, -0.00469283f, -0.01244516f, 
    -0.02059546f, 0.03101410f, -0.00880314f, -0.00545614f, 0.02216292f, -0.02783715f, -0.03622301f, 0.01140205f, 
    -0.02875048f, -0.02965453f, -0.00822650f, 0.00889698f, 0.01529300f, -0.03879694f, 0.00711603f, -0.03585739f, 
    0.01989553f, -0.01350299f, 0.00489050f, -0.01837119f, 0.00623147f, 0.01861776f, 0.00590726f, -0.03210606f, 
    0.00341177f, 0.01472121f, 0.01087736f, 0.02703385f, -0.00078929f, 0.02381781f, -0.00108344f, 0.00169606f, 
    -0.00854343f, -0.00248405f, -0.00415460f, 0.00096431f, 0.02676528f, -0.03919035f, 0.02322535f, -0.02156204f, 
    0.01348263f, -0.02371863f, 0.02510647f, -0.00514066f, -0.00579780f, 0.02280822f, 0.02634122f, 0.00839710f, 
    -0.02439768f, 0.01173949f, -0.02536917f, -0.00278044f, -0.03299483f, -0.04083697f, -0.00690931f, -0.00955160f, 
    -0.00588996f, 0.00121614f, -0.01503381f, -0.00957668f, 0.03615735f, 0.01018580f, 0.03195364f, -0.04444461f, 
    -0.00590517f, 0.02009140f, -0.03584827f, 0.00083147f, -0.00519705f, -0.00881804f, 0.00733320f, 0.01829953f, 
    -0.02630608f, 0.02339144f, 0.01344554f, 0.01676280f, -0.02750258f, 0.02149023f, 0.01481912f, 0.00263752f, 
    0.01573030f, -0.03698379f, -0.00104797f, 0.03531291f, 0.00624284f, -0.03979361f, 0.00199061f, -0.00214060f, 
    -0.03736747f, -0.02397109f, 0.01347452f, -0.03030455f, -0.01226090f, 0.02654298f, 0.01328515f, -0.01047575f, 
    -0.02782739f, -0.03256482f, -0.00954692f, 0.00156036f, 0.00095903f, -0.00446593f, -0.02296926f, 0.00203776f, 
    -0.03649041f, -0.02742272f, 0.01606843f, -0.00387200f, -0.03924923f, -0.03653099f, -0.00010509f, -0.00772996f, 
    -0.03085124f, -0.00035288f, -0.00787316f, -0.01823959f, -0.04031456f, 0.00759564f, 0.01572038f, -0.03985632f, 
    -0.02877482f, -0.00628697f, -0.03586498f, -0.00840808f, -0.00406636f, -0.01206637f, 0.02244413f, 0.02942574f, 
    0.01176472f, 0.00152853f, -0.00609190f, 0.00963549f, -0.00306592f, -0.01687462f, 0.04104868f, 0.02083542f, 
    -0.02999055f, 0.00476267f, 0.00744510f, -0.00289566f, -0.02718726f, -0.00701036f, -0.01532294f, 0.00576846f, 
    0.01349607f, -0.01173092f, -0.03026101f, -0.02608839f, 0.02294066f, 0.01617177f, 0.00897689f, -0.00833173f, 
    -0.03111522f, 0.01559749f, 0.01770065f, -0.00485319f, 0.00046544f, -0.03110124f, 0.00323824f, -0.01004231f, 
    -0.01346718f, 0.01981571f, -0.04105886f, 0.01922405f, -0.00061393f, -0.03067358f, 0.02038293f, -0.00795646f, 
    0.00522453f, 0.02095615f, -0.02956193f, 0.01705360f, -0.03626730f, -0.00729215f, -0.03205663f, -0.01261056f, 
    0.03145122f, -0.03935701f, -0.00450441f, 0.00907676f, -0.04272966f, -0.02242874f, -0.01341675f, 0.01230749f, 
    -0.03983192f, 0.02539004f, 0.01472582f, 0.01183284f, 0.00896749f, -0.03301185f, -0.01202345f, 0.02330187f, 
    -0.02416551f, 0.03458980f, -0.02050892f, -0.01881500f, -0.04107731f, -0.04051647f, -0.00912347f, -0.00319677f, 
    -0.01178977f, 0.00685357f, -0.02440255f, 0.03029117f, -0.00885700f, -0.00571484f, 0.02824038f, 0.02575802f, 
    -0.00382292f, 0.01713454f, -0.02781490f, 0.02158199f, 0.01109643f, -0.03023867f, 0.01542317f, -0.02893700f, 
    -0.00841769f, 0.00609026f, 0.02417697f, 0.01746159f, -0.02249787f, -0.03720149f, -0.00022832f, 0.01808093f, 
    -0.00032260f, 0.01817727f, 0.00399891f, 0.01295684f, -0.04343964f, 0.02785211f, -0.02122463f, -0.00965196f, 
    0.02540196f, -0.00873139f, -0.02319229f, 0.00138607f, -0.02863401f, -0.00346973f, 0.02671475f, 0.00160732f, 
    -0.00414321f, -0.02480815f, 0.00856445f, -0.01607885f, -0.00084672f, -0.02552424f, -0.02152355f, 0.00195412f, 
    -0.04119922f, -0.02163465f, -0.02809360f, 0.02446540f, 0.02051520f, -0.02082559f, -0.03199722f, 0.00612199f, 
    -0.00254082f, -0.01783270f, -0.00855077f, -0.03416463f, -0.01518242f, 0.01950068f, -0.01647297f, -0.01673213f, 
    -0.02551740f, 0.00533257f, -0.00528928f, -0.01596722f, 0.01286507f, 0.01615539f, -0.02213797f, -0.03302206f, 
    0.01203464f, -0.00672413f, 0.02393946f, -0.01897067f, 0.00561041f, -0.00619441f, 0.02434053f, -0.01433388f, 
    -0.03895799f, -0.03908204f, 0.01506045f, 0.01562978f, 0.00246918f, -0.03667584f, 0.00868494f, 0.00205311f, 
    -0.02867062f, -0.02079401f, -0.04015641f, 0.01654927f, -0.03233408f, -0.03262144f, -0.02326069f, 0.01548001f, 
    0.00623873f, 0.01790320f, -0.02480995f, -0.01419693f, 0.02190481f, -0.02630685f, 0.00942125f, -0.03193022f, 
    -0.03813912f, -0.00755534f, -0.01992962f, -0.00226861f, 0.02116518f, -0.02064361f, -0.01413581f, -0.02561978f, 
    0.00785908f, -0.02741778f, 0.01659105f, 0.00196426f, -0.04198176f, -0.03037768f, -0.02116655f, -0.03175494f, 
    -0.02520564f, 0.01076621f, -0.03107103f, 0.00185225f, 0.02197907f, -0.04090325f, -0.02551453f, 0.00810564f, 
    0.01650305f, -0.02266586f, -0.02336975f, -0.03934388f, 0.02470759f, -0.00016991f, 0.02731408f, -0.00959741f, 
    -0.01992246f, 0.03373613f, 0.00306856f, -0.02107535f, -0.03085965f, -0.01687514f, -0.00957957f, -0.02823579f, 
    0.01490917f, -0.01310501f, -0.03088814f, -0.00889879f, -0.01000451f, -0.02865419f, -0.01102528f, 0.00697290f, 
    -0.04119666f, 0.00006879f, -0.03083749f, 0.01265607f, -0.03062429f, -0.02239076f, -0.03673312f, 0.01827342f, 
    -0.04190568f, -0.02921341f, 0.02233018f, 0.00961142f, -0.03807687f, 0.01298347f, 0.01552836f, -0.02466659f, 
    -0.03357998f, -0.01649923f, -0.01998862f, -0.00046089f, 0.03376662f, -0.00610727f, 0.02814465f, 0.00911387f, 
    0.00464018f, 0.01342260f, 0.00624907f, -0.01843687f, -0.02723160f, -0.00724670f, -0.01169368f, -0.00642206f, 
    -0.00879791f, -0.03081873f, 0.02234631f, -0.00467413f, -0.02057432f, -0.03760003f, 0.01849869f, -0.00462180f, 
    0.02286677f, -0.04143490f, 0.01045820f, -0.02700342f, 0.00859850f, 0.02486004f, 0.01033885f, -0.00702176f, 
    0.00362369f, -0.01234051f, -0.03075912f, 0.00011807f, -0.02378503f, -0.02586096f, -0.03135948f, 0.02934812f, 
    0.00996657f, 0.02632185f, 0.02171779f, -0.01379848f, -0.00481897f, -0.01165712f, -0.02837869f, -0.02947168f, 
    0.02444737f, 0.01571757f, -0.01014007f, -0.00704428f, 0.02570217f, 0.02680728f, 0.00077375f, 0.00042101f, 
    0.01138140f, -0.03979927f, -0.01893122f, -0.02020402f, -0.02133702f, 0.01599803f, -0.04264063f, 0.01499692f, 
    -0.00672437f, 0.02269490f, 0.00369825f, -0.00657120f, 0.02806264f, -0.03585287f, -0.00330515f, -0.00272740f, 
    0.01632605f, -0.03975807f, -0.03749956f, 0.01875805f, 0.01981434f, -0.03151744f, 0.02312057f, 0.00656444f, 
    0.02698503f, -0.03014394f, -0.01298765f, -0.01430286f, -0.01154182f, 0.02791954f, -0.02106010f, 0.00032455f, 
    -0.01835721f, 0.02105309f, -0.01338266f, 0.02250458f, 0.00088431f, 0.00251256f, 0.00193471f, 0.01946903f, 
    -0.01222992f, 0.02500162f, -0.04291622f, -0.00775363f, -0.00869397f, -0.01721339f, -0.04098233f, 0.00688886f, 
    0.01912960f, 0.00624384f, 0.02617396f, -0.01398685f, -0.00209179f, -0.03324780f, -0.02010060f, 0.01710723f, 
    0.01047709f, -0.02044699f, 0.00619321f, -0.03181291f, -0.04116920f, -0.02768656f, 0.00160926f, 0.00445472f, 
    -0.02867557f, -0.04226104f, 0.02670251f, -0.03667158f, 0.02518897f, -0.03241955f, -0.02432607f, 0.02569519f, 
    0.02435887f, 0.01683884f, 0.02062279f, -0.01267437f, -0.00074038f, -0.03955794f, -0.03569779f, -0.01342012f, 
    -0.03357179f, 0.00410364f, 0.00899899f, 0.01087818f, -0.01121307f, -0.00702025f, 0.01959922f, -0.00987650f, 
    0.00983735f, -0.02312242f, -0.01986816f, -0.03342925f, -0.02114206f, -0.00421584f, 0.02180695f, -0.00291271f, 
    0.01086419f, 0.00633121f, -0.02727401f, 0.01465841f, -0.03572519f, -0.02141128f, 0.01702784f, -0.02701617f, 
    -0.01633356f, -0.01635846f, 0.01056814f, 0.00779815f, 0.02379432f, -0.02166343f, 0.01683883f, -0.00525372f, 
    0.00297506f, 0.02427009f, 0.02227787f, -0.04009983f, -0.00045936f, -0.01203389f, 0.01053610f, 0.00006474f, 
    -0.01574277f, -0.00954864f, -0.01251912f, -0.02310167f, -0.00360519f, -0.00055319f, -0.00690700f, -0.00564046f, 
    0.01832129f, -0.01456333f, -0.00083366f, 0.01338629f, -0.00467996f, -0.00937876f, -0.03067031f, -0.02883320f, 
    -0.01339620f, -0.00920288f, -0.03516150f, -0.00379016f, -0.00105983f, -0.01452824f, 0.00786102f, -0.03601727f, 
    -0.03376063f, 0.01622434f, 0.01099224f, -0.03749336f, -0.01808926f, -0.04022168f, 0.00784764f, -0.01582760f, 
    0.02288019f, -0.04076430f, 0.00698343f, 0.02184516f, 0.02459990f, -0.02021469f, -0.02822015f, -0.01499841f, 
    0.01111533f, -0.02885050f, 0.00356369f, -0.04012640f, -0.02194710f, 0.00009184f, 0.02645950f, 0.02223674f, 
    -0.01720101f, -0.01999866f, -0.02796338f, -0.02710473f, -0.01728577f, -0.02980707f, 0.02276050f, -0.01745416f, 
    -0.02494221f, 0.00850435f, 0.02351803f, 0.01874575f, -0.00341341f, -0.01194898f, -0.01851727f, -0.04200413f, 
    -0.01010818f, -0.04062583f, -0.01853944f, -0.02460036f, 0.01605238f, -0.00151771f, 0.00341244f, 0.01037060f, 
    -0.01841332f, 0.02715343f, -0.01223732f, 0.02042300f, -0.02566513f, -0.02137648f, 0.02515007f, -0.00336830f, 
    0.02582765f, 0.01934763f, -0.00773674f, -0.03170601f, -0.01167367f, -0.01690281f, -0.00169002f, -0.00275550f, 
    -0.00875172f, -0.01862183f, 0.02448864f, -0.04013363f, 0.01559664f, -0.01330424f, 0.02557716f, -0.00952139f, 
    -0.04309456f, -0.02730355f, 0.00236698f, -0.00609117f, -0.02607848f, 0.03937145f, -0.03643302f, -0.00978614f, 
    0.00346293f, 0.01255311f, 0.01489470f, -0.02051410f, 0.01206755f, -0.04149148f, -0.01448976f, 0.02354527f, 
    0.02668226f, 0.01248971f, 0.01714435f, -0.00820672f, 0.00007145f, -0.03248112f, -0.01446524f, 0.00636075f, 
    -0.03825356f, 0.02759159f, -0.01826005f, -0.03411956f, -0.00890211f, -0.04408207f, -0.02245945f, 0.02206739f, 
    0.01832523f, -0.02382190f, 0.00106118f, -0.01697561f, -0.02918973f, 0.02306607f, 0.00528980f, -0.00989939f, 
    -0.01950659f, 0.01370693f, 0.00079091f, 0.02834922f, -0.00976356f, 0.00016352f, -0.02813847f, -0.02172524f, 
    0.01413075f, -0.03075706f, 0.02468688f, 0.00647820f, -0.03699814f, 0.00067341f, 0.01548803f, 0.01918838f, 
    0.01657948f, -0.02524293f, -0.00224941f, 0.01211246f, 0.00901713f, -0.01599833f, -0.01256814f, 0.01501019f, 
    0.01600095f, -0.02955940f, -0.02403516f, -0.03189753f, -0.01661774f, -0.03512235f, -0.01794802f, -0.03711457f, 
    -0.00000754f, -0.00213393f, -0.01456298f, 0.00527076f, -0.02123323f, -0.01459601f, 0.01558704f, 0.02291320f, 
    0.00585686f, -0.00262686f, -0.01056996f, 0.00766435f, 0.02121692f, -0.02212879f, 0.00212680f, -0.02755741f, 
    -0.03629094f, -0.01594387f, 0.00052404f, -0.02271287f, -0.01074331f, -0.04106367f, -0.02345936f, 0.01347652f, 
    0.02343190f, -0.02001646f, -0.00439260f, -0.04381888f, -0.03035939f, 0.01531359f, -0.02812410f, -0.01945750f, 
    -0.02720231f, 0.02511280f, 0.01980468f, -0.01797687f, 0.01555566f, -0.00111920f, 0.02292665f, 0.02822292f, 
    -0.03849196f, -0.02198685f, 0.01867477f, -0.04014708f, -0.01398581f, 0.01945415f, -0.02233354f, -0.04218716f, 
    -0.00027123f, 0.01416536f, -0.02589272f, 0.00946101f, -0.00897010f, -0.03582399f, 0.02672714f, -0.04155140f, 
    -0.03855056f, 0.00731460f, 0.01673923f, -0.03192748f, -0.04064727f, 0.02702491f, 0.00966216f, -0.03225389f, 
    0.02638130f, -0.03563167f, 0.01125396f, 0.01241304f, 0.00908421f, -0.03494918f, 0.01768542f, -0.03066676f, 
    -0.00775462f, -0.00740894f, -0.01415906f, 0.02622338f, -0.02459398f, -0.03599792f, -0.01259889f, 0.01277482f, 
    0.00435434f, 0.01401853f, 0.00087090f, 0.00944122f, -0.00500079f, -0.02421600f, -0.02013908f, 0.01212882f, 
    -0.01600401f, 0.02580948f, 0.00357658f, -0.03585290f, 0.01947282f, 0.01850213f, 0.01985432f, -0.00559228f, 
    -0.00913985f, -0.01978081f, 0.00513609f, 0.01584002f, 0.00471198f, 0.00726558f, 0.01546573f, -0.01977035f, 
    -0.03380018f, -0.02672920f, -0.04350624f, -0.02949497f, -0.01778904f, -0.04123203f, -0.02204066f, 0.00099862f, 
    -0.00771351f, -0.04054250f, -0.04312287f, 0.01115669f, -0.01894317f, 0.00571511f, -0.03999305f, -0.04049051f, 
    0.02401707f, -0.02068781f, -0.01887257f, 0.01564864f, -0.02996133f, 0.00387223f, 0.01131209f, -0.04142328f, 
    -0.02189742f, -0.04197583f, 0.02525348f, 0.02758292f, 0.01856691f, 0.01979941f, -0.02627183f, -0.01017167f, 
    0.02956466f, 0.00347779f, -0.04339658f, -0.01710355f, -0.00071748f, -0.03072950f, -0.02338938f, -0.00012695f, 
    -0.03932521f, -0.03944250f, -0.02819863f, -0.02240411f, -0.04012384f, -0.04290733f, -0.04346126f, -0.03795243f, 
    0.02376552f, -0.02222901f, 0.01985720f, 0.00197650f, 0.01384539f, 0.00810051f, -0.00027309f, 0.00139874f, 
    -0.04048290f, -0.03410772f, 0.01133153f, 0.02268897f, -0.03917315f, -0.00822992f, 0.02534692f, -0.03671319f, 
    -0.02374425f, -0.02628850f, -0.01214146f, 0.02394675f, 0.01108779f, -0.01783998f, 0.00607174f, 0.02388440f, 
    -0.02345003f, 0.00759393f, 0.01556809f, 0.02433754f, -0.03058692f, -0.01205137f, 0.02813346f, -0.01432248f, 
    -0.03086995f, -0.02313630f, 0.00888553f, -0.00900889f, -0.03946640f, -0.02139980f, -0.03003925f, 0.01093279f, 
    0.02099914f, 0.00821630f, -0.01743984f, -0.01719725f, 0.00387372f, 0.01877906f, 0.00539361f, 0.03493705f, 
    0.02636859f, 0.02663588f, -0.00987752f, -0.01851562f, 0.01093029f, -0.03779894f, 0.02415036f, -0.04337290f, 
    -0.00211068f, 0.00839215f, -0.01453511f, -0.00799055f, -0.00194579f, -0.00434318f, -0.01034054f, -0.00908709f, 
    -0.01406095f, -0.00810303f, -0.01311783f, 0.00649328f, -0.01467365f, -0.00821646f, 0.01802098f, 0.01895492f, 
    0.01705311f, 0.01581758f, 0.01836978f, -0.02493329f, -0.02837892f, -0.01899673f, -0.03609577f, -0.04014941f, 
    0.02502989f, -0.04051629f, -0.03537213f, 0.01426285f, -0.03729158f, 0.02306156f, 0.00688677f, 0.01186688f, 
    -0.03178901f, -0.03473882f, -0.01015554f, -0.04388581f, -0.00128065f, -0.04134145f, -0.03115368f, -0.01226845f, 
    -0.01892885f, 0.03332045f, -0.02628986f, -0.02437782f, 0.00035145f, -0.00725800f, 0.02724377f, 0.03487523f, 
    -0.02326280f, -0.03596809f, -0.00265134f, 0.02231570f, 0.00770038f, -0.03096878f, -0.00911928f, 0.02681744f, 
    0.00059213f, -0.01529140f, 0.01930870f, -0.03840302f, -0.03699103f, 0.00107374f, -0.02658201f, -0.01121516f, 
    0.00767544f, 0.02338094f, 0.02054228f, -0.01816994f, 0.01353910f, -0.00680307f, -0.00498467f, -0.04399758f, 
    -0.03511674f, -0.00420867f, -0.04066778f, -0.02452675f, -0.00253147f, 0.02373596f, -0.03922500f, 0.01098537f, 
    -0.03724432f, -0.02016716f, 0.01776481f, 0.01371551f, 0.01966093f, 0.01467035f, 0.02975704f, 0.01046423f, 
    0.02147685f, 0.00618775f, -0.04144629f, -0.00133299f, -0.02435287f, 0.02939102f, -0.04240046f, -0.00815986f, 
    -0.04330155f, -0.00305512f, 0.02760159f, -0.01389523f, -0.01848525f, 0.02298594f, -0.00523869f, 0.00023972f, 
    -0.03221547f, -0.02760139f, -0.00044029f, 0.01899929f, 0.02116071f, -0.04073122f, -0.02463013f, 0.01084941f, 
    -0.00001528f, -0.00724587f, 0.01275624f, 0.01970364f, -0.00596239f, -0.02192011f, -0.01615957f, -0.00268772f, 
    0.00071825f, 0.02715611f, 0.02368528f, -0.04352956f, -0.03866190f, -0.03960123f, 0.00974882f, 0.01403998f, 
    -0.03102077f, -0.01266016f, -0.00492194f, 0.01266410f, -0.01249259f, -0.02498757f, 0.01677234f, 0.01436448f, 
    -0.01352619f, -0.03712409f, -0.00231474f, -0.04320363f, 0.01051308f, -0.00224335f, -0.00585006f, -0.00825275f, 
    -0.00522517f, -0.03203971f, 0.02159653f, 0.02499282f, -0.02782597f, 0.01742517f, 0.01403533f, -0.01326707f, 
    0.00231313f, -0.00700918f, -0.02293047f, 0.00293705f, -0.02001777f, 0.01671250f, 0.02803161f, 0.02036274f, 
    -0.11074615f, -0.05560801f, -0.00167553f, 0.14287105f, 0.13458486f, -0.06231911f, 0.01733324f, 0.00784067f, 
    0.09826629f, 0.07166927f, -0.00941884f, -0.02066008f, 0.01320613f, 0.08410490f, 0.15952593f, 0.02147573f, 
    0.16729826f, -0.09085552f, -0.01073472f, 0.09530102f, 0.05808127f, 0.00340234f, -0.10354574f, 0.10921911f, 
    0.00108543f, 0.02945680f, 0.04366979f, -0.12525029f, 0.01509718f, 0.08369070f, -0.05271892f, -0.14243871f, 
    -0.05081133f, -0.02419362f, 0.04758297f, 0.07779469f, 0.07487421f, 0.10569976f, -0.07151893f, -0.12824872f, 
    -0.00677703f, 0.11114244f, -0.03624563f, 0.01599215f, -0.02038434f, 0.05819958f, -0.00495783f, 0.05947372f, 
    0.06290378f, -0.29593843f, 0.05750122f, 0.19125877f, 0.06973978f, 0.00277389f, -0.01428835f, -0.06283984f, 
    0.13780540f, 0.04266587f, 0.05890747f, -0.12491529f, -0.14463000f, -0.14727265f, 0.01455721f, 0.07936201f, 
    -0.12919636f, -0.08614294f, -0.08111550f, -0.08745363f, -0.09268012f, 0.02100595f, -0.00678420f, -0.05199746f, 
    -0.33848211f, -0.17369217f, -0.04791882f, -0.01313657f, -0.13520996f, 0.04723169f, 0.11354207f, -0.03506590f, 
    0.00744165f, 0.02678553f, 0.03516819f, -0.12580530f, -0.26586634f, -0.07113389f, -0.01134073f, -0.07701559f, 
    0.08684503f, -0.07981842f, 0.04899781f, 0.01422810f, 0.10301418f, -0.00896729f, 0.02509547f, 0.11883008f, 
    0.03537029f, 0.11896952f, -0.08180879f, -0.17305991f, 0.11073028f, 0.04315952f, -0.09398612f, 0.13895974f, 
    0.12621039f, 0.12027866f, 0.01094173f, -0.05822628f, -0.31543350f, -0.39537200f, -0.00673173f, -0.06540348f, 
    0.03131191f, 0.07494686f, 0.13143598f, 0.03800113f, -0.00978342f, 0.02781820f, 0.06695437f, 0.02166377f, 
    -0.07572316f, -0.10344612f, -0.03883393f, 0.05117015f, 0.13736971f, 0.08194865f, 0.03400485f, -0.12165550f, 
    0.13714325f, 0.02854603f, 0.07377204f, -0.01104707f, 0.04375689f, -0.03404246f, -0.07200295f, 0.19281918f, 
    0.00623772f, 0.01126723f, 0.05687293f, -0.11998114f, -0.10047318f, -0.01031776f, -0.05050243f, -0.03961364f, 
    -0.07751169f, 0.02817081f, 0.06961258f, -0.11312468f, 0.15915583f, -0.12802598f, -0.04088098f, 0.04325673f, 
    0.10166648f, -0.03969157f, 0.06588256f, 0.11553790f, 0.19846353f, 0.05985709f, 0.14008956f, 0.04531909f, 
    0.09075777f, -0.04446690f, -0.10952257f, 0.03497886f, 0.01496291f, 0.07676695f, -0.02128676f, -0.01960698f, 
    -0.14462277f, -0.11772267f, -0.00827601f, 0.07634582f, 0.05098660f, 0.20790485f, 0.22639418f, 0.14099284f, 
    0.06437240f, 0.12651503f, -0.05652762f, 0.06536137f, -0.04461446f, 0.02111321f, 0.08516450f, 0.03950159f, 
    0.11654269f, 0.00961930f, 0.02771060f, 0.07514024f, 0.05507197f, 0.00531853f, 0.04339021f, 0.03069833f, 
    -0.45055768f, -0.02860919f, -0.08757085f, -0.03234201f, 0.20268872f, 0.06773551f, 0.09718372f, -0.02477967f, 
    0.05144067f, 0.02299441f, 0.11155477f, 0.00332203f, -0.33477971f, 0.15434803f, 0.00041982f, 0.13513686f, 
    0.13867126f, -0.02560731f, 0.00242716f, 0.02155093f, 0.11069323f, 0.04338589f, -0.06860488f, -0.02027108f, 
    -0.03073389f, 0.16134898f, 0.17977150f, -0.10567279f, 0.14192970f, -0.01721567f, -0.08682530f, 0.04327026f, 
    0.12539598f, -0.04260195f, 0.08585046f, 0.07803999f, -0.00164511f, -0.11557235f, -0.04651632f, -0.28765076f, 
    0.04421447f, -0.08718680f, -0.00985501f, 0.00416058f, 0.00044099f, -0.04756793f, -0.00135366f, 0.14558126f, 
    -0.41057321f, -0.15087542f, 0.01432577f, -0.10669212f, -0.01972720f, 0.03605685f, 0.12741137f, 0.10484004f, 
    0.05035986f, -0.16091844f, 0.08982182f, 0.01857192f, 0.12346519f, 0.04675222f, -0.00878617f, 0.14577344f, 
    -0.01513131f, 0.07572434f, -0.10736962f, 0.10969577f, 0.08678494f, -0.02667448f, -0.01095075f, 0.15080503f, 
    -0.24018367f, 0.05534454f, 0.02174100f, 0.00761630f, -0.10227211f, -0.02779886f, 0.09897745f, -0.20330387f, 
    -0.07068396f, 0.08934575f, 0.02027074f, 0.12282015f, -0.00908198f, -0.13977446f, -0.08710433f, 0.22979921f, 
    0.00803527f, -0.05348003f, -0.07863707f, -0.09486515f, 0.03982922f, -0.01265648f, 0.01852792f, -0.00878388f, 
    -0.28810507f, 0.11482481f, 0.07648543f, -0.26669708f, 0.05460750f, 0.07045683f, 0.01200761f, 0.07300788f, 
    0.01863948f, 0.02054816f, 0.03380922f, 0.16675542f, -0.45287868f, 0.18581940f, 0.12193751f, -0.09069666f, 
    0.05750525f, 0.02418024f, -0.01936857f, -0.06066418f, 0.13129909f, -0.11539262f, -0.00113145f, 0.01260196f, 
    0.14589401f, 0.19417201f, 0.22686434f, 0.13960411f, 0.18704757f, 0.10234196f, -0.04200216f, 0.00973943f, 
    0.16481687f, 0.01554785f, 0.01981417f, -0.01942636f, 0.00376960f, 0.16060449f, 0.12436800f, -0.09989865f, 
    0.11233906f, -0.01656992f, 0.07424890f, 0.01329311f, 0.05377797f, -0.03415590f, 0.08809166f, 0.06197679f, 
    0.22865063f, 0.14106861f, 0.05357000f, 0.03829851f, 0.18016222f, -0.01375165f, 0.01171791f, -0.04273900f, 
    0.03580718f, -0.00018090f, 0.02256753f, 0.03188530f, 0.05319181f, 0.11628148f, -0.08702803f, -0.13386975f, 
    0.02099130f, -0.09960441f, -0.08749498f, -0.11143384f, -0.01001917f, -0.09435052f, 0.01754943f, 0.08786487f, 
    -0.06961886f, -0.24956773f, -0.11719977f, 0.25813243f, 0.00714824f, 0.10945238f, 0.01748982f, -0.15347990f, 
    -0.06464508f, 0.07427916f, 0.10671254f, 0.07947362f, -0.35693973f, -0.00517104f, -0.11754241f, -0.17992412f, 
    0.01921387f, 0.01783221f, 0.13672592f, 0.05452279f, -0.10102903f, 0.01312898f, 0.00183301f, 0.05038407f, 
    -0.12812904f, -0.00032194f, -0.08497188f, 0.16116370f, 0.02690612f, 0.04000012f, -0.04067190f, -0.04112668f, 
    0.03492061f, 0.06798349f, -0.12300147f, -0.09966160f, 0.09737212f, -0.20279638f, 0.10030735f, 0.19694129f, 
    -0.10305455f, 0.10073052f, 0.04053967f, -0.06497998f, -0.09977734f, 0.15207405f, -0.07405821f, 0.06537183f, 
    -0.18826915f, -0.23239140f, -0.04186913f, 0.22667606f, 0.04268327f, 0.06107654f, 0.08651829f, -0.10506979f, 
    0.06401185f, 0.03101135f, 0.06426485f, -0.02099226f, -0.17808732f, -0.26115665f, -0.10013318f, 0.02962377f, 
    -0.01796676f, 0.06114001f, 0.08758103f, -0.04294433f, -0.09580632f, 0.05752958f, 0.00885989f, 0.00458281f, 
    -0.20045505f, -0.10374781f, -0.10094459f, -0.04485627f, 0.14373997f, -0.02455859f, 0.06366734f, 0.00132281f, 
    -0.03990940f, -0.03280535f, -0.07107174f, 0.08634391f, 0.02870302f, 0.16981848f, 0.34853342f, -0.03862610f, 
    -0.04523965f, 0.09309856f, -0.06225737f, -0.07225717f, 0.04342365f, 0.12054186f, 0.07683147f, 0.22775951f, 
    0.00529911f, 0.03592338f, -0.18071531f, 0.11824455f, 0.07357640f, 0.02451544f, -0.05545290f, 0.02293723f, 
    0.07457287f, 0.00291582f, 0.03945381f, 0.02418263f, 0.08757208f, 0.11221819f, 0.13443097f, -0.06171697f, 
    -0.03861452f, -0.01346251f, -0.05450038f, -0.08718280f, 0.03478919f, 0.04506373f, 0.13312255f, 0.03024204f, 
    -0.36977494f, 0.00065413f, -0.28667450f, 0.15098076f, 0.03396930f, 0.02675337f, -0.06798211f, -0.05422777f, 
    -0.01527344f, -0.00010237f, 0.00381928f, -0.01339578f, -0.17004782f, 0.19427946f, 0.07666661f, -0.04902576f, 
    0.02491913f, 0.05383471f, 0.00600351f, -0.01202167f, 0.06753150f, 0.01179234f, -0.00606693f, -0.06386435f, 
    -0.15452269f, -0.08170001f, 0.11540364f, 0.20906647f, -0.04956627f, 0.04730317f, 0.04930462f, -0.05917880f, 
    -0.04192742f, -0.00220408f, -0.00992919f, 0.02025027f, -0.03096648f, 0.25165468f, 0.05794096f, -0.07073012f, 
    0.20171002f, 0.07836096f, 0.03781193f, 0.05324692f, 0.13556807f, 0.07204430f, -0.02612049f, 0.02131340f, 
    -0.22291638f, -0.20273592f, -0.09301164f, 0.05616817f, -0.02586585f, 0.03267020f, 0.07939280f, -0.03392231f, 
    0.00812653f, -0.01825581f, -0.02660992f, -0.00337943f, -0.01342907f, -0.07390828f, -0.05647521f, 0.14210054f, 
    0.02667777f, 0.09996819f, 0.05656463f, -0.03708638f, 0.05174720f, -0.03837266f, 0.01311618f, 0.01770829f, 
    -0.00688416f, 0.04354946f, -0.10295367f, -0.13557385f, 0.01545047f, 0.01253968f, -0.15855362f, 0.15567292f, 
    -0.02445468f, -0.04062671f, 0.06236899f, 0.02997838f, 0.11078907f, -0.17342168f, -0.04902634f, 0.20185082f, 
    0.01654516f, -0.03903341f, 0.08714747f, 0.12713699f, -0.03836132f, 0.10495418f, 0.03020241f, 0.10598544f, 
    0.20714508f, 0.06088539f, 0.09006616f, -0.11376009f, -0.00640626f, -0.07050177f, -0.05291463f, 0.01865021f, 
    0.02286192f, 0.00147569f, 0.11261569f, -0.05338898f, 0.09030288f, 0.14107299f, 0.19640507f, -0.00341002f, 
    0.08115527f, 0.06401201f, 0.08308494f, -0.04009154f, 0.05636845f, 0.22727263f, -0.03894908f, 0.04359629f, 
    -0.13552262f, -0.17047322f, 0.00972029f, 0.31350091f, 0.02744603f, 0.05284470f, 0.04236175f, 0.06828348f, 
    0.10472955f, 0.06673776f, -0.02448391f, 0.06191382f, 0.01305034f, 0.00988290f, 0.00996869f, 0.09925256f, 
    -0.02868300f, 0.06623167f, 0.02826851f, -0.02185126f, 0.08992470f, -0.09450953f, 0.02396079f, 0.09695089f, 
    -0.27689597f, -0.05411502f, 0.01809788f, -0.05425940f, 0.11285186f, 0.04648564f, -0.03048973f, 0.09836791f, 
    -0.09484487f, -0.02448788f, 0.00591110f, 0.02012295f, 0.05337722f, 0.01449226f, -0.05927730f, 0.15841970f, 
    0.02995562f, -0.07092077f, -0.04880230f, -0.05103258f, 0.08540002f, 0.15411577f, -0.02873660f, -0.04661110f, 
    0.18465006f, 0.05627016f, 0.16595392f, -0.23647091f, 0.08271824f, -0.11281903f, -0.09943400f, 0.14280082f, 
    -0.01404297f, -0.02943758f, 0.10006644f, -0.05421612f, 0.04004366f, 0.07922722f, 0.15268326f, 0.06448932f, 
    0.16798380f, 0.13878635f, 0.03952232f, -0.10836824f, 0.10160747f, 0.07110296f, 0.12119471f, 0.01931546f, 
    -0.12033317f, 0.01938047f, -0.04942681f, -0.18073648f, 0.05982256f, 0.04582545f, 0.08941091f, -0.01208450f, 
    -0.01643797f, 0.08801167f, -0.11878047f, 0.05453931f, -0.11780360f, 0.14396770f, 0.04461535f, 0.11266220f, 
    -0.00396901f, 0.09497229f, -0.01666210f, 0.03787780f, 0.03575842f, -0.06210545f, 0.07110826f, -0.07799697f, 
    -0.00364889f, -0.01841380f, -0.24904382f, 0.00121213f, -0.04514964f, 0.03000663f, 0.08126363f, -0.01712361f, 
    0.01455481f, 0.04105148f, 0.03958970f, 0.02607512f, 0.11107042f, 0.04017690f, 0.18562341f, 0.17356610f, 
    0.00731888f, 0.05828911f, -0.08818198f, -0.01040174f, 0.03338529f, 0.02515464f, 0.15888241f, 0.09576799f, 
    -0.07310373f, -0.00429368f, -0.00425080f, 0.01419461f, -0.17781830f, -0.05699646f, 0.11043558f, 0.04834141f, 
    -0.01870542f, 0.06560238f, 0.03781300f, 0.18147621f, -0.13299547f, 0.20883615f, 0.21500549f, -0.06767476f, 
    0.18857090f, 0.28581583f, -0.05323834f, -0.03450881f, 0.10913961f, 0.01896854f, 0.13183667f, 0.03148658f, 
    -0.15030050f, 0.29987168f, 0.08730529f, -0.21065925f, -0.01940057f, 0.00492836f, -0.00468029f, 0.06231081f, 
    0.03002435f, 0.04260614f, 0.19208181f, 0.08345676f, 0.01602731f, -0.10001465f, 0.03297742f, 0.23747045f, 
    -0.12994926f, -0.04573449f, 0.00633149f, 0.04910579f, 0.01699886f, -0.10759176f, 0.06623513f, 0.06462354f, 
    -0.19793217f, 0.08886995f, 0.10715414f, -0.11360320f, -0.00347517f, 0.15314201f, 0.05200727f, -0.03921493f, 
    -0.03438814f, 0.06936914f, 0.02755107f, 0.09312189f, 0.24921387f, 0.14994739f, -0.05283619f, 0.06938219f, 
    0.04201652f, 0.04687604f, -0.02898740f, 0.03894234f, 0.06407185f, -0.02673456f, 0.02090813f, -0.02689082f, 
    0.04215412f, -0.20033038f, -0.17173094f, 0.18791686f, 0.09986079f, -0.02225904f, -0.00087826f, 0.24879541f, 
    -0.04124768f, 0.10606316f, -0.05559507f, 0.12754939f, 0.00800507f, -0.11725584f, 0.03122636f, 0.03430591f, 
    -0.01541497f, -0.02018504f, 0.00762314f, 0.01981657f, -0.00306162f, -0.01778765f, 0.01252400f, 0.00638784f, 
    -0.15486373f, -0.01286400f, -0.00424597f, -0.12579252f, -0.01303745f, -0.06992125f, 0.15458862f, -0.08074322f, 
    -0.02597666f, -0.02449366f, 0.00473012f, 0.15368398f, 0.05305070f, 0.09140527f, -0.00208916f, -0.33738080f, 
    0.14722925f, 0.10196392f, 0.07550904f, -0.10785358f, -0.03649115f, 0.04261563f, 0.10182136f, 0.17470533f, 
    0.00896293f, -0.01129201f, -0.02284463f, 0.02691124f, 0.12941882f, -0.12131890f, -0.07478999f, 0.01839449f, 
    0.03140534f, 0.00698686f, 0.00305953f, 0.11379652f, -0.00615569f, 0.06767040f, -0.03081536f, 0.03370913f, 
    -0.01096463f, -0.00688198f, -0.00014826f, -0.04357195f, -0.07605422f, 0.06192265f, 0.00302484f, -0.03080350f, 
    0.13830456f, 0.05492156f, -0.07869309f, 0.21239512f, 0.08886716f, 0.03008731f, -0.04187110f, 0.03967187f, 
    -0.14903581f, 0.01262645f, -0.11025642f, 0.04468881f, 0.25415406f, -0.02061909f, 0.04926246f, 0.17350127f, 
    -0.04647014f, -0.05091294f, -0.01698347f, 0.11960360f, 0.00559851f, -0.12245511f, -0.03758569f, -0.06888063f, 
    -0.12466981f, 0.04826590f, 0.02617585f, -0.14277542f, -0.01260669f, -0.02522183f, -0.05479432f, -0.01258774f, 
    0.01443813f, 0.06272767f, 0.00263784f, 0.02936985f, -0.10413317f, -0.11346122f, 0.03322050f, 0.07621084f, 
    0.07629809f, -0.03918671f, -0.12834045f, 0.20223302f, 0.07326209f, -0.00485513f, 0.16306141f, 0.06321695f, 
    -0.09625500f, -0.01667542f, 0.18472664f, -0.05483169f, 0.01785923f, 0.02776306f, 0.01735844f, 0.02009362f, 
    0.11220537f, 0.08063621f, -0.01461917f, -0.02444404f, -0.42706054f, -0.14490156f, 0.22802052f, 0.02148737f, 
    -0.05709558f, 0.11447356f, 0.13951297f, -0.08813753f, 0.01538849f, -0.03855988f, 0.00692532f, 0.04998499f, 
    0.27288154f, -0.10367504f, 0.00310060f, 0.10505398f, -0.00067946f, -0.18982536f, -0.15586914f, 0.07403013f, 
    -0.09111129f, -0.08375357f, 0.04174264f, -0.02489439f, 0.32741684f, 0.17923495f, -0.01384082f, 0.07797030f, 
    -0.04136797f, 0.01966243f, 0.01714451f, -0.01840597f, -0.04325212f, 0.09097940f, 0.11498914f, 0.03274565f, 
    0.15758331f, -0.06726057f, 0.00834371f, 0.07564892f, -0.07310545f, -0.05872678f, 0.03274648f, 0.14069931f, 
    -0.04641901f, -0.03725054f, 0.04511628f, -0.07821446f, 0.16048019f, -0.07153248f, 0.13312045f, 0.03618076f, 
    -0.06610915f, 0.06772476f, -0.01638846f, 0.00457084f, -0.04177959f, -0.08712389f, -0.03911596f, 0.10194828f, 
    0.15500183f, 0.12761720f, 0.11669707f, 0.19234486f, -0.06855679f, 0.06823968f, 0.17107345f, -0.01189084f, 
    0.02945719f, 0.06060756f, 0.12992176f, 0.03709987f, 0.11885010f, 0.05386254f, -0.08117412f, 0.23498292f, 
    0.01639990f, 0.07274386f, 0.00884554f, 0.13104557f, -0.04436347f, 0.12339675f, 0.02035614f, 0.11547152f, 
    0.59512949f, -0.23646539f, -0.11447018f, 0.20764327f, -0.06130763f, 0.04841166f, -0.06273863f, -0.03401100f, 
    0.05143014f, -0.00281751f, 0.06111002f, 0.02980092f, -0.00229745f, -0.10667549f, 0.06536688f, -0.19882497f, 
    -0.05820805f, 0.09314131f, -0.02952472f, 0.00221340f, -0.00883426f, 0.00942626f, -0.01567813f, -0.08931848f, 
    -0.03196153f, -0.07504119f, 0.06750943f, -0.15997344f, 0.15499888f, -0.02043746f, -0.02882006f, 0.09811527f, 
    0.08284982f, 0.01654085f, 0.02465253f, 0.04338472f, -0.23647614f, 0.01685360f, 0.01645824f, 0.00048952f, 
    -0.00537611f, 0.03379836f, -0.00212141f, 0.08730859f, 0.00811452f, -0.11800663f, 0.16153789f, 0.10285985f, 
    0.08680874f, -0.04440660f, -0.09437645f, 0.14745139f, -0.09478008f, -0.07530072f, -0.05200787f, -0.00866175f, 
    0.08556446f, -0.00732010f, -0.01249089f, -0.02224224f, 0.23454173f, -0.20001802f, -0.09586357f, 0.05792572f, 
    -0.04082648f, -0.03311169f, -0.02977258f, 0.02342339f, -0.08766856f, 0.09699871f, 0.02869904f, 0.15907490f, 
    -0.07692727f, 0.12138055f, 0.06609228f, 0.02250659f, 0.04254961f, -0.02717692f, 0.07179342f, 0.02173945f, 
    0.05805944f, 0.01371571f, -0.04390396f, 0.12810086f, -0.10292318f, 0.09833837f, 0.15646504f, 0.13978648f, 
    -0.00684656f, 0.03375216f, -0.05281762f, 0.01933237f, 0.04249061f, 0.07424971f, -0.02444226f, 0.05425733f, 
    -0.39121836f, 0.21629515f, 0.14182286f, -0.11823332f, 0.10618629f, 0.06917547f, -0.06221619f, 0.09634747f, 
    0.02542293f, -0.03911806f, 0.04864000f, -0.04865424f, -0.00592251f, 0.02997596f, -0.02185330f, 0.13216041f, 
    0.09813713f, -0.01110975f, 0.05070990f, 0.13381176f, 0.05478235f, 0.21402992f, -0.04319831f, 0.02910021f, 
    -0.05695179f, 0.09479587f, 0.07407431f, -0.26909816f, -0.03698340f, 0.00541968f, 0.11219186f, -0.02655771f, 
    -0.07892575f, -0.06966463f, -0.02498217f, -0.03730943f, -0.01270355f, -0.12633553f, -0.19876069f, 0.07430946f, 
    -0.03072838f, -0.08549339f, -0.03391868f, -0.02558212f, 0.02417030f, 0.06217383f, -0.04330156f, -0.00315711f, 
    -0.09818588f, 0.03217450f, 0.10390109f, -0.03591608f, -0.00221398f, -0.03677581f, 0.05163394f, 0.02299077f, 
    -0.04241199f, 0.02445389f, 0.00515114f, 0.12545732f, -0.20781784f, -0.11002979f, -0.02219137f, -0.14750107f, 
    0.00733580f, -0.05946552f, -0.01780201f, 0.04646247f, 0.03475413f, -0.09331511f, 0.08565617f, 0.07503557f, 
    0.06994959f, -0.02023597f, -0.02237772f, -0.00703250f, -0.03956437f, 0.01726269f, -0.01105146f, 0.12638532f, 
    -0.05766750f, -0.00511008f, 0.00067706f, 0.00867570f, 0.01999173f, -0.05815419f, 0.02125018f, 0.17829338f, 
    0.01193810f, -0.09254822f, -0.09348158f, 0.08218350f, 0.10148739f, 0.06813138f, -0.04407673f, 0.08120418f, 
    0.07073016f, -0.19674926f, 0.00064017f, 0.12485588f, 0.05945377f, 0.01702421f, -0.06003232f, 0.08268166f, 
    0.22436537f, 0.03182266f, 0.08480634f, -0.00194950f, -0.24862927f, -0.09823553f, 0.24741493f, 0.18975259f, 
    0.06734515f, -0.00885935f, -0.05824813f, 0.01057483f, 0.05134688f, 0.05076426f, 0.00539089f, -0.01887280f, 
    -0.01889965f, 0.29752567f, 0.16470864f, -0.25603405f, 0.13336483f, 0.06072275f, -0.03977414f, 0.00237868f, 
    -0.06522259f, -0.01432589f, 0.00983815f, 0.06340259f, 0.03024205f, 0.03284898f, -0.00535619f, 0.06364198f, 
    0.12920626f, 0.06871431f, -0.05938717f, 0.03838526f, 0.11865705f, 0.03067186f, -0.08386532f, -0.00181975f, 
    -0.03847560f, -0.08289058f, 0.10165157f, 0.12443580f, -0.02036486f, -0.02961501f, 0.09880519f, 0.25557193f, 
    0.05385158f, 0.00917055f, 0.09372526f, 0.00578320f, 0.08934700f, -0.09925620f, 0.09811370f, 0.25526023f, 
    0.02107255f, 0.06324009f, 0.11078822f, 0.05481653f, 0.00087277f, -0.04433534f, 0.03889127f, 0.13051933f, 
    -0.07244414f, 0.03521027f, -0.06182762f, -0.27025729f, 0.03629014f, 0.07278053f, 0.02557749f, 0.00443162f, 
    0.03649220f, -0.03909345f, 0.02303053f, -0.05749581f, -0.00143363f, -0.00073944f, -0.00819509f, -0.00877047f, 
    0.01521061f, -0.06473968f, -0.01989368f, -0.01887592f, 0.04859158f, 0.00484098f, 0.02545981f, -0.00917967f, 
    -0.08762188f, 0.06135104f, 0.03993432f, 0.12023851f, 0.05593494f, -0.02486541f, -0.03178388f, 0.10326363f, 
    -0.13270721f, 0.17751017f, 0.06166783f, 0.07438699f, -0.18578228f, 0.02473077f, -0.12264499f, -0.11508162f, 
    -0.07829339f, 0.00260450f, -0.03123033f, 0.20132934f, -0.06054854f, -0.00480760f, 0.01198712f, 0.02740666f, 
    0.19974788f, 0.06028628f, -0.12836757f, -0.05246181f, 0.03931101f, 0.10238803f, -0.03222161f, 0.01276059f, 
    0.03557154f, 0.02331313f, -0.08556075f, -0.01324467f, 0.18024641f, 0.03787571f, 0.02331292f, 0.02043957f, 
    -0.00163474f, -0.06849445f, -0.01107412f, 0.01803602f, 0.12086013f, -0.00455799f, 0.17045380f, 0.11614455f, 
    -0.01924258f, 0.01172161f, -0.16821022f, 0.02431869f, 0.11142545f, 0.03719857f, -0.01855765f, -0.07907224f, 
    -0.02251586f, 0.08870240f, -0.07063738f, 0.07276485f, -0.27606148f, -0.02026066f, 0.06183723f, -0.03879133f, 
    -0.10950381f, 0.03228667f, -0.01214222f, -0.00996241f, 0.14541031f, 0.07033404f, 0.15830725f, -0.02383231f, 
    -0.11024825f, -0.07333180f, 0.00151609f, -0.30024734f, 0.05780617f, 0.05646525f, 0.02134623f, -0.04060144f, 
    -0.03074867f, 0.04844447f, 0.05358414f, -0.02131041f, -0.19726053f, -0.20589934f, 0.12517764f, -0.06578366f, 
    -0.06785332f, -0.01270540f, 0.20641878f, 0.04668573f, -0.02168628f, 0.18328676f, -0.03838761f, -0.01051003f, 
    0.22469813f, -0.01144005f, -0.08103924f, -0.02870783f, -0.09283092f, 0.03353941f, 0.05333177f, -0.02640961f, 
    -0.02889558f, 0.09154287f, -0.04201417f, 0.02221454f, -0.26494426f, -0.07028002f, -0.01027562f, -0.01855383f, 
    -0.11648817f, 0.03693934f, 0.06093155f, 0.14294519f, 0.02546598f, -0.06620847f, -0.04247776f, -0.01339019f, 
    -0.11860654f, 0.00100048f, 0.04062638f, 0.19346406f, -0.03719839f, 0.18080288f, 0.06671606f, -0.00926958f, 
    0.05136443f, 0.04052214f, 0.01916126f, 0.09511025f, 0.08241773f, -0.09229977f, 0.05647765f, 0.19616145f, 
    0.00612653f, -0.01704324f, 0.08889480f, 0.03432773f, 0.07020359f, -0.01803712f, 0.05722461f, -0.04174587f, 
    0.32405430f, -0.18988633f, -0.33758894f, 0.19287512f, -0.02085426f, -0.00527700f, -0.09692702f, 0.05944195f, 
    0.04498110f, -0.03914683f, 0.02477246f, 0.12162106f, -0.02899223f, 0.07981803f, 0.13915454f, -0.09925719f, 
    0.05001397f, 0.07262523f, 0.09392701f, 0.03354362f, 0.08344138f, 0.07742485f, -0.01671068f, 0.15553334f, 
    0.21335649f, -0.18455753f, -0.11218867f, 0.10878316f, 0.05798056f, -0.00891239f, -0.05557057f, 0.08977938f, 
    -0.02123342f, -0.01974149f, -0.08240189f, 0.07668388f, -0.05980420f, 0.02895498f, -0.06125993f, -0.09096286f, 
    0.02746512f, 0.00151791f, -0.03417057f, 0.00763650f, 0.09450389f, 0.03327210f, 0.03941916f, -0.02588147f, 
    0.24710688f, 0.10095537f, -0.07305285f, -0.20316471f, 0.04949727f, 0.06541099f, -0.01920642f, -0.03029423f, 
    0.07321080f, 0.01420861f, -0.02017196f, -0.05189775f, 0.08972971f, -0.22717917f, 0.05412665f, 0.03413912f, 
    0.11039425f, -0.03208560f, 0.09832506f, 0.01702546f, -0.01329211f, 0.01263680f, -0.10723955f, -0.05159328f, 
    -0.09814584f, 0.01176530f, 0.00446623f, -0.01663975f, 0.01932374f, -0.00576948f, -0.07064722f, 0.01523961f, 
    0.12969419f, -0.02231852f, -0.08290194f, -0.08355092f, 0.08978522f, 0.07396799f, -0.16466357f, -0.22994538f, 
    0.08295427f, 0.06759524f, 0.02067827f, -0.02620194f, 0.09808522f, 0.21439761f, 0.01762875f, 0.02208319f, 
    -0.04384793f, 0.22117439f, -0.07719637f, -0.15573834f, -0.06307912f, 0.13343121f, -0.04057314f, 0.05765746f, 
    -0.06727979f, -0.01728665f, 0.12533270f, 0.01459487f, 0.20782326f, -0.16372666f, 0.07556009f, -0.03680462f, 
    0.07653426f, 0.01880249f, 0.10270104f, -0.01348121f, -0.08087606f, -0.10383339f, 0.01373465f, -0.00413088f, 
    -0.05370232f, 0.01591233f, 0.05834647f, -0.15114301f, -0.18890224f, -0.09810160f, 0.07790416f, -0.06914696f, 
    0.07697627f, 0.08817121f, -0.07979556f, 0.05121895f, -0.00522546f, -0.01210471f, 0.09364327f, -0.12480500f, 
    -0.00973022f, -0.12572718f, 0.00016780f, -0.00349420f, 0.02623268f, -0.02216935f, 0.13647291f, -0.15122449f, 
    0.14318459f, -0.02275773f, 0.00482295f, -0.01606437f, -0.02903932f, 0.05336524f, -0.05314710f, -0.11597116f, 
    -0.05987924f, 0.04460637f, 0.06152089f, -0.02263254f, -0.38978013f, 0.00017831f, -0.05598196f, -0.24431455f, 
    0.03202267f, -0.11725233f, -0.03330231f, -0.02034696f, -0.08354630f, -0.13223645f, 0.00582363f, 0.01205746f, 
    0.54363036f, -0.20286316f, 0.11195589f, -0.08019286f, -0.14481218f, 0.03355133f, -0.12757048f, 0.00835839f, 
    0.00124493f, 0.16287374f, 0.18990174f, 0.11878904f, -0.15941621f, 0.08280787f, 0.02042894f, -0.15397978f, 
    0.00134792f, 0.12237013f, 0.02833452f, 0.02433119f, -0.01619358f, -0.16512977f, -0.08379500f, -0.18137237f, 
    0.04423296f, -0.15364061f, 0.15797791f, 0.18055022f, -0.14671409f, 0.01494208f, 0.06395643f, 0.01460216f, 
    0.12422927f, -0.07839870f, -0.22452690f, -0.01397461f, -0.16495082f, -0.08725520f, 0.13299242f, 0.01149634f, 
    -0.11671985f, -0.01833281f, -0.04608195f, 0.00979138f, -0.02356126f, 0.07847298f, -0.04517080f, 0.18958022f, 
    0.11121445f, 0.05554437f, -0.04647906f, 0.05592255f, 0.09324184f, 0.07668754f, 0.12368095f, -0.00487244f, 
    0.01347069f, 0.04369875f, 0.09117346f, 0.08400124f, -0.10702964f, 0.03899985f, -0.04721215f, -0.23501924f, 
    -0.13893010f, -0.00086442f, -0.01046107f, -0.12208776f, -0.17932770f, -0.04071796f, -0.00726297f, -0.00903862f, 
    0.47993451f, 0.08657826f, 0.09069083f, 0.06674097f, -0.04886990f, -0.06259406f, 0.08097754f, 0.06974617f, 
    -0.00680228f, 0.05465058f, 0.01429533f, 0.12298340f, 0.30441397f, 0.13314292f, -0.07687143f, -0.05259725f, 
    0.07450353f, 0.01721354f, -0.04197172f, 0.00112247f, 0.04912298f, -0.01932919f, -0.00304327f, -0.00578495f, 
    0.00271511f, -0.07359833f, 0.07915313f, 0.02172540f, 0.16603065f, 0.04194387f, 0.04100799f, -0.01392307f, 
    0.15319641f, 0.03583787f, -0.04346436f, -0.14151542f, 0.07203473f, -0.05364015f, -0.02824623f, 0.08519936f, 
    -0.08109166f, -0.03010651f, 0.03811616f, -0.05734325f, 0.09735155f, 0.17210402f, 0.01759589f, 0.12111546f, 
    -0.15050484f, 0.01717255f, 0.14254175f, -0.05598677f, -0.03501286f, -0.05597575f, -0.08111785f, 0.00072496f, 
    0.10861387f, 0.05097285f, 0.10653771f, -0.07520279f, -0.10146768f, 0.05921007f, -0.00569926f, 0.08351828f, 
    0.08056064f, 0.15494452f, -0.10054467f, 0.13439818f, 0.09493724f, 0.02307384f, 0.09746441f, 0.01327582f, 
    -0.19870286f, -0.09492294f, 0.00478609f, -0.01915816f, -0.04046824f, -0.06998669f, -0.03964346f, -0.01253598f, 
    0.00398526f, 0.10222928f, 0.12098010f, 0.22254361f, 0.12115822f, -0.25139982f, 0.16514401f, -0.00841042f, 
    -0.01625037f, -0.03785541f, -0.00660602f, -0.01470190f, 0.00705812f, -0.03699720f, 0.08694981f, -0.04128792f, 
    -0.40763935f, 0.08513066f, 0.13876447f, 0.10075954f, -0.04543379f, -0.02134409f, 0.12575811f, -0.01901064f, 
    -0.01435377f, -0.11980077f, -0.02426715f, -0.02814397f, 0.11704838f, 0.11974438f, 0.03310829f, -0.07532951f, 
    0.14129624f, 0.02440547f, 0.02411836f, 0.03440422f, 0.12148082f, 0.10935558f, -0.02167673f, 0.00288016f, 
    0.06371516f, 0.40498096f, 0.00135200f, 0.04927375f, -0.01099755f, -0.02567279f, -0.04937560f, 0.08923134f, 
    0.05838486f, 0.08506451f, 0.11726730f, 0.17441402f, -0.37751985f, 0.15645754f, -0.20400316f, -0.03397216f, 
    -0.00705113f, -0.12217051f, 0.00928357f, 0.08156822f, -0.05261774f, 0.09141792f, -0.01659061f, 0.09604120f, 
    -0.00357912f, 0.15404993f, -0.03800488f, 0.07653309f, -0.03434169f, 0.13152829f, -0.02621976f, -0.01618759f, 
    0.11603972f, -0.01439139f, -0.06992925f, -0.02612975f, -0.31395733f, 0.27430451f, 0.05625855f, -0.03113945f, 
    0.01626071f, 0.09092257f, 0.10253376f, 0.07125301f, 0.03146994f, -0.10407764f, 0.14372849f, -0.09761727f, 
    0.31405708f, 0.07319958f, -0.03214423f, -0.01899514f, 0.11441674f, -0.05568139f, 0.01083836f, -0.01090221f, 
    -0.04769314f, 0.03522323f, -0.02500204f, -0.15722440f, 0.25203303f, 0.21943139f, -0.09669680f, -0.27534533f, 
    0.14188476f, -0.02984631f, -0.07499574f, 0.01500109f, 0.00500109f, 0.03925414f, -0.00589310f, 0.03654644f, 
    0.39356050f, -0.08220753f, -0.18195482f, -0.09140744f, 0.10206393f, -0.09712854f, -0.01426329f, -0.03155959f, 
    0.05937805f, 0.01171639f, -0.02054129f, -0.03181806f, 0.06406991f, -0.01467896f, 0.19242099f, -0.08433267f, 
    -0.06944208f, 0.12857929f, 0.06137569f, 0.02191022f, -0.07476153f, -0.06704881f, 0.06846762f, 0.02409814f, 
    0.03502412f, -0.07334225f, -0.13146196f, -0.05385480f, -0.01060162f, 0.04622377f, -0.16205665f, -0.04241665f, 
    0.09463582f, -0.12685110f, -0.05195231f, -0.01465021f, -0.12569252f, 0.17406811f, -0.01572646f, -0.00066939f, 
    0.09919966f, -0.10747954f, -0.09792355f, -0.01802550f, 0.01239353f, 0.13143829f, 0.25463244f, -0.12888207f, 
    0.07146582f, -0.06640081f, -0.05231398f, -0.24753733f, -0.20189913f, -0.11558285f, -0.15448864f, -0.08238223f, 
    -0.06997851f, -0.05006159f, 0.03861376f, -0.02178764f, -0.06961334f, -0.08956265f, -0.05743196f, 0.06403008f, 
    -0.00540494f, 0.02590372f, -0.21622643f, 0.02520202f, 0.14811893f, 0.04397552f, 0.08950897f, 0.04489226f, 
    0.28188732f, -0.22088684f, -0.11645248f, 0.12336547f, -0.05686664f, 0.05093330f, 0.04711610f, 0.15214847f, 
    -0.15506972f, -0.04621738f, -0.01181477f, -0.04447708f, -0.25155717f, -0.04763240f, 0.00990163f, -0.14191183f, 
    -0.26401341f, -0.02012202f, -0.02901540f, 0.16147736f, -0.24327134f, -0.04260971f, -0.02693549f, -0.02238163f, 
    -0.02297261f, -0.13058637f, 0.01687436f, 0.04675316f, -0.07852180f, 0.04850002f, -0.00901902f, 0.15980683f, 
    -0.04712628f, 0.00291228f, 0.14307846f, 0.16069642f, 0.00909230f, 0.22993128f, -0.01329665f, -0.28645933f, 
    0.03395533f, 0.16883989f, 0.01049660f, 0.04300070f, -0.00593829f, 0.03961677f, 0.02485564f, -0.15572631f, 
    0.03498609f, 0.00271180f, -0.22965977f, -0.18838350f, -0.14669985f, 0.01615979f, 0.08428190f, -0.06780939f, 
    0.04244251f, -0.00077817f, 0.03064791f, -0.02859760f, 0.07800478f, 0.06146022f, 0.03330035f, -0.07992251f, 
    0.02673025f, -0.04756221f, -0.06194674f, 0.00482118f, 0.13666861f, 0.04710184f, -0.14484791f, -0.05260171f, 
    -0.24697118f, -0.21469568f, -0.18155801f, -0.20128964f, -0.08610167f, -0.02011879f, 0.02959072f, 0.09876210f, 
    0.02431382f, -0.02343113f, 0.06068789f, 0.07168250f, -0.18224423f, 0.17611244f, -0.03921374f, 0.00079204f, 
    0.08855189f, -0.02637135f, 0.08209757f, 0.06809007f, -0.03940820f, 0.06135499f, 0.05968896f, 0.04380395f, 
    0.36934873f, 0.13287739f, -0.02218521f, 0.08610154f, 0.13447049f, 0.11152148f, -0.06438760f, 0.01464827f, 
    0.09073316f, 0.15095745f, -0.05438267f, 0.04902310f, 0.07928424f, 0.23978038f, 0.06823571f, 0.04801641f, 
    0.02392563f, -0.04126981f, 0.06397925f, 0.06548581f, 0.12745889f, 0.14908388f, 0.08001383f, -0.04737584f, 
    0.36471492f, -0.40065229f, -0.08143630f, -0.00109875f, -0.22656034f, 0.10655494f, 0.04408108f, 0.08261850f, 
    0.01691541f, 0.08256214f, 0.01974212f, 0.13557091f, -0.05185401f, 0.03012657f, -0.11757182f, 0.23720653f, 
    0.01926466f, 0.02574867f, 0.05692158f, -0.02910290f, 0.15389690f, 0.04428408f, -0.00890587f, -0.06433047f, 
    0.18661821f, -0.11590660f, -0.03928186f, -0.14719188f, 0.01881370f, -0.09780432f, 0.05000514f, -0.03307144f, 
    0.08834617f, -0.00816815f, -0.02010310f, -0.10805494f, -0.16296980f, -0.08455113f, -0.01616894f, 0.05677809f, 
    -0.04720388f, 0.01855394f, 0.09835269f, 0.04975576f, -0.05538194f, -0.13739190f, 0.06531361f, -0.03359205f, 
    -0.03219255f, 0.12946393f, 0.08131840f, -0.08695605f, 0.07993167f, 0.00099144f, -0.06175287f, 0.01206631f, 
    0.03996428f, -0.01874579f, -0.06279460f, -0.01933227f, 0.21027154f, 0.11854153f, -0.11855960f, -0.11906657f, 
    0.12900726f, 0.24224496f, -0.03274282f, -0.08765506f, -0.15341972f, 0.06220512f, 0.08672831f, 0.00395506f, 
    0.28870106f, 0.14197823f, -0.22212552f, 0.14403036f, 0.03454437f, 0.19027524f, -0.06896418f, 0.07214285f, 
    -0.00911010f, -0.12609340f, 0.06433243f, 0.12027076f, -0.04927871f, 0.10247423f, -0.22311418f, -0.00177471f, 
    0.01010526f, 0.04394681f, -0.08867530f, -0.02689429f, 0.08942648f, 0.08317255f, 0.07076194f, -0.02015183f, 
    0.09570707f, -0.13469310f, 0.21157713f, -0.13172531f, 0.06694171f, -0.06487972f, 0.02832198f, -0.07640065f, 
    0.02819287f, -0.06459159f, 0.05832916f, 0.08700961f, -0.18036455f, 0.11793196f, -0.18439353f, -0.01018832f, 
    -0.01236758f, 0.10009354f, 0.04954125f, 0.04889908f, -0.04282573f, -0.04600027f, 0.07363965f, -0.00138205f, 
    0.16458508f, -0.24779467f, 0.07508340f, -0.03135569f, 0.09356059f, -0.00942203f, 0.01521577f, -0.01280742f, 
    0.05876405f, 0.04372498f, -0.01396733f, 0.16286442f, -0.24035062f, 0.29054198f, -0.01915116f, 0.22679199f, 
    0.11854123f, 0.05704410f, 0.01132214f, 0.06305936f, 0.12733309f, 0.03847810f, 0.11666285f, -0.03693924f, 
    0.14911371f, -0.34472692f, 0.21014166f, -0.00203658f, -0.04616522f, -0.04467055f, -0.04911935f, 0.04409903f, 
    0.00778909f, -0.09008887f, 0.01259410f, -0.02983466f, -0.14559932f, 0.17104489f, -0.11427108f, -0.16945355f, 
    0.07091979f, 0.03299056f, 0.03740180f, -0.06821895f, -0.11264299f, 0.19641411f, 0.14093043f, 0.20656206f, 
    0.01096477f, -0.44034952f, -0.00182316f, 0.05218895f, -0.12503758f, -0.04520795f, 0.07344676f, -0.01258573f, 
    0.09197903f, 0.00267737f, 0.02499604f, 0.04094723f, 0.27088588f, 0.11388122f, -0.00301978f, 0.10568398f, 
    0.11389547f, -0.02155250f, 0.03861570f, 0.00396252f, -0.06392010f, -0.04317889f, -0.09461116f, -0.02491598f, 
    0.01342026f, 0.05352372f, -0.05653889f, -0.01994697f, 0.03866194f, 0.09988688f, 0.03565553f, 0.06076632f, 
    -0.06530491f, -0.01055531f, -0.20273624f, -0.00767416f, 0.46441036f, 0.08980598f, 0.01073694f, 0.24141480f, 
    0.09773641f, 0.03056737f, -0.03339669f, 0.01728409f, 0.00741413f, -0.06169235f, -0.00904396f, 0.13347587f, 
    0.02612505f, 0.07758640f, -0.06917245f, -0.07798238f, 0.16892317f, 0.13732140f, -0.04728651f, -0.01476234f, 
    0.07406794f, 0.08443297f, -0.01800384f, -0.08454235f, 0.17113861f, -0.00527753f, -0.11326123f, -0.06727342f, 
    0.14655176f, 0.08007430f, 0.01164745f, 0.01735341f, -0.08681329f, -0.06638843f, 0.09668036f, -0.06989753f, 
    0.03413759f, 0.02062280f, -0.01215507f, 0.02312238f, -0.00096751f, 0.03034779f, -0.01554699f, 0.00703388f, 
    0.01949611f, -0.03300673f, -0.00530707f, 0.00321977f, -0.00452131f, -0.04472766f, -0.00959465f, -0.02090550f, 
    0.02048654f, -0.04250823f, 0.01596338f, 0.00257071f, 0.01948434f, -0.01701557f, -0.00715722f, -0.00575359f, 
    0.02762090f, 0.01081310f, 0.00829962f, -0.01304528f, -0.00994430f, 0.01505101f, -0.00351396f, -0.02800749f, 
    0.02375173f, -0.02533654f, -0.03110196f, 0.02743435f, -0.02698732f, -0.02277361f, -0.01680185f, -0.04307483f, 
    0.01162993f, -0.03678997f, 0.00201875f, 0.00444942f, 0.01306828f, 0.00616771f, -0.02974433f, -0.03154233f, 
    -0.02828043f, 0.03299579f, 0.03301417f, 0.01316304f, 0.02803373f, 0.01436488f, 0.02362186f, 0.02152582f, 
    -0.01306900f, 0.02986381f, -0.01874194f, -0.03495296f, 0.02027358f, -0.01717281f, -0.02545359f, -0.01731494f, 
    -0.03555925f, 0.02231766f, -0.00104633f, -0.00507994f, -0.02664970f, 0.02171200f, -0.02776682f, -0.03394153f, 
    -0.01997023f, 0.01665388f, -0.01862073f, -0.01451610f, 0.03040959f, -0.00759121f, -0.03511548f, -0.01907724f, 
    -0.02696056f, -0.03751678f, 0.02498431f, 0.00849644f, 0.00502925f, 0.02424809f, -0.02289673f, -0.01932213f, 
    0.03106121f, -0.03862271f, 0.00057417f, 0.02156830f, -0.02078906f, 0.00462029f, -0.01324011f, -0.01819988f, 
    -0.01118319f, 0.00829467f, -0.01243187f, -0.01737313f, -0.02131582f, 0.00085671f, -0.02721826f, -0.00741442f, 
    -0.02377094f, 0.01107045f, -0.02280300f, -0.03050594f, 0.02936181f, 0.00504604f, -0.02531583f, 0.01734836f, 
    0.00768152f, -0.00730031f, -0.03588884f, -0.02808661f, 0.01161559f, 0.02587229f, 0.02214161f, -0.02063534f, 
    0.00503554f, 0.00246998f, 0.01421294f, 0.02099378f, 0.01341559f, 0.01895151f, -0.03502003f, 0.00580807f, 
    -0.03669460f, -0.03084152f, -0.02630952f, -0.03630403f, -0.01439007f, 0.01980567f, 0.00623871f, -0.00391152f, 
    0.01744631f, -0.00349675f, -0.00717630f, 0.02687670f, 0.01080237f, 0.01747000f, -0.00043292f, -0.00947169f, 
    -0.02077620f, 0.02340021f, 0.00290442f, 0.02632652f, 0.02264185f, 0.01338837f, -0.00979028f, -0.00707836f, 
    -0.03074503f, -0.01060333f, -0.01796569f, 0.00028837f, 0.01030086f, -0.01930223f, 0.00644970f, 0.00001010f, 
    0.00810660f, 0.02315401f, -0.02314399f, -0.00303477f, -0.01754623f, -0.00546233f, 0.01462773f, -0.03864035f, 
    -0.01398972f, 0.01954264f, -0.01281946f, -0.01516331f, 0.00594864f, -0.03210783f, 0.01299839f, -0.03065957f, 
    -0.02101487f, -0.01480544f, 0.01488993f, 0.00983702f, 0.02273818f, -0.01044680f, -0.01647004f, 0.02473295f, 
    0.01098550f, -0.02503299f, -0.01507239f, 0.00536097f, 0.02847525f, 0.00739642f, 0.02962831f, 0.02038293f, 
    -0.03229513f, 0.03189752f, -0.03039928f, -0.03784294f, 0.02309272f, -0.01175944f, -0.03832040f, 0.02640277f, 
    -0.03896671f, 0.02825737f, -0.01861145f, 0.02214224f, 0.02644853f, 0.00709880f, 0.01267380f, -0.02739605f, 
    0.00439938f, -0.00459538f, -0.00674740f, -0.00525821f, -0.02597243f, -0.03458726f, -0.03835457f, 0.03455241f, 
    -0.01952726f, 0.01260233f, -0.00817329f, -0.04632042f, 0.00505569f, 0.01368713f, 0.02212777f, 0.00049445f, 
    -0.01193376f, -0.02011948f, -0.02715386f, -0.00180114f, -0.02552206f, -0.01399230f, -0.01830090f, 0.02069978f, 
    -0.02641086f, 0.00009506f, 0.01228677f, -0.01902044f, -0.00776520f, 0.01193252f, -0.02688392f, -0.01821099f, 
    0.01836355f, 0.03452348f, 0.02581689f, 0.02071841f, -0.02353432f, -0.02842970f, 0.02356120f, 0.01130748f, 
    -0.00603540f, 0.02551919f, -0.00380992f, 0.03030351f, -0.01840921f, -0.00000798f, 0.02359044f, 0.00971323f, 
    -0.02669298f, 0.01165593f, -0.03585093f, -0.01384892f, -0.02011673f, -0.03398106f, 0.02024470f, -0.03929620f, 
    0.01480610f, -0.02844700f, 0.02506568f, -0.00163433f, 0.00931697f, 0.02405556f, -0.01795253f, -0.02198937f, 
    -0.01401235f, -0.02886590f, -0.01429484f, -0.03941890f, -0.00108864f, -0.01714029f, -0.01823827f, 0.01683210f, 
    0.01756824f, 0.02686654f, 0.00016620f, 0.00500506f, 0.03009099f, -0.03803698f, -0.00974641f, -0.02450193f, 
    -0.01098312f, -0.02709786f, -0.02853803f, 0.03000150f, 0.01949523f, 0.01873692f, -0.01957453f, -0.03202753f, 
    -0.02161357f, -0.04460147f, 0.00688246f, 0.01761320f, 0.00760723f, 0.02954609f, 0.01959782f, -0.02325913f, 
    -0.01093494f, 0.00293982f, 0.00965743f, 0.01715507f, -0.01010963f, 0.03012149f, 0.01676879f, 0.01437108f, 
    0.00147900f, 0.00326885f, -0.01113626f, -0.00519248f, -0.01740877f, -0.03000758f, -0.00086703f, -0.01128440f, 
    0.02072605f, 0.01462142f, 0.02422419f, 0.02328712f, -0.04031648f, -0.00232476f, -0.01862422f, 0.02440819f, 
    -0.00149917f, -0.01898406f, -0.00777527f, -0.00982476f, 0.00022743f, 0.00222794f, 0.00637619f, -0.02621442f, 
    -0.01847742f, -0.01210365f, 0.01115619f, -0.01417347f, 0.00835337f, 0.03069318f, -0.02874971f, -0.00662029f, 
    -0.01442542f, -0.00548746f, -0.03070341f, 0.02542083f, -0.00400676f, 0.01131945f, 0.01424693f, 0.01571104f, 
    0.01774268f, -0.00424577f, 0.02165099f, -0.00437217f, -0.03459732f, -0.02960935f, 0.01939713f, 0.01588418f, 
    0.00156465f, -0.02236139f, 0.02258625f, 0.01259927f, -0.02408532f, -0.01461277f, 0.01173973f, -0.04494333f, 
    -0.02172339f, -0.01978319f, 0.02451100f, 0.02067419f, 0.01315455f, -0.01128234f, -0.02239081f, -0.02266127f, 
    -0.01466805f, 0.00839630f, -0.02821165f, -0.03107017f, 0.00546762f, -0.02599773f, -0.02125088f, 0.02310877f, 
    0.00065939f, 0.03249091f, -0.02558564f, 0.00824279f, -0.03675641f, 0.02110413f, 0.01334406f, 0.01361416f, 
    0.01662134f, 0.01070080f, -0.00187280f, -0.01055681f, -0.00962659f, 0.00795722f, -0.02311471f, 0.00623949f, 
    -0.02758582f, -0.01641592f, 0.01650151f, 0.00071939f, -0.00854421f, -0.03798847f, -0.04161173f, -0.01975566f, 
    -0.00822925f, -0.02612135f, 0.01082991f, -0.03908247f, -0.00953556f, 0.01807351f, -0.01229333f, -0.02978139f, 
    -0.02453027f, -0.02275958f, 0.02595044f, -0.01911747f, 0.00017433f, -0.02851039f, -0.00773460f, 0.02527472f, 
    -0.01132352f, 0.02216335f, 0.00543431f, 0.00973027f, 0.00149688f, 0.02010040f, -0.01624431f, 0.00354900f, 
    0.01016781f, -0.02784997f, -0.01749944f, 0.01273799f, -0.00368441f, -0.00312204f, 0.02077094f, -0.00082785f, 
    -0.00841186f, -0.01449475f, -0.00944248f, -0.00414831f, -0.01889317f, -0.03556378f, 0.00139248f, -0.01903276f, 
    -0.01677559f, 0.00237058f, 0.02413312f, -0.01998531f, 0.02605747f, -0.00145214f, 0.00122474f, 0.02621347f, 
    0.01615791f, -0.01246618f, 0.02614449f, 0.01278867f, 0.00913405f, 0.03015862f, -0.02443457f, -0.01816993f, 
    -0.00781515f, -0.00705047f, 0.01959335f, -0.01764845f, 0.02407600f, 0.01584576f, -0.02568008f, -0.00681032f, 
    -0.02649469f, 0.02400022f, -0.00137924f, -0.02106150f, 0.02468658f, -0.03737988f, -0.00729795f, 0.02311741f, 
    0.01298154f, 0.02832696f, -0.02730836f, -0.00223082f, 0.01617096f, 0.00322884f, -0.01279713f, 0.00875841f, 
    -0.00736792f, -0.04247522f, -0.02973403f, -0.01018628f, -0.01398581f, 0.01504161f, -0.02926850f, -0.01327975f, 
    0.00148956f, 0.01249362f, 0.00030425f, 0.00227798f, 0.01981298f, -0.02711779f, -0.01928848f, -0.02951131f, 
    0.02933450f, -0.00974983f, 0.01600789f, -0.02030685f, -0.02060486f, -0.03244096f, -0.00447985f, -0.03795866f, 
    0.01363240f, -0.03815584f, 0.02955467f, 0.00268587f, -0.02058256f, -0.01204862f, 0.01512978f, 0.02458181f, 
    -0.01170604f, 0.02176805f, -0.00567994f, 0.00737831f, 0.01161835f, -0.03314287f, -0.01453060f, -0.03902103f, 
    0.01611392f, -0.01026201f, -0.03627327f, 0.00546538f, 0.00245316f, -0.00172003f, 0.02301316f, 0.01669991f, 
    -0.00035901f, 0.02422328f, -0.03851165f, -0.00424739f, 0.01664179f, -0.00979083f, 0.01354832f, -0.01475628f, 
    0.00247350f, -0.00303974f, -0.02251084f, 0.01980077f, 0.01746760f, -0.03375403f, -0.02057019f, -0.02011350f, 
    -0.00286356f, 0.02358468f, -0.02150280f, -0.01385766f, 0.03277211f, 0.00313070f, -0.00331196f, -0.04137705f, 
    -0.01766754f, -0.03421957f, -0.00604481f, -0.03111550f, -0.02301910f, 0.00254910f, -0.00284479f, -0.01162052f, 
    -0.00098057f, -0.01431860f, 0.03011167f, -0.00180586f, -0.01270865f, -0.01733236f, -0.01749779f, -0.03236950f, 
    -0.02335035f, -0.04276688f, -0.02645583f, 0.02174497f, -0.01537121f, -0.03598218f, 0.00792311f, 0.01300888f, 
    -0.00973729f, 0.00330832f, 0.02605000f, -0.02846433f, -0.03696612f, -0.00744050f, -0.01350006f, 0.00188188f, 
    0.00476117f, -0.02176151f, -0.01398619f, 0.01142498f, 0.00255237f, -0.01554881f, -0.02554458f, 0.02224847f, 
    -0.01003383f, -0.00523340f, -0.03363346f, -0.00189674f, 0.00910868f, -0.01677322f, 0.02172995f, -0.01847897f, 
    0.00000906f, -0.03093928f, 0.02841254f, 0.00260796f, -0.01387839f, -0.03269801f, 0.01181953f, 0.02547439f, 
    -0.00746220f, 0.01008989f, 0.00480975f, -0.01086495f, 0.03292046f, 0.00178029f, -0.03057598f, -0.02067990f, 
    -0.03625988f, -0.02037111f, 0.01340544f, -0.01597075f, 0.02837159f, 0.00682770f, 0.00116530f, 0.01921967f, 
    0.00968188f, -0.00787239f, -0.02128887f, -0.00589351f, -0.03178228f, -0.00767131f, -0.02765992f, -0.01967839f, 
    0.02964736f, -0.02663458f, 0.00936275f, -0.02992733f, -0.02876692f, 0.02231554f, -0.03084325f, 0.01328325f, 
    -0.03127773f, 0.00162003f, -0.00693428f, 0.02436207f, -0.00747531f, -0.01185582f, -0.03842478f, -0.03739817f, 
    -0.02247279f, 0.01561375f, 0.01720943f, 0.02748399f, -0.04078702f, -0.00281670f, 0.00060660f, -0.00988335f, 
    -0.01277394f, 0.02230023f, 0.02577157f, -0.00052548f, -0.02101114f, 0.00967409f, 0.00481365f, -0.03818253f, 
    -0.00758264f, 0.02259212f, 0.01046450f, 0.03286887f, -0.02759993f, -0.02164516f, 0.00218134f, -0.04012592f, 
    0.02034677f, -0.02146417f, 0.01396887f, 0.01729871f, -0.00508271f, -0.02797040f, 0.01917122f, -0.01701935f, 
    0.02151111f, -0.01907289f, 0.01017237f, -0.00200514f, -0.01148046f, 0.02971156f, 0.02574918f, -0.04359116f, 
    -0.01256989f, -0.00093531f, -0.01732673f, 0.00925219f, -0.02482681f, -0.00450102f, 0.02003591f, 0.01459475f, 
    0.01039374f, 0.02197723f, -0.01685411f, -0.02669645f, -0.02087725f, -0.01401255f, -0.01489646f, 0.02918593f, 
    -0.00522657f, -0.01782844f, -0.04034008f, -0.02713367f, 0.03116036f, -0.02364204f, -0.01695914f, -0.00093161f, 
    -0.01276776f, 0.02443421f, -0.02269878f, 0.00938273f, 0.01635757f, 0.02785976f, -0.01780436f, 0.00440180f, 
    0.01836793f, -0.03325997f, 0.01832733f, -0.01286546f, 0.01905663f, -0.00734106f, 0.02234255f, -0.01271551f, 
    -0.00256297f, 0.00130091f, -0.00137073f, 0.01259842f, 0.01955028f, -0.04063065f, 0.00864992f, -0.02070223f, 
    -0.02258723f, -0.03400688f, 0.00080061f, 0.02387227f, 0.02216547f, 0.01528984f, -0.00758585f, -0.00574400f, 
    -0.01376640f, 0.01455719f, -0.01162033f, -0.03397964f, -0.02985655f, 0.02191341f, -0.00720975f, 0.03039218f, 
    -0.03674550f, 0.00283616f, -0.03797440f, 0.00100772f, -0.02703816f, 0.01158769f, -0.02384584f, 0.01311575f, 
    0.23590581f, 0.05919504f, -0.08348162f, 0.18189661f, 0.03991969f, -0.03477431f, 0.01936622f, 0.07093721f, 
    0.06215040f, -0.06149765f, -0.01538692f, 0.02539452f, -0.17532195f, -0.13693643f, -0.02869885f, -0.04247935f, 
    -0.06179382f, -0.03044897f, 0.00397197f, 0.01967720f, -0.00589962f, 0.05001626f, 0.09408507f, 0.00626619f, 
    0.02614912f, 0.23296078f, 0.15011132f, -0.03399660f, 0.04005218f, 0.09035051f, 0.11177051f, -0.00915283f, 
    0.03984086f, 0.02311517f, -0.01063735f, -0.09855609f, 0.15920873f, 0.08211532f, 0.08765888f, 0.05031417f, 
    0.12751876f, 0.05467176f, 0.01815626f, 0.08432142f, -0.01062494f, 0.09874604f, 0.00215417f, 0.01416144f, 
    0.20175236f, 0.07615979f, 0.12224333f, -0.02548269f, 0.08972840f, 0.13467149f, 0.00731805f, 0.00381506f, 
    0.03982451f, 0.07549336f, 0.05438446f, -0.02879262f, 0.26593789f, 0.03572323f, 0.04764889f, 0.21467985f, 
    -0.00907402f, 0.03079145f, 0.03842998f, 0.12424543f, 0.07142879f, -0.07460554f, -0.06507402f, -0.07625481f, 
    -0.00754329f, 0.04428017f, 0.03372432f, 0.08578309f, 0.06497361f, -0.00930009f, 0.13180107f, 0.03235039f, 
    -0.00053445f, -0.06427704f, 0.00715572f, -0.00795000f, 0.08043442f, -0.00993595f, 0.01986497f, 0.04066040f, 
    0.06862907f, 0.01764136f, 0.07639589f, 0.07746202f, 0.04565518f, 0.05004515f, 0.00410909f, 0.07910619f, 
    -0.17879839f, 0.02983437f, 0.12577182f, -0.03277829f, -0.00189400f, -0.02632901f, 0.10244516f, 0.02112872f, 
    0.10669063f, 0.01644173f, 0.03135971f, 0.02327725f, -0.18379229f, 0.16710715f, 0.08615854f, 0.12006572f, 
    0.04803704f, -0.03408998f, 0.06963198f, -0.15578054f, 0.03921276f, 0.03187199f, -0.00096864f, 0.00291443f, 
    0.07272530f, 0.17295447f, 0.09165853f, 0.15526776f, -0.07560910f, 0.06389704f, 0.06189788f, 0.02071429f, 
    0.03223991f, 0.00227126f, -0.00598791f, 0.07964043f, 0.06038633f, 0.16866712f, 0.08287078f, -0.05245997f, 
    -0.00931805f, 0.02051344f, 0.07960591f, -0.01637908f, 0.04970583f, -0.01599145f, -0.03649106f, -0.01616148f, 
    -0.02833371f, 0.00954914f, -0.11843902f, 0.12327334f, 0.00394176f, -0.07373313f, 0.05676984f, 0.03889758f, 
    -0.05920421f, 0.01197217f, -0.05851827f, -0.00602776f, 0.17290239f, -0.07858606f, -0.00137426f, 0.09031927f, 
    0.08997089f, -0.06120116f, -0.05529514f, 0.03392858f, 0.06945051f, 0.07183536f, -0.02295039f, 0.06040042f, 
    -0.17105547f, 0.17791043f, 0.01725026f, -0.05072071f, 0.04940841f, 0.05563535f, 0.09189393f, 0.05212859f, 
    0.04415101f, 0.04029343f, 0.03564408f, 0.10356133f, -0.36164677f, -0.09460120f, -0.04159615f, -0.09518082f, 
    0.10193881f, -0.02742747f, -0.08050244f, 0.08169985f, 0.07465084f, -0.07053372f, -0.05906352f, 0.00637853f, 
    0.09549742f, 0.14828412f, 0.04660339f, 0.02780735f, 0.05652441f, 0.14395458f, 0.01948992f, -0.06728616f, 
    -0.02368321f, 0.02563753f, -0.04953853f, 0.16230732f, -0.16637161f, 0.22078386f, -0.03249791f, 0.05235419f, 
    0.04584968f, 0.05846866f, 0.04154167f, -0.09833644f, 0.10531788f, 0.09248301f, 0.11486602f, 0.01239368f, 
    -0.12905665f, -0.09847411f, -0.11950366f, -0.08482535f, 0.05668952f, -0.01672297f, -0.12289953f, 0.02801593f, 
    -0.04799452f, -0.00470816f, -0.03295345f, 0.00182354f, 0.08989082f, -0.12771238f, 0.13114548f, -0.10415929f, 
    0.00984832f, -0.06929603f, 0.04582455f, -0.01797872f, 0.01535494f, -0.01538563f, -0.09146535f, -0.07891013f, 
    -0.19098069f, 0.12015651f, 0.15316959f, 0.05931915f, 0.03147542f, 0.01272479f, -0.00236667f, 0.03802095f, 
    -0.01342591f, 0.11520450f, -0.05511248f, -0.02522539f, -0.03848869f, -0.07785367f, 0.07861768f, 0.06705520f, 
    0.06042854f, -0.11003975f, 0.03896750f, 0.06251696f, 0.12189377f, 0.11601708f, -0.02588322f, -0.01207551f, 
    -0.11381985f, -0.02819269f, 0.01084302f, 0.18166825f, -0.04799531f, 0.09783842f, -0.00482647f, -0.04658773f, 
    0.04207572f, 0.00195223f, 0.03569737f, -0.04594189f, 0.12208287f, -0.01103054f, 0.12647466f, -0.02091246f, 
    0.01850116f, 0.02577587f, 0.04101271f, 0.00971618f, 0.02439522f, 0.02894823f, -0.05776194f, -0.02469800f, 
    0.03661156f, 0.02824670f, 0.00006844f, 0.04350817f, 0.04391652f, -0.01492559f, -0.02992853f, 0.07324407f, 
    0.03704046f, -0.04829890f, -0.00255200f, 0.03270652f, -0.00359778f, 0.12923393f, 0.04048414f, -0.02978849f, 
    0.07886085f, 0.05186401f, 0.07469277f, 0.02622601f, 0.09347931f, -0.07654192f, -0.03987734f, -0.06936528f, 
    -0.16359289f, -0.14921330f, -0.16527246f, -0.00452579f, 0.01946358f, -0.03766008f, -0.15233897f, 0.01845423f, 
    0.03368600f, 0.02746393f, 0.08027322f, 0.03128642f, 0.13629991f, -0.28150344f, -0.09614248f, -0.13686891f, 
    0.02898052f, 0.00516700f, -0.00370565f, -0.04737892f, -0.06483416f, 0.03603744f, -0.01566474f, -0.03728055f, 
    0.01032611f, -0.21567404f, -0.18023403f, -0.00017875f, -0.01254932f, -0.06018297f, 0.02349849f, -0.00955273f, 
    0.06797095f, 0.05177324f, -0.05311221f, 0.10026532f, 0.01844364f, -0.10426426f, 0.21753566f, 0.01622469f, 
    -0.00078483f, 0.04128796f, 0.05795874f, 0.07268568f, 0.01814817f, -0.04321421f, -0.01312375f, -0.00867010f, 
    0.26263076f, 0.10866870f, -0.00418953f, 0.12212937f, 0.00535073f, -0.02093012f, -0.02783921f, 0.14649642f, 
    0.07369357f, 0.00007642f, 0.11092134f, -0.00529398f, 0.25571391f, 0.12305111f, 0.22596036f, 0.13498862f, 
    0.05861565f, 0.02449691f, 0.03818125f, 0.12993111f, 0.03421405f, -0.07171200f, 0.01454893f, 0.09584071f, 
    0.30082470f, 0.11729642f, -0.04693056f, 0.10932126f, 0.06931446f, 0.10289361f, 0.04537318f, 0.02502898f, 
    0.05904013f, 0.02350976f, -0.02941597f, -0.03828399f, 0.30574021f, 0.18481983f, -0.03230053f, 0.00126318f, 
    0.04743233f, 0.03328070f, -0.02474150f, 0.03470299f, 0.04709431f, 0.05277843f, -0.02119322f, 0.02327103f, 
    -0.03817964f, 0.20942533f, 0.04805498f, 0.07390117f, 0.06718358f, 0.00062287f, 0.01285114f, -0.00754910f, 
    0.01807629f, 0.00185553f, 0.05798934f, 0.03155484f, 0.11016261f, 0.14147325f, 0.12658708f, 0.02976325f, 
    0.06243872f, 0.05702145f, 0.14124259f, -0.02506010f, -0.04954843f, 0.01304326f, 0.03564059f, -0.10490584f, 
    -0.17312421f, 0.32234824f, 0.04277395f, 0.08988260f, -0.04868158f, -0.03072626f, 0.06108468f, 0.04089067f, 
    -0.05805305f, 0.01873398f, 0.02321695f, 0.04744003f, 0.09878968f, -0.15220867f, -0.08832675f, -0.02141605f, 
    0.04850421f, -0.00541551f, 0.00476639f, 0.00639882f, -0.02962329f, -0.05108305f, 0.03190983f, -0.01490695f, 
    -0.02732476f, -0.10038123f, 0.01327592f, 0.17415833f, -0.08026873f, -0.03274775f, 0.03775742f, 0.03042983f, 
    0.08033464f, 0.05188866f, 0.03757486f, 0.05252587f, -0.09758464f, -0.12348785f, 0.04549723f, -0.06884856f, 
    -0.01730705f, 0.00722581f, 0.01735123f, 0.03952867f, 0.01204549f, -0.01462095f, 0.12197012f, -0.01235856f, 
    0.00778219f, -0.00064225f, 0.08226245f, 0.07633003f, 0.00672094f, -0.00703281f, 0.09042258f, -0.20275097f, 
    -0.01114171f, 0.02407408f, 0.02105520f, 0.00901234f, -0.09466183f, -0.09347519f, -0.12406647f, -0.09342818f, 
    -0.06976044f, 0.07138563f, -0.14263679f, -0.10077330f, 0.06399861f, 0.09970256f, 0.01352528f, -0.10600561f, 
    0.08791531f, -0.04141686f, -0.00824019f, 0.12274623f, 0.00426120f, -0.05073308f, -0.04872638f, 0.01827684f, 
    0.00901436f, 0.09544867f, 0.09345602f, 0.05814261f, -0.15454531f, -0.07501734f, -0.08332308f, 0.01975449f, 
    -0.08553521f, 0.03713544f, 0.01186492f, 0.00523041f, 0.00277455f, -0.00037885f, 0.05883965f, 0.00381168f, 
    -0.02064984f, 0.18965608f, 0.02609442f, -0.01828426f, 0.03555975f, 0.08031308f, -0.00408744f, -0.01121594f, 
    0.03248791f, -0.07197910f, 0.06108133f, 0.01773350f, 0.12937725f, 0.03499151f, 0.05442301f, 0.22717382f, 
    0.07264187f, -0.03146037f, -0.03280508f, -0.08957925f, 0.02685875f, -0.03302082f, -0.00140499f, -0.03285806f, 
    -0.10344218f, -0.05859047f, 0.13482416f, 0.12051281f, 0.03224729f, -0.11065049f, 0.10157769f, 0.02930821f, 
    -0.09707989f, 0.06887384f, 0.09144858f, 0.07689312f, -0.09804715f, 0.10095839f, -0.01614649f, -0.04872473f, 
    0.01465025f, 0.03250430f, -0.10019669f, 0.01380748f, -0.00092810f, 0.05240089f, -0.13877316f, -0.01959850f, 
    -0.09827727f, -0.17688656f, 0.17253678f, 0.02993335f, -0.06056873f, -0.07341159f, 0.05229263f, 0.05113150f, 
    0.12723213f, -0.06300028f, 0.08185783f, 0.04261464f, 0.08534551f, 0.06579860f, 0.02215647f, 0.09897139f, 
    0.08941580f, -0.02201044f, -0.09098750f, 0.01310452f, 0.01628047f, -0.12916210f, -0.06457462f, -0.04507129f, 
    0.26182193f, 0.14984249f, -0.06656738f, 0.24107273f, -0.04780113f, -0.05273188f, -0.02992281f, -0.05462977f, 
    0.03384690f, 0.04102555f, -0.07377974f, -0.01615274f, 0.19074751f, 0.06420492f, -0.11431748f, -0.00899926f, 
    0.02763240f, 0.06001799f, -0.13303220f, -0.01575754f, 0.06494382f, 0.07342082f, 0.01316192f, 0.03628546f, 
    0.02404660f, -0.07445855f, 0.18920568f, 0.01852587f, 0.10825411f, -0.01568948f, 0.03180994f, 0.01509277f, 
    0.04596647f, -0.03375372f, 0.05010736f, 0.06451813f, 0.18225421f, 0.04739752f, 0.03548034f, 0.11678680f, 
    -0.01143254f, 0.09748038f, -0.06894747f, -0.04190437f, 0.01597780f, 0.08087476f, -0.02194671f, 0.08478561f, 
    0.08665226f, 0.01923760f, -0.05838390f, -0.09476258f, 0.02660914f, -0.07455682f, -0.07310053f, 0.05447781f, 
    0.01659210f, -0.02980516f, -0.07535189f, 0.00395607f, -0.25286004f, -0.10013639f, -0.01860132f, -0.18273447f, 
    0.03140811f, 0.06427588f, -0.14205325f, -0.10175591f, -0.00263621f, 0.06218147f, 0.01196651f, 0.00012013f, 
    -0.17716557f, 0.07015672f, 0.12807506f, 0.03487875f, 0.03929446f, -0.06592511f, 0.03973521f, 0.03355248f, 
    -0.02315438f, 0.02497613f, 0.10368934f, 0.03120137f, 0.11219151f, -0.06665608f, 0.00860183f, 0.00939275f, 
    -0.01516386f, -0.07831953f, -0.09860861f, -0.04886492f, -0.03855448f, 0.00729108f, 0.02030814f, -0.05822674f, 
    -0.16329399f, 0.25335532f, 0.14779775f, -0.00047957f, -0.00781551f, 0.04008904f, 0.04234546f, 0.02279325f, 
    0.04816882f, 0.07987075f, 0.10163951f, -0.03407781f, -0.17897718f, -0.06106126f, -0.02710032f, 0.10371918f, 
    -0.05356056f, -0.09583205f, -0.04084923f, 0.07782295f, -0.00498982f, 0.03414189f, 0.05189414f, -0.01801781f, 
    -0.11980280f, -0.00942628f, 0.07820895f, 0.17632963f, 0.01445746f, -0.04099111f, 0.01038383f, -0.04177611f, 
    0.09473599f, 0.06597523f, 0.02017995f, -0.02076938f, -0.04946479f, 0.24818636f, -0.09437158f, -0.01411518f, 
    -0.11728249f, -0.04742254f, -0.03632922f, -0.01658712f, 0.02890479f, 0.05259093f, 0.10375228f, 0.04312487f, 
    0.08949032f, -0.01828961f, -0.13071419f, 0.08933638f, -0.06587580f, -0.02934688f, 0.02948933f, 0.02590168f, 
    -0.00479643f, -0.02348541f, 0.04795954f, 0.12561850f, -0.10095278f, -0.05842867f, 0.11769275f, 0.11082579f, 
    0.07676418f, -0.04631083f, -0.03554816f, 0.05374756f, 0.03343887f, -0.06419604f, 0.00200710f, 0.08142632f, 
    0.42805389f, -0.10944127f, 0.03532429f, 0.07429099f, -0.08787797f, 0.06232576f, 0.07123331f, 0.09598345f, 
    0.10314285f, 0.02930539f, 0.07584690f, 0.04326846f, -0.17126179f, -0.14764421f, 0.09833849f, 0.16052684f, 
    -0.00899992f, -0.02990967f, 0.10624249f, 0.14091216f, 0.06083210f, 0.07857617f, 0.10103886f, 0.10913288f, 
    0.21513735f, 0.20991896f, -0.02733599f, -0.04455716f, -0.03329430f, 0.12798265f, 0.06877048f, 0.12274700f, 
    0.10948770f, 0.04860526f, -0.01446048f, 0.01223579f, 0.00345970f, 0.14515626f, 0.06327676f, -0.06944982f, 
    0.07871886f, 0.01722180f, 0.06020102f, 0.08355939f, -0.01500337f, 0.01143119f, 0.08687481f, 0.07542673f, 
    -0.05787824f, 0.23253953f, -0.06284154f, -0.01590987f, 0.02802405f, 0.06252999f, 0.04645963f, -0.01686954f, 
    -0.05350984f, 0.11126892f, -0.02107132f, -0.04364096f, -0.09512594f, 0.05770797f, 0.05336278f, 0.06112937f, 
    -0.06283109f, 0.04590527f, 0.02014512f, 0.03021912f, 0.08695254f, 0.04348419f, 0.08274265f, -0.09572574f, 
    0.40505099f, -0.01679675f, -0.03798159f, -0.08573157f, -0.07859297f, 0.01498454f, 0.01345265f, 0.01905195f, 
    -0.03423760f, 0.05204242f, 0.04605941f, 0.05507760f, 0.22100599f, 0.23361568f, -0.00013314f, 0.02403270f, 
    0.04959156f, 0.12651595f, 0.09132630f, -0.02515029f, 0.01084966f, -0.09715530f, 0.12418471f, 0.02332499f, 
    0.37320700f, 0.01913773f, 0.07232022f, 0.08526330f, -0.04647730f, 0.08861620f, -0.00627996f, 0.29808670f, 
    -0.02237966f, -0.07532237f, 0.00038753f, 0.03211805f, 0.05560141f, 0.26380482f, -0.15271603f, 0.00660661f, 
    0.01708750f, -0.05527765f, 0.08286723f, 0.08020600f, 0.00356733f, 0.08276020f, 0.13967836f, 0.04858706f, 
    0.32774800f, -0.04651349f, 0.04414283f, 0.06265329f, -0.00028385f, 0.05459856f, 0.15864857f, 0.12909871f, 
    0.12292491f, -0.06422753f, 0.14200689f, 0.02971709f, 0.25495848f, 0.13084237f, 0.01060038f, -0.02021516f, 
    -0.08454864f, -0.05425225f, 0.02906443f, 0.03262835f, 0.07914902f, -0.00217831f, 0.01410012f, 0.04324651f, 
    0.09437653f, 0.01731605f, -0.04664567f, 0.14942858f, 0.05893580f, -0.01873491f, 0.00325944f, 0.18672329f, 
    0.06332567f, 0.15714440f, 0.11573453f, 0.14809723f, 0.07563023f, 0.32643268f, 0.05269517f, 0.19104497f, 
    0.03028634f, 0.07522332f, -0.00071942f, 0.14411491f, 0.19438522f, 0.07354996f, 0.06988800f, 0.18902540f, 
    0.07130889f, 0.26712883f, 0.09982362f, 0.07077982f, 0.02925073f, 0.12028959f, -0.17536856f, 0.16438003f, 
    0.03790333f, 0.06963479f, 0.02128468f, 0.02726534f, -0.15142484f, 0.00742710f, 0.02960389f, -0.08699340f, 
    -0.00324279f, 0.09344898f, -0.06126259f, 0.08321078f, 0.11328258f, 0.09100503f, 0.04185234f, 0.14918032f, 
    0.25188866f, 0.20933183f, 0.02280178f, -0.05834442f, -0.08702872f, 0.02606845f, 0.08697890f, 0.03289080f, 
    0.11673259f, 0.06224201f, 0.02833467f, -0.12418970f, 0.24796230f, -0.32004213f, 0.09467204f, -0.01369640f, 
    0.08169009f, 0.02638981f, 0.22187248f, 0.10110236f, -0.00436013f, 0.11088631f, -0.02632105f, -0.00940697f, 
    -0.03128380f, -0.13576910f, -0.13744953f, -0.14194430f, 0.06123956f, 0.14137091f, 0.06790677f, 0.20598669f, 
    0.08814809f, 0.04790459f, 0.02858002f, 0.05947181f, 0.02448856f, -0.17299448f, 0.00065419f, -0.05977332f, 
    0.12451678f, 0.02993062f, 0.02387897f, 0.13182530f, 0.12080882f, 0.04585689f, 0.10425144f, 0.12528938f, 
    0.00753647f, 0.38215533f, -0.01508462f, 0.17215377f, 0.06841625f, 0.04474576f, 0.07545782f, 0.17386954f, 
    0.01980981f, -0.01284635f, 0.00978535f, 0.05963269f, 0.21323776f, 0.28457543f, -0.07778006f, 0.10493401f, 
    0.19226716f, 0.10862321f, 0.12261048f, 0.07647884f, 0.12539425f, 0.14402157f, -0.14297324f, 0.11366451f, 
    0.14335999f, 0.06122457f, 0.10038795f, 0.10061651f, 0.05124891f, 0.12040095f, 0.09573363f, 0.11558294f, 
    0.07988350f, 0.16525082f, 0.04254090f, 0.00024773f, -0.00472813f, 0.07160047f, -0.03171572f, 0.00979628f, 
    -0.05273291f, -0.05551773f, 0.11789817f, -0.04438621f, 0.01982956f, 0.03920839f, 0.06018132f, -0.08017854f, 
    0.40356958f, -0.28736034f, -0.03594414f, 0.28082201f, 0.13288961f, -0.10447594f, 0.00464886f, 0.09079683f, 
    0.07050896f, 0.13572180f, 0.01572283f, 0.11494724f, 0.21721429f, -0.27676386f, 0.02480246f, 0.25135803f, 
    0.13153051f, 0.08872131f, 0.10391433f, 0.25999865f, 0.17351340f, 0.08738145f, 0.06185117f, -0.03696391f, 
    -0.13350771f, 0.16318174f, -0.05346774f, -0.00095170f, -0.02036856f, -0.03447904f, -0.01448768f, 0.09470578f, 
    0.10381230f, 0.13326958f, 0.02084208f, 0.05935147f, 0.06185027f, -0.02110314f, 0.11099565f, -0.10940958f, 
    0.06817202f, 0.12839213f, -0.02137595f, 0.04261280f, 0.05670329f, 0.08287667f, 0.04862734f, 0.05900548f, 
    0.19327897f, -0.12413310f, 0.14936873f, 0.13459140f, -0.01954822f, 0.06015718f, 0.10199097f, 0.00690016f, 
    0.17938885f, 0.23530623f, 0.06018815f, 0.05380017f, -0.13938235f, 0.04738231f, 0.06220014f, -0.13138446f, 
    0.11346485f, 0.06306526f, -0.00533740f, 0.25517637f, -0.09819394f, 0.02874793f, 0.00010503f, 0.05282087f, 
    0.25712964f, -0.01611595f, -0.21623142f, -0.18253861f, 0.12030289f, -0.06659074f, -0.00502759f, -0.07167435f, 
    0.04787761f, 0.02163103f, -0.01090753f, -0.01718112f, 0.33891600f, 0.05540111f, 0.06153759f, 0.06349651f, 
    0.11784004f, -0.15897860f, 0.03313522f, 0.00660538f, 0.18221453f, 0.06383617f, 0.09084587f, -0.03008873f, 
    0.26968589f, 0.01538287f, -0.05054191f, -0.03169798f, -0.01202746f, -0.04648119f, -0.03493286f, -0.06413855f, 
    0.05027075f, 0.02100720f, 0.09905460f, -0.03053159f, 0.10841618f, 0.12050478f, -0.03096522f, -0.14755514f, 
    0.11027542f, -0.03421742f, 0.00315325f, -0.06643550f, 0.00242193f, 0.08671954f, 0.03467894f, -0.02017488f, 
    0.49678081f, 0.04499420f, -0.08782839f, 0.02625001f, -0.03863158f, 0.00276646f, 0.05430751f, 0.16453609f, 
    0.05227751f, 0.12109179f, 0.01011960f, -0.04511118f, 0.24494159f, 0.08089938f, -0.00393226f, -0.02172736f, 
    -0.07151784f, 0.01419221f, 0.00164869f, 0.07008402f, -0.01587186f, 0.10023277f, 0.03445803f, -0.08164700f, 
    0.44560805f, -0.00688382f, -0.03912166f, 0.10271073f, -0.07322483f, -0.04307457f, 0.15918905f, 0.15206280f, 
    0.01286585f, 0.01457910f, 0.10237058f, 0.04201020f, 0.15392539f, 0.35962701f, 0.03636283f, -0.03950446f, 
    0.10331765f, -0.00945050f, 0.06350670f, 0.16151503f, 0.02675795f, -0.01437877f, 0.04947045f, 0.05322126f, 
    -0.05152465f, -0.34179115f, 0.25573075f, 0.11569604f, -0.09415848f, -0.08743302f, 0.05226102f, 0.05495265f, 
    0.18060648f, 0.08850936f, 0.04859297f, -0.07162581f, -0.20954810f, 0.06766050f, -0.00185580f, 0.04544499f, 
    0.12177514f, -0.00427776f, 0.01663568f, 0.03811942f, 0.03044386f, 0.08432606f, -0.04523731f, 0.11251763f, 
    0.27462134f, -0.12475105f, 0.09184307f, 0.05492458f, -0.07708339f, -0.07921929f, 0.07746053f, 0.08055390f, 
    0.10445448f, 0.01198639f, -0.03324021f, 0.03520595f, -0.02176372f, -0.13155328f, -0.08588559f, -0.01567567f, 
    0.03562490f, 0.03872234f, 0.06401785f, 0.09639592f, 0.15497056f, 0.05455183f, 0.04565675f, 0.17370975f, 
    0.29145870f, 0.07834144f, -0.04428258f, 0.09072748f, 0.26341733f, 0.01209936f, 0.08125679f, 0.01046077f, 
    0.24098679f, 0.09807652f, 0.08121568f, 0.10974410f, 0.21916553f, -0.24523291f, 0.07749234f, -0.03306782f, 
    0.05500682f, 0.10632712f, 0.10708670f, 0.00911123f, 0.09232433f, 0.07498196f, 0.06358149f, 0.06469149f, 
    0.47589821f, -0.05152722f, 0.08160954f, 0.00616156f, -0.13009705f, 0.03381005f, 0.10668189f, 0.17427811f, 
    0.00256355f, -0.00891942f, -0.06887190f, 0.12769730f, 0.11280979f, -0.07140879f, 0.00502941f, 0.10206985f, 
    0.12732482f, -0.11505676f, 0.25419408f, -0.00225168f, -0.06312711f, 0.06348719f, 0.04563743f, 0.04610910f, 
    -0.12006577f, 0.03784103f, 0.07053664f, 0.03396351f, -0.02078781f, 0.17574421f, 0.10624260f, -0.03972994f, 
    -0.03462782f, 0.02679499f, 0.02293855f, 0.01227226f, -0.11219041f, 0.14784810f, 0.03938660f, -0.00219292f, 
    0.04499196f, 0.17836060f, 0.14178047f, 0.10422871f, 0.12946180f, 0.07834922f, -0.08411267f, 0.12558022f, 
    -0.14048284f, 0.27249876f, 0.11618702f, 0.14784941f, 0.16466637f, 0.08735874f, 0.02322429f, 0.02234147f, 
    0.10570676f, -0.01991654f, 0.07869016f, 0.06513063f, 0.30282998f, 0.10940353f, 0.09206294f, 0.00930461f, 
    0.10637516f, 0.05120617f, 0.05598788f, -0.06910198f, -0.04707890f, 0.09683993f, 0.14033337f, 0.06118548f, 
    0.22433038f, 0.03257149f, -0.06227728f, 0.06759459f, 0.15120235f, 0.05010287f, 0.05122215f, 0.06388512f, 
    0.00590095f, 0.11010204f, 0.10975441f, 0.01407736f, 0.14063069f, 0.11853378f, 0.07994363f, 0.05108289f, 
    0.19157667f, 0.10831674f, -0.01924775f, -0.00042303f, 0.00819623f, 0.10756985f, 0.18866934f, 0.08181808f, 
    -0.03459907f, 0.03027680f, 0.07096133f, 0.10758691f, 0.00170517f, 0.01497111f, 0.03570025f, 0.06813163f, 
    0.06386308f, 0.08675691f, 0.09425376f, 0.07677716f, -0.16434588f, -0.17383207f, 0.06837610f, 0.14794216f, 
    0.20076367f, -0.04884892f, 0.23526508f, 0.03072546f, 0.00068763f, 0.02318303f, 0.09492132f, -0.06335630f, 
    0.11547769f, -0.07175790f, -0.18212366f, -0.07956795f, 0.00254316f, 0.07096864f, -0.02696862f, 0.10830434f, 
    0.18065892f, 0.14697619f, 0.10363384f, 0.22753647f, -0.34301546f, 0.10449224f, 0.03551035f, 0.10786960f, 
    0.15064242f, 0.06930264f, 0.05363676f, 0.06923255f, 0.03419810f, 0.08867381f, 0.04991307f, 0.07498857f, 
    0.25571507f, -0.15094210f, 0.08539905f, -0.06540089f, 0.05335171f, -0.00531033f, -0.03843586f, 0.07898848f, 
    0.04055328f, 0.11727993f, 0.07672873f, 0.00124524f, -0.06116620f, 0.21044776f, 0.20031576f, -0.15886579f, 
    0.02213635f, -0.03335155f, 0.10265888f, 0.00890427f, 0.09069738f, 0.14180179f, 0.05835222f, 0.05408795f, 
    -0.07835352f, 0.13534208f, 0.03563355f, -0.03883881f, -0.07843416f, -0.01145728f, 0.03949864f, 0.16942079f, 
    -0.01189992f, 0.11668257f, -0.01562124f, 0.11459617f, -0.08471353f, 0.36184826f, -0.04728029f, 0.02909060f, 
    0.02511721f, 0.05250146f, 0.18266739f, 0.02470579f, 0.14444481f, -0.00848927f, -0.05841559f, 0.03051349f, 
    0.03944794f, 0.30642188f, 0.08918634f, 0.07454684f, 0.09023611f, 0.05202630f, 0.09067755f, 0.12507223f, 
    0.00953407f, 0.02824477f, -0.02125485f, -0.01844265f, 0.26334393f, -0.33888268f, -0.00342848f, 0.03940834f, 
    0.07289710f, -0.04453997f, -0.00949135f, 0.12023744f, 0.11626946f, 0.11785226f, -0.03312715f, 0.17363587f, 
    0.33457986f, -0.15913303f, 0.16163366f, 0.02908439f, 0.09655756f, 0.00555444f, 0.01937704f, 0.03539780f, 
    0.11819133f, 0.03263130f, 0.08993234f, 0.05450979f, -0.00995226f, 0.34331390f, 0.03769172f, 0.14601393f, 
    0.22459450f, 0.19436868f, 0.06996371f, 0.07104863f, 0.19796628f, 0.05643155f, 0.03290678f, -0.02139888f, 
    0.00577675f, -0.04075440f, 0.00468933f, 0.01403046f, -0.01130971f, 0.02362091f, 0.02465823f, -0.03815374f, 
    -0.03173713f, -0.02193028f, -0.01578468f, 0.00169266f, -0.01900203f, -0.02755980f, 0.00232166f, 0.00499319f, 
    -0.00481805f, -0.03458862f, 0.00530721f, -0.03190176f, -0.01328999f, 0.00634411f, 0.01428853f, -0.01203154f, 
    0.02333738f, -0.03154515f, -0.01686083f, 0.01064050f, -0.03742235f, 0.01049586f, -0.02801182f, 0.00156191f, 
    -0.03378444f, -0.01927847f, 0.03083473f, -0.03290955f, -0.00678986f, -0.01830688f, -0.03140359f, -0.00476060f, 
    -0.00361424f, 0.01336982f, 0.01555636f, -0.03685664f, 0.01354202f, -0.01987441f, -0.01261495f, -0.02809600f, 
    -0.02013263f, 0.00276563f, -0.02326887f, -0.01982953f, -0.02035899f, 0.02429991f, 0.02540353f, -0.04051424f, 
    0.00654792f, 0.01553204f, 0.03358065f, 0.00164396f, -0.01687823f, -0.01152612f, -0.02688170f, -0.04089579f, 
    0.02150325f, -0.03041702f, -0.01925489f, -0.02323901f, -0.01149465f, 0.01551829f, 0.02504790f, 0.00291435f, 
    -0.01534925f, -0.02907797f, -0.04095508f, -0.03768669f, 0.01337470f, 0.00010623f, -0.01472806f, 0.02497267f, 
    0.00751735f, 0.00869945f, 0.02564305f, -0.01158916f, 0.01161243f, -0.01179659f, -0.01180074f, -0.01642861f, 
    0.02321847f, 0.00576540f, 0.03001960f, -0.00196502f, 0.00804544f, -0.02127289f, -0.01895798f, -0.03859067f, 
    -0.00176594f, -0.02739634f, -0.02565434f, 0.02111034f, -0.01718481f, 0.02454478f, -0.03692205f, 0.01869432f, 
    0.00054838f, 0.01775464f, -0.02582272f, -0.02644038f, 0.02325330f, 0.00697039f, 0.00156986f, -0.02425294f, 
    -0.01089020f, -0.00577943f, -0.02378857f, 0.01337266f, -0.01252856f, -0.03743633f, -0.02048571f, -0.03982101f, 
    0.01756642f, 0.02749131f, 0.01792894f, -0.00675177f, 0.01794085f, 0.01014602f, -0.00733281f, -0.02931270f, 
    -0.00443680f, 0.01352371f, -0.00578905f, -0.02928118f, -0.00479398f, 0.01311054f, -0.01997552f, -0.02756051f, 
    -0.03006461f, -0.03202809f, 0.01783017f, -0.02576005f, 0.01993569f, -0.01647264f, -0.02225401f, 0.01251286f, 
    0.00208398f, 0.00528227f, 0.00394549f, 0.01602549f, 0.02933362f, -0.03238533f, -0.02314617f, -0.01815446f, 
    0.02725133f, 0.01573651f, -0.03088900f, 0.02550823f, -0.03702946f, -0.00500192f, -0.02839487f, 0.02912533f, 
    -0.03854442f, 0.00518321f, -0.00694828f, -0.00618613f, 0.01382638f, -0.01314292f, 0.00572693f, -0.01930649f, 
    -0.03783433f, 0.00206960f, -0.01604804f, -0.01472391f, -0.01375769f, 0.02264252f, -0.04021445f, 0.02910213f, 
    0.02652337f, -0.00577313f, 0.00133118f, -0.03611606f, 0.00752101f, 0.01580085f, 0.01271031f, -0.01461334f, 
    0.01280144f, -0.04266357f, -0.01231069f, 0.02520799f, 0.01887669f, 0.03001361f, 0.00571354f, 0.02040543f, 
    -0.02600383f, 0.01770445f, -0.00089127f, 0.01299002f, -0.01660383f, -0.02167132f, -0.03908610f, -0.02352408f, 
    -0.01809524f, -0.02265237f, 0.00705709f, -0.02632279f, -0.00375531f, 0.02903855f, 0.02722372f, -0.00162235f, 
    0.02643366f, -0.03767665f, -0.01847567f, 0.01994636f, 0.00463448f, 0.01438217f, -0.02592297f, 0.02386996f, 
    -0.01038387f, 0.01810257f, 0.00273892f, 0.01686061f, -0.00416667f, 0.01961310f, 0.02089055f, 0.00925812f, 
    0.02499058f, 0.02137315f, 0.00721400f, 0.00022350f, 0.02365515f, 0.02099035f, 0.00367877f, 0.00931399f, 
    0.02075997f, 0.00992061f, 0.01543449f, -0.02934457f, 0.02124323f, 0.02725508f, 0.02964241f, 0.00255612f, 
    0.01539230f, -0.00219088f, 0.01581913f, 0.01552225f, -0.02879433f, 0.02535621f, 0.00890294f, -0.01232434f, 
    -0.00112839f, 0.00641596f, -0.02795400f, -0.00254745f, -0.02374653f, -0.02467774f, 0.00915293f, 0.03229674f, 
    0.01687484f, -0.03516643f, 0.02668999f, 0.00034764f, -0.01542257f, -0.00503787f, 0.00862182f, -0.03391978f, 
    -0.00339529f, 0.02191851f, -0.00154144f, 0.02639891f, -0.03067710f, -0.03011871f, -0.02033660f, 0.00933783f, 
    -0.02598146f, 0.01422520f, -0.01724669f, 0.01166400f, -0.01204747f, 0.01421765f, -0.01562003f, -0.02251335f, 
    -0.02101659f, 0.00448734f, -0.03579151f, -0.02849743f, 0.00676812f, 0.02355971f, 0.00488803f, 0.02102196f, 
    -0.01194296f, -0.02919219f, 0.02536161f, -0.02164107f, -0.02562145f, 0.01087311f, 0.00003288f, -0.03238983f, 
    -0.00563135f, 0.00500539f, -0.01261997f, -0.03125320f, -0.01976726f, 0.00854234f, 0.01286987f, -0.02074791f, 
    -0.01889703f, 0.02995815f, 0.02907351f, 0.00354443f, -0.02219410f, -0.02092049f, -0.04033524f, 0.00027135f, 
    -0.01614653f, -0.02711006f, 0.02769794f, -0.02506996f, -0.01129525f, -0.01555905f, -0.01310337f, 0.00831061f, 
    0.03056194f, 0.02506172f, -0.00751624f, 0.00329218f, -0.02428821f, 0.02358330f, -0.00739850f, -0.01824277f, 
    0.00968551f, -0.01279624f, 0.02964091f, 0.01690121f, 0.00607234f, -0.03719136f, 0.01809854f, -0.02162368f, 
    -0.01248350f, 0.01525022f, 0.02683112f, -0.03076407f, 0.02366065f, 0.00963668f, -0.03694639f, -0.02745654f, 
    -0.03574323f, -0.00198957f, -0.00551800f, 0.02814477f, -0.02432217f, 0.01030978f, -0.01412994f, 0.02739201f, 
    -0.02301615f, -0.01516059f, -0.04119798f, 0.01527469f, 0.00886253f, -0.02169902f, 0.01862870f, 0.00577360f, 
    0.01119728f, 0.00580998f, -0.03372108f, 0.02302650f, -0.03972055f, 0.02665294f, -0.02868399f, 0.02167128f, 
    -0.00102638f, 0.00269957f, -0.03114731f, 0.00932085f, -0.03194132f, -0.03083530f, -0.00228704f, -0.01045167f, 
    -0.02490701f, 0.00875531f, 0.00333767f, 0.01250024f, -0.00739534f, -0.04107401f, -0.01672281f, -0.03018263f, 
    -0.03191548f, -0.03245443f, 0.00868687f, -0.01400224f, -0.04211490f, -0.03933460f, 0.02884840f, 0.01711259f, 
    -0.00183813f, -0.01484294f, 0.02564861f, -0.02458756f, 0.00376960f, -0.00640314f, -0.02932011f, -0.00064181f, 
    0.02484966f, 0.00804408f, 0.03074761f, -0.02288637f, -0.01386086f, 0.02262171f, -0.02888162f, -0.00196363f, 
    0.00306434f, -0.02106579f, 0.01812471f, 0.03238615f, -0.03790292f, 0.01241574f, -0.03577724f, 0.00920098f, 
    -0.01775242f, 0.00842053f, 0.00939906f, 0.01266445f, -0.01271387f, -0.03248358f, -0.02182058f, 0.00501074f, 
    -0.02215601f, -0.04332850f, 0.02532369f, -0.03333563f, 0.02638257f, -0.01395710f, 0.01621610f, 0.00534446f, 
    -0.02008341f, 0.01186643f, -0.02746996f, -0.00965711f, 0.00256422f, -0.03959420f, -0.01080092f, -0.01253205f, 
    -0.01897523f, -0.01496549f, 0.02631173f, 0.00530746f, -0.00556114f, -0.01619722f, -0.01843147f, -0.03451625f, 
    0.02239884f, -0.03302338f, 0.00447333f, -0.03318816f, 0.02833164f, -0.02428321f, 0.02936248f, -0.00787695f, 
    -0.02868746f, 0.01923587f, -0.00006021f, 0.00850797f, -0.01424749f, -0.02855850f, 0.00646561f, -0.00507469f, 
    -0.01689390f, -0.00800631f, 0.02245082f, 0.01339702f, -0.01298569f, -0.01887769f, 0.01007045f, -0.02801325f, 
    -0.00212936f, 0.00651514f, -0.03991215f, -0.00143496f, -0.01711498f, -0.01574201f, 0.02121322f, -0.02737176f, 
    -0.01402617f, -0.00430405f, 0.01049680f, -0.02059573f, -0.03046154f, -0.00833764f, -0.03069800f, -0.01800166f, 
    0.02735214f, -0.01132542f, 0.01684743f, -0.01269959f, -0.04009876f, -0.00521744f, -0.03058238f, 0.00478039f, 
    -0.03597967f, -0.03964246f, -0.01622591f, 0.01877499f, 0.00695479f, -0.00820764f, -0.02278424f, -0.04265005f, 
    -0.00563228f, 0.01361756f, 0.02356882f, -0.01922642f, 0.01991596f, 0.02027633f, -0.02121599f, -0.01134821f, 
    0.01385919f, 0.00719699f, 0.00897002f, 0.00767193f, 0.02510141f, -0.03218792f, -0.02015885f, -0.00224183f, 
    -0.01258093f, 0.02598828f, 0.00045251f, -0.02552148f, -0.03898185f, -0.02168312f, -0.03579635f, -0.02087318f, 
    0.00811290f, 0.00255773f, -0.01352143f, -0.01199958f, 0.01308297f, 0.02157938f, 0.01408581f, 0.02970136f, 
    -0.01564635f, -0.01429006f, -0.03992886f, -0.01529579f, -0.01301167f, -0.00479039f, -0.01505664f, 0.02769843f, 
    -0.02052468f, 0.01667388f, 0.00483383f, -0.00506199f, 0.02785416f, -0.03206952f, 0.00108986f, -0.00536099f, 
    0.00159879f, 0.02084979f, 0.01056496f, -0.01038924f, -0.02012726f, -0.03361807f, -0.00299495f, -0.04219311f, 
    0.00077636f, -0.01564230f, -0.03954989f, 0.01561592f, -0.03519375f, 0.01659104f, -0.03928707f, -0.03318940f, 
    -0.03866631f, -0.04197358f, -0.02910437f, 0.02104542f, 0.00839107f, -0.02036062f, -0.02981685f, -0.00800696f, 
    0.00843394f, -0.01565713f, 0.02967315f, 0.02310366f, -0.00705311f, -0.03184368f, 0.01538145f, -0.00871841f, 
    0.02859854f, -0.01710035f, 0.02155644f, -0.00714768f, 0.00442939f, 0.02088103f, -0.03265163f, 0.00538249f, 
    0.01360995f, 0.01557054f, 0.00552051f, 0.01121566f, -0.01957900f, 0.02661747f, -0.01915439f, -0.03883635f, 
    0.00380787f, -0.02928852f, -0.03774605f, 0.00928147f, 0.02533211f, 0.00038517f, 0.00780539f, -0.01768868f, 
    -0.01733522f, 0.01162016f, -0.01367036f, 0.00162901f, -0.01316425f, -0.00981439f, -0.02926460f, -0.01648817f, 
    -0.02745828f, 0.02336534f, 0.02122680f, -0.01178866f, 0.02137910f, 0.02537494f, 0.01904480f, 0.01678621f, 
    0.02790636f, 0.00759606f, -0.00930334f, 0.00825023f, -0.00733313f, 0.00081148f, -0.01752221f, -0.03386281f, 
    -0.00578118f, -0.01179214f, -0.02494631f, -0.03305266f, 0.01499760f, -0.02847747f, 0.00028995f, -0.00997178f, 
    -0.01849247f, 0.01388370f, -0.00116676f, 0.00586007f, -0.01713588f, -0.03307908f, -0.02311973f, -0.03538022f, 
    -0.03698415f, -0.00864987f, 0.00573813f, -0.02357435f, -0.02694570f, -0.00644514f, 0.01287183f, -0.01029286f, 
    -0.00782150f, 0.00924660f, -0.00377767f, -0.02636940f, 0.00222947f, -0.00137749f, 0.01588228f, -0.03443224f, 
    0.01226018f, 0.02680994f, -0.02843263f, -0.00380409f, 0.01931100f, -0.03427422f, 0.00256283f, -0.02816967f, 
    -0.00628605f, 0.02864724f, 0.02533986f, 0.01904576f, -0.03144118f, -0.00555450f, -0.00793774f, -0.03997420f, 
    -0.03761882f, 0.01517183f, -0.01940728f, 0.02864138f, 0.00556266f, -0.03840229f, -0.01078003f, 0.00796484f, 
    0.00021311f, 0.03199613f, -0.00349499f, -0.02709293f, 0.02035535f, 0.01541310f, -0.01275416f, -0.00147847f, 
    0.01094496f, -0.03049549f, -0.01373442f, -0.00948429f, -0.02030853f, 0.01167240f, -0.03255481f, 0.00233168f, 
    0.03119283f, -0.01377472f, 0.01729709f, -0.00022468f, -0.00841386f, 0.00669442f, 0.02327084f, -0.02249422f, 
    -0.02320099f, -0.04266090f, -0.02025043f, -0.03022455f, -0.01912579f, -0.01060486f, 0.00358815f, 0.00812088f, 
    -0.01168755f, 0.00115050f, -0.03824997f, 0.00506419f, -0.03376499f, -0.01665890f, -0.01760238f, 0.01154236f, 
    -0.00581322f, 0.02225740f, -0.02239730f, 0.02452650f, -0.01199503f, -0.02683191f, 0.02274970f, 0.02751480f, 
    -0.01671962f, -0.00227146f, 0.01780352f, 0.00472930f, 0.02842015f, -0.02929634f, 0.00808024f, -0.01189207f, 
    0.01531949f, 0.01584969f, 0.00593448f, 0.02072219f, 0.00069872f, -0.00409311f, 0.02145069f, 0.01782321f, 
    0.00238548f, -0.03714234f, -0.01103485f, 0.00353929f, -0.01868490f, 0.01061991f, -0.03706897f, -0.01096795f, 
    -0.01537860f, -0.01001183f, -0.03089490f, 0.02974519f, 0.01074597f, -0.01778647f, 0.02298634f, -0.00726585f, 
    0.01442147f, 0.00259745f, -0.00780205f, -0.00210788f, -0.02340593f, 0.03070774f, -0.02675019f, 0.00302104f, 
    0.00269005f, 0.02019413f, -0.02830524f, -0.01266464f, 0.00901299f, 0.02490268f, -0.02208243f, -0.00258180f, 
    -0.01215465f, 0.01884716f, -0.03420036f, 0.02747251f, 0.00392988f, -0.00323728f, -0.04190139f, 0.01560923f, 
    -0.03532518f, -0.01793092f, 0.00305762f, 0.01156750f, -0.00895838f, -0.02865601f, 0.00334102f, -0.02736350f, 
    0.02376700f, 0.01086979f, -0.03995711f, -0.02128949f, 0.02324545f, -0.02119957f, 0.00068243f, 0.01005986f, 
    0.01013780f, -0.00649134f, 0.02017896f, -0.00591109f, 0.01491396f, 0.02889712f, -0.00644555f, -0.00492488f, 
    0.03814718f, -0.02013936f, 0.01593132f, 0.01061065f, -0.02931241f, -0.02703228f, -0.03601128f, -0.01666417f, 
    0.02384232f, 0.01331069f, 0.01043813f, 0.01949297f, 0.01771637f, 0.01558163f, 0.02562607f, 0.01420137f, 
    0.03536355f, -0.00290054f, 0.00761087f, -0.00516405f, 0.02296043f, -0.00409108f, 0.02435275f, 0.02138774f, 
    -0.00926475f, -0.00471592f, 0.01768346f, -0.03335931f, 0.01808011f, -0.02834144f, -0.03366821f, -0.02814855f, 
    0.01896014f, 0.02331804f, -0.00737859f, 0.00740841f, -0.02208437f, 0.01821936f, -0.02987110f, -0.03101396f, 
    -0.03719519f, -0.03036066f, 0.02256739f, 0.02373203f, -0.01057289f, -0.02735008f, 0.02813263f, 0.01710056f, 
    0.03098080f, 0.02279796f, -0.01572844f, -0.00682405f, 0.02063942f, 0.00032811f, -0.01219402f, -0.03923953f, 
    0.00907508f, -0.00118348f, -0.03804886f, -0.03864238f, -0.01735235f, -0.00447322f, 0.02071850f, -0.00959355f, 
    0.02583955f, -0.02884551f, -0.00233393f, -0.00896655f, 0.01902408f, -0.02789965f, 0.02504964f, 0.03913744f, 
    0.03037062f, 0.03666836f, -0.01727656f, -0.02496424f, -0.02808639f, 0.00872454f, 0.02226587f, -0.01288245f, 
    0.00254696f, -0.00148629f, 0.01816966f, 0.01626167f, -0.01488075f, 0.00622035f, -0.01615208f, 0.02247701f, 
    -0.02977922f, 0.01707886f, 0.02336849f, -0.00941898f, 0.01187316f, 0.02724558f, -0.01041842f, 0.02463991f, 
    -0.03420026f, 0.02772060f, -0.02025085f, 0.01425381f, 0.00098095f, -0.02808706f, -0.02439623f, -0.00563261f, 
    -0.03672823f, 0.01695536f, 0.01710089f, 0.03378153f, 0.01587585f, 0.00475638f, -0.01074424f, -0.02656597f, 
    -0.04069366f, -0.00941706f, -0.02187779f, 0.02239895f, -0.01737799f, 0.01526121f, -0.00210718f, 0.00011983f, 
    -0.02686406f, -0.00038089f, -0.01348443f, -0.04484408f, -0.01889957f, -0.01713217f, 0.00911619f, -0.00841742f, 
    0.01705072f, -0.01704351f, -0.01319608f, -0.00742655f, -0.02923162f, -0.00761953f, -0.04500880f, -0.00764890f, 
    -0.03186374f, 0.02761793f, 0.01007489f, -0.01523149f, 0.03604395f, -0.03650134f, -0.00258272f, -0.00956907f, 
    0.01295127f, -0.02818333f, -0.03470676f, 0.01748458f, 0.02135531f, -0.01122274f, -0.02083833f, -0.02426294f, 
    -0.02846672f, 0.01772271f, -0.01847015f, 0.02433173f, -0.00996953f, -0.02809059f, 0.00035158f, -0.04287700f, 
    -0.02004643f, 0.01271865f, -0.01995775f, 0.00340803f, 0.04040654f, -0.03214699f, -0.02105125f, 0.01874455f, 
    0.00907810f, 0.02422467f, -0.02090941f, -0.03113403f, 0.00757223f, -0.03101984f, 0.02913562f, -0.02546324f, 
    -0.02120353f, 0.00372312f, -0.01807054f, -0.01514446f, -0.00181124f, -0.03209898f, 0.01941407f, -0.01681947f, 
    -0.00493043f, 0.02224705f, 0.03138737f, 0.02752946f, -0.03899725f, 0.00186080f, -0.03676001f, -0.03710473f, 
    0.00324294f, -0.03649756f, -0.00411588f, -0.00543677f, 0.01251450f, 0.01641815f, -0.01574056f, -0.02467235f, 
    -0.00362100f, -0.00245726f, -0.02653627f, -0.02016501f, 0.00196358f, -0.02822888f, -0.02718698f, 0.00456080f, 
    0.01955800f, 0.00851983f, 0.01850630f, 0.02733676f, 0.02054608f, -0.03211051f, 0.00143763f, 0.00927447f, 
    0.02155274f, -0.04007285f, 0.01525092f, -0.01959606f, -0.00407135f, 0.01207095f, 0.01718477f, -0.01451814f, 
    0.01287202f, 0.03469357f, 0.03143943f, 0.01939589f, 0.03283992f, 0.00280042f, -0.02893919f, 0.01557694f, 
    0.02098406f, 0.00920430f, 0.03633009f, -0.03986456f, -0.03555275f, -0.00462965f, 0.01147863f, 0.01745017f, 
    0.03123424f, -0.01805308f, 0.02013690f, 0.00479343f, -0.02504077f, 0.02527133f, -0.00429946f, -0.02438162f, 
    -0.00278784f, 0.00830170f, -0.01504646f, -0.00752765f, 0.02654047f, -0.02247109f, -0.02563222f, 0.00421779f, 
    0.01896754f, 0.02553432f, 0.00351983f, 0.02610280f, -0.01207879f, 0.00657842f, 0.00274249f, 0.01574586f, 
    0.00059744f, -0.02570670f, -0.03287169f, 0.01221462f, 0.01135592f, -0.03156151f, 0.01242797f, -0.00077045f, 
    0.02346039f, -0.03469830f, 0.00226174f, 0.00700358f, -0.00720413f, -0.02385944f, -0.02785338f, -0.01611651f, 
    0.01077277f, -0.02843971f, -0.03102221f, -0.03415409f, -0.04349555f, -0.01640981f, -0.02304352f, 0.00835076f, 
    0.01277595f, 0.01426578f, -0.00255197f, 0.00517551f, 0.00243087f, -0.03142350f, -0.00458644f, 0.01226824f, 
    0.00099851f, -0.02829208f, -0.02394040f, 0.01878800f, 0.02380093f, 0.00726306f, 0.00723763f, -0.00320578f, 
    -0.02667733f, 0.00642722f, -0.00516119f, -0.04079860f, -0.04130101f, -0.01745892f, -0.01311945f, -0.01221808f, 
    -0.02826416f, 0.01082527f, -0.03151267f, -0.01112834f, -0.00549382f, -0.01756504f, 0.00009608f, -0.02976258f, 
    0.00044349f, -0.00983772f, 0.01865992f, -0.00580193f, -0.03266435f, -0.00300160f, -0.00703804f, -0.02434935f, 
    -0.01990908f, -0.03990724f, -0.00264737f, 0.02613788f, -0.00823859f, 0.01634850f, 0.00278929f, 0.00100877f, 
    0.00782417f, 0.00665791f, 0.02343221f, 0.01056638f, 0.03215906f, -0.00301521f, -0.01101019f, 0.00837384f, 
    -0.00201671f, -0.00953064f, -0.04222041f, 0.03222519f, 0.00211572f, 0.02439277f, -0.02986617f, 0.01655208f, 
    0.00869030f, 0.01943062f, -0.02395509f, 0.01255024f, 0.00298211f, 0.01245655f, -0.03068845f, -0.00205800f, 
    -0.03073350f, -0.01772652f, 0.00168259f, -0.01977587f, 0.00028376f, -0.01344565f, -0.02863352f, 0.00509381f, 
    -0.00896473f, 0.02529871f, -0.01065314f, 0.00779984f, -0.02291759f, -0.00959548f, 0.00606534f, 0.01197951f, 
    -0.00443767f, 0.03081197f, -0.01015513f, -0.02623906f, -0.00997958f, -0.00690083f, -0.01112675f, -0.00040380f, 
    -0.03057943f, 0.00555179f, -0.00194532f, -0.03682242f, -0.03164246f, -0.00023443f, -0.02466517f, 0.03214935f, 
    -0.03673527f, -0.00629343f, 0.02273985f, 0.01283823f, -0.02769868f, -0.03357095f, 0.00334917f, -0.02234098f, 
    -0.01657698f, 0.01157148f, -0.04082214f, -0.03309081f, 0.00906367f, -0.01251448f, -0.03133739f, -0.03169610f, 
    -0.00163726f, -0.00170792f, 0.03060969f, -0.02823537f, 0.01700357f, 0.00368108f, 0.01647054f, -0.01509726f, 
    -0.03077805f, -0.02648359f, 0.01396176f, -0.01717107f, 0.01128929f, -0.02892510f, -0.02968137f, 0.03890055f, 
    0.01041614f, -0.00238932f, -0.01211528f, -0.00946511f, -0.00872795f, 0.01590378f, -0.00223243f, 0.03175125f, 
    -0.00046799f, -0.01920048f, 0.03610405f, -0.03321934f, 0.02911489f, 0.02233482f, -0.03822281f, 0.03296182f, 
    -0.00076795f, -0.01031679f, -0.02806035f, -0.01300855f, -0.00966090f, 0.01584345f, 0.02652787f, -0.01013982f, 
    0.01058737f, 0.01904796f, -0.01578283f, -0.03208089f, 0.00707167f, -0.04390182f, -0.00303128f, -0.01064419f, 
    0.02266966f, 0.02189235f, -0.01790914f, -0.02492050f, -0.00192602f, 0.01585589f, -0.03436403f, -0.01398720f, 
    0.03404752f, 0.02527880f, -0.02734056f, 0.01959998f, 0.00828582f, 0.02733254f, 0.02654768f, -0.03072093f, 
    0.01580036f, 0.01005473f, -0.00128278f, 0.00975036f, 0.01180275f, -0.01756641f, -0.02571193f, -0.01959063f, 
    0.01392329f, -0.03845555f, -0.00017478f, -0.02821050f, 0.02941826f, 0.02749266f, 0.02403180f, -0.02812534f, 
    -0.04041569f, 0.00438098f, 0.01602242f, 0.02043114f, 0.02157547f, -0.02555826f, -0.03427682f, 0.01687804f, 
    0.02455076f, 0.02244700f, 0.01481797f, 0.00862456f, -0.03120799f, -0.01159588f, -0.00702447f, -0.01165672f, 
    0.01098171f, -0.03036763f, -0.02614487f, -0.03335422f, -0.01059499f, 0.01623721f, -0.03560571f, -0.01900404f, 
    0.02901936f, 0.01974771f, 0.00516203f, 0.00539555f, -0.02613768f, 0.02475406f, -0.03588651f, -0.03391288f, 
    0.01383639f, 0.02328863f, 0.01613980f, 0.03620161f, -0.03480924f, 0.01730421f, -0.03727296f, 0.00929822f, 
    -0.02990092f, -0.02201252f, 0.00849863f, 0.02994638f, 0.03107744f, 0.00950767f, -0.02813901f, -0.02248931f, 
    -0.00882057f, -0.02576751f, 0.02659984f, -0.00349876f, -0.03573846f, -0.03337365f, 0.00716688f, 0.03665001f, 
    -0.00910373f, 0.00917353f, 0.02170862f, 0.01683819f, -0.01184156f, -0.00417872f, 0.00467488f, 0.02347969f, 
    0.00221667f, 0.01217457f, 0.01144745f, 0.00095281f, -0.00255785f, -0.03092004f, 0.01555716f, 0.02551465f, 
    -0.02991199f, -0.01413328f, -0.02305915f, 0.00733993f, 0.00740028f, 0.00631670f, -0.01281286f, 0.02089260f, 
    0.01337080f, -0.02836766f, -0.02941442f, 0.01210290f, 0.01656469f, -0.01997786f, 0.01922895f, -0.03754855f, 
    0.01863382f, -0.02851044f, 0.00114018f, -0.03190153f, -0.01748534f, -0.03768067f, 0.02008915f, -0.02809379f, 
    0.03152626f, -0.03177234f, 0.00653651f, 0.01203803f, -0.02241116f, 0.01953940f, -0.00781310f, -0.02239590f, 
    -0.01756961f, -0.02832191f, 0.00600721f, -0.03136181f, -0.03665378f, -0.01979666f, 0.01271084f, -0.00775946f, 
    0.03227758f, 0.01131730f, -0.01889551f, 0.01075721f, 0.00527990f, 0.02277165f, -0.01662033f, 0.02261020f, 
    -0.00683224f, 0.00568045f, 0.00262802f, -0.03034480f, 0.01755482f, -0.00518669f, -0.02659777f, -0.01636478f, 
    0.00034948f, -0.00446175f, -0.02053615f, 0.01107539f, 0.01818806f, 0.02044053f, -0.03493870f, -0.02738826f, 
    -0.00082427f, -0.03923378f, 0.01242505f, 0.02965557f, -0.03176614f, 0.01070646f, 0.01303737f, 0.00596184f, 
    -0.00627894f, 0.02013416f, -0.00042748f, 0.00825922f, 0.01697660f, -0.00169278f, 0.00741760f, 0.02458607f, 
    0.00475435f, -0.00007354f, -0.02350674f, 0.00590166f, 0.00270649f, 0.03534541f, 0.03601049f, 0.01073712f, 
    -0.01850303f, 0.01014648f, -0.03732505f, 0.00076454f, -0.00278631f, -0.02996529f, 0.00440207f, 0.00130369f, 
    -0.03175553f, -0.03331673f, -0.02891674f, 0.02090226f, -0.02108132f, 0.01206851f, 0.01247223f, -0.01804224f, 
    -0.03624094f, -0.01911017f, -0.01108889f, 0.00219413f, 0.01109556f, 0.02026889f, 0.00452313f, -0.00944508f, 
    -0.00029956f, -0.02595446f, -0.00693387f, -0.03690472f, 0.01653447f, -0.00317722f, -0.03332802f, -0.00971397f, 
    -0.02988757f, -0.00313215f, -0.03849063f, -0.02346077f, 0.00232780f, -0.00439499f, 0.00855449f, 0.00036137f, 
    -0.00337323f, -0.02694778f, -0.02061416f, 0.03599471f, -0.00803874f, 0.01363095f, 0.02890981f, 0.00005633f, 
    0.02448514f, -0.01707192f, -0.02446800f, -0.00926375f, -0.01086366f, 0.01095913f, -0.00541805f, -0.00174302f, 
    0.02600479f, 0.02802633f, -0.03933740f, 0.01066482f, 0.02034349f, -0.01918567f, -0.01465186f, -0.01334402f, 
    0.00451929f, 0.02721880f, -0.01354253f, -0.00420678f, 0.00698813f, -0.01805448f, -0.00734058f, -0.02856124f, 
    0.11570054f, -0.08978853f, 0.11281190f, -0.02729066f, -0.04770324f, -0.12202785f, 0.04709122f, -0.05266365f, 
    0.01718520f, 0.01047915f, -0.08042764f, 0.06011346f, -0.14748025f, -0.04553114f, -0.07098648f, 0.15994109f, 
    -0.06094524f, -0.02641711f, 0.04537980f, 0.07937022f, 0.12720996f, 0.08269455f, 0.05479144f, 0.17785208f, 
    0.05085801f, -0.03272794f, -0.00134761f, 0.00082823f, 0.05889734f, 0.05461461f, -0.00397076f, 0.06581853f, 
    -0.05012529f, -0.02736036f, 0.10666632f, -0.05039998f, -0.07432143f, 0.10420592f, -0.00079970f, 0.02116209f, 
    0.09559176f, 0.04715164f, 0.12062363f, 0.01478951f, 0.02785402f, -0.03183705f, 0.01210242f, 0.20452170f, 
    0.00344689f, 0.07055643f, -0.17148463f, -0.04831508f, -0.06381316f, 0.05726776f, -0.00475833f, 0.11112694f, 
    -0.07945479f, -0.00460022f, 0.00339712f, 0.01065964f, -0.08766903f, 0.04464914f, -0.06550760f, 0.07091483f, 
    -0.09003635f, 0.08382156f, 0.09447061f, 0.12689544f, 0.14614348f, 0.10574999f, 0.00406535f, -0.04540582f, 
    0.04048122f, 0.05894033f, 0.04943594f, -0.01947756f, -0.02202096f, 0.02513152f, 0.07849745f, 0.02641105f, 
    -0.00898663f, -0.05682222f, -0.12060049f, -0.06806970f, 0.15444158f, 0.12254284f, -0.04168065f, -0.04494216f, 
    -0.04336602f, -0.07608710f, 0.06684154f, 0.03519166f, 0.03507917f, 0.10262997f, 0.07109363f, 0.21337074f, 
    0.14588724f, 0.05392690f, -0.02160091f, 0.03833192f, -0.03867926f, -0.03128316f, -0.06473479f, 0.11365829f, 
    -0.15441200f, -0.07044815f, 0.17942727f, 0.11431660f, 0.25160849f, 0.04802457f, -0.11963995f, 0.04138986f, 
    0.06119981f, 0.00027793f, 0.03573167f, 0.06250926f, -0.01851846f, 0.04508364f, 0.07614251f, -0.08666304f, 
    0.19078548f, -0.02144799f, -0.05265410f, 0.04207987f, -0.02814624f, -0.12997808f, -0.02350441f, 0.03669641f, 
    -0.00625541f, -0.02640962f, -0.00909032f, -0.04106576f, 0.11245959f, -0.12270208f, 0.11323905f, 0.02090251f, 
    -0.01742837f, 0.01884147f, -0.01320229f, 0.02825266f, 0.12728478f, 0.01287568f, -0.04919048f, 0.00724552f, 
    -0.24192530f, -0.10882072f, -0.20677394f, 0.09139467f, 0.07007466f, -0.05895876f, -0.08433387f, 0.01039340f, 
    -0.05989189f, -0.05111879f, 0.05398975f, -0.05459709f, 0.19906451f, 0.17951848f, -0.08899827f, -0.11656375f, 
    0.01895763f, 0.03890244f, 0.01748235f, 0.03414784f, 0.01872519f, 0.01465703f, 0.06987520f, 0.04453195f, 
    0.10776169f, 0.06450374f, 0.05758596f, -0.03052603f, -0.00619627f, 0.06598509f, -0.10959849f, -0.02511947f, 
    0.01085227f, 0.08420159f, -0.04678206f, 0.09993972f, 0.10280485f, -0.01353252f, 0.00287924f, -0.16933750f, 
    0.08655834f, 0.07894877f, -0.13246495f, -0.04741774f, 0.04218277f, -0.09323078f, 0.04102191f, -0.08743005f, 
    0.12586187f, 0.16311942f, 0.07492488f, -0.07489767f, -0.09295146f, -0.07569519f, 0.05277104f, -0.02096611f, 
    0.00620613f, 0.01361676f, -0.06569517f, -0.03326886f, 0.25584179f, -0.14503713f, 0.00272309f, -0.03765382f, 
    -0.01698471f, -0.14448746f, 0.13771479f, 0.04585315f, -0.01615009f, -0.01541660f, -0.02734019f, 0.00074186f, 
    0.15541089f, -0.15734686f, -0.25064340f, -0.11688861f, 0.02952672f, 0.05003037f, 0.00732202f, 0.01183978f, 
    0.12457349f, -0.01736593f, -0.19392906f, -0.14376664f, -0.08843184f, -0.03583932f, -0.00390561f, 0.09373308f, 
    0.06487387f, -0.06640425f, -0.05301160f, 0.07415666f, -0.00290042f, 0.08032809f, -0.03138066f, 0.04820528f, 
    0.25381997f, 0.22090924f, 0.01955359f, 0.02743061f, 0.05987925f, 0.01358620f, -0.03074000f, 0.08444619f, 
    0.01610519f, 0.13520549f, 0.01064751f, 0.00791693f, 0.02814467f, 0.00441342f, -0.14244732f, 0.01117353f, 
    0.11720336f, 0.01052915f, 0.08965850f, -0.00033398f, -0.09777559f, -0.08696093f, 0.01244110f, 0.02225393f, 
    0.04795265f, -0.13555570f, -0.13925050f, 0.07727361f, -0.03229181f, -0.10007752f, 0.07406702f, -0.09672050f, 
    0.04435156f, -0.02641144f, -0.09611353f, -0.17530440f, 0.14673936f, 0.03299886f, -0.00826874f, -0.15135145f, 
    -0.05223058f, 0.11502630f, 0.02668282f, -0.09780447f, -0.00719692f, -0.06307694f, -0.04436637f, -0.07056691f, 
    0.12586884f, -0.25689524f, -0.16589288f, 0.02787609f, 0.25639918f, -0.12810874f, 0.01045870f, -0.07126766f, 
    0.00718425f, 0.16204350f, 0.02473538f, -0.03769390f, -0.07311363f, -0.33729640f, 0.00653345f, 0.20209630f, 
    0.07047545f, -0.03647600f, -0.02095310f, 0.09850691f, 0.02106121f, 0.12497143f, -0.05190684f, 0.14654730f, 
    0.11094142f, -0.21004622f, -0.14674892f, -0.10663123f, -0.06551336f, 0.02553816f, -0.03280156f, -0.04854299f, 
    0.04319189f, 0.06658933f, 0.05513370f, 0.08027633f, -0.05793541f, -0.05492198f, -0.03681951f, 0.01041067f, 
    0.02296303f, 0.06100186f, -0.02891934f, -0.05630851f, 0.04166839f, -0.04861564f, 0.10486618f, 0.01356687f, 
    0.16439304f, -0.00871987f, 0.05535768f, 0.10451470f, 0.03546150f, 0.14280318f, 0.05995825f, 0.01259703f, 
    0.00933277f, 0.14717886f, 0.04615842f, 0.11507876f, -0.22627218f, -0.04520256f, -0.01483133f, 0.02132993f, 
    0.05551523f, -0.00748254f, -0.10654852f, 0.04181097f, -0.15732594f, 0.11801232f, -0.03924315f, -0.02652855f, 
    -0.05743583f, 0.05277539f, -0.10984854f, -0.19268821f, 0.07308449f, 0.00392749f, 0.01343132f, -0.01985403f, 
    -0.00368543f, 0.03352366f, -0.03508801f, -0.02335491f, 0.08688908f, -0.03246054f, 0.08511470f, -0.03691985f, 
    0.01244339f, 0.09732595f, 0.05120108f, -0.03026349f, 0.05932487f, -0.05929691f, -0.10449565f, 0.02567100f, 
    0.01415133f, 0.05771723f, 0.14548929f, -0.01338843f, 0.06321153f, 0.04831042f, 0.09731632f, -0.06860235f, 
    0.02199443f, 0.03918307f, 0.05903422f, 0.03128625f, -0.05151831f, 0.03414785f, 0.07025556f, -0.19837072f, 
    0.07418644f, 0.00716871f, 0.13533060f, 0.04450966f, -0.03748049f, -0.01187155f, -0.16251706f, -0.03878467f, 
    0.22708535f, 0.11390559f, -0.00679500f, -0.05103086f, -0.00691915f, 0.03952908f, -0.05948550f, 0.04631237f, 
    0.04003379f, 0.06149888f, 0.01953245f, 0.04616296f, 0.19856380f, 0.07823009f, 0.09478065f, 0.06387880f, 
    0.03997292f, 0.05740362f, 0.00193829f, -0.05557770f, 0.15656696f, 0.02030141f, 0.02491145f, -0.04859776f, 
    0.30757573f, 0.00083089f, 0.01765380f, -0.00412291f, -0.00565149f, -0.02218571f, 0.09445066f, -0.03411496f, 
    0.00939351f, -0.00776132f, -0.12448595f, -0.03161893f, 0.14805277f, -0.10826210f, -0.16749880f, -0.09797758f, 
    -0.03353444f, -0.12157863f, -0.03379602f, 0.16315471f, -0.00420788f, -0.07773688f, -0.02260338f, 0.11793701f, 
    -0.10096281f, -0.21871568f, 0.08373283f, 0.21464005f, -0.03454807f, -0.01407531f, 0.08101498f, -0.01497769f, 
    0.00455929f, 0.09229072f, 0.05258739f, -0.05007182f, -0.21470474f, -0.08477181f, -0.18158428f, -0.01383400f, 
    0.01511271f, -0.03643684f, 0.00429853f, -0.01602501f, -0.10054071f, 0.04911276f, -0.01080358f, 0.08328459f, 
    0.35368645f, 0.06943199f, 0.12550312f, 0.03698782f, -0.05261688f, -0.06769076f, 0.06111743f, 0.03126618f, 
    -0.07489191f, 0.03184264f, -0.12378397f, -0.13350905f, 0.13601638f, -0.06044724f, -0.11925263f, -0.06052232f, 
    0.05075786f, -0.09836235f, -0.01347531f, 0.04214521f, 0.14482033f, -0.00768450f, 0.01725140f, 0.06429370f, 
    -0.12502548f, -0.06178750f, -0.16127256f, -0.09012759f, 0.13306785f, -0.04654956f, 0.08182488f, -0.06723281f, 
    0.05623389f, -0.08192100f, 0.00261047f, -0.04919390f, 0.22495785f, -0.22406057f, -0.05351150f, -0.03500698f, 
    0.06419882f, 0.04289662f, -0.03092397f, -0.08645200f, -0.01598012f, -0.00484268f, 0.01263599f, 0.08219600f, 
    0.08552817f, 0.05743337f, 0.10523245f, 0.04117213f, -0.06370206f, 0.00717779f, 0.04173163f, 0.03190017f, 
    -0.06094003f, -0.17093419f, -0.10723080f, -0.04098771f, 0.01365494f, 0.14721580f, 0.20451610f, -0.06117890f, 
    0.08690956f, -0.00417537f, 0.04291689f, 0.00534092f, -0.17720005f, 0.02046915f, -0.00599126f, 0.08718396f, 
    -0.06704929f, 0.08350435f, -0.02087351f, 0.10052776f, -0.05322462f, 0.05658569f, -0.01081626f, -0.16968343f, 
    -0.07944191f, -0.04032142f, 0.02043435f, 0.05840306f, -0.06561502f, 0.06487761f, 0.08287387f, 0.05452951f, 
    0.03004569f, 0.13431123f, 0.00138325f, -0.05696203f, 0.06757042f, 0.13181444f, -0.15578346f, 0.01418592f, 
    -0.13822024f, -0.07099271f, -0.11420124f, 0.01980720f, 0.06371338f, 0.14227459f, -0.02683274f, 0.03153885f, 
    0.00751405f, 0.03557571f, 0.03610721f, 0.07840327f, 0.13714263f, -0.05807974f, 0.02111032f, -0.08571491f, 
    0.00414914f, -0.18287478f, 0.05237242f, -0.03889974f, -0.03551390f, -0.05265795f, -0.00949766f, -0.08651809f, 
    -0.17306006f, 0.09892663f, -0.05112369f, -0.05959634f, 0.04247788f, -0.06981345f, 0.05997037f, -0.05352579f, 
    0.00985450f, 0.09205139f, -0.00814457f, -0.08352050f, 0.01548320f, 0.28979909f, 0.15922602f, -0.18017645f, 
    0.12321226f, 0.00675199f, 0.00179503f, 0.06312352f, -0.01545933f, -0.06092509f, 0.08145700f, 0.07981116f, 
    0.15163201f, -0.01697843f, -0.11136746f, 0.20524645f, -0.03175811f, -0.03835013f, -0.09735952f, 0.01293381f, 
    0.05803028f, 0.12239843f, -0.01889458f, -0.05814758f, 0.03610944f, 0.05437620f, 0.19198403f, 0.05354667f, 
    0.08219841f, -0.07817920f, 0.12227888f, -0.08075273f, -0.02743782f, 0.01896368f, 0.01115793f, -0.07020432f, 
    -0.07472530f, -0.18018344f, -0.17115594f, -0.00031109f, 0.04529119f, -0.02375726f, -0.07146560f, -0.06674656f, 
    0.11248171f, 0.06705295f, -0.04084028f, -0.03186741f, 0.16598468f, 0.12306815f, -0.10928005f, -0.10201711f, 
    0.08762813f, -0.10934710f, -0.10058778f, -0.06003902f, -0.06086193f, -0.07800266f, -0.12429596f, 0.09759478f, 
    0.04698817f, 0.13911125f, 0.13403471f, 0.04109676f, 0.05609398f, 0.03806087f, -0.01284448f, -0.11966143f, 
    -0.02648535f, 0.15063234f, 0.02449515f, -0.06854036f, -0.01516114f, 0.01530422f, -0.02866238f, -0.08427329f, 
    -0.05798147f, -0.10133629f, 0.05102535f, -0.03891680f, 0.05109287f, -0.06099746f, -0.04210051f, -0.12100539f, 
    -0.06190479f, 0.23719612f, 0.09800278f, 0.02716168f, 0.06093749f, -0.01367229f, -0.03475478f, 0.02932177f, 
    -0.03431079f, -0.01829102f, -0.07989977f, 0.01046016f, 0.23499206f, 0.08539245f, -0.15730126f, -0.10050155f, 
    0.01430603f, 0.02563746f, -0.06716422f, 0.02786499f, 0.03937955f, 0.11288349f, 0.02693076f, 0.14490122f, 
    0.09597804f, 0.09480558f, -0.02858159f, -0.05645948f, -0.01419950f, 0.03007632f, 0.00861069f, 0.03313955f, 
    0.04231795f, -0.01381116f, 0.13117440f, 0.01734710f, -0.00845928f, -0.21523272f, -0.01414508f, -0.16860613f, 
    -0.05047954f, -0.06964364f, -0.03862929f, 0.02334322f, 0.11308330f, 0.06962381f, 0.03215255f, 0.04456336f, 
    0.01873966f, -0.20773269f, -0.00196408f, -0.03419459f, 0.07268434f, -0.06724213f, 0.02075883f, -0.03647383f, 
    -0.03439388f, 0.07485703f, 0.02846159f, -0.04479486f, 0.11101951f, 0.26642722f, -0.10777133f, -0.01268542f, 
    0.05567053f, 0.06786535f, 0.05695881f, 0.02823821f, 0.08484742f, -0.03284977f, 0.03584862f, 0.03641517f, 
    -0.01731429f, 0.00674049f, -0.02606308f, -0.01125071f, -0.04086675f, 0.01516930f, -0.00810696f, -0.01360586f, 
    -0.03078924f, -0.03240333f, -0.02321206f, -0.01759455f, -0.04037815f, 0.01004759f, -0.00051852f, -0.00298629f, 
    0.01024690f, 0.00437741f, -0.00310503f, -0.01752277f, -0.02621662f, -0.00328915f, 0.02216454f, 0.01089772f, 
    0.00912988f, 0.02713794f, 0.01515976f, -0.01762264f, -0.02556678f, -0.03317683f, 0.02040919f, -0.03376573f, 
    0.00241892f, -0.03959912f, 0.02124721f, -0.01966357f, 0.00270319f, -0.00450531f, -0.03163179f, -0.02060299f, 
    0.00169489f, -0.01039383f, -0.02736130f, -0.00807644f, 0.03752582f, 0.00670835f, 0.00481104f, 0.01426690f, 
    0.01952106f, 0.01610058f, -0.02326396f, 0.01985857f, 0.02476850f, -0.01913247f, 0.02740707f, 0.01535390f, 
    -0.04004945f, -0.00218854f, -0.02475270f, -0.02839171f, 0.03529236f, -0.02346133f, 0.00064313f, -0.01820732f, 
    -0.01885405f, 0.02611919f, -0.03698248f, -0.01588967f, -0.03533971f, 0.02075385f, 0.00982266f, -0.01674859f, 
    -0.02082941f, -0.01639545f, 0.00380118f, 0.01196259f, 0.01949444f, 0.01498877f, 0.02621481f, 0.00141807f, 
    -0.01055875f, -0.03248287f, -0.02005989f, -0.00502761f, -0.01298942f, 0.02408991f, -0.02661191f, 0.00466149f, 
    0.00521135f, -0.01240590f, 0.01457481f, 0.02345140f, -0.02820918f, 0.00554075f, -0.00105113f, 0.01983728f, 
    -0.04109523f, -0.00312118f, -0.03928465f, -0.01390193f, -0.00885673f, 0.00940526f, -0.01258612f, -0.03943914f, 
    0.02823004f, -0.00292416f, 0.02632752f, 0.01353513f, 0.02850752f, -0.00304623f, 0.01356869f, -0.00817195f, 
    -0.01774818f, -0.00734911f, 0.00219370f, 0.02504122f, -0.00337034f, -0.02600221f, -0.00147185f, -0.02721221f, 
    -0.03321229f, -0.00909979f, -0.03336086f, -0.02961325f, -0.01504634f, 0.01002278f, -0.00502336f, -0.02941772f, 
    -0.01808417f, -0.00808463f, -0.00774207f, -0.00127137f, -0.02839785f, -0.00723839f, -0.00596123f, 0.00644188f, 
    -0.02409050f, -0.01771485f, 0.00383494f, -0.02843042f, 0.02136007f, 0.01294426f, 0.01654203f, -0.02299498f, 
    0.02885001f, 0.01226782f, -0.01645384f, -0.00242839f, -0.01792397f, -0.02015864f, -0.03427013f, -0.02915294f, 
    0.04081621f, -0.01111889f, -0.02438961f, 0.02741490f, 0.01082896f, -0.03450470f, -0.01679381f, -0.01367950f, 
    -0.01608598f, -0.01319425f, -0.00882668f, -0.01123423f, 0.01327890f, -0.02405766f, 0.01601661f, 0.00255685f, 
    0.02520531f, 0.02723594f, 0.00784569f, -0.00983772f, -0.02297604f, 0.02645595f, 0.01947897f, -0.00177846f, 
    0.01108695f, 0.01682552f, 0.02346643f, -0.00867570f, -0.01408223f, -0.02547063f, -0.03289960f, 0.02911337f, 
    -0.04088480f, 0.02836683f, -0.02575305f, -0.03849449f, 0.02468851f, -0.00940071f, -0.00312796f, -0.01834126f, 
    0.02404562f, 0.01860014f, -0.02604413f, 0.02739437f, -0.00882341f, 0.00676559f, -0.03800990f, -0.00399509f, 
    0.00181100f, 0.02440433f, -0.01033488f, 0.00032515f, 0.00367547f, 0.02723671f, -0.03819863f, -0.00788659f, 
    -0.01875953f, -0.02239673f, 0.01866240f, -0.02165348f, -0.03921400f, -0.04286998f, -0.00013499f, 0.01888781f, 
    -0.02819507f, 0.01859406f, 0.01307781f, -0.00327541f, 0.00867610f, -0.00040064f, -0.00515103f, 0.02305834f, 
    0.00007317f, -0.00488084f, -0.00583095f, 0.00156076f, -0.03204168f, -0.03387180f, -0.02402442f, -0.00318128f, 
    0.00113524f, 0.01419276f, 0.01480305f, 0.00479313f, 0.01103042f, 0.01642069f, 0.01875099f, -0.00954564f, 
    -0.02837672f, -0.01582877f, 0.02855588f, -0.02534447f, -0.02059211f, 0.02568734f, 0.04016745f, 0.02819816f, 
    0.00158402f, 0.01474661f, -0.04246092f, -0.03632722f, 0.03714527f, -0.02887447f, 0.00444374f, -0.01778117f, 
    0.02788316f, 0.02747621f, -0.01630586f, -0.02993522f, -0.00496540f, -0.00488903f, -0.01047864f, -0.01404515f, 
    0.02047704f, 0.00708467f, 0.01497329f, -0.00396278f, -0.03348367f, 0.01522986f, -0.00867987f, 0.00192085f, 
    0.01033341f, -0.04118612f, 0.00530986f, -0.01405757f, 0.00162817f, 0.02879810f, -0.02751163f, -0.02261928f, 
    -0.00704631f, -0.02850690f, 0.01715640f, -0.02027878f, -0.04163761f, -0.01460293f, -0.03330092f, -0.00533953f, 
    0.01729525f, -0.04226672f, 0.02204807f, 0.02219115f, -0.03403438f, -0.01327527f, -0.03447564f, -0.02270821f, 
    0.01178207f, -0.00771793f, 0.01275772f, -0.03170258f, -0.02366612f, -0.01984642f, 0.01268726f, -0.01100370f, 
    -0.01895105f, -0.00472070f, -0.02775149f, -0.01656377f, 0.04006002f, 0.02096883f, 0.00470408f, 0.02052964f, 
    -0.00756916f, -0.00284032f, 0.00968512f, 0.00861101f, -0.01113175f, -0.03676146f, 0.01298215f, -0.00357925f, 
    0.00981713f, 0.01792716f, -0.04211260f, -0.02244411f, -0.00047373f, -0.01491119f, 0.02336899f, -0.03087903f, 
    0.01975340f, -0.01372708f, 0.01910117f, -0.01147932f, 0.02545323f, -0.02806534f, -0.00624860f, 0.02438300f, 
    0.00027442f, 0.01473937f, -0.02117009f, -0.00312114f, -0.00434496f, 0.01718102f, -0.04222587f, 0.01311103f, 
    -0.02284001f, 0.00444501f, -0.01374974f, -0.02628124f, -0.00722243f, -0.03955278f, 0.02373450f, 0.00819795f, 
    -0.00629391f, 0.01456518f, -0.03217279f, 0.01755506f, 0.02247506f, 0.02209192f, 0.00984245f, -0.03320592f, 
    -0.02462198f, 0.01752555f, 0.02803800f, -0.03638383f, -0.01340752f, 0.00791772f, -0.00613009f, 0.00263929f, 
    -0.01457832f, 0.00592024f, 0.01946486f, -0.00700764f, 0.00724867f, 0.02095476f, -0.01195861f, -0.00350157f, 
    -0.03041293f, -0.03594623f, 0.00875593f, -0.00393814f, 0.01248002f, 0.01167755f, 0.00585236f, -0.01798552f, 
    0.01708309f, -0.03349450f, -0.01253132f, 0.00033181f, 0.00133541f, 0.00330587f, -0.01008867f, 0.02622556f, 
    -0.03042242f, -0.00991381f, -0.02104571f, 0.00552761f, -0.03611141f, -0.01798787f, -0.01280965f, -0.00444414f, 
    0.00348299f, 0.03641342f, -0.00998971f, -0.01036659f, 0.00227779f, -0.02970088f, -0.04082606f, -0.03073091f, 
    0.00561252f, -0.02700356f, 0.00444902f, -0.00483165f, 0.01753606f, -0.02730758f, 0.02531841f, -0.01354322f, 
    0.00735131f, 0.02965466f, -0.00472836f, 0.00586900f, -0.02320731f, 0.00247096f, -0.01731270f, -0.03884126f, 
    -0.01724046f, -0.00010080f, -0.01475299f, -0.02841657f, -0.00336850f, -0.02056092f, -0.02936588f, 0.02603000f, 
    0.00230142f, -0.02547846f, 0.02154260f, 0.01125021f, -0.01309726f, -0.01198596f, -0.02005869f, -0.02621624f, 
    0.02658891f, -0.01474607f, -0.01336474f, -0.00560860f, 0.00767007f, -0.00773778f, 0.02853495f, -0.00775527f, 
    -0.02669531f, -0.01152438f, 0.02414482f, 0.02202992f, -0.02679464f, -0.03287383f, 0.03042658f, 0.00921581f, 
    -0.00573734f, 0.00458487f, 0.00266166f, -0.02149836f, -0.02492958f, 0.02458105f, -0.03774132f, -0.02047593f, 
    -0.00598092f, -0.01547761f, -0.00793826f, -0.01580473f, -0.03568291f, -0.04106991f, 0.01334791f, 0.01123609f, 
    0.01880578f, -0.04211562f, -0.04297511f, -0.03236007f, -0.02647188f, -0.01599922f, 0.00878546f, 0.02129176f, 
    0.02833623f, -0.00465083f, -0.00828155f, -0.02412292f, -0.02306224f, 0.00409436f, -0.02343150f, -0.01196431f, 
    0.01389455f, 0.00486288f, 0.00364042f, 0.01118515f, 0.00776794f, 0.02707503f, -0.02979083f, -0.01576430f, 
    -0.03440011f, 0.00889608f, -0.04146646f, 0.01522283f, -0.02702617f, 0.01669569f, -0.02452463f, -0.01781471f, 
    -0.03824995f, -0.00967210f, -0.04236431f, -0.03694628f, -0.02517820f, -0.02926754f, -0.01048303f, -0.04003084f, 
    0.01723502f, 0.02163859f, 0.02551979f, 0.02541158f, -0.00762454f, -0.04116324f, -0.00708932f, 0.02270345f, 
    -0.04120294f, -0.02571294f, -0.01962646f, 0.02205354f, -0.02095316f, -0.01858741f, 0.03188778f, -0.00528217f, 
    -0.03825496f, 0.01861463f, -0.00736926f, -0.02918462f, 0.00660750f, -0.02583655f, 0.01011840f, 0.02389968f, 
    -0.01236765f, -0.01690994f, 0.00015265f, 0.00477207f, -0.03982342f, 0.01666835f, -0.04059311f, -0.01532404f, 
    0.02331602f, -0.03601990f, -0.02954938f, 0.01776196f, -0.00804237f, -0.02527845f, -0.02506138f, 0.01360344f, 
    -0.00044023f, -0.03361532f, 0.02032027f, -0.04126388f, -0.00749777f, 0.01539830f, -0.03913285f, -0.00900338f, 
    -0.03447116f, -0.02111703f, 0.02769316f, 0.01605067f, -0.01416174f, 0.00914676f, -0.03607007f, 0.01259965f, 
    0.01691025f, 0.01245883f, 0.00616020f, 0.01192288f, -0.02497916f, 0.02844634f, 0.02522456f, -0.01261505f, 
    0.00403498f, -0.02214782f, -0.02543690f, 0.00068982f, 0.00881472f, -0.01577992f, 0.00977838f, 0.00697611f, 
    -0.03910951f, -0.04215556f, 0.02406845f, 0.01660186f, 0.01167326f, -0.03619355f, -0.01596081f, 0.00663650f, 
    -0.01732258f, 0.02521503f, 0.02977256f, -0.01355600f, 0.01276726f, -0.00261912f, 0.01399900f, -0.02946760f, 
    0.00380786f, 0.00907431f, 0.02066734f, -0.01354438f, -0.03050754f, -0.02676648f, -0.04215259f, -0.04226196f, 
    -0.03321240f, -0.03385635f, -0.03716226f, -0.02607182f, -0.00246768f, 0.00984257f, -0.03219622f, 0.01181309f, 
    0.01765833f, 0.02760706f, -0.01177961f, -0.03701905f, 0.01860265f, 0.02261935f, -0.01806777f, -0.02349150f, 
    -0.00283698f, -0.02740664f, -0.02510464f, 0.02664888f, -0.01996785f, 0.03048007f, 0.02342049f, 0.00689339f, 
    0.01572215f, 0.02884866f, 0.02086207f, 0.01191961f, 0.03187725f, -0.04070076f, 0.00979127f, 0.02919295f, 
    0.02720390f, 0.02370216f, -0.03392465f, -0.01808255f, 0.01110932f, -0.01819694f, -0.04247181f, -0.01602982f, 
    -0.01060354f, 0.02013510f, -0.02018709f, 0.01574203f, -0.00511542f, 0.00751397f, 0.00244610f, 0.02300216f, 
    -0.01930766f, -0.01536381f, -0.01141714f, -0.03293709f, -0.00815447f, -0.03209328f, 0.00624764f, 0.01599721f, 
    -0.01882702f, -0.01570351f, -0.03864435f, -0.03680972f, -0.04169020f, 0.02103942f, -0.00830888f, 0.00264069f, 
    0.00554984f, -0.02165848f, -0.00607811f, -0.01508709f, -0.02536151f, 0.00130534f, -0.01957759f, 0.01632173f, 
    -0.04173072f, 0.00996411f, 0.02397764f, 0.00063659f, 0.02741319f, -0.03517461f, -0.01509066f, -0.02002268f, 
    -0.03134055f, -0.02870628f, -0.01154593f, -0.02352403f, 0.02034292f, -0.00181644f, -0.01034607f, 0.02616088f, 
    -0.00496942f, 0.00583515f, -0.03059732f, -0.01387282f, 0.02156177f, 0.00818341f, -0.03133746f, 0.02796120f, 
    0.01764929f, -0.02054185f, 0.01904616f, 0.00526375f, 0.00103476f, -0.02248992f, -0.00182638f, -0.01792320f, 
    -0.02894208f, 0.02654335f, 0.03897418f, -0.02786057f, -0.03875648f, 0.01671787f, -0.01867554f, -0.03878648f, 
    -0.00697800f, 0.01367133f, 0.02804939f, -0.03605121f, 0.00424514f, -0.03453072f, 0.00911169f, -0.01660643f, 
    -0.00845311f, -0.01747918f, 0.01384287f, -0.00701311f, 0.01397019f, -0.00406810f, -0.04080528f, 0.02496004f, 
    -0.02909345f, -0.01807923f, -0.02024104f, -0.03134250f, 0.03309046f, -0.02373463f, -0.03493926f, -0.01741889f, 
    -0.01140028f, -0.02941979f, -0.02670088f, 0.00122139f, 0.01527172f, -0.03700864f, -0.00325687f, 0.02559283f, 
    0.02041012f, 0.03809543f, -0.01143540f, -0.03270448f, -0.04292113f, -0.02548728f, 0.00724059f, -0.02023289f, 
    -0.00160683f, -0.04087131f, -0.02776812f, 0.00216433f, 0.01837620f, 0.01006272f, -0.00799761f, -0.00826792f, 
    -0.23644039f, 0.11576544f, 0.12272765f, 0.01119327f, 0.10503742f, -0.07959876f, -0.05257357f, 0.07401390f, 
    0.07369801f, 0.07838731f, -0.04243588f, 0.08546506f, 0.06763161f, 0.04955522f, -0.11429450f, -0.09230439f, 
    0.04559348f, -0.00578429f, 0.03851351f, 0.07625574f, -0.01294432f, -0.03131681f, 0.00777965f, 0.13235626f, 
    0.01148320f, -0.17156653f, 0.09110291f, -0.04795749f, 0.03520649f, -0.03725032f, -0.06864934f, -0.16782883f, 
    -0.10574666f, 0.04120938f, 0.19314586f, -0.01655614f, 0.20764308f, 0.06235899f, 0.05816192f, -0.03066180f, 
    0.07925153f, 0.12644273f, 0.05676588f, -0.03099553f, 0.03759288f, 0.03750178f, 0.12474289f, 0.14743130f, 
    0.27829215f, -0.18178749f, -0.08526358f, 0.18392937f, -0.05374306f, 0.00741653f, -0.02098813f, 0.13287379f, 
    0.06291443f, -0.03577769f, 0.05848352f, 0.08176200f, 0.09257764f, 0.03587253f, -0.20583564f, -0.03292946f, 
    -0.01773961f, -0.05587909f, 0.03569479f, 0.02701273f, -0.03769564f, 0.04531112f, -0.02643968f, 0.01801349f, 
    -0.28076476f, -0.01990873f, 0.05344005f, 0.19025441f, 0.02855894f, -0.03113664f, 0.03757013f, 0.01783370f, 
    0.07051244f, 0.05476465f, 0.00979337f, -0.04027095f, 0.01683549f, 0.06170810f, -0.02447903f, -0.13964342f, 
    -0.05671601f, -0.09254581f, 0.01909593f, 0.09930266f, 0.04854761f, 0.11281432f, 0.03553030f, 0.14209269f, 
    0.03878320f, 0.11173345f, 0.06051172f, 0.05041272f, -0.01517167f, -0.00618987f, -0.04892017f, -0.05571821f, 
    -0.08622266f, -0.01871453f, 0.17039697f, 0.01674123f, 0.04408263f, -0.38534233f, 0.08079227f, 0.16735199f, 
    0.02589932f, 0.07677470f, 0.00280226f, 0.11328311f, 0.00390406f, -0.01388662f, 0.03874647f, 0.01348359f, 
    0.10495968f, -0.01078856f, -0.08226812f, 0.22695088f, 0.14146382f, -0.06131170f, -0.07457628f, -0.06911663f, 
    -0.02949719f, 0.08799171f, -0.00840711f, -0.02677720f, -0.09005737f, -0.07713440f, 0.19652995f, 0.14799301f, 
    0.03540726f, 0.13840154f, -0.10250357f, -0.14358467f, -0.00587581f, 0.09705500f, -0.04291482f, -0.02402095f, 
    -0.16576479f, 0.12501721f, -0.15500994f, -0.35469800f, 0.12502147f, 0.01572264f, 0.02203274f, -0.01793247f, 
    0.06198891f, -0.11795063f, 0.07523171f, 0.07009572f, 0.38951829f, -0.06982516f, 0.05275364f, -0.16976683f, 
    0.15342072f, -0.01253142f, 0.04719361f, 0.05274557f, -0.01833889f, 0.00584238f, 0.05571850f, -0.06668890f, 
    0.19537419f, -0.06029840f, 0.13933045f, -0.01725337f, -0.01666792f, 0.09206617f, 0.20631310f, -0.11253169f, 
    0.02147414f, 0.01883727f, -0.04514716f, 0.05006888f, 0.29108053f, 0.03301172f, 0.05739124f, -0.05958722f, 
    0.17559713f, 0.11139537f, -0.07155804f, -0.07461361f, 0.03885749f, -0.04703257f, -0.00928941f, -0.04941646f, 
    0.03835144f, -0.01158782f, 0.09805413f, 0.06519625f, 0.04627536f, -0.04860150f, -0.02804787f, -0.01612836f, 
    0.10276703f, 0.17193724f, 0.12340720f, -0.00712408f, -0.08168874f, 0.29797944f, -0.05143499f, 0.12919930f, 
    -0.09905896f, -0.12338359f, -0.11313128f, 0.07337783f, 0.14436983f, -0.05863279f, -0.03646152f, 0.00594944f, 
    -0.00851417f, 0.11577824f, -0.02209225f, -0.13306578f, 0.02241539f, 0.06209958f, 0.01311147f, -0.08936429f, 
    0.07658241f, -0.04993710f, -0.05709748f, -0.00676058f, 0.08483048f, -0.04994665f, 0.12861603f, -0.09801389f, 
    0.09060566f, -0.17644185f, -0.04363094f, 0.02687064f, -0.06071682f, 0.01175435f, -0.01321694f, 0.03773435f, 
    0.24638861f, -0.35048085f, 0.07037351f, -0.00093588f, -0.04810067f, -0.00610590f, 0.02349027f, 0.04961034f, 
    -0.04509530f, 0.04541080f, 0.04659811f, -0.06601168f, 0.14436989f, -0.13492183f, -0.07321562f, -0.02614533f, 
    0.15484849f, -0.00545682f, 0.01544528f, 0.04999079f, -0.12455044f, -0.08533470f, 0.07353838f, 0.02549744f, 
    -0.04709872f, 0.07552373f, -0.23783225f, 0.02962099f, 0.07574894f, -0.05929605f, 0.13847202f, -0.16971794f, 
    -0.01558866f, -0.01982999f, 0.07210199f, -0.01773402f, 0.23179336f, -0.09063832f, -0.06339338f, 0.18067180f, 
    0.03240525f, -0.00924151f, 0.02119796f, 0.10576170f, 0.07665434f, 0.04241731f, -0.01359213f, 0.04176780f, 
    -0.33033386f, 0.25575688f, -0.12507568f, -0.25529489f, 0.27195281f, 0.00419042f, 0.01601241f, -0.06540006f, 
    -0.00307265f, 0.04236752f, 0.05100018f, -0.07281643f, -0.53600854f, 0.15906984f, 0.06635698f, -0.28508118f, 
    0.08191814f, -0.00276824f, -0.02472713f, -0.12725517f, -0.08681900f, -0.00187790f, -0.05794382f, 0.15481499f, 
    0.27918226f, -0.13651755f, 0.00378637f, 0.03840142f, 0.08722667f, 0.11209778f, -0.00532333f, -0.02849820f, 
    0.03207449f, -0.09204312f, 0.07183035f, 0.15576409f, -0.08466180f, 0.04780401f, 0.06105372f, -0.10495103f, 
    0.11990894f, 0.03926999f, 0.04570929f, -0.06303256f, -0.06458945f, -0.09673092f, 0.08396257f, 0.06188975f, 
    0.15386309f, 0.00285027f, -0.05405367f, -0.13072219f, 0.16726719f, 0.14416380f, 0.04637558f, -0.02449968f, 
    -0.00793061f, -0.03402464f, 0.02550242f, 0.05835111f, -0.07918023f, -0.05308426f, 0.07987997f, -0.09432392f, 
    -0.02877692f, -0.05701869f, -0.00661927f, -0.11239964f, -0.00123035f, 0.06104664f, 0.11724494f, 0.03557547f, 
    0.00286906f, 0.01605284f, -0.01663494f, 0.25534806f, 0.14471151f, 0.12716432f, -0.00476839f, 0.05348634f, 
    -0.03283652f, 0.00727185f, -0.02346025f, 0.03504473f, -0.21844007f, 0.06581462f, -0.04359385f, -0.07188747f, 
    0.04124010f, 0.16062982f, -0.00809241f, 0.04126757f, -0.06316859f, 0.00182553f, -0.11392568f, 0.06600487f, 
    -0.13251425f, 0.18140870f, 0.17180641f, 0.16270471f, 0.03947685f, 0.09532902f, -0.06881095f, 0.00393759f, 
    0.09944732f, 0.09348840f, -0.09536825f, -0.00233325f, -0.00396498f, -0.04674084f, -0.02849379f, 0.18568665f, 
    0.01835792f, 0.07239079f, -0.03046854f, 0.16165139f, -0.00396858f, 0.01044977f, -0.09669050f, 0.06049962f, 
    -0.35203534f, -0.03949405f, 0.01560978f, 0.13472162f, -0.01038975f, -0.01667096f, -0.02146763f, 0.05386245f, 
    -0.05310122f, 0.03790163f, 0.01662761f, 0.02711597f, -0.15870236f, -0.04481646f, 0.05120056f, 0.20256971f, 
    0.02483305f, -0.00780585f, 0.00497479f, -0.12610848f, 0.05927079f, -0.01127076f, 0.07268614f, 0.07064842f, 
    -0.06650563f, -0.03224257f, -0.08594117f, -0.03864592f, 0.04772912f, -0.03467112f, -0.03027606f, -0.11199840f, 
    0.02768452f, -0.02926354f, -0.03285505f, 0.06375608f, 0.00606131f, -0.14756720f, -0.08365408f, -0.24661247f, 
    0.03211540f, 0.12601945f, 0.02306708f, -0.02803540f, -0.03642635f, -0.02169608f, 0.04486494f, 0.11653855f, 
    -0.00650996f, 0.03569404f, -0.31312534f, 0.32959780f, 0.08969938f, 0.17261177f, 0.08767552f, 0.08552174f, 
    -0.11948144f, -0.01597542f, 0.01251534f, 0.07158075f, -0.12301089f, -0.16905943f, -0.00758100f, -0.08686500f, 
    0.09170296f, 0.05776665f, 0.06547027f, -0.03768223f, -0.00282464f, -0.02500365f, 0.04846806f, -0.01313258f, 
    0.04912823f, 0.06343854f, -0.06957541f, 0.11902423f, 0.01167551f, 0.08198591f, -0.06305064f, -0.03470213f, 
    -0.13877161f, 0.07309330f, -0.01354934f, -0.14063619f, 0.00497371f, 0.07673857f, 0.04549293f, -0.01818650f, 
    0.13516447f, -0.03290183f, 0.12637040f, 0.02726581f, 0.08638577f, 0.00059273f, 0.02841507f, 0.05730747f, 
    -0.12511677f, -0.18060753f, -0.08491658f, 0.14659464f, 0.09934452f, -0.01891502f, 0.02733773f, 0.05134759f, 
    0.00258605f, -0.06150281f, 0.02761113f, -0.06130442f, -0.04996074f, 0.16460979f, -0.08113186f, -0.10229956f, 
    0.21540706f, 0.06215538f, -0.06772932f, -0.12029520f, -0.04713460f, -0.03452974f, 0.03112859f, 0.03714356f, 
    -0.32363826f, -0.09162880f, 0.03568325f, 0.02105344f, -0.02117808f, 0.02237880f, 0.00629866f, 0.04688055f, 
    -0.01751638f, -0.05153783f, 0.01226531f, 0.02223987f, -0.12326645f, 0.24422814f, 0.09377669f, 0.37838817f, 
    0.06271372f, 0.09192446f, -0.11836854f, 0.06895639f, 0.08936677f, 0.10569659f, 0.00511929f, 0.12866971f, 
    0.26644254f, 0.07239724f, -0.03707156f, -0.01216191f, 0.03056982f, -0.00922033f, -0.15396900f, 0.14133896f, 
    0.02331745f, -0.03391780f, 0.09530322f, -0.01671157f, -0.14734320f, -0.12325589f, -0.02980022f, 0.12895632f, 
    0.00891041f, -0.00678953f, -0.07816677f, 0.02476073f, -0.00802357f, -0.02465684f, -0.00616191f, 0.02546496f, 
    0.00909428f, -0.25832582f, -0.13427292f, -0.16963740f, 0.02929923f, 0.07306359f, 0.03073743f, 0.07796719f, 
    -0.01267303f, 0.02316838f, -0.00209466f, 0.03388282f, 0.02328516f, -0.01312393f, 0.00420067f, -0.12350600f, 
    0.02630475f, -0.01754886f, 0.04449303f, 0.02985870f, -0.05095986f, -0.06055499f, -0.00783376f, -0.08224955f, 
    -0.03652595f, -0.02687304f, -0.11885197f, 0.23544030f, -0.03667457f, 0.02445286f, -0.07902929f, 0.12527719f, 
    0.11261791f, 0.03003830f, -0.00424430f, 0.04155338f, 0.20941013f, 0.30286503f, -0.10405345f, -0.01642794f, 
    0.04673584f, -0.02596679f, 0.04970396f, 0.04337146f, 0.03949141f, -0.01287876f, -0.05862844f, 0.13122413f, 
    0.27516508f, 0.07561327f, 0.04989871f, -0.14744513f, 0.13697891f, -0.00857734f, 0.01160529f, 0.04793097f, 
    0.07175558f, 0.02514616f, 0.12012704f, -0.03997156f, -0.02394993f, 0.37362349f, -0.07993951f, 0.26786798f, 
    0.06041805f, -0.04834767f, -0.06662859f, 0.07846380f, 0.06507429f, 0.07138469f, -0.03862318f, -0.01097971f, 
    -0.17146581f, -0.06061731f, 0.15561825f, -0.35689268f, 0.23160194f, 0.04124742f, -0.07734454f, 0.01875135f, 
    0.03389406f, 0.02668675f, 0.04261866f, -0.05117226f, 0.34942213f, 0.19654092f, -0.01966556f, 0.10636349f, 
    0.03704872f, 0.03535932f, 0.00901124f, -0.11729339f, -0.02505607f, 0.00605976f, -0.05968403f, 0.12221354f, 
    0.22622453f, 0.05519782f, 0.17592786f, 0.15251389f, -0.06309865f, -0.04264035f, 0.11372244f, -0.11366105f, 
    -0.04610696f, 0.04288222f, 0.03522168f, 0.00142185f, -0.12935643f, -0.00187458f, -0.19130486f, 0.06170899f, 
    0.13281727f, 0.10723825f, 0.08275998f, 0.05317298f, 0.05423673f, 0.02125083f, 0.01189470f, -0.00203245f, 
    0.22584036f, 0.01971740f, -0.04939921f, 0.21740617f, 0.01963061f, 0.04224794f, 0.04460238f, -0.02249983f, 
    0.04531853f, -0.00654173f, 0.07498872f, -0.01190841f, 0.47544885f, -0.24794441f, -0.00044264f, 0.19004820f, 
    0.13282821f, -0.04455723f, -0.15040039f, -0.04117110f, -0.14822148f, 0.12035166f, 0.06140971f, 0.15145612f, 
    0.23256226f, -0.17848164f, -0.06909157f, -0.03246872f, -0.12225195f, 0.00627467f, 0.02488548f, 0.01869620f, 
    -0.06362339f, 0.03906392f, 0.14997490f, 0.05088535f, -0.11253092f, 0.10575152f, 0.29833597f, 0.02972070f, 
    0.07475003f, 0.10415845f, -0.00866837f, -0.08403920f, -0.05752454f, -0.01143540f, 0.10200404f, -0.07598923f, 
    -0.39576051f, 0.11261667f, -0.22092158f, -0.17208342f, 0.19877087f, 0.04188509f, 0.02013407f, -0.04271807f, 
    -0.10687475f, -0.00715505f, 0.06369589f, -0.04738005f, 0.28770947f, -0.09034558f, -0.15216966f, -0.01158979f, 
    -0.00150862f, -0.03252855f, 0.01275656f, 0.00905620f, -0.08143295f, -0.04638242f, 0.08671351f, 0.10061845f, 
    -0.00067124f, -0.02967732f, -0.00251267f, -0.01904204f, -0.00347288f, 0.02863164f, -0.02165095f, -0.01979725f, 
    -0.01767431f, -0.00391751f, 0.02513528f, 0.02149524f, -0.03104190f, 0.00209549f, -0.02436611f, -0.02977724f, 
    -0.04176366f, 0.01445579f, 0.03082445f, 0.02387158f, -0.01311047f, 0.01801731f, -0.03317687f, -0.01746280f, 
    -0.03573717f, 0.00923289f, 0.00600092f, -0.02394727f, -0.00819913f, -0.03143075f, 0.02098855f, -0.03672542f, 
    -0.04009105f, -0.02663228f, -0.00665060f, -0.01293112f, -0.02015034f, -0.02870450f, -0.03254416f, 0.02323033f, 
    -0.01938923f, -0.01956363f, 0.00378790f, 0.00104645f, -0.02077831f, -0.00701771f, 0.02490231f, 0.01930504f, 
    0.00028979f, 0.00826016f, -0.00199781f, 0.02391559f, 0.00210970f, -0.01376718f, -0.00685886f, -0.00645929f, 
    -0.01833730f, -0.02933278f, -0.02866165f, -0.03014437f, 0.01141137f, 0.00105119f, 0.01122485f, 0.00707867f, 
    0.00327366f, -0.01988659f, 0.00306948f, 0.00034524f, -0.00554279f, -0.01374521f, -0.00396780f, -0.03436599f, 
    0.02917605f, -0.00009770f, 0.02936588f, 0.01451028f, -0.02245578f, 0.01839208f, -0.01100267f, -0.04494880f, 
    -0.01656275f, 0.00029568f, -0.01041265f, 0.00198031f, -0.01853515f, 0.01948457f, 0.01397102f, -0.03113393f, 
    -0.00894619f, -0.01801726f, 0.00935131f, 0.00729948f, 0.00643624f, 0.01978743f, 0.00906349f, -0.02276004f, 
    -0.04203831f, -0.00883030f, 0.00294301f, 0.02118649f, 0.00838118f, -0.02491023f, 0.02309157f, -0.00638067f, 
    -0.01060165f, -0.00776645f, 0.02302683f, -0.00874398f, -0.01232481f, -0.01226197f, -0.00708680f, 0.01968410f, 
    0.00081273f, 0.01778855f, 0.00851932f, 0.02439401f, -0.04254325f, -0.01778386f, 0.00274800f, -0.03018107f, 
    0.01850161f, -0.02706805f, 0.01011690f, -0.00249090f, 0.01343153f, -0.01930093f, 0.00413892f, -0.04089454f, 
    -0.01229769f, 0.02700840f, 0.00940469f, -0.04052041f, -0.02852816f, -0.03126844f, 0.02790632f, 0.02469640f, 
    -0.01498366f, -0.04495247f, -0.03333985f, 0.00717998f, 0.00116112f, 0.01406640f, -0.02072054f, -0.01981897f, 
    0.01619083f, -0.00175965f, -0.01009036f, 0.01105320f, -0.00506460f, -0.01247097f, -0.02621743f, 0.00264846f, 
    0.00981191f, 0.01447994f, -0.01421182f, -0.01264635f, 0.00395775f, -0.02030294f, -0.02935531f, -0.01218760f, 
    0.01135663f, -0.01370996f, 0.03343391f, 0.03163641f, -0.00312447f, -0.04093961f, 0.02251382f, -0.03267235f, 
    0.01130602f, 0.00087487f, -0.01364374f, 0.02884288f, -0.01620609f, -0.00580717f, -0.02017799f, -0.01164890f, 
    -0.00104886f, -0.00215931f, 0.02813897f, 0.01828204f, 0.01735610f, -0.01629961f, 0.02881647f, 0.03190283f, 
    -0.01760489f, -0.01837995f, -0.03201025f, -0.03160525f, -0.00061278f, 0.00584886f, -0.00898191f, 0.01464194f, 
    -0.02381465f, -0.02507983f, -0.04676519f, 0.00614722f, 0.00004257f, 0.00337465f, -0.01982659f, -0.01314095f, 
    -0.01895150f, -0.00496576f, -0.03539216f, -0.01344012f, -0.03269554f, -0.02611231f, -0.03695200f, 0.00981322f, 
    0.00779011f, -0.04011177f, 0.00168481f, 0.03281645f, -0.00165810f, -0.00131045f, 0.00880632f, -0.03984848f, 
    -0.00831395f, 0.00769194f, -0.01342141f, 0.00602794f, -0.02667165f, 0.01650515f, 0.00374286f, 0.00476017f, 
    -0.03008204f, -0.00805209f, 0.01552399f, 0.02937727f, -0.00582275f, 0.00285311f, -0.01322842f, 0.00105970f, 
    0.01183088f, -0.01721703f, -0.02556285f, 0.01246130f, -0.03149807f, -0.04122318f, -0.00945710f, -0.03751538f, 
    -0.00428467f, 0.02046500f, -0.01469607f, -0.00933534f, -0.02094097f, -0.00695404f, -0.04263559f, -0.00382611f, 
    -0.01397840f, -0.03974919f, -0.01614834f, 0.03035668f, -0.04234312f, 0.01652622f, -0.02062239f, -0.01874004f, 
    0.01310861f, 0.01863082f, 0.00928412f, 0.03349455f, -0.02660079f, -0.02465798f, -0.00167202f, 0.01031276f, 
    -0.01235944f, -0.04370421f, -0.03274087f, 0.02816699f, -0.03262815f, -0.01096812f, -0.00236799f, 0.01763941f, 
    -0.03181865f, 0.00136327f, -0.00624014f, -0.03067594f, -0.03156721f, -0.03596674f, -0.00868623f, -0.00379564f, 
    -0.03025096f, 0.02790602f, -0.00887257f, 0.00022762f, -0.03856967f, -0.02799052f, -0.03439369f, 0.00182444f, 
    0.02414241f, -0.03818760f, -0.01998298f, 0.01194117f, -0.01361123f, -0.03671488f, -0.03882620f, -0.01226045f, 
    0.00578247f, 0.00484773f, -0.03559428f, -0.01564696f, 0.00633979f, -0.02628827f, 0.00827476f, 0.02218768f, 
    -0.03728721f, -0.00077227f, -0.01190788f, 0.00201102f, -0.02624245f, 0.02489798f, -0.01656508f, -0.04183692f, 
    -0.00893090f, -0.02767019f, 0.01937338f, -0.00867830f, 0.00771013f, 0.00096854f, 0.01516862f, 0.03417853f, 
    0.02242510f, -0.03715893f, -0.04109299f, -0.02735968f, 0.03113966f, 0.01662581f, 0.02183138f, -0.01486163f, 
    -0.00433160f, 0.02041496f, 0.00132904f, -0.02871131f, 0.01174647f, -0.01679748f, -0.01585121f, 0.01524046f, 
    0.02383050f, 0.00753892f, -0.02275712f, -0.03312067f, -0.00917872f, -0.00924616f, -0.00132574f, -0.00270287f, 
    0.03425404f, -0.00121700f, -0.03673231f, -0.01515821f, -0.02490262f, -0.02688015f, 0.02026410f, -0.01381551f, 
    -0.00745020f, 0.02498587f, -0.00862793f, -0.00279382f, 0.00165884f, -0.03760421f, -0.01613636f, -0.01946495f, 
    -0.01197616f, 0.03619535f, 0.01076961f, -0.03982349f, 0.02741618f, -0.00506433f, 0.00834611f, -0.02397625f, 
    0.00945435f, -0.01723239f, 0.02721888f, 0.00502522f, 0.01402417f, 0.00678103f, 0.03149145f, 0.02438640f, 
    0.00108312f, 0.01744778f, 0.01473846f, 0.01533279f, -0.02713791f, -0.03560056f, 0.00612172f, 0.00706130f, 
    0.03136255f, -0.00784937f, 0.01340255f, -0.01990046f, -0.02146612f, 0.00438543f, -0.04264821f, -0.02612078f, 
    0.03212828f, 0.03516897f, -0.02822661f, -0.00376696f, 0.03370997f, -0.01635613f, 0.01334527f, -0.03893709f, 
    -0.00735831f, -0.02518836f, 0.02089007f, -0.02362316f, -0.01581852f, 0.00267012f, 0.00607864f, 0.01932007f, 
    0.02347744f, -0.02146782f, 0.02292734f, -0.02845948f, 0.02570118f, -0.00692213f, 0.02674664f, -0.02240106f, 
    -0.00429644f, -0.02832315f, -0.01908789f, 0.02228323f, -0.01287580f, 0.00370522f, -0.03598512f, 0.01701741f, 
    0.00998437f, -0.01685805f, 0.00637726f, -0.00870408f, -0.00640823f, 0.02965498f, -0.02846136f, 0.02964299f, 
    0.01300313f, -0.00512660f, -0.03495657f, -0.00345703f, 0.02544593f, 0.00494570f, -0.02712003f, 0.00846906f, 
    0.01054679f, -0.03049180f, 0.00038062f, 0.03020183f, -0.02857670f, 0.02840953f, 0.00204989f, -0.01159501f, 
    -0.02618882f, -0.03500356f, -0.03116751f, -0.01713487f, -0.00306131f, 0.01315734f, -0.03361996f, -0.03722856f, 
    -0.03469878f, -0.02532985f, -0.02241251f, -0.00398957f, -0.04293207f, -0.03808324f, 0.00790021f, -0.02362062f, 
    -0.02510428f, 0.00401298f, 0.02071695f, -0.03055297f, 0.00510008f, 0.01149084f, -0.01230631f, 0.02997472f, 
    0.01104541f, 0.01815245f, 0.02945503f, 0.02103241f, -0.03523191f, 0.01483649f, -0.01314109f, 0.00948676f, 
    -0.02055735f, 0.00263908f, -0.03766283f, 0.02610741f, 0.00471150f, -0.01187169f, -0.02756936f, -0.01444864f, 
    0.03085393f, 0.00599635f, -0.01608496f, 0.00661351f, 0.02244591f, -0.02095309f, -0.00786266f, 0.03170272f, 
    -0.00156742f, -0.01863995f, -0.00609556f, 0.00140321f, 0.02495754f, -0.03661446f, -0.00889152f, -0.00012170f, 
    0.01443237f, -0.01246061f, 0.01902208f, -0.02236718f, 0.02470661f, 0.01838552f, -0.00417007f, -0.03798842f, 
    -0.02189577f, 0.01849538f, -0.03500737f, -0.03935682f, -0.00945748f, -0.02987791f, -0.02602430f, 0.01350121f, 
    -0.03253947f, -0.03231412f, 0.02623108f, -0.03743540f, 0.01155645f, 0.02547951f, 0.02178170f, 0.01754177f, 
    -0.03900652f, -0.00833888f, 0.00887763f, 0.01811447f, 0.01230906f, 0.03302835f, -0.02353953f, -0.03465322f, 
    -0.00088886f, 0.03064843f, 0.02801535f, -0.02162915f, -0.01730874f, -0.02417695f, 0.00760695f, -0.03903862f, 
    -0.01716002f, -0.00040227f, 0.02562178f, -0.01071598f, 0.00154943f, 0.00796958f, -0.00095889f, 0.00950814f, 
    0.03526077f, 0.00545329f, -0.03449551f, -0.02010013f, 0.01742908f, -0.03044955f, 0.02373594f, -0.00721665f, 
    0.01117967f, 0.00953124f, 0.02498579f, -0.01852287f, -0.01915975f, -0.03343944f, 0.02146004f, 0.01053631f, 
    0.01931677f, -0.01598631f, -0.02878434f, 0.02575496f, 0.02413350f, -0.02292046f, -0.01349090f, -0.02681016f, 
    0.01381431f, 0.01634169f, 0.01533434f, 0.01883251f, 0.01211460f, 0.01757536f, -0.02640584f, -0.03779988f, 
    -0.02118191f, -0.00662406f, -0.03954953f, -0.01729006f, 0.00608747f, 0.01861781f, 0.01818811f, -0.00142186f, 
    -0.02526891f, -0.01825041f, 0.00477243f, 0.00436649f, 0.00533917f, -0.00287711f, -0.02087520f, -0.02030452f, 
    -0.00863047f, -0.04546140f, -0.00848232f, -0.00987262f, 0.02664468f, 0.02242729f, -0.03470793f, -0.02770130f, 
    0.02982651f, -0.01010526f, -0.03742757f, -0.02413636f, -0.00463426f, -0.02802829f, -0.03949444f, 0.00002013f, 
    0.02354828f, 0.02479014f, -0.02471289f, -0.01172935f, -0.00676378f, -0.01618316f, 0.00852446f, 0.01400895f, 
    -0.00828938f, -0.02262123f, 0.01097170f, 0.00231862f, -0.04280431f, 0.01921582f, 0.01000813f, 0.01526345f, 
    0.01404625f, 0.01569999f, -0.01442793f, 0.00615435f, -0.02680792f, 0.00660298f, -0.01929949f, -0.02779545f, 
    0.01085787f, 0.00462566f, -0.03641793f, -0.03012052f, -0.00157606f, 0.03405422f, -0.02550133f, -0.01857991f, 
    -0.03822121f, -0.04201593f, 0.02431717f, 0.01470366f, -0.01921026f, -0.00335886f, 0.01842345f, -0.00016199f, 
    -0.02064438f, -0.00784388f, 0.03111380f, -0.03392514f, 0.01066570f, 0.00694318f, -0.02114229f, 0.02686716f, 
    0.02402304f, 0.01836634f, 0.00832251f, -0.03234335f, 0.01441578f, 0.01249276f, -0.00210756f, 0.02483920f, 
    0.01796643f, -0.01278334f, 0.03352001f, -0.02447699f, 0.02094557f, 0.00670272f, -0.00085720f, -0.01682189f, 
    -0.01588687f, 0.01852681f, 0.02023805f, -0.01204825f, -0.01280257f, 0.01884846f, 0.01224567f, -0.03910667f, 
    0.01780719f, 0.00851501f, -0.00251259f, -0.03837454f, 0.01565456f, -0.01140559f, 0.00118671f, 0.00973443f, 
    -0.02518147f, -0.00168757f, -0.00892997f, -0.01094258f, -0.01523555f, -0.00250235f, -0.03142564f, -0.01096253f, 
    -0.04474899f, 0.01519679f, -0.00264803f, -0.04058139f, 0.01565633f, 0.02855276f, 0.00631696f, -0.00213435f, 
    -0.03817041f, -0.01540642f, 0.01471071f, -0.02443005f, 0.01498736f, -0.01453285f, 0.02018820f, 0.00422038f, 
    -0.01686602f, -0.00275006f, 0.00029260f, -0.01211267f, 0.02534246f, -0.03078224f, 0.01949966f, -0.02044358f, 
    0.02912101f, -0.00616234f, 0.01689313f, -0.01509661f, 0.01766381f, -0.00307819f, -0.02671023f, -0.01165065f, 
    -0.02187662f, 0.02199490f, -0.01418694f, -0.04162654f, -0.02060607f, -0.00288935f, 0.01377347f, 0.00366750f, 
    -0.04733327f, -0.01133545f, -0.01717980f, -0.03534650f, -0.00344740f, -0.03169468f, -0.01686532f, -0.02714940f, 
    -0.00188359f, 0.00574466f, 0.02117133f, -0.01490454f, 0.00917616f, 0.02446500f, -0.00302376f, -0.01367490f, 
    0.02605260f, -0.00002660f, 0.02563289f, 0.01536686f, -0.01924943f, 0.00429001f, 0.00972208f, 0.02752799f, 
    -0.01516577f, 0.00439786f, -0.02368512f, -0.02408630f, -0.02002539f, -0.04189735f, -0.02326528f, -0.00510313f, 
    -0.00326365f, 0.01443018f, 0.00165507f, 0.02617029f, 0.02436399f, 0.00321370f, -0.02484281f, -0.00147364f, 
    -0.01230432f, 0.01280189f, 0.02548018f, 0.00496619f, 0.00911172f, 0.00110442f, -0.01151579f, 0.01708983f, 
    0.01724266f, -0.01422459f, -0.00685783f, -0.02363577f, 0.00028713f, -0.02089648f, 0.02374530f, 0.02421512f, 
    0.01009545f, -0.03206522f, 0.02227479f, -0.03622476f, 0.02549946f, -0.01931270f, -0.03487425f, 0.00169366f, 
    0.00491525f, -0.00206567f, -0.03637882f, -0.00487935f, 0.01007617f, -0.00153899f, -0.03095186f, -0.03188408f, 
    0.02260343f, -0.00012392f, -0.01512959f, -0.02274804f, -0.01763783f, -0.02490711f, -0.03973175f, -0.01634201f, 
    -0.03947996f, -0.00791279f, 0.00462924f, -0.03528578f, 0.00260326f, -0.02788344f, -0.02550322f, -0.03146674f, 
    0.00965152f, 0.00528845f, -0.01433621f, 0.00195748f, 0.02055419f, -0.03564254f, 0.02019517f, -0.00585738f, 
    0.01237082f, -0.03354987f, -0.03317815f, -0.03813669f, -0.03476315f, -0.03739965f, 0.00113175f, -0.04011967f, 
    -0.04103218f, -0.00567601f, 0.00162880f, -0.00932008f, -0.00428819f, 0.00127121f, -0.03514700f, 0.01908327f, 
    0.00312556f, -0.00323210f, -0.01196953f, 0.00358671f, -0.00869377f, 0.01126752f, -0.00853477f, -0.03050396f, 
    -0.02845332f, 0.00141189f, 0.00248314f, 0.00037751f, -0.01113308f, -0.03487966f, 0.02541801f, -0.03438344f, 
    -0.03742606f, -0.01854255f, 0.00880089f, 0.00284249f, 0.01369635f, 0.00516903f, -0.02054148f, -0.02051392f, 
    0.00506401f, 0.00519288f, 0.00560588f, -0.03363530f, -0.03496986f, 0.01322149f, 0.01304103f, -0.02153247f, 
    0.01985845f, -0.01028795f, -0.02406621f, 0.01794994f, 0.02009966f, 0.01641146f, 0.02841442f, 0.01574144f, 
    0.01943994f, 0.02096792f, -0.04113766f, 0.02287977f, 0.02027324f, -0.02841594f, 0.00463805f, 0.00742946f, 
    -0.01017536f, 0.01934478f, -0.02999213f, -0.00297052f, -0.01282115f, 0.00739229f, 0.02166844f, 0.01656181f, 
    0.02534324f, -0.01399277f, -0.02107147f, 0.02774669f, 0.00558945f, -0.03833341f, -0.04105870f, -0.02931253f, 
    -0.02015367f, -0.02481998f, -0.01719338f, 0.02402854f, 0.01627402f, 0.00003057f, -0.04022150f, -0.00763660f, 
    -0.02088626f, -0.02433820f, -0.02912824f, -0.02435225f, -0.01552509f, -0.02219180f, -0.03873727f, -0.03556046f, 
    -0.01592531f, 0.02894516f, -0.03930008f, 0.01498742f, 0.02547034f, -0.03389015f, 0.01754410f, 0.00807746f, 
    -0.00230715f, -0.03541358f, -0.02447708f, -0.03112775f, -0.00284826f, -0.03207720f, -0.02958666f, 0.00101129f, 
    0.02716270f, 0.02248632f, 0.02101542f, -0.03117299f, -0.00768386f, 0.01858327f, -0.03942752f, 0.01281200f, 
    0.01935882f, 0.01661575f, -0.01445573f, 0.01524615f, -0.02045862f, -0.02266744f, -0.02424735f, 0.01840869f, 
    0.02540779f, 0.00957378f, 0.02798373f, -0.01687391f, 0.02581375f, -0.00958107f, -0.01922195f, -0.00798596f, 
    -0.00245953f, 0.03409793f, -0.01676849f, -0.04124503f, -0.00014078f, -0.03633800f, 0.02220323f, -0.02648494f, 
    -0.00806027f, 0.01698687f, 0.02588811f, 0.02234545f, -0.03360673f, -0.01769564f, -0.00243725f, 0.02509286f, 
    -0.03518506f, -0.04098295f, -0.00300294f, 0.01132089f, -0.02543782f, -0.03118322f, -0.02776152f, 0.00406732f, 
    -0.02149976f, 0.01259371f, -0.03383864f, -0.04198965f, -0.00753109f, 0.02339119f, -0.01504303f, 0.01147661f, 
    0.00843539f, -0.03755591f, 0.02766848f, -0.03852863f, 0.00395814f, -0.02741440f, -0.01023526f, 0.01343667f, 
    -0.00369339f, -0.01780369f, -0.02833845f, -0.00024506f, 0.02235463f, 0.00126654f, -0.03889283f, -0.02681056f, 
    -0.01334041f, 0.00700999f, 0.01200290f, 0.02048050f, -0.03504347f, -0.01106930f, -0.00888212f, 0.02104486f, 
    0.02942339f, 0.01340531f, -0.02511009f, -0.00490220f, -0.01879108f, -0.03683409f, 0.02397831f, 0.01457340f, 
    -0.00366036f, -0.00468086f, -0.03402461f, 0.00366206f, -0.03360436f, 0.00483214f, 0.00253899f, 0.01564245f, 
    0.01028967f, -0.02209109f, 0.01773138f, 0.01064513f, -0.03871692f, 0.00416574f, -0.03970827f, 0.02720425f, 
    0.02703200f, 0.01682622f, 0.02913412f, -0.04084123f, 0.01441415f, -0.00854927f, -0.04187736f, -0.01264969f, 
    0.01384017f, -0.01700119f, -0.03188021f, -0.01210971f, -0.01734318f, -0.00513358f, 0.01130626f, -0.01880415f, 
    0.02964689f, 0.01810596f, -0.03305908f, -0.01229583f, 0.02623661f, -0.03416316f, -0.01048281f, 0.02947944f, 
    0.02798939f, -0.03553985f, 0.04056427f, 0.00550801f, 0.00533021f, 0.01997993f, 0.01715615f, -0.00989980f, 
    0.01342109f, -0.00586588f, 0.02078687f, 0.02084341f, 0.00783237f, 0.00627276f, -0.02460070f, -0.02200109f, 
    0.00411250f, -0.00748981f, -0.03340282f, 0.01642034f, -0.02548267f, -0.01462942f, -0.03749387f, -0.02364961f, 
    0.00899030f, -0.01077291f, -0.02345356f, -0.03926696f, 0.01560624f, 0.01836809f, 0.02616406f, 0.01886497f, 
    0.01498220f, 0.01998760f, 0.00468685f, -0.00538350f, -0.00473142f, -0.00666609f, -0.01131988f, 0.01161809f, 
    -0.01000207f, -0.03713230f, 0.00891538f, -0.02792888f, -0.01081548f, 0.00684345f, -0.03627040f, 0.00241808f, 
    -0.01669283f, -0.00539347f, -0.02316853f, 0.01109686f, -0.00745894f, -0.00344819f, -0.00587152f, 0.00487775f, 
    0.02288803f, 0.01596950f, 0.02262121f, -0.00816156f, 0.01712570f, 0.02210720f, 0.02282235f, 0.01171918f, 
    -0.01529823f, 0.00341140f, 0.01282907f, -0.01338873f, -0.00790683f, -0.01230224f, -0.03673688f, 0.01356310f, 
    0.00902803f, -0.01752039f, -0.01097802f, 0.02430456f, -0.03643833f, 0.01417315f, -0.01746420f, -0.03946317f, 
    0.00878861f, 0.02257600f, -0.03487436f, -0.01092694f, 0.01332328f, 0.00597350f, -0.01117524f, -0.00343146f, 
    0.00348987f, -0.02508418f, -0.00412541f, 0.00688306f, -0.00978437f, -0.02132327f, 0.02025154f, -0.02221130f, 
    -0.00515887f, -0.03103533f, -0.02081918f, -0.01942725f, -0.02536838f, 0.00610568f, 0.02977328f, -0.01986556f, 
    0.00659244f, -0.03546413f, -0.01842241f, -0.01289412f, 0.02145176f, -0.03627125f, 0.00663571f, 0.00509674f, 
    0.02269867f, -0.00431395f, -0.02133655f, -0.03270122f, -0.03391060f, -0.01050686f, 0.02140933f, -0.03186509f, 
    -0.00450454f, -0.02502637f, -0.02188954f, 0.02737978f, 0.01780809f, -0.03545349f, -0.01821653f, 0.00766546f, 
    -0.01580718f, 0.02453797f, 0.02867491f, -0.01146226f, -0.01397068f, 0.00882715f, -0.01170779f, 0.00356888f, 
    -0.01751865f, -0.00231361f, 0.02394325f, 0.01940634f, -0.03299553f, 0.00767705f, 0.02161914f, -0.01961100f, 
    0.00616671f, -0.02376816f, 0.00369362f, -0.01075044f, -0.04115679f, -0.02825367f, 0.00203362f, 0.02488215f, 
    -0.02873492f, -0.04030270f, 0.02543822f, 0.01278437f, -0.03170934f, -0.01465978f, -0.00929284f, -0.01273508f, 
    -0.03919967f, -0.03552613f, 0.03004391f, -0.00376383f, -0.02228861f, -0.01381443f, 0.01989357f, 0.01658896f, 
    -0.03509409f, -0.00826547f, 0.01370895f, -0.01665662f, 0.02788163f, 0.02189042f, 0.02817189f, -0.02445912f, 
    -0.02647508f, 0.00233559f, -0.03337203f, 0.00922179f, -0.03038761f, -0.00877001f, 0.00617824f, 0.02178123f, 
    -0.02027060f, -0.00660863f, -0.00009403f, -0.02242520f, -0.00407079f, -0.01178257f, 0.02735749f, -0.00054235f, 
    -0.03102741f, 0.00879177f, -0.01567219f, -0.03928685f, 0.02064286f, 0.02693390f, -0.02169697f, -0.01633293f, 
    0.00774136f, -0.00177944f, -0.04004408f, -0.02130331f, 0.02399673f, -0.00017165f, -0.03450235f, -0.02505832f, 
    0.00778470f, 0.01469986f, -0.01990254f, -0.03649084f, -0.01669775f, 0.00981435f, -0.00818447f, 0.01168113f, 
    -0.02258676f, -0.00796711f, -0.01946929f, 0.01104915f, -0.02334660f, -0.02563940f, -0.01495945f, -0.03929437f, 
    -0.01347120f, -0.00571472f, -0.03541250f, -0.00847487f, 0.01394215f, -0.02430055f, -0.03349652f, -0.02672780f, 
    -0.03767994f, -0.02346171f, 0.00083455f, -0.00169033f, -0.02735157f, 0.02619869f, -0.01485114f, 0.00899830f, 
    0.02648545f, 0.00814461f, -0.03739272f, -0.02363914f, -0.01521330f, -0.00035647f, -0.00469743f, 0.00726682f, 
    -0.00901609f, 0.01315488f, 0.01820342f, -0.02315723f, -0.02927629f, -0.02031586f, -0.00708569f, 0.02521319f, 
    0.02236580f, 0.00973956f, 0.01948917f, 0.01912154f, -0.01553146f, -0.01956108f, -0.02972050f, -0.00610509f, 
    0.02799002f, -0.00132859f, 0.01239402f, -0.02776396f, 0.00243477f, 0.02990039f, 0.01622765f, -0.03609772f, 
    -0.01425479f, 0.00334399f, -0.02568192f, 0.02151022f, -0.00666009f, -0.01159852f, -0.01835025f, -0.01103578f, 
    -0.00162273f, 0.00245078f, 0.01513293f, -0.01447384f, 0.00509420f, 0.00001250f, -0.02553456f, -0.03373637f, 
    0.02498066f, -0.01151163f, 0.00234003f, -0.01584651f, -0.03476180f, 0.00185342f, -0.00642864f, 0.01611920f, 
    -0.00402712f, 0.00859317f, -0.03053486f, -0.00101458f, -0.01465436f, -0.00992501f, -0.01780855f, 0.02298213f, 
    -0.03289942f, 0.02250382f, -0.03065271f, -0.01478076f, -0.00507844f, 0.00320994f, -0.01489197f, 0.01748900f, 
    -0.03982514f, 0.02230372f, -0.02281900f, -0.00565460f, -0.02214720f, -0.00985840f, -0.02698999f, -0.03792526f, 
    0.02063666f, 0.01039068f, -0.00799287f, -0.00693143f, -0.02866475f, -0.00376219f, -0.02441791f, 0.00354783f, 
    0.00438579f, -0.03459209f, -0.02087584f, 0.01829241f, -0.03189136f, 0.00468908f, -0.01293178f, 0.00094917f, 
    0.01871286f, 0.00102957f, -0.00980572f, -0.02711103f, 0.02596975f, -0.01204774f, 0.02814881f, -0.02335146f, 
    0.01690872f, 0.03015710f, 0.00923695f, -0.02293463f, 0.02449156f, 0.02589469f, 0.02367654f, 0.01955232f, 
    -0.01348659f, 0.00051379f, 0.01337080f, 0.02274659f, 0.00686529f, -0.03534068f, -0.01252906f, -0.03472424f, 
    0.02977479f, 0.00482380f, -0.01143827f, -0.03710009f, -0.00438424f, -0.01310491f, -0.01586572f, 0.01433914f, 
    -0.03956744f, -0.02498401f, 0.02601067f, 0.00858759f, 0.02251256f, 0.00453285f, 0.03680943f, -0.03760452f, 
    -0.02401905f, -0.00232909f, -0.00369225f, -0.02742027f, -0.04155867f, 0.01413273f, -0.00019436f, -0.00172891f, 
    0.00306399f, -0.02231804f, -0.00324098f, -0.02599314f, -0.03299138f, -0.02477892f, -0.01266317f, -0.01323874f, 
    0.02965919f, -0.03987522f, -0.02928532f, -0.03931066f, -0.01623220f, 0.01453278f, -0.00896726f, -0.03217487f, 
    0.00626957f, -0.03688581f, 0.01387667f, -0.01653091f, 0.02992932f, -0.02085666f, 0.02525338f, 0.00462642f, 
    -0.02485995f, 0.02135298f, -0.00950653f, -0.00467699f, -0.01911728f, -0.02821388f, -0.02620526f, 0.00170758f, 
    0.02044486f, -0.01163724f, 0.02391431f, 0.00761928f, -0.02059888f, -0.01536399f, -0.03172252f, -0.00514623f, 
    -0.04072818f, -0.03981989f, 0.01374460f, -0.00740258f, -0.02255133f, -0.03656948f, -0.02512060f, -0.01734813f, 
    -0.03096645f, -0.01149425f, 0.03415667f, -0.00258425f, -0.00201945f, 0.02984747f, 0.00126768f, 0.02081869f, 
    0.00777398f, -0.03653167f, -0.00143681f, 0.01986817f, 0.01621356f, -0.02003315f, 0.00600712f, -0.03513202f, 
    0.00618317f, 0.01715909f, -0.02800791f, -0.03489216f, -0.00547625f, -0.01739293f, -0.00716695f, 0.01852650f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.00187968f, 0.05540710f, -0.07819730f, 0.02443038f, -0.01708758f, 0.00230434f, 0.01082035f, -0.03049055f, 
    0.01417785f, 0.02396692f, 0.03464828f, -0.00682857f, -0.03308141f, 0.02476540f, -0.02045514f, 0.05549007f, 
    0.03078034f, -0.01996179f, 0.01146824f, 0.07664772f, 0.02695481f, -0.01991522f, 0.01231000f, -0.00202285f, 
    0.12724775f, -0.03232364f, -0.00313718f, 0.05691946f, -0.01317415f, 0.08391650f, -0.03145188f, -0.02867751f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.07255395f, -0.10239179f, -0.07605996f, 0.08956165f, 0.12794173f, 0.08698616f, 0.06931359f, -0.03370022f, 
    0.05591250f, -0.16586255f, -0.08404049f, 0.15322077f, -0.12828895f, 0.15067463f, -0.00959701f, -0.09391010f, 
    0.04374661f, -0.13171335f, -0.01952925f, -0.16489992f, -0.13220794f, -0.07628854f, 0.12005561f, -0.04972363f, 
    0.02188219f, -0.08021080f, 0.15340947f, 0.15559420f, 0.02300577f, 0.14408453f, -0.14988056f, 0.13471578f, 
    0.14452489f, 0.22873451f, -0.21830331f, 0.13990493f, -0.12953165f, 0.01919760f, -0.11074971f, -0.26171455f, 
    -0.01125360f, 0.34341747f, 0.26474348f, 0.09824777f, 0.05833257f, 0.00485842f, -0.05830009f, -0.03936999f, 
    -0.13292289f, 0.03898023f, -0.11319544f, 0.18373591f, 0.03370090f, 0.04496377f, 0.08155700f, -0.11801074f, 
    0.11173773f, 0.15181312f, 0.01804631f, 0.25214800f, -0.02178758f, 0.46732888f, 0.02353676f, -0.03420270f, 
    0.06299983f, -0.14917137f, 0.07111247f, 0.03945810f, 0.11226770f, 0.15099174f, 0.09859741f, 0.02748148f, 
    -0.05593591f, 0.43152609f, -0.33886504f, -0.15343095f, 0.09629015f, -0.12791063f, 0.08184325f, 0.32146108f, 
    -0.13641870f, -0.13034329f, 0.01129115f, -0.07138507f, 0.29208493f, 0.06009653f, 0.13702092f, 0.17084864f, 
    -0.09429145f, -0.03570140f, 0.03903947f, -0.16623102f, 0.03141329f, -0.06705632f, -0.17776482f, 0.11417607f, 
    0.07831447f, -0.47765866f, 0.13396046f, 0.05250196f, 0.01606389f, -0.01744030f, -0.11921309f, 0.01108685f, 
    -0.00516937f, 0.18858229f, -0.34123909f, 0.14476599f, -0.06776074f, 0.03333860f, -0.08478338f, 0.09944997f, 
    0.15319903f, -0.00759534f, 0.09175550f, -0.18334706f, -0.20391595f, 0.09016978f, 0.09448875f, 0.14181766f, 
    0.25418711f, -0.02776901f, 0.15491399f, 0.14754373f, -0.10798722f, -0.28602833f, -0.05760136f, 0.14508149f, 
    0.08829423f, 0.19874908f, -0.16086753f, -0.11820810f, -0.04591712f, 0.10750914f, -0.15029700f, 0.23363635f, 
    -0.16807295f, 0.09154259f, 0.03278068f, -0.15708581f, 0.08494413f, 0.14016883f, 0.15594773f, 0.22615424f, 
    -0.24340409f, -0.14125812f, 0.10344715f, -0.52195674f, 0.13986996f, 0.04558187f, 0.04530168f, 0.15932310f, 
    0.03381552f, -0.03074613f, -0.01390942f, 0.00333221f, 0.11318314f, 0.13172767f, -0.09124386f, 0.00431995f, 
    0.10950994f, 0.20527448f, -0.10659200f, -0.15303665f, -0.14305364f, 0.14960258f, 0.06779338f, 0.20153511f, 
    -0.37693030f, 0.01459390f, -0.28219998f, -0.00381899f, -0.04438332f, -0.12294553f, -0.05810432f, 0.25540313f, 
    -0.24142100f, -0.09968731f, 0.00233985f, 0.07737437f, 0.13337258f, 0.13760248f, 0.05624550f, -0.04776068f, 
    0.06654929f, 0.02996708f, -0.00691591f, -0.30323309f, -0.08857929f, 0.14788866f, 0.09893839f, 0.01977157f, 
    0.04448524f, 0.26328060f, 0.11506807f, 0.08921603f, -0.08781933f, 0.08333997f, -0.01097167f, 0.22698165f, 
    0.05861274f, -0.39835367f, -0.05803732f, 0.09305343f, 0.04825515f, -0.15521173f, -0.10120466f, 0.36470461f, 
    0.26270187f, 0.03139431f, -0.06391102f, -0.06476945f, -0.26872438f, -0.52990770f, 0.08858979f, 0.36617935f, 
    -0.09028509f, 0.02948134f, -0.02784299f, 0.23578495f, 0.03347108f, -0.15537947f, -0.05135732f, -0.02938768f, 
    -0.00920829f, 0.30056265f, 0.16464610f, 0.10005834f, -0.05139977f, -0.11163416f, 0.05603293f, 0.18010424f, 
    0.17529637f, -0.15446711f, -0.14587237f, 0.05655061f, -0.06692802f, -0.15558369f, -0.15111242f, 0.15654804f, 
    0.06156831f, -0.11739640f, 0.15996714f, 0.43034258f, -0.13460860f, -0.45732510f, -0.16170944f, -0.01290491f, 
    -0.20306411f, -0.03016303f, 0.14064707f, -0.13878140f, -0.02474128f, 0.21196254f, 0.08650470f, -0.09460109f, 
    0.01498721f, 0.23773113f, -0.22851847f, 0.16547084f, -0.14289960f, -0.07117534f, -0.05571829f, -0.07440861f, 
    -0.38314521f, 0.08025493f, 0.21619073f, -0.04151231f, -0.16664508f, 0.04854129f, -0.01457388f, -0.08925143f, 
    -0.18801433f, -0.12837513f, -0.03324406f, 0.08745098f, -0.18311810f, -0.02020373f, 0.09957409f, 0.31165281f, 
    0.15753315f, -0.12387655f, -0.00078972f, 0.46059909f, -0.07141296f, 0.19648814f, 0.08133984f, 0.02503158f, 
    0.04135303f, -0.31106675f, 0.16147760f, -0.12962982f, -0.03704482f, 0.07261747f, -0.12566589f, 0.12633394f, 
    -0.27921274f, -0.01869473f, -0.29073837f, 0.10014660f, 0.08534929f, -0.03559923f, 0.06328265f, 0.26121283f, 
    -0.06297705f, 0.15391763f, 0.15234753f, 0.18674511f, -0.16355905f, 0.04165725f, -0.08909743f, -0.05688818f, 
    0.17166865f, -0.17167903f, 0.15746866f, -0.05079313f, 0.13129064f, 0.16298242f, -0.14905930f, 0.06854776f, 
    0.02757116f, -0.13163346f, -0.11983798f, 0.06566924f, 0.17066696f, -0.10062712f, -0.16745651f, -0.04282040f, 
    0.07850744f, -0.16788559f, 0.05703130f, 0.08658033f, 0.17277974f, -0.07767864f, 0.02527144f, -0.04867836f, 
    -0.10872216f, 0.14571552f, -0.17515430f, -0.17157972f, 0.00937004f, 0.14614990f, -0.09745830f, -0.00858580f, 
    -0.10267779f, -0.04241737f, 0.17377853f, -0.05169009f, 0.01409932f, 0.09843203f, -0.10682083f, 0.02969172f, 
    -0.03955587f, 0.10074273f, -0.09530333f, 0.09040957f, -0.07509291f, -0.00257854f, -0.16837481f, -0.06502016f, 
    -0.09440728f, -0.00191403f, -0.15422916f, -0.06058217f, 0.09116766f, 0.03659119f, -0.10303918f, -0.05577505f, 
    -0.15197545f, -0.13886665f, 0.11694775f, 0.12128263f, 0.01055993f, -0.08436892f, 0.13205206f, 0.01778764f, 
    -0.12566154f, -0.09262500f, 0.12834582f, -0.12445632f, 0.09485052f, 0.02933374f, 0.16677818f, -0.07778243f, 
    0.12662561f, -0.16381715f, -0.05648896f, -0.09211339f, -0.13797888f, 0.01294067f, 0.11262122f, 0.11488695f, 
    0.12162932f, -0.06164476f, 0.06819705f, 0.11317735f, 0.10762026f, -0.12789041f, -0.05774097f, -0.12427258f, 
    -0.08453777f, -0.15644877f, -0.02004106f, 0.06077940f, -0.11568321f, 0.11346281f, 0.07752173f, -0.06626387f, 
    -0.08185868f, -0.14746307f, -0.05304331f, 0.02959941f, -0.01286326f, -0.07536922f, -0.07994202f, -0.10586166f, 
    -0.06547096f, 0.22046220f, -0.16484304f, -0.02095691f, -0.01509048f, -0.16437507f, -0.02150682f, -0.16415536f, 
    -0.16805117f, 0.08420458f, -0.17804663f, 0.17412871f, -0.08166310f, -0.10238395f, 0.15569197f, -0.11713190f, 
    0.08492819f, -0.00815708f, -0.04580524f, -0.02820966f, -0.23182388f, -0.15179662f, -0.00942777f, 0.27794877f, 
    0.25468567f, -0.03435195f, 0.09255242f, 0.41446272f, -0.00482232f, 0.11399501f, -0.11274838f, -0.04477670f, 
    0.03553958f, 0.00766769f, -0.04836574f, 0.06701689f, -0.02942322f, 0.16711177f, 0.07439231f, -0.02286575f, 
    -0.00506350f, -0.17270020f, -0.11891857f, -0.03007701f, 0.08619812f, 0.03771804f, 0.13674957f, -0.10791037f, 
    -0.18142842f, 0.05613109f, 0.02564791f, -0.12122754f, -0.14333430f, 0.09940772f, -0.01905994f, 0.09168676f, 
    0.09778123f, -0.14473000f, -0.03301693f, -0.12868558f, 0.15503156f, -0.17816299f, 0.05111236f, -0.04319790f, 
    0.01762337f, 0.15972114f, 0.13775191f, 0.10298966f, -0.07381753f, 0.04072477f, 0.13050142f, -0.02021575f, 
    -0.28462166f, 0.18490654f, -0.13575700f, 0.01746319f, -0.15160586f, 0.03767319f, 0.01267722f, -0.10868240f, 
    -0.15159489f, -0.08435456f, -0.16732322f, 0.00899606f, -0.09498102f, 0.04072487f, -0.01911126f, -0.20718668f, 
    0.09514633f, -0.01090940f, -0.02200980f, 0.35589373f, -0.11818671f, 0.40870938f, -0.10939240f, -0.15030207f, 
    -0.04207052f, -0.02605534f, -0.12156335f, 0.03862489f, -0.01775468f, 0.15445325f, -0.05221457f, -0.07843048f, 
    0.23240151f, -0.17868486f, 0.40099666f, 0.02366661f, -0.13718289f, -0.08076128f, 0.16052553f, 0.07874321f, 
    0.00210277f, -0.10099985f, -0.02682528f, 0.43059009f, 0.33608514f, -0.15977289f, -0.00476567f, -0.17610256f, 
    0.17825875f, 0.02842116f, -0.09500273f, -0.17140086f, 0.10792579f, -0.04344039f, -0.05777610f, -0.08477897f, 
    0.16834721f, -0.12613517f, 0.06076568f, -0.13010359f, 0.16796429f, -0.03539476f, 0.01822858f, 0.09695333f, 
    0.40353784f, 0.17075992f, 0.21552615f, -0.11741687f, -0.13850929f, 0.15128635f, 0.01863467f, -0.28664902f, 
    0.25649038f, -0.14682439f, 0.12297433f, 0.15590970f, 0.24564296f, -0.59170711f, -0.08123310f, -0.06351859f, 
    -0.00050668f, 0.00931862f, -0.05077894f, 0.20635928f, -0.01545694f, 0.00390779f, 0.02495512f, 0.09288193f, 
    -0.02895744f, 0.35685897f, -0.05138708f, -0.14941148f, -0.11171182f, 0.06987553f, 0.10089101f, 0.10820030f, 
    0.37652764f, 0.18064553f, -0.14388067f, -0.13992606f, 0.14573273f, -0.09737878f, -0.16538107f, -0.14382635f, 
    0.21483050f, 0.00933592f, 0.10711174f, -0.06707848f, 0.22591399f, 0.41958091f, -0.07322899f, -0.09281495f, 
    0.18031383f, -0.02309017f, -0.01286599f, 0.25053793f, 0.17828214f, -0.36464205f, 0.05021498f, -0.13025679f, 
    0.09946355f, -0.01914656f, -0.11251345f, 0.06178983f, 0.03977386f, 0.13689673f, 0.13344367f, -0.17947583f, 
    -0.15484419f, -0.06777123f, 0.14420256f, -0.18152349f, 0.03481121f, 0.13931817f, -0.08695502f, 0.03708965f, 
    -0.04113009f, -0.15312816f, 0.13669766f, 0.07021556f, -0.06084877f, -0.07427073f, 0.15336348f, 0.01074381f, 
    0.08813384f, -0.14231293f, -0.12558381f, -0.15951678f, 0.09213545f, -0.15769182f, -0.02291609f, 0.16555858f, 
    -0.03577140f, -0.08773494f, 0.05277407f, 0.06675968f, 0.04840549f, -0.05600106f, 0.08940158f, 0.12788779f, 
    -0.04850654f, -0.11719634f, -0.02048799f, 0.08400482f, 0.15691529f, -0.02413272f, -0.06389955f, 0.05172901f, 
    -0.08607273f, -0.05277970f, -0.09424298f, -0.06765486f, -0.09315316f, -0.04353815f, -0.15729760f, -0.11860405f, 
    -0.19473572f, 0.06583757f, 0.10965531f, -0.02316504f, -0.14746438f, 0.13055390f, -0.10770460f, 0.05259147f, 
    -0.00019994f, 0.03933178f, 0.11262385f, 0.12254389f, -0.00459144f, -0.07427522f, -0.03622141f, -0.13789465f, 
    -0.03172366f, 0.06597979f, -0.05755068f, 0.03946219f, 0.02498935f, -0.15726075f, -0.15234277f, -0.07212324f, 
    -0.11539833f, 0.14319184f, 0.15304485f, -0.00098194f, -0.13963379f, 0.15593913f, 0.01869103f, 0.02507380f, 
    -0.12684871f, 0.02974319f, -0.11230607f, -0.15112664f, -0.14322051f, -0.00726256f, -0.13574636f, 0.07318003f, 
    -0.10765386f, 0.02766826f, 0.05894816f, 0.15044059f, -0.05717342f, 0.12471121f, 0.07699466f, 0.11414213f, 
    -0.02285483f, -0.01096588f, 0.16841498f, -0.08011201f, -0.09998380f, -0.02663118f, 0.14572613f, -0.07399805f, 
    -0.17975093f, -0.02875421f, 0.12473958f, -0.07687237f, -0.15889785f, -0.13273418f, -0.13153313f, -0.16544791f, 
    0.00090247f, 0.12796964f, -0.13252714f, -0.03738398f, 0.12295438f, -0.12345947f, 0.01297682f, 0.13328026f, 
    -0.11893175f, -0.25001416f, 0.09778158f, 0.00796068f, -0.09232050f, 0.02899289f, 0.16188519f, 0.10371941f, 
    -0.06442852f, 0.51272649f, -0.06699716f, 0.07652070f, 0.01562164f, -0.10421567f, 0.14929508f, -0.14901790f, 
    -0.00274125f, -0.12440753f, 0.11287697f, -0.18222211f, 0.43527320f, -0.31603134f, 0.14221032f, -0.34390521f, 
    0.11265931f, 0.15707424f, 0.03576166f, 0.18429030f, -0.01750418f, 0.09949154f, -0.11638626f, 0.08575466f, 
    0.08296265f, -0.34084514f, -0.02116574f, -0.03933315f, 0.10953595f, -0.08391336f, -0.09415270f, 0.05347083f, 
    -0.23669446f, 0.34200290f, -0.00288290f, -0.14667152f, -0.07867298f, -0.02925823f, -0.15781267f, 0.35667363f, 
    -0.21440022f, 0.09901514f, 0.10490223f, -0.07370236f, 0.17156111f, -0.33428016f, -0.11150091f, 0.29885805f, 
    -0.10610683f, -0.06208090f, -0.08913507f, -0.08753044f, 0.12649649f, 0.17789698f, -0.15065196f, 0.12678246f, 
    -0.10288979f, -0.15673706f, 0.01512604f, 0.16991037f, 0.04682162f, 0.03556124f, -0.13602582f, -0.12424852f, 
    0.11860920f, -0.13323441f, 0.41380998f, 0.12013995f, -0.16332233f, 0.12863819f, 0.09981499f, 0.15515892f, 
    0.23827869f, 0.05858142f, 0.04214765f, 0.19499741f, -0.18666707f, -0.22482386f, 0.08548658f, 0.02048799f, 
    -0.02839528f, -0.00717309f, -0.13719012f, 0.23310331f, -0.08372354f, 0.19462691f, -0.05886563f, -0.07796182f, 
    0.16555850f, -0.37780961f, 0.39278921f, 0.06722274f, -0.04391116f, 0.04650480f, -0.00568629f, 0.30155373f, 
    -0.07537735f, 0.17906815f, 0.24877515f, 0.16788463f, 0.10628208f, -0.05880355f, 0.02789116f, -0.15914416f, 
    0.15709187f, -0.11397079f, -0.08002098f, 0.28767797f, -0.14662586f, 0.51634192f, -0.03552457f, 0.00268162f, 
    -0.12489761f, 0.01394363f, -0.01635728f, -0.15699261f, 0.01472008f, 0.39400211f, 0.11762366f, -0.17089967f, 
    0.18235049f, 0.12304530f, -0.04605843f, 0.13045652f, -0.01572197f, 0.04394657f, 0.16907153f, -0.09585969f, 
    0.06837225f, -0.17965694f, 0.08492549f, 0.04996571f, -0.07126189f, -0.05532719f, -0.09992865f, 0.04840500f, 
    -0.14042886f, 0.10489140f, 0.14105795f, 0.13318366f, 0.04647621f, -0.10606849f, 0.15408586f, 0.01893716f, 
    -0.16281410f, 0.13799405f, 0.11388078f, 0.06219535f, 0.10617594f, 0.12744530f, 0.15319508f, -0.04822429f, 
    0.03717369f, 0.55135161f, -0.19065772f, 0.16771510f, 0.17542177f, -0.00203310f, 0.00985478f, -0.13329512f, 
    0.32358342f, -0.07926002f, -0.08011735f, 0.15592945f, 0.06992465f, -0.04379476f, 0.01757414f, 0.28232297f, 
    -0.22772262f, 0.08191627f, -0.13383810f, -0.23674931f, -0.02015159f, -0.37947017f, -0.04662220f, 0.33390006f, 
    0.20142305f, -0.12661117f, -0.00160274f, -0.15514946f, 0.01614418f, -0.16504048f, -0.15658070f, -0.13814360f, 
    0.13752814f, -0.20392755f, 0.22480679f, 0.00022046f, -0.07205074f, -0.07130937f, 0.16312748f, 0.13040744f, 
    -0.12931688f, -0.28499126f, -0.05915908f, -0.01317408f, -0.11561546f, 0.17016147f, -0.05203484f, 0.11880209f, 
    0.02127873f, -0.14237294f, -0.14509794f, 0.39887610f, -0.18632294f, 0.11229066f, -0.17488340f, 0.15111661f, 
    0.18255934f, -0.06012581f, 0.05635986f, -0.31258923f, 0.09166399f, -0.14117904f, 0.00035274f, 0.12385122f, 
    -0.05473318f, 0.18083097f, 0.00612481f, -0.12431972f, 0.00621653f, -0.00743545f, -0.01981935f, 0.17181683f, 
    -0.05817979f, -0.24689928f, 0.16160125f, 0.05391343f, -0.09808543f, 0.10116014f, 0.16598992f, 0.16704465f, 
    -0.01562193f, 0.03527163f, -0.12577292f, 0.32173079f, -0.12213619f, 0.64971149f, -0.01975871f, 0.27332890f, 
    0.06975714f, 0.16970776f, 0.02315691f, -0.38329259f, -0.07789888f, 0.12508550f, 0.08054607f, -0.03270013f, 
    0.12219218f, 0.10326041f, 0.05658690f, -0.16150783f, -0.02256028f, 0.04425890f, 0.00493906f, -0.00189962f, 
    0.24023511f, -0.06901405f, 0.31896591f, 0.14447860f, -0.16160879f, 0.02447193f, 0.08902638f, -0.10323820f, 
    0.47685722f, 0.08138671f, 0.08293570f, -0.24294491f, 0.20116393f, -0.09375617f, 0.13151635f, -0.26538950f, 
    0.25693652f, 0.05400433f, -0.17659579f, 0.12908028f, -0.04127415f, -0.11465106f, 0.04920394f, -0.08256774f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16079481f, 0.08792387f, 0.15819849f, -0.13200183f, -0.05732224f, -0.13318169f, -0.06337869f, -0.11221918f, 
    0.14267588f, 0.04777588f, -0.15834613f, 0.01529945f, -0.02500312f, 0.08359422f, 0.13319334f, -0.06248017f, 
    0.19034578f, 0.07752866f, -0.09946952f, 0.07556418f, -0.16462272f, 0.12981664f, 0.04149704f, -0.12931582f, 
    0.12852040f, 0.15851712f, -0.16131143f, -0.12003613f, 0.04772598f, 0.16578236f, 0.18734275f, -0.07651347f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.03532447f, -0.68915170f, 0.07841665f, 0.49443239f, -0.28012532f, -0.52029729f, 0.12912233f, -0.40414315f, 
    -0.59080082f, 0.03776468f, -0.12979326f, 0.00576887f, -0.11439057f, 0.00135662f, 0.00461212f, -0.70609969f, 
    -0.21376222f, -0.01536731f, 0.30072165f, 0.01735232f, 0.04311404f, 0.12783197f, -0.08298484f, -0.08291142f, 
    -0.40700859f, -0.18796389f, -0.06188307f, 0.02847714f, -0.08546833f, 0.15593173f, 0.01838628f, 0.20986018f, 
    0.10129565f, -0.16118094f, -0.50245851f, -0.20954007f, -0.13203722f, -0.26339456f, 0.03852605f, -0.33460101f, 
    -0.14026698f, -0.32826471f, 0.10466626f, -0.10103850f, 0.08921012f, -0.11345278f, -0.00556425f, -0.45141223f, 
    0.22909625f, 0.37943113f, 0.01936883f, 0.01386847f, -0.15385292f, 0.15060574f, -0.04271707f, 0.22846434f, 
    0.07405227f, 0.20824550f, -0.10041859f, -0.04920178f, -0.00599442f, -0.23195606f, -0.08577240f, 0.33113667f, 
    -0.09123917f, 0.06856601f, 0.04109692f, -0.01914353f, 0.14886512f, 0.18385616f, -0.64377761f, -0.35212231f, 
    -0.15917428f, 0.12229732f, -0.12726849f, 0.13373865f, -0.06184831f, 0.05725428f, 0.13000034f, 0.32044441f, 
    -0.12282468f, 0.13265681f, 0.23303117f, 0.00264605f, 0.08321737f, -0.00373151f, 0.04077128f, 0.34147260f, 
    -0.46290055f, -0.61318451f, -0.01487711f, -0.15720931f, -0.35032317f, -0.34850454f, -0.27288446f, 0.19802296f, 
    -0.06322528f, -0.19258565f, 0.08818436f, -0.09240156f, 0.40770259f, 0.19373450f, 0.22535510f, -0.59677011f, 
    -0.10777353f, 0.07119082f, -0.02706333f, -0.16354109f, -0.13190416f, 0.02796509f, 0.17740571f, -0.50239331f, 
    -0.04937526f, -0.58781290f, -0.01890166f, 0.15456086f, -0.18183042f, -0.05386870f, 0.03295488f, -0.42889214f, 
    0.01935992f, -0.04134505f, -0.58095306f, 0.12282780f, 0.40976664f, -0.07497024f, 0.16299714f, 0.01255801f, 
    0.10380740f, -0.31704402f, 0.23858176f, -0.17330901f, -0.16464356f, 0.29836512f, 0.16661754f, 0.37983075f, 
    -0.30031091f, 0.05474294f, -0.01562386f, 0.09818412f, 0.00775667f, -0.22045235f, -0.08134513f, -0.53211433f, 
    0.16566058f, -0.08922844f, 0.08262245f, 0.10270539f, -0.02367711f, -0.02462069f, -0.11278443f, -0.06924466f, 
    -0.05293194f, -0.22312722f, -0.20375672f, 0.08333597f, 0.14676648f, 0.20225938f, 0.13808012f, -0.11686242f, 
    0.14066979f, 0.09807747f, -0.52308583f, -0.30284974f, -0.58008802f, -0.36714518f, 0.29184982f, 0.61996472f, 
    -0.13641389f, 0.09114417f, 0.01294366f, 0.00293397f, 0.08889991f, -0.00448620f, 0.00426582f, -0.07787358f, 
    0.09748602f, 0.03847512f, -0.10607328f, -0.13432920f, 0.12269264f, -0.11817495f, 0.14027369f, -0.41506645f, 
    -0.63974738f, 0.35559246f, 0.12519713f, -0.01042256f, -0.03843050f, 0.16527165f, -0.01365518f, 0.12188432f, 
    -0.13671239f, -0.14168143f, -0.19394922f, -0.03610123f, -0.26812196f, 0.13310347f, -0.43235388f, -0.41310698f, 
    -0.26492336f, 0.03104824f, 0.17591064f, -0.13560015f, -0.06005372f, -0.43406928f, 0.00158601f, -0.49338180f, 
    0.16812569f, -0.17900755f, 0.08791932f, -0.03511867f, -0.04504106f, 0.15506430f, -0.00119615f, -0.32373318f, 
    -0.55238938f, -0.11796740f, 0.31604266f, 0.08362205f, -0.28146809f, 0.35354683f, 0.37510693f, 0.01870037f, 
    -0.07998876f, -0.27470565f, 0.06063518f, 0.02717553f, 0.28196454f, 0.09517370f, 0.15852533f, 0.13550636f, 
    0.24153547f, 0.15479431f, -0.06884696f, -0.10823186f, 0.10781141f, 0.17984006f, -0.14984991f, 0.02604846f, 
    -0.57564539f, -0.06362748f, -0.38351369f, -0.15448435f, -0.02862661f, 0.15763670f, -0.15692584f, -0.14062205f, 
    0.38216960f, -0.24627189f, 0.18223138f, 0.00057017f, 0.07906725f, 0.11763205f, -0.04317086f, -0.44152781f, 
    -0.02296824f, 0.35331342f, -0.29922706f, -0.65734363f, 0.14256017f, -0.10928440f, -0.27040064f, 0.08056001f, 
    0.32457638f, -0.62533891f, -0.00325350f, 0.06677828f, -0.02773934f, 0.21357839f, -0.10455805f, 0.11904167f, 
    -0.08546802f, -0.03600027f, 0.29957712f, -0.15164025f, 0.05286422f, -0.01416163f, 0.04187293f, -0.17738807f, 
    -0.52176231f, -0.13639228f, -0.03572021f, 0.00464105f, 0.04873954f, -0.49556157f, 0.18164389f, 0.05759249f, 
    -0.06363364f, 0.09163082f, 0.35646170f, -0.15199478f, -0.08101862f, 0.18139227f, -0.24248277f, -0.00073411f, 
    -0.30442411f, 0.17099485f, -0.17665339f, 0.08554123f, -0.17938314f, -0.51198912f, 0.02588500f, 0.10812542f, 
    -0.03456130f, -0.11639123f, -0.11657341f, 0.12074701f, -0.05486260f, -0.02415750f, 0.12028615f, 0.30282950f, 
    0.41947794f, 0.11249390f, 0.31810322f, 0.06803194f, -0.69842458f, -0.09903563f, 0.09217742f, -0.17454688f, 
    -0.05363916f, 0.29604164f, 0.10275757f, 0.07374228f, -0.08322232f, -0.22961101f, -0.24641691f, -0.32667834f, 
    0.27017298f, -0.04593591f, -0.09007774f, -0.02668325f, -0.09091499f, 0.36230755f, -0.05167669f, -0.06706592f, 
    0.18645437f, 0.06702368f, 0.00172345f, 0.09217261f, 0.09877481f, -0.04459314f, -0.10527240f, -0.06482250f, 
    0.11963029f, 0.11241379f, -0.64908445f, 0.09451116f, 0.21889268f, -0.22346646f, -0.14926611f, -0.11596587f, 
    0.17245646f, -0.04824862f, -0.39892727f, 0.12250672f, -0.13485280f, 0.11273097f, 0.05358139f, -0.47292894f, 
    0.35988832f, 0.20583850f, -0.06106994f, 0.14815697f, -0.14778955f, 0.28796044f, -0.06071110f, 0.14976789f, 
    -0.12880433f, -0.46208012f, -0.04509468f, 0.06267641f, 0.02393980f, -0.04122721f, 0.09799009f, -0.30838934f, 
    -0.36782265f, 0.12179997f, 0.07260462f, -0.03862192f, -0.27364057f, 0.23060419f, 0.20280169f, -0.07376052f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.05597194f, 0.12346463f, -0.10346743f, 0.11580862f, -0.15125272f, 0.11099464f, -0.00303588f, -0.25340357f, 
    -0.17678274f, 0.12553771f, 0.09650379f, 0.14677422f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
