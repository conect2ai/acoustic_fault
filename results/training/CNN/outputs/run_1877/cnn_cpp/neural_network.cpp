#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.42031044f, 0.30463561f, -0.24713050f, -0.04703280f, 0.63124621f, 0.63185382f, -0.05869124f, 0.39526331f, 
    0.51728809f, -0.40748250f, 0.14221582f, 0.18121074f, -0.66541868f, -0.14640416f, -0.03156300f, 0.16195823f, 
    0.70946407f, -0.79858202f, -0.78302473f, -0.15286130f, -0.62845296f, -0.58209163f, -0.09490862f, -0.69579744f, 
    -0.65538639f, 0.51960057f, -0.31359217f, 0.01288643f, 0.08756500f, 0.20703550f, 0.86377817f, -0.22064847f, 
    -0.64667308f, -0.75130016f, 0.85942656f, -0.23140699f, 0.74109393f, -0.14259508f, -0.17356822f, -0.85572600f, 
    -1.03982735f, -1.11996949f, -0.36916986f, 0.68479151f, -0.60753882f, -0.88932049f, 0.09002487f, 1.05995607f, 
    0.72775984f, -0.03483791f, -0.02638647f, -0.70489240f, -0.13566670f, -0.45185217f, -1.06802344f, -0.37874338f, 
    -0.42819771f, -0.70451391f, 0.33591756f, 0.92644387f, -0.54519922f, -0.49726069f, -0.18493760f, -1.21473539f, 
    -0.99989158f, -0.82604158f, 0.61966872f, -0.23412879f, 0.19226971f, 0.17118166f, 0.03878874f, 0.67683744f, 
    0.31158897f, 0.31597266f, -0.18890916f, 0.51797080f, 0.98150492f, -0.04168292f, 0.38151163f, -0.47435391f, 
    0.23446520f, 1.45323765f, -1.26843953f, -1.05039597f, -0.54696757f, -0.45506823f, -0.06712304f, 0.00672366f, 
    -0.06054877f, 0.12504101f, -0.29452986f, -0.27630877f, 0.02802492f, -0.88310224f, -0.85803896f, -0.87494576f, 
    0.50919843f, 0.27531710f, 0.61543864f, -1.00050318f, 0.11583578f, -0.76120019f, 0.24200207f, 0.47103718f, 
    0.36065438f, -0.00691799f, 0.94332957f, 0.13134588f, -0.71959251f, 0.61419392f, -0.08830983f, 0.32539740f, 
    -0.54201818f, 0.50816345f, -0.43600562f, 0.62647158f, -0.56088841f, -0.52239943f, -0.41829640f, -0.05790604f, 
    0.36178422f, -0.00910225f, -0.56730264f, -0.83304042f, 1.31794894f, -1.01683497f, -0.60504848f, -0.51169962f, 
    -0.44633922f, -0.23525083f, 1.24691296f, -1.10667467f, -0.24100776f, -0.46610934f, -0.02860955f, 0.29452419f, 
    0.08333222f, 0.04788354f, 0.55929804f, 0.96718490f, -0.56122643f, 0.25341743f, 0.06081924f, -0.20834173f, 
    0.04014778f, 0.20915672f, 0.32121956f, 0.16679776f, 0.28736296f, -0.38024509f, 0.95106047f, -0.84841496f, 
    -0.47373098f, -1.32314754f, -0.82402539f, 1.48799503f, -0.47995716f, -0.19849634f, -0.71895587f, -0.12183304f, 
    -0.32442388f, -0.69865912f, -0.13139698f, 0.44462934f, 0.66758537f, 0.17921314f, -0.07250982f, -0.83608902f, 
    -0.13428389f, -0.40117243f, -0.22875869f, 0.53407288f, 0.70352107f, 0.32944223f, 0.25539765f, 0.80629295f, 
    -0.19550271f, 0.04240193f, -0.07304291f, -0.54092783f, 1.13997149f, -1.12964118f, 0.88705784f, -0.06225917f, 
    -0.22566132f, -0.07436728f, 0.65780991f, -0.28698808f, -0.25873610f, -0.94709200f, -0.34707838f, 0.87709278f, 
    -0.44902143f, 0.01528054f, 0.77857357f, 0.13839239f, 0.05935301f, 0.51224118f, -0.04251921f, -0.47799227f, 
    0.09642265f, -0.38132054f, -0.35155043f, -0.94347274f, -0.40237382f, -0.54427719f, 0.44985035f, 0.87003720f, 
    0.51479501f, -0.02455983f, -0.87730420f, -0.41251922f, -0.16684020f, 0.54782587f, 0.49607223f, 0.18469854f, 
    -0.67918992f, -0.77138555f, -0.12354821f, -0.64024210f, -0.93401664f, -1.11001968f, 0.44373614f, 0.32102740f, 
    0.15740670f, 0.01816817f, -0.30068633f, -0.97242820f, -0.58300596f, -0.51025987f, -0.39950374f, -0.42629194f, 
    -0.71565431f, -0.30235538f, 0.63497216f, 1.23158813f, -0.23323901f, -0.39047951f, 0.34563980f, -0.77421576f, 
    -0.41758063f, 0.09475240f, 0.42834920f, -0.83492738f, -0.87448132f, 0.26847699f, 1.25532448f, -0.74066764f, 
    -0.42428541f, 0.10538094f, -0.01079567f, 0.40531713f, -1.08036923f, -0.67429721f, -0.86357594f, 1.14947200f, 
    0.91810310f, 0.27863014f, -0.00637496f, -0.28213236f, -0.09199326f, -0.78216940f, -0.45062011f, 0.15416864f, 
    0.56779563f, 0.37263739f, 0.55171376f, -0.55255377f, -0.68178242f, -0.50951087f, -0.25668877f, -0.61137122f, 
    -0.08396591f, -0.15856747f, -0.36333171f, 0.59797990f, 0.42683396f, 0.41276261f, 0.38827655f, 0.16598618f, 
    -0.44052288f, 0.29493147f, -0.04128694f, -0.51743430f, -0.66153616f, 0.63877451f, 0.75867182f, 0.62437212f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.22785541f, 0.65814143f, -0.47477803f, 0.34900701f, 0.16448310f, -0.18847083f, -0.35005543f, 0.06414465f, 
    0.08795827f, 0.41326550f, 0.04209997f, 0.22059041f, 0.57400447f, 0.07074307f, 0.41122878f, -0.00914905f, 
    -0.04869874f, -0.51320839f, 0.09832102f, 0.09351234f, 0.17162801f, 0.15498026f, 0.65725696f, 0.27732661f, 
    -0.31684333f, -0.47301334f, 0.09618155f, -0.05863939f, 0.10586593f, 0.10485369f, 0.12980373f, 0.08731712f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.05290882f, 0.00251862f, -0.16801833f, -0.13042003f, 0.00149657f, 0.08556350f, 0.04469639f, 0.16337967f, 
    -0.02462358f, -0.01517418f, 0.17736074f, -0.03518824f, 0.05225994f, 0.17837247f, -0.10528912f, 0.01468475f, 
    0.20551221f, 0.16570874f, -0.09889366f, -0.37050414f, -0.04658502f, 0.09200222f, 0.10224702f, -0.09144519f, 
    0.10937579f, -0.05001522f, 0.08998781f, -0.23178811f, 0.18722680f, -0.00013812f, 0.15034322f, 0.23983295f, 
    0.08881465f, 0.12179336f, 0.00479401f, 0.14327267f, 0.12305883f, -0.49365538f, -0.14679775f, 0.04646935f, 
    0.03938691f, -0.02034179f, 0.03833909f, -0.03784553f, 0.07141478f, -0.01739003f, 0.29717103f, -0.15248305f, 
    -0.15645909f, 0.00644200f, -0.07351401f, -0.14674735f, -0.06367011f, -0.09259883f, -0.02380096f, -0.41755998f, 
    -0.18392040f, -0.05726183f, 0.06358772f, 0.12616420f, -0.05939665f, 0.04408566f, 0.03041571f, -0.22647214f, 
    -0.02799068f, -0.06307393f, 0.28884676f, -0.03379556f, -0.13861784f, -0.04140685f, -0.17525010f, 0.11963362f, 
    -0.06895665f, -0.05886943f, -0.06752923f, -0.04334382f, -0.11303104f, 0.10193042f, 0.12363750f, 0.13576607f, 
    0.21875428f, 0.10433087f, -0.15145910f, 0.03320578f, 0.05059345f, -0.18752013f, -0.04104498f, 0.01381238f, 
    0.00619548f, 0.00587395f, -0.40629876f, -0.36159381f, -0.35167062f, 0.00680090f, -0.05402968f, -0.14725600f, 
    0.17851071f, -0.12433103f, 0.02342120f, -0.17519854f, 0.22311012f, 0.29038671f, 0.13097332f, 0.04927073f, 
    -0.12622361f, -0.01811838f, 0.02578996f, 0.11754151f, 0.10080410f, 0.15366553f, 0.09561015f, 0.19486080f, 
    0.08519002f, -0.09001023f, -0.06019681f, 0.03538552f, 0.22820829f, 0.02249996f, 0.09979083f, 0.19867247f, 
    0.01270858f, 0.35601863f, -0.22907503f, 0.00971999f, 0.07293525f, 0.23160556f, -0.02426663f, -0.20751701f, 
    0.32456532f, -0.03259607f, 0.01804138f, 0.08869400f, -0.01177065f, 0.10043608f, 0.18133482f, -0.13373202f, 
    -0.03648185f, 0.04292387f, 0.01512345f, -0.02998508f, 0.15231273f, 0.03932537f, 0.08975365f, -0.09468989f, 
    -0.07665546f, -0.17671205f, 0.07753396f, -0.02446131f, -0.04151236f, 0.09043584f, -0.11534642f, 0.23202781f, 
    0.10878000f, -0.20795056f, 0.30438203f, -0.02707130f, -0.11531218f, 0.01394665f, -0.10821137f, 0.15309623f, 
    -0.04171498f, 0.20458288f, -0.32614890f, -0.00834696f, 0.15971482f, 0.06133781f, 0.00935254f, 0.05864650f, 
    0.17027639f, 0.01208252f, 0.04627972f, -0.06380852f, 0.07856616f, -0.10002985f, -0.05474478f, 0.06038952f, 
    -0.05479699f, 0.00046314f, 0.11333082f, -0.17436914f, -0.14850457f, 0.19417807f, 0.49805671f, 0.01166769f, 
    0.06820124f, 0.15549642f, 0.02894987f, -0.12958296f, 0.04275590f, -0.20337106f, 0.23522262f, -0.06861065f, 
    -0.01261361f, 0.10046946f, -0.08715540f, -0.06453869f, 0.06780691f, -0.11606959f, -0.09676692f, -0.37125784f, 
    0.00368447f, -0.02435132f, -0.05046688f, 0.04428219f, 0.15660334f, -0.14153603f, 0.15822603f, 0.21746759f, 
    -0.03684135f, -0.10990816f, 0.06684286f, 0.16891803f, -0.05125961f, 0.00408234f, 0.10710824f, -0.20053752f, 
    0.01716653f, -0.21705458f, -0.48851088f, 0.05621141f, -0.06010948f, -0.04274176f, 0.11766673f, -0.13804932f, 
    0.07812690f, 0.01467485f, -0.13448852f, 0.02644672f, 0.03449807f, -0.04459371f, 0.09128839f, 0.02758161f, 
    0.00660996f, 0.12663904f, 0.03337810f, 0.24073127f, 0.22871764f, 0.06587626f, 0.23405787f, 0.00471062f, 
    0.03838914f, 0.14036456f, -0.24450730f, -0.58530128f, 0.17199890f, -0.08140310f, 0.15318054f, -0.33253381f, 
    0.15565152f, -0.12020760f, -0.13348565f, 0.08514550f, -0.29376987f, 0.08314709f, 0.15473078f, -0.11284891f, 
    -0.11099240f, 0.19936684f, -0.19431223f, 0.13145827f, 0.18837713f, 0.23828992f, 0.18850784f, -0.03790776f, 
    -0.20418143f, 0.05594179f, 0.09980687f, -0.23074977f, 0.04674708f, 0.05033364f, -0.02281935f, 0.20635884f, 
    0.10600508f, -0.06480693f, -0.00448077f, -0.14798625f, 0.10183485f, 0.03300890f, -0.03649233f, -0.00963669f, 
    0.03363530f, -0.06070902f, -0.04639561f, 0.07009888f, -0.11763772f, 0.19433513f, -0.05424461f, -0.19662291f, 
    0.06001833f, -0.04596898f, -0.05934118f, -0.25483367f, -0.13334601f, 0.20723942f, 0.09353144f, 0.10729709f, 
    0.07491045f, 0.05992319f, -0.02855671f, 0.19162494f, 0.10100055f, 0.04814986f, -0.02834370f, 0.08101518f, 
    0.16726300f, 0.26553082f, -0.11774082f, -0.22453032f, 0.08228942f, -0.05479748f, -0.05900439f, -0.10361304f, 
    -0.06666779f, -0.13561198f, 0.13150090f, 0.02173997f, -0.03609172f, 0.21394856f, 0.21033187f, -0.02549117f, 
    -0.19659486f, -0.16387872f, -0.03844159f, 0.11900357f, -0.43115595f, -0.15839149f, 0.29926524f, 0.09943182f, 
    0.03952873f, -0.04981131f, 0.07322650f, 0.01984734f, 0.07854640f, 0.08617883f, 0.02726760f, -0.14999512f, 
    -0.08774128f, -0.09905340f, -0.09759495f, -0.05290598f, 0.11187360f, 0.17901146f, -0.25013906f, -0.46451890f, 
    -0.10367551f, 0.02048426f, -0.06340774f, 0.04637934f, -0.23255165f, -0.05101904f, -0.06926847f, -0.24828018f, 
    0.07516093f, 0.24469064f, -0.02800440f, 0.04678935f, -0.02810297f, -0.02896421f, -0.07633360f, 0.06161141f, 
    -0.05790183f, -0.02794758f, 0.00980722f, -0.12462724f, -0.12355794f, -0.03293312f, 0.15689239f, 0.05493429f, 
    0.21465306f, -0.05111720f, 0.34182227f, 0.02090305f, 0.11699435f, -0.02267670f, 0.05170682f, -0.09585066f, 
    0.10598610f, -0.16591462f, -0.28609335f, -0.65483910f, -0.02652612f, -0.16514257f, -0.00291210f, -0.14551245f, 
    0.14793171f, -0.05081958f, 0.11253531f, 0.14431120f, 0.14464231f, 0.30651316f, -0.17995293f, -0.03188640f, 
    0.04426873f, 0.06418051f, 0.03546570f, 0.06326991f, 0.14071716f, -0.01181770f, 0.17039917f, 0.03224017f, 
    0.08112922f, -0.31155419f, -0.00405845f, 0.10477881f, 0.21339901f, 0.27773064f, 0.09870069f, 0.71278352f, 
    0.06157479f, 0.13127525f, -0.21668950f, -0.04022491f, 0.07388479f, 0.29860952f, -0.23057060f, 0.24790615f, 
    0.59596944f, 0.07607240f, -0.00864696f, 0.01284292f, -0.01965198f, -0.01594488f, 0.28417549f, -0.13122796f, 
    -0.03537930f, 0.07534369f, -0.09606221f, 0.00728812f, -0.05515354f, 0.13109787f, 0.08668386f, 0.13502109f, 
    -0.11265251f, 0.08489195f, 0.15507101f, -0.18561164f, 0.04250728f, -0.11999673f, -0.01693724f, -0.06382968f, 
    0.51096177f, -0.16897616f, -0.24171476f, -0.13262221f, 0.01985448f, -0.09275696f, -0.05825918f, 0.08153249f, 
    0.01689019f, 0.07685810f, -0.12530477f, 0.07506729f, 0.10900072f, 0.01650975f, 0.01763766f, 0.00322756f, 
    0.29453343f, -0.03721359f, 0.17211482f, -0.13088751f, -0.03855480f, 0.01164309f, -0.13289542f, 0.07106716f, 
    -0.11534607f, -0.03375691f, 0.12584049f, 0.24515052f, -0.24864091f, -0.07627191f, 0.07831123f, 0.17785154f, 
    0.01721951f, 0.04475122f, 0.22225013f, -0.15477379f, 0.09451576f, 0.05140503f, -0.07685313f, -0.20286353f, 
    0.04075236f, -0.05007137f, -0.00309175f, 0.02823662f, 0.10384145f, -0.01357811f, -0.25966141f, -0.19622073f, 
    0.29428592f, 0.09120347f, 0.12034293f, -0.05463634f, 0.00927667f, -0.01278796f, 0.10304572f, -0.13196670f, 
    -0.21830063f, -0.38307235f, 0.07948327f, 0.21178228f, -0.15372318f, 0.10982961f, 0.02336270f, -0.04978557f, 
    -0.24757829f, -0.48415717f, -0.18567525f, -0.15477428f, 0.03166927f, -0.20946600f, -0.01097835f, -0.06994125f, 
    0.08003505f, -0.35941136f, -0.47247997f, -0.18825662f, -0.12558231f, -0.08882248f, 0.07596200f, -0.04258962f, 
    -0.10965011f, -0.12745522f, 0.02114871f, -0.11608829f, 0.21857190f, 0.02553311f, -0.00611486f, 0.02092150f, 
    -0.17901278f, 0.00829314f, -0.04656475f, -0.50670987f, -0.42034140f, 0.29097641f, -0.09265106f, 0.14341800f, 
    -0.13420092f, -0.13517512f, 0.11181115f, -0.05581585f, -0.29688147f, 0.15744179f, 0.44869897f, 0.06858493f, 
    -0.03752263f, 0.26716620f, -0.04120915f, 0.09963178f, 0.19044247f, 0.06444464f, -0.01984887f, -0.03432554f, 
    -0.05630876f, 0.03352293f, 0.14346249f, 0.01528157f, 0.19775002f, 0.34917429f, -0.02648349f, 0.20060948f, 
    -0.10758746f, -0.29942629f, -0.08070858f, -0.04833976f, 0.02334819f, 0.00501312f, -0.03670439f, -0.23656727f, 
    -0.23723648f, -0.02256209f, -0.21402541f, -0.01430157f, -0.06836870f, 0.14442809f, 0.02294592f, -0.03492738f, 
    0.02332241f, -0.15318593f, -0.10032416f, -0.02569270f, -0.14462085f, -0.14138336f, -0.17189990f, -0.06687330f, 
    -0.13847794f, 0.04966250f, -0.14389896f, 0.07642816f, 0.06699901f, 0.22311535f, -0.36296871f, -0.21119818f, 
    -0.00317990f, -0.01442430f, 0.02836882f, 0.15815437f, 0.37806141f, 0.00876536f, -0.15619756f, 0.03129530f, 
    0.15990248f, 0.13154201f, -0.06824767f, -0.21898367f, -0.25554970f, -0.07539112f, -0.05823703f, -0.24443069f, 
    0.07050875f, -0.06257686f, -0.07881358f, 0.01624385f, -0.00085365f, 0.01791328f, 0.25793561f, 0.12295108f, 
    -0.02385964f, 0.02467527f, -0.06667078f, 0.03985872f, 0.04212692f, -0.15595366f, -0.41840389f, 0.03091347f, 
    -0.06420281f, 0.02034071f, -0.17102639f, 0.00464012f, 0.04673484f, 0.08953625f, -0.09929886f, 0.30037317f, 
    0.23673268f, 0.25503752f, -0.17155899f, -0.06454382f, 0.30680031f, 0.06525815f, 0.20014861f, -0.01989352f, 
    0.23071383f, 0.31594688f, 0.01466996f, 0.09307183f, 0.17234302f, -0.02040654f, 0.16767259f, 0.17568891f, 
    0.01732724f, -0.19012193f, -0.25135705f, 0.02809733f, -0.00391003f, -0.12829134f, -0.15901528f, -0.01925493f, 
    0.20026022f, 0.02330086f, 0.23162903f, -0.12853009f, -0.04287427f, 0.09067255f, 0.05061338f, -0.04787942f, 
    -0.00647668f, 0.10376166f, 0.13810082f, 0.16326645f, 0.34140915f, 0.06450814f, -0.01624274f, 0.21171391f, 
    -0.03217555f, 0.00493532f, 0.05804883f, -0.15463072f, -0.20966093f, 0.09835395f, -0.05853115f, -0.02612533f, 
    -0.02386200f, -0.08151903f, 0.05220098f, -0.05823282f, -0.17381887f, -0.19423553f, -0.12956719f, -0.07438207f, 
    0.10717057f, 0.04565791f, -0.11908148f, -0.06272206f, -0.13589492f, -0.12591013f, 0.00320390f, 0.16606897f, 
    -0.05170387f, -0.09511264f, -0.15001260f, 0.04312184f, 0.04661229f, 0.01832689f, 0.12599745f, 0.24067596f, 
    0.25426698f, 0.11014821f, -0.08854724f, -0.00000490f, 0.16686709f, -0.06391684f, -0.04298415f, 0.04247886f, 
    -0.15943275f, -0.42439786f, -0.20310985f, 0.05135126f, -0.05458667f, -0.22638397f, -0.17305188f, -0.00820505f, 
    -0.04011553f, -0.30338281f, -0.03304946f, -0.26618260f, -0.05823026f, 0.25694689f, 0.07342543f, -0.10730611f, 
    -0.05579217f, 0.01509933f, 0.09808026f, 0.05142658f, 0.02914709f, 0.08231571f, -0.24918897f, -0.02587071f, 
    0.01830500f, -0.03177975f, 0.12191339f, -0.22149341f, -0.04936298f, 0.12488018f, -0.02982737f, 0.11694021f, 
    0.05202043f, -0.07738031f, -0.01990386f, -0.24956913f, -0.50105417f, -0.29993206f, -0.05176210f, -0.01513026f, 
    -0.04545807f, -0.12612082f, 0.00639217f, -0.11809609f, -0.64133406f, -0.06640122f, -0.56512910f, -0.02020278f, 
    -0.22373992f, -0.15856059f, -0.05116755f, -0.05326683f, -0.08080948f, -0.04458153f, 0.03524156f, -0.50477982f, 
    -0.15879267f, 0.17595586f, -0.20639502f, 0.00103962f, 0.29203162f, 0.17840977f, 0.05379194f, 0.23359688f, 
    0.08825456f, 0.07515687f, 0.07911804f, 0.15974012f, 0.12091494f, -0.00204843f, -0.08950923f, -0.12471007f, 
    -0.21276824f, 0.12988488f, 0.16186419f, -0.12382367f, -0.00778385f, -0.24743694f, -0.12489892f, 0.10992718f, 
    0.00470347f, 0.46550024f, 0.36380824f, -0.12837051f, -0.17624603f, 0.18995531f, 0.01448766f, 0.10683225f, 
    0.03753091f, 0.14789541f, 0.23466626f, 0.16043442f, 0.11163807f, -0.06498136f, -0.00655724f, -0.03214096f, 
    -0.00803994f, 0.08446557f, -0.70608580f, -0.49008837f, 0.05041591f, -0.07287569f, -0.29616523f, -0.14592434f, 
    -0.03628259f, 0.08324986f, -0.12117359f, -0.04968351f, 0.20756371f, 0.29343781f, -0.08289795f, 0.14334066f, 
    0.01547256f, -0.11256708f, 0.19686684f, 0.16697758f, -0.06511477f, 0.35261241f, 0.62207699f, 0.16027804f, 
    -0.18166013f, -0.11995074f, 0.04109529f, -0.17466547f, -0.01099258f, -0.20768614f, -0.07320368f, 0.14063551f, 
    0.04068827f, 0.03596440f, -0.06179485f, 0.17293411f, 0.00573718f, -0.02510816f, -0.07240298f, 0.00212899f, 
    -0.35006884f, 0.16763672f, 0.04813091f, 0.20151058f, 0.09605531f, 0.07858809f, 0.00866091f, 0.24666299f, 
    0.07060124f, 0.06559043f, 0.03847224f, -0.13251115f, 0.22550759f, 0.01929582f, 0.23790501f, 0.19051474f, 
    0.08658904f, -0.04214576f, -0.09212287f, 0.05929380f, -0.04454340f, -0.01337010f, 0.04427025f, 0.17564102f, 
    -0.19086380f, -0.13348195f, -0.13050899f, 0.14763978f, -0.22606504f, -0.21568656f, -0.01902458f, -0.18661731f, 
    -0.03126379f, -0.11117255f, 0.32089567f, 0.33165538f, -0.26134366f, 0.03580903f, 0.03470128f, -0.19083944f, 
    0.10621872f, 0.03144494f, 0.03335837f, 0.11063270f, 0.12089396f, 0.51797527f, 0.00963663f, 0.01863706f, 
    -0.10830513f, -0.03888365f, 0.35146633f, 0.00636149f, -0.15433243f, -0.31919026f, 0.18151972f, -0.10158660f, 
    -0.18775882f, 0.15327585f, -0.01266525f, -0.02148370f, 0.01271539f, -0.72252297f, -0.18257284f, 0.12534006f, 
    -0.03186530f, 0.22725528f, -0.14031953f, -0.07678828f, -0.09359496f, 0.02233191f, 0.28781572f, 0.56421554f, 
    -0.20045415f, 0.16946885f, 0.16858882f, 0.02068886f, 0.13978910f, 0.01594990f, 0.12155604f, 0.24495588f, 
    0.09355511f, -0.11177462f, -0.06044285f, -0.16325541f, -0.25053185f, -0.20737797f, -0.12255293f, -0.18079372f, 
    0.12060583f, -0.04740526f, 0.14806241f, -0.02063726f, -0.01884064f, -0.09597413f, 0.22054324f, 0.05223554f, 
    -0.25352907f, 0.02813848f, -0.26622549f, -0.21239860f, -0.02616465f, -0.04477355f, 0.38528216f, -0.03158694f, 
    -0.00531296f, -0.10826571f, -0.48732123f, -0.08527626f, -0.00521126f, -0.18855111f, -0.12994875f, -0.17501938f, 
    -0.03794384f, -0.10263374f, -0.01392102f, 0.10880806f, -0.32784197f, -0.32830533f, 0.07117365f, -0.02437574f, 
    -0.19636954f, 0.01174565f, 0.03864338f, 0.11775627f, -0.12852286f, 0.29312989f, 0.08585123f, 0.07977687f, 
    0.02887609f, 0.14242715f, 0.04831659f, 0.03505892f, 0.12231734f, -0.14274207f, -0.09691352f, 0.01291513f, 
    0.09999131f, -0.04280612f, -0.04011994f, -0.04313841f, -0.01814374f, 0.20499900f, -0.08924909f, -0.27809122f, 
    0.31572992f, -0.09713791f, 0.28280625f, -0.00618575f, 0.01370820f, 0.10200091f, -0.00269081f, 0.22886591f, 
    -0.12273140f, 0.27232304f, 0.12548405f, -0.02316155f, 0.01145000f, 0.17974618f, 0.03804124f, -0.01791007f, 
    0.23087457f, 0.19918001f, 0.40712675f, 0.00293817f, 0.02040721f, -0.06338987f, 0.02017215f, 0.13429131f, 
    0.22296812f, -0.75691336f, -0.03086057f, 0.17031708f, 0.10746010f, 0.16878822f, -0.18283567f, -0.03436653f, 
    0.09354611f, -0.15006642f, 0.19977267f, 0.24303579f, 0.00861646f, 0.04022713f, -0.07664397f, 0.04976946f, 
    0.00822881f, -0.06678369f, 0.10385875f, 0.12597547f, -0.02168258f, 0.35181579f, 0.07679611f, -0.05256297f, 
    -0.08567969f, 0.06414563f, 0.15886444f, 0.06240156f, 0.31568024f, 0.29575172f, 0.65982497f, -0.18253310f, 
    0.10441335f, -0.00763909f, -0.09564873f, 0.02059799f, 0.12224670f, -0.17414373f, 0.11683230f, -0.11139100f, 
    0.21074207f, 0.10880115f, -0.18321976f, 0.21521847f, -0.22634806f, -0.02138920f, -0.22601967f, -0.15098281f, 
    0.04622809f, 0.07185887f, 0.08157844f, 0.11193140f, 0.12007940f, 0.00305207f, 0.02271507f, 0.13343932f, 
    -0.06567199f, 0.14639093f, 0.13631885f, 0.00305756f, 0.21784350f, -0.10849311f, -0.06249607f, 0.02249962f, 
    -0.08330234f, 0.34018224f, 0.38662890f, -0.18561751f, -0.24272940f, -0.21726346f, 0.04678369f, -0.04930127f, 
    0.00587848f, 0.27782995f, 0.15256476f, -0.33821732f, 0.02532282f, 0.06803392f, 0.02363698f, 0.07796373f, 
    -0.00690658f, 0.06828411f, 0.27070692f, 0.41363060f, 0.19093856f, 0.11433052f, -0.31302693f, 0.02906530f, 
    0.24011239f, -0.03143608f, -0.01186603f, -0.35077700f, -0.10704631f, 1.18094730f, -0.25230506f, 0.05309419f, 
    -0.35780492f, -0.28881964f, -0.17730810f, -0.03498413f, 0.25106508f, -0.46120593f, -0.40002656f, -0.09497335f, 
    -0.16690083f, -0.15517551f, -0.18925345f, -0.10585388f, 0.00808965f, -0.21204717f, -0.00599317f, -0.27581206f, 
    -0.02510604f, 0.16907068f, -0.06448628f, 0.02861414f, -0.07493858f, 0.12886390f, -0.25134438f, -0.12346326f, 
    -0.16681987f, 0.23004848f, 0.05392836f, -0.00589288f, 0.08725187f, -0.06582383f, 0.07284229f, -0.11312494f, 
    -0.33522308f, 0.12182482f, 0.20917551f, 0.12067463f, -0.09314606f, -0.13407922f, 0.12423813f, 0.06564621f, 
    -0.21628019f, -0.29195637f, -0.27385768f, -0.02445512f, -0.29896653f, -0.11718649f, -0.11300261f, -0.09312289f, 
    0.22208582f, 0.08430566f, 0.35503516f, 0.27361357f, -0.22586380f, 0.12508519f, -0.15305483f, 0.01940420f, 
    0.23783608f, -0.07061920f, 0.14501387f, 0.36992356f, 0.25715631f, -0.01930812f, -0.08535020f, 0.14232340f, 
    0.13512817f, 0.09393612f, 0.00049249f, -0.29131755f, 0.20691118f, 0.17396042f, -0.43681613f, 0.12094072f, 
    -0.25698853f, -0.08881301f, 0.31988317f, 0.17181937f, 0.02962699f, 0.50466520f, 0.28853163f, -0.13483897f, 
    -0.11708739f, -0.01913494f, 0.04106249f, 0.02543777f, -0.09507744f, -0.94514245f, -0.43900713f, 0.26857367f, 
    -0.08612729f, 0.08384133f, -0.22399731f, -0.03165635f, -0.06493706f, 0.08546662f, -0.41328448f, -0.02051146f, 
    -0.61652875f, -0.12782174f, -0.21135350f, 0.11470283f, 0.09404083f, -0.04517579f, -0.04141051f, -0.10006413f, 
    0.13674486f, 0.03447167f, 0.00979966f, 0.02899146f, -0.14912130f, 0.18246138f, -0.05927938f, 0.13111891f, 
    0.18388967f, 0.01439497f, 0.30131340f, -0.20699900f, -0.25498900f, -0.47294748f, -0.04762089f, -0.02235596f, 
    0.23277602f, -0.10865744f, -0.29137647f, -0.38759157f, 0.11280774f, -0.04635961f, 0.18374896f, -0.08437622f, 
    -0.03783972f, -0.03397958f, 0.13244730f, 0.55473483f, 0.30534136f, 0.03977212f, 0.09718566f, -0.08521279f, 
    0.03822181f, 0.01425899f, 0.09747086f, 0.23664418f, 0.16427012f, -0.29070878f, -0.06621964f, -0.02526140f, 
    0.24167401f, 0.16302674f, -0.08292783f, 0.12357183f, -0.15732893f, 0.12672564f, 0.11339025f, 0.09455152f, 
    0.05705063f, -0.07244877f, -0.16472119f, 0.20848361f, -0.05468139f, 0.07971763f, 0.57987005f, 0.16017972f, 
    -0.20267528f, -0.02908030f, -0.24741970f, -0.02676633f, 0.46944264f, -0.05182267f, -0.21959910f, 0.25678751f, 
    0.08601671f, -0.03950414f, -0.18540461f, -0.17301099f, -0.01404661f, 0.08586115f, 0.06459627f, 0.28592336f, 
    0.29896551f, -0.01178850f, -0.21898040f, -0.28859150f, -0.31785715f, 0.08193559f, -0.02574201f, 0.08764565f, 
    -0.23514387f, 0.05045956f, 0.31737053f, -0.23376894f, -0.15131508f, -0.26536375f, -0.10998884f, -0.04661497f, 
    0.19976813f, -0.18512444f, -0.07641882f, -0.01118082f, -0.22776575f, 0.19257882f, -0.08687067f, -0.08400863f, 
    -0.09596287f, 0.05549739f, -0.47541529f, -0.20703851f, 0.32818267f, -0.16219522f, -0.02016529f, -0.15529662f, 
    -0.09618121f, 0.00843224f, 0.11580802f, -0.02316796f, 0.23178399f, 0.54949981f, -0.10002400f, -0.26805151f, 
    -0.28330806f, 0.20579259f, 0.07615350f, 0.13415805f, -0.60769737f, -0.57039672f, -0.07080017f, 0.00184094f, 
    0.35522780f, 0.55756938f, 0.15166290f, -0.11624515f, -0.10650826f, -0.63276815f, 0.35912791f, -0.31465092f, 
    -0.19174570f, 0.13184114f, 0.14180787f, -0.10677256f, -0.00983464f, 0.07921720f, 0.02749643f, 0.49785158f, 
    0.17573813f, 0.05910214f, -0.01719205f, 0.01398394f, -0.04624448f, 0.08391526f, 0.04189413f, -0.30709916f, 
    -0.17852964f, 0.09128487f, -0.00453555f, -0.01793150f, 0.02620975f, -0.09287886f, 0.07980648f, -0.05296969f, 
    0.25622031f, 0.34214917f, 0.12692505f, 0.04004288f, -0.02178470f, -0.30609626f, 0.10592002f, 0.08298206f, 
    0.08635185f, 0.09772474f, -0.05055468f, 0.02170780f, 0.05678274f, -0.25415787f, -0.06294289f, 0.14084551f, 
    -0.02062963f, 0.24056178f, -0.45693490f, -0.11394522f, 0.28113353f, -0.16970873f, 0.23358491f, -0.08720706f, 
    -0.30044678f, 0.06316656f, 0.02865251f, -0.06115726f, -0.00884561f, 0.34064692f, -0.02166730f, -0.00412478f, 
    -0.47030962f, -0.00060883f, -0.05372693f, 0.11720257f, -0.36516151f, -0.10293595f, -0.33944002f, -0.09939474f, 
    -0.00410092f, -0.09198232f, 0.05717540f, -0.12076089f, 0.05255677f, -0.32097927f, 0.03755539f, -0.36238629f, 
    -0.14433940f, 0.01330349f, -0.16082402f, -0.00960961f, -0.08865512f, -0.19686148f, -0.02789123f, 0.36447206f, 
    -0.09978306f, -0.05910437f, 0.03523793f, 0.08542274f, 0.01004331f, -0.11761207f, 0.08931379f, -0.01938672f, 
    0.18668146f, -0.13897656f, 0.10432637f, 0.01101006f, -0.03396325f, 0.05700039f, -0.04561301f, 0.21577646f, 
    -0.00393413f, 0.05385376f, 0.00718248f, -0.02476134f, -0.02784285f, 0.01481131f, -0.00738018f, -0.05166792f, 
    0.00625884f, -0.04014729f, -0.04411689f, -0.01530215f, -0.03757551f, 0.04146418f, -0.00008099f, 0.01481294f, 
    -0.04844612f, -0.06598651f, -0.02363761f, -0.06718142f, 0.01781591f, 0.04211673f, -0.03640349f, 0.01487637f, 
    -0.03493118f, -0.03724204f, 0.01144151f, -0.02658193f, -0.00121652f, 0.03872625f, -0.03425503f, -0.03970415f, 
    -0.00549912f, -0.02842820f, 0.00951907f, 0.02098326f, 0.03576063f, -0.04513051f, -0.03309502f, 0.01954434f, 
    -0.01200420f, -0.02059000f, -0.02392744f, -0.00841739f, -0.02442141f, 0.00261024f, 0.02417360f, -0.06302852f, 
    -0.03511446f, -0.03967521f, 0.01690421f, 0.03198844f, 0.03086183f, -0.03645010f, -0.00446366f, 0.04755474f, 
    -0.00642713f, 0.00724128f, -0.05203055f, 0.04634595f, -0.03067096f, -0.00568904f, -0.00955588f, 0.02661314f, 
    -0.04266189f, 0.03739557f, -0.02854622f, -0.02268549f, 0.04554371f, 0.01193987f, 0.02559714f, -0.03889868f, 
    -0.04062310f, -0.05200126f, -0.05252180f, -0.04206045f, 0.01078726f, 0.03761230f, -0.02897085f, 0.03309551f, 
    0.03525366f, -0.03959186f, 0.03814538f, 0.00465842f, -0.02747945f, -0.00200334f, 0.04476322f, 0.00181958f, 
    -0.01480562f, -0.00955681f, -0.00240624f, 0.03715163f, 0.00298016f, 0.02226993f, -0.03188510f, -0.01896478f, 
    -0.05374792f, 0.01953898f, -0.03656063f, -0.05253754f, -0.00899992f, -0.03362390f, -0.03754623f, -0.00161441f, 
    0.02362251f, -0.04617279f, -0.03110579f, 0.02318263f, 0.04775786f, -0.02215091f, -0.06004621f, 0.04975289f, 
    -0.06112933f, 0.01327514f, 0.00873185f, -0.04652824f, 0.01378089f, 0.00119196f, -0.00790852f, 0.02307140f, 
    0.01133526f, -0.06033570f, -0.01254448f, -0.01497178f, -0.04129194f, -0.06516768f, 0.00012206f, 0.03637388f, 
    0.02439290f, -0.03446744f, -0.01125905f, -0.02104824f, 0.02043626f, -0.00431398f, -0.00658080f, 0.05186925f, 
    -0.00711375f, 0.00764810f, -0.06023618f, -0.01906351f, 0.04630055f, -0.01597995f, 0.03030522f, 0.02516772f, 
    -0.05737019f, -0.00653559f, 0.01926189f, -0.00594151f, 0.00791817f, 0.05070229f, 0.01237569f, -0.00367408f, 
    -0.03274205f, 0.03399125f, -0.00039248f, -0.00448817f, 0.04580394f, 0.04017587f, 0.01959464f, 0.02277860f, 
    0.00206264f, -0.04830216f, 0.00524432f, -0.01226159f, 0.02215657f, 0.05254288f, 0.02683522f, -0.03773216f, 
    0.04547546f, 0.00352331f, 0.03267887f, -0.06068276f, 0.01296150f, -0.04263918f, -0.00887829f, -0.04678091f, 
    -0.04769661f, 0.04189467f, -0.04111627f, -0.05150032f, 0.01970991f, 0.00092885f, 0.04940078f, -0.04741661f, 
    0.01314818f, -0.01571035f, 0.01593224f, -0.04776574f, -0.03966691f, -0.01329668f, -0.02390380f, -0.04459208f, 
    0.00523650f, 0.03166176f, 0.00369585f, -0.02990785f, -0.04036177f, -0.01166136f, 0.02853937f, 0.00367450f, 
    -0.04411603f, 0.00711200f, -0.00172824f, -0.02869162f, -0.00286238f, -0.05708102f, -0.02408832f, -0.05145513f, 
    0.03329372f, -0.05592469f, -0.05100335f, -0.02575605f, 0.02533632f, -0.04248817f, -0.05758939f, 0.00736242f, 
    0.00090847f, -0.02668439f, 0.04571167f, 0.01480748f, 0.00090710f, 0.01734434f, 0.00849099f, 0.00393958f, 
    -0.04495309f, -0.05811140f, -0.00482104f, -0.03903795f, 0.00957270f, 0.04102029f, -0.05060114f, -0.00656707f, 
    0.05354948f, 0.05979628f, -0.05209972f, 0.00776931f, -0.06161563f, 0.02054984f, -0.05523470f, 0.01148113f, 
    -0.00401565f, -0.01655633f, -0.05903366f, -0.04034502f, -0.04946682f, 0.00768720f, 0.00195235f, -0.05018591f, 
    0.02258966f, -0.03921255f, -0.04438176f, 0.05989833f, -0.03244542f, 0.01685652f, -0.00011604f, -0.01235221f, 
    0.04777056f, 0.04396025f, -0.06425186f, -0.00675495f, 0.04152902f, -0.01277823f, 0.03690135f, -0.03429853f, 
    0.01848497f, -0.01645972f, -0.04070879f, 0.03664164f, -0.06061387f, -0.05821981f, 0.02985474f, 0.04457682f, 
    -0.02682098f, -0.00741904f, 0.04459973f, -0.06325997f, 0.01411077f, 0.03696567f, 0.00972302f, 0.03647326f, 
    -0.06092298f, 0.00118431f, -0.01045718f, -0.00534081f, 0.03586234f, -0.02551781f, -0.05411443f, -0.00434121f, 
    -0.01097158f, -0.05113662f, -0.03859415f, -0.05090962f, 0.00807608f, 0.00397470f, -0.07275195f, 0.03370362f, 
    -0.02849086f, 0.02841578f, -0.05121592f, -0.01119499f, -0.04591424f, 0.00372695f, -0.01618520f, -0.03693759f, 
    0.03809959f, 0.03610902f, -0.02839327f, 0.04789066f, 0.02202926f, -0.07635849f, -0.01070947f, -0.00575132f, 
    -0.00126970f, -0.04423834f, 0.01547240f, -0.04802220f, 0.00051730f, -0.00527298f, 0.02831637f, 0.02488581f, 
    0.00361886f, 0.03853699f, -0.05452757f, 0.00747182f, -0.01306405f, -0.01506875f, 0.03797685f, 0.00543128f, 
    -0.01746509f, 0.01239729f, 0.00033219f, 0.01797715f, 0.03897026f, -0.01810207f, -0.07131630f, 0.04149776f, 
    -0.06967808f, -0.00608457f, 0.03868023f, 0.02021482f, 0.00069532f, 0.03718889f, -0.01454375f, 0.01241312f, 
    0.00882536f, -0.00047319f, 0.01530137f, -0.00985814f, -0.01488423f, 0.05949633f, 0.03521080f, -0.05484070f, 
    -0.04831405f, 0.01162061f, -0.00632899f, -0.02050928f, -0.02096415f, 0.02949859f, -0.00584535f, -0.07279172f, 
    -0.06455324f, -0.00358157f, 0.02075973f, 0.01055357f, 0.03387560f, -0.02782073f, 0.00774898f, 0.01352434f, 
    0.04893235f, -0.01711012f, 0.01196613f, -0.03794368f, -0.06803539f, -0.04786315f, 0.05052215f, 0.01828332f, 
    0.02920749f, -0.04431568f, 0.05568422f, 0.03762870f, -0.02822661f, 0.03889592f, 0.02175912f, 0.02251460f, 
    -0.01735112f, -0.06512406f, -0.03867392f, 0.01058876f, 0.03893965f, -0.00860104f, -0.04943409f, 0.00161857f, 
    -0.05648807f, 0.01400468f, 0.00851347f, 0.00687255f, 0.02581799f, -0.03574616f, -0.00966984f, -0.05295045f, 
    0.00589415f, -0.02757115f, 0.01465385f, 0.05641719f, 0.04229102f, -0.01305616f, 0.04170989f, -0.02988848f, 
    0.03930288f, 0.04307035f, 0.02006182f, 0.02474625f, 0.00816339f, -0.01595836f, -0.04365359f, -0.01394985f, 
    0.00153059f, -0.01586896f, 0.04045129f, -0.06490918f, -0.01922521f, -0.05059293f, 0.04669574f, -0.07460189f, 
    0.02763322f, -0.00616236f, -0.00637936f, 0.00219578f, 0.01701451f, -0.04984262f, -0.06154915f, 0.00385532f, 
    0.01496908f, -0.00512042f, 0.04944234f, -0.01018175f, -0.04762825f, 0.00486442f, -0.02986772f, -0.05156964f, 
    0.00474497f, -0.02487070f, 0.04419070f, 0.00155921f, 0.02441446f, -0.00534276f, -0.00140002f, -0.02829369f, 
    0.00278287f, 0.02390198f, -0.01260419f, -0.03134096f, -0.00685616f, -0.03992209f, -0.05293053f, -0.00575559f, 
    0.01858839f, -0.02564507f, -0.00803144f, -0.03554432f, 0.05112050f, -0.01650135f, 0.03242733f, 0.03765211f, 
    -0.05496947f, 0.04431849f, -0.01707791f, 0.06237229f, 0.02037263f, -0.02498545f, 0.03128079f, -0.03494354f, 
    0.00238953f, 0.04051313f, 0.02857547f, 0.01006041f, -0.01125010f, 0.02864020f, 0.01422113f, -0.07246596f, 
    -0.03520184f, 0.04320096f, -0.05544357f, 0.01095947f, -0.04136546f, -0.02456403f, -0.00794990f, -0.01878240f, 
    0.04890947f, -0.06269249f, -0.04345972f, 0.00988294f, -0.01993226f, -0.02965948f, -0.01566813f, -0.06776634f, 
    0.04621898f, -0.05149790f, -0.04706831f, -0.00067477f, 0.00997208f, 0.00649834f, -0.05111166f, 0.03541860f, 
    -0.06798316f, 0.01272508f, -0.02004094f, 0.00971783f, 0.04240498f, -0.01566583f, 0.01374829f, 0.03093617f, 
    -0.05912319f, -0.00249281f, -0.05562281f, 0.02045615f, 0.03100306f, -0.05118986f, -0.01722006f, 0.02648236f, 
    -0.03300867f, 0.03348756f, 0.03800340f, 0.06749538f, -0.02547539f, 0.01498423f, -0.04501679f, -0.02262696f, 
    -0.00198807f, -0.04008545f, 0.00371135f, -0.05666612f, 0.03025434f, 0.06460563f, 0.00242953f, -0.00823119f, 
    0.02003009f, -0.00467598f, 0.02731573f, -0.04417957f, -0.03563680f, 0.03794876f, 0.02303930f, -0.05063449f, 
    0.05368138f, -0.05371497f, 0.02693990f, 0.02566208f, -0.01143921f, 0.03630602f, -0.00056247f, -0.04767511f, 
    0.03007541f, -0.01835707f, 0.03886932f, -0.00178479f, -0.04321548f, -0.05639531f, 0.02912677f, -0.00039341f, 
    -0.01011050f, 0.01539099f, -0.00994522f, -0.05859155f, -0.02870308f, -0.02663459f, 0.04121807f, 0.04889734f, 
    0.01804278f, -0.02088203f, -0.05226371f, -0.04216876f, -0.04113183f, 0.02953505f, 0.03363036f, -0.04917897f, 
    -0.11946301f, 0.06475142f, -0.17171790f, -0.18664064f, -0.00151270f, -0.01883260f, 0.16106534f, 0.18201095f, 
    0.19017668f, -0.10311629f, -0.03688866f, 0.24611656f, 0.15070170f, 0.02373485f, 0.16254587f, 0.20870042f, 
    0.03124252f, 0.15773518f, -0.29868573f, -0.03474147f, 0.10340048f, -0.04805036f, -0.10762945f, -0.07875356f, 
    -0.04686253f, 0.02367698f, 0.09773320f, -0.20346580f, -0.41763225f, 0.20815498f, 0.01054595f, -0.11645362f, 
    -0.06924076f, 0.29786545f, 0.01218148f, 0.06324047f, 0.35149461f, -0.19186415f, 0.05822729f, 0.09620366f, 
    -0.03272185f, -0.09228168f, 0.10695965f, 0.10412177f, 0.13594714f, -0.70242184f, -0.14588228f, 0.03912069f, 
    -0.27014273f, -0.13675685f, -0.11211917f, -0.13348329f, -0.22127882f, -0.23834442f, -0.54280108f, -0.06036468f, 
    -0.30235231f, 0.12603144f, -0.08585939f, -0.15354589f, 0.12784480f, -0.06353654f, 0.06923751f, -0.08835468f, 
    -0.13817969f, 0.16565715f, 0.07662695f, 0.04823254f, -0.07860602f, 0.12786351f, -0.06934979f, 0.00504217f, 
    0.07417635f, -0.06242739f, -0.03294767f, -0.35720125f, -0.25862449f, 0.05913704f, 0.19400217f, 0.09715014f, 
    0.12428603f, 0.26327366f, 0.12727553f, 0.17697337f, 0.17711481f, -0.01627819f, 0.05097091f, 0.04008244f, 
    0.03703047f, 0.07138433f, 0.07972397f, 0.20185840f, 0.23476961f, -0.14767627f, -0.13480677f, -0.05979201f, 
    0.10592464f, 0.07199498f, 0.00431401f, -0.07265209f, 0.07504144f, -0.07736181f, 0.18892775f, 0.05931810f, 
    -0.14529742f, 0.09426831f, 0.08986669f, 0.08709076f, 0.01547296f, 0.13683012f, -0.30517656f, 0.20618093f, 
    0.11902931f, -0.12386188f, 0.23903655f, -0.18129480f, -0.10344528f, -0.17748946f, -0.26288718f, 0.12451284f, 
    0.17983727f, -0.13306794f, -0.10914534f, -0.07075135f, -0.01271244f, -0.00339390f, -0.34696791f, -0.10720884f, 
    0.15952070f, 0.06475585f, 0.10192354f, 0.09788456f, 0.13617535f, -0.04060600f, 0.13399477f, -0.06742779f, 
    -0.22044112f, 0.03056039f, -0.18409282f, -0.01881668f, -0.09926461f, 0.17181067f, 0.03096223f, -0.09339684f, 
    0.09011757f, -0.16604744f, -0.17209926f, -0.20094489f, -0.18057801f, 0.06609923f, 0.03423836f, 0.00791953f, 
    0.10648914f, -0.69954586f, -0.35840136f, 0.28139454f, 0.02736890f, -0.06508522f, 0.16631047f, -0.09558196f, 
    -0.02590858f, 0.21241340f, -0.06131497f, -0.42150420f, 0.15736426f, -0.02339100f, 0.00202589f, 0.01232947f, 
    0.09823134f, 0.06240432f, 0.01814392f, 0.04791879f, -0.00076419f, -0.05553688f, -0.06828849f, 0.01377595f, 
    -0.01514108f, -0.02743760f, 0.05847777f, -0.07714044f, 0.76883656f, -0.60790765f, -0.51435876f, -0.02390040f, 
    -0.18048503f, -0.10494439f, -0.17789048f, -0.36251009f, 0.10029150f, -0.28250876f, -0.22784774f, -0.36889946f, 
    -0.03514752f, 0.06849679f, -0.16766188f, 0.12340355f, 0.02319723f, 0.11163759f, 0.10975429f, 0.03397519f, 
    0.19013375f, 0.08983665f, 0.20637789f, 0.13713288f, 0.13045789f, -0.01149754f, 0.23541316f, 0.12437758f, 
    -0.01658695f, -0.27522615f, 0.08712301f, -0.06514709f, -0.01898357f, 0.06880460f, 0.09482206f, -0.03729496f, 
    -0.10920687f, 0.16031352f, 0.30383983f, -0.13039781f, -0.19881821f, -0.00759175f, 0.04773463f, -0.04274565f, 
    0.07006241f, -0.20853649f, -0.08908577f, -0.07344308f, -0.01455732f, -0.01785055f, 0.02473729f, 0.17639267f, 
    0.10014354f, 0.15301129f, 0.22241171f, -0.28999853f, -0.40186751f, 0.03812033f, -0.07815357f, -0.07400887f, 
    0.10097935f, -0.04061522f, -0.22875254f, -0.15401381f, -0.50837839f, 0.38448760f, -0.23777342f, 0.03866135f, 
    0.16930464f, 0.06000992f, -0.05751794f, 0.02004214f, -0.36067286f, 0.11531882f, 0.10375499f, 0.02903126f, 
    -0.01649208f, -0.26516780f, 0.21245033f, 0.01767229f, 0.10323934f, -0.10814968f, 0.23856992f, -0.03394468f, 
    0.03500276f, -0.10317466f, -0.18346971f, 0.04693378f, 0.02607171f, 0.03757113f, -0.12523828f, -0.25463185f, 
    0.21259621f, -0.11808079f, 0.04621780f, -0.01546564f, 0.10983373f, 0.08692623f, 0.04178704f, 0.01427754f, 
    0.04704413f, 0.03990064f, -0.24335107f, -0.01108115f, 0.01931899f, 0.05630462f, 0.12776953f, 0.03100220f, 
    -0.08897470f, 0.15962549f, -0.16769995f, 0.08466151f, 0.04852439f, 0.12039239f, 0.05666063f, 0.01651709f, 
    0.27973795f, 0.23312432f, 0.11035900f, 0.18819141f, 0.17200601f, 0.10818274f, 0.16005303f, 0.17480038f, 
    0.38109943f, 0.10895755f, 0.72825342f, -0.07530371f, -0.41191918f, -0.36247531f, -0.08929852f, -0.30250821f, 
    0.07783420f, 0.03611723f, -0.09391416f, -0.15311725f, 0.24265534f, 0.32048839f, 0.09484634f, 0.08238386f, 
    -0.11368699f, 0.03339993f, 0.09170491f, 0.05004636f, -0.26687804f, 0.15034637f, 0.38351843f, -0.23587626f, 
    -0.04215509f, -0.08003948f, 0.02112010f, 0.12801765f, -0.00105245f, -0.36570305f, -0.51420152f, -0.39097676f, 
    -0.09720840f, 0.17446381f, -0.35928664f, 0.11741265f, 0.08617639f, 0.05317952f, -0.13110548f, -0.02842816f, 
    -0.45599577f, 0.22552314f, -0.13925609f, 0.00638184f, -0.03585761f, -0.10737570f, 0.02474749f, -0.53875571f, 
    -0.60979462f, -0.75997102f, -0.22755592f, 0.22665530f, -0.13667481f, 0.00313088f, -0.09422316f, -0.01387079f, 
    -0.21576424f, -0.00211554f, -0.05834781f, -0.12397589f, 0.01484234f, -0.03428461f, 0.22925200f, 0.03572728f, 
    -0.01888976f, -0.52483481f, -0.68253309f, -0.44649518f, -0.21422015f, -0.11641607f, 0.49405485f, 0.06068776f, 
    0.01492079f, 0.13071632f, -0.36673972f, 0.02311404f, 0.23346753f, -0.21790582f, -0.03230545f, -0.13957773f, 
    -0.01728206f, 0.03863484f, 0.13103017f, -0.34827307f, -0.52768707f, -0.20719035f, 0.04303280f, 0.12371499f, 
    0.14811645f, 0.24304144f, 0.17866851f, 0.00130544f, -0.11922085f, 0.30726099f, 0.37468901f, 0.08895295f, 
    -0.00926136f, 0.15130825f, 0.07249545f, 0.00643347f, 0.08543789f, 0.50743467f, 0.31045899f, 0.34227204f, 
    -0.09632961f, -0.00743698f, -0.14021155f, 0.03398217f, 0.01714726f, -0.09706523f, 0.16469033f, -0.15257967f, 
    0.43181106f, 0.23376159f, 0.26440319f, 0.02965488f, 0.09355396f, -0.16045892f, -0.01293055f, -0.09547161f, 
    -0.01549367f, 0.06400146f, -0.18567032f, -0.07929128f, -0.02949675f, 0.17240320f, -0.02940935f, 0.10842475f, 
    -0.20706655f, 0.20210809f, 0.40045911f, -0.17505938f, 0.09396501f, -0.09715972f, 0.13070156f, 0.31671306f, 
    0.03457994f, 0.13033298f, -0.52725291f, -0.66589421f, -0.37904269f, 0.19302122f, -0.05182957f, 0.13527709f, 
    0.00094557f, 0.04196179f, 0.09771323f, 0.58136761f, -0.03499141f, -0.25772840f, -0.05615029f, -0.03600777f, 
    0.12500395f, -0.03958053f, 0.07434054f, -0.12989284f, 0.26718146f, 0.03866494f, -0.17425688f, -0.21702664f, 
    -0.23960337f, -0.00022245f, 0.02022365f, 0.02950781f, 0.22964445f, 0.11691945f, 0.41211164f, -0.28031227f, 
    0.19057764f, 0.19256802f, -0.14014105f, 0.17621914f, -0.24693707f, -0.19027834f, -0.32834384f, -0.45144534f, 
    0.03324232f, -0.04296621f, 0.06024968f, 0.05434484f, 0.19938418f, 0.16651000f, 0.05562219f, -0.05829306f, 
    0.07832461f, 0.09625722f, 0.13231981f, 0.08789226f, 0.17697966f, 0.03910425f, 0.08915582f, 0.24814519f, 
    0.15502493f, 0.08308531f, -0.00773364f, 0.03196656f, -0.14189851f, 0.05051532f, 0.02318411f, 0.18748955f, 
    -0.06328935f, -0.24561884f, 0.13565701f, -0.13054600f, -0.10363092f, -0.24618809f, -0.08817269f, -0.02786154f, 
    0.02921374f, -0.07833931f, -0.47620630f, -0.67204988f, -0.35806182f, -0.02181947f, -0.05575204f, 0.10752665f, 
    -0.05338166f, -0.10128005f, 0.07590462f, 0.44289395f, 0.11455811f, 0.03322870f, -0.21909595f, 0.11419851f, 
    0.21970224f, -0.03716797f, 0.05823571f, -0.93799883f, -0.86938620f, 0.61016542f, -0.19634256f, 0.02035696f, 
    -0.20524912f, -0.02660179f, -0.07824928f, -0.10302005f, 0.08221573f, -0.89888954f, -0.62435168f, -0.01722670f, 
    0.13827504f, 0.01875046f, 0.17746511f, -0.09630708f, 0.14245860f, 0.01989093f, -0.32567057f, -0.36637536f, 
    0.12263244f, -0.04107503f, -0.18166797f, -0.02219588f, -0.05869411f, 0.31671751f, -0.50112659f, -0.27332860f, 
    -0.07474988f, 0.01355461f, 0.01749302f, 0.02574637f, 0.05378643f, -0.00204740f, 0.05750423f, -0.13361518f, 
    -0.18044811f, 0.07467482f, -0.01933408f, 0.00298750f, -0.02152551f, 0.23564154f, 0.00467127f, -0.25643885f, 
    0.07315050f, -0.01157928f, -0.00088286f, -0.10844596f, -0.45634317f, -0.06791295f, -0.00591526f, -0.00214236f, 
    0.13499340f, 0.01083557f, 0.06950678f, 0.06484334f, -0.10330864f, -0.14784582f, -0.12860979f, -0.10204414f, 
    0.00648075f, -0.08722156f, 0.24551260f, 0.25107846f, 0.08471953f, 0.04559160f, 0.11091545f, 0.22391187f, 
    0.05661216f, -0.06248243f, -0.12480314f, -0.13229033f, -0.13314022f, 0.00587412f, -0.23088953f, -0.10082468f, 
    0.10384083f, -0.18187840f, 0.03329227f, -0.10518944f, -0.06815292f, 0.32993925f, 0.12752767f, -0.06945285f, 
    -0.02277564f, 0.06021317f, -0.01067043f, -0.17094782f, 0.01847303f, 0.10151007f, 0.23004059f, 0.07371647f, 
    -0.12637451f, 0.17154670f, 0.11563228f, -0.03551666f, -0.10512991f, -0.14970995f, 0.66554844f, -0.04952442f, 
    0.38340506f, -0.03712017f, 0.04016085f, 0.18730706f, 0.05094203f, 0.16501977f, 0.14438178f, 0.32706267f, 
    0.21339230f, -0.05200418f, -0.00339839f, -0.05466681f, -0.09244511f, -0.01011410f, 0.02363832f, 0.13065864f, 
    0.06521830f, 0.02119990f, -0.05264290f, -0.09962296f, -0.39723659f, 0.00934966f, -0.00634955f, 0.00288476f, 
    0.03270704f, -0.00390923f, 0.09915633f, 0.17568189f, -0.16824847f, -0.04298283f, 0.11539289f, -0.06490667f, 
    -0.08344751f, -0.07849730f, 0.23181309f, 0.56290579f, 0.38625404f, -0.04355561f, -0.00438689f, 0.00710909f, 
    -0.01909104f, -0.04678956f, 0.06772624f, 0.05265709f, -0.06594323f, -0.13619038f, 0.06470080f, -0.11840153f, 
    -0.03263661f, -0.01611438f, 0.11097778f, 0.07462272f, -0.17807376f, 0.06082627f, -0.01724254f, -0.30186409f, 
    -0.02520887f, 0.00849197f, -0.30408207f, -0.00215937f, -0.02582986f, 0.10453594f, 0.24411681f, -0.06172311f, 
    -0.12838969f, 0.14066738f, 0.07742538f, -0.10527762f, 0.00995250f, -0.04580802f, 0.36981952f, 0.00125633f, 
    -0.35839450f, 0.00949305f, -0.09298199f, -0.02269481f, -0.03695432f, 0.13858353f, -0.00351686f, 0.03065912f, 
    0.09718574f, -0.01598827f, -0.10344671f, -0.23142742f, 0.02584919f, -0.16842853f, 0.09571632f, -0.06912474f, 
    -0.25163424f, -0.03498534f, 0.04225091f, -0.02695340f, 0.11465231f, -0.04550514f, -0.30076322f, 0.21277827f, 
    0.01138678f, 0.53251040f, 0.64934230f, -0.00178404f, 0.07007527f, -0.04223022f, 0.06974483f, 0.11767044f, 
    0.08183780f, -0.01485686f, -0.42781451f, -0.05247520f, -0.04894323f, -0.06845494f, -0.04694660f, 0.05151483f, 
    -0.08077051f, -0.09071127f, 0.28683254f, -0.09042234f, -0.09236070f, 0.03252108f, 0.02938341f, 0.09436139f, 
    0.15631855f, -0.31920609f, -0.35325602f, -0.16305730f, -0.45634538f, -0.15711407f, 0.07781640f, -0.05160082f, 
    0.25667620f, 0.01826493f, -0.18082978f, 0.19915263f, -0.12725946f, -0.05033129f, 0.16608529f, 0.34510094f, 
    -0.08459882f, -0.14675674f, -0.12701875f, 0.02189923f, -0.01414862f, 0.05545607f, 0.20150250f, 0.19265233f, 
    -0.12386598f, -0.04824704f, 0.03881601f, 0.05476233f, -0.06399673f, -0.31239948f, -0.05699860f, -0.12409689f, 
    0.00072801f, 0.21288967f, -0.12048777f, 0.06518473f, 0.08803809f, -0.02180462f, 0.26982325f, 0.03506893f, 
    0.36235648f, 0.53382736f, 0.27176276f, 0.04295859f, -0.02369748f, -0.02630641f, 0.01789626f, -0.00160793f, 
    0.00216312f, 0.28492913f, 0.21556495f, 0.48075160f, 0.01588963f, -0.00447572f, 0.04740883f, 0.07795465f, 
    -0.03685629f, -0.11263593f, -0.10586072f, -0.33744109f, -0.14359397f, 0.13032377f, 0.01772546f, 0.25955188f, 
    0.26575813f, 0.11303533f, 0.00733654f, 0.43031919f, 0.58629209f, -0.30954337f, -0.02824171f, -0.22296289f, 
    0.00723427f, -0.04672082f, 0.01030478f, 0.15780571f, 0.58382690f, -0.20172946f, -0.54878414f, -0.09510180f, 
    -0.16440064f, 0.17769048f, -0.10094979f, -0.02003023f, -0.07330771f, 0.20361000f, 0.03867241f, 0.08770034f, 
    -0.04423632f, -0.10522462f, -0.02826460f, -0.15771309f, -0.13831130f, -0.16300565f, 0.12955372f, 0.18356903f, 
    0.49572021f, -0.16231099f, -0.07623137f, -0.09057315f, 0.04861641f, 0.07683725f, 0.05865905f, 0.12861013f, 
    0.28078818f, 0.16088276f, 0.11070863f, 0.22087780f, 0.00729465f, 0.09486119f, 0.15994902f, 0.03231468f, 
    -0.14188084f, -0.54917508f, -0.09969302f, -0.08281493f, -0.21334007f, 0.16511828f, 0.24413821f, 0.06072798f, 
    0.02418464f, 0.23957136f, -0.00933704f, 0.09985388f, 0.11673951f, 0.09126621f, 0.00405203f, -0.13518161f, 
    -0.03382120f, 0.26409948f, -0.08351114f, -0.16582522f, 0.35132933f, 0.12041688f, -0.04218282f, 0.04063517f, 
    0.13373733f, -0.17604880f, -0.00058420f, -0.16898866f, 0.01689704f, 0.10840043f, -0.32261747f, 0.19957532f, 
    0.04442717f, 0.08427081f, -0.00433655f, 0.10487541f, -0.21185149f, 0.09433439f, -0.01413553f, -0.19584198f, 
    -0.11188272f, -0.18371564f, 0.00501306f, -0.03636827f, 0.01593731f, 0.24626684f, 0.28847829f, 0.12254226f, 
    -0.05664978f, -0.15588823f, -0.08694609f, -0.11723945f, 0.10727310f, -0.04676311f, -0.03096061f, 0.11059646f, 
    0.10014553f, 0.08314605f, 0.06538454f, -0.10265948f, 0.41982856f, 0.12502129f, -0.20031998f, -0.24019672f, 
    0.08890839f, 0.22935535f, 0.19584428f, 0.06127164f, -0.02805343f, 0.09697403f, 0.08064751f, 0.14481980f, 
    -0.11516853f, -0.34859595f, -0.06772766f, 0.22360145f, -0.25736097f, -0.17109296f, 0.20408972f, 0.17336245f, 
    0.05957097f, 0.25314844f, 0.05685340f, 0.38810882f, -0.03228544f, 0.16795526f, 0.08162332f, 0.02612050f, 
    0.09907274f, -0.17514503f, -0.03340989f, -0.12744465f, 0.06697776f, -0.03670069f, -0.00634239f, 0.07571333f, 
    -0.04054800f, -0.16067706f, 0.01404065f, -0.18785539f, -0.00636205f, 0.26334792f, -0.14644951f, -0.09923735f, 
    0.15356237f, 0.12384335f, -0.02407506f, 0.12079941f, 0.17025103f, 0.18156295f, 0.02304174f, -0.00046390f, 
    0.12525377f, 0.27440110f, -0.15496996f, 0.08486435f, 0.15071319f, -0.04831612f, 0.14352173f, 0.18920843f, 
    -0.19849212f, 0.18227920f, 0.12116089f, 0.25201851f, -0.16897182f, 0.38420537f, -0.06310767f, 0.36755404f, 
    0.21055953f, 0.10956781f, 0.11980788f, -0.01685123f, 0.28578833f, 0.12318218f, -0.15380463f, -0.43835786f, 
    -0.32389799f, -0.02214092f, 0.18625899f, 0.05745596f, -0.37628391f, 0.17032778f, 0.17139016f, 0.11611320f, 
    -0.18444467f, -0.05495578f, 0.13900700f, 0.09583928f, 0.17909153f, -0.21729368f, 0.16045454f, 0.00484779f, 
    0.25759536f, 0.06813255f, 0.30773866f, 0.09703747f, -0.04473596f, 0.10544886f, 0.01834171f, 0.03621653f, 
    0.02247714f, -0.18990465f, -0.20045508f, 0.02564730f, -0.02071147f, -0.31029543f, -0.09097914f, 0.05851170f, 
    0.07106478f, 0.02031826f, -0.18129027f, -0.46135959f, -0.34414297f, -0.01159451f, -0.07716028f, -0.22568269f, 
    -0.04065805f, -0.01796104f, -0.14851779f, -0.09553444f, -0.29197624f, -0.27524862f, -0.14473100f, 0.13946296f, 
    -0.02472064f, -0.17600700f, -0.00012118f, 0.17522138f, 0.37259772f, 0.00880828f, -0.13223110f, -0.08281613f, 
    -0.01674184f, 0.03530741f, -0.22676979f, 0.16740303f, 0.13739750f, -0.04919934f, -0.08790981f, 0.16779310f, 
    0.30625179f, -0.08591089f, -0.01753850f, -0.00352017f, 0.17067079f, 0.00869107f, -0.09390479f, -0.56986040f, 
    -0.40941373f, 0.12119415f, -0.07843971f, -0.21499570f, 0.08985290f, -0.20497859f, -0.12243042f, 0.26958364f, 
    -0.21086098f, -0.22215801f, 0.05804199f, -0.06542241f, -0.07029206f, 0.00900820f, 0.07269810f, -0.09722772f, 
    -0.37576491f, -0.25768802f, -0.16083333f, 0.24557945f, 0.00747598f, 0.03194487f, -0.17912266f, 0.04067717f, 
    -0.07292368f, -0.33674881f, -1.00564373f, -0.09015138f, -0.21319668f, -0.47423407f, 0.02024056f, 0.08068787f, 
    0.12542781f, 0.09575839f, 0.14755194f, -0.52988571f, 0.33255944f, 0.06315488f, 0.22486824f, 0.12256216f, 
    -0.14928651f, -0.03919658f, -0.12125068f, -0.00886118f, -0.08000597f, 0.66901374f, 0.15897302f, 0.15603393f, 
    0.00890923f, -0.09462411f, 0.09405965f, 0.07241256f, 0.04728027f, 0.02644759f, 0.27826360f, 0.10933954f, 
    0.22145708f, -0.17233491f, -0.26769039f, 0.21821927f, 0.00353387f, 0.01020327f, -0.16049889f, -0.26289123f, 
    0.08784557f, 0.04978779f, 0.08631738f, -0.07449009f, 0.08999640f, 0.07418056f, -0.09103326f, -0.25512338f, 
    -0.47949779f, -0.12014619f, -0.05714593f, 0.09129841f, 0.01205638f, -0.27462980f, -0.14623269f, 0.08472657f, 
    -0.00218636f, -0.04629558f, -0.05050788f, -0.03889374f, -0.03704758f, -0.05528032f, 0.01990883f, 0.03942867f, 
    -0.02663105f, 0.04444621f, -0.05006389f, 0.00970679f, 0.04002859f, -0.01076681f, -0.06469841f, 0.03738779f, 
    -0.03992410f, -0.03379490f, -0.01667066f, 0.02182519f, -0.04459039f, -0.03961589f, 0.02926826f, 0.02159790f, 
    -0.05898336f, -0.02498543f, -0.02059676f, 0.02843940f, 0.04917339f, 0.02500479f, 0.00823037f, 0.05288312f, 
    -0.02923287f, -0.04351184f, -0.00990332f, -0.05301221f, -0.03356136f, 0.01944540f, 0.01708348f, -0.04916923f, 
    -0.02327681f, -0.00877105f, 0.01775233f, -0.01449784f, -0.04610404f, 0.02671631f, 0.02767338f, 0.01215882f, 
    0.03090629f, 0.05082054f, -0.02258525f, -0.04230042f, 0.05117496f, 0.00345178f, 0.00677625f, -0.00716345f, 
    -0.05348894f, -0.03922718f, 0.01553843f, -0.03377559f, 0.01036569f, -0.03485803f, -0.02284339f, 0.00525222f, 
    -0.02991930f, -0.05663480f, -0.02972390f, -0.03885663f, 0.01117931f, 0.02726060f, 0.04053605f, 0.01033386f, 
    -0.02367184f, -0.04149889f, -0.02229603f, -0.05635082f, 0.02876674f, -0.00776723f, -0.04736600f, -0.05432870f, 
    -0.03898468f, 0.01865520f, -0.00688489f, -0.02701892f, -0.04567516f, -0.03624736f, -0.06440639f, -0.03059427f, 
    0.06295880f, 0.03855522f, 0.02615711f, -0.04340607f, -0.03320558f, 0.03197244f, 0.04771501f, 0.02430444f, 
    -0.01045460f, -0.01434901f, -0.00866776f, 0.00271636f, -0.03112377f, 0.02190843f, 0.04577983f, -0.02629073f, 
    0.04397565f, -0.02574786f, 0.03872008f, 0.00681946f, -0.00687205f, -0.06339939f, -0.01575886f, 0.04744866f, 
    0.05086264f, 0.02777516f, -0.06438898f, -0.05086773f, 0.04533861f, -0.01738063f, -0.03307224f, -0.04243382f, 
    -0.06020465f, -0.05624036f, 0.01335809f, 0.05377055f, 0.02836742f, 0.03574120f, 0.01061865f, 0.05128849f, 
    0.00255314f, -0.03242057f, 0.02673473f, 0.00060122f, -0.05878120f, -0.01957183f, 0.01598403f, 0.04927884f, 
    -0.05427605f, 0.05022473f, 0.03461464f, -0.03432886f, -0.01735615f, 0.03397208f, -0.00993148f, -0.05036116f, 
    -0.05631347f, -0.03943193f, 0.03538381f, -0.01433985f, -0.00060729f, -0.02009415f, -0.06136712f, 0.02354133f, 
    -0.02298213f, 0.00958313f, -0.04218302f, 0.00254146f, 0.04164634f, 0.04335533f, 0.05047589f, -0.01322478f, 
    -0.01359091f, 0.01288561f, 0.01866094f, -0.03452754f, -0.02651469f, -0.03095663f, -0.01772272f, -0.05845444f, 
    0.04471102f, -0.01405328f, -0.05271330f, -0.03099177f, 0.03532252f, 0.00667891f, -0.06079973f, -0.02555430f, 
    0.03572049f, 0.03952918f, 0.05129664f, -0.01956623f, 0.00166430f, -0.04277251f, 0.02814355f, -0.06004851f, 
    -0.02779940f, -0.03704255f, -0.05918309f, -0.00374070f, 0.03731867f, -0.03880651f, 0.01084783f, 0.00857561f, 
    -0.00529151f, 0.03306319f, 0.02843002f, 0.02950801f, 0.00853132f, -0.02110302f, -0.02653370f, 0.02559555f, 
    -0.00222579f, -0.00130109f, -0.01937210f, -0.04229177f, 0.04655923f, -0.00066272f, -0.05732479f, 0.04738908f, 
    -0.04710116f, 0.03628404f, 0.03464122f, -0.03142065f, -0.01668338f, -0.00949424f, -0.06416260f, -0.02448029f, 
    0.04063119f, 0.02936738f, -0.02430119f, -0.04293675f, -0.05202846f, -0.04932551f, -0.00033846f, -0.02138394f, 
    0.00557769f, 0.00700645f, -0.00489797f, -0.03043231f, 0.00670452f, 0.04217823f, 0.01283643f, -0.01876682f, 
    -0.01342123f, -0.00019987f, 0.04056285f, 0.02454275f, -0.05290863f, -0.05790382f, 0.00491862f, 0.02990050f, 
    -0.03026810f, 0.04580095f, -0.03381526f, 0.00082685f, 0.03023750f, -0.00180639f, 0.03228704f, 0.01597628f, 
    -0.02941554f, 0.03486904f, -0.03388513f, -0.06408445f, 0.00756216f, -0.01007874f, 0.01731594f, 0.04546108f, 
    -0.00139515f, 0.01992834f, -0.04433849f, -0.03609812f, 0.00155351f, -0.00859085f, -0.03906496f, -0.02151659f, 
    -0.06146584f, -0.03931171f, 0.02353639f, 0.04697628f, -0.03432131f, -0.02397916f, 0.01266285f, -0.01347463f, 
    -0.00120804f, -0.06035318f, -0.01844668f, 0.01584821f, -0.01282273f, -0.02491804f, -0.02527734f, 0.03634212f, 
    -0.05849609f, -0.01730078f, 0.01539794f, -0.00833439f, 0.03906767f, 0.03191071f, -0.00510315f, -0.04579308f, 
    -0.03014333f, -0.17013572f, -0.10310148f, -0.22769284f, 0.24808696f, 0.21702971f, -0.03929051f, 0.07605582f, 
    0.10097783f, -0.15746652f, -0.09448051f, 0.16848341f, -0.08286027f, 0.02983885f, -0.08185691f, -0.06071005f, 
    0.18003778f, -0.02861810f, -0.09976009f, 0.20714353f, 0.37843367f, -0.11428870f, 0.17277153f, -0.02107486f, 
    -0.16015919f, 0.09792709f, 0.14221278f, -0.33946651f, -0.52328831f, -0.07862777f, 0.13575350f, -0.19252858f, 
    -0.02145951f, 0.21317688f, 0.21929537f, 0.15161972f, 0.12554975f, -0.03298869f, -0.13546869f, -0.19902979f, 
    -0.04338231f, -0.19842172f, 0.05780100f, -0.05320272f, 0.10114142f, -1.41248763f, -0.35105839f, -0.16756952f, 
    -0.13297480f, -0.27560693f, 0.07946688f, 0.24060857f, -0.15240212f, -0.04282831f, -0.36996025f, -0.04182233f, 
    0.28740728f, 0.04951189f, 0.14127490f, 0.21126740f, 0.33482885f, -0.01073395f, -0.08505048f, 0.25643450f, 
    0.11964028f, 0.03629304f, -0.23216058f, 0.20487742f, 0.03797201f, -0.02075184f, -0.02160637f, -0.16209944f, 
    -0.23599592f, -0.34181461f, -0.29896727f, -0.41013426f, -0.05924054f, 0.04866957f, 0.20165306f, 0.09647243f, 
    0.29580000f, 0.47409034f, 0.20865618f, -0.18577510f, 0.03850901f, 0.04762003f, -0.01015917f, 0.13135521f, 
    -0.06813373f, -0.12323407f, -0.05333178f, 0.14704888f, 0.29473886f, -0.11288460f, -0.01497506f, -0.22018321f, 
    -0.01423961f, 0.03861711f, -0.04171815f, -0.26559746f, -0.16996132f, -0.34699020f, -0.02224398f, 0.21194030f, 
    0.09396852f, -0.01605766f, 0.04742487f, 0.19117606f, -0.72763234f, 0.02326985f, -0.08679652f, -0.05822801f, 
    0.01156901f, -0.32986921f, 0.02811337f, 0.06898627f, 0.12740776f, -0.19758585f, -0.02358952f, 0.31802061f, 
    -0.03929012f, 0.23236078f, -0.18535763f, -0.04438206f, 0.15977870f, -0.06702404f, 0.03323988f, -0.03430328f, 
    0.21535663f, 0.13301432f, -0.02123919f, 0.06770678f, 0.17843786f, 0.12136260f, 0.00172582f, -0.11522534f, 
    -0.26265153f, -0.30258328f, -0.23778081f, -0.19812022f, -0.04030521f, 0.14637420f, -0.02360488f, 0.08932041f, 
    -0.00344185f, 0.03687048f, -0.34739920f, 0.15704587f, -0.04637555f, -0.15950418f, -0.03959504f, -0.04472177f, 
    -0.23997338f, 0.11842909f, 0.02041431f, 0.27000391f, -0.33850816f, -0.09879313f, 0.43168798f, 0.11969931f, 
    -0.06029240f, -0.03400315f, -0.44425762f, -0.13427123f, -0.59106129f, 0.06497823f, -0.21728502f, -0.03426690f, 
    0.02421573f, 0.24286768f, -0.22366840f, 0.33902666f, -0.22708473f, -0.11686114f, 0.14490852f, -0.23616058f, 
    -0.36153299f, 0.01345481f, -0.02485583f, -0.05753475f, 0.45276913f, -0.61470550f, -0.96930778f, -0.29886979f, 
    0.26411027f, 0.17998603f, -0.17458759f, 0.05355190f, 0.20060430f, -0.73069173f, -0.48676541f, -0.00953071f, 
    0.06290025f, 0.01993852f, 0.22127908f, -0.07260633f, 0.21439290f, 0.07196295f, 0.24843965f, 0.21250676f, 
    0.23408817f, 0.03969269f, 0.07426554f, 0.05239893f, 0.04616832f, -0.03972189f, 0.03359936f, 0.06400141f, 
    -0.37194926f, -0.30511025f, -0.33123896f, 0.07773043f, -0.11754495f, 0.12440860f, 0.15079109f, 0.19714220f, 
    -0.00364710f, 0.25466111f, 0.21128790f, -0.19552600f, -0.02605107f, -0.26043755f, -0.08168284f, -0.00486800f, 
    0.02797515f, 0.05508671f, 0.35415679f, 0.32836664f, -0.03675735f, 0.14715266f, 0.02841573f, 0.08834015f, 
    -0.15761332f, -0.11227102f, 0.39478359f, -0.62456322f, -0.67785192f, 0.11863589f, -0.09029092f, -0.04041849f, 
    -0.10943526f, 0.08444800f, 0.06511199f, 0.21890181f, 0.05274381f, 0.24238139f, -0.17718227f, 0.15531844f, 
    0.07164968f, 0.16550978f, 0.07729612f, 0.06679868f, 0.28766999f, -0.31927648f, -0.19983530f, -0.09216944f, 
    0.05374730f, 0.10016748f, 0.16042478f, 0.01618931f, 0.01797955f, -0.17483696f, -0.01692147f, 0.26595441f, 
    -0.03065909f, 0.05050822f, -0.13637701f, 0.15291734f, 0.04113299f, 0.00052889f, -0.14085536f, -0.11743810f, 
    0.19589745f, -0.00857309f, -0.03891042f, -0.01300842f, 0.01301396f, 0.03485930f, -0.20804255f, 0.09825573f, 
    0.15984449f, 0.08998813f, -0.13905600f, -0.00545267f, -0.01510800f, 0.02579950f, 0.09431656f, 0.07850906f, 
    0.02890169f, 0.14887473f, 0.14122705f, -0.07940185f, -0.30359706f, -0.10555562f, 0.04002696f, -0.14281560f, 
    0.09040125f, 0.06407432f, 0.06933307f, -0.01654171f, 0.20665164f, -0.18074529f, 0.21232541f, 0.01651566f, 
    0.06481990f, 0.07953995f, 0.17512988f, 0.02833431f, 0.23341346f, -0.02747795f, -0.05045632f, -0.05740873f, 
    0.09033722f, -0.11408150f, 0.17330424f, 0.10896195f, -0.07964190f, 0.33017939f, -0.04384729f, -0.12072902f, 
    0.01993731f, 0.02093916f, -0.07741597f, -0.13310097f, -0.06546161f, -0.29693457f, 0.08824158f, -0.05340935f, 
    0.06010130f, 0.10512783f, 0.08833317f, 0.09465664f, -0.15570045f, -0.09826068f, -0.02947798f, 0.17706096f, 
    0.09383632f, 0.22448795f, -0.01199445f, -0.23582864f, 0.07720203f, -0.47876185f, 0.21240671f, 0.23808596f, 
    0.11339831f, -0.04940528f, -0.18138999f, -0.20225409f, 0.17573386f, 0.02995849f, 0.28646711f, 0.41901708f, 
    0.04272088f, -0.12394227f, -0.13513905f, -0.00777251f, -0.12865114f, 0.13358226f, 0.17370720f, -0.01053445f, 
    0.15611491f, 0.18346255f, 0.21872273f, -0.03945961f, -0.00789156f, -0.09485419f, -0.16613503f, -0.16608185f, 
    0.04513154f, -0.05885646f, -0.29329470f, -0.12244549f, -0.05477199f, 0.12533946f, 0.00181557f, -0.06015328f, 
    0.13704582f, -0.25431103f, -0.05083146f, 0.00359481f, 0.13922764f, 0.18223007f, -0.00525257f, 0.15851612f, 
    0.04844033f, -0.04400576f, -0.19551501f, 0.21155749f, -0.14631659f, -0.12749101f, 0.10157166f, -0.02138625f, 
    -0.13282560f, 0.19483040f, -0.09383503f, 0.07196300f, 0.10521567f, -0.02892050f, 0.17926532f, -0.20109212f, 
    -0.02100055f, -0.03755802f, -0.11124267f, -0.05008873f, -0.07218314f, 0.15799151f, -0.21592994f, 0.04248680f, 
    -0.16440992f, -0.04116314f, -0.01050827f, -0.09889812f, -0.07710216f, 0.29391050f, 0.15244807f, 0.07115759f, 
    0.04706952f, -0.10116696f, -0.00774705f, -0.17067593f, 0.10537902f, -0.14504635f, 0.08950715f, 0.07678869f, 
    0.18820319f, 0.19744959f, -0.13791883f, -0.04734021f, -0.09871641f, -0.19099656f, -0.14903240f, -0.01228878f, 
    -0.09542900f, 0.03328905f, 0.19974773f, 0.00266570f, 0.06711701f, 0.04677781f, -0.03585694f, -0.25855887f, 
    0.07987784f, 0.20430985f, -0.23482442f, 0.12542075f, -0.03996199f, 0.01011906f, -0.08006062f, 0.06394675f, 
    -0.00953613f, -0.20466772f, -0.18653558f, -0.17392659f, 0.05202287f, 0.10747223f, -0.06189162f, -0.02408698f, 
    -0.00330755f, -0.22239146f, -0.03778896f, 0.00570425f, 0.04720992f, 0.18400340f, 0.02234644f, 0.00017110f, 
    0.03504993f, -0.03802416f, -0.29128730f, -0.30076870f, -0.08682244f, 0.06251048f, 0.00004764f, 0.04786338f, 
    0.02750423f, 0.00790674f, -0.01823829f, 0.24573608f, -0.04299592f, 0.32317469f, 0.23888132f, -0.12419213f, 
    0.22638781f, 0.06398799f, -0.08680166f, 0.07226124f, 0.15425569f, 0.08880048f, 0.17785843f, 0.19224754f, 
    0.03060644f, 0.04169531f, 0.00897022f, -0.02932248f, -0.10162484f, 0.01468721f, -0.09212103f, -0.57443869f, 
    -0.09086680f, 0.08956956f, -0.01504225f, -0.00696668f, 0.37718782f, 0.01688141f, -0.05407064f, 0.22238082f, 
    0.08351883f, 0.11149283f, 0.20279036f, -0.00458899f, -0.01446916f, 0.08385757f, 0.07714005f, -0.01532135f, 
    -0.13676348f, 0.10301722f, 0.17643787f, -0.14916097f, -0.03843759f, -0.01119750f, -0.03317815f, -0.10880952f, 
    0.02409329f, -0.20966166f, -0.22351554f, -0.25612596f, 0.32722071f, -0.10583578f, 0.06629727f, 0.13885397f, 
    0.10325126f, -0.03461123f, 0.23499584f, 0.85848212f, 0.10762782f, 0.01818656f, -0.13837561f, 0.01653777f, 
    -0.08757660f, -0.00775772f, 0.11679626f, 0.11937714f, 0.08980732f, -0.21080023f, 0.10002027f, -0.05139954f, 
    -0.09346736f, -0.19431451f, -0.01688571f, -0.17615181f, -0.00908257f, -0.18070319f, -0.07031473f, -0.07435895f, 
    -0.03880733f, -0.01732097f, -0.09904376f, 0.01616192f, -0.20961101f, -0.31400457f, -0.01681523f, -0.11826593f, 
    -0.26298973f, 0.40987128f, -0.04124551f, -0.02090837f, 0.23493379f, 0.02236422f, 0.01054958f, -0.12805162f, 
    0.04450567f, 0.07028785f, 0.14526232f, 0.01600478f, 0.08695588f, 0.17593820f, 0.08866780f, 0.17274544f, 
    -0.01203267f, 0.01090981f, 0.05299964f, 0.04834797f, -0.02590724f, -0.05230780f, 0.00159825f, -0.05504414f, 
    -0.01350249f, 0.03479146f, 0.01000967f, -0.04883121f, 0.01150685f, -0.04101394f, -0.00700110f, 0.04818024f, 
    0.00748995f, -0.00233277f, -0.05557112f, 0.01386983f, -0.02047674f, -0.04253981f, -0.03057909f, -0.06244433f, 
    0.04301630f, 0.00172780f, 0.04572081f, 0.00558292f, -0.01474757f, 0.02271334f, -0.05442056f, -0.03790126f, 
    0.00400377f, 0.03199265f, -0.03845633f, -0.02031681f, 0.03875834f, 0.01998691f, -0.02663497f, 0.02858473f, 
    -0.03033614f, 0.00133302f, -0.03327272f, -0.02073475f, -0.01172001f, 0.00652886f, -0.03147411f, 0.04154791f, 
    -0.01240255f, 0.03592495f, 0.04508847f, -0.03373921f, -0.01399474f, -0.05237990f, -0.01325242f, 0.02337140f, 
    -0.06152787f, 0.00376524f, -0.04461547f, -0.02568351f, -0.01453214f, -0.02055830f, -0.01931376f, -0.00904289f, 
    0.02412548f, 0.04043965f, 0.02274796f, 0.05166381f, -0.03399347f, 0.01731493f, 0.02406133f, -0.05594631f, 
    -0.03736306f, 0.03965633f, -0.01602119f, -0.01531645f, -0.03969896f, -0.02312756f, -0.01996205f, 0.03184779f, 
    0.01902331f, -0.02604466f, -0.01471544f, -0.05281258f, -0.01788791f, -0.00333880f, 0.02627561f, -0.00454945f, 
    -0.04414277f, 0.00418437f, 0.02428016f, -0.05834571f, -0.01293490f, -0.02845953f, 0.00287213f, -0.00975580f, 
    0.04527681f, 0.04510830f, 0.01124625f, -0.02948404f, -0.05770852f, -0.00530308f, -0.01886607f, -0.00282004f, 
    -0.01126605f, 0.01524625f, -0.01527204f, 0.03629069f, -0.00003274f, 0.05373549f, 0.02088782f, -0.01750168f, 
    -0.04950211f, -0.02497785f, 0.02296478f, -0.01504659f, -0.02426476f, 0.05751998f, 0.04255368f, 0.00369812f, 
    -0.06281134f, -0.02949292f, 0.01276720f, -0.03959953f, -0.00748677f, 0.03760793f, 0.01653257f, -0.00928417f, 
    0.02529042f, -0.05096648f, -0.04588955f, 0.02964536f, -0.04861801f, -0.04797244f, 0.02103040f, 0.05127253f, 
    -0.02463631f, 0.03356791f, -0.01720355f, 0.02879943f, -0.05018774f, 0.02094206f, 0.01046088f, -0.00979831f, 
    0.05458414f, 0.01918028f, -0.01825910f, -0.01554611f, 0.00188732f, 0.01473632f, -0.00443424f, -0.05654662f, 
    0.03867385f, 0.04526383f, -0.02213381f, -0.00921801f, -0.02790548f, -0.00638714f, -0.03798872f, 0.02982240f, 
    -0.01916461f, 0.02645686f, -0.01452693f, 0.01349421f, -0.00731926f, 0.00811958f, -0.02161879f, 0.02028609f, 
    -0.05643098f, -0.06365669f, -0.06075760f, -0.02361539f, -0.03187868f, -0.05907297f, -0.03391811f, 0.02056337f, 
    0.01322042f, -0.04759061f, -0.03914877f, -0.04057783f, 0.04359654f, 0.02905188f, -0.01864415f, 0.01760784f, 
    -0.03959454f, -0.03920694f, 0.04975095f, 0.00313409f, 0.02242082f, 0.02388787f, 0.01853567f, -0.01493215f, 
    0.04455714f, -0.04471024f, 0.03121645f, 0.02671085f, -0.05491828f, 0.02905738f, 0.02265255f, -0.03618905f, 
    -0.04044266f, 0.01387406f, -0.04703775f, -0.01393683f, -0.00636818f, 0.04143864f, 0.01444858f, -0.05363421f, 
    -0.02574787f, -0.02383182f, 0.01151782f, 0.02167042f, -0.03314168f, 0.03844642f, -0.04942807f, -0.03849538f, 
    -0.02995101f, -0.05342945f, 0.01713475f, 0.04531329f, -0.06181211f, 0.02337912f, -0.01484455f, 0.02716986f, 
    0.03004698f, 0.02009857f, -0.02611076f, 0.01967614f, 0.02901900f, -0.05947772f, -0.00651526f, -0.05807679f, 
    0.02960207f, 0.03898565f, 0.01749302f, -0.05331766f, 0.05579258f, 0.00698652f, -0.04570034f, -0.03456805f, 
    -0.01018962f, -0.05516859f, -0.05592273f, 0.06012004f, 0.03568277f, -0.00610811f, 0.02145012f, -0.02894653f, 
    0.02752516f, -0.02029243f, -0.01075570f, -0.04407759f, -0.03148521f, -0.00879215f, -0.01167810f, 0.04081665f, 
    -0.03610756f, -0.06299871f, 0.02010755f, 0.02576402f, -0.01285924f, 0.00702863f, -0.02073065f, -0.04955187f, 
    0.01400605f, -0.03586039f, -0.05861891f, 0.03703104f, -0.00189691f, -0.01608063f, -0.01410067f, -0.06481843f, 
    0.03643079f, -0.04039248f, 0.00721375f, 0.04226067f, -0.03572036f, -0.01464544f, 0.01592966f, -0.04987664f, 
    -0.06161979f, -0.01558298f, -0.05203702f, -0.00964418f, 0.03525810f, 0.04403966f, -0.05825864f, -0.02265462f, 
    -0.09698287f, 0.04964270f, -0.21022691f, 0.03940711f, 0.06170645f, 0.08004989f, 0.13415831f, 0.08988481f, 
    0.08799572f, 0.04325657f, -0.02687439f, 0.36795545f, 0.23111539f, 0.14698653f, 0.05485778f, 0.12828325f, 
    0.29449567f, 0.06545486f, -0.14914286f, -0.12878248f, -0.24845310f, -0.03133553f, -0.02561215f, 0.04521602f, 
    -0.04552176f, 0.06641363f, 0.09494825f, 0.10109878f, -0.13193525f, 0.41170144f, 0.04553983f, 0.09429999f, 
    -0.24936399f, 0.26169485f, 0.20682110f, -0.30083340f, -0.01429405f, -0.23260631f, -0.00283097f, 0.13454463f, 
    0.05291529f, 0.03933210f, -0.10365756f, 0.19186816f, -0.09269303f, -0.06167734f, -0.07290469f, -0.18984646f, 
    -0.09072275f, -0.07837413f, -0.04814879f, 0.28638774f, -0.07155170f, -0.49755326f, 0.07283980f, -0.25506714f, 
    -0.28906053f, 0.01721635f, -0.10188617f, 0.03178490f, -0.03789529f, -0.08220018f, 0.06738887f, 0.03283655f, 
    -0.79118919f, -0.42116445f, -0.11675078f, 0.00370031f, 0.09115942f, 0.04822987f, 0.05343619f, -0.00886931f, 
    -0.04134318f, 0.01954850f, -0.08195227f, -0.06924713f, -0.00311580f, -0.09797229f, 0.17297536f, 0.14692947f, 
    -0.09987406f, -0.02912291f, -0.41738197f, -0.00297110f, 0.13052066f, 0.16462269f, 0.01463982f, 0.09624126f, 
    0.18685713f, -0.14913490f, 0.06165086f, -0.10571946f, 0.18427780f, -0.04668477f, -0.16522869f, -0.05101408f, 
    -0.03758431f, -0.03421682f, 0.05478872f, 0.10731947f, -0.19945821f, -0.28667092f, -0.09443613f, 0.14822705f, 
    0.34464806f, 0.06034288f, 0.14297007f, -0.12065097f, 0.38661623f, 0.22668400f, 0.09134918f, 0.25777254f, 
    0.22462998f, 0.02989913f, 0.06435733f, -0.06810258f, -0.07168600f, 0.37463969f, -0.16465171f, 0.13721767f, 
    0.06847326f, 0.33404836f, -0.13388531f, 0.29399067f, 0.25186145f, -0.24375558f, 0.01388005f, -0.06191174f, 
    -0.02436674f, -0.10481633f, 0.00654698f, 0.00316464f, 0.11081014f, 0.18024790f, 0.16321765f, -0.13990305f, 
    0.11697904f, 0.09782153f, -0.11944484f, 0.02945609f, -0.10082269f, 0.06625027f, 0.13541353f, -0.12422989f, 
    -0.21430257f, 0.14861244f, 0.03152245f, 0.00187788f, 0.09933089f, -0.18598473f, 0.09090973f, -0.06147943f, 
    0.11618532f, -0.15869434f, -0.27707991f, -0.03053106f, 0.07842857f, 0.00942566f, -0.00467655f, 0.06149740f, 
    0.03061615f, 0.06190203f, -0.24608019f, -0.37950191f, 0.31999955f, -0.00980404f, 0.03375147f, 0.00041548f, 
    0.06949219f, -0.07519562f, -0.05078753f, -0.22856048f, -0.04842467f, 0.09892448f, -0.16415216f, 0.04498364f, 
    0.01838378f, -0.07326803f, 0.01454584f, 0.13791279f, 0.28865537f, -0.01324469f, -0.08944453f, -0.09881564f, 
    0.11275950f, -0.04878035f, 0.06955283f, -0.08466242f, 0.08155196f, 0.12569444f, -0.26279238f, -0.28002968f, 
    0.10345415f, -0.18858993f, -0.01013867f, 0.16364647f, -0.01949941f, -0.04056868f, 0.13023697f, 0.07807551f, 
    0.03315426f, 0.07299987f, 0.17883883f, 0.00110717f, 0.13079667f, 0.05452840f, 0.08415978f, 0.14008649f, 
    0.09595151f, 0.00812657f, 0.12270269f, -0.06951722f, -0.08176289f, -0.09243665f, 0.25590172f, -0.12218004f, 
    0.14537981f, -0.09782293f, 0.17709155f, -0.06149666f, -0.04933665f, -0.05953816f, 0.01239676f, -0.03252127f, 
    0.01060287f, -0.34798843f, -0.26239783f, -0.32707927f, -0.02431471f, -0.07456198f, -0.03458148f, 0.08551871f, 
    -0.00881675f, 0.05631042f, -0.19432604f, -0.02915089f, -0.16099261f, 0.18240087f, -0.13521251f, 0.09864303f, 
    -0.06516984f, 0.11897396f, 0.01993401f, -0.12659615f, -0.38617617f, -0.31012294f, -0.08267052f, 0.09332957f, 
    -0.16035396f, 0.05673295f, 0.15996628f, 0.06799117f, -0.00396434f, -0.23269778f, -0.47798315f, -0.17459372f, 
    0.06804666f, 0.09432485f, -0.09857633f, -0.07243106f, -0.00699898f, 0.19691275f, -0.01663504f, -0.06960340f, 
    -0.08282215f, -0.10333443f, 0.11446373f, 0.09398106f, -0.00079849f, -0.07820544f, 0.20961215f, -0.23835292f, 
    0.03771522f, 0.09187465f, -0.15729235f, 0.26466900f, 0.08280541f, -0.00750738f, 0.02846605f, 0.17772509f, 
    0.03994624f, 0.21972354f, -0.29674819f, -0.16826062f, -0.12559159f, 0.12313409f, 0.16213109f, 0.03963751f, 
    0.01916808f, -0.11128171f, -0.03084848f, 0.07557838f, 0.12873943f, 0.08985831f, 0.23733534f, 0.22626692f, 
    0.26350272f, -0.00314002f, -0.11002045f, 0.10930597f, -0.03345698f, -0.24734189f, -0.02333147f, -0.06230554f, 
    -0.01346782f, 0.13014399f, -0.04262581f, -0.02053419f, 0.31388482f, 0.09531646f, -0.32456195f, -0.09154767f, 
    -0.00796024f, -0.04566452f, 0.12497865f, -0.17974785f, -0.21407181f, 0.08976432f, -0.01756573f, 0.02946139f, 
    -0.13652688f, -0.03830106f, -0.07700783f, 0.32574242f, 0.07519150f, 0.35760561f, 0.85029757f, -0.41522598f, 
    -0.03664928f, 0.02204172f, 0.06035310f, -0.14278057f, 0.07515149f, 0.16861781f, 0.04460780f, 0.01323790f, 
    0.15340960f, 0.09621944f, -0.13059984f, 0.09362496f, -0.10219975f, 0.06138356f, 0.17545128f, -0.10570554f, 
    -0.30250996f, -0.12344247f, -0.23581401f, -0.10277562f, 0.03630166f, 0.06888615f, 0.09618836f, -0.30732012f, 
    -0.24944617f, 0.14817256f, 0.04702231f, -0.03224482f, 0.05016839f, 0.25427344f, 0.21685767f, 0.12725072f, 
    -0.02845063f, -0.30795839f, 0.02795554f, 0.33550149f, 0.01915084f, -0.02164381f, -0.10145425f, 0.15616386f, 
    0.24372239f, -0.03411949f, -0.06156218f, 0.18781075f, -0.09271469f, 0.02202212f, 0.14357251f, 0.16218901f, 
    -0.02665233f, 0.01685030f, 0.10121827f, 0.12048726f, 0.24896990f, 0.13574828f, 0.05411410f, 0.18762475f, 
    0.06131575f, 0.06200618f, -0.03613323f, -0.25072744f, -0.14900880f, 0.21493547f, 0.02273147f, 0.10157385f, 
    0.16446258f, 0.21766825f, 0.12797725f, -0.12758978f, 0.12828770f, -0.26759723f, -0.20013843f, -0.03665117f, 
    -0.06994008f, 0.20689447f, -0.07212063f, -0.13775659f, 0.25983730f, -0.12603861f, 0.04034930f, 0.19744745f, 
    0.06086258f, -0.24156855f, -0.10620621f, -0.18428271f, -0.03267162f, 0.29770204f, -0.13080631f, -0.05773797f, 
    0.30856395f, 0.01323865f, 0.01971245f, -0.06902017f, -0.10679577f, 0.04362906f, 0.02865332f, -0.05138998f, 
    -0.31582779f, -0.19069751f, 0.26401976f, 0.06033316f, 0.06401227f, 0.18416998f, -0.13092251f, 0.25337389f, 
    -0.06868815f, -0.38808641f, 0.13974039f, 0.19420138f, -0.03352622f, 0.08924144f, 0.17562614f, 0.08136530f, 
    0.18283516f, -0.02862438f, 0.06248451f, 0.56784320f, -0.19943483f, -0.06916686f, -0.43459046f, -0.00631212f, 
    0.18999785f, -0.08387066f, 0.26491377f, 0.35830003f, 0.41001964f, -0.10790024f, 0.01504381f, 0.02610610f, 
    0.10459003f, 0.02558613f, 0.02638071f, -0.42818832f, -0.40627217f, -0.08617511f, 0.16301191f, 0.10831324f, 
    0.01306635f, 0.17986542f, 0.09219318f, 0.15906560f, -0.15456946f, -0.24590796f, 0.27598074f, -0.04461415f, 
    0.01784573f, 0.03427063f, 0.05202705f, 0.16961205f, 0.14642668f, 0.00178189f, 0.01699990f, -0.14083527f, 
    0.05110816f, 0.12491301f, -0.21506730f, 0.49655974f, 0.21934600f, -0.11278292f, -0.08730047f, 0.20621696f, 
    0.35965833f, -0.17170447f, 0.01137370f, -0.09846502f, -0.13916589f, -0.04078818f, -0.05780961f, -0.01303003f, 
    0.16062585f, 0.13688886f, -0.07806684f, -0.16431518f, -0.07181944f, 0.26275700f, 0.03750088f, -0.09135567f, 
    0.21424961f, 0.01699780f, 0.32252941f, 0.14650215f, -0.01710677f, 0.12775038f, 0.01591177f, -0.01955656f, 
    -0.07934172f, 0.05733707f, -0.05194652f, 0.15499559f, -0.27425912f, -0.14203879f, -0.08850444f, -0.05393526f, 
    -0.00265040f, 0.05953652f, 0.01933923f, -0.10279803f, -0.41692880f, -0.22863033f, -0.01386463f, -0.03804884f, 
    0.16257231f, -0.03636781f, -0.04691572f, -0.19829388f, -0.22471304f, 0.14393537f, -0.14648537f, -0.25804755f, 
    -0.08794615f, -0.00911363f, -0.12942961f, -0.01799111f, -0.57912862f, -0.10757329f, 0.03320330f, 0.09241241f, 
    0.06707030f, 0.09267616f, -0.02194086f, 0.03081678f, 0.06361707f, -0.19227904f, -0.16895427f, -0.15466787f, 
    0.07356220f, 0.09433057f, -0.03378732f, -0.23477638f, -0.01427411f, -0.06050155f, -0.07276551f, 0.13473347f, 
    0.00993192f, 0.28831178f, 0.17553669f, -0.00727160f, 0.28897479f, 0.18879369f, 0.06485385f, 0.00991156f, 
    -0.01984183f, -0.01319313f, 0.07901987f, 0.12621564f, -0.06747086f, 0.08640149f, -0.18851554f, -0.13677615f, 
    -0.13840187f, -0.05009175f, -0.11684992f, 0.07725259f, -0.01134041f, -0.00593048f, -0.03113475f, -0.12478317f, 
    -0.38735175f, 0.06788398f, 0.21267381f, -0.09088459f, 0.06065548f, 0.16622931f, 0.00839013f, -0.02917300f, 
    -0.30776820f, 0.00435672f, 0.04651325f, 0.00180195f, 0.08857602f, 0.16707323f, -0.00181879f, -0.08443277f, 
    0.02277165f, 0.12941711f, 0.22524939f, 0.40661612f, 0.14109835f, 0.03266604f, 0.34964091f, 0.07665540f, 
    0.20162822f, -0.11444619f, 0.14549430f, -0.12100187f, 0.27258763f, 0.20672251f, 0.37031999f, 0.06805443f, 
    0.03348588f, 0.13230915f, 0.10989378f, 0.08386026f, 0.11424132f, 0.16164799f, 0.27734071f, -0.26823786f, 
    0.20552316f, 0.11849411f, 0.06832500f, 0.14860535f, 0.04477271f, -0.31565961f, 0.24185407f, 0.06229275f, 
    -0.19287650f, -0.34879112f, -0.06839675f, 0.21566303f, 0.09688576f, 0.15695035f, 0.11632562f, 0.07784263f, 
    -0.37635380f, 0.04601363f, 0.17597143f, -0.02512237f, 0.06760269f, 0.01956228f, 0.26927412f, 0.06066123f, 
    -0.03493247f, -0.16456187f, -0.12231272f, 0.16917084f, 0.10785324f, -0.00598266f, -0.20054309f, 0.11261008f, 
    -0.12406537f, -0.13581590f, 0.24350826f, 0.47628665f, -0.06313770f, 0.13891371f, -0.08749696f, 0.07232825f, 
    0.09863504f, 0.07469300f, 0.05264496f, -0.09173904f, -0.40936130f, 0.09220473f, 0.12167554f, 0.19853796f, 
    -0.25809211f, -0.07005676f, -0.21094257f, -0.19708976f, -0.21668656f, 0.11921216f, 0.16807404f, 0.04603044f, 
    -0.00595157f, -0.12863627f, -0.23534797f, -0.03664594f, 0.32695791f, 0.05322102f, -0.16877849f, 0.19117309f, 
    0.16198982f, 0.31084964f, 0.27611464f, 0.11729816f, 0.11534295f, 0.09024401f, -0.08386414f, -0.04081097f, 
    0.00120109f, 0.18738590f, 0.14131019f, 0.12796688f, 0.21879399f, 0.33323118f, 0.10619876f, 0.04039471f, 
    0.08755364f, 0.01004387f, -0.05783949f, 0.06253608f, 0.20718531f, 0.18099798f, 0.27493492f, 0.03635521f, 
    -0.13879447f, -0.05369635f, 0.17152862f, 0.01492292f, 0.09328416f, -0.16369140f, 0.12442438f, -0.12310238f, 
    0.05386793f, 0.16133137f, 0.24363287f, 0.08498181f, 0.20835494f, 0.03209663f, 0.01463801f, 0.13556591f, 
    -0.01041139f, 0.39398018f, 0.36485422f, 0.02130706f, -0.08050899f, 0.03164631f, 0.15065220f, 0.01375260f, 
    0.03744243f, 0.12071211f, 0.55878586f, 0.41474870f, 0.36963531f, 0.02569617f, 0.03838671f, 0.12762611f, 
    0.10513428f, -0.00471730f, 0.05906615f, 0.01985198f, 0.30417290f, -0.05560042f, 0.11788248f, 0.05327841f, 
    0.15944271f, 0.21037623f, 0.06008731f, -0.00258823f, -0.03385846f, 0.14599271f, 0.21454468f, -0.09733030f, 
    0.17530000f, 0.00444657f, 0.14537828f, 0.38162574f, -0.16249923f, 0.09234972f, 0.10610814f, 0.04490155f, 
    -0.02989307f, 0.12677534f, -0.05428802f, 0.20907053f, -0.14840926f, -0.74908388f, 0.02578660f, 0.01843426f, 
    0.26937470f, 0.05527312f, -0.03169296f, -0.09699018f, 0.01471907f, 0.16427957f, 0.06247865f, -0.01675084f, 
    0.27199531f, 0.14415406f, -0.00022564f, -0.17229721f, -0.18398905f, -0.02118846f, -0.18551444f, -0.34467205f, 
    0.06982449f, -0.21323261f, -0.09861439f, 0.19187772f, 0.06071656f, 0.19781373f, -0.07406586f, -0.00004032f, 
    -0.06908664f, 0.20823698f, 0.01167030f, 0.38681114f, -0.05065965f, 0.16479743f, 0.04774391f, -0.05214234f, 
    0.10750628f, 0.28946015f, 0.18336435f, 0.29881454f, 0.15968509f, -0.15252098f, -0.27519944f, 0.07117883f, 
    0.13743825f, -0.05710703f, -0.13788228f, 0.01194742f, -0.28573477f, -0.33455622f, 0.19935226f, -0.09276577f, 
    0.34503987f, -0.09514483f, 0.30968988f, 0.03459614f, -0.38729846f, -0.43968603f, 0.05545777f, -0.03891606f, 
    0.16379628f, 0.24523674f, 0.16780767f, 0.12925412f, 0.25019932f, -0.07387765f, -0.03118294f, -0.19620034f, 
    0.06875544f, 0.13593341f, 0.17077160f, 0.31875032f, 0.25525641f, 0.04144380f, -0.00951600f, -0.14323018f, 
    0.00526408f, 0.19702280f, 0.03848743f, -0.24923235f, 0.10676470f, -0.32184994f, -0.33043900f, -0.03427957f, 
    -0.01789056f, -0.04898344f, 0.10053024f, -0.00858661f, -0.16356097f, -0.52057052f, -0.24604101f, -0.44937408f, 
    -0.06430435f, 0.14751668f, 0.15889008f, -0.10189504f, -0.34221533f, -0.15277387f, 0.12628847f, 0.01896944f, 
    0.01818700f, 0.00118649f, -0.03850504f, 0.12513252f, -0.02768358f, 0.07734830f, 0.00107434f, 0.11440433f, 
    0.05469768f, -0.13631459f, 0.02811572f, 0.06580265f, 0.14482574f, -0.03662423f, -0.02491368f, -0.16642851f, 
    0.05980919f, -0.21361022f, -0.12014386f, -0.11776323f, 0.03073525f, 0.09850119f, -0.26555401f, 0.12202127f, 
    -0.15676446f, 0.12187620f, -0.01608380f, -0.18046951f, 0.18190348f, 0.04070589f, 0.24572045f, 0.00751559f, 
    0.00573422f, 0.03246284f, 0.05858672f, -0.02424482f, 0.15588054f, 0.05785387f, -0.01204923f, -0.10334561f, 
    -0.63549185f, -0.10846411f, -0.35943031f, 0.03098203f, 0.20861585f, 0.08040540f, -0.35671690f, 0.06274005f, 
    -0.30240783f, 0.09852697f, -0.00897031f, -0.22843398f, 0.02419668f, 0.10618262f, -0.03010109f, 0.20880698f, 
    -0.06221413f, 0.42367876f, -0.03127711f, -0.00582270f, -0.16580319f, -0.00204925f, 0.01661624f, 0.06727138f, 
    0.18157977f, 0.19167741f, 0.39508173f, -0.49939948f, -0.26233330f, -0.22777611f, 0.15392627f, 0.11755038f, 
    0.09568208f, -0.04587753f, 0.25686434f, 0.29685959f, 0.00787701f, -0.25366279f, 0.07095832f, -0.05787023f, 
    0.06932650f, -0.13021256f, 0.54991454f, 0.45959166f, 0.33196872f, -0.08143228f, -0.16868475f, 0.00154892f, 
    0.06370281f, -0.01973460f, -0.18771605f, 0.14184226f, 0.24914379f, 0.19269471f, -0.10036979f, 0.18882877f, 
    -0.27918378f, 0.09610313f, -0.00670197f, -0.00664850f, -0.16178796f, 0.07403303f, 0.05505993f, -0.15509586f, 
    0.16171402f, 0.03046549f, -0.07822571f, 0.11820379f, -0.08020200f, 0.06025192f, 0.14065939f, 0.15239255f, 
    -0.01298900f, 0.14083242f, -0.27006352f, -0.06580307f, 0.00595423f, -0.02638590f, -0.09120860f, -0.31152984f, 
    -0.04615917f, 0.00997912f, -0.05345932f, -0.23532298f, 0.10570193f, 0.10662493f, 0.22013356f, -0.00773689f, 
    0.02097093f, 0.37512866f, -0.67549837f, -0.04183840f, 0.01267336f, 0.22148742f, 0.02967035f, -0.00679849f, 
    -0.16857043f, -0.39109102f, 0.24170801f, -0.09108227f, 0.09487148f, -0.00318780f, 0.18753098f, 0.05549103f, 
    0.03982307f, 0.27217957f, -0.18922161f, -0.38531262f, -0.01967733f, 0.02006906f, -0.08208882f, 0.05694422f, 
    -0.10033503f, 0.26142004f, -0.12067842f, -0.11712896f, 0.09391626f, 0.08568843f, 0.16625267f, -0.04455252f, 
    0.37625730f, 0.06632400f, -0.05174953f, -0.06081825f, -0.02406627f, 0.11699504f, -0.03447468f, 0.01037802f, 
    0.07753932f, 0.03757958f, 0.19775032f, 0.00852610f, -0.40095752f, -0.48166856f, -0.23231986f, -0.00833233f, 
    0.15561792f, 0.16651374f, 0.19810164f, -0.20162062f, -0.18584208f, 0.00981264f, 0.40966564f, -0.06656417f, 
    -0.25309202f, 0.16680585f, -0.18122520f, -0.07306857f, 0.02064641f, -0.07453758f, 0.03147605f, 0.06058270f, 
    -0.24078321f, 0.09700861f, 0.10389303f, -0.05728003f, -0.01387464f, -0.11658894f, -0.00339627f, -0.24919064f, 
    0.18380724f, 0.03847806f, 0.13370189f, 0.07682211f, 0.08527157f, 0.09908025f, -0.01099186f, -0.17772414f, 
    0.32928300f, 0.23149112f, 0.42738962f, -0.08289909f, -0.18015067f, -0.06646562f, 0.04950411f, -0.07052137f, 
    -0.08750174f, 0.17217197f, -0.12713212f, 0.06194406f, 0.12958045f, -0.03568514f, 0.06184822f, -0.01085720f, 
    -0.08151761f, 0.01472566f, -0.56785738f, 0.18195429f, 0.04015211f, 0.15234841f, 0.01732390f, 0.13470094f, 
    -0.07121056f, 0.04399116f, -0.12661146f, 0.21399759f, -0.61146921f, -0.16766109f, -0.46861026f, 0.05441634f, 
    -0.15005201f, 0.07347237f, 0.16683300f, 0.07924198f, 0.01706434f, 0.18013032f, 0.48410425f, -0.21545742f, 
    -0.28078991f, -0.72918802f, 0.11810516f, -0.01507639f, 0.15235433f, -0.00216368f, 0.00914080f, 0.09364830f, 
    -0.21342219f, -0.19219857f, -0.26850390f, 0.09822720f, 0.10563366f, 0.19899565f, 0.21728116f, 0.20858331f, 
    0.17212594f, 0.13181502f, 0.01730016f, -0.01178121f, 0.04707349f, -0.02700605f, -0.11601979f, 0.41353446f, 
    -0.06422789f, 0.16276926f, 0.07155699f, 0.07902975f, 0.09864852f, 0.16768609f, -0.08220209f, -0.23840930f, 
    0.05101771f, 0.07679182f, -0.07963432f, 0.11625218f, 0.00362936f, -0.15800762f, 0.07259678f, 0.03297775f, 
    -0.10051550f, -0.01916967f, 0.06569961f, 0.16396943f, -0.07282928f, 0.16757965f, 0.03468921f, -0.07892409f, 
    0.03689925f, 0.01576267f, -0.43996811f, -0.04727797f, 0.05840712f, 0.09765172f, 0.02852422f, -0.06902675f, 
    -0.05613682f, 0.11304819f, -0.19937192f, 0.06407879f, -0.22637905f, 0.12470905f, 0.24180129f, 0.10510732f, 
    0.04735506f, 0.35440952f, 0.16753082f, 0.26958355f, 0.22172317f, -0.25938559f, -0.46181634f, 0.09455771f, 
    -0.08859762f, -0.05035326f, 0.00813294f, -0.03144216f, -0.17712750f, 0.06629144f, -0.08415128f, 0.05428565f, 
    -0.35847923f, 0.05256690f, -0.18153529f, 0.26314256f, -0.03986197f, 0.12101655f, -0.50916976f, -0.13376954f, 
    0.18172818f, -0.12285012f, 0.00784387f, -0.39399666f, -0.02535148f, 0.20086727f, 0.19724402f, -0.35145164f, 
    0.26726449f, 0.49894232f, -0.03772675f, 0.10308471f, 0.01510401f, 0.04997059f, 0.05801645f, 0.07496426f, 
    0.02103145f, 0.02836419f, -0.00701553f, -0.21272407f, -0.08662889f, 0.07800203f, 0.04577741f, 0.02389756f, 
    0.02191412f, 0.10625934f, 0.43251252f, -0.34333974f, -0.00231949f, 0.04114094f, -0.04525942f, 0.06744467f, 
    0.04431281f, -0.27833652f, -0.32051983f, -0.15440440f, -0.58247012f, -0.12304019f, 0.04993576f, 0.01931147f, 
    -0.02434865f, -0.09903918f, -0.38136587f, -0.22254914f, 0.28301632f, 0.26067996f, 0.15171900f, -0.02743237f, 
    -0.03016781f, 0.09048551f, 0.10541136f, 0.04507265f, 0.12436867f, 0.03145526f, 0.04096007f, 0.09422909f, 
    0.07398970f, 0.10777669f, 0.40652391f, 0.12100394f, 0.14264631f, -0.19264998f, -0.08442652f, 0.19816603f, 
    0.21519443f, -0.06937763f, -0.03205759f, -0.09687620f, 0.00472409f, -0.08414908f, -0.37945127f, -0.10769414f, 
    -0.00829876f, 0.12142754f, 0.04508768f, 0.00673043f, 0.01420979f, 0.08265669f, 0.12903503f, 0.10821495f, 
    -0.09912502f, 0.05523156f, -0.00899451f, 0.02500459f, -0.06942523f, -0.03211883f, 0.04597005f, 0.14937137f, 
    -0.04216910f, -0.13194448f, -0.26772892f, 0.06559419f, -0.08906370f, -0.15689230f, 0.18049426f, -0.06790264f, 
    0.10389081f, -0.06004254f, -0.29062396f, 0.03107976f, -0.16854888f, 0.03612447f, -0.09494990f, 0.01143323f, 
    -0.12746316f, -0.07108973f, 0.08345787f, -0.25094533f, -0.01226747f, 0.09010018f, 0.16601768f, -0.10225129f, 
    0.31281209f, 0.18254150f, 0.13515423f, -0.02372953f, -0.05785158f, 0.03001644f, -0.00280783f, 0.08338372f, 
    -0.09912223f, 0.21345051f, -0.02056696f, 0.24092695f, 0.03256076f, -0.17759420f, -0.44016713f, 0.21226400f, 
    0.04182559f, -0.04088946f, 0.06776284f, -0.24572344f, 0.18687330f, -0.21136869f, -0.00237334f, 0.14910480f, 
    -0.01548136f, 0.09235451f, 0.07589165f, 0.04660482f, -0.08874048f, 0.07978991f, -0.42577079f, -0.04875612f, 
    -0.23643711f, 0.09130705f, 0.02682535f, 0.05905268f, 0.14092033f, 0.09617984f, -0.04965904f, 0.49627686f, 
    -0.07864363f, -0.21425070f, 0.22965230f, 0.06803286f, 0.11149505f, 0.00576411f, -0.02127536f, -0.10008151f, 
    -0.42065150f, -0.13649328f, -0.26548457f, -0.15515274f, 0.08794919f, -0.05931770f, -0.00442506f, -0.00150415f, 
    -0.42831478f, -0.01121637f, 0.04876131f, -0.08419057f, -0.02483493f, 0.00745420f, -0.16657779f, 0.05937992f, 
    0.14813089f, -0.02883521f, 0.01035604f, -0.36091155f, 0.27531305f, -0.04800903f, 0.08050370f, 0.03261738f, 
    -0.03323842f, -0.02880802f, 0.02658980f, -0.39801449f, -0.04736583f, 0.02996530f, 0.02898427f, 0.25874323f, 
    -0.05460233f, 0.10588262f, -0.19667254f, -0.07702094f, -0.04467416f, 0.04416939f, 0.21237977f, -0.20686629f, 
    -0.32617214f, -0.20443968f, 0.09835579f, 0.22954491f, 0.11575343f, 0.21764845f, -0.04345579f, 0.11544731f, 
    -0.12367539f, -0.08571408f, -0.26611206f, 0.15489976f, 0.13947159f, 0.40188760f, -0.28326201f, 0.17473873f, 
    -0.08752216f, -0.12601559f, 0.25320575f, -0.01180893f, 0.07244569f, -0.09766522f, -0.06444609f, -0.02687919f, 
    0.02359271f, -0.13807270f, 0.04890651f, 0.20519385f, 0.12741479f, -0.09901930f, -0.10712763f, -0.09414767f, 
    -0.01390364f, 0.08158573f, 0.21670182f, 0.04335175f, -0.04225245f, -0.04204958f, -0.00726735f, -0.05514430f, 
    0.13119061f, 0.12050131f, 0.21326028f, -0.06326338f, 0.16727801f, 0.00219061f, 0.20278184f, 0.05162742f, 
    0.01846752f, 0.30122590f, 0.13874598f, -0.09595241f, 0.23681213f, -0.26550370f, -0.15919040f, -0.10347373f, 
    0.04359138f, -0.07505024f, -0.03562904f, 0.07613139f, -0.07844521f, 0.34104928f, 0.05467279f, 0.02253414f, 
    0.05254693f, 0.22990952f, -0.00018331f, 0.17259337f, -0.15432075f, -0.26872468f, -0.34635359f, -0.04569024f, 
    -0.12880197f, 0.05012027f, 0.00133411f, 0.03651384f, 0.09388021f, -0.37372240f, 0.11989807f, 0.15150657f, 
    -0.16507258f, -0.03393709f, -0.08685287f, 0.16478458f, 0.01231318f, -0.17781493f, 0.11617079f, 0.28833476f, 
    -0.12976515f, -0.13314387f, -0.24281907f, -0.22025862f, 0.09957806f, -0.06037331f, -0.05880592f, -0.14210576f, 
    -0.00798611f, 0.09302153f, 0.02596377f, -0.00231214f, -0.00891609f, -0.01051116f, -0.02997358f, 0.06179620f, 
    0.12499446f, 0.12658311f, 0.15192780f, -0.06324020f, -0.05630771f, -0.05388157f, 0.01255437f, -0.00414719f, 
    -0.09677968f, -0.00584534f, -0.32717255f, 0.03573658f, -0.00872394f, 0.04882609f, 0.15818723f, -0.06544314f, 
    0.09719814f, 0.08443914f, 0.28207716f, 0.13556059f, 0.22451437f, -0.05106118f, 0.07030322f, 0.11419228f, 
    -0.01248368f, 0.16966513f, 0.15447004f, -0.13045593f, -0.31342399f, 0.05058662f, -0.00320175f, -0.03685044f, 
    -0.09435715f, 0.04307524f, -0.22449149f, 0.12488639f, -0.12660092f, 0.37771729f, 0.08495762f, 0.10318466f, 
    0.00460074f, -0.01358011f, 0.31241184f, -0.13029945f, 0.32791615f, -0.06269743f, 0.01282935f, -0.07647929f, 
    0.05549999f, -0.03368987f, 0.05568599f, -0.04390128f, -0.24295084f, 0.12684043f, -0.11136832f, 0.13218705f, 
    -0.10385161f, 0.19912289f, -0.00748375f, -0.03875423f, -0.03818049f, 0.01309178f, -0.20775840f, 0.08659290f, 
    -0.01647464f, 0.14680499f, -0.07164174f, 0.03071061f, -0.05730996f, -0.11393774f, 0.06188298f, -0.01562786f, 
    -0.24908619f, 0.19416261f, 0.26243070f, -0.21371531f, 0.04967397f, 0.01879937f, -0.17420492f, 0.18391475f, 
    -0.09796571f, -0.26091886f, -0.08503198f, -0.26525214f, -0.15223987f, -0.13479003f, 0.39012095f, -0.04007067f, 
    0.05824750f, -0.20136949f, -0.41799003f, 0.09800118f, 0.41602626f, 0.05531146f, -0.07682054f, 0.20690994f, 
    -0.05681974f, 0.12020312f, -0.02519088f, 0.00544578f, 0.14092010f, 0.14579645f, -0.00998772f, -0.03538150f, 
    -0.10863101f, -0.08974837f, 0.09671962f, -0.10858615f, -0.03683521f, -0.19387883f, 0.02451164f, 0.03078864f, 
    0.15372287f, 0.03830193f, -0.39421669f, 0.09389555f, 0.11837880f, 0.07416145f, -0.04450889f, -0.00588774f, 
    0.05845606f, 0.14490144f, -0.07721338f, 0.04061733f, -0.12280696f, 0.15377569f, 0.29173070f, 0.10949325f, 
    -0.29891452f, 0.05831213f, 0.10004546f, 0.06889620f, 0.07958587f, 0.08106106f, 0.14292786f, -0.20426357f, 
    0.06825040f, 0.06503352f, 0.05012576f, -0.05811709f, 0.18794277f, -0.18382633f, 0.06860041f, 0.27941456f, 
    0.13214146f, 0.04409949f, 0.21581902f, -0.16332552f, -0.14388821f, -0.01796780f, -0.05590926f, -0.01141794f, 
    0.07207461f, 0.07733355f, 0.00406424f, -0.31654677f, -0.17135055f, -0.01986364f, -0.17638116f, 0.02947216f, 
    -0.04624802f, -0.11293939f, -0.39502046f, -0.28891742f, 0.01505237f, 0.19419776f, -0.16143823f, 0.03702230f, 
    -0.02205241f, 0.17226620f, 0.02852137f, 0.34360251f, 0.02496782f, -0.04303143f, -0.02519036f, 0.22935045f, 
    -0.00737203f, -0.15974623f, -0.25238147f, -0.17421971f, 0.10363474f, -0.25488111f, -0.12431767f, 0.01061609f, 
    -0.10497833f, -0.13221398f, -0.21281447f, -0.16245979f, 0.07627137f, -0.07705095f, -0.00350879f, -0.02476579f, 
    -0.13308029f, -0.06045413f, 0.00288042f, 0.03761822f, -0.00185952f, -0.26265270f, 0.11775948f, -0.13318019f, 
    -0.03721419f, -0.06389981f, 0.17759573f, -0.00290153f, -0.02330538f, 0.03728615f, 0.07417561f, 0.15268375f, 
    -0.15513203f, -0.09740342f, -0.08068947f, 0.03212104f, -0.05786099f, -0.00084877f, 0.15243171f, 0.11651069f, 
    -0.00998308f, -0.42127845f, 0.02396872f, -0.14334778f, 0.13675401f, -0.05838258f, 0.13265337f, 0.05358428f, 
    0.24693704f, 0.15780312f, 0.15932120f, 0.20983249f, 0.14440411f, -0.09731499f, 0.23279914f, -0.02054023f, 
    -0.01012952f, 0.33058488f, -0.25511345f, 0.08724631f, 0.20606242f, -0.37045154f, -0.16521099f, -0.21966931f, 
    -0.08969100f, 0.02818709f, 0.04253348f, -0.03260989f, -0.26606399f, 0.08664844f, -0.18050189f, 0.29136795f, 
    -0.03132436f, 0.12751102f, -0.01188259f, 0.18410045f, -0.14062868f, 0.15464832f, 0.09998124f, 0.22654791f, 
    -0.21223830f, -0.18627401f, -0.01114701f, -0.10217341f, 0.07209410f, 0.09052472f, -0.63588476f, 0.03699118f, 
    -0.06165677f, 0.20895480f, -0.06730830f, 0.13972138f, -0.24560338f, 0.05485034f, -0.67279482f, -0.09001832f, 
    -0.01617122f, -0.10980178f, -0.07957750f, -0.24019323f, -0.15855341f, 0.04824568f, 0.02396980f, -0.17429237f, 
    0.29704306f, 0.39368415f, 0.01700143f, 0.15289736f, -0.24147518f, -0.19705139f, -0.02969120f, 0.01498888f, 
    -0.15354447f, -0.41879290f, -0.11670993f, -0.08844726f, -0.03102931f, -0.20959903f, 0.24540780f, 0.05864179f, 
    -0.16079965f, 0.07647571f, -0.05313597f, -0.23699854f, 0.10143051f, -0.08351023f, -0.05845625f, 0.01230902f, 
    -0.01571938f, 0.12246870f, -0.69640815f, -0.27142167f, -0.15393487f, 0.07004317f, -0.03506162f, -0.04275308f, 
    0.01121286f, 0.03379353f, 0.05771621f, 0.29122749f, 0.24599655f, 0.30270085f, -0.02351587f, 0.26973143f, 
    0.15227331f, -0.09462295f, 0.02128321f, 0.04531291f, 0.04001627f, -0.17902540f, 0.52052039f, -0.04598118f, 
    -0.10684322f, 0.09460011f, 0.06542804f, -0.09979893f, 0.30498922f, 0.00028616f, 0.21732083f, 0.42212600f, 
    0.05909544f, 0.08450434f, -0.12930973f, 0.00080175f, 0.01501943f, 0.33949751f, -0.32945576f, 0.47337857f, 
    0.48489130f, -0.01499238f, 0.03046288f, 0.03560942f, 0.00659364f, 0.03515784f, 0.08700264f, -0.05238057f, 
    -0.37338689f, 0.05817325f, -0.23217097f, 0.08292129f, -0.24774177f, -0.02388671f, 0.18380198f, -0.10901857f, 
    0.07666801f, -0.11172763f, 0.19277184f, -0.13034675f, -0.06070742f, -0.09525049f, 0.18609338f, -0.09352195f, 
    -0.09340159f, -0.00773723f, 0.15546487f, -0.19198255f, 0.19723716f, -0.08821363f, 0.19753742f, -0.12759267f, 
    -0.02347924f, -0.02788365f, -0.01951655f, -0.08518768f, 0.07712376f, -0.05898864f, -0.22924890f, 0.04590457f, 
    0.02317689f, 0.05702940f, 0.00675381f, -0.13949792f, -0.15794200f, 0.06804493f, -0.29720417f, -0.26693246f, 
    -0.27656901f, -0.05711544f, 0.02682112f, 0.04598602f, 0.19643112f, 0.11301837f, -0.05499747f, -0.15360038f, 
    -0.25589341f, 0.31427416f, -0.12660110f, 0.11127103f, -0.04632026f, 0.18912715f, -0.49626765f, 0.19554392f, 
    0.00733988f, -0.14772238f, 0.15077032f, -0.05803695f, 0.16375901f, 0.19526447f, -0.01748140f, 0.19652066f, 
    0.31109008f, 0.03120941f, 0.04536979f, 0.09285074f, 0.03277927f, -0.02024533f, 0.34792176f, 0.02556870f, 
    -0.35405055f, -0.02179319f, 0.03326402f, -0.09704452f, -0.18264207f, -0.04099379f, 0.10438281f, 0.20838679f, 
    -0.43380433f, -0.18687472f, -0.67078692f, -0.04221527f, -0.05800449f, -0.21631908f, -0.05938203f, 0.07452226f, 
    0.03932539f, -0.28299248f, -0.21527687f, -0.48463917f, -0.05086416f, -0.06380142f, -0.25056520f, 0.24424401f, 
    0.21238552f, 0.03183759f, -0.04336395f, -0.45115858f, 0.34173426f, -0.00506637f, -0.19536869f, 0.16064578f, 
    0.05161598f, 0.08612065f, 0.05480447f, -0.27451992f, 0.03886091f, 0.36450988f, -0.02471429f, -0.23087865f, 
    -0.18097380f, 0.06138272f, -0.02943253f, -0.02078901f, -0.33077672f, 0.39708579f, -0.02575545f, 0.10127896f, 
    0.25861284f, 0.16657130f, -0.06389358f, 0.03546862f, -0.06240008f, -0.06728155f, 0.09954242f, 0.14582707f, 
    0.03381179f, 0.16772053f, -0.11145825f, 0.08952057f, -0.07914854f, -0.06363405f, -0.15167281f, -0.26451337f, 
    0.11855456f, -0.14765230f, 0.10567799f, 0.06641100f, 0.16989365f, 0.15623322f, 0.07645034f, -0.43345630f, 
    -0.43700466f, -0.55034125f, -0.20735653f, -0.00377291f, 0.08792209f, 0.17549363f, 0.08261154f, 0.05318922f, 
    0.08551524f, -0.05550865f, -0.29244906f, -0.32465455f, -0.26982364f, -0.18552251f, 0.12908423f, -0.01424703f, 
    -0.02596536f, 0.02974548f, -0.06194151f, 0.28298315f, 0.24647425f, 0.10489558f, 0.00971276f, 0.00246114f, 
    -0.05693858f, -0.04809206f, 0.71895987f, -0.02180999f, -0.11252502f, -0.04772331f, -0.08324597f, -0.15885893f, 
    0.06743129f, -0.14721800f, 0.10358493f, -0.07822002f, 0.10830452f, 0.07078345f, 0.10454020f, 0.11583557f, 
    -0.17329451f, -0.03442250f, 0.08465181f, 0.07425811f, -0.80002910f, -0.45229504f, 0.22599171f, -0.00003689f, 
    0.07062699f, 0.01334738f, -0.01072144f, -0.04129945f, -0.05862014f, 0.01352836f, 0.01553212f, 0.03661330f, 
    -0.07731286f, -0.06945421f, -0.36286083f, 0.11420336f, 0.20995805f, 0.25588915f, 0.50197524f, -0.35769945f, 
    -0.75473583f, -0.02599877f, -0.04423577f, -0.03403503f, -0.11220638f, 0.07083840f, -0.01017505f, 1.19664609f, 
    0.21538642f, -0.81553108f, -0.20435134f, 0.11481482f, -0.02438478f, 0.07861516f, -0.09386025f, 0.02229427f, 
    0.00766094f, 0.10086374f, -0.15641282f, -0.39550364f, -0.32402286f, -0.02027491f, 0.11043105f, -0.03681926f, 
    0.01961704f, 0.24547437f, -1.43427980f, -0.54176372f, -0.09681010f, 0.08421149f, 0.08768950f, -0.10844212f, 
    -0.03901643f, -0.03807194f, -0.62745750f, -0.73530567f, 0.07208199f, -0.11690117f, -0.04103987f, -0.05997264f, 
    -0.01444297f, -0.03663454f, 0.10968805f, 0.55789739f, 0.28264707f, -0.37823999f, 0.14205189f, 0.14877075f, 
    0.04598125f, 0.23802620f, -0.01460520f, -0.03766416f, 0.38639683f, 0.06100255f, 0.27730519f, 0.01686881f, 
    0.11065550f, 0.07270877f, 0.16243106f, 0.03114953f, 0.04557304f, -0.12766135f, 0.23828803f, 0.68238479f, 
    0.13761553f, 0.03743700f, -0.27925080f, 0.00592836f, -0.13805164f, 0.04852472f, -0.19133367f, -0.10559308f, 
    0.01166177f, -0.03001412f, -0.04864894f, 0.08276857f, -0.00634517f, 0.10705961f, 0.05203076f, -0.00641861f, 
    0.18482482f, 0.15703912f, -0.15934831f, -0.21534441f, -0.05500742f, 0.06480120f, -0.15620613f, -0.01429452f, 
    0.04469325f, -0.08030815f, 0.10216901f, -0.06603130f, 0.10607588f, 0.09525290f, -0.21105114f, -0.07503579f, 
    -0.06707833f, 0.35505903f, -0.02084448f, -0.42074430f, -0.00417777f, -0.13796213f, -0.35219446f, 0.14987235f, 
    0.12522791f, -0.09960335f, -0.12373986f, -0.04601384f, -0.33720246f, -0.04459066f, 0.10155889f, 0.02081953f, 
    -0.10424236f, -0.05323186f, 0.12535952f, 0.06569976f, 0.09013506f, -0.04279852f, -0.01989079f, 0.02601481f, 
    -0.09245520f, -0.04514721f, -0.11372180f, -0.14250281f, 0.33280936f, -0.24023837f, -0.02557087f, -0.00480746f, 
    0.27788633f, 0.08578531f, -0.04427838f, 0.08092117f, 0.05611856f, 0.14836521f, 0.23411991f, -0.31630170f, 
    -0.31402668f, -0.08767764f, 0.18541351f, 0.11361506f, 0.08910644f, -0.03451477f, -0.49251425f, -0.55498827f, 
    0.26384929f, 0.07995894f, 0.06852724f, -0.06720029f, -0.03417829f, 0.02984338f, 0.19897635f, -0.32049102f, 
    -0.30996239f, 0.05504350f, 0.09633944f, 0.00159856f, 0.00041452f, 0.04232492f, 0.02913170f, 0.23573524f, 
    -0.13696688f, -0.71899360f, -0.22065529f, -0.18656029f, -0.06157150f, -0.12860404f, 0.08535805f, -0.07104850f, 
    0.11858279f, -0.16807799f, -0.20521474f, -0.38745114f, -0.03593307f, -0.10848004f, -0.13204943f, -0.03224656f, 
    -0.02911754f, -0.14836988f, -0.46732730f, 0.05412949f, 0.35298440f, -0.04902873f, 0.17812331f, 0.05384999f, 
    -0.00581883f, 0.12903897f, 0.07988766f, 0.69060755f, 0.50830257f, 0.31036943f, -0.40523061f, 0.17216754f, 
    -0.20069237f, 0.24468301f, -0.03295270f, 0.10465560f, 0.26462474f, 0.03578106f, -0.80353910f, -0.33203042f, 
    0.18756194f, 0.27115986f, 0.11748318f, 0.03364450f, 0.03177809f, -0.01303984f, 0.12078836f, -0.11686219f, 
    -0.11038786f, -0.09207410f, -0.08675873f, 0.09197746f, 0.08604289f, 0.14105593f, 0.21610370f, -0.15454221f, 
    -0.50492883f, 0.26852065f, 0.16892849f, 0.07847358f, 0.13745816f, -0.01510058f, -0.12155639f, -0.21775511f, 
    -0.04210153f, 0.26889890f, 0.09322554f, 0.03944761f, 0.00279381f, -0.00032085f, 0.07903555f, 0.10920309f, 
    0.07523672f, 0.08556414f, 0.12696396f, 0.08459304f, 0.07583178f, 0.08582351f, 0.07932723f, 0.08614258f, 
    0.19140509f, -0.14706968f, -0.02148078f, 0.21905923f, 0.00812270f, 0.27336979f, 0.17715995f, -0.00556791f, 
    0.22846833f, 0.02003062f, -0.31557924f, 0.19530538f, 0.11162259f, -0.09029477f, -0.16063876f, -0.04203793f, 
    0.07106633f, 0.11441481f, -0.09696048f, 0.04531511f, -0.11195925f, 0.11941488f, -0.00220206f, -0.06294551f, 
    0.24492030f, 0.41817498f, -0.08897093f, 0.17101273f, 0.43092111f, 0.03399331f, -0.37018287f, 0.06861903f, 
    0.06554288f, -0.02374458f, 0.01371183f, 0.04274993f, 0.04182979f, -0.47007895f, -0.22645883f, -0.03685056f, 
    -0.02420010f, -0.21487927f, 0.12304077f, -0.13255055f, -0.25614920f, -0.36067095f, -0.44159746f, -0.07328974f, 
    0.20458521f, -0.03624925f, -0.25703081f, 0.05610387f, -0.00953024f, -0.09171804f, -0.05552398f, 0.14627841f, 
    0.04385754f, 0.23960979f, 0.01249866f, -0.29963231f, -0.10336685f, 0.04072889f, 0.03178994f, 0.07938325f, 
    0.24442369f, 0.06500013f, 0.31780633f, -0.17006561f, 0.17138040f, 0.10833418f, 0.04991738f, -0.05212222f, 
    0.09399854f, 0.12291478f, 0.17379734f, 0.13591640f, 0.11318552f, -0.03900482f, 0.00881306f, -0.00067114f, 
    0.12156687f, -0.08092481f, 0.00074388f, 0.26707864f, 0.18854198f, 0.25802404f, 0.01362951f, -0.00900319f, 
    -0.01890532f, 0.01436332f, -0.16331026f, 0.14852636f, 0.17318285f, 0.22429845f, 0.03970825f, -0.09891947f, 
    -0.10108355f, 0.19881159f, 0.14969246f, 0.25288537f, -0.06256737f, 0.03429245f, 0.00216045f, 0.27881747f, 
    0.15265831f, 0.13430634f, -0.04674156f, -0.15532248f, -0.06306992f, -0.07734925f, 0.14860001f, 0.05135722f, 
    -0.13252629f, -0.17688121f, -0.05655479f, -0.11224774f, -0.07171072f, -0.24498221f, -0.01435188f, 0.06838829f, 
    -0.06109336f, -0.12807986f, -0.09802584f, 0.04284234f, -0.00469047f, 0.02869140f, 0.11557419f, 0.10714153f, 
    -0.05988023f, 0.21041253f, -0.08957601f, 0.15660343f, -0.05506357f, 0.06799647f, -0.09438997f, 0.06501337f, 
    -0.02804606f, -0.08847692f, 0.19707350f, -0.08411409f, 0.07783578f, -0.14052805f, 0.10671281f, -0.23929857f, 
    -0.18283743f, -0.66408992f, -0.41435784f, 0.08918844f, 0.09596753f, 0.01059038f, 0.15652044f, -0.10703615f, 
    -0.06540082f, -0.27677378f, -0.13181764f, -0.40876311f, 0.10832124f, 0.05117691f, -0.09612808f, -0.12486110f, 
    -0.07955491f, -0.04639422f, -0.18248025f, -0.03322890f, -0.21933743f, 0.05057975f, -0.05533595f, 0.04182070f, 
    -0.08669272f, 0.18146145f, -0.16270302f, 0.06185637f, 0.03031028f, -0.11739617f, -0.18337452f, 0.06874539f, 
    -0.10517234f, -0.00865130f, -0.01182685f, -0.10545761f, -0.17896785f, -0.08647934f, -0.05759966f, 0.13432844f, 
    0.19421242f, -0.18324061f, 0.06054242f, -0.20771867f, 0.03919609f, 0.16878080f, 0.12893778f, 0.21051978f, 
    -0.07675476f, 0.08002408f, 0.09081752f, 0.06460248f, 0.03817855f, 0.04935199f, -0.01641963f, -0.28017879f, 
    -0.18776046f, -0.27366400f, 0.20730418f, 0.03034818f, 0.10466877f, 0.05465878f, 0.11062583f, 0.13928522f, 
    -0.11834772f, 0.21533231f, 0.11213760f, -0.01931815f, -0.15029766f, 0.05400942f, -0.03384360f, -0.03998452f, 
    -0.20937192f, -0.02464804f, 0.12146562f, -0.04400289f, -0.00401755f, 0.04290590f, -0.01748431f, 0.22310774f, 
    0.13408805f, -0.21997330f, 0.21203990f, -0.46698645f, 0.01480000f, 0.10852488f, 0.00953663f, 0.04372488f, 
    0.20404038f, 0.00399937f, 0.17735900f, 0.03204772f, 0.18032058f, -0.22574612f, 0.08611986f, 0.09189916f, 
    -0.03640162f, 0.15417738f, -0.11280052f, 0.07221306f, 0.06571135f, 0.15833029f, 0.19144903f, 0.01406344f, 
    -0.10979237f, -0.18633166f, -0.03160378f, -0.12879127f, 0.06296856f, -0.28156158f, -0.08775514f, 0.10600863f, 
    -0.01042266f, -0.02471098f, -0.11298684f, -0.14835697f, -0.19880883f, -0.15088044f, 0.02256295f, -0.09055201f, 
    -0.03186366f, 0.13152686f, -0.28603834f, 0.11116986f, 0.05729302f, 0.12929571f, 0.04056145f, 0.05089985f, 
    -0.10049550f, -0.17330083f, 0.15589811f, 0.00323044f, 0.17963700f, 0.17550643f, 0.14717700f, 0.12633333f, 
    0.02357057f, -0.00715566f, 0.01484869f, 0.05248627f, -0.05647016f, 0.01491102f, -0.05561540f, 0.03740118f, 
    0.03985141f, -0.01287214f, 0.02573459f, -0.05701615f, 0.04534310f, 0.01152101f, -0.02229010f, 0.01443884f, 
    -0.00850147f, -0.00436958f, -0.04257870f, -0.00455031f, -0.03038583f, -0.04104837f, -0.04886494f, -0.05814868f, 
    0.04617276f, -0.01366518f, 0.02983184f, 0.00228689f, -0.03531651f, -0.03649385f, -0.05567839f, -0.02633922f, 
    -0.04575252f, -0.04738543f, 0.04128624f, 0.03184100f, 0.03954998f, -0.04968602f, 0.04119529f, 0.00252862f, 
    -0.00210954f, -0.03366439f, 0.02171042f, -0.01639584f, -0.01761638f, 0.02660935f, -0.01484416f, 0.00413606f, 
    -0.02957588f, 0.03552017f, -0.04905402f, -0.02609388f, 0.02497037f, -0.03696989f, -0.03801473f, -0.00945075f, 
    0.04283031f, -0.04996465f, -0.01721896f, 0.01333071f, -0.02856923f, -0.04623394f, -0.02015488f, 0.04286521f, 
    -0.04252081f, -0.04535796f, 0.03347677f, 0.01211233f, -0.03304651f, -0.04972107f, -0.00473701f, -0.05945199f, 
    -0.05680722f, 0.01843806f, 0.04473395f, -0.00860293f, 0.01228879f, -0.06361732f, -0.00540794f, -0.04116268f, 
    0.04598282f, -0.03083485f, 0.03549846f, 0.03363122f, -0.03902337f, 0.04738025f, -0.02803439f, -0.04239725f, 
    -0.00500848f, 0.01120256f, -0.04788639f, -0.03098406f, 0.03627414f, 0.02978369f, -0.03225242f, -0.05103667f, 
    -0.06138121f, 0.00137190f, -0.00237282f, -0.03081866f, 0.05118706f, 0.02809407f, -0.05497396f, -0.02229009f, 
    -0.05811945f, 0.03709269f, -0.00115406f, -0.06628634f, 0.01272912f, -0.06128827f, -0.05608821f, -0.04934061f, 
    0.00519428f, -0.02510991f, -0.01317459f, 0.03068013f, 0.03059862f, -0.01452990f, 0.00144134f, -0.06427285f, 
    0.03045678f, -0.01836878f, 0.00494614f, -0.02013343f, 0.01742445f, 0.01810032f, 0.04405859f, 0.03416105f, 
    -0.03827089f, 0.03045446f, -0.04063497f, -0.02717212f, -0.01413833f, -0.04380000f, -0.01370479f, -0.06064247f, 
    -0.05400770f, 0.04346963f, 0.05010589f, 0.02496115f, -0.04016327f, 0.02265999f, -0.00477523f, -0.01078324f, 
    0.04588543f, -0.04875673f, -0.01279915f, -0.01850247f, -0.03246635f, 0.00070083f, 0.05125267f, -0.02309572f, 
    -0.05170240f, 0.04503576f, -0.01102935f, 0.03849771f, 0.00764164f, 0.04315344f, 0.04089613f, -0.01499436f, 
    -0.03155558f, 0.00166864f, -0.04579527f, -0.05114835f, 0.04213234f, -0.04814129f, 0.05250318f, 0.04052145f, 
    0.01679406f, -0.06062537f, -0.06419922f, 0.05065744f, 0.00377549f, 0.02263888f, -0.03629864f, -0.03064068f, 
    0.00696188f, -0.02224055f, 0.03406828f, -0.02510698f, 0.01716658f, 0.02827203f, -0.01819860f, 0.04732952f, 
    0.04751027f, -0.05720217f, -0.05732822f, 0.00416273f, -0.06489566f, -0.00076539f, 0.00345170f, -0.05685218f, 
    -0.04205682f, -0.05998996f, 0.05903193f, -0.02333093f, 0.05045112f, -0.05058886f, 0.03133008f, -0.02997888f, 
    0.00092363f, -0.03174738f, -0.00148164f, 0.03864237f, -0.03832131f, -0.03422755f, -0.03074434f, -0.03702210f, 
    -0.03989308f, -0.06217566f, 0.03578994f, 0.01342638f, 0.04331756f, -0.00584287f, 0.02524550f, -0.06159780f, 
    -0.05467173f, 0.01016821f, 0.02661410f, -0.02987137f, 0.01584467f, -0.00949617f, 0.03081714f, -0.05472315f, 
    0.03906918f, -0.02094358f, 0.00122857f, 0.01704149f, 0.02331328f, 0.00094428f, -0.03893620f, -0.04837284f, 
    0.00274825f, 0.01883579f, -0.01464574f, -0.05242381f, -0.02326818f, -0.01770855f, -0.03635953f, -0.00808617f, 
    -0.05893230f, -0.04142400f, -0.04159390f, -0.03737008f, -0.02283368f, 0.03212175f, -0.03769121f, 0.03876495f, 
    -0.03656150f, -0.01525697f, 0.04431814f, 0.02274451f, -0.06275012f, 0.03308323f, -0.02818590f, -0.01405614f, 
    -0.06225404f, -0.05809868f, 0.04049575f, -0.01856378f, 0.00781841f, 0.02020038f, -0.00391682f, 0.01742318f, 
    -0.05895215f, -0.05967136f, -0.01590657f, 0.00287087f, 0.04419514f, -0.04287218f, -0.00495145f, -0.03121190f, 
    0.04825127f, 0.03655438f, -0.04183269f, 0.00431499f, -0.02459413f, -0.05155854f, -0.00435051f, 0.05662084f, 
    0.01138015f, -0.00955393f, -0.00389303f, -0.01828089f, -0.01457713f, 0.00075471f, -0.04820057f, -0.06633288f, 
    0.00973061f, -0.05298877f, 0.06974776f, -0.09956029f, 0.10846960f, 0.08836836f, 0.13851666f, 0.13295442f, 
    0.09877806f, -0.02263701f, 0.33056310f, -0.02518605f, -0.11374836f, -0.23574449f, 0.04411711f, -0.04942527f, 
    0.15503526f, 0.07745519f, 0.23945256f, 0.10952114f, 0.03279205f, 0.02882872f, 0.11533626f, 0.11140113f, 
    0.15314798f, 0.05957032f, 0.12329350f, -0.13104710f, -0.19021820f, 0.04828187f, 0.16400854f, 0.06626936f, 
    -0.09587829f, -0.02194251f, -0.24812587f, 0.09263074f, -0.13614899f, 0.37381807f, 0.01314662f, 0.06270544f, 
    0.01148523f, -0.04161977f, -0.06022113f, -0.10576502f, -0.17881285f, 0.09322656f, 0.03949992f, -0.05496067f, 
    0.32886919f, 0.04712921f, 0.44454136f, -0.67605060f, -0.39252731f, -0.50557715f, 0.11189520f, -0.19688496f, 
    0.08458450f, -0.02674095f, -0.06926031f, 0.10437828f, 0.01250789f, 0.02038524f, -0.31061029f, 0.01528300f, 
    -0.11618488f, 0.09480681f, 0.11011400f, -0.20899145f, -0.23419660f, 0.15750459f, -0.00032602f, 0.08805836f, 
    -0.03934139f, 0.02695161f, -0.11704217f, 0.21281545f, 0.06257106f, 0.19329236f, -0.11584482f, -0.00708807f, 
    -0.05769370f, -0.11965334f, 0.04389292f, 0.01420553f, 0.16480629f, -0.04130517f, 0.04648399f, -0.00676720f, 
    -0.18490073f, 0.08006217f, 0.22038580f, 0.08807455f, 0.03088899f, 0.12694679f, -0.09092714f, 0.01345963f, 
    0.11813471f, 0.17682405f, 0.07370616f, -0.00480944f, 0.07427225f, 0.04715249f, -0.13394599f, 0.10863671f, 
    -0.17774881f, 0.06497871f, 0.18410198f, 0.12987500f, 0.05789989f, -0.03182650f, -0.04012028f, 0.09553105f, 
    -0.10911314f, 0.08974332f, -0.19737451f, -0.20810360f, -0.07086741f, 0.11041055f, 0.18662785f, -0.15596154f, 
    -0.04882634f, 0.13846362f, -0.01376505f, 0.07670750f, -0.23057213f, -0.17429672f, 0.04386815f, -0.03584132f, 
    0.01725475f, -0.08052733f, -0.01816862f, -0.09193416f, -0.00850102f, 0.03730445f, 0.03466101f, 0.04819405f, 
    -0.06568564f, -0.23859361f, 0.25507566f, 0.11425643f, 0.02879686f, -0.13601463f, -0.11029194f, -0.07016447f, 
    -0.00999385f, 0.21742366f, 0.07204774f, 0.17947727f, -0.07441485f, -0.02915590f, -0.27454937f, 0.01521681f, 
    -0.13162190f, 0.28201780f, 0.50201190f, -0.07061962f, -0.03378100f, -0.00075260f, 0.20902607f, 0.34796825f, 
    0.21333194f, -0.44306642f, -0.07910512f, 0.01341155f, -0.10756145f, 0.04107641f, -0.00484491f, -0.01482439f, 
    -0.39190564f, -0.08741088f, -0.35395449f, -0.13745442f, -0.06713419f, -0.12322174f, 0.17314301f, -0.08063071f, 
    0.11663615f, -0.17465560f, -0.39069098f, -0.29597291f, 0.22072238f, 0.27242455f, 0.16029344f, 0.07636908f, 
    0.04422219f, 0.20487586f, -0.32932797f, 0.16840887f, 0.26143140f, 0.20360731f, -0.05667255f, 0.09241592f, 
    0.02366902f, -0.27455863f, -0.13842647f, 0.22284772f, 0.23923109f, -0.00792628f, 0.24456652f, 0.14215027f, 
    0.07883538f, 0.06259461f, -0.00506466f, 0.03407361f, 0.03612673f, -0.11242285f, -0.21261281f, -0.22333476f, 
    0.12102191f, -0.01881657f, -0.09883196f, -0.04882516f, -0.16094743f, -0.05267828f, 0.27425292f, 0.18434861f, 
    0.29428074f, 0.20016733f, -0.12475704f, 0.06461432f, -0.08921449f, 0.08401608f, 0.05716487f, -0.01165019f, 
    0.09552097f, 0.32266000f, 0.08386212f, 0.18868616f, 0.03760830f, 0.06102151f, -0.08145327f, 0.22862424f, 
    0.00144432f, -0.22442299f, -0.15806378f, 0.13569486f, 0.06027547f, -0.02537776f, 0.17939614f, -0.10969713f, 
    -0.04071604f, 0.24234082f, 0.13353410f, -0.13280925f, -0.05841228f, 0.14523824f, 0.34614658f, -0.17078196f, 
    -0.07368051f, 0.18718483f, -0.12825744f, 0.06357133f, 0.00650164f, -0.14898050f, -0.27630267f, -0.04210890f, 
    0.05547084f, 0.14371833f, -0.12403042f, -0.06160990f, -0.04984638f, -0.04473808f, -0.13392586f, -0.15512031f, 
    0.16161446f, 0.12860183f, 0.19256662f, -0.41577399f, -0.38275132f, -0.54732829f, 0.22064476f, -0.00766963f, 
    0.08653574f, -0.21297067f, -0.14506252f, -0.13622212f, 0.19921975f, 0.30267563f, 0.12865373f, 0.03587132f, 
    -0.08503508f, 0.04443818f, -0.27649158f, -0.08783416f, -0.03593872f, 0.20603821f, 0.29193467f, -0.00895879f, 
    -0.07535154f, -0.05126060f, 0.02133247f, -0.19469334f, 0.02270831f, -0.27639264f, 0.02366514f, -0.06825970f, 
    0.00110855f, -0.01868861f, 0.03147741f, -0.21905032f, 0.09416515f, -0.32084453f, 0.10678158f, 0.20955895f, 
    -0.08038928f, 0.06615516f, 0.31788656f, 0.16502526f, -0.11507989f, 0.10301372f, 0.06523488f, 0.01531791f, 
    0.06859513f, 0.04044432f, 0.05066635f, -0.12003672f, -0.15412441f, 0.13919258f, -0.10352281f, -0.14461495f, 
    0.06011046f, 0.07550468f, 0.11243610f, -0.19037201f, 0.10375033f, -0.17233227f, -0.52963912f, -0.11994465f, 
    -0.07216573f, -0.07094806f, 0.02196301f, 0.11863363f, 0.20584044f, 0.08503094f, -0.00395253f, -0.12546614f, 
    0.14870614f, -0.00238735f, 0.12287784f, 0.08974921f, 0.03547860f, -0.36259657f, 0.31476945f, 0.49007642f, 
    0.32770637f, 0.18541035f, 0.02895357f, -0.12229122f, 0.04028614f, -0.05931194f, -0.12822372f, 0.26867852f, 
    0.30478609f, -0.15743862f, 0.10626446f, 0.14353529f, -0.06857245f, 0.07112083f, -0.07098535f, -0.07785008f, 
    -0.01200443f, -0.15234250f, 0.08804812f, -0.29743215f, -0.03430364f, -0.25737983f, 0.05890698f, -0.07077590f, 
    0.08914483f, 0.26199269f, -0.01944245f, -0.22678840f, 0.04402937f, -0.00427602f, -0.03221365f, -0.05791683f, 
    0.00148671f, 0.10401713f, 0.34601042f, 0.23253021f, -0.37297988f, -0.09195673f, -0.00354614f, 0.09085379f, 
    0.01356701f, 0.07708608f, 0.07090291f, -0.17552005f, -0.18621203f, -0.02653167f, -0.07633165f, 0.05140508f, 
    0.06771148f, -0.05395103f, 0.04674060f, -0.03153724f, -0.07018930f, 0.06793021f, 0.13970500f, -0.12444690f, 
    -0.10555039f, 0.04552179f, 0.02640347f, 0.11772934f, -0.20437978f, 0.22137214f, 0.00534298f, 0.02520567f, 
    0.07102104f, 0.03768494f, 0.00034019f, 0.12194668f, -0.00489194f, -0.04641834f, 0.14691606f, 0.10251400f, 
    -0.06845229f, -0.04928950f, 0.08122254f, -0.14280869f, 0.07133695f, -0.26590338f, -0.10620230f, -0.05755840f, 
    -0.02753563f, 0.10126229f, -0.50078684f, -0.21915434f, -0.29653403f, 0.05293437f, -0.00764020f, 0.04635965f, 
    -0.07689431f, 0.04521184f, -0.17699608f, -0.07817239f, 0.04183413f, -0.00254033f, 0.03888164f, 0.23174009f, 
    0.02676578f, 0.46140084f, 0.20871074f, -0.90461439f, 0.10737403f, 0.09136332f, 0.30548736f, -0.19818784f, 
    -0.16328903f, -0.09772334f, -0.09621502f, -0.06852031f, -0.46447015f, -0.03071902f, -0.09366973f, -0.14270633f, 
    -0.03393121f, 0.26357290f, 0.01801346f, -0.07971273f, -0.06869987f, -0.01610504f, -0.09706882f, 0.01279765f, 
    -0.08236443f, -0.00568520f, -0.01877060f, -0.13219133f, -0.29909682f, -0.11555125f, -0.15886371f, -0.02014787f, 
    -0.12620804f, 0.21708868f, 0.04926981f, 0.14971325f, -0.04163280f, -0.16719295f, 0.10432900f, 0.09860895f, 
    0.09275492f, 0.15295804f, 0.17489068f, 0.07180452f, -0.01471571f, -0.03240705f, 0.24345191f, 0.10418236f, 
    -0.30867782f, -0.07457987f, -0.06225652f, -0.09092680f, -0.04133289f, 0.03746452f, 0.10587425f, -0.27134746f, 
    -0.40633526f, -0.10265532f, -0.11710085f, -0.05411608f, -0.02332152f, 0.01383207f, 0.06179569f, 0.14590243f, 
    0.40939653f, 0.17162929f, -0.50825858f, -0.00544631f, 0.04162507f, 0.09919177f, -0.01819195f, -0.00587744f, 
    0.10514829f, 0.25905311f, 0.34165311f, -0.20197321f, 0.01674633f, 0.09162103f, -0.05578401f, -0.24523169f, 
    0.00492163f, 0.07758345f, -0.27853075f, -0.35661119f, -0.01444863f, -0.15263103f, -0.00294992f, -0.02359379f, 
    0.13718884f, 0.06305265f, 0.03060094f, 0.32536623f, 0.24343927f, -0.35161018f, -0.00760741f, 0.01702819f, 
    0.00256501f, 0.12395068f, 0.13050866f, 0.07641784f, 0.18345751f, -0.07716125f, -0.01421704f, 0.02642129f, 
    0.04240479f, -0.08844885f, 0.01199715f, 0.01064767f, -0.02348733f, 0.07273591f, 0.12416063f, 0.02805469f, 
    0.01614451f, 0.12494469f, -0.17469846f, 0.07600722f, -0.07704181f, -0.26712665f, -0.03429044f, 0.12058819f, 
    -0.05908803f, 0.13611163f, 0.03739427f, -0.03081043f, 0.11744680f, -0.00404441f, -0.01538622f, -0.01474361f, 
    0.07893597f, -0.20389397f, -0.05841698f, -0.02856283f, -0.03984963f, 0.04678718f, 0.03073721f, 0.03125134f, 
    0.10983097f, 0.03337756f, -0.00741322f, 0.06911134f, 0.04876330f, 0.05344546f, -0.03998184f, -0.06328675f, 
    0.09984437f, 0.15730046f, 0.07583018f, 0.10035614f, 0.03528956f, 0.10874894f, 0.07470361f, 0.22626451f, 
    0.08666692f, 0.27647454f, 0.42956451f, 0.00902452f, 0.20178166f, 0.11350435f, -0.02201184f, -0.06910189f, 
    -0.00639691f, -0.10807662f, 0.19248438f, -0.19864136f, -0.11523312f, 0.08347397f, 0.20426454f, 0.06036209f, 
    -0.10527270f, -0.04782289f, 0.20560908f, 0.33974975f, -0.34965447f, -0.68138766f, -0.79610622f, 0.10460809f, 
    0.13828789f, 0.05110058f, 0.07037286f, -0.00600575f, 0.02840723f, -0.12169956f, -0.06630770f, 0.06072583f, 
    -0.19513340f, 0.09467874f, 0.04831650f, 0.15057305f, -0.00478354f, -0.23556779f, 0.19111672f, -0.03423132f, 
    -0.18134895f, 0.03941167f, 0.04939713f, -0.09825324f, 0.06211141f, -0.12461102f, 0.13824980f, -0.03238887f, 
    0.50920206f, 0.28557569f, -0.07882250f, -0.05037230f, 0.14529586f, -0.01897713f, 0.05245357f, -0.13479201f, 
    -0.07510871f, -0.01140891f, 0.04614581f, -0.02800834f, 0.20887025f, 0.10833607f, 0.02180628f, -0.17541656f, 
    -0.02943338f, -0.09407700f, 0.02106130f, -0.65609014f, 0.06576923f, 0.10520200f, -0.10151193f, 0.05812772f, 
    0.03120350f, -0.07954103f, -0.30386695f, -0.27009213f, -0.14457162f, 0.03177658f, 0.03620586f, 0.01018533f, 
    0.06123737f, 0.01763048f, 0.09866659f, -0.26591092f, 0.00275171f, 0.21690847f, 0.05347666f, -0.22107686f, 
    -0.03435669f, 0.03302727f, -0.16409558f, 0.00073819f, -0.05505449f, 0.09432337f, 0.25631922f, 0.03901306f, 
    -0.08071667f, 0.04614333f, 0.42330626f, 0.21781287f, 0.36246705f, 0.01763627f, -0.09622616f, 0.11601383f, 
    0.24601366f, -0.12501904f, 0.01377437f, -0.12144981f, -0.16601095f, 0.20249939f, 0.12196752f, -0.11473491f, 
    0.17308800f, 0.12509738f, 0.06856316f, -0.18437926f, 0.05990727f, -0.04164473f, -0.22909079f, 0.03830285f, 
    0.04088924f, -0.00887404f, 0.01750474f, 0.06273898f, -0.05262337f, -0.09593982f, 0.00773926f, 0.19716558f, 
    -0.01543434f, -0.07393847f, -0.02319434f, 0.15065603f, 0.00600255f, -0.02025281f, -0.07063051f, -0.00144773f, 
    0.26908422f, -0.07365935f, -0.00817654f, -0.17399037f, -0.02815511f, 0.14799172f, -0.02784407f, -0.04464215f, 
    -0.19607550f, -0.14894271f, -0.10065188f, -0.16733654f, -0.09509894f, 0.06486291f, -0.02005342f, 0.04938847f, 
    -0.01218243f, 0.04665953f, 0.00694561f, -0.01033464f, 0.03179647f, 0.11538834f, -0.09266764f, -0.03014679f, 
    -0.04142592f, -0.05706066f, -0.19726788f, 0.13636599f, 0.10128991f, 0.05658889f, -0.23913383f, 0.11703627f, 
    0.01178001f, 0.00108319f, 0.10920439f, 0.25587812f, 0.14412431f, -0.06948964f, 0.07264744f, -0.09878339f, 
    -0.02771791f, -0.12874341f, 0.17099269f, 0.19251812f, 0.00013856f, 0.18259732f, -0.05206192f, -0.21293597f, 
    -0.53143281f, 0.21975252f, 0.01952832f, 0.04722066f, 0.03767627f, 0.11550165f, -0.00055896f, 0.23620622f, 
    -0.19234468f, -0.05798756f, 0.12092245f, 0.07267909f, 0.20578013f, 0.14880373f, 0.12501912f, 0.16706003f, 
    0.17451265f, -0.05685658f, -0.17655200f, -0.05858622f, 0.05221256f, -0.08066069f, 0.02154251f, 0.00172659f, 
    -0.01646433f, -0.03814466f, -0.13401850f, -0.16396885f, -0.07042799f, 0.01153726f, -0.18428771f, -0.24673443f, 
    0.05208096f, 0.16598138f, -0.01826224f, -0.47278059f, -0.01347749f, -0.07327165f, -0.00828163f, 0.18126014f, 
    0.07941126f, 0.11339335f, 0.02123849f, -0.26862720f, 0.44416425f, 0.09778231f, -0.00357747f, -0.16034639f, 
    -0.01609115f, 0.05494702f, 0.19640608f, -0.23954192f, -0.04829513f, -0.00958411f, -0.05764864f, -0.12255418f, 
    0.15322515f, 0.20636247f, 0.12046126f, -0.05012495f, -0.06147335f, -0.07450245f, -0.00051432f, -0.07746303f, 
    0.00450115f, 0.05506644f, -0.02474920f, 0.19635503f, -0.10448287f, -0.17617203f, -0.16333589f, 0.05608784f, 
    -0.09189236f, -0.04032930f, -0.13263735f, 0.03004103f, 0.07439644f, -0.01408247f, 0.05291654f, -0.19456691f, 
    -0.02365827f, 0.04255481f, 0.15441164f, 0.02598452f, 0.05421433f, 0.01701212f, 0.02272528f, 0.14688073f, 
    0.05829507f, -0.09484848f, -0.07421556f, 0.02980425f, 0.04343077f, 0.04949217f, 0.08168373f, -0.23583435f, 
    0.31684616f, -0.17259215f, 0.12288532f, 0.61400676f, 0.15557003f, 0.19294430f, -0.02087176f, 0.05612285f, 
    -0.02635927f, 0.20074309f, 0.15444636f, -0.15103443f, -0.10596696f, -0.09967295f, -0.08634870f, 0.12600964f, 
    -0.04809893f, -0.00530896f, -0.05716654f, -0.00582420f, 0.43463531f, 0.14345840f, -0.02793247f, -0.11732925f, 
    0.18456624f, 0.10472547f, 0.22527350f, 0.17746867f, -0.23215617f, 0.37069538f, 0.24407588f, -0.01186495f, 
    0.09015565f, 0.19022563f, -0.13613591f, 0.00950135f, -0.05702019f, -0.15228365f, -0.12370671f, -0.06332538f, 
    -0.08404592f, -0.10327000f, 0.01230954f, 0.05959493f, -0.10727707f, -0.12834451f, 0.16760147f, 0.00784978f, 
    -0.25494725f, -0.05078367f, -0.32663292f, -0.39312875f, 0.05374241f, 0.06047029f, -0.13400240f, -0.16145356f, 
    -0.26722407f, -0.78378361f, -0.00613927f, -0.13976961f, 0.06101798f, 0.04981628f, -0.07707483f, 0.13426596f, 
    0.25132167f, 0.08167768f, -0.00235113f, 0.16950551f, 0.09199733f, -0.09635714f, 0.07499786f, -0.12275039f, 
    -0.08649348f, -0.28754276f, -0.17527133f, -0.17422992f, -0.12883040f, 0.32308069f, 0.09812824f, 0.07029786f, 
    0.00896878f, -0.05470909f, 0.02206224f, 0.07257570f, 0.19581576f, -0.05460995f, -0.13526510f, -0.06284840f, 
    -0.10498188f, -0.05840652f, 0.02730540f, -0.11606697f, -0.46620107f, -0.31266537f, -0.07043880f, -0.07359339f, 
    -0.04554002f, 0.04047660f, -0.01830101f, 0.18246926f, 0.15062325f, 0.03788086f, -0.00746841f, 0.08157162f, 
    0.15534677f, 0.03585735f, 0.10875666f, 0.20640780f, 0.22883777f, -0.13353734f, 0.20002243f, -0.26615649f, 
    -0.00148848f, -0.05702890f, 0.23123302f, 0.01637125f, 0.04551982f, 0.06395096f, -0.00773697f, 0.28781530f, 
    -0.44330812f, -0.05979922f, -0.15039206f, 0.09886719f, 0.02462744f, -0.00465718f, 0.00987793f, 0.21766493f, 
    0.25589213f, 0.11533119f, 0.20910238f, 0.08193796f, -0.10013533f, 0.10383078f, 0.00499316f, -0.01187169f, 
    -0.24621171f, 0.48093778f, -0.03839324f, 0.15422903f, -0.00817421f, 0.04968629f, 0.09738112f, 0.15254621f, 
    0.04848723f, -0.22030310f, -0.01054346f, -0.06757292f, -0.04287057f, 0.05696418f, 0.25554645f, 0.11601115f, 
    0.07962289f, -0.21197446f, -0.21482641f, 0.11779777f, 0.10486717f, -0.07356303f, -0.19703533f, -0.00954859f, 
    -0.00250290f, 0.02594052f, 0.04066161f, -0.04164789f, 0.06441014f, 0.24871758f, 0.05806085f, -0.07068555f, 
    -0.12466699f, 0.16398549f, 0.09163790f, 0.16042279f, 0.03887299f, 0.12947327f, -0.47279140f, 0.08768953f, 
    0.10532621f, -0.28563198f, 0.09116101f, 0.29350230f, -0.00819381f, 0.11620824f, -0.48031032f, -0.36298707f, 
    -0.13639110f, -0.09515709f, -0.15001649f, 0.20592608f, 0.03986758f, 0.08415211f, -0.10606171f, 0.32724065f, 
    -0.25913864f, 0.19339141f, 0.05280397f, 0.13153717f, 0.12957825f, 0.06226529f, -0.10982269f, -0.31002218f, 
    0.03466511f, 0.14959465f, -0.07642755f, 0.08770008f, 0.15233128f, 0.11584059f, 0.09950627f, 0.07075883f, 
    0.21314168f, 0.34718087f, 0.35457033f, -0.14414227f, -0.19778520f, 0.02520420f, -0.08017657f, -0.06584065f, 
    -0.04705647f, 0.07118823f, -0.34522006f, -0.15427148f, 0.04025414f, -0.04436107f, 0.06370094f, 0.05678480f, 
    -0.03652278f, -0.13263401f, -0.13534819f, 0.19616541f, 0.00546242f, -0.23630565f, -0.07352094f, 0.13612798f, 
    0.09214671f, -0.02087449f, 0.04927364f, -0.07930841f, 0.48970044f, -1.13374579f, 0.01635419f, -0.22180076f, 
    0.18856113f, 0.29369098f, 0.20912997f, -0.00774036f, 0.05952744f, -0.43457499f, -0.49691266f, -0.01669687f, 
    -0.22575037f, -0.06708008f, -0.13888791f, -0.16063227f, -0.00776260f, -0.03458920f, -0.10274428f, -0.21274018f, 
    -0.05966174f, 0.01833734f, 0.11164439f, 0.07135663f, -0.01183561f, -0.21121038f, -0.29960918f, -0.50778300f, 
    -0.30874646f, -0.02593540f, 0.04150160f, 0.04537540f, 0.11291582f, -0.01614653f, 0.12094636f, -0.14642817f, 
    0.01298456f, -0.02213348f, 0.34077290f, 0.04842724f, 0.17383423f, -0.14720315f, 0.20002595f, 0.17513371f, 
    0.05616269f, 0.01466984f, 0.07347470f, -0.12460717f, 0.04782249f, -0.17019893f, -0.10485381f, 0.00232876f, 
    -0.05459867f, 0.03722420f, -0.12127392f, -0.15345393f, 0.01918251f, 0.09700235f, 0.06662910f, 0.24922225f, 
    -0.05665572f, 0.08676863f, -0.39360183f, -0.45711684f, 0.04337491f, -0.07478385f, -0.12064247f, -0.09404331f, 
    -0.05358620f, -0.17883584f, 0.00327874f, -0.02954494f, 0.09761564f, 0.02370974f, 0.15590835f, -0.00608767f, 
    -0.16693690f, 0.09221985f, 0.06185152f, 0.10780210f, -0.42733413f, -0.22133562f, 0.07053573f, -0.06022346f, 
    -0.00209131f, 0.03527744f, -0.02345251f, -0.01219865f, 0.04151877f, -0.19426033f, 0.06876338f, 0.15298598f, 
    0.08405438f, 0.14516120f, -0.03123158f, -0.14712474f, -0.14735262f, -0.01559940f, -0.42837003f, 0.03828396f, 
    0.00737596f, -0.07047594f, -0.15971833f, -0.04901252f, 0.02518594f, 0.08996772f, 0.02306009f, -0.01787572f, 
    0.49707940f, 0.20135404f, -0.18870850f, -0.07556970f, 0.00161500f, 0.00203456f, 0.04793945f, 0.02254078f, 
    -0.02675259f, -0.05716217f, 0.02315472f, -0.25960439f, -0.06572288f, -0.20461507f, 0.00137985f, -0.01034755f, 
    0.05976665f, -0.20784985f, 0.46534190f, -0.12729928f, -0.00648103f, 0.13449883f, 0.07532041f, 0.08696637f, 
    0.06162328f, 0.11483864f, -0.81976503f, -0.32321298f, -0.50577229f, 0.04329096f, 0.01020881f, -0.11766329f, 
    0.01672192f, -0.00020988f, 0.00023422f, -0.14645007f, -0.06737239f, 0.23695479f, -0.14449836f, -0.06365476f, 
    0.07569283f, 0.06326643f, -0.09216664f, 0.09212461f, -0.13907441f, -0.03829209f, 0.04278561f, 0.28008470f, 
    -0.20996417f, 0.09816461f, 0.00976365f, -0.01951175f, 0.13878015f, -0.05039375f, -0.31932825f, 0.34880361f, 
    0.07936588f, -0.08445378f, 0.06003620f, -0.26392344f, -0.01495095f, -0.06534892f, -0.26027018f, -0.01081473f, 
    0.45275250f, 0.06666509f, -0.05828294f, 0.00365144f, -0.17177723f, 0.05380586f, 0.06021075f, 0.11151127f, 
    -0.01301401f, 0.10501913f, -0.01756865f, -0.01968705f, -0.19171557f, -0.00865847f, -0.07974570f, 0.06273199f, 
    0.02194499f, 0.23300527f, 0.18317817f, 0.12258516f, 0.08716508f, 0.11377098f, 0.08892120f, 0.27244169f, 
    0.06902031f, -0.30694440f, 0.08305430f, 0.06145795f, -0.00749222f, 0.14422250f, -0.11315811f, 0.03247780f, 
    0.02714943f, -0.11768078f, -0.13058750f, 0.26201800f, 0.07937643f, 0.10410749f, 0.04939546f, 0.01039955f, 
    0.20772162f, 0.32725027f, 0.14095622f, 0.09850253f, 0.17405075f, 0.28370258f, 0.01737455f, -0.10086767f, 
    -0.02818150f, -0.13946745f, -0.17727876f, -0.05744706f, 0.22554892f, 0.42717096f, 0.27806336f, 0.00195078f, 
    0.27080357f, -0.00169158f, -0.02161548f, 0.01089338f, 0.04727101f, 0.12070035f, 0.12053534f, -0.22054179f, 
    0.08198625f, 0.06464117f, -0.06766974f, 0.02430824f, 0.05390698f, 0.01831438f, 0.11144888f, 0.01956752f, 
    0.15885881f, 0.03701447f, 0.00414888f, 0.00650958f, -0.02192394f, 0.00072233f, 0.13928756f, 0.12092750f, 
    0.11195762f, 0.13163957f, 0.10452455f, 0.14589317f, 0.12527472f, -0.02578158f, -0.11995834f, 0.05654990f, 
    -0.64324403f, -0.25376403f, -0.29603523f, 0.04933076f, -0.03984815f, -0.06166359f, 0.04098232f, 0.11333568f, 
    -0.10822006f, -0.69802159f, -0.30307910f, -0.57890385f, -0.03850876f, -0.02693105f, -0.00202701f, -0.08388302f, 
    0.07493638f, 0.07511950f, 0.49101222f, -0.21141990f, 0.24720944f, -0.00960714f, -0.03835843f, -0.02340665f, 
    -0.14682433f, 0.09886093f, -0.21538641f, -0.34595239f, 0.26043776f, 0.54924220f, -0.01932870f, -0.12220506f, 
    -0.00858294f, -0.00785022f, -0.09023905f, 0.03371872f, -0.61123514f, -0.25153378f, 0.24946907f, -0.19649038f, 
    -0.01334333f, -0.09207459f, -0.00101090f, 0.05553659f, 0.06601109f, -0.25459602f, -0.02884875f, -0.01842920f, 
    0.02814693f, 0.03075915f, -0.11963981f, -0.07963866f, -0.01691262f, 0.08112627f, -0.12431655f, 0.31393939f, 
    -0.15329993f, -0.02873722f, 0.14449604f, 0.03386407f, 0.05336848f, -0.04614741f, -0.13016257f, -0.21487817f, 
    -0.01822049f, -0.01957021f, -0.07489642f, -0.00093116f, -0.09196515f, -0.11011478f, -0.10663632f, -0.11355554f, 
    0.01531574f, 0.02036020f, -0.08360919f, 0.08473097f, 0.06699030f, 0.13315582f, -0.29814115f, -0.10581315f, 
    -0.39191771f, 0.11044206f, -0.16618550f, -0.10909308f, -0.04529437f, -0.04901112f, -0.01181526f, -0.09906048f, 
    -0.18331391f, 0.13992487f, 0.21223606f, -0.26269707f, 0.33686790f, 0.30074286f, -0.07027067f, 0.15780254f, 
    -0.07449054f, -0.18432325f, 0.00422404f, -0.22822043f, -0.42360222f, -0.13480526f, 0.01943444f, -0.02655812f, 
    0.16364118f, 0.09311245f, -0.04933425f, -0.17455404f, 0.19287670f, 0.11353736f, 0.37801838f, 0.11104093f, 
    -0.04232143f, 0.13454521f, 0.13496734f, -0.14458893f, 0.03686390f, -0.11582796f, -0.12290527f, -0.33049300f, 
    0.11053970f, -0.07928106f, -0.03020743f, -0.09002347f, 0.17130010f, -0.13875075f, 0.05160506f, -0.32854274f, 
    -0.10381317f, -0.00460926f, 0.22691248f, 0.22161746f, -0.10785798f, 0.05784628f, 0.06947790f, -0.20703599f, 
    0.05042354f, -0.05280893f, 0.33008212f, -0.13717093f, -0.09463847f, 0.16689767f, 0.01291743f, -0.15546298f, 
    0.10770687f, -0.07002241f, -0.23405746f, 0.17328766f, 0.01702559f, 0.09010957f, -0.27894676f, -0.16263057f, 
    0.05877943f, -0.14007835f, 0.21697775f, 0.13412155f, 0.10059496f, 0.07035235f, -0.14136010f, 0.01990225f, 
    0.05465935f, -0.07712059f, 0.31257328f, 0.04657034f, -0.05343458f, 0.14179812f, 0.02854323f, -0.06646106f, 
    0.00132793f, 0.00076150f, -0.20074376f, -0.04377669f, 0.00524896f, -0.26100954f, 0.02949667f, -0.01082130f, 
    0.20495607f, 0.17977427f, -0.23926643f, 0.06795534f, -0.15112802f, 0.03067669f, -0.49947634f, 0.17618246f, 
    -0.27492076f, -0.13027744f, 0.05764428f, -0.25571129f, 0.20727356f, -0.06127130f, -0.51858187f, 0.12105855f, 
    0.29942071f, -0.13300671f, 0.11015060f, -0.03910948f, -0.13218665f, 0.17684381f, -0.32644850f, -0.12125042f, 
    0.11470094f, 0.03414379f, 0.00199832f, -0.11256695f, -0.01837551f, 0.12078447f, 0.03840616f, 0.02373240f, 
    0.01019634f, -0.14388508f, 0.15736480f, 0.02131601f, 0.13297260f, -0.15362570f, -0.19936232f, -0.06708468f, 
    -0.13680570f, 0.19573700f, -0.18007009f, 0.05595509f, 0.10772102f, -0.03747907f, -0.04994847f, -0.00357497f, 
    0.10946422f, 0.12055993f, -0.07351859f, 0.40517625f, 0.21660018f, -0.07616561f, -0.17910109f, 0.00491801f, 
    0.15013707f, 0.02391389f, 0.28650120f, 0.20540033f, 0.13592957f, -0.14243025f, 0.06233760f, -0.00213047f, 
    -0.03416976f, 0.18353817f, 0.13329898f, 0.33023861f, 0.20059241f, -0.15054412f, 0.25277635f, 0.10757978f, 
    0.02801372f, 0.01049883f, -0.01169627f, 0.17040509f, 0.01289961f, -0.17425726f, -0.14671941f, 0.16655774f, 
    0.09106050f, 0.19518794f, 0.13026871f, -0.05647639f, 0.08349188f, 0.24785598f, 0.12151501f, -0.10143468f, 
    0.17523357f, -0.02733765f, -0.06751535f, 0.09682442f, 0.05618333f, -0.32788709f, 0.09887379f, 0.09870904f, 
    0.10275072f, 0.13002086f, 0.05106371f, -0.19375625f, -0.07480624f, -0.08563096f, -0.00673919f, 0.14708778f, 
    0.04705338f, -0.12424280f, 0.00561750f, -0.09504715f, 0.10669775f, 0.06921880f, 0.03442028f, -0.11067044f, 
    0.55914026f, 0.18723316f, 0.32204300f, 0.22896658f, 0.24054630f, 0.12013184f, 0.08793317f, -0.05108959f, 
    -0.14596553f, 0.19874240f, 0.12332663f, 0.44772419f, 0.10239875f, 0.15942432f, 0.10199735f, -0.14193241f, 
    -0.03911225f, 0.02752711f, 0.41383299f, -0.07438111f, -0.19200373f, -0.04352768f, 0.00746057f, 0.09507590f, 
    -0.08495577f, -0.02765767f, -0.07974643f, -0.27393407f, 0.09620567f, 0.04714454f, 0.21070790f, -0.14208804f, 
    0.13285160f, 0.06484824f, 0.13780360f, -0.13331577f, -0.51682132f, -0.31647059f, -0.44603375f, -0.03048642f, 
    -0.06191484f, 0.01140123f, 0.02176813f, 0.23649263f, 0.12042467f, -0.21115237f, -0.20245324f, -0.11629993f, 
    -0.08642691f, 0.05511421f, 0.14936523f, -0.17107365f, 0.05607885f, 0.09453533f, 0.17907695f, 0.06908461f, 
    0.04509993f, 0.20405026f, 0.07395110f, -0.15568878f, -0.26867315f, -0.15507883f, -0.11332783f, 0.10095446f, 
    0.00044338f, 0.02668734f, -0.02611790f, 0.17156230f, 0.08973923f, -0.24914715f, -0.30880204f, -0.43640834f, 
    0.05856116f, 0.07010571f, 0.11044347f, 0.08494344f, 0.06816677f, 0.18723267f, -0.15615720f, -0.12512290f, 
    0.03676346f, 0.11298779f, -0.02638818f, -0.01731621f, 0.00210021f, -0.05995334f, 0.22111511f, -0.03142701f, 
    0.12479954f, 0.24945186f, -0.35512811f, -0.04427088f, 0.12049511f, 0.08612363f, -0.08717929f, -0.08679311f, 
    0.10089797f, -0.14377888f, -0.11963984f, 0.01758249f, -0.04276434f, 0.16286108f, 0.06411540f, 0.06085071f, 
    -0.03958405f, 0.21060568f, 0.22697991f, 0.07350414f, 0.01969315f, -0.48382810f, -0.40054765f, 0.10053732f, 
    0.09846593f, 0.03427453f, -0.09311815f, 0.01693833f, -0.06487726f, -0.09834602f, -0.06994729f, 0.14491233f, 
    0.10986079f, 0.19814765f, -0.07054141f, 0.10344972f, -0.04650781f, -0.28977156f, -0.20194969f, -0.00437405f, 
    -0.00470417f, -0.09146915f, 0.00172603f, -0.14754339f, -0.03087342f, 0.07776385f, 0.06407406f, -0.11159363f, 
    0.18708798f, 0.05140453f, -0.14938065f, 0.09365032f, -0.06286082f, 0.00850624f, 0.03608870f, -0.04785038f, 
    0.00036771f, -0.00125516f, 0.04276556f, -0.11379730f, -0.05554466f, 0.00418246f, -0.12843105f, 0.03261175f, 
    0.09338316f, 0.06832530f, 0.15054774f, -0.12129374f, 0.07140034f, 0.12321770f, -0.19051901f, 0.11511668f, 
    0.06461246f, -0.01605552f, 0.08227652f, -0.01697736f, -0.24961434f, 0.09281914f, 0.11379684f, 0.06803374f, 
    0.01841325f, 0.18260954f, 0.12944266f, -0.13725489f, -0.00026534f, -0.00832081f, -0.11131606f, -0.02400300f, 
    0.07918827f, -0.04549649f, -0.02273939f, 0.11876173f, -0.02589892f, 0.05888911f, -0.03523012f, 0.15289892f, 
    -0.26570433f, 0.05264638f, -0.01468048f, 0.02641759f, 0.47815359f, -0.17957374f, -0.03516520f, 0.14702867f, 
    0.16882053f, -0.09962423f, 0.18232822f, -0.12223893f, -0.13699554f, 0.00351068f, 0.02031574f, 0.05932023f, 
    0.32125029f, 0.17550273f, -0.00345954f, -0.22084484f, -0.05119608f, -0.22335890f, -0.06058111f, -0.01794787f, 
    0.11719678f, -0.01895587f, -0.08811311f, 0.02256018f, -0.07535337f, -0.12012057f, 0.16257651f, 0.06485611f, 
    0.00552748f, 0.20416924f, -0.13953547f, 0.04101940f, -0.02447154f, 0.01405064f, 0.22365369f, -0.05696993f, 
    0.04129371f, -0.29129320f, -0.15057142f, 0.25829789f, 0.12440921f, 0.01067245f, 0.07643520f, -0.02804725f, 
    -0.09244034f, -0.30000204f, 0.11625221f, 0.14597462f, 0.03712070f, 0.06775558f, 0.10058690f, 0.04713019f, 
    0.14901388f, 0.20750318f, -0.05144479f, -0.02029790f, 0.18781392f, 0.03196616f, -0.02396894f, -0.02062402f, 
    -0.03286073f, -0.08492018f, -0.00290330f, 0.03854422f, -0.02199529f, 0.36570922f, 0.15716811f, -0.22112198f, 
    0.02147084f, 0.22658056f, -0.10064661f, 0.01583323f, 0.22274008f, 0.11705045f, 0.16847098f, 0.12631141f, 
    0.25706953f, 0.31299031f, -0.00071013f, 0.04106530f, 0.10833050f, -0.04944523f, 0.18374559f, 0.08144985f, 
    -0.10805314f, 0.01540739f, 0.02196519f, -0.02346557f, 0.19341433f, 0.05184158f, 0.03743825f, -0.02317264f, 
    -0.18609421f, 0.30278730f, -0.04735010f, -0.00508915f, 0.18993829f, -0.03548249f, 0.01774139f, 0.26773661f, 
    -0.07771985f, -0.07325628f, -0.23038663f, 0.09560647f, 0.07077902f, 0.01345391f, 0.07438688f, 0.18685924f, 
    -0.22649160f, -0.26903453f, -0.12437167f, -0.18743661f, -0.01939879f, 0.08765570f, -0.26643333f, -0.04601646f, 
    0.01226306f, -0.10676527f, 0.08040179f, -0.04566755f, -0.07760478f, -0.04643939f, 0.08946896f, 0.07326627f, 
    0.02854922f, 0.03784005f, 0.06374628f, -0.04150587f, 0.36224917f, 0.10924611f, -0.03608282f, -0.04469996f, 
    -0.04697339f, -0.08492972f, -0.08533381f, 0.06465684f, -0.18536718f, -0.00976854f, -0.16856927f, -0.08549810f, 
    -0.00692780f, -0.29518661f, -0.05051336f, -0.03873878f, -0.02539488f, -0.08070081f, 0.00816894f, -0.08512092f, 
    -0.03640367f, 0.09725023f, -0.09166076f, -0.01891499f, -0.16096835f, -0.16374990f, 0.09572993f, 0.03218481f, 
    0.01654956f, -0.07982107f, -0.07035540f, 0.03173552f, 0.21256873f, 0.05316579f, -0.13187562f, -0.14793512f, 
    0.08190150f, 0.01573406f, -0.16376553f, 0.00425370f, 0.11757747f, -0.05643976f, 0.08160982f, 0.15420680f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.08366396f, 0.10183746f, -0.00920061f, 0.07198824f, -0.07148426f, -0.02406680f, 0.02897529f, 0.38070190f, 
    0.25916517f, -0.30194831f, 0.19382012f, -0.04743005f, 0.00364510f, -0.06981857f, -0.03579921f, 0.20115700f, 
    0.03491900f, 0.09289588f, 0.02342713f, 0.34880641f, 0.31757227f, 0.19325455f, 0.02075103f, 0.20125103f, 
    -0.04693930f, -0.15586330f, -0.18112996f, 0.29325017f, 0.26884252f, 0.15161568f, -0.06294639f, 0.17326713f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.33147430f, -0.26554039f, -0.12854743f, -0.25278223f, 0.03665625f, -0.17406949f, -0.11277413f, -0.80127972f, 
    -0.10995618f, 0.47932997f, -0.25149274f, 0.16756788f, 0.38766474f, 0.22986166f, 0.04812054f, -0.35466078f, 
    -0.15455645f, -0.09157869f, 0.14700463f, -0.12184951f, -0.06628241f, -0.38926819f, 0.17306428f, -0.04617791f, 
    -0.03436612f, 0.11099570f, 0.72851956f, -0.12160480f, -0.58396769f, 0.12680165f, 0.14451894f, -0.10499371f, 
    -0.38322592f, -0.51119334f, 0.37543839f, 0.17602175f, -0.31300235f, 0.11865260f, -0.11198703f, 0.01662442f, 
    0.14489262f, -0.07952052f, 0.36027297f, 0.17015743f, 0.41504961f, 0.27897540f, 0.03400500f, -0.29477274f, 
    -0.04002975f, -0.18457408f, -0.40191898f, 0.16056073f, 0.39357764f, -0.17668383f, 0.02744273f, 0.06299157f, 
    0.15770620f, -0.10114709f, 0.10152572f, 0.32297254f, 0.27416879f, 0.16307709f, -0.21269388f, 0.27052826f, 
    -0.13823174f, 0.40924484f, -0.03482421f, -0.80660325f, -0.81537455f, 0.08488189f, 0.11869269f, -0.15836158f, 
    -0.81997579f, -0.52666992f, 0.60873783f, 0.06868270f, -0.42802617f, 0.04666925f, -0.15726943f, -0.26924837f, 
    0.11671340f, 0.03383782f, -0.03265758f, 0.12087247f, -0.18141121f, 0.70018315f, -0.24635740f, 0.00258362f, 
    -0.02050842f, -0.17174995f, -0.24962686f, -0.04349752f, -0.21576828f, 0.30890098f, 0.05403903f, 0.23029663f, 
    -0.55722588f, 0.07806137f, 0.12603666f, -0.45595139f, -0.17825809f, 0.09742201f, 0.07269419f, -0.59103864f, 
    -0.34151098f, 0.13167985f, 0.44395238f, -0.10373069f, -0.81654698f, -0.01428901f, -0.05370053f, 0.08209243f, 
    0.50154424f, 0.28273544f, 0.19968247f, -0.79577744f, 0.16067176f, -0.42206302f, 0.02976528f, -0.56350327f, 
    -0.16979164f, 0.13398160f, -0.15698895f, 0.27521005f, 0.18254271f, -1.25965965f, 0.11784136f, -0.47380218f, 
    0.04107048f, -0.38935474f, 0.47147989f, 0.31108329f, 0.54462337f, -0.08862304f, 0.01268279f, 0.06129968f, 
    -0.52058357f, -0.05102786f, -0.38534760f, 0.00343681f, 0.28175160f, 0.09835595f, -0.08831038f, -0.43193528f, 
    0.15469091f, 0.03614930f, 0.28956640f, 0.13399304f, -0.34720534f, -0.82738572f, -0.10102381f, 0.27993554f, 
    -0.07291749f, 0.02842624f, -0.52796382f, -0.25716722f, -0.07105698f, -0.00592656f, 0.12788481f, -0.30836016f, 
    -0.03468298f, -0.16734660f, -0.39997071f, -0.35451645f, 0.26940039f, -0.12359430f, 0.13427025f, 0.19738850f, 
    -0.41194376f, 0.21864218f, 0.11303832f, 0.09458621f, 0.35802194f, -0.13424662f, 0.04370826f, 0.38057181f, 
    0.21325581f, -0.19396587f, -0.41035029f, -0.16499417f, 0.13977940f, -0.09375040f, -0.23411365f, 0.19252011f, 
    0.11605984f, 0.43056726f, -0.18141317f, -0.07463736f, 0.24300070f, -0.24075109f, 0.45040092f, -0.00124618f, 
    0.37034369f, 0.43514255f, -0.36775997f, -0.27108479f, -0.08764248f, 0.14312325f, -0.05603205f, 0.02939062f, 
    -0.37657568f, -0.67354023f, -0.57605523f, 0.00641307f, -0.54548067f, -0.60762030f, 0.00024120f, -0.16522747f, 
    -0.23132838f, 0.19688438f, -0.38205487f, 0.61504936f, -0.52924824f, 0.08268892f, 0.37415722f, -0.24909425f, 
    -0.10151564f, -0.27094230f, -0.07673603f, 0.48231676f, -0.29188368f, 0.24862304f, -0.12012579f, -0.03443568f, 
    -0.20530374f, 0.12282168f, 0.32985541f, 0.41292885f, -0.17984806f, -0.16149336f, 0.12705627f, -0.06080756f, 
    -0.09044729f, 0.11819147f, -0.38547292f, -0.06574801f, 0.23504953f, 0.24481757f, 0.02301437f, 0.26853076f, 
    -0.20854603f, -0.23788230f, -0.02631703f, -0.05059011f, -0.29513204f, -0.39535075f, 0.59959930f, -0.13980560f, 
    -0.12277246f, -0.04538830f, -0.15481141f, -0.16720986f, 0.51218987f, -0.10019418f, 0.05586559f, -0.08450796f, 
    -0.08767285f, 0.02930354f, 0.27980766f, -0.64688694f, -0.76093721f, 0.04808568f, -0.11077934f, -0.01462998f, 
    0.82806909f, -0.00438096f, -0.38730171f, -0.01505007f, -0.76955020f, 0.30566677f, 0.11778062f, 0.50165039f, 
    -0.10096564f, -0.23958494f, -0.36622235f, -0.24561237f, 0.36301452f, 0.16913323f, -0.06704748f, 0.32626671f, 
    0.15652464f, 0.34743494f, 0.21726656f, 0.12386615f, 0.12829421f, -0.13363910f, -0.62451959f, -0.11728481f, 
    0.00822086f, 0.26825136f, -0.09679498f, -0.03655104f, -0.50540906f, 0.04989810f, 0.07858261f, 0.41831639f, 
    -0.58851612f, -0.20022987f, -0.41080481f, 0.12704501f, 0.07973666f, -0.32219842f, -0.13157336f, 0.33713973f, 
    -0.14757785f, 0.30201355f, 0.45241976f, 0.16970177f, 0.14588520f, -0.72467744f, -0.62555033f, 0.37882963f, 
    0.16474234f, -0.62647724f, -0.28997841f, -0.07421199f, 0.00072721f, -0.51962435f, 0.25829446f, -0.10971057f, 
    0.30292580f, 0.11258213f, -0.41067186f, -0.31048727f, 0.80119711f, -0.00965775f, 0.10082611f, -0.26774019f, 
    -0.00233590f, 0.04044548f, 0.26023206f, 0.12562281f, -0.29326570f, 0.17812498f, 0.16086596f, -0.06736508f, 
    -0.15884963f, -0.27215055f, 0.03674534f, 0.06756791f, -0.12478156f, 0.91430259f, 0.10787807f, 0.03469005f, 
    0.15483151f, 0.28537887f, -0.04363981f, -0.26788530f, -0.25918821f, -0.51054054f, -0.73026693f, 0.12737893f, 
    0.11628406f, 0.24457587f, -0.35792598f, 0.67236996f, -0.42311525f, 0.15875848f, 0.09730817f, -0.23217952f, 
    0.63692188f, 0.03512061f, -0.64461941f, 0.13389191f, -0.27773258f, -0.26608738f, 0.16019198f, 0.06559955f, 
    0.43522441f, -0.02908446f, -0.22499874f, -0.33879840f, 0.01282799f, 0.28128979f, -0.85850072f, -0.43083999f, 
    0.01067873f, -0.23310840f, 0.19707136f, -0.00176224f, -0.71228141f, 0.22413082f, -0.08056016f, 0.32414043f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.33352101f, 0.23761979f, 0.13121091f, 0.17712335f, 0.03322450f, -0.19441423f, -0.11468728f, -0.40604109f, 
    0.18027978f, 0.19146277f, -0.01481471f, -0.20962112f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
