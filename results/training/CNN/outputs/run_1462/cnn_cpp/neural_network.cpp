#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.60446954f, -0.79878205f, 0.19161892f, 0.89146709f, 0.62030238f, 0.73992997f, 0.33011439f, -0.24108912f, 
    0.00537493f, 0.20169227f, -0.21628937f, -0.16848503f, -0.03849930f, 0.14191537f, -0.41275588f, 0.00882204f, 
    0.03023363f, 0.07007055f, -0.04498405f, 0.15715693f, 0.06390734f, -0.09632906f, -0.04368872f, 0.24052282f, 
    -0.06316341f, -0.05475121f, 0.80617452f, 0.70664102f, 0.53707606f, -0.13911988f, -0.81745189f, -0.58195281f, 
    -0.54426157f, -0.54331082f, -0.42075211f, -0.30266964f, 0.11121080f, -0.31432316f, 0.48495039f, -0.25102881f, 
    0.28885162f, 0.33886218f, 0.29784629f, -0.05862892f, 0.36690217f, -0.09697645f, -0.09152934f, -0.28098193f, 
    -0.16748585f, -0.26479861f, 0.50393814f, 0.36691183f, 0.40259060f, -0.30274120f, -0.44971934f, -0.36605671f, 
    -0.09823850f, 0.41544995f, -0.26935515f, -0.30995929f, -0.05168359f, -0.29471263f, 0.29299596f, 0.35025713f, 
    -0.28522190f, -0.10144450f, 0.18242542f, 0.21731852f, 0.16234773f, -0.40455621f, 0.16647567f, -0.38084623f, 
    -0.28809354f, 0.41824111f, 0.29985532f, -0.54318434f, 0.03479028f, 0.20464391f, 0.48447588f, -0.14684230f, 
    -0.96078473f, -0.82058042f, 0.42303172f, 0.86634642f, -0.10295431f, -0.06587743f, 0.17107192f, 0.18341342f, 
    -0.17299247f, -0.15966663f, -0.24891502f, -0.02580621f, 0.48633516f, -0.80951184f, -0.60401690f, -0.05410047f, 
    0.19503038f, 0.04301456f, 0.09421244f, 0.24864298f, -1.59579110f, 0.58725280f, 0.35417050f, 0.32604712f, 
    0.07707950f, -0.39791989f, -0.57997018f, -0.05999898f, 0.64952117f, 0.16599034f, 0.11837921f, -0.49625334f, 
    -0.08487477f, 0.07267317f, -0.08197912f, 0.19398646f, 0.01024994f, 0.14419055f, -0.20498502f, -0.15111481f, 
    -0.23547713f, -0.10065509f, -0.10224263f, -0.18777169f, -0.38143474f, 0.11401339f, -0.46108419f, -0.87253743f, 
    -0.98995072f, -0.71912843f, 0.24787344f, 0.28309512f, 0.40876591f, 0.39120886f, 0.30712330f, 0.21795219f, 
    -0.05682166f, -0.04357857f, -0.24018975f, 0.05753506f, 0.14609548f, 0.09705185f, -0.36924100f, -0.24113724f, 
    -0.07341023f, -0.06697372f, -0.31502831f, -0.22172116f, -0.39980301f, -0.25324500f, 0.72159225f, 0.40952498f, 
    0.07365368f, 0.00637752f, 0.06326982f, -0.84191900f, -0.23700318f, 0.70861125f, -0.01066221f, -0.70507056f, 
    -0.27183935f, 0.48293409f, 0.15533771f, 0.68265992f, -0.18545027f, -0.23956005f, 0.19804153f, -0.15668142f, 
    -0.49023744f, -0.37698123f, 0.10434289f, 0.33533710f, 0.29633617f, -0.28321353f, -0.10235984f, -0.05771020f, 
    -0.73399198f, -0.72174245f, 0.13458221f, 0.20659576f, -0.43711033f, -0.44389489f, -0.00279165f, -0.33625877f, 
    0.38606679f, 0.33389020f, 0.54981798f, 0.36259916f, -0.07819682f, -0.12433162f, 0.18064652f, -0.13030085f, 
    -0.22504359f, 0.04711188f, 0.27040055f, -0.53018063f, -0.27670416f, 0.07906816f, -0.17148143f, -0.32679009f, 
    -0.29203615f, 0.38411325f, 0.17527653f, -0.20801620f, 0.47914109f, 0.42158484f, 0.13136868f, 0.25645438f, 
    -0.10462297f, 0.05784966f, -0.40596211f, -0.47593033f, 0.08255207f, -0.05175391f, -0.01192310f, -0.12807962f, 
    -0.22325368f, -0.27840379f, 0.02651171f, 0.03374863f, -0.46108413f, -0.39722800f, -0.22390942f, -0.20929763f, 
    -0.47012606f, -1.05496156f, -0.72662050f, -0.44097218f, -0.33410659f, -0.40284234f, 0.00038222f, -0.34254044f, 
    -0.72941977f, -0.26127481f, 0.31856200f, -0.46121043f, -0.11014761f, -0.10331612f, 0.14102070f, -0.36854899f, 
    0.25231221f, 0.25214908f, 0.25646317f, 0.02369526f, -0.05813449f, 0.09262577f, 0.34989050f, 0.39519823f, 
    0.00415634f, 0.25857952f, -0.75159663f, -0.08005488f, 0.09102703f, -0.30679724f, 0.26649302f, 0.07368268f, 
    -0.27295744f, 0.16612503f, -0.08092853f, 0.30476174f, -0.36690989f, -0.43904862f, 0.83118570f, -0.47797143f, 
    0.27695379f, -0.25166076f, -0.24684465f, -0.23760299f, 0.20657155f, 0.10991879f, 0.12768862f, -0.24081556f, 
    -0.09944551f, 0.22357242f, 0.45166779f, -0.84073645f, 0.56125569f, -0.33355716f, -0.42863643f, -0.55429715f, 
    -0.84671211f, -0.62409782f, 0.41464603f, 0.22566800f, 0.02886643f, -0.24035367f, -0.13070011f, -0.01350097f, 
    0.45367733f, -0.10865106f, -0.07810874f, -0.25437793f, -0.15971005f, 0.04588689f, -0.45480582f, -0.19249295f, 
    0.11100563f, -0.41252574f, -0.53490335f, -0.68190444f, 0.54295003f, -0.80318153f, -0.16809586f, 0.43142447f, 
    0.50712359f, 0.40264979f, 0.11316373f, 0.37666279f, -0.01986045f, 0.01929752f, -0.34680709f, -0.10832998f, 
    0.38811070f, -0.38885882f, -0.36495024f, 0.20166205f, -0.09859534f, -0.15808746f, -0.07189628f, -0.42586994f, 
    -0.06126250f, 0.02976913f, -0.06333119f, -0.27711219f, -0.10304625f, -0.62619603f, 0.04617395f, -0.56891316f, 
    0.05770432f, 0.77471548f, -0.29113457f, -0.09119136f, 0.10734250f, 0.72193706f, -0.36617464f, -0.32747680f, 
    0.54507148f, -0.56934649f, 0.33863306f, -0.11984686f, 0.04788288f, 0.04532231f, -0.24693261f, -0.13703841f, 
    0.03794260f, -0.03116960f, -0.09527817f, -0.02276866f, 0.15282679f, 0.27247429f, -0.74555641f, -0.14130528f, 
    -0.00187755f, -0.29776978f, -0.08180995f, -0.42779741f, -0.66273689f, -0.68341416f, -0.44792980f, -0.54275107f, 
    0.44574219f, 0.35556999f, -0.33880112f, -0.42243478f, -0.47151834f, -0.32667151f, -0.51585406f, -0.39502436f, 
    -0.01929714f, -0.50513196f, -0.13776821f, -0.21637917f, 0.10695538f, 0.07236515f, 0.36644742f, -0.73230070f, 
    -0.32613128f, -0.64113426f, 0.42887914f, 0.62043536f, -0.60024273f, -0.49418253f, -0.12601390f, -0.05417451f, 
    -0.05285126f, 0.19908926f, 0.00413625f, 0.23176660f, 0.35619664f, 0.16170307f, 0.51555228f, -0.24055991f, 
    -0.02699563f, -0.35445124f, -0.24149057f, -0.29186210f, -0.07228820f, 0.17543769f, -0.07055309f, 0.15624851f, 
    0.07473647f, -0.16518052f, -0.18986180f, -0.34146401f, 0.43858248f, 0.02406710f, 0.36186558f, 0.11811073f, 
    0.18423297f, -0.38467917f, -0.06669845f, -0.12610556f, -0.16953065f, -0.05564465f, 0.22896089f, -0.46816689f, 
    0.20597541f, 0.20190908f, 0.25681522f, -0.32823741f, 0.11109634f, -0.16684805f, -0.49749625f, 0.16197854f, 
    0.48245692f, -0.72499120f, -1.11290133f, 0.07087398f, -0.08344737f, 0.21925314f, 0.16491623f, 0.43290114f, 
    -0.59770387f, -0.16744570f, 0.78222752f, 0.06955869f, 0.19320881f, 0.34453073f, -0.29415220f, 0.06943301f, 
    -0.29009315f, 0.11909611f, 0.08161316f, -0.30138797f, 0.05980662f, -0.14145973f, -0.31816679f, 0.13296886f, 
    0.27265337f, -0.30702028f, 0.21183079f, 0.54486734f, 0.21264619f, -0.02678601f, 0.28398871f, 0.04279270f, 
    0.01870850f, -0.12235029f, 0.20667657f, 0.25582200f, 0.37921792f, -0.29027176f, -0.01373546f, 0.45196316f, 
    -0.29925209f, 0.01617274f, -0.13256334f, -0.03461480f, -0.16834801f, 0.10148241f, -0.08823111f, 0.22131315f, 
    0.03801630f, 0.06386671f, -0.19631870f, -1.23165357f, 0.45102099f, 0.56890672f, 0.49263164f, -0.04955323f, 
    0.02426840f, -0.42061201f, -0.22721758f, 0.50483418f, -0.15956381f, -0.45936465f, 0.41393313f, -0.52213389f, 
    0.39038035f, 0.02371809f, -0.13984005f, -0.04071581f, 0.10119991f, -0.14844358f, 0.14676675f, 0.17018415f, 
    0.00132825f, 0.12124955f, 0.08435503f, -0.09834830f, -0.75905895f, -0.89829963f, -0.40120131f, -0.00248311f, 
    0.20927767f, -0.49301532f, -0.69053972f, -0.46769130f, -0.54604113f, -0.59249002f, -0.05358795f, -0.33462337f, 
    -0.34870219f, 0.41537511f, -0.40628850f, 0.18582951f, -0.10048014f, -0.10204810f, 0.60589397f, 0.39104539f, 
    0.03897401f, -0.39047298f, -0.35605329f, 0.10672367f, -0.27766660f, -0.26150793f, -0.44182938f, -0.36363763f, 
    -0.54372627f, -0.81864625f, -0.52292103f, -0.60017300f, -0.67059988f, -0.95223117f, -0.87269646f, 0.27536696f, 
    -0.23272806f, -0.02494573f, 0.20753296f, 0.64586276f, -0.15704864f, -0.27006030f, -0.39527932f, -0.63038844f, 
    -0.37687474f, -0.12918080f, -0.00463838f, 0.26052842f, 0.10509140f, -0.20740429f, -0.50540620f, 0.02146303f, 
    -0.72526336f, -0.65326607f, -0.34429547f, 0.73901320f, 0.39576823f, 0.20893976f, 0.06992481f, 0.36903244f, 
    0.13501950f, -0.00517164f, -0.15842915f, 0.06524979f, -0.13127404f, -0.57925856f, -0.52961373f, 0.10773332f, 
    -0.29108045f, -0.28210855f, 0.12749536f, 0.37138295f, -0.00358891f, 0.26818815f, 0.52631307f, 0.80216789f, 
    0.03693533f, -0.98699391f, -0.56596363f, 0.61255521f, 0.67851216f, 0.92996430f, -0.76109248f, -1.05192304f, 
    -0.88103950f, -0.46896148f, 0.03342388f, -0.17798702f, -0.01239431f, -0.41997612f, -0.26005712f, -0.24514019f, 
    0.15656962f, 0.01323589f, -0.28835768f, -0.06018737f, -0.07470908f, -0.19928890f, 0.05048639f, -0.15921091f, 
    -0.34234643f, 0.20022997f, -0.11973323f, -0.98006827f, -0.78254181f, -0.08217427f, 0.16324976f, 0.27402452f, 
    -0.03896758f, 0.29909268f, 0.40699506f, 0.42433739f, 0.44964290f, 0.27800775f, 0.32609540f, -0.12852323f, 
    -0.12033878f, -0.15111434f, -0.04480033f, -0.24826975f, 0.13705479f, -0.17508411f, 0.21926056f, 0.03949253f, 
    0.01079367f, -0.50236785f, 0.02358776f, 0.67444754f, 0.17150803f, -0.65800124f, 0.50172108f, -0.03403679f, 
    -0.13701807f, -0.03801955f, -0.53738135f, -0.17050430f, -0.53356063f, -0.32864407f, 0.58677530f, -0.13684420f, 
    -0.09508029f, 0.06657337f, -0.00249896f, -0.27726236f, -0.34665039f, 0.13253166f, -0.28730050f, 0.27357605f, 
    0.02245864f, -0.07091717f, 0.42189917f, 0.15460709f, 0.12824829f, -0.07495088f, 0.39102757f, -0.05820940f, 
    0.06347715f, 0.32306936f, -0.53952289f, -0.54084587f, -0.01634538f, -0.03199260f, -0.20616435f, 0.02036523f, 
    0.17954417f, 0.32972059f, 0.61630279f, -0.33307889f, -0.07774153f, 0.28120217f, -0.09595547f, -0.19230333f, 
    -0.01111720f, -0.19185333f, 0.20197055f, 1.14575088f, -0.89474088f, -1.39727092f, -0.90631789f, -0.34734511f, 
    -0.19817990f, -0.04045775f, 0.58216798f, 0.42841998f, -0.04770412f, 0.04626054f, -0.14025500f, 0.22468981f, 
    -0.56323993f, -0.26428577f, 0.18634339f, 0.06848524f, 0.47162235f, -0.14554760f, -0.16529086f, -0.37567547f, 
    -0.14403163f, 0.01338738f, -0.05302094f, -0.28835207f, 0.61012650f, 0.35148153f, 0.05224800f, -0.31314066f, 
    -0.70784408f, 0.17507188f, -0.09796129f, 0.41149107f, -0.49481404f, 0.18071608f, 0.18966837f, 0.05289802f, 
    -0.33366823f, -0.02378348f, 0.25922784f, -0.19949037f, 0.38544574f, -0.18994756f, -0.32587695f, 0.03314001f, 
    -0.19165513f, -0.03330699f, -0.01924778f, -0.03975662f, 0.13397695f, 0.48006064f, 0.08845130f, 0.29663351f, 
    0.18939969f, 0.09233388f, -0.19383998f, -0.20884620f, 0.20147008f, -0.59258705f, -0.58153284f, -0.19716533f, 
    -0.25205716f, 0.56176078f, -0.34269169f, -0.36514354f, 0.23313099f, -0.26812282f, -0.12388338f, -0.04067369f, 
    0.22558872f, -0.04290702f, 0.15268098f, 0.04983012f, 0.27882078f, 0.31777960f, -1.52896726f, -0.00936967f, 
    -0.28907514f, -1.45504153f, -1.23421669f, 0.87246811f, -0.01046404f, -0.40044811f, 0.58705968f, 0.87312484f, 
    -0.15557389f, -0.51771665f, -0.40479675f, -0.39955834f, -0.28920120f, 0.06973194f, 0.02313843f, -0.01790321f, 
    0.09024624f, 0.02011044f, -0.11099059f, -0.13278633f, -0.09132385f, -0.07975364f, 0.08881320f, 0.12175764f, 
    -0.10679565f, 0.29443908f, 0.48584488f, 0.10198877f, -0.22668026f, -0.12532568f, -0.04761127f, -0.03828636f, 
    0.10664809f, 0.40203407f, 0.31147778f, 0.13813782f, -0.22995259f, 0.11892160f, 0.16453007f, 0.22882485f, 
    0.15301655f, 0.17558944f, -0.30479094f, 0.27666155f, 0.25853482f, 0.15383023f, 0.16855900f, -0.22930139f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.37647733f, 0.11174046f, 0.34646735f, 0.43783674f, 0.06277945f, 0.16151077f, 0.08003259f, 0.02224349f, 
    0.05090766f, -0.41473716f, 0.26776093f, -0.08747382f, 0.49040011f, 0.29359236f, 0.30546820f, 0.61769342f, 
    0.44769591f, 0.23104005f, 0.22969781f, 0.20728299f, -0.03557517f, -0.35535458f, 0.24242491f, 0.26063585f, 
    0.21402302f, 0.34593597f, 0.29133084f, 0.11456443f, 0.33326751f, 0.07738306f, -0.23889980f, -0.16731411f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.68747622f, 0.06722207f, -0.03834504f, -0.45726004f, -0.15120642f, -0.04372701f, 0.08690639f, -0.02932780f, 
    -0.23410392f, -0.17370778f, -0.09212992f, -0.16199352f, -0.05582809f, 0.11273899f, -0.03465363f, -0.15243898f, 
    0.15546721f, 0.05632717f, -0.12027736f, -0.00436197f, 0.00088260f, -0.03972257f, 0.02618636f, 0.05130883f, 
    -0.01031207f, -0.28125277f, 0.03033104f, -0.04043522f, 0.07668240f, -0.12902762f, -0.24730019f, -0.17812204f, 
    0.00530557f, 0.01041854f, -0.04684386f, 0.04031728f, -0.47224805f, -0.02494168f, 0.44878280f, -0.29992643f, 
    -0.05773220f, -0.01409701f, -0.04735065f, 0.00356595f, -0.01152832f, -0.02638333f, -0.03128997f, -0.10589775f, 
    -0.09052383f, 0.27631539f, 0.30369627f, -0.35014939f, -0.08272534f, -0.07527876f, 0.06897835f, 0.05406583f, 
    -0.08397449f, -0.10514986f, -0.13917686f, 0.04529211f, 0.06702282f, -0.19348773f, -0.05546339f, 0.00413242f, 
    0.09518599f, 0.11439168f, -0.14394179f, -0.04748983f, -0.07456812f, 0.09439407f, 0.09290943f, 0.03922302f, 
    -0.22411650f, -0.47560787f, -0.02247571f, -0.08543289f, -0.26720825f, -0.05577923f, 0.07208475f, -0.02056597f, 
    0.07773862f, 0.05116633f, -0.12576154f, -0.12697537f, 0.32383507f, 0.24828827f, 0.02861927f, -0.07936549f, 
    -0.04598591f, -0.04141903f, 0.05613552f, -0.07402495f, -0.05731172f, 0.31195903f, -0.05238992f, 0.15105495f, 
    -0.40215051f, -0.22073965f, -0.17498896f, 0.06243933f, -0.02208579f, 0.00720584f, 0.11015058f, 0.07326937f, 
    0.11102159f, -0.08381588f, 0.16694394f, 0.18901870f, 0.50697172f, 0.29145673f, 0.05555003f, -0.38679898f, 
    0.22386079f, 0.09595520f, 0.14005022f, 0.00144637f, -0.02041432f, 0.01959517f, 0.01987587f, 0.04709125f, 
    -0.04045736f, 0.11180369f, 0.05036839f, -0.08049441f, -0.11582050f, -0.21547668f, -0.03342936f, -0.15141395f, 
    -0.08680033f, -0.15458728f, -0.05533611f, -0.08319835f, 0.10080354f, 0.03741471f, 0.10400897f, 0.04683294f, 
    -0.07273717f, -0.00702588f, -0.21940766f, -0.13453923f, -0.13253608f, -0.17534007f, -0.07290145f, 0.19424355f, 
    -0.17857319f, -0.39500540f, -0.11186286f, 0.04169519f, 0.05991007f, 0.03092591f, 0.11549749f, -0.02483210f, 
    0.05194589f, 0.05639496f, 0.06565011f, -0.00045620f, -0.20958677f, 0.02095659f, 0.03651468f, -0.26660049f, 
    -0.11169400f, 0.05947681f, 0.09035436f, -0.09718421f, -0.10220293f, -0.14958066f, -0.01810320f, -0.27955717f, 
    0.36256811f, 0.34532654f, -0.04318659f, -0.27627218f, 0.18536693f, 0.04733680f, 0.03343168f, 0.04502152f, 
    -0.04509193f, -0.12192846f, -0.05226776f, -0.21710274f, 0.24052778f, 0.24486123f, 0.10347969f, -0.34596115f, 
    -0.25716549f, 0.03624619f, 0.05451520f, -0.15241852f, -0.05561041f, -0.01109924f, -0.11203262f, -0.07849425f, 
    -0.13070244f, -0.39456844f, -0.07032400f, -0.10055476f, -0.22338086f, -0.02338563f, -0.07788497f, -0.03522065f, 
    -0.13111991f, -0.09049295f, -0.02289360f, -0.20830786f, 0.25455892f, 0.28340271f, -0.02483012f, -0.01707410f, 
    0.01478759f, 0.04699807f, 0.11585701f, -0.07323106f, 0.04775573f, -0.03034917f, -0.11471808f, -0.03836304f, 
    -0.07016177f, -0.03970946f, 0.04571959f, 0.13305645f, 0.01061148f, 0.03550516f, 0.03447532f, 0.01347500f, 
    -0.00752520f, 0.03232177f, -0.05743201f, 0.03142430f, -0.17228703f, 0.03492488f, 0.05638923f, -0.45954287f, 
    -0.03731545f, -0.16113897f, 0.01075169f, 0.15982270f, 0.02625570f, -0.02509019f, -0.09125176f, -0.03053587f, 
    0.64060211f, 0.21839002f, -0.04197660f, -0.33150309f, 0.23204552f, 0.28920519f, 0.20288733f, 0.02979947f, 
    0.00970594f, -0.03755929f, 0.02747533f, -0.07181522f, 0.55470622f, 0.17906596f, -0.28340316f, -0.31412286f, 
    0.04223448f, 0.14368029f, -0.05643924f, 0.03848465f, -0.13160653f, -0.05475806f, -0.00812609f, -0.06278826f, 
    -0.06527627f, -0.47876632f, -0.27394417f, 0.09544661f, 0.08194885f, 0.10715213f, -0.10150210f, -0.06352644f, 
    -0.05080315f, -0.16215478f, -0.40901208f, -0.24932985f, 0.24321015f, -0.28474864f, -0.69639170f, 0.11633600f, 
    -0.23481813f, -0.16808289f, -0.10424523f, -0.07386477f, -0.13195154f, -0.07395069f, -0.06964117f, 0.01788068f, 
    0.31348893f, -0.09384722f, 0.06542675f, 0.03502878f, 0.07473361f, 0.08395126f, 0.01353611f, 0.03001103f, 
    0.02167130f, -0.07936842f, -0.07870432f, -0.07733863f, 0.05144719f, -0.30064163f, -0.31262523f, -0.54318500f, 
    -0.09536386f, -0.24611740f, -0.47438931f, -0.02401199f, -0.12362947f, -0.04695738f, 0.04781922f, 0.13409133f, 
    -0.07710396f, -0.09351441f, -0.01479493f, 0.00143290f, -0.17876966f, -0.26697499f, -0.17497253f, -0.08631310f, 
    -0.10918409f, -0.00606663f, 0.04632363f, -0.03322957f, 0.17573106f, 0.05553238f, -0.33129564f, -0.08352223f, 
    0.26524451f, 0.10377522f, 0.02089098f, 0.03581684f, -0.07623836f, -0.04339570f, -0.11192267f, 0.14808004f, 
    -0.15071964f, -0.33791119f, -0.31233490f, 0.09265596f, -0.02417388f, -0.07780237f, -0.29135251f, -0.19503631f, 
    -0.17799039f, 0.06814698f, -0.14771713f, -0.47030237f, -0.09225567f, -0.11840747f, -0.14813742f, 0.01278036f, 
    0.01860938f, -0.06515175f, -0.04049714f, 0.12726991f, -0.02763634f, -0.00278009f, 0.00808422f, 0.03280701f, 
    0.15283804f, 0.28956637f, 0.10450744f, -0.12694047f, 0.08460803f, 0.37992299f, -0.01136362f, 0.29855448f, 
    0.00311916f, 0.09440593f, 0.05343796f, 0.01538008f, 0.00175998f, 0.05185995f, 0.08910510f, 0.12152462f, 
    -0.32773966f, -0.09589581f, -0.04106788f, 0.01216734f, -0.06805262f, -0.10535991f, 0.02182774f, -0.04635380f, 
    0.07658536f, -0.02993183f, 0.07100307f, 0.07098220f, -0.16343810f, -0.01224603f, 0.10666734f, 0.00849413f, 
    0.21337415f, -0.17534105f, -0.09326471f, 0.02307282f, -0.18136261f, 0.10130417f, -0.16673124f, -0.37667298f, 
    0.15428928f, -0.18904863f, -0.09282701f, -0.09494746f, -0.03534874f, 0.02178503f, -0.12065821f, 0.04027889f, 
    0.16106771f, -0.01690573f, 0.10952783f, -0.08206401f, 0.13278089f, -0.01057115f, 0.15474398f, -0.22448607f, 
    0.06280626f, -0.08241422f, 0.05600252f, 0.06220593f, -1.11907113f, 0.14845295f, 0.01294509f, -0.33373553f, 
    -0.06408887f, 0.09732895f, -0.02687456f, 0.05434545f, -0.01122326f, 0.03803308f, -0.04403131f, 0.10601934f, 
    -1.01312327f, 0.04489234f, -0.13225769f, -0.19898972f, 0.02074861f, -0.04523877f, -0.00817917f, 0.04906185f, 
    -0.02975743f, 0.13436848f, -0.39759496f, -0.27410081f, 0.14814048f, -0.11793634f, -0.04635075f, -0.08035263f, 
    0.02448603f, 0.06274392f, -0.04170294f, -0.16176704f, -0.07061707f, -0.12456473f, -0.15814710f, -0.06920131f, 
    0.15053388f, 0.32395330f, -0.10840477f, -0.17544611f, -0.17210272f, -0.03559193f, 0.03598818f, 0.02747853f, 
    -0.15037510f, -0.03412021f, -0.08787394f, 0.24592362f, -0.12673773f, 0.08908499f, -0.19632272f, 0.13441066f, 
    -0.17134584f, 0.23157604f, 0.06595871f, 0.04544674f, 0.08624705f, -0.29177728f, 0.00209443f, 0.04681836f, 
    0.19465922f, 0.02496293f, 0.15863292f, 0.17767723f, -0.03569871f, 0.00753010f, -0.06079939f, -0.00970069f, 
    -0.42158923f, -0.03303695f, 0.07580000f, -0.55553424f, 0.18063889f, 0.38680118f, 0.24967930f, 0.31508547f, 
    -0.04684554f, -0.01957555f, -0.06671323f, 0.04930589f, -0.08103342f, -0.00283275f, -0.02321107f, -0.04471150f, 
    -0.45958760f, -0.02518989f, -0.05499789f, 0.29709503f, -0.07649061f, 0.27659056f, 0.26164284f, -0.11447243f, 
    0.09346847f, 0.17395048f, -0.01525735f, -0.07806090f, -0.53171498f, -0.26862514f, 0.21328515f, -0.00051434f, 
    0.03923354f, 0.09726769f, -0.01947320f, 0.09905413f, -0.08304677f, 0.07145336f, -0.05751334f, -0.07963326f, 
    0.70417768f, 0.28515080f, 0.17863297f, 0.35696340f, -0.04966231f, 0.02419387f, -0.07356802f, 0.10989013f, 
    -0.07965564f, 0.11598147f, 0.11922923f, 0.15999940f, -0.47362328f, -0.11224084f, -0.22013991f, 0.17910467f, 
    0.10684125f, 0.09317579f, 0.04872554f, -0.02511182f, 0.17224266f, 0.06038302f, -0.06783518f, 0.09574432f, 
    -0.12372457f, -0.23755160f, -0.13633029f, 0.06592577f, -0.02449709f, 0.16550642f, -0.18943642f, 0.22439194f, 
    -0.02543041f, 0.03807198f, -0.14117928f, 0.13150959f, -0.59580892f, -0.12848733f, -0.19422868f, -0.02470214f, 
    0.07527191f, 0.16445571f, 0.30240229f, -0.00172364f, 0.08774570f, 0.16020592f, 0.11232118f, 0.03240445f, 
    0.08645682f, 0.16710407f, 0.11354817f, 0.10823923f, -0.07466142f, 0.06601002f, 0.16436276f, -0.09586666f, 
    0.33298588f, -0.00229691f, -0.02770388f, -0.18864435f, 0.36922473f, 0.05912144f, -0.11758780f, -0.14726622f, 
    -0.01561791f, 0.04421180f, 0.03627879f, 0.01460879f, -0.06406452f, -0.07724097f, 0.04367666f, -0.23832054f, 
    0.13881618f, 0.22135557f, 0.04716565f, 0.17111984f, -0.01658780f, -0.04099977f, 0.01315565f, 0.00106171f, 
    0.01244053f, -0.02634331f, 0.07183957f, -0.08734314f, -0.50761414f, -0.09251224f, -0.11797672f, 0.14943334f, 
    0.02175865f, -0.03032315f, 0.16675030f, 0.22445329f, -0.03073544f, -0.08379894f, 0.07674281f, 0.08191264f, 
    -0.13246229f, 0.06571578f, 0.04099831f, 0.03670059f, -0.09648858f, -0.11695226f, -0.10089838f, -0.32203823f, 
    -0.01792741f, -0.07081697f, 0.03061497f, -0.07341445f, -0.03467834f, 0.04384259f, 0.46177828f, -0.03923919f, 
    0.09080487f, -0.03076424f, -0.00191304f, 0.11050849f, -0.07886188f, 0.02286666f, 0.06110371f, -0.00327581f, 
    -0.05940524f, -0.09046061f, -0.03395367f, -0.16109502f, -0.03485443f, -0.03328490f, 0.08821932f, 0.09205528f, 
    -0.04907641f, 0.19080272f, 0.09800761f, 0.03337057f, 0.63883406f, -0.47426188f, -0.12867032f, 0.29182819f, 
    -0.00393673f, -0.14544518f, 0.17457946f, 0.00978473f, -0.08857299f, -0.02263615f, -0.13436660f, 0.02895227f, 
    -0.33817855f, -0.49003828f, -0.15430543f, -0.30561620f, -0.00405611f, 0.13244222f, 0.01801479f, 0.09350905f, 
    0.19784884f, 0.07684279f, 0.00532510f, 0.00717405f, -0.25034952f, -0.60288876f, 0.29180425f, -0.23657455f, 
    0.22112249f, -0.30749390f, 0.14805500f, 0.02135485f, 0.01605044f, -0.13878623f, 0.11697913f, -0.26142085f, 
    0.13344790f, 0.05007983f, 0.01243156f, 0.03716303f, -0.02325214f, -0.19924432f, 0.23635940f, 0.02978715f, 
    0.01516091f, 0.03564759f, -0.11281505f, -0.05949758f, 0.26194316f, 0.10885494f, 0.07637101f, 0.13340889f, 
    0.14269298f, -0.21137510f, -0.05786548f, -0.54122043f, 0.11405168f, -0.01982760f, -0.14669472f, -0.01001129f, 
    0.35978130f, -0.15484868f, 0.02066329f, -0.07342913f, -0.02124945f, 0.06758956f, 0.09664907f, -0.00426303f, 
    0.08727914f, 0.06129816f, -0.18241310f, 0.01330144f, 0.47945753f, 0.12501433f, -0.00043557f, 0.02285346f, 
    -0.41988194f, -0.02300999f, -0.03692919f, -0.24946544f, -0.10703874f, 0.01682686f, -0.03705558f, 0.06443970f, 
    0.53834367f, 0.45987266f, -0.02422412f, -0.38463536f, 0.02637194f, -0.02428201f, -0.09249586f, -0.18696524f, 
    -0.01356667f, 0.01535219f, -0.15714902f, -0.15098138f, 0.01126412f, 0.01052381f, -0.00092074f, -0.01923055f, 
    0.03361718f, 0.04993775f, 0.00678708f, -0.05802993f, -0.19786462f, -0.08632114f, -0.04520046f, 0.03685273f, 
    -0.03123696f, -0.01484169f, 0.11210373f, 0.22677761f, 0.12312343f, -0.08332181f, 0.03707420f, 0.14284980f, 
    0.02900252f, 0.06773193f, -0.06804092f, -0.18267132f, -0.43414927f, -0.07883045f, 0.10350093f, -0.55616540f, 
    -0.07947889f, -0.27713102f, -0.26690850f, -0.15678485f, 0.01848187f, -0.04734808f, 0.02967082f, 0.02153336f, 
    -0.32062292f, -0.06812623f, 0.05679372f, -0.00301479f, -0.13883090f, 0.12995405f, 0.10519855f, 0.08059092f, 
    -0.02853427f, -0.16390368f, 0.08876563f, -0.08464825f, -0.07408476f, 0.04559578f, -0.11299138f, -0.06711913f, 
    0.01275571f, 0.07975845f, 0.00009774f, -0.03038105f, -0.02504203f, -0.03702105f, 0.02397725f, 0.03137232f, 
    0.16585915f, -0.07936843f, -0.45909289f, 0.05939088f, 0.02529646f, -0.05070304f, -0.12708808f, -0.07421786f, 
    -0.16614372f, -0.10831257f, -0.06904601f, -0.01150194f, 0.02679869f, 0.45079720f, 0.28982344f, 0.21686266f, 
    0.00881732f, 0.07770235f, 0.14840116f, -0.03479552f, 0.10724424f, 0.11941877f, -0.11972085f, 0.18406764f, 
    -0.35923806f, -0.58839375f, -0.36434460f, 0.04125913f, -0.30952489f, -0.06449791f, 0.18045931f, -0.12988938f, 
    0.06979706f, -0.06794412f, -0.08211689f, 0.09884538f, 0.06982470f, -0.19811410f, -0.18389733f, 0.14605440f, 
    -0.03666344f, -0.08769839f, -0.02641624f, -0.15519577f, -0.22813867f, 0.01045652f, 0.13146593f, 0.02254592f, 
    -0.00770890f, -0.17583525f, -0.27810246f, -0.01347543f, -0.04066485f, -0.01809047f, -0.03016562f, -0.00559850f, 
    0.00338905f, 0.18816236f, 0.15152545f, -0.28083137f, -0.56569171f, -0.70336586f, 0.28892234f, 0.25780168f, 
    -0.14451195f, 0.04762949f, 0.15847512f, 0.20332187f, 0.02199418f, -0.06036725f, -0.01500734f, -0.05632738f, 
    0.08048964f, -0.15202506f, -0.13473625f, 0.24222608f, 0.00960832f, 0.08290695f, -0.02824134f, 0.01457357f, 
    -0.12652260f, 0.05286099f, 0.01487814f, -0.09820690f, 0.06245450f, 0.08872271f, -0.21234709f, 0.25634125f, 
    -0.10054627f, 0.03515001f, 0.05580582f, -0.11334054f, -0.20226979f, -0.24067993f, 0.04101881f, -0.11870141f, 
    -0.01078802f, -0.08059635f, -0.41756597f, 0.19473855f, -0.01005485f, 0.03656743f, 0.01248527f, 0.07899117f, 
    0.01058237f, -0.04429825f, 0.36392859f, -0.02205264f, 0.26387057f, -0.19824654f, -0.16462334f, 0.21838617f, 
    -0.11757822f, 0.01055925f, 0.12350298f, -0.05012464f, 0.09614323f, 0.03308702f, -0.20434004f, 0.22797979f, 
    -0.02510553f, -0.01840401f, -0.34006518f, -0.32708961f, 0.21168359f, 0.12978224f, -0.04024150f, -0.01854535f, 
    0.04133969f, -0.06016250f, 0.06339942f, -0.01766281f, 0.12722851f, -0.24082865f, -0.20564008f, 0.21093255f, 
    0.06699710f, -0.13960832f, -0.18417601f, -0.21773882f, -0.26185653f, 0.04154670f, -0.00444488f, 0.09038512f, 
    -0.04212962f, 0.19103165f, 0.03089489f, 0.12264794f, 0.11280937f, 0.06424276f, 0.04386420f, 0.07205326f, 
    -0.07752196f, 0.09356214f, 0.08953238f, -0.14972571f, 0.20662016f, -0.18162835f, 0.17236137f, 0.14714913f, 
    -0.03683929f, 0.02133366f, 0.02023292f, -0.02264966f, 0.03616790f, 0.09274958f, 0.24427412f, 0.01077322f, 
    0.00016478f, -0.06500775f, 0.04129374f, -0.02408581f, 0.01268052f, -0.10242800f, 0.03896957f, 0.07132809f, 
    0.00172981f, -0.06741706f, 0.03429665f, 0.03600940f, 0.20195213f, 0.24564093f, -0.48393142f, -0.12889408f, 
    0.10595153f, 0.00621517f, 0.04582302f, 0.14226218f, 0.00849906f, -0.01335685f, -0.00934917f, 0.00870060f, 
    -1.03371680f, -0.46715006f, -0.19749852f, -0.21177928f, 0.03571435f, 0.02202790f, 0.18889761f, 0.30075583f, 
    -0.00213160f, -0.01269263f, 0.04252067f, -0.09163950f, -1.30302894f, -0.76167953f, -0.05953323f, -0.65727508f, 
    -0.10592844f, 0.04444059f, 0.05471644f, -0.25973514f, -0.05554715f, -0.07032937f, -0.10885385f, -0.03042453f, 
    -0.10155824f, 0.04462133f, 0.35879776f, 0.08113918f, 0.14457829f, 0.12066612f, -0.10593743f, 0.04554856f, 
    -0.13757451f, -0.40798762f, -0.10670162f, -0.38909450f, 0.07711439f, -0.16421127f, -0.09218218f, -0.45133695f, 
    0.01854863f, -0.12765475f, 0.09767360f, -0.04906853f, 0.03102392f, -0.04763062f, 0.01192746f, -0.10043314f, 
    0.24327357f, 0.15799901f, 0.11625862f, 0.07920220f, -0.01481048f, 0.07756012f, 0.05563033f, -0.32352293f, 
    -0.05148942f, -0.06255575f, -0.04078019f, 0.01708690f, 0.39618257f, 0.24183579f, 0.04495930f, 0.16289970f, 
    0.02166159f, 0.07010367f, 0.12886815f, -0.03232554f, -0.05516754f, -0.04968951f, 0.04713441f, -0.09399637f, 
    -0.04553296f, -0.03611319f, -0.09859387f, 0.12403566f, 0.03587557f, 0.07215045f, 0.01453833f, -0.07191555f, 
    0.20214516f, 0.06794795f, -0.11991411f, 0.10604742f, -0.34687248f, 0.65722674f, 0.10598236f, 0.09499864f, 
    -0.16340354f, 0.02837312f, 0.17570607f, -0.21451204f, 0.04335531f, 0.14469652f, 0.11428550f, 0.07638166f, 
    -0.28764668f, -0.00576575f, 0.05659621f, -0.20347038f, -0.00220974f, -0.02253601f, -0.04012026f, -0.20465100f, 
    0.20476162f, 0.05891423f, -0.22442409f, 0.22871110f, -0.07802290f, 0.10163004f, -0.28477791f, -0.32903543f, 
    0.02650790f, 0.05643933f, 0.09119425f, 0.01496867f, -0.00796263f, -0.02577800f, 0.06826729f, -0.09740163f, 
    0.39609849f, 0.86857033f, 0.41053659f, 0.76495820f, 0.03003705f, -0.09192519f, -0.07783582f, 0.15540342f, 
    0.03447043f, -0.01687629f, -0.05118653f, 0.07377168f, -0.15205736f, -0.06422284f, -0.05690085f, 0.05600345f, 
    -0.12867685f, -0.11745846f, -0.08228722f, 0.09385815f, 0.05114217f, -0.15626976f, 0.07552797f, -0.00207542f, 
    -0.83658075f, 0.84914374f, -0.39264658f, -0.94081455f, 0.29161057f, 0.30430299f, -0.07155049f, -0.04731466f, 
    -0.42603892f, -0.07318536f, -0.13051526f, 0.03499465f, 0.02845848f, 0.16470343f, 0.19992384f, 0.06742167f, 
    -0.32352594f, 0.05175159f, 0.21664661f, -0.02075633f, 0.03698039f, 0.03134867f, 0.05240952f, 0.11638082f, 
    -0.17736658f, -0.34497201f, -0.06859418f, 0.23333192f, -0.22413097f, -0.00665038f, -0.14752454f, -0.03927464f, 
    0.20100583f, 0.24796422f, -0.13032816f, -0.22675598f, 0.53980446f, -0.04839266f, 0.05372166f, -0.38584331f, 
    -0.13080351f, -0.38535270f, -0.06259270f, 0.06814367f, -0.09865223f, 0.14212367f, -0.25209504f, 0.04119071f, 
    0.61150980f, 0.32777321f, 0.12724559f, -0.47654134f, -0.16125233f, -0.06024808f, 0.09091902f, -0.12210228f, 
    -0.05805440f, 0.04994099f, 0.06211581f, -0.11549412f, -0.03779187f, -0.11379894f, 0.11822280f, 0.29212061f, 
    0.09929943f, 0.17194754f, 0.03159384f, -0.19542347f, -0.04208641f, 0.10567749f, -0.11482187f, 0.22208385f, 
    0.28493091f, -0.04963691f, 0.34307340f, -0.05427592f, 0.02621272f, 0.02305370f, 0.04156653f, 0.36238545f, 
    -0.11018346f, 0.03222023f, 0.01545595f, -0.05790227f, -0.33550358f, -0.25957075f, -0.38032544f, 0.08775363f, 
    0.14054063f, 0.05590070f, 0.18125395f, -0.05330757f, 0.07030845f, -0.06109249f, -0.08274198f, 0.09791373f, 
    0.41115078f, 0.34017298f, -0.08649379f, -0.41476974f, -0.03283271f, 0.14066142f, 0.06967790f, 0.08624417f, 
    0.00514422f, -0.10796017f, 0.19061804f, -0.08385593f, -0.00659720f, -0.14039552f, -0.13055052f, 0.14496019f, 
    -0.18083318f, -0.10341793f, -0.11505894f, -0.07639475f, -0.12982485f, 0.12318122f, -0.08870447f, 0.10563882f, 
    0.25188178f, 0.01435006f, -0.23645601f, -0.14580813f, 0.15814577f, 0.01884039f, -0.26575655f, -0.16759348f, 
    -0.02241631f, -0.08523029f, 0.13123903f, 0.00082270f, 0.37334585f, -0.15029940f, -0.05358918f, 0.09989818f, 
    -0.10477125f, -0.04058126f, 0.03117553f, 0.12536947f, 0.00486586f, -0.15998501f, 0.32699946f, 0.07337926f, 
    -0.40910804f, 0.90567458f, -0.68429768f, -0.20660052f, 0.25835374f, 0.10430090f, 0.08861793f, -0.06923404f, 
    -0.09557387f, 0.03821355f, -0.03383676f, -0.11333027f, 0.57266814f, -0.33637494f, -0.36313915f, -0.50744641f, 
    -0.19141164f, -0.23521310f, -0.00458302f, -0.03343924f, -0.15061855f, -0.08276230f, -0.14542399f, -0.01998518f, 
    -0.02056133f, -0.00471957f, -0.08567727f, 0.04000781f, 0.06476832f, 0.01800395f, 0.00217083f, -0.06335425f, 
    -0.08422648f, -0.01940810f, 0.04009865f, -0.05458605f, 0.21382286f, -0.07094832f, -0.41939002f, 0.00095305f, 
    -0.05590063f, -0.00055493f, -0.00025735f, 0.04560565f, 0.00104459f, -0.00289795f, -0.03657126f, -0.19127594f, 
    0.07510213f, 0.42225865f, -0.13696267f, 0.08228415f, -0.08852759f, -0.15964264f, 0.17274517f, -0.10595205f, 
    -0.21785465f, -0.16120772f, -0.18927702f, 0.04210883f, -0.65556264f, -0.18849649f, -0.18633407f, -0.22524311f, 
    0.34469804f, 0.01645496f, 0.04778411f, -0.12504281f, 0.02035001f, 0.07386789f, -0.25461909f, 0.07296024f, 
    -0.50662410f, -0.55782527f, -0.42654470f, -0.28844881f, -0.37641600f, 0.03583395f, -0.37993664f, -0.02278583f, 
    -0.10877310f, -0.12314503f, 0.17909084f, -0.11647245f, 0.38072205f, 0.83690590f, -0.19865388f, -0.74890119f, 
    -0.23859462f, -0.02887951f, -0.05952086f, -0.15385243f, -0.20954256f, 0.05213389f, 0.00641979f, 0.11401267f, 
    -0.29552969f, -0.04353572f, -0.20231254f, 0.05057679f, -0.05616706f, -0.01966157f, -0.03454243f, -0.12379389f, 
    -0.11150390f, -0.12822622f, 0.07059305f, -0.03206942f, 0.00663514f, -0.34391016f, 0.02938753f, 0.25658479f, 
    0.01759618f, 0.09431424f, 0.04218059f, 0.31648499f, -0.06395342f, -0.07797991f, -0.04497309f, -0.11393229f, 
    0.26460060f, 0.01436571f, -0.01493018f, 0.24146497f, 0.35064688f, 0.00532985f, 0.05440332f, -0.05799883f, 
    -0.10423040f, -0.01251133f, 0.08885413f, -0.04742341f, 0.07091279f, 0.20485932f, 0.08684257f, 0.42245868f, 
    0.12563111f, -0.16790435f, -0.13554397f, -0.05117471f, -0.09597293f, -0.08278338f, 0.03828122f, -0.03798184f, 
    0.12865557f, -0.10215996f, 0.02390480f, 0.38202170f, 0.11322317f, 0.02486453f, -0.08245975f, 0.03833396f, 
    -0.03770411f, 0.00273608f, 0.10494834f, 0.07954498f, -0.06465828f, 0.30105969f, 0.28684309f, 0.12895155f, 
    -0.22182171f, -0.10799267f, 0.08270375f, -0.00197661f, -0.16699913f, 0.04715713f, -0.10085785f, -0.05716503f, 
    0.06886005f, 0.09559029f, 0.09140363f, 0.37485111f, -0.05178825f, -0.01303037f, -0.10482843f, -0.25669321f, 
    0.11267371f, -0.13952000f, -0.13547765f, 0.05881015f, -0.24456823f, 0.02544435f, -0.02523453f, 0.26819468f, 
    -0.10238574f, -0.05256137f, 0.01153569f, 0.02498240f, -0.08156399f, 0.07649618f, -0.03098756f, 0.11114004f, 
    -0.72272563f, -0.38924086f, -0.03681998f, 0.13711324f, -0.07802328f, -0.22576565f, -0.22235411f, -0.10812944f, 
    -0.06483038f, 0.11243335f, -0.37492472f, 0.09335537f, -0.25689659f, 0.27068162f, 0.00803076f, 0.39348480f, 
    0.17146602f, 0.06377127f, -0.18198712f, -0.09280646f, 0.00564654f, 0.05079814f, 0.22843923f, -0.00281760f, 
    0.60372430f, -0.26227221f, 0.17945094f, 0.24131881f, 0.09782252f, -0.11262880f, 0.04944842f, -0.02318265f, 
    -0.04959244f, -0.06442395f, 0.01642619f, 0.21919145f, -0.22358634f, -0.29328805f, 0.02860737f, -0.00020204f, 
    -0.14189506f, 0.03580870f, 0.02442487f, -0.25222853f, 0.16756178f, 0.14564240f, -0.02390803f, 0.05780384f, 
    0.23477818f, -0.77406281f, 0.33590469f, 0.11428281f, -0.03907814f, 0.14532274f, -0.02546700f, -0.11100288f, 
    -0.02763891f, 0.13744187f, -0.15045221f, -0.10956751f, 0.32809168f, 0.07472776f, 0.17777771f, 0.34692821f, 
    0.37585196f, 0.14749877f, -0.13861226f, 0.11686917f, 0.14634170f, 0.00405840f, -0.08508664f, -0.03477529f, 
    -0.07355921f, 0.04581161f, 0.03761310f, 0.12182144f, -0.25942904f, 0.03964479f, -0.30647406f, 0.00514369f, 
    -0.05732152f, -0.04671779f, -0.16522622f, -0.05826077f, -0.54969949f, -0.19092847f, -0.03706329f, 0.04861688f, 
    -0.04438870f, -0.10913040f, 0.11287961f, -0.00012627f, -0.07768524f, -0.10939496f, -0.05447890f, -0.19631146f, 
    0.15004164f, -0.42340252f, -0.30817118f, 0.10614939f, -0.12273521f, -0.10819961f, 0.00266163f, -0.16112867f, 
    0.06735329f, 0.02512871f, 0.37699068f, 0.28521976f, -0.06948455f, 0.04555589f, 0.10788733f, 0.04346736f, 
    -0.12922482f, -0.06908950f, -0.03416931f, 0.10396818f, 0.19191042f, -0.00533044f, 0.03398174f, 0.08833260f, 
    -0.09291696f, -0.30336982f, 0.06369144f, 0.09062198f, 0.05058845f, 0.08673435f, 0.03919503f, -0.09233405f, 
    0.06767774f, -0.02065331f, 0.09199833f, -0.24526350f, 0.12540926f, 0.05471022f, 0.19138092f, -0.05165036f, 
    0.08195722f, -0.00784106f, -0.00279145f, -0.16112903f, -0.09651688f, 0.34306467f, 0.18036175f, -0.02330090f, 
    -0.00664089f, -0.02335192f, 0.13122751f, 0.00418101f, 0.05133424f, 0.02293599f, 0.03977233f, 0.00473243f, 
    0.05398204f, 0.13654979f, -0.03057325f, 0.25232419f, -0.09996248f, 0.03977077f, 0.16333158f, 0.01398829f, 
    -0.17550367f, 0.02118742f, 0.02540498f, -0.13986033f, 0.09734543f, 0.03574992f, -0.00484292f, 0.06041662f, 
    -0.19092211f, 0.05783748f, -0.09100793f, -0.12209156f, -0.14468029f, -0.10387452f, -0.00846311f, 0.01836112f, 
    -0.03255080f, -0.15587232f, -0.09817241f, -0.23676498f, 0.00964078f, 0.11919975f, 0.17891736f, 0.08263067f, 
    0.00299198f, 0.11311804f, 0.04695074f, -0.10560696f, 0.14793977f, 0.12731305f, 0.00515780f, 0.25583872f, 
    0.00665080f, -1.05310512f, 0.26143762f, -0.56474656f, 0.03943269f, 0.01685902f, 0.00694340f, 0.05495142f, 
    0.04983640f, -0.18134670f, -0.06801224f, 0.10008011f, -0.04738133f, -0.08686300f, 0.18732825f, 0.00432307f, 
    -0.29418057f, -0.02641399f, -0.29015887f, 0.13828425f, -0.22131950f, -0.08942115f, -0.18803009f, -0.21991318f, 
    0.10698350f, 0.13413863f, 0.12777326f, 0.23043147f, -0.16381642f, -0.13066572f, 0.09265498f, -0.03717116f, 
    -0.18143375f, -0.03415697f, 0.01124736f, -0.09382466f, 0.08969781f, 0.03364506f, 0.29530826f, 0.07410266f, 
    -0.01006852f, -0.06577532f, -0.38057849f, 0.03369751f, -0.29549816f, -0.01012663f, -0.00528478f, 0.04828601f, 
    -0.25223163f, -0.11096675f, 0.01799849f, -0.11064024f, 0.11313616f, 0.04845574f, -0.22021553f, 0.06188551f, 
    -0.28182957f, 0.10920507f, -0.06180602f, -0.64985955f, 0.00888777f, 0.23947197f, -0.17269118f, 0.06013723f, 
    0.06532475f, -0.13284633f, 0.05194248f, -0.03383626f, -0.21368559f, -0.09406999f, -0.02913418f, -0.10119656f, 
    -0.05278493f, -0.05228199f, -0.00562795f, -0.05933633f, 0.03878770f, 0.10992540f, -0.00558133f, 0.05032371f, 
    0.08344371f, -0.02591924f, -0.12671162f, -0.00016306f, 0.10849600f, -0.97485644f, 0.02385286f, 0.54876238f, 
    0.08002722f, -0.05130025f, -0.03516375f, -0.14234704f, 0.01619421f, 0.01726718f, -0.11358058f, 0.04210353f, 
    -0.09751178f, 0.02479778f, 0.28227559f, 0.18429333f, -0.11171222f, 0.05029625f, -0.16347833f, -0.01687731f, 
    -0.02165099f, 0.07849371f, -0.15239388f, 0.10022058f, 0.12010849f, 0.33845150f, 0.25629607f, 0.21823168f, 
    -0.12997966f, -0.03995345f, 0.07959986f, 0.19243042f, 0.12070700f, -0.11087891f, 0.07294262f, 0.08388294f, 
    0.33360234f, 0.39971074f, -0.04388499f, 0.16033994f, -0.10455742f, -0.20740691f, -0.09431995f, 0.03127268f, 
    -0.11117008f, -0.50883245f, -0.06033611f, -0.02633188f, -0.24604851f, -0.01563121f, 0.07293627f, -0.08856618f, 
    0.17925236f, 0.12694688f, -0.18965425f, -0.09972174f, -0.00927694f, -0.04701378f, -0.02700649f, -0.10888779f, 
    0.01115773f, 0.20985618f, 0.05057908f, 0.12602624f, 0.03963590f, -0.09826877f, -0.01222994f, -0.04482894f, 
    0.02829909f, -0.23430370f, 0.07035515f, -0.01804814f, -0.10556994f, -0.24676442f, -0.35263726f, -0.15831043f, 
    -0.15513378f, -0.06949379f, -0.05337715f, -0.09395208f, 0.03120503f, -0.05271815f, -0.09538276f, -0.21538451f, 
    0.08301146f, 0.10456987f, -0.00247951f, 0.12723696f, -0.06622300f, 0.10437138f, -0.07294054f, 0.03137891f, 
    -0.09825404f, -0.09030464f, 0.09216890f, -0.05901947f, -0.15110059f, -0.18464591f, 0.17526853f, -0.05352690f, 
    -0.00199445f, 0.03463070f, -0.21475174f, -0.18587506f, -0.01693762f, -0.08580812f, 0.04677523f, -0.01511182f, 
    0.03746785f, -0.04072000f, -0.07460042f, -0.00539928f, 0.02774571f, 0.01623213f, -0.17213826f, -0.05191447f, 
    -0.22830294f, 0.02133890f, 0.16337322f, -0.21483885f, 0.05585322f, -0.00366006f, 0.43473828f, 0.02707557f, 
    -0.14727017f, 0.06767315f, 0.00949906f, 0.16024087f, 0.05869329f, -0.05154490f, -0.09846099f, -0.12339608f, 
    -0.21341720f, -0.09084187f, -0.00808805f, 0.19803894f, -0.05818034f, -0.15092444f, -0.08744674f, 0.06492734f, 
    -0.01146119f, 0.00498648f, 0.02885132f, 0.05126119f, 0.09369034f, 0.14880352f, 0.08768235f, 0.08477107f, 
    0.18385378f, -0.01307973f, -0.00667760f, -0.03163342f, 0.05238113f, 0.03993505f, -0.11873277f, -0.01635921f, 
    -0.29685974f, -0.13069659f, 0.17728889f, 0.21518499f, -0.06091949f, -0.27009460f, -0.09139052f, -0.00633258f, 
    0.06292018f, -0.01548476f, 0.07019412f, 0.08741353f, -0.08021743f, -0.20906261f, 0.23955062f, 0.26455629f, 
    -0.20128356f, 0.05395668f, 0.12108406f, 0.06729823f, 0.00112897f, -0.01150555f, 0.04554850f, -0.17176747f, 
    0.10975792f, -0.08626720f, -0.32066572f, 0.07814822f, 0.17808610f, 0.22629546f, -0.38827032f, -0.03839166f, 
    -0.15572719f, 0.01966869f, 0.07669069f, -0.03450337f, 0.44958165f, -0.26279381f, -0.07338928f, 0.41203579f, 
    0.09844401f, 0.05240864f, -0.05760314f, -0.02465859f, 0.05471646f, -0.02992506f, 0.05650607f, 0.11507840f, 
    -0.74889135f, -0.20369361f, 0.51582032f, 0.27632773f, 0.02837580f, -0.03826748f, -0.03602588f, 0.03394186f, 
    0.03816120f, -0.27014944f, -0.36705366f, -0.16788173f, -0.07721468f, -0.23374249f, -0.39406163f, -0.27688107f, 
    0.07438378f, -0.08128591f, -0.04570421f, 0.10158712f, -0.01364180f, -0.18465680f, -0.06742104f, -0.10538338f, 
    0.22109345f, -0.42687178f, -0.27271172f, 0.26241919f, 0.23681372f, -0.14323924f, -0.02468012f, -0.01153533f, 
    0.00820806f, 0.15732761f, 0.02767855f, -0.10519744f, 0.25450212f, -0.02410596f, 0.24171372f, -0.15204498f, 
    0.07792082f, -0.26417458f, -0.09285101f, 0.15812470f, -0.25677440f, -0.17774421f, -0.22484152f, -0.04059755f, 
    -0.30518869f, -0.14425020f, -0.10926417f, -0.10976883f, 0.03157495f, 0.07309492f, -0.01816200f, 0.01122570f, 
    -0.05120872f, -0.30721062f, -0.53608143f, -0.16303992f, -0.31776676f, -0.11367620f, 0.21773314f, -0.06307671f, 
    0.37133431f, 0.00557673f, 0.20310552f, 0.20314817f, 0.02642923f, -0.00726217f, 0.04517332f, 0.07910524f, 
    0.07797795f, -0.08955991f, 0.22541811f, -0.01569753f, 0.03050378f, -0.00515026f, -0.28591132f, -0.00829885f, 
    -0.05962029f, 0.14784731f, -0.04875984f, 0.23695524f, -0.07409725f, 0.11794230f, 0.01547322f, 0.00956153f, 
    0.09663915f, -0.13609581f, 0.01615594f, -0.01588605f, -0.04997989f, -0.02437434f, -0.09221645f, -0.47639653f, 
    -0.12806876f, -0.11845854f, 0.25064707f, -0.09595723f, -0.01316223f, -0.00199529f, 0.07755890f, -0.11360309f, 
    0.04458979f, -0.13290721f, -0.23986880f, -0.18485695f, -0.13357945f, 0.13516006f, 0.40104470f, 0.02470165f, 
    -0.05781284f, 0.00617950f, 0.14185306f, -0.24600068f, -0.03051955f, 0.11240152f, 0.06294258f, 0.19652580f, 
    0.05167994f, 0.33014125f, 0.16066681f, -0.03237114f, -0.00954647f, 0.08331377f, 0.31325805f, -0.22281080f, 
    0.14525157f, 0.01171269f, -0.02708843f, 0.08721817f, 0.01707998f, 0.09628193f, 0.30802131f, -0.08689548f, 
    -0.01721852f, 0.08448812f, 0.03509133f, 0.07195786f, 0.15909459f, -0.24816178f, -0.04717558f, 0.05396788f, 
    -0.06974327f, -0.34154677f, -0.18434758f, -0.05065573f, -0.06369229f, -0.01668510f, -0.10684410f, 0.00491676f, 
    0.05431610f, -0.08541282f, 0.14420865f, 0.58703995f, -0.23271970f, -0.40106836f, 0.14838588f, 0.03653839f, 
    -0.06631546f, 0.12552387f, -0.00353891f, 0.22403149f, 0.19270442f, 0.12004430f, 0.15484723f, -0.04382917f, 
    -0.30249384f, -0.22167732f, -0.05891868f, 0.06425851f, 0.04835182f, -0.07466635f, -0.03904012f, -0.01769220f, 
    -0.12170107f, -0.03268024f, 0.12773353f, 0.23105283f, -0.16412953f, -0.25187349f, 0.58280736f, 0.17839867f, 
    -0.10928965f, -0.08510603f, -0.15344043f, -0.01921801f, 0.05778408f, 0.06564050f, -0.08027314f, -0.06212307f, 
    0.12910885f, 0.18313168f, 0.09406009f, 0.03146778f, 0.08903725f, -0.02084761f, 0.23772506f, 0.01523034f, 
    0.02199909f, 0.14372636f, 0.01999707f, 0.09921386f, 0.10312033f, 0.18733791f, -0.08743966f, 0.05716785f, 
    0.18153879f, 0.02050490f, -0.05271576f, -0.16682737f, 0.14089328f, 0.04548579f, -0.00401914f, 0.02126338f, 
    -0.48135349f, -0.20791452f, -0.33641297f, -0.40017769f, -0.11254290f, 0.10346187f, -0.11643206f, -0.20270745f, 
    0.35082683f, 0.12427223f, 0.09141197f, 0.09828709f, -0.24320368f, 0.73967785f, -0.28726524f, -0.82302058f, 
    -0.18660647f, -0.00099192f, 0.01636764f, 0.15283975f, 0.07418031f, -0.01666245f, -0.01336705f, -0.08920434f, 
    -0.13389383f, 0.08071339f, -0.27581632f, -0.07053045f, 0.00277911f, -0.13202529f, -0.02870450f, 0.05253908f, 
    -0.07160946f, 0.09372870f, -0.09729537f, -0.11613116f, 0.12422776f, 0.27405983f, -0.06891962f, 0.17246175f, 
    0.08777912f, 0.29794621f, -0.21954721f, 0.07208941f, 0.02580741f, 0.00139239f, -0.10041771f, 0.04332726f, 
    -0.31657657f, -0.08925961f, -0.17611453f, -0.02713465f, 0.14302525f, 0.05712837f, -0.17682411f, -0.15934132f, 
    -0.03078927f, 0.03220120f, 0.19691831f, 0.17701025f, 0.32017571f, -0.08371791f, -0.15954852f, -0.27180105f, 
    -0.21303360f, 0.04870667f, -0.17180178f, 0.16327089f, -0.07775494f, -0.33127171f, 0.08467845f, -0.12687522f, 
    -0.28542629f, 0.22449751f, -0.19055732f, 0.16517858f, 0.25910306f, 0.02826850f, -0.11808327f, 0.20748761f, 
    0.26791918f, 0.04391481f, 0.13614452f, 0.12836024f, -0.07503761f, -0.07071780f, -0.34262151f, 0.19485338f, 
    0.34099481f, 0.03814032f, 0.07448368f, -0.00591257f, 0.10287463f, 0.00996384f, -0.01381055f, 0.07682338f, 
    -0.64207000f, -0.23956649f, -0.12952955f, -0.29088798f, -0.03855703f, -0.07832269f, -0.09329547f, -0.05131571f, 
    -0.03724943f, -0.19418985f, -0.01952358f, 0.10910504f, 0.00069980f, -0.06921306f, -0.03979552f, -0.01944687f, 
    0.18365313f, -0.05970307f, -0.03983321f, 0.07709925f, -0.01536515f, 0.09461091f, 0.07122300f, -0.08431713f, 
    -0.14084445f, -0.27089566f, 0.05677892f, 0.15405919f, -0.04990523f, -0.06796872f, -0.02366976f, -0.01542630f, 
    -0.03387468f, 0.07229527f, -0.00806897f, -0.01913969f, -0.25833648f, -0.63302487f, -0.62153500f, -0.17403325f, 
    -0.18202461f, 0.24132626f, 0.25168905f, -0.14857371f, 0.02807747f, 0.01223034f, 0.02027559f, 0.05152291f, 
    0.54252058f, 0.01935580f, -0.15330896f, -0.35480615f, 0.02681067f, -0.09280634f, 0.28063795f, -0.03099859f, 
    0.06092564f, 0.02475489f, -0.22497301f, 0.06878231f, -0.02644516f, -0.09325273f, -0.62967831f, -0.38272494f, 
    -0.17226411f, 0.16357692f, 0.02344978f, 0.05154165f, -0.07822450f, 0.02129560f, -0.03870249f, -0.20163132f, 
    -0.17516533f, -0.20554133f, 0.00575158f, 0.06817231f, -0.13760608f, 0.08646765f, -0.03201925f, 0.14221296f, 
    0.10708065f, 0.17590965f, 0.31489033f, 0.15459032f, 0.21526474f, 0.42283994f, 0.19970128f, 0.19722521f, 
    -0.05666548f, 0.06037989f, 0.05121171f, 0.03124607f, -0.00762651f, 0.06845433f, 0.08710527f, 0.01306087f, 
    0.09196118f, 0.19381042f, -0.05139581f, -0.61717772f, 0.10812563f, 0.03218613f, 0.02217119f, 0.08435305f, 
    -0.08435813f, -0.01813634f, -0.02066721f, -0.06689852f, -0.30241656f, 0.09906616f, 0.06367821f, -0.00704296f, 
    -0.12160799f, 0.00003225f, -0.10137155f, 0.03961892f, 0.11534013f, -0.07621440f, -0.05122339f, 0.07671320f, 
    -0.13549086f, 0.05795238f, 0.04616882f, -0.02908775f, -0.00859155f, -0.02801226f, 0.00386968f, 0.08987834f, 
    0.00538112f, 0.05396282f, 0.07545651f, 0.22536016f, -0.62704670f, -0.74309099f, -0.80021876f, -0.41163155f, 
    0.03339219f, -0.32784894f, -0.21673326f, -0.26148197f, -0.01741189f, 0.07568662f, 0.03266196f, -0.03409690f, 
    0.15240191f, 0.14618436f, 0.23283556f, 0.24675274f, -0.14363316f, -0.32730964f, 0.10923164f, 0.18066752f, 
    -0.04598689f, -0.06411973f, -0.09836356f, 0.20965715f, 0.08583967f, -0.19121960f, -0.33377528f, -0.41631994f, 
    -0.24588545f, 0.15089490f, 0.01731127f, -0.06660113f, 0.11508814f, 0.02908890f, 0.02719763f, 0.03108493f, 
    -0.00929036f, 0.01538406f, -0.09896304f, -0.12685543f, 0.03524085f, 0.00103287f, -0.01606437f, 0.09031547f, 
    0.11750749f, 0.16611937f, 0.11596704f, 0.07136216f, -0.09643042f, 0.04040407f, 0.19865425f, 0.23391296f, 
    0.07099214f, -0.21507283f, -0.01569766f, 0.32551971f, -0.04909886f, 0.09346958f, 0.10550497f, -0.21028797f, 
    -1.01557744f, -0.66709286f, -0.04229676f, -0.73071623f, -0.01181531f, -0.21594384f, -0.13450189f, -0.45266101f, 
    -0.05639857f, 0.03257354f, 0.01955511f, -0.19294834f, -0.77167678f, 0.11743145f, -0.21903360f, -0.08419026f, 
    -0.15270694f, -0.19082005f, -0.21472241f, 0.19053431f, 0.09961917f, 0.00448986f, 0.13819617f, 0.01652974f, 
    -0.23366171f, 0.18001065f, 0.08556218f, -0.08193441f, 0.27631667f, -0.15791152f, 0.08276316f, 0.08768485f, 
    -0.04560188f, 0.02850326f, -0.14239885f, 0.24158046f, -0.22573364f, 0.21513441f, 0.33575809f, 0.06233168f, 
    -0.07835135f, -0.01896185f, -0.08047480f, 0.16225371f, 0.09708153f, 0.03510425f, 0.04685222f, 0.14965427f, 
    0.08167556f, -0.07381020f, -0.15178560f, -0.07407814f, 0.01047369f, -0.00648090f, -0.03515018f, 0.10500532f, 
    -0.08228298f, -0.07207427f, -0.03069671f, -0.20360088f, -0.28059459f, -0.03746372f, -0.05162840f, 0.22837707f, 
    -0.07268740f, 0.29385689f, -0.20360859f, -0.05502032f, 0.08681107f, 0.05458656f, 0.07716886f, -0.06321033f, 
    -0.73500550f, -0.77753145f, -0.38624594f, 0.32252195f, -0.25023484f, 0.07882536f, -0.01660294f, -0.12771583f, 
    0.00551321f, 0.07054156f, 0.01437648f, -0.00032597f, -0.96324515f, -0.77202690f, -0.49071744f, -0.58805090f, 
    0.02978253f, -0.31963211f, -0.25489545f, -0.44904107f, -0.08005437f, -0.15781897f, 0.11896665f, -0.02538737f, 
    -0.29606166f, 0.16218121f, 0.41488922f, -0.18307310f, -0.02390439f, -0.26509893f, 0.07569958f, 0.07771313f, 
    -0.05506197f, 0.13915010f, 0.03083604f, 0.28132519f, -1.06201625f, -0.91535819f, 0.17950690f, 0.42222399f, 
    0.19559489f, 0.02089179f, -0.05975810f, -0.22587201f, 0.00496304f, 0.19648360f, 0.06169535f, 0.17018025f, 
    0.45989496f, 0.24328259f, 0.05035032f, 0.04690756f, -0.03947983f, -0.16211668f, -0.19832301f, 0.02794507f, 
    -0.18531248f, -0.08017857f, 0.05779639f, 0.04998242f, -0.06846108f, 0.05786990f, 0.20983699f, -0.44718117f, 
    0.05779523f, 0.16196384f, -0.04391886f, -0.15603927f, 0.08043084f, 0.07428357f, 0.04074665f, 0.16424212f, 
    -0.08888921f, -0.11689404f, 0.07947174f, 0.02521925f, 0.16727248f, -0.04312044f, 0.09654743f, -0.03591568f, 
    0.05670928f, -0.14477825f, 0.11141760f, -0.01402638f, -0.27807924f, 0.74538225f, -0.53567278f, 0.29798353f, 
    -0.19375822f, 0.21809086f, -0.03137395f, 0.32210085f, 0.08280163f, 0.16221984f, 0.05515715f, -0.15263402f, 
    0.68087894f, 0.02203968f, 0.14054753f, 0.05293846f, 0.00108097f, -0.03376575f, 0.17239852f, 0.07342493f, 
    0.05926731f, -0.16274296f, 0.24507914f, -0.13587743f, -0.34199834f, -0.18009947f, -0.12423246f, -0.02469476f, 
    0.02938533f, 0.07112879f, 0.03592083f, 0.03391132f, -0.01773152f, 0.00499401f, -0.06173898f, 0.10865200f, 
    -1.02767622f, -0.55811465f, 0.28296894f, 0.58778745f, -0.03863249f, -0.09670686f, 0.07261919f, 0.06351978f, 
    -0.03967866f, 0.08749364f, 0.14998028f, -0.05935671f, -0.00919881f, -0.11154654f, -0.12756748f, -0.00618024f, 
    -0.32091609f, -0.18016882f, -0.04394762f, -0.07333652f, -0.08039612f, 0.03643501f, -0.20482261f, -0.14472474f, 
    0.52901131f, 0.22824225f, -0.17584936f, -0.43589950f, 0.08500987f, 0.04838923f, -0.06757215f, -0.02352052f, 
    -0.17176135f, 0.16711636f, -0.07174271f, -0.17427093f, 0.02816035f, 0.13234402f, -0.40840796f, 0.08918566f, 
    -0.15321670f, -0.01953170f, 0.00841871f, 0.13229862f, -0.03743021f, 0.00607987f, 0.10293438f, 0.06233842f, 
    -0.11170591f, 0.19155526f, -0.06011961f, 0.10983782f, -0.18568367f, 0.01470988f, -0.22294065f, 0.03037396f, 
    -0.02644625f, 0.07798566f, -0.05402759f, 0.00630187f, 0.15470581f, -0.06116303f, -0.16461667f, 0.23221897f, 
    -0.00889629f, -0.04933029f, -0.08704312f, -0.01173744f, 0.00222294f, -0.00431572f, -0.01046025f, -0.12454352f, 
    0.73403686f, -0.00612698f, 0.42909208f, 0.14094602f, -0.06218715f, -0.02143182f, -0.11761282f, -0.15003793f, 
    -0.00767537f, -0.10424744f, -0.03500644f, -0.03467285f, -0.27468795f, -0.43223235f, -0.30333656f, -0.12617892f, 
    -0.16143788f, -0.10123559f, 0.02374050f, -0.06180955f, 0.19268721f, -0.00040261f, -0.03755473f, -0.11413883f, 
    -0.08601438f, 0.17322791f, 0.02050783f, 0.28553334f, 0.02146021f, -0.10193752f, 0.09337304f, -0.09276211f, 
    0.11650351f, 0.00700588f, 0.00082712f, -0.09991983f, 0.17157255f, -0.27205563f, -0.09614757f, -0.07795680f, 
    0.17882335f, 0.10776357f, 0.11771549f, 0.14201806f, 0.14057940f, 0.02146831f, 0.27025273f, 0.01411505f, 
    0.10440326f, 0.09241045f, -0.23759465f, 0.06180387f, 0.07091641f, -0.05407034f, 0.00934074f, -0.06888451f, 
    0.03761633f, 0.09720132f, -0.16475485f, 0.07552992f, 0.15628733f, -0.43480816f, -0.55368698f, -0.65579933f, 
    -0.05007263f, -0.13852052f, -0.31768817f, 0.06722965f, 0.09726335f, 0.06554437f, -0.02449125f, -0.08092095f, 
    0.42319420f, -0.02394060f, -0.22337478f, -0.29033497f, -0.21405019f, 0.16038890f, 0.11931127f, 0.09674454f, 
    -0.01790184f, -0.00480296f, 0.08454881f, 0.05209803f, -0.09526910f, -0.14343399f, -0.73538303f, 0.41825274f, 
    -0.02984517f, -0.03816424f, -0.03309261f, -0.15565147f, 0.18795727f, -0.09168873f, 0.04717183f, -0.03662879f, 
    -0.06885704f, -0.03563252f, -0.05478279f, -0.11698116f, 0.10209689f, -0.05945177f, 0.08919422f, -0.04793111f, 
    0.10059056f, -0.11043535f, -0.14158885f, -0.31925610f, 0.50432104f, -0.07413821f, -0.31760800f, -0.23425357f, 
    -0.10110438f, 0.05736187f, 0.04264782f, -0.05375249f, -0.10168096f, 0.02306255f, 0.05111733f, -0.13660079f, 
    -0.67113709f, 0.01999866f, 0.34988290f, 0.62551171f, -0.16870299f, -0.07974449f, -0.14292480f, 0.00655293f, 
    -0.07009051f, -0.08100168f, -0.03515568f, -0.02239633f, 0.49495038f, -0.93461555f, -0.00041564f, -0.06494246f, 
    -0.11113761f, 0.08442079f, 0.08120258f, -0.18497242f, -0.07308942f, 0.08981799f, 0.04298687f, -0.04020887f, 
    0.15220012f, -0.05006247f, -0.06694462f, -0.04338660f, -0.07075002f, 0.09877682f, -0.01515005f, -0.04905067f, 
    -0.03372039f, 0.01995064f, -0.09905180f, -0.06687649f, 0.35695410f, -0.21067666f, -0.01104424f, -0.24523509f, 
    0.01332246f, -0.03436378f, -0.04836865f, -0.06712783f, 0.04851666f, -0.02232595f, -0.01162348f, -0.01994545f, 
    0.00362767f, 0.10116921f, 0.07524508f, -0.13805063f, -0.05518485f, 0.03320739f, -0.06080054f, 0.00365257f, 
    0.07653648f, -0.02232308f, -0.08262163f, -0.12053038f, 0.32939756f, 0.05438472f, -0.07185553f, -0.09598003f, 
    -0.11934417f, 0.00076892f, -0.11556970f, 0.02281623f, -0.04929551f, 0.06279715f, 0.04191590f, -0.10505247f, 
    -0.12770492f, -0.44266558f, -0.17364377f, -0.22770348f, 0.08269789f, -0.07171619f, -0.07258139f, 0.21365070f, 
    -0.02392031f, -0.02481057f, -0.11791097f, 0.02392740f, -0.73858780f, 0.08629613f, -0.32858339f, 0.55514306f, 
    -0.05516350f, 0.02324890f, 0.20109832f, 0.07888830f, 0.02029774f, -0.04634871f, 0.01490277f, -0.01229591f, 
    0.41037151f, -0.06900092f, -0.21563175f, -0.45733622f, -0.06827870f, 0.10219440f, 0.13676980f, 0.05844656f, 
    -0.03113333f, 0.05837556f, -0.02687584f, -0.09098473f, 0.00418836f, 0.49082488f, 0.60186869f, 0.01332024f, 
    0.00492159f, -0.20955338f, 0.19128206f, 0.08256422f, 0.06184576f, -0.03119368f, 0.06909268f, -0.05997007f, 
    0.17417422f, -0.30248991f, -0.33769855f, -0.03204373f, 0.03908181f, 0.02778900f, -0.02264494f, 0.02364102f, 
    0.01474245f, -0.04698261f, 0.08672908f, 0.12056166f, 0.10299324f, 0.16802858f, -0.22170572f, 0.06652703f, 
    -0.26630723f, 0.13235195f, -0.15606919f, 0.02220946f, -0.12002458f, 0.07413028f, -0.09918360f, -0.08030844f, 
    0.03096406f, 0.13969122f, -0.01276194f, -0.01365211f, -0.08150556f, -0.15518916f, 0.12751366f, -0.19684832f, 
    -0.16695625f, 0.01339398f, 0.10073495f, 0.03800274f, -0.76853663f, -0.52953488f, -0.13028103f, -0.01169651f, 
    -0.02149089f, -0.07348378f, 0.15849294f, -0.05076030f, -0.03050745f, 0.00403630f, 0.05730739f, -0.00139884f, 
    -0.11036428f, 0.26462698f, 0.01044751f, -0.03697428f, -0.10066675f, 0.08202107f, 0.05217253f, -0.04667264f, 
    -0.13885565f, -0.13210204f, -0.10069430f, -0.22809805f, -0.20378262f, 0.20392911f, -0.16966781f, -0.02118821f, 
    0.11066955f, -0.09781655f, 0.07834558f, -0.05665044f, -0.00060928f, 0.09513800f, 0.02249849f, -0.01977964f, 
    0.16922073f, -0.50343573f, -0.43556565f, -0.69190186f, -0.00759288f, 0.34470320f, -0.17446601f, 0.03505681f, 
    0.12211802f, 0.01311709f, -0.11499887f, 0.08593483f, 0.08603372f, 0.03089077f, 0.02728625f, -0.03201859f, 
    0.00649862f, -0.01149617f, 0.02831869f, -0.01453763f, 0.00733124f, -0.00044642f, 0.04210818f, 0.07654174f, 
    0.13981958f, 0.02655935f, -0.24100141f, -0.27278298f, -0.10185853f, -0.23892881f, -0.02025116f, -0.00231097f, 
    0.14443980f, 0.08094829f, 0.15496667f, 0.23947452f, -0.15254256f, 0.07056405f, 0.07777347f, -0.01911721f, 
    0.02285002f, 0.04915819f, -0.34742081f, -0.13353018f, -0.09743338f, -0.11474794f, -0.09123863f, -0.09584843f, 
    -0.39707136f, 0.02546141f, 0.25075954f, 0.27197474f, -0.10016948f, -0.12270971f, 0.07191404f, 0.07321347f, 
    0.14712809f, -0.06229837f, 0.18441372f, 0.15401648f, 0.73229998f, 0.30251205f, -0.07253660f, -0.01600763f, 
    0.41400313f, -0.04229914f, -0.11773425f, 0.04158875f, 0.03653155f, 0.17076284f, 0.13889761f, 0.21627077f, 
    0.81635469f, 0.21764612f, -0.11729132f, -0.54778457f, 0.14906353f, -0.04977525f, 0.01997267f, 0.06502212f, 
    -0.12336216f, 0.11800542f, -0.08808947f, -0.13225119f, -0.21534437f, -0.30741888f, 0.06172536f, 0.07975905f, 
    0.00105605f, 0.09824104f, -0.00169876f, 0.01853225f, -0.31487373f, -0.12982990f, -0.08297613f, -0.40151450f, 
    -0.66108030f, 0.28408837f, -0.31085649f, 0.00325294f, -0.04522397f, 0.03295561f, -0.28570005f, 0.04390094f, 
    0.00463941f, 0.03090341f, 0.04437618f, 0.18242967f, 0.07823740f, -0.05204896f, -0.06248694f, 0.08664727f, 
    -0.04129401f, -0.00660467f, -0.14414939f, -0.11350605f, 0.12823911f, -0.23108169f, -0.19559467f, -0.35867923f, 
    -0.05210864f, -0.20843130f, -0.10315149f, -0.06106711f, -0.11685226f, -0.11914390f, -0.20628944f, -0.06051903f, 
    -0.14611232f, -0.16520484f, -0.01405476f, -0.26608434f, 0.00639850f, -0.40393743f, -0.26460046f, -0.05436868f, 
    0.21445595f, -0.00485450f, 0.04885248f, -0.09891246f, -0.04713988f, -0.10984835f, -0.12264091f, 0.09863595f, 
    0.17782153f, -0.16033576f, -0.40298766f, 0.06771362f, 0.11895592f, -0.09835998f, 0.26120067f, 0.05666092f, 
    0.17067745f, 0.00347654f, 0.07902885f, 0.04642093f, 0.07970252f, -0.19223662f, -0.02318314f, 0.07804299f, 
    0.27676517f, 0.27681541f, -0.05276920f, 0.26219973f, -0.31703559f, -0.17827521f, -0.22510283f, -0.49734497f, 
    0.04317295f, 0.07204694f, -0.16055684f, -0.23598659f, -0.08951319f, -0.12978388f, -0.12645756f, -0.16691147f, 
    -0.08059572f, -0.02779128f, -0.22795689f, -0.06910720f, 0.21600682f, -0.03181411f, -0.22378747f, -0.19856194f, 
    0.07471082f, -0.11534289f, 0.14248455f, 0.00978543f, 0.17042908f, -0.05675041f, 0.04612083f, 0.15484233f, 
    0.20361336f, -0.37341285f, -0.46190774f, -0.37622586f, 0.02443265f, -0.33332896f, 0.00247471f, 0.07926220f, 
    0.17720769f, 0.15799750f, 0.23425230f, 0.03533181f, 0.23815207f, -0.10093742f, -0.19612688f, -0.13699730f, 
    0.02475647f, -0.09664384f, -0.16730143f, 0.00726829f, 0.25882497f, 0.17386951f, -0.06378704f, -0.00515674f, 
    0.01613385f, 0.10832180f, 0.03051692f, 0.10394569f, -0.08792908f, -0.18668656f, 0.07540151f, -0.07817688f, 
    0.11028351f, 0.01413827f, 0.19736746f, 0.16117750f, -0.20790271f, -0.10867299f, -0.17264849f, 0.06751158f, 
    -0.14449047f, 0.04832537f, -0.03366557f, 0.04613328f, 0.20392653f, -0.42603740f, 0.17785649f, -0.01074553f, 
    -0.05296855f, 0.10333972f, 0.03271696f, -0.23617673f, 0.01773307f, -0.06552902f, 0.01524136f, 0.00157620f, 
    -0.04287332f, -0.01384327f, 0.01098209f, 0.08751396f, 0.71777564f, 0.19184555f, 0.09517774f, -0.33873206f, 
    0.13831444f, -0.01645379f, -0.06933835f, -0.10993264f, -0.05586028f, 0.02927234f, 0.01768411f, 0.11014334f, 
    0.40625498f, -0.07186946f, -0.08774102f, 0.11378279f, 0.12716413f, 0.07772803f, 0.14587598f, -0.11251337f, 
    0.10660950f, -0.10048611f, -0.00023298f, -0.02828057f, -0.71722138f, -0.98684299f, -0.37281078f, -0.24018908f, 
    -0.09002716f, 0.10329334f, -0.03307089f, -0.07821221f, 0.06114322f, 0.04996831f, 0.00304805f, 0.08990292f, 
    -0.68366033f, -0.45955774f, -0.18517962f, 0.05114124f, 0.05313595f, 0.14146966f, 0.22332416f, 0.01556314f, 
    0.13545938f, 0.13563319f, 0.12579122f, 0.26511875f, -0.44732729f, -0.05002112f, -0.14642847f, 0.03250892f, 
    -0.13094112f, -0.09131978f, -0.02428471f, -0.25101912f, -0.02364204f, 0.13703153f, 0.04517118f, 0.20079419f, 
    -0.35137618f, -0.31354365f, -0.03113982f, 0.13723931f, -0.00133229f, 0.07512578f, 0.00686228f, 0.13064960f, 
    0.09080791f, 0.00098998f, -0.11621432f, -0.08757109f, 0.10796999f, 0.27951697f, 0.01639475f, 0.00794141f, 
    0.04739644f, -0.24836232f, 0.05143450f, 0.21377836f, 0.09637172f, 0.07841317f, -0.03904361f, 0.16407147f, 
    -0.30556628f, 0.02290348f, 0.04321680f, 0.01501518f, 0.06203858f, 0.09843287f, 0.06675980f, 0.03091725f, 
    0.05519022f, -0.14837344f, 0.00769946f, 0.03381665f, -0.31807053f, -0.85482651f, -0.00226596f, 0.19706142f, 
    -0.03926716f, 0.36471161f, 0.07831544f, -0.18779366f, 0.05865464f, -0.22966498f, -0.16015130f, 0.12323902f, 
    -0.64930207f, 0.13053401f, 0.00780608f, 0.10539225f, 0.00736690f, 0.08757868f, -0.11208908f, 0.09020367f, 
    0.03425958f, -0.01945954f, 0.05566792f, 0.04816243f, -0.20606467f, 0.02043844f, 0.17037076f, 0.08394831f, 
    0.04375893f, -0.08742291f, -0.00132256f, -0.20475967f, 0.01626891f, 0.00465481f, 0.07456172f, 0.09762765f, 
    -0.42504236f, -0.56858265f, -0.51741946f, 0.53791124f, -0.00715912f, 0.03962571f, 0.21318147f, 0.01149013f, 
    -0.07186323f, 0.03307177f, -0.00733842f, -0.07840245f, -0.08971194f, 0.01290693f, -0.01429842f, -0.07955342f, 
    0.00263084f, -0.06293004f, 0.00034370f, -0.01220524f, 0.05522745f, 0.11299480f, 0.07210890f, 0.06928889f, 
    -0.15955313f, -0.08974548f, 0.19507381f, 0.51918966f, 0.14975527f, 0.20264244f, -0.15027525f, 0.05437405f, 
    0.13757503f, -0.11842310f, -0.06631258f, -0.06420571f, 0.14261417f, 0.16428657f, -0.80957961f, 0.10555691f, 
    0.11408123f, 0.02331518f, 0.18670797f, 0.25828931f, -0.01149363f, -0.05398028f, -0.00407010f, -0.01756961f, 
    -0.64691240f, 0.47842428f, -0.43677172f, 0.06063749f, 0.04887895f, -0.07268792f, 0.28415969f, -0.00334194f, 
    -0.05231600f, 0.02129977f, -0.25970986f, -0.02270195f, -0.27949336f, -0.07612010f, -0.50555664f, 0.33418739f, 
    0.08892269f, -0.21558274f, 0.01056782f, -0.03362880f, 0.13144481f, -0.01125335f, -0.25397363f, -0.11382685f, 
    -0.60959202f, -0.07486018f, -0.32723168f, 0.45203534f, 0.04300839f, 0.14963315f, 0.01007805f, -0.21490805f, 
    0.22585690f, -0.02308070f, 0.09580804f, 0.01284696f, 0.06052339f, 0.21258144f, 0.36965132f, -0.21276256f, 
    -0.08433943f, -0.16375798f, -0.09796690f, -0.10192405f, -0.04515391f, -0.05831773f, 0.10856494f, -0.06056103f, 
    -0.48708904f, 0.27661160f, -0.68461847f, 0.33867607f, 0.32590309f, -0.15577197f, -0.00298273f, -0.07102301f, 
    0.25306252f, -0.08899723f, -0.27635592f, -0.18193409f, 0.13776676f, 0.01900895f, 0.41633052f, -0.22800325f, 
    -0.06165477f, -0.17650767f, -0.02148282f, 0.01444495f, 0.12524664f, 0.04498880f, 0.03799021f, -0.00554168f, 
    -0.05543404f, 0.09588911f, 0.16531844f, 0.25974283f, 0.03137811f, 0.01496337f, 0.05363109f, -0.01843724f, 
    -0.02945373f, 0.06620239f, 0.25091717f, 0.32069281f, -0.21116140f, -0.21477005f, -0.26213783f, 0.12271439f, 
    -0.28309849f, 0.14561886f, -0.22792420f, 0.14022797f, 0.16522016f, -0.02596360f, -0.00368998f, 0.05178826f, 
    -0.18513538f, -0.08259580f, -0.33850771f, -0.17254394f, -0.07473022f, -0.07411288f, 0.03759782f, -0.01944080f, 
    -0.07684931f, -0.22388692f, -0.14805597f, -0.12454239f, -0.29352009f, 0.34445319f, -0.12611359f, -0.01415730f, 
    -0.02115013f, -0.26020554f, 0.00403009f, -0.08349964f, 0.04837158f, 0.11464822f, -0.02606596f, 0.20268472f, 
    -0.13159280f, -0.15324019f, 0.16816476f, 0.12432611f, 0.22174609f, 0.00610386f, 0.06563321f, 0.03317206f, 
    0.03877428f, 0.25131291f, 0.04848135f, 0.18994890f, -0.15410055f, 0.33965755f, -0.23171557f, 0.06765348f, 
    0.25459066f, -0.30907968f, -0.11596038f, -0.05390062f, -0.16509829f, -0.17969939f, 0.01158055f, -0.23099436f, 
    -0.35176665f, -0.25384006f, -0.11722871f, -0.00668484f, -0.11362554f, -0.16365527f, 0.07776786f, 0.23820168f, 
    0.05827292f, 0.07557897f, 0.03626211f, -0.01600295f, 0.02042554f, 0.04996515f, 0.31373489f, 0.24465337f, 
    0.18759790f, -0.13753079f, -0.00139127f, -0.11095409f, -0.17432445f, -0.06452284f, 0.00191219f, -0.12904404f, 
    0.47556633f, -0.40583488f, 0.03590385f, -0.17819472f, 0.09108114f, -0.12915552f, 0.08885773f, -0.03081674f, 
    -0.17201018f, -0.00853012f, -0.09484567f, -0.02516806f, 0.07965530f, -0.16336071f, 0.16307993f, 0.27661306f, 
    0.01569648f, 0.01103581f, -0.20390098f, -0.23222989f, -0.08267549f, -0.11282130f, -0.07418491f, 0.16220495f, 
    -0.17864437f, -0.07604977f, -0.11896334f, 0.08837125f, 0.13722944f, 0.12334336f, 0.15630494f, -0.05751854f, 
    0.21437870f, 0.03422853f, -0.15372777f, -0.10655909f, -0.30221733f, -0.41406915f, -0.63328183f, 0.04617685f, 
    -0.02303184f, 0.04548165f, 0.10651837f, -0.10612016f, -0.01425929f, -0.09264200f, 0.01579223f, -0.03203172f, 
    -0.16621210f, -0.17655757f, 0.14796925f, 0.11475324f, 0.01449443f, -0.13835627f, -0.08854595f, 0.07847306f, 
    0.01441252f, 0.05007667f, 0.04912683f, -0.05712135f, 0.15169664f, 0.07384355f, -0.07267424f, -0.40977585f, 
    -0.04816190f, 0.02097160f, 0.22477898f, 0.27424812f, 0.01196789f, 0.01467626f, 0.00352979f, -0.05882983f, 
    0.55177736f, 0.08658556f, 0.36081094f, -0.16864958f, -0.03935685f, -0.38561699f, -0.25026673f, -0.17859145f, 
    -0.26732469f, 0.09432306f, -0.18658766f, -0.03254919f, 0.09601722f, -0.52551430f, 0.30607644f, -0.55197853f, 
    -0.09073567f, 0.10715503f, -0.07912044f, 0.17087449f, 0.05510743f, 0.13559589f, 0.01958039f, -0.05737032f, 
    -0.02279784f, 0.60098034f, 0.22550316f, -0.29360634f, -0.03505037f, -0.26225176f, -0.00071743f, -0.14472060f, 
    -0.02060833f, -0.06826152f, 0.03437719f, 0.08904002f, -0.16626543f, -0.11622047f, -0.36821806f, 0.15604463f, 
    -0.03792411f, 0.13162832f, 0.08924671f, 0.17208023f, -0.03533483f, 0.03196130f, 0.14417988f, 0.01794902f, 
    -0.06551942f, -0.02943418f, -0.13009556f, -0.38425523f, 0.09915740f, 0.08383886f, 0.02697467f, 0.14149179f, 
    0.01487102f, 0.00541002f, -0.15826286f, 0.01357201f, 0.25820905f, -0.21089171f, 0.90500188f, -0.48049352f, 
    0.15917554f, -0.32780567f, 0.13436091f, 0.02780000f, -0.05585278f, 0.08807438f, 0.03574267f, -0.05318059f, 
    -0.12163074f, 0.14874974f, -0.36911160f, -0.44005704f, -0.08365214f, 0.00635402f, 0.16381279f, 0.15619093f, 
    -0.04110615f, -0.01506749f, -0.04664471f, -0.04650247f, -0.23930290f, -0.40711820f, -0.09305041f, -0.09506470f, 
    0.13928117f, -0.00905144f, 0.01958819f, 0.12976970f, 0.01253362f, -0.05197906f, -0.04605445f, -0.08155715f, 
    -0.11104789f, -0.31745499f, 0.01969339f, -0.80886316f, -0.11494882f, -0.01450549f, 0.10733701f, -0.22093618f, 
    0.11095601f, -0.00076836f, 0.08018323f, -0.07489017f, 0.20779625f, -0.26198423f, -0.04932319f, 0.14117390f, 
    0.26188490f, 0.13418534f, 0.18574727f, 0.07924522f, 0.27876160f, -0.12933542f, 0.02826213f, -0.03262793f, 
    -0.41124234f, 0.16450371f, -0.17151791f, 0.02794478f, 0.03379333f, 0.06772537f, -0.03537340f, 0.04194900f, 
    -0.02594090f, -0.12971853f, 0.06448847f, -0.05007757f, 0.06333381f, 0.00590101f, -0.01131311f, -0.07245790f, 
    -0.08864387f, 0.11033504f, 0.07773613f, -0.16542639f, -0.08008004f, 0.00957650f, -0.10385566f, -0.14405064f, 
    -0.13129207f, -0.45851111f, 0.02942471f, 0.01048203f, 0.00413454f, -0.04981483f, -0.14341855f, 0.08520822f, 
    0.09879533f, 0.22751644f, 0.17784159f, 0.08681470f, -0.12381034f, 0.31664309f, 0.11378904f, -0.39157736f, 
    -0.24518822f, 0.21391506f, 0.13256335f, -0.26044682f, 0.01010154f, -0.19131629f, 0.19188178f, 0.25453216f, 
    0.14997935f, 0.47167826f, -0.39498654f, -0.46694681f, -0.22889592f, 0.09535153f, 0.14013033f, 0.28192782f, 
    -0.26010236f, -0.16181071f, -0.40067676f, -0.24085128f, 0.04406862f, 0.05869691f, -0.22926489f, -0.02301211f, 
    -0.02090101f, -0.21327838f, -0.11360182f, 0.12417109f, -0.14389473f, -0.20746182f, -0.17236325f, -0.52761191f, 
    -0.53822339f, 0.04237708f, 0.14870410f, -0.07644866f, 0.09255683f, -0.11335636f, -0.08989830f, 0.02078476f, 
    -0.20316873f, 0.08603872f, 0.01097193f, -0.00399255f, -0.79269642f, 0.16428281f, -0.04684006f, -0.19810441f, 
    0.13257724f, 0.00017486f, -0.27817336f, 0.18224989f, -0.22069940f, -0.22298644f, -0.40237001f, -0.18257661f, 
    0.06181597f, -0.10697792f, 0.22214717f, -0.11246118f, -0.16381559f, 0.14900284f, 0.05262960f, -0.21720825f, 
    0.17464106f, -0.16791861f, -0.51839149f, -0.18740317f, -0.39209124f, 0.32663247f, -0.36597151f, 0.29840925f, 
    -0.20278260f, -0.03155010f, 0.02640197f, 0.14026058f, -0.05483174f, 0.21133865f, 0.00026570f, 0.12210020f, 
    -0.01563457f, -0.06758572f, 0.64053804f, 0.13411246f, -0.09237388f, 0.16499245f, -0.01521761f, 0.04726619f, 
    0.06400657f, -0.03289516f, 0.38239607f, 0.08809367f, 0.14638452f, 0.20448267f, -0.03415626f, -0.20896612f, 
    -0.11762862f, -0.35184106f, 0.33400917f, 0.01328724f, -0.00383003f, 0.03779633f, -0.66755301f, -0.28683168f, 
    -0.77087337f, 0.00846529f, 0.09763020f, -0.21615492f, -0.11990765f, -0.08139036f, -0.05548511f, -0.00192113f, 
    -0.01393930f, -0.26227140f, -0.15730684f, -0.07488996f, -0.09860270f, 0.42067578f, 0.56399602f, 0.11798007f, 
    -0.16334137f, 0.10336472f, -0.08149272f, 0.04522158f, 0.05676455f, -0.02773249f, 0.29112417f, -0.04401385f, 
    -0.13735022f, -0.42281571f, 0.16820829f, -0.13270538f, -0.11296067f, -0.10799920f, -0.01517212f, -0.03053307f, 
    0.11586722f, 0.16661063f, 0.09972836f, 0.08303169f, -0.51040751f, 0.30122781f, -0.20596619f, 0.08645519f, 
    -0.00570865f, 0.15306310f, 0.08709136f, 0.12412870f, -0.09142012f, 0.20040491f, -0.27470657f, 0.08341019f, 
    -0.02940769f, 0.28220829f, 0.19594237f, 0.16440749f, 0.12939015f, 0.03932437f, -0.04329061f, 0.18690869f, 
    0.17187768f, 0.06638879f, 0.21269514f, 0.09313875f, -0.74462438f, 0.49882311f, 0.18556823f, -0.03337124f, 
    0.09929927f, 0.01075375f, 0.07541383f, 0.07920570f, -0.37389427f, 0.01878035f, -0.02754281f, 0.08680435f, 
    -0.09941010f, 0.03231977f, -0.60798800f, -0.16384022f, -0.45157203f, 0.06360207f, 0.27051628f, -0.16647570f, 
    -0.08595796f, 0.27301654f, -0.17477430f, 0.04373213f, -0.13783538f, 0.37616903f, 0.27872947f, 0.16928108f, 
    -0.33603969f, 0.16762562f, 0.05800770f, 0.00409075f, -0.02347685f, 0.06134931f, 0.20817924f, -0.07871912f, 
    -0.43159139f, 0.04022901f, -0.33614856f, 0.00288477f, -0.10330993f, -0.06905327f, -0.44805828f, -0.09255563f, 
    -0.03129253f, 0.20767343f, -0.04874903f, -0.11756845f, -0.31300199f, -0.01841583f, -0.42321706f, 0.23293780f, 
    -0.06139423f, -0.20278887f, -0.11396942f, -0.11800689f, 0.11589697f, 0.20011370f, 0.06620102f, 0.10103679f, 
    0.45616582f, 0.08223961f, 0.15930362f, 0.21520725f, -0.00422761f, -0.04683037f, 0.30352059f, -0.08584852f, 
    0.08195182f, 0.16495359f, 0.03462395f, 0.20516323f, -0.00874175f, -0.44866240f, 0.32900298f, 0.43017969f, 
    0.04297075f, 0.12078571f, -0.12004104f, 0.06950790f, 0.00912974f, -0.16457963f, -0.15862831f, 0.03832117f, 
    0.41065699f, -0.25228870f, 0.28433213f, -0.02856126f, -0.03574102f, 0.00616308f, 0.23359309f, 0.05166490f, 
    -0.17195821f, -0.00718671f, 0.00595157f, 0.03069321f, 0.23842210f, 0.53650308f, -0.17282484f, 0.18331945f, 
    -0.05079544f, 0.13528156f, -0.00362990f, 0.09470969f, -0.02752328f, 0.03017139f, -0.19486225f, -0.06874236f, 
    0.06257381f, -0.41755676f, 0.15644188f, -0.32663542f, -0.16204084f, 0.06050259f, -0.07681159f, 0.01174264f, 
    -0.10804506f, 0.11002756f, 0.19712281f, -0.20671263f, -0.44033334f, -0.05655534f, -0.37125874f, 0.20833287f, 
    0.07108427f, -0.18723787f, -0.00720809f, 0.32889873f, 0.09439696f, -0.16431855f, -0.23230301f, -0.02679604f, 
    0.17592429f, -0.28152764f, 0.41591883f, 0.28757030f, -0.11817704f, 0.07498264f, 0.10316892f, 0.04506869f, 
    -0.14738187f, -0.00913138f, 0.04423308f, 0.04662135f, -0.20203510f, -0.46640447f, 0.26642105f, 0.07598847f, 
    -0.12583560f, 0.07466727f, -0.07040732f, 0.37477875f, 0.05519566f, -0.06708185f, 0.25956017f, 0.33908260f, 
    0.30692193f, -0.37351134f, -0.01835743f, 0.11511833f, 0.14732660f, -0.14056520f, -0.03048964f, -0.10271157f, 
    -0.07538716f, -0.08203529f, -0.18736364f, -0.31015742f, -0.42232305f, -0.22596225f, -0.39455980f, -0.43755317f, 
    -0.07304550f, 0.09741148f, -0.09255762f, -0.05506245f, -0.05130331f, -0.01814016f, 0.18250628f, 0.13926837f, 
    -0.81495601f, -0.14867885f, -0.64053059f, 0.12739471f, 0.25410485f, 0.04910819f, 0.13844407f, -0.13123260f, 
    -0.12310026f, -0.04472227f, 0.20469037f, 0.00001365f, 0.45724645f, -0.16842771f, 0.61505109f, -0.27122384f, 
    -0.05715834f, -0.34720829f, 0.02975447f, -0.04999631f, -0.07633491f, -0.07415138f, 0.10298862f, -0.03055521f, 
    0.28003693f, -0.10134826f, 0.41567743f, 0.05200929f, 0.13851348f, -0.17618883f, 0.17765957f, 0.22643870f, 
    -0.15250455f, 0.02069589f, -0.08557834f, 0.06342594f, 0.50508046f, -0.03136880f, 0.05886882f, 0.12413491f, 
    0.14543426f, -0.10471684f, 0.12076408f, 0.06071579f, -0.03503885f, 0.05629515f, -0.03976301f, -0.26550734f, 
    0.03747062f, -0.48777249f, 0.06092801f, -0.10244531f, 0.26627612f, 0.03103366f, 0.14863145f, 0.16446577f, 
    0.09011687f, 0.18783009f, 0.38418099f, 0.08322261f, -0.48324022f, 0.00985684f, -0.05701332f, -0.53348601f, 
    -0.11343925f, -0.07710722f, 0.05513002f, 0.01842411f, -0.08947144f, 0.07224749f, 0.12426280f, 0.02497433f, 
    0.85404313f, -0.17766482f, 0.59391081f, -0.31305343f, 0.03281893f, 0.23146781f, -0.25654122f, 0.03003442f, 
    -0.05346671f, -0.19091229f, 0.37341219f, 0.14014708f, -0.14147261f, -0.31983396f, -0.13125707f, 0.02446015f, 
    -0.17206103f, 0.00393747f, 0.14338785f, -0.18110573f, -0.01230822f, 0.14647375f, 0.04621020f, 0.03421079f, 
    -0.08286116f, 0.01269898f, 0.08407842f, -0.30087209f, -0.01123805f, 0.10474115f, -0.02181254f, -0.03171335f, 
    0.24622265f, 0.23125774f, 0.14169927f, 0.20858455f, 0.20957984f, 0.12373226f, -0.13728167f, -0.22564830f, 
    0.02786096f, 0.12217805f, 0.10082231f, -0.35360685f, 0.06289746f, -0.03782035f, -0.06133312f, -0.18530068f, 
    -0.00786295f, -0.02345848f, 0.23411198f, -0.39765799f, 0.29801050f, 0.01241251f, -0.17835268f, 0.03512358f, 
    -0.11364421f, -0.22729428f, -0.14887443f, -0.08549055f, 0.23763527f, -0.58820742f, 0.00063851f, -0.61502653f, 
    0.13097943f, -0.12692310f, -0.24579148f, 0.08869562f, 0.08323401f, 0.17124072f, 0.16576138f, 0.18151012f, 
    -0.32425034f, 0.13852540f, -0.17128722f, 0.02295329f, -0.03641262f, -0.11940209f, -0.01297969f, 0.07098506f, 
    -0.05967158f, 0.12109419f, -0.04298971f, -0.01500509f, -0.00649383f, -0.36396408f, -0.23141143f, 0.23729089f, 
    0.22817148f, 0.31219333f, -0.34091681f, 0.14511549f, 0.28794783f, -0.12911727f, -0.09268181f, 0.01137984f, 
    -0.13460444f, -0.58866912f, -0.15953395f, 0.43442178f, -0.08294538f, -0.16233636f, -0.19399863f, -0.05749404f, 
    0.02239208f, 0.16630548f, -0.11176623f, -0.06194514f, 0.19261476f, -0.24102628f, 0.11175505f, 0.26050243f, 
    0.01789351f, -0.01302238f, -0.21485573f, -0.14778318f, 0.19213547f, -0.02543241f, 0.09543004f, 0.01196009f, 
    -0.06511188f, 0.08304511f, -0.14724062f, -0.00661514f, -0.08618421f, 0.00799441f, -0.26905185f, -0.03478533f, 
    -0.27725762f, 0.05539802f, -0.03425945f, 0.15099393f, -0.56817389f, 0.16677602f, -0.55171257f, 0.45978859f, 
    0.15167655f, -0.04660238f, 0.02416037f, -0.16559361f, 0.00517792f, 0.14888451f, -0.12198304f, 0.13413356f, 
    0.18994805f, -0.13676605f, 0.32633170f, -0.06866930f, -0.09916773f, 0.20256598f, -0.06565501f, 0.08189590f, 
    -0.13545120f, -0.02227894f, 0.04676650f, 0.08366993f, -0.16756603f, -0.10162330f, 0.22588010f, -0.04020471f, 
    0.30977395f, -0.07493532f, 0.13570322f, -0.15224251f, -0.05085992f, -0.02854731f, -0.07780919f, 0.02634208f, 
    0.37358710f, -0.33117199f, 0.08908112f, -0.19345668f, 0.03351609f, -0.09099650f, -0.12941770f, 0.01637956f, 
    -0.06979295f, -0.05375574f, 0.01772675f, -0.00485988f, -0.72925365f, -0.38344485f, 0.16989921f, -0.06429718f, 
    -0.42165786f, -0.34373996f, -0.17409985f, -0.24171735f, 0.09614053f, -0.01221807f, -0.10448216f, -0.04154906f, 
    -0.50432312f, -0.03935149f, -0.42184395f, 0.11033611f, 0.07233832f, -0.06097552f, -0.21530947f, 0.23122993f, 
    -0.34793222f, -0.15989365f, -0.23741661f, -0.14034243f, -0.26866743f, 0.43705419f, -0.21467747f, 0.12142285f, 
    -0.14537860f, 0.33905524f, -0.20905982f, -0.04362516f, -0.00046594f, 0.10798201f, 0.02109627f, 0.14613067f, 
    -0.52619958f, 0.00110772f, 0.22114736f, 0.05411064f, -0.05469043f, 0.00756638f, 0.13618609f, 0.01566026f, 
    -0.09471727f, 0.02593721f, -0.30093250f, 0.03462721f, -0.28263053f, -0.15012409f, 0.41953498f, 0.37730068f, 
    0.20572805f, -0.02075955f, 0.23274490f, -0.17677036f, -0.02786629f, 0.01529509f, -0.00017912f, 0.15700938f, 
    0.29265213f, 0.10853536f, 0.16122338f, -0.23329858f, -0.19906016f, 0.08921776f, -0.09846887f, 0.17396434f, 
    0.03026579f, -0.01905081f, -0.09286781f, -0.07445639f, -0.24488407f, -0.11000496f, 0.17720294f, -0.01102536f, 
    -0.05200272f, 0.08228447f, -0.14675853f, 0.34280255f, -0.23301849f, 0.24577589f, 0.11146710f, -0.08454258f, 
    0.00006360f, 0.00521457f, 0.29142919f, -0.09376521f, -0.19960196f, -0.06334085f, 0.14807686f, -0.11546768f, 
    -0.22876525f, -0.19952631f, 0.06731762f, 0.24618332f, 0.44752607f, 0.32298914f, 0.46895409f, -0.46782809f, 
    -0.14045963f, 0.06660583f, -0.29647398f, 0.09056590f, -0.13809197f, 0.02734311f, -0.20615554f, -0.13287659f, 
    -0.15562403f, 0.34109974f, 0.11937812f, -0.61540383f, -0.07967912f, -0.04187062f, 0.20387672f, -0.08092490f, 
    -0.01437613f, 0.08579217f, 0.15466227f, 0.08645874f, -0.11412058f, 0.31068465f, -0.17425491f, -0.13192798f, 
    -0.06027134f, 0.01138324f, 0.10114820f, 0.03318265f, 0.03227591f, -0.02170421f, -0.10352370f, -0.15147680f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25115871f, 0.16676100f, 0.10567846f, -0.16844390f, -0.09648168f, 0.04662504f, 0.08574020f, -0.16262908f, 
    0.08590429f, 0.04029941f, 0.00075292f, 0.01580159f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
