#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.64040053f, 1.20641196f, 1.23653364f, 0.76485741f, 0.43071598f, -0.88668269f, -1.03120184f, 0.22435132f, 
    0.08755814f, 0.79822999f, 0.69658405f, 0.36099735f, -0.28388816f, 0.17023015f, -0.52109951f, -0.07516754f, 
    -0.31261238f, -0.01118023f, -0.00392311f, -0.28553659f, 0.44522670f, 0.09188662f, -0.09713602f, -0.45753992f, 
    -0.37725231f, 1.12216151f, 0.91199172f, -0.23656085f, 1.04972935f, 1.84899342f, 0.55431259f, 0.45182547f, 
    0.69532233f, 0.62640518f, 0.71994090f, 0.02040631f, -0.39394873f, 0.38269794f, -0.75390434f, 0.17869762f, 
    -0.08433969f, -0.20398180f, -0.17810610f, -0.57752430f, 0.01625342f, -0.11702899f, -0.32972741f, -0.17202239f, 
    0.02811043f, -0.21743314f, 1.76099706f, -0.14276664f, 0.79075444f, -0.30695987f, -1.16937900f, -0.48388365f, 
    -0.31885964f, -0.04156660f, 0.71677029f, 0.79140764f, 0.27593184f, 0.26358250f, -0.34809160f, -0.08117459f, 
    -0.04236645f, 0.14432713f, 0.25364944f, -0.17337848f, -0.33733228f, 0.11585926f, 0.26632994f, 0.01196560f, 
    0.02754303f, -0.04952082f, -0.23033524f, 0.26561657f, -2.20338798f, -0.42131254f, 1.15375400f, 0.13773791f, 
    -0.98902249f, 1.71104121f, 0.86614740f, -0.81883150f, 0.37594607f, 0.42219678f, 0.33608153f, -0.27597305f, 
    -0.16946591f, 0.26085126f, -0.37028199f, 0.03374708f, -0.01594134f, 0.14000784f, -0.16149069f, 0.22700681f, 
    -0.12346607f, 0.14674826f, 0.16015956f, 0.12506565f, -0.62644517f, -1.03092265f, -0.38492477f, -0.58513588f, 
    0.67096215f, 0.49374714f, -0.83151668f, -0.91534400f, -0.51129305f, -0.67727947f, -0.35682818f, 0.76725847f, 
    0.46236458f, 0.31682223f, 0.57836944f, 0.59144843f, 0.30280703f, 0.41147310f, 0.32544547f, 0.24306171f, 
    0.31450513f, -0.05775927f, -0.37854844f, -0.16878898f, 0.25755456f, 1.61705768f, 0.59188420f, -1.53853595f, 
    -0.23831047f, -0.47241774f, 0.82180083f, 0.70849305f, 1.07250428f, 1.06944776f, 0.57590574f, -0.41523668f, 
    0.03429307f, -0.21667080f, -0.20791532f, 0.08187065f, 0.10119104f, -0.40001252f, -0.34374607f, 0.09789895f, 
    0.31086785f, 0.17633291f, -0.14408974f, -0.20403393f, -0.09753507f, 0.13809298f, -1.10213673f, 0.30299938f, 
    -1.26052248f, -0.51579577f, -0.63900572f, 0.38014516f, -0.90955794f, 0.02077252f, 0.87065279f, -0.44601485f, 
    -0.75418741f, 0.08184376f, -0.20672102f, 0.38259661f, -0.24987435f, -0.34612980f, -0.00728294f, -0.31115693f, 
    0.09665207f, -0.20192856f, -0.17946996f, 0.22890766f, 0.27758282f, -0.25625494f, 0.03689931f, -1.17798615f, 
    0.76205987f, 0.65388966f, -0.25383133f, -0.05970703f, -1.95681798f, -0.33327886f, -0.03141432f, -0.79240167f, 
    -0.28757894f, -0.49807909f, 0.27567938f, -0.10100656f, -0.63422000f, -0.35986790f, -0.33762798f, -0.47782281f, 
    0.18675332f, -0.36406124f, -0.72218019f, -0.00924256f, 0.23259348f, -0.24627990f, 0.18676263f, 0.02498031f, 
    -0.96358353f, -1.32018304f, -0.78929389f, -0.95726645f, -0.25513569f, -0.92179793f, 0.62505627f, 1.04932594f, 
    -0.24573453f, 0.70790905f, 0.31812429f, 0.00386714f, 0.43804172f, -0.35635713f, 0.31418666f, -0.17644198f, 
    0.14374423f, -0.15144688f, -0.15498877f, 0.13330311f, 0.17147726f, 0.16864635f, 0.09762523f, 0.51979965f, 
    0.26116875f, 0.20839132f, 0.56466788f, -0.62479454f, -1.50144792f, -0.51620674f, -0.64892340f, 1.05119872f, 
    0.19710280f, -0.85763937f, -0.32014906f, 0.16670482f, -0.29765010f, -0.28340414f, -0.40459460f, -0.05945746f, 
    0.47677442f, 0.37443179f, 0.10610951f, 0.22552864f, -0.01347848f, 0.11925392f, 0.34110522f, -0.12617469f, 
    -0.07049809f, -0.00552922f, 1.54860020f, 1.17424440f, 0.84258586f, -0.94928390f, -1.13794017f, 0.59635061f, 
    0.12836997f, -0.58304048f, -0.82681304f, 0.04731895f, 0.86165553f, 0.18736590f, -0.54411387f, -0.00096729f, 
    -0.08009813f, 0.03336897f, -0.10623335f, 0.07602800f, 0.14234249f, 0.02378681f, -0.26457179f, 0.41832110f, 
    0.37654740f, 0.00360483f, 0.24736379f, -1.13260305f, -0.77139616f, -1.04538274f, -0.54757392f, -0.76327550f, 
    0.42269656f, 1.25019705f, 0.20345473f, 0.74964398f, 0.64952314f, -0.11741784f, -0.48713529f, -0.14616676f, 
    -0.92451811f, -0.27427638f, 0.15942208f, 0.17745054f, 0.33946803f, 0.05963826f, -0.45128179f, -0.06696310f, 
    -0.38647541f, 0.10221458f, -0.20678130f, 0.39801154f, -0.58993280f, -0.66371155f, -0.35741767f, -0.37626523f, 
    0.38870052f, -0.64368695f, -0.09462883f, 0.11813599f, -0.14415316f, -0.92076200f, -0.59336132f, 0.83022505f, 
    -0.38690180f, -0.14599377f, 0.08088792f, 0.45744535f, 0.17425251f, -0.54104728f, -0.89025462f, -0.19223705f, 
    0.19187008f, 0.34277883f, 0.62291628f, 0.30613002f, 0.39457420f, 1.59960878f, 0.94839013f, 0.91352803f, 
    0.86766887f, 0.43639153f, -0.35412869f, -1.00113773f, -0.17649731f, -0.62619174f, -0.40492249f, -0.27857211f, 
    -0.05193745f, 0.25442013f, 0.11255628f, 0.29668558f, 0.10901231f, 0.11850752f, 0.15969977f, 0.02607661f, 
    0.17355603f, 0.20629545f, -0.03423565f, 0.22558635f, 0.35387230f, 0.37710294f, 0.56817019f, -0.57960618f, 
    1.07785809f, 0.86806041f, 0.62436944f, 0.76472014f, -0.82545942f, 1.04354572f, -0.06612301f, -0.41615251f, 
    0.69455159f, -0.13441458f, -0.33762273f, -0.20562182f, -0.24835312f, 0.71159703f, 0.23575529f, -0.00720991f, 
    0.19259550f, 0.19658767f, 0.47444567f, -0.01766904f, 0.45470279f, -0.07638722f, 0.50248915f, 0.36453810f, 
    0.94618744f, -0.68361610f, -0.72460365f, -0.20018744f, 0.57561105f, -1.44082189f, -1.18412340f, 0.13472953f, 
    -0.74434662f, 0.06296200f, 0.68473637f, 0.29813209f, -0.04976440f, -0.28474674f, -0.38180271f, -0.28513595f, 
    0.29725367f, 0.00914337f, 0.20171833f, 0.30057636f, 0.28509170f, -0.23373726f, 0.20721382f, 0.24368054f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.18666704f, -0.05225563f, 0.13000403f, 0.27715647f, 0.58848423f, 0.42210317f, 0.28078520f, 0.30464187f, 
    0.44027162f, 0.32569891f, 0.20117134f, 0.08800264f, 0.36767149f, 0.21416838f, 0.40637562f, 0.56287158f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.11893555f, 0.09905247f, 0.04766611f, -0.08057220f, -0.35000238f, -0.34692115f, -0.10019467f, -0.02158680f, 
    0.03440564f, -0.09878083f, 0.20611072f, -0.33461767f, 0.06468128f, -0.03848839f, 0.34817615f, 0.32002106f, 
    -0.33294278f, 0.16782890f, 0.24384673f, 0.20211960f, -0.10303577f, 0.21635747f, 0.10699400f, -0.06649063f, 
    0.24803297f, -0.37071079f, -0.10997354f, 0.26469392f, 0.01544641f, -0.29398650f, -0.40309277f, 0.10015634f, 
    -0.08429404f, 0.12038051f, 0.06564086f, 0.10235739f, -0.45255405f, 0.13507104f, -0.13561788f, 0.31028914f, 
    0.16382715f, -0.07803982f, -0.21498893f, -0.07706291f, 0.11996910f, 0.02965436f, -0.10655294f, 0.06088215f, 
    -0.72754127f, -0.31256634f, 0.40161434f, -0.12408105f, 0.10389240f, 0.10116961f, -0.00091538f, -0.09886425f, 
    0.03855511f, -0.07172498f, 0.06282678f, -0.00104234f, 0.25834429f, -0.03823571f, -0.07794171f, -0.31643373f, 
    0.08255558f, -0.16501969f, 0.05339389f, 0.05660680f, -0.08426341f, 0.10519154f, 0.03832880f, 0.08335310f, 
    0.43366843f, -0.12220785f, -0.54374903f, -0.33573654f, 0.11500665f, -0.31899410f, 0.18440381f, -0.02106618f, 
    0.04986691f, -0.12161573f, -0.04879656f, -0.10762319f, -0.63501424f, 0.04532226f, -0.24042524f, 0.50446963f, 
    -0.18229140f, -0.03878192f, -0.25722882f, -0.16905373f, -0.01028072f, -0.06377768f, 0.13845521f, 0.17212196f, 
    -0.73040706f, 0.29309937f, -0.43706766f, -0.29400283f, 0.09615152f, -0.04078670f, -0.02207126f, 0.13480020f, 
    0.10585604f, 0.04025856f, -0.05763462f, 0.06496344f, -0.49009550f, 0.23423550f, 0.53291875f, -0.64376187f, 
    0.06733827f, -0.10558282f, 0.06215186f, -0.07297277f, -0.13953894f, -0.09977875f, -0.18690298f, 0.03128358f, 
    -0.34840846f, 0.25690728f, 0.28621185f, -0.44313765f, -0.03316920f, -0.01090774f, 0.01441758f, 0.15412003f, 
    -0.04079089f, -0.08613624f, -0.14802362f, -0.05365513f, 0.79382086f, 0.42303935f, 0.17079200f, -0.56095403f, 
    0.26546812f, -0.00401090f, 0.09928978f, 0.08641674f, 0.12181572f, -0.12841374f, 0.02464500f, 0.20011027f, 
    -0.21043415f, 0.10232119f, 0.22929855f, 0.02800160f, 0.27963775f, 0.17401433f, -0.09645913f, 0.10292048f, 
    -0.03135015f, 0.09243847f, 0.29186121f, -0.39042264f, 0.43950972f, -0.01943840f, 0.06003358f, 0.06333780f, 
    -0.25693446f, -0.35727194f, -0.11871351f, 0.19771364f, -0.15098475f, -0.06624240f, -0.19932108f, 0.05568573f, 
    -0.12740771f, -0.22689284f, -0.10347985f, 0.26877251f, -0.04853629f, 0.03164099f, -0.02923005f, -0.07828906f, 
    -0.05135286f, -0.08610143f, -0.03903606f, -0.12907682f, -0.08183869f, -0.07937650f, 0.42527717f, -0.44152448f, 
    -0.17101559f, 0.05050457f, 0.12973134f, -0.07161299f, 0.03461525f, 0.02229165f, 0.03691387f, -0.06011209f, 
    0.11285525f, 0.12454514f, 0.18441540f, 0.39594582f, -0.11647329f, -0.04917514f, 0.09385942f, -0.10542694f, 
    0.00723145f, -0.28331262f, -0.03626491f, 0.12618424f, 0.59819186f, 0.09378863f, 0.19955304f, 0.15686943f, 
    -0.22791195f, 0.13621801f, -0.18580961f, 0.04406742f, 0.04217521f, 0.00751377f, -0.17326705f, -0.04308399f, 
    0.30136225f, 0.05186911f, -0.37468269f, -0.32168061f, -0.10572702f, -0.14479071f, -0.00781946f, -0.12205502f, 
    -0.16108201f, 0.21398090f, -0.08217907f, -0.07453748f, 0.09217474f, -0.38483757f, -0.15342301f, 0.23664728f, 
    -0.21107416f, 0.06288474f, -0.04259595f, 0.00838128f, -0.00271324f, -0.09653733f, 0.03026231f, 0.12895732f, 
    0.26388088f, 0.13168886f, 0.09003935f, -0.05216605f, -0.07692567f, 0.06330906f, -0.02465870f, 0.15513532f, 
    -0.13804200f, 0.18501456f, 0.00715593f, 0.14460650f, 0.57707518f, -0.57442772f, 0.46102378f, -0.21142417f, 
    -0.08347506f, -0.26470074f, -0.13773116f, 0.04863431f, -0.07122038f, 0.04678575f, -0.10687266f, 0.19131696f, 
    -0.65292817f, -0.10993076f, -0.06230161f, -0.20696931f, -0.08430881f, -0.30321008f, -0.00678609f, 0.13904810f, 
    0.16521510f, -0.05586030f, -0.06479219f, -0.26283634f, -0.34086138f, 0.07139275f, -0.57231420f, -0.71327907f, 
    0.08401706f, 0.01307518f, -0.06907604f, 0.27983603f, -0.02707916f, 0.01318124f, -0.04494442f, -0.06232937f, 
    0.49158797f, -0.22227596f, -0.12132212f, -0.10658419f, 0.15542690f, -0.06277795f, -0.01469929f, 0.08504128f, 
    0.08205757f, -0.12398745f, -0.08176188f, -0.02744499f, 0.20558837f, 0.23221989f, -0.35591391f, -0.19125095f, 
    0.05602689f, 0.07892061f, -0.14578147f, 0.18749970f, 0.16373272f, 0.04324120f, -0.01813344f, -0.06565113f, 
    0.31806415f, 0.04566969f, -0.00303977f, -0.30874997f, -0.14934944f, -0.15363695f, 0.03008235f, -0.14486603f, 
    -0.04991062f, -0.21523397f, 0.16887720f, 0.13078149f, -0.06215601f, -0.24103503f, -0.29692206f, -0.13289410f, 
    0.09991001f, -0.01739885f, -0.11463422f, 0.18210095f, 0.20868234f, -0.01190038f, -0.04460540f, -0.02564142f, 
    -0.07642029f, -0.25025672f, 0.15634455f, -0.50950783f, 0.08011053f, 0.02457532f, 0.04293572f, -0.11534497f, 
    0.20971213f, -0.23468091f, -0.14447775f, 0.04991824f, 0.25866848f, 0.13160285f, 0.01009868f, 0.28890029f, 
    -0.08019084f, -0.16017091f, 0.20424353f, 0.02948348f, 0.21902110f, 0.14795235f, 0.02445918f, 0.18111479f, 
    -0.12201862f, 0.29362026f, 0.19739242f, 0.28706110f, -0.24902047f, -0.06857481f, -0.01729166f, -0.08031711f, 
    -0.07285012f, 0.02974566f, -0.03803834f, 0.13673125f, -0.32539165f, -0.58495790f, 0.11512785f, -0.24666952f, 
    -0.12372261f, 0.09408908f, -0.07906431f, 0.23195079f, 0.03643703f, 0.07309011f, -0.04354092f, -0.20733635f, 
    -0.14956358f, 0.29477948f, -0.13067842f, 0.12382245f, -0.16001375f, 0.07591228f, 0.05013742f, -0.34177130f, 
    -0.05754511f, -0.00890588f, 0.08487144f, -0.01947528f, 0.22791314f, -0.15016238f, -0.08024861f, -0.40659079f, 
    0.17534159f, -0.19168895f, 0.09690131f, -0.15530053f, 0.10120676f, 0.11822401f, 0.10544868f, 0.12395608f, 
    -0.58234221f, 0.20452972f, 0.28991511f, -0.22353458f, -0.00398348f, -0.03585603f, 0.10287750f, 0.26742926f, 
    0.13149895f, -0.08866718f, -0.04704316f, -0.14747466f, 1.18046069f, -0.25916919f, 0.22525878f, 0.16079855f, 
    -0.14046951f, -0.00418028f, -0.00074138f, 0.11512333f, 0.04392434f, 0.07518856f, 0.10021757f, -0.13395545f, 
    -0.09016962f, -0.36698097f, 0.14866798f, -0.28651699f, -0.07322419f, -0.11787350f, -0.05165278f, 0.09096278f, 
    -0.26645517f, -0.18775035f, -0.25843596f, -0.07498694f, 0.21573138f, 0.14933170f, -0.32859224f, 0.27012241f, 
    -0.07791002f, -0.27894637f, 0.30917457f, 0.27406508f, 0.02953620f, -0.26041698f, 0.09317039f, -0.01868846f, 
    -0.49656788f, 0.18000223f, -0.22077084f, 0.07733127f, -0.18353409f, -0.03635552f, -0.25082004f, -0.22998075f, 
    -0.12456450f, -0.02716952f, 0.00019859f, -0.03894658f, 0.62799764f, -0.44122487f, -0.56443369f, -0.51056081f, 
    0.08806925f, 0.06547238f, -0.04251681f, -0.08072200f, -0.02378139f, -0.04858545f, 0.05745616f, -0.00006742f, 
    0.48821563f, 0.09026372f, -0.10543948f, 0.34519848f, -0.42471611f, -0.13432693f, -0.16887718f, -0.00969494f, 
    0.04616778f, -0.19859536f, 0.02469397f, 0.04692939f, -0.30464414f, 0.23154604f, -0.48360088f, -0.36406803f, 
    -0.03204565f, -0.19194859f, -0.09111055f, -0.04541998f, -0.08804886f, -0.03750580f, 0.08930035f, 0.02973705f, 
    -0.28484339f, 0.09225814f, 0.14872777f, -0.49829698f, 0.12392392f, 0.15655105f, 0.18726525f, 0.00164150f, 
    0.01844498f, -0.12366872f, 0.05645328f, -0.06114991f, 0.30154991f, 0.02071776f, 0.30169532f, 0.49797317f, 
    -0.14146703f, -0.15413460f, 0.20233327f, 0.42748237f, 0.05171685f, 0.11657811f, 0.00281334f, -0.10891816f, 
    0.32799801f, -0.05001395f, -0.22505660f, -0.20099932f, -0.07006319f, 0.07827996f, -0.06294967f, -0.24487931f, 
    0.16305077f, -0.07393755f, 0.01595933f, -0.08049551f, -0.49222782f, 0.24651513f, -0.24306637f, -0.25958812f, 
    0.20949841f, 0.09885048f, 0.02507425f, -0.12735699f, -0.13781793f, 0.03676315f, 0.03231580f, -0.05411762f, 
    -0.50003111f, 0.20186375f, -0.14749217f, 0.02788656f, -0.07829612f, 0.06595726f, -0.12125736f, 0.06054090f, 
    0.11492369f, -0.16968496f, 0.08253337f, -0.17820449f, -0.53250802f, -0.19740576f, -0.13158798f, -0.64454639f, 
    0.28404188f, -0.04613690f, 0.21036646f, -0.19259533f, 0.00636304f, 0.14697614f, -0.02555108f, 0.01321010f, 
    -0.62816942f, -0.28452197f, -0.48019245f, 0.78258330f, -0.12167310f, 0.13074547f, 0.21417426f, -0.11283137f, 
    -0.25948933f, 0.20064908f, -0.07837288f, -0.13935861f, -0.76997036f, -0.14358813f, -0.44766006f, -0.29337731f, 
    -0.12255844f, -0.14050919f, 0.03526432f, -0.17070055f, 0.00130086f, -0.01850606f, 0.00552421f, -0.00056315f, 
    -0.26481280f, -0.02032143f, -0.14206828f, -0.04617061f, -0.07620589f, 0.10168442f, -0.16915870f, 0.32864532f, 
    0.22287409f, 0.08957107f, -0.14801978f, 0.10752236f, -0.20472814f, 0.05879338f, 0.23564765f, 0.07956350f, 
    0.00035419f, -0.02047180f, 0.08799487f, -0.00840313f, -0.22360721f, 0.15476266f, -0.16113850f, -0.06311093f, 
    0.08786798f, 0.03554739f, -0.11427258f, 0.24837463f, 0.03529202f, 0.01387687f, -0.05647130f, 0.01005340f, 
    0.03324577f, -0.02647501f, -0.25021672f, -0.02319936f, -0.08454634f, -0.34886539f, -0.08766325f, 0.13975592f, 
    -0.09702035f, 0.09608117f, -0.15803342f, -0.11647781f, -0.15924378f, 0.06876459f, -0.01451874f, -0.05373085f, 
    0.14753036f, 0.14866564f, -0.02651052f, 0.11793356f, -0.26249695f, 0.23208347f, 0.13712902f, 0.14071542f, 
    0.02733294f, 0.18387145f, 0.05239708f, 0.09993239f, -0.30169660f, 0.75683659f, 0.38440904f, -0.05876048f, 
    0.25429493f, 0.00761228f, -0.05281068f, 0.04543424f, 0.04896206f, 0.15727128f, 0.08697993f, -0.00348550f, 
    0.47803736f, -0.12841721f, 0.12184478f, -0.15647806f, -0.17323560f, -0.29676682f, -0.01924493f, -0.12619323f, 
    -0.18292274f, 0.03438666f, -0.04007059f, 0.02531100f, -0.28462830f, -0.10364281f, 0.07014090f, -0.01138090f, 
    -0.20340371f, -0.14441265f, 0.13384700f, -0.01050948f, 0.06409175f, 0.08401637f, -0.14791954f, 0.22358233f, 
    -0.27196839f, -0.24130866f, -0.21852086f, 0.12021257f, -0.06390449f, -0.01238723f, -0.23281567f, 0.24186043f, 
    0.01657766f, -0.06525183f, -0.01780345f, -0.13099667f, -0.33402970f, 0.14951622f, -0.05125466f, -0.34211102f, 
    -0.36775932f, -0.09120330f, 0.19991609f, -0.07372244f, -0.06466588f, -0.12390254f, 0.10387760f, -0.01356821f, 
    0.29357865f, 0.29653189f, 0.05518034f, 0.34163114f, 0.09858301f, -0.01587186f, -0.04887807f, -0.10717946f, 
    0.02095068f, 0.14261158f, -0.05074985f, -0.14157994f, 0.58315390f, -1.33396649f, -0.33647376f, 0.13658051f, 
    -0.07386621f, 0.13772179f, 0.09429479f, -0.06649916f, 0.08846928f, -0.23605230f, 0.04412453f, -0.24090089f, 
    0.07447054f, -0.54618621f, -0.06264023f, 0.34566757f, -0.14603510f, 0.05508418f, 0.08649376f, -0.20631713f, 
    -0.12320413f, 0.13217074f, 0.04342432f, -0.26881161f, 0.62207174f, 0.12821007f, 0.12672710f, 0.31561178f, 
    0.27911085f, -0.00962431f, 0.07580396f, 0.03185474f, -0.04360617f, 0.04494311f, -0.26845160f, 0.05191516f, 
    -0.48681194f, -0.32909560f, -0.08062716f, 0.08418816f, -0.14167684f, -0.03354429f, 0.09212967f, -0.10629909f, 
    -0.01295221f, 0.05532084f, -0.09814629f, -0.11475784f, 0.71099603f, -0.47306406f, -0.36010799f, 0.21704997f, 
    -0.06792420f, -0.00483838f, 0.13091980f, 0.20251636f, -0.20175332f, 0.07666542f, 0.04394804f, 0.15862684f, 
    -0.10489521f, -0.29861617f, 0.19183569f, -0.28372309f, -0.01328565f, 0.00432484f, 0.10174932f, -0.01551314f, 
    0.10843464f, 0.14569965f, 0.04281630f, 0.09253211f, -1.44237292f, 0.42679530f, 0.06113739f, -0.29732546f, 
    -0.06846677f, 0.02888302f, -0.11103413f, -0.06239215f, 0.03305785f, -0.01510553f, -0.04081141f, -0.06894415f, 
    -0.19103561f, 0.02717744f, 0.25783256f, 0.11229566f, 0.04504329f, -0.04183992f, 0.03570673f, 0.05648261f, 
    0.10022974f, -0.29267371f, -0.05724318f, -0.07694627f, -0.25465018f, -0.09462190f, -0.15185778f, 0.31036288f, 
    0.09716945f, 0.04365712f, -0.00239310f, -0.17297219f, -0.06498920f, -0.03866820f, -0.04608460f, -0.05462480f, 
    0.82878572f, -0.02740276f, -0.29592404f, -0.15022288f, 0.02190601f, 0.20355205f, 0.07257091f, 0.10484251f, 
    0.24521315f, -0.11638122f, -0.01356456f, 0.09736927f, 0.17246678f, -0.27419192f, 0.39314768f, 0.13391817f, 
    -0.08704232f, -0.05408279f, 0.27991390f, 0.05709054f, 0.06401826f, 0.03779636f, -0.11338721f, 0.06297979f, 
    -0.17319755f, 0.05830898f, -0.16637920f, 0.12418984f, 0.00111130f, 0.04671192f, 0.00189174f, 0.15427366f, 
    -0.04743812f, -0.27708152f, 0.17367668f, -0.06863128f, -0.00783209f, -0.05789183f, 0.50375634f, 0.11007237f, 
    -0.00176318f, -0.07680590f, 0.25778016f, -0.07375140f, 0.20403236f, 0.02099086f, -0.10209558f, 0.04949946f, 
    -0.40540951f, -0.24351105f, 0.30923396f, -0.30453941f, -0.00690474f, 0.09987863f, -0.15246713f, -0.01034974f, 
    0.02026733f, 0.05047411f, -0.06296211f, -0.15690689f, -0.76676887f, -0.31973836f, 0.13650174f, 0.39242384f, 
    -0.02536060f, -0.18996978f, -0.01989818f, 0.11039878f, -0.16152589f, 0.12663729f, 0.35347918f, 0.06872407f, 
    0.01944084f, 0.08979065f, -0.15766639f, -0.11691909f, -0.15206209f, -0.12652589f, -0.04598080f, 0.20403083f, 
    -0.28237545f, 0.23927087f, 0.07366040f, -0.04305287f, -0.01739847f, -0.08059661f, 0.46242681f, 0.25002062f, 
    -0.20709132f, 0.08292533f, -0.02842910f, -0.11361364f, 0.04032823f, -0.05501893f, -0.03733860f, -0.16173975f, 
    0.34330752f, 0.03473812f, 0.02617178f, -0.19750932f, 0.19917479f, -0.18576422f, -0.02431178f, 0.06438453f, 
    0.20603652f, -0.07857560f, 0.05429952f, -0.16695571f, -0.13054693f, -0.09742916f, -0.19309051f, 0.08648976f, 
    -0.00785089f, 0.03366030f, -0.00834007f, 0.02384501f, -0.05234914f, -0.24823199f, 0.09985120f, 0.21054399f, 
    0.21380404f, 0.13266893f, 0.03177122f, 0.10615705f, -0.07193171f, -0.11156300f, 0.04123104f, 0.30999893f, 
    0.02821460f, -0.04394788f, -0.07165319f, 0.26025519f, -0.31559843f, 0.26779556f, 0.25890598f, -0.39811990f, 
    0.16946082f, 0.06506427f, -0.03324469f, -0.24930637f, 0.07754127f, -0.09763315f, -0.13877606f, -0.07301949f, 
    0.04130584f, 0.08920436f, 0.08045565f, 0.20396674f, -0.02104160f, -0.13540389f, 0.12348683f, -0.05209829f, 
    0.00828266f, 0.15570150f, -0.05091989f, -0.12010992f, -0.74318659f, 0.29819629f, 0.08388887f, -0.45565236f, 
    0.07325202f, 0.11850365f, -0.08843965f, 0.18646325f, 0.11353435f, -0.13838473f, -0.01216913f, -0.18159410f, 
    -0.12962233f, -0.17936210f, -0.22450490f, 0.03170716f, 0.09815807f, -0.00154341f, -0.19217339f, 0.21374136f, 
    -0.12755316f, 0.22877711f, 0.43200526f, 0.29838106f, 0.54767936f, 0.31239310f, -0.23517072f, -0.23849337f, 
    -0.03657279f, 0.19048297f, -0.40871611f, -0.21048646f, 0.02274746f, 0.09239651f, -0.07836516f, -0.00305774f, 
    -0.22173613f, -0.26715651f, 0.07092050f, -0.03778800f, 0.27218929f, 0.22324005f, -0.02645721f, -0.05311046f, 
    -0.25624326f, -0.16071847f, -0.16862912f, -0.07061934f, 0.10241754f, -0.05206579f, -0.27799675f, 0.38506505f, 
    -0.15751089f, -0.17426211f, -0.08369769f, 0.11308710f, 0.15598507f, -0.11501194f, 0.09381328f, -0.12373657f, 
    -0.93928254f, -0.38672420f, -0.27686897f, -0.14843087f, 0.13445109f, -0.03803047f, 0.01169909f, 0.11628091f, 
    -0.04315647f, 0.43159255f, -0.21312959f, 0.22252220f, 0.03425563f, -0.75432271f, -0.21059111f, 0.08200792f, 
    0.16704568f, 0.05103150f, -0.00876471f, 0.12429409f, 0.20725846f, 0.45513305f, -0.14065661f, 0.11353045f, 
    -0.38469589f, 0.13256624f, -0.14272189f, 0.26950470f, 0.21509841f, -0.05835505f, 0.20498729f, -0.06648934f, 
    -0.02048095f, -0.03047298f, -0.00641700f, -0.01888245f, -0.30343542f, 0.01721071f, -0.45262808f, -0.03149720f, 
    0.17771105f, 0.32306874f, -0.10977916f, -0.33257923f, 0.09141164f, -0.30719942f, -0.27721760f, -0.02225741f, 
    -0.17171296f, 0.13335221f, -0.03041598f, 0.09085487f, 0.01646212f, 0.04532736f, 0.10381477f, 0.05312499f, 
    0.06113077f, -0.02497042f, -0.33256581f, 0.10496213f, 0.17357649f, 0.07871381f, 0.08364656f, 0.16987759f, 
    -0.13673408f, -0.09895413f, -0.03230074f, 0.12220634f, -0.12136505f, -0.00245693f, 0.25345314f, 0.30850813f, 
    -0.46657786f, -0.17601283f, 0.16167192f, 0.25028369f, 0.01235891f, -0.01400317f, 0.15703984f, 0.02769469f, 
    0.30362150f, 0.18217623f, -0.08389948f, 0.29913026f, -0.05740453f, 0.00941195f, 0.03615491f, 0.37569109f, 
    -0.18809040f, -0.23307367f, -0.13905536f, 0.01057808f, -0.26153114f, -0.32861310f, -0.07533636f, 0.04794642f, 
    0.10085719f, 0.35890689f, 0.08104989f, -0.45484513f, 0.00551521f, 0.11057819f, -0.07838540f, 0.04331709f, 
    0.06392457f, 0.11737690f, 0.10488294f, -0.00356541f, -0.89639252f, 0.22094980f, 0.17358819f, -0.27989852f, 
    -0.31063873f, -0.18199818f, 0.15725352f, 0.26270416f, -0.08933745f, 0.08764039f, 0.18019688f, 0.18559720f, 
    -0.73161918f, 0.31649339f, -0.13238573f, 0.47672912f, -0.02323980f, -0.11568531f, -0.04987661f, -0.19306250f, 
    -0.14391914f, -0.07757490f, 0.15113483f, -0.11768108f, 0.91197050f, -0.47683695f, 0.16763481f, -0.19139218f, 
    -0.05331289f, -0.13777930f, 0.10362171f, -0.00670203f, -0.06817486f, 0.14089389f, 0.07695872f, -0.02054793f, 
    0.02986066f, 0.02548409f, -0.05573231f, -0.07220460f, 0.08929636f, 0.12914900f, 0.03125520f, -0.13069269f, 
    -0.05017564f, -0.13491780f, -0.34123293f, -0.09695636f, -0.64706576f, 0.02193040f, -0.02897547f, 0.24175286f, 
    -0.16492517f, 0.00107661f, 0.23258923f, 0.00657053f, 0.07758464f, -0.24956743f, 0.13367955f, -0.10406964f, 
    -0.05967435f, 0.39400917f, 0.31174579f, 0.01221875f, -0.17847249f, 0.09742441f, 0.06412577f, -0.11260287f, 
    -0.01718819f, 0.17153634f, 0.28952843f, 0.24444692f, -0.08907428f, -0.29695991f, -0.19870017f, -0.36487472f, 
    -0.06461038f, 0.01546014f, 0.07563671f, -0.17765440f, 0.03683900f, 0.00437670f, -0.06787810f, 0.27092713f, 
    -0.50976813f, -0.11206082f, 0.11060151f, -0.09379013f, 0.12833451f, 0.24211839f, -0.04936443f, -0.27290881f, 
    0.08846889f, -0.23558895f, 0.14492282f, -0.09771352f, -0.27057263f, -0.17803718f, -0.67201310f, 0.39573249f, 
    -0.00881409f, -0.05608739f, 0.06318164f, 0.23881136f, 0.03904973f, -0.14631857f, 0.03170998f, -0.14639129f, 
    -0.07194529f, 0.19433199f, -0.39330670f, 0.46411344f, -0.01232003f, 0.12611739f, 0.05913169f, 0.09484513f, 
    -0.10691759f, -0.01689562f, 0.03207088f, -0.10495048f, -0.23613067f, -0.43585330f, -0.27140269f, -0.35129264f, 
    -0.09513471f, 0.07905884f, 0.01822693f, -0.03088097f, -0.00670544f, 0.14902391f, -0.01297639f, 0.35451156f, 
    0.11536162f, -0.11430800f, -0.08661869f, -0.10954928f, -0.09342358f, -0.05451902f, -0.15493022f, -0.31092298f, 
    0.02246954f, 0.09857125f, 0.16323927f, -0.20758741f, -0.05680206f, 0.32448125f, 0.20887505f, -0.44140539f, 
    0.08365019f, 0.01495872f, -0.10146755f, 0.11009127f, -0.04715500f, -0.05345254f, -0.09550659f, -0.17009905f, 
    0.18022341f, 0.24075297f, 0.14159313f, -0.24461216f, 0.09313431f, 0.17815107f, 0.24294266f, 0.01692493f, 
    -0.10149483f, -0.21331492f, -0.00209507f, -0.17567074f, 0.08466344f, -0.25352484f, -0.37567592f, 0.20867513f, 
    0.02788850f, 0.18395205f, 0.05330396f, 0.12458907f, 0.10922368f, -0.04673872f, -0.10399330f, 0.12989603f, 
    -0.31756139f, -0.18678881f, -0.44673330f, -0.58822066f, 0.16783077f, 0.13406555f, -0.04514199f, -0.19133362f, 
    -0.28015757f, -0.03886649f, -0.10625531f, -0.25122446f, -0.43510872f, 0.35610420f, 0.11275360f, 0.01536218f, 
    0.21796173f, 0.00874686f, -0.21761501f, -0.10540312f, -0.14845055f, -0.18304047f, -0.12540880f, -0.19811317f, 
    -0.19503808f, 0.11051223f, -0.31511953f, -0.13447036f, -0.21780427f, 0.04473476f, -0.24253057f, 0.01308389f, 
    -0.01931549f, -0.02328046f, 0.06894634f, -0.13944036f, 0.73755920f, -0.05126455f, 0.39863330f, -0.45308098f, 
    -0.08180739f, 0.07649957f, -0.04841001f, -0.14775065f, -0.08881853f, 0.29434329f, -0.25681156f, -0.00322849f, 
    -0.14411625f, 0.00810889f, 0.09291801f, 0.02177800f, -0.05363706f, -0.12717955f, -0.05696316f, -0.18436207f, 
    0.06130819f, -0.19646050f, -0.14326312f, -0.16165397f, -0.21917920f, 0.03616902f, -0.14993617f, -0.12678476f, 
    -0.17440090f, 0.08811041f, -0.01634743f, -0.07195391f, 0.04958362f, 0.09053882f, -0.07947409f, -0.19016960f, 
    0.21974361f, 0.49006546f, 0.04378337f, 0.47899440f, 0.23027863f, -0.00465239f, 0.01274071f, -0.08203179f, 
    -0.11349975f, 0.14913251f, -0.21137084f, -0.20967323f, 0.44306341f, -0.57014239f, 0.36462829f, 0.40448290f, 
    0.05728242f, -0.26527449f, -0.11065553f, -0.25025710f, -0.10720405f, 0.08225574f, -0.07466479f, -0.20347953f, 
    0.19737840f, 0.08040120f, 0.38791245f, 0.16743585f, 0.12838632f, 0.08484123f, 0.15714294f, -0.15947376f, 
    0.04360433f, 0.04680915f, 0.09664646f, -0.12008003f, 0.31139627f, 0.25619063f, 0.37848392f, 0.30067307f, 
    0.18993995f, 0.02099152f, 0.02661147f, -0.06536786f, -0.04082863f, -0.19773918f, -0.16966310f, -0.22343978f, 
    -0.35708433f, -0.23063931f, -0.12702043f, 0.18937358f, -0.09991058f, -0.12124113f, -0.11336340f, -0.08747602f, 
    -0.04252136f, -0.06210312f, -0.03345850f, 0.08770902f, -0.05110015f, 0.33553883f, 0.27649608f, 0.31955904f, 
    0.29801068f, 0.00324427f, 0.06666867f, -0.05383426f, -0.09080794f, 0.18196011f, 0.14205523f, -0.04824353f, 
    0.07121911f, -0.35334793f, 0.37460729f, 0.13974638f, -0.00205503f, 0.04952019f, -0.20067960f, -0.03830769f, 
    -0.14162216f, -0.05855247f, 0.06834798f, -0.00504053f, -0.39100379f, -0.01395367f, -0.46459115f, -0.11292222f, 
    -0.07730696f, -0.15879996f, -0.01184127f, -0.01211483f, -0.20165794f, 0.06553081f, 0.14578490f, 0.00957306f, 
    0.12088834f, 0.08092281f, -0.41147140f, -0.21821021f, -0.02410865f, -0.01860111f, -0.11450302f, -0.15335137f, 
    -0.01890923f, -0.09109922f, -0.13637352f, -0.11991734f, 0.02469032f, 0.32220352f, -0.58985806f, 0.45852101f, 
    -0.03820217f, -0.30184379f, -0.05255651f, -0.04034782f, -0.18897596f, 0.19150953f, 0.09340084f, 0.06075904f, 
    0.03969194f, -0.37811327f, -0.09959320f, 0.02846829f, 0.16720459f, 0.03272375f, -0.15642902f, -0.08910111f, 
    0.12625162f, 0.17454715f, -0.08517227f, -0.12786318f, 0.24457484f, -0.06106497f, 0.05627695f, 0.27985927f, 
    0.32031482f, -0.17189048f, -0.18626150f, -0.35790953f, 0.00133852f, -0.01639218f, -0.12122203f, -0.21804145f, 
    0.31655779f, 0.15380907f, -0.26855299f, -0.01252323f, 0.07476042f, -0.15816575f, -0.06291708f, 0.05267546f, 
    0.25005609f, -0.08691579f, -0.01864993f, 0.21035358f, 0.07851629f, 0.01913856f, -0.06582315f, -0.10548462f, 
    0.00302597f, -0.01378205f, 0.05367403f, -0.05021434f, 0.15935118f, -0.01987987f, -0.03232872f, 0.29445040f, 
    -0.70169640f, -0.12122349f, -0.12634259f, -0.58848017f, -0.24587816f, -0.06773760f, 0.10200453f, -0.13354911f, 
    0.16030967f, 0.22478715f, 0.14207476f, 0.12560432f, 0.16815156f, 0.33849850f, -0.10371856f, 0.11582593f, 
    -0.26641014f, 0.08288354f, -0.32262456f, 0.06489391f, 0.02939439f, 0.04500301f, -0.13267009f, -0.00769127f, 
    -0.32426915f, -0.18205115f, 0.07558744f, -0.33603522f, 0.12419641f, -0.22990881f, 0.05973261f, -0.08801296f, 
    -0.02044012f, -0.12185602f, 0.14355405f, -0.40414900f, -0.11015318f, -0.22480807f, 0.14246061f, -0.66454178f, 
    -0.15520410f, 0.02122988f, -0.04509019f, -0.00417025f, 0.05972221f, -0.12857504f, 0.07626119f, -0.00037071f, 
    -0.04944605f, 0.00105178f, 0.27139568f, 0.13461645f, 0.06547470f, 0.15068838f, 0.02116737f, -0.14445898f, 
    0.11783756f, 0.07902637f, 0.08365946f, 0.21334091f, -0.17057744f, 0.48114356f, -0.58396989f, -0.41925830f, 
    -0.01725565f, -0.19268817f, -0.15977661f, -0.13408577f, 0.06732101f, 0.00419518f, 0.00012964f, 0.08181478f, 
    0.54415423f, 0.43103772f, -0.67762512f, -0.11606064f, 0.08037929f, 0.12535806f, 0.12198476f, -0.13922183f, 
    -0.06980267f, -0.02761167f, -0.10960618f, 0.27012360f, -0.35924426f, -0.13673115f, 0.33182371f, 0.01466158f, 
    -0.40712431f, 0.18784817f, -0.27020696f, -0.15935165f, -0.02532318f, -0.29968849f, -0.25653118f, -0.04355244f, 
    -0.67190391f, 0.19850783f, -0.16506563f, -0.54207867f, 0.03764674f, -0.01648840f, -0.05825077f, 0.01070656f, 
    0.09515087f, 0.09011679f, -0.49080309f, 0.23924173f, -0.45774263f, -0.39300632f, -0.14801908f, 0.12590447f, 
    0.08854461f, 0.23411101f, 0.07722345f, -0.08706741f, 0.29597059f, 0.15217032f, 0.19839352f, 0.04498907f, 
    -0.08708972f, 0.54973686f, 0.01044871f, 0.17689388f, 0.03362658f, 0.02722587f, -0.06899075f, -0.25197536f, 
    -0.02995263f, 0.03076235f, -0.06826533f, 0.20279175f, -0.02454910f, 0.35087508f, -0.43409550f, -0.27867010f, 
    0.06805773f, -0.21728794f, -0.25561818f, 0.41989303f, 0.03248625f, -0.27542657f, 0.16440184f, 0.19123098f, 
    -0.06564075f, -0.23202258f, 0.61967927f, -0.32740909f, -0.02719261f, 0.04055849f, 0.08489681f, 0.06746908f, 
    0.11914954f, 0.03641614f, 0.09088455f, 0.03738867f, -0.37458172f, 0.21496989f, -0.51536673f, -0.19208644f, 
    0.05679142f, 0.01439167f, -0.16243649f, -0.02812512f, 0.04266210f, -0.12925406f, 0.24882907f, 0.06119562f, 
    0.54488289f, 0.15302862f, -0.05194128f, -0.02793876f, 0.07334526f, 0.40491813f, 0.18700387f, -0.05940830f, 
    -0.04103914f, -0.17034896f, -0.05081691f, 0.02949024f, -0.33083281f, -0.43132994f, -0.31119207f, 0.04055745f, 
    0.18928248f, 0.05449479f, -0.07670205f, -0.05906879f, -0.07015315f, 0.05665965f, 0.11657058f, -0.04257365f, 
    0.04388025f, 0.03726956f, -0.60693443f, -0.03242691f, 0.11467128f, -0.18806140f, 0.25705656f, -0.22448727f, 
    0.11278620f, -0.04558178f, -0.28586277f, -0.08898785f, -0.65754008f, 0.56511128f, 0.45456621f, 0.22869687f, 
    -0.00509193f, 0.03773016f, 0.13879155f, 0.02264666f, 0.09220398f, -0.00711370f, 0.01466338f, 0.11614466f, 
    -0.54058474f, -0.29873231f, 0.56093723f, 0.32510713f, 0.03222539f, -0.19839811f, -0.20971978f, 0.11771035f, 
    0.05889269f, 0.16194996f, 0.00601442f, 0.24452242f, 0.25787145f, -0.70384324f, 0.07945394f, -0.00401140f, 
    0.28416878f, 0.08611453f, 0.00672961f, 0.04890195f, -0.10946225f, 0.08917108f, 0.21195844f, 0.07634015f, 
    0.30011976f, -0.32739243f, -0.03774885f, 0.05087265f, -0.10266164f, -0.15051748f, -0.01403223f, -0.06435217f, 
    -0.14892529f, 0.11855768f, -0.06137551f, -0.16291636f, 0.06604197f, -0.46823823f, -0.04089180f, 0.03057339f, 
    -0.05369010f, 0.20443143f, -0.14106171f, 0.02260141f, -0.23568250f, -0.02853839f, 0.15228179f, -0.14992483f, 
    0.36958644f, 0.00869762f, 0.46346921f, 0.03133928f, -0.09461457f, -0.01953213f, -0.15893266f, 0.12102102f, 
    0.02250170f, 0.07101874f, 0.14352830f, 0.17240107f, -0.00881509f, -0.52244025f, 0.00167026f, -0.10161185f, 
    0.11471023f, -0.11249530f, 0.02751547f, 0.07302091f, -0.12289481f, 0.19656099f, 0.02917032f, 0.00962609f, 
    -0.04852380f, 0.01433111f, -0.28426075f, 0.50547838f, -0.27040109f, 0.14169586f, -0.09386818f, 0.04737001f, 
    -0.03645844f, -0.20982432f, 0.11917800f, 0.11369511f, -0.45722765f, 0.00624110f, -0.10878706f, -0.52746785f, 
    -0.05083098f, 0.13878566f, -0.04431943f, 0.03572550f, -0.30803144f, -0.09122138f, -0.23628525f, -0.12960517f, 
    0.85990644f, 0.00887459f, -0.27816308f, -0.49598962f, 0.08394131f, -0.16843249f, -0.05396002f, 0.14769678f, 
    -0.22434096f, -0.00224896f, 0.12806851f, -0.25565934f, -0.07441305f, 0.50676119f, 0.28395662f, -0.48894575f, 
    -0.26009002f, -0.04909061f, 0.13359614f, -0.26749408f, -0.12839028f, 0.11729965f, -0.00428357f, -0.14536402f, 
    -0.26474586f, -0.12432938f, -0.34496409f, -0.49439111f, 0.28248855f, -0.16881511f, -0.15909101f, 0.14264907f, 
    -0.04893301f, -0.12429298f, 0.02321585f, 0.12107015f, -0.33266735f, -0.23695038f, -0.80975795f, -0.17319557f, 
    0.01183250f, -0.09592491f, -0.23915806f, 0.07020450f, -0.00821922f, -0.24000691f, -0.24038877f, 0.04169152f, 
    -0.96278280f, -0.40679675f, 0.40175864f, 0.29820189f, 0.27646327f, 0.00654348f, 0.07769476f, -0.34925267f, 
    0.04045134f, -0.11767269f, -0.15164550f, 0.24133755f, 0.12324268f, 0.01617536f, -0.29164058f, 0.08637615f, 
    -0.05525653f, 0.03926321f, -0.01225739f, 0.17580894f, -0.00207908f, -0.06345053f, 0.02630195f, 0.12223636f, 
    0.60150659f, 0.35122359f, -0.17636681f, -0.01179428f, -0.02455455f, 0.08762819f, 0.15289997f, 0.03585175f, 
    -0.06983460f, 0.27366188f, 0.29871574f, 0.25128955f, -0.46414378f, -0.51267964f, 0.02226322f, -0.34045431f, 
    -0.00688031f, 0.16881564f, 0.13796368f, -0.09785734f, 0.24017678f, -0.21494320f, -0.02584427f, 0.06919093f, 
    0.06638025f, -0.18540840f, 0.08529139f, -0.07033501f, -0.20685098f, 0.09924641f, 0.00272854f, -0.09816141f, 
    -0.21959934f, 0.15235235f, -0.21082814f, -0.35195920f, 0.10755859f, 0.52151501f, -0.13575490f, 0.05253975f, 
    -0.01572564f, 0.22855747f, 0.10838776f, 0.05795513f, 0.07630996f, -0.14999965f, -0.03861434f, -0.21339667f, 
    0.22638553f, 0.17800312f, 0.09351277f, -0.15470056f, 0.03022223f, 0.16606314f, 0.07852525f, -0.02976616f, 
    0.14963214f, 0.13798437f, 0.02068998f, 0.17192619f, 0.10953115f, -0.07433500f, 0.17537189f, 0.20718728f, 
    -0.10164520f, -0.00422600f, -0.17962751f, -0.24901451f, -0.09178849f, -0.04047018f, 0.14370275f, -0.04375652f, 
    -1.09847879f, -0.33108154f, -0.17698172f, 0.10661126f, 0.37198618f, -0.09853647f, 0.20639199f, -0.14212380f, 
    0.00438998f, -0.01349952f, -0.07136726f, 0.25025687f, 0.52761120f, 0.22695358f, 0.09995092f, -0.10039614f, 
    -0.42222807f, -0.21216609f, -0.09067413f, -0.22984457f, 0.06457104f, -0.16581139f, -0.16749747f, -0.16669060f, 
    0.39873680f, -0.07123957f, -0.04906858f, -0.00813766f, 0.00322050f, 0.11271907f, 0.10562968f, -0.01653522f, 
    0.03879946f, -0.13871258f, -0.05745753f, 0.21928409f, -1.07771015f, -0.65371311f, 0.01557683f, -0.43496448f, 
    0.28326964f, 0.07437693f, 0.02336258f, 0.06135461f, 0.16144834f, 0.43666357f, -0.03042029f, 0.13970144f, 
    -0.82623571f, -0.21394756f, 0.00367014f, -0.50459081f, 0.21903583f, 0.00162449f, 0.06124058f, 0.28183624f, 
    -0.02279213f, 0.13917246f, 0.13499770f, 0.36030307f, 0.05991950f, 0.14680779f, 0.24568823f, -0.08003726f, 
    0.09727108f, 0.13155548f, 0.03144122f, 0.07274734f, -0.08384934f, 0.01068114f, 0.05647669f, -0.04143149f, 
    0.85175884f, 0.20084412f, -0.36326715f, -0.44753352f, -0.03886491f, 0.13185647f, -0.07100515f, 0.11492985f, 
    0.05114069f, 0.08027098f, 0.09589288f, 0.07450335f, -0.47990909f, -0.45224640f, -0.08171923f, -0.11137597f, 
    0.12501186f, -0.09935864f, 0.03765072f, 0.08770231f, 0.10112114f, 0.20509461f, -0.05730120f, -0.05908874f, 
    0.27109143f, 0.22417364f, 0.13018952f, -0.50575739f, 0.12330034f, 0.08823135f, -0.06588026f, 0.00603626f, 
    -0.06799213f, -0.01931896f, 0.24101284f, 0.07561311f, -0.48509607f, 0.42807239f, -0.11388581f, 0.08463531f, 
    0.19456568f, -0.09062000f, 0.22448844f, -0.00004180f, -0.02936214f, 0.04548119f, -0.01166463f, 0.02632020f, 
    0.25394401f, -0.10656355f, -0.07473338f, 0.28423402f, -0.20661472f, 0.20323393f, -0.12435617f, 0.17761563f, 
    0.03903308f, -0.23411798f, -0.06864814f, -0.19983634f, -0.82056677f, -0.03630162f, -0.12099526f, 0.07136735f, 
    0.26769379f, 0.05614106f, 0.26580676f, 0.12153688f, -0.05949017f, -0.08006449f, 0.01979422f, -0.06060719f, 
    0.21859694f, 0.20142716f, -0.13110323f, -0.24770728f, -0.14738201f, 0.12950477f, -0.24847227f, -0.37912181f, 
    0.02021662f, 0.17852698f, 0.13069566f, 0.15009426f, -0.34303439f, 0.35411251f, -0.22453724f, -0.01119923f, 
    -0.42121226f, 0.11967947f, -0.09738162f, 0.03432060f, 0.11856268f, 0.00743614f, 0.01212240f, 0.00998985f, 
    -0.66634065f, 0.48948190f, 0.03456224f, 0.11898968f, -0.21342877f, 0.00889164f, 0.04104549f, -0.08319817f, 
    -0.04896931f, 0.00158969f, 0.17799132f, -0.40459999f, 0.12415263f, -0.02377923f, -0.24215360f, 0.08178058f, 
    0.09280494f, 0.03589304f, 0.05415750f, -0.20838429f, -0.24719034f, -0.03860769f, 0.08239919f, 0.06041497f, 
    0.92475379f, -0.41686866f, -0.06999549f, 0.34786537f, -0.18373254f, -0.20678055f, -0.15612696f, -0.11400812f, 
    0.15381895f, 0.29650342f, 0.08516985f, -0.10992429f, -0.10876995f, 0.00762240f, -0.09612436f, 0.03541997f, 
    -0.30826306f, -0.15351012f, -0.02403042f, -0.11161155f, -0.31382960f, 0.02996278f, 0.10354919f, -0.29964569f, 
    -0.27909029f, 0.01202981f, -0.16922539f, 0.13985378f, 0.04486535f, -0.21519029f, 0.04497784f, 0.10395870f, 
    -0.12647000f, 0.13075340f, 0.12527321f, 0.06708261f, 0.21553475f, 0.36837268f, -0.53763419f, 0.11375856f, 
    0.34382963f, -0.12272729f, 0.00968363f, -0.00060759f, 0.03453339f, -0.14496887f, -0.02864205f, -0.17462847f, 
    -0.33058229f, -0.36152932f, 0.04204578f, -0.31745845f, -0.07673763f, -0.08020350f, -0.38488150f, 0.15426660f, 
    -0.18893722f, 0.04758052f, -0.10995904f, -0.09052503f, 0.30092606f, -0.02126730f, -0.31896895f, 0.31034210f, 
    0.14596936f, 0.04154247f, 0.02006464f, -0.12449025f, 0.19290332f, 0.30868265f, -0.02771016f, -0.04748525f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.21255809f, 0.05906696f, -0.04812710f, -0.08739904f, 0.07632470f, -0.07717354f, 0.00501344f, -0.11375980f, 
    -0.07007362f, 0.06824745f, 0.18761675f, 0.05009308f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
