#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.49364290f, -1.06177509f, 0.38299638f, -0.95062411f, -0.51577365f, 0.21896590f, 0.20596679f, 0.21250336f, 
    0.80352783f, 0.65887803f, 0.44489297f, 0.97404921f, 0.01398696f, 0.24164097f, 0.84289771f, -0.81747693f, 
    -0.58044773f, -0.27474260f, -0.94356483f, -1.41798639f, -0.80939728f, -0.44986367f, -0.37000713f, 0.16796127f, 
    0.29323566f, -0.44598609f, -0.11264364f, -0.46066803f, -1.04295087f, -0.96991003f, -0.61633766f, 0.79034442f, 
    0.89589113f, -0.03783996f, 0.22092620f, 0.44586951f, -1.51428723f, 1.26396239f, -0.66988540f, 0.39246076f, 
    0.19812328f, -0.36596271f, -0.12528476f, 0.09396478f, -0.46369237f, 0.77881610f, -0.07933979f, -0.51196361f, 
    -0.91624981f, 0.04440909f, 0.75961488f, -0.64590400f, -0.69318366f, 0.82769203f, -0.01333417f, -0.39062470f, 
    0.32062572f, -0.70481396f, -1.12516510f, -1.11750996f, -0.64768732f, 0.46363610f, 0.81681716f, -0.38338053f, 
    -0.98801851f, -1.03084731f, -0.59603357f, 0.92816037f, -0.58833522f, 0.63273400f, 0.63169098f, -0.29036775f, 
    0.57789272f, -1.02759087f, -0.79829854f, -1.02724349f, -0.40493691f, 0.70469636f, 0.57360721f, 0.37417659f, 
    0.01662297f, 0.61244339f, 0.14271690f, -0.00727309f, -0.54355121f, 1.37579620f, 1.00977337f, -0.36045963f, 
    0.61629224f, -0.49380970f, -0.16122700f, -0.24186927f, 0.25914577f, -1.05228889f, 1.06834078f, -1.30788648f, 
    0.39389798f, -0.26235315f, -0.19423018f, 1.25058031f, -1.18755698f, -0.10238835f, -0.57357085f, 0.43465629f, 
    -0.54619139f, -0.39122713f, 0.37472886f, 0.10517835f, 1.41864777f, 0.91907328f, 1.00272250f, -0.29489404f, 
    -0.57672733f, -0.64300472f, -0.43266064f, -0.76700115f, 0.02622147f, -0.99688345f, -0.49847001f, 1.35293567f, 
    -0.32763976f, -0.09454612f, -0.40893969f, 0.05018188f, 0.32047519f, 0.26315138f, -1.71620929f, 0.12482189f, 
    -1.45382524f, -0.01035056f, 0.98732919f, 0.63674539f, -0.01262622f, -0.43246701f, 0.54197687f, -0.64201772f, 
    -1.08818269f, -1.16632628f, 0.54379457f, -0.16693833f, 0.35652134f, -0.75657022f, -0.51137841f, -0.01354445f, 
    0.55117065f, 0.15393820f, 0.91852671f, -0.46583319f, -1.31912088f, 0.78654051f, -0.00600250f, 0.41049975f, 
    -0.29780427f, 1.34955275f, 1.01335418f, 0.94867843f, 0.14079699f, 0.59687948f, -0.11626650f, -0.19096076f, 
    0.87833363f, 0.37368682f, 1.10720634f, 0.97983432f, 0.30472338f, 0.23828486f, 0.17984666f, -0.09407200f, 
    0.80736971f, -0.61015660f, 0.65651369f, -0.48284453f, 1.08374083f, 0.49895096f, -0.38032189f, -1.05129945f, 
    -0.96259409f, 0.10012967f, -0.48745424f, -0.67319280f, -1.16646302f, 1.01300812f, 0.89779234f, 1.27229464f, 
    0.93945557f, 0.15000567f, 0.70740074f, -0.31770509f, -0.22145689f, -0.90119720f, -1.11801243f, 0.14853777f, 
    0.93205190f, 0.89186478f, 1.24451077f, -0.22221239f, -0.75523204f, -0.52351546f, -0.42888355f, -0.31926832f, 
    -0.75667375f, -0.20848541f, -0.79880369f, 0.94851965f, -0.77337003f, 0.13013791f, -0.40178385f, -0.76443267f, 
    0.10649338f, 0.33889073f, -0.52522373f, 0.42937979f, 0.83668143f, 0.74883592f, -0.06608964f, 0.75047761f, 
    1.11486638f, 0.51714760f, -0.19028950f, -1.27555394f, -0.61450738f, -1.00620699f, 0.37773341f, 0.38629606f, 
    0.00683067f, 0.50272703f, -0.12386621f, -1.01459229f, 0.67103612f, -1.16787064f, -0.52715838f, -0.85561877f, 
    -0.51519793f, 0.29907095f, -0.89711028f, -0.87967718f, 0.49328309f, -1.24107170f, 0.70371783f, 0.39383474f, 
    -0.06519610f, 0.50857031f, -0.21740380f, 1.19800055f, 0.94722664f, 0.81820583f, 0.42008945f, -0.39417502f, 
    0.54924172f, -0.15991980f, 0.50381559f, -0.59471494f, 1.17308509f, -1.12101436f, 0.42898783f, 1.67688942f, 
    0.26263717f, -0.20125861f, 0.28517264f, -0.11530558f, -0.05275410f, 0.29937068f, 1.37045217f, -1.00948405f, 
    1.30134451f, 0.25725061f, -0.85700721f, 0.18609475f, 0.04305870f, -0.11708102f, -0.53380233f, 0.27268043f, 
    0.05657720f, -0.91028786f, -0.80586404f, 0.09551276f, -0.09098916f, 0.25784573f, -0.20850849f, -1.35653055f, 
    -1.21921682f, -0.99552023f, 0.24750865f, -0.67177474f, -0.24025747f, 0.39562002f, 0.46432886f, 0.38303274f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.06981026f, 0.58833516f, -0.49233994f, -0.26290262f, -0.08879636f, -0.24634010f, -0.16888975f, 0.28850442f, 
    -0.12000092f, -0.07915445f, 0.03831391f, -0.23721422f, 0.43146107f, 0.28798777f, 0.06114184f, 0.18002473f, 
    -0.02731988f, 0.41247496f, -0.00485946f, 0.14724639f, -0.15676396f, 0.07875414f, -0.24458040f, -0.10129783f, 
    0.25994843f, 0.02719365f, 0.08492463f, 0.14846286f, 0.30867264f, -0.18265270f, 0.42506236f, -0.00300680f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.19265497f, -0.06702895f, -0.19869024f, 0.01018709f, 0.12855369f, -0.13143460f, 0.07248746f, -0.20171928f, 
    -0.15501444f, 0.11128533f, 0.03818307f, 0.21904631f, 0.16456790f, 0.01886819f, -0.13951255f, 0.28627864f, 
    0.01289927f, 0.10036251f, 0.22610374f, -0.01385818f, -0.20350315f, -0.16796501f, 0.06286685f, 0.18457159f, 
    -0.29963133f, 0.09371911f, -0.05987916f, -0.11010250f, 0.02943151f, -0.07571578f, -0.04211748f, 0.04181897f, 
    0.22529231f, -0.00478564f, 0.10467324f, -0.25006726f, -0.24272218f, -0.21758914f, 0.38575399f, -0.34407899f, 
    -0.19155945f, -0.06454872f, -0.10010817f, -0.06213180f, -0.17799850f, -0.04185650f, 0.11090610f, 0.24706990f, 
    -0.03537311f, 0.08976701f, 0.06535608f, -0.02220405f, -0.04483467f, 0.19681382f, -0.04312481f, -0.05790950f, 
    -0.16386901f, 0.24379900f, -0.13959135f, 0.12109571f, -0.05930438f, -0.25699979f, -0.22102949f, 0.01424481f, 
    -0.04804025f, -0.18286362f, 0.19169575f, 0.10392752f, 0.01010983f, -0.09521300f, -0.04615572f, 0.10703417f, 
    0.14614739f, 0.01890453f, -0.18069158f, -0.04754469f, 0.04013431f, -0.08666036f, 0.06854055f, 0.29244849f, 
    0.10139123f, -0.35476172f, -0.37165558f, 0.36786708f, -0.03389710f, 0.14291181f, -0.29395610f, -0.21550758f, 
    0.02993503f, 0.01988945f, -0.05281989f, -0.13183400f, -0.47322345f, 0.11396001f, 0.07826909f, 0.11124793f, 
    -0.04138529f, 0.00928550f, 0.12259803f, 0.00941474f, -0.04064931f, -0.12275773f, -0.10340404f, -0.04243192f, 
    -0.20148018f, 0.13271318f, 0.15898634f, 0.21452151f, 0.56327456f, 0.40645304f, 0.08331573f, 0.17737782f, 
    -0.21834213f, -0.07650869f, 0.02579203f, 0.07612563f, 0.03511719f, -0.32350123f, 0.14630927f, 0.11958545f, 
    0.13408765f, -0.09952101f, 0.06526992f, 0.11606244f, 0.04206992f, -0.09338711f, 0.02904285f, -0.16839911f, 
    0.45272321f, -0.11061955f, 0.06385633f, 0.03877751f, -0.08859462f, 0.04679177f, -0.02606221f, -0.13459417f, 
    -0.19780926f, -0.16790088f, -0.17282981f, -0.01293344f, 0.19814312f, 0.02933112f, -0.02603571f, 0.23585740f, 
    0.29894203f, 0.09127519f, 0.09871198f, -0.05519683f, -0.23738118f, -0.19283172f, 0.08588047f, -0.08023886f, 
    0.16205864f, 0.51546633f, 0.28385779f, 0.01559278f, -0.07391469f, -0.11989437f, -0.19422646f, 0.17551968f, 
    -0.00456086f, -0.13067126f, 0.37111801f, -0.04697087f, -0.03142928f, 0.08662555f, -0.04739916f, 0.11645436f, 
    0.03084892f, 0.17429918f, -0.17969790f, -0.02438608f, 0.11996744f, -0.37559214f, -0.08534481f, -0.10002185f, 
    -0.09692906f, 0.05316256f, 0.15484248f, -0.00108174f, -0.41604269f, -0.52283561f, -0.14716211f, -0.08489821f, 
    0.21251412f, 0.30418745f, -0.09114402f, -0.01690858f, -0.20343706f, -0.22959575f, -0.04798831f, -0.04551516f, 
    0.26371709f, -0.03352067f, 0.36503196f, -0.25463253f, -0.00411630f, 0.10101929f, -0.29328835f, -0.19885075f, 
    -0.30249786f, -0.20329101f, 0.00443153f, -0.18453662f, -0.07133192f, 0.01765027f, 0.12024304f, -0.62997705f, 
    -0.10745157f, 0.22397155f, -0.00916605f, 0.26625773f, 0.10088053f, -0.05230508f, 0.01772958f, -0.22359255f, 
    0.62116498f, 0.21791525f, -0.31114280f, 0.12366301f, 0.05255444f, -0.14511752f, 0.08769758f, -0.10989585f, 
    -0.00824262f, 0.00052455f, -0.09515167f, 0.17565303f, 0.08208264f, 0.12097769f, -0.04357355f, 0.04180897f, 
    0.05550054f, 0.26261193f, -0.37295604f, -0.00704933f, 0.00789991f, 0.09855783f, -0.01178455f, 0.00635904f, 
    -0.05373416f, 0.17312530f, 0.14497623f, 0.66827267f, 0.26756793f, 0.27790031f, 0.07481282f, -0.24991827f, 
    -0.15405865f, 0.26224166f, -0.07327398f, -0.09042807f, -0.06059410f, -0.19778477f, -0.33595082f, 0.03593090f, 
    0.02557271f, 0.30480033f, -0.09436014f, 0.20924579f, 0.04157223f, 0.17092419f, 0.29093227f, 0.49938142f, 
    0.08096208f, -0.08206680f, 0.05807763f, 0.10298904f, 0.20190413f, 0.14442874f, -0.15899895f, -0.02007676f, 
    -0.06368800f, 0.08012188f, 0.17720443f, 0.06911209f, 0.04317350f, 0.17137393f, 0.15526298f, 0.01628252f, 
    -0.25490439f, 0.07684586f, 0.10950608f, -0.01299863f, -0.19400401f, -0.04527754f, 0.01152663f, -0.15865332f, 
    -0.06276835f, 0.03334941f, 0.04150732f, -0.02573287f, -0.04438646f, -0.00875440f, -0.03929434f, -0.05414542f, 
    -0.04138199f, -0.02779353f, -0.04209929f, -0.02448374f, 0.01037108f, 0.03695233f, -0.04838263f, -0.06408242f, 
    -0.06073930f, -0.03647222f, 0.02771668f, -0.02028528f, 0.01668069f, -0.01447121f, 0.01675416f, 0.00472430f, 
    -0.00546735f, -0.04880832f, 0.03194941f, 0.03584410f, 0.04270387f, 0.03850143f, -0.03369265f, -0.00714852f, 
    0.01130560f, -0.01944862f, 0.00085091f, -0.02510987f, 0.03330825f, -0.00852496f, 0.01534471f, 0.02241588f, 
    -0.02344601f, 0.01329328f, 0.02394216f, -0.00937808f, 0.00487611f, -0.01846202f, -0.02334297f, 0.00640050f, 
    -0.03756158f, -0.04038173f, 0.03503122f, 0.04562378f, -0.02120712f, -0.04762823f, 0.02076946f, 0.03113572f, 
    0.04794814f, -0.06525183f, 0.03335824f, -0.03366361f, -0.05752863f, -0.03990746f, -0.06547549f, 0.01615320f, 
    0.04649030f, -0.00819547f, 0.00345170f, 0.00716828f, 0.02785293f, -0.05855443f, 0.03950747f, -0.02642867f, 
    0.00172187f, 0.03309894f, -0.01903789f, -0.04786087f, 0.02709237f, -0.04448538f, -0.04420745f, 0.02738190f, 
    -0.01794576f, -0.04529942f, -0.02587338f, 0.00312387f, 0.01325729f, 0.01630938f, 0.00568119f, 0.02209338f, 
    0.04566853f, 0.00629279f, -0.04426501f, 0.04108564f, 0.01609213f, -0.02662117f, 0.02036053f, 0.04563344f, 
    -0.03151236f, 0.04856841f, -0.04472593f, 0.01926851f, -0.04346872f, 0.02348394f, -0.02000370f, -0.00837373f, 
    -0.03648680f, -0.01992001f, -0.01745232f, 0.03139242f, -0.04526241f, 0.04996981f, 0.03530205f, -0.03766908f, 
    -0.03620533f, 0.02127339f, 0.04699599f, -0.05701965f, -0.04364569f, 0.02744132f, -0.03678903f, -0.02442909f, 
    -0.03444499f, -0.04642169f, 0.01669098f, -0.02053624f, -0.01622218f, 0.04167309f, 0.02027840f, -0.00627850f, 
    -0.02332452f, -0.02870943f, 0.03662121f, -0.01978377f, 0.00359808f, -0.02524908f, 0.04779003f, -0.00371338f, 
    -0.02653010f, -0.01308257f, 0.00395635f, 0.01418446f, -0.06236396f, 0.01706154f, -0.00578558f, -0.02199764f, 
    0.05248129f, 0.01364896f, -0.04659208f, -0.05995704f, -0.01063516f, -0.00391610f, -0.00320106f, 0.02532260f, 
    -0.04272891f, -0.06815719f, 0.04778419f, 0.03138482f, -0.01492506f, -0.01577968f, -0.03938273f, -0.03715076f, 
    -0.03214444f, -0.00646824f, 0.00126091f, -0.02194588f, 0.04181331f, -0.01674796f, -0.00894899f, -0.02915997f, 
    0.01030293f, -0.05323311f, -0.05459506f, 0.04830521f, -0.00703660f, -0.00827292f, 0.03268933f, -0.04968651f, 
    0.03001686f, 0.01913499f, -0.05851669f, 0.04274935f, 0.00002200f, 0.03820523f, -0.06280343f, -0.03272425f, 
    -0.01460862f, 0.02252104f, -0.03000214f, 0.01576865f, 0.04256050f, 0.01457371f, 0.00553627f, -0.05352394f, 
    -0.05802015f, 0.00520336f, -0.05124287f, -0.04880437f, 0.00055534f, -0.00306296f, 0.05122925f, -0.03744417f, 
    -0.04949576f, 0.04666078f, -0.03394813f, -0.05517317f, -0.06679299f, -0.05388787f, -0.03850335f, -0.05029338f, 
    -0.04020483f, 0.03660143f, -0.02361607f, 0.03741645f, 0.04979339f, -0.05081375f, -0.02351950f, -0.00612035f, 
    0.02799226f, 0.00424853f, -0.01459848f, -0.01901533f, -0.04916519f, 0.04095563f, -0.01223556f, 0.00464140f, 
    0.02996593f, 0.01493244f, 0.02328409f, -0.06366266f, -0.03232894f, 0.03866427f, 0.02222290f, -0.03218143f, 
    0.03031891f, 0.02166687f, -0.03642609f, -0.05677474f, 0.04621581f, -0.05386236f, -0.04450328f, 0.02682727f, 
    0.03987435f, -0.00590225f, 0.02776753f, -0.03311066f, -0.01804004f, -0.01366034f, -0.00994740f, -0.01343414f, 
    0.02463817f, -0.05024690f, -0.00794387f, 0.02708195f, -0.05699273f, 0.04090648f, 0.02022666f, 0.03426456f, 
    -0.02537748f, 0.02710877f, -0.04613916f, 0.00117223f, -0.04079765f, 0.04725708f, 0.00902001f, -0.06427638f, 
    -0.05436676f, 0.01927809f, -0.01482833f, 0.00380373f, -0.00460186f, -0.01306135f, -0.02616357f, -0.04786702f, 
    0.01960965f, -0.05417417f, 0.01703808f, -0.03272546f, -0.01276121f, -0.05856805f, -0.00459707f, -0.01547597f, 
    0.03481983f, 0.02120421f, -0.00377858f, -0.06380856f, -0.05051887f, 0.02658818f, -0.06794471f, 0.03522249f, 
    0.02284308f, 0.03721475f, -0.00327383f, -0.00338574f, -0.01920262f, -0.04913024f, -0.02425034f, -0.04273577f, 
    -0.04550361f, -0.03067253f, 0.03605793f, -0.00570603f, 0.03314321f, -0.02052319f, 0.01675278f, -0.03457173f, 
    -0.06614068f, 0.01404256f, 0.00824166f, 0.04935057f, -0.00058453f, -0.00052387f, 0.02650995f, -0.06634195f, 
    -0.01649292f, -0.04955147f, -0.03207617f, 0.01638555f, -0.03917319f, 0.01230362f, 0.01500584f, -0.05471689f, 
    0.02141229f, -0.03687100f, -0.02088294f, 0.02469807f, -0.04249220f, 0.00765145f, -0.02331334f, 0.04538672f, 
    0.01052905f, 0.04973846f, -0.01474854f, -0.02214220f, -0.02909465f, 0.04722684f, -0.06226739f, 0.05109135f, 
    -0.00200531f, -0.00628929f, -0.01567823f, -0.00783041f, -0.04545057f, -0.03816873f, 0.04333960f, 0.01768005f, 
    0.05203439f, 0.04467672f, 0.01981673f, -0.01412148f, -0.06103320f, 0.00248997f, 0.01956674f, -0.00579346f, 
    -0.00215250f, -0.03533897f, -0.06105551f, -0.01281613f, 0.01480871f, 0.04335156f, -0.04201920f, -0.05779344f, 
    -0.05703684f, 0.03810290f, -0.05000860f, 0.02998665f, -0.05685147f, -0.00888851f, 0.01398089f, -0.00838638f, 
    -0.00928369f, -0.02164840f, -0.05420060f, 0.00682062f, -0.04065791f, 0.01506761f, 0.04730272f, -0.05851155f, 
    0.03623774f, 0.00035467f, -0.01781534f, 0.02144303f, 0.04884354f, -0.00198438f, 0.04681590f, 0.03203365f, 
    -0.02623602f, -0.06238035f, 0.02822158f, -0.01910260f, -0.04516164f, -0.03614292f, 0.02724531f, 0.02003306f, 
    -0.06593265f, -0.04468992f, -0.04075250f, -0.04225441f, -0.06793071f, -0.02074297f, 0.04109498f, 0.02880398f, 
    0.00374999f, 0.04610142f, -0.04721871f, 0.00791111f, -0.01135711f, -0.02061317f, 0.04510771f, -0.04924839f, 
    0.02121471f, -0.05131310f, -0.00987167f, -0.04923426f, 0.03854303f, 0.03616523f, -0.05574325f, -0.01769001f, 
    -0.01804890f, -0.02986969f, -0.04417333f, 0.05177755f, 0.01916501f, 0.02694883f, 0.04511110f, -0.03126225f, 
    -0.03591173f, 0.05232323f, -0.00377384f, -0.00125958f, 0.02748721f, 0.01518579f, -0.05336584f, -0.03336107f, 
    -0.01667021f, 0.01696682f, 0.00504359f, 0.00027547f, 0.03454191f, 0.02778402f, -0.05929514f, -0.03009217f, 
    -0.04085112f, -0.04854087f, 0.04880930f, -0.05155234f, 0.01458331f, 0.03100475f, 0.00154853f, -0.04472962f, 
    0.00592536f, -0.00846705f, -0.00395099f, -0.05850767f, -0.06746645f, -0.02321220f, -0.03987657f, -0.01712773f, 
    0.01439832f, -0.03737775f, -0.01170512f, 0.03047502f, 0.02972469f, -0.05632220f, 0.00133781f, 0.04493592f, 
    -0.00602984f, -0.03522694f, -0.06013414f, 0.03014119f, -0.02614068f, 0.03719289f, -0.03601704f, 0.00530843f, 
    -0.00185980f, -0.06434169f, -0.03839237f, -0.02359451f, 0.04596085f, -0.05920280f, -0.04904355f, 0.03734538f, 
    -0.06106974f, -0.02862150f, -0.03661237f, 0.00417468f, 0.04789766f, 0.01538678f, -0.03405151f, 0.01898971f, 
    0.00039739f, -0.06061658f, -0.03910922f, -0.03071305f, 0.01052156f, 0.00225153f, 0.02046313f, 0.03133030f, 
    -0.05975121f, -0.01865030f, 0.02516457f, -0.03532526f, -0.03193819f, -0.01361837f, 0.04149721f, 0.02049821f, 
    -0.02034478f, 0.01521421f, -0.03806922f, 0.02077952f, -0.05590210f, -0.02693506f, -0.03720740f, 0.00893497f, 
    0.00842571f, -0.06044132f, -0.04210743f, -0.00974027f, 0.05099421f, 0.00128081f, 0.02189466f, 0.03564593f, 
    0.04211197f, -0.05919891f, 0.04684900f, 0.03174168f, -0.00867528f, 0.03221947f, -0.03235213f, -0.03660870f, 
    -0.01686811f, 0.01567645f, -0.02122467f, -0.05228671f, -0.04655711f, -0.04237370f, 0.01585134f, -0.00270899f, 
    0.02772852f, -0.04999779f, 0.02493106f, -0.03695675f, -0.00206713f, -0.00511244f, 0.04675470f, -0.05358218f, 
    -0.03171492f, 0.00175060f, 0.02248220f, 0.01571769f, -0.05485955f, 0.04532606f, 0.03914511f, 0.02196432f, 
    -0.03872572f, 0.03972351f, -0.01573652f, -0.03496712f, 0.01583855f, -0.05949439f, 0.03596634f, -0.05528273f, 
    -0.04222707f, -0.02168460f, -0.01688676f, -0.01286649f, 0.00592244f, 0.00987056f, 0.04413236f, 0.00190541f, 
    0.03324620f, 0.01619382f, -0.06441793f, 0.03282883f, -0.02465732f, 0.01675276f, 0.04743987f, 0.00247258f, 
    0.35408232f, 0.05304036f, 0.30778509f, -0.07148620f, -0.26185632f, 0.00941457f, 0.12254709f, -0.08711057f, 
    0.06626248f, -0.06979865f, -0.16385891f, -0.11160927f, -0.04808332f, -0.06898286f, 0.05219351f, -0.07601104f, 
    -0.04382307f, 0.30616704f, 0.14511856f, 0.34633151f, 0.15147062f, 0.18334986f, 0.15498394f, -0.06949469f, 
    0.05346131f, 0.17972589f, -0.24786501f, 0.17464213f, 0.05520223f, 0.15794639f, 0.09292528f, 0.10950931f, 
    0.04672038f, -0.12935141f, 0.30461696f, 0.07845587f, -0.05735765f, -0.07986644f, 0.25449878f, 0.18519506f, 
    0.13811480f, 0.05219918f, -0.10883042f, 0.11356297f, -0.05447069f, 0.10044502f, -0.19689977f, 0.08033044f, 
    -0.03658540f, -0.10947519f, -0.02298554f, -0.14874007f, 0.11012060f, 0.25718245f, 0.46964577f, 0.05121727f, 
    0.11612137f, -0.27607524f, 0.21531846f, 0.25136003f, -0.25212020f, -0.02392063f, -0.26749763f, 0.04341342f, 
    0.18913870f, 0.21494219f, 0.09724359f, 0.02020444f, -0.01349791f, 0.37584472f, 0.04223663f, -0.27635056f, 
    0.09539199f, 0.31182486f, 0.29699939f, -0.11601142f, -0.00046553f, -0.16505985f, -0.08315897f, 0.10321433f, 
    -0.20919886f, 0.25285992f, -0.12957594f, -0.09268346f, 0.21158993f, -0.04306195f, -0.27276132f, -0.13985272f, 
    0.00717071f, 0.21957512f, -0.06911625f, 0.36812219f, 0.09911630f, 0.01522236f, 0.04603619f, 0.19917403f, 
    -0.00725945f, 0.13310365f, -0.13604547f, 0.24998565f, 0.10243480f, 0.28563437f, 0.06177595f, -0.05209239f, 
    -0.10605292f, -0.09718522f, -0.02376665f, -0.03214819f, -0.24674444f, -0.31954527f, -0.00518079f, -0.11663371f, 
    -0.05710353f, 0.09059699f, -0.27889505f, -0.00139406f, -0.05299092f, -0.02224236f, 0.04145693f, 0.01970642f, 
    -0.00155775f, 0.07167295f, 0.00778794f, -0.23338589f, -0.02621931f, 0.06331424f, 0.12886283f, 0.08130196f, 
    0.10723235f, 0.05043251f, 0.15878709f, -0.04562674f, 0.13010581f, 0.25894395f, -0.07890800f, 0.22065063f, 
    0.24155308f, -0.08742727f, 0.23593064f, 0.18866183f, 0.00390061f, 0.02715590f, 0.07152326f, -0.18531410f, 
    0.18952020f, -0.09204925f, -0.15527189f, -0.27056956f, -0.06226084f, 0.19525479f, -0.18495907f, -0.01620528f, 
    0.24039093f, -0.21336707f, 0.01288236f, -0.13529806f, -0.24777035f, -0.12233644f, -0.08840232f, -0.16010958f, 
    -0.06038969f, 0.09837659f, -0.54808468f, -0.09771006f, 0.04166578f, -0.04884200f, -0.06172317f, -0.07523209f, 
    0.07008145f, 0.22437420f, 0.25298604f, -0.25632846f, -0.25079235f, 0.00759542f, 0.01023704f, 0.00036013f, 
    0.16386358f, -0.20668168f, -0.31209630f, -0.18933113f, -0.05882458f, 0.02141231f, -0.19755542f, -0.05141046f, 
    -0.11519329f, -0.09228414f, 0.15245278f, 0.05249554f, 0.37518835f, 0.14605640f, -0.13734017f, -0.05520368f, 
    0.06195863f, 0.03602385f, -0.03106646f, 0.25991493f, 0.14944600f, -0.04589153f, -0.02942156f, 0.25291872f, 
    0.05875533f, -0.08987747f, 0.16744307f, -0.10429323f, 0.07480384f, 0.10972932f, -0.12651147f, -0.00148281f, 
    -0.00745672f, -0.10329617f, -0.01662461f, -0.03545624f, 0.13064902f, -0.09078112f, -0.00346711f, -0.09409322f, 
    0.18771602f, -0.35723117f, -0.09162465f, 0.02017677f, -0.18152456f, 0.24997018f, -0.12440363f, 0.06298962f, 
    -0.55100644f, 0.34294471f, 0.15673323f, 0.14504963f, 0.02773854f, -0.19401652f, 0.25930929f, -0.15329957f, 
    -0.14076202f, -0.29400280f, -0.07755677f, 0.11344797f, 0.26483962f, 0.09619848f, 0.06328861f, 0.01341770f, 
    0.02776223f, -0.21841829f, 0.09459084f, -0.19949743f, -0.12257260f, -0.06746238f, -0.25732943f, 0.05974786f, 
    -0.20714134f, -0.21348237f, 0.17949362f, 0.19553176f, -0.00272465f, -0.15969250f, -0.08322981f, 0.05462721f, 
    0.04378569f, -0.03068106f, 0.04179943f, 0.14130914f, 0.17298074f, -0.02845099f, 0.26661804f, -0.10187708f, 
    -0.07292404f, -0.08760440f, 0.17232057f, -0.00641801f, 0.15956534f, -0.41445795f, -0.00594843f, -0.01287746f, 
    0.18426611f, -0.03642009f, -0.03958723f, -0.03149692f, -0.11761151f, -0.16647710f, 0.05583407f, 0.08453996f, 
    0.37153804f, 0.04396653f, 0.09117407f, -0.01888338f, 0.27916798f, -0.05768093f, 0.25122616f, -0.05627224f, 
    -0.13206895f, -0.08444068f, -0.25385657f, -0.16515607f, -0.01274389f, -0.08015971f, 0.05456389f, -0.12525587f, 
    0.06807485f, 0.01492834f, 0.20158941f, 0.18303503f, 0.20945042f, -0.02022447f, 0.13239986f, 0.18242109f, 
    0.06034430f, -0.01734580f, -0.27892330f, 0.01152438f, -0.31737229f, 0.00174871f, -0.12752150f, 0.10560083f, 
    0.02598371f, -0.02980814f, 0.10223359f, -0.21830669f, -0.55496418f, -0.53069252f, 0.23079386f, 0.00189144f, 
    -0.00807113f, -0.04345891f, -0.20281351f, -0.14632586f, -0.11426114f, -0.49790496f, -0.34657708f, -0.09429508f, 
    -0.09323159f, 0.03621798f, -0.00021519f, -0.02321212f, 0.01555408f, -0.67742062f, -0.25058827f, 0.06867449f, 
    0.00836389f, -0.01784205f, -0.31637347f, -0.07440726f, -0.08892856f, -0.05274991f, -0.03059980f, 0.13083975f, 
    -0.41567376f, -0.08877350f, 0.09448435f, 0.14938368f, -0.30570933f, 0.19371596f, 0.41708353f, -0.38150576f, 
    -0.42721292f, -0.16555077f, 0.12357338f, 0.04346806f, -0.00508262f, 0.13945718f, 0.00731923f, -0.20517381f, 
    -0.15232082f, -0.50624192f, 0.02615052f, -0.17002931f, -0.15989994f, -0.15609039f, 0.17617399f, 0.34311280f, 
    -0.09331977f, 0.00171421f, 0.09797624f, -0.15077549f, 0.13160470f, 0.04816233f, 0.15196665f, 0.05223709f, 
    0.11805452f, -0.04497297f, 0.13520415f, 0.09675641f, -0.05083615f, 0.15950929f, 0.12852116f, 0.12518926f, 
    0.30969375f, -0.09808518f, 0.04072714f, 0.01529995f, -0.37442526f, -0.26211929f, -0.17184483f, 0.08057606f, 
    -0.38362163f, -0.20123953f, -0.17846583f, -0.29171118f, -0.09217251f, 0.32364881f, 0.24485558f, -0.27247882f, 
    -0.18053140f, 0.14929235f, 0.02572795f, 0.13125204f, 0.05841397f, 0.03013906f, -0.13606022f, -0.14286052f, 
    0.21438129f, 0.18206623f, 0.12672719f, -0.08145832f, -0.03032891f, 0.05168890f, 0.48140892f, -0.29976097f, 
    -0.28570503f, 0.19549431f, 0.01130508f, 0.12451582f, 0.04575856f, -0.18473257f, -0.04672316f, 0.04089434f, 
    0.07246290f, -0.07538544f, 0.09837677f, -0.05663854f, -0.05485184f, 0.28072029f, 0.13010305f, -0.08698156f, 
    0.20389907f, 0.42409131f, 0.33029446f, -0.15394925f, -0.13606510f, 0.22765094f, 0.01981308f, 0.09158839f, 
    0.02558383f, -0.05218051f, 0.37420246f, 0.32252675f, 0.01627599f, 0.11765668f, 0.19883174f, -0.02564538f, 
    0.05357118f, 0.09558754f, -0.17803723f, -0.03301693f, 0.24340306f, 0.02005383f, -0.00131828f, 0.14137150f, 
    0.25426567f, 0.21450120f, -0.11229208f, 0.31463173f, -0.00325415f, -0.00909115f, -0.03403512f, -0.03187050f, 
    -0.10537454f, -0.01303282f, 0.03563616f, 0.26201382f, -0.11235704f, -0.18002795f, 0.21838562f, -0.05950368f, 
    0.12054811f, -0.06039729f, 0.05518599f, 0.02089542f, 0.01671159f, 0.42914134f, 0.15687954f, -0.50498974f, 
    0.09171513f, -0.11948028f, 0.25922889f, 0.05749279f, -0.13698587f, -0.04775942f, -0.37724978f, 0.14902858f, 
    0.04345635f, 0.11849599f, -0.10780974f, -0.22928014f, -0.01628808f, -0.03582135f, 0.12653738f, 0.27467847f, 
    -0.21465024f, -0.10817441f, -0.18705797f, -0.00342527f, -0.00103751f, 0.34165660f, -0.37997201f, 0.00972055f, 
    0.28659493f, 0.11672244f, -0.05549303f, -0.29077655f, -0.01073755f, 0.16051939f, -0.17007008f, -0.06075836f, 
    -0.03683677f, -0.19451350f, -0.08444945f, 0.21644925f, 0.04841154f, -0.01306726f, -0.22123058f, 0.14553159f, 
    -0.02631474f, -0.07258976f, 0.21052703f, -0.29555923f, -0.14573407f, 0.07154483f, 0.08990480f, 0.04020885f, 
    -0.03351451f, 0.06064215f, -0.05437442f, -0.16512591f, 0.29449126f, 0.37445021f, 0.02439454f, 0.09691340f, 
    0.09628183f, 0.03080135f, -0.00410827f, -0.03874419f, 0.30777356f, -0.19065741f, -0.01411732f, 0.24147569f, 
    0.17953032f, 0.13853514f, 0.37313795f, 0.19882494f, -0.10427145f, -0.54322910f, -0.32044521f, 0.43685263f, 
    0.01032752f, 0.28825331f, 0.00318942f, -0.04668840f, -0.10692281f, -0.16483930f, -0.10756478f, -0.16582416f, 
    0.09792891f, -0.09243481f, 0.26760566f, 0.13518979f, 0.02833369f, 0.25951600f, 0.26777792f, -0.62746024f, 
    -0.09632851f, -0.15149610f, -0.08122631f, 0.15961136f, -0.06913015f, -0.00115819f, 0.04718048f, -0.15777741f, 
    0.43398783f, -0.23597591f, 0.08903784f, 0.25967824f, 0.28545314f, -0.10048431f, -0.13835706f, 0.10847407f, 
    -0.09703030f, 0.13592239f, -0.04077664f, -0.24355032f, 0.02207666f, -0.00017932f, -0.35851303f, 0.13733326f, 
    0.11618030f, 0.09511540f, -0.34393823f, 0.29905114f, -0.07197518f, -0.04490809f, -0.03549112f, 0.02924341f, 
    0.00470499f, 0.13131094f, -0.03093487f, 0.05098253f, 0.43551734f, -0.19803213f, 0.15484992f, 0.09359491f, 
    0.13461272f, 0.02264830f, 0.12714222f, -0.05046496f, 0.67613089f, -0.01398638f, -0.02223168f, 0.17164509f, 
    -0.01439193f, -0.05249104f, 0.07625731f, -0.06907048f, -0.20290691f, -0.20800477f, -0.34737203f, -0.15982117f, 
    -0.16522224f, 0.06177136f, -0.12092131f, -0.09641609f, -0.09144739f, 0.04952005f, 0.01634691f, -0.04074097f, 
    0.03442803f, -0.14140181f, -0.03044365f, -0.09217936f, -0.12581597f, 0.11024498f, -0.09477204f, -0.08965775f, 
    0.03564132f, 0.09851781f, 0.10675684f, 0.14103937f, 0.15683483f, -0.05920670f, 0.02337554f, -0.13664454f, 
    0.20429640f, -0.34896439f, 0.28939402f, -0.11997610f, 0.34756395f, -0.08916914f, 0.20889761f, 0.00889657f, 
    -0.01123242f, -0.29123682f, -0.20656462f, -0.53347415f, -0.10666772f, -0.12019897f, -0.28595245f, -0.09870230f, 
    -0.10233478f, 0.33309963f, 0.07783753f, -0.46272650f, -0.23789722f, 0.06985586f, 0.13951343f, 0.22192596f, 
    -0.04504181f, -0.06043522f, 0.02545891f, 0.32898206f, -0.63816112f, 0.17727295f, -0.11024794f, -0.19988744f, 
    0.06165718f, -0.07192852f, 0.03693884f, 0.08214254f, 0.12519509f, -0.00947965f, 0.16319036f, -0.02712418f, 
    -0.09498022f, 0.02842912f, 0.00210387f, 0.07637125f, 0.09644339f, -0.84460747f, -0.33694163f, 0.21052372f, 
    -0.13297388f, 0.15078820f, -0.20092791f, -0.23606753f, 0.25839740f, 0.08126897f, 0.80049562f, 0.68180680f, 
    -0.24766397f, 0.21218090f, 0.17968602f, -0.08499266f, 0.05623561f, -0.01513700f, -0.07657681f, 0.12192117f, 
    0.11294556f, -0.39512047f, -0.09155191f, 0.05585913f, 0.01507049f, 0.00536578f, -0.07974726f, -0.21461084f, 
    -0.17395180f, 0.27563989f, -0.06700084f, -0.03152354f, -0.24121723f, -0.24515387f, -0.08395098f, -0.01426953f, 
    0.19311057f, 0.04965756f, 0.32132640f, -0.03137906f, -0.13051079f, -0.10324825f, -0.17431206f, 0.01718517f, 
    0.10546406f, -0.06149584f, 0.09235363f, 0.09997792f, -0.01666641f, -0.34980729f, 0.11755601f, 0.19226688f, 
    -0.21352139f, 0.06685089f, -0.01851078f, -0.06289768f, 0.24479210f, 0.00789523f, -0.15648805f, 0.09609625f, 
    0.01221114f, -0.01542244f, 0.28135911f, 0.02565825f, 0.41892827f, -0.03601823f, 0.52961743f, -0.21307607f, 
    0.09542435f, -0.00060536f, -0.10064502f, -0.14172040f, 0.18419915f, -0.03995119f, 0.55177420f, -0.04003538f, 
    0.07695596f, -0.00817248f, 0.00654354f, 0.15298298f, -0.17311542f, 0.04643117f, 0.17933114f, -0.04175335f, 
    -0.56844145f, -0.00410200f, -0.01088552f, 0.28927436f, 0.26723537f, -0.18941027f, 0.05275209f, -0.46973893f, 
    0.10354155f, -0.58785582f, -0.01104364f, 0.02653588f, 0.10145479f, 0.14530590f, -0.04866249f, 0.14797072f, 
    0.35862893f, -0.02721335f, 0.10408730f, -0.02790443f, -0.11036077f, -0.07188837f, 0.14252421f, -0.17925200f, 
    0.23342554f, -0.13741036f, -0.66963100f, 0.03658224f, -0.13075343f, -0.09404834f, -0.10245845f, 0.00797074f, 
    0.22525446f, -0.17885058f, -0.22679430f, -0.05404181f, 0.21686587f, 0.06530931f, 0.05041530f, 0.14869706f, 
    0.13229215f, -0.10508659f, -0.15983166f, 0.19913505f, 0.10438434f, 0.21915826f, -0.14178826f, -0.08110464f, 
    -0.05198893f, -0.15179704f, 0.03076619f, -0.07427880f, 0.01438257f, -0.23219016f, -0.07625065f, -0.03725371f, 
    0.24901076f, -0.10382517f, -0.06964649f, 0.16901354f, 0.04192164f, 0.50056338f, -0.51758301f, -0.04351893f, 
    -0.21908556f, -0.08646613f, -0.16542970f, 0.01905242f, 0.13119057f, -0.06154191f, -0.73414993f, 0.02632266f, 
    -0.01164427f, -0.05461132f, -0.14487045f, 0.04948337f, 0.10810593f, -0.06348173f, 0.20855851f, -0.51137871f, 
    -0.16495901f, -0.38603303f, -0.06471211f, 0.02973336f, -0.12105890f, -0.14947544f, 0.08215640f, 0.14957079f, 
    -0.05870147f, 0.01460785f, -0.04392717f, -0.04540470f, -0.07017618f, -0.04957829f, 0.01295688f, 0.03966609f, 
    0.00491518f, -0.06070509f, 0.02602894f, 0.01740538f, -0.03314716f, -0.00589967f, 0.01214559f, 0.03521719f, 
    -0.05639833f, 0.02788561f, 0.00132871f, 0.01020451f, 0.02390256f, -0.03962427f, 0.00292006f, -0.05379491f, 
    -0.02035552f, -0.03461364f, -0.03240463f, 0.03124287f, 0.00230727f, -0.04367341f, 0.02682036f, -0.01587616f, 
    -0.06721111f, 0.01607600f, -0.03091672f, -0.04181967f, 0.01393494f, 0.01350503f, 0.00036490f, 0.02379296f, 
    -0.00387799f, 0.05029592f, 0.03121783f, -0.04121904f, -0.05702963f, -0.00952073f, -0.04248221f, -0.03199581f, 
    0.01918721f, -0.03284176f, -0.02932893f, -0.00299877f, -0.03090075f, -0.02257308f, -0.00088345f, -0.04547193f, 
    -0.05920775f, -0.00611822f, 0.03640174f, -0.02964032f, 0.02837588f, 0.04831324f, -0.01060787f, -0.01123162f, 
    -0.00742980f, 0.02716555f, -0.00652172f, -0.02771899f, -0.02656416f, -0.01156524f, -0.05638891f, -0.03045182f, 
    0.00904413f, -0.03581146f, 0.03197997f, 0.01493579f, -0.02383040f, -0.03574993f, -0.04020707f, -0.02325976f, 
    0.01829672f, -0.03403709f, 0.04782574f, -0.02734434f, -0.03815519f, 0.01088218f, -0.06133735f, -0.05137229f, 
    0.01023982f, 0.01894671f, -0.03134965f, 0.03651855f, -0.02734331f, 0.05316619f, -0.01634563f, -0.00708474f, 
    0.02622670f, 0.02282709f, -0.00473554f, -0.04584369f, -0.02053347f, -0.06444167f, 0.02280587f, -0.02897726f, 
    -0.03889636f, -0.04635791f, -0.00780366f, 0.01567928f, -0.01370921f, -0.06834480f, 0.01442518f, -0.00604944f, 
    -0.01215253f, 0.02331584f, 0.02341154f, -0.02167422f, 0.04324931f, -0.00186889f, -0.05636599f, -0.03026926f, 
    -0.04099215f, 0.00483072f, -0.04570179f, 0.04923794f, 0.01754041f, 0.01104473f, -0.06154094f, 0.01535393f, 
    -0.00002040f, -0.05590709f, -0.06507451f, 0.00473524f, -0.04984814f, 0.04687807f, -0.01087655f, -0.03597230f, 
    0.01921591f, 0.01483841f, -0.01787839f, -0.01979578f, -0.01780478f, -0.00359591f, 0.04039859f, 0.04110795f, 
    0.03022173f, 0.01770460f, -0.06706659f, 0.03187419f, -0.02420832f, 0.00225378f, -0.05058422f, -0.01707302f, 
    -0.00985411f, -0.02913186f, 0.00975560f, -0.02947035f, 0.02874287f, 0.02847933f, -0.06386820f, -0.00714043f, 
    -0.05140999f, -0.00387793f, -0.03868824f, -0.05816964f, -0.05354248f, -0.06219055f, -0.02887202f, -0.00021181f, 
    -0.00030419f, -0.04025828f, 0.05659674f, -0.05200989f, 0.01909932f, 0.05220065f, 0.01658448f, -0.04751891f, 
    0.01917587f, -0.02309392f, -0.02425573f, -0.01210793f, -0.03540204f, -0.00396622f, -0.00736095f, -0.02015936f, 
    -0.00890422f, -0.06261138f, -0.04219543f, 0.01285546f, -0.03825279f, -0.01140498f, 0.01093174f, -0.02225066f, 
    -0.03099018f, -0.03289441f, 0.05227910f, 0.00579946f, -0.00877009f, 0.01884612f, 0.01665413f, -0.02349929f, 
    -0.03099122f, 0.03900816f, -0.00770959f, 0.01695467f, -0.00563782f, -0.06504603f, 0.00027847f, -0.00297251f, 
    -0.01767652f, 0.01845440f, -0.05014793f, 0.01221522f, -0.04522754f, 0.00225099f, -0.05523527f, 0.00680442f, 
    0.02322616f, 0.03038033f, -0.04396093f, -0.04606896f, 0.05212780f, -0.05672510f, -0.00255607f, 0.03880244f, 
    -0.01759215f, -0.01157410f, 0.02924755f, -0.02086732f, 0.05383233f, -0.04382386f, 0.02482250f, -0.05099112f, 
    0.04898824f, 0.04707680f, 0.01595699f, -0.05851610f, -0.05715187f, -0.03664058f, 0.02269861f, -0.05597330f, 
    0.04309439f, -0.00894689f, -0.05748221f, 0.05110804f, -0.05519883f, -0.01746801f, 0.04290480f, -0.00557367f, 
    -0.01788743f, 0.02112654f, -0.00437805f, 0.04195108f, 0.04479232f, -0.06345766f, -0.01091366f, -0.01602656f, 
    -0.04737829f, 0.04737500f, 0.03752263f, -0.04705028f, 0.01879088f, 0.00532458f, -0.04095184f, -0.06426739f, 
    -0.04708136f, -0.06276990f, -0.04956066f, -0.01710565f, -0.05235956f, -0.00844887f, -0.03782999f, 0.04583807f, 
    0.00115688f, -0.04176670f, -0.02541345f, 0.01347257f, 0.02971770f, 0.02371244f, 0.01522161f, -0.01754153f, 
    -0.00345165f, -0.01305131f, 0.00073839f, 0.01326033f, 0.02760203f, -0.01588114f, -0.04017488f, -0.04263837f, 
    -0.02778113f, -0.04120930f, 0.01507016f, 0.02390036f, -0.05082110f, -0.04121054f, 0.03511651f, 0.04422366f, 
    -0.01858835f, -0.03377803f, -0.03599723f, -0.02802212f, -0.02614586f, -0.06108198f, -0.05150902f, -0.03798232f, 
    0.03862046f, -0.00861897f, 0.00826156f, 0.00128203f, 0.01197696f, -0.03470245f, -0.03203564f, 0.03075935f, 
    -0.06228551f, -0.00672194f, 0.01720099f, 0.02975966f, 0.04779256f, 0.04726369f, 0.00897837f, -0.05810240f, 
    0.01604034f, -0.03877890f, -0.06592023f, 0.01436298f, -0.05747362f, 0.04056955f, -0.00963152f, -0.02201751f, 
    -0.04444291f, 0.03786477f, -0.03751470f, -0.03451044f, -0.04470663f, -0.05422076f, -0.06284714f, 0.04452287f, 
    0.00272547f, 0.03633044f, 0.00975092f, 0.01931510f, 0.04145615f, -0.03869325f, -0.03448554f, 0.04547105f, 
    -0.00254156f, 0.00673969f, -0.04129217f, 0.00609895f, 0.03341874f, -0.03978676f, -0.05377788f, -0.02544188f, 
    -0.05368687f, 0.00816717f, -0.06466759f, 0.02460134f, -0.01347548f, -0.01875191f, 0.00366932f, -0.03821145f, 
    0.04730418f, 0.01657797f, -0.05129784f, 0.01928220f, -0.05858893f, -0.04750797f, 0.03558687f, -0.01606248f, 
    -0.03264468f, -0.06275930f, 0.02577883f, -0.05774659f, 0.00408864f, 0.00250209f, -0.05220506f, -0.01735207f, 
    0.04219835f, -0.06104371f, -0.01687879f, -0.03478969f, 0.02739825f, -0.02634558f, -0.01109395f, -0.02698183f, 
    0.05090234f, -0.00012803f, 0.00121603f, -0.05363484f, -0.00190711f, 0.01251795f, -0.04053714f, -0.00045181f, 
    0.04978896f, -0.01391888f, -0.02026583f, 0.01633118f, 0.00806686f, -0.05550805f, -0.05352986f, -0.05584292f, 
    -0.03481695f, -0.01425545f, -0.05676514f, -0.00553671f, 0.02058010f, 0.04381512f, -0.04986684f, -0.04707847f, 
    0.05224055f, -0.02648537f, -0.04308290f, -0.06511105f, -0.05044987f, -0.06188570f, 0.03411403f, 0.01922949f, 
    -0.04400164f, -0.03917444f, -0.00635390f, 0.04012441f, -0.01985223f, -0.01936199f, 0.04651106f, 0.04518620f, 
    -0.00078186f, -0.03160534f, -0.06122768f, -0.01241274f, 0.00115764f, -0.05212018f, -0.01818709f, 0.03185806f, 
    0.04376251f, -0.04227255f, 0.02447849f, 0.00299092f, 0.03642557f, -0.01067966f, -0.04821105f, -0.03893581f, 
    0.03976526f, 0.01001305f, -0.03734659f, 0.04266642f, -0.04794873f, -0.01440412f, 0.02721400f, 0.01880424f, 
    -0.03349239f, 0.00471770f, 0.01573120f, -0.05140902f, -0.04685884f, 0.01370768f, 0.02439222f, -0.01241982f, 
    0.03359814f, -0.00224551f, -0.01543326f, -0.01196200f, -0.03380141f, -0.06436867f, -0.01423316f, -0.04554484f, 
    0.01843319f, -0.04417812f, 0.04396056f, -0.05537177f, -0.03286245f, -0.04963453f, 0.02488056f, 0.02047192f, 
    0.05274922f, -0.03177857f, -0.00344837f, -0.05766905f, -0.03453762f, -0.01037816f, 0.04222615f, 0.03659387f, 
    0.01863901f, -0.02604753f, -0.03716709f, -0.03441840f, -0.00749128f, -0.05287814f, -0.02774176f, -0.04754442f, 
    0.02932039f, 0.00905481f, -0.03386565f, -0.04747267f, -0.02408324f, -0.03177120f, -0.01974899f, 0.01046677f, 
    0.05428511f, -0.04769709f, -0.06558183f, 0.00893550f, 0.04382926f, -0.01723782f, 0.03673858f, -0.04168366f, 
    -0.00557639f, 0.03464303f, -0.05208715f, -0.02777019f, 0.04750189f, -0.04659957f, 0.03947855f, -0.00714047f, 
    -0.01743778f, -0.02890931f, -0.04152022f, -0.05046489f, -0.04352724f, 0.02665133f, 0.04816158f, 0.03914680f, 
    0.03993114f, -0.01578037f, -0.02900016f, 0.03141754f, -0.04415869f, 0.03822177f, 0.01237467f, -0.04552813f, 
    -0.06165565f, 0.04627498f, 0.04706421f, -0.04029419f, 0.05209895f, 0.01749758f, 0.04778600f, 0.02932907f, 
    0.04098753f, -0.03166035f, 0.03662045f, -0.04716385f, 0.02943548f, 0.04776841f, 0.05073841f, 0.00699324f, 
    0.02727520f, 0.01589878f, -0.01650385f, 0.02751411f, -0.02765645f, 0.03726470f, 0.01185599f, 0.02216486f, 
    -0.03727267f, -0.02575064f, -0.01479430f, -0.02204694f, 0.00503579f, 0.02301630f, 0.01950509f, 0.03033985f, 
    -0.01494736f, -0.01271705f, -0.00606096f, -0.05318381f, 0.03574346f, 0.03494233f, 0.03372731f, -0.04622072f, 
    0.04565052f, 0.02180757f, -0.04184354f, -0.06556579f, -0.01384684f, 0.00052867f, -0.03345763f, 0.01403286f, 
    -0.38800600f, 0.05285615f, -0.13008858f, 0.03642444f, -0.05323499f, 0.06966928f, 0.09792963f, -0.02311254f, 
    0.24903692f, 0.05413270f, -0.04109909f, -0.12052026f, 0.07037769f, -0.13070740f, -0.01756699f, -0.15940081f, 
    -0.18898691f, 0.09791423f, -0.12352698f, 0.58623654f, -0.21393840f, 0.05735689f, -0.15218213f, -0.20646355f, 
    0.07710029f, 0.09905313f, 0.03734372f, -0.07559023f, 0.34449244f, 0.04374922f, 0.21641651f, -0.02183455f, 
    -0.27315122f, -0.05529181f, 0.20193598f, 0.20055445f, -0.93421900f, -0.24612376f, -0.25771299f, -0.15956682f, 
    -0.02341709f, 0.20609826f, 0.07472638f, -0.21614303f, -0.06897052f, -0.16608027f, 0.13209112f, -0.04057582f, 
    0.02081837f, -0.15884095f, -0.12369065f, 0.04851941f, -0.06082044f, -0.00662533f, -0.26942456f, -0.22033168f, 
    -0.10991916f, -0.06038575f, 0.11530192f, 0.15189047f, 0.03212003f, -0.02007891f, 0.21233177f, 0.08173462f, 
    -0.04331258f, -0.38014847f, -0.05495365f, 0.10027072f, 0.01046494f, 0.13833539f, -0.10285050f, -0.11847670f, 
    -0.12980732f, 0.18704230f, -0.23159201f, 0.03710095f, -0.04320556f, -0.20029613f, 0.15636499f, 0.07820591f, 
    -0.08354453f, -0.18287793f, 0.08014923f, 0.04176243f, -0.06292208f, -0.22714075f, -0.07000127f, 0.17243543f, 
    0.07048518f, -0.18479468f, 0.26771128f, -0.08399615f, -0.50039577f, 0.03729582f, 0.13979270f, 0.21295625f, 
    0.02123291f, 0.15000495f, -0.09604206f, -0.00414347f, -0.45006797f, -0.36187780f, 0.27496821f, 0.07023424f, 
    0.14337644f, -0.08296989f, 0.03352142f, 0.09148258f, 0.63825917f, 0.28420666f, 0.03028497f, 0.10520863f, 
    0.07112080f, 0.06030920f, -0.17842408f, -0.11359739f, 0.20305714f, 0.07351865f, 0.01283146f, -0.36971754f, 
    -0.15939973f, 0.09080421f, 0.07682772f, 0.01706369f, -0.04036077f, -0.08941509f, 0.14832240f, 0.25984567f, 
    -0.08073225f, -0.12536716f, 0.03291051f, -0.01350368f, -0.12249973f, 0.15601103f, -0.08443015f, 0.29549494f, 
    0.12764162f, 0.14710709f, -0.12631185f, 0.09115949f, 0.08372265f, 0.16950661f, 0.05053968f, -0.13419251f, 
    -0.15928915f, 0.06244627f, 0.06792112f, 0.09566385f, -0.24553539f, -0.00395556f, 0.12403977f, 0.04491517f, 
    0.22642739f, 0.35392010f, 0.12851377f, -0.00275531f, 0.21242656f, -0.15347405f, -0.12011179f, 0.09832659f, 
    0.02896387f, 0.18070970f, 0.35159892f, -0.12192470f, 0.06770076f, 0.20423514f, -0.15497851f, 0.06436002f, 
    -0.02019639f, 0.30437088f, 0.01029400f, 0.17547697f, -0.34953851f, -0.16144782f, 0.02370776f, 0.23987837f, 
    0.03369446f, -0.10694247f, -0.07444388f, -0.01798488f, -0.34025910f, 0.07069146f, -0.10133430f, -0.03733782f, 
    0.19828674f, 0.04218978f, 0.00382293f, 0.13013066f, 0.02743880f, -0.13780619f, 0.15721011f, -0.20922337f, 
    0.16232015f, 0.11385106f, -0.29902798f, -0.03005103f, 0.06185243f, -0.18878464f, -0.19707084f, -0.01296284f, 
    -0.02008992f, 0.06102191f, -0.28063735f, -0.17723615f, -0.05852754f, -0.11377520f, 0.07850469f, 0.20533189f, 
    0.18077281f, -0.15846701f, -0.01302872f, 0.33299184f, -0.04773144f, -0.02703552f, 0.08770270f, -0.00715271f, 
    0.46631423f, -0.24693818f, -0.19768307f, 0.07751799f, -0.12992130f, 0.29583371f, 0.15570854f, 0.00732939f, 
    0.05109670f, 0.07037808f, -0.03456702f, -0.01131242f, 0.07883454f, 0.06738132f, 0.01938701f, -0.16598405f, 
    -0.00313153f, -0.02930859f, -0.22069849f, 0.17400639f, -0.25261670f, 0.09271310f, -0.10702067f, -0.02967916f, 
    0.03853212f, 0.19017266f, 0.02986082f, 0.20333470f, -0.42627653f, -0.11026017f, 0.12756392f, 0.01731600f, 
    -0.05340008f, 0.06903247f, -0.20901942f, 0.13364421f, -0.05387805f, -0.31814444f, -0.00871850f, 0.10083973f, 
    0.04009672f, -0.10940857f, 0.21494626f, 0.07137199f, 0.03588495f, -0.16988404f, -0.63092744f, -0.39138475f, 
    0.01902093f, -0.03810312f, 0.03417817f, -0.00647898f, 0.22939657f, 0.20945361f, -0.11067611f, 0.01996417f, 
    -0.19337679f, 0.08451804f, 0.01825402f, 0.07880352f, 0.13633597f, 0.04665747f, -0.01809538f, 0.16987865f, 
    0.34372202f, -0.14470451f, 0.01368629f, -0.05248950f, 0.17324834f, 0.18089795f, -0.11259201f, -0.06879532f, 
    -0.04148982f, 0.02029674f, 0.04491680f, -0.04065693f, -0.00916283f, -0.06130252f, -0.00219013f, -0.06179215f, 
    0.04904849f, -0.01794855f, -0.06039913f, -0.03291660f, -0.05338128f, 0.01950718f, -0.03215002f, -0.00007070f, 
    -0.05668041f, -0.06781308f, 0.01100057f, -0.04936685f, -0.04099610f, 0.01256244f, 0.02430137f, -0.03250045f, 
    0.04275087f, 0.00401436f, 0.03224261f, 0.04937484f, 0.01791921f, -0.02524988f, -0.04049822f, -0.02430128f, 
    0.04464138f, -0.05354715f, 0.03367003f, -0.00815100f, -0.03498978f, 0.00815775f, -0.04538465f, 0.00599687f, 
    -0.03291952f, 0.01823267f, -0.05308693f, -0.03575369f, 0.03658471f, 0.07013022f, -0.05155895f, 0.05626113f, 
    -0.06716505f, 0.04497143f, -0.04076289f, 0.03361549f, 0.01335753f, -0.02534880f, -0.04848301f, 0.00251099f, 
    0.03519313f, 0.04125064f, -0.00623113f, -0.02477341f, -0.04850022f, 0.02857375f, -0.00905652f, -0.02717851f, 
    -0.01627498f, 0.02443456f, 0.03614927f, 0.04310058f, 0.02470314f, -0.01143950f, 0.01723838f, 0.01392279f, 
    -0.02232296f, -0.01193877f, -0.01448851f, 0.01825767f, 0.03540153f, -0.03352738f, 0.03453830f, -0.02173074f, 
    -0.03464926f, -0.02519642f, -0.03682614f, 0.01659406f, -0.03911209f, 0.05030652f, 0.04115607f, 0.03596092f, 
    -0.00509510f, -0.05564085f, -0.02268592f, -0.00048214f, -0.05356005f, -0.00111129f, -0.06121913f, -0.00582167f, 
    -0.02686870f, -0.03019207f, 0.05754858f, 0.03709569f, 0.04249329f, 0.01635077f, -0.04690289f, -0.04509856f, 
    -0.02927907f, -0.04810109f, -0.04794782f, 0.01617589f, -0.06278768f, -0.03932851f, -0.00681339f, -0.05076969f, 
    -0.05300194f, -0.01353533f, 0.04848500f, -0.01857494f, -0.03734834f, -0.00062063f, -0.04307763f, 0.03181590f, 
    -0.06333421f, 0.00209174f, 0.00949894f, 0.00925921f, 0.03648079f, 0.04024678f, -0.01268679f, 0.00024813f, 
    -0.02341169f, 0.02878371f, 0.03770740f, 0.05187424f, 0.04909450f, -0.05893020f, -0.01282855f, -0.04807943f, 
    0.00434120f, 0.01054671f, 0.02271868f, -0.02807072f, 0.02153103f, 0.02175831f, -0.02164086f, -0.02069133f, 
    0.00463228f, -0.04743543f, -0.02551865f, 0.03029920f, 0.00859751f, -0.06784821f, -0.03663210f, -0.02198427f, 
    0.00131494f, -0.05817259f, -0.03064342f, -0.00156004f, 0.01703766f, -0.01804707f, 0.03214930f, 0.02991009f, 
    0.04035475f, -0.01386558f, -0.04161522f, -0.00846780f, -0.05040187f, -0.00564397f, 0.04781161f, 0.03772954f, 
    -0.00014676f, 0.01279256f, 0.02383807f, 0.03469773f, 0.01480323f, -0.00941040f, -0.00887075f, -0.01297442f, 
    -0.01109769f, 0.04701991f, 0.01817559f, 0.01864483f, -0.02037104f, -0.00998966f, 0.03047337f, -0.00572477f, 
    0.01626977f, -0.04733769f, 0.02311159f, -0.02072175f, -0.06433057f, -0.03594764f, -0.05386953f, -0.01365020f, 
    -0.04175935f, -0.00982254f, -0.01926211f, -0.06333948f, -0.02671793f, 0.05097868f, -0.04545901f, 0.02115703f, 
    0.02827130f, -0.01834368f, -0.03049715f, -0.06241864f, -0.04533361f, -0.02194883f, 0.04273739f, 0.00580591f, 
    -0.03347327f, 0.00378810f, 0.00714409f, 0.00596918f, 0.02093674f, -0.03280971f, -0.02853749f, -0.06588195f, 
    -0.00274502f, 0.02660135f, -0.04102064f, -0.02793830f, 0.02996341f, 0.03344557f, -0.06124995f, -0.02308630f, 
    0.02310456f, 0.00590582f, -0.02903862f, 0.02326892f, 0.02958967f, -0.02363059f, -0.03259046f, -0.04980959f, 
    0.00355005f, 0.02437876f, 0.02079968f, 0.01994815f, -0.02753500f, -0.02272076f, 0.02890242f, -0.04306198f, 
    0.00754318f, 0.01678244f, -0.06111881f, 0.00245003f, -0.05132132f, 0.03337087f, 0.02368127f, 0.03504548f, 
    0.03236440f, 0.04323311f, -0.03644171f, 0.00360554f, 0.03694332f, -0.01709635f, 0.02612871f, -0.02173093f, 
    -0.05694373f, 0.03847754f, 0.02252035f, 0.00573082f, 0.00514565f, 0.00192666f, -0.06033000f, -0.07090461f, 
    0.00597164f, 0.03823949f, 0.02681542f, -0.02992694f, -0.03275294f, -0.01622181f, -0.02365162f, -0.04829293f, 
    0.01017076f, 0.02504536f, -0.01696483f, -0.03105241f, -0.06026898f, 0.01071191f, 0.00988044f, -0.01037638f, 
    -0.02359839f, 0.02980787f, -0.03926848f, 0.02776463f, 0.04703259f, -0.01119567f, 0.01232085f, 0.05013093f, 
    0.14051510f, -0.10556236f, -0.17648636f, 0.35729003f, -0.03315896f, 0.06537034f, 0.16593732f, 0.09724698f, 
    -0.04755531f, -0.14063711f, -0.08656999f, 0.21452630f, -0.00786021f, 0.12676990f, 0.11880992f, -0.02949120f, 
    -0.05411006f, 0.07275705f, -0.06499659f, 0.01439136f, 0.29892766f, 0.03813218f, -0.09130354f, 0.02041713f, 
    -0.08219787f, 0.09246008f, -0.02184415f, -0.26820827f, -0.00117916f, 0.24327542f, -0.17472973f, 0.01837198f, 
    0.16538595f, -0.08474971f, 0.06501677f, -0.03986588f, -0.36325505f, -0.55110258f, -0.84901750f, 0.11605115f, 
    0.02273260f, -0.15865059f, 0.06022947f, -0.02455821f, -0.26944497f, 0.03924613f, 0.05308564f, -0.03492544f, 
    -0.34105620f, -0.17602946f, 0.17890400f, 0.09529381f, 0.25438389f, -0.10351735f, -0.43974978f, -0.02095477f, 
    -0.24837394f, 0.15893492f, 0.07141080f, -0.14273562f, 0.08575515f, 0.12194548f, 0.04716093f, -0.34185651f, 
    -0.14331220f, 0.01914007f, -0.00289559f, 0.27330866f, -0.00920720f, -0.02769822f, 0.07837591f, 0.07556836f, 
    -0.50473052f, -0.01385987f, 0.12181173f, -0.10789331f, 0.12067245f, 0.05403515f, -0.02426430f, -0.14381476f, 
    -0.06304301f, 0.01614933f, -0.10142015f, 0.02294124f, -0.00942344f, 0.13627334f, -0.04775511f, 0.02301610f, 
    0.26393017f, -0.14206500f, -0.56740588f, -0.53082442f, -0.23655958f, 0.11233145f, 0.15342742f, 0.26813754f, 
    0.02928490f, -0.16748534f, 0.12720723f, 0.00823439f, -0.00073706f, -0.22273320f, 0.29192001f, -0.05925360f, 
    -0.06898066f, -0.06573915f, 0.18052192f, 0.18766703f, -0.07354768f, 0.00520050f, -0.10139599f, -0.05152581f, 
    0.16663483f, -0.16901568f, -0.12401438f, -0.10850828f, 0.08207072f, -0.04244612f, 0.15295264f, 0.17083503f, 
    -0.01855518f, 0.11176259f, -0.16034582f, -0.13191304f, -0.00680338f, 0.05453674f, 0.05112833f, -0.00748883f, 
    0.03012702f, -0.23532388f, -0.03857927f, 0.07098978f, -0.03010062f, -0.03287621f, 0.09574480f, 0.08551990f, 
    -0.14489451f, 0.21056819f, -0.26522222f, -0.29949525f, 0.06861700f, 0.04864004f, 0.01122550f, 0.01658586f, 
    0.25512195f, 0.10574701f, -0.04181722f, -0.06240849f, 0.21701396f, -0.08265778f, 0.22424078f, -0.11513153f, 
    0.08671794f, 0.26445955f, 0.07007959f, -0.16354363f, 0.00866033f, 0.04522598f, -0.03160807f, 0.03266842f, 
    0.10103747f, -0.03806642f, -0.07828881f, 0.34499690f, 0.02558906f, -0.10718776f, 0.08924880f, -0.17824876f, 
    0.15018758f, -0.20915838f, 0.19849417f, -0.18078676f, 0.18450536f, -0.37046069f, 0.07075727f, -0.01721030f, 
    -0.24803548f, 0.11944130f, 0.28036028f, 0.05490069f, 0.20890887f, 0.18523662f, -0.01009483f, 0.18443382f, 
    -0.04659516f, -0.11715382f, 0.18505450f, -0.08185239f, 0.09636235f, 0.43556607f, 0.03428453f, 0.21361381f, 
    -0.20222653f, -0.07610448f, -0.12437161f, -0.09835516f, 0.20785868f, -0.04505599f, -0.15511079f, -0.18129942f, 
    -0.16538757f, -0.35373536f, -0.02430563f, -0.03862816f, -0.09324609f, 0.05415902f, -0.06154541f, 0.26497793f, 
    -0.19907419f, 0.00349922f, -0.26900071f, -0.02579178f, 0.03614832f, 0.03829680f, 0.00025026f, 0.21714121f, 
    0.13836186f, 0.09610658f, -0.38119784f, 0.19154730f, 0.21909335f, -0.05174446f, -0.04092985f, 0.10107843f, 
    -0.06365063f, 0.22278579f, 0.19622974f, -0.03915145f, -0.13694596f, -0.00556200f, 0.15564996f, -0.09743042f, 
    0.05099772f, 0.08842975f, -0.45355317f, 0.13621718f, 0.07969040f, -0.00357932f, -0.10029685f, -0.04746661f, 
    0.01835207f, 0.04821789f, 0.03688570f, 0.00173032f, 0.13114059f, 0.03295269f, 0.02591489f, 0.04594590f, 
    -0.05654420f, -0.15103891f, 0.05112793f, -0.22743049f, 0.46385464f, 0.19525339f, -0.14740163f, -0.10841656f, 
    0.20285124f, 0.06946865f, 0.05496412f, -0.03549268f, 0.06206521f, -0.10369909f, 0.28345963f, -0.60099584f, 
    -0.20176683f, -0.07788459f, 0.06610862f, -0.05127695f, 0.01690924f, 0.40305519f, -0.15966707f, -0.05059569f, 
    -0.26091263f, 0.19463935f, 0.00128388f, -0.02758878f, 0.21881445f, 0.14753945f, -0.08817539f, -0.22392264f, 
    -0.10191799f, 0.70104289f, -0.14678021f, 0.01592408f, 0.11595799f, 0.00674672f, 0.12815663f, -0.05270465f, 
    0.08521427f, -0.15058142f, -0.46138984f, 0.00499410f, 0.03196824f, -0.06021620f, -0.14748539f, 0.04185115f, 
    0.01992454f, -0.22381486f, -0.08496200f, -0.20629191f, -0.01253166f, -0.02260672f, -0.00754556f, 0.00429171f, 
    0.07357316f, 0.26576534f, 0.35419083f, 0.11732580f, -0.00316042f, 0.02692210f, -0.12630624f, -0.14543580f, 
    -0.11564185f, 0.04360043f, 0.00240987f, 0.44193292f, 0.14318906f, 0.10120748f, -0.07770029f, -0.23098134f, 
    -0.00040530f, -0.16527213f, 0.15379843f, 0.03789018f, -0.05460792f, 0.01526531f, -0.09207796f, -0.11808826f, 
    0.25456265f, 0.01217981f, -0.23642163f, -0.10604097f, -0.03981072f, 0.26642132f, 0.06032455f, -0.16815996f, 
    -0.06479771f, 0.01125730f, -0.02499352f, -0.04039960f, 0.02923089f, 0.26929757f, -0.46954009f, -0.14775032f, 
    -0.22024037f, 0.01775800f, 0.06154181f, -0.06437978f, 0.15923981f, 0.09634392f, 0.29083291f, 0.11728682f, 
    0.02169256f, 0.01554990f, -0.03996229f, -0.06709550f, 0.08452639f, -0.11401180f, -0.11566249f, -0.10649074f, 
    0.40923730f, -0.12891857f, -0.14701664f, 0.07293570f, -0.12613158f, 0.01629525f, -0.06414372f, 0.22231907f, 
    0.06560753f, 0.21137019f, 0.03004292f, 0.05238006f, 0.08332770f, -0.09072698f, 0.07165470f, 0.05785483f, 
    0.00983542f, -0.10581096f, 0.24027327f, 0.12006817f, -0.24620697f, 0.06851280f, 0.14086699f, -0.15818805f, 
    -0.05359921f, 0.14854331f, 0.17205073f, -0.38733602f, 0.10900877f, -0.23033690f, 0.15402490f, -0.03078752f, 
    0.11723100f, -0.16479152f, 0.09663402f, -0.06902983f, -0.12971528f, -0.05038040f, -0.08645003f, 0.21631053f, 
    0.11688211f, 0.07575939f, -0.13305424f, 0.05543250f, -0.02626427f, 0.44876659f, -0.30702648f, -0.32901150f, 
    -0.19705757f, 0.01437011f, 0.24286939f, 0.07447959f, -0.10086273f, -0.02534353f, 0.05827028f, 0.25068343f, 
    -0.17217760f, 0.04461729f, -0.23857433f, 0.19405942f, -0.10049429f, -0.10695808f, -0.10769956f, -0.10799253f, 
    0.10182805f, 0.14106558f, 0.21061698f, -0.03080741f, -0.15559064f, -0.08702859f, 0.10302687f, -0.29317299f, 
    -0.61595058f, 0.10466620f, -0.41026291f, 0.19311009f, -0.08034198f, 0.06472071f, -0.00032261f, 0.21122341f, 
    -0.20088962f, 0.22380029f, 0.02032078f, 0.07927242f, 0.16365702f, -0.03990938f, 0.12744838f, -0.08117130f, 
    0.15000457f, 0.10652504f, 0.26602143f, 0.11379724f, 0.07284313f, 0.05999029f, -0.17351215f, 0.15230125f, 
    0.08698668f, -0.26215699f, 0.03626885f, -0.31004870f, -0.09340818f, 0.24825603f, 0.21145770f, -0.03162955f, 
    0.16783853f, -0.01697470f, -0.00851027f, -0.25427750f, 0.44486919f, 0.24383733f, -0.13475782f, 0.02107898f, 
    -0.01817207f, 0.09374548f, 0.00685283f, 0.27173132f, -0.01029867f, 0.11654433f, 0.13129757f, 0.23253240f, 
    -0.17191875f, -0.19075763f, -0.05297167f, -0.11431008f, -0.05926501f, -0.00472130f, -0.07030223f, 0.11536950f, 
    0.06064175f, 0.07817123f, 0.21029204f, -0.20672603f, 0.02661850f, 0.10281109f, -0.18354495f, 0.19421957f, 
    0.07447249f, 0.12189659f, 0.06431633f, 0.08026677f, -0.02899866f, -0.01271002f, 0.05365958f, -0.00306381f, 
    -0.08220319f, 0.16345030f, -0.00918861f, 0.05547775f, 0.03349696f, 0.07899348f, -0.03200594f, 0.08398826f, 
    0.00523963f, -0.46687159f, -0.11794975f, -0.13626918f, 0.19098984f, 0.03661094f, -0.25960428f, -0.27820414f, 
    0.13338575f, -0.03611691f, 0.33705157f, -0.03432405f, -0.32619193f, -0.05076184f, -0.01837027f, 0.03683584f, 
    -0.30521235f, 0.08634599f, -0.20052773f, 0.06566106f, 0.06560690f, -0.05237114f, 0.25769967f, 0.13155065f, 
    -0.03209652f, 0.10718809f, 0.09577362f, 0.24019636f, -0.03565671f, -0.03700697f, 0.32034838f, -0.09839441f, 
    -0.14096469f, -0.05934496f, 0.32499975f, -0.02432391f, -0.07676510f, 0.33952510f, -0.25398710f, -0.21067795f, 
    0.07679043f, 0.05434230f, -0.03891124f, -0.12415688f, -0.11093723f, 0.07548417f, -0.20571399f, -0.09165440f, 
    -0.09673604f, -0.00065758f, -0.03360026f, -0.04539297f, 0.07542288f, -0.02222726f, -0.10939264f, 0.06656890f, 
    0.20702113f, 0.09335292f, 0.08080524f, 0.05432295f, -0.34005991f, 0.05751542f, 0.08705071f, -0.12885502f, 
    -0.01863278f, -0.01147227f, -0.04738379f, -0.01221081f, 0.00697858f, -0.06758980f, 0.03619283f, -0.05487957f, 
    -0.02713126f, -0.02287001f, -0.06258626f, -0.03906294f, 0.01950380f, -0.00148313f, -0.05915863f, -0.04627329f, 
    -0.00893874f, 0.01621697f, -0.05462553f, -0.06479865f, 0.00657517f, -0.00585722f, 0.04720826f, 0.00693651f, 
    -0.00002907f, 0.03084008f, -0.06418906f, -0.04154550f, -0.03998130f, 0.00287869f, -0.03428546f, 0.03067687f, 
    0.00170550f, -0.02701169f, -0.03906791f, 0.00236602f, -0.03123288f, 0.03974608f, 0.02435835f, 0.00825618f, 
    -0.05650352f, 0.01275283f, -0.04018173f, -0.03004285f, 0.02881064f, -0.04230787f, -0.00309223f, -0.02711672f, 
    -0.06505789f, -0.05529962f, -0.03381673f, 0.00031703f, 0.04356612f, -0.05007381f, 0.01556132f, -0.05224426f, 
    -0.03508871f, 0.02845188f, -0.04009403f, 0.00013313f, 0.05310950f, 0.04023550f, -0.05837429f, 0.00672220f, 
    0.02547548f, 0.00408187f, -0.06165252f, -0.07039403f, 0.03889753f, 0.00303498f, 0.01761147f, -0.02508102f, 
    -0.05863173f, 0.04933849f, -0.01119662f, -0.03029291f, -0.00055952f, -0.03286271f, 0.01264417f, -0.00927617f, 
    0.05258144f, 0.00923413f, -0.02218593f, -0.06231614f, 0.04245733f, -0.01756909f, -0.05361897f, 0.00144584f, 
    -0.02368102f, 0.03076620f, -0.06055817f, 0.01047652f, -0.00277375f, -0.02244176f, -0.04016845f, -0.00708030f, 
    -0.03675710f, 0.01373842f, 0.00686125f, 0.00734694f, -0.01153003f, -0.03336771f, 0.01420310f, 0.03814747f, 
    0.00552854f, -0.01838543f, 0.04221736f, 0.00417188f, -0.07459933f, -0.03170297f, 0.01067658f, -0.02367847f, 
    -0.00864440f, -0.05388143f, -0.01381532f, -0.02796668f, -0.02868611f, -0.01231369f, -0.06239999f, 0.03565745f, 
    -0.00739465f, -0.01268638f, 0.02684778f, -0.05698929f, 0.00940924f, -0.00240548f, 0.01179401f, -0.01730979f, 
    0.02275235f, -0.03331282f, -0.02848146f, 0.01966049f, 0.01275942f, -0.03376728f, -0.06148646f, 0.04686899f, 
    0.02439850f, -0.03237841f, -0.01780696f, -0.05286840f, -0.01423018f, -0.02672718f, -0.03180872f, 0.01192515f, 
    -0.07325260f, 0.00037815f, 0.04492461f, 0.00985759f, 0.03987007f, 0.04651425f, 0.04527221f, 0.01757983f, 
    0.01351378f, -0.05089767f, -0.04615765f, -0.03345605f, 0.03029291f, -0.05270324f, -0.06593961f, -0.02167523f, 
    -0.02173571f, -0.06685594f, 0.03880262f, 0.03914333f, -0.06107425f, -0.01593912f, 0.02886572f, -0.07079121f, 
    0.02902956f, 0.03247771f, -0.05904536f, -0.03733707f, -0.06240217f, -0.07413812f, -0.04132582f, -0.03199171f, 
    -0.04836676f, -0.01212704f, -0.00281714f, -0.07542090f, 0.02625646f, -0.01899929f, -0.01182442f, -0.00556968f, 
    -0.05836426f, -0.06667797f, -0.05293239f, -0.03143304f, -0.00668638f, -0.04809712f, 0.01167792f, -0.01530721f, 
    -0.00102919f, -0.04231219f, -0.03643369f, -0.02405656f, -0.00959478f, 0.02095574f, -0.03694433f, -0.08312163f, 
    -0.03605332f, 0.04273676f, 0.00366235f, 0.00233334f, -0.00542185f, 0.00091578f, -0.01749470f, -0.02193500f, 
    -0.04120278f, 0.03530864f, 0.00793693f, -0.07715496f, -0.05484369f, -0.03392477f, -0.07970529f, -0.03018011f, 
    -0.04021546f, -0.03046868f, -0.05101886f, -0.03101850f, -0.02220296f, -0.00868008f, 0.02516971f, 0.02267261f, 
    -0.06770539f, -0.03106028f, -0.01577316f, -0.05778166f, -0.05403353f, -0.07023136f, 0.02043981f, -0.05553543f, 
    -0.01810131f, 0.02422236f, 0.04258709f, -0.06258077f, 0.02788008f, -0.03332222f, 0.02654436f, 0.00930518f, 
    -0.05802594f, -0.01629211f, 0.02586880f, 0.02792893f, 0.01642009f, -0.01290257f, -0.06020254f, -0.02970910f, 
    -0.02116023f, 0.01360604f, -0.02928936f, -0.04095781f, -0.02134867f, -0.06285515f, 0.03025644f, -0.04123309f, 
    0.01817117f, 0.00948314f, -0.01915364f, -0.02342889f, -0.06872037f, 0.03671885f, -0.05099655f, -0.05847212f, 
    0.00143629f, 0.01522917f, -0.04254978f, 0.04833436f, 0.01825965f, 0.01435844f, -0.04774582f, -0.07706509f, 
    -0.01650332f, -0.04133092f, -0.04144853f, -0.04339186f, -0.00383003f, -0.00493907f, -0.02117331f, 0.01077388f, 
    -0.06660790f, -0.06105373f, -0.00644992f, -0.03442118f, -0.01875833f, -0.05206014f, -0.02231227f, -0.03722618f, 
    0.35243171f, 0.05590137f, -0.12209263f, -0.14682069f, -0.11028560f, 0.14152248f, 0.01299196f, 0.06961043f, 
    0.01555277f, -0.02710488f, -0.29984275f, 0.17909195f, -0.03850295f, 0.01456368f, 0.19268529f, 0.12050856f, 
    0.07805488f, -0.16069427f, 0.13510042f, -0.17046794f, 0.08942150f, -0.10871474f, -0.07811438f, -0.01480859f, 
    -0.09309956f, -0.20782700f, 0.04974514f, 0.09252087f, -0.15442236f, 0.06267779f, 0.02819465f, 0.04782997f, 
    -0.22792166f, -0.04092733f, 0.05104980f, -0.10916294f, 0.77234274f, 0.15901789f, -0.08609232f, 0.01852235f, 
    -0.27736390f, -0.07994112f, -0.01991167f, -0.06497990f, 0.11945184f, 0.28306690f, -0.10818169f, -0.22963208f, 
    -0.29957327f, 0.27989426f, 0.17475206f, 0.16385774f, 0.21135351f, -0.13654792f, 0.34872693f, -0.00094976f, 
    0.16145222f, 0.03078739f, -0.06253006f, -0.26134548f, 0.21471861f, -0.18194902f, 0.00152257f, -0.02739387f, 
    0.06761821f, 0.27442300f, -0.02660637f, -0.10784875f, -0.04440073f, -0.10236963f, -0.05605872f, 0.13848121f, 
    0.10754950f, -0.00162666f, -0.15717764f, -0.15999946f, -0.09832795f, 0.12122752f, -0.09596806f, 0.09219751f, 
    -0.00790033f, 0.00658793f, -0.14618811f, -0.03547569f, -0.04434042f, 0.12576404f, -0.06151079f, 0.17412934f, 
    0.13001822f, -0.04363670f, -0.71904379f, 0.26088670f, 0.20799500f, 0.23621097f, -0.08588156f, -0.09844901f, 
    0.16731673f, -0.26227129f, -0.13720623f, -0.29304096f, 0.38347289f, 0.47097662f, -0.01281262f, 0.08228228f, 
    -0.32776821f, 0.04954243f, -0.09850428f, 0.15413202f, -0.24721423f, -0.28048828f, -0.10926522f, 0.03851194f, 
    0.04318261f, 0.02376759f, -0.03297674f, -0.04225142f, -0.02273978f, 0.08212595f, -0.01335683f, 0.10581791f, 
    0.12523808f, -0.10640180f, -0.11087939f, 0.15084112f, -0.12354443f, 0.00672993f, -0.30144852f, 0.09443064f, 
    0.05757729f, 0.05937706f, -0.09134249f, 0.24131867f, -0.08527903f, 0.23606311f, 0.07373292f, 0.13574496f, 
    0.17467918f, 0.03582366f, -0.23455065f, -0.00041258f, 0.24769308f, -0.05424667f, 0.00304171f, -0.16834833f, 
    -0.02387228f, -0.85211968f, -0.09152880f, 0.07637414f, 0.33099166f, 0.11646421f, -0.00825130f, 0.02120520f, 
    -0.29548141f, -0.69855762f, -0.32403716f, -0.07857315f, -0.08589235f, -0.13309860f, 0.19052422f, 0.25276589f, 
    0.28873819f, -0.15218130f, -0.39883953f, -0.43859866f, 0.05079936f, 0.09192871f, -0.01438305f, -0.02986131f, 
    -0.30197611f, 0.13605173f, 0.02439975f, 0.75980294f, 0.22283509f, -0.06938794f, 0.21466719f, -0.11756615f, 
    0.01644963f, -0.07423652f, -0.04408291f, -0.03007887f, -0.05456517f, 0.30641627f, -0.12336829f, 0.00391669f, 
    -0.12445827f, 0.13656704f, 0.02328217f, 0.16711035f, 0.18960597f, 0.25295755f, -0.18792334f, 0.02138534f, 
    -0.12152116f, 0.13025422f, 0.20021999f, 0.00678964f, 0.09432122f, 0.24088471f, 0.20319712f, -0.23676960f, 
    0.43426096f, -0.02998261f, 0.21982460f, 0.10421547f, -0.35967946f, 0.07000028f, 0.08614898f, -0.19034046f, 
    0.01198400f, -0.00758660f, -0.07185295f, -0.11244558f, -0.18705685f, 0.17341764f, 0.05489963f, 0.13546754f, 
    -0.09305631f, 0.05040389f, 0.06560814f, 0.00481080f, 0.10285939f, 0.05847820f, -0.08199570f, 0.20553887f, 
    0.07003202f, 0.28283882f, 0.33908910f, 0.07516037f, -0.02647977f, 0.07565983f, 0.23440550f, 0.24906170f, 
    0.11479161f, 0.13383770f, -0.18797711f, 0.15359780f, 0.09787481f, -0.03454767f, -0.15458086f, -0.16745085f, 
    -0.08298095f, 0.02672709f, 0.08496228f, -0.57423860f, -0.56079018f, -0.09576973f, 0.03549217f, -0.01655897f, 
    -0.09753949f, 0.02717949f, 0.01600919f, -0.18661834f, -0.51899987f, 0.11603634f, -0.80680770f, 0.13493782f, 
    0.04001233f, -0.04099897f, -0.09075404f, 0.22889155f, 0.02953946f, 0.63909364f, 0.42535460f, -0.01358270f, 
    -0.22178362f, 0.12678868f, -0.04838878f, -0.16887744f, 0.04941058f, -0.02582625f, -0.17827666f, 0.21902545f, 
    -0.08666099f, 0.03933044f, 0.13527599f, -0.02428375f, -0.11304921f, -0.10431443f, -0.10634324f, 0.04403345f, 
    -0.01183548f, 0.23375379f, -0.13840111f, -0.05333558f, 0.03174037f, 0.08382768f, -0.08016466f, 0.09048434f, 
    -0.47591835f, -0.21265894f, -0.04005617f, -0.13383459f, -0.23545142f, 0.02156283f, 0.01629584f, 0.16460298f, 
    0.13491525f, 0.20932163f, -0.04407075f, 0.04611635f, 0.06870119f, 0.10491555f, 0.05910567f, 0.33399630f, 
    0.16154875f, 0.16065985f, -0.58844155f, 0.21602683f, 0.04579789f, 0.29840174f, -0.07287147f, 0.11007321f, 
    -0.01924478f, 0.14496115f, 0.09923618f, -0.17151907f, 0.23271090f, -0.00497864f, -0.09018771f, 0.05080645f, 
    0.08599861f, 0.01376582f, -0.25294247f, 0.06227213f, 0.12098553f, -0.10835529f, -0.14144628f, 0.30653834f, 
    -0.11820127f, 0.05740089f, -0.15014708f, -0.02542143f, -0.08403274f, 0.10334155f, -0.19567835f, -0.38570565f, 
    0.02200094f, -0.12777805f, 0.12617399f, 0.05392098f, -0.13071306f, 0.17041254f, -0.00731827f, 0.05342957f, 
    0.27134523f, -0.13056853f, -0.21364862f, 0.06974258f, 0.00377453f, 0.16111742f, 0.15236032f, 0.31280985f, 
    0.20689435f, 0.09664892f, 0.15259182f, -0.03583303f, 0.12355530f, 0.20220132f, -0.07514971f, -0.03284137f, 
    -0.17994018f, -0.20805639f, -0.50205213f, 0.06137341f, -0.03885573f, 0.10762770f, 0.13967709f, 0.12614305f, 
    -0.14686522f, 0.11427182f, 0.07179434f, -0.03412580f, 0.09445337f, 0.12985438f, -0.15761657f, 0.10768791f, 
    -0.14284177f, 0.00948696f, -0.00040996f, 0.05678691f, -0.15373041f, 0.17713255f, 0.17795771f, 0.15000957f, 
    -0.08900124f, -0.33717215f, -0.16598281f, -0.34790048f, -0.35172579f, -0.11315241f, 0.21387857f, -0.21962826f, 
    -0.09052047f, -0.07978648f, -0.09814145f, 0.02121964f, 0.16096278f, 0.12948869f, 0.49743384f, 0.15921955f, 
    0.08403514f, 0.00924537f, -0.02101169f, 0.11029789f, 0.13709158f, -0.03055257f, -0.16125199f, -0.24367535f, 
    -0.08396921f, -0.01390364f, 0.05906793f, 0.12614800f, 0.04514562f, 0.05393509f, -0.81771863f, -0.00500149f, 
    0.01622159f, -0.00732136f, -0.01312954f, 0.15254150f, 0.24591520f, -0.13365409f, -0.08244065f, -0.19279683f, 
    -0.05073612f, -0.11738025f, 0.20498884f, 0.06783022f, 0.00613186f, 0.07609899f, -0.00038149f, 0.13679323f, 
    -0.26706067f, -0.15889850f, 0.29841521f, 0.03625245f, -0.34202465f, -0.15255602f, -0.02470660f, 0.19464548f, 
    0.07716578f, -0.10860039f, -0.00222686f, 0.33122316f, 0.09348611f, -0.00607768f, -0.05518503f, 0.02970156f, 
    0.15296538f, 0.34583348f, 0.38830283f, -0.11119428f, 0.17459098f, 0.11871646f, -0.17731155f, -0.10489072f, 
    0.20756166f, 0.30056649f, 0.04828443f, 0.17496032f, 0.09259574f, 0.26039979f, -0.08372641f, 0.12910527f, 
    -0.10487867f, -0.01284220f, -0.03915217f, -0.04292785f, 0.79423171f, 0.06840564f, 0.43985215f, 0.22869678f, 
    -0.02630366f, -0.08117614f, -0.06810885f, 0.21204898f, 0.06212405f, -0.55628884f, 0.25901285f, -0.15970689f, 
    0.06780978f, -0.19787695f, 0.05813354f, -0.19772476f, -0.03055857f, -0.03395853f, -0.47831109f, -0.01430208f, 
    -0.51644158f, 0.14910924f, 0.16264364f, -0.08429889f, -0.03124982f, 0.00313608f, -0.28191823f, -0.36252671f, 
    -0.00538200f, 0.20511340f, -0.00856730f, 0.06639305f, 0.08624679f, 0.18579644f, 0.06766736f, 0.02425491f, 
    -0.21685000f, 0.03072220f, 0.40206122f, 0.06413834f, -0.02751489f, 0.07873430f, 0.12524609f, -0.00761836f, 
    0.22809863f, -0.04525683f, -0.60582024f, 0.17591839f, 0.29805663f, 0.27111778f, 0.18932672f, 0.01173340f, 
    -0.10067941f, -0.00733103f, 0.23551887f, 0.12261181f, -0.09597655f, 0.11030792f, -0.01266294f, 0.30232418f, 
    -0.00588273f, -0.07783714f, 0.18101154f, -0.05452554f, 0.11727979f, 0.33265951f, 0.01163911f, -0.07436160f, 
    -0.10304312f, 0.25675613f, 0.21930653f, 0.09658636f, -0.90137130f, -0.27197096f, 0.02186754f, -0.12176120f, 
    0.23287773f, -0.08092475f, -0.13185933f, 0.09689556f, -0.03993468f, -0.11661419f, -0.49680191f, -0.02514263f, 
    -0.04999775f, -0.01502559f, -0.11000987f, -0.02120626f, 0.18380289f, -0.05742781f, 0.06389225f, -0.02249850f, 
    -0.17235981f, -0.05184748f, -0.05767732f, 0.01776571f, -0.03138475f, 0.13113785f, -0.13671631f, 0.09459371f, 
    0.07528988f, -0.36739457f, 0.09176455f, -0.01141926f, 0.06989145f, 0.22461967f, 0.48003134f, -0.17127390f, 
    0.31686020f, 0.33064166f, -0.10210922f, -0.19953188f, -0.20209032f, 0.08494272f, 0.06220057f, -0.09774958f, 
    0.15400326f, -0.44304958f, -0.18288770f, -0.22234906f, 0.23301972f, 0.18015301f, 0.14330423f, -0.20236108f, 
    -0.16132408f, -0.01908583f, 0.05510168f, -0.01439162f, -0.10207371f, -0.11979218f, -0.09548815f, 0.06837487f, 
    -0.12414930f, 0.07043447f, 0.18273827f, 0.20430361f, 0.02688572f, -0.10045157f, -0.03694968f, 0.13197924f, 
    -0.10740130f, 0.06249043f, 0.17466976f, 0.13178673f, -0.33218214f, 0.02182589f, 0.23725061f, 0.13181999f, 
    0.02335844f, -0.10685252f, -0.00116917f, -0.03672586f, 0.11514629f, -0.07682048f, 0.08542858f, 0.15563820f, 
    0.03393794f, 0.03758550f, 0.11314516f, 0.11055224f, -0.22537784f, 0.09000158f, 0.23275518f, -0.02796154f, 
    -0.10876825f, 0.11526407f, -0.19631353f, 0.15667433f, -0.07465534f, 0.13854651f, 0.01500260f, 0.09972166f, 
    -0.02654817f, 0.10442272f, -0.02297523f, 0.05351416f, -0.01628877f, 0.16799895f, 0.04616090f, -0.14973538f, 
    0.00608597f, -0.10253248f, -0.05342525f, -0.09522441f, -0.23948085f, -0.16513915f, -0.02859796f, 0.14858137f, 
    0.09793475f, 0.11292458f, -0.18570425f, 0.17697176f, -0.04087491f, 0.09920946f, -0.20169187f, 0.01495883f, 
    0.01773037f, -0.01861820f, 0.03118671f, 0.01679072f, -0.02904273f, 0.17092967f, 0.07264683f, 0.05960711f, 
    -0.05119015f, -0.00563000f, -0.06088134f, -0.31366542f, -0.05811256f, 0.06474699f, 0.13289720f, 0.11583243f, 
    0.05370128f, -0.16404369f, -0.21322241f, -0.07475666f, -0.34935880f, 0.08060850f, -0.11308487f, 0.21021833f, 
    0.11185655f, 0.19802289f, 0.04146059f, -0.01534444f, -0.09370026f, 0.17940967f, 0.19964544f, -0.10793954f, 
    -0.27455235f, 0.04822914f, -0.04700419f, 0.08787571f, 0.23026136f, 0.05929621f, 0.17186484f, 0.14872098f, 
    -0.08828782f, 0.03381515f, 0.00309599f, -0.03443819f, 0.19895118f, -0.04650526f, 0.09095950f, 0.33197951f, 
    0.21804030f, 0.27586418f, -0.02601096f, -0.03578859f, -0.01312882f, 0.06113164f, 0.15754414f, -0.05881984f, 
    -0.18598457f, 0.00952274f, -0.36934206f, -0.05062370f, -0.02003390f, 0.04490448f, -0.13195184f, 0.30670205f, 
    0.06386295f, -0.32856426f, -0.11615761f, -0.16546467f, 0.35083640f, 0.00539646f, 0.10852333f, 0.19052990f, 
    -0.00068419f, 0.18727064f, -0.32971764f, -0.12684110f, 0.03650159f, 0.06567159f, -0.24167858f, 0.14342539f, 
    0.09046387f, -0.01144174f, 0.12751041f, 0.18240821f, 0.26837173f, -0.00197308f, 0.03777829f, -0.04603077f, 
    0.17224322f, -0.10808394f, -0.17353164f, -0.18107831f, -0.27326146f, 0.19239339f, -0.30330014f, 0.19578344f, 
    0.20586337f, -0.15313274f, 0.18916388f, -0.05582301f, -0.01462895f, 0.48880538f, 0.21664515f, 0.25621563f, 
    0.01291476f, 0.03393175f, -0.08661705f, -0.03345082f, 0.29288563f, -0.07748574f, 0.09088025f, -0.04675980f, 
    0.18820080f, 0.11135075f, 0.13802956f, 0.09599283f, 0.09257612f, 0.09503423f, 0.10079018f, 0.01400159f, 
    -0.02315084f, -0.09919509f, -0.02718074f, 0.26822588f, 0.24990323f, 0.09757948f, -0.02881806f, -0.07894038f, 
    0.38566563f, -0.02191200f, 0.28316084f, 0.11113292f, -0.05831180f, 0.10373478f, -0.25773916f, 0.18550996f, 
    0.07858729f, -0.04898629f, -0.30514079f, 0.28614104f, -0.00892399f, 0.14862062f, 0.13617760f, 0.07181403f, 
    -0.17516898f, -0.20844114f, 0.03907299f, -0.03824531f, -0.21133567f, -0.15393624f, 0.14233768f, -0.13305360f, 
    -0.06633399f, 0.07690513f, -0.04206865f, -0.66687000f, -0.37048659f, -0.35630003f, 0.10335186f, 0.06253415f, 
    -0.14383048f, 0.19907832f, -0.16730040f, -0.00951942f, -0.56415546f, -0.02337352f, -0.05646120f, -0.13275707f, 
    0.01739207f, -0.08212050f, 0.18108897f, 0.08912298f, 0.11920577f, -0.51047897f, -0.17485948f, 0.02368675f, 
    -0.19674242f, 0.05934395f, 0.02785022f, 0.05450996f, 0.17380707f, 0.01659898f, 0.14534661f, 0.04283723f, 
    -0.09734778f, -0.12080304f, -0.12705624f, -0.00114001f, -0.01295863f, 0.07331553f, 0.02626272f, 0.09698919f, 
    0.25071362f, 0.18821909f, -0.19819997f, -0.06613170f, 0.19196279f, 0.02276079f, 0.08605677f, 0.04166058f, 
    -0.00715561f, 0.00165090f, -0.03751612f, 0.04760106f, 0.01088935f, -0.03162440f, -0.06297182f, 0.02838530f, 
    -0.00948065f, -0.00650627f, 0.04533376f, 0.03634211f, -0.06340584f, 0.01023451f, -0.03871953f, 0.00391656f, 
    -0.02048411f, -0.03119826f, -0.04572259f, -0.02999055f, 0.04394937f, -0.03044821f, -0.01223931f, -0.04998376f, 
    -0.02019505f, -0.00494081f, 0.03948288f, 0.03920410f, -0.04114879f, -0.00952753f, 0.00965771f, 0.02900165f, 
    -0.00395995f, 0.00237567f, -0.06493499f, -0.04460905f, -0.06252113f, -0.01266028f, -0.05319552f, -0.01977287f, 
    0.00185499f, -0.03285929f, -0.03325541f, -0.02130884f, 0.00454627f, -0.01210602f, 0.03924939f, 0.01409932f, 
    -0.03475089f, -0.05105546f, -0.00427004f, -0.01039908f, 0.01099174f, 0.02023668f, -0.01040296f, 0.02125261f, 
    0.02669930f, 0.00185569f, -0.05585625f, -0.02287814f, 0.01940618f, -0.03924542f, 0.00205602f, -0.04750955f, 
    0.02732366f, 0.00672700f, 0.02942378f, -0.03838680f, -0.00630244f, 0.01878433f, -0.03589009f, 0.04160484f, 
    0.01370683f, 0.03056656f, 0.01130013f, -0.06494722f, 0.00335649f, -0.05276799f, -0.03040941f, -0.05249816f, 
    -0.03089428f, 0.02834161f, 0.03921959f, -0.05712651f, -0.05842477f, -0.05902497f, 0.04859721f, -0.02904081f, 
    0.01928978f, 0.00761868f, -0.02699907f, -0.04275624f, 0.02775517f, -0.01595991f, -0.03138676f, 0.03565639f, 
    0.03653239f, 0.00377677f, 0.03568126f, -0.04995817f, -0.05118352f, -0.04713699f, 0.04723830f, 0.03902895f, 
    0.00686858f, 0.05555898f, 0.01874256f, -0.01758515f, 0.00261603f, -0.05149555f, -0.04788824f, -0.02692669f, 
    -0.05656569f, -0.02804781f, 0.00219579f, 0.01249554f, -0.05517841f, 0.03272625f, 0.02622147f, 0.02294542f, 
    0.00390427f, 0.04757255f, 0.04468946f, 0.04618585f, -0.04127406f, -0.04038899f, -0.02792509f, 0.04834946f, 
    -0.02305382f, 0.00607442f, 0.03441259f, -0.05324162f, 0.03573089f, 0.02776109f, -0.00630594f, 0.02696860f, 
    0.02057065f, -0.01437473f, -0.06363382f, -0.05805996f, -0.02557657f, -0.00362078f, -0.04721990f, -0.00370570f, 
    0.00280676f, 0.05151302f, 0.01317503f, 0.02273143f, 0.03287740f, 0.01603886f, -0.02156548f, 0.02159089f, 
    0.00206469f, -0.01163554f, -0.02420315f, 0.01279760f, -0.00203461f, -0.01647786f, 0.02418466f, -0.00252162f, 
    -0.04486687f, -0.04901925f, 0.04427970f, 0.02000351f, -0.04930254f, 0.04185230f, 0.03807975f, -0.03029992f, 
    -0.01240949f, -0.01654646f, -0.04895918f, -0.01134689f, 0.03989892f, 0.01367603f, 0.00682740f, -0.05276496f, 
    0.00478446f, -0.01955370f, 0.02093416f, 0.02776288f, -0.02889774f, 0.03848895f, 0.01976364f, -0.04507587f, 
    0.03903747f, -0.04088579f, -0.06624633f, 0.05145342f, -0.01804659f, 0.02309202f, -0.02052765f, -0.05259771f, 
    -0.00514727f, 0.00557622f, -0.03588767f, 0.01947781f, 0.00636401f, -0.04410597f, 0.04511780f, -0.06266011f, 
    -0.02749575f, 0.04883389f, 0.01868803f, 0.01082113f, -0.02446115f, -0.02410247f, -0.05571951f, 0.01548642f, 
    -0.04028089f, -0.03283899f, -0.01070256f, -0.01829532f, 0.02851661f, -0.00433238f, 0.02842160f, -0.01477926f, 
    -0.04148169f, -0.03054644f, 0.03630543f, 0.01201675f, -0.04829122f, 0.02689715f, -0.03869136f, -0.02243969f, 
    0.04110564f, 0.00818186f, -0.05570379f, 0.04104995f, -0.02549561f, 0.00355232f, -0.05013569f, 0.03351706f, 
    -0.05959867f, 0.01987095f, -0.02846268f, -0.03910316f, -0.05335857f, -0.04346151f, -0.02909485f, -0.02867265f, 
    0.00755481f, 0.02937262f, 0.04616633f, 0.01059106f, -0.04929667f, 0.02226806f, -0.00518227f, -0.01645337f, 
    -0.00744475f, 0.03713042f, 0.00702022f, -0.02642647f, -0.05894337f, 0.03371868f, 0.01964802f, 0.02420994f, 
    0.02608509f, -0.02188847f, -0.01947483f, -0.05851430f, 0.00734157f, -0.05793973f, 0.00820155f, -0.01080188f, 
    -0.04214584f, 0.03796887f, -0.01018669f, -0.03871727f, 0.00735863f, 0.00332903f, -0.06298547f, -0.03011049f, 
    0.01599752f, 0.04966871f, -0.01737159f, -0.00079500f, 0.04471424f, 0.04759843f, 0.03930767f, 0.01175704f, 
    0.00720579f, 0.02282017f, 0.03859809f, 0.01824427f, 0.01468085f, 0.02977956f, 0.02110299f, -0.00568565f, 
    -0.05105200f, -0.02102751f, 0.03950666f, -0.00479940f, 0.01059011f, 0.00966578f, -0.04853080f, -0.05182042f, 
    -0.01701630f, -0.00308521f, 0.02881224f, -0.00935904f, -0.04470679f, -0.01027246f, -0.05595024f, -0.01965893f, 
    -0.02768344f, 0.01290800f, -0.02880101f, -0.00456618f, 0.00348127f, -0.02689479f, -0.06641853f, -0.00005409f, 
    -0.00346946f, 0.03576757f, 0.01410709f, -0.02360775f, -0.06035017f, 0.01520010f, 0.01727919f, -0.00467914f, 
    -0.00051859f, -0.00937130f, -0.02912161f, -0.04179630f, 0.02713160f, -0.03445820f, -0.02785925f, 0.01234078f, 
    -0.00406540f, 0.02331998f, -0.01806881f, -0.02780410f, -0.04920712f, -0.01012598f, 0.04310690f, 0.01518834f, 
    -0.01690380f, -0.01980146f, 0.02947268f, -0.00583134f, 0.02549690f, 0.04007354f, -0.04395516f, -0.04512442f, 
    -0.05826255f, -0.05824905f, 0.00696916f, 0.01771022f, 0.00022734f, -0.02293560f, -0.05561544f, -0.01693143f, 
    -0.00586093f, 0.04380619f, 0.02771489f, -0.03541962f, -0.01899270f, -0.00725704f, -0.04491809f, 0.00845979f, 
    -0.06551579f, -0.04738006f, 0.05764157f, 0.03400321f, 0.02902152f, 0.01800295f, 0.00418839f, 0.04297873f, 
    -0.05673780f, -0.02809998f, 0.00217965f, 0.03603021f, -0.04858279f, 0.01956204f, 0.00420093f, -0.03326517f, 
    0.04947792f, -0.01117121f, -0.01541451f, -0.00168228f, 0.01292087f, -0.02156624f, -0.02416991f, -0.04125521f, 
    0.04264278f, -0.01623258f, -0.02003538f, 0.04752037f, 0.03233383f, -0.00561662f, -0.04088110f, -0.03988601f, 
    -0.04228876f, -0.06213227f, 0.03265066f, -0.03449163f, -0.02634623f, -0.00620016f, -0.05216737f, -0.04024472f, 
    0.02633398f, -0.05516252f, -0.04872060f, -0.04356781f, -0.02111485f, 0.02729250f, 0.03485747f, -0.03710499f, 
    0.02236388f, -0.04140053f, 0.01981062f, 0.01964048f, -0.04379176f, -0.03466044f, 0.04357180f, 0.03960865f, 
    -0.05998299f, -0.05359344f, -0.01410577f, 0.01306815f, -0.01246257f, 0.04475453f, -0.01555177f, -0.03761151f, 
    -0.04728073f, -0.00923360f, 0.03151779f, -0.03684281f, -0.04814171f, 0.04146010f, -0.03920359f, 0.00949231f, 
    -0.04063349f, -0.01125565f, 0.03902071f, -0.00702695f, -0.02135302f, 0.02586695f, 0.03491054f, 0.04639727f, 
    0.01724044f, -0.01619363f, -0.03420651f, -0.06705331f, -0.02486879f, 0.03823766f, -0.05254760f, -0.03749207f, 
    -0.06260408f, 0.03646028f, -0.06021835f, -0.02609434f, 0.03291572f, -0.06206014f, 0.05525949f, 0.03081097f, 
    -0.04582014f, -0.02171333f, 0.01865105f, 0.05213502f, 0.04367208f, -0.00083090f, -0.06414922f, 0.01170920f, 
    0.03209124f, -0.02310390f, 0.03037965f, 0.00782904f, -0.05553762f, 0.02876144f, 0.04496095f, 0.01459062f, 
    0.04491776f, -0.01593217f, -0.02625566f, -0.04230293f, -0.02971628f, 0.04197405f, -0.01767424f, -0.02352185f, 
    -0.00046877f, -0.01874663f, -0.03953064f, 0.03070102f, 0.03176061f, -0.03963475f, 0.03861155f, -0.04209669f, 
    -0.06067658f, -0.05766373f, -0.01633752f, 0.03642957f, 0.00395433f, -0.04659040f, -0.04730666f, 0.01741978f, 
    -0.02635872f, 0.00805841f, 0.00699820f, -0.02314708f, 0.02946012f, -0.01997801f, -0.00447396f, 0.01165790f, 
    -0.00154377f, 0.05349588f, -0.01270115f, 0.02523849f, 0.02296520f, 0.03522815f, 0.03643888f, -0.04667003f, 
    0.04371426f, 0.02021949f, -0.01119482f, 0.03068951f, 0.00522625f, -0.02095122f, -0.03225641f, -0.02640757f, 
    -0.04121962f, -0.00257085f, -0.03717774f, 0.03816746f, 0.00603127f, -0.01916993f, -0.01734714f, -0.02855388f, 
    -0.05257613f, -0.03974318f, -0.05497815f, 0.03931458f, -0.00847870f, 0.02412362f, 0.04452205f, 0.00267517f, 
    -0.03900506f, 0.04862958f, 0.02883500f, 0.02222813f, -0.05062569f, 0.00141832f, -0.01781720f, -0.01450598f, 
    0.03457189f, -0.04524175f, 0.04350296f, -0.05561064f, 0.01773185f, -0.03721057f, -0.00100505f, 0.01198781f, 
    -0.00815162f, -0.03934724f, 0.05037123f, 0.01953803f, 0.00844848f, 0.00333907f, 0.04159980f, -0.04663103f, 
    0.04229521f, -0.03958718f, 0.00949898f, -0.00888193f, -0.02537126f, 0.00991183f, -0.04560836f, 0.03586913f, 
    -0.01809174f, -0.05522687f, 0.00558714f, -0.06469568f, -0.04985645f, 0.04538580f, 0.02663156f, -0.02638746f, 
    -0.01338793f, -0.04637884f, -0.04225605f, -0.02150243f, -0.05621700f, 0.00628490f, -0.03556855f, 0.01368061f, 
    0.04637464f, -0.04216728f, 0.00342074f, -0.00669624f, -0.00737052f, -0.03001798f, 0.01075584f, -0.02287479f, 
    -0.04884504f, 0.00967029f, 0.01793745f, 0.04342780f, -0.01678858f, 0.02627967f, 0.03397794f, -0.04705246f, 
    0.01078683f, 0.03873939f, -0.01496325f, -0.00870666f, 0.03287783f, -0.03805662f, -0.04858757f, -0.01688643f, 
    -0.03203776f, 0.00397349f, -0.01921957f, 0.01794050f, 0.00623412f, -0.03479056f, 0.02965182f, 0.01787710f, 
    -0.01480154f, -0.04319949f, -0.00714519f, 0.03946748f, -0.02891151f, 0.03712209f, -0.02309093f, -0.05184329f, 
    0.00805373f, -0.01683230f, 0.02376039f, -0.00874295f, -0.00122832f, 0.03932450f, -0.01123326f, -0.01568413f, 
    -0.03154308f, -0.05950887f, 0.04949011f, -0.05874779f, -0.05403580f, -0.05856129f, 0.00149803f, 0.03922364f, 
    -0.03669960f, -0.01203629f, -0.01831770f, 0.02492839f, 0.03794283f, 0.04669007f, -0.00450340f, -0.02148321f, 
    -0.01020768f, -0.04901334f, -0.06008162f, 0.00361164f, -0.05967338f, 0.04170273f, 0.02153542f, -0.01245249f, 
    -0.01672141f, -0.00659362f, -0.00956136f, -0.06119787f, 0.01275319f, 0.00397102f, 0.02192798f, -0.02419567f, 
    -0.06175082f, 0.03818793f, -0.01838497f, -0.03974847f, -0.00904123f, -0.01042461f, 0.02005263f, 0.03104019f, 
    0.02495176f, -0.05580556f, 0.02901764f, 0.00845714f, 0.04158691f, 0.03108671f, -0.02393578f, -0.05668594f, 
    0.03850483f, -0.05475793f, -0.04689938f, -0.00477077f, 0.04074821f, 0.00375916f, 0.05101738f, -0.04069789f, 
    -0.03868123f, 0.04881277f, 0.00051167f, 0.02565287f, -0.03145700f, 0.04970502f, -0.05681936f, -0.04768011f, 
    -0.02296482f, 0.02165206f, -0.05769021f, -0.01223622f, 0.03657571f, -0.02843129f, 0.04707624f, -0.00645695f, 
    -0.03858664f, -0.02443696f, -0.05304786f, 0.02197999f, -0.05344281f, -0.00949761f, -0.02473230f, 0.00828000f, 
    -0.04744801f, -0.01654165f, -0.00450155f, -0.04921595f, -0.01790607f, -0.03226933f, -0.02127948f, 0.01400751f, 
    -0.02307461f, -0.02794063f, 0.03439806f, 0.04063088f, -0.02071474f, 0.04622729f, -0.06393521f, 0.05464719f, 
    0.00642455f, 0.01624228f, -0.02917507f, -0.01142478f, 0.00500595f, 0.04205665f, -0.02341592f, -0.06578046f, 
    0.04493664f, -0.06472442f, 0.03944591f, -0.03586626f, -0.00234626f, 0.02528335f, 0.02353723f, -0.01337416f, 
    0.00958864f, 0.01588187f, 0.02497889f, 0.00734556f, -0.02787288f, 0.00302836f, 0.01109245f, -0.01219718f, 
    -0.05062802f, 0.01797381f, -0.03875450f, -0.04139318f, 0.02227502f, -0.04090662f, 0.03072450f, -0.03253978f, 
    -0.05751491f, 0.00077026f, -0.02213694f, 0.02920473f, -0.00803463f, -0.01172862f, -0.03524375f, -0.04831505f, 
    -0.06028631f, 0.03240201f, -0.02570937f, 0.04474953f, 0.02952023f, 0.00507420f, 0.01585524f, -0.00376474f, 
    0.03666018f, 0.03477114f, 0.00262451f, -0.01940528f, 0.04062275f, -0.01953697f, 0.01945735f, -0.04936967f, 
    -0.01904114f, -0.01197885f, 0.04619760f, 0.01785460f, -0.02569664f, 0.02817951f, 0.00284047f, -0.04642104f, 
    -0.00737938f, 0.00567091f, -0.03502867f, -0.04408376f, 0.04193533f, 0.00246701f, -0.02637607f, 0.04597340f, 
    -0.01657823f, -0.02724406f, -0.04216303f, 0.04413978f, -0.07135725f, -0.02094693f, -0.04399179f, 0.03666461f, 
    0.05882972f, 0.05129829f, 0.04306390f, 0.01539469f, -0.00774639f, 0.04476860f, 0.03040776f, -0.05368880f, 
    -0.00028932f, -0.05799238f, 0.03351315f, 0.01317388f, 0.04945513f, -0.05261707f, 0.03487395f, 0.05009900f, 
    0.04865640f, -0.00359350f, -0.02284455f, -0.04121082f, -0.05216855f, 0.01636343f, 0.01065640f, 0.03240821f, 
    -0.04079694f, 0.04965984f, -0.05867682f, -0.02780134f, 0.02502136f, -0.01854124f, 0.01336537f, 0.02419196f, 
    0.04560318f, -0.01343696f, -0.04820012f, -0.02843246f, -0.01941472f, 0.00413662f, -0.01594548f, -0.01424106f, 
    -0.05340429f, -0.04563397f, -0.01157851f, 0.02616735f, -0.05726312f, 0.05124958f, 0.00561815f, 0.00614101f, 
    0.01093749f, 0.00193896f, 0.00953216f, -0.04557858f, 0.00638609f, -0.02530446f, 0.05026941f, 0.00798222f, 
    -0.02130281f, 0.02166291f, 0.01387319f, -0.00470759f, -0.02739555f, 0.02219452f, 0.03705514f, 0.00304342f, 
    -0.03811225f, -0.03940761f, 0.03648623f, 0.04496875f, 0.03404459f, 0.02390207f, 0.02489409f, -0.06278398f, 
    -0.03214679f, 0.03647939f, 0.00252202f, -0.04015268f, 0.01651359f, 0.02775568f, 0.03229130f, -0.01369077f, 
    0.05033493f, -0.00837592f, 0.00930523f, 0.03323939f, 0.02183720f, -0.05450724f, 0.00231500f, 0.01932658f, 
    -0.05867044f, -0.04757657f, -0.02772698f, 0.03839137f, 0.03035831f, -0.05527503f, 0.03847870f, 0.04172453f, 
    0.03393598f, 0.04264856f, -0.06716690f, -0.02267246f, -0.01930359f, -0.03283201f, 0.05205053f, -0.04466999f, 
    -0.01905130f, -0.01780134f, 0.01565192f, 0.02628917f, -0.00201038f, -0.02889071f, -0.00499377f, -0.01078841f, 
    -0.00467651f, 0.01080146f, 0.00544861f, -0.03818773f, -0.03430199f, -0.04670671f, 0.02850684f, -0.05429997f, 
    -0.04148798f, -0.05193052f, 0.03694407f, 0.03223950f, 0.03679106f, 0.05254237f, -0.05124744f, -0.00780019f, 
    0.04922803f, -0.03144830f, -0.03306321f, 0.01062629f, 0.03226133f, 0.04336210f, 0.03450309f, -0.03978705f, 
    -0.02888517f, 0.01244631f, 0.02007484f, -0.01716868f, 0.04813066f, 0.00160055f, 0.03474595f, 0.02856399f, 
    0.04100832f, -0.00052580f, -0.02215224f, -0.04468093f, -0.01290161f, -0.00237463f, -0.06139921f, 0.02040426f, 
    -0.00649367f, -0.04825010f, -0.04063657f, -0.02295633f, 0.05257299f, 0.02860945f, 0.00009495f, -0.01391265f, 
    0.01034803f, 0.01664965f, -0.04178606f, 0.04839856f, -0.03134743f, -0.02507053f, 0.03133765f, -0.01910186f, 
    -0.00694067f, -0.05193298f, 0.00314570f, -0.01282143f, -0.05669193f, -0.05736481f, -0.06090353f, -0.05806321f, 
    0.00105945f, -0.06077123f, -0.02799958f, -0.04948065f, 0.04219549f, -0.06715639f, 0.03149913f, 0.03039559f, 
    0.00328268f, -0.01828927f, -0.01802683f, -0.02250131f, -0.03454945f, 0.01353699f, -0.06486136f, -0.02763969f, 
    -0.05253725f, -0.00485411f, -0.00585616f, -0.03755054f, -0.01033811f, 0.04116909f, -0.02869049f, -0.00224231f, 
    -0.03536810f, -0.02213702f, -0.00702707f, -0.04203111f, -0.04831203f, -0.04221427f, 0.04566798f, -0.01618529f, 
    -0.01314736f, -0.00800201f, -0.05044562f, -0.03924124f, 0.03805741f, -0.01850943f, 0.03055305f, -0.04330151f, 
    0.01063438f, 0.02749325f, 0.00201047f, 0.04143240f, -0.02148011f, -0.04864897f, 0.02053112f, -0.00277166f, 
    -0.03692981f, -0.00839471f, 0.05434442f, -0.00675623f, -0.00897539f, 0.00937786f, -0.01624138f, 0.01780146f, 
    0.01006100f, -0.02161781f, -0.04227456f, -0.01906348f, -0.00810590f, -0.04252332f, -0.00022619f, -0.02252038f, 
    -0.00207276f, -0.01612616f, -0.02366382f, 0.05934568f, 0.04953218f, -0.04512174f, -0.02142113f, 0.00037478f, 
    0.03324312f, 0.03174727f, 0.02974015f, -0.06449950f, -0.02735177f, 0.03982184f, -0.03760186f, 0.00224636f, 
    -0.02433563f, 0.04514775f, -0.02574275f, -0.01471690f, -0.02819447f, -0.01422990f, 0.02706379f, 0.03011268f, 
    -0.05398559f, 0.04618962f, -0.00938524f, -0.01399313f, 0.04082675f, 0.02097598f, -0.01290808f, -0.00435262f, 
    0.00432340f, 0.04977935f, -0.02644198f, -0.02786902f, -0.05702762f, -0.05560390f, 0.02209339f, -0.06543301f, 
    -0.01970832f, 0.00583447f, -0.05299614f, -0.02019650f, 0.03582295f, -0.03880126f, 0.04793923f, 0.03602429f, 
    -0.02543859f, -0.04555259f, 0.00884591f, -0.02190850f, -0.04837020f, 0.00764868f, -0.05847652f, -0.02906926f, 
    -0.00415750f, -0.02007074f, -0.05600243f, -0.03660272f, -0.00190276f, -0.00986516f, -0.05219851f, 0.00733312f, 
    0.01091065f, -0.03889120f, -0.04530530f, -0.05821649f, 0.05117701f, -0.05117217f, -0.05410891f, -0.05872375f, 
    -0.06209713f, -0.03341492f, -0.05043869f, -0.05581717f, 0.00883986f, -0.02462309f, -0.02578458f, 0.02987505f, 
    0.01673132f, 0.03438653f, -0.02736914f, -0.04827451f, -0.04143038f, -0.03068688f, -0.04194541f, -0.03019447f, 
    0.04069412f, -0.06332774f, 0.05091408f, 0.02714929f, -0.00968623f, -0.01461624f, -0.04198654f, 0.02674735f, 
    0.01194841f, 0.04743391f, 0.01872351f, 0.04036827f, 0.05070461f, -0.01912704f, 0.05758870f, 0.02194989f, 
    -0.05722828f, 0.22506198f, -0.01719234f, 0.18495283f, 0.10042740f, 0.07553501f, -0.06397008f, 0.07244899f, 
    0.17696045f, 0.15313952f, -0.14231211f, -0.03729605f, -0.04720549f, -0.00543882f, 0.04370933f, -0.05908854f, 
    0.10216200f, -0.12651931f, -0.35102206f, 0.20518784f, 0.31375211f, 0.12505870f, -0.16656412f, -0.21952614f, 
    -0.02992694f, 0.16560854f, 0.10419605f, 0.18672958f, 0.34422770f, 0.10215806f, -0.01803014f, 0.14566590f, 
    -0.05528739f, 0.03296861f, 0.16319869f, 0.18806186f, -0.38095441f, -0.40576440f, -0.21868686f, 0.01230568f, 
    0.10846414f, 0.01099533f, 0.08684113f, -0.32886854f, -0.15596770f, -0.39258638f, -0.30382514f, -0.37370983f, 
    -0.09831120f, 0.01940237f, 0.16112442f, 0.01538444f, 0.03199399f, -0.11338238f, 0.21668650f, 0.04960482f, 
    -0.22655325f, 0.06394328f, -0.09295394f, -0.31064057f, 0.10417304f, 0.02133917f, 0.00895013f, 0.28176787f, 
    0.24761669f, 0.06670064f, -0.28984591f, -0.14506732f, -0.26989737f, 0.02066700f, 0.12928289f, 0.08894483f, 
    -0.00000490f, -0.01420462f, -0.09129641f, -0.00941644f, -0.23924175f, -0.04575661f, -0.10505663f, -0.04478114f, 
    0.29454276f, 0.13942304f, -0.17326221f, 0.26894224f, 0.11915261f, -0.03300695f, 0.02389499f, 0.32840022f, 
    -0.08085130f, -0.02376943f, -0.10361233f, -0.24455385f, -0.47610772f, -0.14572948f, -0.01793752f, -0.20265818f, 
    0.22699609f, -0.08855826f, -0.11891660f, -0.01641767f, -0.22094265f, 0.09261261f, -0.09603412f, -0.04740011f, 
    0.14931862f, 0.09829358f, -0.07930809f, 0.05086390f, -0.86832851f, -0.25176048f, 0.48642522f, 0.28569233f, 
    0.06699050f, 0.03708168f, -0.15342233f, 0.01872175f, -0.06326822f, -0.24647610f, 0.25120211f, 0.15031815f, 
    -0.11024790f, -0.00401387f, -0.23996939f, -0.11124031f, -0.07576684f, 0.02216735f, -0.15539420f, 0.07715116f, 
    0.24862853f, -0.30877692f, 0.31909177f, 0.08564518f, -0.08989311f, 0.09633592f, 0.15443157f, 0.02018386f, 
    0.24310367f, 0.04838880f, 0.00316989f, 0.02097531f, -0.00436848f, -0.15330519f, 0.05488447f, -0.14235795f, 
    -0.03545151f, 0.01444941f, -0.05139339f, 0.24631552f, 0.06180738f, -0.12772040f, 0.03545529f, -0.08155949f, 
    0.15559283f, -0.49991098f, -0.56801832f, -0.06456103f, 0.09093028f, 0.24366410f, -0.01652784f, -0.02254684f, 
    0.16141826f, 0.05872772f, -0.09874354f, -0.40698680f, -0.17066838f, 0.21253052f, -0.01636312f, 0.05661434f, 
    -0.01695017f, -0.11813329f, -0.13298376f, -0.19962537f, -0.26196733f, -0.11496297f, 0.22342193f, -0.10523574f, 
    0.19542952f, -0.02843895f, 0.11125390f, -0.14076337f, -0.10501941f, 0.00560208f, 0.11725374f, 0.12229212f, 
    0.08496720f, 0.01365768f, 0.19937232f, -0.19237840f, 0.00217405f, 0.47396827f, 0.28288645f, -0.02575869f, 
    -0.01050102f, 0.07716247f, -0.07181277f, 0.16587952f, -0.12981744f, -0.15604681f, -0.17514312f, -0.01071286f, 
    0.08125380f, -0.16965602f, 0.11562400f, -0.14809804f, 0.04868292f, -0.16997054f, -0.22232139f, 0.08697139f, 
    0.20917460f, 0.13284560f, -0.09911630f, -0.29997176f, -0.08212946f, 0.12577008f, 0.05620448f, 0.17891212f, 
    0.24844472f, -0.13654347f, -0.04363255f, 0.10372490f, 0.13306265f, 0.01648441f, -0.03110912f, -0.20690136f, 
    0.09393009f, 0.19495849f, 0.07706539f, 0.24537303f, -0.00088474f, -0.07471368f, -0.12975183f, 0.03665339f, 
    0.06270444f, -0.11938964f, -0.28630412f, 0.07554966f, 0.14526650f, 0.02066266f, -0.07820130f, -0.06578925f, 
    0.17058735f, 0.09111700f, -0.18516025f, -0.38368729f, -0.45694795f, -0.04838706f, 0.23744343f, 0.11735162f, 
    -0.08097014f, -0.08987887f, -0.04663213f, -0.05635869f, 0.26043180f, 0.44727054f, 0.23726276f, 0.14555363f, 
    -0.13446791f, -0.11687101f, 0.07185384f, 0.20242715f, 0.21074457f, 0.09139725f, 0.18520023f, -0.10946415f, 
    0.05252184f, -0.05107488f, -0.09733903f, -0.00038525f, 0.10460737f, 0.12509945f, 0.07571727f, 0.07555369f, 
    -0.08577964f, 0.22761522f, -0.19015941f, -0.03505970f, 0.00191702f, -0.04030813f, -0.09583859f, -0.20683171f, 
    0.35055754f, 0.23671764f, 0.18176423f, -0.19486906f, -0.05009675f, -0.07343432f, 0.13183685f, 0.16648965f, 
    0.08847481f, 0.02101452f, 0.23337922f, -0.01500737f, 0.08317414f, -0.13818549f, -0.07578051f, 0.19536985f, 
    -0.01656649f, -0.52928239f, 0.22075897f, 0.06575813f, 0.23043227f, -0.06162329f, -0.09408864f, -0.13267817f, 
    0.02366848f, -0.00487448f, 0.29784861f, -0.51881820f, 0.30191323f, -0.09909095f, 0.17309637f, -0.08254834f, 
    0.11499739f, 0.06446157f, -0.06326346f, 0.61425960f, -0.15212433f, 0.31154647f, -0.21619494f, 0.00452851f, 
    0.02684744f, 0.17381093f, -0.02531870f, 0.15468581f, 0.45482796f, -0.01354829f, -0.56595778f, 0.03221061f, 
    -0.00822539f, 0.19240324f, 0.12744083f, 0.16818218f, 0.07768883f, 0.06145047f, -0.42659992f, -0.29463661f, 
    -0.21923859f, -0.23626372f, 0.03325716f, 0.07269970f, -0.06320577f, 0.00906716f, 0.08712516f, 0.14573029f, 
    0.16644579f, 0.31155765f, 0.01888593f, -0.09177832f, -0.35515326f, 0.05207652f, 0.25544849f, 0.29491061f, 
    -0.21732160f, 0.15726724f, 0.08126758f, 0.01451876f, 0.01488602f, -0.02565463f, -0.09286824f, 0.12714954f, 
    0.09051646f, -0.16332954f, 0.05434303f, 0.00886157f, 0.20663781f, 0.23919654f, 0.02329602f, 0.00690901f, 
    -0.19442992f, 0.02287340f, 0.16128331f, 0.00487940f, -0.12937641f, -0.10200552f, 0.42018467f, -0.09011367f, 
    0.04567308f, 0.17576073f, 0.16095211f, 0.24013062f, -0.35392892f, 0.10359698f, -0.04297905f, 0.26445487f, 
    -0.13464676f, -0.09252095f, -0.16172302f, -0.17122540f, 0.15419592f, -0.00888914f, 0.04469976f, 0.02388466f, 
    0.15244347f, -0.04416211f, 0.07409750f, -0.14490853f, -0.14559014f, -0.07458187f, 0.34869689f, 0.03079578f, 
    0.11062156f, 0.16370267f, -0.03220947f, -0.04415424f, -0.02060621f, 0.02943799f, -0.13019817f, -0.32974428f, 
    -0.03574884f, 0.25748625f, -0.10087465f, 0.05165739f, -0.09405277f, -0.10543137f, 0.40689576f, 0.08227944f, 
    -0.53679448f, -0.13350360f, -0.05671408f, -0.01846522f, -0.06622703f, -0.04411099f, 0.02434882f, -0.09743271f, 
    -0.26186752f, 0.02869559f, 0.04251947f, 0.13975120f, 0.04339873f, 0.01849702f, -0.04442347f, 0.12545656f, 
    -0.54957557f, 0.18849997f, 0.13492776f, -0.00986583f, 0.04126307f, -0.04526911f, 0.09130705f, -0.12559171f, 
    -0.09969015f, -0.08422461f, 0.05297917f, 0.39520335f, -0.23268953f, 0.09752370f, 0.06993997f, -0.06623331f, 
    0.04522707f, -0.28436148f, -0.07605566f, 0.13865159f, 0.10108922f, -0.06243010f, -0.15070719f, 0.10263710f, 
    0.10374410f, 0.00939312f, 0.13319983f, 0.34322384f, 0.05851425f, 0.03476466f, 0.18886331f, 0.08915282f, 
    -0.02839815f, -0.03791115f, 0.07028493f, -0.06410375f, 0.21839207f, 0.34792426f, 0.17857984f, -0.02155208f, 
    0.12223552f, 0.03021661f, -0.18103933f, 0.00851567f, -0.00295468f, -0.01636852f, 0.02212388f, 0.08832993f, 
    -0.01696745f, -0.14596157f, -0.07771408f, -0.04820189f, 0.03494924f, 0.01979096f, -0.11226203f, -0.16937806f, 
    -0.15787728f, 0.14932597f, -0.09385218f, 0.14248577f, -0.02659489f, -0.10692267f, 0.27513605f, 0.24256562f, 
    0.21481106f, -0.06481528f, -0.10878103f, 0.05735569f, -0.16680606f, -0.20549271f, -0.14862305f, 0.09866592f, 
    0.21965559f, -0.00203134f, -0.11699568f, 0.08085075f, 0.08914473f, -0.02714247f, -0.01990386f, 0.04401712f, 
    -0.11277047f, -0.52494490f, 0.01379280f, 0.02098547f, 0.03547413f, 0.07059799f, 0.04659241f, -0.15974313f, 
    -0.03926460f, 0.09114257f, 0.25921091f, 0.04373476f, -0.15358265f, -0.20881908f, -0.09006841f, -0.03856154f, 
    -0.06703970f, -0.06396896f, -0.14273320f, -0.49939543f, 0.01538849f, 0.26313096f, 0.01965692f, 0.17350319f, 
    0.20847452f, 0.12801762f, 0.08416326f, -0.19044122f, -0.34659284f, -0.42290655f, 0.10048359f, -0.08213652f, 
    0.07780962f, -0.04351632f, -0.09076424f, -0.05691907f, -0.24145181f, 0.14585944f, -0.54161525f, -0.18344267f, 
    -0.15575130f, -0.07953001f, -0.01360074f, -0.04595292f, -0.05790539f, 0.08320015f, -0.13846309f, 0.03175324f, 
    0.00601620f, 0.03516573f, -0.23355614f, -0.08203501f, -0.22849511f, 0.04928804f, -0.01842847f, 0.19614731f, 
    -0.26455101f, 0.16901098f, -0.08852469f, 0.01351207f, -0.02571335f, -0.00110609f, -0.02509032f, 0.02819612f, 
    -0.19915898f, -0.03672350f, -0.17172670f, -0.04734311f, 0.04669550f, -0.04419938f, -0.01130912f, 0.08260237f, 
    -0.03503490f, 0.28639534f, 0.15388484f, -0.10576959f, -0.00095354f, -0.03353357f, -0.09067846f, 0.28305316f, 
    0.05970804f, 0.06365032f, 0.15563171f, 0.00371995f, 0.48070252f, 0.14711642f, -0.36377233f, 0.15013191f, 
    -0.06610169f, -0.01636086f, -0.05986927f, 0.23776747f, 0.07842861f, 0.24925236f, -0.01917738f, 0.09779359f, 
    0.18129452f, 0.01371902f, 0.08520725f, -0.05368331f, 0.10171276f, -0.21477558f, -0.44306770f, 0.34503236f, 
    -0.07212035f, 0.16916989f, 0.09625096f, 0.08766232f, 0.02166160f, 0.16698867f, -0.23468357f, -0.31248271f, 
    -0.24505137f, -0.04754903f, -0.13663065f, -0.25164121f, 0.04923625f, -0.12110209f, -0.21932144f, -0.06049934f, 
    0.04745417f, -0.05844584f, -0.14506125f, 0.01383621f, -0.20802005f, -0.15075558f, 0.07082170f, 0.38785401f, 
    -0.17959107f, 0.17456916f, 0.10491835f, 0.12883793f, 0.18049128f, 0.00037645f, -0.00876519f, 0.11885042f, 
    0.09706625f, -0.08905694f, -0.05179334f, -0.18065980f, -0.17452231f, 0.01486985f, 0.09218354f, -0.03358719f, 
    0.15863323f, -0.11102400f, 0.11331772f, 0.20796685f, 0.00469492f, -0.08846044f, -0.05166418f, 0.12328447f, 
    0.00666045f, -0.06743851f, -0.00675786f, 0.10937391f, -0.22637959f, 0.06250487f, 0.04505946f, 0.11844453f, 
    0.04092853f, 0.07814413f, -0.03094815f, 0.54857546f, -0.08400265f, -0.16399865f, 0.30768570f, -0.03187243f, 
    -0.21724404f, -0.21622731f, 0.16783999f, -0.01037540f, -0.07108718f, -0.04433296f, 0.06021894f, -0.15068763f, 
    0.15906800f, -0.00431782f, -0.07951001f, 0.06998827f, -0.01077969f, -0.41481400f, -0.26203057f, -0.37147886f, 
    -0.06368759f, -0.04738074f, -0.09656812f, -0.03800668f, -0.18383159f, 0.05717132f, 0.20825535f, 0.09298231f, 
    0.08644944f, 0.28312707f, 0.00503162f, 0.05304146f, -0.06830505f, 0.02148822f, 0.08303583f, -0.22351228f, 
    0.11738228f, 0.29050666f, 0.16150813f, 0.03351598f, 0.01839968f, 0.17561978f, -0.03302075f, -0.10022903f, 
    -0.39690876f, 0.07060173f, -0.02587247f, 0.09562696f, 0.07217698f, 0.11484710f, 0.03107589f, 0.05635289f, 
    -0.03212484f, -0.11198653f, -0.07754704f, 0.20374732f, -0.11510058f, -0.14922333f, -0.15796609f, 0.03748417f, 
    0.05726176f, -0.05820896f, 0.03833919f, -0.01199421f, 0.07965426f, -0.08117357f, -0.20934816f, 0.13954924f, 
    -0.27491710f, 0.02709872f, 0.07738569f, -0.28535143f, -0.10509969f, -0.27388316f, 0.04374048f, 0.17126587f, 
    -0.14546503f, 0.02817736f, 0.08337837f, -0.13850266f, 0.39941883f, 0.08047447f, 0.19289191f, 0.04978833f, 
    0.10261725f, 0.10386324f, 0.14249291f, 0.03965910f, -0.16249160f, -0.00291414f, 0.06639172f, 0.11862809f, 
    0.11032242f, -0.08008870f, -0.03194360f, 0.19962277f, 0.00130949f, 0.01855734f, -0.30977085f, -0.21066448f, 
    0.37340975f, 0.17824391f, 0.24079409f, 0.23953341f, 0.13389638f, -0.07953339f, 0.13508517f, -0.00640600f, 
    -0.02864080f, -0.11381528f, -0.17381199f, 0.03462507f, -0.07599448f, -0.16364327f, 0.00300042f, -0.07095220f, 
    -0.03279765f, -0.15278672f, -0.28376931f, -0.01238787f, -0.18620704f, -0.15267964f, 0.04821640f, 0.08484325f, 
    0.01291540f, -0.14622147f, 0.02598727f, 0.05219978f, -0.25687629f, 0.15221724f, -0.02445279f, -0.10733942f, 
    -0.08452757f, -0.02009937f, -0.13808027f, 0.02850600f, 0.20829520f, -0.17921095f, 0.22068997f, -0.26325914f, 
    -0.09642734f, 0.14449573f, 0.10367083f, -0.10722831f, 0.14651765f, 0.24494372f, -0.08933235f, -0.22475041f, 
    0.01352277f, -0.06739160f, -0.05620351f, -0.13226329f, 0.37851653f, -0.09880667f, -0.13681711f, -0.09304784f, 
    -0.02821731f, -0.10767554f, -0.14902128f, -0.02125002f, -0.00203326f, -0.24022086f, -0.39618549f, 0.12308262f, 
    0.06565238f, -0.20361423f, -0.00643931f, 0.02941690f, 0.18322837f, 0.06015202f, -0.17337005f, -0.20378642f, 
    -0.15532804f, 0.03100806f, 0.13314380f, 0.07147870f, 0.15265940f, -0.10107183f, 0.14155702f, 0.08739253f, 
    0.29138348f, 0.23398626f, 0.22354804f, -0.35568571f, 0.21619387f, 0.05524221f, 0.01796415f, 0.01150682f, 
    0.03604097f, -0.00535924f, 0.05070017f, -0.02246988f, -0.03349363f, 0.01801586f, -0.04965916f, -0.02973749f, 
    0.02014034f, 0.04827102f, 0.04338494f, -0.04296244f, 0.04289068f, 0.02452707f, 0.01309350f, -0.02917355f, 
    0.00815110f, -0.01658104f, 0.01868806f, -0.01399201f, 0.04205294f, 0.03281236f, -0.05774047f, 0.03008023f, 
    0.04780766f, 0.05008508f, -0.06341522f, -0.00060810f, 0.03232899f, -0.03036247f, -0.01865672f, -0.04559759f, 
    -0.04885305f, 0.03612887f, -0.03808987f, -0.02200154f, -0.02304914f, 0.04087126f, 0.05572331f, -0.03874002f, 
    -0.02255771f, 0.01439114f, 0.01944449f, -0.00754803f, -0.05514933f, -0.05137245f, -0.05116870f, 0.03058224f, 
    0.04747592f, 0.01924602f, 0.04612034f, 0.02199412f, -0.00522411f, -0.00993725f, -0.02069809f, 0.04400879f, 
    -0.05316062f, 0.03572021f, 0.04690616f, -0.03282915f, 0.04872224f, 0.02887966f, -0.02799442f, 0.04754565f, 
    0.03998232f, 0.00623900f, 0.05101051f, -0.00617015f, -0.03999927f, -0.02496353f, -0.05760079f, 0.00741783f, 
    -0.04967801f, -0.05093871f, -0.05386876f, 0.04456224f, 0.02644109f, 0.01668180f, 0.02343410f, -0.03953739f, 
    -0.01747935f, -0.02603257f, -0.01882176f, 0.03404585f, 0.00432679f, 0.02247520f, -0.02872022f, 0.01968187f, 
    -0.01068006f, -0.01846334f, -0.04673219f, -0.05844238f, -0.05277507f, -0.05183043f, -0.00501974f, 0.02840852f, 
    0.02727181f, -0.00587820f, -0.02603649f, 0.01221397f, 0.00845165f, 0.00628718f, -0.02609656f, 0.03749771f, 
    0.00019714f, -0.03176479f, 0.01529150f, -0.06868680f, -0.02630613f, -0.01160455f, 0.02709148f, -0.02740854f, 
    -0.01509673f, 0.00194643f, -0.02845214f, -0.00982935f, 0.05433270f, 0.01548057f, -0.03138506f, 0.03094235f, 
    0.04260187f, -0.04336166f, 0.03118270f, 0.01655963f, 0.03109470f, -0.00755660f, -0.02271200f, -0.00810740f, 
    -0.02048983f, -0.03084551f, 0.05280174f, 0.03725451f, -0.00528495f, 0.01565903f, 0.00300978f, -0.03191290f, 
    0.01544775f, 0.00980392f, -0.04674639f, -0.03946296f, -0.00769992f, -0.00547669f, -0.02642237f, -0.00168940f, 
    0.02055478f, 0.02422900f, -0.00839239f, -0.03171123f, 0.01125830f, -0.01218109f, 0.03955493f, 0.03554342f, 
    -0.01243821f, -0.04597050f, -0.00527300f, 0.00408811f, -0.00620189f, 0.05404750f, -0.01243543f, 0.04862350f, 
    -0.01883856f, -0.00255352f, -0.03196548f, 0.03066530f, 0.04123075f, -0.03945337f, -0.05933062f, -0.01943878f, 
    0.03349345f, 0.04824253f, 0.05498486f, -0.04532245f, -0.04569945f, 0.04574624f, 0.00796836f, -0.04803371f, 
    0.03143062f, 0.01219747f, -0.05487378f, 0.02555054f, 0.03175594f, -0.03196418f, 0.01546589f, -0.04223642f, 
    0.01677502f, 0.00899923f, -0.01196466f, 0.04464274f, -0.01474175f, 0.00619901f, -0.00212836f, 0.02461753f, 
    0.00188886f, 0.01373842f, -0.01437138f, -0.01791427f, 0.02763981f, 0.00361505f, 0.05443014f, -0.01675347f, 
    -0.05200677f, 0.02225585f, -0.05300364f, -0.02020406f, -0.02765932f, -0.03371079f, -0.01265899f, -0.00309535f, 
    0.02317929f, -0.00907072f, -0.02926856f, 0.00045737f, -0.06001378f, -0.00821360f, 0.05071967f, -0.04599100f, 
    -0.01778038f, 0.00422428f, 0.05051414f, -0.01011992f, 0.00146661f, -0.05216087f, 0.01690784f, -0.00958500f, 
    -0.05261962f, -0.05199268f, -0.05579069f, -0.02286283f, -0.01544093f, 0.02205381f, -0.00254786f, -0.04270205f, 
    0.04808717f, -0.04510475f, -0.04199890f, 0.02914469f, -0.06411898f, 0.01725913f, -0.03041738f, -0.03172973f, 
    -0.03424567f, -0.04575255f, 0.02477216f, -0.05667844f, -0.00449493f, 0.04344968f, -0.02747532f, 0.02646107f, 
    -0.05146845f, 0.01086348f, -0.04212169f, -0.01003376f, -0.03754880f, 0.02321600f, -0.05493183f, 0.03092823f, 
    -0.01110945f, -0.04126519f, -0.03172523f, -0.03418573f, -0.05732982f, -0.00339217f, -0.06296588f, 0.01336891f, 
    0.03177071f, 0.00356551f, -0.01155216f, 0.01467118f, -0.03541569f, -0.05964967f, 0.06239136f, 0.01190129f, 
    -0.00695299f, -0.05827475f, -0.00926189f, -0.01264187f, -0.02853012f, -0.06524860f, 0.03860334f, 0.01017408f, 
    -0.06722967f, -0.01715026f, -0.02242244f, 0.00320566f, -0.05020700f, -0.00582135f, -0.00637459f, 0.02125233f, 
    0.00056264f, -0.01434760f, 0.00411355f, -0.05539957f, 0.02658042f, -0.01272321f, 0.02355883f, -0.04427413f, 
    -0.05442347f, -0.05095730f, -0.06608155f, -0.02578713f, 0.03717190f, 0.01362295f, 0.04904137f, 0.03325690f, 
    0.04669002f, -0.01926152f, 0.01047715f, -0.00206486f, 0.01668599f, -0.04277961f, -0.02003152f, -0.06077131f, 
    0.00520727f, -0.03108410f, 0.01404666f, 0.05070650f, -0.06757248f, 0.04899007f, 0.02228883f, -0.02167361f, 
    0.00523116f, -0.02219643f, -0.01436437f, 0.02430525f, 0.04491060f, 0.03709554f, 0.01347810f, 0.03144950f, 
    0.04000795f, 0.03537226f, -0.04258999f, -0.01911119f, 0.00358787f, -0.01662629f, 0.02624183f, 0.00832134f, 
    -0.00357785f, -0.06771601f, -0.02415158f, -0.00318581f, 0.01082887f, 0.03593118f, 0.01598556f, -0.03318211f, 
    -0.05104024f, -0.03795401f, 0.03878856f, 0.05065691f, -0.01522808f, -0.05734200f, 0.00044100f, -0.00562269f, 
    -0.02108147f, 0.00521214f, -0.01770954f, -0.02322080f, -0.03495457f, -0.00396964f, -0.03162597f, 0.00161584f, 
    0.03932865f, 0.01671935f, -0.00690212f, 0.02247014f, -0.05070448f, 0.00242198f, -0.01772270f, -0.03586848f, 
    -0.05846333f, 0.00739009f, 0.02474872f, 0.01496095f, -0.00312232f, -0.02403815f, -0.00303937f, 0.02747207f, 
    -0.01796309f, -0.05687783f, 0.01020679f, -0.04443950f, 0.03763143f, 0.02616317f, 0.01459203f, -0.05541620f, 
    0.03604520f, -0.05912647f, -0.00114935f, -0.03677966f, -0.05492521f, -0.03139186f, -0.01896319f, 0.02026105f, 
    -0.04754534f, -0.06704178f, -0.06185345f, -0.05780001f, -0.05818902f, -0.03131248f, 0.02247784f, 0.04300440f, 
    -0.00969909f, 0.04778976f, 0.01196729f, -0.04050692f, 0.02933355f, -0.05776602f, 0.01152406f, -0.02231123f, 
    -0.04987064f, 0.02011332f, -0.06527501f, -0.02141277f, 0.03727583f, 0.00299154f, -0.02473740f, -0.04791344f, 
    0.03617920f, 0.00203665f, -0.01692812f, -0.03012389f, 0.05055680f, -0.03738445f, 0.00288517f, -0.04234009f, 
    0.02720290f, -0.03547959f, 0.00582287f, 0.01974946f, -0.02757404f, -0.02048225f, -0.03291621f, 0.03830719f, 
    0.03107572f, 0.01432069f, 0.00011740f, -0.03554659f, 0.02541750f, 0.02906640f, 0.02469003f, -0.04232102f, 
    0.00718173f, -0.00257095f, -0.06406911f, -0.06616785f, 0.02742184f, 0.02218207f, -0.01033084f, -0.05950770f, 
    0.00627173f, 0.04383731f, -0.05459319f, -0.01141066f, -0.03967301f, -0.05402000f, 0.01181580f, 0.03174894f, 
    -0.00860627f, -0.06232613f, -0.04047512f, -0.00327493f, -0.04439020f, -0.06696028f, 0.01360412f, -0.00638500f, 
    -0.00127814f, -0.01998541f, 0.03064038f, -0.01878464f, -0.03499821f, -0.01074312f, -0.05389211f, -0.00132091f, 
    0.01785594f, 0.01025585f, 0.01236555f, -0.02209641f, 0.02220041f, -0.00053065f, 0.04506267f, 0.05272639f, 
    -0.02034179f, -0.03464172f, 0.02072477f, -0.03463236f, 0.02355652f, -0.05708835f, 0.00902382f, 0.02540564f, 
    -0.05707276f, 0.00854280f, -0.00319291f, 0.02294426f, -0.06749850f, -0.01103629f, -0.05797989f, 0.02819031f, 
    -0.05262198f, 0.00030595f, -0.04414965f, -0.00740766f, -0.06030531f, -0.00688510f, -0.06839102f, 0.01014115f, 
    0.01747192f, 0.00472687f, -0.03120425f, -0.05708843f, 0.02178009f, -0.02612708f, -0.00433120f, 0.02981861f, 
    0.04378870f, 0.02765147f, 0.03626793f, -0.00270500f, 0.03745999f, -0.03663758f, 0.02255578f, -0.06369815f, 
    0.01743803f, 0.03915604f, 0.03599646f, -0.01456736f, 0.00163402f, 0.03634831f, 0.01724176f, -0.04713917f, 
    0.00438616f, 0.00123923f, -0.06539728f, -0.01494019f, 0.02571057f, 0.00832054f, 0.01517361f, 0.04348338f, 
    0.02065869f, 0.01311789f, -0.00640391f, 0.02029220f, 0.04324319f, 0.04438841f, -0.01565519f, -0.05025477f, 
    0.02044948f, -0.02008308f, 0.01966189f, 0.05130486f, 0.00332951f, 0.00567942f, -0.05004712f, 0.04852976f, 
    0.02302930f, -0.03121790f, -0.03489434f, -0.01336094f, -0.02280347f, 0.01388679f, -0.01262295f, -0.05334117f, 
    0.01403833f, -0.04202599f, -0.03731534f, 0.00281567f, -0.06312776f, 0.02183064f, -0.00355984f, -0.05642034f, 
    0.04077854f, -0.00475202f, -0.03838865f, -0.01955156f, 0.00930610f, 0.02841100f, -0.02353969f, 0.00474358f, 
    0.00379913f, -0.00242521f, -0.02047092f, -0.03723730f, 0.00563800f, -0.05871995f, 0.00522229f, -0.03481568f, 
    -0.02662518f, -0.02592296f, 0.00915785f, -0.06778797f, -0.02522792f, -0.03655658f, -0.02937571f, 0.01628604f, 
    -0.03588686f, -0.06578485f, -0.02337511f, -0.01759643f, 0.04635574f, 0.03271437f, -0.00442189f, -0.00309790f, 
    0.00226411f, 0.02833856f, -0.04640713f, -0.00076304f, 0.01365924f, -0.00203484f, -0.00245159f, -0.03190881f, 
    0.03684901f, -0.03966410f, -0.03906402f, -0.04571100f, 0.01268962f, -0.01312622f, -0.02168025f, -0.03631475f, 
    -0.00320925f, 0.02205949f, -0.05876384f, 0.00492554f, 0.02237136f, 0.03853895f, -0.00904996f, -0.02411775f, 
    0.04485578f, 0.01388314f, 0.02885784f, 0.03390946f, -0.03789175f, 0.03349110f, -0.02051104f, 0.01038775f, 
    -0.05202616f, 0.01216027f, 0.04383081f, -0.05826294f, 0.04888493f, -0.04087662f, 0.00830852f, 0.02884853f, 
    -0.05522675f, -0.05799863f, 0.02163634f, -0.04819655f, -0.04104874f, -0.05032810f, -0.02928703f, -0.02905762f, 
    0.03806491f, -0.05836889f, -0.03570459f, -0.05402409f, 0.02317483f, -0.04689934f, -0.06368227f, -0.02398512f, 
    -0.04029489f, 0.04880526f, -0.05081926f, 0.02795522f, 0.00149399f, 0.01171823f, 0.01468851f, 0.00994226f, 
    0.02739253f, -0.00240940f, -0.00675456f, 0.00392427f, 0.04255201f, -0.05503585f, -0.02562744f, 0.00354215f, 
    -0.06887673f, -0.06159601f, 0.04765202f, -0.00626651f, 0.00052565f, -0.01244104f, -0.03505304f, -0.01366464f, 
    0.02571190f, -0.06408495f, -0.00498788f, -0.04706370f, 0.03618776f, 0.04065526f, 0.04222789f, -0.04521730f, 
    0.04137024f, 0.01568387f, 0.02605597f, 0.03606587f, 0.03320859f, -0.01779721f, 0.03223164f, -0.01318647f, 
    -0.00652186f, -0.00175911f, 0.03144028f, -0.06643805f, -0.01438753f, 0.04366889f, 0.04186203f, -0.05995085f, 
    -0.00588225f, 0.04296612f, 0.03115118f, -0.02618182f, -0.00725650f, 0.01801575f, 0.00939553f, 0.02455892f, 
    -0.04483776f, 0.03240508f, 0.01967491f, -0.00081944f, -0.01153530f, -0.05007415f, -0.01649883f, 0.01627166f, 
    0.01585480f, 0.01071642f, 0.02956012f, 0.03004101f, -0.05897886f, 0.02491052f, -0.06361590f, 0.02512108f, 
    -0.06578764f, 0.04415204f, 0.00355700f, 0.00747115f, -0.05987436f, -0.04550791f, -0.00599945f, -0.06275342f, 
    -0.00997458f, -0.06847182f, -0.04320459f, 0.05186862f, -0.00926046f, 0.01903351f, -0.01733289f, -0.00880450f, 
    -0.03834711f, 0.04288193f, 0.00351282f, 0.03811767f, -0.01060268f, 0.04243051f, -0.00971523f, -0.01125448f, 
    0.01542042f, -0.03178272f, -0.01565491f, -0.03869651f, -0.06393041f, -0.02885351f, 0.02600970f, -0.00635668f, 
    -0.04596942f, 0.02109729f, -0.06012854f, 0.01657505f, -0.04569180f, 0.02074203f, -0.04656294f, -0.02334454f, 
    0.04177907f, 0.00501201f, 0.00990217f, 0.00495635f, -0.02450443f, -0.06535000f, 0.01787113f, 0.00748591f, 
    0.00366977f, -0.01668124f, -0.03027402f, 0.02116007f, 0.00689221f, -0.00841494f, -0.04767808f, -0.01831696f, 
    -0.05974999f, 0.01548646f, 0.00878051f, -0.05359621f, 0.03302931f, 0.02003901f, -0.04098207f, -0.04279028f, 
    -0.02527708f, -0.06063542f, 0.00332580f, 0.01169007f, -0.02220562f, -0.01206916f, -0.00321654f, -0.05226960f, 
    0.02418792f, -0.04095393f, -0.06501225f, -0.06821606f, -0.04924038f, -0.00773284f, -0.03214072f, 0.01664799f, 
    -0.02533285f, -0.03174213f, -0.06159449f, -0.01732048f, -0.01593743f, -0.00209654f, 0.04103316f, 0.02797213f, 
    0.04433146f, 0.02172479f, -0.01124997f, -0.04059158f, -0.02704475f, 0.01146603f, 0.01860533f, -0.04652698f, 
    -0.06360935f, -0.05467344f, -0.00759088f, -0.06679269f, 0.01587171f, 0.03079163f, -0.01807672f, 0.04839235f, 
    -0.02694609f, 0.04571152f, -0.02561525f, 0.04295566f, -0.00376592f, -0.00331999f, -0.03117160f, -0.03846951f, 
    -0.01488427f, -0.05870434f, -0.06543007f, 0.04127213f, -0.04235471f, -0.02644170f, -0.06136775f, 0.01159068f, 
    -0.04262006f, -0.04063823f, 0.01546304f, 0.00161776f, 0.02031037f, -0.03665703f, 0.03876664f, -0.06272589f, 
    0.01580704f, -0.03798655f, -0.01149824f, 0.02433311f, -0.06096131f, -0.01872616f, 0.03191809f, -0.01803431f, 
    -0.02241087f, -0.11025861f, -0.19324248f, -0.16122632f, -0.09991554f, -0.05422018f, 0.04885207f, -0.06995393f, 
    -0.18961324f, 0.08596265f, 0.17946319f, 0.09240704f, 0.11534056f, 0.10450584f, -0.35227475f, 0.18250558f, 
    0.18733341f, 0.06963295f, -0.66966534f, 0.15945455f, 0.13282965f, 0.39981553f, 0.18529120f, 0.01881336f, 
    0.13005780f, 0.02511391f, 0.02552614f, -0.26436761f, 0.15305841f, 0.02313846f, 0.11424251f, 0.07123248f, 
    -0.08502951f, -0.13629045f, -0.23228268f, 0.01894856f, 0.23772795f, -0.21737905f, 0.33480754f, 0.20576955f, 
    0.27269295f, -0.02729082f, -0.05650578f, -0.07166856f, -0.12717624f, 0.17884172f, -0.18956573f, -0.07666428f, 
    0.04265355f, 0.01570421f, 0.06164738f, 0.01952864f, 0.03970700f, 0.24146843f, 0.07337768f, 0.04217511f, 
    -0.17864433f, -0.04884972f, -0.06064983f, -0.03614239f, 0.17302433f, 0.02569061f, -0.03144325f, -0.72154164f, 
    0.22028358f, 0.14403951f, 0.23653091f, 0.03272544f, 0.13368212f, -0.09749022f, 0.01572895f, 0.00605141f, 
    -0.05815747f, -0.07682022f, -0.16379662f, -0.13105828f, 0.15847746f, -0.02324320f, -0.01058923f, -0.06812409f, 
    0.05348795f, -0.50944495f, 0.23115072f, -0.11649180f, 0.18164766f, -0.01418469f, -0.16318722f, 0.32184988f, 
    0.24360628f, -0.02139421f, -0.38136250f, -0.03184920f, -0.00779430f, -0.00125179f, -0.02351468f, 0.03534332f, 
    -0.00164041f, 0.01150014f, -0.22217624f, 0.07143295f, -0.08594157f, 0.12909368f, -0.56138152f, -0.23824504f, 
    0.06918186f, 0.11397112f, -0.23386809f, 0.15673828f, 0.11466305f, 0.03207838f, 0.24797505f, -0.19667433f, 
    -0.02212788f, 0.01116497f, 0.15901235f, -0.15299885f, -0.11598489f, 0.00582006f, -0.25780880f, -0.19181347f, 
    0.11285788f, -0.06097151f, -0.21620302f, -0.04946030f, 0.07898324f, 0.09577610f, -0.15016869f, -0.15291193f, 
    0.07308715f, 0.19320507f, 0.29286185f, 0.28713864f, -0.06760302f, 0.05702051f, 0.06916725f, -0.11576000f, 
    -0.11831495f, 0.29021323f, 0.26096910f, 0.07811993f, -0.08680006f, -0.03156669f, 0.35291681f, 0.16797857f, 
    -0.05911038f, -0.16152321f, 0.16598488f, -0.15523392f, 0.00155981f, -0.22557262f, -0.08376061f, -0.06446262f, 
    0.02651309f, -0.51278168f, 0.12795335f, 0.03562934f, 0.16555367f, 0.03555583f, 0.17095469f, 0.08670806f, 
    -0.05593483f, 0.08480083f, -0.33014154f, 0.13584514f, -0.24752602f, -0.12795311f, 0.05739224f, -0.00036342f, 
    -0.14594693f, -0.11948750f, -0.09293164f, -0.09769801f, -0.02092004f, 0.23288745f, 0.05848191f, 0.16174576f, 
    0.09418226f, -0.01197213f, 0.06805783f, 0.20646936f, -0.01702549f, 0.10221331f, 0.06983358f, -0.02491977f, 
    0.04839481f, 0.11653063f, 0.03425483f, -0.18203600f, 0.07411862f, 0.19268005f, 0.10984341f, -0.17934150f, 
    0.06504981f, -0.01022711f, 0.10137370f, 0.07462445f, -0.06445645f, 0.05612703f, 0.23555776f, -0.25443819f, 
    -0.02838644f, 0.22543317f, 0.23239110f, -0.06899010f, -0.24709626f, 0.38652518f, 0.18566136f, -0.09600558f, 
    -0.06531078f, -0.16189218f, -0.09777580f, -0.23859645f, 0.14223698f, -0.01051195f, 0.01187618f, 0.03205802f, 
    -0.07409437f, 0.21269989f, -0.08211085f, -0.32770008f, -0.13642733f, -0.04658485f, -0.10824772f, 0.01592748f, 
    0.01829294f, 0.09574375f, -0.04623758f, 0.23922466f, -0.02596567f, -0.32310027f, -0.08588839f, 0.10000351f, 
    -0.06357874f, 0.16873223f, -0.59208769f, 0.03239256f, 0.08942719f, 0.15082026f, -0.04379453f, 0.31627780f, 
    -0.04485731f, -0.23860252f, 0.00651355f, -0.13715757f, 0.07434059f, 0.19343933f, 0.06016667f, 0.35866213f, 
    0.03666155f, -0.20694524f, -0.04991247f, -0.15769076f, 0.23390000f, 0.03192303f, -0.21497098f, -0.15220043f, 
    -0.02075894f, 0.09554874f, 0.12063368f, 0.10963448f, 0.18151963f, -0.42467844f, 0.06210411f, 0.15713821f, 
    -0.01367703f, 0.05348157f, -0.08716738f, 0.18662639f, -0.33661044f, 0.19758485f, 0.32666501f, -0.14418885f, 
    0.13860945f, 0.01192550f, 0.09266705f, -0.13400228f, -0.05176536f, 0.31553480f, 0.28625163f, -0.89449638f, 
    -0.07759362f, 0.33416039f, 0.29629281f, 0.10949560f, 0.16264212f, 0.03673065f, 0.02096314f, 0.11351284f, 
    0.00852204f, 0.04813079f, -0.05826479f, -0.04542601f, 0.02419801f, 0.04222304f, -0.03575289f, -0.01152945f, 
    -0.02421619f, 0.03389452f, 0.04649687f, 0.03994944f, 0.00956157f, 0.01562913f, -0.01000453f, 0.00490833f, 
    0.04245216f, -0.00603939f, -0.05633511f, -0.00378018f, 0.02958629f, 0.01173097f, 0.02784345f, -0.03716770f, 
    -0.00121078f, -0.06492603f, 0.02520480f, -0.01867875f, -0.03854945f, 0.04449649f, -0.04037452f, 0.00113399f, 
    -0.01035578f, 0.01475462f, -0.06063493f, 0.01893478f, -0.01606533f, 0.00124983f, 0.03484846f, -0.00440239f, 
    0.01961004f, 0.02582482f, -0.02042153f, 0.04113859f, 0.00484794f, -0.00145855f, -0.04122040f, -0.05833630f, 
    0.01652060f, 0.00152561f, 0.04368990f, -0.00700554f, -0.02077326f, -0.02578905f, -0.06026354f, -0.01227668f, 
    -0.04910928f, 0.01837218f, -0.04491508f, 0.01857854f, 0.01194856f, -0.00371311f, -0.05849889f, -0.04669740f, 
    0.01521826f, 0.04924779f, -0.06305974f, -0.00115905f, -0.05687338f, 0.01338178f, -0.03501619f, -0.04290029f, 
    -0.06409508f, -0.01347917f, -0.04657780f, -0.06516402f, 0.03383088f, 0.04221239f, 0.02057481f, 0.03438349f, 
    0.01086195f, 0.02081642f, -0.01148470f, -0.06444376f, -0.01709624f, -0.04204833f, 0.01526249f, 0.00385024f, 
    -0.03484862f, 0.03811631f, 0.00071122f, 0.00723360f, 0.01353901f, 0.02509466f, -0.01204339f, -0.04171243f, 
    0.00581867f, 0.01264850f, 0.03870800f, 0.02114091f, 0.03014353f, 0.00246777f, -0.03195858f, -0.00131727f, 
    -0.02291007f, 0.01399940f, -0.03499791f, -0.05957200f, -0.05007341f, -0.03302192f, -0.00161501f, -0.03036533f, 
    0.04675487f, 0.04473545f, -0.04509826f, -0.05560194f, -0.01630280f, -0.02215251f, -0.04221250f, -0.01679141f, 
    -0.01520981f, 0.02165744f, -0.03231423f, 0.02215997f, 0.01947361f, -0.04764385f, 0.04634974f, 0.05151911f, 
    -0.03812667f, 0.04706615f, -0.02043601f, -0.03069388f, -0.05923669f, -0.05398946f, -0.05879129f, -0.02948837f, 
    -0.05235917f, -0.02620876f, -0.06339175f, -0.01665225f, -0.05102300f, -0.04504317f, 0.00606434f, 0.04786899f, 
    0.02531503f, -0.00028325f, -0.06455201f, 0.02516872f, 0.00210503f, -0.03408045f, -0.04175357f, -0.02139836f, 
    0.03110662f, 0.01635116f, -0.06184322f, 0.02995519f, 0.02004974f, 0.00394627f, -0.05086488f, 0.03627899f, 
    -0.05696048f, -0.01592761f, 0.04201172f, -0.05619805f, 0.03168397f, 0.04973711f, -0.05307820f, -0.02602096f, 
    -0.00755009f, 0.04289947f, -0.04512945f, -0.06084502f, 0.01135287f, -0.01136424f, -0.04004043f, -0.06310152f, 
    -0.00084412f, 0.01233593f, -0.01588782f, 0.03283837f, -0.00470711f, -0.00847272f, -0.00619922f, -0.05470928f, 
    -0.05359369f, 0.02384222f, 0.03993690f, -0.00898176f, -0.04950038f, 0.01058536f, -0.03781211f, 0.03375732f, 
    -0.05334928f, 0.02346770f, 0.01167840f, -0.04801448f, 0.00488691f, -0.04617732f, 0.00535248f, -0.06084470f, 
    0.00902561f, -0.03950927f, -0.06561019f, -0.05527230f, -0.06297672f, -0.01282056f, -0.05465876f, -0.00154961f, 
    0.03151225f, -0.04809150f, 0.00147323f, -0.00145021f, 0.02374205f, 0.01332252f, 0.03947307f, 0.00929913f, 
    0.02513988f, 0.00813444f, -0.03236963f, -0.04238903f, 0.00994490f, 0.04233296f, 0.04025932f, 0.01763058f, 
    -0.01279455f, -0.01701346f, -0.06812631f, 0.05279901f, -0.05688370f, -0.02465240f, -0.00459224f, -0.04283543f, 
    -0.05669411f, 0.01512543f, 0.03100623f, -0.03668692f, -0.00673581f, 0.04910307f, 0.02395490f, -0.03252007f, 
    -0.01791098f, 0.00603969f, -0.06099171f, 0.02680487f, 0.04466458f, 0.02818492f, 0.00830566f, 0.03675704f, 
    0.01013927f, 0.00775422f, -0.03119783f, -0.03528243f, -0.00365874f, -0.01264581f, -0.05600524f, -0.06378935f, 
    -0.04184510f, -0.00610816f, -0.05608399f, 0.04938691f, -0.00509621f, -0.01737383f, -0.02200527f, -0.04058720f, 
    -0.02535281f, -0.03087740f, -0.01132860f, -0.03325190f, 0.05294576f, -0.04947340f, -0.03743763f, 0.04541592f, 
    0.00833503f, 0.03810526f, -0.06281076f, -0.01257109f, -0.01925562f, 0.04061166f, -0.05051977f, 0.00624943f, 
    -0.03220749f, -0.00921105f, -0.04184891f, -0.01427147f, -0.05596697f, 0.04386404f, -0.04837064f, -0.02791732f, 
    -0.03511125f, 0.01140608f, -0.03018325f, -0.04373387f, 0.03977536f, -0.03383581f, 0.00556300f, -0.02332729f, 
    -0.05921873f, 0.02162456f, -0.06258387f, -0.05992737f, -0.01233965f, 0.00427168f, -0.02809940f, -0.05582622f, 
    0.01227153f, 0.00087154f, -0.05135027f, -0.01119322f, -0.00994991f, 0.01303372f, -0.03404390f, -0.03436424f, 
    -0.05604318f, 0.03044283f, 0.03290378f, -0.05947067f, -0.04794584f, -0.05456746f, -0.04031280f, 0.00842772f, 
    -0.05802593f, 0.04454594f, 0.00248712f, 0.00694617f, -0.03349411f, -0.01911616f, 0.01587636f, -0.05121061f, 
    -0.01927106f, 0.03080753f, 0.01644712f, -0.01540347f, 0.04637772f, 0.04801027f, 0.01227664f, -0.01274814f, 
    -0.02769133f, -0.01178340f, -0.00812879f, -0.03728342f, -0.04013519f, -0.05145163f, -0.06229688f, 0.00744863f, 
    -0.04096738f, 0.02725244f, 0.03987348f, -0.00767894f, 0.03208831f, 0.02661012f, 0.05184710f, 0.03630456f, 
    0.05119744f, -0.00352405f, -0.00835353f, 0.03654828f, -0.06208978f, 0.01732630f, -0.01142978f, -0.00644216f, 
    0.04756629f, 0.04475272f, -0.01153347f, -0.03504737f, 0.02877927f, -0.02639536f, -0.00033351f, 0.00264351f, 
    0.02893279f, 0.00320198f, 0.00939702f, -0.04328600f, 0.02917697f, -0.00546526f, -0.04261403f, 0.02256543f, 
    0.02439539f, 0.01128808f, 0.03062205f, -0.00830734f, -0.02650176f, -0.05711702f, -0.04227638f, -0.04447800f, 
    0.04347231f, -0.00006374f, -0.01206678f, -0.03968458f, 0.03698736f, 0.01571227f, 0.03459240f, -0.01131326f, 
    -0.02849722f, 0.03307497f, -0.00494224f, -0.00655741f, 0.05135224f, -0.02558900f, -0.03895883f, 0.02535005f, 
    -0.04474949f, 0.01578371f, -0.04617796f, -0.04569463f, -0.02897383f, -0.02809775f, -0.05872232f, -0.03447039f, 
    0.01612212f, -0.05060931f, -0.06308668f, 0.02106950f, 0.04428695f, -0.00946116f, -0.05191007f, 0.03566615f, 
    0.03926415f, 0.04230014f, -0.04288146f, 0.04382996f, 0.05023876f, -0.02822090f, 0.03520647f, -0.02677863f, 
    0.02943664f, -0.02860056f, 0.01109478f, 0.03573957f, -0.03555156f, -0.00151869f, 0.04052290f, 0.00162171f, 
    0.01607155f, -0.04232631f, -0.00026426f, 0.00305413f, -0.03474357f, -0.03791795f, 0.04360179f, 0.03123731f, 
    -0.03713231f, -0.06150753f, 0.00986885f, -0.03518885f, -0.01362830f, -0.03673472f, 0.05001758f, 0.03791764f, 
    0.03144535f, -0.01414333f, -0.01539512f, -0.00633758f, 0.05024064f, -0.03622464f, 0.05386880f, -0.00677381f, 
    -0.04972147f, -0.01692199f, -0.06268156f, -0.01097552f, 0.02524945f, 0.02166118f, -0.03988641f, -0.02805975f, 
    -0.05992209f, -0.02753778f, -0.02894591f, -0.03306831f, 0.00431825f, 0.00011793f, 0.01562031f, 0.00981276f, 
    -0.00698931f, 0.00884712f, -0.04649785f, -0.03915406f, 0.04111291f, 0.03605279f, 0.03306945f, -0.02728445f, 
    0.01570417f, -0.03904916f, -0.06511253f, -0.00922247f, -0.04524174f, -0.04101354f, -0.06075927f, 0.01325945f, 
    0.03251381f, -0.02597206f, -0.06296250f, -0.05639451f, 0.01454446f, 0.00874542f, -0.03601249f, -0.02852342f, 
    0.02596898f, 0.02360555f, -0.05953258f, -0.03672648f, -0.03208590f, -0.00623903f, 0.02426489f, 0.03437363f, 
    -0.02317970f, -0.05389968f, -0.01306375f, 0.01229594f, -0.06480227f, -0.02201226f, -0.00378838f, -0.00183856f, 
    0.04018335f, -0.02263283f, 0.02055266f, -0.04685237f, 0.01619717f, 0.01933222f, 0.01714626f, 0.00933484f, 
    0.01000929f, 0.00688990f, -0.02194114f, -0.03232447f, -0.00277366f, 0.05170785f, -0.04085428f, -0.02834715f, 
    0.00975337f, -0.03236806f, -0.05873155f, -0.03359999f, -0.06456251f, -0.02643055f, -0.03757748f, -0.01997963f, 
    0.04126707f, -0.04372878f, 0.02592416f, 0.02249198f, 0.04750050f, -0.02452856f, 0.03261023f, -0.00865913f, 
    -0.04429670f, -0.01838023f, 0.01198708f, 0.02364825f, -0.06114598f, -0.04189966f, -0.06134028f, -0.01113988f, 
    0.01464286f, -0.03008089f, -0.04425522f, -0.03292482f, -0.05054841f, -0.03319814f, -0.04183525f, -0.02619432f, 
    -0.00350642f, 0.04817488f, -0.00211670f, -0.02690431f, 0.00895722f, -0.00592740f, -0.05331534f, -0.01327301f, 
    -0.04295043f, -0.01689824f, -0.02888713f, -0.02587379f, 0.04402161f, -0.01362244f, 0.02007907f, 0.00590131f, 
    0.18234704f, -0.12594941f, -0.26101640f, -0.36110616f, -0.31245789f, 0.03241955f, 0.13016354f, -0.06377821f, 
    0.08773061f, -0.00668303f, 0.03970891f, -0.48653316f, 0.12028117f, 0.13963298f, 0.22962528f, 0.04325451f, 
    0.15061095f, 0.17008051f, 0.15556315f, 0.03981151f, 0.11232678f, -0.08810603f, -0.08190954f, -0.19362357f, 
    0.07016594f, 0.05274682f, 0.07733678f, -0.04657523f, -0.36216134f, 0.42059216f, 0.18588887f, 0.11735400f, 
    -0.12379806f, -0.01375290f, -0.07447222f, 0.09903527f, 0.19023603f, 0.17007482f, 0.34769404f, -0.18123546f, 
    0.16966470f, 0.05033281f, -0.17543615f, -0.02932565f, 0.21144082f, 0.44633040f, 0.05885318f, -0.23258983f, 
    0.12835440f, -0.00460574f, -0.05920851f, 0.00903195f, -0.31597438f, -0.03008519f, 0.02937641f, -0.11402845f, 
    0.05673329f, -0.12043311f, 0.05672575f, -0.15694585f, 0.18444560f, -0.04088173f, -0.10108978f, -0.09505450f, 
    0.13438059f, 0.18801099f, 0.33055377f, 0.02013561f, -0.05636951f, -0.26803747f, 0.04001701f, 0.00671395f, 
    0.17423068f, -0.02928983f, 0.21279719f, -0.17500529f, 0.05280265f, -0.28980550f, -0.16008946f, 0.25112793f, 
    -0.02375218f, -0.19718505f, 0.03907862f, 0.04780727f, 0.02496053f, 0.28406680f, 0.12763512f, -0.05805611f, 
    -0.10379088f, -0.11035401f, 0.08544602f, 0.23052911f, -0.11712856f, 0.05361247f, -0.01985877f, 0.00970648f, 
    -0.16416696f, -0.06965206f, -0.20607272f, 0.34091640f, -0.01824278f, 0.15838766f, -0.19481853f, -0.04944816f, 
    0.11756364f, 0.02765044f, 0.07738253f, 0.08111410f, 0.32625580f, 0.03664031f, -0.29233572f, -0.01268510f, 
    -0.06489522f, 0.14134260f, -0.09038798f, 0.06364244f, 0.01448551f, 0.03261014f, 0.00241853f, -0.19978824f, 
    -0.01755472f, -0.33892307f, -0.02167291f, 0.06994408f, -0.10768961f, -0.06890360f, -0.19231211f, 0.03879863f, 
    0.32192817f, 0.15816566f, 0.22845218f, 0.05137131f, -0.20214486f, 0.03137749f, 0.14131790f, 0.21343568f, 
    0.04339553f, 0.41332677f, 0.13251254f, 0.04788447f, 0.16912539f, -0.16803506f, 0.05515181f, 0.35811320f, 
    -0.04912101f, -0.32458952f, -0.77256131f, -0.00624217f, 0.03517953f, -0.01008365f, 0.10959261f, -0.17267306f, 
    -0.19657640f, 0.05381654f, 0.06286376f, -0.12937808f, 0.03850320f, 0.05618339f, 0.18095584f, 0.07919937f, 
    0.10724809f, -0.03581704f, -0.12302876f, -0.03209161f, 0.38750035f, 0.02559917f, -0.37103513f, -0.12435574f, 
    0.09022273f, -0.22921276f, -0.10761302f, -0.08570472f, -0.23288044f, 0.15109210f, -0.05027226f, 0.04184631f, 
    0.09231891f, 0.01605146f, 0.05902594f, 0.06425688f, -0.09729650f, -0.02153113f, 0.06969395f, 0.12772068f, 
    0.00548855f, 0.18626061f, 0.00566726f, -0.09599350f, -0.20624208f, 0.04094651f, -0.08704647f, 0.32390523f, 
    0.12732501f, 0.15273349f, 0.06621373f, -0.05955435f, -0.02497845f, 0.06993287f, 0.29641685f, 0.05044254f, 
    0.40434214f, 0.10349024f, 0.19973846f, 0.22594179f, -0.30936694f, -0.26749182f, 0.30531237f, -0.07086266f, 
    0.04167220f, -0.02343172f, -0.12360425f, 0.18592581f, 0.21586713f, 0.34836459f, -0.36373851f, -0.40817073f, 
    0.11826939f, 0.09989878f, -0.07920910f, -0.20006682f, 0.03750249f, -0.34673437f, 0.25531507f, 0.25789714f, 
    -0.11026021f, 0.55290431f, 0.13606474f, -0.00730253f, -0.00928599f, 0.02813708f, -0.14022778f, -0.07405729f, 
    0.16913623f, 0.05004033f, -0.15988450f, 0.06040395f, -0.15566948f, 0.04210841f, -0.04031994f, -0.01800155f, 
    -0.13520488f, 0.20757101f, -0.17794250f, -0.11074746f, 0.09829541f, -0.12652345f, 0.22853823f, 0.17978400f, 
    0.08877256f, -0.02209052f, 0.02804242f, -0.09192162f, -0.25130090f, -0.26064974f, -0.28267294f, 0.12409011f, 
    0.00081484f, -0.05215398f, -0.16719568f, 0.05205694f, -0.42520106f, 0.30318606f, 0.22942553f, 0.11447293f, 
    0.25212291f, -0.04762750f, -0.31513345f, -0.22948658f, 0.13220458f, 0.02985880f, -0.27289581f, 0.02327426f, 
    -0.07132890f, -0.05351562f, -0.02445048f, -0.08075937f, 0.23549320f, -0.04614267f, -0.07645689f, 0.13027401f, 
    -0.02524642f, 0.34961596f, -0.01962491f, 0.04092590f, -0.10911792f, 0.21179903f, 0.00182494f, 0.10629366f, 
    0.62531620f, 0.18500023f, -0.10252357f, -0.08356310f, -0.04040165f, -0.03368068f, -0.08511934f, 0.01136843f, 
    0.10360169f, 0.08813931f, -0.01417794f, -0.00328805f, -0.20618604f, -0.09046295f, -0.02177640f, 0.14547898f, 
    -0.03959987f, -0.00692346f, -0.02030364f, -0.13816161f, 0.29920435f, 0.12357651f, -0.05888988f, 0.00797064f, 
    0.13008571f, 0.02658194f, 0.08193142f, 0.53886491f, -0.02659694f, 0.24659884f, -0.10211642f, 0.12435450f, 
    -0.05728545f, 0.12622094f, 0.03437553f, 0.09991481f, -0.12011282f, -0.63862997f, -0.16542870f, 0.08869246f, 
    0.07247777f, -0.23380463f, 0.19876829f, -0.03698420f, -0.05391100f, 0.10495371f, 0.22979629f, 0.17749934f, 
    0.09208015f, 0.19558750f, 0.02017368f, -0.02961551f, 0.10478992f, -0.14566396f, -0.17937663f, 0.29201421f, 
    -0.57224733f, -0.09917904f, 0.04083851f, -0.24142019f, -0.12205637f, 0.10023239f, 0.00144576f, 0.13482617f, 
    0.20007181f, 0.07759655f, -0.05986438f, 0.28566298f, -0.06211595f, 0.02585381f, -0.04677103f, -0.06403207f, 
    0.27131087f, 0.00130162f, 0.21028171f, -0.11586377f, -0.07585786f, -0.06268527f, -0.19252247f, 0.04937475f, 
    0.11477671f, 0.12590304f, -0.05953323f, -0.03927477f, -0.14575569f, -0.23594680f, 0.10094015f, 0.05842197f, 
    0.08853622f, -0.12172233f, -0.05811083f, -0.00632493f, 0.08544081f, -0.07907876f, 0.10762525f, 0.07131466f, 
    -0.17490956f, -0.13173431f, -0.01472777f, 0.24729455f, 0.17134118f, 0.08235250f, -0.25048822f, 0.04766071f, 
    -0.09135345f, 0.02185902f, 0.19865528f, -0.20454586f, -0.05820066f, 0.10695710f, -0.12701897f, -0.25345060f, 
    0.11470693f, -0.09801873f, -0.15038686f, 0.05276849f, 0.21471313f, 0.15665412f, -0.43491477f, 0.11357875f, 
    0.04664816f, -0.06544388f, -0.05110255f, 0.08570155f, -0.05305578f, -0.10970633f, 0.07409708f, -0.20232394f, 
    -0.01082424f, 0.13608606f, -0.04952174f, 0.10952513f, 0.08157813f, -0.04400963f, 0.06350013f, -0.03870141f, 
    0.21299915f, 0.26640430f, 0.11357731f, -0.07676233f, -0.05394568f, 0.14009279f, -0.04374191f, 0.01372955f, 
    -0.20715173f, 0.25046054f, -0.10291827f, -0.06585355f, -0.04429167f, 0.03183186f, -0.05860105f, -0.05642228f, 
    -0.00973307f, 0.06954814f, 0.00330456f, -0.11838496f, -0.15465449f, 0.11505639f, -0.12586284f, 0.14343058f, 
    0.09419908f, -0.11933485f, -0.08443172f, 0.19976620f, -0.23119862f, -0.23081705f, 0.25047612f, -0.02032215f, 
    -0.19784130f, -0.09835594f, -0.16228496f, -0.25759950f, 0.17691667f, -0.13828272f, -0.11358478f, -0.00580561f, 
    -0.14121522f, 0.15990263f, -0.04010471f, 0.06693777f, 0.34113467f, 0.17197919f, 0.28983814f, -0.01074610f, 
    0.07354223f, -0.29254857f, -0.06152259f, -0.11190873f, -0.06968109f, 0.13525413f, 0.23490366f, 0.25451729f, 
    0.06578410f, -0.04717165f, -0.09595587f, 0.03893468f, 0.02652413f, 0.25332299f, -0.02652958f, 0.10883510f, 
    0.07915442f, 0.10815965f, 0.13012040f, 0.07717925f, -0.01126937f, 0.04335861f, -0.01898831f, 0.17254832f, 
    0.08407283f, 0.17002465f, -0.10864573f, 0.12574033f, -0.18448125f, 0.00452016f, 0.02145783f, 0.16116515f, 
    -0.00487555f, 0.12976174f, -0.23649152f, 0.02480239f, -0.17137568f, -0.16499214f, 0.06759746f, -0.05247481f, 
    0.10881088f, 0.35024384f, 0.32554662f, -0.07247925f, -0.07520472f, -0.06842875f, -0.29195508f, -0.14675991f, 
    -0.07410220f, -0.08095639f, 0.12154879f, -0.12631029f, 0.18914193f, 0.25894096f, 0.24284782f, 0.00508793f, 
    0.11295595f, -0.13745368f, -0.10870360f, 0.11681487f, 0.08096752f, 0.03757976f, -0.16781974f, 0.15294188f, 
    -0.02163491f, -0.11098853f, 0.10004947f, -0.19530298f, -0.22674029f, -0.08904722f, 0.06589213f, -0.27907580f, 
    -0.11032337f, 0.08168373f, 0.15837073f, -0.07520774f, -0.09989902f, -0.12274534f, 0.17545760f, 0.01565790f, 
    -0.03164045f, -0.20773248f, 0.08237835f, 0.12292743f, -0.17099625f, 0.06708381f, -0.38207313f, -0.24852981f, 
    -0.21289690f, -0.04192339f, -0.03115409f, -0.11465024f, -0.03334184f, -0.00192052f, -0.27962404f, -0.42659312f, 
    -0.16821070f, 0.22189364f, 0.07865963f, 0.13761520f, 0.06467569f, 0.05679424f, -0.07097747f, 0.01486633f, 
    0.32067573f, -0.03890828f, 0.31158826f, -0.10839383f, 0.16741440f, -0.06109584f, 0.12431700f, -0.03223868f, 
    -0.12636605f, -0.36363155f, 0.10860049f, 0.10791063f, 0.11939465f, -0.07244334f, 0.19531424f, 0.02032054f, 
    0.14529158f, -0.25723815f, -0.23293589f, -0.06156328f, -0.15430015f, -0.07982375f, -0.08080296f, 0.07334817f, 
    -0.20938146f, -0.04403357f, -0.00615842f, 0.36543068f, 0.11817005f, -0.01598248f, -0.06836393f, -0.14700636f, 
    -0.18702826f, -0.09593294f, 0.13026211f, -0.09309144f, 0.29366207f, 0.02881165f, -0.11152858f, -0.50970954f, 
    0.02918239f, -0.00726333f, 0.20309424f, -0.02441041f, 0.06410453f, -0.51649851f, -0.56752914f, -0.15352082f, 
    0.21440600f, -0.11771990f, 0.12624699f, 0.18993330f, 0.03136919f, -0.28451529f, 0.24491973f, 0.08125782f, 
    0.19225404f, 0.08801916f, 0.03369385f, -0.29736030f, 0.07596332f, 0.06612493f, 0.08157156f, 0.25147012f, 
    -0.04096488f, -0.02001019f, 0.01686522f, 0.04743832f, -0.15781149f, -0.20909604f, 0.07472125f, 0.20605364f, 
    0.34228471f, -0.21296345f, 0.11918310f, -0.04790190f, 0.03637870f, 0.26887184f, -0.15088353f, 0.16292715f, 
    0.03119602f, 0.01997538f, 0.04204838f, -0.13020006f, -0.07772466f, -0.29712915f, 0.12228332f, -0.13523324f, 
    -0.06897530f, 0.34579492f, 0.07750373f, -0.00775929f, 0.07650366f, 0.19930102f, 0.08279197f, -0.12109137f, 
    0.17648041f, 0.12521677f, 0.12369926f, 0.22508824f, -0.03093945f, -0.09214860f, -0.11754628f, 0.37231395f, 
    0.30137652f, 0.04740215f, -0.08277056f, 0.13696748f, -0.17501111f, 0.38531321f, 0.23335800f, 0.13990115f, 
    0.25402668f, -0.12018920f, -0.02355243f, -0.02963938f, 0.01718500f, 0.55192518f, -0.10599138f, -0.17161554f, 
    0.14333323f, -0.04041848f, 0.01460754f, 0.06305361f, -0.06677208f, 0.03405083f, 0.34897041f, -0.02554808f, 
    -0.03172823f, -0.15686233f, 0.00816830f, 0.10185603f, 0.27795532f, -0.04305749f, 0.01825401f, 0.06699534f, 
    -0.05761766f, -0.00059781f, 0.04041148f, -0.15039629f, -0.06762239f, -0.18107437f, -0.04163577f, 0.07294228f, 
    -0.05158051f, 0.49564537f, 0.31310108f, 0.19765279f, 0.24777196f, -0.23097861f, -0.15131603f, 0.13163571f, 
    -0.05452820f, -0.46011114f, 0.09486779f, -0.10728487f, 0.11620955f, 0.00867337f, 0.12193866f, 0.09236548f, 
    -0.01076832f, -0.11135760f, -0.43453670f, 0.00469428f, -0.12919040f, 0.19659472f, -0.01322443f, -0.14018831f, 
    -0.23659725f, -0.10175774f, 0.00176947f, 0.43135199f, 0.08993928f, -0.07828319f, 0.04659126f, 0.14016463f, 
    -0.04816310f, 0.06024307f, -0.10334827f, 0.26272264f, 0.38347748f, -0.51883984f, -0.15470673f, 0.10494503f, 
    -0.08478288f, 0.10768335f, -0.17055081f, -0.30782118f, 0.03382842f, 0.18312037f, -0.20794034f, -0.39393985f, 
    -0.31129813f, -0.17706975f, -0.10943545f, 0.05864346f, 0.08471568f, -0.00185611f, -0.30925238f, -0.29946989f, 
    -0.20580375f, -0.15558234f, -0.11055954f, 0.15051749f, -0.11984629f, -0.02862756f, -0.05913173f, 0.07935008f, 
    0.10861330f, -0.02611127f, -0.03255307f, 0.09502050f, 0.00283363f, -0.03685198f, 0.22761932f, -0.06826726f, 
    0.18478711f, 0.38864449f, -0.03994076f, 0.52098632f, 0.05004456f, -0.12820379f, -0.13335897f, 0.20908284f, 
    0.22660632f, -0.01150027f, -0.13846554f, 0.17168041f, 0.08659732f, -0.01330601f, -0.33104676f, -0.01412311f, 
    -0.01745789f, 0.14982435f, 0.38019699f, -0.04651845f, -0.03698400f, -0.11080348f, -0.05339401f, -0.17678085f, 
    -0.09135544f, 0.28056672f, 0.12095363f, -0.36422521f, 0.14404580f, 0.16388153f, 0.19264959f, 0.13825008f, 
    0.11037549f, -0.23516296f, 0.04034253f, -0.00167433f, -0.04587704f, -0.08995320f, -0.16853300f, -0.15505196f, 
    0.02693006f, 0.13661426f, -0.12121630f, 0.14670110f, 0.19528602f, 0.34272435f, -0.18977661f, -0.27672595f, 
    0.15282896f, -0.19400774f, 0.03227694f, -0.18710595f, -0.01102522f, -0.03911567f, 0.11320329f, 0.20013340f, 
    -0.01615920f, 0.02788867f, 0.04429362f, -0.15269217f, -0.09799806f, -0.00157035f, 0.21660542f, 0.01690483f, 
    0.13347703f, 0.04127617f, -0.12071395f, 0.09151081f, -0.17632738f, -0.17866494f, -0.20066151f, 0.09045505f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.02772629f, -0.03296719f, 0.00191380f, -0.00437597f, 0.22490476f, -0.09398791f, -0.00114861f, 0.03186080f, 
    0.01043910f, -0.05518365f, 0.06078741f, 0.05254438f, -0.07142366f, 0.10548556f, 0.18574412f, 0.15419389f, 
    -0.03979516f, 0.04395322f, -0.01753230f, -0.03439851f, 0.03463842f, -0.09201507f, -0.03438886f, 0.01683634f, 
    0.02435779f, 0.00532732f, 0.11991251f, -0.05827141f, -0.06524583f, -0.02089857f, -0.29272616f, 0.08147271f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.19314356f, 0.16247571f, -0.06156901f, -0.36350447f, -0.19176824f, 1.08881772f, 0.07552206f, 0.06250838f, 
    -0.38179463f, -0.05713482f, -0.00300106f, -0.22406180f, -0.11481917f, 0.26842666f, 0.05562361f, 0.17458594f, 
    0.13066776f, 0.07564540f, 0.03264235f, -0.08898181f, -0.54216844f, -0.12028929f, -0.17244972f, 0.01511746f, 
    0.16266860f, 0.03128153f, 0.25631168f, -0.02193092f, 0.03807199f, -0.19596615f, 0.28759092f, -0.26881751f, 
    -0.21939634f, -0.11777627f, -0.08779779f, 0.39169213f, 0.45151830f, 0.16511568f, 0.11265635f, 0.01848513f, 
    0.57360351f, 0.08965917f, 0.39115554f, -0.13875280f, -0.18288796f, -0.35697249f, -0.12362166f, -0.11347900f, 
    0.15924403f, -0.05046999f, 0.11432619f, 0.05089299f, -0.19973832f, 0.51331866f, 0.68043441f, 0.15980937f, 
    0.04123762f, -0.01999454f, -0.28986895f, 0.14217055f, -0.15185514f, -0.28839618f, -0.33940411f, -0.31460279f, 
    0.18792009f, -0.05175453f, 0.11078522f, -0.35407132f, -0.51037031f, 0.05467735f, -0.19041803f, 0.14755458f, 
    -0.56196034f, -0.06626531f, 0.25078264f, 0.78324306f, -0.04278251f, -0.75304550f, -0.31088591f, 0.10288081f, 
    -0.10164600f, 0.11327137f, 0.14392778f, 0.00579791f, -0.70539206f, 0.65463197f, -0.29404703f, -0.16946670f, 
    0.04746171f, 0.07458182f, 0.06785787f, 0.02445958f, -0.06722569f, -0.18562081f, 0.42625460f, 0.35130537f, 
    -0.36836362f, 0.00241175f, 0.08963628f, 0.15677346f, -0.40256563f, -0.07364587f, 0.17284238f, 0.14657176f, 
    -0.34572461f, 0.02910011f, -0.02091161f, -0.65766412f, 0.03180782f, 0.84887600f, -0.12181237f, -0.08265616f, 
    -0.02922508f, -0.03921244f, 0.16888691f, 0.10778231f, 0.31662953f, 0.74727142f, -0.19447243f, 0.13608091f, 
    -0.07628597f, -0.02512913f, -0.64582098f, 0.08810320f, -0.09810074f, 0.17515649f, -0.63287580f, 0.28935882f, 
    -0.20150946f, 0.11758685f, 0.11337665f, -0.45162135f, -0.33911830f, -0.43772474f, 0.10081995f, 0.03556253f, 
    -0.68839377f, 0.04283115f, -0.23013103f, 0.04002083f, -0.03896469f, 0.09053686f, 0.41972938f, -0.06708555f, 
    -0.01345619f, -0.15464301f, -0.03634630f, 0.06783099f, -0.12546244f, -0.08326942f, 0.59871614f, -0.08098175f, 
    0.01920828f, 0.16230582f, 0.48742637f, 0.15815158f, 0.11877224f, 0.30614284f, -0.37382361f, 0.20851512f, 
    -0.39089265f, -0.08690488f, -0.18039627f, 0.52037406f, 0.61068845f, -0.05640996f, 0.09824125f, 0.06185385f, 
    -0.05167268f, 0.16407138f, -0.61360240f, 0.50473279f, 0.08886877f, -0.36911348f, 0.33511561f, 0.07681452f, 
    -0.07758185f, -0.09680479f, 0.14045732f, -0.04513871f, -0.62569857f, -0.33670038f, -0.62817109f, 0.14024973f, 
    0.14134391f, -0.07860436f, 0.55078739f, 0.07483276f, -0.17642348f, -0.12926984f, -0.50533658f, -0.50493789f, 
    0.75050533f, -0.12497870f, -0.14697914f, -0.08660576f, 0.27355757f, -0.10120359f, 0.11764787f, 0.11768334f, 
    -0.17276566f, 0.02131051f, -0.98078465f, -0.51352477f, -0.09950189f, -0.07022805f, 0.23647669f, -0.54563200f, 
    -0.03759718f, -0.15514450f, -0.02460774f, 0.07817564f, -0.21595770f, 0.02120674f, -0.13975012f, -0.02992179f, 
    -0.01882309f, -0.13228299f, -0.04873289f, -0.04896433f, 0.11601824f, -0.24018385f, 0.00161944f, 0.49995011f, 
    -0.60206842f, 0.04590420f, -0.05379114f, 0.13975562f, -0.15767212f, -0.24248657f, 0.02856310f, -0.14560033f, 
    -0.04936285f, 0.16654746f, -0.05394364f, -0.04833994f, -0.13771309f, 0.22795109f, -0.40526381f, 0.20391971f, 
    -0.15098794f, 0.15403394f, -0.05436886f, -0.12337957f, 0.24427436f, -0.17889485f, 0.19119988f, 0.00084652f, 
    -0.03493802f, -0.10377528f, -0.02264725f, -0.09964990f, -0.00582927f, 0.30169567f, 0.98090345f, -0.64039475f, 
    -0.21002068f, 0.09397668f, 0.03154926f, 0.02951935f, -0.37123576f, 0.04235250f, -0.14048827f, -0.03291307f, 
    0.41761568f, -0.12689915f, 0.79032832f, -0.02536715f, 0.01084276f, -0.60125577f, 0.22450957f, -0.39457053f, 
    -0.03793536f, -0.17558375f, -0.12518637f, -0.17702118f, 0.82113808f, -0.37526244f, 0.36160123f, -0.09090931f, 
    -0.05249106f, -0.03682975f, 0.03791345f, -0.10828499f, 0.02270584f, -0.39382750f, 0.19521534f, -0.29689950f, 
    0.39894950f, 0.16415325f, -0.08694201f, -0.06459627f, 0.39659956f, -0.39215511f, 0.00472825f, 0.10524625f, 
    -0.40770561f, -0.03439575f, 0.42260247f, -0.20536482f, 0.05908197f, -0.23701085f, -0.48346123f, -0.31566504f, 
    0.05815585f, -0.02468885f, 0.05597649f, -0.15211229f, -0.16813348f, -0.83382934f, -0.27297646f, 0.02679851f, 
    -0.13196295f, 0.00119473f, 0.56149310f, 0.13679075f, -0.12437896f, 0.46288881f, 0.22129372f, 0.15397076f, 
    -0.53733176f, -0.01483578f, -0.11137113f, 0.09320327f, -0.52109849f, -0.69220233f, 0.07073297f, 0.02040105f, 
    0.16934891f, -0.02457162f, -0.17903462f, 0.00386219f, -0.12901504f, 0.00499135f, 0.20835589f, 0.83024830f, 
    0.08676902f, -0.08510246f, 0.02475132f, 0.08886056f, 0.59814149f, -0.12562738f, -0.51842165f, 0.05835806f, 
    0.12805499f, 0.09142765f, -0.56570286f, 0.08904818f, -0.04735338f, -0.45902890f, -0.27763864f, 0.30872938f, 
    0.28596765f, -0.11472029f, -0.08169299f, -0.01452049f, -0.43039003f, -0.44629347f, -0.16343655f, -0.07512618f, 
    0.91119635f, -0.10382456f, -0.17245410f, 0.12257107f, -0.08619728f, -0.28838620f, -0.00799879f, 0.19645754f, 
    0.07242356f, -0.16607198f, 0.06715763f, 0.08803736f, -0.14510001f, 0.07494380f, -0.69237393f, -0.09714541f, 
    0.02678906f, -0.07492582f, -0.70622677f, 0.00442856f, -0.05408376f, 0.54293507f, -0.22727969f, -0.04313481f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.03977130f, 0.06231344f, -0.30013633f, 0.02851503f, 0.22776981f, 0.10872716f, -0.17525351f, -0.61182195f, 
    -0.16140449f, 0.06516130f, 0.25807059f, 0.04118495f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
