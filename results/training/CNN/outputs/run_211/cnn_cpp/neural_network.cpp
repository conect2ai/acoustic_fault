#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.34048152f, -0.22909209f, 0.52036345f, -0.43031552f, 0.17940708f, 0.33178428f, 0.08909927f, 0.25232106f, 
    0.31048542f, -0.20369571f, 0.15748042f, -0.17757651f, -0.22903740f, -0.20551996f, 0.21844551f, 0.22108667f, 
    0.51441067f, 0.32248348f, -0.11607189f, 0.22489415f, -0.48204282f, -0.15583991f, 0.14731829f, -0.03391302f, 
    -0.05126616f, -0.43399721f, -0.20797005f, 0.02045898f, -0.50460881f, -0.42563358f, 0.06746162f, -0.69831157f, 
    -0.19389997f, -0.39070114f, -0.27008989f, -0.16002691f, 0.16859667f, 0.22894295f, 0.23038945f, -0.25825322f, 
    0.04113686f, 0.07492431f, -0.25558677f, -0.07655502f, 0.22587639f, 0.03714842f, 0.08922509f, -0.00124833f, 
    0.21785997f, -0.23674470f, 0.43011683f, 0.03639023f, 0.29360846f, 0.52366263f, 0.48872504f, -0.30126742f, 
    -0.16781342f, 0.17638832f, 0.09094415f, 0.43000826f, -0.02263046f, -0.16660285f, -0.14874950f, 0.11809113f, 
    -0.20793895f, -0.40388057f, -0.30100238f, -0.12616065f, 0.04597087f, -0.25340080f, 0.23432839f, 0.11809562f, 
    0.01269412f, -0.43128988f, 0.17139420f, -0.38849273f, 0.16372460f, 0.19214366f, 0.42760274f, -0.30629468f, 
    -0.23732908f, 0.18237045f, 0.37914088f, 0.01913043f, -0.25472566f, -0.33581465f, 0.15451334f, -0.39624348f, 
    0.27373973f, -0.31073660f, -0.20869464f, 0.13015173f, -0.38305411f, -0.10114987f, -0.20555381f, -0.08588438f, 
    -0.09829462f, -0.27075258f, 0.09018877f, -0.43578666f, 0.58591485f, -0.04560076f, -0.58395112f, -0.59057415f, 
    -0.58928311f, 0.31994268f, 0.50314999f, 0.16858956f, 0.04045289f, 0.03808916f, -0.14981459f, 0.29575562f, 
    -0.06471088f, 0.10682323f, 0.08197933f, -0.29531640f, -0.01549069f, 0.04589549f, 0.06695551f, 0.07398634f, 
    -0.13937216f, 0.04926648f, -0.05752889f, -0.08895466f, -0.12848787f, -0.14520441f, 0.35898373f, 0.08378657f, 
    -0.46729162f, -0.33251336f, -0.35092366f, 0.21245907f, 0.21717976f, -0.32851768f, 0.02183867f, 0.38116091f, 
    0.34435555f, 0.20526160f, -0.29907975f, -0.12731819f, 0.07677429f, 0.13907748f, 0.15585858f, 0.22577059f, 
    -0.02163553f, -0.03894841f, -0.03737578f, 0.13372800f, -0.31436822f, 0.25906473f, -0.06524887f, -0.50784755f, 
    -0.53557587f, -0.07868068f, 0.13892187f, -0.60996991f, -0.59467238f, -0.05759249f, -0.10229636f, 0.04216031f, 
    0.16175552f, 0.17846566f, 0.05483037f, 0.17910737f, -0.10856099f, 0.04730919f, 0.03343383f, -0.21327814f, 
    0.25086591f, -0.12443175f, -0.08924514f, 0.19085801f, 0.29480946f, -0.13290621f, 0.41468257f, -0.64398289f, 
    -0.06715566f, 0.15426001f, -0.18311766f, -0.10311066f, 0.37353501f, 0.51291931f, -0.20497665f, 0.21143739f, 
    -0.39906806f, -0.07004196f, -0.35730386f, 0.22509664f, -0.15322913f, 0.01168124f, 0.15743342f, -0.29162043f, 
    -0.18292677f, -0.16963370f, -0.11643307f, 0.02374029f, -0.00378056f, 0.31184900f, 0.41702476f, -0.01889739f, 
    0.42024785f, 0.35941187f, 0.23337930f, 0.63940787f, 0.44197115f, 0.40795845f, 0.41416621f, 0.53024566f, 
    0.17579055f, 0.16542731f, -0.30674008f, 0.21205071f, 0.15247773f, 0.05412776f, -0.00746130f, 0.03769806f, 
    0.03135506f, 0.32486546f, 0.08068818f, 0.14619721f, -0.00823276f, -0.27845648f, -0.22511731f, 0.03052832f, 
    0.09500638f, -0.06356400f, -0.36568961f, -0.36253303f, 0.98532301f, 0.44614652f, -0.15540986f, 0.22377773f, 
    -0.13555545f, 0.34369716f, 0.00221100f, 0.43181700f, 0.05337069f, -0.14242610f, -0.13849048f, -0.14739336f, 
    -0.15675406f, -0.04636057f, -0.12655541f, -0.31576529f, -0.04181148f, -0.04253276f, -0.08438095f, 0.05758993f, 
    0.15861894f, 0.05672888f, -0.26527444f, 0.47629875f, -0.40514544f, -0.25355947f, -0.19458152f, 0.21792054f, 
    -0.48032108f, -0.64846796f, -0.21407364f, -0.25115383f, -0.32579386f, 0.23527652f, -0.38478720f, 0.22327870f, 
    -0.24767414f, -0.39875621f, -0.03766171f, -0.22824493f, 0.14833179f, -0.15475258f, 0.19966380f, 0.05702862f, 
    0.30206773f, -0.04399085f, 0.04194518f, -0.07554869f, 0.43845740f, 0.24853720f, 0.37035263f, 0.36263216f, 
    0.08650226f, 0.36235109f, 0.40743202f, -0.20296662f, 0.14835784f, -0.57752985f, -0.31788436f, -0.06687483f, 
    0.09235746f, 0.05932903f, -0.11208083f, 0.09058464f, 0.20702192f, 0.29165632f, 0.04887949f, 0.03524928f, 
    -0.30234644f, -0.03369546f, 0.25309166f, 0.19187269f, -0.73509192f, 0.36702722f, 0.23196104f, -0.04034859f, 
    0.19006222f, -0.14695805f, -0.16478568f, -0.27882352f, 0.40599853f, -0.21757078f, 0.47026101f, -0.11088596f, 
    -0.17090932f, -0.19806513f, 0.09185713f, 0.04557608f, 0.18980032f, 0.27766448f, 0.10721630f, 0.15087526f, 
    -0.31844199f, 0.04310574f, -0.21547811f, 0.01074867f, 0.29249635f, 0.07420461f, 0.09951967f, -0.28765771f, 
    0.41295257f, -0.18812144f, 0.11804051f, -0.56399268f, -0.33432901f, -0.25785854f, -0.39428115f, -0.17740852f, 
    0.25560379f, -0.22442448f, -0.16505910f, 0.11515778f, 0.15433885f, -0.10246030f, -0.08864548f, -0.05011196f, 
    -0.07736597f, 0.20243646f, 0.15123281f, -0.21848395f, 0.21960337f, -0.09845585f, 0.83253425f, 0.51138866f, 
    0.44176903f, -0.41126147f, -0.44716114f, 0.04530535f, 0.17685196f, -0.29151279f, 0.18694901f, 0.35706323f, 
    0.43992302f, 0.18442293f, 0.01603502f, -0.07983238f, -0.05580004f, -0.12038574f, -0.08935492f, 0.28186715f, 
    0.20963860f, -0.04069992f, -0.15244968f, 0.03493297f, 0.02409728f, 0.04793198f, -0.11500417f, -0.21465650f, 
    -0.49680161f, -0.40348145f, -0.22203833f, -0.16881664f, -0.34426215f, -0.37906903f, -0.29071197f, 0.36735117f, 
    -0.08455209f, -0.48044679f, 0.04031060f, 0.25366130f, 0.07259338f, -0.30718943f, 0.00816580f, 0.17242250f, 
    0.17518702f, 0.20410533f, 0.11551755f, 0.28612873f, 0.02237752f, 0.15730441f, 0.12548064f, 0.12056662f, 
    -0.55118120f, 0.05306286f, -0.27731520f, -0.02679603f, 0.65644914f, -0.65043104f, 0.22335534f, 0.03386027f, 
    -0.49006304f, -0.37914386f, 0.33300984f, -0.03518087f, 0.09402201f, -0.13352039f, 0.18311290f, 0.17683573f, 
    0.05677395f, -0.25788042f, 0.15379573f, -0.19949587f, -0.09229725f, -0.11113465f, 0.02696854f, 0.14410384f, 
    -0.05614220f, -0.30380690f, -0.54177904f, -0.57203782f, -0.09057384f, -0.01214352f, 0.49610054f, -0.41928935f, 
    0.12344573f, 0.35925230f, 0.02810150f, 0.05926637f, -0.31228566f, -0.06662672f, -0.08657623f, -0.00744083f, 
    -0.23114738f, 0.16374843f, 0.00953989f, 0.17011668f, 0.28430307f, -0.20645140f, -0.11123337f, -0.00781637f, 
    -0.21602909f, -0.17024358f, 0.02816804f, 0.11964372f, -0.25776714f, 0.32002354f, 0.38108492f, 0.18788697f, 
    0.42885968f, 0.46079290f, -0.00405093f, -0.02136924f, 0.21705098f, -0.07812566f, -0.49584261f, -0.06480559f, 
    -0.42604628f, 0.25038213f, -0.17614393f, -0.20414279f, -0.05383382f, 0.08903660f, 0.09117040f, -0.17668065f, 
    0.35304305f, -0.30909172f, -0.27435869f, -0.97657937f, 0.25721169f, -0.24593171f, -0.18149114f, -0.42008561f, 
    0.36751872f, 0.82587612f, -0.47665974f, 0.29962128f, 0.50676310f, -0.15848248f, 0.11507081f, 0.12111932f, 
    -0.17845759f, 0.22030608f, -0.03427568f, 0.09446863f, 0.16148140f, 0.13306746f, -0.03484197f, 0.19925041f, 
    0.09204428f, 0.12175198f, -0.03326580f, 0.10547639f, -0.74339336f, -0.67241937f, -0.48023367f, -0.36459458f, 
    -0.16209912f, 0.41435203f, 0.15613134f, 0.17085847f, 0.20892082f, 0.45516336f, 0.44101030f, -0.08926190f, 
    0.08373143f, -0.16687346f, 0.22801208f, -0.18868536f, 0.04558031f, -0.20402932f, 0.19976656f, -0.34944680f, 
    -0.43409604f, -0.18906893f, 0.13208336f, 0.10175149f, 0.01808836f, 0.50992769f, 0.53633928f, 0.56089270f, 
    0.35318756f, 0.33006930f, -0.26708809f, -0.44796041f, -0.58744842f, -0.70249414f, -0.05713702f, -0.09947367f, 
    0.22638963f, 0.12481142f, 0.38664299f, -0.14874619f, 0.16149585f, 0.13044551f, 0.28247851f, 0.26410523f, 
    0.18665031f, 0.23640969f, -0.00513362f, -0.22016892f, 0.12145900f, 0.00598423f, -0.58861971f, -0.02624757f, 
    -0.15898190f, -0.40594131f, 0.35508710f, 0.55244422f, 0.29412273f, -0.46660164f, 0.32230097f, -0.17185591f, 
    0.02229773f, 0.13492200f, 0.11800357f, 0.19691876f, 0.23122068f, -0.12331759f, 0.00128971f, -0.12239101f, 
    -0.09457748f, -0.14144900f, 0.29639915f, 0.13760994f, 0.33854508f, 0.11695498f, -0.35778940f, 0.81771386f, 
    0.65324473f, 0.10364275f, 0.17667992f, 0.69691700f, -0.41133779f, -0.37155262f, -0.10627053f, -0.25198361f, 
    -0.42655584f, 0.20051934f, 0.18977620f, -0.17636499f, 0.07610551f, 0.05062597f, 0.18558985f, -0.14452669f, 
    0.01203229f, 0.04796549f, -0.02709049f, -0.26467603f, -0.07066928f, 0.01464130f, -0.01963915f, -0.06013326f, 
    -0.49940264f, -0.11783597f, -0.19338828f, -0.40697429f, 0.02121711f, 0.39767936f, 0.64002979f, -0.19422176f, 
    0.25619170f, 0.15749806f, 0.23825382f, -0.29745188f, -0.03667685f, -0.42441449f, -0.30421695f, -0.12434208f, 
    -0.16451132f, 0.20863712f, 0.11646554f, -0.38589159f, 0.18031263f, 0.19729252f, -0.28461733f, -0.03774979f, 
    0.05798536f, -0.07194875f, -0.29196480f, -0.08611317f, -0.36315081f, 0.50966275f, -0.31942993f, -0.57361656f, 
    -0.37106586f, 0.06136962f, -0.30994111f, -0.00109910f, 0.14494571f, 0.14250979f, 0.06153314f, 0.03992864f, 
    0.43856758f, 0.02417257f, 0.07263771f, -0.27028576f, -0.24456540f, -0.32176566f, -0.22738431f, 0.17402811f, 
    0.22051789f, 0.05408075f, -0.11416460f, -0.15463986f, -0.56154692f, -0.58187401f, 0.02429381f, 0.13275608f, 
    -0.15194833f, 0.20157090f, 0.32479057f, -0.15735504f, -0.37716383f, -0.22814932f, -0.40974241f, -0.34746954f, 
    -0.13404386f, 0.17692724f, 0.04014521f, -0.09236078f, -0.00915068f, 0.10759245f, -0.09640068f, 0.24458800f, 
    -0.24365886f, 0.00582062f, -0.19289546f, -0.35901406f, -0.33670321f, -0.33605900f, 0.40115839f, -0.13991138f, 
    0.19022362f, 0.73436010f, -0.35200787f, 0.16166681f, -0.59962940f, 0.29381558f, -0.12858637f, -0.08396868f, 
    0.25481045f, 0.35874245f, -0.35779402f, -0.17699601f, 0.32679012f, -0.04339308f, 0.15448858f, 0.15085602f, 
    -0.01748818f, -0.11139880f, 0.08458463f, 0.19586103f, 0.31920439f, -0.22335148f, -0.47052482f, -0.31864488f, 
    0.32097831f, 0.17125031f, 0.49390078f, -0.24495476f, -0.02924797f, 0.01505536f, 0.33715808f, 0.11109385f, 
    -0.11729588f, -0.02816138f, -0.02016654f, -0.03769190f, -0.17051682f, -0.02888768f, -0.41784689f, -0.14790846f, 
    0.00259299f, -0.24738719f, 0.50711066f, 0.23602706f, -0.06724431f, -0.30488688f, 0.16067381f, -0.14311518f, 
    -0.19444151f, -0.20679277f, 0.26178226f, 0.68714982f, 0.56026375f, 0.00078575f, 0.27775177f, 0.05411651f, 
    -0.21564765f, -0.12730089f, -0.23641336f, 0.04495900f, -0.01066078f, -0.14459701f, -0.24290296f, 0.24487810f, 
    -0.14158057f, -0.24329194f, -0.35532260f, -0.13637461f, -0.16454440f, -0.03512565f, 0.26020932f, -0.28565910f, 
    -0.47200379f, -0.32963723f, -0.43858016f, 0.16200930f, 0.74327600f, 0.09471674f, 0.19324209f, 0.40064788f, 
    -0.03014009f, -0.24400599f, -0.57217574f, 0.12423846f, 0.17347029f, 0.17341256f, -0.09806567f, -0.13634609f, 
    0.04538235f, 0.09139425f, 0.24554269f, 0.05730703f, -0.13101541f, -0.15253668f, 0.02968656f, 0.54622847f, 
    0.54318684f, 0.59894431f, 0.33312166f, 0.27314389f, -0.02669231f, 0.11315237f, 0.14938886f, 0.31085107f, 
    -0.32066485f, 0.08561418f, -0.15191995f, -0.30082816f, 0.00856502f, -0.18590072f, -0.09964991f, -0.20812836f, 
    -0.08283395f, -0.28394946f, 0.05682838f, 0.05642295f, 0.09942286f, -0.15888910f, 0.26093692f, 0.14277278f, 
    0.52141440f, 0.45765960f, -0.24839303f, -0.25217196f, -0.50393480f, -0.47966543f, -0.35060611f, 0.09116916f, 
    -0.16360794f, -0.09313247f, 0.51065797f, 0.11239672f, 0.07946538f, 0.09140079f, -0.04721425f, 0.22890207f, 
    0.23909186f, -0.35883227f, -0.04960220f, 0.33502784f, -0.17777371f, 0.21679345f, 0.37580353f, -0.19313446f, 
    0.21922517f, 0.51364577f, -0.52035338f, 0.67701304f, 0.61148798f, -0.41884312f, 0.13055673f, -0.95589501f, 
    0.33441806f, -0.01394283f, 0.09277045f, 0.17932747f, -0.17351061f, -0.29642186f, -0.23434798f, -0.02662120f, 
    -0.11508011f, -0.02884557f, 0.11462544f, 0.01988107f, -0.08150854f, 0.04599681f, 0.07884928f, 0.24230736f, 
    0.24110447f, 0.00258883f, 0.12276700f, 0.71556032f, -0.16742611f, -0.67117214f, -0.16146499f, 0.39114028f, 
    0.19952820f, -0.50780183f, -0.25209820f, 0.10246769f, 0.21368340f, 0.17799802f, 0.03273282f, 0.20031120f, 
    0.28788674f, 0.09030069f, 0.01364619f, 0.09135634f, -0.19582225f, 0.27163422f, 0.15372610f, -0.02687288f, 
    -0.11855092f, 0.02211426f, 0.21813880f, -0.33822197f, 0.68571532f, 0.10091070f, 0.11446210f, 0.05058924f, 
    -0.67513317f, 0.05281265f, 0.14446503f, 0.25587204f, -0.31902587f, 0.06399960f, 0.27148458f, -0.33503604f, 
    -0.05458664f, 0.28960404f, 0.28978232f, 0.10831352f, 0.17955840f, -0.10130652f, -0.01479822f, 0.15554817f, 
    0.15469970f, -0.22890182f, -0.05195391f, 0.10537739f, -0.35133108f, -0.12841430f, -0.20893323f, 0.54462230f, 
    0.51157528f, 0.42595083f, -0.04852545f, -0.36445630f, 0.01797272f, -0.00556495f, 0.16588445f, 0.16299923f, 
    -0.36130443f, 0.33462983f, -0.28520599f, -0.11840110f, -0.03805200f, -0.12855749f, 0.10646608f, 0.15383649f, 
    0.03377381f, -0.04197107f, -0.24986370f, -0.00302563f, -0.19493948f, -0.19274557f, 0.06403527f, -0.21574633f, 
    -0.65064991f, 0.13762638f, -0.55801672f, 0.22735205f, 0.40707129f, -0.26378188f, -0.49306837f, -0.18348145f, 
    -0.18209063f, -0.26346555f, -0.17163679f, -0.46843207f, -0.30838478f, -0.02745519f, 0.28942081f, 0.10108639f, 
    -0.01950259f, -0.11793985f, -0.24052052f, -0.05650192f, -0.30967838f, 0.05180283f, -0.14558752f, 0.29142079f, 
    0.64699125f, 0.29375839f, -0.02048843f, -0.46364778f, 0.32617411f, -0.36186236f, -0.65330350f, -0.12307718f, 
    0.15429255f, 0.39228281f, -0.03314674f, 0.23656285f, 0.09355380f, -0.01684994f, -0.22435386f, -0.08877425f, 
    -0.17306063f, 0.22966595f, 0.13686498f, 0.24091092f, 0.16293161f, 0.17666952f, -0.20325053f, -0.49586716f, 
    -0.61218840f, -0.52357686f, -0.12623759f, -0.24400385f, -0.45561963f, -0.10684623f, 0.26386106f, 0.24841347f, 
    0.28098235f, -0.22905399f, 0.28343046f, 0.49120966f, -0.06676432f, -0.01307280f, -0.48078954f, -0.25911051f, 
    -0.00530929f, -0.13573872f, -0.10395500f, 0.12837484f, -0.19163799f, -0.23227395f, 0.17831236f, -0.07094597f, 
    -0.01943851f, -0.15362228f, -0.07610958f, 0.02055687f, -0.06889851f, -0.53600687f, -0.14806034f, -0.24687243f, 
    -0.41479051f, 0.40425956f, 0.09452770f, 0.19487713f, 0.22526215f, 0.01805478f, -0.04533781f, 0.22289483f, 
    -0.34460250f, -0.28320965f, 0.36855817f, 0.01354446f, -0.26306379f, -0.01128926f, -0.19455320f, -0.30604261f, 
    0.30884039f, -0.13757119f, -0.18463688f, -0.45376450f, 0.22874545f, 0.35632658f, 0.06139112f, 0.29492944f, 
    -0.21632616f, 0.19759987f, -0.11707246f, 0.20542562f, -0.02939752f, -0.42365032f, 0.08685228f, 0.09154632f, 
    0.06191901f, -0.37851965f, 0.03611011f, -0.12909368f, -0.32685536f, 0.37143582f, 0.36353341f, -0.17889507f, 
    -0.24799891f, 0.40359804f, 0.25557965f, 0.24005786f, -0.38650155f, -0.02562855f, -0.56540233f, 0.50509083f, 
    -0.14237669f, 0.37702027f, 0.47452775f, 0.25046566f, -0.09116312f, -0.33341649f, -0.30818784f, -0.32211560f, 
    0.34150168f, -0.09034235f, -0.25887462f, -0.19960466f, 0.00282560f, -0.22838530f, -0.04028630f, -0.27098060f, 
    0.08064898f, -0.18341938f, -0.09975661f, 0.25974965f, -0.07019228f, -0.42354748f, -0.13889596f, 0.52795023f, 
    -0.06374524f, 0.20129147f, 0.47892040f, -0.24424164f, 0.02147741f, -0.07919090f, 0.38908309f, -0.32104349f, 
    -0.15352650f, 0.15215831f, 0.10824712f, -0.16185528f, -0.22620206f, -0.14096543f, 0.38983491f, -0.08260535f, 
    -0.19131824f, -0.36668181f, 0.35065645f, 0.18525670f, 0.41329867f, 0.68972611f, 0.53782529f, 0.09350164f, 
    0.33351186f, -0.52419269f, 0.50864023f, -0.00554923f, -0.44246152f, 0.08853202f, 0.22326277f, -0.09947664f, 
    -0.18752614f, -0.05642052f, -0.08167163f, -0.20771284f, -0.10027660f, -0.06128127f, -0.00589225f, -0.15182208f, 
    -0.20299587f, 0.09854772f, 0.11380976f, 0.13577099f, 0.10535271f, 0.18439457f, -0.09154551f, 0.17102019f, 
    0.33925045f, 0.31609339f, -0.87656027f, 0.44758669f, -0.07213841f, -0.51965970f, 0.22576235f, 0.24994548f, 
    -0.01278168f, 0.02695756f, 0.12336776f, 0.16505729f, -0.03078902f, 0.27876031f, 0.10742436f, 0.36820641f, 
    -0.12685534f, 0.24402182f, 0.06170252f, 0.13724639f, -0.11561698f, 0.12767527f, -0.12981518f, -0.34773621f, 
    0.28067601f, 0.32849482f, 0.38801640f, -0.62100542f, 0.23016757f, -0.15307336f, -0.39274710f, -0.04927762f, 
    -0.01054245f, 0.37861788f, 0.31099948f, 0.32973135f, -0.11488400f, -0.27278566f, -0.09079456f, 0.20206779f, 
    -0.27369973f, -0.35855052f, -0.33712626f, -0.09617130f, -0.26732400f, 0.03294111f, 0.01461440f, -0.48447317f, 
    0.51450729f, -0.25592080f, 0.56589442f, -0.04421530f, -0.00341737f, -0.13177508f, -0.54250538f, 0.07671267f, 
    -0.17662846f, 0.23653214f, -0.34918725f, -0.01243055f, 0.18105088f, -0.05878330f, 0.06456076f, 0.21045105f, 
    -0.19344425f, -0.02411976f, 0.32302856f, -0.23545161f, 0.13520388f, 0.44728065f, 0.14750275f, -0.06328135f, 
    0.25799856f, -0.13508505f, 0.34764832f, 0.72924924f, 0.45537993f, 0.43235719f, 0.33616504f, 0.34211656f, 
    0.02526746f, 0.01326453f, -0.52837723f, -0.41538781f, -0.30146483f, 0.08669890f, 0.13012327f, -0.04206103f, 
    0.12320291f, 0.12295220f, 0.34030768f, -0.18989560f, -0.14961880f, -0.03889178f, 0.06753020f, -0.17530113f, 
    -0.00410298f, 0.61689913f, 0.25591540f, -0.27093163f, -0.09668496f, -0.15015222f, -0.59923387f, -0.38570687f, 
    0.15869585f, 0.13911495f, -0.10553812f, -0.41183299f, -0.08499809f, 0.30285674f, 0.22062853f, 0.20237039f, 
    0.15610334f, -0.35833514f, 0.01483760f, 0.34261265f, 0.44237357f, 0.27807546f, 0.00888059f, -0.08481681f, 
    0.06534792f, -0.15473789f, 0.22461984f, -0.34244365f, 0.50682729f, 0.57207340f, 0.09086105f, 0.59215456f, 
    0.36531043f, -0.24826550f, 0.26041940f, -0.02262321f, -0.03428696f, 0.33038899f, 0.24866462f, 0.22568166f, 
    0.16759780f, 0.09676526f, 0.09338878f, -0.09578341f, 0.03846581f, 0.21126568f, -0.21973740f, 0.14278688f, 
    0.13864945f, 0.12551649f, 0.17180893f, 0.50807613f, -0.28380823f, 0.43569231f, 0.16635512f, 0.39186531f, 
    0.54974872f, 0.39011276f, 0.15251151f, 0.26432586f, 0.28691116f, -0.13112110f, 0.47055340f, -0.03435368f, 
    0.37087426f, -0.14151216f, -0.17803103f, -0.07351924f, -0.05620224f, -0.10002787f, -0.14646085f, 0.30298734f, 
    -0.11745632f, -0.01074548f, 0.02126868f, -0.07007731f, -0.38442668f, 0.52833545f, 0.22660320f, -0.56703544f, 
    0.69218302f, -0.46183705f, 0.01543369f, -0.09110274f, -0.24143255f, 0.10314513f, 0.04200608f, 0.19972461f, 
    0.04330149f, -0.20054965f, 0.10773839f, 0.06665128f, -0.06659754f, -0.25240996f, 0.21297881f, 0.35575905f, 
    0.18999219f, 0.03015319f, -0.00115170f, 0.01328408f, -0.41409802f, 0.93557227f, -0.13476001f, -0.39033365f, 
    0.85993892f, -0.18836664f, -0.30475301f, 0.11885007f, -0.11784506f, 0.12563358f, -0.03327439f, -0.00773167f, 
    0.13953386f, 0.22541392f, -0.16795848f, -0.19435385f, 0.18631595f, -0.16159859f, -0.18614790f, -0.03460865f, 
    0.35894489f, 0.33152711f, -0.03005893f, 0.00580996f, -0.31024393f, -0.19636835f, 0.60798758f, -0.06314652f, 
    -0.40532601f, -0.32114464f, 0.49141735f, -0.06408550f, -0.10609590f, 0.08988524f, -0.03531820f, 0.39998949f, 
    -0.13893056f, 0.14015320f, 0.11931922f, -0.23401758f, 0.28452137f, -0.12394597f, -0.01666581f, 0.17947705f, 
    0.27212819f, 0.00794194f, 0.23306355f, -0.02174561f, 0.18565470f, -0.35736674f, 0.22562182f, -0.48006526f, 
    -0.36554560f, -0.59420741f, -0.07356623f, -0.26594093f, 0.39858624f, 0.30222809f, 0.32787591f, 0.55559599f, 
    0.23123910f, -0.11478567f, 0.18290387f, -0.12143607f, -0.08877618f, -0.06192577f, 0.26449418f, -0.12111428f, 
    0.21066292f, -0.35321328f, -0.11984687f, -0.22442053f, -0.07439087f, 0.22585674f, -0.38702562f, 0.29634985f, 
    0.75561202f, -0.14565019f, 0.03414033f, -0.33881748f, 0.70030963f, 0.42595077f, -0.41943386f, 0.10588454f, 
    0.07093900f, 0.49490908f, -0.25998875f, 0.08752006f, -0.48834178f, -0.03169591f, 0.03298065f, -0.09321506f, 
    -0.09511007f, -0.23403658f, 0.06940076f, -0.08495204f, -0.05636444f, -0.16981116f, 0.08383636f, 0.00743435f, 
    -0.17229779f, 0.54749018f, 0.40990666f, -0.65877235f, -0.24610849f, 0.08753420f, -0.14084627f, -0.55950046f, 
    -0.20236078f, -0.32972488f, 0.04381862f, -0.22790098f, 0.40891254f, 0.43360847f, 0.19891293f, -0.03381189f, 
    -0.25377655f, -0.15446909f, -0.13820770f, 0.02280210f, 0.05163609f, 0.19856390f, 0.13585320f, -0.04918841f, 
    -0.17678834f, 0.19487748f, -0.65755796f, 0.25831750f, 0.29244989f, -0.05676080f, 0.23792864f, -0.10365370f, 
    0.57282156f, -0.02392213f, -0.28732744f, -0.12680171f, -0.16507547f, -0.23121232f, 0.39509347f, 0.08890169f, 
    0.11290944f, 0.21863642f, 0.24403262f, -0.03147852f, 0.22352134f, 0.11312521f, 0.29146084f, 0.19796018f, 
    -0.37507209f, -0.07714662f, 0.03632732f, 0.16843121f, 0.09207533f, -0.06059038f, 0.18596804f, 0.36269826f, 
    -0.50958258f, 0.58049023f, -0.44021448f, -0.45913482f, -0.06531381f, 0.08301271f, 0.11897682f, 0.07319406f, 
    0.33839512f, 0.13929389f, -0.48016050f, -0.13650805f, -0.32377139f, -0.08001028f, -0.42095920f, 0.10439476f, 
    0.21176383f, 0.06080007f, -0.00606910f, -0.05797096f, 0.33527720f, 0.59335965f, -0.60050511f, 0.28785017f, 
    -0.45206866f, 0.30843329f, -0.41644037f, -0.23979278f, -0.38612875f, -0.13693872f, 0.46433380f, 0.06590613f, 
    0.17734160f, 0.00244197f, -0.10248262f, 0.06341054f, 0.23285003f, 0.09173853f, 0.17662805f, -0.00243596f, 
    -0.20375213f, -0.51205534f, 0.10221187f, -0.14359304f, 0.11711632f, -0.22015056f, -0.30332497f, -0.22479571f, 
    -0.26295865f, -0.55166507f, 0.17480947f, 0.13861072f, 0.00022367f, -0.65078640f, -0.15141588f, -0.28365141f, 
    -0.31356800f, -0.26726988f, 0.08423910f, 0.01495860f, -0.38565817f, 0.01498440f, 0.05898904f, -0.16508295f, 
    0.01510396f, -0.04472812f, 0.29086164f, 0.01318687f, -0.29370654f, -0.09615973f, -0.14736831f, 0.23392642f, 
    -0.11734864f, 0.06776980f, 0.62936682f, 0.48903111f, 0.07252437f, -0.73490512f, -0.03496129f, -0.24282385f, 
    -0.06385469f, 0.26796928f, -0.07096268f, 0.01220000f, -0.00646421f, -0.13459037f, -0.12972713f, 0.16270685f, 
    -0.12189268f, 0.26812226f, 0.21239658f, -0.15416002f, -0.11337016f, -0.18242823f, -0.05894282f, 0.27012682f, 
    -0.31191868f, -0.45217973f, -0.35115400f, -0.29314968f, 0.33771706f, 0.23071727f, 0.03432109f, 0.30124661f, 
    0.40067527f, 0.07585989f, 0.23073791f, 0.05356063f, 0.06857215f, 0.04319454f, 0.07688734f, 0.02530707f, 
    0.15691261f, 0.31595388f, -0.10323188f, -0.13750324f, 0.07048246f, 0.04586005f, 0.13455506f, 0.10690256f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.10931747f, 0.17386983f, 0.05356455f, 0.04478103f, 0.03853517f, 0.09386385f, 0.21005589f, 0.03690446f, 
    0.10426085f, 0.09125587f, 0.03481320f, -0.06332245f, 0.16598114f, 0.20824333f, -0.09859966f, -0.01641412f, 
    -0.08001979f, -0.11178886f, 0.15525264f, 0.14497915f, 0.03963530f, -0.01121044f, 0.27166456f, -0.02839546f, 
    0.08418803f, 0.11412538f, -0.20184785f, 0.04145131f, 0.06539242f, -0.00323234f, 0.03672411f, 0.16599590f, 
    -0.01777734f, 0.02284065f, 0.00257461f, 0.21925986f, 0.19829412f, -0.20977290f, 0.22981229f, 0.09113701f, 
    0.13814636f, 0.14500283f, 0.10584523f, 0.19084261f, 0.12024085f, 0.10242774f, 0.01489619f, -0.00059555f, 
    -0.05880522f, -0.01213128f, 0.01227076f, 0.03630793f, 0.01734732f, 0.08028637f, 0.18282476f, 0.07012003f, 
    0.12057912f, 0.06413234f, 0.11959708f, -0.03147328f, 0.08333422f, 0.14280050f, 0.12056611f, -0.10355759f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04441003f, -0.10399639f, -0.16941150f, 0.08036409f, -0.08156058f, 0.06916875f, 0.10386021f, 0.21351202f, 
    0.07790468f, -0.04607492f, -0.05479891f, -0.11666837f, -0.05665151f, -0.07827038f, -0.03754447f, -0.13774632f, 
    0.01513131f, 0.08424131f, -0.06220719f, 0.01560925f, 0.01929034f, 0.01666766f, 0.13298532f, 0.08561619f, 
    0.14915672f, 0.09727036f, 0.17671059f, 0.02517370f, -0.01216471f, 0.12686102f, -0.04235938f, -0.01232325f, 
    -0.03631714f, 0.11589378f, 0.03639178f, 0.05880071f, 0.02254821f, 0.16617994f, 0.11531202f, 0.00701714f, 
    -0.00809033f, 0.20692717f, 0.03817238f, 0.03433878f, 0.09694652f, 0.06715821f, 0.16589014f, 0.11757058f, 
    -0.08130031f, -0.09859046f, 0.09260177f, 0.00198965f, 0.07407658f, -0.02080579f, 0.06707331f, -0.05988167f, 
    -0.06227568f, -0.08671921f, -0.00182067f, -0.01999649f, -0.14151907f, -0.15848747f, -0.02239151f, 0.12270517f, 
    0.04886099f, 0.00236948f, 0.02826016f, -0.07399799f, 0.02264758f, -0.10755446f, -0.06253453f, -0.09466529f, 
    -0.16245541f, 0.01860981f, -0.03069652f, -0.07703813f, -0.09345661f, -0.03071126f, 0.03233704f, 0.01592505f, 
    -0.03000822f, 0.05993746f, 0.04950414f, -0.20099851f, 0.27234358f, -0.11853124f, -0.03555635f, 0.00247126f, 
    -0.00700620f, -0.07858541f, -0.09325726f, 0.01281243f, 0.00638904f, 0.05996820f, 0.01747805f, 0.10389770f, 
    -0.07572208f, -0.08595451f, 0.07626999f, -0.05822714f, -0.13433179f, -0.04464236f, 0.06794086f, -0.01018657f, 
    -0.03833175f, -0.11736156f, -0.07394929f, 0.00451772f, 0.26591358f, 0.03174484f, 0.01372258f, 0.09884077f, 
    0.00165143f, 0.00457180f, -0.00430250f, -0.06751400f, 0.12519324f, 0.02731533f, 0.05238270f, -0.09628016f, 
    0.09852049f, -0.03914157f, 0.01402517f, -0.08667050f, -0.03616596f, 0.04925761f, -0.08391809f, 0.04338812f, 
    0.06634878f, 0.03352278f, 0.02597285f, 0.09931378f, -0.02437298f, -0.02604083f, 0.11884006f, -0.04151235f, 
    -0.02880065f, 0.02634406f, 0.05643805f, 0.03134890f, 0.00408677f, -0.05007670f, -0.18298006f, 0.06119552f, 
    0.24904992f, 0.03594795f, 0.12671156f, 0.12979962f, -0.00533362f, -0.05302735f, 0.04174349f, -0.07404538f, 
    -0.01657092f, 0.03095067f, -0.14825931f, -0.08202247f, 0.00331358f, 0.03837580f, -0.05915936f, -0.02535631f, 
    0.04270635f, 0.09427168f, -0.06194782f, -0.00034510f, -0.01583533f, -0.04947560f, 0.08214074f, 0.06796336f, 
    -0.18148737f, 0.17417890f, 0.10942291f, 0.24810448f, 0.02143432f, -0.00075670f, 0.03353599f, 0.09327345f, 
    0.07574913f, 0.15975980f, -0.04660866f, -0.06677127f, -0.25467926f, -0.02141314f, -0.15232582f, -0.21565807f, 
    -0.05512998f, -0.08630773f, 0.02854691f, 0.04715278f, -0.05804128f, 0.05292559f, -0.00669444f, -0.08455946f, 
    -0.00381023f, 0.12427647f, 0.08389599f, -0.00616481f, 0.07578977f, 0.08919703f, 0.00990435f, -0.04457016f, 
    0.00737998f, 0.08805763f, -0.00249212f, -0.17903125f, -0.24333785f, -0.10765813f, -0.08686122f, -0.24383697f, 
    -0.17153250f, 0.07682583f, 0.04284624f, -0.11353816f, 0.01300247f, -0.02433080f, 0.07102044f, 0.04733090f, 
    -0.08251010f, -0.02821691f, 0.01549238f, 0.02730703f, -0.02784382f, 0.04459816f, 0.06092576f, 0.13437599f, 
    -0.09123215f, -0.09155622f, 0.10341405f, 0.00153177f, 0.29413247f, -0.09200061f, -0.01791346f, -0.01737128f, 
    -0.15626945f, 0.06937434f, -0.07969832f, -0.04697840f, -0.00451271f, 0.01148187f, -0.04133909f, -0.05625050f, 
    0.00480751f, -0.03570379f, -0.04037420f, -0.16151029f, -0.05607197f, 0.10785475f, -0.09559858f, 0.01567927f, 
    0.01907705f, 0.20378433f, 0.02164223f, 0.10312151f, 0.14854090f, 0.26007220f, 0.10423162f, -0.07664347f, 
    0.01712870f, 0.03415747f, -0.01224959f, 0.04878852f, 0.02003758f, -0.04390940f, -0.12957262f, -0.07519741f, 
    0.14025252f, -0.09168223f, 0.03928851f, 0.03131679f, -0.00085997f, 0.09045397f, -0.12620859f, -0.03348739f, 
    -0.07792462f, 0.02805328f, -0.03765446f, -0.01920655f, 0.22834203f, 0.37813938f, 0.14256658f, -0.27727926f, 
    0.02262430f, 0.01831302f, 0.06665844f, 0.06668033f, 0.12672165f, 0.06311979f, -0.00307039f, -0.11538701f, 
    0.04630432f, -0.03357650f, 0.00465376f, -0.00406554f, -0.04208204f, 0.05488672f, 0.10893548f, 0.04730017f, 
    -0.04163200f, 0.18212306f, -0.07732381f, 0.18122813f, -0.04757721f, -0.08712316f, 0.07055192f, -0.13621791f, 
    0.04176742f, -0.07449050f, -0.00975725f, -0.05221356f, -0.01783741f, 0.08722082f, -0.15077981f, -0.15184215f, 
    -0.40938205f, -0.17817542f, -0.10110952f, -0.13359036f, -0.09116694f, -0.05283732f, 0.21639074f, 0.00799588f, 
    0.04548297f, -0.01954381f, 0.07581269f, 0.06831801f, 0.20426287f, 0.09657443f, 0.02231247f, 0.08506168f, 
    0.07624005f, -0.01280877f, -0.05214303f, -0.11895307f, 0.15207843f, -0.06477656f, 0.01396847f, 0.09390847f, 
    0.03742060f, 0.02136536f, 0.08224268f, -0.15232082f, 0.05413543f, 0.01969716f, -0.07202075f, 0.02636405f, 
    0.02127568f, 0.06817833f, 0.05806181f, 0.02941128f, -0.05412402f, -0.21987770f, -0.06570505f, 0.08183447f, 
    0.00014575f, 0.09445382f, -0.02689920f, 0.10064869f, 0.06391411f, 0.03765192f, 0.05085167f, 0.01392231f, 
    -0.08885505f, -0.16664571f, -0.01002064f, -0.02787044f, -0.04792069f, -0.01874680f, 0.05410030f, 0.00114245f, 
    -0.00951339f, -0.02440410f, 0.04112043f, -0.02033688f, 0.03428886f, 0.19474106f, 0.07042776f, -0.04241452f, 
    -0.06507238f, -0.09364078f, 0.07079732f, 0.01994975f, -0.00982775f, -0.13303113f, 0.03997592f, -0.01463970f, 
    -0.18479173f, -0.11546698f, -0.03541933f, 0.18661126f, -0.02112082f, 0.09588052f, 0.01707032f, 0.11074559f, 
    0.02794824f, -0.10813435f, 0.07124691f, -0.10653909f, 0.07085059f, -0.21545160f, 0.13089906f, -0.09448114f, 
    -0.02966296f, 0.08572261f, 0.00615327f, -0.03174729f, -0.17268349f, -0.11516595f, -0.06226586f, 0.10696529f, 
    0.06189768f, -0.10116090f, -0.07212429f, 0.05489717f, -0.03091925f, 0.06467405f, 0.09422508f, 0.13425663f, 
    0.03153007f, -0.03603442f, -0.10821859f, -0.12272751f, 0.00563080f, 0.08775828f, 0.08528326f, 0.13238867f, 
    0.11948514f, 0.03231579f, 0.07374172f, -0.11242057f, -0.12331095f, -0.06184807f, 0.08418975f, -0.06553886f, 
    0.21302082f, -0.05384848f, 0.08264190f, 0.09929125f, 0.00987009f, 0.12046434f, 0.01227968f, 0.05993283f, 
    0.04101221f, -0.00740987f, 0.05926782f, -0.09266723f, -0.17263725f, 0.07321826f, -0.09637841f, 0.04427350f, 
    -0.01247221f, 0.01596782f, 0.19386145f, 0.01633462f, 0.04325337f, -0.01061326f, 0.02511763f, 0.17715642f, 
    0.06803006f, 0.01956938f, -0.02309306f, -0.00658582f, 0.10124820f, 0.08751063f, 0.01379126f, -0.01072639f, 
    -0.01420194f, -0.05113336f, 0.10000569f, -0.07963709f, -0.09505875f, 0.06810794f, -0.02793660f, -0.16156459f, 
    -0.02468389f, -0.03612570f, 0.02376703f, -0.11413536f, 0.08219302f, 0.00924549f, -0.03060179f, 0.14417803f, 
    -0.19316091f, 0.08326678f, 0.04669264f, 0.08301435f, 0.03479555f, 0.07187286f, -0.03458859f, -0.00226711f, 
    0.09873168f, -0.05893739f, -0.04281076f, -0.10893337f, -0.03972305f, 0.06512220f, 0.08133986f, -0.12312329f, 
    0.05161949f, -0.03145652f, 0.08721031f, 0.07824668f, 0.01621849f, 0.01537812f, 0.09288031f, -0.15096302f, 
    -0.08240595f, 0.13401018f, 0.04285482f, 0.16776097f, -0.04952036f, 0.03872631f, -0.08804327f, -0.01257622f, 
    0.02828336f, -0.01107060f, 0.11834703f, 0.03305265f, -0.08783825f, 0.05196087f, 0.09893298f, -0.07818665f, 
    -0.02631160f, 0.00741452f, -0.00173642f, 0.05815103f, 0.01299323f, 0.06858841f, 0.24279553f, -0.02438478f, 
    0.09096084f, 0.16291636f, 0.12907754f, -0.05265508f, 0.02604849f, -0.03755466f, 0.07353818f, 0.02313894f, 
    -0.04848277f, 0.02572927f, 0.02454400f, 0.07827220f, 0.18869050f, 0.06121687f, 0.13683477f, 0.05386375f, 
    -0.02277496f, 0.05504146f, 0.00614658f, -0.06710523f, 0.01147148f, 0.00472406f, -0.15126422f, -0.00305748f, 
    0.19603315f, 0.00285305f, 0.05221221f, 0.04490185f, 0.03987809f, 0.03429002f, 0.01350352f, -0.00144652f, 
    0.14169033f, 0.16483663f, 0.05687080f, 0.10559650f, 0.25587499f, 0.17944363f, -0.03162827f, 0.01656396f, 
    0.04006350f, 0.05455594f, -0.02820541f, -0.04400070f, -0.01047085f, -0.01866836f, 0.07160107f, -0.06230579f, 
    -0.06876158f, -0.22306900f, 0.11247846f, -0.07960157f, 0.02958677f, 0.08653338f, -0.03244995f, 0.11095412f, 
    -0.02085120f, -0.07109679f, -0.11710838f, 0.08725854f, -0.09823938f, -0.00741356f, 0.08259066f, 0.09988441f, 
    0.00314792f, 0.05634310f, 0.07036931f, 0.18445989f, 0.00848038f, -0.11429972f, 0.04095204f, 0.01753508f, 
    0.13887450f, -0.18113992f, -0.06653535f, -0.05316195f, -0.15827872f, 0.01291440f, 0.06201247f, -0.03478190f, 
    -0.01739120f, -0.12136673f, -0.07790905f, -0.16663469f, 0.04208356f, -0.09606547f, 0.10977757f, 0.01529907f, 
    -0.17698564f, -0.06294844f, -0.01192700f, 0.08483872f, -0.03538233f, 0.04801228f, 0.02010706f, 0.09077326f, 
    -0.17313935f, 0.04255094f, 0.05893503f, -0.11526984f, 0.02198090f, 0.20584440f, 0.08619614f, 0.01328720f, 
    -0.06216130f, -0.09845188f, 0.04180175f, 0.01393967f, 0.01695563f, 0.11469601f, 0.02693388f, -0.04236422f, 
    -0.07450165f, 0.12194324f, -0.03629770f, 0.02056695f, -0.09504969f, -0.07537539f, 0.10470741f, -0.11057800f, 
    0.00862977f, 0.04847180f, 0.07210786f, -0.12370738f, 0.01968326f, 0.06523518f, 0.07117440f, 0.01258337f, 
    -0.03809922f, 0.00203075f, -0.04027414f, 0.04791827f, -0.09681466f, -0.08668089f, -0.09409209f, -0.06712997f, 
    -0.10281610f, -0.01994334f, -0.06515660f, 0.08334438f, 0.07225557f, 0.05742032f, 0.01295178f, 0.08913693f, 
    -0.13498797f, 0.11222488f, 0.17989530f, 0.01181498f, 0.01870868f, 0.03482416f, 0.04310791f, 0.09538694f, 
    0.02507319f, -0.01303434f, 0.05142811f, 0.06636276f, 0.10083478f, 0.05344068f, 0.10371622f, -0.14856760f, 
    0.08072228f, -0.00394478f, 0.02734724f, -0.03983658f, 0.00635785f, -0.01875391f, 0.00956340f, -0.02478245f, 
    0.10994214f, -0.07398106f, -0.00132782f, 0.04094359f, -0.02226042f, 0.00569468f, 0.06784209f, 0.04040838f, 
    -0.12552269f, -0.04181691f, -0.11384542f, 0.02124466f, 0.12872604f, 0.14740285f, 0.15142693f, -0.13735156f, 
    0.07634313f, -0.01358161f, -0.07867565f, -0.07317045f, 0.00481672f, 0.02959805f, 0.09341253f, 0.08620582f, 
    0.34763029f, -0.00774534f, 0.01495794f, 0.26935926f, 0.02629793f, -0.02476664f, 0.01632828f, 0.05193058f, 
    0.02118051f, 0.00982664f, 0.00524068f, 0.00187551f, 0.03982028f, -0.09901156f, -0.03782900f, -0.12752326f, 
    -0.06941095f, -0.09413958f, -0.01924932f, 0.03725483f, 0.00044732f, 0.03685014f, 0.11329860f, 0.19438748f, 
    0.00995903f, -0.11174935f, 0.07854372f, 0.00658831f, -0.06586534f, 0.13030648f, -0.06804940f, 0.03460332f, 
    0.09624812f, -0.07314437f, -0.13853826f, 0.00547176f, -0.09375992f, -0.18044703f, -0.06812087f, -0.14365126f, 
    -0.04576244f, 0.01799723f, -0.05943305f, -0.12200721f, -0.09798718f, 0.09133928f, -0.07063035f, -0.03098611f, 
    0.00137248f, 0.12390602f, -0.02641626f, 0.16491750f, 0.00758635f, 0.19423743f, 0.07974095f, 0.11269063f, 
    0.11260014f, 0.09515256f, -0.16432385f, -0.02441139f, -0.14065962f, -0.13857426f, 0.06470345f, 0.01691270f, 
    0.03573412f, 0.01268939f, 0.01067381f, -0.08011185f, -0.01880375f, 0.04236372f, 0.09970695f, -0.01281400f, 
    0.33148450f, 0.18983477f, 0.15356120f, 0.02856992f, -0.02049661f, -0.02494589f, -0.03454122f, 0.11176524f, 
    0.04254228f, 0.09953681f, 0.10608876f, 0.02831309f, -0.00121595f, -0.03399913f, -0.07045249f, 0.11983793f, 
    0.04186114f, 0.02682983f, -0.13274390f, 0.02847574f, 0.01937146f, 0.04235104f, 0.02600896f, -0.11450924f, 
    0.02639660f, -0.07227401f, 0.08570959f, -0.13680886f, 0.03871828f, 0.01728975f, 0.19000061f, -0.01497654f, 
    0.08811147f, -0.03353430f, 0.04076995f, 0.01378599f, -0.13470033f, -0.06119616f, -0.10181500f, 0.09747529f, 
    0.00065753f, 0.01132197f, 0.05752352f, -0.03511142f, 0.06559613f, -0.03361188f, 0.04153563f, -0.10625485f, 
    -0.02145473f, -0.18817542f, 0.03997368f, 0.01973048f, 0.15839966f, 0.05952316f, -0.03252726f, 0.14832135f, 
    -0.08059616f, -0.00676170f, 0.03715825f, -0.07545353f, 0.04128776f, -0.08274580f, -0.04517229f, -0.06909642f, 
    -0.04227632f, 0.17738380f, -0.03720859f, -0.06355154f, 0.05377729f, 0.07370743f, -0.00498404f, -0.01989092f, 
    0.23240101f, 0.21431197f, 0.17440867f, -0.04648712f, 0.02710590f, 0.10663839f, -0.07025941f, 0.06371476f, 
    0.02392048f, 0.02024532f, 0.06157383f, 0.15241642f, 0.15529558f, -0.01366139f, -0.18013696f, 0.02365419f, 
    0.09922563f, 0.08805823f, -0.09434200f, 0.10650415f, 0.05016593f, -0.06759456f, 0.03295679f, 0.06660309f, 
    -0.28622621f, -0.26182818f, -0.03585043f, 0.06267243f, 0.03168449f, 0.06743568f, 0.02107202f, 0.10574510f, 
    -0.04575238f, -0.02719335f, 0.08027355f, -0.06699613f, 0.26907095f, 0.27829343f, 0.10262689f, -0.05961398f, 
    0.07853898f, 0.12175604f, -0.08744302f, -0.03163736f, 0.06005256f, 0.12597381f, -0.11377367f, -0.08417927f, 
    0.15902980f, -0.10834261f, -0.02680695f, -0.09406498f, 0.00712903f, -0.05862310f, 0.05556249f, 0.02082868f, 
    0.08981553f, 0.06188313f, 0.02008883f, 0.04228882f, -0.15122531f, 0.10606372f, 0.11421817f, 0.06064082f, 
    -0.05967170f, 0.11257114f, -0.01277409f, -0.01480076f, 0.01577352f, -0.05218207f, 0.06549694f, 0.12897971f, 
    -0.00317487f, 0.03697355f, 0.16286480f, 0.21551310f, 0.14340255f, -0.12212878f, 0.05788640f, -0.04975891f, 
    0.03419782f, -0.02103405f, 0.11401388f, -0.09451217f, -0.18187462f, -0.16160408f, -0.11248075f, 0.02233786f, 
    0.12523779f, 0.01854246f, 0.12058651f, 0.07328586f, 0.00308146f, 0.06297988f, -0.01872315f, -0.05677600f, 
    0.36049089f, 0.08039409f, -0.29186201f, -0.04972350f, -0.03432374f, 0.05597331f, 0.05224936f, -0.03204715f, 
    0.06056951f, 0.03887779f, 0.03497192f, 0.07114819f, -0.10174013f, -0.07344493f, -0.04244434f, -0.08709969f, 
    0.16507305f, 0.05390786f, -0.02057265f, -0.00756815f, -0.00766734f, 0.02904221f, -0.06681135f, 0.00808594f, 
    0.06792182f, 0.12724622f, 0.02905326f, -0.06111734f, 0.03985287f, -0.02629683f, 0.06696127f, -0.00316042f, 
    0.10665432f, -0.06537558f, 0.02479700f, 0.14458737f, 0.03255622f, -0.15212457f, -0.12538351f, 0.00326275f, 
    0.07203659f, 0.04271995f, 0.18287145f, -0.07514440f, 0.06888061f, 0.12163071f, 0.01845063f, -0.02876002f, 
    -0.06315766f, -0.08770307f, -0.08955684f, -0.04257930f, 0.11223512f, 0.04867459f, 0.07094925f, 0.03049406f, 
    -0.05499858f, 0.11646239f, -0.11281658f, -0.00840950f, 0.34655830f, 0.42232773f, 0.25652239f, -0.13994178f, 
    -0.19025958f, -0.04145273f, -0.04223980f, 0.01778789f, 0.01439232f, 0.06585686f, 0.04142080f, 0.11897452f, 
    -0.24536385f, -0.11053307f, -0.01934486f, -0.11070345f, 0.06638812f, 0.06938864f, 0.01734819f, 0.04342987f, 
    0.00058993f, 0.09862021f, -0.01567271f, -0.01111796f, 0.25633436f, 0.45946226f, 0.29938176f, -0.11882820f, 
    -0.11710326f, -0.08336485f, -0.02934536f, -0.01353527f, 0.05382045f, 0.13011117f, -0.02660839f, 0.24545762f, 
    0.17771614f, -0.09153289f, -0.12078011f, -0.05453273f, 0.10973751f, 0.00924385f, 0.02355917f, -0.01211558f, 
    -0.01717760f, -0.01330282f, -0.02161617f, -0.02607966f, 0.00464386f, 0.05535766f, 0.03341317f, -0.20805551f, 
    0.00147496f, 0.02319835f, 0.00722182f, -0.00823129f, 0.02689021f, -0.11926170f, 0.03766825f, 0.00717901f, 
    -0.02549074f, -0.11246529f, -0.05493957f, -0.11097519f, 0.06798498f, 0.04867294f, 0.06025079f, 0.01138356f, 
    0.08423951f, -0.05955574f, -0.00461435f, 0.03023928f, 0.07596352f, 0.02552115f, -0.18464346f, 0.17682037f, 
    0.12687074f, 0.08744710f, -0.00103147f, 0.17592938f, 0.14349280f, 0.01306547f, -0.02554045f, -0.02299846f, 
    -0.03670803f, -0.15742043f, 0.07845488f, -0.18334992f, 0.01631091f, 0.01163657f, -0.01950781f, -0.01826016f, 
    0.05758452f, -0.05545579f, 0.00145212f, 0.00796545f, 0.17587997f, -0.07380987f, -0.10338755f, -0.00979639f, 
    0.03028052f, 0.06478865f, -0.02117700f, -0.07913263f, -0.01181763f, -0.04771044f, -0.00964382f, 0.14840180f, 
    0.07497229f, -0.19111173f, -0.09650723f, -0.08934059f, 0.05683491f, -0.01124009f, 0.15587181f, 0.02934908f, 
    0.14658390f, -0.04738041f, -0.02651812f, 0.05476325f, -0.04589524f, 0.31755364f, 0.25537550f, 0.10923906f, 
    -0.11461520f, -0.01534812f, -0.03424273f, 0.03308169f, 0.09204806f, 0.05923491f, 0.04123323f, 0.10168489f, 
    -0.13824591f, -0.00436820f, 0.25083855f, 0.19614725f, 0.01414613f, -0.06596074f, 0.14384276f, -0.06284916f, 
    -0.12417786f, -0.05068559f, 0.02320377f, 0.05274783f, -0.16742519f, 0.16735879f, 0.29654902f, 0.18961497f, 
    -0.03352686f, -0.04003050f, 0.00128939f, 0.03345804f, 0.02020535f, -0.01743999f, -0.02420210f, 0.02718896f, 
    -0.26515368f, -0.14847255f, 0.03163778f, 0.03659140f, -0.03788941f, 0.05656132f, 0.07504848f, -0.00647262f, 
    0.03655448f, 0.05168265f, 0.01723091f, -0.11468027f, 0.19081557f, 0.05101667f, 0.06392529f, 0.09693562f, 
    0.12755650f, 0.03320881f, -0.01477731f, -0.02341579f, 0.05272772f, 0.08278056f, 0.13011414f, 0.02580885f, 
    -0.02307591f, -0.12261686f, -0.15841123f, -0.15578993f, 0.09253199f, -0.00167787f, -0.03228113f, 0.07869585f, 
    0.02105060f, 0.01533753f, -0.04604948f, 0.08592351f, 0.11560681f, -0.04275008f, -0.23064344f, 0.01157534f, 
    0.02073900f, 0.00619740f, -0.11975718f, 0.13836770f, 0.09099803f, -0.05258060f, 0.00965164f, -0.02170820f, 
    0.06479118f, 0.03764973f, -0.01455282f, -0.06051871f, 0.04620400f, 0.02060972f, 0.02460419f, 0.02945909f, 
    -0.00029746f, 0.04653503f, 0.03871935f, -0.02388682f, -0.13487184f, -0.17403708f, -0.15131347f, 0.01776005f, 
    0.13085060f, 0.05927530f, 0.03530667f, 0.06830147f, 0.05341860f, -0.11994699f, -0.09791794f, 0.00333314f, 
    -0.06333138f, -0.03515344f, 0.03430455f, 0.04457747f, 0.02800927f, 0.00552677f, -0.04672900f, 0.04892314f, 
    0.05469504f, 0.01610124f, -0.02840109f, -0.06200204f, -0.06695451f, -0.07475252f, -0.15402409f, -0.02906519f, 
    0.10933466f, 0.12285583f, -0.05693975f, 0.12526464f, 0.10263885f, -0.00249304f, 0.05443133f, 0.03957940f, 
    0.15868458f, -0.03407279f, -0.03683712f, 0.12674174f, 0.03803336f, 0.03150008f, -0.07753848f, -0.04754820f, 
    0.07864517f, -0.01979653f, -0.00717870f, 0.06668378f, 0.06797096f, -0.08441509f, 0.09921386f, -0.22833855f, 
    0.03757111f, 0.15761073f, -0.15911590f, -0.03121206f, 0.08172476f, 0.03574755f, 0.03778227f, 0.16363086f, 
    0.23357296f, 0.39158061f, 0.19006112f, -0.12948304f, -0.08283657f, -0.01955906f, -0.01662206f, 0.02975679f, 
    0.09574390f, 0.09967711f, 0.07084253f, 0.19529243f, 0.47376916f, 0.13592081f, 0.04441303f, -0.06607449f, 
    -0.05485845f, -0.02590598f, -0.05610460f, 0.05475714f, 0.16942291f, 0.06869147f, 0.08389853f, 0.09566791f, 
    0.40677446f, 0.02402460f, -0.19866863f, -0.06202728f, 0.01150094f, 0.07392264f, -0.04035198f, 0.04201158f, 
    0.10314251f, -0.06548303f, 0.06995066f, 0.03011675f, -0.02874351f, 0.02563916f, 0.09659753f, 0.03562928f, 
    0.01133146f, -0.01392641f, 0.08829930f, -0.11960133f, 0.08706851f, 0.13042480f, -0.01824657f, 0.16164260f, 
    0.34114528f, 0.11438081f, 0.05732335f, -0.05380024f, -0.00493879f, 0.03039235f, -0.08707150f, 0.01298914f, 
    0.12675810f, 0.07531824f, -0.17861183f, 0.01810555f, -0.06118966f, -0.18447362f, 0.17048748f, 0.25059178f, 
    0.01725306f, -0.01952534f, 0.06792771f, 0.11076342f, -0.02965685f, 0.00885897f, 0.03763130f, 0.02874406f, 
    0.23438324f, 0.11029457f, 0.05504283f, -0.06423412f, -0.06623049f, 0.08958787f, 0.04769652f, -0.00814391f, 
    0.11735310f, 0.07720838f, 0.11533238f, 0.00676339f, 0.17305350f, 0.11748090f, 0.27470762f, 0.03717307f, 
    -0.11914308f, -0.03434693f, -0.00231529f, 0.09178136f, 0.04659802f, -0.04371859f, 0.04853477f, 0.08591472f, 
    -0.06195094f, -0.02113223f, 0.02218567f, -0.32427523f, 0.04819036f, -0.03424130f, 0.09296978f, -0.09564892f, 
    0.03456744f, -0.02039206f, 0.06276961f, 0.06335890f, -0.03892941f, 0.03755327f, 0.17007896f, 0.10487514f, 
    -0.19819501f, 0.04685592f, 0.00563551f, -0.00414753f, 0.08726709f, -0.03218498f, 0.03530755f, 0.13484575f, 
    0.10109227f, -0.22867312f, 0.08511180f, -0.02899359f, 0.00254784f, -0.02906203f, 0.02346751f, 0.18443897f, 
    0.01737737f, 0.09139659f, 0.04524055f, 0.07447030f, -0.01024580f, -0.11917160f, -0.20071125f, -0.04006898f, 
    0.01008431f, 0.02838741f, 0.03681958f, 0.01923367f, 0.09326763f, 0.03446430f, -0.02867103f, 0.14711884f, 
    0.11900029f, -0.06430422f, 0.47061583f, -0.05687801f, -0.01329613f, -0.09401689f, 0.04235469f, 0.13620701f, 
    0.06347388f, 0.09483311f, 0.03091004f, 0.14280239f, 0.00316841f, -0.26168975f, 0.13001366f, -0.05982096f, 
    -0.03084368f, -0.01451691f, 0.12556203f, -0.05953916f, -0.01636153f, -0.09004398f, 0.07005455f, -0.03355492f, 
    0.08456318f, -0.00148966f, -0.08667493f, -0.04313124f, -0.01750132f, 0.11878435f, 0.01801253f, -0.04492017f, 
    0.00806030f, 0.12970589f, 0.07320864f, -0.11082832f, 0.24808937f, 0.12079951f, -0.00577887f, -0.01180460f, 
    -0.06818721f, -0.09461704f, 0.14682280f, 0.10546236f, 0.06613256f, 0.01516983f, -0.07043078f, 0.03218050f, 
    -0.12860300f, -0.03279838f, 0.26576972f, 0.20009892f, -0.03671316f, -0.01360587f, 0.03516363f, -0.13599628f, 
    0.05490449f, 0.00250389f, 0.00154128f, 0.08270448f, -0.04027923f, 0.08072277f, 0.04723478f, 0.04524007f, 
    0.01044796f, -0.04529872f, -0.01457904f, -0.04987247f, -0.07103206f, 0.10260458f, 0.06757721f, -0.09532516f, 
    -0.29231015f, -0.13636734f, -0.04162505f, -0.13025372f, 0.00214461f, -0.06796893f, 0.07931194f, 0.11901578f, 
    -0.00155871f, 0.03038281f, 0.03288828f, 0.01234239f, 0.01398756f, -0.23367926f, -0.11822080f, -0.01186468f, 
    0.14067344f, 0.03674528f, 0.11910058f, 0.10303946f, 0.00077654f, 0.03965802f, 0.03750591f, 0.00689832f, 
    0.00917807f, 0.02237294f, -0.01247521f, 0.00492761f, -0.02422133f, 0.00443812f, -0.03936018f, 0.01320022f, 
    -0.01200737f, -0.01984440f, -0.00468633f, 0.01923410f, -0.02499136f, -0.03008362f, 0.02777553f, 0.01114440f, 
    -0.02565579f, -0.02336402f, -0.00349660f, -0.00964329f, 0.00620314f, -0.01616229f, 0.01892738f, 0.02908699f, 
    -0.02212597f, -0.01311108f, -0.00950730f, 0.01136317f, 0.01513689f, 0.00523515f, 0.00805204f, 0.00206547f, 
    -0.01812136f, -0.00688965f, -0.02826855f, 0.02625178f, -0.03074530f, -0.02615696f, -0.01324108f, 0.02662968f, 
    0.01624340f, 0.02539299f, -0.01624585f, -0.02717751f, -0.01718359f, -0.03777743f, -0.03076212f, -0.01166173f, 
    0.00386117f, 0.00185962f, -0.04130848f, 0.01942280f, -0.00538414f, -0.02950723f, -0.02069359f, -0.00583822f, 
    -0.02030358f, 0.01903066f, -0.00607403f, -0.00455833f, 0.00832485f, -0.02299380f, -0.00292128f, -0.03492306f, 
    -0.02624316f, -0.00381082f, -0.00033035f, 0.01033278f, -0.03344001f, -0.03986390f, -0.03345319f, -0.01464286f, 
    0.00965429f, 0.01901040f, -0.03143052f, -0.00458736f, -0.01104958f, -0.01546471f, -0.03525461f, -0.03195646f, 
    0.01377194f, -0.01538347f, -0.03060904f, -0.02724496f, -0.03396497f, 0.02052078f, 0.01530985f, 0.00982729f, 
    0.00737056f, -0.00219306f, -0.01751563f, -0.00720857f, 0.01380847f, 0.01387599f, -0.03180612f, -0.02697119f, 
    -0.00147089f, 0.00598754f, -0.03160200f, -0.03351844f, -0.00350707f, -0.01068398f, 0.01259880f, -0.00252473f, 
    0.01539701f, 0.01584011f, -0.03013929f, 0.02347713f, -0.04201214f, -0.00034670f, 0.00137595f, -0.00051600f, 
    -0.01703700f, -0.00889887f, -0.01955117f, 0.01912929f, -0.00301061f, -0.01712597f, -0.00728886f, -0.03374270f, 
    0.01521904f, -0.00954603f, 0.01993021f, -0.00047593f, 0.01806669f, 0.01477417f, 0.01225432f, 0.02824103f, 
    0.02815249f, 0.00872428f, 0.01320348f, 0.01140729f, 0.00108142f, -0.01235551f, -0.01869259f, 0.01802475f, 
    -0.01737905f, 0.02198984f, -0.03239142f, 0.02631170f, 0.02954539f, -0.04146978f, -0.04033281f, -0.04034671f, 
    0.01926525f, -0.00767026f, -0.02488912f, 0.02310677f, 0.02748399f, 0.00167596f, -0.00595616f, -0.03343606f, 
    -0.03475185f, -0.01733856f, -0.03306581f, 0.01954381f, 0.01149247f, -0.01990213f, 0.00431355f, -0.03848957f, 
    0.01480247f, -0.02435550f, -0.00854125f, -0.01444084f, 0.02432550f, 0.01354349f, -0.02254602f, -0.00250417f, 
    -0.00694679f, -0.03404035f, 0.02493059f, 0.00094096f, -0.01556467f, 0.00348101f, -0.00691016f, -0.02887442f, 
    -0.00305224f, -0.02676535f, -0.02215287f, -0.03819923f, 0.02349532f, 0.02768868f, -0.00751760f, 0.02801441f, 
    -0.03132191f, 0.02282684f, 0.03007214f, 0.01487422f, -0.02950692f, 0.00721511f, 0.00234223f, -0.00882750f, 
    0.01145734f, 0.01256447f, -0.03733551f, 0.01853327f, -0.03730214f, -0.03537243f, 0.02515567f, -0.00805796f, 
    0.02510950f, 0.01376676f, 0.00481334f, -0.01216025f, 0.00414564f, -0.03401900f, -0.00678194f, -0.03795948f, 
    0.02107354f, 0.00627471f, 0.00522763f, 0.00194360f, -0.00732861f, -0.00147428f, -0.00312780f, -0.01842559f, 
    -0.00202406f, -0.00626816f, 0.00278575f, -0.02439491f, 0.00617139f, 0.01902015f, -0.04074300f, -0.00950680f, 
    -0.02192892f, 0.01851152f, 0.00578234f, -0.00696619f, 0.00329321f, 0.00349175f, -0.02833892f, 0.02579766f, 
    0.02314511f, -0.03855168f, 0.00249207f, -0.00305801f, 0.01086647f, 0.00529866f, 0.02411378f, -0.01983722f, 
    0.02823146f, 0.01403433f, -0.01781537f, -0.04130095f, -0.03679880f, -0.01243975f, -0.02613112f, -0.01617805f, 
    -0.03523055f, -0.00294660f, -0.03834511f, -0.00568851f, -0.04087620f, -0.01726195f, 0.00226828f, -0.01077193f, 
    0.01975695f, 0.01701585f, -0.03325289f, 0.02472753f, -0.00074120f, -0.03870966f, 0.00534251f, -0.02591900f, 
    0.01809851f, -0.04055700f, 0.00004416f, -0.00215215f, -0.01562718f, -0.01289657f, -0.00558660f, -0.03316990f, 
    -0.03662565f, -0.02792676f, -0.02063507f, -0.02925527f, 0.00106273f, -0.03034833f, 0.01690255f, -0.00330215f, 
    -0.03340961f, 0.01950027f, 0.01709883f, -0.02183879f, -0.03549762f, -0.02101221f, 0.00435076f, -0.02072421f, 
    -0.02368341f, 0.01217297f, -0.03801152f, -0.00853763f, -0.02228416f, 0.00608784f, -0.03587851f, 0.02852695f, 
    0.01129287f, -0.01443416f, 0.02075276f, -0.01900624f, 0.00746359f, 0.02353503f, -0.03004508f, -0.03923625f, 
    0.00381972f, -0.02070577f, -0.04185453f, -0.01285592f, -0.01090759f, -0.02228741f, 0.02245530f, -0.03685780f, 
    0.00173383f, -0.03859885f, 0.02781496f, 0.00755088f, -0.01844186f, -0.00957866f, -0.02601086f, -0.03119972f, 
    -0.00343024f, 0.02304695f, 0.01448675f, 0.01138590f, -0.00509584f, 0.00446767f, -0.01541807f, -0.00306451f, 
    -0.00381956f, 0.02594019f, -0.00668665f, -0.00189665f, 0.00598590f, 0.00175720f, 0.01858893f, 0.01531447f, 
    -0.02676908f, 0.00944702f, 0.02437672f, -0.00132750f, 0.00811760f, 0.01464685f, -0.01128007f, 0.02052399f, 
    0.01941058f, -0.04127765f, -0.00539543f, -0.00842945f, -0.03849570f, -0.02986179f, -0.00055105f, -0.01008974f, 
    0.00161825f, 0.01684386f, -0.00467975f, 0.01175509f, 0.02599033f, -0.00683175f, 0.01259009f, -0.03629413f, 
    -0.01429293f, -0.00041478f, -0.01394487f, -0.04038047f, -0.02692626f, -0.03738886f, -0.03920510f, 0.00242924f, 
    0.02044420f, -0.04020621f, 0.02194415f, -0.00808895f, -0.03251720f, -0.02780610f, 0.00633964f, -0.01890647f, 
    0.00655863f, -0.02897519f, -0.01947555f, -0.03942847f, -0.03370140f, -0.01397560f, -0.01273949f, -0.04023244f, 
    -0.00886656f, -0.01009922f, 0.01656653f, 0.00852279f, 0.02426141f, -0.00503982f, -0.02495323f, -0.02965615f, 
    0.00958307f, -0.02885880f, 0.01746207f, -0.01435191f, -0.01789530f, -0.02270441f, -0.00805900f, 0.02255981f, 
    0.02348082f, -0.00423457f, 0.01129166f, -0.01886376f, 0.00225255f, -0.01855671f, -0.01893162f, -0.02898730f, 
    -0.02261336f, -0.02150272f, -0.01329642f, -0.03646678f, -0.02712979f, 0.00937130f, 0.01229324f, 0.00076345f, 
    0.01577191f, -0.03286648f, -0.00095509f, 0.02173980f, 0.02464048f, 0.01128616f, -0.03395735f, -0.00276247f, 
    -0.00787505f, -0.03192049f, -0.03710196f, 0.02888831f, -0.03725261f, -0.04025690f, 0.00541407f, -0.04121016f, 
    -0.00889392f, 0.01651052f, -0.00326165f, -0.00258337f, -0.01485209f, 0.02923382f, -0.00120120f, 0.00071276f, 
    -0.04036522f, 0.02525840f, -0.04129861f, -0.00118208f, -0.01843110f, 0.02743036f, -0.01054346f, -0.01630384f, 
    -0.03129469f, -0.02543906f, -0.02004333f, 0.00798864f, -0.00612033f, 0.00962982f, -0.01448255f, -0.02589098f, 
    -0.03991187f, 0.00267536f, -0.00619711f, 0.01507799f, 0.02325409f, 0.00047734f, -0.02606282f, -0.03694659f, 
    0.02066070f, -0.00197975f, -0.01229420f, -0.02292831f, 0.01487119f, 0.02750478f, 0.00736739f, -0.03624083f, 
    0.00060022f, -0.03366897f, -0.02319392f, -0.03858199f, -0.03202077f, 0.00629010f, -0.01623617f, -0.00303105f, 
    0.02797170f, -0.00981716f, 0.02688993f, 0.01803285f, -0.03154183f, 0.02812147f, -0.01435201f, 0.02020798f, 
    0.00231397f, -0.03685053f, -0.00571200f, -0.03388683f, 0.01038618f, 0.01242441f, 0.00929282f, -0.03387273f, 
    -0.00709248f, 0.01817842f, -0.00058843f, -0.02651606f, -0.00809748f, -0.00678092f, -0.03696365f, -0.02832914f, 
    -0.00722127f, -0.01716164f, 0.01692359f, -0.03147725f, 0.02339489f, 0.00374766f, -0.02140881f, 0.01339424f, 
    0.00316711f, 0.02572138f, 0.02900135f, 0.01974803f, 0.02975521f, -0.03759537f, 0.02290930f, -0.03740291f, 
    -0.03827534f, 0.00166798f, -0.03449012f, 0.02130436f, 0.01709286f, -0.01570016f, 0.00542825f, 0.00755968f, 
    -0.03012999f, -0.03137112f, -0.03562364f, -0.03755175f, 0.02836132f, -0.03530343f, -0.01713729f, 0.01098241f, 
    0.01336319f, -0.04047232f, -0.01697656f, 0.03004055f, -0.01327919f, -0.03216701f, 0.02173787f, 0.00344872f, 
    -0.01741196f, 0.01001592f, -0.00328775f, 0.01701356f, -0.02670889f, -0.03272446f, 0.00932069f, -0.00362482f, 
    -0.02388790f, -0.01039823f, -0.00276590f, -0.02337854f, -0.03701682f, -0.01583708f, 0.00399869f, -0.03198383f, 
    0.01253350f, -0.02570437f, 0.01244617f, -0.01985899f, 0.02409915f, 0.02406780f, 0.01519500f, -0.00088243f, 
    -0.04002057f, 0.02986809f, 0.00413791f, -0.00264461f, 0.01562373f, -0.03043313f, -0.02665464f, 0.02489654f, 
    0.00398349f, -0.02173205f, 0.01506799f, 0.01489033f, 0.01751677f, -0.00942342f, -0.02131716f, -0.02160698f, 
    0.02849100f, 0.00940242f, -0.03895687f, -0.02317597f, -0.03426766f, 0.02549497f, -0.04159665f, -0.00678310f, 
    -0.02412322f, 0.01337810f, 0.01940143f, -0.03793618f, 0.02020014f, 0.02388861f, 0.01894763f, -0.02649122f, 
    -0.00338605f, -0.01103293f, -0.01465153f, 0.00258316f, 0.01570142f, -0.02357828f, 0.00132635f, 0.01921324f, 
    0.00745569f, -0.02357461f, 0.02266559f, -0.00229400f, 0.00580555f, 0.02202144f, 0.00547901f, 0.02806487f, 
    -0.02027621f, -0.02606433f, 0.01880948f, -0.01593461f, -0.02283483f, -0.00515964f, 0.02393694f, -0.04023442f, 
    -0.01589842f, -0.01581364f, 0.01560263f, -0.01805600f, 0.00645780f, 0.00277723f, 0.02737492f, 0.02538001f, 
    -0.00604314f, 0.01911642f, 0.02782742f, 0.01280198f, 0.01484810f, 0.00383211f, -0.03392954f, 0.02066925f, 
    0.00571120f, 0.02060803f, -0.01007273f, 0.01775865f, -0.02691503f, 0.01157694f, 0.02927920f, -0.00810680f, 
    0.00621309f, 0.00192939f, -0.02597492f, -0.01852566f, 0.00992642f, -0.01477332f, 0.02762089f, -0.02284581f, 
    -0.02144665f, 0.01265031f, 0.00529036f, -0.03501651f, 0.02640329f, 0.02093199f, 0.01276502f, 0.00133279f, 
    -0.02725190f, -0.02924549f, -0.01358333f, -0.02312306f, -0.00792693f, -0.00424547f, 0.02560820f, -0.03247408f, 
    -0.03816172f, -0.02912573f, 0.02283658f, -0.00578851f, 0.02525538f, -0.03473225f, 0.00302861f, -0.01577253f, 
    -0.03082796f, 0.02937816f, 0.02894742f, 0.00675183f, -0.01852067f, -0.03290946f, -0.04024935f, -0.01346800f, 
    0.02253500f, -0.00006979f, -0.02708754f, -0.02060710f, 0.03963711f, -0.01816221f, -0.02659298f, 0.02187066f, 
    -0.02375947f, 0.01660489f, -0.01864601f, -0.03656567f, -0.04042698f, 0.01298763f, -0.02271417f, -0.00771717f, 
    -0.02542618f, -0.02694315f, -0.01390596f, -0.02305279f, -0.03305357f, -0.02649733f, 0.02138266f, 0.00102599f, 
    -0.01981600f, -0.00572276f, 0.01010250f, -0.04123092f, -0.02522245f, 0.00667219f, -0.02106856f, -0.00618763f, 
    -0.01842946f, -0.04041166f, 0.02935047f, 0.01470410f, -0.00111857f, -0.01916906f, 0.00258857f, -0.01731384f, 
    -0.02508080f, -0.03578894f, 0.02912766f, -0.00230630f, -0.03397622f, -0.00007441f, -0.00398374f, 0.02641736f, 
    -0.00889259f, -0.02404266f, 0.02097476f, -0.02344418f, -0.00972326f, -0.02622679f, -0.02465954f, 0.01810431f, 
    -0.01751066f, -0.01923583f, -0.03813629f, 0.00731996f, -0.01173600f, -0.02019321f, -0.02514184f, -0.03290136f, 
    -0.03397410f, -0.03128375f, -0.01915686f, -0.02997377f, 0.03004793f, -0.00218796f, -0.02571410f, -0.00216136f, 
    0.01806928f, -0.04055961f, -0.03650982f, 0.01178926f, -0.02593783f, 0.02828255f, 0.00568023f, -0.04031691f, 
    -0.00757963f, 0.00795364f, -0.01196664f, -0.01469143f, -0.02816267f, -0.01553252f, -0.00720755f, -0.01298947f, 
    0.00910072f, -0.03862754f, 0.02570908f, -0.03885864f, 0.02166937f, -0.03362726f, 0.01348440f, -0.01812974f, 
    -0.02292893f, 0.01853487f, -0.00223204f, -0.00435279f, -0.03151191f, -0.03720009f, 0.00416842f, -0.00066798f, 
    0.00145571f, 0.02994896f, -0.02830649f, 0.02621316f, -0.02217616f, -0.01318032f, -0.02532928f, -0.01790063f, 
    0.02999217f, -0.02974949f, 0.02634031f, -0.03979855f, -0.00754699f, -0.04007744f, 0.00649391f, -0.02718612f, 
    -0.02277179f, 0.02030817f, 0.00366435f, 0.02000907f, -0.03943456f, -0.02997388f, -0.04090929f, 0.02913633f, 
    -0.00166851f, 0.02405171f, -0.01936423f, -0.02371087f, -0.03753366f, 0.01611537f, 0.02571386f, -0.02674405f, 
    0.00760021f, -0.00779691f, 0.01696367f, -0.02212152f, 0.01915747f, -0.02997312f, -0.03756721f, -0.02602272f, 
    0.00650430f, -0.01071716f, 0.01003748f, -0.00313416f, 0.01805368f, -0.01995989f, 0.02017489f, -0.01865739f, 
    0.02167420f, 0.00627531f, -0.03688205f, 0.00787454f, 0.02277676f, -0.02093605f, -0.01635128f, 0.02108263f, 
    0.02677772f, 0.02415923f, -0.02847336f, -0.04011348f, 0.01007405f, 0.01181123f, -0.03270157f, 0.02950859f, 
    -0.00677159f, -0.03082746f, -0.03173669f, 0.02809574f, 0.01170034f, -0.04202634f, -0.02983224f, -0.03331751f, 
    -0.02745485f, 0.01486135f, -0.03826680f, 0.00419867f, -0.00542158f, -0.02138846f, -0.02861002f, -0.02854206f, 
    0.01894026f, -0.01070512f, -0.01658386f, -0.03688246f, -0.03735443f, -0.01798998f, -0.03808710f, 0.00774514f, 
    0.00786214f, 0.02470909f, 0.02945287f, -0.00454864f, -0.00481779f, -0.01304039f, -0.03937479f, -0.03733118f, 
    0.00946012f, 0.02819357f, -0.00262308f, 0.01660672f, 0.00058406f, -0.01864239f, -0.00315356f, -0.01644188f, 
    -0.02139992f, 0.01607469f, -0.03537554f, -0.00284315f, -0.00271808f, 0.03985159f, -0.03129856f, -0.00983295f, 
    -0.00214480f, -0.00898093f, 0.01800583f, -0.02329252f, 0.01681243f, -0.02773165f, -0.01753756f, -0.00097491f, 
    0.00646060f, -0.03477210f, -0.03782328f, -0.02741619f, 0.02683230f, 0.01899240f, -0.02193354f, -0.02516967f, 
    0.01963112f, -0.01710720f, 0.01499779f, -0.00622380f, -0.03982707f, 0.03109094f, -0.00147556f, 0.02865493f, 
    0.02083974f, 0.00265486f, -0.00713808f, 0.02126862f, -0.01198627f, 0.00210546f, 0.01420917f, -0.02472219f, 
    0.00066110f, -0.01598294f, 0.00128356f, 0.01532984f, -0.02719969f, -0.03725011f, 0.00568357f, -0.00401954f, 
    0.02701364f, -0.03060880f, 0.00019601f, -0.03940136f, 0.00595991f, -0.00194136f, 0.02293298f, -0.01310045f, 
    -0.00955038f, 0.01597769f, 0.00831504f, -0.03182110f, -0.00157354f, 0.02690417f, -0.01661735f, 0.03035763f, 
    -0.03762095f, 0.00289787f, 0.00501090f, -0.00586782f, 0.01589502f, 0.02604922f, -0.01125856f, -0.03688742f, 
    -0.02891892f, -0.02427365f, 0.00318305f, 0.01657286f, -0.02230218f, -0.02677124f, -0.02303691f, 0.00359659f, 
    0.01562974f, -0.04009439f, -0.02033843f, 0.01514529f, -0.02023767f, -0.00522301f, -0.02586300f, -0.02557930f, 
    0.00340931f, -0.02926277f, 0.01425038f, -0.00972230f, 0.02592713f, -0.00542276f, 0.01648652f, -0.01649412f, 
    -0.01410135f, -0.01860399f, -0.01678399f, 0.00444885f, 0.00542530f, 0.02031275f, 0.00647624f, -0.03425780f, 
    0.02959906f, -0.03705525f, -0.03046748f, -0.03336240f, 0.00530119f, -0.00043058f, 0.03027320f, -0.03377540f, 
    -0.02868158f, -0.03317196f, -0.01843439f, 0.00133330f, 0.00633904f, 0.02285495f, 0.01630913f, -0.02282515f, 
    -0.00584372f, -0.02655577f, 0.02526680f, 0.01739600f, -0.03847665f, 0.01529939f, 0.00895954f, -0.02116413f, 
    -0.00032028f, 0.00056972f, 0.03048434f, -0.02893513f, -0.01336963f, 0.00067668f, -0.02518765f, -0.02409314f, 
    0.01824756f, 0.02806730f, -0.03911361f, -0.01491563f, 0.01864799f, -0.00343364f, -0.00539738f, 0.01015333f, 
    -0.02067258f, 0.00569830f, -0.01106500f, 0.02298447f, -0.03050126f, -0.03445904f, 0.01811289f, 0.01946235f, 
    0.01765231f, 0.02723560f, 0.02189012f, 0.00773342f, 0.00452182f, -0.00816406f, -0.02652966f, -0.02157945f, 
    -0.01425654f, -0.00339429f, 0.02848810f, 0.02561709f, -0.00685682f, 0.00188879f, -0.01553013f, 0.02962112f, 
    -0.01652183f, 0.01347526f, -0.01580346f, 0.01643488f, -0.01052898f, 0.01374161f, -0.01339578f, -0.00555641f, 
    0.01949529f, -0.00477621f, -0.02282166f, -0.02648336f, -0.00575285f, -0.00274010f, -0.00283040f, -0.00115416f, 
    0.01583799f, -0.02573794f, 0.03157238f, -0.01420145f, 0.01582312f, 0.02667104f, -0.03082176f, 0.03098081f, 
    -0.03416903f, -0.04096852f, 0.01397575f, -0.03182819f, 0.01550787f, -0.01554688f, 0.00678150f, -0.03360632f, 
    -0.03261591f, -0.03400229f, -0.02829541f, 0.01313285f, 0.03397318f, -0.01322425f, 0.00242200f, 0.00744677f, 
    -0.00126585f, 0.01210295f, -0.03593149f, -0.03463640f, 0.02714786f, -0.01813447f, -0.01047114f, -0.01595127f, 
    -0.00299444f, 0.00287220f, -0.02050718f, 0.00428144f, 0.02966764f, -0.03792903f, -0.01376957f, -0.00035933f, 
    -0.02004851f, 0.02066021f, 0.02609628f, -0.01171235f, 0.02151093f, 0.01433720f, 0.00209494f, 0.00713863f, 
    -0.01646506f, -0.00846274f, 0.02887021f, -0.02514862f, -0.02451904f, 0.01516050f, -0.02657233f, 0.01288200f, 
    -0.02100557f, 0.02733498f, -0.00268673f, -0.00702539f, 0.00305754f, -0.01336435f, -0.02308824f, -0.02355180f, 
    0.00565149f, 0.01404894f, 0.01422399f, -0.01597072f, -0.03516539f, -0.02486391f, 0.00586437f, -0.02194570f, 
    0.00522491f, -0.00460839f, -0.02684605f, -0.02400415f, -0.01217664f, -0.02126939f, 0.01225530f, 0.01027576f, 
    -0.00622421f, -0.00294183f, 0.01918720f, -0.01128619f, 0.00280189f, -0.01902922f, -0.00211245f, 0.01556305f, 
    0.00784449f, -0.02713454f, -0.02018996f, -0.03743625f, -0.03385523f, 0.02992848f, 0.02542087f, 0.01955136f, 
    -0.03264090f, -0.03366784f, -0.00416349f, 0.02329658f, -0.01514322f, -0.00419322f, -0.00015409f, -0.01071874f, 
    0.00252710f, -0.03630769f, -0.00229358f, -0.00460542f, -0.04090073f, -0.01446737f, 0.00943833f, -0.02280777f, 
    -0.01019730f, 0.00750660f, 0.00212441f, -0.03103938f, 0.02903798f, -0.03665749f, -0.02431931f, -0.02536537f, 
    0.00832266f, 0.00003100f, -0.03009019f, -0.03013889f, 0.00852383f, 0.00412041f, -0.00814644f, 0.00740335f, 
    0.00296390f, -0.00765205f, 0.01048431f, 0.02175714f, 0.00904788f, -0.03992431f, 0.00771505f, -0.02610998f, 
    -0.00357552f, 0.00791201f, 0.01519515f, -0.02280105f, -0.00004302f, 0.02133150f, -0.00631947f, 0.00233487f, 
    0.01329920f, 0.01264471f, -0.00790104f, -0.01098269f, 0.02603923f, 0.01399456f, 0.02407766f, -0.00036149f, 
    -0.03691986f, 0.02569934f, 0.02503718f, -0.03723559f, -0.03700165f, 0.02231148f, 0.00911637f, 0.03137945f, 
    0.02404950f, -0.01585868f, -0.02228575f, -0.03624107f, -0.02471801f, 0.01694134f, 0.00048877f, -0.01010294f, 
    0.01625804f, -0.03841326f, 0.03120729f, 0.00271980f, 0.02166029f, -0.02693931f, -0.03839388f, 0.00097416f, 
    -0.01231068f, -0.03918957f, -0.03502214f, 0.01527457f, -0.02768369f, -0.00791036f, -0.02776557f, -0.01538942f, 
    -0.01363704f, 0.00717966f, 0.03083048f, -0.01652494f, -0.01617246f, -0.02623460f, -0.02948652f, -0.03422281f, 
    0.03102493f, 0.01954456f, 0.00898314f, -0.00476561f, -0.00885370f, 0.03094168f, 0.00556475f, 0.01820272f, 
    0.03140232f, 0.00673283f, 0.01137867f, 0.01836232f, -0.03791098f, 0.01850228f, -0.01176223f, -0.02673516f, 
    -0.02625417f, -0.03203079f, -0.02264890f, -0.03890399f, 0.03065291f, -0.03562918f, 0.00806053f, 0.00756542f, 
    -0.00804319f, 0.02086462f, -0.03474538f, -0.03537238f, -0.01422652f, 0.01879075f, 0.02607004f, 0.02686934f, 
    -0.01556188f, -0.01893860f, -0.01571816f, -0.03985228f, 0.02341579f, -0.01324273f, -0.00168498f, 0.00295718f, 
    -0.01010788f, 0.01909907f, -0.01712776f, -0.01424886f, 0.01306403f, -0.01334772f, -0.00657191f, 0.01070772f, 
    0.00664621f, -0.00546473f, -0.00479463f, -0.03228505f, -0.01854101f, 0.01376806f, -0.04075994f, -0.03690644f, 
    0.02609473f, -0.03384148f, -0.03142196f, 0.00224947f, 0.01812262f, 0.00643911f, 0.02498532f, 0.01542413f, 
    -0.01018036f, -0.03226202f, -0.01290958f, 0.01818875f, -0.02436790f, 0.01787059f, -0.02504769f, -0.02996346f, 
    0.00955246f, 0.02721837f, 0.00502299f, 0.01299292f, -0.03966306f, -0.01991616f, -0.00320889f, 0.02731546f, 
    -0.00526807f, -0.01342042f, -0.03410842f, -0.04038284f, 0.03152448f, -0.00719958f, 0.01585221f, -0.03328146f, 
    0.00931398f, -0.03968362f, -0.03931438f, -0.01192845f, 0.00174548f, 0.01958006f, -0.01378088f, -0.02138662f, 
    0.03074234f, -0.01511051f, -0.00011684f, -0.03130301f, 0.00458225f, -0.01318834f, -0.02472829f, -0.03521432f, 
    -0.02222978f, 0.01181753f, -0.03789004f, 0.02750526f, 0.02013049f, 0.01084205f, 0.02698569f, 0.00865612f, 
    -0.00387811f, 0.02185479f, -0.03881801f, 0.01268239f, 0.00267659f, -0.02622425f, -0.01984276f, 0.00585337f, 
    -0.00174271f, -0.03715575f, -0.00710880f, -0.02525745f, -0.00139351f, -0.03287930f, -0.02684406f, 0.01796252f, 
    -0.00918974f, 0.02443898f, 0.01364634f, -0.03508467f, 0.01083073f, -0.00208452f, -0.03971735f, 0.00380422f, 
    -0.04074856f, -0.00461054f, -0.02457177f, -0.00588825f, -0.02855321f, -0.01012556f, -0.01598065f, -0.00146383f, 
    0.02110082f, -0.01523329f, -0.02134603f, -0.00344831f, 0.01486830f, -0.00570140f, 0.02099504f, -0.00604559f, 
    0.02869255f, -0.01791229f, -0.01568325f, 0.02331560f, -0.01829387f, -0.03010187f, 0.02901909f, 0.00082086f, 
    0.00891910f, -0.00361950f, 0.00111883f, -0.02372772f, 0.01997515f, -0.00215780f, -0.01024566f, -0.01730727f, 
    -0.02930610f, -0.00823699f, -0.01945891f, -0.03802365f, 0.00802409f, -0.01186551f, 0.00576880f, -0.01511197f, 
    0.01060798f, -0.02473521f, -0.01551048f, 0.02434585f, 0.00266783f, 0.00440220f, 0.02966544f, -0.02828435f, 
    -0.03242520f, -0.02601083f, 0.01139794f, -0.01525251f, -0.02749694f, 0.00252305f, -0.00718110f, 0.00414207f, 
    -0.03144140f, -0.02201282f, 0.02818168f, 0.02755394f, -0.02355745f, -0.02063213f, 0.01098802f, 0.00930894f, 
    -0.01581561f, -0.03425325f, -0.02441874f, 0.00373056f, -0.02457294f, -0.00104202f, -0.03109743f, -0.00984414f, 
    0.02201697f, 0.00325779f, 0.01765350f, 0.01941073f, -0.04027128f, 0.01069650f, 0.01674739f, 0.00633659f, 
    -0.01811587f, -0.03628063f, -0.03141471f, -0.03458114f, 0.00788203f, 0.00354387f, -0.02112789f, -0.03292476f, 
    -0.03655527f, 0.02540843f, -0.01991402f, 0.02019218f, -0.02954010f, -0.00004170f, -0.01830410f, -0.02649322f, 
    -0.01219484f, 0.01354860f, -0.02080949f, -0.01433992f, -0.01703514f, 0.02242959f, -0.00056957f, -0.03868364f, 
    -0.01194074f, 0.01876978f, -0.02298341f, -0.03026195f, -0.03020043f, -0.02678291f, -0.03612671f, -0.00675368f, 
    -0.02141570f, 0.01312446f, -0.00224911f, -0.03433659f, -0.01368759f, 0.03223932f, -0.02650321f, -0.01908342f, 
    -0.04032088f, 0.00768243f, 0.00947136f, -0.01706714f, 0.02696345f, -0.01360980f, -0.01348359f, -0.00078747f, 
    -0.07426360f, 0.02386826f, 0.15727365f, 0.01037005f, 0.01585517f, -0.03895246f, 0.04043986f, -0.00111094f, 
    -0.01519103f, 0.07509881f, -0.05603587f, 0.00221880f, 0.30121976f, 0.07816662f, -0.00672510f, -0.17751449f, 
    -0.03023603f, -0.07303231f, 0.11353407f, 0.05569255f, 0.08577111f, 0.10618512f, 0.15357386f, 0.01368806f, 
    -0.03270992f, 0.10415411f, 0.01097993f, 0.02831421f, -0.01495667f, 0.06593893f, 0.10441814f, 0.18458670f, 
    0.23475908f, -0.00390207f, 0.16437045f, 0.04850278f, -0.15868019f, -0.05067198f, 0.01503489f, -0.23599648f, 
    -0.05586620f, 0.01239404f, 0.03348107f, 0.09325616f, -0.11010312f, -0.09969987f, -0.02822290f, -0.02339992f, 
    0.18049417f, -0.01497722f, -0.05664087f, 0.05081684f, 0.00647827f, 0.00857759f, 0.10637248f, 0.08327834f, 
    -0.00472793f, -0.01174945f, -0.01457270f, -0.10246548f, 0.04031946f, 0.15397908f, -0.02670718f, -0.01294549f, 
    0.01805731f, 0.07302659f, -0.00089681f, 0.12102667f, 0.08486811f, 0.04551443f, 0.10465851f, 0.03423770f, 
    0.14815332f, 0.18270163f, -0.04002375f, -0.06780084f, 0.21979517f, 0.03718689f, -0.02295057f, 0.14112297f, 
    0.04737819f, 0.05031541f, 0.18313466f, 0.14766091f, -0.00949339f, -0.01252456f, -0.16276847f, -0.08394636f, 
    -0.03535445f, 0.06415027f, 0.05784313f, -0.05065555f, 0.05775943f, 0.01144796f, -0.02814024f, 0.04823213f, 
    0.12849453f, -0.07159583f, 0.07072290f, -0.13033500f, 0.09063616f, 0.06568983f, -0.07700828f, 0.06912762f, 
    0.01092049f, 0.00556978f, 0.16796541f, -0.01828752f, 0.50299519f, -0.18099278f, 0.00059532f, -0.00765570f, 
    0.10688135f, 0.02709942f, 0.11373673f, 0.10197373f, -0.06452945f, 0.05021234f, 0.12790848f, 0.04796535f, 
    0.28613651f, 0.08464752f, -0.08303091f, 0.00651018f, -0.01113090f, 0.07057646f, -0.03145355f, 0.08529472f, 
    0.15950678f, 0.10972496f, 0.12252550f, -0.11789431f, -0.12107105f, 0.24379100f, -0.04781662f, -0.04914759f, 
    0.03797846f, 0.02585496f, -0.07807450f, 0.06813643f, -0.04882484f, -0.01812381f, 0.00636299f, -0.13407724f, 
    0.18793517f, 0.14793584f, 0.05383880f, -0.06700005f, 0.06248040f, 0.10600813f, 0.09088603f, 0.03010477f, 
    -0.02180056f, 0.03474165f, -0.09835068f, 0.22233978f, 0.22728631f, -0.04953007f, -0.06442729f, 0.00537679f, 
    0.10384537f, 0.10145506f, 0.02130560f, 0.05075407f, 0.06678264f, 0.03331642f, 0.04972456f, 0.15390354f, 
    -0.08776686f, -0.11914772f, -0.02291001f, 0.07875026f, 0.14605419f, -0.03129793f, 0.05412899f, -0.13628314f, 
    0.04833375f, -0.02785762f, 0.07135945f, 0.11976744f, 0.02544870f, 0.07463459f, -0.01109367f, -0.06063791f, 
    -0.18131906f, 0.00343566f, 0.01459691f, -0.00591812f, -0.06269971f, 0.07668240f, 0.14221402f, 0.13201898f, 
    -0.10856915f, 0.28650960f, 0.16026893f, 0.07155392f, 0.02114289f, 0.10264931f, 0.13683511f, -0.04887503f, 
    -0.09541583f, 0.00952573f, -0.05041215f, 0.21146585f, -0.12078644f, 0.04650565f, 0.01729258f, -0.01495546f, 
    -0.16096318f, -0.17118210f, -0.04967038f, -0.09244985f, 0.10394529f, 0.11287326f, -0.16049404f, 0.03917567f, 
    0.17337114f, -0.17567724f, -0.05759615f, -0.03869758f, 0.11836209f, -0.06438819f, 0.07300501f, 0.07722309f, 
    0.00445658f, 0.01480952f, -0.06064263f, 0.22243433f, -0.39081419f, 0.16173795f, -0.17976895f, 0.15057237f, 
    -0.16930155f, -0.04157576f, 0.03157437f, 0.05354199f, -0.03400521f, 0.07488887f, 0.06825316f, -0.12463026f, 
    0.11828738f, 0.12552319f, 0.14166330f, 0.17598531f, -0.17091587f, 0.04385480f, -0.00521416f, -0.03732900f, 
    -0.02892208f, -0.07934432f, -0.03449851f, 0.02098770f, 0.16862300f, -0.22829928f, 0.04068241f, 0.22747216f, 
    0.07198355f, 0.13507864f, -0.01052840f, 0.00642938f, 0.11870515f, 0.01636356f, 0.26118520f, 0.06969113f, 
    0.27832708f, 0.02105840f, -0.07843260f, 0.00891818f, 0.04124046f, -0.17185999f, 0.01439975f, 0.01049109f, 
    -0.06715836f, 0.19741632f, -0.04078177f, -0.00495806f, -0.14692496f, -0.11661652f, -0.14195104f, 0.33017042f, 
    0.25343066f, 0.08375647f, -0.00253749f, -0.10768070f, 0.01948757f, 0.04908959f, -0.03335422f, 0.24995561f, 
    0.04526402f, -0.05626091f, -0.25978634f, 0.12123885f, -0.17428559f, 0.03432869f, -0.05605114f, 0.07462493f, 
    0.11119023f, -0.05426700f, 0.02545510f, -0.18619741f, 0.18544836f, 0.25922406f, 0.06668755f, -0.08118579f, 
    0.04033383f, 0.01043107f, 0.07193060f, 0.02493952f, -0.08003271f, -0.01662064f, 0.00322852f, 0.21071093f, 
    -0.03911037f, -0.14543849f, 0.03529097f, 0.00951762f, -0.14355251f, -0.14283659f, -0.10992652f, -0.23594011f, 
    0.06559496f, -0.02947812f, -0.05746309f, -0.05766504f, 0.26066941f, -0.08963799f, 0.01819997f, 0.10636097f, 
    0.10561065f, 0.10918517f, -0.05658413f, 0.13803387f, -0.07328670f, 0.18920010f, 0.01330867f, -0.01367191f, 
    0.35664463f, -0.28932482f, -0.10198830f, -0.00104402f, 0.16490667f, 0.06828839f, 0.09701297f, 0.01583926f, 
    0.04822299f, -0.01861764f, -0.01776596f, 0.01314918f, -0.15918180f, -0.11556666f, -0.08179417f, 0.16649207f, 
    -0.11274157f, 0.07868497f, -0.07252119f, -0.06893535f, -0.13048267f, -0.06466959f, 0.00623133f, -0.03143791f, 
    0.30135524f, -0.13589513f, -0.02865597f, 0.11776785f, -0.01675763f, -0.09328426f, 0.05709833f, 0.12304011f, 
    -0.02620240f, 0.05798499f, -0.14798306f, -0.13518953f, 0.07294367f, -0.09703128f, 0.01139525f, 0.00937517f, 
    0.08230788f, 0.11839917f, -0.00750584f, 0.04944472f, 0.05991404f, 0.20791887f, 0.17480764f, 0.15441832f, 
    0.25057697f, 0.11722541f, -0.21692811f, -0.06632051f, 0.19853504f, 0.00295693f, -0.04181425f, -0.01106518f, 
    0.11864351f, 0.21165127f, -0.02796709f, 0.10288741f, -0.48162907f, 0.12786463f, 0.16430324f, -0.04749451f, 
    0.13193791f, 0.06286772f, 0.03733174f, 0.11342560f, 0.10762211f, 0.04408946f, 0.04469575f, 0.15312354f, 
    0.08562123f, -0.20090292f, -0.28677750f, 0.13754790f, 0.11729878f, 0.07395570f, -0.08912412f, -0.03306935f, 
    0.04485045f, 0.09273218f, 0.07292785f, 0.00488310f, -0.00059866f, 0.21915944f, -0.01491322f, -0.04492370f, 
    0.05088172f, 0.05769912f, 0.01231756f, 0.07351670f, -0.08886906f, -0.07303309f, -0.00536781f, 0.24692191f, 
    0.36520252f, 0.02259824f, -0.05482436f, 0.01655384f, 0.01292817f, 0.05009136f, 0.03933935f, 0.16249087f, 
    -0.06481361f, 0.02137594f, 0.00324320f, 0.04730138f, 0.03533395f, 0.09081265f, 0.05780952f, -0.14673105f, 
    0.04417658f, -0.03494956f, -0.04846696f, -0.10561822f, 0.02351475f, -0.14883052f, -0.02956150f, 0.01242260f, 
    -0.06707942f, -0.01481709f, 0.03164266f, 0.06839787f, 0.06486806f, 0.05398693f, 0.10348198f, 0.00687569f, 
    0.05196375f, 0.11259811f, 0.11076625f, -0.03012307f, 0.04484125f, 0.05941845f, 0.12517054f, 0.04627240f, 
    -0.05783403f, 0.09187824f, 0.00787803f, 0.05298523f, 0.01441835f, -0.03290879f, 0.12745747f, -0.04138616f, 
    0.14551009f, 0.15033135f, 0.00003316f, 0.08511679f, 0.10375018f, -0.10707983f, 0.06251732f, -0.01786516f, 
    -0.00514722f, 0.00279120f, 0.11861133f, 0.03623834f, 0.50231880f, -0.07492265f, -0.05912409f, -0.02484913f, 
    -0.03779289f, 0.12208360f, -0.10899302f, 0.12072651f, 0.13248786f, 0.11339090f, 0.09205382f, 0.01287887f, 
    -0.12643360f, -0.06086512f, 0.02909650f, 0.05821657f, 0.11548447f, 0.06311619f, -0.08675514f, 0.05682943f, 
    0.09309465f, 0.00094113f, -0.12885697f, -0.12017436f, 0.18174720f, -0.04927759f, 0.13871977f, 0.07700542f, 
    0.07097046f, 0.13140035f, 0.05186358f, -0.06935584f, -0.12545739f, -0.00160272f, -0.13296442f, 0.15450534f, 
    -0.19874862f, 0.22227766f, -0.10647780f, 0.10383975f, 0.13241984f, 0.09598891f, 0.07322376f, 0.05021752f, 
    0.10069150f, 0.12964377f, 0.10885104f, 0.14870998f, -0.20672765f, 0.14459042f, -0.00218750f, 0.04680702f, 
    0.17460147f, 0.13689588f, 0.05897481f, 0.10011891f, -0.01050418f, 0.04894676f, 0.01296364f, 0.06451588f, 
    -0.06221243f, 0.16892469f, 0.14362481f, 0.05605627f, 0.11812226f, 0.12838565f, -0.07014747f, 0.12370192f, 
    0.03859697f, -0.13272651f, 0.05890528f, -0.06972005f, 0.20135291f, -0.04167087f, 0.11863783f, 0.16363034f, 
    0.15061894f, -0.10265779f, 0.12464843f, -0.01828166f, -0.05871258f, 0.15771040f, 0.15754116f, 0.17838231f, 
    0.05356655f, -0.14673795f, 0.03673990f, -0.19463661f, -0.01257700f, 0.00754916f, -0.13703500f, 0.08644345f, 
    0.01621088f, 0.08801926f, 0.01612875f, -0.14270215f, 0.02975723f, 0.02183558f, -0.02495155f, 0.16272350f, 
    -0.06839202f, -0.03958979f, 0.12142050f, 0.05118126f, 0.01402626f, 0.22138558f, -0.01893329f, -0.01367460f, 
    0.00055203f, -0.24515159f, 0.28915241f, -0.04603010f, 0.04732645f, 0.08831004f, -0.02134891f, 0.01963068f, 
    -0.04019576f, -0.00833583f, 0.06884804f, 0.09339296f, 0.10905346f, -0.10415062f, 0.13763092f, 0.03057274f, 
    0.05061261f, 0.09774087f, 0.00241921f, 0.12892653f, 0.07995252f, -0.22703464f, -0.11327329f, 0.06083651f, 
    -0.00170455f, 0.35850203f, -0.19827986f, 0.13880903f, 0.12530419f, -0.16317105f, -0.04822510f, 0.09000040f, 
    0.15257365f, 0.15820463f, -0.06909333f, 0.11717939f, 0.10105283f, -0.24589698f, 0.11120432f, -0.12352845f, 
    0.12129271f, -0.02850069f, 0.02418255f, 0.02871954f, 0.09107522f, -0.01080182f, -0.06564796f, 0.13450609f, 
    0.02946370f, 0.05790306f, 0.02866060f, 0.10465296f, 0.06653445f, 0.07630026f, 0.07801163f, 0.04174690f, 
    0.01389101f, 0.12495100f, 0.10947957f, 0.04402247f, 0.00702754f, -0.06401968f, 0.08160124f, -0.04392414f, 
    -0.09707092f, -0.07085833f, -0.03407282f, -0.12431613f, 0.02700668f, 0.12773342f, 0.04929790f, 0.11229648f, 
    -0.37628430f, -0.16740789f, 0.10091993f, 0.04360295f, 0.11931376f, -0.00772104f, 0.14816804f, -0.00938255f, 
    0.09421504f, 0.10026662f, -0.12647258f, 0.10411280f, 0.17177242f, -0.18407418f, -0.22427931f, 0.13556661f, 
    0.06201145f, -0.00371236f, 0.04693238f, 0.05616137f, 0.11474247f, 0.08041551f, 0.03646196f, -0.08253380f, 
    -0.25842044f, 0.13690054f, -0.13105276f, -0.02560883f, 0.00399342f, 0.07891262f, -0.04736686f, -0.02558906f, 
    0.00715782f, 0.09555880f, 0.12634875f, -0.07105163f, 0.11819562f, 0.16458100f, 0.00321290f, 0.19581732f, 
    0.12316788f, 0.10316050f, 0.22690684f, 0.19397794f, 0.31125176f, -0.08877777f, 0.00160893f, -0.09863108f, 
    0.36091319f, -0.18697995f, -0.17626336f, 0.20975597f, 0.23728809f, 0.06416642f, 0.00375550f, -0.16283667f, 
    0.08777583f, 0.09511016f, 0.03410469f, 0.11303850f, 0.23033547f, -0.09004638f, -0.08831307f, 0.07161010f, 
    -0.12681763f, -0.12048677f, 0.07023387f, -0.00940979f, 0.07118951f, 0.08218681f, 0.03026328f, -0.13540977f, 
    0.39481145f, -0.06473770f, -0.11956701f, 0.22553049f, 0.10603970f, 0.06989700f, -0.00433719f, -0.00590369f, 
    -0.10229421f, -0.03442971f, -0.00881739f, 0.00857374f, 0.06551702f, 0.08313750f, -0.00774102f, 0.16088356f, 
    -0.04024557f, 0.05284932f, 0.00781714f, -0.02411639f, 0.04352761f, 0.03506926f, 0.05085448f, 0.02496164f, 
    0.00081380f, 0.00665540f, 0.02249992f, 0.02698374f, -0.02757295f, -0.02545428f, 0.00465851f, -0.03639423f, 
    -0.04118567f, -0.01831714f, 0.00950050f, -0.00867929f, 0.01376570f, -0.03958204f, 0.01236205f, 0.01245703f, 
    -0.00175457f, -0.01053472f, -0.03276600f, -0.03589340f, 0.02936138f, 0.03004706f, 0.01834534f, 0.00821064f, 
    0.02929309f, -0.01445474f, -0.03523864f, -0.01442426f, -0.02287584f, -0.00304693f, -0.00127790f, 0.00720234f, 
    -0.02366144f, -0.03631512f, 0.01032993f, -0.03324631f, -0.00759891f, -0.03721898f, -0.00158495f, -0.01149411f, 
    0.00040374f, -0.00750773f, 0.00354753f, -0.02592167f, 0.00028113f, -0.02725636f, -0.03228609f, 0.01720442f, 
    -0.02795800f, 0.01801575f, -0.01129180f, -0.01558254f, 0.01382037f, -0.00636205f, -0.04083121f, -0.02313621f, 
    -0.01182352f, -0.01544018f, -0.03227241f, -0.01089488f, -0.01080856f, -0.01921191f, 0.01955433f, -0.02487564f, 
    -0.02575592f, 0.02671791f, -0.00757334f, -0.03698697f, -0.00793728f, -0.00345095f, -0.03990266f, 0.02672101f, 
    -0.03478911f, 0.00141590f, 0.02127381f, 0.02972648f, -0.00301014f, 0.01041677f, -0.00056466f, 0.01396893f, 
    -0.00445502f, -0.01658047f, 0.02001714f, 0.02775231f, -0.01693723f, -0.03410870f, -0.01256327f, 0.00375889f, 
    0.00483178f, 0.00947234f, 0.01244725f, -0.04129640f, 0.02168311f, 0.02698679f, -0.00017900f, -0.00917355f, 
    -0.02316602f, 0.00793156f, -0.01843550f, -0.02723715f, -0.04118728f, -0.00440288f, 0.01752253f, -0.01699135f, 
    -0.00185578f, -0.00064535f, -0.03986458f, -0.03051618f, -0.02377808f, 0.02320702f, -0.01535880f, -0.02243312f, 
    0.00250535f, 0.02756636f, 0.00411427f, -0.00201953f, -0.01235684f, -0.00686831f, -0.01281420f, -0.02397210f, 
    -0.03033881f, -0.02665466f, -0.03212416f, -0.04190493f, 0.01693572f, -0.02745667f, -0.00060009f, -0.00146133f, 
    0.01606543f, 0.00609967f, 0.02512341f, -0.03220387f, -0.02231933f, -0.01235053f, 0.01447209f, 0.01518040f, 
    0.00679397f, 0.00242549f, 0.00708965f, -0.03303633f, -0.01588477f, 0.00844781f, 0.01641762f, -0.02691683f, 
    -0.04003359f, -0.00909715f, -0.01125833f, -0.03036273f, 0.00304382f, -0.01111858f, -0.01753529f, -0.01084139f, 
    -0.03934070f, -0.00836183f, -0.00225616f, -0.02365038f, 0.02728241f, -0.00623985f, -0.04085833f, 0.02580316f, 
    0.02246569f, -0.02938152f, -0.03480481f, -0.03634528f, -0.02254715f, -0.02280245f, 0.02659142f, -0.02432342f, 
    0.02973938f, -0.03527235f, 0.02440957f, 0.02271119f, 0.01116357f, -0.03431122f, -0.01882748f, -0.00495570f, 
    0.01693030f, 0.02001189f, 0.00437282f, -0.01985025f, -0.00378145f, -0.00994800f, 0.02802764f, -0.03686159f, 
    0.02375481f, 0.02140372f, 0.02428703f, -0.01633574f, -0.00325605f, -0.02840030f, -0.03811772f, 0.02031180f, 
    -0.02849500f, -0.00963311f, -0.02777527f, -0.00985831f, -0.01535919f, -0.01406708f, -0.02943709f, -0.03861915f, 
    -0.03379923f, -0.00992807f, -0.00583343f, -0.01026151f, -0.01028156f, -0.00815185f, -0.00417935f, -0.00072839f, 
    0.01179576f, 0.01125881f, 0.02749487f, 0.00142021f, -0.01798739f, -0.00696470f, -0.01807925f, -0.02692179f, 
    -0.03521506f, 0.01202878f, 0.01089252f, -0.01256555f, -0.01103496f, -0.00171347f, 0.02232292f, 0.02074906f, 
    0.02495871f, -0.01349473f, -0.00202784f, 0.01361882f, 0.00312533f, -0.00426520f, 0.00661484f, 0.00796967f, 
    -0.00623189f, -0.02049254f, 0.01310272f, 0.01791326f, 0.00639014f, -0.01799458f, 0.02134616f, 0.02498003f, 
    0.01120402f, -0.02145672f, -0.01449071f, 0.01578321f, -0.00916804f, -0.03002384f, -0.01521212f, -0.01089152f, 
    -0.03359247f, -0.01656912f, 0.00921890f, -0.04101851f, -0.01305847f, 0.02851966f, -0.00208995f, -0.00477619f, 
    -0.01312688f, -0.00152901f, -0.04200812f, 0.02934860f, -0.00376735f, -0.01234703f, 0.00201083f, -0.01015124f, 
    0.01757244f, -0.02340048f, 0.02366407f, -0.00046960f, 0.01715479f, 0.02575191f, -0.01540130f, 0.00126145f, 
    -0.01861472f, -0.03144422f, 0.00953220f, 0.00390098f, -0.00118878f, 0.00983391f, -0.03181730f, -0.04012962f, 
    -0.02731417f, -0.00984386f, -0.02297296f, -0.01773785f, -0.00517870f, 0.01866863f, -0.03300493f, 0.01104397f, 
    -0.03111453f, -0.03339501f, -0.01648354f, 0.02460552f, -0.00143812f, -0.02056895f, -0.01393697f, -0.00736814f, 
    0.00846894f, -0.01818439f, 0.01527603f, -0.02912427f, 0.00237810f, -0.03662729f, -0.00063393f, -0.03389839f, 
    0.02183887f, 0.01592247f, -0.02896638f, -0.02537584f, -0.00835667f, 0.02464540f, 0.00671242f, -0.03997498f, 
    0.00730884f, -0.03692202f, 0.02897768f, -0.01022743f, -0.03711931f, 0.00898260f, -0.04123990f, -0.01034368f, 
    0.02885074f, -0.02887583f, 0.01269144f, -0.02628756f, 0.00229321f, 0.00391937f, 0.00317018f, 0.02891405f, 
    -0.03475481f, -0.01131327f, 0.02095581f, -0.02938929f, 0.00150090f, 0.00739748f, -0.00820912f, -0.01000791f, 
    -0.02210747f, 0.01326395f, 0.00916646f, -0.00114946f, 0.00543111f, 0.02180135f, -0.01721582f, -0.03274241f, 
    -0.01397690f, 0.01246464f, -0.00116390f, 0.01409113f, 0.01134273f, 0.00368859f, -0.03514249f, 0.00750806f, 
    -0.02029644f, -0.03969627f, -0.03164853f, 0.01634023f, -0.01419661f, -0.02439178f, 0.00950466f, -0.01949079f, 
    0.01590347f, -0.01234051f, 0.01845407f, 0.01310453f, 0.02496826f, -0.02885923f, 0.00357809f, -0.03722442f, 
    0.00433858f, 0.01979761f, 0.02288180f, 0.00279452f, 0.02945658f, -0.03753826f, -0.01068755f, 0.02786232f, 
    -0.02800854f, 0.00940021f, -0.00030866f, 0.01331370f, 0.00831160f, 0.02954488f, -0.04063671f, 0.01480498f, 
    0.00234382f, -0.02797172f, 0.02671123f, 0.00474566f, -0.02393045f, -0.02466005f, -0.02577986f, 0.01934111f, 
    0.02325749f, -0.00695542f, -0.03342566f, -0.01817058f, 0.01836312f, -0.03821099f, 0.01202220f, 0.00700353f, 
    0.01687574f, 0.00102004f, -0.00519232f, 0.00521224f, -0.02453509f, -0.01823298f, -0.01945757f, 0.01554097f, 
    -0.01022895f, 0.00247320f, -0.00686629f, -0.01116607f, 0.02037471f, -0.01730212f, -0.03122788f, 0.01206104f, 
    -0.03477623f, -0.02774510f, 0.02821703f, 0.00787363f, 0.01479713f, -0.02162122f, -0.00459200f, -0.03650907f, 
    -0.03037174f, 0.00866850f, -0.00737243f, -0.00662991f, 0.02525330f, -0.00300031f, 0.02630715f, 0.02609912f, 
    -0.03590429f, -0.01502743f, -0.03277596f, 0.01604488f, -0.03107979f, -0.02543451f, -0.00631694f, 0.02617505f, 
    -0.01940479f, 0.02622491f, 0.02268895f, -0.02086281f, -0.04192698f, 0.00329486f, 0.00680025f, -0.02040059f, 
    0.01689635f, -0.01980192f, 0.00463051f, -0.00226321f, -0.01346066f, 0.01915764f, 0.02672989f, -0.01102353f, 
    0.02691070f, -0.01918123f, -0.02166632f, 0.00544391f, -0.01515555f, 0.01396414f, 0.01682921f, -0.02992387f, 
    -0.01210912f, 0.01556704f, 0.00997623f, 0.01394556f, -0.03949726f, -0.03553924f, -0.03344326f, 0.02592778f, 
    0.02375084f, 0.00188918f, 0.01707517f, -0.03501882f, -0.00193744f, 0.01116866f, 0.00651995f, 0.01094561f, 
    -0.03702700f, -0.02424671f, -0.02436566f, -0.03991012f, -0.02265406f, 0.00012537f, -0.01607333f, 0.02216477f, 
    0.02536111f, 0.02471769f, 0.02890047f, 0.01743218f, -0.01385647f, 0.01401630f, -0.02240528f, -0.00363494f, 
    -0.01849162f, -0.04030259f, -0.03758698f, -0.00794707f, -0.01382165f, -0.00438807f, -0.00782543f, -0.03616847f, 
    -0.02225309f, -0.02694335f, 0.02759067f, -0.03430627f, 0.02304308f, 0.02278560f, 0.01571705f, -0.00054565f, 
    0.00624899f, -0.03841560f, -0.03700523f, -0.01879735f, 0.01837690f, 0.01967135f, -0.02673945f, -0.01248002f, 
    -0.01983824f, -0.03389515f, -0.03162447f, -0.01202470f, -0.03400418f, 0.00077695f, -0.02298090f, -0.00119321f, 
    0.02975234f, -0.03282913f, 0.02795490f, -0.02278941f, 0.01491407f, -0.01358915f, -0.01535138f, -0.00769897f, 
    0.02485131f, 0.01826301f, -0.00323851f, 0.02081173f, -0.04178528f, 0.02484913f, -0.02843937f, -0.00464701f, 
    -0.00835193f, -0.01557524f, -0.03768915f, 0.02847464f, 0.02730869f, -0.00465782f, -0.00361281f, -0.02949897f, 
    -0.03110745f, -0.02799062f, -0.00627534f, 0.00494835f, 0.02217636f, -0.01395301f, -0.04032921f, -0.02238713f, 
    -0.01987347f, 0.02941638f, -0.02714761f, -0.04136298f, 0.00410966f, -0.00790997f, -0.00057145f, 0.01790022f, 
    -0.01538775f, 0.00310676f, -0.00493905f, 0.00476301f, -0.03758389f, -0.02533134f, 0.01313259f, 0.02396235f, 
    -0.03739426f, 0.00950779f, 0.03005829f, 0.01419666f, -0.03542172f, 0.00210820f, -0.01148956f, -0.02557449f, 
    -0.02958560f, -0.00575612f, -0.00331563f, 0.00567549f, -0.00861163f, 0.02492117f, 0.00857822f, -0.03929195f, 
    0.01816292f, -0.03384231f, -0.03889713f, -0.01961717f, -0.03586557f, -0.01593015f, -0.03358545f, -0.01030996f, 
    -0.01496677f, -0.01442326f, -0.03567302f, 0.02568518f, -0.03712031f, -0.04151130f, 0.00175362f, -0.03661482f, 
    -0.03842130f, 0.02419567f, -0.04128921f, -0.01951525f, -0.02814069f, 0.00904272f, -0.01645823f, 0.01914636f, 
    -0.01868612f, 0.02264011f, 0.02640478f, -0.02785490f, -0.03332320f, -0.01055766f, -0.00601825f, -0.02537932f, 
    -0.02425824f, -0.03145549f, -0.03411902f, 0.00751258f, 0.01549254f, -0.02842948f, -0.00464993f, 0.02711343f, 
    -0.02639929f, 0.02415561f, -0.02405228f, 0.02382599f, 0.02676026f, -0.00687918f, -0.02402116f, 0.00127648f, 
    0.01347763f, -0.01780920f, 0.00045078f, -0.01533395f, 0.00027404f, -0.02290001f, 0.01414400f, -0.00327209f, 
    0.01869643f, 0.00589539f, -0.00176372f, -0.02621394f, -0.03945139f, 0.00176911f, 0.01404899f, 0.01481133f, 
    0.00846243f, -0.03506552f, -0.02949399f, -0.03215069f, -0.03172766f, -0.01744894f, -0.00257273f, -0.02609548f, 
    -0.00381192f, 0.02713830f, 0.01128905f, -0.03517191f, -0.02606202f, -0.01329366f, -0.02848237f, -0.02054880f, 
    0.02246903f, 0.02320501f, -0.04111795f, -0.03585308f, -0.00268773f, 0.00316897f, 0.01460103f, -0.00943775f, 
    -0.00136664f, 0.02150512f, 0.01038780f, -0.03358185f, 0.02932727f, 0.02385518f, 0.00907885f, -0.00850352f, 
    -0.03429968f, 0.01030483f, 0.00753674f, 0.02871636f, -0.01359923f, -0.02357802f, -0.01049425f, 0.00257364f, 
    0.00584964f, 0.00061641f, 0.01309719f, 0.00046898f, -0.04073583f, -0.01960028f, -0.00588124f, -0.02971612f, 
    -0.03109911f, 0.00971773f, -0.00239761f, -0.04016100f, 0.02985780f, 0.02464731f, -0.03387533f, -0.00842084f, 
    -0.03285822f, -0.03324993f, 0.00507620f, -0.03218832f, 0.00469155f, 0.00239423f, 0.01789018f, -0.03627361f, 
    -0.03764560f, 0.00961705f, 0.01714872f, -0.03551411f, -0.00746007f, -0.01543743f, 0.02043881f, 0.00781404f, 
    -0.03396500f, 0.00508578f, 0.02995510f, -0.02316582f, 0.02110826f, -0.03641766f, -0.00448747f, -0.01425202f, 
    -0.02042040f, -0.01921277f, 0.01272487f, -0.01048693f, 0.01811908f, 0.01223583f, -0.01716854f, -0.00099700f, 
    -0.00542621f, 0.00263499f, -0.00733627f, -0.01293068f, -0.01859588f, 0.02120479f, 0.00418191f, -0.02039801f, 
    -0.01119862f, -0.01857427f, -0.04039781f, 0.02588162f, 0.02905921f, -0.04100899f, -0.02252521f, -0.02746232f, 
    0.02093253f, -0.02793516f, -0.02739292f, -0.01448497f, -0.01190004f, -0.02978532f, 0.00841506f, -0.03261048f, 
    0.20943800f, -0.02989086f, -0.01527039f, 0.06005680f, 0.00918203f, -0.10740610f, -0.03756503f, -0.00294517f, 
    -0.01236420f, -0.01273974f, 0.05306488f, 0.02965462f, 0.03267419f, 0.07778493f, -0.04437611f, 0.15913744f, 
    0.10384719f, -0.03159749f, -0.02287310f, 0.05429528f, 0.07457302f, 0.02199608f, -0.03344418f, 0.09015604f, 
    -0.11888169f, 0.09107256f, -0.04906926f, -0.18216629f, 0.12744448f, -0.07018890f, 0.03771747f, -0.00595710f, 
    -0.00743431f, -0.04963823f, -0.02445013f, -0.00678164f, 0.15813155f, -0.03988954f, -0.02527226f, -0.11367273f, 
    0.06508490f, -0.02893452f, -0.01031511f, 0.10254091f, 0.01972134f, 0.12013029f, -0.03145685f, 0.09861686f, 
    -0.06395661f, 0.22303821f, 0.03901260f, 0.31197134f, 0.05411162f, 0.02406698f, -0.04790137f, -0.03554781f, 
    0.10699262f, 0.00661601f, -0.00115853f, 0.01032621f, 0.27290934f, 0.07205489f, 0.10889457f, 0.11070203f, 
    -0.07372245f, -0.01102086f, -0.03404623f, 0.01078489f, -0.08104604f, 0.11962509f, -0.05951225f, 0.11519991f, 
    -0.17098123f, 0.05008938f, 0.00978876f, 0.05114314f, 0.03545243f, 0.08953916f, -0.06677025f, -0.08855817f, 
    0.04358524f, -0.10560629f, -0.01878162f, 0.11000726f, -0.25803864f, -0.10315339f, 0.00100375f, 0.10867712f, 
    0.04965764f, -0.02395814f, 0.02219867f, 0.10967936f, 0.07542558f, 0.02348395f, -0.09243864f, -0.02667219f, 
    0.08945873f, 0.12108308f, 0.10868113f, 0.08335142f, 0.08485357f, -0.03439236f, 0.08192215f, -0.05085554f, 
    -0.00611636f, 0.01274226f, -0.04446409f, -0.09908745f, -0.41178310f, 0.14445792f, 0.21873394f, -0.26003012f, 
    0.03288718f, 0.00042624f, 0.03700873f, -0.01273931f, 0.01025339f, 0.08156250f, -0.02949756f, 0.04606837f, 
    -0.06482922f, -0.00938972f, -0.03195987f, 0.04999867f, -0.01623771f, 0.01191677f, -0.02497054f, -0.14553593f, 
    0.00533378f, 0.05511137f, -0.03849163f, 0.13453975f, 0.24685095f, -0.11239862f, 0.05891434f, 0.09194139f, 
    0.06401233f, -0.01093620f, 0.18806735f, -0.02537802f, -0.04924078f, 0.07035193f, 0.02446085f, 0.01686514f, 
    -0.12894855f, -0.19888327f, -0.06450533f, -0.01496498f, -0.02133266f, 0.04201488f, -0.10957732f, 0.00880107f, 
    -0.02672478f, -0.01681262f, 0.15107438f, -0.04007883f, -0.12468513f, -0.10356631f, 0.05000867f, -0.11074971f, 
    -0.02090113f, -0.08372243f, 0.01050645f, 0.06235691f, 0.04121363f, 0.06457677f, 0.00588906f, -0.10797841f, 
    0.51107204f, 0.07013075f, 0.05698917f, -0.06468067f, -0.04099632f, 0.04204433f, 0.03169172f, 0.07169619f, 
    -0.06497899f, -0.05557947f, 0.03085179f, 0.03643063f, 0.08441354f, 0.06040657f, -0.02609127f, 0.20807277f, 
    0.07277140f, 0.01873707f, -0.17687698f, -0.07963194f, -0.01071169f, -0.02906313f, -0.01891238f, 0.09229351f, 
    -0.03347922f, -0.24257416f, -0.06159163f, -0.09404652f, -0.03490051f, -0.02961824f, -0.00067839f, 0.02097596f, 
    -0.04703525f, -0.12536570f, 0.17757373f, 0.01963899f, -0.06570090f, 0.05070826f, 0.07599133f, 0.19583088f, 
    0.05681001f, 0.00341959f, 0.06255086f, 0.10748278f, -0.07394914f, -0.03513823f, -0.00291693f, -0.01223032f, 
    -0.01258921f, 0.08465960f, -0.06957659f, 0.07726252f, 0.16593741f, -0.01024944f, 0.05223220f, 0.00320939f, 
    0.06798654f, 0.03307577f, 0.00368417f, -0.01997878f, -0.27713308f, -0.20703273f, 0.16236247f, 0.05023454f, 
    0.09146369f, 0.01185364f, 0.00614050f, -0.02921659f, -0.01965826f, -0.10768029f, -0.01864264f, 0.05077126f, 
    -0.29207271f, -0.20489350f, 0.02121860f, 0.10074058f, 0.04378323f, 0.04513606f, 0.21852155f, -0.00101848f, 
    0.09323264f, 0.02838715f, 0.15569763f, -0.03670452f, -0.19226968f, 0.02293601f, -0.19490133f, 0.02499247f, 
    0.05826007f, -0.02361220f, 0.01922903f, -0.01833977f, -0.11631817f, -0.04451014f, -0.08390652f, 0.01596413f, 
    -0.20621857f, -0.01793510f, 0.05211688f, 0.07755939f, 0.00027113f, -0.00952978f, 0.06771817f, 0.09656098f, 
    0.03467579f, -0.11533133f, 0.02898678f, 0.05070680f, -0.11413992f, -0.09235384f, -0.06199516f, 0.15614332f, 
    0.11411117f, 0.00181372f, 0.01190926f, -0.08232708f, -0.04457377f, -0.08152137f, 0.03376618f, -0.01464286f, 
    -0.23334320f, -0.16701680f, 0.05405584f, 0.06412835f, 0.07419342f, 0.02475975f, -0.06374409f, -0.03632104f, 
    -0.01813417f, -0.02336606f, 0.07862114f, 0.01697236f, -0.21543784f, -0.01430448f, -0.24876443f, 0.23687248f, 
    -0.05282945f, -0.01837566f, -0.00197671f, 0.00761131f, -0.10716666f, 0.08814057f, 0.10494572f, 0.07302567f, 
    0.07487740f, 0.13906597f, -0.09063081f, 0.27505356f, 0.12881008f, 0.03860808f, -0.10885125f, 0.19033624f, 
    0.04044149f, -0.00930484f, 0.04551846f, 0.05996110f, -0.10846628f, -0.11994111f, 0.03921441f, -0.07687812f, 
    0.03598283f, 0.08065784f, 0.10247641f, -0.05882567f, -0.13786575f, 0.02961002f, -0.06979389f, -0.06439219f, 
    -0.11618620f, 0.10108723f, -0.04368039f, 0.16141680f, 0.13188547f, -0.01132718f, -0.04992562f, 0.02299342f, 
    0.03814975f, 0.06926409f, 0.00678495f, 0.07432912f, -0.05806332f, 0.08708809f, -0.02825437f, 0.15098566f, 
    0.02734548f, -0.07755259f, 0.07998406f, 0.10579383f, 0.02656654f, 0.07584395f, 0.03796398f, -0.01500157f, 
    -0.19073443f, 0.21112825f, 0.05384634f, 0.19444041f, 0.13607275f, 0.09131904f, -0.12381084f, 0.00404014f, 
    -0.01785900f, -0.01441815f, 0.05466587f, -0.00418411f, 0.11652065f, 0.01983570f, 0.07001515f, 0.10735561f, 
    0.20189312f, 0.13224539f, -0.02193525f, -0.00633642f, 0.05000622f, -0.09182490f, 0.01346243f, -0.06492162f, 
    0.18035097f, 0.17540301f, 0.12513162f, -0.04214643f, -0.02223437f, -0.04489323f, -0.04499755f, -0.16572130f, 
    0.00604514f, -0.02549145f, 0.00972056f, -0.01642123f, 0.22244449f, 0.29867482f, -0.11335906f, -0.32879212f, 
    0.06222855f, -0.00460789f, -0.03318688f, 0.09684681f, 0.01866326f, 0.02336474f, 0.08500244f, -0.09055582f, 
    0.19145525f, 0.04499882f, 0.08377834f, 0.24416089f, 0.00395710f, -0.04920970f, -0.01064427f, -0.03925976f, 
    -0.04220051f, -0.02102659f, 0.03231398f, 0.00892674f, 0.25487334f, -0.21221817f, 0.05176792f, 0.01449711f, 
    -0.08240338f, 0.01911495f, 0.01450478f, 0.05068241f, 0.16223288f, 0.02849375f, -0.07742658f, -0.06544096f, 
    -0.19157261f, 0.16207375f, 0.02081964f, -0.06058539f, 0.02049577f, 0.00241821f, 0.07805776f, -0.02844021f, 
    0.05976363f, 0.11151389f, -0.02669595f, 0.14558244f, 0.14087035f, -0.14755490f, -0.09739819f, 0.32994446f, 
    0.05597515f, 0.02643225f, 0.01486384f, -0.02352050f, -0.00289276f, 0.20134300f, 0.07210761f, -0.05114252f, 
    0.32125193f, -0.10883019f, 0.04530700f, -0.16025464f, -0.09725837f, -0.04599700f, -0.03405040f, 0.03569391f, 
    -0.07052343f, 0.02355420f, -0.08713616f, 0.01798165f, -0.06464295f, 0.06948078f, 0.05464707f, 0.13071357f, 
    0.10990939f, 0.10270174f, 0.11371208f, -0.00812576f, -0.04959937f, 0.11960373f, -0.00215078f, 0.00836048f, 
    0.06328586f, -0.03608770f, -0.06136039f, -0.05313317f, 0.03714674f, 0.05333926f, 0.04308157f, -0.01616216f, 
    0.02988751f, 0.03276218f, 0.10484759f, 0.05985138f, -0.11776873f, 0.06532837f, -0.01865649f, 0.03914441f, 
    0.09259756f, 0.00880361f, -0.02491893f, -0.09286926f, 0.00443536f, -0.03524492f, -0.04864762f, 0.08654522f, 
    -0.10337836f, 0.12505729f, 0.07464657f, -0.05697752f, -0.01577685f, 0.00240310f, 0.04664866f, 0.15890767f, 
    0.01696404f, 0.05147018f, 0.08213191f, 0.09390628f, -0.19342571f, 0.20566694f, -0.13955897f, 0.11548012f, 
    0.00302319f, -0.04215539f, 0.04029845f, 0.03272014f, -0.00589027f, 0.04228483f, -0.04516177f, -0.06191428f, 
    0.27958217f, -0.22244887f, 0.09084034f, 0.11239135f, 0.14872012f, -0.01377522f, -0.05791979f, -0.00359521f, 
    -0.02051758f, -0.06298278f, -0.01007124f, -0.00148743f, -0.00712212f, 0.02334197f, 0.03558360f, -0.07871196f, 
    0.03218336f, -0.04324651f, 0.04264773f, -0.06778727f, -0.03358220f, -0.06982058f, 0.08087509f, 0.00592709f, 
    -0.02751216f, 0.01571276f, 0.06215334f, -0.11537600f, -0.00015433f, 0.04953203f, -0.01368490f, -0.07611813f, 
    -0.09708054f, 0.02717757f, 0.02477516f, 0.06402309f, -0.21571536f, -0.00638777f, -0.00176979f, -0.01872932f, 
    -0.14570035f, 0.00136817f, -0.07228281f, 0.02870955f, -0.05646230f, -0.08277506f, -0.09375603f, 0.02548843f, 
    -0.01250409f, 0.26219755f, 0.08420399f, -0.07816842f, 0.07624630f, -0.09709727f, 0.11339525f, -0.01370854f, 
    -0.03179356f, -0.01367669f, 0.04715634f, -0.00161097f, 0.01362196f, 0.25473306f, -0.08837107f, 0.04027219f, 
    0.06077240f, -0.01341479f, 0.04055487f, -0.11925354f, 0.00121858f, -0.02251896f, -0.06045328f, -0.09636581f, 
    0.09465477f, 0.29313436f, 0.12126107f, -0.10221927f, 0.13966967f, 0.01695548f, 0.01159798f, 0.01371132f, 
    -0.01780568f, -0.01380240f, -0.11143211f, -0.02423711f, -0.02368484f, 0.20010191f, -0.00112370f, 0.00385421f, 
    0.09146256f, 0.06785871f, -0.00594309f, -0.05890285f, -0.06693655f, 0.05077067f, -0.03697797f, -0.11866343f, 
    0.16841418f, -0.18493918f, 0.13174658f, 0.27483970f, -0.16250592f, 0.01221766f, 0.02333513f, 0.01550910f, 
    -0.08205739f, 0.05714372f, 0.06126951f, -0.10620660f, -0.09005816f, 0.22132090f, 0.05836162f, -0.10844139f, 
    0.11470199f, 0.00248796f, 0.09445379f, 0.04362452f, -0.06297506f, 0.02386592f, 0.03471946f, 0.00075426f, 
    0.02937315f, 0.26750198f, -0.08461672f, 0.17298487f, -0.07507505f, 0.01591794f, -0.02301789f, -0.12938166f, 
    0.03514665f, -0.11466885f, -0.05249525f, -0.12147481f, -0.27739325f, -0.07347178f, 0.17628659f, 0.20163159f, 
    0.14395888f, 0.05482738f, -0.04018464f, 0.02186825f, -0.04474473f, -0.02799772f, 0.00134563f, -0.03029987f, 
    0.17497218f, 0.26929367f, -0.23983882f, 0.03554442f, 0.01150716f, 0.02090183f, -0.02749818f, -0.09459279f, 
    0.00672648f, 0.01817036f, 0.13061160f, -0.03092405f, -0.21550173f, 0.29946664f, -0.11859789f, 0.22952482f, 
    -0.04756390f, -0.01750126f, -0.03466052f, -0.04040379f, -0.02144183f, 0.02982276f, -0.02303537f, -0.00039858f, 
    0.25434887f, -0.10605309f, 0.07817137f, 0.08510009f, 0.06950508f, -0.12020444f, -0.02049899f, -0.03030247f, 
    -0.00242550f, -0.02758330f, 0.03027605f, 0.08957743f, -0.07212781f, -0.02014426f, -0.17994909f, -0.05228259f, 
    0.03678909f, -0.06100430f, 0.00271251f, -0.03209680f, -0.14676189f, -0.05611321f, 0.13889113f, 0.06762443f, 
    -0.26466161f, 0.18922116f, 0.04523854f, -0.18404341f, -0.05724620f, 0.03047093f, -0.06534363f, 0.08719786f, 
    0.06706131f, 0.00781095f, -0.00592368f, -0.10465758f, -0.15976468f, 0.06215424f, 0.01128553f, -0.03117686f, 
    0.13247281f, 0.06197732f, 0.02066982f, 0.00350056f, 0.06940074f, -0.01137532f, 0.00066946f, 0.05832049f, 
    -0.07717378f, 0.30338347f, 0.05085532f, -0.00176342f, 0.04065830f, -0.00345822f, -0.01293680f, 0.06266693f, 
    0.08965262f, 0.09291121f, 0.07664725f, -0.01498985f, -0.05767372f, 0.18897127f, 0.15832317f, 0.20441227f, 
    0.01503363f, -0.08160549f, -0.01256259f, 0.08577529f, 0.02047881f, -0.01398633f, -0.03779530f, 0.06886461f, 
    -0.05290164f, -0.02535422f, 0.06774138f, -0.04481270f, 0.07760780f, -0.08697907f, 0.04704756f, -0.07301981f, 
    0.03124087f, -0.01879074f, 0.16494599f, -0.01688800f, 0.11054838f, 0.00394186f, -0.07547490f, 0.28784287f, 
    -0.00394839f, 0.11550356f, -0.06449503f, 0.06392172f, -0.01267154f, -0.09970091f, -0.10635081f, 0.06590085f, 
    0.09223399f, -0.07892745f, -0.06193884f, -0.32119474f, -0.02117453f, -0.01817849f, -0.12149715f, -0.10583180f, 
    -0.01040189f, -0.07426611f, -0.05404415f, 0.07061246f, 0.03319427f, 0.07950120f, 0.20811905f, -0.04831931f, 
    0.11844273f, -0.00686460f, -0.01083591f, 0.05492663f, 0.07553472f, 0.04728425f, -0.10875646f, 0.09462015f, 
    -0.18059939f, -0.08909293f, -0.15432727f, 0.10947595f, -0.03735453f, 0.02618401f, -0.13017987f, 0.02134073f, 
    0.10203449f, 0.03421832f, -0.00825266f, 0.02034861f, -0.03117700f, -0.05372705f, 0.07411562f, 0.02228513f, 
    -0.05642189f, 0.02723357f, 0.00034490f, -0.04293100f, -0.00822886f, 0.02231996f, -0.10971427f, 0.12536654f, 
    0.04997570f, 0.06464390f, -0.14055479f, 0.10706948f, -0.00073082f, -0.03808304f, 0.00403046f, -0.10545576f, 
    0.11903385f, 0.04616461f, -0.05286353f, 0.05128358f, -0.02676006f, 0.10320765f, 0.16007221f, 0.20440261f, 
    0.03786379f, 0.02125822f, 0.16042739f, 0.12461307f, 0.02314770f, -0.01602614f, 0.04587578f, -0.03106003f, 
    -0.30947372f, 0.02612867f, 0.00035260f, -0.22414678f, -0.03540712f, 0.00252200f, 0.00158593f, -0.06779139f, 
    0.05719356f, 0.00340422f, -0.03719051f, -0.02504718f, -0.16047421f, 0.18912943f, 0.13396391f, -0.16964638f, 
    -0.03921964f, -0.16221911f, 0.03258478f, -0.05293441f, 0.13568294f, -0.02631535f, 0.01559678f, 0.06746502f, 
    0.26088431f, 0.20609742f, 0.20065631f, 0.37422168f, -0.00052744f, 0.06610661f, 0.03880355f, -0.09362926f, 
    -0.04286643f, -0.02109112f, -0.05469129f, 0.14198722f, -0.15173276f, -0.16475172f, 0.17033534f, -0.18016131f, 
    -0.05698096f, -0.00930048f, 0.04102937f, -0.03296342f, 0.03268556f, -0.11015266f, 0.16341931f, 0.10974782f, 
    -0.05784773f, 0.17764090f, 0.14701296f, 0.15214005f, 0.02740167f, -0.07395516f, -0.06172777f, -0.04117513f, 
    0.16236402f, 0.05302411f, 0.04294218f, 0.01978222f, 0.27033952f, 0.06936380f, 0.11349172f, 0.17810336f, 
    -0.00550839f, -0.02632931f, 0.01821714f, 0.02554621f, -0.02406312f, -0.04359788f, 0.05336666f, -0.09905646f, 
    -0.19245705f, 0.08690865f, -0.02149454f, 0.00284849f, 0.01657485f, 0.13442554f, 0.01733517f, 0.05461304f, 
    -0.01104339f, 0.03789271f, -0.04074916f, 0.06798559f, 0.22843996f, 0.10624813f, -0.18880937f, 0.07959112f, 
    0.09707894f, 0.04554538f, -0.05189785f, -0.06959499f, 0.07385018f, 0.06319144f, 0.01965856f, -0.11669208f, 
    -0.31286225f, -0.05439555f, 0.10932687f, 0.13221319f, 0.05207543f, -0.15285140f, 0.00235825f, 0.17499624f, 
    0.01875731f, -0.10340483f, 0.00784137f, 0.11839610f, 0.23342538f, -0.12619616f, -0.23398222f, -0.12879664f, 
    0.06285539f, 0.01795493f, 0.14788008f, 0.06756343f, -0.01093768f, 0.03966114f, 0.02847986f, -0.03689425f, 
    -0.15045246f, 0.14876090f, 0.14672719f, -0.09078472f, -0.01676060f, -0.03075015f, 0.01324575f, -0.09189226f, 
    0.02028536f, 0.03716424f, 0.01710512f, -0.16403230f, -0.02817316f, -0.01405478f, 0.07635182f, -0.05912234f, 
    -0.00453648f, 0.17023097f, 0.00235482f, -0.02365641f, -0.08003405f, -0.06933613f, 0.03498700f, 0.04805502f, 
    -0.14622509f, -0.09031042f, -0.18768404f, -0.15964799f, 0.15039930f, -0.01579188f, 0.13602869f, -0.03476912f, 
    0.04510456f, -0.02701863f, 0.06245366f, -0.00583645f, 0.08736034f, 0.01922363f, -0.08161463f, -0.07418625f, 
    -0.01421127f, -0.06283505f, 0.07688954f, -0.00261033f, -0.02131696f, 0.04604594f, 0.00385643f, 0.17639671f, 
    -0.08467987f, -0.01265788f, 0.14108330f, 0.05713182f, 0.01276414f, 0.11248003f, 0.07684453f, 0.08462505f, 
    0.07525434f, 0.03004945f, 0.15588230f, 0.07579086f, -0.02868311f, -0.04244396f, -0.07814985f, -0.16970673f, 
    -0.02393523f, 0.05564477f, -0.01184126f, 0.01205790f, -0.07359162f, -0.09659465f, 0.16889155f, -0.03592439f, 
    -0.05843255f, 0.05065263f, 0.10858115f, -0.05774533f, 0.00470252f, 0.07724822f, 0.09858128f, -0.01825958f, 
    -0.03906751f, -0.06704807f, -0.07088356f, 0.04461261f, 0.21909620f, -0.01379193f, -0.06067832f, 0.23933227f, 
    0.01344310f, -0.00313451f, 0.06348962f, -0.01229004f, 0.04794882f, 0.00469757f, 0.05676638f, 0.06866696f, 
    0.22920829f, 0.10632458f, -0.02102093f, -0.01196998f, 0.02031581f, -0.02142794f, 0.03154068f, -0.00873422f, 
    -0.11810453f, 0.02318195f, -0.02598801f, -0.04539950f, -0.31011891f, 0.06567917f, 0.21387826f, -0.06942064f, 
    -0.05181986f, -0.04958977f, 0.09824447f, -0.11499073f, 0.07759912f, 0.04391286f, 0.10280733f, -0.05509668f, 
    -0.21324462f, 0.15649065f, 0.08441131f, 0.21725819f, -0.04419824f, 0.01512091f, 0.03776393f, 0.02952857f, 
    0.12426763f, 0.06484887f, 0.01350710f, -0.10015710f, -0.16439576f, 0.07970414f, 0.05208018f, -0.18780491f, 
    0.02381571f, -0.09421115f, 0.02386667f, -0.01756965f, 0.14585026f, 0.03867701f, -0.07443931f, -0.00433682f, 
    -0.22593980f, 0.07878945f, -0.06883284f, 0.02602673f, 0.11730601f, 0.19729908f, -0.08889629f, -0.13141540f, 
    0.00555433f, 0.01184764f, 0.02494216f, 0.07826996f, 0.03353100f, -0.07708037f, -0.06758222f, -0.20584305f, 
    0.03331134f, 0.03966495f, -0.08641962f, -0.06902062f, 0.01724422f, -0.03784788f, -0.06769080f, 0.01446161f, 
    -0.01381237f, -0.08629190f, 0.11877673f, 0.22426358f, 0.04821576f, 0.04626765f, -0.09752872f, 0.02355247f, 
    0.15128729f, -0.02271764f, -0.10010207f, -0.07349250f, 0.56664115f, -0.30129659f, -0.19651867f, -0.02655163f, 
    0.20231503f, -0.03390170f, -0.08300734f, 0.01474374f, -0.00962755f, 0.00217738f, -0.00056977f, 0.04085312f, 
    0.17332932f, 0.02424863f, 0.07066775f, 0.20535576f, 0.02291413f, -0.03191729f, 0.03010580f, 0.01272749f, 
    0.07239335f, 0.00579399f, -0.05984365f, 0.03113644f, -0.00273733f, 0.16730370f, 0.21618702f, 0.08481375f, 
    -0.04871137f, 0.03673324f, -0.00947501f, 0.01290083f, 0.08637202f, 0.01181558f, -0.00485911f, -0.03994660f, 
    0.03700850f, 0.13822183f, 0.16058069f, -0.01724564f, -0.00290644f, -0.04865360f, 0.16235019f, -0.03780805f, 
    0.08442428f, 0.05559628f, 0.09733735f, 0.05014461f, -0.06997053f, 0.00570021f, 0.16334194f, 0.32794306f, 
    -0.08986789f, 0.00193405f, 0.15115923f, -0.14822695f, 0.04737429f, 0.14845493f, -0.02938127f, -0.05665956f, 
    0.15647350f, 0.04840672f, 0.08598956f, 0.00756785f, 0.05564245f, -0.03194971f, -0.01557646f, 0.06009505f, 
    0.01153704f, 0.04471188f, -0.07013752f, 0.16591513f, -0.25345677f, 0.00425830f, -0.11526163f, -0.11834004f, 
    0.03954148f, 0.05420186f, 0.05988086f, 0.01770286f, 0.04993409f, 0.16835120f, 0.07175401f, 0.08326523f, 
    0.05447447f, -0.06570475f, -0.00474532f, 0.06386097f, -0.01138205f, 0.06377210f, -0.06578805f, -0.03103054f, 
    0.05593159f, 0.00760345f, 0.16312928f, 0.08219430f, -0.06873509f, 0.14135540f, 0.12039456f, 0.04737568f, 
    0.01306206f, -0.18977901f, 0.05163122f, -0.09489141f, 0.04314122f, -0.05145926f, -0.01637424f, 0.01697394f, 
    0.11513715f, 0.06573313f, -0.08899646f, -0.19638363f, 0.01161337f, 0.04825517f, 0.07970838f, -0.00286680f, 
    0.01129718f, 0.00987094f, -0.04343202f, 0.15769354f, -0.11227019f, 0.14052169f, 0.10705607f, 0.06701446f, 
    0.03239276f, 0.04334873f, 0.10744458f, -0.01985339f, 0.00461903f, 0.07724611f, -0.02009793f, -0.07347716f, 
    -0.05713131f, -0.18668202f, -0.01614766f, -0.13546772f, -0.00414482f, 0.01373050f, -0.03058739f, -0.07109544f, 
    0.02498184f, -0.05186315f, -0.04258490f, -0.08471456f, -0.22227184f, -0.01558646f, 0.08607699f, -0.06236891f, 
    0.01269009f, -0.07352224f, -0.01306056f, -0.03657049f, -0.04780717f, -0.06976892f, 0.00487027f, -0.02826037f, 
    -0.12481586f, 0.11975251f, 0.02187132f, -0.00823849f, 0.12000083f, -0.07680498f, 0.02439081f, -0.01038814f, 
    -0.06883501f, 0.11824994f, 0.05188975f, 0.14640473f, 0.08500779f, -0.00880946f, 0.22902276f, 0.06243534f, 
    -0.18574393f, 0.03120601f, 0.02122519f, 0.12260033f, 0.08279470f, 0.03845588f, -0.12602220f, 0.00114114f, 
    -0.21162982f, 0.08653063f, -0.00483218f, -0.07873022f, -0.02784113f, -0.11844363f, 0.03455124f, -0.06942032f, 
    -0.02340038f, -0.11182790f, 0.03600031f, 0.10514234f, 0.11398848f, 0.12346821f, 0.13710696f, 0.00628340f, 
    0.06474897f, -0.02691975f, -0.09123357f, -0.06092208f, 0.06857971f, 0.00769554f, 0.05346379f, -0.04522351f, 
    -0.29709896f, 0.24613443f, -0.17354041f, 0.00791019f, 0.14160575f, -0.04227612f, 0.02130404f, -0.04233135f, 
    0.02872092f, 0.06976559f, -0.00517215f, 0.03610682f, -0.34804556f, -0.02038170f, -0.18489331f, -0.07959585f, 
    0.07673832f, -0.04835193f, -0.03483415f, -0.10410837f, -0.01215739f, 0.14219423f, 0.04449974f, 0.01626035f, 
    0.04367087f, -0.17755111f, 0.17569177f, 0.24912582f, -0.13689332f, 0.05424638f, -0.01784955f, 0.08805502f, 
    -0.02387457f, 0.00483617f, -0.03418988f, 0.09123122f, -0.07155697f, 0.10340055f, 0.06835204f, -0.09821393f, 
    0.15434343f, -0.05480652f, -0.04033995f, -0.04048746f, 0.07420342f, -0.09762200f, 0.01550373f, 0.02812683f, 
    -0.06534618f, 0.04189504f, -0.06160885f, -0.06812445f, 0.04976689f, 0.08612085f, 0.10092710f, -0.00870275f, 
    0.09635249f, -0.00776085f, 0.01145484f, 0.05478493f, -0.02765322f, 0.10809572f, 0.01748274f, -0.16198684f, 
    0.08111002f, 0.16657130f, 0.10052527f, -0.04189727f, -0.11949827f, -0.06403436f, 0.01755360f, -0.00428428f, 
    -0.03815632f, -0.02134223f, -0.18584915f, 0.02620956f, 0.01544992f, 0.01451609f, -0.07868783f, -0.05027764f, 
    -0.02561342f, 0.03061077f, 0.03046880f, -0.04593445f, 0.10521349f, 0.25101408f, 0.03028334f, 0.32760468f, 
    -0.03339115f, 0.10307959f, -0.00307248f, 0.03083339f, 0.05084249f, 0.06083951f, -0.01289638f, 0.13241132f, 
    -0.12215711f, -0.09812156f, 0.13105471f, 0.09656943f, 0.06872138f, 0.06449092f, 0.03381563f, 0.02815660f, 
    0.03822907f, -0.02899413f, 0.06328356f, 0.07155725f, -0.12233639f, -0.17123377f, 0.02281677f, 0.18304525f, 
    0.02099022f, 0.01470754f, -0.14228043f, 0.00785766f, -0.20782740f, 0.02543432f, 0.13811171f, 0.04724639f, 
    0.00054696f, 0.17043887f, 0.12566274f, -0.08338931f, 0.02734583f, -0.03815695f, 0.02100789f, 0.14425084f, 
    0.06157743f, -0.11942952f, -0.00261854f, 0.05264992f, 0.02050277f, -0.09398992f, -0.00157113f, 0.00871580f, 
    0.12349255f, 0.18838868f, 0.05244778f, 0.06935550f, -0.02249314f, -0.06265839f, 0.13421679f, 0.10406459f, 
    0.26347521f, 0.22152793f, 0.12952709f, -0.01077458f, 0.03350882f, 0.05529937f, 0.02416777f, 0.01033097f, 
    0.13382818f, 0.02950993f, 0.11057831f, 0.11092682f, -0.04864066f, 0.09725562f, -0.26114357f, -0.04119428f, 
    0.00911307f, 0.03184670f, -0.02164571f, -0.09787549f, 0.09714991f, 0.02599793f, -0.03710901f, -0.00356375f, 
    0.00064636f, -0.00355941f, -0.03205631f, -0.03624708f, -0.02781633f, -0.02987516f, 0.00123258f, 0.01864146f, 
    -0.02577776f, -0.01947035f, 0.02290736f, -0.02247587f, -0.00118940f, -0.03069535f, -0.01377273f, 0.01601904f, 
    -0.03241383f, -0.00109328f, -0.02898982f, -0.00099811f, 0.01348211f, -0.02081975f, 0.02952266f, -0.02290889f, 
    0.01894728f, -0.00149200f, 0.03399282f, 0.03661613f, -0.02795146f, -0.03188045f, 0.00698924f, -0.03459871f, 
    -0.04226535f, 0.02347242f, 0.01367177f, -0.03111775f, -0.02760435f, 0.02725559f, -0.02275952f, 0.00056894f, 
    -0.01481190f, -0.02286479f, 0.02921045f, 0.00607442f, 0.02945970f, 0.02127368f, -0.01072544f, -0.02950612f, 
    0.02869501f, 0.00227650f, 0.02353323f, -0.03985905f, 0.01755472f, 0.00498296f, -0.01329094f, -0.01085312f, 
    -0.00534792f, 0.02833963f, 0.03004235f, -0.03158718f, 0.00712195f, -0.00355791f, -0.03775045f, -0.00774771f, 
    -0.00015503f, 0.01973334f, 0.01227690f, 0.00163624f, 0.00673261f, -0.02745011f, 0.01457858f, -0.03203674f, 
    -0.04587334f, -0.03924408f, 0.00115502f, 0.01571014f, -0.00281663f, -0.03673809f, 0.01952166f, -0.00929758f, 
    0.01489746f, -0.02296960f, 0.01164690f, -0.01622901f, 0.01869472f, -0.02854592f, 0.01269980f, -0.01548395f, 
    -0.01491149f, 0.00936397f, -0.02079534f, 0.00768611f, 0.00123139f, -0.00965702f, -0.03568326f, 0.03241409f, 
    -0.01289841f, 0.01933081f, 0.02960941f, -0.00445236f, 0.02210032f, -0.00713986f, -0.01845834f, 0.02028217f, 
    0.01183575f, -0.04454261f, -0.03818935f, -0.02223732f, 0.00189402f, -0.02976293f, 0.00864242f, -0.02754374f, 
    0.00757864f, 0.03352340f, 0.01386765f, -0.00661644f, -0.00230423f, -0.04296531f, -0.01592687f, 0.01926417f, 
    -0.03737663f, -0.00386154f, -0.03925183f, -0.00450033f, 0.01045491f, -0.02405450f, -0.00999643f, 0.00436905f, 
    0.02603569f, 0.01715379f, -0.00642982f, -0.02904398f, -0.01531565f, -0.01432366f, -0.03632578f, 0.01637072f, 
    -0.01211791f, 0.00002054f, 0.02026025f, -0.01456033f, -0.03161178f, 0.02754086f, -0.00621149f, 0.00921264f, 
    0.00922197f, 0.01804289f, -0.01540666f, -0.00442641f, -0.01610627f, -0.00639324f, 0.01735510f, -0.01430991f, 
    -0.02784155f, 0.00522628f, -0.00805772f, -0.02133863f, -0.02585937f, -0.02461498f, -0.00998940f, 0.03226330f, 
    -0.01030051f, 0.00060559f, -0.00276708f, 0.00663509f, -0.03092082f, -0.00206407f, 0.01803423f, -0.02276371f, 
    -0.00561256f, 0.02939411f, -0.01465974f, 0.02009882f, -0.02532951f, 0.02549542f, 0.02718218f, 0.00495395f, 
    -0.00068907f, -0.03121919f, -0.02901556f, -0.01396877f, -0.04631462f, -0.03905081f, 0.00578038f, 0.00351989f, 
    0.01685593f, -0.01575583f, 0.00581688f, 0.03099693f, -0.00079778f, -0.03887870f, 0.02108135f, -0.01606414f, 
    -0.03426740f, -0.02418154f, -0.00385706f, -0.00097713f, -0.00776601f, 0.03290068f, -0.02739564f, 0.03211817f, 
    0.01280195f, 0.03135744f, -0.02792460f, 0.00739121f, 0.01126101f, -0.01393150f, -0.01885940f, -0.01918978f, 
    0.02052285f, -0.00152862f, -0.00980259f, -0.02412417f, 0.02126197f, -0.03214565f, 0.03895561f, 0.01688383f, 
    0.03459024f, -0.02358010f, 0.02077184f, -0.00734147f, 0.02840203f, -0.00949021f, 0.02288917f, 0.00647532f, 
    -0.01524475f, -0.02645176f, 0.01615396f, -0.01829869f, -0.02266978f, -0.02634486f, 0.01633758f, -0.02570536f, 
    0.02223438f, -0.00494584f, -0.00815005f, -0.00077278f, -0.02525615f, 0.01066370f, 0.02404607f, 0.01658244f, 
    0.00245242f, 0.02534300f, -0.03135877f, 0.00730642f, 0.00798275f, -0.00689172f, -0.03508171f, -0.02104319f, 
    -0.01706675f, 0.01827275f, -0.03978683f, 0.02517510f, -0.02604734f, -0.01102805f, -0.00696542f, -0.03736970f, 
    0.02757914f, -0.02770128f, -0.02477100f, -0.02084210f, -0.03871394f, -0.01199512f, 0.03014376f, 0.02185391f, 
    -0.03769367f, -0.02870283f, -0.01727735f, 0.01831244f, -0.01573820f, 0.02018526f, 0.01268946f, 0.00697364f, 
    0.01809249f, -0.01411088f, 0.01625297f, -0.00144228f, -0.02793401f, -0.03749302f, -0.02896564f, -0.00021366f, 
    -0.00788038f, -0.02233187f, 0.00460820f, 0.01795128f, 0.00839066f, -0.00354522f, -0.01541494f, 0.02331156f, 
    -0.01124381f, -0.00249887f, -0.00946924f, -0.01057915f, 0.00459517f, -0.02376694f, -0.02790084f, -0.02953029f, 
    -0.00785478f, -0.02530708f, 0.00228296f, -0.01087973f, -0.01058440f, -0.00088863f, -0.03296678f, -0.04118407f, 
    0.01648098f, 0.02699913f, 0.03069674f, -0.02159707f, -0.02917829f, 0.01632731f, 0.01494951f, 0.02651814f, 
    -0.03055352f, 0.00151337f, 0.03004224f, -0.04037557f, 0.02638779f, 0.03029667f, -0.01898174f, 0.00084513f, 
    -0.01269473f, -0.00627640f, 0.00989194f, 0.03026622f, -0.00581200f, 0.03433543f, 0.00264231f, 0.02124939f, 
    -0.01501925f, 0.00049862f, -0.04171289f, 0.00620943f, -0.00390074f, -0.02006755f, -0.03455603f, 0.00899413f, 
    -0.00056780f, 0.01645292f, -0.02538182f, 0.01517337f, 0.02554204f, 0.00661217f, 0.00432814f, -0.02539220f, 
    -0.00783037f, 0.01738427f, -0.03134565f, 0.02043425f, 0.02146273f, 0.00110701f, 0.00827145f, 0.02968377f, 
    -0.01314093f, -0.02585094f, -0.00989044f, 0.02431081f, -0.03035178f, -0.00437192f, -0.03433383f, 0.01466629f, 
    0.03417620f, -0.00399328f, 0.01012196f, -0.03305515f, -0.01862335f, -0.03465013f, -0.02381940f, -0.02837820f, 
    -0.00721785f, 0.03012730f, 0.03174580f, 0.00869395f, -0.02703213f, 0.02665986f, 0.02457582f, 0.03227833f, 
    -0.00359163f, 0.01682074f, 0.01363137f, 0.03165277f, 0.00221116f, -0.02913119f, -0.03730030f, -0.02488997f, 
    0.01997172f, 0.00104039f, -0.02253192f, -0.03125660f, -0.02212910f, 0.00979582f, -0.02957000f, 0.02261588f, 
    0.01016966f, -0.01898680f, -0.02868637f, 0.01469585f, -0.03845093f, -0.01449098f, -0.03838232f, 0.00947175f, 
    -0.01993938f, 0.01003584f, 0.00347518f, 0.03075610f, -0.00271239f, 0.01768087f, -0.01864628f, 0.01644792f, 
    0.01233012f, 0.03344407f, -0.01277004f, -0.02604000f, -0.02296342f, -0.00312251f, -0.02729695f, -0.04645302f, 
    0.00283037f, 0.02148008f, -0.02502222f, -0.01596043f, -0.04173974f, 0.00943891f, -0.01124197f, -0.04619387f, 
    0.01629282f, 0.03156625f, -0.04272856f, -0.00292129f, -0.00189453f, 0.02154944f, -0.00377919f, 0.01972444f, 
    -0.00057138f, -0.01584780f, 0.02472435f, -0.00407184f, -0.01115229f, -0.00894729f, -0.03085916f, 0.00133726f, 
    -0.01376441f, 0.03107497f, -0.03346662f, -0.02233282f, -0.02282751f, 0.03321007f, 0.01569596f, 0.02347324f, 
    0.00632945f, -0.00107691f, -0.02337190f, -0.01082096f, 0.02792401f, -0.01946601f, -0.01046562f, -0.01221299f, 
    -0.00113465f, -0.03546454f, 0.02465102f, -0.02937401f, -0.00082574f, -0.01860473f, -0.02406138f, -0.00916545f, 
    -0.02465966f, -0.00278135f, -0.02389391f, 0.00768845f, -0.01529961f, -0.00179475f, -0.02352156f, -0.00983357f, 
    -0.03651023f, -0.03057502f, 0.00097965f, 0.00182686f, 0.01489029f, 0.00228529f, -0.03449586f, -0.02734080f, 
    -0.01145639f, -0.01960932f, 0.00626339f, 0.00522804f, 0.01953961f, -0.02366354f, -0.03580908f, -0.02921514f, 
    -0.02757637f, -0.02137329f, -0.03219445f, -0.01020674f, -0.03476638f, -0.00879783f, -0.02238694f, 0.03266546f, 
    0.02528022f, -0.02754163f, 0.00904808f, 0.03064017f, -0.00572771f, -0.01324872f, -0.00255208f, -0.00831713f, 
    -0.00774042f, 0.00654206f, 0.00698404f, -0.00333553f, -0.01523665f, 0.02771335f, 0.01752113f, 0.02404986f, 
    -0.03596143f, -0.01225961f, -0.02814634f, -0.02593229f, -0.01634769f, -0.02416840f, 0.02302294f, -0.02771558f, 
    0.02342579f, 0.01533529f, 0.00536821f, 0.01864245f, 0.03138690f, -0.03338206f, -0.02372315f, 0.01051085f, 
    -0.01350755f, 0.00301907f, 0.00463121f, -0.01090518f, -0.00686665f, -0.00373117f, 0.01608686f, -0.02229084f, 
    -0.03658580f, -0.00404048f, -0.01841420f, -0.01402397f, -0.02503506f, -0.00376646f, 0.02417972f, -0.02845507f, 
    -0.02330321f, 0.00718830f, -0.00838346f, -0.02860199f, -0.03598079f, -0.02432532f, 0.00959532f, -0.02755115f, 
    -0.00210792f, 0.00978738f, 0.04303631f, -0.01679857f, -0.00266929f, -0.00692130f, 0.00878102f, 0.00558341f, 
    0.01330650f, -0.02752275f, -0.00760069f, 0.01723305f, -0.00200964f, 0.00359435f, 0.00037934f, -0.01133403f, 
    -0.02635103f, 0.01695328f, -0.00780214f, -0.00068758f, -0.03716999f, 0.00059591f, -0.03797730f, -0.03176182f, 
    -0.02021304f, 0.00396999f, -0.02269037f, -0.00125383f, 0.02835845f, 0.01803201f, -0.00878510f, -0.00736706f, 
    0.00391584f, -0.02954373f, 0.01669936f, -0.03146007f, -0.03315111f, 0.01647842f, -0.03824055f, 0.00646820f, 
    0.03310316f, 0.01555114f, 0.02579454f, 0.01367625f, -0.02106412f, 0.00858716f, -0.00353745f, 0.00588849f, 
    -0.03935375f, 0.02695920f, -0.02003595f, 0.00002703f, 0.00597767f, -0.04510270f, -0.03753614f, -0.02439378f, 
    0.01247124f, -0.03146516f, 0.03318501f, -0.00207666f, -0.00611414f, -0.02767538f, -0.03182721f, -0.00853844f, 
    0.02337512f, -0.00857010f, 0.01756955f, 0.01122385f, -0.03122467f, 0.00811823f, -0.02086111f, -0.01074719f, 
    -0.00477652f, -0.00318816f, -0.04554946f, -0.00279047f, -0.00448588f, 0.01531487f, 0.00248172f, -0.03292779f, 
    0.03489559f, -0.01064524f, 0.02927615f, -0.01206323f, 0.02031451f, 0.00321953f, -0.01783188f, 0.03389747f, 
    0.00974073f, -0.03384520f, 0.01967127f, 0.01871020f, -0.00571266f, -0.02784053f, -0.00475408f, -0.02615453f, 
    -0.01576098f, -0.02633499f, -0.04164833f, 0.01071112f, -0.02792067f, -0.03684662f, -0.02008955f, 0.00113479f, 
    -0.01459808f, 0.02713089f, 0.01328862f, -0.02395752f, 0.00541396f, -0.01632605f, -0.01248597f, 0.01014297f, 
    -0.00199984f, 0.02041381f, -0.01716902f, -0.00721552f, 0.03121157f, 0.02758053f, 0.03098190f, -0.02088935f, 
    -0.04199916f, -0.01453439f, 0.00645858f, -0.01406257f, 0.01664280f, -0.03124608f, -0.03841811f, 0.00717523f, 
    0.00372667f, -0.00579329f, 0.02366078f, -0.01862392f, -0.03773632f, -0.00302452f, -0.02732282f, -0.03167496f, 
    -0.02937138f, -0.01212347f, -0.02157825f, -0.02817045f, -0.00926776f, -0.02149878f, -0.00400345f, -0.01046455f, 
    0.00944420f, -0.00343113f, -0.02406067f, -0.04724438f, -0.00681548f, 0.02919072f, 0.01042586f, -0.00334187f, 
    -0.02097681f, 0.01539928f, -0.01705446f, 0.02804173f, 0.02066333f, 0.01047429f, -0.01959009f, -0.01186814f, 
    0.01699199f, -0.00721443f, -0.03122327f, -0.03921992f, 0.02617673f, -0.01679070f, 0.02776960f, -0.01121764f, 
    -0.02243853f, -0.02848740f, -0.03821377f, 0.02424435f, -0.03234022f, 0.00481848f, -0.01308658f, -0.00692025f, 
    -0.01085259f, 0.02529283f, -0.01441163f, -0.00118216f, 0.01452218f, -0.02894737f, -0.03499107f, 0.00849480f, 
    0.00759908f, 0.00584057f, 0.02137471f, -0.02348569f, 0.02906734f, -0.03311170f, 0.00898110f, 0.01370678f, 
    0.01814568f, 0.01881084f, -0.02761307f, -0.00777171f, -0.03935337f, -0.02933694f, -0.03638702f, 0.02227498f, 
    -0.00316402f, -0.01346321f, 0.02177911f, -0.01788870f, -0.02025861f, -0.01766963f, -0.01251708f, 0.01579162f, 
    0.00073924f, -0.02742115f, -0.02028342f, 0.00057770f, -0.01314267f, 0.01219273f, -0.02379471f, -0.03650352f, 
    -0.00615620f, 0.02209030f, 0.01545500f, -0.00851171f, -0.01408839f, -0.01177151f, -0.00185585f, -0.00620705f, 
    0.00606944f, 0.00485532f, 0.01709058f, 0.00164429f, 0.02307209f, -0.04180547f, -0.02615176f, 0.00376376f, 
    -0.00552275f, 0.02544673f, -0.03764373f, -0.03219922f, -0.03762594f, -0.02259226f, -0.01974733f, -0.00377331f, 
    0.01767352f, -0.03790272f, 0.00623379f, 0.01591135f, -0.04154266f, -0.02704777f, 0.01905275f, 0.00330067f, 
    0.01920676f, -0.01266435f, 0.01228492f, 0.02817522f, 0.01191720f, 0.01802494f, -0.02974405f, -0.02225386f, 
    0.02450421f, -0.03627330f, -0.02817493f, 0.00114192f, 0.02225005f, -0.02934643f, -0.02859197f, -0.00886702f, 
    0.00555894f, -0.01384983f, -0.01378771f, -0.01514725f, 0.02787646f, -0.01775296f, 0.01890599f, -0.03249031f, 
    -0.03054348f, -0.01715163f, -0.02064298f, 0.00802727f, -0.04060008f, -0.04516881f, -0.00342258f, -0.00015800f, 
    0.01420094f, -0.03522832f, 0.02377424f, 0.02313855f, 0.02194726f, 0.01132140f, -0.03781958f, -0.03069238f, 
    -0.00217910f, -0.04501159f, -0.02678673f, -0.03369418f, 0.02351454f, -0.00427233f, -0.04367599f, 0.01864695f, 
    -0.02311047f, -0.01045265f, -0.02944041f, 0.01762778f, 0.02999015f, -0.00854500f, -0.03241122f, 0.00542084f, 
    0.02420228f, 0.00815464f, 0.00310957f, 0.00976954f, 0.02470856f, 0.00673322f, -0.03488973f, 0.02837358f, 
    -0.02612688f, 0.01875342f, 0.00262855f, 0.01487913f, 0.01161650f, 0.00963166f, -0.03595400f, -0.03907890f, 
    -0.02665094f, -0.00135015f, -0.01923121f, 0.02104331f, 0.00736983f, -0.01625177f, 0.01570375f, 0.01644642f, 
    0.01040863f, -0.00940323f, -0.03162164f, -0.01884070f, -0.03958771f, -0.00109003f, -0.01844118f, 0.02335817f, 
    -0.00603003f, -0.01708633f, 0.03282406f, -0.01675667f, -0.02930533f, -0.03879198f, -0.03047139f, 0.01929495f, 
    -0.04524189f, -0.00637238f, -0.00579300f, -0.04181050f, -0.01706735f, -0.02845391f, -0.00509488f, -0.03457693f, 
    0.00676757f, -0.01263124f, 0.00884072f, 0.00192158f, -0.02552200f, -0.02804944f, -0.02305797f, -0.01521789f, 
    -0.04028009f, -0.00076867f, -0.02841324f, -0.00659255f, -0.03952459f, -0.04429525f, 0.00462204f, 0.03249599f, 
    0.00394195f, -0.04741700f, 0.00835284f, -0.00772500f, -0.01312646f, 0.01215579f, -0.03876532f, -0.01873501f, 
    -0.00346914f, -0.00055645f, 0.00821438f, -0.03781924f, -0.01671541f, -0.00401297f, 0.02884456f, 0.01505879f, 
    0.01599901f, -0.03830279f, -0.02322067f, 0.01975454f, -0.03309984f, 0.01913625f, -0.00142073f, -0.00263941f, 
    -0.03044784f, 0.02103223f, 0.02013993f, -0.00127790f, -0.02217132f, 0.02471521f, -0.00018574f, -0.02290718f, 
    0.02386311f, -0.01200104f, -0.00154288f, -0.02337171f, 0.01995989f, 0.02446540f, -0.00572382f, -0.03223639f, 
    -0.02018182f, -0.00336336f, 0.03342864f, 0.01403038f, -0.01898385f, -0.03017948f, -0.00602939f, 0.01545750f, 
    0.01825065f, -0.02441419f, -0.03908314f, 0.01756702f, 0.02252051f, 0.00803490f, -0.01683622f, 0.00584735f, 
    -0.00419407f, -0.02955702f, 0.02059763f, -0.02221334f, 0.01728659f, 0.01540538f, -0.00288224f, -0.01508587f, 
    -0.02163481f, -0.02196953f, 0.02167035f, 0.01042842f, -0.01174239f, 0.00560814f, 0.00969680f, -0.00775733f, 
    -0.02677312f, -0.00918244f, -0.01908498f, 0.01785094f, -0.00591728f, -0.03165423f, -0.02425697f, 0.01737421f, 
    0.01515907f, -0.04376850f, -0.03298831f, -0.02740187f, 0.02528357f, -0.01311440f, 0.02595137f, 0.01002759f, 
    -0.03612817f, -0.00950244f, -0.03328909f, -0.00176214f, -0.00268176f, -0.01638633f, -0.01215703f, -0.03119261f, 
    -0.00083240f, 0.00121553f, -0.00040988f, -0.00416739f, -0.02852526f, -0.01966869f, -0.03558077f, 0.01282503f, 
    -0.03043327f, 0.01743050f, 0.00903260f, 0.00724844f, 0.01286936f, -0.02660930f, -0.03698409f, -0.00480078f, 
    -0.02027466f, -0.00885837f, -0.01858660f, -0.00762434f, -0.02604330f, 0.01945208f, 0.00032292f, 0.00715678f, 
    0.01091297f, -0.01370835f, -0.00944573f, -0.02725107f, -0.03557408f, -0.02452978f, 0.02862726f, -0.02396725f, 
    0.03293692f, 0.00299182f, 0.00657150f, 0.01932893f, -0.02968830f, 0.01600913f, 0.01358711f, 0.00030675f, 
    -0.00523430f, 0.02490781f, -0.02407061f, 0.01320895f, -0.01905916f, 0.00059116f, -0.02828515f, -0.01757342f, 
    0.00964968f, -0.00902379f, -0.03045782f, -0.00840933f, -0.00204934f, -0.03849236f, -0.00583865f, -0.01395200f, 
    -0.01657533f, 0.01210582f, 0.00111198f, -0.00350414f, 0.02238086f, -0.02926366f, -0.00651728f, -0.03883598f, 
    0.00974575f, -0.01309472f, -0.03068309f, -0.02896763f, -0.01358892f, -0.00743754f, -0.00274115f, -0.02659588f, 
    0.01234318f, 0.01334671f, -0.02961061f, -0.03087682f, -0.03623139f, -0.02585179f, 0.02327316f, 0.02286922f, 
    -0.02213042f, -0.04505860f, 0.01200065f, -0.00696917f, -0.01266634f, -0.03084759f, 0.00259371f, -0.01337661f, 
    -0.04145206f, 0.00593135f, -0.02425459f, -0.02730919f, -0.03725348f, -0.04425048f, -0.02929652f, 0.01583237f, 
    0.01867469f, -0.01124686f, 0.02698728f, -0.04394463f, 0.02590280f, -0.00911372f, -0.01282808f, 0.00673099f, 
    -0.01782397f, -0.04148613f, -0.01431890f, -0.03133287f, -0.03757915f, 0.01183415f, -0.01908571f, 0.02153422f, 
    0.00173354f, 0.02455288f, -0.03484729f, -0.02401247f, 0.00331426f, -0.04053208f, -0.02024353f, -0.01310802f, 
    0.03353258f, 0.01400810f, 0.02852939f, 0.00310625f, -0.04276560f, 0.01070333f, 0.00586519f, -0.00139707f, 
    0.02299405f, -0.02072102f, 0.01160108f, -0.03490560f, 0.01856929f, -0.00146113f, 0.01132881f, -0.03768308f, 
    -0.00016056f, -0.03851290f, -0.03525102f, 0.03560075f, 0.01403949f, -0.02290158f, -0.03105715f, -0.02603136f, 
    -0.01454741f, -0.00038655f, -0.02879952f, -0.02770073f, -0.02443815f, 0.02045839f, -0.00135112f, 0.01225198f, 
    0.01695537f, -0.01524989f, -0.00367492f, -0.00110936f, -0.00380925f, -0.03606184f, -0.00222187f, -0.02065889f, 
    0.02805010f, 0.01758335f, -0.02209916f, 0.01583459f, 0.03197742f, 0.00810857f, 0.01172587f, 0.03095370f, 
    -0.03851490f, -0.01461656f, -0.02919401f, 0.02207810f, 0.02412921f, 0.00278418f, 0.02352017f, -0.02043878f, 
    -0.02173555f, -0.00154399f, -0.02650949f, -0.01945777f, -0.03840770f, -0.04478393f, 0.00716780f, 0.01890141f, 
    0.00838572f, -0.02093289f, -0.02845735f, -0.01655856f, 0.03150907f, -0.00698992f, 0.02885647f, -0.01120844f, 
    0.00688539f, -0.02899755f, -0.02396366f, 0.01125687f, -0.02760307f, 0.01725077f, 0.01106005f, -0.00703277f, 
    -0.01204833f, 0.00234547f, -0.00789224f, -0.00123293f, -0.01129407f, 0.03551894f, -0.00771420f, 0.01268834f, 
    -0.00860020f, 0.00792868f, -0.03837699f, -0.02603933f, 0.01155168f, -0.02143830f, 0.00063369f, -0.02563526f, 
    -0.03878147f, 0.00764824f, -0.04072613f, -0.01326524f, -0.00971130f, 0.02769456f, 0.01407180f, 0.00646705f, 
    -0.00194132f, -0.00985596f, 0.02712909f, 0.02067709f, -0.01475313f, 0.00153259f, 0.00695703f, 0.02196668f, 
    -0.02359051f, 0.00624641f, 0.00910089f, 0.01998689f, -0.04484290f, 0.00139819f, -0.02404305f, -0.02107983f, 
    -0.03358285f, 0.02286070f, -0.02062241f, 0.00104329f, -0.02410837f, 0.02458691f, -0.00589879f, 0.01620255f, 
    0.00397591f, -0.00695120f, -0.01794245f, -0.02124259f, -0.02344423f, 0.01595110f, 0.00695968f, -0.01564699f, 
    -0.00954505f, -0.03024413f, -0.02583480f, 0.02229112f, -0.02838940f, -0.01439739f, 0.02927064f, -0.02717607f, 
    0.00963927f, 0.00328919f, -0.01258058f, -0.01842678f, -0.03034364f, -0.04169271f, -0.02797030f, 0.00073121f, 
    -0.01417569f, -0.00427114f, -0.01045515f, 0.02144998f, 0.02827892f, -0.02925002f, -0.00103031f, 0.02680450f, 
    0.01426991f, -0.02428255f, 0.00162320f, 0.00203179f, 0.02127937f, 0.02403233f, 0.00312223f, 0.03269646f, 
    0.01986416f, -0.01311230f, 0.00158850f, 0.00657183f, -0.01310634f, 0.01976566f, -0.00330966f, -0.02106029f, 
    0.02708261f, -0.01817285f, -0.01445704f, -0.03236115f, 0.00251100f, -0.02579451f, -0.03639300f, -0.04125350f, 
    0.01130074f, 0.00581575f, 0.00280042f, 0.01202311f, 0.02469208f, 0.02329480f, 0.01448062f, -0.02381637f, 
    0.02699354f, -0.02820531f, 0.02135260f, 0.00694850f, -0.01286537f, -0.02419633f, -0.02423480f, -0.01846680f, 
    -0.04196343f, -0.02288061f, -0.00616366f, -0.03511599f, -0.00641492f, 0.02106908f, 0.00786366f, -0.01272681f, 
    -0.01613455f, 0.02689818f, -0.01107115f, 0.00055664f, 0.00389299f, -0.01425114f, 0.00767445f, 0.02812426f, 
    -0.01985147f, 0.01221831f, 0.01364388f, -0.01936080f, 0.00810355f, -0.01294000f, 0.00846658f, 0.02363465f, 
    -0.00358295f, 0.02553195f, 0.00360340f, -0.02524807f, -0.00116911f, -0.02586925f, -0.03211044f, -0.01060259f, 
    -0.00735495f, -0.01935400f, 0.02175250f, 0.00029232f, 0.01925390f, -0.03479397f, -0.00170155f, -0.03094749f, 
    -0.01084755f, -0.00345127f, 0.02334177f, -0.03773746f, 0.02351364f, -0.02752169f, -0.04018021f, 0.01739112f, 
    0.00567737f, 0.01123727f, 0.00545797f, 0.01716560f, -0.04013836f, 0.00580218f, 0.02163219f, -0.00676021f, 
    0.00601141f, -0.02976890f, 0.02615575f, -0.03009599f, 0.01916026f, -0.03942395f, -0.00074666f, -0.03499109f, 
    0.00525817f, -0.04198665f, 0.01201768f, -0.02231966f, -0.00697924f, 0.02974828f, -0.03835532f, -0.02289407f, 
    0.00934400f, 0.03541407f, -0.01675657f, 0.02063154f, -0.02836086f, 0.02409418f, -0.00574412f, -0.02914251f, 
    0.00248374f, 0.01536325f, -0.02185011f, -0.02407325f, -0.03234364f, -0.03270827f, -0.03480972f, -0.00788642f, 
    -0.04483051f, -0.04464348f, 0.02478650f, 0.00473422f, -0.00660076f, 0.01933053f, 0.00263645f, -0.02912104f, 
    -0.00138969f, -0.03855268f, -0.00796480f, -0.02158717f, -0.00635465f, 0.02158067f, -0.01149493f, 0.02428274f, 
    -0.03614429f, 0.00655290f, -0.03005823f, -0.01163156f, 0.00557519f, -0.00262183f, 0.02084328f, -0.02360795f, 
    -0.01736192f, 0.01381454f, 0.03664723f, -0.01122487f, -0.02540191f, -0.02181104f, -0.00367152f, 0.00389213f, 
    -0.01070296f, -0.01308378f, -0.03706644f, 0.02156794f, -0.03221437f, -0.03148437f, 0.00125025f, 0.02388737f, 
    -0.02702161f, -0.00635360f, -0.04179917f, 0.01937409f, 0.03234784f, -0.00910570f, -0.01989969f, 0.01929220f, 
    -0.01080222f, 0.02317699f, -0.02163628f, -0.01369550f, 0.01412625f, -0.00817661f, -0.00791376f, -0.01823659f, 
    -0.01596770f, -0.02926828f, -0.03110383f, 0.01783400f, 0.00102085f, -0.01919316f, -0.03382811f, -0.02510154f, 
    0.00773119f, -0.03284903f, -0.00147834f, 0.00213382f, 0.00689905f, 0.02544634f, 0.02078718f, -0.03452393f, 
    -0.00747553f, -0.01529674f, -0.01196051f, 0.01249981f, 0.02754865f, -0.02344779f, 0.01591112f, -0.01664894f, 
    -0.02720390f, -0.02421057f, -0.00663462f, -0.02491927f, -0.04343178f, 0.02389462f, 0.00394466f, 0.02603099f, 
    -0.00124829f, -0.01167541f, -0.03679942f, -0.02531470f, -0.04194115f, -0.00898725f, 0.01202579f, -0.04053619f, 
    -0.02132023f, -0.04394584f, -0.01196177f, -0.03676026f, -0.01296713f, -0.01567413f, 0.00242070f, 0.02440789f, 
    0.01708128f, 0.00547512f, 0.01438189f, 0.02840842f, 0.00361243f, -0.03863879f, 0.00518837f, 0.01245467f, 
    0.00427653f, 0.08074165f, -0.03284047f, -0.15734364f, 0.13815004f, -0.08214471f, 0.03408132f, -0.11802600f, 
    0.01723578f, -0.05735537f, 0.16592261f, 0.07963225f, 0.28606817f, -0.00811005f, 0.12606004f, 0.26595086f, 
    -0.05556257f, -0.00509827f, 0.03316922f, 0.05626168f, -0.05453298f, -0.01883378f, -0.00839560f, 0.05555225f, 
    0.03357603f, -0.11334205f, 0.03572618f, 0.05937978f, -0.00815627f, 0.01918178f, -0.04082874f, -0.06157159f, 
    -0.00274906f, -0.08500709f, 0.01345498f, 0.01778489f, 0.05513705f, -0.07632333f, 0.06308194f, -0.04724059f, 
    0.11188685f, -0.01648716f, 0.07350738f, 0.20774610f, -0.07540794f, -0.02800885f, 0.00121579f, 0.00038606f, 
    -0.06539004f, -0.09853653f, 0.01140485f, 0.15247715f, -0.10947730f, 0.05615026f, -0.06615326f, 0.06270774f, 
    0.05297257f, 0.04182164f, 0.08163557f, -0.02729151f, -0.06054367f, -0.00636485f, 0.06372198f, -0.11474090f, 
    -0.00086493f, 0.05859619f, 0.00847978f, 0.03218396f, 0.04778557f, 0.08331150f, -0.11495835f, 0.03181826f, 
    0.02648131f, -0.05983891f, -0.05712356f, 0.19668271f, 0.07553396f, -0.02692017f, 0.05923701f, -0.04183706f, 
    0.00213495f, 0.04408343f, -0.05935560f, 0.03567621f, -0.09246087f, 0.26712057f, -0.01336624f, 0.04600434f, 
    0.07414959f, -0.04433589f, 0.12942968f, 0.07450721f, 0.00188021f, -0.12001523f, -0.05558423f, -0.00415899f, 
    -0.06498933f, 0.09111307f, -0.03101453f, -0.10222161f, -0.04801379f, -0.02371184f, 0.05235904f, 0.05171684f, 
    -0.04149275f, 0.05261149f, 0.02470558f, 0.00699950f, -0.02450177f, 0.05799970f, 0.09376604f, -0.09412166f, 
    -0.00088192f, -0.00747607f, 0.04352049f, 0.02731897f, 0.05836535f, -0.06703241f, 0.02308321f, 0.05743165f, 
    0.29360509f, 0.16611160f, 0.09182452f, 0.15120816f, -0.03199825f, 0.07456414f, 0.06093116f, -0.01091977f, 
    -0.05071072f, -0.01600190f, -0.05387363f, 0.10392398f, -0.00123990f, 0.19074143f, 0.00167287f, -0.05729019f, 
    -0.08920402f, 0.00797965f, 0.03919850f, 0.01431787f, 0.03858765f, -0.04916406f, 0.10920152f, 0.04499303f, 
    0.05490282f, 0.28523988f, 0.09425931f, -0.05423489f, 0.13839696f, 0.01488855f, -0.06465466f, -0.01787123f, 
    0.13556211f, 0.06172175f, 0.08324616f, 0.00844985f, 0.15548085f, 0.05012892f, 0.05376614f, 0.11798824f, 
    0.01425065f, 0.03103021f, -0.04235332f, 0.02542537f, 0.02784716f, -0.09595092f, 0.04344055f, -0.02854685f, 
    -0.33640441f, -0.11729587f, -0.02779147f, -0.20800363f, -0.06256135f, 0.09228241f, 0.09746421f, -0.05404872f, 
    0.05113753f, -0.02432574f, -0.01579431f, 0.06376328f, 0.20527726f, 0.01085184f, 0.04307147f, 0.21491374f, 
    0.07922862f, 0.11144958f, 0.01768391f, 0.01509756f, -0.02180632f, -0.02393596f, 0.00641985f, -0.01418249f, 
    -0.20384093f, -0.04397075f, 0.16214512f, 0.17002499f, 0.08073338f, -0.18438572f, 0.00336053f, 0.06899696f, 
    0.08152348f, -0.03567837f, -0.00850296f, 0.12436415f, -0.14354801f, 0.04393074f, -0.24932247f, 0.15128544f, 
    -0.01826647f, 0.02192635f, 0.05787710f, 0.05650565f, 0.05570595f, 0.00863092f, -0.05519374f, 0.01657647f, 
    0.01203190f, 0.03681559f, 0.08164829f, -0.04429787f, -0.06243097f, -0.02856019f, 0.00243104f, -0.03326890f, 
    0.02947365f, 0.02044735f, 0.03630849f, -0.05045852f, -0.35377368f, 0.16292964f, 0.10533716f, -0.03760961f, 
    -0.00014625f, 0.00098842f, 0.04881481f, 0.06770999f, -0.01436181f, -0.01569075f, 0.02685758f, 0.00426457f, 
    -0.07166208f, 0.12216714f, -0.16449971f, 0.05319037f, 0.17273994f, -0.06160904f, 0.03265433f, 0.03398914f, 
    0.03871640f, -0.08870238f, 0.02749753f, 0.04039782f, -0.13302113f, -0.13569824f, 0.17890090f, 0.15914574f, 
    0.00169929f, -0.01233693f, 0.02015981f, 0.00178783f, 0.05976607f, -0.02712874f, 0.04118229f, 0.13113745f, 
    0.05710399f, 0.10256170f, -0.06136270f, -0.07346547f, 0.02729841f, -0.03864674f, 0.02794592f, 0.08844156f, 
    0.01885323f, 0.04299565f, 0.01780203f, 0.01906519f, -0.15586969f, -0.14243697f, 0.13866593f, 0.10966022f, 
    -0.01609177f, -0.02210158f, -0.01028490f, -0.01754209f, -0.10349296f, -0.07076707f, 0.02637233f, -0.00297532f, 
    -0.06531686f, 0.18640238f, 0.01677594f, 0.04631526f, -0.03235165f, -0.02052473f, 0.15635158f, 0.04272765f, 
    0.11495519f, 0.00986649f, -0.05430338f, -0.06685667f, 0.19979768f, 0.11641860f, 0.13110912f, 0.13376176f, 
    0.01394091f, 0.00605656f, -0.00972364f, -0.09358484f, 0.12476645f, -0.01458842f, 0.01647113f, -0.00103241f, 
    0.16488540f, -0.01877383f, 0.10121715f, 0.10999682f, 0.03902873f, -0.02552166f, 0.00041575f, 0.01079143f, 
    -0.04570848f, 0.05989584f, -0.00810439f, 0.00875104f, -0.28165054f, 0.02146627f, 0.15926875f, -0.26865032f, 
    0.01871918f, -0.03114496f, 0.04665056f, -0.05248758f, 0.06201632f, 0.00580831f, 0.07157185f, 0.02204357f, 
    -0.12054674f, 0.02145668f, -0.04796697f, 0.01467456f, 0.01707640f, -0.00587285f, 0.11976542f, 0.02685913f, 
    -0.03490871f, -0.03704463f, 0.06054387f, 0.05481937f, -0.13245660f, 0.11422858f, 0.04794216f, -0.05761599f, 
    0.05833075f, -0.04382857f, 0.03280019f, -0.02173517f, 0.12463906f, 0.00228462f, -0.02823820f, 0.00898225f, 
    -0.23716320f, 0.07105350f, 0.01554407f, 0.16633250f, 0.03983470f, 0.08386438f, -0.06414921f, -0.04681744f, 
    0.08492085f, 0.03407924f, -0.08591498f, 0.01256248f, 0.02757267f, -0.00183582f, 0.05121163f, -0.02835730f, 
    -0.03355388f, 0.06154849f, 0.01633380f, -0.05492610f, -0.03437692f, 0.09116742f, 0.07714821f, 0.03081604f, 
    0.01349185f, -0.08448532f, -0.00185305f, 0.08518464f, -0.06306329f, -0.02690257f, 0.07512940f, -0.06063770f, 
    0.07091325f, 0.06441285f, -0.14121771f, -0.08391960f, 0.15486516f, -0.14077088f, -0.01602777f, -0.01428841f, 
    0.01012641f, 0.09390953f, -0.06784526f, -0.04073638f, 0.11507943f, 0.07166956f, -0.05988276f, 0.04450835f, 
    -0.08281309f, -0.00346446f, 0.00387889f, 0.13073772f, 0.05031854f, 0.02313808f, -0.08688881f, -0.08810778f, 
    0.03929850f, -0.02912478f, -0.01772641f, 0.00005032f, -0.07537907f, 0.16347140f, 0.13745441f, 0.03938213f, 
    -0.06458456f, -0.05210156f, -0.00122252f, -0.02257076f, 0.03866944f, 0.03743473f, -0.07156280f, 0.02721703f, 
    0.02173154f, 0.00256423f, -0.02153115f, -0.07766581f, -0.00550671f, 0.05374567f, 0.09078893f, 0.03915842f, 
    0.04470147f, 0.03155545f, 0.08811013f, -0.00619985f, 0.06965865f, -0.02250941f, 0.30026674f, 0.06840884f, 
    0.05936671f, -0.01687781f, 0.07609419f, -0.12680110f, -0.04657943f, 0.04643024f, -0.02683700f, -0.00063033f, 
    -0.29396728f, 0.00334640f, 0.17893256f, 0.06008084f, 0.05648497f, -0.00548445f, -0.03479885f, 0.02488528f, 
    0.00018234f, 0.03627640f, -0.06161626f, 0.08687570f, -0.09779307f, -0.02637549f, 0.01409623f, -0.03243280f, 
    0.02674110f, 0.00786616f, -0.09726077f, 0.10883227f, -0.05758942f, 0.10220402f, 0.13156390f, -0.00895152f, 
    0.02770875f, -0.25488296f, 0.01422425f, 0.14225318f, -0.03923406f, -0.01737637f, -0.00001197f, -0.03727506f, 
    0.00765129f, -0.04363203f, 0.18517534f, 0.05378494f, 0.13859597f, -0.01366976f, 0.02636029f, -0.07575151f, 
    -0.03194304f, -0.05755638f, -0.02156236f, 0.01146951f, 0.03185053f, 0.06527548f, 0.04586878f, 0.06274796f, 
    0.03441296f, -0.04729734f, -0.02635521f, -0.00253378f, 0.04939125f, 0.10128065f, 0.04315842f, -0.02159769f, 
    0.07303319f, -0.05887746f, -0.04059164f, 0.07099237f, 0.07943790f, 0.03685717f, -0.01558354f, 0.05043134f, 
    0.05088431f, -0.02923539f, 0.04643462f, -0.04226683f, -0.05534711f, 0.01517566f, -0.02052198f, -0.10770606f, 
    -0.35663939f, -0.06001328f, 0.09440270f, -0.07293424f, -0.06290684f, 0.05529795f, 0.05025870f, -0.01440757f, 
    0.04678335f, 0.03246493f, -0.00269959f, -0.04334660f, -0.45208421f, -0.07520007f, 0.16140184f, 0.05813349f, 
    -0.06657956f, -0.05379808f, -0.05565172f, -0.04953969f, -0.03229167f, -0.06958584f, 0.00836022f, -0.03917242f, 
    -0.21573773f, -0.01547194f, 0.21749084f, 0.03216723f, 0.11391113f, -0.05370660f, -0.03330610f, -0.02965742f, 
    -0.02154682f, -0.04041364f, 0.00448900f, 0.09420807f, 0.01302320f, 0.00926011f, 0.27790508f, 0.07772756f, 
    -0.05531548f, 0.02614809f, -0.03711767f, -0.01909575f, 0.06486620f, -0.06932324f, -0.05629596f, -0.06278519f, 
    -0.01561620f, 0.22999422f, -0.06451032f, 0.02794144f, -0.00067011f, -0.03165238f, -0.02039332f, -0.02771604f, 
    0.07322412f, 0.02010937f, 0.04205163f, 0.02861950f, 0.25257221f, -0.05898616f, 0.06267426f, 0.07788459f, 
    0.01298640f, 0.01091055f, -0.02136346f, -0.23463854f, 0.07967819f, 0.05188840f, 0.07862871f, -0.11762584f, 
    -0.41004387f, 0.30017799f, -0.03878959f, -0.00671297f, 0.00021554f, 0.01144009f, -0.02294929f, 0.03046928f, 
    -0.00417498f, -0.07700600f, 0.04066306f, 0.01419224f, -0.22584233f, -0.01079292f, -0.10446967f, -0.07236571f, 
    0.11504096f, -0.06580120f, 0.03938625f, -0.05769912f, 0.05035543f, -0.06410100f, 0.02036738f, 0.08325129f, 
    -0.02475999f, 0.10945716f, 0.01078106f, 0.13745731f, -0.01459097f, -0.18135980f, -0.04660759f, -0.04176177f, 
    0.12150702f, 0.07159126f, -0.11619180f, 0.07229532f, 0.18958674f, 0.05673588f, 0.03259752f, -0.05377241f, 
    -0.01834818f, -0.07247961f, -0.04760792f, -0.05512978f, 0.05696611f, -0.04869967f, -0.03639533f, -0.05736385f, 
    0.01732353f, -0.17888580f, -0.07305868f, -0.13747971f, -0.07515240f, 0.04034774f, 0.09801368f, -0.05901404f, 
    0.07742361f, -0.04764975f, 0.00269089f, -0.02491260f, -0.03649141f, 0.12950915f, 0.00462552f, -0.04885978f, 
    0.05739159f, 0.13639426f, 0.07574324f, -0.04117527f, -0.05772491f, 0.07873068f, 0.04911940f, 0.07978296f, 
    -0.13902508f, -0.11263406f, -0.17841750f, -0.03759585f, 0.09080618f, 0.00343375f, -0.04518867f, -0.01018407f, 
    0.02913130f, 0.04041578f, -0.07593014f, -0.00841565f, 0.11135817f, -0.11829942f, -0.05996738f, 0.33445683f, 
    -0.15667509f, 0.02453195f, 0.05188637f, 0.02238590f, 0.00143593f, -0.01023266f, 0.00130151f, 0.08188139f, 
    -0.27884901f, 0.06634784f, -0.01654619f, -0.02733375f, 0.08658297f, -0.00754945f, 0.00357431f, -0.04106849f, 
    0.01864627f, -0.01867365f, 0.04030956f, -0.01592526f, -0.25524095f, -0.19297045f, 0.15844667f, 0.15026872f, 
    0.06368433f, -0.06123557f, -0.03573359f, 0.02745476f, -0.04332973f, 0.03923430f, 0.03597265f, 0.09169714f, 
    0.00823441f, 0.11155444f, 0.00184053f, -0.03946419f, -0.01262241f, 0.12378276f, 0.04038620f, 0.02749791f, 
    0.06720605f, -0.01364100f, -0.04667762f, -0.03990258f, 0.04247778f, -0.01565525f, 0.00859726f, 0.09919440f, 
    0.04007046f, 0.10490873f, 0.06319034f, 0.13233648f, -0.05106706f, -0.05399445f, 0.06412875f, -0.02088225f, 
    0.25383729f, 0.12858401f, 0.02324371f, -0.15872920f, 0.08368538f, 0.05711551f, -0.02763524f, -0.02742127f, 
    -0.03940431f, 0.00829335f, 0.02363123f, -0.00166934f, -0.11794025f, 0.17089154f, -0.11191773f, 0.08026035f, 
    -0.06113554f, 0.02067114f, 0.05267835f, -0.07311811f, 0.06549147f, 0.02989112f, -0.03159266f, 0.02513152f, 
    0.22686645f, 0.10246559f, -0.17849033f, -0.08195732f, 0.14368618f, -0.01124185f, 0.00595153f, -0.05726594f, 
    0.09002370f, -0.01512685f, 0.07943685f, 0.10547165f, 0.03660167f, -0.09343002f, 0.18347405f, 0.08927471f, 
    -0.01198624f, 0.02277198f, 0.03843896f, 0.02027245f, -0.00266897f, 0.01831123f, 0.03497780f, 0.09065787f, 
    -0.01896500f, -0.08418145f, 0.20188311f, 0.43073812f, 0.08416386f, 0.02944044f, 0.04125722f, -0.00966290f, 
    -0.00970593f, -0.03988843f, -0.01951129f, 0.03851557f, 0.10791656f, -0.07393327f, -0.15455952f, 0.20089476f, 
    0.05416107f, 0.02971654f, 0.08479733f, 0.15971345f, 0.01216965f, 0.05919442f, 0.04512819f, 0.08691189f, 
    0.08321643f, 0.05784011f, 0.29366753f, 0.03608835f, 0.06902418f, 0.03073036f, 0.02028401f, 0.19306268f, 
    0.05587519f, 0.07177486f, 0.10060058f, 0.12155437f, 0.11781804f, -0.04960059f, -0.03952385f, -0.18529125f, 
    -0.05328256f, 0.05933357f, 0.02376848f, 0.09597094f, 0.01815649f, 0.06693450f, -0.00489250f, -0.03623194f, 
    -0.18923293f, -0.15931727f, 0.11910945f, 0.22686051f, -0.02415287f, -0.03159617f, 0.04666117f, -0.04426573f, 
    -0.00719552f, 0.01610965f, -0.08904872f, -0.01407284f, -0.24785629f, 0.12672114f, -0.07335327f, 0.01653053f, 
    0.18908864f, -0.03069679f, 0.04503169f, 0.00028014f, 0.10187153f, -0.05275340f, -0.00110952f, 0.00083422f, 
    0.30673712f, 0.26019064f, -0.02300433f, 0.31557426f, 0.00776026f, -0.00854704f, 0.09826291f, 0.01149068f, 
    -0.00280900f, 0.09003980f, -0.06379946f, -0.01681375f, -0.35106897f, 0.12438071f, 0.05499090f, 0.10323323f, 
    0.04879306f, 0.08805860f, 0.03452110f, 0.01781812f, -0.03719826f, -0.03612250f, 0.00650980f, 0.01972603f, 
    -0.14818481f, -0.08455180f, 0.15559794f, -0.09354392f, -0.05934959f, 0.07380921f, 0.00440207f, -0.00562104f, 
    -0.09241399f, -0.03223988f, 0.03022471f, 0.14905331f, 0.38976768f, 0.18252526f, -0.07200623f, 0.27853462f, 
    -0.02297410f, 0.01807569f, 0.09959225f, 0.00148298f, -0.00443344f, 0.10372929f, -0.00280638f, 0.04449553f, 
    0.01964286f, -0.00388625f, 0.02828259f, -0.15051278f, 0.00654584f, 0.05379726f, -0.06692483f, -0.00994304f, 
    0.02508851f, 0.03919704f, 0.18217878f, -0.06580203f, -0.27131239f, -0.00835883f, 0.02149104f, -0.04043663f, 
    -0.06285597f, 0.01751942f, -0.01299620f, -0.06173981f, -0.01247001f, -0.02628157f, 0.05811907f, -0.02766475f, 
    0.12830125f, -0.14146882f, 0.09447947f, -0.24014851f, -0.09816480f, -0.00270421f, 0.07535033f, 0.05458258f, 
    0.04040395f, -0.11281886f, 0.08315492f, 0.01701063f, -0.09535568f, -0.27196544f, 0.10335127f, 0.24897417f, 
    0.13942696f, 0.09506992f, -0.02190872f, 0.16290408f, 0.04113116f, -0.06862964f, -0.07447805f, 0.09514362f, 
    0.05593928f, -0.18510331f, -0.10824414f, -0.02689296f, 0.01221333f, -0.00832299f, 0.03988022f, 0.08556502f, 
    0.09647638f, 0.09987400f, 0.12618871f, -0.01804401f, -0.29134390f, 0.07797048f, -0.07527060f, 0.24689062f, 
    0.08763255f, 0.08081156f, 0.02471914f, 0.07514927f, 0.02200639f, -0.09457892f, 0.06018952f, 0.09956940f, 
    0.15467842f, 0.11365876f, 0.01996732f, 0.14644249f, 0.05378656f, 0.02632878f, -0.01820670f, 0.03027541f, 
    0.15580852f, 0.03650767f, 0.12865178f, 0.01389446f, -0.32111013f, -0.16501889f, 0.12867488f, -0.19855613f, 
    0.12394401f, -0.05552703f, 0.04696863f, -0.00350936f, 0.16539338f, 0.06281718f, -0.01560964f, 0.08672746f, 
    -0.11260203f, -0.05530676f, -0.18440519f, 0.12466737f, 0.19470923f, -0.05191644f, 0.02917686f, 0.06722009f, 
    0.05531478f, 0.04994404f, 0.13625416f, 0.04262304f, -0.23731281f, 0.04932123f, 0.29252273f, 0.11711507f, 
    0.00748047f, -0.01871315f, -0.02633582f, 0.01453107f, -0.02278900f, -0.03957045f, -0.08967795f, 0.00481702f, 
    -0.12095585f, 0.02377694f, -0.08501509f, -0.09349829f, -0.01079173f, -0.02450698f, 0.04562232f, 0.00934741f, 
    0.07821144f, -0.02843734f, -0.03518869f, 0.03390178f, -0.09230047f, 0.01552143f, 0.34574714f, 0.07995703f, 
    -0.01543362f, -0.03960540f, -0.03582859f, -0.01047155f, -0.00821388f, 0.00141353f, 0.03058749f, 0.01560303f, 
    -0.16302149f, 0.01175737f, 0.04162242f, -0.01058223f, 0.10731008f, -0.00426814f, 0.12052461f, 0.03473716f, 
    0.08223253f, 0.04163821f, 0.00603559f, 0.03044495f, -0.15092646f, 0.06210864f, 0.14239135f, 0.11422464f, 
    -0.11550393f, 0.04340138f, -0.08389988f, -0.00992328f, 0.11946614f, 0.03143585f, 0.04926936f, -0.03933540f, 
    -0.07891543f, -0.08240306f, -0.01573991f, 0.09507642f, 0.17599578f, 0.13254893f, -0.03049497f, 0.25540593f, 
    0.09330452f, 0.08116386f, 0.09394496f, 0.13465890f, -0.34057918f, 0.09415057f, -0.05085962f, -0.22955912f, 
    0.09045973f, 0.05276614f, 0.07026284f, -0.02909931f, 0.03583306f, -0.15238136f, -0.01417901f, -0.03987825f, 
    -0.12326353f, 0.10706162f, -0.04457851f, -0.12968054f, 0.04850847f, -0.06422731f, -0.02526180f, 0.05662071f, 
    -0.13734594f, 0.02440518f, 0.06245091f, 0.09981617f, 0.01478484f, 0.14582630f, 0.04815347f, 0.06429006f, 
    0.09040077f, 0.01987436f, 0.09894416f, 0.03242119f, 0.10824669f, 0.07846014f, 0.05090537f, 0.09778761f, 
    -0.21543266f, 0.04634297f, 0.10887098f, 0.07102493f, 0.07997088f, 0.01153736f, -0.02955484f, 0.02396527f, 
    0.04629841f, 0.05606205f, 0.02647834f, 0.07900392f, 0.05403453f, 0.15422577f, 0.15309139f, 0.26870906f, 
    -0.03422034f, 0.03733939f, 0.14729336f, -0.00808066f, -0.00656678f, 0.00507464f, -0.02744911f, -0.05598501f, 
    -0.00721808f, -0.14829293f, 0.13403495f, -0.09576397f, -0.16069761f, -0.05096561f, 0.17798108f, -0.12031647f, 
    -0.08263545f, 0.05541815f, -0.03187363f, -0.04141361f, 0.16288432f, 0.21740839f, 0.11031761f, 0.05255330f, 
    -0.10404354f, 0.10166269f, 0.00909007f, -0.06777578f, 0.16672534f, 0.00702271f, 0.04246164f, -0.07436299f, 
    -0.22766359f, 0.06276774f, 0.18979442f, -0.11016974f, -0.08488036f, -0.00238455f, -0.06908070f, -0.06482308f, 
    -0.05000396f, -0.04323325f, -0.04698872f, -0.09348094f, 0.14915177f, -0.09237950f, 0.04893531f, 0.11740219f, 
    -0.07682910f, 0.02464150f, 0.02238061f, -0.02223873f, 0.16234966f, 0.02928335f, 0.00503211f, -0.11201012f, 
    -0.21174324f, 0.01794888f, -0.10006037f, -0.01980542f, 0.05713381f, 0.12269624f, 0.03748633f, 0.09823409f, 
    0.03974732f, 0.07306542f, 0.07825194f, -0.01277119f, 0.05984181f, -0.07576277f, 0.04167347f, -0.08028455f, 
    0.02850325f, -0.01397383f, -0.04635138f, 0.14608532f, -0.04047726f, 0.05616742f, 0.01656559f, 0.14521986f, 
    -0.44167104f, -0.04045070f, 0.14056857f, -0.09070358f, -0.02252409f, -0.02411643f, -0.02210224f, -0.00504348f, 
    -0.02599444f, 0.03717024f, -0.09009625f, 0.03173706f, -0.09257334f, -0.13074574f, -0.02969246f, 0.11667962f, 
    0.07377831f, 0.00045678f, 0.02685539f, 0.12097537f, -0.06612600f, -0.04301189f, -0.01076586f, -0.04190214f, 
    -0.16133222f, -0.28001413f, 0.05201731f, 0.05760802f, -0.10957414f, -0.03693274f, 0.12723646f, -0.00777983f, 
    0.06176284f, 0.05372749f, 0.08094619f, 0.01130301f, -0.04768194f, 0.01800122f, -0.11824968f, 0.04333752f, 
    0.08132733f, 0.06750571f, -0.03101770f, -0.04835683f, -0.03873739f, 0.06058548f, 0.05234021f, 0.07401347f, 
    0.02443300f, 0.00085838f, 0.10711281f, 0.09000496f, 0.02854295f, 0.01828357f, 0.02700601f, 0.02434407f, 
    0.08598951f, 0.04616345f, 0.07311724f, 0.04937463f, -0.09073133f, 0.02140035f, -0.23087341f, 0.01148460f, 
    0.08188231f, -0.08320852f, -0.06675402f, 0.12769674f, 0.06090145f, -0.03532509f, 0.09653188f, -0.06133729f, 
    -0.16997433f, -0.00168527f, 0.33542782f, 0.00750479f, -0.01020772f, 0.04146056f, 0.01093279f, 0.03530056f, 
    0.07451878f, 0.00510449f, 0.01920572f, -0.01252857f, -0.30465996f, -0.14266562f, 0.21357068f, 0.03336643f, 
    -0.04733846f, -0.05514798f, -0.11137325f, -0.03638657f, 0.11454302f, -0.09153480f, 0.07410918f, -0.06706578f, 
    -0.20170626f, -0.09529945f, 0.12199581f, 0.03623553f, -0.01863175f, -0.01666811f, -0.08745249f, -0.02392245f, 
    -0.04480121f, -0.11963487f, -0.02026737f, 0.06963591f, -0.11115725f, 0.08311780f, 0.11551756f, -0.08195774f, 
    -0.00126624f, 0.11754562f, -0.01474782f, -0.08803069f, 0.05450933f, -0.15708508f, -0.06562277f, -0.07845861f, 
    0.26463392f, 0.50756389f, -0.16280775f, 0.30915612f, 0.09825131f, 0.00324356f, 0.07648158f, -0.00041641f, 
    0.10106242f, 0.02454998f, 0.07477795f, 0.13769980f, 0.15501605f, -0.25068542f, 0.06647553f, -0.04069651f, 
    0.01394367f, -0.01175129f, 0.12703325f, -0.16415094f, 0.01349385f, -0.00370646f, 0.06030803f, -0.03099893f, 
    -0.09289028f, 0.47402772f, -0.00251133f, -0.10080232f, -0.01653731f, -0.00966208f, -0.02966516f, 0.06775524f, 
    -0.01027405f, -0.04190484f, -0.02195403f, -0.07050859f, 0.09006011f, 0.31343332f, 0.03701544f, 0.08110906f, 
    0.11901337f, -0.06230816f, 0.01331856f, -0.04116743f, 0.01388812f, 0.00688234f, -0.02452650f, 0.00925468f, 
    0.00197243f, -0.07565980f, 0.08244526f, -0.14737064f, -0.09994801f, -0.11776538f, 0.07210458f, -0.13458148f, 
    0.07185136f, -0.01054676f, 0.07259138f, -0.00589061f, 0.26213419f, 0.22690070f, 0.00812102f, 0.13019171f, 
    -0.10880096f, -0.02134915f, 0.05538564f, -0.05102034f, -0.02979460f, 0.07821435f, -0.03343637f, -0.02833843f, 
    0.12577148f, -0.16209622f, 0.01127623f, -0.06247282f, -0.10913790f, 0.00586280f, -0.03243432f, -0.06045053f, 
    0.07358160f, -0.13153167f, -0.07306750f, -0.04269905f, -0.23693360f, -0.05819794f, -0.09062917f, 0.05456723f, 
    0.12877089f, 0.12645757f, 0.03636253f, 0.08139364f, 0.03400876f, 0.09994186f, 0.08824489f, 0.07759193f, 
    0.26884779f, 0.15671396f, -0.06036006f, -0.02832371f, 0.06474317f, 0.01330977f, -0.10976461f, -0.00909831f, 
    0.05133668f, 0.00416464f, -0.01583154f, -0.01987082f, -0.10298184f, -0.14545098f, 0.15695412f, 0.08321872f, 
    -0.20807138f, -0.00441892f, 0.08275823f, -0.01278431f, -0.07303353f, -0.06705062f, -0.08130980f, -0.02746930f, 
    0.14423309f, 0.07947125f, -0.05375996f, -0.05757923f, 0.03386948f, -0.05956210f, -0.01147178f, -0.09569350f, 
    0.02677967f, 0.00241590f, -0.04755611f, -0.04275275f, -0.24363779f, -0.06633088f, 0.08648401f, -0.01066731f, 
    0.01441999f, -0.01375723f, 0.01618929f, 0.01235951f, -0.11347800f, 0.03546559f, -0.01396175f, 0.15540865f, 
    -0.15973450f, 0.25734097f, 0.13457838f, -0.13626765f, -0.14027190f, 0.13899074f, 0.14405821f, 0.05579091f, 
    0.01804953f, 0.07006864f, -0.06298044f, -0.08972936f, -0.16395216f, 0.19253664f, 0.12292512f, 0.10411196f, 
    0.10982799f, 0.02831504f, 0.00067989f, 0.09887099f, -0.07091407f, 0.02433161f, 0.06563723f, 0.09016175f, 
    -0.21926133f, 0.17854179f, -0.04850613f, -0.26729625f, 0.08122370f, -0.05121687f, -0.04033717f, 0.01786063f, 
    -0.09370570f, 0.05043393f, 0.05889975f, -0.04172793f, 0.02341941f, 0.00107413f, 0.12754998f, -0.01187297f, 
    0.10010308f, 0.01291837f, 0.05831828f, 0.08048589f, 0.02972788f, 0.02643063f, -0.00901884f, 0.05216039f, 
    0.01220343f, 0.01467723f, -0.02431303f, 0.00041836f, 0.02322548f, 0.02892947f, 0.01721174f, -0.02667909f, 
    -0.03377369f, 0.00934254f, -0.02993152f, -0.03086925f, 0.01044085f, 0.01269978f, 0.00009488f, -0.00390539f, 
    -0.01997156f, -0.01573259f, -0.02880219f, 0.00777789f, -0.01299715f, -0.02689772f, -0.03430549f, -0.01794232f, 
    -0.01071666f, -0.01807356f, -0.00221753f, 0.00605839f, -0.01386913f, 0.01949298f, -0.01450179f, 0.00108589f, 
    -0.03915389f, -0.02417498f, -0.02870960f, -0.01915205f, -0.03081914f, 0.01794126f, -0.04300992f, -0.02398843f, 
    -0.02329673f, -0.00276761f, 0.01610892f, 0.00609189f, -0.02883080f, -0.01902867f, -0.01518778f, -0.02250152f, 
    -0.00507165f, -0.01911436f, -0.00663931f, 0.01677182f, -0.01066625f, -0.00120287f, 0.02733361f, -0.00646473f, 
    -0.00932269f, 0.00171935f, 0.01542575f, -0.01235016f, 0.01225557f, 0.01931375f, 0.01311615f, -0.03618008f, 
    -0.01427327f, 0.02315307f, 0.00485527f, -0.01260901f, 0.02260412f, -0.02415596f, 0.01090177f, -0.02872493f, 
    0.01660014f, -0.02498683f, -0.04452749f, -0.03618855f, 0.02368504f, -0.01768712f, -0.00254791f, 0.01754087f, 
    -0.00619153f, 0.00029101f, 0.01059690f, 0.00737526f, -0.01596915f, -0.01488950f, 0.01461599f, -0.01175083f, 
    -0.01769460f, -0.03732443f, -0.03220953f, -0.03445702f, 0.02489391f, 0.01143614f, -0.00118181f, -0.03189018f, 
    -0.03952027f, -0.02477090f, -0.00207398f, -0.02335944f, -0.04239673f, -0.04113306f, 0.00335913f, -0.02022317f, 
    0.01697526f, -0.00219690f, -0.03490247f, 0.00075175f, 0.01731204f, -0.04089402f, -0.01386841f, -0.01926047f, 
    -0.02278281f, 0.01355599f, -0.00744212f, 0.01196859f, -0.04416334f, -0.02381861f, -0.02185262f, 0.00294167f, 
    0.01503219f, -0.01642884f, 0.02739717f, -0.01767251f, -0.01791675f, 0.01524847f, 0.02257723f, 0.00600799f, 
    0.02515347f, 0.01506345f, 0.01740561f, -0.01613468f, -0.03336108f, -0.01723478f, 0.02404983f, 0.02512254f, 
    -0.03184158f, -0.03599841f, 0.01158252f, -0.01930594f, -0.03213963f, -0.00343117f, 0.00517102f, 0.00998041f, 
    -0.01202382f, 0.02434153f, -0.03020794f, 0.00547332f, 0.00403774f, -0.03724762f, 0.02237374f, -0.01939332f, 
    0.00207958f, 0.01037484f, -0.03507549f, 0.01830103f, 0.03376119f, -0.03407745f, 0.02158406f, -0.02704079f, 
    0.02705338f, 0.00329599f, -0.02281638f, -0.03814897f, 0.00707703f, 0.00550417f, 0.00314120f, 0.00451478f, 
    -0.01975694f, 0.00217473f, 0.01956351f, -0.00197135f, -0.04540523f, -0.00110594f, 0.00383647f, 0.02597172f, 
    -0.00568734f, -0.00876667f, 0.02353827f, -0.00282688f, -0.03639876f, -0.03481376f, 0.02992360f, 0.00417662f, 
    -0.02448589f, -0.01319402f, 0.02807850f, -0.00644036f, -0.01398794f, -0.00764918f, -0.03661068f, 0.00411469f, 
    0.01733330f, -0.01210011f, 0.00039844f, -0.00770867f, -0.04145728f, -0.02034425f, -0.03854383f, 0.01168436f, 
    -0.02914152f, -0.00633689f, -0.03284477f, 0.01436374f, -0.01877188f, -0.02147445f, -0.01125447f, -0.00416153f, 
    0.01923524f, -0.03059454f, -0.01045302f, -0.04342860f, -0.02024395f, -0.01207369f, 0.03165630f, -0.00135363f, 
    0.00600932f, -0.02971138f, 0.00532384f, -0.01032341f, 0.01182203f, 0.02552295f, -0.04209602f, 0.01377898f, 
    0.00637165f, 0.02349527f, 0.01707283f, 0.00804850f, -0.02876567f, -0.04268513f, 0.02209575f, 0.01905287f, 
    0.01379653f, -0.03705095f, -0.04186931f, -0.00999465f, -0.02721214f, -0.02333113f, -0.02248949f, -0.03072629f, 
    0.00693807f, 0.00562812f, -0.03097172f, 0.01101284f, -0.00285196f, 0.01925990f, -0.02565693f, 0.00632733f, 
    -0.03999430f, 0.02683126f, -0.02925561f, 0.00013617f, 0.02049824f, -0.00638763f, -0.03118221f, 0.01498889f, 
    -0.04262634f, -0.02307631f, 0.01451238f, 0.00875479f, -0.02438883f, -0.03467492f, -0.03381794f, -0.01304998f, 
    0.01635214f, 0.00249102f, -0.01580352f, -0.01954711f, -0.02239688f, 0.00118695f, 0.00532949f, -0.01323050f, 
    -0.02590558f, -0.03793153f, -0.01279694f, -0.01951707f, 0.01091421f, -0.02937604f, 0.02596829f, 0.01809352f, 
    -0.01990189f, -0.00214968f, -0.02546283f, 0.01086186f, 0.00301701f, -0.02238072f, -0.03425775f, -0.02472506f, 
    -0.02284007f, -0.03941490f, -0.02379434f, -0.03751119f, -0.03239959f, 0.01631160f, 0.01033830f, -0.00168593f, 
    -0.00088367f, -0.00594882f, -0.03539066f, 0.01565966f, -0.02882287f, 0.01708450f, 0.02712373f, -0.01074188f, 
    0.01743091f, 0.01449009f, -0.01225890f, 0.00673383f, -0.00542819f, -0.00392795f, -0.02043765f, 0.01606515f, 
    0.01596868f, -0.04264777f, -0.01683288f, -0.02871841f, 0.01499940f, -0.02212805f, -0.04027957f, 0.01418625f, 
    -0.01887036f, -0.02427077f, 0.01437466f, -0.01374627f, -0.01292238f, -0.01438332f, 0.00233623f, -0.01250133f, 
    -0.01608881f, 0.02370255f, 0.01199510f, -0.03350378f, -0.03928142f, -0.00111138f, -0.01245475f, -0.00877586f, 
    -0.01108449f, -0.00397321f, 0.02108040f, 0.00250310f, -0.03266719f, 0.00243365f, 0.00401924f, -0.02857170f, 
    -0.02896926f, -0.02928985f, -0.00052926f, 0.02099867f, 0.00944323f, -0.00806962f, -0.04037300f, -0.03270196f, 
    -0.03154711f, -0.02905251f, 0.00277743f, -0.00410334f, -0.03323910f, -0.00911151f, -0.03171503f, -0.03339756f, 
    -0.02393547f, 0.02450642f, 0.01097451f, 0.00406250f, -0.02236008f, 0.02558748f, 0.01120099f, -0.00305880f, 
    0.02283724f, 0.02610732f, 0.01210046f, -0.02020675f, -0.01969941f, 0.01212166f, -0.00091874f, 0.00556237f, 
    0.01904506f, -0.03481879f, -0.02752985f, 0.02070864f, -0.03636603f, -0.04071242f, -0.01933510f, -0.01411738f, 
    -0.02280675f, 0.01026823f, 0.01933933f, -0.01877499f, -0.02465391f, -0.00924913f, -0.03310506f, -0.00154366f, 
    0.01456243f, 0.00340490f, 0.00946984f, -0.03261761f, -0.01651485f, 0.01125356f, -0.02137008f, -0.01828565f, 
    -0.01574052f, -0.01953634f, -0.00617407f, 0.00071287f, 0.02030795f, -0.00822583f, -0.01734519f, -0.03820687f, 
    -0.01497890f, 0.01116643f, -0.03750220f, -0.02770546f, 0.01695226f, -0.02941087f, -0.04214751f, -0.03314212f, 
    -0.02093651f, -0.03917594f, 0.02813916f, -0.03404509f, -0.04052647f, -0.02128721f, -0.01366687f, 0.00197534f, 
    -0.03324904f, -0.00784142f, -0.01546553f, -0.00924955f, 0.02579809f, -0.03250800f, 0.01595014f, 0.00477615f, 
    -0.03946076f, -0.00610881f, 0.01367055f, -0.03212056f, -0.02256572f, -0.00123688f, -0.01043315f, -0.00417561f, 
    -0.01261168f, -0.03326979f, -0.00396199f, 0.01833436f, -0.03695476f, -0.02623635f, -0.02993708f, -0.00484017f, 
    -0.02933915f, -0.02231358f, -0.00956770f, -0.03699391f, -0.01770352f, 0.02479134f, 0.01186914f, -0.00308139f, 
    -0.02131861f, 0.01395615f, -0.00638491f, -0.03504751f, -0.00679077f, -0.03328700f, -0.02463313f, -0.01149589f, 
    0.00136450f, -0.00077902f, -0.01330696f, 0.00134298f, 0.02113604f, -0.02438479f, -0.00745156f, 0.01295532f, 
    -0.00860503f, -0.03348603f, -0.00125679f, -0.02974020f, 0.01506205f, -0.02905469f, 0.02150861f, -0.01669427f, 
    0.01274886f, 0.01729009f, 0.00946742f, -0.01680860f, 0.00888086f, -0.01100703f, 0.01958919f, 0.00754808f, 
    0.00357493f, -0.03572321f, -0.02108210f, 0.02095038f, -0.03922212f, -0.03365405f, 0.00845172f, -0.01675681f, 
    0.01261459f, -0.03659247f, 0.01260781f, -0.00364025f, -0.04067587f, -0.02599358f, 0.02660008f, -0.03418766f, 
    0.00978444f, 0.01740962f, -0.00743408f, 0.00428066f, -0.02312595f, 0.01658216f, -0.00548791f, 0.00574526f, 
    0.02684691f, 0.00684385f, -0.03058323f, 0.00543615f, 0.00462055f, 0.00654777f, -0.03493730f, 0.02030245f, 
    -0.02293365f, -0.03534615f, 0.02061891f, 0.01652916f, 0.01288163f, -0.01851395f, -0.03656936f, -0.03367859f, 
    0.01495208f, 0.01489639f, -0.02061561f, -0.00653967f, -0.03279784f, 0.01634081f, 0.01102406f, -0.01168519f, 
    0.01500106f, 0.02089130f, -0.00870032f, 0.01861575f, -0.01874399f, 0.01569406f, 0.01184421f, 0.00296981f, 
    -0.01162922f, -0.01692902f, 0.02035688f, 0.02450839f, -0.01143928f, -0.03128322f, 0.02655686f, -0.00304588f, 
    0.02751041f, 0.03163925f, -0.02594632f, -0.02190209f, -0.03287786f, 0.01219079f, -0.00727885f, 0.01853062f, 
    0.01336357f, -0.02329840f, -0.02712594f, -0.01015612f, -0.04297989f, -0.04514932f, 0.00793890f, -0.01975540f, 
    0.01487864f, 0.02805974f, -0.02026336f, 0.00484372f, -0.01076571f, -0.02424439f, -0.01536907f, 0.00385852f, 
    0.02567098f, 0.01304265f, -0.00414814f, -0.01297597f, -0.00400593f, 0.01657793f, -0.02970910f, -0.03631232f, 
    0.02650476f, 0.00148702f, 0.01839950f, 0.01454450f, 0.02587795f, -0.01138971f, -0.01852219f, -0.02333275f, 
    -0.03503955f, 0.00756329f, -0.03131518f, 0.02122355f, -0.00189762f, 0.02637319f, -0.01470980f, 0.01175202f, 
    0.00914381f, -0.02873572f, -0.03109514f, 0.01197725f, 0.00278072f, -0.01528566f, -0.01144699f, -0.00491153f, 
    0.01565575f, -0.03664851f, -0.02570520f, -0.02499613f, -0.03948398f, -0.00951255f, -0.03061741f, -0.00473512f, 
    0.00788645f, 0.00771060f, 0.01799432f, -0.02314020f, -0.00250163f, 0.00677077f, 0.01741061f, -0.01692677f, 
    0.01640726f, -0.01471953f, 0.00600832f, 0.01190601f, -0.04127686f, 0.02175527f, -0.00871757f, 0.02329708f, 
    -0.03342392f, -0.01104286f, 0.00438308f, 0.01706273f, -0.04350536f, 0.00039229f, -0.00452862f, -0.00177488f, 
    -0.00908119f, -0.00792228f, 0.02295170f, -0.02955301f, 0.02357114f, 0.00133810f, -0.03819731f, 0.01908873f, 
    0.00757334f, -0.01185106f, 0.00552099f, -0.02452476f, 0.00221032f, -0.04192320f, 0.02050971f, -0.03504257f, 
    -0.02084075f, -0.01982420f, 0.02256922f, -0.01740487f, -0.02303080f, 0.02324673f, 0.00959792f, -0.03828776f, 
    0.00052796f, 0.02632160f, -0.02762481f, 0.02114542f, 0.00392489f, -0.00086809f, -0.04305645f, -0.00178002f, 
    0.00400222f, -0.04001052f, -0.03208576f, 0.00017819f, 0.00773507f, 0.01723609f, -0.01718604f, 0.02450988f, 
    -0.04338519f, -0.03246832f, 0.01250182f, -0.00007565f, 0.02853009f, -0.01925227f, -0.02830630f, -0.01873977f, 
    -0.00792732f, 0.00919826f, -0.03553222f, 0.02126980f, -0.02044800f, 0.02910373f, 0.01419230f, 0.02184869f, 
    -0.03860717f, 0.00316226f, 0.00176565f, -0.02487541f, 0.01286622f, -0.01253579f, -0.02739355f, 0.02777217f, 
    -0.02194614f, -0.00863560f, -0.02302741f, -0.02045863f, -0.03316869f, -0.00839422f, -0.04187669f, -0.03487590f, 
    0.00331935f, -0.03390568f, 0.01877471f, -0.01593888f, 0.01246923f, -0.03592056f, -0.03186759f, -0.01399211f, 
    0.01780888f, -0.02118529f, 0.02630020f, -0.01712161f, -0.03048177f, -0.02449300f, -0.02517725f, 0.01947664f, 
    -0.04433268f, -0.01312820f, 0.01575152f, -0.04345358f, -0.03964050f, -0.02504048f, -0.01946213f, 0.01505225f, 
    -0.02254987f, -0.03427967f, -0.03590242f, 0.01952907f, 0.01779095f, 0.00111465f, -0.00196974f, 0.01995301f, 
    -0.00822021f, -0.03355846f, -0.03792021f, 0.02453296f, 0.02355072f, -0.03151561f, 0.01510541f, -0.03404729f, 
    0.00954104f, 0.00115814f, -0.03106518f, 0.01507432f, -0.03858477f, -0.03329656f, -0.03752675f, 0.01336662f, 
    0.00231026f, -0.01959635f, -0.02326923f, -0.03157204f, -0.03655944f, -0.00243818f, -0.02811660f, -0.03005514f, 
    -0.01404721f, -0.01269367f, -0.01791848f, -0.03308275f, -0.04195287f, 0.01706881f, 0.01911426f, -0.03629845f, 
    -0.03042448f, -0.01915161f, -0.01588926f, 0.00733350f, 0.01729400f, -0.00716060f, 0.00292875f, -0.02081132f, 
    0.02798896f, 0.02806966f, -0.02325633f, -0.01493228f, -0.01317100f, 0.01180943f, 0.01238050f, -0.00292596f, 
    0.00031023f, -0.02256392f, -0.01137040f, 0.01487374f, -0.02773983f, 0.00570348f, -0.00441310f, 0.01668374f, 
    0.02431193f, 0.01810871f, -0.04183080f, 0.00982409f, 0.00233066f, -0.00799030f, 0.02833992f, -0.00599807f, 
    -0.03650589f, 0.00169473f, -0.01077605f, -0.00586027f, 0.02669418f, 0.00859951f, 0.00449567f, 0.01178377f, 
    -0.04177495f, 0.01098503f, 0.00506985f, 0.02119740f, -0.02817089f, -0.02341153f, 0.02840735f, 0.01908166f, 
    -0.00451592f, -0.02195181f, -0.01036274f, -0.01629756f, -0.02396356f, -0.00006746f, -0.02175753f, -0.03459941f, 
    -0.01300871f, 0.00337206f, -0.02141082f, 0.00974715f, -0.00187938f, -0.02066582f, 0.00287761f, -0.01506171f, 
    0.01761823f, -0.02127625f, -0.01111704f, 0.00782267f, -0.02998205f, -0.03132768f, 0.02120984f, -0.00591461f, 
    -0.00061225f, 0.01289284f, 0.00304856f, 0.02995845f, -0.01509392f, 0.01574617f, -0.00725872f, -0.01933150f, 
    -0.01229945f, -0.00311803f, -0.03957201f, 0.01821376f, 0.01122797f, 0.00393215f, -0.00708013f, 0.01841597f, 
    0.01026571f, -0.01736004f, -0.00256742f, 0.02463224f, -0.03479256f, -0.00688882f, -0.01266827f, -0.03745465f, 
    -0.02209538f, -0.02325372f, -0.02464403f, 0.00221633f, 0.00048865f, -0.01051384f, -0.03018782f, -0.01548444f, 
    -0.02099554f, 0.02811610f, -0.01050064f, 0.02621810f, 0.01559072f, -0.03088325f, 0.02107982f, 0.00702806f, 
    0.00113162f, -0.02774337f, 0.01801992f, -0.02638176f, -0.03858647f, -0.01743604f, -0.04149172f, -0.00483940f, 
    -0.00297942f, -0.00963745f, -0.02769763f, 0.01948532f, -0.03172923f, 0.02274192f, -0.04006783f, 0.02674183f, 
    0.00416115f, -0.02550348f, 0.00809364f, -0.02744617f, 0.00874863f, 0.02990949f, -0.02773775f, -0.01096690f, 
    -0.03155699f, -0.02339812f, -0.02077592f, 0.02861193f, -0.02291485f, 0.01279467f, -0.01001871f, 0.01216516f, 
    0.00960294f, -0.03596761f, -0.00026672f, -0.03883453f, 0.00007823f, -0.00521043f, -0.03112181f, -0.00798079f, 
    0.00768144f, -0.03640871f, 0.01883998f, -0.00505176f, -0.01907127f, 0.00940697f, 0.01916517f, 0.01409288f, 
    0.00031841f, -0.01881297f, -0.00529556f, -0.01551844f, -0.00768859f, 0.01357420f, 0.02192396f, 0.01900027f, 
    0.01869820f, -0.00461952f, 0.01737267f, -0.00105744f, -0.03082369f, 0.02008607f, 0.00224010f, -0.01476627f, 
    -0.03089255f, -0.01023732f, -0.00559136f, 0.01414053f, -0.02880147f, 0.02127224f, 0.00865402f, 0.00774170f, 
    -0.03325387f, -0.03618059f, 0.00989975f, 0.02125679f, 0.00570338f, 0.00431862f, 0.02610286f, 0.02624321f, 
    0.01972641f, -0.02791635f, -0.03739765f, -0.00200308f, -0.01009082f, -0.03067439f, -0.03962741f, -0.00271483f, 
    -0.02728987f, -0.03572565f, -0.02639418f, -0.02251597f, -0.02978464f, -0.03577224f, -0.03266181f, 0.00032176f, 
    -0.03371460f, -0.00892690f, -0.00203264f, 0.01371390f, -0.02210301f, -0.03004821f, -0.03359364f, -0.00956581f, 
    -0.03932609f, 0.01711851f, -0.01439612f, -0.01481205f, -0.01821279f, 0.00955393f, -0.03783551f, -0.02547693f, 
    -0.02120010f, 0.00907251f, -0.02046690f, -0.03354073f, -0.03908006f, -0.03116020f, -0.02326645f, 0.01409264f, 
    0.02546841f, -0.03445373f, 0.00202773f, -0.01587214f, 0.01859198f, 0.02054790f, 0.02163391f, 0.01559039f, 
    -0.04180570f, -0.02601540f, -0.03003183f, -0.03792120f, -0.00052300f, 0.00881730f, -0.03549608f, 0.02226993f, 
    -0.03431071f, -0.03307542f, 0.02238703f, 0.01611146f, -0.01951652f, -0.01427760f, 0.00847453f, 0.00709044f, 
    -0.03794068f, -0.01715009f, 0.00854476f, -0.00043703f, -0.04075165f, 0.01288991f, -0.01708650f, -0.02632330f, 
    -0.01279391f, -0.03906675f, 0.01058269f, 0.02204269f, -0.02805809f, 0.02195083f, -0.02097978f, -0.03328654f, 
    -0.03183594f, -0.03622148f, -0.03815734f, -0.01885366f, -0.00213323f, 0.03657215f, 0.02890825f, -0.02560319f, 
    -0.00466106f, -0.00802645f, -0.02427430f, 0.01302696f, -0.03409008f, -0.03154008f, -0.03578318f, -0.03486853f, 
    0.00745523f, 0.01307693f, -0.02988018f, -0.03194559f, 0.01875643f, -0.01806934f, -0.02139234f, -0.03767961f, 
    -0.00844054f, -0.00859967f, -0.01059644f, -0.04192833f, -0.00390894f, 0.01031835f, 0.01807078f, -0.03404867f, 
    0.00394323f, -0.02808708f, 0.00421530f, 0.01096293f, -0.02602023f, -0.00727296f, -0.01556032f, -0.01402637f, 
    0.01442388f, -0.02286798f, -0.02161378f, 0.00631885f, -0.01361174f, 0.02565768f, 0.02825145f, -0.02816569f, 
    -0.00963067f, 0.00155510f, 0.01389794f, -0.00228464f, -0.00440543f, -0.02083274f, -0.01443830f, -0.03166974f, 
    -0.01571265f, -0.02169713f, 0.02734592f, 0.02643447f, 0.01004362f, -0.03212949f, 0.02084446f, 0.01242572f, 
    -0.01121267f, 0.00179068f, -0.00860391f, 0.01151696f, 0.01873755f, -0.04151311f, -0.02677984f, -0.01256304f, 
    -0.02352276f, -0.03731715f, 0.00883531f, -0.01958893f, -0.00886951f, 0.02116481f, 0.01127886f, 0.02854664f, 
    0.01208959f, -0.01682646f, 0.00045801f, -0.03101580f, -0.00063334f, 0.02079968f, -0.00631738f, 0.02574776f, 
    -0.00318986f, -0.01967891f, -0.01049802f, 0.01905240f, 0.00826588f, 0.01968964f, -0.01626063f, -0.04091837f, 
    -0.01214005f, 0.00459231f, -0.03184507f, -0.02989411f, -0.00355496f, -0.03279473f, 0.01196162f, 0.01631231f, 
    -0.04158135f, 0.01310418f, 0.04097489f, 0.01709235f, -0.02486927f, -0.00313397f, 0.01724247f, 0.02666835f, 
    0.00549826f, -0.00875705f, 0.02443541f, 0.02814139f, -0.01784163f, 0.00274058f, -0.02979819f, -0.04179925f, 
    0.01221047f, -0.00238013f, -0.03774074f, 0.01138843f, 0.01014039f, -0.02490585f, -0.00595610f, 0.00280569f, 
    -0.02980123f, -0.04066816f, -0.03077168f, 0.01976222f, -0.04029308f, -0.01072717f, -0.04187843f, -0.01116270f, 
    0.00772778f, -0.02389961f, -0.00788374f, -0.00234826f, -0.02408276f, -0.03318803f, -0.03338097f, -0.02332067f, 
    -0.02860890f, 0.01885166f, -0.02365544f, 0.01418721f, 0.00188445f, -0.01624586f, -0.01374593f, -0.01289161f, 
    0.00678634f, -0.01104804f, -0.01781061f, 0.01129618f, -0.00746566f, 0.01600064f, -0.01740077f, -0.03186629f, 
    -0.02384124f, -0.03941972f, -0.00970123f, 0.01934986f, -0.00961052f, -0.00247940f, 0.00230200f, 0.01312725f, 
    0.01523706f, -0.01933736f, -0.02208592f, -0.04031678f, -0.03947645f, -0.01171985f, -0.02282328f, -0.01462355f, 
    0.00748217f, -0.00011782f, -0.01101086f, -0.02009235f, -0.02190800f, -0.01927806f, -0.02486013f, 0.00817403f, 
    -0.00250732f, -0.00181357f, -0.01359372f, -0.04095257f, 0.02068732f, 0.01625698f, -0.00417833f, -0.03637682f, 
    0.02450017f, 0.01955027f, 0.01502918f, -0.01871118f, -0.03806886f, -0.01137937f, 0.02428801f, 0.01191167f, 
    0.02171069f, -0.03716407f, 0.00076691f, -0.00411807f, 0.00999875f, -0.02473708f, -0.02342162f, -0.00339344f, 
    0.01452877f, 0.01196771f, 0.02697116f, 0.00944890f, -0.04068440f, -0.02700370f, -0.01536906f, -0.03083065f, 
    -0.00348420f, -0.01021501f, -0.03852724f, -0.00743628f, -0.01606709f, 0.00022399f, -0.00033471f, 0.00227813f, 
    0.00399212f, -0.01647720f, -0.03424351f, -0.03836795f, 0.02719912f, -0.01754141f, -0.02200495f, -0.00883017f, 
    -0.03160319f, 0.00223835f, -0.02930566f, 0.01548333f, 0.00020558f, 0.00238322f, 0.02404381f, 0.01967758f, 
    0.00310829f, -0.02039530f, 0.01788474f, 0.02702255f, 0.02676524f, -0.03367954f, 0.00651704f, 0.00671512f, 
    0.00827075f, -0.03829790f, -0.02430674f, -0.02082671f, -0.03653704f, 0.02683627f, 0.00545693f, -0.00207282f, 
    -0.00385043f, -0.03741146f, -0.00379943f, -0.01555928f, 0.02895471f, -0.02411420f, 0.01767505f, -0.03769572f, 
    0.01064831f, -0.00183790f, -0.00193649f, 0.02672911f, -0.01272870f, 0.01843488f, 0.00998549f, 0.01765995f, 
    0.02052096f, 0.01047468f, 0.02057265f, -0.01136606f, 0.00967352f, 0.01313400f, -0.03191851f, -0.00613058f, 
    0.00868830f, 0.02580909f, -0.02061914f, 0.02283741f, -0.03049765f, -0.01483420f, -0.00662857f, 0.00570846f, 
    -0.00126628f, 0.00063009f, 0.00886108f, -0.01677188f, -0.03206692f, 0.02407703f, -0.01701292f, -0.03056227f, 
    -0.02693068f, 0.02998198f, -0.00830721f, -0.01677276f, -0.01026838f, 0.02249465f, -0.01340140f, -0.01069019f, 
    -0.03693923f, 0.02046060f, -0.00105355f, -0.00047092f, 0.02246834f, 0.00057882f, 0.02541775f, 0.02891556f, 
    -0.01391038f, -0.01298386f, -0.02390884f, -0.03937783f, -0.00483226f, -0.01811991f, 0.01557670f, 0.00485972f, 
    0.02480026f, -0.03552234f, 0.01094740f, -0.00300588f, -0.04138575f, -0.02761559f, -0.02670585f, 0.01596868f, 
    -0.02685353f, -0.00630925f, 0.02323065f, -0.03514674f, 0.01147013f, 0.00510418f, 0.00819830f, -0.04185588f, 
    -0.01764335f, -0.00366962f, 0.00361674f, -0.03791092f, -0.02707543f, -0.02102535f, 0.02084759f, -0.00559978f, 
    0.00987677f, 0.02777233f, -0.01119919f, -0.00407395f, 0.00056759f, 0.02558666f, -0.01540019f, -0.02170604f, 
    -0.02050151f, 0.01168312f, 0.01032811f, 0.02121959f, 0.02848830f, -0.00998081f, -0.03037686f, -0.01953433f, 
    0.00498180f, -0.03937560f, 0.01440221f, 0.00682654f, -0.01700107f, 0.01871649f, -0.01866156f, -0.01192143f, 
    0.01453680f, -0.01106440f, 0.00980932f, -0.01713923f, 0.01333851f, 0.00963638f, -0.03475987f, -0.03074683f, 
    -0.01994517f, 0.01543297f, -0.01415697f, -0.00988615f, 0.02230919f, -0.02305406f, 0.02097715f, -0.02049393f, 
    -0.01725879f, 0.00369002f, 0.02206182f, -0.02483397f, -0.03498791f, 0.00627809f, -0.01330572f, -0.03219168f, 
    -0.01708055f, 0.02358290f, -0.02426105f, -0.03265412f, 0.00526583f, 0.00496099f, -0.02483233f, -0.01766600f, 
    -0.02840058f, -0.03396392f, 0.00217548f, -0.00485896f, 0.02331628f, -0.01819074f, -0.01120545f, 0.02618249f, 
    -0.00071934f, 0.00647670f, 0.01934136f, 0.01558699f, -0.01606953f, 0.00334100f, -0.03946275f, 0.02042093f, 
    -0.01436655f, 0.00605024f, 0.01805407f, 0.01739311f, 0.00046021f, 0.01699561f, 0.02808539f, 0.02956259f, 
    0.02495092f, -0.01982002f, 0.00665484f, -0.03927591f, -0.03122636f, 0.00630166f, 0.00967272f, -0.01103572f, 
    0.00670815f, 0.00674477f, 0.00639113f, 0.02218604f, 0.02412310f, 0.01323528f, 0.02889121f, -0.01533177f, 
    -0.03827353f, -0.03583426f, -0.00823581f, 0.03001945f, 0.00114796f, -0.00014926f, 0.01143728f, -0.00982685f, 
    0.02011112f, -0.01119813f, -0.01872156f, -0.02376973f, 0.01951849f, -0.01090629f, 0.01097628f, 0.01177472f, 
    0.00082695f, 0.00509424f, 0.00118094f, -0.02096281f, -0.02422374f, -0.01489735f, 0.01582511f, -0.03735385f, 
    0.00119963f, 0.00482649f, -0.01145742f, 0.01420339f, -0.03562741f, 0.00285339f, -0.00873273f, 0.00040910f, 
    0.00301475f, 0.02988891f, -0.02209016f, 0.00812926f, 0.00791677f, 0.00817865f, 0.01541220f, -0.02922573f, 
    -0.03316450f, -0.02651911f, -0.03200408f, 0.01290314f, -0.01291820f, -0.03334160f, 0.02339464f, 0.00188885f, 
    -0.05802580f, 0.13770229f, 0.09550862f, -0.09867675f, 0.12762976f, 0.06864087f, 0.05120940f, -0.09559680f, 
    0.11822242f, 0.04045215f, 0.05253154f, 0.06289611f, 0.08743718f, -0.04114503f, 0.24155346f, 0.17718148f, 
    0.00571642f, 0.02114236f, 0.12530418f, 0.05965209f, -0.02839908f, -0.01072886f, 0.04952903f, -0.04562651f, 
    0.17363666f, -0.04213389f, 0.10022298f, 0.28602675f, -0.05515867f, 0.02474101f, 0.06210677f, 0.10914492f, 
    -0.04620869f, 0.00887958f, -0.02791356f, 0.06638391f, -0.07808460f, -0.01665702f, 0.01348285f, 0.25612092f, 
    -0.00150798f, 0.09779455f, 0.06738074f, 0.03013874f, 0.05662631f, -0.01513309f, 0.01412675f, -0.04185839f, 
    0.28179038f, -0.13100037f, 0.07858194f, -0.16456230f, 0.03278561f, -0.07243732f, -0.00656874f, 0.09263507f, 
    -0.01794732f, 0.09405334f, 0.10734104f, 0.06457315f, -0.12185356f, 0.00532484f, 0.02625172f, -0.11188108f, 
    0.05978721f, 0.00027674f, 0.05062972f, 0.05456455f, 0.12980428f, 0.01534516f, 0.05911926f, -0.01778850f, 
    0.10360000f, -0.17520206f, 0.11673436f, 0.17966178f, 0.06266163f, -0.00280060f, 0.06258857f, 0.11476189f, 
    -0.06359175f, 0.11179165f, -0.02106181f, 0.00113754f, 0.04894752f, 0.28323793f, 0.06650256f, -0.04196569f, 
    0.11466760f, 0.08585095f, 0.06595369f, 0.01290659f, 0.03086811f, -0.06034632f, 0.07882702f, 0.04321519f, 
    0.15028813f, 0.10100359f, -0.03849215f, 0.09763969f, -0.04461968f, 0.04721983f, -0.03768715f, 0.06025851f, 
    0.03832130f, 0.06872119f, -0.00649713f, 0.08205709f, 0.09079007f, -0.01056271f, -0.16426687f, 0.22146927f, 
    0.09495828f, 0.10351857f, -0.02514967f, 0.10266803f, -0.04321006f, -0.06605721f, 0.08895710f, -0.00359663f, 
    0.07830548f, 0.03615715f, 0.08647061f, 0.04834320f, 0.04125205f, 0.04395928f, 0.09054784f, 0.11346816f, 
    -0.03821616f, 0.01763220f, 0.03772100f, -0.00418610f, 0.06162505f, 0.26242980f, -0.06331252f, 0.11453377f, 
    -0.02389583f, 0.02913544f, -0.07375868f, 0.06292638f, 0.13087557f, 0.01705543f, 0.07804768f, -0.04337265f, 
    0.06978374f, 0.21612388f, 0.06829441f, -0.08998595f, 0.11274320f, 0.10367677f, 0.08536569f, 0.09296918f, 
    0.08064028f, 0.09311125f, -0.00746721f, 0.07039297f, 0.10151347f, 0.03927369f, 0.06158599f, 0.16825740f, 
    0.04012238f, 0.06120432f, 0.04778595f, 0.02439037f, -0.00862920f, -0.00889654f, 0.02460059f, 0.15967892f, 
    -0.18555614f, -0.08952721f, -0.01019325f, -0.06689285f, 0.01014252f, -0.04268050f, 0.02748747f, -0.02736812f, 
    0.09813060f, 0.05489630f, 0.01840411f, -0.03460364f, 0.10236496f, -0.08550651f, 0.23395973f, 0.09934691f, 
    0.17158194f, 0.07744652f, 0.16400772f, 0.09844401f, 0.01521972f, 0.00950487f, 0.07791881f, 0.09625598f, 
    0.00542717f, 0.04698796f, 0.01413306f, 0.13574986f, 0.09768599f, 0.05912121f, 0.04580776f, 0.06423169f, 
    0.07891297f, 0.17018718f, -0.08345988f, 0.08168861f, 0.13275263f, 0.10186025f, -0.00859333f, 0.03602726f, 
    0.12695320f, 0.12785156f, 0.00692456f, 0.05083438f, 0.15492642f, 0.04612361f, 0.05896789f, 0.06317278f, 
    0.09738189f, 0.03734989f, 0.16981761f, -0.00329079f, -0.11377426f, 0.06822968f, -0.01964165f, 0.00798118f, 
    0.09787021f, 0.10420769f, 0.04880564f, 0.03503522f, 0.11204890f, 0.28717288f, 0.07645910f, -0.07030911f, 
    0.16705534f, 0.02259756f, 0.04976012f, 0.04838490f, 0.12783694f, 0.12643129f, 0.06594851f, 0.00384420f, 
    0.26637602f, 0.24542412f, -0.03062374f, 0.06948084f, 0.15737024f, -0.02183889f, -0.01322566f, 0.06115162f, 
    0.02562120f, -0.01707329f, -0.02704794f, 0.11932774f, 0.08425699f, -0.00886868f, 0.24187586f, 0.13395691f, 
    -0.07689651f, -0.02370782f, -0.01171239f, 0.05210438f, 0.10560940f, 0.06458420f, 0.04294015f, 0.08877933f, 
    0.13856973f, 0.16446364f, 0.01583589f, -0.06769586f, 0.06249715f, 0.00344483f, 0.00245131f, -0.02085753f, 
    0.01805782f, 0.13547871f, 0.03596041f, -0.01831145f, 0.13762999f, -0.01467855f, 0.19033347f, 0.10234350f, 
    -0.17119527f, -0.07127437f, 0.01601667f, 0.11888804f, 0.03798932f, 0.08449790f, -0.07010468f, 0.09252899f, 
    0.16796598f, 0.29379332f, -0.02316953f, 0.00493177f, 0.10239471f, 0.05649986f, 0.11081149f, 0.10026666f, 
    0.17319407f, 0.03564790f, 0.01014772f, -0.03019224f, 0.07882150f, 0.03262753f, 0.27121097f, 0.00079239f, 
    0.09941021f, 0.05817818f, 0.02562879f, -0.01780421f, 0.18215163f, -0.01508909f, 0.08193660f, 0.04168259f, 
    0.28061229f, 0.05676589f, 0.23819816f, -0.12010203f, 0.09895843f, 0.07275277f, 0.10093044f, -0.07233331f, 
    0.06204206f, 0.13720797f, 0.06339022f, 0.06055127f, -0.21259144f, 0.13923849f, 0.03539044f, -0.04321337f, 
    0.02876878f, 0.01672064f, 0.01246833f, 0.09338444f, 0.18017538f, -0.01822118f, 0.06684906f, 0.04970798f, 
    0.05601735f, -0.00277986f, 0.04169975f, -0.11974247f, -0.05906691f, -0.01539541f, 0.10948185f, 0.07006826f, 
    -0.07238932f, -0.03022823f, 0.01746183f, -0.02482444f, 0.05561379f, 0.16594431f, 0.13140024f, -0.09514970f, 
    0.11946521f, 0.04761769f, 0.08259670f, -0.10236930f, 0.05938517f, 0.02307889f, -0.02671359f, 0.10650212f, 
    0.21197627f, -0.02224139f, -0.02977555f, -0.08113702f, -0.00144932f, -0.00346799f, 0.05295342f, 0.04101959f, 
    0.03602853f, 0.04753940f, 0.00878715f, 0.11875170f, 0.07021482f, 0.02611647f, 0.07356314f, 0.08182193f, 
    -0.21917933f, -0.07389873f, 0.05318348f, 0.02361268f, 0.03513266f, 0.12718463f, 0.01545322f, 0.00930744f, 
    0.02574443f, -0.19973950f, 0.01282958f, 0.02030610f, 0.00181358f, -0.07691215f, 0.09592455f, 0.07427429f, 
    -0.04481632f, 0.11944131f, -0.04223941f, 0.03492531f, 0.07368000f, -0.08404263f, 0.07531627f, 0.33509752f, 
    -0.11014435f, 0.05030520f, 0.08498946f, -0.03498469f, 0.13832217f, 0.00636926f, -0.02360353f, -0.00234266f, 
    -0.22072734f, 0.06224455f, 0.07884274f, -0.15663585f, -0.04031352f, 0.04141829f, 0.05297883f, -0.01551884f, 
    0.05219278f, 0.06285201f, 0.03339439f, 0.02603078f, -0.13257013f, 0.12061857f, -0.01564523f, -0.03789289f, 
    -0.00514829f, -0.01247374f, 0.00401863f, -0.00547444f, 0.00207294f, 0.08819146f, 0.07685194f, 0.04452448f, 
    0.00566804f, -0.07509740f, -0.01992272f, 0.00470208f, 0.09992819f, 0.10636819f, -0.03695907f, 0.02955095f, 
    0.02708955f, -0.06764647f, 0.07723844f, -0.03242013f, 0.08822302f, 0.12254725f, 0.28627062f, -0.25223136f, 
    0.03770991f, 0.02986681f, -0.00045253f, 0.11483196f, 0.03705822f, -0.00085922f, 0.10394057f, 0.08754813f, 
    -0.33024287f, 0.04136885f, 0.10126665f, 0.08289897f, 0.08322927f, 0.03612639f, -0.00591676f, 0.00460776f, 
    0.10724928f, 0.04598165f, 0.06593572f, 0.01478222f, -0.01523492f, -0.04134889f, -0.03596829f, 0.06871680f, 
    0.05779848f, 0.04578248f, -0.02309402f, 0.13869081f, 0.00458595f, -0.08058052f, 0.12643011f, -0.00290070f, 
    -0.05586676f, -0.12474658f, 0.04064135f, 0.15437806f, -0.04855160f, -0.01579995f, 0.04702506f, 0.11887193f, 
    -0.00497729f, -0.00267777f, 0.02171015f, 0.01235050f, -0.00809866f, -0.04326910f, -0.01533574f, -0.00124562f, 
    0.00563609f, 0.10646887f, 0.06908950f, 0.10802236f, 0.06276680f, 0.07339730f, 0.08691341f, 0.05350491f, 
    0.28728962f, -0.10049785f, 0.01262511f, 0.03979152f, 0.08638393f, 0.04118962f, 0.06440069f, -0.07181024f, 
    0.03373580f, 0.01503089f, 0.03531876f, 0.03269632f, 0.17060286f, -0.11131898f, 0.08618832f, -0.03008366f, 
    0.17951684f, 0.00783301f, -0.04099277f, 0.03440820f, -0.01127578f, -0.01633407f, 0.05003276f, 0.08544076f, 
    -0.12713665f, 0.07893842f, 0.13534202f, -0.01408473f, -0.22888464f, 0.05050601f, 0.07904762f, 0.08409533f, 
    0.06758081f, 0.07133637f, -0.02867311f, -0.04152047f, -0.10091857f, -0.03270255f, 0.12500955f, 0.08460255f, 
    -0.06252022f, 0.01856447f, -0.03609677f, 0.02051889f, 0.07538654f, 0.03712300f, -0.02172888f, -0.05588329f, 
    -0.13660164f, -0.07926876f, 0.07441546f, 0.12764947f, 0.08891427f, 0.00065811f, 0.05777097f, 0.05117213f, 
    0.09740400f, -0.06443943f, 0.00015006f, 0.02014535f, 0.07230608f, -0.02440479f, 0.14581904f, -0.01528215f, 
    0.08735409f, -0.00698813f, 0.01937915f, 0.06056339f, 0.11402516f, 0.02909474f, 0.00285404f, 0.03952385f, 
    0.14946543f, 0.06676039f, -0.02864454f, 0.21977465f, -0.03719195f, 0.13967073f, 0.05847763f, 0.03955229f, 
    0.13335568f, 0.09455638f, 0.07839187f, 0.05458573f, 0.33396611f, -0.15594341f, 0.06816357f, -0.03640774f, 
    -0.00903158f, -0.03128342f, 0.01200484f, 0.03951176f, 0.05483900f, 0.03262572f, 0.02625754f, 0.06951428f, 
    -0.16818871f, 0.08950774f, -0.01396750f, 0.13693194f, -0.14497413f, -0.01882675f, -0.01750440f, 0.04328751f, 
    0.03615015f, 0.01526504f, 0.07468938f, 0.05847586f, 0.07926149f, 0.04962271f, 0.03823996f, 0.07064666f, 
    0.02819228f, 0.01921395f, 0.04027578f, 0.01047972f, 0.12736334f, -0.00986948f, -0.02996443f, 0.08285871f, 
    -0.13914940f, 0.16282560f, 0.00673570f, -0.19698675f, 0.10315927f, -0.01063389f, 0.00929184f, -0.02067515f, 
    0.09492610f, -0.03443437f, -0.04731654f, 0.15384834f, 0.37796396f, -0.05537280f, 0.02858425f, 0.22887711f, 
    -0.09442703f, 0.02833750f, 0.02659602f, 0.02034380f, 0.09803498f, 0.07244844f, -0.08806544f, 0.01055079f, 
    0.14721048f, -0.22746870f, 0.05937095f, -0.08797286f, 0.07491447f, -0.00135565f, 0.08107397f, 0.12567878f, 
    -0.01052440f, 0.07278731f, 0.00787509f, 0.03884830f, 0.18131368f, 0.18591902f, -0.08894634f, -0.12618631f, 
    0.07757030f, 0.08551050f, 0.13233635f, -0.05546990f, 0.11611176f, 0.11925997f, 0.01236513f, 0.02323143f, 
    0.21589613f, -0.16769333f, 0.09490977f, 0.00086882f, 0.07053441f, -0.04764263f, -0.02859756f, 0.09362873f, 
    0.03654362f, 0.01727822f, -0.10709138f, 0.04338527f, 0.19050002f, -0.20819117f, 0.16312417f, -0.05403392f, 
    -0.00188886f, -0.01572473f, 0.14101395f, 0.12752637f, 0.01917170f, 0.05145238f, -0.00133677f, 0.06049109f, 
    -0.27266055f, 0.14861688f, 0.02668230f, -0.01570582f, 0.01660782f, 0.15235582f, -0.01202351f, 0.00608495f, 
    0.03332171f, 0.08956316f, 0.03275584f, -0.05927235f, 0.04658459f, -0.06004446f, 0.12412504f, 0.06522623f, 
    -0.03538315f, 0.03689443f, -0.01647437f, 0.05336823f, 0.02279880f, 0.11383300f, -0.13266781f, 0.03131501f, 
    0.09562366f, -0.06836467f, 0.07509622f, 0.09549794f, 0.02735933f, 0.05703324f, 0.11546820f, 0.05680376f, 
    -0.00219898f, 0.06524074f, 0.00739169f, 0.04559509f, 0.13630491f, 0.15937796f, 0.13585234f, 0.29664609f, 
    0.05589678f, 0.09368958f, 0.07884975f, 0.13034402f, -0.05436628f, 0.05771596f, 0.07703578f, 0.01281305f, 
    -0.00597479f, -0.04356224f, 0.00018492f, -0.12076143f, 0.03897803f, -0.05165157f, 0.00622422f, -0.01922162f, 
    -0.06969318f, 0.02720345f, 0.03805283f, 0.02040059f, 0.20805962f, 0.03500342f, -0.07622436f, -0.10120361f, 
    0.09370593f, 0.09911047f, 0.10386690f, -0.03997209f, 0.01345320f, 0.03203347f, 0.01297776f, 0.03101243f, 
    0.12734054f, -0.09602436f, -0.13711180f, 0.08862683f, -0.04049136f, -0.02348360f, 0.03950970f, 0.17955148f, 
    0.00621781f, 0.00403081f, -0.01668569f, 0.00920848f, -0.11581844f, 0.00365264f, -0.14627282f, -0.24276103f, 
    0.02030877f, 0.05338860f, -0.03584779f, 0.09374104f, 0.04486647f, 0.01192847f, -0.00604017f, 0.13292745f, 
    -0.08316048f, 0.09630612f, 0.00154070f, -0.07177725f, 0.13265528f, -0.02873394f, -0.02854499f, -0.05609073f, 
    0.02617982f, 0.10297740f, 0.02023028f, 0.06093764f, -0.04331314f, 0.20580357f, -0.05465165f, -0.15608601f, 
    0.03492091f, 0.04277625f, -0.04889143f, 0.05945003f, -0.05074933f, 0.08212878f, 0.08402082f, 0.05586497f, 
    -0.33813465f, 0.13116036f, 0.21489550f, 0.10802656f, 0.07024211f, 0.08743263f, 0.19196515f, 0.00949642f, 
    0.06861472f, -0.10403372f, -0.04709203f, -0.06112980f, -0.08010718f, -0.00421967f, 0.02259257f, 0.00725604f, 
    -0.03752574f, 0.07349768f, 0.06949070f, 0.01938156f, -0.04916850f, 0.06820583f, -0.01165097f, 0.05387549f, 
    -0.01139228f, 0.05153067f, -0.15356036f, 0.00457523f, 0.00152167f, 0.01262651f, 0.05252542f, 0.03819003f, 
    0.10822023f, 0.07098138f, 0.06931557f, -0.08455380f, 0.23315786f, -0.20119767f, -0.13212618f, 0.02579614f, 
    -0.06016013f, -0.05582483f, -0.08696278f, 0.10807687f, 0.06797735f, 0.02707740f, 0.10872149f, 0.04386713f, 
    -0.07160009f, -0.05933118f, -0.06587815f, -0.09018040f, 0.05093547f, 0.02924957f, 0.04178490f, -0.02047480f, 
    0.03313602f, -0.02055103f, 0.01951325f, 0.05412758f, 0.07943262f, 0.03382912f, -0.11751732f, 0.08416770f, 
    0.01471172f, -0.08554924f, 0.00388968f, 0.04301002f, 0.10904286f, 0.04450318f, 0.01650849f, 0.09370663f, 
    -0.15078562f, -0.11097378f, 0.13315623f, -0.11587089f, 0.09905601f, 0.10287697f, -0.02490773f, 0.00113549f, 
    0.11279744f, 0.01044589f, 0.04226374f, 0.08827259f, 0.05356948f, -0.07072752f, -0.04224649f, -0.11826158f, 
    0.06055377f, 0.02702930f, 0.02988134f, 0.06899699f, -0.05392446f, 0.06908381f, -0.08936874f, 0.06477059f, 
    0.14124334f, -0.08172330f, -0.07680232f, 0.16328165f, -0.08637393f, -0.05099382f, -0.00240691f, 0.01620086f, 
    -0.06811158f, 0.00439395f, -0.00413368f, -0.02829978f, -0.10451621f, 0.02138058f, 0.10024185f, -0.07797200f, 
    0.03017924f, 0.02258776f, 0.02155910f, 0.04261931f, 0.08911168f, -0.00565911f, 0.00094778f, -0.01677596f, 
    -0.02366890f, 0.08785298f, 0.23165366f, 0.02529634f, 0.05669593f, 0.12951432f, -0.01131128f, 0.08572426f, 
    0.00022475f, 0.06082642f, 0.05840818f, 0.02665115f, -0.19503669f, -0.06495164f, -0.24321057f, 0.06890097f, 
    -0.06224662f, -0.04646840f, -0.04642104f, 0.09089468f, 0.07601128f, 0.04762781f, -0.07579003f, -0.04096261f, 
    0.16107309f, 0.04433834f, -0.17061959f, -0.06041311f, -0.03221988f, 0.00796061f, -0.02763097f, 0.04916921f, 
    0.02296267f, -0.08295903f, 0.04429434f, -0.04834699f, -0.11863576f, -0.20859906f, -0.03782985f, -0.02464584f, 
    -0.09558055f, -0.05566099f, 0.06124609f, 0.06262319f, -0.11152621f, -0.07336855f, 0.02469037f, -0.00538980f, 
    -0.07732254f, 0.07729565f, -0.14573325f, -0.02367014f, 0.13761324f, -0.02147253f, 0.05694968f, 0.05494295f, 
    0.02244190f, -0.05716276f, 0.10291437f, 0.06261642f, 0.15486595f, -0.30701399f, 0.00360139f, 0.03407514f, 
    -0.19491319f, 0.06014897f, 0.01328807f, -0.02178250f, -0.08043692f, -0.00473179f, -0.10255031f, 0.03882503f, 
    -0.03327653f, -0.19986281f, -0.03458654f, -0.02121283f, -0.12598386f, -0.02067007f, 0.03497165f, 0.09687330f, 
    -0.00367193f, 0.15225959f, 0.02733136f, 0.00191412f, 0.02586468f, 0.25793630f, 0.02484023f, -0.17298040f, 
    0.12702194f, 0.12091602f, -0.03522272f, 0.04617724f, -0.06100407f, 0.04710684f, -0.09766050f, -0.11530770f, 
    0.03979263f, -0.12308510f, -0.08471420f, 0.10360108f, 0.00104491f, 0.05370987f, 0.07011862f, 0.05716784f, 
    0.00818039f, -0.05685790f, 0.09406212f, 0.07243978f, 0.11239143f, 0.18647283f, 0.03056878f, -0.22369966f, 
    0.12536414f, 0.06113784f, 0.00362587f, -0.06280959f, 0.10774219f, 0.05343698f, 0.08852606f, -0.10212518f, 
    0.06716640f, -0.23355946f, 0.05581285f, 0.02519287f, -0.02644306f, 0.02239282f, 0.03669905f, -0.04839752f, 
    -0.08549339f, 0.14623725f, 0.05605269f, 0.10241565f, 0.07644956f, -0.12387240f, -0.12082197f, 0.01006424f, 
    -0.09579071f, -0.03785020f, 0.07752128f, 0.11940916f, -0.08013756f, 0.08182397f, -0.03897426f, -0.05785992f, 
    -0.35189676f, -0.22988930f, -0.16875961f, 0.15532221f, -0.15232196f, -0.06660756f, 0.03662356f, 0.13790676f, 
    0.00350815f, -0.10110378f, 0.04390929f, 0.00759446f, 0.18468642f, -0.02127605f, -0.09250303f, 0.08410840f, 
    0.11664259f, 0.03342608f, 0.08228718f, -0.05520302f, -0.00126145f, -0.05340211f, -0.01438913f, -0.00471782f, 
    -0.01042866f, 0.02853653f, 0.17581902f, 0.01951267f, 0.09673660f, 0.09383883f, -0.06204825f, 0.01494374f, 
    0.07751670f, 0.10186724f, 0.06067541f, 0.03695799f, 0.09032604f, -0.16777545f, -0.05444736f, 0.11737180f, 
    -0.07862581f, 0.05680444f, -0.04117529f, 0.16459623f, 0.03100881f, 0.04821834f, 0.04179306f, -0.00544688f, 
    -0.18923812f, -0.04172929f, 0.18099870f, 0.08808999f, 0.00583172f, 0.05128278f, 0.13086319f, 0.02500614f, 
    -0.00494773f, -0.01808235f, 0.10507906f, -0.03588346f, 0.01687324f, 0.15112218f, 0.09593072f, -0.16466832f, 
    0.14633609f, 0.00932375f, -0.07129014f, -0.01968396f, 0.01415145f, -0.06053923f, 0.04640832f, 0.05876240f, 
    -0.16843949f, 0.03598316f, 0.18669236f, 0.00541690f, 0.02180375f, 0.14279257f, 0.09463927f, -0.05336070f, 
    0.06454048f, -0.05388865f, 0.13512632f, -0.03470935f, -0.10208472f, 0.06200533f, 0.12790121f, -0.19887739f, 
    0.11572532f, 0.01593096f, -0.02436069f, -0.03115214f, -0.07516948f, -0.00089518f, 0.00137151f, 0.05189878f, 
    0.09797966f, -0.22977807f, 0.11074205f, 0.03302764f, 0.08357541f, 0.04055633f, 0.08599621f, 0.06205893f, 
    0.03414712f, -0.05250482f, -0.09228165f, -0.00234795f, 0.21293786f, 0.02079614f, 0.11231646f, 0.15583847f, 
    0.04101102f, 0.09690970f, 0.10634588f, 0.03930555f, 0.07181147f, -0.02376370f, 0.04928697f, -0.05711319f, 
    0.13722761f, 0.05423906f, 0.04926331f, 0.12865987f, 0.01108745f, -0.05166223f, 0.05557289f, 0.19289856f, 
    0.07610344f, 0.07515992f, -0.01674830f, 0.10463092f, -0.15584436f, -0.02233001f, -0.17003599f, 0.10130207f, 
    -0.01461324f, -0.00830950f, 0.04592811f, -0.06382871f, -0.01395189f, -0.00660624f, -0.04780728f, 0.03673526f, 
    0.14049239f, 0.20112811f, -0.06464075f, -0.12536770f, 0.05772446f, 0.04874702f, 0.01898967f, 0.06221800f, 
    0.02029304f, 0.04620480f, 0.07418337f, 0.02190086f, 0.11818282f, 0.04012788f, -0.07381167f, 0.07347953f, 
    0.05856263f, 0.00112568f, 0.03499106f, 0.01448873f, 0.09673856f, 0.06087416f, -0.12000498f, 0.00380835f, 
    -0.07169423f, 0.16989829f, -0.01123886f, -0.06562934f, 0.11351226f, 0.12661262f, 0.07962167f, -0.01008634f, 
    0.14367028f, 0.10137755f, 0.01150892f, -0.07117692f, 0.11538567f, 0.05543494f, -0.00431304f, 0.06038055f, 
    0.12900977f, -0.09288684f, 0.04511120f, 0.06694855f, 0.07855079f, -0.05006815f, 0.06446172f, 0.02401406f, 
    -0.18774974f, 0.09792968f, 0.12669303f, 0.06018917f, -0.03278939f, 0.02952790f, 0.02653784f, 0.09149221f, 
    0.04622083f, 0.06942505f, 0.06269100f, 0.03315388f, -0.02578252f, 0.05166068f, -0.08327590f, 0.10034943f, 
    -0.08916672f, -0.02843291f, 0.02921226f, 0.09248888f, 0.07532053f, -0.03415673f, 0.15204196f, 0.01165293f, 
    0.07294721f, 0.10819203f, -0.04603789f, -0.07367826f, 0.16473539f, 0.00825317f, -0.10431145f, -0.02346530f, 
    0.01390583f, 0.09497875f, 0.03899560f, 0.11705852f, 0.06355198f, 0.09092290f, -0.05705216f, 0.06738955f, 
    0.12690668f, 0.06515632f, 0.04205609f, 0.00707364f, 0.05906448f, 0.02794246f, 0.09501642f, 0.08803585f, 
    0.17650501f, 0.19579549f, -0.11556032f, -0.01517589f, 0.04307895f, 0.01607772f, -0.05798784f, 0.05235970f, 
    0.04991217f, 0.12989141f, 0.09397872f, 0.09911428f, 0.10630977f, 0.08923271f, -0.08930130f, 0.02403675f, 
    -0.07729219f, 0.08390706f, -0.00702595f, 0.01089366f, 0.00173300f, 0.08198468f, 0.04395249f, 0.05319154f, 
    -0.04804903f, -0.02446221f, -0.11477956f, -0.16745310f, 0.18589047f, -0.09826288f, -0.03890027f, 0.04305365f, 
    -0.06155677f, -0.08376151f, -0.07570878f, 0.11742660f, -0.26503465f, -0.08818421f, 0.10421746f, 0.15609297f, 
    -0.00594867f, 0.07290870f, 0.14868124f, 0.03769015f, 0.06633016f, 0.01700246f, -0.00742446f, 0.02389767f, 
    0.20772755f, -0.00941720f, -0.12757967f, -0.16431716f, 0.12901440f, 0.04652134f, 0.04205890f, 0.05821184f, 
    0.05046758f, -0.07829142f, 0.08522750f, -0.00809191f, -0.04349449f, 0.01985551f, -0.04313214f, -0.02932289f, 
    -0.00787712f, -0.03408249f, -0.01283859f, 0.03901882f, -0.01073452f, 0.08689994f, 0.15164903f, 0.04844414f, 
    0.11840071f, -0.12833272f, -0.05330944f, -0.01386180f, -0.04919434f, 0.13391960f, 0.06299142f, 0.01722417f, 
    -0.00887080f, 0.04321986f, 0.12921762f, 0.00732796f, -0.37632042f, 0.06454338f, 0.03996832f, -0.14728436f, 
    0.11797376f, 0.10320792f, 0.01410269f, -0.02527817f, 0.01122390f, -0.03136255f, 0.11569782f, 0.08400004f, 
    0.05334172f, 0.06864228f, -0.00312994f, 0.15070704f, -0.01419198f, 0.04078009f, 0.09317507f, 0.00183609f, 
    0.02827779f, 0.01047771f, 0.00408922f, 0.03116633f, -0.13026141f, -0.12419823f, 0.00843990f, 0.15658410f, 
    -0.11378157f, -0.05822484f, -0.04432941f, 0.22205369f, -0.02988243f, 0.01166185f, -0.00919741f, 0.08091249f, 
    -0.12402721f, 0.19269323f, 0.07199741f, 0.11299469f, 0.07220583f, 0.05245186f, 0.05055925f, 0.01782065f, 
    0.10646348f, -0.02162486f, 0.15167835f, 0.10763922f, -0.16116832f, -0.04414511f, 0.04410287f, -0.00009147f, 
    0.09115791f, 0.06489816f, 0.04179265f, -0.09426799f, 0.05133063f, 0.00693596f, 0.04334657f, 0.02320028f, 
    0.31093907f, -0.01641353f, -0.04863330f, -0.09932764f, -0.08910071f, -0.04542936f, 0.11143959f, 0.07627090f, 
    -0.07965635f, -0.04470022f, -0.04969161f, 0.11299680f, 0.04909028f, 0.17324883f, -0.08190806f, -0.02570012f, 
    0.04868295f, -0.02180693f, -0.00662193f, -0.05597230f, 0.04550861f, 0.03757126f, 0.12838575f, 0.11441410f, 
    -0.03573048f, 0.01109309f, 0.06767923f, -0.07203946f, 0.02171534f, 0.04357684f, 0.05708740f, -0.05934403f, 
    0.02840769f, -0.03103373f, 0.14306904f, -0.01882662f, -0.09672732f, -0.10901544f, -0.02469557f, -0.16546437f, 
    -0.07020307f, -0.07531176f, 0.01397476f, -0.07437301f, 0.10611015f, 0.00536538f, 0.01832608f, 0.13323559f, 
    -0.00714471f, 0.01671015f, 0.01534221f, 0.07613282f, 0.03392804f, 0.06533028f, -0.03812470f, 0.10629507f, 
    0.12310100f, -0.01196438f, -0.01500867f, 0.02925298f, -0.17068167f, -0.17368230f, 0.14345600f, 0.02683774f, 
    -0.00063479f, 0.00555118f, 0.10176838f, 0.06219190f, -0.06159723f, 0.06597708f, 0.02144023f, 0.00897612f, 
    -0.03087257f, -0.00754038f, 0.00129864f, 0.00890461f, -0.01886052f, -0.04086916f, -0.02178981f, -0.01368495f, 
    -0.02700376f, -0.02167431f, -0.00532633f, 0.00200576f, 0.01294759f, -0.03521404f, -0.03447587f, 0.01956530f, 
    0.01256776f, -0.00024226f, -0.03196739f, 0.03311351f, -0.02925985f, -0.00090109f, -0.02043147f, 0.01454438f, 
    -0.01107315f, 0.02496967f, -0.03441831f, -0.01837613f, 0.01901754f, -0.02839756f, -0.01776764f, 0.01390788f, 
    0.01564245f, -0.00743789f, 0.01653104f, 0.02690064f, -0.03362825f, -0.01267259f, 0.00741785f, 0.02833559f, 
    -0.02621321f, -0.00828594f, -0.04085408f, 0.02944927f, -0.04593079f, -0.03720621f, -0.00839673f, 0.01704713f, 
    -0.00548559f, 0.00105426f, -0.02283968f, 0.01601897f, 0.01565067f, -0.01357841f, -0.03453198f, 0.02262682f, 
    -0.00473533f, 0.00807414f, -0.00677576f, -0.00479739f, -0.00066088f, 0.02139811f, -0.03013962f, -0.01985534f, 
    -0.02620162f, 0.00232708f, 0.03211365f, -0.02853552f, 0.01757865f, 0.01635911f, -0.01220062f, 0.03185556f, 
    0.00571231f, 0.00599206f, 0.02411130f, -0.00063168f, -0.01284560f, -0.03394592f, 0.02597884f, 0.02403806f, 
    -0.01126574f, 0.01872971f, 0.01571503f, -0.01940608f, -0.03969947f, -0.00650317f, 0.00134670f, -0.00467833f, 
    0.02090180f, 0.01871842f, -0.00643193f, -0.00344915f, -0.00879638f, -0.02216453f, -0.00663940f, -0.03700210f, 
    -0.03130465f, -0.00694693f, -0.02541988f, 0.03102779f, 0.01049961f, -0.02595458f, 0.00880965f, -0.01140477f, 
    0.02571010f, 0.01929502f, -0.02730925f, -0.03443935f, -0.00094034f, -0.04301826f, 0.00413042f, -0.00546617f, 
    -0.00247365f, -0.02309437f, 0.02390227f, -0.02041980f, -0.02513539f, -0.00040085f, -0.01666605f, -0.00848220f, 
    -0.00676917f, -0.02816003f, -0.00148993f, -0.00818743f, -0.02160469f, 0.03021245f, -0.02831317f, 0.00964224f, 
    0.01400977f, 0.01507247f, -0.00112890f, 0.02658819f, -0.03997878f, -0.02325423f, -0.02124341f, 0.00537612f, 
    -0.00023428f, -0.03305150f, -0.02166849f, -0.00101130f, -0.03087809f, -0.02643310f, -0.03142419f, 0.00470942f, 
    -0.02943727f, -0.00643221f, 0.03564511f, 0.02044763f, -0.02843865f, 0.03184108f, 0.02118856f, -0.02697806f, 
    0.01688449f, 0.02878387f, -0.01410240f, 0.02281591f, -0.02995844f, 0.03074366f, 0.03424232f, -0.02902323f, 
    -0.02562410f, -0.01057713f, -0.03534001f, 0.00884733f, -0.00646380f, -0.02261595f, 0.00509829f, -0.01946036f, 
    -0.02759731f, -0.01791569f, -0.01803852f, 0.02415628f, 0.02141476f, 0.01307407f, 0.03145621f, -0.03940645f, 
    -0.00131043f, -0.02641828f, -0.00225248f, -0.02737391f, 0.00604872f, 0.00170216f, -0.00880293f, -0.00355468f, 
    -0.03434615f, 0.02825886f, 0.01884723f, 0.01966200f, 0.03118712f, -0.03232276f, -0.01369797f, -0.01710670f, 
    0.00327847f, -0.00432940f, -0.03004518f, 0.00175606f, -0.02987231f, 0.00548854f, -0.01598255f, 0.00327715f, 
    -0.03553992f, -0.00854902f, -0.01577080f, -0.02297979f, -0.03318544f, -0.01128944f, 0.00938886f, -0.01259196f, 
    0.01423770f, -0.00330376f, 0.01280183f, 0.02438409f, -0.03353190f, 0.03356186f, -0.00142989f, 0.00296826f, 
    0.02346712f, -0.00466479f, 0.02553511f, 0.00378291f, 0.02549841f, -0.01092883f, -0.01585414f, -0.03409656f, 
    0.01191921f, 0.02459575f, 0.01167388f, 0.01966717f, -0.02519686f, 0.00682026f, 0.02225203f, -0.01206491f, 
    0.00283068f, -0.02045740f, -0.01938740f, -0.01774690f, -0.00693997f, 0.02377934f, -0.00431933f, 0.02123087f, 
    -0.02688439f, 0.03406689f, 0.00263967f, -0.02331465f, -0.03091655f, -0.02682061f, -0.00925895f, -0.02974571f, 
    -0.02990977f, -0.03352879f, 0.00734722f, -0.03109667f, 0.01071901f, -0.02464991f, 0.02103246f, -0.04035265f, 
    -0.02002893f, 0.00184563f, 0.00239314f, 0.00386810f, 0.02402183f, -0.03313626f, 0.01078056f, 0.02710297f, 
    -0.00389676f, -0.02520537f, -0.03104144f, -0.02589687f, -0.00515771f, 0.00740527f, -0.02638416f, 0.02948432f, 
    0.02044277f, -0.01616321f, -0.01367660f, -0.01083107f, 0.02629802f, -0.01269410f, -0.00098694f, 0.01540868f, 
    -0.02685015f, 0.00270008f, -0.02092504f, 0.00601723f, -0.02883426f, 0.02219759f, -0.01870687f, 0.02340747f, 
    0.00750887f, -0.03441698f, -0.02382165f, 0.00518316f, 0.00477558f, -0.03001876f, 0.00655021f, 0.01805755f, 
    0.00712662f, -0.00431185f, -0.03810319f, 0.01167223f, -0.02298804f, 0.00523020f, 0.01267388f, 0.02342047f, 
    -0.01632369f, 0.00067509f, -0.01434922f, 0.01627054f, 0.03341421f, 0.02769224f, -0.00507726f, -0.03746499f, 
    0.02278338f, 0.00321282f, -0.02739790f, -0.00618609f, 0.01645122f, -0.01411081f, 0.00256607f, -0.02866334f, 
    -0.01148532f, -0.00910834f, 0.01168091f, 0.00852627f, 0.01386620f, -0.01718229f, 0.00875230f, 0.03487791f, 
    0.01428452f, 0.00160987f, 0.02902439f, 0.00738355f, 0.01185390f, 0.00026236f, -0.03523483f, -0.02705538f, 
    0.00960573f, 0.00300057f, -0.04438091f, -0.01509349f, 0.02972078f, -0.00894152f, -0.02364421f, -0.04030704f, 
    -0.00962056f, -0.02218511f, 0.02809587f, -0.02941874f, 0.00724046f, 0.02281410f, -0.00164472f, -0.02458621f, 
    0.03910846f, -0.03224184f, -0.01300289f, -0.04020489f, -0.04207632f, 0.00159793f, -0.03610195f, -0.03213580f, 
    -0.01073992f, -0.01805003f, 0.01348047f, 0.00963685f, -0.00449105f, -0.00183454f, -0.03693560f, -0.04114272f, 
    0.00961685f, 0.03842302f, -0.00373581f, 0.04445006f, 0.00476194f, -0.03897392f, 0.02689551f, 0.01728759f, 
    -0.01902048f, 0.01506415f, 0.01193018f, -0.02806340f, -0.03478267f, -0.04250914f, 0.02763864f, -0.00020353f, 
    -0.01288266f, -0.01723978f, -0.00954037f, -0.02941877f, -0.02292929f, 0.02968790f, -0.03680591f, 0.01550421f, 
    0.00625438f, -0.03467212f, 0.00793765f, 0.01182016f, 0.00210169f, -0.03089661f, -0.01419212f, -0.00700196f, 
    -0.01924702f, 0.02119510f, -0.00519171f, -0.02614239f, 0.01910930f, 0.00265349f, 0.00858863f, -0.00929591f, 
    0.02818308f, -0.02345081f, -0.00480350f, 0.00037471f, -0.03593226f, -0.02858879f, -0.00516515f, 0.00867030f, 
    -0.01997925f, 0.00367224f, -0.02717967f, -0.01854346f, -0.02288066f, 0.00005685f, -0.01218734f, -0.00989841f, 
    0.02502421f, -0.02755648f, 0.01111845f, -0.00910336f, -0.00083139f, -0.03173222f, 0.01832172f, -0.00574699f, 
    0.03036812f, -0.02991155f, 0.01972525f, 0.01609427f, 0.02499251f, -0.00108863f, 0.01236865f, -0.02396129f, 
    0.01699234f, 0.00101789f, -0.01856245f, 0.03023718f, 0.00010728f, 0.00177930f, 0.02135607f, -0.01776373f, 
    0.00532342f, 0.02654578f, -0.00753560f, -0.01107157f, 0.01316237f, -0.03521934f, -0.02025461f, 0.02804234f, 
    -0.00987597f, 0.00115521f, 0.02010006f, -0.03593768f, -0.00356028f, -0.00618585f, 0.01310408f, -0.03794122f, 
    -0.00344452f, -0.01548616f, 0.01823216f, 0.01941664f, 0.02364268f, -0.00332320f, 0.02080599f, -0.01555395f, 
    -0.02479592f, -0.03546760f, -0.02425916f, 0.03329465f, -0.02915986f, 0.01242502f, -0.00677670f, 0.00908459f, 
    -0.03446759f, -0.01195797f, -0.03058188f, 0.02739475f, 0.00907137f, 0.01810559f, -0.01127174f, -0.01268260f, 
    0.00587166f, -0.02986683f, -0.00612182f, 0.02982979f, 0.02502201f, 0.01013057f, 0.03269718f, 0.02587046f, 
    0.01210220f, -0.00039931f, -0.01880563f, -0.00040819f, 0.03009227f, -0.02275878f, -0.01276964f, 0.00465336f, 
    -0.02973625f, -0.03747910f, 0.02744386f, -0.00080768f, 0.01306321f, -0.00255848f, 0.03090533f, -0.01591434f, 
    -0.02322657f, -0.03708928f, -0.03164189f, -0.00422586f, -0.03902347f, -0.03836248f, 0.01429067f, -0.00065576f, 
    0.01727150f, 0.03417512f, -0.01576762f, -0.03824812f, 0.02520202f, -0.03802000f, -0.03521973f, 0.03010745f, 
    0.00860802f, -0.03483797f, -0.00330390f, 0.00611073f, 0.01781793f, 0.01400794f, 0.00913883f, -0.01277279f, 
    -0.00018897f, 0.00262899f, -0.02598302f, 0.01598771f, 0.02397371f, -0.02171881f, 0.02518894f, -0.00006441f, 
    0.02886179f, -0.01030356f, -0.03154311f, -0.00915984f, 0.03482461f, 0.01116574f, 0.03208637f, -0.03246326f, 
    -0.01892048f, 0.00050852f, -0.00185587f, 0.02088125f, 0.02437882f, -0.00808894f, 0.01121229f, -0.03193696f, 
    -0.02927011f, -0.03213549f, -0.01789601f, 0.00522599f, 0.02328895f, 0.02461124f, 0.02084896f, -0.00444194f, 
    0.02777041f, -0.00992107f, -0.02562012f, -0.01125260f, 0.02964761f, 0.00029053f, 0.00648889f, -0.00697548f, 
    -0.03711863f, -0.01090657f, 0.01659929f, -0.02166172f, 0.00072320f, -0.02998286f, 0.00064033f, -0.00840487f, 
    -0.02879649f, 0.01054373f, -0.01970658f, 0.02313804f, 0.02662276f, 0.01297424f, -0.00544221f, -0.02709749f, 
    0.00739819f, -0.02331792f, 0.00165012f, -0.02949570f, 0.03006884f, -0.02130305f, -0.03206134f, -0.03731500f, 
    -0.01086236f, -0.04346404f, -0.00685692f, 0.00175696f, 0.00434224f, 0.01685718f, -0.01584143f, -0.02064835f, 
    0.01605157f, -0.01423381f, 0.03321945f, 0.03260549f, -0.01775208f, 0.03414436f, 0.01286068f, -0.00798771f, 
    -0.03433189f, -0.00857716f, 0.00537726f, -0.02767853f, -0.01197880f, 0.01636889f, 0.02101708f, 0.03929088f, 
    0.01988097f, 0.02139441f, -0.02700946f, 0.01388552f, -0.00165125f, -0.02858200f, -0.01584913f, -0.03082512f, 
    -0.01072922f, -0.01199366f, 0.00166054f, -0.02770750f, -0.01038261f, -0.00852463f, -0.02728952f, 0.01403295f, 
    0.01689082f, -0.00013743f, 0.01630901f, 0.01196136f, -0.01890563f, -0.03733056f, 0.00785068f, 0.01906042f, 
    -0.02974230f, -0.02701740f, -0.01331357f, 0.02202723f, 0.00054467f, -0.00085993f, 0.00222849f, -0.01025899f, 
    0.01255782f, -0.00610551f, -0.01539588f, 0.01060048f, -0.00972273f, 0.00919820f, -0.02975193f, 0.02734033f, 
    0.00065404f, 0.00275625f, 0.02444577f, -0.03583860f, -0.02478816f, -0.03182102f, 0.02296074f, 0.02273328f, 
    -0.00599394f, 0.00804628f, -0.00288812f, -0.02557705f, -0.03504968f, 0.01947142f, 0.01859084f, 0.00427747f, 
    -0.03744319f, -0.00053964f, -0.03650338f, -0.01956738f, 0.01107631f, 0.00998098f, 0.02420631f, -0.04188725f, 
    -0.01203177f, 0.03602497f, -0.03812384f, -0.03477179f, -0.02180696f, 0.02567587f, 0.01400337f, 0.03199131f, 
    -0.02418192f, 0.02552694f, 0.00852671f, -0.01929243f, -0.01034648f, 0.00524414f, 0.00576698f, -0.02470098f, 
    0.00808310f, 0.00822685f, -0.02993460f, -0.02295743f, 0.02497031f, -0.02181349f, 0.02288412f, -0.01932091f, 
    0.01627208f, -0.03276460f, 0.00007924f, 0.00051747f, 0.02425214f, -0.01971418f, 0.01765547f, 0.02837186f, 
    0.00774004f, -0.03022025f, -0.03429856f, -0.01844314f, 0.01986438f, 0.01350613f, -0.02707014f, -0.02256483f, 
    0.01099456f, -0.03758306f, -0.02358926f, -0.00981070f, 0.01574535f, 0.00908342f, 0.01412843f, -0.00550851f, 
    0.00558446f, 0.00397525f, -0.00706067f, -0.02223275f, 0.03227836f, 0.00130876f, 0.00739564f, -0.02953794f, 
    0.03772694f, -0.00898504f, 0.03158987f, 0.00823757f, -0.01829067f, 0.02995212f, -0.00778817f, 0.02388351f, 
    -0.02177063f, 0.02311210f, 0.02724745f, -0.01970077f, -0.00992259f, -0.02178986f, 0.00634200f, 0.03218381f, 
    -0.02850147f, 0.02515558f, -0.01898951f, -0.03449820f, -0.02948188f, 0.00268534f, -0.01903438f, -0.03397988f, 
    0.05738904f, 0.04793638f, -0.00753776f, 0.03450042f, -0.11319342f, 0.12983048f, -0.04985864f, 0.14037572f, 
    -0.02620851f, 0.01027172f, -0.11877787f, 0.03815324f, -0.23852821f, 0.06518859f, -0.01626744f, -0.16241965f, 
    0.11156841f, 0.07398456f, 0.00048297f, -0.06839339f, 0.08530124f, 0.03293798f, 0.03896253f, -0.07263194f, 
    -0.06590991f, 0.12412052f, -0.06291208f, 0.02813541f, 0.04109512f, -0.02453622f, 0.02131927f, -0.02842029f, 
    -0.02774209f, 0.13434911f, -0.02198602f, 0.03772642f, 0.05722106f, 0.00891467f, -0.17107064f, 0.12768948f, 
    -0.04823080f, -0.00285461f, -0.01550352f, -0.21702334f, 0.05701904f, 0.01637925f, 0.08537114f, -0.01885577f, 
    0.02556198f, 0.14092878f, 0.11846498f, -0.11080533f, 0.07415111f, -0.01199299f, 0.13370708f, -0.08246017f, 
    -0.01807509f, 0.00718366f, 0.00585375f, 0.01663222f, 0.12985525f, 0.11156316f, 0.01364742f, 0.04082547f, 
    0.04954572f, -0.02120570f, 0.06223740f, -0.05714374f, -0.04882972f, 0.03374446f, 0.13421753f, -0.11878800f, 
    0.12585162f, -0.07442065f, 0.05588651f, -0.07363401f, -0.04253578f, 0.05123683f, 0.07053128f, 0.02996469f, 
    -0.06237054f, -0.02486285f, 0.05446692f, -0.07488491f, 0.10921072f, -0.11864258f, 0.00690806f, -0.06313668f, 
    -0.00270940f, 0.01420720f, -0.09431004f, -0.02057591f, -0.01839503f, 0.06535581f, 0.09893651f, 0.05124699f, 
    0.09944901f, -0.01605665f, -0.12494326f, 0.25173846f, 0.06013674f, -0.04822967f, 0.03728452f, -0.03695621f, 
    0.04499688f, -0.00899021f, -0.07338373f, 0.01404262f, -0.10980043f, 0.02316191f, -0.15485461f, 0.18621662f, 
    0.10181806f, 0.09852177f, -0.09215485f, 0.05745757f, 0.00951719f, 0.08882449f, -0.03792193f, -0.02859698f, 
    -0.39277169f, -0.13761806f, -0.07824083f, -0.24306588f, 0.08157636f, -0.07417243f, 0.01240001f, -0.02147031f, 
    0.07744047f, 0.07870328f, 0.04760087f, -0.00216311f, 0.17835666f, -0.05972913f, -0.14027536f, 0.16436133f, 
    0.04491874f, -0.01188599f, -0.00979672f, -0.02200281f, -0.00077617f, 0.11673001f, -0.06878124f, 0.05592710f, 
    -0.10798067f, -0.22183622f, -0.16198373f, 0.06399475f, -0.09072395f, 0.06920815f, 0.00223055f, 0.09735849f, 
    -0.10893731f, -0.00507851f, 0.00667379f, -0.05708564f, -0.16634664f, -0.02195337f, -0.03106317f, -0.07614448f, 
    0.00612254f, -0.03559853f, 0.06968361f, -0.01657530f, 0.06360771f, 0.08870697f, -0.00596627f, 0.03707675f, 
    0.23064138f, 0.00025802f, 0.17128418f, -0.08160727f, 0.01475049f, -0.02713202f, -0.03612237f, 0.05220791f, 
    -0.00197125f, 0.03311809f, 0.04874409f, -0.04215380f, -0.03067053f, 0.05789696f, 0.10537572f, 0.01824828f, 
    0.01867858f, 0.04836578f, -0.00649503f, 0.11210655f, 0.06792326f, -0.05320955f, -0.04923994f, 0.08703349f, 
    0.38499820f, -0.11178871f, -0.24011260f, -0.15016814f, -0.06937783f, 0.09211385f, -0.01148112f, -0.02885846f, 
    0.02554277f, 0.04464430f, 0.04212613f, -0.16356856f, 0.20075996f, -0.00300989f, 0.23963560f, 0.13505152f, 
    0.05244453f, 0.06768235f, 0.03775902f, 0.08458288f, -0.06847905f, -0.02511560f, 0.10395571f, 0.02276514f, 
    0.04737039f, 0.04782313f, -0.10796002f, 0.09502693f, 0.08109875f, 0.10533066f, -0.06882048f, 0.06466595f, 
    0.02994377f, 0.04063529f, 0.10524591f, 0.03914729f, 0.44049886f, -0.12944402f, 0.00409925f, 0.08946260f, 
    0.11990015f, -0.07102055f, 0.01633043f, -0.02873586f, 0.00947295f, 0.09489546f, -0.04724635f, 0.08277421f, 
    0.19039927f, -0.06517348f, 0.19924819f, 0.10119739f, -0.04906546f, -0.02135632f, 0.04172334f, 0.10906903f, 
    0.00983585f, 0.11820517f, 0.00647640f, -0.04549183f, -0.01549957f, 0.21018288f, -0.10939480f, -0.16719937f, 
    -0.02383424f, -0.02316594f, -0.09002069f, -0.01997117f, -0.01907870f, 0.01106455f, -0.13327186f, -0.18119965f, 
    -0.04187314f, 0.05093334f, -0.07932380f, 0.05408737f, 0.05245750f, 0.02906505f, 0.01729791f, -0.05779081f, 
    0.07319186f, -0.08152784f, 0.03591629f, 0.05078715f, 0.14201863f, 0.07912367f, -0.04663287f, 0.00591505f, 
    -0.01214598f, -0.12037015f, 0.04889417f, 0.00930835f, 0.14883706f, 0.08838239f, -0.04139558f, -0.07599476f, 
    0.09333066f, 0.01032655f, 0.10893551f, 0.06331680f, 0.12931269f, -0.04428515f, -0.02894352f, 0.02169755f, 
    -0.03593732f, 0.06373079f, 0.16416760f, 0.07293538f, -0.14802755f, -0.13956141f, -0.16635849f, -0.01692356f, 
    0.02205346f, 0.06000147f, 0.00477670f, 0.21637784f, -0.02945617f, 0.06832083f, 0.03968024f, -0.08454665f, 
    -0.06280421f, 0.07699196f, -0.04005917f, 0.11337283f, 0.10610659f, 0.09285585f, 0.07436057f, 0.09305012f, 
    0.05781527f, -0.04548230f, 0.09430552f, 0.02262100f, 0.21227498f, -0.03888055f, -0.15505941f, 0.19150789f, 
    -0.06974251f, 0.10081095f, 0.02083616f, 0.09855198f, -0.07585285f, -0.01647787f, -0.04245762f, 0.06014933f, 
    0.01859740f, -0.03260257f, 0.01758040f, -0.00189963f, 0.02058570f, 0.00303430f, -0.06470783f, -0.04295637f, 
    0.02049159f, 0.03891793f, 0.07702666f, 0.01052443f, 0.21009463f, -0.00869554f, -0.01170484f, 0.03487520f, 
    0.01569301f, 0.04022584f, 0.09819370f, 0.14604720f, -0.06098200f, 0.05399933f, 0.05904723f, 0.06215880f, 
    0.11539922f, 0.10252630f, 0.10965382f, -0.03288617f, -0.01108219f, -0.07238830f, 0.10989854f, 0.14840059f, 
    0.01590129f, 0.00573838f, 0.09083651f, 0.05008370f, 0.02069290f, 0.06677782f, 0.06437523f, 0.06312093f, 
    -0.00553294f, -0.08736605f, -0.01526670f, -0.06329969f, 0.01915235f, -0.04218298f, -0.02856341f, 0.02396906f, 
    -0.10133992f, 0.03158795f, 0.11410161f, -0.15539792f, -0.02854821f, 0.02186448f, 0.05182426f, -0.09007666f, 
    -0.10187057f, -0.01416996f, 0.13671356f, -0.02813396f, -0.16884151f, 0.31546587f, 0.09888022f, -0.00885682f, 
    -0.08082961f, -0.05418818f, 0.05340097f, -0.08919568f, 0.03146859f, 0.01810236f, 0.08185973f, -0.03387270f, 
    -0.01150885f, 0.00764534f, 0.13217933f, -0.18420321f, 0.04630218f, 0.01225122f, 0.06512380f, 0.06486933f, 
    -0.02612508f, -0.00606301f, 0.02337840f, 0.04467281f, 0.12874734f, -0.17655876f, -0.14493480f, -0.06362082f, 
    0.02791378f, 0.05833425f, 0.04468788f, 0.00091920f, 0.06601404f, 0.02434049f, -0.00472813f, -0.05602822f, 
    -0.16348904f, 0.10275384f, -0.06704760f, 0.03991730f, 0.03686391f, -0.02963592f, -0.16784190f, -0.00216745f, 
    0.03419043f, -0.02189160f, -0.02211648f, 0.04246423f, 0.11461469f, 0.07456302f, -0.09868746f, -0.04312821f, 
    0.04687496f, 0.06720219f, -0.05100562f, 0.17767829f, -0.05193336f, -0.03854612f, 0.04077059f, -0.03592673f, 
    0.17605110f, 0.06353850f, -0.12561281f, -0.07504112f, -0.15076523f, -0.04360896f, 0.03902323f, -0.06868500f, 
    0.04969833f, -0.01960652f, 0.02868756f, -0.04510240f, 0.35224178f, 0.07568140f, 0.05151768f, 0.12926146f, 
    0.08840160f, 0.04935869f, 0.07867913f, -0.01072138f, 0.08046188f, -0.01794687f, -0.10572468f, -0.01006257f, 
    0.08105299f, 0.17272256f, 0.02089955f, -0.14984778f, 0.04744283f, 0.03059699f, 0.05794171f, 0.09380253f, 
    -0.01077424f, 0.11081057f, -0.21870746f, -0.05176848f, -0.13955659f, 0.01916020f, -0.02075395f, 0.09594765f, 
    0.03893261f, 0.14298642f, 0.00601690f, 0.03677497f, -0.04446024f, -0.00988803f, 0.00201788f, 0.04123711f, 
    -0.09224450f, 0.00998070f, 0.06724408f, 0.03846389f, -0.01061063f, -0.06121164f, 0.07979981f, 0.12966497f, 
    0.04085251f, 0.07127120f, 0.10274634f, 0.01151923f, 0.05298023f, -0.06208502f, -0.10166163f, 0.07315230f, 
    -0.05108608f, -0.03892410f, -0.09587736f, 0.13615723f, 0.17331065f, -0.04711152f, 0.13367133f, 0.05198441f, 
    0.34075370f, 0.05098984f, -0.05454304f, 0.05782500f, 0.06029272f, -0.03134236f, -0.08156746f, -0.01692763f, 
    -0.05862266f, 0.00136626f, -0.02719415f, 0.06536019f, 0.39011922f, 0.07103023f, -0.12748133f, 0.02010251f, 
    -0.01344569f, 0.05660390f, -0.03196728f, -0.03305815f, 0.03944181f, 0.08799233f, -0.01142989f, 0.05926744f, 
    0.17065406f, -0.04828548f, -0.20694913f, -0.04368494f, -0.13334626f, -0.01844419f, 0.02580687f, -0.00374371f, 
    0.05618270f, 0.08384378f, 0.01227737f, -0.04657532f, -0.15495861f, 0.01204158f, -0.31683308f, -0.10920203f, 
    0.07418436f, 0.07968337f, -0.10015370f, -0.02711849f, 0.02911342f, 0.03097080f, 0.07196502f, 0.04978418f, 
    0.09970415f, -0.01615576f, -0.01837065f, 0.04481696f, 0.03983063f, 0.02383852f, 0.03225213f, 0.01664731f, 
    0.03288920f, 0.00627846f, -0.00436289f, 0.00359454f, -0.21992767f, 0.09771664f, -0.14560677f, 0.01868043f, 
    -0.00167573f, 0.06580257f, 0.01281359f, 0.08911349f, -0.06116893f, -0.00970909f, -0.11265877f, 0.06444176f, 
    0.25403029f, -0.06883603f, -0.04465898f, 0.01822400f, 0.05133745f, 0.02844341f, -0.04486390f, -0.00190155f, 
    0.06567772f, 0.06640936f, -0.00089960f, -0.01565070f, 0.17961644f, 0.07675511f, 0.03254937f, 0.02117717f, 
    -0.00227260f, 0.04462783f, 0.02706777f, -0.01226582f, -0.07426565f, 0.13039272f, 0.03789115f, -0.03908573f, 
    0.13828203f, -0.12852769f, 0.01264435f, -0.08832483f, -0.01831109f, 0.13968158f, 0.07906737f, -0.00416727f, 
    -0.02008688f, -0.03784875f, 0.15639892f, -0.08777168f, -0.18581897f, 0.00369381f, -0.05715808f, 0.17355761f, 
    -0.02694148f, 0.11323351f, 0.02814630f, 0.04922305f, 0.00937310f, 0.10087346f, 0.03909272f, 0.08273032f, 
    0.02136780f, 0.10852157f, -0.00654577f, 0.27496272f, 0.00741760f, -0.09440266f, -0.04766500f, 0.04857093f, 
    -0.04697788f, 0.03159660f, -0.00605257f, -0.02243479f, 0.11679918f, -0.01043056f, 0.05577807f, 0.22541438f, 
    0.05188809f, -0.10088202f, -0.06648488f, 0.14351377f, 0.12989782f, -0.04298325f, 0.00137334f, -0.08712771f, 
    0.32271257f, 0.13236208f, 0.05712385f, 0.02697013f, 0.00944066f, 0.00655181f, 0.03199277f, 0.03137065f, 
    0.02413101f, -0.01272508f, 0.15196888f, 0.01416800f, -0.22493984f, 0.04909381f, 0.09372360f, -0.32093328f, 
    0.17054948f, -0.03973797f, -0.00420407f, -0.01999627f, 0.03381501f, 0.02765231f, -0.01877777f, -0.10805353f, 
    0.34112030f, 0.00406905f, -0.00947393f, -0.05246200f, -0.04379512f, -0.03196590f, 0.04508684f, 0.07035176f, 
    -0.00535138f, 0.02264889f, -0.02120022f, 0.08013938f, 0.14997078f, 0.09774869f, -0.15184322f, -0.19232225f, 
    -0.03836365f, -0.03987049f, 0.03133342f, -0.12840648f, 0.08261410f, 0.04432011f, -0.03381492f, 0.02811396f, 
    -0.30548286f, -0.06436017f, 0.06656486f, -0.16159536f, 0.02120482f, -0.01640421f, -0.00139692f, -0.06022565f, 
    -0.05199752f, 0.08386513f, 0.07882343f, -0.05438004f, -0.07448101f, 0.12919535f, 0.09688649f, -0.01467178f, 
    0.03896602f, -0.03326802f, -0.06194049f, -0.12766476f, 0.08930501f, 0.00379516f, -0.08330376f, 0.08248450f, 
    -0.31704229f, -0.01644321f, -0.08838472f, 0.07138947f, -0.07253611f, -0.07359927f, 0.03915214f, 0.05267460f, 
    0.03128578f, 0.06489643f, 0.00560521f, -0.01742564f, 0.08037232f, -0.08208772f, 0.21794850f, 0.07658297f, 
    0.09532823f, -0.02166351f, 0.03870446f, 0.21608502f, -0.01518410f, 0.02450487f, 0.09415207f, 0.01656278f, 
    0.10995428f, -0.10234427f, -0.10094211f, 0.04390894f, 0.09689055f, -0.08451337f, 0.07258146f, 0.07679935f, 
    0.01259527f, -0.05199822f, 0.10439647f, -0.09152790f, 0.18650027f, -0.04875367f, -0.11019675f, 0.19974092f, 
    -0.00643071f, 0.09129135f, -0.03863082f, 0.14607950f, -0.00264726f, -0.03284287f, -0.03138411f, 0.10118758f, 
    0.18606582f, 0.14637531f, 0.08907002f, -0.33776692f, 0.02306118f, -0.05854341f, 0.01627560f, 0.02606854f, 
    0.02641170f, 0.02818224f, -0.02187567f, 0.04245238f, 0.02506717f, 0.02872754f, 0.27814168f, -0.13773073f, 
    0.05462604f, 0.08483951f, 0.07948191f, 0.07634360f, 0.02491307f, 0.09840807f, 0.02916654f, 0.17183152f, 
    -0.17400716f, 0.01451096f, -0.03754153f, 0.33895236f, 0.06237357f, 0.09032626f, -0.08563316f, -0.08882604f, 
    0.08149862f, 0.00387492f, -0.06807668f, -0.05568261f, 0.00616203f, -0.13306850f, -0.01930556f, 0.19284889f, 
    -0.01975027f, 0.12372005f, 0.05734624f, -0.09764896f, -0.01431613f, 0.05071165f, -0.16268477f, -0.04025334f, 
    -0.16500153f, 0.13388671f, -0.17593621f, 0.03053494f, 0.06829756f, 0.02554590f, -0.05588256f, -0.01149963f, 
    0.08085507f, 0.03202801f, -0.04045875f, -0.06389977f, -0.01835656f, -0.08552224f, -0.02587486f, 0.19631666f, 
    0.01512577f, 0.01505174f, 0.01706483f, 0.09658457f, 0.02966074f, -0.04177170f, -0.10289767f, 0.01529062f, 
    -0.20792007f, -0.01127901f, 0.06543538f, -0.17907296f, -0.15194397f, -0.03882460f, 0.07349029f, 0.06206672f, 
    0.01676665f, -0.02060430f, -0.03286042f, -0.08137897f, 0.04123907f, 0.16432945f, 0.18701679f, -0.30739355f, 
    -0.02954390f, -0.06774552f, 0.11242700f, -0.05551130f, 0.13965581f, -0.01550529f, 0.00499344f, 0.02780325f, 
    0.34315890f, 0.10461684f, 0.12702671f, 0.25140041f, -0.05573395f, 0.09150460f, -0.04829039f, -0.07114980f, 
    -0.03158243f, -0.01947474f, 0.00075205f, 0.19332416f, -0.01867352f, -0.09630504f, 0.16681331f, -0.12768668f, 
    -0.03822982f, 0.00471725f, 0.15892160f, 0.04274904f, -0.00720894f, -0.03684547f, -0.10839392f, 0.00872451f, 
    0.10638723f, 0.02820667f, 0.17298111f, 0.06042954f, -0.01155479f, -0.06910436f, -0.06257003f, -0.05665425f, 
    0.08995654f, -0.00457867f, -0.04549822f, -0.04989519f, 0.12439344f, 0.11210247f, 0.07384194f, 0.08395766f, 
    -0.01611729f, 0.00745711f, -0.02224496f, 0.04655810f, 0.05570908f, -0.09288934f, 0.03214101f, -0.10273634f, 
    0.04432702f, 0.09899598f, 0.11022940f, 0.17643020f, -0.00804125f, 0.03328363f, -0.04161682f, 0.00581987f, 
    0.02876390f, 0.09727263f, -0.05947716f, 0.07232886f, 0.12245853f, 0.15564190f, -0.21849690f, 0.00570606f, 
    0.05289039f, -0.02651585f, -0.03993626f, -0.06465572f, -0.03418303f, 0.06402364f, -0.07066759f, -0.14456360f, 
    -0.33669639f, -0.00754808f, 0.12069128f, 0.06450740f, 0.05427041f, -0.03293568f, 0.03382400f, 0.10688352f, 
    0.02923486f, -0.13194649f, 0.03735615f, -0.05359896f, -0.01201113f, -0.09101888f, -0.24172442f, -0.15839304f, 
    -0.04537547f, -0.02746911f, 0.05275540f, -0.03377764f, -0.05560015f, 0.04571730f, 0.02416850f, 0.02061361f, 
    -0.17703815f, -0.05506719f, 0.00319619f, 0.01379609f, 0.04419756f, 0.01318551f, 0.13082294f, 0.02510983f, 
    -0.01435908f, -0.00662894f, 0.09768993f, -0.06371248f, -0.25149447f, -0.12707776f, 0.07417393f, -0.00486503f, 
    -0.09504701f, 0.14955828f, -0.04063812f, -0.09602084f, -0.12989710f, -0.04917199f, -0.06881127f, -0.00160571f, 
    -0.31048691f, -0.20693637f, -0.15308343f, -0.08537378f, 0.08689166f, 0.07712528f, 0.10599060f, -0.05755957f, 
    0.07735703f, 0.14628354f, 0.08916523f, 0.05907991f, 0.08037125f, 0.10281924f, -0.05936538f, -0.13465320f, 
    0.05067618f, -0.06439999f, 0.03890108f, 0.04785827f, -0.00310190f, -0.02732127f, -0.03778479f, 0.06139070f, 
    -0.08704565f, -0.14808474f, 0.11354400f, 0.12473185f, 0.02446170f, 0.12708153f, 0.02417116f, 0.02960652f, 
    -0.02872212f, 0.03189560f, 0.07512282f, 0.04242602f, 0.03735658f, 0.13364658f, -0.03289802f, -0.17379400f, 
    0.04458862f, 0.06100902f, -0.00571085f, 0.05504017f, 0.01767630f, -0.01889055f, 0.08890337f, -0.04039348f, 
    -0.21743332f, -0.22340745f, 0.04720815f, -0.00290984f, -0.04969524f, 0.10405751f, 0.07073612f, -0.08718439f, 
    -0.06470463f, 0.03988402f, 0.00049927f, 0.03179812f, 0.00449863f, 0.01995185f, -0.09876023f, 0.16780965f, 
    -0.01804316f, -0.05331326f, 0.04702377f, -0.04030454f, -0.04951847f, 0.08701166f, -0.05951298f, 0.03367288f, 
    -0.10214900f, -0.07368108f, -0.13248487f, -0.01433207f, -0.01253950f, -0.07509361f, -0.04449276f, 0.04926912f, 
    -0.04392986f, -0.04905522f, 0.02451720f, 0.04401217f, -0.18316802f, -0.01771322f, 0.18538405f, 0.04206444f, 
    0.16108038f, 0.05910296f, -0.00448034f, -0.18572949f, 0.01052833f, 0.02847575f, 0.01674746f, -0.01983266f, 
    -0.07645859f, 0.01269237f, 0.03936019f, 0.13562876f, 0.12666376f, 0.01568334f, -0.01753620f, 0.05022203f, 
    -0.03029284f, 0.12674828f, -0.01848034f, 0.02894534f, -0.31775555f, -0.26465341f, -0.10347494f, 0.12439608f, 
    0.01284552f, 0.00093781f, 0.00731244f, 0.04623516f, 0.13612324f, 0.11769007f, 0.06763458f, 0.00737271f, 
    -0.29249349f, -0.00617529f, -0.06229249f, 0.16978385f, 0.17930479f, 0.06548678f, -0.11213639f, -0.10892040f, 
    -0.01056050f, 0.00995846f, 0.03334733f, 0.02538939f, 0.18257542f, 0.02737169f, 0.12873553f, -0.09178896f, 
    0.05908288f, 0.06369038f, -0.01494581f, 0.04667496f, 0.02865614f, -0.01854151f, 0.01677013f, 0.04185024f, 
    0.10946748f, -0.04712084f, 0.02713513f, 0.31152198f, 0.04285045f, 0.08318426f, -0.06953979f, -0.04016348f, 
    0.13081521f, -0.00813773f, -0.02156745f, -0.13807149f, 0.41748023f, -0.11531119f, 0.01898053f, -0.37964752f, 
    0.18955855f, -0.00873092f, -0.01650747f, 0.06929704f, -0.06500469f, -0.01963473f, -0.08203558f, 0.05086849f, 
    0.25550500f, -0.17478047f, -0.05493627f, 0.40685049f, 0.05230239f, -0.00601149f, -0.05347979f, -0.00761936f, 
    -0.01194425f, -0.09634054f, -0.10303859f, -0.09636423f, 0.13053793f, 0.07480814f, 0.27709898f, 0.13272463f, 
    -0.00296037f, 0.08013368f, 0.06451793f, -0.04331481f, 0.05939440f, -0.05397981f, -0.02290367f, -0.09810709f, 
    0.11494417f, 0.10214888f, 0.02976550f, -0.01651157f, -0.03239381f, 0.01385714f, 0.14210035f, 0.02397769f, 
    0.05058401f, 0.06701029f, -0.02698614f, 0.07665504f, -0.08730318f, -0.15095882f, -0.00143490f, 0.37004554f, 
    0.06667963f, -0.00139255f, 0.14374506f, -0.21166320f, 0.04860875f, 0.01188654f, -0.08478685f, -0.06363008f, 
    0.23570810f, -0.08796684f, 0.05824889f, -0.04548503f, 0.02155626f, 0.02698712f, -0.00716157f, 0.00691396f, 
    -0.02257211f, 0.08974339f, 0.01708212f, 0.06597582f, -0.37047285f, 0.07662937f, 0.02955545f, -0.10252018f, 
    0.03786744f, 0.04880010f, -0.03881059f, -0.08947617f, 0.03563358f, 0.11213072f, 0.03654092f, 0.11606227f, 
    -0.14242028f, -0.04065387f, 0.04018929f, 0.05118458f, 0.02161267f, 0.08980372f, -0.03200730f, -0.05831075f, 
    0.10163575f, -0.05760579f, 0.10905281f, 0.00768682f, -0.02927355f, 0.16401553f, 0.06587733f, -0.06648877f, 
    0.07808214f, -0.12395661f, 0.02588850f, -0.00161921f, 0.00217920f, -0.09592952f, 0.00324095f, -0.03383581f, 
    -0.16742006f, 0.08176293f, 0.03680336f, 0.06546682f, -0.03151776f, 0.07080050f, -0.08635382f, 0.09366091f, 
    -0.00962778f, 0.00752876f, 0.07265098f, 0.14497776f, -0.10551910f, 0.12381843f, -0.02320536f, 0.08147977f, 
    -0.03588546f, 0.00566369f, 0.09550086f, -0.04325026f, -0.05694043f, 0.04051750f, 0.03624386f, -0.10206675f, 
    0.12742870f, -0.02818664f, 0.08353201f, -0.10307129f, 0.01100497f, -0.01351691f, 0.04152906f, 0.05031447f, 
    0.04473533f, 0.00626345f, 0.04279229f, 0.01236042f, -0.24025127f, 0.00312412f, 0.11782500f, 0.01652376f, 
    0.02660495f, -0.09851314f, 0.04221866f, -0.04753985f, 0.00206084f, -0.06784425f, -0.01612454f, -0.02508744f, 
    -0.10980980f, 0.09387834f, 0.09948415f, -0.08659908f, 0.06784072f, -0.02898977f, -0.00469154f, -0.00418293f, 
    0.08333425f, 0.06007022f, 0.02361014f, 0.21239434f, 0.09839667f, 0.05217626f, 0.14019911f, 0.12128741f, 
    -0.17225167f, 0.01843948f, -0.00264427f, 0.08908932f, -0.01783602f, -0.06241509f, -0.06551573f, -0.10970593f, 
    -0.03817169f, -0.02965530f, 0.01430958f, -0.23018964f, 0.10051843f, -0.05826951f, 0.06211817f, 0.04666838f, 
    -0.07098345f, -0.01716735f, -0.05778377f, 0.10988691f, 0.10916974f, 0.14580287f, 0.08495702f, 0.20231670f, 
    0.06804407f, -0.02848274f, 0.02115940f, -0.00076697f, 0.07229090f, -0.08627133f, 0.04487667f, -0.13228621f, 
    -0.06933782f, 0.16715297f, -0.03571185f, -0.13115098f, 0.01249924f, -0.00375892f, 0.03965040f, 0.00556469f, 
    0.03106633f, -0.02412163f, -0.07824256f, -0.05992054f, -0.26406333f, -0.04759949f, -0.06845161f, -0.02905255f, 
    -0.03358738f, -0.01103654f, 0.02381024f, 0.00398803f, 0.02371118f, 0.09471957f, 0.01855765f, 0.11034449f, 
    -0.04097532f, -0.11180137f, 0.09988632f, 0.32562101f, -0.19449115f, 0.02576005f, 0.02903896f, 0.04782701f, 
    -0.02983375f, -0.08172915f, 0.02290270f, -0.07007644f, -0.07062091f, 0.23370416f, 0.07480599f, -0.28850070f, 
    0.05985451f, -0.01659635f, 0.00654049f, -0.03937733f, -0.06600022f, -0.15132041f, 0.07886511f, -0.02669650f, 
    0.05764472f, 0.19713627f, -0.01325960f, -0.01695728f, -0.01985507f, 0.13858159f, 0.09475461f, -0.08191945f, 
    0.07835422f, -0.07490569f, 0.00526589f, -0.02772657f, -0.27921379f, -0.09712253f, 0.05347787f, -0.05764453f, 
    0.06673533f, 0.04979720f, -0.05378849f, -0.03988517f, -0.14043148f, -0.02756607f, 0.10121249f, 0.12057769f, 
    -0.11868208f, 0.18295020f, -0.09313833f, 0.04583717f, -0.04425734f, -0.02202833f, 0.00128989f, 0.03718010f, 
    0.03706650f, 0.00841330f, 0.03307632f, 0.09426500f, 0.11506841f, 0.18259081f, -0.10151175f, 0.33681127f, 
    -0.01177388f, 0.06717423f, -0.04372244f, -0.04723771f, -0.01884039f, -0.00286846f, 0.03868555f, 0.06325929f, 
    0.03782853f, -0.08782004f, 0.06654676f, 0.09946403f, 0.02197092f, -0.01140421f, 0.04721045f, -0.08130929f, 
    -0.06005041f, -0.08715696f, 0.00571685f, 0.04803479f, -0.08778080f, 0.06445349f, 0.05115823f, 0.10626818f, 
    0.01891067f, -0.02113236f, -0.03088071f, 0.06001458f, -0.08570719f, -0.05539680f, 0.24090968f, 0.11007074f, 
    0.16316226f, 0.12055761f, -0.01889486f, 0.11449510f, 0.01229220f, 0.03172744f, -0.00617450f, 0.04046452f, 
    0.04776672f, -0.03226459f, 0.03123525f, -0.00932038f, 0.03247113f, -0.11521592f, -0.08539423f, -0.08987604f, 
    0.03866986f, 0.02406690f, 0.08837412f, -0.00154110f, -0.03884498f, -0.00635462f, 0.16665463f, 0.19277994f, 
    0.18762675f, 0.21284342f, -0.02203818f, 0.04150585f, 0.01625801f, 0.11658872f, -0.00296417f, 0.05973691f, 
    0.07894494f, -0.06555320f, 0.01202952f, 0.05323691f, -0.12590910f, 0.07735766f, -0.11756784f, 0.06084678f, 
    0.01137281f, -0.02628350f, -0.09688932f, -0.11192609f, -0.03363949f, 0.13920356f, -0.15703879f, -0.07544371f, 
    0.11682670f, -0.05877454f, -0.04333729f, 0.10511629f, 0.01056602f, 0.11976036f, 0.18498898f, 0.18438169f, 
    0.08293357f, 0.01970157f, -0.01610547f, -0.03195969f, -0.25655773f, -0.12692761f, 0.03397517f, -0.12698054f, 
    -0.04948827f, 0.02683272f, -0.16945764f, -0.01798241f, 0.01791797f, -0.00671827f, -0.00012122f, 0.02456179f, 
    0.12870543f, 0.00934166f, 0.08778924f, 0.11430852f, 0.02259476f, 0.08386421f, -0.05124186f, -0.04727275f, 
    -0.11682158f, 0.15331103f, -0.02728720f, 0.07375716f, -0.09129875f, 0.17293596f, 0.03328429f, 0.12962757f, 
    0.04162112f, 0.20858966f, 0.02530950f, 0.04651408f, 0.09530018f, 0.03358632f, 0.11025007f, 0.02655566f, 
    -0.02715202f, -0.14130916f, 0.11673810f, -0.09445830f, 0.12795880f, -0.11553887f, 0.08671965f, 0.00463614f, 
    -0.15062658f, -0.04575470f, -0.02449700f, 0.09142420f, -0.19919527f, -0.19208610f, 0.10076869f, 0.04530771f, 
    0.04320152f, 0.00552328f, -0.01720389f, -0.01813436f, -0.02746306f, -0.14955154f, -0.02710256f, -0.03466122f, 
    -0.14146592f, -0.11403278f, -0.01505117f, 0.13962682f, -0.12080930f, -0.04033351f, 0.04539394f, -0.01697201f, 
    -0.04239414f, 0.08589929f, 0.06740363f, -0.16003019f, 0.24975251f, -0.03015172f, 0.05872658f, 0.02680247f, 
    0.01844390f, -0.03180078f, -0.11771373f, 0.01468948f, 0.04658862f, 0.04685744f, 0.10979387f, 0.03764287f, 
    -0.07140218f, -0.04153114f, 0.04734265f, 0.01760082f, 0.02300168f, 0.00983220f, 0.03627289f, 0.02768718f, 
    0.06760408f, -0.02922396f, -0.08695799f, 0.05454371f, 0.00102703f, 0.07554051f, -0.07686806f, 0.16311592f, 
    -0.01567082f, 0.03929248f, -0.01083484f, -0.05402285f, 0.12139887f, -0.00997637f, 0.05246250f, -0.08405749f, 
    -0.17833771f, -0.07221687f, 0.08755464f, -0.08504398f, 0.01390592f, -0.00795998f, -0.01658539f, 0.03784677f, 
    0.00655418f, 0.12185480f, 0.02023054f, 0.18501939f, -0.01505714f, -0.00487115f, 0.10534444f, -0.06199685f, 
    0.01946839f, 0.03139917f, 0.01282421f, 0.04859774f, 0.06417643f, -0.04132295f, -0.02664775f, 0.18990050f, 
    0.17185175f, -0.05252083f, 0.10290863f, 0.19121306f, -0.06896821f, -0.09701825f, 0.04146940f, -0.04986921f, 
    0.08649574f, 0.01317055f, -0.02651856f, -0.02583691f, -0.09381229f, 0.08949198f, 0.03539874f, 0.03613134f, 
    -0.01155262f, -0.00694021f, -0.00313369f, -0.00062796f, -0.07211651f, -0.06056968f, 0.06819639f, 0.12534353f, 
    -0.08082626f, 0.21125871f, 0.09521022f, 0.13577002f, 0.05114139f, 0.08484612f, 0.08321006f, 0.17411666f, 
    0.05239029f, 0.09713452f, 0.01833560f, -0.14461990f, -0.21519539f, -0.09768924f, -0.13971741f, -0.12158287f, 
    0.02018579f, -0.10061168f, 0.03291733f, 0.03721569f, 0.06473614f, 0.01391266f, -0.00177843f, -0.02382647f, 
    0.02229565f, 0.10521077f, -0.02906445f, 0.03312871f, 0.08132701f, 0.03163181f, -0.08808679f, 0.03351958f, 
    0.08734702f, 0.13785157f, -0.01421829f, -0.05423583f, -0.02771020f, -0.14118271f, -0.05354429f, -0.10506441f, 
    0.03149422f, 0.18333006f, 0.07047047f, -0.06149469f, -0.03217418f, -0.12866440f, 0.08233164f, 0.05396057f, 
    -0.04807359f, 0.15396427f, 0.14839846f, -0.02216109f, -0.06757182f, 0.08765806f, 0.05580172f, 0.10070283f, 
    0.04418601f, -0.03114106f, 0.09095850f, -0.10853157f, 0.51333046f, -0.06536733f, 0.04183362f, -0.13681367f, 
    -0.10077032f, 0.11773045f, -0.10318422f, 0.03531480f, 0.00603341f, -0.00041809f, -0.01530609f, 0.07949879f, 
    0.14435475f, -0.01999939f, -0.09025964f, -0.16535071f, 0.07849478f, 0.08089761f, -0.05214260f, 0.09146897f, 
    -0.03192494f, 0.09129754f, -0.06257071f, 0.04616066f, 0.16981792f, 0.29155710f, 0.26637429f, 0.04616095f, 
    -0.04859862f, 0.03444348f, 0.02394454f, 0.03190409f, 0.03988391f, 0.01847161f, -0.15895830f, 0.04309006f, 
    0.03255283f, -0.06080685f, 0.02991804f, 0.06871622f, -0.04707186f, 0.12145072f, -0.11183830f, -0.04019215f, 
    -0.02677582f, 0.00043716f, 0.00647017f, 0.00277307f, 0.34524485f, 0.38159531f, 0.14408050f, -0.26246345f, 
    -0.08415333f, 0.05112160f, 0.02895513f, 0.14999734f, 0.20675726f, 0.05223721f, 0.05348424f, -0.10764076f, 
    0.18546292f, -0.05028510f, 0.10869573f, -0.07382001f, 0.03731538f, 0.01922389f, 0.12473948f, 0.05923991f, 
    -0.05650703f, 0.10988651f, -0.12144288f, 0.18490675f, -0.06576931f, -0.19348444f, 0.11600924f, -0.09144586f, 
    0.02034429f, 0.00252496f, -0.02420132f, -0.00087249f, 0.13712813f, 0.05370728f, -0.09051522f, -0.10585927f, 
    -0.22928697f, -0.08797433f, -0.08517854f, -0.21034093f, -0.06257196f, 0.03844136f, 0.21901499f, -0.04252318f, 
    0.02527401f, 0.03203785f, 0.01924393f, 0.06174209f, 0.06202358f, 0.19027768f, 0.07298034f, 0.05901851f, 
    0.06445582f, -0.02350673f, 0.07827385f, -0.05145267f, 0.16219629f, -0.10479752f, 0.06964163f, 0.03054515f, 
    -0.05685744f, 0.13103710f, 0.12520592f, -0.09272727f, -0.02727780f, 0.02850534f, 0.00465138f, 0.04165802f, 
    0.10206239f, 0.06074187f, 0.02248241f, -0.02594347f, 0.09917145f, -0.07231445f, 0.08235911f, -0.08313625f, 
    0.08721749f, 0.09709764f, 0.06021246f, 0.16664210f, 0.07017834f, 0.02584183f, -0.00275425f, -0.02041505f, 
    0.02287279f, -0.14532611f, 0.00116217f, -0.14405479f, 0.01687302f, -0.04654441f, 0.05424502f, -0.09347916f, 
    0.02333366f, -0.01094779f, 0.12550806f, 0.07310043f, 0.01619179f, 0.19322799f, 0.00885757f, -0.01686905f, 
    -0.10694367f, -0.12134013f, 0.10551377f, 0.08488565f, 0.03332816f, -0.07427102f, 0.00357358f, -0.05937240f, 
    -0.16489579f, -0.12091104f, 0.18222876f, 0.15756460f, -0.04181632f, 0.01484663f, 0.06616204f, 0.16462931f, 
    0.03219697f, -0.13442154f, 0.04519921f, -0.08900432f, 0.34921309f, -0.36141366f, -0.04749938f, 0.20689490f, 
    -0.08099531f, -0.01128824f, 0.06503449f, -0.09346796f, -0.10564621f, -0.05372673f, -0.01045024f, 0.02730768f, 
    0.08812083f, -0.06427223f, 0.21789131f, -0.09549358f, -0.02916970f, 0.04446303f, 0.14065406f, 0.14318492f, 
    0.05746510f, -0.01242813f, -0.03349148f, -0.00229649f, 0.04471425f, 0.11826300f, 0.13648431f, 0.17614160f, 
    0.04076444f, 0.10327139f, 0.03485544f, -0.04195155f, -0.08643537f, -0.01533133f, 0.05993659f, -0.06608491f, 
    0.02846191f, -0.15546128f, 0.15929289f, 0.15685365f, 0.10505207f, 0.02481752f, 0.02322684f, -0.03583840f, 
    0.01918362f, 0.00698599f, 0.10954775f, -0.14197189f, -0.25656718f, 0.06734421f, -0.12440552f, -0.01006663f, 
    -0.12942842f, 0.03293762f, 0.05739897f, 0.10715502f, 0.05163340f, 0.12863514f, 0.04448412f, 0.23650305f, 
    0.03308655f, 0.12793425f, 0.00456122f, 0.08569196f, 0.10004086f, 0.13084534f, -0.04885247f, 0.05357917f, 
    0.08153281f, -0.07579978f, 0.01737171f, -0.00231933f, -0.10528266f, 0.00491925f, -0.13445888f, -0.02789959f, 
    0.02717337f, -0.06586709f, 0.01211206f, -0.03932520f, 0.07160955f, -0.02900391f, -0.08743636f, 0.12639801f, 
    -0.18240348f, 0.01973914f, 0.03616355f, 0.11966926f, 0.02465462f, 0.07698417f, -0.04011985f, 0.05171030f, 
    0.08142409f, 0.02430326f, -0.03940291f, -0.03359777f, -0.19076343f, 0.06479549f, 0.08470704f, -0.11980965f, 
    0.04551710f, -0.01779072f, 0.12406732f, 0.02071117f, 0.01454488f, 0.03492948f, 0.02872985f, -0.08373971f, 
    0.15471698f, 0.07187060f, 0.02139835f, 0.07229364f, 0.07795476f, 0.02439193f, 0.09834352f, -0.09454263f, 
    -0.01823812f, -0.01075912f, 0.07659797f, 0.03105275f, -0.05809884f, 0.05261216f, 0.04881191f, -0.14050946f, 
    0.03605125f, 0.00990557f, 0.00547748f, 0.09040044f, 0.10647823f, 0.00452219f, 0.24725671f, 0.00593672f, 
    0.05740812f, 0.10890638f, 0.11154509f, -0.05334615f, -0.06731986f, 0.00142064f, 0.04466328f, 0.07770623f, 
    -0.03807551f, -0.04688924f, 0.09415084f, 0.00994715f, 0.18313374f, 0.06916265f, 0.14575188f, 0.13464482f, 
    0.02776804f, 0.04194890f, -0.02793833f, -0.02573071f, -0.01854269f, -0.03865968f, -0.09711610f, 0.07798569f, 
    0.16978072f, 0.02568969f, -0.02842408f, 0.08043472f, 0.05819476f, 0.02560250f, 0.10030835f, -0.01628189f, 
    0.12027217f, 0.14833841f, -0.01594983f, 0.13518324f, 0.23499894f, 0.18937470f, -0.00286090f, -0.00426702f, 
    -0.02330476f, 0.06013227f, -0.00295579f, 0.03608117f, 0.06347628f, 0.06142494f, 0.02460135f, -0.07316933f, 
    -0.10520166f, -0.07927702f, 0.08332092f, 0.07338810f, 0.11900719f, 0.10640756f, 0.04745096f, 0.13797362f, 
    0.03064415f, -0.09557020f, -0.03801576f, 0.10393315f, -0.03322958f, -0.06076114f, 0.21280600f, -0.03813825f, 
    0.04769467f, 0.07677829f, 0.02173230f, 0.13554633f, 0.06794240f, -0.09327859f, 0.14370742f, 0.14282466f, 
    0.16930401f, 0.00464748f, -0.11065067f, 0.10294976f, -0.11030716f, -0.01036001f, 0.07285210f, 0.06129333f, 
    0.08732471f, -0.04058107f, -0.02840299f, -0.02785681f, -0.05274419f, 0.00509177f, 0.04260392f, 0.00843537f, 
    -0.02823898f, 0.01748303f, 0.12936975f, 0.13916111f, -0.03768967f, 0.15690833f, 0.04995605f, 0.07343043f, 
    -0.17603309f, -0.09756155f, 0.11156972f, -0.25212640f, 0.02884816f, 0.21555157f, 0.11215525f, 0.01307002f, 
    -0.08999027f, -0.10444325f, 0.07925258f, 0.05456433f, 0.04324279f, 0.15073462f, 0.02311515f, 0.08111704f, 
    -0.02763972f, 0.05885657f, -0.04403420f, 0.04536779f, 0.09229451f, -0.03448102f, 0.09449484f, -0.04728613f, 
    0.06127641f, 0.01900174f, 0.13823090f, -0.11639115f, 0.03857598f, 0.03719880f, 0.09637859f, 0.11179168f, 
    -0.02286384f, -0.01595714f, -0.01112662f, 0.08411540f, 0.06627537f, -0.01512796f, -0.16396889f, -0.03446743f, 
    0.00802549f, 0.04846848f, 0.02835691f, 0.05860139f, 0.00972565f, -0.02415436f, -0.05423053f, -0.01245745f, 
    0.11525576f, 0.09627338f, 0.15178546f, 0.01586978f, 0.05728136f, 0.06982590f, 0.01652952f, 0.16793686f, 
    0.03360033f, -0.00721754f, 0.12528761f, 0.02369373f, 0.08386736f, 0.01182835f, 0.25261757f, -0.21501496f, 
    0.07695023f, 0.01550151f, 0.06547473f, -0.00206891f, -0.02213153f, 0.06384190f, 0.00289392f, 0.04153923f, 
    0.09420622f, -0.04128241f, 0.18396737f, 0.05892832f, -0.07515189f, 0.11848032f, 0.03549488f, 0.14181791f, 
    -0.01757149f, -0.00567731f, -0.12767144f, 0.05836208f, 0.05820153f, 0.01718038f, 0.11366841f, -0.12478475f, 
    0.04498729f, -0.02048965f, -0.10024849f, -0.03999596f, -0.06705038f, 0.08915263f, -0.02913678f, 0.04313650f, 
    0.23448646f, 0.01377634f, 0.15055685f, 0.14783341f, -0.01291455f, -0.01543728f, 0.07725696f, 0.12047743f, 
    -0.03090207f, -0.00789757f, -0.00775860f, 0.00926136f, -0.05419379f, -0.03410713f, 0.02534593f, -0.07676493f, 
    -0.02222705f, 0.02804879f, -0.13241379f, 0.08019020f, -0.00344269f, 0.05231208f, 0.17767394f, 0.11711792f, 
    -0.18017800f, -0.16623771f, 0.17585106f, -0.05453245f, -0.04610583f, 0.12780891f, 0.04642078f, 0.03652656f, 
    0.07780340f, 0.05888544f, -0.03240477f, 0.06216841f, 0.03074330f, -0.24781494f, 0.02458990f, -0.19282687f, 
    0.12818150f, -0.05002265f, 0.05187352f, -0.06636508f, -0.09609865f, 0.05743207f, -0.07250488f, 0.01509474f, 
    0.06370108f, -0.09845021f, -0.00920007f, -0.09682158f, -0.05494925f, -0.03265619f, 0.00346479f, 0.17483908f, 
    -0.01918649f, -0.06569551f, 0.06552871f, -0.08515762f, 0.08813200f, 0.06237128f, -0.08283440f, -0.21300316f, 
    0.00285637f, 0.05812600f, -0.06426429f, 0.06743407f, 0.04256602f, -0.00228691f, -0.02595230f, 0.02850604f, 
    -0.00195694f, 0.02440599f, -0.08830870f, 0.05114458f, 0.03964874f, 0.02331062f, -0.00773483f, -0.13221325f, 
    -0.03564343f, 0.08964782f, 0.10832135f, 0.09421150f, -0.04210994f, 0.18021818f, 0.10138923f, -0.16011348f, 
    -0.02824168f, 0.15069823f, 0.06361847f, 0.02083637f, -0.05373403f, 0.07224256f, 0.05843308f, 0.13928431f, 
    -0.24948558f, 0.00379783f, 0.05605564f, 0.09967369f, -0.00833376f, -0.00721493f, 0.06445844f, -0.03272246f, 
    -0.11751167f, -0.03396637f, -0.06762554f, -0.03676201f, -0.08821322f, 0.03578503f, 0.09895921f, -0.07380047f, 
    0.07225560f, 0.14145035f, 0.01432303f, -0.06734079f, -0.10664353f, -0.01592642f, -0.08561017f, -0.03318163f, 
    0.12137476f, 0.14707024f, -0.11970938f, -0.04281553f, -0.04683555f, -0.04773377f, 0.06007381f, -0.03702082f, 
    0.07973150f, 0.11797352f, 0.05278018f, -0.10212266f, 0.28047284f, -0.02763003f, -0.09686460f, -0.02490054f, 
    0.01259341f, -0.09962323f, -0.10775872f, 0.01871011f, 0.01366078f, -0.03910059f, 0.11146332f, 0.14173098f, 
    -0.15084445f, -0.14641103f, -0.22630195f, -0.10024829f, -0.00150955f, -0.07841160f, 0.04245266f, -0.00265792f, 
    0.02989841f, -0.04220141f, -0.04675989f, -0.04506540f, 0.23905924f, 0.05199333f, -0.11163373f, 0.08626587f, 
    0.00734694f, -0.14782576f, 0.07040092f, 0.03168852f, 0.06101431f, 0.13207978f, 0.03688339f, -0.03003415f, 
    0.21505454f, 0.15120360f, 0.05573763f, -0.06143764f, -0.00254217f, -0.07562903f, -0.07157427f, -0.06389753f, 
    0.18126509f, 0.07659135f, 0.04139595f, 0.13036385f, -0.18239363f, -0.10124001f, -0.09694954f, -0.01769676f, 
    -0.02924191f, -0.06419832f, -0.02217776f, 0.07567699f, -0.03367088f, -0.07759497f, 0.01194021f, 0.13831143f, 
    0.13655832f, 0.10231164f, 0.01360342f, 0.16737853f, -0.03406975f, -0.00045190f, 0.02904451f, 0.02960673f, 
    -0.04911316f, 0.05181853f, -0.16527849f, -0.07565577f, 0.12641346f, 0.00273202f, -0.06198367f, 0.06146874f, 
    0.10168963f, 0.00621956f, -0.02426288f, 0.00107160f, 0.05360905f, -0.07689960f, 0.02106523f, -0.00039178f, 
    -0.24704589f, 0.04077656f, 0.11152600f, -0.02356999f, -0.09566449f, 0.13950957f, 0.00373254f, 0.05528277f, 
    0.07041834f, 0.19647838f, -0.05989483f, 0.03896827f, -0.00209319f, 0.17054449f, -0.06360276f, -0.03514983f, 
    -0.11367042f, -0.06739184f, -0.09583322f, 0.02308076f, 0.00936903f, 0.05282006f, -0.07178702f, -0.06669297f, 
    -0.15490483f, 0.07924866f, 0.17537425f, 0.06424829f, 0.07650568f, -0.04539965f, -0.05291864f, 0.03085703f, 
    0.05657714f, 0.03998936f, -0.06083418f, -0.10748448f, 0.01319679f, -0.16405350f, -0.01793358f, -0.03092664f, 
    -0.14653666f, 0.03503744f, 0.06065254f, -0.02253178f, 0.04310352f, -0.08255693f, 0.07527702f, -0.02620893f, 
    -0.04962996f, -0.06254353f, -0.08013756f, -0.01696244f, -0.03512728f, 0.03367970f, -0.03866554f, 0.08965650f, 
    -0.06021471f, 0.00159579f, 0.19479150f, -0.08884421f, 0.27799916f, 0.08506391f, 0.01163575f, -0.01501785f, 
    -0.13373516f, 0.04848926f, -0.10718931f, 0.03954595f, -0.09607057f, -0.02784857f, -0.07135996f, 0.02266580f, 
    0.21003717f, 0.03614262f, 0.02510794f, 0.04729759f, -0.11132169f, 0.04142100f, -0.04128489f, 0.17074132f, 
    0.02200196f, -0.00921572f, 0.04699077f, 0.01202589f, -0.05451512f, 0.03424592f, -0.03775864f, 0.06098357f, 
    0.13029858f, 0.05863610f, -0.05813434f, -0.04338598f, 0.07413737f, 0.00177154f, -0.06451941f, -0.11242218f, 
    0.33676866f, 0.01250759f, -0.06176923f, 0.13109604f, 0.03454255f, 0.05358235f, -0.05616545f, -0.10104360f, 
    0.01739373f, -0.07927431f, -0.00037572f, 0.00374601f, 0.07322235f, 0.02447017f, -0.09165397f, -0.01299567f, 
    0.05041315f, 0.00875653f, 0.04442957f, -0.01162405f, 0.16673374f, -0.03408798f, 0.08870199f, -0.22779287f, 
    0.03377004f, 0.03938795f, 0.02978984f, 0.05643819f, -0.08334848f, 0.03322685f, 0.14357306f, 0.06618467f, 
    -0.07248665f, 0.12392242f, 0.01815533f, 0.13030849f, 0.11902291f, -0.05903414f, 0.02454639f, 0.10100675f, 
    0.01204140f, -0.09257626f, 0.07649195f, 0.03075419f, 0.04594053f, 0.11600504f, -0.08455532f, -0.10848720f, 
    -0.27149561f, -0.18151096f, -0.02144919f, 0.05065072f, -0.12079644f, -0.12387969f, 0.06300998f, -0.01909339f, 
    -0.06969918f, -0.06492460f, 0.08063322f, -0.00184144f, 0.16661994f, -0.06276342f, 0.05995999f, -0.02292945f, 
    0.03423171f, 0.01289471f, 0.02485844f, -0.09294644f, 0.00987433f, -0.07088604f, 0.02131653f, 0.06296737f, 
    0.04350584f, 0.05774310f, -0.01520394f, 0.09212045f, 0.03806632f, 0.04934491f, -0.02434656f, 0.00568660f, 
    0.02185910f, 0.11467769f, 0.11000256f, 0.01849013f, -0.12863284f, -0.12619312f, 0.03438323f, 0.04841858f, 
    -0.06114029f, 0.04638856f, 0.08210693f, 0.22836100f, 0.06262216f, 0.07858884f, 0.04137906f, -0.06046272f, 
    -0.14970392f, -0.04442361f, 0.20948765f, 0.10314712f, -0.03646188f, -0.03450603f, 0.05001891f, 0.04667838f, 
    -0.09876607f, -0.02295196f, 0.04956289f, -0.00168438f, 0.16296962f, 0.07029620f, -0.05491562f, -0.22590213f, 
    0.03213193f, -0.04172330f, -0.03838013f, -0.05262098f, 0.04615668f, -0.03058899f, 0.09342317f, -0.00680695f, 
    -0.06856488f, -0.10758732f, -0.13507219f, -0.06498686f, -0.03062791f, 0.11242233f, -0.09192345f, 0.05750190f, 
    0.14339437f, 0.04154395f, 0.10002393f, -0.12980919f, 0.01497019f, -0.12329051f, 0.00578607f, -0.18514168f, 
    0.06033035f, 0.02082096f, -0.02337225f, -0.10583192f, -0.04579280f, 0.01448329f, 0.01723887f, 0.14504316f, 
    0.21758096f, -0.15624836f, 0.00401618f, 0.03799704f, 0.04354127f, 0.05196049f, 0.05847011f, 0.07894462f, 
    0.01658070f, -0.02223476f, -0.03105300f, -0.04370367f, -0.01075573f, 0.10930691f, 0.05147450f, 0.00736731f, 
    -0.03921077f, 0.02613421f, 0.07160333f, -0.00911810f, -0.09402113f, -0.10782108f, -0.03803644f, -0.04320046f, 
    0.23750040f, 0.01042685f, 0.08660030f, 0.15502696f, -0.06135935f, -0.06077305f, 0.01702774f, 0.07900937f, 
    0.05790451f, -0.01805636f, 0.05516265f, -0.05444162f, -0.34092134f, 0.13291603f, 0.12837596f, -0.03740911f, 
    -0.03755566f, -0.00995192f, 0.15062381f, -0.10969248f, -0.07191660f, -0.04834162f, -0.03072873f, 0.04958321f, 
    -0.00640695f, 0.14379427f, 0.02336481f, 0.06918264f, 0.05927685f, 0.04559370f, -0.05700578f, 0.03411808f, 
    0.06987047f, 0.00538019f, 0.07812288f, -0.00936785f, 0.16212593f, 0.19018815f, 0.00010610f, -0.05836028f, 
    -0.01425437f, -0.03922657f, -0.05513998f, 0.02883990f, 0.07985832f, 0.14345571f, -0.00229926f, 0.07632904f, 
    0.01950642f, 0.16246799f, 0.00704967f, -0.00263692f, 0.12223332f, 0.06254214f, 0.07507043f, 0.06382515f, 
    0.09098680f, 0.03138653f, -0.04383617f, -0.07737423f, 0.12223440f, 0.05555930f, 0.12324450f, -0.06554119f, 
    0.01038419f, -0.09888838f, 0.07118154f, -0.00437600f, 0.01588229f, -0.02137517f, 0.12292414f, -0.04527421f, 
    -0.27239424f, -0.03467641f, 0.08868911f, 0.04055741f, -0.04520773f, 0.03249668f, 0.11957105f, 0.03470947f, 
    0.03067319f, -0.00672907f, 0.03203950f, 0.03320689f, 0.01058788f, 0.00339684f, -0.04318716f, 0.11029696f, 
    -0.05150478f, -0.07866512f, 0.16133767f, 0.12527440f, 0.06843471f, -0.05823830f, 0.24685948f, -0.11054464f, 
    -0.05542888f, 0.03933672f, -0.07865967f, -0.01158269f, 0.06394783f, -0.00878198f, -0.06760639f, 0.02892456f, 
    -0.00581381f, 0.03466030f, 0.02737964f, -0.02695561f, -0.13731793f, 0.06074123f, -0.02779189f, 0.17438509f, 
    0.10640788f, 0.04732618f, -0.03853534f, -0.03625917f, -0.07842654f, 0.04667629f, -0.07612865f, -0.05895399f, 
    -0.10175699f, 0.10115925f, 0.04592223f, 0.01941022f, 0.02639769f, -0.04212898f, 0.01072197f, 0.03130278f, 
    0.03685625f, 0.17613074f, -0.06527721f, 0.07624456f, 0.20878379f, 0.09385794f, -0.13093999f, 0.00435301f, 
    0.01356146f, 0.04791772f, -0.13569438f, 0.08251450f, 0.01173978f, 0.01378248f, 0.13936275f, -0.08231632f, 
    -0.16525136f, -0.17796193f, -0.06135768f, -0.10497830f, 0.07153679f, 0.02624642f, -0.01884118f, 0.12293823f, 
    -0.04291106f, -0.04048111f, 0.00770871f, 0.05182997f, -0.04186523f, 0.08326644f, -0.06424266f, 0.03580621f, 
    0.01162791f, 0.13659497f, 0.03697131f, 0.02143253f, 0.07283176f, -0.00975014f, -0.02408170f, 0.05302298f, 
    -0.01116864f, -0.14241132f, -0.15577304f, -0.03061664f, 0.04394424f, -0.02725170f, -0.03065747f, 0.08838408f, 
    -0.01360050f, -0.04553755f, -0.05244431f, -0.02031012f, -0.17440060f, -0.12290547f, -0.18707670f, -0.06722274f, 
    0.01272782f, 0.04420379f, 0.10522076f, -0.00319344f, -0.00658204f, 0.10404461f, 0.09250168f, 0.07434897f, 
    0.08438829f, 0.01194834f, -0.04398770f, 0.19642010f, 0.01675575f, 0.17098993f, 0.02301247f, 0.08811439f, 
    0.04470639f, -0.01511185f, -0.00004586f, -0.03603273f, -0.11731590f, 0.00991745f, -0.04603197f, -0.15035002f, 
    0.13003531f, 0.14585522f, -0.05733426f, -0.01320000f, 0.03804991f, 0.03357087f, 0.10955403f, -0.06831930f, 
    -0.01590311f, 0.11423979f, -0.01142660f, 0.10354254f, 0.03916438f, 0.08434409f, 0.08996590f, -0.09865499f, 
    -0.04389798f, -0.01989274f, -0.00193783f, 0.00359308f, -0.00639296f, -0.06211568f, 0.07088610f, 0.10590554f, 
    -0.03394644f, -0.03998200f, -0.08600478f, 0.15554036f, 0.01420949f, 0.00732125f, 0.05931487f, -0.02310538f, 
    -0.19900958f, 0.02879982f, -0.17371735f, 0.04238367f, 0.07229824f, 0.06508765f, 0.06234875f, 0.02193124f, 
    0.01776934f, -0.02178428f, 0.11951395f, 0.09810608f, 0.03646195f, 0.02340103f, -0.08930358f, -0.01151578f, 
    0.11867451f, -0.03825266f, 0.05242359f, -0.04491254f, 0.06335312f, 0.09309693f, -0.03834224f, 0.02988457f, 
    0.03348491f, 0.07012111f, 0.04065089f, -0.00318563f, -0.06173015f, -0.01599849f, 0.04332446f, 0.12146374f, 
    -0.06771684f, -0.07182064f, -0.14524168f, 0.07405132f, -0.03922323f, 0.06738199f, 0.04471362f, -0.00454678f, 
    0.09569567f, -0.01498802f, -0.10807563f, -0.08644135f, 0.12546174f, 0.02036810f, 0.11234295f, 0.14079861f, 
    0.26723561f, -0.13826038f, -0.09826932f, -0.01295256f, 0.04562803f, 0.01422892f, 0.07758630f, 0.00165178f, 
    -0.00589644f, 0.05936892f, 0.09205315f, -0.06398955f, 0.04041806f, -0.15862145f, -0.09919097f, -0.09202977f, 
    -0.05075335f, 0.01367915f, 0.03636960f, -0.01996846f, 0.09812309f, -0.05084843f, 0.01788093f, 0.17279142f, 
    0.22347085f, 0.04125917f, 0.00918143f, 0.19369599f, 0.04207782f, 0.09810289f, 0.00611735f, 0.01068463f, 
    0.03496386f, -0.07924365f, -0.08448424f, 0.02643184f, -0.14272322f, -0.04162697f, 0.08746134f, -0.02399737f, 
    -0.07258547f, -0.01364205f, 0.03360298f, -0.10691038f, -0.08641228f, 0.06024957f, -0.05064846f, -0.02771614f, 
    0.01927120f, -0.03843268f, -0.02836329f, -0.00988584f, -0.02888430f, -0.02739852f, -0.00112372f, -0.02865380f, 
    0.01955920f, -0.02301007f, 0.00998780f, 0.00390271f, 0.00098138f, -0.02605469f, -0.02615418f, 0.00631623f, 
    -0.03309535f, 0.01384835f, -0.02510121f, 0.01159580f, -0.03905077f, -0.03629749f, -0.03413310f, 0.02498561f, 
    0.01712296f, -0.02502586f, 0.00183346f, -0.01089357f, 0.00038809f, 0.00469054f, 0.00796968f, 0.01102722f, 
    0.01105022f, -0.04184897f, -0.00413333f, 0.01657774f, 0.01488135f, -0.03365948f, -0.01956800f, -0.02805470f, 
    -0.01198032f, -0.03041949f, -0.01052837f, 0.01820715f, 0.03688494f, -0.04362170f, -0.01329900f, -0.01223518f, 
    -0.02992146f, 0.00784897f, -0.00197777f, 0.00514249f, -0.00015853f, -0.01080295f, -0.01932383f, 0.02200905f, 
    -0.03063894f, 0.02551723f, 0.03112181f, -0.02095543f, -0.01562680f, -0.01412017f, -0.01392044f, -0.02498975f, 
    -0.03147923f, 0.01420727f, -0.02980412f, -0.00690492f, -0.01910921f, -0.02848442f, -0.00213636f, -0.00494557f, 
    -0.00124614f, -0.03312415f, 0.02325129f, -0.02575476f, 0.01112718f, 0.01599015f, -0.02955036f, -0.00799592f, 
    -0.00685889f, -0.03821703f, -0.03218641f, -0.02056168f, 0.00350025f, -0.01094782f, -0.00891152f, -0.02779301f, 
    -0.02205776f, -0.00618095f, -0.03660456f, 0.00776911f, 0.02877060f, 0.00266464f, -0.03783381f, 0.02266402f, 
    -0.03238623f, 0.01125378f, -0.01807721f, -0.02826477f, -0.00641944f, 0.02505210f, -0.02892816f, 0.00684992f, 
    -0.00547779f, -0.03176676f, 0.01081302f, -0.01825900f, 0.01109205f, 0.02431644f, 0.00242053f, 0.00217695f, 
    -0.03047319f, 0.01892428f, 0.03003491f, -0.00797637f, 0.01023908f, -0.03584895f, 0.00543014f, -0.00493258f, 
    0.02953007f, -0.03261142f, -0.01060361f, -0.02347453f, -0.04184414f, -0.02545195f, -0.00609474f, -0.01260705f, 
    0.02497592f, -0.04131401f, -0.03143856f, -0.00391990f, 0.01784808f, -0.00982631f, -0.03929168f, 0.02118631f, 
    -0.01002554f, -0.00860114f, 0.01808154f, 0.02486561f, -0.00376012f, -0.00532745f, -0.01200831f, 0.00252259f, 
    -0.02904610f, 0.02413282f, 0.01506401f, -0.03130109f, 0.03125132f, -0.00033546f, -0.01157259f, -0.03606389f, 
    -0.03874191f, 0.02054437f, 0.01692010f, -0.00159088f, 0.01644048f, 0.02781668f, -0.03155465f, 0.01940778f, 
    -0.00028311f, -0.01777623f, -0.00525833f, 0.02788754f, -0.02369969f, -0.02027780f, -0.00634229f, 0.00563459f, 
    -0.02293815f, -0.04194668f, -0.02516789f, 0.01877451f, 0.01724192f, 0.02197151f, 0.02343192f, -0.02990073f, 
    0.03072863f, -0.02086346f, 0.00789253f, 0.00369595f, -0.01261375f, 0.02671423f, 0.01920859f, 0.01901487f, 
    0.01134850f, -0.02988854f, -0.01236420f, 0.01523899f, -0.02217126f, -0.00741475f, -0.02490694f, -0.01243980f, 
    -0.00023781f, -0.03423829f, 0.00484068f, -0.04212002f, -0.02729655f, -0.00909057f, -0.03455268f, -0.03483101f, 
    -0.02951237f, -0.00868079f, -0.00714293f, 0.02014787f, -0.03635761f, -0.00676596f, 0.02507483f, -0.03585345f, 
    0.00165571f, 0.02551281f, 0.01020640f, 0.02241469f, 0.00831280f, -0.04050155f, 0.02582246f, -0.01432731f, 
    0.00783413f, -0.02459620f, -0.03357804f, 0.02277606f, -0.00979894f, -0.02320655f, -0.03403396f, -0.02064175f, 
    -0.04094235f, 0.00693801f, 0.02526961f, -0.00754525f, 0.00985929f, -0.01495381f, 0.01691940f, 0.00757172f, 
    -0.03030655f, 0.01515484f, -0.01718759f, -0.03370942f, 0.01266115f, -0.02967885f, -0.01876645f, 0.01684644f, 
    0.02187238f, -0.00063543f, -0.02678466f, -0.00132774f, -0.00616603f, -0.01933608f, 0.00372255f, -0.00081826f, 
    0.02630158f, -0.01431597f, -0.03110228f, 0.02941000f, 0.01373723f, 0.01861895f, 0.01538686f, -0.03664777f, 
    0.01891123f, -0.00437327f, -0.02699418f, 0.00464291f, 0.02139257f, -0.00675759f, 0.01300193f, 0.01659310f, 
    -0.01241274f, -0.01201109f, -0.00682451f, -0.01547630f, 0.02080725f, -0.02999313f, -0.03600084f, -0.04208785f, 
    -0.01199806f, -0.03937495f, -0.00919757f, -0.00676124f, 0.01445764f, -0.00213258f, -0.04008242f, -0.00219040f, 
    -0.01367876f, 0.02592373f, -0.01488249f, -0.02541951f, 0.01809373f, -0.03471421f, -0.03721754f, -0.01412945f, 
    -0.02897723f, 0.01270902f, 0.00026207f, 0.01437506f, -0.00022045f, -0.01862920f, 0.02948944f, -0.03171340f, 
    0.02223085f, -0.00172345f, -0.02990910f, -0.01821743f, -0.01233022f, -0.01585600f, 0.02150665f, -0.00019497f, 
    -0.03526215f, -0.00704737f, -0.00774074f, -0.00826382f, 0.02686721f, -0.02186057f, -0.00739077f, 0.01485035f, 
    -0.03482372f, -0.04051806f, -0.00462787f, 0.00037825f, 0.00768803f, -0.00694856f, -0.01680135f, 0.02139551f, 
    0.02193253f, 0.01825587f, 0.00847594f, -0.01568493f, 0.01731093f, 0.01034699f, 0.01046507f, 0.00000579f, 
    0.00733713f, -0.04157831f, 0.01732408f, -0.00958348f, 0.02707732f, 0.01755982f, 0.00286712f, 0.02167900f, 
    -0.03319859f, -0.03556432f, -0.02743924f, -0.03372655f, 0.00683654f, -0.03317019f, -0.00408079f, -0.02405284f, 
    0.01065270f, 0.01704061f, 0.01364058f, -0.04028061f, 0.02320866f, -0.00758102f, 0.00556435f, -0.00584681f, 
    -0.01209813f, -0.00929502f, 0.02256744f, -0.03178040f, 0.02650670f, -0.00122008f, 0.01826702f, -0.00341170f, 
    -0.02484039f, 0.01627286f, 0.00202922f, 0.02441987f, -0.01136707f, 0.02350534f, 0.02749100f, 0.00863740f, 
    -0.00521851f, -0.04137971f, -0.00425952f, -0.02241140f, -0.03004991f, 0.00332254f, 0.01175386f, -0.03487493f, 
    0.00053206f, -0.04038169f, 0.00617707f, -0.04175710f, 0.03527317f, -0.03123152f, 0.02802306f, -0.02442400f, 
    -0.03969406f, -0.01709992f, -0.03917836f, 0.02460513f, 0.01885848f, -0.01034400f, -0.01575873f, 0.02123430f, 
    -0.00027848f, -0.01614901f, -0.02734073f, 0.00230698f, 0.00622066f, -0.02529759f, -0.02028979f, -0.03079029f, 
    -0.02484139f, 0.00016084f, -0.00535997f, -0.00540843f, 0.02870560f, -0.02614169f, 0.01048336f, -0.00297321f, 
    -0.01589558f, 0.01059874f, -0.01426942f, 0.00309045f, 0.00978173f, 0.02519884f, -0.02880714f, -0.02893959f, 
    -0.00179355f, 0.01225697f, 0.01212175f, -0.01812741f, -0.02731465f, -0.00312579f, 0.01035893f, -0.02150472f, 
    -0.03754189f, -0.00375484f, -0.00845851f, 0.02222512f, -0.01552490f, -0.03888823f, 0.02404638f, -0.01176730f, 
    0.00497362f, -0.02594106f, -0.03796455f, -0.01312185f, -0.03806975f, -0.01435012f, -0.00813210f, -0.00778039f, 
    0.02195114f, -0.00888599f, 0.00719656f, -0.01499220f, 0.01932990f, 0.01222071f, -0.01879623f, 0.02483287f, 
    -0.00885168f, 0.01925935f, 0.00263941f, -0.03553396f, -0.02185271f, -0.02204324f, 0.01351790f, 0.00788330f, 
    -0.01494813f, -0.00268033f, 0.02228191f, 0.00573871f, 0.02705260f, 0.00307315f, -0.02156180f, -0.03847593f, 
    0.00378718f, -0.02169430f, -0.00098680f, 0.00421123f, -0.04217554f, 0.02657434f, -0.01003407f, -0.04288350f, 
    0.02034216f, -0.04130787f, 0.00437447f, -0.04242567f, 0.00194898f, -0.02245747f, -0.00694720f, -0.02784040f, 
    0.02667712f, 0.02853468f, -0.02826401f, -0.03187230f, -0.02583072f, -0.04322360f, -0.01513204f, 0.00774078f, 
    0.00518368f, -0.03380989f, 0.02715524f, 0.02697467f, 0.00701954f, -0.02668549f, -0.03843994f, 0.02190939f, 
    0.01253515f, 0.01124993f, -0.03716578f, -0.00362025f, -0.00875430f, 0.01586824f, 0.00142381f, -0.02075412f, 
    -0.03451949f, -0.01445226f, -0.02684176f, -0.01211475f, -0.01904431f, 0.00317265f, 0.01257065f, -0.04278049f, 
    0.00059110f, -0.02390179f, -0.01006374f, -0.01132120f, -0.02959352f, 0.01077670f, 0.01838559f, 0.00813594f, 
    0.02154372f, 0.00445707f, -0.02360264f, 0.02713445f, 0.02644649f, -0.00747057f, 0.02014637f, -0.03468870f, 
    -0.00368181f, 0.01712183f, -0.03816799f, -0.00464331f, -0.04000099f, -0.01909494f, 0.01425372f, 0.02940167f, 
    -0.02658330f, 0.01896153f, -0.03027652f, 0.02841768f, -0.02671891f, 0.02383723f, 0.01574646f, -0.00730222f, 
    -0.02734643f, -0.01890941f, 0.02587903f, 0.02094692f, -0.00498506f, 0.01811564f, -0.04344646f, -0.00914476f, 
    0.00025643f, -0.04148464f, 0.02035531f, 0.02466557f, -0.02910136f, -0.01438901f, -0.01815436f, 0.01341202f, 
    0.01204223f, 0.01924553f, -0.00616736f, -0.02535691f, -0.03679316f, -0.03972822f, 0.00728785f, -0.02609643f, 
    -0.03160930f, 0.02207372f, -0.03794973f, -0.02811061f, 0.01407408f, 0.01968819f, 0.01391658f, 0.01213488f, 
    -0.03786034f, 0.01361689f, 0.00696915f, -0.03247995f, 0.02590532f, -0.01091180f, 0.02171166f, -0.02751468f, 
    0.02300105f, -0.01288291f, 0.00934651f, -0.00328403f, -0.02845538f, 0.02832555f, -0.01705544f, 0.00756155f, 
    -0.01702649f, 0.02397480f, 0.02403755f, -0.02472579f, -0.00769896f, 0.00594370f, 0.00800942f, -0.02342014f, 
    0.00044967f, -0.02163689f, -0.01281095f, 0.00533025f, -0.00908851f, 0.02502796f, -0.02659797f, 0.02018859f, 
    -0.03982236f, 0.00238408f, 0.01130908f, -0.01338279f, 0.00102016f, 0.00906302f, -0.01117071f, -0.00673908f, 
    -0.04215873f, 0.01859287f, 0.02245972f, -0.01960206f, -0.03614058f, -0.01951402f, 0.02873611f, -0.00165353f, 
    -0.03132046f, -0.02379445f, -0.00538221f, -0.03465589f, 0.01899530f, -0.01714497f, 0.02581433f, -0.00850242f, 
    0.00494625f, 0.00832021f, -0.02120342f, -0.01684616f, 0.00091833f, -0.04338348f, 0.00104928f, -0.02048437f, 
    0.00110077f, -0.03548693f, 0.01188124f, 0.03024562f, -0.03978783f, -0.01752571f, -0.02815819f, -0.01245860f, 
    -0.03341482f, -0.00347118f, -0.01585053f, -0.03123602f, 0.01658348f, -0.02056932f, 0.01006925f, -0.02579202f, 
    -0.03605979f, -0.02488199f, -0.01938199f, -0.01380761f, 0.01272222f, 0.02087792f, -0.02562032f, 0.01601599f, 
    0.02453838f, 0.00776058f, -0.04394178f, 0.02670884f, -0.00568515f, -0.00742188f, -0.02847038f, -0.04048396f, 
    -0.02759256f, 0.02456776f, 0.01057309f, -0.02524399f, -0.00145085f, -0.03422655f, 0.01283914f, -0.00448194f, 
    0.01108640f, -0.00670859f, -0.03571833f, -0.01326427f, 0.00091850f, 0.01711742f, 0.02230765f, 0.03401075f, 
    -0.03929042f, 0.00216582f, -0.00258373f, -0.02981922f, -0.04129938f, -0.03574019f, -0.03189726f, 0.02484142f, 
    0.01659759f, 0.01770519f, -0.03812982f, -0.04309361f, 0.00512781f, -0.03947076f, -0.02415515f, 0.01649118f, 
    -0.00574669f, 0.02769035f, 0.00610558f, 0.01744300f, -0.01037644f, 0.00219047f, 0.01606736f, 0.02794118f, 
    0.02651772f, -0.00908934f, 0.01128215f, 0.01671556f, 0.00150498f, -0.01617582f, -0.01702741f, 0.00172341f, 
    -0.04105707f, -0.02633321f, 0.01395187f, 0.01430622f, -0.00350938f, 0.01525631f, -0.02547846f, 0.02732425f, 
    0.01620973f, -0.01114514f, -0.02703250f, -0.00510195f, -0.02851306f, 0.02414096f, 0.02328786f, 0.00683054f, 
    -0.00786697f, -0.00295344f, 0.01423031f, 0.02289702f, -0.02399836f, 0.02191444f, -0.02852102f, 0.01216473f, 
    -0.04033965f, -0.02615304f, 0.00086370f, 0.01037952f, -0.01406270f, -0.00739521f, 0.00877425f, -0.03553119f, 
    -0.04294702f, 0.02679905f, -0.04095173f, -0.01994662f, -0.03621010f, -0.01844991f, 0.01041485f, 0.00370973f, 
    -0.02551907f, -0.02800310f, -0.02836237f, -0.00426613f, 0.01735825f, -0.00978588f, 0.01708781f, -0.02880812f, 
    0.01257607f, -0.03241111f, 0.08276594f, -0.11529841f, 0.01473220f, -0.04438310f, -0.03360265f, 0.07427697f, 
    -0.12599398f, -0.06167918f, 0.11202604f, 0.03333186f, 0.09406386f, 0.21079741f, 0.00243056f, 0.01338765f, 
    0.08767048f, 0.14855839f, 0.04385122f, 0.06226592f, -0.02251863f, -0.02461054f, -0.04239314f, -0.03014072f, 
    0.01134726f, -0.08162107f, -0.13836537f, -0.01030639f, 0.00902854f, -0.02694609f, -0.02565243f, -0.13013995f, 
    -0.08896215f, 0.04724012f, 0.03844485f, 0.02396034f, 0.09746824f, 0.04112613f, 0.13799068f, -0.07742924f, 
    0.03590260f, 0.11516245f, 0.09043804f, -0.03067039f, 0.02397588f, 0.01227100f, 0.03933685f, 0.04323988f, 
    -0.08921061f, 0.09823788f, -0.01741209f, 0.11872363f, -0.01863150f, 0.09082933f, 0.04180159f, -0.09529295f, 
    -0.02462116f, 0.02973220f, 0.02758636f, -0.03803402f, 0.11518304f, 0.20692882f, 0.20484003f, -0.03010725f, 
    0.10681948f, 0.09182756f, 0.05571728f, -0.05336763f, -0.10033619f, 0.03926997f, -0.02090256f, 0.01023689f, 
    0.19119357f, 0.14920203f, -0.03766287f, -0.01190942f, -0.09769105f, -0.02153965f, 0.12365678f, -0.03271458f, 
    0.01854778f, 0.05052473f, 0.01140769f, -0.01160877f, 0.18021436f, 0.12488322f, 0.13549598f, -0.01762914f, 
    0.04842616f, -0.05687321f, 0.03390392f, 0.08865657f, -0.08258718f, -0.03357483f, 0.05620271f, 0.10660393f, 
    -0.13991405f, -0.21089074f, -0.24361999f, 0.01322940f, -0.01753784f, -0.05024683f, 0.04037260f, -0.03653425f, 
    0.06649888f, -0.01566401f, -0.04970546f, -0.07593028f, -0.13487238f, 0.01803712f, -0.01032626f, 0.04586315f, 
    -0.01932346f, -0.04650206f, 0.03360463f, 0.08101743f, 0.04808653f, 0.14028239f, -0.00030424f, 0.00665039f, 
    0.20435889f, 0.20087995f, -0.02144915f, 0.01460241f, 0.06347884f, -0.07631965f, 0.02939196f, -0.15330611f, 
    0.09878831f, 0.08020570f, -0.02859109f, 0.10187724f, -0.16057427f, -0.17147011f, -0.13666107f, 0.01584943f, 
    -0.04082705f, -0.12544712f, 0.02699367f, 0.02823074f, -0.02851906f, -0.09643141f, 0.10067227f, 0.11059500f, 
    -0.06211405f, 0.13624813f, 0.03348240f, 0.15910465f, -0.02807835f, 0.02891707f, 0.00465184f, 0.07222008f, 
    0.01068935f, 0.01564881f, -0.06851929f, -0.03463786f, 0.18509187f, 0.00200441f, -0.01194955f, 0.07058594f, 
    0.08642276f, -0.04765996f, 0.03155175f, 0.05231620f, 0.02008663f, 0.00193414f, -0.03950489f, -0.02423947f, 
    -0.12295599f, 0.03114485f, 0.00177264f, -0.19900149f, -0.09006678f, 0.16815160f, 0.01103470f, 0.01198091f, 
    0.09311620f, 0.17393981f, -0.09047180f, 0.00799073f, 0.27187979f, 0.34394944f, 0.11984519f, 0.06598195f, 
    0.00413084f, 0.06495886f, -0.01271396f, -0.01360603f, 0.02757501f, 0.03993610f, -0.00483519f, -0.04207330f, 
    -0.21681277f, -0.02877250f, 0.25538224f, 0.13220945f, 0.03511586f, -0.05363565f, -0.03299465f, 0.07362805f, 
    0.07025774f, -0.01236501f, 0.05363966f, -0.05092975f, 0.22487436f, -0.00278476f, 0.15684436f, 0.20115611f, 
    -0.02926999f, 0.06949835f, 0.15646255f, 0.10430340f, 0.02021055f, 0.01515905f, 0.04891558f, -0.04121327f, 
    0.00656385f, -0.05062648f, 0.01433995f, 0.00411926f, -0.05274622f, 0.10844999f, 0.00706662f, 0.05877975f, 
    -0.04399564f, 0.05505905f, 0.17995676f, -0.17044298f, 0.38284907f, 0.17853753f, 0.18668975f, 0.09212410f, 
    0.04719568f, -0.02927296f, -0.03736068f, 0.12320571f, -0.05355765f, -0.05246283f, -0.03794339f, 0.01855398f, 
    0.14300710f, 0.14575633f, 0.15378714f, 0.12574808f, 0.03236344f, 0.02002069f, 0.05438997f, 0.18396963f, 
    0.04120485f, -0.07454658f, 0.08373186f, 0.02622186f, -0.17849949f, -0.08568015f, -0.12776807f, 0.10515447f, 
    0.05990131f, -0.09037451f, -0.04442689f, -0.04459260f, 0.09656277f, -0.01627652f, -0.07994204f, -0.12876688f, 
    0.25298741f, 0.19804190f, 0.05540568f, 0.14581725f, 0.04724091f, 0.07221203f, 0.05918569f, -0.02891762f, 
    0.01661776f, -0.07338391f, 0.05110357f, 0.01566581f, -0.01600268f, -0.22497863f, -0.17105010f, 0.12569043f, 
    0.04122989f, -0.05572194f, 0.02736049f, -0.01902534f, 0.09733791f, -0.07391363f, 0.05600771f, -0.27632931f, 
    0.00740983f, 0.20518401f, 0.16269888f, 0.08315118f, -0.02581905f, 0.00184236f, 0.17436251f, 0.02889366f, 
    -0.01237821f, 0.07982031f, 0.07249364f, 0.12041532f, 0.08649801f, -0.08397220f, -0.05812666f, 0.18101282f, 
    0.06579638f, -0.01652459f, 0.01873843f, 0.06129676f, 0.03685530f, 0.07582366f, 0.08630704f, -0.04444864f, 
    0.06481203f, 0.12075198f, 0.09352754f, 0.24791844f, -0.02609850f, 0.00540635f, 0.06842473f, -0.03004627f, 
    -0.11491621f, 0.03642554f, 0.09341675f, -0.01217539f, -0.07039171f, -0.01472538f, 0.17988706f, -0.11813934f, 
    -0.11862826f, 0.02538238f, 0.07295069f, -0.06624246f, -0.08047692f, -0.01199741f, 0.03078309f, 0.05867270f, 
    -0.04583070f, 0.16480872f, -0.00849394f, 0.19496667f, -0.01167488f, -0.01464115f, 0.09021772f, -0.04862517f, 
    0.03451384f, 0.05108176f, 0.07418464f, 0.01897043f, -0.01925086f, 0.09910155f, 0.11296242f, -0.00514880f, 
    0.00804781f, -0.00799909f, 0.14469585f, 0.24203239f, 0.06503636f, 0.08442430f, 0.04931873f, 0.00607724f, 
    -0.10954586f, 0.23411402f, 0.28143615f, 0.14005969f, -0.02166124f, 0.03725364f, 0.04590326f, -0.01571222f, 
    -0.01929212f, -0.03153754f, 0.08627922f, 0.02009510f, 0.23895521f, -0.13014129f, -0.14944763f, -0.23983537f, 
    0.03065482f, -0.03266501f, -0.02035105f, -0.04560629f, -0.00710529f, -0.04522644f, 0.03981500f, 0.01851100f, 
    -0.01684915f, 0.02400049f, -0.06942339f, -0.10853666f, 0.01498235f, 0.08095256f, -0.06038310f, 0.04267992f, 
    0.10648248f, 0.03920030f, 0.04116715f, -0.14779194f, 0.12822008f, -0.07107772f, -0.17358728f, -0.10507110f, 
    0.01461873f, 0.01123044f, -0.03239078f, -0.08171566f, -0.04723711f, 0.04680801f, -0.02988723f, 0.11089703f, 
    0.24760908f, 0.12254853f, 0.00527818f, 0.01511179f, 0.07088941f, -0.00064754f, 0.06084284f, 0.04956835f, 
    0.01938489f, 0.03101367f, 0.04757837f, 0.06993027f, -0.05300303f, 0.00204719f, 0.05649946f, -0.12727720f, 
    -0.11075322f, -0.01575721f, 0.02594898f, -0.00923115f, -0.05403756f, -0.04910311f, -0.10183950f, -0.05779713f, 
    -0.03050015f, 0.18320917f, 0.09293202f, 0.15241401f, -0.09003153f, -0.04154767f, 0.00287837f, 0.00682795f, 
    0.10197800f, -0.07216145f, 0.03596001f, -0.01243402f, -0.10674551f, 0.16683429f, 0.34331468f, 0.02055808f, 
    0.01197862f, -0.01090723f, 0.13938239f, -0.13083337f, -0.09787279f, 0.01036317f, 0.05946691f, 0.02677156f, 
    0.06923526f, 0.00272892f, 0.03460883f, 0.10773182f, 0.02202383f, -0.04100408f, -0.04595812f, -0.03684602f, 
    0.09229457f, 0.00584039f, 0.01460756f, 0.01168047f, 0.19908614f, 0.19783673f, 0.06826879f, 0.03370131f, 
    0.06355859f, 0.00226081f, -0.05403969f, 0.09029109f, 0.05259767f, 0.18076104f, 0.05779558f, 0.02241591f, 
    0.12115631f, 0.10402183f, -0.04251708f, -0.03544644f, 0.07373166f, 0.04306941f, 0.07113431f, 0.12187361f, 
    0.00352754f, 0.06353739f, 0.00679351f, -0.01487454f, 0.01091590f, 0.09105958f, 0.17553726f, 0.01436174f, 
    -0.02251901f, -0.06262072f, 0.10060356f, -0.02962675f, 0.02502229f, -0.03417449f, 0.05591165f, 0.01128574f, 
    -0.09309997f, -0.06580826f, 0.02459862f, 0.06311131f, -0.02509391f, -0.02139572f, 0.20240220f, 0.07996438f, 
    -0.06078985f, 0.03394910f, 0.06156616f, 0.08141294f, 0.05037883f, 0.04029903f, -0.06213043f, 0.20001015f, 
    0.03470051f, -0.04121776f, 0.15908973f, 0.11487547f, 0.08017873f, -0.01537598f, 0.11683007f, -0.15907514f, 
    0.04988039f, -0.14172512f, -0.13074417f, 0.05427560f, 0.04455666f, -0.03863068f, -0.07011545f, -0.06025773f, 
    -0.05424297f, -0.02232322f, 0.04706721f, -0.13836253f, -0.11205520f, -0.04500525f, -0.07759842f, 0.10621268f, 
    0.02241323f, -0.00654966f, -0.00294032f, -0.10672404f, -0.10838203f, -0.02630446f, -0.03971220f, -0.10510886f, 
    -0.26600921f, -0.02141342f, 0.02355441f, 0.02003665f, 0.04535950f, -0.15702096f, 0.07100941f, -0.00881210f, 
    0.06007517f, 0.17671102f, -0.04964701f, 0.03237625f, 0.02950737f, 0.02110112f, -0.06944474f, 0.00048020f, 
    -0.08109849f, 0.07493659f, -0.18032587f, 0.15544212f, 0.00538746f, 0.01796634f, 0.05087231f, -0.08899458f, 
    -0.19091153f, -0.14434287f, -0.09896725f, -0.03041135f, -0.05493882f, -0.00678473f, 0.08234765f, 0.01784465f, 
    -0.00845939f, 0.02280295f, 0.09782041f, 0.03121303f, 0.09843823f, 0.30680454f, -0.13107574f, 0.00476662f, 
    0.07080670f, 0.12132072f, -0.05200141f, -0.05004019f, 0.07378317f, 0.02911097f, -0.03113621f, -0.01326596f, 
    -0.17425232f, -0.05551577f, -0.18374239f, 0.04358985f, 0.05975900f, -0.07081988f, -0.03866556f, 0.00484918f, 
    0.00124142f, -0.00042223f, -0.04421020f, 0.05579145f, -0.21433902f, -0.07692822f, -0.26467398f, -0.09263236f, 
    0.14598781f, 0.04635068f, 0.03162043f, -0.01419605f, -0.04198033f, 0.18134354f, 0.12392485f, -0.07713333f, 
    0.12648785f, 0.01732022f, 0.05080730f, 0.43495908f, -0.00020594f, 0.09298960f, -0.02401602f, 0.04901703f, 
    0.04044790f, -0.04821530f, -0.05620366f, -0.06705003f, -0.07384193f, 0.06464849f, -0.11717735f, -0.06003136f, 
    0.11201413f, 0.09415281f, -0.03724450f, 0.03126246f, 0.04239848f, 0.07365807f, 0.09765965f, -0.04588257f, 
    -0.05774879f, 0.09861605f, -0.04179702f, 0.17426397f, 0.03544181f, -0.04489200f, 0.10366756f, -0.09368475f, 
    -0.00517338f, 0.03006842f, -0.04050027f, -0.00529615f, 0.12451635f, 0.15701465f, 0.17102274f, 0.22812101f, 
    0.02758041f, 0.02597264f, -0.01987311f, 0.16952597f, -0.06670966f, -0.02847028f, 0.04044689f, -0.15988895f, 
    0.04456401f, 0.00455451f, -0.34592855f, 0.06799904f, 0.10128955f, 0.09704240f, 0.06606115f, 0.00365174f, 
    0.01364471f, -0.00665062f, 0.07913750f, -0.03907529f, -0.01877007f, 0.19531091f, -0.10970834f, 0.03022351f, 
    0.15592682f, 0.03619513f, -0.00811419f, -0.00689899f, 0.08485159f, 0.15278719f, -0.01437932f, 0.10013511f, 
    -0.03676119f, 0.07818086f, 0.13947266f, 0.08167817f, 0.01577968f, -0.04739094f, 0.09945708f, 0.12002464f, 
    -0.03779118f, -0.06214434f, -0.07558869f, 0.08531007f, -0.08412495f, -0.06820377f, -0.00440614f, 0.04000041f, 
    -0.00554421f, -0.06666213f, -0.13913730f, -0.18254365f, 0.01662496f, 0.06729774f, 0.09027044f, 0.10071529f, 
    0.01168195f, -0.00311180f, -0.06258913f, -0.17183718f, -0.01230557f, -0.02430282f, 0.01183876f, 0.06689448f, 
    -0.03557045f, 0.06551192f, 0.11950747f, -0.08197995f, 0.09960154f, -0.02041873f, 0.10866127f, 0.02953648f, 
    0.08538271f, 0.14194696f, 0.05240290f, 0.05193736f, 0.08173601f, -0.09395535f, -0.03180633f, 0.13286707f, 
    0.12284951f, 0.14626583f, 0.01856297f, 0.19823690f, -0.01430810f, 0.00126839f, 0.01914983f, -0.05163164f, 
    0.08869609f, 0.02433802f, -0.01248936f, 0.02861199f, -0.00309872f, 0.25430959f, 0.15517324f, 0.14366409f, 
    -0.05044217f, 0.01950660f, 0.06233432f, -0.02127508f, -0.00993420f, -0.00437690f, 0.02625022f, -0.05571755f, 
    0.01968908f, 0.03357793f, -0.00451725f, -0.01250012f, 0.02220088f, 0.01798278f, -0.04077077f, -0.00457494f, 
    -0.00765537f, 0.01219644f, -0.02583300f, -0.04006433f, -0.02652758f, -0.00333760f, -0.02218556f, 0.00459278f, 
    0.01485278f, 0.01157212f, -0.02866893f, -0.01146807f, 0.01856844f, -0.01741819f, 0.02512326f, 0.01359937f, 
    0.03221936f, 0.01708057f, -0.03984275f, 0.01443015f, 0.02459216f, 0.00694876f, -0.00432069f, 0.02483936f, 
    0.01910982f, 0.03261917f, -0.02846327f, 0.01546139f, -0.02641402f, 0.02777370f, -0.02017535f, -0.00709345f, 
    -0.00862581f, 0.03717992f, 0.00249531f, -0.01418068f, 0.01773470f, 0.02114346f, -0.01561371f, -0.00033665f, 
    0.01110949f, 0.00463965f, -0.04078690f, -0.00684372f, 0.00479293f, 0.01897714f, 0.00019314f, -0.02960252f, 
    -0.03772013f, -0.04024094f, 0.01322172f, 0.01538476f, -0.03254531f, -0.02567828f, -0.02019178f, 0.00567901f, 
    -0.03027844f, 0.01966273f, 0.02696580f, -0.03048832f, 0.02918897f, -0.02871754f, 0.03304497f, -0.00268720f, 
    0.00481165f, -0.02698553f, 0.02506885f, -0.00411579f, 0.01433168f, 0.02463677f, -0.00949027f, -0.03901128f, 
    0.00140303f, 0.00962966f, -0.02805274f, -0.00924668f, -0.02649535f, -0.00746748f, 0.00923987f, -0.03755010f, 
    0.03034676f, 0.01050931f, -0.00844256f, -0.00371922f, -0.00909171f, 0.01342319f, 0.00704135f, -0.02108192f, 
    -0.00498980f, -0.02429291f, 0.00022344f, -0.02265044f, 0.02832155f, -0.01115171f, -0.00531233f, -0.03972582f, 
    -0.01391314f, -0.02397636f, -0.01282156f, -0.01183560f, -0.02348334f, 0.01060218f, -0.03769574f, 0.00664769f, 
    0.01912836f, -0.02947753f, -0.03758813f, -0.00641642f, 0.02804294f, -0.02879735f, -0.01289342f, 0.02920583f, 
    -0.01509649f, -0.00872689f, -0.00420503f, -0.00656910f, -0.01150762f, 0.02999728f, -0.02530820f, -0.02426796f, 
    -0.01052427f, -0.01460581f, 0.02304441f, 0.00298952f, 0.00108937f, -0.01115522f, -0.01487664f, -0.03106658f, 
    0.01799557f, 0.00911229f, -0.01281181f, 0.02783025f, 0.01100204f, 0.01677616f, 0.03012715f, -0.00592557f, 
    -0.00195184f, -0.01109349f, -0.01646090f, -0.01672337f, -0.03188507f, 0.01712343f, 0.02634035f, -0.03732534f, 
    -0.02721109f, 0.03199879f, -0.03812158f, 0.01597631f, 0.00584425f, -0.00697990f, 0.00054054f, 0.01078560f, 
    -0.03507165f, 0.01638400f, -0.03310263f, -0.01676494f, -0.02915806f, -0.00031023f, -0.00650862f, 0.01137688f, 
    -0.04065507f, -0.00169746f, -0.00960579f, -0.00722368f, -0.02434178f, -0.03642674f, 0.00838572f, -0.02535481f, 
    -0.02588768f, -0.02158112f, -0.01267769f, 0.02670879f, -0.03759642f, -0.02863386f, -0.00251881f, -0.02200853f, 
    -0.02063538f, -0.02305014f, 0.00853867f, 0.00765922f, 0.02129922f, -0.02591989f, 0.01904738f, 0.03017130f, 
    0.01169932f, 0.00499219f, -0.00536487f, 0.02151139f, -0.02926919f, -0.01467182f, 0.00497246f, -0.02027518f, 
    -0.01416547f, -0.00582160f, -0.03740566f, -0.00744454f, -0.00881714f, -0.00454535f, -0.01643369f, -0.03373945f, 
    0.02352833f, -0.02919419f, -0.02019650f, 0.03177109f, -0.00763063f, 0.00629999f, -0.00500792f, 0.01979650f, 
    0.02566844f, -0.01230455f, 0.00089596f, 0.01364148f, 0.02880419f, 0.02198517f, 0.01252513f, 0.01623414f, 
    -0.02363420f, -0.00624573f, -0.00151967f, 0.03033482f, 0.02082009f, 0.01761983f, -0.04072664f, -0.02596506f, 
    -0.01142593f, 0.00687375f, -0.00475311f, -0.04009918f, -0.01273057f, -0.01366806f, 0.01181275f, -0.00133608f, 
    0.02010322f, 0.01159588f, -0.04260127f, -0.00635819f, -0.01694518f, -0.03678953f, -0.02799170f, -0.03488997f, 
    0.00458299f, -0.00928002f, -0.01156106f, 0.02400920f, 0.01531136f, 0.03246306f, -0.00879174f, -0.03374936f, 
    -0.02741412f, 0.01643783f, -0.03426380f, -0.02486107f, 0.01082609f, 0.00606663f, -0.00275077f, -0.04140329f, 
    -0.01528313f, -0.02519122f, -0.01980815f, -0.03457005f, 0.00539076f, -0.03692271f, -0.00603014f, 0.01547528f, 
    -0.01452674f, 0.02222918f, -0.03133551f, -0.00110863f, -0.01763313f, -0.01541644f, -0.00949605f, 0.02453098f, 
    0.03096288f, -0.01911000f, 0.01689003f, -0.02145442f, 0.01396666f, 0.02296227f, 0.00209205f, 0.03277868f, 
    0.00340746f, 0.02188972f, -0.01951588f, 0.00089326f, -0.00505287f, 0.00259612f, -0.03679634f, -0.03796779f, 
    0.02757520f, -0.00051903f, 0.03320304f, 0.01237779f, 0.02321716f, -0.02214205f, 0.02100872f, 0.02258279f, 
    -0.01867598f, 0.01223350f, -0.00104059f, -0.01817680f, -0.02748866f, 0.03055421f, -0.02158582f, 0.01501772f, 
    -0.02969144f, 0.00365278f, 0.02342165f, 0.02472532f, 0.00133182f, 0.01045759f, 0.02201036f, 0.02885161f, 
    0.02900765f, 0.00084155f, 0.02157127f, -0.01679645f, -0.02289092f, 0.02570927f, 0.02342574f, -0.02246568f, 
    -0.01302000f, -0.00684052f, 0.00997111f, -0.01627768f, -0.01751258f, -0.00598611f, 0.00182878f, -0.01540063f, 
    0.02883542f, -0.03257853f, 0.01381694f, -0.00765136f, 0.00507719f, -0.01386272f, 0.00736852f, 0.00866096f, 
    0.02616606f, 0.00555040f, 0.01335926f, -0.02325925f, 0.02589098f, -0.00536040f, -0.00340907f, -0.03444590f, 
    -0.01576529f, 0.02611369f, 0.00939466f, 0.00169257f, -0.03557887f, 0.00657123f, -0.03477749f, -0.02229998f, 
    0.00926453f, 0.01036834f, -0.02141119f, -0.01435076f, -0.02824449f, 0.00589448f, 0.01779585f, -0.02994457f, 
    -0.01654117f, -0.01895953f, -0.03783999f, -0.02109515f, 0.03340011f, -0.00640529f, 0.01705154f, -0.02197630f, 
    0.02749968f, -0.02659897f, 0.02027014f, -0.02738663f, 0.00812300f, -0.03580090f, 0.02226779f, 0.00770327f, 
    0.01191598f, 0.02242157f, -0.01787648f, 0.00002970f, -0.03288304f, 0.01636752f, -0.03807636f, -0.02954112f, 
    0.00029857f, -0.01815977f, 0.00322580f, -0.04037517f, 0.02506562f, 0.01092462f, -0.00798618f, -0.02736837f, 
    0.00469999f, 0.00034874f, 0.01330786f, -0.02759285f, -0.01802144f, -0.01429998f, -0.01777625f, 0.02569920f, 
    0.02565510f, -0.03879072f, -0.03233294f, -0.02788291f, -0.01835120f, -0.01974066f, -0.03443460f, -0.03328627f, 
    0.01168678f, -0.00680617f, -0.03746145f, -0.02238175f, -0.01447371f, 0.01192654f, 0.01716991f, -0.00507046f, 
    -0.03560889f, -0.00343194f, -0.01202539f, -0.03365412f, 0.00313689f, -0.01827950f, 0.00624472f, 0.00091351f, 
    0.00864552f, -0.03624703f, -0.02235051f, -0.01050482f, 0.00995415f, 0.02575220f, -0.00481218f, 0.02332265f, 
    -0.03053862f, -0.03279139f, -0.00465408f, -0.02690387f, -0.02822283f, -0.00560534f, -0.03426848f, -0.02228975f, 
    -0.02027913f, -0.00064087f, -0.01765688f, 0.00665883f, 0.01648111f, -0.02594282f, 0.00455981f, 0.00010577f, 
    0.01484538f, 0.00994655f, -0.01736358f, 0.00295644f, -0.03370830f, -0.01369795f, 0.02007554f, 0.03151441f, 
    0.02923180f, 0.03126794f, 0.02417168f, -0.01119787f, 0.02875122f, -0.01142972f, -0.02770251f, 0.00427949f, 
    0.03077485f, -0.00349903f, 0.01163155f, 0.03522991f, -0.03001178f, -0.02668328f, -0.03395284f, -0.02428786f, 
    -0.03076485f, -0.01246124f, 0.00389017f, 0.02843632f, -0.00454939f, -0.01546100f, -0.01646345f, -0.02612696f, 
    0.02999789f, 0.02967307f, 0.02902346f, -0.02069055f, 0.02716958f, 0.01747502f, 0.01033536f, -0.00713812f, 
    -0.03029917f, -0.03241729f, -0.03266133f, -0.03089167f, -0.01977870f, -0.01231681f, -0.03393662f, -0.02756516f, 
    -0.01160200f, 0.01866582f, -0.04020815f, -0.00727704f, 0.00869224f, 0.02095189f, 0.02217988f, -0.02594825f, 
    0.00602258f, 0.02743887f, 0.01600403f, 0.03257314f, 0.02328737f, 0.02252723f, -0.02895035f, -0.01654157f, 
    -0.02578883f, 0.03167446f, -0.00132142f, -0.00543979f, -0.02671067f, 0.01694603f, 0.01982387f, -0.00170874f, 
    0.03137471f, -0.02773316f, -0.00323364f, 0.02360122f, -0.03527239f, 0.02435716f, 0.02281627f, -0.02909020f, 
    -0.01376159f, -0.02697964f, 0.03039727f, -0.00518628f, -0.00676492f, 0.01020672f, -0.01641309f, 0.00005817f, 
    -0.03722963f, 0.00060402f, 0.00801141f, 0.01360650f, 0.01044969f, -0.02186135f, 0.01142892f, -0.01471378f, 
    -0.03363921f, -0.01931732f, -0.03113906f, 0.01174586f, 0.02978170f, -0.03675777f, -0.00486251f, 0.00909836f, 
    -0.00321094f, -0.01493114f, 0.00920841f, -0.02757632f, -0.00733577f, -0.02063895f, -0.02245880f, 0.00476976f, 
    -0.00291843f, -0.00155410f, 0.01449952f, 0.00923117f, -0.02242823f, 0.00917815f, 0.01512678f, -0.02378905f, 
    0.00632884f, -0.02237668f, -0.00798024f, -0.00545935f, -0.01405038f, -0.01933349f, -0.01472798f, 0.00452513f, 
    0.02919120f, 0.01523860f, 0.03070297f, 0.01338675f, -0.02351043f, -0.03674024f, 0.00996370f, 0.00510870f, 
    -0.00557983f, -0.01479396f, 0.00045525f, 0.00333497f, -0.00350349f, 0.00228076f, -0.02686129f, 0.02273712f, 
    -0.02835709f, -0.00120430f, -0.03124200f, -0.02688234f, 0.02201656f, -0.02228738f, 0.01472605f, -0.02381021f, 
    -0.02766459f, -0.02309324f, 0.01462082f, -0.03634677f, 0.02664000f, 0.00857165f, 0.02834159f, -0.03140458f, 
    0.00872749f, 0.00028225f, 0.01515750f, 0.02940853f, -0.00155997f, -0.01859782f, 0.03082345f, 0.03133193f, 
    -0.03746007f, -0.03976256f, -0.00796351f, -0.01684046f, -0.03028349f, 0.01761248f, 0.01992488f, -0.01669322f, 
    -0.03219450f, -0.00856676f, -0.02050531f, -0.01512166f, 0.02624271f, -0.00153063f, 0.01155810f, -0.01969606f, 
    -0.00784098f, -0.02495763f, -0.02766854f, -0.03096810f, 0.00255921f, 0.00708548f, 0.00856915f, -0.01073086f, 
    -0.02369969f, -0.03525613f, -0.03348765f, 0.00469643f, 0.02968899f, 0.01218911f, -0.01032043f, -0.02076852f, 
    -0.01495495f, -0.01509388f, 0.01055648f, 0.02067487f, 0.01640732f, 0.00185720f, 0.01335427f, 0.03066886f, 
    0.01294961f, 0.02923305f, -0.01568469f, -0.02894681f, -0.02134992f, -0.00787055f, 0.00075075f, -0.00278230f, 
    -0.02886741f, -0.02481291f, -0.00837595f, 0.02247512f, -0.02304969f, -0.03340051f, 0.02843888f, -0.01588243f, 
    -0.01247732f, 0.02663263f, -0.01032690f, 0.00176694f, 0.01809596f, 0.02766196f, -0.01638291f, -0.01219591f, 
    -0.01927255f, -0.03148468f, -0.01927010f, -0.03390468f, 0.00302721f, 0.00861406f, -0.00514633f, -0.00179104f, 
    -0.00692567f, -0.00593908f, -0.00898277f, -0.03921648f, -0.02576251f, -0.00539101f, -0.02107268f, 0.02203554f, 
    0.01577813f, -0.01077723f, -0.00012569f, 0.02306917f, 0.00884368f, 0.00220150f, -0.00090958f, -0.01961992f, 
    -0.00904750f, -0.02076919f, 0.01077446f, -0.02460574f, 0.00717054f, -0.03314116f, -0.01826562f, 0.00545105f, 
    -0.00917077f, -0.01791435f, 0.03324104f, -0.00407980f, 0.02819253f, -0.00638734f, -0.00876776f, 0.02524073f, 
    0.02171368f, -0.00061990f, 0.01911327f, 0.01410038f, 0.02578953f, -0.00527543f, -0.02406894f, 0.03429629f, 
    0.00299775f, -0.03143360f, -0.03226044f, 0.02954470f, -0.03833143f, -0.02476444f, -0.02093656f, 0.00472402f, 
    -0.03446216f, -0.03567250f, -0.03524721f, 0.00917835f, -0.00928432f, -0.03388527f, 0.00169006f, -0.00693358f, 
    0.03448197f, -0.00036622f, 0.01362082f, -0.00319121f, -0.01931141f, -0.01002529f, 0.01471971f, 0.02170961f, 
    0.01807853f, 0.01710138f, 0.02749771f, -0.02198945f, -0.01925700f, -0.02858650f, -0.02533529f, 0.03040611f, 
    0.01960271f, -0.04002173f, 0.07085662f, 0.19621898f, -0.07912650f, 0.05772272f, 0.06549023f, -0.08119197f, 
    0.07562422f, 0.11468959f, -0.11286063f, 0.05058109f, -0.13507387f, -0.05918661f, -0.19635387f, -0.00817121f, 
    0.05411931f, -0.06608509f, -0.00543113f, -0.05978308f, 0.10638996f, 0.01977651f, 0.09175123f, 0.09215590f, 
    0.05212824f, 0.13409497f, 0.04919064f, -0.19805847f, 0.01498475f, -0.07981480f, -0.01159586f, 0.11342988f, 
    0.17068535f, -0.04452351f, -0.04353403f, -0.11719710f, -0.02761189f, -0.02945537f, -0.02211788f, 0.03275702f, 
    0.05612177f, -0.10150927f, -0.17061681f, 0.01449746f, 0.11470716f, 0.05745500f, -0.04960295f, -0.01081272f, 
    0.15275905f, 0.09497170f, -0.19987223f, 0.01621271f, 0.11226494f, 0.08808221f, -0.02151014f, -0.00433585f, 
    0.10553715f, -0.00386028f, 0.00130801f, -0.01337853f, 0.12206434f, 0.01595549f, -0.14801154f, 0.16407752f, 
    -0.08426838f, -0.05833632f, -0.08638128f, 0.06068906f, 0.00412456f, 0.01354302f, 0.06678465f, 0.13728893f, 
    -0.15858050f, 0.08118498f, 0.01542160f, -0.14461489f, 0.12273802f, 0.14549293f, -0.13776098f, 0.06909318f, 
    0.04251074f, -0.11236689f, 0.08818993f, 0.13121463f, -0.24795145f, -0.23279336f, 0.07346929f, 0.01833303f, 
    -0.05308008f, 0.10888054f, 0.04344366f, 0.04827467f, 0.05209483f, 0.12896377f, -0.07707463f, -0.10181488f, 
    0.09774636f, 0.11497863f, 0.27675849f, -0.03997901f, 0.12884411f, 0.02774921f, -0.11780509f, -0.05307984f, 
    0.01014785f, 0.04434201f, 0.06025374f, -0.03263219f, -0.08714123f, 0.01350716f, 0.17005575f, -0.22550063f, 
    0.09413109f, 0.00966868f, -0.02958534f, -0.04237273f, 0.02185912f, 0.00851115f, 0.00464668f, 0.06918985f, 
    -0.16841018f, -0.13286188f, 0.03405705f, 0.13115790f, 0.01526006f, 0.07420062f, -0.00852215f, 0.08746111f, 
    -0.02910514f, -0.00435553f, 0.00081634f, -0.08573098f, 0.10720656f, -0.04774030f, 0.17182116f, -0.02196167f, 
    0.05743211f, 0.08905360f, -0.07796018f, -0.07466935f, -0.02479759f, 0.15561329f, 0.00527988f, -0.16760497f, 
    -0.14380196f, -0.28661317f, -0.00877025f, -0.07448506f, -0.05587681f, 0.01921922f, -0.06847503f, -0.05115467f, 
    0.03266412f, -0.02213448f, 0.05413581f, 0.08335308f, -0.12409901f, -0.01937107f, 0.00550800f, -0.02950153f, 
    -0.08265094f, 0.03145147f, -0.03118339f, 0.03394370f, 0.00065876f, 0.16552712f, 0.03786851f, -0.07295187f, 
    0.50858086f, 0.10720068f, -0.15217848f, 0.24400537f, 0.22366029f, -0.06266648f, -0.08474328f, -0.04458638f, 
    -0.09002645f, -0.08979613f, 0.12601404f, 0.04616867f, -0.21050717f, -0.09571885f, -0.09491514f, -0.03153965f, 
    0.05420061f, 0.03714860f, 0.01272907f, -0.08849736f, 0.04442890f, 0.03067159f, 0.08017974f, 0.03922764f, 
    0.05123464f, 0.12732993f, -0.11490023f, -0.12976101f, -0.06926209f, 0.00060302f, 0.06792786f, -0.07318202f, 
    -0.04023521f, -0.09618240f, 0.13744023f, 0.08997764f, -0.09634832f, -0.02380733f, 0.07765738f, -0.17432834f, 
    0.13426687f, -0.07598824f, -0.04037915f, 0.05029119f, -0.04926940f, 0.03932128f, -0.13931289f, 0.05287537f, 
    0.02370098f, 0.11907915f, -0.03845786f, 0.04258627f, 0.21001297f, -0.14840962f, 0.06008274f, -0.08188941f, 
    0.05274964f, 0.00092909f, -0.11467344f, 0.18611588f, -0.34992355f, -0.25813675f, -0.12145189f, 0.04536031f, 
    -0.00732066f, 0.08905862f, 0.12333801f, -0.10234235f, -0.02544296f, -0.02670144f, 0.10080958f, 0.01594672f, 
    -0.38449582f, -0.31439021f, 0.02301831f, -0.08442718f, -0.02947024f, 0.09353211f, 0.11857580f, -0.17396420f, 
    0.00039441f, 0.07576127f, 0.02765960f, 0.01468637f, 0.29437965f, 0.02784044f, -0.10312347f, -0.11525887f, 
    -0.05409371f, -0.02710451f, 0.05066674f, -0.02123143f, -0.06155298f, 0.06243190f, 0.17055602f, 0.07635289f, 
    -0.35065690f, -0.18140952f, 0.12063610f, -0.01953075f, -0.01876847f, -0.01213137f, 0.10418116f, 0.12245408f, 
    0.02781700f, 0.10656252f, 0.02652583f, 0.06472355f, -0.00527743f, 0.15787287f, -0.04249054f, 0.12018028f, 
    0.06554186f, 0.06288038f, -0.05845445f, -0.11598177f, -0.06826659f, 0.04640708f, 0.00659338f, 0.23505838f, 
    -0.09362646f, -0.26913100f, -0.11367258f, -0.08481028f, 0.04038415f, 0.07125309f, -0.19385560f, -0.03423894f, 
    0.02902469f, -0.14002670f, 0.04445843f, -0.10857376f, -0.15847698f, 0.12146334f, -0.18091039f, -0.07093510f, 
    0.00466048f, 0.02264788f, 0.01389310f, 0.02303012f, -0.12498613f, -0.00877504f, 0.06044137f, 0.20821524f, 
    -0.01520077f, 0.05310493f, -0.14166722f, -0.12676360f, 0.05541240f, -0.00587227f, -0.09511851f, 0.07957380f, 
    0.11084221f, -0.02827924f, -0.14569813f, 0.03496724f, 0.13589086f, -0.09088557f, -0.07219616f, 0.15791768f, 
    0.10494959f, 0.01530826f, -0.01763602f, 0.04808870f, -0.02994267f, 0.10536945f, -0.03410684f, -0.05135352f, 
    0.05410610f, -0.07879514f, 0.05571720f, 0.02617229f, 0.13937199f, -0.00965626f, -0.02881784f, 0.03906929f, 
    0.07443160f, -0.00844413f, -0.04513970f, -0.00796479f, 0.11277849f, -0.05939732f, -0.19004349f, -0.01503133f, 
    -0.06469700f, -0.01148393f, -0.07717477f, -0.16427797f, -0.05683964f, -0.03303100f, -0.03210229f, 0.01922114f, 
    0.15538402f, -0.08110721f, -0.24062377f, -0.04984270f, 0.03951535f, 0.07009286f, -0.03806759f, -0.05161378f, 
    0.04201863f, 0.04752683f, -0.02472486f, 0.02197081f, -0.07105270f, -0.03784520f, 0.03795777f, 0.20196675f, 
    0.21010461f, 0.15107407f, -0.06027827f, 0.00572678f, 0.07512395f, -0.02363562f, 0.01237397f, 0.02529765f, 
    0.12764023f, 0.27725056f, 0.10352596f, 0.05340069f, 0.07509539f, 0.04816234f, -0.00765614f, -0.08512443f, 
    -0.01050067f, 0.00374457f, 0.05240199f, 0.24358678f, -0.06824014f, 0.24205522f, 0.01957091f, -0.04239422f, 
    0.10951407f, -0.05380900f, -0.00411260f, 0.12765205f, 0.03889825f, 0.03619152f, 0.13785088f, -0.07500573f, 
    0.14355448f, 0.01770698f, -0.09146728f, 0.10141365f, 0.05903276f, 0.03234651f, -0.01292000f, -0.03898637f, 
    -0.05477789f, 0.01139556f, 0.10683302f, 0.02228564f, 0.19547051f, -0.09157180f, 0.00164591f, 0.09154742f, 
    0.10871281f, 0.06764141f, -0.04409330f, 0.08550082f, 0.07947812f, 0.05507161f, 0.09609129f, 0.00333683f, 
    -0.11886422f, -0.01791340f, 0.04672810f, -0.04884532f, 0.06911400f, -0.03159915f, 0.02820811f, -0.05623884f, 
    -0.05696036f, 0.12420149f, -0.10215951f, 0.16882236f, 0.16374210f, -0.20761192f, -0.33309546f, 0.16301467f, 
    0.02764127f, 0.02790769f, -0.06721495f, 0.06856167f, 0.10666893f, 0.08144844f, -0.04644584f, -0.06854620f, 
    0.40797946f, -0.11978575f, -0.03325617f, -0.07599434f, -0.01926212f, 0.02340017f, 0.09415491f, 0.02293424f, 
    -0.07803947f, 0.06859162f, -0.04856230f, -0.00070224f, -0.29982170f, -0.13445978f, -0.06324644f, 0.03244483f, 
    0.12852614f, 0.13595894f, 0.18106554f, -0.01695266f, 0.02244928f, -0.02987495f, -0.02297385f, 0.01758299f, 
    0.04510161f, 0.08221151f, -0.02278573f, -0.06677091f, 0.02591164f, 0.06609981f, -0.03302828f, -0.01743645f, 
    -0.00071869f, 0.04461096f, 0.08039076f, 0.08871949f, -0.14266329f, 0.05988214f, -0.09607185f, 0.10001945f, 
    0.11850719f, 0.09639381f, -0.05865707f, 0.01269769f, 0.03147475f, -0.01442435f, -0.17237584f, 0.11315642f, 
    0.11183675f, 0.12439160f, -0.02862141f, -0.13741946f, 0.00256658f, -0.00065922f, -0.13128269f, 0.04336956f, 
    0.01763841f, 0.12412645f, 0.02060243f, -0.05259750f, -0.18224575f, 0.13061337f, 0.13091709f, -0.06347378f, 
    0.04859294f, 0.09338892f, -0.04739749f, -0.05321874f, -0.05886466f, 0.07682274f, -0.18235239f, 0.19591545f, 
    0.35589832f, 0.02939529f, 0.02082518f, 0.12436872f, 0.11553320f, 0.01326386f, -0.01165572f, -0.05026476f, 
    0.04584100f, 0.03856572f, 0.01878162f, 0.15044394f, 0.28761584f, 0.06798117f, -0.06805612f, -0.12298919f, 
    0.04696377f, -0.00843119f, 0.01749781f, 0.03404251f, 0.10231937f, 0.01392646f, 0.14546138f, 0.06847428f, 
    0.19142030f, -0.00542832f, -0.07999508f, -0.10201166f, 0.00998564f, 0.11527568f, -0.01727753f, -0.01181923f, 
    -0.02311069f, -0.09666971f, 0.09314720f, -0.02660273f, -0.11622661f, -0.11956125f, 0.05039177f, 0.14732386f, 
    -0.01896428f, -0.10691810f, 0.10316330f, -0.09053393f, -0.02402480f, 0.11506276f, -0.10469542f, 0.20761146f, 
    0.16111536f, 0.07186527f, 0.23116089f, -0.03715752f, 0.02775339f, -0.15508480f, -0.12694441f, -0.15300986f, 
    0.03283388f, 0.02610623f, -0.03401256f, -0.06248131f, -0.16017418f, 0.07579070f, 0.00108397f, 0.06432230f, 
    0.00972556f, -0.07120693f, -0.01960997f, 0.02770464f, -0.01790882f, -0.01154760f, 0.01005438f, -0.02521018f, 
    0.32928699f, -0.04448117f, 0.19526789f, -0.02111191f, 0.06455545f, 0.08033745f, 0.01398317f, -0.15165938f, 
    0.00714983f, 0.08389902f, 0.05632538f, 0.02477669f, 0.22211429f, 0.06010129f, 0.19790874f, 0.07588392f, 
    -0.06634547f, 0.02915499f, -0.08740058f, 0.01467155f, 0.02643819f, -0.08526295f, -0.02432074f, -0.07919154f, 
    0.02846141f, -0.00848644f, 0.05473913f, -0.04674919f, -0.02451382f, -0.05261768f, 0.00874329f, 0.03073455f, 
    -0.05311799f, 0.05260517f, 0.03494928f, -0.07402004f, -0.19392389f, -0.03454985f, 0.20189402f, -0.01475466f, 
    0.02217931f, -0.09343889f, 0.04165199f, 0.01896948f, 0.01077105f, 0.02805431f, 0.00632093f, 0.15818515f, 
    -0.03417613f, 0.18043588f, -0.01855416f, 0.00667450f, 0.03294947f, 0.00088131f, -0.11729176f, 0.03637261f, 
    0.08024131f, 0.07909726f, 0.04836681f, 0.01611254f, -0.21219620f, -0.14357036f, -0.03956168f, -0.13699265f, 
    0.03642293f, 0.00969181f, 0.08239415f, -0.06089908f, 0.00548010f, -0.05101009f, -0.01845507f, 0.06446908f, 
    0.08626363f, 0.14107548f, 0.24313627f, 0.03871918f, -0.09995186f, -0.13647689f, -0.03374830f, -0.06485111f, 
    0.00022330f, 0.07852651f, 0.01942305f, 0.02502738f, -0.06080119f, 0.18671773f, -0.05233778f, 0.06587677f, 
    -0.07092261f, 0.10169283f, -0.03678187f, 0.02325236f, 0.06870771f, 0.00197668f, 0.09374157f, -0.00413430f, 
    0.17386559f, -0.11991136f, -0.05390364f, 0.03785605f, 0.09134093f, 0.02505873f, -0.11208925f, -0.03737853f, 
    0.07250766f, 0.06658524f, 0.13178010f, -0.06849431f, 0.16838810f, 0.11164764f, -0.19817983f, 0.08806779f, 
    -0.02450497f, 0.04792367f, 0.14510262f, 0.14508021f, 0.03351610f, -0.07411427f, 0.04801784f, -0.11204588f, 
    -0.13718930f, 0.13664934f, 0.05889288f, 0.05325140f, 0.02412674f, -0.01800423f, -0.13743961f, -0.09489584f, 
    0.06127467f, -0.00456592f, -0.00935308f, 0.15539734f, -0.08459686f, -0.02489768f, -0.07263107f, -0.09349632f, 
    0.02234664f, -0.01749245f, 0.02175837f, -0.02766699f, 0.02732243f, 0.05180927f, 0.04297558f, -0.10668775f, 
    -0.13591012f, -0.03601572f, 0.02153591f, 0.11825377f, -0.01642911f, -0.05926150f, 0.04221710f, 0.13894096f, 
    0.08047873f, 0.08869582f, 0.05317426f, 0.05502705f, 0.02151517f, -0.12024600f, -0.09262365f, 0.02300732f, 
    0.06597308f, -0.02451611f, -0.06594750f, 0.07005244f, 0.04398534f, -0.08893073f, 0.06885183f, 0.01972692f, 
    -0.00148424f, -0.07820280f, 0.09146199f, 0.05738606f, -0.07415256f, 0.02218099f, -0.06006034f, 0.06844841f, 
    -0.09941675f, -0.03440999f, 0.02827750f, 0.00937824f, -0.07537227f, 0.17574419f, -0.12837085f, 0.07504777f, 
    0.10315285f, 0.05893379f, -0.11207267f, -0.02262489f, 0.02767074f, -0.04614096f, -0.06093539f, -0.00598932f, 
    -0.11095602f, 0.00979289f, -0.23621726f, -0.31945506f, 0.04272226f, -0.04794993f, -0.05095429f, -0.06457713f, 
    -0.05243147f, 0.00871839f, -0.02042725f, 0.06018069f, 0.09274703f, 0.09324554f, 0.07043846f, -0.14019613f, 
    0.02274265f, -0.00690165f, -0.03488989f, -0.13188770f, 0.10783295f, 0.06446418f, -0.05740776f, 0.03477831f, 
    -0.20173082f, 0.15488617f, -0.02494872f, 0.14592390f, 0.01025700f, -0.00629299f, -0.03519122f, -0.13067065f, 
    -0.01415866f, -0.04250780f, -0.01363481f, -0.00651088f, 0.12761515f, 0.12818879f, 0.20092878f, 0.11581358f, 
    0.02927814f, -0.03830877f, 0.01528989f, -0.12680414f, -0.12017070f, 0.01663452f, -0.03336497f, 0.09654793f, 
    0.12860517f, 0.11201575f, -0.03379202f, -0.01189087f, -0.05312981f, 0.03401532f, 0.02405074f, -0.05323629f, 
    0.03654901f, 0.00388327f, 0.01839648f, 0.08935554f, 0.10696396f, -0.09370640f, 0.16636574f, 0.12072731f, 
    -0.06357861f, -0.01920671f, -0.03491662f, 0.14467040f, 0.01952969f, 0.11045037f, 0.12871431f, -0.00906765f, 
    -0.22377934f, -0.04689240f, -0.12224191f, -0.08929002f, 0.09902318f, 0.01349548f, 0.03482030f, -0.07217480f, 
    0.03207859f, -0.02786192f, -0.07538136f, 0.00544380f, -0.20399810f, 0.11904726f, 0.00360165f, -0.11562622f, 
    -0.04431736f, -0.12900853f, -0.03107684f, 0.02362796f, 0.05858597f, 0.08236777f, -0.04678245f, 0.03672870f, 
    -0.10742371f, 0.11051522f, -0.02643280f, 0.08816048f, 0.05641815f, -0.06700478f, -0.03046765f, -0.16491522f, 
    0.09517877f, 0.04358931f, -0.03324670f, 0.08447491f, -0.15565822f, -0.30631465f, -0.00058494f, -0.07690344f, 
    0.06018322f, -0.00628887f, 0.03913976f, -0.02854454f, -0.04423480f, -0.05413277f, 0.06042109f, 0.11105702f, 
    -0.14578533f, -0.11256982f, -0.07250851f, 0.23063877f, -0.03697787f, -0.06965449f, -0.01060225f, 0.05012171f, 
    0.02773198f, -0.00941264f, 0.02205225f, 0.01485243f, 0.10225683f, -0.00696448f, 0.07218313f, -0.06038371f, 
    0.03163058f, -0.09156305f, 0.06390700f, 0.06541760f, 0.01339893f, 0.11008498f, -0.05585909f, -0.08057849f, 
    0.13786183f, 0.16729811f, 0.08218260f, 0.02268923f, 0.01785672f, 0.12839796f, -0.02713764f, 0.11749616f, 
    -0.00427541f, 0.05112607f, -0.02343813f, -0.05161528f, 0.21896820f, 0.19247003f, -0.04940354f, 0.03511716f, 
    -0.01670417f, 0.00780380f, -0.14655378f, -0.10149498f, 0.05258994f, 0.07067193f, -0.03410152f, -0.08453649f, 
    0.10696319f, -0.13568951f, -0.03635986f, -0.00059863f, -0.05250638f, -0.02728318f, -0.11476531f, -0.02054145f, 
    0.01182481f, -0.05901194f, 0.05741474f, -0.00693364f, 0.34991935f, -0.04631063f, 0.11381090f, 0.02833000f, 
    -0.00647892f, -0.03032262f, 0.05062007f, 0.08590563f, -0.09024077f, -0.01751002f, 0.09999906f, -0.08757783f, 
    -0.12449362f, 0.01642323f, -0.01484361f, 0.00583160f, 0.08205134f, 0.03623190f, -0.02696536f, 0.01203306f, 
    -0.05156431f, 0.02997553f, -0.00185352f, -0.13078067f, 0.38438219f, -0.01521021f, 0.13395287f, 0.07733215f, 
    0.02960591f, 0.03855600f, -0.03884559f, 0.00679557f, -0.11481556f, -0.04741202f, -0.02785142f, 0.08163643f, 
    0.00779923f, -0.11570675f, 0.08115126f, -0.00343728f, -0.07204331f, -0.00068321f, 0.06068560f, 0.10617677f, 
    0.00288112f, 0.02209478f, 0.00765468f, -0.03875738f, -0.03546844f, 0.08687086f, -0.30709237f, -0.23709269f, 
    0.07297196f, -0.05349268f, 0.02860421f, -0.06705285f, -0.03691183f, 0.01673356f, -0.09062718f, -0.04900463f, 
    0.01616343f, 0.06591827f, 0.12937358f, 0.16938445f, 0.00888280f, 0.06547303f, 0.06952475f, 0.05433157f, 
    0.10387859f, -0.11548854f, 0.11769379f, 0.01831684f, -0.00674383f, -0.04150904f, -0.21647730f, -0.13889471f, 
    0.05358528f, 0.06944784f, 0.06122293f, -0.02962984f, 0.05350893f, -0.06591725f, 0.10808793f, -0.11563311f, 
    0.04569670f, -0.04891303f, 0.16335313f, 0.05463215f, 0.02615679f, -0.01489752f, -0.03554378f, -0.02031247f, 
    -0.04915806f, -0.00804702f, 0.07546411f, 0.11472689f, 0.01628163f, -0.12113701f, -0.25056764f, 0.12869166f, 
    0.03424308f, 0.02278659f, 0.03353078f, 0.12063856f, -0.04435300f, 0.04584686f, 0.14345813f, 0.00016285f, 
    0.07474197f, 0.17771232f, -0.00953056f, 0.19972430f, -0.02839151f, -0.01302017f, 0.07773178f, 0.05437242f, 
    -0.09669654f, -0.06108179f, 0.03080887f, -0.06624733f, 0.13279192f, -0.03971534f, 0.09544406f, 0.07435340f, 
    -0.13372028f, 0.02257084f, 0.11350188f, 0.01198999f, -0.07016324f, 0.03475049f, -0.03891263f, 0.04676897f, 
    -0.10132327f, 0.18327458f, 0.08913089f, 0.25315058f, 0.01574800f, -0.00674988f, 0.00039075f, -0.03122606f, 
    0.18589452f, 0.08154416f, 0.05369134f, -0.08105101f, 0.09606651f, 0.04774325f, -0.01108565f, 0.00649503f, 
    0.02236622f, -0.06211454f, 0.07531433f, 0.16762766f, 0.01825770f, 0.05460352f, -0.00495052f, -0.03488023f, 
    -0.06889844f, 0.19250610f, 0.07555562f, 0.05552528f, 0.00880319f, 0.03716464f, 0.04134198f, -0.02562369f, 
    0.02757500f, -0.03528017f, 0.07473972f, 0.02589054f, 0.01124260f, -0.05137138f, -0.15712559f, -0.21288554f, 
    0.16445351f, 0.06693808f, -0.04919407f, -0.05957542f, 0.00477988f, -0.11154776f, -0.05444854f, 0.01538999f, 
    -0.02719785f, 0.15525374f, 0.11431525f, -0.01766249f, 0.05086708f, 0.07882064f, -0.07856664f, 0.04508989f, 
    0.06263571f, -0.03624582f, 0.02804501f, -0.00768626f, 0.16752398f, -0.00893323f, -0.19232377f, -0.14162016f, 
    0.15731795f, -0.08319680f, -0.00069530f, -0.04663493f, -0.10337590f, 0.04539719f, 0.04425058f, -0.00664104f, 
    0.27703625f, 0.04856302f, 0.09194493f, 0.04414078f, 0.07124168f, 0.01230193f, 0.08408654f, 0.10255623f, 
    0.07900453f, -0.02701438f, 0.02164000f, 0.08453596f, 0.03421821f, -0.03747484f, -0.03408144f, -0.05860963f, 
    -0.04093163f, 0.03890494f, -0.00716777f, 0.00444177f, 0.05312372f, 0.06751680f, -0.04536472f, -0.04422601f, 
    -0.07834093f, 0.12973419f, 0.12539828f, 0.05159310f, -0.06442215f, -0.12594216f, 0.00707474f, -0.07119799f, 
    0.06993612f, -0.00524218f, 0.04298736f, 0.08039613f, -0.00438801f, 0.04561800f, 0.02352760f, 0.23777901f, 
    -0.08425604f, 0.07255368f, 0.08454125f, -0.02484079f, -0.02116562f, 0.12431728f, 0.02156626f, -0.10835272f, 
    0.44454512f, 0.11450192f, -0.06877884f, -0.01537801f, -0.02264906f, 0.01014433f, -0.03792112f, 0.03437287f, 
    0.07453952f, -0.01388693f, -0.06599849f, 0.03062571f, 0.18461086f, 0.12015955f, 0.03898860f, 0.00017432f, 
    0.00796301f, -0.01813098f, 0.04628289f, -0.05879380f, 0.07965133f, 0.16402262f, -0.09287901f, 0.03073049f, 
    0.17141671f, 0.18709400f, -0.01813581f, -0.09193583f, 0.06461652f, 0.14493687f, 0.03181643f, 0.03969557f, 
    -0.00370058f, 0.10962182f, -0.06858030f, 0.06165696f, -0.13374375f, 0.10271756f, 0.10641802f, 0.12074786f, 
    -0.02776495f, -0.14211930f, 0.06364357f, -0.02035564f, -0.03462506f, -0.07020716f, -0.08735215f, 0.02207290f, 
    -0.06659678f, 0.08197034f, -0.02569548f, -0.12676385f, -0.02385064f, -0.04060154f, 0.13849932f, 0.10152948f, 
    -0.09702946f, 0.07696080f, 0.03483487f, 0.04951525f, -0.06581938f, 0.09556537f, 0.01418378f, 0.09021422f, 
    -0.04870255f, -0.03290334f, 0.08612693f, 0.08020906f, 0.08599884f, 0.03649786f, 0.06645480f, -0.02845451f, 
    0.28861687f, -0.23602855f, -0.15412389f, -0.00519051f, 0.17703035f, -0.00402556f, -0.09168127f, -0.03165177f, 
    -0.08817532f, -0.07746792f, -0.03418009f, -0.06196738f, 0.26012325f, 0.06622037f, -0.15076460f, -0.06796428f, 
    0.08745603f, -0.02716838f, 0.09812811f, -0.01960679f, -0.09192122f, -0.01731102f, 0.02804419f, 0.03386898f, 
    0.12993202f, 0.06245675f, -0.17259726f, -0.11053064f, -0.01069447f, -0.02392037f, 0.03103929f, 0.00748839f, 
    -0.01021812f, 0.21047382f, 0.01653477f, 0.03700785f, -0.05003020f, -0.01546074f, -0.19447117f, -0.03206838f, 
    -0.15243503f, 0.03764657f, -0.10935950f, 0.11463813f, 0.05019668f, 0.06021802f, -0.07838171f, -0.00161167f, 
    -0.29272234f, -0.16939555f, 0.02946065f, -0.11712924f, 0.05552789f, -0.09363665f, 0.01772473f, -0.04186583f, 
    -0.05109430f, -0.04992396f, 0.05663492f, -0.00767860f, -0.16099150f, 0.22801651f, -0.10059035f, -0.01577583f, 
    0.05567458f, 0.10444751f, -0.04269933f, 0.02107363f, 0.04711988f, -0.01737268f, -0.01564676f, 0.01291823f, 
    0.12004141f, 0.01109904f, -0.10552628f, 0.03237999f, 0.20712298f, -0.00211959f, 0.06214610f, 0.01042916f, 
    0.05844215f, 0.01735153f, -0.06139440f, 0.02318290f, -0.14613934f, -0.00099057f, -0.13612469f, -0.04391839f, 
    0.08565725f, 0.05374982f, -0.00834172f, -0.05168742f, -0.05077413f, 0.18953642f, 0.09906968f, -0.11783785f, 
    0.17053865f, -0.24579822f, 0.08833797f, 0.20212983f, -0.01139952f, 0.18534158f, -0.04903919f, 0.09162135f, 
    -0.03478762f, -0.03204584f, 0.05854865f, -0.08912537f, -0.28690818f, 0.06633705f, -0.02249512f, -0.01309686f, 
    0.13828255f, 0.11841663f, -0.01579793f, 0.06824999f, 0.02938779f, -0.01666418f, 0.08721697f, 0.06200475f, 
    -0.05092404f, 0.26151386f, -0.06232313f, 0.18811832f, 0.09306438f, -0.05274871f, -0.02196621f, -0.02337235f, 
    0.02917042f, 0.01918628f, 0.02923502f, 0.01994299f, 0.08896615f, 0.05888066f, 0.14902243f, 0.17583260f, 
    0.03454826f, 0.00774781f, 0.02435454f, 0.09893662f, -0.04472838f, -0.06384886f, -0.03099723f, -0.13431604f, 
    0.05225929f, 0.13595852f, -0.20785160f, 0.06778207f, -0.03377742f, 0.06848169f, 0.00599384f, -0.01968724f, 
    -0.03667236f, -0.04528071f, 0.18121797f, -0.07377060f, -0.12381048f, 0.33427128f, -0.03720018f, 0.01570603f, 
    0.19276330f, 0.11595901f, -0.09595036f, 0.02019751f, 0.07440052f, 0.07503194f, 0.02674117f, 0.06868797f, 
    0.25235331f, -0.10556757f, 0.16759770f, 0.06801283f, 0.02785077f, 0.00009418f, 0.00462062f, 0.14415838f, 
    0.03385274f, -0.08981755f, -0.01401310f, 0.12865734f, 0.04733375f, 0.01926075f, -0.21553154f, -0.05286820f, 
    0.00541613f, -0.00568336f, -0.07822537f, -0.09585899f, -0.09486604f, 0.02044378f, 0.13743134f, 0.03410055f, 
    -0.19508402f, 0.01419611f, 0.02404193f, -0.19079329f, 0.02830217f, -0.09572586f, -0.05800850f, 0.07731148f, 
    -0.01211638f, 0.00195317f, 0.08215589f, 0.01797231f, -0.02409990f, -0.04049799f, -0.00521945f, -0.04077746f, 
    0.08574574f, 0.11370198f, 0.01073152f, -0.04782082f, 0.08789767f, -0.06336062f, -0.00459719f, 0.06930991f, 
    -0.03883277f, 0.11798763f, 0.10770925f, 0.14037497f, 0.02230129f, 0.01054731f, 0.03822045f, 0.02748231f, 
    0.09588464f, 0.08187243f, 0.07990240f, 0.03828820f, -0.04606624f, 0.07808113f, 0.05860623f, 0.09393020f, 
    -0.02075932f, -0.02802282f, -0.03718380f, 0.04896595f, -0.02586932f, -0.01435761f, 0.01777819f, -0.04671055f, 
    -0.03901131f, 0.10518698f, 0.18875894f, 0.10169701f, 0.02867560f, 0.09573753f, 0.03047719f, -0.11907874f, 
    0.07081612f, 0.13995603f, -0.05752192f, 0.13995172f, -0.04808106f, 0.01962728f, 0.02768948f, 0.12591486f, 
    0.05713063f, -0.07607195f, 0.10015123f, -0.06523361f, 0.01855712f, 0.05843513f, 0.02291952f, -0.02294230f, 
    -0.00347214f, -0.08225570f, -0.07909990f, 0.09202816f, 0.02357123f, -0.01184512f, 0.03885342f, 0.10827097f, 
    0.03134208f, -0.03541486f, 0.03644003f, -0.05611303f, -0.01783365f, -0.11611051f, -0.16365004f, 0.13967152f, 
    -0.01901869f, -0.12700960f, -0.07322369f, -0.01162826f, 0.05706926f, -0.04606855f, -0.15263575f, -0.15927973f, 
    0.28175917f, 0.06278814f, -0.13553992f, -0.16248634f, -0.05869459f, -0.01317402f, -0.02552681f, 0.10743657f, 
    0.08902898f, 0.02379050f, 0.04500560f, 0.06826928f, 0.09698402f, 0.10370248f, -0.06383578f, -0.03575017f, 
    -0.00759181f, -0.11626527f, -0.03777971f, 0.13677327f, 0.09058498f, 0.01241933f, 0.19770412f, 0.14749902f, 
    0.08925990f, -0.09818240f, 0.21380384f, 0.02890313f, 0.11533237f, 0.05078808f, -0.02461099f, 0.07224528f, 
    -0.02066651f, -0.05683951f, 0.07571957f, 0.19365722f, -0.16511765f, 0.04566399f, 0.12356410f, 0.03379380f, 
    -0.02232446f, 0.15562160f, 0.15240203f, 0.02188358f, 0.05108233f, 0.09847607f, 0.03770345f, -0.06089235f, 
    0.17752719f, 0.18024933f, 0.16181059f, 0.04050332f, 0.11105672f, 0.06945512f, -0.13117704f, -0.05105036f, 
    -0.02246220f, 0.07699627f, 0.09611794f, 0.10310638f, -0.07353323f, -0.02778842f, 0.02504691f, 0.07281377f, 
    0.06836251f, 0.06373194f, -0.08120182f, 0.06968794f, -0.09868106f, -0.04805059f, 0.04311615f, 0.07542323f, 
    -0.24184193f, -0.10387912f, -0.01097081f, 0.02905634f, 0.10940772f, 0.02606575f, 0.08342960f, 0.13737780f, 
    -0.04184198f, -0.04128116f, 0.05102855f, -0.16583616f, 0.08282255f, 0.13960175f, 0.02703604f, 0.05269432f, 
    0.06096236f, 0.12813987f, -0.10743093f, -0.11168712f, 0.04980379f, 0.06058095f, 0.13699327f, -0.10893143f, 
    -0.18849720f, -0.03614657f, -0.03883851f, -0.11382076f, 0.03798516f, 0.00923175f, 0.03553225f, 0.10280042f, 
    0.08237976f, 0.05768229f, 0.16387406f, 0.17935552f, -0.06134807f, -0.00498316f, 0.04779467f, -0.03140448f, 
    -0.01864848f, 0.04050105f, 0.08767316f, 0.02727815f, 0.01337951f, 0.16297798f, -0.03863580f, 0.07765910f, 
    0.16450395f, -0.02115948f, -0.08334537f, 0.05187551f, 0.14254731f, -0.02219298f, 0.03175617f, -0.10328545f, 
    -0.06378126f, -0.18599369f, 0.12100481f, 0.02021812f, -0.02725863f, -0.16604820f, 0.10987839f, 0.06298988f, 
    0.04109256f, 0.12742050f, 0.15031129f, 0.08963569f, 0.06478184f, 0.05692911f, 0.10842451f, 0.14622796f, 
    0.31505236f, 0.02952692f, -0.21947224f, -0.01626808f, -0.06029317f, 0.02844351f, 0.03872953f, -0.03833292f, 
    -0.02891238f, 0.04803784f, 0.02855857f, 0.14869365f, 0.11991605f, 0.17297421f, 0.12353243f, 0.06863078f, 
    0.09116337f, -0.07323936f, -0.01038825f, 0.08878970f, 0.02889382f, 0.11843716f, -0.08598678f, 0.03847983f, 
    0.11095542f, 0.16680025f, 0.04868241f, -0.00449410f, 0.11188500f, -0.10763939f, -0.03644632f, -0.08825090f, 
    0.08628481f, 0.05113814f, -0.15211006f, 0.13760728f, -0.13689049f, 0.02577875f, -0.08566283f, -0.00822235f, 
    0.11352655f, -0.06865884f, 0.16933785f, 0.05407446f, 0.17085244f, 0.09027558f, 0.13760106f, 0.08774251f, 
    0.06332734f, 0.02565536f, 0.15497044f, -0.00745522f, 0.01495976f, -0.02980080f, 0.07404722f, -0.09927740f, 
    -0.06507647f, -0.05967653f, -0.08713656f, -0.06178705f, 0.07384522f, -0.05522683f, -0.01260801f, -0.04214836f, 
    -0.06337761f, 0.04135601f, 0.03790238f, 0.01065409f, -0.02512868f, 0.06632829f, 0.18469405f, 0.11040325f, 
    -0.19689190f, 0.02807427f, 0.02495793f, -0.05163450f, -0.00829423f, -0.08210092f, 0.06240379f, 0.12379366f, 
    0.11717936f, 0.13091721f, 0.04989061f, 0.05091131f, -0.13862258f, -0.06116579f, -0.01972249f, 0.10200653f, 
    -0.01979453f, 0.03903120f, -0.02702388f, -0.07473746f, -0.13618433f, -0.01027866f, -0.01613884f, 0.28113654f, 
    0.16269559f, 0.04763171f, -0.06804900f, -0.05074023f, 0.06637373f, 0.00830004f, -0.11448008f, 0.05277320f, 
    0.11522725f, -0.14244446f, -0.01872713f, -0.16243814f, 0.01876596f, 0.11476331f, -0.02429122f, -0.09252019f, 
    0.04475757f, 0.04326075f, -0.05737901f, 0.02099006f, 0.06855908f, -0.11450186f, 0.19701783f, 0.19133067f, 
    0.31489769f, 0.19400086f, 0.06145288f, -0.09922490f, 0.08201563f, 0.08435613f, -0.06974872f, 0.02455450f, 
    0.11015958f, 0.03876797f, -0.08977775f, 0.00820844f, 0.01047789f, 0.02177551f, -0.11508971f, 0.08618152f, 
    -0.06064032f, -0.04217853f, 0.03199514f, 0.20098878f, 0.04390347f, 0.16488594f, 0.02939730f, 0.02785945f, 
    0.02263829f, 0.00068600f, 0.04820772f, -0.04128763f, -0.03650372f, -0.00747132f, 0.09246551f, 0.02354074f, 
    0.16024150f, -0.08275826f, -0.05406490f, -0.06794865f, 0.25552526f, 0.29324394f, -0.01446332f, -0.12149750f, 
    -0.00334223f, -0.03122464f, -0.06755388f, -0.19936901f, -0.03940561f, -0.10608996f, -0.11428946f, 0.10143574f, 
    0.32109490f, -0.00497442f, -0.16901632f, -0.15571143f, -0.00462161f, 0.08841777f, 0.03407173f, 0.04886179f, 
    0.15196554f, 0.03166043f, -0.09340353f, 0.03438580f, -0.15602306f, -0.04799078f, 0.01098194f, 0.09225535f, 
    0.05088904f, 0.05173963f, -0.03592770f, -0.03559622f, -0.04458049f, 0.05356459f, -0.03018229f, 0.07605930f, 
    0.09026072f, 0.22763264f, 0.10535281f, -0.05789852f, 0.09543415f, -0.08583525f, 0.11468947f, -0.03353403f, 
    -0.04511043f, -0.01038361f, -0.09191294f, 0.26942998f, -0.18623167f, 0.15777794f, -0.01225950f, 0.29966205f, 
    0.00384378f, -0.02432550f, 0.07068439f, 0.04769805f, 0.09176125f, 0.03108460f, 0.11817323f, -0.03923124f, 
    -0.20070787f, 0.14278500f, -0.01671224f, -0.18276711f, -0.05388209f, 0.02695554f, 0.02862676f, -0.05060392f, 
    0.10235167f, 0.10054953f, 0.12628965f, 0.14924613f, -0.04392901f, -0.09132726f, -0.13325779f, -0.00852732f, 
    0.08135308f, 0.00623219f, -0.04065149f, 0.15509692f, 0.07302222f, 0.19133249f, 0.03837504f, 0.17989723f, 
    -0.07492533f, -0.05775525f, 0.02731621f, -0.05493216f, 0.05966182f, -0.04872047f, 0.02702603f, -0.05443459f, 
    -0.05952238f, 0.08855171f, 0.02848014f, 0.12429538f, 0.31650868f, 0.02993743f, -0.08040185f, -0.05025310f, 
    0.01292099f, 0.05149312f, -0.13332708f, 0.14123160f, 0.07629272f, 0.05008543f, 0.04311209f, -0.03442767f, 
    -0.02194277f, -0.00011539f, -0.01717696f, 0.02889838f, -0.01096594f, -0.03401772f, 0.08830917f, 0.07670078f, 
    0.00057969f, 0.08064743f, -0.01013533f, 0.10213058f, 0.09650277f, -0.08389661f, 0.00036175f, 0.09308245f, 
    0.01700878f, 0.04435421f, 0.08416392f, 0.08631033f, -0.06539553f, -0.07014642f, 0.00677324f, -0.05674528f, 
    0.13588333f, 0.00782094f, -0.00696651f, -0.03006146f, -0.06277037f, -0.01306804f, -0.02354278f, 0.05244826f, 
    -0.09380157f, 0.05107621f, 0.00601507f, 0.08896483f, -0.02293438f, -0.03725789f, -0.08852796f, 0.13602263f, 
    -0.03147107f, 0.11913464f, -0.05281143f, 0.09190434f, 0.08851329f, 0.05661967f, -0.09470471f, 0.14082639f, 
    0.34382930f, 0.01557860f, -0.05333202f, -0.14455941f, 0.09674637f, -0.01590956f, -0.01540105f, -0.03337567f, 
    0.03445755f, 0.02006564f, -0.08210355f, -0.05229853f, 0.09032598f, 0.03218128f, 0.14051473f, -0.08848065f, 
    0.03518582f, 0.07518938f, -0.09147707f, -0.02672992f, 0.03343823f, 0.05456353f, -0.16316789f, 0.17544125f, 
    -0.01094772f, 0.05804164f, 0.01467775f, 0.07640342f, 0.08485503f, 0.05278469f, 0.00954274f, -0.06103726f, 
    -0.00709390f, -0.03498233f, -0.01206320f, 0.06825933f, 0.21036948f, -0.00247913f, -0.09504654f, -0.08966586f, 
    0.01985142f, 0.00941052f, 0.04819469f, 0.07661097f, 0.03689478f, 0.05925046f, 0.14249022f, 0.12672049f, 
    0.24057335f, -0.06147486f, -0.09894385f, 0.04501493f, -0.02549943f, 0.01867205f, -0.00555619f, 0.01618121f, 
    -0.06645774f, -0.15131477f, 0.02558654f, -0.12069687f, -0.19757897f, -0.13754506f, 0.08101334f, 0.04592129f, 
    0.14142957f, -0.06084286f, 0.15280776f, -0.05767994f, 0.06928252f, 0.14520022f, -0.01096886f, 0.20879525f, 
    0.08846842f, 0.16570550f, 0.10147706f, 0.13689061f, -0.04994354f, -0.03394606f, -0.10139953f, -0.11400578f, 
    0.09752645f, 0.07192968f, 0.07766201f, -0.10273398f, 0.01173868f, -0.19547048f, -0.01340772f, -0.02909959f, 
    0.03448765f, -0.02937595f, 0.05082837f, 0.03553021f, -0.01727713f, 0.08036046f, 0.02424429f, 0.09574821f, 
    0.11057881f, 0.05288503f, 0.15282144f, 0.08203759f, 0.07395664f, 0.04624027f, 0.03518407f, -0.05200472f, 
    0.02448228f, 0.15018196f, 0.15543318f, 0.08419421f, 0.22873694f, 0.16978621f, 0.15928558f, 0.09024828f, 
    0.03226503f, -0.00251632f, -0.07969452f, -0.01785324f, 0.04811089f, -0.17647292f, -0.04958738f, -0.06033561f, 
    0.04268322f, 0.02978315f, -0.02709476f, -0.18061110f, 0.12247805f, -0.12633485f, -0.03749947f, 0.02141174f, 
    0.07068864f, 0.10174148f, 0.03475310f, 0.07894904f, 0.02912525f, -0.16310649f, 0.07199251f, 0.24463835f, 
    -0.02661192f, -0.09740248f, 0.03922689f, 0.02691623f, 0.08993855f, 0.09480404f, -0.09347522f, 0.16781394f, 
    -0.05037468f, -0.10884942f, 0.06339248f, 0.01396145f, -0.00176658f, -0.02111754f, -0.02196290f, 0.15723050f, 
    0.11190219f, 0.10982126f, 0.07830874f, 0.09225415f, 0.21061443f, 0.12961066f, 0.00072258f, -0.06070400f, 
    0.07336734f, 0.03004895f, 0.14304976f, -0.09684064f, 0.04802695f, 0.01927862f, -0.05355402f, -0.00910930f, 
    0.14023638f, -0.07185868f, 0.26352689f, -0.00358966f, 0.02747598f, -0.04247792f, 0.02112307f, -0.04639084f, 
    0.03298325f, 0.05170438f, -0.10108399f, -0.08307160f, -0.00060359f, -0.07410870f, 0.05517177f, -0.05203728f, 
    -0.04983476f, 0.07145504f, 0.06943285f, 0.07464341f, 0.00926099f, 0.01562714f, 0.05691553f, 0.02321488f, 
    -0.04238244f, 0.03102401f, -0.02647956f, -0.05548592f, 0.07522971f, 0.07448424f, -0.09443589f, -0.01594963f, 
    0.10468684f, 0.16718414f, 0.19713975f, -0.06539147f, 0.11274957f, 0.03060644f, -0.11177740f, 0.09025895f, 
    -0.03090932f, 0.07224205f, 0.13758704f, 0.09762800f, 0.02952952f, 0.00585845f, -0.13310249f, -0.18833174f, 
    -0.25165877f, 0.09653723f, 0.05406881f, -0.00958403f, 0.06238407f, -0.01445762f, -0.02394129f, -0.00811607f, 
    0.07295695f, 0.00658216f, -0.02173854f, 0.13031858f, 0.00685317f, 0.18503703f, 0.10335005f, 0.08742768f, 
    0.06679443f, 0.04498114f, -0.01655832f, 0.04384644f, 0.04394704f, 0.10048456f, -0.10631634f, -0.25914168f, 
    -0.12689815f, -0.01641388f, -0.01559813f, -0.09670176f, 0.05745849f, -0.07393501f, 0.07250067f, 0.02226219f, 
    -0.02384275f, 0.13867001f, 0.16254793f, 0.00826183f, 0.16962695f, 0.03596989f, -0.02547656f, -0.00600966f, 
    0.00090304f, 0.04086246f, 0.10801830f, 0.20631865f, 0.14524166f, -0.11336878f, 0.15970649f, 0.06426463f, 
    -0.03571184f, -0.04118470f, 0.00758303f, -0.03904280f, -0.03219360f, 0.02644300f, 0.01874163f, -0.00439072f, 
    -0.00823457f, -0.04180585f, -0.01001452f, -0.02892196f, -0.00649343f, 0.01500209f, 0.01715354f, -0.00200198f, 
    0.01288504f, -0.00014659f, -0.03584393f, 0.01306393f, -0.00171931f, 0.00538942f, -0.00960691f, 0.02477097f, 
    0.02809245f, -0.00730932f, -0.01907371f, 0.00316387f, 0.01108993f, -0.00360208f, 0.02094718f, -0.03090298f, 
    0.01995473f, 0.00446553f, -0.00346233f, -0.01363491f, -0.00315671f, 0.01364224f, 0.02994310f, -0.00543536f, 
    -0.01862408f, 0.01071902f, 0.02740450f, -0.03759382f, -0.00135554f, -0.02942448f, -0.02831114f, 0.02338473f, 
    0.01072444f, -0.02856294f, -0.03817016f, 0.00169145f, 0.00542525f, -0.03303741f, -0.01281594f, -0.03079052f, 
    -0.01840480f, 0.01439912f, 0.00817456f, 0.02610839f, 0.02485207f, -0.00881100f, 0.00368346f, 0.02092627f, 
    -0.00724959f, 0.00926311f, -0.01338741f, -0.02472483f, 0.01689371f, -0.00269580f, -0.00502169f, 0.02014708f, 
    -0.03739846f, -0.01677867f, -0.01604701f, -0.02406739f, 0.02972528f, -0.02568606f, 0.02756949f, 0.01620520f, 
    0.00038399f, -0.01967489f, 0.01429152f, -0.01970421f, 0.00371817f, -0.02878395f, -0.01430293f, -0.00019658f, 
    -0.01951670f, -0.00254492f, -0.01478467f, -0.03926261f, -0.04009860f, -0.00580183f, 0.00571203f, -0.02813784f, 
    0.02428992f, -0.01922081f, -0.02958612f, -0.00104547f, 0.02323666f, -0.02164285f, -0.00321726f, -0.00228584f, 
    0.02555793f, 0.02672190f, 0.00750797f, -0.02062778f, 0.02156383f, 0.00723114f, 0.01639779f, -0.04084269f, 
    0.02152686f, 0.00304588f, -0.01468821f, -0.03606929f, -0.02238096f, -0.00454859f, -0.03857835f, -0.01140964f, 
    0.04142592f, -0.00699334f, 0.01372058f, -0.03335587f, 0.02522303f, 0.00354175f, 0.01588597f, -0.01610489f, 
    -0.00631133f, 0.01912105f, 0.00408992f, -0.00927953f, -0.00511776f, -0.04145463f, -0.03873942f, -0.02146295f, 
    -0.02421770f, 0.00867320f, 0.02195973f, -0.01955861f, -0.03616058f, -0.04154934f, -0.02547808f, -0.04141164f, 
    -0.00647666f, 0.00513522f, -0.02184563f, 0.02980155f, -0.00252324f, -0.02556278f, -0.02080170f, 0.00222002f, 
    0.02194431f, -0.03399359f, 0.02234306f, 0.02608142f, -0.03141442f, -0.01348101f, -0.03964036f, -0.02822125f, 
    -0.00392053f, 0.01850732f, -0.02688920f, -0.01471562f, -0.00997597f, 0.00154561f, 0.00900097f, -0.03559213f, 
    -0.03612617f, 0.00013673f, 0.00744196f, -0.01197503f, 0.00352710f, -0.01407501f, -0.01687787f, 0.02199110f, 
    -0.04128996f, -0.00279238f, -0.02728213f, 0.00329605f, 0.01833323f, 0.02300495f, 0.02435886f, 0.01073077f, 
    -0.03482057f, -0.01333364f, -0.04049354f, -0.03815278f, -0.01367566f, -0.02237486f, -0.03598093f, -0.03461309f, 
    -0.01867998f, -0.01763217f, 0.00425480f, 0.01485051f, -0.03901447f, 0.01085720f, 0.01076468f, -0.01511549f, 
    -0.00112446f, 0.02861213f, -0.01670921f, 0.01313268f, -0.01342254f, 0.02921429f, -0.00468261f, 0.00169995f, 
    0.02817521f, -0.04033776f, 0.01095668f, 0.00682999f, -0.02379478f, 0.00307214f, 0.01009000f, -0.02608662f, 
    -0.00947472f, -0.00133164f, 0.01135792f, -0.03003339f, -0.00110102f, 0.02228462f, -0.02851793f, -0.03628017f, 
    -0.02551766f, -0.03338331f, 0.01065402f, 0.02453110f, -0.00759095f, 0.00148038f, -0.00058374f, -0.00394819f, 
    -0.01176314f, -0.01668784f, 0.00939558f, -0.02212689f, 0.00372267f, -0.00345305f, -0.03751604f, 0.02765764f, 
    0.00316723f, 0.00279710f, -0.00706097f, 0.00254418f, -0.00668478f, 0.01640602f, -0.03616224f, -0.01265471f, 
    -0.03094172f, -0.04205135f, 0.00166159f, -0.02497371f, 0.00549054f, 0.00089687f, -0.02058894f, 0.02310242f, 
    0.00779706f, -0.02091493f, 0.01532002f, 0.00369262f, -0.02592515f, -0.01241190f, -0.03253831f, -0.01344698f, 
    -0.02620325f, -0.01124732f, 0.02239795f, -0.02039936f, 0.01788321f, -0.00035088f, 0.00575056f, 0.00347308f, 
    -0.01807401f, 0.00737213f, 0.02815995f, -0.01346661f, -0.01852000f, -0.00205608f, 0.01268850f, 0.01902588f, 
    0.00142537f, -0.04162385f, -0.00287251f, -0.01038575f, -0.02859103f, -0.00584470f, 0.00938627f, -0.01988798f, 
    -0.03831715f, -0.03440587f, 0.02379023f, -0.03295952f, 0.01399854f, -0.03910268f, -0.03964502f, -0.00676206f, 
    -0.04101199f, -0.03889368f, 0.02009950f, -0.01106036f, 0.02626777f, -0.02450773f, -0.02177880f, -0.03464204f, 
    -0.02611810f, 0.02741702f, -0.01267043f, -0.00821627f, 0.01656384f, -0.01212929f, 0.02109154f, -0.02122218f, 
    -0.02500479f, -0.00433695f, 0.02165968f, -0.02179664f, 0.01145296f, 0.00805271f, 0.00254442f, 0.02851824f, 
    -0.04161161f, 0.01835370f, -0.04030022f, -0.01002616f, 0.01398978f, -0.02274746f, -0.03081303f, -0.01665054f, 
    -0.00702043f, -0.03193237f, 0.01485580f, 0.02456982f, -0.01787185f, 0.02324024f, 0.02187408f, -0.02711805f, 
    -0.00021761f, -0.01144870f, -0.00328627f, 0.02840078f, 0.00669646f, -0.01166373f, -0.02430117f, 0.00760076f, 
    -0.02425582f, -0.00473754f, -0.00463222f, 0.01307883f, -0.03051332f, -0.02878482f, -0.03383595f, -0.01713858f, 
    -0.01300221f, -0.01643081f, -0.03616952f, 0.02444383f, 0.01475753f, -0.02819750f, -0.03813486f, -0.02924957f, 
    -0.03273392f, -0.02029755f, -0.00276729f, 0.00547865f, -0.02418677f, -0.02470638f, 0.01788964f, 0.01637106f, 
    0.02390914f, -0.02532110f, 0.02084992f, -0.02534316f, 0.02745335f, 0.00287141f, -0.03072168f, 0.01173118f, 
    0.02384935f, 0.01343620f, -0.03357979f, 0.02665765f, -0.04129429f, 0.00793106f, 0.01789800f, -0.02398657f, 
    0.02528537f, 0.01081995f, 0.01331274f, 0.01359682f, 0.02733356f, -0.01314759f, -0.01305474f, -0.01021393f, 
    0.01344243f, -0.00112140f, -0.01440524f, -0.00018781f, -0.04071513f, -0.03526680f, -0.02117142f, -0.02136895f, 
    -0.00540596f, -0.01891085f, -0.03179538f, 0.00145272f, 0.02788156f, -0.03278883f, 0.01596173f, -0.02495690f, 
    -0.02404500f, -0.02756531f, -0.03366789f, -0.01109962f, 0.00481031f, 0.00250167f, -0.00715048f, 0.00911739f, 
    -0.01120703f, -0.00250767f, -0.02906938f, -0.00132555f, 0.00732281f, 0.00241869f, 0.02842708f, -0.02225099f, 
    0.00335191f, 0.01045091f, 0.00523842f, -0.03282458f, -0.00816441f, -0.02782371f, 0.00953469f, 0.01310019f, 
    -0.03838802f, -0.01896424f, -0.02977179f, 0.02673109f, 0.02660732f, 0.01805459f, 0.01151928f, -0.02225160f, 
    0.02918273f, -0.01560347f, 0.02995948f, -0.01793095f, -0.01805632f, -0.01539937f, -0.03426635f, -0.01349381f, 
    -0.02528724f, -0.00822747f, -0.02106783f, 0.01798960f, 0.01654619f, -0.00869665f, 0.02894537f, -0.01940775f, 
    -0.01214222f, 0.00845338f, 0.00263210f, 0.00360928f, -0.03672732f, 0.01247744f, 0.00062190f, 0.02986093f, 
    0.00118674f, -0.02528792f, 0.01449738f, 0.00679131f, 0.01121631f, -0.02405977f, -0.01625930f, -0.03635789f, 
    -0.00872975f, -0.03307304f, -0.01157534f, 0.02575409f, 0.00681503f, -0.02673157f, -0.00215741f, 0.02108514f, 
    -0.03305623f, 0.01526706f, 0.00480939f, -0.02920411f, -0.00109792f, -0.00402909f, 0.02796576f, -0.00947234f, 
    -0.03148688f, 0.00011416f, 0.00379549f, -0.01594960f, -0.00295919f, 0.01355790f, 0.02815097f, -0.04046480f, 
    -0.02950717f, -0.02543792f, 0.01946948f, 0.01692982f, -0.03821691f, -0.01179636f, -0.01548290f, 0.00784955f, 
    -0.02394075f, -0.01433044f, 0.02669402f, -0.01519994f, 0.00561150f, -0.01103597f, -0.03232584f, -0.01402347f, 
    -0.03054382f, 0.02635573f, -0.01068920f, 0.01962287f, -0.04190211f, -0.03485860f, -0.02042755f, -0.00436335f, 
    -0.03931124f, -0.01700306f, -0.03749178f, -0.02690154f, 0.00739068f, 0.02701691f, -0.02764672f, -0.03971149f, 
    0.01797555f, -0.02499003f, -0.00620369f, 0.00652727f, -0.02113162f, 0.02214337f, -0.02392218f, 0.00878020f, 
    0.01926525f, -0.00774701f, -0.03207703f, 0.01015471f, -0.02726164f, -0.00394807f, 0.00404684f, -0.03560512f, 
    -0.01310426f, -0.01439931f, -0.00343240f, -0.01882391f, 0.02838908f, -0.02424903f, 0.02129519f, 0.00918161f, 
    0.02557183f, -0.02655851f, -0.01336577f, 0.01301759f, -0.01106012f, -0.02956806f, -0.02512950f, 0.01714895f, 
    0.02823745f, 0.02377884f, 0.00488289f, 0.02099143f, -0.03733518f, 0.02346906f, 0.00103865f, -0.02818622f, 
    -0.02742194f, 0.00362193f, -0.04053712f, -0.01658844f, -0.02731873f, -0.02287506f, 0.01306447f, 0.00610823f, 
    -0.01352969f, 0.02436960f, -0.01197419f, 0.01228170f, 0.00034384f, -0.00674499f, 0.01735651f, -0.02785018f, 
    -0.00704565f, 0.02867981f, -0.03766573f, -0.04202237f, 0.03044705f, 0.00844779f, 0.00382065f, -0.02588451f, 
    0.01724960f, 0.00836452f, -0.01478168f, -0.03030392f, -0.03627696f, -0.02177249f, 0.02274173f, 0.02381803f, 
    -0.03852990f, -0.00978204f, 0.00306757f, -0.00269823f, 0.02801777f, 0.01839968f, -0.03615803f, -0.03150181f, 
    0.00534024f, 0.00483867f, -0.03437174f, 0.02535323f, -0.02363157f, 0.02568709f, -0.01786874f, -0.03571899f, 
    0.02623890f, -0.02623237f, 0.01643540f, 0.00495680f, -0.00813955f, -0.03240995f, -0.00380000f, -0.01906409f, 
    -0.01637650f, -0.00372051f, -0.03469037f, -0.03147822f, -0.02820075f, -0.01016749f, 0.02684297f, 0.01693259f, 
    0.02016333f, 0.01007040f, 0.00444512f, -0.02829082f, 0.00061455f, -0.00977706f, 0.00808822f, -0.01650741f, 
    -0.00125429f, -0.01178225f, 0.01552393f, -0.03647217f, 0.00908457f, 0.00518656f, 0.02843690f, 0.02438315f, 
    0.02414963f, -0.02468799f, 0.01814097f, -0.03947519f, -0.03122210f, -0.00507221f, 0.01709178f, -0.03171041f, 
    -0.01058401f, -0.02195072f, 0.00006391f, -0.00562987f, -0.02004923f, 0.02180711f, 0.00435861f, 0.01270446f, 
    -0.02290235f, -0.00722462f, 0.01652108f, 0.01195814f, -0.00217643f, -0.03259635f, 0.02193820f, -0.02567364f, 
    -0.02731599f, -0.03618034f, 0.01349286f, -0.03691259f, -0.00362103f, -0.01513828f, 0.01581717f, -0.03659456f, 
    -0.02829705f, -0.01607540f, 0.01478619f, -0.01522950f, 0.03119456f, 0.01224490f, 0.02217447f, -0.01116847f, 
    -0.00353109f, -0.04168532f, 0.00106293f, -0.00122181f, 0.02342479f, 0.01255481f, 0.00114148f, 0.02358748f, 
    -0.00223306f, 0.00213105f, -0.04049723f, 0.00786573f, -0.03007082f, -0.00479621f, 0.01690027f, -0.01207830f, 
    -0.01144761f, -0.02406128f, -0.00625416f, -0.02095500f, -0.03873935f, 0.02422743f, 0.01943811f, 0.02213398f, 
    -0.00543402f, 0.00982653f, -0.02505284f, 0.02595968f, -0.01600578f, 0.02329281f, -0.03141071f, -0.03295404f, 
    -0.04201553f, -0.01986184f, 0.00961311f, -0.00351419f, -0.04145957f, 0.01512262f, 0.02678191f, 0.00672278f, 
    0.02454817f, 0.02341830f, -0.03605425f, -0.01390419f, 0.02872039f, -0.01297492f, -0.03306771f, -0.01998194f, 
    0.02295760f, -0.03819920f, 0.02281144f, -0.02155304f, 0.01755812f, -0.00284804f, -0.00436408f, -0.04052119f, 
    0.02091174f, 0.01411122f, 0.01290387f, -0.01482158f, 0.02237645f, 0.02042403f, -0.03082971f, -0.02052411f, 
    0.01447587f, -0.03851474f, -0.00365230f, 0.00719030f, 0.02022914f, -0.01290883f, 0.02643807f, -0.00950297f, 
    -0.01490684f, 0.02538978f, -0.00070844f, 0.01813317f, -0.02586145f, -0.00190321f, 0.00239107f, 0.03720094f, 
    -0.02867808f, 0.00325518f, -0.00195054f, 0.01868324f, 0.00856623f, -0.00967131f, 0.01684975f, 0.01606978f, 
    -0.02833314f, -0.01423481f, -0.02470461f, -0.03890699f, -0.04471255f, -0.01764069f, 0.01955213f, 0.00612145f, 
    0.02670530f, 0.01249070f, -0.02362507f, -0.03656422f, 0.01801793f, -0.04091731f, -0.02747365f, -0.00863565f, 
    -0.01423419f, 0.01236711f, -0.03099604f, -0.03819202f, -0.00497808f, 0.00961288f, -0.00138209f, -0.00449409f, 
    0.00828269f, -0.02390242f, -0.03630029f, -0.00784664f, 0.01525693f, 0.01558237f, 0.03329298f, 0.00402180f, 
    -0.00422318f, 0.02277293f, -0.00120243f, 0.00048853f, -0.03002779f, 0.00463187f, -0.03611419f, 0.00781863f, 
    -0.01099989f, 0.02908718f, -0.01300692f, -0.02083789f, -0.02005310f, 0.01696928f, 0.02945427f, 0.00022213f, 
    -0.02563852f, -0.01464325f, 0.04094413f, 0.01555989f, 0.02353214f, -0.02288555f, -0.01678391f, -0.04001177f, 
    -0.01305331f, -0.00309825f, 0.01317077f, -0.04493026f, -0.04116058f, -0.01621054f, -0.03836573f, -0.00500570f, 
    0.01564929f, 0.02735322f, -0.00843991f, -0.02397349f, -0.02037099f, -0.02785918f, -0.00991656f, 0.00595895f, 
    -0.04277575f, -0.01026946f, -0.03147881f, 0.01072367f, -0.00528534f, -0.03872522f, -0.00848475f, 0.02555972f, 
    -0.01031165f, -0.00915917f, 0.02890515f, -0.03443721f, -0.00599965f, 0.02827487f, -0.03628028f, 0.02717908f, 
    -0.00677073f, -0.00606251f, -0.03122379f, 0.00664633f, 0.01101973f, 0.02954491f, 0.03135701f, 0.01815622f, 
    -0.00324937f, 0.02475105f, -0.01364814f, 0.01535418f, 0.01350228f, -0.01350098f, -0.02293402f, 0.00716753f, 
    -0.03237274f, -0.01630326f, 0.02307232f, -0.01869353f, 0.02602387f, -0.01841391f, -0.00213216f, -0.00671673f, 
    0.00413845f, -0.03575829f, -0.03272924f, -0.02862990f, 0.00050761f, -0.02904248f, -0.03448202f, 0.01067082f, 
    -0.00317707f, -0.03689872f, 0.02383314f, -0.01836313f, 0.03059024f, -0.02323825f, 0.03170884f, -0.03129561f, 
    -0.02108778f, 0.02938607f, 0.00234925f, -0.03218555f, -0.00537590f, -0.02262489f, 0.00453167f, -0.01781578f, 
    0.01877609f, -0.01684715f, -0.04725750f, -0.00397662f, -0.00417306f, -0.02213768f, 0.00205142f, -0.03354346f, 
    -0.00078199f, -0.01500273f, 0.00823148f, -0.00029052f, -0.03250914f, -0.01932433f, -0.00769448f, -0.03428017f, 
    0.02238338f, -0.02046010f, -0.03103709f, 0.00806758f, 0.02644191f, -0.03535387f, -0.00473473f, 0.00497294f, 
    -0.01890225f, 0.00908535f, 0.01943588f, -0.00965558f, -0.00907130f, 0.02124115f, -0.02490541f, -0.02969806f, 
    0.00958151f, 0.01011142f, -0.01064959f, 0.02350874f, 0.01280025f, -0.03058095f, 0.02690993f, -0.01139637f, 
    -0.02159331f, -0.01971435f, 0.00010850f, 0.02177181f, 0.02471568f, -0.01512599f, 0.00417936f, 0.02904266f, 
    0.00316400f, 0.00147088f, -0.02277965f, 0.01856011f, -0.01486075f, 0.00141589f, -0.02974906f, 0.00170260f, 
    -0.01231162f, -0.00737128f, -0.02745658f, 0.02344524f, -0.04643446f, 0.00145456f, -0.02679639f, -0.01568387f, 
    -0.01362492f, -0.02476897f, -0.00683222f, -0.02624532f, -0.00006102f, 0.01568660f, -0.00486210f, 0.00255220f, 
    0.00326772f, 0.02477778f, -0.02781739f, -0.03348709f, 0.01295305f, 0.00904667f, -0.02162268f, 0.01423480f, 
    -0.00886149f, -0.03726431f, -0.04799946f, 0.02582703f, 0.01433371f, 0.00130945f, -0.01003196f, -0.01868989f, 
    -0.02372229f, -0.04170701f, 0.00411387f, -0.01197287f, 0.00443469f, 0.00919037f, -0.01556839f, -0.00640137f, 
    -0.02363621f, 0.03413470f, -0.01953095f, 0.00046433f, 0.00836322f, 0.01104148f, 0.00190871f, -0.02346640f, 
    0.02022812f, -0.02811895f, -0.01727962f, -0.03190141f, -0.02363880f, -0.03483851f, -0.03103014f, 0.03475961f, 
    -0.02624289f, 0.02521703f, 0.00343520f, -0.01341079f, -0.00693119f, -0.00605018f, 0.00378727f, 0.02428454f, 
    -0.00624771f, -0.00802268f, -0.00697669f, -0.03393863f, -0.01638010f, 0.01368221f, 0.00428901f, -0.02772246f, 
    0.01610667f, -0.04430993f, -0.00509928f, 0.02769619f, 0.01230575f, 0.02441707f, 0.02359629f, -0.00023017f, 
    0.01823216f, -0.03388096f, -0.00940614f, -0.01513681f, -0.01979474f, 0.03293229f, -0.02854156f, -0.04806257f, 
    -0.03134986f, -0.01690483f, -0.01117013f, 0.00987925f, -0.03122126f, -0.00478232f, 0.01513963f, -0.01736983f, 
    0.01994664f, 0.01704319f, 0.00441001f, 0.01034508f, -0.01484366f, 0.00990473f, -0.02934801f, 0.01911675f, 
    -0.00339328f, 0.01051021f, -0.03954042f, 0.01516852f, 0.01733861f, -0.00747990f, -0.01957458f, 0.02510644f, 
    0.00051422f, -0.00531663f, 0.02107548f, -0.00289780f, -0.00518335f, 0.02470591f, 0.02140538f, -0.02083388f, 
    0.02300926f, 0.01263900f, 0.01506227f, -0.00313822f, -0.00481307f, 0.01948316f, 0.00454297f, 0.00172924f, 
    -0.01193111f, -0.02425604f, -0.00234927f, -0.02992972f, -0.02658430f, 0.00363014f, 0.00987230f, -0.00829372f, 
    0.02161883f, 0.02029071f, 0.02119534f, 0.01084120f, 0.02903159f, -0.02414945f, -0.00049927f, 0.01914333f, 
    -0.00396781f, -0.00649742f, 0.01331750f, 0.01059089f, -0.00390223f, -0.01589324f, 0.01288508f, 0.03749935f, 
    -0.02170750f, -0.04025163f, -0.01969774f, -0.02241736f, -0.01875251f, -0.01288404f, -0.00105067f, -0.00750765f, 
    -0.02271873f, 0.04106431f, 0.01965217f, -0.01893352f, 0.00321609f, 0.00761466f, -0.00271269f, -0.00004839f, 
    -0.03704183f, -0.02005932f, -0.03799380f, -0.00162845f, 0.03295599f, 0.01347751f, 0.00995990f, -0.03467034f, 
    -0.03163586f, 0.02446143f, -0.02701746f, 0.00407791f, -0.03258194f, -0.02806891f, -0.01031747f, -0.00985194f, 
    0.01416324f, 0.00377499f, -0.02534900f, 0.00164257f, -0.00331651f, -0.03862264f, 0.01587934f, -0.01611003f, 
    0.00564262f, 0.03441038f, -0.01638133f, 0.01060503f, 0.00039831f, 0.02498902f, 0.00664791f, -0.03492614f, 
    0.02488657f, -0.00410150f, 0.02160366f, -0.00226673f, -0.01150786f, 0.01652785f, -0.02000829f, -0.00727754f, 
    0.03137843f, 0.01008899f, 0.00589642f, 0.02044019f, 0.02027509f, -0.00084346f, -0.04372041f, 0.01610261f, 
    -0.03242698f, -0.02498762f, 0.01079801f, -0.02709496f, -0.02689043f, 0.02648176f, -0.03292111f, -0.00698698f, 
    -0.03016088f, 0.03361395f, 0.02422845f, 0.01713326f, 0.01585809f, 0.00055423f, -0.03523142f, -0.01191737f, 
    0.02129998f, -0.02901901f, -0.03703227f, -0.00249096f, -0.00083409f, -0.03165942f, 0.00759889f, -0.01060440f, 
    -0.01136419f, -0.00071084f, -0.02199667f, -0.03421993f, -0.02391456f, 0.01393933f, 0.00453908f, -0.00152940f, 
    -0.04002068f, 0.01081290f, -0.02921094f, 0.00853828f, -0.01538123f, 0.00885369f, -0.03380913f, 0.02090277f, 
    0.02825875f, 0.02510459f, 0.00042161f, -0.04168366f, -0.02141027f, -0.02455511f, 0.01477385f, 0.00322238f, 
    -0.02119204f, -0.01779750f, -0.02606313f, -0.02163021f, -0.01232092f, -0.03332286f, -0.02963396f, 0.00480897f, 
    0.02819618f, -0.01916990f, -0.03072344f, 0.01352269f, 0.03680638f, 0.01146575f, 0.02341216f, 0.01390694f, 
    -0.02117840f, 0.02525572f, -0.02640014f, 0.01739930f, -0.02341016f, -0.01194383f, 0.02071791f, -0.02768765f, 
    -0.03459752f, -0.00073602f, -0.01079873f, 0.01372445f, 0.01722102f, -0.00678886f, -0.02521072f, -0.00576926f, 
    -0.00385728f, 0.02212879f, -0.00639665f, -0.04343201f, 0.01233057f, 0.00416239f, 0.00255096f, -0.03139753f, 
    -0.02213655f, 0.02034308f, -0.01829432f, -0.01536105f, -0.00585922f, 0.02055105f, 0.01118713f, -0.01162345f, 
    0.02350383f, 0.02563638f, 0.02193383f, 0.01764201f, 0.01240546f, -0.00569296f, 0.02661175f, -0.01647268f, 
    -0.02747701f, -0.01280449f, 0.01608029f, -0.01441136f, 0.02450249f, 0.01639148f, -0.00022287f, -0.04099826f, 
    0.04166784f, 0.01470464f, -0.01765605f, 0.00652046f, 0.01752605f, 0.00027582f, -0.02759625f, -0.00071962f, 
    0.00028443f, 0.00539599f, 0.02393304f, -0.01390435f, 0.01508208f, -0.01634446f, 0.00664484f, 0.00401765f, 
    -0.02167544f, 0.00213666f, -0.00009796f, 0.00956354f, -0.01265941f, 0.00967858f, -0.01355402f, -0.01991410f, 
    0.01125318f, 0.00456465f, -0.02064953f, -0.02190359f, -0.00526916f, -0.01770267f, -0.01746055f, 0.00524600f, 
    -0.03257020f, -0.00204525f, 0.00721752f, 0.02705226f, -0.02226250f, 0.02021446f, -0.00843556f, 0.02098325f, 
    -0.00119603f, -0.02815154f, -0.00489679f, -0.01292311f, -0.02568835f, 0.00367463f, 0.02460398f, 0.02059617f, 
    -0.02161350f, 0.01378144f, 0.00647207f, 0.01515108f, 0.00042238f, -0.03924828f, -0.02871286f, 0.01293650f, 
    0.00767988f, -0.02373684f, -0.00252908f, 0.01614170f, 0.02032538f, -0.00181110f, -0.01583101f, -0.02111552f, 
    -0.00097094f, -0.03542414f, -0.02726185f, -0.02811614f, -0.00669514f, 0.02418624f, -0.00866873f, 0.03134872f, 
    -0.02194157f, -0.03318861f, -0.01150643f, -0.01662852f, 0.01069521f, -0.02614364f, 0.00283002f, 0.02371130f, 
    0.00849754f, 0.02803707f, -0.02518011f, 0.02268618f, 0.03336184f, 0.00581734f, 0.02407326f, 0.01343516f, 
    -0.02710373f, 0.00735145f, -0.03288385f, 0.03263642f, 0.02640008f, -0.03679200f, 0.01152080f, 0.00625421f, 
    0.01666343f, -0.00495910f, -0.01465133f, 0.03722537f, 0.01435176f, 0.01197538f, -0.01764579f, -0.02564948f, 
    -0.02825660f, 0.01132986f, 0.01260389f, 0.01456214f, -0.03313794f, -0.00712750f, -0.00145844f, -0.03882281f, 
    -0.01701477f, 0.01958719f, -0.02711447f, -0.04041549f, 0.01259708f, -0.00829822f, 0.02315114f, 0.00096605f, 
    0.00870583f, 0.03234183f, -0.01393403f, 0.01465200f, 0.01461934f, -0.01336513f, 0.02335291f, 0.02040891f, 
    0.01829502f, -0.02716741f, -0.00430602f, -0.02863161f, 0.01339436f, 0.00452140f, -0.01956594f, 0.00886573f, 
    0.02247084f, 0.00787779f, 0.00162643f, -0.02225748f, 0.01119344f, -0.02316302f, 0.02046730f, -0.01980836f, 
    -0.01376480f, -0.00661825f, -0.00547483f, 0.00842019f, -0.04064317f, -0.03721121f, -0.00172288f, -0.00644195f, 
    0.03916157f, 0.00922819f, 0.01385096f, 0.01802902f, 0.00171541f, 0.02092215f, 0.02226399f, -0.03063508f, 
    0.02849510f, -0.02447149f, 0.00229732f, -0.02850780f, 0.02481239f, -0.00732925f, 0.00166142f, -0.03754328f, 
    -0.00101320f, -0.03100032f, -0.02729731f, 0.00417172f, 0.01754228f, 0.02006807f, -0.03490579f, 0.01796275f, 
    -0.03173182f, 0.02736903f, -0.01033025f, -0.01150647f, 0.02407385f, 0.03674088f, 0.02340672f, -0.00969496f, 
    0.02561486f, -0.04138787f, 0.03020717f, -0.04652693f, 0.00553475f, 0.01796211f, -0.01415877f, -0.01854778f, 
    -0.00342190f, -0.00364936f, 0.01899610f, 0.01646983f, 0.02663965f, -0.01799850f, -0.03360004f, 0.00378671f, 
    -0.00115992f, -0.04363056f, -0.03087856f, -0.03236388f, 0.03372746f, 0.00132721f, 0.02482717f, -0.01433717f, 
    0.01022197f, -0.03081731f, -0.03033126f, 0.02191180f, 0.00625585f, -0.04264354f, -0.00593724f, 0.01636911f, 
    -0.01373571f, -0.00026112f, -0.01482110f, -0.02539501f, -0.00750542f, -0.02575664f, -0.03878548f, -0.03823945f, 
    -0.04198614f, 0.01267409f, 0.02227711f, -0.02799498f, -0.03756182f, 0.01800721f, 0.03146797f, -0.02452675f, 
    0.01458178f, 0.01563475f, 0.01753108f, -0.00443350f, 0.00977853f, 0.01552155f, 0.01112963f, -0.04119781f, 
    -0.00493942f, -0.00893226f, 0.02717277f, 0.02953536f, -0.02828707f, -0.03742964f, -0.01515316f, -0.00940771f, 
    0.01739260f, -0.00996803f, 0.02241725f, -0.01486440f, -0.03657519f, -0.02685972f, -0.01773541f, -0.02961295f, 
    0.01353968f, -0.00525536f, 0.00931388f, 0.01032669f, -0.02887984f, -0.00211296f, 0.01299993f, 0.02738848f, 
    0.01924806f, 0.02042878f, -0.04108746f, -0.01031362f, -0.02442635f, 0.01022691f, 0.02673079f, -0.04062837f, 
    0.02767524f, -0.02185443f, -0.01323055f, 0.02073577f, -0.00772729f, 0.01048856f, 0.00212034f, 0.02886862f, 
    0.01563950f, 0.01626714f, 0.02809930f, -0.02551936f, 0.01405479f, -0.03959659f, -0.01689723f, 0.00556594f, 
    0.01300332f, 0.02560044f, -0.03974335f, -0.02061761f, -0.03750507f, -0.01974431f, -0.04032344f, -0.01210140f, 
    0.02074764f, -0.00856521f, 0.01159195f, -0.01699098f, 0.02134283f, -0.01482576f, 0.02683394f, -0.03078364f, 
    0.00016262f, -0.02692759f, -0.00658929f, -0.02691763f, 0.02127351f, -0.00719399f, -0.02117281f, 0.00448731f, 
    0.02657523f, -0.01667612f, -0.01025879f, -0.02437291f, 0.02607274f, -0.01861059f, -0.02008349f, 0.01799991f, 
    0.02108916f, 0.00356814f, -0.04234769f, -0.01314832f, 0.01361969f, 0.02348622f, -0.01242578f, -0.04081919f, 
    0.02378082f, 0.02474659f, 0.00157036f, -0.03801500f, -0.01088875f, -0.00239008f, 0.00310207f, -0.01092753f, 
    0.01463766f, 0.00399235f, 0.00253430f, -0.02241029f, -0.02304375f, 0.02864777f, -0.03376921f, -0.03355533f, 
    0.02815635f, -0.03644298f, -0.01256246f, -0.01215494f, 0.02461492f, 0.00587065f, -0.02848528f, -0.00756988f, 
    -0.01016059f, -0.00042812f, 0.00043306f, 0.00501176f, 0.01497910f, 0.01820760f, -0.00931211f, -0.02989649f, 
    -0.02984369f, -0.00449688f, -0.01512813f, -0.00111107f, 0.00037095f, 0.02581901f, -0.01224608f, 0.01681830f, 
    0.00173834f, -0.03569669f, 0.02234779f, -0.03750897f, 0.00611125f, 0.01156071f, -0.01552937f, 0.01612944f, 
    -0.02958927f, -0.02185724f, -0.01581229f, 0.02821921f, 0.00416052f, -0.03097609f, -0.02032365f, -0.00224848f, 
    -0.03951639f, -0.03125925f, -0.03138076f, 0.00663845f, -0.00633397f, -0.03334171f, 0.02753227f, -0.02096340f, 
    0.01034059f, -0.02602772f, -0.00114450f, 0.02119667f, 0.01828560f, 0.02772802f, 0.01567659f, -0.01045719f, 
    -0.03277324f, 0.02239765f, -0.03850373f, -0.03758319f, -0.01646671f, -0.01762409f, 0.01956716f, -0.00106775f, 
    0.01181792f, -0.03215696f, -0.03281137f, -0.03484504f, 0.02150509f, -0.04107216f, -0.03701716f, -0.01788029f, 
    -0.03867011f, -0.03570769f, -0.02374404f, -0.03862820f, -0.03454445f, -0.01004398f, -0.03754902f, 0.00573424f, 
    -0.02808937f, -0.00061207f, 0.01583211f, -0.00764813f, -0.02718486f, -0.00097857f, 0.01503955f, -0.02406938f, 
    -0.02259709f, 0.02498453f, -0.01529719f, -0.03887166f, 0.02197224f, -0.04109947f, -0.00303656f, -0.00548749f, 
    -0.00868607f, -0.01377379f, 0.00616481f, 0.01918925f, 0.02937661f, -0.02396802f, 0.00116062f, -0.00406149f, 
    -0.02834692f, -0.03049596f, 0.00178034f, -0.03590933f, -0.02836031f, 0.01463652f, -0.00360669f, -0.01236029f, 
    0.00824581f, 0.01022903f, 0.02874023f, 0.02160376f, 0.01244793f, 0.01063035f, -0.02284550f, 0.00300173f, 
    -0.02637005f, 0.01281909f, -0.01016870f, 0.00860297f, -0.00122376f, -0.03679465f, 0.00181321f, 0.02481839f, 
    -0.00141407f, 0.02324970f, 0.00242789f, -0.01571161f, -0.01312417f, -0.03129190f, -0.00956903f, 0.00363849f, 
    0.00877126f, -0.01163466f, -0.03880867f, -0.00562821f, 0.00796922f, 0.01758538f, -0.00612751f, 0.02603431f, 
    0.00589447f, -0.02435163f, -0.03164792f, 0.01258521f, -0.03969713f, -0.01179465f, -0.03121269f, -0.03319747f, 
    0.02169255f, -0.02668778f, -0.01152503f, 0.02255222f, -0.01784407f, -0.01868649f, 0.02341249f, 0.01849620f, 
    -0.00267010f, -0.03686062f, 0.00583817f, 0.00165266f, 0.00868204f, -0.01259431f, -0.03026858f, -0.00079672f, 
    -0.03944749f, 0.00725262f, 0.02197864f, 0.00390856f, -0.02043634f, -0.01054864f, 0.00389218f, 0.01344398f, 
    0.00838932f, -0.02868151f, 0.02156170f, -0.00999378f, -0.00346217f, -0.04056350f, -0.01288884f, 0.00943426f, 
    0.00372291f, -0.02036568f, -0.03586479f, -0.01401816f, -0.03866253f, 0.02054824f, -0.00577228f, -0.02843963f, 
    0.02827249f, -0.03758354f, 0.02559552f, 0.02029081f, 0.01703785f, -0.00662433f, -0.03788559f, -0.00290856f, 
    0.00860787f, 0.01454342f, 0.01654940f, 0.00458453f, 0.02290553f, 0.00706425f, -0.01534779f, 0.00038800f, 
    -0.00115991f, -0.03452113f, 0.01962694f, 0.02702401f, -0.02371637f, -0.01022856f, -0.00068999f, 0.01274942f, 
    -0.01210898f, -0.02063740f, 0.00462806f, 0.00370322f, -0.02025604f, 0.01968715f, 0.02858613f, -0.01994117f, 
    -0.01334386f, -0.00284181f, -0.01373161f, -0.01047107f, -0.03413524f, -0.00593191f, 0.01113550f, 0.02642732f, 
    0.02524565f, -0.03388359f, -0.00533937f, -0.00822401f, 0.02915189f, -0.00154648f, 0.02143323f, 0.00507567f, 
    -0.04119202f, 0.00737551f, -0.00511747f, -0.00856821f, -0.01960707f, -0.01587671f, -0.00474107f, -0.02398785f, 
    0.02020821f, 0.00562734f, 0.02523655f, -0.02734790f, -0.03368400f, 0.00472558f, -0.00677158f, -0.00212260f, 
    -0.01478375f, -0.03584429f, 0.01291620f, -0.03422486f, 0.02309457f, 0.01451168f, -0.03727320f, 0.02459117f, 
    -0.01694218f, 0.00872675f, -0.03130984f, -0.01110371f, -0.00361156f, 0.02266989f, -0.02732798f, -0.01306494f, 
    0.00233144f, -0.02553699f, -0.01225406f, -0.03671172f, -0.02206960f, -0.00333257f, -0.00555839f, 0.00518176f, 
    -0.02769091f, 0.00470730f, 0.00429078f, 0.02394901f, 0.00652070f, 0.01048451f, -0.02107579f, 0.01015988f, 
    0.00835138f, 0.00039649f, 0.01453567f, -0.03893776f, -0.00670463f, 0.01695871f, 0.00104783f, -0.03763833f, 
    -0.03957725f, 0.01877280f, 0.02509265f, -0.01707198f, 0.01759326f, -0.03320190f, 0.00130972f, -0.00510192f, 
    0.02497074f, 0.00679786f, -0.01106341f, -0.02042420f, 0.00559703f, 0.00050824f, 0.01626884f, 0.01764414f, 
    0.00791890f, -0.03373687f, -0.03472720f, -0.01437910f, 0.01816691f, 0.02605333f, 0.01507140f, 0.01974748f, 
    0.00340391f, -0.03546660f, 0.00223700f, -0.02323318f, 0.01268415f, -0.02325540f, -0.00536070f, 0.01933671f, 
    -0.00249740f, -0.03933749f, -0.03779968f, 0.01543479f, -0.02329821f, -0.01304940f, -0.02158213f, 0.02871941f, 
    -0.00597680f, 0.01654472f, -0.04191602f, -0.02509331f, -0.00480762f, -0.01690897f, 0.02928436f, 0.02192250f, 
    -0.00632513f, -0.00109956f, -0.00690043f, 0.02818071f, -0.04028418f, -0.03628080f, -0.02357624f, 0.02436612f, 
    -0.02676831f, -0.01449259f, 0.00838986f, 0.02370193f, 0.00314795f, -0.02793284f, -0.01927005f, -0.02744858f, 
    -0.03773927f, 0.00076066f, -0.00687805f, 0.01100640f, -0.00398103f, -0.02010792f, -0.01270075f, 0.02155401f, 
    -0.02347768f, 0.01933698f, 0.00763754f, -0.02764713f, -0.01705019f, -0.01604586f, -0.01403371f, -0.01980015f, 
    -0.00813033f, -0.00797570f, -0.01697231f, -0.04001264f, -0.03020244f, 0.02799188f, -0.02243158f, 0.00810460f, 
    -0.02641795f, -0.03822954f, 0.00385968f, 0.00705321f, 0.02723803f, 0.02822286f, 0.00869579f, -0.02900519f, 
    -0.01214034f, -0.03287001f, -0.00575766f, 0.02215154f, -0.01554877f, -0.04085442f, -0.02595077f, -0.01304150f, 
    -0.02059380f, 0.01479060f, -0.01235704f, -0.02913123f, -0.02986717f, -0.00263753f, -0.02458870f, 0.01248772f, 
    0.01775324f, -0.01981208f, -0.04239206f, -0.03152528f, -0.00744838f, -0.04068623f, -0.02247263f, -0.01147522f, 
    0.02734283f, 0.01319067f, -0.01630893f, 0.02806086f, -0.02859456f, 0.02561048f, 0.00829686f, -0.02264154f, 
    0.02853411f, -0.02200769f, -0.00102848f, -0.02126272f, 0.00375997f, -0.00293459f, 0.00265458f, -0.00657745f, 
    -0.02750488f, -0.03594395f, -0.03104992f, -0.03323378f, 0.00635984f, -0.02595280f, -0.03569407f, 0.00241711f, 
    -0.03160530f, 0.00032749f, 0.01213273f, -0.03316633f, 0.00636145f, -0.01750738f, -0.04123571f, -0.00709602f, 
    -0.03941020f, -0.03167590f, 0.01289345f, -0.00642470f, -0.00550484f, -0.00676404f, -0.02167095f, -0.03447789f, 
    -0.04102703f, 0.00184965f, -0.00084281f, -0.01507005f, -0.01579153f, -0.03356501f, 0.00257127f, -0.00865517f, 
    -0.03536432f, -0.01994384f, -0.01932269f, 0.02101071f, 0.02163344f, -0.04073200f, -0.03558284f, 0.00407205f, 
    -0.01171781f, 0.02038893f, -0.01124961f, -0.00510183f, -0.01812904f, 0.02694292f, 0.02637754f, -0.03956973f, 
    0.02622563f, 0.02516787f, 0.02567993f, -0.00866538f, -0.02119628f, 0.00857468f, 0.00118011f, -0.00080583f, 
    -0.00888107f, 0.01707067f, -0.04042623f, 0.00624475f, -0.03600394f, 0.02995706f, -0.00655131f, 0.00203893f, 
    0.02400466f, 0.00381531f, 0.02651086f, -0.03817436f, -0.01520969f, -0.04155196f, -0.01276371f, -0.01907306f, 
    0.02738688f, 0.00128841f, -0.02830326f, -0.01953356f, -0.02535644f, 0.01331306f, 0.01979055f, -0.01325933f, 
    -0.01208457f, 0.00451245f, 0.00991354f, -0.04020532f, -0.03668485f, -0.00353190f, -0.02788114f, 0.00247451f, 
    -0.03431781f, -0.03051949f, -0.03518612f, 0.01013542f, -0.03601958f, 0.00409395f, 0.01797028f, -0.02979515f, 
    -0.03058715f, -0.01538406f, -0.00600677f, -0.01096139f, -0.00344513f, -0.03830240f, -0.00126591f, -0.02494251f, 
    -0.00888454f, 0.02111373f, -0.03271548f, 0.01796510f, -0.01794332f, 0.02141398f, 0.00602762f, -0.01706585f, 
    -0.01357179f, 0.00869759f, -0.03139791f, 0.00424244f, -0.01315385f, -0.03500515f, -0.01627392f, 0.02784773f, 
    -0.03096237f, 0.02926672f, -0.01488728f, -0.01508900f, -0.03784287f, 0.02441105f, 0.01680695f, -0.03814943f, 
    0.00593586f, 0.01599658f, -0.01335836f, 0.01529124f, -0.00430590f, 0.01030353f, -0.02095347f, -0.02156604f, 
    -0.04242054f, -0.01449513f, -0.01844069f, 0.00595770f, -0.02785828f, -0.02943339f, -0.03067361f, -0.01211043f, 
    0.00109719f, -0.03308243f, 0.02811179f, 0.00238993f, -0.00947447f, -0.02959060f, -0.01492295f, -0.03811781f, 
    -0.00762221f, 0.01953979f, 0.01544837f, 0.00352565f, -0.00450160f, -0.03223761f, -0.01211806f, 0.02334757f, 
    0.01661818f, 0.02653551f, -0.01454903f, 0.02964210f, 0.01938306f, -0.00880312f, 0.00838359f, 0.01431548f, 
    -0.01073820f, -0.03107844f, -0.00554047f, -0.03907700f, 0.01753963f, -0.02131855f, -0.00234399f, -0.01008517f, 
    -0.02803159f, 0.01530848f, 0.00377063f, -0.03784342f, -0.01729212f, -0.02882244f, 0.01708634f, -0.00424540f, 
    -0.00410631f, -0.01412899f, -0.00453024f, -0.00893593f, -0.00678283f, 0.00689083f, 0.02224994f, -0.01055377f, 
    0.02429370f, -0.04110404f, -0.00947593f, -0.01894348f, -0.02115176f, 0.01446794f, -0.02366545f, 0.02283420f, 
    0.00985470f, -0.02533877f, 0.02761970f, 0.02457507f, 0.02469578f, 0.00626384f, 0.00817147f, -0.03981990f, 
    0.01211613f, 0.01153352f, 0.02684255f, -0.02997765f, -0.03748830f, -0.02439358f, -0.02747492f, 0.00162049f, 
    -0.02710274f, 0.00787891f, 0.02157065f, 0.01991893f, 0.00628183f, -0.01906114f, -0.01993413f, -0.00849965f, 
    -0.01693595f, -0.02091936f, 0.00435371f, -0.00894783f, -0.02419594f, 0.02594391f, -0.04113278f, -0.00774561f, 
    -0.01618065f, 0.01411809f, 0.00104362f, -0.03219867f, -0.03719972f, -0.00606620f, 0.00110375f, -0.02383194f, 
    -0.00830150f, -0.00747735f, 0.01116096f, -0.00111565f, -0.03484387f, -0.02818194f, 0.00064380f, 0.00115748f, 
    0.00369809f, 0.00206320f, 0.03181333f, 0.02720539f, 0.02274397f, -0.02411963f, -0.02823589f, -0.02383133f, 
    0.01829141f, -0.00993793f, -0.00901239f, -0.02885870f, -0.03627492f, -0.03057987f, -0.01338302f, 0.00779499f, 
    0.00118544f, -0.00820698f, -0.02622750f, -0.03284621f, 0.02520662f, 0.02879204f, -0.02233579f, -0.03256707f, 
    0.01773391f, -0.03600992f, 0.00294430f, -0.00480362f, 0.02738166f, 0.03040971f, -0.01212709f, 0.01533191f, 
    -0.02199237f, 0.01903931f, 0.01465912f, 0.02542389f, -0.01974580f, 0.02400614f, -0.01961789f, -0.00715857f, 
    0.02386393f, -0.02149890f, 0.03156774f, -0.03408583f, -0.02279448f, 0.00969518f, -0.01671584f, 0.02860319f, 
    -0.03702161f, 0.03338137f, -0.03050036f, 0.02789860f, -0.02889682f, 0.01083763f, 0.02951575f, -0.01666967f, 
    -0.02582914f, 0.00798716f, 0.03214141f, 0.00715724f, -0.01028436f, 0.02010545f, -0.01025172f, -0.02302132f, 
    -0.01809075f, -0.02691204f, -0.01099102f, -0.00576221f, 0.01088852f, 0.01746367f, 0.03029093f, 0.00466638f, 
    -0.00527910f, -0.02462933f, 0.02973463f, -0.02299950f, -0.00560542f, -0.00614418f, -0.02545342f, 0.01277099f, 
    0.01611491f, -0.00661852f, -0.03588143f, 0.02967144f, -0.01780235f, 0.01155930f, 0.00504186f, 0.02895931f, 
    -0.04227368f, -0.04085280f, 0.02524302f, -0.01268663f, 0.02692531f, -0.03853513f, -0.00496685f, 0.00732069f, 
    0.00520656f, 0.03490726f, 0.00492037f, -0.02262826f, 0.00828243f, -0.01060558f, -0.03516243f, -0.03137955f, 
    -0.03728895f, 0.01788960f, -0.01549113f, 0.02251321f, 0.00141183f, -0.04249381f, 0.01000375f, -0.03032042f, 
    -0.01057480f, 0.00778182f, 0.02851705f, -0.00033781f, -0.00849626f, 0.00139768f, -0.03982983f, 0.00737971f, 
    0.00445866f, 0.03483553f, 0.01895547f, 0.02410209f, -0.00968360f, -0.03934754f, 0.02010917f, -0.02139886f, 
    -0.03260233f, -0.01381039f, -0.02611538f, 0.01468767f, -0.03388869f, -0.03458302f, 0.02380799f, 0.00765632f, 
    -0.01695585f, -0.00374328f, -0.01718193f, 0.01213285f, -0.02617389f, -0.03457232f, 0.00553072f, -0.02972273f, 
    -0.00305961f, -0.00263046f, 0.02025704f, 0.02512367f, -0.03104927f, -0.03946321f, -0.00891202f, 0.02928689f, 
    0.02753572f, 0.02613725f, -0.02734550f, -0.01725718f, -0.03002559f, 0.01188013f, 0.02681795f, -0.00351913f, 
    -0.00251148f, -0.00605731f, -0.03113587f, -0.01910236f, -0.00615285f, 0.00791097f, 0.02649158f, -0.00151658f, 
    -0.01316773f, 0.02498576f, 0.01220131f, -0.03291942f, 0.00333973f, 0.00434172f, 0.02820858f, 0.01571000f, 
    0.00223755f, -0.03192503f, 0.01236472f, -0.03290848f, 0.02768326f, 0.00866622f, 0.00428563f, -0.02864486f, 
    -0.00453947f, -0.00366120f, -0.01466073f, 0.00611955f, 0.01484525f, -0.03291787f, -0.03045449f, 0.02551951f, 
    0.01553195f, 0.00376608f, -0.02939175f, 0.01341442f, -0.00809871f, -0.04073521f, 0.02303218f, -0.01929010f, 
    -0.01344732f, 0.01427657f, 0.01927730f, 0.00058769f, 0.01239576f, 0.00521306f, -0.02846720f, 0.01213852f, 
    -0.03850030f, -0.01076094f, 0.00347809f, -0.02796669f, 0.00665342f, -0.00617447f, 0.01945752f, -0.04262564f, 
    -0.04056930f, -0.04058857f, 0.00856831f, 0.00311872f, 0.02467088f, -0.02158106f, -0.03057023f, -0.02476296f, 
    -0.02886688f, 0.01683468f, 0.02666611f, -0.00435065f, 0.02005527f, -0.01105496f, -0.00478838f, 0.02619294f, 
    0.03348352f, -0.03873720f, 0.02092039f, -0.02814512f, 0.02202617f, -0.00168544f, 0.01185505f, 0.01487989f, 
    0.00397464f, -0.00591382f, 0.00030129f, -0.03996183f, 0.00539589f, 0.01093743f, -0.00767752f, 0.01101238f, 
    0.02005599f, -0.04240342f, -0.03770681f, 0.00228328f, -0.01526223f, -0.00595945f, 0.01599350f, 0.01388440f, 
    0.03082064f, -0.02312611f, 0.01604955f, 0.03623802f, -0.02567749f, 0.00472049f, -0.00538049f, 0.01320533f, 
    -0.02979990f, -0.03765571f, -0.02769960f, 0.01680175f, -0.00312593f, -0.00458669f, 0.00633242f, -0.02532356f, 
    -0.03058743f, -0.00190619f, -0.03455643f, -0.03113228f, -0.01920042f, -0.03015138f, -0.00358186f, -0.01863474f, 
    0.00100232f, 0.02068373f, 0.02198322f, 0.01811788f, 0.01007147f, -0.01307476f, 0.00390893f, -0.01081089f, 
    0.02563657f, 0.02937656f, 0.01582779f, -0.04163327f, -0.02186206f, -0.03592820f, -0.00425606f, 0.03275375f, 
    -0.04275058f, -0.01694249f, -0.03779365f, 0.02057398f, -0.03944728f, 0.00871581f, 0.00240211f, -0.01368359f, 
    -0.02096653f, -0.01376631f, 0.02337977f, 0.02626630f, 0.00639499f, -0.03403774f, 0.01405286f, 0.00105188f, 
    0.01388878f, -0.01292556f, -0.02992673f, -0.00033462f, 0.01744105f, -0.00206752f, -0.01952098f, 0.01258234f, 
    -0.04154034f, 0.00637367f, 0.00622232f, 0.01989592f, -0.01669430f, 0.00852777f, 0.02934497f, 0.01799535f, 
    0.02349691f, 0.02262921f, 0.01583554f, -0.00289115f, 0.02693845f, 0.00828038f, 0.01290439f, -0.03160415f, 
    -0.03259970f, -0.03311551f, 0.00998790f, -0.04000191f, -0.01591553f, 0.01143543f, 0.02226241f, -0.00672585f, 
    -0.00280526f, -0.01998941f, 0.00859901f, -0.01309985f, -0.03177888f, 0.01171533f, 0.03344779f, -0.03101638f, 
    -0.03619811f, 0.02536487f, -0.01147435f, -0.01829864f, -0.00942978f, 0.00456485f, -0.03187333f, -0.02061980f, 
    0.02096199f, -0.01365234f, -0.04054628f, 0.00903696f, 0.00889925f, -0.00019344f, 0.02846259f, 0.01738099f, 
    -0.04149223f, -0.02234573f, 0.00511310f, -0.00028944f, 0.01735703f, 0.00616952f, 0.00091921f, -0.02718070f, 
    -0.01541614f, -0.02216512f, 0.00830037f, 0.02285717f, -0.03593419f, -0.01048775f, 0.01465863f, 0.00060119f, 
    0.02183632f, 0.02353779f, -0.00193106f, -0.02380792f, 0.01393651f, 0.02083648f, 0.03644668f, -0.00591493f, 
    -0.03619261f, 0.01262985f, -0.00017504f, 0.01211008f, -0.03768971f, 0.02193853f, 0.00097436f, 0.02247404f, 
    0.02757357f, -0.01664385f, 0.02232975f, -0.02340811f, -0.02441826f, -0.00019325f, 0.00021768f, -0.04648202f, 
    -0.03643447f, -0.03387299f, -0.00775130f, 0.03195244f, -0.04011153f, -0.02436331f, -0.01403839f, 0.01996288f, 
    -0.01429752f, -0.03487859f, -0.03440561f, -0.00480303f, -0.01759762f, 0.01981492f, -0.01200873f, -0.04044803f, 
    -0.00568372f, 0.00774539f, -0.01002081f, -0.02070383f, 0.02817672f, -0.00663354f, 0.01395722f, 0.02312472f, 
    0.02359600f, -0.01268123f, -0.02298226f, -0.02484712f, -0.00676883f, -0.02304853f, -0.00173822f, 0.00951143f, 
    -0.02581202f, -0.02585582f, -0.03992483f, -0.00486659f, -0.04022469f, 0.02464130f, -0.03220511f, -0.00066775f, 
    -0.01283554f, 0.01116837f, -0.01578804f, 0.02892481f, -0.00208539f, -0.00187575f, -0.00438271f, -0.01824876f, 
    -0.02693402f, 0.02070856f, 0.00442630f, -0.00505530f, -0.01903295f, 0.03366128f, -0.02516863f, -0.00012141f, 
    0.00840597f, 0.00541549f, 0.01062388f, 0.02897047f, 0.00510253f, -0.01632648f, -0.01192182f, 0.00277277f, 
    0.02292055f, 0.01955256f, -0.02221153f, 0.01934664f, -0.00617559f, -0.01729435f, -0.02790216f, 0.00659451f, 
    -0.01819113f, -0.04137168f, -0.01326614f, -0.02709240f, 0.02892693f, 0.02419653f, -0.03816655f, -0.02365747f, 
    0.01276132f, -0.00467289f, 0.00966492f, 0.01848396f, -0.01822672f, -0.02261750f, -0.01596699f, -0.02249778f, 
    0.00293810f, 0.00909121f, 0.00754070f, -0.04072490f, 0.01845149f, -0.03238804f, -0.02502087f, -0.03764582f, 
    -0.02080581f, -0.00083109f, 0.02284313f, 0.01957480f, 0.01596428f, 0.02916620f, -0.00552317f, 0.00585920f, 
    0.01509112f, -0.01897133f, -0.01368069f, -0.02928736f, -0.00997669f, -0.00223668f, 0.01350878f, -0.01723873f, 
    -0.04027050f, -0.00248500f, -0.03964095f, -0.03146548f, 0.01164122f, 0.01428893f, -0.03931877f, -0.04569014f, 
    0.02710248f, -0.03934631f, -0.00760527f, -0.03166250f, -0.04262495f, 0.01010896f, -0.00888133f, 0.02908877f, 
    -0.03808328f, 0.02997804f, -0.01593770f, -0.01591786f, -0.00452636f, -0.00947550f, -0.01559438f, 0.01297924f, 
    -0.00144584f, 0.02126174f, -0.00454508f, 0.02670790f, 0.00668396f, -0.02433711f, 0.00205181f, 0.01154787f, 
    0.00876992f, 0.00605426f, -0.00965717f, -0.01036094f, -0.02303489f, -0.03318761f, -0.02210865f, -0.01335219f, 
    0.01875062f, -0.02746838f, 0.00556430f, 0.01034195f, -0.03585585f, -0.00652067f, -0.03630718f, -0.00686419f, 
    0.00946669f, 0.03099444f, 0.01411504f, -0.02690977f, 0.01716566f, 0.01231011f, 0.00269590f, 0.03021976f, 
    -0.01469736f, 0.02352803f, 0.02025682f, 0.01516468f, 0.01408293f, 0.00664922f, 0.01781859f, -0.01346779f, 
    0.00429155f, -0.00129951f, -0.02098994f, -0.00681267f, -0.03083073f, 0.02782536f, 0.01757992f, -0.01679850f, 
    -0.03869164f, 0.00541809f, 0.03081719f, -0.00928961f, 0.00398169f, -0.03409733f, 0.02333915f, -0.01723309f, 
    -0.03917554f, -0.02488976f, 0.01235192f, 0.02264177f, -0.03017000f, -0.02715762f, -0.00793981f, -0.01504816f, 
    0.00323497f, 0.02497213f, -0.02173733f, -0.03052822f, 0.01712485f, -0.00497474f, -0.00199973f, 0.02573607f, 
    0.01249851f, -0.01878231f, -0.02142225f, -0.01060908f, -0.02028654f, 0.00607079f, 0.00132486f, 0.01321616f, 
    0.02946704f, -0.02168474f, 0.01800724f, 0.00534112f, 0.03016409f, -0.02044687f, -0.01397026f, -0.03899061f, 
    -0.01163707f, 0.01356473f, -0.02413398f, 0.00594575f, -0.03914987f, -0.01173830f, 0.02567394f, 0.00618784f, 
    0.01271244f, -0.00262361f, 0.02691698f, 0.00546751f, 0.01694890f, 0.02462556f, 0.02117055f, 0.02106683f, 
    0.00539118f, 0.01180286f, -0.01928424f, -0.03053882f, -0.00827405f, 0.00916724f, 0.02259751f, -0.02407155f, 
    0.02781857f, 0.02030303f, 0.02788387f, -0.01429597f, 0.00270978f, -0.03662994f, 0.02066165f, 0.02903885f, 
    -0.02154082f, -0.03890323f, 0.02373883f, 0.00293486f, -0.02559000f, 0.01037098f, 0.01175631f, -0.00860663f, 
    -0.00396218f, -0.00662004f, -0.01566335f, -0.03459341f, 0.00900327f, 0.02719671f, -0.01067299f, -0.02805517f, 
    -0.03162963f, -0.00449943f, -0.01660694f, 0.00944071f, 0.02708373f, 0.02552156f, -0.01185510f, -0.02246636f, 
    -0.02258040f, -0.03092135f, -0.03196716f, 0.00421007f, -0.02211595f, 0.01668854f, -0.03260555f, -0.03319783f, 
    0.02676713f, 0.02284295f, 0.02237119f, 0.00143589f, -0.00847345f, -0.03159062f, -0.01713796f, 0.00108535f, 
    -0.03864064f, -0.02487604f, 0.01796410f, 0.02762948f, -0.00191798f, 0.01828033f, -0.01676033f, 0.02649384f, 
    0.01302664f, -0.01619303f, -0.02077031f, -0.02644214f, -0.02583566f, 0.02029751f, -0.02849618f, -0.02291347f, 
    0.00803237f, -0.03857324f, 0.01593816f, -0.03692360f, -0.03111173f, -0.01402080f, -0.03958530f, -0.02309074f, 
    -0.02161160f, 0.02440314f, 0.02761171f, -0.01367268f, -0.00721703f, -0.01503233f, 0.00241102f, 0.00538422f, 
    -0.00441518f, 0.01254781f, -0.00600592f, -0.00465176f, -0.00341420f, -0.02784776f, -0.00263055f, -0.00653496f, 
    -0.00834794f, -0.02706393f, 0.02732406f, -0.01059147f, -0.00419950f, -0.01700005f, 0.01593984f, -0.01698382f, 
    -0.03395674f, -0.02955155f, -0.02626885f, 0.01227780f, -0.01564598f, -0.01445311f, -0.02235304f, 0.00614501f, 
    -0.04318643f, 0.01632138f, 0.01667379f, 0.00800967f, 0.02011689f, 0.00323425f, -0.03975612f, 0.01316261f, 
    0.01317900f, -0.01604459f, -0.01246319f, -0.01592126f, 0.01451895f, -0.01976780f, 0.01184131f, -0.02819270f, 
    -0.00800283f, -0.00696178f, -0.00752000f, 0.01253739f, -0.00869476f, -0.00346210f, -0.00519814f, 0.00077985f, 
    0.02880690f, -0.00076884f, 0.02795571f, 0.02966617f, -0.00545742f, 0.00094612f, -0.01492650f, 0.01088057f, 
    0.00169367f, 0.02396454f, -0.02535308f, -0.01668594f, -0.01664690f, -0.03356278f, -0.03032877f, -0.03847620f, 
    -0.02589035f, -0.03807695f, -0.03394506f, 0.02373540f, 0.00473790f, -0.00901538f, 0.01891441f, -0.00159632f, 
    -0.01373595f, -0.00916863f, 0.00104864f, -0.00685230f, -0.00401972f, -0.03669289f, -0.01218894f, -0.01754324f, 
    0.01531711f, -0.01394143f, 0.00309165f, 0.02495011f, 0.01758325f, -0.01781235f, -0.00413163f, -0.02856210f, 
    0.01411175f, 0.01602895f, -0.04032019f, 0.02001972f, -0.00128341f, 0.02626725f, -0.01694034f, -0.03114958f, 
    -0.03446293f, -0.02890968f, -0.02499647f, 0.01089302f, -0.01752502f, -0.02533820f, -0.04428017f, -0.00491519f, 
    -0.02591933f, -0.02412071f, -0.00179719f, -0.04026617f, 0.01122278f, -0.02412948f, -0.00123148f, -0.02851045f, 
    0.01877164f, -0.02375240f, 0.02964057f, -0.03366820f, -0.01585550f, 0.01023472f, 0.01852150f, 0.01576554f, 
    0.01114696f, -0.00384211f, -0.03932237f, -0.03922546f, 0.00965965f, -0.03338021f, -0.02434297f, 0.01867140f, 
    0.01418271f, -0.02317497f, 0.00186917f, 0.01433516f, -0.03047360f, 0.00997999f, -0.03424335f, -0.02348725f, 
    -0.02954269f, -0.02289421f, 0.02812817f, -0.00278033f, -0.03401822f, -0.02738101f, -0.01417582f, -0.03722755f, 
    -0.01128019f, -0.01406025f, -0.00305672f, -0.01131587f, -0.01172466f, -0.00868273f, -0.00119416f, -0.02303140f, 
    -0.01329132f, -0.02069250f, 0.00867550f, 0.01981851f, -0.01161748f, 0.01169314f, -0.03700985f, 0.00279217f, 
    -0.01001048f, -0.02471292f, 0.00747388f, 0.01253398f, 0.01075008f, 0.00009521f, 0.01401495f, -0.00050142f, 
    0.02748139f, -0.04299865f, -0.02096635f, -0.01710069f, 0.01764608f, 0.02473845f, -0.02352604f, -0.03595392f, 
    -0.01415939f, -0.03764573f, -0.01100259f, 0.02038831f, 0.02463496f, 0.00092980f, -0.02363175f, 0.01516549f, 
    -0.01034043f, -0.00956959f, -0.00978833f, -0.02079640f, -0.00417957f, -0.02621752f, 0.00251220f, -0.02345412f, 
    0.00836575f, 0.03586544f, -0.03445825f, 0.01335436f, -0.00742491f, 0.01076103f, 0.00570930f, -0.03908127f, 
    -0.03287694f, -0.01551984f, -0.01158995f, 0.00405658f, -0.03755346f, -0.03029746f, -0.02443583f, 0.01107982f, 
    0.00665504f, 0.00792227f, -0.01884229f, 0.01635566f, -0.02307613f, 0.00483822f, 0.00232556f, 0.00203346f, 
    -0.00184918f, -0.03738594f, -0.04077123f, -0.01298314f, -0.03218569f, 0.02968174f, -0.00235165f, 0.02028400f, 
    -0.00580874f, 0.00719460f, 0.01585883f, -0.00350659f, -0.00720028f, 0.01950000f, 0.02846005f, -0.03376918f, 
    0.02010394f, -0.03495729f, 0.01491151f, -0.02627713f, -0.03057276f, -0.01977593f, -0.02483767f, 0.01451600f, 
    -0.00655544f, 0.01747854f, 0.00967990f, 0.02631399f, -0.03772680f, -0.01550761f, 0.00499995f, -0.01230548f, 
    -0.00691732f, 0.01679401f, 0.00704998f, 0.02663426f, 0.01161672f, -0.00395819f, -0.01990044f, -0.00517074f, 
    -0.03324058f, 0.00029169f, 0.02086410f, 0.01301749f, -0.00725908f, 0.01912151f, -0.00205399f, -0.02929632f, 
    -0.01518032f, 0.01579878f, -0.02490616f, -0.03313034f, 0.00202389f, 0.03228085f, 0.00664879f, -0.03441767f, 
    0.01313932f, -0.01186489f, -0.01901539f, 0.02322933f, 0.02559983f, 0.02478769f, -0.04191982f, -0.03450758f, 
    0.00618465f, 0.02975576f, 0.02027795f, -0.03318609f, -0.01980435f, 0.00727152f, 0.00836488f, 0.02735298f, 
    -0.01249693f, 0.00232719f, -0.04086883f, 0.02002393f, -0.02804987f, 0.00923435f, -0.01722097f, 0.01475925f, 
    -0.02805018f, 0.00741876f, -0.04127413f, 0.00500051f, -0.04348707f, 0.01283345f, -0.01747383f, -0.01606029f, 
    -0.00993394f, -0.02184461f, -0.04121072f, -0.02154603f, -0.01332141f, 0.02746188f, 0.01066403f, 0.00498844f, 
    -0.03417393f, -0.01322884f, 0.00364342f, -0.01119046f, -0.02677490f, 0.00695213f, 0.03207653f, -0.03642963f, 
    -0.00093203f, -0.01177330f, -0.03885956f, -0.00636998f, -0.01372703f, 0.00231064f, -0.02493781f, 0.01584775f, 
    0.00182682f, 0.00217606f, -0.00561479f, -0.02772812f, 0.02806375f, -0.00105583f, -0.00744083f, 0.02311139f, 
    0.01260206f, -0.04204764f, 0.02361284f, -0.00280781f, -0.01391883f, -0.02256561f, -0.00415592f, -0.01265513f, 
    -0.01893476f, 0.00575753f, 0.00474175f, -0.01169303f, -0.00575992f, 0.03111445f, 0.02508129f, 0.00949414f, 
    -0.02764632f, 0.02470547f, -0.02981683f, -0.03594610f, 0.01028808f, -0.03518916f, -0.01285813f, -0.01943981f, 
    0.00405747f, 0.01237892f, -0.03533045f, 0.02844285f, -0.02964699f, 0.03441007f, -0.01092665f, -0.00850847f, 
    -0.01171875f, -0.03270151f, -0.02013995f, -0.04125169f, -0.00789236f, 0.02770184f, -0.04234730f, -0.03150078f, 
    -0.00090545f, -0.03000676f, -0.03469605f, -0.02588264f, -0.01407385f, -0.03924775f, -0.01932970f, 0.01859565f, 
    0.02488546f, 0.00907773f, -0.01054464f, 0.01943057f, 0.01459191f, -0.01906540f, -0.02132717f, -0.02827429f, 
    -0.02090070f, 0.00668246f, 0.01669435f, -0.01650583f, 0.02750752f, -0.00080379f, -0.03547731f, -0.03091023f, 
    -0.02177125f, -0.02703312f, -0.03917637f, 0.00916202f, -0.00912039f, -0.01487923f, -0.00899762f, -0.02720766f, 
    0.02377164f, -0.00600100f, 0.02627843f, 0.02844716f, -0.01754378f, -0.00439826f, 0.01324069f, -0.02674118f, 
    0.02698113f, 0.01337647f, -0.03089699f, 0.02144978f, 0.02648228f, -0.04088334f, -0.01664306f, -0.04015169f, 
    -0.03096651f, 0.01827884f, 0.01990074f, 0.01131808f, -0.01868678f, 0.00374953f, 0.02567120f, -0.01647765f, 
    -0.01915576f, 0.01542273f, -0.01208199f, 0.02858734f, -0.00776013f, -0.01620046f, 0.00995026f, -0.00728710f, 
    0.00870809f, 0.02939544f, 0.00145817f, -0.02533929f, -0.00993790f, -0.00314497f, -0.04267139f, -0.00405223f, 
    0.01872647f, 0.00620623f, 0.01893879f, -0.02192518f, 0.02262696f, -0.03448682f, -0.02752583f, 0.02553865f, 
    -0.02216120f, 0.01612875f, 0.02500983f, -0.01427901f, 0.02405437f, -0.01656711f, -0.04177646f, 0.02530000f, 
    -0.02771620f, 0.01064152f, -0.01824334f, -0.00242658f, -0.02805563f, -0.01353768f, 0.00687328f, -0.01324746f, 
    0.02631534f, -0.03521266f, 0.01605333f, -0.00906914f, -0.03433790f, -0.03311167f, -0.02516209f, -0.02346073f, 
    0.00803096f, -0.02017836f, -0.03420315f, -0.03826258f, 0.03112346f, -0.02657083f, 0.01064547f, -0.02720803f, 
    0.02706525f, -0.00631224f, 0.01427790f, -0.00687742f, 0.02707996f, -0.03728141f, 0.01611129f, -0.01945442f, 
    -0.03687678f, 0.01101227f, -0.01171409f, 0.01763592f, -0.03497488f, -0.01010134f, -0.03320302f, 0.00799407f, 
    -0.01480071f, -0.03313006f, 0.02555755f, -0.02766997f, 0.00424512f, 0.02312545f, 0.02401568f, -0.01213910f, 
    -0.03142913f, 0.02150516f, 0.00042032f, -0.03186015f, -0.00698221f, -0.02767617f, -0.02195352f, 0.00240649f, 
    -0.03562411f, -0.04038549f, -0.03085468f, -0.04377574f, -0.02614393f, 0.00103534f, 0.00740238f, -0.04329809f, 
    -0.02940964f, 0.02163155f, 0.02445611f, 0.01525095f, -0.03464581f, 0.00167184f, -0.02395818f, -0.03448668f, 
    0.00976752f, -0.00682167f, -0.00988963f, -0.00794137f, 0.02380513f, 0.00676004f, -0.02159859f, 0.01764813f, 
    -0.01492295f, 0.02759937f, -0.01461285f, -0.02512874f, 0.01916462f, 0.00264041f, 0.00894755f, 0.00172042f, 
    0.01691007f, 0.00011930f, -0.03122333f, -0.01506586f, 0.00139374f, 0.02398668f, 0.00478079f, 0.00120982f, 
    0.01187390f, -0.00037663f, 0.02688406f, 0.00531047f, 0.01323797f, -0.04096631f, -0.01243734f, -0.03651290f, 
    0.02768746f, -0.03224080f, -0.01266506f, 0.02342648f, -0.00697558f, 0.02290890f, -0.01152605f, 0.02291048f, 
    0.00735130f, 0.02730612f, 0.02741710f, 0.01815261f, -0.01793674f, -0.00436895f, -0.03665965f, -0.02394228f, 
    0.00024215f, 0.01659844f, 0.02225942f, -0.02243906f, -0.03952016f, -0.01628150f, -0.00923196f, -0.00037237f, 
    0.01235095f, -0.02713971f, -0.02181805f, 0.00807855f, -0.02789107f, -0.03291183f, -0.02173493f, -0.02740492f, 
    0.02449333f, -0.04448831f, -0.01176473f, 0.01542062f, -0.03841320f, 0.00603947f, -0.00345020f, -0.01990492f, 
    -0.04009241f, 0.02740731f, -0.03221619f, -0.01716777f, -0.00110192f, -0.02117556f, 0.00035421f, -0.04314352f, 
    0.03857574f, -0.00631189f, -0.01946067f, -0.03319758f, -0.01436423f, -0.03142989f, 0.00044180f, 0.01556094f, 
    -0.04027760f, -0.02650755f, 0.00602076f, 0.02253061f, 0.01287267f, 0.02387182f, -0.02279230f, 0.02712325f, 
    0.02318765f, -0.01788853f, -0.02439022f, 0.02309162f, 0.00968078f, 0.02577784f, -0.03099930f, 0.02541447f, 
    0.00484091f, 0.01459812f, -0.03597520f, -0.01582649f, 0.00442112f, -0.00221299f, 0.01106900f, -0.03596197f, 
    -0.04163806f, 0.01642948f, -0.00287569f, -0.00732989f, 0.00257344f, -0.02081683f, 0.00163950f, -0.00569068f, 
    0.01158285f, 0.00575954f, -0.00851719f, 0.01277595f, -0.04312002f, -0.02208496f, -0.03455582f, -0.00072537f, 
    -0.02422728f, -0.00048293f, 0.01379266f, -0.00007671f, -0.01069917f, -0.04221583f, -0.02525827f, -0.02286009f, 
    0.02538816f, -0.01323083f, 0.00549211f, 0.02618994f, 0.02676247f, 0.01718154f, 0.00079303f, -0.00051799f, 
    0.01530455f, -0.00144244f, 0.00199466f, 0.02419880f, 0.01218748f, -0.03588534f, 0.01778520f, -0.00949900f, 
    0.00166179f, 0.01940083f, -0.04178691f, 0.02517527f, -0.01424770f, -0.03406740f, 0.00291675f, 0.01052761f, 
    -0.04172169f, -0.01813437f, -0.03583116f, -0.01626752f, 0.02621077f, 0.01513201f, 0.02202561f, 0.00605371f, 
    -0.02502244f, 0.01500737f, -0.02499667f, -0.01814476f, 0.01031182f, 0.01209169f, 0.01187456f, -0.03718791f, 
    -0.00032100f, -0.03082302f, -0.03677079f, -0.03638726f, 0.02561555f, 0.01924706f, 0.03113514f, 0.00003151f, 
    -0.00375948f, 0.00538029f, 0.02713670f, -0.00869352f, -0.03924985f, 0.02539476f, -0.03063136f, -0.00366748f, 
    -0.02500837f, 0.01722048f, 0.03129359f, 0.00131310f, -0.02769222f, -0.01083781f, 0.01562515f, -0.02589315f, 
    -0.01268113f, -0.02078137f, 0.00771705f, -0.02084845f, -0.01091668f, 0.00903704f, -0.02018644f, -0.02106743f, 
    -0.03983846f, -0.01911046f, -0.02316928f, -0.00022648f, 0.01973192f, 0.00303530f, 0.00744764f, -0.02545768f, 
    -0.03089092f, -0.01145603f, 0.01561095f, -0.01579521f, -0.02305357f, -0.00257021f, -0.03302686f, -0.00118804f, 
    0.01112224f, -0.01450828f, 0.02077682f, 0.02492438f, -0.01873364f, -0.01862426f, 0.00044412f, -0.01702095f, 
    0.00298869f, -0.03818480f, -0.00513927f, -0.00679569f, 0.02815486f, -0.02393423f, 0.02513319f, -0.01992204f, 
    0.01057599f, 0.02647023f, 0.00623986f, 0.00279180f, 0.00485895f, -0.02769018f, 0.00666111f, 0.01463949f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.00605961f, 0.02202567f, -0.01031230f, 0.02671181f, 0.14393082f, -0.01644101f, 0.00902647f, 0.01007455f, 
    0.02711530f, 0.00923060f, 0.04450658f, 0.03051688f, 0.01772416f, 0.02293354f, 0.06851072f, 0.03318219f, 
    -0.00047900f, -0.02496423f, 0.04073837f, 0.00857238f, 0.05542302f, 0.01462374f, -0.02584670f, -0.03025585f, 
    0.07551604f, 0.00051665f, 0.01585852f, -0.04120638f, -0.02695541f, 0.02867466f, -0.01776657f, -0.02450133f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.10600843f, -0.03120421f, 0.07735845f, -0.10549181f, -0.12662061f, 0.10019433f, -0.11070719f, 0.02715184f, 
    -0.14272122f, -0.07716154f, -0.11723611f, -0.10185645f, -0.11905399f, 0.12621398f, 0.00894684f, -0.01082236f, 
    0.11865690f, -0.00589542f, -0.14591151f, -0.13510573f, -0.15499415f, -0.17273569f, 0.09780400f, 0.13438641f, 
    0.02850810f, -0.10750305f, 0.13161600f, 0.09462844f, -0.03798137f, -0.10200671f, 0.01769830f, -0.11188195f, 
    0.35210013f, -0.04015847f, -0.12400182f, -0.09759800f, -0.02066254f, 0.12651612f, -0.30920446f, 0.23322870f, 
    -0.05921029f, 0.04523008f, -0.19062023f, -0.00334821f, -0.16308114f, -0.08264549f, 0.11699621f, 0.42955989f, 
    0.15950885f, -0.05170958f, 0.04696772f, 0.37569577f, 0.46113157f, -0.12004359f, 0.00728084f, -0.03446004f, 
    -0.09106404f, 0.02025131f, -0.11107052f, 0.01906219f, 0.02681747f, 0.08162046f, -0.01530999f, -0.10504392f, 
    -0.27219209f, -0.09348129f, -0.13640450f, -0.13475935f, -0.24954683f, 0.09019767f, 0.42726332f, 0.28048226f, 
    0.01863616f, -0.17577885f, -0.33050185f, -0.02328284f, -0.14266834f, -0.02168683f, 0.00668527f, -0.18247971f, 
    0.02605995f, 0.32945740f, 0.01054833f, 0.16917355f, -0.05534611f, 0.06517389f, 0.11472982f, -0.13334097f, 
    0.28033102f, 0.39452553f, 0.16064699f, 0.03856413f, 0.02920770f, 0.15587497f, -0.02042663f, -0.02127321f, 
    -0.16437456f, 0.02768214f, 0.12659442f, 0.05503042f, 0.10288001f, -0.00258482f, -0.01728489f, -0.16177748f, 
    0.16124439f, -0.04566843f, -0.17335910f, -0.17710984f, 0.10124269f, 0.04258073f, 0.07815829f, -0.14459217f, 
    0.01999944f, 0.06666525f, -0.13904810f, -0.16510420f, 0.10783590f, -0.15574360f, -0.16876252f, -0.12158284f, 
    -0.18301432f, -0.08030340f, -0.00190920f, 0.00137628f, 0.13835873f, 0.15227669f, 0.02673027f, 0.14368340f, 
    0.45406890f, 0.11728787f, -0.08259786f, -0.04154726f, 0.09818552f, -0.15139057f, 0.22256272f, 0.30163303f, 
    -0.00073440f, 0.14021635f, 0.26211369f, 0.06188678f, 0.12482056f, -0.13738294f, -0.15744761f, 0.23591097f, 
    -0.06407822f, -0.24438918f, 0.54719961f, 0.31252825f, 0.41144678f, -0.15304257f, -0.13183746f, 0.02125996f, 
    -0.11368595f, 0.11825811f, -0.24868666f, -0.16852707f, 0.04295568f, -0.12860110f, -0.14744428f, 0.06168714f, 
    0.02177409f, 0.05319292f, -0.03477472f, -0.17959513f, -0.05740051f, -0.00104051f, -0.05222331f, 0.23706360f, 
    -0.13455844f, 0.05745321f, -0.07718980f, -0.36906633f, 0.11031173f, 0.06100118f, 0.03106047f, 0.12455440f, 
    -0.17457992f, 0.36035225f, 0.11644612f, -0.05769649f, 0.31761730f, 0.08545575f, 0.30843860f, -0.12226510f, 
    -0.14341652f, 0.46280026f, -0.13240512f, -0.02868218f, -0.04334076f, 0.14670934f, -0.00807089f, 0.04479636f, 
    0.54867667f, 0.09962968f, 0.02626284f, -0.04861972f, 0.03279570f, 0.03583725f, -0.02269180f, 0.28640562f, 
    0.11774801f, 0.09944076f, 0.04203220f, -0.11076143f, 0.03610099f, -0.11859242f, 0.15458913f, -0.10813063f, 
    0.04427987f, -0.36280802f, 0.53612673f, 0.12285416f, -0.11189611f, -0.12609509f, -0.10454570f, -0.01351091f, 
    0.21227382f, -0.17410225f, -0.02430525f, 0.14806817f, 0.12438018f, -0.01766586f, -0.08644889f, 0.03519451f, 
    -0.05042353f, 0.20815989f, 0.11539836f, 0.12073001f, 0.32409209f, -0.08930660f, -0.04202084f, -0.53574234f, 
    -0.14443159f, -0.10029436f, -0.38309452f, 0.03929855f, -0.14397062f, 0.00900178f, 0.20804900f, -0.05938846f, 
    -0.15394032f, 0.33373556f, -0.65576267f, 0.03772285f, -0.25996038f, -0.08657545f, -0.17328857f, 0.06525815f, 
    0.24110302f, -0.16309264f, 0.29389310f, 0.10114570f, 0.02273981f, -0.08477940f, -0.07919035f, 0.05888274f, 
    0.37096345f, 0.31927076f, -0.14156282f, 0.15748258f, -0.13599588f, -0.17073007f, -0.09348214f, -0.38434365f, 
    0.14865121f, -0.02231930f, -0.39022267f, 0.25756645f, -0.02677149f, 0.03239970f, 0.06444018f, 0.29358354f, 
    -0.02565775f, 0.50203073f, -0.44832066f, 0.33595815f, 0.00421337f, 0.14165869f, -0.13781855f, 0.03745992f, 
    0.05269321f, 0.06150305f, 0.22834635f, 0.00985149f, 0.07551605f, -0.15472266f, 0.10835417f, 0.05848968f, 
    -0.14823383f, -0.13712157f, -0.10278040f, -0.02090859f, -0.13919057f, 0.10838905f, -0.09482225f, -0.10460614f, 
    0.10399733f, 0.06549960f, -0.14984980f, -0.09605119f, 0.12210587f, 0.16637962f, -0.14721014f, -0.08789565f, 
    0.04618947f, 0.13415523f, 0.03871930f, -0.09831934f, 0.13070722f, 0.01747362f, 0.02294021f, 0.05338130f, 
    -0.10808399f, -0.03168568f, -0.02030863f, -0.11457671f, -0.12117202f, 0.07658070f, 0.01411624f, -0.15447621f, 
    -0.34805101f, -0.09529655f, -0.09262919f, 0.08820841f, -0.30553043f, 0.01581672f, 0.43230858f, 0.33462718f, 
    0.15468456f, 0.04960886f, 0.36451963f, 0.49394348f, -0.06672442f, -0.01690690f, 0.08057289f, 0.00374376f, 
    0.04448298f, -0.04540343f, -0.13197432f, 0.02676454f, -0.13009964f, -0.15896857f, 0.14993916f, 0.00116023f, 
    -0.14330691f, 0.16675942f, 0.15135123f, -0.08820409f, 0.02051926f, -0.00668152f, 0.12206244f, 0.01570344f, 
    -0.38780707f, -0.11581229f, -0.11692558f, 0.13701446f, 0.37561387f, -0.01133886f, -0.01673671f, 0.22442974f, 
    0.17124723f, -0.04444746f, 0.24575593f, 0.01562709f, 0.00259433f, 0.14779423f, 0.23397416f, -0.19096662f, 
    0.06505744f, -0.22320493f, -0.13948049f, -0.21341689f, -0.02654338f, 0.14073654f, -0.15641910f, -0.02975368f, 
    -0.00690080f, -0.08851656f, 0.27198389f, 0.14464436f, -0.06324174f, 0.16060396f, 0.03495772f, -0.12145118f, 
    0.05159843f, 0.01263098f, 0.09842718f, -0.08541737f, 0.20234112f, -0.01983266f, -0.44500393f, 0.03705179f, 
    0.05464850f, -0.09782667f, 0.23356631f, -0.10717295f, 0.13700123f, -0.15734823f, 0.25380582f, -0.03536287f, 
    -0.05699202f, -0.05269184f, -0.11444149f, 0.13798682f, 0.48974100f, 0.00774203f, 0.32735685f, 0.03475334f, 
    -0.48322976f, -0.14471073f, -0.09738654f, 0.17853913f, -0.15233269f, -0.03595155f, 0.11113060f, -0.16931412f, 
    -0.06597225f, -0.05327725f, 0.07095225f, 0.08640702f, 0.21382308f, 0.04487423f, 0.64834094f, 0.02798239f, 
    -0.16183352f, -0.09505410f, -0.14851651f, -0.21304752f, 0.17750727f, 0.08092803f, -0.21724471f, 0.34260729f, 
    0.16973330f, 0.05141382f, 0.45420060f, -0.18971251f, 0.21794620f, -0.11423250f, 0.29108053f, -0.09211684f, 
    0.30085367f, 0.30009344f, -0.12906976f, 0.16848451f, 0.10433346f, 0.01795891f, 0.11962570f, -0.11546309f, 
    -0.16351579f, -0.19010715f, -0.05828748f, -0.08487029f, 0.01222235f, -0.01738648f, 0.09502036f, -0.13720348f, 
    -0.08686499f, -0.15207915f, 0.14177127f, 0.09604133f, 0.14286774f, 0.04966160f, 0.10817199f, 0.03083821f, 
    0.05852201f, -0.07171282f, -0.20827830f, -0.09615657f, -0.18528287f, -0.05251323f, -0.17748773f, 0.13969208f, 
    0.09398872f, -0.15768811f, -0.00121282f, -0.16235751f, -0.16031711f, 0.01452537f, 0.09610281f, -0.14610539f, 
    -0.10448189f, -0.16679478f, -0.07671732f, -0.15528199f, -0.09205744f, 0.10409881f, -0.12865359f, -0.12324703f, 
    0.15197098f, -0.14481139f, -0.03282281f, -0.12766640f, 0.16088149f, 0.13629134f, -0.02955335f, -0.14177038f, 
    0.04270150f, -0.08617289f, -0.15409638f, -0.09200617f, -0.13117558f, 0.11930921f, -0.15072598f, 0.14333855f, 
    -0.04570531f, 0.04822670f, 0.15946315f, 0.15416358f, -0.16511953f, -0.09989880f, -0.05686096f, 0.07444963f, 
    -0.15137781f, -0.12955908f, 0.13413589f, -0.17337535f, 0.15652412f, 0.00876283f, -0.04998568f, -0.10820667f, 
    -0.09085704f, 0.10862593f, 0.09872717f, 0.13421153f, -0.13466212f, 0.14675376f, -0.14418001f, -0.09285878f, 
    -0.11469727f, 0.06825180f, -0.14720771f, 0.01196410f, -0.15956233f, -0.07132785f, -0.10744084f, 0.17229646f, 
    -0.04898223f, -0.12426412f, -0.05690172f, -0.17484042f, 0.11364458f, 0.02174477f, 0.07775316f, 0.04215699f, 
    0.16330059f, -0.16636243f, 0.04016319f, -0.10481218f, 0.17251365f, 0.06334916f, -0.04367020f, -0.17259939f, 
    -0.17573868f, -0.07109830f, 0.01548313f, 0.04456507f, -0.03846732f, -0.14358379f, -0.14401865f, 0.10746894f, 
    -0.17353694f, -0.16376415f, -0.05748115f, -0.10786147f, 0.11171724f, 0.00767229f, 0.04863337f, 0.10741369f, 
    -0.16934477f, -0.07631472f, -0.12053434f, 0.05283531f, -0.09433181f, 0.07576592f, -0.01126646f, -0.05361359f, 
    0.03728141f, 0.01687648f, 0.15920025f, -0.02681740f, 0.00966667f, 0.16646536f, 0.01479578f, -0.11765932f, 
    0.11241589f, 0.04866039f, 0.09490346f, -0.08181018f, 0.07270826f, 0.02687355f, -0.17532502f, 0.05070036f, 
    -0.08257625f, -0.03025844f, 0.04231223f, -0.17303768f, -0.16347739f, 0.14036262f, -0.09147903f, -0.04982422f, 
    -0.11578838f, -0.02395133f, 0.12975660f, 0.10292779f, 0.09270336f, 0.12679915f, 0.16403550f, 0.05565912f, 
    -0.29740804f, 0.11432632f, -0.10746047f, -0.10311846f, 0.00822002f, 0.16292645f, -0.17752923f, 0.17638931f, 
    0.11314980f, 0.00213493f, 0.46602786f, 0.43233126f, 0.06527896f, 0.05599399f, 0.27523085f, -0.15141584f, 
    0.05465714f, -0.14054228f, 0.05463546f, -0.13338357f, -0.24345596f, 0.16434166f, -0.00809749f, -0.01071777f, 
    0.03941805f, -0.22454812f, 0.15419246f, -0.15443371f, -0.03873825f, -0.07558117f, 0.08230902f, -0.14669764f, 
    -0.05629387f, -0.14016712f, 0.18227528f, 0.04721275f, 0.06686305f, -0.10067300f, 0.20241652f, -0.02795000f, 
    0.00962228f, 0.11346868f, 0.37344635f, 0.18508036f, 0.15310773f, -0.14023289f, 0.14086428f, -0.40058115f, 
    0.01998837f, -0.14537139f, -0.15457015f, 0.08672719f, 0.11856756f, 0.13075802f, 0.33729741f, -0.09158165f, 
    -0.39875099f, -0.02328785f, -0.09356055f, 0.16575114f, 0.13489941f, 0.09782722f, 0.12546201f, 0.09341816f, 
    0.07583023f, 0.05186411f, -0.00137607f, -0.01826293f, 0.20498523f, 0.14213277f, 0.34775725f, -0.27344415f, 
    -0.06267282f, 0.02037899f, 0.01904164f, 0.45644987f, -0.16502132f, -0.12919551f, -0.15695092f, 0.25380081f, 
    -0.12804079f, 0.16470239f, 0.27119693f, -0.11551877f, 0.12812497f, 0.06829874f, -0.14730747f, -0.07798077f, 
    0.15183136f, -0.31443661f, -0.13358958f, 0.13954931f, 0.09448791f, -0.10556068f, -0.06441810f, -0.10827889f, 
    0.08009043f, -0.03303618f, -0.15562993f, 0.03291629f, -0.17402278f, -0.13058445f, -0.09160618f, -0.09971654f, 
    -0.13499224f, -0.01151473f, -0.08789565f, -0.17467698f, 0.08650141f, -0.05833520f, 0.02561371f, 0.08259044f, 
    -0.12971754f, -0.13094497f, -0.10429958f, -0.14913683f, -0.05964388f, -0.04912968f, 0.15277484f, -0.03874351f, 
    0.14653559f, -0.11098175f, -0.12527356f, 0.05498425f, -0.17657389f, 0.12232305f, -0.01715583f, 0.01723888f, 
    0.08057588f, -0.02437958f, -0.02630168f, 0.00795553f, 0.02263316f, -0.08968173f, -0.11365032f, -0.12113904f, 
    0.05341270f, -0.15294768f, -0.03913069f, -0.17201467f, 0.00247430f, -0.07531996f, -0.08746991f, -0.04805768f, 
    -0.13821523f, -0.06763017f, -0.16544025f, 0.11532263f, -0.15154083f, 0.14285299f, -0.01892588f, -0.08239828f, 
    0.07757922f, -0.02405843f, 0.01805498f, 0.14192724f, 0.08620933f, 0.10644327f, 0.00576516f, -0.12285990f, 
    0.02792610f, -0.03734628f, -0.03132332f, -0.11379584f, 0.01405500f, 0.15245470f, -0.11502282f, 0.09409618f, 
    -0.09129830f, -0.14160228f, -0.16100545f, 0.15228690f, 0.12348744f, -0.17551227f, -0.15095048f, 0.08035661f, 
    0.06983056f, 0.01842359f, 0.05286942f, -0.13083665f, -0.17272644f, 0.06126034f, 0.10413168f, -0.15767394f, 
    -0.12883782f, -0.14819245f, -0.10280452f, -0.02517158f, -0.06410110f, 0.07996712f, -0.02416229f, 0.10703501f, 
    -0.28951696f, 0.28018707f, -0.03665894f, 0.07431068f, 0.32240269f, -0.05735517f, -0.02334168f, 0.12247585f, 
    -0.01935607f, -0.03495472f, 0.11220906f, -0.31205177f, 0.13307919f, -0.08824355f, -0.11871357f, 0.00563482f, 
    0.03213452f, -0.20808241f, -0.04499852f, -0.08225182f, -0.39874920f, 0.15840998f, -0.15703945f, 0.08871453f, 
    0.53943694f, -0.00462137f, 0.41717055f, 0.12658559f, -0.06900214f, -0.10445650f, 0.14412323f, 0.00369581f, 
    -0.48994720f, -0.00970895f, -0.05030109f, 0.04448589f, 0.15954491f, 0.00371179f, 0.53338343f, 0.01314545f, 
    0.09433033f, 0.16424930f, 0.12496941f, 0.08310500f, 0.15626200f, -0.02455586f, -0.12272555f, 0.12620127f, 
    -0.07997451f, 0.23515941f, 0.04305096f, -0.33280358f, 0.19796191f, 0.03535433f, 0.12713172f, 0.15175453f, 
    -0.08348036f, 0.16947567f, 0.05922009f, -0.15712994f, 0.10503896f, 0.17052060f, -0.08772591f, -0.09928463f, 
    -0.02814657f, 0.26001471f, -0.12118448f, -0.14834873f, -0.00596582f, -0.11907861f, 0.10844837f, 0.08114849f, 
    0.03907178f, 0.10850935f, 0.11638003f, 0.28963742f, -0.16783634f, 0.07030160f, 0.23376209f, -0.07018329f, 
    0.16334540f, -0.15663654f, 0.21959294f, 0.17483599f, -0.48319030f, -0.03229539f, -0.25727487f, 0.13351795f, 
    0.13162817f, -0.24427016f, -0.03160260f, 0.11306158f, 0.09793712f, -0.10754529f, -0.14601782f, -0.06327838f, 
    -0.02592311f, 0.10418706f, -0.00875124f, -0.04085670f, -0.09008183f, -0.00186250f, 0.01123053f, -0.08107255f, 
    -0.02703656f, 0.13004185f, -0.14375976f, -0.00920558f, 0.12899847f, -0.15530396f, -0.04795976f, -0.14462924f, 
    -0.06834231f, -0.13285668f, 0.03997137f, 0.00839481f, 0.17458223f, -0.05483611f, -0.14752674f, 0.08086362f, 
    -0.10800353f, 0.05950140f, -0.01025568f, -0.06934924f, 0.16353609f, -0.07949932f, 0.13694239f, 0.14504094f, 
    -0.11106567f, 0.14659810f, -0.14601086f, 0.11900192f, -0.11843488f, -0.03063102f, -0.10538071f, 0.01551771f, 
    0.01761313f, -0.09266277f, 0.10106140f, 0.14953309f, 0.11801144f, -0.08249609f, -0.09997293f, -0.13441104f, 
    0.01027964f, 0.14416254f, -0.12756525f, -0.04563998f, -0.08573484f, -0.16685811f, -0.07549206f, -0.11397361f, 
    -0.14998557f, -0.15279762f, -0.02953143f, 0.14837368f, -0.05780992f, 0.10178466f, -0.11920597f, -0.03199534f, 
    0.12924965f, -0.21805255f, 0.07337251f, 0.17238149f, 0.50575548f, 0.14762178f, -0.25277001f, 0.03606777f, 
    0.04593916f, -0.07703056f, -0.00228339f, -0.33219817f, -0.10121198f, -0.02369353f, 0.01191313f, 0.03930541f, 
    0.15816617f, -0.23399127f, -0.11177383f, 0.08091909f, 0.38814190f, -0.01925629f, 0.17506923f, 0.08918773f, 
    -0.08521070f, 0.05180915f, -0.00896638f, 0.08719951f, 0.12257387f, 0.02769153f, 0.09291040f, -0.08680575f, 
    -0.03045557f, -0.05601180f, -0.02921107f, 0.15977947f, -0.13181590f, 0.14644752f, 0.06297491f, 0.10096493f, 
    0.00757185f, -0.14150666f, 0.01915340f, -0.07876953f, 0.04555226f, -0.16438609f, -0.14136729f, 0.11190308f, 
    -0.08027501f, -0.03691334f, 0.01078027f, 0.07888393f, 0.13726574f, 0.10909022f, 0.02661341f, 0.06503391f, 
    0.13996010f, -0.15710717f, -0.04626884f, 0.07994635f, -0.04548800f, -0.13206500f, -0.17531163f, -0.15255058f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.14426161f, 0.00522501f, -0.02918848f, -0.17864598f, -0.13602939f, 0.14601545f, -0.13462618f, 0.15240514f, 
    0.18604247f, -0.06157644f, 0.16897184f, -0.01821468f, 0.20920797f, 0.07076575f, -0.07686315f, -0.16322796f, 
    0.01579699f, -0.15707394f, 0.09874479f, -0.10621089f, -0.04005023f, 0.21163270f, -0.10828459f, 0.00066163f, 
    -0.02573642f, 0.27411446f, 0.03722710f, 0.12931433f, 0.07384263f, -0.13858025f, 0.23694479f, -0.10694450f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.11888265f, 0.20060141f, 0.12461161f, -0.05919438f, -0.11215758f, -0.00016293f, 0.02719667f, 0.05723645f, 
    0.24393786f, -0.02023186f, 0.09746652f, -0.29856360f, 0.33276224f, -0.58720541f, 0.03460385f, 0.07530855f, 
    0.04246292f, -0.07397067f, -0.04527285f, 0.13341177f, 0.00087949f, -0.60642916f, 0.15481764f, -0.09375548f, 
    -0.05629136f, -0.05853656f, -1.11247540f, 0.10591593f, -0.04968975f, -0.16851723f, -0.38658631f, -0.06492488f, 
    -0.06026281f, -0.16415206f, -0.19792844f, -0.12944111f, -0.34866214f, -0.40319952f, -0.15490732f, 0.35149643f, 
    0.21054018f, -0.04344006f, -0.28389817f, 0.19108841f, 0.00979178f, -0.38814831f, -0.14346574f, -0.06486933f, 
    -0.17378622f, 0.17006817f, -0.06904282f, 0.19563137f, 0.26813790f, 0.33117327f, -0.02734252f, 0.09977727f, 
    -0.11057360f, 0.09828354f, -0.29833886f, 0.19744655f, -0.15124643f, 0.05922684f, -0.00604852f, -0.08170617f, 
    0.13357976f, 0.10105393f, -0.03322040f, 0.07706992f, -0.00641847f, 0.12519792f, -0.53210324f, 0.30842006f, 
    0.33114493f, -0.17476836f, -0.02693763f, -0.51832777f, -0.00872710f, 0.05620440f, 0.01048739f, 0.02974269f, 
    0.06878254f, -0.14003198f, -0.14304908f, -0.52920955f, -0.25244552f, -0.06245146f, -0.16070412f, -0.09146202f, 
    -0.07612540f, -0.15000929f, 0.01248476f, -0.27193752f, 0.10061880f, 0.05774548f, 0.03292813f, 0.11165181f, 
    -0.07097122f, 0.18675052f, -0.31211165f, -0.15779693f, 0.16216664f, -0.11630501f, 0.14683880f, -0.58301371f, 
    -0.64106107f, 0.12298461f, 0.12608348f, 0.17834778f, 0.31637743f, -0.19585326f, -0.06106401f, 0.03642638f, 
    -0.05440408f, 0.01554024f, 0.12232390f, 0.04148382f, 0.33916813f, -0.52788663f, 0.00910755f, -0.01036078f, 
    -0.12077882f, -0.33341441f, -0.28678325f, -0.24769075f, 0.02722069f, 0.16269444f, 0.32019368f, 0.12523697f, 
    -0.03262263f, -0.01097420f, -0.39712554f, -0.07471289f, 0.14810358f, -0.24456874f, -0.07508459f, -0.25555009f, 
    -0.24069183f, 0.16309644f, 0.25958607f, -0.02089630f, 0.24836183f, -0.00524645f, -0.14482662f, 0.10915785f, 
    0.10441577f, -0.17498536f, -0.06437490f, 0.28576502f, 0.13774872f, 0.35735905f, 0.02623751f, 0.16379964f, 
    0.05697561f, -0.24471059f, 0.15371041f, 0.10182435f, -0.09697983f, -0.12425217f, -0.32136419f, -0.10145982f, 
    0.09244295f, -0.07000226f, 0.02243920f, -0.02066263f, 0.06133306f, -0.42840073f, 0.20398761f, -0.06250727f, 
    -0.15925941f, 0.16418570f, 0.23729514f, 0.21440208f, -0.31246483f, -0.13628499f, -0.03408870f, -0.10947553f, 
    0.04542137f, -0.09863254f, 0.16487081f, 0.18322366f, -0.30282298f, -0.06674819f, -0.06293755f, 0.14143361f, 
    -0.11087393f, 0.42698643f, -0.12762839f, 0.27387762f, -0.17820437f, -0.02603737f, -0.35356432f, -0.05484599f, 
    0.07805422f, 0.18337241f, -0.20861501f, 0.09945592f, 0.27752545f, -0.04735775f, 0.40203986f, -0.22563505f, 
    0.04011932f, 0.06814303f, -0.38177267f, -0.31635845f, -0.05999473f, 0.00858949f, 0.03670911f, -0.05795112f, 
    0.10556105f, 0.13229191f, 0.10179228f, -0.13421386f, -0.36032295f, 0.14006220f, -0.05578717f, 0.10696295f, 
    0.11955596f, 0.01792676f, -0.61292225f, 0.09076634f, 0.13775343f, 0.01409249f, -0.09754824f, 0.08648670f, 
    -0.12257906f, -0.44579288f, 0.30736610f, 0.02009607f, -0.28462309f, 0.20695579f, -0.11643761f, -0.24612468f, 
    -0.38169664f, -0.09225509f, 0.36866698f, 0.09617956f, 0.08868510f, 0.03648705f, -0.13620126f, -0.06934219f, 
    -0.13732836f, 0.08327212f, -0.11410224f, 0.17092133f, 0.27117532f, -0.43919325f, -0.04662179f, -0.15573792f, 
    0.00454750f, -0.13621962f, 0.31430006f, -0.05743885f, 0.09508429f, -0.01092693f, -0.30994186f, 0.01953755f, 
    0.08826022f, -0.35882246f, 0.22662999f, 0.13973765f, -0.45201793f, -0.25705487f, -0.38469788f, 0.33036059f, 
    -0.11943328f, 0.09032120f, 0.11411115f, 0.16763744f, -0.47109661f, 0.27118087f, -0.11367086f, 0.06504106f, 
    0.01388033f, -0.02336366f, 0.07445295f, 0.05411347f, -0.20350888f, 0.14384781f, 0.07945469f, -0.01918769f, 
    0.16394316f, 0.33361122f, 0.35674408f, -0.14422125f, -0.16083463f, 0.09250325f, 0.07931420f, 0.01423756f, 
    -0.01638975f, 0.14860635f, 0.30521488f, -0.02735584f, 0.11566889f, 0.07265796f, -0.24309109f, -0.36871204f, 
    0.03188063f, -0.02039010f, 0.39348990f, -0.34686938f, -0.33323109f, 0.16710439f, 0.09032889f, 0.13279645f, 
    0.12968956f, 0.14068392f, 0.09937640f, -0.04858575f, -0.52098542f, 0.09744777f, 0.00286788f, 0.12613672f, 
    -0.04216306f, -0.19964860f, 0.27340907f, -0.00033797f, -0.12798649f, 0.02438688f, -0.65979290f, 0.14699407f, 
    -0.11957327f, 0.08770223f, -0.38022172f, 0.07502499f, -0.09598590f, 0.12434095f, -0.22700728f, -0.00511963f, 
    -0.15193070f, 0.00769996f, -0.19097686f, 0.28971469f, 0.27014500f, -0.09745333f, -0.03155724f, -0.09692749f, 
    -0.07042288f, -0.05235070f, 0.06873534f, 0.07441635f, -0.16931571f, -0.65310544f, -0.11873382f, -0.07779434f, 
    0.14205335f, 0.36653975f, 0.06011660f, -0.19399603f, -0.12590468f, 0.02882179f, 0.24240494f, -0.06185438f, 
    -0.17166148f, 0.14936429f, 0.17312083f, -0.16298141f, 0.16769584f, 0.28822964f, 0.04973056f, -0.34637755f, 
    -0.37533182f, 0.05380774f, -0.32235581f, -0.09455077f, 0.05731369f, 0.33080229f, 0.04129508f, -0.03826784f, 
    0.10577820f, 0.13034151f, -0.05555229f, -0.32701987f, -0.24030572f, -0.34238607f, -0.00225184f, -0.13711677f, 
    -0.00454695f, 0.03935343f, 0.18968478f, -0.17555082f, 0.11358459f, 0.09952801f, 0.12636220f, -0.11807210f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.05561621f, 0.04107535f, -0.17481552f, -0.06631201f, 0.05695650f, 0.09636177f, 0.08436231f, 0.07894166f, 
    0.07034168f, 0.04661880f, 0.14358656f, -0.07226130f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
