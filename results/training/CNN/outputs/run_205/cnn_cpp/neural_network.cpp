#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.30846214f, 0.34942991f, -0.50578529f, -0.28256041f, -0.05826616f, -0.61828542f, 0.60387188f, 0.60787445f, 
    -0.19046825f, 0.49624026f, 0.14761223f, -0.00978460f, 0.37887016f, -0.23322570f, 0.40657505f, 0.15695620f, 
    0.06195351f, 0.04983842f, 0.22208820f, -0.07927974f, -0.16910809f, -0.09398221f, -0.16697803f, 0.04602982f, 
    -0.26987809f, 0.01701882f, -0.46717218f, -0.81162983f, -0.66767818f, -0.28857970f, 0.45131961f, -0.03011884f, 
    0.53587383f, 0.14898786f, 0.32912475f, -0.48776621f, -0.04095235f, -0.12859732f, -0.36620668f, -0.38909614f, 
    -0.25333792f, 0.02183642f, 0.24056672f, 0.26393548f, -0.07577900f, -0.25339162f, 0.31623909f, -0.46171162f, 
    0.10893244f, 0.23138450f, 0.59261614f, 0.56355530f, 0.56856006f, 0.64918464f, 0.80478823f, 0.67715043f, 
    -0.14177254f, -0.61654216f, -0.06778838f, -0.08350559f, 0.12553889f, 0.18022156f, -0.15442745f, 0.43154234f, 
    -0.21240298f, -0.29294732f, -0.07882731f, -0.13582054f, -0.04779421f, -0.20435005f, 0.06566735f, 0.18867336f, 
    -0.05630897f, -0.08336984f, 0.08960073f, -0.72128743f, 0.44881931f, -0.25948033f, -0.10706788f, 0.45948213f, 
    -0.64744592f, 0.53130192f, 0.52668405f, -0.44088030f, -0.31661943f, -0.19342636f, -0.06105159f, 0.24373618f, 
    0.03430856f, 0.05695640f, -0.27669877f, -0.03119020f, 0.24723077f, -0.02595705f, -0.02216864f, -0.04106853f, 
    0.21996260f, 0.21360180f, 0.19613899f, -0.28826159f, 0.06373159f, -0.25811625f, -0.50475889f, -0.45042220f, 
    0.37555942f, -0.01580873f, -0.63770700f, -0.35781869f, -0.42084828f, -0.24057496f, -0.29269746f, 0.36953467f, 
    0.40032592f, 0.16812861f, 0.16958296f, 0.16699287f, -0.17017555f, 0.10656303f, 0.08426348f, -0.01372419f, 
    -0.24222721f, -0.11671802f, 0.11263656f, 0.29163626f, 0.06470951f, -0.31638399f, -0.74675930f, -0.62568122f, 
    0.01204927f, -0.33927998f, 0.45978668f, 0.52840245f, 0.10053461f, 0.53882009f, 0.54403502f, -0.11176961f, 
    -0.07439238f, -0.05030979f, 0.23326150f, -0.20248838f, -0.15178959f, 0.18634385f, 0.24647336f, -0.16687986f, 
    -0.13232554f, 0.16385980f, -0.14705963f, 0.18473949f, -0.07426311f, 0.04906026f, 0.97948295f, -0.21857560f, 
    0.55767751f, -0.34983477f, 0.50113058f, 0.77406931f, -0.01415075f, 0.13584407f, 0.15445541f, -0.09211112f, 
    -0.25428522f, 0.07829386f, -0.22376174f, 0.14669003f, 0.05060923f, 0.13892983f, -0.07405419f, -0.04487821f, 
    0.04561725f, 0.06172415f, 0.00377008f, 0.21617313f, -0.14188944f, -0.12322203f, 0.17773157f, 0.84672523f, 
    -0.39572161f, -0.40413025f, 0.27626339f, -0.03254575f, -0.33130476f, -0.05193245f, -0.33028755f, 0.25501552f, 
    0.00028413f, -0.51189756f, 0.06016492f, -0.11270614f, 0.09353030f, -0.17428617f, -0.41312581f, -0.20056689f, 
    0.06953869f, -0.17889479f, -0.40015906f, 0.05781050f, 0.18137704f, 0.04433620f, -0.17520972f, 0.09206972f, 
    -0.19592008f, 0.44902253f, -0.41871846f, -0.71974367f, -0.36949155f, 0.38592315f, -0.30073515f, -0.48667544f, 
    -0.47742075f, 0.00632926f, 0.19276088f, -0.38190794f, -0.10704608f, 0.14664926f, -0.25850123f, -0.24477582f, 
    0.30789733f, -0.28533873f, -0.09834761f, 0.32919079f, -0.19102763f, 0.18472244f, 0.00297744f, 0.01965274f, 
    0.00668154f, 0.82190174f, -0.13182375f, -0.85661411f, 0.57615453f, -0.49426046f, -0.47700468f, 0.46538761f, 
    0.16457595f, 0.18502915f, -0.03862389f, -0.09966304f, 0.22351182f, -0.01266598f, -0.09703241f, 0.27977139f, 
    0.15098961f, -0.16664129f, -0.35641810f, 0.10151105f, 0.32664430f, -0.09794755f, -0.27906144f, 0.19920199f, 
    0.05903355f, 0.02943807f, -0.48405927f, 0.50411803f, -0.28210521f, -0.02623341f, 0.22879106f, -0.57857680f, 
    -0.12699440f, 0.07676313f, 0.38452095f, -0.35737428f, -0.44493821f, 0.11204045f, 0.14606029f, -0.21648768f, 
    0.05685101f, -0.02657458f, -0.04106609f, -0.28167626f, 0.47596878f, 0.13664620f, -0.04371128f, -0.09378363f, 
    -0.21477114f, -0.25698683f, -0.44142541f, 0.52457434f, -0.52718025f, 0.41934305f, 0.77255017f, 0.39808503f, 
    -0.46624038f, -0.42687503f, -0.00119977f, -0.00933504f, -0.27977905f, 0.05227141f, -0.04768241f, 0.06399062f, 
    -0.27858487f, 0.03545111f, -0.09212599f, 0.05778883f, -0.15999143f, 0.21795082f, 0.07357898f, 0.24021040f, 
    0.22772561f, -0.09117455f, -0.31987879f, -0.31380239f, 0.36850795f, 0.14912230f, 0.40403399f, 0.44581217f, 
    0.61588985f, -0.73051620f, -0.08099463f, -0.44156960f, -0.50267786f, -0.27653882f, 0.00753508f, -0.27663973f, 
    0.23472950f, 0.05468985f, 0.32479259f, -0.04673273f, 0.16493590f, 0.01689501f, -0.19739200f, 0.06793036f, 
    -0.20982960f, -0.24691510f, -0.15305316f, 0.09498487f, 0.24128446f, -0.80783397f, -0.74342638f, -0.18523680f, 
    -0.09217521f, -0.00558170f, 0.24799100f, 0.59920651f, 0.23470800f, 0.12808293f, 0.51979631f, 0.09328636f, 
    -0.09162904f, 0.33642736f, 0.23145045f, 0.14574827f, 0.17155343f, 0.20026737f, -0.18420149f, 0.21904495f, 
    0.01682644f, -0.03773221f, -0.00269294f, -0.09123936f, -0.01833185f, 0.28113782f, -0.67526299f, -0.49224404f, 
    -0.02916134f, -0.60680783f, -0.62678885f, -0.43851396f, -0.45066318f, -0.20445968f, -0.10191196f, -0.22521996f, 
    0.04231089f, -0.06316902f, 0.06225643f, 0.05445936f, -0.15942283f, 0.07010426f, 0.12917826f, -0.07838710f, 
    0.02315960f, 0.17158018f, 0.13805929f, -0.09419479f, 0.20869340f, 0.21788365f, 0.06322851f, -0.22334678f, 
    0.17522430f, 0.63513100f, 0.48613104f, -0.50534922f, -0.66257489f, -0.61742353f, -0.05584285f, -0.12827657f, 
    -0.15384294f, 0.59778386f, 0.35935432f, -0.02438839f, 0.05272496f, -0.22216785f, -0.30565763f, 0.23771296f, 
    -0.02745942f, 0.14534569f, 0.16773270f, 0.30683702f, -0.04955544f, -0.19606508f, 0.02225343f, -0.14399377f, 
    0.19281606f, 0.55643690f, 0.64275277f, 0.53383648f, -0.04003135f, -0.04165896f, -0.28810182f, 0.03244516f, 
    0.02165640f, 0.37995702f, -0.31029922f, 0.11260361f, -0.14832059f, 0.07319014f, -0.38556165f, 0.08053142f, 
    0.43877727f, -0.25154456f, 0.18993492f, 0.10953958f, 0.04869049f, 0.02954410f, 0.05953507f, -0.29013458f, 
    0.30005738f, -0.05695754f, 0.43329450f, -0.52986401f, -0.64080411f, -0.30038670f, 0.80529219f, -0.13530052f, 
    -0.03116032f, 0.19894515f, -0.19144499f, 0.13151032f, 0.11370215f, 0.27447760f, -0.03388743f, -0.15995480f, 
    -0.06767458f, -0.22454315f, 0.29442799f, 0.23445256f, 0.06581793f, 0.10113432f, -0.04108567f, -0.00547678f, 
    -0.28468633f, 0.43033400f, 0.26887280f, 0.31806511f, -0.23677967f, 0.41425830f, 0.77255124f, -0.06429851f, 
    -0.59332198f, -0.40943134f, -0.28986302f, -0.03380376f, 0.28575307f, 0.37265420f, 0.03833127f, 0.03504788f, 
    0.17445351f, 0.27719498f, 0.16641377f, 0.26563591f, 0.13333613f, 0.27021429f, 0.36962503f, 0.14392303f, 
    0.05481113f, -0.33978558f, -0.18087325f, 0.18405044f, 0.43149155f, 0.09044390f, -0.04196158f, -0.65162414f, 
    0.50482935f, 0.25651485f, -0.23768765f, 0.15215419f, -0.07359668f, 0.50554639f, 0.38633516f, 0.36429137f, 
    0.37340587f, 0.05373800f, -0.05616021f, -0.34851903f, 0.01931537f, -0.23727548f, -0.31927568f, 0.13047147f, 
    0.24113815f, -0.01501640f, 0.02980069f, -0.03017259f, -0.80551541f, 0.29884425f, 0.40617532f, -0.42346153f, 
    -0.00230927f, 0.58258063f, 0.14351466f, 0.09585427f, 0.60426265f, 0.72809267f, 0.10935365f, -0.01998690f, 
    0.06810880f, -0.29466337f, -0.29477468f, 0.03775689f, 0.06226723f, -0.04439182f, 0.05508249f, -0.09397002f, 
    -0.20483389f, -0.06272206f, -0.07385436f, 0.07682105f, 0.00318292f, 0.44556171f, 0.41395417f, 0.34768561f, 
    0.38701722f, -0.51944590f, -0.48175541f, -0.16998041f, -0.47661340f, -0.54396117f, -0.02545076f, -0.11097022f, 
    -0.00092630f, 0.36651218f, 0.00069592f, -0.16718625f, -0.00986109f, 0.06535172f, 0.00956581f, 0.06467881f, 
    -0.25881860f, 0.21448353f, 0.31555700f, 0.23486792f, 0.16355692f, 0.16579671f, 0.78635234f, 0.52861440f, 
    0.58153445f, 0.17063576f, -0.00044377f, 0.34835309f, 0.08240116f, -0.23292038f, -0.56224144f, -0.04627555f, 
    -0.13541049f, 0.27104071f, -0.10993168f, 0.23688035f, -0.07010514f, -0.28348228f, -0.16769204f, 0.15051937f, 
    0.14914256f, -0.09999334f, -0.29589126f, -0.12822363f, -0.34833246f, -0.35137731f, -0.41051340f, -0.96145898f, 
    0.57242811f, 0.10885113f, -0.18030192f, 0.73838824f, 0.78030688f, -0.22432290f, -0.79796368f, 0.40994370f, 
    -0.49077797f, 0.16002147f, 0.05057958f, -0.44165507f, 0.23591238f, -0.27023864f, -0.41949043f, 0.00629757f, 
    0.24482653f, -0.18528670f, 0.01885505f, 0.18431096f, -0.09377351f, -0.09105706f, 0.00642684f, -0.35902917f, 
    0.26874077f, -0.39292219f, -0.19946396f, -0.14222892f, 0.15381697f, -0.54125196f, -0.09074947f, 0.17024790f, 
    -0.23649533f, -0.02517826f, 0.11381698f, 0.20900415f, 0.05225876f, 0.02474719f, 0.42151812f, -0.17779377f, 
    0.26093635f, 0.19004470f, 0.23272671f, 0.44539347f, -0.34604964f, -0.23125467f, 0.33076283f, -0.39236909f, 
    0.34245312f, 0.81612533f, -0.76634997f, 0.34718153f, 0.20640470f, -0.31093293f, 0.22022830f, 0.13410479f, 
    0.25826102f, 0.29462641f, 0.00864551f, 0.42714795f, 0.21621482f, 0.00608122f, 0.20740472f, -0.14681163f, 
    -0.31739551f, -0.23195487f, -0.19713682f, -0.06712799f, 0.18551598f, -0.08327468f, -0.01484793f, 0.20496623f, 
    -0.23419379f, -0.00552883f, 0.64432514f, -0.10293519f, 0.38519961f, 0.08629090f, -0.13624159f, -0.15744622f, 
    -0.48310313f, -0.54910362f, -0.23933806f, 0.46474379f, -0.17109752f, 0.43509352f, 0.44483414f, 0.00141195f, 
    -0.08385541f, -0.32783881f, -0.19571915f, 0.18781359f, -0.04485450f, 0.47644016f, 0.38707757f, 0.14204128f, 
    -0.18839215f, -0.02274916f, -0.15637092f, -1.34576178f, 0.69300526f, -0.02480964f, 0.11047015f, -0.40438393f, 
    0.41557884f, 0.45325455f, -0.32632273f, 0.14634933f, -0.21822745f, 0.00203615f, -0.27730730f, 0.00753701f, 
    -0.09094651f, 0.34699672f, -0.17284980f, -0.32845733f, -0.06060142f, -0.18712002f, -0.01613475f, 0.13478567f, 
    0.22869344f, 0.31914884f, 0.29803681f, 0.09056555f, 0.59190845f, 0.21583331f, 0.08631925f, -0.05444360f, 
    0.43883836f, 0.04415227f, 0.12042866f, -0.52673417f, 0.07440702f, 0.35778069f, 0.22174339f, -0.14747435f, 
    0.04646042f, -0.19570138f, -0.00672662f, 0.24584506f, 0.16255525f, 0.17463826f, -0.11749830f, 0.21971835f, 
    -0.29893437f, -0.02271291f, 0.32388443f, 0.47606662f, -0.38344055f, 0.24095568f, -0.44789696f, -0.67823058f, 
    0.05148047f, 0.58372205f, 0.16788639f, 0.54844207f, 0.49231809f, 0.01185588f, 0.28857934f, -0.26970556f, 
    -0.33760673f, -0.58794862f, -0.06998815f, 0.12557505f, 0.09163681f, -0.12946033f, 0.00045871f, -0.21896844f, 
    -0.08528270f, 0.03677994f, -0.30489770f, -0.11386991f, -0.07115234f, -0.18435337f, 0.02905646f, -0.06899076f, 
    -0.42755991f, -0.30492848f, 0.05843600f, -0.19066912f, 0.43392843f, 0.13316293f, 0.25850517f, -0.49937198f, 
    -0.34661505f, -0.08237536f, 0.05734888f, -0.23381069f, -0.36272687f, 0.18482269f, -0.03980749f, 0.51716298f, 
    0.26035529f, -0.27972099f, -0.28940314f, -0.47472245f, -0.60045660f, -0.20283070f, 0.25837201f, 0.13638522f, 
    -0.39353043f, -0.43116471f, 0.36270609f, 0.17613678f, -0.43678504f, -0.66309983f, 0.14506753f, 0.02683045f, 
    0.18864581f, -0.42355567f, 0.21857706f, 0.24177170f, -0.39497989f, -0.39561367f, 0.46606091f, 0.02022082f, 
    0.18387647f, -0.28635538f, -0.15976329f, -0.08059668f, 0.01493166f, 0.11652375f, -0.06867307f, -0.07851893f, 
    -0.97077155f, 1.07346380f, 0.37474597f, -0.31422839f, 0.21330594f, -0.38353398f, 0.69838816f, -0.19123825f, 
    -0.16404203f, -0.20537859f, -0.19438212f, -0.20096716f, 0.10552837f, -0.17758876f, -0.01255764f, -0.02356459f, 
    -0.07064091f, 0.04985318f, -0.16175377f, -0.20748208f, -0.02201191f, -0.01343305f, 0.00247917f, -0.00657507f, 
    0.05654331f, 0.32416204f, 0.12097825f, 0.44631770f, 0.67226446f, 0.41761395f, -0.03035997f, 0.07410311f, 
    0.08226847f, 0.39760208f, -0.19506513f, -0.39500293f, 0.01934924f, -0.04324530f, -0.15932234f, 0.11260783f, 
    -0.06648761f, -0.22068015f, 0.27764827f, 0.31352329f, -0.12053595f, 0.22538760f, -0.21014604f, -0.13712412f, 
    0.15658940f, 0.34068865f, -0.16446391f, -0.91602397f, -0.12666382f, 0.35898244f, -0.38322011f, -0.52972215f, 
    0.65095276f, -0.04475865f, -0.53747582f, -0.30183658f, -0.03808847f, 0.40499595f, 0.18905954f, -0.14024891f, 
    0.29074749f, -0.49749577f, 0.03230007f, -0.00483179f, -0.27923539f, -0.42072460f, 0.17774761f, -0.12274374f, 
    0.28661036f, -0.10600792f, 0.10916663f, 0.46215060f, -0.77258515f, 0.68883771f, 0.22048195f, 0.51897168f, 
    0.06870207f, 0.27355051f, -0.16134839f, -0.18649332f, -0.29748264f, 0.19936498f, -0.24832720f, -0.21421778f, 
    -0.05016535f, 0.07427878f, 0.16899019f, 0.15516336f, -0.03179682f, 0.16700789f, 0.22064072f, -0.30361864f, 
    -0.01014475f, 0.10301298f, 0.12315741f, 0.23535447f, -0.31900153f, -0.63080049f, -0.61568403f, -0.58138412f, 
    -0.12864092f, -0.38083789f, -0.33220908f, 0.25997773f, 0.00070644f, 0.31093788f, 0.20124941f, 0.06553029f, 
    0.16096844f, -0.21948762f, -0.14449082f, 0.23685901f, 0.18654856f, 0.01448751f, 0.32590142f, -0.50903988f, 
    0.18761685f, -0.38235828f, 0.38819242f, 0.06467873f, 0.33232972f, -0.24599810f, -0.20217587f, 0.11279274f, 
    -0.43467769f, 0.23034318f, -0.09046776f, -0.20658195f, -0.79343891f, -0.52816910f, -0.39199087f, -0.06710648f, 
    0.39459065f, -0.04425807f, -0.11190311f, 0.24800166f, -0.33162639f, -0.09155903f, -0.47093463f, -0.42357111f, 
    -0.18952949f, 0.06866017f, 0.35549822f, 0.40664402f, 0.03778336f, -0.28030151f, -0.55433047f, -0.77236658f, 
    -0.77099252f, 0.37139133f, 0.18664977f, -0.53550798f, 0.41173473f, 0.68882197f, -0.62987828f, -0.07773200f, 
    0.27364835f, -0.19143419f, 0.03705013f, -0.25593776f, 0.35498977f, -0.09954600f, 0.22705106f, 0.28955132f, 
    0.02928330f, 0.10004870f, 0.21918403f, 0.15518965f, -0.26037186f, 0.21160762f, 0.02014017f, -0.49823719f, 
    -0.63735849f, -0.01986527f, 0.60975862f, 0.21138290f, -0.47543269f, -0.59532452f, -0.63636035f, -0.08437015f, 
    -0.10808302f, 0.54713511f, 0.28895330f, -0.07785463f, 0.05935668f, -0.32759902f, -0.08197580f, 0.02907673f, 
    0.17434049f, -0.01366723f, -0.07300097f, -0.07911067f, -0.12699306f, 0.03118141f, 0.06086539f, 0.11577605f, 
    -0.35909545f, 0.47708586f, -0.08406750f, -0.47873372f, -0.05124383f, 0.53532249f, -0.75987619f, -0.37325695f, 
    -0.47906330f, -0.20779140f, -0.46389410f, -0.12526843f, 0.07495888f, 0.17496255f, 0.08513223f, -0.02488910f, 
    0.24434635f, -0.10868750f, 0.02485955f, -0.05664964f, 0.04572857f, -0.04992855f, 0.04172555f, -0.17232682f, 
    -0.00958479f, 0.23837988f, 0.83633500f, 0.68429965f, -0.57830840f, -0.50134587f, -0.38227558f, 0.26692367f, 
    -0.42996618f, -0.47117290f, -0.29588997f, 0.11451737f, 0.56063408f, 0.08672002f, 0.09229206f, 0.22043276f, 
    0.13459283f, 0.09073394f, -0.28313568f, 0.04980266f, 0.04476334f, 0.07988816f, 0.07210951f, 0.15626828f, 
    0.09026592f, 0.32826602f, 0.70115662f, -0.05704559f, -0.48668391f, -0.56632376f, 0.13139150f, 0.18453777f, 
    0.22997929f, 0.21335377f, 0.31299028f, 0.38874149f, -0.05767156f, 0.03037649f, -0.23350421f, -0.21567781f, 
    0.02807767f, -0.05958551f, -0.30996594f, -0.03649660f, 0.03851329f, 0.15730308f, 0.15290304f, 0.32330132f, 
    -0.10924503f, -0.06393201f, -0.23311813f, -0.59761792f, -0.68554300f, -0.13284206f, -0.08214787f, 0.07925980f, 
    -0.19425724f, 0.65997130f, -0.07971817f, 0.32064810f, 0.11101269f, -0.08465718f, 0.00116036f, -0.28441390f, 
    0.00755172f, -0.13384880f, 0.12395912f, -0.03501634f, 0.08689886f, 0.00742024f, -0.11843173f, -0.02564594f, 
    0.31108439f, -0.17297928f, 0.07198821f, -0.31324232f, -0.27127731f, 0.44071150f, -0.02993146f, -0.54944026f, 
    -0.36511502f, -0.09857329f, -0.27917752f, -0.14542639f, 0.06462310f, -0.19856952f, 0.17923619f, 0.00326555f, 
    0.19373323f, -0.19008780f, -0.36769322f, 0.29903820f, 0.05539276f, 0.28872770f, -0.04238108f, -0.56942356f, 
    -0.47211525f, -0.12750737f, 0.24523512f, -0.30532146f, 0.17258266f, 0.40085584f, 0.15921277f, -0.44025949f, 
    0.64785624f, -0.54496598f, 0.36630815f, -0.43347782f, 0.15116689f, 0.34039429f, -0.18561763f, 0.21254984f, 
    0.17649524f, -0.00697790f, 0.27189234f, -0.35135308f, 0.29397351f, 0.06772991f, 0.12562166f, -0.47927296f, 
    0.20985933f, -0.11928871f, -0.16452526f, 0.40099558f, -0.20467916f, 0.14719142f, 0.66367042f, 0.06326661f, 
    -0.57008457f, 0.50483948f, 0.15481812f, -0.75668395f, 0.10064650f, -0.43257904f, -0.27429259f, 0.09179816f, 
    0.23589428f, 0.38121891f, -0.07931244f, -0.01622475f, 0.16073462f, -0.10832808f, -0.27073762f, 0.01329801f, 
    -0.31811064f, -0.22625509f, -0.16779217f, -0.02525666f, 0.11976156f, 0.08309465f, -0.10398342f, 0.48192409f, 
    -0.30301574f, -0.37793222f, -0.37459311f, 0.65628088f, -0.38334623f, -0.53188086f, 0.36064678f, -0.12148727f, 
    0.21217653f, -0.51862502f, -0.11267292f, 0.00877546f, -0.07676531f, 0.07860911f, 0.36254925f, -0.43565577f, 
    -0.02961008f, 0.12675329f, -0.04010218f, 0.30046639f, -0.00850224f, -0.03699972f, -0.07549553f, -0.01270128f, 
    0.72816592f, 0.47103164f, 0.44559437f, 0.57091814f, 0.55282789f, 0.37403411f, -0.03997406f, -0.20859250f, 
    0.29236972f, -0.06877121f, 0.28015247f, 0.33991665f, 0.17244221f, 0.11975476f, -0.29710624f, 0.11275577f, 
    -0.34649345f, -0.12596832f, 0.15679650f, 0.10263767f, 0.07622895f, -0.24856140f, 0.33654216f, 0.01857266f, 
    0.22769047f, 0.30114686f, 0.82758236f, 0.61191273f, 0.54091299f, -0.42147711f, 0.10729589f, -0.07239043f, 
    -0.37307522f, 0.26386520f, 0.37363905f, -0.03107856f, 0.14014807f, -0.05457694f, -0.03074336f, 0.18724446f, 
    0.22896081f, -0.29522067f, 0.23412682f, -0.07136723f, -0.37575850f, -0.26546606f, 0.06483697f, -0.59228146f, 
    -0.15432687f, 0.04890286f, 0.26334795f, -0.36036757f, 0.18434575f, 0.70296997f, 0.33373287f, -0.05127741f, 
    0.31199285f, -0.17206343f, -0.02554158f, -0.25738898f, -0.33326286f, 0.05440458f, 0.16490300f, 0.54815936f, 
    0.14617558f, 0.24405086f, 0.33233118f, 0.47027463f, -0.16738030f, 0.25405785f, 0.14255413f, 0.02107573f, 
    -0.17129074f, 0.15827817f, 0.00171628f, 0.47500464f, 0.44102561f, -0.45252362f, -0.86543661f, -0.59114450f, 
    0.32686439f, -0.34149358f, -0.07712378f, 0.31619570f, -0.22065102f, -0.30893293f, -0.12499283f, -0.11182546f, 
    -0.02007634f, -0.23477006f, 0.29761469f, 0.13836798f, -0.26279435f, -0.09209266f, 0.14532381f, -0.18312234f, 
    0.00066957f, -0.01131402f, -0.03868310f, -0.12207745f, -0.02812171f, 0.20053507f, 0.59351254f, 0.54781419f, 
    0.52347654f, 0.47486475f, -0.23550740f, -0.15839763f, -0.07048807f, -0.20274635f, 0.33303902f, 0.33241040f, 
    0.17245437f, -0.04259965f, -0.39654699f, 0.13523456f, -0.25927061f, 0.33829170f, 0.01778185f, -0.17030731f, 
    -0.12619194f, -0.12219498f, 0.09401298f, 0.08596324f, 0.16098553f, 0.76258707f, 0.39470237f, -0.42293963f, 
    0.25111702f, -0.18593940f, -0.42764246f, 0.33862308f, -0.07684243f, -0.15750974f, 0.13914725f, 0.34607595f, 
    0.05234051f, 0.06016443f, -0.12354755f, 0.02481632f, 0.00169091f, 0.25132820f, -0.09022515f, 0.29666466f, 
    0.23835780f, 0.26696789f, 0.22074047f, -0.30625799f, 0.33268583f, -0.11252186f, -0.52482760f, -0.75700009f, 
    -0.72954649f, 0.05339377f, -0.31365481f, -0.26080588f, -0.10271725f, -0.44825903f, 0.27179167f, 0.55423909f, 
    0.07094987f, -0.04073194f, 0.22658272f, 0.04981481f, -0.16020949f, -0.15471061f, 0.14026281f, 0.20710412f, 
    0.22497717f, 0.19273756f, -0.30179280f, 0.12490435f, -0.16791211f, -0.07211420f, 0.36518708f, -0.98848784f, 
    0.60861963f, -0.14083208f, 0.06998145f, 0.04995965f, 0.23361164f, 0.65231824f, 0.14475530f, 0.37470061f, 
    0.68769985f, -0.34616286f, -0.22337060f, -0.05679290f, -0.39054826f, -0.01665915f, 0.01301348f, 0.24451502f, 
    -0.22419904f, 0.23402962f, -0.11564874f, -0.03829594f, -0.06003195f, -0.16677424f, -0.08781499f, -0.12994888f, 
    0.65984851f, 0.27297348f, -0.41907880f, 0.37811312f, 0.71368831f, -0.19486132f, 0.21655887f, 0.39540136f, 
    0.32903662f, 0.38510272f, -0.12392579f, -0.10508259f, -0.36782470f, 0.06842823f, -0.11562783f, 0.01188911f, 
    -0.05319047f, 0.39910659f, 0.23431228f, -0.15708399f, -0.11303110f, -0.16049530f, -0.01648554f, -0.13655773f, 
    -0.10346487f, 0.10157590f, 0.46417657f, 0.04005497f, 0.44348916f, 0.50853211f, 0.24401806f, 0.35307413f, 
    0.38494179f, 0.22233233f, -0.11454577f, 0.27676982f, -0.15561752f, -0.33286095f, -0.34562305f, -0.05031005f, 
    0.00120868f, -0.27660856f, 0.28487232f, -0.06648482f, 0.16660860f, 0.04443139f, 0.39435437f, 0.29163337f, 
    -0.07485727f, -0.02383015f, -0.32948568f, -0.46310657f, -0.59880900f, -0.38777521f, -0.14905086f, 0.06169879f, 
    0.80267054f, 0.07478447f, -0.20227051f, 0.20576410f, -0.00536328f, -0.17936538f, -0.08757248f, 0.07892807f, 
    0.24426721f, 0.00934785f, 0.11864889f, 0.16585444f, -0.19115494f, -0.20834838f, 0.20158762f, -0.08013248f, 
    -0.31416124f, -0.07364365f, 0.14608383f, 0.57102388f, 0.42307332f, -0.04688028f, 0.68100244f, -0.13399318f, 
    -0.18011810f, -0.46004784f, 0.59357810f, 0.14959873f, 0.28197780f, -0.12746909f, -0.28268170f, -0.14178118f, 
    -0.08299898f, -0.27112454f, 0.14566262f, -0.28936750f, -0.36712873f, -0.16123152f, 0.00226382f, -0.06152635f, 
    0.23115085f, -0.16250803f, 0.39398849f, -0.01780755f, -0.60520190f, -0.51526791f, -0.31872407f, 0.17038727f, 
    -0.53153604f, 0.12216096f, 0.76576954f, 0.46289021f, -0.12404916f, -0.12094384f, -0.24838963f, -0.27870747f, 
    -0.45835829f, -0.23534827f, 0.09267038f, 0.20767504f, -0.16605744f, -0.14805043f, -0.04080901f, -0.25286922f, 
    -0.28798693f, 0.11797484f, 0.27278480f, 0.17871489f, -0.02225719f, 0.35439175f, 0.38877180f, 0.62001806f, 
    0.47479799f, 0.26448855f, -0.21859513f, -0.62910962f, -0.51328915f, -0.44631687f, -0.32843935f, 0.24147239f, 
    0.00701121f, -0.02770153f, 0.14051470f, 0.17892785f, 0.31999764f, -0.10168190f, -0.39128986f, 0.09839735f, 
    -0.00963737f, -0.07154112f, 0.12945390f, 0.24989457f, -0.29882264f, 0.02698318f, 0.56652701f, 0.40780157f, 
    0.61948603f, 0.50382268f, 0.62223572f, 0.16373728f, 0.22009815f, 0.26171628f, 0.11581802f, 0.28398386f, 
    0.02958313f, -0.12627484f, -0.05648448f, -0.42480972f, 0.07165799f, -0.36669460f, -0.06058566f, -0.18958706f, 
    -0.23506507f, -0.31111053f, 0.25155494f, -0.29010987f, 0.34021872f, -0.23305181f, -0.34732813f, -0.52763116f, 
    -0.10325213f, 0.68136895f, 0.55988157f, -0.65692616f, 0.11509988f, 0.10906519f, 0.34856507f, -0.02523711f, 
    -0.27301273f, -0.09903734f, 0.14798284f, -0.22400968f, 0.29481366f, -0.16904055f, -0.05560937f, 0.30028027f, 
    -0.25047967f, -0.23293196f, 0.02405946f, 0.09762280f, -0.13104978f, -0.19968693f, 0.39162263f, -0.40187010f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.03422192f, -0.04235891f, 0.06458788f, 0.12220272f, 0.19423504f, 0.17835683f, 0.17334498f, 0.02225957f, 
    0.17921330f, 0.12768288f, -0.08316146f, 0.04447184f, 0.25764740f, 0.23271713f, 0.20411536f, 0.14541502f, 
    0.14668265f, 0.21041001f, -0.02175604f, -0.06813261f, 0.11874985f, 0.05365684f, 0.00603111f, 0.00732248f, 
    0.17018414f, 0.01894977f, 0.15271665f, -0.02845048f, 0.24374864f, 0.14623600f, 0.03832199f, 0.05984622f, 
    -0.01211308f, 0.03236368f, 0.21883662f, -0.03563528f, 0.02131021f, 0.18769813f, 0.23255867f, 0.31694272f, 
    0.01553288f, 0.07819159f, -0.02254505f, 0.18746214f, 0.12135239f, 0.27957660f, 0.07404232f, 0.22115296f, 
    0.01580736f, -0.00078166f, 0.03096186f, 0.07483131f, 0.06678177f, 0.23811209f, 0.14160849f, -0.02211815f, 
    0.11882559f, 0.00899547f, 0.21696517f, 0.05451130f, -0.06744955f, 0.21473251f, 0.04977223f, -0.01143895f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.48344114f, -0.16540450f, 0.02275108f, -0.08965585f, -0.12507799f, -0.01358129f, 0.00209581f, 0.15804814f, 
    -0.01543663f, 0.01957135f, -0.01178613f, -0.02278780f, -0.11146974f, 0.03772583f, 0.30017948f, 0.33747080f, 
    -0.01061823f, 0.05866562f, 0.03911538f, 0.13730326f, -0.03670932f, 0.14466718f, 0.03408049f, 0.11359423f, 
    -0.24507688f, 0.26159808f, -0.03140970f, -0.11315008f, 0.16570939f, 0.09389231f, -0.06746088f, -0.01098088f, 
    -0.07223494f, -0.00474565f, -0.00038613f, -0.02658402f, 0.53206664f, -0.04935318f, -0.06240407f, -0.03189321f, 
    -0.07629754f, 0.14868236f, -0.05737003f, 0.03714284f, -0.07478034f, -0.06320979f, -0.01694304f, -0.00666617f, 
    -0.17977755f, 0.04595002f, 0.05997562f, -0.06892645f, -0.05617982f, 0.05078575f, -0.03526931f, 0.02633319f, 
    -0.00314120f, 0.02593383f, -0.06762634f, -0.05356859f, 0.00664643f, -0.00842924f, 0.14731933f, 0.19672437f, 
    0.07447935f, -0.03186825f, -0.00944824f, 0.04854581f, 0.10817802f, 0.11660949f, 0.00503178f, 0.00320425f, 
    -0.03424968f, 0.09771810f, -0.04274433f, -0.09943837f, 0.19406730f, -0.02872147f, -0.02679714f, -0.02083263f, 
    -0.01149069f, 0.00121941f, 0.06892241f, -0.02907230f, 0.02177924f, 0.20706338f, 0.03339029f, -0.04249808f, 
    -0.09690748f, 0.07623649f, 0.01901805f, -0.01804328f, -0.04879081f, 0.03220125f, -0.05935999f, 0.09347901f, 
    -0.10224168f, 0.21729903f, 0.08186150f, -0.12528419f, 0.07322957f, -0.00163732f, -0.00800028f, -0.03717605f, 
    -0.00749547f, 0.02239724f, 0.09999012f, -0.04160689f, 0.18682945f, 0.15461954f, -0.09541401f, -0.10498205f, 
    -0.08586767f, 0.10597815f, 0.03583511f, 0.10625400f, 0.02386666f, -0.05345222f, 0.05450941f, 0.06654643f, 
    0.09493862f, -0.11795608f, -0.02560902f, 0.15756014f, 0.08825899f, 0.13707346f, 0.14055634f, 0.05179720f, 
    0.01149312f, 0.08341758f, -0.09673911f, -0.01877880f, -0.17000696f, 0.06823013f, 0.00785405f, 0.08433045f, 
    -0.05037802f, 0.06049105f, -0.02064337f, -0.00161907f, 0.01079259f, 0.07808096f, -0.00869301f, -0.07280770f, 
    -0.10347300f, -0.13048424f, -0.08214258f, -0.00011458f, 0.03941874f, 0.09494280f, -0.07598316f, -0.03758542f, 
    0.06113772f, 0.02675629f, 0.00338688f, -0.06031645f, 0.31232005f, -0.02648269f, 0.11080119f, 0.07712304f, 
    0.00445493f, -0.11046629f, 0.12000471f, 0.01533255f, -0.00753655f, 0.02983404f, -0.05895070f, -0.02119550f, 
    0.23597284f, 0.01525177f, 0.18806733f, 0.04059831f, 0.19182390f, 0.02424432f, -0.00583552f, 0.05734684f, 
    -0.04498450f, 0.00051697f, 0.03510863f, 0.04679326f, -0.19734564f, -0.04309721f, 0.04965405f, 0.07827117f, 
    0.03048420f, -0.01246132f, -0.03655632f, -0.04734749f, -0.06203595f, -0.00976531f, -0.01953766f, -0.07856022f, 
    0.00075859f, -0.13642687f, 0.05673779f, 0.07347751f, -0.03766529f, 0.06784523f, -0.02288657f, -0.02626965f, 
    -0.00316514f, -0.03530124f, 0.10465024f, -0.09292641f, -0.31658480f, 0.13031547f, 0.26996869f, 0.04110074f, 
    0.00685599f, -0.07580065f, 0.06878302f, 0.06321777f, 0.01697646f, 0.13108760f, 0.03789700f, 0.02237544f, 
    -0.26794389f, -0.04465687f, -0.02133460f, -0.02852243f, 0.03704588f, -0.06973799f, -0.10389991f, -0.11903592f, 
    -0.02004346f, 0.01217239f, 0.00047667f, -0.11825066f, 0.07016468f, 0.06496672f, 0.17528574f, -0.08771279f, 
    0.02506204f, -0.00798118f, 0.06112185f, -0.04302886f, 0.03822914f, -0.11390270f, -0.13617389f, -0.04198476f, 
    0.01780837f, 0.15971553f, 0.03461713f, 0.00197273f, 0.07269109f, -0.01299276f, -0.00729066f, 0.18523280f, 
    0.01236317f, 0.10634702f, 0.06863989f, -0.02576262f, -0.16101509f, -0.08773762f, -0.08407963f, -0.09052868f, 
    -0.06289389f, -0.00656965f, 0.00072519f, -0.01277912f, 0.06612020f, -0.03281299f, 0.02132593f, -0.03933498f, 
    -0.17346162f, -0.12123539f, -0.03133648f, -0.10449836f, 0.03919789f, -0.01755690f, 0.08497571f, 0.05512526f, 
    0.01034854f, 0.03698171f, 0.00708624f, 0.04655258f, -0.10284907f, 0.34174880f, -0.34301245f, -0.10068177f, 
    -0.00825971f, -0.07128911f, -0.03528069f, 0.00591409f, -0.08261907f, -0.10175922f, 0.11351521f, -0.06271302f, 
    0.25864244f, -0.01119245f, -0.03035064f, 0.04411099f, 0.05523997f, 0.01073172f, -0.04935195f, 0.00109914f, 
    -0.06944302f, -0.01085005f, 0.03340488f, -0.06264751f, 0.09685711f, 0.21735655f, 0.06226097f, -0.15826556f, 
    -0.12565038f, 0.06839534f, -0.00782465f, 0.08123662f, -0.08493335f, 0.05549952f, 0.00097437f, -0.00309524f, 
    -0.27173740f, 0.07472422f, 0.05887847f, -0.22197449f, -0.19425477f, 0.19071214f, 0.00311811f, 0.00628297f, 
    0.08938944f, 0.05037295f, 0.00596534f, -0.09232330f, -0.05969918f, 0.07453562f, -0.26160479f, -0.15781465f, 
    0.18710001f, 0.05467232f, -0.01312096f, -0.06641134f, 0.00989785f, -0.16263558f, 0.00028097f, 0.02369924f, 
    -0.04816846f, 0.00640644f, 0.04611219f, -0.06817821f, -0.04398794f, -0.01691299f, -0.06197632f, -0.00852718f, 
    0.03249064f, -0.06275927f, 0.04658094f, -0.02141752f, 0.16527048f, -0.12793264f, -0.10593728f, 0.10662761f, 
    0.05001999f, -0.03509194f, 0.03436839f, 0.16389884f, 0.00864477f, 0.08680874f, 0.09824929f, 0.04202654f, 
    0.10092188f, -0.00973114f, 0.04359630f, 0.16400225f, 0.08706202f, 0.04972361f, 0.01076379f, 0.10387988f, 
    -0.18412687f, -0.00893076f, -0.12291766f, 0.03039879f, -0.00984200f, -0.02330773f, 0.11377332f, 0.14181150f, 
    -0.07122260f, 0.11103988f, -0.00286896f, -0.09472156f, -0.07220566f, -0.03275426f, -0.03868297f, 0.01550740f, 
    0.34274864f, -0.10510044f, -0.11441626f, -0.21171112f, 0.07643571f, 0.11199010f, 0.03397777f, -0.02262413f, 
    -0.05267092f, -0.01557043f, 0.00173858f, 0.01360163f, -0.06984340f, 0.11696059f, -0.14645375f, 0.16296154f, 
    -0.08653852f, -0.01110038f, 0.01863565f, -0.08076220f, -0.06582531f, -0.01242122f, -0.06148916f, -0.03787188f, 
    0.32624045f, -0.04057574f, -0.04514342f, -0.03524048f, -0.05556182f, -0.00125559f, -0.06130243f, 0.00738788f, 
    0.03045017f, -0.00275751f, -0.07647318f, 0.04323624f, -0.02314871f, -0.02188333f, -0.02658412f, -0.19530642f, 
    0.13635315f, -0.02942102f, 0.03933297f, 0.01372075f, 0.01732541f, -0.01081855f, 0.00611207f, -0.07849233f, 
    0.30800286f, -0.00526526f, 0.21826336f, 0.31597686f, -0.00459394f, -0.03861167f, -0.01512693f, 0.06808689f, 
    -0.11270625f, -0.05860435f, 0.01346980f, 0.01946541f, 0.02594298f, -0.08328115f, -0.12322532f, -0.07693938f, 
    0.06931201f, 0.04415354f, -0.00647924f, -0.09278335f, 0.04679759f, 0.04212697f, -0.03472513f, 0.02366790f, 
    0.66508979f, -0.11061149f, -0.04487662f, 0.14895104f, -0.06416681f, 0.05264424f, -0.01547101f, -0.06815530f, 
    -0.06446896f, 0.00982542f, 0.10557189f, -0.02228596f, -0.11465395f, 0.02135986f, 0.08012228f, 0.10735403f, 
    -0.01232599f, 0.05296699f, -0.08678104f, -0.02833026f, -0.03083223f, 0.08224182f, 0.02845830f, -0.12297107f, 
    0.17205170f, 0.24585143f, -0.09443480f, -0.08493366f, -0.03812573f, -0.02170637f, -0.04485255f, 0.10547183f, 
    -0.04122788f, -0.00601498f, -0.14694689f, 0.04775587f, -0.01191412f, -0.08223568f, 0.03234961f, -0.21448863f, 
    -0.02101416f, -0.03330877f, 0.02178887f, -0.10163382f, 0.08213575f, -0.01100908f, 0.01369559f, -0.05365813f, 
    0.06528746f, 0.09641307f, 0.08407430f, 0.16691148f, -0.05386779f, 0.17106315f, -0.02608390f, 0.03144567f, 
    -0.03724248f, 0.00184641f, 0.04875784f, 0.02346862f, 0.18740375f, -0.12429508f, 0.05642468f, 0.15498982f, 
    -0.05068332f, 0.08258021f, 0.06122847f, -0.07713851f, 0.09123184f, 0.05600132f, -0.01223833f, 0.07719743f, 
    0.04561219f, -0.09306347f, 0.00397328f, -0.02934875f, 0.17482413f, 0.08914978f, 0.02741889f, 0.22787698f, 
    0.01241726f, 0.00975815f, 0.03106710f, -0.01809504f, -0.09790406f, 0.02142918f, -0.00678748f, 0.03105974f, 
    -0.09983560f, -0.01643474f, 0.13540879f, 0.09537444f, 0.05873530f, 0.00911337f, 0.05695496f, -0.08011565f, 
    -0.00190980f, -0.03802729f, 0.07994091f, -0.10263748f, -0.06812312f, -0.01804695f, 0.04263943f, -0.01736319f, 
    0.04169879f, 0.07689322f, 0.00186896f, 0.01993358f, 0.13176434f, -0.06330176f, -0.10826252f, 0.14993513f, 
    -0.03503840f, 0.10992751f, -0.02335382f, -0.16801430f, 0.00530744f, 0.02256050f, -0.04764253f, 0.05154628f, 
    -0.04169013f, 0.19553454f, 0.09813829f, 0.02184165f, 0.00408539f, 0.00041381f, 0.02589914f, 0.01135175f, 
    -0.13400841f, 0.02984237f, -0.01695715f, -0.04030798f, -0.17078790f, -0.01496194f, 0.03443812f, -0.20762657f, 
    -0.00768875f, -0.03439512f, 0.03036881f, 0.03391965f, 0.03308716f, -0.09945320f, -0.06651682f, 0.00306495f, 
    0.09328992f, 0.08031314f, -0.11049039f, -0.07684077f, -0.01875338f, 0.09300102f, -0.05311847f, 0.06763569f, 
    0.03710119f, -0.07606446f, -0.09777925f, 0.00598757f, -0.10414186f, 0.00597455f, 0.10826092f, -0.01433919f, 
    0.04853021f, -0.05217935f, 0.04530387f, 0.18309195f, -0.04790478f, -0.01649412f, 0.13099557f, -0.00804468f, 
    -0.05570519f, 0.25041631f, -0.03330817f, 0.00612832f, -0.02568762f, -0.08979104f, -0.06253540f, -0.03451391f, 
    -0.04505905f, 0.10012362f, -0.04700477f, -0.10699647f, 0.06324720f, -0.02649129f, -0.04618244f, -0.06374137f, 
    -0.07920834f, -0.02167229f, -0.00092033f, -0.05499874f, 0.07043547f, 0.06343132f, 0.00108747f, 0.05118705f, 
    0.00449367f, -0.06392119f, 0.18664889f, 0.09019399f, 0.14405338f, 0.01456609f, 0.07105570f, 0.09828255f, 
    -0.15876448f, 0.07530057f, -0.00248647f, -0.02661525f, 0.18834409f, -0.15782094f, -0.05240234f, 0.04268485f, 
    0.03405474f, 0.04228366f, 0.02872966f, 0.16500537f, 0.05997505f, 0.07380975f, 0.05362170f, 0.02613527f, 
    0.03487403f, -0.10330382f, -0.08386761f, 0.10847095f, 0.09926327f, 0.00796966f, -0.01589097f, 0.02976228f, 
    -0.02023676f, -0.03320503f, -0.03944714f, -0.01440464f, 0.04830178f, 0.01092071f, -0.01707104f, 0.14843999f, 
    -0.04281108f, 0.08816529f, 0.02299320f, -0.12135128f, 0.00609823f, -0.02550446f, 0.03083294f, 0.00085505f, 
    0.21830021f, 0.03050676f, 0.08007810f, 0.19985221f, 0.05286653f, -0.07090311f, 0.07250742f, 0.03255480f, 
    -0.03965676f, 0.06156323f, 0.02519696f, -0.06048132f, -0.05955249f, 0.03668838f, 0.07874984f, 0.15853621f, 
    -0.06588908f, 0.01987127f, 0.01934073f, 0.03665746f, 0.01876018f, 0.02421942f, 0.01130168f, 0.14174017f, 
    0.07504889f, 0.00053092f, 0.03521983f, 0.31276888f, -0.00702249f, -0.04907651f, -0.03847970f, 0.02034897f, 
    0.05588369f, 0.01479328f, 0.02747259f, 0.07686923f, -0.24527900f, -0.00384057f, 0.02586203f, -0.03197970f, 
    -0.00086339f, 0.04038829f, 0.01776825f, -0.04596422f, -0.00472654f, -0.07844099f, -0.01301521f, -0.09429898f, 
    -0.03502525f, -0.01070859f, -0.03375205f, -0.00107427f, 0.13111849f, 0.04809266f, 0.03563076f, -0.05364437f, 
    -0.06912816f, 0.01793969f, 0.03283106f, 0.06005780f, 0.18261012f, 0.07279820f, -0.02994420f, -0.07561070f, 
    -0.00402696f, 0.07867322f, 0.04758527f, -0.05256556f, 0.01957911f, -0.06642744f, 0.03209355f, 0.05506082f, 
    0.00366464f, -0.01806700f, 0.00340169f, -0.00174393f, -0.00450756f, -0.03689951f, 0.02271602f, 0.03306518f, 
    -0.03797110f, -0.01472764f, -0.02345325f, -0.02540524f, 0.02008199f, -0.03869899f, -0.03254829f, -0.03052538f, 
    0.02853090f, 0.02224095f, -0.02494894f, -0.00225954f, 0.00737483f, -0.00474538f, -0.02720783f, 0.01325548f, 
    0.00269922f, 0.00096835f, 0.02921682f, 0.00479341f, 0.00967916f, 0.00141069f, 0.02596918f, -0.02532219f, 
    0.02088852f, -0.00018871f, -0.01692699f, -0.01188106f, 0.01854777f, -0.01255241f, -0.00289887f, -0.00268140f, 
    0.01272029f, 0.02068991f, -0.00271938f, -0.00908696f, 0.01041516f, -0.01855826f, -0.03830773f, 0.00360660f, 
    -0.02823753f, 0.01901758f, -0.02507330f, -0.03041908f, 0.01255734f, 0.00536982f, 0.02031240f, -0.01753575f, 
    -0.02284009f, -0.01287071f, 0.02094128f, -0.04239658f, 0.01124160f, -0.00146098f, -0.04163183f, -0.00729629f, 
    0.02435817f, 0.00547793f, -0.03960571f, -0.01802690f, 0.02575974f, 0.02273230f, -0.04062891f, -0.02461296f, 
    -0.03397749f, -0.02163753f, -0.03998694f, 0.02181818f, -0.00239606f, 0.00267497f, -0.02275483f, -0.01424318f, 
    -0.01605345f, 0.02382565f, -0.01211398f, 0.02559619f, -0.02161217f, -0.00991204f, 0.00741424f, -0.02328265f, 
    0.00444781f, -0.00995318f, 0.00005444f, 0.01162412f, -0.01676964f, 0.00465741f, -0.03637815f, 0.00670358f, 
    -0.01670512f, -0.00738687f, 0.01191216f, -0.01900328f, -0.03392157f, -0.03455535f, -0.01018480f, 0.00365622f, 
    -0.00754095f, 0.01464229f, 0.00280778f, 0.00563973f, 0.01945186f, -0.00961557f, -0.03815206f, 0.02746469f, 
    -0.03867180f, 0.00057064f, -0.00397048f, -0.01477420f, -0.02027497f, -0.00706329f, -0.03424510f, -0.02766923f, 
    0.00331209f, -0.01593524f, -0.02248909f, 0.02420228f, 0.02932152f, 0.01044090f, -0.03724951f, 0.01501204f, 
    -0.01036739f, -0.00325468f, -0.00625261f, -0.00037233f, -0.03242107f, -0.00480190f, -0.01280814f, -0.02116056f, 
    0.00057054f, -0.00595024f, -0.03104908f, 0.00154523f, 0.00259016f, -0.02216295f, -0.00267272f, 0.01952470f, 
    -0.02928196f, 0.02220051f, -0.00527454f, -0.02060085f, -0.01135403f, -0.03622605f, 0.02401111f, -0.02985519f, 
    -0.01131986f, -0.01541630f, 0.00502064f, -0.04383399f, 0.01465471f, 0.01596227f, -0.00855707f, -0.00949731f, 
    -0.03887400f, 0.02254260f, -0.02172088f, 0.00612697f, -0.03757240f, 0.01046765f, 0.00161341f, -0.00678126f, 
    0.00458797f, 0.02906630f, -0.00227592f, 0.02100375f, -0.02669128f, -0.04056245f, 0.00872453f, 0.00916324f, 
    -0.02936566f, -0.02938185f, 0.02151303f, -0.02491909f, 0.02129306f, -0.03179786f, 0.02815577f, 0.01009556f, 
    -0.00453161f, -0.03966029f, -0.03138963f, -0.00472641f, 0.00848003f, -0.03687390f, -0.01408590f, -0.02159007f, 
    -0.00231008f, 0.01456616f, 0.02710557f, 0.01494569f, -0.01297530f, 0.03057752f, 0.00618932f, -0.03510306f, 
    -0.01183811f, 0.00414380f, 0.02377844f, -0.01763774f, 0.03600056f, 0.01263993f, -0.00244138f, -0.03744120f, 
    0.00491449f, -0.01821973f, -0.04060498f, 0.02781371f, -0.02499216f, 0.02605386f, 0.01698518f, -0.03589364f, 
    -0.02955590f, -0.00830198f, 0.01806777f, -0.00697613f, -0.02128747f, -0.03769957f, -0.03123129f, -0.00216355f, 
    0.02110332f, 0.02429547f, 0.02627760f, -0.01474616f, 0.02793608f, 0.00315474f, -0.01023643f, -0.02730120f, 
    0.01418162f, 0.03736352f, -0.00277487f, -0.01464895f, -0.03402747f, -0.00154219f, -0.01451491f, -0.03010860f, 
    -0.01058681f, -0.02097075f, -0.01124334f, -0.01158776f, 0.01484692f, 0.00793155f, -0.00688886f, -0.01029362f, 
    0.02237206f, -0.01021866f, -0.01171131f, -0.01195471f, -0.01265118f, -0.01852825f, -0.00874965f, -0.03723758f, 
    -0.04043609f, -0.03644132f, -0.03978756f, -0.01822086f, -0.00766076f, 0.02150620f, -0.01208842f, -0.03899231f, 
    0.01265137f, -0.00576470f, 0.00113678f, -0.00420999f, -0.00171804f, -0.01198061f, 0.00779508f, -0.01226519f, 
    -0.01679784f, -0.01366438f, 0.01124860f, 0.00582768f, -0.01764650f, 0.01660722f, 0.01944525f, -0.03339809f, 
    0.01621330f, 0.02677415f, 0.02305999f, -0.02565112f, -0.00688524f, -0.02943854f, 0.00061327f, 0.02622288f, 
    -0.01230032f, 0.00125067f, 0.00661050f, 0.00843617f, 0.00121382f, 0.03158692f, -0.04249621f, 0.00670529f, 
    -0.01043132f, -0.01816510f, -0.02303971f, 0.01264869f, 0.01976539f, 0.00858890f, -0.00982538f, -0.03671033f, 
    0.02323553f, -0.01748640f, -0.03846460f, 0.00306413f, 0.00834114f, 0.01053610f, -0.00686294f, 0.02717361f, 
    0.01678928f, -0.01811771f, -0.02224348f, 0.00156796f, 0.01507730f, 0.00582491f, 0.00155034f, -0.03172599f, 
    -0.01913911f, 0.01929687f, 0.01033939f, -0.01955754f, -0.02246994f, -0.02072993f, 0.03084695f, 0.01975214f, 
    -0.03459821f, -0.00663670f, -0.00703825f, -0.03365690f, -0.03285019f, -0.01835608f, -0.00941135f, -0.01769686f, 
    -0.01886151f, -0.01320731f, -0.00072724f, -0.02800403f, 0.00489387f, -0.03354206f, 0.02557513f, 0.01328673f, 
    0.02935610f, -0.01226308f, -0.01782299f, 0.01858634f, -0.02888628f, -0.00825144f, -0.01348906f, -0.01212699f, 
    -0.02434651f, 0.02702325f, 0.01384424f, 0.01876945f, 0.02990844f, -0.03653551f, 0.01642982f, -0.03681693f, 
    0.03314121f, -0.01967398f, -0.01347503f, 0.00113485f, -0.02820513f, -0.03144312f, -0.04032397f, -0.01806801f, 
    -0.03910754f, -0.01374648f, -0.00142306f, 0.00747602f, 0.01155439f, 0.02160526f, 0.01015066f, 0.01040067f, 
    -0.04145141f, -0.00075874f, -0.01657500f, -0.01502343f, -0.00195724f, 0.02989391f, 0.01843785f, 0.01026570f, 
    0.01655520f, 0.02761293f, 0.02830322f, 0.00859176f, -0.01600319f, -0.03879372f, -0.00091336f, -0.03785262f, 
    0.01977153f, -0.02227806f, 0.00894837f, -0.01973583f, 0.03052866f, 0.00902328f, -0.02569870f, 0.01835917f, 
    -0.01024897f, -0.04264746f, -0.00374185f, -0.03487498f, -0.03468510f, -0.00805364f, -0.03250508f, 0.00081411f, 
    0.00638371f, -0.00810517f, -0.02091262f, 0.01654967f, 0.02673731f, 0.00128891f, 0.01763018f, 0.01361811f, 
    0.00690175f, -0.00404982f, -0.01542478f, 0.02870708f, -0.00511148f, 0.00155314f, -0.03755364f, 0.02626190f, 
    -0.00335755f, -0.00280368f, 0.02993219f, -0.01445211f, -0.00149726f, 0.01361089f, -0.01548476f, 0.00143796f, 
    -0.01092216f, 0.01771289f, 0.02887537f, -0.03537981f, 0.01167163f, 0.02408295f, 0.02051802f, 0.02877139f, 
    -0.01130945f, -0.02294723f, 0.04093388f, 0.01104631f, -0.02684367f, -0.00883285f, 0.02717733f, 0.01324404f, 
    0.02767038f, -0.02145141f, 0.02585744f, -0.00082983f, -0.02182598f, 0.01487653f, 0.03185834f, 0.02130398f, 
    -0.03555029f, 0.00025010f, 0.03196459f, 0.02802384f, -0.03392890f, -0.03580585f, 0.01608177f, -0.02951804f, 
    -0.03097575f, -0.03360456f, -0.01553679f, 0.03868638f, -0.00633943f, -0.03250630f, 0.00714698f, -0.01843973f, 
    0.01660576f, -0.02370714f, -0.01361533f, -0.03482931f, 0.02417092f, 0.00503748f, -0.01157487f, 0.02077843f, 
    -0.02302420f, -0.03006182f, 0.02420861f, -0.02319003f, -0.03586681f, -0.01281350f, 0.01264415f, -0.02164211f, 
    0.02252706f, 0.02357908f, -0.03783425f, -0.00493861f, -0.03237369f, -0.04267754f, 0.00070354f, -0.02105294f, 
    -0.04214279f, -0.00185195f, 0.00119976f, -0.00124767f, 0.00883758f, -0.00160498f, 0.02473641f, -0.01466806f, 
    -0.00690249f, 0.02720034f, -0.01760214f, 0.02885180f, -0.02752561f, 0.02737684f, -0.00013701f, 0.01955339f, 
    0.00937417f, -0.04070419f, -0.00857376f, -0.00583518f, 0.01544973f, -0.02064092f, 0.02577829f, 0.02776282f, 
    -0.00057710f, -0.02782949f, 0.04109065f, 0.03243946f, 0.01775950f, -0.00568741f, -0.01591193f, -0.03000705f, 
    -0.00767825f, 0.00883712f, -0.03355035f, -0.01787349f, 0.01458899f, 0.00470923f, -0.03375360f, 0.00120176f, 
    0.02675327f, -0.01433416f, -0.00358182f, 0.00622856f, 0.02330320f, 0.00787580f, -0.03551712f, -0.02473202f, 
    -0.03388653f, -0.01178724f, 0.01506321f, -0.01261080f, 0.01434856f, -0.03323627f, -0.02918410f, -0.02862219f, 
    0.00493054f, 0.02760107f, 0.01439243f, 0.02245951f, 0.01541182f, 0.02919870f, -0.00958788f, -0.01236412f, 
    -0.02259387f, -0.00393942f, -0.01036670f, 0.00215800f, -0.03411377f, 0.02819778f, 0.02434812f, -0.00948579f, 
    -0.03359120f, 0.02289335f, 0.00726549f, 0.03358269f, 0.00308961f, -0.00620522f, -0.01162476f, -0.00703383f, 
    -0.01812785f, 0.01980017f, 0.00858431f, -0.03180329f, 0.01219280f, -0.00413718f, -0.02674082f, 0.02010868f, 
    0.00708556f, -0.01014671f, -0.01671586f, 0.02310327f, 0.02503343f, -0.02899142f, -0.03129779f, 0.00896118f, 
    0.02862899f, 0.00016434f, -0.04235375f, -0.00040586f, 0.01584376f, 0.02365774f, 0.00550727f, 0.01402035f, 
    -0.01913177f, -0.00586353f, 0.00219405f, -0.03994501f, -0.03075913f, -0.01045172f, -0.04120480f, 0.01341562f, 
    -0.03388446f, 0.01858681f, -0.01446954f, -0.03468603f, -0.00472767f, -0.00795428f, 0.01153271f, -0.03014329f, 
    0.03045018f, 0.01109331f, -0.02710121f, 0.02847785f, -0.04029499f, 0.01179952f, -0.01698997f, -0.01406133f, 
    -0.03335143f, -0.03554909f, 0.00819602f, -0.02570442f, -0.00209245f, 0.00527787f, -0.01991710f, 0.02085406f, 
    -0.00057982f, 0.01417191f, -0.00351583f, 0.02777707f, 0.00901761f, -0.01712958f, 0.01743053f, -0.00389116f, 
    -0.02949492f, -0.00122159f, -0.02369883f, 0.01251482f, -0.00005501f, -0.01655042f, 0.02571338f, -0.00646539f, 
    0.00009177f, 0.00912481f, -0.01692152f, 0.01642602f, 0.00103751f, -0.01298744f, -0.00968603f, -0.03209769f, 
    -0.00566958f, -0.01314099f, 0.01253656f, -0.02707309f, -0.02644673f, -0.00641073f, 0.02914448f, -0.00762151f, 
    -0.01390414f, 0.00722677f, 0.01009436f, 0.02226412f, -0.01681394f, 0.03088615f, 0.00744217f, -0.01213497f, 
    0.02074075f, -0.04034794f, 0.01552481f, -0.02646013f, 0.00086938f, -0.01581092f, -0.02879400f, 0.02852744f, 
    -0.02342281f, -0.01535567f, 0.01690110f, 0.02544604f, -0.03089386f, -0.03341180f, -0.00746110f, -0.02999144f, 
    -0.01500705f, -0.00397549f, -0.00176741f, -0.00657781f, 0.00128498f, -0.01829022f, 0.01380912f, -0.01203028f, 
    -0.03412568f, -0.02591081f, 0.02337169f, -0.03975827f, 0.01664903f, -0.03786824f, 0.01619503f, -0.01855791f, 
    -0.03636004f, -0.02016519f, 0.01080156f, 0.00267957f, -0.00124003f, 0.02040708f, 0.01520052f, 0.02526682f, 
    0.02699474f, -0.01879778f, -0.00363527f, -0.02688294f, 0.01026899f, -0.00587718f, 0.01204435f, 0.03791728f, 
    -0.02689592f, -0.03185555f, 0.00809050f, 0.02279360f, 0.01011666f, -0.01225535f, 0.00432999f, -0.02448108f, 
    -0.03587979f, -0.03018492f, -0.03011824f, 0.00565155f, -0.01229088f, 0.01221912f, 0.00688597f, 0.00737664f, 
    0.00448579f, 0.01043558f, 0.03242187f, 0.02094767f, -0.03392152f, 0.01947938f, -0.02846615f, 0.01287388f, 
    -0.00474200f, -0.00867382f, -0.03648886f, 0.01044683f, -0.00469045f, -0.00134696f, -0.02343775f, -0.00878932f, 
    -0.02778154f, -0.00156510f, 0.00036330f, -0.00836682f, -0.02620916f, 0.02703010f, -0.02038648f, -0.00944737f, 
    0.03303401f, -0.02113627f, -0.03858471f, 0.01915921f, -0.00679579f, 0.01979401f, -0.01944217f, 0.02387347f, 
    -0.01317208f, -0.00863681f, -0.02982987f, -0.03301066f, -0.02268846f, 0.02065367f, 0.01047126f, -0.03647864f, 
    -0.00689297f, -0.02150813f, 0.01368584f, 0.01066086f, -0.02936444f, 0.02927691f, -0.02677757f, 0.00120743f, 
    0.00636659f, -0.00543403f, -0.02964078f, 0.01176324f, -0.03333990f, 0.01971252f, 0.01880712f, -0.01923338f, 
    -0.03563438f, 0.00119797f, -0.02558028f, -0.01213237f, 0.00073479f, 0.00247422f, -0.01043191f, 0.01764412f, 
    0.00602185f, 0.01654345f, 0.01699522f, -0.01487295f, -0.03356852f, 0.00584030f, 0.02577292f, -0.00286178f, 
    0.01125612f, -0.01041241f, 0.00976365f, 0.03482633f, 0.03423589f, 0.03078793f, -0.01029567f, 0.03458886f, 
    0.03687422f, -0.01070397f, 0.02723289f, -0.02176992f, 0.02176657f, 0.02582407f, -0.00090056f, 0.02434753f, 
    -0.03092196f, 0.02180976f, -0.03841804f, 0.01403636f, 0.01461198f, -0.00608686f, 0.00267581f, 0.03427702f, 
    -0.00110464f, -0.00279863f, 0.02817855f, -0.02246816f, 0.01670784f, 0.00857597f, 0.02441479f, -0.00402301f, 
    0.01950955f, 0.00032975f, 0.02532051f, -0.03278119f, 0.00604345f, 0.00657001f, -0.00643923f, -0.02158762f, 
    -0.03188296f, 0.03237300f, -0.02548805f, -0.01636850f, 0.01391692f, 0.03152062f, -0.03411979f, -0.00924144f, 
    0.03292098f, 0.02700500f, 0.01560951f, -0.00417519f, 0.03297667f, -0.03384046f, -0.02890567f, 0.01083838f, 
    0.02681311f, 0.02988696f, 0.01420155f, -0.00319574f, 0.00885517f, -0.02768343f, -0.03130271f, 0.00146182f, 
    0.01489296f, -0.02137782f, 0.00633165f, 0.00288786f, 0.01514875f, 0.01878300f, -0.02070630f, 0.01441352f, 
    0.00290793f, -0.02521487f, 0.02590380f, 0.01259039f, -0.00712924f, -0.01755007f, -0.03317689f, -0.02351852f, 
    -0.02864139f, 0.02191013f, -0.00065544f, 0.01342140f, 0.00803366f, -0.01040236f, 0.01447311f, 0.02486297f, 
    -0.00672476f, -0.01058066f, -0.03130494f, 0.03460344f, 0.02820963f, 0.00774612f, 0.01554704f, -0.00882840f, 
    -0.00956913f, 0.02497867f, 0.00551084f, -0.00839396f, 0.00304666f, 0.00089671f, -0.00764084f, 0.02532168f, 
    -0.00424813f, -0.01963975f, 0.01808483f, -0.02120657f, -0.03487477f, 0.02625052f, -0.01348570f, -0.03396571f, 
    -0.02956120f, 0.02119792f, 0.01784993f, 0.02854331f, 0.02774482f, 0.01116719f, -0.00663207f, -0.01269990f, 
    0.01564681f, 0.00942940f, 0.02853530f, 0.02231437f, -0.01846758f, -0.02653452f, 0.02177427f, -0.00475911f, 
    0.03923162f, -0.03094310f, -0.00047453f, 0.02304617f, -0.03137065f, -0.02826571f, -0.00658912f, -0.01681767f, 
    -0.03577064f, 0.00664008f, -0.00717380f, 0.04107570f, 0.01291632f, -0.03048262f, -0.00156607f, -0.00125373f, 
    0.02447689f, 0.02887603f, 0.01392067f, 0.02648935f, -0.00906671f, 0.02377685f, 0.01858951f, -0.02661653f, 
    0.02696694f, -0.01239932f, -0.00271117f, -0.01443836f, -0.00761909f, -0.01908075f, 0.01883314f, -0.03394060f, 
    0.01828868f, 0.02866567f, -0.03249603f, 0.01632643f, -0.02708210f, -0.02851367f, -0.02495990f, -0.02430101f, 
    0.02450014f, 0.01790635f, 0.02014066f, 0.01413196f, -0.03537519f, -0.03137508f, 0.02601019f, -0.00095885f, 
    -0.01811532f, -0.02472542f, 0.02713540f, -0.00098953f, -0.03646682f, -0.01359243f, -0.02018872f, 0.01644227f, 
    0.00881395f, 0.01933494f, 0.00187165f, -0.02933755f, -0.03440864f, 0.01028255f, 0.00545028f, -0.02886176f, 
    -0.00253891f, 0.01933114f, -0.01674822f, 0.01463729f, -0.03306708f, -0.00015450f, 0.02034959f, 0.01525539f, 
    0.03265991f, 0.02974107f, 0.00553200f, -0.02456106f, 0.03498881f, -0.01598365f, -0.01791044f, -0.01734792f, 
    -0.00857389f, 0.01097764f, -0.01973316f, -0.01286712f, -0.01797855f, -0.00538327f, 0.00685725f, 0.01518363f, 
    -0.01915440f, 0.02139502f, -0.03349861f, 0.00148202f, -0.03101011f, -0.02760820f, 0.00379316f, 0.02562606f, 
    0.01688341f, -0.01435405f, -0.01045033f, -0.02221305f, -0.03534765f, 0.02346987f, 0.00760402f, -0.02757484f, 
    -0.01759463f, -0.01861108f, 0.01099887f, -0.02042281f, -0.02924188f, -0.00663960f, -0.01462443f, 0.00219971f, 
    0.01578008f, 0.00285973f, -0.01075320f, -0.03334527f, -0.02317277f, 0.01803605f, -0.01112924f, 0.01485783f, 
    0.03098418f, -0.01698813f, 0.02143166f, -0.02498061f, 0.00926573f, -0.03190994f, -0.00261304f, -0.02300885f, 
    0.01121185f, -0.01799926f, -0.02831322f, -0.00693290f, -0.03815156f, -0.02754510f, -0.01987096f, -0.01975653f, 
    0.03155596f, -0.01736043f, 0.02868753f, -0.01979479f, -0.01055027f, 0.01859234f, -0.03646884f, -0.02544850f, 
    -0.02793902f, -0.01415073f, 0.03531944f, 0.01280834f, -0.01189176f, -0.02258796f, 0.02605445f, 0.02174252f, 
    -0.02638056f, -0.01032165f, 0.02513874f, -0.01658392f, -0.03840702f, -0.01465541f, -0.03109601f, 0.01601358f, 
    0.00095277f, -0.02615749f, -0.01156051f, -0.03624487f, 0.01595326f, -0.01861666f, -0.01313327f, -0.02756440f, 
    0.00110986f, 0.02842329f, -0.03577941f, 0.01746611f, 0.02151189f, -0.01638267f, -0.00641769f, -0.01031614f, 
    -0.02889835f, 0.01030437f, 0.03329655f, 0.00902422f, 0.01274393f, -0.01836555f, 0.00383860f, -0.03247786f, 
    -0.01162478f, 0.01698398f, 0.03074849f, -0.02097159f, 0.00899909f, 0.00616117f, -0.01078014f, -0.02213542f, 
    -0.02930426f, -0.03692361f, 0.03412429f, -0.01856009f, -0.02852425f, -0.00227088f, 0.02666832f, -0.01609025f, 
    -0.02292731f, -0.01998277f, -0.02239002f, -0.03456894f, -0.01593948f, 0.02342472f, 0.02843718f, -0.00553685f, 
    -0.02904107f, 0.01523190f, -0.03530796f, -0.01718765f, -0.00958429f, 0.02289801f, -0.00871038f, -0.01353037f, 
    -0.03249608f, -0.02541951f, 0.01147800f, -0.02933202f, -0.03702797f, 0.02038439f, 0.03202413f, -0.01282502f, 
    -0.01390460f, -0.01022868f, 0.01652861f, -0.01444510f, -0.01707778f, 0.02788115f, 0.01591824f, 0.00076989f, 
    0.02445239f, 0.02879825f, 0.03286033f, -0.02959415f, 0.03710154f, 0.00996606f, 0.03103872f, -0.03144012f, 
    -0.01423240f, -0.02139289f, -0.00572025f, 0.02159668f, -0.01113035f, -0.02094153f, -0.02096918f, -0.01983915f, 
    -0.01138344f, 0.00533411f, 0.01525199f, -0.00293042f, 0.02534148f, -0.03060857f, 0.01566418f, -0.02277184f, 
    -0.00783871f, -0.00183896f, 0.01262557f, -0.03084360f, -0.03072170f, -0.01949564f, -0.02694838f, -0.03238888f, 
    -0.02921858f, 0.02447448f, 0.00891287f, -0.00432122f, -0.01189705f, 0.01935981f, -0.01518015f, -0.02799763f, 
    -0.01748199f, -0.01797823f, 0.02308620f, -0.02437166f, -0.02170343f, -0.01809062f, 0.00132594f, 0.00552691f, 
    0.03202004f, 0.02424754f, 0.00522377f, 0.02156937f, -0.02251603f, 0.00917285f, 0.02162521f, 0.03200292f, 
    -0.01745779f, -0.03547348f, -0.00680863f, -0.01870557f, 0.00635410f, 0.00110261f, 0.01412022f, -0.03494368f, 
    0.00927418f, -0.03448726f, 0.02774334f, 0.03285505f, 0.03771682f, 0.01244668f, -0.00809141f, 0.00805904f, 
    -0.02690429f, 0.02820986f, -0.02338490f, -0.02423207f, 0.00515443f, 0.02478415f, 0.02046758f, -0.00877041f, 
    0.01423713f, -0.01046095f, 0.02288231f, 0.02261093f, -0.02907290f, -0.03133262f, -0.03582973f, -0.01756497f, 
    -0.02578066f, -0.02452420f, -0.01792453f, 0.01416628f, 0.00964008f, 0.02312984f, 0.00049418f, -0.03565128f, 
    -0.02929520f, -0.03347274f, 0.02782036f, 0.02006922f, 0.01484642f, -0.02312394f, -0.03019254f, 0.03082879f, 
    -0.02147013f, 0.02006483f, 0.02218483f, 0.00081044f, -0.01700202f, -0.02769738f, 0.00450009f, 0.03406985f, 
    -0.02588762f, -0.03895064f, 0.03517791f, -0.00545678f, -0.00647312f, 0.00683192f, 0.00582877f, 0.01303267f, 
    0.02210842f, -0.01018905f, -0.03441416f, 0.02078256f, 0.01317620f, -0.01682221f, 0.01491580f, 0.01837774f, 
    0.03286721f, 0.02421086f, 0.03015239f, -0.02825076f, -0.02160555f, -0.03869041f, -0.01489252f, 0.02356851f, 
    0.01285063f, -0.00704878f, 0.02517194f, 0.00510478f, -0.00948892f, -0.02369106f, -0.02043215f, -0.02447394f, 
    -0.02675360f, -0.00563100f, -0.02652227f, -0.01534737f, -0.01136544f, 0.01124941f, 0.00237001f, -0.00415096f, 
    -0.03706815f, 0.02545395f, -0.00526075f, -0.01020580f, -0.00121295f, 0.01919447f, -0.03407966f, 0.01458402f, 
    -0.01779513f, -0.02627267f, 0.01963404f, 0.01240471f, 0.00189012f, -0.02936898f, -0.00780078f, -0.01006970f, 
    0.02208291f, -0.02309632f, -0.03234853f, 0.02281448f, 0.01003413f, -0.02117179f, -0.01874614f, 0.02560057f, 
    0.01595485f, -0.01050848f, 0.00868101f, -0.01671709f, -0.01217249f, -0.01836756f, -0.00100092f, -0.02091515f, 
    -0.00097014f, -0.03009951f, 0.01388387f, -0.02270502f, -0.01013991f, 0.01020028f, 0.00870871f, 0.00991269f, 
    0.01779116f, 0.02476695f, -0.03875666f, -0.00873011f, 0.00920532f, -0.03370860f, -0.02635703f, 0.00484145f, 
    0.01188364f, 0.01531814f, -0.01060259f, -0.01023237f, -0.02067128f, -0.00277715f, -0.01592389f, -0.01868608f, 
    0.01598259f, 0.00248875f, 0.02596785f, 0.01021674f, -0.02070862f, -0.01665723f, -0.01824304f, -0.00741517f, 
    0.00213501f, 0.00286366f, -0.00306899f, 0.01144455f, -0.03323596f, -0.02708216f, 0.01002019f, 0.01523074f, 
    -0.03412216f, -0.00652009f, -0.00143019f, -0.03497021f, -0.01728335f, -0.02690907f, -0.03284920f, 0.02136839f, 
    -0.02083502f, 0.02881755f, -0.02564233f, 0.01446272f, -0.03143339f, 0.03049396f, -0.02008321f, -0.01973726f, 
    -0.03623559f, 0.01983281f, 0.00670573f, -0.01947240f, -0.02206644f, 0.02905908f, -0.01001506f, -0.03249190f, 
    -0.02163334f, 0.03829975f, 0.02559228f, 0.01042145f, -0.02589333f, -0.02239708f, 0.01311404f, -0.01640858f, 
    -0.00575632f, -0.00719791f, -0.01301825f, 0.00450642f, -0.03727670f, -0.02021468f, 0.02853703f, -0.00305701f, 
    0.02459349f, 0.01650098f, -0.03329993f, 0.00801095f, -0.00895925f, -0.01593312f, 0.03271867f, -0.02891387f, 
    0.01932591f, -0.01463498f, 0.02783999f, 0.02128490f, 0.02858313f, 0.02451478f, -0.03992087f, -0.02517678f, 
    0.02556982f, -0.00844795f, 0.03084970f, -0.02849115f, -0.00020540f, -0.00424925f, 0.01038718f, -0.02367486f, 
    -0.03607927f, 0.01307166f, -0.02250162f, -0.02921287f, 0.02984888f, -0.02714997f, 0.00085830f, 0.01114420f, 
    0.02476172f, 0.03054579f, 0.01630573f, 0.00007601f, 0.01239263f, -0.01870617f, -0.02497229f, -0.02773598f, 
    0.02438654f, -0.00116623f, 0.00846609f, -0.01349822f, -0.03421830f, -0.03044120f, -0.03242709f, -0.02693390f, 
    -0.02795251f, -0.02258445f, -0.03364310f, -0.00695780f, 0.01428494f, 0.00260385f, -0.03206801f, -0.03203178f, 
    0.02454091f, -0.01437703f, 0.00867419f, 0.00603223f, 0.01368596f, 0.00821273f, 0.00227830f, -0.02805308f, 
    -0.01709130f, 0.02754352f, -0.03389163f, 0.03380855f, 0.02387163f, 0.00236678f, 0.02384248f, -0.02299786f, 
    -0.02379262f, 0.00507405f, 0.01730151f, 0.02725540f, 0.03014347f, -0.00376501f, 0.02306833f, 0.02670117f, 
    0.01848860f, -0.01323396f, -0.01935971f, 0.02063503f, -0.02403834f, -0.02551661f, -0.01648921f, -0.01300677f, 
    -0.03691064f, -0.01948598f, -0.00794287f, 0.00440055f, -0.02969348f, 0.02504159f, -0.03266000f, -0.01287254f, 
    -0.02513306f, -0.01097270f, 0.00786161f, -0.02505345f, 0.02839033f, 0.03012415f, 0.00360666f, -0.02575360f, 
    -0.04115950f, -0.02101242f, 0.02540237f, 0.02362513f, 0.00895242f, -0.01132823f, -0.01283659f, 0.01759355f, 
    0.02192567f, -0.00217222f, -0.00338770f, 0.02437839f, -0.03079213f, -0.01952165f, -0.00411513f, -0.00102572f, 
    -0.03411533f, -0.02729964f, -0.02785110f, 0.00672191f, -0.03932100f, 0.01142351f, -0.00888232f, 0.02499526f, 
    -0.03603120f, -0.02510018f, -0.01099799f, -0.02272988f, -0.00097636f, -0.00935995f, 0.02194631f, 0.03006768f, 
    0.02592117f, 0.00519457f, 0.01576448f, -0.01704370f, -0.01586445f, -0.03427281f, -0.01382724f, -0.03374698f, 
    0.01015429f, -0.01635556f, -0.01177211f, 0.00537861f, -0.02970010f, -0.02935939f, 0.00469722f, 0.00757339f, 
    -0.02697829f, -0.02701856f, 0.02945917f, -0.00265437f, 0.01519934f, -0.00398909f, 0.01308831f, -0.02524455f, 
    -0.03148431f, 0.02322216f, 0.01423736f, 0.02540295f, -0.02832377f, -0.02122297f, -0.01110088f, -0.00962419f, 
    0.02769482f, -0.00801614f, -0.00955256f, -0.01280329f, 0.00088603f, -0.00027873f, -0.01202442f, -0.01168635f, 
    0.02101024f, -0.01927972f, 0.01410838f, -0.01706938f, -0.03181042f, 0.01430133f, 0.02146832f, -0.01182636f, 
    -0.01936772f, 0.02910454f, -0.03844358f, 0.01609533f, -0.02307937f, -0.03281311f, -0.02854505f, -0.01857397f, 
    0.02981182f, -0.02897883f, -0.01709838f, -0.01822622f, 0.02689308f, -0.03480183f, -0.03008961f, 0.01250201f, 
    0.01927790f, -0.02729148f, 0.00868573f, 0.01544972f, 0.02876635f, 0.02238943f, 0.02457776f, -0.01894767f, 
    -0.03988333f, 0.02145820f, -0.00568851f, -0.02643061f, -0.02039992f, -0.00036241f, 0.02755173f, 0.02597536f, 
    0.01072978f, 0.01431150f, -0.03635342f, -0.03072314f, -0.01236427f, 0.01414969f, -0.03727162f, -0.00512519f, 
    0.00151017f, -0.02917641f, 0.01296430f, -0.03686842f, -0.03023278f, -0.02026560f, -0.02767119f, -0.01657845f, 
    0.00494979f, -0.03991915f, -0.00993847f, -0.02593843f, -0.02442165f, -0.00693339f, -0.01305144f, -0.02589195f, 
    -0.03605686f, 0.01104736f, -0.00013113f, -0.01542868f, -0.00655684f, -0.01364846f, 0.02955114f, -0.03571834f, 
    -0.02290595f, 0.01033922f, -0.01548306f, 0.00104167f, -0.02632735f, -0.00757356f, -0.02100547f, -0.00849919f, 
    -0.01889893f, -0.00522500f, -0.01550307f, -0.03663936f, -0.01237358f, 0.02243929f, 0.02596139f, 0.01732174f, 
    -0.02946533f, -0.00695176f, -0.02891414f, 0.01682466f, -0.01964315f, 0.00724574f, -0.01038693f, -0.02835385f, 
    0.01180363f, -0.02007931f, -0.03534043f, -0.01093935f, -0.03454477f, 0.02584975f, -0.02294260f, -0.02340402f, 
    0.00304724f, 0.01853008f, -0.01051027f, 0.02977214f, -0.01581068f, 0.02395764f, 0.01270859f, 0.01583469f, 
    -0.00441252f, -0.03849734f, -0.01545565f, -0.03041410f, -0.03143838f, -0.03074107f, -0.03362971f, -0.02512424f, 
    -0.01072370f, 0.01091159f, 0.00015681f, -0.03452093f, -0.00560066f, -0.00602649f, -0.01288131f, -0.01866480f, 
    0.02388093f, 0.00277978f, 0.02287109f, -0.00513677f, 0.02767521f, -0.02208685f, -0.04023427f, -0.02442674f, 
    0.02299329f, -0.00147541f, -0.01320999f, 0.02812486f, -0.00537174f, -0.00898381f, 0.00890601f, -0.02788774f, 
    -0.03270007f, -0.01860807f, 0.00022733f, -0.02434312f, -0.02538484f, -0.00785861f, -0.01852257f, -0.02296300f, 
    -0.02804955f, -0.03014458f, -0.02557002f, 0.00573772f, -0.03121235f, 0.01913450f, 0.01714258f, -0.03046796f, 
    -0.03760438f, -0.01452394f, 0.02184553f, 0.01151567f, -0.03622502f, -0.01832111f, 0.00315425f, 0.00581456f, 
    -0.00723077f, -0.03904710f, -0.00645720f, -0.03858491f, -0.02349950f, -0.00638726f, -0.03490645f, 0.02640759f, 
    -0.02948700f, -0.03556325f, -0.02179998f, 0.02344387f, -0.01587001f, -0.03266626f, -0.03226375f, -0.01124244f, 
    -0.01192501f, 0.00241769f, 0.00502174f, -0.00128467f, 0.01223270f, 0.02018143f, 0.02960940f, -0.00530666f, 
    -0.03346120f, 0.00976510f, -0.02619317f, -0.01121288f, -0.03722788f, -0.00582636f, -0.02397411f, 0.00273953f, 
    0.01364060f, -0.01247144f, 0.01109665f, -0.03675411f, -0.03512850f, 0.02455186f, -0.02757091f, 0.02985865f, 
    -0.00920568f, -0.00969852f, 0.00554199f, 0.00326899f, -0.03165358f, -0.03862938f, -0.01498680f, -0.02885964f, 
    -0.03043810f, 0.00139622f, -0.00928540f, -0.04059465f, -0.00058831f, 0.02216173f, -0.01661943f, 0.01324675f, 
    0.02332832f, 0.02890207f, -0.01809563f, 0.01577039f, 0.00243751f, 0.02905669f, -0.03416058f, -0.01226568f, 
    -0.03204315f, 0.00863077f, -0.00866688f, -0.00298956f, -0.00574773f, 0.00972907f, 0.01330308f, -0.01632244f, 
    -0.00767693f, -0.00952020f, -0.01406490f, 0.01568072f, -0.01087656f, 0.01813346f, -0.04082950f, 0.00018273f, 
    0.02661630f, 0.00350709f, 0.02468954f, 0.01519708f, 0.00372180f, -0.01083671f, 0.01808856f, -0.01846889f, 
    -0.02192278f, 0.01563932f, -0.04098769f, 0.00753852f, -0.02809588f, 0.00481121f, -0.01153940f, -0.03578694f, 
    -0.01754797f, 0.00395217f, -0.01110820f, -0.00333016f, -0.00005442f, -0.01661872f, -0.00974378f, -0.02922353f, 
    0.00479729f, 0.02399571f, 0.02497073f, 0.00471113f, 0.00050527f, -0.02799853f, -0.01020815f, -0.01678484f, 
    -0.01607394f, -0.00519390f, -0.03694839f, -0.01845797f, 0.01038158f, -0.04074589f, 0.02947716f, -0.01584136f, 
    -0.02586368f, 0.00563074f, -0.02914339f, -0.00626137f, 0.01869282f, -0.03945572f, -0.02344553f, 0.01156951f, 
    -0.03237928f, -0.00198676f, -0.01993174f, -0.01644793f, 0.02851315f, 0.01788504f, -0.03098984f, -0.01032659f, 
    -0.03547429f, -0.01291445f, 0.02197827f, -0.01971351f, -0.01597057f, -0.04171564f, 0.01996601f, 0.01268594f, 
    0.00782100f, -0.03858819f, -0.03700677f, -0.00926310f, -0.02296348f, -0.00399980f, -0.01309909f, -0.02326740f, 
    0.00911928f, 0.02649863f, -0.01915956f, -0.01887052f, -0.00698335f, -0.03544959f, 0.01135209f, 0.02350090f, 
    -0.02945018f, 0.02605444f, 0.00519775f, -0.01484440f, 0.02555437f, 0.02705229f, 0.01423060f, 0.00998911f, 
    -0.00537861f, 0.00371001f, 0.00471220f, 0.01537727f, 0.01621629f, 0.02278574f, -0.03382625f, -0.03909883f, 
    -0.00092393f, -0.03315525f, -0.00474224f, 0.02020244f, -0.02946601f, -0.00008859f, -0.00100149f, -0.03700127f, 
    0.01761478f, -0.01606092f, -0.03556571f, 0.02996633f, -0.01053657f, -0.00813415f, -0.03290702f, 0.01051083f, 
    0.01179183f, -0.02282757f, 0.00825000f, 0.01891819f, 0.00136695f, -0.03174702f, 0.01627072f, 0.00286877f, 
    0.01836137f, -0.00163197f, -0.03905164f, -0.00173016f, 0.00901399f, 0.00332623f, 0.00797688f, 0.01989976f, 
    0.01961333f, 0.00200574f, -0.03969258f, -0.02348502f, -0.00957930f, 0.02925398f, 0.01744341f, -0.03102402f, 
    0.01565765f, -0.04144106f, 0.01511674f, -0.03700086f, -0.02377348f, 0.02570217f, 0.00189867f, -0.01941013f, 
    0.00711639f, 0.00671985f, -0.02983131f, 0.00511230f, 0.01217769f, -0.01406956f, -0.00773899f, -0.03022307f, 
    -0.02589484f, -0.03616970f, -0.00862146f, -0.01640218f, 0.01998393f, 0.00580218f, -0.02315838f, 0.02192718f, 
    -0.02802212f, -0.03618179f, 0.00111505f, -0.02298310f, -0.02623193f, -0.03198694f, 0.02919137f, -0.04101135f, 
    0.01663081f, 0.03003560f, 0.02460004f, -0.00794122f, 0.02586068f, 0.02141041f, 0.02641956f, 0.01751829f, 
    -0.01562408f, 0.01187893f, 0.00409865f, -0.04196415f, -0.02942285f, 0.00213532f, 0.00678031f, -0.00131864f, 
    -0.03480352f, -0.02121006f, 0.01675492f, -0.03909531f, -0.03255128f, -0.03284374f, 0.02404787f, 0.02274530f, 
    -0.02978484f, 0.02701962f, 0.00876560f, -0.00110998f, -0.01852514f, -0.01019304f, -0.03176850f, -0.03119411f, 
    -0.03138069f, -0.00187086f, -0.02983438f, 0.00426492f, 0.01262967f, 0.01292284f, -0.03582082f, -0.02638175f, 
    -0.00474366f, 0.01321138f, -0.00790335f, -0.00723831f, 0.01358730f, -0.01420185f, 0.00961430f, 0.00629195f, 
    0.01370346f, 0.00612979f, -0.02285517f, 0.01324416f, 0.00546597f, -0.01795176f, 0.01306199f, 0.01400706f, 
    -0.01519940f, -0.01972871f, -0.01003800f, -0.03301596f, 0.00985283f, 0.00329092f, -0.02423843f, -0.03287014f, 
    0.02137380f, 0.00629601f, -0.02467656f, 0.02834026f, -0.01071688f, 0.01627393f, 0.01589444f, -0.03333640f, 
    -0.02441675f, 0.02076752f, -0.00433241f, -0.00931065f, 0.01079544f, -0.00015693f, -0.02816971f, -0.02344927f, 
    -0.03325572f, -0.00138085f, -0.02297906f, -0.02329615f, -0.00369552f, -0.02690858f, 0.00567630f, 0.01333693f, 
    0.02466474f, -0.00357896f, 0.00006549f, 0.00075267f, -0.01112432f, 0.02316013f, -0.03960681f, -0.00185852f, 
    -0.00957493f, -0.02083582f, 0.01631929f, -0.00206668f, 0.02559069f, -0.02190980f, -0.00791997f, -0.00359440f, 
    -0.01623014f, -0.00782806f, -0.02420569f, 0.00787256f, -0.04173974f, 0.02204520f, 0.00311811f, -0.02111205f, 
    -0.02872781f, 0.02548391f, 0.00659236f, 0.02826597f, 0.02150685f, 0.01483961f, -0.02343989f, 0.01024193f, 
    -0.02100649f, 0.00021785f, 0.02266982f, 0.00725806f, 0.00780632f, -0.02963328f, -0.02925974f, -0.01253549f, 
    -0.00658422f, -0.02641918f, -0.04125394f, -0.02612054f, 0.01021485f, -0.01450616f, -0.01079989f, 0.02480687f, 
    0.00062358f, 0.00180966f, 0.02455166f, -0.01065085f, 0.01744459f, -0.01435567f, 0.00624384f, -0.00144788f, 
    -0.02488364f, -0.01488662f, -0.03858074f, -0.00594621f, -0.00995123f, -0.01171890f, -0.02742783f, -0.03118985f, 
    0.01109577f, -0.03688278f, -0.00544159f, -0.01150614f, -0.01799718f, -0.00722401f, 0.02679806f, 0.00061138f, 
    -0.02780318f, -0.03195724f, 0.00254076f, -0.00074104f, -0.01520976f, -0.04121184f, 0.01529695f, -0.01200414f, 
    0.00410949f, -0.02582123f, -0.01692973f, 0.00106292f, 0.01164038f, -0.00357368f, -0.03813156f, 0.01664862f, 
    -0.02432254f, -0.04055097f, 0.02527114f, 0.00475525f, 0.01413630f, -0.01822792f, 0.00343825f, 0.00404649f, 
    -0.04057267f, -0.03312196f, 0.00685457f, -0.01515884f, 0.01526181f, 0.00981333f, 0.01347988f, 0.00862041f, 
    -0.03777175f, 0.02832566f, -0.04107165f, -0.03519635f, -0.03693198f, -0.01648474f, 0.00872143f, 0.01012993f, 
    -0.04104888f, 0.02698211f, 0.02364066f, 0.00432912f, 0.02958253f, -0.00112781f, -0.01233756f, 0.02450716f, 
    0.01843097f, 0.01070101f, -0.02634748f, -0.00009908f, 0.00169295f, 0.02101077f, 0.02336801f, -0.02032953f, 
    0.01907994f, -0.02908767f, -0.03484918f, -0.00308638f, -0.02718445f, -0.02586626f, -0.04038602f, -0.03283568f, 
    -0.02148806f, 0.02425091f, -0.02141976f, -0.03697154f, -0.01731663f, -0.02959048f, -0.00612479f, -0.00540934f, 
    -0.03744154f, 0.01619952f, 0.00169605f, -0.02459874f, 0.00465893f, -0.03441282f, -0.02111899f, -0.00015933f, 
    0.02364987f, 0.00974526f, 0.02358706f, 0.01665671f, -0.00695193f, -0.00363363f, 0.01426109f, 0.02851272f, 
    0.00238433f, 0.01895725f, 0.01084252f, 0.02797720f, -0.03457620f, -0.01680139f, -0.00891208f, -0.04181382f, 
    0.00876402f, -0.01798035f, 0.02334289f, -0.00922305f, -0.02141253f, -0.03897980f, -0.00187993f, -0.01668658f, 
    0.02535280f, -0.02475096f, -0.04062335f, -0.03829584f, 0.00854761f, -0.00603668f, -0.01927792f, -0.00182932f, 
    -0.01870293f, -0.02297366f, 0.00124767f, -0.00729602f, -0.04154001f, -0.02705929f, -0.02522260f, -0.03896303f, 
    0.40816736f, 0.19297734f, -0.07554203f, 0.11163479f, -0.00474477f, 0.08451969f, 0.14031205f, -0.07247845f, 
    -0.14611758f, 0.08089042f, 0.06175592f, -0.03800465f, 0.01731564f, 0.14251618f, 0.08819857f, 0.12998345f, 
    -0.05258188f, 0.04791385f, -0.20169704f, 0.10205150f, 0.15292202f, -0.15189739f, -0.00956366f, -0.17465562f, 
    -0.16739923f, -0.02152067f, 0.02204118f, -0.02918272f, 0.13108703f, 0.09378643f, 0.02583757f, -0.10253514f, 
    0.03466132f, -0.03529843f, 0.04932208f, 0.00983033f, 0.20441461f, -0.10693016f, -0.15281285f, 0.05274712f, 
    0.02841146f, 0.02894784f, 0.05856759f, 0.01238668f, 0.12548865f, 0.09046170f, 0.07217850f, 0.05802437f, 
    0.04546935f, 0.08155054f, -0.14971517f, -0.02339833f, 0.03257123f, 0.04456855f, -0.08444560f, 0.02514438f, 
    -0.00879280f, 0.08793333f, 0.13002795f, 0.11543751f, 0.12184051f, -0.04556711f, 0.14707795f, 0.09108740f, 
    -0.07200148f, 0.01066715f, 0.08316182f, 0.02360186f, 0.07864532f, -0.05736347f, -0.01711296f, -0.07052551f, 
    -0.07287157f, 0.26034907f, 0.13692114f, 0.11596733f, 0.04105246f, 0.07797202f, 0.08888321f, -0.07138423f, 
    0.09151082f, 0.00546834f, 0.05689992f, 0.14224632f, -0.23636572f, 0.00292230f, 0.02804818f, -0.06299589f, 
    0.10675799f, -0.03179957f, 0.08354051f, 0.03672156f, 0.13301861f, -0.15580194f, 0.06503961f, -0.10900208f, 
    -0.10641118f, 0.02175704f, 0.03379202f, 0.01905270f, 0.15210566f, -0.10748874f, -0.07110443f, 0.01533458f, 
    0.11634711f, 0.04485492f, -0.05813234f, 0.03470012f, -0.05324354f, 0.03092445f, 0.00403461f, -0.06619404f, 
    0.01513388f, -0.05948417f, 0.08170155f, 0.06380765f, 0.09256470f, 0.02300113f, -0.08553704f, 0.07294408f, 
    -0.01191819f, -0.15327400f, -0.06212656f, 0.00120131f, 0.10607757f, -0.17824788f, -0.20917906f, 0.04243706f, 
    -0.00637504f, 0.09944491f, 0.00063012f, -0.08787400f, -0.39222002f, 0.02227596f, -0.02990347f, -0.07309443f, 
    0.06174073f, -0.24092408f, -0.09281135f, 0.03285191f, 0.05738230f, 0.08360167f, 0.13640890f, 0.10531088f, 
    -0.09404957f, -0.05042614f, -0.11148597f, 0.03972840f, 0.09606329f, 0.00085858f, 0.04732176f, -0.00796555f, 
    -0.09603873f, 0.04912374f, 0.00005005f, 0.07865618f, 0.03747238f, -0.04077413f, 0.06733566f, 0.08933767f, 
    -0.04285372f, 0.05985026f, 0.04039662f, -0.00249264f, -0.00817046f, 0.05048043f, 0.13933992f, 0.05999779f, 
    -0.04491851f, 0.00975681f, -0.04352863f, -0.00368654f, 0.11021421f, 0.04172920f, 0.02034354f, -0.03434797f, 
    -0.03480474f, 0.02506620f, 0.06000194f, 0.05517729f, 0.31592342f, 0.12442572f, 0.09916256f, -0.17468290f, 
    -0.06970228f, -0.03240981f, -0.04521271f, 0.12293980f, 0.03150177f, 0.10083424f, 0.09435294f, 0.10841784f, 
    0.01108925f, -0.10585827f, 0.10883570f, -0.03460023f, 0.09406453f, -0.06148816f, -0.07508499f, -0.05351649f, 
    0.03125343f, 0.04343650f, -0.01917812f, 0.02959966f, -0.14259982f, 0.20303349f, 0.04858617f, 0.01064467f, 
    0.05204998f, 0.01039178f, -0.10693613f, 0.07787106f, 0.01417119f, -0.00937716f, 0.10534444f, 0.05160069f, 
    0.00305523f, -0.01406158f, -0.13133459f, -0.03791969f, 0.13381894f, -0.14306833f, 0.06543564f, 0.13939221f, 
    0.02187584f, 0.15398560f, 0.10780852f, 0.13359921f, 0.11885212f, 0.10048160f, -0.00880934f, -0.11714131f, 
    -0.05013160f, -0.06400612f, 0.01608400f, 0.09017392f, 0.08719677f, 0.02913143f, 0.13640215f, -0.04890206f, 
    -0.06191426f, -0.04373080f, 0.08442992f, 0.13054043f, 0.01483557f, -0.01002393f, -0.05323046f, 0.02643953f, 
    0.09862763f, -0.12085541f, 0.02852305f, 0.01191250f, -0.03371783f, 0.05934163f, 0.02308964f, -0.08175134f, 
    -0.01983102f, -0.09047864f, 0.05662684f, 0.01781501f, 0.03716190f, 0.00017939f, 0.10509782f, 0.02398628f, 
    -0.11044218f, -0.17069358f, -0.10165990f, 0.07424500f, 0.09040513f, 0.09219927f, -0.06826825f, -0.16791911f, 
    -0.02842526f, 0.09869778f, 0.04317415f, -0.14335503f, -0.23476157f, -0.18710782f, -0.00383509f, 0.08699426f, 
    0.00940416f, -0.12071657f, -0.02685246f, 0.13834031f, 0.02499339f, -0.03185865f, 0.00688197f, 0.00992796f, 
    -0.06560589f, 0.08183767f, 0.01060820f, -0.08790467f, 0.02315185f, -0.00528902f, -0.05255320f, -0.08891841f, 
    -0.00894403f, 0.11756210f, 0.12449478f, 0.10423872f, 0.01249793f, 0.08072880f, 0.11691172f, 0.05854092f, 
    0.02110973f, -0.05230575f, 0.09679216f, -0.04271227f, 0.07500513f, 0.01015278f, 0.08968710f, -0.09634697f, 
    0.00065013f, 0.01903911f, 0.05810716f, -0.03770277f, 0.12069498f, 0.00804679f, 0.08585676f, -0.01650847f, 
    0.01981041f, 0.17849891f, 0.10175206f, -0.00584287f, -0.43908831f, -0.23384316f, -0.08152097f, 0.08181623f, 
    -0.06883769f, -0.05180560f, 0.03645439f, 0.05416529f, 0.06335078f, 0.11607119f, -0.05952084f, 0.03802732f, 
    -0.00576423f, -0.04263425f, -0.01384875f, 0.14317840f, 0.20451967f, -0.06732867f, 0.11510240f, -0.10191543f, 
    0.09687991f, 0.06380431f, -0.02817399f, 0.09083561f, 0.09925528f, 0.21437612f, -0.09416189f, 0.00146135f, 
    0.04285031f, -0.01991283f, -0.02609809f, 0.03032125f, 0.02954088f, 0.03025333f, -0.09939573f, -0.13025501f, 
    0.02496333f, -0.05555335f, -0.14637098f, 0.14472017f, -0.05738147f, 0.09330202f, -0.11077718f, -0.14422901f, 
    -0.08341780f, -0.07946233f, 0.13357975f, -0.01949408f, -0.14681484f, 0.00039898f, -0.12970786f, -0.13161269f, 
    0.13076466f, -0.13729429f, 0.10587707f, -0.03255999f, 0.00685323f, -0.10381374f, 0.10151307f, 0.02311267f, 
    -0.12790848f, -0.13337284f, -0.25484991f, 0.10548428f, 0.01765597f, -0.05463739f, -0.11915088f, -0.05801161f, 
    0.09910964f, -0.05299794f, 0.13373351f, -0.04791754f, -0.10970674f, -0.08001063f, 0.11764967f, -0.00710244f, 
    0.10698137f, 0.05823869f, -0.06016893f, -0.00272486f, -0.05323490f, 0.08804524f, 0.12859006f, 0.04557013f, 
    0.15424548f, 0.00402830f, -0.09617458f, 0.05267486f, 0.02319862f, 0.09788512f, 0.07052102f, 0.09624925f, 
    0.00699827f, -0.05612472f, 0.04551610f, -0.13131580f, -0.24240582f, 0.13316837f, -0.07428449f, 0.03947430f, 
    0.02552522f, -0.00432229f, -0.06622435f, -0.08917428f, -0.06906861f, 0.00841477f, -0.09496460f, 0.18540396f, 
    -0.08685780f, 0.02698796f, 0.18510567f, 0.07538275f, -0.09836772f, 0.15914179f, -0.10193017f, -0.07661971f, 
    0.11409864f, -0.10676639f, 0.02243018f, 0.21711308f, 0.09094375f, 0.05030182f, -0.11708888f, 0.07940490f, 
    0.03851281f, 0.02794995f, 0.18088430f, 0.04785551f, 0.13390630f, 0.02345182f, -0.06499398f, -0.03821729f, 
    0.07098130f, -0.09037820f, 0.04486144f, -0.03010830f, -0.00193780f, 0.00300899f, -0.06010912f, 0.01517272f, 
    -0.01751719f, 0.11435217f, -0.03161737f, 0.02306890f, 0.12071757f, 0.11395412f, 0.17415245f, -0.14066465f, 
    -0.03685259f, 0.05563471f, 0.01545347f, 0.01903990f, -0.06760351f, 0.01537215f, 0.14058614f, 0.15747437f, 
    -0.25868914f, -0.09379308f, -0.07248454f, -0.09508989f, 0.12127177f, -0.05214244f, -0.11202884f, -0.08306783f, 
    0.07617787f, 0.00960697f, 0.00227847f, -0.12786207f, 0.28703550f, 0.03769069f, -0.05611101f, 0.04126569f, 
    0.05379337f, -0.07056347f, 0.02167744f, 0.06172878f, -0.00225272f, 0.04134246f, 0.05214920f, 0.19383544f, 
    0.07285539f, 0.11264553f, -0.00798834f, 0.12435623f, -0.12286883f, -0.05718950f, -0.10865305f, 0.08203495f, 
    0.13018954f, 0.03272526f, -0.07540577f, -0.06818597f, 0.14982517f, -0.16313170f, -0.07983989f, 0.01744971f, 
    -0.00551492f, -0.12627633f, -0.07454005f, -0.02340122f, 0.08444953f, 0.00434606f, 0.00757791f, -0.07420514f, 
    -0.08830036f, 0.00461920f, 0.01236099f, -0.01353348f, 0.13589650f, -0.11037298f, 0.03628265f, -0.01129654f, 
    -0.09962974f, -0.22790462f, 0.08164804f, 0.09393642f, -0.14334880f, -0.00357153f, 0.22075532f, -0.11290061f, 
    0.16769883f, -0.03885623f, 0.09520552f, 0.01183713f, 0.01893559f, 0.14828290f, 0.11406273f, 0.09507938f, 
    -0.11232487f, -0.01590614f, 0.00260275f, -0.11726721f, 0.17867540f, 0.02391089f, 0.10331036f, 0.02069605f, 
    -0.02253290f, -0.07924055f, 0.01169773f, -0.08458122f, -0.17398584f, 0.15006730f, -0.04370481f, -0.02650352f, 
    0.03031273f, -0.03194357f, -0.11773667f, 0.10643989f, 0.02944751f, 0.06944961f, -0.06959766f, -0.04858181f, 
    -0.03137930f, -0.16144267f, 0.03875542f, -0.03991295f, 0.18830664f, 0.05738439f, 0.02321971f, -0.10058440f, 
    0.04257083f, 0.06115103f, 0.02336031f, -0.01265706f, 0.10533558f, -0.16284741f, 0.10903352f, -0.04099902f, 
    0.11230177f, 0.13807048f, -0.18477312f, -0.08521243f, -0.01013283f, -0.01658545f, 0.11071940f, -0.00088094f, 
    -0.07332943f, -0.11945260f, -0.00044157f, -0.02739009f, -0.04067890f, -0.03712482f, -0.01954840f, 0.11538944f, 
    -0.00272982f, 0.08195414f, 0.21128446f, 0.07322392f, -0.13513637f, 0.08907201f, 0.00219818f, -0.01838531f, 
    0.12400543f, 0.00813089f, -0.01508002f, -0.11364040f, 0.05778311f, -0.05912555f, -0.05796396f, -0.04269952f, 
    0.11475445f, -0.05582455f, 0.06617346f, 0.04304110f, 0.08516932f, 0.10243169f, -0.01745880f, -0.00932552f, 
    -0.05356927f, -0.01094795f, 0.11187969f, 0.00408510f, -0.06670199f, 0.08037273f, 0.07422961f, 0.02796046f, 
    0.08467566f, -0.03048187f, 0.08280974f, -0.00282359f, 0.03723756f, 0.06709528f, 0.03338723f, 0.10565171f, 
    -0.05516687f, -0.06885273f, 0.09270040f, 0.07417599f, 0.06922477f, -0.04802719f, -0.11641051f, 0.00574987f, 
    0.04436558f, 0.04829652f, 0.01960684f, 0.07543427f, -0.13174751f, -0.06298743f, -0.04511842f, 0.02564065f, 
    0.04044824f, -0.07460558f, -0.12620007f, -0.08410706f, 0.06324007f, -0.06735913f, 0.04596618f, -0.04928960f, 
    -0.10312368f, 0.00781712f, -0.14515890f, 0.04147777f, 0.15263557f, -0.15890355f, 0.03001496f, -0.06085075f, 
    -0.01822979f, -0.01057925f, 0.07687011f, -0.00100125f, -0.00026186f, 0.01443144f, -0.05592486f, 0.00477263f, 
    0.17991129f, -0.09675813f, -0.07144440f, 0.04651702f, 0.01109542f, 0.04228577f, -0.08223974f, 0.03783399f, 
    0.14627647f, -0.04070530f, -0.09881489f, 0.08471909f, 0.00586483f, 0.01662932f, -0.08625992f, 0.05143320f, 
    0.04009572f, 0.12616105f, -0.00397414f, -0.08431175f, 0.00803827f, 0.00729763f, -0.18248026f, -0.19316679f, 
    0.10722605f, -0.04919056f, 0.01070459f, -0.07301951f, 0.02142596f, 0.00456413f, -0.09430414f, 0.02516831f, 
    0.10611685f, 0.03653970f, -0.07010809f, 0.00149374f, -0.10273875f, -0.05229724f, 0.09243049f, 0.05390320f, 
    -0.07203393f, 0.07008826f, -0.16096593f, -0.13424496f, -0.00453332f, -0.00593958f, -0.04713814f, -0.00187248f, 
    0.08214814f, -0.01402405f, 0.02091956f, -0.09523904f, -0.01369479f, 0.07467926f, 0.00955589f, 0.10599707f, 
    0.06884405f, -0.01567256f, -0.09165379f, -0.09618485f, 0.09382126f, 0.01492289f, -0.11184068f, -0.06319546f, 
    0.09382568f, -0.02638781f, -0.03153064f, -0.17526416f, 0.14034964f, 0.03628471f, -0.08403892f, -0.07389834f, 
    -0.02280681f, -0.16953593f, -0.10770493f, -0.00917570f, 0.00891792f, 0.05907002f, -0.07651265f, -0.01804004f, 
    -0.11273924f, -0.07742344f, -0.02498143f, 0.01355424f, 0.07838978f, -0.03226414f, -0.05341722f, 0.08771137f, 
    0.11121187f, -0.02262796f, -0.00042154f, -0.00787978f, -0.15479432f, -0.17951232f, -0.08633139f, -0.11587160f, 
    0.04312787f, -0.00978530f, 0.10520064f, -0.06069401f, -0.05535115f, 0.05784696f, 0.03834683f, 0.22253868f, 
    0.38082683f, -0.03411151f, 0.12979729f, 0.17847884f, -0.10418608f, -0.06523766f, -0.02369948f, 0.09849530f, 
    0.03987658f, 0.05995977f, -0.02517179f, -0.07490149f, -0.22909023f, 0.21208133f, 0.08294782f, -0.07618146f, 
    -0.04693330f, -0.04640702f, 0.00715573f, -0.01016167f, -0.04289660f, -0.09484615f, 0.00268333f, 0.05543719f, 
    -0.13147359f, -0.03749766f, 0.07131916f, -0.05289188f, -0.03755497f, -0.06393901f, 0.07288576f, 0.01338705f, 
    0.06517959f, -0.05344870f, -0.08749983f, -0.02505339f, -0.00144630f, -0.08788956f, -0.13153607f, -0.08443194f, 
    0.00215712f, -0.06726892f, -0.06574782f, 0.02634060f, -0.06954733f, 0.02067191f, 0.04621897f, 0.05642751f, 
    0.04049671f, -0.15922613f, -0.05611549f, 0.00794998f, -0.01875643f, -0.06168066f, -0.02089345f, 0.08378243f, 
    -0.08809471f, -0.04562942f, 0.03496845f, -0.07986539f, 0.14948766f, -0.06739285f, -0.01941465f, -0.05335500f, 
    -0.01194864f, 0.04601434f, -0.02398043f, 0.02143257f, -0.02059159f, 0.08988857f, -0.08332738f, 0.13189907f, 
    0.16904716f, -0.02622827f, -0.04374298f, -0.19435151f, -0.11616218f, 0.08351184f, 0.09190516f, 0.03668996f, 
    -0.08278652f, -0.04087182f, 0.15668672f, 0.04186194f, 0.24493425f, -0.16406183f, -0.01721570f, 0.08162902f, 
    -0.03845723f, -0.03232300f, 0.01448182f, -0.06277129f, -0.11626303f, -0.02764845f, 0.07890508f, -0.03162639f, 
    -0.08626425f, 0.19462690f, -0.00297918f, -0.06459246f, 0.01011161f, 0.21884792f, 0.20934688f, -0.03728101f, 
    0.04649932f, -0.03670888f, 0.04895030f, 0.15048030f, 0.14365214f, 0.00016110f, 0.05992069f, 0.18179531f, 
    -0.02149601f, 0.19497301f, 0.08406249f, -0.04965453f, 0.03018517f, 0.03047934f, -0.01104202f, -0.06360225f, 
    0.08290390f, 0.06137674f, 0.15500972f, 0.02099986f, 0.05368290f, 0.06360490f, -0.03148216f, -0.01821395f, 
    0.14503562f, -0.00053546f, -0.00658405f, -0.09025986f, 0.00776226f, -0.01945484f, -0.01105769f, -0.00646544f, 
    -0.02749704f, -0.05822729f, -0.01212163f, 0.06057841f, -0.01735343f, -0.01795041f, -0.08498417f, -0.02611690f, 
    -0.10355031f, -0.05780877f, -0.03106117f, -0.15543495f, -0.13875741f, -0.05252184f, 0.00092862f, 0.09438231f, 
    0.03464440f, 0.03974430f, 0.06512820f, -0.00291610f, -0.29325783f, -0.10092230f, -0.04469227f, 0.13908324f, 
    0.05718151f, 0.08567061f, 0.08232015f, -0.02492946f, -0.05459617f, -0.02495444f, -0.02808504f, -0.01539626f, 
    0.10582518f, 0.11683983f, -0.09372607f, 0.18735315f, -0.11925796f, 0.09169270f, 0.08722883f, 0.02025990f, 
    -0.01207003f, -0.08647514f, 0.02976879f, -0.06598495f, 0.02289470f, -0.19393156f, -0.02871047f, -0.01460045f, 
    -0.01372742f, 0.01824511f, 0.07747809f, -0.01003339f, -0.03004837f, 0.01313908f, -0.04404344f, -0.02036670f, 
    0.05567837f, -0.01819818f, 0.17258243f, 0.10697997f, -0.06678879f, 0.17785580f, -0.07746101f, -0.12427669f, 
    0.03172849f, -0.10106997f, -0.02802348f, -0.14327866f, 0.08808503f, -0.10964662f, -0.00054271f, -0.00854594f, 
    0.10221446f, 0.06584031f, -0.05749499f, -0.05484033f, -0.08686530f, 0.00683176f, -0.11308012f, 0.03695663f, 
    0.15750368f, 0.00378780f, 0.01247261f, -0.00736331f, -0.05399700f, 0.06374923f, 0.03871784f, 0.07276967f, 
    -0.07483019f, 0.18012850f, 0.03054058f, 0.02040800f, -0.00711859f, -0.05582243f, -0.06777278f, 0.00869330f, 
    0.05857343f, 0.11493316f, 0.02941120f, -0.00026213f, 0.03561569f, 0.03671584f, -0.05114218f, -0.01600115f, 
    0.27909899f, 0.22586368f, 0.10761622f, -0.03176410f, -0.07760812f, -0.04430711f, 0.00437761f, 0.10106781f, 
    0.10006766f, -0.02171556f, 0.01594064f, 0.12130499f, 0.43498057f, 0.03144284f, -0.00846872f, 0.07587824f, 
    -0.01727781f, 0.16238789f, -0.02850640f, -0.03837937f, 0.02654993f, 0.09082083f, -0.06849790f, -0.01335395f, 
    0.10132601f, -0.09679901f, 0.07883869f, 0.04379611f, -0.01625883f, 0.05967181f, 0.03040135f, 0.12577876f, 
    0.05242223f, -0.07409548f, -0.03817348f, -0.07188944f, 0.03667838f, -0.11420767f, -0.05346116f, -0.08729305f, 
    -0.00209366f, 0.04435768f, -0.09384672f, 0.06186208f, -0.06927586f, -0.01636312f, 0.04192045f, 0.05356704f, 
    -0.06994742f, 0.03939388f, 0.03221252f, 0.01318276f, -0.04409101f, 0.10151619f, -0.04004519f, 0.00469202f, 
    0.06959895f, -0.11744764f, 0.05426626f, -0.01991847f, 0.41451898f, 0.26458004f, 0.00101039f, -0.15702419f, 
    0.00502846f, 0.05598328f, -0.02818678f, -0.05293259f, -0.04268265f, -0.12753646f, 0.00686915f, 0.02818228f, 
    0.12279302f, 0.04947562f, 0.14484882f, -0.03113027f, -0.15630092f, 0.08000309f, -0.01267243f, 0.06011713f, 
    -0.08279892f, -0.05487283f, -0.01885439f, -0.03804058f, -0.06264414f, -0.29108188f, 0.01911477f, 0.06159022f, 
    0.10582376f, 0.01666112f, 0.06329327f, 0.01687315f, 0.01565085f, 0.01063374f, 0.09863908f, 0.09746693f, 
    -0.10266201f, 0.02355723f, 0.05043048f, -0.12471726f, 0.07844368f, -0.08708449f, 0.04704891f, 0.21117482f, 
    0.02591818f, 0.04775980f, -0.09212978f, 0.02618880f, 0.03566222f, -0.03230781f, 0.11297356f, 0.13682480f, 
    -0.09379760f, 0.10270111f, -0.11510620f, 0.06542041f, 0.09287046f, 0.12357165f, -0.04005013f, 0.04384157f, 
    0.09131588f, 0.27746484f, 0.02396329f, -0.16434900f, 0.01812212f, 0.04385952f, 0.13593234f, 0.01261077f, 
    -0.00579813f, 0.06680688f, -0.08343703f, 0.10432751f, 0.14121349f, 0.08055699f, -0.04615905f, 0.10966001f, 
    -0.06300267f, -0.02272566f, 0.06804798f, 0.05785475f, 0.06989760f, -0.06213899f, -0.06870963f, -0.04626051f, 
    -0.03201870f, -0.03131851f, 0.01972085f, -0.12079363f, 0.01253625f, -0.03506126f, -0.03855591f, -0.08730796f, 
    0.02822698f, 0.04012257f, -0.00202729f, 0.14269324f, 0.19050984f, -0.14229877f, 0.16486822f, 0.02454126f, 
    0.09571837f, 0.00194018f, 0.02449899f, 0.06303359f, 0.08179753f, -0.09616823f, 0.03382036f, -0.14885876f, 
    -0.03244927f, -0.10983033f, -0.16705897f, -0.09437374f, -0.06253137f, -0.15713573f, 0.02928775f, 0.08429138f, 
    -0.10932202f, 0.08071979f, 0.00505049f, -0.10652655f, -0.10272690f, -0.03566698f, 0.06667498f, -0.14032732f, 
    -0.01160894f, -0.01501244f, -0.13168579f, 0.00851306f, -0.00695270f, 0.02898841f, 0.10847500f, 0.05325060f, 
    0.02259332f, 0.05603070f, -0.07411435f, 0.13647375f, 0.01329864f, -0.08317606f, 0.08984961f, -0.04604024f, 
    0.02290779f, -0.08635046f, 0.05891928f, 0.00935747f, -0.21260686f, -0.14766262f, -0.08973135f, 0.16610697f, 
    0.01295200f, -0.00889470f, 0.02440227f, -0.00733503f, 0.08187155f, 0.03818667f, -0.04866665f, -0.07890842f, 
    0.20313159f, 0.00962835f, 0.07484679f, -0.05509458f, -0.14082263f, 0.02131693f, 0.09041793f, 0.12708560f, 
    0.02445900f, -0.03203604f, 0.03469349f, 0.13061465f, -0.13956754f, 0.17137796f, -0.05871183f, -0.10143790f, 
    -0.02374811f, 0.03897391f, 0.06542579f, -0.05633290f, 0.05377626f, 0.01200761f, -0.05763723f, -0.10087044f, 
    -0.00141166f, -0.00591279f, 0.07295909f, -0.09878215f, 0.08111095f, 0.00644057f, 0.15404272f, 0.09205968f, 
    -0.10024250f, -0.08084647f, 0.02352940f, 0.13654451f, -0.05111399f, -0.02179605f, -0.03281597f, 0.01479392f, 
    -0.04580452f, 0.09436984f, 0.06119370f, 0.03979327f, 0.02902002f, 0.00186423f, 0.00455817f, 0.03649788f, 
    0.01401298f, -0.02409376f, -0.02888465f, -0.05978137f, -0.12592997f, 0.15737708f, 0.02211793f, 0.05371589f, 
    0.09543339f, 0.15926041f, -0.02702688f, 0.02625293f, 0.14608900f, -0.02885934f, -0.14083798f, 0.12408008f, 
    -0.05638378f, 0.03595449f, -0.05711285f, 0.00254611f, -0.01993662f, -0.03988583f, -0.04981810f, -0.04880860f, 
    0.21785001f, -0.04711065f, -0.00375138f, -0.00412050f, -0.03331452f, 0.06539924f, -0.00354647f, 0.05201275f, 
    0.00180804f, 0.14625719f, 0.04053883f, 0.09191816f, 0.10789777f, -0.03775256f, 0.02440638f, -0.01210191f, 
    0.02393916f, 0.01527584f, 0.05856888f, -0.12377384f, 0.01698335f, -0.00246602f, 0.07021452f, 0.02304671f, 
    0.26449355f, 0.13414443f, 0.05191170f, 0.15688455f, -0.17509587f, -0.07401492f, -0.04884123f, 0.06048727f, 
    -0.01653628f, 0.02877207f, 0.00759931f, 0.00331498f, 0.14901043f, 0.12393198f, -0.03733356f, 0.01923067f, 
    -0.16182317f, -0.07053306f, 0.14167078f, 0.10033002f, 0.08820058f, 0.02372939f, -0.08223335f, 0.08207656f, 
    0.15531842f, 0.03608733f, 0.03269488f, 0.05941358f, 0.04477979f, 0.08191987f, -0.00242534f, -0.09274121f, 
    0.03572030f, -0.07498015f, -0.12568358f, -0.09348798f, 0.03674960f, -0.15541358f, -0.00178791f, 0.03326163f, 
    -0.04231004f, 0.01833911f, 0.06881543f, 0.06208209f, 0.01064694f, 0.10794320f, 0.06804594f, 0.06540715f, 
    0.07019357f, 0.03640918f, 0.04685935f, 0.09631673f, -0.08853502f, -0.01738651f, 0.00112623f, 0.01099302f, 
    0.10346790f, 0.03965080f, -0.10562503f, 0.03045702f, 0.26367092f, -0.01321330f, -0.07839288f, 0.05734987f, 
    -0.04992934f, 0.10447878f, 0.04625170f, 0.04987625f, -0.04602945f, -0.04560562f, 0.00282451f, -0.07083259f, 
    -0.00402169f, -0.00829536f, -0.07423815f, -0.04481748f, -0.13359325f, -0.03799707f, 0.12082434f, -0.00255748f, 
    0.01505535f, -0.04677621f, -0.01372597f, -0.00992524f, 0.12191167f, 0.00717596f, -0.03668858f, 0.03577211f, 
    -0.09543815f, 0.07856488f, 0.05801953f, 0.09563418f, -0.00726568f, 0.06555317f, 0.02605159f, 0.03878991f, 
    0.13540694f, -0.06708220f, 0.14482522f, -0.00689075f, -0.04317972f, 0.10508236f, 0.03323713f, 0.07246448f, 
    0.04300235f, -0.00241126f, -0.04996620f, 0.03359346f, 0.18446147f, 0.03659246f, 0.07689721f, 0.12452515f, 
    -0.10398082f, 0.09160047f, 0.10401613f, -0.04350229f, 0.06051559f, 0.00516750f, 0.09232227f, -0.02029242f, 
    -0.08016144f, -0.03342060f, -0.00241294f, -0.05267951f, 0.04856221f, -0.03727983f, 0.11348493f, 0.03661915f, 
    -0.03217785f, -0.03270737f, 0.03397873f, 0.07981703f, -0.00640922f, 0.02748197f, 0.17285189f, 0.35644156f, 
    -0.09964363f, -0.03121523f, 0.09638929f, 0.09324044f, -0.03164038f, 0.10969992f, 0.10513302f, 0.04497713f, 
    -0.16395281f, -0.09778452f, 0.01364512f, -0.04822424f, 0.02898402f, -0.00469882f, -0.07081632f, -0.07825379f, 
    0.02291357f, -0.05018596f, 0.09326270f, 0.13332190f, -0.02176827f, -0.01662832f, 0.02602147f, 0.04698783f, 
    0.03189604f, 0.07976446f, -0.03809701f, -0.00496029f, 0.07168315f, -0.05532363f, -0.02748728f, -0.11137013f, 
    0.04478951f, 0.04288990f, 0.07801529f, 0.22024262f, -0.07896582f, -0.01382168f, 0.11009476f, 0.05316797f, 
    -0.05761647f, 0.14241488f, 0.14707536f, 0.17981231f, -0.04878422f, 0.01642373f, 0.03771858f, -0.03274733f, 
    -0.04133775f, 0.11783643f, 0.06366773f, -0.03055598f, -0.03780597f, -0.04412531f, 0.13373378f, 0.06943461f, 
    0.01258582f, 0.00644515f, 0.02222820f, -0.01327015f, 0.02781614f, -0.02901473f, 0.01045347f, 0.03511660f, 
    -0.00574864f, -0.02586916f, 0.02788003f, 0.02797409f, 0.00925702f, 0.02280739f, -0.03973852f, 0.01199945f, 
    0.00080097f, -0.01975726f, 0.00818109f, -0.03217805f, 0.02622032f, 0.00139860f, -0.03127993f, -0.01311807f, 
    0.01220603f, -0.00625632f, -0.01925937f, -0.01466035f, 0.01745841f, 0.02341953f, 0.01050572f, 0.02001834f, 
    0.00298974f, 0.00794843f, -0.02621195f, -0.01867128f, -0.02918079f, 0.00922709f, 0.03674847f, -0.00910197f, 
    -0.02543600f, 0.02556721f, 0.02448250f, 0.00150588f, -0.00052801f, -0.00089234f, -0.03938115f, 0.02939393f, 
    -0.04111836f, 0.04005922f, -0.01732286f, -0.01187152f, -0.04135198f, -0.01777255f, -0.03511567f, 0.02193871f, 
    0.01540113f, -0.01212614f, 0.00632190f, -0.01010540f, -0.04121185f, 0.00250377f, -0.00707456f, 0.01390754f, 
    -0.01075728f, 0.00693089f, -0.00564516f, -0.01156783f, -0.01773090f, -0.01733271f, -0.01076430f, -0.04122045f, 
    -0.00596145f, 0.02884848f, -0.03374438f, 0.02750576f, -0.00362933f, 0.01316351f, -0.01283639f, 0.00963564f, 
    -0.01477630f, -0.00154967f, 0.01171178f, 0.03223316f, -0.00684301f, 0.02271518f, 0.01449983f, -0.03320482f, 
    -0.01702155f, 0.00020728f, -0.04187793f, -0.03337788f, -0.00349380f, 0.01018067f, -0.03648617f, -0.01721493f, 
    -0.00527875f, 0.02597510f, 0.02680799f, 0.01596414f, 0.01026785f, 0.01807397f, -0.03304127f, -0.00030244f, 
    0.02746494f, 0.00185948f, -0.02776891f, 0.01811917f, 0.00473987f, -0.01091088f, 0.00827784f, 0.01767950f, 
    0.01190269f, 0.02316653f, 0.02065511f, -0.03751351f, -0.00524821f, -0.03384883f, 0.01018695f, -0.00769544f, 
    -0.02619197f, 0.00315680f, -0.00658206f, -0.03293072f, 0.00275123f, 0.01777221f, -0.01870940f, 0.00655986f, 
    -0.01307497f, 0.02885788f, 0.02669565f, -0.01298375f, 0.03268821f, -0.00139761f, 0.00029291f, -0.02467741f, 
    -0.02760750f, -0.03518739f, 0.02174658f, 0.00482919f, -0.02595506f, 0.01441384f, 0.02301472f, -0.00650429f, 
    0.02881972f, -0.00004093f, -0.04058627f, -0.02779264f, -0.02310609f, -0.02965067f, 0.02385626f, -0.03403414f, 
    0.00461319f, -0.02088546f, -0.03945204f, -0.00140318f, -0.03503482f, -0.01861036f, 0.00812390f, -0.01903717f, 
    -0.01513423f, -0.03659388f, 0.01184110f, -0.01687643f, 0.02567539f, -0.02761810f, -0.00382154f, 0.02431788f, 
    -0.02830459f, 0.01220077f, 0.03175655f, 0.01335006f, -0.03896057f, -0.00871800f, -0.04200384f, -0.02137759f, 
    -0.03891181f, -0.00606313f, 0.03330589f, -0.02102653f, -0.02022637f, -0.01914561f, -0.01589053f, 0.00331439f, 
    -0.01619062f, -0.04089531f, 0.02348001f, 0.00031749f, -0.03282458f, -0.01830835f, -0.00167713f, -0.02761094f, 
    0.00807609f, -0.01506849f, -0.03684888f, 0.03006798f, -0.02369580f, -0.00791543f, -0.03422526f, -0.01617067f, 
    -0.00446673f, -0.04176308f, 0.03989951f, 0.02856227f, -0.01318452f, 0.01136000f, 0.01866858f, 0.00543197f, 
    -0.02913039f, -0.02994723f, 0.02605382f, -0.01125858f, -0.04010585f, -0.01112410f, -0.02361593f, 0.01613393f, 
    0.03216193f, -0.03603929f, 0.01539051f, 0.03308695f, 0.00350961f, 0.00216768f, -0.02969762f, -0.01549046f, 
    -0.02864623f, 0.00962248f, -0.01713733f, -0.00182015f, 0.03918601f, -0.01049653f, 0.02174152f, 0.03525573f, 
    -0.00912919f, 0.02621336f, -0.02909780f, 0.01718604f, 0.00939105f, 0.02013188f, 0.01058371f, 0.01901743f, 
    -0.01642417f, 0.02325537f, -0.02127730f, -0.01963469f, -0.01387994f, -0.00862013f, -0.02985260f, -0.00691381f, 
    0.02190309f, -0.02993882f, 0.00135428f, -0.03165754f, -0.01989050f, 0.01132254f, -0.00681795f, -0.03495590f, 
    -0.00261041f, -0.01046160f, -0.03349515f, -0.01941446f, -0.00591768f, 0.00215911f, -0.00126856f, 0.01347044f, 
    0.00063230f, 0.02751099f, -0.02730835f, -0.03066391f, -0.02000733f, 0.02873761f, -0.02662384f, -0.00796473f, 
    0.01518626f, -0.03568114f, -0.01852201f, 0.04013146f, -0.02148644f, 0.01698754f, -0.00629624f, 0.02193805f, 
    -0.01201001f, -0.00903501f, -0.00616666f, 0.01408864f, -0.02665586f, 0.00397952f, 0.01537641f, -0.03870472f, 
    0.02044732f, -0.00060115f, -0.01274540f, 0.00815525f, 0.01273525f, 0.02079388f, 0.02927144f, 0.00669017f, 
    0.02372171f, -0.01666494f, 0.01341319f, 0.02103975f, -0.02567404f, -0.00847287f, 0.01190727f, 0.00459911f, 
    -0.02613149f, -0.03363978f, 0.03153200f, -0.01710002f, 0.00368591f, -0.02685165f, -0.01636156f, -0.02711643f, 
    0.02566932f, -0.00548975f, -0.01300403f, -0.01900546f, -0.03258744f, -0.02731870f, -0.00106201f, -0.00408698f, 
    -0.01594653f, 0.00189076f, -0.03824475f, -0.00024197f, 0.02677713f, -0.00141455f, 0.02457776f, -0.03827967f, 
    -0.04191261f, 0.02681615f, -0.01518240f, 0.00618810f, -0.02258315f, 0.01547810f, 0.02079268f, 0.04065749f, 
    -0.00646390f, -0.00511279f, -0.00611473f, -0.02978879f, 0.02922295f, 0.02641926f, -0.03179443f, -0.00807152f, 
    0.01211967f, -0.01005705f, -0.00955779f, -0.00081396f, -0.00265074f, 0.02874934f, -0.01714775f, -0.03860132f, 
    -0.02941732f, -0.01626401f, -0.02022764f, 0.00805520f, -0.03088203f, 0.02483830f, -0.02168618f, 0.01201805f, 
    -0.01466050f, 0.03266402f, -0.02670983f, -0.03903073f, 0.01544181f, -0.01167653f, -0.00593201f, 0.01684813f, 
    -0.01862360f, -0.01432745f, -0.03544800f, 0.01227490f, -0.01582408f, 0.02857229f, -0.01825314f, -0.04122986f, 
    0.01911275f, -0.02541270f, -0.00910091f, 0.00037253f, -0.03120246f, 0.00563189f, -0.04140592f, -0.02715587f, 
    -0.00593461f, -0.02963469f, -0.04057592f, -0.02497403f, 0.00486384f, -0.03736496f, 0.02917671f, -0.02840523f, 
    0.02566620f, -0.03583578f, -0.01542449f, 0.01652641f, 0.00135727f, -0.00442215f, -0.02409912f, -0.00581550f, 
    -0.00241487f, 0.01902255f, 0.01041991f, -0.04065001f, -0.03968652f, 0.00874023f, 0.00100112f, 0.01025686f, 
    -0.01577355f, 0.01257846f, 0.02011984f, 0.02906565f, -0.03916511f, -0.04110676f, -0.03795479f, -0.03131130f, 
    0.02221719f, 0.00180918f, -0.02869289f, -0.03477269f, -0.00377927f, -0.01428979f, -0.02658056f, -0.03758483f, 
    -0.01269284f, -0.00012960f, -0.02249290f, 0.02630009f, -0.01062673f, -0.03913361f, -0.01960318f, -0.01159267f, 
    -0.00328679f, -0.00000794f, -0.03084543f, -0.02518876f, -0.01693912f, -0.02162147f, -0.03006521f, -0.00004494f, 
    0.00772815f, 0.00334994f, 0.02614336f, 0.01443722f, -0.00397494f, 0.01099937f, 0.02036471f, -0.00076098f, 
    -0.01382241f, -0.03415429f, 0.01860421f, -0.01150121f, -0.01320561f, 0.01525516f, -0.02929097f, 0.00013997f, 
    0.01188735f, -0.03069678f, 0.01253163f, 0.00071280f, -0.03558140f, -0.01780171f, -0.01377805f, -0.02995139f, 
    0.00936675f, 0.00581461f, -0.01870785f, 0.01176408f, 0.02084999f, -0.02729883f, 0.01588716f, 0.02385930f, 
    -0.03736010f, 0.00185673f, 0.01784219f, -0.03076735f, -0.00979048f, -0.00081491f, -0.00067625f, -0.01599937f, 
    -0.01522612f, -0.01361294f, 0.02102772f, 0.00058790f, -0.01483931f, -0.00448763f, 0.00203554f, 0.02184922f, 
    0.01273713f, 0.00359120f, -0.01732052f, 0.01187923f, -0.01482039f, -0.03187440f, -0.03601225f, -0.00571346f, 
    0.00571511f, 0.00178355f, 0.02511137f, 0.03655320f, -0.03461615f, -0.00087350f, 0.01191759f, -0.00745803f, 
    -0.02676963f, -0.00007294f, 0.02718547f, 0.01369923f, 0.01405061f, 0.02373040f, -0.01976446f, -0.00522965f, 
    -0.02935871f, -0.02435062f, 0.00930267f, 0.01495011f, 0.02628368f, -0.02732265f, 0.00450818f, -0.00343585f, 
    0.01563121f, -0.00741191f, -0.00462782f, 0.00193844f, -0.01749507f, -0.00844222f, -0.01233661f, -0.00001181f, 
    -0.01906590f, -0.00719428f, -0.00563456f, 0.02278157f, 0.02862416f, -0.03730937f, -0.03212902f, -0.03272646f, 
    0.01242901f, -0.02298230f, -0.03285199f, 0.00826940f, 0.00604831f, 0.00462575f, 0.00441185f, 0.01454719f, 
    0.02228706f, -0.02795320f, -0.01143582f, 0.02657936f, -0.01158829f, -0.01901296f, -0.01679601f, 0.01924524f, 
    -0.01606450f, 0.03539815f, 0.01501361f, 0.00127520f, -0.00390740f, -0.00887175f, 0.00089866f, 0.02903813f, 
    -0.03874584f, -0.03335792f, -0.01015428f, -0.01425669f, 0.00728582f, -0.01852214f, -0.00955033f, -0.00726005f, 
    0.00848491f, 0.00475853f, 0.01263728f, -0.01437361f, -0.04007397f, 0.01574185f, -0.02677578f, 0.00277656f, 
    0.01727108f, -0.01979869f, 0.00115563f, -0.00528191f, -0.02155772f, -0.00920107f, 0.00150497f, -0.02431848f, 
    -0.00465663f, 0.00328602f, -0.01101580f, 0.02390979f, 0.00389235f, -0.02230713f, -0.00167821f, 0.01343061f, 
    -0.03138395f, 0.02220793f, -0.00361957f, 0.01458809f, 0.01528092f, 0.00652350f, -0.02339357f, -0.01406981f, 
    0.02727260f, -0.04033279f, 0.03567781f, -0.03772512f, 0.00326275f, 0.01926789f, 0.00536138f, -0.01043156f, 
    0.00982868f, 0.03980357f, -0.01631434f, -0.02962948f, -0.02973195f, -0.04123555f, -0.00408572f, 0.02893942f, 
    -0.00791715f, -0.00617662f, 0.00313791f, -0.01243956f, -0.04114150f, -0.02859583f, -0.02790171f, -0.01030485f, 
    -0.03118310f, -0.03729347f, 0.01204776f, -0.00966101f, 0.03442369f, -0.03957333f, 0.01376075f, -0.02459124f, 
    0.00063612f, 0.02447838f, -0.02670917f, 0.00978423f, 0.02225311f, -0.00433562f, -0.01395407f, 0.01754029f, 
    0.00308058f, 0.02525537f, -0.00601736f, -0.03821209f, -0.02326026f, -0.01740408f, 0.01903856f, 0.02672090f, 
    0.03699399f, -0.01930640f, 0.01067894f, 0.01650600f, 0.02258169f, -0.00627521f, -0.01148490f, -0.00925267f, 
    -0.00692199f, 0.00745373f, 0.03006288f, -0.01007297f, -0.00010678f, 0.02573907f, 0.02779105f, 0.00432104f, 
    -0.01429225f, 0.00661867f, 0.00874292f, -0.02462389f, 0.01118095f, -0.01692558f, -0.01949766f, -0.00572921f, 
    0.02290705f, -0.00716288f, 0.01991082f, 0.01025543f, 0.01009403f, -0.01792231f, -0.02781009f, -0.02770578f, 
    0.01930324f, 0.00492931f, 0.03143480f, 0.00875243f, 0.01964385f, 0.00349837f, 0.01562036f, 0.01820655f, 
    0.02360936f, 0.02618102f, -0.00932369f, -0.01363411f, -0.00247954f, 0.00868348f, 0.02581370f, 0.01880423f, 
    -0.00179141f, -0.00400859f, 0.00737165f, 0.02284494f, -0.01585769f, 0.02750552f, 0.01645264f, 0.01697631f, 
    0.00078405f, -0.03616457f, -0.01835141f, -0.00893660f, -0.01996535f, 0.01675584f, -0.01786182f, -0.00795475f, 
    -0.03836116f, 0.02461922f, -0.04020926f, -0.00583174f, -0.02372467f, 0.00762144f, -0.01182651f, 0.00653612f, 
    0.02874194f, 0.01461857f, -0.01248992f, -0.01445495f, -0.00148022f, -0.03402385f, 0.02631910f, 0.02646144f, 
    -0.04020524f, -0.03994347f, 0.00974824f, 0.00051037f, -0.01703344f, -0.01802353f, 0.00645187f, -0.01929610f, 
    0.02173246f, -0.02676295f, 0.00493867f, -0.02251888f, 0.02375133f, 0.03001382f, 0.01725981f, 0.01281954f, 
    -0.03994378f, 0.00509516f, 0.01853890f, 0.00686484f, -0.00527465f, 0.02887327f, 0.01764769f, -0.00902903f, 
    -0.03243541f, -0.02510073f, 0.00794069f, 0.04029899f, 0.00996678f, -0.03770529f, -0.02060363f, -0.01739006f, 
    -0.01354667f, -0.00670681f, -0.00559590f, -0.00754048f, -0.03734730f, -0.02554464f, -0.01984092f, 0.00260451f, 
    -0.15384603f, 0.04472594f, 0.03886406f, -0.08048724f, 0.01547136f, -0.07077704f, -0.04323149f, -0.17874910f, 
    0.04526517f, 0.03281854f, 0.02650426f, 0.05394620f, 0.29454669f, 0.06137258f, -0.05637446f, -0.11489027f, 
    0.11817452f, 0.08282284f, -0.03231804f, 0.02506139f, 0.01102981f, -0.06856328f, 0.03069855f, -0.09447639f, 
    -0.06211130f, 0.01976898f, 0.00442643f, 0.11414605f, -0.00519208f, -0.04934837f, 0.02167547f, 0.00338292f, 
    -0.09647033f, 0.03588456f, 0.02981725f, 0.03696679f, -0.06183999f, 0.02540744f, 0.11262769f, 0.07193550f, 
    0.07274534f, -0.08675738f, 0.06376411f, 0.01247619f, 0.07734637f, -0.01578723f, -0.00419547f, 0.01511012f, 
    0.02775011f, -0.05222584f, 0.16677573f, 0.16679518f, -0.02173872f, -0.03740497f, -0.01728942f, -0.07550175f, 
    0.00528978f, -0.03664975f, 0.08833674f, 0.07719099f, -0.12341364f, 0.15269718f, -0.06757131f, 0.04670379f, 
    0.07804283f, 0.11140773f, 0.01706215f, -0.02745251f, -0.03823252f, 0.01970910f, -0.02884083f, -0.04823756f, 
    0.41036600f, 0.03604495f, 0.05052666f, 0.01045475f, -0.01176038f, 0.03611692f, 0.01412562f, 0.00490000f, 
    0.03967187f, -0.05613328f, -0.00310100f, 0.06897933f, 0.14745942f, -0.05393343f, -0.16322148f, 0.23002014f, 
    -0.01033775f, 0.05279410f, -0.04995538f, 0.03690432f, -0.04619451f, -0.07145178f, 0.07484179f, -0.07870288f, 
    0.00946270f, 0.04450913f, 0.10008213f, 0.14339939f, 0.08195557f, -0.02327086f, 0.04415524f, 0.01704339f, 
    -0.01869612f, -0.04244092f, -0.07697646f, -0.01623404f, -0.05495850f, 0.20035154f, 0.01784902f, 0.03586078f, 
    -0.01588283f, -0.00336793f, -0.00726435f, -0.08719291f, -0.07066341f, 0.10566404f, -0.08395609f, -0.05706358f, 
    0.07722614f, -0.04225748f, 0.07754724f, -0.05122996f, -0.00773881f, -0.04924887f, -0.10362203f, -0.05643161f, 
    -0.06169874f, -0.00979922f, 0.00211661f, 0.04683400f, 0.19354402f, -0.16155714f, -0.10273965f, 0.15582892f, 
    -0.04113349f, -0.04028941f, -0.03109515f, 0.04068876f, -0.02414955f, -0.05245842f, -0.08051632f, 0.04739447f, 
    -0.01614288f, -0.04880099f, 0.07750265f, 0.07959657f, -0.17906058f, -0.09400730f, 0.02021395f, -0.03042202f, 
    -0.09070893f, -0.03048114f, 0.05492945f, 0.02822891f, -0.27205479f, 0.11198677f, -0.00830065f, -0.05737401f, 
    0.13197139f, 0.11865809f, -0.14792325f, -0.09952059f, -0.00673675f, -0.03072170f, 0.02151413f, 0.01286114f, 
    0.03770054f, 0.00992850f, 0.05316574f, 0.30558640f, 0.06758099f, -0.01994740f, 0.09859066f, -0.01250530f, 
    0.04098365f, 0.02650463f, -0.07369480f, -0.03599725f, 0.01477607f, -0.12900956f, -0.10716783f, 0.10784511f, 
    -0.04066234f, -0.02196345f, -0.06228850f, -0.02267577f, 0.00788085f, 0.01531093f, 0.03157557f, 0.05044111f, 
    -0.03763673f, -0.01735241f, 0.01127147f, -0.01420826f, 0.03545006f, -0.06916339f, -0.00159176f, 0.05489668f, 
    -0.03337561f, 0.03766376f, -0.02037525f, 0.12223285f, 0.20775844f, 0.15528631f, -0.09391354f, -0.10411046f, 
    0.04401785f, 0.03279689f, 0.00332145f, 0.00603091f, 0.02831974f, -0.07538708f, 0.06944703f, -0.01861419f, 
    -0.06336355f, -0.06211325f, 0.07178007f, -0.01450215f, -0.11300680f, 0.02306041f, 0.00396708f, 0.09684938f, 
    0.11125172f, 0.05028172f, 0.04773735f, 0.18330772f, -0.12435541f, 0.16347767f, -0.07781468f, 0.03950645f, 
    -0.17243831f, 0.09174471f, 0.06392065f, 0.05088523f, 0.02240525f, 0.09187020f, 0.13697302f, 0.08937334f, 
    0.07371747f, 0.04101900f, 0.04163400f, -0.00460278f, 0.08387786f, -0.00261440f, -0.05140996f, -0.15356340f, 
    0.07706615f, -0.10881176f, -0.00989597f, 0.00959972f, 0.12480673f, 0.06785174f, 0.04429947f, 0.12808128f, 
    -0.07157144f, -0.10432309f, -0.03806796f, 0.00393640f, -0.00611538f, 0.01431184f, -0.03220952f, 0.00138703f, 
    0.08312544f, 0.05266201f, 0.05794418f, 0.09525888f, -0.03280494f, 0.02317631f, 0.01343832f, 0.04788224f, 
    -0.04528518f, 0.05255592f, 0.06298300f, 0.02124103f, -0.37180939f, 0.05805431f, 0.16468586f, -0.13217495f, 
    0.00300692f, -0.05302626f, 0.04148168f, -0.03099487f, -0.02916313f, -0.03966371f, -0.00597053f, -0.00333323f, 
    -0.16777796f, -0.03001925f, -0.01798410f, 0.03941507f, -0.07031126f, 0.04136892f, 0.07409239f, -0.03078254f, 
    -0.02624208f, -0.04479756f, -0.07157236f, 0.12880124f, 0.04059495f, 0.10237233f, -0.10490228f, 0.14399876f, 
    -0.06604785f, 0.04528889f, -0.00010863f, -0.05918523f, 0.02349216f, 0.03150583f, 0.00161697f, 0.06235813f, 
    0.23207675f, -0.11467254f, -0.09586113f, 0.06205172f, -0.04259075f, -0.10495625f, -0.01353030f, 0.00470870f, 
    -0.10554040f, -0.04810420f, -0.10543022f, 0.16809827f, -0.01188434f, 0.04333035f, 0.31873265f, 0.07413457f, 
    0.01662747f, -0.12040967f, 0.15788475f, 0.10404326f, -0.00808317f, 0.06378634f, 0.09321322f, -0.01186368f, 
    0.00556475f, -0.05217419f, -0.12508072f, 0.04060233f, -0.03149735f, -0.00580412f, 0.00288654f, 0.01258394f, 
    0.09268296f, -0.00077539f, -0.04591963f, -0.03187019f, -0.10747141f, 0.24091573f, 0.11825407f, -0.05278420f, 
    -0.04463087f, 0.03566136f, -0.08937208f, -0.20569538f, -0.02807350f, -0.09367846f, -0.05010008f, -0.12724836f, 
    0.07024696f, 0.08019396f, 0.05829838f, -0.09357267f, 0.01396726f, -0.00691240f, 0.02750537f, -0.10705250f, 
    0.11731462f, 0.12425540f, 0.11929934f, 0.06215953f, 0.13849442f, -0.00542252f, -0.03509711f, 0.07589090f, 
    0.04561590f, 0.04454532f, 0.03984196f, 0.00148836f, -0.00892455f, 0.04453769f, -0.01496720f, -0.02587292f, 
    -0.11283027f, -0.10343660f, 0.33050939f, 0.31618434f, -0.01606760f, -0.10384800f, -0.03349022f, -0.00007248f, 
    0.05474236f, 0.02610655f, 0.11110707f, -0.03263360f, 0.16184109f, -0.04440341f, 0.05788959f, 0.13022402f, 
    -0.02339418f, 0.00053963f, 0.04380907f, -0.02154065f, -0.04130717f, 0.01863608f, 0.09927066f, 0.03184930f, 
    -0.30659580f, 0.01065831f, 0.10646472f, 0.05137082f, 0.05620762f, 0.02804060f, -0.03806863f, 0.07646143f, 
    -0.09266329f, 0.03655275f, -0.01285731f, -0.03833020f, -0.05420756f, 0.06853580f, 0.00677816f, 0.12865025f, 
    -0.07216958f, 0.02296874f, 0.06331170f, 0.03586024f, 0.06567452f, 0.02363696f, 0.04402103f, 0.07721069f, 
    -0.03538141f, 0.00850512f, 0.02000889f, 0.00682924f, 0.13644563f, 0.07413111f, 0.10290207f, 0.08475947f, 
    0.08204325f, 0.12402380f, -0.05956553f, 0.01601467f, -0.17179322f, -0.01330303f, 0.20754959f, 0.18264554f, 
    0.01209004f, -0.00177369f, -0.06186362f, 0.07449847f, -0.12861513f, 0.00742244f, 0.04045008f, 0.04332566f, 
    -0.49205360f, 0.12108151f, 0.08137566f, -0.21350561f, 0.07819767f, 0.04955740f, -0.04376469f, 0.15108530f, 
    0.09182752f, 0.07459719f, -0.07932344f, -0.00887183f, -0.21864060f, -0.17175059f, 0.06434336f, 0.01927921f, 
    -0.04055554f, -0.04566891f, 0.02699449f, -0.02608907f, 0.04333444f, 0.00774674f, -0.07517122f, 0.05793895f, 
    -0.24831383f, 0.11111383f, 0.18782422f, 0.18027429f, 0.06875205f, -0.02024976f, 0.02526802f, -0.05220031f, 
    -0.03057339f, 0.06293114f, 0.06203065f, -0.02164852f, -0.09446235f, -0.03830638f, 0.14314832f, 0.10212962f, 
    -0.00378682f, 0.06781950f, 0.02242798f, 0.00563394f, -0.06382444f, -0.01816326f, 0.05885655f, 0.08047105f, 
    0.15501805f, -0.12990022f, -0.03705341f, -0.18580818f, 0.06416549f, -0.02624110f, -0.08496066f, -0.08283292f, 
    -0.06479854f, 0.03736854f, 0.05103287f, -0.08280327f, -0.23177235f, 0.27427229f, 0.12703653f, -0.00330615f, 
    0.12387622f, 0.03734509f, 0.01513500f, 0.09195993f, -0.05734649f, -0.02275282f, -0.04564146f, -0.04492001f, 
    0.11091857f, 0.06758106f, 0.12687361f, -0.01259036f, -0.07153239f, -0.05283474f, -0.05944322f, -0.04769876f, 
    0.03486052f, 0.04247948f, 0.01401124f, -0.03296430f, 0.18508528f, 0.10069150f, -0.10308507f, 0.01010778f, 
    -0.09609783f, 0.08905979f, -0.04233766f, -0.02067730f, -0.01815236f, 0.02623099f, -0.03065281f, 0.04417411f, 
    -0.10583085f, -0.01023204f, 0.02233166f, 0.11580892f, -0.12264857f, -0.13460390f, -0.05683773f, -0.01945584f, 
    -0.05359486f, -0.04092987f, 0.00225181f, -0.03702837f, -0.03435326f, -0.12319443f, 0.03017847f, -0.07853873f, 
    -0.03642953f, 0.01922307f, -0.00759515f, 0.06052671f, -0.03529665f, -0.05219881f, 0.04571200f, -0.07568956f, 
    -0.04561380f, -0.00270713f, -0.03044595f, 0.04693841f, 0.05737718f, 0.10977049f, 0.01559584f, 0.04449354f, 
    0.03963777f, -0.07263041f, 0.00195732f, 0.01274041f, -0.01187481f, -0.01198762f, -0.06598166f, 0.09702943f, 
    0.10564557f, 0.09161962f, 0.00079997f, 0.02880699f, -0.07392076f, 0.02121617f, 0.03160555f, 0.01446722f, 
    0.00695489f, 0.09906854f, 0.02159936f, 0.10532149f, 0.00842297f, -0.08725824f, 0.14599806f, -0.05650732f, 
    0.05298881f, 0.13170399f, 0.05143470f, 0.17179027f, 0.32817668f, 0.17629497f, 0.02142326f, -0.13309282f, 
    -0.07329389f, 0.02030979f, -0.02142556f, -0.01777769f, 0.01421041f, 0.02269044f, -0.09301450f, -0.00665392f, 
    -0.19512953f, -0.12105557f, 0.02566260f, 0.04186621f, 0.05365299f, 0.07098100f, 0.04370091f, 0.04521865f, 
    0.07611475f, -0.06053915f, 0.06415147f, 0.09063202f, -0.00359447f, 0.06105868f, 0.08269697f, -0.02199394f, 
    -0.07771315f, -0.03083472f, -0.04458023f, 0.02656844f, -0.02854117f, 0.02051259f, -0.01037179f, -0.06056898f, 
    -0.13830321f, 0.11563858f, 0.02610217f, 0.12891752f, 0.06035696f, 0.11518348f, -0.03957418f, -0.00589836f, 
    0.03978580f, -0.02088025f, 0.09041402f, 0.02896497f, 0.06884483f, 0.20129037f, 0.17921293f, -0.00797421f, 
    0.15115012f, -0.01899390f, -0.02235841f, -0.13302208f, 0.05169617f, 0.00223036f, 0.00266377f, 0.05233593f, 
    0.08767454f, 0.08923000f, 0.10652874f, 0.01960655f, -0.18455465f, 0.06191785f, -0.03125903f, -0.09649615f, 
    -0.03116816f, -0.04999208f, 0.08075106f, -0.00687325f, -0.08870528f, 0.10647780f, 0.09882768f, -0.00818168f, 
    -0.04504643f, -0.04774592f, -0.00859347f, -0.00930275f, 0.01967146f, -0.00125662f, 0.02301308f, -0.04040263f, 
    -0.28001407f, 0.15901281f, 0.07448084f, -0.08072846f, 0.05371947f, 0.04594291f, -0.08364093f, 0.07141314f, 
    0.05082650f, 0.00129695f, -0.05248377f, 0.01548398f, 0.30711240f, -0.06262663f, -0.05730055f, -0.07499729f, 
    -0.03759339f, 0.07306624f, -0.04485449f, -0.05552921f, 0.01137207f, -0.04405751f, 0.03237669f, -0.14732093f, 
    -0.00537666f, 0.30254027f, 0.09501595f, -0.16696312f, 0.10122613f, 0.06624152f, 0.12253124f, 0.00133998f, 
    -0.02742275f, -0.01528860f, 0.03353899f, -0.05078910f, -0.01712990f, -0.08091772f, -0.00740667f, 0.20606506f, 
    -0.04549443f, -0.07840595f, -0.02514046f, 0.06745966f, -0.00175753f, 0.09888472f, 0.01417752f, 0.10316508f, 
    0.13585952f, -0.05649119f, 0.06497373f, 0.06061915f, -0.08999740f, -0.02344357f, -0.06430516f, 0.04525289f, 
    0.04572860f, -0.05390581f, -0.12090898f, -0.09384718f, -0.06452695f, 0.00124207f, -0.02330149f, 0.22621098f, 
    0.08784006f, -0.12804376f, -0.00000823f, 0.06971534f, 0.06614130f, 0.00605089f, -0.14603749f, -0.04447498f, 
    -0.01740928f, 0.00426390f, -0.01218915f, -0.02546135f, -0.03597186f, -0.02561009f, 0.01696466f, -0.00744237f, 
    0.02834108f, -0.01087152f, 0.00365329f, -0.02881538f, -0.03333198f, -0.02647024f, -0.00255341f, -0.03141074f, 
    -0.00573263f, 0.00484313f, 0.01063046f, 0.01257238f, -0.02299692f, -0.01893162f, 0.00346868f, -0.02790538f, 
    -0.01710557f, 0.00588745f, -0.04029108f, 0.01059806f, 0.02056879f, 0.00705422f, 0.01545157f, 0.02755128f, 
    0.00872840f, 0.02430575f, 0.01280671f, -0.01828994f, 0.01127304f, 0.01032745f, 0.02162317f, -0.03100942f, 
    0.01221118f, 0.02379088f, -0.01012160f, 0.02410736f, 0.01580162f, 0.02423731f, -0.02107694f, 0.00459842f, 
    -0.02627156f, 0.03019662f, 0.01825102f, -0.02398647f, -0.03648865f, -0.01673252f, -0.02336404f, -0.01123634f, 
    -0.02246259f, 0.00540103f, 0.03464820f, 0.01122137f, 0.01669338f, -0.00138084f, -0.00211183f, -0.00089987f, 
    -0.02106481f, 0.01311920f, 0.02298508f, -0.03495025f, -0.02485563f, -0.00472597f, 0.00788424f, -0.01407955f, 
    -0.02621102f, 0.01735822f, 0.00195440f, 0.02597431f, 0.00619084f, -0.03744131f, -0.03333106f, 0.00057411f, 
    -0.01367095f, -0.01909065f, 0.00547889f, 0.01617740f, 0.00315183f, -0.02287946f, -0.01367107f, 0.01597149f, 
    -0.01800888f, 0.01147869f, -0.01124202f, 0.00999217f, 0.01816490f, 0.01908910f, 0.02867289f, -0.03921889f, 
    -0.04058313f, 0.01759675f, 0.00690835f, 0.00557953f, 0.01548759f, 0.00888456f, -0.00734972f, -0.01484380f, 
    0.01563998f, 0.00345097f, 0.00761260f, 0.01929406f, -0.02646705f, -0.03805377f, -0.00517529f, -0.01768607f, 
    -0.00338337f, 0.00033675f, 0.00955100f, 0.00650245f, 0.01018376f, 0.00857622f, -0.02316137f, -0.02335718f, 
    -0.02225177f, -0.00855634f, -0.02418064f, 0.02386253f, -0.03282229f, -0.01633996f, -0.03473604f, -0.04023603f, 
    -0.01396835f, -0.03289295f, 0.02245452f, 0.01263075f, -0.01405760f, -0.01813639f, 0.02317937f, -0.00633005f, 
    -0.01197531f, -0.00199669f, -0.04124179f, -0.01462757f, 0.01017946f, -0.02408774f, -0.02864542f, -0.00389710f, 
    0.02436448f, 0.00649549f, 0.01256288f, -0.02778790f, 0.00727488f, -0.02124189f, -0.00603269f, -0.01109718f, 
    -0.02350047f, 0.02635556f, -0.02301852f, 0.00786255f, -0.02875021f, -0.03182365f, 0.00913231f, -0.01730185f, 
    0.01817172f, -0.03558270f, 0.00592169f, -0.00222018f, -0.01413459f, -0.02448899f, -0.00324872f, -0.01466884f, 
    -0.00369201f, -0.01102723f, -0.01841315f, 0.01746705f, -0.01405945f, 0.01597776f, -0.03631463f, 0.00799045f, 
    0.03036792f, -0.03146099f, 0.01030067f, -0.01538523f, 0.02066423f, 0.00957016f, -0.01781651f, -0.01951901f, 
    0.00008696f, 0.01143860f, -0.00943799f, 0.00072308f, 0.00700196f, -0.00973205f, -0.01790557f, -0.02419131f, 
    -0.03830685f, -0.03787758f, 0.00653169f, -0.01910753f, -0.00093887f, 0.00404347f, 0.00927426f, -0.01858394f, 
    -0.00126957f, -0.00659394f, 0.02764543f, -0.01209771f, 0.01687735f, 0.01972517f, -0.01806900f, -0.02351223f, 
    0.02925129f, -0.02480224f, -0.04055149f, -0.00591780f, 0.01503488f, 0.02002227f, -0.03996931f, -0.01104796f, 
    -0.02393248f, 0.03052971f, -0.02954298f, -0.02443593f, 0.01729118f, 0.00016664f, -0.03750177f, 0.00689425f, 
    -0.02739302f, 0.01578075f, -0.03194978f, -0.01362821f, 0.03523389f, 0.02649214f, 0.00417395f, -0.01720847f, 
    0.00255560f, -0.00317314f, 0.01741640f, -0.03146183f, -0.01766156f, -0.03358053f, 0.01367042f, -0.00628895f, 
    -0.02228673f, -0.03435344f, -0.02236678f, -0.02212179f, 0.02872132f, -0.02047784f, 0.00365884f, -0.01442477f, 
    0.01371616f, -0.03393031f, -0.03396245f, 0.00381579f, -0.00690192f, -0.00316597f, -0.00345774f, -0.00719480f, 
    -0.00987129f, 0.03128139f, -0.03720795f, -0.00802564f, -0.01030239f, -0.04048047f, 0.01028815f, 0.01173187f, 
    -0.03518125f, 0.00589235f, 0.00087062f, -0.00813638f, -0.03525433f, -0.00282706f, 0.03038236f, 0.00802588f, 
    -0.03774381f, -0.01856615f, 0.02679386f, -0.04069532f, -0.02423847f, -0.00532741f, -0.02753798f, -0.01987446f, 
    -0.01975111f, 0.02743686f, -0.03001915f, -0.00803503f, -0.02959615f, 0.00405184f, 0.01150335f, -0.02822027f, 
    0.00589230f, 0.00362790f, -0.01301470f, 0.02875059f, -0.01976537f, 0.01290768f, -0.02335070f, 0.02420705f, 
    -0.03983114f, 0.00555551f, 0.02424873f, -0.02835050f, 0.01208727f, -0.02635812f, 0.02827599f, -0.03182889f, 
    -0.01511497f, -0.02961679f, -0.03868834f, -0.00643107f, -0.02063459f, -0.00221721f, 0.02163850f, 0.02185529f, 
    -0.01663572f, -0.00042390f, -0.03440388f, -0.00352024f, -0.00044893f, 0.00515959f, -0.03860692f, -0.00009756f, 
    0.00882875f, -0.02034131f, -0.01644610f, 0.00366301f, 0.00232334f, 0.01847393f, -0.00931105f, 0.02528675f, 
    -0.01443622f, -0.03345374f, 0.00837707f, -0.02649226f, 0.01725854f, 0.01256320f, 0.01451008f, 0.01257337f, 
    -0.02941006f, -0.03833916f, 0.00793478f, -0.02790207f, -0.00420666f, 0.00382818f, -0.03001982f, -0.02868211f, 
    0.02453384f, -0.02222608f, -0.03480686f, 0.01600272f, -0.00698118f, -0.02349108f, -0.00110465f, -0.03431999f, 
    -0.00221979f, 0.02221485f, -0.00810488f, -0.03049674f, 0.02814608f, -0.01797743f, 0.02389210f, -0.00876969f, 
    0.00586998f, 0.00086472f, -0.02110011f, 0.00843930f, 0.01209496f, -0.01334273f, 0.00380657f, -0.02152810f, 
    -0.00575448f, -0.02946991f, -0.03678946f, -0.03838246f, 0.00047125f, -0.01247752f, 0.00208280f, -0.00840953f, 
    0.02947269f, -0.03499372f, 0.01447670f, -0.00419976f, -0.01120802f, 0.02943458f, 0.02912806f, -0.03727600f, 
    0.01010790f, 0.01164873f, -0.03656339f, -0.03087624f, -0.00954351f, -0.01432390f, -0.00169316f, -0.02221846f, 
    0.02593476f, 0.01303388f, -0.00540669f, -0.02957286f, -0.03993513f, -0.01535110f, 0.02593252f, -0.00396898f, 
    -0.03116232f, 0.02918968f, -0.01826901f, -0.02960120f, -0.01272743f, 0.01595313f, -0.00025586f, 0.02205486f, 
    -0.00331096f, 0.00005237f, -0.03574138f, -0.01005978f, 0.01022681f, -0.03688658f, 0.00323658f, 0.01833034f, 
    0.01038286f, -0.02182832f, -0.02491016f, -0.03132682f, 0.00809548f, -0.02992973f, -0.02840949f, -0.03502415f, 
    -0.00530131f, -0.02305724f, -0.01506380f, 0.01229073f, -0.00636498f, -0.01061989f, 0.02359026f, -0.03279133f, 
    0.03276550f, 0.02022327f, 0.00713010f, 0.02758102f, -0.02358876f, -0.01783667f, 0.00803754f, -0.00523111f, 
    -0.03998452f, -0.02134046f, 0.01416214f, -0.01341630f, 0.00296155f, 0.02895104f, 0.00899166f, -0.03064558f, 
    -0.01898972f, -0.03640830f, 0.01169774f, -0.03656275f, -0.03366916f, -0.01662045f, 0.03042416f, 0.02074024f, 
    -0.01535955f, -0.03910961f, -0.03061768f, -0.02099308f, -0.02484328f, -0.00762552f, 0.01843338f, -0.03668885f, 
    -0.00757160f, 0.01475582f, -0.01720221f, 0.02107087f, -0.01705706f, -0.01043275f, -0.01842024f, -0.02791520f, 
    0.00967801f, -0.00294947f, -0.03203004f, -0.03777269f, 0.01873727f, 0.01171678f, 0.01594757f, 0.00960588f, 
    -0.02944851f, -0.00980986f, 0.02827043f, 0.00556560f, 0.01019197f, 0.00223052f, 0.02692076f, -0.03125872f, 
    -0.00353821f, -0.03061166f, 0.03159754f, -0.00409610f, 0.00788259f, -0.02686902f, -0.03102925f, -0.03852948f, 
    -0.01181865f, -0.00988691f, -0.00655941f, 0.01508809f, -0.02397929f, -0.00735042f, -0.02338134f, -0.00077760f, 
    -0.02804301f, -0.03494575f, -0.01736603f, 0.02012054f, 0.01833460f, -0.03454743f, 0.01403398f, 0.02527728f, 
    -0.00210739f, -0.01744311f, 0.01107278f, -0.01862551f, 0.02586607f, -0.03048318f, 0.01321411f, -0.02435442f, 
    -0.02422157f, 0.00547863f, -0.00637563f, -0.00389685f, 0.02129502f, -0.01243669f, -0.00387951f, -0.03962276f, 
    0.01045974f, 0.01749826f, -0.02388912f, -0.02881019f, -0.02351275f, -0.01497283f, 0.02040847f, -0.03129023f, 
    -0.00592438f, 0.00833785f, 0.02512223f, -0.02509289f, -0.03106395f, -0.01586946f, 0.00543411f, 0.01792096f, 
    0.00044265f, -0.03420793f, -0.03334823f, -0.01588142f, 0.01855042f, -0.02494722f, -0.03328172f, 0.00229287f, 
    0.02216223f, 0.02383809f, -0.03503154f, -0.03652498f, 0.03039641f, -0.01096976f, 0.00154674f, 0.00169957f, 
    -0.01305747f, 0.01383565f, -0.02182608f, 0.01191339f, -0.03297609f, 0.01294267f, 0.03062998f, 0.02919023f, 
    -0.00748928f, -0.01510983f, 0.00522960f, -0.01775908f, 0.01861712f, -0.02270846f, -0.02223646f, -0.03908157f, 
    0.01476780f, -0.02290859f, 0.01783878f, 0.01840276f, 0.03567717f, -0.03308148f, 0.01648914f, -0.02186417f, 
    -0.01025192f, 0.01601574f, -0.02648850f, -0.00617144f, -0.03251223f, 0.00338213f, -0.00732649f, -0.01728177f, 
    0.01715151f, -0.00853027f, 0.01806765f, -0.03006519f, 0.01541241f, 0.02981640f, 0.01848449f, -0.00124938f, 
    -0.04036311f, -0.04063245f, -0.01829131f, -0.01007175f, -0.03735466f, -0.00858676f, -0.01117389f, -0.01864029f, 
    -0.02817608f, 0.03060375f, -0.01737834f, -0.00527148f, 0.02412294f, 0.01862104f, -0.01484770f, -0.02015814f, 
    -0.00813504f, -0.01260732f, -0.02518735f, 0.01214450f, 0.01266372f, -0.02566886f, 0.00548285f, 0.00656674f, 
    -0.01060547f, 0.03056657f, -0.01733536f, -0.03245508f, 0.00351264f, -0.03206924f, 0.02989928f, 0.00376214f, 
    0.00128687f, -0.02843654f, 0.02410928f, -0.03537194f, 0.02570832f, -0.03744655f, -0.02835196f, 0.02876836f, 
    0.01433335f, 0.01588758f, -0.01311888f, -0.04030623f, -0.02757879f, -0.00505675f, -0.03557806f, -0.04127101f, 
    0.00685712f, 0.02387647f, 0.01392278f, 0.02613159f, -0.04091457f, -0.03061561f, -0.00463596f, -0.02336446f, 
    0.00170717f, 0.00113785f, 0.01909305f, 0.02480410f, -0.02012531f, 0.01957764f, -0.02676564f, -0.00490278f, 
    -0.03015017f, -0.00151968f, -0.01582151f, 0.00055332f, -0.02264621f, 0.02493410f, 0.02321472f, -0.00953205f, 
    -0.03893785f, -0.02255085f, -0.01979167f, 0.01976080f, -0.01855116f, 0.00836912f, -0.00552229f, -0.02004355f, 
    0.00424433f, -0.00092902f, -0.03140864f, -0.01746553f, -0.00213840f, 0.00791681f, -0.01012093f, 0.00906611f, 
    -0.00910440f, 0.00884337f, 0.03248100f, 0.01960139f, -0.02896242f, 0.01904180f, 0.02634432f, -0.02900814f, 
    -0.02540341f, 0.02468336f, 0.01247928f, -0.02003271f, 0.01847478f, 0.01188537f, 0.00708782f, -0.00746020f, 
    -0.00686485f, 0.02858634f, -0.04059364f, 0.00724273f, -0.03988651f, 0.01401571f, -0.01847244f, 0.02708561f, 
    0.01145897f, -0.01548786f, -0.01465829f, 0.02796159f, -0.00755198f, 0.02350252f, -0.01518840f, -0.01028477f, 
    0.00861700f, -0.03919114f, -0.03306041f, -0.02571817f, -0.00458890f, -0.02405779f, -0.03084880f, -0.01353777f, 
    -0.00680050f, -0.03311637f, -0.03079339f, -0.00024307f, 0.02012254f, -0.01047059f, 0.00606124f, 0.02272260f, 
    -0.03909050f, 0.00345248f, 0.00399560f, -0.03193269f, 0.00161050f, -0.01752451f, -0.00649348f, 0.01412803f, 
    0.01889674f, -0.01459243f, -0.00123739f, 0.02127504f, -0.00007506f, 0.02065382f, 0.02354212f, -0.01392835f, 
    -0.02194706f, 0.02319387f, 0.02053767f, 0.00838345f, 0.02637217f, -0.01724888f, -0.03913918f, 0.00744379f, 
    -0.01606179f, -0.00686835f, 0.01874420f, 0.01086265f, 0.01292843f, -0.03596092f, -0.03483485f, -0.00973429f, 
    -0.01588588f, -0.13202418f, -0.06330558f, -0.01084880f, 0.08461819f, -0.09197389f, 0.07666262f, 0.11207732f, 
    -0.02381011f, -0.05148321f, -0.05978699f, 0.07817589f, -0.03943400f, 0.04418129f, 0.12901333f, -0.04013724f, 
    -0.03927390f, 0.02438085f, 0.08924336f, 0.17530559f, -0.10150500f, 0.05823761f, -0.12245440f, 0.10472780f, 
    -0.17038628f, 0.15769577f, -0.21070059f, -0.25211883f, 0.19774775f, 0.07212424f, -0.13858820f, -0.05172637f, 
    -0.04587371f, -0.04204090f, -0.01650259f, 0.00245207f, 0.34867784f, -0.12974229f, -0.09591649f, 0.09551816f, 
    -0.12553863f, 0.01194103f, -0.02033167f, 0.18715328f, 0.05527375f, 0.10985796f, 0.03110796f, 0.06388524f, 
    -0.09685820f, 0.14467855f, -0.17232975f, 0.06776308f, 0.02556905f, 0.01282513f, 0.01042113f, 0.05520354f, 
    -0.01452930f, 0.04611380f, -0.06691319f, 0.02567244f, 0.10350364f, -0.10446507f, 0.00950589f, -0.07821354f, 
    0.03898228f, -0.06359937f, 0.01146606f, 0.04076939f, 0.09624111f, 0.01103107f, -0.02996244f, 0.01603204f, 
    0.00594371f, 0.22787733f, -0.16203929f, -0.08101597f, 0.07014232f, 0.02912693f, 0.06076572f, 0.04122205f, 
    -0.12848544f, 0.08601552f, 0.01557011f, 0.02648238f, -0.15624034f, 0.15867421f, 0.01478895f, -0.00521224f, 
    0.06032646f, 0.02601225f, 0.03182169f, -0.00590537f, 0.14440092f, 0.12710455f, -0.01540412f, 0.06147371f, 
    -0.08108559f, 0.00569895f, 0.14614807f, -0.24212180f, 0.02472279f, 0.04211969f, -0.08516832f, 0.01850255f, 
    0.10131512f, -0.03484989f, 0.06778521f, 0.04662387f, -0.42627639f, 0.04333457f, 0.02254828f, 0.01568872f, 
    0.04099619f, 0.03011857f, 0.01253041f, 0.03334996f, 0.16641088f, -0.09585494f, 0.16509023f, 0.12536375f, 
    0.12976429f, -0.15157495f, -0.04111069f, 0.26916146f, -0.15893231f, 0.00700665f, 0.10230242f, 0.17039073f, 
    0.09925793f, 0.07586373f, 0.08424614f, -0.09257576f, 0.00003963f, 0.06210586f, -0.05336886f, -0.04548918f, 
    0.00628938f, -0.04883623f, 0.05696921f, 0.02272655f, -0.06053057f, 0.00488646f, 0.03198676f, -0.03138749f, 
    -0.12930731f, -0.14721267f, -0.18024404f, -0.23049887f, 0.06945148f, -0.12472030f, 0.05831008f, 0.03644994f, 
    -0.05010461f, -0.00925708f, 0.03466189f, 0.02851735f, 0.30909744f, -0.22914346f, 0.09127198f, -0.06985259f, 
    0.04634721f, -0.12563485f, 0.05800704f, 0.00294407f, 0.01863615f, 0.00200379f, 0.02716962f, -0.00878765f, 
    -0.10348426f, -0.13361567f, -0.17388929f, -0.08663494f, 0.02476228f, 0.03373285f, -0.04273249f, 0.06084763f, 
    -0.05603098f, -0.03824074f, 0.03836229f, -0.05173344f, 0.12726703f, 0.27620590f, 0.12863438f, -0.02502006f, 
    -0.04292331f, -0.05816943f, 0.01821322f, -0.00359573f, 0.07241467f, 0.01327873f, 0.03132437f, -0.05045913f, 
    -0.06956568f, -0.08869011f, 0.01425974f, -0.03554627f, 0.06757174f, 0.02663785f, -0.02478343f, -0.06818437f, 
    0.05930143f, 0.10882663f, 0.00572839f, 0.04551424f, -0.14475104f, 0.09198334f, 0.40837893f, -0.04094797f, 
    -0.00607791f, -0.04553538f, -0.02152307f, 0.01116468f, 0.06016807f, 0.03697379f, -0.12080026f, 0.05258777f, 
    0.00860154f, 0.14621118f, -0.01368057f, -0.11382148f, 0.07296079f, 0.12047054f, -0.02331677f, -0.02362628f, 
    -0.06515811f, 0.02477085f, -0.04860350f, -0.10603117f, 0.11852830f, 0.09449665f, 0.16349457f, 0.02389005f, 
    0.09249381f, -0.02040933f, -0.04978762f, -0.13169107f, 0.08339487f, 0.13977659f, 0.19563499f, 0.03994508f, 
    -0.03167805f, -0.20820984f, 0.08700704f, -0.08014302f, 0.03475238f, 0.05805115f, 0.03568397f, 0.08740196f, 
    0.03716646f, -0.00977576f, 0.07476985f, -0.00906914f, 0.03189246f, 0.04770618f, -0.13984551f, -0.11296425f, 
    0.06735876f, 0.11361440f, 0.03410101f, 0.04031551f, -0.20939793f, -0.01036745f, -0.04346750f, 0.06705800f, 
    -0.11799560f, -0.07760286f, -0.17369440f, -0.07440890f, -0.02521474f, 0.06875926f, 0.04270998f, 0.00873583f, 
    0.10947827f, 0.17494346f, 0.01193463f, 0.03991838f, -0.23582910f, -0.00020777f, 0.04561238f, 0.23314749f, 
    -0.05722407f, -0.08287036f, -0.00812630f, 0.01395760f, 0.00681478f, -0.11831923f, 0.11035297f, 0.05785273f, 
    0.11178395f, -0.01101006f, -0.04405501f, -0.01535793f, 0.03879997f, -0.01726827f, 0.07165001f, -0.00780608f, 
    0.12075999f, -0.14731324f, -0.00761731f, -0.09674072f, 0.29954731f, 0.06991285f, -0.10882308f, 0.00637295f, 
    0.00922236f, 0.07384769f, 0.14086941f, 0.03502779f, 0.01651718f, -0.01823663f, 0.01343654f, 0.06899024f, 
    0.03182487f, 0.19620843f, -0.06820994f, -0.25707451f, 0.08207466f, 0.08890722f, 0.11004509f, 0.04590065f, 
    -0.08410240f, 0.01886479f, -0.11160687f, 0.08942192f, 0.27299157f, -0.12414693f, -0.03535641f, 0.18280774f, 
    -0.09178756f, 0.05324652f, -0.04657728f, -0.01014387f, 0.01181804f, -0.07237744f, 0.07859062f, 0.07530444f, 
    0.02991382f, 0.12252191f, 0.02571946f, 0.11621223f, 0.12707187f, 0.03245655f, -0.05451800f, 0.01943782f, 
    0.03029971f, -0.00161271f, 0.06942365f, -0.08968918f, -0.13706127f, 0.27790391f, -0.19214232f, 0.12590440f, 
    0.00946329f, -0.05341426f, 0.05750221f, 0.12345482f, -0.03844425f, -0.02880041f, 0.23282729f, -0.03203624f, 
    -0.00026468f, 0.06476034f, -0.03084547f, 0.25118116f, -0.02898671f, -0.04100132f, 0.11000741f, 0.05756196f, 
    -0.01921138f, 0.09418853f, -0.02199868f, 0.01090031f, -0.05583942f, 0.08773442f, -0.08536789f, 0.13293867f, 
    -0.01779744f, 0.06469280f, 0.00421439f, 0.00826039f, -0.04014717f, 0.12359616f, -0.01096074f, 0.06029302f, 
    0.37256709f, -0.37258533f, 0.03838848f, -0.16217090f, -0.02313797f, -0.05421364f, -0.08838507f, 0.15969406f, 
    -0.03609337f, -0.04980176f, 0.06930368f, 0.03538974f, -0.29556271f, -0.06248010f, -0.00557554f, 0.07991612f, 
    0.11522532f, -0.03394302f, 0.01715049f, -0.17517635f, -0.01266991f, 0.01283702f, 0.00681079f, 0.04567892f, 
    0.01784127f, 0.02005385f, -0.07039638f, 0.17333528f, 0.00832649f, -0.03445579f, 0.07396543f, -0.07483214f, 
    0.02240337f, 0.07306651f, 0.05953499f, 0.07343521f, 0.21256314f, -0.06550328f, -0.24824131f, 0.01140138f, 
    0.12876864f, -0.07790903f, 0.05663113f, 0.05619451f, -0.13596551f, -0.11333992f, 0.02730859f, 0.07626077f, 
    -0.08963219f, -0.15542977f, -0.17258681f, 0.07131087f, -0.06019808f, 0.01555631f, 0.01185497f, 0.04374789f, 
    0.04082194f, 0.04650573f, -0.04881388f, 0.07791252f, 0.05398963f, -0.03083743f, -0.21112542f, 0.12323060f, 
    0.00329762f, 0.13453230f, -0.01410540f, 0.04974791f, 0.11199437f, 0.02490198f, 0.09984326f, 0.02782930f, 
    0.11686255f, 0.04521253f, -0.07312942f, 0.08318567f, 0.04652016f, -0.04436634f, -0.00258878f, -0.04759265f, 
    -0.11648291f, -0.04015964f, -0.05005417f, -0.06138193f, -0.08463760f, 0.06881583f, 0.01771470f, 0.12619968f, 
    -0.02747167f, -0.06483614f, 0.06632219f, -0.00607683f, 0.11101215f, 0.10282894f, -0.01582187f, -0.07854997f, 
    -0.11783151f, -0.11080600f, 0.02116235f, -0.12110252f, 0.00610701f, 0.09834614f, -0.07427645f, 0.06542840f, 
    0.02497431f, -0.14779885f, -0.11215433f, 0.09610078f, 0.22774200f, 0.03115876f, 0.10649908f, -0.07431585f, 
    0.12809822f, 0.01091327f, -0.13557060f, 0.14441097f, -0.16191544f, -0.02889159f, -0.02440506f, 0.10671992f, 
    -0.24863707f, 0.42232522f, -0.04256896f, 0.17992106f, 0.02804785f, 0.05505884f, -0.08781009f, 0.12511660f, 
    -0.08700456f, 0.07147212f, 0.07370427f, 0.01241746f, 0.07491498f, -0.14896485f, 0.06430036f, 0.14519773f, 
    0.03645563f, -0.13654451f, -0.03389629f, -0.00441327f, 0.00675799f, -0.09418234f, 0.02551300f, 0.10087969f, 
    -0.03232343f, -0.18985604f, 0.06588887f, 0.03129854f, 0.03787277f, 0.01958262f, -0.03474163f, 0.18912351f, 
    0.00031355f, 0.05373967f, -0.06657835f, -0.06309310f, 0.08065101f, 0.08943699f, 0.12627587f, 0.02013256f, 
    0.09073726f, 0.06983712f, 0.06886538f, 0.17260188f, 0.04829762f, -0.03353184f, -0.02816598f, -0.12476007f, 
    -0.21590634f, 0.14214140f, 0.01654032f, -0.11400240f, 0.01997247f, 0.05187416f, 0.05631107f, 0.03586594f, 
    0.04364250f, 0.02429822f, 0.19741072f, -0.07381760f, -0.04136921f, 0.21915406f, -0.20236751f, 0.16163668f, 
    -0.01826121f, 0.07350686f, 0.02828087f, -0.03575021f, -0.03159110f, 0.14205968f, 0.09583795f, 0.07796355f, 
    -0.10245270f, 0.12326516f, -0.20425427f, -0.23011336f, 0.14262173f, -0.01460061f, 0.01855493f, 0.01506968f, 
    -0.00247106f, -0.03855584f, -0.00930695f, -0.12425828f, -0.13804275f, -0.07258473f, 0.11959565f, 0.03857742f, 
    -0.03573120f, 0.01171254f, -0.05700790f, -0.08430059f, -0.04478392f, 0.09575599f, 0.06952788f, -0.07410692f, 
    -0.01313307f, 0.03895147f, -0.11954809f, 0.05037168f, 0.02987114f, -0.20671001f, 0.04703202f, 0.14460751f, 
    -0.02004606f, -0.09050192f, -0.14500496f, 0.05497218f, -0.15316492f, 0.08840774f, 0.17615947f, -0.10116015f, 
    0.05340654f, 0.02331027f, -0.06386391f, 0.17135504f, 0.01969095f, -0.06444235f, -0.02971784f, 0.11268406f, 
    0.05268877f, 0.08218042f, -0.16706841f, -0.02333488f, 0.16836090f, -0.15390924f, -0.07079892f, -0.04677830f, 
    0.04869626f, 0.05663485f, -0.04855964f, -0.09344642f, -0.27811363f, 0.11827431f, 0.03510339f, 0.00864522f, 
    0.12186613f, 0.05613143f, 0.02942816f, -0.00003204f, -0.04001828f, -0.08417808f, 0.02879828f, 0.07494183f, 
    -0.05273591f, -0.31750268f, 0.04825964f, -0.15535258f, -0.01904753f, 0.02639765f, 0.00207530f, -0.01556482f, 
    -0.02710359f, 0.02184571f, -0.15117982f, -0.05775184f, 0.30003199f, -0.28317833f, -0.01985377f, 0.00127186f, 
    -0.07940447f, 0.06595173f, 0.01177151f, 0.07068588f, -0.00320611f, 0.00031339f, -0.01390668f, 0.04873077f, 
    -0.19152881f, 0.10439801f, -0.06589018f, 0.01443156f, 0.05510627f, -0.02182782f, -0.00804854f, -0.03622352f, 
    -0.00829527f, 0.07584279f, 0.14559695f, 0.05654907f, -0.20770064f, 0.00794167f, -0.15017174f, -0.11960909f, 
    0.09596179f, 0.02421856f, -0.08315509f, -0.00446108f, -0.13595842f, -0.05036106f, -0.02409526f, -0.08354682f, 
    0.04246896f, -0.16756222f, 0.03577307f, 0.11642543f, 0.07489396f, -0.04094498f, 0.05064749f, -0.07365116f, 
    -0.05233738f, 0.07288805f, 0.00420339f, 0.02313736f, -0.03616834f, 0.06470060f, -0.14258024f, -0.09708382f, 
    0.10698539f, -0.04238717f, 0.08500028f, 0.00214082f, 0.06923637f, -0.09272479f, 0.17404558f, 0.07338661f, 
    0.26557332f, 0.20612969f, 0.02791832f, 0.19911905f, 0.01019648f, -0.03994714f, -0.06291111f, 0.10798226f, 
    0.08686133f, -0.06605233f, 0.14024815f, -0.01373820f, 0.11423984f, 0.00643744f, -0.12298236f, -0.26453924f, 
    0.04385877f, 0.15569656f, -0.01849768f, 0.05514908f, -0.09024320f, -0.06858102f, 0.01805688f, -0.06448648f, 
    -0.21434754f, -0.03750919f, -0.19158772f, -0.16291626f, 0.12622088f, 0.07921595f, -0.04732547f, -0.14930651f, 
    0.06466801f, 0.00127494f, 0.02171128f, -0.02126656f, 0.25076529f, 0.20212102f, 0.06701888f, 0.14680934f, 
    0.17189287f, -0.02261016f, -0.09786703f, 0.05206826f, 0.14070952f, 0.09795413f, 0.02447720f, 0.04694379f, 
    0.03849140f, 0.06915178f, -0.04448208f, 0.19065648f, -0.04211672f, -0.07391393f, 0.06680718f, -0.10515173f, 
    0.10411590f, 0.05241403f, 0.06219247f, -0.06743868f, -0.25222692f, -0.09049294f, 0.10276656f, 0.46147251f, 
    -0.00851666f, 0.01589671f, -0.09625742f, 0.07361609f, 0.01394908f, 0.06460577f, 0.07884669f, -0.04915190f, 
    -0.02822053f, 0.30150336f, -0.01764015f, 0.10776825f, 0.06931598f, 0.06477246f, -0.01776342f, 0.01438845f, 
    0.06576345f, -0.01837892f, -0.03437927f, 0.03930593f, 0.20664528f, -0.21878906f, 0.08628622f, 0.17053796f, 
    -0.00033631f, -0.07510817f, 0.12839335f, -0.09860619f, -0.01813195f, -0.09873672f, -0.03634072f, 0.00446051f, 
    -0.22575782f, 0.16700660f, -0.13580826f, 0.30354753f, -0.03751941f, -0.04348315f, -0.14234795f, 0.03128597f, 
    0.02088656f, -0.03289513f, 0.01515711f, 0.06037140f, -0.41985413f, -0.14587854f, 0.14417504f, 0.15199281f, 
    0.10843514f, 0.11335403f, 0.00714592f, -0.12918283f, -0.08210483f, -0.00148600f, 0.01583368f, -0.02625279f, 
    0.05177422f, 0.37806529f, -0.08626541f, 0.12201991f, 0.04414230f, 0.02500883f, 0.03141230f, -0.00523840f, 
    0.07875064f, -0.00994045f, -0.04252915f, -0.04453296f, -0.01696707f, 0.33090067f, -0.17314038f, -0.07534114f, 
    -0.00173852f, -0.06658499f, 0.01203403f, 0.00272102f, 0.00992161f, -0.00849992f, 0.07776573f, 0.08178964f, 
    0.13340117f, -0.15182796f, 0.09220032f, 0.35187891f, 0.01977857f, -0.00640284f, 0.01128132f, 0.02729265f, 
    0.10930938f, -0.05177386f, -0.01637719f, 0.05701635f, -0.07712452f, 0.47992265f, -0.05769210f, -0.05604591f, 
    0.10149699f, -0.07534689f, -0.02081692f, -0.05707764f, -0.02291165f, -0.02185540f, -0.01167675f, -0.15154587f, 
    0.10724770f, -0.10525075f, -0.10943761f, 0.03549576f, -0.02329087f, 0.01692683f, 0.03972679f, -0.06319015f, 
    0.04996627f, 0.12651461f, -0.01862074f, 0.00016818f, -0.14131081f, 0.04511511f, 0.11281637f, -0.09054390f, 
    0.04453560f, -0.08145726f, 0.04317342f, 0.06242658f, 0.10517662f, -0.07238676f, 0.07174967f, 0.08819175f, 
    -0.08045442f, 0.00864951f, 0.16367087f, -0.00553729f, 0.04481799f, -0.08149692f, 0.01902953f, 0.01005798f, 
    0.04569219f, 0.01133936f, 0.04939579f, 0.09117399f, -0.31882721f, -0.13502024f, 0.01397596f, 0.09284657f, 
    0.15099724f, 0.02813986f, -0.04043989f, -0.07891086f, 0.01978877f, -0.05609211f, 0.10931242f, -0.04387159f, 
    0.09669226f, -0.02262746f, -0.03906507f, 0.19530112f, 0.09326942f, -0.00932507f, 0.00397619f, 0.00025004f, 
    -0.04619131f, -0.00692972f, -0.02415754f, 0.00354707f, 0.27136710f, -0.27665064f, 0.10466462f, -0.16049461f, 
    0.01628889f, 0.05800985f, -0.03785685f, 0.01554435f, 0.08349257f, 0.00163255f, -0.04606954f, 0.04656479f, 
    0.13247584f, -0.05039688f, 0.14205627f, -0.17208569f, -0.05318290f, 0.13505779f, -0.05227466f, 0.04727769f, 
    0.02060151f, 0.14055596f, 0.10092642f, 0.07612646f, -0.14271756f, 0.19067730f, 0.05605835f, 0.29394943f, 
    0.04633893f, 0.07207926f, -0.06885300f, -0.03886844f, -0.06826233f, -0.00376332f, 0.01818106f, -0.12901810f, 
    -0.19905902f, 0.06075809f, -0.03002761f, 0.15732670f, 0.00084777f, 0.02462843f, 0.07011059f, -0.01372325f, 
    0.03056615f, -0.10140260f, -0.05296640f, -0.05606178f, 0.11650193f, 0.15304060f, 0.00674177f, -0.02794589f, 
    0.09982836f, -0.02254595f, -0.03806193f, -0.03298954f, 0.09727673f, -0.00342953f, 0.00730748f, 0.04707970f, 
    0.03621719f, -0.06859368f, 0.02546522f, 0.05686736f, 0.12501465f, 0.07958956f, -0.00291433f, 0.07352675f, 
    0.01716816f, -0.00381809f, 0.04035940f, 0.03162976f, 0.13259925f, 0.01239658f, 0.02249336f, -0.02763489f, 
    -0.08966610f, -0.09128393f, -0.02609121f, -0.02046872f, 0.11530346f, 0.00752553f, 0.03621595f, 0.02293332f, 
    0.15977706f, 0.04196858f, 0.09777547f, 0.05626925f, 0.15452102f, 0.14872505f, 0.04351349f, 0.06102690f, 
    0.03295580f, 0.11724874f, 0.00344050f, 0.08039590f, 0.12120926f, -0.00721930f, -0.01548142f, -0.08729526f, 
    -0.20465873f, 0.02006379f, -0.01841956f, -0.09117880f, 0.00418313f, -0.00164399f, 0.00283707f, 0.23548947f, 
    -0.20881730f, 0.04665731f, -0.03732128f, 0.02136181f, -0.03614202f, -0.01976389f, 0.04295380f, -0.15023752f, 
    0.02105253f, -0.08910064f, -0.05905227f, -0.03542194f, -0.13827209f, 0.27905959f, 0.08984012f, -0.16569860f, 
    0.08841274f, 0.01873947f, 0.05122035f, -0.05663785f, -0.00053980f, -0.10636978f, 0.13341108f, 0.06981283f, 
    0.00489161f, 0.07472193f, -0.11549055f, 0.03505868f, -0.03117921f, -0.00117591f, 0.00838910f, -0.02908731f, 
    -0.01790060f, -0.15852188f, -0.11112990f, 0.04921687f, -0.11193540f, -0.21154657f, 0.10913743f, -0.04500549f, 
    0.13988118f, 0.06803750f, 0.08693023f, -0.02223115f, -0.08481679f, -0.06255436f, -0.03331554f, -0.14130999f, 
    0.04329252f, 0.17418276f, -0.01409456f, 0.00467806f, 0.11587726f, 0.00066783f, -0.02158006f, 0.01687337f, 
    -0.01891789f, -0.06099689f, -0.06288902f, 0.00201585f, -0.12320441f, 0.18359782f, -0.19968954f, 0.04795112f, 
    0.11246837f, -0.06587734f, 0.16780882f, -0.04918286f, 0.04064045f, -0.08631475f, 0.08146336f, 0.06476580f, 
    0.00734609f, -0.01211048f, -0.02106830f, 0.18876499f, -0.06135646f, -0.09166826f, 0.08136994f, -0.10737984f, 
    0.05545208f, 0.12846653f, 0.08157948f, 0.06271317f, -0.09380680f, 0.06300689f, -0.07725555f, -0.02378017f, 
    0.05891062f, 0.01507504f, -0.04068454f, 0.05162370f, 0.04388990f, 0.08530661f, 0.01911177f, 0.01235283f, 
    0.23134421f, -0.08495105f, 0.22237469f, 0.29688472f, 0.00534061f, -0.04000674f, 0.04673078f, 0.05213797f, 
    0.03655409f, 0.01664110f, 0.00567842f, 0.01779743f, 0.14979164f, 0.09008813f, 0.24469651f, -0.09250323f, 
    0.05994638f, -0.00215139f, 0.06973848f, 0.06804562f, 0.00810065f, 0.00390033f, 0.07267421f, 0.04269454f, 
    -0.44232076f, 0.05291676f, 0.04869941f, -0.12162945f, 0.04759431f, -0.05463190f, 0.02990241f, 0.03304655f, 
    -0.16158880f, 0.04097300f, 0.02170251f, 0.03335332f, 0.03983004f, 0.26408926f, 0.03346341f, -0.09183657f, 
    0.23362678f, -0.06372742f, -0.01956787f, -0.02475819f, -0.06802952f, -0.09445830f, -0.06134764f, -0.01496108f, 
    -0.08825424f, -0.05007057f, -0.05990997f, 0.23132794f, 0.09897973f, 0.08393779f, 0.12113548f, -0.05042272f, 
    -0.02552527f, 0.09607403f, 0.03933803f, 0.06731582f, -0.14507104f, -0.09141017f, -0.01129690f, 0.19422223f, 
    -0.05156742f, -0.02852932f, -0.08657814f, -0.01204910f, 0.05001908f, 0.09394276f, 0.01758158f, 0.18850170f, 
    -0.32967213f, -0.04452617f, -0.09170755f, -0.28025240f, 0.13638860f, -0.01839100f, 0.05824437f, 0.03233718f, 
    0.03538200f, -0.03811477f, -0.11568803f, -0.07931243f, -0.26381466f, -0.04519260f, 0.20219950f, -0.11931618f, 
    0.01475012f, 0.05608622f, -0.05493807f, -0.11680704f, 0.12686476f, 0.13224721f, -0.03977500f, 0.16003783f, 
    -0.16711274f, -0.10694670f, 0.03622618f, 0.03745376f, -0.02454459f, 0.04618290f, -0.09779423f, 0.06989811f, 
    -0.01289671f, 0.04294823f, 0.11990043f, 0.06047530f, 0.49220040f, -0.17251574f, 0.04739243f, 0.15106109f, 
    -0.09091026f, -0.00131294f, -0.02092202f, -0.02134752f, -0.12407472f, 0.03916206f, 0.03056620f, 0.00485805f, 
    -0.12977208f, 0.21437030f, -0.11467827f, 0.13990654f, -0.05899329f, 0.07025512f, -0.14434126f, -0.06250609f, 
    0.10815527f, 0.02108149f, -0.01144897f, -0.04629074f, -0.26434746f, -0.00989029f, 0.07131072f, 0.00145184f, 
    0.02912628f, 0.09714077f, 0.00094706f, -0.02386284f, -0.02902765f, -0.00681185f, 0.20948561f, 0.04916906f, 
    0.10159910f, -0.13133721f, 0.02963803f, 0.18544279f, 0.04044896f, 0.06057425f, 0.06253783f, 0.00787259f, 
    -0.03160931f, 0.11131595f, 0.01779405f, 0.13851102f, -0.00455860f, 0.10018174f, 0.03713385f, -0.18077940f, 
    0.01272956f, 0.11086716f, 0.02239895f, -0.10765429f, -0.01332047f, -0.02740664f, -0.00051464f, -0.02349098f, 
    -0.26455468f, 0.20825011f, 0.03809293f, -0.20559022f, -0.02016645f, -0.05247883f, 0.06799410f, -0.08758343f, 
    -0.06169841f, -0.09109046f, 0.11226108f, 0.02948404f, -0.03687333f, 0.08790130f, -0.34679738f, 0.12621441f, 
    -0.09867590f, -0.06104792f, 0.07669408f, -0.04532486f, 0.02446235f, 0.02209205f, 0.09226671f, -0.02567571f, 
    0.01973886f, 0.18356004f, -0.02202449f, -0.02787419f, 0.08954693f, 0.02381748f, 0.04146975f, -0.00976560f, 
    -0.04489458f, -0.08854456f, -0.00078453f, -0.05066483f, 0.16594365f, -0.01951440f, 0.18291417f, -0.13181078f, 
    0.08307312f, 0.11408180f, 0.04796245f, 0.09685861f, 0.10706242f, -0.03654229f, 0.11735817f, 0.06552869f, 
    -0.03784333f, 0.21793266f, 0.17019136f, -0.08718959f, 0.13568804f, -0.04524576f, -0.04554524f, -0.04710877f, 
    -0.05908375f, 0.06163504f, -0.07909793f, -0.00935544f, 0.19123031f, 0.18322252f, -0.08122580f, 0.32403314f, 
    -0.00388603f, 0.04061499f, -0.00894529f, 0.12527603f, 0.11899988f, 0.05602783f, -0.01734404f, 0.04487291f, 
    0.07045867f, 0.17417517f, 0.10777052f, 0.00692634f, 0.09621837f, 0.02166595f, 0.05144028f, 0.07461818f, 
    0.03028133f, -0.03113941f, -0.00493165f, 0.06634778f, -0.08220791f, 0.16020848f, 0.05547550f, -0.05887263f, 
    -0.07467618f, -0.04938515f, 0.04670014f, -0.11772261f, 0.03733791f, -0.05579272f, -0.12993944f, -0.16103645f, 
    -0.16318272f, -0.08814128f, 0.14060666f, 0.26721615f, -0.02192106f, 0.14970092f, -0.10317604f, 0.02664701f, 
    -0.00496937f, 0.03672120f, 0.00969772f, -0.03718431f, -0.11155105f, -0.19309822f, 0.08611464f, 0.04455560f, 
    -0.07998662f, 0.02749684f, 0.07298797f, 0.12924871f, -0.01647720f, -0.02094296f, 0.16877989f, 0.08863542f, 
    0.03578041f, 0.18651378f, -0.07914881f, -0.07349724f, 0.06785857f, -0.05209891f, 0.03874529f, -0.03634737f, 
    -0.04971241f, 0.07253940f, 0.06800303f, 0.09292918f, 0.08310795f, 0.01944313f, -0.10622232f, 0.01009067f, 
    0.12727830f, 0.02260397f, 0.02135006f, 0.05573692f, 0.07421037f, -0.06171633f, 0.04215802f, 0.00261065f, 
    -0.35217664f, -0.04538758f, 0.12038781f, 0.12926383f, 0.15122241f, 0.09627388f, 0.05667833f, 0.02989853f, 
    -0.05263663f, 0.03061590f, 0.02513704f, 0.04941306f, 0.12028079f, 0.05585213f, 0.06875126f, -0.22072943f, 
    0.03593196f, 0.02012224f, 0.00650602f, -0.01480852f, 0.01949189f, 0.14171675f, 0.05220686f, -0.08451765f, 
    -0.41336650f, -0.10756126f, -0.02225392f, 0.07579726f, 0.19939305f, 0.00709818f, 0.12376273f, 0.12331477f, 
    -0.09506979f, -0.06306396f, 0.01634553f, 0.01253190f, 0.00995726f, -0.09325688f, 0.20006703f, 0.12129917f, 
    -0.06514875f, 0.12707347f, 0.00841853f, -0.03706073f, 0.04048335f, -0.03421573f, 0.03773418f, 0.02320517f, 
    0.20040549f, 0.09134682f, 0.07663172f, -0.01222426f, 0.16625763f, -0.01854278f, -0.01745103f, 0.09821741f, 
    0.14293993f, 0.00368819f, -0.03639182f, -0.04895716f, 0.30311882f, 0.01601793f, 0.06504931f, -0.40790802f, 
    0.07570613f, 0.04145813f, -0.10171995f, 0.17433806f, 0.03728737f, 0.00378098f, 0.02172863f, 0.00166814f, 
    -0.40415293f, -0.01652910f, -0.00870654f, 0.02814885f, 0.12215226f, -0.06722019f, -0.00006590f, 0.06513095f, 
    0.09900413f, -0.03151121f, -0.02224064f, -0.08859660f, 0.07570230f, 0.08475395f, -0.00546473f, 0.07452413f, 
    -0.01088407f, -0.02383382f, 0.18301970f, -0.07644155f, -0.03509157f, 0.19552658f, 0.01270281f, 0.08245297f, 
    0.05244325f, 0.05473561f, -0.10116187f, -0.06216568f, -0.05048259f, -0.09255898f, -0.06488813f, 0.01366760f, 
    0.09963644f, 0.09635594f, 0.01184215f, 0.07825485f, -0.11624114f, 0.04100520f, 0.12576737f, 0.14815125f, 
    -0.03071140f, -0.01694498f, -0.04982855f, -0.02447207f, -0.01588243f, 0.00675771f, -0.06164323f, -0.02676963f, 
    -0.03617327f, 0.04179118f, -0.03495139f, 0.16420221f, 0.08534840f, -0.03113855f, 0.06087049f, 0.03444149f, 
    0.02242558f, -0.06543455f, -0.12305980f, -0.07478304f, -0.01546174f, 0.08740075f, 0.10250486f, 0.02091418f, 
    -0.00233654f, 0.01015756f, -0.00333014f, 0.08372133f, -0.08613989f, 0.05535782f, 0.02165985f, 0.05246574f, 
    -0.05305422f, -0.11046151f, -0.20913877f, -0.09382863f, -0.03089752f, -0.06490216f, 0.04291991f, 0.02423453f, 
    -0.03410154f, 0.01056576f, 0.02637474f, -0.05553572f, 0.00146845f, 0.16433211f, -0.08325336f, 0.06101749f, 
    0.06322040f, 0.04787613f, -0.00557435f, -0.02201554f, 0.03337713f, 0.18375739f, 0.06587765f, 0.07534785f, 
    0.21603845f, 0.05711395f, -0.00195175f, 0.15134566f, -0.04054428f, 0.15027231f, -0.00626958f, -0.04044737f, 
    0.03518575f, 0.00280654f, 0.11670606f, 0.02971490f, -0.26011074f, 0.27503434f, 0.07267255f, -0.02069671f, 
    0.08364335f, -0.00665111f, 0.03096299f, 0.03356729f, 0.13424797f, -0.02231068f, 0.10629187f, -0.11552073f, 
    -0.06796669f, 0.11321115f, 0.07548483f, 0.07260495f, -0.10399935f, 0.07826936f, 0.09241261f, 0.06626453f, 
    0.16679022f, -0.01498580f, 0.02643949f, -0.02093833f, 0.27615565f, 0.03866627f, -0.00748006f, 0.04591602f, 
    0.00563065f, 0.09283536f, 0.04914012f, -0.00649870f, -0.01152558f, -0.10241906f, -0.01269427f, -0.03634571f, 
    0.06412343f, 0.01446364f, 0.03566605f, 0.05539547f, -0.01973958f, -0.16845195f, 0.01827410f, 0.00479406f, 
    0.08573163f, 0.05292043f, -0.04605212f, -0.04467402f, 0.06423976f, 0.07142001f, 0.15974626f, -0.00379468f, 
    0.04168428f, 0.00446140f, -0.03308334f, 0.06831837f, 0.08225133f, -0.06392808f, -0.05614085f, -0.05802561f, 
    0.06484389f, 0.13790075f, -0.02413477f, 0.06403937f, -0.10584865f, 0.07608160f, 0.00280937f, 0.04726909f, 
    -0.01955408f, -0.04209842f, -0.05156259f, -0.18982735f, 0.16709524f, -0.01052547f, 0.01591555f, 0.07304303f, 
    0.06400385f, 0.04963030f, 0.02953779f, -0.11929133f, 0.01888927f, -0.07440541f, -0.04128776f, -0.00903808f, 
    0.00120499f, 0.07422807f, -0.04032908f, -0.17189711f, -0.03923516f, 0.06905141f, -0.03542352f, 0.00789890f, 
    0.00906222f, 0.02136063f, 0.05885400f, 0.03374550f, 0.17672567f, 0.13472226f, 0.01965235f, 0.12101647f, 
    0.02419822f, -0.00026925f, 0.13248964f, -0.11682045f, 0.03794599f, -0.02853999f, -0.11253859f, -0.07589398f, 
    0.02128329f, 0.08217306f, 0.06254204f, 0.12481120f, 0.01321476f, 0.08611792f, -0.02156332f, -0.04194561f, 
    -0.00022728f, -0.11146477f, -0.03268855f, -0.10699490f, -0.02341834f, -0.00192767f, -0.05074825f, 0.04800363f, 
    0.09122945f, 0.05140530f, 0.02896433f, -0.09268933f, 0.02083429f, 0.17442858f, 0.05516113f, 0.07665984f, 
    0.16231698f, -0.02211375f, -0.06017810f, -0.02191501f, 0.00414935f, 0.15304069f, 0.05107371f, 0.11762855f, 
    -0.00412988f, 0.09662397f, -0.02200886f, -0.03734953f, 0.14538008f, 0.01109881f, -0.09634630f, 0.00056585f, 
    0.04625035f, 0.02222456f, -0.00990880f, -0.10942126f, -0.02507896f, 0.10094415f, -0.07084599f, 0.03965137f, 
    0.09034851f, 0.09576722f, -0.04572006f, -0.18979213f, -0.05299411f, -0.00159910f, 0.02318615f, 0.03304211f, 
    0.17919005f, 0.07774022f, -0.05302981f, 0.07620662f, -0.00807133f, 0.09677485f, 0.13935225f, 0.11109255f, 
    0.02137795f, 0.09178703f, 0.09686644f, -0.10599633f, 0.10231964f, 0.00022105f, 0.10219644f, 0.11748166f, 
    -0.00755872f, 0.00902463f, -0.04578231f, 0.02648983f, -0.00217295f, 0.08209366f, 0.13589235f, -0.01871495f, 
    0.09074391f, -0.07697970f, -0.12494210f, -0.20354360f, -0.04042850f, -0.02612271f, -0.14014983f, -0.08249897f, 
    0.13990866f, 0.07571542f, -0.02477390f, 0.02345003f, 0.03995800f, 0.04721529f, -0.01270149f, 0.08388593f, 
    0.07378893f, 0.08364667f, -0.09581724f, -0.02330250f, 0.05416077f, -0.05518639f, -0.13462894f, -0.02244706f, 
    0.00621021f, -0.06366176f, -0.09620032f, 0.06746809f, 0.58327419f, -0.00482151f, 0.06814171f, 0.02271112f, 
    0.03607710f, 0.09083159f, -0.06255810f, -0.03188002f, -0.02721696f, -0.00561476f, 0.20876029f, 0.06038896f, 
    0.03291579f, 0.02489754f, -0.04714468f, 0.01597057f, -0.04522928f, -0.00315495f, -0.10883785f, 0.10226007f, 
    -0.12143710f, -0.04396752f, 0.04491244f, -0.10075923f, -0.16470401f, -0.04288441f, 0.07062057f, 0.13778026f, 
    -0.02670892f, -0.01140334f, 0.17231691f, 0.01375582f, -0.00011253f, -0.08027615f, 0.15512362f, 0.14509338f, 
    -0.01137114f, 0.17032042f, 0.14150868f, 0.00005290f, -0.02324022f, -0.12476092f, 0.24271058f, 0.10827832f, 
    0.01200556f, 0.13749224f, -0.03698476f, -0.08745200f, 0.10698098f, 0.08775154f, 0.06983177f, 0.19088450f, 
    0.04898833f, 0.09119993f, -0.01841730f, 0.11616389f, 0.07245919f, 0.25755131f, 0.02175965f, 0.08378477f, 
    0.27518886f, -0.01334910f, 0.26451769f, 0.12044253f, 0.01680400f, -0.07502024f, -0.00110766f, 0.00532244f, 
    -0.06210585f, 0.07435985f, -0.01120344f, 0.03174749f, -0.09610809f, -0.01474742f, -0.05075795f, -0.09741489f, 
    0.01252165f, -0.00488422f, -0.00197973f, -0.02579734f, 0.04624480f, -0.01964675f, -0.10004131f, 0.04906996f, 
    -0.02762768f, 0.10078775f, 0.09589826f, -0.01929607f, 0.03084828f, -0.11643835f, 0.09580707f, -0.14922421f, 
    0.02765579f, 0.20205596f, -0.06799425f, 0.07608628f, 0.32721823f, -0.14131650f, -0.00645823f, 0.09126139f, 
    -0.03150522f, -0.09750289f, 0.05516218f, 0.03202463f, -0.03593237f, -0.07534087f, 0.10708162f, -0.06288297f, 
    0.00327723f, 0.18592197f, -0.04605435f, 0.04673686f, 0.00958215f, -0.09463944f, 0.12083825f, 0.03729808f, 
    -0.05907529f, 0.19270726f, 0.00208565f, -0.15781635f, -0.05120138f, -0.08319239f, -0.04306338f, 0.08151331f, 
    -0.01672089f, 0.04625987f, -0.05883685f, -0.03755004f, -0.01652667f, 0.06471952f, 0.08509244f, 0.11805090f, 
    -0.12448210f, 0.10036818f, 0.10942634f, -0.01330049f, -0.00190210f, 0.03856429f, 0.06054229f, -0.01185052f, 
    0.01472311f, -0.03606789f, -0.02546313f, -0.01053456f, -0.04313898f, -0.07187029f, -0.00941959f, 0.01660852f, 
    -0.01070642f, -0.05729360f, -0.02294046f, 0.00828438f, 0.08665009f, 0.09111246f, -0.19186299f, -0.03815088f, 
    0.04863752f, 0.10255827f, -0.00112895f, 0.14361535f, 0.05580239f, 0.12151423f, -0.01722136f, 0.11674266f, 
    0.01284765f, 0.00306344f, 0.01406515f, 0.15212023f, 0.24620868f, -0.16498187f, 0.02000995f, 0.05416669f, 
    0.02891169f, 0.04971639f, -0.05834618f, -0.02182817f, -0.10968988f, -0.00782458f, 0.03495168f, -0.09547616f, 
    -0.20438759f, 0.15536560f, -0.04095808f, 0.06365543f, 0.06694581f, 0.08676453f, 0.16819203f, -0.02680966f, 
    -0.00289556f, 0.10947636f, 0.07561451f, 0.07666793f, -0.13785000f, 0.16219211f, 0.29410127f, -0.00585772f, 
    0.01013036f, 0.05362398f, 0.03089346f, 0.03753693f, -0.05578859f, -0.04039671f, 0.07211316f, 0.06449354f, 
    0.13022587f, 0.03946868f, 0.07117658f, 0.13687104f, -0.08507273f, 0.04499028f, -0.01817632f, 0.00567471f, 
    -0.01149147f, 0.19145088f, -0.10062040f, -0.11786686f, 0.13109140f, 0.01957296f, 0.01862808f, -0.00560721f, 
    -0.04883355f, 0.03864213f, -0.05699962f, -0.00678534f, -0.07179180f, -0.03665835f, -0.04647978f, -0.14668314f, 
    -0.04582692f, 0.16212945f, -0.10571434f, 0.04997142f, 0.00029549f, -0.01702440f, -0.05781646f, -0.00402556f, 
    0.07162505f, 0.06670564f, 0.12746923f, -0.02012934f, 0.00651416f, 0.05286698f, -0.10779741f, 0.28084078f, 
    -0.01739289f, -0.06467891f, 0.10342802f, 0.00907777f, -0.01042767f, -0.00503633f, 0.12578954f, 0.07069799f, 
    -0.02546918f, 0.01741504f, -0.16018498f, -0.09153682f, -0.03334256f, -0.01548341f, -0.06049339f, 0.06952737f, 
    0.02487344f, -0.03531984f, 0.05281236f, -0.05152567f, -0.07530884f, 0.07752525f, -0.01039810f, 0.04621647f, 
    -0.04208001f, -0.01903023f, 0.08463936f, 0.03135483f, 0.07341353f, 0.17708269f, -0.05885812f, -0.01173157f, 
    -0.09818532f, 0.02324493f, -0.02052703f, 0.02503131f, 0.08794713f, -0.05067420f, 0.04117392f, -0.03954107f, 
    -0.10697392f, -0.02771770f, -0.14830892f, -0.10824366f, 0.17038994f, 0.28916880f, -0.11543481f, 0.12656723f, 
    -0.04127678f, 0.02526255f, -0.07397667f, 0.06656056f, -0.00742467f, 0.03819916f, 0.05181441f, 0.13901606f, 
    -0.05316278f, -0.05522331f, -0.13068996f, -0.08793308f, -0.03380397f, -0.12043786f, 0.02016255f, 0.04305113f, 
    0.06777123f, 0.03970321f, -0.08969526f, -0.03357060f, -0.11673719f, 0.09678728f, 0.03400896f, 0.05250749f, 
    0.02870718f, 0.08895445f, 0.00350352f, -0.03100564f, -0.04152100f, -0.11212298f, -0.03658647f, -0.11267903f, 
    0.16049832f, 0.11993259f, 0.09720298f, -0.03035209f, -0.07230717f, 0.05462743f, -0.01087329f, -0.02231709f, 
    0.07477530f, -0.01252651f, -0.19389333f, -0.04859457f, 0.20108940f, -0.08819397f, 0.02792056f, 0.03652375f, 
    -0.06042412f, 0.02694931f, 0.09716079f, 0.11599761f, -0.05936037f, -0.02084281f, -0.04484989f, 0.08005407f, 
    -0.10497045f, 0.04131453f, -0.01036120f, 0.02190694f, -0.02114042f, 0.05087014f, 0.03705358f, 0.06667350f, 
    -0.01051958f, 0.05470652f, 0.00154537f, -0.04778675f, -0.03229732f, -0.07564198f, -0.08141198f, -0.13710092f, 
    -0.00903141f, 0.14080746f, 0.03185548f, -0.01742039f, -0.04250072f, -0.00556247f, 0.09687839f, -0.02845899f, 
    -0.06406853f, 0.05550956f, 0.30932152f, 0.02412252f, 0.03542549f, -0.02036422f, 0.10138497f, 0.03757833f, 
    -0.09211682f, 0.00745273f, 0.05914475f, 0.14101505f, -0.02261513f, -0.01718369f, -0.01017268f, -0.09362167f, 
    0.02199587f, 0.07703698f, -0.03610823f, 0.00867280f, -0.03461906f, 0.02528202f, 0.22212109f, -0.02914202f, 
    0.10160576f, 0.01049705f, 0.24287973f, 0.04258094f, 0.13378462f, 0.04715865f, -0.03786049f, 0.12121272f, 
    -0.02156109f, 0.09019795f, 0.22258051f, 0.08865523f, 0.10014831f, -0.03858479f, -0.05680851f, -0.08939450f, 
    -0.04600672f, 0.03030202f, -0.07736745f, 0.04002609f, 0.05545442f, -0.01464764f, 0.04285721f, -0.08284147f, 
    -0.15396848f, -0.02191728f, -0.13390408f, -0.08537956f, -0.03963241f, 0.00027852f, -0.00527820f, -0.04858071f, 
    -0.01831591f, 0.04628123f, 0.04083668f, 0.11833698f, 0.12798275f, 0.02360692f, 0.15541306f, 0.12108801f, 
    0.11579242f, 0.23397945f, 0.00903231f, -0.00563422f, 0.00210665f, -0.00054824f, 0.09847600f, -0.06627169f, 
    -0.13701870f, -0.12760335f, -0.03154881f, -0.13693450f, -0.07587337f, -0.02166532f, -0.06427055f, -0.06207068f, 
    0.03786378f, -0.01898684f, 0.03879453f, -0.01690592f, -0.01069083f, 0.01152303f, -0.02913234f, 0.08004927f, 
    0.04068156f, 0.02559288f, 0.07893082f, 0.04127787f, -0.16054267f, -0.03408079f, 0.04183529f, 0.00403040f, 
    -0.20901339f, -0.10194010f, -0.06633939f, 0.13782984f, 0.12149619f, 0.03633823f, -0.02947433f, -0.08721542f, 
    -0.02661504f, -0.07111369f, -0.09814985f, 0.03170450f, 0.01939856f, -0.01662397f, 0.11496245f, -0.01302058f, 
    -0.00556122f, 0.09655091f, 0.10007461f, -0.06803450f, 0.07796204f, 0.02440396f, 0.00081963f, -0.00677805f, 
    0.14663035f, 0.04409013f, 0.05451628f, 0.14202875f, 0.00203791f, -0.05803634f, -0.03279404f, 0.04779636f, 
    0.00303199f, 0.05225791f, 0.13319181f, 0.01379019f, -0.13071807f, 0.28809845f, -0.18137465f, 0.05993455f, 
    0.12117852f, 0.03858793f, 0.11126217f, 0.03235493f, 0.04970036f, 0.02117364f, -0.04611136f, -0.01088576f, 
    -0.06784303f, -0.01133110f, 0.00561133f, -0.11957736f, 0.03092670f, -0.01687811f, -0.01243812f, -0.00375701f, 
    0.09472401f, -0.04460188f, -0.02175375f, 0.09054973f, 0.05221477f, -0.16751856f, -0.01245202f, 0.28204364f, 
    -0.08600447f, 0.07982088f, 0.00210159f, 0.03991973f, 0.09311327f, 0.02685973f, 0.01615758f, -0.05841696f, 
    0.04751291f, 0.07179668f, 0.18850587f, 0.12380231f, 0.07882343f, 0.04110285f, 0.05698483f, 0.04755158f, 
    0.05513524f, 0.01963818f, -0.04271825f, 0.04571139f, -0.01943233f, -0.03662685f, -0.18593596f, -0.04731891f, 
    0.01846614f, -0.06751165f, 0.01918471f, 0.00733458f, 0.05934270f, -0.06103063f, -0.02913786f, 0.00728117f, 
    0.22669032f, -0.02576913f, 0.06753463f, -0.00664119f, 0.01804540f, 0.02367919f, -0.09721855f, -0.06976673f, 
    0.04491662f, 0.05708795f, -0.08264402f, 0.02620952f, 0.04156917f, -0.00924490f, -0.00291992f, 0.21744892f, 
    0.02295464f, -0.05960942f, -0.10388581f, -0.02956864f, 0.03698388f, 0.03569385f, -0.04334202f, 0.00464609f, 
    -0.06734923f, -0.02973807f, 0.16765948f, 0.13429642f, -0.02343210f, 0.03832586f, -0.09834994f, -0.09925990f, 
    -0.06541196f, -0.04021193f, 0.02735980f, -0.02703542f, -0.15236674f, 0.12827148f, -0.04557649f, -0.10206734f, 
    0.08739656f, -0.01570968f, -0.13413671f, 0.01312074f, 0.05257341f, 0.03270394f, 0.05660497f, -0.05561611f, 
    0.19237240f, -0.06697642f, 0.06125266f, 0.12296764f, 0.13173993f, -0.03424367f, 0.04515011f, -0.04942242f, 
    0.07765825f, -0.01882545f, 0.04821480f, 0.07080153f, -0.07559226f, 0.08709064f, 0.04943641f, 0.12833622f, 
    -0.05002860f, 0.00369707f, 0.00800082f, -0.02229419f, -0.02478021f, 0.09056077f, 0.09617714f, 0.01963720f, 
    -0.19162014f, -0.11306466f, -0.21138744f, 0.15398295f, 0.01731094f, -0.01363826f, -0.03120279f, -0.08166473f, 
    -0.05868068f, -0.00389790f, -0.04952383f, 0.26121646f, -0.04732408f, 0.17653930f, -0.03109306f, -0.20041972f, 
    -0.02071413f, 0.01752957f, 0.12732278f, 0.08690502f, -0.08364712f, 0.02431693f, -0.01105028f, 0.01874111f, 
    0.06327783f, -0.04981699f, 0.03866642f, 0.06570668f, -0.07068175f, 0.03682503f, -0.00840013f, -0.03294596f, 
    0.03858610f, 0.05697644f, 0.09043466f, 0.01065491f, -0.25042257f, 0.07868481f, -0.15951678f, -0.16539253f, 
    -0.05024365f, -0.05592022f, 0.04365768f, -0.04907458f, 0.10100651f, -0.02874089f, 0.07894289f, -0.01030627f, 
    0.26494429f, 0.31394222f, -0.01832645f, -0.19728790f, 0.14601479f, -0.02853815f, 0.00781680f, -0.07207572f, 
    0.10399042f, -0.06336290f, -0.01374803f, 0.07217445f, -0.05258634f, 0.00485218f, 0.20983316f, -0.01605025f, 
    -0.07368200f, -0.00238194f, -0.00886407f, -0.09099931f, 0.10792917f, -0.03006726f, 0.02297372f, 0.04649528f, 
    -0.35593051f, -0.13874489f, 0.14896442f, 0.06911318f, 0.05067651f, 0.12723096f, -0.11188135f, 0.05177664f, 
    -0.03299110f, -0.03743559f, 0.09995092f, -0.01071577f, 0.27334827f, 0.20618567f, -0.03406070f, -0.14711969f, 
    0.04182044f, -0.11465014f, 0.06633241f, 0.04507446f, -0.09462075f, -0.00018859f, -0.00927441f, -0.00860696f, 
    -0.10167605f, -0.03636139f, -0.14393193f, 0.01626783f, -0.10230466f, 0.05945143f, 0.02642032f, 0.02963460f, 
    0.05386902f, -0.09950786f, -0.07915673f, 0.14526814f, -0.34385166f, 0.01289165f, -0.16039763f, 0.00000632f, 
    -0.09828892f, 0.04815044f, 0.04436781f, 0.02877344f, 0.11260029f, -0.01969810f, -0.07810254f, 0.03564673f, 
    -0.04479871f, -0.21365288f, 0.05635827f, 0.15386809f, -0.01453538f, -0.08083843f, 0.08214179f, -0.06111354f, 
    0.00913537f, 0.07425936f, -0.05950686f, 0.11451411f, -0.06236707f, 0.15820070f, 0.00716038f, -0.26586047f, 
    0.01262929f, 0.07183967f, 0.10268900f, -0.03767867f, 0.14439148f, -0.03342701f, -0.01413878f, 0.00052644f, 
    -0.13497700f, -0.10099246f, -0.09459563f, 0.00823014f, 0.00765122f, 0.08392607f, -0.04284000f, 0.05565605f, 
    0.09286831f, 0.00098013f, 0.00663317f, -0.00667387f, 0.02621095f, 0.32593033f, -0.12479816f, -0.03602016f, 
    -0.03114836f, 0.01159321f, 0.05152240f, 0.02376990f, 0.01964444f, 0.02129239f, 0.03042749f, -0.02790244f, 
    -0.05029195f, 0.06426352f, 0.24453381f, -0.00653378f, 0.02742849f, -0.03160319f, 0.10945280f, -0.06546154f, 
    0.01287790f, 0.09771345f, 0.10573534f, 0.04442902f, 0.20661284f, -0.07701568f, -0.10372289f, 0.16991574f, 
    -0.00320647f, -0.00771867f, 0.02288714f, -0.07646249f, 0.15531376f, 0.03418627f, -0.00650897f, -0.01623838f, 
    -0.19807769f, 0.18771888f, 0.19610794f, 0.11529709f, 0.09382986f, 0.07472976f, -0.01248889f, -0.01363461f, 
    0.10201731f, 0.02336695f, 0.02002452f, 0.03984886f, 0.03748266f, -0.06402134f, 0.02133728f, 0.04639883f, 
    -0.04949743f, -0.08830353f, -0.00575369f, -0.09903419f, 0.01698671f, 0.04984504f, 0.13405433f, 0.02176127f, 
    -0.15665393f, 0.09459355f, 0.00147122f, 0.04731287f, 0.02368241f, 0.05348740f, -0.05508929f, 0.10561856f, 
    -0.03938516f, 0.10612055f, -0.00185100f, -0.02002184f, -0.29780877f, 0.15753926f, -0.00146092f, 0.02718554f, 
    0.02688704f, 0.09845684f, -0.05290690f, 0.06264498f, 0.06195055f, -0.02901078f, 0.00916251f, 0.03328267f, 
    -0.05280634f, -0.13342506f, 0.02695677f, 0.04409928f, 0.22905499f, 0.01570516f, 0.07101390f, -0.00426381f, 
    0.10972971f, 0.01965485f, -0.04882380f, 0.05805872f, 0.04149495f, 0.16645196f, 0.24819218f, 0.05908590f, 
    0.15559097f, 0.09831619f, -0.16530131f, 0.01683853f, -0.00178236f, 0.09921145f, 0.04287336f, 0.05667498f, 
    -0.23657250f, -0.05045231f, -0.06711992f, -0.13099881f, 0.07693628f, 0.01255361f, 0.02389613f, 0.15176009f, 
    0.04839677f, 0.04211912f, -0.01945426f, 0.04047557f, 0.09219711f, 0.11407200f, 0.26320568f, 0.17341381f, 
    0.07850705f, -0.08817180f, -0.02544666f, -0.04973453f, 0.08611202f, 0.00825301f, 0.06332213f, 0.07481635f, 
    0.06721783f, 0.07646976f, 0.15037940f, 0.01428498f, 0.07453211f, 0.06922343f, 0.04285960f, -0.04439983f, 
    0.00231726f, 0.09932678f, -0.01000516f, 0.07238512f, -0.34937453f, 0.09134012f, 0.07795003f, -0.15369855f, 
    -0.02486260f, 0.03491999f, 0.05041676f, -0.06648308f, -0.03761565f, -0.01262421f, -0.01961336f, 0.03590987f, 
    -0.00549077f, -0.05954089f, -0.19287516f, -0.14971723f, -0.11943460f, -0.02206019f, -0.02597010f, -0.00270413f, 
    -0.02745014f, 0.04368089f, -0.00144755f, -0.02746621f, -0.14840268f, 0.26735610f, -0.02942443f, 0.04577214f, 
    0.04592551f, 0.03288002f, 0.06638872f, 0.13866712f, 0.02675718f, -0.00594630f, -0.01818275f, -0.00187601f, 
    0.09169999f, 0.11573002f, 0.17009993f, -0.08555247f, -0.00832930f, -0.00877040f, 0.06912912f, 0.08294621f, 
    -0.04922500f, 0.12089194f, 0.07878656f, 0.03271966f, 0.09892916f, -0.09698039f, -0.22655131f, -0.04968793f, 
    -0.09261516f, 0.06005996f, 0.03442193f, -0.03119277f, 0.09308367f, 0.05868464f, -0.01909942f, 0.10755484f, 
    -0.09384246f, -0.17719305f, 0.29436284f, 0.17108397f, -0.07770040f, 0.00650555f, 0.00306724f, -0.08907270f, 
    0.01656251f, -0.05588512f, 0.03622952f, -0.07719152f, 0.21331033f, -0.07972318f, -0.05463502f, 0.14038981f, 
    -0.05080577f, -0.01505976f, -0.00785493f, -0.04550691f, -0.00399224f, 0.14135122f, 0.02097042f, -0.02119003f, 
    -0.27324048f, -0.18735561f, -0.20922813f, -0.07348980f, 0.06482127f, 0.00293947f, 0.05835302f, -0.03614672f, 
    -0.03768085f, -0.06324127f, -0.04933968f, -0.02657712f, -0.32516149f, -0.15905952f, -0.21884017f, 0.04674988f, 
    0.07768804f, 0.05044989f, -0.00618747f, -0.10223682f, -0.03878372f, -0.14569348f, -0.01693960f, 0.04904382f, 
    -0.14815335f, 0.11520961f, -0.04633985f, 0.08558974f, 0.03324076f, -0.12232539f, 0.03526671f, -0.12122705f, 
    0.05459880f, 0.07202658f, -0.07078241f, 0.26957259f, -0.20541759f, -0.15077250f, 0.23795533f, -0.08554577f, 
    -0.10392412f, 0.08449151f, 0.00914611f, 0.01766337f, 0.04110506f, 0.05116010f, 0.00661765f, 0.05069439f, 
    -0.28131610f, -0.01373897f, 0.04014070f, 0.06309414f, 0.02269258f, 0.01335900f, 0.05930832f, 0.02010622f, 
    -0.00069556f, -0.07396036f, 0.06434195f, -0.02829611f, -0.20411727f, -0.16321856f, 0.04245437f, -0.06235220f, 
    -0.16355228f, -0.08566388f, -0.00944985f, 0.02948055f, 0.08240636f, -0.07825185f, 0.04416978f, -0.06456108f, 
    -0.04676002f, 0.10532171f, -0.02838726f, 0.24955995f, 0.09073091f, 0.15307483f, -0.00040954f, 0.09023372f, 
    0.04471158f, -0.02881725f, 0.12118259f, 0.06572182f, 0.10663658f, 0.29994920f, 0.11525894f, -0.21143232f, 
    0.01479152f, 0.06456674f, -0.09936217f, -0.06899102f, 0.01175320f, 0.03669947f, -0.03461335f, 0.02878169f, 
    0.11872564f, -0.04334354f, -0.06982770f, -0.12130068f, -0.10707404f, 0.08112030f, -0.04765866f, -0.10452110f, 
    -0.03212570f, 0.01727844f, 0.13511290f, 0.04026305f, -0.02108411f, 0.08862910f, 0.08553914f, -0.08048127f, 
    -0.05396696f, -0.09468073f, -0.01178992f, -0.11056841f, -0.00373987f, -0.01136398f, 0.02631730f, 0.03464524f, 
    -0.19736375f, 0.11147054f, -0.01001611f, -0.06246255f, 0.09415264f, -0.05797838f, 0.08240595f, 0.13589767f, 
    0.12940982f, 0.12868606f, -0.09296605f, 0.07139120f, 0.25349408f, -0.28245357f, -0.12016596f, 0.01309698f, 
    -0.08081247f, 0.03400991f, -0.02291649f, -0.21016572f, -0.04679938f, -0.03705709f, -0.02634786f, -0.00125140f, 
    -0.14903629f, 0.14434758f, -0.10811014f, -0.17198469f, 0.09499456f, -0.00278631f, 0.18193306f, 0.13067435f, 
    0.09827999f, 0.03530438f, 0.07104517f, -0.02105270f, -0.09367391f, -0.02775191f, 0.12147088f, 0.21239568f, 
    0.03501429f, 0.00572641f, -0.14343770f, -0.06396162f, 0.05278821f, 0.01645666f, 0.00069322f, -0.00822052f, 
    -0.10650263f, -0.15205613f, -0.06581377f, 0.06060063f, 0.00002641f, 0.01464779f, -0.14466929f, -0.04969537f, 
    0.01664719f, -0.08734596f, -0.03830257f, -0.09831604f, -0.18513949f, 0.06170161f, -0.02325921f, -0.10837408f, 
    -0.07391357f, -0.02515567f, 0.04662874f, 0.06423617f, -0.02639884f, 0.03790350f, -0.07846829f, 0.03988900f, 
    0.21443076f, -0.08191018f, -0.02882767f, -0.03083960f, 0.04049661f, 0.09162254f, -0.01382890f, 0.07857265f, 
    0.00157826f, -0.03484106f, -0.07216230f, 0.01077013f, -0.03301325f, -0.03447265f, -0.01971159f, 0.21941301f, 
    -0.05911656f, -0.03225212f, 0.00635510f, -0.12143417f, -0.00848361f, 0.07788838f, 0.07742994f, -0.08990272f, 
    0.09564254f, -0.22757931f, -0.06620800f, -0.08252224f, 0.00010224f, -0.01054987f, 0.03141265f, 0.05545706f, 
    0.07187674f, 0.05385436f, 0.04118796f, 0.03329703f, -0.05520182f, 0.15015750f, 0.08028727f, 0.03560637f, 
    0.06776249f, 0.08640867f, -0.05193169f, -0.07643238f, -0.00261748f, -0.16308264f, -0.04157851f, 0.00889462f, 
    0.27129376f, -0.01730308f, -0.01425940f, 0.28064567f, 0.10995615f, -0.02034043f, 0.11648817f, 0.14630695f, 
    -0.04337063f, 0.09414744f, -0.03245543f, 0.02288733f, 0.20443116f, 0.06874078f, -0.12018734f, 0.12426985f, 
    0.03512590f, -0.06687699f, 0.04978836f, 0.07747087f, -0.01510442f, 0.04805402f, 0.03885448f, -0.03401306f, 
    -0.09164529f, -0.35625988f, -0.01215698f, -0.11486118f, 0.05077040f, 0.01672307f, 0.05187268f, 0.00802496f, 
    0.07591254f, 0.11944720f, 0.04195747f, 0.04399474f, 0.02561566f, 0.00799695f, 0.03130109f, 0.12020703f, 
    -0.00092242f, -0.03842174f, 0.08916110f, -0.06532378f, 0.01193358f, -0.04184342f, -0.00844645f, 0.03206562f, 
    0.12882145f, -0.18403514f, -0.06505631f, 0.16522449f, -0.06705968f, 0.12148634f, 0.04225541f, -0.00394904f, 
    0.08642527f, 0.13970317f, 0.08071565f, 0.02908554f, -0.12586237f, 0.03147094f, -0.04583600f, 0.04722148f, 
    0.14901477f, 0.05500374f, 0.01103230f, 0.05799937f, 0.03525131f, 0.00230872f, -0.03113413f, 0.02307345f, 
    0.04682638f, 0.13872737f, -0.09415780f, 0.10787210f, -0.01841492f, -0.01331748f, -0.06503791f, 0.09320827f, 
    0.08975497f, -0.02860682f, -0.11995002f, 0.05062118f, -0.27188182f, 0.11661114f, -0.03083493f, 0.02849451f, 
    0.12070266f, -0.02949408f, 0.00229517f, 0.01064554f, 0.11878401f, 0.04261234f, 0.01676025f, 0.09285501f, 
    -0.16687386f, 0.00359125f, 0.06965961f, 0.17262073f, 0.09410985f, 0.02098009f, 0.01532805f, 0.07211365f, 
    0.06904624f, 0.05052642f, 0.03627235f, 0.05830198f, 0.13147391f, 0.27905995f, -0.04583541f, 0.06425376f, 
    0.01748662f, -0.05865068f, 0.08375360f, 0.13541238f, -0.03569769f, 0.06424048f, -0.10668655f, 0.01056492f, 
    0.29115006f, 0.17973460f, 0.10100591f, 0.04162614f, -0.03789340f, 0.08077680f, 0.05554295f, 0.05770250f, 
    0.04918457f, 0.00104413f, 0.03368902f, 0.07983071f, -0.09460167f, 0.11940811f, 0.02299159f, 0.04489018f, 
    -0.04062317f, 0.11049699f, -0.08943824f, -0.00676296f, 0.00117492f, -0.00274430f, 0.03155825f, -0.08252441f, 
    0.05876528f, -0.16616112f, -0.07180072f, -0.08105266f, -0.00859283f, 0.09721273f, -0.05367852f, 0.01467215f, 
    0.05741116f, 0.03650055f, 0.05128606f, 0.02216659f, -0.02465167f, -0.24411821f, 0.15745278f, -0.01859858f, 
    0.01257811f, 0.02219315f, 0.10107760f, 0.07040608f, 0.04479520f, 0.15325338f, -0.00253012f, -0.01649406f, 
    0.02536721f, -0.09843774f, -0.08859774f, 0.22891442f, 0.15352453f, -0.08776940f, 0.02410256f, -0.02920265f, 
    0.04119890f, -0.00731415f, 0.10722956f, -0.04200085f, -0.14052555f, -0.27174908f, 0.05998714f, -0.14074126f, 
    0.11464880f, -0.00102955f, -0.07950068f, -0.03090273f, 0.10778041f, -0.06178428f, -0.12895408f, 0.02779764f, 
    -0.19883639f, 0.18537892f, 0.03103503f, -0.17052254f, 0.04714486f, 0.07938160f, -0.00592904f, 0.21339120f, 
    -0.02845049f, 0.07537623f, -0.01876648f, -0.06783298f, 0.11181563f, -0.03446831f, 0.02256359f, 0.02551887f, 
    0.09381104f, 0.10606841f, 0.00501419f, 0.09077547f, 0.15900935f, 0.01945450f, 0.07268389f, -0.04400187f, 
    -0.03716530f, -0.27320337f, -0.05437020f, -0.14023536f, 0.06848101f, 0.01776085f, -0.03358804f, -0.09727334f, 
    0.12086242f, -0.01788305f, 0.07462404f, 0.11438718f, 0.22723432f, 0.30523002f, -0.21673124f, -0.01496427f, 
    -0.00577095f, -0.02746848f, 0.02835615f, 0.09553134f, -0.06416555f, -0.03506438f, 0.13804238f, -0.09951986f, 
    0.03121733f, 0.00710367f, 0.02492903f, 0.11941917f, 0.18170671f, 0.04706464f, -0.01787640f, 0.05048805f, 
    0.03236283f, 0.03610695f, 0.06072576f, -0.00502480f, -0.28015089f, -0.02723045f, 0.09903337f, -0.11510398f, 
    0.12278941f, 0.02839081f, -0.02485389f, 0.07106865f, 0.07681638f, 0.07177951f, -0.04885260f, -0.03715856f, 
    0.04327293f, -0.13609672f, 0.15158503f, 0.11778340f, 0.13845538f, 0.09374690f, -0.05473201f, 0.06953023f, 
    0.19040354f, 0.11134681f, 0.02192397f, 0.06321182f, -0.39957619f, 0.06037715f, -0.18721719f, -0.08301742f, 
    0.02261719f, 0.17346279f, -0.05165806f, 0.01457142f, 0.05798027f, 0.02831734f, 0.06485558f, 0.03957976f, 
    0.15842427f, -0.24898885f, 0.00130713f, 0.09846884f, 0.06716008f, 0.00549023f, -0.04331132f, 0.03823756f, 
    0.04414596f, -0.05180786f, 0.11741528f, 0.06738695f, 0.12522994f, -0.15184081f, -0.18659273f, 0.18942112f, 
    0.08972907f, 0.01075146f, 0.11793505f, 0.06701667f, -0.04484957f, 0.00156840f, 0.05520531f, 0.04788746f, 
    0.03296425f, 0.06663080f, 0.17030065f, 0.09637920f, -0.00714154f, -0.02182494f, -0.03622512f, 0.01815478f, 
    -0.10812071f, 0.04393088f, -0.08523533f, -0.09261196f, 0.01367865f, 0.13450556f, -0.14246145f, 0.18638827f, 
    0.06881787f, -0.10063612f, 0.13422160f, -0.09734531f, 0.02909493f, 0.01520359f, 0.11450285f, 0.02781130f, 
    -0.33664411f, 0.38067141f, -0.18526305f, -0.15023503f, -0.07822157f, 0.14686610f, 0.06576909f, 0.00598537f, 
    0.00623833f, 0.06087827f, 0.10790405f, 0.00632835f, -0.07408256f, -0.04356864f, -0.13322589f, -0.11464115f, 
    -0.08385672f, -0.03706019f, -0.01762277f, 0.07942738f, 0.09530294f, -0.00703499f, -0.04619567f, 0.05073278f, 
    -0.28835934f, 0.24935563f, -0.03853228f, 0.14074230f, 0.16314903f, 0.00168274f, 0.01120889f, 0.04333033f, 
    0.00540956f, -0.08508907f, 0.00542111f, 0.10233680f, -0.16579404f, -0.05010564f, 0.09772752f, -0.09536318f, 
    0.07185021f, -0.00682416f, 0.01629316f, 0.06489091f, 0.05262000f, 0.04523539f, -0.02492834f, -0.03440663f, 
    0.27312720f, 0.25343525f, 0.01744191f, 0.05488444f, 0.01095801f, -0.08735593f, 0.14643589f, 0.02409294f, 
    -0.08293884f, -0.01391641f, 0.09958267f, -0.03858757f, 0.14442435f, 0.03554533f, -0.03278564f, 0.18832524f, 
    0.04205768f, 0.00082994f, 0.06844155f, -0.08939067f, 0.07836681f, 0.06929102f, -0.01360344f, -0.03820315f, 
    0.11485333f, 0.11134368f, 0.06177742f, 0.20048304f, -0.01476740f, 0.03243702f, -0.08338998f, -0.07881617f, 
    -0.01550819f, -0.05934959f, 0.08376945f, 0.00832218f, 0.17611824f, 0.33680728f, 0.05986719f, 0.14363989f, 
    0.16451477f, -0.00428970f, 0.02835703f, 0.16051368f, -0.02050106f, -0.01177453f, 0.07193330f, -0.01278211f, 
    0.32016733f, -0.11423332f, -0.14530790f, 0.11954792f, -0.06481467f, 0.19443974f, 0.15834808f, -0.01849228f, 
    -0.03379798f, 0.02763261f, -0.10661975f, 0.01873317f, -0.10362862f, -0.09865866f, 0.02835687f, -0.00686298f, 
    -0.05560213f, -0.10048079f, 0.07347496f, 0.01875321f, 0.08792184f, 0.10706875f, 0.04369462f, -0.02862621f, 
    0.17390326f, -0.21508671f, 0.06504783f, 0.06033986f, 0.09818841f, 0.05356508f, 0.11554117f, -0.01733875f, 
    -0.01533072f, 0.00329544f, 0.01616798f, 0.05756761f, 0.04413491f, 0.24369290f, -0.08701688f, 0.13227573f, 
    -0.05221638f, 0.02947200f, 0.07886263f, 0.05930507f, 0.02854055f, 0.14275105f, 0.05461935f, -0.01578203f, 
    0.10785970f, 0.05103867f, 0.11686689f, -0.06818845f, -0.11491296f, 0.07964001f, 0.12315709f, -0.00701626f, 
    0.06370568f, 0.04355114f, 0.02921628f, 0.06433220f, 0.01946363f, -0.18932234f, -0.04263420f, -0.12926313f, 
    0.14045763f, -0.04490842f, 0.08391085f, 0.11676873f, 0.13294180f, 0.11842808f, 0.18495010f, 0.11357518f, 
    -0.03617369f, -0.27262110f, 0.08760498f, 0.14778365f, 0.10834198f, 0.03030811f, 0.07932866f, -0.09790292f, 
    0.09533814f, 0.00598690f, -0.09769083f, 0.04650686f, 0.15111417f, 0.07869690f, -0.03449944f, 0.28721693f, 
    0.09247737f, -0.13842516f, 0.11697786f, 0.01061367f, 0.07313564f, 0.10242872f, -0.02797124f, 0.03417234f, 
    0.00438646f, -0.27771935f, -0.12320826f, -0.02550905f, 0.00163704f, -0.07420848f, -0.02197760f, 0.05859768f, 
    0.02879307f, -0.03286423f, -0.07369429f, -0.00939432f, -0.02553771f, -0.04793662f, -0.08597545f, -0.18804651f, 
    -0.05046647f, -0.05362164f, 0.02545351f, -0.00492987f, 0.09295838f, -0.14254926f, -0.07610154f, 0.21164168f, 
    -0.17914268f, 0.01497449f, 0.02818248f, 0.02751009f, -0.10948335f, 0.06058576f, -0.07945084f, 0.04194222f, 
    0.02472509f, -0.01304066f, 0.01197385f, 0.02036715f, -0.03996941f, -0.20250216f, 0.16868228f, -0.03814914f, 
    -0.02232018f, 0.00443245f, 0.06480747f, 0.00164627f, -0.10088196f, 0.04332256f, -0.01717076f, -0.02153702f, 
    -0.04478753f, 0.05138905f, -0.06177728f, -0.09947506f, -0.04538670f, 0.02129475f, -0.08894832f, 0.15249942f, 
    -0.04244098f, 0.01441123f, 0.07041819f, -0.05192767f, 0.01970957f, -0.15908960f, 0.04524639f, 0.04099293f, 
    0.01169143f, 0.07511740f, -0.06057482f, -0.05766552f, 0.08334734f, 0.04932182f, -0.01530120f, 0.05265610f, 
    0.38849387f, 0.21683943f, -0.04274769f, 0.14078194f, 0.03517273f, -0.03545544f, 0.05678922f, 0.07543207f, 
    0.00564472f, -0.02007115f, 0.06434965f, 0.00537983f, -0.41981459f, -0.02944943f, -0.06431274f, -0.13332017f, 
    0.01558821f, 0.06479759f, -0.03202119f, 0.18467179f, -0.02054620f, 0.12035377f, -0.02173350f, -0.03391640f, 
    -0.15042056f, -0.21066865f, -0.28919703f, 0.09075145f, 0.14917062f, -0.01583609f, 0.07946305f, 0.07408013f, 
    0.10688676f, 0.00025983f, -0.08101390f, 0.01979085f, 0.01420799f, -0.23487915f, -0.11072588f, -0.04461926f, 
    -0.05093279f, 0.08184420f, 0.04455291f, -0.08334492f, 0.04527562f, 0.02474231f, -0.01648398f, -0.02906381f, 
    0.23285614f, 0.06790366f, -0.03611168f, 0.14864871f, -0.06179069f, -0.05522102f, 0.13923261f, 0.02210438f, 
    -0.05778606f, -0.02094847f, 0.12635361f, -0.09103300f, 0.05119447f, -0.12613115f, -0.07808167f, 0.08563056f, 
    0.05830582f, 0.03840687f, 0.01515288f, 0.02053882f, 0.11548286f, 0.11964093f, -0.07181446f, 0.12085336f, 
    -0.23688081f, -0.16272077f, -0.03301470f, 0.08638177f, 0.03295921f, -0.03940224f, -0.04007037f, 0.16771455f, 
    -0.05558417f, 0.05279529f, -0.04184880f, 0.07238231f, 0.11235295f, -0.10030371f, 0.13897413f, 0.08801702f, 
    0.04992620f, 0.00909255f, 0.02805362f, 0.03688617f, 0.07140425f, -0.06101614f, 0.06375168f, 0.02523163f, 
    -0.00592759f, -0.11880979f, -0.21356678f, -0.13208218f, 0.06492947f, 0.09226785f, 0.07848430f, 0.01701510f, 
    0.03699300f, 0.04545989f, 0.10847458f, 0.08590181f, -0.41640982f, 0.17768206f, 0.01964548f, -0.10788305f, 
    -0.10776635f, 0.09469058f, -0.07301901f, -0.07327902f, -0.09620256f, -0.01989277f, -0.01535124f, 0.07633755f, 
    -0.02233211f, 0.01458347f, -0.01612958f, 0.02727923f, -0.00467682f, -0.02903137f, -0.03868402f, 0.01971897f, 
    -0.01934136f, -0.03100427f, 0.01850635f, -0.00523953f, 0.02383590f, -0.02909070f, -0.03101985f, 0.01744958f, 
    -0.03572107f, -0.01481297f, -0.00509785f, -0.01376955f, 0.02504824f, 0.00607818f, 0.03363346f, 0.02141286f, 
    -0.01081534f, -0.01422307f, 0.01919671f, -0.03757708f, 0.00693481f, 0.00270789f, -0.03919423f, 0.02542263f, 
    0.02188231f, -0.00520665f, -0.02688143f, -0.03462209f, -0.02147021f, 0.00943294f, -0.02881816f, 0.01048452f, 
    -0.01839291f, 0.00309415f, 0.02775230f, -0.02743684f, 0.02447281f, 0.00649365f, 0.01616406f, -0.00869382f, 
    -0.00859990f, 0.02475761f, -0.00219400f, -0.03380077f, -0.00834895f, 0.00313279f, 0.01106595f, -0.00159669f, 
    -0.04018015f, -0.03300336f, -0.03017880f, -0.01109040f, -0.00763588f, 0.02646501f, -0.02815896f, 0.00226734f, 
    -0.02541091f, -0.02101205f, -0.02635034f, 0.00402319f, -0.01302035f, 0.00661148f, 0.00212169f, -0.01234972f, 
    -0.03170290f, -0.01958126f, -0.00581806f, 0.02048188f, -0.01172201f, -0.01598452f, 0.02144987f, 0.01755904f, 
    0.00637598f, 0.02671778f, -0.01051604f, 0.02126153f, -0.02578013f, -0.02993396f, -0.00545080f, 0.00987982f, 
    -0.03609787f, 0.01520806f, -0.00881242f, -0.01576761f, 0.00604810f, 0.02986145f, 0.02323087f, -0.03577487f, 
    0.01262964f, -0.02467299f, -0.00282423f, -0.02731370f, 0.01090213f, -0.01055428f, -0.02109021f, -0.01588356f, 
    0.00913048f, -0.03220084f, -0.01298038f, -0.03695783f, -0.00211319f, 0.01004801f, 0.00403080f, -0.00450690f, 
    0.02695289f, 0.01793239f, 0.01646371f, -0.01398305f, -0.01148814f, 0.01242691f, 0.01706955f, 0.01170090f, 
    0.01916019f, -0.00151795f, 0.01598733f, -0.03694366f, 0.02566077f, -0.03938875f, -0.00308615f, -0.02994788f, 
    -0.03806027f, 0.02107755f, -0.02935472f, -0.01817840f, 0.00044757f, -0.03866000f, 0.01428432f, 0.02388812f, 
    0.02300458f, -0.00716643f, -0.00307741f, -0.00767921f, -0.02976512f, -0.01266335f, -0.01580392f, -0.02725507f, 
    0.01502998f, 0.02891780f, -0.00346753f, 0.02912294f, 0.00675867f, 0.01025745f, 0.02139425f, -0.00637700f, 
    0.02838064f, 0.02735619f, 0.00745780f, 0.01789648f, 0.02329675f, 0.01262548f, -0.00456940f, -0.00952644f, 
    -0.01701800f, -0.02434460f, 0.00949096f, 0.00357319f, -0.01567021f, 0.01815735f, -0.01627514f, 0.03119916f, 
    -0.00564598f, -0.00562245f, 0.01792019f, 0.02444172f, -0.02171849f, 0.01380964f, 0.02431394f, -0.03334165f, 
    0.02490352f, -0.02189761f, -0.02533095f, 0.02369981f, 0.00864067f, 0.02932223f, 0.01444188f, -0.03232118f, 
    -0.01285140f, 0.00586782f, 0.00637870f, 0.00853710f, 0.01065027f, -0.04061324f, 0.01332278f, 0.00188682f, 
    -0.02020662f, -0.00472442f, 0.02285986f, -0.03857391f, 0.01734685f, -0.01524350f, 0.01093810f, 0.01328355f, 
    -0.02693983f, 0.02549675f, 0.00966144f, -0.00637248f, 0.01756489f, 0.03130461f, 0.02166717f, -0.02313226f, 
    -0.02674698f, 0.01274884f, -0.01038664f, 0.01202506f, 0.02843954f, 0.00913604f, 0.03270732f, -0.03782295f, 
    0.02961043f, 0.03064230f, -0.02619979f, 0.01540982f, -0.01408073f, -0.00545834f, 0.00174528f, 0.01274341f, 
    -0.03548931f, 0.02995187f, 0.02898931f, -0.02019267f, 0.00677039f, -0.02070604f, -0.00486489f, -0.02975778f, 
    -0.01411505f, -0.02816092f, -0.01342752f, 0.00995024f, -0.00921603f, 0.00336817f, -0.02009021f, -0.01459262f, 
    -0.01338277f, -0.02186379f, 0.02810413f, -0.00644650f, 0.02925295f, -0.03666139f, -0.02925263f, -0.01915902f, 
    -0.01080548f, 0.02476095f, -0.00954874f, -0.01037374f, 0.02116957f, -0.02689230f, 0.00952576f, -0.03195155f, 
    0.03484682f, 0.02478772f, 0.01750056f, -0.03413508f, -0.03007605f, -0.01954747f, -0.02277896f, 0.01123111f, 
    0.02591173f, -0.03472201f, 0.02381476f, 0.00244852f, 0.03651953f, -0.03586555f, 0.00397325f, -0.03905239f, 
    0.01057332f, -0.00691616f, -0.00921425f, 0.02516662f, -0.01489026f, 0.00375765f, 0.00520266f, 0.00553230f, 
    -0.02529061f, -0.01235537f, 0.01295923f, -0.01476345f, 0.02374121f, -0.02792740f, -0.02270618f, -0.00640013f, 
    0.01161682f, 0.00712511f, 0.01207593f, -0.03002508f, 0.01792171f, -0.02210502f, -0.02700494f, -0.03136486f, 
    0.02067183f, 0.00272608f, 0.01216235f, -0.02689561f, 0.00507322f, -0.03612225f, -0.00188894f, -0.03205243f, 
    -0.00073734f, -0.01972432f, -0.02170845f, -0.00581850f, 0.02240685f, 0.02769315f, -0.02711312f, -0.00227032f, 
    -0.00003986f, -0.03647663f, -0.03950759f, 0.02229957f, -0.02783596f, 0.00494234f, -0.01609298f, -0.01157592f, 
    -0.01103489f, 0.00268320f, -0.02829146f, 0.01483935f, -0.00393077f, -0.03708727f, -0.02864514f, 0.00162890f, 
    0.00614515f, -0.00785743f, -0.03383805f, -0.00297498f, -0.02475047f, 0.00760025f, 0.02894370f, 0.01502110f, 
    0.01547923f, 0.00837542f, -0.00079610f, 0.00833454f, -0.01651108f, -0.03607285f, -0.01850887f, -0.00967217f, 
    -0.02484764f, -0.03272591f, -0.03010010f, 0.01691522f, 0.00922739f, -0.03962908f, 0.00462513f, 0.01826524f, 
    0.01394333f, -0.00609438f, -0.00669136f, -0.00895643f, 0.02822390f, 0.03039964f, -0.01480516f, 0.03140639f, 
    0.03166486f, 0.02606590f, -0.02084258f, 0.00804012f, -0.03711739f, 0.03266206f, 0.00959836f, -0.03440430f, 
    -0.02311541f, 0.00387597f, 0.02490869f, -0.01136111f, -0.02785638f, 0.02528255f, 0.02041160f, 0.03565452f, 
    -0.01486904f, 0.02391357f, -0.00301601f, 0.02336234f, -0.01906479f, -0.01918500f, 0.00409166f, -0.03612958f, 
    -0.03064430f, -0.03435717f, -0.01366803f, -0.01365240f, 0.00177837f, 0.01951027f, 0.02517296f, -0.01571013f, 
    0.00774527f, 0.01396134f, 0.01335060f, 0.00688443f, -0.02361169f, 0.01197790f, 0.00172140f, 0.00464290f, 
    -0.02341259f, 0.02871513f, -0.04151095f, -0.02726766f, -0.03282324f, -0.01897814f, 0.00292992f, 0.01480009f, 
    0.00584861f, -0.03962175f, 0.02456580f, -0.00964469f, -0.02450417f, 0.02885401f, 0.02185247f, 0.02366621f, 
    0.01666056f, -0.02605202f, 0.02118986f, -0.03972411f, -0.00376653f, 0.03027464f, -0.03528494f, 0.01362515f, 
    -0.03327374f, 0.03571178f, 0.02496975f, -0.03704829f, 0.01267279f, 0.00610591f, 0.00838244f, 0.02914464f, 
    0.02272238f, 0.01949216f, -0.01767541f, -0.02703250f, 0.01717874f, -0.00294690f, 0.00689595f, -0.00772414f, 
    0.01603925f, -0.00610299f, -0.02178746f, -0.01847015f, -0.00172974f, 0.01318300f, 0.01544252f, -0.00703133f, 
    0.00856172f, 0.01522875f, 0.01464547f, 0.02620326f, -0.00311004f, -0.01091344f, -0.02377951f, 0.01013594f, 
    0.02882830f, -0.01737130f, 0.02213675f, 0.01884778f, -0.04110175f, -0.03230153f, -0.01609809f, -0.03611689f, 
    0.00939014f, 0.01043267f, -0.00389037f, 0.01963795f, 0.00805247f, 0.02514574f, -0.00441961f, -0.02131040f, 
    0.00273437f, -0.02355240f, -0.02665942f, 0.01534967f, 0.03182880f, -0.03221106f, 0.01357014f, -0.03224039f, 
    -0.00200866f, -0.02888111f, -0.04027529f, 0.02577544f, 0.02873326f, 0.00836256f, 0.00944842f, 0.01714621f, 
    0.01659063f, 0.01154271f, 0.01809413f, -0.01589502f, -0.03585497f, 0.00566550f, -0.03119721f, -0.02859479f, 
    -0.02753601f, 0.03241764f, 0.02729425f, -0.00481549f, -0.03428816f, 0.01954057f, -0.03821597f, -0.00154829f, 
    0.01540881f, -0.02385466f, 0.02606518f, -0.02694876f, 0.01405436f, -0.01171167f, 0.01949489f, -0.00265126f, 
    0.01931929f, 0.00908115f, -0.01897202f, 0.00191757f, -0.01665395f, -0.01825692f, -0.02499200f, 0.01880013f, 
    -0.03927352f, -0.02356186f, -0.03198473f, -0.00250548f, -0.02726172f, 0.01441343f, 0.01115209f, -0.02778727f, 
    -0.01412968f, -0.03762212f, -0.00479777f, 0.00843360f, 0.00964332f, -0.00810967f, -0.03409154f, 0.03193403f, 
    -0.03583386f, -0.01929178f, -0.01703029f, -0.00226481f, -0.00658256f, 0.01966552f, -0.02203881f, 0.02229132f, 
    -0.03085454f, 0.01383823f, -0.04041222f, 0.01421761f, -0.02431316f, 0.03125381f, 0.02469134f, -0.00140346f, 
    -0.02196947f, -0.01720268f, -0.02957094f, -0.02655688f, -0.01463270f, 0.02785324f, -0.02028406f, 0.00573040f, 
    -0.00981421f, -0.00464433f, -0.03361899f, 0.02183054f, -0.02266198f, 0.02867977f, -0.00474933f, -0.03786346f, 
    -0.02235072f, -0.01015622f, -0.02542072f, 0.01577659f, 0.03220597f, 0.03488214f, 0.02886139f, 0.03333354f, 
    0.02392164f, 0.01085673f, -0.00097131f, 0.00501840f, 0.02657570f, 0.03388590f, -0.00711713f, -0.03293590f, 
    -0.00475076f, -0.00833633f, 0.02907029f, -0.02701224f, -0.01106797f, -0.01651671f, -0.03157108f, 0.00132390f, 
    -0.00260579f, -0.01375210f, 0.02507152f, -0.02407055f, 0.01935198f, 0.03165925f, -0.01489595f, 0.02333815f, 
    0.01515156f, 0.01531752f, 0.00256825f, 0.02277171f, 0.01736605f, -0.03533542f, -0.01783173f, -0.00407184f, 
    -0.04033460f, 0.01820949f, -0.03826002f, -0.03563850f, -0.03319016f, 0.00928404f, -0.03763858f, 0.02940226f, 
    -0.00895990f, -0.02674516f, -0.00029100f, 0.02869633f, 0.03196634f, -0.03503815f, -0.00001065f, -0.03043935f, 
    0.02501886f, -0.00207186f, 0.02891383f, 0.00312255f, 0.00334095f, 0.00573040f, -0.00594623f, 0.00335376f, 
    -0.00850183f, -0.03686040f, -0.01554738f, -0.03605136f, 0.02944883f, 0.00825715f, -0.02069621f, 0.03061989f, 
    0.01712251f, -0.01979626f, 0.00578757f, 0.00791861f, -0.02097150f, -0.03506874f, -0.02927837f, -0.03660252f, 
    0.02607549f, -0.02146402f, -0.02006087f, -0.02121708f, -0.01819987f, 0.02180950f, -0.03420997f, -0.03495416f, 
    -0.03165379f, -0.03260944f, -0.03325277f, 0.02068299f, 0.02955481f, -0.03109755f, 0.02911189f, 0.02628817f, 
    -0.00795668f, 0.01449797f, -0.03840898f, 0.00444154f, -0.03228744f, -0.01257105f, 0.01650429f, -0.02655210f, 
    -0.01425314f, -0.03934595f, 0.03276642f, -0.02942019f, -0.03570649f, -0.01237819f, -0.00612419f, -0.00594077f, 
    -0.03181429f, 0.02339986f, -0.01823308f, -0.00272246f, 0.01740094f, -0.01315131f, -0.01959226f, -0.00223793f, 
    -0.01431090f, 0.00575662f, -0.04071943f, 0.01650599f, 0.02722516f, -0.03762608f, -0.02784524f, -0.02396855f, 
    0.02142394f, -0.01966785f, 0.00510028f, 0.02797863f, -0.02236741f, -0.02640613f, 0.03088017f, 0.02704154f, 
    0.03293497f, -0.02574375f, 0.01664436f, 0.01183610f, -0.00924856f, -0.01143390f, 0.02125842f, 0.02662669f, 
    -0.02550460f, 0.02708028f, 0.01892228f, -0.03177590f, -0.03776718f, -0.03951179f, 0.00388625f, -0.01199952f, 
    0.01794573f, -0.00572715f, 0.02124679f, 0.03237027f, 0.01899938f, -0.00634139f, 0.02596610f, 0.01727665f, 
    -0.03869764f, 0.03073310f, 0.02213752f, 0.02737478f, 0.00768395f, -0.01052668f, 0.01109945f, -0.02249420f, 
    0.00014379f, 0.01553695f, -0.01218759f, -0.01583955f, -0.03475317f, 0.00136969f, -0.00323368f, -0.03391064f, 
    -0.01650665f, 0.01503016f, -0.01150129f, -0.01758311f, 0.03209404f, -0.01837922f, 0.01784113f, 0.02484200f, 
    -0.02046177f, 0.01093173f, 0.01515722f, 0.03113038f, 0.00408563f, 0.00572121f, 0.01482925f, -0.02351719f, 
    -0.00231844f, -0.03850118f, -0.01121096f, -0.04383158f, -0.01697976f, -0.00141828f, -0.03332028f, -0.02068239f, 
    -0.18895887f, -0.13168740f, 0.05226069f, -0.05639721f, -0.01990438f, 0.01195490f, 0.03903826f, 0.10997332f, 
    0.05193721f, -0.01384116f, -0.08268291f, 0.03990824f, -0.04739479f, -0.29361832f, -0.18093206f, -0.35320586f, 
    0.08331094f, 0.08487763f, 0.03400236f, 0.05688855f, 0.00250802f, -0.07530735f, 0.05985022f, 0.08066778f, 
    -0.11215688f, 0.18000236f, 0.15668318f, -0.11740325f, -0.11316285f, -0.03702011f, 0.01747919f, 0.02947812f, 
    -0.05991686f, -0.06293114f, 0.06058149f, -0.01688116f, -0.07729271f, -0.16209553f, -0.03975445f, 0.01003091f, 
    0.04703353f, -0.01737922f, 0.03750453f, 0.11177383f, 0.01897943f, 0.06211868f, -0.01971145f, 0.06000609f, 
    0.07842454f, -0.00638568f, 0.06592476f, -0.03811806f, -0.03650593f, 0.01885939f, -0.02994377f, -0.07358840f, 
    0.12112842f, -0.05107220f, 0.08602180f, 0.03758405f, -0.25750336f, -0.09485615f, -0.26062042f, -0.27263510f, 
    0.10115964f, 0.07045017f, 0.02665565f, -0.04535670f, -0.01501053f, 0.06842977f, -0.00244653f, 0.06929767f, 
    0.14633420f, 0.04645559f, 0.01432919f, 0.17647620f, -0.08141485f, 0.02275428f, -0.07267937f, 0.05255946f, 
    -0.00447502f, -0.01702768f, -0.00929587f, 0.05575482f, 0.03077100f, -0.21759397f, -0.05957590f, 0.01212238f, 
    -0.03116387f, 0.00546410f, 0.00456123f, -0.03066063f, -0.13061842f, -0.07496203f, 0.05580917f, 0.12051809f, 
    -0.02122148f, -0.15366279f, -0.02218745f, 0.11047471f, -0.07721870f, -0.03921427f, -0.00316592f, 0.08163670f, 
    -0.01401420f, -0.02984097f, -0.02931485f, -0.00155450f, 0.07150864f, -0.13674480f, 0.05300524f, 0.08351211f, 
    -0.04457058f, 0.07340381f, 0.05241316f, -0.13251153f, -0.09317752f, 0.07215633f, -0.00358125f, 0.00410417f, 
    0.11101750f, 0.00025314f, 0.07494085f, 0.01197641f, -0.05123910f, 0.02190307f, 0.14392881f, -0.04859702f, 
    -0.00868672f, 0.05667958f, 0.08635587f, 0.11830524f, 0.20802175f, -0.02496235f, 0.14960539f, -0.02415866f, 
    -0.12060410f, 0.00465371f, 0.06079573f, -0.07352240f, -0.03432496f, 0.04762069f, -0.03484370f, 0.01320101f, 
    0.03282955f, 0.19951925f, 0.25428897f, -0.16178130f, -0.12037232f, 0.10361272f, -0.00477719f, -0.03389879f, 
    0.02958480f, -0.02953732f, 0.09786586f, 0.08809660f, -0.25032154f, -0.18251868f, -0.25855291f, -0.17409386f, 
    0.07664480f, 0.07417992f, 0.05394452f, -0.08153044f, -0.01378692f, 0.05210093f, 0.03386587f, 0.08926890f, 
    -0.04763011f, -0.15326513f, -0.08764229f, 0.04473443f, -0.01115461f, -0.08466384f, -0.01125063f, 0.10007054f, 
    -0.01032150f, 0.08267670f, 0.00239217f, 0.04130846f, -0.12350231f, -0.08749159f, 0.10455436f, -0.01431150f, 
    0.06389481f, -0.02867692f, 0.10426314f, 0.03478277f, 0.03189983f, 0.09829681f, -0.01603915f, -0.01096409f, 
    0.01046919f, 0.09354881f, 0.23232549f, 0.00282138f, 0.01915962f, -0.00464109f, 0.06210636f, 0.01756928f, 
    0.04135224f, -0.00148173f, 0.02909243f, -0.03402049f, 0.12409277f, -0.26078156f, -0.09156233f, -0.03096507f, 
    -0.03502112f, 0.07657211f, 0.01037401f, 0.16681509f, 0.11524210f, -0.00392409f, 0.01080415f, 0.03041933f, 
    0.01838518f, 0.08624844f, 0.04618053f, -0.09255559f, -0.13833354f, 0.07396518f, -0.03337931f, 0.00738003f, 
    0.04731300f, 0.00462351f, -0.08394264f, 0.03106188f, -0.11543564f, 0.01602440f, 0.03346074f, 0.13753909f, 
    0.06577423f, 0.12349720f, 0.03200844f, 0.11026000f, 0.01535910f, 0.00653868f, -0.03151399f, -0.08568877f, 
    -0.27170238f, -0.12884794f, -0.06295398f, -0.04906198f, 0.08234496f, -0.09579202f, -0.00947141f, -0.13642088f, 
    0.05669124f, 0.04232527f, 0.09971710f, 0.10900686f, -0.07846563f, -0.09158354f, 0.17199993f, 0.02319721f, 
    0.02612839f, -0.02487247f, -0.06278529f, 0.08017659f, -0.04179104f, -0.06232781f, -0.03371524f, 0.02523035f, 
    0.06179629f, 0.18570489f, 0.14294292f, 0.15233539f, -0.07347243f, 0.03116860f, 0.02260140f, 0.09770003f, 
    -0.04224507f, 0.00605743f, 0.00700352f, 0.07735240f, 0.01330368f, -0.01533664f, 0.03342593f, -0.15909477f, 
    -0.00279687f, 0.04874464f, -0.08129516f, 0.04460793f, 0.01195272f, 0.12515923f, -0.03424261f, -0.03222806f, 
    -0.12720113f, -0.05763754f, 0.07852457f, 0.07389292f, -0.01635629f, 0.03116414f, -0.05213238f, 0.03901776f, 
    0.00626750f, 0.07561041f, 0.03494818f, 0.09188312f, 0.11022053f, -0.07193720f, -0.03134967f, 0.10977171f, 
    -0.05360910f, -0.00046116f, 0.07567146f, -0.12018225f, -0.05887006f, -0.06727386f, -0.04477334f, 0.03882990f, 
    -0.03242752f, 0.04110355f, 0.04052580f, 0.21156925f, 0.00424918f, -0.04640849f, 0.05943470f, -0.03023992f, 
    -0.12250997f, -0.10978815f, 0.03090792f, -0.04504563f, -0.06487202f, 0.04507382f, 0.19334738f, 0.19549194f, 
    0.03030188f, -0.06479242f, 0.12600967f, -0.05327876f, -0.03761302f, -0.04612230f, -0.01792615f, -0.02776493f, 
    -0.08314107f, 0.13606565f, 0.10281519f, -0.09980560f, 0.03343308f, 0.02155177f, 0.04049427f, 0.01697905f, 
    0.07392087f, 0.11352964f, -0.00128580f, 0.07071216f, -0.08019564f, -0.11243730f, 0.06298241f, -0.16311619f, 
    0.00006455f, 0.09980978f, -0.07740467f, 0.00400920f, 0.02410313f, 0.02240834f, -0.02370529f, 0.00168564f, 
    -0.01966055f, -0.23252076f, -0.04902506f, -0.09614738f, 0.22632283f, 0.03376275f, -0.01208003f, 0.10981202f, 
    0.19753256f, -0.01871906f, -0.00625329f, 0.06543414f, -0.04996810f, -0.02866510f, 0.12187000f, -0.18045525f, 
    0.00468709f, -0.02150181f, -0.03853165f, 0.10718909f, -0.04200444f, -0.02273121f, -0.02902891f, -0.06835833f, 
    -0.10801227f, -0.11055286f, 0.11347744f, 0.01103542f, 0.00541664f, 0.06652947f, 0.08924303f, 0.08501539f, 
    0.02199578f, -0.03343235f, -0.10838777f, 0.01226326f, 0.15327804f, 0.08002765f, 0.08999920f, 0.04434282f, 
    0.04029686f, 0.01912451f, 0.07919480f, -0.00467006f, -0.01216622f, 0.05564839f, 0.05515394f, 0.00190904f, 
    -0.26047096f, -0.11043964f, 0.08872765f, 0.05216275f, 0.01386813f, -0.01807269f, 0.01972990f, 0.10706710f, 
    -0.02856620f, -0.02058450f, 0.11275305f, 0.04456930f, 0.07939602f, 0.18966408f, 0.08370739f, -0.02308692f, 
    0.04549880f, 0.03340318f, -0.01448356f, 0.04452745f, 0.09967309f, 0.13098265f, 0.00076145f, 0.00401438f, 
    -0.15472579f, -0.25885856f, -0.22946768f, -0.34660196f, 0.08939568f, 0.02304304f, -0.08831211f, 0.08371197f, 
    0.00102053f, 0.00778228f, -0.00353104f, 0.02915427f, -0.04558315f, 0.11451407f, 0.11214703f, -0.01210411f, 
    0.00748502f, 0.03194088f, -0.06124584f, 0.08873039f, -0.09879895f, -0.08339243f, 0.09506480f, 0.10356657f, 
    -0.32424569f, -0.04338284f, -0.10051919f, -0.12193787f, 0.08074461f, 0.02111327f, 0.11054132f, 0.07119785f, 
    0.05957637f, 0.01519398f, -0.06788336f, 0.00822589f, 0.01469368f, 0.05263330f, -0.03934413f, -0.01612881f, 
    0.09791655f, 0.04826019f, 0.02815786f, -0.05846032f, 0.12767121f, -0.02158473f, 0.07048114f, -0.04422721f, 
    0.19135508f, -0.03267325f, 0.07012806f, 0.11395156f, -0.12806559f, -0.07899410f, -0.00517600f, 0.03207233f, 
    -0.00691118f, -0.00407862f, 0.10186544f, 0.06974627f, -0.36474642f, -0.00896695f, 0.18269874f, 0.14720285f, 
    0.02512780f, 0.02204302f, -0.05578414f, -0.00911798f, 0.01990681f, -0.03070464f, -0.01480462f, 0.05461980f, 
    0.04441792f, -0.20981467f, 0.08553049f, -0.10684577f, 0.09093406f, -0.07345706f, -0.06016286f, -0.05204891f, 
    0.05705168f, -0.15271007f, -0.01664820f, -0.05437516f, -0.02088729f, -0.11925863f, -0.20739225f, 0.01092867f, 
    0.18770535f, 0.12215605f, 0.04969632f, -0.02193599f, -0.01176781f, 0.03706266f, 0.03790320f, -0.00719684f, 
    0.04916032f, -0.08995227f, 0.05918210f, 0.04602602f, -0.01812855f, -0.02435643f, -0.03958536f, 0.02416697f, 
    0.07128813f, 0.09317981f, 0.04334202f, 0.11376827f, 0.03127202f, 0.12565818f, 0.09720153f, 0.07354757f, 
    -0.07151643f, 0.01715721f, 0.04859985f, -0.09180592f, 0.09774373f, -0.10850394f, 0.02404364f, 0.02396949f, 
    -0.16021781f, 0.00841766f, 0.09489431f, 0.19244625f, -0.08775047f, 0.09843012f, -0.09603856f, 0.08069115f, 
    -0.04828455f, 0.03599835f, -0.14059356f, 0.14396483f, 0.04140053f, -0.14964768f, 0.30117750f, -0.26663014f, 
    -0.05792433f, 0.07009355f, 0.01303814f, 0.02045707f, -0.01492424f, -0.05510239f, 0.06257841f, -0.04870949f, 
    -0.13990401f, 0.27375442f, 0.24171861f, -0.07704533f, -0.05124009f, 0.04083528f, -0.02752460f, -0.01878069f, 
    0.09315518f, 0.00705465f, 0.02089535f, 0.04202001f, -0.04826096f, 0.16637357f, 0.15020823f, 0.10528808f, 
    0.08106708f, 0.00062128f, 0.06601214f, 0.05045164f, 0.03352454f, 0.03224837f, 0.07733260f, 0.00958715f, 
    0.10235430f, 0.16784158f, 0.12996627f, -0.08587165f, 0.06619078f, 0.02605574f, -0.00491276f, 0.03359046f, 
    0.04521919f, 0.04074274f, 0.03818452f, -0.00208167f, 0.05391036f, -0.20901276f, 0.06471634f, 0.12779425f, 
    -0.07454579f, 0.09158328f, 0.05844663f, 0.07446520f, 0.15031594f, 0.08277240f, -0.02463545f, 0.00317767f, 
    -0.03938223f, 0.09095285f, 0.15853746f, 0.00993066f, 0.10847742f, 0.02635384f, 0.03552992f, 0.02325234f, 
    0.12538785f, 0.01286222f, 0.13413921f, 0.05644560f, 0.01421835f, -0.03888965f, 0.10114686f, 0.06998228f, 
    -0.06554268f, 0.04474196f, -0.09953702f, 0.03324030f, 0.06150999f, 0.06458799f, -0.01791282f, -0.04926923f, 
    -0.36310640f, -0.08850969f, -0.15127660f, -0.15320350f, 0.04758668f, 0.09216174f, 0.02934632f, -0.06127082f, 
    -0.04364040f, 0.10316782f, 0.05828378f, 0.05450815f, -0.12621225f, -0.02644607f, -0.04348582f, -0.03920108f, 
    0.07620571f, 0.03686506f, -0.03562407f, -0.04836265f, 0.09805895f, 0.09241696f, 0.17050961f, 0.11705442f, 
    0.03536195f, 0.01938207f, 0.21721269f, -0.16485745f, -0.05592887f, 0.03034223f, 0.01511760f, 0.02741566f, 
    -0.00670929f, 0.07181741f, 0.04583270f, 0.03674595f, -0.03165669f, 0.15649715f, 0.11716004f, 0.07547338f, 
    -0.06569312f, -0.04481198f, 0.04868060f, 0.06608291f, 0.04629856f, 0.06450468f, 0.06297906f, 0.04845995f, 
    -0.25149500f, -0.20302662f, -0.33866552f, -0.12875281f, 0.03966284f, 0.06750201f, 0.04406901f, 0.02422709f, 
    0.06247830f, 0.02680300f, -0.02756448f, -0.02473276f, -0.11271454f, 0.06211701f, 0.16434297f, 0.06275176f, 
    -0.09121791f, 0.07404629f, 0.04033310f, -0.02862940f, 0.04803907f, 0.01153777f, -0.00962704f, 0.01067370f, 
    -0.17215702f, -0.00463015f, -0.16413730f, -0.13723342f, 0.05653577f, 0.04492379f, 0.07379940f, -0.08689129f, 
    -0.01411578f, -0.03850250f, -0.02378019f, 0.12445103f, -0.09206804f, 0.21065390f, 0.15036876f, -0.02368646f, 
    -0.03676364f, -0.01116917f, 0.00281760f, -0.02078905f, 0.03969647f, -0.00349633f, -0.01058167f, 0.13476902f, 
    0.08865089f, 0.12686932f, 0.23312791f, 0.11637391f, -0.13075010f, 0.02032524f, 0.01656019f, 0.05145159f, 
    -0.01145554f, 0.02484284f, -0.02832969f, 0.09771731f, 0.01922480f, -0.11290798f, 0.02615859f, 0.02061354f, 
    0.10495005f, 0.01517303f, 0.04245128f, 0.07804142f, -0.03027777f, 0.02861754f, 0.05749833f, 0.08887494f, 
    -0.01606101f, -0.00080832f, -0.03679108f, -0.00639120f, -0.00783666f, 0.02485728f, -0.00602665f, -0.01918987f, 
    -0.00963976f, 0.02651651f, -0.00131509f, 0.01295682f, -0.00306184f, -0.03279489f, -0.01686531f, -0.02720736f, 
    0.02437137f, 0.01228882f, 0.00710140f, 0.01614228f, -0.03311687f, 0.00363419f, -0.03439213f, 0.02246655f, 
    -0.01067169f, -0.03444348f, -0.01694590f, -0.01149935f, 0.02801257f, -0.01492647f, 0.01130044f, -0.03961643f, 
    0.02505310f, -0.02986555f, -0.01579091f, 0.00612197f, 0.01914145f, -0.03617836f, -0.00709992f, -0.03924025f, 
    -0.03984863f, 0.01061810f, -0.03929083f, 0.01273677f, -0.01265005f, 0.00659270f, -0.01957069f, 0.01135173f, 
    0.01501288f, -0.00264967f, 0.02809487f, -0.03567074f, -0.02843506f, -0.02559466f, 0.00350975f, -0.00349214f, 
    0.01367981f, -0.02690859f, 0.02139066f, -0.03950891f, -0.01461414f, -0.00055100f, 0.00945084f, 0.01563822f, 
    -0.01930508f, -0.03719706f, -0.01376016f, -0.02794526f, 0.02200437f, -0.04170782f, 0.01977130f, -0.00868500f, 
    -0.02468847f, -0.01065402f, -0.03430419f, -0.03639916f, 0.00405695f, -0.03712152f, -0.02276203f, -0.00041268f, 
    0.01933520f, -0.00434187f, -0.00192357f, 0.01830347f, 0.01986699f, -0.03324218f, -0.03503533f, -0.00943469f, 
    -0.02080639f, -0.02069498f, -0.00259600f, -0.02180894f, 0.01430294f, -0.03440085f, 0.02690223f, -0.02902850f, 
    0.01262732f, -0.01691933f, -0.01813410f, 0.02820297f, -0.02851281f, -0.03268331f, -0.01838046f, 0.01099158f, 
    -0.01664721f, 0.02057157f, 0.01951358f, -0.01605455f, 0.02732196f, 0.02533066f, -0.03896893f, -0.03971756f, 
    -0.02643946f, 0.00757726f, 0.00743229f, -0.01483493f, -0.03376338f, 0.02356454f, 0.00623907f, -0.00698086f, 
    -0.02385397f, -0.00259370f, -0.02819121f, 0.01106966f, -0.01408754f, -0.02582713f, -0.00692866f, 0.02032105f, 
    -0.01022993f, -0.00916251f, -0.01235034f, -0.01516495f, -0.01080089f, -0.00551449f, 0.02973332f, -0.00018136f, 
    -0.02658041f, -0.01614354f, 0.01870571f, 0.02443705f, -0.02528963f, -0.02906143f, 0.02795319f, -0.03983717f, 
    0.02911428f, -0.03614989f, -0.03556635f, -0.03846058f, 0.00765023f, -0.01285334f, -0.03465211f, 0.02968451f, 
    -0.00402813f, -0.01174056f, -0.03219563f, -0.02764540f, -0.02029404f, -0.02095025f, -0.01676916f, -0.00920974f, 
    -0.02928266f, 0.00514355f, 0.02787779f, -0.01182767f, -0.02655700f, 0.00935656f, -0.00475500f, -0.02451411f, 
    0.01570406f, 0.00480711f, -0.00301083f, 0.02350824f, -0.02610035f, -0.01657484f, -0.02642994f, -0.02829786f, 
    0.00373521f, -0.04102943f, 0.01012968f, -0.02678791f, -0.02043913f, 0.02659605f, -0.03008387f, 0.00790207f, 
    0.02727469f, -0.03287897f, -0.02427248f, 0.01180425f, 0.00771377f, 0.00459887f, 0.00967626f, -0.04068648f, 
    -0.00845775f, 0.01534495f, -0.03854591f, -0.01469732f, -0.03801345f, 0.00327561f, -0.01766806f, -0.02941255f, 
    0.02063292f, 0.02695878f, -0.00938988f, -0.01730875f, -0.01114546f, 0.00610991f, 0.02082439f, -0.00217423f, 
    -0.01660842f, 0.02523743f, -0.00331754f, -0.04078190f, 0.00124589f, 0.01204925f, 0.01068751f, 0.01134057f, 
    -0.03471314f, -0.00080357f, -0.00278322f, 0.02167202f, 0.03071182f, -0.01084752f, -0.02577766f, -0.03492079f, 
    0.00861549f, 0.00075162f, -0.01227136f, 0.00099732f, -0.01767533f, -0.03532297f, 0.01170302f, -0.02230390f, 
    -0.01253293f, -0.01444946f, -0.01751076f, 0.02617249f, 0.02217684f, -0.03227266f, -0.02402001f, 0.01499192f, 
    -0.00855277f, -0.02049605f, -0.03552384f, -0.00222562f, 0.00508072f, -0.02148832f, -0.01157067f, 0.00185679f, 
    0.02524749f, -0.01826237f, -0.02696709f, -0.00671097f, -0.03469404f, -0.00669502f, -0.00919035f, -0.00512205f, 
    -0.03942196f, 0.01806393f, -0.03269210f, 0.01571588f, 0.01259948f, 0.01195604f, -0.01353756f, 0.01834128f, 
    -0.01013910f, -0.00851930f, -0.00998798f, 0.00397915f, -0.02236077f, -0.02476764f, -0.01666648f, -0.03441254f, 
    -0.01907847f, -0.01058862f, 0.02920142f, -0.03039704f, 0.02660530f, -0.02399573f, -0.01426795f, -0.03643195f, 
    -0.01496997f, -0.03842432f, -0.04048236f, -0.04423287f, -0.00792233f, -0.01571864f, 0.00271230f, 0.00829671f, 
    -0.04319552f, -0.00538122f, 0.00063075f, 0.02577760f, -0.02802184f, 0.00725696f, -0.01388450f, -0.02274377f, 
    -0.03011879f, -0.03333491f, 0.01000430f, -0.03194267f, -0.01730833f, -0.00602830f, 0.02519578f, -0.02829180f, 
    -0.00251263f, 0.00071577f, -0.01367256f, -0.00412009f, 0.01863766f, -0.01629808f, -0.02690575f, 0.02223491f, 
    -0.01583595f, 0.00627833f, -0.00776374f, 0.00861846f, -0.02747433f, 0.01224756f, 0.00398022f, -0.02289075f, 
    -0.00874922f, 0.01146508f, 0.00302046f, -0.00090151f, 0.01255937f, -0.02647742f, -0.02098227f, -0.03276917f, 
    -0.00022790f, -0.03183272f, -0.02407510f, 0.02982442f, 0.01799089f, -0.03938350f, -0.00925271f, -0.02688828f, 
    -0.00035054f, 0.01922563f, -0.01926806f, -0.00843739f, -0.00125506f, 0.01322691f, -0.01367801f, 0.01376561f, 
    -0.00622615f, -0.04345250f, 0.01690874f, -0.00621493f, -0.01391851f, 0.01221554f, 0.00288931f, -0.01463665f, 
    0.02633761f, -0.03209425f, -0.02207866f, -0.04086006f, 0.02001601f, -0.04207411f, -0.00492659f, -0.02038696f, 
    -0.03488399f, -0.01058056f, -0.01223248f, 0.00488864f, -0.02481791f, 0.01722387f, 0.01180510f, -0.03693004f, 
    -0.02247472f, -0.02079274f, 0.01724713f, 0.02346054f, 0.02592852f, -0.01332074f, -0.01539832f, -0.03172521f, 
    0.01060724f, -0.04190606f, 0.02758749f, -0.00977331f, 0.00112732f, 0.00052527f, 0.00203963f, 0.02612459f, 
    -0.01719784f, 0.00047540f, -0.00086163f, 0.02641484f, 0.00727774f, 0.01312193f, -0.00215166f, -0.03831353f, 
    -0.01411766f, -0.01083405f, -0.01039331f, -0.02420278f, -0.01852636f, -0.03364833f, 0.01349435f, -0.00124596f, 
    -0.02685191f, 0.00815419f, 0.01227658f, 0.00454287f, -0.02952527f, 0.01624953f, 0.01736179f, 0.00172323f, 
    0.02260366f, -0.02426880f, 0.00520690f, -0.01495232f, -0.03750435f, 0.01967687f, -0.02906032f, -0.00535528f, 
    -0.03285177f, -0.02152237f, 0.00223687f, -0.03986767f, -0.00187619f, 0.02033001f, -0.02211635f, 0.03033425f, 
    0.02180410f, 0.01830258f, -0.03813821f, -0.02644144f, 0.01034547f, -0.01308379f, -0.00350363f, 0.02332205f, 
    0.01826420f, 0.01525837f, 0.01012048f, -0.03231714f, 0.00717637f, -0.00731358f, -0.00591213f, -0.02269451f, 
    0.02135827f, -0.01117153f, -0.02021999f, 0.02935000f, 0.01617390f, 0.01942671f, 0.00246122f, -0.02190057f, 
    0.00370242f, -0.00014594f, 0.01984839f, -0.00146951f, 0.00949399f, 0.00894323f, 0.01498081f, 0.02669569f, 
    -0.01431504f, 0.01268558f, -0.02985655f, 0.02183900f, 0.00562133f, -0.03764801f, -0.01819286f, -0.02218197f, 
    0.01378048f, -0.03525421f, 0.00525879f, -0.03558467f, 0.00382486f, -0.03986527f, -0.03955333f, 0.01663904f, 
    0.02519013f, -0.02439521f, -0.02209641f, -0.04159049f, 0.02036911f, -0.03193976f, -0.02738195f, -0.01356281f, 
    -0.00998558f, -0.03838629f, -0.00235627f, 0.02715137f, -0.01243224f, 0.02718367f, -0.01315638f, -0.01312480f, 
    0.00793422f, 0.00728797f, 0.00362090f, -0.01070543f, -0.01705864f, -0.04015222f, -0.01796021f, 0.00190663f, 
    -0.01689897f, -0.00120710f, 0.00768214f, -0.02390219f, 0.00278910f, -0.04079000f, 0.01790789f, -0.00565807f, 
    -0.00877639f, 0.01887577f, 0.00464407f, 0.00003768f, -0.00750372f, 0.00109630f, -0.03387763f, -0.00303958f, 
    0.02510318f, 0.01686539f, 0.00368699f, -0.03039954f, -0.03998384f, -0.02640722f, -0.01834512f, 0.01922924f, 
    0.00230470f, 0.02313751f, -0.04136712f, -0.02315116f, -0.03681044f, -0.02719064f, -0.00466831f, -0.00083111f, 
    -0.02707007f, -0.01463332f, 0.01006071f, 0.02007114f, 0.02422705f, -0.00552216f, 0.01093009f, 0.02503098f, 
    -0.03722833f, 0.01687753f, 0.02072385f, -0.01401212f, -0.03296245f, -0.00512986f, -0.00003992f, -0.00227966f, 
    -0.02636331f, 0.00584723f, 0.02387477f, 0.00230714f, 0.02498488f, -0.02455214f, -0.00540466f, -0.03058947f, 
    -0.01925431f, 0.01278971f, -0.01647005f, -0.00947741f, 0.00333093f, 0.02801836f, 0.00936132f, 0.01327179f, 
    -0.00794688f, -0.00589439f, -0.00930941f, -0.02399605f, -0.03789610f, -0.02659883f, 0.01357326f, 0.00226826f, 
    0.00119830f, -0.02418429f, -0.01251956f, 0.02335967f, -0.02735009f, -0.01651126f, -0.01642393f, -0.03276990f, 
    0.01984174f, -0.01773053f, 0.00189806f, -0.02650040f, -0.01244586f, 0.00311242f, 0.00950369f, 0.02049691f, 
    -0.03929139f, -0.02177018f, -0.02606538f, -0.02030804f, -0.02228429f, 0.00759628f, 0.01103251f, 0.00107524f, 
    -0.00633842f, 0.01016924f, -0.01095179f, -0.00057691f, 0.02057047f, 0.02917601f, -0.01243412f, -0.04155016f, 
    -0.02767513f, -0.01519025f, 0.02431008f, 0.00817403f, 0.02278170f, -0.01873852f, -0.01010989f, 0.02457255f, 
    0.01541088f, -0.02603050f, 0.01789085f, 0.00062387f, 0.01034535f, -0.02427970f, 0.00374005f, -0.01236233f, 
    -0.00755450f, -0.03063187f, -0.04442921f, -0.00292056f, -0.01442254f, -0.02122162f, -0.03401680f, 0.00819895f, 
    -0.01242252f, -0.01010631f, -0.03359804f, -0.04331714f, -0.03036475f, 0.00196279f, -0.01721432f, -0.02367833f, 
    -0.00252942f, 0.01809710f, 0.01946547f, -0.00736773f, -0.03350036f, -0.03486788f, 0.00003201f, 0.01830904f, 
    -0.02506789f, -0.02031143f, 0.02154893f, 0.01692146f, -0.01803650f, -0.00743428f, -0.02190270f, 0.02834305f, 
    -0.00480606f, -0.00209178f, -0.03538632f, 0.00093217f, 0.00088201f, 0.02792221f, -0.00184455f, 0.02773924f, 
    -0.03754585f, -0.02297539f, 0.02388977f, -0.00734496f, -0.00141805f, 0.00308639f, -0.00215180f, -0.01180641f, 
    -0.02829438f, -0.03313965f, -0.03488814f, 0.00491645f, 0.02450914f, -0.02414769f, 0.00682515f, -0.03632299f, 
    0.01247146f, -0.03389374f, -0.01277532f, -0.01756407f, -0.03516166f, 0.00432331f, -0.03236281f, -0.03855357f, 
    0.01486761f, 0.01085655f, 0.01774220f, 0.00591669f, 0.00950362f, -0.03399904f, 0.01530451f, -0.00378704f, 
    -0.04544752f, -0.03281698f, -0.02311396f, -0.01000802f, -0.02760089f, -0.03831466f, 0.02481233f, -0.04157858f, 
    0.01807407f, 0.02630295f, -0.00387638f, -0.00660958f, 0.02681471f, -0.03879242f, -0.00907856f, 0.00445570f, 
    -0.03799633f, 0.01675056f, 0.00639789f, 0.00902783f, 0.01580948f, 0.02578658f, -0.00343652f, -0.03263211f, 
    0.02554917f, 0.01722248f, 0.01799767f, 0.00224741f, 0.02270139f, 0.00716523f, -0.01301143f, 0.01015957f, 
    -0.00735365f, -0.01290882f, -0.03377774f, -0.00996796f, -0.02118554f, -0.02089822f, -0.01814709f, -0.00771249f, 
    -0.00640156f, 0.00140652f, 0.02470676f, -0.00709206f, -0.03966314f, 0.00973961f, -0.01692705f, 0.00772352f, 
    0.01139957f, 0.02169019f, -0.03332771f, 0.00101534f, -0.01842629f, -0.03998344f, -0.01823418f, 0.01169142f, 
    -0.03637978f, -0.01980098f, -0.00841643f, 0.00164732f, -0.00164679f, -0.02859673f, -0.03896036f, 0.03392611f, 
    -0.01675595f, -0.01154422f, -0.02453919f, 0.01658958f, -0.03257599f, -0.02828038f, -0.00811207f, -0.04196795f, 
    0.00854393f, 0.01761152f, -0.01271487f, -0.02810177f, -0.03844823f, -0.02042347f, 0.00158201f, 0.02156669f, 
    0.01614177f, 0.01346916f, -0.01471224f, 0.02686385f, 0.03431657f, -0.01516476f, 0.02842869f, 0.01652097f, 
    0.00600899f, 0.01144560f, -0.01200310f, -0.02353915f, -0.01926390f, -0.02978811f, 0.03214897f, -0.01345267f, 
    -0.02991072f, 0.00915662f, 0.01634864f, 0.03691345f, -0.01050994f, -0.03216272f, 0.02281742f, 0.02303061f, 
    0.03482760f, -0.02775917f, -0.00880745f, 0.02399495f, 0.02342024f, 0.01866175f, 0.01657811f, 0.01493524f, 
    -0.01309770f, 0.01334283f, -0.01022806f, -0.01786688f, -0.00490793f, 0.02932182f, 0.00122913f, -0.03426630f, 
    -0.03812446f, 0.01981713f, -0.02347255f, 0.03392701f, -0.02058088f, -0.00386773f, -0.00581261f, -0.00020258f, 
    0.00968710f, -0.01463427f, -0.03191172f, -0.01538178f, 0.01840510f, -0.02129263f, 0.00726000f, -0.01178544f, 
    0.02441168f, 0.00675928f, -0.04115994f, -0.02311491f, 0.00927496f, 0.00540581f, 0.00181644f, 0.01028506f, 
    0.00159693f, -0.03054465f, -0.00316198f, 0.02984157f, -0.00921222f, 0.00002665f, -0.01416470f, 0.01806674f, 
    0.00912806f, 0.02674471f, 0.01090894f, -0.02507613f, 0.00962801f, -0.01546530f, -0.01657768f, -0.04139278f, 
    -0.01949963f, -0.00504987f, 0.02412380f, -0.03276240f, 0.02244484f, 0.02126838f, 0.00647145f, 0.01650092f, 
    0.01318141f, 0.02032024f, 0.01404167f, 0.01625639f, -0.03929219f, -0.00201384f, 0.00854189f, 0.01779546f, 
    -0.02459856f, 0.00375655f, 0.00144931f, 0.00036798f, -0.00604279f, -0.03876448f, 0.00395792f, 0.02786697f, 
    -0.00718429f, -0.00499077f, -0.03108777f, -0.03140642f, -0.02279453f, 0.01893611f, -0.04192420f, -0.03551416f, 
    -0.03456752f, -0.03361540f, 0.00030440f, 0.01574268f, -0.01525653f, -0.03488074f, 0.00486875f, 0.00303425f, 
    0.02139659f, -0.01233685f, -0.03001175f, -0.00784955f, 0.00023553f, -0.01241332f, -0.00748539f, -0.01873135f, 
    0.01597409f, 0.01417893f, 0.02081938f, 0.03023686f, -0.02046949f, 0.02116542f, 0.03002943f, 0.02399796f, 
    -0.01670442f, -0.00232588f, 0.01654263f, 0.02535973f, -0.02573442f, 0.02150508f, 0.00243819f, -0.02839839f, 
    0.01742572f, -0.01132244f, -0.03699779f, 0.03657573f, 0.01745235f, -0.02874418f, 0.01427616f, -0.03576238f, 
    -0.01543770f, 0.02474060f, 0.00673599f, -0.01961084f, -0.02019230f, 0.02427763f, -0.04092536f, -0.04188462f, 
    -0.00174505f, -0.01262514f, 0.01979756f, 0.02816762f, -0.02063771f, 0.02603086f, 0.02300167f, -0.03725383f, 
    -0.00231138f, 0.00026430f, -0.01093018f, 0.00870105f, 0.02158819f, 0.02252716f, -0.00773201f, 0.01597686f, 
    -0.03474514f, -0.00780510f, -0.03656836f, -0.00208460f, -0.02797404f, 0.01823848f, 0.02684311f, 0.02059524f, 
    0.02325685f, -0.02148323f, -0.01260197f, -0.00485662f, -0.00959006f, -0.03238220f, 0.02863268f, 0.02214057f, 
    0.01104331f, -0.01879171f, -0.03437953f, -0.01747573f, -0.01198534f, -0.01877839f, 0.02266427f, 0.00053635f, 
    -0.02098731f, 0.02991727f, 0.00935071f, 0.03732705f, -0.02942529f, 0.00259615f, 0.02262196f, -0.04058194f, 
    -0.00303320f, 0.02242148f, -0.01081233f, 0.01359389f, 0.00742615f, 0.00944961f, 0.00389638f, 0.01752115f, 
    -0.00711721f, -0.03474811f, -0.02506096f, 0.02394989f, -0.00329979f, 0.00469504f, -0.03056774f, 0.02162591f, 
    -0.03378943f, -0.02723761f, 0.02842304f, 0.01707945f, -0.01616022f, -0.02955526f, -0.01177259f, -0.02140400f, 
    0.02209696f, -0.01799274f, 0.02580427f, 0.02484357f, 0.02281099f, -0.03528412f, -0.02242390f, -0.00485312f, 
    0.02582171f, -0.02602497f, -0.04046980f, 0.02630542f, -0.01926646f, -0.02242922f, -0.02391024f, -0.00519009f, 
    -0.00208395f, 0.02230709f, 0.02928189f, 0.02326001f, 0.02016506f, -0.02325400f, 0.02849390f, 0.02254256f, 
    0.01413194f, -0.00439512f, 0.01946892f, -0.00392434f, 0.00190023f, 0.00309874f, -0.02492482f, 0.01097324f, 
    -0.03084826f, 0.02850534f, -0.00773488f, 0.02647115f, -0.01898232f, 0.00388164f, 0.00055365f, 0.01889836f, 
    0.01100445f, -0.01373432f, 0.02582148f, 0.02457705f, 0.00472707f, -0.00186883f, -0.03366838f, -0.02373596f, 
    -0.03529505f, 0.01586190f, -0.03728335f, 0.02455512f, -0.00830522f, -0.03084070f, 0.01619111f, -0.00428852f, 
    -0.02902669f, 0.01140569f, -0.01980113f, 0.00709884f, 0.00213856f, -0.03071487f, -0.01428072f, 0.00607242f, 
    0.02935572f, 0.02916797f, 0.00138670f, 0.00741206f, 0.02701131f, 0.01879746f, 0.01098182f, -0.00066046f, 
    -0.01933376f, 0.00207535f, 0.00773766f, 0.01147819f, -0.02533944f, -0.02742409f, 0.01472486f, 0.00337603f, 
    -0.02120483f, 0.00563204f, 0.02720058f, 0.02439536f, -0.03168130f, 0.01237348f, -0.03325396f, -0.00506473f, 
    0.01680973f, -0.00170830f, -0.01522915f, 0.01827316f, -0.02911867f, 0.00581881f, -0.03568291f, 0.02693710f, 
    -0.02118921f, 0.02281838f, -0.00718140f, 0.01159938f, -0.01040946f, 0.01306444f, 0.02348335f, 0.01411363f, 
    0.01154852f, 0.01331920f, 0.01115490f, -0.03202918f, -0.02182635f, -0.02394405f, 0.01954050f, -0.02536210f, 
    -0.00801296f, -0.02424678f, 0.00369556f, 0.00053015f, 0.01643977f, 0.02454456f, 0.01207564f, -0.01955547f, 
    -0.02340931f, -0.01224290f, 0.00016450f, -0.04198700f, -0.03105794f, 0.01101549f, -0.02230463f, 0.01539751f, 
    0.01849200f, -0.00635288f, 0.01968129f, 0.00458177f, 0.02179564f, 0.01360684f, 0.02312880f, 0.03627042f, 
    0.01529685f, -0.02570946f, -0.01371330f, 0.02308398f, -0.00339463f, -0.01275817f, -0.03377956f, 0.00328234f, 
    -0.03465574f, 0.03817880f, -0.02405048f, 0.01218531f, -0.01020731f, -0.03298788f, 0.00064944f, -0.02728838f, 
    0.01063684f, -0.00280556f, -0.01524072f, -0.02465666f, 0.01962417f, -0.00049137f, 0.03565602f, 0.01422179f, 
    -0.02807608f, 0.02440600f, 0.01639110f, 0.00209260f, -0.03552193f, -0.00532323f, 0.02975811f, 0.03060560f, 
    0.03039707f, -0.03759250f, 0.01009484f, -0.02913579f, -0.02673137f, -0.01764175f, -0.04068984f, -0.02168193f, 
    0.00963209f, 0.00718531f, -0.02955449f, -0.03458539f, -0.02458184f, 0.00220841f, -0.04171703f, 0.01939117f, 
    -0.01993892f, -0.03681183f, 0.01816156f, -0.01771450f, 0.00358626f, -0.01254588f, -0.04041181f, -0.02819317f, 
    0.01517674f, -0.00786481f, -0.02630783f, -0.02709643f, 0.01301229f, 0.01812289f, 0.02034538f, 0.01033087f, 
    0.01625486f, -0.03823208f, 0.00374866f, 0.01139930f, -0.00691600f, 0.01172637f, -0.02637848f, 0.02034972f, 
    0.02123484f, -0.03452533f, -0.01973308f, -0.01552747f, 0.01670027f, -0.01412659f, -0.00625649f, -0.00781745f, 
    0.02312530f, -0.01457291f, -0.01001399f, 0.03577788f, 0.00787146f, -0.03974317f, 0.02936410f, 0.00845324f, 
    0.00779230f, 0.00857604f, 0.02460496f, 0.03103196f, 0.01851087f, 0.02553118f, 0.01747991f, 0.02663673f, 
    0.02218174f, -0.00960006f, -0.03674986f, -0.03242454f, 0.00223008f, -0.03778897f, -0.04048978f, 0.01799837f, 
    0.01509212f, -0.00583328f, -0.00996098f, -0.02325299f, -0.03295401f, -0.00084688f, -0.02851667f, 0.02967709f, 
    -0.02707953f, -0.00897990f, -0.04034793f, 0.01997679f, 0.02995587f, -0.00644055f, -0.00355627f, -0.01385940f, 
    0.01255654f, -0.00911758f, -0.01174004f, -0.02041465f, -0.00275207f, -0.00102874f, -0.00508959f, -0.02102145f, 
    0.00460740f, -0.03045341f, -0.02952190f, 0.01214477f, 0.01426590f, 0.02911170f, -0.00265689f, -0.03834811f, 
    -0.02266971f, -0.01454951f, -0.03929299f, -0.02618715f, -0.02061813f, -0.01708228f, 0.00615594f, 0.00784591f, 
    0.02147506f, -0.01677086f, -0.00331507f, 0.01515630f, -0.02662829f, 0.00712805f, -0.02859538f, -0.02788591f, 
    0.02479383f, -0.03053991f, 0.01620278f, -0.00089448f, 0.00415047f, 0.02717460f, 0.00555094f, -0.02386100f, 
    0.00879550f, 0.02860283f, -0.03307206f, 0.02617836f, -0.00732345f, 0.02595516f, -0.02842356f, -0.01543048f, 
    -0.01632483f, 0.03123146f, -0.02814366f, 0.00378379f, 0.02849495f, -0.03380545f, -0.01525370f, -0.03579575f, 
    0.01093318f, -0.02477261f, 0.00364413f, -0.02473419f, 0.00749923f, -0.03083176f, -0.00525908f, -0.03207737f, 
    0.00237271f, -0.02152084f, -0.00341513f, 0.02837352f, -0.03010180f, -0.02054350f, -0.01364194f, -0.02530929f, 
    0.03007768f, 0.00574038f, -0.01332061f, 0.00766591f, -0.01255866f, 0.01247111f, 0.02834074f, -0.00639085f, 
    -0.02606338f, -0.00557845f, -0.01296936f, -0.01453892f, -0.03629428f, 0.01691357f, 0.00226542f, -0.01671140f, 
    -0.03369145f, 0.02081292f, -0.00774686f, -0.01197579f, -0.01543410f, -0.02699836f, -0.00033289f, -0.03103025f, 
    0.03288948f, 0.01601145f, -0.02078983f, 0.02780977f, -0.02527200f, 0.03642922f, -0.03674927f, -0.00867385f, 
    -0.04093642f, 0.02796224f, -0.01081329f, -0.00689116f, -0.02301929f, 0.01349222f, 0.02274394f, -0.01894201f, 
    -0.01963623f, -0.01942090f, 0.02781070f, -0.00575608f, 0.00567012f, -0.01725116f, 0.02068025f, -0.00136004f, 
    -0.01356722f, 0.02042644f, -0.01559591f, -0.04052892f, -0.02247921f, 0.00340187f, -0.00730156f, 0.00503212f, 
    0.02121587f, -0.00333512f, 0.03650739f, 0.00138156f, -0.03152006f, 0.03619549f, -0.00476558f, -0.02868341f, 
    -0.01400080f, -0.03718259f, -0.01067826f, -0.01061678f, 0.00957852f, -0.03623177f, -0.04113112f, 0.02656764f, 
    0.01084797f, -0.02593006f, 0.00609284f, -0.03855639f, -0.02287630f, -0.01521292f, 0.01582387f, 0.00930983f, 
    0.00671032f, 0.00868404f, -0.03094738f, 0.02458050f, 0.01557116f, 0.01373269f, 0.00837984f, 0.02283381f, 
    0.01126832f, 0.02074368f, 0.00957653f, -0.03398036f, -0.00007094f, -0.04163122f, 0.02694478f, 0.02223156f, 
    -0.02590453f, -0.03149886f, 0.01252796f, -0.00243538f, 0.02695699f, 0.02253074f, -0.01453960f, -0.03517761f, 
    -0.02240169f, 0.00547866f, -0.00912716f, -0.03387249f, -0.04064390f, 0.00430392f, 0.03376294f, -0.02487016f, 
    -0.00844044f, 0.01635863f, 0.01311542f, -0.02799067f, 0.01473719f, -0.03874950f, -0.00672617f, -0.01503316f, 
    0.00725946f, -0.02465126f, -0.00105874f, -0.00063050f, 0.01172135f, -0.00635817f, -0.02648620f, -0.03982204f, 
    0.02337272f, -0.01263940f, -0.03289203f, -0.02617122f, -0.03898743f, -0.01610898f, 0.00031066f, 0.01623110f, 
    -0.01293214f, 0.01251824f, -0.03050118f, 0.00512396f, -0.01388609f, 0.01590735f, -0.01866471f, -0.03801200f, 
    -0.01489081f, 0.02762623f, -0.00409855f, -0.02864699f, 0.00383435f, -0.00340719f, -0.00122629f, 0.01400177f, 
    0.00234938f, 0.01744569f, -0.00499969f, -0.02717507f, -0.00531940f, 0.00751854f, -0.01388621f, 0.01213393f, 
    0.00654706f, -0.01086421f, -0.00963711f, 0.03251170f, -0.00109339f, -0.03878998f, -0.02330373f, -0.00196685f, 
    0.01730281f, 0.03690490f, -0.03117668f, -0.01103675f, 0.01858940f, -0.00075982f, -0.02779618f, -0.01638685f, 
    -0.01365360f, -0.02009608f, 0.02580873f, -0.01945365f, 0.01741435f, 0.01702558f, -0.00901651f, 0.01162040f, 
    0.00570301f, -0.01678005f, -0.00856695f, 0.03408904f, -0.02348799f, -0.01657501f, -0.01784479f, -0.04166266f, 
    -0.00894949f, 0.01069591f, 0.00901764f, -0.02361573f, -0.02248172f, 0.01737402f, 0.00421548f, -0.03761774f, 
    -0.01346453f, -0.02236816f, -0.03805145f, -0.03764290f, -0.00138145f, -0.02937210f, -0.03257258f, 0.00271223f, 
    -0.02865767f, -0.01158870f, 0.02080491f, -0.00061575f, -0.00634216f, 0.02070946f, -0.01332038f, -0.02870291f, 
    -0.04195342f, -0.00132131f, -0.01763339f, -0.03211530f, 0.03319053f, -0.03751269f, -0.02557701f, -0.01233601f, 
    -0.01165639f, -0.03613687f, -0.01309070f, 0.01000616f, -0.03958882f, -0.03707401f, -0.00785685f, 0.00787347f, 
    0.01291451f, -0.02771235f, 0.02043570f, 0.00912904f, -0.02684318f, -0.00855030f, 0.01623259f, -0.04028400f, 
    -0.02284270f, 0.02063272f, -0.03878664f, -0.02858293f, 0.00695082f, 0.02556687f, 0.00780283f, -0.02424186f, 
    -0.02323637f, -0.03622323f, -0.00699440f, 0.02354825f, 0.00493041f, -0.01094545f, -0.01301143f, -0.00556605f, 
    0.00359639f, 0.00487109f, 0.00441069f, -0.00158178f, 0.01672782f, 0.00909962f, -0.03553468f, 0.01392384f, 
    -0.01845032f, -0.00372802f, 0.01297628f, 0.01812672f, 0.01962530f, -0.00144086f, 0.01045272f, -0.00270432f, 
    -0.02506545f, 0.01994232f, 0.00876767f, -0.01198644f, -0.00163507f, -0.03196616f, -0.01916654f, -0.01038101f, 
    0.02901776f, -0.04067905f, -0.02888263f, 0.02698260f, -0.00552261f, 0.01944232f, 0.00887430f, 0.01939917f, 
    -0.02076048f, -0.03340416f, -0.01286592f, -0.00791429f, 0.00839705f, 0.00521725f, -0.03546051f, -0.03173512f, 
    0.01204884f, -0.01679977f, 0.00571430f, -0.01966815f, -0.03308036f, 0.02414791f, 0.02282764f, 0.01456443f, 
    0.02410888f, 0.02928184f, 0.01642407f, -0.02529948f, -0.01244542f, 0.02615681f, -0.02280990f, -0.02048538f, 
    0.02352786f, 0.02792566f, -0.03222172f, -0.01987451f, -0.02487854f, -0.01249580f, 0.01512377f, 0.02728378f, 
    0.02157743f, 0.01297766f, -0.02169146f, 0.00429402f, 0.00691033f, -0.00985935f, 0.02438432f, -0.01634196f, 
    0.01030733f, -0.02934014f, -0.03442140f, 0.01411371f, -0.02341129f, 0.01129326f, -0.02295391f, -0.02843566f, 
    0.02580844f, -0.02539280f, -0.02705590f, -0.01537069f, -0.02868749f, -0.01865475f, -0.03532382f, -0.02504559f, 
    -0.03284836f, -0.02319638f, -0.03306319f, -0.00975578f, 0.02617286f, 0.00787040f, -0.00850315f, -0.01612165f, 
    -0.02276515f, -0.00418738f, -0.01147447f, -0.00374591f, -0.03926481f, -0.01756513f, -0.04048971f, -0.01873220f, 
    0.02313294f, -0.03540580f, 0.01429771f, -0.00877530f, 0.02927814f, -0.03848048f, -0.02488320f, -0.00084964f, 
    -0.02388139f, -0.02295909f, 0.02046600f, -0.03791232f, 0.02577678f, -0.03147885f, 0.02518346f, 0.02140638f, 
    0.01107308f, -0.02001273f, 0.00439665f, -0.03721533f, -0.02201428f, 0.00447779f, 0.04068045f, 0.01018726f, 
    -0.00276084f, -0.03729426f, -0.02448680f, 0.01226216f, -0.00090805f, 0.02637883f, 0.02427330f, 0.02361535f, 
    -0.00278329f, -0.02874168f, -0.02263374f, -0.00682090f, -0.01739227f, 0.01269668f, 0.02688465f, -0.02419272f, 
    -0.01675911f, 0.02861671f, 0.01037003f, 0.00594621f, -0.02737407f, 0.03003447f, 0.00577883f, 0.00201860f, 
    -0.01493494f, -0.03737031f, -0.02342647f, -0.02646904f, 0.02206447f, 0.02370966f, -0.03206729f, -0.01450092f, 
    -0.02319447f, -0.02438533f, 0.01137418f, -0.01869492f, -0.00395870f, -0.00392424f, 0.00414323f, 0.01178540f, 
    -0.00409019f, -0.03346618f, -0.01832120f, -0.00609329f, -0.01505231f, 0.02548874f, -0.03061704f, -0.02691862f, 
    -0.01588310f, 0.02344601f, -0.03593920f, 0.01498473f, -0.00633072f, -0.02014606f, 0.01290032f, -0.00459138f, 
    -0.02504514f, -0.03876892f, -0.00175501f, -0.00345299f, -0.03269204f, -0.02065792f, -0.00555296f, -0.03269747f, 
    -0.02347372f, -0.02875612f, -0.02463137f, 0.01735102f, 0.01509330f, -0.03681276f, 0.01917060f, -0.02401276f, 
    -0.00895661f, 0.02458716f, -0.01967674f, -0.03198553f, -0.00081069f, -0.02072799f, 0.02754715f, 0.02101389f, 
    -0.02298263f, 0.00221139f, 0.02510574f, -0.01778913f, 0.00103809f, 0.00316253f, -0.00195782f, -0.03837945f, 
    -0.01057158f, -0.03799080f, -0.03998879f, -0.02096083f, 0.01519607f, -0.02066213f, -0.02709099f, -0.01461238f, 
    -0.03491841f, -0.02852922f, -0.00860426f, 0.01296264f, -0.01519383f, -0.01177642f, -0.03864091f, 0.02050757f, 
    0.00399518f, 0.00594302f, -0.02911398f, -0.03582794f, 0.02520027f, -0.02475205f, 0.01522230f, 0.00251336f, 
    -0.03605632f, -0.00323572f, 0.01632162f, 0.00491023f, -0.02023107f, 0.02719581f, -0.02427444f, 0.02200335f, 
    -0.01905950f, -0.02706186f, -0.02828014f, 0.00956610f, -0.01673780f, 0.00948971f, 0.00212194f, 0.02058252f, 
    0.00628358f, -0.04083037f, -0.03464139f, 0.01210976f, -0.02758015f, -0.03860285f, 0.02017456f, 0.00171658f, 
    0.00150317f, -0.03549838f, -0.01993787f, 0.01362044f, -0.01859367f, 0.01633058f, -0.02690805f, 0.01383610f, 
    0.01287903f, -0.03008740f, -0.01998821f, -0.00824306f, -0.00263244f, 0.00482161f, 0.00067954f, 0.00226934f, 
    -0.03294407f, -0.01325099f, 0.01948063f, -0.03895582f, -0.04037446f, -0.00143216f, -0.01850984f, 0.00582050f, 
    -0.03979644f, -0.03356033f, 0.02207915f, 0.01255588f, 0.00589717f, 0.02744728f, -0.03302167f, -0.02949434f, 
    -0.01573601f, -0.02738500f, -0.03751322f, 0.02117119f, -0.01132110f, 0.02297110f, -0.00343089f, -0.03210410f, 
    -0.01547531f, -0.01953715f, -0.02821823f, 0.02001749f, -0.01045507f, 0.02876800f, 0.02602232f, -0.01791529f, 
    0.02843927f, -0.02517127f, -0.02610170f, 0.00142318f, -0.03317443f, 0.01042586f, -0.02023881f, 0.02889306f, 
    -0.01917391f, -0.03948453f, -0.02697369f, -0.03770856f, 0.01270704f, -0.01141759f, -0.01643631f, -0.01637022f, 
    0.02906668f, -0.03369502f, 0.01800548f, -0.01048979f, -0.03906858f, -0.01028456f, 0.02214158f, -0.00543528f, 
    0.00585677f, 0.02929572f, 0.02866676f, -0.04062391f, -0.00768371f, -0.01304808f, 0.01289952f, 0.01524772f, 
    0.01970005f, 0.01763640f, -0.02834795f, -0.03932791f, 0.02052031f, -0.03533052f, -0.04146359f, -0.00484879f, 
    -0.03732613f, 0.02944559f, 0.01629742f, 0.00590541f, -0.00899092f, -0.03957733f, -0.00799485f, -0.02732631f, 
    -0.01841514f, 0.02314976f, -0.04050574f, -0.00369390f, 0.02892604f, -0.02420033f, -0.01342238f, -0.02665392f, 
    0.00550803f, -0.02365371f, -0.03328558f, 0.00022477f, 0.01645360f, 0.02568160f, -0.03351663f, -0.01095339f, 
    -0.03407614f, 0.01194636f, 0.00074196f, -0.03036601f, -0.02018293f, 0.02466343f, 0.01446760f, 0.00023337f, 
    -0.01255015f, -0.00380553f, -0.03897372f, -0.03844776f, 0.01138734f, -0.00656056f, -0.01517346f, 0.02860331f, 
    0.01155213f, 0.01497848f, -0.01051434f, -0.02138216f, 0.00500941f, -0.00992788f, 0.01419083f, 0.02360824f, 
    0.00757624f, 0.00725147f, -0.01479685f, -0.01136143f, 0.02540910f, -0.03279554f, -0.01539607f, -0.00616015f, 
    -0.00481915f, -0.01194470f, 0.00195413f, 0.00501287f, 0.02480238f, 0.02041793f, 0.02578522f, -0.00361002f, 
    -0.01910804f, 0.02277270f, -0.01623742f, -0.02457815f, -0.01180089f, 0.00100684f, 0.00069169f, -0.00274748f, 
    -0.00417325f, -0.02440719f, -0.00215687f, -0.00464547f, -0.03444484f, 0.02497401f, 0.02638320f, -0.03652962f, 
    0.00941607f, 0.00364875f, 0.02803071f, -0.00924677f, 0.00420933f, -0.02888123f, 0.02934760f, -0.03754454f, 
    0.02408125f, 0.02899005f, 0.01065966f, 0.00574222f, 0.00656445f, 0.01031409f, 0.00892609f, -0.01427300f, 
    -0.00446059f, 0.02255434f, -0.03600052f, -0.03561352f, 0.01541645f, -0.00951886f, -0.02091611f, -0.02176308f, 
    0.00635444f, 0.01076150f, -0.02518980f, 0.00540162f, -0.03942955f, -0.02227652f, 0.01825714f, 0.01207366f, 
    0.01460186f, -0.04089862f, 0.01668315f, 0.01582110f, 0.01064190f, -0.01408353f, -0.02610812f, -0.00731513f, 
    0.00719704f, -0.03813524f, -0.03500249f, -0.01099100f, -0.04053650f, 0.02553056f, -0.04084662f, -0.00523567f, 
    -0.04136400f, 0.01052047f, 0.02454337f, 0.02797180f, 0.00432768f, -0.00954259f, -0.03957601f, -0.02307601f, 
    -0.03113298f, -0.03736330f, -0.03275040f, -0.01815791f, 0.02355502f, 0.02101050f, -0.00065814f, -0.03481253f, 
    -0.02344641f, 0.00757172f, -0.00402938f, 0.00002457f, -0.02772625f, -0.03152634f, 0.01814671f, -0.02279675f, 
    -0.03929227f, -0.00218362f, 0.00984635f, 0.00939399f, 0.00404781f, 0.01099724f, -0.02680648f, -0.01971005f, 
    -0.03457726f, -0.01114560f, -0.02416836f, 0.01425755f, 0.01921596f, 0.02017725f, 0.01209072f, 0.02958097f, 
    0.00516612f, -0.01638633f, -0.02520118f, -0.01354352f, 0.01659859f, 0.01115996f, -0.03739145f, 0.01274793f, 
    -0.02309999f, -0.02428414f, -0.00057727f, -0.00978705f, 0.02773342f, 0.01967567f, 0.00392946f, -0.01337906f, 
    -0.03483361f, 0.02685509f, -0.01548860f, 0.02848579f, 0.00953889f, -0.00122917f, -0.03891292f, 0.01124803f, 
    0.00044159f, 0.01424906f, -0.04143063f, -0.01631114f, -0.03673746f, -0.02109040f, 0.02535452f, -0.03464129f, 
    -0.03893429f, -0.02902267f, 0.01950693f, -0.03339208f, -0.02510148f, -0.01452351f, -0.00951027f, -0.00555916f, 
    -0.02570386f, 0.01233916f, -0.00991944f, 0.02329032f, -0.03829494f, -0.02091651f, 0.02586315f, -0.04099326f, 
    -0.03878980f, 0.00666301f, -0.00368118f, -0.03145798f, 0.00939357f, -0.00197411f, -0.00876383f, 0.00460140f, 
    0.01047935f, 0.01416472f, 0.00615574f, 0.01138077f, -0.03346977f, 0.01749709f, -0.02734668f, 0.00935168f, 
    -0.00349406f, 0.02269555f, 0.02214605f, -0.00916489f, 0.02282628f, 0.02579704f, -0.00702716f, -0.01261973f, 
    0.00808964f, 0.01870905f, 0.01726393f, -0.00598054f, 0.02337015f, 0.00528170f, 0.00100769f, -0.00151863f, 
    -0.00440416f, -0.00481897f, -0.02979173f, -0.02231221f, 0.01595295f, -0.02278890f, -0.01579659f, -0.03370299f, 
    -0.02603652f, -0.03735800f, -0.03158769f, -0.02982797f, -0.01849079f, -0.01972498f, 0.00657395f, -0.02859926f, 
    0.02867574f, 0.01203746f, 0.00133580f, 0.02235982f, -0.01118899f, -0.01833201f, 0.01376178f, -0.03092556f, 
    -0.01933893f, -0.03614016f, 0.02013932f, -0.01953804f, 0.02248201f, 0.00446393f, 0.02021075f, 0.01186794f, 
    -0.00472032f, -0.02459988f, 0.00220848f, 0.00443829f, -0.01305846f, -0.00360209f, -0.03356290f, -0.02410251f, 
    0.00206623f, -0.02557135f, 0.01608250f, -0.00646553f, -0.02786727f, -0.02609726f, -0.02527532f, -0.00452318f, 
    0.00171620f, -0.02675178f, 0.02440468f, 0.00653353f, -0.04157466f, -0.00133701f, 0.02369029f, -0.04015337f, 
    -0.02555246f, -0.01736454f, -0.03762826f, -0.01179264f, 0.00434437f, 0.00650782f, -0.00087145f, 0.02751733f, 
    -0.01607082f, -0.03612901f, -0.03048561f, 0.02069160f, 0.01322684f, -0.02834019f, 0.00157449f, -0.01965534f, 
    -0.00055524f, 0.00295925f, 0.01114042f, 0.00350641f, 0.02575311f, -0.03126384f, -0.01730520f, -0.02193866f, 
    0.00281738f, 0.00473186f, -0.00930695f, -0.01365257f, -0.00745934f, -0.02342498f, -0.00027409f, -0.03581923f, 
    -0.00990761f, -0.04093832f, -0.03093944f, -0.02531773f, -0.00972873f, 0.02711761f, -0.00311939f, -0.04191041f, 
    0.00239385f, 0.01873646f, -0.02278108f, -0.01461791f, 0.01912209f, -0.01682088f, 0.01586214f, -0.00520873f, 
    -0.00498159f, -0.01702229f, -0.02197258f, 0.00439121f, -0.02355774f, 0.00283057f, 0.01667864f, -0.00459800f, 
    -0.03275198f, 0.02952032f, -0.03734648f, 0.01791555f, -0.03905941f, 0.01108446f, 0.01328312f, -0.03818366f, 
    -0.00140657f, 0.02830501f, 0.02840379f, 0.00550693f, -0.02978102f, -0.03291488f, -0.00350478f, -0.02652452f, 
    0.02254024f, 0.01078101f, -0.04191808f, 0.01484119f, -0.03812996f, -0.03305502f, -0.01089200f, -0.02199350f, 
    0.02831196f, 0.02444016f, 0.01479187f, -0.03316166f, -0.02971084f, 0.02206091f, -0.01213926f, -0.01805401f, 
    -0.00030586f, -0.03642739f, -0.03787189f, -0.02237052f, -0.02232081f, 0.02345106f, 0.01760839f, 0.00257229f, 
    0.01838968f, 0.00830655f, 0.00914911f, -0.01806332f, -0.00718771f, -0.02541020f, 0.00257812f, -0.01220046f, 
    0.00008465f, -0.00501839f, 0.02639922f, 0.01344279f, 0.02716007f, -0.00355129f, 0.00840129f, -0.02001103f, 
    0.01083086f, -0.00301251f, 0.00591027f, 0.00483770f, -0.01628796f, -0.00343802f, -0.00335842f, -0.01003264f, 
    -0.01209206f, -0.03480001f, 0.02082129f, 0.00604911f, -0.02508499f, -0.01009236f, 0.01612392f, -0.03805330f, 
    -0.02028843f, 0.00744063f, -0.00289659f, -0.03614879f, -0.00115869f, -0.00239289f, 0.00114093f, 0.00279761f, 
    -0.01267550f, 0.02183363f, 0.02042599f, -0.01313833f, -0.01612108f, 0.00329696f, -0.00552069f, -0.00008558f, 
    -0.02143151f, -0.01946227f, -0.00048681f, -0.02295987f, 0.02747829f, 0.02885490f, 0.02455111f, -0.00366660f, 
    0.01507629f, -0.03343339f, -0.03772688f, -0.00805014f, -0.02775764f, 0.01891776f, 0.02901231f, -0.01178082f, 
    0.00955842f, -0.00837140f, -0.00630374f, -0.01353676f, -0.00935831f, -0.00874831f, -0.01113323f, 0.00254840f, 
    0.01102933f, -0.02909189f, -0.03285271f, 0.00630128f, -0.01974203f, -0.01379186f, 0.00323293f, 0.00167833f, 
    -0.01275424f, -0.03430070f, 0.00134578f, -0.01834168f, 0.02883952f, 0.01423792f, -0.00208868f, -0.00647322f, 
    -0.02426934f, 0.00037869f, -0.00687389f, 0.02036300f, -0.03372353f, -0.04033337f, 0.02152318f, -0.01077559f, 
    -0.00272415f, -0.03238810f, 0.00696663f, 0.02444741f, -0.03980754f, 0.02493678f, -0.03201475f, -0.03241020f, 
    -0.00619601f, 0.00307365f, -0.02350025f, -0.01390867f, 0.01838736f, 0.01717733f, 0.00042479f, -0.02358723f, 
    -0.01011400f, -0.02735673f, 0.00197425f, 0.01267410f, 0.02614178f, 0.00312372f, -0.00998353f, -0.02602362f, 
    -0.04135589f, 0.02377175f, 0.00319933f, 0.01773323f, -0.03723447f, 0.00768803f, -0.03212000f, -0.03756063f, 
    0.02921988f, -0.03066399f, -0.02174499f, 0.00844645f, 0.02306097f, 0.02195296f, 0.01952456f, -0.02130946f, 
    -0.01925108f, -0.01077597f, -0.03790484f, -0.00314253f, 0.01856492f, -0.03510823f, -0.02327780f, -0.01888322f, 
    -0.01586265f, 0.00214106f, -0.02260403f, -0.02215432f, -0.01670442f, 0.01933420f, -0.03333918f, 0.02949623f, 
    -0.04079567f, -0.01215579f, -0.02726684f, 0.00851826f, -0.02487569f, 0.02745165f, -0.00523426f, -0.01536590f, 
    -0.00118768f, -0.03082870f, -0.03535355f, 0.01489969f, -0.00906212f, 0.02492711f, -0.02036464f, -0.03745597f, 
    0.00550197f, 0.01519309f, 0.01895123f, -0.03861186f, 0.01476875f, 0.00396589f, 0.02824587f, 0.01143155f, 
    -0.02058598f, -0.04140588f, 0.01102676f, -0.02283098f, 0.00885007f, -0.00406784f, 0.02790768f, -0.00749920f, 
    -0.00737569f, 0.01427437f, -0.04064557f, -0.02255355f, 0.01065310f, -0.00930875f, -0.00775988f, -0.03892027f, 
    0.00465819f, 0.00038479f, -0.01337402f, 0.01695907f, -0.00255761f, -0.03005532f, -0.01293590f, 0.00932285f, 
    0.02956884f, -0.02954967f, 0.00373718f, -0.01552372f, -0.01007371f, -0.02882349f, -0.03635138f, -0.00179037f, 
    0.02403336f, 0.01081123f, 0.00877211f, -0.03322245f, -0.01891705f, -0.00631566f, 0.02909330f, -0.03110889f, 
    0.02277308f, -0.01426816f, 0.01682994f, 0.00223567f, -0.00094996f, -0.03477207f, -0.03949172f, -0.00868433f, 
    -0.00545296f, -0.01928493f, -0.03586359f, 0.02450733f, -0.01168118f, 0.01077081f, -0.02939009f, -0.03954392f, 
    -0.01944747f, -0.00084032f, 0.01098624f, -0.01864266f, -0.03690738f, 0.02501538f, 0.02328040f, -0.01092662f, 
    -0.00473877f, 0.01030531f, -0.03236346f, 0.01235678f, 0.00354044f, -0.00197025f, 0.02566796f, -0.02713195f, 
    -0.04190589f, -0.00581430f, -0.01821187f, -0.00496071f, 0.00558057f, -0.03314373f, -0.04143453f, -0.01893506f, 
    -0.03967998f, 0.02846099f, -0.02385081f, -0.00360638f, -0.02527110f, -0.00533002f, 0.02584173f, -0.00767135f, 
    0.00694479f, -0.01872156f, 0.00386975f, -0.01578084f, 0.01536367f, 0.01664758f, -0.02197836f, 0.00812018f, 
    -0.02955502f, -0.03231173f, -0.03357878f, -0.00816381f, 0.02707425f, -0.00829519f, 0.01850474f, 0.01737855f, 
    0.00021081f, -0.02778637f, 0.00755414f, -0.01953125f, 0.01318457f, 0.01789174f, -0.02194328f, 0.02906519f, 
    -0.03560062f, 0.00832196f, 0.01790587f, 0.01674776f, -0.03303230f, 0.00050281f, -0.02229568f, -0.01942752f, 
    -0.03370132f, -0.00639942f, 0.01827973f, 0.02444308f, -0.04206005f, 0.00306965f, 0.02936023f, -0.01763513f, 
    0.01602801f, -0.04041553f, 0.02781573f, -0.00844047f, -0.03394178f, -0.02225606f, 0.01797837f, 0.02277246f, 
    -0.03107606f, -0.01486619f, -0.01657840f, -0.01955584f, -0.02616421f, 0.00613878f, 0.02847432f, 0.01953012f, 
    -0.04171765f, -0.00148260f, 0.01726594f, 0.01225453f, 0.02118649f, -0.02020725f, 0.02775617f, 0.01806901f, 
    -0.04021486f, -0.01341130f, 0.02784801f, 0.02985972f, 0.00584268f, 0.00474843f, 0.01588488f, -0.01451294f, 
    0.00992218f, -0.00547263f, -0.02595924f, -0.00543600f, -0.01336394f, 0.02141771f, -0.03346108f, -0.00974630f, 
    -0.03685198f, 0.01594138f, 0.02798944f, -0.04102320f, 0.02299074f, -0.02085269f, -0.03030229f, -0.02306347f, 
    0.02638448f, -0.03638846f, 0.02419985f, -0.00098548f, -0.04138826f, -0.02749049f, 0.00355446f, -0.00920128f, 
    -0.03180538f, -0.01325647f, 0.01834123f, -0.01745970f, 0.01750560f, 0.01261965f, 0.01364753f, -0.01577151f, 
    -0.03638535f, 0.02958040f, 0.00949557f, 0.01128621f, 0.00258040f, -0.02940939f, 0.02779189f, -0.03483432f, 
    -0.01501409f, 0.01604053f, 0.00307980f, 0.02589073f, 0.02366374f, -0.00101441f, 0.01056093f, -0.03889121f, 
    -0.03005242f, 0.00623326f, 0.01951703f, -0.02326697f, -0.00550462f, -0.01773655f, 0.02607813f, -0.02832638f, 
    0.00791137f, 0.01666424f, 0.01746660f, 0.02249377f, -0.03193288f, -0.01489700f, -0.02000915f, -0.02138651f, 
    -0.02692736f, 0.01015950f, -0.02769509f, -0.02727899f, -0.00678609f, 0.01231736f, -0.01340276f, -0.01996491f, 
    -0.01942252f, -0.01307648f, -0.03550791f, 0.02660288f, -0.01320362f, -0.01568809f, 0.01381443f, -0.01822478f, 
    -0.03289809f, -0.03542595f, -0.02803633f, -0.01744461f, 0.01994239f, -0.03379561f, -0.00759216f, 0.00473102f, 
    -0.03254401f, -0.04162012f, -0.01090946f, 0.00835790f, -0.01955407f, 0.01595505f, 0.02772612f, 0.00585307f, 
    -0.00576312f, 0.02270457f, -0.03967792f, -0.00628882f, -0.02404924f, -0.02192983f, 0.02111427f, 0.01450445f, 
    -0.04105798f, -0.02932595f, -0.00395078f, -0.00046365f, 0.02684092f, -0.03334596f, -0.04167666f, 0.01978847f, 
    -0.01739796f, -0.00375923f, -0.04047884f, -0.00266827f, 0.01053861f, -0.01364630f, 0.01558287f, -0.00901886f, 
    -0.02375564f, 0.00536295f, -0.00600379f, 0.02887752f, 0.01729043f, -0.02346021f, -0.02716061f, -0.00812965f, 
    0.01462647f, -0.02487941f, 0.00883003f, -0.01355601f, -0.02352846f, -0.01075657f, 0.00179491f, -0.00207202f, 
    -0.02545341f, 0.02277387f, 0.00510982f, 0.01291919f, 0.00120396f, 0.01642233f, 0.01726826f, 0.01003709f, 
    -0.02927571f, -0.00290085f, -0.01716539f, -0.02477656f, -0.00654208f, -0.01922613f, 0.01333325f, -0.00181679f, 
    -0.02653404f, 0.02410954f, 0.00391108f, 0.00543609f, 0.00124779f, 0.01341687f, -0.03483951f, 0.02709106f, 
    0.02027218f, 0.01985108f, -0.02955016f, 0.01326431f, 0.01955583f, -0.03286007f, 0.01781514f, 0.00206315f, 
    -0.01833466f, 0.01366669f, -0.02218172f, 0.01922865f, -0.02312591f, 0.00385695f, 0.02027045f, -0.01014388f, 
    0.01298875f, -0.03700897f, -0.03175036f, -0.03266873f, -0.01893810f, -0.00692040f, 0.01380502f, -0.03694192f, 
    0.01711969f, -0.00213312f, -0.03472712f, 0.02982805f, 0.00788883f, 0.02847606f, -0.03552265f, 0.02531043f, 
    -0.03337834f, -0.00624050f, -0.02953316f, 0.00226559f, -0.02369140f, 0.00793266f, 0.00775052f, 0.00805093f, 
    0.00081380f, -0.03891404f, -0.00831937f, -0.03717528f, -0.04114515f, -0.04148748f, 0.02774023f, -0.01015817f, 
    -0.03880985f, 0.00661161f, 0.00225961f, 0.02090300f, -0.01670426f, -0.00040512f, -0.00068359f, -0.03283915f, 
    0.00268754f, -0.03218731f, 0.02158483f, -0.03820328f, 0.02013888f, 0.01335538f, -0.01367468f, -0.03848861f, 
    -0.03462106f, 0.01142596f, -0.01926688f, 0.02109422f, 0.02652594f, -0.03313386f, -0.01841211f, -0.02150348f, 
    -0.03326903f, -0.00251023f, 0.02977758f, 0.02269341f, -0.02919032f, -0.02199921f, 0.00873085f, 0.02669215f, 
    -0.03612256f, 0.01331331f, 0.02326204f, -0.03785468f, -0.01246325f, -0.00721308f, -0.00777869f, 0.00547270f, 
    0.02518097f, 0.01351292f, -0.02162667f, -0.02163357f, -0.02590036f, 0.01473118f, 0.02398375f, -0.02854427f, 
    0.01551818f, -0.01977338f, 0.01053246f, -0.03109186f, -0.02091682f, -0.03232510f, -0.01263116f, -0.01606038f, 
    -0.00815426f, 0.02349623f, -0.01585754f, -0.03125582f, -0.02572241f, 0.01874183f, -0.00024970f, 0.01376162f, 
    -0.02803240f, -0.01772600f, -0.00678796f, -0.02593222f, -0.03601568f, 0.02634280f, -0.02057159f, -0.00523286f, 
    -0.01840717f, 0.00142422f, -0.03187171f, -0.00744641f, -0.00161144f, 0.01609202f, -0.03069408f, 0.00053198f, 
    -0.01061334f, 0.02465121f, -0.03955362f, -0.03898907f, -0.03806047f, -0.01557480f, -0.00163566f, -0.00605669f, 
    -0.00339779f, -0.02888937f, 0.00097842f, -0.03013701f, 0.01322108f, 0.01150780f, -0.00105657f, -0.01433830f, 
    -0.00302334f, 0.01258898f, -0.01441297f, 0.00391841f, 0.00563221f, 0.02584024f, 0.01568779f, -0.03299080f, 
    -0.03538559f, -0.01739910f, 0.02030517f, 0.02622275f, -0.00059743f, -0.00716721f, -0.02009373f, -0.03372240f, 
    -0.04067208f, -0.00884304f, -0.02881192f, -0.02811302f, -0.04068315f, 0.01872644f, -0.01502672f, -0.02856833f, 
    -0.00397275f, 0.02016562f, 0.00103817f, -0.00697364f, -0.03294083f, 0.00953828f, 0.02398258f, -0.01513954f, 
    0.00405194f, -0.00827572f, 0.00547029f, -0.02224002f, -0.02116859f, -0.02362282f, 0.00684933f, 0.02102088f, 
    -0.01348204f, 0.01023028f, 0.02854130f, -0.02674904f, 0.02051693f, 0.01850779f, -0.01031260f, -0.04091097f, 
    -0.02274125f, 0.00307175f, 0.01240237f, -0.01915677f, -0.03344498f, -0.00324955f, -0.01034239f, 0.00256116f, 
    -0.03749135f, -0.01580723f, 0.01988850f, -0.02957735f, 0.01875916f, 0.00442016f, -0.01739799f, -0.00921693f, 
    0.01296563f, -0.02988608f, 0.01317686f, 0.01019839f, -0.01038670f, 0.00678041f, 0.00509702f, -0.02918611f, 
    0.02624325f, 0.01119879f, 0.02898762f, 0.01281310f, 0.01758936f, 0.01572377f, -0.03720490f, -0.03059890f, 
    0.00940337f, -0.03367198f, -0.00685507f, 0.00223907f, -0.02575069f, -0.00884205f, -0.04105131f, -0.02650746f, 
    -0.02728958f, -0.03276735f, -0.04167477f, 0.00699830f, 0.00020917f, -0.00370395f, -0.03474272f, 0.00580119f, 
    0.07770201f, -0.05994245f, 0.12798816f, -0.12405919f, -0.03744378f, 0.10194211f, 0.00538203f, 0.09690407f, 
    -0.03294327f, 0.02856799f, -0.05387851f, 0.06331026f, 0.16909929f, -0.06362366f, -0.00817791f, -0.10789245f, 
    0.15485981f, 0.11979378f, -0.00739204f, 0.17196903f, 0.07922533f, -0.06899502f, 0.04122372f, -0.08440392f, 
    -0.33809593f, 0.27006122f, 0.11776283f, -0.35011294f, 0.01461622f, 0.00747545f, 0.02961745f, 0.04425638f, 
    -0.15172864f, -0.04580406f, 0.01950710f, -0.01263120f, 0.36914247f, -0.30451429f, -0.15983121f, 0.00688133f, 
    0.07234368f, 0.08118236f, -0.08089292f, 0.09016992f, 0.04852356f, 0.13564509f, 0.02199777f, 0.01901249f, 
    0.13200426f, -0.00499286f, 0.12641464f, -0.04094784f, -0.00056246f, 0.11605816f, -0.05738411f, 0.01514816f, 
    0.07892428f, 0.01821534f, 0.01854469f, 0.02097740f, -0.08822010f, -0.00130695f, -0.12608656f, -0.06231806f, 
    0.14728123f, 0.11029505f, 0.02044915f, 0.02202019f, 0.08600941f, 0.05025870f, 0.03572431f, 0.11842737f, 
    0.33376810f, 0.15247332f, 0.10036173f, 0.05531232f, 0.01456938f, 0.02351022f, -0.00853275f, 0.05028656f, 
    0.01192081f, 0.01837878f, -0.02280045f, 0.12334930f, -0.02625130f, -0.03243410f, 0.01751984f, -0.05548592f, 
    0.00474035f, 0.01157846f, 0.07676204f, -0.06334779f, -0.08076476f, -0.06989053f, 0.00965739f, 0.03564415f, 
    -0.23047727f, -0.10136709f, 0.06025908f, 0.12406430f, 0.09382154f, 0.00066697f, -0.07118044f, 0.07193652f, 
    -0.03812731f, 0.09987137f, -0.01826459f, 0.01035089f, -0.05327326f, -0.00753719f, 0.03581251f, 0.04396775f, 
    0.00543809f, 0.09969192f, 0.02565049f, 0.02028240f, -0.01422014f, 0.04204834f, -0.07976881f, 0.14378777f, 
    0.14917701f, -0.15369835f, 0.09317195f, 0.08763153f, -0.02345586f, -0.06730933f, 0.02254597f, 0.00799206f, 
    -0.02803653f, 0.08580743f, -0.00522730f, -0.08469651f, -0.01031656f, -0.01069347f, 0.02652653f, -0.10277563f, 
    -0.09181987f, -0.14076863f, 0.00686737f, -0.03838697f, -0.05170485f, 0.06717087f, -0.04214962f, 0.09933681f, 
    0.06351428f, 0.06067862f, 0.00062908f, -0.17813028f, -0.12406559f, -0.00354964f, -0.02500555f, 0.07948221f, 
    -0.00109350f, -0.03597819f, 0.08074664f, 0.10172433f, -0.04320211f, -0.08246723f, -0.17727445f, -0.05493632f, 
    0.07064336f, 0.11223650f, 0.11317942f, 0.01640702f, -0.01304009f, 0.13913222f, 0.03700985f, 0.10749549f, 
    0.12623364f, 0.03135014f, 0.06079537f, 0.22810450f, 0.18770561f, 0.12630256f, 0.09846526f, 0.06245493f, 
    0.04102897f, 0.04688329f, 0.03109260f, 0.07082706f, 0.13450326f, 0.06613427f, 0.02475972f, -0.15076678f, 
    0.00224843f, -0.11649819f, -0.04018093f, 0.07380776f, 0.07297599f, 0.05735294f, 0.08257136f, -0.02494514f, 
    -0.00426808f, 0.00750935f, 0.29932350f, -0.16880979f, 0.11658046f, -0.13070726f, 0.00430092f, -0.09115089f, 
    0.03194706f, -0.00462716f, -0.02053333f, -0.14572141f, -0.04420510f, -0.12505826f, 0.07369165f, -0.01038436f, 
    0.09610688f, -0.01764614f, -0.00485724f, 0.17136838f, 0.10868815f, 0.11454291f, 0.07336321f, 0.05360583f, 
    -0.14459290f, 0.03273067f, -0.08508112f, -0.25237525f, -0.08275035f, -0.10182689f, -0.01871596f, 0.08848687f, 
    0.03432388f, 0.08600523f, -0.04359940f, 0.05402387f, -0.17877319f, 0.07947660f, 0.08286519f, 0.10628232f, 
    -0.04583386f, 0.00213724f, 0.01351399f, 0.10458563f, 0.01463766f, -0.08521044f, -0.05596213f, -0.08646535f, 
    -0.31753302f, -0.12821122f, -0.03592144f, -0.00391094f, 0.08441792f, -0.09736233f, -0.03072140f, -0.12274419f, 
    0.03633983f, -0.01662955f, 0.07164576f, 0.04367059f, -0.02090977f, 0.08073480f, 0.18370952f, 0.01268138f, 
    0.00666069f, -0.05829797f, -0.04560076f, 0.09373255f, -0.06131520f, -0.00849109f, 0.07671241f, -0.03233957f, 
    -0.06482922f, 0.05431267f, 0.01650802f, -0.07406888f, 0.05127617f, 0.01252300f, 0.02382028f, 0.01638752f, 
    -0.09860885f, 0.07447705f, -0.02739068f, -0.10260002f, -0.69458085f, -0.04013924f, -0.08177615f, -0.15406922f, 
    0.06297250f, -0.09150127f, -0.07238276f, 0.11605215f, -0.06966354f, -0.05913752f, 0.02541468f, -0.10280199f, 
    0.01481427f, 0.02049499f, 0.08116386f, 0.07781075f, 0.03416704f, -0.03945279f, -0.11862839f, 0.03652540f, 
    -0.09284266f, 0.11481241f, 0.11360711f, 0.09836718f, 0.20069784f, 0.02510549f, 0.04757490f, 0.12831436f, 
    -0.03949506f, -0.07260314f, 0.19012865f, -0.19468328f, -0.05331196f, -0.03711412f, -0.11677977f, 0.00426451f, 
    0.04235761f, 0.04231413f, 0.03522622f, -0.07501239f, -0.06084350f, -0.01979956f, 0.12827115f, 0.02757357f, 
    -0.10832439f, 0.00255756f, 0.05766281f, -0.03646247f, -0.30321044f, -0.26600096f, 0.02631621f, 0.26286286f, 
    0.07965378f, -0.08205894f, 0.06070101f, -0.06105584f, -0.06833587f, 0.00317690f, -0.00099124f, 0.10817689f, 
    -0.09325181f, 0.05514526f, 0.03414642f, -0.10050137f, 0.06368244f, -0.05380563f, 0.01272473f, -0.05084896f, 
    0.12139525f, 0.05047121f, 0.03577707f, 0.09195980f, 0.16706719f, 0.09521522f, 0.03641858f, -0.12387149f, 
    -0.00747005f, 0.06864342f, -0.10301471f, 0.14043489f, 0.00734635f, 0.04674904f, -0.00485999f, -0.01587676f, 
    0.22586897f, -0.20783536f, -0.12470231f, 0.09859926f, 0.16608784f, 0.11428744f, -0.12245405f, -0.02799482f, 
    0.05402520f, -0.08267937f, -0.03840091f, 0.07048795f, -0.10354814f, -0.02101566f, 0.07893074f, -0.13911481f, 
    0.02727907f, 0.02990126f, 0.04045462f, 0.02212675f, -0.15541978f, -0.08419230f, 0.12331461f, -0.09234059f, 
    -0.00193951f, -0.40499321f, -0.09849580f, -0.05229358f, -0.01198560f, 0.08749042f, -0.04276796f, -0.01329061f, 
    -0.00446313f, -0.04697450f, -0.02726120f, -0.02906280f, 0.01520719f, 0.07909904f, 0.04379247f, 0.04525862f, 
    0.04615081f, 0.03352792f, -0.00437970f, -0.02686258f, -0.08435895f, 0.01588602f, 0.05774644f, 0.03465693f, 
    -0.07454346f, -0.10517096f, 0.01913752f, 0.16279531f, 0.04463210f, 0.08863815f, 0.09764956f, 0.14171723f, 
    -0.06847994f, -0.09348893f, 0.06724422f, -0.05143180f, 0.15408772f, 0.11042134f, -0.09863673f, -0.18457289f, 
    -0.01259399f, 0.01745608f, -0.00940811f, -0.00332017f, 0.08142643f, 0.09598470f, -0.05887244f, 0.05628259f, 
    0.08094469f, -0.08775369f, 0.05133488f, -0.06736957f, 0.15013808f, 0.10127400f, -0.03733741f, 0.07074931f, 
    0.02218058f, -0.07915294f, 0.06358241f, 0.08386189f, 0.04996259f, -0.02591165f, -0.05391216f, 0.05490053f, 
    0.08543752f, 0.03065918f, 0.13921088f, 0.01734880f, -0.06969082f, -0.05856306f, -0.03553991f, 0.07251728f, 
    0.00473676f, -0.05355896f, -0.11875418f, 0.03026246f, 0.09116179f, 0.10011040f, -0.05226474f, 0.09274340f, 
    -0.00229237f, 0.03151640f, 0.04232261f, -0.00001066f, 0.19878250f, 0.08564569f, -0.02656024f, -0.05463796f, 
    0.00880382f, 0.09709678f, 0.00305088f, 0.03834234f, 0.05424157f, -0.03964099f, 0.11858325f, 0.00994015f, 
    -0.09973669f, 0.08353204f, 0.01303599f, 0.04846941f, 0.02076611f, -0.06772558f, -0.02966273f, -0.04549654f, 
    -0.04920277f, 0.01443945f, 0.07203785f, 0.00152699f, -0.19682258f, -0.11847345f, 0.16076665f, 0.03139971f, 
    0.01913031f, -0.00431182f, -0.09768750f, -0.02279756f, 0.04120321f, -0.05028416f, 0.06352639f, 0.14015532f, 
    0.22847445f, -0.23651509f, 0.04242732f, 0.05765712f, 0.10193857f, -0.02263340f, -0.11058521f, -0.06773643f, 
    0.02459617f, 0.02323056f, -0.00676792f, -0.06869877f, 0.22991270f, -0.13873620f, -0.11074706f, 0.06910333f, 
    0.18873768f, 0.04610858f, -0.04061090f, -0.03302022f, 0.02973042f, 0.06718910f, 0.04142620f, 0.03374750f, 
    0.01470371f, -0.10939403f, 0.12887700f, 0.08657885f, 0.16794115f, -0.06275316f, 0.04872137f, 0.00432647f, 
    -0.00199335f, -0.07964148f, 0.11069837f, 0.01798917f, -0.17916399f, 0.10869420f, 0.25229117f, 0.02151650f, 
    0.00656751f, -0.04699969f, -0.00810218f, -0.04234914f, 0.11252961f, -0.00502820f, 0.06076227f, 0.00099598f, 
    -0.19229910f, 0.04400394f, 0.06156066f, 0.14487828f, -0.10740592f, 0.01174843f, 0.02946178f, 0.05834153f, 
    -0.04244835f, -0.03842690f, -0.09368455f, 0.17937392f, 0.03421415f, -0.11386806f, 0.19756649f, -0.15942021f, 
    -0.04557868f, 0.05080120f, -0.00369489f, 0.13787763f, -0.02542451f, -0.05301518f, 0.03494113f, 0.00959424f, 
    -0.27072695f, 0.21470590f, 0.23704509f, -0.14501072f, -0.01544501f, 0.02330392f, -0.04857583f, -0.04915629f, 
    0.04176725f, -0.04478427f, -0.00735038f, -0.01332176f, -0.02990860f, 0.16964123f, 0.15633042f, -0.00331589f, 
    0.17592010f, 0.04253783f, -0.09599908f, -0.11548097f, -0.08581772f, -0.07112973f, 0.09001938f, -0.04213434f, 
    0.16258729f, 0.16485204f, -0.12161793f, -0.16892537f, -0.09204078f, -0.04975531f, -0.01732731f, 0.15961537f, 
    0.05905227f, 0.02272392f, 0.11751808f, -0.05319814f, 0.09525935f, 0.06781694f, 0.13719139f, 0.11213510f, 
    0.07870097f, -0.02271872f, 0.05280354f, 0.01276000f, -0.00230527f, -0.00958160f, 0.01499980f, -0.04307819f, 
    -0.07884989f, 0.14448144f, 0.00114154f, -0.14344366f, 0.06105199f, 0.01908102f, -0.03948531f, 0.01849186f, 
    -0.01986710f, -0.01334395f, 0.14406690f, -0.05026951f, -0.04708117f, 0.02698313f, 0.11560655f, 0.07855603f, 
    0.03752853f, -0.04258906f, -0.10171302f, 0.00410099f, 0.09051076f, 0.05308224f, -0.08111610f, 0.04192401f, 
    -0.14136945f, -0.04110326f, 0.02612653f, 0.05073697f, 0.18488388f, 0.06030244f, 0.02890624f, 0.01025207f, 
    -0.00080804f, 0.18007401f, 0.05844438f, 0.07190758f, -0.09582614f, -0.17355253f, -0.01671131f, 0.00441418f, 
    0.22279963f, 0.01387516f, -0.02256067f, -0.15881047f, 0.08098146f, 0.08775578f, 0.14364600f, 0.06530592f, 
    0.06291214f, -0.03764058f, 0.02622166f, -0.03602722f, 0.05029063f, -0.09009919f, -0.03537264f, -0.02484031f, 
    0.01889541f, -0.00483083f, -0.03581726f, -0.02670166f, -0.11701624f, 0.13633429f, 0.02966431f, 0.04190746f, 
    0.06641533f, -0.09589659f, 0.02360865f, 0.01539372f, -0.00205239f, 0.02266018f, -0.07317709f, 0.03820778f, 
    -0.02351059f, -0.01392683f, -0.13521329f, 0.01756550f, 0.07091817f, 0.14211610f, -0.02266622f, -0.01182048f, 
    0.06987854f, 0.04341266f, 0.06175256f, -0.03710923f, -0.12966156f, 0.19156350f, 0.06695468f, -0.07601580f, 
    -0.03064865f, 0.01472770f, -0.01840975f, 0.00434715f, 0.16329792f, -0.03755795f, -0.05249449f, 0.11970437f, 
    0.12145845f, 0.09445246f, -0.06071561f, 0.02548768f, 0.07654290f, 0.05571629f, -0.02919589f, -0.01014917f, 
    -0.01765898f, 0.05119536f, -0.05111723f, -0.00348797f, -0.09545145f, 0.27233064f, 0.07634449f, -0.20591293f, 
    -0.05975156f, -0.05575037f, 0.06840117f, 0.00723700f, -0.05735471f, 0.01675265f, 0.03726359f, 0.19692709f, 
    0.11954893f, 0.18325090f, 0.15247968f, 0.00292763f, -0.05229665f, -0.00769451f, -0.02622699f, 0.00830703f, 
    -0.04883119f, -0.10435552f, -0.09825801f, 0.02241403f, 0.13180313f, -0.04430000f, -0.07788426f, 0.16442950f, 
    0.12087768f, -0.06953152f, -0.03899594f, -0.08181041f, 0.04686404f, -0.01699335f, 0.01531062f, -0.03068924f, 
    0.21775277f, 0.17265746f, -0.06473211f, -0.07698582f, -0.02964730f, 0.04044547f, 0.06851201f, -0.04774667f, 
    -0.07811937f, 0.06272823f, -0.03732279f, 0.04901498f, 0.22016080f, 0.07879990f, -0.08678613f, -0.21989523f, 
    0.02397792f, 0.01529273f, -0.16661330f, 0.03753918f, 0.13626973f, -0.14665373f, 0.01603379f, -0.02654032f, 
    0.27750492f, -0.24572673f, 0.08720832f, 0.24863936f, -0.06765881f, 0.05598435f, 0.11185805f, -0.05354211f, 
    0.01070636f, 0.03025501f, 0.03250469f, -0.05052840f, -0.35311133f, 0.19859622f, 0.07114972f, -0.14760812f, 
    0.10919135f, 0.03328196f, 0.05990019f, 0.08256198f, 0.01306147f, 0.01440257f, 0.11324116f, -0.01250747f, 
    0.06914750f, 0.08121736f, 0.06996940f, -0.03421259f, 0.03081367f, 0.01360115f, 0.03892877f, -0.01872052f, 
    -0.05345511f, 0.10061603f, 0.15484670f, 0.09694470f, 0.22260498f, -0.05432996f, -0.04388544f, -0.15547743f, 
    -0.01044633f, 0.06470611f, 0.06199935f, -0.05724342f, -0.00721171f, -0.04602130f, 0.00811640f, -0.10428090f, 
    0.12802833f, -0.08341952f, 0.11349922f, 0.14969639f, -0.16398177f, 0.01238999f, -0.05411192f, -0.00556350f, 
    -0.01010382f, -0.00314013f, 0.03970230f, 0.03150862f, 0.19098252f, -0.11682824f, 0.10105310f, -0.04606574f, 
    0.08357763f, -0.02827447f, 0.01877522f, 0.04067493f, 0.11682204f, -0.08365134f, 0.04896525f, -0.08830667f, 
    0.10352546f, 0.11655934f, 0.00653803f, -0.00947099f, 0.02707322f, -0.10254725f, -0.01611739f, 0.03921651f, 
    0.02892663f, 0.00949019f, -0.05480666f, 0.00907073f, 0.43680421f, -0.34674311f, -0.01529533f, -0.02022313f, 
    -0.03603981f, -0.03173166f, -0.02265792f, 0.07964738f, -0.10178635f, 0.09724890f, -0.16843311f, 0.08260304f, 
    -0.07402054f, 0.16706274f, -0.06320515f, -0.16792148f, 0.08370560f, -0.08841575f, -0.12320735f, -0.03663142f, 
    -0.05313754f, -0.01489509f, 0.00437001f, 0.04480671f, -0.13309085f, -0.08475544f, 0.00800382f, 0.13533071f, 
    0.03057060f, -0.07570537f, 0.00375816f, 0.05480512f, -0.00600786f, 0.07768323f, 0.10016042f, 0.00953732f, 
    -0.02189930f, -0.01108862f, -0.01813653f, 0.12913415f, 0.08065266f, 0.09187483f, 0.09040991f, -0.06862811f, 
    -0.06510155f, -0.07660073f, 0.01472791f, 0.03185520f, -0.02813811f, 0.08223538f, -0.07486584f, 0.00815757f, 
    0.01111006f, 0.08435044f, 0.02352797f, -0.02711353f, -0.03709728f, 0.02451525f, 0.09844576f, 0.07393888f, 
    -0.16656953f, 0.16455542f, 0.13748768f, 0.04078254f, 0.06916708f, -0.08412342f, 0.01765497f, -0.05129184f, 
    0.07103396f, 0.07084431f, 0.12177390f, 0.12691268f, -0.01979525f, 0.00709602f, -0.10960894f, 0.06990913f, 
    0.01228855f, -0.00643741f, 0.01533913f, 0.13324755f, -0.02800468f, 0.08644909f, 0.03518490f, 0.06898297f, 
    0.12276711f, -0.01713174f, -0.08381739f, 0.22472517f, 0.04588740f, -0.09322366f, -0.00188902f, -0.01642870f, 
    -0.01732341f, -0.00845814f, -0.02956658f, 0.08881164f, 0.11001372f, 0.06362576f, -0.07643839f, -0.11007685f, 
    -0.00031028f, 0.08227314f, -0.06808034f, 0.09613690f, 0.02948129f, -0.05777613f, 0.02124744f, 0.13844751f, 
    0.12586822f, -0.09913707f, -0.06351198f, 0.06423858f, 0.07567109f, -0.05727388f, 0.08016268f, 0.06838904f, 
    -0.06266895f, 0.15304470f, 0.01177153f, 0.07551047f, 0.19539955f, -0.08502451f, -0.02622853f, 0.02102237f, 
    -0.03692824f, -0.00084544f, -0.00390547f, 0.13198516f, 0.05286338f, -0.02202799f, -0.02038666f, -0.04046119f, 
    -0.25386435f, -0.03246627f, 0.08572585f, -0.02573905f, -0.04813175f, -0.04276108f, 0.00520376f, -0.06377392f, 
    0.08825778f, -0.14815906f, -0.04977106f, 0.03021271f, 0.19634080f, -0.03318922f, -0.06465869f, 0.19190973f, 
    -0.00292332f, -0.04562242f, 0.06280129f, 0.07142133f, 0.00307123f, -0.00620868f, 0.06204867f, 0.04626096f, 
    0.24167772f, -0.07321919f, -0.03836871f, 0.32672396f, 0.03255451f, -0.02009152f, 0.00073622f, -0.12451703f, 
    -0.01692973f, -0.08614464f, 0.05938441f, -0.08202251f, 0.27372217f, -0.19693808f, 0.15210558f, 0.26356640f, 
    0.03877048f, -0.08812565f, -0.01038062f, 0.08595096f, -0.01395490f, 0.06759129f, -0.05875303f, -0.13601707f, 
    -0.02543603f, 0.07334826f, 0.09091755f, -0.12051433f, 0.03031962f, -0.09197783f, -0.13028531f, 0.00333609f, 
    -0.09354278f, 0.16894090f, 0.09083340f, 0.13095929f, 0.13982356f, -0.14743301f, 0.03105934f, 0.03488051f, 
    -0.02750330f, -0.07066150f, -0.02514143f, 0.06853656f, 0.08506660f, 0.06941786f, 0.10716423f, -0.15456162f, 
    0.27814731f, 0.06283806f, -0.05544271f, 0.09439769f, 0.07470663f, -0.00069516f, 0.07280160f, 0.02740110f, 
    0.09439909f, 0.05101464f, 0.12049921f, -0.07746793f, -0.51107568f, 0.10168988f, 0.03301192f, 0.09740908f, 
    -0.09036016f, -0.06393287f, 0.06548813f, 0.14942624f, -0.05886293f, 0.14787275f, -0.04789895f, -0.01662331f, 
    0.10776027f, -0.11339830f, 0.02181578f, 0.14329332f, 0.04031252f, -0.06844062f, 0.06887776f, -0.12460104f, 
    -0.00835751f, 0.02940883f, -0.01886630f, 0.09368601f, 0.09177878f, 0.00818319f, 0.11231501f, -0.12876497f, 
    -0.01984530f, 0.09587532f, -0.07185375f, -0.13705365f, 0.02202801f, 0.12269274f, -0.15799062f, -0.11769160f, 
    0.05070705f, 0.04411934f, -0.04327984f, -0.08871462f, 0.04702819f, 0.13537893f, -0.05977365f, -0.04721530f, 
    -0.03882998f, -0.06333314f, 0.09963337f, 0.00891223f, 0.07855640f, 0.13425618f, -0.02276900f, -0.11368997f, 
    0.02195371f, -0.14346372f, 0.09612974f, -0.01102245f, 0.05791527f, -0.19162123f, -0.00003727f, 0.01690613f, 
    -0.34957474f, 0.12546879f, -0.09992874f, 0.15435036f, -0.02962905f, 0.13977908f, 0.00043924f, 0.02652186f, 
    0.01942561f, -0.07182330f, 0.14537825f, 0.00714576f, 0.08485696f, -0.11214871f, 0.12599006f, 0.07824147f, 
    0.06494752f, 0.01090027f, -0.08608165f, 0.00251420f, 0.01245384f, -0.01480972f, 0.13627289f, -0.03987158f, 
    0.06254720f, 0.03003449f, -0.00116568f, 0.14590999f, 0.08991016f, 0.10697167f, -0.02502338f, 0.11291742f, 
    0.06920708f, -0.08547728f, 0.07435393f, -0.04084161f, -0.32036945f, -0.05293699f, 0.08750875f, 0.29605663f, 
    -0.14446062f, 0.13471878f, -0.03228042f, -0.14501850f, -0.03959629f, 0.07058101f, -0.01322556f, 0.12875217f, 
    0.04396211f, 0.00836053f, 0.13909976f, -0.06559669f, -0.02471879f, 0.09867520f, -0.13087508f, -0.10524120f, 
    0.09143989f, -0.13076656f, -0.04193345f, 0.12860526f, 0.19116631f, 0.14530230f, 0.07073428f, 0.11667407f, 
    -0.08280200f, 0.05223415f, 0.07369213f, 0.11708087f, 0.07713687f, 0.04461604f, -0.03280916f, -0.20445579f, 
    -0.08474156f, 0.02016610f, 0.17338224f, 0.04334496f, 0.01693763f, 0.02866286f, 0.00613746f, -0.05028023f, 
    0.06042670f, 0.06121090f, 0.03482715f, 0.02867126f, -0.06839149f, 0.02683235f, -0.01883919f, 0.01536940f, 
    0.09691753f, 0.05585036f, 0.12109490f, 0.04994397f, -0.11412019f, -0.03717181f, 0.17952687f, 0.07460493f, 
    0.14197467f, 0.03083637f, 0.00559432f, 0.14839317f, -0.00802155f, -0.02940895f, 0.05783900f, -0.06757693f, 
    0.15625682f, 0.12290149f, 0.03146872f, -0.06776942f, 0.21973564f, 0.22241069f, -0.10675856f, 0.05395174f, 
    -0.04035393f, -0.05893015f, 0.10585550f, 0.14812832f, 0.14142443f, 0.07653110f, -0.03553222f, 0.11175727f, 
    0.23702213f, -0.04469616f, 0.00881322f, -0.20768765f, -0.02887668f, -0.05044390f, -0.11612341f, -0.01302744f, 
    0.04896262f, 0.05462207f, -0.15176980f, 0.00315757f, 0.03919646f, 0.11998679f, -0.12629528f, -0.05704033f, 
    0.05781595f, -0.07517587f, -0.02181596f, 0.07996721f, 0.06513643f, -0.00563789f, -0.04533345f, -0.09966049f, 
    -0.07613151f, 0.13339399f, -0.03895006f, -0.01664184f, 0.03811270f, -0.01813510f, -0.06156697f, -0.05163269f, 
    0.15424001f, -0.16642974f, 0.08893874f, 0.03317510f, 0.10422359f, -0.09618259f, 0.03580383f, 0.08312612f, 
    0.16660009f, -0.12200037f, 0.04426975f, 0.06160847f, 0.09401871f, 0.06264117f, 0.02873747f, 0.18680878f, 
    0.27845684f, -0.03310625f, -0.08501599f, -0.04257072f, 0.15085483f, -0.03181924f, 0.02215152f, 0.12021067f, 
    0.01396785f, -0.03447547f, -0.01106485f, -0.04261171f, -0.13909917f, 0.23764378f, 0.17199546f, -0.12962863f, 
    0.09611834f, 0.05364540f, -0.13508718f, 0.03579458f, 0.01607954f, 0.01037880f, -0.07400120f, 0.01698730f, 
    0.19818220f, -0.26389000f, 0.09289535f, 0.14756387f, 0.03820297f, 0.01594513f, 0.02646577f, -0.04882208f, 
    0.00232936f, 0.09257131f, -0.04346702f, 0.10683694f, 0.30663043f, -0.05738927f, -0.11611713f, 0.00839317f, 
    -0.05429601f, -0.00675765f, -0.01645643f, 0.01737365f, -0.00199940f, -0.02963633f, 0.12190545f, 0.09801401f, 
    0.03766488f, -0.20662166f, 0.12405107f, 0.02512346f, -0.06307073f, 0.06082623f, -0.01719643f, -0.06628147f, 
    0.07013094f, -0.08571915f, 0.19911398f, 0.07608522f, 0.19478531f, -0.05414819f, 0.00639419f, -0.11984062f, 
    -0.02682661f, -0.01835946f, 0.00761405f, -0.05148132f, 0.04242375f, 0.04435045f, -0.09155112f, -0.06218239f, 
    0.10945688f, -0.27058175f, 0.17655201f, 0.26198143f, 0.11834490f, 0.11318007f, 0.00197562f, -0.09555112f, 
    -0.03553870f, 0.00165985f, 0.06867591f, 0.06386603f, 0.32130685f, -0.06678008f, -0.07733408f, -0.02326372f, 
    -0.01949594f, -0.00245225f, 0.01174065f, 0.01993430f, -0.00346755f, 0.09805672f, -0.00292295f, 0.15047707f, 
    0.00719501f, 0.12409092f, -0.10650525f, -0.10228800f, 0.01989739f, -0.07573745f, 0.00581885f, 0.02987097f, 
    0.09977382f, -0.13384883f, 0.15547137f, 0.01054852f, -0.40035793f, 0.30903906f, -0.08238754f, -0.13177297f, 
    0.03227641f, -0.07439224f, -0.14349641f, -0.11428059f, 0.03771979f, -0.02955093f, 0.05334156f, -0.05338143f, 
    0.02953053f, 0.06645957f, 0.11895736f, -0.08209954f, 0.03989148f, -0.01210090f, -0.00830736f, -0.04639892f, 
    0.02867188f, -0.05627447f, 0.01777279f, 0.03232968f, 0.08624656f, -0.02957212f, 0.14545183f, 0.06613269f, 
    0.07097504f, -0.01856637f, -0.04742391f, 0.11851124f, 0.08185779f, 0.10388361f, -0.08355248f, 0.05530334f, 
    0.21166369f, 0.04614264f, -0.15967119f, -0.02595150f, -0.01597083f, 0.11066210f, -0.02764408f, -0.00041859f, 
    0.02475813f, 0.04346594f, 0.03777786f, -0.06845490f, 0.24808066f, -0.03332053f, -0.11579856f, -0.04362859f, 
    -0.00767630f, -0.06195405f, 0.00046554f, 0.00153352f, 0.01419451f, -0.00316563f, -0.14454287f, 0.06365684f, 
    -0.05031083f, 0.06792321f, -0.08187665f, -0.14732125f, -0.06364657f, -0.06649403f, 0.17491257f, -0.02717589f, 
    -0.03506747f, 0.02535995f, -0.00833641f, -0.15543170f, 0.19692266f, -0.15814658f, -0.10019112f, 0.20402752f, 
    0.05502322f, 0.01392170f, 0.13832566f, 0.00463609f, 0.01251358f, 0.07064610f, -0.01787846f, 0.06864525f, 
    0.26077503f, -0.10553294f, 0.05118871f, 0.02534060f, -0.08058157f, -0.01275465f, -0.02491090f, -0.00885942f, 
    0.10813107f, 0.01195692f, 0.01681860f, -0.15877682f, -0.21872114f, -0.06854140f, -0.07091552f, 0.05112490f, 
    -0.10189913f, -0.19017987f, -0.01543563f, -0.04112982f, 0.02321544f, 0.06245796f, -0.05477336f, 0.01474854f, 
    -0.17291141f, 0.01335631f, 0.09441377f, -0.05488205f, 0.10162162f, -0.02865978f, 0.00816736f, 0.06628218f, 
    -0.02469008f, -0.04312106f, -0.06207658f, -0.04323501f, 0.20726156f, -0.02656064f, -0.08221198f, -0.24313945f, 
    0.12341301f, -0.03797701f, 0.04350606f, 0.03426085f, -0.03571340f, -0.12160938f, -0.10499569f, -0.03529445f, 
    0.16670510f, -0.01110979f, 0.10970023f, -0.11204115f, 0.06173262f, -0.00528952f, 0.07977132f, -0.00307360f, 
    -0.05512007f, 0.02301303f, 0.01133300f, 0.11346825f, -0.08522674f, 0.09973942f, -0.19025715f, 0.06577532f, 
    0.07026751f, -0.03046494f, -0.01353971f, 0.06804288f, 0.04733485f, 0.10781376f, 0.11340141f, 0.04931221f, 
    0.04032518f, -0.12909088f, 0.16182564f, -0.15314114f, 0.06747486f, -0.00559133f, -0.01617174f, -0.07447002f, 
    -0.04671906f, 0.02996781f, 0.05331297f, 0.04241963f, 0.11668888f, 0.11721341f, -0.15081550f, -0.11270252f, 
    0.00975737f, 0.00499541f, 0.05420596f, 0.08283677f, 0.07817336f, -0.04714992f, -0.07244039f, 0.02429884f, 
    -0.01571248f, 0.02734882f, 0.15223284f, -0.03179450f, 0.09202968f, -0.02888390f, 0.09436468f, 0.05237044f, 
    0.03806319f, -0.10802694f, -0.00011067f, 0.13269989f, -0.17659488f, -0.26357183f, -0.05856887f, 0.00623136f, 
    0.11512652f, -0.01385726f, 0.01386055f, 0.01412206f, 0.02159685f, 0.11776678f, 0.01446906f, -0.01162845f, 
    -0.10680474f, -0.12282959f, 0.16728954f, -0.09579501f, 0.04251705f, 0.05303447f, 0.03233094f, -0.05852612f, 
    -0.01835522f, -0.01370147f, 0.04349808f, -0.01365135f, 0.01576624f, -0.23897256f, 0.14208654f, 0.12551834f, 
    -0.10607864f, 0.01720941f, 0.08916491f, 0.00176425f, -0.02036659f, -0.00853457f, 0.06832958f, 0.01166508f, 
    0.02320595f, -0.00264226f, 0.04357424f, -0.09354943f, -0.09239850f, 0.11934257f, 0.07164003f, -0.04469963f, 
    -0.04830262f, 0.02609740f, 0.13676973f, -0.00366662f, 0.23108515f, 0.12706114f, -0.14505099f, -0.03298285f, 
    0.02472305f, 0.06654095f, -0.01585323f, 0.02511506f, 0.02503104f, -0.04127054f, -0.01004660f, -0.04624100f, 
    0.25734824f, 0.17485128f, -0.09861782f, -0.01458176f, -0.04574285f, 0.01890803f, 0.04362840f, -0.02179073f, 
    -0.13496374f, -0.01049259f, 0.01127076f, -0.01031086f, 0.11138642f, -0.04806932f, -0.14240541f, -0.10638748f, 
    -0.01306356f, 0.09914604f, -0.02571334f, 0.04672826f, 0.06999805f, 0.09383903f, -0.03048129f, 0.04269588f, 
    -0.30234471f, -0.22424544f, -0.17343299f, 0.01663694f, -0.03997834f, 0.05396996f, -0.08415589f, -0.00348967f, 
    0.00098172f, 0.09586576f, -0.00932167f, -0.06319731f, 0.05418620f, 0.26060462f, -0.01093099f, 0.14550517f, 
    -0.14643061f, 0.05083637f, 0.05124418f, 0.00729939f, 0.02103921f, 0.01672902f, 0.00915074f, 0.05510877f, 
    -0.01961962f, 0.20425467f, -0.06124434f, 0.01744044f, 0.02628412f, -0.01581545f, 0.10574728f, -0.03157707f, 
    -0.01329144f, -0.02971920f, -0.05902846f, -0.01326346f, 0.03895266f, -0.19793400f, -0.02289057f, -0.06515627f, 
    0.02249656f, -0.07505315f, 0.07006360f, -0.03647131f, -0.06487074f, 0.03919015f, -0.03570771f, 0.02451015f, 
    0.33656445f, 0.00790093f, 0.24420875f, -0.19283161f, -0.00811628f, 0.02851084f, 0.02977284f, -0.00212290f, 
    -0.01437120f, 0.01596031f, 0.02709085f, 0.07828887f, -0.10584153f, 0.07730420f, 0.04203321f, 0.03300300f, 
    -0.14937967f, 0.01604979f, 0.04905532f, 0.06185567f, -0.05425808f, 0.04278811f, 0.00723270f, -0.00301206f, 
    0.22525403f, -0.06803200f, -0.04521496f, 0.02853069f, -0.03795589f, 0.05530902f, 0.11393414f, -0.11435499f, 
    -0.04126251f, 0.05309342f, -0.04318102f, -0.00812902f, -0.05796947f, 0.20503759f, 0.10006336f, -0.00861079f, 
    -0.08051746f, 0.09791564f, -0.05466503f, -0.03622759f, -0.17317282f, 0.00695742f, -0.03600436f, 0.08718829f, 
    -0.08798777f, 0.16797395f, 0.12556447f, -0.05381118f, -0.10453928f, -0.03954574f, 0.05857948f, 0.02895860f, 
    -0.02762886f, 0.06061105f, -0.03061452f, -0.05296832f, -0.20146485f, -0.31150514f, 0.30417153f, 0.14512895f, 
    0.06256976f, 0.10759959f, 0.08411814f, -0.00871932f, -0.03507297f, 0.04076857f, -0.07379198f, 0.09751614f, 
    0.13144292f, -0.03456761f, 0.06725504f, 0.03426833f, -0.04760632f, -0.04526693f, 0.11723008f, 0.08370458f, 
    -0.03848931f, -0.03494258f, 0.00136115f, 0.00740061f, -0.10482012f, -0.05144870f, -0.07573208f, 0.09714352f, 
    -0.03481247f, 0.03765253f, 0.15832633f, 0.03930772f, 0.00864202f, 0.03223853f, -0.05888478f, -0.06455171f, 
    -0.00605684f, 0.08832812f, 0.14696045f, -0.01574853f, -0.01690192f, -0.03791678f, 0.15805790f, 0.03531665f, 
    -0.15689424f, 0.00399055f, 0.00474573f, 0.11074051f, 0.40848023f, 0.00992094f, 0.22747330f, 0.18296462f, 
    -0.13987491f, -0.01723369f, 0.01484082f, 0.01349525f, 0.02263788f, 0.07798807f, 0.11024159f, 0.05221664f, 
    0.06433324f, 0.04704063f, 0.07786728f, -0.12829661f, 0.02602305f, 0.00802674f, 0.07587454f, 0.07965455f, 
    0.03429186f, 0.01332518f, 0.01689039f, -0.03925008f, -0.05767593f, 0.08317722f, 0.18035865f, -0.20527728f, 
    0.02638994f, 0.03302906f, -0.10963639f, 0.04728256f, 0.04962088f, -0.02010190f, -0.03908584f, 0.00359956f, 
    -0.04858973f, 0.11206621f, -0.13380639f, 0.03568298f, 0.02275806f, -0.02501658f, 0.02212946f, 0.07951833f, 
    0.14113167f, 0.03010849f, -0.04120122f, 0.04428991f, 0.06515384f, -0.07314512f, -0.03833155f, -0.09307683f, 
    -0.03315715f, 0.21416281f, -0.04472331f, 0.10935105f, 0.02890282f, 0.05274890f, 0.01207214f, -0.04138002f, 
    0.11973333f, -0.21780735f, 0.00639720f, 0.02315239f, -0.00816200f, -0.05677833f, -0.03321464f, -0.02276916f, 
    0.04556051f, 0.01495043f, 0.05928169f, 0.00806247f, -0.08246451f, 0.06705324f, -0.06890114f, 0.00597876f, 
    0.06604920f, 0.13265127f, 0.00922308f, -0.02271538f, 0.04163980f, 0.06106152f, -0.02499131f, 0.03164856f, 
    0.28396156f, -0.00738012f, -0.02674389f, 0.10235532f, -0.00322369f, 0.02372074f, -0.00369153f, -0.00130521f, 
    0.05852542f, 0.02325175f, 0.09549531f, -0.11555042f, 0.18209320f, -0.02531674f, 0.01285083f, 0.07299984f, 
    -0.07370339f, 0.07484536f, 0.03281200f, 0.07700738f, 0.08100982f, -0.02027410f, 0.00299616f, -0.02267197f, 
    -0.21343179f, -0.30913547f, -0.09286063f, -0.08923472f, 0.05658364f, 0.02012391f, -0.12146076f, 0.06864674f, 
    0.14896311f, 0.07336318f, -0.11245144f, 0.00172873f, 0.09209870f, -0.04432620f, 0.09096903f, -0.06313702f, 
    0.04047437f, 0.04489826f, -0.00482134f, 0.09161945f, -0.08687060f, -0.11467515f, 0.08251168f, -0.02186215f, 
    0.00366867f, 0.15485626f, -0.02500570f, 0.08941536f, 0.05908272f, 0.04970968f, -0.09641308f, 0.05047869f, 
    0.03005060f, -0.00721012f, 0.03513269f, 0.00604525f, 0.24500665f, -0.11884199f, -0.17360187f, 0.12745933f, 
    -0.03160967f, -0.01386479f, -0.06337301f, 0.01912549f, 0.00856918f, -0.00927070f, 0.08296391f, -0.01869182f, 
    -0.40607077f, -0.07021993f, 0.24648823f, -0.09172037f, 0.12590396f, -0.06218680f, 0.10572071f, -0.09522163f, 
    -0.02918347f, -0.03346673f, 0.02643773f, 0.05688247f, -0.26158187f, 0.21381924f, 0.15121529f, 0.04936241f, 
    0.03152749f, 0.10980701f, -0.04150797f, 0.07944343f, -0.10418566f, -0.12373910f, 0.00619794f, -0.03850974f, 
    0.03749644f, -0.05499147f, 0.04521314f, -0.15987612f, 0.14186212f, -0.19563358f, 0.16823445f, 0.02762288f, 
    -0.00477986f, -0.09575428f, 0.02286963f, 0.04409022f, 0.14748555f, -0.09482156f, -0.14811261f, -0.11372058f, 
    0.01057059f, -0.03953997f, 0.01641349f, 0.13458540f, -0.05180432f, -0.06812730f, -0.10711766f, -0.00951699f, 
    -0.17252786f, -0.02471505f, 0.07193946f, 0.04137161f, -0.06413310f, -0.04768558f, -0.00010748f, -0.10980199f, 
    -0.07603544f, 0.02027361f, -0.06207043f, -0.08996898f, -0.02092166f, 0.12135187f, 0.01607616f, 0.11679137f, 
    -0.03317419f, 0.01048277f, -0.04436799f, -0.00469256f, 0.02805969f, 0.00069923f, -0.09938966f, 0.01100598f, 
    0.12478744f, 0.07322802f, 0.17323472f, 0.04365947f, 0.02540688f, 0.07169295f, 0.04988322f, 0.10768101f, 
    -0.02486731f, 0.04310640f, 0.02357257f, -0.03468517f, 0.11268362f, -0.04660258f, 0.09230895f, -0.28214675f, 
    0.11938965f, 0.04995644f, -0.02225321f, 0.08492226f, 0.04455252f, -0.05782834f, 0.02790680f, 0.07669725f, 
    0.08296182f, 0.06429010f, 0.04768793f, -0.07192358f, -0.01156971f, 0.00989335f, 0.01485880f, 0.03885243f, 
    0.14076482f, -0.00828189f, 0.03041192f, 0.09239700f, 0.04932335f, 0.14455894f, 0.07498992f, 0.09158285f, 
    -0.09200584f, 0.13479123f, 0.05965693f, -0.10807439f, -0.08281084f, 0.17404473f, -0.04902157f, -0.12427452f, 
    0.10130052f, 0.06830597f, -0.06604135f, 0.01563088f, 0.11410068f, 0.00434789f, -0.00235031f, -0.02647351f, 
    0.02706800f, 0.04262974f, 0.00448616f, 0.03174907f, -0.12755901f, -0.08057659f, 0.00352909f, -0.02722072f, 
    0.02624557f, 0.02341069f, 0.11145445f, -0.17792912f, 0.01350181f, -0.02412212f, 0.00383729f, -0.02372331f, 
    0.14150111f, -0.07435527f, 0.01430641f, 0.02254670f, -0.01411646f, 0.01691947f, 0.04843696f, -0.08168837f, 
    -0.04151330f, -0.00782783f, 0.00859187f, 0.07195297f, 0.00030169f, 0.07335746f, 0.17343174f, 0.12129760f, 
    0.04256360f, -0.05026820f, 0.04088917f, 0.06588247f, -0.09127886f, -0.09010021f, 0.10303451f, -0.00986461f, 
    -0.17070958f, -0.18758611f, -0.13812657f, -0.09986120f, -0.01301403f, -0.04316637f, 0.02988582f, -0.01078791f, 
    0.02220283f, 0.01834427f, 0.00822328f, 0.04971676f, 0.37766269f, 0.05957503f, 0.03054177f, -0.07490935f, 
    0.03940697f, 0.11775950f, 0.09464123f, -0.15890996f, -0.02353368f, 0.03264727f, -0.05978001f, 0.07858524f, 
    0.07854611f, 0.03887863f, 0.16014495f, -0.14573202f, -0.07594169f, 0.03620411f, -0.00473473f, 0.06741036f, 
    -0.03353221f, 0.01109744f, 0.00234204f, 0.05011117f, -0.06272128f, 0.11201853f, 0.07022364f, -0.22223300f, 
    0.04861183f, -0.13146067f, 0.05359058f, 0.01837274f, 0.01322976f, 0.02369476f, 0.03188412f, 0.05893782f, 
    -0.01425341f, -0.01651080f, -0.08450297f, -0.14745253f, 0.03607680f, -0.04764392f, -0.01244320f, 0.01316513f, 
    0.08137708f, -0.05445506f, -0.01192078f, 0.04893074f, -0.07982469f, 0.20507176f, -0.09846829f, -0.02034303f, 
    -0.03785034f, 0.02512360f, 0.06468168f, -0.04216293f, -0.03607844f, -0.06134278f, 0.06976314f, -0.04529870f, 
    0.25138673f, 0.27094346f, -0.09264296f, -0.06816134f, 0.01417518f, 0.06146212f, -0.07445721f, 0.02918328f, 
    0.06015435f, 0.04215048f, 0.10657308f, -0.06786729f, 0.19297692f, 0.30500305f, -0.04232459f, -0.00377150f, 
    -0.00552950f, 0.04457155f, -0.03139635f, -0.00603088f, -0.07743087f, -0.02293660f, -0.00193420f, 0.06219594f, 
    -0.06660819f, 0.08094338f, 0.04679589f, -0.07348939f, -0.10637956f, 0.00115948f, 0.00955469f, -0.01806966f, 
    0.00393429f, 0.00494768f, 0.03335602f, 0.09854679f, -0.07528527f, 0.07119867f, -0.09650133f, 0.26856932f, 
    0.00789316f, 0.11469477f, -0.07326908f, 0.07705183f, 0.05353085f, 0.01061592f, -0.01751279f, -0.15846680f, 
    -0.42752168f, -0.01216778f, -0.08106305f, 0.06921460f, 0.11220431f, 0.12526897f, 0.10366195f, 0.04225071f, 
    0.02649305f, -0.09773050f, -0.05163576f, -0.03290945f, -0.00664180f, 0.01074915f, -0.16317308f, 0.00132172f, 
    -0.15819648f, 0.01486761f, 0.06382723f, -0.08612385f, 0.10214246f, 0.06119477f, 0.05727304f, -0.00349561f, 
    -0.10935002f, -0.04884185f, -0.14478241f, -0.12185009f, -0.03307772f, 0.01483024f, 0.00619740f, 0.01797112f, 
    0.07591944f, 0.01225067f, 0.04172301f, 0.04097817f, -0.18641715f, -0.10127481f, 0.10002971f, 0.13186377f, 
    0.00805768f, 0.03552162f, 0.10149882f, 0.02687464f, 0.00055094f, 0.14030056f, -0.07526563f, -0.00542356f, 
    0.19564654f, 0.18485126f, -0.17987250f, 0.02865629f, 0.02698663f, 0.01203780f, -0.03057904f, -0.02278880f, 
    0.02893092f, 0.00735083f, -0.07129618f, 0.00404224f, -0.02615420f, -0.15912367f, 0.08299738f, -0.17131585f, 
    -0.17789540f, 0.00328614f, 0.08691664f, -0.09805167f, -0.08337429f, -0.01866279f, 0.06734715f, 0.06774642f, 
    -0.40652609f, 0.05177602f, -0.13049537f, 0.18112296f, -0.20691711f, 0.06622806f, 0.03573040f, 0.02962695f, 
    -0.08864665f, -0.01584985f, -0.02840799f, -0.03190731f, -0.04236810f, 0.07086591f, 0.12588401f, -0.13808921f, 
    0.14092949f, -0.00332404f, 0.06127315f, -0.03131931f, 0.06952030f, 0.08548567f, 0.08693521f, 0.11745991f, 
    0.19802973f, 0.13898326f, -0.20038387f, 0.31811267f, -0.01611758f, 0.06065461f, -0.07397289f, 0.06543463f, 
    0.10997937f, 0.00676526f, -0.02675181f, 0.05743392f, -0.19995256f, -0.02862869f, 0.12344873f, -0.06157489f, 
    0.16593915f, 0.04625507f, 0.03505917f, -0.00959146f, 0.13273156f, -0.07360430f, 0.05654796f, -0.06085490f, 
    0.04541738f, 0.17330398f, 0.20008361f, 0.07164373f, 0.02643495f, -0.07264876f, 0.00897161f, 0.04090066f, 
    0.03572589f, 0.02468253f, 0.11745933f, 0.08932604f, 0.20725109f, 0.10880204f, 0.20389712f, -0.34170523f, 
    0.02505485f, 0.04791550f, 0.07009150f, 0.02507744f, 0.00824882f, -0.01962719f, 0.10496984f, -0.00874806f, 
    0.01058416f, 0.21247235f, 0.13153858f, -0.13993320f, 0.04975880f, 0.00178373f, 0.07975339f, 0.03269811f, 
    0.02147518f, 0.06881198f, -0.05496978f, 0.03748510f, -0.06222155f, -0.15068534f, 0.02085637f, 0.00453359f, 
    -0.07967268f, 0.03565795f, 0.06504927f, -0.09152129f, 0.04976581f, -0.05332578f, 0.09911679f, -0.01591191f, 
    0.09746910f, 0.17090945f, -0.04570302f, -0.03776151f, -0.07432284f, 0.02030646f, -0.05982031f, 0.01097362f, 
    -0.03571509f, -0.03104907f, 0.04886556f, -0.16393298f, 0.28401190f, 0.10521694f, 0.19918831f, -0.15353146f, 
    0.13813928f, 0.05569380f, 0.13923380f, 0.07949464f, 0.05835306f, -0.03447910f, -0.05315911f, -0.00782583f, 
    -0.16091904f, 0.05584180f, 0.10420272f, -0.18652907f, 0.07741679f, 0.04109143f, 0.02651450f, 0.03872905f, 
    -0.00916519f, 0.10632684f, 0.00155502f, 0.00252349f, 0.18524677f, 0.11259238f, -0.15172617f, 0.27386960f, 
    -0.10047106f, 0.08098447f, -0.02666141f, -0.07911892f, 0.03309328f, -0.06385994f, -0.07187103f, -0.05190507f, 
    0.10111506f, 0.24090981f, -0.09639254f, 0.03156490f, 0.00921625f, 0.08897452f, 0.02056498f, 0.00798434f, 
    -0.07971802f, -0.08045258f, -0.06376194f, -0.06551971f, 0.01505327f, 0.00090318f, -0.01284416f, 0.13710770f, 
    0.12076250f, -0.01707914f, -0.05024372f, 0.01123688f, -0.03636290f, 0.13109356f, 0.07710921f, -0.00205770f, 
    -0.20635617f, -0.14555335f, -0.15288232f, 0.03191519f, -0.03734900f, 0.02341356f, 0.01689230f, -0.07082537f, 
    -0.04912570f, -0.00731208f, 0.02936025f, 0.10316056f, 0.11882632f, -0.14781360f, 0.01795040f, -0.04155739f, 
    0.19773215f, 0.01380708f, 0.02899044f, 0.01483331f, -0.07773949f, 0.02335345f, -0.05320430f, 0.01277834f, 
    -0.05724614f, 0.00888688f, -0.06461710f, 0.10308657f, -0.02314165f, 0.02397590f, -0.00030041f, -0.05305831f, 
    -0.01729487f, -0.00741968f, -0.00232341f, -0.04150045f, 0.39896658f, -0.05618780f, 0.09995485f, 0.16691914f, 
    0.08087797f, 0.11293350f, -0.00760663f, 0.05236315f, 0.11895185f, 0.12236525f, -0.04333900f, 0.11386193f, 
    -0.06559986f, 0.15199725f, 0.01464749f, -0.09176432f, 0.02878859f, 0.03967451f, -0.02768170f, 0.00251746f, 
    0.11909908f, 0.10538235f, -0.05057893f, -0.06109024f, 0.03847516f, -0.22777012f, 0.04608963f, -0.08184651f, 
    0.08469503f, -0.05865269f, 0.01240059f, -0.01644393f, 0.03258227f, -0.09258749f, 0.16830917f, 0.02952716f, 
    0.02110281f, 0.14958824f, -0.08755077f, 0.18732645f, 0.17008501f, 0.00787955f, -0.01740629f, -0.00354896f, 
    -0.08675428f, -0.01119729f, 0.00497121f, 0.00601161f, 0.04564231f, 0.04698422f, -0.00969388f, 0.25413877f, 
    0.00033210f, -0.03330950f, -0.04708173f, 0.02379838f, -0.05850760f, 0.12669842f, 0.06026768f, -0.07078439f, 
    -0.23287907f, 0.17132249f, 0.04258377f, 0.04065260f, 0.07361566f, 0.02077571f, 0.08384976f, 0.08189049f, 
    -0.09941618f, 0.09105632f, -0.03671734f, 0.08766725f, -0.09398563f, -0.14384899f, -0.02675726f, -0.02774257f, 
    0.02352380f, 0.09118199f, 0.08555277f, 0.03816074f, 0.03586488f, -0.06734493f, 0.00234439f, 0.10568471f, 
    0.02794804f, -0.09235820f, 0.06436031f, -0.04880000f, -0.04746870f, 0.04416115f, 0.08934618f, 0.05838070f, 
    0.06711646f, 0.08025151f, -0.02756620f, -0.06497702f, 0.05858613f, 0.18475106f, 0.09551688f, -0.15721940f, 
    0.16555671f, -0.08337114f, -0.00446702f, 0.08576970f, 0.00247942f, 0.11858401f, 0.04054217f, 0.07873894f, 
    0.07738724f, 0.01865156f, 0.02155961f, 0.23639986f, 0.11494859f, -0.06148886f, -0.06285877f, 0.12185865f, 
    -0.05910794f, 0.02191716f, -0.12500285f, -0.04479484f, -0.15876643f, -0.04919368f, 0.15400781f, -0.38287437f, 
    0.13897425f, -0.04242727f, -0.05252836f, 0.09959647f, 0.00872306f, -0.05290478f, 0.00489340f, 0.02725815f, 
    0.17896463f, 0.06202240f, 0.16059537f, -0.05603548f, -0.02799092f, -0.01660775f, 0.17012250f, -0.01670860f, 
    0.05798335f, 0.10924720f, 0.02367508f, -0.02736265f, 0.06128960f, 0.08861554f, 0.02069511f, 0.09986696f, 
    -0.03508680f, 0.00628353f, -0.04318653f, -0.02307255f, -0.10411494f, 0.03402413f, 0.05181253f, -0.02477398f, 
    -0.01814291f, 0.11944627f, -0.02982650f, -0.14327066f, -0.09619552f, 0.00055756f, 0.00534079f, -0.17585619f, 
    -0.00667247f, 0.06454342f, 0.10337614f, -0.04369342f, 0.25959086f, 0.13654926f, -0.02066685f, 0.08945975f, 
    -0.06850176f, 0.06707391f, 0.03100344f, 0.07961735f, 0.09317093f, -0.00473490f, 0.01407921f, 0.05529780f, 
    0.00961027f, -0.16682170f, 0.19300728f, -0.13094559f, -0.04228707f, -0.04947811f, 0.18094315f, -0.03047528f, 
    0.01585664f, 0.07130026f, -0.10473690f, -0.00715270f, 0.30388913f, 0.26645812f, 0.10983083f, -0.11197788f, 
    0.02899329f, 0.00552018f, 0.06919585f, -0.04277224f, 0.05553979f, 0.02459347f, -0.05666114f, -0.01127335f, 
    0.38464329f, 0.09442728f, -0.10781532f, 0.20930113f, 0.05460157f, 0.12082279f, -0.09491199f, 0.15483621f, 
    0.04737278f, -0.00591770f, 0.07360917f, -0.07886854f, 0.26142552f, -0.19932063f, -0.10847178f, 0.29091442f, 
    0.12081535f, -0.07308839f, -0.05106417f, 0.07310661f, -0.06214043f, 0.04699724f, -0.07830779f, -0.01943923f, 
    -0.27436125f, 0.09690434f, -0.08830562f, 0.22835770f, -0.10451966f, 0.02228426f, -0.04551798f, 0.02394245f, 
    0.12506261f, 0.00933263f, 0.08326463f, -0.01282744f, 0.08009098f, -0.01571332f, 0.05313895f, 0.06214752f, 
    -0.00704024f, -0.01269485f, 0.01024982f, -0.10882536f, -0.03280593f, -0.04202032f, 0.18701874f, 0.05486201f, 
    0.08228076f, 0.02266328f, -0.00101331f, 0.32101464f, -0.02890557f, -0.02723924f, -0.06233795f, -0.08557662f, 
    -0.03860697f, -0.01764400f, -0.08072553f, 0.02329057f, -0.01127781f, 0.01379792f, 0.20214973f, -0.05732052f, 
    0.12458605f, 0.02849586f, 0.02896002f, -0.01798682f, -0.02621264f, 0.01063533f, 0.03061255f, -0.01327468f, 
    -0.10412538f, 0.23218760f, -0.17198740f, -0.12590383f, 0.10913195f, 0.18604109f, -0.01517238f, 0.00870100f, 
    -0.02566598f, -0.03809195f, 0.04159836f, 0.07014375f, -0.04686676f, 0.21525384f, 0.11201425f, 0.16179161f, 
    -0.02847194f, -0.02370950f, 0.03926808f, 0.00787178f, -0.00924483f, -0.00912907f, 0.08306539f, 0.05135041f, 
    -0.22452363f, 0.02901779f, -0.07547805f, -0.25914648f, -0.01650358f, 0.00078117f, 0.01512420f, -0.05671846f, 
    0.03374198f, -0.02883358f, 0.01483604f, 0.02773098f, -0.06877862f, 0.06428268f, 0.13102058f, 0.15312500f, 
    0.14119253f, -0.00949644f, -0.00792087f, -0.02175448f, 0.05646946f, 0.02965341f, 0.14569995f, -0.03600499f, 
    -0.16349176f, -0.17824458f, 0.20951317f, -0.15523231f, 0.08449709f, -0.00115065f, -0.00470534f, 0.01205005f, 
    -0.13025746f, -0.01587992f, -0.00040947f, -0.14809941f, -0.04784981f, 0.03913210f, -0.11807823f, 0.35439369f, 
    0.02200193f, 0.16389680f, -0.05672142f, -0.00299939f, 0.13670404f, 0.05643498f, -0.00174464f, 0.04942369f, 
    0.10841373f, -0.05493398f, -0.00794556f, -0.09429324f, 0.10518924f, -0.02959468f, 0.05440387f, -0.01656093f, 
    -0.02571909f, 0.03061672f, 0.00214205f, 0.04571329f, -0.23227821f, -0.01321222f, 0.03568361f, 0.06328902f, 
    0.08831013f, 0.15042928f, 0.02662107f, 0.09752837f, -0.01784347f, -0.00716695f, -0.02557315f, -0.03623134f, 
    0.04830292f, 0.15228254f, -0.05014187f, -0.19478801f, -0.11874457f, 0.00562645f, 0.00554704f, -0.13757633f, 
    0.02379309f, -0.01644348f, -0.16238669f, -0.01556556f, -0.36378232f, -0.08425917f, -0.18869151f, -0.03717015f, 
    -0.16949439f, -0.00380286f, -0.00425376f, 0.10168042f, -0.05244670f, -0.02684545f, 0.08088698f, 0.03647436f, 
    -0.24849300f, 0.03364195f, 0.05690895f, -0.19215368f, 0.03289341f, 0.07427830f, 0.07727550f, 0.03884490f, 
    -0.00966461f, 0.04371948f, -0.01311522f, 0.06859417f, -0.18816358f, -0.08934467f, -0.14631501f, -0.11945400f, 
    0.11016995f, 0.03067243f, -0.11241326f, 0.07073563f, -0.05481996f, 0.01360192f, 0.00012895f, -0.04771494f, 
    0.03385064f, -0.13285151f, -0.05470655f, 0.06209460f, -0.10253516f, 0.08881825f, 0.07525889f, -0.10157775f, 
    -0.04320820f, 0.01933157f, 0.03536655f, 0.10451335f, -0.33563578f, -0.00388816f, -0.05339713f, -0.28912678f, 
    0.09696826f, 0.02776719f, 0.01708203f, -0.02371813f, 0.02110489f, 0.04350767f, -0.04689839f, -0.02074051f, 
    0.18383183f, -0.25874314f, 0.00541686f, -0.05002304f, -0.02831346f, -0.03138897f, 0.04095633f, -0.01482038f, 
    -0.06954716f, 0.08941739f, 0.10065193f, 0.01572308f, 0.15955019f, 0.00543481f, 0.03672407f, -0.10944039f, 
    0.09788009f, 0.00120099f, 0.03549907f, 0.03918829f, 0.00525424f, 0.02074892f, 0.03517500f, -0.04205034f, 
    -0.21844766f, 0.02703715f, -0.02286664f, -0.22521789f, 0.00202665f, 0.02302755f, 0.00009405f, -0.01832735f, 
    0.01401650f, 0.02819176f, 0.05444639f, 0.07591944f, 0.29445618f, -0.10118864f, 0.26601857f, -0.15514478f, 
    0.05167359f, -0.01633794f, -0.01234645f, 0.07228317f, 0.02509434f, 0.03705790f, 0.12979859f, 0.04625238f, 
    0.01996728f, 0.01694549f, -0.02312968f, -0.03513493f, 0.01482120f, 0.01310915f, 0.01452518f, -0.03823356f, 
    0.01912443f, -0.00370423f, 0.01972420f, -0.04084357f, -0.00746579f, -0.03424830f, 0.02101057f, -0.00793387f, 
    -0.00991286f, -0.02670670f, -0.03276208f, -0.02162350f, -0.02509715f, -0.03298086f, -0.03316870f, -0.00645922f, 
    -0.04360540f, 0.00535731f, -0.03003066f, -0.03479516f, -0.01033180f, -0.01699702f, 0.02175623f, -0.03843172f, 
    -0.02120155f, -0.02080997f, 0.02052889f, 0.03486473f, 0.02440313f, 0.02323466f, -0.01535530f, -0.03375233f, 
    0.02301921f, 0.01366551f, -0.02529879f, -0.03448626f, -0.03116664f, 0.00199699f, -0.04101615f, -0.03868213f, 
    -0.00131361f, 0.02360712f, -0.00496376f, 0.03163070f, -0.00111426f, 0.02500036f, -0.03342375f, -0.00503091f, 
    0.00685448f, -0.01640928f, -0.01058695f, 0.02119021f, 0.00016727f, -0.00882566f, -0.02356642f, -0.01769130f, 
    0.01907692f, 0.00732474f, -0.02412839f, -0.03178534f, -0.01997629f, 0.01378829f, 0.00355372f, 0.02675317f, 
    0.02331476f, 0.01436870f, 0.00432103f, 0.02284763f, 0.02874126f, -0.01760106f, -0.00661938f, 0.00538430f, 
    -0.01094233f, -0.03938475f, 0.02689906f, -0.01209956f, 0.02193320f, -0.03470682f, -0.03820766f, -0.04089273f, 
    -0.02694508f, -0.02842505f, -0.02292754f, -0.00819215f, 0.00823443f, 0.00279134f, 0.00183809f, -0.01350296f, 
    -0.01804295f, 0.02776350f, 0.01119300f, -0.03598777f, 0.01450581f, -0.03268695f, 0.01399870f, 0.02280682f, 
    0.00540958f, -0.00548628f, -0.03960633f, 0.00985575f, 0.01213164f, -0.03643541f, -0.00633711f, 0.01156417f, 
    -0.01844548f, -0.01722535f, -0.01684503f, -0.00734339f, -0.02762977f, 0.01450666f, 0.01160737f, -0.03962542f, 
    -0.01171292f, -0.03687731f, -0.02839167f, 0.02518479f, 0.02863113f, 0.00819023f, 0.00688557f, 0.00482044f, 
    -0.02114597f, -0.02435933f, 0.02390690f, 0.01415813f, -0.04347482f, 0.02406364f, 0.02264604f, -0.02074688f, 
    -0.00664093f, -0.03596658f, -0.02925194f, -0.01310710f, 0.01878145f, 0.00663571f, 0.02839434f, 0.02610438f, 
    -0.01450096f, -0.04147280f, 0.02540569f, -0.03755528f, 0.01891045f, 0.01119931f, 0.00324577f, -0.00957646f, 
    -0.01169719f, 0.00325001f, 0.00742463f, 0.01904649f, 0.01665759f, 0.00747645f, 0.01237269f, -0.01882061f, 
    0.02161255f, 0.01092063f, -0.01056023f, -0.01145973f, 0.01071890f, 0.01819081f, -0.04098331f, 0.01887588f, 
    -0.01852332f, 0.03237246f, -0.01857952f, 0.00539069f, 0.02331956f, 0.00208002f, 0.00691233f, -0.03130740f, 
    0.01958082f, -0.03873361f, 0.00526116f, -0.02370610f, 0.00041357f, 0.00078713f, -0.00759624f, -0.03051675f, 
    -0.03105847f, -0.02412111f, 0.00115788f, 0.03060338f, -0.01373647f, -0.01145569f, -0.01886003f, -0.02962574f, 
    -0.03335733f, 0.01926606f, -0.04039529f, -0.00180258f, 0.00169253f, -0.02220540f, 0.02910220f, 0.03037627f, 
    0.02282235f, 0.02413204f, -0.00081922f, 0.01038454f, -0.03240578f, -0.00840426f, -0.00609877f, -0.03878029f, 
    -0.03192219f, 0.02199828f, 0.00007963f, 0.02089451f, -0.02494683f, 0.01973100f, 0.01724170f, -0.01379010f, 
    -0.02206571f, -0.00320881f, -0.00009165f, -0.02103936f, 0.01215274f, 0.02323207f, -0.01042045f, -0.01388909f, 
    0.00568236f, -0.01290657f, 0.02876016f, -0.00968470f, 0.00538795f, 0.01671831f, -0.03339696f, -0.00937026f, 
    0.00699687f, 0.02146411f, -0.02957968f, 0.01302544f, 0.01675188f, -0.01128032f, -0.00325043f, 0.02815453f, 
    -0.00170008f, -0.01074328f, 0.03064242f, -0.00346322f, -0.01312065f, -0.01631091f, 0.01299882f, 0.02781050f, 
    0.01779977f, 0.02066983f, 0.01632513f, 0.00683383f, 0.01144766f, -0.01289129f, -0.00810523f, -0.00798752f, 
    0.00008579f, 0.02690315f, 0.01300625f, 0.00691816f, 0.02260374f, -0.02078483f, 0.01149651f, -0.04066543f, 
    0.00644091f, 0.02248658f, 0.00945183f, -0.00770791f, 0.02931516f, 0.01960910f, -0.03360161f, -0.03570290f, 
    0.00522673f, 0.01165878f, 0.01324822f, 0.02399305f, -0.03384763f, 0.00950290f, 0.03039818f, -0.00106701f, 
    0.00207055f, 0.02753742f, 0.01454928f, -0.01999659f, 0.02464299f, 0.01803637f, 0.02757318f, 0.02168120f, 
    0.00480298f, -0.02339650f, -0.01418963f, -0.01331347f, -0.01064218f, 0.01602325f, -0.03413257f, 0.00232901f, 
    -0.00143784f, 0.00810697f, 0.01196977f, 0.00494432f, -0.01636439f, -0.00904718f, 0.03002089f, -0.03481621f, 
    -0.01856337f, 0.01494228f, 0.00455744f, -0.00843913f, -0.00445118f, 0.02243869f, 0.03346284f, -0.02273129f, 
    0.01857186f, -0.01007541f, 0.01466328f, 0.00968694f, 0.02292416f, 0.02058739f, -0.01000737f, -0.01777729f, 
    -0.00727420f, 0.00709930f, -0.02731209f, -0.03734643f, 0.00498045f, -0.01137017f, -0.03639261f, -0.00874666f, 
    0.00527060f, -0.02133205f, 0.02235505f, 0.00372770f, 0.02908466f, -0.00368817f, 0.02144198f, -0.00844976f, 
    -0.00756506f, 0.01634706f, 0.00545638f, 0.01444094f, -0.00195541f, 0.00798659f, 0.03277537f, -0.03547218f, 
    -0.02156582f, -0.00391324f, -0.00432046f, 0.02875525f, 0.02435810f, -0.01704486f, 0.00850568f, -0.03508022f, 
    -0.02810969f, -0.03420724f, -0.01365869f, -0.00462818f, 0.02838837f, -0.02208346f, -0.00899116f, 0.01630501f, 
    -0.01980290f, -0.02033360f, -0.01799974f, -0.00043559f, 0.00739659f, -0.02675868f, 0.00710654f, -0.00389481f, 
    -0.03832701f, -0.00068811f, 0.02204230f, 0.00360657f, -0.02596108f, 0.01579396f, -0.00512751f, 0.01775203f, 
    0.02056033f, -0.00340786f, 0.00220858f, -0.01095956f, -0.00032034f, 0.02461966f, -0.00672662f, -0.02092778f, 
    0.03629874f, -0.03415709f, -0.01897606f, 0.02213619f, -0.02437811f, -0.00004591f, -0.02146340f, -0.02032945f, 
    -0.03324304f, 0.00524317f, 0.03149930f, -0.00172167f, -0.01808749f, 0.00694515f, 0.02110697f, 0.00065134f, 
    0.01792297f, -0.02543261f, -0.00234866f, 0.02960492f, 0.02307758f, 0.02356584f, 0.02038000f, -0.01411624f, 
    -0.01267270f, -0.02565772f, -0.03914518f, -0.02981663f, 0.02907052f, 0.02620482f, -0.04014973f, -0.01569969f, 
    0.02122799f, -0.01921834f, -0.00904236f, -0.01940807f, -0.03328659f, -0.01778749f, -0.00836977f, -0.00418145f, 
    0.00473474f, -0.02741465f, -0.02526167f, -0.00408941f, -0.02482021f, -0.02770500f, 0.02530376f, 0.02593675f, 
    0.02750893f, 0.00832824f, 0.00262066f, -0.03482415f, 0.01904575f, -0.01839285f, 0.00223555f, -0.03226881f, 
    0.01287200f, -0.03455766f, 0.02549768f, -0.01352039f, 0.01897621f, -0.00845697f, -0.01985380f, -0.03762533f, 
    0.03046069f, 0.01901244f, 0.02141890f, -0.01539274f, -0.01739066f, -0.01618072f, -0.03688798f, 0.00784267f, 
    0.02758438f, 0.01144335f, -0.00828773f, 0.00656804f, -0.03563874f, 0.00210692f, 0.00512985f, -0.03402879f, 
    -0.00884682f, 0.01659843f, -0.02684665f, -0.01144581f, -0.01453375f, -0.00153887f, -0.00448097f, -0.02724778f, 
    -0.03083658f, -0.01692900f, -0.03359174f, 0.00202898f, -0.03044934f, 0.00371835f, -0.03885538f, 0.02692419f, 
    0.00647355f, -0.03040127f, -0.02682252f, -0.01906894f, -0.00321441f, -0.01649753f, 0.01945989f, -0.02489275f, 
    -0.01037778f, -0.00612367f, 0.02034102f, -0.00175193f, -0.00463470f, 0.02337424f, 0.01802930f, -0.03054658f, 
    -0.00368501f, 0.00118770f, 0.01591849f, 0.01196393f, 0.01436687f, 0.01394940f, -0.03282326f, 0.02259443f, 
    0.00080491f, -0.00795681f, -0.04260313f, -0.03659868f, -0.02516448f, 0.02947759f, 0.00202157f, -0.04043850f, 
    -0.00171279f, 0.00818500f, 0.02134262f, -0.02125588f, -0.02084571f, 0.02681920f, -0.01048474f, -0.03998232f, 
    0.01688601f, 0.00372450f, -0.00044791f, 0.00650988f, 0.02158445f, -0.01866686f, 0.02378931f, 0.01148987f, 
    -0.02600441f, -0.03631926f, -0.03822622f, 0.00501945f, 0.02633809f, -0.00416866f, -0.03616412f, -0.04127432f, 
    -0.02830354f, 0.02590898f, 0.01392219f, -0.02893601f, 0.01164830f, -0.03073737f, -0.03276579f, -0.01698238f, 
    0.01183895f, 0.02014885f, -0.03380894f, -0.01817818f, -0.00746551f, 0.00061889f, 0.02193994f, -0.00273592f, 
    -0.02491808f, 0.02126977f, -0.03478852f, -0.03720490f, -0.02000150f, -0.00336347f, 0.01782516f, -0.03160523f, 
    -0.01081017f, -0.03598779f, 0.00430832f, -0.03903121f, 0.01074368f, -0.01915908f, -0.03291138f, 0.02497626f, 
    0.00357622f, 0.02902471f, 0.01442865f, 0.01396932f, -0.01424799f, -0.03371553f, -0.00441467f, -0.04010991f, 
    -0.01853645f, 0.01068227f, -0.03472123f, 0.03841608f, 0.01474150f, 0.01529665f, -0.02570928f, -0.00278316f, 
    0.01276025f, 0.00539623f, -0.02841612f, 0.02052586f, 0.01685688f, -0.02814899f, -0.02637085f, 0.00736239f, 
    -0.02571710f, 0.01975915f, -0.03873622f, -0.01853438f, -0.00958942f, 0.02002610f, 0.00645744f, -0.03167595f, 
    -0.01192929f, -0.01558905f, 0.01360005f, -0.00097909f, 0.00306018f, -0.02063047f, -0.03824934f, -0.00480930f, 
    -0.03542934f, 0.02329080f, -0.02423039f, 0.00438823f, 0.03706841f, -0.03820657f, 0.01549758f, 0.02723335f, 
    -0.00566526f, -0.02680912f, -0.02261988f, -0.00635278f, 0.01736027f, -0.02131456f, -0.01523447f, -0.03670326f, 
    -0.01389154f, 0.02365881f, -0.00035386f, -0.02077657f, 0.02168705f, -0.00208605f, -0.01564711f, -0.02064581f, 
    0.01834331f, -0.01241952f, 0.00189995f, 0.01959907f, 0.00503623f, 0.01018516f, -0.00397850f, -0.00592350f, 
    -0.02640202f, 0.01465084f, 0.02118539f, -0.02800510f, -0.02129460f, 0.01916107f, -0.02001264f, 0.01874614f, 
    -0.03427323f, 0.01924280f, -0.01743623f, -0.03990824f, 0.01543005f, 0.02580795f, -0.02243522f, 0.02980935f, 
    -0.00793994f, 0.02551445f, -0.01938174f, -0.03488695f, -0.02608092f, 0.00011392f, 0.00536649f, 0.01774319f, 
    0.00724009f, 0.00958471f, -0.00796646f, -0.00659148f, -0.00241922f, -0.01237025f, -0.01389952f, 0.01013979f, 
    -0.02683485f, 0.02110693f, -0.00123650f, 0.00622773f, 0.01665869f, 0.02026718f, 0.02235013f, -0.02198633f, 
    -0.02228354f, -0.00580775f, 0.02005640f, -0.02172250f, 0.01297685f, -0.02811466f, -0.01043746f, -0.03454857f, 
    -0.02948331f, -0.01829147f, -0.02784956f, 0.02285273f, 0.00835099f, -0.03014052f, -0.03506908f, 0.02784372f, 
    0.00572498f, -0.02884252f, -0.00950390f, -0.03181970f, -0.03617575f, -0.02378826f, -0.03775092f, -0.01058683f, 
    -0.01327672f, 0.01783870f, -0.00106370f, 0.02331872f, 0.00331441f, -0.00827736f, 0.01315524f, -0.00629679f, 
    -0.01034142f, 0.00021090f, -0.00431288f, 0.00625972f, 0.02164746f, 0.03205535f, 0.03210153f, -0.01869991f, 
    0.02108463f, -0.01931458f, -0.00973062f, -0.03451495f, 0.02021169f, -0.01771194f, -0.02274791f, -0.02374264f, 
    0.03043802f, 0.02866054f, -0.00147144f, -0.00089782f, 0.02439795f, -0.02050876f, -0.02379103f, -0.00544883f, 
    -0.02213151f, 0.00787079f, 0.02841347f, 0.00236010f, 0.00519623f, -0.03913105f, -0.03005598f, -0.01138872f, 
    0.00477144f, 0.02215245f, -0.01791477f, -0.02545338f, 0.02405925f, -0.02562563f, -0.01013013f, -0.03293583f, 
    -0.02347588f, 0.01484642f, 0.02665406f, -0.03441311f, -0.00440283f, -0.00480161f, -0.02321617f, -0.02096522f, 
    -0.02891497f, -0.02828027f, 0.02990797f, 0.00394177f, -0.00072293f, 0.01644230f, 0.03274350f, -0.04129625f, 
    -0.01423526f, -0.03880445f, 0.01417520f, 0.02903394f, -0.03165760f, -0.01690752f, 0.01471157f, -0.03009392f, 
    -0.02205296f, 0.01124026f, -0.00046584f, -0.01164145f, -0.01579347f, -0.02908462f, -0.01397284f, -0.00054246f, 
    0.02390603f, 0.01252069f, -0.03579650f, 0.02542081f, -0.00981862f, -0.02275422f, 0.00074331f, 0.01140932f, 
    0.00622125f, 0.02232291f, 0.01560176f, 0.01842111f, -0.00174373f, -0.03779785f, -0.02078721f, -0.00128082f, 
    -0.03343574f, -0.00952668f, -0.02792097f, -0.00935412f, 0.02541700f, -0.02489460f, 0.00270177f, -0.02278454f, 
    -0.03216334f, -0.00253095f, -0.01999103f, -0.02276280f, -0.03754503f, -0.02922484f, -0.02328742f, -0.00716365f, 
    0.00905688f, -0.00169358f, -0.00399246f, -0.04048295f, -0.02783304f, 0.00248102f, -0.01933200f, -0.00318114f, 
    -0.01539798f, -0.02276617f, -0.00532147f, -0.02823042f, -0.02030976f, -0.04150877f, -0.00246767f, 0.00987575f, 
    -0.03881474f, -0.02191803f, -0.01367885f, -0.03410547f, -0.02028061f, -0.03326114f, 0.00555777f, -0.03858007f, 
    -0.00158711f, 0.01232642f, 0.02361996f, 0.00989636f, -0.00119984f, -0.03302238f, 0.02403415f, -0.00014267f, 
    -0.01950435f, -0.01922038f, 0.01298273f, 0.00599261f, -0.03251464f, -0.02221077f, -0.01543253f, -0.00215782f, 
    0.02728094f, 0.02194052f, 0.00199254f, 0.00326451f, 0.02661270f, -0.00621709f, 0.02823291f, -0.00316143f, 
    -0.02301188f, -0.01354871f, -0.03223512f, -0.03182307f, 0.01253582f, -0.03682875f, -0.00002043f, -0.01711324f, 
    -0.00927552f, -0.03677641f, 0.01654003f, -0.02385479f, -0.00153878f, -0.01100245f, 0.02482271f, -0.01757679f, 
    0.00444102f, -0.03916817f, 0.02053318f, 0.01235025f, -0.01844731f, -0.00632869f, -0.03701932f, 0.01781597f, 
    -0.03694211f, -0.02007597f, 0.01262552f, -0.00172248f, -0.01381240f, -0.03748185f, 0.00640725f, 0.01562585f, 
    -0.01686809f, -0.00020948f, -0.02525823f, 0.01901328f, -0.00501861f, -0.02783431f, 0.00656298f, -0.02829756f, 
    0.02994674f, 0.01108890f, -0.01523283f, -0.03161474f, -0.00696242f, -0.03692267f, -0.00487841f, -0.00484657f, 
    -0.02024724f, 0.01115058f, 0.00926235f, 0.01599356f, 0.01694985f, 0.00222383f, -0.01630641f, -0.02411043f, 
    -0.03412919f, 0.01757017f, 0.01878975f, 0.00089437f, 0.01748221f, 0.00251700f, 0.02530115f, -0.00236590f, 
    -0.01289915f, -0.00834478f, 0.01802403f, 0.01296845f, -0.02822033f, 0.02164776f, -0.02236806f, 0.02878074f, 
    -0.00195721f, -0.04150181f, -0.02069324f, -0.03936506f, -0.04102254f, 0.03519499f, 0.00743546f, 0.00657076f, 
    -0.02729943f, -0.02783939f, -0.03258825f, -0.04130057f, 0.02011807f, 0.02320055f, -0.04176693f, -0.01830978f, 
    -0.03183214f, -0.01294161f, 0.01184222f, 0.00183047f, -0.03540126f, -0.01748313f, -0.00348792f, -0.02091647f, 
    -0.02734804f, -0.01276013f, -0.04072308f, 0.01048421f, -0.04156892f, -0.00857015f, 0.02413625f, -0.03501271f, 
    0.02888106f, 0.01129272f, -0.00443671f, -0.00164894f, 0.01998390f, 0.00837724f, -0.01966759f, 0.01562425f, 
    0.02310145f, 0.02255331f, -0.03788840f, 0.00348307f, -0.00114467f, -0.01201974f, -0.00297222f, -0.02123087f, 
    -0.02768632f, 0.01216433f, -0.01699597f, 0.01090734f, 0.00741267f, -0.02964854f, -0.03164458f, -0.03456863f, 
    -0.02915697f, -0.03847008f, -0.01238289f, -0.00405730f, -0.01771496f, 0.02229824f, 0.00720675f, 0.02598707f, 
    -0.00265398f, -0.03698935f, -0.03689598f, -0.01503097f, -0.00796539f, 0.02275329f, 0.02452989f, -0.00492026f, 
    -0.00325345f, -0.01487413f, -0.02772835f, 0.01966463f, -0.03110716f, 0.02143782f, -0.03438662f, -0.02890295f, 
    -0.02520172f, -0.02615061f, 0.01150293f, 0.02433333f, 0.00889918f, 0.03758715f, -0.00645471f, 0.02281589f, 
    -0.01552167f, -0.01542333f, 0.00420207f, -0.01294943f, -0.02688744f, -0.04155529f, 0.02961531f, -0.01241586f, 
    -0.02401975f, -0.00833370f, -0.02622008f, -0.00801174f, -0.03021493f, -0.03673708f, -0.02008848f, -0.03389097f, 
    0.00031271f, 0.02745835f, -0.03597408f, -0.00234611f, 0.01512529f, -0.00195881f, -0.00011536f, 0.02908703f, 
    0.02147229f, 0.00137007f, -0.03424763f, -0.02489461f, -0.00149556f, 0.01372719f, -0.02806051f, 0.00600790f, 
    -0.03041144f, -0.00497138f, 0.02728918f, 0.01629617f, -0.01931472f, 0.01564078f, -0.00350380f, -0.03354018f, 
    -0.00744401f, 0.01922577f, 0.00602113f, -0.00909299f, -0.00261541f, 0.01412064f, 0.00822357f, 0.02962312f, 
    0.02565106f, -0.02651329f, -0.00553444f, 0.01678176f, -0.02134884f, -0.01314406f, 0.01189745f, -0.01384622f, 
    -0.03473205f, -0.03459824f, 0.00831876f, -0.01184825f, 0.02090504f, 0.00651248f, -0.01630509f, -0.01682005f, 
    -0.00409646f, 0.00058970f, -0.02643306f, 0.01557514f, -0.01130246f, 0.02416451f, -0.02061539f, 0.00823164f, 
    -0.02417484f, -0.00662861f, 0.00774581f, 0.00498343f, -0.01390283f, -0.02801877f, -0.03193401f, -0.03421341f, 
    0.00409975f, 0.00559942f, -0.01703972f, 0.02355636f, -0.03861304f, -0.02163233f, 0.00161727f, 0.01444449f, 
    -0.04166403f, -0.00652540f, 0.02982697f, 0.02008338f, -0.00549471f, -0.00765888f, 0.00726481f, 0.00958338f, 
    0.01626347f, 0.01639821f, 0.01294092f, -0.04039653f, -0.04153151f, -0.01244454f, 0.02239995f, 0.02256973f, 
    -0.00010921f, 0.00353482f, -0.01970490f, -0.01667431f, -0.00642422f, 0.01253322f, -0.03081045f, -0.00260797f, 
    0.02623706f, 0.02493408f, 0.00718681f, 0.00342149f, 0.00035382f, -0.00872650f, -0.02025188f, -0.03386140f, 
    -0.01263454f, 0.02944317f, 0.01581455f, 0.01684112f, -0.00775205f, 0.02501209f, 0.02635116f, 0.02894506f, 
    0.01267532f, 0.00276605f, 0.01006514f, -0.01780294f, -0.03607812f, -0.01275619f, 0.01247994f, -0.02485345f, 
    0.02224126f, 0.02990804f, -0.00508857f, -0.02450238f, -0.02731518f, -0.02784721f, -0.00031170f, -0.02212754f, 
    0.02138006f, 0.00568238f, -0.00122909f, -0.01272935f, 0.01673050f, -0.02256113f, 0.00045457f, -0.02368687f, 
    0.00065500f, -0.00785710f, 0.01777278f, -0.03374040f, -0.03980826f, -0.01938891f, -0.02605652f, 0.01219666f, 
    -0.02477721f, -0.01393552f, 0.02121593f, -0.01620164f, 0.02867695f, 0.01853886f, -0.01567595f, -0.03789851f, 
    0.02229189f, 0.02926959f, 0.00393918f, 0.01968371f, -0.03031596f, 0.00543424f, 0.01240875f, -0.00977314f, 
    0.02970373f, 0.02481781f, 0.00929514f, -0.03969209f, 0.01497746f, 0.00721488f, -0.00055701f, -0.02526576f, 
    0.00859420f, -0.00805610f, 0.02452364f, -0.01359089f, -0.03599852f, -0.00372552f, 0.01555253f, -0.00485292f, 
    0.01991979f, -0.00908219f, -0.01544194f, -0.02832598f, -0.00485056f, -0.01054521f, -0.03967554f, 0.00484609f, 
    0.00933747f, -0.02334293f, -0.02577022f, -0.03857011f, -0.03860000f, 0.00891807f, -0.03099994f, -0.00808864f, 
    -0.00224155f, -0.03268010f, -0.04014065f, 0.01067683f, -0.03610019f, 0.01050206f, 0.00942713f, 0.00533120f, 
    0.01755096f, -0.00362145f, 0.02688745f, -0.00480103f, -0.04075978f, -0.01758309f, -0.02604889f, 0.01358202f, 
    -0.00482203f, 0.02149274f, 0.00559844f, -0.03542814f, 0.02903046f, -0.00259574f, 0.02875847f, -0.00794166f, 
    -0.02147437f, -0.03146688f, 0.01718497f, -0.02038374f, -0.00112917f, -0.03579780f, -0.00686847f, 0.01921261f, 
    -0.02157935f, -0.01606844f, -0.02288156f, 0.00700543f, -0.01243905f, 0.02099369f, -0.00431035f, -0.02358446f, 
    0.02388586f, -0.02390061f, 0.01093995f, -0.02493199f, 0.02021472f, -0.02174794f, 0.03480731f, 0.02696616f, 
    -0.02652092f, -0.00879931f, 0.00535340f, -0.02676953f, -0.02355320f, 0.02672066f, 0.00846773f, -0.03675579f, 
    -0.03873741f, -0.02458834f, -0.02915215f, -0.03216695f, -0.01457791f, 0.00904740f, 0.01629757f, -0.00860698f, 
    -0.00181709f, -0.00833329f, 0.01487639f, -0.03484907f, 0.02981182f, 0.00775096f, -0.00571647f, -0.02902495f, 
    -0.00711354f, -0.01259202f, 0.01338260f, -0.01046503f, -0.00114416f, -0.01462700f, 0.01243915f, 0.00332743f, 
    -0.01199971f, 0.01072922f, -0.03460239f, -0.02090813f, 0.02469962f, -0.00478091f, -0.03866309f, 0.00980794f, 
    0.01604692f, -0.03990200f, -0.02093263f, -0.01200747f, 0.00772907f, -0.00564098f, -0.04066205f, 0.00866060f, 
    -0.02592827f, -0.00216475f, -0.02315598f, 0.00235838f, -0.03199816f, 0.02957154f, -0.00905645f, 0.00324351f, 
    -0.02436812f, 0.02544940f, 0.01205653f, -0.03714493f, 0.02202057f, 0.02701830f, -0.03085842f, -0.02870851f, 
    -0.03592667f, 0.02325616f, -0.03332491f, -0.00256505f, 0.03715466f, 0.01352246f, -0.01047990f, -0.02677294f, 
    0.00880196f, -0.03132879f, -0.03845204f, 0.00814446f, -0.02461345f, 0.03478291f, -0.00595110f, -0.02063628f, 
    0.02231934f, -0.03298280f, -0.03300311f, -0.01835933f, 0.03381684f, 0.00922052f, 0.01886787f, -0.00446903f, 
    0.01633758f, 0.01366450f, 0.00318877f, 0.02966573f, 0.02484320f, -0.01452250f, -0.00303835f, 0.02236352f, 
    -0.00978148f, -0.00184770f, 0.01487750f, 0.00995443f, 0.01167892f, 0.02990081f, 0.02249870f, 0.01898495f, 
    -0.01952265f, -0.01316126f, -0.02679075f, -0.02885699f, 0.01170575f, 0.00119843f, -0.00273346f, 0.00649180f, 
    0.01908129f, 0.00100259f, 0.00531790f, 0.01801996f, 0.02159132f, -0.00751232f, 0.00734955f, -0.01600540f, 
    -0.00373339f, -0.03484243f, -0.00633484f, -0.00507290f, 0.01879368f, 0.00050422f, -0.02960726f, 0.01644027f, 
    -0.00739246f, -0.03067532f, -0.00493011f, -0.01501214f, 0.02725576f, -0.02169434f, 0.00735028f, 0.00165378f, 
    0.00603628f, 0.00452347f, -0.01059750f, 0.01425763f, -0.01875959f, 0.01432644f, -0.02437365f, 0.02086276f, 
    -0.00869575f, -0.03015657f, -0.02974827f, -0.01152012f, -0.01694142f, 0.01144509f, -0.04016238f, -0.02009575f, 
    -0.00253589f, 0.01516636f, -0.01924720f, 0.01338227f, -0.01900792f, 0.00182657f, 0.01718090f, -0.01548993f, 
    -0.00979690f, -0.04124835f, 0.02086872f, 0.01447194f, -0.01930422f, -0.03267932f, -0.00416653f, -0.01283513f, 
    -0.02212594f, -0.03789194f, -0.01340232f, 0.01924816f, -0.02107112f, 0.02162384f, -0.00695878f, 0.02726261f, 
    0.02088084f, -0.00944336f, -0.03860871f, 0.02439523f, 0.01879510f, -0.02289543f, -0.00937562f, 0.00575787f, 
    -0.01734018f, 0.01784433f, 0.00314225f, -0.04064940f, -0.00029174f, 0.01947778f, -0.02390778f, -0.02366610f, 
    -0.01544330f, 0.02422720f, -0.00585992f, -0.03855665f, -0.01968507f, 0.00442542f, -0.00238947f, 0.00881572f, 
    0.02120261f, 0.01460995f, 0.01289030f, -0.00705884f, -0.00792190f, 0.01825703f, 0.00318386f, 0.02502136f, 
    -0.02260093f, 0.01039082f, 0.00611633f, 0.00170410f, 0.00192091f, -0.02259073f, 0.02626937f, -0.00598065f, 
    0.02253333f, -0.02119262f, -0.00911079f, 0.00215631f, -0.03127815f, -0.00724930f, 0.01413945f, 0.02920867f, 
    -0.04005461f, -0.02616761f, 0.02230087f, 0.02524370f, -0.03903452f, -0.00449858f, -0.00291057f, 0.01408469f, 
    -0.02087813f, 0.03304569f, 0.01588620f, -0.03477332f, -0.03283428f, -0.01101211f, 0.01257897f, -0.03554801f, 
    0.00604422f, -0.03607152f, 0.00574755f, 0.00898033f, -0.03621379f, -0.04121509f, 0.01464234f, -0.03910483f, 
    -0.02174958f, 0.02473591f, -0.01025670f, 0.00402680f, -0.01554366f, 0.00984538f, 0.02035950f, -0.01479140f, 
    0.22496819f, 0.05775922f, 0.00576651f, 0.00645770f, 0.01352618f, 0.00608485f, -0.03840652f, 0.13338436f, 
    -0.02946572f, 0.07149594f, -0.00477958f, 0.09512058f, 0.03805410f, 0.07316745f, 0.15513237f, -0.14010605f, 
    0.09334727f, 0.04952334f, 0.04178185f, 0.10534156f, 0.00510689f, -0.03581127f, -0.03963918f, 0.08726235f, 
    0.14538758f, 0.13322285f, 0.08680343f, 0.07835545f, 0.06805924f, 0.04802350f, -0.04899648f, -0.02109793f, 
    -0.04741733f, 0.05102638f, 0.01194686f, -0.00041320f, 0.14504419f, 0.10919330f, -0.07530177f, -0.21410815f, 
    -0.06878189f, 0.03006489f, -0.08739192f, 0.04253104f, 0.00853863f, 0.03084606f, 0.10527737f, -0.06100867f, 
    -0.22839634f, -0.01269189f, 0.04729846f, -0.26437381f, -0.02226637f, 0.01683889f, 0.13812988f, 0.03959581f, 
    0.04631159f, 0.04584102f, -0.01646947f, -0.02547040f, 0.18222430f, -0.06852164f, 0.09061165f, 0.06410050f, 
    0.03826020f, -0.04024474f, -0.08696900f, 0.15923886f, 0.05464567f, 0.05201604f, -0.02310001f, 0.03614067f, 
    0.33931008f, 0.05204570f, 0.10919181f, -0.03119408f, 0.04562060f, -0.04701748f, -0.11674953f, -0.02141773f, 
    -0.07427155f, 0.07737866f, 0.04799365f, -0.02988559f, 0.01555689f, -0.01204430f, 0.03423048f, -0.01218274f, 
    -0.00497311f, 0.05224292f, -0.01134842f, -0.01333764f, 0.05404589f, 0.04942672f, -0.07956242f, -0.00247942f, 
    -0.17564727f, 0.00784823f, 0.04891494f, -0.42764109f, -0.00969039f, 0.04311047f, 0.05739712f, -0.02579276f, 
    -0.06654893f, 0.03417305f, 0.06666214f, 0.02578745f, 0.04123468f, -0.12680128f, -0.02193274f, 0.08500531f, 
    -0.09826421f, -0.02754692f, 0.00628986f, 0.08171256f, 0.02436357f, 0.08604845f, 0.08658640f, 0.09140766f, 
    -0.12549239f, -0.17734368f, -0.09602129f, 0.02599728f, 0.01993400f, 0.01672293f, 0.05876455f, 0.03960403f, 
    0.04887654f, 0.00889006f, -0.00179878f, -0.10353947f, -0.13119370f, -0.05676128f, -0.07123351f, 0.16980678f, 
    0.02316361f, 0.00384110f, -0.01637611f, 0.00479984f, -0.05127500f, 0.08751646f, -0.02214970f, -0.01265273f, 
    0.06786846f, -0.15003327f, -0.17809440f, 0.06793654f, 0.04646766f, 0.01368004f, -0.06681896f, -0.03180481f, 
    0.07379086f, 0.07457081f, 0.01365989f, -0.03236544f, 0.24617043f, -0.01281519f, 0.10629351f, 0.05136878f, 
    -0.02983816f, -0.03332087f, 0.03353933f, 0.13572323f, 0.05941384f, 0.01397726f, -0.02066384f, 0.02188053f, 
    -0.14310990f, -0.10424738f, 0.05028972f, -0.14368752f, 0.05122161f, 0.08990832f, 0.09598733f, 0.07954495f, 
    -0.01391741f, 0.06341123f, 0.08393347f, 0.06047139f, -0.13757803f, 0.01243773f, -0.04058052f, -0.08372074f, 
    -0.01546344f, -0.09380223f, -0.05519068f, -0.03219302f, 0.02190797f, -0.00604472f, 0.01033167f, 0.00173854f, 
    0.17803466f, 0.06904439f, 0.08860131f, 0.18940118f, 0.04001538f, -0.04192345f, -0.02715450f, -0.07038866f, 
    0.04830321f, -0.05626306f, -0.00935412f, -0.08740751f, -0.09974907f, -0.06568850f, 0.17476071f, -0.20608866f, 
    0.10928089f, -0.05646937f, -0.01321279f, 0.03548771f, 0.09273817f, 0.00552263f, 0.08559648f, 0.07345986f, 
    -0.03240445f, -0.02948541f, 0.01899751f, -0.09854287f, 0.00094806f, -0.01885642f, -0.07049654f, 0.00196239f, 
    0.04563284f, 0.13039050f, 0.01047116f, -0.05776566f, 0.23612738f, -0.04187780f, 0.06267639f, -0.06247399f, 
    -0.00197682f, -0.00113751f, 0.04040563f, 0.01317082f, -0.00918706f, -0.04380970f, -0.04875788f, 0.01471529f, 
    0.12304121f, -0.05745989f, 0.03712256f, 0.11796939f, -0.07801259f, 0.00133641f, 0.02791194f, 0.04751480f, 
    -0.02072603f, 0.09312192f, 0.02062888f, -0.03734490f, 0.04001616f, 0.14376691f, -0.12090072f, 0.02818030f, 
    -0.03664992f, 0.02305700f, -0.00319581f, 0.04313459f, -0.02085637f, 0.00436058f, 0.05077000f, -0.00469589f, 
    0.22449894f, 0.10492182f, -0.10255904f, -0.08173166f, -0.01576470f, -0.06519117f, -0.02694572f, 0.00383551f, 
    0.04215342f, 0.08912437f, -0.04635014f, 0.00093215f, -0.48546720f, -0.12650512f, -0.02635829f, 0.08385347f, 
    0.03582923f, -0.01582699f, -0.05993530f, 0.03658707f, 0.04476698f, -0.01668485f, 0.04554258f, -0.06207231f, 
    0.15289128f, 0.02029545f, -0.00761168f, -0.04046143f, 0.06610502f, -0.05583179f, -0.02779896f, 0.05353776f, 
    -0.03855118f, 0.04034077f, 0.07126290f, 0.01271684f, 0.33638763f, 0.01902646f, -0.03849116f, 0.06082855f, 
    -0.02341482f, 0.00586726f, 0.02745419f, 0.01256593f, -0.02579302f, 0.11310233f, 0.02614618f, -0.03985623f, 
    0.02859849f, 0.02481190f, -0.03419574f, -0.26969323f, -0.06453780f, 0.09070807f, 0.10506563f, -0.01891103f, 
    0.07926058f, 0.04046150f, 0.09931688f, -0.04801291f, 0.19166553f, -0.15391880f, -0.12908283f, 0.00259597f, 
    -0.05369326f, 0.09049713f, -0.01363378f, -0.06689347f, 0.05494362f, -0.02704412f, -0.01004657f, 0.16305993f, 
    0.18377163f, 0.01985995f, 0.08359641f, 0.11376766f, 0.01926806f, -0.01662567f, -0.03791315f, -0.05683997f, 
    0.03627317f, -0.02913351f, 0.06264921f, -0.03340837f, 0.15072036f, 0.07162063f, 0.07885844f, 0.07339232f, 
    -0.00819593f, -0.05496742f, -0.05311820f, 0.07792453f, 0.02037437f, 0.15318437f, 0.09082574f, 0.01971283f, 
    -0.03416070f, -0.01225753f, -0.11583612f, -0.00893353f, 0.02913712f, 0.09622486f, -0.00033866f, 0.08112170f, 
    -0.10055637f, -0.13128592f, -0.03903531f, 0.00811972f, -0.19777110f, -0.11268999f, 0.06297514f, 0.05901181f, 
    -0.09941623f, 0.03046262f, -0.01859877f, 0.01468566f, 0.03321462f, 0.00305816f, 0.00835360f, 0.02888141f, 
    0.09762003f, -0.15287040f, -0.22145304f, -0.26021427f, -0.02487852f, 0.10156738f, -0.01118319f, -0.10518465f, 
    -0.06247418f, -0.04648686f, 0.05618489f, 0.10471027f, 0.07351673f, 0.02581894f, -0.00388847f, 0.40385726f, 
    0.04207635f, 0.01707072f, -0.02451957f, -0.07073060f, -0.04016807f, -0.05568572f, 0.01062733f, -0.02104651f, 
    0.01971198f, -0.12075970f, -0.18105516f, 0.05541492f, -0.03556419f, 0.03225956f, 0.01554099f, -0.00893175f, 
    0.07600752f, 0.02037619f, 0.01917391f, 0.02802329f, 0.14633368f, -0.28154656f, -0.01642497f, 0.02295983f, 
    0.02659438f, -0.02651178f, 0.04750473f, -0.03599257f, 0.00146038f, -0.03858412f, 0.06837123f, 0.09360208f, 
    -0.01943319f, 0.03330977f, 0.06248602f, 0.06050715f, -0.03351430f, -0.02628060f, -0.04872197f, 0.11504592f, 
    -0.05507519f, -0.07195280f, 0.04797901f, 0.07531171f, -0.18359333f, -0.10215589f, -0.14728376f, -0.27407730f, 
    0.08149921f, 0.04764679f, 0.17603688f, -0.07971277f, 0.02384376f, 0.03691181f, 0.01252955f, -0.04271026f, 
    0.08984286f, 0.10568435f, -0.12658644f, 0.22669525f, -0.00574382f, 0.01698545f, -0.03505875f, -0.03223791f, 
    0.02706530f, -0.03601979f, 0.10284576f, 0.04722679f, -0.25432006f, -0.16988017f, -0.13220377f, 0.03217547f, 
    -0.00446309f, 0.00017679f, -0.03572712f, 0.03903747f, -0.02656117f, 0.06391144f, 0.00660725f, -0.05774597f, 
    -0.27967051f, -0.03843575f, -0.07508329f, -0.31633222f, -0.08242534f, -0.06423403f, -0.00668009f, -0.04630639f, 
    0.20221157f, 0.00582294f, -0.07726319f, 0.06358510f, 0.13417128f, 0.14370564f, -0.09612778f, -0.28735605f, 
    0.07987853f, 0.06777852f, -0.03663646f, -0.04386232f, 0.06888881f, -0.01449265f, 0.02623493f, 0.08875964f, 
    0.13831070f, 0.17620517f, 0.11188617f, -0.03331058f, 0.09842394f, 0.01962564f, 0.10291079f, 0.08582476f, 
    -0.00926706f, 0.02987448f, -0.01519072f, 0.13681902f, 0.12871926f, -0.14576791f, -0.00583995f, -0.06826322f, 
    0.04898012f, 0.01344486f, -0.03811075f, 0.01003261f, 0.12067606f, 0.02463566f, -0.11057788f, 0.00175374f, 
    -0.08620738f, 0.00329752f, -0.06926946f, -0.20118871f, 0.09271353f, 0.04186635f, 0.01684835f, 0.05949330f, 
    0.01722728f, -0.04682793f, 0.11376388f, -0.02002074f, -0.01606541f, -0.05838002f, 0.06812799f, 0.04085403f, 
    -0.01861915f, -0.02235781f, -0.00870231f, 0.06388617f, 0.00411477f, -0.05593120f, 0.02742618f, -0.10434955f, 
    0.15180939f, 0.03466651f, -0.14592969f, -0.00361624f, -0.01486011f, -0.04499380f, -0.02309241f, 0.07376866f, 
    0.11487970f, 0.13341686f, -0.03243662f, 0.12277064f, -0.08235858f, -0.02951648f, -0.10792067f, -0.15682986f, 
    0.04676640f, 0.08472472f, -0.04220374f, 0.03868231f, 0.02031527f, -0.03813031f, -0.07237373f, 0.10165409f, 
    0.21697143f, 0.02808456f, 0.13705775f, 0.27097714f, 0.00095321f, -0.02371391f, -0.05890272f, 0.03121290f, 
    -0.08466836f, 0.04047325f, -0.00266711f, -0.03840042f, 0.17966452f, 0.07604750f, -0.01896735f, 0.07512677f, 
    -0.12422639f, -0.01508774f, 0.00578532f, -0.00922574f, -0.02971634f, 0.03194364f, -0.02205748f, 0.00846893f, 
    0.25597554f, -0.07803539f, -0.23410040f, 0.09664899f, -0.07932533f, -0.02201825f, -0.04900038f, 0.01471239f, 
    0.05983998f, -0.06476415f, -0.03198683f, -0.08010449f, 0.05242804f, 0.11186070f, 0.01409092f, -0.30187261f, 
    0.06108767f, -0.09838146f, 0.00114548f, 0.06387203f, -0.04410378f, -0.06865142f, 0.07861946f, 0.06664737f, 
    0.03527464f, 0.04124392f, -0.04530917f, 0.03380629f, -0.03573813f, -0.01801320f, -0.10615782f, -0.06944453f, 
    0.03582448f, 0.05831815f, 0.01287356f, -0.04816306f, 0.26405227f, 0.06116762f, -0.09283495f, 0.05231195f, 
    0.10499851f, 0.04579011f, 0.02736155f, 0.01996695f, 0.04502508f, 0.02295146f, 0.03643327f, 0.16150545f, 
    0.07809098f, -0.08324090f, 0.06960894f, -0.04326067f, 0.03310400f, -0.09122416f, 0.09142703f, 0.02896462f, 
    0.03327184f, 0.07035189f, -0.03823141f, 0.04371617f, 0.42369878f, -0.08195729f, 0.00295394f, 0.18160215f, 
    0.04549622f, 0.04923739f, 0.02684767f, -0.05106094f, 0.04718387f, 0.08041800f, -0.05864365f, -0.03080201f, 
    0.19637570f, -0.02565632f, 0.00781025f, 0.29760191f, 0.05512568f, -0.05201324f, -0.08441393f, 0.06689493f, 
    0.03858735f, 0.01320156f, 0.04042799f, -0.05683326f, 0.21420707f, 0.07598291f, 0.04976216f, 0.18828762f, 
    0.01561964f, 0.06537762f, 0.02749671f, -0.01269230f, -0.09622124f, 0.02834383f, -0.01594995f, 0.03072068f, 
    0.11038580f, 0.03350894f, 0.03572786f, -0.11031573f, -0.00894361f, 0.04386273f, -0.07303247f, 0.06600320f, 
    -0.00679910f, 0.07290006f, -0.01399410f, 0.01660310f, 0.01998636f, 0.01751922f, 0.09084259f, 0.30170375f, 
    0.01833898f, -0.06903330f, 0.01638729f, 0.04538527f, 0.05207228f, 0.01610662f, 0.09511963f, 0.10989426f, 
    0.14080662f, 0.09868495f, 0.05381314f, 0.07647215f, 0.00616727f, 0.05554918f, -0.09950490f, -0.05016720f, 
    0.09117880f, 0.00867032f, -0.03447447f, -0.03051957f, -0.00376549f, 0.05132768f, -0.11337892f, -0.10975838f, 
    0.00475508f, 0.04078817f, 0.00472860f, 0.01378198f, -0.03740672f, 0.01432587f, -0.06269611f, 0.05080019f, 
    0.13784647f, 0.05577459f, 0.02975633f, 0.28570533f, 0.02243175f, -0.00515907f, 0.07012868f, -0.02942026f, 
    -0.12588805f, 0.01484324f, 0.01418438f, 0.03183950f, 0.06585208f, -0.01600311f, -0.07372313f, 0.19003493f, 
    0.05088657f, 0.05490878f, 0.06517456f, -0.19230005f, 0.01441465f, -0.06988132f, 0.02887670f, -0.06012942f, 
    0.10778087f, 0.16080967f, -0.05874367f, 0.14020242f, -0.06261969f, 0.08904617f, -0.04260239f, -0.08550934f, 
    0.07582907f, 0.07153959f, 0.14178914f, 0.02772021f, -0.20226648f, -0.02898140f, -0.03736994f, 0.04430708f, 
    0.03583923f, -0.03040702f, -0.08677208f, -0.09733224f, 0.02834461f, -0.10190088f, 0.06853114f, -0.06259309f, 
    0.10758059f, -0.05066677f, 0.26302806f, 0.13235925f, 0.00255852f, 0.04572709f, 0.06061924f, 0.02855938f, 
    0.08708737f, -0.01333013f, 0.11533280f, 0.00881057f, -0.13226321f, 0.12287014f, -0.06468421f, -0.08166601f, 
    0.07649849f, 0.01866164f, 0.00741511f, -0.09349273f, 0.09966174f, -0.04369454f, 0.06730023f, 0.03835539f, 
    0.10188620f, -0.07834098f, 0.00786887f, -0.17229523f, 0.02243369f, 0.05453793f, 0.02086715f, 0.02949550f, 
    0.00392536f, -0.00401291f, 0.15300336f, 0.00079189f, 0.00040598f, -0.00495657f, -0.00933186f, 0.05670072f, 
    -0.04345131f, -0.03264096f, 0.01805624f, 0.02863538f, 0.03784122f, -0.03770107f, 0.01330623f, 0.01026174f, 
    -0.16068311f, -0.05519976f, 0.30035597f, 0.00371261f, 0.09504781f, 0.05943557f, 0.03006203f, 0.06908730f, 
    0.13952729f, 0.04736446f, 0.03886278f, 0.06026109f, -0.08116537f, -0.20431334f, 0.15297984f, 0.02906355f, 
    -0.01952397f, -0.00276458f, -0.00814118f, 0.07236392f, -0.01692944f, -0.10817359f, -0.01682095f, -0.04690506f, 
    -0.00790873f, -0.09036795f, -0.10311557f, 0.01027446f, 0.06815493f, 0.06623939f, 0.12867050f, 0.00446139f, 
    -0.05992038f, 0.06706304f, 0.00535871f, 0.06926434f, 0.15638267f, -0.09811635f, -0.01288158f, 0.08411036f, 
    0.05785200f, -0.04601583f, -0.00314475f, -0.03975620f, -0.07153363f, 0.06610931f, -0.02795703f, 0.01454523f, 
    0.00097025f, -0.06632548f, -0.03157150f, -0.10806324f, 0.12011848f, 0.08210356f, -0.03334535f, -0.11806868f, 
    -0.05822740f, -0.02840591f, -0.04352343f, 0.04512583f, -0.20443146f, 0.02861873f, 0.14245553f, -0.03145043f, 
    0.07275413f, 0.00230075f, -0.04035352f, 0.02994825f, 0.07681800f, 0.09739399f, 0.03962160f, 0.03007593f, 
    0.11560023f, 0.22969633f, 0.12853363f, 0.12649289f, 0.10519833f, 0.14268790f, -0.00370098f, 0.01106077f, 
    0.02948875f, 0.07136442f, -0.01444895f, 0.07988812f, -0.10027852f, -0.02412729f, -0.07158800f, 0.09785470f, 
    -0.03003439f, 0.06748204f, 0.07803711f, 0.11225198f, -0.00062625f, 0.07735300f, 0.04814875f, 0.06694507f, 
    -0.00140992f, -0.13255568f, 0.02823649f, -0.23478729f, 0.02387438f, -0.01942328f, 0.10957283f, 0.00347030f, 
    0.01352386f, 0.10632341f, 0.00276157f, 0.14632128f, -0.12238618f, -0.13477790f, 0.04395635f, -0.04902686f, 
    0.01588177f, 0.05568823f, 0.05567594f, 0.09285214f, 0.02530132f, 0.08129067f, -0.00179580f, 0.11153639f, 
    0.03334723f, 0.12249169f, 0.06523708f, 0.15491079f, 0.02087045f, 0.03906716f, 0.02407194f, 0.05107969f, 
    0.01195122f, -0.07451952f, 0.03236309f, -0.01869264f, -0.03637039f, -0.15763074f, -0.18390036f, -0.04884044f, 
    -0.01388389f, 0.09987042f, 0.02446075f, 0.00583735f, -0.07442414f, 0.01516635f, 0.12333414f, 0.01844374f, 
    0.17216779f, -0.08285088f, 0.07106798f, -0.00677161f, -0.01025898f, -0.05146598f, 0.09819081f, 0.04418468f, 
    0.10371976f, 0.02204103f, 0.10162692f, 0.15753569f, -0.01612387f, -0.05392370f, -0.08878558f, -0.07292675f, 
    0.03026493f, -0.00253830f, 0.02228505f, 0.10267737f, -0.04090359f, -0.09603962f, -0.03120496f, -0.00124762f, 
    0.30238119f, 0.15807869f, 0.05054497f, 0.17186795f, -0.03862533f, -0.08698808f, -0.00257858f, 0.03853526f, 
    -0.01476584f, 0.09331957f, 0.05507713f, 0.11009339f, -0.19080146f, 0.10772479f, 0.18273136f, -0.01669144f, 
    0.02612494f, 0.08428527f, 0.07966961f, 0.08419169f, 0.16034661f, 0.01069162f, 0.07687753f, 0.03489050f, 
    -0.09926233f, 0.05046006f, 0.22205319f, -0.04269066f, 0.11365792f, 0.04671366f, -0.07997204f, 0.00604768f, 
    0.00147085f, -0.02886186f, 0.04479380f, 0.06698157f, 0.23457409f, -0.06288317f, -0.07864770f, -0.21618526f, 
    0.00186708f, 0.02487582f, 0.00035929f, 0.11760621f, 0.07386893f, 0.09881081f, -0.09517981f, 0.09477514f, 
    0.04969934f, -0.05584512f, 0.00702785f, 0.03208740f, 0.01137001f, 0.09600831f, 0.00719706f, 0.11055331f, 
    0.01067783f, 0.10029945f, 0.10489104f, 0.16207761f, -0.29357460f, -0.01836809f, 0.21333893f, 0.07378760f, 
    0.06387160f, -0.06190582f, 0.01726232f, -0.13611646f, 0.01153860f, 0.01067996f, -0.00947686f, -0.02989926f, 
    -0.12127703f, -0.17036882f, 0.18721931f, 0.18170738f, 0.01848818f, 0.02223565f, 0.02203854f, -0.01601074f, 
    0.09377253f, 0.06031822f, 0.22527632f, -0.02939854f, -0.05175882f, 0.05074865f, -0.05588098f, -0.19828393f, 
    0.00259270f, 0.01106718f, -0.00586961f, -0.08568957f, 0.05967784f, 0.08252509f, -0.10160933f, -0.07361498f, 
    0.10191239f, -0.03883803f, 0.02206532f, -0.06010983f, -0.00292187f, 0.00732598f, 0.09557708f, 0.06071762f, 
    0.05423345f, 0.03614556f, -0.00543761f, 0.07098815f, 0.12117925f, -0.06765491f, -0.01762114f, 0.07495359f, 
    0.02438210f, -0.02320023f, -0.02964852f, 0.12488943f, 0.09350239f, 0.06047745f, -0.12907694f, 0.06095546f, 
    -0.12545297f, -0.03722714f, -0.10620348f, -0.11200780f, -0.03631455f, 0.07451627f, -0.12783422f, -0.00836073f, 
    0.03873940f, -0.08818834f, 0.12005980f, 0.03454735f, -0.03221375f, -0.16231620f, -0.02488185f, -0.03157645f, 
    -0.05340375f, -0.04047342f, -0.03633608f, 0.05043498f, 0.08459616f, -0.08952726f, 0.03505407f, -0.06502794f, 
    -0.32562640f, 0.39534771f, -0.25846028f, -0.11786505f, 0.05719398f, 0.02990143f, 0.10840303f, -0.12708090f, 
    0.11284959f, 0.06379230f, -0.10378473f, -0.02504968f, 0.23214798f, 0.12682889f, 0.06088748f, 0.08859114f, 
    -0.12250283f, 0.07314519f, 0.00545003f, 0.14851737f, -0.00677807f, 0.02048666f, 0.04665271f, -0.04168294f, 
    -0.01294046f, 0.01548427f, -0.10998600f, -0.08543212f, 0.03316950f, 0.09571782f, -0.00441385f, 0.17368054f, 
    0.03076360f, -0.09462241f, 0.01481738f, -0.00697723f, -0.19483386f, 0.18580078f, 0.11838572f, -0.17927578f, 
    0.04340183f, 0.03341416f, -0.02430820f, 0.04250105f, 0.10479403f, 0.03372831f, -0.03231253f, -0.01066225f, 
    -0.12206937f, -0.07357737f, 0.03112899f, -0.10589925f, 0.10102065f, 0.05199714f, 0.00704282f, 0.04490123f, 
    -0.01345540f, -0.11972275f, 0.05324327f, 0.07445081f, -0.06086965f, 0.06330784f, 0.08414444f, -0.26713318f, 
    0.08606948f, -0.05724411f, 0.04628672f, 0.03133074f, 0.03181605f, -0.04020783f, -0.05350897f, 0.04463331f, 
    -0.02292731f, 0.04062613f, -0.14561805f, 0.03817687f, -0.00446091f, -0.03853981f, -0.00756061f, 0.07708568f, 
    0.06739735f, 0.02269931f, 0.07747743f, 0.13605088f, 0.19263703f, 0.06440215f, 0.09025612f, -0.02981667f, 
    0.05013864f, 0.03744269f, 0.04255332f, 0.08991159f, 0.01634488f, -0.06024559f, 0.05725572f, 0.12723714f, 
    -0.14548162f, -0.11701792f, 0.01040764f, -0.21954568f, 0.02962226f, 0.01433739f, 0.08279540f, -0.00493838f, 
    -0.06681132f, 0.09350896f, 0.04873079f, -0.13464890f, -0.29398382f, 0.23448579f, -0.11992392f, -0.18061596f, 
    0.02396062f, 0.11288264f, 0.12880805f, -0.01565848f, 0.10717830f, 0.01256925f, 0.01026752f, -0.01210405f, 
    0.10375111f, -0.17737165f, 0.07826895f, -0.03668771f, 0.00985406f, -0.06088465f, 0.15348603f, 0.03217569f, 
    0.11317879f, -0.10787627f, -0.05511234f, -0.00896868f, 0.05606625f, -0.14437732f, -0.15145248f, -0.04945904f, 
    -0.02918250f, 0.04397283f, 0.02797059f, 0.06425701f, 0.05861216f, 0.13077947f, -0.04113828f, -0.02161128f, 
    0.01836006f, 0.10693420f, -0.01974448f, -0.16609704f, -0.00597066f, 0.00502670f, 0.15094163f, -0.09678533f, 
    -0.06908164f, -0.01704645f, 0.08035287f, 0.10196224f, -0.10848461f, -0.09501158f, -0.03309783f, 0.01822658f, 
    0.04608940f, 0.05755697f, -0.03921008f, -0.16491966f, 0.00267962f, 0.04005773f, -0.00369476f, 0.19128828f, 
    0.11496223f, -0.11197535f, 0.12796520f, 0.11723910f, 0.04525791f, 0.08855602f, 0.05191347f, -0.01778396f, 
    0.00418800f, 0.00809382f, -0.13586943f, 0.06436974f, 0.08324530f, -0.18079367f, 0.04567449f, -0.19736220f, 
    0.02385060f, -0.04660939f, -0.00261948f, 0.07555260f, 0.04645592f, 0.01395788f, -0.04427818f, -0.02622452f, 
    0.09309275f, -0.10642947f, 0.22084059f, 0.14411516f, -0.07094757f, 0.04850893f, 0.02603201f, -0.00773474f, 
    0.05620690f, 0.07089453f, 0.12547788f, 0.03848447f, 0.06659360f, -0.01919290f, 0.08644899f, 0.07688806f, 
    0.03281598f, 0.01661153f, -0.03832532f, -0.00950527f, 0.08822921f, -0.03579048f, -0.00895214f, 0.11384281f, 
    0.13119026f, 0.06714644f, -0.03658360f, 0.10252187f, 0.03785392f, 0.08454909f, -0.10809488f, 0.00319225f, 
    0.07326133f, 0.13743633f, 0.15898137f, 0.04354031f, -0.16161403f, -0.26266947f, -0.05596603f, -0.01224697f, 
    0.02131069f, 0.05365226f, 0.13304505f, -0.19581978f, 0.00402626f, 0.02298360f, 0.10727920f, -0.05596250f, 
    0.14550379f, 0.13039559f, 0.15161680f, -0.05134375f, -0.12095135f, 0.10279105f, 0.02997747f, 0.03306967f, 
    0.01069946f, -0.04467993f, 0.03249703f, 0.10666826f, 0.10092696f, -0.04441899f, 0.07117215f, 0.05607497f, 
    0.03520130f, 0.02893688f, -0.01700751f, -0.01986924f, 0.13911302f, 0.07858340f, 0.05699760f, 0.00004103f, 
    -0.00618520f, 0.01559569f, 0.02822871f, 0.20842472f, 0.06125733f, 0.05431922f, -0.02438326f, 0.09039155f, 
    0.03269877f, 0.04932297f, 0.16919474f, 0.11123653f, 0.08576047f, 0.08612785f, 0.02798455f, 0.15139040f, 
    -0.02521928f, -0.00425082f, 0.05324350f, -0.01884079f, -0.00534822f, 0.04521638f, -0.01181985f, -0.07263670f, 
    0.18321058f, -0.08937626f, -0.03346410f, 0.07204688f, 0.02648094f, -0.05337388f, 0.11170787f, 0.07159765f, 
    0.06318355f, 0.01333706f, -0.08022530f, 0.01298889f, 0.35631633f, 0.06089732f, 0.06247855f, 0.08682104f, 
    0.05765431f, -0.04765420f, 0.08238778f, 0.03785846f, 0.07863599f, 0.04897737f, -0.03271051f, 0.13646930f, 
    -0.03623356f, 0.00330402f, -0.12799948f, -0.11259045f, 0.01862298f, 0.01599546f, 0.05847738f, 0.10687280f, 
    0.09067047f, -0.03110697f, -0.01165618f, 0.04493095f, -0.12875997f, -0.11179635f, 0.17806226f, 0.32773361f, 
    -0.02670443f, -0.00467581f, 0.02249805f, 0.05060030f, 0.00199666f, 0.08995821f, -0.09280074f, -0.01612199f, 
    -0.14708224f, -0.11520533f, -0.14071925f, -0.05126683f, -0.08309872f, -0.03765363f, -0.05943397f, -0.02281166f, 
    0.00092366f, 0.04212269f, -0.18702704f, 0.04433985f, -0.15427101f, 0.18811359f, 0.22809525f, 0.07784449f, 
    0.05419606f, -0.00999602f, 0.03473384f, -0.00900087f, 0.06242738f, 0.03628767f, -0.00446094f, 0.08803437f, 
    0.18577839f, 0.14006628f, 0.18168022f, 0.24814276f, 0.03012305f, -0.12095882f, 0.03074606f, 0.10552166f, 
    -0.03383020f, 0.08900412f, 0.02083636f, 0.08604163f, -0.11629280f, -0.09371420f, -0.11301234f, -0.18555661f, 
    -0.14895353f, -0.02439909f, 0.05438200f, 0.07550240f, -0.15279639f, -0.08276295f, 0.03144522f, 0.08124520f, 
    -0.02386974f, -0.03518553f, -0.04008154f, 0.02682713f, 0.02664018f, -0.04069258f, -0.02942156f, 0.02038779f, 
    -0.01754403f, -0.02684898f, 0.02121996f, 0.01503981f, -0.00920499f, 0.02900625f, 0.02539332f, -0.03764594f, 
    -0.03173823f, -0.03532762f, -0.01308004f, 0.02223145f, -0.00636286f, 0.00207024f, 0.01502235f, 0.00596075f, 
    -0.03389423f, -0.02973361f, -0.00180389f, -0.02608695f, -0.02110804f, 0.02092171f, -0.00518871f, -0.03336183f, 
    -0.00589462f, 0.01419713f, -0.03860139f, 0.02625612f, 0.01130013f, -0.02364135f, -0.03179339f, 0.01860114f, 
    -0.01394046f, 0.00908652f, 0.01139232f, 0.01900594f, -0.04172527f, 0.02959505f, -0.03380483f, -0.02676809f, 
    -0.00524572f, 0.02468012f, -0.03833225f, -0.00420615f, -0.01786621f, -0.02961368f, 0.02614316f, 0.00416689f, 
    0.01258265f, -0.01577188f, 0.00033273f, 0.02819688f, 0.02002647f, 0.02579758f, -0.00354128f, 0.02025794f, 
    0.02728180f, -0.00607231f, 0.01744406f, 0.01186678f, -0.02979821f, 0.02610439f, 0.00464045f, -0.03887473f, 
    -0.01133478f, -0.02162394f, 0.02524011f, -0.04072291f, -0.00406097f, 0.00865335f, 0.00726718f, -0.03657026f, 
    0.01557994f, -0.03862023f, -0.03578803f, 0.00965664f, -0.03092620f, 0.02108688f, -0.00437246f, -0.01516229f, 
    0.00739804f, 0.01974818f, -0.03220273f, 0.02251096f, 0.01074746f, 0.00510090f, 0.01744555f, -0.00343430f, 
    -0.00611870f, 0.00547043f, -0.03983938f, 0.01614989f, -0.00613116f, 0.00809976f, 0.02223392f, -0.02903524f, 
    -0.00797164f, -0.02478798f, 0.02140596f, 0.00941026f, 0.02537526f, 0.00910167f, 0.02863697f, 0.01720096f, 
    -0.04165948f, -0.00581351f, -0.00527303f, -0.03475327f, 0.00808594f, -0.00435665f, -0.02137574f, -0.00044878f, 
    0.00338340f, 0.00189304f, 0.00529660f, -0.03286291f, 0.01712796f, 0.00223296f, 0.00335422f, -0.01153004f, 
    -0.01522214f, 0.00068714f, -0.01365902f, -0.02552698f, 0.00181271f, -0.00004436f, -0.03683543f, -0.03919780f, 
    0.01402217f, -0.02912595f, -0.02663132f, 0.00052127f, -0.04146864f, -0.03325870f, 0.01276727f, 0.02360223f, 
    0.01542850f, -0.00272682f, 0.02515044f, -0.03478955f, -0.02969637f, 0.00398690f, -0.03505858f, -0.02866036f, 
    0.01799940f, -0.03476144f, 0.02880896f, -0.04022474f, -0.01035679f, 0.02597194f, 0.01446104f, -0.02799072f, 
    0.01290841f, -0.03836427f, -0.03511192f, 0.02629231f, 0.02248694f, -0.02659445f, -0.03849566f, 0.02020524f, 
    -0.02516468f, 0.03232649f, -0.01219206f, -0.01653649f, 0.01925576f, -0.00965123f, -0.00678807f, 0.02935584f, 
    -0.04176437f, -0.03787095f, 0.00860012f, -0.04040153f, 0.01750048f, -0.02839630f, -0.03765306f, 0.00599661f, 
    -0.01657716f, -0.03304034f, -0.04206563f, 0.02216770f, -0.00768586f, 0.01534781f, -0.04165525f, -0.01258774f, 
    -0.03974332f, 0.01082422f, -0.00667311f, -0.01588725f, -0.02268235f, 0.02884721f, 0.00071386f, 0.00163955f, 
    0.02220191f, 0.02870088f, -0.00230482f, -0.01994295f, 0.00012398f, -0.04149489f, 0.00199312f, -0.03048838f, 
    0.01643975f, -0.00252426f, -0.01115532f, -0.00497122f, -0.02277317f, -0.01369771f, -0.01418145f, -0.03827326f, 
    0.00734436f, -0.00970718f, -0.03475926f, -0.03785935f, 0.01797461f, -0.01524625f, -0.03437541f, -0.02375752f, 
    -0.02608178f, 0.00918040f, 0.02703036f, -0.00166888f, -0.03933980f, -0.01530829f, -0.03882525f, 0.02019524f, 
    -0.03215349f, -0.03447495f, -0.03356029f, -0.02074906f, -0.00172787f, 0.00289355f, 0.01848488f, -0.00245669f, 
    -0.00976933f, -0.04028756f, -0.03926754f, -0.01811710f, 0.01928345f, -0.03708867f, 0.01755938f, -0.03647837f, 
    -0.02319366f, -0.04013738f, -0.03327172f, 0.02014980f, -0.00191059f, -0.03609630f, 0.02223029f, -0.01360811f, 
    -0.01581764f, -0.02091689f, -0.03906883f, -0.02386025f, -0.01978046f, -0.02822839f, -0.02386905f, 0.02064330f, 
    0.02548302f, 0.01988132f, 0.02348443f, -0.00297407f, 0.00075998f, -0.02940116f, -0.00465789f, 0.02651591f, 
    -0.02905041f, -0.02441839f, -0.02511907f, -0.03675522f, 0.00805746f, -0.03337827f, 0.00961800f, 0.01546460f, 
    0.00139495f, 0.00989295f, 0.00474419f, 0.01122709f, 0.00299572f, -0.00083714f, -0.03118704f, 0.02235370f, 
    -0.00051709f, -0.00489544f, -0.03232279f, 0.01407916f, -0.03289291f, -0.02854748f, -0.01242191f, 0.02321465f, 
    0.01682402f, 0.02876042f, -0.00391167f, 0.01612679f, 0.00418872f, 0.00735328f, 0.00664798f, -0.03702909f, 
    -0.01085942f, -0.03548468f, -0.03295675f, -0.03989408f, 0.01861484f, 0.03346863f, 0.01807870f, -0.00131655f, 
    0.02405141f, -0.02396964f, 0.02423611f, -0.03489067f, -0.01374865f, 0.00603168f, -0.03733495f, 0.02082065f, 
    0.01534337f, 0.02636414f, -0.02970546f, -0.00665093f, -0.02657238f, 0.02958309f, -0.01184644f, -0.01268301f, 
    -0.03835554f, -0.02578006f, -0.00435375f, 0.00087357f, 0.02324913f, 0.02885423f, 0.00035662f, 0.02694058f, 
    -0.03702873f, 0.01760413f, -0.01666013f, -0.01902999f, 0.00410779f, -0.02056219f, 0.00085525f, 0.00045033f, 
    -0.01772879f, -0.02423324f, -0.02371089f, -0.03442256f, 0.00173022f, 0.00903572f, -0.00241708f, -0.00484147f, 
    0.00299949f, -0.01170720f, 0.00515247f, -0.01325382f, 0.02821850f, 0.02469539f, 0.02164469f, 0.00039242f, 
    -0.01097079f, 0.01163267f, -0.02671062f, 0.02176652f, 0.00606127f, -0.01632689f, 0.00249676f, -0.00350172f, 
    0.01402227f, -0.00994900f, 0.02745906f, -0.04143897f, -0.04137561f, 0.02885047f, -0.03272122f, 0.01594143f, 
    -0.04141328f, -0.03285783f, 0.00071283f, 0.02784176f, -0.02041382f, -0.02326863f, 0.02116391f, -0.01171629f, 
    -0.02245841f, -0.01420138f, -0.02097852f, -0.03354207f, 0.00724877f, 0.03425835f, -0.02984689f, 0.00125816f, 
    -0.02219624f, -0.03664624f, -0.01212158f, 0.02082286f, -0.03365280f, 0.01264263f, 0.02114857f, -0.04050454f, 
    -0.02152512f, 0.01416617f, -0.02752182f, 0.01452984f, -0.00599907f, -0.02794421f, -0.00500581f, 0.03194271f, 
    -0.02583458f, 0.01129138f, 0.00638868f, -0.00232111f, 0.01530825f, 0.01123169f, -0.03065237f, 0.00638485f, 
    -0.03775102f, 0.00049647f, 0.02013609f, -0.03961951f, 0.02890912f, -0.03014530f, -0.01494393f, 0.02147285f, 
    -0.03710435f, 0.02566067f, -0.01300425f, 0.00734580f, -0.00441766f, -0.02048635f, -0.01968417f, -0.02011242f, 
    0.00258213f, 0.00644637f, -0.02215389f, -0.01500340f, -0.02072785f, 0.03171892f, -0.01588298f, 0.02708927f, 
    0.02767617f, 0.01383645f, -0.03245962f, -0.02146066f, 0.00462002f, 0.00562577f, 0.02322600f, 0.00308300f, 
    -0.03325363f, 0.02637373f, -0.03014448f, -0.03649325f, 0.01009593f, -0.01736611f, 0.02779362f, -0.03459187f, 
    0.00434281f, -0.00645437f, -0.02910814f, -0.01030312f, 0.02181176f, -0.00422492f, -0.03387549f, -0.04187560f, 
    -0.01609295f, -0.01802853f, -0.04204167f, -0.04113151f, -0.02727025f, -0.02231140f, 0.00712010f, -0.00423126f, 
    -0.00361858f, 0.00958569f, 0.01400841f, 0.01949774f, -0.03785542f, -0.02243188f, -0.01673586f, -0.00880774f, 
    -0.00192225f, -0.01495189f, -0.00162521f, -0.00379997f, 0.02741124f, -0.01855257f, -0.02812147f, 0.02074589f, 
    0.01497491f, 0.01330883f, -0.00050828f, -0.00219854f, -0.02289150f, 0.00606993f, -0.03872501f, -0.00215124f, 
    -0.02099113f, -0.02630067f, 0.01834722f, 0.02347150f, 0.01875824f, 0.01905724f, 0.01737290f, -0.03380943f, 
    -0.00534023f, -0.03049636f, -0.01662552f, -0.01381084f, -0.03550642f, 0.01784095f, 0.02504657f, -0.00600111f, 
    -0.03186456f, -0.01648972f, 0.02423961f, 0.00312073f, -0.01704667f, -0.00149489f, 0.01886011f, -0.01827739f, 
    0.00282828f, -0.01196760f, -0.01515769f, -0.02577475f, 0.02828737f, -0.00138602f, -0.02871769f, -0.01678994f, 
    -0.02631182f, -0.01102570f, -0.03321379f, -0.01559584f, -0.02792868f, -0.01939596f, 0.00791984f, -0.02814481f, 
    -0.03277278f, 0.01629662f, 0.01963075f, 0.00872379f, -0.00567602f, -0.01009431f, -0.02885747f, -0.01349787f, 
    0.01418610f, 0.02710034f, -0.03165126f, -0.00452140f, -0.00771086f, 0.00779709f, -0.02758693f, 0.00734185f, 
    -0.00677052f, -0.02175459f, -0.00240319f, -0.01875746f, 0.02396256f, -0.00713393f, -0.01211924f, -0.02623411f, 
    -0.03161854f, -0.02842565f, -0.01231811f, -0.02330190f, -0.02955151f, 0.00601739f, 0.01562032f, 0.00585583f, 
    0.02662824f, -0.00235391f, 0.03547455f, 0.02602586f, 0.02798763f, 0.02928772f, -0.01670059f, 0.02252029f, 
    0.01889619f, -0.02467424f, 0.02211967f, 0.00945851f, -0.03347807f, 0.02969719f, 0.02756516f, 0.02538077f, 
    -0.00917013f, 0.02356825f, -0.00261224f, -0.01479430f, 0.00681962f, -0.01103344f, -0.00800538f, -0.04000222f, 
    -0.02140670f, 0.02835701f, -0.03124038f, 0.00476935f, -0.03415722f, -0.03572681f, -0.01362301f, -0.00214417f, 
    -0.00915551f, -0.01010452f, -0.00016488f, -0.04126371f, -0.00882822f, -0.00131848f, 0.01830401f, -0.00895004f, 
    -0.00463125f, 0.00507868f, -0.03353317f, 0.01549104f, -0.00361349f, -0.03293841f, 0.00180206f, -0.03811368f, 
    0.00678975f, 0.00168020f, -0.02814825f, -0.04074228f, 0.02129526f, 0.01868431f, -0.03382927f, -0.03807374f, 
    0.02365614f, -0.03593550f, -0.03029980f, -0.03677719f, -0.01640105f, -0.00802394f, -0.00600311f, 0.01556423f, 
    -0.01669844f, 0.01905620f, -0.00491422f, -0.03113344f, -0.00151334f, 0.02070647f, 0.00975821f, 0.02227777f, 
    -0.01859486f, -0.03257391f, -0.03500750f, -0.02681340f, -0.02318631f, -0.00700068f, -0.01969360f, 0.01198964f, 
    0.02919646f, 0.00173937f, -0.01171287f, 0.02440257f, -0.01469789f, -0.01355855f, 0.02121776f, -0.03039761f, 
    -0.00185732f, 0.03003445f, -0.01193915f, -0.01945081f, -0.03802926f, -0.02401795f, -0.02177805f, 0.01853939f, 
    0.02305712f, -0.01728869f, -0.02448631f, 0.01023701f, 0.00818156f, -0.02214327f, 0.00333570f, -0.03750695f, 
    -0.03394303f, 0.00696293f, -0.03669919f, 0.01281343f, 0.01760839f, -0.02131229f, -0.03253153f, -0.02257992f, 
    -0.04192424f, -0.03982933f, 0.01094597f, -0.03689048f, -0.00464679f, 0.02795567f, 0.02154201f, -0.03534393f, 
    0.01940832f, -0.03063780f, 0.01482742f, 0.00835528f, 0.00461690f, -0.01559118f, 0.00189382f, 0.02913573f, 
    0.01045091f, -0.02100701f, 0.02771397f, 0.00406254f, -0.04037163f, -0.01624681f, -0.01453320f, -0.03934391f, 
    0.02104497f, -0.02789872f, -0.01341337f, -0.03579269f, 0.02256892f, -0.03126814f, 0.01818161f, -0.00731588f, 
    -0.01251709f, 0.01687155f, -0.03808265f, 0.02208436f, 0.00205306f, -0.01589552f, 0.01176281f, -0.02774997f, 
    0.00236310f, -0.03311040f, -0.03338693f, -0.01705649f, -0.00223559f, 0.01288603f, 0.00599119f, -0.03383188f, 
    0.02692003f, 0.01540019f, -0.01233814f, 0.00254796f, -0.00049344f, -0.02743673f, 0.01898921f, 0.01889830f, 
    0.02687479f, -0.02415861f, 0.02407600f, -0.00824186f, 0.00883719f, 0.00994461f, -0.02988084f, -0.03426528f, 
    0.02080523f, 0.01780123f, -0.03639010f, -0.02246343f, 0.01042693f, 0.02174889f, 0.01570573f, 0.01128289f, 
    0.00317806f, -0.01094688f, -0.03751907f, -0.00242603f, 0.02217103f, -0.02469868f, 0.01100873f, 0.00478512f, 
    -0.00872339f, -0.00883558f, -0.00512403f, -0.02971891f, -0.01645540f, -0.03324607f, -0.02071405f, 0.00955953f, 
    0.12055514f, -0.11392660f, 0.06594267f, -0.10302240f, -0.09744382f, 0.00292945f, 0.04342556f, -0.06804899f, 
    0.07136202f, 0.04082868f, 0.09659271f, -0.03369341f, 0.06689691f, 0.12441227f, 0.19348763f, 0.12474734f, 
    -0.08944882f, -0.00094187f, -0.00504484f, 0.01174632f, -0.02114316f, 0.04083806f, 0.03574407f, 0.14143671f, 
    -0.20748967f, -0.00119295f, -0.01056366f, 0.12162030f, 0.10494230f, 0.06320002f, 0.05934520f, -0.02193045f, 
    -0.06199068f, -0.02520525f, 0.04567915f, -0.04335591f, 0.02696161f, 0.01152699f, 0.13754277f, -0.00041451f, 
    -0.01034271f, 0.02206245f, -0.00840361f, -0.03137705f, 0.02339884f, 0.12905253f, 0.00461513f, 0.08294512f, 
    -0.01786467f, 0.03284414f, 0.03132613f, -0.07992668f, -0.06162670f, 0.07674900f, -0.07969449f, -0.08543397f, 
    -0.02887744f, 0.00427833f, 0.03906211f, -0.05931648f, 0.11406932f, 0.12407444f, 0.19287586f, 0.11415275f, 
    -0.17856701f, -0.10433194f, -0.00059402f, -0.09982061f, -0.03137190f, 0.00802953f, 0.07185702f, -0.01305269f, 
    -0.31599590f, 0.03585496f, -0.07550847f, -0.01964095f, 0.01187540f, 0.00656291f, -0.05897537f, -0.04280395f, 
    0.04200367f, -0.05000747f, 0.11381102f, -0.05572195f, 0.14210166f, 0.00100302f, 0.09019655f, 0.16519623f, 
    -0.12056202f, 0.14390667f, -0.00201285f, 0.03940159f, -0.01383810f, 0.03552092f, -0.02403594f, -0.01834608f, 
    0.02965002f, 0.30746225f, 0.05577726f, 0.04555654f, 0.09146097f, -0.05181918f, 0.01287378f, 0.04072887f, 
    0.01142113f, -0.00508003f, -0.00637330f, -0.05809641f, 0.36890259f, -0.08587275f, -0.09899085f, -0.05262306f, 
    -0.10755863f, 0.07522682f, 0.07580531f, 0.00383848f, -0.04601358f, -0.04556252f, 0.06929662f, 0.00627385f, 
    0.05563279f, 0.14576484f, 0.11987937f, 0.00582580f, 0.18547890f, 0.04513615f, 0.05495813f, -0.01098032f, 
    -0.07955843f, -0.03706532f, -0.01077483f, 0.14317791f, 0.07930388f, 0.05240435f, 0.07080391f, 0.11215658f, 
    0.00344921f, 0.17737503f, 0.01412013f, -0.00053417f, 0.03018317f, 0.12061337f, 0.11958162f, -0.03122436f, 
    -0.03823750f, -0.08722880f, 0.11432227f, 0.09175452f, 0.05847497f, 0.13926458f, -0.03130713f, -0.05461018f, 
    -0.06352235f, -0.06681579f, 0.01745860f, -0.10777378f, 0.11873645f, 0.04144181f, 0.14243606f, 0.09281167f, 
    -0.11770777f, -0.09109987f, -0.05289539f, -0.07045671f, 0.01521789f, -0.06104080f, 0.03560825f, -0.00054002f, 
    0.07688545f, 0.11759424f, 0.14868952f, -0.02599338f, 0.01651561f, -0.08780345f, -0.06037991f, -0.04163896f, 
    0.02477832f, 0.03393813f, 0.04936145f, 0.04146299f, -0.13126335f, -0.13997546f, -0.01839748f, 0.14130491f, 
    0.08798676f, 0.13697699f, 0.07810917f, -0.02109555f, -0.03330863f, 0.04546741f, 0.00822193f, 0.00498410f, 
    -0.28600186f, -0.11697154f, -0.14498426f, 0.20427848f, 0.07196087f, 0.03700767f, 0.02035896f, 0.00517071f, 
    -0.06456837f, -0.08140396f, 0.02049930f, -0.00151910f, 0.07511104f, 0.32904884f, -0.07834392f, 0.03901785f, 
    -0.05348626f, -0.06520873f, 0.00564910f, 0.03479947f, -0.04765722f, -0.00128098f, 0.01236693f, 0.02561373f, 
    -0.10415829f, 0.01549467f, -0.08157127f, -0.02567943f, 0.01662467f, 0.03918713f, 0.01634221f, -0.14435321f, 
    -0.03747129f, -0.00903008f, -0.04346862f, 0.00360990f, 0.07019655f, 0.14618573f, -0.01429429f, 0.05009381f, 
    -0.13613202f, 0.06470335f, 0.07590966f, 0.07981170f, -0.02919632f, 0.01077684f, -0.06255732f, -0.12125000f, 
    0.09783537f, 0.25928113f, -0.02964149f, 0.03308357f, -0.06720138f, -0.15626568f, -0.02731459f, 0.03333319f, 
    0.01088773f, -0.00023846f, 0.07339330f, 0.08015244f, -0.23146400f, -0.22317238f, -0.03823118f, 0.00110964f, 
    0.00433500f, 0.01721934f, -0.02065827f, -0.04574537f, 0.07089408f, -0.04723660f, -0.01270247f, 0.06149415f, 
    -0.30823347f, -0.11018617f, 0.15102154f, 0.15629564f, 0.03674564f, 0.00211303f, 0.06850775f, 0.05692006f, 
    -0.14735734f, -0.10171066f, 0.00307371f, -0.03423426f, 0.40923700f, 0.24855162f, -0.13943653f, -0.14602733f, 
    0.10000970f, 0.06435967f, 0.00623571f, 0.04507431f, 0.02449204f, -0.02099751f, 0.01977665f, -0.04229322f, 
    0.12946340f, -0.04074475f, -0.04834478f, -0.13851717f, -0.09223756f, 0.05886390f, -0.02280209f, 0.05007919f, 
    -0.03507264f, 0.01997449f, -0.08866457f, 0.08590962f, 0.01622774f, 0.13536754f, -0.06955551f, 0.02408210f, 
    -0.19787900f, 0.04183415f, -0.03582608f, 0.04826461f, 0.00822717f, 0.02201275f, 0.03352033f, 0.03502218f, 
    -0.28321606f, 0.00951833f, -0.01455504f, 0.11547417f, -0.07373276f, 0.10623322f, -0.04978666f, -0.02027848f, 
    -0.00766418f, 0.03673733f, 0.00820491f, -0.03331960f, 0.05420521f, 0.33918193f, -0.00604279f, -0.18118016f, 
    0.20831119f, -0.12317344f, 0.00659027f, 0.00643454f, 0.00004952f, -0.03164419f, -0.05106976f, -0.04445951f, 
    -0.31622985f, 0.00638967f, -0.06826169f, -0.02106274f, -0.06160337f, 0.01199781f, 0.05955559f, -0.00127951f, 
    -0.04359880f, 0.01097534f, -0.06008960f, 0.02571491f, -0.01488724f, -0.15763696f, 0.08975080f, 0.01753120f, 
    -0.09469646f, 0.00968570f, 0.00047792f, 0.02642672f, -0.01150666f, 0.02390785f, 0.00456923f, 0.00868981f, 
    0.03089442f, -0.00548249f, 0.08323975f, -0.14194791f, -0.05361909f, 0.04734889f, 0.00227753f, 0.08604012f, 
    -0.05292483f, 0.06350757f, 0.05977556f, 0.05470857f, 0.19671442f, -0.00747291f, 0.08903036f, 0.11769165f, 
    0.00405758f, 0.04650204f, -0.06237432f, -0.10210767f, -0.04688781f, -0.03906159f, -0.07082490f, -0.00131751f, 
    0.09575772f, 0.11364909f, 0.16392198f, 0.06949858f, 0.18139532f, 0.03081400f, -0.03985346f, 0.06082589f, 
    0.01694452f, 0.07016724f, -0.10705826f, 0.01117139f, -0.02704186f, 0.00609782f, -0.09814598f, -0.02652358f, 
    -0.02308635f, 0.01550653f, -0.01549105f, -0.00453564f, -0.11611349f, 0.03660699f, 0.02214786f, -0.01848615f, 
    0.57232398f, -0.03704406f, 0.13817224f, -0.13689469f, -0.14932117f, 0.08657297f, -0.08722921f, 0.06301446f, 
    0.05643538f, 0.10667602f, -0.08362004f, 0.02564123f, -0.27054134f, 0.09042439f, 0.02751413f, 0.02775602f, 
    -0.01916524f, 0.06807180f, -0.01074952f, 0.04258868f, 0.03398421f, 0.02983076f, 0.05738924f, -0.07486899f, 
    0.14849584f, 0.07428481f, 0.26377183f, 0.15656498f, -0.03542068f, 0.00656671f, -0.11398500f, -0.07122036f, 
    -0.05783999f, -0.01885127f, -0.09023655f, 0.02790664f, 0.15343039f, 0.07605437f, 0.12493976f, -0.11226338f, 
    0.04202463f, 0.00748906f, -0.16149998f, -0.03002379f, 0.02328583f, 0.07162458f, 0.02197404f, -0.01974833f, 
    0.47922641f, -0.19728874f, 0.09817097f, -0.04124052f, -0.12970811f, -0.07538716f, 0.09660245f, 0.09852119f, 
    0.06652474f, 0.09960707f, 0.04678531f, 0.10109873f, 0.11924437f, -0.02937953f, 0.08674901f, 0.07584235f, 
    -0.02309723f, 0.02529306f, -0.06592315f, -0.02905634f, -0.07729360f, 0.00505368f, -0.02613413f, -0.07337909f, 
    0.29942650f, 0.32019311f, 0.08548383f, 0.13518059f, 0.17937899f, -0.05163547f, 0.03480263f, 0.13179137f, 
    -0.03093684f, 0.03763332f, 0.02784888f, -0.06094917f, -0.22853605f, 0.01086914f, -0.03970943f, -0.14746080f, 
    0.06650103f, -0.01421911f, 0.08144958f, -0.00698677f, 0.07464004f, 0.04993657f, -0.03087801f, -0.12534942f, 
    -0.06760982f, -0.02780456f, -0.05566302f, 0.07535180f, -0.10699864f, 0.05478829f, -0.02345375f, -0.07993967f, 
    0.01807401f, -0.04071235f, 0.02999204f, -0.04319515f, 0.09128761f, 0.10377662f, 0.18004510f, 0.12922627f, 
    -0.07525406f, 0.00544652f, 0.03058378f, -0.01494243f, 0.01289085f, -0.01339090f, -0.02469638f, 0.03835302f, 
    0.02597582f, 0.15182246f, -0.10055277f, 0.04973687f, 0.10916835f, -0.02929161f, -0.09317788f, 0.18782249f, 
    0.03786291f, 0.07184393f, 0.10508393f, 0.00341529f, 0.07047953f, 0.11773830f, -0.15353860f, 0.17413928f, 
    -0.10688754f, 0.04817588f, 0.04671310f, -0.05721354f, -0.02356707f, 0.03905279f, -0.01298569f, 0.02902062f, 
    0.18449457f, -0.02542089f, -0.04677581f, 0.01166282f, 0.05576834f, 0.02524897f, -0.00650284f, 0.05887685f, 
    -0.03504338f, -0.02342022f, 0.05645643f, -0.08496613f, 0.07226907f, -0.10561049f, 0.09802899f, 0.08822145f, 
    -0.03485109f, 0.10703582f, -0.04894874f, -0.14161927f, -0.06527708f, -0.00625438f, -0.04993739f, -0.02681544f, 
    -0.22368148f, 0.09391793f, 0.03413837f, 0.01824881f, 0.01676393f, 0.06795529f, 0.09825857f, -0.01861487f, 
    -0.06500693f, 0.00728907f, -0.01062047f, -0.00857929f, -0.29825035f, -0.10731362f, -0.11674274f, -0.02596455f, 
    0.11484598f, -0.03763051f, 0.05868661f, 0.07703505f, -0.05730356f, -0.04941174f, -0.00570271f, -0.04018037f, 
    -0.07608737f, -0.10586696f, 0.06852653f, -0.03097070f, 0.06336202f, 0.01102797f, 0.04937670f, -0.00286929f, 
    0.01653253f, 0.02377493f, 0.03201458f, 0.05938992f, -0.07298365f, -0.00127470f, -0.09269910f, 0.07693641f, 
    0.00284782f, 0.05053046f, 0.06030468f, 0.04738410f, 0.05124889f, 0.06470153f, 0.01472203f, -0.02573274f, 
    -0.12608297f, 0.04823991f, 0.09392197f, 0.14631423f, -0.02644630f, -0.01853053f, 0.01029433f, -0.01656436f, 
    -0.02957542f, 0.03457708f, -0.07811966f, -0.00686617f, 0.01676808f, -0.12425976f, -0.13932762f, -0.14614189f, 
    -0.10283135f, -0.04541808f, 0.02952729f, 0.03964661f, -0.06471980f, 0.06372106f, 0.13453703f, -0.03146719f, 
    -0.03145936f, 0.12960231f, 0.10239639f, 0.05805575f, -0.01052303f, 0.01729816f, -0.02443836f, 0.06829268f, 
    -0.10488963f, -0.11389019f, 0.10369016f, 0.00963345f, -0.08743089f, 0.23517190f, 0.01262968f, -0.02460700f, 
    0.00381591f, -0.06004687f, -0.08835936f, -0.02373064f, 0.02649887f, -0.03192230f, 0.03873020f, -0.01291976f, 
    0.06190921f, -0.10961550f, 0.02161368f, -0.12318046f, -0.02732310f, 0.06035325f, 0.00183276f, -0.06869214f, 
    0.00479553f, -0.07086886f, 0.00441588f, 0.03002834f, -0.01125811f, 0.06811892f, 0.03293622f, -0.01404522f, 
    -0.08549420f, -0.03466591f, -0.01280035f, -0.00122397f, 0.05490965f, -0.00149736f, 0.10536514f, 0.07269971f, 
    0.08352100f, 0.08475900f, 0.08004213f, 0.11355909f, -0.06999817f, -0.06673021f, 0.02468147f, 0.09378210f, 
    -0.01837316f, -0.02653857f, -0.03913297f, -0.03762042f, -0.05191978f, -0.14825866f, -0.02481601f, 0.03998219f, 
    -0.04501582f, 0.07804266f, 0.02680704f, -0.01891390f, -0.13514723f, -0.05155468f, -0.07037041f, 0.02985763f, 
    0.19772466f, 0.00260016f, 0.08767404f, 0.01731110f, -0.08971127f, -0.07844306f, 0.04392704f, -0.06639931f, 
    0.08648268f, -0.00259939f, 0.05332133f, 0.11901277f, -0.26934516f, -0.10697141f, -0.06252207f, 0.11402000f, 
    0.08610377f, 0.00852893f, -0.00616472f, -0.00586361f, 0.03009251f, 0.00004044f, 0.02751507f, -0.07040185f, 
    -0.22647373f, -0.11380541f, 0.02786244f, 0.00392632f, 0.05539537f, 0.02270437f, 0.00394298f, -0.01661037f, 
    -0.05081705f, 0.01534360f, -0.04055111f, 0.01051744f, 0.17205518f, -0.13391031f, -0.00483282f, -0.06206278f, 
    -0.05558812f, -0.02397989f, 0.13849166f, 0.11247750f, 0.06415987f, -0.02898637f, 0.00444716f, 0.09375836f, 
    -0.00806487f, -0.01705597f, 0.00702638f, 0.00301715f, 0.02230035f, -0.02488193f, -0.02586291f, -0.01809496f, 
    -0.02053171f, -0.04041960f, 0.02086204f, -0.03120700f, 0.00413580f, -0.02440979f, -0.04128626f, -0.01410960f, 
    -0.01920459f, 0.00311676f, -0.00059148f, 0.02797647f, 0.02395250f, 0.01423386f, 0.02588712f, 0.01050460f, 
    0.01711167f, 0.00542716f, -0.04171833f, -0.00432362f, -0.04032919f, 0.01180565f, -0.02460061f, -0.03880947f, 
    0.02400554f, -0.01116261f, 0.01920325f, -0.02074620f, -0.02814820f, -0.00059063f, -0.01997218f, -0.00444718f, 
    -0.03374812f, 0.02628121f, -0.04199227f, -0.02668624f, 0.01933585f, -0.00393514f, -0.00409026f, 0.01622790f, 
    -0.00507328f, 0.01682549f, 0.01779691f, -0.03191030f, -0.01223119f, -0.03673431f, 0.00195373f, -0.00707646f, 
    -0.04152058f, 0.02485960f, 0.01978488f, -0.01362280f, -0.02725862f, 0.02711746f, -0.04046796f, 0.02243783f, 
    -0.02150983f, -0.01747188f, 0.02539253f, 0.01965642f, -0.02002870f, 0.01694478f, -0.03113442f, 0.02986884f, 
    0.01835754f, 0.00445499f, 0.02417447f, -0.03451509f, -0.01771525f, -0.00504685f, 0.00155070f, -0.03670115f, 
    -0.02415579f, -0.00207723f, -0.02909070f, -0.04290218f, -0.03596192f, -0.02407533f, 0.00446955f, -0.00462618f, 
    -0.03333392f, -0.02394561f, -0.02691016f, -0.04202912f, 0.02476125f, 0.02125452f, 0.00179077f, -0.02910005f, 
    0.00621848f, -0.03470111f, -0.01898265f, -0.00396646f, 0.00470764f, 0.02504948f, -0.01025027f, -0.00580794f, 
    0.02384938f, 0.01378108f, -0.02719783f, -0.00045389f, -0.01982284f, -0.02523097f, -0.04013932f, 0.00365533f, 
    -0.00892602f, -0.00015530f, 0.00674494f, 0.01704437f, 0.01500022f, -0.01197520f, -0.02594427f, 0.00615793f, 
    -0.01008418f, -0.02416775f, 0.02852368f, 0.01896388f, -0.01701357f, -0.01389457f, 0.00101171f, 0.02538276f, 
    -0.02559516f, 0.02241076f, -0.01788430f, 0.00223882f, 0.01577432f, -0.01855240f, 0.00915491f, -0.04330862f, 
    -0.03477697f, -0.03543391f, -0.00426241f, 0.00593241f, -0.00350355f, -0.04259764f, -0.01497245f, 0.01946975f, 
    -0.03331548f, -0.03451450f, -0.02216088f, -0.01931435f, 0.01185427f, -0.04262083f, -0.03178275f, -0.03308278f, 
    -0.03682453f, -0.03441348f, -0.01775124f, -0.04151079f, 0.00155230f, -0.04000837f, 0.03860437f, -0.02336599f, 
    0.00933198f, -0.03814516f, -0.01280212f, 0.00926450f, -0.01381798f, -0.03150910f, -0.03941094f, 0.00834699f, 
    -0.02090660f, -0.03342014f, -0.03186290f, -0.01978542f, 0.01959477f, -0.01827485f, -0.02773281f, 0.01087960f, 
    0.02251835f, 0.00420811f, -0.04296656f, 0.02758236f, 0.02723552f, -0.00364375f, -0.04138341f, -0.02977532f, 
    -0.00203410f, -0.03481353f, 0.00728206f, 0.00135348f, -0.04019334f, 0.02222858f, -0.03066217f, 0.00110917f, 
    -0.01458933f, 0.00458205f, -0.02829364f, -0.03994298f, 0.00119602f, 0.02728572f, 0.00923451f, -0.00081353f, 
    0.01577295f, -0.02927870f, -0.01134877f, 0.03053967f, 0.01388022f, 0.03500695f, 0.00408079f, 0.00695240f, 
    -0.04088035f, 0.02466416f, -0.01567001f, -0.02343835f, 0.00458216f, 0.02152933f, 0.00858665f, -0.02007250f, 
    -0.02415816f, -0.03499004f, 0.00707491f, 0.00619925f, -0.01294945f, -0.04261751f, -0.03992624f, -0.03655539f, 
    -0.03802203f, -0.02152238f, -0.03545355f, -0.02172250f, -0.01309276f, -0.02029191f, -0.03204517f, -0.01884130f, 
    0.01929837f, -0.01826315f, -0.01616482f, -0.00642419f, 0.02352276f, -0.03729925f, 0.00204829f, -0.02678022f, 
    0.02428597f, 0.01506831f, 0.01023374f, 0.00225751f, 0.00351728f, 0.02637476f, -0.00226689f, -0.03388994f, 
    -0.03332404f, -0.01260385f, -0.02028274f, -0.01004350f, -0.03184753f, -0.02866665f, -0.02510256f, 0.01167758f, 
    0.02115033f, -0.02970406f, 0.02448416f, -0.03130211f, -0.02806024f, -0.01202932f, 0.02627037f, -0.04166453f, 
    -0.02493742f, -0.02889094f, 0.02033339f, 0.02570332f, -0.00129655f, -0.01605814f, -0.00776723f, 0.00469820f, 
    0.01990537f, 0.02277627f, 0.00803755f, -0.02630183f, -0.03853941f, 0.00893109f, -0.00901488f, 0.02112846f, 
    -0.01967409f, -0.01893015f, -0.02409746f, -0.04239252f, -0.01880008f, 0.00881395f, 0.03147496f, -0.00346997f, 
    -0.04213346f, 0.02035482f, 0.00550006f, 0.01695164f, -0.00263315f, -0.03471746f, -0.01448741f, 0.01084215f, 
    -0.00052639f, -0.01886600f, -0.03981668f, -0.01710015f, -0.01033260f, -0.00833760f, -0.03168656f, 0.01993575f, 
    0.00284195f, -0.03920757f, -0.04396950f, -0.01895360f, 0.00645382f, -0.01956587f, 0.01793626f, 0.01823029f, 
    0.00695769f, -0.02487190f, -0.00247707f, -0.03277877f, -0.00859813f, 0.01714433f, 0.02059535f, 0.00622642f, 
    -0.02288019f, -0.02241915f, -0.00436778f, 0.02315962f, -0.04246610f, 0.02025991f, 0.00545343f, -0.02137534f, 
    -0.00418976f, 0.02674469f, -0.03888232f, -0.03986122f, 0.01391021f, 0.02100458f, 0.00737475f, 0.01198016f, 
    -0.00314396f, 0.02555260f, -0.01531052f, 0.01161871f, -0.00349694f, -0.03435411f, -0.01130436f, -0.03768885f, 
    -0.03131409f, 0.00132484f, -0.04175761f, 0.02420587f, -0.03271083f, -0.00553034f, -0.04388145f, 0.00077313f, 
    -0.02578110f, -0.00051216f, -0.01336735f, -0.00529612f, -0.00929395f, -0.02885943f, -0.00532732f, 0.02052592f, 
    0.01058759f, -0.02888071f, -0.03135895f, -0.04138994f, 0.02068711f, -0.04283947f, -0.02289765f, 0.02415099f, 
    -0.03635253f, -0.03627858f, -0.01141520f, -0.00717706f, 0.00377759f, -0.00980659f, 0.02361163f, 0.00695761f, 
    0.01997784f, -0.00160255f, 0.00053727f, 0.02287098f, -0.00200659f, 0.01782809f, 0.00430210f, -0.02658374f, 
    -0.01261558f, -0.03072204f, -0.02018853f, 0.01581908f, -0.02033589f, -0.03520843f, 0.01078193f, -0.00365202f, 
    0.01275781f, 0.01652079f, -0.00593668f, -0.02751710f, -0.03259405f, -0.03147116f, 0.00109296f, -0.02534192f, 
    0.01088969f, -0.03402681f, 0.01851447f, -0.02958987f, 0.00313696f, 0.00401993f, -0.03398206f, -0.00440839f, 
    -0.02859156f, 0.02260113f, 0.00827704f, -0.02377040f, -0.03253201f, 0.01246011f, 0.02295661f, -0.03819376f, 
    -0.01910727f, -0.02840948f, -0.03094903f, -0.00202576f, 0.01368537f, -0.02890797f, -0.00786972f, -0.02189112f, 
    0.01751523f, -0.04006774f, 0.00081144f, -0.03860487f, 0.02617495f, 0.00013330f, -0.02348227f, -0.01488891f, 
    0.00763399f, 0.01031477f, 0.01297740f, 0.00304278f, -0.03149466f, -0.02562296f, -0.00799159f, -0.00753438f, 
    -0.02842039f, -0.01765577f, 0.01711265f, -0.00843678f, -0.02179084f, 0.02097203f, -0.00188037f, -0.02770961f, 
    -0.00064984f, 0.01305786f, -0.03865425f, 0.00198614f, 0.02030323f, -0.02240302f, 0.01139591f, -0.03177493f, 
    0.02001110f, -0.02969351f, -0.00080800f, -0.01141321f, -0.03513107f, -0.02378407f, -0.03106443f, -0.03274224f, 
    -0.01296247f, 0.01020552f, -0.00702750f, -0.02714858f, 0.01932456f, 0.01859692f, 0.02268024f, -0.01777060f, 
    -0.02506098f, 0.02618571f, -0.00488726f, -0.00684608f, -0.02418467f, 0.00573989f, 0.00716367f, -0.00507131f, 
    -0.02728252f, 0.02522338f, -0.02205618f, -0.02217031f, -0.01755501f, 0.00344038f, 0.02162259f, -0.02675096f, 
    0.02256704f, -0.00818537f, -0.03202388f, 0.01230854f, -0.02353555f, -0.01368073f, -0.01016518f, -0.00196159f, 
    0.00135344f, -0.03177946f, 0.00192305f, -0.02470784f, -0.02219967f, 0.02512718f, -0.03378473f, 0.01640538f, 
    -0.03902046f, -0.01753405f, 0.01535776f, 0.01002555f, -0.03015630f, -0.00039147f, -0.04215315f, 0.00481857f, 
    -0.03176471f, -0.03541108f, 0.01155267f, 0.02625631f, -0.01891152f, -0.03625607f, -0.00656058f, -0.00241900f, 
    0.00069188f, -0.04353173f, -0.02403145f, 0.00712499f, -0.00205773f, 0.02521877f, -0.00217255f, 0.01290459f, 
    -0.01466126f, -0.02234384f, -0.01671316f, -0.02997629f, -0.04166207f, -0.03298026f, -0.00144803f, 0.02375008f, 
    -0.00000830f, 0.00201347f, 0.00224573f, -0.03281211f, -0.00011087f, 0.02481801f, -0.00426394f, 0.02158182f, 
    0.00511813f, -0.04090896f, -0.02781640f, 0.02718150f, 0.02453332f, 0.00358245f, 0.02452973f, -0.00327119f, 
    -0.03196194f, -0.02729576f, -0.01123787f, -0.01425894f, 0.02355322f, -0.04189698f, -0.01466146f, 0.00074890f, 
    -0.03956877f, -0.02282995f, -0.00532610f, 0.01546936f, 0.02547313f, 0.00200414f, -0.04276220f, 0.00857124f, 
    -0.00383041f, -0.00118966f, -0.01080957f, -0.00179059f, 0.00006083f, -0.00237678f, -0.02299395f, -0.03320178f, 
    0.00298634f, -0.01629096f, -0.00089878f, -0.00741356f, -0.01953403f, -0.03824880f, -0.00791662f, 0.01960366f, 
    0.00421708f, -0.03715335f, -0.02553018f, 0.02371502f, 0.00652616f, 0.00494908f, 0.00097573f, 0.02595483f, 
    -0.00274102f, 0.01438674f, -0.02773719f, -0.02942308f, -0.04070425f, -0.02359094f, -0.03568007f, 0.01456261f, 
    0.01891315f, -0.00534452f, 0.01917663f, -0.00142456f, -0.00851360f, 0.02018672f, -0.01552613f, -0.00878993f, 
    -0.00942140f, 0.02733019f, -0.02111333f, -0.00802048f, 0.00381523f, 0.01710590f, 0.00447712f, 0.01115701f, 
    -0.00602012f, -0.00346908f, -0.01520384f, -0.01081123f, 0.02079489f, -0.01348580f, 0.01860449f, -0.04049249f, 
    0.02640758f, -0.00710015f, -0.04107827f, -0.01370977f, -0.00669827f, -0.00516653f, -0.01503300f, 0.01789118f, 
    0.02363803f, -0.02926889f, 0.00158216f, 0.02260458f, -0.02266405f, -0.03825301f, 0.02810772f, -0.03133328f, 
    0.00387336f, 0.00425398f, -0.03848854f, -0.02245189f, -0.01365926f, 0.00828038f, 0.00529144f, -0.01993056f, 
    0.00077508f, -0.02921693f, -0.01069942f, 0.02357573f, -0.03641106f, 0.00627670f, -0.00017839f, 0.00553331f, 
    -0.00396667f, 0.00894592f, -0.01143332f, -0.01221828f, 0.00000819f, 0.02900793f, 0.02451733f, 0.00557369f, 
    0.02511184f, -0.00611129f, -0.03447931f, -0.01490100f, -0.00399740f, 0.01323366f, 0.00867463f, -0.01482431f, 
    0.00057306f, 0.02276898f, 0.02333397f, -0.01717268f, -0.02697015f, -0.04073831f, 0.01186834f, -0.04352411f, 
    0.01148083f, -0.03299438f, -0.00432994f, -0.01481470f, 0.00573310f, 0.01000373f, -0.03200312f, -0.01978522f, 
    0.00486578f, -0.01320438f, 0.00630005f, 0.02334881f, 0.00999422f, 0.00054511f, -0.02204679f, -0.02958580f, 
    -0.02130578f, -0.02715214f, -0.03543438f, -0.02640498f, 0.02840183f, -0.03900931f, 0.01779157f, -0.02616634f, 
    -0.00306634f, 0.02679631f, 0.01412980f, -0.02634932f, -0.01363665f, 0.02707215f, -0.00764726f, -0.03061370f, 
    -0.01323332f, 0.02312606f, -0.03973988f, -0.00702592f, 0.00390447f, -0.00209625f, -0.02724786f, -0.02187893f, 
    -0.02318782f, -0.01540699f, 0.02772487f, -0.01033521f, 0.02074388f, -0.01481434f, -0.00459603f, -0.01695642f, 
    0.03228447f, 0.01247084f, -0.00936782f, 0.02369489f, -0.00702662f, 0.02612325f, -0.01733641f, -0.01527098f, 
    0.00731305f, 0.03289363f, -0.00063319f, -0.04248297f, 0.01675816f, -0.00365055f, -0.01508890f, -0.03609592f, 
    0.02145932f, -0.01028458f, -0.02127606f, 0.01765510f, 0.01427789f, 0.03388319f, 0.01172581f, -0.01666607f, 
    -0.01430021f, 0.00022988f, 0.01492834f, -0.03278761f, -0.00017825f, 0.00962728f, 0.00517255f, 0.02620016f, 
    -0.02596591f, 0.02123706f, 0.01841216f, -0.02576049f, 0.01546064f, -0.01044105f, -0.00903444f, -0.00614333f, 
    -0.03525541f, 0.01438194f, 0.02645962f, -0.03241816f, 0.01497994f, -0.02754599f, -0.00017249f, -0.03052372f, 
    0.02688359f, -0.01621375f, 0.01992626f, -0.01570653f, -0.00657796f, -0.03436486f, 0.00678662f, 0.00254643f, 
    0.00565024f, 0.01635041f, 0.01579424f, 0.00225487f, -0.03286725f, -0.00794969f, -0.01187983f, -0.00904740f, 
    0.01769204f, 0.02297080f, -0.02423090f, -0.03948833f, -0.03617746f, -0.02272210f, -0.02640750f, 0.00109307f, 
    0.00878160f, -0.03658286f, 0.01870788f, 0.03142635f, 0.02407974f, 0.00212806f, -0.03191812f, -0.02676157f, 
    -0.02347349f, 0.01060221f, -0.02095843f, -0.03502438f, -0.01525764f, 0.01035962f, -0.03837086f, -0.00638486f, 
    0.00973809f, -0.01896026f, 0.02565038f, 0.02634784f, -0.01658048f, -0.02958561f, 0.00659524f, -0.01654922f, 
    -0.03451293f, -0.03213938f, -0.01766676f, -0.00132774f, 0.00044912f, -0.02432268f, -0.01055083f, 0.01740619f, 
    -0.02945798f, 0.01309539f, 0.02050437f, -0.00363700f, 0.02709297f, -0.03687923f, -0.03105424f, -0.02069361f, 
    0.00043620f, 0.02054547f, 0.00187201f, -0.01928372f, 0.02253748f, -0.02865044f, 0.02448964f, -0.03132910f, 
    0.00319273f, -0.03485395f, -0.00293028f, 0.01747199f, -0.01759014f, 0.02225678f, 0.02045853f, -0.01525139f, 
    -0.03321842f, 0.00234807f, -0.00986316f, -0.00238734f, 0.00138898f, 0.02585888f, -0.00441868f, 0.00046694f, 
    -0.01504736f, -0.02662009f, -0.02079505f, -0.00405608f, 0.01994316f, -0.03687851f, -0.00283833f, 0.01540502f, 
    -0.04379428f, -0.03035880f, -0.01117447f, -0.02173235f, 0.01234884f, -0.00119667f, -0.02764785f, 0.01246727f, 
    -0.00762209f, 0.03133404f, 0.00656526f, 0.01504954f, 0.01769684f, -0.02787274f, 0.00714565f, 0.01690233f, 
    -0.02800972f, 0.00982034f, 0.01737889f, 0.00250571f, 0.00366621f, -0.03394454f, -0.00325231f, 0.01282607f, 
    -0.04114560f, 0.02103481f, -0.03756779f, 0.03284220f, -0.00878980f, -0.04244377f, -0.01371957f, 0.01303788f, 
    -0.03660434f, 0.02534486f, 0.01065492f, -0.03472471f, -0.01037204f, -0.03092227f, -0.02391054f, 0.02457723f, 
    0.00339878f, -0.04001804f, 0.02704186f, -0.00024674f, -0.02477860f, -0.04260906f, -0.03327199f, -0.03402858f, 
    0.00097542f, -0.04648674f, 0.01467301f, -0.02287229f, -0.02476269f, -0.04609174f, -0.02647384f, -0.02065686f, 
    0.03679534f, -0.00253574f, -0.02015505f, -0.03074341f, 0.01740504f, -0.04538104f, -0.00146556f, -0.04223916f, 
    0.01709755f, 0.00973980f, 0.02038429f, -0.03628584f, -0.00608637f, 0.03551457f, -0.00029021f, 0.01779030f, 
    0.00808198f, -0.02236527f, 0.01850153f, -0.02865858f, -0.02811975f, 0.02056518f, -0.01361795f, -0.00702725f, 
    0.01505754f, 0.01420845f, -0.02805697f, -0.01176003f, 0.00769008f, -0.03279963f, -0.01375849f, 0.02755710f, 
    0.03423145f, 0.00027602f, 0.01709475f, 0.00722852f, 0.01668059f, 0.01587595f, -0.03494748f, -0.00641471f, 
    0.02408899f, -0.00597611f, -0.04078922f, 0.00447989f, -0.04591044f, 0.02589299f, 0.02934929f, -0.03209165f, 
    -0.03811703f, 0.00283064f, -0.01436340f, -0.00024424f, 0.01507501f, -0.01087851f, -0.00190426f, -0.00140314f, 
    -0.02028588f, -0.02477037f, 0.01481475f, 0.01137694f, -0.01030886f, 0.02698909f, 0.03297969f, -0.01676107f, 
    -0.01458629f, -0.01495967f, -0.02982682f, 0.00124866f, 0.00346604f, 0.00731351f, -0.03097307f, -0.00097740f, 
    -0.03174923f, 0.00494299f, 0.00823213f, -0.01121276f, 0.00198002f, 0.03098236f, 0.03215398f, 0.02376517f, 
    -0.03936495f, 0.02360693f, -0.02798494f, -0.01976049f, 0.00565738f, 0.03154488f, -0.02416036f, -0.00190537f, 
    -0.02818785f, 0.01272404f, -0.00599797f, -0.03288236f, 0.00062611f, 0.01471379f, 0.00193273f, -0.04346251f, 
    -0.01419502f, -0.01187193f, -0.03908569f, -0.04185802f, 0.00567298f, 0.00021712f, -0.03084979f, 0.02325542f, 
    -0.02804684f, 0.03272882f, 0.02432960f, 0.00736474f, -0.00584534f, 0.00745906f, -0.01623162f, -0.03127568f, 
    0.01352626f, 0.01840065f, -0.03180128f, -0.01795427f, -0.04141511f, 0.02061470f, 0.00160172f, -0.00981972f, 
    0.01191024f, -0.01838491f, -0.02372166f, -0.02410356f, 0.02547493f, 0.02526303f, -0.00312317f, -0.03589424f, 
    0.00259641f, -0.01693531f, -0.00666503f, 0.00473449f, 0.00450055f, 0.00978722f, -0.03415703f, 0.00259348f, 
    0.01231356f, 0.02866948f, -0.03543302f, -0.04346003f, -0.00273287f, -0.02319020f, -0.00020079f, -0.00771181f, 
    0.00912410f, 0.00335375f, -0.01453969f, 0.00957353f, -0.00413225f, -0.01348298f, -0.02405484f, 0.01738791f, 
    0.01627179f, -0.00631202f, -0.02499648f, -0.02338663f, -0.01658449f, -0.01173999f, -0.04086046f, 0.00863541f, 
    -0.00060286f, -0.00068381f, 0.02543115f, -0.02890290f, -0.02192673f, -0.03873326f, -0.04444977f, 0.00076594f, 
    0.02533954f, 0.02171713f, -0.01673918f, 0.00702481f, 0.02262688f, 0.00742063f, -0.02860788f, -0.01288106f, 
    -0.02941561f, -0.02995462f, -0.01588710f, -0.01264732f, 0.02765845f, -0.00873888f, 0.01708272f, -0.00469363f, 
    0.00837538f, 0.01710509f, -0.01500572f, -0.01985168f, -0.01025737f, -0.04589263f, -0.03483414f, -0.00462990f, 
    0.02244748f, 0.02142712f, -0.02691461f, -0.01836213f, -0.02146237f, -0.00266693f, 0.02608807f, 0.01887564f, 
    0.01831467f, -0.04110564f, 0.01797373f, -0.03778013f, -0.02355344f, 0.02707257f, -0.01138017f, 0.01231277f, 
    -0.04365194f, 0.02523702f, -0.01895154f, 0.00858117f, 0.01977382f, -0.03293676f, 0.02150222f, -0.00236215f, 
    0.00843184f, -0.02576962f, -0.02538474f, 0.01622313f, -0.02579408f, -0.00773535f, 0.02212442f, 0.00025883f, 
    -0.02135398f, -0.03773575f, -0.01297574f, 0.02580259f, -0.04039940f, -0.02454570f, -0.01284624f, 0.01110728f, 
    -0.01780279f, 0.00589763f, -0.00181001f, 0.03294729f, 0.02308740f, -0.03844873f, -0.01410133f, -0.00001537f, 
    -0.01651309f, 0.00268398f, -0.01343737f, 0.00872145f, -0.01745076f, -0.03145861f, -0.02105846f, 0.01938071f, 
    0.00794759f, 0.00374332f, -0.03182552f, -0.00387651f, 0.02226854f, 0.02143161f, -0.00078462f, 0.02021979f, 
    0.02368394f, 0.01448692f, 0.00576893f, 0.01831289f, 0.02290740f, 0.01383236f, -0.03777441f, 0.02683244f, 
    0.00293725f, -0.02894583f, 0.03771286f, -0.01505525f, 0.00315708f, 0.01719235f, -0.03133800f, -0.02571017f, 
    0.01999865f, -0.04089854f, -0.03428189f, -0.01185027f, -0.01721187f, 0.01879901f, 0.01711752f, 0.01526134f, 
    0.01467414f, -0.01033975f, 0.03527039f, 0.02261414f, -0.01138689f, -0.01906355f, -0.00689015f, 0.01977619f, 
    0.01960142f, -0.00894711f, -0.00130760f, -0.00867670f, 0.02571379f, 0.00480694f, -0.01062337f, 0.01714202f, 
    -0.00080716f, -0.01711262f, -0.03748897f, -0.03685291f, 0.02396448f, 0.00764898f, 0.02300093f, 0.00492325f, 
    0.00711810f, 0.01606209f, -0.03256744f, 0.01733775f, 0.02583336f, -0.00915946f, -0.02616985f, 0.01891331f, 
    -0.01000065f, 0.00237277f, 0.01534627f, 0.02228415f, -0.00608382f, -0.01573669f, -0.02324160f, 0.02082253f, 
    -0.02474545f, -0.01653857f, 0.00837126f, 0.02282923f, -0.00554922f, -0.03577981f, -0.02923303f, 0.00452004f, 
    -0.01144481f, -0.01813330f, -0.03625195f, 0.00753387f, 0.00916681f, -0.01510345f, 0.02918692f, -0.01083115f, 
    0.02399814f, 0.00481723f, 0.00704848f, 0.02194433f, 0.01499810f, -0.01200113f, -0.01859160f, -0.02984976f, 
    0.02252997f, -0.01019585f, 0.01012956f, -0.02906596f, -0.00049384f, -0.03014913f, -0.02560074f, 0.03736882f, 
    0.01616716f, -0.03574658f, -0.01866519f, -0.02857821f, -0.04051980f, 0.02518733f, 0.00157498f, 0.00295007f, 
    0.02609308f, -0.02297586f, -0.02361282f, 0.02881091f, -0.04562597f, 0.00270499f, -0.01194216f, -0.02091279f, 
    -0.00721624f, -0.00682159f, -0.00125174f, -0.02860061f, -0.02801981f, -0.03402535f, -0.03454730f, -0.02369365f, 
    0.00612277f, -0.01823511f, 0.00803082f, 0.00292539f, 0.00506207f, -0.00247427f, 0.01614763f, 0.02411153f, 
    -0.03763065f, 0.02061550f, -0.00931519f, 0.02405988f, -0.00500413f, -0.03720139f, 0.00200903f, 0.00277627f, 
    -0.04522372f, 0.01576542f, -0.04271221f, 0.01042148f, -0.03316788f, 0.00777690f, -0.02722052f, -0.00835364f, 
    0.03016808f, -0.02438848f, 0.01786558f, -0.02998260f, -0.02650563f, 0.00772582f, -0.00460570f, 0.02564740f, 
    0.00777294f, 0.02614124f, -0.01600211f, 0.01866672f, -0.02212805f, -0.01817007f, 0.02459912f, -0.00743535f, 
    0.01561688f, -0.00548608f, 0.02232286f, -0.04018142f, 0.00516775f, 0.01719191f, -0.03183532f, -0.02824322f, 
    0.00480302f, -0.03484094f, 0.00145252f, 0.01408694f, 0.00389336f, -0.02587836f, -0.03007514f, -0.02267351f, 
    -0.04454549f, -0.00577221f, 0.01548596f, -0.02214148f, 0.00743150f, -0.02967147f, -0.03483367f, 0.01029925f, 
    0.01520863f, -0.02309620f, 0.03268049f, 0.01333193f, 0.00152867f, 0.01848309f, -0.00827192f, -0.03419972f, 
    0.02508866f, 0.01299742f, -0.02880638f, -0.00274264f, 0.02157962f, 0.03182005f, -0.00626778f, -0.02084761f, 
    -0.03778767f, -0.03143097f, -0.00968368f, -0.04037391f, -0.01041550f, -0.01816168f, 0.01454750f, -0.02420453f, 
    -0.02221985f, -0.00529327f, 0.02176356f, 0.01951137f, -0.02955264f, 0.02615654f, 0.02668196f, 0.00582176f, 
    -0.03361334f, 0.00662302f, -0.04065193f, 0.02476033f, -0.00690292f, 0.02374103f, -0.03599603f, 0.00537751f, 
    0.01521074f, -0.00211271f, -0.03812263f, 0.00081744f, 0.02096468f, 0.01843539f, -0.04194890f, -0.00326619f, 
    -0.01297524f, 0.02453202f, 0.00765219f, -0.02380406f, -0.03265714f, -0.02313245f, -0.00762009f, 0.01525298f, 
    0.00484527f, 0.02247501f, -0.00855290f, 0.00693893f, -0.02820261f, 0.00285757f, -0.01496474f, -0.02631307f, 
    -0.01710602f, 0.03413627f, -0.00506801f, -0.02917654f, -0.01020950f, 0.00187801f, -0.00332663f, -0.00391312f, 
    -0.01407695f, -0.00417476f, 0.01285595f, 0.00638006f, 0.02540932f, 0.00541096f, 0.01005743f, 0.02535274f, 
    0.00139526f, 0.01293650f, -0.01827937f, 0.00189087f, -0.00995228f, -0.03293534f, 0.01564244f, 0.01483514f, 
    0.01142989f, -0.02633146f, 0.01591693f, -0.01939953f, -0.03368475f, -0.00242746f, -0.00937060f, -0.02958998f, 
    0.02127656f, 0.01218276f, -0.00317055f, -0.03312238f, 0.00187368f, 0.02079852f, -0.02040812f, 0.03450978f, 
    -0.00447233f, -0.02867353f, -0.01900615f, -0.03083712f, 0.00236910f, -0.02779925f, -0.01915315f, -0.02445148f, 
    -0.04170764f, -0.03664808f, -0.03389528f, 0.00565097f, 0.02547866f, -0.01235029f, 0.00761778f, 0.00642856f, 
    -0.03528063f, -0.00969177f, -0.01475975f, 0.01052449f, 0.00852971f, -0.03883659f, -0.00890535f, 0.02120337f, 
    -0.03203483f, -0.02612937f, 0.00524520f, 0.00208572f, -0.00965399f, 0.02053111f, -0.03150379f, -0.01121921f, 
    -0.02402454f, 0.02374178f, -0.03391596f, 0.02970110f, 0.00843817f, 0.01121530f, -0.03353159f, -0.03349372f, 
    -0.01066722f, -0.00882971f, -0.01663108f, 0.00042212f, -0.02156132f, 0.01377989f, -0.02199245f, -0.01223791f, 
    0.00666939f, 0.00825588f, -0.02747168f, -0.00573848f, 0.00007955f, 0.02356882f, 0.00818572f, 0.01141431f, 
    -0.01674874f, -0.01907921f, -0.02710296f, 0.01846242f, -0.00923511f, -0.00139393f, 0.03113964f, -0.01111543f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.01238327f, 0.00739616f, 0.03281413f, -0.03655580f, 0.08755610f, -0.00990040f, 0.02419410f, -0.05056705f, 
    -0.02200962f, 0.00173007f, -0.01877375f, 0.00483451f, 0.02287599f, 0.07415495f, 0.00021507f, 0.07549633f, 
    -0.02249017f, -0.01720083f, -0.00456364f, 0.02624827f, 0.06883209f, 0.03396564f, -0.01247408f, 0.00984854f, 
    0.00584948f, 0.01236555f, 0.00840032f, 0.04847629f, -0.02103281f, 0.00190123f, 0.00411955f, 0.01465485f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.30178952f, 0.03175049f, -0.11251508f, 0.06900119f, -0.52200812f, 0.25564146f, 0.05789105f, 0.32235560f, 
    0.09840247f, -0.03802704f, -0.39421433f, 0.27677560f, 0.17057703f, -0.21086805f, 0.05824764f, -0.02845484f, 
    0.05669373f, 0.11683506f, 0.03323983f, 0.02491936f, -0.06646990f, -0.12165093f, 0.36088422f, -0.45606333f, 
    0.08613133f, 0.16886374f, 0.23387592f, 0.03570818f, -0.17273141f, -0.13533445f, -0.14779721f, 0.12836227f, 
    0.20838594f, -0.16088399f, 0.08920825f, 0.01213039f, -0.07112801f, 0.19137289f, -0.12317522f, -0.16078603f, 
    0.05950995f, -0.51294374f, -0.32237932f, -0.37065640f, -0.41556522f, 0.06920575f, 0.10859989f, 0.16224767f, 
    -0.06330571f, 0.06991919f, -0.16255419f, -0.16954604f, 0.27542120f, 0.31311718f, -0.05472974f, -0.44140899f, 
    -0.02923805f, -0.09701110f, 0.23401564f, 0.15454148f, 0.16326711f, 0.01750753f, -0.16406013f, 0.02531998f, 
    0.41507530f, -0.07851104f, -0.01089003f, -0.17512557f, 0.04474066f, 0.18489997f, 0.00982851f, -0.68192017f, 
    -0.13818076f, 0.05337664f, -0.17100121f, -0.01987480f, -0.19376878f, -0.17798470f, 0.07676572f, -0.53733432f, 
    0.11310549f, 0.05203950f, -0.01820373f, -0.02260667f, -0.27014115f, -0.15593536f, 0.36533999f, -0.26081774f, 
    -0.04541764f, 0.08658577f, 0.18182683f, 0.15744716f, -0.12437201f, 0.25762746f, -0.04848532f, -0.00276873f, 
    -0.05081878f, -0.09987573f, -0.02505742f, 0.02651537f, -0.29176843f, 0.29071954f, 0.05887210f, -0.07364881f, 
    0.05514015f, -0.01000836f, -0.27660966f, 0.06727439f, 0.38519454f, 0.03240666f, -0.10504859f, -0.08771016f, 
    0.08458900f, 0.07208271f, -0.04205578f, -0.13359638f, -0.61478311f, 0.28362185f, -0.29040989f, 0.24451306f, 
    -0.12716120f, -0.11547222f, -0.53560388f, -0.15791380f, 0.14019872f, 0.35842013f, 0.09173454f, -0.11199424f, 
    0.11488868f, 0.01208798f, 0.14041506f, -0.15563206f, -0.28465655f, 0.18225431f, -0.05406808f, -0.00581304f, 
    -0.07466809f, -0.34510565f, 0.43271184f, 0.11415883f, 0.33717349f, 0.10051654f, 0.01779152f, -0.00187602f, 
    0.06822512f, 0.09466958f, -0.01440324f, 0.10856359f, -0.11179041f, -0.45172027f, -0.32158980f, -0.13612178f, 
    -0.06871891f, -0.03490895f, -0.21494931f, 0.20274299f, -0.13352230f, -0.02772538f, -0.04002171f, 0.17350426f, 
    -0.50306749f, -0.16273908f, 0.04980965f, -0.03108413f, 0.26454389f, -0.28213531f, 0.12912837f, 0.32101434f, 
    -0.00576359f, -0.21509351f, 0.23422243f, -0.26468098f, 0.29646200f, -0.28616542f, -0.08448873f, 0.20455374f, 
    0.11017309f, -0.06539501f, -0.08453368f, -0.15421154f, 0.24625176f, 0.23217216f, 0.26538754f, -0.04295111f, 
    -0.02474640f, 0.03433572f, -0.31999528f, 0.06633501f, -0.10533377f, -0.16498975f, -0.16402642f, 0.08058084f, 
    -0.21577817f, 0.09255371f, 0.10774033f, 0.14820568f, -0.30983540f, 0.25211343f, -0.00602163f, -0.26565707f, 
    -0.12306933f, -0.10172131f, 0.05615045f, 0.18878895f, -0.83809215f, -0.32735831f, 0.13657038f, 0.30014637f, 
    -0.10328811f, 0.07228499f, -0.08529855f, 0.04140040f, 0.16200830f, -0.28631195f, 0.16332203f, 0.45488366f, 
    -0.11738974f, -0.02544214f, -0.13891721f, 0.04516788f, 0.11618602f, 0.03891256f, -0.15665643f, -0.08080095f, 
    0.30832830f, -0.06469220f, 0.04077275f, 0.06896108f, -0.12443511f, -0.35525909f, -0.16247515f, 0.22675453f, 
    -0.07379234f, -0.16199546f, 0.09590207f, 0.30860066f, -0.02099515f, -0.12872082f, 0.14800458f, -0.23576815f, 
    -0.16965958f, -0.07039312f, -0.00868419f, 0.13323821f, 0.17972429f, -0.11182364f, -0.38543817f, 0.11265986f, 
    0.07235665f, -0.01092827f, -0.20368472f, -0.53561389f, -0.09328842f, 0.32030448f, 0.06652784f, -0.00479361f, 
    -0.07867779f, -0.04297867f, 0.16245760f, -0.01094832f, 0.39744568f, -0.18976843f, -0.08804262f, -0.06711730f, 
    -0.01142214f, -0.06221876f, 0.25833380f, -0.11361001f, -0.33201855f, -0.39886984f, 0.06538535f, -0.38440120f, 
    -0.08946712f, 0.13528095f, 0.15232138f, 0.02725771f, -0.09505095f, 0.31758705f, -0.47487009f, 0.02645411f, 
    0.16371220f, 0.00709005f, 0.31120610f, 0.10245769f, 0.17005800f, 0.02910589f, 0.10217742f, -0.00507473f, 
    0.33352140f, 0.00816433f, -0.17628820f, 0.04742260f, 0.07748538f, -0.15730134f, -0.07724610f, -0.18768167f, 
    0.09605318f, 0.63033837f, 0.20660107f, 0.11817423f, -0.21264896f, -0.14333865f, -0.04628984f, -0.00120301f, 
    0.08732190f, -0.06492747f, -0.15083672f, -0.09533542f, 0.30726862f, -0.55493891f, -0.03784749f, -0.00929993f, 
    0.05235861f, -0.09714142f, 0.13758543f, -0.29110640f, -0.17462306f, -0.30412960f, -0.08201692f, 0.10138579f, 
    -0.02133352f, -0.03330380f, 0.03465099f, -0.02982801f, 0.38095611f, -0.53831726f, 0.03949418f, -0.24583378f, 
    -0.02717126f, -0.11920703f, -0.65351677f, -0.10767314f, 0.21268980f, 0.31628722f, 0.16282058f, -0.23774312f, 
    0.04912253f, -0.08885606f, 0.05322448f, -0.01771309f, 0.29175577f, -0.03409973f, -0.02012283f, 0.23565847f, 
    -0.14235753f, 0.16352035f, -0.23921892f, 0.25723717f, -0.10770324f, 0.08541077f, -0.17274231f, -0.14294007f, 
    -0.37235451f, 0.07648367f, -0.13016111f, -0.05023639f, 0.03722503f, 0.03114877f, -0.09562401f, -0.18087946f, 
    0.14794901f, -0.01048344f, 0.19765390f, 0.32323948f, -0.51849526f, 0.27774173f, -0.07344986f, -0.37833461f, 
    0.08687300f, -0.00564999f, 0.10763398f, -0.09584862f, -0.25918987f, 0.21220072f, -0.13674359f, 0.28778702f, 
    0.15945962f, 0.07325513f, -0.16574018f, -0.15392470f, -0.16865198f, -0.47849190f, -0.13512498f, 0.08515619f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.09196346f, 0.00907438f, 0.04628304f, -0.14172442f, -0.10451690f, -0.06118527f, -0.09113828f, 0.00411091f, 
    0.09666944f, 0.05150323f, 0.07515856f, 0.20110223f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 3072);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
