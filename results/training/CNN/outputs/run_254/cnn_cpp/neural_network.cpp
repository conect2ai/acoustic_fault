#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.09712508f, -0.00557229f, -0.60721910f, 1.27562773f, -0.08301462f, -0.66582519f, -0.64660555f, -0.45118332f, 
    -0.92810106f, -1.24740946f, -0.71630114f, -0.99287349f, 0.10673331f, 0.06783781f, 0.14192492f, -0.20211306f, 
    -0.10046488f, -0.95717531f, -0.49628830f, 0.49942508f, -0.64550942f, -0.96521717f, 0.37689784f, 1.24557900f, 
    -0.10517533f, 0.12803400f, 0.87430072f, 1.10219824f, -1.38819575f, -0.84563905f, -1.06180525f, -0.06306262f, 
    -0.31789479f, -0.35732162f, -0.15902789f, 0.16815343f, 1.08284926f, 0.49447659f, 1.38577402f, 0.36353615f, 
    0.35436192f, -0.67582041f, 0.33599299f, -0.11860061f, 0.01650634f, 0.30751222f, 0.74473441f, 0.35900038f, 
    -1.12450945f, -0.63960046f, -0.67197293f, 0.37931651f, -0.41369942f, -0.38924807f, -1.53593886f, 1.02593029f, 
    0.68981987f, 0.00302038f, 0.05013242f, -0.99756527f, -0.38943937f, -0.44166780f, -0.54103720f, -0.70935774f, 
    -0.61359495f, -0.69014758f, -0.22592618f, 1.01592779f, 1.20385385f, 0.03040353f, 0.18423678f, 0.42111549f, 
    -0.48712724f, -0.90527713f, -0.96714044f, 0.37074712f, -1.02208662f, -0.64403534f, 0.30930850f, -0.32534987f, 
    0.62907481f, -1.19222212f, -0.74537748f, -1.24414706f, 0.13647842f, 0.15013051f, 0.22034144f, 0.62412441f, 
    -0.64050692f, 0.27501264f, -0.73735136f, -1.23931468f, -0.33016300f, 0.82905275f, -0.17783973f, 0.79387391f, 
    -0.53104728f, -0.18612669f, -0.08228887f, -0.01354575f, -0.14367297f, 0.58891910f, -0.74466884f, -1.06782186f, 
    0.54601437f, -0.35906696f, 0.47037852f, 0.78864300f, 1.11408186f, 1.29607964f, -0.57447135f, 0.20862533f, 
    -0.78010881f, 0.44644713f, 0.43785244f, -0.03221149f, -0.10565847f, -1.10003567f, 0.33586815f, -1.19405568f, 
    0.07549635f, 1.20390046f, 0.02493751f, 0.70157665f, -0.47394007f, 0.07929920f, 1.13497949f, 0.71032417f, 
    0.84757960f, 0.66079479f, -0.92456663f, 0.85450912f, 0.46029627f, -0.17592971f, -0.57482105f, -0.08937763f, 
    -1.47733176f, 0.86333090f, 1.06134427f, -1.17960286f, 0.19708475f, -0.29265356f, -0.17432983f, -0.41892236f, 
    -0.03812988f, -0.74325377f, -0.85304117f, -0.73613918f, -0.07352623f, -0.99130028f, 0.24353391f, 0.38323855f, 
    -0.79923254f, 0.89775842f, 1.14243078f, -0.02943435f, -0.24100187f, -0.32150856f, -1.14073586f, 0.09403298f, 
    -0.73889321f, 0.05263318f, 0.97631508f, 0.44304436f, 0.80296576f, 1.17289150f, 0.89222729f, -0.28444973f, 
    0.10358822f, -0.54904699f, 0.22672111f, 1.17995846f, 0.99957496f, 1.07577491f, -0.13548532f, -0.85127288f, 
    0.15678626f, 0.08486914f, 0.71275789f, 0.45566124f, -0.14707832f, -1.02093983f, -1.10948777f, 0.48081681f, 
    0.43215057f, 0.10532503f, -0.95089692f, 0.43970039f, 0.68897039f, 0.69253367f, 0.10558124f, 0.25915658f, 
    -1.35739350f, -1.29082322f, -0.83184928f, -0.16468792f, 0.13965182f, 0.14531714f, 0.46107161f, 1.03337419f, 
    -1.36921608f, 0.42297903f, -0.46667823f, -0.13548590f, 0.55132812f, 0.37479338f, 0.32417583f, 0.36781570f, 
    0.33835995f, -0.25915179f, 0.11792035f, 0.89564973f, 0.99471682f, 0.46187752f, -0.32973474f, 1.02059650f, 
    0.27589947f, -0.70919794f, -0.95439744f, 1.29079378f, -0.15714930f, 0.39414376f, 0.33693478f, -0.53276724f, 
    0.16613314f, -0.90164542f, -0.28380257f, 0.10312900f, 0.58137757f, 1.59006512f, 0.43796748f, -0.40110955f, 
    -0.46115878f, -0.23088907f, -1.12745583f, -1.29438245f, -1.22381902f, -0.73208237f, -0.51066089f, 0.42257553f, 
    -0.04954362f, 0.25284025f, 0.41843531f, 0.93592888f, 0.47416878f, -0.94915003f, -0.18129124f, -0.18402006f, 
    -0.57640594f, 1.00485170f, 0.61203402f, 0.42410490f, 1.35117245f, 1.06396687f, 0.31663972f, 0.77667361f, 
    0.51022398f, 0.30782419f, -0.54533792f, 0.68512923f, -0.25037259f, -0.56638408f, 0.77177936f, 0.07193346f, 
    -1.22161126f, 0.00939719f, -0.71778756f, 0.60760802f, 0.03469821f, 0.65791464f, 1.05305338f, 0.63993633f, 
    0.93481690f, -0.80803281f, -0.69086206f, 0.09635022f, -0.92609584f, -0.24585885f, -0.18857966f, 1.04240739f, 
    -0.90265679f, -0.37906435f, 0.73018217f, -0.90281820f, -1.25372005f, -0.19567159f, 0.32425240f, 0.13082621f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.12572828f, -0.00684293f, -0.17164269f, -0.12090591f, 0.58483380f, 0.24878603f, 0.02613222f, 0.11520479f, 
    0.20603183f, 0.29252070f, 0.14571618f, 0.20016578f, -0.24679351f, -0.12954345f, 0.19053155f, 0.08619476f, 
    0.37352878f, 0.16812123f, 0.03728124f, 0.13634700f, -0.19678730f, 0.04934892f, 0.17578419f, 0.12942311f, 
    0.03031296f, 0.04927376f, 0.02136145f, -0.00711588f, 0.12653142f, 0.04774615f, 0.37556064f, 0.43309242f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04362945f, 0.00564348f, 0.02470626f, 0.00082516f, -0.04732468f, -0.01736248f, -0.01491591f, -0.04175239f, 
    0.02618987f, 0.02996224f, -0.01982154f, 0.03644439f, -0.04929821f, -0.01754090f, 0.03369208f, 0.00222668f, 
    -0.05316216f, 0.05267386f, -0.02097460f, 0.04460554f, 0.03301725f, -0.00132107f, 0.03405969f, -0.06184204f, 
    -0.03330905f, 0.01944351f, -0.00706845f, 0.02793042f, -0.00661351f, 0.04576664f, -0.04941441f, 0.01972968f, 
    0.01817759f, 0.01441004f, 0.02505860f, 0.00305460f, 0.02562018f, -0.01433108f, -0.03094410f, 0.00888289f, 
    0.04304446f, -0.03063883f, -0.01457947f, -0.03692359f, 0.03311140f, -0.04218456f, 0.00278236f, 0.01945110f, 
    -0.01712801f, -0.01421274f, -0.00784837f, -0.00479380f, -0.01553658f, 0.02511897f, 0.00203138f, 0.01282132f, 
    -0.04467278f, -0.00782513f, -0.00310946f, 0.04319274f, 0.00211807f, -0.00640102f, -0.03639085f, -0.03643310f, 
    -0.04985772f, 0.04485712f, -0.01934056f, 0.01171866f, -0.01705573f, -0.04294984f, -0.05175967f, -0.00504045f, 
    0.00972407f, 0.00786352f, -0.03517149f, -0.03022611f, -0.04927113f, 0.00453720f, -0.02568708f, 0.01174172f, 
    0.02031558f, 0.05114366f, -0.01305500f, 0.02874576f, -0.06057784f, -0.03781943f, 0.00603741f, -0.04366816f, 
    -0.05980224f, 0.00887292f, 0.00664422f, 0.00799232f, 0.01487157f, -0.03785913f, -0.01265372f, 0.00939762f, 
    -0.05432622f, -0.02421783f, -0.00327153f, -0.01494813f, 0.04376037f, 0.00034899f, 0.05662782f, -0.04438942f, 
    0.04091735f, -0.04316753f, -0.02437752f, 0.00787610f, 0.00318488f, -0.00381434f, -0.01157789f, -0.00366248f, 
    0.01884188f, -0.02623287f, 0.00580875f, -0.06358980f, 0.00655787f, -0.02571403f, -0.06299844f, -0.01101463f, 
    -0.03364236f, 0.02273680f, 0.01468764f, 0.03051352f, -0.05218480f, -0.01731533f, -0.04150085f, 0.04854575f, 
    -0.00126542f, -0.05578176f, 0.05292695f, -0.05712756f, -0.04928279f, 0.01572001f, -0.05023251f, -0.05441950f, 
    0.05271235f, -0.04560105f, 0.01899932f, 0.01626373f, -0.05197053f, -0.00583216f, -0.04787084f, -0.02849615f, 
    -0.02348031f, -0.01010333f, -0.04757574f, 0.01898409f, -0.02261245f, 0.01536620f, 0.02996606f, -0.00049341f, 
    0.03428501f, -0.01512541f, -0.02144833f, 0.05185516f, -0.01424683f, -0.05909517f, 0.03559247f, -0.03197917f, 
    0.02981658f, 0.05570311f, 0.03528646f, -0.04704227f, -0.04063458f, -0.01100591f, 0.03639082f, -0.04409510f, 
    0.03720816f, 0.02358182f, -0.00189729f, 0.04816053f, -0.00801095f, 0.03853906f, 0.03445644f, -0.04181628f, 
    -0.05388898f, 0.01980873f, -0.00322295f, -0.04998286f, -0.03266197f, 0.01550065f, -0.02566975f, 0.04484478f, 
    -0.04762995f, 0.02139077f, -0.03606240f, 0.02897389f, -0.02655210f, 0.03498711f, -0.02370756f, -0.04280213f, 
    -0.01568638f, -0.04753567f, 0.03512693f, -0.00902175f, -0.05521508f, -0.04510214f, 0.04032256f, 0.02596133f, 
    0.01519975f, 0.00571764f, 0.03859670f, -0.06092509f, 0.03709870f, -0.01014211f, -0.06324766f, -0.06366881f, 
    0.03392207f, 0.03413318f, -0.05354889f, 0.01960116f, 0.04877474f, 0.00073054f, -0.05642666f, 0.02690817f, 
    -0.00142733f, -0.00226953f, -0.06151945f, 0.02615858f, -0.02394836f, -0.00854419f, -0.05373774f, -0.02507302f, 
    0.03441392f, -0.00194805f, 0.00526633f, 0.00266767f, -0.05871826f, 0.02911350f, 0.00176760f, 0.02158677f, 
    -0.06069223f, 0.00374867f, -0.03754571f, -0.05812558f, 0.05490019f, -0.04666935f, -0.06757640f, -0.03441154f, 
    0.03401818f, 0.03372411f, 0.00700327f, 0.00107224f, 0.00089452f, 0.05205777f, 0.00481233f, -0.03951441f, 
    -0.04462291f, -0.02197816f, 0.03961784f, -0.00129156f, -0.02751305f, -0.01744135f, -0.04988588f, 0.02123545f, 
    -0.01311560f, 0.03505928f, -0.04090459f, 0.00293069f, -0.05491931f, -0.02853924f, -0.05112351f, -0.03534381f, 
    -0.01422879f, -0.04799269f, 0.02277765f, -0.02513389f, 0.02588829f, -0.00792410f, 0.03351271f, 0.02724762f, 
    -0.05834291f, -0.06091778f, -0.07172662f, 0.03526628f, -0.05749903f, -0.04441850f, -0.05968088f, -0.03824747f, 
    0.01082497f, 0.00418608f, 0.04770170f, 0.04081188f, 0.00448226f, -0.06420291f, 0.03295811f, 0.03076950f, 
    -0.10855380f, -0.20163046f, 0.22489494f, 0.13527538f, 0.02865473f, 0.05989854f, 0.07407193f, 0.17775136f, 
    -0.19018015f, 0.05392321f, 0.41936445f, -0.30240300f, 0.13765906f, -0.06338058f, -0.02380481f, 0.16943988f, 
    -0.10752039f, 0.01359502f, -0.46253321f, 0.16381931f, -0.55369502f, 0.11350065f, 0.04472072f, -0.19013174f, 
    0.02650155f, -0.07825433f, 0.25961441f, -0.19114064f, -0.55291849f, 0.35300568f, -0.04543772f, 0.08871741f, 
    -0.07768379f, -0.11290777f, -0.14561862f, -0.09967221f, 0.20355150f, 0.04365029f, 0.31454372f, 0.09054964f, 
    0.00710112f, -0.03943851f, 0.04956366f, 0.19156636f, 0.00704735f, 0.15094322f, 0.23573972f, 0.00552395f, 
    -0.01875193f, -0.04904962f, 0.11024939f, -0.03800876f, -0.05646602f, 0.07368981f, 0.09161128f, 0.00119680f, 
    0.30540353f, 0.23942696f, 0.13167715f, -0.16318780f, -0.03790098f, 0.39196056f, -0.04807161f, -0.41362903f, 
    0.33594471f, -0.51371455f, 0.14451495f, 0.11018582f, -0.09389194f, 0.06523084f, 0.03875314f, 0.08377833f, 
    -0.30108216f, -0.20069252f, -0.21561579f, -0.03522573f, 0.21872696f, 0.00340244f, 0.15520461f, -0.05209346f, 
    -0.08695675f, 0.03690761f, 0.36670822f, -0.13179432f, -0.01376650f, 0.16793466f, 0.00576183f, 0.27503470f, 
    0.04347406f, -0.13455442f, -0.65505368f, -0.01271152f, -0.29330221f, 0.13642271f, 0.05319051f, -0.06443291f, 
    0.04404869f, 0.01973835f, 0.00750338f, 0.28780809f, 0.08076232f, -0.17017376f, 0.01958909f, -0.18043609f, 
    0.10880306f, -0.17874995f, -0.04339422f, 0.21079934f, 0.17672500f, -0.12989236f, -0.20110300f, -0.03822127f, 
    0.02710977f, 0.13907933f, 0.21763137f, 0.02987520f, 0.05221681f, 0.65743887f, 0.31641987f, 0.12736641f, 
    -0.17632262f, 0.02034245f, -0.08211942f, 0.11633052f, -0.11582106f, -0.25276974f, -0.02346669f, 0.10072906f, 
    0.13667843f, 0.20749865f, 0.04096032f, 0.15531874f, -0.14824831f, 0.14008394f, 0.04125057f, -0.56020933f, 
    -0.24293022f, 0.34134164f, 0.21157414f, 0.35074660f, -0.04702542f, -0.18212935f, 0.00697305f, -0.18545115f, 
    -0.51215959f, -0.05268080f, 0.09622725f, -0.07272124f, 0.18265978f, 0.05291969f, -0.02099838f, -0.17247415f, 
    -0.13457181f, 0.14867023f, -0.03164146f, 0.20341530f, 0.23096600f, 0.32196259f, 0.14344086f, -0.12552948f, 
    -0.12777786f, 0.08949317f, 0.19207212f, 0.00532672f, 0.41401029f, -0.13067980f, -0.00533079f, 0.06262850f, 
    -0.04195350f, 0.29352304f, 0.15016289f, 0.33423015f, 0.29776737f, -0.06928132f, -0.04607890f, -0.19922338f, 
    0.16212218f, -0.04464823f, -0.08622923f, -0.06790289f, -0.43810126f, -0.04177701f, -0.66684180f, -0.17518090f, 
    0.03253805f, -0.08680997f, 0.00127180f, 0.08480711f, -0.02877684f, 0.18932842f, -0.06249539f, 0.14700982f, 
    -0.12148533f, -0.24200432f, 0.12991765f, -0.10684125f, 0.10582159f, 0.17872708f, 0.04196720f, -0.42719567f, 
    0.21242006f, -0.29985273f, 0.09804116f, -0.15341374f, 0.10172290f, -0.06151407f, -0.01327048f, -0.51695764f, 
    0.10948195f, -0.14626929f, -0.05428036f, -0.05966125f, -0.05266137f, -0.04035952f, 0.09427780f, 0.16596685f, 
    -0.04753470f, -0.37306091f, -0.31823698f, -0.04714432f, 0.07341117f, -0.06354520f, -0.01113225f, -0.03619680f, 
    -0.20291564f, 0.22200787f, 0.26926875f, -0.13502723f, -0.08706623f, -0.06664483f, -0.15121435f, 0.18791051f, 
    -0.27911693f, -0.09329609f, -0.35044998f, 0.22702010f, -0.19469789f, -0.04269229f, 0.14911345f, 0.01728881f, 
    0.10962617f, 0.01623563f, -0.00800266f, -0.12187157f, -0.18777093f, 0.46346882f, 0.06793711f, 0.12374644f, 
    -0.02717707f, -0.12883514f, -0.07069232f, 0.16501206f, 0.47699353f, 0.09083270f, -0.03903074f, -0.16228932f, 
    0.12683812f, 0.17515324f, -0.06123840f, 0.05265993f, -0.05438999f, 0.24165069f, -0.05903071f, -0.15515511f, 
    -0.05488785f, -0.16256684f, 0.00684674f, -0.20095553f, 0.02768039f, 0.17488667f, 0.34147424f, 0.13213317f, 
    -0.18220413f, -0.12106273f, -0.10893593f, 0.12906025f, 0.02799969f, 0.05092489f, -0.03421976f, -0.21004784f, 
    -0.69081229f, 0.01909304f, -0.15908086f, 0.30921081f, -0.21298659f, 0.07614826f, -0.12383943f, -0.02392382f, 
    0.01524174f, 0.03668492f, 0.04942328f, -0.02604458f, 0.00928653f, -0.06092708f, -0.02320322f, 0.04753278f, 
    -0.03510150f, 0.00378011f, -0.03089483f, -0.03143153f, 0.03687441f, 0.00443114f, 0.02879876f, 0.00387498f, 
    -0.04539360f, -0.01642828f, -0.01950652f, 0.04106728f, -0.01696082f, 0.01656666f, -0.02957942f, 0.02097355f, 
    -0.05874384f, 0.02753427f, 0.00999714f, 0.02898489f, 0.00215438f, 0.02949552f, -0.06497180f, -0.00617114f, 
    -0.04677554f, -0.01910272f, -0.00337279f, 0.02398542f, 0.01376999f, -0.02071891f, -0.06258214f, 0.00126779f, 
    -0.05669233f, 0.00139243f, -0.04776175f, 0.00729077f, 0.02899202f, 0.03966989f, 0.00707722f, 0.06199741f, 
    0.03820711f, 0.04771858f, -0.01290656f, 0.04397792f, 0.04480686f, -0.03010199f, -0.05414651f, -0.01592754f, 
    -0.03217509f, -0.02505488f, 0.05177382f, 0.01869433f, -0.03062870f, -0.02096790f, -0.04996143f, -0.04588177f, 
    0.03612569f, 0.04570849f, 0.01307884f, -0.00292183f, 0.03390525f, 0.00462907f, 0.00190972f, 0.02681775f, 
    -0.04467617f, -0.05586209f, 0.04106168f, -0.06117104f, 0.04046170f, -0.05017897f, 0.02073654f, -0.02204504f, 
    -0.05366733f, 0.04613720f, -0.03040053f, 0.01181984f, -0.04396560f, -0.01679746f, -0.03803844f, 0.01974029f, 
    -0.00602909f, -0.01070895f, 0.04203505f, -0.00728735f, -0.05118967f, -0.06273530f, -0.03674608f, -0.04133119f, 
    -0.04131730f, 0.01536364f, -0.05988923f, 0.02231590f, 0.00958871f, 0.01816138f, 0.00618122f, -0.00908594f, 
    0.00141303f, -0.02299222f, -0.03472807f, -0.03201733f, -0.00691616f, -0.03341918f, 0.00590498f, -0.01974856f, 
    0.00037227f, 0.03368708f, -0.02116651f, 0.03785060f, -0.06237192f, 0.02709829f, 0.01470269f, 0.03538664f, 
    0.03416251f, -0.05365313f, -0.00613450f, -0.01782121f, -0.06317726f, -0.05620165f, -0.03809261f, -0.03894570f, 
    -0.04250679f, -0.02662727f, 0.02628281f, -0.05489871f, 0.02265012f, 0.02301590f, -0.04096264f, -0.06506674f, 
    0.00721938f, -0.00718949f, 0.00151304f, 0.01212834f, -0.04321843f, 0.00621846f, 0.02376268f, -0.02360658f, 
    -0.00892187f, -0.00935378f, 0.01928360f, -0.03063126f, 0.00054056f, -0.05411948f, -0.03854530f, 0.05214599f, 
    -0.02748591f, -0.05727107f, -0.00101886f, -0.03846338f, -0.01498150f, -0.00817983f, -0.02091522f, -0.04018565f, 
    0.05310334f, -0.01250141f, -0.00313769f, -0.01835112f, -0.01325259f, -0.03721296f, -0.05028094f, -0.00534710f, 
    0.01187313f, 0.01252395f, 0.02252104f, -0.00725218f, 0.00031685f, -0.05825178f, -0.05976929f, -0.05130693f, 
    0.01946471f, 0.04799226f, -0.05305065f, -0.05132346f, -0.04818426f, 0.04798063f, -0.01113515f, 0.03901155f, 
    -0.05525564f, -0.04041378f, -0.00460574f, -0.04607505f, -0.01761158f, 0.04689835f, 0.03987807f, 0.06450167f, 
    0.01141619f, 0.02324490f, -0.00079363f, -0.00694097f, -0.03614058f, 0.04341239f, 0.04366551f, 0.00961229f, 
    0.03179738f, -0.03746495f, 0.03890268f, -0.03811434f, 0.03374511f, 0.01450066f, -0.00957092f, -0.04472248f, 
    0.01256972f, -0.02546179f, 0.01191784f, -0.02076811f, -0.04711829f, 0.04564181f, 0.02480479f, 0.03598808f, 
    -0.00110309f, -0.00499185f, 0.04453742f, 0.00283366f, 0.03189280f, -0.02966268f, 0.02229230f, -0.02035745f, 
    0.00407230f, -0.04042489f, -0.04118140f, 0.03808106f, -0.01385555f, 0.04301028f, 0.03348225f, 0.03356656f, 
    -0.05743802f, -0.04352108f, -0.00072944f, 0.01397557f, -0.05794337f, 0.04027828f, 0.02406697f, 0.04713363f, 
    -0.02630436f, 0.03558775f, -0.05131263f, -0.02004625f, 0.04506510f, 0.00306279f, -0.00547333f, 0.00510009f, 
    -0.03836880f, -0.04825783f, -0.03719449f, -0.04699285f, -0.05344487f, 0.03214853f, 0.02987581f, -0.01292469f, 
    0.04693030f, -0.02968892f, 0.00521599f, -0.05768063f, -0.03175421f, 0.03778091f, 0.02239530f, -0.02864536f, 
    -0.04096525f, -0.06094774f, -0.03483065f, -0.03487060f, 0.02253086f, 0.01110428f, 0.01600884f, 0.00372020f, 
    0.03617367f, -0.06047135f, -0.04077142f, -0.02045662f, -0.03520950f, -0.00172721f, -0.03197638f, -0.00480704f, 
    -0.00758008f, -0.01648714f, -0.00286799f, -0.01653554f, -0.04859209f, 0.02101287f, -0.04314076f, 0.03215371f, 
    -0.00319897f, 0.04235325f, 0.05238123f, -0.04181886f, 0.03007945f, -0.02749839f, 0.04407950f, 0.04704712f, 
    -0.00066337f, -0.02309762f, -0.03978528f, -0.06230005f, 0.00296057f, 0.03649828f, 0.03318756f, -0.02610226f, 
    -0.00124364f, -0.02441230f, 0.03543182f, 0.04450461f, 0.00207072f, -0.05688781f, -0.01811882f, -0.06078300f, 
    0.03142067f, 0.05392877f, -0.02536493f, -0.04807925f, -0.02597575f, 0.00033533f, -0.00469952f, -0.01575813f, 
    0.02974506f, 0.03140681f, -0.02497886f, -0.05514412f, -0.00073930f, 0.02609095f, -0.04944418f, 0.01775503f, 
    -0.01027922f, 0.00798567f, 0.00621338f, 0.02725796f, -0.04285078f, -0.00200334f, -0.03306722f, 0.00621151f, 
    0.04671028f, 0.05367517f, -0.01605844f, -0.03917002f, -0.01561830f, 0.01112636f, 0.01589721f, 0.02971119f, 
    0.02093191f, 0.02001109f, -0.00979495f, -0.01860987f, -0.05731871f, 0.05022381f, -0.04554778f, -0.04875189f, 
    -0.01190768f, -0.05999652f, 0.03572842f, -0.06022480f, 0.00912696f, 0.05524691f, 0.00199038f, 0.04024244f, 
    -0.01134763f, -0.05272205f, -0.06913855f, -0.05448197f, -0.01813043f, 0.04806506f, -0.05253325f, -0.03290922f, 
    -0.01239058f, 0.03777602f, 0.01689567f, -0.05498764f, -0.01294819f, 0.01247662f, 0.05120097f, -0.05958026f, 
    0.02850766f, -0.04737107f, -0.02761796f, -0.01108395f, -0.05208504f, -0.01401564f, -0.02566024f, -0.04255250f, 
    -0.05864498f, -0.01373838f, -0.00735256f, -0.04796822f, -0.06367171f, 0.02257650f, -0.05941124f, -0.01684470f, 
    -0.03134584f, 0.02986412f, 0.00442787f, 0.02997564f, -0.02387678f, -0.04123741f, 0.00890898f, 0.01862948f, 
    0.00734504f, 0.01111363f, 0.01241735f, 0.04496855f, 0.00127454f, 0.00545889f, -0.01809912f, 0.05012323f, 
    0.00406114f, -0.03490676f, 0.03406570f, 0.00117228f, -0.01982396f, 0.05888757f, -0.03371646f, -0.02065379f, 
    -0.05658399f, -0.00864106f, -0.00317227f, -0.06703000f, 0.02416059f, -0.01594203f, 0.02153652f, -0.05691266f, 
    0.05323963f, -0.06590649f, -0.05464144f, 0.02613092f, 0.01814626f, 0.00623417f, 0.02764161f, 0.04564970f, 
    -0.06804837f, 0.05170377f, -0.06139591f, 0.01467755f, -0.03597116f, 0.03902344f, -0.00743823f, -0.02885016f, 
    -0.03115908f, -0.02343298f, -0.01949169f, 0.02788010f, 0.01494949f, 0.01100587f, 0.01861619f, -0.05055951f, 
    -0.05338605f, 0.00213536f, -0.02793629f, 0.02296121f, 0.01757141f, -0.00921310f, 0.00333980f, -0.07165004f, 
    -0.00502879f, -0.02519092f, 0.04044339f, -0.00562542f, -0.01204364f, 0.00155844f, -0.03497249f, -0.06607045f, 
    -0.00753559f, -0.04273992f, 0.01498656f, -0.05828763f, 0.02451064f, 0.01239532f, 0.03637871f, 0.04358124f, 
    0.01471745f, -0.03682720f, -0.03858715f, -0.00962642f, 0.04523592f, 0.01306610f, -0.05736102f, -0.00216373f, 
    0.02417238f, 0.00230920f, 0.00434726f, -0.01460133f, -0.05764487f, -0.06534471f, -0.03889327f, -0.05580557f, 
    -0.05987416f, 0.01260156f, 0.00141925f, 0.03554191f, -0.04479179f, 0.02858737f, -0.03910520f, 0.00510818f, 
    -0.00168449f, -0.05018106f, 0.03710049f, 0.01855021f, -0.00959794f, -0.05020084f, 0.04508643f, 0.04079980f, 
    0.04607887f, -0.02049949f, 0.01755005f, 0.00927536f, -0.00844201f, 0.03453263f, -0.03014422f, -0.03165953f, 
    -0.03044072f, -0.02014997f, -0.04293918f, 0.01129856f, -0.05383686f, 0.02804102f, 0.05106163f, -0.01994688f, 
    0.04161125f, -0.00310936f, 0.02590816f, -0.05691520f, 0.01482714f, 0.02767744f, 0.04020939f, -0.04249170f, 
    0.04952937f, -0.01908987f, 0.03738277f, -0.01152269f, -0.01164482f, 0.05398566f, -0.01555020f, 0.00384869f, 
    0.00459877f, 0.05050686f, -0.00087264f, -0.01093769f, -0.00480571f, -0.03917252f, 0.02647579f, 0.04570158f, 
    -0.01573717f, -0.05760352f, 0.00834954f, -0.05236771f, 0.00618136f, -0.02552315f, 0.00914093f, -0.06143440f, 
    -0.05924759f, 0.00355066f, -0.03044814f, -0.04859190f, -0.00488504f, 0.02781998f, 0.00702590f, 0.04850936f, 
    0.03634262f, -0.00542561f, -0.01475318f, 0.04094551f, -0.06389901f, -0.01918468f, 0.00684728f, 0.03541102f, 
    -0.05455105f, -0.02229567f, 0.02098838f, 0.03764303f, -0.06466777f, -0.00949172f, 0.02885479f, 0.01783922f, 
    -0.02976744f, -0.07646360f, 0.21104604f, 0.15099029f, -0.00038296f, 0.22929400f, -0.24429807f, 0.34716555f, 
    0.24694958f, -0.11583695f, 0.01761972f, -0.01471705f, -0.19914855f, -0.03658096f, 0.01408611f, -0.00551994f, 
    -0.04804371f, 0.34381756f, -0.23083009f, -0.16652845f, 0.09121228f, 0.21723343f, 0.17962214f, -0.06078863f, 
    0.16355984f, -0.02594706f, -0.50186414f, -0.06075875f, 0.21739027f, 0.04893577f, -0.05397586f, -0.00165908f, 
    -0.09421337f, 0.04334876f, 0.23381037f, 0.06411095f, -0.30021995f, -0.12349272f, -0.00470739f, 0.01566270f, 
    0.06693868f, 0.04012696f, 0.05972454f, 0.05847403f, 0.12311053f, 0.09972061f, 0.07843858f, -0.02352527f, 
    0.13524090f, -0.11480020f, -0.21670973f, 0.09963883f, 0.09853649f, -0.05821769f, 0.21054550f, 0.22013512f, 
    0.22833779f, 0.05644426f, -0.15808080f, 0.06305479f, 0.07623819f, 0.00673793f, -0.03413222f, 0.14043932f, 
    0.04475471f, 0.12191980f, 0.07481854f, -0.03949619f, 0.00704996f, -0.05562308f, 0.00638400f, -0.10095451f, 
    0.21267842f, -0.16699374f, 0.03862721f, 0.12104748f, 0.14888202f, 0.01635373f, -0.09979595f, -0.08147553f, 
    0.21539728f, 0.14086343f, -0.07320478f, 0.06619134f, 0.02368771f, 0.06767254f, 0.00087031f, -0.03845032f, 
    -0.15432914f, 0.18525253f, 0.14818293f, -0.01158486f, 0.03817552f, -0.12801014f, 0.13998424f, 0.01696597f, 
    0.07888719f, 0.19807260f, 0.11364345f, 0.06066488f, -0.38185680f, -0.04966658f, 0.09748600f, 0.05756301f, 
    -0.09630670f, 0.08528905f, 0.08492110f, -0.36609483f, -0.03887899f, 0.06543122f, -0.01468747f, 0.28602362f, 
    0.00236863f, -0.08991087f, -0.03723345f, 0.15089116f, -0.12449317f, 0.20839094f, 0.06729674f, -0.03960197f, 
    0.05438118f, -0.08315474f, 0.21728107f, -0.02188951f, 0.03652006f, -0.03971971f, -0.32210264f, -0.08936267f, 
    -0.00630533f, 0.14459401f, -0.00581486f, -0.05508857f, -0.00933641f, -0.06584462f, -0.16237487f, 0.30249709f, 
    0.11590390f, 0.17272308f, -0.01980410f, -0.15329574f, -0.07216308f, -0.02856382f, 0.00554288f, -0.14851198f, 
    0.14172991f, 0.19605023f, -0.13401847f, -0.05204903f, -0.18461898f, -0.10802551f, -0.01287293f, 0.21567225f, 
    0.15547827f, -0.05594623f, 0.15781792f, -0.15381254f, 0.12830995f, -0.05171776f, -0.13960408f, -0.05639060f, 
    0.19701616f, 0.06676837f, -0.30975598f, -0.17752174f, -0.01413900f, 0.08822957f, -0.12013867f, 0.30310261f, 
    0.06831171f, -0.04942601f, -0.05346105f, -0.37918299f, -0.27784073f, 0.06544473f, 0.00190500f, -0.04977580f, 
    -0.19586559f, -0.03651899f, 0.07429850f, -0.02416898f, -0.00413488f, 0.09339862f, 0.14203100f, 0.05563334f, 
    0.15865757f, 0.01336007f, 0.00632790f, -0.30853692f, -0.10806870f, 0.14087836f, 0.00936959f, 0.06469427f, 
    0.03734904f, 0.14391461f, -0.22892147f, 0.04875280f, -0.11006384f, -0.01128910f, 0.22166996f, -0.17739289f, 
    -0.11376242f, 0.05508879f, -0.15003358f, 0.08048753f, -0.16911066f, 0.11509230f, 0.01511613f, -0.05773713f, 
    -0.19230413f, -0.12997890f, 0.22312714f, 0.07785298f, 0.13926826f, -0.08530179f, -0.13132483f, -0.34340003f, 
    0.19767535f, -0.11371274f, 0.03777954f, 0.11843721f, 0.10640502f, 0.00787928f, -0.20333922f, 0.23376814f, 
    0.17929335f, 0.05803629f, -0.17995164f, -0.04717777f, -0.04654768f, 0.06285588f, 0.51785272f, 0.06941395f, 
    0.21856782f, 0.05242876f, -0.01490920f, -0.10766670f, -0.03448851f, -0.06792945f, -0.06191870f, 0.12824243f, 
    -0.14421323f, -0.02438745f, -0.01592087f, -0.10337618f, -0.17562479f, -0.04978837f, 0.06597552f, -0.17344496f, 
    -0.15308869f, 0.04485493f, 0.00044322f, 0.17432716f, -0.61161214f, 0.09968986f, 0.06861817f, 0.09720467f, 
    -0.01535858f, 0.10662378f, 0.00214363f, -0.04535434f, -0.04944928f, -0.10064672f, 0.17478095f, -0.03540088f, 
    0.11836220f, -0.25837049f, -0.10370696f, 0.02916615f, -0.18424259f, 0.09240479f, -0.17990480f, -0.07266469f, 
    -0.04484133f, 0.12695691f, 0.18430112f, 0.06125435f, 0.19604313f, -0.11196955f, -0.25399637f, 0.12419880f, 
    0.09576082f, 0.05093436f, 0.02655014f, -0.09166810f, 0.01774375f, -0.03001597f, 0.05913337f, 0.15852852f, 
    -0.28375754f, 0.04783415f, -0.11329036f, 0.14252394f, -0.18495470f, -0.19008769f, 0.24393372f, 0.19403724f, 
    -0.48552909f, -0.38566124f, -0.04192033f, -0.25218672f, 0.15850243f, 0.11625064f, -0.17920433f, 0.15294695f, 
    0.03832766f, 0.02438283f, 0.12775052f, -0.23047969f, 0.03005358f, 0.09924199f, 0.02356599f, 0.16073178f, 
    -0.02189979f, 0.25379804f, 0.16890852f, -0.36326140f, -0.13177912f, -0.36846396f, 0.02556476f, 0.04821724f, 
    0.09342346f, -0.17384605f, -0.13588415f, -0.28010356f, -0.00862715f, 0.11458042f, 0.16644192f, -0.01878975f, 
    0.07933286f, 0.02670644f, 0.04039562f, 0.13064273f, 0.12926552f, 0.03308649f, -0.09077491f, 0.10866520f, 
    0.12098118f, -0.05212088f, 0.19069865f, -0.13622060f, -0.06300692f, 0.16534838f, -0.24077465f, -0.36152002f, 
    0.10709433f, 0.17932767f, -0.03561972f, -0.02513555f, -0.16200653f, 0.00600638f, 0.10286583f, -0.34676427f, 
    -0.16078293f, -0.10871202f, 0.05269046f, -0.15892152f, 0.01979351f, -0.20068289f, 0.15377176f, -0.01742943f, 
    -0.16139488f, 0.20486608f, -0.05260583f, 0.10711668f, 0.14076744f, 0.20342250f, -0.07196493f, -0.15647164f, 
    -0.24382351f, -0.29191801f, 0.05061448f, -0.14633587f, 0.10143343f, 0.00209370f, 0.08807018f, -0.06950601f, 
    0.03622436f, 0.08093780f, 0.20954849f, 0.10836045f, -0.00095210f, 0.17186224f, 0.05562129f, -0.10836478f, 
    0.05756972f, 0.04763951f, -0.15684110f, 0.14325994f, 0.12016410f, -0.14490956f, 0.07290154f, 0.11385816f, 
    -0.01080513f, 0.16039900f, 0.22373068f, 0.17633134f, -0.35514101f, -0.05335904f, 0.03807744f, -0.15674473f, 
    -0.02045982f, -0.02917490f, -0.12783855f, 0.01119361f, 0.00724940f, -0.45004055f, -0.32173190f, 0.19082575f, 
    -0.02005144f, 0.02830010f, -0.13685013f, -0.16672537f, 0.10912007f, -0.13377501f, 0.17777668f, 0.16675527f, 
    0.11153997f, 0.09398156f, 0.02755584f, 0.43804333f, 0.06017000f, 0.08800275f, 0.12109805f, 0.55393672f, 
    -0.18529832f, 0.02609515f, 0.04755801f, -0.08741263f, 0.23255643f, -0.05808302f, 0.00947433f, 0.06989623f, 
    0.07231907f, -0.15821691f, 0.07587182f, 0.20291644f, 0.23606884f, 0.34431833f, 0.09698968f, -0.38558701f, 
    -0.07797658f, -0.19450217f, -0.00819283f, 0.02526293f, -0.19247717f, -0.09162363f, -0.04512493f, -0.06927546f, 
    0.04926093f, 0.05905312f, -0.05644300f, 0.21287890f, 0.20780617f, 0.03313744f, -0.00840270f, -0.18438141f, 
    0.30773017f, 0.19124652f, 0.05291620f, 0.00048032f, 0.23948988f, 0.08558619f, 0.13036515f, 0.04695733f, 
    0.24923047f, -0.09506274f, 0.07247935f, 0.22891225f, -0.42656156f, -0.19524981f, 0.05646352f, 0.07007513f, 
    -0.03897045f, 0.06321199f, -0.15108675f, 0.23985487f, -0.30422318f, -0.18052362f, 0.17927194f, -0.00934790f, 
    0.10168149f, -0.01039317f, 0.43068671f, -0.07997229f, -0.15324816f, 0.14122431f, -0.25101319f, 0.24879529f, 
    0.22410493f, -0.06546462f, 0.07880517f, -0.19327062f, 0.00246806f, 0.19054893f, -0.09212315f, 0.34140426f, 
    0.08216953f, 0.19795617f, -0.09723120f, -0.02131251f, -0.00594033f, 0.07409460f, 0.15020205f, 0.12507536f, 
    0.21016668f, 0.37841156f, 0.18784347f, 0.00209762f, -0.22959600f, 0.04918043f, 0.01091903f, 0.10646334f, 
    -0.15399522f, -0.11426307f, -0.38024589f, -0.12843421f, 0.15871882f, -0.12884493f, -0.24745142f, 0.08147489f, 
    -0.10077432f, -0.20972431f, -0.39825532f, 0.15839925f, -0.12190224f, 0.24350376f, 0.18853518f, 0.14361309f, 
    -0.04187539f, -0.01142680f, -0.11059345f, -0.05770959f, 0.03099027f, 0.15500002f, -0.09204728f, -0.02510736f, 
    -0.15124013f, 0.11547655f, -0.11932436f, -0.05968587f, 0.05987818f, 0.26017869f, 0.17458238f, 0.04533681f, 
    -0.17549352f, -0.05456811f, 0.07792243f, 0.22389002f, 0.12238395f, 0.02342791f, -0.24531950f, 0.15108241f, 
    0.19618998f, -0.08818170f, 0.27683383f, 0.00937942f, 0.01795128f, 0.09601073f, -0.06549452f, 0.07633042f, 
    0.12145577f, -0.01458630f, 0.08839133f, -0.05788086f, -0.12024085f, 0.01104387f, 0.12406405f, -0.01276139f, 
    0.30606616f, -0.26388574f, 0.07812358f, 0.01229522f, 0.18140009f, -0.12604739f, 0.07120161f, -0.10354016f, 
    0.43779811f, 0.09565020f, -0.07044730f, -0.01984191f, -0.15614484f, 0.19005279f, 0.12027901f, -0.07869075f, 
    0.21260431f, -0.10037652f, -0.16415465f, 0.35860473f, 0.22138558f, 0.05615335f, -0.03700241f, -0.02778788f, 
    0.39169052f, 0.19874229f, -0.04281538f, -0.42837045f, -0.07577485f, -0.05137663f, -0.01276186f, 0.00116035f, 
    -0.05780886f, -0.00547383f, 0.12434413f, 0.54030210f, 0.16023043f, 0.30441150f, -0.21130970f, -0.07836621f, 
    0.00541443f, -0.21042213f, -0.09730589f, -0.15029405f, -0.06960807f, 0.13157214f, -0.41179740f, -0.01165968f, 
    0.01380389f, 0.01897321f, -0.02816585f, -0.05485660f, 0.12191477f, -0.36987260f, -0.11752258f, -0.43159762f, 
    0.05048090f, -0.05561552f, -0.18684924f, 0.01795163f, 0.23835084f, -0.12701392f, -0.37021270f, -0.12566596f, 
    -0.35359302f, -0.09270385f, -0.18896748f, -0.01951161f, 0.04609232f, 0.02537629f, 0.14512721f, 0.29973036f, 
    -0.57603377f, 0.29412195f, -0.17768072f, -0.02329679f, 0.09329373f, -0.12038216f, 0.09387948f, 0.16751236f, 
    -0.18225537f, 0.27946433f, 0.36398685f, 0.07919972f, 0.00503950f, 0.09505659f, -0.03559102f, -0.16707960f, 
    0.02680378f, -0.33797228f, -0.15456247f, 0.39885736f, 0.11194050f, 0.02160839f, 0.05876464f, -0.03668132f, 
    0.18090233f, 0.26653329f, 0.17587836f, -0.24491717f, 0.19522449f, 0.02339038f, -0.15949838f, 0.17450479f, 
    -0.08905751f, -0.03993807f, 0.14858972f, 0.07619379f, 0.22001600f, -0.29030794f, 0.01045860f, 0.05151786f, 
    -0.12108983f, 0.24962351f, -0.16903411f, -0.00188747f, -0.08249501f, 0.51877546f, 0.22694932f, -0.01036574f, 
    -0.11924794f, -0.12831716f, -0.16686514f, 0.05449184f, 0.06562334f, -0.44445786f, -0.18900691f, -0.00168543f, 
    0.00158899f, -0.13600156f, 0.01958833f, -0.06419947f, 0.07403981f, 0.03415228f, 0.20709725f, 0.24025664f, 
    -0.00286117f, 0.03592352f, 0.02584071f, 0.02881085f, -0.03780958f, 0.01860005f, -0.19692869f, 0.26914877f, 
    -0.17039205f, -0.25848454f, -0.00913651f, 0.03598776f, 0.11450818f, 0.01975917f, 0.02830031f, -0.03216913f, 
    0.03078925f, 0.07826156f, 0.16951354f, 0.12424557f, -0.16049585f, 0.13381684f, -0.08957605f, -0.05006376f, 
    -0.07231095f, -0.33606932f, 0.24070685f, -0.37224966f, -0.00098133f, -0.10562225f, -0.03826679f, -0.12114696f, 
    0.09406842f, -0.07398631f, 0.28325072f, 0.08302857f, -0.13591436f, 0.00625041f, -0.11507760f, 0.06703282f, 
    0.07496456f, 0.07044026f, 0.19487150f, -0.05002936f, 0.33772972f, -0.28303820f, 0.18992859f, -0.00661427f, 
    -0.13764118f, -0.13144952f, -0.16622211f, -0.12598953f, -0.06537285f, 0.07854796f, 0.46215796f, 0.12180708f, 
    -0.07963367f, 0.22732107f, -0.05662451f, -0.04762795f, -0.20500286f, 0.06077103f, 0.02431357f, -0.48672035f, 
    0.07595252f, -0.03644770f, -0.21998885f, 0.14016286f, 0.11323481f, 0.04518851f, -0.36030337f, 0.37466016f, 
    -0.08668593f, -0.08982337f, 0.07077441f, -0.02081074f, -0.10274691f, -0.00154432f, 0.05237530f, 0.24587268f, 
    -0.10620957f, -0.00376509f, -0.06288388f, -0.01519023f, -0.04147136f, -0.10200703f, -0.01924750f, -0.04291657f, 
    0.12103848f, 0.18911487f, 0.15378575f, -0.01819934f, 0.15205061f, -0.17004342f, 0.17447774f, 0.03654813f, 
    0.10121901f, 0.03871686f, 0.06515519f, -0.00363728f, 0.00922618f, 0.04763219f, 0.17445858f, 0.03730287f, 
    0.02683537f, 0.12758498f, 0.02996079f, 0.02332430f, 0.50172597f, -0.01839699f, 0.13881825f, 0.01699018f, 
    -0.05926389f, 0.09876664f, 0.16080764f, -0.05305541f, 0.26868576f, -0.24115199f, 0.04637675f, -0.04757731f, 
    -0.05422192f, -0.09892821f, -0.09892108f, -0.11885642f, 0.72078860f, 0.26302135f, 0.17969784f, 0.10784183f, 
    0.07277201f, -0.04705812f, 0.18512690f, 0.11430752f, 0.10084355f, -0.25438115f, -0.10661093f, -0.53934538f, 
    -0.09503017f, 0.00275563f, -0.03081917f, -0.12805153f, -0.10559785f, -0.17928071f, -0.26029885f, -0.04220739f, 
    -0.08056614f, 0.01951722f, -0.03324331f, -0.03456928f, 0.04992207f, 0.06670607f, -0.07420135f, 0.15508133f, 
    -0.12293705f, -0.08905439f, -0.03661860f, 0.06264168f, -0.01025844f, -0.04216995f, -0.08751319f, -0.12020394f, 
    -0.29703429f, 0.06576248f, -0.09529643f, 0.07826223f, 0.01027146f, -0.01594204f, 0.19928543f, 0.10905712f, 
    -0.05367241f, -0.35432315f, -0.05498321f, -0.16280156f, -0.29521123f, -0.07341471f, 0.02342522f, 0.06588021f, 
    0.12154304f, 0.04032300f, -0.00830467f, -0.20807852f, 0.19386874f, -0.02307900f, 0.00122350f, 0.03178287f, 
    0.00373327f, -0.00518949f, -0.17161423f, 0.05973605f, -0.00784948f, -0.20863052f, -0.08577389f, -0.07742351f, 
    -0.11291270f, -0.08082121f, 0.25752378f, -0.15652935f, 0.20591937f, 0.09187652f, 0.05735636f, 0.02234235f, 
    0.01399229f, 0.04611981f, 0.19156435f, -0.00719764f, 0.01441022f, 0.13652186f, 0.16846320f, 0.05317050f, 
    -0.00270842f, 0.09228311f, 0.04259444f, 0.12195730f, -0.08946826f, -0.11891285f, -0.26621926f, -0.32906216f, 
    -0.05724177f, -0.23861624f, -0.14083195f, 0.01471444f, -0.01189699f, 0.09827434f, 0.28109643f, -0.17852984f, 
    -0.35065368f, -0.28715572f, 0.00950126f, 0.04243681f, -0.06828211f, -0.12845616f, -0.09035444f, -0.15621722f, 
    -0.15306653f, -0.03920801f, -0.36654818f, 0.04085483f, 0.09161825f, -0.09531200f, 0.10712810f, -0.00725400f, 
    -0.06365389f, -0.42858145f, -0.12375065f, -0.03978021f, -0.08004079f, -0.06427832f, -0.00164043f, 0.08588936f, 
    0.11982620f, 0.00145119f, 0.39236939f, -0.09306537f, -0.28745446f, 0.09629449f, -0.03382848f, 0.02666078f, 
    -0.21584766f, 0.09501678f, -0.02787423f, 0.16850758f, 0.14575188f, 0.07865963f, -0.07258577f, 0.09694599f, 
    0.10777538f, -0.02329094f, -0.01101802f, -0.02562802f, 0.15019774f, 0.06284130f, 0.31757212f, 0.16411932f, 
    0.04853299f, -0.01463407f, 0.09494419f, -0.06748596f, 0.04205180f, -0.35083786f, -0.52342659f, 0.21192047f, 
    -0.11641954f, -0.02049325f, -0.02869205f, -0.23569965f, 0.06143393f, -0.14722200f, 0.31523737f, 0.11051502f, 
    0.12415320f, 0.00318560f, 0.21238649f, 0.27398238f, 0.05800565f, 0.14302762f, -0.07287931f, 0.52346504f, 
    0.04563880f, -0.47295555f, -0.07930905f, -0.23029609f, 0.33860013f, 0.29635060f, 0.09511425f, 0.10974007f, 
    -0.01102459f, -0.16481301f, -0.10396932f, 0.03093077f, 0.16980673f, 0.13338886f, 0.16360155f, 0.05844567f, 
    0.06447070f, 0.25633743f, 0.05122085f, -0.08467846f, 0.18679923f, 0.08948390f, 0.00188902f, -0.07895972f, 
    0.02515689f, 0.05681282f, -0.27518678f, 0.01555707f, -0.01962168f, 0.21355964f, 0.05617160f, 0.18246868f, 
    0.07367561f, -0.08962609f, -0.03795328f, 0.38993043f, 0.40378562f, 0.11078384f, -0.09415023f, -0.02309286f, 
    -0.03791692f, -0.04719024f, 0.00683383f, 0.04357398f, -0.17102505f, -0.10248610f, -0.00973621f, 0.00544998f, 
    -0.00484300f, -0.08677386f, 0.17083636f, -0.30238882f, 0.07932920f, 0.23193188f, 0.27558729f, -0.07603840f, 
    -0.03599454f, 0.07761003f, 0.33593470f, 0.01923656f, -0.19786918f, -0.04052956f, 0.02912312f, -0.15604195f, 
    0.39135820f, 0.09871645f, -0.16657591f, -0.02363062f, 0.17783470f, -0.14684510f, 0.12131205f, -0.36201173f, 
    0.00169524f, 0.33737254f, 0.01657971f, 0.00778838f, -0.05325297f, 0.00391433f, -0.12833011f, -0.31056139f, 
    -0.00899371f, 0.03615681f, 0.08566757f, -0.04768576f, 0.22140242f, 0.19665696f, -0.02988738f, -0.16910081f, 
    0.06900309f, -0.09316559f, -0.73463738f, -0.48659834f, -0.00266536f, 0.11552921f, -0.09525594f, -0.05998497f, 
    -0.25086647f, -0.06065042f, -0.46011275f, -0.02651865f, -0.36769527f, 0.05154114f, 0.19745976f, 0.03062005f, 
    -0.16320905f, 0.12676947f, -0.09815849f, 0.09459087f, 0.00549515f, 0.01189527f, 0.02166823f, 0.05888109f, 
    -0.14947887f, 0.03361053f, 0.01667355f, -0.19696610f, -0.20662396f, 0.17792372f, 0.28006074f, 0.02778008f, 
    0.11193458f, -0.07594521f, -0.05283623f, 0.21225648f, 0.01056909f, 0.11136627f, -0.09624794f, 0.09344798f, 
    0.03052740f, 0.08345231f, -0.20414641f, -0.04186397f, -0.26995012f, 0.02564717f, 0.22797896f, 0.10582371f, 
    0.11496955f, 0.06489655f, 0.13472304f, -0.09735787f, -0.08795941f, -0.13335097f, 0.17857346f, -0.05112756f, 
    0.15224937f, -0.54972434f, 0.13798828f, 0.04569462f, 0.15910269f, -0.03030846f, 0.14139539f, 0.12229624f, 
    -0.05504133f, 0.02979741f, -0.06119056f, 0.03129031f, -0.01399761f, 0.03195922f, 0.04013854f, -0.05428281f, 
    -0.03642896f, -0.05761921f, 0.04646168f, -0.05237667f, 0.04698011f, 0.05244596f, -0.02183589f, -0.01302661f, 
    -0.04138461f, 0.03815006f, -0.02454162f, -0.02609190f, -0.00681868f, -0.01204725f, -0.04784092f, 0.04615968f, 
    0.02007245f, -0.03107892f, -0.01817657f, -0.03912392f, -0.00018836f, 0.04634920f, -0.03353446f, 0.00309881f, 
    -0.04449136f, 0.00916268f, -0.04565211f, 0.05133170f, -0.04684473f, -0.06236384f, -0.05942537f, -0.06026538f, 
    -0.01295803f, 0.02916925f, 0.04827285f, -0.00860800f, 0.02236487f, -0.04993313f, -0.03487816f, -0.04313430f, 
    -0.01285346f, 0.00233998f, -0.00181782f, -0.00085213f, 0.02981906f, 0.02588373f, -0.04658987f, 0.00740094f, 
    -0.05771145f, -0.04163673f, -0.01841734f, -0.00061925f, -0.03636735f, -0.02942189f, 0.01867669f, -0.04815346f, 
    0.01185548f, -0.02444793f, -0.03334232f, -0.05138072f, -0.06336206f, 0.00874403f, 0.04987535f, 0.02949643f, 
    -0.03346537f, -0.04696266f, -0.05534001f, 0.01820702f, -0.03814533f, -0.03908747f, 0.01086013f, 0.03205336f, 
    0.00011026f, 0.00043154f, -0.06309837f, 0.00158469f, -0.02252229f, 0.05073693f, -0.04943788f, -0.00597755f, 
    -0.05403553f, -0.03381547f, 0.00278668f, 0.04846852f, -0.01045812f, -0.05524015f, -0.01174529f, 0.01718579f, 
    -0.00822974f, 0.01438778f, 0.03901543f, -0.03956561f, -0.02770755f, -0.04329519f, 0.05544795f, 0.01916503f, 
    -0.00846849f, -0.05290745f, 0.01123746f, -0.00789983f, -0.00333767f, -0.05033989f, 0.03383088f, 0.01896880f, 
    -0.05066057f, 0.02228699f, 0.02968566f, 0.04703077f, 0.03765162f, -0.00451378f, -0.00175425f, 0.04722920f, 
    -0.00700391f, -0.00711984f, -0.06230406f, -0.02028772f, -0.04726967f, 0.00446182f, -0.00079069f, -0.04584884f, 
    -0.02220271f, 0.00763690f, 0.01644511f, 0.01593213f, 0.00453541f, 0.02496375f, -0.01202167f, -0.04371062f, 
    0.00573370f, -0.05568628f, 0.02110745f, -0.01439409f, 0.05210230f, -0.03885933f, -0.05911009f, 0.02332667f, 
    -0.01372807f, 0.01644440f, 0.04375324f, 0.01964773f, 0.03278947f, -0.00788704f, -0.03751248f, -0.02454601f, 
    -0.04981328f, 0.01669711f, -0.02943495f, -0.02034191f, -0.02536269f, -0.05753896f, -0.03091331f, 0.03843443f, 
    0.01655278f, 0.04994013f, -0.01136379f, 0.02921805f, -0.06139569f, 0.00508654f, 0.01652352f, 0.04238179f, 
    -0.02494576f, -0.01860364f, -0.04675911f, 0.04796421f, -0.06081247f, 0.00259426f, 0.02794331f, 0.03851519f, 
    -0.04707117f, -0.01370511f, 0.02837299f, -0.05102720f, 0.00511655f, -0.05544743f, -0.05926843f, -0.05792440f, 
    -0.05860774f, 0.03403302f, -0.01136018f, 0.03106235f, 0.01496045f, -0.04818004f, -0.04008789f, -0.02513874f, 
    0.00088384f, -0.03018407f, -0.01687788f, -0.05491649f, -0.04484273f, 0.04625418f, -0.01802155f, 0.00206142f, 
    0.00733320f, 0.03092485f, -0.01933577f, 0.02089679f, 0.01425398f, 0.00498723f, 0.03487450f, 0.04767486f, 
    -0.03701680f, 0.05019180f, -0.03888302f, 0.04385185f, -0.05473519f, -0.01971318f, -0.02768917f, -0.00775965f, 
    -0.01296676f, 0.03437775f, 0.03096760f, -0.05652831f, 0.00255891f, -0.02455794f, 0.02770033f, -0.03057430f, 
    -0.01925216f, -0.00303850f, 0.02757636f, -0.02359815f, -0.06259613f, -0.03907714f, -0.03549314f, -0.06217995f, 
    0.04137264f, -0.00672890f, 0.03048461f, -0.00206162f, -0.02684442f, -0.00044482f, 0.02033506f, -0.04303628f, 
    -0.04134492f, -0.05136618f, 0.00829894f, 0.02729703f, 0.01836730f, -0.00585891f, -0.00314426f, -0.02567728f, 
    -0.00854463f, -0.01596345f, -0.03209488f, -0.02527340f, -0.05343498f, -0.03353104f, 0.00028167f, -0.00031498f, 
    0.02489878f, -0.00503316f, -0.00253014f, -0.03724294f, -0.06350511f, -0.05016702f, -0.05448942f, 0.03325418f, 
    -0.02391226f, -0.04881665f, 0.01521730f, 0.02089143f, 0.02987019f, -0.03989066f, -0.02915125f, 0.03953214f, 
    -0.01236960f, -0.01762066f, -0.00905500f, 0.00938623f, -0.00036730f, 0.01476272f, -0.06052997f, -0.04880894f, 
    0.02563321f, -0.02408387f, 0.04412511f, -0.03109011f, -0.02576836f, 0.02461344f, -0.00072419f, -0.02519313f, 
    0.51273972f, 0.26882806f, 0.16549623f, -0.07751270f, -0.01324231f, 0.07257032f, -0.13625321f, -0.13724975f, 
    -0.14106555f, 0.38700402f, 0.29035631f, 0.20012000f, 0.18467493f, 0.14082903f, -0.08036084f, -0.05147716f, 
    0.13941167f, 0.02248193f, 0.01433346f, -0.08045988f, 0.06852448f, -0.11686613f, -0.16015723f, 0.01543280f, 
    -0.08981230f, 0.13482285f, -0.12627490f, 0.44576687f, 0.18625551f, 0.01716817f, 0.00680942f, -0.05648858f, 
    -0.24924387f, -0.12506607f, 0.18404567f, -0.12694401f, -0.22900814f, -0.12523529f, -0.04633093f, -0.10118869f, 
    -0.05567289f, 0.12942891f, -0.07297591f, 0.02431673f, -0.02533409f, -0.27306482f, -0.18663709f, -0.07535584f, 
    -0.27149633f, -0.10006401f, 0.12796080f, -0.12785964f, 0.00556331f, -0.24606000f, 0.16410924f, 0.02711252f, 
    0.33439007f, -0.09685694f, 0.05838238f, 0.04909663f, -0.20621075f, -0.25423479f, 0.14538692f, -0.15550561f, 
    0.03369588f, 0.00520401f, 0.17975044f, -0.08505885f, -0.01539869f, -0.22785729f, 0.09187625f, 0.07700018f, 
    0.16189453f, 0.21677567f, 0.15883115f, 0.00970744f, -0.09374532f, 0.16312107f, 0.10790452f, -0.09059700f, 
    -0.17896199f, 0.26784346f, 0.11962698f, 0.10844126f, 0.06018526f, 0.14931595f, 0.06782103f, 0.00528882f, 
    -0.06401657f, 0.02740346f, 0.24639992f, 0.23947373f, 0.27916688f, 0.16195603f, -0.02768560f, -0.04368348f, 
    -0.14640591f, -0.01910066f, 0.29002500f, 0.06385471f, -0.31036079f, -0.22925612f, -0.17422181f, -0.19315737f, 
    -0.08748609f, -0.04414898f, -0.04546512f, -0.05022683f, 0.17817529f, 0.42407688f, -0.41529748f, -0.00400198f, 
    -0.16181131f, 0.10776687f, 0.18971014f, -0.03871783f, 0.08455808f, 0.15354231f, 0.07641715f, 0.03369462f, 
    0.04955855f, 0.08891252f, -0.09081274f, 0.01620718f, -0.10672958f, -0.19015087f, -0.04164316f, 0.02216870f, 
    -0.28101239f, -0.01307518f, -0.18961892f, -0.01174177f, 0.12969668f, -0.05268855f, 0.02338037f, 0.28538731f, 
    -0.16353187f, -0.24171630f, 0.02781233f, 0.00425172f, 0.00308562f, -0.06572932f, -0.06450047f, -0.05441283f, 
    0.05984125f, 0.17484643f, -0.03945847f, -0.17228389f, -0.10960829f, -0.11706118f, 0.00317697f, 0.17692183f, 
    -0.24570696f, -0.18465418f, -0.37253562f, 0.02138269f, -0.14110488f, -0.15226121f, 0.01362716f, -0.02768678f, 
    -0.23073781f, -0.04144599f, -0.01663184f, 0.03365859f, 0.02525960f, 0.05603275f, -0.02468708f, 0.05912364f, 
    0.11011675f, -0.01333220f, 0.10039984f, 0.17895757f, -0.06590675f, -0.08481070f, -0.04175915f, -0.10590962f, 
    -0.01964313f, -0.13841946f, 0.19283520f, 0.18065645f, -0.05105835f, 0.31641343f, 0.12606648f, 0.07164371f, 
    0.18365179f, 0.05326802f, -0.04337437f, 0.08048664f, -0.08179526f, 0.24823432f, -0.43065903f, -0.04941074f, 
    -0.09562721f, -0.12876223f, -0.00622009f, -0.00612593f, -0.01606432f, 0.09772737f, -0.02682801f, 0.37962854f, 
    -0.08328134f, -0.00804063f, -0.22792655f, -0.03580099f, 0.10190121f, -0.11017545f, -0.11159319f, -0.49199450f, 
    -0.01473133f, 0.02888760f, 0.15782280f, 0.22452392f, -0.21813312f, 0.16731961f, -0.20022689f, -0.10079522f, 
    0.32130834f, 0.17442638f, -0.04378930f, 0.18569934f, -0.05817845f, -0.01356256f, -0.02642603f, 0.04659815f, 
    0.17307612f, 0.16435228f, 0.30407825f, 0.09156001f, 0.35357556f, 0.25045675f, -0.29750365f, -0.15518764f, 
    0.17823882f, 0.24810150f, 0.21847786f, 0.21713562f, 0.43426967f, 0.15283942f, 0.02403397f, -0.00373692f, 
    0.10465310f, 0.01355042f, 0.03229165f, -0.06091921f, 0.09006410f, 0.16580726f, -0.13790715f, -0.14774154f, 
    -0.15059520f, -0.05896843f, -0.09656837f, -0.13241722f, 0.27135295f, 0.16602246f, -0.03683883f, 0.06172100f, 
    -0.05002671f, -0.01476460f, -0.03694231f, 0.12159118f, -0.14925888f, -0.30313662f, -0.01080003f, -0.03769211f, 
    -0.12887377f, -0.08967385f, -0.04459042f, -0.06868270f, -0.13559088f, -0.28676695f, 0.06989648f, -0.12836844f, 
    0.02798207f, -0.25997669f, -0.16552615f, 0.01155295f, -0.15863428f, 0.00277220f, 0.04287773f, -0.02654040f, 
    -0.34799331f, 0.12378249f, -0.22578600f, -0.06442621f, 0.07620422f, -0.13606304f, -0.08367597f, -0.13481039f, 
    0.06085142f, -0.71473885f, -0.13191487f, -0.02211668f, 0.08877133f, -0.11003903f, 0.01892852f, 0.09592360f, 
    -0.02739022f, 0.10966823f, -0.51124167f, 0.05306573f, 0.19642596f, 0.17695408f, -0.02310375f, 0.25056985f, 
    0.04784692f, 0.03059210f, 0.44181296f, 0.14310083f, -0.25807136f, -0.02146793f, -0.33419767f, 0.05284643f, 
    -0.20423748f, -0.11815768f, 0.08553192f, -0.87900388f, -0.33959311f, 0.11207611f, 0.26339650f, 0.28813392f, 
    0.05625741f, 0.05552506f, 0.11860401f, -0.10785180f, 0.02374308f, -0.18284452f, 0.12786603f, -0.06681998f, 
    0.07191578f, 0.00783793f, 0.06275623f, 0.04474511f, 0.06394520f, 0.10003559f, 0.19555002f, -0.18082224f, 
    0.18941057f, 0.03145296f, 0.09604917f, -0.16516230f, 0.09129328f, -0.00619601f, -0.17897235f, -0.20324390f, 
    -0.74932450f, 0.09650875f, 0.25115013f, 0.03283239f, 0.03491299f, -0.06928536f, -0.01869099f, 0.53314483f, 
    0.16513929f, -0.09335846f, 0.07264163f, 0.09067024f, -0.09752773f, 0.09379064f, 0.11574225f, 0.13712960f, 
    0.03084332f, -0.15960565f, -0.13642113f, 0.09484825f, 0.07060684f, 0.06295680f, 0.08684044f, 0.00455105f, 
    -0.06289088f, 0.65977436f, 0.28343576f, -0.00768626f, 0.32661784f, 0.06533008f, 0.11008140f, -0.02397274f, 
    -0.05230870f, -0.03227672f, 0.20462814f, 0.05008750f, 0.03872702f, 0.04390670f, 0.08418496f, 0.01227622f, 
    0.18995939f, 0.02063980f, 0.24017297f, -0.14755337f, -0.04410563f, -0.35789597f, 0.03892177f, 0.01991649f, 
    0.03541594f, -0.06534339f, 0.02851538f, 0.09195058f, -0.36987966f, -0.22275308f, -0.04213796f, -0.27388608f, 
    -0.15850843f, -0.02174891f, 0.01154202f, 0.06566155f, 0.02543787f, 0.80604863f, -0.06169190f, -0.26126096f, 
    0.20508400f, 0.04069967f, -0.00021300f, 0.06228234f, -0.08100854f, -0.12985303f, -0.05493676f, 0.00146379f, 
    -0.17367524f, -0.32995027f, -0.11508979f, 0.14922056f, -0.12060622f, 0.05437115f, 0.13609998f, 0.06605581f, 
    0.11828011f, 0.17073482f, 0.04177399f, 0.10852025f, -0.08959155f, -0.05519042f, 0.06979891f, -0.11047956f, 
    -0.11183404f, -0.29530677f, 0.11222017f, 0.01623773f, 0.14851783f, 0.22132249f, -0.01460608f, -0.23157330f, 
    0.00230445f, 0.35326520f, -0.33317900f, 0.10689086f, -0.20367961f, 0.01808991f, 0.03947612f, -0.15745963f, 
    0.09171560f, 0.00418245f, -0.19014674f, -0.21403083f, 0.24892271f, -0.13717583f, 0.02634029f, -0.06810808f, 
    -0.03561440f, 0.07856366f, 0.04817393f, -0.24945958f, 0.00658806f, 0.00065568f, -0.00184017f, 0.03515793f, 
    0.03424876f, 0.12969770f, -0.09955645f, 0.05338104f, 0.03704062f, -0.14589372f, 0.16800277f, 0.12141707f, 
    -0.14856337f, -0.17956282f, 0.05035716f, 0.31430948f, 0.16661403f, -0.14554445f, -0.11208954f, -0.08100944f, 
    -0.00368789f, 0.05784752f, 0.08369347f, -0.19464026f, -0.07762498f, -0.10733910f, -0.11341671f, -0.35589284f, 
    0.04449183f, -0.02612421f, 0.10255418f, -0.11713591f, 0.05164417f, 0.05139076f, 0.10893938f, 0.36850950f, 
    0.14868744f, 0.03725630f, 0.14181343f, -0.08157569f, -0.14269793f, -0.04840837f, -0.05618414f, -0.09111632f, 
    0.01578733f, 0.09026778f, -0.06910437f, -0.00022880f, 0.04020022f, -0.14804989f, 0.18084243f, 0.03473347f, 
    -0.05598245f, 0.00772614f, 0.07329021f, 0.11918884f, 0.06019774f, -0.03005983f, -0.05681653f, 0.16821650f, 
    0.20310570f, -0.25374866f, 0.25622836f, -0.27752700f, 0.26887256f, -0.01174024f, -0.06701104f, -0.07416979f, 
    0.03265652f, -0.01706759f, 0.10903151f, 0.12505533f, -0.28078547f, 0.16882488f, -0.09697772f, 0.21446159f, 
    -0.05528163f, 0.10824339f, -0.16016497f, -0.02487964f, 0.01217640f, 0.06852705f, 0.02930190f, -0.00001764f, 
    -0.02123978f, -0.07940160f, 0.00389252f, 0.01796290f, 0.11376076f, -0.32320279f, -0.03983690f, -0.53736621f, 
    0.19364119f, 0.08471522f, 0.17201860f, -0.10841872f, -0.11893878f, -0.11979918f, 0.09399626f, -0.12943818f, 
    -0.21158530f, 0.12023488f, -0.09709624f, 0.04470621f, -0.18409778f, -0.22094597f, -0.09556337f, -0.17227879f, 
    0.09582146f, -0.16201226f, -0.08297487f, 0.10006009f, 0.29861325f, -0.08928889f, 0.20687672f, 0.08693936f, 
    0.05548629f, 0.15064606f, 0.00305018f, 0.10330950f, -0.19213907f, 0.09056398f, 0.27418989f, 0.14180160f, 
    0.06493603f, 0.10656482f, 0.26509494f, -0.04034669f, 0.19061233f, 0.04892068f, 0.13238005f, 0.09132037f, 
    -0.11285555f, 0.22484708f, -0.33002365f, 0.03457994f, -0.02327749f, 0.08841030f, 0.05176311f, -0.18543804f, 
    0.12140421f, -0.06103366f, -0.24321198f, -0.01354006f, -0.07059837f, -0.30687925f, -0.10529584f, -0.21897022f, 
    0.17326583f, -0.16766146f, 0.09024490f, -0.06116736f, 0.15629858f, 0.03319363f, 0.20255621f, -0.00522682f, 
    0.18574415f, -0.05132998f, 0.06210901f, 0.05687612f, 0.06720635f, -0.12815586f, 0.22145279f, 0.13337272f, 
    -0.15148176f, 0.13463487f, -0.03990310f, -0.01973175f, 0.14572100f, 0.12285972f, 0.30279976f, 0.16340886f, 
    0.20439950f, -0.03099094f, -0.01971232f, -0.07366151f, 0.04788248f, 0.23873436f, 0.16797526f, -0.19271392f, 
    -0.10982028f, -0.08976144f, 0.17343280f, -0.01247263f, 0.02531841f, -0.06558345f, -0.13191564f, 0.00711841f, 
    -0.23387045f, -0.36257714f, 0.03800896f, 0.24683000f, 0.28041708f, -0.12805532f, 0.02324810f, 0.06195208f, 
    0.25553358f, -0.68423891f, -0.09480187f, -0.17855617f, 0.17588328f, 0.18472815f, 0.02020121f, 0.03758300f, 
    -0.03821835f, 0.04521299f, -0.61161613f, -0.13939255f, -0.29092780f, 0.17729336f, 0.11804161f, 0.14561076f, 
    -0.00097343f, 0.16033334f, -0.10111590f, 0.12747589f, -0.15840539f, -0.03205163f, -0.02407510f, 0.04519055f, 
    -0.05116859f, 0.13782223f, 0.09740227f, 0.06766026f, -0.33920172f, -0.04430679f, 0.16834563f, -0.17166890f, 
    -0.02599629f, 0.05267083f, -0.09398378f, 0.02971194f, -0.20340191f, -0.82246226f, 0.34804976f, 0.28314608f, 
    0.08258437f, 0.02613091f, 0.36594829f, 0.06379840f, -0.22956838f, 0.02740619f, -0.17691247f, -0.13231471f, 
    0.15410446f, 0.13468711f, 0.01833067f, -0.12534720f, 0.17918718f, 0.08635273f, -0.12296263f, -0.42134890f, 
    -0.32367077f, -0.54038048f, -0.19317336f, 0.04796357f, 0.04891392f, 0.23281534f, -0.12768765f, -0.12232540f, 
    -0.01132777f, 0.15842550f, -0.02518372f, 0.27687395f, 0.05032254f, -0.03133383f, 0.08010209f, 0.10613479f, 
    0.18380375f, -0.04715989f, 0.11532230f, -0.03708309f, 0.12713125f, -0.13061410f, 0.06097954f, 0.18628262f, 
    0.03328468f, 0.11819501f, 0.30106807f, -0.00777888f, 0.01785799f, 0.11777539f, 0.05573111f, -0.05042863f, 
    0.06014298f, -0.03866743f, -0.07038641f, -0.26515883f, 0.24511142f, 0.19193844f, -0.14066617f, 0.24587001f, 
    -0.01955120f, -0.04858967f, -0.02743562f, -0.07808987f, -0.10569236f, -0.16607018f, 0.01072822f, 0.22570647f, 
    -0.04080880f, -0.10576199f, -0.27872056f, 0.07875048f, 0.13277194f, -0.06743468f, 0.07273675f, 0.02732669f, 
    -0.36648005f, 0.24585947f, -0.08997984f, 0.18740310f, 0.09312261f, 0.26767090f, -0.12969272f, -0.09099969f, 
    0.07074473f, -0.25297004f, 0.08790801f, -0.09730675f, -0.09981299f, -0.03540612f, 0.01633895f, -0.10922045f, 
    0.17510757f, -0.04117764f, 0.20248300f, -0.03154384f, 0.02517207f, -0.10418744f, -0.17458270f, -0.11248658f, 
    -0.06366842f, 0.02949371f, -0.16565569f, 0.09588052f, -0.08845162f, -0.07671600f, 0.00492504f, 0.09043006f, 
    0.17592137f, 0.13940185f, 0.02698687f, 0.17227015f, 0.23634370f, 0.00475722f, 0.59132272f, -0.17335366f, 
    -0.05006734f, 0.04403539f, -0.46217534f, -0.51803690f, -0.41518116f, 0.36712453f, 0.35050765f, -0.17970613f, 
    -0.00362898f, -0.11884695f, -0.12559761f, -0.00288283f, -0.04459849f, 0.12178170f, -0.40283880f, -0.03361648f, 
    -0.13816048f, -0.19685562f, 0.00801964f, 0.08399664f, -0.44094697f, 0.11135781f, 0.22913040f, 0.10813192f, 
    0.10563848f, 0.04199772f, 0.01745212f, -0.00328707f, -0.04514111f, 0.00792724f, 0.29678518f, 0.16345483f, 
    -0.05238841f, -0.04235749f, 0.17524722f, 0.20252405f, 0.12643783f, -0.08469836f, 0.15402572f, 0.20379016f, 
    0.18106379f, 0.07089854f, 0.24023889f, -0.14234222f, 0.14910042f, 0.20718327f, 0.05710668f, 0.21187298f, 
    -0.36130419f, -0.22929409f, -0.03407126f, -0.03277025f, -0.11353757f, 0.08850846f, 0.00686322f, 0.09499345f, 
    0.00361556f, -0.01482758f, -0.02858781f, -0.05748395f, 0.02270603f, -0.01211711f, -0.00637785f, -0.00557154f, 
    0.05059272f, -0.03216156f, 0.02249884f, -0.04454675f, 0.03677920f, 0.02267237f, 0.02683433f, 0.05055015f, 
    0.01239458f, -0.03342503f, 0.01024556f, -0.03988357f, 0.03433025f, 0.02932413f, -0.05045946f, -0.06386191f, 
    -0.06123135f, -0.01936389f, -0.01265508f, 0.06239171f, -0.04176155f, -0.04450203f, 0.04799469f, -0.00447139f, 
    -0.00771448f, 0.01381717f, -0.00173807f, -0.04768418f, 0.03921437f, 0.02176637f, -0.01349248f, 0.00021442f, 
    -0.01285301f, 0.00548601f, -0.02798551f, -0.04997591f, 0.00269819f, 0.00069696f, 0.04274907f, 0.02529295f, 
    0.04664748f, -0.00415892f, 0.02504913f, -0.03934399f, 0.01232376f, 0.00632845f, -0.05810795f, 0.02714403f, 
    -0.01198643f, 0.04965304f, 0.04234507f, -0.04374106f, -0.02406474f, 0.01052267f, 0.04068366f, -0.00437293f, 
    -0.01613012f, -0.00950522f, -0.00075504f, -0.06076084f, -0.03733452f, -0.05057776f, 0.04929397f, -0.04712936f, 
    0.06269867f, 0.03702569f, 0.04107251f, -0.04059296f, -0.05211835f, 0.00678915f, -0.04412298f, 0.00577528f, 
    -0.00099675f, 0.06111079f, -0.01752917f, -0.05185373f, -0.03875908f, 0.01532447f, -0.00388760f, -0.02073774f, 
    0.00199378f, -0.01263096f, 0.03872392f, 0.03011024f, -0.05887643f, 0.02435476f, -0.03535049f, -0.01197034f, 
    -0.03708736f, 0.02226838f, 0.01813864f, -0.01313044f, -0.01179762f, -0.04644272f, 0.03782903f, -0.05138048f, 
    -0.00741722f, -0.03891550f, 0.01684074f, -0.06529924f, -0.02343012f, -0.02745169f, -0.00715670f, 0.02324636f, 
    -0.00423085f, 0.00120528f, -0.02985446f, 0.04875569f, 0.01394944f, -0.03937453f, -0.03376503f, 0.00743036f, 
    -0.01579622f, 0.03459696f, 0.01735473f, 0.04174466f, -0.05683457f, 0.03785210f, -0.06957079f, -0.06247222f, 
    -0.05962025f, -0.04461908f, -0.06062805f, -0.01028966f, -0.00836598f, -0.02720337f, 0.01702885f, -0.05657337f, 
    0.02422212f, 0.04600699f, -0.04539858f, 0.03374213f, -0.04234609f, 0.01442076f, -0.05118207f, -0.01892954f, 
    -0.00445507f, -0.05056779f, -0.04246883f, 0.01146645f, 0.01955281f, 0.04104581f, 0.00678192f, 0.02386387f, 
    -0.05358926f, -0.00463086f, -0.00300847f, -0.03079976f, 0.04141711f, 0.02445290f, -0.00144706f, -0.03329631f, 
    0.02946408f, 0.01680675f, -0.02630091f, 0.03679071f, 0.00624774f, 0.04279627f, -0.01289254f, -0.02946910f, 
    -0.01786698f, -0.02493723f, -0.01160515f, -0.03053408f, -0.07010294f, 0.03043048f, -0.00323802f, -0.01548446f, 
    -0.06788523f, 0.03453637f, -0.04828954f, -0.00302939f, -0.04542369f, 0.01232014f, -0.05725512f, 0.00458317f, 
    -0.04016158f, -0.05370026f, -0.06440635f, -0.04060728f, 0.00308355f, 0.03981526f, -0.04347192f, -0.00234953f, 
    0.00292413f, -0.00259920f, -0.04219190f, 0.05384506f, 0.02201565f, 0.05466478f, -0.00072335f, -0.06128164f, 
    -0.05394166f, 0.02589969f, -0.03751359f, -0.00485933f, -0.05201896f, 0.02270590f, -0.00518574f, -0.06074555f, 
    -0.05365528f, -0.01473510f, 0.01794828f, -0.00056886f, 0.01230150f, 0.01413907f, 0.03819326f, 0.00224217f, 
    0.03092261f, 0.04452962f, -0.01227315f, 0.03458874f, -0.02582864f, 0.00754592f, 0.00271280f, 0.01047460f, 
    -0.02801337f, -0.01349973f, 0.02884551f, -0.00670489f, -0.02759507f, -0.05504195f, -0.06972622f, 0.04348660f, 
    -0.05585352f, -0.02651309f, 0.02010663f, 0.02682894f, 0.03052170f, -0.04524708f, 0.02481227f, -0.03807968f, 
    -0.04368636f, -0.01222217f, -0.00470815f, -0.02699519f, 0.01113186f, 0.03808048f, -0.01824054f, 0.02988794f, 
    -0.00346003f, 0.03563455f, -0.05277289f, -0.03572602f, -0.04317551f, -0.01950792f, -0.02385732f, 0.00250401f, 
    0.02159079f, 0.02079356f, -0.02035846f, 0.00468147f, -0.02979721f, -0.02880691f, -0.05934808f, -0.06615746f, 
    0.00279289f, 0.01546236f, 0.03177680f, 0.01315313f, -0.00346260f, 0.04786675f, 0.02423500f, -0.00320991f, 
    -0.00230312f, 0.01316686f, -0.01047947f, -0.00252271f, -0.00362274f, 0.01439579f, -0.00653618f, -0.06294196f, 
    0.04140948f, 0.01740612f, -0.03767388f, 0.00667972f, 0.01937880f, -0.03574059f, -0.00265563f, 0.02897555f, 
    -0.06905361f, -0.16682673f, 0.04877747f, 0.01041481f, 0.01753624f, -0.04475613f, -0.20663473f, -0.09736878f, 
    0.03099520f, 0.15313433f, 0.32386801f, -0.05060422f, -0.03538302f, -0.10412865f, 0.15875082f, -0.19541809f, 
    -0.07789608f, -0.08301829f, -0.41496706f, -0.03107941f, 0.00951810f, -0.08179372f, -0.01464258f, 0.14395598f, 
    -0.11880464f, 0.02650102f, 0.12026118f, -0.06125638f, -0.01480304f, -0.00126431f, 0.16935971f, -0.04316559f, 
    -0.08060191f, 0.08311389f, 0.05763693f, -0.06900620f, 0.45696151f, 0.07323175f, -0.19402260f, 0.01325443f, 
    0.02715444f, -0.11617409f, 0.10687359f, 0.08986331f, 0.05370728f, 0.43726471f, 0.05573611f, -0.30091265f, 
    0.02799107f, 0.12929054f, 0.06300168f, 0.07029848f, -0.12568483f, 0.00311901f, -0.31870097f, -0.16733368f, 
    -0.11640898f, -0.10497945f, 0.07875337f, -0.15102285f, -0.06146594f, -0.26232091f, 0.09990819f, -0.40153047f, 
    -0.17337081f, 0.01925909f, 0.20509961f, -0.04996283f, 0.09807802f, 0.02417730f, -0.14222930f, 0.05046742f, 
    0.15706114f, 0.05536497f, -0.08067369f, -0.22143295f, -0.08343960f, 0.08430066f, 0.06177453f, 0.04513045f, 
    -0.02004453f, 0.04231102f, 0.05316660f, 0.15296879f, 0.02079445f, -0.01134693f, -0.07657407f, 0.02912952f, 
    0.16536385f, -0.13177870f, -0.12750091f, 0.08597160f, 0.07502588f, 0.09893722f, 0.18088797f, 0.01306896f, 
    0.02696614f, -0.16556087f, 0.02951309f, -0.31741050f, 0.13139649f, -0.13659956f, 0.03622634f, -0.09759839f, 
    0.10543944f, -0.01981740f, 0.08009346f, -0.10253339f, 0.37605107f, 0.13354543f, -0.36478192f, 0.21259502f, 
    -0.01145468f, -0.07821378f, -0.06391931f, 0.12413184f, 0.03443008f, -0.16801676f, -0.20962802f, -0.03968814f, 
    0.09746452f, 0.08698206f, -0.04333036f, -0.20402002f, 0.16963276f, -0.11602685f, 0.50349361f, -0.10229632f, 
    -0.18189569f, 0.16069350f, 0.05983101f, 0.04535003f, -0.13006352f, -0.07128802f, 0.13707259f, -0.16882227f, 
    -0.08603321f, -0.09152516f, -0.22148491f, 0.09744179f, -0.05765605f, -0.20377581f, -0.00635585f, 0.11253996f, 
    0.09791720f, -0.01876813f, -0.03932232f, -0.03729263f, -0.11770085f, 0.10107611f, -0.12852091f, 0.03322267f, 
    -0.02795888f, 0.33728889f, 0.20809431f, -0.34977818f, -0.00172124f, -0.11285786f, 0.00241524f, 0.07520888f, 
    0.02006923f, 0.03630219f, 0.09783989f, -0.02316165f, -0.17877166f, -0.06327768f, 0.18534659f, -0.10773113f, 
    0.00315546f, 0.02457891f, -0.01861526f, 0.51448870f, 0.20642963f, -0.03967980f, 0.16001014f, 0.03096022f, 
    0.11541522f, 0.26830298f, 0.22071840f, 0.15871210f, 0.13134491f, 0.05773952f, 0.00201954f, 0.12087943f, 
    -0.03892583f, 0.14090143f, 0.19186132f, -0.35098025f, 0.01260727f, 0.11183237f, 0.24416724f, -0.15873417f, 
    0.03769557f, -0.11352264f, 0.34155619f, 0.05669674f, -0.00839742f, -0.19175911f, -0.06714957f, 0.15593830f, 
    -0.06521800f, 0.28406033f, -0.02282225f, -0.15966280f, 0.13544114f, 0.08676351f, 0.12479180f, -0.03734433f, 
    -0.37343273f, -0.05281526f, -0.01137368f, -0.04006165f, 0.10147166f, -0.02810214f, -0.03021564f, -0.14439617f, 
    0.01851111f, -0.18573822f, 0.19561721f, 0.02040227f, 0.09054807f, -0.05723868f, 0.01572117f, -0.13829435f, 
    -0.09259067f, -0.57458574f, -0.37955692f, -0.17734276f, 0.12900436f, 0.06068416f, -0.15449432f, -0.36479414f, 
    0.17914447f, -0.00935874f, 0.09577753f, 0.31778684f, 0.01225364f, 0.12834103f, 0.07194629f, -0.07273816f, 
    -0.00662695f, 0.04356065f, 0.08605898f, 0.07281925f, 0.09257267f, 0.02740681f, 0.17144077f, -0.17893001f, 
    -0.07003532f, 0.05386787f, 0.00547238f, -0.01801707f, 0.16656132f, -0.27563459f, 0.01658489f, 0.06374868f, 
    0.06213449f, -0.05486701f, 0.02005520f, -0.12430314f, 0.14547177f, 0.06700168f, -0.16258129f, -0.19873385f, 
    0.07290072f, 0.14825429f, 0.12916359f, 0.23995499f, -0.13403973f, 0.09625179f, 0.01398535f, 0.39311397f, 
    -0.10720131f, -0.02201422f, -0.02497203f, -0.10277405f, 0.01201117f, -0.04824841f, 0.11419730f, 0.11842359f, 
    -0.11953502f, -0.23192737f, 0.14233339f, -0.06915240f, 0.13502769f, -0.07734696f, -0.03653476f, -0.00508254f, 
    -0.08248753f, 0.28959256f, 0.03328878f, 0.05626423f, -0.09737682f, 0.16918942f, -0.04086617f, -0.03252489f, 
    -0.13457860f, 0.41627768f, 0.13726754f, 0.13233696f, 0.02639574f, 0.01883871f, -0.17246740f, -0.04108575f, 
    0.09261225f, -0.04564137f, -0.52021825f, -0.01794628f, 0.04402791f, -0.12325319f, -0.00881921f, 0.08911011f, 
    -0.20274828f, 0.11892301f, -0.20529404f, -0.20652179f, -0.27802792f, -0.04571707f, -0.12566575f, 0.04627136f, 
    -0.20035748f, 0.03959902f, -0.10422119f, 0.07445303f, -0.42716959f, 0.32227731f, -0.31587344f, 0.22566102f, 
    0.00331072f, -0.01412477f, -0.08912183f, -0.09281505f, 0.03963034f, -0.04790700f, 0.08532781f, -0.07410809f, 
    -0.15516144f, -0.10384602f, 0.03915945f, -0.06650333f, 0.01808232f, -0.00861961f, -0.43527153f, -0.04808029f, 
    -0.35249746f, 0.06542870f, -0.01421707f, -0.03004622f, 0.19524305f, -0.04087853f, -0.06682245f, 0.00966572f, 
    0.04311839f, 0.04908146f, 0.15211488f, 0.20108278f, 0.03689136f, -0.04597983f, 0.03542570f, -0.09197877f, 
    0.19006485f, 0.26822734f, -0.14699146f, -0.14960733f, -0.09469319f, 0.11533815f, 0.07689224f, 0.11354310f, 
    0.00473944f, 0.24473692f, 0.33099353f, -0.13213915f, -0.08938390f, 0.03916025f, 0.14815558f, 0.04329706f, 
    -0.06299282f, 0.05750579f, 0.25494188f, 0.35662508f, 0.18669333f, 0.09947658f, -0.04107289f, 0.03030545f, 
    0.10143225f, 0.03033320f, -0.03882850f, -0.02333286f, -0.00915757f, -0.03994703f, -0.01298203f, -0.03959650f, 
    -0.09026955f, 0.00754767f, 0.10318696f, 0.09202565f, -0.83331752f, 0.06122001f, -0.11757994f, 0.03351648f, 
    -0.04491470f, -0.18585160f, 0.18599823f, -0.08107435f, -0.00213221f, 0.09513091f, 0.17841974f, -0.11801376f, 
    -0.18422893f, 0.05344436f, 0.18771906f, 0.22300090f, 0.02294117f, 0.02663321f, -0.39158458f, 0.09063914f, 
    -0.18815653f, -0.01762359f, 0.14947814f, -0.12596986f, -0.17931262f, 0.03013341f, -0.00844329f, -0.06215568f, 
    0.15468742f, 0.03017423f, 0.01310949f, -0.14534226f, 0.04817313f, -0.04438529f, 0.09633129f, -0.01087516f, 
    0.12437306f, -0.02046946f, 0.17877463f, 0.07212313f, 0.00916839f, 0.13364664f, -0.06596872f, -0.03372813f, 
    0.04477464f, -0.28140968f, 0.06149485f, 0.26313704f, 0.04468883f, 0.03895202f, 0.06907314f, 0.05411929f, 
    0.03184268f, -0.08060770f, -0.20640315f, 0.10338875f, -0.25889918f, 0.27839440f, 0.16184381f, -0.02088581f, 
    -0.05157582f, -0.03844700f, -0.03188112f, -0.35233667f, -0.00564506f, -0.33015126f, 0.00512785f, -0.10869692f, 
    -0.10409146f, 0.10956278f, 0.14702976f, 0.06054201f, -0.01092194f, 0.30364242f, -0.05741220f, -0.12947753f, 
    0.05904923f, -0.13016088f, 0.21059975f, -0.02201116f, 0.04283068f, -0.10146247f, 0.03456940f, -0.10617428f, 
    0.00257627f, -0.08454761f, 0.03057948f, -0.11429501f, 0.12849568f, -0.02182354f, -0.21764168f, -0.11431865f, 
    -0.08069501f, -0.03565568f, 0.01148674f, -0.14773937f, 0.11485933f, 0.06585909f, 0.05620034f, 0.13712594f, 
    -0.02929893f, -0.14093104f, -0.02194749f, 0.08754004f, -0.07467442f, 0.12586066f, 0.23964687f, -0.08445406f, 
    -0.11991362f, 0.02014630f, -0.12206628f, 0.07381753f, 0.09595113f, -0.03144505f, 0.17678703f, 0.17523082f, 
    0.00053862f, 0.39894408f, 0.14040698f, -0.02486943f, 0.07637843f, 0.00795619f, -0.05401535f, 0.10244785f, 
    0.03150821f, -0.09261183f, 0.17987354f, 0.36604580f, -0.07699252f, 0.32691157f, 0.08688415f, 0.01446065f, 
    -0.12919962f, -0.12194549f, -0.11440283f, -0.07903489f, -0.16572975f, -0.14468363f, 0.01666532f, -0.02185654f, 
    -0.05699760f, 0.02217415f, 0.09507826f, 0.12479658f, -0.28359932f, -0.08802925f, -0.15058614f, 0.17523658f, 
    0.16137534f, -0.17309687f, 0.08231380f, -0.12382744f, 0.05026252f, 0.04120327f, -0.20695637f, 0.00069204f, 
    -0.01444270f, -0.14828689f, -0.10394812f, -0.05387930f, -0.08045950f, 0.03933196f, -0.43592912f, 0.07054796f, 
    -0.18646248f, 0.09968168f, -0.03993686f, 0.01825682f, 0.16716757f, -0.06645309f, 0.01549941f, -0.25719598f, 
    0.01317354f, -0.10625194f, -0.02403535f, -0.12781920f, 0.16283175f, -0.02689939f, 0.22734679f, -0.07507979f, 
    -0.02512311f, -0.05478948f, -0.13851450f, 0.05454682f, 0.24650134f, -0.11205663f, 0.20370805f, -0.06976712f, 
    0.07904296f, -0.11320223f, -0.05234259f, 0.03883079f, 0.05828828f, 0.07088275f, -0.08242691f, 0.10301092f, 
    -0.14284089f, 0.10277802f, -0.20513289f, -0.11119206f, -0.24732418f, 0.13813326f, -0.18030721f, 0.10397009f, 
    0.09187348f, 0.22863477f, -0.10021552f, 0.15602744f, -0.33308420f, -0.21797937f, -0.05893998f, 0.07717757f, 
    0.05660670f, -0.15958942f, -0.09042569f, -0.13732268f, -0.16059607f, 0.28840035f, 0.09231314f, -0.05951140f, 
    -0.17751363f, -0.02203499f, -0.02139824f, 0.12953499f, -0.03185093f, -0.21252403f, 0.21546501f, 0.09677594f, 
    -0.16911878f, -0.18171215f, 0.03040205f, 0.00485401f, 0.18998745f, 0.08950702f, 0.42707187f, -0.01579406f, 
    -0.09913026f, -0.05433441f, -0.05893649f, -0.03992115f, 0.22840293f, 0.12085836f, -0.00208175f, 0.22175470f, 
    -0.33416143f, -0.11679610f, 0.25843939f, 0.11821962f, 0.05356273f, 0.06902965f, -0.11218934f, -0.08346982f, 
    -0.31997266f, 0.11280914f, -0.01803985f, 0.07168004f, -0.05499759f, -0.05616723f, 0.11401287f, -0.22041340f, 
    -0.12796117f, 0.28948003f, 0.26922044f, -0.03360466f, 0.13160259f, -0.01969816f, 0.05444304f, -0.00759785f, 
    0.13294415f, -0.03474733f, 0.03371132f, -0.22023821f, -0.00426000f, -0.00250029f, 0.05578445f, 0.22944999f, 
    0.00676491f, -0.03393068f, -0.11500220f, -0.28119525f, -0.21284011f, 0.03239225f, 0.11307899f, -0.03020928f, 
    -0.18276003f, -0.13317747f, 0.15899712f, -0.02251518f, -0.30115360f, -0.06168176f, 0.28956440f, -0.26716590f, 
    -0.04058827f, 0.17425752f, -0.05598415f, -0.07329825f, 0.05324188f, 0.43964565f, -0.12662372f, -0.24603650f, 
    0.11396104f, 0.13901235f, 0.04935683f, -0.19669242f, -0.01439041f, 0.25347900f, -0.03141246f, 0.21150659f, 
    0.27732420f, -0.04303109f, 0.21953797f, 0.25570482f, -0.01244875f, 0.01166031f, -0.01795983f, 0.26992127f, 
    0.01227989f, -0.07505455f, -0.01939591f, -0.03578406f, 0.13191381f, -0.08562030f, -0.21851403f, 0.03436766f, 
    -0.08889431f, -0.00004526f, -0.16328925f, -0.03864792f, 0.14487527f, 0.09239884f, 0.00385973f, -0.13994129f, 
    0.01142986f, -0.17988430f, 0.42252639f, 0.17905369f, 0.06403795f, -0.04939153f, -0.26114538f, -0.00413760f, 
    0.01631522f, -0.07665066f, -0.17984983f, 0.03287081f, -0.01083021f, -0.14189641f, 0.04374983f, 0.09204535f, 
    -0.01926565f, 0.03397227f, 0.12452608f, -0.02768853f, 0.30007020f, 0.31475285f, -0.42833611f, -0.02288793f, 
    -0.19368073f, -0.01663399f, 0.14565213f, 0.02587575f, -0.23576437f, -0.05383071f, 0.14637756f, 0.09653694f, 
    -0.20577902f, 0.04720581f, 0.19056416f, 0.01692097f, 0.05142120f, 0.08860302f, 0.03518973f, 0.08824877f, 
    0.13655072f, 0.05653778f, -0.05240171f, -0.11170600f, 0.32146439f, -0.04037308f, -0.13372613f, -0.10464846f, 
    -0.23772608f, -0.20094022f, -0.02961311f, -0.00138642f, 0.05825014f, -0.16753587f, 0.05802545f, -0.18397468f, 
    -0.21932933f, -0.15303352f, -0.11553321f, 0.08491772f, -0.05835139f, 0.08440900f, -0.11326648f, -0.34694746f, 
    0.12101512f, 0.01097880f, -0.30046058f, -0.02266877f, 0.37888590f, 0.27905905f, -0.08016620f, -0.24300583f, 
    -0.02980557f, 0.50994676f, -0.42505714f, -0.16344866f, 0.07469999f, 0.19265975f, 0.24262646f, -0.03267532f, 
    -0.00929670f, -0.12048966f, -0.28162020f, 0.14644346f, -0.00238033f, 0.12717921f, 0.04587622f, 0.04860512f, 
    -0.09468041f, -0.21150857f, -0.10617807f, 0.03249664f, 0.20229319f, -0.45765731f, 0.15903431f, -0.10269578f, 
    -0.12434161f, 0.06968326f, 0.11974245f, -0.16201665f, 0.09083322f, 0.43380669f, 0.20020181f, 0.17070290f, 
    -0.19773476f, 0.21324256f, 0.04323861f, -0.08375061f, -0.02355202f, -0.02359608f, 0.06917992f, -0.18024772f, 
    -0.14816059f, -0.01696629f, -0.00995802f, -0.22996099f, -0.13537844f, 0.06730645f, -0.00629553f, 0.21387345f, 
    0.32885137f, 0.03194028f, -0.02406511f, -0.31820777f, 0.08096536f, 0.04352544f, 0.04224924f, 0.20669004f, 
    -0.08585168f, -0.23100214f, -0.06856670f, 0.01375726f, -0.25347143f, -0.11685945f, -0.13214646f, 0.27208585f, 
    -0.03275743f, -0.04529429f, -0.03271619f, -0.01529257f, 0.04994297f, 0.02120259f, 0.03139660f, 0.03737633f, 
    -0.03663771f, -0.00639739f, 0.00324923f, -0.03133667f, 0.00878314f, -0.05240858f, 0.01202408f, -0.00996540f, 
    -0.00517973f, -0.04269079f, 0.04197692f, -0.00769694f, 0.01468300f, -0.03759880f, 0.02808202f, -0.05645532f, 
    0.04157573f, -0.03698578f, 0.00776396f, -0.03734455f, -0.02509578f, -0.03554635f, -0.05640998f, -0.05500097f, 
    -0.00729826f, 0.00048873f, 0.03000572f, -0.04554218f, -0.05888198f, 0.04457742f, 0.03655741f, -0.02654954f, 
    -0.02414766f, -0.02035214f, -0.02824226f, 0.00441808f, -0.03307755f, -0.00394146f, 0.03557440f, 0.05068520f, 
    -0.03902839f, -0.01587952f, -0.06184741f, -0.06116528f, -0.01095407f, -0.01077245f, -0.01313842f, -0.00402819f, 
    -0.03786058f, 0.02208024f, -0.02702482f, -0.01605296f, -0.00248818f, -0.04367032f, 0.02283420f, 0.02824731f, 
    0.05197610f, -0.03179963f, -0.03160206f, -0.04996574f, -0.04066111f, 0.01686729f, 0.03092306f, -0.03210327f, 
    -0.05201989f, 0.01048973f, 0.03998614f, -0.03037762f, -0.05366028f, 0.01968976f, 0.05160910f, -0.06350812f, 
    -0.05271394f, -0.04395505f, 0.03376251f, 0.04304766f, -0.05708339f, 0.04337835f, 0.01850050f, -0.00916252f, 
    0.03331729f, -0.04853183f, 0.01088987f, -0.02029258f, -0.01589503f, -0.04739350f, 0.04467491f, -0.05542445f, 
    -0.03592217f, -0.04632648f, -0.05222500f, 0.00289777f, -0.02207837f, -0.01173379f, 0.00322092f, 0.00558256f, 
    0.02941355f, -0.02230699f, 0.04188772f, -0.00906251f, 0.00216812f, 0.04077792f, 0.00944507f, -0.05793647f, 
    -0.06442642f, -0.00575656f, -0.01020984f, 0.00965899f, -0.01111177f, -0.03614299f, -0.03268497f, 0.01029821f, 
    -0.03983381f, -0.01116172f, 0.01254361f, -0.06138302f, 0.03219353f, -0.03254960f, 0.00524590f, 0.04850353f, 
    0.02363709f, 0.03014076f, -0.02586519f, 0.02983778f, -0.04944516f, 0.04909773f, 0.03092020f, -0.05719204f, 
    -0.01789197f, 0.02663326f, -0.03032668f, -0.00974785f, -0.04482043f, -0.05536364f, -0.02941435f, 0.02009398f, 
    0.00180155f, -0.05990624f, 0.01703117f, 0.00345068f, -0.01934467f, -0.03559579f, -0.05539151f, -0.01283446f, 
    -0.03839447f, -0.04429689f, -0.02571047f, -0.03285264f, 0.00946090f, -0.02678811f, -0.06268843f, 0.02090764f, 
    0.01035776f, 0.04478656f, 0.01438341f, 0.04644561f, -0.05232958f, -0.02957267f, 0.01037162f, 0.02235377f, 
    -0.01035054f, -0.03788961f, 0.04796405f, 0.00470041f, -0.02478538f, 0.02625499f, -0.05635173f, 0.03575301f, 
    0.00193768f, -0.01257405f, 0.01404854f, -0.06209251f, 0.00190826f, 0.01171683f, -0.02304945f, -0.00146577f, 
    -0.03065282f, -0.04137849f, -0.04419207f, -0.04502792f, -0.00269731f, -0.04085097f, 0.04387365f, 0.04068400f, 
    -0.04047760f, 0.03178342f, -0.04017674f, -0.00160009f, -0.00418684f, -0.04893000f, -0.04927207f, 0.00025085f, 
    -0.03535306f, 0.04547645f, 0.02232314f, 0.05187242f, -0.03402230f, -0.05983802f, -0.00835495f, 0.02156052f, 
    -0.04929496f, -0.00416861f, 0.04617257f, -0.03737574f, 0.02332071f, 0.04332058f, -0.00948496f, 0.01421603f, 
    -0.00465036f, 0.00957682f, -0.02380326f, 0.04630468f, -0.04907839f, -0.03749800f, 0.02953244f, 0.03261841f, 
    -0.00297552f, 0.05174669f, 0.04472073f, -0.04773522f, -0.05600565f, -0.05364193f, 0.02264995f, -0.03548208f, 
    0.02573061f, -0.03183967f, 0.01644580f, -0.06414311f, 0.04989633f, -0.01328990f, -0.04767879f, 0.02112377f, 
    -0.01966059f, -0.02979186f, 0.01342191f, 0.04349993f, -0.05560755f, -0.04895209f, -0.02675658f, -0.00595547f, 
    0.05024518f, 0.01385675f, -0.05287123f, -0.04567178f, -0.00511089f, -0.00189908f, -0.05049503f, 0.01423930f, 
    0.02740213f, -0.03874559f, -0.05245290f, 0.01137808f, 0.01965916f, -0.04709781f, 0.03650546f, 0.04295407f, 
    0.05216143f, -0.01899204f, -0.01695226f, 0.00730127f, -0.00982659f, -0.04266828f, 0.04248543f, 0.03520184f, 
    0.01493765f, -0.01236437f, -0.05500245f, 0.01246031f, -0.05841772f, -0.00332378f, -0.01912032f, 0.03184074f, 
    -0.03188340f, 0.04344214f, -0.02253742f, -0.05440573f, -0.04054643f, 0.02231646f, 0.03624661f, 0.04577675f, 
    -0.02404797f, 0.03236712f, 0.02033457f, -0.02201444f, -0.01009022f, 0.00115881f, 0.01820241f, 0.02369072f, 
    0.04054158f, 0.04389832f, -0.06477808f, -0.04900699f, 0.05164032f, -0.01532221f, -0.03924370f, 0.03735221f, 
    -0.00934918f, 0.01810625f, 0.03106631f, -0.01034037f, 0.02889866f, 0.04463970f, -0.02943613f, -0.01485613f, 
    0.03716601f, 0.03325368f, -0.02476285f, -0.04483541f, 0.04172693f, -0.00053239f, 0.04847696f, 0.04084944f, 
    -0.03644842f, 0.00453787f, 0.03531335f, -0.01948284f, 0.00669544f, -0.05173496f, -0.01643565f, 0.00550673f, 
    -0.00403005f, -0.02870031f, -0.03246984f, 0.00679184f, 0.02804045f, 0.00796245f, -0.02642834f, -0.04578776f, 
    -0.03232444f, 0.00410819f, -0.01232976f, 0.01477959f, -0.05401997f, 0.00027694f, -0.06759909f, -0.04309267f, 
    -0.05495889f, 0.04772538f, 0.04417447f, -0.00025755f, -0.04684795f, 0.03727042f, -0.02154639f, -0.05116457f, 
    -0.02816752f, -0.02355591f, -0.01299426f, 0.00122626f, -0.01220422f, -0.02057995f, 0.02294697f, -0.06670087f, 
    0.00871968f, -0.01291194f, -0.05884439f, -0.02957550f, -0.00871608f, -0.00989039f, -0.03322219f, -0.00902580f, 
    -0.01172513f, -0.01872093f, 0.03277851f, 0.00672490f, -0.01630323f, -0.03364850f, -0.07316705f, 0.01971295f, 
    -0.02179810f, -0.02991258f, 0.02306128f, -0.04735016f, 0.02450675f, 0.02873976f, 0.04219535f, 0.04430002f, 
    -0.01475565f, -0.02141709f, 0.01818152f, -0.03406941f, 0.00503434f, -0.03738999f, -0.00635778f, 0.05364503f, 
    0.04335544f, 0.02780414f, 0.02512428f, 0.03335256f, 0.01655713f, -0.05593615f, 0.01922979f, -0.05008500f, 
    -0.01571980f, -0.04346204f, 0.05948793f, -0.03923615f, 0.01086572f, -0.04414182f, 0.00395898f, -0.00424393f, 
    -0.00422648f, -0.03083898f, 0.00032306f, 0.04141352f, 0.04520205f, -0.03276386f, 0.02953215f, 0.00906941f, 
    -0.06432202f, -0.01111164f, -0.00962336f, -0.02182155f, 0.00339753f, 0.01126180f, -0.04072330f, -0.03813478f, 
    0.02048288f, -0.06227501f, -0.06119534f, 0.04597639f, -0.03163447f, 0.03771842f, 0.04304709f, -0.00560702f, 
    -0.03696818f, -0.04743272f, 0.04301682f, 0.04406347f, 0.03553977f, -0.06151515f, -0.01667858f, 0.02864284f, 
    -0.00135458f, -0.03380029f, 0.03687032f, 0.04640262f, 0.01782047f, 0.00190120f, 0.01469649f, -0.03689022f, 
    -0.00246600f, 0.01658290f, -0.04026424f, 0.04818809f, -0.03218329f, -0.03120079f, -0.02910921f, -0.00587829f, 
    -0.04186573f, -0.03988767f, -0.01027714f, 0.04681866f, 0.01583472f, -0.01073506f, -0.02910632f, -0.02725421f, 
    -0.04906020f, -0.04504982f, -0.05875614f, -0.00887816f, -0.01553685f, 0.03559018f, 0.04413639f, -0.04333723f, 
    -0.02875507f, 0.03901774f, -0.05814052f, -0.01383635f, -0.06207611f, -0.01250927f, 0.00772094f, -0.02339491f, 
    0.01767168f, 0.00625569f, 0.02643233f, -0.01416041f, 0.04560799f, -0.04974066f, -0.01641890f, -0.01326289f, 
    -0.01662285f, -0.03767973f, -0.04674212f, 0.02689019f, -0.03493960f, -0.00477989f, -0.06980166f, -0.01954315f, 
    -0.01197257f, -0.04069190f, -0.02929528f, -0.02668457f, -0.02718238f, 0.01802293f, 0.03149536f, -0.02026974f, 
    0.01075960f, 0.00871529f, 0.02829299f, -0.05527936f, -0.03926659f, -0.00263858f, 0.04872864f, 0.00184877f, 
    -0.00407126f, 0.04262794f, 0.02895733f, -0.01730839f, 0.03514891f, 0.01419566f, 0.00459455f, 0.00924394f, 
    -0.02000533f, 0.03525855f, 0.02596996f, -0.03634412f, -0.03599017f, 0.03462641f, -0.05655014f, 0.01454406f, 
    -0.03221474f, 0.00142228f, 0.03545937f, -0.04674733f, -0.04045454f, 0.01730723f, -0.00004339f, -0.01125166f, 
    -0.02442057f, -0.00601694f, 0.02968926f, 0.04103944f, 0.00028677f, 0.02017844f, -0.04296447f, -0.02795428f, 
    -0.05390449f, 0.03815673f, -0.04527404f, -0.02251908f, 0.00021310f, -0.04600010f, 0.03272149f, 0.00551828f, 
    -0.03880334f, -0.06524850f, 0.05123633f, -0.00309014f, 0.02307540f, 0.00415768f, -0.00468850f, 0.04891368f, 
    -0.02577665f, -0.01441675f, 0.04655651f, -0.06538107f, 0.04164683f, 0.00714108f, -0.04957857f, 0.01260119f, 
    -0.02186152f, -0.02009486f, 0.00941556f, -0.05405175f, -0.06349822f, -0.02747054f, 0.04529583f, 0.03916689f, 
    -0.05278979f, 0.05075284f, 0.19640470f, -0.01486401f, -0.24073374f, 0.14239837f, -0.16531616f, 0.21675363f, 
    0.19546312f, -0.12228022f, -0.07439152f, 0.22229660f, -0.20471869f, -0.10835893f, 0.05702206f, -0.07960055f, 
    0.09085254f, 0.27089769f, -0.11350422f, 0.17808534f, -0.07658746f, -0.12965024f, 0.17439330f, -0.22063728f, 
    -0.21142195f, 0.13536814f, -0.13947651f, 0.26638353f, 0.06344350f, 0.05035017f, -0.15639755f, 0.11403177f, 
    -0.05850267f, 0.20595033f, -0.02455744f, 0.08649059f, 0.14011998f, 0.13371782f, -0.18618059f, 0.01906470f, 
    0.06543403f, 0.15145002f, 0.02105924f, 0.01743340f, -0.27731353f, 0.15930222f, -0.05384182f, 0.01488300f, 
    0.08598793f, 0.05865254f, -0.08573470f, 0.11286583f, 0.10713068f, 0.08230416f, 0.56437486f, 0.05004380f, 
    -0.08311779f, -0.13503924f, -0.02644494f, -0.04128201f, -0.10628550f, -0.00592986f, -0.13780913f, -0.06271191f, 
    0.02270847f, 0.36474225f, -0.06031176f, -0.14854798f, -0.11161470f, -0.15341894f, -0.10486658f, 0.25484625f, 
    0.05871186f, 0.01540273f, 0.00374600f, -0.10801636f, 0.10401352f, -0.17726932f, -0.03699197f, 0.04343757f, 
    0.03678966f, -0.19039227f, -0.06525913f, 0.15678032f, -0.10965274f, 0.03533499f, 0.02121576f, 0.06557097f, 
    0.04272475f, 0.16066448f, -0.03505971f, -0.16686188f, 0.39564326f, -0.11452159f, -0.01112217f, 0.04765365f, 
    -0.18055207f, -0.06304941f, 0.01078350f, -0.06150362f, 0.02636519f, -0.10554621f, -0.11226288f, 0.04149059f, 
    -0.00920042f, 0.12361123f, -0.18189187f, -0.25371671f, 0.15819293f, 0.05101411f, -0.00854008f, 0.22976443f, 
    0.10785165f, 0.13438584f, -0.03952864f, -0.01470626f, -0.10257677f, -0.21610348f, -0.04926285f, 0.28902301f, 
    0.00107809f, 0.07169775f, -0.06622324f, -0.08159591f, -0.09649806f, 0.14972226f, 0.13390782f, -0.00892628f, 
    -0.35895276f, 0.06424937f, 0.16985282f, 0.09339028f, -0.12844875f, -0.11982980f, -0.41670540f, 0.11036294f, 
    -0.28195593f, -0.23415177f, -0.25673959f, 0.00643709f, -0.10488173f, -0.04590854f, -0.07625020f, -0.08913085f, 
    0.21691038f, -0.03866256f, -0.00703184f, -0.12122364f, 0.11157520f, -0.22730063f, 0.04179539f, 0.10772963f, 
    -0.06894583f, 0.31111348f, -0.05155049f, -0.23730527f, 0.05661253f, 0.10203969f, -0.00419623f, 0.02993082f, 
    -0.03013484f, -0.01235886f, 0.00868664f, -0.06510333f, -0.22263752f, 0.14417030f, -0.01469207f, 0.33581892f, 
    -0.06173625f, 0.15679610f, -0.49499160f, -0.05443539f, -0.18717404f, 0.09192388f, 0.01662727f, 0.17079633f, 
    0.11405610f, 0.08316952f, 0.02431631f, -0.35071275f, 0.21861975f, -0.06218921f, 0.29518101f, -0.17367086f, 
    0.19162174f, -0.10521751f, 0.22038738f, -0.09701107f, 0.02975212f, 0.27302277f, -0.09837443f, 0.12905599f, 
    0.21688649f, -0.14232211f, -0.25242320f, 0.05552222f, -0.01098750f, -0.18234041f, 0.20824172f, -0.21830319f, 
    0.09880719f, 0.00618453f, -0.03413793f, -0.05070632f, -0.16483279f, 0.07530437f, -0.09056080f, -0.19927493f, 
    -0.02373034f, 0.00114276f, -0.11315528f, -0.01931994f, 0.06965123f, -0.08468007f, -0.14536551f, -0.04992558f, 
    0.12226062f, 0.26456326f, 0.22692738f, -0.12996669f, -0.06686355f, -0.03642876f, -0.29829350f, -0.00931882f, 
    -0.01111775f, -0.46918419f, -0.02111075f, 0.30762374f, 0.08649554f, -0.00977744f, 0.43097842f, -0.04862424f, 
    -0.09534778f, 0.14248402f, 0.17245434f, -0.23751988f, -0.06131157f, -0.08389197f, -0.01439759f, -0.11437475f, 
    0.05760340f, 0.00697919f, 0.08306805f, 0.21541317f, -0.17606883f, 0.13033567f, -0.15068957f, 0.03560944f, 
    -0.17538767f, -0.06386244f, 0.09262560f, 0.14216156f, -0.07423379f, -0.05271099f, -0.03242851f, 0.20315397f, 
    0.26430362f, 0.13333806f, -0.01306241f, 0.05481646f, -0.07466409f, 0.11009198f, 0.37784368f, 0.01949261f, 
    -0.06244333f, -0.01901163f, -0.11959787f, 0.07528184f, 0.10714682f, -0.04295027f, 0.23064722f, 0.06270820f, 
    -0.35303733f, 0.16601160f, 0.19004986f, -0.06307561f, 0.01325775f, 0.05591336f, 0.05990762f, 0.07113505f, 
    0.10370477f, 0.27093154f, -0.02027687f, -0.20883159f, 0.02406025f, 0.02720323f, 0.02738568f, -0.08128941f, 
    0.03740003f, -0.02407246f, -0.01071898f, 0.04149991f, -0.00349895f, 0.02889011f, -0.01754963f, -0.01758004f, 
    -0.03478346f, 0.02685208f, -0.05205831f, -0.05592048f, -0.04276782f, 0.05126152f, -0.04366757f, 0.04357726f, 
    0.00244374f, -0.02769715f, -0.02724692f, 0.04558133f, 0.03107229f, 0.03853678f, 0.00813023f, -0.01029541f, 
    0.03711420f, -0.05962805f, 0.00562448f, -0.01828342f, 0.01950496f, 0.01679124f, 0.01877533f, 0.04370047f, 
    0.01500658f, -0.05894151f, 0.00603600f, -0.04475300f, -0.04028217f, 0.03455063f, -0.00077350f, 0.03421639f, 
    -0.01165983f, -0.01767262f, 0.02433109f, -0.04141647f, -0.05523528f, -0.02034015f, 0.05133360f, 0.00166273f, 
    0.04487108f, 0.00413262f, 0.00517295f, -0.05553795f, -0.00434486f, 0.01996036f, -0.00632204f, -0.03590119f, 
    0.03416175f, 0.01970978f, -0.04018424f, -0.00363011f, -0.02455096f, -0.00397328f, -0.06087545f, 0.03653987f, 
    0.02786014f, -0.04531745f, 0.00847456f, 0.01260254f, -0.02182974f, -0.00754888f, -0.04901513f, -0.02221303f, 
    0.04838894f, -0.02797126f, -0.02525778f, 0.00403774f, -0.06233716f, 0.02956626f, -0.00180775f, -0.05963909f, 
    -0.02280951f, -0.05609908f, 0.03997544f, -0.04268882f, 0.02562958f, -0.01751200f, -0.03790703f, -0.02602265f, 
    -0.02134781f, 0.02046590f, 0.01669214f, -0.03048243f, 0.03055744f, 0.01387956f, -0.02115993f, -0.02278601f, 
    0.05610037f, 0.04571000f, 0.00401945f, -0.05144562f, -0.00088884f, -0.03477871f, 0.04779982f, -0.03516438f, 
    -0.00007202f, -0.02251552f, 0.04512493f, -0.00547541f, -0.03462788f, -0.01221279f, -0.02585484f, -0.02017064f, 
    -0.05763222f, 0.03532082f, 0.01129733f, 0.00636786f, -0.02093473f, -0.02793276f, -0.05468418f, -0.02533479f, 
    -0.03496935f, -0.03806245f, -0.02595145f, 0.01437809f, 0.04647524f, 0.02131702f, -0.03707142f, 0.04361038f, 
    0.02405814f, -0.05738115f, 0.01391402f, -0.03455832f, -0.04448775f, -0.01538975f, -0.00958414f, -0.05993280f, 
    -0.03445610f, -0.05697367f, -0.02165147f, 0.01160204f, 0.00204239f, -0.06209385f, -0.02251027f, 0.01068727f, 
    0.01082026f, -0.02447745f, -0.03694589f, -0.04882658f, -0.05915566f, -0.04127210f, -0.03640665f, 0.04257317f, 
    0.03877704f, -0.02197957f, 0.01005940f, -0.02141908f, -0.00370475f, 0.01361072f, 0.03574989f, -0.01310827f, 
    -0.02034300f, 0.04078500f, -0.06263420f, -0.06274751f, 0.03807462f, 0.04474707f, 0.00629424f, 0.05090357f, 
    0.03835319f, -0.03162027f, 0.01736550f, 0.00707610f, -0.04195035f, 0.02348242f, 0.00824474f, 0.03110228f, 
    0.02569431f, 0.00475076f, -0.02233586f, -0.05853835f, 0.00365020f, 0.00039468f, 0.04329811f, -0.04946441f, 
    0.04797817f, 0.00472636f, -0.01585178f, 0.01389701f, 0.02220461f, -0.06042433f, 0.05186926f, -0.01382558f, 
    0.05546888f, -0.02175884f, -0.04257710f, -0.03624893f, 0.00827522f, -0.05382168f, -0.00999311f, -0.01146797f, 
    -0.03845892f, -0.02206152f, -0.01483651f, -0.03424573f, -0.03096221f, -0.04445014f, 0.00374861f, 0.04077018f, 
    0.02574262f, 0.02494477f, 0.04869606f, -0.03981216f, -0.04840203f, -0.00691094f, 0.01812047f, 0.01267287f, 
    0.03944398f, -0.01337985f, -0.01081360f, 0.03129962f, -0.01364721f, -0.02283676f, -0.02478550f, -0.02123345f, 
    -0.04474795f, -0.04404291f, -0.05336542f, -0.04399216f, -0.03214419f, -0.02426124f, 0.02209491f, 0.03548735f, 
    0.04838310f, 0.03289183f, -0.00542383f, -0.02936403f, -0.03289736f, 0.03533349f, 0.00079022f, 0.02191764f, 
    0.03724312f, -0.04633254f, -0.03997513f, 0.03425151f, 0.02578415f, -0.06732236f, -0.04348233f, 0.01651807f, 
    0.01226578f, -0.01906831f, -0.00236006f, 0.00538181f, 0.04159499f, 0.05067400f, -0.06620087f, -0.05787583f, 
    -0.00220564f, 0.03514419f, 0.01519173f, 0.03732415f, -0.03053100f, 0.00441532f, -0.06249580f, -0.04986851f, 
    -0.01293803f, 0.03658282f, -0.05218601f, 0.01725847f, 0.00770647f, -0.03658250f, 0.02036350f, 0.01817209f, 
    -0.00403893f, 0.00756298f, -0.05595522f, -0.06595335f, -0.01695914f, -0.06008880f, -0.02048406f, -0.04390302f, 
    -0.01363347f, -0.02812706f, -0.02679715f, 0.04234916f, -0.02882176f, -0.03141404f, -0.06501473f, -0.04278184f, 
    -0.31687942f, 0.09116813f, -0.42271224f, -0.17477046f, 0.11389676f, 0.15324026f, 0.12514858f, 0.08270091f, 
    -0.04324933f, -0.23659523f, 0.28098008f, 0.07054983f, 0.15172385f, -0.19324893f, 0.10437128f, 0.05231369f, 
    0.05514840f, -0.09778419f, 0.07579156f, 0.17993779f, 0.09755108f, -0.10739736f, -0.28886020f, -0.07579735f, 
    -0.05105594f, -0.21404037f, -0.03566335f, 0.53076422f, -0.01681963f, -0.45852700f, 0.02388683f, -0.11410013f, 
    0.12079676f, 0.00203039f, -0.02852443f, -0.06414053f, -0.01047113f, -0.11604750f, 0.14531694f, 0.08690295f, 
    -0.00866616f, -0.04533512f, -0.17142443f, -0.01639764f, -0.09298726f, -0.25966626f, -0.41575181f, -0.11242131f, 
    0.12405428f, 0.05139258f, 0.01658035f, 0.19532830f, -0.26660740f, 0.07251015f, -0.56575984f, -0.22101377f, 
    -0.00396784f, -0.01724998f, 0.10154561f, -0.13218287f, 0.04404515f, -0.17960253f, -0.03632332f, -0.20083451f, 
    0.33254242f, 0.33679745f, 0.11583629f, -0.04071972f, 0.05499535f, 0.03219289f, -0.01056685f, 0.10880313f, 
    -0.11415115f, 0.36602125f, -0.01256079f, -0.11786328f, -0.03998841f, 0.09106299f, 0.14662294f, -0.03948630f, 
    -0.17902488f, -0.22485822f, 0.43887436f, -0.07078505f, 0.03547688f, 0.08244812f, 0.00522486f, 0.07448717f, 
    0.02265596f, -0.03511328f, -0.28186351f, 0.33147544f, -0.07105946f, -0.05658488f, -0.07045786f, -0.06775633f, 
    0.05666856f, 0.06102041f, -0.29418725f, -0.38746786f, -0.12904325f, -0.06197655f, -0.06169263f, 0.10560550f, 
    0.00186592f, -0.04213847f, 0.20148443f, 0.13061574f, 0.17666659f, -0.57088500f, -0.09817933f, 0.04391877f, 
    0.00596530f, -0.14029038f, -0.12735878f, -0.19202758f, 0.20390825f, -0.08350256f, 0.00744103f, -0.11915676f, 
    -0.09233895f, -0.00426019f, 0.25325230f, 0.04186593f, 0.05034786f, -0.11044442f, 0.25981271f, -0.14183734f, 
    0.16811909f, 0.23536487f, -0.14330111f, -0.07398333f, -0.08989269f, 0.03138229f, 0.23185658f, -0.18301493f, 
    0.28882539f, -0.05628883f, -0.14103748f, 0.00971749f, -0.25931489f, 0.14632703f, -0.05605800f, -0.18847176f, 
    0.39939293f, -0.03790217f, -0.30339187f, -0.14552231f, 0.00515288f, -0.07375412f, -0.12883952f, 0.02430099f, 
    0.05126970f, -0.15199283f, -0.56271565f, 0.11100550f, 0.22828382f, 0.12043335f, 0.06573130f, 0.06633797f, 
    -0.07063849f, 0.05409600f, 0.11257316f, -0.18963329f, 0.19832726f, -0.02985368f, -0.15661223f, -0.02321632f, 
    -0.07712925f, 0.45901564f, -0.13263239f, 0.08160158f, -0.01943471f, 0.32490069f, 0.20216002f, -0.03140696f, 
    0.00478388f, -0.07396540f, 0.16534354f, 0.05861694f, 0.15761346f, 0.30084825f, -0.08654907f, -0.04328816f, 
    -0.04941976f, -0.20008856f, -0.06604137f, 0.18967430f, -0.01360378f, -0.04849397f, -0.77220488f, -0.24547958f, 
    0.05456469f, -0.14658695f, 0.08347412f, 0.15456711f, 0.07847308f, 0.23124006f, 0.42909461f, -0.25183615f, 
    -0.02101962f, 0.05131453f, 0.04086147f, -0.24999329f, 0.08758325f, 0.03607603f, 0.07999071f, 0.31418648f, 
    -0.21493164f, 0.12165660f, 0.03581273f, -0.24720432f, 0.02434925f, -0.01558149f, 0.14959463f, -0.13600214f, 
    0.07565230f, 0.37227821f, 0.12955354f, -0.25076327f, -0.07464115f, 0.21936256f, 0.08657917f, -0.01128182f, 
    -0.22195263f, -0.25492695f, -0.04277919f, 0.13850370f, -0.48539111f, 0.28361049f, -0.09465723f, -0.15749273f, 
    -0.04311556f, -0.30238464f, 0.03720292f, 0.60553867f, 0.05205196f, 0.12085575f, 0.02803272f, 0.12965810f, 
    0.20180854f, 0.10694467f, 0.27204430f, 0.48238015f, -0.31271932f, 0.03517982f, -0.16034046f, -0.05455485f, 
    -0.08881374f, -0.00328809f, 0.05075948f, 0.12856360f, 0.17645782f, -0.19681366f, 0.36926880f, 0.00254793f, 
    -0.23500787f, -0.10743102f, 0.06348664f, 0.07358582f, -0.05063682f, 0.16673674f, -0.56374115f, -0.30717796f, 
    -0.02198932f, 0.14327660f, -0.05872253f, 0.00389378f, 0.03614241f, 0.17370689f, -0.37909633f, -0.02803676f, 
    -0.02014509f, 0.18167032f, -0.08624662f, 0.02798267f, 0.04889917f, -0.16720483f, 0.16835541f, 0.17728379f, 
    0.32896757f, 0.02786143f, -0.09242479f, -0.18226269f, -0.11014397f, -0.24420670f, 0.07434256f, -0.00265410f, 
    0.03760516f, -0.27882698f, -0.21928355f, 0.21473587f, 0.10756485f, 0.25336659f, -0.22006486f, -0.16650192f, 
    -0.25828028f, 0.27596605f, -0.44589907f, -0.17885572f, -0.12988660f, 0.15699340f, 0.06833505f, -0.03384571f, 
    -0.01076526f, -0.05492139f, -0.07979634f, -0.08381109f, 0.16445728f, -0.10964770f, -0.02101230f, -0.49357775f, 
    -0.03165489f, -0.24204318f, 0.09022105f, -0.19295211f, -0.27669349f, 0.07525365f, 0.12905590f, -0.02742507f, 
    0.07868805f, 0.13331977f, 0.00556998f, 0.00778982f, -0.50619411f, 0.07448613f, 0.28206366f, 0.08806346f, 
    0.09863010f, 0.14185643f, 0.13884845f, -0.07244220f, -0.05895417f, 0.22593682f, 0.02379747f, 0.19041222f, 
    -0.03382067f, -0.06500125f, -0.22376928f, 0.03149452f, 0.12553844f, 0.01964094f, 0.20494987f, 0.12185423f, 
    0.28555855f, 0.06493563f, -0.17877710f, 0.03762164f, 0.05311984f, -0.07311894f, 0.06114577f, 0.21283883f, 
    -0.16550691f, -0.09612529f, -0.18984573f, 0.21326821f, -0.19793659f, 0.12672155f, 0.03769610f, 0.17532766f, 
    0.10827497f, -0.07895247f, 0.05273096f, 0.07380417f, 0.00648788f, 0.11424449f, 0.06109445f, -0.00940016f, 
    -0.08660521f, 0.30742761f, -0.03318172f, -0.16295810f, -0.09069961f, 0.18062049f, -0.05572107f, 0.04104638f, 
    -0.03071233f, -0.02069024f, -0.12595235f, -0.08233902f, -0.16046232f, 0.19259374f, 0.18905669f, 0.15561707f, 
    -0.08825359f, 0.00893841f, 0.12493315f, -0.05687430f, -0.12513193f, 0.22965154f, -0.09505203f, -0.24476084f, 
    -0.03760389f, 0.07885257f, 0.14384645f, 0.19772597f, -0.32150257f, -0.09520459f, 0.02862772f, -0.03198439f, 
    0.16287087f, -0.18310778f, -0.10533050f, -0.03318675f, -0.07443038f, 0.00168406f, -0.18507236f, -0.12826498f, 
    0.04584353f, 0.10576955f, -0.01047378f, 0.09166715f, -0.00387102f, 0.01014852f, -0.33701172f, 0.18241440f, 
    0.13948801f, 0.23559669f, 0.19055240f, 0.13651817f, 0.06701519f, -0.06131689f, -0.05539804f, -0.52680528f, 
    -0.17593397f, -0.03465415f, 0.13180423f, 0.15762226f, -0.04660808f, -0.18709140f, -0.23629463f, -0.11303728f, 
    0.11696577f, -0.14304042f, 0.06253789f, -0.03807294f, -0.27091557f, 0.01164727f, -0.00553757f, -0.00611054f, 
    -0.06937394f, -0.15204273f, -0.01556601f, 0.01896505f, 0.05165531f, 0.14670505f, 0.08058812f, -0.00502853f, 
    0.00661028f, 0.06041159f, -0.14171739f, 0.13911240f, 0.19166444f, -0.04133517f, 0.12608132f, 0.13871071f, 
    0.03469869f, -0.06720434f, -0.15971902f, -0.26760471f, -0.13371743f, 0.33147639f, 0.01413613f, -0.03475094f, 
    0.16750012f, 0.09395616f, 0.01312898f, 0.06682447f, 0.12875728f, -0.26199955f, -0.08312989f, 0.02287901f, 
    0.08835029f, -0.12663227f, 0.14140971f, 0.12410472f, 0.21464610f, 0.11104312f, -0.04460873f, 0.15742159f, 
    -0.17054015f, -0.25398335f, -0.12980251f, 0.04450284f, 0.11480997f, 0.04588123f, -0.02982732f, 0.04877403f, 
    -0.00081206f, -0.02038768f, 0.17578915f, -0.11931427f, -0.01778037f, -0.14712003f, -0.00670956f, 0.28034538f, 
    -0.08639374f, 0.20566896f, 0.07662801f, -0.02075559f, -0.11656460f, 0.30549565f, -0.13365203f, 0.00874207f, 
    0.13206701f, -0.29358315f, -0.21599354f, 0.04525288f, 0.17398183f, -0.01885381f, -0.07422344f, 0.08024358f, 
    -0.01041585f, -0.10937760f, -0.17160572f, -0.04626418f, -0.03668236f, 0.28134006f, 0.03384415f, -0.17004855f, 
    0.11420768f, 0.16184498f, -0.11495167f, -0.09435499f, 0.08177313f, -0.01036585f, -0.06764388f, 0.02119052f, 
    0.12574521f, 0.05776038f, -0.02087903f, -0.09093917f, -0.15908182f, 0.09861813f, 0.10807704f, 0.04423025f, 
    -0.11674025f, -0.02877158f, -0.13292652f, -0.14681058f, -0.31944209f, 0.24818686f, 0.34358433f, -0.00423000f, 
    0.02106068f, 0.13520777f, -0.05081968f, -0.02376118f, -0.13520956f, -0.03513178f, 0.06463282f, 0.21697444f, 
    0.01707290f, 0.01738183f, -0.06591909f, 0.02893416f, 0.03070460f, 0.15846516f, -0.20353110f, 0.12103765f, 
    0.17949750f, -0.16871697f, -0.12260405f, -0.04657087f, 0.30519146f, -0.16849419f, 0.03581251f, 0.01243144f, 
    -0.08646338f, 0.05452928f, -0.02373557f, 0.09363220f, 0.01831504f, 0.01500343f, 0.08532133f, -0.14576645f, 
    0.17357354f, 0.01279492f, -0.16717666f, 0.03795956f, 0.23762864f, 0.04346005f, 0.02193511f, -0.29454163f, 
    -0.24812418f, 0.21930808f, 0.17593673f, 0.19748300f, 0.05963014f, 0.07643144f, 0.06630809f, 0.17991191f, 
    0.01830065f, -0.24291475f, -0.16315840f, -0.24354595f, -0.20105349f, -0.17764729f, -0.03137774f, -0.04620081f, 
    0.09468208f, -0.01003448f, 0.18412553f, 0.32166338f, 0.34996232f, -0.01891931f, -0.03381084f, 0.04006791f, 
    -0.18889382f, 0.02115485f, -0.12256192f, -0.08192991f, -0.62775385f, -0.73069417f, -0.02458115f, 0.01256763f, 
    0.00145777f, 0.14063326f, -0.06576843f, 0.00751182f, 0.13995828f, -0.05241903f, -0.05269986f, 0.28835371f, 
    0.18827948f, 0.08331364f, 0.25308764f, -0.27169174f, -0.16116428f, 0.01996176f, 0.38632855f, 0.02697524f, 
    -0.17383923f, 0.23277502f, -0.17242609f, 0.01406407f, -0.41315070f, -0.21544802f, -0.06940681f, 0.31774366f, 
    0.06282850f, -0.02124564f, 0.14272361f, -0.13153166f, -0.02478984f, 0.14303932f, 0.16840738f, -0.16713512f, 
    0.11333229f, 0.16603528f, 0.01665277f, -0.13421665f, -0.02836249f, 0.24536917f, -0.14996606f, 0.14610095f, 
    0.06561690f, 0.25615036f, 0.24999404f, -0.02009221f, -0.12265666f, 0.09397414f, 0.17979620f, -0.15332998f, 
    0.03630618f, -0.07842498f, 0.19865815f, 0.16707048f, -0.11167789f, 0.05051024f, 0.13573690f, 0.18155321f, 
    -0.04927745f, 0.30235627f, -0.06682322f, 0.10256977f, -0.00633403f, 0.06591291f, -0.20954509f, -0.01123429f, 
    -0.11784425f, 0.06541943f, 0.16815130f, 0.11596152f, -0.04507652f, -0.63805252f, -0.28804219f, -0.04264783f, 
    0.19361845f, -0.26769605f, 0.06512392f, -0.09642637f, 0.03924882f, 0.19155636f, -0.02740870f, 0.05713707f, 
    -0.03911782f, -0.00285564f, 0.12879871f, 0.37667373f, -0.11907603f, -0.12361471f, -0.47901157f, -0.83823299f, 
    0.07984452f, 0.19225848f, 0.10278085f, 0.26810127f, -0.09384824f, -0.05395322f, 0.08074111f, -0.19093838f, 
    -0.15054661f, -0.07958495f, 0.05987603f, -0.06697101f, 0.01550751f, -0.07091476f, 0.10564548f, 0.00265889f, 
    0.05862707f, 0.16428776f, 0.09884814f, -0.01829250f, -0.08686170f, 0.02203931f, 0.01761808f, -0.09789070f, 
    -0.23956393f, -0.06432279f, -0.11129638f, 0.16817351f, 0.10857665f, 0.08787246f, -0.03538384f, -0.03605738f, 
    -0.10581695f, 0.17224252f, -0.51400197f, -0.25404948f, -0.24348886f, -0.23982932f, 0.05070609f, -0.11034520f, 
    0.17304526f, 0.06942201f, 0.09746737f, -0.52903730f, -0.81901062f, -0.02862073f, 0.08875397f, -0.02833919f, 
    0.11847911f, 0.16011672f, 0.14566594f, 0.02648527f, 0.27359495f, 0.23947322f, 0.07267196f, -0.00236643f, 
    -0.42398876f, -0.02937740f, 0.05178322f, 0.31033790f, 0.33733293f, 0.34081972f, 0.17255820f, 0.13452011f, 
    0.17374453f, 0.03253969f, 0.18225865f, -0.09525076f, -0.08533879f, -0.10215420f, 0.31652290f, -0.24717340f, 
    -0.10407209f, -0.14887750f, 0.06133613f, 0.02456454f, 0.11559140f, 0.09194969f, 0.10593169f, 0.06056180f, 
    -0.24018909f, -0.06163733f, -0.24148460f, -0.16471621f, -0.11008628f, 0.18694358f, 0.10456221f, 0.30616045f, 
    0.26227912f, 0.28434485f, -0.17371149f, -0.12042466f, 0.09912018f, 0.05052552f, -0.04641507f, 0.01044163f, 
    -0.14222445f, 0.00436482f, -0.01937095f, -0.01210130f, 0.00101644f, 0.06271712f, -0.12166486f, 0.11013710f, 
    0.16329095f, -0.18878219f, -0.05127541f, 0.23532827f, -0.02123764f, 0.08715149f, -0.32543322f, 0.09044302f, 
    -0.18576913f, 0.10147358f, 0.05843749f, 0.31188881f, -0.40623572f, -0.20390712f, -0.12283919f, 0.05376696f, 
    0.11761065f, -0.06969031f, 0.24882604f, 0.09952182f, -0.59664780f, -0.31251204f, -0.23236004f, -0.27913135f, 
    -0.13874069f, -0.00997313f, -0.00447044f, -0.11325939f, -0.10566255f, -0.01123817f, -0.02029345f, 0.00769368f, 
    0.17278661f, 0.05497842f, 0.22844079f, 0.02187613f, -0.04531546f, -0.07260349f, -0.24764921f, -0.38859013f, 
    0.29074743f, 0.06553447f, 0.00949661f, -0.12656644f, -0.12482668f, -0.20356975f, -0.14606306f, 0.55693823f, 
    0.35310972f, -0.12159631f, -0.05643521f, 0.00967267f, -0.00286838f, -0.12292814f, 0.07375649f, -0.06549352f, 
    0.03663873f, -0.04354337f, -0.04712047f, -0.00231956f, 0.03094088f, -0.00285865f, 0.04228413f, 0.02027708f, 
    0.01972071f, 0.01267606f, 0.03162602f, -0.03990153f, 0.03328584f, 0.00297628f, -0.04374101f, 0.03493549f, 
    0.01070548f, -0.01510634f, -0.00072281f, -0.04406936f, -0.04723407f, -0.01338482f, 0.02946511f, -0.03534857f, 
    0.01107213f, 0.01366462f, 0.03423903f, -0.01212477f, 0.05292807f, 0.05736596f, -0.04654283f, 0.02668734f, 
    0.03194931f, -0.02423098f, 0.02525881f, 0.03516597f, 0.00638371f, -0.01774429f, -0.04982087f, -0.00571566f, 
    -0.04571199f, -0.03124916f, -0.04501625f, 0.02856140f, 0.03844482f, -0.04608946f, 0.00113993f, -0.04309642f, 
    -0.02780204f, -0.03460055f, -0.03550119f, -0.03632551f, -0.00461494f, 0.02633615f, -0.03179479f, -0.03073275f, 
    -0.03073026f, 0.05409894f, 0.05082357f, 0.01888314f, 0.00739738f, -0.02945075f, 0.01789490f, -0.01457349f, 
    0.04359618f, -0.00242646f, 0.00078895f, -0.02338374f, -0.03986071f, -0.05783194f, 0.04178716f, -0.03449292f, 
    0.02383378f, -0.00316665f, 0.00720455f, -0.00420684f, -0.02662259f, -0.05439823f, 0.04894837f, -0.01026106f, 
    0.03936890f, -0.03168340f, -0.03016728f, -0.04768233f, 0.03644345f, 0.04065708f, -0.03868356f, -0.02363782f, 
    -0.03453703f, 0.02075604f, 0.02510300f, -0.03654520f, -0.02328883f, 0.05371188f, 0.01338980f, -0.05663018f, 
    -0.02107990f, 0.01979723f, 0.02223825f, 0.00297231f, 0.01112556f, 0.04762203f, -0.02567097f, -0.01682509f, 
    -0.03998980f, -0.03435300f, 0.01072253f, -0.06274007f, 0.00265506f, -0.03288528f, 0.02289321f, 0.02989464f, 
    0.03880508f, 0.00343067f, -0.02155526f, -0.00447922f, -0.05940191f, 0.04789464f, -0.03374052f, -0.01075298f, 
    -0.01395284f, -0.05826768f, -0.00578870f, 0.00576911f, 0.03371339f, -0.03401388f, 0.02351077f, -0.03295443f, 
    -0.01964885f, -0.05112946f, 0.02752646f, 0.00649388f, -0.05092554f, -0.05504724f, -0.01072946f, -0.02195818f, 
    -0.03547907f, 0.04600237f, -0.05058254f, -0.03613503f, -0.00722488f, 0.01728707f, 0.01699521f, 0.02822519f, 
    -0.02613331f, 0.03793684f, 0.01526388f, -0.01238678f, 0.00136752f, 0.03049511f, 0.04596553f, 0.00628978f, 
    -0.04406191f, 0.04949040f, -0.00828166f, 0.03902702f, 0.03666396f, -0.00159867f, 0.00989269f, -0.03794418f, 
    -0.02586578f, -0.01992679f, -0.04993275f, 0.04311216f, -0.04225294f, -0.00435827f, 0.00007857f, -0.02946723f, 
    0.01807040f, 0.03896445f, 0.02714540f, 0.05601084f, 0.04891200f, -0.02176302f, -0.04723703f, -0.00409291f, 
    -0.04504038f, 0.02169690f, 0.00780066f, -0.06150247f, -0.00607697f, 0.05947392f, 0.01908544f, 0.01876610f, 
    0.02819275f, 0.02914649f, -0.05846447f, 0.05490370f, 0.00588529f, 0.01733868f, 0.03212053f, 0.01358032f, 
    -0.04845975f, -0.01687086f, 0.04365509f, 0.02556917f, -0.02099470f, -0.01544491f, 0.03425637f, 0.04407402f, 
    -0.05569499f, -0.04709979f, 0.00123853f, 0.01853937f, -0.05242001f, -0.03569635f, -0.03451283f, 0.02052109f, 
    -0.00584210f, -0.05547760f, -0.04983311f, 0.04935985f, -0.06182753f, -0.00006203f, -0.02911158f, 0.01593906f, 
    -0.04472581f, -0.03883499f, -0.05595841f, 0.02532297f, 0.01160932f, 0.04427702f, -0.02674265f, -0.00035900f, 
    0.00989867f, 0.00408342f, 0.01918827f, 0.03128749f, 0.01956909f, -0.02558488f, 0.04569411f, 0.03250041f, 
    -0.04679276f, 0.04238568f, 0.01532466f, -0.00869077f, -0.00073758f, -0.01885210f, -0.04977645f, -0.02743980f, 
    0.00346954f, -0.05077529f, 0.00738510f, -0.04006958f, -0.05087741f, 0.03020181f, -0.04825703f, 0.04828925f, 
    -0.02998265f, 0.00041761f, 0.00304965f, 0.01033313f, -0.05130283f, -0.03175574f, -0.04683512f, 0.03321458f, 
    -0.02713962f, -0.05314866f, -0.03027777f, -0.06817032f, -0.05519496f, -0.04601721f, 0.04303933f, -0.03879508f, 
    -0.00503016f, -0.06283054f, -0.01113698f, 0.02122789f, 0.01290894f, 0.01809670f, 0.04220617f, -0.02036363f, 
    -0.01353488f, -0.01050508f, 0.04547517f, -0.04130584f, 0.04038069f, 0.03005870f, -0.06484251f, 0.04132145f, 
    -0.05216093f, -0.05794096f, -0.05937586f, -0.03197067f, 0.05053488f, -0.02921861f, -0.02615380f, -0.01952157f, 
    -0.06040000f, 0.04190294f, -0.06456912f, 0.02321748f, 0.01588731f, -0.02486479f, -0.03015575f, 0.01178108f, 
    -0.00225469f, 0.01289606f, 0.01174306f, 0.04050383f, -0.06190478f, 0.04031402f, 0.02645890f, -0.01817110f, 
    -0.04374643f, -0.05941817f, -0.06911848f, -0.04334990f, -0.05984224f, 0.00196811f, -0.01694908f, -0.04532574f, 
    -0.02811302f, 0.02745033f, 0.00795098f, 0.02093918f, -0.03398499f, -0.02674479f, -0.05500458f, 0.03502769f, 
    0.00175827f, 0.04398940f, -0.06759862f, 0.01945998f, -0.05955292f, -0.06681558f, -0.05088056f, -0.02686753f, 
    0.03005766f, 0.01759568f, -0.02279396f, -0.05685172f, -0.04180836f, -0.03712282f, -0.03673453f, 0.02136550f, 
    -0.06894856f, 0.02819695f, 0.01528490f, -0.03118929f, -0.04799420f, 0.04295294f, 0.01085842f, -0.03293746f, 
    -0.02536072f, -0.04161044f, -0.01708253f, 0.01840003f, 0.02803884f, -0.02126752f, 0.03661347f, -0.00662066f, 
    -0.03074889f, -0.00457116f, -0.00738629f, 0.01015122f, -0.02901570f, -0.05963257f, -0.01140450f, -0.05327596f, 
    -0.00493894f, -0.01857769f, -0.05226958f, 0.04100116f, -0.05196942f, 0.04318261f, -0.04920473f, 0.03316304f, 
    -0.06017958f, 0.00507083f, -0.02772851f, 0.03018391f, 0.01513938f, 0.00500673f, 0.01618974f, 0.01409577f, 
    0.04658215f, 0.00980789f, -0.02898205f, 0.04059362f, -0.01951089f, -0.01015869f, 0.04641633f, 0.04329897f, 
    -0.05754856f, -0.02922691f, -0.05593019f, -0.03830178f, 0.04343807f, -0.05627755f, 0.02201103f, 0.04532108f, 
    0.01653338f, 0.04640891f, 0.04543106f, -0.05994665f, 0.00662959f, -0.03216248f, 0.00369964f, 0.02450766f, 
    -0.04589273f, -0.04687481f, -0.05489394f, 0.01128959f, 0.02414337f, -0.06898954f, -0.03175377f, -0.06770661f, 
    0.00650641f, -0.01721246f, -0.04011850f, 0.03077937f, -0.05947154f, 0.00915234f, 0.03206432f, 0.00493597f, 
    -0.03881598f, -0.06067273f, -0.06298810f, -0.03376313f, -0.00872343f, 0.01904928f, -0.04855017f, 0.02178196f, 
    0.02883943f, -0.06355981f, -0.01423032f, 0.04382799f, -0.04513826f, -0.04519726f, 0.02278905f, -0.01512600f, 
    -0.04608751f, 0.03675225f, -0.06968874f, -0.03767193f, 0.03278180f, 0.02866706f, -0.01927623f, -0.01733984f, 
    -0.05601883f, 0.03156423f, -0.04126363f, 0.04655292f, 0.02500148f, 0.04100871f, 0.03540406f, -0.02036534f, 
    0.02279810f, -0.04867953f, -0.02838961f, 0.03573086f, -0.02921284f, -0.04511714f, -0.05442132f, 0.03136976f, 
    -0.06061555f, 0.02649200f, -0.00737046f, 0.00204766f, 0.06018748f, 0.00887631f, 0.02926675f, -0.03430580f, 
    -0.06442982f, -0.06225692f, -0.01759367f, -0.06054317f, -0.02524477f, 0.02576682f, -0.05463479f, -0.06094825f, 
    -0.01244057f, 0.03643349f, -0.03182960f, -0.01224617f, -0.06559846f, -0.05849752f, -0.03175615f, -0.03268608f, 
    0.02615980f, 0.03500320f, 0.02366065f, 0.02489270f, 0.01446120f, 0.01067252f, 0.02978842f, -0.04617577f, 
    -0.00921146f, -0.00365188f, -0.04787194f, 0.02336041f, -0.03459265f, -0.02123369f, 0.04360054f, -0.00654770f, 
    -0.01003208f, 0.02028630f, -0.00103107f, -0.00997478f, -0.01209473f, 0.02523586f, -0.00504296f, 0.04025021f, 
    0.00509973f, -0.03320353f, -0.01015905f, -0.06113023f, 0.04209764f, -0.06152468f, -0.04864201f, 0.02888689f, 
    -0.05458898f, 0.03516703f, -0.03091851f, -0.03717042f, 0.00919069f, -0.04518608f, -0.06586260f, 0.04241049f, 
    0.02600778f, 0.01439619f, -0.02647918f, 0.03585226f, -0.01153491f, -0.01968188f, -0.05868810f, -0.02605772f, 
    -0.03830944f, -0.03192132f, -0.03031370f, -0.00715721f, -0.06060395f, -0.03643924f, -0.02142138f, -0.02406630f, 
    -0.04561370f, -0.05415846f, 0.01476653f, -0.04353996f, -0.02373949f, -0.03859095f, 0.03017021f, -0.00354678f, 
    -0.02256300f, 0.02162387f, -0.05096677f, -0.04888857f, 0.00857636f, 0.02481426f, -0.02116530f, -0.03536553f, 
    -0.01583126f, 0.00309888f, 0.02837617f, 0.02248638f, -0.02212551f, -0.02180510f, -0.01865100f, 0.04058253f, 
    0.01900544f, -0.00704071f, -0.03231795f, 0.02749275f, 0.00762321f, -0.04021572f, -0.05742487f, 0.00918455f, 
    0.01265818f, -0.02887858f, 0.02953519f, -0.02111045f, -0.03274703f, 0.01517245f, -0.00741593f, -0.00921841f, 
    0.04768827f, -0.05170018f, 0.00368690f, 0.03615179f, -0.03071177f, -0.06732303f, -0.01280643f, 0.03916904f, 
    -0.05883996f, -0.06437457f, 0.01351961f, 0.04894169f, 0.01080259f, 0.03756091f, 0.00972877f, -0.05767772f, 
    0.00263757f, 0.02820594f, -0.00226212f, -0.02679109f, -0.00424333f, -0.01332653f, -0.03760327f, -0.02960249f, 
    -0.05365156f, -0.00459901f, 0.00170493f, -0.04896788f, -0.03401966f, -0.05862222f, -0.06046742f, 0.03403170f, 
    -0.06398042f, -0.05920176f, 0.02500586f, 0.03715580f, -0.03556808f, 0.01129760f, -0.01673092f, 0.03768742f, 
    0.03093329f, -0.01125052f, -0.03681745f, -0.05142417f, 0.04954525f, 0.03911188f, 0.00811318f, -0.03017239f, 
    0.01339779f, -0.03960373f, 0.01872895f, 0.00101919f, -0.00314151f, -0.06965112f, -0.05340956f, -0.03438538f, 
    -0.03556662f, -0.04525562f, 0.01666384f, -0.00066148f, -0.02438159f, -0.05097755f, -0.03212218f, -0.02531698f, 
    0.02090444f, -0.00589352f, 0.02126984f, 0.03164195f, -0.00750472f, -0.05709051f, -0.06796222f, -0.03484762f, 
    0.00211948f, 0.00509427f, -0.06106284f, -0.03495722f, 0.04081938f, -0.02201048f, 0.03571391f, 0.04504223f, 
    -0.03088882f, -0.01067631f, 0.01190839f, -0.00986196f, -0.02768042f, -0.01814130f, -0.00719819f, 0.05028002f, 
    0.02850587f, -0.03661608f, 0.03373433f, 0.00556973f, 0.03113137f, -0.01028555f, -0.00297883f, -0.02719660f, 
    -0.02189242f, 0.05036856f, -0.04187424f, -0.05845906f, -0.00485745f, 0.04160102f, -0.04919994f, 0.04570285f, 
    -0.01303294f, 0.01870121f, -0.02984128f, -0.02910868f, 0.00772495f, 0.03396336f, 0.00215686f, 0.02137113f, 
    -0.00209783f, -0.05547174f, 0.04192627f, -0.04130450f, 0.01470800f, 0.03196952f, -0.05307865f, -0.02949108f, 
    -0.02672301f, -0.03411085f, -0.03135816f, 0.03515279f, -0.00897060f, 0.02657124f, -0.05352484f, 0.04646358f, 
    -0.06219227f, -0.00126511f, -0.04038008f, -0.04395727f, 0.04033756f, -0.04192227f, 0.00917281f, -0.04994388f, 
    0.03717186f, -0.04170666f, 0.00844536f, 0.03134041f, -0.04683940f, 0.03320454f, -0.01449571f, 0.03165254f, 
    0.00151801f, 0.00766922f, -0.06033173f, 0.00883608f, -0.00066503f, -0.04289362f, 0.00278286f, 0.01338414f, 
    0.02257791f, 0.02295303f, -0.05785986f, 0.03998977f, 0.02264009f, -0.03231854f, 0.00311643f, -0.06166648f, 
    -0.03223404f, 0.04488000f, -0.04993114f, -0.05353776f, -0.03503761f, -0.04942672f, -0.05800726f, -0.04203296f, 
    -0.02815900f, -0.03658760f, 0.04313480f, -0.05762564f, -0.03324181f, -0.01240143f, -0.00018575f, 0.03219133f, 
    -0.05982539f, -0.02613135f, 0.01790798f, 0.04087245f, 0.02266560f, -0.02140530f, 0.01907360f, 0.03692549f, 
    -0.02589399f, 0.04070451f, -0.02562414f, -0.00983233f, -0.01766597f, -0.01676192f, -0.00832209f, -0.04350026f, 
    -0.05010327f, -0.03412285f, -0.04340917f, -0.01948230f, 0.05105850f, -0.04678261f, 0.02037148f, -0.01673537f, 
    -0.03816657f, -0.05400981f, -0.04130867f, -0.03559528f, -0.02317608f, -0.01279281f, 0.00985917f, 0.00855697f, 
    0.03692685f, 0.02418711f, -0.02690979f, 0.02727716f, 0.02223073f, -0.05730306f, 0.00449464f, 0.03025922f, 
    0.00532994f, -0.03207877f, 0.03512176f, -0.04576527f, 0.03229232f, -0.03400602f, 0.03936357f, -0.01480747f, 
    -0.01855184f, 0.04740984f, -0.05023620f, -0.00628248f, -0.01144082f, 0.02996150f, -0.01029423f, 0.01015604f, 
    0.04791380f, 0.03015792f, -0.06762449f, 0.04749914f, 0.04090426f, 0.02121751f, -0.00307427f, -0.01960558f, 
    -0.00958189f, -0.05609664f, 0.03918764f, 0.03992440f, 0.03147956f, 0.03589696f, 0.02005450f, -0.00630871f, 
    -0.02644593f, -0.05530816f, -0.00704549f, -0.00572309f, -0.05774768f, 0.01807997f, -0.01045843f, -0.01116009f, 
    -0.05595281f, 0.04766714f, 0.02614991f, -0.02170423f, 0.01414599f, 0.03246802f, -0.04843400f, -0.02542612f, 
    -0.03726294f, -0.05649067f, -0.05586831f, 0.02719350f, -0.04239525f, -0.00930822f, -0.04800508f, -0.03735096f, 
    0.02530312f, 0.03113512f, -0.04382233f, 0.02736589f, -0.05297080f, -0.06995315f, -0.01318553f, -0.05865840f, 
    -0.05983876f, -0.00858938f, -0.06156447f, 0.03316939f, -0.01973912f, 0.01147597f, 0.02314314f, -0.06343092f, 
    0.09268582f, 0.15718152f, 0.16865006f, -0.16346264f, 0.12017933f, 0.21641724f, -0.07393546f, -0.00153143f, 
    0.08334939f, -0.07736882f, 0.27988601f, -0.00660041f, -0.30668089f, -0.09905768f, 0.09028349f, 0.10146061f, 
    -0.03082624f, 0.00865620f, -0.20279463f, 0.02773706f, -0.10984401f, -0.11147205f, -0.16402914f, 0.13488042f, 
    0.14785776f, 0.14019783f, 0.03549330f, -0.07983685f, 0.51293516f, -0.41120529f, -0.04599448f, -0.03785755f, 
    -0.06312519f, 0.09451693f, 0.07327151f, -0.26948580f, -0.17252094f, -0.60327995f, 0.11229242f, -0.08077037f, 
    0.08704986f, 0.04722164f, -0.10180900f, 0.02951249f, -0.04182492f, 0.33222392f, 0.01992504f, 0.01456551f, 
    -0.04167729f, -0.01601670f, -0.03023381f, 0.03839125f, 0.11885384f, -0.11119103f, 0.08606077f, -0.11040513f, 
    0.04304971f, -0.13663779f, 0.16858952f, -0.00218597f, 0.17309578f, -0.09184329f, 0.20528190f, 0.13059439f, 
    0.07929755f, -0.11699631f, -0.06740322f, 0.01383051f, -0.01456496f, 0.06726375f, -0.03770015f, 0.08046237f, 
    0.21397740f, 0.11477450f, -0.20520619f, -0.06529851f, 0.00356781f, 0.01116352f, 0.07718778f, -0.08557387f, 
    -0.02033173f, -0.05738670f, 0.11112071f, -0.19556700f, -0.29454440f, 0.06626081f, -0.00666907f, 0.20098387f, 
    0.14912780f, 0.08788282f, 0.16038828f, 0.22147995f, 0.01908956f, -0.12873574f, 0.02653183f, 0.23395997f, 
    -0.09129959f, -0.00913307f, 0.23852517f, -0.22745301f, 0.04013720f, -0.04806589f, -0.13674606f, 0.00449918f, 
    -0.10667109f, 0.15085146f, 0.03647776f, -0.09327079f, 0.46548650f, 0.06812710f, -0.18508425f, 0.02347082f, 
    0.14336860f, 0.22661655f, 0.14779179f, -0.11240222f, -0.12452882f, 0.21660383f, 0.15229702f, -0.10473244f, 
    -0.13470909f, 0.05495967f, -0.16387939f, 0.22591317f, 0.07769827f, -0.17080085f, -0.18939286f, -0.69546133f, 
    -0.16095696f, 0.08695152f, -0.01871594f, 0.28557947f, -0.14302954f, 0.01362209f, -0.02987716f, -0.25822437f, 
    -0.13372229f, 0.02943038f, -0.04960528f, 0.12977320f, 0.01483663f, -0.19848296f, -0.05660871f, -0.04982203f, 
    -0.03099936f, 0.34609130f, -0.28206423f, 0.09217285f, -0.10328917f, -0.18068250f, -0.05608460f, 0.10581611f, 
    -0.27936691f, 0.49038100f, 0.13853978f, -0.05069681f, -0.00584599f, 0.07779114f, 0.04684119f, 0.05445569f, 
    0.07374379f, 0.25640920f, -0.51744395f, -0.13522483f, 0.10955990f, -0.06692875f, 0.12921470f, 0.10851410f, 
    0.00491487f, 0.20911449f, -0.05088725f, 0.11883982f, -0.29082534f, -0.05683765f, 0.03331400f, -0.13477467f, 
    0.11040567f, 0.13835348f, -0.02636009f, -0.03850440f, 0.27135286f, 0.08609279f, -0.27047110f, 0.14618295f, 
    -0.07327969f, 0.01038029f, 0.20965970f, 0.15050961f, -0.05267702f, 0.48354918f, 0.16081367f, -0.09010182f, 
    -0.19749805f, -0.18295901f, -0.12853117f, 0.06900881f, -0.08791951f, -0.11917290f, 0.15961261f, -0.06053614f, 
    0.07386529f, -0.01348171f, 0.03925727f, -0.09914567f, 0.08893447f, 0.04476512f, -0.04282701f, -0.27575457f, 
    -0.18124598f, -0.01762813f, 0.09367979f, 0.03406021f, 0.01048787f, -0.04029406f, 0.21319592f, -0.09629717f, 
    0.22455917f, -0.01622362f, 0.24428906f, -0.10917140f, 0.21644768f, -0.07524893f, -0.04088250f, -0.11189270f, 
    0.27434146f, 0.02821687f, 0.42078838f, 0.03208052f, -0.32469404f, 0.04108911f, 0.01590087f, -0.00975376f, 
    0.08576696f, 0.14877750f, -0.17836739f, 0.27875194f, -0.25016084f, -0.11428743f, 0.01542955f, -0.20674728f, 
    0.06954226f, 0.25096297f, 0.08875332f, -0.01502613f, 0.02522107f, 0.10124060f, 0.16952783f, 0.05403911f, 
    0.04774163f, 0.02240695f, 0.04832032f, 0.10171676f, -0.59911090f, -0.09318430f, 0.03689181f, 0.21735778f, 
    0.06419151f, 0.05842446f, -0.00395035f, 0.13459805f, -0.01170029f, -0.13476488f, -0.12947607f, 0.05287443f, 
    -0.20721710f, -0.04837954f, 0.03331125f, 0.02275174f, 0.12899227f, -0.20837264f, 0.00689105f, -0.16089664f, 
    0.01872729f, 0.01895408f, 0.07222039f, 0.08835082f, -0.00244583f, -0.19094235f, 0.22397146f, -0.06106807f, 
    -0.23124336f, -0.01338552f, -0.04290529f, 0.09342463f, -0.16912015f, -0.06210404f, 0.00430600f, -0.09136176f, 
    -0.12925516f, -0.03068778f, 0.23088928f, -0.16538055f, 0.10755892f, 0.08589200f, -0.08827825f, -0.12454627f, 
    0.04589943f, -0.21482496f, -0.39016688f, -0.15704754f, 0.05747810f, -0.09893627f, 0.15100208f, -0.03909793f, 
    0.03763828f, 0.00470803f, -0.10402231f, -0.14861715f, -0.20295723f, 0.00924869f, -0.06604632f, -0.08255085f, 
    -0.13393830f, 0.09072545f, 0.04750067f, -0.47336996f, -0.31975412f, 0.28682822f, -0.00168382f, 0.02843538f, 
    0.14654639f, -0.17698601f, -0.00145488f, 0.04665866f, 0.24435818f, 0.21920405f, -0.12574306f, 0.07290412f, 
    0.05835932f, 0.00969474f, -0.03285256f, -0.02941779f, 0.16528822f, -0.20007442f, 0.17752203f, 0.25107729f, 
    -0.01312357f, -0.13093510f, -0.23014893f, 0.08721847f, 0.03033908f, -0.11450376f, 0.32381171f, 0.13283041f, 
    -0.01206061f, 0.28883243f, 0.11996911f, -0.17522976f, -0.23696725f, -0.10291557f, 0.25876433f, 0.03939955f, 
    0.01496152f, 0.19898677f, 0.02257006f, 0.20781180f, -0.02763673f, 0.05935800f, -0.00596904f, 0.03444399f, 
    -0.28475344f, 0.19471940f, 0.05588897f, 0.07625134f, -0.05553239f, 0.12256974f, 0.10965186f, 0.08469786f, 
    0.01596331f, -0.04394192f, -0.05739911f, 0.06303567f, -0.00882920f, -0.05266555f, 0.02142177f, 0.18106160f, 
    -0.03960502f, 0.02910539f, -0.60418296f, -0.26353481f, 0.02423423f, -0.09445117f, -0.00379144f, 0.19534595f, 
    -0.06023497f, -0.06639516f, 0.03396526f, -0.10152842f, -0.14081091f, 0.24425822f, 0.01860808f, 0.06801381f, 
    -0.20530123f, 0.19314362f, -0.16727819f, -0.02359013f, -0.35142016f, -0.41280532f, 0.16953978f, 0.00574175f, 
    -0.04337312f, 0.20013176f, -0.05696828f, -0.09218869f, -0.25177690f, -0.16569701f, -0.14967501f, 0.22031957f, 
    0.04984742f, 0.24731979f, 0.00594230f, 0.08554402f, -0.12074535f, -0.04551101f, 0.10125227f, 0.07328714f, 
    -0.07272145f, 0.02925571f, -0.04627557f, -0.02261285f, -0.06283063f, -0.01897768f, 0.11200418f, -0.17586446f, 
    -0.22187619f, -0.15286422f, -0.15714830f, 0.11129636f, 0.04854771f, -0.13610905f, -0.06326607f, 0.05811713f, 
    0.17184858f, 0.03075609f, 0.11334381f, 0.03118121f, -0.01593022f, 0.20576124f, 0.15551332f, -0.10338356f, 
    -0.10423493f, -0.06493683f, 0.18725134f, 0.14078891f, 0.18393712f, -0.03654273f, -0.03283446f, -0.04194710f, 
    0.05495179f, -0.07753564f, 0.46563008f, -0.05540253f, -0.38915601f, 0.02668892f, -0.24806482f, 0.14915963f, 
    0.04483392f, 0.05822990f, 0.11084004f, -0.13169803f, 0.13435137f, 0.18328734f, 0.01273741f, -0.23298034f, 
    -0.09876955f, -0.05660449f, -0.00258194f, 0.03497921f, 0.09343606f, 0.03356157f, 0.31868663f, -0.19666792f, 
    -0.19642322f, 0.07270523f, -0.08438215f, -0.10723510f, 0.01453425f, -0.19234452f, -0.10043096f, 0.29862049f, 
    -0.24961361f, 0.04908736f, -0.28623247f, 0.00127573f, -0.05364755f, -0.24007130f, -0.25587934f, -0.26082590f, 
    -0.15162823f, 0.05442591f, -0.06524455f, 0.21104935f, 0.10316733f, 0.16059251f, 0.06043169f, 0.14893083f, 
    -0.06666256f, -0.01477770f, -0.18159807f, -0.00383036f, 0.01206996f, 0.28774211f, 0.12643521f, 0.19965197f, 
    -0.15388642f, -0.22711976f, 0.33794245f, -0.01520227f, 0.05030725f, -0.14661667f, 0.13676399f, 0.07065707f, 
    0.01894389f, -0.07612207f, -0.12621535f, 0.16028105f, -0.08426282f, 0.00605800f, -0.01735063f, -0.11238945f, 
    -0.03384696f, 0.17578691f, -0.08174935f, -0.15350282f, 0.08322965f, 0.14112709f, -0.04169907f, 0.09550753f, 
    -0.08605970f, -0.09900226f, -0.20343415f, -0.19290620f, -0.11860020f, -0.19638859f, 0.01865921f, -0.07990328f, 
    -0.02668938f, 0.08999670f, 0.03277451f, -0.07466833f, 0.06366891f, 0.06701487f, 0.04655494f, 0.19443956f, 
    -0.28902194f, 0.12294469f, 0.22865005f, -0.08073846f, -0.07688469f, 0.08336379f, 0.37755004f, 0.19107439f, 
    0.16832869f, -0.04849964f, -0.05928152f, -0.07403516f, -0.13817662f, 0.18301857f, 0.08066898f, 0.24696650f, 
    0.21597840f, 0.13734812f, 0.13336098f, -0.03979958f, 0.16079296f, 0.08380701f, 0.02925215f, 0.13179390f, 
    0.08262588f, 0.25526005f, -0.01490622f, -0.08005998f, -0.12991746f, -0.06806771f, 0.01759850f, 0.03777120f, 
    -0.26915872f, 0.00022970f, -0.19683990f, 0.09640626f, -0.17459209f, 0.07236778f, 0.28453723f, -0.14788009f, 
    -0.17278893f, -0.18316768f, 0.23329107f, -0.48162428f, 0.15136622f, 0.12580758f, 0.04363538f, -0.01255981f, 
    -0.06970840f, -0.12930517f, 0.12291417f, -0.18452664f, -0.17903429f, 0.09606972f, -0.15893953f, 0.15379527f, 
    0.08401247f, 0.04641489f, 0.20935977f, -0.57107198f, -0.33248633f, 0.13630252f, -0.07563121f, -0.05648281f, 
    -0.14851172f, -0.17766429f, -0.22131483f, -0.08022175f, 0.14995909f, -0.24169753f, 0.04540264f, -0.18161766f, 
    0.00468424f, 0.13520685f, 0.15669474f, 0.11869920f, 0.02810431f, 0.03621259f, 0.09450375f, 0.20683964f, 
    -0.13026400f, -0.07760561f, 0.01594202f, 0.16931731f, -0.03503213f, 0.17758586f, -0.33685622f, 0.02208189f, 
    0.11014652f, 0.01064428f, -0.17410785f, 0.19054359f, 0.08237408f, 0.03191841f, 0.00156652f, 0.26843789f, 
    0.01270560f, -0.38472149f, 0.05673903f, 0.15967067f, 0.01049049f, -0.04263779f, 0.14719188f, -0.02133884f, 
    -0.04363524f, -0.24767686f, 0.26033390f, 0.14079711f, 0.03735200f, -0.07033675f, -0.17735927f, 0.14419799f, 
    -0.28651166f, 0.25615865f, 0.10310765f, -0.23733026f, 0.15913637f, 0.11791421f, 0.09710831f, -0.11566120f, 
    0.03492669f, -0.18686897f, 0.38795608f, 0.04638381f, -0.15814143f, 0.28913459f, 0.02293363f, 0.00948980f, 
    -0.01056750f, -0.07806177f, 0.05601661f, -0.13660079f, 0.10844873f, -0.08174609f, -0.01369804f, -0.05177021f, 
    0.14246781f, -0.16275069f, 0.11157040f, 0.08079379f, -0.20397651f, 0.07687067f, -0.03845249f, -0.00143515f, 
    -0.13920127f, -0.03369775f, -0.31467700f, -0.06903666f, 0.10522096f, 0.54455316f, 0.06274787f, -0.39887667f, 
    -0.00179283f, 0.06370281f, -0.13204022f, 0.08481124f, -0.02079555f, -0.13362834f, -0.13138443f, -0.28969398f, 
    0.01932613f, -0.26993480f, 0.10234853f, -0.09175295f, -0.03828574f, 0.09230615f, 0.18503428f, 0.33129030f, 
    0.07030409f, 0.16740887f, 0.13123102f, 0.05705311f, 0.06795454f, -0.01125283f, -0.07405424f, 0.19812536f, 
    -0.52144343f, -0.36674407f, 0.22324270f, 0.05617473f, 0.06734633f, 0.11154400f, 0.00324457f, -0.00581299f, 
    -0.19428922f, 0.02627884f, 0.07603716f, 0.12451398f, -0.21680953f, -0.14243993f, 0.02183269f, -0.20696093f, 
    0.06502923f, -0.03991387f, 0.06789520f, 0.03422846f, 0.00669466f, -0.08378673f, -0.08425085f, 0.09576944f, 
    0.32729679f, 0.18702045f, 0.04099127f, 0.05199738f, -0.02902818f, -0.05525088f, -0.25815058f, -0.07192970f, 
    0.07205797f, -0.13827570f, -0.02246273f, 0.08655110f, 0.19380401f, -0.55268365f, -0.35675427f, -0.03332061f, 
    0.22995985f, -0.10449007f, -0.06167222f, -0.03613903f, -0.09676018f, -0.41007292f, -0.18949775f, 0.32801291f, 
    -0.13040411f, 0.01474690f, 0.12987512f, -0.07075078f, 0.25077173f, 0.40633532f, -0.50408894f, 0.00234957f, 
    0.16460522f, 0.10127612f, 0.01774997f, 0.13006982f, -0.14982867f, -0.19610348f, 0.12049233f, -0.01226891f, 
    0.12870409f, -0.12680781f, 0.06405683f, 0.01873918f, -0.02309594f, 0.15163125f, 0.25351483f, 0.05484511f, 
    0.36863366f, -0.01639664f, 0.13584211f, 0.23630925f, 0.05880405f, 0.05257418f, -0.13712586f, 0.17546363f, 
    -0.09622463f, 0.43980989f, 0.60212660f, 0.04601102f, 0.06174985f, -0.06926855f, -0.15016669f, 0.09164208f, 
    0.05156002f, -0.02419496f, -0.31494427f, -0.16356662f, -0.12923259f, -0.02943665f, 0.09759312f, 0.06769161f, 
    0.06394071f, 0.13636985f, 0.05187576f, -0.54207742f, 0.11786044f, 0.19684988f, -0.04369431f, -0.10004321f, 
    0.10076657f, 0.00809194f, -0.08366533f, 0.19995624f, 0.28836432f, -0.09188148f, 0.10181169f, 0.09797852f, 
    -0.11806459f, -0.16075906f, 0.13810816f, 0.16581407f, 0.07459544f, -0.39195138f, 0.08951013f, -0.10914410f, 
    -0.05953190f, -0.15271404f, 0.03251787f, 0.00763818f, -0.04915033f, 0.28582022f, -0.00653195f, -0.23560266f, 
    0.16913907f, -0.24534123f, -0.09203879f, -0.00335429f, -0.15345146f, 0.16719040f, 0.04320384f, -0.14252882f, 
    0.06459331f, -0.00022623f, -0.03955235f, 0.00497049f, 0.07917178f, 0.10906236f, 0.14350161f, 0.28267193f, 
    -0.18456553f, 0.15215586f, 0.17895968f, 0.08181912f, 0.17398559f, -0.13161843f, -0.08820625f, -0.01348561f, 
    -0.04085847f, 0.30075336f, -0.11410273f, -0.05953002f, -0.11063903f, 0.11664408f, -0.13568647f, -0.05312894f, 
    -0.09327715f, 0.08143514f, 0.17388186f, 0.08984800f, -0.25960276f, -0.11734294f, -0.02727904f, -0.15104027f, 
    0.08466679f, 0.12995289f, 0.18316352f, 0.50501484f, -0.27699965f, -0.24590644f, 0.04783805f, 0.20003970f, 
    0.20061530f, -0.09553980f, -0.11440407f, -0.12225519f, -0.17227770f, -0.07652121f, 0.14069225f, 0.14612554f, 
    0.27178526f, 0.07583921f, 0.07570140f, -0.06512292f, 0.09696213f, 0.07956334f, 0.08337560f, 0.17411360f, 
    0.08062784f, 0.07216340f, 0.13697957f, -0.09785622f, 0.11383428f, -0.03089736f, 0.35443744f, -0.30710617f, 
    -0.54177028f, -0.06463636f, 0.02931098f, 0.11513210f, -0.10129216f, -0.09791051f, 0.13715847f, 0.55552286f, 
    0.21169135f, 0.34103876f, -0.13118142f, 0.09845488f, -0.04850073f, -0.09118444f, 0.04605361f, 0.09753304f, 
    -0.28986952f, 0.04048584f, -0.02997573f, -0.14056800f, -0.08925613f, -0.03106520f, -0.07956985f, 0.10941844f, 
    0.01474303f, 0.16450937f, 0.03462785f, 0.20410775f, -0.02274798f, 0.00745763f, -0.19245045f, 0.09610711f, 
    0.01263132f, -0.12733650f, 0.20323560f, 0.30558300f, 0.20513183f, -0.13128875f, -0.08158865f, -0.01967571f, 
    -0.03592973f, 0.02640306f, 0.03772378f, -0.08034269f, 0.20230094f, -0.38074154f, -0.18722521f, 0.03275136f, 
    -0.00585148f, -0.01444953f, 0.04795340f, 0.04626202f, 0.10708012f, -0.14980127f, -0.01489687f, -0.06994621f, 
    -0.13138482f, 0.20762683f, 0.04095991f, 0.05875979f, -0.00638963f, 0.23555163f, 0.31094986f, 0.11731566f, 
    -0.10814289f, -0.06815146f, 0.07698869f, 0.18155231f, -0.00064611f, -0.05231239f, -0.32840806f, 0.09661867f, 
    -0.17012031f, 0.23047689f, 0.10477252f, 0.14610885f, -0.09792180f, -0.01219813f, 0.18520363f, -0.83542371f, 
    0.11306692f, -0.00759100f, 0.12078988f, 0.17041121f, -0.28137442f, 0.06127752f, -0.13037106f, 0.08049852f, 
    -0.12961198f, -0.14966825f, -0.01038997f, -0.03215526f, 0.05823872f, -0.08475344f, 0.02070778f, -0.10025567f, 
    -0.17268226f, -0.02152112f, -0.08866547f, 0.29525709f, 0.08560979f, 0.03655546f, 0.24736650f, -0.08212493f, 
    -0.09929562f, 0.02519470f, -0.05072314f, -0.18055151f, 0.27003241f, -0.07309996f, 0.02324509f, 0.05169025f, 
    0.06737737f, 0.09706865f, 0.10770757f, -0.57650357f, 0.16371304f, -0.08526686f, 0.02603189f, 0.09526197f, 
    0.04935747f, -0.15688826f, 0.14950112f, 0.04242020f, 0.10299339f, 0.19308193f, 0.25314796f, -0.22908953f, 
    0.00176312f, -0.13830294f, -0.02143281f, 0.11615036f, 0.03333941f, 0.16391216f, 0.13466156f, 0.04232620f, 
    -0.08873112f, -0.08352134f, 0.08255443f, -0.14500855f, 0.09769320f, -0.12993500f, 0.09155108f, -0.01297867f, 
    0.06886829f, -0.18176162f, -0.23761685f, 0.16608211f, 0.15506133f, -0.01242936f, -0.04985701f, 0.25827712f, 
    0.25494495f, -0.11358407f, 0.05754267f, -0.14483698f, 0.10435626f, 0.08056387f, 0.04225734f, -0.02481823f, 
    -0.07632716f, 0.34770685f, 0.16872792f, 0.13109912f, 0.08831275f, 0.04974999f, 0.02193532f, -0.01484884f, 
    -0.16841626f, 0.78536052f, 0.29382989f, -0.06279913f, -0.11419728f, -0.27853599f, 0.01143048f, 0.11688004f, 
    0.04828890f, -0.08458386f, 0.50396872f, -0.23385906f, 0.16034424f, -0.25626835f, -0.04774521f, -0.29341203f, 
    -0.03970689f, -0.16326195f, 0.11569351f, 0.38344091f, -0.00633725f, 0.12814420f, -0.19820571f, -0.35985583f, 
    0.11922231f, -0.00765648f, 0.03712339f, 0.01583350f, 0.00960451f, -0.17268990f, 0.01514078f, 0.06099464f, 
    0.22419092f, 0.11617950f, -0.22184436f, 0.11229999f, 0.09883378f, 0.30380738f, -0.17220040f, -0.31789985f, 
    -0.01520826f, -0.01622861f, 0.12163536f, -0.11329623f, -0.19564624f, -0.04775416f, -0.66298717f, 0.23465584f, 
    -0.12657362f, 0.04945276f, 0.10081621f, 0.22861834f, -0.14735582f, 0.05741263f, 0.01584922f, -0.66148913f, 
    -0.37091631f, -0.06264348f, 0.10150701f, 0.10418150f, -0.32748508f, 0.09418949f, 0.09886654f, -0.05893506f, 
    -0.03296271f, -0.03071114f, -0.01926742f, -0.02488672f, -0.02375480f, 0.01534678f, 0.01097171f, -0.03661585f, 
    0.00446977f, -0.03554513f, 0.02663489f, -0.05219882f, 0.05367632f, -0.00520928f, 0.03442816f, -0.05213224f, 
    -0.03509679f, 0.00830511f, -0.04345835f, 0.04871469f, 0.04444386f, 0.04184422f, -0.01893164f, 0.02740340f, 
    0.01690483f, -0.02133266f, -0.02739475f, 0.02758657f, -0.03162103f, -0.00920922f, -0.00671586f, -0.03885160f, 
    0.01212644f, -0.06114198f, -0.02137923f, 0.04281956f, -0.05237304f, -0.00666570f, 0.00223982f, -0.04456761f, 
    -0.01741919f, 0.03009871f, -0.04026583f, -0.02292572f, -0.00432390f, -0.01469964f, 0.00211049f, 0.02417545f, 
    -0.03773181f, -0.04650617f, 0.01114960f, 0.02546722f, -0.00348640f, -0.03755735f, -0.02369981f, 0.00036632f, 
    -0.04699551f, 0.01323666f, -0.00781459f, 0.01575835f, 0.00349381f, -0.02203252f, 0.01331745f, 0.02952161f, 
    0.05032485f, -0.01863860f, -0.04383147f, -0.05964481f, -0.06166752f, 0.04877444f, 0.04356968f, 0.03750028f, 
    0.01257994f, -0.00977262f, -0.06138436f, -0.02212469f, 0.00282555f, 0.00205584f, -0.03363528f, 0.00809315f, 
    0.04699679f, -0.06222382f, 0.00117541f, -0.03311123f, 0.04183303f, -0.00826331f, 0.04745866f, 0.04250000f, 
    -0.02145239f, 0.01252235f, 0.03911988f, 0.02657562f, 0.05090754f, 0.00318650f, 0.03657662f, 0.00854331f, 
    -0.03078092f, 0.05355699f, 0.04752685f, 0.01552443f, -0.04389095f, -0.05739214f, 0.01132016f, -0.01364939f, 
    -0.06555793f, -0.05521186f, 0.03007499f, 0.02537660f, 0.03133170f, 0.02123280f, -0.02289248f, -0.01524121f, 
    -0.03364658f, -0.05019777f, 0.02692728f, 0.00661669f, 0.05240943f, 0.00698308f, -0.03148103f, -0.03867813f, 
    -0.03198282f, 0.04987465f, 0.04658577f, 0.04579045f, 0.03338791f, 0.01923415f, 0.03367468f, 0.00940948f, 
    0.02569900f, -0.06027006f, -0.00914712f, 0.04055509f, 0.01659112f, -0.05040511f, 0.03182742f, -0.02403632f, 
    -0.05120844f, -0.01595447f, -0.03610671f, -0.04755298f, -0.04193872f, 0.00763111f, -0.00137823f, -0.03636945f, 
    -0.05899025f, -0.05970365f, 0.02320036f, -0.01418464f, 0.04224503f, 0.02781808f, 0.02363757f, -0.00228513f, 
    0.04486258f, 0.01732763f, -0.01228654f, -0.03057667f, -0.00916145f, 0.01258470f, -0.02890921f, 0.04824740f, 
    -0.05333075f, -0.00165356f, 0.03567619f, 0.04778773f, -0.04871546f, -0.06858589f, -0.05643594f, -0.02727757f, 
    0.01799857f, -0.00353430f, -0.02531048f, -0.05961451f, -0.02315437f, 0.04555455f, 0.02158324f, -0.03187748f, 
    -0.06290958f, -0.01845698f, -0.00340155f, -0.02034900f, 0.01451329f, 0.00662888f, -0.05161502f, -0.01496602f, 
    0.03820022f, 0.03202447f, -0.03845817f, 0.05472511f, 0.00234685f, 0.02027393f, -0.05398379f, -0.01963434f, 
    0.04669203f, 0.00587317f, -0.07137387f, -0.00641067f, -0.02414926f, 0.00956806f, -0.04073045f, -0.02845399f, 
    0.04063646f, 0.04517226f, 0.03226002f, 0.02687660f, -0.04221049f, -0.00152296f, -0.05808124f, -0.07339761f, 
    -0.00284180f, 0.04223458f, -0.01300175f, -0.05824368f, 0.02668854f, -0.04253297f, -0.04591522f, 0.03084961f, 
    -0.03789512f, 0.00148028f, 0.01251087f, -0.03137053f, 0.00275554f, -0.01456407f, -0.00315197f, -0.01754808f, 
    -0.02796514f, 0.04142386f, -0.00688265f, -0.00294462f, 0.02229779f, 0.04261837f, 0.03957038f, 0.00611724f, 
    -0.02560086f, -0.02175741f, 0.03498852f, 0.05017877f, 0.01224201f, -0.05490475f, 0.02033176f, -0.05566894f, 
    -0.02874541f, 0.03450206f, 0.01325332f, 0.00746616f, 0.02734330f, 0.00995768f, -0.01250078f, -0.02027264f, 
    -0.06646488f, 0.03405689f, -0.06177634f, 0.02782365f, -0.06847511f, 0.02949809f, -0.00642244f, 0.03597946f, 
    -0.01183939f, -0.06101993f, 0.04396494f, -0.04663363f, -0.05711109f, -0.03810819f, -0.04121109f, -0.04244865f, 
    -0.05065341f, 0.04342106f, -0.01522766f, 0.02230958f, -0.02080139f, 0.04318033f, 0.04117531f, -0.01187539f, 
    0.01734586f, 0.00888118f, -0.03706390f, -0.00627476f, 0.01955911f, -0.05910739f, -0.02386850f, 0.01941690f, 
    -0.05995173f, -0.03883028f, 0.00027496f, -0.04584754f, 0.02288613f, 0.01796991f, 0.00206579f, -0.00753560f, 
    -0.01033356f, -0.01607427f, 0.02010272f, 0.02928830f, -0.02286914f, 0.00171619f, 0.04040650f, 0.01458651f, 
    0.00466000f, -0.06804329f, 0.03116042f, -0.04485838f, 0.00865027f, -0.00413229f, -0.04797021f, 0.02254910f, 
    0.00261299f, -0.04219852f, 0.02213944f, -0.02594001f, 0.04181979f, 0.04874149f, -0.00667757f, -0.02545554f, 
    0.04127957f, -0.01094265f, 0.04874364f, -0.04369746f, 0.02273982f, 0.01946459f, -0.02926487f, 0.00079180f, 
    -0.06268510f, -0.00931090f, 0.02183863f, -0.00716989f, 0.04083781f, -0.02422272f, -0.06263695f, 0.00736505f, 
    -0.06047405f, -0.00303540f, 0.01482175f, 0.02479994f, 0.01863584f, 0.02102999f, 0.03361567f, 0.02102293f, 
    -0.01820458f, -0.02274645f, -0.03188000f, -0.04812798f, 0.02737043f, 0.03114789f, -0.03264738f, -0.02186988f, 
    0.03278841f, -0.01875450f, -0.00290664f, 0.00635920f, 0.04451020f, 0.02235421f, -0.00133239f, -0.04593080f, 
    -0.03883329f, 0.00825352f, 0.00618760f, -0.02722960f, 0.01228959f, 0.01471652f, -0.05127132f, -0.01210678f, 
    -0.06094481f, 0.05128101f, 0.02698749f, -0.02882565f, 0.01535246f, 0.04018330f, 0.03682104f, 0.03560941f, 
    -0.06441113f, -0.05979032f, -0.02073041f, 0.03021706f, 0.02847066f, -0.03016035f, -0.06271838f, -0.01208581f, 
    0.04994880f, -0.06101425f, 0.01801657f, 0.00171297f, 0.00608577f, -0.04818327f, -0.01281548f, -0.05897160f, 
    0.00250132f, -0.05469971f, -0.02201076f, 0.01394833f, -0.06032592f, -0.00330231f, 0.03715746f, 0.01997580f, 
    -0.05341616f, 0.01856279f, -0.06026028f, 0.04747313f, 0.00529020f, 0.02635695f, -0.04582757f, 0.03509400f, 
    -0.04073762f, 0.03685618f, 0.03757052f, -0.05819953f, 0.02688890f, 0.03756126f, 0.04220965f, 0.04367958f, 
    0.01819914f, 0.04662441f, -0.05942441f, -0.04152442f, -0.00433212f, -0.01950860f, 0.00131473f, -0.00970631f, 
    0.02982332f, -0.04679730f, -0.02923573f, -0.03516880f, 0.01546964f, -0.01051759f, -0.04712635f, -0.00587670f, 
    0.01351706f, -0.04967478f, 0.04498268f, 0.01496005f, -0.05514495f, 0.00975612f, -0.01814414f, 0.00191519f, 
    0.02878360f, 0.02666284f, 0.00226346f, -0.02504005f, -0.03023996f, 0.00385843f, -0.05414522f, 0.02156575f, 
    -0.03801538f, 0.00762449f, 0.05319207f, 0.02840623f, -0.00908020f, -0.00864585f, -0.02669467f, -0.01542946f, 
    -0.05630330f, -0.03226042f, -0.00392094f, -0.02020521f, -0.01228111f, 0.01916156f, -0.01353669f, 0.04077126f, 
    -0.04100814f, -0.04071406f, -0.00798203f, -0.00076265f, 0.00630637f, -0.02939776f, -0.02493552f, 0.03811712f, 
    -0.03024609f, -0.03694295f, 0.01043291f, 0.03750813f, -0.02055494f, 0.00474677f, 0.01745592f, -0.02421523f, 
    -0.00485294f, 0.02929508f, 0.00344814f, -0.06838239f, 0.01077907f, -0.06793896f, 0.03082350f, 0.04828365f, 
    -0.03495486f, 0.03687993f, -0.00979756f, -0.02521298f, -0.04384853f, -0.02675566f, 0.00349259f, -0.01309706f, 
    -0.00716088f, 0.04059651f, 0.01987956f, 0.03886633f, -0.02823713f, -0.00459647f, -0.05832522f, 0.01180663f, 
    -0.00242494f, -0.04361816f, -0.00079168f, 0.03656062f, 0.00031625f, -0.04744538f, 0.00146241f, 0.05905996f, 
    0.03999010f, -0.02890923f, -0.04126838f, -0.00278801f, 0.04391871f, -0.00558048f, -0.00630340f, -0.00034642f, 
    -0.05129213f, 0.04778735f, -0.05233260f, 0.05325581f, 0.00086493f, 0.01493197f, -0.00443873f, -0.01740827f, 
    -0.04645129f, -0.04780085f, -0.04173198f, -0.02080061f, 0.03802083f, 0.04373632f, 0.00221744f, 0.02254092f, 
    0.00899666f, 0.03653762f, -0.02569400f, -0.00522798f, -0.03790241f, -0.00712874f, 0.02320932f, -0.04970273f, 
    -0.06703939f, -0.05548919f, 0.03285136f, 0.04489042f, 0.04057210f, -0.01004075f, 0.01503037f, -0.02599160f, 
    -0.05511742f, -0.04054106f, 0.04056179f, -0.03351052f, -0.02780854f, -0.04775330f, 0.00102990f, -0.00304486f, 
    0.00007099f, 0.00758691f, -0.04406077f, 0.02728017f, 0.04693413f, -0.02799222f, 0.03696281f, -0.04857060f, 
    -0.03293910f, -0.06064617f, -0.04402842f, 0.03772725f, 0.00210275f, 0.03205770f, 0.03351939f, -0.06385812f, 
    -0.02706818f, -0.03414690f, 0.00250970f, -0.05992741f, 0.03773925f, 0.01288160f, -0.03267114f, -0.01222973f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.03327595f, 0.04787691f, 0.02821893f, 0.00639382f, 0.02212572f, 0.10959835f, -0.06922068f, 0.08712406f, 
    -0.04613941f, -0.27279738f, 0.19896686f, 0.12940094f, 0.04611009f, -0.01059934f, 0.10833528f, -0.01635358f, 
    -0.03957549f, -0.04984881f, 0.06687752f, 0.03728678f, -0.00307649f, 0.19380637f, -0.03449611f, 0.00851213f, 
    0.01370266f, 0.03994801f, -0.08890194f, 0.14678542f, 0.09455439f, 0.07247952f, -0.06417273f, -0.05940918f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.18559958f, 0.64104915f, -0.04062863f, 0.14763275f, 0.29967910f, -0.50854057f, -0.04773775f, -0.63301814f, 
    0.09493923f, 0.11341605f, 0.14965245f, -0.14081049f, 0.10400423f, -0.59794885f, 0.29328275f, 0.11788039f, 
    0.11675208f, 0.01314822f, -0.12032254f, 0.04611351f, -0.29801986f, -0.14330335f, -0.33600986f, 0.10976256f, 
    0.03547164f, -0.01558539f, 0.22292279f, 0.00940579f, 0.69407898f, -0.22841901f, -0.02235856f, -0.03779762f, 
    -0.05242865f, -0.02208335f, -0.04754530f, -0.12749150f, -0.40743551f, 0.26473758f, 0.01988604f, -0.03973497f, 
    0.05212813f, -0.09489090f, 0.88232911f, -0.34686100f, 0.08326197f, 0.01151522f, -0.32353771f, 0.22486266f, 
    -0.09497929f, -0.09940652f, -0.48660934f, -0.08500290f, 0.15632720f, 0.18406196f, 0.20192057f, 0.03017474f, 
    0.08566237f, -0.03781234f, -0.40021908f, -0.21019928f, 0.35674268f, -0.28148261f, -0.01083663f, 0.08854076f, 
    0.01312134f, 0.05299260f, 0.11324476f, -0.07430055f, -0.15255538f, -0.07160403f, -0.00974973f, -0.15413241f, 
    -0.04868596f, -1.04770863f, 0.16871575f, 0.07770585f, 0.04568759f, 0.04988517f, 0.07524349f, -0.27307791f, 
    -0.08153011f, 0.06669579f, 0.28649139f, -0.09892248f, -0.47168449f, -0.67764467f, -0.96940684f, 0.15766497f, 
    0.06099871f, 0.10641000f, -0.10370678f, -0.22408645f, -0.57545751f, 0.81359988f, -0.07826806f, 0.13483259f, 
    0.14147311f, -0.15839811f, 0.11939579f, -0.16025928f, 0.20420814f, -0.41512367f, -0.23298131f, -0.29381037f, 
    0.14599822f, -0.24251142f, -0.30432016f, -0.19818489f, 0.14802553f, -0.34194684f, -0.67950571f, -0.59413755f, 
    0.14586547f, -0.16798469f, 0.59416062f, 0.07634721f, -0.15661965f, 0.48226017f, 0.76243347f, -0.14031702f, 
    -0.14921808f, -0.11135957f, 0.47611064f, 0.03816357f, -0.38772565f, -0.06223338f, -0.12307217f, 0.07495800f, 
    -0.03186875f, -0.50858939f, -0.01418960f, -0.14384829f, 0.19110392f, -0.03307788f, -0.02370059f, -0.78163767f, 
    0.02871042f, 0.02322356f, 0.02104186f, 0.38967007f, 0.12987408f, -0.22532122f, 0.27198911f, 0.12783903f, 
    0.00832110f, -0.11669414f, 0.42774665f, -0.02396672f, -0.07088690f, 0.36348018f, -0.37513310f, 0.05634676f, 
    0.02420663f, -0.14838921f, -0.39153981f, 0.69330812f, -0.26351789f, -0.21435370f, 0.01578610f, -0.07878330f, 
    0.03671051f, 0.35181484f, 0.16567619f, 0.04633883f, -0.64093971f, 0.31211483f, -0.64512551f, 0.04165351f, 
    0.11783945f, 0.67612171f, -0.17742375f, 0.57438231f, -0.09057245f, -0.01274228f, 0.32053459f, -0.50804442f, 
    0.06331787f, 0.14696282f, -0.54330444f, 0.04514538f, -0.24671714f, 0.12651749f, 0.02421959f, -0.12501574f, 
    0.05261482f, -0.08074347f, -0.21811856f, -0.03839742f, 0.27382097f, -0.33755499f, -0.00907623f, -0.15684989f, 
    -0.08946143f, 0.26520440f, 0.02222055f, -0.08745134f, 0.33489859f, 0.05032574f, -0.51797390f, 0.58190560f, 
    0.10311524f, -0.41315702f, -0.63993114f, 0.18174015f, -0.01919964f, 0.22044106f, -0.42098865f, 0.64585459f, 
    -0.14694077f, -0.16582714f, -0.11117594f, 0.02691663f, -0.13676916f, 0.23107925f, -0.19363146f, -0.00308487f, 
    -0.07676145f, 0.15079491f, 0.00973757f, -0.13077907f, -0.60273778f, -0.46693233f, 0.16718379f, -0.02923165f, 
    0.01494114f, -0.27144307f, 0.03582527f, 0.02100533f, -0.11886536f, -0.27422038f, 0.82068318f, -0.21289045f, 
    -0.00958280f, 0.56572497f, -0.25563243f, -0.22646622f, 0.13548498f, -0.64067549f, 0.16664897f, 0.06933283f, 
    -0.06669796f, -0.14850834f, 0.00113644f, -0.00097066f, -0.39697814f, -0.26778191f, 0.00930869f, 0.10028179f, 
    -0.16509230f, -0.04352797f, 0.25577688f, -0.53971279f, -0.31667545f, 0.22118922f, 0.12627399f, -0.01842851f, 
    -0.08875406f, 0.10870486f, -0.07717698f, 0.10526229f, -0.66839027f, 0.23841402f, 0.45421615f, -0.07348253f, 
    -0.00071213f, -0.23868339f, -0.43831065f, -0.21047848f, 0.08322690f, 0.28628859f, -0.34167087f, -0.24810165f, 
    0.05866665f, -0.15544303f, -0.30731276f, 0.09852415f, 0.96685737f, -0.53071696f, -0.05307066f, -0.03569761f, 
    0.14238094f, -0.01784795f, 0.04657310f, 0.01256800f, -0.00272049f, -0.14018275f, -0.02047240f, 0.06918198f, 
    0.03103201f, -0.69998437f, -0.08839475f, 0.02873343f, 0.04432325f, 0.29597458f, 0.82841522f, 0.59217471f, 
    -0.18331435f, 0.28906295f, -0.44624642f, 0.14579672f, -0.07142534f, -0.06170517f, -0.22040476f, 0.31861144f, 
    0.10709892f, 0.02382720f, 0.03594705f, -0.00101710f, -0.59275472f, -0.48449796f, -0.18099993f, 0.00036768f, 
    -0.09139742f, -0.08616984f, -0.48833883f, -0.25341478f, 0.24450529f, -0.48354670f, -0.16321698f, -0.02073689f, 
    0.16692100f, -0.08565184f, -0.16269624f, -0.07762269f, -0.01817232f, 0.20695423f, -0.46435806f, -0.25556132f, 
    -0.08719773f, -0.67205024f, 0.24773088f, -0.59378242f, 0.11125278f, 0.04293805f, 0.85663092f, -0.73818320f, 
    0.05254326f, 0.02042675f, -0.19660977f, 0.08467549f, -0.23946163f, -0.09401155f, 0.43344340f, -0.10592274f, 
    0.12541729f, 0.09733461f, 0.06736950f, 0.28196797f, -0.25633430f, 0.37116110f, 0.01792447f, 0.06290510f, 
    -0.07055503f, -0.20446330f, 0.06559838f, -0.04213008f, 0.10013711f, -0.16659786f, -0.58011043f, 0.11578730f, 
    0.04385282f, 0.00780738f, -0.00268704f, -0.18501894f, 0.13280743f, 0.98358285f, -0.57090908f, -0.49927163f, 
    -0.06510134f, 0.01016040f, 0.36272532f, 0.03980485f, 0.08931138f, 0.18418105f, -0.35257682f, 0.00129985f, 
    -0.10608155f, -0.09972126f, 0.59379828f, -0.48633134f, -0.26604158f, -0.15540807f, -0.10837226f, 0.06556179f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.18404292f, 0.07588588f, 0.02015361f, -0.24406730f, -0.08077680f, -0.12081727f, -0.14919618f, -0.43587118f, 
    -0.16825701f, 0.23639217f, 0.13744405f, 0.15330781f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
