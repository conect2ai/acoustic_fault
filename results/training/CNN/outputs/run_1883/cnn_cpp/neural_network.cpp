#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.08326051f, 0.11259718f, -0.13147037f, 0.58314461f, 0.41051394f, 0.37335828f, -0.60451579f, 0.36262441f, 
    -0.53587180f, 0.94112456f, -0.69038522f, -0.37798837f, 0.17707165f, -0.20674464f, -0.11431495f, 0.36886758f, 
    0.20411992f, 0.07883207f, -0.50416017f, -0.47705731f, -0.23383342f, 0.33893198f, -0.08972894f, -0.30079889f, 
    0.18600845f, -0.31285846f, 0.59624606f, -0.07614075f, 0.02173773f, 0.05467152f, 0.02942633f, -0.45423329f, 
    -0.47362909f, 0.35401180f, 0.17516029f, 0.50897270f, -0.51552933f, -0.50110173f, -0.96257806f, -0.13533533f, 
    0.71603715f, 0.32053357f, 0.31068194f, 0.44701388f, -0.03701895f, -0.24879533f, -0.14858417f, 0.16632143f, 
    -0.19934325f, -0.27869383f, -0.08147655f, 0.33144820f, 0.46117276f, 0.01678324f, -0.43051571f, -0.62835997f, 
    -0.34512594f, -0.00085342f, 0.38375452f, 0.26976785f, -0.13404985f, -0.35943526f, -0.53999871f, -0.12818787f, 
    -0.27438661f, -0.52189767f, 0.62247497f, 0.31279632f, -0.21232887f, 0.06991517f, -0.45087072f, -0.39994067f, 
    -0.03426414f, 0.74379992f, -0.35925108f, 0.09025011f, -0.26303411f, -0.41679993f, -0.01419097f, 0.41826597f, 
    0.34546280f, -0.11999968f, -0.21456137f, -0.38566467f, -0.50848705f, -0.54618329f, -0.17035510f, 0.00769269f, 
    0.56318974f, 0.34384534f, -0.36754015f, -0.33399123f, -0.37611610f, 0.05812762f, -0.08280914f, -0.05318683f, 
    -0.37174967f, -0.40851796f, 0.21493237f, -0.48665115f, 0.21639682f, -0.52775693f, 0.21609028f, 0.39581454f, 
    -0.58792621f, 0.34403077f, 0.24699029f, 0.40932986f, -0.03631282f, 0.93809807f, -0.57310075f, 0.21686919f, 
    -0.05435500f, -0.35282570f, -0.32015222f, -0.26009133f, 0.23486438f, 0.94748139f, -0.60238200f, -0.38026187f, 
    -0.14768064f, -0.16308144f, 0.53768265f, -0.18372421f, 0.24800701f, -0.13952710f, 0.39566886f, -0.00571316f, 
    0.17352660f, 0.23475102f, 0.33033869f, 0.14780119f, -0.38689449f, 0.60379899f, 0.04907541f, 0.03158221f, 
    0.09969073f, 0.45853925f, 0.08782793f, -0.19524533f, 0.41435131f, 0.33264571f, -0.40514687f, -0.17879109f, 
    0.01771506f, 0.51276714f, 0.51815003f, 0.54721648f, -0.62985450f, -0.58057368f, -0.01823721f, -0.17759444f, 
    -0.11638215f, -0.14959393f, 0.43751734f, -0.56880116f, -0.45090520f, 0.51598990f, -0.49641475f, 0.07931709f, 
    0.04015474f, -0.22220564f, -0.51416510f, 1.07929122f, -0.63185596f, -0.47616681f, -0.24764656f, 0.06928109f, 
    -0.03637013f, -0.04890507f, 0.09604391f, 0.72749013f, 0.38957354f, 0.13529979f, 0.01471335f, -0.30303881f, 
    -0.42407525f, 0.11325192f, 0.38192424f, -0.04122895f, 0.77302444f, -0.36786604f, -0.55510432f, 0.63206917f, 
    -0.39496163f, -0.68653846f, -0.08226523f, -0.13283922f, -0.14736702f, -0.45440814f, -0.37765500f, 0.63834447f, 
    0.18927214f, -0.34949157f, -0.69072783f, -0.05989481f, -0.24590693f, -0.07411820f, -0.36439994f, -0.02831119f, 
    0.12111020f, -0.45483240f, -0.37776986f, -0.29556930f, 0.34187680f, 0.33979040f, -0.32295701f, 0.15629306f, 
    -0.55150139f, 0.60785514f, -0.55103868f, 0.40126649f, 0.03611187f, 0.10621899f, -0.06814804f, 0.28548405f, 
    0.21732900f, 0.01403760f, 0.09347533f, 0.29765287f, 0.19202077f, 0.34555963f, 0.38870013f, 0.46429038f, 
    -0.34427375f, 0.60127532f, -0.47320449f, 0.52654767f, -0.11041731f, 0.39502764f, -0.45081425f, 0.06113225f, 
    -0.09107354f, 0.05899655f, -0.43839607f, 0.03151942f, -0.28019893f, -0.30181363f, -0.58336383f, -0.01122855f, 
    -0.19889101f, -0.29732096f, -0.14865524f, -0.60931498f, -0.41000816f, 0.15097328f, 0.38545120f, 0.13221385f, 
    -0.43705612f, -0.26839507f, -0.09784260f, -0.04304590f, -0.11746068f, -0.00955700f, 0.56918842f, 0.61764359f, 
    0.46311128f, 0.49896184f, 0.12712498f, 0.01864372f, -0.10945968f, -0.65222645f, 0.40650207f, 0.77758485f, 
    0.45761162f, -0.28250551f, -0.24289657f, -0.36710915f, -0.29578242f, -0.13016412f, -0.04835279f, -0.83500439f, 
    0.92773879f, -0.43072936f, -0.40274841f, 0.28672194f, -0.23677365f, 0.32009026f, -0.29130653f, 0.31253320f, 
    -0.70396167f, 0.67211634f, -0.01099186f, -0.67914617f, 0.61945039f, 0.12915283f, -0.20465398f, -0.05085554f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.16475543f, -0.08619855f, -0.21731563f, -0.21308061f, 0.32429388f, 0.23528232f, -0.18525806f, 0.19976163f, 
    -0.11911458f, -0.29261985f, -0.19819941f, -0.06532776f, 0.20715715f, -0.06769323f, 0.32533520f, 0.34683219f, 
    -0.15228727f, 0.17397800f, 0.07600273f, 0.10503607f, -0.17137273f, -0.36061403f, 0.33836704f, 0.22792248f, 
    -0.34762469f, -0.15125187f, -0.40709180f, 0.16595210f, -0.11401479f, -0.06930622f, -0.08057434f, -0.14151148f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.13420844f, -0.39710996f, 0.09294616f, -0.04571975f, -0.11806175f, -0.19786540f, -0.06117424f, -0.03815439f, 
    0.23889004f, 0.01924251f, -0.29190290f, 0.07047480f, -0.06178128f, 0.05125628f, 0.23988184f, 0.02020680f, 
    -0.07375677f, -0.07098788f, -0.17265284f, -0.13263801f, 0.04825690f, -0.26093754f, 0.02057270f, -0.24383192f, 
    0.09016532f, -0.00879574f, -0.07484042f, -0.13891424f, -0.13117857f, -0.16945641f, -0.12781398f, -0.08955507f, 
    -0.22820160f, 0.00982768f, -0.06936616f, -0.01682254f, -0.35713312f, -0.13111298f, -0.00073841f, 0.11731371f, 
    -0.02911748f, 0.10851234f, -0.03271561f, 0.13343868f, 0.13927409f, -0.05280128f, 0.01922411f, -0.03323290f, 
    -0.01556727f, 0.12922569f, 0.00669976f, 0.00733660f, 0.01795895f, 0.13920493f, -0.23309700f, -0.15229216f, 
    -0.07145408f, 0.12950422f, -0.01515645f, 0.04710486f, -0.15721594f, -0.04185680f, 0.17460699f, 0.16607377f, 
    -0.10837519f, -0.13897482f, 0.05481983f, 0.06525409f, 0.02667698f, -0.11864089f, 0.12555064f, 0.09922953f, 
    -0.22315235f, -0.03650342f, -0.08608852f, -0.06729962f, 0.02673433f, -0.04410596f, 0.20769520f, 0.16475488f, 
    -0.05048885f, -0.12246803f, 0.19568281f, -0.14779204f, -0.03417413f, -0.13779676f, -0.08168865f, 0.15120250f, 
    -0.07747198f, -0.02431406f, 0.11476251f, -0.00337964f, -0.30970302f, -0.04715413f, 0.18147288f, 0.01492517f, 
    0.04048749f, 0.07249928f, -0.01503224f, -0.48116288f, -0.15519056f, 0.17985830f, -0.14967054f, -0.02084631f, 
    0.02184812f, -0.05747508f, 0.02398276f, -0.08355353f, 0.16695268f, 0.30081016f, -0.13283819f, 0.06714677f, 
    -0.01491445f, 0.14118105f, 0.14440854f, 0.03874246f, 0.07409462f, -0.03531380f, -0.19019589f, 0.18506387f, 
    0.09919027f, -0.03211331f, 0.26634088f, -0.05749331f, -0.13996692f, 0.20502868f, 0.09301855f, -0.21224950f, 
    0.14737846f, -0.02301970f, 0.07863925f, 0.00590062f, 0.07077148f, 0.04055418f, 0.06608374f, -0.07046055f, 
    0.21149868f, 0.20018077f, -0.06479030f, -0.01750555f, -0.04005051f, -0.01745286f, 0.02729222f, 0.00938161f, 
    0.00270396f, 0.18670024f, 0.06346516f, 0.00855632f, -0.17337255f, -0.07478888f, 0.17414674f, 0.07065199f, 
    0.10129452f, 0.04710283f, -0.07659745f, 0.21371272f, 0.01730225f, -0.00134969f, 0.09496760f, -0.01449526f, 
    0.05972589f, -0.00876172f, -0.32529125f, -0.01249402f, -0.42807028f, -0.10246212f, -0.08051696f, 0.18361722f, 
    0.22884895f, 0.09769651f, -0.00257926f, 0.32061234f, 0.04122559f, 0.26764697f, -0.04610115f, 0.00952145f, 
    -0.19866593f, 0.12714022f, 0.17140448f, 0.07807595f, 0.24525534f, -0.13081908f, 0.38641685f, -0.41563499f, 
    -0.02509072f, -0.02391084f, 0.04834967f, -0.00437926f, -0.05805740f, -0.26681373f, -0.31114131f, 0.37065995f, 
    -0.14506365f, -0.03702968f, -0.18045136f, 0.02462419f, 0.04629879f, 0.10143940f, -0.05350963f, 0.01267045f, 
    0.00069037f, -0.00349339f, 0.04334724f, -0.09792799f, 0.05667105f, 0.05353959f, 0.11544157f, 0.01566523f, 
    -0.07545915f, 0.08855217f, 0.33253393f, 0.05372322f, -0.06214360f, -0.02995100f, 0.08819064f, -0.01272559f, 
    0.01233553f, -0.03274047f, -0.07803249f, -0.03786004f, 0.07714073f, 0.09068773f, -0.01486334f, 0.10092832f, 
    0.10278597f, 0.39759576f, 0.03750640f, -0.06413851f, -0.28486916f, 0.18040867f, -0.13369599f, 0.06350882f, 
    0.03724511f, -0.03965096f, -0.18015549f, 0.17566717f, -0.02571114f, -0.19058877f, -0.16414249f, -0.05700724f, 
    0.26204363f, 0.15176769f, -0.07319808f, -0.24806772f, -0.13160965f, 0.08541068f, -0.09240972f, 0.10769510f, 
    -0.06020202f, -0.03661181f, -0.04129231f, 0.05319217f, -0.18795359f, -0.02462794f, 0.03875083f, -0.04068225f, 
    0.09750447f, -0.19195080f, -0.08621956f, -0.05295878f, -0.04085216f, -0.52750826f, 0.02615273f, 0.23296383f, 
    0.01399053f, -0.04482520f, 0.02089884f, 0.14226083f, 0.04629470f, 0.00907356f, -0.20261091f, -0.04568167f, 
    0.25890511f, 0.13121937f, 0.11596747f, 0.07864922f, -0.12665886f, -0.02212512f, 0.15291934f, -0.00985585f, 
    0.20770450f, 0.32354257f, -0.18721655f, -0.07475326f, -0.10637511f, -0.17785962f, -0.15889597f, -0.07447905f, 
    0.05485843f, -0.02034443f, -0.02873723f, 0.19911717f, -0.04782039f, -0.02869220f, 0.13187496f, 0.00138653f, 
    -0.21679789f, -0.02446636f, -0.12354413f, 0.29345042f, 0.05898763f, -0.04335676f, 0.11151751f, -0.18087345f, 
    -0.21184857f, 0.19411540f, -0.06852980f, 0.02515035f, -0.12866646f, 0.04692218f, 0.11969597f, 0.04022391f, 
    0.03908078f, -0.10500976f, -0.07508242f, -0.16994770f, -0.17127605f, 0.01059174f, 0.13285610f, -0.06943966f, 
    -0.00033171f, -0.17153165f, -0.19714645f, 0.05650292f, -0.02199570f, -0.11066521f, -0.08301100f, 0.02276792f, 
    -0.07268746f, -0.03761385f, -0.02377728f, 0.05983697f, -0.09218484f, -0.10066064f, -0.05744059f, -0.03314546f, 
    0.05274168f, 0.00076010f, -0.03310007f, -0.15856166f, 0.06657598f, 0.07487106f, 0.00943671f, -0.00975416f, 
    -0.15229198f, 0.10965860f, -0.18415609f, -0.08008385f, 0.14745681f, -0.13771537f, -0.10200730f, -0.04775976f, 
    -0.18121360f, -0.03136132f, -0.00642112f, -0.15203758f, 0.01094498f, 0.10521818f, -0.04703587f, -0.14329994f, 
    -0.10426335f, 0.07547478f, 0.11424092f, 0.07640430f, 0.12518312f, 0.00052621f, -0.05806290f, 0.22420721f, 
    0.01651313f, -0.03808333f, -0.16508520f, -0.08435292f, 0.03830703f, 0.07828357f, -0.10106833f, -0.04822465f, 
    -0.03870870f, 0.04535599f, -0.03685112f, 0.07996538f, -0.06697507f, 0.00480372f, -0.11621653f, 0.06298319f, 
    0.05081267f, -0.07982838f, 0.00412340f, 0.04706524f, -0.00366019f, -0.05419795f, 0.00606953f, 0.07615521f, 
    0.06705066f, 0.10558233f, 0.10950341f, 0.07819137f, 0.00244337f, 0.14121400f, 0.05183741f, 0.01312596f, 
    0.09302634f, -0.11762737f, -0.00394143f, 0.00861425f, 0.05761307f, 0.14325637f, -0.02599154f, 0.41003904f, 
    -0.15066381f, 0.00254760f, 0.26570794f, -0.01806617f, -0.13439626f, -0.01887875f, 0.15867153f, 0.07185585f, 
    0.07561342f, 0.06366058f, -0.02395794f, 0.05202440f, 0.14570493f, 0.06265751f, -0.13445418f, 0.01137807f, 
    0.24247143f, 0.00769779f, -0.06028970f, 0.01858411f, 0.04539639f, 0.00021854f, -0.04248900f, -0.05013414f, 
    0.22769329f, 0.16310161f, 0.02249706f, -0.05825616f, 0.00958225f, -0.07815585f, 0.14607593f, 0.05401037f, 
    0.24299465f, -0.04077320f, -0.04770233f, -0.10923301f, 0.08887988f, 0.07826115f, 0.00324772f, 0.06980564f, 
    0.07753621f, -0.12339663f, -0.05353770f, 0.17941481f, 0.00939545f, 0.00301005f, -0.05443427f, 0.05571728f, 
    0.08540548f, 0.04760518f, -0.19620973f, 0.09274610f, 0.05135809f, 0.15090281f, 0.06228000f, 0.07969129f, 
    0.00307680f, 0.00638487f, -0.02529871f, 0.01525909f, 0.13205004f, -0.18727292f, 0.27967781f, -0.04789428f, 
    0.00420687f, 0.26716974f, 0.09856623f, -0.29961306f, -0.09951665f, -0.11494315f, 0.08438078f, -0.01142599f, 
    -0.07694903f, 0.10397049f, 0.10140863f, -0.01333188f, -0.04194448f, 0.17900425f, -0.23824419f, -0.14499044f, 
    -0.17833237f, 0.04502077f, -0.05250769f, -0.03815059f, -0.07080203f, -0.11943667f, 0.06074443f, -0.07752544f, 
    0.13500670f, 0.03261980f, -0.01758152f, -0.13336715f, 0.10332046f, 0.07159656f, 0.00434293f, -0.15292411f, 
    0.17721196f, 0.10425113f, 0.08386341f, 0.09243444f, -0.00882656f, 0.03762745f, 0.00397303f, -0.02094030f, 
    -0.07000817f, 0.12781234f, 0.15946174f, 0.25120559f, 0.10453999f, -0.02027457f, 0.09379597f, 0.00913151f, 
    0.01518893f, -0.01278853f, -0.04664940f, 0.03702465f, -0.02630017f, 0.04752579f, 0.00940186f, 0.03767448f, 
    0.03773689f, -0.10934649f, 0.13230391f, -0.15570381f, 0.03323263f, -0.11382394f, -0.00272825f, 0.04710137f, 
    0.02152425f, 0.06758126f, -0.04083835f, 0.01190113f, -0.02323446f, 0.24244201f, 0.18527922f, 0.05964583f, 
    0.02706953f, -0.05801487f, -0.04216327f, -0.09579859f, -0.06342351f, 0.00678143f, 0.20982285f, -0.08001238f, 
    0.14512940f, -0.04990315f, 0.00244511f, 0.04552075f, 0.09429209f, 0.23089950f, -0.17008133f, 0.28126156f, 
    0.05675636f, 0.09602803f, 0.12143813f, -0.01570138f, -0.00316725f, -0.09401543f, -0.09680495f, 0.16001461f, 
    0.16270553f, 0.30629799f, -0.05111800f, 0.14369895f, -0.09608592f, -0.16441797f, -0.07084879f, -0.10649014f, 
    0.22686447f, 0.12317839f, -0.23440073f, 0.03231822f, -0.01852250f, -0.08460809f, 0.16393676f, -0.13470015f, 
    0.07831526f, -0.16437143f, 0.22635637f, -0.08828156f, -0.01989210f, 0.21739252f, -0.01081857f, -0.01130527f, 
    -0.06166853f, -0.01863909f, 0.36098632f, 0.18574359f, 0.15515140f, -0.04259361f, 0.13408114f, -0.03531748f, 
    -0.02599095f, 0.07965295f, 0.07546388f, 0.20395091f, 0.09486427f, 0.09198215f, 0.03966378f, 0.01621157f, 
    -0.12169361f, -0.06775454f, -0.11263315f, 0.04052172f, -0.02952922f, 0.01512377f, 0.14674458f, 0.01956373f, 
    0.15472612f, 0.04617940f, -0.03534718f, -0.03330087f, -0.04275548f, 0.04602394f, 0.09061234f, 0.15296184f, 
    -0.05060440f, 0.01366168f, 0.02474811f, 0.15413862f, 0.00166417f, 0.00353979f, 0.09965903f, 0.00077752f, 
    0.16830389f, 0.07978421f, 0.03135657f, -0.00169075f, -0.07558694f, -0.05487929f, 0.06722959f, 0.09196366f, 
    -0.01012141f, 0.06465385f, 0.09168465f, -0.01584756f, -0.04647083f, 0.07370134f, -0.05033884f, -0.07224290f, 
    0.06809542f, -0.18294457f, -0.05310953f, 0.10240104f, 0.01490663f, -0.07910596f, -0.09046512f, 0.20328698f, 
    -0.02440787f, 0.04834777f, 0.26196262f, 0.24029723f, -0.04598859f, -0.04612860f, -0.02511504f, 0.17540962f, 
    0.01628297f, -0.12224237f, 0.19608283f, 0.00576679f, 0.10271847f, -0.07510111f, 0.09603316f, 0.06893906f, 
    -0.04730722f, 0.01601740f, 0.03307990f, 0.11796919f, -0.06935409f, 0.16379826f, -0.05703438f, -0.01918519f, 
    -0.04721900f, -0.00257329f, 0.04239292f, 0.06852380f, -0.16852687f, 0.20887972f, -0.04051062f, -0.12129039f, 
    0.02541927f, 0.00496830f, 0.14531168f, 0.04280402f, 0.02130854f, -0.54187679f, 0.29884627f, -0.17779075f, 
    0.02205407f, 0.15525657f, -0.07386221f, -0.03853295f, 0.15982284f, 0.01050696f, -0.05139479f, -0.20898256f, 
    -0.29439920f, 0.06398895f, 0.00669603f, 0.09378678f, 0.00878623f, -0.01315584f, 0.04173737f, 0.00505336f, 
    -0.25727293f, -0.12714911f, -0.03941930f, -0.00156124f, -0.08206968f, 0.05347282f, -0.03966225f, -0.02992258f, 
    0.05888212f, -0.16043280f, -0.10684823f, -0.14812727f, 0.03350195f, -0.03034795f, -0.00052327f, -0.07809418f, 
    -0.08148399f, -0.17209503f, -0.04199594f, -0.03126497f, -0.03065364f, -0.10896457f, -0.03597246f, 0.14292930f, 
    0.07982384f, 0.00079254f, -0.18821032f, 0.10135517f, -0.02399094f, -0.03433146f, -0.11436693f, -0.01104027f, 
    0.11995298f, 0.09042769f, -0.07288434f, -0.03606492f, -0.19766818f, -0.00398684f, -0.08064235f, -0.01210001f, 
    0.01741904f, -0.09564550f, 0.09909070f, -0.06945863f, -0.02438102f, 0.23153181f, 0.07008184f, 0.09703338f, 
    0.02788294f, -0.23625681f, -0.06124801f, -0.04755669f, 0.07045369f, 0.35582072f, 0.09278768f, 0.02491346f, 
    0.07976195f, 0.04945612f, 0.03232251f, -0.02088250f, 0.00788853f, 0.03938891f, 0.05279400f, 0.13337389f, 
    0.25386354f, 0.01342738f, 0.02342841f, -0.09168473f, -0.04668667f, -0.00671294f, -0.02983569f, -0.25082743f, 
    -0.14174661f, -0.21603143f, 0.01260122f, -0.14782694f, -0.04964282f, 0.06620995f, -0.13619862f, 0.01794297f, 
    -0.12770385f, -0.10077368f, -0.13056499f, -0.03055975f, 0.01993300f, 0.03815888f, 0.03820194f, -0.00153125f, 
    0.09156741f, -0.00300633f, -0.06885813f, -0.19677967f, -0.06835995f, -0.15801840f, -0.17786370f, 0.16888104f, 
    -0.02903168f, -0.10073484f, 0.08695428f, 0.08497130f, 0.22699252f, -0.11582413f, 0.14130652f, -0.13004157f, 
    0.04709876f, 0.12008566f, 0.03490184f, 0.19510432f, -0.09720591f, 0.08233128f, -0.05437797f, -0.05022992f, 
    -0.05756417f, -0.01817668f, -0.02179412f, -0.01022771f, 0.25168228f, -0.07007441f, -0.20091553f, -0.12497785f, 
    -0.00116904f, 0.05206621f, -0.04861596f, 0.10318381f, 0.14116304f, -0.04496716f, -0.16211858f, -0.24786837f, 
    -0.12219585f, -0.02083924f, -0.12229144f, 0.19553974f, 0.04131963f, 0.05782933f, -0.00823389f, -0.03242680f, 
    -0.03493032f, -0.01264123f, 0.29611295f, -0.08973241f, 0.04336604f, 0.03971963f, -0.03776525f, -0.05712663f, 
    -0.40777585f, -0.12836573f, -0.12519510f, 0.01790279f, -0.04250534f, 0.00703660f, 0.06781255f, -0.02508698f, 
    -0.02278047f, 0.00714449f, 0.00724239f, -0.07360931f, 0.02697375f, -0.04668692f, -0.00323210f, 0.04031593f, 
    0.00124894f, -0.03364910f, 0.02054060f, -0.03068639f, -0.00086650f, -0.04129345f, 0.00160311f, -0.03865454f, 
    -0.05234162f, -0.03419863f, -0.03454207f, 0.04678289f, -0.00017188f, -0.01359628f, 0.04348267f, -0.03458097f, 
    0.03023308f, 0.01028293f, 0.05473794f, -0.07326587f, 0.01381397f, 0.03751010f, -0.00179872f, 0.00576205f, 
    0.02221712f, -0.01237877f, -0.03865670f, 0.00154755f, -0.06274305f, 0.01880243f, -0.04497936f, 0.02542087f, 
    -0.03623151f, -0.01228981f, 0.05101694f, -0.01304442f, -0.01112626f, 0.02747634f, 0.04256220f, 0.03188040f, 
    0.02196887f, 0.01822829f, -0.00883459f, -0.01625495f, -0.02083634f, 0.02289109f, -0.03455857f, 0.02100135f, 
    -0.02991310f, -0.04576321f, -0.06098724f, 0.04192263f, 0.01236661f, -0.00541985f, 0.04899812f, 0.02572997f, 
    -0.03003988f, -0.03404949f, -0.03810448f, 0.00890955f, -0.04940877f, 0.01518264f, -0.05240503f, 0.04979362f, 
    -0.00264607f, 0.02860596f, 0.03313287f, 0.00349865f, -0.03123898f, 0.02392725f, -0.01773760f, 0.02556520f, 
    0.02655964f, -0.04487326f, 0.02427712f, -0.01927149f, 0.03879921f, 0.01109776f, -0.02129488f, 0.04415508f, 
    0.01046469f, -0.00203288f, -0.01821241f, 0.01056491f, -0.04287990f, -0.03283272f, -0.00935040f, 0.01056868f, 
    -0.06872437f, 0.00990242f, -0.06133680f, 0.01260884f, 0.03710181f, -0.01736551f, -0.04571865f, -0.03833152f, 
    -0.04065533f, 0.02289254f, -0.01022734f, 0.03729535f, -0.05075087f, 0.03205099f, -0.05550761f, -0.04188002f, 
    -0.02789474f, -0.00533834f, -0.03924105f, -0.03987251f, 0.01226588f, -0.05371786f, 0.01617735f, -0.02504712f, 
    -0.04715760f, -0.01523271f, -0.03106835f, -0.01307698f, 0.04477019f, -0.00098460f, -0.02366354f, 0.05063399f, 
    -0.03063968f, -0.03266229f, -0.02571348f, -0.04851440f, 0.01818020f, 0.05853638f, -0.04367875f, -0.02613445f, 
    0.02926788f, 0.02480970f, -0.03129505f, 0.01578053f, -0.04996986f, -0.03563661f, -0.00495720f, -0.05743597f, 
    -0.04695718f, 0.02259422f, -0.04022696f, 0.03616269f, -0.05106303f, 0.02772645f, -0.00240812f, 0.02426288f, 
    0.04946573f, 0.04025217f, 0.04694183f, 0.00822112f, 0.02859936f, -0.00051076f, 0.00821372f, 0.04967729f, 
    -0.01997790f, 0.02037856f, -0.03211313f, 0.01875039f, 0.05231126f, -0.01151205f, 0.00904070f, -0.06008594f, 
    -0.04294018f, 0.01929531f, -0.06254483f, -0.05168932f, -0.02489949f, -0.04096546f, -0.04755078f, -0.01765022f, 
    -0.04431123f, -0.00557447f, -0.04999368f, -0.01782665f, -0.05722811f, -0.03517641f, -0.01814314f, -0.01167683f, 
    -0.00395640f, -0.02395699f, -0.01280243f, -0.02652333f, -0.03038744f, -0.04367400f, 0.04299552f, -0.01827415f, 
    -0.00370970f, 0.05365000f, 0.03258018f, -0.03733413f, -0.02051061f, -0.01616415f, 0.03214110f, 0.02189739f, 
    0.04373838f, 0.01796369f, -0.02914882f, -0.05546773f, 0.04425717f, 0.01712398f, 0.02037176f, 0.02820986f, 
    0.01901398f, -0.02179821f, -0.00873154f, -0.00169515f, -0.02200000f, 0.04335126f, -0.00205276f, 0.00708436f, 
    -0.00878067f, -0.04109244f, 0.05104603f, -0.02137694f, 0.04269290f, 0.05479073f, -0.02909090f, -0.03089773f, 
    -0.00301256f, -0.02108040f, -0.03814963f, -0.04737988f, 0.00553966f, 0.04001141f, -0.05746813f, -0.02978528f, 
    0.00857673f, -0.00863396f, 0.04269498f, -0.01289818f, -0.05160343f, -0.06179247f, -0.04718275f, 0.01553491f, 
    -0.05158519f, -0.04925602f, 0.05282065f, -0.05414061f, -0.05533560f, -0.05673051f, 0.02166599f, -0.02827891f, 
    0.04962965f, -0.00828939f, -0.01306819f, -0.01248619f, 0.03437558f, 0.02807350f, -0.01792735f, -0.01718445f, 
    0.00305458f, 0.05786495f, 0.01326036f, 0.00948304f, -0.04323627f, -0.02125063f, -0.01839569f, -0.04500711f, 
    -0.06367677f, -0.04064976f, 0.01673353f, 0.00993037f, -0.04933530f, -0.01735164f, 0.04148048f, -0.00054216f, 
    -0.05796551f, 0.00595915f, 0.05131705f, 0.04893688f, 0.01603482f, -0.00873014f, 0.03026450f, 0.03502784f, 
    0.03934143f, 0.04986223f, 0.03477084f, 0.03394528f, 0.01434476f, 0.02021395f, -0.01984146f, -0.00929190f, 
    0.12704843f, -0.13321364f, 0.15437067f, -0.02711531f, 0.05577813f, -0.34652606f, 0.06087390f, -0.08586437f, 
    0.01883094f, 0.01592944f, 0.10431420f, -0.10662895f, -0.09902637f, -0.08079553f, 0.09294697f, 0.01073310f, 
    -0.11299451f, 0.04239549f, -0.06116371f, 0.10351295f, 0.21500207f, -0.04234200f, -0.02815097f, 0.01146153f, 
    -0.11992481f, -0.04443203f, 0.20210344f, -0.14418776f, 0.01815454f, 0.05920883f, 0.01070614f, 0.00399823f, 
    0.03024625f, -0.08154150f, -0.13971871f, 0.06579759f, -0.11495005f, 0.13679464f, 0.02932289f, -0.07042518f, 
    0.05545495f, -0.22826357f, 0.01201043f, 0.01358683f, 0.02211749f, -0.02060414f, 0.09350941f, 0.11316100f, 
    -0.09613866f, 0.13066757f, 0.11556850f, 0.02181436f, -0.05367592f, 0.04268328f, -0.28998607f, 0.14292035f, 
    0.06619987f, 0.01269828f, -0.00296771f, -0.17697586f, 0.05226664f, 0.08683764f, -0.19056565f, 0.03234176f, 
    0.07312554f, 0.19264571f, 0.13431433f, 0.03708456f, -0.06096460f, 0.12390023f, -0.06589267f, -0.07606813f, 
    -0.02029338f, -0.34045017f, 0.08035718f, 0.15611976f, 0.17248125f, 0.15678844f, -0.13592504f, -0.06202810f, 
    0.17351495f, -0.16523367f, -0.01397453f, 0.21014959f, 0.01675741f, -0.01846160f, -0.09504647f, -0.03042281f, 
    -0.00038285f, 0.06044737f, -0.17022939f, 0.05270335f, 0.20383719f, -0.13793802f, 0.01227365f, -0.07150508f, 
    -0.03175141f, 0.02379320f, -0.15789309f, 0.29933813f, -0.33359829f, 0.20226029f, -0.13595717f, -0.04508503f, 
    0.18528761f, -0.06902274f, 0.08613331f, 0.08371291f, 0.05877861f, -0.11757314f, -0.06692467f, 0.11507384f, 
    0.14510156f, 0.30798513f, 0.05541564f, 0.02373214f, 0.01766065f, 0.03106604f, 0.24557890f, 0.10691416f, 
    0.24015968f, 0.03636521f, -0.27147228f, 0.00969603f, 0.01733709f, -0.05577452f, 0.03938151f, 0.05256135f, 
    0.31869113f, -0.03084143f, 0.01731222f, -0.10787319f, 0.15273805f, 0.04758799f, 0.02922639f, -0.02469135f, 
    -0.14959757f, 0.28450322f, -0.06517920f, -0.05683129f, 0.12874532f, -0.01035517f, 0.04355058f, -0.03092166f, 
    0.01203548f, -0.48472220f, -0.52342391f, -0.14031862f, -0.28624928f, 0.02694980f, -0.09601758f, 0.03403404f, 
    0.08598131f, -0.07970519f, -0.06443282f, 0.24167784f, 0.06405318f, 0.03701060f, 0.10341767f, 0.23061955f, 
    0.04150400f, -0.18888758f, -0.03907835f, -0.09962723f, -0.02376557f, 0.07227568f, 0.07441522f, 0.36766529f, 
    0.02542963f, 0.12261390f, -0.16659898f, -0.11346543f, -0.09842501f, 0.17539968f, -0.05239007f, -0.19384421f, 
    -0.04273274f, -0.07626375f, 0.08110947f, 0.14775088f, 0.09687519f, 0.07243077f, -0.16759096f, -0.01888595f, 
    -0.07044192f, -0.07343797f, 0.08700845f, -0.10880250f, -0.12789416f, -0.05709346f, -0.10137027f, -0.24061137f, 
    -0.00368616f, -0.07980409f, -0.07240952f, 0.04772706f, 0.14198624f, -0.01490906f, -0.11851798f, 0.19225909f, 
    0.13694406f, 0.08407602f, -0.06629658f, 0.04086251f, 0.07553101f, 0.00037931f, 0.15425637f, -0.28594637f, 
    0.03527199f, 0.00292028f, -0.05541837f, 0.17337337f, 0.08701082f, 0.05604162f, 0.03755566f, 0.02378638f, 
    -0.11330004f, -0.03821635f, -0.03634579f, -0.36511940f, -0.06942093f, -0.07873130f, 0.05285673f, -0.01798775f, 
    -0.03931759f, -0.13329434f, 0.11389868f, 0.07938316f, -0.13894622f, -0.15368560f, 0.15969761f, -0.10349436f, 
    0.01896378f, -0.12408984f, -0.01957806f, 0.11057767f, -0.19371812f, -0.09650795f, 0.04308359f, -0.12994862f, 
    0.03169811f, 0.17914380f, -0.14333650f, 0.11611322f, 0.10832185f, 0.14985700f, 0.02547309f, -0.01702615f, 
    -0.05411836f, 0.10796115f, 0.07743551f, 0.07251556f, 0.30777511f, -0.03121119f, -0.09161193f, -0.29077047f, 
    -0.01292933f, -0.01254459f, 0.01828510f, -0.02276587f, -0.07232445f, -0.15164383f, -0.62940705f, -0.27326906f, 
    -0.06639910f, 0.00642971f, 0.01300666f, 0.12249045f, -0.05302810f, -0.07860062f, -0.40009406f, -0.08334117f, 
    -0.11648072f, 0.04972612f, -0.00599717f, 0.12997879f, -0.05074441f, 0.06088871f, -0.05068463f, -0.70905036f, 
    -0.23192824f, 0.20511015f, -0.11111610f, -0.17350855f, 0.03208051f, -0.00693684f, 0.03482622f, -0.17052503f, 
    -0.06752025f, 0.04669300f, 0.14690816f, -0.07304021f, -0.15468720f, -0.06398288f, -0.26768300f, 0.04949825f, 
    0.21168031f, 0.10753362f, 0.02901395f, -0.20589109f, 0.00906476f, 0.12979315f, 0.05205515f, 0.00929827f, 
    -0.10706849f, -0.02290267f, -0.12683609f, 0.41527700f, 0.28639272f, -0.03641985f, 0.00592844f, -0.01744475f, 
    -0.02763538f, -0.06397054f, -0.04086644f, -0.33670869f, -0.01458603f, -0.02968559f, -0.08052014f, -0.00750400f, 
    -0.15685606f, 0.09917811f, -0.09043998f, -0.03705162f, -0.35331875f, 0.02261120f, 0.12000427f, -0.04361148f, 
    0.32812482f, -0.02521150f, -0.05077593f, 0.01495011f, -0.00736049f, -0.12953441f, 0.03566116f, 0.16210744f, 
    0.04174465f, 0.11416112f, 0.04830199f, -0.01628590f, 0.00878662f, -0.12778805f, 0.01991064f, -0.12076776f, 
    -0.53402984f, -0.06652345f, 0.14531378f, 0.08647963f, -0.04698043f, 0.02067883f, 0.12629297f, 0.00902477f, 
    -0.02799508f, -0.05138071f, 0.08801273f, 0.11075132f, -0.07205447f, 0.02275470f, 0.10040062f, 0.10523178f, 
    -0.07103620f, -0.09262261f, -0.00885002f, 0.13511761f, 0.04216281f, -0.03970968f, 0.02241803f, -0.12956062f, 
    -0.06468717f, -0.33068734f, -0.08750094f, -0.27596879f, -0.09575479f, 0.02518041f, -0.15868835f, -0.11998506f, 
    -0.20990065f, -0.08108782f, 0.00023495f, -0.39447388f, -0.29674271f, -0.07651559f, 0.01238334f, 0.07306371f, 
    0.04329265f, 0.10180694f, -0.04670307f, -0.40851340f, -0.14232624f, 0.28222075f, 0.06897789f, 0.05759436f, 
    -0.06631098f, 0.08819952f, -0.07345017f, -0.14088582f, -0.06316619f, -0.15952162f, 0.18676753f, -0.01139633f, 
    0.21586457f, 0.18388310f, 0.11301398f, 0.02490056f, -0.03477322f, 0.17373148f, 0.11503666f, -0.05819875f, 
    0.00687354f, 0.12847213f, 0.27997491f, -0.03531468f, 0.01458977f, 0.14080945f, 0.08983555f, 0.06650010f, 
    0.21552357f, -0.02693183f, -0.07433752f, 0.08930019f, -0.00601588f, -0.08004975f, -0.06087371f, 0.19210535f, 
    0.20305087f, 0.12735701f, 0.05531303f, -0.11895217f, -0.10606352f, -0.03412474f, 0.07756680f, 0.09777065f, 
    -0.19256398f, -0.02718583f, -0.08755268f, 0.01169868f, 0.08161815f, -0.14874473f, 0.09772693f, -0.04119724f, 
    0.11928263f, 0.02805790f, -0.16624849f, 0.21220700f, 0.05053978f, 0.26528269f, 0.01492433f, 0.01256234f, 
    0.09433065f, 0.02091025f, -0.26160151f, -0.73987538f, -0.34352234f, 0.08583760f, 0.13680783f, 0.24595106f, 
    0.02430365f, 0.04679802f, -0.01806482f, 0.35265085f, 0.01095621f, 0.06079779f, 0.01895435f, -0.01552788f, 
    -0.05161354f, -0.02703915f, -0.02927579f, 0.01616520f, -0.49992889f, 0.06390216f, 0.18781190f, -0.18884809f, 
    0.13835742f, -0.13717759f, 0.05243113f, -0.05524291f, -0.00185057f, -0.12548566f, -0.19973801f, -0.22381842f, 
    -0.20543349f, 0.03567996f, -0.12210582f, 0.11252063f, -0.03381614f, 0.09214646f, -0.34192273f, -0.20910552f, 
    -0.09400415f, -0.01135723f, 0.13240141f, -0.05717127f, 0.07677486f, 0.06277161f, -0.06321215f, 0.15370232f, 
    0.03974045f, 0.08806980f, -0.13188536f, 0.14485292f, 0.10835799f, 0.03340634f, 0.19584964f, 0.14243555f, 
    0.01198863f, -0.02945268f, 0.07856064f, -0.13824354f, -0.11308786f, 0.07062551f, -0.04463288f, 0.06307138f, 
    -0.02707140f, 0.18476382f, -0.04883260f, 0.09039122f, -0.06672164f, 0.10578234f, 0.10909779f, -0.13293147f, 
    -0.04865134f, -0.04652613f, -0.15282422f, -0.33626786f, -0.31109449f, -0.31329998f, -0.43325570f, 0.03281002f, 
    0.06419910f, -0.03225675f, -0.04577920f, 0.11517854f, -0.04589549f, -0.06359269f, -0.06399763f, 0.01477606f, 
    0.05163552f, 0.02165948f, -0.02753619f, -0.03501920f, -0.00080855f, -0.02573118f, -0.12401498f, 0.00742559f, 
    -0.06585501f, 0.01269106f, 0.09139594f, -0.09498839f, 0.08257512f, -0.07409673f, 0.14802290f, -0.11930294f, 
    -0.17809224f, 0.05867330f, -0.13774367f, 0.00523572f, -0.06411596f, 0.10607449f, 0.08651304f, -0.16452660f, 
    -0.39279664f, -0.15626580f, 0.20504667f, -0.04650885f, -0.06810030f, -0.06492624f, 0.07592912f, 0.15826656f, 
    0.44384140f, 0.06723790f, 0.02304177f, 0.16708019f, 0.03208870f, -0.16914411f, 0.13491139f, 0.03342946f, 
    -0.16449869f, -0.41376761f, -0.34051633f, 0.05832219f, -0.03666266f, -0.23287942f, 0.02398948f, 0.01727141f, 
    0.04328829f, 0.14369148f, 0.30119431f, -0.35473001f, 0.11362650f, 0.18807347f, 0.04050840f, -0.12180011f, 
    0.17748952f, 0.06967009f, -0.11928742f, 0.01505096f, 0.21533440f, -0.07918900f, 0.12390599f, 0.02113720f, 
    0.02967553f, 0.03769919f, 0.21363412f, 0.12469159f, 0.26170039f, 0.15755492f, -0.19461474f, -0.07738373f, 
    -0.07987664f, -0.07202955f, -0.15816322f, 0.10865077f, -0.14320193f, -0.10132071f, -0.18578584f, 0.03384043f, 
    0.08647172f, 0.19671091f, 0.15116502f, 0.12804469f, -0.02062260f, 0.01802233f, 0.06055331f, 0.22131968f, 
    -0.08868197f, 0.02162687f, 0.09321006f, 0.03213596f, 0.01284212f, 0.02240322f, 0.14613064f, -0.03880154f, 
    0.23146269f, 0.06867128f, 0.08178103f, 0.16204992f, 0.15150052f, -0.01213409f, -0.00876598f, 0.18228227f, 
    0.14835361f, 0.00308597f, -0.01466889f, 0.03680729f, -0.01821262f, 0.07922450f, 0.05676863f, 0.08643623f, 
    0.17211394f, -0.07962856f, -0.22093847f, -0.07421086f, -0.19527137f, -0.03766614f, -0.07348915f, 0.11323433f, 
    -0.05426946f, 0.09460636f, 0.20383149f, 0.20313214f, -0.11404637f, 0.06458738f, -0.07846706f, 0.11203920f, 
    -0.16917574f, 0.08674439f, 0.05056590f, 0.15168644f, 0.20842853f, 0.06313801f, 0.17960466f, 0.17943734f, 
    0.06382473f, -0.02404245f, -0.09295064f, -0.20013967f, 0.03607785f, -0.06077660f, -0.04561152f, 0.00329053f, 
    0.18813366f, 0.08406352f, -0.01449863f, 0.02187693f, -0.01190311f, 0.06717451f, -0.14172219f, 0.07472719f, 
    -0.00323022f, 0.03955652f, -0.11548273f, 0.02541193f, -0.04640212f, 0.75039208f, 0.16282044f, -0.31995028f, 
    -0.05109706f, 0.00804074f, -0.07527451f, 0.00014889f, 0.02892493f, 0.06619033f, 0.12310312f, -0.34158194f, 
    -0.15229648f, 0.14490643f, 0.07448614f, 0.07558704f, 0.17123106f, 0.07199435f, 0.08190854f, -0.14208902f, 
    -0.18997632f, 0.02504941f, -0.01516706f, -0.04002907f, 0.01788644f, -0.05229787f, 0.03911619f, -0.00266658f, 
    -0.41718400f, -0.19484502f, -0.34884331f, -0.17144278f, -0.05680330f, -0.05121792f, 0.00036356f, 0.02613762f, 
    0.14581534f, -0.06309139f, 0.00474344f, -0.06744070f, -0.05138230f, 0.02865633f, -0.08716084f, 0.05904328f, 
    -0.02341718f, -0.16650183f, -0.19825958f, 0.02474595f, -0.11973806f, -0.06274329f, -0.06352738f, 0.01667458f, 
    -0.02134888f, -0.01501695f, -0.13444328f, -0.02356242f, -0.26064211f, -0.14279887f, -0.12295574f, 0.01233255f, 
    0.03813148f, -0.02641095f, 0.03060409f, 0.17430241f, 0.24403094f, 0.14873095f, -0.51853842f, 0.01991023f, 
    0.01784592f, -0.02750260f, 0.06418490f, -0.03170941f, 0.09742653f, 0.25182557f, 0.11605577f, -0.00892252f, 
    0.05060403f, -0.05423475f, -0.00432624f, -0.00628627f, -0.04915145f, 0.01635581f, 0.01965586f, 0.04071389f, 
    0.14845604f, -0.02078824f, 0.07607353f, -0.10787115f, 0.03347610f, -0.02650273f, -0.05147219f, 0.11500779f, 
    0.19295476f, -0.07016994f, -0.06059406f, -0.10358163f, -0.05902245f, -0.13889410f, 0.18483251f, 0.05423022f, 
    0.03066198f, -0.07301962f, -0.17005283f, -0.04208948f, -0.07405331f, 0.02169156f, -0.01507716f, -0.02216000f, 
    0.09871955f, 0.02511111f, -0.02718244f, -0.27493772f, -0.11640937f, 0.11532638f, -0.14787394f, -0.00533123f, 
    0.03010733f, 0.12927082f, -0.11939093f, 0.11108596f, 0.20244537f, 0.12503116f, 0.08819243f, 0.08389840f, 
    0.01301419f, 0.02202496f, -0.12436241f, 0.20455088f, 0.05654546f, 0.12208898f, 0.01019858f, 0.08225600f, 
    0.15927325f, 0.03560126f, 0.07144955f, 0.06205853f, -0.33213395f, -0.42108968f, -0.30380285f, -0.17469092f, 
    -0.11798359f, -0.16217130f, 0.06995980f, -0.01186404f, 0.29367575f, -0.73189509f, -0.05775363f, -0.10127934f, 
    -0.02358956f, 0.01392378f, 0.06406736f, -0.00076486f, 0.06423792f, 0.05341811f, 0.15281349f, 0.09665036f, 
    0.03531754f, -0.08354786f, -0.03303424f, -0.06044052f, 0.05437859f, 0.05371549f, -0.06327295f, -0.26667014f, 
    -0.31640604f, -0.28216720f, -0.08293489f, 0.26606306f, -0.01528504f, 0.21460456f, 0.18467566f, 0.02860545f, 
    0.07577745f, 0.13980541f, 0.02720979f, -0.11448649f, -0.19983141f, -0.14500569f, -0.06836651f, 0.18150727f, 
    0.10670587f, -0.22492640f, 0.02697829f, -0.11100069f, -0.11530319f, -0.04193062f, 0.07589457f, 0.05752572f, 
    -0.00639644f, -0.03111840f, 0.43069169f, 0.19570893f, -0.04527276f, -0.03775800f, -0.20183387f, -0.11283084f, 
    0.02229957f, 0.03900367f, 0.05033756f, 0.11274197f, 0.18609281f, -0.03153575f, -0.04018766f, 0.01998065f, 
    -0.09822649f, 0.01990734f, 0.04721086f, 0.02395219f, 0.28229830f, 0.02175769f, -0.04469395f, -0.13243377f, 
    -0.19595931f, 0.08072779f, 0.00830324f, 0.04621029f, 0.04489767f, 0.21120448f, 0.07889202f, -0.07362475f, 
    0.03553313f, 0.02578333f, 0.06059069f, -0.00024357f, 0.01265317f, -0.00353381f, 0.12713398f, -0.01788734f, 
    0.02033840f, -0.01364899f, 0.02095007f, 0.01525045f, -0.15406911f, -0.07780385f, 0.12603857f, -0.12810105f, 
    -0.04722464f, -0.04419537f, -0.05641649f, -0.04795129f, -0.01301144f, -0.09014838f, -0.01802304f, 0.00475109f, 
    0.04629956f, -0.04441791f, -0.13103460f, -0.02601726f, 0.16618191f, -0.06838612f, -0.05296283f, 0.22680150f, 
    0.20207116f, 0.23411219f, 0.33277673f, 0.01662994f, 0.02055505f, -0.19464444f, -0.09025785f, -0.04130579f, 
    0.04855137f, 0.00805976f, -0.00934306f, 0.03089979f, -0.05925933f, -0.07402524f, -0.08376201f, 0.08916572f, 
    0.00294971f, -0.03135927f, 0.11707037f, 0.20368709f, 0.08392428f, -0.14279564f, -0.08053434f, -0.26678485f, 
    -0.06112004f, 0.09082115f, 0.12377457f, 0.11409342f, -0.03818108f, 0.19277902f, -0.19371887f, -0.00742167f, 
    0.00090886f, -0.03494678f, 0.08081060f, -0.01238068f, 0.12017744f, -0.49792835f, -0.08412145f, -0.40496850f, 
    -0.00581238f, -0.03124758f, 0.04536300f, 0.16315055f, -0.03572306f, 0.02621192f, -0.09851884f, 0.10488065f, 
    -0.02367687f, -0.08430656f, -0.09453171f, -0.03282414f, 0.03679688f, 0.12980640f, 0.04003454f, -0.04049252f, 
    -0.00064385f, 0.06076315f, 0.02963596f, 0.07533310f, -0.11248077f, 0.05054635f, 0.00869953f, -0.00061451f, 
    -0.17153086f, -0.13839529f, 0.04335762f, 0.02663336f, 0.06330170f, -0.12699284f, 0.04882836f, -0.10946878f, 
    0.01541971f, 0.02646206f, -0.00762832f, 0.08270260f, -0.16542569f, 0.11637007f, -0.16748831f, 0.03300573f, 
    0.02216227f, 0.07479882f, 0.12132557f, -0.04427679f, -0.03881167f, -0.00627285f, 0.19621168f, -0.03294809f, 
    -0.01194704f, 0.09859636f, -0.00652799f, -0.06342711f, 0.01351678f, 0.24446000f, 0.02414622f, 0.04441071f, 
    -0.05237534f, -0.01563671f, 0.10184720f, -0.03974449f, -0.01035634f, 0.11868077f, -0.21885245f, -0.06432086f, 
    -0.05010343f, -0.01699256f, 0.13436759f, 0.04778881f, -0.10717952f, 0.20938510f, 0.09703131f, -0.08429083f, 
    -0.02741612f, -0.14367931f, -0.05501620f, 0.07379223f, 0.01381006f, 0.01228179f, 0.17426158f, 0.02371027f, 
    0.20871568f, -0.02415802f, 0.10119934f, -0.00375200f, -0.01030634f, -0.06919801f, -0.03814201f, -0.27690604f, 
    -0.14169861f, -0.01286148f, 0.04296029f, -0.00989273f, 0.04809627f, 0.00415625f, -0.09572922f, 0.02703146f, 
    0.05188196f, 0.13336375f, -0.01259811f, -0.41827792f, -0.29378232f, -0.23515783f, 0.20648906f, 0.06592131f, 
    0.01912109f, -0.23735739f, 0.09736488f, -0.05333133f, -0.01178972f, -0.09154147f, 0.13652550f, -0.01517365f, 
    -0.25194669f, 0.00724972f, 0.03678296f, 0.16151536f, 0.20266704f, -0.05688350f, -0.01288059f, -0.04857345f, 
    0.05400914f, -0.02320578f, 0.04963176f, 0.09623110f, -0.00813849f, -0.05241299f, -0.10915121f, -0.11757835f, 
    0.04622022f, -0.05939477f, 0.10996234f, -0.11585738f, 0.16631861f, 0.11271742f, 0.12516716f, -0.33016655f, 
    -0.36742443f, -0.25260884f, 0.13578241f, 0.14230751f, 0.08632915f, -0.26695749f, -0.13455042f, -0.06158376f, 
    0.05509252f, 0.02261974f, -0.22031046f, -0.00438114f, 0.09923977f, 0.12911724f, -0.18015133f, 0.15105447f, 
    0.36198151f, -0.13242066f, 0.20072769f, 0.07161981f, -0.04964759f, 0.07231806f, -0.04780077f, -0.04772926f, 
    -0.17584422f, 0.23952390f, -0.11713381f, -0.01136269f, 0.04736592f, 0.05223306f, -0.14533226f, 0.08469535f, 
    0.15390171f, 0.35331112f, 0.12213475f, -0.04513279f, -0.10482249f, 0.00753259f, 0.08866094f, 0.17276835f, 
    -0.02752498f, 0.13544509f, 0.16837980f, 0.17076048f, 0.08130381f, 0.00319516f, -0.13891190f, -0.10268120f, 
    -0.04184787f, -0.24350989f, 0.20194247f, -0.19785850f, 0.06062789f, 0.10040981f, 0.07342527f, 0.03014492f, 
    0.00909188f, 0.01530499f, -0.22305231f, 0.31750834f, 0.10665837f, -0.00158757f, 0.11619761f, -0.02064063f, 
    -0.36148167f, -0.12100036f, -0.19499341f, -0.45720401f, -0.06534941f, 0.02013079f, 0.29860407f, -0.00868686f, 
    0.10916724f, -0.06731093f, -0.06035649f, 0.04174116f, 0.10927252f, 0.14400022f, 0.07152989f, 0.18330480f, 
    0.04498466f, -0.01377428f, -0.25872481f, -0.12055866f, -0.24580087f, -0.20386232f, -0.01224723f, 0.00804005f, 
    -0.05028865f, -0.28723910f, 0.00730842f, 0.04349746f, 0.12367201f, 0.08017782f, 0.35685226f, 0.11111961f, 
    -0.03309063f, 0.12396184f, -0.17835346f, 0.14472984f, -0.08829207f, 0.03968012f, 0.18027785f, 0.20826879f, 
    0.15192568f, 0.01018186f, -0.01232226f, -0.00026685f, -0.07648859f, -0.12651338f, -0.06634391f, -0.14245217f, 
    -0.27007410f, -0.05415583f, 0.13638367f, 0.17261593f, -0.08133230f, 0.00372219f, -0.12861758f, -0.12339932f, 
    -0.21412565f, -0.20913002f, 0.00119808f, 0.00967910f, -0.05396901f, -0.07229563f, -0.01737631f, 0.03528810f, 
    0.02489783f, 0.04354937f, 0.08823329f, 0.08954209f, -0.11227502f, 0.04640451f, 0.01662530f, -0.05181486f, 
    -0.13229975f, 0.00252383f, -0.05913346f, -0.23409213f, -0.18900537f, -0.03324623f, -0.02389810f, 0.09630637f, 
    -0.06747469f, 0.16884659f, -0.08909107f, 0.08772111f, -0.01114085f, -0.55253726f, 0.04208048f, -0.00089437f, 
    0.12352704f, -0.05358256f, 0.03979802f, -0.04980062f, 0.13743508f, 0.09118570f, -0.04119590f, -0.04437852f, 
    0.06093318f, 0.07396164f, 0.00899532f, 0.04486649f, 0.05492894f, -0.06944877f, -0.26931155f, 0.10540602f, 
    0.05414470f, -0.03698375f, 0.12094904f, 0.05452016f, 0.07389367f, 0.13395575f, -0.03960530f, -0.08445010f, 
    0.24905522f, 0.14286038f, -0.18328659f, 0.04003261f, 0.06805397f, 0.18380553f, 0.07982498f, 0.14509259f, 
    0.03263037f, -0.03658231f, 0.03633123f, -0.07678657f, 0.07832769f, 0.04121352f, -0.05671554f, 0.03338987f, 
    -0.01883983f, 0.12996590f, -0.10647272f, 0.03070927f, -0.22720727f, 0.10022876f, -0.08753452f, -0.02280820f, 
    0.10136016f, -0.00550192f, -0.10895742f, 0.34979907f, 0.04451934f, 0.10570758f, 0.04920864f, 0.01442946f, 
    -0.06443092f, -0.06138715f, -0.11704849f, -0.21614356f, 0.08196282f, -0.07613031f, 0.04335118f, -0.13915114f, 
    0.05457364f, -0.10037867f, -0.02588082f, 0.01617340f, 0.03429000f, 0.13751930f, 0.05524215f, -0.18976535f, 
    -0.14070091f, -0.00555358f, -0.06687102f, -0.03072996f, -0.11861978f, 0.12356129f, -0.06095586f, -0.08180106f, 
    0.01657108f, 0.10580937f, 0.03740847f, -0.12985867f, 0.02362628f, -0.15478787f, 0.00695353f, -0.04375226f, 
    -0.03526910f, -0.22244838f, -0.04630010f, -0.06497250f, 0.10266991f, 0.18016556f, -0.01198232f, -0.12731247f, 
    0.09524123f, 0.01971648f, 0.10694920f, 0.06777097f, -0.02027772f, -0.00901357f, 0.01665805f, -0.08444203f, 
    -0.02803030f, 0.03002284f, -0.17904001f, -0.14464015f, 0.10712520f, -0.04195973f, 0.01971743f, 0.18272081f, 
    0.03324349f, -0.09464467f, -0.02025439f, -0.00146540f, 0.03641039f, -0.00648851f, -0.06346368f, 0.00324345f, 
    -0.08266964f, -0.07676820f, 0.08035217f, -0.03024082f, -0.12299381f, -0.14695297f, -0.28659469f, 0.02657965f, 
    -0.03883163f, 0.09315934f, 0.02688819f, 0.17929792f, 0.04576338f, 0.19940951f, 0.18179592f, 0.03847539f, 
    0.06448951f, -0.06340465f, -0.06125953f, -0.01916905f, 0.06510602f, -0.09008415f, 0.10622629f, -0.09617443f, 
    -0.07256526f, -0.06175213f, 0.08678062f, 0.10437895f, 0.17834425f, 0.20858599f, 0.11128297f, -0.13607079f, 
    -0.25824368f, -0.12963498f, 0.11751186f, -0.05437499f, 0.13284825f, -0.15655597f, 0.07808132f, 0.24727842f, 
    -0.05868611f, -0.07185477f, -0.05165609f, 0.10157840f, 0.01134663f, 0.07156574f, -0.06625736f, 0.06255059f, 
    -0.33519036f, -0.05169212f, 0.16645655f, -0.02681088f, -0.14897636f, -0.12929101f, 0.06606330f, -0.06535646f, 
    -0.09633188f, 0.05797453f, -0.34482786f, -0.39890721f, -0.02163173f, 0.01671631f, -0.09522463f, 0.15687108f, 
    0.06621703f, 0.05302578f, 0.17656533f, -0.13998976f, 0.16472550f, -0.15357713f, -0.03888600f, -0.12578915f, 
    -0.07126474f, -0.00951655f, 0.12522268f, -0.25023684f, -0.36803517f, 0.02150233f, 0.12316790f, -0.00148082f, 
    -0.02127082f, 0.16410191f, 0.20584208f, 0.09133434f, 0.22561024f, -0.04206600f, -0.16528018f, -0.02365177f, 
    0.08468665f, 0.11101732f, 0.05508260f, -0.03724232f, -0.01995761f, 0.16343407f, -0.10974437f, -0.37003773f, 
    0.03947920f, 0.10267992f, 0.06274707f, 0.07029942f, 0.08253432f, 0.16945608f, 0.05067025f, -0.07770658f, 
    -0.12747981f, -0.05043475f, -0.09777715f, -0.02382433f, 0.00095766f, 0.03258402f, -0.14914709f, -0.08087083f, 
    0.02729333f, 0.19551621f, -0.05957797f, 0.09101014f, 0.07659572f, -0.12165569f, 0.02046388f, -0.13999887f, 
    -0.24086367f, -0.33431375f, 0.17875253f, 0.08802468f, -0.07092820f, -0.02432272f, -0.00168211f, -0.05620979f, 
    0.01053019f, -0.32701302f, -0.57376683f, -0.19262496f, 0.08756337f, 0.04531779f, -0.02664649f, 0.03038632f, 
    0.08025059f, 0.11059938f, -0.02419496f, -0.18287398f, -0.04716569f, -0.17113206f, -0.06891789f, -0.15965660f, 
    0.07080958f, 0.07733391f, 0.08526272f, 0.24697676f, -0.24825069f, 0.20058961f, -0.08713645f, -0.02296541f, 
    0.01990629f, -0.00739016f, -0.19408675f, 0.12363782f, -0.14370522f, -0.09453761f, 0.18947472f, -0.02646072f, 
    0.08341745f, 0.17173606f, -0.01191234f, -0.04469910f, 0.04774085f, 0.29081920f, -0.10152213f, -0.22609462f, 
    0.01131343f, 0.17754507f, 0.02983466f, 0.13564131f, 0.02380300f, 0.16668929f, -0.13631168f, 0.00393697f, 
    0.07131726f, 0.02548294f, 0.07528035f, -0.04839041f, 0.00505520f, -0.02211984f, 0.13235883f, -0.02554362f, 
    0.05167916f, -0.01686165f, 0.08458897f, -0.01017001f, -0.04916936f, 0.04967819f, 0.04380893f, 0.10551295f, 
    -0.69410139f, -0.15437841f, -0.11891167f, 0.00040629f, -0.13766629f, -0.10184465f, 0.06590126f, 0.14812376f, 
    0.04203915f, -0.10707603f, -0.10242543f, 0.20537290f, -0.06392210f, 0.01695742f, 0.14048201f, -0.08401313f, 
    0.15289328f, 0.05910218f, 0.14723015f, -0.11872645f, -0.03920460f, 0.14414945f, 0.05216108f, 0.05464596f, 
    -0.02330480f, 0.01954344f, 0.05801370f, -0.57670164f, 0.10000209f, 0.10039306f, 0.07898164f, -0.02900038f, 
    -0.11971482f, 0.15417607f, -0.00621852f, 0.16378258f, 0.03719978f, -0.00555289f, -0.09694506f, -0.14573081f, 
    -0.18313554f, -0.06697156f, 0.05183231f, 0.24126942f, -0.03568780f, 0.08956999f, -0.26965499f, 0.12816294f, 
    -0.04743795f, -0.08101168f, -0.07540324f, -0.03299234f, 0.13287233f, -0.00888731f, 0.00924284f, -0.06305566f, 
    -0.16297661f, 0.01959017f, 0.12970902f, 0.03367876f, -0.02630725f, 0.17451447f, 0.05218253f, 0.36054602f, 
    0.03199440f, -0.04446787f, 0.01321317f, 0.04271358f, 0.11759074f, 0.19496018f, 0.03506801f, 0.17518204f, 
    -0.16656193f, -0.03589966f, 0.12691462f, -0.20406966f, -0.13102378f, -0.30853960f, -0.05537802f, -0.13820782f, 
    0.11943930f, 0.15663370f, -0.05803004f, 0.17104149f, -0.14901516f, -0.16603328f, -0.18787195f, 0.10360749f, 
    -0.02419933f, 0.15552813f, -0.10125197f, -0.03218992f, -0.01244332f, -0.13063170f, -0.16828762f, -0.14403401f, 
    -0.03065671f, 0.15451184f, 0.02633133f, 0.20965979f, 0.10792214f, 0.11734067f, -0.06761815f, -0.02759182f, 
    0.00656888f, 0.09963598f, 0.03434702f, 0.01120579f, 0.04263584f, -0.03226266f, -0.01331108f, -0.12986763f, 
    -0.06392283f, -0.13195015f, 0.00290463f, -0.05115586f, 0.00539492f, 0.14208217f, -0.01902699f, 0.09150027f, 
    -0.02659136f, -0.10478565f, -0.10074586f, 0.09815821f, 0.06840017f, -0.00021093f, 0.34769431f, -0.24925211f, 
    -0.33616638f, -0.12552939f, -0.09183899f, -0.07734055f, 0.10760459f, 0.07392345f, 0.05676555f, 0.30981022f, 
    -0.15517478f, -0.20595008f, -0.01079422f, 0.04881750f, -0.09044968f, 0.01356969f, -0.09062083f, 0.10858150f, 
    0.17515723f, 0.18004833f, 0.22665675f, -0.00799443f, -0.12425764f, -0.09498293f, -0.01410762f, 0.04472572f, 
    -0.03065063f, 0.45817220f, 0.15800630f, -0.16606610f, 0.10190821f, 0.02055555f, 0.02489008f, 0.05774433f, 
    -0.05626784f, 0.10152366f, 0.24404979f, 0.36220965f, -0.17556736f, -0.14721434f, -0.08915216f, -0.03054558f, 
    0.05824892f, 0.06838727f, -0.06272960f, -0.15610570f, 0.14475708f, 0.28406534f, 0.22897443f, -0.04234667f, 
    0.11261974f, 0.07146088f, -0.16350830f, -0.14348720f, 0.10107538f, -0.05579258f, -0.20493442f, -0.04866404f, 
    -0.12072421f, 0.00118006f, 0.07211573f, -0.01145741f, -0.04838219f, -0.16528820f, 0.34274966f, 0.29475626f, 
    0.07423870f, -0.06436063f, 0.07450064f, 0.12218797f, 0.04019203f, 0.10294472f, -0.17087355f, -0.25696075f, 
    -0.46655792f, -0.16202754f, 0.08218149f, 0.07824717f, 0.03917287f, -0.07933179f, -0.10109416f, -0.17634475f, 
    -0.08828765f, -0.19363445f, -0.13797502f, 0.02801829f, 0.08599672f, -0.04102349f, -0.09143065f, 0.06421354f, 
    -0.26698488f, 0.06030833f, -0.01720897f, 0.11470253f, 0.13811150f, 0.02652747f, 0.00640910f, -0.04779517f, 
    0.01649834f, -0.11630512f, 0.26976097f, 0.07779466f, -0.07755421f, -0.10110124f, -0.05147324f, 0.00741046f, 
    -0.16943671f, 0.09760759f, 0.11649593f, -0.21043594f, -0.61160570f, 0.06185204f, -0.05537957f, -0.09492785f, 
    -0.12200702f, 0.08152131f, 0.09458906f, 0.09635314f, 0.04902416f, -0.25712994f, -0.05680994f, -0.01544648f, 
    0.12148307f, 0.14523719f, 0.07706391f, 0.01552804f, 0.10071182f, -0.09091444f, -0.09034903f, 0.07036486f, 
    0.20850286f, 0.11000782f, -0.13184513f, 0.06380227f, 0.01514339f, 0.55459654f, -0.10046239f, -0.36026123f, 
    -0.16063100f, 0.07024145f, -0.03791283f, -0.04812737f, 0.10867979f, 0.05553100f, 0.21121146f, 0.17069723f, 
    0.06105950f, 0.10802311f, -0.11772627f, -0.17814684f, 0.06104325f, 0.07279348f, 0.08063834f, 0.10258371f, 
    0.14923070f, 0.11716729f, 0.09145190f, 0.09368312f, 0.00244786f, 0.12629053f, 0.28074819f, 0.13191219f, 
    -0.02890530f, -0.13474154f, 0.02862476f, -0.07054384f, 0.12803966f, -0.01964291f, -0.02625395f, -0.22085644f, 
    0.07652169f, -0.08098424f, -0.11633482f, -0.24138057f, 0.05338490f, -0.04194313f, 0.04613988f, 0.14172353f, 
    -0.07426932f, -0.05737836f, -0.27250266f, -0.27495408f, -0.50519508f, 0.02636229f, 0.25795975f, -0.09389552f, 
    0.02171133f, -0.05253657f, 0.02793470f, 0.16261062f, -0.15692255f, -0.02665922f, 0.03945932f, 0.09970798f, 
    0.08047506f, 0.09719607f, -0.09219596f, -0.03022465f, 0.06894531f, 0.01417154f, -0.37183014f, 0.04904372f, 
    -0.06246851f, 0.04812256f, -0.02092189f, 0.12644501f, -0.05414987f, -0.70239663f, 0.08251061f, -0.17861338f, 
    -0.01747739f, -0.03878765f, -0.12630525f, -0.03127936f, 0.03352220f, 0.05394581f, -0.51492101f, -0.03249956f, 
    0.13564681f, 0.07825472f, 0.02249975f, -0.02381539f, -0.00364606f, 0.04092929f, -0.03814068f, -0.08190818f, 
    0.01430780f, -0.09558493f, 0.07079022f, 0.10779405f, 0.06864872f, 0.22574158f, 0.10312249f, 0.08084786f, 
    0.14934017f, -0.03238105f, 0.04014208f, -0.03197461f, -0.12746684f, -0.21913616f, -0.00837512f, -0.03618012f, 
    -0.07151647f, 0.07935586f, -0.06512593f, -0.14653358f, 0.20812123f, 0.02204640f, 0.00038770f, -0.00471966f, 
    -0.16911975f, 0.06833598f, -0.10160895f, 0.04160129f, -0.34590825f, -0.06547204f, -0.02347836f, -0.22725283f, 
    -0.04370487f, -0.02060975f, 0.00800244f, -0.21197134f, -0.28789955f, -0.45334837f, 0.03223612f, 0.02266820f, 
    0.08818769f, 0.06715748f, -0.04225558f, 0.06923892f, 0.29170552f, 0.12481995f, 0.14514340f, -0.11186282f, 
    -0.28233635f, -0.18716089f, 0.02893562f, -0.04466517f, -0.13603395f, -0.12183805f, -0.00462306f, 0.09908780f, 
    0.04953903f, 0.13829583f, -0.14898285f, -0.07154751f, -0.25504708f, 0.19215024f, -0.53792077f, -0.26060602f, 
    -0.14433399f, -0.19084263f, -0.02239694f, -0.26302695f, 0.03390009f, 0.05264923f, -0.08441836f, -0.10877817f, 
    -0.13596052f, -0.21669501f, -0.11057340f, 0.11935814f, -0.13025956f, -0.04162424f, 0.35512045f, -0.31686962f, 
    -0.01758710f, -0.03413747f, 0.03323663f, -0.05413873f, -0.04699923f, -0.06542999f, -0.04148358f, 0.03258349f, 
    0.02198918f, 0.03446191f, -0.01561438f, 0.00123899f, -0.03922501f, 0.02664176f, -0.04599258f, -0.00416082f, 
    -0.00713090f, -0.00392745f, -0.03596288f, -0.04980339f, -0.05052989f, 0.02330870f, -0.00594116f, -0.00784712f, 
    -0.05935048f, -0.01882252f, -0.00721861f, -0.00181146f, 0.03529438f, -0.05939774f, -0.02856988f, 0.01398851f, 
    -0.01694100f, 0.03677310f, 0.01528591f, 0.05344734f, 0.01342357f, -0.00477907f, -0.03347448f, -0.06146431f, 
    -0.03171358f, -0.06056378f, -0.00724796f, -0.03497098f, -0.04599509f, -0.01666629f, -0.02387695f, -0.01455693f, 
    0.02124928f, -0.06368066f, 0.03775042f, -0.03029894f, 0.00127055f, -0.01614888f, -0.03505493f, 0.02746590f, 
    -0.01294474f, -0.04499613f, -0.03112724f, -0.05903770f, 0.03876543f, 0.01560180f, -0.02977947f, 0.01617236f, 
    0.00206947f, 0.03002027f, 0.04640011f, -0.04331942f, -0.00067978f, 0.01081180f, -0.05903221f, 0.01608451f, 
    -0.02009143f, 0.00100495f, 0.01892422f, 0.04371066f, 0.03463316f, -0.04097218f, 0.01006270f, -0.01302180f, 
    0.01758813f, -0.03943598f, -0.05617255f, -0.02772041f, -0.01611994f, -0.06399759f, -0.01330957f, -0.01754003f, 
    -0.06063848f, 0.01521606f, 0.04490058f, -0.04947118f, -0.02538778f, -0.02828728f, 0.00717955f, -0.01924045f, 
    -0.05580403f, 0.04953942f, 0.04908114f, 0.03262777f, 0.02262376f, -0.00519384f, 0.03513101f, -0.04452512f, 
    -0.00517836f, -0.04016896f, -0.05904438f, -0.04002754f, -0.05218798f, 0.04852620f, 0.00013022f, -0.05181373f, 
    -0.04904325f, -0.05929906f, 0.03974689f, -0.01922010f, 0.03065111f, 0.04981673f, -0.02904109f, 0.04752501f, 
    -0.02311755f, -0.01750997f, -0.01297970f, -0.02221817f, 0.01639058f, -0.00443263f, -0.01900233f, -0.00135062f, 
    -0.00638119f, -0.00856152f, 0.00035664f, -0.04593023f, -0.03119653f, 0.03696069f, -0.01864628f, -0.01412542f, 
    -0.05611163f, 0.00618946f, -0.04469750f, 0.02715637f, -0.04548053f, -0.00091758f, -0.04072066f, -0.01771124f, 
    0.01690957f, -0.05794186f, -0.06082420f, 0.01096216f, 0.04661061f, 0.04529256f, -0.03909657f, 0.02425921f, 
    -0.03709914f, -0.02942506f, -0.02117134f, 0.01870089f, 0.01378983f, -0.05389012f, -0.04650966f, -0.03218761f, 
    -0.05433156f, 0.01835339f, -0.05924392f, -0.05844774f, 0.01256444f, 0.01021158f, 0.00355876f, 0.05075191f, 
    0.04865956f, 0.00089893f, -0.02605971f, 0.01467497f, -0.00501085f, 0.05403714f, -0.04421563f, 0.03982472f, 
    -0.02346495f, -0.00916802f, -0.02674451f, -0.04938402f, -0.05589803f, -0.01855665f, -0.00253440f, 0.02829146f, 
    -0.04395520f, -0.01045282f, -0.04396063f, 0.03700445f, 0.01022893f, -0.05213309f, 0.03749954f, -0.01105891f, 
    -0.03129755f, -0.03855661f, 0.02544434f, -0.05968707f, -0.06106023f, -0.05731026f, -0.01178421f, -0.05850154f, 
    0.04516954f, -0.03088839f, 0.04632591f, -0.00529601f, -0.01484127f, -0.02777901f, 0.02328994f, -0.00096778f, 
    -0.05256894f, -0.02615991f, 0.00402335f, 0.02699018f, -0.05568429f, -0.00939642f, -0.00349140f, 0.04435699f, 
    0.00167225f, 0.04918654f, 0.00192648f, 0.04596775f, -0.06529445f, -0.02872879f, -0.06486369f, 0.03542586f, 
    0.04160493f, -0.03549193f, 0.04082492f, -0.05374589f, 0.03834182f, -0.01602638f, 0.01154478f, 0.05196741f, 
    -0.05069744f, 0.04757905f, 0.05228826f, 0.01341391f, 0.02883310f, -0.00398565f, 0.02504337f, 0.03820402f, 
    -0.04370144f, -0.04577451f, 0.01300525f, -0.01456959f, 0.03094966f, -0.03606082f, 0.02031933f, 0.00241577f, 
    0.02263124f, -0.03801614f, 0.03676490f, 0.04215689f, 0.03848164f, -0.06442845f, 0.04985678f, -0.05982227f, 
    -0.04235304f, -0.03242786f, -0.03137698f, -0.06152614f, -0.01415406f, -0.03126573f, 0.02753861f, -0.02936464f, 
    0.03915213f, 0.02891243f, -0.04169970f, -0.05936618f, -0.00622474f, 0.00074870f, -0.03511593f, -0.01616427f, 
    -0.05428628f, 0.04531384f, 0.04772075f, 0.02511654f, -0.05354215f, -0.03421836f, -0.01378625f, 0.03596536f, 
    0.02620329f, 0.03164979f, 0.01798269f, -0.02722005f, 0.01751369f, 0.05015929f, 0.01015426f, -0.03746478f, 
    0.02408338f, -0.04818228f, -0.05298815f, 0.01111598f, -0.05998353f, -0.04968125f, -0.00903464f, 0.04208436f, 
    0.04463033f, -0.03455167f, 0.05136280f, -0.01480734f, -0.01353215f, -0.04787770f, 0.03599865f, -0.02569588f, 
    0.00698013f, -0.05920852f, 0.00948601f, 0.04310266f, -0.00080152f, 0.00095491f, 0.04044067f, -0.01194814f, 
    -0.00283831f, -0.04842301f, 0.03111771f, 0.01503316f, 0.04798291f, 0.04057278f, 0.01573330f, -0.04448599f, 
    -0.05539532f, -0.05791533f, -0.01911000f, 0.04223293f, 0.04028482f, 0.02283452f, 0.03970003f, -0.03797918f, 
    0.03989913f, 0.01747289f, 0.02656229f, 0.03530083f, -0.00495784f, -0.04873656f, 0.01436126f, 0.03914956f, 
    -0.02448137f, 0.04917664f, 0.04589355f, 0.03084278f, 0.01008192f, 0.02823755f, -0.06295446f, -0.01606650f, 
    0.04107386f, -0.01848466f, -0.04870205f, -0.02246855f, -0.00726372f, -0.00882428f, -0.03327377f, -0.00347267f, 
    -0.05454796f, -0.00674132f, 0.05130819f, -0.02786208f, -0.05213301f, 0.01909834f, -0.04712853f, -0.04178911f, 
    0.02455262f, 0.00463579f, -0.04854306f, -0.06484558f, -0.03847627f, 0.01481228f, 0.04009550f, 0.04764095f, 
    -0.00674157f, -0.05077851f, 0.04922396f, 0.02237717f, 0.02397407f, -0.04854808f, -0.00486231f, -0.05193476f, 
    -0.04098715f, -0.04110826f, 0.05684788f, 0.03509780f, 0.01103065f, 0.01373427f, 0.04138990f, -0.01098821f, 
    -0.04042183f, -0.01532054f, 0.00051271f, -0.01327719f, -0.06305460f, -0.05940553f, -0.04403079f, -0.01758900f, 
    0.01319287f, -0.00950896f, -0.01092855f, -0.06274332f, -0.06389538f, -0.05565134f, -0.04990062f, 0.04063592f, 
    -0.05004571f, -0.04511364f, 0.03518046f, 0.04382962f, 0.02192470f, -0.01389339f, 0.01565888f, 0.01970592f, 
    -0.00864488f, -0.02102390f, -0.01519537f, -0.04541852f, -0.04554709f, -0.05041272f, 0.00604345f, -0.04474585f, 
    0.04589912f, 0.00984187f, -0.05571996f, -0.00714435f, -0.01794128f, -0.06314402f, -0.05116595f, -0.00324496f, 
    0.03822203f, 0.00376809f, -0.04611917f, 0.03477876f, -0.03319165f, -0.01458795f, -0.05592292f, -0.05513974f, 
    -0.04348588f, -0.03518519f, 0.02076039f, -0.03303031f, 0.04419898f, 0.03079847f, 0.01407659f, 0.02624388f, 
    -0.04704212f, -0.00244856f, -0.02806753f, -0.00091193f, 0.03496133f, 0.05290536f, -0.01898004f, -0.04623667f, 
    0.03027549f, -0.01846682f, 0.05047332f, 0.03186591f, 0.03157645f, 0.00639705f, -0.03978861f, 0.04654161f, 
    -0.02767141f, 0.00787803f, 0.01591266f, 0.02227045f, -0.02314587f, 0.02069064f, 0.04870499f, 0.03665815f, 
    0.01084763f, -0.05057725f, 0.02980544f, -0.02733961f, -0.04476320f, 0.00556544f, 0.00709475f, 0.05055895f, 
    0.01799885f, -0.06433416f, 0.04281026f, 0.03299460f, 0.02690656f, -0.04929073f, 0.02648995f, -0.05570705f, 
    0.00625923f, -0.01206250f, 0.00803078f, -0.05392073f, -0.00616538f, 0.02727869f, 0.00445991f, -0.04719786f, 
    -0.05237287f, 0.03329646f, -0.06462490f, -0.05359786f, 0.02718621f, -0.03680229f, -0.02116883f, 0.00475204f, 
    0.00446625f, 0.01118339f, -0.05262050f, 0.00043728f, -0.01105117f, 0.00407198f, -0.01326288f, -0.02358822f, 
    -0.05982827f, 0.01249877f, -0.00379047f, -0.00267349f, 0.00555283f, 0.05227947f, -0.02089397f, -0.05710278f, 
    -0.04670312f, 0.04902666f, -0.03081923f, 0.01825286f, -0.05795353f, -0.03138132f, 0.03142088f, -0.03456901f, 
    -0.03867766f, 0.00682494f, -0.01615326f, -0.03336890f, 0.02205271f, 0.04735956f, 0.00944827f, -0.04368415f, 
    0.02818973f, -0.02714035f, -0.03514998f, -0.04176391f, -0.01587887f, 0.00012663f, -0.02757478f, -0.04854946f, 
    -0.03987424f, -0.00452503f, 0.03088579f, -0.03624027f, -0.04292490f, -0.02561099f, 0.03139926f, 0.03302990f, 
    -0.01252409f, 0.00467434f, -0.02116056f, -0.02746747f, 0.00607708f, -0.05918402f, -0.01479620f, 0.02626679f, 
    -0.00272408f, -0.02832860f, -0.04914011f, 0.03361068f, 0.02943174f, -0.03372457f, 0.00296815f, -0.01982571f, 
    -0.03377376f, -0.04033542f, -0.03001035f, 0.00385820f, -0.04193016f, 0.04237969f, -0.01657273f, -0.05370851f, 
    -0.02540654f, -0.03735239f, 0.02724336f, -0.01279899f, -0.04423689f, -0.04591942f, -0.01413946f, -0.03146777f, 
    -0.07269442f, -0.09041409f, 0.04174950f, 0.25795400f, 0.11168546f, 0.04923192f, -0.14961386f, -0.30954832f, 
    -0.24724977f, -0.17934720f, -0.04113653f, -0.10079927f, 0.06893736f, 0.12849222f, -0.03594342f, 0.12844488f, 
    0.09881469f, 0.03027408f, 0.05146677f, -0.02682072f, 0.18245049f, -0.02373296f, -0.10622038f, -0.12559201f, 
    0.09755872f, 0.10051964f, -0.02651308f, -0.09052414f, -0.00877889f, -0.02708176f, -0.06423555f, -0.01205924f, 
    -0.04409771f, 0.08223033f, 0.10354511f, 0.04818269f, -0.06504216f, -0.05858214f, -0.25507051f, -0.06845208f, 
    0.07744789f, -0.15181801f, 0.12632969f, 0.08137538f, 0.11938631f, -0.06823897f, -0.09657043f, 0.03125589f, 
    -0.08433128f, 0.03063336f, -0.07783107f, 0.16774002f, 0.12086752f, 0.13941538f, -0.14674713f, 0.07731931f, 
    -0.27362359f, -0.00408649f, -0.00308191f, -0.06056523f, -0.21174555f, -0.26607716f, -0.08217672f, -0.00916892f, 
    -0.01183085f, -0.13729279f, 0.02647957f, 0.06260030f, -0.02968978f, -0.15741724f, -0.24288681f, -0.23004608f, 
    -0.11866552f, -0.16608618f, 0.12616260f, -0.06566611f, -0.13431311f, 0.11222285f, 0.16216677f, 0.18209048f, 
    -0.02933566f, 0.03229007f, -0.02464440f, -0.13492699f, 0.11645520f, -0.18643592f, -0.05344822f, 0.07001407f, 
    0.08394998f, 0.08452962f, 0.13945976f, 0.07871879f, -0.15583482f, 0.04181957f, 0.02454747f, -0.00938554f, 
    -0.03008730f, -0.07985564f, -0.20984888f, -0.13441920f, -0.04299728f, 0.17006432f, 0.01976404f, 0.00541238f, 
    -0.08479426f, 0.19591561f, 0.14954115f, 0.06602228f, 0.02490583f, -0.04305756f, -0.02804118f, 0.03183595f, 
    -0.01191156f, 0.14465351f, -0.05096253f, -0.06258560f, -0.02936634f, 0.07333660f, -0.05961847f, -0.04865943f, 
    0.07139194f, 0.03090276f, 0.14289255f, -0.11837342f, 0.02255450f, 0.17314878f, 0.03914767f, -0.01548046f, 
    0.22775623f, 0.00391850f, 0.13072753f, 0.02466010f, -0.14330857f, 0.00345590f, 0.10379086f, 0.06331176f, 
    -0.00216549f, 0.12306538f, -0.02439017f, -0.11152100f, 0.03333830f, -0.07296015f, -0.07711592f, -0.01969093f, 
    -0.06773657f, -0.21928279f, 0.01711728f, 0.01182356f, -0.13553734f, 0.09119534f, -0.00782300f, -0.01332644f, 
    0.08247514f, 0.05049885f, 0.12786105f, 0.05564177f, -0.00560137f, -0.00924582f, 0.10785831f, -0.01363435f, 
    0.00124727f, 0.04118721f, -0.02706135f, -0.15328570f, -0.10846484f, 0.08772577f, 0.07926097f, 0.16754080f, 
    0.11337299f, 0.09126427f, -0.06181449f, 0.04765167f, 0.14027888f, 0.00042165f, -0.06029068f, -0.08713380f, 
    -0.01660178f, 0.12570083f, 0.03052064f, 0.09715902f, -0.09197715f, 0.05137954f, 0.01690519f, 0.05542290f, 
    -0.10529148f, 0.13266273f, 0.05154536f, -0.14553867f, 0.12042185f, 0.21790403f, -0.14143924f, 0.05139590f, 
    0.03774181f, -0.03786831f, 0.09051704f, -0.09377110f, -0.03306848f, -0.02449132f, 0.05357563f, 0.00135323f, 
    -0.13830318f, 0.00206154f, 0.05737447f, -0.09784707f, -0.02570706f, 0.08299496f, 0.16787589f, 0.15257876f, 
    0.17422254f, 0.09756423f, -0.03890729f, 0.07983514f, 0.03726505f, 0.03418756f, 0.15828724f, 0.11641086f, 
    0.06661653f, -0.02190614f, 0.11166981f, 0.03720493f, -0.12524010f, -0.05899729f, -0.20617126f, -0.03450661f, 
    0.28511390f, 0.15736870f, 0.11850076f, 0.05302168f, -0.01913750f, 0.01183479f, -0.03017381f, -0.09204540f, 
    0.12762375f, 0.19415198f, 0.15714557f, 0.12544391f, 0.01014777f, 0.01784259f, -0.08202874f, 0.00869728f, 
    -0.05794717f, 0.00403615f, -0.03651904f, 0.07788196f, 0.09874857f, 0.03123659f, 0.06776585f, -0.01016345f, 
    -0.08149194f, -0.08777454f, -0.07124884f, -0.12424855f, -0.06101715f, -0.01560222f, 0.10342589f, 0.13916366f, 
    -0.03552232f, -0.09628656f, -0.17509726f, -0.11786718f, 0.06099401f, -0.01572557f, -0.14133798f, 0.12284777f, 
    0.02013031f, -0.03097490f, 0.08050802f, -0.15913707f, -0.15512691f, -0.12347110f, 0.31405303f, 0.10861155f, 
    0.06740499f, 0.03569609f, 0.06671737f, 0.08227929f, 0.13324051f, -0.04958907f, -0.00009604f, 0.18792257f, 
    0.32494298f, 0.09688310f, 0.15819545f, -0.00237702f, 0.04945632f, 0.05758874f, 0.09111730f, 0.00319204f, 
    0.41014308f, -0.16011620f, 0.02123699f, -0.07361649f, -0.13041365f, -0.28857017f, 0.06729118f, 0.02958343f, 
    0.03291400f, 0.29452035f, 0.08079966f, -0.21505062f, -0.02001399f, -0.11049017f, 0.13567972f, 0.10988545f, 
    0.18976597f, -0.09975175f, 0.27723941f, 0.24551941f, 0.01543574f, 0.02101058f, -0.06150528f, 0.18888265f, 
    -0.01857234f, 0.01441145f, 0.01437854f, 0.08879540f, 0.20425864f, 0.20543009f, -0.07939056f, 0.00540257f, 
    0.00491766f, 0.06344363f, 0.17682840f, 0.06698523f, 0.18465790f, 0.03118382f, -0.11146554f, -0.06423620f, 
    -0.03684029f, 0.04226004f, -0.03084882f, 0.11808334f, -0.15623201f, 0.00610375f, 0.16477904f, 0.20623916f, 
    -0.04068489f, 0.07934688f, -0.00235960f, 0.02093602f, 0.13807175f, -0.01306567f, 0.17857175f, -0.01840424f, 
    0.18331558f, 0.04738120f, 0.05854940f, 0.18686327f, 0.05500918f, 0.03761185f, 0.09499455f, 0.12259136f, 
    -0.08808400f, 0.05308251f, -0.04090504f, 0.06426746f, 0.16039304f, 0.05608249f, 0.00770215f, -0.01964071f, 
    0.06415303f, -0.45622081f, -0.38677111f, -0.00634844f, -0.13111201f, -0.06122012f, 0.06440173f, 0.15481599f, 
    -0.14478146f, 0.10602988f, 0.31781501f, 0.10264375f, 0.06087892f, -0.00914472f, -0.20175827f, 0.02406206f, 
    0.07901350f, 0.01066716f, 0.11224062f, 0.13062619f, 0.22959422f, -0.05054084f, 0.07306565f, 0.18049243f, 
    -0.00680658f, -0.01732383f, -0.03144583f, 0.06723460f, 0.06312142f, -0.11266855f, 0.03507161f, -0.09994134f, 
    0.15990038f, -0.04170235f, 0.04190112f, -0.14097898f, -0.15274812f, -0.07018319f, -0.14034013f, -0.01038026f, 
    -0.15583639f, -0.02415642f, -0.00783710f, 0.02172975f, -0.08121673f, 0.43788636f, -0.06106377f, -0.15126699f, 
    -0.05221913f, -0.14290686f, -0.10652754f, -0.09286343f, -0.07773121f, -0.09752581f, 0.28814226f, 0.02866454f, 
    -0.07173552f, -0.01602547f, -0.03017932f, 0.03938917f, 0.09037991f, -0.00135680f, -0.06886514f, -0.19961515f, 
    -0.12992731f, 0.10903536f, -0.01134664f, -0.00921900f, -0.06983059f, -0.06543379f, 0.00196855f, -0.04343179f, 
    0.10155136f, -0.08815639f, -0.09633172f, -0.05445468f, -0.02760859f, -0.19047947f, -0.11024722f, 0.03351881f, 
    -0.08570165f, -0.10059354f, -0.03592682f, -0.05933021f, -0.02881110f, -0.05582686f, -0.03746643f, 0.16406354f, 
    -0.00368324f, 0.00164836f, -0.25869918f, 0.01761388f, -0.09673015f, -0.05563457f, -0.23714314f, -0.02321975f, 
    0.05037092f, 0.01543005f, -0.02448498f, 0.01135795f, -0.31768116f, -0.16955787f, -0.10967314f, -0.04205029f, 
    -0.00627379f, 0.04594052f, 0.11832664f, -0.07371641f, 0.16745125f, -0.10437892f, -0.10584859f, -0.04587539f, 
    -0.22956923f, 0.04138928f, 0.08017939f, 0.02213915f, 0.16234690f, 0.37012219f, 0.00993678f, -0.19516255f, 
    0.05888067f, -0.00704180f, -0.01516758f, -0.04162569f, -0.13611463f, 0.03095636f, 0.11544313f, 0.16070323f, 
    0.16275477f, -0.08398376f, 0.05528202f, -0.14360841f, 0.01235789f, 0.04237232f, 0.05599723f, -0.18969797f, 
    -0.16692054f, -0.10679521f, -0.16449875f, 0.06319135f, -0.08443944f, -0.16637656f, 0.08454481f, -0.07653859f, 
    -0.33282492f, -0.28735909f, -0.02259095f, -0.13103165f, 0.04978245f, 0.09506522f, -0.04747936f, -0.09606690f, 
    0.10417998f, -0.18732882f, -0.39200762f, -0.03144175f, -0.31782949f, -0.01720372f, -0.39662895f, -0.08796595f, 
    0.02249552f, 0.14326110f, 0.01580267f, 0.17328547f, 0.18124367f, -0.02410661f, 0.08937588f, -0.11619381f, 
    -0.07817960f, -0.04804932f, -0.03575323f, 0.25947911f, 0.07995833f, 0.06424012f, -0.01611535f, 0.00605333f, 
    0.09177242f, 0.00975088f, -0.05584287f, 0.06260168f, 0.11994158f, 0.07228008f, -0.21927020f, -0.30994359f, 
    0.03099280f, -0.09900138f, 0.01070464f, 0.03451886f, 0.16879897f, -0.44906592f, -0.17843069f, -0.32189611f, 
    -0.14177243f, -0.08482347f, -0.17519657f, 0.06628363f, -0.02462185f, -0.20626701f, 0.17881279f, 0.08989374f, 
    0.00360650f, -0.06060537f, -0.09279869f, 0.19466272f, 0.04620511f, -0.14401759f, 0.04178414f, -0.60959840f, 
    -0.48561877f, 0.29660290f, -0.20313342f, -0.04607435f, 0.19249858f, 0.00880425f, -0.04439781f, 0.20072834f, 
    -0.11040566f, -0.14160003f, -0.07386266f, -0.03341029f, 0.05164114f, 0.07165565f, -0.01450427f, 0.11581144f, 
    0.20016460f, -0.05559270f, -0.04256158f, 0.26213142f, -0.09456721f, 0.09413503f, 0.03642479f, -0.04737973f, 
    -0.05526211f, 0.01859162f, 0.01288007f, -0.11516780f, 0.22954813f, 0.25212714f, -0.02522335f, -0.08118574f, 
    0.18842268f, 0.03668732f, 0.02644321f, 0.10170239f, 0.01110247f, 0.09919886f, 0.15602928f, -0.09644020f, 
    0.21689662f, -0.10310569f, -0.25259838f, -0.29173470f, -0.15968508f, 0.12398071f, 0.22742271f, -0.02097948f, 
    -0.06082559f, 0.09228685f, -0.11587611f, 0.23493573f, 0.10997795f, 0.04939901f, 0.01023006f, 0.03536355f, 
    0.10070036f, 0.11280681f, -0.00058810f, 0.00172804f, -0.02319596f, 0.01842636f, -0.00583775f, -0.20963740f, 
    -0.08143566f, 0.01602215f, 0.06317943f, 0.05644649f, -0.02581036f, 0.08251575f, 0.18769334f, 0.00494165f, 
    -0.08303539f, 0.06589313f, 0.04188977f, -0.01662785f, -0.11068276f, -0.03986049f, 0.11954391f, 0.26423156f, 
    0.09287772f, 0.21974815f, -0.06193752f, -0.04451867f, 0.16583444f, -0.14555979f, -0.20816906f, -0.13912249f, 
    -0.21368723f, 0.19470912f, 0.14238457f, 0.40331483f, 0.05315661f, 0.12930793f, -0.05934566f, 0.11160865f, 
    -0.13668697f, -0.22473785f, -0.02997558f, -0.18260098f, 0.00067259f, 0.03583403f, -0.01117667f, -0.14477144f, 
    0.16188778f, 0.06789916f, 0.07151473f, 0.06706473f, -0.10203418f, 0.34221628f, 0.03139529f, 0.11069097f, 
    -0.07323675f, -0.02799378f, 0.11960195f, -0.16184911f, 0.01152613f, 0.17154074f, -0.09114733f, -0.07926741f, 
    0.07332378f, 0.05387881f, 0.01214544f, 0.19053710f, -0.09623097f, -0.47626436f, -0.06207081f, -0.12881230f, 
    0.00110101f, -0.09554303f, -0.01290974f, 0.09384832f, 0.16126753f, -0.01848131f, -0.15939267f, -0.07234820f, 
    -0.14015073f, -0.10919271f, -0.03646402f, -0.01639707f, -0.02762948f, -0.04038692f, 0.11708865f, -0.02998434f, 
    -0.11960632f, -0.17071794f, -0.04145824f, -0.00085368f, 0.03673081f, 0.05712746f, 0.10914367f, -0.12154578f, 
    0.06761610f, 0.14659150f, 0.17923236f, 0.01665608f, -0.09581324f, 0.04137459f, -0.12686503f, -0.03733452f, 
    -0.04173237f, 0.04568585f, 0.32500765f, 0.20581584f, -0.01133778f, 0.06085035f, 0.12823711f, -0.02296175f, 
    -0.04500356f, -0.01494894f, 0.11233217f, 0.33841339f, 0.12409428f, -0.01206504f, 0.17847781f, 0.09286271f, 
    0.13406804f, 0.09262996f, -0.20702015f, -0.03308607f, -0.05574830f, 0.02275966f, -0.12504429f, 0.08668923f, 
    -0.12358563f, -0.03536511f, -0.27894789f, 0.03205879f, -0.02163954f, 0.06150631f, 0.47823519f, -0.04859505f, 
    0.01515622f, -0.11338734f, 0.07553842f, -0.22691292f, -0.01525343f, 0.25468358f, 0.14839691f, 0.26945680f, 
    0.03223651f, -0.08499376f, -0.02526297f, -0.01258144f, -0.08968896f, -0.06085336f, 0.15437411f, 0.11569650f, 
    0.12106642f, 0.09304832f, 0.03965554f, 0.04946610f, -0.04182809f, -0.06154875f, 0.12400075f, -0.12722266f, 
    0.06634067f, 0.04837447f, -0.04309927f, -0.20454329f, 0.07938399f, -0.02942820f, 0.05321725f, -0.04343068f, 
    -0.12210013f, -0.00265445f, -0.13005158f, -0.00612692f, -0.11563760f, -0.08213782f, -0.06972500f, -0.09161364f, 
    -0.07670824f, -0.15178366f, 0.03634750f, -0.02959440f, -0.07942902f, -0.13048454f, 0.10913227f, 0.14468682f, 
    -0.05184220f, 0.16703831f, 0.22254404f, -0.11768859f, 0.09638590f, 0.15314898f, -0.04401427f, 0.03793782f, 
    -0.02750142f, -0.09621623f, 0.11218456f, 0.06680494f, -0.01721362f, 0.08015334f, 0.01081836f, -0.00836381f, 
    -0.14782394f, 0.03796165f, -0.05499549f, 0.09506389f, -0.02465631f, -0.08536413f, -0.14212744f, -0.01831863f, 
    -0.00074591f, -0.09672548f, 0.09244065f, -0.00735297f, 0.16562337f, 0.27455309f, 0.26869839f, 0.01556415f, 
    -0.00866250f, -0.14578782f, -0.05990773f, 0.03340982f, 0.16380887f, -0.01612104f, -0.03843760f, 0.09439328f, 
    0.13748924f, 0.17456186f, 0.12234811f, -0.15537173f, 0.06681729f, 0.06993547f, -0.04985397f, -0.21203607f, 
    0.01434634f, -0.28372300f, 0.01822424f, -0.20007960f, 0.17463814f, -0.01614242f, 0.08044310f, -0.17024577f, 
    0.04318194f, -0.03745262f, 0.04127998f, 0.02619850f, -0.04988246f, -0.04844902f, 0.05013023f, 0.01181428f, 
    0.00228125f, 0.01554860f, -0.02640310f, 0.00677726f, 0.02796299f, 0.03525833f, -0.02429143f, -0.06682456f, 
    -0.00245916f, 0.00430302f, -0.03716923f, -0.02639801f, -0.05516847f, 0.02107121f, -0.03627545f, -0.00047178f, 
    -0.02786242f, -0.01477567f, -0.04721526f, 0.01132780f, -0.03187887f, -0.05628664f, -0.00661898f, -0.01429032f, 
    0.02698593f, -0.01643989f, -0.00569685f, 0.05015745f, -0.01457287f, 0.04009163f, -0.00462435f, -0.05211162f, 
    -0.03986286f, 0.02170863f, 0.03373175f, 0.03328254f, 0.01262548f, 0.01132167f, 0.01002155f, -0.02174016f, 
    0.02208574f, 0.04341267f, 0.00905553f, -0.02331748f, 0.02548519f, -0.01470013f, -0.01753453f, -0.01855983f, 
    0.00189402f, -0.03153162f, 0.02433466f, -0.01125165f, 0.04658575f, 0.01736401f, 0.03791723f, 0.01908396f, 
    -0.04520997f, -0.05840863f, -0.03469667f, -0.02859166f, -0.02763490f, -0.02916012f, -0.00871182f, -0.03015697f, 
    -0.03098964f, -0.04806021f, -0.06026471f, 0.01654789f, -0.06129682f, 0.01077339f, -0.06592561f, 0.00076058f, 
    0.01091796f, 0.02339370f, -0.01811706f, -0.01788346f, -0.05135218f, -0.04820567f, -0.01326341f, -0.05020893f, 
    0.03158282f, -0.06491585f, -0.00610645f, 0.00120789f, -0.01885117f, -0.06440279f, 0.01469039f, -0.01932427f, 
    0.03106989f, 0.04884458f, 0.02460546f, -0.00410588f, -0.00450763f, -0.01909455f, 0.03014448f, 0.04845496f, 
    0.02673482f, 0.00361707f, 0.02082280f, 0.02405542f, -0.02822209f, -0.05642358f, 0.02914632f, -0.06522359f, 
    0.00113705f, -0.05610139f, -0.04934442f, -0.05185944f, -0.05497201f, -0.04901724f, 0.02320084f, -0.02743065f, 
    -0.02182733f, 0.02392783f, 0.04283011f, -0.01172632f, 0.04149447f, -0.00447225f, 0.00369158f, -0.05505137f, 
    -0.04228203f, -0.05244392f, 0.04029521f, 0.01077777f, -0.01087959f, 0.01651766f, 0.03972544f, -0.01195101f, 
    -0.00680405f, 0.01782948f, -0.02557022f, 0.04351480f, 0.01351204f, -0.00872921f, -0.05483678f, 0.03441734f, 
    -0.01773515f, -0.03278988f, -0.04328293f, 0.02447394f, -0.02122795f, 0.00896680f, 0.03221627f, -0.01723831f, 
    0.03898423f, -0.05993563f, 0.01787835f, 0.00945200f, -0.06406181f, 0.04286574f, -0.01733263f, -0.00422265f, 
    -0.04924222f, -0.04890538f, -0.01908662f, -0.01698540f, -0.00751285f, -0.06559350f, 0.02627121f, 0.03475217f, 
    -0.05114651f, -0.05926478f, -0.06144634f, -0.05036240f, -0.03103718f, 0.00856072f, 0.02854310f, -0.03141864f, 
    0.04462654f, -0.04721135f, 0.02291039f, -0.00932864f, -0.00606693f, -0.03607348f, 0.01514551f, 0.02435000f, 
    -0.02533405f, 0.04023881f, -0.04439099f, -0.05388355f, 0.00029793f, -0.01667314f, -0.02281647f, -0.04168472f, 
    0.04582094f, -0.02684704f, 0.00775202f, -0.02318775f, 0.01044437f, 0.02635015f, -0.01496870f, -0.02541475f, 
    0.00124139f, -0.02328300f, 0.01635242f, -0.04384397f, -0.06417584f, -0.04075516f, -0.01919739f, -0.01918465f, 
    -0.00644069f, -0.01718239f, 0.00841195f, 0.02599655f, -0.03035706f, -0.00990172f, -0.04523879f, -0.01944557f, 
    0.00890549f, -0.02405879f, -0.06166906f, 0.00788216f, 0.03021856f, 0.03453260f, -0.04118234f, 0.02620736f, 
    -0.02458679f, 0.02636980f, -0.01373076f, -0.04938412f, -0.02074639f, -0.01322991f, -0.06549546f, -0.00796719f, 
    0.01977897f, -0.01214356f, -0.00073356f, -0.01765134f, -0.00347723f, -0.00675259f, 0.00578623f, 0.03932399f, 
    0.03646374f, -0.05261748f, 0.04957264f, 0.00350472f, 0.00598895f, -0.03410176f, -0.01164276f, -0.02927689f, 
    0.01415559f, -0.02103778f, -0.00008679f, -0.04706172f, -0.05664971f, 0.01932943f, -0.06310160f, -0.06076345f, 
    -0.05857279f, 0.04148329f, -0.01425590f, -0.02063945f, -0.00869102f, -0.00465186f, 0.00241259f, -0.00246378f, 
    -0.05279727f, 0.00071490f, -0.01265929f, -0.01411638f, -0.03704481f, -0.00131320f, 0.01650443f, -0.01724902f, 
    -0.06063177f, 0.00729565f, 0.02051681f, -0.02274779f, -0.01622800f, 0.01460428f, 0.03573392f, -0.02042284f, 
    -0.03049910f, -0.05253450f, -0.01388088f, 0.02227551f, -0.02705882f, -0.06229178f, -0.06369027f, -0.00327799f, 
    -0.02164530f, -0.02785983f, -0.19187440f, -0.16495427f, 0.01679023f, -0.06324381f, 0.21017948f, -0.05161506f, 
    -0.18108390f, 0.07061494f, 0.09683388f, -0.05097289f, -0.23543678f, -0.10980286f, -0.15624729f, 0.15117821f, 
    0.12146685f, 0.09924951f, -0.18101612f, -0.22551654f, -0.00424541f, -0.00776159f, -0.08276957f, -0.04521348f, 
    0.07620923f, -0.00504414f, 0.15362588f, -0.10308553f, 0.00725221f, -0.03438334f, -0.09213543f, -0.17463258f, 
    -0.05649967f, 0.13844608f, 0.10317852f, 0.09935807f, -0.00407437f, 0.20521523f, 0.01023508f, 0.12665388f, 
    -0.02643377f, 0.15013850f, -0.10610229f, 0.06071014f, 0.03760545f, 0.06626881f, 0.03165135f, 0.00518139f, 
    -0.09780468f, -0.15117295f, -0.00919581f, 0.01758419f, 0.11305182f, 0.12614439f, -0.06875279f, -0.05520139f, 
    -0.00837474f, -0.02686223f, -0.16719502f, 0.00788241f, -0.27114475f, -0.09710137f, -0.15133815f, 0.02866485f, 
    0.05044964f, 0.02050179f, 0.00141945f, 0.12302837f, 0.16121584f, -0.06430361f, -0.01193100f, -0.16293208f, 
    -0.11734647f, 0.08783995f, 0.01708695f, 0.10939230f, -0.03934908f, -0.07103486f, 0.30116823f, 0.07169040f, 
    0.23730230f, -0.12757467f, -0.21671274f, -0.01062846f, 0.06938972f, -0.04116919f, 0.06771430f, 0.18869410f, 
    0.02705894f, 0.08450884f, -0.11005153f, -0.23154981f, -0.00613547f, 0.05706668f, 0.01699448f, -0.00639003f, 
    0.05435552f, -0.18098664f, -0.00068572f, -0.09159204f, 0.04494114f, 0.15978678f, 0.02796802f, 0.11148817f, 
    -0.23210365f, -0.06362542f, 0.08009718f, 0.03769230f, -0.00627941f, 0.05660069f, 0.06395575f, -0.06969247f, 
    0.14219263f, -0.11290637f, 0.08642457f, -0.08018418f, 0.07361315f, -0.03576005f, -0.00716344f, -0.08434261f, 
    0.25857878f, 0.10171561f, -0.03396445f, -0.07310524f, -0.07559477f, 0.19903609f, 0.12636480f, 0.01357019f, 
    -0.00850178f, 0.08947326f, 0.16057809f, 0.15143925f, -0.03091169f, -0.06435554f, 0.23515293f, -0.06600813f, 
    -0.14054878f, 0.10040455f, -0.05232233f, 0.11112654f, 0.13959314f, 0.04644968f, -0.18590908f, -0.15811364f, 
    -0.12454215f, -0.15233770f, 0.03498036f, 0.19112325f, -0.01414120f, -0.06287446f, -0.00647736f, -0.04980559f, 
    -0.09879845f, -0.20486635f, 0.16262633f, 0.19199026f, 0.00448121f, -0.04170984f, 0.18938416f, 0.07298559f, 
    0.01961129f, 0.22944163f, 0.00261646f, 0.15215144f, 0.17882730f, 0.09694593f, -0.07625712f, 0.13298965f, 
    0.14497322f, -0.00548887f, 0.05653873f, -0.07174955f, -0.05764734f, -0.06722743f, 0.11422497f, 0.03500909f, 
    -0.05839061f, 0.00496548f, 0.09547111f, 0.10673774f, -0.10998304f, -0.00841925f, -0.07490409f, -0.09219863f, 
    0.07123163f, 0.14314090f, 0.12628162f, -0.24006279f, 0.09402277f, -0.32411069f, -0.04644441f, -0.08005759f, 
    0.13528007f, 0.03293382f, -0.02332115f, 0.03425562f, -0.07020346f, -0.15140510f, -0.11794116f, 0.01902467f, 
    -0.03702766f, 0.02493095f, 0.02725004f, 0.11488321f, -0.07050663f, 0.10509931f, -0.02821505f, 0.12657502f, 
    0.00676786f, 0.11114309f, 0.13785417f, 0.17556557f, -0.03308148f, 0.06423608f, 0.11767209f, 0.10610314f, 
    -0.10030081f, -0.05420574f, -0.04934802f, 0.22324528f, 0.12952855f, 0.15942670f, -0.06318695f, 0.08375521f, 
    0.05232075f, -0.02336187f, -0.00590474f, -0.04686145f, -0.06441528f, 0.03679797f, -0.02368077f, -0.00316849f, 
    0.07631958f, -0.10485330f, -0.21983382f, -0.23023228f, -0.00241011f, 0.14895621f, 0.02331588f, 0.16211435f, 
    -0.03514898f, 0.03068683f, -0.03900494f, -0.10454921f, 0.00850069f, 0.03179152f, 0.13579978f, -0.01092459f, 
    -0.00139593f, 0.03495780f, -0.04463056f, -0.11301569f, -0.10588559f, -0.13905923f, -0.08714880f, 0.21497786f, 
    0.09399259f, 0.16047402f, 0.17025538f, 0.13591570f, -0.02872166f, 0.02667054f, -0.16287562f, 0.11045598f, 
    0.03231476f, -0.03354343f, -0.07575774f, -0.00517411f, -0.20364256f, -0.20726646f, -0.12163294f, -0.19095400f, 
    -0.01440092f, 0.13933866f, 0.13056535f, 0.32521811f, 0.00029132f, -0.08405836f, -0.22707570f, 0.01070678f, 
    0.00872319f, 0.02106793f, 0.09792079f, -0.01850679f, 0.05571515f, -0.18663317f, -0.03002435f, -0.16877839f, 
    -0.07757824f, 0.12371554f, 0.06149313f, -0.25171581f, -0.09527022f, 0.02535018f, 0.01083899f, -0.03719152f, 
    -0.05510645f, -0.09308994f, 0.18201034f, -0.15632683f, -0.03433274f, -0.02212294f, 0.07762542f, -0.00113891f, 
    -0.10784876f, -0.10887001f, 0.01582275f, -0.17331448f, 0.28327939f, 0.01230272f, -0.03379801f, -0.10618135f, 
    0.02112729f, -0.00942818f, 0.08296769f, -0.36632767f, -0.26183847f, -0.07920943f, -0.22055915f, -0.05721695f, 
    -0.07761792f, 0.06828370f, 0.06133898f, 0.04428041f, -0.15800001f, 0.00614029f, 0.53993022f, -0.03791875f, 
    0.20785607f, 0.04116803f, 0.14120486f, 0.04412686f, -0.06855519f, 0.00587989f, 0.00848675f, -0.05373918f, 
    -0.05093338f, 0.07422026f, -0.00360197f, -0.01309772f, -0.02534685f, -0.01363163f, -0.16850498f, -0.20738314f, 
    0.09927990f, 0.07473654f, 0.15816322f, -0.00803016f, -0.02228511f, -0.01131107f, 0.00035443f, -0.18070741f, 
    0.04315083f, 0.23566629f, 0.06129154f, 0.11293110f, 0.02055782f, -0.01159231f, 0.11313707f, 0.13951084f, 
    0.15611835f, -0.09611369f, -0.00643210f, -0.07245115f, -0.01857912f, -0.10198280f, 0.04121110f, 0.10347550f, 
    -0.05101435f, -0.17453921f, -0.15755841f, 0.00978698f, -0.22830094f, 0.05022420f, -0.11112159f, -0.00839126f, 
    0.04045803f, -0.13000323f, -0.16015698f, -0.04779136f, 0.03951561f, -0.00090943f, 0.09111053f, -0.01822573f, 
    0.05655984f, -0.05539910f, 0.19063182f, 0.00945843f, -0.20193803f, 0.16694218f, 0.01770519f, -0.14630543f, 
    -0.09091885f, 0.00356153f, 0.14287803f, -0.03365161f, 0.40595436f, -0.19095412f, 0.20087080f, -0.11364924f, 
    0.04322567f, -0.00927763f, 0.19767547f, 0.02103889f, -0.01626884f, 0.17427561f, 0.07377255f, 0.01921940f, 
    0.00612456f, 0.05477031f, 0.03011283f, 0.08879189f, 0.06677444f, 0.11589953f, -0.00936604f, 0.13930498f, 
    -0.03496434f, -0.02477416f, -0.10394910f, 0.18934864f, 0.03070950f, 0.07709531f, 0.14427695f, 0.14331412f, 
    -0.00984186f, -0.03559688f, 0.03187243f, -0.05255059f, -0.04727834f, -0.02281283f, 0.04590631f, 0.06835834f, 
    0.00006609f, -0.40626246f, 0.02241927f, -0.00181273f, 0.00468574f, -0.22015388f, 0.04705473f, -0.01197568f, 
    0.13546294f, 0.26883513f, -0.12315587f, 0.21435930f, 0.05345749f, 0.09665298f, 0.09728032f, -0.00002794f, 
    0.08761851f, 0.04438675f, 0.35923344f, -0.11198592f, -0.08315056f, 0.01976100f, -0.00648334f, 0.05091516f, 
    0.05487658f, 0.01043238f, -0.05359544f, -0.01658673f, 0.02832254f, -0.17051911f, 0.03791658f, 0.11887826f, 
    -0.13919829f, -0.03402190f, 0.00731821f, 0.17375569f, -0.10022366f, 0.55884337f, 0.14437988f, 0.01577635f, 
    -0.06556183f, -0.23561808f, -0.06419551f, -0.19156769f, -0.07044040f, -0.02873345f, 0.00289171f, 0.13942720f, 
    -0.18863733f, -0.08577600f, -0.06415751f, 0.05256339f, -0.04334251f, 0.10027023f, -0.10552690f, -0.09133369f, 
    0.11220880f, -0.06783875f, 0.08396389f, -0.04399631f, -0.02814797f, -0.05131890f, 0.10364153f, 0.23256215f, 
    -0.43131536f, -0.16138655f, -0.13435398f, -0.16313322f, -0.09406478f, -0.08931720f, 0.14964168f, 0.00866715f, 
    0.09224883f, 0.14731623f, -0.04400184f, -0.10494688f, -0.17357901f, -0.06364616f, 0.01097699f, 0.14206249f, 
    0.13061421f, 0.01759980f, 0.01927602f, 0.03087118f, 0.16738082f, -0.24384438f, -0.12699038f, -0.18440238f, 
    -0.15878412f, -0.07854268f, -0.01635135f, -0.02281589f, 0.10490103f, -0.11214691f, -0.03917688f, -0.07546487f, 
    -0.02155925f, -0.07230352f, 0.01821250f, -0.19297743f, 0.03103380f, 0.09512141f, -0.04627980f, 0.02906072f, 
    -0.03137122f, 0.07073662f, 0.00032537f, -0.05918200f, 0.04664557f, 0.12589560f, -0.09189554f, -0.26841497f, 
    -0.17201062f, 0.07128512f, 0.07681187f, 0.01608512f, 0.02031505f, 0.17864151f, -0.14185534f, 0.00331362f, 
    -0.02050146f, -0.09283563f, -0.00355175f, -0.09740345f, -0.15139744f, -0.07853244f, 0.24461086f, -0.43388358f, 
    -0.11278680f, -0.20829155f, 0.05280929f, 0.12505272f, -0.01903760f, -0.05493688f, -0.09012124f, 0.36536092f, 
    -0.15902025f, -0.17992088f, 0.09783810f, -0.03328878f, 0.02810530f, -0.24594471f, -0.14028306f, -0.01205278f, 
    -0.28098178f, -0.10920165f, -0.19178580f, 0.05966002f, 0.13746029f, 0.06121293f, -0.03219542f, -0.23891002f, 
    -0.17243779f, -0.00808861f, -0.13564517f, -0.17976609f, -0.04293371f, 0.08192348f, 0.04224736f, 0.07308588f, 
    -0.02163083f, -0.00912190f, 0.07350416f, -0.09659245f, 0.14043353f, 0.02091934f, -0.09575879f, 0.02020295f, 
    0.03825592f, 0.02930325f, 0.13375057f, 0.20615670f, 0.08852497f, 0.14109442f, 0.12934816f, -0.03935555f, 
    -0.00024411f, -0.05303128f, -0.07428136f, -0.06362942f, 0.07376453f, 0.04230426f, 0.04328935f, 0.03046831f, 
    -0.08488837f, 0.02033979f, 0.07068959f, 0.05631683f, -0.01434323f, 0.08503731f, 0.03113877f, 0.16067874f, 
    0.07788369f, -0.05698851f, 0.06349234f, 0.03298820f, 0.05460943f, -0.01112116f, -0.20420407f, -0.11863390f, 
    -0.20403180f, 0.04718139f, -0.02420565f, 0.13746604f, -0.14404838f, -0.06684574f, -0.23822545f, -0.20683376f, 
    -0.06038902f, -0.28096515f, 0.05518719f, 0.09376737f, 0.01239168f, -0.06874599f, -0.05674847f, -0.13406913f, 
    0.17219505f, -0.06406852f, -0.17053410f, -0.00619800f, 0.00677510f, -0.01216867f, -0.02980659f, 0.18995379f, 
    -0.02210662f, 0.34995517f, 0.12630615f, 0.25268522f, 0.01557916f, 0.01391733f, -0.00333746f, 0.05121660f, 
    0.06725799f, -0.06374919f, -0.16586852f, -0.05346841f, 0.05073293f, 0.08703813f, 0.02204075f, 0.10660882f, 
    0.18625833f, -0.11744003f, -0.17765343f, 0.08004298f, 0.09867594f, 0.25229535f, -0.24405095f, -0.13905832f, 
    0.08339552f, 0.09516261f, 0.16011831f, 0.22765818f, 0.50381798f, 0.05912444f, 0.03389272f, -0.09489162f, 
    0.09186708f, 0.02981433f, 0.08327507f, 0.13275173f, -0.05429330f, 0.14117706f, -0.23449056f, -0.43561321f, 
    0.15047513f, 0.11922839f, -0.21571583f, 0.19976206f, 0.09705826f, -0.06960190f, -0.18526115f, -0.06779181f, 
    -0.19380742f, -0.03989663f, 0.18003741f, -0.09230152f, 0.11396872f, -0.01742418f, 0.19396845f, -0.16084673f, 
    -0.05966304f, -0.02653016f, -0.05987806f, -0.04052007f, 0.00200793f, -0.15173531f, -0.10239698f, -0.02448587f, 
    -0.11487056f, -0.58591485f, -0.06929918f, 0.05116774f, 0.04328706f, 0.06006305f, -0.05036235f, -0.09953179f, 
    -0.24885608f, 0.03856202f, 0.31510946f, 0.06992974f, -0.01378401f, 0.07461163f, 0.12843113f, -0.02126324f, 
    0.13413826f, 0.12255760f, 0.14774705f, 0.16662548f, 0.03931529f, 0.05750817f, 0.16261977f, 0.09682468f, 
    0.00161609f, 0.13288835f, 0.06918893f, -0.08316035f, -0.24297214f, -0.23178956f, 0.24329977f, 0.06326717f, 
    0.00151453f, -0.05589889f, 0.02513215f, 0.07617676f, 0.29155779f, 0.21646579f, -0.11410300f, 0.06442879f, 
    0.09148642f, -0.00288247f, 0.15360616f, -0.35965201f, -0.23594339f, 0.00607218f, 0.08447813f, 0.11535254f, 
    0.03516597f, -0.04913344f, 0.06717219f, -0.07021804f, -0.00956699f, -0.40339643f, -0.00076714f, 0.16609922f, 
    0.16681373f, 0.06659613f, -0.03256877f, 0.09548481f, -0.03539433f, 0.11952020f, -0.04731245f, 0.07069472f, 
    -0.00486090f, -0.10793211f, 0.03656634f, 0.06241438f, -0.07481670f, -0.06287623f, 0.13871343f, 0.13499539f, 
    -0.03785663f, 0.05351610f, -0.04297790f, 0.20605606f, -0.13121955f, -0.18202770f, 0.00612140f, -0.13493833f, 
    -0.06611473f, 0.17933984f, 0.06173369f, -0.11072239f, 0.01196159f, 0.17352800f, -0.09388618f, 0.00996691f, 
    -0.00462081f, 0.03320690f, -0.01133948f, 0.12469958f, 0.26219139f, 0.02538031f, 0.11549231f, 0.11907661f, 
    0.15352611f, -0.01782095f, -0.03390000f, -0.22323489f, -0.01363808f, -0.02090624f, 0.02409911f, -0.07119542f, 
    0.09806123f, 0.14662562f, -0.02045129f, -0.17715277f, 0.02128197f, -0.13679783f, -0.13526638f, -0.08204149f, 
    -0.05777109f, -0.02874141f, -0.00976458f, -0.05742239f, 0.00092236f, -0.35607946f, -0.40394032f, 0.14858489f, 
    0.01901019f, -0.02209837f, 0.02267672f, -0.05051928f, -0.06841235f, -0.41849294f, 0.10064415f, 0.02851887f, 
    0.16575100f, 0.17189002f, 0.10449401f, -0.00030067f, -0.03781278f, 0.08808583f, -0.06854402f, 0.11693094f, 
    -0.10504552f, -0.17835842f, 0.00978841f, -0.09986122f, -0.07967373f, -0.07598712f, 0.01853653f, 0.02742024f, 
    -0.04593851f, -0.04950280f, -0.01384468f, -0.23243931f, -0.12613967f, 0.13261966f, 0.06313822f, 0.04936394f, 
    0.08935229f, 0.28448391f, 0.45401564f, -0.37791353f, 0.07332414f, -0.04460328f, -0.06628890f, -0.02476020f, 
    0.00418013f, -0.03591527f, -0.30136180f, -0.22954336f, 0.50187147f, 0.06780551f, -0.07021017f, -0.04481114f, 
    0.05691248f, 0.04202291f, 0.01826095f, 0.00657072f, -0.57943642f, -0.38786986f, -0.09335253f, -0.08563875f, 
    -0.04788135f, 0.05730827f, 0.00900351f, 0.03108636f, -0.24136643f, 0.27914730f, 0.45575219f, -0.07772381f, 
    0.02314733f, 0.11886276f, 0.06217648f, 0.01583447f, 0.06570821f, -0.03519233f, 0.04410510f, 0.12589413f, 
    -0.03568176f, 0.09391349f, -0.03801946f, 0.01389075f, 0.01813794f, 0.02595595f, 0.14977148f, -0.07829969f, 
    0.25883311f, -0.01890152f, -0.06763905f, 0.01884895f, 0.09614448f, 0.09140839f, 0.05832300f, 0.03021078f, 
    0.00079754f, 0.26805961f, 0.09306514f, -0.02979202f, 0.11986805f, 0.12653799f, 0.18064488f, 0.09577911f, 
    0.03988180f, -0.81615156f, -0.29007456f, 0.22132216f, -0.15942049f, -0.14100714f, -0.00303576f, -0.08113502f, 
    -0.11212178f, -0.45179662f, -0.07456853f, -0.56296974f, -0.21263942f, -0.08583442f, -0.11959364f, -0.03124415f, 
    -0.01305905f, 0.04965375f, 0.12120117f, -0.08786352f, 0.27318609f, 0.07210694f, -0.00803561f, 0.01323272f, 
    -0.12240794f, -0.01654211f, -0.00163902f, -0.31059495f, -0.32337844f, 0.06066317f, 0.05894231f, 0.01179914f, 
    0.10912512f, -0.03356173f, -0.03429414f, -0.10723831f, 0.06233453f, -0.29186174f, -0.08353788f, 0.05231368f, 
    -0.08633407f, 0.10083354f, 0.10430458f, -0.04996159f, 0.24158914f, 0.28647608f, 0.31186828f, -0.24311545f, 
    -0.08477834f, -0.01106746f, 0.05194485f, 0.04017789f, -0.00069604f, 0.06186744f, 0.11003432f, 0.00997728f, 
    0.10239583f, 0.00824817f, 0.12277155f, 0.08144994f, -0.03994820f, 0.08253812f, 0.11091927f, 0.00796167f, 
    0.11354922f, 0.03083685f, 0.07324272f, 0.12793417f, -0.01705392f, 0.13184716f, -0.03687556f, 0.24473095f, 
    -0.21286742f, -0.27257788f, -0.02917816f, 0.07651541f, 0.03524247f, -0.08633223f, 0.16260396f, 0.09216159f, 
    0.03830291f, -0.12408914f, -0.35924423f, -0.11580338f, 0.10657088f, 0.04833758f, 0.14222468f, 0.07950374f, 
    0.07298584f, 0.05994127f, -0.21721825f, -0.26640809f, -0.48378840f, 0.03466432f, 0.03008622f, -0.05573229f, 
    0.15514128f, -0.11485536f, 0.09569892f, 0.09848671f, -0.13498674f, -0.12386423f, 0.07209705f, 0.01259000f, 
    -0.03128771f, 0.03213718f, -0.07695322f, -0.15907663f, 0.23636068f, -0.10937162f, -0.45647889f, -0.17686889f, 
    -0.07854525f, -0.05752842f, 0.00461400f, -0.01809181f, 0.02350068f, 0.18596584f, -0.32427770f, -0.25356334f, 
    -0.04605259f, 0.04628924f, -0.11864740f, 0.10838799f, 0.05137007f, -0.07344260f, -0.12536182f, -0.18274032f, 
    0.04425855f, -0.05862693f, 0.06571431f, -0.08924591f, 0.11127493f, 0.14032686f, 0.04384448f, 0.19161275f, 
    -0.00159891f, -0.26998246f, 0.00223592f, 0.09773886f, 0.10590572f, 0.18684524f, 0.11039229f, 0.06437362f, 
    -0.06755014f, -0.04516088f, -0.06188744f, -0.06985957f, -0.22982506f, -0.06414881f, -0.01308819f, 0.01897570f, 
    0.06448369f, 0.10623033f, -0.21372676f, -0.14083390f, -0.03096525f, -0.04580116f, -0.02224983f, 0.00940185f, 
    -0.25592551f, 0.09337299f, -0.58007979f, -0.02448357f, -0.05813835f, -0.13838969f, -0.10590699f, -0.07345884f, 
    -0.08818345f, 0.01878611f, -0.02850407f, 0.24839938f, 0.05880554f, 0.22072540f, 0.07254721f, 0.02701493f, 
    0.03402979f, 0.03051329f, 0.10531097f, -0.00365941f, -0.02959348f, 0.01169380f, -0.07976797f, -0.10649717f, 
    -0.00328569f, -0.13428940f, 0.08485565f, -0.04082554f, 0.18619989f, -0.30314392f, 0.06549314f, -0.03122389f, 
    0.08821602f, 0.02576221f, -0.01887515f, 0.13721195f, 0.06725994f, 0.08224487f, -0.07887230f, -0.38952801f, 
    -0.96123636f, -0.23897578f, -0.04146288f, 0.03717279f, -0.09741665f, -0.11688638f, 0.02631922f, -0.19592503f, 
    -0.05658614f, -0.19951171f, -0.06959729f, 0.04238800f, -0.04192067f, 0.00259393f, 0.01532303f, 0.02135522f, 
    0.04075273f, 0.01650765f, -0.03463852f, -0.02670852f, -0.03133979f, 0.03784738f, 0.01025991f, -0.00529973f, 
    0.04009918f, -0.02539850f, -0.00459667f, -0.03851245f, 0.00639778f, 0.02862619f, -0.04628249f, -0.05566020f, 
    -0.00123810f, -0.03904236f, -0.00166952f, 0.03146208f, -0.00368256f, -0.03162387f, 0.04457223f, 0.05100002f, 
    0.01275957f, 0.00932501f, 0.01183446f, 0.05443232f, 0.00639952f, 0.00700946f, -0.05044928f, 0.04850934f, 
    -0.01463249f, 0.03322424f, -0.06269155f, -0.02789027f, 0.03011385f, 0.04889899f, 0.00575457f, -0.01830590f, 
    0.03753727f, -0.03714301f, -0.02328185f, -0.02494372f, -0.01853980f, 0.02777624f, 0.01232717f, -0.05334768f, 
    0.01667713f, -0.00789562f, 0.04927726f, -0.05801950f, 0.02137846f, -0.02270527f, -0.02804069f, 0.02800877f, 
    -0.05392974f, 0.00315689f, -0.01189579f, -0.04469827f, -0.00689873f, 0.05140047f, 0.02310956f, -0.04980721f, 
    0.03595520f, -0.06292067f, 0.05375470f, 0.03296781f, -0.02495561f, -0.03733065f, 0.02994251f, 0.02442111f, 
    -0.05037878f, 0.00181375f, -0.01078275f, -0.04568777f, 0.02403162f, 0.04138213f, -0.00626410f, 0.01487251f, 
    -0.01991268f, 0.01271549f, 0.00426152f, -0.00473863f, -0.04303433f, -0.04526060f, -0.03483393f, 0.03837802f, 
    0.01029004f, -0.00892438f, -0.04907241f, -0.06174411f, -0.03327652f, -0.02287134f, 0.03714291f, 0.02662563f, 
    -0.00859366f, 0.00438946f, 0.00377999f, 0.00861652f, 0.01918954f, 0.01461904f, -0.00038220f, -0.02438247f, 
    0.00319401f, 0.04223206f, 0.04673282f, -0.05422961f, 0.02019539f, -0.06182704f, 0.01817657f, 0.03134822f, 
    0.01621545f, -0.02564964f, -0.00333234f, -0.05629130f, -0.01757928f, 0.02431490f, 0.00110763f, -0.05995767f, 
    0.03462960f, 0.00826497f, -0.01804487f, 0.01294403f, 0.01380211f, 0.03939240f, 0.00737119f, -0.02733555f, 
    -0.00255820f, 0.02443892f, 0.05260871f, -0.04879463f, -0.01285641f, -0.05642217f, -0.04500342f, -0.03793780f, 
    -0.02737963f, -0.05584390f, -0.05477317f, -0.00107203f, -0.02254574f, -0.01664842f, -0.02431901f, -0.02345224f, 
    0.00451024f, -0.03423095f, 0.00174948f, 0.01215110f, -0.04870987f, -0.02125053f, -0.04220567f, -0.05496657f, 
    -0.05324828f, -0.03066343f, -0.00216266f, -0.03274954f, 0.03808517f, 0.00004163f, 0.00558422f, 0.04390796f, 
    -0.06271310f, -0.04272943f, 0.03031238f, -0.05066121f, -0.01542666f, -0.04203102f, -0.02832715f, -0.03450067f, 
    -0.00649001f, -0.04574380f, -0.02591888f, 0.00931728f, -0.02676699f, -0.05711793f, -0.06025510f, 0.02100889f, 
    -0.03309046f, -0.05953010f, -0.02347556f, 0.02271257f, -0.04458608f, -0.05536435f, -0.05322731f, -0.03812037f, 
    0.02212439f, 0.05743137f, -0.02175152f, 0.00598373f, 0.02583768f, -0.00687924f, -0.06167312f, 0.04777918f, 
    0.00101179f, -0.04355069f, -0.00043248f, -0.00658582f, -0.05220338f, 0.00818864f, -0.05795627f, 0.00928315f, 
    -0.04382014f, 0.02154197f, 0.02958078f, 0.01147600f, 0.03617349f, 0.02726253f, 0.00787263f, 0.01605514f, 
    -0.01475833f, 0.00697988f, -0.05846487f, -0.01234673f, -0.00605029f, 0.03957995f, -0.05160730f, 0.03503435f, 
    -0.03715367f, -0.04320495f, 0.05778529f, -0.01752966f, -0.00878592f, 0.01197982f, 0.04775323f, 0.03811955f, 
    -0.01727062f, -0.05212273f, 0.01799943f, -0.00805671f, -0.04768430f, 0.03793229f, -0.05252907f, 0.01232535f, 
    -0.02181387f, 0.04036295f, -0.02618093f, -0.03735575f, 0.04851552f, -0.01842812f, -0.05803122f, -0.00874383f, 
    -0.06302992f, -0.05707642f, -0.05678786f, -0.05426957f, -0.03930167f, -0.04888461f, 0.03352480f, 0.01154735f, 
    -0.04884101f, -0.03259324f, 0.03424210f, 0.01539413f, 0.02582469f, 0.00109278f, -0.02523801f, -0.02421320f, 
    -0.01249107f, 0.00753006f, -0.02936363f, 0.04663168f, -0.06328372f, 0.01377549f, 0.04478082f, -0.05253604f, 
    -0.05470187f, 0.04342138f, -0.00596572f, -0.00031863f, -0.00172204f, -0.04045139f, 0.02298545f, 0.05286860f, 
    0.04400238f, -0.03171663f, 0.00073863f, -0.01068435f, -0.01423712f, 0.04566785f, -0.05075658f, 0.00245040f, 
    0.04920864f, -0.05676941f, 0.02972784f, -0.00997063f, -0.00003458f, 0.03611121f, 0.04597444f, -0.03414542f, 
    -0.05432831f, 0.10457302f, -0.08178479f, -0.09881523f, -0.07027739f, -0.27617449f, -0.03120496f, 0.09311505f, 
    0.24847591f, 0.29566333f, 0.16891398f, -0.09597546f, 0.09888595f, -0.03619086f, 0.12523443f, -0.12507471f, 
    -0.17443459f, -0.22285208f, -0.07156294f, -0.03561064f, 0.09709407f, -0.07095559f, 0.02534153f, -0.17611752f, 
    0.10661275f, -0.07219670f, 0.21783410f, 0.08371607f, -0.17944491f, -0.19503503f, -0.13125017f, -0.20628271f, 
    -0.15326767f, 0.22101273f, -0.09310374f, -0.03645458f, -0.19497591f, 0.36733946f, 0.42609680f, 0.02384681f, 
    -0.13611311f, -0.09593768f, 0.08372261f, 0.20083725f, 0.04897625f, 0.01312580f, 0.15066890f, 0.07857522f, 
    0.08729297f, 0.08380365f, 0.01543660f, 0.07786758f, -0.09249701f, 0.03555376f, -0.09623406f, -0.12699974f, 
    -0.02874374f, 0.07323912f, -0.07261759f, 0.07839943f, -0.00861853f, -0.02161228f, 0.07109395f, -0.08379301f, 
    -0.04296568f, 0.13141671f, 0.06136960f, -0.01899843f, 0.08424662f, 0.02259039f, 0.19191448f, 0.22086555f, 
    0.00539743f, -0.05610764f, -0.39769396f, -0.06354289f, 0.07594674f, 0.16187932f, 0.21370541f, -0.00738310f, 
    -0.09541352f, -0.19713731f, 0.19507216f, 0.06459233f, -0.06960044f, -0.07461336f, -0.22486918f, -0.01999851f, 
    -0.10033583f, -0.09037133f, -0.08822228f, 0.02316613f, -0.15960205f, -0.07246950f, -0.01931258f, 0.05732471f, 
    0.01956240f, 0.03844898f, 0.10111290f, -0.49253607f, -0.03471566f, 0.01523776f, 0.01302215f, 0.03024340f, 
    0.00104657f, 0.13768126f, 0.03774162f, 0.13359985f, 0.07089873f, 0.04859558f, -0.00860183f, -0.05821666f, 
    0.14628978f, 0.09382556f, 0.08144526f, 0.04192300f, 0.08659536f, -0.16638622f, -0.00408556f, -0.23340738f, 
    -0.07554653f, -0.12190354f, 0.12694395f, -0.10762296f, 0.07482105f, 0.07707760f, -0.13842908f, 0.02591204f, 
    -0.03379034f, -0.07398739f, 0.03202554f, 0.06463108f, 0.10296602f, 0.00783208f, 0.13765849f, -0.14674431f, 
    -0.07577289f, -0.03428983f, -0.01514743f, 0.10590222f, 0.00014035f, -0.06886774f, 0.17400381f, 0.08320164f, 
    -0.26622206f, -0.47273463f, 0.08213180f, -0.01890984f, -0.15686539f, -0.18400128f, 0.06386680f, 0.13156097f, 
    -0.08857575f, 0.00494933f, -0.00631302f, 0.07674097f, -0.01976639f, 0.13385038f, 0.14996170f, 0.01350851f, 
    0.14470160f, -0.05065740f, 0.00110966f, -0.00238938f, -0.27824324f, -0.03363048f, 0.21411902f, 0.14143668f, 
    0.00313115f, -0.04387390f, 0.03185118f, 0.41537791f, -0.22563627f, -0.09292037f, -0.06030116f, -0.04425890f, 
    -0.03286290f, 0.02316028f, 0.14602524f, -0.15163098f, 0.28095993f, -0.11381502f, 0.13753022f, -0.18829380f, 
    -0.23966242f, 0.04609123f, -0.05665133f, 0.03109444f, 0.05716047f, -0.20460662f, -0.08265637f, -0.08201761f, 
    -0.16516183f, 0.07541130f, -0.07312939f, 0.10767277f, 0.04066771f, 0.00297639f, -0.12763077f, 0.12740868f, 
    0.10093787f, -0.04191893f, 0.07989030f, -0.01742353f, 0.12990956f, 0.02053519f, 0.03516044f, -0.33902767f, 
    -0.31575304f, -0.08126047f, -0.01279145f, 0.13184565f, -0.09742648f, 0.08426787f, -0.01793411f, 0.00311472f, 
    0.10828277f, 0.11576555f, -0.06711110f, 0.03458010f, -0.19162081f, 0.00853983f, 0.09130491f, 0.00083110f, 
    -0.04554785f, -0.05512381f, -0.13871530f, -0.08612484f, -0.03033144f, -0.00333545f, 0.08799183f, 0.06787627f, 
    -0.04395346f, -0.01748225f, -0.07565776f, -0.06865926f, 0.08279738f, -0.18821067f, -0.08547767f, 0.07528190f, 
    0.09493621f, 0.09496269f, 0.14506437f, -0.29737756f, -0.06596772f, 0.02204913f, 0.00263926f, 0.19203241f, 
    -0.03033332f, 0.04233827f, 0.07934018f, 0.05069137f, 0.06176700f, 0.11769077f, 0.03192101f, 0.01663683f, 
    -0.15893574f, -0.10881682f, 0.01573664f, 0.09366658f, -0.09507655f, -0.64089739f, -0.42698845f, 0.10023779f, 
    -0.01900928f, 0.10634501f, -0.20513643f, -0.02332040f, 0.01840451f, -0.07734922f, -0.23339295f, -0.22044310f, 
    0.14226030f, -0.07006083f, 0.04807489f, -0.04210370f, -0.10229100f, 0.06740150f, 0.08412256f, -0.11794216f, 
    -0.30351502f, -0.09366794f, -0.07987210f, -0.10429547f, 0.00359423f, -0.20739946f, 0.18581182f, -0.18601117f, 
    -0.14200035f, -0.21639699f, -0.03417263f, 0.17198564f, -0.11303435f, 0.06980983f, 0.08197270f, -0.05926374f, 
    0.23099479f, -0.16409335f, -0.02757429f, 0.13573320f, 0.00323631f, 0.02891591f, 0.05249667f, 0.05380893f, 
    -0.04237277f, -0.02723509f, -0.24775565f, -0.22066148f, 0.23344418f, 0.18177493f, -0.13658720f, 0.10019687f, 
    0.04974752f, 0.08786761f, -0.09322917f, 0.11339594f, -0.02683460f, -0.04489281f, 0.05811411f, -0.11458638f, 
    0.17110766f, 0.03944963f, -0.08935905f, -0.35454381f, -0.02984556f, -0.04622535f, 0.25692126f, -0.08211397f, 
    0.04925822f, 0.06587045f, -0.08316541f, 0.01509508f, 0.02029011f, 0.28460452f, -0.09448223f, 0.01476912f, 
    0.05597944f, 0.09232830f, 0.07369293f, 0.10611772f, -0.02870527f, -0.15411107f, -0.08688722f, -0.13557188f, 
    0.07730972f, 0.02815266f, -0.14858115f, 0.01537578f, 0.03338138f, -0.01907407f, -0.09263811f, -0.20841068f, 
    0.08286074f, 0.01987888f, -0.00789519f, -0.06630279f, 0.03982615f, 0.15473044f, 0.00440543f, 0.18611531f, 
    0.03134212f, -0.04262984f, -0.01878665f, 0.03757649f, -0.08878000f, -0.00453038f, 0.08461169f, -0.24463804f, 
    -0.11537448f, 0.16969833f, -0.07754970f, 0.31423676f, -0.05677214f, 0.09847387f, -0.02023037f, 0.00382319f, 
    -0.10909622f, -0.43181115f, -0.07359112f, -0.13782954f, 0.15349840f, 0.05915959f, 0.03007444f, -0.03252848f, 
    -0.05583628f, 0.07353342f, -0.07557081f, -0.09899653f, -0.16561243f, 0.05236311f, 0.21316366f, -0.12031070f, 
    0.00435756f, 0.04539718f, -0.04325419f, -0.03811607f, 0.30792716f, 0.04279580f, -0.03197469f, 0.03368200f, 
    -0.00789320f, -0.02091710f, 0.13429201f, -0.06237948f, -0.01397458f, -0.24002141f, -0.30832925f, -0.06310727f, 
    -0.09749909f, -0.01411397f, -0.02138302f, 0.06243570f, -0.19194414f, -0.02920031f, 0.12556271f, 0.10706052f, 
    0.04695229f, 0.20709032f, 0.02355726f, 0.11633434f, 0.12347777f, 0.06752907f, 0.14861494f, -0.04746044f, 
    0.17466435f, -0.08349350f, 0.11786029f, 0.07691514f, -0.04682863f, 0.09664405f, 0.15992372f, 0.16256204f, 
    0.11435187f, 0.19963482f, 0.14260878f, -0.02423174f, -0.14424324f, -0.05836140f, -0.03441633f, -0.09618263f, 
    -0.16401629f, 0.10036075f, 0.19470693f, 0.07825195f, 0.15428843f, -0.00360954f, 0.07666151f, 0.04141745f, 
    0.07472298f, 0.15152766f, 0.20476507f, 0.15832114f, -0.06940935f, 0.00357833f, 0.14112982f, 0.04278648f, 
    0.12834215f, -0.05248958f, 0.07934348f, 0.15728383f, 0.04663642f, -0.00774021f, 0.21065256f, -0.05902961f, 
    -0.08753437f, 0.15457332f, -0.23033233f, -0.02880277f, -0.26802158f, 0.29495001f, 0.30099031f, -0.18030661f, 
    0.24243347f, -0.01697165f, 0.14855510f, 0.03890685f, -0.04222308f, -0.23399653f, -0.07731727f, 0.35816842f, 
    -0.06892852f, -0.04505783f, -0.02246515f, -0.01208339f, 0.06788901f, 0.01471083f, 0.17194153f, 0.02996175f, 
    0.24322595f, 0.05101608f, 0.06840542f, 0.02035362f, 0.10465667f, 0.01218806f, 0.00618872f, 0.23703173f, 
    -0.13198669f, -0.19691911f, 0.01998109f, -0.01980084f, 0.02583278f, 0.17726912f, -0.09908614f, 0.04325001f, 
    -0.10023915f, 0.02159509f, -0.13583633f, 0.10941692f, -0.02904171f, -0.10956369f, 0.03968081f, -0.08162518f, 
    0.05758046f, -0.10085645f, -0.22102365f, -0.17487778f, 0.06345224f, -0.06402432f, -0.08296040f, 0.16952710f, 
    -0.25290918f, 0.14452936f, -0.00476206f, -0.11399857f, 0.12892115f, 0.10567598f, -0.07390235f, 0.13100177f, 
    -0.05539427f, -0.08425827f, 0.11027951f, -0.18586314f, -0.01720486f, 0.07588024f, 0.12257423f, -0.08659635f, 
    0.02151361f, 0.08696708f, 0.13210899f, 0.03756794f, -0.02264378f, 0.11308800f, -0.12440135f, 0.14947298f, 
    -0.06680255f, -0.09733830f, 0.03136272f, -0.02081508f, 0.06889319f, 0.24952798f, 0.12344815f, 0.09109737f, 
    -0.10229231f, -0.17570886f, -0.06566001f, 0.06485925f, 0.05330729f, -0.06547074f, 0.20400923f, -0.17603768f, 
    -0.03135384f, 0.10993156f, 0.04392825f, -0.10601421f, -0.03892327f, 0.08184265f, 0.08944984f, 0.00743515f, 
    -0.21013863f, -0.45602223f, -0.01730808f, -0.11603191f, 0.07836062f, -0.04661499f, 0.31887317f, -0.11460625f, 
    -0.00858794f, 0.22531903f, -0.01809530f, -0.02457809f, -0.02751714f, -0.02707769f, -0.23899834f, -0.03368305f, 
    0.14769968f, -0.03810588f, -0.15886486f, -0.22968398f, 0.06816129f, 0.18646818f, 0.14903867f, 0.01394722f, 
    -0.02004293f, 0.01455435f, 0.25838634f, -0.00449776f, -0.07686431f, -0.04506956f, -0.00578104f, -0.16646534f, 
    -0.08286843f, -0.02788189f, -0.02029464f, -0.30716774f, 0.11393020f, 0.14747638f, -0.02292236f, -0.03840502f, 
    -0.03177417f, 0.05589068f, 0.04962764f, 0.04689949f, -0.37536663f, -0.46981534f, -0.52076370f, 0.05079290f, 
    0.23288532f, 0.08311997f, 0.11834704f, -0.10700170f, -0.02897867f, -0.19845006f, -0.06353808f, 0.07778437f, 
    0.05314451f, 0.20062159f, 0.10372543f, 0.01437837f, 0.11819021f, 0.06899105f, 0.02261837f, -0.39861625f, 
    -0.72059160f, -0.17014575f, 0.02692347f, -0.00350677f, 0.11223774f, -0.11931538f, -0.00917669f, -0.11068390f, 
    -0.11197466f, -0.13374017f, -0.02595394f, 0.03172871f, 0.14013775f, -0.05684018f, 0.09882886f, 0.09484345f, 
    -0.12236059f, 0.04012134f, -0.02876437f, 0.01342750f, 0.09305865f, 0.02359737f, 0.13232097f, 0.01411245f, 
    0.04992306f, -0.02802506f, -0.17854555f, -0.21933374f, -0.14573196f, -0.04999244f, -0.13119006f, -0.09515455f, 
    -0.13433780f, 0.06598597f, -0.14680301f, -0.37617058f, -0.48449045f, -0.02088637f, -0.07521249f, -0.04620295f, 
    0.08766055f, -0.03053120f, 0.07380999f, -0.26754534f, -0.30802429f, -0.08616939f, 0.00065582f, 0.14787233f, 
    -0.00462177f, 0.11745822f, 0.07195695f, -0.01823346f, -0.18450734f, 0.16140309f, -0.01385287f, 0.03919686f, 
    0.15833363f, 0.19820878f, 0.14655629f, 0.02323114f, 0.00666398f, 0.18828437f, -0.11688201f, -0.27118346f, 
    0.13616462f, 0.21291116f, -0.01075127f, 0.05493582f, 0.04046948f, 0.13561150f, 0.07768410f, 0.27150574f, 
    0.15639257f, 0.03443515f, -0.03983658f, 0.01633428f, 0.08653887f, -0.00891837f, -0.12436273f, 0.20386580f, 
    0.25468150f, 0.09927837f, 0.02880703f, -0.04283229f, -0.00582014f, 0.07430505f, 0.15236782f, 0.07523737f, 
    0.15180431f, 0.08604275f, -0.09202062f, -0.09972659f, -0.12182593f, -0.18505752f, 0.01293883f, 0.01284452f, 
    0.09926745f, -0.19349332f, 0.03944119f, 0.07163566f, 0.06527290f, 0.21176572f, 0.06014184f, 0.02354733f, 
    0.11981682f, -0.04888116f, -0.38233754f, -0.45173621f, -0.29297009f, 0.04092326f, 0.21436383f, 0.11332908f, 
    0.00454739f, -0.04712576f, -0.09382245f, 0.25290361f, 0.20469113f, -0.06987702f, 0.04788657f, -0.09502943f, 
    -0.15617491f, -0.03467729f, 0.12518330f, 0.10988774f, -0.41314852f, -0.14919706f, -0.09674317f, -0.05470822f, 
    0.10891372f, 0.05310020f, -0.12327079f, 0.07949974f, -0.08324778f, 0.00066527f, 0.34159184f, 0.16730753f, 
    -0.35313633f, -0.10394494f, -0.10190750f, 0.07533702f, -0.06115600f, 0.07397446f, -0.18840156f, -0.10563729f, 
    0.03098132f, 0.01950676f, 0.10574717f, -0.08594647f, -0.04820771f, 0.05981448f, 0.08630755f, 0.11866577f, 
    -0.03329332f, 0.09346890f, -0.06850200f, 0.04347715f, 0.09500573f, 0.23053749f, 0.10491902f, 0.06565712f, 
    0.03935803f, 0.03718300f, -0.03827640f, -0.10080650f, -0.06613935f, -0.02881652f, -0.12360430f, -0.02685865f, 
    -0.12704059f, 0.19719201f, 0.04276662f, -0.02420293f, -0.04764040f, -0.09313270f, -0.21990575f, 0.08800182f, 
    -0.05590804f, -0.05472792f, -0.26928875f, -0.10063773f, -0.03545602f, -0.29860222f, -0.24375743f, -0.01520003f, 
    -0.03075459f, -0.12021165f, 0.03486225f, 0.13569880f, -0.17307025f, -0.28444096f, -0.12754841f, 0.02575379f, 
    -0.00416492f, 0.08296356f, 0.01737849f, 0.06204461f, 0.12982354f, 0.11567041f, -0.04975149f, -0.10788102f, 
    -0.09784056f, 0.06750418f, 0.01621330f, -0.05064094f, -0.19106981f, 0.21950299f, 0.08345696f, -0.11899459f, 
    -0.11031767f, -0.08509061f, 0.01181660f, 0.10519816f, 0.00193359f, 0.12267359f, -0.03461846f, -0.30904612f, 
    -0.20859322f, -0.22247709f, -0.04341694f, -0.04197443f, 0.03325988f, 0.11413366f, -0.12027363f, 0.13268551f, 
    0.02846968f, 0.00291805f, -0.02630583f, 0.09956203f, -0.11529783f, 0.07948065f, -0.02734231f, 0.07927244f, 
    -0.15522125f, 0.06366082f, 0.09610295f, -0.13314125f, 0.01797374f, -0.00028730f, -0.02750352f, -0.03702616f, 
    -0.03359781f, -0.03467593f, -0.15034024f, 0.15140860f, -0.01018844f, 0.04953362f, 0.14813133f, 0.09768362f, 
    0.03022946f, 0.01167304f, 0.15445675f, -0.08162301f, -0.29149953f, 0.11626232f, 0.10084227f, -0.14116348f, 
    -0.02267690f, 0.16443373f, 0.08726014f, 0.13344954f, 0.14733332f, 0.16392453f, 0.14749454f, 0.22193116f, 
    0.12908635f, 0.11742913f, 0.08331914f, 0.06239909f, 0.10928227f, -0.22082090f, 0.15963489f, 0.05036045f, 
    -0.11887658f, -0.13916785f, -0.02389780f, -0.03519730f, 0.12650776f, 0.21566820f, -0.00932898f, 0.06653164f, 
    0.17414346f, 0.04341690f, 0.00886254f, 0.16929187f, 0.02118431f, 0.17392236f, 0.37026983f, -0.05440431f, 
    0.00621409f, -0.00253628f, -0.02660476f, -0.07142439f, -0.01006609f, 0.04128693f, 0.03992174f, 0.09941887f, 
    -0.09691736f, 0.09370456f, -0.05272277f, -0.11523885f, -0.09191576f, -0.09423748f, 0.00794530f, -0.10937073f, 
    -0.02881404f, 0.00290180f, 0.16905771f, -0.06166232f, 0.09612445f, 0.18515758f, 0.09804255f, -0.13581362f, 
    0.11561631f, 0.29238564f, 0.11991005f, 0.08606575f, -0.05508273f, -0.09791940f, -0.02544740f, 0.13704585f, 
    -0.01207609f, 0.11591183f, 0.35806757f, 0.03321970f, -0.34980693f, -0.02672603f, -0.04757234f, -0.09853619f, 
    0.03077511f, 0.16571821f, 0.05775442f, 0.04269882f, 0.04199222f, -0.02291921f, 0.10947649f, 0.22376239f, 
    -0.20550060f, -0.00886808f, 0.11452074f, 0.22527221f, -0.05373348f, 0.03983414f, 0.09098668f, 0.05810029f, 
    0.04775254f, 0.15403949f, -0.01147986f, -0.07840862f, -0.01805588f, -0.10967200f, -0.41671056f, 0.14768952f, 
    0.12582453f, -0.15107103f, -0.07329105f, 0.03268937f, -0.17928976f, 0.01628765f, -0.05887860f, 0.01864005f, 
    -0.01388625f, 0.09412432f, -0.08869067f, -0.12742403f, 0.10835289f, -0.03035505f, -0.00759766f, -0.19772074f, 
    -0.02901445f, -0.05221469f, -0.08490463f, 0.09654075f, -0.00348082f, -0.01577465f, 0.05887081f, -0.07908834f, 
    -0.36368471f, -0.07832080f, 0.23234089f, -0.10598963f, -0.02263027f, 0.05001433f, -0.01498383f, -0.03797863f, 
    -0.20963439f, 0.05185797f, 0.12176409f, -0.00214934f, -0.01300537f, 0.06929129f, 0.17639031f, -0.03843326f, 
    -0.00309686f, 0.02650707f, 0.06268483f, 0.09936715f, -0.03442762f, 0.01253150f, 0.06603294f, 0.13346696f, 
    -0.05451934f, 0.11751956f, -0.02499364f, -0.32799742f, -0.14138897f, 0.07348569f, -0.03503890f, -0.05873049f, 
    0.11716839f, 0.24590065f, -0.06828351f, 0.11682644f, -0.20594652f, -0.13380504f, 0.03825065f, -0.06039127f, 
    -0.12292597f, 0.07372309f, 0.07590768f, -0.04285214f, -0.20212267f, 0.25055924f, 0.18600817f, 0.05911745f, 
    0.08845197f, -0.04247107f, -0.03287315f, -0.02345729f, 0.05835991f, -0.07378735f, 0.34666809f, 0.10413042f, 
    0.14681953f, 0.06783693f, -0.02522790f, 0.19574127f, 0.09108283f, 0.02819968f, 0.16418305f, -0.01158581f, 
    0.06543737f, 0.03604492f, 0.05421637f, 0.06419087f, -0.10677014f, -0.07278024f, 0.01592729f, 0.06744932f, 
    -0.23429987f, -0.14311962f, -0.04761335f, -0.03606615f, -0.01419864f, -0.14401208f, 0.08763190f, -0.05998562f, 
    0.06348861f, -0.33934557f, -0.24885298f, 0.01550903f, -0.08227903f, 0.03536540f, -0.04024393f, 0.05853418f, 
    0.09608657f, -0.19919352f, 0.44021490f, -0.00791978f, -0.21787816f, 0.03927960f, -0.05214782f, 0.05613910f, 
    0.05422071f, 0.11297940f, 0.03834958f, 0.23598315f, 0.01681744f, -0.21027911f, -0.03095347f, -0.03039456f, 
    -0.06354876f, -0.12587063f, 0.02149336f, 0.10528190f, -0.14797713f, 0.08009955f, 0.08343724f, 0.03160606f, 
    0.04764284f, -0.25573176f, -0.09475050f, -0.04884614f, -0.09632214f, 0.06907479f, -0.08113415f, -0.07768491f, 
    -0.05055167f, -0.06503384f, 0.10747255f, -0.07501362f, -0.02966979f, -0.18776262f, 0.22285368f, -0.04255333f, 
    -0.27256510f, 0.18815489f, 0.02049094f, -0.06908225f, 0.00796078f, 0.03372473f, 0.02129676f, -0.11517951f, 
    -0.11728476f, -0.36044794f, -0.00204491f, -0.05300518f, -0.32578745f, 0.04359221f, -0.14435652f, -0.08204710f, 
    -0.29358494f, -0.04452727f, -0.17080171f, -0.02459463f, 0.17568314f, 0.08440350f, -0.09566443f, 0.08421776f, 
    0.08703072f, -0.25214973f, -0.10656419f, -0.03601282f, 0.02696800f, 0.14757147f, -0.09903111f, 0.06355377f, 
    0.09379546f, -0.12685506f, 0.25587738f, -0.22009188f, -0.05204983f, 0.02247087f, -0.08984894f, -0.04224039f, 
    -0.06196562f, -0.10048466f, 0.00714595f, -0.40385777f, -0.10355533f, -0.02466254f, 0.02834622f, 0.00341126f, 
    -0.01193019f, 0.05486488f, -0.06259241f, -0.20577966f, 0.12345884f, -0.17897183f, -0.03250801f, 0.01137545f, 
    0.15119319f, 0.08889062f, -0.00867027f, -0.07467799f, 0.02664747f, -0.10028062f, -0.05302886f, -0.13673046f, 
    0.03041860f, 0.04718560f, 0.02017306f, 0.12408576f, 0.02127747f, -0.25189617f, 0.14433239f, -0.23616894f, 
    -0.15717763f, -0.00722501f, 0.03082603f, 0.17332385f, -0.10304406f, 0.03395139f, 0.17702225f, 0.00859930f, 
    -0.10076917f, 0.00532579f, 0.07417297f, 0.09691719f, 0.10076218f, 0.07911362f, -0.05324189f, 0.20541744f, 
    -0.24170128f, -0.21581897f, -0.09093522f, 0.20656937f, 0.17558546f, -0.07034566f, -0.15696764f, -0.04989786f, 
    -0.12753868f, -0.30775654f, -0.12691209f, -0.05671756f, 0.06354030f, 0.01736294f, -0.15402430f, 0.12204819f, 
    -0.08323795f, -0.28634387f, 0.18244869f, -0.02252310f, -0.01886776f, 0.02564090f, -0.12225339f, 0.12383655f, 
    -0.11895070f, -0.01549152f, 0.20562524f, -0.08893976f, -0.23048709f, -0.34523752f, -0.04739814f, 0.17680378f, 
    -0.20232749f, 0.03111928f, 0.04169540f, -0.05735536f, 0.00943839f, -0.21622734f, 0.12294161f, 0.11357999f, 
    0.15406257f, -0.17565045f, 0.23295717f, 0.01766535f, 0.05711986f, -0.30336958f, -0.23778617f, 0.11131811f, 
    -0.04687355f, 0.14230308f, 0.01094829f, 0.01658235f, -0.10752160f, 0.07801291f, -0.03744961f, 0.17687416f, 
    -0.04936980f, -0.03205819f, 0.05098718f, 0.17658132f, 0.00350315f, 0.00215571f, -0.11119761f, 0.03934305f, 
    0.21941166f, -0.00872583f, 0.08062743f, 0.12463191f, 0.04043665f, 0.16338386f, 0.09264429f, -0.01917533f, 
    0.39217982f, 0.19860297f, 0.15525688f, 0.05549468f, -0.13630904f, -0.03281993f, -0.06030766f, -0.03781459f, 
    -0.04486134f, 0.05045237f, -0.02848618f, -0.15744278f, 0.04413953f, 0.30532238f, -0.07036355f, -0.05002014f, 
    0.03796180f, 0.13559142f, 0.17139332f, -0.16463701f, -0.16736059f, 0.07141750f, 0.05239156f, -0.01878244f, 
    -0.04996666f, -0.02083292f, -0.00544390f, 0.27113014f, 0.19731054f, 0.06522907f, -0.04075485f, -0.04969200f, 
    0.03614168f, -0.07997390f, -0.06776183f, -0.06094717f, -0.37149173f, -0.13830468f, 0.03761258f, -0.14727998f, 
    -0.02677961f, 0.16331276f, 0.10856991f, -0.03872276f, 0.19847620f, 0.08127381f, -0.05128689f, -0.12260892f, 
    0.04050126f, -0.22635791f, 0.01904861f, -0.15722463f, -0.05408464f, 0.06796524f, -0.01248737f, -0.13954686f, 
    0.01669996f, 0.03096308f, 0.07194015f, 0.14519626f, 0.15727191f, 0.01833895f, 0.05332756f, 0.22935648f, 
    -0.00519333f, -0.07172217f, 0.11565402f, 0.02282204f, 0.15261413f, 0.00185927f, -0.02937961f, 0.03374201f, 
    -0.24288651f, -0.07241883f, -0.12374952f, -0.21255735f, -0.00595539f, 0.04960927f, -0.00983188f, -0.06784292f, 
    -0.05671970f, 0.33084020f, 0.13942508f, -0.09825791f, 0.14085618f, -0.18740445f, -0.05954838f, -0.04015317f, 
    -0.12278268f, -0.00493610f, 0.15695627f, -0.14513700f, 0.00165796f, -0.15797715f, -0.04336109f, 0.03734860f, 
    0.04790983f, -0.19278735f, 0.11119185f, 0.18491347f, 0.07082623f, -0.06086555f, 0.02353873f, -0.11643740f, 
    0.01468319f, -0.04822296f, 0.03426183f, 0.14214571f, -0.24875456f, -0.09961016f, -0.24332376f, 0.06502096f, 
    0.18552391f, 0.21934952f, -0.08406245f, -0.05810292f, -0.02299636f, 0.42190069f, 0.11943831f, -0.02111571f, 
    -0.04787910f, -0.12277614f, -0.08143083f, 0.12750511f, 0.09979679f, 0.00886760f, 0.25378761f, -0.05255112f, 
    -0.14391765f, 0.09838431f, -0.10930720f, 0.21373251f, 0.11920182f, -0.01506670f, 0.02180100f, 0.22986646f, 
    -0.21670513f, -0.10870062f, 0.05639764f, 0.19732919f, 0.13657424f, 0.05092670f, 0.11963326f, -0.07524400f, 
    0.09967481f, 0.05177383f, 0.04770253f, -0.04746780f, -0.05576880f, -0.06672465f, 0.04028361f, 0.00597044f, 
    0.02473238f, -0.34836757f, 0.08156388f, -0.02925970f, -0.02998852f, 0.17861462f, 0.08838031f, 0.03459905f, 
    -0.01074522f, -0.00847759f, -0.05929439f, 0.07166310f, -0.04534021f, 0.20261025f, -0.20957096f, 0.07401158f, 
    -0.08770271f, -0.06904492f, -0.11982810f, -0.17611407f, 0.27573475f, 0.42172727f, 0.08116949f, 0.02101742f, 
    -0.01607521f, -0.12396334f, -0.07279891f, -0.20289665f, -0.03908531f, -0.18246175f, -0.23488620f, -0.08282889f, 
    -0.09259801f, 0.12903982f, -0.03201122f, 0.04206273f, 0.05520748f, -0.03945318f, 0.07938946f, 0.16008186f, 
    0.15433532f, 0.12417830f, 0.15224947f, -0.09944639f, -0.01245945f, 0.04153099f, -0.26618448f, -0.26103050f, 
    -0.19732876f, 0.02668322f, 0.11731719f, 0.06455681f, 0.02326101f, -0.03948105f, 0.04257346f, -0.18330912f, 
    -0.03133415f, -0.13688955f, -0.03234746f, 0.09785984f, 0.03749107f, 0.07238150f, -0.02058120f, 0.02253812f, 
    0.06378613f, 0.25049290f, 0.01880707f, -0.09336858f, 0.08305709f, 0.08793341f, -0.10974126f, 0.01333057f, 
    0.16627230f, -0.00439084f, -0.17232768f, 0.22200865f, 0.06301211f, 0.03818224f, 0.01489842f, -0.04895435f, 
    -0.09043468f, 0.02913349f, 0.00795053f, -0.01058988f, -0.04022361f, -0.03396036f, -0.08573695f, 0.05777213f, 
    -0.02919003f, -0.00129235f, -0.00404499f, -0.00537849f, 0.05315467f, -0.19627440f, -0.06545427f, -0.07784063f, 
    0.06863783f, -0.06532159f, 0.05736128f, -0.04261981f, 0.34266123f, 0.05766679f, -0.11700768f, 0.06527171f, 
    0.06883294f, -0.00695678f, 0.06814766f, 0.09593138f, 0.01296886f, -0.06668989f, -0.25194463f, 0.11064307f, 
    -0.06486256f, 0.33421794f, -0.26044026f, 0.31522402f, 0.05449758f, 0.11583868f, 0.10768746f, -0.00735166f, 
    -0.00082177f, -0.22459929f, 0.03275622f, -0.10080709f, -0.00810684f, 0.14004505f, -0.03807898f, -0.01510029f, 
    0.22540449f, 0.04117345f, 0.04273510f, -0.04066355f, -0.14608511f, -0.04122037f, -0.10226252f, 0.07757276f, 
    0.34889662f, 0.04218883f, -0.02025056f, 0.05225711f, -0.15450521f, -0.04803790f, 0.01731031f, 0.08591238f, 
    -0.00181602f, -0.21425505f, 0.17228746f, 0.13079964f, 0.05867608f, -0.02149532f, -0.08921499f, -0.10014668f, 
    -0.06355135f, 0.12299971f, -0.10490439f, -0.08589094f, 0.15860528f, -0.07640788f, 0.20532010f, -0.15342142f, 
    0.02511331f, 0.03735515f, -0.02540259f, 0.08315982f, 0.09467570f, 0.06063220f, -0.05097867f, -0.10339774f, 
    -0.01513477f, 0.02377168f, -0.06826381f, -0.05651803f, 0.11447592f, 0.44844037f, -0.00975102f, -0.03352993f, 
    0.15317969f, 0.02966622f, -0.07305303f, -0.05966672f, -0.07131679f, -0.27835381f, 0.18581997f, 0.02154716f, 
    -0.02596950f, 0.01730537f, 0.08118097f, 0.14792326f, -0.04320655f, 0.13685279f, -0.29351991f, 0.04429654f, 
    0.17489696f, 0.16822915f, -0.01639021f, 0.05493356f, -0.14166752f, 0.01006359f, -0.05859811f, -0.06632148f, 
    -0.07574389f, -0.04694900f, -0.02614789f, -0.08015186f, -0.02170115f, 0.03569321f, -0.09213308f, -0.04599583f, 
    0.05368198f, 0.14451669f, -0.03442617f, -0.04394736f, -0.08718143f, -0.18944205f, -0.03429940f, -0.09189463f, 
    0.02457489f, -0.05720172f, 0.12551013f, -0.17000037f, 0.04054204f, 0.04379149f, 0.01862217f, 0.20701502f, 
    -0.14119972f, -0.10817367f, -0.03910185f, 0.05466448f, 0.17923640f, 0.01031063f, -0.12323721f, 0.09867555f, 
    -0.12330677f, -0.20542720f, 0.12288440f, -0.25546688f, -0.09797660f, -0.13357958f, -0.00843952f, -0.04300449f, 
    0.14892054f, 0.10624894f, 0.06724001f, -0.09010950f, 0.11579891f, 0.12612754f, -0.05653413f, -0.01621228f, 
    -0.14714360f, -0.23783620f, 0.04147342f, -0.05205667f, 0.02459674f, 0.19191678f, -0.20259951f, -0.10303605f, 
    0.16091651f, -0.12233721f, 0.02103312f, 0.09516285f, 0.00501515f, 0.08884171f, -0.11588992f, 0.11160189f, 
    0.45788229f, 0.12385911f, 0.02973131f, 0.00736824f, 0.08427966f, -0.07290768f, 0.14201036f, -0.00400463f, 
    0.10713303f, 0.15906379f, 0.16150534f, 0.11282839f, -0.20694758f, 0.13109748f, -0.46401238f, 0.11167581f, 
    -0.06097380f, -0.01100696f, -0.22131877f, 0.21572842f, -0.04065011f, -0.00062123f, 0.11698534f, -0.22950590f, 
    -0.15823445f, -0.03712678f, -0.18495587f, 0.25776699f, 0.14387400f, -0.02274742f, 0.05789708f, 0.06877030f, 
    0.06167545f, 0.04137787f, -0.08854517f, 0.05187012f, 0.03757321f, -0.05508916f, -0.04311914f, -0.04521310f, 
    -0.00028023f, 0.00406636f, -0.11385967f, -0.00076946f, 0.05717470f, 0.01552941f, -0.11407050f, -0.11898018f, 
    0.03509216f, 0.09403628f, 0.09055799f, 0.20100671f, 0.08969899f, 0.14195973f, 0.07865972f, 0.07406832f, 
    -0.10476904f, 0.03539889f, 0.04274604f, -0.00682037f, -0.05616715f, -0.06520467f, 0.12363038f, 0.13445826f, 
    -0.03284265f, -0.13742201f, 0.07564276f, 0.05471724f, 0.08849276f, 0.02566544f, -0.08749761f, 0.03501168f, 
    -0.01694738f, 0.06934020f, -0.04829214f, -0.20058028f, -0.20551272f, -0.02274780f, -0.11333178f, 0.08747737f, 
    0.21476033f, 0.10256001f, 0.07100537f, 0.03846205f, -0.30882525f, -0.16308090f, -0.24516816f, -0.02541405f, 
    0.01009081f, 0.06286614f, 0.08645178f, 0.04113583f, 0.02771601f, 0.18153434f, 0.13173668f, 0.19312786f, 
    0.12882565f, 0.02899292f, -0.10115121f, 0.04114091f, -0.15540738f, 0.09177468f, 0.05711934f, 0.10599776f, 
    0.06553250f, 0.00727671f, 0.00995775f, 0.05308156f, 0.11662812f, -0.02167713f, -0.04842087f, -0.20234267f, 
    -0.08705759f, -0.11940262f, -0.07728865f, -0.02930713f, 0.22283910f, 0.11645093f, -0.20093963f, -0.09314562f, 
    0.12204113f, 0.16961214f, 0.09932330f, 0.00123274f, 0.07699395f, 0.14284466f, -0.04358700f, -0.16288669f, 
    0.15782215f, 0.08119268f, 0.04480458f, 0.07631798f, -0.02106346f, 0.30676264f, 0.01111445f, 0.27224624f, 
    -0.07741605f, 0.05704091f, 0.17866114f, -0.06380577f, -0.14710735f, 0.06119185f, -0.03302179f, -0.07975711f, 
    -0.01072453f, 0.09128611f, -0.07310825f, 0.16373812f, 0.09643243f, -0.05027132f, 0.11096950f, -0.04411054f, 
    -0.11233301f, -0.05915269f, -0.07509618f, 0.06326175f, 0.04448010f, 0.00119676f, 0.04332402f, 0.02997427f, 
    -0.37103084f, -0.12876092f, 0.01260304f, 0.03930207f, 0.02716507f, -0.09402201f, -0.06166184f, -0.00030985f, 
    -0.04531492f, -0.02938778f, 0.30517563f, -0.08562502f, -0.01416521f, -0.07814883f, 0.04033857f, 0.06413494f, 
    0.08518620f, -0.05158710f, 0.08874867f, 0.21429352f, 0.14582816f, 0.05307535f, 0.08826519f, 0.04790551f, 
    0.03464394f, -0.12662509f, -0.08807038f, -0.16560319f, -0.04939893f, 0.02218722f, 0.04314931f, 0.11123898f, 
    0.04659397f, -0.04216112f, 0.11100886f, 0.26852486f, -0.10462046f, 0.22921365f, 0.07006992f, 0.11480376f, 
    -0.00901909f, 0.02400745f, -0.10919389f, -0.14967670f, 0.04822676f, -0.18884802f, 0.03569210f, -0.00253861f, 
    0.02265186f, 0.01983027f, 0.08999351f, -0.13371560f, -0.05421304f, -0.40379563f, -0.06265064f, 0.10166986f, 
    0.03484396f, 0.06382330f, -0.10417402f, 0.09632757f, 0.03633365f, 0.10713354f, -0.10301671f, 0.01389865f, 
    0.23057984f, 0.10065210f, 0.01034415f, 0.13200393f, 0.00063330f, 0.12797932f, 0.03639651f, 0.26850224f, 
    -0.15975766f, -0.06399580f, -0.13450116f, 0.11171875f, 0.08943215f, 0.07481907f, -0.05912284f, -0.12165418f, 
    -0.01615294f, -0.06741472f, 0.14604394f, 0.07304429f, -0.12342071f, 0.07924461f, 0.02728631f, 0.01817646f, 
    0.00431578f, 0.04141551f, -0.08054684f, -0.16887067f, -0.02767085f, 0.01664666f, 0.06939737f, -0.04696391f, 
    0.04599877f, -0.03355003f, -0.19341178f, -0.00046954f, 0.08462503f, 0.16138840f, 0.07182535f, -0.03351320f, 
    0.02006835f, -0.10011185f, -0.18885784f, -0.22297196f, -0.13161957f, -0.14994225f, -0.10402232f, 0.14516023f, 
    0.08913903f, 0.00914345f, 0.05028789f, -0.10958476f, -0.02805723f, -0.07242036f, -0.05837434f, 0.18654326f, 
    -0.09026472f, 0.00458033f, -0.05177242f, -0.02995979f, 0.06587030f, -0.06135852f, 0.10485303f, 0.06000061f, 
    0.32759327f, -0.06426296f, 0.02093896f, 0.01143550f, -0.00147781f, -0.00655482f, -0.21613342f, 0.06751719f, 
    0.07370880f, 0.03450815f, -0.01794860f, 0.03703690f, 0.02033151f, -0.18708119f, 0.05476404f, -0.08789310f, 
    -0.04484875f, -0.05067106f, 0.03002707f, -0.04817394f, -0.03468869f, 0.04812288f, -0.00975745f, 0.01253801f, 
    -0.02932706f, 0.01941996f, 0.01051317f, 0.02193868f, 0.00066095f, -0.03494995f, -0.05120377f, 0.04961811f, 
    -0.04291606f, -0.04423073f, -0.01818754f, -0.02998596f, 0.01844387f, 0.04253424f, 0.04949731f, 0.01237491f, 
    -0.05873275f, 0.04207747f, -0.04199494f, -0.03376889f, -0.05397453f, 0.01776950f, -0.03871763f, -0.02234046f, 
    0.04696230f, -0.05635988f, -0.04386089f, -0.01898044f, -0.01569698f, 0.05074321f, 0.01026112f, -0.01545348f, 
    -0.06066240f, -0.04177763f, -0.01315846f, 0.00150503f, 0.00471746f, 0.02903250f, -0.02616537f, -0.06395151f, 
    -0.03952137f, -0.05299650f, -0.06477915f, -0.01023134f, -0.03197110f, 0.04237591f, -0.03732704f, 0.04322261f, 
    -0.00240060f, 0.03590119f, 0.04763816f, -0.05489863f, 0.03333692f, 0.04507868f, -0.04797689f, -0.01743272f, 
    0.03703576f, -0.05077836f, 0.03347440f, 0.00611851f, 0.00855121f, 0.04616032f, -0.02375870f, -0.04684973f, 
    0.04691603f, -0.03562151f, -0.00994760f, -0.02694462f, -0.04547703f, 0.04962850f, 0.01339110f, -0.02485901f, 
    -0.04926240f, 0.04434975f, -0.00339772f, -0.05130579f, -0.00010796f, -0.02872043f, -0.02040419f, -0.04666751f, 
    0.04503071f, 0.04121738f, 0.03174235f, 0.02807496f, 0.03890792f, -0.01060787f, -0.04009330f, -0.03021440f, 
    -0.04268500f, -0.03752116f, -0.01954507f, 0.03458932f, -0.03473236f, -0.05581576f, -0.02452139f, -0.03345772f, 
    0.00971476f, -0.03397145f, -0.02767329f, 0.03380551f, 0.00330699f, 0.01484614f, 0.04290086f, -0.04976121f, 
    0.03552142f, 0.03507825f, -0.05319062f, -0.04701983f, 0.03212269f, 0.01365583f, -0.05017679f, 0.04519983f, 
    0.05193029f, -0.00006085f, -0.03658783f, -0.03091564f, -0.03542061f, 0.02811272f, -0.05501870f, -0.02967047f, 
    0.02578536f, 0.05183084f, -0.01059964f, -0.01578917f, -0.04678570f, 0.03612940f, -0.05613740f, -0.03911725f, 
    -0.02181892f, 0.01339837f, -0.04030499f, 0.01523977f, -0.04173292f, -0.02874533f, 0.00633783f, -0.02337971f, 
    0.02104628f, 0.04570392f, 0.01025285f, -0.04956190f, 0.04434740f, 0.00609956f, 0.01685493f, 0.04968662f, 
    -0.00622784f, 0.00155707f, 0.04933240f, -0.02878527f, -0.04318903f, 0.03592648f, -0.06274967f, -0.01215352f, 
    -0.03818110f, -0.03226138f, 0.03024083f, 0.05139624f, -0.00536378f, -0.01822747f, 0.04115322f, -0.05866076f, 
    0.04409438f, 0.01808812f, -0.03841426f, 0.04114175f, -0.02023517f, 0.00325739f, -0.00995371f, -0.05773046f, 
    0.04062451f, 0.01613290f, -0.05090012f, -0.05444983f, 0.04341957f, -0.03380411f, -0.00143952f, -0.03419568f, 
    -0.00344299f, -0.01462044f, -0.01606171f, -0.02099692f, -0.06386271f, -0.03629508f, -0.00208402f, -0.02973683f, 
    -0.01131827f, -0.06375476f, -0.03799613f, -0.06113918f, -0.02317206f, 0.00093786f, -0.06138402f, 0.01818966f, 
    -0.01176114f, 0.04268103f, -0.03344860f, -0.05845103f, 0.05183486f, -0.05494082f, -0.00537468f, 0.04719776f, 
    -0.03723070f, -0.04641578f, -0.00878043f, -0.02130423f, -0.05808999f, -0.02721413f, 0.01357635f, -0.05614375f, 
    0.03075868f, 0.01319466f, -0.05079942f, 0.01758690f, -0.04409229f, -0.01859208f, -0.00997990f, -0.02085438f, 
    -0.03754994f, -0.05604151f, -0.03022963f, -0.00870961f, 0.04065891f, -0.03223259f, -0.01658225f, -0.04153728f, 
    -0.03688116f, 0.02565763f, -0.03881912f, 0.00464596f, 0.04847851f, -0.02324777f, -0.03192316f, 0.00520452f, 
    -0.01858162f, 0.01707693f, -0.06420604f, 0.02142282f, -0.00809198f, 0.04553325f, -0.03856904f, -0.03964488f, 
    -0.01873130f, -0.01542069f, 0.03527197f, -0.05954910f, -0.00468379f, -0.02536213f, 0.02323938f, 0.02423193f, 
    -0.00450196f, 0.01476604f, 0.00290887f, -0.05268273f, -0.05218308f, 0.00668492f, 0.01303910f, 0.00058285f, 
    -0.05635751f, 0.03780599f, 0.02057818f, -0.04288962f, 0.02850690f, -0.02279342f, 0.00783838f, -0.03946382f, 
    -0.01270404f, -0.05856844f, -0.00715501f, -0.03745991f, -0.04607940f, 0.01202460f, 0.04533171f, -0.05090215f, 
    -0.05378592f, 0.03709795f, 0.00303736f, -0.03272086f, 0.01281374f, 0.00070834f, -0.01493849f, -0.01354282f, 
    -0.05442325f, 0.03236810f, -0.01536324f, -0.05230136f, -0.02915435f, -0.02500230f, 0.00447092f, 0.02431000f, 
    0.04788883f, 0.04933874f, 0.01587909f, -0.00679875f, -0.02857353f, -0.05912384f, -0.06288450f, -0.02867844f, 
    -0.02997090f, -0.05234263f, 0.03802828f, 0.00454251f, 0.02314100f, -0.02486513f, -0.01485548f, -0.00586206f, 
    -0.01214725f, -0.04144367f, 0.02702616f, 0.04685458f, 0.00416385f, 0.00764127f, -0.06104596f, -0.03376434f, 
    0.02503233f, -0.01902060f, -0.02240052f, 0.01332295f, 0.04878346f, 0.03002275f, -0.05895380f, 0.04692627f, 
    0.02411060f, 0.02462039f, 0.03171348f, -0.01524624f, -0.02825416f, -0.03588338f, 0.00196487f, 0.00683583f, 
    -0.00651609f, 0.04591345f, 0.02219035f, -0.02052779f, 0.01537341f, 0.05257554f, 0.04838919f, -0.00521720f, 
    0.02110842f, -0.05988999f, -0.00114544f, -0.00802605f, -0.06492909f, -0.04249824f, 0.02330955f, -0.05921975f, 
    -0.05665256f, 0.04530932f, 0.02121522f, -0.05893840f, -0.06302913f, -0.00113230f, -0.03074257f, 0.03411609f, 
    0.03815186f, 0.00660499f, 0.04515185f, -0.00597657f, 0.02013605f, 0.01227235f, -0.02547346f, 0.01954951f, 
    -0.04151506f, -0.01183888f, 0.00225765f, -0.04653147f, -0.03003104f, -0.01546887f, -0.06646156f, 0.03599668f, 
    -0.00513684f, -0.04203175f, 0.03632658f, 0.05018643f, 0.00688007f, 0.00752246f, -0.02348284f, -0.01203224f, 
    0.02634631f, 0.02239783f, 0.02917517f, -0.01783883f, 0.04850083f, -0.05631464f, -0.01857806f, 0.04236382f, 
    -0.04451827f, 0.00409469f, -0.05719953f, -0.06565547f, -0.01806491f, -0.04668134f, 0.04433421f, -0.00681645f, 
    0.02723178f, -0.06571446f, 0.03935339f, 0.03626847f, -0.01815199f, 0.00656405f, -0.01228954f, -0.01686528f, 
    -0.03864319f, -0.01191096f, -0.04883288f, -0.04238520f, 0.01149250f, -0.06203591f, -0.03280816f, -0.05843785f, 
    0.03390899f, 0.03454966f, 0.04222323f, -0.02970031f, 0.05067543f, 0.03748129f, 0.01625033f, -0.02006990f, 
    -0.04880966f, 0.00054819f, -0.04539522f, 0.00585406f, 0.00718554f, -0.04570337f, -0.02428260f, -0.05333659f, 
    0.00542365f, -0.05666982f, -0.01812052f, -0.02574966f, 0.05739013f, 0.02913879f, 0.03633349f, -0.05214204f, 
    0.00045888f, -0.03416580f, -0.05434001f, -0.01709275f, -0.01507682f, 0.04556691f, 0.02323084f, -0.03370503f, 
    -0.05225137f, -0.05752065f, -0.01498547f, -0.03019473f, 0.01650154f, -0.05570509f, 0.02571822f, -0.04897660f, 
    0.01337636f, -0.01176031f, -0.05110975f, -0.03412524f, -0.03631223f, -0.01997559f, -0.02783692f, -0.02685690f, 
    -0.02610575f, -0.05305116f, -0.05410097f, -0.01745774f, -0.04656254f, -0.01371091f, -0.04967616f, -0.00522018f, 
    0.03132885f, -0.03336604f, -0.02022403f, 0.00861589f, 0.04572035f, -0.04503722f, -0.03213167f, 0.01368821f, 
    -0.04419545f, -0.00213945f, -0.02264999f, -0.04041265f, -0.01160284f, 0.01548949f, 0.00732148f, -0.04658813f, 
    0.02578209f, -0.02138923f, -0.00758835f, 0.01272469f, 0.01125067f, -0.04495380f, -0.00070746f, -0.01820156f, 
    -0.02256037f, 0.04451733f, 0.02281206f, 0.04468814f, -0.04836079f, -0.06056058f, -0.01556963f, -0.02092453f, 
    -0.02969481f, 0.02677858f, 0.02556066f, 0.00903831f, 0.00408659f, 0.03907027f, 0.02267124f, 0.03223998f, 
    -0.04284903f, -0.02540776f, 0.04046297f, 0.00739434f, 0.00340921f, 0.05297848f, -0.02485686f, 0.00628649f, 
    0.04149247f, 0.04467800f, -0.04595428f, 0.04696831f, -0.02235969f, -0.02903173f, 0.02393996f, -0.01844124f, 
    -0.03915099f, -0.04087635f, -0.04876474f, 0.04774144f, -0.03942922f, -0.00386719f, 0.03334618f, -0.05948965f, 
    -0.01340277f, -0.03462918f, 0.02065000f, 0.03397973f, -0.03698458f, 0.00234747f, -0.04382835f, 0.02388166f, 
    0.01710717f, -0.03244065f, -0.00433858f, -0.05872417f, 0.03657623f, 0.01177958f, -0.01747627f, 0.04398048f, 
    0.01480169f, 0.04536220f, -0.02208564f, 0.01391300f, -0.03399590f, 0.00364528f, -0.05165307f, -0.01456884f, 
    -0.06677522f, -0.05728887f, 0.05377936f, 0.04911876f, -0.03115167f, 0.02580944f, 0.04895344f, 0.04471943f, 
    0.02478659f, -0.02306622f, -0.05668351f, -0.03771748f, 0.02317621f, -0.03749878f, 0.02963886f, 0.01853932f, 
    -0.00325840f, -0.04960655f, -0.00166540f, 0.10746507f, 0.03391872f, 0.13150626f, -0.01587811f, -0.39738774f, 
    -0.19685608f, -0.01168799f, 0.12149318f, 0.01004334f, 0.03253945f, 0.18777962f, -0.00019705f, -0.00294796f, 
    0.25498757f, -0.03531575f, 0.10355899f, 0.05689007f, -0.10607254f, 0.01462278f, 0.10885581f, 0.01029719f, 
    0.16448772f, -0.01343418f, -0.08235821f, 0.02534160f, -0.06423722f, -0.07485707f, 0.01582424f, 0.04692765f, 
    0.11308760f, -0.31237629f, -0.13795306f, -0.07902528f, 0.13620748f, -0.14551714f, 0.19477075f, -0.06792340f, 
    0.08011861f, -0.00623184f, -0.05081139f, -0.18241605f, 0.04401277f, -0.15060152f, 0.08334345f, -0.02042338f, 
    0.10336827f, 0.02277094f, -0.06646381f, -0.36739257f, -0.00818765f, -0.27313823f, 0.15635431f, 0.16996807f, 
    -0.06659777f, -0.06060918f, 0.09362717f, 0.09083514f, 0.07013220f, 0.04717425f, 0.20354012f, 0.01833951f, 
    0.16686285f, -0.02011649f, 0.02167225f, 0.08370590f, 0.02956067f, -0.13062099f, 0.08014242f, 0.02963075f, 
    0.11088631f, -0.08431310f, 0.05992111f, 0.06671347f, -0.21658999f, 0.10598348f, -0.16742836f, -0.04837220f, 
    0.04125693f, -0.13193491f, -0.12482090f, -0.09896190f, 0.05741309f, 0.05457029f, 0.08852111f, -0.09558773f, 
    -0.08961963f, -0.12917437f, 0.06245406f, 0.13658087f, -0.07999382f, -0.01968486f, -0.00907096f, -0.04983379f, 
    -0.00805870f, 0.06151328f, -0.04114638f, 0.13471399f, -0.01075782f, -0.09893330f, 0.21121985f, 0.01994038f, 
    0.08548622f, -0.01031188f, -0.13886118f, -0.10316441f, 0.03456783f, -0.06659096f, 0.03723537f, 0.12225827f, 
    0.01862857f, 0.01766002f, 0.13446364f, 0.07531863f, 0.04049804f, -0.13584210f, 0.05563734f, 0.05559724f, 
    -0.06327156f, 0.16189806f, 0.11797137f, -0.03874556f, 0.10693387f, 0.20049597f, -0.02702808f, 0.10641129f, 
    -0.03420597f, 0.02019322f, -0.08180972f, 0.23781793f, 0.10314970f, -0.10828637f, 0.01142409f, -0.10485340f, 
    -0.04215605f, -0.09293845f, -0.02579097f, 0.10329331f, 0.05839097f, 0.11600854f, 0.13688689f, -0.16526784f, 
    0.08260942f, -0.04564679f, 0.27839354f, -0.21024281f, 0.06511216f, -0.09786924f, 0.00803831f, 0.07533918f, 
    -0.01109144f, 0.10321886f, -0.01291747f, -0.05392290f, 0.04419211f, -0.03735505f, 0.10168613f, 0.01335733f, 
    0.03521740f, 0.14677981f, 0.11025727f, 0.06468799f, 0.01592072f, 0.03537382f, -0.04991741f, -0.00514909f, 
    0.00777186f, -0.05968586f, 0.16383629f, -0.26161179f, -0.12717988f, 0.07316916f, -0.13961865f, -0.17586337f, 
    -0.07235397f, -0.13832009f, -0.03999930f, 0.07764129f, -0.25586796f, -0.03133866f, 0.06681405f, 0.01789560f, 
    -0.07234646f, -0.07547810f, -0.22088392f, 0.31637183f, 0.07901672f, 0.11176229f, 0.19535804f, -0.05843568f, 
    0.03535340f, -0.01337286f, -0.15086618f, -0.10423272f, 0.06763756f, -0.18814659f, 0.02056010f, -0.04062653f, 
    -0.05216677f, -0.02526605f, 0.11907942f, -0.01358304f, -0.07323375f, -0.00249545f, -0.07823750f, -0.03124374f, 
    -0.05069742f, 0.10668889f, 0.03706289f, 0.30307716f, -0.00651218f, 0.12009855f, 0.19713281f, 0.30235404f, 
    -0.06504853f, -0.09370765f, 0.05617964f, 0.06926857f, 0.14967448f, -0.00382505f, -0.08489490f, -0.04653835f, 
    -0.40237167f, -0.24993601f, -0.18279977f, 0.07761143f, 0.01567053f, 0.03167010f, -0.02925080f, 0.06184307f, 
    0.24037242f, 0.08593992f, 0.28871331f, -0.01782815f, -0.01600339f, -0.28802094f, 0.08114281f, -0.30147049f, 
    0.03282382f, -0.11874529f, 0.05706115f, 0.06720320f, 0.13126959f, -0.07602534f, -0.08133811f, 0.00766740f, 
    0.01840964f, -0.07373575f, 0.05920302f, 0.06361391f, -0.01814409f, -0.15455048f, 0.00216160f, 0.02409895f, 
    0.07319604f, 0.00287284f, -0.11561155f, -0.11282757f, -0.16208981f, -0.02222077f, 0.19707459f, -0.05248492f, 
    -0.01706432f, 0.11092407f, -0.13282257f, 0.09142903f, 0.04751164f, 0.02718282f, 0.01617067f, -0.00107207f, 
    -0.19320545f, -0.19528013f, 0.04630107f, 0.06064601f, 0.07471170f, 0.26579863f, -0.21147531f, -0.19673057f, 
    -0.15361351f, -0.09449392f, 0.11696368f, 0.06306521f, 0.09347202f, 0.30588531f, 0.46284509f, -0.13316797f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.13085781f, -0.02941317f, -0.08333055f, -0.00847934f, 0.12033174f, 0.03968516f, 0.03804995f, -0.01440924f, 
    0.07668571f, 0.04947260f, 0.25893092f, 0.00742799f, -0.04232324f, 0.00998388f, -0.07363468f, 0.07042251f, 
    -0.04296124f, 0.10459499f, 0.02727127f, 0.00446069f, 0.20044243f, -0.05996330f, 0.15714397f, 0.14503543f, 
    0.22485127f, 0.02344101f, 0.13473557f, -0.00998088f, -0.00703719f, 0.02669770f, -0.02215168f, -0.05689727f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06909894f, 0.04865831f, -0.21991660f, 0.13372461f, 0.24202266f, -0.06724966f, -0.31893846f, 0.08025751f, 
    -0.24634807f, 0.11300541f, 0.11076240f, 0.14562228f, 0.15633592f, -0.04109447f, 0.04027956f, 0.20575541f, 
    0.09505524f, -0.16467969f, -0.14503835f, -0.19781239f, -0.01480326f, 0.14202118f, -0.29920417f, -0.08301277f, 
    0.01362254f, 0.26051205f, 0.25565678f, -0.10870037f, -0.10612116f, 0.09714393f, 0.07395866f, -0.08871956f, 
    0.43131977f, 0.11243371f, -0.27514267f, -0.17549869f, -0.16525348f, 0.30502900f, 0.15262397f, -0.33041012f, 
    0.16549483f, -0.05275233f, 0.08217067f, -0.09351990f, -0.08094539f, -0.01931449f, -0.73818541f, 0.00975710f, 
    0.12030093f, 0.05243917f, 0.10923368f, -0.21286203f, -0.20798124f, 0.10999198f, -0.10741360f, -0.06318393f, 
    0.09828576f, -0.11749583f, 0.08619166f, 0.10751098f, -0.03680322f, -0.11769120f, -0.15903915f, 0.00110263f, 
    -0.13955055f, -0.12002710f, 0.32088542f, 0.05245035f, -0.24038826f, -0.06692195f, 0.26170751f, 0.09025946f, 
    0.10357036f, 0.01277145f, 0.14782521f, 0.13251519f, 0.04849325f, -0.26467878f, 0.15243779f, 0.28523740f, 
    0.10327441f, -0.12719175f, 0.26427197f, 0.29423505f, 0.30816352f, -0.11963883f, 0.18910970f, 0.09338691f, 
    -0.04063563f, -0.24431261f, -0.01405863f, -0.08472218f, -0.15647784f, -0.15511245f, 0.02276504f, 0.16465193f, 
    -0.33563295f, -0.17182547f, -0.01961517f, 0.06653640f, -0.13225403f, 0.03368348f, -0.20318446f, -0.19965355f, 
    0.13942225f, -0.01309473f, -0.29712862f, -0.05824099f, -0.03158259f, -0.46654519f, -0.24406487f, 0.34282285f, 
    -0.06526796f, -0.21981691f, 0.29741886f, -0.22888684f, 0.26584607f, -0.07182010f, 0.05355032f, 0.34369466f, 
    0.04610360f, 0.06525635f, 0.40751725f, 0.15921701f, -0.21220256f, -0.02942508f, 0.02858489f, 0.24714747f, 
    0.27590656f, 0.09180747f, 0.24165213f, -0.09159744f, -0.16164474f, -0.04634433f, 0.08618303f, 0.35774371f, 
    0.16753247f, -0.36905292f, -0.06845200f, -0.16088015f, 0.15927565f, -0.13196526f, 0.11997584f, 0.02618668f, 
    -0.12434401f, -0.04797703f, 0.20530324f, -0.03838973f, -0.19479509f, -0.13281146f, 0.36535338f, -0.07151920f, 
    0.23126866f, -0.17617947f, 0.14914580f, 0.30636019f, 0.06731964f, 0.18185943f, 0.02499824f, -0.16966175f, 
    -0.28375044f, -0.03108745f, 0.00421460f, 0.13358295f, 0.19707640f, 0.03624713f, -0.08769783f, -0.30151507f, 
    -0.14870393f, 0.06272292f, 0.09514886f, -0.13019012f, 0.16195168f, -0.45643786f, -0.17526354f, 0.32399064f, 
    0.03150808f, -0.10652774f, 0.19511123f, 0.17133176f, 0.68406576f, -0.07545882f, 0.39929298f, 0.19268754f, 
    -0.31348780f, -0.23703824f, 0.21652623f, -0.13916200f, -0.17936645f, 0.02789153f, 0.04205028f, 0.14334546f, 
    -0.14660956f, 0.09467516f, -0.15984908f, -0.13578914f, -0.11047538f, -0.03679075f, 0.00286599f, -0.01737107f, 
    -0.09506523f, -0.05755290f, -0.18534546f, -0.11581627f, -0.16937743f, -0.08085614f, 0.06419212f, -0.07580077f, 
    -0.14292665f, 0.04295547f, -0.04762699f, -0.03579707f, 0.06170131f, -0.11571485f, 0.05379426f, -0.14911383f, 
    -0.06634263f, -0.06397737f, -0.15751337f, -0.14398207f, -0.18897009f, -0.14371245f, -0.13778061f, 0.01089481f, 
    -0.11114086f, -0.10086454f, 0.38561371f, -0.05710427f, 0.13737518f, 0.02613404f, 0.07734127f, 0.17865674f, 
    -0.21782696f, 0.38805908f, 0.13031247f, 0.10157214f, -0.03593949f, 0.13786821f, -0.25999019f, 0.34668779f, 
    0.08235373f, 0.02088584f, 0.08883740f, 0.44785181f, -0.57451963f, -0.05941841f, -0.20188653f, 0.00273488f, 
    0.36293179f, 0.05782636f, -0.30853269f, 0.02783210f, 0.14627266f, -0.09536459f, 0.03157322f, -0.18882453f, 
    -0.06430682f, -0.05979656f, -0.09710288f, 0.15958248f, 0.02807301f, -0.08814129f, -0.00431144f, 0.02267897f, 
    0.06752311f, -0.12618580f, -0.06029089f, 0.07609504f, -0.09753421f, -0.18071376f, 0.04250094f, -0.13570306f, 
    -0.11543836f, 0.17114718f, -0.09297551f, -0.01953480f, -0.11444288f, 0.07627829f, 0.20559360f, 0.13027982f, 
    0.13284889f, 0.06832142f, -0.14464970f, -0.05597200f, -0.04366155f, 0.03452708f, 0.02840403f, 0.10896707f, 
    -0.08364991f, -0.34999639f, -0.14238237f, 0.16028793f, -0.04315710f, 0.34988409f, -0.14868742f, -0.16915941f, 
    -0.12184650f, 0.48026583f, -0.29241800f, 0.01567490f, 0.03046292f, 0.34231421f, -0.09616130f, 0.03118371f, 
    0.05508127f, -0.00927596f, 0.20482047f, 0.16767061f, -0.00269545f, 0.13088506f, -0.31952542f, 0.07468769f, 
    0.18467942f, 0.11343814f, 0.30813366f, -0.28018463f, 0.18473105f, 0.02513766f, -0.11032846f, 0.10865864f, 
    0.12558366f, 0.14454725f, -0.15360221f, 0.01364809f, -0.26979616f, -0.12338956f, -0.11878894f, -0.06534006f, 
    0.14771344f, -0.34340927f, -0.05845928f, 0.12674919f, 0.15447524f, -0.07431611f, 0.01509163f, 0.19231355f, 
    0.17067012f, -0.12588257f, -0.30921572f, -0.16318797f, -0.32461670f, 0.02777562f, 0.20043950f, 0.30090383f, 
    -0.27986196f, 0.17497459f, 0.25974756f, -0.23848820f, 0.14470516f, 0.17074279f, 0.12107188f, 0.17037958f, 
    0.01597937f, -0.15051126f, 0.12607558f, -0.16133620f, 0.10293078f, -0.03912779f, -0.02205192f, 0.14578731f, 
    -0.09675183f, -0.06783982f, 0.00303740f, -0.09745534f, -0.01317671f, 0.06250586f, -0.06652856f, -0.00777996f, 
    0.11437266f, -0.02331090f, -0.10740153f, -0.13966884f, -0.05181355f, -0.09437604f, -0.09429199f, -0.10650055f, 
    0.10563478f, -0.06625081f, -0.14101373f, -0.02093470f, -0.05742167f, -0.12561660f, 0.04077817f, -0.03563913f, 
    -0.11471198f, -0.00716717f, 0.20014776f, -0.08963584f, 0.33574045f, 0.04178587f, -0.06643100f, -0.18763353f, 
    -0.22444798f, 0.07132326f, 0.12309423f, -0.01452870f, -0.11023182f, -0.06328433f, -0.01198336f, -0.06817631f, 
    0.13711149f, 0.09422706f, 0.11078512f, 0.09859295f, -0.05299146f, 0.01894104f, 0.02907460f, 0.03613251f, 
    0.22025852f, 0.10902461f, -0.05942716f, -0.15830703f, 0.09819368f, 0.01885148f, -0.02329440f, -0.12717937f, 
    0.33348796f, -0.17869999f, -0.07341380f, -0.00952983f, -0.28990164f, -0.15288129f, -0.16068847f, 0.16876489f, 
    0.43704548f, -0.02751607f, -0.27529290f, -0.04751499f, -0.08928506f, -0.07043134f, -0.14814086f, 0.33779523f, 
    -0.15576220f, 0.00639010f, 0.41061822f, 0.24489130f, -0.30309707f, 0.10816156f, 0.22706467f, 0.28785747f, 
    -0.44968233f, -0.10502927f, 0.35397628f, -0.25577930f, -0.13702427f, -0.07215707f, -0.05049428f, -0.02906466f, 
    -0.30991605f, 0.05233967f, 0.09106576f, -0.12660770f, 0.27262565f, 0.13435517f, 0.33031362f, -0.11708600f, 
    -0.09191886f, 0.44894966f, 0.11528173f, 0.12160237f, -0.12575893f, 0.18147124f, 0.28710455f, -0.09620453f, 
    0.02224097f, 0.07166877f, 0.04340887f, 0.10904284f, -0.03127143f, 0.06785879f, -0.31252226f, -0.19825256f, 
    0.17397860f, 0.29238749f, -0.21974975f, 0.02506380f, 0.09944069f, 0.04249481f, 0.00760481f, 0.08555645f, 
    0.32833308f, 0.08548503f, -0.01610552f, -0.14471512f, 0.19781342f, -0.11763801f, 0.17660168f, 0.29469684f, 
    -0.21892454f, -0.05092850f, -0.16149406f, 0.12482442f, 0.09803712f, 0.05723964f, 0.16197053f, 0.13662732f, 
    -0.05684100f, -0.09486431f, 0.23971930f, 0.00823942f, -0.44438475f, -0.05399809f, -0.05538541f, -0.09972590f, 
    0.19452374f, -0.21240057f, -0.10466164f, 0.32994381f, -0.00017161f, 0.15100367f, 0.03671070f, 0.02663388f, 
    0.09824593f, -0.06003168f, 0.23377277f, 0.17768027f, 0.56440681f, 0.26167357f, 0.09411879f, -0.11177995f, 
    -0.35193056f, -0.03992509f, -0.05086282f, -0.14956009f, -0.01349696f, -0.12053610f, 0.19695008f, 0.01107523f, 
    -0.02052691f, 0.08501153f, 0.13008153f, 0.04313653f, 0.57492012f, -0.10982136f, 0.31182528f, -0.11636118f, 
    0.09287693f, -0.21321206f, -0.21699490f, 0.21958466f, 0.22355638f, -0.11205068f, 0.12592447f, -0.16236281f, 
    -0.20966834f, -0.11031453f, -0.15827180f, -0.08961368f, 0.00817355f, -0.14918667f, -0.09780046f, -0.16281864f, 
    -0.07728330f, 0.06698316f, -0.09612452f, 0.10547196f, -0.10272266f, -0.11676350f, 0.02432572f, -0.06538229f, 
    0.00909545f, 0.11158235f, -0.18025859f, -0.13974819f, -0.12673092f, 0.16858937f, -0.07177670f, -0.13159868f, 
    0.01329259f, 0.09524120f, -0.10995360f, 0.05495166f, 0.08477037f, 0.08616479f, -0.13929266f, -0.09711193f, 
    -0.20419505f, -0.21677506f, 0.01617393f, 0.13512261f, 0.09092033f, 0.29072797f, 0.16663025f, -0.26714543f, 
    0.08007383f, 0.02325484f, 0.06327796f, -0.13753083f, -0.15039960f, 0.04986884f, 0.27358568f, 0.13932189f, 
    0.16211587f, -0.17470786f, -0.06584661f, -0.31851846f, 0.24773885f, -0.09082711f, -0.19476606f, -0.12238825f, 
    0.16545434f, 0.06720255f, 0.19286834f, -0.14763413f, 0.18765351f, -0.16601799f, -0.09686630f, 0.25421941f, 
    0.20521645f, -0.18845873f, -0.18701994f, -0.08091017f, -0.08147095f, 0.36789793f, 0.02157138f, -0.06585081f, 
    -0.24572346f, 0.43260530f, -0.17348194f, 0.08435413f, -0.13778239f, 0.24784073f, -0.03578513f, 0.00197019f, 
    -0.11886559f, 0.09874251f, 0.15356162f, 0.08567170f, -0.13433126f, 0.13334166f, 0.11338013f, -0.15024005f, 
    0.28938079f, -0.10354774f, 0.06746959f, -0.01956078f, 0.12358385f, -0.14608319f, 0.16583133f, 0.18993932f, 
    -0.11631537f, -0.16932997f, 0.08098204f, 0.12988815f, 0.23481324f, 0.36107239f, 0.30519724f, -0.36198130f, 
    -0.03004637f, 0.10729971f, -0.05641903f, 0.11175093f, -0.08350563f, -0.08972444f, -0.14211942f, -0.11782001f, 
    -0.00376679f, 0.14334089f, 0.18707156f, 0.05599971f, 0.43846080f, -0.06759825f, 0.22698145f, 0.22079673f, 
    0.34405598f, -0.11514495f, 0.06811187f, -0.34266314f, 0.14143033f, -0.04800713f, -0.16997837f, -0.09756631f, 
    0.04125865f, -0.31321704f, -0.00571586f, 0.10854945f, -0.07271611f, 0.13854153f, 0.30985776f, 0.08576176f, 
    -0.13478017f, 0.29706782f, 0.00707614f, -0.07750818f, 0.06146473f, 0.07380055f, 0.13833585f, -0.05259122f, 
    -0.10382320f, -0.07982761f, -0.34489241f, 0.28017208f, -0.31074649f, 0.02392592f, -0.41051942f, -0.00750555f, 
    0.48989642f, 0.42940116f, 0.22230430f, 0.00924153f, 0.22776470f, 0.15150054f, 0.03755636f, -0.04975834f, 
    -0.13112265f, -0.07465614f, 0.06282610f, 0.10683958f, -0.11620991f, -0.14300756f, -0.17989397f, -0.05629303f, 
    -0.12293691f, -0.14629178f, 0.12253022f, 0.01496663f, 0.02899971f, 0.11026923f, 0.02888545f, 0.09518979f, 
    -0.02037170f, -0.17938805f, 0.15797552f, 0.15560980f, -0.02274763f, 0.05819460f, -0.04541443f, -0.09791788f, 
    0.05144383f, -0.05157813f, -0.19450562f, 0.07285868f, -0.08195389f, -0.15453213f, 0.08654182f, -0.15209614f, 
    -0.15191871f, -0.07354797f, 0.01237800f, -0.14425151f, -0.06641416f, -0.01414954f, 0.04897365f, -0.16496278f, 
    -0.08575813f, -0.08961214f, -0.14432651f, 0.05409957f, -0.11924624f, -0.09951863f, 0.00189859f, -0.15115963f, 
    -0.10167432f, 0.02313044f, -0.16204385f, 0.14397420f, -0.10281818f, 0.15365560f, -0.11707098f, -0.05162633f, 
    -0.09289551f, -0.06866080f, 0.06042764f, -0.12201995f, -0.15014635f, 0.11559670f, 0.12243191f, 0.11189436f, 
    0.21147469f, -0.02008630f, 0.01555061f, -0.02841028f, 0.28965366f, 0.08454561f, -0.03587024f, 0.27380869f, 
    -0.22925058f, 0.07814825f, -0.41549176f, -0.12677953f, -0.00756791f, 0.15572050f, 0.13175099f, 0.10689124f, 
    -0.08120882f, 0.05213507f, -0.15334521f, 0.33301282f, -0.21649964f, 0.01529326f, 0.32600743f, -0.06704216f, 
    0.16887206f, 0.04618739f, -0.21465012f, -0.00128313f, 0.12497356f, -0.13662961f, 0.13621992f, -0.31886527f, 
    -0.24111760f, -0.14762437f, 0.23368493f, -0.12597944f, 0.01547086f, 0.15222295f, 0.06240511f, 0.12183712f, 
    -0.22365914f, 0.49014720f, -0.09146995f, -0.05488741f, -0.08801788f, 0.04978339f, -0.34459725f, 0.21354924f, 
    0.06172230f, 0.21063742f, 0.49874905f, -0.00275086f, -0.27349401f, 0.14136429f, 0.16052242f, 0.01704585f, 
    0.16994973f, -0.12617877f, 0.14509234f, -0.24417509f, 0.05804937f, 0.07042159f, -0.08244788f, -0.21586348f, 
    -0.29778922f, -0.08163134f, 0.15570742f, -0.11167705f, 0.36077279f, 0.08922228f, -0.21571773f, 0.04019642f, 
    0.10198207f, 0.34798202f, 0.16841584f, 0.01484525f, -0.01852703f, 0.15222363f, 0.09208301f, 0.11377122f, 
    0.12302051f, -0.19948371f, -0.19128755f, 0.02877605f, 0.55353332f, 0.00165884f, -0.00318025f, -0.16185416f, 
    0.18196039f, -0.08315034f, -0.03601905f, -0.04651397f, 0.22245733f, -0.09563946f, -0.01840668f, 0.14394204f, 
    -0.05039139f, 0.06242888f, 0.08091442f, -0.05088310f, -0.05037899f, 0.04420274f, 0.23163532f, 0.14046775f, 
    -0.23441279f, 0.11628805f, -0.05813542f, -0.00454114f, 0.12328520f, 0.03742905f, 0.32938802f, 0.20636910f, 
    0.04220402f, -0.29496717f, -0.05327558f, 0.07916757f, -0.34686655f, -0.03244000f, -0.44456455f, 0.08554500f, 
    0.41448700f, 0.27739981f, -0.14686655f, 0.16525325f, -0.07401359f, 0.14644097f, -0.10306567f, 0.12252215f, 
    -0.21144052f, -0.08723589f, 0.05072766f, -0.12935406f, -0.05419359f, -0.21909566f, -0.17619886f, 0.11861074f, 
    0.17296024f, -0.03375552f, -0.17612393f, 0.14944004f, 0.17468733f, -0.26418486f, -0.02024313f, 0.02919268f, 
    0.15303320f, -0.23256664f, -0.03296749f, -0.06393404f, -0.30290425f, -0.06639846f, -0.06328473f, 0.26243070f, 
    0.19176678f, 0.32596308f, 0.47227713f, 0.23953906f, -0.10597189f, 0.01683467f, -0.15979299f, 0.18482713f, 
    0.00260873f, 0.13496798f, 0.12790798f, -0.10254335f, 0.19662839f, 0.30775514f, -0.16717437f, 0.08887230f, 
    0.01593914f, 0.11194009f, -0.08377959f, 0.03391555f, 0.05732631f, 0.00035429f, -0.01480629f, -0.28778857f, 
    -0.02607986f, -0.04991558f, -0.08110417f, -0.32836568f, -0.13909765f, 0.05969376f, -0.08303905f, -0.04957117f, 
    -0.04599776f, -0.02082298f, -0.06525628f, 0.13780648f, -0.10504374f, 0.11461213f, -0.15197821f, -0.21667181f, 
    0.20650096f, 0.05459232f, 0.11332051f, 0.07777564f, 0.22111510f, 0.34621376f, 0.30622083f, -0.35851592f, 
    -0.23883326f, 0.11813810f, -0.11755697f, 0.14290184f, 0.08394589f, 0.19439103f, 0.14589196f, -0.07430063f, 
    -0.12364531f, 0.08698715f, 0.03864783f, 0.22430116f, 0.15452807f, 0.03532043f, -0.00241804f, -0.11863595f, 
    -0.01337784f, -0.10700598f, -0.06133831f, -0.07469486f, 0.16823691f, 0.06247804f, 0.14574534f, -0.19084351f, 
    0.44214246f, 0.12704600f, 0.09056406f, -0.13551049f, -0.48404428f, 0.18471746f, -0.01790214f, -0.30552244f, 
    -0.09917518f, -0.08969101f, -0.11326265f, 0.12419483f, -0.10681274f, 0.16437602f, -0.19485894f, -0.03964050f, 
    0.04192505f, 0.21575759f, 0.02272854f, -0.10282502f, -0.32665259f, 0.02829303f, -0.22920781f, -0.03674908f, 
    0.00172737f, 0.22103792f, 0.30012858f, -0.02671247f, 0.09967979f, 0.05428910f, -0.09880195f, 0.01289287f, 
    -0.33605680f, -0.04626826f, -0.04807782f, 0.05207760f, -0.05573021f, 0.18424988f, -0.05731644f, -0.22022265f, 
    0.07719248f, 0.54823637f, 0.11428916f, -0.15563186f, 0.01436603f, -0.16112062f, -0.26808527f, -0.12155333f, 
    0.10254058f, -0.11812727f, 0.14550062f, -0.07269031f, 0.71500051f, -0.08154821f, 0.31873488f, 0.11339164f, 
    0.17998073f, 0.13305488f, 0.12516633f, 0.28285706f, -0.07781857f, 0.08621751f, -0.10930201f, -0.05278212f, 
    -0.05403357f, 0.02671431f, -0.15089047f, -0.12826578f, -0.01339242f, 0.16380683f, 0.10835633f, -0.31822667f, 
    0.10076669f, -0.15882033f, -0.03478136f, 0.01310765f, 0.01936133f, -0.18011512f, -0.14166124f, -0.03022912f, 
    0.04634824f, 0.27953848f, -0.06526524f, -0.21397130f, 0.40230325f, 0.10276812f, 0.00696781f, 0.04695907f, 
    -0.14189456f, -0.06025149f, 0.24576777f, -0.17220683f, 0.14003973f, 0.13860275f, -0.17245540f, 0.21601130f, 
    -0.01107522f, -0.05769673f, -0.12526783f, -0.12202632f, 0.20837003f, -0.26517862f, 0.23871580f, 0.20982164f, 
    0.07701872f, 0.02141521f, 0.06492400f, -0.01701645f, -0.07758166f, -0.09517436f, 0.23699763f, 0.04840586f, 
    0.07817965f, 0.00450954f, -0.05477766f, -0.01406084f, 0.55885684f, 0.00360113f, 0.52043885f, 0.31141907f, 
    -0.43222278f, -0.31848568f, 0.13567701f, 0.09955398f, -0.01183893f, 0.06409204f, 0.04918539f, -0.13631628f, 
    -0.00407443f, 0.00653643f, 0.12185814f, -0.10890101f, 0.16913196f, 0.14574116f, -0.18835163f, 0.11766854f, 
    -0.01635601f, -0.10203161f, -0.08734638f, -0.03879327f, -0.04491712f, 0.17022289f, -0.12192670f, 0.08509310f, 
    -0.10543729f, -0.14152479f, -0.07452083f, -0.15591279f, 0.17982602f, -0.08041859f, -0.08739407f, -0.21941811f, 
    -0.10434724f, 0.13684765f, -0.08160812f, -0.17923683f, -0.00207751f, 0.03642141f, 0.12042794f, -0.05384922f, 
    0.04802074f, -0.14542204f, 0.05801940f, 0.08847686f, 0.19236644f, 0.23238620f, -0.30784220f, 0.14027508f, 
    0.37471399f, -0.31676582f, -0.33222207f, 0.07238933f, 0.04873252f, -0.20369904f, -0.09642795f, 0.16481014f, 
    0.14031623f, 0.05024602f, 0.37769985f, -0.10969453f, 0.07559417f, 0.14532858f, 0.53596717f, 0.16439177f, 
    -0.19727133f, -0.07418907f, 0.28037277f, -0.33698273f, 0.01220412f, 0.13129598f, -0.04572409f, 0.25570264f, 
    -0.17298828f, -0.07390033f, -0.28959140f, -0.04790648f, -0.30024555f, 0.08581080f, 0.10295001f, -0.33675942f, 
    0.16818228f, 0.08043604f, -0.06348643f, 0.07197897f, -0.15014812f, -0.02513550f, -0.29375955f, -0.10939711f, 
    -0.11124070f, 0.23890820f, 0.01521200f, -0.18817313f, 0.22086039f, -0.09903377f, -0.03664574f, 0.11996822f, 
    0.01401990f, 0.27630553f, 0.26903388f, -0.13877347f, 0.01268339f, -0.13394363f, 0.00542513f, 0.08668844f, 
    0.22510833f, -0.29761192f, -0.12645817f, 0.08083480f, 0.06315678f, 0.38082406f, 0.19911844f, -0.25786060f, 
    -0.36208332f, 0.01641700f, -0.02648024f, 0.10847082f, -0.15200333f, -0.01501228f, 0.28074887f, -0.12546577f, 
    0.00161040f, 0.21178420f, 0.07564658f, 0.00993882f, 0.27413160f, 0.09627464f, 0.07751311f, 0.01546353f, 
    0.44506210f, 0.00677733f, 0.03156333f, -0.16059183f, 0.02623997f, -0.00615944f, 0.01839495f, 0.15779345f, 
    -0.10256988f, -0.00558485f, 0.06118283f, -0.17360470f, 0.16379426f, 0.05181993f, 0.24193843f, -0.00669379f, 
    0.24092130f, -0.02420023f, 0.13405074f, -0.07028821f, -0.05620820f, 0.02539408f, 0.24365835f, -0.14669672f, 
    0.13841297f, -0.24602328f, 0.08676632f, 0.08106528f, -0.10810708f, -0.10070330f, 0.00841446f, 0.06133140f, 
    0.12894636f, -0.27387705f, 0.26431543f, 0.19432801f, 0.16392523f, 0.17830749f, -0.10128824f, -0.13148844f, 
    0.00684050f, -0.07801794f, -0.01037006f, 0.14309332f, 0.39170712f, -0.13921359f, 0.18324094f, -0.19137278f, 
    0.01926122f, 0.16085844f, -0.51282626f, 0.10670155f, 0.04366374f, 0.01780117f, 0.16541955f, -0.09292673f, 
    0.04717877f, 0.11672810f, -0.02428378f, 0.04247014f, -0.14848480f, 0.12395767f, -0.07879377f, 0.09295560f, 
    -0.24437200f, 0.27140445f, 0.06414374f, -0.02785367f, 0.32103363f, 0.13168062f, 0.14641689f, 0.21239690f, 
    0.16089214f, 0.18980789f, 0.12740873f, 0.05634808f, 0.12740593f, -0.13763379f, 0.10447029f, -0.07243315f, 
    0.21688835f, -0.49877682f, -0.00518109f, -0.04604037f, -0.00893199f, -0.08695377f, 0.28543150f, -0.07076634f, 
    -0.06563567f, -0.12026357f, -0.09107768f, 0.06064106f, 0.48909804f, -0.15527877f, 0.08061343f, 0.07407661f, 
    0.01410159f, -0.01557924f, 0.09508658f, 0.11899115f, -0.04758401f, -0.07764579f, -0.02743429f, -0.14010432f, 
    -0.21375936f, -0.20372500f, -0.21176302f, -0.06974397f, 0.31350651f, -0.22727905f, -0.03406072f, -0.04267166f, 
    -0.03746058f, 0.11148481f, -0.39848161f, -0.16652337f, 0.03576729f, 0.00746601f, -0.10492764f, 0.28050089f, 
    0.12775120f, -0.13026100f, 0.34058857f, 0.21871442f, 0.07353629f, 0.00869405f, 0.11004855f, 0.31964093f, 
    -0.28400135f, -0.25214094f, -0.23934191f, -0.06596588f, 0.07473385f, 0.09206665f, -0.05958270f, -0.04142573f, 
    0.27673268f, -0.00653166f, 0.16473904f, -0.13538495f, 0.19411087f, -0.41376054f, 0.07630673f, 0.17319423f, 
    -0.19538769f, -0.12279480f, 0.12784219f, -0.05571855f, -0.11990494f, -0.20049968f, 0.18499526f, 0.30076668f, 
    0.04396277f, -0.00744836f, -0.31402588f, 0.17389067f, -0.09052181f, 0.05763630f, 0.24921571f, 0.01493412f, 
    -0.20132312f, 0.04841468f, -0.03879289f, 0.10477250f, 0.27259448f, 0.04635728f, -0.12241618f, -0.23214594f, 
    -0.30556425f, 0.14192532f, 0.02981450f, 0.13618155f, 0.34224799f, -0.11709166f, -0.23111826f, -0.02906600f, 
    -0.14383504f, 0.17669861f, 0.17290594f, 0.05537046f, 0.13039681f, -0.08492766f, 0.30559295f, -0.03472599f, 
    0.11646505f, -0.09581194f, -0.10024333f, 0.16941853f, 0.36891094f, 0.10193519f, -0.06310054f, -0.03816466f, 
    0.29593623f, 0.24017906f, 0.35460889f, -0.07116188f, 0.06800678f, 0.11239123f, -0.03387385f, -0.10433512f, 
    -0.13145274f, -0.32771802f, -0.05605797f, -0.06330469f, -0.05664062f, -0.32779694f, 0.04156761f, -0.12940766f, 
    -0.34826887f, 0.45306444f, -0.02766954f, -0.16182080f, -0.02016343f, -0.00903169f, -0.26423374f, 0.21875237f, 
    0.16636431f, 0.24659523f, 0.05648140f, -0.04518586f, 0.05126740f, 0.04299115f, -0.20122249f, 0.23227732f, 
    -0.33043385f, 0.09141861f, -0.06479098f, -0.37325236f, 0.19766781f, 0.15002151f, 0.07539564f, 0.12417641f, 
    0.00834454f, 0.03144101f, 0.18990944f, 0.02929573f, -0.07772736f, -0.22832876f, -0.04225537f, 0.32852075f, 
    0.17617796f, -0.37292430f, -0.01758901f, 0.06151297f, -0.02059223f, -0.25220039f, 0.19763890f, 0.08867549f, 
    -0.15853989f, -0.30984768f, -0.38151845f, 0.13896993f, -0.03322154f, -0.06689799f, 0.22088878f, 0.06123553f, 
    -0.15694271f, 0.26659814f, 0.39085633f, -0.13453925f, -0.24250954f, -0.12764192f, 0.16009539f, 0.19096938f, 
    -0.21570976f, -0.17859644f, 0.17074783f, -0.11166894f, -0.23673415f, -0.23818812f, 0.33060521f, 0.17125462f, 
    0.11584205f, 0.19732337f, 0.32986051f, 0.08970622f, -0.08990984f, 0.05591881f, 0.35366079f, -0.15528058f, 
    0.12234667f, -0.10783882f, 0.27454695f, -0.04363161f, 0.21475433f, -0.11759526f, -0.12825267f, 0.19137144f, 
    0.12877758f, 0.00919869f, 0.10906246f, 0.20746540f, 0.04852228f, 0.03965266f, -0.07871692f, -0.00673042f, 
    -0.20378163f, -0.01516844f, 0.16816905f, -0.09797964f, 0.44135404f, -0.27006724f, 0.24339823f, 0.00610875f, 
    -0.24465337f, -0.16015847f, -0.30812579f, -0.13651769f, 0.12756537f, 0.07816364f, 0.35545278f, -0.12190820f, 
    -0.06390149f, 0.16251618f, -0.22045250f, 0.11379696f, 0.00870684f, 0.02185287f, -0.04340617f, -0.06443580f, 
    -0.36723062f, 0.26720580f, -0.41346708f, 0.00906683f, 0.23235150f, -0.15224949f, 0.07567778f, 0.01719113f, 
    -0.31628099f, 0.12938395f, 0.29078242f, 0.16154251f, 0.14138502f, -0.19240534f, 0.12933637f, 0.07460531f, 
    0.25677386f, -0.28160572f, -0.19265179f, 0.15637873f, 0.13161105f, -0.45402116f, 0.13135217f, 0.06952455f, 
    -0.01569904f, -0.31509292f, -0.10568426f, 0.27895793f, -0.39925840f, -0.17043635f, 0.10842235f, 0.06162804f, 
    0.06280752f, 0.08885077f, 0.15053783f, 0.26281664f, -0.11475478f, -0.00699501f, -0.11719622f, -0.12071519f, 
    -0.05185089f, 0.09979188f, -0.22638585f, 0.13397798f, 0.24106152f, 0.28093985f, 0.00578922f, -0.44594935f, 
    -0.13074791f, 0.04888790f, 0.11700069f, 0.08055394f, -0.12801407f, -0.05310883f, 0.07349118f, 0.04799896f, 
    -0.15283807f, -0.11080670f, -0.18924689f, -0.28186974f, 0.36390871f, 0.02254705f, -0.12591538f, 0.31771052f, 
    0.10939082f, -0.09519579f, 0.26792467f, -0.13488616f, -0.10434147f, 0.01482574f, 0.04092480f, -0.19041419f, 
    0.10465866f, -0.04393599f, -0.25337547f, -0.06145209f, -0.08437344f, 0.10061909f, -0.32252896f, -0.12362602f, 
    0.08288870f, 0.26893139f, -0.06502596f, 0.10858569f, 0.05989973f, 0.09393064f, -0.23208366f, 0.13594875f, 
    -0.06243910f, 0.30165008f, 0.27224472f, -0.03538977f, 0.03783193f, 0.04112066f, 0.40934539f, 0.23427744f, 
    -0.44272622f, -0.19379528f, 0.27240416f, 0.18829407f, -0.00437377f, -0.06838503f, 0.12097706f, -0.10705973f, 
    0.16140418f, 0.19425334f, 0.26199922f, 0.16143426f, 0.53804547f, -0.24030815f, -0.06177302f, -0.09109037f, 
    -0.15291496f, 0.13227275f, -0.03271367f, -0.16467163f, 0.10116059f, -0.20861825f, 0.34164622f, 0.28772834f, 
    -0.09691577f, -0.17100628f, -0.14947237f, -0.12711507f, -0.14946048f, -0.07730331f, -0.28379300f, 0.30502361f, 
    -0.11039758f, 0.18521966f, -0.11396945f, 0.24853991f, 0.00178310f, 0.00614387f, 0.13949490f, 0.20250842f, 
    -0.01130252f, -0.06766600f, -0.15896972f, 0.02573232f, -0.04628432f, -0.16831103f, -0.17544858f, -0.11505511f, 
    -0.09192339f, 0.08851211f, -0.01546467f, 0.13543296f, 0.14069425f, -0.15674283f, 0.04314729f, -0.11412784f, 
    0.01552134f, -0.04194785f, 0.14753328f, -0.17069775f, -0.06278319f, 0.15778001f, -0.00304074f, -0.04331436f, 
    -0.17812525f, -0.17231373f, -0.01546578f, -0.07414149f, 0.17259948f, -0.14624326f, -0.14611091f, 0.04093390f, 
    0.08166537f, -0.16100322f, 0.04136084f, 0.14918940f, 0.14035231f, -0.19887403f, -0.18704420f, 0.19129540f, 
    -0.28006768f, 0.15599939f, 0.04623943f, 0.08828376f, 0.11511545f, -0.16692930f, 0.08987682f, -0.13182773f, 
    -0.16130869f, 0.17212567f, -0.06677961f, -0.31055760f, -0.08333915f, 0.08311139f, -0.13380699f, 0.01216049f, 
    0.18666455f, 0.10923430f, 0.26476693f, -0.30709565f, -0.01934173f, 0.11929766f, 0.14325033f, -0.02838622f, 
    0.02240914f, -0.12431645f, 0.05083526f, 0.13320976f, 0.24809931f, -0.31762588f, 0.37186444f, -0.03680321f, 
    0.17773879f, -0.18165405f, -0.36512300f, 0.14156860f, -0.16579287f, -0.14722039f, 0.29799798f, 0.05965118f, 
    -0.12721953f, 0.03241773f, -0.16489966f, 0.20656212f, -0.07962462f, 0.15590595f, 0.03777338f, 0.13883585f, 
    -0.51606792f, -0.03279708f, -0.05094050f, 0.26779804f, 0.22797489f, 0.00055493f, -0.10372852f, 0.19688317f, 
    0.25321853f, -0.16717596f, -0.28985831f, -0.00739499f, -0.16463444f, 0.36422423f, -0.09156739f, -0.30946177f, 
    0.24132666f, 0.33371460f, -0.62893301f, -0.15637593f, 0.01405340f, 0.13190922f, -0.17220145f, 0.00600813f, 
    -0.13041493f, 0.16855216f, 0.18298760f, 0.05304304f, -0.13695107f, -0.07476332f, -0.00217665f, 0.10825630f, 
    -0.00660637f, -0.20952062f, 0.63142961f, 0.02836058f, 0.08503374f, -0.10812622f, 0.01979136f, -0.08358168f, 
    0.43111739f, 0.11630748f, -0.09876185f, 0.09027375f, -0.16052470f, 0.19509260f, -0.08604138f, -0.13829920f, 
    0.05044149f, -0.43530077f, 0.02855151f, 0.09620430f, -0.09001961f, 0.04618435f, -0.13712040f, 0.01496031f, 
    0.02674542f, -0.07005563f, -0.10028758f, -0.41462207f, 0.24938674f, 0.09742178f, 0.23543501f, 0.29105780f, 
    -0.01952281f, -0.27795407f, 0.19734356f, 0.07579311f, -0.08292503f, 0.00326598f, 0.07473215f, -0.05044255f, 
    0.11648641f, -0.29395288f, 0.01351156f, -0.07064562f, -0.03246674f, 0.00336179f, -0.08560114f, -0.22165826f, 
    -0.45041469f, -0.01388719f, 0.09218873f, 0.07837768f, -0.07154059f, -0.30144954f, -0.13476582f, 0.26170117f, 
    0.14480543f, 0.31903258f, -0.15671460f, -0.15975989f, 0.49398360f, -0.06044138f, 0.21512237f, 0.17336118f, 
    0.08447398f, 0.10037938f, -0.05899602f, -0.16946931f, 0.20678799f, -0.07741691f, 0.08643400f, 0.13433415f, 
    -0.13444816f, 0.22854701f, 0.24599077f, 0.13999078f, 0.12205022f, -0.17881899f, -0.33796510f, 0.34545395f, 
    -0.09163405f, -0.03333365f, 0.06332100f, 0.16057764f, -0.00720339f, -0.21474017f, -0.06451062f, 0.23337704f, 
    0.13133527f, -0.18379900f, 0.10547473f, 0.03622679f, -0.04677208f, 0.11110268f, 0.41340292f, 0.09861346f, 
    -0.13833828f, 0.01994122f, 0.08486374f, 0.23683701f, -0.05551760f, -0.15116049f, -0.00236047f, 0.18239327f, 
    -0.05571107f, -0.33822787f, 0.10956393f, -0.03806267f, -0.12014165f, -0.27355644f, 0.46351472f, 0.01992579f, 
    -0.02118445f, 0.25983036f, -0.42731133f, 0.05860895f, 0.08222178f, -0.14721316f, 0.23217510f, -0.09149700f, 
    0.03770443f, 0.17530298f, 0.20627996f, 0.31884491f, 0.22682180f, -0.08276844f, 0.04740471f, 0.29027259f, 
    -0.48722842f, -0.11365259f, -0.20087752f, 0.27217612f, -0.05656650f, -0.15482837f, 0.13078308f, -0.14998747f, 
    -0.18129420f, 0.07110781f, -0.21598999f, 0.00078051f, 0.15728690f, 0.11044665f, -0.11751530f, 0.16657080f, 
    0.16708691f, 0.24495044f, -0.18634988f, 0.07592353f, 0.03976110f, -0.06352607f, -0.29195464f, 0.16503511f, 
    0.05479490f, 0.15277630f, 0.10932408f, 0.09065033f, 0.00872400f, -0.13587844f, -0.02659636f, -0.19828393f, 
    -0.30470189f, -0.14182392f, 0.03065442f, -0.12700252f, 0.18211791f, -0.04096389f, 0.11222485f, 0.15314484f, 
    0.22424990f, -0.01699927f, 0.09596146f, 0.12621260f, 0.14384006f, -0.11169405f, 0.19682647f, 0.16446751f, 
    -0.17047229f, -0.05079148f, -0.29336560f, -0.10783102f, -0.05835050f, -0.01945931f, 0.13043225f, -0.05704356f, 
    0.01407981f, 0.20554546f, 0.03542724f, 0.12390748f, -0.44732273f, -0.17001079f, -0.15197338f, 0.25153744f, 
    0.01408085f, 0.38992476f, 0.20184077f, 0.25672430f, 0.16576736f, -0.16065474f, -0.16966084f, -0.09801035f, 
    -0.15809786f, -0.26193127f, -0.08561590f, 0.18514684f, -0.05210840f, -0.07731396f, -0.16749269f, 0.02189635f, 
    0.14771029f, 0.27927855f, -0.03967350f, -0.11533573f, 0.15961990f, -0.07664658f, -0.27558279f, 0.16132532f, 
    -0.01458874f, 0.15428740f, 0.10709510f, 0.06587297f, 0.23587862f, -0.11439240f, 0.32663858f, 0.20980084f, 
    -0.36293450f, 0.05464879f, 0.01090759f, -0.08034856f, 0.01160911f, 0.09093650f, 0.11424911f, -0.02419497f, 
    -0.06677916f, -0.18977028f, -0.26658353f, 0.12317817f, 0.13708574f, 0.04836578f, -0.04167587f, 0.30647826f, 
    -0.13848804f, 0.50178659f, 0.16016605f, 0.16753531f, 0.01847310f, -0.10701323f, 0.22048093f, -0.19099739f, 
    0.07630232f, 0.11561080f, -0.05819970f, -0.20768723f, 0.36848617f, -0.08256976f, -0.07626291f, -0.04045368f, 
    -0.03765270f, 0.04397611f, 0.08718819f, -0.26067933f, 0.05047408f, 0.09764145f, 0.02739378f, 0.15672244f, 
    -0.04135286f, 0.18218939f, 0.07795279f, -0.09495390f, 0.16699736f, 0.31833568f, -0.06156946f, -0.19362973f, 
    -0.15639405f, 0.33703649f, -0.02724739f, -0.16766264f, 0.10029312f, 0.17647079f, -0.29526147f, 0.22807261f, 
    -0.10147138f, -0.05118613f, 0.18431424f, 0.20348491f, 0.01392055f, -0.14077647f, 0.31713447f, -0.11265635f, 
    0.27791351f, -0.19056086f, 0.13783328f, 0.10075346f, 0.11321410f, -0.12762289f, -0.13283287f, 0.06173255f, 
    0.15380865f, 0.06947366f, 0.02667196f, 0.03160582f, 0.41315910f, -0.06260564f, -0.09255635f, 0.34617344f, 
    -0.07662591f, -0.00782001f, -0.16600530f, 0.16127606f, -0.01156537f, -0.03753896f, 0.02334413f, -0.04119904f, 
    0.11701988f, 0.03278112f, -0.05120016f, 0.33110225f, -0.15316144f, 0.17224894f, 0.20506066f, 0.03478296f, 
    -0.20226544f, -0.12984622f, -0.12651841f, 0.01416756f, 0.02437132f, -0.16271897f, 0.00469373f, -0.09631176f, 
    0.03530402f, -0.16692676f, 0.03856221f, 0.08601767f, 0.03509867f, -0.14397454f, 0.10494434f, -0.00544489f, 
    0.04206813f, 0.13545355f, -0.21383972f, -0.06690184f, -0.17428917f, 0.00134893f, -0.10987219f, -0.10024349f, 
    -0.15455003f, 0.00867719f, -0.12223262f, 0.04514949f, -0.07949617f, -0.09322988f, -0.05077824f, -0.20543250f, 
    -0.10001501f, -0.18663266f, 0.16423044f, -0.13761906f, 0.03837864f, -0.02148164f, 0.13087903f, -0.09881823f, 
    -0.02488314f, -0.15081711f, -0.16981335f, 0.11196847f, -0.00812711f, -0.11314100f, 0.06749493f, 0.00930709f, 
    -0.17669934f, 0.12786944f, 0.16108730f, 0.17087540f, -0.11889444f, -0.05491987f, 0.01632762f, -0.11157779f, 
    0.17133038f, -0.14301360f, -0.09016684f, 0.14636448f, 0.04699989f, -0.12760369f, -0.00628424f, 0.04818071f, 
    0.07163095f, -0.07672177f, -0.01799078f, -0.23611203f, 0.09594766f, 0.15385972f, -0.16808769f, -0.16767576f, 
    -0.07498101f, -0.25271609f, 0.08124060f, 0.07219539f, -0.39810085f, -0.11873414f, -0.13964514f, 0.00011355f, 
    0.11458689f, 0.27467486f, -0.07355420f, -0.11863505f, -0.05714782f, 0.17044194f, -0.27640808f, 0.00109552f, 
    0.16619684f, 0.04181840f, 0.24450435f, 0.17093602f, -0.10193497f, 0.10846382f, 0.20398332f, 0.28367713f, 
    0.00183116f, 0.19747609f, 0.41664937f, -0.11726876f, -0.03223041f, -0.11615035f, -0.15527089f, -0.13867159f, 
    0.40595630f, 0.19126450f, -0.19426884f, 0.06634561f, 0.01051147f, 0.43254799f, -0.12287162f, -0.40455863f, 
    0.04354900f, -0.16103643f, -0.07441017f, -0.04008161f, -0.06789834f, -0.08611512f, -0.18866068f, 0.21610512f, 
    0.14910513f, -0.04214619f, -0.27139929f, -0.22962867f, 0.19110461f, -0.10064421f, 0.11259022f, 0.15281434f, 
    0.31802413f, -0.15565045f, 0.11519731f, 0.02851116f, -0.17730065f, 0.12926577f, -0.14871179f, -0.21560808f, 
    0.01121903f, 0.07596438f, -0.06111202f, 0.02596309f, 0.16201989f, 0.16049711f, -0.16151828f, 0.11984679f, 
    -0.32858664f, 0.32378951f, -0.19488724f, -0.15274292f, 0.07826295f, 0.06134168f, -0.41578636f, 0.02780562f, 
    -0.02810230f, 0.20158149f, -0.03504714f, -0.05263287f, -0.46921596f, 0.14336169f, -0.16848180f, 0.19755346f, 
    0.08261188f, 0.33613560f, 0.32895544f, -0.16178612f, 0.24299607f, 0.09697053f, -0.05377836f, -0.16178247f, 
    0.39694750f, -0.04150379f, -0.26013216f, 0.03302990f, -0.12475334f, 0.05681088f, 0.23540971f, -0.11132378f, 
    -0.31168982f, 0.25391838f, -0.28702176f, -0.16362923f, -0.04574062f, 0.14448984f, -0.27160898f, -0.05339450f, 
    0.16171487f, 0.16662031f, 0.27101088f, 0.14446327f, -0.30034095f, -0.01064681f, -0.36324394f, 0.19495839f, 
    0.36264420f, -0.15203305f, 0.23827916f, -0.11697061f, 0.15646443f, -0.13040312f, 0.15122013f, -0.09941485f, 
    -0.20789376f, 0.05412198f, -0.13011149f, -0.13627701f, 0.24656293f, 0.08086082f, 0.29487807f, -0.16122685f, 
    -0.10269009f, 0.32653761f, 0.16437396f, -0.09718329f, 0.05716198f, 0.14759949f, 0.18434459f, -0.12647185f, 
    -0.05181039f, -0.05934313f, -0.08809966f, 0.00804551f, -0.00291151f, 0.00266068f, -0.38341597f, 0.08893239f, 
    -0.05411395f, 0.23026544f, 0.21635748f, -0.27592626f, 0.18717605f, -0.04254065f, -0.06211881f, 0.03486782f, 
    0.22479285f, -0.11542790f, -0.04907845f, -0.05328814f, -0.18189961f, 0.22870520f, -0.00788639f, -0.26982778f, 
    0.10860482f, -0.21225172f, -0.04272942f, -0.11783999f, 0.03328694f, 0.08947372f, -0.28888750f, 0.10617840f, 
    0.12689449f, 0.21719995f, -0.04894919f, -0.01729288f, 0.39476767f, -0.13358673f, 0.16018297f, 0.05844579f, 
    -0.16171087f, 0.10964441f, 0.18975839f, -0.25442824f, 0.19137453f, -0.09594759f, 0.05892484f, 0.00196514f, 
    -0.18154086f, -0.25702417f, -0.18798369f, 0.06806985f, -0.07834467f, 0.06226633f, 0.12373857f, -0.22870170f, 
    -0.22498435f, 0.55375588f, -0.66116065f, 0.13159586f, -0.09553220f, 0.01635497f, -0.20627856f, -0.12928194f, 
    0.11556543f, 0.14800328f, 0.54229069f, 0.09622984f, 0.12526643f, -0.06747474f, -0.00591512f, 0.26045799f, 
    0.07221028f, 0.15356772f, -0.08987018f, -0.32537183f, 0.22372583f, -0.13510506f, 0.01526175f, -0.05376077f, 
    -0.19184586f, 0.05913037f, 0.30046397f, -0.11745770f, 0.05848043f, 0.00110730f, -0.01642539f, 0.12148654f, 
    0.09435452f, -0.33472237f, 0.04404049f, 0.06559917f, -0.14862093f, -0.19928725f, 0.12292700f, -0.01300124f, 
    0.04913356f, -0.31320271f, 0.05072322f, -0.16571943f, 0.18864393f, -0.08425538f, 0.23889308f, 0.15520050f, 
    0.30946529f, 0.03449180f, 0.28517154f, 0.13470583f, 0.14531180f, 0.02536510f, -0.16509996f, -0.09961995f, 
    0.02408061f, -0.19588277f, 0.16831528f, -0.14636622f, 0.01236337f, 0.18331525f, -0.08254696f, 0.13188271f, 
    0.01991258f, -0.06034787f, -0.31191075f, 0.11935278f, -0.15138619f, -0.07586887f, -0.31872681f, -0.05398470f, 
    -0.08079135f, 0.26482263f, 0.23799285f, 0.31241053f, 0.21380290f, 0.02083892f, 0.65975749f, 0.08954687f, 
    -0.16132119f, -0.12031877f, -0.09957533f, -0.06078316f, 0.10836806f, -0.17426376f, -0.16702189f, -0.06451672f, 
    -0.04842793f, -0.08561639f, 0.14922461f, -0.03300545f, 0.02715278f, 0.02447843f, -0.15470687f, -0.11788376f, 
    -0.04345469f, 0.01437064f, -0.02154870f, -0.00365873f, -0.03219031f, 0.07005154f, 0.15093511f, -0.12510331f, 
    0.00746886f, -0.05399180f, -0.11900848f, -0.05491886f, -0.05931611f, -0.14794658f, -0.00635548f, -0.12412587f, 
    0.06604984f, -0.08654128f, 0.14219375f, -0.16696586f, -0.05278018f, 0.16596743f, -0.05398358f, -0.17744376f, 
    -0.09126142f, -0.09606938f, 0.23420160f, -0.06882762f, -0.03426514f, -0.22083427f, 0.06892545f, 0.23403928f, 
    -0.00005269f, -0.03472310f, 0.20678931f, 0.08385342f, -0.02130234f, -0.18168664f, -0.29785803f, 0.40329415f, 
    0.10168464f, 0.11913006f, -0.05353204f, 0.17883225f, -0.52952766f, 0.12011091f, 0.13714847f, 0.23025362f, 
    0.23435050f, 0.37679556f, 0.00429802f, -0.08644734f, -0.15239224f, 0.14457226f, -0.11550181f, -0.05302507f, 
    0.17808597f, -0.44050002f, -0.22191276f, -0.18351199f, -0.40208307f, -0.12893097f, 0.01555795f, -0.14437889f, 
    0.18878062f, 0.44060275f, -0.46492630f, 0.16412790f, -0.16778056f, -0.01314473f, -0.30924073f, 0.03310365f, 
    -0.06183709f, 0.22477058f, 0.18991564f, 0.08112145f, -0.12986241f, -0.13064292f, 0.00191760f, 0.29159686f, 
    -0.16374950f, 0.13874860f, 0.11400548f, -0.02891529f, -0.01282055f, 0.10501080f, -0.05884004f, -0.00280636f, 
    -0.29216868f, -0.20277742f, 0.08127221f, 0.05667615f, 0.20753464f, -0.18431090f, -0.00030413f, -0.06589919f, 
    -0.06683577f, 0.11074302f, 0.18481232f, -0.14457768f, -0.15812238f, -0.26075268f, 0.12722023f, -0.04921525f, 
    -0.09033064f, 0.14829104f, -0.25577393f, -0.18716276f, -0.02419367f, 0.15093857f, -0.16337954f, 0.19144402f, 
    0.10054093f, 0.16208781f, 0.14459421f, -0.09552544f, 0.20204911f, -0.00402494f, 0.03384832f, -0.08196019f, 
    -0.18172683f, -0.16297950f, -0.10581877f, -0.08019345f, -0.15775295f, -0.43801731f, 0.35314038f, 0.16339652f, 
    0.02751634f, 0.28851768f, 0.14673455f, -0.07263058f, 0.17411038f, -0.02057567f, 0.22526346f, -0.13904053f, 
    0.02173227f, 0.01255822f, -0.20087691f, 0.07326543f, 0.26387665f, -0.06696416f, -0.44631183f, -0.06300379f, 
    -0.46680233f, 0.19702442f, -0.16149962f, -0.07619579f, 0.16124271f, 0.00331775f, -0.08592235f, 0.28310248f, 
    0.11965676f, -0.27407986f, -0.22211990f, -0.03338803f, 0.01738379f, -0.00183644f, 0.08045024f, -0.11821689f, 
    -0.10976071f, 0.11420648f, -0.11485023f, 0.10547666f, -0.17640321f, 0.15036727f, -0.33324081f, 0.11597817f, 
    0.16143483f, 0.34418216f, -0.05442500f, 0.24558581f, -0.25985363f, -0.17252295f, -0.05258118f, 0.20055141f, 
    -0.01785535f, -0.16809157f, -0.00121990f, -0.08457979f, 0.20884126f, 0.15503196f, 0.13875484f, -0.21343209f, 
    -0.35978600f, -0.23089324f, -0.07750259f, 0.02732742f, -0.09589332f, 0.09740435f, 0.04867356f, -0.22778721f, 
    0.16555806f, 0.37265301f, -0.24341576f, -0.00362295f, 0.15868501f, -0.22809501f, -0.28185675f, 0.04088005f, 
    0.06841242f, 0.06892384f, 0.29505876f, -0.08080889f, 0.14790323f, -0.17072211f, 0.01169038f, 0.24250551f, 
    0.15124653f, 0.03437903f, 0.20279169f, -0.07976836f, -0.14562905f, 0.12048428f, -0.08439252f, 0.10109171f, 
    0.05778943f, -0.03939997f, 0.19989932f, -0.12451919f, 0.19339915f, -0.08413024f, -0.18455496f, 0.28791666f, 
    0.29939297f, -0.20641015f, -0.20424688f, -0.06993821f, 0.02261983f, -0.27951136f, 0.22315438f, 0.00550282f, 
    0.02229992f, 0.11048878f, 0.12284328f, 0.04592600f, 0.26187688f, -0.17825411f, 0.30122235f, 0.14399806f, 
    -0.13067317f, -0.06686530f, 0.18036696f, 0.11982659f, -0.30234492f, 0.12602466f, -0.07058784f, 0.00110494f, 
    -0.12983282f, 0.10849828f, 0.10759855f, -0.10509580f, 0.14253645f, 0.00890815f, -0.09133771f, 0.05532805f, 
    -0.05235852f, 0.38894749f, 0.03957352f, 0.01178608f, 0.01024752f, -0.08342472f, -0.19971438f, -0.06228158f, 
    -0.15108104f, 0.21321918f, 0.28858733f, 0.35029528f, 0.21715339f, 0.17626664f, 0.26340705f, -0.07249093f, 
    0.12565149f, 0.05478868f, -0.04781517f, 0.02077875f, 0.16324008f, 0.07899405f, -0.16215152f, -0.25056139f, 
    0.28974521f, 0.07875643f, 0.23764852f, -0.01677027f, -0.17530246f, 0.29780346f, -0.04893844f, -0.13169093f, 
    -0.10426738f, 0.00949322f, -0.32914558f, 0.09410246f, -0.05508991f, -0.23466948f, -0.05808583f, -0.00282672f, 
    -0.10971944f, -0.22045542f, 0.28982696f, 0.00370358f, -0.19646160f, 0.14927293f, 0.16491033f, 0.03456710f, 
    0.24538670f, 0.01220878f, 0.40970162f, 0.05253733f, -0.07373650f, 0.17675477f, -0.15903321f, -0.01906726f, 
    -0.27595729f, -0.08440980f, 0.11443905f, 0.15136871f, 0.02536425f, 0.09122383f, -0.14893468f, -0.17681341f, 
    -0.01703643f, 0.43675473f, -0.31397882f, -0.00872878f, 0.10398278f, -0.29762077f, -0.14844796f, 0.30327308f, 
    0.05315358f, -0.28333431f, 0.53301227f, -0.07964011f, 0.02666380f, -0.03536325f, -0.12069140f, 0.20489374f, 
    -0.14764892f, -0.10774036f, 0.15329860f, 0.48470691f, -0.10434879f, -0.13380340f, -0.14381720f, 0.14814816f, 
    0.17040086f, -0.16372755f, 0.08228918f, 0.12268631f, -0.05326145f, 0.54098016f, -0.20966595f, -0.52545440f, 
    0.03941470f, 0.16686378f, 0.06097681f, -0.03097719f, -0.10784949f, -0.07209873f, -0.46460515f, -0.06933563f, 
    0.15303430f, -0.12832549f, 0.00398079f, 0.09679609f, 0.04947925f, 0.12816572f, 0.16151819f, 0.16068654f, 
    0.47328374f, -0.05152486f, 0.23240256f, -0.08054968f, -0.00157201f, -0.15533946f, -0.11769235f, 0.06452976f, 
    0.19235584f, 0.16736524f, 0.17773692f, -0.12254019f, 0.45863953f, 0.30526668f, 0.00413110f, 0.01829374f, 
    0.08882332f, -0.39523906f, -0.05136705f, 0.10638145f, 0.08876030f, -0.23396114f, 0.26075783f, -0.07145597f, 
    0.08509032f, -0.13702206f, -0.01555464f, 0.04126508f, -0.15052916f, -0.09468086f, 0.34243128f, -0.01059155f, 
    0.06458864f, -0.18882555f, 0.13936378f, -0.21633731f, 0.31376556f, -0.03809526f, 0.06105136f, -0.14394541f, 
    0.08736419f, -0.07282498f, 0.03236219f, 0.14898178f, 0.07448516f, 0.02048423f, -0.21043359f, -0.00604326f, 
    0.12443176f, 0.10963103f, -0.31907171f, 0.00840594f, 0.06931694f, -0.43113869f, -0.08442516f, 0.16741472f, 
    -0.07916790f, 0.08219184f, 0.36919910f, 0.03515999f, 0.05846125f, -0.13996065f, 0.32499501f, 0.18029062f, 
    0.04100562f, -0.27611077f, 0.20836219f, 0.27594706f, 0.04240856f, -0.08907916f, -0.03066741f, 0.07015985f, 
    0.14609064f, 0.14250295f, 0.16178474f, -0.10532712f, -0.18704230f, 0.11837491f, -0.37275448f, 0.09276575f, 
    0.14049886f, -0.12428988f, -0.26213372f, 0.07216395f, 0.06693997f, 0.00738608f, -0.08139404f, 0.22268194f, 
    -0.13828757f, 0.13556549f, -0.00438804f, 0.13768134f, -0.33143651f, 0.11749182f, 0.40304053f, 0.14183962f, 
    0.06335158f, -0.08131266f, 0.36674708f, -0.01939756f, -0.04603728f, 0.16189884f, 0.07363982f, 0.03825035f, 
    -0.19493516f, -0.28398505f, 0.06803738f, 0.12915708f, -0.19916347f, -0.05485604f, 0.10147434f, -0.02510214f, 
    0.10145070f, 0.30356130f, -0.02237307f, -0.17271720f, 0.05508024f, -0.16429096f, 0.01617753f, -0.05860020f, 
    0.10884373f, -0.16185883f, -0.09195887f, -0.03810982f, -0.22120373f, 0.14853756f, 0.09373668f, 0.06743815f, 
    0.15849723f, 0.19645780f, 0.02693989f, 0.17902029f, -0.14885162f, -0.04651495f, -0.14476973f, -0.08857905f, 
    0.21971568f, 0.08844825f, -0.32813200f, 0.12618352f, 0.24788512f, 0.19485158f, -0.29295841f, -0.07984265f, 
    0.01171548f, -0.03467860f, -0.06547152f, 0.10454407f, 0.15932587f, -0.07158173f, -0.15145926f, 0.09156683f, 
    -0.07695941f, -0.00644505f, -0.17613055f, 0.05893009f, 0.01711018f, -0.16169499f, 0.41387016f, 0.03240615f, 
    -0.10255706f, 0.24217826f, 0.03720497f, 0.05697631f, 0.00047665f, -0.07818152f, -0.06511858f, -0.11108673f, 
    -0.13042441f, -0.02656862f, -0.07311720f, -0.06592216f, -0.06966019f, -0.10160918f, -0.08553717f, -0.16039488f, 
    -0.20153022f, 0.16715525f, 0.05775142f, -0.09199890f, -0.11362295f, 0.01129145f, -0.12969239f, -0.22202922f, 
    -0.00642336f, 0.08059295f, -0.01735443f, -0.07845081f, -0.06209240f, -0.06540067f, -0.12541269f, -0.01172229f, 
    -0.21906734f, 0.08583292f, 0.05020825f, -0.13274574f, -0.11126854f, 0.14127687f, -0.16845879f, -0.10653184f, 
    0.30273747f, 0.04724909f, -0.21296665f, -0.03811455f, 0.07521321f, -0.07490680f, -0.01419632f, 0.28773835f, 
    -0.22915906f, 0.10185283f, -0.08587159f, 0.01919670f, -0.14151913f, -0.13205206f, -0.32502434f, 0.24297738f, 
    -0.10404938f, -0.05662296f, -0.08433810f, 0.05488238f, -0.55779040f, 0.03214017f, 0.07525200f, 0.15143248f, 
    -0.00121556f, 0.11204278f, -0.04951565f, 0.28832489f, 0.15365203f, 0.09245587f, 0.09766784f, -0.05987751f, 
    0.21621826f, -0.19881345f, 0.10696792f, -0.01372619f, -0.25013360f, -0.13408832f, 0.27890071f, -0.25956810f, 
    0.17588061f, 0.22356500f, 0.14528038f, 0.08403493f, -0.02766359f, -0.09659599f, -0.16755949f, -0.03898038f, 
    -0.02395914f, -0.06348733f, 0.26119617f, -0.06160961f, -0.03021336f, 0.17115898f, 0.01679902f, 0.23958026f, 
    0.26076216f, 0.12215821f, 0.14946407f, 0.16098723f, 0.14186805f, 0.03926427f, 0.06784485f, -0.10114890f, 
    -0.01244497f, -0.17405564f, -0.12814389f, -0.05731613f, 0.24646138f, -0.32330307f, 0.10373496f, -0.13028578f, 
    -0.45221904f, 0.37389806f, -0.23887365f, -0.07553017f, 0.05633280f, 0.09043916f, -0.19583085f, 0.18441501f, 
    -0.03826832f, 0.24056359f, 0.30030236f, 0.19798642f, 0.31047496f, -0.12918085f, 0.01981311f, 0.17969871f, 
    -0.27825704f, 0.03048907f, -0.50802314f, -0.07501189f, 0.25509450f, -0.04207341f, 0.11561511f, -0.25673637f, 
    -0.09080600f, 0.22723816f, 0.18865927f, 0.03496793f, 0.02303487f, -0.09431997f, -0.19904090f, -0.02847867f, 
    0.00333403f, -0.37668628f, -0.08563952f, 0.10191058f, 0.04458428f, -0.33456939f, -0.17777540f, -0.08602796f, 
    -0.13154291f, -0.04316914f, 0.26014146f, 0.09124961f, -0.24106075f, 0.17033434f, 0.36147183f, 0.21834408f, 
    -0.02044060f, -0.02515594f, 0.19887523f, -0.14229417f, 0.29450765f, -0.16068099f, 0.07646172f, 0.03543179f, 
    -0.45549321f, -0.28702629f, 0.24921396f, 0.10792372f, -0.29195422f, -0.40664655f, 0.06450601f, 0.14418574f, 
    0.05316848f, -0.26458168f, -0.25746697f, -0.13582365f, 0.15736525f, 0.34670141f, 0.00278998f, 0.15175709f, 
    -0.04536586f, -0.23066983f, -0.59744847f, 0.10991564f, 0.12629364f, 0.11412860f, -0.55978274f, -0.15232149f, 
    0.14722505f, 0.25353882f, -0.34363860f, -0.19458388f, -0.01583378f, -0.14259189f, 0.12906069f, 0.11586592f, 
    -0.17952211f, -0.11599627f, -0.14985067f, 0.02410017f, 0.29061952f, -0.21449803f, 0.45222384f, -0.17927298f, 
    -0.24492198f, 0.19019917f, -0.16574511f, 0.16532460f, -0.16164054f, 0.08888234f, 0.36990869f, 0.01567585f, 
    0.05509074f, 0.13999131f, -0.15044698f, 0.22543955f, 0.15582150f, 0.02717580f, -0.13188113f, 0.17805791f, 
    -0.03056676f, 0.26391715f, 0.03105447f, -0.15392134f, 0.15558296f, -0.08397593f, -0.07283602f, -0.10791600f, 
    -0.33763716f, -0.04463620f, 0.10880115f, 0.05046041f, 0.27794233f, -0.17472312f, 0.09399404f, 0.00229869f, 
    -0.34361905f, 0.50973028f, -0.08651602f, 0.09343524f, -0.02395070f, 0.24333169f, -0.30642498f, 0.33826214f, 
    0.16679756f, 0.15690522f, 0.19966400f, 0.11163311f, -0.32727733f, -0.05631801f, -0.06060501f, 0.10608030f, 
    -0.19648787f, 0.18904632f, -0.13528728f, -0.24339606f, 0.11738937f, -0.06221299f, -0.06607011f, -0.04336407f, 
    -0.00846327f, -0.30343708f, -0.30047742f, 0.01673519f, 0.11416912f, 0.41882524f, -0.08069418f, -0.17080267f, 
    -0.18434568f, 0.18809643f, -0.09183726f, -0.15673281f, 0.00388139f, -0.07621990f, -0.02439268f, 0.14858511f, 
    -0.16819143f, 0.02287964f, -0.07760207f, -0.24312463f, 0.42838064f, 0.07543488f, 0.38106358f, 0.07952024f, 
    -0.12994862f, -0.12112762f, 0.01887213f, -0.27685806f, 0.19161063f, -0.16293539f, -0.06567965f, 0.28949058f, 
    0.16752812f, 0.07696010f, 0.05059516f, -0.01568299f, 0.17965774f, -0.13278277f, 0.02840087f, 0.27652845f, 
    -0.04181486f, -0.30821922f, -0.10311471f, 0.00744823f, -0.08355520f, -0.15416999f, -0.08442742f, 0.00303280f, 
    0.15766367f, -0.01411502f, -0.12377582f, 0.01861638f, -0.39416909f, 0.03811580f, -0.13797061f, 0.35425356f, 
    0.01464541f, 0.18769917f, 0.31069925f, 0.10813153f, -0.05905384f, -0.05121567f, -0.00538677f, 0.08398308f, 
    0.31889471f, 0.04563183f, -0.07995401f, 0.00682783f, -0.35394228f, 0.37526894f, -0.01361561f, -0.07446394f, 
    0.17016567f, -0.16428834f, 0.11190671f, 0.08464227f, 0.08157217f, 0.15904842f, -0.65883225f, 0.06496613f, 
    0.17485383f, -0.12911904f, 0.21917130f, -0.08307897f, -0.17235489f, 0.15859126f, 0.03278501f, 0.01054941f, 
    0.27386799f, -0.20151183f, 0.20043711f, 0.07860018f, -0.09801132f, -0.08714139f, 0.02733942f, -0.04105045f, 
    -0.12868175f, -0.06513793f, -0.02632573f, 0.00896797f, 0.12720561f, 0.12812018f, -0.21190071f, 0.03108727f, 
    0.02844324f, 0.25680915f, -0.59721625f, 0.15610643f, -0.04926699f, -0.07305134f, -0.33698735f, 0.25846612f, 
    -0.08437689f, -0.03577724f, 0.44474253f, 0.11363418f, -0.15022217f, -0.03641837f, 0.18707694f, 0.29556563f, 
    -0.21427600f, -0.00275450f, 0.06375725f, -0.05959493f, -0.09299947f, -0.04784348f, 0.05313803f, 0.02232826f, 
    -0.15250072f, -0.04932258f, -0.12173426f, -0.11956100f, -0.31521952f, -0.26691628f, 0.19012599f, 0.13294344f, 
    0.19882448f, -0.02278797f, 0.05755711f, 0.00157942f, 0.02525265f, 0.01995667f, 0.21514893f, 0.26221269f, 
    0.05193166f, 0.06439845f, -0.13284805f, 0.18302619f, -0.09195298f, 0.09161992f, -0.27012280f, 0.40445518f, 
    -0.26056501f, 0.00191678f, -0.14154781f, -0.07945114f, -0.08378185f, 0.15267779f, -0.04032262f, 0.19446768f, 
    0.12674727f, -0.07699570f, -0.01067698f, -0.15788022f, 0.20719156f, 0.13777402f, 0.03048106f, -0.07257570f, 
    0.12862246f, 0.06071738f, 0.01230021f, 0.03867967f, 0.13172840f, 0.07117284f, 0.25400388f, -0.14695357f, 
    0.00552057f, -0.03780349f, -0.03089870f, 0.32667723f, 0.46623665f, -0.13305897f, 0.05544889f, -0.08894234f, 
    0.19301617f, 0.10131142f, 0.02799718f, -0.18033899f, 0.17367922f, 0.05317432f, -0.05702182f, -0.18114451f, 
    -0.00906010f, 0.07630640f, 0.20176037f, 0.16037858f, -0.34033459f, -0.31894279f, -0.09814170f, 0.20966399f, 
    0.24728523f, 0.14497893f, 0.08996895f, -0.07858369f, -0.09313387f, -0.18201034f, 0.00917629f, 0.29791760f, 
    -0.08189375f, -0.12563892f, 0.17659794f, 0.17581190f, -0.22413340f, 0.17420436f, 0.07645070f, 0.35098416f, 
    -0.21634769f, -0.11504902f, 0.02594139f, 0.23259395f, -0.15778810f, 0.08226978f, 0.00561368f, -0.01325308f, 
    -0.23576787f, -0.08140159f, -0.01616952f, 0.08142928f, 0.42958543f, 0.29636297f, 0.06818757f, -0.15107602f, 
    -0.22350655f, 0.24068770f, -0.24401736f, 0.11429848f, 0.01132251f, 0.29154491f, 0.19887023f, 0.05932019f, 
    -0.07034592f, -0.07684784f, 0.20780310f, 0.09678406f, 0.40129542f, -0.12620032f, -0.01333479f, -0.05202329f, 
    -0.00821902f, -0.19147386f, 0.07434058f, -0.12666520f, 0.12016161f, 0.13926186f, -0.10705329f, 0.19886522f, 
    0.08988841f, 0.05756765f, -0.01867996f, 0.11791375f, 0.28331643f, 0.10048646f, -0.21328379f, 0.18877456f, 
    0.28937149f, -0.39804915f, -0.00062370f, 0.13664481f, 0.14156950f, -0.27581143f, 0.20717530f, -0.06028479f, 
    -0.05240178f, 0.16326992f, -0.30280036f, -0.16514769f, 0.08381627f, 0.11443780f, 0.30017021f, 0.22566886f, 
    -0.20110753f, -0.18902583f, 0.16292262f, -0.18737423f, -0.01610963f, 0.02162254f, 0.12076490f, 0.15573370f, 
    -0.09568644f, 0.02506840f, -0.16016877f, 0.16718848f, 0.43400133f, 0.15083668f, 0.26133260f, 0.13675894f, 
    -0.02641405f, -0.02202454f, 0.10852331f, 0.10742526f, 0.08280792f, -0.24109776f, 0.15285371f, -0.01529851f, 
    0.13949837f, 0.16058287f, 0.07477570f, 0.01241391f, 0.38541391f, -0.05986951f, 0.31927025f, -0.03446027f, 
    -0.29420424f, -0.32095325f, -0.23312445f, 0.06145472f, 0.09434412f, -0.07939799f, -0.04709541f, 0.00428990f, 
    0.02465353f, -0.34773341f, -0.17564934f, 0.04069936f, -0.03877509f, 0.36470532f, 0.21053199f, -0.14727254f, 
    -0.22481467f, 0.38575619f, 0.00549868f, 0.01189650f, 0.16542812f, 0.29285693f, -0.02528671f, -0.00483939f, 
    -0.16483758f, 0.27718282f, 0.21802472f, 0.20181416f, 0.24449724f, -0.04928061f, -0.09886338f, 0.11480979f, 
    0.23934798f, -0.27377129f, -0.02699332f, -0.23211864f, 0.10440805f, 0.13809155f, 0.10567226f, -0.05222606f, 
    0.23479170f, 0.08627003f, 0.12624031f, 0.11589533f, 0.42668721f, 0.31830028f, -0.00768561f, -0.15533312f, 
    -0.14858671f, 0.03144709f, -0.20633373f, 0.01969364f, -0.13546103f, 0.03343292f, -0.07730965f, -0.14294243f, 
    -0.05926355f, 0.24842902f, 0.08324183f, -0.00555267f, -0.05130091f, -0.13621694f, 0.04654962f, -0.15928645f, 
    0.16252595f, -0.00780405f, -0.05108068f, 0.10493053f, 0.23028442f, -0.05859917f, 0.11142012f, -0.00974486f, 
    -0.22672535f, -0.36864036f, 0.21895668f, 0.08717555f, -0.16333060f, 0.04826053f, 0.33094078f, -0.14405997f, 
    -0.12473858f, 0.10589126f, 0.11389240f, 0.17486855f, 0.11532950f, 0.06754866f, 0.36672795f, 0.18029240f, 
    -0.01670494f, 0.07366002f, -0.42984062f, -0.00086261f, -0.31584534f, -0.16222423f, -0.19102444f, 0.12851499f, 
    0.41477427f, 0.32163608f, 0.21444719f, -0.05418720f, -0.05753932f, 0.16674949f, -0.06466709f, 0.13335428f, 
    -0.22698706f, 0.03346381f, 0.35549656f, -0.09574719f, 0.39110506f, -0.17163794f, 0.33744517f, -0.04603911f, 
    -0.18034920f, -0.14345050f, 0.06837628f, 0.07058147f, -0.15415275f, 0.02527211f, 0.29730916f, 0.25912610f, 
    0.10664297f, -0.13473614f, -0.53022540f, 0.11875524f, -0.47545516f, 0.16232434f, -0.31431413f, -0.05882378f, 
    -0.25863257f, 0.28733817f, -0.26218626f, 0.16824915f, 0.30271193f, -0.00335566f, 0.09475002f, 0.17910022f, 
    0.09237468f, -0.15776905f, 0.28085068f, -0.14077055f, -0.04737495f, -0.20319375f, -0.09251989f, 0.40343621f, 
    0.27403656f, 0.12526819f, -0.22746842f, 0.14170992f, 0.11809376f, 0.17419815f, 0.18072966f, -0.05305996f, 
    -0.12943193f, -0.10853161f, 0.00272998f, 0.30750227f, -0.24529299f, -0.05567630f, 0.08357815f, 0.19805236f, 
    -0.04970023f, 0.27892697f, 0.22344327f, 0.30247065f, -0.16277930f, -0.01829576f, 0.14173572f, -0.26497009f, 
    0.12185941f, 0.15528952f, 0.34536734f, 0.01624730f, 0.27394822f, -0.02107084f, 0.16417405f, 0.12997520f, 
    0.11606900f, -0.32018033f, 0.20005798f, 0.00646849f, -0.15886751f, -0.09217653f, 0.23089416f, 0.17859662f, 
    0.13357735f, -0.26667422f, -0.07239237f, -0.10381297f, -0.05397040f, -0.16920073f, -0.08381805f, 0.02594478f, 
    0.27884799f, -0.04880517f, 0.04074309f, -0.11287647f, 0.12442100f, -0.07826238f, 0.02077694f, -0.05612938f, 
    -0.02523027f, -0.14088696f, -0.01993255f, -0.00932380f, 0.02490519f, -0.25406900f, -0.11287755f, -0.03641912f, 
    0.07699812f, 0.08169361f, 0.03464642f, -0.07417437f, 0.03681789f, -0.18658769f, 0.07117917f, -0.10382093f, 
    -0.15822171f, 0.01095041f, -0.10935160f, -0.26242006f, 0.03378895f, 0.15021752f, -0.00008051f, 0.11944652f, 
    -0.22314237f, -0.21863684f, 0.00892928f, -0.02909390f, -0.07025728f, 0.05326258f, 0.06813715f, -0.02637081f, 
    0.13229264f, 0.20111853f, -0.14330088f, 0.15874609f, 0.44728526f, 0.10954736f, -0.11159299f, -0.02124132f, 
    0.09305394f, -0.05957912f, -0.00385164f, -0.02320745f, -0.10255714f, -0.26382664f, -0.13171890f, 0.06229327f, 
    0.04849992f, -0.03628036f, 0.02552048f, -0.16489740f, 0.25285003f, 0.17294329f, 0.53941464f, -0.19598117f, 
    -0.25222510f, -0.19345373f, 0.24477251f, 0.10946575f, 0.01984098f, 0.14032115f, 0.16298670f, 0.07118311f, 
    -0.11041262f, -0.19590378f, -0.05682354f, -0.11465406f, -0.30947554f, -0.11698921f, 0.43124455f, 0.10132119f, 
    0.08421213f, 0.19646828f, 0.26160407f, -0.16566341f, 0.16703822f, 0.19861084f, 0.12956777f, -0.01810313f, 
    0.09208739f, 0.07620560f, -0.02678947f, 0.06406627f, 0.11448777f, 0.01162966f, 0.08483206f, 0.13802285f, 
    0.26098505f, 0.07658183f, -0.34978572f, 0.28369668f, 0.06154300f, 0.00749689f, 0.15900730f, -0.24519384f, 
    0.01641376f, -0.09289528f, 0.20500278f, -0.17041056f, -0.36750430f, -0.12025321f, 0.05441948f, 0.38119233f, 
    0.32316133f, -0.17319892f, -0.26808098f, 0.01792483f, 0.05288926f, -0.08709925f, 0.26242775f, 0.14208934f, 
    0.10082338f, -0.19757460f, -0.31045994f, 0.14849292f, -0.46727353f, -0.03335156f, 0.05674814f, 0.26289934f, 
    0.01780405f, 0.31378207f, 0.48083198f, -0.09939007f, -0.22103573f, 0.05184176f, -0.12037221f, 0.07500070f, 
    0.03701589f, 0.07729156f, 0.07472222f, -0.05977982f, 0.08893359f, 0.02620043f, 0.04798828f, 0.08553212f, 
    -0.33890224f, 0.00173790f, -0.15861435f, -0.09241988f, -0.12896045f, 0.21457683f, -0.22283353f, 0.18743162f, 
    0.16042311f, 0.00041023f, 0.15299395f, 0.29894337f, -0.49361587f, 0.13223708f, -0.08106403f, -0.00420573f, 
    0.23593834f, 0.05963216f, -0.19102678f, -0.00642618f, 0.21300158f, 0.15495889f, -0.09601571f, -0.27376199f, 
    0.27143544f, -0.28022611f, -0.18328679f, 0.05418570f, -0.04797485f, 0.12807998f, 0.14831950f, 0.22958620f, 
    -0.15372318f, -0.05069790f, -0.31217340f, -0.03825621f, -0.12566943f, 0.06645642f, -0.04432232f, -0.09745625f, 
    -0.04183124f, 0.20920672f, 0.38493615f, 0.27952579f, 0.19370383f, 0.08461668f, 0.29309431f, 0.17876957f, 
    -0.02474177f, -0.24351771f, 0.12663543f, 0.16408214f, -0.15560676f, 0.05861026f, 0.12212264f, -0.21084091f, 
    0.25921130f, -0.26896814f, -0.11824004f, 0.14017127f, -0.06178084f, 0.10869397f, 0.09465139f, -0.25658622f, 
    -0.10718000f, 0.50761026f, -0.86217892f, 0.15295050f, -0.00175881f, 0.09653353f, -0.17026030f, 0.00642591f, 
    0.04655893f, 0.27435476f, 0.03619855f, -0.00239708f, -0.12670471f, -0.01737009f, -0.03713500f, 0.16488774f, 
    -0.01191954f, 0.00550307f, 0.24684379f, -0.29432496f, -0.07999814f, 0.02652700f, -0.01370371f, 0.22066514f, 
    -0.22693099f, -0.09821917f, 0.27924451f, -0.05883085f, 0.01702628f, 0.13572365f, 0.08010871f, 0.12011393f, 
    0.33374727f, 0.05057880f, -0.18720870f, 0.15004395f, -0.11488099f, -0.11436008f, 0.28872335f, 0.05110324f, 
    -0.10252649f, -0.05075368f, 0.03380127f, 0.19199833f, -0.14398810f, 0.00976429f, 0.07088389f, -0.11259735f, 
    0.21856980f, -0.06752697f, -0.01563761f, 0.42538643f, -0.10356484f, 0.12621206f, 0.08303662f, -0.25432849f, 
    0.15637106f, -0.09869818f, 0.15290909f, -0.01594518f, -0.06133815f, -0.09768815f, 0.52301770f, 0.05748094f, 
    -0.12319345f, -0.16916810f, 0.14032856f, -0.12732503f, -0.06496867f, -0.10088623f, 0.56429267f, 0.22142945f, 
    0.08814385f, 0.06732376f, -0.37798715f, 0.26642334f, 0.03096367f, 0.04156715f, 0.33592707f, 0.24293481f, 
    0.07897545f, -0.02359435f, -0.18775739f, -0.20744035f, -0.09955318f, 0.08892092f, 0.15692881f, -0.24217214f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.19195706f, -0.05417825f, 0.00790328f, 0.21959689f, 0.00590171f, 0.05432631f, 0.05659383f, -0.03044396f, 
    -0.08168849f, 0.15211989f, -0.06114994f, 0.04961197f, -0.07726425f, 0.05756196f, -0.12965845f, 0.03260530f, 
    -0.06134954f, 0.01209185f, -0.03596235f, 0.06014554f, 0.05252360f, -0.00793251f, -0.17430788f, 0.07198711f, 
    -0.10347991f, 0.03895473f, 0.10552436f, 0.10772636f, -0.02169639f, 0.17956947f, 0.02624202f, -0.19659017f, 
    0.07164078f, 0.33040854f, 0.09654092f, -0.13246159f, 0.11129582f, 0.08754969f, 0.30870727f, -0.15726744f, 
    0.22208907f, 0.00000024f, 0.14725369f, 0.20813911f, 0.24224088f, 0.29016981f, 0.16347924f, 0.07313781f, 
    0.13274361f, -0.11363477f, 0.13451108f, 0.05473746f, 0.00359251f, -0.09917327f, 0.02822142f, -0.00965587f, 
    0.20278625f, 0.26677456f, 0.18100344f, -0.03367980f, 0.20399486f, -0.17688696f, 0.12663199f, 0.01844155f, 
    -0.02701618f, -0.11660805f, -0.02962613f, -0.07386127f, -0.16182533f, -0.01983245f, 0.25182676f, 0.14560564f, 
    0.18698351f, 0.18769912f, 0.18448970f, 0.19129011f, -0.09808427f, 0.10485914f, 0.14551471f, 0.08269419f, 
    0.26036280f, -0.02047056f, 0.05069343f, 0.20522158f, 0.09165207f, -0.04301142f, -0.08666030f, -0.06623355f, 
    0.13994239f, 0.20585437f, 0.32070068f, 0.22600757f, 0.08534917f, -0.01015376f, 0.08251102f, 0.06364056f, 
    0.15465173f, -0.10366191f, 0.25038370f, 0.26120141f, -0.20747094f, 0.16769379f, 0.15842649f, 0.39379185f, 
    0.00614962f, -0.03282081f, 0.09121151f, 0.18550882f, 0.12344813f, 0.06760070f, 0.13125959f, 0.25297433f, 
    -0.07644225f, -0.01931850f, 0.29251149f, 0.09260738f, 0.25282720f, -0.09393270f, -0.17352864f, 0.08770198f, 
    0.03091474f, -0.17099252f, 0.02150553f, -0.05227192f, 0.15847400f, 0.11966088f, -0.29460195f, 0.37431225f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.03538162f, -0.09243821f, 0.02611258f, -0.39822584f, -0.00595482f, -0.20727201f, 0.02218463f, -0.01116638f, 
    0.08032649f, 0.01161130f, 0.03598839f, -0.04957899f, -0.06267111f, -0.32351393f, 0.08429675f, 0.05704860f, 
    -0.16405417f, 0.04979789f, 0.17129056f, -0.16555360f, -0.55819792f, 0.21290694f, -0.10907697f, 0.08199718f, 
    0.01948178f, -0.55574262f, 0.05591860f, 0.19277014f, 0.05222064f, -0.07008761f, -0.11798643f, -0.54040128f, 
    -0.09711936f, -0.17883472f, 0.04439041f, -0.00116209f, -0.49354896f, -0.09140711f, -0.11106829f, 0.03441237f, 
    0.13238667f, 0.07571878f, -0.15879183f, 0.08380070f, 0.15769388f, -0.28324211f, 0.20259321f, 0.10531513f, 
    0.12009430f, 0.15595230f, -0.09092794f, -0.03482186f, 0.12045072f, 0.04385094f, -0.10177566f, 0.15401623f, 
    0.11815043f, -0.17410319f, -0.46836463f, -0.01541377f, 0.05555391f, 0.01384627f, 0.04074497f, -0.37218475f, 
    0.14808910f, -0.35866198f, -0.00713633f, -0.03731032f, -0.00670379f, -0.38258383f, -0.50191915f, -0.15796348f, 
    -0.28580311f, 0.12711237f, -0.34385890f, -0.50341249f, 0.03927978f, -0.53699476f, -0.08221582f, -0.02424015f, 
    -0.32210520f, -0.06283766f, 0.24167000f, -0.29107103f, -0.31836021f, 0.08309451f, -0.18045649f, -0.12665828f, 
    -0.16478468f, -0.07440419f, -0.00921207f, -0.33594385f, -0.18012422f, 0.09383926f, -0.06804615f, -0.00250103f, 
    -0.07419426f, -0.20441183f, -0.46029446f, -0.51135761f, 0.40302834f, 0.11665874f, 0.03045536f, -0.21043122f, 
    0.07302645f, -0.06186658f, -0.41673854f, 0.15926743f, 0.00949512f, 0.03534255f, 0.11183684f, 0.03060304f, 
    0.05675501f, -0.26130915f, -0.19941212f, 0.21738417f, 0.18556249f, 0.18001324f, 0.08627984f, 0.05700731f, 
    -0.11569849f, 0.09810255f, 0.19407606f, -0.07634763f, -0.29732639f, -0.12768491f, 0.14379717f, 0.12813716f, 
    -0.00925193f, 0.09588575f, -0.03297012f, -0.18563206f, -0.14347525f, -0.01233167f, 0.03545687f, 0.00996524f, 
    0.01458450f, -0.08350038f, -0.15895237f, -0.07425316f, 0.08293194f, -0.82008833f, 0.12469810f, -0.11529433f, 
    0.29618821f, 0.00190417f, 0.22192213f, -0.06958840f, 0.18717492f, 0.11817332f, -0.07872228f, 0.02844227f, 
    -0.08866943f, -0.04630310f, 0.07504658f, 0.07946337f, -0.35361302f, 0.09332452f, 0.09878799f, -0.09522103f, 
    0.03695884f, 0.08815553f, -0.06149568f, 0.05683166f, -0.56072623f, 0.02972017f, 0.26623043f, 0.00075068f, 
    0.16450971f, 0.02928387f, -0.08165920f, 0.15346447f, 0.08150143f, 0.16932090f, -0.44183746f, 0.05520314f, 
    0.31951290f, -0.50127196f, 0.26386374f, -0.23350656f, 0.08187681f, 0.00294409f, 0.08379305f, 0.15520838f, 
    -0.82060426f, 0.04363846f, 0.26442727f, -0.25149980f, 0.11908771f, -0.05370690f, 0.05771940f, -0.20844354f, 
    0.03549077f, -0.02596239f, -0.16005933f, 0.04064851f, 0.02801740f, -0.32134518f, 0.23186779f, -0.13805053f, 
    0.05642015f, 0.16606770f, 0.04004291f, 0.07682633f, -0.00041071f, -0.14181067f, -0.03494370f, -0.09884053f, 
    -0.29552144f, 0.17173465f, 0.19689606f, 0.04593204f, -0.08223545f, -0.54941732f, -0.08393515f, -0.12044838f, 
    -0.59154111f, 0.28353572f, 0.15859827f, -0.21340615f, -0.27181724f, -0.21070197f, -0.08164762f, 0.01794271f, 
    -0.15747592f, 0.12721236f, 0.22666043f, -0.13038985f, -0.53472143f, 0.14214684f, 0.08135503f, 0.04986564f, 
    -0.12148467f, 0.11090418f, -0.68276763f, 0.00542150f, 0.03581477f, -0.28916523f, 0.13655210f, -0.14908063f, 
    0.06113245f, 0.21101800f, 0.05307647f, 0.10353150f, 0.25853872f, -0.37297550f, 0.07001527f, -0.05562998f, 
    -0.09867453f, 0.12186787f, -0.30458495f, 0.03279222f, -0.17837946f, -0.18433341f, -0.14181639f, 0.19525278f, 
    -0.01613591f, -0.00261822f, 0.03427095f, 0.25653246f, -0.19505328f, 0.31166059f, -0.01442948f, -0.27774310f, 
    -0.03683556f, 0.19868329f, -0.05181164f, 0.04542066f, -0.01170136f, 0.06537563f, -0.00781871f, -0.11705377f, 
    -0.00574377f, 0.02457919f, -0.00131469f, -0.13466787f, -0.00091938f, -0.70678777f, 0.05421442f, 0.02298517f, 
    -0.55322248f, 0.03052904f, 0.13795990f, -0.20679671f, -0.07298386f, -0.12972866f, -0.01479109f, -0.23443034f, 
    0.09783902f, 0.19758509f, 0.13053928f, -0.02701556f, -0.02140442f, 0.05886253f, -0.06535104f, 0.20740907f, 
    0.15125138f, -0.00717124f, 0.32586059f, -0.32432264f, -0.01605257f, 0.19656175f, -0.39302447f, 0.08113226f, 
    -0.35123241f, -0.22603017f, 0.07324783f, 0.03351537f, -0.09777927f, 0.07462824f, 0.00802064f, 0.03458586f, 
    0.05862540f, -0.06370685f, -0.00291214f, -0.00057972f, 0.19708258f, 0.19194323f, -0.31548044f, 0.10001758f, 
    0.08533876f, -0.01037546f, -0.19022657f, -0.12011406f, 0.03310019f, 0.00630605f, -0.32140738f, -0.20157199f, 
    0.01991783f, 0.09026219f, 0.04790863f, 0.39288858f, -0.06606705f, -0.08238830f, 0.04592116f, -0.43441325f, 
    0.13422315f, -0.43397912f, -0.01179136f, -0.09792334f, 0.14186355f, 0.04883885f, 0.04680433f, -0.01336472f, 
    0.50898188f, -0.21475185f, -0.21712805f, 0.07444054f, -0.15663210f, 0.04840848f, -0.12446105f, -0.02577030f, 
    -0.29604098f, -0.15459754f, 0.22013924f, 0.03014622f, -0.29934263f, 0.12587959f, 0.03344263f, 0.16739778f, 
    -0.30401075f, -0.18473102f, 0.21851325f, 0.10664825f, 0.01032168f, 0.05476619f, 0.31845099f, 0.03299212f, 
    0.17133689f, 0.04601983f, -0.07408796f, -0.51253814f, -0.49821955f, -0.41741151f, -0.04810029f, 0.03113642f, 
    0.04269222f, -0.02825529f, -0.32525200f, -0.23955610f, 0.09615541f, 0.35956064f, -0.01489401f, -0.41444489f, 
    0.13249245f, -0.83424950f, 0.03447869f, 0.36476710f, -0.20411895f, 0.13708790f, -0.05504968f, 0.07242797f, 
    -0.00296300f, 0.14720123f, 0.34501520f, -0.08335359f, -0.09021266f, 0.20950380f, -0.07892414f, -0.13650104f, 
    -0.74295497f, -0.09650387f, 0.25059253f, -0.07098434f, -0.30089319f, 0.04480990f, 0.00407694f, -0.07104831f, 
    -0.39620885f, 0.03768461f, 0.07006088f, 0.10058000f, 0.20885348f, -0.17044879f, -0.47768578f, 0.07232779f, 
    -0.44964302f, -0.03258213f, -0.18521854f, -0.03079870f, 0.10732508f, 0.21211897f, -0.23289770f, -0.33839965f, 
    0.09539853f, -0.53509855f, 0.10065982f, 0.06008394f, -0.11083435f, 0.26164418f, 0.07237822f, -0.01535947f, 
    -0.05762419f, -0.17841066f, -0.60958803f, -0.15705736f, 0.05875894f, -0.06038952f, 0.41433325f, -0.01809563f, 
    -0.10191386f, -0.56897062f, 0.21828997f, 0.06190065f, -0.11487904f, 0.05027233f, -0.04526002f, 0.16722019f, 
    0.41051477f, -0.00319402f, -0.25069213f, 0.01334831f, -0.00280108f, 0.13910787f, -0.50823230f, 0.10241729f, 
    -0.07249698f, -0.00170411f, 0.04828098f, -0.05054155f, -0.06207823f, -0.21235220f, -0.00152549f, 0.21318674f, 
    0.12620346f, 0.33131039f, 0.14860523f, -0.00074260f, 0.05987940f, -0.15869598f, -0.29060987f, -0.02786907f, 
    0.26779810f, -0.36214620f, -0.56634152f, -0.08176993f, 0.08421608f, 0.00059266f, -0.03487834f, -0.00455007f, 
    0.04066105f, 0.02647952f, -0.06620681f, -0.01215033f, 0.33255905f, -0.01273112f, 0.17288192f, 0.07508446f, 
    0.06001356f, -0.45294842f, 0.16354229f, 0.18473884f, -0.36457169f, 0.11035562f, -0.10916345f, -0.02620597f, 
    -0.29131204f, -0.16486304f, -0.25724784f, 0.20822036f, 0.13855614f, -0.12254186f, 0.02008570f, -0.05189867f, 
    -0.14937708f, -0.12807991f, 0.16564699f, -0.02931136f, -0.48458996f, 0.16263509f, -0.24964057f, -0.03666500f, 
    -0.14578074f, -0.02726769f, 0.09782797f, -0.16881840f, 0.19164243f, 0.10920049f, -0.06097306f, 0.13256918f, 
    -0.05775750f, -0.09152519f, 0.06173425f, -0.02769039f, 0.08577305f, 0.24669872f, -0.05513987f, 0.02093585f, 
    -0.10257823f, -0.05789445f, -0.15947792f, -0.39320192f, -0.21356730f, -0.10472013f, -0.05853329f, -0.07218742f, 
    -0.05060948f, 0.03764959f, 0.03667890f, 0.02112608f, 0.05596174f, -0.11392082f, -0.12495279f, 0.11718454f, 
    -0.67464584f, -0.20085204f, -0.01288718f, -0.06275324f, 0.11943114f, -0.30499154f, -0.54974264f, 0.05717252f, 
    0.00904160f, 0.12326766f, 0.05592356f, 0.15504368f, 0.09190167f, -0.21334544f, 0.12312818f, -0.04086081f, 
    0.02031917f, 0.18647237f, -0.14085905f, -0.44400722f, -0.01951525f, -0.00517826f, -0.11191497f, 0.08552781f, 
    -0.75984818f, 0.03046847f, -0.27597496f, 0.07508097f, -0.00298054f, -0.10957780f, 0.01699038f, -0.00229099f, 
    -0.10995175f, 0.06102086f, 0.05556098f, -0.05880842f, -0.06381933f, -0.01038000f, -0.94262379f, -0.06749018f, 
    -0.30297276f, -0.06639142f, -0.01132965f, -0.20832784f, 0.17029797f, 0.01888653f, -0.05339659f, 0.12889601f, 
    -0.33327356f, -0.02095147f, -0.20581414f, -0.19696124f, -0.16669734f, 0.17314556f, 0.02720873f, 0.20985831f, 
    0.01700598f, -0.39345962f, 0.32570803f, -0.05898071f, 0.09610901f, -0.12419517f, -0.24074118f, -0.02280495f, 
    -0.05321223f, -0.05256686f, -0.13675562f, 0.31313646f, -0.53625363f, -0.04437297f, 0.06580624f, -0.62304842f, 
    0.07201021f, 0.00708632f, 0.03235812f, 0.00998502f, -0.02043000f, 0.09559599f, -0.10688920f, 0.03760759f, 
    -0.12705360f, -0.45382112f, -0.05971607f, -0.06416778f, 0.05649602f, 0.18520562f, 0.18439323f, -0.06326239f, 
    -0.12123138f, -0.01460423f, 0.11735666f, 0.11819552f, -0.07303924f, -0.50926828f, 0.13706502f, 0.07498037f, 
    -0.23644122f, 0.13800925f, 0.03071384f, -0.59266931f, 0.05517996f, -0.13089573f, -0.05188277f, 0.16491184f, 
    -0.01309098f, 0.01060920f, -0.12475301f, 0.01177722f, -0.02550745f, 0.09900796f, -0.06331119f, 0.07735109f, 
    -0.12741107f, 0.00061394f, -0.34372237f, 0.02837688f, -0.13096997f, -0.02344845f, -0.03018867f, -0.04235846f, 
    0.14582388f, 0.11807978f, -0.21591264f, -0.00765791f, -0.32494819f, -0.16039573f, 0.01924358f, 0.08220817f, 
    -0.36019287f, -0.21957842f, 0.10275394f, -0.06834650f, -0.29928499f, -0.09373911f, -0.02583881f, -0.09094150f, 
    -0.00738341f, -0.13781980f, 0.11471342f, 0.12909685f, -0.34126663f, 0.12550522f, -0.27545536f, 0.01827454f, 
    0.09972642f, -0.14948098f, -0.22245187f, 0.09970976f, -0.20120293f, -0.01168449f, -0.20928025f, 0.05853256f, 
    -0.08527578f, -0.02693514f, 0.01887446f, -0.11608666f, 0.27042618f, -0.00104036f, 0.07451759f, 0.04639602f, 
    -0.15811478f, -0.02789514f, 0.02860661f, 0.02505516f, -0.12154169f, 0.09552182f, -0.06252369f, -0.06975066f, 
    0.17978010f, -0.04848787f, -0.06456435f, 0.13737933f, -0.21059580f, 0.19682388f, 0.01500215f, 0.09304041f, 
    0.16030021f, -0.38653821f, -0.00949937f, 0.24295495f, -0.11778563f, -0.09469957f, -0.03151051f, -0.23187172f, 
    -0.33252120f, -0.22136861f, -0.22639267f, -0.05359956f, 0.00721015f, -0.08900181f, -0.11549765f, -0.05771323f, 
    0.15323472f, 0.10688055f, 0.26360479f, -0.13891275f, -0.60183883f, 0.02494241f, 0.10129248f, -0.21635145f, 
    -0.02625227f, 0.16554148f, -0.05406335f, 0.15407212f, -0.06414167f, 0.15330568f, -0.06947289f, -0.24637607f, 
    0.00582920f, 0.20866212f, -0.05227265f, -0.06938923f, -0.09393191f, 0.14268345f, -0.07209422f, -0.03555075f, 
    -0.21247137f, 0.22371016f, -0.02957472f, 0.10583699f, 0.30047032f, 0.12742808f, 0.10055726f, 0.17816207f, 
    -0.19363222f, 0.01234497f, 0.19490048f, 0.19710733f, 0.08532242f, 0.31009334f, 0.00134541f, -0.46336678f, 
    -0.08490586f, -0.02973821f, -0.21809280f, 0.02357145f, -0.13882238f, -0.06769561f, -0.16328101f, -0.05968972f, 
    0.29929161f, 0.03119553f, 0.12871067f, 0.13271247f, 0.16314729f, -0.65860075f, -0.09997848f, 0.03603277f, 
    -0.39382562f, 0.06415249f, 0.11513173f, -0.39799127f, -0.14768858f, 0.13602619f, 0.00637345f, -0.15674172f, 
    0.24065131f, 0.04022580f, 0.09858020f, -0.13582855f, 0.28804836f, 0.08506867f, 0.12958577f, -0.04136749f, 
    -0.84103990f, 0.03553839f, -0.11287358f, -0.37074509f, -0.04292565f, -0.60233241f, -0.21470413f, 0.04385994f, 
    -0.28331339f, -0.40250677f, -0.00331437f, 0.18033937f, -0.63989007f, 0.00216791f, -0.08962879f, -0.72137302f, 
    0.06327005f, 0.08424886f, 0.20974110f, 0.03498739f, -0.75487727f, 0.09730293f, -0.97197694f, 0.14050613f, 
    0.06135897f, 0.14354268f, -0.23675506f, -0.05940316f, 0.06233506f, -0.01823859f, 0.02084322f, -0.46666011f, 
    -0.49666390f, -0.34644082f, 0.08296570f, -0.26973817f, 0.03968025f, 0.28097132f, 0.02872529f, -0.46338555f, 
    -0.05494003f, -0.39735350f, -0.31338102f, -0.31381968f, 0.15483041f, 0.12367215f, 0.09948782f, 0.03341055f, 
    0.04578478f, 0.14756109f, -0.09067016f, 0.08975233f, 0.10484482f, -0.04529626f, 0.08873106f, 0.06037689f, 
    -0.38423926f, 0.05858455f, -0.45744136f, -0.13327108f, -0.02946747f, -0.50423467f, -0.67990756f, 0.38050944f, 
    -0.57549649f, 0.03592093f, -0.00671477f, -0.34794927f, 0.05647115f, 0.04577312f, 0.18120837f, 0.02320815f, 
    0.12708177f, 0.20542799f, 0.02421878f, -0.35006180f, -0.21814699f, -0.63208538f, -0.07965034f, 0.01202439f, 
    0.15113842f, 0.03769485f, -0.40124589f, -0.41215616f, 0.18007606f, -0.30999434f, 0.31998509f, -0.09298323f, 
    0.14966875f, -0.03887057f, 0.04014615f, 0.24248740f, 0.12567702f, -0.36414143f, -0.05348230f, 0.16725503f, 
    0.07583597f, 0.07948530f, -0.12397986f, -0.03308294f, 0.11007177f, -0.30960366f, 0.05051168f, 0.15199907f, 
    0.09907003f, 0.05542354f, -0.03598362f, 0.12862003f, -0.20201264f, 0.18787904f, 0.06850819f, -0.04522450f, 
    -0.20435125f, 0.07179347f, 0.02479503f, 0.30371365f, 0.43335834f, -0.10866426f, 0.00039090f, -0.08713592f, 
    0.09005611f, -0.33385241f, -0.51943052f, -0.03292954f, -0.22254048f, -0.26986474f, 0.03333522f, 0.08441176f, 
    -0.56426895f, -0.12061789f, -0.29153225f, -0.25371936f, 0.14247721f, -0.19852701f, -0.09454579f, 0.12875836f, 
    -0.13937066f, 0.37405083f, -0.27068093f, -0.11697497f, 0.17113754f, -0.00931325f, -0.07760014f, -0.58986402f, 
    -0.14635551f, -0.11351649f, -0.41974220f, 0.20593980f, -0.59117186f, -0.08981006f, 0.32063612f, -0.31297398f, 
    0.03132304f, 0.11634188f, 0.06271771f, 0.02711371f, -0.00918288f, 0.03409920f, -0.38775143f, 0.11697377f, 
    0.07292611f, 0.00712796f, -0.47595039f, -0.17833599f, 0.12372813f, -0.22654095f, -0.05161260f, 0.02754257f, 
    -0.12048181f, -0.05649489f, -0.31440774f, -0.53069073f, 0.13879593f, 0.06512018f, 0.07925673f, 0.16604789f, 
    0.65764362f, 0.01277170f, -0.31796312f, 0.10310168f, -0.07570600f, 0.16990696f, -0.05837511f, -0.06928582f, 
    0.25838166f, 0.12666517f, -0.34192336f, -0.05913814f, -0.38686505f, -0.59865022f, -0.03148844f, -0.52847874f, 
    0.05847117f, -0.03059777f, -0.07568882f, -0.20422935f, -0.19922093f, 0.17064252f, -0.43056107f, -0.27799466f, 
    -0.00412518f, -0.13967697f, -0.03920996f, 0.02065947f, -0.51973259f, 0.20680885f, 0.08811989f, 0.06004668f, 
    -0.00106526f, 0.02926847f, 0.12521952f, 0.09214212f, -0.08380784f, -0.55866748f, 0.23261346f, -0.78085077f, 
    -0.31995147f, -0.12697273f, -0.53398389f, -0.08491436f, -0.30603999f, -0.51812518f, 0.00452596f, -0.04226407f, 
    0.07240073f, 0.50684333f, -0.09049518f, -0.04662453f, 0.08637187f, -0.31552032f, 0.02298612f, -0.32565767f, 
    -0.26838210f, 0.00413573f, -0.07835454f, 0.12450762f, 0.15592861f, 0.28524691f, -0.12323805f, 0.03449490f, 
    -0.07107906f, 0.20488256f, -0.05317351f, -0.15979910f, -0.06056536f, -0.26402649f, 0.11664158f, 0.14873059f, 
    0.08497427f, 0.13785708f, -0.71014661f, -0.09775277f, -0.30137715f, 0.31214526f, 0.04737753f, -0.04811349f, 
    0.08242178f, 0.01202257f, -0.34604615f, -0.62533140f, 0.17998074f, 0.03685921f, -0.04612938f, -0.04783767f, 
    -0.31552321f, -0.44606549f, 0.03532631f, 0.08306522f, -0.75333536f, -0.02696893f, -0.08883404f, -0.50242627f, 
    0.39792445f, -0.18321301f, -0.15624429f, -0.39171556f, -0.22459377f, 0.01244001f, 0.08377923f, 0.04910045f, 
    -0.03824132f, 0.02522644f, -0.16470523f, -0.04089095f, 0.02219691f, 0.33129710f, -0.20890595f, 0.26000074f, 
    0.29429740f, 0.22657859f, 0.20463981f, 0.35688275f, -0.21082243f, -0.09058538f, -0.00274120f, -0.22432104f, 
    0.24573989f, -0.23885991f, -0.01341527f, 0.14199591f, 0.19373922f, -0.32446486f, 0.16158590f, 0.03092790f, 
    -0.37917942f, 0.09900752f, -0.13790987f, -0.06432384f, -0.00752272f, -0.00340575f, 0.04274661f, -0.01224648f, 
    -0.15547383f, 0.00079822f, -0.11807027f, -0.06211012f, -0.32372242f, 0.05086030f, 0.05139209f, -0.10769227f, 
    -0.10471355f, -0.14267088f, 0.05592049f, -0.30456561f, 0.13843390f, -0.37679425f, -0.02909731f, -0.25422171f, 
    -0.21420482f, 0.24517250f, 0.08703673f, 0.05466315f, -0.40008545f, 0.09970360f, -0.30826703f, -0.01545582f, 
    -0.13356619f, -0.02078671f, -0.02506215f, 0.06602713f, 0.02952662f, 0.30410376f, 0.11102200f, -0.40960741f, 
    -0.10051196f, -0.23265235f, 0.02046792f, 0.15847227f, 0.04192349f, 0.12949920f, -0.07329228f, -0.58050919f, 
    0.13684101f, -0.62092566f, 0.27627027f, -0.06912564f, -0.01282743f, 0.10319371f, -0.37730384f, -0.26353991f, 
    -0.09518310f, -0.05658102f, -0.19856641f, -0.38073897f, -0.06836448f, -0.49147940f, 0.02480416f, -0.04402158f, 
    -0.23431300f, -0.10687103f, -0.06967592f, -0.24085884f, 0.16809441f, -0.16628160f, -0.20395134f, -0.23238276f, 
    0.12368451f, 0.14183076f, 0.24581152f, 0.00509243f, 0.12419455f, 0.07415061f, -0.15315412f, -0.04666615f, 
    -0.05133992f, 0.19966388f, -0.18724397f, 0.17243466f, 0.15827034f, -0.36836758f, 0.35443109f, 0.03249464f, 
    -0.23651098f, -0.78303260f, 0.05142712f, 0.10389981f, -0.01653470f, -0.02276064f, -0.17094614f, -0.01537515f, 
    -0.12776934f, 0.13687755f, 0.11860048f, 0.17436992f, 0.00536036f, -0.14543484f, 0.03101206f, 0.13078691f, 
    -0.18626846f, -0.09555548f, 0.05564863f, 0.01152537f, -0.04987162f, 0.08213925f, -0.09424841f, -0.18179721f, 
    -0.39295134f, -0.17539001f, 0.08647469f, -0.12153870f, 0.17284338f, 0.11074544f, -0.03611043f, 0.05057184f, 
    0.09244262f, -0.01356859f, -0.42834392f, -0.19212326f, 0.08454066f, 0.32188442f, -0.03041855f, -0.14167619f, 
    -0.23384207f, -0.10073020f, 0.17558762f, 0.09566360f, 0.05972785f, -0.07974881f, 0.14578050f, 0.03688931f, 
    0.02524156f, 0.03865078f, -0.09020048f, 0.18778868f, -0.59701538f, -0.03801990f, -0.33624148f, 0.03064828f, 
    0.17374487f, -0.19989173f, -0.24153534f, -0.03556881f, -0.06700311f, 0.15226322f, -0.35798132f, 0.32768929f, 
    0.09261566f, -0.40919521f, -0.02955777f, -0.23593776f, -0.62642664f, 0.10059338f, -0.01271972f, 0.11581573f, 
    0.09183998f, -0.07610809f, 0.11624637f, -0.35720411f, -0.05231705f, -0.20530672f, -0.42699066f, 0.23299797f, 
    -0.04709447f, -0.82229084f, -0.57687491f, -0.44788805f, -0.12063694f, -0.08798005f, 0.03126876f, 0.24571103f, 
    -0.08815177f, -0.03589172f, -0.08539665f, 0.01532427f, 0.14371398f, -0.32951206f, 0.12596986f, 0.16112295f, 
    0.24019398f, 0.00948062f, -0.29536089f, 0.03176737f, -0.14738090f, -0.22058295f, 0.08694197f, -0.01788894f, 
    0.42662835f, 0.13686633f, 0.16279371f, -0.08400299f, -0.38220525f, -0.18326966f, 0.09891986f, -0.25147492f, 
    -0.09928002f, -0.12235081f, -0.15237328f, 0.09763982f, 0.00023288f, -0.24657668f, -0.12937294f, -0.45579827f, 
    0.14938675f, -0.32078630f, 0.05963014f, 0.26528448f, 0.17768115f, -0.06361514f, -0.18736345f, -0.61994493f, 
    0.17354409f, -0.43374929f, -0.61994278f, 0.14183542f, 0.08849995f, 0.05632629f, -0.01671520f, -0.12678705f, 
    -0.12109679f, -0.43999511f, 0.07253427f, 0.17855670f, -0.53131616f, 0.29198143f, 0.05951184f, 0.07452675f, 
    -0.09647010f, 0.19116534f, 0.34303379f, -0.03825974f, -0.10627222f, -0.21154833f, -0.28994757f, 0.29287195f, 
    -0.00009337f, -0.06346032f, -0.00557678f, -0.03340376f, -0.28700244f, 0.20223710f, 0.08035744f, 0.01115533f, 
    -0.15120344f, -0.20531943f, -0.33021107f, 0.16291888f, -0.25999451f, -0.20607476f, 0.21456520f, -0.35048372f, 
    -0.24090646f, -0.21556410f, 0.29074594f, 0.03270631f, 0.06034799f, -0.31775790f, 0.27930921f, -0.13309249f, 
    0.24665710f, -0.40517792f, 0.23882043f, 0.10281418f, -0.17128401f, -0.02441419f, 0.25598177f, 0.14447330f, 
    -0.03867806f, -0.72563672f, 0.04543237f, -0.37111226f, 0.01956416f, -0.26030049f, 0.16172023f, 0.04514096f, 
    0.13552020f, 0.02024763f, 0.18914017f, -0.59334594f, 0.05471141f, -0.25130779f, -0.03919987f, 0.04393632f, 
    0.15081938f, -0.29195330f, -0.52029318f, 0.26445228f, -0.07988710f, -0.12633872f, -0.21044891f, -0.22074607f, 
    -0.17555812f, 0.20487590f, -0.28529713f, -0.00381615f, 0.05547727f, -0.26836723f, -0.04608962f, -0.52626729f, 
    -0.09762475f, 0.00739791f, 0.37178186f, -0.01949247f, -0.19976696f, 0.33319896f, -0.42362753f, 0.12286398f, 
    -0.06246594f, 0.01290424f, 0.00970843f, 0.15100980f, -0.01818216f, -0.22480127f, -0.03080032f, 0.00399007f, 
    -0.00105887f, -0.07399271f, -0.45725405f, -0.18321267f, -0.02545387f, 0.02205499f, 0.11919287f, 0.39225164f, 
    -0.50320768f, 0.19384138f, -0.27651504f, 0.02614204f, 0.29993761f, 0.00537225f, 0.18310179f, -0.02076127f, 
    0.10291696f, -0.10525361f, -0.30685717f, -0.06880695f, -0.40424770f, 0.12226386f, -0.10330758f, -0.47701979f, 
    -0.31900820f, -0.47801563f, -0.04407675f, 0.14010510f, -0.11601093f, -0.08028864f, -0.22504869f, 0.08304556f, 
    0.44414935f, 0.19824667f, 0.02841559f, -0.24423189f, -0.31044978f, 0.07119039f, 0.13655311f, -0.15235850f, 
    -0.57007736f, 0.02594559f, -0.07349087f, 0.05964048f, -0.07211541f, -0.02335717f, 0.16354227f, 0.08917403f, 
    0.34325004f, -0.18875553f, 0.11898955f, -0.06738629f, -0.12068631f, -0.06360509f, 0.02722412f, -0.42585120f, 
    0.20866735f, 0.25123069f, -0.04134611f, 0.12151554f, -0.04212030f, -0.02077773f, -0.28347555f, 0.36036798f, 
    -0.21583250f, 0.12678067f, 0.37143815f, 0.10545300f, 0.12031331f, -0.24675903f, 0.09368569f, 0.01434543f, 
    0.10841698f, -0.04740583f, -0.29029948f, 0.12875962f, -0.21281379f, -0.28786960f, -0.23505513f, 0.11779059f, 
    0.10990315f, 0.02148236f, -0.02724912f, -0.19825932f, -0.19610037f, -0.21787706f, -0.25072503f, 0.14698319f, 
    -0.16399978f, 0.02027364f, 0.11518487f, -0.24062425f, -0.32720661f, -0.24596415f, -0.06864790f, 0.05313362f, 
    0.02653172f, -0.64171040f, 0.13911401f, -0.05869610f, 0.15254138f, 0.45543826f, -0.48584315f, -0.30266672f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.16302681f, 0.06116081f, -0.07796453f, 0.10805739f, -0.11619823f, 0.02345202f, 0.03347765f, -0.08779005f, 
    -0.10546236f, 0.13377222f, 0.04059758f, -0.00855257f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
