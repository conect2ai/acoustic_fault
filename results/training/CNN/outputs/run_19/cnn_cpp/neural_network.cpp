#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    1.63446426f, 0.29318106f, -0.82773328f, 1.12040842f, 1.15981412f, 0.76718754f, 0.32579017f, -1.16092885f, 
    0.44482020f, 0.28083187f, -0.35593793f, 0.01329610f, -0.51538497f, 0.12060303f, -0.12137581f, -0.12699743f, 
    0.02608820f, -0.06112590f, -0.09347189f, -0.17786725f, 0.22277133f, 0.25321764f, 0.11295321f, -0.14356376f, 
    0.34347475f, 1.29093826f, 0.90378857f, -1.11156750f, 0.72677773f, -0.52950907f, 0.03955304f, 0.72966069f, 
    1.15832770f, 1.05496609f, 0.63750219f, 0.05304097f, -0.01092319f, 0.26105797f, -0.43077850f, -0.00628235f, 
    -0.11161959f, -0.38398957f, -0.15680209f, -0.31766969f, 0.12735300f, 0.19753885f, -0.19560988f, 0.07222915f, 
    0.22074604f, -0.22199500f, 1.65423787f, -0.82686353f, 0.81422049f, 0.20928080f, 0.83516741f, 0.55846554f, 
    0.16605669f, -0.19590665f, -0.61460620f, -0.85522950f, 0.15795675f, -0.19533202f, -0.45932865f, -0.08708267f, 
    0.20570669f, 0.15528397f, 0.13587247f, -0.17957970f, 0.15124410f, 0.07928725f, 0.13809237f, 0.14132653f, 
    0.08766289f, -0.00516564f, 0.26092345f, 0.08787284f, 0.73300552f, -0.67302680f, -0.53478926f, 0.25911900f, 
    -1.16797900f, -1.22294545f, -1.12889433f, -0.61000568f, -0.74140495f, -0.17785171f, 0.13058712f, -0.05465446f, 
    -0.45241049f, -0.68815547f, -0.59242553f, -0.18178551f, -0.28526145f, -0.42446813f, -0.07954118f, 0.18459560f, 
    -0.18219511f, 0.20110488f, 0.22168612f, -0.19716544f, 1.06423783f, 1.73168945f, 1.26974905f, 0.65037787f, 
    -0.16618386f, -0.53954500f, 0.37270489f, -0.66499162f, -0.47187224f, -0.00544915f, 0.31304434f, 0.40943429f, 
    -0.07023416f, 0.62518138f, 0.40237480f, 0.57278806f, -0.52739632f, -0.04748286f, 0.17291917f, -0.44681105f, 
    0.16679177f, 0.46941927f, 0.01294603f, 0.25911003f, 0.12048105f, 0.85412747f, 0.48331609f, 1.14660811f, 
    1.19207942f, 0.96359479f, 1.37222123f, 0.61518013f, 0.49727488f, 0.35854936f, -0.06538098f, -0.42327067f, 
    0.30429769f, -0.25245762f, 0.31263837f, 0.08261673f, -0.18548007f, -0.02381468f, 0.14706101f, -0.04299818f, 
    0.31724676f, -0.39718169f, -0.25369513f, 0.31070408f, 0.20985883f, -0.04083408f, 1.49265373f, 0.23748356f, 
    -0.26022378f, 1.39221299f, -0.13498577f, -0.65712458f, -0.81936538f, 0.54780787f, -0.85145450f, -0.04862476f, 
    -0.66733611f, -0.22244921f, 0.55914348f, -0.29999101f, -0.07883310f, 0.37131390f, 0.18096726f, 0.41899455f, 
    0.26084694f, 0.26069823f, 0.26223010f, -0.13901256f, -0.14042322f, -0.24611783f, -0.18823779f, -1.08572865f, 
    -0.48980740f, -1.44944894f, -0.86030328f, 0.08641470f, -0.59361821f, 1.09477544f, 0.62165999f, 0.34895253f, 
    0.88655597f, -0.29350144f, -0.21439011f, 0.58309674f, -0.42718565f, -0.30940065f, -0.09626606f, 0.37725312f, 
    0.05984527f, 0.20488292f, -0.44737047f, -0.15318033f, -0.02197926f, -0.44405347f, -0.26965272f, 0.08386221f, 
    -0.57667607f, -1.53732312f, -0.64992714f, -0.18469197f, -0.92450100f, 0.09100694f, 1.38693905f, 0.61443782f, 
    -0.74502134f, 0.24979088f, -0.38886178f, -0.38541803f, -0.44275612f, -0.26029494f, -0.26929650f, -0.52367228f, 
    0.09239601f, 0.01809398f, -0.43896464f, -0.14903465f, -0.21974306f, 0.26574880f, 0.28928956f, 0.38938984f, 
    -0.01854749f, -1.36572468f, -1.13730812f, -0.48365030f, 0.12534259f, 0.08009818f, -0.38979682f, 0.79304677f, 
    0.39920968f, -0.70035726f, -0.27379525f, 0.31476587f, 0.70016617f, 0.09994263f, 0.73051029f, 0.55011851f, 
    0.11683744f, 0.10391909f, 0.08022705f, 0.12112951f, 0.29112417f, 0.35754192f, -0.38332576f, 0.25251997f, 
    -0.20220119f, 0.00410848f, 1.42128050f, 0.05798188f, -1.40417087f, -1.72819710f, -0.82323039f, 0.69627506f, 
    -0.05702024f, 0.36656100f, 0.03353469f, 0.05476881f, -0.38264617f, -0.03004070f, -0.00958765f, -0.08250899f, 
    -0.49318424f, -0.11262520f, -0.00192316f, 0.02832402f, 0.32028595f, -0.02034802f, 0.16153826f, 0.04583915f, 
    -0.12226772f, -0.13358866f, 0.16249746f, -1.21202672f, -0.63448751f, -0.44776708f, 0.51034361f, -0.05434253f, 
    -1.48380983f, -0.31729859f, -0.34929073f, -0.93596637f, -0.13465440f, 0.49630535f, 0.25968748f, 0.27739766f, 
    0.13955019f, -0.13384114f, 0.30679390f, 0.47343153f, 0.40819877f, 0.04505035f, 0.27518833f, -0.18060860f, 
    -0.27839819f, -0.05761493f, 0.48356581f, -0.01711797f, -0.22998525f, -1.28891647f, 0.99158138f, 1.20195889f, 
    -0.93913001f, -0.71203446f, 0.66454560f, 1.04312897f, -0.26831335f, -0.28520289f, 0.14290214f, -0.06977608f, 
    0.14053103f, 0.21202691f, 0.13800429f, -0.55619931f, -0.15406418f, -0.18731466f, -0.03960819f, -0.50904304f, 
    -0.38946006f, 0.07707253f, -0.48215559f, 0.12641044f, -0.07061927f, -0.01083225f, 1.28335571f, 1.10981631f, 
    -1.84203470f, -0.12401246f, -0.56961954f, 0.48935917f, -0.09738439f, -0.40357611f, -0.33496344f, 0.35662639f, 
    0.67918712f, -0.11170501f, 0.12508322f, 0.02541289f, 0.11909327f, 0.41246277f, 0.01778779f, 0.18636332f, 
    0.41462722f, -0.15201625f, -0.15698050f, 0.08341204f, -0.30769014f, 0.49487296f, 0.34145057f, -0.34303880f, 
    1.14244652f, 1.11168098f, 0.93908173f, -1.00005329f, 0.09610993f, -0.93660456f, -0.90407699f, 0.21769805f, 
    0.75451946f, 0.23736218f, 0.56180996f, 0.41475499f, -0.08573184f, -0.39517802f, 0.39955994f, 0.31544861f, 
    0.29887769f, -0.05750443f, -0.16188917f, 0.01537487f, -0.04093279f, -0.07040735f, 0.34393221f, 0.41765353f, 
    0.04846669f, 0.96868151f, 0.47263616f, 0.46727052f, -0.66662163f, 0.50698113f, -0.05376619f, -0.04551017f, 
    0.17111006f, 0.34239277f, -0.37268731f, -0.70916438f, -0.54117757f, -0.89236313f, 0.52291894f, -0.63820815f, 
    -0.71391439f, -0.54605609f, -0.11178498f, -0.33729830f, -0.07178256f, 0.05855454f, 0.25967279f, -0.47342333f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.16715939f, 0.39907783f, -0.03992090f, 0.55389816f, 0.00530688f, 0.07107300f, 0.01714265f, 0.43277887f, 
    0.08199755f, 0.61530185f, 0.29722965f, 0.42496055f, 0.21870683f, 0.31844226f, 0.12035057f, 0.01700034f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.25289062f, -0.20563400f, 0.37267360f, 0.51846677f, -0.07987893f, -0.07214545f, 0.08314455f, 0.06518708f, 
    -0.12488894f, 0.13834536f, 0.03044610f, -0.13636066f, -0.42605430f, 0.19763093f, -0.30576667f, 0.01928835f, 
    -0.19867887f, 0.02377884f, -0.14206490f, -0.14495668f, -0.03289299f, -0.03550472f, 0.17399786f, 0.04626005f, 
    0.58260608f, -0.31855065f, -0.02181210f, -0.09984668f, -0.27293637f, -0.08610818f, -0.01333079f, 0.07079444f, 
    -0.04297252f, -0.00088540f, 0.11026667f, -0.19253631f, -0.09542023f, -0.14987604f, 0.18617985f, 0.06235022f, 
    -0.23298271f, -0.13558835f, 0.01499333f, -0.08228665f, 0.05484051f, -0.24232820f, -0.01249092f, 0.11721496f, 
    -0.02374294f, 0.24623282f, -0.05957772f, 0.05069199f, -0.42874938f, 0.20553339f, -0.06332355f, 0.17059076f, 
    -0.23247541f, 0.14577666f, -0.21035486f, -0.16239224f, 0.15995286f, -0.05643156f, -0.38152310f, 0.34980801f, 
    -0.03248110f, -0.02000105f, -0.05108852f, 0.02479861f, 0.03720459f, -0.04649493f, -0.08720827f, 0.10334770f, 
    0.56599760f, -0.11542380f, -0.07628317f, 0.38897651f, -0.12905672f, 0.04497857f, -0.26185769f, 0.05895946f, 
    -0.07961010f, 0.17397562f, 0.00497320f, -0.05994359f, 0.23900862f, 0.57787561f, -0.24263437f, -0.58891648f, 
    0.05830332f, 0.14064902f, -0.01067940f, 0.08170452f, -0.03897652f, 0.00946797f, -0.13944513f, 0.14107192f, 
    -0.30889788f, 0.43863696f, 0.06231735f, -0.17522563f, -0.04210937f, 0.10487397f, -0.24139331f, 0.01731230f, 
    -0.12885658f, 0.03856703f, 0.09255695f, -0.01280130f, -0.78694254f, 0.18036158f, -0.01916791f, 0.15059946f, 
    0.17596094f, 0.11728048f, -0.04808140f, 0.10968705f, 0.16145217f, 0.15333164f, -0.04362584f, 0.01872929f, 
    0.18315622f, -0.36778846f, -0.06987497f, -0.79970980f, 0.10984875f, -0.14639731f, 0.26652384f, -0.15301810f, 
    -0.24028501f, 0.11599943f, -0.01477823f, 0.01229581f, -0.53792381f, -0.65077758f, -0.47516429f, 0.16260497f, 
    -0.02798635f, -0.12820418f, -0.01459231f, -0.06674181f, 0.16005820f, 0.10049012f, 0.10566026f, -0.16646038f, 
    -0.30561012f, 0.08001235f, -0.28192961f, 0.52812552f, -0.25686434f, -0.13347983f, 0.16558941f, -0.15273482f, 
    0.06813163f, -0.06326331f, 0.05683502f, 0.06374937f, -0.76005042f, 0.51830798f, 0.24543862f, -0.48206547f, 
    0.06072283f, 0.04782651f, 0.02315520f, 0.00739236f, 0.14101867f, -0.14336030f, 0.05537803f, -0.22421272f, 
    0.24201728f, -0.06646787f, -0.34124240f, 0.28108186f, -0.17219737f, -0.32690933f, 0.08582722f, -0.14904724f, 
    0.00712911f, 0.14200604f, -0.20793614f, 0.06494516f, 0.33679849f, -0.12781574f, -0.05414780f, 0.35515648f, 
    -0.30032685f, -0.10512111f, -0.02225776f, 0.14074494f, 0.09666333f, -0.06713067f, 0.13370830f, -0.19358359f, 
    0.44984719f, -0.40043890f, -0.05262912f, 0.03508834f, -0.01546330f, -0.04117659f, -0.32305738f, -0.04149582f, 
    -0.09895574f, -0.00326216f, -0.07014917f, -0.04773125f, 0.69928348f, -0.21166392f, 0.24905586f, 0.05187211f, 
    -0.03038951f, -0.04379752f, -0.15074366f, 0.14209826f, -0.01694740f, -0.03270062f, -0.19397739f, 0.30196726f, 
    -0.01066265f, -0.39848667f, 0.25292328f, 0.17494310f, -0.06271978f, 0.09322997f, 0.00893095f, 0.00608020f, 
    0.03082172f, 0.12651913f, -0.03961633f, 0.14995554f, -0.12565108f, -0.20559628f, -0.41876036f, -0.77493107f, 
    0.06265096f, -0.14568977f, 0.11421270f, 0.18381217f, -0.07534906f, -0.08716140f, 0.04357843f, -0.11515798f, 
    0.01389143f, 0.10215771f, 0.21846239f, -0.02637078f, -0.19328094f, -0.09319271f, 0.05741823f, 0.07937641f, 
    0.08468977f, 0.11565016f, -0.10133828f, 0.18187983f, 0.53192049f, 0.32585272f, 0.24658538f, 0.36159101f, 
    -0.45534769f, 0.14434378f, -0.04071380f, 0.01878923f, -0.12228834f, 0.07626897f, -0.00511018f, 0.03859253f, 
    0.10037648f, -0.14501818f, -0.02736445f, 0.24206351f, -0.10371007f, -0.15562242f, -0.03932968f, 0.02328295f, 
    0.11452337f, -0.10851464f, -0.10548416f, 0.09913857f, 0.38818553f, -0.27281505f, -0.17043757f, -0.37985921f, 
    0.18474685f, -0.11696459f, -0.02508258f, 0.08998365f, 0.02905084f, -0.03960064f, -0.00298303f, -0.17296340f, 
    0.11869887f, -0.40401661f, -0.27299038f, 0.18066834f, 0.00803430f, -0.18768296f, -0.14417003f, -0.00082156f, 
    0.27851820f, -0.10677658f, -0.07331356f, 0.04860095f, 0.24612054f, -0.08250868f, -0.37532219f, 0.01421891f, 
    -0.16673300f, 0.02821576f, 0.02314217f, 0.06603196f, -0.03846572f, -0.14902885f, -0.03713849f, 0.05577541f, 
    0.28530678f, -0.44720379f, 0.50489336f, -0.79526466f, 0.14824963f, -0.01117690f, -0.09204850f, 0.03585325f, 
    -0.03531995f, -0.20084225f, 0.27119878f, -0.07639997f, -0.02639336f, 0.02015282f, 0.09798941f, 0.08906466f, 
    0.04865508f, 0.11238198f, 0.00494253f, 0.14829431f, -0.11021788f, 0.04436675f, 0.26644716f, 0.25592673f, 
    -0.79421169f, -0.15484490f, 0.02853017f, 0.18429261f, -0.30417001f, 0.03190122f, -0.21038345f, -0.10441453f, 
    -0.13937689f, -0.08027536f, -0.05171017f, -0.20699009f, -0.26242912f, 0.41502726f, -0.38044015f, -0.37302458f, 
    -0.08214223f, 0.10626996f, -0.03046127f, -0.08052737f, 0.12388252f, 0.21223186f, 0.17598313f, -0.05905164f, 
    -0.19309507f, -0.21586394f, 0.05218546f, 0.09531393f, -0.08409777f, 0.01673296f, -0.06671420f, 0.07932147f, 
    0.29733598f, -0.05505344f, 0.17876437f, -0.25535339f, -0.03706181f, 0.11142640f, 0.27160245f, 0.17455347f, 
    -0.06469253f, -0.05871624f, 0.11341266f, -0.19130535f, -0.06975055f, -0.17690942f, -0.47833180f, -0.08312526f, 
    0.57166928f, -0.59843242f, 0.14709246f, -0.34841245f, 0.30375743f, -0.09969971f, 0.09218982f, 0.05879823f, 
    -0.05875549f, 0.09813119f, -0.10381903f, -0.14506519f, 0.30835310f, 0.04676969f, -0.09435397f, 0.12113868f, 
    -0.24264382f, -0.14270280f, 0.23148048f, 0.14994282f, -0.27176222f, -0.15708600f, 0.20182018f, -0.07535748f, 
    -0.69263172f, 0.35537481f, -0.13161893f, -0.40461999f, 0.14302391f, -0.07283063f, -0.13997735f, 0.10710178f, 
    -0.05801535f, -0.05176948f, -0.02289282f, -0.21054466f, -0.88387090f, -0.12596963f, -0.33004490f, -0.57662940f, 
    0.25883225f, -0.03306160f, 0.12189958f, -0.19684950f, -0.05411172f, 0.21164346f, 0.04409525f, -0.17765947f, 
    0.02882485f, 0.13277191f, -0.19460118f, -0.36321446f, -0.03376375f, 0.12656146f, 0.06523651f, -0.18122739f, 
    -0.09189952f, 0.05319703f, -0.02630599f, -0.31913486f, 0.08518375f, -0.10454857f, 0.05761471f, 0.05031077f, 
    0.05405216f, 0.06897100f, -0.11112930f, -0.00898376f, -0.04108945f, 0.13628443f, -0.03533482f, 0.02799486f, 
    -0.02339165f, 0.22888011f, -0.03292030f, -0.10232000f, -0.07299764f, 0.02581811f, -0.08778784f, 0.13486709f, 
    -0.03594832f, -0.03845882f, -0.11178785f, -0.01227240f, 0.40635100f, 0.19266061f, 0.18893690f, 0.50499016f, 
    -0.17247021f, -0.23268510f, 0.18450621f, 0.15747713f, -0.04193468f, 0.09105130f, -0.13927659f, 0.03349909f, 
    0.21942547f, -0.09725615f, 0.48068479f, 0.16756354f, -0.19339390f, -0.26910037f, -0.12623802f, 0.01615420f, 
    0.20959176f, 0.14799333f, 0.06367123f, 0.11508556f, 0.78666198f, -0.03118377f, -0.02791683f, -0.13747540f, 
    0.00988237f, 0.01751103f, -0.09731971f, 0.17775147f, -0.00679822f, -0.16931638f, -0.12105972f, -0.11347789f, 
    -0.58782423f, 0.01682760f, -0.02471226f, -0.05964500f, -0.09521864f, -0.29419523f, 0.13174939f, -0.00170728f, 
    -0.32745925f, 0.03482880f, 0.00367323f, 0.27332121f, 0.75907540f, -0.28018233f, -0.30430663f, -0.05451018f, 
    -0.11474781f, 0.26704830f, -0.41206130f, -0.00246573f, -0.20136814f, -0.13090114f, -0.08275675f, -0.33312735f, 
    0.49142587f, -0.04073524f, -0.39396700f, -0.10058584f, -0.19601227f, 0.12796970f, 0.08859617f, 0.12594835f, 
    0.35931522f, 0.17906132f, -0.00170686f, -0.20160936f, -0.21252961f, -0.12875877f, -0.27837542f, -0.24810810f, 
    0.12756246f, -0.12605719f, 0.11497860f, -0.04425362f, -0.03926338f, -0.06284679f, -0.02714624f, -0.12647766f, 
    0.45367047f, 0.13083218f, -0.00793674f, 0.25261143f, -0.08638064f, 0.27384236f, -0.13305061f, -0.17666334f, 
    -0.27495036f, 0.01869767f, -0.15635453f, -0.08536217f, -0.00115178f, 0.06425432f, -0.24429196f, -0.18888867f, 
    0.00732571f, -0.01868269f, -0.04008312f, -0.12620921f, -0.25156644f, -0.05621672f, 0.05691545f, -0.12897916f, 
    0.23966333f, -0.34299776f, -0.54097980f, -0.05302429f, 0.06518487f, -0.06820071f, -0.02239897f, -0.16897681f, 
    0.01334212f, -0.24305449f, 0.18069169f, 0.01915618f, 0.35021693f, -0.68656451f, -0.35618824f, -0.18730295f, 
    -0.00818569f, 0.03056432f, -0.01001206f, 0.01377302f, -0.14486329f, 0.05847551f, -0.01422685f, 0.02898873f, 
    -0.77904284f, -0.30806538f, 0.09575257f, 0.25632674f, -0.23195052f, 0.32882828f, -0.11592157f, 0.16921718f, 
    -0.04772537f, -0.01416542f, -0.09597360f, -0.07045554f, 0.40122613f, 0.42056391f, 0.13993502f, -0.04848084f, 
    0.15651995f, 0.13522352f, -0.03535160f, 0.13423985f, 0.24576488f, 0.14891268f, -0.20376107f, -0.07081079f, 
    -0.43451458f, -0.44345659f, -0.10709509f, 0.00470440f, -0.02803965f, -0.08567060f, -0.09501743f, 0.03062594f, 
    -0.14138600f, -0.11939701f, 0.18644431f, -0.31204158f, -1.07063222f, -0.74727285f, -0.15279834f, 0.06032297f, 
    0.02829931f, -0.20078732f, -0.09528617f, 0.02763931f, 0.12778963f, -0.00256059f, 0.05838386f, -0.03128570f, 
    0.75240827f, -0.58081377f, 0.07292783f, 0.13033354f, 0.00652036f, 0.18412034f, 0.28752595f, -0.27505234f, 
    -0.04097053f, -0.07899263f, 0.08658901f, 0.26907364f, -0.34351927f, 0.21032399f, -0.11049686f, -0.18074974f, 
    -0.21682449f, -0.16547740f, -0.09684718f, -0.22322707f, -0.24867597f, -0.02025370f, -0.32753628f, 0.08123086f, 
    0.30810651f, -0.28192419f, 0.05063612f, 0.09350757f, -0.22336482f, 0.02673538f, 0.10479609f, 0.27941638f, 
    -0.04719271f, 0.09103777f, 0.07271085f, 0.02201795f, -0.13186355f, 0.15444969f, 0.17867336f, -0.18888642f, 
    -0.27322894f, -0.36858070f, 0.04669244f, -0.09310874f, 0.10471881f, -0.06727444f, -0.02863852f, 0.11955895f, 
    -0.08258634f, -0.40837967f, 0.09931011f, 0.21243730f, 0.05958646f, 0.06397144f, 0.04478671f, 0.00394845f, 
    -0.28284702f, 0.29797569f, -0.13164726f, 0.21722737f, -0.18623438f, 0.20497771f, 0.25466505f, 0.13128074f, 
    0.13118750f, -0.09055028f, -0.00154464f, -0.08555298f, -0.10582519f, -0.09839627f, -0.19129618f, -0.06870432f, 
    0.09990909f, 0.18254535f, 0.25455114f, -0.30352458f, 0.02721286f, 0.27680168f, 0.06220338f, 0.11301294f, 
    -0.16043025f, -0.02216904f, -0.11028898f, 0.13806851f, 0.06666923f, 0.16675858f, 0.16396557f, -0.10141803f, 
    0.18514469f, 0.13814177f, 0.12862909f, 0.25660762f, 0.13456866f, -0.02805954f, -0.16309749f, 0.00321473f, 
    -0.71333575f, -0.24211703f, 0.37180573f, 0.70680487f, 0.27125713f, 0.05584259f, 0.10178441f, -0.15422122f, 
    -0.22513723f, 0.01482131f, -0.20618655f, -0.05555873f, -0.61512923f, -0.01570713f, -0.10592870f, 0.01919823f, 
    -0.03241381f, -0.01286086f, -0.17608269f, 0.07879658f, 0.00359705f, 0.21154635f, 0.17950054f, -0.09960054f, 
    0.51060343f, 0.18307374f, 0.00755295f, 0.09139087f, -0.14481671f, 0.10059037f, 0.15244536f, 0.10209407f, 
    -0.19199386f, -0.03981237f, -0.05963990f, 0.24173410f, 0.25708804f, -0.35758212f, -0.12996070f, 0.17180829f, 
    0.02343462f, 0.04364269f, -0.08598349f, -0.26973841f, -0.00747334f, 0.25700471f, 0.01216736f, -0.18848826f, 
    0.11520248f, 0.33831614f, 0.19304618f, -0.45661339f, 0.30559245f, 0.08027647f, -0.16636866f, -0.10324883f, 
    0.06563015f, -0.07917051f, -0.03784065f, -0.21241298f, -0.13236177f, -0.03234315f, 0.25338933f, 0.17378691f, 
    -0.12359634f, 0.09534345f, -0.02103127f, -0.11435552f, -0.10326471f, 0.07964153f, -0.10388038f, 0.11153620f, 
    -0.98785490f, -0.15091485f, 0.21455084f, 0.09871710f, -0.08581680f, -0.13701193f, 0.07835429f, -0.06389901f, 
    0.29002601f, -0.11487892f, 0.09815979f, -0.14093828f, -0.26564845f, 0.17727593f, -0.46391380f, -0.17817481f, 
    0.02846418f, -0.15392801f, 0.08976714f, 0.23516004f, 0.01572383f, -0.06239063f, 0.25022009f, 0.00574434f, 
    0.00035498f, 0.24379252f, 0.01072408f, 0.08410806f, -0.21417907f, -0.00722492f, 0.12130740f, -0.28052327f, 
    0.24993037f, 0.02983161f, -0.13011988f, -0.33149806f, -0.20448290f, -0.30120993f, 0.21620743f, 0.36566898f, 
    -0.03199255f, -0.11924212f, 0.14326811f, 0.02190507f, 0.11261425f, 0.06089801f, 0.08678885f, 0.05259694f, 
    -1.23750114f, -0.06977458f, 0.05028076f, 0.00899577f, 0.11387324f, 0.00149312f, 0.00172765f, 0.18659329f, 
    -0.15488411f, -0.06905399f, 0.07226858f, 0.18919797f, -0.53452075f, 0.44621935f, 0.19081379f, -0.11769145f, 
    0.17594616f, 0.00214210f, 0.05062704f, 0.08465390f, -0.08209635f, 0.05047166f, -0.18969862f, 0.03201215f, 
    -0.40182871f, -0.29461545f, -0.17122254f, 0.43108362f, -0.19373888f, -0.03019644f, 0.13738799f, -0.03285566f, 
    -0.20244369f, 0.04503321f, -0.01159297f, -0.03982805f, -0.00473210f, -0.17187664f, 0.05524666f, 0.20339140f, 
    0.17740934f, -0.08119388f, 0.07565855f, 0.13165878f, 0.08099779f, 0.06840041f, -0.31640133f, 0.05300627f, 
    -0.34180021f, 0.01027142f, -0.07412685f, -0.54776293f, 0.08729721f, 0.15912572f, 0.04398210f, 0.19254564f, 
    -0.11213320f, -0.07657623f, 0.05861881f, 0.16331916f, 0.23262057f, -0.09742606f, 0.25305921f, -0.36538625f, 
    -0.33212161f, 0.03100112f, 0.01702852f, -0.26362392f, -0.10384627f, -0.03531797f, -0.16026209f, -0.05264232f, 
    -0.64433986f, -0.25729162f, 0.31386310f, 0.11155256f, -0.02915706f, 0.06376600f, -0.21883225f, 0.00042570f, 
    0.09251116f, 0.00205091f, -0.14638586f, 0.12052043f, -0.05048975f, 0.37335190f, 0.22055854f, -0.10054454f, 
    0.14074123f, 0.25252026f, 0.12498564f, 0.36625743f, -0.05042707f, -0.00013966f, 0.02650768f, -0.00705291f, 
    -0.38666984f, -0.09926321f, -0.03751707f, -0.37832916f, -0.08515853f, -0.04761962f, 0.11837539f, 0.12511386f, 
    0.20232411f, 0.17783290f, -0.05153363f, 0.04195159f, 0.48614857f, 0.29119575f, -0.02730831f, -0.31052324f, 
    -0.24265106f, -0.08591282f, -0.22348003f, -0.18268514f, -0.02326608f, -0.03443232f, -0.17811935f, -0.06832460f, 
    -0.11550182f, 0.19434214f, 0.09434292f, 0.46564493f, -0.21985045f, -0.02336484f, -0.03626726f, 0.10152780f, 
    0.15059322f, -0.00522426f, -0.04442142f, 0.20068964f, 0.12483878f, -0.08663858f, 0.18130817f, 0.62874824f, 
    -0.05160100f, -0.00887545f, 0.13195883f, -0.11681034f, -0.12285371f, -0.28668374f, 0.01586927f, 0.15732819f, 
    0.22487400f, -0.02131712f, 0.09311204f, 0.16962530f, -0.16048855f, 0.09323499f, -0.00613689f, 0.07397534f, 
    -0.12526751f, -0.05081368f, 0.09915406f, 0.21008724f, -0.15130989f, 0.14402159f, 0.42784151f, 0.11912468f, 
    0.15345867f, 0.05081987f, 0.14644594f, -0.19394012f, 0.14674155f, 0.03991713f, -0.05271556f, -0.04328441f, 
    0.05987583f, -0.04490737f, -0.03056563f, -0.33462393f, 0.05731041f, -0.16047756f, -0.14710055f, 0.18443704f, 
    -0.22922769f, 0.01711804f, 0.01590928f, -0.07936481f, -0.53395098f, -0.32084557f, -0.47525805f, -0.24467891f, 
    0.10092539f, 0.24599974f, -0.20195165f, -0.27055672f, 0.20492902f, -0.10717317f, 0.18748982f, 0.00181354f, 
    -0.25052455f, 0.30250546f, -0.53983152f, -0.09894485f, 0.20969538f, 0.08664250f, 0.19873580f, 0.12348623f, 
    -0.01339479f, -0.07282644f, -0.20225626f, -0.18229562f, -0.59119630f, -0.38273457f, -0.05451949f, -0.18341461f, 
    0.11315358f, -0.06228597f, 0.11197877f, -0.05440864f, 0.15530677f, 0.12626965f, 0.11728087f, 0.11355689f, 
    0.22151628f, -0.18772393f, 0.02670118f, -0.10462703f, 0.08872481f, 0.01195458f, -0.22111766f, 0.09367810f, 
    0.20516358f, 0.01223939f, -0.04507622f, -0.15345757f, 0.15928186f, -0.19361106f, 0.11009433f, -0.21085115f, 
    -0.02733110f, -0.08693372f, -0.12295579f, 0.06698690f, 0.15315011f, 0.15648976f, 0.07681270f, 0.38425276f, 
    -0.27438498f, 0.09993334f, -0.09549193f, -0.08397201f, 0.06305063f, 0.03149859f, -0.08743934f, 0.04683343f, 
    -0.30713487f, -0.26999763f, -0.09343477f, -0.36449009f, -0.00355546f, -0.15165870f, 0.16631484f, 0.13380373f, 
    -0.07270431f, -0.00254913f, 0.07097232f, -0.02381098f, -0.13867126f, 0.06612021f, -0.04067316f, 0.30466315f, 
    0.06952579f, 0.22456259f, 0.12198268f, -0.31823888f, -0.06490339f, -0.05765874f, 0.18599704f, 0.02375995f, 
    -0.18869261f, -0.12739572f, 0.31636667f, 0.18738738f, -0.18353151f, -0.04053817f, -0.09866992f, 0.01255833f, 
    0.00783360f, -0.19508308f, 0.13469113f, -0.07586221f, 0.17440119f, 0.19851516f, -0.36632746f, 0.12445759f, 
    -0.40501347f, -0.03260147f, -0.10807124f, -0.31601217f, -0.11491054f, 0.11790229f, 0.07258619f, 0.04415675f, 
    0.06516133f, -0.27545401f, 0.07506981f, -0.05728254f, -0.98486221f, 0.23322226f, 0.28091818f, 0.31030887f, 
    -0.01065373f, 0.06207652f, 0.07157001f, -0.02924770f, 0.12804137f, -0.07404178f, 0.04934816f, -0.06507810f, 
    0.33924386f, 0.18784018f, 0.15794815f, -0.25658882f, 0.08121158f, -0.08596122f, 0.02179443f, 0.09052006f, 
    -0.25660744f, 0.07181104f, 0.31083709f, -0.01473859f, -0.27959195f, -0.22981907f, -0.32450959f, -0.19212721f, 
    0.11679941f, 0.11615394f, -0.22233178f, 0.01119847f, 0.01353142f, -0.04063996f, -0.03096861f, 0.18184444f, 
    -0.13939916f, 0.36074719f, 0.22041300f, -0.05698729f, 0.18763499f, -0.11372460f, 0.02623073f, 0.10235871f, 
    0.01651526f, 0.00690165f, -0.09076551f, -0.10919488f, 0.13015401f, 0.07457739f, 0.24259229f, -0.43671948f, 
    -0.47045130f, -0.03312475f, 0.03347487f, -0.00748992f, -0.01652928f, -0.11539771f, -0.11740581f, 0.00497432f, 
    -0.02118086f, 0.21651101f, 0.40608513f, -0.40486544f, 0.02740661f, 0.15531939f, -0.18413265f, 0.07780950f, 
    -0.21004660f, -0.08292362f, 0.06729644f, 0.12213676f, -0.91531450f, -0.34173396f, -0.26749092f, -0.25596294f, 
    -0.01707314f, 0.10563641f, 0.14521502f, -0.07220882f, 0.01218211f, 0.03214873f, 0.11064276f, 0.23571008f, 
    0.50315249f, -0.56430942f, -0.00204721f, -0.44272852f, -0.22057590f, 0.12859903f, -0.12307493f, -0.25978681f, 
    -0.24846013f, 0.05932979f, 0.16272882f, 0.18249191f, -0.05745317f, -0.13013345f, -0.16789389f, 0.27208990f, 
    -0.11068882f, 0.12118081f, 0.09548469f, -0.04930303f, -0.06908254f, -0.11207977f, 0.18418522f, -0.15647736f, 
    0.11979850f, 0.02786713f, -0.54148239f, 0.23119630f, 0.06491918f, -0.03085607f, 0.16343576f, -0.00805824f, 
    0.14808676f, -0.01865145f, -0.08543940f, -0.07956635f, -0.21548764f, 0.17839909f, -0.22881101f, 0.01297255f, 
    -0.14674968f, 0.06872889f, 0.06937259f, -0.09666140f, -0.12386556f, -0.17633438f, -0.12004652f, -0.40435785f, 
    0.72402710f, -0.24737136f, 0.38149741f, -0.17813937f, 0.03298782f, -0.25929710f, 0.13339321f, 0.03621030f, 
    0.38965780f, -0.01131838f, 0.14925843f, 0.12092245f, -0.02939578f, -0.34683040f, -0.16043465f, 0.50284511f, 
    0.04955129f, 0.23686573f, -0.01094686f, -0.03738318f, -0.01900654f, -0.27520388f, -0.27384254f, -0.25283587f, 
    0.52870601f, 0.28967118f, 0.21725546f, -0.33360931f, -0.09519750f, 0.10285021f, 0.02020427f, -0.10729561f, 
    0.21278159f, 0.09069261f, -0.29878324f, -0.06551699f, 0.19104448f, 0.07458263f, 0.24236156f, 0.00015607f, 
    -0.00721256f, 0.09631991f, 0.10342794f, 0.12557201f, -0.37843126f, -0.06892043f, 0.43534967f, 0.19320573f, 
    -0.58302742f, 0.46687967f, 0.13101625f, -0.05055307f, -0.12947565f, 0.13081285f, -0.07855409f, -0.04959736f, 
    -0.16412869f, 0.04432113f, -0.09961990f, -0.07583398f, -0.57436180f, 0.08259330f, -0.07960831f, -0.30766228f, 
    -0.14717996f, 0.05105664f, -0.00212183f, -0.22462021f, -0.00105028f, 0.00998061f, 0.08806358f, -0.24475056f, 
    -0.06369480f, -0.16574480f, -0.27700320f, 0.30792603f, -0.02615991f, -0.02215158f, 0.04167930f, -0.21304050f, 
    0.09292337f, -0.04862671f, 0.04035157f, 0.09335097f, 0.07271061f, -0.00147819f, 0.05127449f, 0.39838660f, 
    -0.20691754f, -0.12537862f, -0.42208695f, -0.07414681f, -0.22194126f, -0.08238124f, -0.10603245f, -0.07492162f, 
    -0.19811949f, -0.67072600f, -0.65884972f, -0.17851667f, -0.05676748f, 0.06003391f, 0.04458238f, 0.04497262f, 
    -0.17164318f, -0.07468141f, 0.12048490f, 0.06747805f, -0.31123075f, 0.13708074f, -0.14881398f, -0.27556935f, 
    -0.11685599f, -0.05419238f, 0.01915364f, -0.10486353f, -0.06557573f, -0.07265319f, -0.15486968f, -0.22490925f, 
    -0.02222057f, 0.47202519f, 0.10602716f, -0.05666400f, -0.17778395f, 0.01136650f, 0.19414808f, -0.00048231f, 
    -0.28710803f, -0.15132995f, 0.08492516f, 0.00530598f, 0.09614809f, 0.19450668f, 0.31695312f, 0.22201818f, 
    0.17571782f, 0.08542430f, 0.09689941f, -0.07218402f, -0.03213207f, 0.10574228f, 0.02630899f, -0.03097014f, 
    0.21231298f, 0.39637482f, 0.42432681f, 0.36481336f, 0.05332206f, 0.06510298f, -0.05453298f, 0.19386359f, 
    -0.05258145f, 0.14254054f, 0.05325098f, 0.00545332f, 0.36727026f, -0.18549900f, 0.32685888f, 0.05108495f, 
    -0.09619242f, 0.03240045f, -0.12572244f, -0.08696840f, -0.20729318f, -0.08146524f, -0.14016685f, 0.03933945f, 
    0.17063057f, 0.36979565f, -0.11503448f, 0.16557066f, 0.08749723f, 0.03833994f, 0.02673068f, 0.02986189f, 
    -0.09780858f, 0.15028419f, -0.18620364f, -0.09518089f, 0.21066357f, -0.27666405f, 0.20791630f, -0.01261840f, 
    0.02449284f, -0.14258705f, -0.14383860f, -0.16995884f, 0.06515934f, 0.07956847f, -0.04238148f, -0.27499643f, 
    0.66655600f, -0.01074130f, -0.05113754f, -0.19350003f, 0.07422394f, 0.01197990f, 0.06539537f, -0.04000179f, 
    -0.01874241f, 0.04633973f, -0.01156898f, -0.01908152f, 0.33898899f, -0.54317904f, 0.26451850f, 0.35066727f, 
    0.12219992f, -0.07900153f, -0.02763758f, 0.00876266f, 0.01502875f, -0.40439048f, -0.21883808f, -0.19504718f, 
    0.21468689f, -0.64850414f, -0.25044361f, -0.21828160f, -0.23122996f, -0.06696456f, -0.06593163f, -0.01259911f, 
    -0.14517783f, -0.03241874f, -0.12488653f, -0.19024719f, 0.07626691f, -0.47323555f, -0.04447364f, -0.03519032f, 
    -0.25066271f, 0.01836008f, -0.14005250f, -0.03040275f, -0.21281758f, -0.03396223f, 0.22265868f, -0.00059307f, 
    0.40600935f, -0.02336808f, 0.33507034f, 0.30441666f, 0.00988599f, 0.04468947f, -0.11511289f, -0.05547550f, 
    0.07486662f, -0.15133803f, -0.19465017f, -0.12289450f, 0.15898097f, -0.08395698f, -0.02273623f, 0.05546992f, 
    -0.11690212f, -0.24055924f, -0.24226855f, -0.01734180f, -0.00437136f, 0.10480843f, -0.18435283f, -0.02698641f, 
    -0.13231255f, 0.29585207f, -0.03232284f, 0.22558239f, 0.06911935f, -0.06580882f, -0.09604154f, -0.17599469f, 
    0.09155046f, 0.08457991f, 0.12433230f, 0.26026449f, -0.35286885f, 0.02557599f, -0.53743082f, -0.84497344f, 
    0.04402589f, -0.09483876f, -0.26765493f, 0.22613232f, 0.15350039f, -0.02807981f, 0.01284855f, -0.23542212f, 
    0.23888181f, -0.39065307f, -0.46582040f, 0.30390096f, 0.16107467f, 0.07614490f, 0.05024209f, -0.09250300f, 
    -0.11467253f, 0.04655955f, 0.12196691f, 0.15266897f, 0.27259398f, -0.10357030f, 0.24892405f, 0.36414391f, 
    0.02827372f, -0.03958694f, -0.08725624f, -0.26897138f, -0.15121058f, 0.07500094f, -0.10302063f, -0.35825604f, 
    -0.15808411f, -0.30108446f, -0.24292907f, -0.02856343f, 0.08804798f, -0.22773202f, 0.02914251f, -0.07653200f, 
    0.20045777f, 0.14514059f, 0.24235986f, 0.09554803f, -0.29394281f, 0.11017284f, 0.34073445f, 0.22751655f, 
    -0.29873252f, 0.09022462f, -0.40704584f, -0.19098301f, 0.04732739f, -0.10833805f, -0.04216550f, -0.25107205f, 
    -0.33043444f, -0.11097708f, 0.23934877f, -0.40047866f, -0.16005839f, -0.17130952f, 0.26042432f, 0.04504109f, 
    0.03028761f, -0.24203792f, -0.36417311f, -0.12744378f, 0.01435768f, -0.18151625f, 0.07020642f, -0.11910713f, 
    -0.08162865f, 0.04734697f, -0.05679428f, -0.13499025f, 0.11286524f, 0.01444336f, 0.12842612f, 0.20486635f, 
    -0.25912109f, 0.69080693f, -0.31973410f, -0.16495290f, -0.34844360f, 0.10508130f, -0.34935975f, 0.00814034f, 
    0.24262202f, -0.04846323f, 0.10727663f, -0.16143410f, -0.29565331f, -0.07647896f, -0.08268061f, -0.34915191f, 
    -0.03538645f, 0.12246691f, 0.23070525f, -0.08848791f, -0.01069166f, 0.02950368f, 0.07026766f, 0.18499979f, 
    0.17301226f, -0.40350249f, 0.14994599f, -0.09217651f, 0.21830636f, -0.12561192f, 0.05287104f, -0.02380766f, 
    0.04281391f, 0.03247916f, -0.00934306f, -0.21250315f, 0.61453038f, 0.13766874f, -0.34150124f, 0.08135828f, 
    -0.02888757f, -0.15422885f, -0.13382582f, 0.06279955f, -0.08410303f, 0.09413941f, 0.04268379f, 0.26935208f, 
    0.05186259f, -0.19685479f, -0.51574326f, 0.10267025f, 0.25309175f, -0.05955492f, -0.03100545f, -0.10927802f, 
    0.10077515f, -0.00679454f, 0.13183425f, 0.01153106f, -0.03867229f, -0.23780534f, -0.10426547f, 0.11487593f, 
    0.20611623f, -0.19213359f, -0.07113212f, -0.07550859f, 0.23470815f, 0.03034648f, -0.32935470f, 0.10750355f, 
    -1.08854389f, 0.92438549f, -0.13765012f, -0.15820885f, 0.18643034f, 0.04591243f, 0.02779359f, -0.13219056f, 
    -0.18525524f, 0.08337940f, 0.09824929f, -0.02329410f, -0.29906559f, 0.16693272f, 0.38260967f, -0.17132783f, 
    0.10596288f, 0.06157148f, 0.19360934f, -0.04093556f, 0.13944550f, 0.09946401f, 0.08834150f, 0.09773119f, 
    0.29673669f, 0.16608748f, -0.65031892f, -0.20336899f, 0.22003049f, 0.02432548f, 0.06635163f, 0.03964611f, 
    -0.35378599f, -0.03547614f, 0.04016094f, -0.03472460f, -0.03111914f, -0.19214331f, -0.07648101f, -0.22570719f, 
    -0.04815098f, 0.04769943f, -0.05465018f, -0.01574836f, 0.02573423f, 0.11426919f, 0.15405732f, 0.04127643f, 
    0.07110318f, 0.13636412f, 0.25421032f, -0.35765013f, 0.04788815f, 0.22008811f, -0.06473870f, -0.16822749f, 
    -0.08238662f, -0.15111290f, 0.01693824f, -0.19655575f, -0.12815157f, 0.38737941f, -0.44909143f, -0.47292435f, 
    0.34096333f, 0.02414949f, -0.12166756f, 0.17090380f, 0.16247235f, -0.07709658f, 0.04875840f, -0.02993203f, 
    -0.53276378f, -0.11684419f, -0.33802241f, -0.01323108f, -0.12772833f, -0.09344426f, 0.19482642f, -0.07024967f, 
    -0.13070297f, -0.06454135f, -0.21933681f, -0.08790385f, 0.40127805f, -1.02900064f, -0.16921480f, -0.03387451f, 
    -0.00664152f, -0.14587285f, -0.11068738f, 0.29199532f, -0.18593244f, 0.10805454f, 0.00371383f, -0.04420163f, 
    -0.14424962f, 0.22870065f, -0.15518472f, 0.03275324f, 0.16790067f, 0.19697778f, -0.16662566f, -0.02978409f, 
    -0.13333322f, 0.16285506f, 0.12640809f, 0.12440591f, 0.16061999f, -0.37321317f, -0.62157905f, 0.23252264f, 
    -0.01785040f, -0.13128327f, -0.03036387f, -0.11574627f, 0.01630469f, -0.00684924f, -0.21960986f, -0.24956796f, 
    -0.33832362f, 0.60228831f, 0.41572645f, 0.37321627f, -0.01350912f, 0.08533156f, -0.03423763f, 0.24715047f, 
    0.13663982f, 0.11817581f, 0.00561981f, 0.22450247f, -0.04166941f, -0.15560007f, 0.19164442f, -0.07383119f, 
    0.22489433f, 0.06107541f, -0.00098433f, -0.11133944f, -0.03477684f, -0.16468589f, 0.12590459f, -0.23389697f, 
    0.19784108f, 0.06830675f, -0.19483821f, 0.13976990f, -0.08839759f, -0.01864520f, 0.02598204f, 0.18959679f, 
    0.02058066f, 0.21714684f, 0.03395246f, 0.30615470f, -0.04474565f, -0.31960791f, 0.10521583f, -0.24401987f, 
    0.17894977f, -0.13798182f, -0.06523166f, 0.15316501f, -0.04269466f, 0.09675731f, 0.02167454f, -0.03191698f, 
    -0.46414325f, 0.34455374f, -0.04438459f, -0.64473248f, 0.06454553f, -0.16292843f, 0.02136432f, 0.21823148f, 
    0.00462923f, 0.06938253f, -0.19169600f, -0.01592435f, -0.01912786f, -0.18661216f, 0.02284219f, -0.31597227f, 
    0.04370995f, -0.03386734f, -0.15992394f, -0.04843819f, 0.14883101f, -0.01293679f, 0.24237838f, 0.10017790f, 
    -0.46247432f, -0.39352673f, 0.04650370f, -0.05170159f, 0.29782313f, -0.08597051f, 0.19701232f, 0.07799866f, 
    0.21989852f, 0.21162608f, 0.06498189f, 0.13954526f, -0.45178103f, -0.45913780f, -0.21916805f, 0.03012057f, 
    0.17806749f, 0.19996712f, 0.05682128f, 0.19734553f, 0.14698824f, 0.00541124f, 0.04285466f, 0.09675925f, 
    -0.97058183f, -0.05978167f, -0.12132479f, -0.17638354f, -0.07640408f, -0.13150169f, 0.03322267f, -0.08870810f, 
    -0.13893829f, 0.12150801f, 0.03563230f, 0.15515077f, 0.46284956f, 0.15611085f, 0.42299321f, -0.02369849f, 
    0.23400420f, 0.17339614f, -0.04422479f, 0.24493431f, -0.15850526f, -0.10900412f, 0.02847926f, -0.18116283f, 
    -1.11230171f, -0.40076309f, -0.15733138f, -0.31591880f, 0.18552117f, 0.22956362f, -0.36303741f, -0.06723384f, 
    -0.00174019f, -0.02110532f, 0.04476171f, 0.07262729f, -0.48325393f, 0.08855640f, -0.29906118f, -0.61002427f, 
    0.08668713f, 0.12344158f, -0.14991322f, -0.06989456f, -0.02672233f, -0.07203716f, 0.17779851f, -0.01213432f, 
    -1.15805066f, -0.59202176f, 0.11340985f, -0.20868598f, 0.21146928f, 0.14184415f, 0.01898780f, -0.02140982f, 
    0.22298785f, 0.18160714f, 0.02819972f, 0.13448723f, 0.34159356f, 0.11415537f, 0.06963035f, -0.02585946f, 
    -0.15595002f, 0.12056225f, -0.08982674f, 0.08662118f, 0.05932704f, -0.08794680f, 0.07807229f, -0.25510019f, 
    0.55070066f, 0.12990458f, -0.29182133f, -0.12025554f, -0.30970949f, -0.19412196f, 0.19049457f, -0.35676262f, 
    0.14091446f, -0.00253691f, 0.00121292f, -0.32889590f, 0.24553232f, -0.08479581f, 0.03757088f, 0.00068203f, 
    -0.33884531f, 0.13280950f, 0.05665846f, 0.25966451f, -0.00695907f, 0.13302931f, -0.00559720f, 0.22871773f, 
    -0.31854972f, -0.36323628f, 0.04847112f, 0.16470104f, -0.10465074f, 0.12530392f, 0.02784819f, -0.05697727f, 
    0.19715033f, -0.27483618f, 0.00927136f, -0.28035596f, 0.36240587f, 0.39312169f, -0.02793900f, -0.03190544f, 
    -0.03620865f, 0.22555643f, 0.05055006f, 0.11495479f, -0.04114935f, 0.07288732f, 0.23766784f, 0.36884242f, 
    -0.41872871f, -0.09663192f, 0.02137092f, 0.36062095f, 0.03639623f, 0.19068763f, -0.08548308f, -0.23740509f, 
    -0.04338005f, 0.09805873f, -0.09562989f, -0.08272400f, -0.48196983f, 0.07145374f, -0.12159093f, -0.22046916f, 
    0.04941134f, 0.01226833f, -0.33844298f, 0.12545002f, 0.23318207f, -0.00287042f, 0.13721791f, 0.44112599f, 
    0.10133167f, 0.19297808f, -0.09987677f, -0.39722565f, 0.02269910f, 0.19902362f, 0.00208318f, 0.26574314f, 
    -0.05909023f, 0.01631916f, 0.20128696f, 0.02584252f, -0.40367359f, -0.02304450f, -0.23640172f, -0.45419413f, 
    0.13585085f, 0.13639602f, -0.03191157f, -0.18311858f, 0.15876484f, -0.48265955f, -0.55955976f, 0.00381817f, 
    0.01977684f, -0.11071260f, 0.04308992f, 0.22090942f, 0.04260810f, 0.13076842f, 0.03387113f, 0.02152397f, 
    0.01058025f, 0.06065769f, 0.12144902f, -0.06087463f, -1.00816607f, 0.07707464f, -0.15133059f, 0.09900457f, 
    0.41143638f, 0.07790278f, 0.09259190f, 0.29356787f, 0.04672169f, 0.05300055f, 0.04762678f, -0.15355027f, 
    0.02070355f, -0.50974089f, 0.08832721f, -0.05016246f, 0.07875834f, 0.04329297f, 0.09412663f, -0.12051114f, 
    0.10661674f, -0.03200210f, -0.15022767f, 0.11381206f, 0.09008705f, 0.21642976f, -0.35797632f, 0.45813724f, 
    0.05366864f, 0.00810576f, 0.14370532f, 0.09955034f, 0.12534085f, 0.17906405f, 0.07410039f, -0.11551978f, 
    0.96448296f, 0.07239084f, -0.55998528f, 0.01323386f, -0.04248790f, -0.45706835f, -0.08248944f, -0.03226318f, 
    0.07090253f, -0.02240994f, -0.12404811f, -0.03150700f, 0.12409043f, -0.71185786f, -0.18288888f, -0.62475240f, 
    -0.00440924f, -0.06526222f, -0.00802797f, 0.02182582f, -0.03858310f, 0.00855857f, -0.03324913f, -0.02375485f, 
    -0.62873524f, 0.40840468f, -0.15808249f, 0.06838931f, 0.13397375f, -0.06433680f, 0.18621059f, -0.20267642f, 
    0.11936172f, 0.01497726f, -0.09930234f, 0.00421172f, -0.21924886f, 0.17330296f, -0.15572998f, 0.23011541f, 
    -0.03111198f, -0.08359873f, 0.21582742f, 0.02351809f, 0.00579092f, 0.05016933f, 0.07028078f, -0.16515087f, 
    -0.15577053f, -0.17997201f, 0.00612878f, 0.10815920f, -0.08577952f, 0.03343005f, 0.10709582f, -0.30364272f, 
    -0.05464983f, 0.03673442f, 0.15467830f, -0.21965906f, -0.04629640f, 0.40231234f, 0.15425792f, -0.01816325f, 
    0.13289468f, 0.08693845f, -0.14655218f, -0.09697121f, -0.11645411f, 0.00510233f, 0.10408076f, -0.09556253f, 
    -0.01117693f, 0.09193376f, -0.42708898f, 0.12559637f, 0.05124496f, -0.07920694f, 0.04316478f, -0.40066630f, 
    -0.13565020f, -0.18896747f, -0.00317061f, -0.03532156f, -0.19763990f, 0.45197144f, -0.25488421f, -0.10756065f, 
    -0.16979185f, -0.09742319f, -0.01864443f, -0.21415216f, -0.14766520f, -0.16412370f, -0.15770085f, -0.29280329f, 
    -0.70092189f, 0.32375616f, 0.05580389f, -0.24017981f, 0.19737603f, -0.11395659f, -0.10817283f, -0.04796955f, 
    0.11684731f, 0.20922978f, 0.02638148f, 0.13915560f, 0.26556656f, -0.28181291f, -0.00248879f, 0.64113843f, 
    -0.18407691f, -0.11947465f, 0.08175382f, -0.06973661f, -0.09060033f, -0.00461606f, 0.11023591f, -0.10708617f, 
    0.13143982f, -0.04088292f, -0.45707199f, 0.10174066f, 0.26703304f, -0.00758013f, -0.02989861f, 0.15938424f, 
    -0.04438807f, 0.12954734f, -0.01025010f, -0.02269266f, 0.19743222f, 0.21671493f, -0.56038731f, -0.30284503f, 
    -0.14556064f, -0.00409254f, -0.01358428f, 0.05921501f, 0.01721534f, 0.10371026f, 0.25767300f, -0.25509492f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.08118097f, -0.00519035f, -0.16685449f, 0.02352940f, 0.01130554f, -0.04881733f, -0.08804926f, -0.18975998f, 
    -0.01769952f, -0.01963646f, 0.27328429f, 0.05092283f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
