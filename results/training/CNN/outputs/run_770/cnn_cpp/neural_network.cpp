#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.49626580f, 0.28330395f, -0.04565813f, -0.28701594f, 0.13480993f, -0.24748436f, -0.41159183f, -0.34835362f, 
    -0.34997204f, 0.15281230f, -0.26057541f, 0.50670123f, 0.23856306f, -0.51014704f, 0.48176074f, 0.00072048f, 
    -0.49597421f, 0.18156074f, 0.48261738f, -0.10986680f, -0.14426070f, -0.69989049f, 0.11522257f, 0.36467141f, 
    0.02881573f, 0.21702898f, 0.39779198f, -0.10381853f, -0.63601142f, -0.56467247f, -0.36097464f, -0.56430036f, 
    -0.20540318f, -0.01416830f, 0.21219380f, 0.17937808f, -0.73942780f, -0.55276829f, -0.27478358f, 0.29637507f, 
    0.45053986f, 0.56920266f, 0.09294870f, -0.26546085f, 0.18469733f, -0.77285248f, 0.25762409f, 0.30158824f, 
    0.50843573f, 0.29636830f, -0.27262682f, 0.10227838f, -0.04218910f, -0.08458630f, 0.25196016f, 0.64095086f, 
    0.00160360f, 0.43700901f, 0.38945732f, 0.41785938f, 0.34067014f, -0.22247007f, 0.12090424f, 0.47715718f, 
    0.29614079f, 0.15942691f, 0.38693374f, -0.63902384f, -0.08860098f, 0.16395697f, 0.24738646f, 0.05768067f, 
    -0.32983434f, 0.42119417f, -0.09470718f, -0.45449269f, -0.48509333f, -0.50775778f, -0.05476561f, 0.23264761f, 
    -0.07100989f, 0.41338822f, 0.58934361f, 0.66997343f, 0.15430301f, -0.22851655f, 0.23895907f, -0.34200600f, 
    -0.11509246f, -0.15678962f, 0.84312898f, 0.42313549f, 0.16615649f, 0.06705388f, -0.00796077f, 0.11133052f, 
    -0.14813960f, 0.53050631f, -0.15569170f, -0.35870135f, -0.13915154f, -0.20039424f, -0.03753138f, 0.70759070f, 
    -0.51842195f, 0.29032689f, 0.10841226f, -0.35661003f, -0.03922392f, 0.60258442f, -0.34053800f, -0.35144421f, 
    0.02460791f, -0.56110507f, 0.18107334f, 0.12548436f, 0.29150915f, 0.37444794f, 0.49768138f, -0.88756901f, 
    0.37957022f, -0.28337422f, 0.00474140f, 0.07487544f, 0.25241461f, 0.27644575f, 0.44049314f, 0.75262088f, 
    0.04827236f, -0.38219231f, -0.13835754f, -0.49762210f, -0.00698689f, -0.15101765f, -0.16703930f, 0.39513922f, 
    -0.15807408f, 0.23586728f, 0.41988751f, 0.47485670f, 0.34617433f, -0.33456823f, -0.26085624f, -0.22183041f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.06693148f, -0.08765141f, -0.13332085f, 0.06500741f, 0.30713803f, -0.15985405f, -0.28572530f, -0.09682152f, 
    0.28923908f, 0.26421943f, 0.12255847f, -0.18379574f, 0.09662326f, -0.10347936f, -0.23142923f, -0.04896758f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.12583649f, 0.12960023f, 0.13665365f, -0.04203351f, -0.02064303f, -0.01930191f, 0.14752525f, -0.07929743f, 
    0.05742500f, -0.44825315f, -0.14402473f, -0.11473306f, 0.07318503f, 0.14028932f, 0.20007282f, 0.00832962f, 
    -0.04454814f, -0.09265879f, -0.00568306f, 0.02787320f, -0.20030361f, -0.15328573f, 0.04451813f, -0.02423961f, 
    0.10955119f, -0.08133131f, 0.12313721f, 0.07653459f, -0.11502516f, -0.14562251f, 0.11529135f, -0.06110972f, 
    -0.03968707f, 0.16569249f, 0.03367136f, -0.06632587f, -0.17086197f, -0.25123018f, 0.03262144f, 0.11040577f, 
    -0.04752370f, -0.01131990f, -0.10795272f, -0.06392088f, -0.02503877f, 0.15397944f, -0.20210166f, -0.20142001f, 
    -0.02459783f, -0.01243055f, 0.00391757f, -0.00690092f, -0.11121140f, -0.08593783f, -0.19224051f, -0.16917366f, 
    -0.02888059f, 0.28334042f, 0.05802247f, 0.28839180f, 0.09434269f, -0.02522181f, 0.07278439f, 0.10150000f, 
    0.00601828f, 0.11316691f, -0.03793210f, 0.14176187f, -0.01187977f, 0.17639494f, -0.04496130f, 0.06565595f, 
    -0.02238091f, 0.09869594f, 0.06961334f, 0.04295828f, 0.04013611f, -0.06922564f, -0.01193858f, 0.13986263f, 
    0.17086017f, 0.07362900f, 0.37681070f, 0.30916876f, 0.11842269f, 0.05833622f, 0.13954122f, 0.18716218f, 
    0.08972289f, -0.06938558f, -0.01517078f, 0.30398831f, 0.03641269f, 0.10365551f, 0.10509345f, 0.04212474f, 
    0.15118763f, -0.12293293f, -0.02254791f, -0.25116876f, -0.07236436f, -0.25228772f, 0.00149082f, 0.05405430f, 
    0.03700421f, -0.01179075f, -0.06515953f, -0.00684161f, -0.07459979f, 0.09951431f, 0.16202375f, 0.12731107f, 
    0.00024056f, -0.13670404f, 0.03366829f, -0.14710271f, -0.03172869f, 0.00953365f, -0.08484464f, 0.10824283f, 
    -0.42913416f, -0.06528856f, -0.20190488f, -0.09014276f, 0.01357806f, -0.13670221f, -0.21124330f, 0.20232294f, 
    0.09549942f, -0.04314947f, 0.08557571f, -0.04130631f, -0.03313651f, -0.00491959f, 0.03685179f, -0.08194375f, 
    0.07541333f, 0.07891347f, 0.12743208f, 0.16258831f, 0.13190696f, 0.02898824f, 0.00540517f, 0.09962494f, 
    -0.05049229f, 0.01615824f, 0.02716674f, 0.01193744f, -0.05608872f, -0.01651116f, 0.00452318f, -0.00553607f, 
    -0.07149768f, 0.02784749f, -0.04987933f, -0.01919788f, -0.03277303f, -0.06847057f, -0.05003713f, 0.05579188f, 
    -0.06109570f, -0.04921794f, 0.00165130f, 0.06024339f, 0.01367898f, -0.01477552f, 0.02077036f, 0.03181151f, 
    0.00702209f, -0.05356598f, -0.04078827f, -0.09614515f, 0.02038822f, 0.05828812f, -0.02264533f, -0.03369896f, 
    0.03914735f, -0.08389118f, 0.06148986f, 0.02848713f, -0.07885327f, -0.00000535f, -0.06718274f, 0.04391866f, 
    -0.04335950f, -0.01685114f, 0.04332212f, -0.04059780f, -0.03275786f, -0.08416568f, -0.04733959f, 0.04380708f, 
    0.00831294f, 0.00358029f, -0.04972908f, -0.05325413f, -0.06871140f, 0.03511747f, -0.08261878f, -0.03258764f, 
    0.03203908f, -0.08489831f, 0.06058229f, -0.01277641f, -0.05823135f, -0.04635735f, 0.02819334f, 0.03565506f, 
    0.01398517f, 0.07002088f, -0.02120255f, -0.00142771f, -0.04727226f, 0.05286590f, -0.07346598f, -0.00377536f, 
    -0.09423958f, -0.07459304f, 0.04381531f, -0.03082050f, -0.04599817f, -0.00059627f, -0.02768732f, -0.02083341f, 
    0.02166993f, -0.05137856f, -0.01727187f, 0.00609476f, -0.08126821f, 0.04959884f, -0.02642545f, -0.02431046f, 
    -0.05664441f, 0.03912445f, -0.05603737f, -0.00857114f, -0.03900193f, -0.05786120f, -0.03968184f, 0.03306422f, 
    -0.04846785f, -0.09312171f, -0.05399096f, 0.01186549f, 0.06856909f, -0.02161042f, -0.09575814f, -0.01599509f, 
    -0.08044220f, -0.00790059f, 0.01180520f, 0.01552643f, 0.05367575f, 0.04340389f, -0.02508222f, 0.05016614f, 
    -0.02428381f, 0.04715693f, 0.01765350f, 0.01443221f, -0.06611626f, 0.03497846f, 0.04157655f, -0.07604120f, 
    -0.01332870f, 0.04438209f, 0.03554637f, -0.08676878f, 0.04051137f, 0.01828648f, -0.05106919f, 0.05998408f, 
    0.02162958f, -0.00643769f, 0.02662902f, 0.05625854f, -0.03916878f, -0.04939188f, -0.01649219f, -0.08630861f, 
    0.00581279f, -0.00470475f, -0.07390417f, 0.02903442f, -0.03142906f, -0.01057277f, -0.05909947f, -0.04393494f, 
    0.10950834f, -0.14973320f, 0.03539065f, 0.34317112f, 0.12647381f, 0.01166671f, -0.09774382f, -0.02379304f, 
    -0.11117668f, -0.12301577f, 0.02277156f, 0.05141410f, 0.16690773f, 0.07131978f, 0.00535695f, -0.13317083f, 
    0.00296752f, 0.11698952f, -0.45039701f, -0.17812628f, -0.31638393f, -0.13383268f, 0.03239563f, -0.07362799f, 
    -0.08942507f, 0.01436787f, 0.09046963f, -0.33299291f, -0.05263722f, 0.23313498f, -0.08974720f, 0.15586208f, 
    0.04974093f, -0.09263108f, 0.15602894f, 0.05778940f, 0.47899839f, 0.24108861f, -0.11252812f, 0.07109702f, 
    0.10834248f, 0.00755819f, 0.08228917f, -0.12457990f, 0.02449867f, -0.17477623f, 0.46830311f, 0.11337707f, 
    0.10377265f, 0.08381865f, -0.08145091f, 0.09328130f, -0.00488099f, -0.01036400f, -0.25018468f, 0.04495018f, 
    -0.17785494f, 0.02115545f, 0.05090073f, -0.07075547f, 0.07369612f, 0.05851502f, -0.03919814f, -0.18397513f, 
    0.15318978f, 0.02622250f, -0.16822781f, 0.04197706f, -0.06340837f, 0.08637866f, 0.14046556f, 0.18598135f, 
    -0.28382155f, -0.12903728f, -0.09863742f, -0.04905693f, -0.08850993f, 0.05701854f, 0.01068709f, 0.19066073f, 
    -0.02800547f, -0.05616123f, -0.01225385f, 0.20072165f, -0.13049991f, 0.07674671f, -0.00216386f, 0.20178591f, 
    -0.00024150f, 0.03131066f, 0.23813508f, 0.05157290f, -0.04526370f, 0.03093689f, -0.06397206f, 0.02428994f, 
    -0.08239939f, -0.01582754f, -0.03538531f, -0.07587817f, -0.05305741f, -0.14862077f, -0.12942536f, -0.01977140f, 
    0.20352577f, 0.03222967f, -0.14146180f, -0.07889255f, -0.29689014f, 0.07957626f, 0.16851379f, 0.00117957f, 
    -0.01150172f, 0.02933058f, -0.15943164f, -0.04985773f, -0.12483891f, -0.55871254f, 0.00320728f, -0.22084238f, 
    -0.02744540f, -0.14453426f, -0.07902724f, -0.05522063f, -0.12143850f, -0.00261863f, 0.13076501f, -0.15362348f, 
    -0.02427939f, -0.26720116f, -0.08453678f, 0.06270599f, -0.07765579f, -0.06211532f, 0.00376087f, 0.41606238f, 
    0.11103342f, 0.21899544f, 0.01465058f, -0.05277182f, 0.04533202f, 0.15094773f, 0.19932735f, 0.04559873f, 
    -0.41052896f, -0.03064222f, 0.13880581f, -0.14419661f, -0.08459210f, -0.00030695f, 0.07930227f, -0.02894897f, 
    0.24221668f, -0.12275466f, 0.02946075f, 0.04025536f, -0.25854883f, 0.07802637f, 0.03991427f, 0.17480887f, 
    0.01298606f, 0.08690294f, 0.03738178f, -0.11561106f, 0.16033143f, 0.04886148f, 0.07570256f, -0.12867114f, 
    -0.03188400f, -0.19643611f, -0.02459346f, 0.26096955f, -0.09133883f, 0.11287480f, 0.27568668f, -0.11006413f, 
    -0.02763969f, -0.05892280f, -0.13161699f, -0.01193572f, -0.02902149f, -0.01748944f, 0.13056353f, 0.11061163f, 
    0.13319777f, 0.12750712f, 0.00511687f, -0.07171878f, 0.06056906f, -0.22473490f, -0.31869039f, -0.01951041f, 
    0.02927715f, -0.03432874f, -0.01633898f, -0.09435136f, -0.05967958f, -0.09321970f, -0.17279924f, 0.01346743f, 
    -0.10979342f, -0.05874308f, 0.15050235f, 0.11000000f, -0.15565521f, -0.18572553f, -0.13462558f, 0.42274711f, 
    0.06863429f, -0.07012057f, -0.02015956f, -0.07037891f, 0.06347471f, 0.11389311f, 0.18044898f, -0.05444508f, 
    -0.27243680f, 0.07344568f, -0.15118702f, 0.22997305f, -0.06029076f, 0.04191889f, 0.02504984f, 0.10879304f, 
    -0.00585039f, 0.09981763f, 0.27691418f, 0.06878167f, -0.07487762f, 0.00485011f, -0.15836284f, -0.02544043f, 
    0.08350587f, 0.02110902f, 0.38210851f, 0.13906665f, 0.22122280f, -0.26079255f, -0.02617454f, -0.08383789f, 
    0.09224732f, -0.09180110f, 0.07965725f, -0.05407114f, -0.28915405f, 0.03957145f, 0.21485466f, -0.02775609f, 
    0.07282120f, -0.09471374f, 0.06375134f, 0.10883108f, -0.10432810f, -0.04111291f, -0.17460874f, 0.07098203f, 
    0.07542015f, 0.12734351f, -0.06278916f, -0.12173726f, 0.09029045f, 0.15233777f, 0.28624845f, 0.05158425f, 
    -0.07350306f, 0.03791736f, -0.16135563f, -0.07742954f, 0.04773961f, 0.05495572f, 0.23329119f, 0.19953197f, 
    -0.26840141f, -0.06838182f, -0.10790522f, -0.09496401f, 0.10437978f, -0.02537720f, -0.08307537f, 0.13244827f, 
    -0.24598266f, -0.06268876f, 0.05335056f, -0.00502492f, 0.00664063f, -0.07810427f, 0.09954744f, -0.14522870f, 
    -0.11725380f, 0.03596528f, -0.13635947f, -0.02368460f, 0.10430294f, 0.12045379f, -0.19316681f, 0.08694612f, 
    0.07186250f, -0.20611675f, -0.04836674f, -0.34345642f, 0.01704018f, 0.14363869f, 0.05942177f, -0.15039103f, 
    0.04774942f, 0.05537295f, 0.39594018f, 0.12507932f, -0.06309099f, -0.08458640f, 0.11717370f, 0.16559897f, 
    -0.02378798f, 0.15194248f, 0.10561384f, 0.05224835f, -0.35353830f, -0.02776356f, -0.05984988f, -0.04116951f, 
    -0.09957392f, 0.06945865f, -0.01886887f, 0.05850282f, 0.11479159f, 0.16539894f, 0.16269028f, -0.13242990f, 
    -0.03028807f, -0.12997316f, -0.01755836f, -0.11790030f, 0.02052118f, 0.50556487f, 0.08132178f, -0.12062901f, 
    -0.17548670f, -0.25544673f, -0.03126599f, -0.03503053f, 0.07761333f, -0.02603761f, -0.00552844f, 0.20464990f, 
    -0.05796329f, 0.00819753f, -0.05667178f, 0.05109644f, -0.11368149f, -0.02810876f, 0.01567348f, -0.07249871f, 
    -0.10690733f, 0.08422730f, 0.01990626f, 0.03625787f, 0.06939622f, 0.06450249f, 0.11337753f, -0.08668426f, 
    0.06395721f, -0.22310953f, 0.04952908f, 0.06655230f, 0.00792848f, -0.15714224f, 0.06164914f, 0.00810662f, 
    -0.03514367f, -0.23144953f, -0.07094523f, -0.02224624f, -0.05051284f, 0.15793492f, 0.26511699f, -0.02262352f, 
    0.01177193f, 0.04526387f, -0.15254202f, 0.20332099f, 0.03494127f, 0.06859852f, -0.10138768f, 0.12972218f, 
    0.05397906f, 0.16421215f, -0.18329598f, 0.14760755f, 0.10614364f, 0.25394365f, 0.10713443f, 0.01938690f, 
    -0.08513402f, 0.05288650f, 0.00844697f, -0.21064097f, -0.00687794f, 0.02914884f, -0.16878806f, 0.09086794f, 
    -0.13752754f, -0.01433769f, 0.00350456f, -0.11717502f, 0.00179315f, 0.07272772f, -0.06790806f, 0.02492425f, 
    -0.19127478f, -0.12202442f, -0.01555921f, -0.16844258f, -0.09040368f, -0.08537943f, 0.26477286f, -0.08461056f, 
    0.03079613f, -0.08521426f, 0.15392902f, 0.09537696f, -0.00947430f, -0.05246937f, 0.00255491f, -0.33638018f, 
    0.12928925f, 0.07960518f, 0.01342232f, -0.07279848f, -0.01090282f, -0.02431176f, -0.03957876f, 0.23831825f, 
    -0.00236325f, 0.08086102f, 0.27331141f, 0.22918370f, 0.20764902f, 0.09522113f, 0.02408758f, -0.24080096f, 
    -0.10583362f, 0.33838332f, -0.29472658f, -0.46610254f, -0.24651448f, 0.01351310f, 0.18881679f, 0.17533681f, 
    0.10065711f, 0.01612210f, 0.10833049f, -0.04846725f, -0.20318358f, -0.21524714f, -0.05964310f, -0.03105846f, 
    -0.00821922f, 0.27761066f, 0.01464668f, 0.22836107f, 0.25273415f, 0.09877359f, -0.06371698f, -0.00718488f, 
    -0.16346949f, 0.04369479f, -0.03320698f, -0.06181173f, 0.01082170f, 0.13863762f, 0.06626230f, -0.03572331f, 
    0.12647429f, 0.05181930f, -0.03135543f, 0.09563636f, 0.02852486f, 0.34948587f, -0.00589098f, 0.07201255f, 
    0.10422063f, 0.05255815f, -0.00757186f, -0.09417589f, -0.15393056f, 0.02057300f, -0.13849714f, 0.11322673f, 
    0.11776255f, -0.04244939f, 0.00613407f, -0.11718891f, 0.02493939f, 0.04930270f, -0.06137789f, 0.23603813f, 
    -0.15569279f, -0.22255532f, 0.06691936f, -0.17489880f, 0.01555319f, -0.06081798f, -0.10765111f, -0.20984896f, 
    -0.03410835f, 0.16751319f, -0.22880362f, -0.04914874f, 0.09173679f, -0.07001424f, 0.04414092f, -0.01203994f, 
    0.06736670f, 0.05768134f, -0.34621888f, -0.01214101f, -0.14891739f, 0.01534226f, -0.13317020f, -0.05367950f, 
    0.03663661f, 0.14335580f, -0.07873172f, -0.12734933f, -0.00511667f, -0.10122561f, 0.07376315f, -0.14434773f, 
    0.09701347f, -0.03516476f, -0.19101579f, 0.05703091f, 0.25397602f, 0.24003127f, 0.01387366f, 0.02254558f, 
    -0.01077884f, -0.06709553f, 0.05797590f, -0.04022301f, 0.07850520f, 0.19443025f, -0.12313625f, -0.08944672f, 
    -0.06325287f, -0.16282094f, -0.09219665f, -0.00455242f, -0.00520381f, 0.27125341f, 0.18689656f, 0.07112758f, 
    -0.28438282f, -0.05039919f, -0.21766721f, -0.03525160f, 0.14513722f, -0.20736635f, -0.13161348f, -0.09215149f, 
    -0.06141551f, 0.01055946f, -0.10609338f, 0.08983938f, -0.12492440f, -0.09556064f, 0.02705265f, 0.03042992f, 
    -0.05394977f, -0.19855712f, -0.10201301f, -0.05720480f, -0.12407736f, 0.09237374f, 0.17351997f, 0.15497109f, 
    -0.01425321f, -0.02268737f, -0.10178515f, 0.20457149f, 0.07945214f, 0.07331584f, -0.04010103f, 0.10359742f, 
    -0.32119271f, -0.15666319f, -0.00955073f, 0.18769521f, 0.02059649f, 0.09485269f, -0.15610969f, 0.09018108f, 
    -0.00627018f, 0.16057904f, -0.09732945f, 0.03756657f, 0.00378004f, -0.04348705f, -0.25900480f, 0.01801489f, 
    0.04482945f, -0.34570268f, -0.06839179f, -0.03351085f, -0.00110657f, 0.12978466f, 0.06602564f, -0.03922526f, 
    0.13795662f, -0.00607737f, 0.16583271f, -0.11533735f, 0.47971487f, 0.26073965f, -0.13507104f, -0.05662837f, 
    0.06529243f, -0.10580674f, 0.07144220f, 0.10535534f, 0.05024774f, 0.04925753f, -0.15488563f, -0.18551129f, 
    -0.02256496f, -0.03756118f, -0.06011747f, 0.04570157f, 0.16232911f, 0.17459120f, -0.18674004f, 0.10772112f, 
    -0.10873233f, -0.03517953f, -0.34706253f, -0.36818668f, 0.12533700f, 0.09661170f, 0.07845181f, -0.09035590f, 
    -0.36344010f, -0.04195127f, 0.09281277f, 0.14784238f, 0.15735903f, 0.03566132f, -0.09090759f, 0.13166587f, 
    0.21835688f, 0.11952553f, -0.02302748f, 0.02811351f, 0.01748325f, 0.04050983f, 0.00444076f, -0.02940257f, 
    0.08666928f, -0.15209338f, -0.12444972f, 0.11890712f, 0.06308160f, 0.11043644f, 0.09468861f, -0.09240535f, 
    -0.12084679f, 0.17903955f, -0.44196141f, -0.43107668f, 0.19330816f, 0.08154768f, 0.22413300f, 0.22929835f, 
    0.01909876f, -0.11242258f, -0.05547918f, 0.07713931f, 0.18881395f, -0.14658974f, -0.20880130f, -0.03560172f, 
    0.10864547f, 0.07241800f, 0.00021916f, -0.02991539f, 0.13634053f, -0.01582986f, -0.06845608f, 0.05996285f, 
    0.01155492f, 0.13788624f, -0.04485774f, 0.00200948f, 0.14212388f, -0.01793170f, -0.39501718f, -0.23280504f, 
    0.00984919f, 0.22704980f, 0.09497590f, -0.01658144f, -0.04234171f, -0.07343531f, -0.17916861f, 0.02482915f, 
    0.02498856f, 0.01809896f, -0.00062138f, 0.17488180f, -0.15507418f, -0.07668796f, -0.14567792f, -0.00586593f, 
    0.11790501f, 0.10152665f, -0.05900026f, 0.08891077f, -0.40367308f, 0.08649693f, 0.00383714f, 0.01588154f, 
    -0.22530907f, -0.06460568f, -0.06798880f, -0.22051473f, 0.18292350f, 0.12385515f, -0.07931889f, 0.04849176f, 
    -0.26412085f, -0.11578541f, 0.19606456f, 0.15654469f, 0.07612186f, -0.18851461f, -0.02243865f, 0.07128335f, 
    0.13465166f, 0.16810252f, -0.02340639f, -0.00579557f, 0.00543804f, 0.10483411f, -0.16516712f, -0.03907469f, 
    0.14843106f, 0.02319730f, 0.28041121f, 0.17224219f, 0.33288181f, -0.11540841f, 0.35406265f, 0.06992043f, 
    0.06293593f, -0.17365237f, 0.07789142f, 0.02734541f, 0.01347631f, 0.27942830f, -0.02996289f, -0.01929871f, 
    0.03213255f, -0.06994025f, 0.10817265f, -0.11138862f, -0.05210066f, -0.36523244f, -0.20874126f, -0.04250191f, 
    -0.05388702f, 0.04854798f, -0.18153195f, 0.00372496f, 0.00035382f, 0.13888757f, 0.20641118f, -0.08830719f, 
    -0.03425206f, 0.00684655f, 0.05123039f, -0.13376537f, 0.04989951f, -0.03073370f, 0.03395661f, -0.08752218f, 
    0.04008932f, 0.12368266f, 0.32051024f, 0.01460565f, 0.10505215f, 0.00889623f, 0.12199008f, 0.05888249f, 
    -0.23746127f, -0.01881750f, -0.43645942f, 0.08704683f, 0.03982558f, 0.19900572f, 0.10461643f, -0.13910180f, 
    -0.23726352f, 0.13771047f, 0.11397870f, 0.07771125f, 0.18216531f, 0.10528946f, -0.05923316f, -0.03715720f, 
    0.04104364f, 0.13207054f, -0.08569213f, 0.03375489f, -0.06978469f, -0.02289226f, 0.03486298f, -0.00011886f, 
    0.09216408f, -0.09925479f, 0.12452931f, -0.04567201f, -0.10126279f, -0.09446245f, -0.19629745f, -0.10755038f, 
    0.08968071f, 0.01184893f, -0.02761659f, -0.20668392f, 0.15628843f, -0.16362189f, -0.04970850f, -0.04851798f, 
    -0.05777656f, 0.08665056f, 0.09649175f, -0.09760762f, -0.03143651f, 0.13608503f, 0.08400282f, -0.11840500f, 
    0.17507282f, -0.08721717f, -0.25842851f, 0.07958501f, -0.15913507f, -0.09447817f, 0.17245105f, -0.22292319f, 
    -0.00800808f, 0.11924793f, -0.16441461f, 0.16062285f, -0.19107415f, -0.06396708f, 0.04969363f, 0.04780673f, 
    0.07401585f, -0.09134401f, 0.09082920f, -0.06886336f, -0.30294618f, 0.08917270f, 0.15922081f, 0.05136014f, 
    0.00301883f, 0.02209894f, 0.04985024f, -0.15559432f, 0.05287229f, -0.05034042f, 0.03028950f, 0.17444809f, 
    0.07650268f, 0.28500906f, -0.03409336f, -0.02103394f, -0.06468337f, -0.07981155f, 0.04610360f, 0.01102045f, 
    0.09484772f, 0.22306107f, -0.10626181f, -0.12977549f, -0.10068641f, -0.06119158f, -0.06148353f, 0.08288880f, 
    0.00642906f, -0.06088017f, 0.13285631f, -0.38824743f, 0.09703165f, 0.00987185f, 0.05954483f, 0.15784040f, 
    -0.03790235f, -0.03502883f, 0.10043588f, 0.16487546f, -0.27108982f, -0.16099776f, -0.26921213f, 0.12728032f, 
    0.00097228f, 0.08797703f, 0.07624176f, 0.12902515f, -0.05373760f, -0.29955795f, -0.27853209f, -0.18407942f, 
    -0.00579183f, 0.01913376f, 0.02924019f, 0.00764222f, -0.12009484f, -0.04069558f, -0.05965007f, 0.14057970f, 
    0.23288780f, -0.23954968f, -0.24236108f, -0.09325079f, 0.12996227f, -0.04852878f, -0.17885983f, 0.15639728f, 
    0.17047584f, 0.22541511f, 0.04291967f, 0.04534090f, 0.10227702f, 0.12574825f, 0.01843062f, 0.00134625f, 
    0.07680151f, 0.12019410f, -0.04356419f, 0.04281281f, -0.03881865f, 0.07801514f, -0.05142140f, -0.00679536f, 
    0.02253509f, -0.15142578f, 0.14659607f, 0.24112850f, 0.36795986f, 0.01228506f, -0.10193511f, -0.02772513f, 
    0.12046183f, 0.18876731f, -0.17101283f, 0.11576791f, 0.24283633f, -0.22671756f, -0.01490150f, 0.00665153f, 
    -0.02493060f, 0.08738193f, -0.06520449f, -0.37960398f, -0.24081148f, -0.29243505f, 0.21334583f, 0.39146963f, 
    -0.01793393f, 0.04667291f, -0.12955022f, -0.03322511f, -0.01996539f, -0.06541174f, -0.00540717f, 0.04429604f, 
    -0.09344703f, -0.00992376f, -0.06534518f, 0.07309246f, -0.07916179f, -0.17997622f, -0.14006189f, 0.14194052f, 
    0.12931862f, -0.10300446f, 0.07419136f, -0.06364588f, -0.23794819f, 0.00622141f, -0.10071360f, -0.03033674f, 
    -0.00598074f, -0.14258367f, 0.04720135f, -0.01251545f, -0.15103151f, -0.03973882f, 0.01996673f, 0.32474658f, 
    -0.12555158f, 0.03990099f, -0.03002484f, -0.12980662f, -0.10876819f, 0.04732330f, 0.11267151f, 0.12524647f, 
    -0.04200090f, -0.18808748f, -0.01594883f, 0.21552122f, 0.07685723f, -0.13704187f, 0.01890828f, 0.17434983f, 
    0.01017464f, -0.32707775f, 0.19883992f, 0.26903746f, 0.02370734f, 0.00805260f, 0.01672874f, -0.02291419f, 
    0.16785724f, 0.02411807f, 0.20059094f, 0.07178821f, 0.09476396f, 0.04537957f, -0.10049054f, -0.02476010f, 
    -0.08254786f, 0.24563682f, 0.06692801f, -0.28515628f, 0.01313810f, -0.24076371f, -0.07601189f, -0.04635359f, 
    0.20020175f, -0.00982832f, -0.00427692f, 0.01955163f, 0.01723823f, 0.05456069f, -0.33075261f, -0.00171856f, 
    0.00612328f, -0.04193185f, 0.03540936f, 0.00073431f, -0.05561813f, -0.53859895f, -0.18689935f, 0.06698106f, 
    -0.09121229f, 0.14047731f, 0.02702733f, -0.07642392f, 0.05454728f, 0.05360193f, 0.00325439f, -0.03763219f, 
    -0.09340370f, -0.02161343f, 0.17020988f, -0.05644068f, -0.14462271f, 0.17050537f, -0.14580837f, 0.18083026f, 
    0.22703190f, 0.12382057f, 0.17372561f, 0.04127042f, -0.09512047f, 0.03100220f, -0.15042463f, 0.19509627f, 
    0.05975660f, -0.06966064f, -0.13472238f, 0.05958562f, 0.10601529f, -0.01769901f, 0.13825840f, 0.17144807f, 
    -0.21068697f, 0.19682966f, 0.19194986f, 0.23087415f, -0.21265060f, 0.07720814f, -0.02355934f, 0.00296171f, 
    0.09538613f, -0.06505007f, 0.40606445f, 0.26175708f, -0.05107067f, -0.05737187f, -0.03842825f, 0.16471270f, 
    -0.05811980f, 0.01962339f, -0.06090449f, -0.04074175f, -0.15949477f, -0.04740381f, -0.01460800f, 0.02624291f, 
    0.00932077f, -0.01459837f, -0.14162102f, -0.09670378f, 0.25691092f, -0.42268360f, -0.10604624f, 0.00196468f, 
    0.04335447f, -0.01135980f, -0.01349771f, -0.04699955f, 0.19541015f, -0.08243155f, -0.16381057f, -0.13299105f, 
    0.01001517f, -0.01168370f, -0.21326432f, -0.04906928f, -0.07452926f, -0.06229446f, 0.37516043f, -0.05400030f, 
    -0.11297857f, -0.01373980f, 0.04077726f, -0.00807223f, -0.07041249f, -0.07052917f, -0.03244724f, -0.13946916f, 
    0.01615882f, -0.06708270f, -0.23248051f, 0.18006381f, -0.09769651f, -0.02821640f, 0.00994396f, -0.05665382f, 
    -0.20527513f, -0.32844499f, 0.11012695f, -0.00964306f, 0.15419903f, -0.10037912f, -0.13484140f, 0.05067148f, 
    -0.19496259f, -0.01947864f, -0.23268229f, 0.08110733f, 0.08320557f, 0.00888460f, 0.08386552f, -0.05914778f, 
    0.00757612f, -0.11688592f, -0.36821783f, -0.06046856f, -0.07175649f, 0.07658026f, -0.06908683f, -0.00695148f, 
    0.12473924f, 0.03671086f, -0.05360288f, 0.10151571f, 0.04243705f, -0.01644242f, -0.18916893f, -0.04135897f, 
    -0.02094188f, 0.02682041f, 0.07022438f, 0.11649965f, -0.01725957f, 0.01427668f, 0.09231687f, -0.06201715f, 
    0.11565099f, 0.05008106f, -0.06333166f, 0.00237794f, -0.04254831f, 0.09648049f, 0.06031724f, -0.12879112f, 
    -0.02926573f, -0.00711814f, -0.08740022f, -0.08444484f, -0.05091178f, 0.01694049f, -0.43215573f, -0.35836425f, 
    -0.03521650f, 0.21243623f, 0.02151219f, 0.05910071f, -0.02614887f, 0.21123071f, -0.06692790f, -0.15997355f, 
    -0.13177738f, 0.04107785f, 0.09914493f, 0.11861410f, -0.02799206f, 0.04294152f, 0.03023503f, 0.09041250f, 
    0.23293093f, -0.06375746f, 0.28924569f, -0.11181135f, 0.12608156f, 0.17144832f, 0.08587733f, 0.04767373f, 
    0.07189989f, -0.00451361f, -0.16088606f, 0.01441772f, 0.14720073f, 0.08496328f, 0.15458272f, -0.00606941f, 
    -0.04313885f, -0.02607168f, -0.20276105f, -0.31798220f, -0.02223298f, 0.07811257f, -0.06233849f, -0.07505440f, 
    0.03343951f, 0.05414051f, 0.08460633f, -0.04670246f, 0.00090427f, -0.09691955f, -0.26660112f, -0.04299751f, 
    0.01016015f, -0.00432940f, 0.13136734f, 0.03829949f, 0.18074204f, -0.06474160f, -0.00570351f, 0.11890551f, 
    0.04426631f, -0.06632283f, 0.01933567f, -0.04647269f, 0.11580592f, 0.30304772f, -0.20740066f, 0.25578770f, 
    -0.04854988f, -0.11226121f, -0.16501634f, 0.08122405f, -0.01120968f, -0.02122374f, 0.42206842f, -0.11965484f, 
    -0.05365650f, 0.02891598f, -0.05717516f, -0.13576169f, 0.08829390f, 0.00329046f, 0.03123361f, -0.45763546f, 
    -0.06358065f, -0.24874070f, 0.01053218f, 0.18099050f, 0.15786675f, -0.05211682f, 0.10430741f, -0.16148816f, 
    0.09296655f, 0.01582822f, 0.08201846f, -0.07802968f, -0.08650876f, 0.17142411f, -0.05634055f, 0.09336929f, 
    0.05211276f, 0.24903321f, 0.00326051f, -0.17198004f, -0.10040721f, 0.09817853f, 0.08937865f, -0.00035834f, 
    -0.10835699f, -0.13274302f, -0.01155745f, -0.13192211f, -0.16022545f, -0.05849232f, 0.20100804f, 0.06317698f, 
    -0.02517843f, -0.10053010f, -0.37196922f, 0.09488901f, -0.09188244f, -0.00423585f, -0.01960018f, 0.14490232f, 
    0.04646504f, 0.13830446f, 0.01005357f, -0.07865670f, -0.10866464f, -0.00312473f, 0.06454963f, 0.07031715f, 
    0.02436114f, 0.16508283f, 0.12030527f, -0.17591374f, 0.06536862f, 0.18600500f, 0.06430078f, -0.16050383f, 
    0.07944308f, -0.03964553f, 0.30729854f, 0.11828388f, 0.06897809f, -0.26275727f, -0.16450427f, -0.14407989f, 
    0.16792943f, 0.00838301f, 0.05039089f, -0.02876876f, -0.02415111f, -0.01281521f, -0.35232428f, 0.00402597f, 
    -0.00188259f, 0.07279035f, -0.10217702f, 0.11324205f, -0.13980405f, -0.00942754f, -0.05189283f, -0.00364922f, 
    -0.01826058f, 0.19573154f, 0.05066584f, -0.05344515f, 0.03278555f, -0.10063327f, 0.22768214f, 0.06699501f, 
    0.11890899f, 0.17293593f, 0.01902228f, -0.02924458f, 0.01073125f, 0.11110339f, 0.11342089f, 0.12105186f, 
    -0.02427362f, -0.09733246f, 0.02529860f, -0.02282522f, -0.17094222f, -0.03572669f, 0.06971518f, -0.10117558f, 
    -0.12690145f, -0.02355760f, 0.00547814f, -0.01244908f, 0.00189769f, 0.11920513f, 0.16795026f, -0.20680119f, 
    -0.12877047f, -0.13322890f, 0.11257128f, 0.04527710f, -0.02303596f, 0.07388820f, 0.22652866f, 0.13349549f, 
    -0.06190375f, -0.17519966f, 0.02573778f, 0.05242932f, 0.13550456f, 0.11289075f, -0.05562177f, -0.12201227f, 
    0.07872594f, -0.07300311f, 0.04991880f, -0.07707578f, 0.12763125f, 0.03806412f, -0.07845467f, 0.17804186f, 
    -0.21768777f, -0.00489332f, 0.00585312f, -0.24323873f, 0.03262307f, 0.09818995f, 0.00740290f, 0.12664454f, 
    -0.12285911f, -0.30201274f, -0.03509538f, -0.17674541f, 0.18102266f, -0.00001032f, 0.00678079f, -0.12054945f, 
    -0.05181294f, -0.04371314f, 0.05417245f, -0.04340277f, -0.02648388f, -0.07469396f, 0.05007116f, 0.01183686f, 
    -0.09563662f, -0.05852872f, -0.00307149f, 0.05802297f, 0.03683620f, 0.03903524f, -0.06686126f, -0.10414676f, 
    0.05358887f, -0.03381819f, -0.06121736f, -0.10702654f, 0.02704891f, -0.04106251f, 0.01288713f, 0.05347380f, 
    -0.02200667f, -0.07474914f, -0.05321829f, -0.06012086f, -0.03473754f, 0.05068672f, -0.08658602f, 0.03849797f, 
    0.05308010f, -0.03564399f, 0.00752837f, -0.02437226f, -0.07070030f, -0.06693167f, -0.01388254f, 0.05684092f, 
    -0.09037131f, 0.01750870f, -0.05552425f, -0.02548034f, 0.04837818f, 0.05101100f, -0.11740995f, -0.04785404f, 
    -0.07573538f, -0.05962339f, 0.04499802f, -0.07865243f, 0.00986153f, -0.06432191f, -0.07941640f, 0.01290034f, 
    0.01332168f, 0.03595950f, 0.02780303f, 0.00646181f, 0.07332669f, 0.05397655f, -0.07871189f, -0.06170556f, 
    -0.04246468f, -0.05453213f, 0.00862395f, -0.00042407f, -0.04592667f, -0.06220508f, -0.02851615f, -0.09759163f, 
    0.02017584f, -0.06444176f, 0.03677882f, -0.10346200f, -0.08900224f, -0.04118652f, 0.02627123f, -0.04091159f, 
    -0.01480703f, 0.04156189f, 0.00543096f, -0.08929460f, -0.06765939f, -0.10825457f, 0.03682354f, -0.07149062f, 
    0.00556938f, -0.05918173f, -0.02894109f, -0.02038722f, -0.00517600f, -0.05815352f, 0.02042061f, -0.08542961f, 
    0.05207191f, -0.02948278f, 0.04732358f, -0.04597254f, 0.04467015f, 0.03678561f, 0.00771796f, 0.02368414f, 
    -0.08244406f, 0.04545423f, -0.10768341f, -0.00552008f, -0.00830565f, 0.03147334f, -0.09129944f, 0.02702197f, 
    0.00912843f, -0.03107397f, 0.01313845f, -0.02274032f, -0.10509502f, -0.06973612f, -0.06214639f, -0.00826908f, 
    -0.00154297f, -0.00863188f, -0.01508917f, -0.05885445f, -0.03905742f, -0.01007059f, 0.03737779f, 0.01433980f, 
    -0.10079008f, 0.03753337f, -0.06684993f, -0.03332252f, -0.07312475f, 0.02433012f, -0.07325815f, -0.06244484f, 
    0.07659681f, -0.05491656f, 0.05616147f, 0.01325688f, 0.05209586f, -0.01961822f, 0.00567528f, -0.07696228f, 
    -0.05394685f, 0.05567411f, -0.00579119f, 0.02778552f, -0.05449683f, 0.01741732f, 0.01007723f, -0.06536443f, 
    -0.07916000f, -0.02024658f, 0.05807630f, -0.02393738f, -0.04329993f, 0.00101455f, 0.01326251f, 0.06094968f, 
    -0.00235578f, 0.01416417f, -0.03602343f, 0.01499949f, -0.02725266f, 0.04243772f, -0.01883689f, 0.07035016f, 
    0.05929877f, 0.05024831f, -0.04673559f, -0.08524825f, -0.02510880f, -0.01189236f, -0.04224240f, -0.03354530f, 
    -0.06835442f, 0.06992167f, 0.04612854f, -0.09458427f, -0.04267736f, -0.04934873f, 0.00375906f, -0.05401912f, 
    -0.08223098f, 0.02034953f, -0.03711071f, 0.00616515f, -0.06254530f, 0.06567688f, -0.06412695f, 0.02585272f, 
    -0.01136624f, -0.02549636f, -0.08059436f, 0.02801646f, 0.04156405f, -0.05989120f, -0.01573659f, -0.00908850f, 
    -0.05140275f, -0.02183665f, 0.01719567f, 0.00653847f, -0.02204459f, -0.00670658f, -0.03236204f, -0.03552438f, 
    -0.05743440f, 0.03511729f, -0.03761705f, -0.00654738f, -0.05924816f, 0.05394172f, -0.09299503f, -0.05197216f, 
    -0.08876432f, -0.07401522f, -0.02298846f, -0.03656479f, -0.09294469f, 0.06083011f, 0.02728595f, -0.05215259f, 
    -0.04669964f, 0.06478126f, -0.06015693f, 0.04487113f, -0.02192211f, 0.05403263f, -0.07083891f, -0.08386479f, 
    0.04469784f, -0.08591266f, 0.04683722f, -0.08141842f, -0.03191198f, -0.08701934f, 0.04097395f, -0.00217770f, 
    0.06441662f, 0.02632014f, 0.00995356f, 0.02168389f, 0.00315090f, -0.04850573f, -0.08768158f, -0.04069014f, 
    0.02017810f, -0.05599395f, -0.03223955f, -0.06372309f, -0.00779865f, 0.00951384f, -0.04316900f, 0.06358674f, 
    0.01591995f, -0.03464416f, 0.05892745f, -0.08506397f, -0.01476406f, -0.02200456f, -0.02216846f, -0.05908800f, 
    0.02985331f, 0.02534677f, 0.05863718f, -0.00525739f, 0.05233514f, -0.03735028f, -0.01774393f, 0.04567349f, 
    -0.05924341f, -0.03332499f, -0.00004376f, 0.03891710f, 0.05365023f, 0.03302866f, -0.04376017f, 0.06814522f, 
    -0.02543588f, 0.04010074f, 0.05717820f, -0.04364944f, 0.01288238f, 0.02872572f, -0.00566957f, 0.01823911f, 
    -0.28031990f, -0.00312428f, -0.08096711f, 0.02868229f, 0.04363236f, 0.10169505f, 0.01222648f, 0.04362334f, 
    -0.03562021f, 0.31311309f, 0.12034109f, -0.08079993f, -0.11771131f, -0.04755637f, -0.02385454f, 0.01400520f, 
    0.02917578f, 0.02829417f, 0.25179216f, 0.13636369f, -0.05255579f, -0.14685136f, -0.05068613f, 0.04454052f, 
    -0.04661423f, 0.07720545f, -0.04331895f, -0.34504488f, 0.18263482f, 0.32332480f, 0.09968564f, -0.18552695f, 
    -0.01879701f, 0.01151972f, 0.04464825f, -0.08860663f, 0.22795746f, -0.08302931f, 0.39299208f, -0.19807278f, 
    -0.14845954f, 0.00077781f, -0.14319170f, 0.10932051f, 0.08745798f, -0.02157329f, -0.30730703f, -0.08811721f, 
    -0.03170910f, -0.22590220f, -0.10952476f, 0.01945776f, -0.07297695f, 0.11352942f, 0.03511604f, 0.10925656f, 
    -0.22481373f, 0.04790938f, 0.08425964f, 0.04929971f, 0.10888116f, 0.11998215f, 0.04115720f, -0.03787300f, 
    0.27166054f, -0.07541741f, 0.09538075f, 0.12186128f, 0.10951659f, -0.01453889f, -0.16247383f, -0.06683066f, 
    -0.23445389f, -0.09202306f, -0.22569075f, 0.16554266f, 0.02542181f, -0.08244523f, 0.18111017f, 0.14626068f, 
    -0.13607241f, -0.17266810f, -0.04765937f, 0.05680319f, 0.16856244f, 0.15328845f, 0.03237517f, 0.03309135f, 
    0.03206570f, 0.07162052f, 0.29327881f, -0.01808151f, -0.02437406f, 0.08426543f, 0.02729280f, 0.00591750f, 
    0.08563568f, 0.14078048f, -0.18506141f, -0.04624774f, -0.25981557f, -0.12796156f, -0.00843535f, 0.04892310f, 
    -0.03195514f, 0.12460639f, -0.02581194f, 0.01264460f, -0.04219937f, -0.10237839f, -0.58938092f, 0.06940506f, 
    -0.00748530f, -0.00224456f, -0.05032965f, 0.10890982f, -0.00588501f, -0.34207353f, 0.15082328f, -0.03577633f, 
    -0.01018775f, 0.02253474f, -0.11346855f, -0.20375231f, -0.04470089f, 0.07807612f, 0.08873238f, 0.13176294f, 
    -0.05285898f, 0.07982341f, 0.03767185f, -0.00636346f, -0.03492944f, -0.05433824f, -0.08226921f, 0.09504092f, 
    -0.15071164f, 0.13245785f, -0.03218063f, -0.11175552f, 0.16208182f, 0.07185056f, 0.08338591f, 0.00069493f, 
    -0.01171510f, -0.06452069f, 0.08916905f, 0.18145357f, 0.09084661f, -0.00570833f, -0.10828768f, -0.12733771f, 
    0.03012526f, 0.18122616f, -0.02060856f, -0.25694299f, 0.00450964f, -0.07141419f, -0.05277555f, -0.06741194f, 
    0.02433270f, 0.04406162f, 0.03655025f, -0.05643771f, -0.09593941f, -0.02230933f, 0.04946870f, -0.22316946f, 
    -0.01402811f, -0.03103049f, -0.05144356f, 0.22120903f, 0.31487066f, 0.24886206f, -0.08261817f, 0.12400282f, 
    -0.06376754f, -0.15421548f, -0.05456538f, 0.02246040f, 0.08445176f, 0.07630330f, 0.13365662f, -0.01845757f, 
    0.01397494f, 0.14154665f, 0.05755202f, -0.02841360f, 0.10462426f, 0.02502363f, 0.09039149f, -0.01046862f, 
    -0.01432736f, 0.00286803f, 0.07706506f, -0.01347499f, 0.06103762f, 0.14343983f, -0.13697079f, 0.02916074f, 
    0.05848560f, 0.03085929f, 0.10600586f, 0.04659463f, 0.10903934f, -0.09979039f, 0.04801597f, -0.16625148f, 
    0.11129375f, -0.21808650f, 0.12875181f, -0.25844225f, -0.01473870f, -0.10012938f, 0.12761496f, -0.02377187f, 
    0.13575786f, -0.22749005f, -0.29519057f, -0.03068944f, -0.01943200f, -0.06861168f, 0.08744562f, -0.06788221f, 
    -0.03597943f, 0.18103871f, 0.01403535f, 0.10926566f, -0.18420039f, 0.07153980f, -0.04957138f, -0.07359547f, 
    -0.08640478f, -0.01733908f, -0.23510627f, -0.22506507f, -0.16815093f, -0.00370399f, -0.05908890f, -0.11372969f, 
    0.12465578f, -0.12886399f, 0.19991043f, -0.04418502f, 0.25286561f, 0.24815471f, 0.20351651f, -0.15096748f, 
    0.02985002f, 0.05617255f, -0.03927520f, -0.08800574f, -0.20506769f, 0.09466068f, 0.08438193f, 0.11949123f, 
    0.03612749f, -0.00724775f, 0.00825967f, -0.00697282f, -0.16323222f, -0.07516590f, 0.12698917f, -0.02254729f, 
    0.05506661f, 0.15505338f, -0.12141085f, -0.13630509f, 0.13130991f, 0.16136634f, -0.70709240f, -0.01181974f, 
    0.05290435f, 0.13107568f, -0.01609688f, 0.03275445f, 0.02741015f, 0.08400729f, 0.05009578f, 0.05872445f, 
    -0.09084786f, -0.08110189f, 0.01191666f, 0.03187914f, -0.05582280f, 0.16199744f, -0.05469534f, -0.00889984f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.14030433f, -0.09264909f, 0.09457340f, -0.00655276f, -0.05393330f, -0.11484655f, 0.23845954f, 0.00332386f, 
    0.13299488f, 0.18948604f, 0.24890648f, 0.00726723f, 0.04530223f, -0.05339663f, 0.06864388f, 0.01298638f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04792474f, -0.04374325f, 0.16611923f, 0.15365185f, 0.17882124f, 0.47658208f, -0.29319671f, 0.17748199f, 
    -0.87276274f, -0.20695440f, 0.09618005f, -0.19314478f, 0.18650049f, 0.23957774f, 0.54673707f, -0.47918460f, 
    0.02760466f, 0.15222372f, 0.29776600f, 0.22337468f, 0.20910528f, 0.13650988f, -0.24243531f, 0.39245355f, 
    0.01667645f, 0.29296425f, -0.14227119f, 0.00315218f, 0.05581979f, 0.08614385f, 0.10361525f, -0.47732472f, 
    -0.06912405f, 0.02218508f, 0.27016723f, -0.16311209f, 0.37514243f, 0.18603012f, 0.11389147f, -0.23658377f, 
    0.01599551f, 0.27425739f, -0.31995168f, 0.16331972f, -0.08169482f, 0.13681945f, -0.10284314f, 0.38104168f, 
    -0.18956617f, -0.15749793f, -0.09251957f, 0.19579034f, 0.07131692f, -0.42064151f, 0.12386081f, 0.38173217f, 
    0.31757626f, -0.07609241f, 0.09281939f, 0.04850980f, -0.02055983f, -0.18259656f, -0.19889241f, -0.13001148f, 
    0.32785654f, -0.08115067f, -0.27508849f, 0.19526848f, -0.05922308f, 0.51084167f, -0.23355477f, -0.17034459f, 
    -0.30673337f, 0.16655456f, 0.32396638f, 0.46076438f, -0.12248442f, -0.22374558f, -0.25621367f, 0.16825619f, 
    0.02677304f, -0.08134541f, -0.09254459f, 0.48953736f, -0.31795201f, 0.24987422f, -0.11645948f, 0.31775481f, 
    0.16059038f, 0.05680677f, -0.08976837f, 0.17581354f, 0.17186345f, 0.24614014f, 0.39480567f, -0.38082013f, 
    -0.20038861f, -0.11923471f, -0.22006869f, -0.01371794f, 0.28649884f, -0.22422892f, -0.01988803f, 0.26437250f, 
    -0.62186903f, -0.12814583f, -0.13645817f, 0.25116071f, -0.21413518f, -0.07419187f, -0.07637594f, 0.45625016f, 
    -0.05750358f, 0.24763651f, 0.03875023f, -0.49019232f, 0.24225733f, -0.36415815f, -0.20941870f, 0.45283008f, 
    0.53769416f, 0.02037043f, -0.02021310f, -0.23938739f, 0.17173675f, -0.19591156f, 0.45039982f, -0.04194842f, 
    0.10774626f, 0.25284266f, -0.32989722f, 0.50810456f, 0.18226182f, -0.03214475f, 0.16756608f, 0.28782853f, 
    0.30220848f, 0.28850681f, -0.30423227f, -0.22411448f, 0.13135931f, -0.03651493f, 0.32828161f, -0.32790008f, 
    -0.01732672f, 0.24207154f, -0.39229441f, 0.13473515f, 0.01040832f, -0.32930455f, 0.35172224f, 0.31057554f, 
    -0.20971122f, 0.27429497f, 0.02908772f, -0.22314037f, 0.09996898f, -0.24680458f, 0.19806039f, 0.07726720f, 
    -0.06939980f, -0.03169788f, 0.44743437f, -0.28941390f, 0.28381222f, 0.56228071f, 0.17225899f, 0.00074545f, 
    0.00856125f, 0.39883199f, -0.41399300f, -0.19006260f, 0.07276810f, -0.05339554f, -0.10506197f, 0.41628310f, 
    0.27772614f, 0.06962059f, -0.34238094f, 0.06109440f, -0.02160899f, 0.83854485f, 0.16567631f, 0.13833401f, 
    -0.26838818f, 0.07545737f, 0.12829179f, -0.26352191f, -0.21805982f, -0.11217289f, -0.01014797f, 0.15931232f, 
    -0.26367024f, -0.02627671f, -0.10118204f, -0.06043081f, -0.26360592f, -0.15722270f, -0.07263717f, 0.16721597f, 
    -0.15039328f, -0.13574065f, -0.13091481f, 0.11380793f, -0.09690508f, 0.06194625f, -0.16450559f, -0.11942887f, 
    0.24812356f, -0.16502076f, -0.38622016f, 0.51391703f, 0.08884095f, -0.04479320f, -0.06061448f, 0.23692575f, 
    -0.08524744f, 0.23055445f, 0.16393895f, -0.04600956f, 0.11738903f, 0.01060935f, -0.36815083f, -0.57016796f, 
    -0.08874694f, -0.17541310f, -0.04227519f, 0.12570423f, -0.01907745f, 0.20633295f, -0.11400059f, -0.16620174f, 
    -0.17832878f, -0.10851672f, -0.02848431f, -0.18854669f, -0.10172722f, -0.02559939f, -0.15994328f, -0.20500505f, 
    -0.29989439f, 0.00041158f, 0.23510611f, 0.47704497f, -0.28310820f, -0.33553815f, 0.02548622f, 0.23981987f, 
    -0.38439178f, 0.40871614f, -0.16964734f, 0.18494426f, 0.13894992f, 0.00429512f, 0.09960453f, -0.11449661f, 
    -0.25389346f, 0.03489591f, 0.31117606f, 0.24477808f, -0.12374084f, -0.25904986f, 0.34639508f, 0.05364637f, 
    0.05601691f, 0.21859425f, -0.42813578f, -0.18160555f, -0.02632315f, 0.22466704f, 0.51228583f, -0.31394133f, 
    -0.25702950f, 0.21892902f, 0.11625218f, 0.07375302f, 0.10325629f, -0.40739435f, 0.11331672f, 0.47903374f, 
    -0.23397774f, 0.44605651f, -0.02860918f, -0.24461690f, 0.10544404f, 0.10772154f, 0.55650437f, -0.13630179f, 
    -0.06674919f, 0.12578224f, 0.09174372f, 0.09647234f, 0.05569980f, -0.56275648f, 0.34421340f, -0.07592467f, 
    0.25338814f, 0.39303508f, 0.45922372f, -0.35211468f, 0.13591191f, 0.18949036f, -0.14936723f, -0.07300662f, 
    0.29634768f, 0.16037200f, 0.63003629f, -0.12811244f, 0.08328737f, -0.33684444f, -0.20982552f, 0.04140758f, 
    -0.10869303f, 0.36478034f, -0.22014563f, -0.05985759f, -0.15615715f, 0.00319898f, -0.13157931f, -0.16264133f, 
    0.17657010f, 0.04259997f, 0.19090617f, -0.27217144f, -0.38385978f, 0.07537120f, 0.01837785f, 0.29918271f, 
    0.59683049f, -0.05443591f, -0.44385886f, 0.07254096f, -0.02280555f, -0.10289178f, -0.10792459f, 0.07903154f, 
    0.05393784f, 0.03840257f, 0.27710977f, -0.30707332f, 0.27051646f, 0.38017762f, 0.12140699f, 0.15791194f, 
    -0.37635693f, -0.07151134f, 0.36163712f, 0.20263812f, -0.09128564f, 0.16740067f, -0.31934997f, 0.28882280f, 
    0.07740449f, 0.07470163f, 0.53920126f, -0.16012824f, -0.54879439f, -0.12917957f, 0.45771354f, -0.28185907f, 
    -0.13772193f, 0.38951746f, 0.00344922f, -0.14074151f, -0.18062800f, -0.06939451f, -0.29916105f, 0.14911410f, 
    0.26693183f, -0.05409923f, 0.22789630f, -0.54165083f, 0.10121867f, -0.47813043f, -0.22400717f, -0.32130790f, 
    0.32814518f, 0.05319877f, 0.03379576f, -0.14021118f, -0.04160893f, -0.20988801f, 0.42148012f, -0.23889872f, 
    -0.26421204f, -0.15437385f, 0.28682017f, 0.16667783f, -0.35178033f, 0.06035923f, -0.02070512f, 0.24232186f, 
    0.30078495f, 0.05154328f, 0.06313246f, -0.20207059f, 0.08929364f, -0.07308851f, 0.40338480f, 0.27759650f, 
    0.28946683f, -0.09379325f, 0.29280671f, -0.02061745f, 0.28429961f, 0.04633787f, -0.01434325f, -0.13369623f, 
    -0.26251560f, -0.29332247f, 0.05045456f, 0.31573221f, 0.00499559f, 0.16746522f, 0.21998236f, -0.52902228f, 
    0.15783337f, -0.02253672f, -0.11561049f, 0.12042052f, -0.20136771f, -0.17864612f, -0.42944944f, -0.18437622f, 
    0.06585237f, 0.08353839f, 0.03732153f, 0.11723196f, 0.06041837f, -0.09661391f, 0.06131811f, -0.17742829f, 
    -0.10824604f, -0.15370028f, 0.17620264f, 0.11881675f, -0.05725016f, -0.17440654f, 0.15482788f, -0.35950369f, 
    -0.45378637f, -0.14540853f, 0.26399559f, 0.45147899f, 0.06503110f, 0.21655768f, 0.43034542f, 0.24940720f, 
    0.20974800f, -0.06431313f, 0.45551309f, 0.01760619f, -0.33054751f, -0.16265167f, -0.02269641f, 0.32961565f, 
    0.41554153f, -0.09539660f, -0.22198485f, -0.08984211f, -0.02642476f, 0.23544167f, -0.22483593f, 0.46071681f, 
    -0.09719419f, 0.05880457f, -0.02401361f, -0.21683413f, -0.23421749f, -0.05867639f, -0.13822547f, -0.18240190f, 
    0.01148301f, 0.15035853f, 0.12498552f, -0.08423981f, 0.17909250f, -0.07625282f, -0.05799037f, -0.16343796f, 
    0.33749342f, -0.22025010f, 0.40197995f, 0.11700529f, 0.30493021f, 0.47265869f, 0.03481950f, -0.44521326f, 
    0.12815998f, -0.14679231f, -0.26118016f, 0.08742233f, 0.02851736f, -0.12228417f, -0.07418134f, -0.08734746f, 
    0.41096622f, -0.22442639f, -0.27278501f, -0.13322484f, -0.47156793f, 0.12754168f, -0.33055401f, 0.07779512f, 
    0.04093200f, 0.55748123f, -0.01699180f, 0.07246986f, -0.14629996f, 0.24283203f, -0.12139355f, -0.03001496f, 
    0.19995314f, 0.21219689f, -0.38997099f, -0.20860191f, 0.28249636f, -0.03548774f, 0.34353501f, -0.04141605f, 
    -0.02779268f, 0.30205137f, 0.26734975f, -0.20240174f, -0.23829603f, 0.03863801f, -0.31166017f, 0.20587648f, 
    0.12246296f, 0.10066326f, 0.37749112f, 0.24475461f, -0.33003139f, 0.27999935f, 0.09574401f, -0.37981319f, 
    0.11945423f, 0.29414329f, -0.26748562f, 0.14033541f, 0.18680117f, 0.19239382f, -0.12866907f, 0.41702560f, 
    0.11757565f, 0.07529205f, 0.00157386f, 0.07728058f, -0.21766856f, -0.20173213f, -0.18124023f, 0.03493443f, 
    -0.22405216f, -0.11289379f, -0.06322604f, -0.15325996f, -0.02038455f, 0.03625634f, -0.13696471f, -0.13019484f, 
    0.25051212f, -0.03109894f, 0.39203075f, 0.41098619f, -0.27680904f, 0.04522958f, -0.25428116f, -0.09605972f, 
    0.33396372f, 0.07073258f, -0.23876533f, -0.00653277f, -0.12834822f, -0.23548004f, -0.36465070f, -0.00680169f, 
    0.00387655f, 0.21749189f, 0.03534380f, 0.19586536f, 0.32477906f, 0.38842306f, -0.30428001f, -0.32117379f, 
    -0.47193223f, 0.26582268f, -0.31933326f, 0.15375654f, -0.18538535f, 0.19997232f, 0.25692031f, 0.21129319f, 
    -0.22519904f, -0.16687593f, 0.44270873f, -0.31376842f, 0.20395586f, 0.09157874f, 0.19852141f, 0.32992184f, 
    -0.21055765f, 0.04961227f, 0.42175439f, -0.17151566f, 0.05196854f, 0.03207565f, 0.05413102f, 0.35800305f, 
    0.30946094f, 0.04991687f, -0.11425296f, -0.51494217f, -0.21769838f, 0.00247501f, 0.39874959f, -0.24156252f, 
    0.20061702f, 0.24369086f, 0.09200386f, -0.11646515f, 0.09042366f, 0.09021440f, 0.04533981f, 0.42499235f, 
    -0.19162948f, -0.15473834f, 0.06777933f, -0.16251931f, -0.14756575f, -0.14596777f, -0.09793285f, -0.16305460f, 
    -0.07800303f, 0.18966782f, -0.03464389f, -0.03126865f, -0.07205808f, 0.00536251f, 0.03625359f, 0.02439764f, 
    0.11546061f, -0.20365252f, -0.25564978f, -0.22088534f, 0.29949424f, 0.22807573f, 0.28063828f, -0.07718121f, 
    -0.31056362f, 0.06059603f, 0.16788256f, 0.23066917f, -0.05289855f, 0.01868210f, -0.12848438f, -0.08390965f, 
    0.04374273f, -0.10617727f, 0.51023018f, 0.22431490f, -0.12949380f, 0.01437381f, 0.15322670f, -0.36012924f, 
    0.02048233f, -0.46469110f, -0.03199937f, 0.27979073f, -0.14114262f, -0.18725395f, -0.31457272f, 0.52819228f, 
    -0.04417421f, 0.06856751f, -0.57340050f, 0.02340983f, -0.09002092f, 0.22589159f, -0.10430186f, 0.02869453f, 
    0.11269438f, -0.39874762f, 0.32543275f, 0.08194226f, -0.12419128f, 0.09549332f, -0.40611029f, 0.37504405f, 
    0.16171595f, 0.06205643f, 0.02490301f, -0.07694759f, 0.03001148f, 0.61372226f, -0.06856708f, -0.03020761f, 
    -0.34464526f, -0.26402813f, 0.42224038f, 0.25246823f, 0.13727725f, -0.19630940f, -0.05011239f, 0.00999976f, 
    0.33256918f, -0.07730906f, 0.14581989f, 0.11630782f, -0.07142755f, 0.24433331f, 0.06776959f, -0.32599539f, 
    0.30260050f, -0.21797599f, -0.20900731f, 0.28833583f, -0.24283139f, -0.02852091f, -0.19338226f, 0.39520478f, 
    0.03237678f, 0.08913717f, 0.05390526f, -0.18815437f, 0.00321305f, -0.06124729f, -0.18481481f, -0.17717682f, 
    -0.06176576f, -0.17481324f, 0.10685900f, -0.14769363f, 0.13397843f, 0.20705670f, -0.09722536f, -0.15267867f, 
    -0.13657051f, 0.15355648f, -0.07894280f, 0.09008647f, -0.20018570f, 0.13145125f, -0.26130944f, 0.31405321f, 
    0.04594061f, 0.21636637f, -0.11302926f, 0.24466468f, -0.21100496f, 0.02262783f, 0.51513022f, 0.08589659f, 
    -0.07523420f, 0.15640569f, 0.13794293f, -0.07380727f, -0.09768954f, 0.33932739f, 0.42595875f, 0.17160709f, 
    -0.32838008f, 0.41856197f, 0.10898659f, -0.12826633f, 0.14504769f, 0.15033047f, -0.25915539f, 0.11286386f, 
    -0.08584687f, 0.13878256f, -0.02179670f, -0.25514948f, 0.36578947f, 0.41616625f, 0.41462955f, 0.10786548f, 
    -0.15632217f, -0.12003869f, 0.16179703f, 0.29109183f, -0.19628479f, 0.11150369f, 0.36484849f, -0.10536249f, 
    0.38113281f, 0.08391244f, 0.11083475f, 0.46285719f, 0.20633696f, -0.39772964f, -0.32209516f, -0.42313471f, 
    0.13207629f, 0.20304018f, 0.27035499f, 0.40529418f, 0.17817034f, -0.16647391f, 0.06040541f, 0.01793711f, 
    -0.21023723f, -0.11401910f, -0.24793515f, 0.45835462f, -0.26063362f, -0.26405942f, 0.16995579f, 0.19887257f, 
    -0.09552506f, 0.35119298f, 0.00170005f, 0.25972417f, 0.18698570f, -0.17532495f, 0.01846055f, -0.30890107f, 
    -0.20509574f, -0.10199110f, -0.18650000f, -0.08203822f, -0.10291465f, -0.44890541f, 0.44471955f, 0.10176816f, 
    -0.16366997f, 0.29182532f, 0.25275558f, -0.06667968f, 0.07074185f, 0.05608708f, 0.25506234f, 0.09697174f, 
    -0.23910239f, -0.22675130f, 0.14271411f, -0.19955485f, 0.19887604f, 0.24891746f, -0.09970796f, -0.01985827f, 
    -0.17164510f, 0.05188103f, -0.06939387f, -0.07725192f, 0.04150009f, -0.15336096f, -0.20703648f, -0.02584791f, 
    0.20667249f, -0.06206945f, -0.14936203f, 0.28683013f, 0.00594125f, -0.07746512f, 0.04502986f, -0.04793733f, 
    -0.41229171f, -0.27236977f, -0.28158870f, 0.12994227f, -0.18658143f, 0.22096056f, -0.21366243f, 0.56694770f, 
    0.03264235f, -0.03308713f, 0.43713033f, -0.18944584f, 0.63043791f, -0.41310823f, -0.04959509f, 0.04955868f, 
    -0.32450998f, 0.29240468f, -0.23926033f, 0.36921301f, -0.04115505f, 0.17623024f, 0.21353756f, -0.02083297f, 
    0.20140608f, 0.21729577f, 0.29039380f, -0.27110219f, -0.48240343f, -0.39056191f, -0.00134781f, -0.12368669f, 
    0.00837107f, 0.18110102f, -0.46196786f, 0.06563345f, -0.17061487f, 0.08464196f, 0.25034377f, -0.25033480f, 
    0.14661232f, 0.04099369f, 0.21659972f, -0.06563792f, -0.25128478f, -0.16121191f, -0.06907426f, 0.22473538f, 
    0.20243198f, 0.01281875f, -0.53898448f, 0.23258312f, 0.01423230f, 0.21171743f, 0.63124430f, -0.02172757f, 
    0.16904590f, 0.11873657f, 0.00274728f, 0.02796478f, 0.25732285f, -0.34287995f, 0.15747628f, -0.14812784f, 
    -0.29572669f, 0.00434182f, 0.54617363f, 0.38134965f, 0.08755818f, -0.11295528f, -0.33021757f, -0.13163336f, 
    -0.10945629f, -0.18467557f, -0.09233566f, -0.03809047f, 0.28843078f, 0.22831956f, -0.13540158f, -0.15995356f, 
    -0.35704842f, 0.02788694f, -0.31601965f, 0.00810320f, 0.12417337f, 0.20014393f, 0.24476661f, -0.13117725f, 
    0.34570521f, 0.23697278f, -0.04282347f, 0.17404200f, -0.05771839f, 0.30736855f, -0.26446095f, -0.07252374f, 
    0.25379366f, -0.33876872f, -0.08404177f, 0.39770481f, 0.12347574f, 0.13227774f, -0.11898570f, 0.21520092f, 
    0.39569041f, 0.00689805f, -0.04388475f, 0.07345855f, -0.02609129f, -0.32976639f, 0.16798541f, 0.16634440f, 
    -0.21665509f, 0.29570156f, 0.18525426f, -0.01002316f, -0.14682697f, 0.10637515f, -0.35441291f, -0.36070296f, 
    0.15161176f, 0.16586532f, 0.58509004f, -0.26448643f, 0.09173188f, 0.03732619f, 0.10271644f, 0.24073657f, 
    0.14079583f, -0.12875375f, -0.28336012f, -0.06923533f, -0.20074199f, -0.10943609f, -0.60515779f, -0.21979325f, 
    -0.24483106f, -0.09222654f, -0.20747611f, -0.18849620f, -0.15509212f, -0.16360751f, -0.04596055f, -0.14789367f, 
    0.10020557f, -0.16822574f, -0.10928708f, -0.13102254f, -0.10440630f, -0.11534172f, 0.21028641f, 0.23607579f, 
    0.34329572f, -0.10005145f, -0.23783953f, -0.37167323f, -0.25425440f, -0.18554363f, 0.20214522f, 0.43089080f, 
    0.49258184f, 0.23192514f, -0.00291906f, -0.19326092f, -0.14477792f, -0.21609342f, -0.25869280f, -0.13223258f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.15032341f, -0.11749440f, -0.49375856f, 0.54048663f, -0.02237382f, -0.11902503f, 0.19635250f, -0.48638776f, 
    -0.18879010f, 0.07342576f, -0.49335548f, 0.08659821f, 0.13023402f, 0.23333779f, -0.06780565f, -0.03367611f, 
    0.25798473f, 0.12552732f, 0.00566366f, 0.24667689f, 0.20548442f, -0.14464845f, 0.33953053f, 0.04224578f, 
    0.14960231f, -0.03409820f, -0.06536949f, 0.19574414f, 0.09346072f, -0.08682737f, 0.06377858f, 0.15183319f, 
    0.28745511f, -0.14799440f, -0.16661891f, -0.07538257f, 0.05744828f, -0.19344319f, 0.07735188f, -0.01091723f, 
    0.42261583f, -0.07157657f, -0.56248969f, 0.10736551f, -0.20544282f, -0.19867958f, 0.23045151f, 0.07681333f, 
    -0.08377613f, -0.03455958f, 0.55816174f, 0.51185399f, -0.21412137f, -0.13043442f, -0.12908541f, 0.31923741f, 
    0.00302395f, 0.56097955f, -0.04981101f, 0.13743064f, 0.55034566f, 0.16087343f, 0.08085451f, 0.04351879f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.25672317f, 0.28589889f, -0.09806114f, 0.26553437f, -0.01221300f, 0.05189046f, 0.44001433f, -0.66587567f, 
    0.15752651f, -0.00876182f, -0.09346785f, 0.05223911f, -0.04194321f, 0.44894448f, 0.05313583f, 0.11584226f, 
    0.09074945f, -0.15463442f, 0.03294229f, 0.11712303f, 0.12766215f, -0.09071761f, 0.04686543f, 0.11681362f, 
    -0.31586310f, -0.02769975f, -0.10912758f, -0.42698056f, 0.18582605f, -0.00250527f, 0.26978499f, -0.01492847f, 
    0.16557015f, -0.04085739f, 0.08640955f, 0.32393637f, -0.06078053f, -0.29656413f, -0.31790599f, 0.04349180f, 
    -0.03717004f, -0.08680004f, -0.73739910f, -0.11315671f, 0.04725670f, 0.11456329f, -0.00139742f, 0.13570297f, 
    -0.33038178f, 0.15853593f, 0.12058908f, -0.09066983f, -0.04243350f, -0.09334303f, 0.13194960f, -0.09339844f, 
    -0.17931145f, 0.06797761f, 0.10302574f, 0.00657379f, 0.34830856f, 0.35917360f, -0.06263228f, -0.00622487f, 
    0.12521838f, 0.08891536f, 0.16801207f, -0.14008783f, -0.00174296f, 0.14580354f, -0.29544023f, -0.34667906f, 
    0.10169891f, -0.16957046f, 0.17927244f, -0.07384502f, -0.10559472f, -0.21996093f, 0.03635418f, 0.10496949f, 
    0.20286724f, -0.07859764f, -0.03520082f, 0.49355564f, 0.45019281f, -0.15088643f, 0.56271553f, -0.13042863f, 
    0.27289456f, -0.01562130f, 0.13263990f, -0.05249211f, 0.67796713f, -0.02581045f, 0.36299500f, 0.22720812f, 
    -0.18872945f, 0.43926850f, -0.07323684f, 0.28267607f, 0.06810573f, -0.01575956f, 0.28957734f, -0.05845687f, 
    -0.33409855f, 0.38728926f, 0.02989472f, -0.17045353f, 0.35463834f, -0.01787202f, 0.13020267f, 0.04879525f, 
    -0.40237883f, 0.17536864f, 0.07961147f, -0.03818461f, 0.13760348f, -0.08100548f, 0.05826732f, 0.65314859f, 
    0.43355674f, -0.27680808f, -0.14449422f, 0.17491877f, -0.03671308f, 0.31578499f, 0.03509411f, 0.06131313f, 
    0.45114452f, 0.36228481f, -0.17638005f, 0.21015884f, 0.18546265f, 0.07566359f, 0.21937115f, 0.04094830f, 
    0.15697686f, -0.10501868f, -0.14773458f, 0.10176277f, 0.10897470f, 0.32256415f, 0.05307010f, -0.14905480f, 
    -0.18661833f, 0.03096745f, -0.18801852f, 0.29287958f, 0.04951810f, 0.20758396f, -0.66500384f, 0.07499819f, 
    -0.13810676f, 0.42215768f, 0.00649807f, -0.32554933f, -0.12645967f, 0.06180264f, 0.23063260f, 0.15058774f, 
    0.02690546f, -0.22266778f, 0.06656541f, 0.19666508f, 0.17436601f, 0.12221035f, -0.74431390f, 0.05185530f, 
    0.32557768f, -0.24728681f, -0.86953902f, 0.41296178f, -0.16119888f, 0.04030275f, 0.11871800f, 0.06819364f, 
    0.17355721f, 0.05167031f, 0.00158538f, -0.19570035f, -0.03989811f, -0.15479666f, 0.17605187f, 0.12674609f, 
    -0.14824265f, 0.26559782f, 0.01890084f, 0.21376890f, 0.21943982f, 0.14933108f, -0.01843622f, 0.09364889f, 
    -0.62255079f, 0.03404225f, 0.31282458f, -0.03669051f, 0.06090333f, -0.05284449f, -0.15550868f, 0.55494571f, 
    0.28862914f, 0.19784237f, 0.30986854f, 0.18346782f, -0.04511267f, -0.07675718f, -0.02974494f, -0.35136753f, 
    0.12829976f, 0.17862958f, -0.05371399f, -0.36149043f, -0.16571321f, 0.10356947f, -0.09558387f, -0.00993714f, 
    -0.14702378f, 0.01184429f, 0.25682661f, 0.17753954f, -0.48248240f, 0.05358303f, 0.09377129f, -0.06054565f, 
    0.29922220f, -0.09586047f, 0.03126019f, -0.34248346f, 0.21778287f, 0.19179186f, 0.46953782f, 0.07353403f, 
    0.33120441f, -0.23838748f, 0.32480469f, 0.25065929f, 0.09733065f, -0.09477754f, 0.02396943f, 0.03635001f, 
    0.59044009f, -0.01937992f, -0.10477089f, 0.07199186f, 0.08693908f, 0.04892414f, 0.05024926f, -0.64687431f, 
    0.06187630f, -0.20075426f, 0.13788848f, -0.13444473f, -0.13950476f, -0.32770181f, -0.03242154f, 0.16982548f, 
    -0.35281640f, 0.16779843f, 0.24459483f, 0.19331212f, 0.02335820f, 0.23642585f, -0.18230386f, 0.29808500f, 
    0.36354873f, 0.31139204f, 0.31418899f, 0.24047863f, 0.10619109f, 0.11665068f, 0.02117647f, 0.17447011f, 
    0.15625073f, 0.32635430f, -0.01360097f, -0.23869120f, -0.03990658f, 0.14201669f, -0.09706346f, -0.41050604f, 
    -0.06850048f, -0.00499955f, -0.33460119f, -0.06973029f, -0.06576591f, -0.01131587f, -0.20056352f, -0.00324368f, 
    0.28235945f, -0.13231328f, -0.01787052f, -0.28575993f, -0.24320744f, 0.13413028f, 0.12992947f, -0.09935182f, 
    0.22945121f, -0.45628887f, -0.74898648f, -0.10862026f, -0.14111944f, 0.05499874f, 0.16719964f, 0.23213466f, 
    0.42984727f, -0.10245246f, 0.21847437f, 0.26769093f, -0.31060466f, -0.09892724f, 0.29182652f, -0.16760209f, 
    0.03761715f, 0.02936654f, 0.20080471f, -0.31403971f, 0.06603167f, -0.05868932f, 0.06186092f, 0.21852590f, 
    0.24948022f, 0.23071598f, -0.32717395f, 0.26856416f, 0.13001765f, 0.33909723f, 0.14819762f, 0.27837831f, 
    0.26092896f, 0.01638970f, -0.44800857f, -0.25908211f, -0.04213962f, 0.16839154f, 0.08785714f, 0.56684303f, 
    0.10475388f, 0.04990542f, -0.07871492f, -0.17432384f, 0.05165923f, -0.11694136f, -0.29897639f, 0.33667502f, 
    0.26628587f, 0.24466759f, 0.16802873f, 0.04148801f, 0.09214548f, -0.11693083f, 0.10201109f, -0.04376569f, 
    -0.30909216f, -0.03790868f, -0.07414852f, 0.15187930f, -0.46022695f, 0.01056849f, -0.44896680f, -0.01581458f, 
    -0.19530846f, 0.21325471f, -0.50842530f, 0.09745241f, 0.15037228f, -0.04434161f, 0.13917404f, -0.32876506f, 
    -0.09917050f, 0.14244553f, 0.30442974f, 0.10076290f, -0.09413645f, -0.16806580f, 0.13375917f, 0.20207413f, 
    0.15647036f, 0.09347583f, 0.14168037f, 0.11730600f, 0.09493617f, -0.11381802f, 0.10813963f, -0.10747230f, 
    0.61957502f, -0.06610929f, 0.13503979f, -0.16300048f, 0.04094970f, -0.11381997f, 0.14553858f, 0.09437478f, 
    -0.04987429f, 0.15731321f, 0.26159447f, 0.24249515f, -0.06783886f, -0.26555881f, 0.07179447f, -0.09780026f, 
    -0.07744975f, -0.00537532f, 0.16458619f, -0.10824434f, 0.00428608f, 0.38137320f, 0.30107060f, 0.26433077f, 
    0.20281637f, -0.37099567f, 0.08146196f, 0.26294097f, 0.04886401f, 0.10808602f, 0.06071956f, -0.41102880f, 
    0.07059062f, -0.02049272f, 0.07614881f, -0.24279799f, -0.15413894f, 0.69607276f, 0.29195130f, -0.06249867f, 
    0.13722400f, 0.31724530f, 0.42994711f, 0.35383502f, -0.01200609f, -0.09891012f, -0.19697361f, 0.58044624f, 
    0.34661499f, -0.13673465f, -0.16687295f, 0.16378389f, -0.00835488f, 0.33179396f, -0.01853582f, -0.07591186f, 
    -0.20445888f, -0.08225264f, 0.06482954f, -0.13410710f, -0.18614946f, 0.15164469f, -0.07063496f, 0.09395066f, 
    0.30778620f, 0.11545316f, -0.30761087f, -0.11771317f, 0.13432172f, 0.33200350f, 0.03993229f, 0.17456782f, 
    0.13471718f, 0.03519181f, -0.20555896f, 0.37890863f, -0.08273234f, 0.03136675f, -0.09473208f, 0.17183942f, 
    0.05533139f, 0.32402059f, -0.37816727f, 0.03877217f, 0.32616007f, 0.07347289f, -0.67569029f, 0.31583768f, 
    0.38852173f, -0.01737748f, 0.08636905f, 0.17758484f, 0.22892731f, -0.02530740f, -0.35208252f, 0.53875494f, 
    -0.53460526f, -0.08479477f, -0.04988027f, -0.02869892f, 0.28051379f, 0.21903676f, -0.03472061f, -0.11276942f, 
    -0.23328891f, -0.45558780f, -0.81390047f, 0.19793312f, -0.35422325f, -0.02541754f, 0.37470400f, -0.34475991f, 
    0.01521614f, 0.04590572f, 0.03735209f, -0.01792019f, -0.14384006f, 0.34532583f, -0.05753050f, -0.10811934f, 
    0.37867534f, -0.49227449f, 0.13411058f, 0.01234561f, -0.17412587f, -0.43502688f, -0.03121577f, 0.00420650f, 
    0.10398858f, -0.06120841f, -0.04959245f, 0.34989563f, -0.22454433f, -0.04038561f, -0.15424709f, -0.29126713f, 
    -0.24245597f, -0.09399484f, -0.21661319f, -0.19873804f, -0.07928084f, -0.21998769f, -0.04867347f, 0.19808248f, 
    0.39237651f, 0.33996066f, -0.05277536f, -0.19768862f, 0.01608585f, 0.03104742f, 0.26637313f, -0.31118563f, 
    0.35052601f, -0.02368792f, -0.11315671f, 0.39037865f, 0.10451481f, 0.05674051f, -0.18485722f, -0.65038359f, 
    -0.08364516f, -0.06188216f, -0.02486804f, -0.01557559f, -0.30826548f, 0.16912657f, -0.02257678f, -0.02009219f, 
    0.16696134f, 0.27601111f, -0.01473543f, 0.14874393f, -0.13363369f, -0.08584865f, 0.12549397f, -0.02125053f, 
    -0.01350609f, -0.03147211f, 0.14997426f, 0.34197426f, -0.20793168f, -0.16345729f, 0.12545343f, 0.10470653f, 
    0.04206585f, 0.20510770f, 0.09467999f, -0.20898521f, 0.17619784f, 0.10312035f, -0.00177899f, -0.05688142f, 
    0.26768070f, -0.11459308f, -0.11446522f, -0.03921616f, -0.08579932f, -0.09629556f, 0.03769464f, 0.16082068f, 
    -0.11430808f, 0.27384278f, 0.10296204f, 0.24440175f, -0.03996165f, 0.01529127f, -0.00035098f, -0.29004306f, 
    0.02530580f, 0.32855505f, 0.11241441f, 0.06966437f, 0.35842800f, 0.24897456f, 0.17703006f, -0.21994333f, 
    0.26720917f, -0.41249362f, 0.01425120f, -0.10080872f, 0.13245246f, -0.03888665f, -0.42005998f, 0.54091054f, 
    0.34934357f, 0.02760940f, 0.09107746f, -0.11020752f, -0.73321176f, 0.49266219f, 0.54914057f, 0.04178665f, 
    0.01834361f, -0.43115705f, -0.32211992f, 0.05035885f, -0.12573285f, 0.10904524f, 0.23097189f, 0.40566811f, 
    0.03203060f, -0.24175425f, 0.12198595f, 0.28214118f, -0.40676197f, 0.00692401f, -0.26350135f, 0.12486432f, 
    0.06222153f, -0.08494516f, -0.00822998f, -0.17530437f, 0.20274310f, 0.16560000f, 0.04259759f, 0.46883467f, 
    0.52757055f, 0.23190884f, 0.09658401f, 0.01085450f, 0.15765199f, 0.07366234f, -0.18675198f, 0.46341360f, 
    0.03183688f, 0.16684869f, 0.14884675f, 0.24927136f, -0.01015056f, 0.26470950f, -0.07927559f, 0.20024936f, 
    -0.13319556f, 0.24449201f, 0.01170542f, -0.00690814f, -0.49732739f, 0.26503816f, -0.31070152f, 0.19945395f, 
    -0.26752719f, 0.14897132f, -0.23657076f, 0.22575946f, -0.32269531f, -0.02859029f, -0.19909534f, -0.07803579f, 
    -0.02543350f, -0.15013839f, -0.00950080f, -0.04593389f, 0.20337042f, 0.23149072f, -0.50659037f, -0.01553857f, 
    0.29139537f, -0.00929546f, 0.10672908f, 0.37825188f, -0.19653457f, 0.12117428f, -0.03223947f, 0.46853653f, 
    0.33452451f, -0.05475498f, 0.09624739f, 0.00463570f, 0.19461463f, 0.34424734f, 0.07359249f, -0.74692923f, 
    -0.40736419f, 0.05310755f, 0.05110461f, -0.11430681f, 0.07918013f, -0.15149949f, 0.02311273f, -0.15743689f, 
    0.40351340f, 0.10182003f, 0.29853362f, 0.21235979f, 0.15244450f, 0.25787377f, 0.60070610f, -0.80489361f, 
    0.06588582f, 0.19720407f, 0.03219767f, -0.14703248f, -0.06433606f, 0.23376973f, -0.04314576f, 0.57557321f, 
    0.02029195f, 0.35549152f, 0.28393090f, -0.20209730f, -0.27545583f, -0.13160945f, 0.06494426f, -0.31491622f, 
    0.22637956f, -0.35555676f, 0.25618291f, 0.11027078f, -0.03833169f, 0.08178701f, -0.36852300f, 0.26478985f, 
    -0.10495836f, 0.25034767f, 0.06555946f, 0.14916925f, -0.29633147f, 0.19532028f, -0.34065595f, 0.12253368f, 
    -0.13834883f, -0.04902099f, 0.25778624f, -0.24933784f, -0.12809198f, 0.03299938f, 0.17446414f, 0.19789052f, 
    -0.27968711f, 0.25733912f, 0.15918458f, 0.11908147f, -0.02777494f, 0.08294274f, 0.10459823f, 0.24055307f, 
    -0.15072422f, -0.02099345f, 0.03609565f, 0.01589372f, -0.00346174f, -0.42446098f, -0.04553780f, -0.08899381f, 
    0.23008633f, 0.04723781f, -0.23781134f, 0.30517620f, -0.24893183f, 0.19829521f, 0.11224928f, -0.15723047f, 
    0.17326124f, -0.00983828f, -0.14055055f, -0.09304103f, 0.00459474f, -0.02134964f, 0.08834359f, 0.01738529f, 
    0.40991601f, 0.16602318f, 0.00631655f, -0.41335863f, 0.20697029f, -0.16503872f, -0.14354913f, -0.07800860f, 
    0.49298924f, 0.02491233f, 0.26601794f, 0.26442295f, 0.29754740f, -0.09174299f, 0.14485452f, -0.21029125f, 
    -0.23699802f, -0.01440540f, 0.03864847f, 0.17846312f, -0.22376341f, 0.09285326f, 0.04944988f, -0.01253466f, 
    -0.15276118f, 0.35764477f, 0.40837494f, -0.09547148f, 0.08472030f, -0.12388168f, 0.19600859f, -0.16299862f, 
    -0.03498335f, 0.15805151f, 0.09007471f, 0.19874232f, -0.00327030f, -0.29091945f, -0.09761360f, 0.50190431f, 
    0.24360552f, -0.03148750f, 0.12068758f, 0.22147109f, -0.10666149f, -0.16781557f, 0.06958969f, 0.02278733f, 
    -0.18973351f, -0.40410516f, 0.30748352f, -0.07107144f, 0.18401788f, -0.28270707f, -0.13823758f, -0.22774477f, 
    -0.30331144f, -0.22511716f, 0.09170361f, 0.11147893f, 0.04981318f, -0.04839244f, 0.11775731f, -0.74700576f, 
    -0.49980211f, -0.75119472f, -0.17601798f, -0.36318365f, 0.09842180f, 0.45450276f, 0.01632307f, -0.52198851f, 
    -0.12078094f, 0.19515854f, -0.04128800f, -0.03489654f, -0.00167729f, 0.03253497f, 0.27776933f, -0.59666538f, 
    0.20914765f, 0.21416761f, -0.06542470f, -0.14255241f, 0.52157891f, 0.23245795f, 0.28928217f, 0.06950076f, 
    0.21953583f, 0.28477588f, 0.10761686f, 0.49254346f, 0.38530326f, 0.05900354f, -0.12119875f, 0.01963429f, 
    0.40161315f, -0.09374186f, -0.12107123f, -0.25822741f, -0.12093943f, 0.29785672f, -0.21345207f, -0.41529796f, 
    -0.20406471f, 0.14132756f, -0.08887386f, 0.41967207f, -0.20852944f, 0.40544990f, -0.05307990f, -0.02122076f, 
    0.44557133f, 0.01607984f, 0.00545887f, 0.39385620f, 0.01062724f, 0.16071691f, 0.52082896f, -0.66469103f, 
    0.10703815f, -0.07568288f, -0.37924373f, -0.16130880f, -0.03714285f, 0.24460821f, -0.00058779f, 0.19958244f, 
    0.27798215f, -0.24416603f, 0.02715060f, -0.44879571f, 0.40449598f, 0.04056783f, -0.02242523f, 0.29517046f, 
    0.38098574f, 0.07781664f, 0.17412736f, -0.05010325f, 0.70188683f, -0.11384515f, -0.09051447f, 0.11971682f, 
    0.00328472f, 0.04935146f, -0.06107530f, 0.53396815f, -0.21814257f, -0.02037629f, -0.17045203f, 0.12371153f, 
    -0.24729885f, 0.40741077f, 0.24315968f, -0.16209920f, 0.09473480f, -0.11241733f, 0.15512620f, -0.29028851f, 
    -0.17834413f, 0.10448572f, 0.07174959f, -0.08222569f, -0.03454268f, 0.21235146f, -0.01490201f, 0.33908424f, 
    0.36237830f, 0.11882727f, -0.07455086f, 0.23768999f, 0.08553623f, 0.30062389f, -0.09100752f, -0.02388900f, 
    -0.46426153f, 0.02612448f, 0.13470726f, -0.17213945f, 0.29198208f, -0.10429446f, -0.32796040f, 0.11228482f, 
    -0.09149580f, -0.17365332f, 0.12442626f, -0.13579549f, 0.10184451f, 0.05712532f, 0.12124701f, 0.01227637f, 
    0.02429310f, -0.11395845f, -0.16010968f, 0.26145646f, -0.05432412f, 0.05973397f, 0.07747757f, 0.26632005f, 
    -0.20394801f, 0.44353122f, 0.15333743f, 0.26803231f, -0.09981753f, 0.11876111f, 0.36191770f, -0.36254227f, 
    -0.11446811f, 0.25178036f, 0.08018912f, 0.13823485f, 0.48098138f, 0.05344314f, -0.20689233f, 0.07752470f, 
    0.15527853f, 0.25602961f, 0.46026021f, 0.42529356f, 0.16247649f, -0.05728514f, -0.04134282f, 0.01715410f, 
    0.24760793f, 0.24218771f, -0.05966710f, -0.07149325f, -0.04251130f, -0.08160782f, 0.27230883f, 0.34432822f, 
    0.18216579f, 0.02538463f, -0.01941920f, 0.24265483f, -0.03301445f, 0.01136510f, -0.01937695f, -0.28711036f, 
    -0.41643238f, -0.20266338f, -0.34473598f, 0.02850150f, 0.34353837f, 0.19244635f, -0.23506136f, -0.11740465f, 
    0.22366093f, 0.03533496f, -0.57259691f, 0.22939609f, -0.01590091f, 0.20160931f, 0.12060729f, -0.22425795f, 
    -0.04972194f, -0.48571983f, 0.01821293f, -0.31388560f, -0.10865980f, -0.16885234f, -0.02231360f, -0.11791335f, 
    -0.08069464f, 0.29110250f, -0.00388240f, 0.15907234f, -0.13035169f, 0.11611488f, 0.24529552f, 0.33108401f, 
    -0.00182517f, 0.14668335f, -0.00580373f, 0.04132058f, -0.07479262f, -0.62547100f, 0.23612124f, 0.10697198f, 
    0.07562825f, 0.01512058f, -0.64346689f, 0.16025497f, 0.25953805f, -0.01057544f, 0.17179592f, -0.32455215f, 
    -0.10252663f, 0.26888487f, 0.14651126f, 0.01920832f, 0.08877885f, -0.36483246f, -0.31855920f, -0.38908952f, 
    -0.08624518f, 0.17061819f, 0.01592939f, 0.33801126f, 0.05710889f, -0.39671773f, -0.03808574f, 0.03190911f, 
    0.02860894f, -0.09682973f, 0.00604119f, 0.37499756f, -0.01463134f, -0.00019985f, 0.06482438f, -0.22399291f, 
    0.17297611f, 0.39936969f, -0.20218232f, 0.03004624f, -0.07725343f, 0.22925486f, 0.06739154f, 0.04872761f, 
    0.02824862f, -0.03079090f, 0.20032354f, -0.22049774f, 0.00451375f, -0.10924219f, 0.07001023f, -0.67886877f, 
    -0.24674469f, 0.10322616f, -0.07802995f, 0.25818738f, -0.07513719f, -0.00347121f, -0.11369931f, 0.28266892f, 
    0.30175191f, 0.02629393f, -0.08611326f, -0.06270526f, -0.33307070f, -0.17112599f, 0.09851437f, 0.06942717f, 
    0.23520203f, -0.11752266f, -0.41738626f, -0.09359751f, -0.11724064f, 0.09258946f, 0.03295973f, 0.04083419f, 
    0.04018395f, 0.02596275f, 0.14813003f, 0.34869164f, 0.05624629f, -0.09779228f, 0.18077636f, -0.26074243f, 
    0.02372563f, 0.34341809f, 0.17223635f, -0.01729176f, 0.21516059f, -0.13271940f, -0.12004985f, 0.17675184f, 
    0.00076686f, -0.01067391f, 0.22603607f, -0.23915301f, 0.02905642f, 0.05502215f, -0.32138401f, -0.66912127f, 
    -0.16528586f, 0.02148217f, 0.16984010f, 0.05292242f, 0.06631000f, 0.13257642f, -0.00682451f, 0.46893808f, 
    0.15410738f, 0.24965417f, -0.08467955f, 0.26564047f, -0.27435601f, 0.07121898f, 0.14535446f, -0.49424675f, 
    0.03047603f, 0.07498305f, -0.24606942f, 0.08453002f, -0.11482877f, 0.01426411f, -0.16365185f, 0.22015002f, 
    -0.15632512f, 0.25586084f, 0.09964892f, 0.20960155f, -0.17333373f, 0.20171094f, -0.29385251f, 0.01539789f, 
    -0.16146411f, 0.01409171f, 0.36565542f, -0.03787779f, -0.11118723f, -0.07582018f, 0.07996708f, 0.34014267f, 
    -0.09681471f, 0.02319987f, 0.05075287f, -0.11565973f, 0.15676247f, 0.28515065f, 0.31550625f, 0.44271401f, 
    0.04131505f, 0.15936011f, -0.25725165f, -0.05039963f, 0.15138213f, -0.03504271f, 0.10605815f, -0.30765876f, 
    -0.12408137f, -0.18782474f, -0.11332696f, 0.09458739f, 0.06554978f, 0.02535555f, 0.18027496f, 0.19430906f, 
    0.10605884f, 0.25611636f, -0.43854678f, -0.01761740f, 0.06864165f, 0.28986633f, -0.12353310f, -0.17885752f, 
    -0.22448811f, -0.03840652f, -0.02090572f, -0.38464734f, 0.00890666f, 0.09109850f, -0.14938930f, -0.55740368f, 
    -0.18525960f, 0.17158967f, -0.05863009f, 0.04196176f, -0.23792456f, 0.08722745f, -0.05915712f, 0.32807341f, 
    0.33391872f, -0.17164552f, -0.10537077f, -0.16332035f, -0.38505393f, -0.16787621f, 0.10939422f, 0.01344972f, 
    0.31651890f, -0.10239469f, -0.73539889f, 0.11387416f, -0.05038755f, -0.05254252f, 0.17904988f, 0.03927595f, 
    0.09367617f, 0.08003394f, 0.10107828f, 0.31044558f, 0.14800622f, 0.00566690f, 0.07020720f, -0.44102114f, 
    -0.24162538f, 0.31361586f, 0.03255819f, -0.03626141f, 0.20976076f, -0.01839048f, -0.09791154f, 0.44757447f, 
    -0.29153049f, 0.16671970f, -0.30005398f, 0.05183903f, 0.29515246f, 0.27687922f, 0.12237933f, 0.23030132f, 
    0.04059638f, 0.15479746f, -0.03927213f, 0.29076421f, -0.00543215f, 0.27373263f, -0.02044144f, 0.53333884f, 
    0.03462956f, 0.18113312f, 0.15828727f, -0.18238711f, -0.44897896f, -0.04722299f, 0.20382157f, -0.49643862f, 
    0.18207519f, -0.15351424f, 0.07285557f, 0.23185052f, -0.44174817f, -0.11842375f, -0.21511394f, -0.01221028f, 
    0.03330007f, 0.20785959f, 0.12366077f, -0.23575921f, -0.02521534f, -0.04062732f, -0.35868999f, -0.11630018f, 
    0.31338084f, 0.06525021f, 0.02240802f, 0.28479916f, -0.27256352f, 0.06940930f, 0.11929944f, 0.35671204f, 
    0.14317843f, -0.08281157f, 0.33140540f, 0.14442846f, -0.18288562f, -0.43463868f, -0.28219062f, -0.36034665f, 
    -0.31942129f, 0.24983659f, 0.06232210f, -0.22788225f, -0.08732973f, -0.75971544f, -0.04591446f, -0.28857601f, 
    0.04975757f, -0.11887539f, 0.08606755f, -0.08840478f, -0.14533660f, -0.00974031f, -0.04192071f, 0.06752191f, 
    -0.13945170f, -0.00023417f, 0.02626276f, -0.06358254f, -0.10113978f, -0.01097453f, -0.00859524f, -0.04369465f, 
    0.09422879f, -0.00479646f, -0.03994196f, 0.06437559f, -0.11807378f, -0.07115514f, -0.05572855f, 0.00925468f, 
    -0.11151548f, 0.06635854f, 0.03201324f, -0.05296893f, 0.09906302f, -0.03333756f, 0.00700668f, -0.05449343f, 
    0.10017519f, -0.00090747f, 0.03757074f, 0.05197423f, -0.06100701f, -0.10228705f, 0.08543753f, -0.08977838f, 
    -0.09039608f, 0.05898024f, 0.11775483f, -0.09499194f, -0.05674988f, -0.01738417f, 0.04830855f, 0.06818289f, 
    -0.09078702f, 0.04176267f, -0.01299033f, -0.12134419f, 0.03037839f, 0.04872847f, -0.06846461f, 0.05089363f, 
    -0.10737408f, -0.00061034f, 0.05844845f, 0.03687145f, -0.07824584f, -0.05985693f, 0.04159859f, -0.11162706f, 
    -0.09840655f, 0.11942956f, -0.25733936f, 0.25136369f, -0.00875344f, 0.32447830f, -0.09726577f, 0.20718572f, 
    0.19421971f, 0.04804999f, -0.08323240f, 0.00232452f, -0.04527211f, 0.12899789f, 0.03119187f, 0.25575641f, 
    0.25715208f, 0.17713127f, 0.24993469f, -0.18996546f, -0.11468768f, -0.05109646f, -0.18373829f, 0.10274937f, 
    0.28166705f, 0.31682342f, 0.24837284f, 0.24050164f, -0.23861563f, -0.11126626f, 0.21115972f, -0.44923386f, 
    -0.09127805f, 0.05162432f, 0.09133425f, -0.04276133f, -0.20168941f, 0.11908131f, -0.26624453f, -0.10167663f, 
    -0.02977474f, 0.11673971f, -0.58583170f, 0.09235814f, -0.05550782f, -0.07892632f, 0.06193805f, -0.06630988f, 
    0.30534491f, 0.15642715f, 0.07397600f, 0.08950703f, 0.02836026f, -0.65310377f, 0.06174400f, 0.19729424f, 
    -0.04633927f, 0.03179242f, 0.14382121f, 0.09717086f, -0.01373601f, -0.21045899f, 0.01882556f, -0.27691996f, 
    0.64826077f, -0.03089439f, 0.17351961f, -0.07346459f, 0.22483118f, 0.07625712f, 0.37179363f, 0.40783793f, 
    -0.13714714f, 0.12557569f, 0.36411092f, 0.28108662f, 0.06728742f, -0.11657033f, -0.08114192f, 0.18767606f, 
    -0.11843041f, 0.12875628f, 0.01675728f, -0.51321667f, -0.04094535f, 0.08635703f, 0.03274851f, 0.23717353f, 
    0.37430111f, -0.30131242f, -0.19985496f, 0.23919238f, 0.04934061f, -0.00523621f, 0.02495549f, -0.55582565f, 
    0.01199450f, 0.17775089f, 0.05672562f, 0.04424742f, 0.35869685f, 0.36949793f, 0.03463797f, -0.06190076f, 
    -0.17445622f, 0.21998860f, 0.43824631f, 0.16398840f, 0.13161463f, -0.05015872f, 0.02644800f, 0.24623469f, 
    0.13071391f, -0.09519212f, -0.07693740f, -0.08279518f, 0.21041159f, 0.41471165f, -0.03233283f, 0.11356162f, 
    -0.11843806f, -0.24635072f, -0.11559868f, -0.00455150f, -0.47989610f, -0.33692649f, 0.00255796f, -0.25626117f, 
    0.35801572f, 0.00690958f, -0.31614500f, 0.06379604f, 0.12718682f, -0.03213469f, 0.03510106f, -0.69555992f, 
    -0.02950096f, 0.07706689f, -0.10848520f, 0.08122032f, -0.24743627f, 0.29274046f, 0.12281337f, -0.22621192f, 
    -0.07101505f, -0.40577346f, 0.19934121f, -0.04201118f, 0.19565134f, -0.03976909f, 0.45362517f, -0.78197545f, 
    -0.39012417f, -0.08443111f, -0.04858430f, -0.00543503f, -0.06410366f, -0.02476914f, 0.01701156f, 0.57291740f, 
    0.34977290f, 0.14839934f, -0.11725861f, 0.06528812f, -0.24939203f, -0.22918205f, 0.43780512f, 0.04904872f, 
    0.20814742f, -0.01240908f, -0.34215134f, -0.17099823f, 0.12441833f, 0.01749047f, -0.10654134f, 0.07551984f, 
    -0.15734495f, 0.12948847f, 0.08152905f, 0.23060223f, -0.20134580f, -0.21797813f, -0.13170616f, -0.42781600f, 
    -0.27449721f, 0.06858966f, -0.05414558f, -0.00664141f, 0.20102613f, 0.11938063f, -0.10625012f, 0.41762310f, 
    -0.03446273f, -0.00670130f, -0.04873707f, -0.05713305f, -0.11697312f, -0.08281161f, -0.08227156f, -0.02860415f, 
    -0.01943520f, -0.09873918f, -0.05489171f, 0.00561248f, -0.10116243f, 0.01338529f, 0.04260650f, -0.10739105f, 
    -0.12069581f, 0.01164642f, -0.13640730f, -0.01096739f, 0.09265254f, 0.08883644f, -0.02835423f, -0.13898182f, 
    -0.12340995f, -0.00456567f, -0.04313678f, -0.04232042f, -0.03380539f, 0.11347488f, 0.05069065f, 0.11119189f, 
    0.05196088f, -0.02270806f, -0.09021600f, 0.08621380f, 0.05278314f, -0.11600936f, 0.03808245f, 0.09544036f, 
    -0.02512585f, -0.05905188f, -0.05864550f, 0.00384164f, -0.13461611f, 0.09077679f, -0.14771421f, -0.00882048f, 
    -0.00772094f, 0.04410026f, -0.05819181f, -0.13171466f, -0.06221126f, 0.08499602f, -0.03840150f, 0.03350602f, 
    -0.08601580f, -0.10830364f, 0.07241403f, -0.03423010f, -0.06341656f, -0.05762129f, -0.02850063f, -0.13396972f, 
    -0.35206524f, 0.02548301f, 0.06437755f, 0.17248516f, 0.18884741f, 0.18991633f, 0.15598576f, 0.08125567f, 
    0.10882402f, 0.01455506f, 0.08800787f, -0.15105230f, -0.09380251f, 0.13613297f, 0.03067106f, -0.02097252f, 
    0.13532762f, -0.19059281f, -0.14813624f, -0.23548923f, 0.27074882f, 0.03492733f, -0.49386105f, 0.20963161f, 
    0.12871641f, 0.13831992f, 0.29943952f, 0.03667584f, 0.22181635f, -0.00797191f, 0.18811594f, -0.44217768f, 
    -0.17073104f, 0.08697066f, -0.08083265f, 0.05346639f, 0.44786879f, -0.10749324f, -0.30383030f, -0.07686061f, 
    -0.08522513f, 0.35176462f, 0.40833801f, 0.04286157f, 0.29143474f, -0.08010413f, 0.02960202f, -0.35426152f, 
    -0.00545746f, 0.13618232f, 0.13231981f, -0.09697185f, 0.05371906f, 0.31905138f, 0.07259160f, 0.05647841f, 
    0.35698238f, -0.04075119f, -0.03726625f, 0.34493271f, -0.09638475f, 0.06219897f, 0.09453772f, -0.01810322f, 
    0.03540233f, -0.05661467f, 0.05519741f, -0.01965708f, -0.14515509f, -0.07278787f, -0.08522695f, -0.11091425f, 
    0.02984735f, 0.00815674f, 0.05996002f, -0.07518917f, -0.00438100f, -0.06648210f, 0.09077422f, -0.05333984f, 
    0.03261197f, 0.00872686f, -0.14839305f, -0.09633784f, -0.00188171f, 0.03690120f, -0.03473964f, -0.12205246f, 
    0.02866796f, 0.08865929f, -0.08489405f, 0.07426687f, -0.14857055f, -0.01121667f, 0.09285270f, 0.03181464f, 
    0.02789016f, -0.08051170f, 0.00749683f, -0.10201033f, -0.03305708f, -0.13934149f, -0.09957966f, 0.08692764f, 
    -0.07959320f, -0.08133011f, 0.09714153f, -0.00465129f, 0.04600108f, 0.06094544f, -0.07017338f, 0.08460147f, 
    -0.10070429f, -0.06528146f, -0.12515506f, -0.12362281f, 0.09408902f, 0.12234139f, 0.08550102f, -0.06048724f, 
    0.08562288f, -0.03271534f, 0.03721985f, -0.13888454f, -0.00535229f, -0.07418749f, 0.11275655f, -0.05356927f, 
    0.37501496f, -0.14123315f, 0.21569236f, -0.06927704f, -0.35252124f, -0.09403794f, -0.56753546f, -0.27840036f, 
    -0.02652646f, 0.12556435f, 0.37041312f, 0.15226783f, 0.09609020f, -0.10781079f, 0.05746706f, -0.19649561f, 
    0.14965279f, 0.01129615f, 0.29858455f, -0.08588196f, 0.17700565f, 0.08966563f, 0.55857503f, 0.25951710f, 
    0.50091904f, -0.47832605f, 0.02045767f, -0.21778052f, 0.08080778f, 0.03086057f, -0.05287310f, -0.14184017f, 
    0.25402966f, 0.13465980f, 0.00372680f, -0.01272441f, -0.37180862f, 0.34917706f, 0.42690668f, 0.03332147f, 
    -0.01880155f, 0.09458669f, -0.56571198f, -0.00489416f, -0.05452131f, 0.04518640f, -0.26996887f, 0.59584618f, 
    0.09761943f, -0.32956958f, -0.01833834f, 0.24304622f, -0.47996110f, -0.42324856f, -0.15811001f, 0.34757546f, 
    0.02181675f, -0.04305962f, -0.13556238f, -0.33809930f, -0.01391154f, -0.11422404f, 0.08799541f, 0.18135460f, 
    0.22345236f, 0.03387782f, -0.06810815f, 0.16281684f, -0.16803339f, 0.13228965f, 0.62801117f, -0.35862604f, 
    0.32868227f, 0.24064600f, -0.23168258f, -0.01973484f, -0.10645576f, 0.14041369f, -0.02820601f, 0.10366753f, 
    0.21869178f, 0.16453809f, 0.23329924f, -0.37694597f, -0.05258319f, -0.23729122f, 0.12940311f, -0.15627642f, 
    -0.04320902f, 0.00860576f, 0.06861285f, -0.09187200f, -0.01275924f, 0.11804937f, -0.16939010f, 0.17322965f, 
    0.24017656f, -0.04686574f, -0.03163944f, 0.06505067f, -0.00926738f, -0.05254975f, -0.03279222f, 0.04241250f, 
    0.04882873f, 0.07106442f, -0.44275016f, -0.24689397f, -0.05305394f, -0.07991268f, 0.00405173f, -0.22254260f, 
    -0.08106390f, 0.01893568f, 0.25669086f, 0.34898782f, 0.01946268f, 0.11965061f, 0.00923914f, -0.12860481f, 
    0.01695705f, 0.03335899f, 0.22293381f, 0.13436885f, 0.25076133f, -0.33456424f, -0.02393612f, 0.25123248f, 
    0.47375870f, 0.15357502f, 0.09905235f, 0.06451385f, 0.09023128f, 0.07192477f, 0.10478406f, -0.65446186f, 
    0.08182050f, -0.05024897f, 0.10367998f, 0.10031336f, 0.05447840f, 0.42444727f, 0.00778200f, -0.07807613f, 
    0.02713523f, -0.37624919f, 0.20509940f, 0.21798132f, 0.04007025f, -0.23712741f, 0.06966715f, 0.18824001f, 
    -0.20809892f, -0.27469453f, 0.26928368f, -0.42233738f, 0.10633548f, -0.10191840f, 0.26974952f, 0.46867487f, 
    0.12166859f, 0.28104961f, -0.10566506f, 0.48656583f, -0.47848448f, -0.14121433f, -0.15921934f, 0.06648718f, 
    -0.21538135f, 0.02064831f, -0.30222714f, -0.29350606f, 0.20832862f, -0.00837662f, -0.04300429f, 0.00286021f, 
    -0.34882614f, 0.26597044f, 0.16134147f, -0.04232712f, -0.12425894f, -0.63856483f, -0.05057122f, 0.22686142f, 
    0.05911199f, -0.13172567f, -0.18139572f, 0.13685188f, 0.14101906f, 0.09944354f, 0.08208160f, 0.15937494f, 
    0.76446670f, -0.06608481f, -0.14007697f, 0.19666655f, 0.04008370f, 0.06682590f, 0.21685237f, -0.57254779f, 
    0.19492948f, 0.10204251f, -0.02139933f, 0.17087436f, 0.12120442f, 0.39441609f, -0.01241374f, -0.22199354f, 
    -0.13583244f, -0.42247826f, 0.33486593f, 0.09497491f, 0.10195743f, -0.06824814f, 0.43445420f, -0.48750117f, 
    -0.31838742f, -0.12357979f, 0.16427062f, -0.24852376f, 0.05372566f, 0.07547659f, 0.13691340f, 0.76363498f, 
    0.13086112f, 0.07322393f, 0.10461003f, 0.21728109f, -0.41183335f, -0.10260659f, -0.00433907f, 0.02561088f, 
    0.17451476f, -0.01258126f, -0.46742055f, -0.05509104f, 0.08189530f, -0.06269753f, -0.01898400f, 0.25891185f, 
    -0.17048992f, 0.04450822f, -0.00146457f, 0.19757514f, -0.19367269f, -0.35278663f, -0.12683077f, 0.04087700f, 
    -0.26732779f, 0.09410774f, -0.26070407f, 0.03590102f, 0.40009013f, 0.22338137f, 0.05906503f, 0.30221358f, 
    -0.28063148f, 0.03017753f, 0.15533736f, -0.15960230f, -0.10155284f, -0.00126556f, -0.44179901f, -0.24925880f, 
    -0.06186675f, -0.20708650f, 0.34593984f, -0.12160629f, 0.15576676f, -0.25471714f, -0.11650597f, 0.18242547f, 
    0.32292241f, 0.00847359f, -0.02657430f, 0.03921825f, 0.01728169f, -0.17438459f, 0.33219004f, 0.27497700f, 
    0.23383504f, 0.00806798f, 0.29085040f, 0.46982154f, 0.12710693f, 0.09620166f, 0.37070450f, -0.32250485f, 
    -0.14186667f, 0.34734669f, 0.02376300f, 0.18391883f, 0.28068519f, -0.02133786f, 0.12510972f, -0.01251332f, 
    -0.07457812f, 0.41915786f, 0.67081100f, 0.01421897f, 0.11917657f, -0.11435582f, 0.05225598f, -0.20758498f, 
    -0.10341547f, 0.32240871f, 0.00053998f, 0.04515128f, 0.18125868f, -0.07729398f, 0.12825623f, 0.49542132f, 
    0.25571021f, -0.07174177f, 0.04897789f, 0.12622331f, -0.02012986f, -0.19422892f, -0.10646045f, -0.20063443f, 
    -0.11452582f, 0.09286756f, -0.12134299f, -0.05752316f, 0.00129746f, 0.00948439f, 0.08853196f, 0.15491809f, 
    0.02528290f, -0.04392749f, 0.06625549f, -0.14118329f, 0.11479017f, 0.03133554f, -0.12071352f, -0.00321554f, 
    -0.11329757f, -0.06963409f, -0.09853657f, 0.08403460f, 0.10549261f, -0.11500873f, -0.00862847f, -0.02686234f, 
    0.07541040f, -0.07500930f, 0.00370545f, 0.03670345f, 0.03802941f, 0.11142465f, -0.00257734f, 0.14853027f, 
    0.00431443f, 0.00015624f, 0.02430418f, 0.09620521f, -0.11109810f, -0.04890539f, -0.11958180f, 0.10675086f, 
    -0.15723118f, -0.04530323f, -0.09281108f, 0.04012931f, -0.10736428f, 0.01633954f, -0.04395422f, 0.00011003f, 
    0.07839339f, -0.09810658f, -0.16687398f, -0.12102181f, 0.12192684f, -0.09782361f, -0.09901199f, 0.10666262f, 
    -0.09932217f, -0.08017331f, 0.06595176f, -0.01632891f, -0.00023410f, 0.08743178f, 0.10145186f, -0.07348243f, 
    -0.09544555f, -0.03239391f, 0.03422107f, 0.01199982f, -0.10428059f, -0.01465295f, -0.01336746f, 0.00620717f, 
    -0.01395616f, -0.01561033f, -0.06072563f, 0.04249854f, -0.05063848f, -0.04901877f, -0.09949644f, -0.03144108f, 
    0.03921181f, -0.06025084f, -0.08266409f, 0.05692865f, -0.03089510f, -0.05589266f, -0.13576920f, 0.02619177f, 
    0.08504799f, -0.05905183f, -0.09425342f, 0.06417415f, -0.00387116f, 0.00224455f, -0.07911998f, 0.07952153f, 
    -0.00486716f, 0.08507456f, -0.11985040f, 0.09169160f, -0.05728628f, 0.05083405f, -0.06880516f, 0.00861280f, 
    0.06198980f, -0.03583391f, -0.03319964f, 0.05707010f, 0.00000952f, -0.10296711f, -0.08341125f, -0.12919536f, 
    -0.08127486f, -0.14353509f, 0.03124619f, -0.02113646f, 0.04132934f, -0.07478912f, 0.07141147f, -0.05456461f, 
    0.00593943f, -0.11535929f, 0.00761929f, -0.07416060f, -0.01352886f, -0.13899364f, 0.09803930f, -0.01397406f, 
    -0.22819057f, 0.06961111f, 0.27810270f, 0.16393931f, -0.19960569f, 0.14484958f, -0.03296385f, 0.40667894f, 
    0.38801730f, 0.04745017f, 0.31410304f, 0.11368296f, -0.11381120f, 0.05558065f, -0.03258988f, -0.04662599f, 
    0.28923178f, 0.31490716f, -0.08778211f, 0.02333530f, 0.08643610f, -0.28413293f, -0.24601187f, 0.14491013f, 
    0.19116127f, -0.02880405f, -0.10123526f, -0.06677786f, -0.13644566f, -0.06852975f, 0.21764894f, -0.37037054f, 
    0.03561663f, 0.15514047f, 0.11794208f, -0.08118282f, 0.48474306f, -0.29322723f, 0.08947399f, -0.07638217f, 
    -0.04404029f, -0.18176487f, -0.32331219f, -0.43483624f, -0.03934990f, 0.00960697f, 0.16129439f, -0.14030613f, 
    0.08473704f, -0.01042811f, 0.01199944f, 0.13367791f, -0.19246452f, -0.46365973f, 0.10604607f, -0.23720409f, 
    0.46923009f, -0.38861266f, 0.26917928f, 0.10971089f, 0.03545730f, -0.24925993f, 0.10470097f, -0.04803424f, 
    0.23537229f, -0.17525461f, -0.36838400f, -0.00978230f, 0.27083397f, 0.05385993f, 0.05057732f, -0.09097920f, 
    -0.23774047f, -0.02609263f, -0.46470824f, 0.23961692f, 0.00328011f, 0.16146082f, -0.07027695f, -0.07318731f, 
    -0.26821652f, -0.28165102f, -0.18408023f, 0.13331443f, 0.16742305f, 0.22525884f, 0.22200756f, -0.05729470f, 
    0.02871406f, 0.14077784f, 0.06562411f, 0.21847206f, 0.19393566f, 0.06878881f, 0.02876371f, 0.25570595f, 
    0.01466490f, 0.15057693f, 0.03897856f, 0.09951441f, 0.01500926f, -0.04703250f, 0.00540890f, 0.00596116f, 
    0.09576233f, 0.16138615f, -0.35634166f, 0.34654975f, 0.11854607f, -0.05688367f, 0.09071238f, -0.01327916f, 
    -0.23290955f, 0.20175403f, 0.13769430f, -0.19371682f, -0.08194698f, 0.33835810f, -0.05986003f, -0.04073790f, 
    -0.14636339f, 0.41316304f, -0.18934271f, 0.39044502f, -0.01095635f, 0.21134754f, -0.09133500f, 0.00743584f, 
    0.35029885f, 0.11848010f, -0.29483691f, 0.29033729f, 0.21947035f, 0.22250831f, 0.42259237f, -0.12082998f, 
    0.19253200f, 0.14443992f, -0.50286299f, -0.02249150f, 0.09156492f, 0.48499805f, -0.09709094f, 0.26898286f, 
    0.08145583f, -0.21125829f, 0.19989669f, -0.25340024f, -0.18147109f, -0.01782267f, -0.09449465f, -0.10212362f, 
    -0.13164762f, 0.05056650f, 0.15141818f, -0.01179754f, -0.27375019f, -0.02887827f, -0.19310407f, 0.41152492f, 
    0.01781370f, -0.04004809f, 0.03084014f, 0.09423979f, -0.45662060f, 0.03243416f, -0.09751888f, -0.03466433f, 
    0.20308000f, -0.04531435f, -0.40216041f, 0.03325295f, 0.02242901f, -0.08433037f, 0.06141920f, 0.12285303f, 
    -0.09872290f, 0.11526120f, 0.33792904f, 0.26216295f, 0.17297329f, -0.17308368f, -0.24511860f, -0.06558523f, 
    -0.30496660f, 0.27870655f, 0.21222508f, 0.03217326f, 0.21197580f, -0.31229651f, -0.07906710f, 0.18757467f, 
    -0.00129266f, -0.03329739f, -0.04213057f, 0.05061982f, 0.25307515f, -0.00528395f, -0.02519304f, -0.22967586f, 
    -0.04930340f, -0.11292464f, -0.24424686f, 0.09237318f, 0.12113692f, 0.08741528f, -0.11501469f, -0.24787712f, 
    -0.14682071f, -0.28700346f, -0.34621248f, -0.01888418f, 0.41796240f, 0.16978686f, -0.09279650f, -0.28243634f, 
    -0.14233780f, 0.05679338f, -0.14688490f, -0.30710566f, 0.20553066f, -0.06265570f, 0.00626452f, 0.53680670f, 
    -0.12607707f, -0.06663138f, 0.05459151f, 0.19535187f, 0.15166238f, -0.22640908f, -0.01208321f, 0.07004131f, 
    0.18629786f, 0.02259158f, -0.43818876f, -0.01233469f, 0.03674543f, -0.06423903f, 0.17548124f, -0.33821294f, 
    -0.18687247f, 0.07549579f, 0.13309886f, -0.20434883f, -0.05334652f, 0.44888183f, 0.01162718f, 0.00076811f, 
    0.14842252f, 0.08660401f, -0.05165473f, 0.40202799f, 0.12946622f, 0.52267396f, 0.11747476f, 0.27187002f, 
    -0.17698544f, 0.15410854f, -0.06493084f, -0.11475372f, -0.02567340f, 0.19269694f, 0.02533612f, -0.02210312f, 
    0.20266603f, 0.01750069f, 0.18311377f, -0.09969692f, -0.03957262f, 0.08688259f, 0.03458001f, 0.31551003f, 
    0.10556431f, -0.06721935f, 0.05089829f, -0.22018695f, -0.24165189f, -0.06877618f, -0.06116877f, 0.39068395f, 
    0.47495425f, 0.11616110f, 0.27539545f, 0.22199966f, -0.10553131f, 0.11469717f, 0.07801148f, -0.07931947f, 
    -0.04264054f, 0.20106757f, 0.02512604f, 0.17064844f, 0.12031943f, -0.09464519f, -0.16827501f, 0.06153247f, 
    -0.16558912f, 0.03853006f, 0.25330475f, 0.01891262f, 0.11057380f, -0.07175648f, 0.14575696f, -0.17738047f, 
    -0.04762647f, 0.15498100f, 0.13576230f, -0.15283236f, 0.01623694f, -0.53137326f, 0.05741917f, 0.22251596f, 
    0.07046674f, -0.11830071f, 0.16582820f, 0.14094350f, -0.16726342f, -0.41174129f, 0.01131770f, -0.20760915f, 
    0.26402137f, 0.09417336f, 0.22859032f, 0.07098192f, -0.04378806f, -0.18740693f, -0.18858790f, 0.00599923f, 
    -0.20041904f, 0.05579381f, 0.20131174f, 0.17043035f, -0.08708704f, 0.11329072f, -0.06607671f, 0.21825708f, 
    0.07824709f, 0.15838091f, 0.19394961f, 0.50785375f, -0.19125243f, 0.25821653f, 0.43073756f, 0.26374462f, 
    0.06808458f, -0.34693974f, -0.19690339f, 0.08224332f, 0.03502198f, -0.05811213f, 0.01432067f, 0.01575353f, 
    0.25115749f, 0.10056385f, 0.08415976f, -0.00130164f, 0.09538492f, 0.37439424f, 0.09962741f, 0.08065276f, 
    0.23841633f, 0.06799996f, 0.44254580f, 0.09341084f, -0.15558018f, 0.09886497f, -0.04541049f, 0.53461564f, 
    0.10556699f, -0.16227181f, 0.12722440f, 0.05817509f, -0.01732177f, 0.03841758f, 0.12882501f, 0.01828587f, 
    -0.04526447f, 0.14721043f, -0.11585630f, -0.31614643f, 0.02618241f, 0.14484325f, 0.06422634f, 0.07792792f, 
    -0.01454273f, -0.06983249f, 0.08327894f, -0.02915518f, -0.11139707f, -0.03786977f, -0.12497719f, -0.10991330f, 
    -0.08214860f, -0.05366985f, 0.02612182f, 0.06113185f, -0.05035348f, -0.07518148f, 0.11735050f, 0.10206319f, 
    -0.00410327f, -0.00823195f, 0.04796058f, -0.01259959f, -0.07872277f, -0.10892212f, 0.04723112f, -0.08844468f, 
    -0.11864415f, 0.10484283f, -0.07411292f, -0.09990725f, 0.01549807f, 0.06334481f, 0.02643031f, -0.05202134f, 
    0.11194499f, 0.10742065f, -0.01458396f, -0.04202786f, -0.03731869f, -0.02547105f, -0.12433942f, -0.03551985f, 
    0.04058890f, -0.11340381f, 0.11083519f, 0.06144372f, 0.04083642f, 0.01912989f, -0.08144966f, -0.08646159f, 
    -0.06965791f, -0.05850513f, -0.06197959f, -0.06078641f, -0.12241745f, 0.09840348f, -0.05885500f, -0.01302049f, 
    0.08189726f, -0.05646358f, -0.00500977f, 0.02194889f, -0.04944693f, -0.09615432f, 0.03507785f, 0.07888776f, 
    0.66198671f, 0.02635747f, -0.21086952f, 0.16915010f, -0.39839593f, 0.13739698f, -0.28601080f, -0.44333586f, 
    0.06081637f, 0.20756286f, -0.15458392f, -0.08650947f, 0.04457458f, 0.09243409f, -0.03798684f, 0.32727683f, 
    0.31551987f, 0.10344139f, 0.22925663f, -0.04110684f, 0.09751396f, -0.21972029f, 0.46342507f, -0.03209240f, 
    0.48605266f, -0.30382740f, 0.19403920f, -0.27240005f, 0.11251576f, 0.10681309f, -0.14079422f, -0.00662643f, 
    0.10908531f, 0.02280563f, -0.00286715f, 0.01508276f, -0.24428977f, -0.11999582f, 0.20839351f, -0.10458422f, 
    -0.01267563f, -0.03163365f, -0.14921071f, -0.42767537f, 0.01647803f, 0.05360755f, 0.02692362f, 0.22843626f, 
    -0.10014856f, -0.12359043f, 0.30534679f, 0.27714530f, 0.07611687f, -0.57100302f, -0.22551179f, 0.64034802f, 
    -0.01422310f, -0.10277304f, 0.01172271f, -0.29281762f, -0.00148743f, -0.06096650f, 0.10888964f, 0.13530575f, 
    0.31201696f, 0.15311688f, -0.03864085f, 0.01677283f, 0.02136605f, 0.16423203f, 0.11711615f, -0.32634366f, 
    0.12610593f, -0.05590555f, -0.06535866f, 0.05850328f, -0.06435683f, 0.07771287f, -0.09290004f, -0.18932411f, 
    -0.09358269f, -0.37592393f, -0.19783838f, 0.13612446f, 0.53042907f, -0.23998505f, 0.17484429f, -0.03934557f, 
    -0.10237907f, -0.03529196f, 0.16588897f, -0.45004243f, 0.36104038f, -0.11588861f, 0.07760815f, 0.50993705f, 
    -0.01126783f, 0.27926821f, 0.11475538f, 0.33340287f, -0.05668132f, -0.43393350f, 0.22243094f, 0.08605437f, 
    0.00770847f, 0.26245633f, -0.42680565f, -0.14571436f, 0.30093953f, 0.02617656f, 0.09406559f, -0.11989265f, 
    -0.25348371f, 0.08870709f, 0.05006186f, -0.15043643f, -0.13836826f, 0.07385135f, -0.04288895f, 0.29132575f, 
    0.17337568f, -0.22778890f, -0.16922075f, 0.37768450f, 0.07671964f, 0.40437239f, -0.10267484f, 0.36137512f, 
    -0.86097807f, 0.12656192f, 0.33630863f, 0.13307902f, 0.08518421f, -0.25486240f, -0.56507546f, 0.22661626f, 
    0.03972697f, -0.03745211f, 0.26694685f, -0.19056560f, 0.01809450f, 0.01535520f, -0.05271697f, -0.00317934f, 
    0.09730872f, 0.09987482f, 0.04870880f, 0.24132743f, -0.33625829f, 0.22172259f, 0.19593808f, 0.07710406f, 
    -0.38037878f, 0.35313520f, -0.05128970f, 0.17726372f, -0.34743765f, -0.00869337f, 0.22145598f, -0.44761047f, 
    0.16933239f, 0.00773170f, -0.04147486f, -0.09347977f, 0.41543284f, 0.20880038f, -0.01306248f, 0.01478532f, 
    0.29937458f, 0.04909224f, 0.14082307f, 0.19841434f, -0.06772355f, -0.08600139f, -0.14025165f, 0.23163754f, 
    0.24937148f, 0.12749118f, 0.11684531f, 0.08073813f, -0.18516737f, -0.02791156f, 0.37618184f, -0.31555572f, 
    0.03088407f, 0.38891578f, -0.06496867f, -0.17523040f, 0.13825160f, 0.11780078f, -0.00852779f, -0.12820239f, 
    0.32534575f, 0.31418326f, -0.48241505f, 0.15165144f, -0.06377681f, 0.23587784f, 0.27292386f, 0.12848261f, 
    0.00127130f, -0.09441575f, -0.33259436f, -0.07979777f, -0.11940277f, 0.01300235f, -0.00086784f, 0.27554968f, 
    0.28690967f, 0.50603759f, -0.25159663f, 0.00699527f, 0.13884038f, -0.30652016f, -0.35350838f, 0.54932034f, 
    0.30997464f, 0.46254310f, 0.07462257f, 0.28069094f, -0.12668495f, 0.02216646f, -0.07849433f, 0.04636294f, 
    -0.31538612f, 0.00002507f, 0.12462902f, 0.03125805f, 0.67091686f, -0.22776350f, -0.38514292f, 0.01324275f, 
    -0.06382780f, -0.15447982f, -0.81289202f, 0.18733984f, -0.24998406f, -0.08701444f, 0.25381935f, -0.29869792f, 
    0.10050476f, 0.03471365f, 0.15317285f, 0.23049161f, -0.09871990f, 0.09931493f, 0.17157349f, 0.48825631f, 
    0.39280933f, -0.05970512f, 0.24765229f, -0.02954706f, 0.13189988f, -0.35909554f, -0.10805073f, -0.23430978f, 
    -0.63870400f, -0.21581285f, -0.17766339f, -0.11880689f, 0.46166056f, 0.06316207f, -0.02485138f, -0.53096503f, 
    -0.03544762f, -0.06589410f, -0.55833763f, -0.11174949f, 0.03312022f, 0.11861055f, -0.08735290f, 0.00802707f, 
    0.04174098f, -0.17853130f, -0.00496252f, 0.02300544f, -0.42239350f, 0.15853824f, 0.05601263f, 0.37352759f, 
    -0.02211554f, 0.23948918f, 0.32248241f, 0.55551594f, -0.24797454f, 0.05081366f, 0.15039191f, -0.05455529f, 
    -0.03113196f, 0.10573103f, -0.10362576f, 0.08381996f, 0.20509622f, -0.00238506f, -0.16499606f, -0.07724486f, 
    0.27481171f, 0.37350702f, 0.66160464f, 0.40030435f, 0.17723265f, 0.01572991f, 0.03750420f, -0.17855287f, 
    -0.16961399f, 0.35700828f, 0.11813404f, 0.22599383f, -0.01662588f, 0.26571658f, 0.14775804f, 0.30082607f, 
    -0.18848662f, 0.46473372f, -0.08075700f, 0.18636639f, 0.11030409f, -0.48940921f, 0.11936505f, -0.42815220f, 
    -0.42216986f, -0.11339819f, 0.24272493f, -0.01068385f, 0.14416696f, -0.21149904f, -0.17657441f, -0.11985945f, 
    -0.10343087f, 0.12834406f, 0.08006819f, 0.05291337f, 0.11389985f, 0.08337153f, 0.03934808f, -0.29034156f, 
    -0.08139811f, -0.05327718f, -0.13335149f, 0.24409384f, -0.15799630f, -0.03104093f, 0.40386423f, -0.49197346f, 
    -0.39330235f, 0.22484758f, -0.14383450f, 0.16357176f, -0.03350383f, -0.10971083f, 0.10287584f, 0.20385581f, 
    0.18417735f, 0.06463741f, -0.10633475f, -0.02666505f, 0.12442649f, -0.12305868f, 0.30586675f, 0.09762250f, 
    0.12343203f, -0.11626481f, -0.30917856f, -0.12084301f, 0.02828714f, 0.07859945f, -0.00565189f, -0.09276246f, 
    -0.00685652f, 0.25894997f, -0.10865220f, 0.19483265f, -0.17040072f, 0.16718364f, 0.40884733f, -0.32947919f, 
    0.02622448f, 0.22424795f, -0.32642078f, 0.05874517f, 0.26269892f, 0.27911606f, 0.04636301f, 0.21315372f, 
    -0.06237194f, 0.04400052f, -0.06109143f, -0.11293678f, -0.11929136f, 0.09056859f, -0.11196995f, -0.03189127f, 
    -0.00848972f, -0.03500337f, -0.06367905f, -0.11089447f, 0.01577340f, -0.03429560f, 0.11045431f, -0.08357538f, 
    -0.10468438f, -0.10162408f, -0.01549892f, -0.09755242f, -0.01331683f, -0.01081999f, 0.06872058f, -0.03649512f, 
    0.01846845f, -0.06904560f, 0.07628664f, 0.06549474f, -0.08715329f, -0.01812989f, -0.00860563f, -0.03072406f, 
    -0.11444005f, 0.09174330f, -0.09876899f, 0.05951978f, -0.14179690f, -0.06392464f, 0.03351501f, -0.06239499f, 
    0.08611573f, 0.07143016f, 0.06657328f, 0.04778842f, -0.04738026f, 0.05268286f, -0.06707136f, -0.10352720f, 
    -0.03501247f, 0.02562243f, 0.06387399f, -0.14483242f, 0.12105817f, -0.01764546f, 0.08815465f, 0.08851944f, 
    -0.06773967f, -0.07157373f, -0.04078989f, -0.08066680f, 0.00977020f, -0.07464793f, 0.00567366f, 0.00245621f, 
    -0.39112785f, 0.13602458f, 0.07571855f, 0.09571865f, -0.54978275f, -0.18483594f, -0.09634784f, 0.87592250f, 
    -0.12759423f, -0.16921426f, 0.20817171f, -0.36682817f, 0.07442954f, -0.32627365f, 0.07836150f, -0.54759020f, 
    -0.15409721f, -0.05501121f, 0.31699052f, 0.07823003f, 0.16057085f, 0.17144680f, -0.33116123f, 0.10017141f, 
    0.19601639f, 0.00885254f, -0.08120553f, 0.03731293f, 0.25847226f, 0.00732401f, -0.01255201f, 0.04228079f, 
    0.12658116f, -0.38627857f, -0.05512369f, -0.09804355f, -1.35782230f, 0.62630326f, 0.08824391f, -0.07285814f, 
    -0.05800209f, -0.27036676f, 0.01037415f, 0.10880862f, -0.06433859f, -0.01051842f, -0.14597784f, -0.28468537f, 
    0.14379987f, -0.07701258f, -0.47662672f, 0.08837438f, 0.04190157f, -0.21002491f, 0.11232383f, -0.20296669f, 
    0.05743411f, -0.04844039f, 0.00865970f, -0.23180276f, -0.02304068f, 0.42466265f, -0.11530168f, 0.35732114f, 
    -0.59725237f, -0.38365078f, -0.08992171f, 0.39922619f, -0.33971664f, -0.13150047f, 0.31150472f, 0.07850868f, 
    -0.10475827f, 0.15295723f, -0.31381953f, -0.03213026f, -0.16718836f, -0.15734272f, -0.08976354f, -0.28044173f, 
    0.33683944f, -0.00192045f, 0.35477534f, -0.45416200f, 0.24134606f, 0.04399617f, 0.20543952f, 0.14185202f, 
    0.18331090f, -0.04550727f, -0.09369414f, 0.27465951f, 0.03104115f, 0.05590416f, 0.09068547f, -0.50237972f, 
    0.09684310f, -0.10841957f, -0.01708987f, -0.20752360f, -0.86431199f, 0.28512412f, 0.26905999f, -0.11382823f, 
    0.13651380f, 0.37320966f, -0.06202092f, 0.03618115f, 0.20344751f, -0.14410076f, -0.17929292f, -0.03579144f, 
    0.28271630f, -0.14452124f, 0.05033146f, 0.27934220f, -0.30165175f, 0.11152398f, -0.29467225f, 0.03427968f, 
    0.01237067f, 0.10504840f, -0.03193695f, 0.11623830f, 0.13020438f, 0.19137374f, 0.10091954f, 0.18810196f, 
    -0.36525977f, 0.05183257f, 0.17342061f, 0.07959129f, 0.38477829f, -0.20644999f, -0.07307613f, 0.01702870f, 
    -0.13726297f, -0.07735348f, 0.08732589f, -0.03988007f, 0.06033584f, 0.05188151f, 0.02312404f, -0.07943700f, 
    -0.10251100f, -0.15729642f, -0.05371619f, 0.26097789f, -0.03034016f, 0.28912470f, 0.14563857f, -0.10779786f, 
    -0.38923204f, -0.03066067f, -0.13760814f, 0.23918603f, -0.15478420f, 0.02102152f, 0.01870066f, 0.07723202f, 
    0.19138813f, 0.06923044f, 0.07922089f, -0.01300357f, 0.32563922f, 0.01497257f, 0.17756708f, -0.05781656f, 
    0.23458219f, 0.06863607f, 0.55321532f, 0.13658912f, 0.02929283f, 0.05347984f, 0.10311100f, 0.01267453f, 
    -0.06635650f, 0.20586909f, -0.03946986f, -0.01038944f, -0.04222259f, 0.75873601f, 0.12731297f, -0.21137416f, 
    -0.10580110f, 0.44169146f, -0.34641230f, 0.15419026f, 0.22186454f, 0.33687559f, -0.02931435f, 0.04224983f, 
    0.05289734f, -0.16168334f, -0.17416012f, 0.05832845f, 0.31605226f, 0.06392904f, 0.10307951f, 0.18217604f, 
    0.14011174f, 0.19809626f, -0.20964856f, 0.09332909f, -0.03965028f, 0.17545423f, 0.05328180f, 0.00902585f, 
    -0.25737911f, -0.24227218f, 0.11529553f, -0.31118721f, 0.09052560f, 0.02703903f, 0.12451836f, 0.13038149f, 
    -0.11296923f, -0.11003646f, -0.07117097f, -0.00228212f, -0.01366490f, -0.09939054f, -0.17428549f, 0.56534833f, 
    0.34513456f, -0.00101462f, 0.03576571f, -0.03912124f, -0.25294584f, 0.21732621f, 0.23853825f, -0.05164674f, 
    0.09570709f, -0.14730662f, -0.57065570f, 0.22272994f, -0.05871139f, 0.04455516f, -0.02311881f, 0.23810689f, 
    0.00383560f, -0.04597537f, 0.14001985f, 0.16763976f, -0.01125966f, 0.05422072f, -0.24584697f, -0.36268005f, 
    -0.30485031f, 0.29137468f, -0.04549432f, 0.11244116f, 0.06221977f, 0.03949314f, -0.00538534f, 0.26304096f, 
    -0.07362387f, 0.04575188f, -0.00092168f, -0.11910681f, -0.17828232f, -0.07235187f, -0.10596991f, -0.01137508f, 
    -0.14047068f, 0.09090083f, 0.04596276f, 0.08494566f, 0.07352275f, 0.07856805f, 0.07137816f, -0.14446825f, 
    -0.08360205f, 0.04785470f, -0.13244568f, 0.06334560f, -0.07823579f, -0.10698298f, 0.01004527f, -0.07388425f, 
    0.05566906f, 0.00788954f, 0.03918558f, -0.10291246f, 0.00548203f, 0.00897564f, 0.06721125f, -0.03630702f, 
    -0.15259600f, 0.06349313f, -0.05614971f, -0.18861766f, -0.03484012f, -0.08643957f, -0.12450356f, -0.03684197f, 
    -0.06491407f, 0.05533407f, -0.09936161f, 0.08232311f, -0.01902225f, 0.10482918f, 0.02828520f, 0.00174571f, 
    -0.10776997f, -0.05407526f, -0.11862589f, 0.11003681f, 0.01696712f, -0.06066270f, -0.06853162f, -0.07062057f, 
    -0.01071815f, -0.01291883f, 0.05611342f, -0.07371422f, -0.13407195f, 0.04147303f, -0.08864935f, -0.05420088f, 
    0.19551314f, 0.24260850f, 0.00756826f, 0.10278039f, -0.46825668f, 0.12746441f, -0.01993927f, 0.10718021f, 
    0.08397368f, 0.27425689f, 0.43657792f, -0.18396929f, 0.04189327f, 0.03828412f, -0.03710359f, 0.32889906f, 
    0.39869580f, 0.56539917f, 0.01841256f, 0.19702165f, 0.17026924f, -0.16677557f, 0.25998619f, 0.05651174f, 
    0.34747586f, -0.28319153f, -0.01061398f, -0.00703838f, -0.02142500f, -0.01129974f, -0.24140668f, -0.19673516f, 
    -0.06253094f, -0.09782336f, -0.04240622f, -0.01043541f, -0.23372456f, 0.15297231f, -0.00947558f, 0.02068015f, 
    -0.09300750f, -0.42760387f, 0.37777644f, -0.34241712f, -0.29856569f, 0.06038378f, 0.10904759f, 0.35529241f, 
    0.23675838f, -0.12817918f, 0.25998321f, 0.29915962f, -0.13065761f, -0.19511117f, 0.18372357f, 0.27615011f, 
    0.10881204f, -0.29549274f, 0.31725356f, -0.39549151f, 0.18180633f, 0.03545906f, 0.03591505f, 0.10016830f, 
    0.32928488f, 0.10605761f, 0.40741584f, 0.08304148f, -0.19454519f, -0.17074724f, -0.64239436f, -0.49874210f, 
    0.10723013f, 0.12372653f, 0.57054257f, 0.06823958f, 0.10382526f, -0.07466906f, 0.02792388f, 0.05001605f, 
    0.09590918f, 0.05520562f, 0.11664628f, 0.25464600f, 0.15293214f, -0.09208039f, 0.28944167f, -0.23739623f, 
    -0.20908432f, -0.07680666f, -0.19978255f, -0.65817750f, 0.33278728f, 0.10188267f, 0.28228614f, 0.34777951f, 
    0.25855130f, 0.27584615f, 0.06893976f, 0.27611303f, -0.09446592f, -0.21815713f, 0.19468756f, 0.02553354f, 
    -0.28814521f, -0.14602284f, -0.93033695f, -0.58575231f, 0.11883876f, -0.05173782f, -0.17190941f, 0.32350755f, 
    -0.28409177f, 0.00680996f, -0.16767460f, 0.06215508f, -0.17418736f, -0.64529079f, 0.16933587f, 0.08609241f, 
    0.16092436f, -0.28839621f, 0.15088975f, -0.06146570f, 0.09018124f, 0.26983687f, 0.08938755f, 0.27196383f, 
    -0.45153499f, -0.24796626f, 0.67019641f, -0.42135483f, 0.29385149f, -0.25824323f, 0.04414979f, 0.13694766f, 
    -0.08683191f, 0.01682189f, 0.63563561f, 0.36751309f, 0.01530864f, -0.37978467f, -0.00600807f, -0.58303785f, 
    -0.33639544f, -0.07682565f, -0.31651703f, -0.27570570f, -0.00915604f, 0.20799854f, -0.30716100f, -0.29836407f, 
    -0.09895352f, -0.09390438f, -0.19675806f, -0.09013889f, 0.03292254f, 0.07672112f, 0.16477939f, 0.00297370f, 
    0.21064068f, 0.04353695f, -0.01787513f, -0.31542990f, 0.43860999f, 0.16220812f, 0.25037694f, 0.11167751f, 
    0.15925162f, 0.23221537f, 0.33583805f, 0.23705432f, 0.32519823f, 0.06705724f, 0.03124233f, 0.29953462f, 
    0.34577233f, -0.09582243f, -0.29568425f, -0.05636769f, 0.14740898f, 0.57971728f, 0.14738257f, -0.91856843f, 
    -0.00900309f, -0.07083435f, -0.13412471f, 0.21847053f, -0.30275342f, 0.03457011f, -0.11394835f, -0.20542507f, 
    -0.19682607f, -0.32613748f, -0.04021524f, -0.07286456f, 0.06584787f, -0.33251172f, 0.03235653f, 0.08622509f, 
    -0.17886561f, -0.00998824f, -0.21428275f, -0.00005588f, 0.04148708f, -0.27928892f, -0.05235584f, -0.13387659f, 
    0.15391287f, -0.21933046f, 0.01027238f, 0.16552985f, -0.08625265f, 0.10614554f, 0.49500930f, 0.00767404f, 
    -0.27864382f, -0.04783786f, -0.33195171f, 0.18643498f, -0.03231939f, -0.08503366f, 0.25552723f, -0.36752498f, 
    0.24568045f, 0.01505326f, 0.06813651f, 0.12301424f, 0.45272037f, 0.06512147f, 0.31099576f, 0.04735700f, 
    0.20564002f, 0.28638810f, 0.71992779f, -0.01251478f, 0.07678389f, 0.04013584f, -0.12518509f, -0.16505012f, 
    -0.12740234f, 0.12673271f, -0.06288558f, 0.17290613f, -0.05148564f, 0.51122743f, 0.05045844f, -0.13106096f, 
    -0.10682444f, 0.34992841f, 0.11086202f, 0.15291269f, -0.01841483f, 0.14182611f, -0.01293765f, -0.03556295f, 
    -0.08789257f, 0.07982951f, 0.06698555f, 0.00401569f, 0.34676939f, 0.26743022f, 0.11427980f, -0.55444473f, 
    0.12990981f, -0.13373798f, 0.12143830f, 0.19074138f, 0.11094569f, 0.33436033f, -0.06748199f, -0.10718209f, 
    -0.00850619f, -0.41144058f, 0.05199536f, 0.27007145f, 0.11962209f, 0.01244360f, 0.17262957f, -0.32631734f, 
    -0.35041076f, 0.21072774f, 0.24479420f, -0.18541473f, -0.06835204f, 0.08193015f, 0.56911629f, 0.38697478f, 
    0.00051741f, 0.27160737f, 0.02794915f, 0.39771524f, -0.01774004f, -0.38514319f, -0.01826113f, 0.08155787f, 
    0.02941067f, -0.00158486f, -0.46204898f, -0.03744266f, 0.28424492f, -0.11786459f, -0.01369214f, -0.04222048f, 
    -0.20484571f, 0.23828331f, 0.09019684f, -0.16332357f, -0.05508816f, -0.53683555f, 0.07163391f, 0.21491621f, 
    0.20805228f, 0.00407406f, -0.07420272f, 0.38268301f, 0.07995347f, 0.19848900f, -0.05036333f, 0.06737760f, 
    -0.58804435f, -0.01448615f, 0.38153353f, -0.27021340f, 0.36049682f, -0.10253977f, -0.28601360f, 0.23116018f, 
    -0.11914229f, 0.11146975f, 0.48173958f, 0.23743227f, -0.04250653f, 0.15300959f, 0.06380190f, 0.28306827f, 
    -0.16087091f, 0.05897114f, 0.04863284f, 0.32285839f, -0.31729409f, 0.13795516f, 0.18238278f, 0.16943701f, 
    -0.28873727f, 0.05001119f, -0.07179467f, 0.27186835f, -0.05825416f, 0.08989944f, 0.17271611f, 0.05890410f, 
    0.23195316f, 0.30185553f, 0.06014568f, 0.15505844f, 0.46206760f, 0.20621055f, -0.09480365f, 0.03887556f, 
    0.14145331f, 0.07707207f, 0.63229889f, 0.22438022f, 0.11744697f, -0.04384683f, -0.02236103f, 0.37174827f, 
    0.01204585f, 0.14310998f, 0.07916164f, 0.02215010f, 0.04502168f, 0.25772130f, 0.37569726f, -0.23974946f, 
    -0.15008570f, 0.25458607f, -0.14349945f, -0.11690482f, -0.03842228f, -0.08670496f, 0.00243074f, -0.20823464f, 
    0.09847410f, 0.00940048f, 0.00326234f, -0.03910063f, -0.00344013f, 0.03181571f, -0.04436426f, 0.04086585f, 
    -0.10246512f, 0.01713650f, -0.10397461f, 0.05786480f, -0.07083309f, 0.06464998f, -0.12384817f, -0.00370103f, 
    -0.03648929f, -0.05083608f, 0.03962428f, 0.00342715f, 0.11246943f, 0.02093314f, 0.04380676f, -0.10604765f, 
    -0.08884902f, -0.06499343f, -0.08916393f, -0.07365829f, -0.11349514f, -0.02622922f, 0.10916035f, -0.00304441f, 
    -0.08168826f, -0.08827774f, 0.00962853f, -0.09699467f, 0.03677899f, -0.10426406f, -0.00886139f, 0.06951158f, 
    -0.09012599f, 0.06788589f, 0.06347997f, -0.00603686f, -0.04218125f, 0.10485284f, -0.07957140f, 0.04061879f, 
    -0.00999118f, 0.10051607f, -0.07218192f, 0.09668399f, 0.00342570f, -0.04622418f, -0.02477610f, 0.05074601f, 
    0.00255109f, -0.07593723f, 0.05877590f, 0.04032563f, -0.03577121f, -0.05026163f, 0.01758324f, -0.05412406f, 
    -0.97832608f, -0.33312809f, -0.18356569f, -0.12503898f, 0.34252828f, 0.00063587f, -0.53535932f, 0.33570850f, 
    -0.07631253f, 0.19580105f, -0.21704695f, 0.34184489f, 0.12822379f, 0.13711263f, -0.12350906f, -0.39044416f, 
    -0.28160948f, -0.18932195f, -0.21902779f, -0.17370899f, -0.02398959f, 0.00492879f, -0.08289786f, -0.13061205f, 
    -0.14414364f, 0.38279498f, -0.24507134f, 0.16228218f, -0.33917975f, -0.10692219f, 0.27256769f, 0.01738213f, 
    0.01983370f, -0.04343105f, 0.04905061f, -0.22370337f, 0.34081909f, -0.18626799f, 0.09935748f, 0.05870502f, 
    0.19617870f, -0.03569700f, -0.34333879f, 0.28671694f, 0.18887882f, -0.15501624f, 0.14391060f, -0.21808971f, 
    0.34868658f, 0.09326647f, 0.09303100f, -0.04810950f, 0.01314675f, -0.10361748f, -0.01991318f, -0.26038426f, 
    0.05435139f, 0.01568842f, -0.15670805f, 0.22414117f, 0.14120655f, 0.06920481f, 0.03933047f, 0.19326182f, 
    0.53920591f, -0.06474778f, 0.02993186f, 0.02680557f, 0.01200595f, 0.01455647f, -0.24800156f, -0.32780036f, 
    -0.27732253f, -0.06656080f, -0.04184561f, -0.03604191f, 0.05373910f, 0.02350055f, -0.01856673f, 0.17731403f, 
    0.09164821f, 0.01883486f, -0.11245931f, 0.08321098f, 0.36835724f, 0.28368121f, 0.12559602f, 0.16348706f, 
    0.22494557f, -0.09501193f, 0.09728789f, 0.03016007f, 0.42247513f, 0.06631620f, 0.01962938f, 0.09876810f, 
    -0.09642358f, 0.07172028f, -0.05988349f, 0.12962601f, 0.04729808f, 0.23119918f, -0.06403387f, -0.06695357f, 
    0.07959947f, 0.23835093f, 0.29699627f, 0.21290185f, -0.11950934f, 0.08637445f, 0.09130727f, 0.01449407f, 
    -0.13739850f, -0.01835655f, 0.03613080f, 0.03855586f, 0.03814552f, 0.73508590f, -0.02070440f, 0.25217232f, 
    0.06597114f, 0.06239955f, -0.03131295f, 0.11301866f, 0.13887507f, 0.53901207f, 0.11187458f, -0.00391629f, 
    -0.27682105f, 0.15126768f, 0.04572911f, 0.09600188f, 0.02816287f, -0.21999329f, 0.14337097f, 0.43360719f, 
    0.08646051f, 0.06541710f, -0.08579177f, 0.22794344f, 0.11331546f, 0.37107053f, -0.00161976f, 0.01015622f, 
    -0.06424662f, 0.35022399f, 0.28020763f, -0.03414946f, -0.61570227f, 0.28504583f, -0.13691850f, 0.23828092f, 
    -0.41582483f, 0.27430743f, -0.10817249f, 0.17172097f, -0.52773875f, -0.01862372f, 0.08431095f, -0.31912881f, 
    0.29242790f, -0.25362250f, 0.04503788f, -0.23122343f, -0.09089866f, 0.28534350f, -0.07371835f, -0.01501413f, 
    0.29219759f, -0.13500735f, -0.38686436f, 0.09729514f, -0.20289727f, -0.02016669f, -0.03259440f, 0.36662930f, 
    0.22922152f, 0.11682971f, 0.09743593f, 0.24733977f, -0.20316781f, -0.14578140f, 0.25725687f, -0.77669805f, 
    -0.37949738f, 0.34905726f, 0.12762846f, -0.28123540f, 0.33797485f, -0.12038594f, 0.10122417f, -0.07702970f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.22068633f, 0.20235865f, 0.05406795f, -0.31305218f, -0.17954727f, -0.00915001f, -0.06429144f, 0.04543449f, 
    0.44676957f, 0.02681881f, -0.21197850f, -0.03799305f, 0.24466829f, 0.19405226f, 0.33371955f, 0.01974263f, 
    0.27622280f, 0.32602158f, -0.32528672f, 0.25662655f, 0.18900630f, -0.11855995f, 0.11911836f, -0.29344895f, 
    0.31159335f, -0.00586928f, -0.08435928f, -0.06063149f, 0.02342669f, 0.18070780f, -0.07978561f, 0.34285739f, 
    0.09402402f, 0.00405480f, -0.07052292f, -0.12365048f, 0.16032167f, 0.07927975f, 0.14642306f, -0.11907192f, 
    0.09215726f, -0.06905486f, 0.18930788f, 0.17479068f, 0.11963361f, 0.44750968f, 0.28171924f, 0.27060226f, 
    -0.11549775f, -0.43489614f, 0.25542352f, 0.15494242f, 0.09894546f, -0.02541955f, 0.04199044f, -0.23294067f, 
    -0.12116251f, 0.26447412f, -0.01485237f, -0.06018682f, -0.08843110f, -0.02289893f, 0.13841400f, 0.24470654f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    0.04736714f, 0.20316151f, -0.62575662f, -0.34350216f, -0.49107486f, -0.03957651f, 0.08211648f, -0.57487273f, 
    0.14906968f, -0.28699002f, -0.35785437f, 0.06398271f, 0.03264562f, -0.18052691f, 0.04976309f, 0.18832079f, 
    -0.27158421f, -0.25496447f, 0.13622583f, -0.23368266f, 0.06424245f, -0.01340302f, -0.07122111f, 0.12007418f, 
    -0.15935428f, -0.04612253f, -0.04856970f, 0.11022981f, -0.03102383f, -0.48512670f, 0.08880300f, -0.21995872f, 
    0.35328263f, -0.09909573f, 0.10444193f, -0.19315939f, 0.11511250f, -0.44868192f, -0.32949355f, 0.10249318f, 
    0.21197723f, 0.10012826f, -0.16660799f, -0.17266633f, 0.17949007f, -0.06559660f, 0.33470860f, 0.06470105f, 
    0.00237443f, 0.02457327f, -0.13070758f, 0.16364241f, -0.12045965f, 0.07017697f, 0.03135401f, -0.02953829f, 
    -0.51195621f, 0.31125841f, -0.00032919f, 0.27598262f, -0.08101545f, -0.14033781f, 0.12534691f, 0.08817460f, 
    0.02666172f, 0.20204146f, -0.21220988f, 0.02499261f, 0.11187355f, 0.14715049f, -0.02933035f, -0.38962930f, 
    0.20038106f, 0.22653763f, -0.05150459f, 0.13460273f, 0.19785769f, 0.32646403f, 0.07160233f, -0.02515032f, 
    -0.55731839f, 0.10119956f, 0.12958643f, -0.14129853f, -0.59109569f, 0.06489726f, 0.06352673f, -0.07110060f, 
    -0.24892488f, 0.09438816f, -0.06987045f, 0.09420132f, 0.31662965f, 0.01476982f, 0.11827943f, 0.03560503f, 
    0.21737307f, -0.07048234f, -0.02883294f, 0.07592676f, -0.12796938f, -0.09447303f, -0.30790168f, 0.14697529f, 
    0.01295193f, -0.09158152f, 0.24825042f, -0.01713898f, -0.12089355f, -0.04324454f, -0.40615058f, -0.12908697f, 
    -0.07189012f, -0.25800106f, -0.12530755f, -0.23685209f, -0.53317750f, 0.02321641f, 0.32555673f, 0.19097604f, 
    0.65537035f, -0.54501092f, 0.03812813f, -0.14462993f, -0.05574381f, -0.24959782f, 0.05449481f, -0.35771477f, 
    0.14795697f, -0.19586919f, 0.29756942f, 0.15578681f, 0.25954437f, 0.06967833f, -1.30460262f, -0.55301994f, 
    -0.03593180f, -0.49649233f, 0.04417034f, 0.00007335f, -0.01214555f, -0.62274969f, -0.13167396f, 0.11175027f, 
    0.25522557f, 0.15801941f, -0.12023617f, 0.13866553f, 0.21870835f, -0.10085487f, 0.21867479f, -0.71170151f, 
    -0.31981945f, -0.01417922f, 0.14181970f, 0.10822961f, -0.57848823f, 0.08201405f, 0.03862872f, -0.12594366f, 
    -0.06217907f, 0.05578060f, 0.05687985f, 0.23434071f, -0.39138266f, 0.03654321f, -0.50361609f, 0.13234857f, 
    -0.06618938f, -0.06167395f, -0.20391546f, -0.43060139f, 0.23842953f, 0.12959918f, 0.11743242f, -0.02745222f, 
    -0.00968981f, -0.06203013f, -0.60022080f, -0.12568216f, -0.49414968f, -0.06779670f, 0.17396809f, -0.04649496f, 
    -0.16123931f, 0.03179393f, 0.02236164f, 0.01117965f, 0.10799163f, 0.23915100f, -0.51254231f, 0.43626219f, 
    -0.73632711f, -0.18735352f, -0.23513702f, 0.16884731f, 0.02367393f, -0.40534946f, 0.16217676f, -0.22549704f, 
    -0.24257933f, 0.22125117f, 0.13963965f, -0.76130277f, -0.28566444f, 0.20883454f, -0.82216650f, 0.11272406f, 
    0.43277583f, -0.05151160f, -0.07811870f, 0.04723821f, 0.38370204f, -0.11189201f, 0.05714366f, 0.00825365f, 
    0.11296500f, 0.04668142f, -0.53625733f, 0.08258502f, 0.22343235f, -0.65632480f, -0.58691508f, -0.00080892f, 
    -0.25449270f, 0.00739971f, 0.07461100f, -0.13268368f, 0.10842978f, -0.03978914f, -0.11752418f, 0.10328723f, 
    0.11088400f, -0.00742763f, -0.49078760f, -0.33540487f, 0.10377681f, -0.91933173f, 0.00962054f, 0.11298221f, 
    -0.02147344f, 0.48998517f, -0.03439512f, 0.04235623f, 0.25331789f, 0.08920725f, 0.00216007f, -0.16358337f, 
    0.03568378f, 0.05693620f, -0.00194360f, 0.14455812f, -0.07364953f, 0.33316308f, -0.18837009f, 0.20080829f, 
    -0.13226312f, 0.10451316f, -0.12328563f, -0.30859268f, 0.01905156f, 0.02704103f, -0.22101367f, 0.37485468f, 
    0.16367638f, 0.07255873f, -0.40202421f, -0.52470815f, 0.09335352f, 0.35442373f, 0.12712315f, 0.13819283f, 
    0.25913775f, 0.06194566f, -0.16115111f, 0.08795382f, -0.67083478f, 0.06163701f, -0.04846648f, -0.42876917f, 
    -0.05390177f, 0.06690299f, 0.12807225f, -0.03592928f, -0.49146217f, -0.07055356f, -0.21632083f, -0.21250576f, 
    0.03526682f, -0.15867543f, -0.01795636f, -0.01008098f, 0.23323147f, -0.30971804f, 0.31240448f, -0.18758002f, 
    -0.27783847f, 0.11215091f, -0.90211678f, 0.09479947f, 0.06699695f, 0.14833695f, 0.27420884f, 0.20870484f, 
    -0.10568684f, 0.28225586f, 0.09456895f, 0.17016563f, 0.00853105f, -0.06873810f, 0.11817217f, -0.38810816f, 
    -0.28158915f, 0.19399600f, 0.02104043f, -0.10328719f, 0.08836383f, 0.30982542f, 0.16459295f, -0.31958550f, 
    0.22109999f, 0.18580201f, 0.53885335f, -0.47463831f, -0.20959181f, -0.20605497f, 0.11100579f, 0.04372563f, 
    -0.12519585f, 0.12737085f, 0.13742107f, -0.29004633f, -0.02466080f, 0.20160834f, 0.11163877f, -0.07390447f, 
    -0.39603972f, -0.05614530f, -0.42340976f, -0.17002743f, -0.10904906f, 0.04397959f, -0.25594190f, 0.03753267f, 
    0.13225923f, 0.02154205f, -0.04717571f, -0.03330346f, 0.27578920f, 0.07939205f, 0.21268831f, 0.20432566f, 
    -0.11591235f, -0.06400122f, -0.08060721f, -0.03087365f, 0.04945941f, -0.16965675f, 0.19939536f, -0.24285923f, 
    0.05706152f, -0.08032195f, 0.20544462f, 0.25943702f, -0.25659758f, 0.11704312f, -0.68729484f, 0.02396115f, 
    -0.11188315f, -0.86747563f, -0.04003908f, 0.00409422f, -0.09158953f, -0.08403502f, 0.01178115f, 0.32719627f, 
    0.08568379f, -0.08667269f, 0.14344756f, -0.16109000f, -0.06467281f, -0.42308879f, 0.19625635f, -0.08786396f, 
    0.06746154f, 0.13668175f, -0.12723574f, 0.00127516f, 0.07768492f, -0.01113853f, -0.41213134f, 0.13793018f, 
    -0.28747234f, 0.00192657f, -0.54224813f, 0.16106102f, -0.03816399f, -1.14208543f, 0.07508321f, -0.12110421f, 
    0.29492167f, 0.26164871f, 0.15859722f, 0.19635922f, -0.31628665f, 0.04579062f, -0.15246074f, -0.26172173f, 
    0.30342838f, -0.08005647f, -0.03579412f, 0.05812877f, -0.17343974f, 0.23480935f, 0.29442704f, 0.29022709f, 
    -0.13308561f, -0.03608777f, -0.17885531f, -0.01184957f, 0.11357615f, 0.11581324f, 0.12676853f, 0.03391504f, 
    -0.29038337f, -0.03136294f, -0.21186493f, 0.17284355f, -0.15538083f, -0.67656553f, -0.02073957f, 0.26450378f, 
    0.06290433f, -0.31502327f, -0.56658673f, 0.12620406f, 0.21585065f, -0.08345973f, -0.44296083f, 0.31188783f, 
    -1.12032855f, 0.07638549f, 0.26965261f, 0.02766867f, -0.00942769f, -0.06911062f, -0.13906744f, -0.24659185f, 
    -0.44322026f, -0.13972165f, -0.38911799f, 0.23024762f, -0.10495310f, -0.39418104f, 0.15937211f, -0.07509641f, 
    -0.60199130f, -0.02940487f, 0.20398551f, 0.16758479f, -0.34617376f, 0.21763286f, -0.21255364f, 0.14884897f, 
    -0.57658678f, -0.79919875f, 0.37728155f, -0.84034002f, -0.07175776f, 0.07146949f, -0.51377052f, 0.31874791f, 
    -0.67593628f, 0.06831393f, 0.21380554f, -0.07740048f, -0.06039141f, -0.20399366f, -0.18583339f, -0.71652740f, 
    -0.12486021f, 0.00135263f, -0.00832682f, 0.35119370f, 0.00967017f, -0.74821585f, 0.03844391f, 0.01640348f, 
    0.07009105f, 0.08721997f, 0.12558623f, -0.10350730f, 0.03849882f, 0.06045885f, 0.15384856f, -0.09946021f, 
    0.03284378f, 0.28506809f, -0.14436769f, 0.14855230f, 0.02959386f, -0.07115047f, 0.00782756f, 0.12012678f, 
    0.42898750f, 0.05721388f, -0.15053450f, 0.24220671f, 0.04597864f, 0.19022390f, 0.05726044f, -0.40082994f, 
    -0.06895184f, -0.10616481f, -0.18194301f, -0.07488003f, 0.19910040f, 0.18738069f, 0.18371820f, 0.74859285f, 
    0.12692404f, 0.19310944f, 0.00992401f, 0.23636717f, 0.22640595f, -0.12973037f, 0.15146743f, -0.68856192f, 
    -0.17799935f, 0.07613836f, -0.39675358f, -0.35120186f, 0.36981809f, -0.01506701f, 0.04626826f, 0.27332506f, 
    -0.33839241f, -0.02109376f, 0.02071059f, -0.03530457f, 0.21673831f, 0.24327978f, -0.11852496f, -0.17296481f, 
    -0.23157388f, -0.03680581f, -0.03391384f, 0.14509857f, -0.68166190f, 0.09687548f, -0.63306665f, 0.12515882f, 
    -0.09053340f, -0.00117870f, 0.36770704f, -0.23326162f, -0.74619293f, 0.30683649f, -0.46372703f, -0.75841153f, 
    0.04482195f, 0.10728677f, 0.08640063f, -0.68684578f, -0.14432263f, -0.06356492f, 0.29969174f, -0.33962682f, 
    -0.16096626f, -0.09720057f, -0.47909966f, -0.55028182f, 0.07340708f, -0.53768539f, -0.10027340f, -0.15883768f, 
    -0.03327661f, 0.07992581f, 0.15567076f, -0.47127593f, -0.57935166f, 0.29904759f, 0.08061538f, 0.29968405f, 
    -0.03415640f, -1.01722753f, -0.60309386f, 0.07013720f, 0.27005503f, -0.04327280f, 0.30076611f, 0.07648447f, 
    0.16287398f, -0.10266210f, -0.24025114f, -0.37204915f, -0.08972622f, 0.03296758f, 0.11917775f, 0.40384391f, 
    -0.10325696f, 0.05124793f, 0.24221304f, 0.06954131f, 0.21409829f, 0.09853873f, 0.17978027f, -0.03304146f, 
    0.05154498f, -0.06031466f, -0.10893658f, -0.11456324f, 0.14191969f, 0.17159963f, 0.02156865f, 0.19466966f, 
    -0.50836456f, 0.08728606f, 0.12535985f, 0.13834286f, -0.36033198f, 0.32214898f, 0.26714975f, -0.26937598f, 
    -0.00704942f, -1.00398779f, 0.46171060f, -0.16930082f, 0.01942134f, -0.09659033f, -0.51797301f, -0.32656997f, 
    -0.15769868f, -0.10624821f, 0.16022053f, -0.32297876f, -0.00161045f, -0.21050787f, -0.05136319f, -0.73087454f, 
    -0.22225310f, -0.78599161f, -0.30042410f, 0.24103013f, 0.10773803f, -0.42428914f, 0.06799348f, -0.33569974f, 
    0.10356470f, 0.32082468f, 0.06923790f, 0.04625065f, -0.05234518f, 0.12343973f, -0.24839874f, -0.24049014f, 
    -0.34716156f, 0.26673746f, -0.29937202f, 0.20999190f, 0.06356599f, -0.12186325f, -0.11149596f, -0.22910824f, 
    0.09842772f, -0.10622516f, -0.46198511f, 0.11470664f, 0.15027732f, 0.16692702f, -0.28343257f, 0.06309447f, 
    -0.39127645f, -0.11837639f, 0.05452177f, -0.00631674f, -0.05451938f, 0.14268114f, -0.21194224f, -0.41933939f, 
    0.24910161f, 0.06508598f, 0.30738473f, -0.68122107f, 0.09333696f, -0.58143610f, -0.10050915f, 0.13237774f, 
    -0.05090015f, -0.60173440f, 0.34707972f, 0.11195032f, 0.12218037f, 0.10160313f, 0.27353096f, -0.20478798f, 
    0.10156152f, 0.27941519f, -0.67508709f, -0.04138809f, -0.07518881f, -0.22083260f, -0.11501122f, 0.37805131f, 
    0.09915638f, -0.48097917f, 0.45826566f, -0.23755540f, 0.05206013f, 0.12223101f, -0.15560809f, 0.02792987f, 
    0.01162829f, -0.08759078f, 0.29193452f, 0.23890175f, -0.21770819f, -0.48467958f, -0.05239118f, -0.04356501f, 
    0.06318802f, 0.05079466f, 0.27620742f, 0.26749134f, 0.37459624f, -0.02932849f, 0.00718858f, -0.18114360f, 
    -0.03242687f, -0.05608273f, -0.45095354f, -0.13005172f, -0.42567706f, -0.13095436f, 0.11353176f, 0.10803882f, 
    -0.64864641f, -0.12691198f, -0.10000330f, -0.95675713f, 0.12248308f, 0.23267023f, 0.05389922f, -0.15283965f, 
    0.13374665f, 0.11848536f, -0.34273481f, -0.19641738f, 0.05976831f, -0.14446107f, 0.20346367f, -0.16133472f, 
    0.09115747f, 0.52704126f, -0.38993126f, 0.05140210f, 0.27176124f, 0.04626862f, -0.13570665f, -0.54308575f, 
    -0.59391832f, -0.14738607f, -0.06246566f, 0.11690934f, 0.08183470f, -0.10087992f, 0.13181068f, 0.31390941f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    0.08153298f, -0.05419196f, -0.07666139f, -0.02970648f, 0.28118876f, 0.27704081f, -0.09980360f, -0.42802155f, 
    -0.22272395f, 0.07534558f, 0.14010748f, -0.11137205f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
