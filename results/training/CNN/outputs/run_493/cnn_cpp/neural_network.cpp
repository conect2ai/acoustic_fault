#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.28661901f, 0.27046248f, -0.66620004f, -0.09082203f, -0.29887626f, 0.06333687f, 0.79610413f, 0.99170172f, 
    0.33233455f, -0.11969943f, 0.11574898f, -0.04040782f, -0.20197785f, 0.08707795f, -0.48516473f, -0.47845224f, 
    0.03230307f, -0.10163842f, 0.28674883f, -0.26613674f, 0.17138904f, 0.03035639f, 0.06676564f, -0.20799509f, 
    0.26303682f, -0.42686874f, 0.19080314f, 0.66591156f, 0.92626101f, -0.30340376f, 0.50561768f, -0.28534412f, 
    -0.50891960f, 0.08167936f, -0.04977013f, 0.09131797f, 0.19796222f, 0.26773912f, -0.17448823f, 0.31977823f, 
    -0.31530774f, 0.13455406f, 0.48204547f, -0.30415076f, 0.10859328f, 0.14718039f, -0.13808535f, -0.20641834f, 
    -0.05159546f, -0.24100007f, 0.12010999f, -0.59350544f, -0.73194200f, 0.57633096f, 0.39478952f, -0.94067436f, 
    -0.02283799f, 0.10459790f, -0.23116326f, -0.52657932f, 0.22419144f, -0.05004578f, -0.06504343f, 0.16099249f, 
    0.35875157f, 0.14638984f, 0.31098625f, -0.14944056f, -0.18013954f, 0.05550929f, -0.26435104f, 0.09993939f, 
    -0.23174396f, 0.39617467f, 0.19101295f, -0.85683960f, 0.20337887f, 0.78542727f, -0.11129586f, 0.10383067f, 
    -0.12780876f, 0.63804531f, 0.13350353f, -0.00730276f, 0.40788177f, -0.29673019f, -0.06125329f, 0.30738619f, 
    0.10807773f, -0.24914879f, 0.17838129f, -0.32924032f, -0.25812465f, -0.25386509f, 0.12836139f, 0.02861486f, 
    -0.09501932f, -0.32300764f, -0.11902449f, -0.33870518f, -0.30216485f, 0.03526515f, 0.68780434f, 0.25553182f, 
    -0.91358638f, -0.12839825f, -0.41205084f, 0.46272954f, 0.19659083f, -0.52595901f, -0.12527338f, 0.28527766f, 
    -0.41067064f, 0.07391613f, -0.24680778f, -0.18319850f, 0.15422909f, -0.08314147f, -0.31005523f, -0.49141052f, 
    0.02445335f, -0.23142886f, -0.16697973f, -0.18583067f, 0.06623138f, 0.56699359f, 0.71580809f, 0.79311895f, 
    0.61814952f, 0.09079995f, -0.14597155f, 0.42697775f, -0.31876782f, 0.11472694f, 0.22202159f, 0.06540092f, 
    0.00491639f, 0.08852582f, -0.00152773f, 0.23076835f, 0.01344875f, -0.21699059f, 0.26172814f, -0.05946796f, 
    -0.29525378f, -0.07586230f, 0.14258556f, -0.18780684f, 0.40608427f, -0.19965994f, -0.30703864f, 0.43965492f, 
    0.81271631f, 0.27918720f, 0.56523907f, 0.43166319f, -0.22635528f, 0.65267563f, 0.16043043f, 0.10774496f, 
    -0.32342985f, -0.28263193f, -0.30722055f, -0.22592010f, -0.02970206f, -0.10328003f, 0.09400785f, -0.22504628f, 
    0.06683823f, -0.13197441f, 0.04229681f, 0.02076712f, 0.09144282f, 0.40083918f, 0.37059644f, 0.08660849f, 
    1.18115532f, -0.68810248f, -0.49514666f, -0.80451322f, 0.74869603f, 0.26862097f, -0.60503781f, -0.39940405f, 
    -0.12404519f, 0.28806874f, 0.06899796f, -0.03380532f, 0.18967740f, -0.06121521f, 0.03747539f, 0.13496606f, 
    0.03567394f, 0.02345693f, -0.02792425f, 0.00250063f, -0.06028236f, 0.08201133f, -0.01789448f, 0.16278207f, 
    0.32515192f, -0.24370755f, -0.78406751f, -0.55321640f, 0.37867120f, 0.00203518f, -0.31258202f, 0.47044146f, 
    0.72705889f, 0.04695367f, -0.52369297f, -0.10226055f, -0.13308764f, -0.23632327f, -0.16442619f, 0.21492770f, 
    -0.06183905f, -0.22211471f, -0.19659540f, -0.04739127f, -0.46310374f, -0.27677763f, -0.27999341f, 0.17302004f, 
    -0.12445138f, -0.40220153f, -0.44239324f, -0.11857770f, -0.32984212f, -0.17090347f, 0.22693755f, -0.39942607f, 
    -0.36067179f, -0.55658019f, -0.59934682f, -0.36050829f, -0.03539422f, 0.29504299f, 0.28233781f, 0.58124387f, 
    -0.04863253f, -0.19492649f, 0.08839165f, 0.36378926f, 0.43894547f, 0.33686969f, 0.20846528f, -0.54671931f, 
    0.04613071f, -0.01108046f, -0.23208988f, -0.16800065f, 0.85123384f, -0.50068194f, -0.27061841f, -0.03914805f, 
    -0.18189630f, 0.19002596f, 0.35634094f, -0.35788044f, 0.28622144f, -0.00309454f, -0.15575379f, 0.45290676f, 
    -0.35740629f, 0.32507148f, -0.02955256f, 0.36446214f, -0.26184538f, 0.15486947f, -0.45925367f, 0.06618144f, 
    0.09832581f, -0.02465781f, 0.09371788f, -0.50899416f, -0.92586559f, -0.89112878f, -0.05536804f, 0.15883712f, 
    -0.28299862f, -0.07567601f, 0.02832299f, 0.04135621f, 0.43042263f, 0.03281876f, -0.09522450f, 0.03150054f, 
    -0.14468910f, 0.10756078f, -0.08106592f, -0.12937704f, 0.14209160f, -0.19648653f, 0.03595419f, 0.00110282f, 
    -0.11613516f, -0.49300122f, -0.00869103f, 0.27367291f, -0.33990601f, 0.89337355f, -0.22542335f, 0.45288345f, 
    0.26795095f, 0.10004650f, 0.55172747f, 0.69736642f, 0.44224179f, 0.83749801f, -0.58825248f, 0.12986577f, 
    -0.12175170f, -0.35180613f, -0.07681597f, 0.27763045f, 0.04310865f, -0.01105112f, 0.31212166f, 0.06352323f, 
    -0.21887845f, -0.03609136f, -0.09283501f, 0.08917459f, -0.33044079f, 1.15828419f, -0.24593505f, -0.46307859f, 
    -0.66357434f, -0.18392925f, -0.43579713f, 0.35139149f, -0.03926697f, 0.11089058f, 0.03696777f, -0.28937134f, 
    -0.12507994f, 0.22543244f, -0.10671209f, -0.27402693f, -0.14022148f, 0.02686990f, 0.27319267f, -0.21927188f, 
    -0.09276382f, 0.13105939f, 0.13656184f, -0.14867394f, 0.00493903f, -0.31701016f, 0.44999143f, 0.07122526f, 
    0.58412743f, 0.82722592f, 0.46295613f, -0.57869142f, -0.00896025f, -0.45552185f, 0.53112704f, 0.36271936f, 
    0.36074790f, -0.07283765f, -0.16666874f, 0.28075498f, -0.26223040f, -0.15298429f, -0.00311984f, -0.04883297f, 
    0.25270626f, -0.14339024f, -0.32028738f, 0.08571143f, 0.05140280f, 0.07024977f, 0.12016430f, 0.49900842f, 
    0.76494753f, 0.02406379f, 1.01899433f, 0.19748692f, 0.36467233f, 0.36249936f, -0.15006596f, 0.12491638f, 
    -0.04636822f, 0.06301963f, -0.24046296f, 0.03936099f, 0.10147126f, -0.00724655f, 0.18372470f, 0.13163838f, 
    0.15594655f, 0.03733760f, -0.13114721f, -0.10063919f, -0.39381009f, -0.40722358f, -0.22712432f, 0.01312621f, 
    -1.40624940f, 0.92816734f, 0.53000683f, -0.57470620f, -0.41287252f, 0.08392695f, 0.55565393f, -0.10858107f, 
    0.31187928f, -0.25197688f, -0.36962301f, 0.15112045f, 0.08856537f, -0.09376089f, 0.17942940f, -0.23234600f, 
    -0.13616012f, -0.09539213f, -0.18367863f, -0.17711090f, 0.24827327f, 0.09042286f, 0.19756500f, 0.21022724f, 
    0.16962799f, -0.69769561f, 0.03084092f, 0.77048606f, -0.68683910f, -0.63068295f, 0.50758344f, -0.03789387f, 
    0.48144644f, 0.37999615f, 0.53884715f, 0.15691273f, 0.11322653f, -0.10721463f, 0.08563111f, -0.19278465f, 
    -0.30395526f, 0.10258045f, -0.19000691f, -0.25203922f, -0.21666285f, 0.02382625f, 0.00990072f, 0.00261911f, 
    -0.19857642f, -0.05494360f, 1.01425302f, 0.47464311f, -0.16452850f, 0.78470159f, 0.50568849f, -0.38476229f, 
    -0.49818876f, 0.26150364f, -0.32018733f, -0.12112777f, -0.54021996f, 0.19118713f, 0.14784329f, -0.15595827f, 
    -0.14525968f, 0.05111700f, -0.17808440f, -0.21130234f, 0.00294757f, -0.01336058f, 0.15777425f, -0.02378418f, 
    -0.04515534f, -0.27342591f, 0.08407462f, 0.59065914f, -0.02233697f, 0.77907217f, 0.41012323f, 0.64034718f, 
    0.49623230f, -0.36155814f, -0.67691725f, -0.38686219f, -0.40082854f, 0.30668324f, 0.37803051f, -0.00022107f, 
    -0.04280351f, 0.13322154f, 0.09576743f, -0.02880285f, -0.17035475f, 0.15397063f, 0.10117806f, 0.12380317f, 
    0.29593486f, 0.15917751f, 0.17144746f, 0.54962462f, -0.18267761f, -0.49691707f, -0.65858710f, -0.60927588f, 
    -0.42432353f, 0.04931636f, 0.27917099f, 0.24006149f, 0.49819797f, 0.01535374f, -0.26110154f, 0.06249753f, 
    -0.42499447f, -0.00734971f, 0.08492169f, 0.31265110f, -0.03731053f, -0.00295082f, 0.18744029f, 0.25214815f, 
    0.09392467f, 0.23724574f, 0.26233405f, -0.13467690f, 0.32278842f, -0.63292503f, -0.58959597f, -0.51525903f, 
    -0.23982690f, -0.26831955f, 0.73028392f, 0.81715417f, 0.46274900f, 0.46316296f, 0.60337538f, -0.40229872f, 
    -0.02774611f, 0.27233481f, -0.43615231f, -0.17910810f, 0.04742031f, -0.04781063f, 0.00378811f, -0.26350138f, 
    -0.39742002f, -0.31154296f, 0.06962090f, -0.14203255f, 0.29361263f, 0.15114139f, 0.08544279f, -0.59105283f, 
    -0.06479497f, -0.49696591f, -0.27391481f, 0.26342604f, 0.24248670f, -0.31750339f, 0.01052195f, -0.43799129f, 
    0.34270641f, 0.31913754f, 0.17218825f, 0.14180475f, 0.09194010f, -0.34359267f, -0.34586191f, -0.23385721f, 
    -0.70233041f, -0.29011199f, 0.21595795f, 0.10637946f, 0.26925772f, 0.51194006f, 0.08262199f, -0.24224606f, 
    -0.44651106f, -0.23714377f, 0.45709848f, -0.18752483f, -0.61682510f, 0.31226480f, 0.60542488f, -0.31101012f, 
    0.23950039f, 0.32313713f, 0.15940522f, 0.31441399f, 0.12181192f, -0.25040287f, 0.53493762f, 0.14778955f, 
    -0.19149208f, -0.20950751f, -0.53073245f, -0.10005800f, -0.35722426f, 0.41489422f, 0.19427583f, 0.25714368f, 
    -0.93038321f, -0.94583130f, -0.00291424f, 0.59387147f, -0.13476528f, 0.59844381f, 0.63765925f, -0.35775688f, 
    0.27499238f, -0.32723343f, -0.00910345f, 0.34819743f, 0.07731651f, 0.25205147f, 0.04654191f, 0.05525090f, 
    0.06409845f, 0.01850902f, -0.07049208f, -0.16378805f, -0.12618546f, -0.03833354f, -0.08031370f, -0.16578443f, 
    -0.05194908f, 0.61466032f, 0.22019461f, 0.19226784f, -0.58993542f, -0.26516575f, 0.42121905f, -0.53982383f, 
    0.55467355f, 0.73324567f, -0.17960910f, -0.37516445f, -0.37262350f, -0.26235816f, -0.43015391f, 0.21874963f, 
    -0.13125534f, -0.12382915f, -0.32031792f, -0.04900758f, 0.16116861f, 0.12180545f, -0.07711369f, 0.06318144f, 
    -0.08654331f, -0.30781367f, -0.63952506f, -0.72166210f, -0.15467189f, -0.32699218f, -0.51782626f, -0.33735934f, 
    -0.47858918f, 0.01170606f, -0.00921047f, 0.21406299f, -0.15870519f, 0.31201112f, -0.31080294f, 0.07208051f, 
    -0.50853407f, 0.00103588f, 0.19476053f, 0.08287336f, 0.06217508f, -0.18113646f, 0.26853251f, 0.23420574f, 
    -0.16431661f, 0.05951309f, 0.09632784f, 0.26350427f, -0.51296586f, 0.06076098f, 0.88349563f, 0.65921855f, 
    0.41385183f, 0.57881486f, 0.70539957f, -0.00731041f, -0.18035166f, 0.27142304f, 0.06769549f, -0.28005451f, 
    0.20266670f, -0.11656500f, -0.18970533f, -0.13282551f, 0.09946605f, -0.00770554f, -0.10633449f, 0.28557464f, 
    0.16585907f, -0.16884021f, 0.23589540f, -0.21696392f, 0.09786270f, 0.42808172f, 0.73899889f, 0.51169777f, 
    -0.19229101f, -0.82005948f, -0.69767559f, -0.21693382f, -0.23910953f, -0.60924691f, 0.17079407f, 0.16094445f, 
    -0.12707460f, -0.11501662f, -0.07679640f, 0.22741602f, -0.09206773f, 0.03301869f, 0.23893480f, 0.36893174f, 
    0.08966701f, 0.16080692f, 0.14495142f, -0.49371782f, -0.41460994f, 1.13833821f, 0.56687379f, -0.16337027f, 
    0.57757300f, -0.57581121f, -0.53631461f, -0.02275270f, -0.55164367f, 0.26852003f, 0.09388213f, 0.28906465f, 
    -0.13693079f, -0.33831298f, -0.21042509f, -0.12133204f, -0.12865295f, -0.09117856f, 0.05112360f, -0.31356719f, 
    0.22524604f, -0.15906011f, 0.36235520f, -0.01859774f, -0.20934366f, -0.12732391f, 0.18355696f, 0.92935610f, 
    0.84040624f, 0.19720683f, -0.10789461f, -0.31158376f, 0.64010972f, 0.03656233f, -0.05937029f, 0.22406568f, 
    -0.11786513f, 0.27893853f, -0.30123255f, -0.24803843f, 0.33760497f, 0.22566879f, 0.03879144f, -0.12637047f, 
    -0.25093830f, -0.13500451f, 0.04881398f, 0.05054316f, 0.05248415f, -0.22596589f, -0.08111588f, -0.67693913f, 
    -0.24589416f, 0.61487854f, 0.42318544f, 0.26840901f, -0.82324827f, 0.76761538f, -0.32528374f, -0.62387186f, 
    -0.04536054f, 0.33678547f, 0.10205884f, 0.20768389f, -0.10147678f, 0.03651630f, 0.09118722f, -0.16068701f, 
    -0.00557365f, 0.17914081f, 0.25800267f, -0.00136451f, 0.05340117f, 0.23238306f, -0.02820100f, 0.15143199f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.29539967f, -0.01354622f, 0.11331990f, 0.08137064f, 0.23424707f, 0.16645254f, 0.18717454f, 0.30589154f, 
    0.11339541f, 0.26853025f, 0.30676267f, 0.32143912f, -0.04278674f, 0.00365784f, 0.03026253f, 0.13248523f, 
    -0.01068565f, 0.05752004f, -0.01007730f, 0.28923780f, 0.23406142f, 0.01421474f, 0.19104606f, 0.28654397f, 
    0.36757278f, -0.08440872f, 0.24912468f, 0.17059653f, 0.22630556f, 0.03677132f, 0.33246425f, 0.12625034f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.34116349f, 0.06783814f, -0.16626443f, -0.03703274f, -0.06246553f, 0.07605421f, -0.02875751f, -0.03028037f, 
    0.13261636f, -0.06127534f, 0.04551642f, -0.07947355f, 0.10544970f, -0.21996160f, 0.30390507f, 0.13311292f, 
    -0.08500310f, 0.05916964f, -0.12103116f, 0.07633004f, -0.14454566f, 0.04382396f, 0.07928912f, -0.06612808f, 
    0.26401222f, -0.03379376f, 0.11442770f, -0.12799665f, 0.02676395f, 0.15120730f, -0.15534918f, 0.12582912f, 
    0.05514809f, 0.21030508f, 0.03138878f, 0.23314847f, 0.15021801f, -0.00873057f, -0.16821276f, -0.07186166f, 
    -0.00608565f, -0.17191119f, -0.04471679f, -0.05295259f, -0.04106192f, 0.00663814f, -0.03220214f, -0.16618717f, 
    -0.13922760f, 0.04889774f, -0.19124572f, -0.00433401f, 0.15400556f, 0.07355264f, -0.11228104f, 0.04909609f, 
    -0.01865660f, -0.09807085f, -0.09294213f, -0.02687021f, -0.07671811f, 0.03120516f, 0.10206722f, 0.03117262f, 
    0.10631522f, 0.07609452f, 0.01081347f, 0.02106788f, 0.05107844f, -0.04891132f, 0.00219096f, 0.04261855f, 
    0.06572256f, 0.17808798f, 0.12273974f, 0.10594799f, -0.02429659f, 0.07096431f, 0.02628714f, 0.04213509f, 
    0.08153887f, 0.06242566f, 0.02132359f, -0.02092418f, -0.30327126f, 0.24932098f, -0.26724237f, 0.14719981f, 
    0.05634097f, -0.12236787f, -0.03860382f, 0.00661293f, 0.09933047f, 0.10289084f, 0.12860844f, 0.00358568f, 
    0.15175024f, 0.02965332f, -0.05004171f, -0.14933732f, 0.14089619f, 0.11708660f, 0.02160314f, -0.19423988f, 
    -0.09758116f, -0.18227866f, -0.17170171f, -0.08680560f, -0.02829703f, 0.00552750f, -0.06665447f, 0.12845278f, 
    -0.00715443f, 0.04271343f, -0.08698379f, 0.10729028f, -0.06847361f, 0.27680397f, 0.24654028f, 0.00459826f, 
    -0.19025135f, 0.05392248f, 0.15343975f, 0.27481481f, -0.10575507f, 0.09600347f, -0.01267833f, -0.08657660f, 
    -0.06884629f, -0.09512104f, -0.05014880f, 0.00754520f, -0.15042010f, 0.04117678f, 0.08347778f, 0.05307710f, 
    0.09183528f, 0.21814609f, -0.07100933f, 0.09595653f, -0.00963541f, 0.08274566f, 0.07975759f, 0.03127732f, 
    -0.00678511f, 0.26145205f, 0.10701776f, -0.13923272f, 0.04898745f, -0.10215166f, 0.01666521f, -0.12916873f, 
    0.00269077f, 0.06615994f, 0.02494067f, 0.02970322f, 0.14649141f, -0.25395355f, 0.03973965f, 0.05503099f, 
    -0.07840030f, 0.00288847f, 0.06081611f, -0.09157523f, 0.16361575f, -0.12366303f, 0.07205160f, -0.19350775f, 
    0.01387752f, -0.01456791f, -0.02755754f, -0.12013446f, 0.00634702f, 0.00333224f, 0.07012533f, -0.06210740f, 
    -0.05053612f, -0.06932917f, 0.03698384f, 0.01736613f, 0.05691920f, 0.18219948f, 0.31068137f, -0.08555935f, 
    0.12898532f, 0.01956546f, -0.15686665f, -0.09721763f, -0.00895846f, -0.08318996f, 0.03599547f, 0.04816199f, 
    -0.24752814f, -0.27128854f, -0.25963989f, 0.20788166f, 0.13568254f, -0.04146377f, 0.08373295f, 0.02141544f, 
    0.01889271f, 0.13443291f, -0.06824835f, -0.14214015f, 0.23636681f, -0.01525977f, -0.21542139f, 0.26387233f, 
    0.06228438f, -0.19177182f, 0.00048375f, -0.07995998f, -0.04720846f, -0.08095518f, -0.09357435f, -0.01923187f, 
    -0.04308547f, 0.07844543f, 0.17769590f, -0.05997286f, -0.01944212f, 0.00221295f, 0.00905970f, -0.01644464f, 
    -0.18075241f, -0.02419465f, 0.06990077f, -0.00113416f, -0.07181752f, 0.01425774f, 0.12888072f, 0.11341092f, 
    -0.09542524f, 0.04759910f, 0.01180460f, -0.00183804f, 0.08014745f, 0.10513454f, -0.04867496f, 0.13508487f, 
    0.17455585f, 0.09094408f, -0.04397447f, 0.10300390f, 0.17253247f, 0.10575850f, 0.09465302f, 0.05012473f, 
    -0.00408028f, 0.08805785f, -0.09369645f, 0.13891152f, 0.01585644f, 0.15998840f, -0.06990122f, 0.04440708f, 
    -0.11431356f, -0.02555377f, 0.04354088f, -0.00589904f, 0.00937496f, 0.01839419f, 0.00616017f, -0.07072254f, 
    -0.16841358f, 0.10798796f, 0.13186930f, 0.02520033f, -0.09140739f, 0.04223315f, 0.14451599f, 0.14168905f, 
    0.06031287f, 0.00349928f, -0.10129666f, -0.03065731f, 0.12646604f, -0.00960798f, -0.01072699f, -0.26483518f, 
    -0.04104606f, 0.03457665f, 0.03632208f, 0.06515570f, 0.13410453f, -0.17456751f, -0.02570732f, 0.15095565f, 
    -0.19357607f, 0.06297915f, 0.11936263f, -0.17509072f, -0.04217128f, 0.17266673f, -0.05495524f, 0.00524852f, 
    -0.04593524f, -0.02244149f, 0.12809308f, -0.06638040f, 0.25782850f, 0.00075237f, -0.16126534f, 0.11540088f, 
    0.05512770f, -0.08185190f, 0.05076300f, -0.19707370f, 0.02025147f, 0.03405212f, -0.11031891f, -0.13906853f, 
    0.02207472f, 0.12044954f, 0.10000920f, 0.29726025f, 0.27314511f, 0.11058623f, 0.16702348f, 0.01992144f, 
    0.11699290f, -0.09518182f, -0.00768440f, -0.00358668f, -0.15256312f, -0.00521148f, 0.22348662f, -0.24479942f, 
    0.01191223f, -0.03372667f, -0.03390704f, 0.12448405f, 0.10078178f, -0.04352785f, -0.02070121f, 0.09274170f, 
    -0.03430106f, -0.04875058f, 0.04690338f, 0.01644740f, -0.01654612f, -0.15418372f, 0.13120750f, -0.04599278f, 
    -0.10508957f, 0.15883496f, 0.00931946f, 0.25162375f, -0.28092781f, -0.10709052f, 0.07230395f, 0.19780990f, 
    0.04181840f, -0.18896553f, -0.10466304f, 0.11990134f, -0.05277893f, 0.04568191f, -0.07213973f, -0.08628172f, 
    -0.17442761f, -0.07955169f, -0.16025068f, -0.10913671f, 0.05756398f, 0.10985034f, -0.05107402f, -0.00243717f, 
    -0.05748275f, -0.07330991f, -0.04353178f, 0.06070562f, 0.44032672f, -0.05769781f, -0.08565293f, -0.09621390f, 
    0.00155537f, -0.09595282f, 0.02946746f, -0.06369157f, 0.03801902f, -0.04217098f, 0.07428285f, 0.17334759f, 
    0.41412044f, 0.16414055f, -0.03846863f, 0.07507301f, -0.08814600f, -0.06312628f, -0.17004670f, -0.01353719f, 
    -0.10925717f, -0.08369427f, -0.08380531f, -0.09958103f, -0.13161926f, -0.07325251f, 0.01180895f, 0.10438081f, 
    -0.03257462f, 0.16381286f, -0.10815453f, 0.19506216f, -0.15692733f, 0.21127348f, 0.08884961f, -0.07729055f, 
    0.19742562f, -0.14653656f, 0.13903302f, -0.18650709f, -0.04174574f, 0.08239233f, -0.13357174f, 0.09104002f, 
    0.00859150f, 0.12622188f, -0.05405420f, 0.26733729f, 0.22417167f, 0.12519854f, -0.00458906f, -0.09082263f, 
    0.03545882f, -0.17794789f, -0.00190656f, -0.06652047f, -0.06933495f, 0.03109301f, -0.02834951f, -0.15456362f, 
    0.02174292f, 0.05227373f, -0.27160743f, 0.13264528f, -0.02289192f, -0.01599061f, -0.12006915f, 0.09473117f, 
    -0.09342025f, -0.01805220f, -0.11528817f, 0.03191555f, -0.12185329f, -0.19507672f, -0.05250907f, 0.22864129f, 
    0.02472003f, 0.21160047f, 0.07443660f, 0.03105969f, 0.09637425f, -0.10848296f, -0.00320249f, -0.01909714f, 
    0.07832989f, 0.08976076f, 0.00131296f, 0.11398008f, 0.07590639f, 0.06071595f, 0.01097122f, -0.00027717f, 
    0.05807392f, 0.05242669f, 0.14152145f, -0.01577201f, -0.24800754f, 0.35573715f, 0.14039837f, -0.22710967f, 
    -0.01948705f, -0.21192896f, 0.02058793f, 0.01851112f, 0.00853987f, -0.03154567f, 0.11638382f, 0.01037461f, 
    0.10200876f, 0.17856909f, 0.00856099f, 0.05906726f, -0.03084780f, 0.15495603f, 0.01701021f, -0.18690535f, 
    -0.20657943f, -0.10126265f, -0.18179969f, -0.11403810f, -0.05503857f, 0.07139761f, -0.06050811f, -0.09725884f, 
    0.05176750f, 0.01282180f, -0.07950934f, 0.10043938f, -0.00704685f, 0.28278720f, 0.07275172f, 0.06526121f, 
    -0.04200202f, 0.03564319f, 0.16566396f, 0.04049018f, -0.06107866f, 0.10224414f, -0.01777455f, 0.07596626f, 
    -0.01774701f, -0.01549204f, 0.03808236f, 0.16530019f, -0.08343694f, 0.00472742f, 0.01401500f, 0.24871589f, 
    0.03932522f, 0.19750731f, -0.09143647f, -0.01592224f, 0.02889983f, 0.14591208f, 0.02941996f, -0.03145510f, 
    0.27698091f, 0.11137731f, 0.07824184f, -0.04170987f, -0.02752452f, -0.01047057f, 0.02241679f, -0.14583389f, 
    -0.01654728f, 0.13629723f, 0.08661551f, -0.01485561f, 0.18824236f, -0.04604695f, -0.05878423f, -0.05639687f, 
    -0.10308184f, -0.03084429f, -0.06114607f, -0.02579291f, 0.22465503f, -0.10307632f, -0.06877496f, -0.07485940f, 
    -0.15671420f, -0.13252960f, -0.07857230f, 0.22024129f, 0.02326860f, 0.13427627f, 0.05714992f, -0.07540245f, 
    -0.02543564f, -0.13960448f, 0.06265863f, -0.05362570f, 0.04172553f, 0.02023440f, 0.21236584f, 0.13875929f, 
    0.19287574f, 0.11196694f, -0.11161599f, -0.11814039f, -0.04731037f, -0.04686860f, 0.03712901f, 0.08709753f, 
    -0.25287402f, -0.02569036f, -0.02348115f, -0.04217055f, 0.09024046f, -0.01941670f, 0.10808597f, 0.10804072f, 
    0.08443554f, 0.05010475f, 0.01415896f, -0.00170530f, 0.22885291f, 0.12373824f, 0.06127421f, -0.06407686f, 
    0.00874117f, -0.23597151f, 0.08872236f, 0.00560530f, 0.00700656f, -0.05042290f, -0.06400435f, -0.04653698f, 
    -0.07976846f, -0.26240912f, -0.04639826f, 0.20550254f, 0.10837357f, 0.02823086f, 0.12322497f, -0.09962998f, 
    0.04345376f, -0.02881017f, 0.05909168f, 0.00419480f, -0.09018067f, 0.04511693f, 0.11765935f, 0.17588054f, 
    0.05500488f, 0.13233085f, 0.06366045f, -0.05762506f, 0.00649049f, 0.02724329f, 0.00385780f, 0.09281246f, 
    0.12953392f, 0.04266760f, 0.11842495f, 0.12400012f, 0.07146567f, 0.09013777f, 0.07415681f, 0.05147222f, 
    -0.00156682f, -0.00384463f, -0.22078638f, 0.19728942f, 0.07587198f, 0.22559531f, -0.00782650f, 0.04056523f, 
    -0.04106259f, -0.07659160f, -0.02049091f, 0.00632346f, 0.01063202f, -0.05655874f, -0.07423622f, -0.22274637f, 
    -0.07542017f, 0.14252575f, 0.16045469f, 0.21048349f, -0.11874750f, -0.01016350f, 0.15261310f, 0.18266703f, 
    0.12829594f, 0.10421351f, -0.00813908f, -0.01847266f, 0.25695679f, -0.02861904f, 0.10973050f, -0.03755808f, 
    -0.07464943f, 0.11030596f, -0.06919055f, -0.04192054f, 0.09212136f, -0.28437710f, -0.17943601f, 0.19886978f, 
    -0.09448183f, 0.03905924f, -0.00900601f, 0.04858799f, -0.01068429f, -0.04762162f, 0.00752749f, -0.04543552f, 
    -0.11082352f, -0.04180634f, 0.08897237f, 0.12090899f, 0.38050440f, 0.06858403f, 0.03027757f, -0.14248349f, 
    0.07310987f, -0.12449985f, 0.03585038f, 0.02656022f, 0.02427880f, -0.02906724f, -0.10340140f, -0.12025712f, 
    0.17514232f, -0.00142489f, 0.13144732f, 0.22348712f, 0.07410174f, 0.11059859f, 0.06095881f, 0.20087066f, 
    0.09854702f, -0.11439969f, -0.12327936f, 0.11665075f, -0.32338369f, 0.22078663f, 0.15013321f, 0.00900888f, 
    0.06192815f, -0.09524289f, -0.05846930f, 0.06880751f, 0.05657296f, 0.01408424f, -0.06383248f, -0.00579400f, 
    -0.12662092f, -0.12403879f, -0.14603655f, 0.23172277f, -0.02729547f, -0.12417357f, 0.04942353f, -0.00450644f, 
    0.00604219f, 0.17802984f, 0.09862160f, 0.12037104f, 0.16462275f, -0.14661428f, -0.09948044f, -0.00678789f, 
    0.00687689f, -0.14010769f, 0.04916397f, 0.07677796f, 0.03005445f, 0.10645006f, -0.02581532f, -0.09490204f, 
    -0.03692538f, -0.08638699f, -0.15073484f, 0.06434947f, 0.02352882f, 0.13839690f, -0.04316556f, 0.00303134f, 
    0.00863117f, 0.02195061f, -0.06657855f, 0.15366547f, 0.14169195f, -0.03545440f, 0.03004194f, -0.11888126f, 
    0.05351105f, -0.05840954f, -0.04649546f, 0.00534824f, -0.03774385f, -0.10613766f, 0.00416623f, 0.14376262f, 
    -0.07078763f, -0.08387004f, 0.11152269f, -0.15888956f, -0.01721145f, -0.07008710f, 0.16433738f, 0.09351917f, 
    0.00160199f, 0.19600886f, 0.00593029f, 0.02997938f, -0.22173615f, 0.17687954f, -0.24666518f, 0.24546494f, 
    0.14157414f, -0.11290123f, 0.19218500f, -0.11670878f, 0.06064406f, 0.00747607f, -0.02083707f, 0.07269511f, 
    0.48548490f, 0.04999749f, 0.13079715f, 0.18457970f, -0.04237297f, -0.09954612f, 0.06989149f, -0.06107828f, 
    0.00862038f, -0.12204671f, 0.05268699f, -0.16697326f, -0.14143291f, 0.11153109f, 0.13394976f, 0.06707142f, 
    0.01679323f, -0.00093244f, -0.01619078f, 0.04452701f, 0.12077437f, 0.00540864f, 0.07494029f, 0.12596150f, 
    -0.14050835f, 0.12729450f, 0.05735210f, 0.22212337f, -0.01149497f, 0.04253412f, 0.18153059f, -0.10071658f, 
    0.04299272f, 0.09610394f, 0.07705115f, -0.12894000f, -0.12629819f, -0.07673432f, -0.14876635f, -0.15598674f, 
    -0.15952349f, -0.11369877f, 0.04390253f, -0.02441764f, -0.06507771f, 0.05381158f, -0.06011703f, 0.00162000f, 
    -0.40453169f, -0.15968905f, -0.09755802f, -0.10074356f, -0.09872356f, -0.08446383f, -0.02473493f, 0.03121535f, 
    -0.01011220f, 0.01310010f, 0.05503047f, -0.02263214f, 0.26341125f, -0.01297529f, 0.06345281f, -0.07011542f, 
    -0.03179079f, 0.00378286f, 0.10082186f, 0.07918501f, 0.01147675f, -0.03214205f, -0.13581906f, -0.02340782f, 
    0.29756907f, 0.02571329f, 0.18487175f, 0.08293892f, -0.11883166f, -0.04185962f, 0.02999664f, 0.10572887f, 
    0.12996125f, -0.01389669f, 0.07949515f, 0.03000198f, 0.25918913f, 0.16275224f, 0.07993320f, 0.09007917f, 
    -0.07627171f, 0.05458365f, 0.18106444f, -0.03363853f, 0.05045542f, -0.18665662f, -0.17438112f, 0.05708933f, 
    -0.12944667f, 0.12719148f, 0.01601911f, 0.01435148f, 0.04578868f, -0.01889685f, 0.00427580f, 0.19552542f, 
    0.14817485f, 0.01906593f, 0.09668803f, 0.00007981f, 0.39979455f, 0.21675129f, -0.00403066f, 0.04147872f, 
    -0.06283972f, -0.12844974f, 0.08926481f, 0.02387156f, 0.02095956f, 0.00503522f, -0.04148757f, 0.06204583f, 
    -0.30367157f, 0.01516167f, -0.15741566f, -0.13860485f, -0.17060623f, 0.10121818f, 0.00566852f, 0.14295729f, 
    0.00793159f, -0.05819399f, 0.04432250f, 0.04811085f, -0.16728964f, 0.08242487f, 0.20181321f, -0.03406284f, 
    0.08441689f, 0.07571175f, 0.07280198f, 0.10234687f, -0.14193124f, 0.19201045f, 0.03798773f, 0.10018037f, 
    0.09033539f, -0.02866027f, -0.21109331f, 0.15999193f, -0.00868254f, -0.03339808f, 0.00813827f, 0.08953134f, 
    -0.06844004f, 0.12916449f, -0.02300619f, 0.00998759f, -0.30323914f, -0.22087429f, -0.23527369f, -0.06648972f, 
    -0.19941115f, -0.00091920f, 0.09980551f, 0.03164688f, 0.01533003f, 0.05023152f, -0.10323761f, 0.01449753f, 
    0.16586781f, 0.49783108f, 0.01693146f, -0.03729857f, 0.00963660f, 0.10585340f, 0.01565860f, -0.07083974f, 
    -0.03792140f, -0.01273057f, 0.06253040f, 0.07892942f, -0.07415507f, 0.18532798f, 0.18053772f, -0.11046387f, 
    0.05580801f, 0.25913471f, 0.07404099f, 0.17013794f, 0.07477418f, 0.07023182f, 0.05104630f, -0.14295536f, 
    0.22216672f, -0.04548848f, -0.01399201f, 0.03491207f, 0.09077453f, 0.03198315f, -0.05107448f, 0.04108830f, 
    0.08966031f, 0.02121509f, -0.00895629f, -0.00771596f, 0.08149432f, -0.13361198f, -0.07214102f, 0.04095588f, 
    0.00785500f, -0.05108082f, 0.00364207f, 0.07851233f, 0.00359847f, 0.01609346f, 0.08433941f, -0.05763703f, 
    0.20934691f, 0.03180705f, 0.16343066f, -0.05674264f, -0.08154449f, -0.01530805f, 0.07095268f, -0.01536164f, 
    -0.00511435f, -0.03273722f, 0.17526345f, -0.04187958f, 0.29925352f, 0.33333221f, 0.06859488f, -0.08386743f, 
    0.01919677f, -0.00279825f, -0.00746492f, 0.04125357f, 0.02578144f, 0.00227048f, 0.05907574f, 0.00609125f, 
    0.24634296f, 0.03272129f, 0.08006464f, 0.00241923f, 0.01120058f, 0.09839480f, -0.11728536f, -0.05415437f, 
    0.09303742f, 0.00250835f, 0.13254368f, 0.01696775f, -0.03159383f, 0.06160342f, 0.00258908f, 0.05790897f, 
    0.00776614f, 0.11102861f, -0.14508842f, 0.00785774f, -0.07602986f, 0.16859350f, 0.03120728f, -0.09986512f, 
    0.43078771f, 0.21984121f, 0.06853706f, 0.10324751f, -0.01395983f, 0.07291260f, 0.01531634f, 0.08328671f, 
    0.00315567f, 0.00596414f, -0.02585162f, -0.01497572f, -0.15007280f, -0.14832255f, 0.08938884f, -0.05283755f, 
    -0.03524796f, 0.00799807f, 0.05794591f, 0.00166433f, -0.03052851f, -0.06276477f, 0.04600667f, 0.13200788f, 
    0.21492119f, 0.09208301f, 0.07698227f, -0.07381169f, -0.11318070f, 0.06961567f, 0.05336419f, 0.02544885f, 
    0.02195042f, 0.09005303f, -0.00812521f, -0.03453369f, -0.14829513f, -0.01433356f, -0.18920632f, 0.04990716f, 
    -0.07324198f, 0.05477536f, 0.00560679f, -0.08774233f, -0.06480210f, -0.02168974f, 0.07064084f, -0.01101555f, 
    0.09227029f, 0.25480488f, -0.07791350f, 0.13446486f, 0.06069214f, 0.08664229f, -0.07283027f, 0.03954330f, 
    -0.01887757f, -0.14493720f, 0.04740335f, -0.14959829f, 0.13748069f, -0.01187244f, -0.10021499f, -0.02415324f, 
    -0.09959295f, 0.15791179f, -0.06743298f, 0.01419687f, 0.06920184f, -0.01997435f, 0.05133675f, 0.13567796f, 
    -0.31161472f, -0.06465910f, -0.16340931f, -0.03198588f, -0.06562760f, -0.14464371f, 0.01351974f, -0.00717528f, 
    0.10136580f, 0.02410306f, -0.00051308f, -0.12377503f, -0.05944365f, 0.29299033f, 0.14782329f, 0.20312802f, 
    0.02990760f, 0.08361933f, -0.01289431f, 0.11356229f, -0.00783697f, -0.00237472f, -0.10806151f, -0.08894105f, 
    -0.02952911f, 0.04339970f, -0.02553828f, -0.00744692f, 0.03552859f, 0.00440325f, -0.04627854f, 0.02971091f, 
    0.03945831f, -0.03877417f, -0.01981165f, 0.02562208f, 0.03620968f, 0.00044357f, 0.04361905f, -0.03932641f, 
    -0.03601512f, 0.02625850f, -0.04607526f, 0.01924605f, 0.00983312f, -0.03573086f, 0.03930207f, 0.04293226f, 
    0.03104027f, 0.03227702f, 0.01394611f, -0.00997538f, -0.05401739f, -0.04260168f, 0.02510257f, -0.00464764f, 
    0.02126206f, -0.00866166f, 0.00022588f, 0.04514131f, 0.00652168f, 0.00504737f, -0.00548718f, -0.03883833f, 
    -0.01192180f, 0.03784599f, 0.01586119f, 0.01140663f, -0.02831548f, 0.01210349f, -0.00116806f, -0.02313225f, 
    -0.03977720f, -0.05318790f, -0.04118491f, 0.02817946f, -0.03962163f, -0.00535614f, 0.01364982f, -0.01412959f, 
    0.00789700f, 0.00392381f, 0.03768668f, 0.01300843f, -0.03213873f, -0.04250782f, -0.02375126f, 0.00236421f, 
    0.03924732f, -0.05047926f, -0.04620318f, -0.02447343f, 0.00019357f, 0.04161112f, 0.02501953f, 0.03732666f, 
    0.02497204f, -0.00902414f, 0.04233833f, -0.01162014f, -0.04146020f, 0.04226049f, 0.02723394f, -0.00483179f, 
    -0.00367498f, -0.04529687f, 0.03108133f, 0.01886051f, 0.00543571f, -0.01614926f, 0.01796892f, -0.03968577f, 
    -0.00662920f, -0.03471882f, -0.03053232f, 0.01338969f, -0.02865482f, 0.00835366f, -0.00537817f, 0.03100854f, 
    0.02938962f, -0.00474962f, 0.01685287f, -0.02321789f, 0.04511677f, -0.00299969f, -0.04760550f, -0.00696051f, 
    -0.04250561f, 0.00813791f, 0.00348046f, 0.00680320f, -0.03386023f, -0.01884985f, -0.03781367f, 0.02015249f, 
    -0.05080870f, 0.01786956f, 0.03954191f, -0.03694470f, 0.00724485f, -0.01635141f, -0.05481306f, -0.01394612f, 
    -0.05581588f, 0.01787695f, 0.01298940f, -0.01626642f, 0.02078294f, -0.01141528f, -0.03345994f, -0.00526069f, 
    -0.04561147f, -0.03666016f, 0.01625664f, 0.01499833f, -0.05608872f, -0.01924529f, 0.01342620f, -0.01458697f, 
    -0.00381445f, -0.03252815f, -0.00105470f, 0.04095587f, 0.01006427f, -0.04435229f, -0.02675586f, -0.03318902f, 
    0.03510623f, -0.03226365f, -0.04670971f, 0.03599256f, -0.00801323f, 0.02227445f, -0.00489124f, -0.00272248f, 
    0.01190274f, 0.01981366f, -0.05064385f, 0.02315225f, -0.03001426f, -0.00179923f, 0.02171171f, -0.05183394f, 
    -0.05057082f, -0.02834613f, -0.00799136f, -0.01198443f, -0.03672471f, -0.01462468f, -0.03229631f, -0.01324628f, 
    -0.04045943f, -0.05462911f, -0.02312874f, -0.04259719f, -0.02981896f, -0.04677847f, -0.02917941f, -0.02371500f, 
    0.04494531f, -0.01401919f, 0.03764112f, 0.02182904f, 0.00730212f, -0.00493042f, -0.02880892f, 0.00618949f, 
    -0.03464642f, -0.04157310f, 0.02004153f, -0.01766786f, 0.02031530f, -0.01789022f, 0.02994630f, -0.02679186f, 
    0.01887765f, -0.04268469f, 0.00365850f, 0.02464348f, 0.01371533f, -0.03763233f, -0.01954940f, -0.03836242f, 
    -0.05469833f, -0.04797157f, -0.01832194f, -0.01106419f, 0.04531328f, 0.00937126f, -0.03658689f, -0.03506647f, 
    -0.03786964f, 0.02979463f, -0.04160275f, 0.01712095f, -0.02734232f, 0.01515445f, -0.04402269f, -0.04277351f, 
    -0.05045555f, -0.05371283f, -0.01319575f, -0.02174160f, -0.02345890f, 0.03815006f, -0.00971273f, -0.04864941f, 
    0.02585803f, 0.00933304f, -0.03617548f, -0.02899417f, -0.05146656f, 0.01358263f, -0.01535364f, -0.01143392f, 
    -0.05396954f, 0.00450538f, 0.02080137f, -0.01253072f, -0.01835111f, -0.02033947f, 0.00899302f, -0.01966175f, 
    -0.01480982f, 0.03515205f, 0.04303764f, -0.03792246f, -0.03207389f, -0.03259070f, 0.03463676f, -0.02383469f, 
    -0.04597300f, 0.00272747f, -0.02628796f, 0.03046142f, 0.03042142f, -0.03413517f, 0.04122037f, -0.04025979f, 
    -0.01233704f, -0.03139870f, 0.01416426f, -0.01935182f, 0.00530872f, -0.04688022f, 0.04319826f, 0.02871153f, 
    0.00076293f, -0.02634451f, -0.02411648f, -0.01937733f, 0.01514797f, 0.03270093f, 0.03464825f, -0.03568625f, 
    -0.03035368f, -0.03026896f, 0.03014759f, -0.00385104f, -0.00713591f, 0.01626201f, -0.00332081f, 0.04046651f, 
    0.02028041f, -0.04697450f, -0.04768346f, 0.02847834f, 0.01406519f, 0.00568284f, -0.04375678f, 0.04079763f, 
    -0.02722462f, -0.05387115f, -0.05244607f, -0.05199026f, -0.03172495f, -0.01081094f, 0.04325690f, -0.01475359f, 
    0.04045687f, 0.03987803f, 0.02953943f, -0.04508328f, -0.03280604f, 0.01432632f, -0.04217999f, 0.03096857f, 
    0.00811491f, 0.02343398f, -0.04562307f, -0.04978837f, 0.02713122f, 0.03997198f, 0.02425012f, -0.04596341f, 
    0.04102797f, -0.02565749f, -0.00384382f, 0.04488917f, -0.04482999f, 0.02124240f, -0.01376074f, -0.05562563f, 
    -0.02633203f, 0.01555052f, -0.04576794f, -0.02449716f, -0.02900092f, -0.04588819f, -0.03667907f, 0.01296570f, 
    -0.02735722f, -0.01787629f, 0.00987613f, -0.00308933f, -0.04453905f, -0.00824810f, 0.02774419f, 0.02133273f, 
    0.03399369f, -0.00472294f, 0.03678869f, 0.04358018f, -0.01178003f, -0.05473181f, -0.03925055f, -0.01938068f, 
    -0.02388009f, 0.04431111f, -0.02312937f, 0.03075473f, -0.03930233f, -0.01365598f, 0.00328404f, 0.00753043f, 
    0.03412892f, 0.00156606f, -0.05546764f, -0.00835674f, -0.03781217f, -0.03291768f, 0.02965682f, 0.04166630f, 
    0.00897106f, 0.02656246f, -0.05115039f, -0.03418059f, -0.04514001f, 0.01923858f, -0.05090089f, -0.01652299f, 
    -0.01753486f, -0.00369017f, -0.05551704f, -0.00303819f, 0.03207246f, -0.04321697f, -0.01078386f, -0.03011018f, 
    0.01389001f, -0.03383894f, 0.01719118f, 0.00368233f, -0.05554415f, 0.01993478f, -0.02732297f, -0.02080492f, 
    -0.00260807f, 0.01684814f, 0.00741374f, -0.07057917f, 0.11589173f, 0.05604176f, 0.04999443f, 0.04815943f, 
    -0.00531856f, 0.06475453f, 0.00882727f, 0.09114140f, 0.15444513f, 0.06595403f, 0.06860799f, -0.04199982f, 
    -0.03035387f, -0.05831387f, 0.01949301f, 0.01522247f, -0.04234407f, 0.05775276f, 0.01302087f, -0.04373340f, 
    -0.13664687f, 0.23488492f, 0.04554807f, -0.07410988f, -0.07387660f, 0.02274757f, 0.11152746f, -0.09391094f, 
    0.12547129f, -0.02694065f, 0.08579969f, -0.09598994f, 0.30906785f, -0.36185044f, 0.18032357f, 0.13425063f, 
    0.00117366f, 0.13400140f, 0.08585499f, -0.07063446f, 0.14631313f, -0.07542454f, -0.11754376f, 0.03940618f, 
    0.14577243f, 0.02210706f, 0.15194331f, 0.24082386f, 0.14703250f, -0.08282737f, 0.01934981f, -0.00415497f, 
    0.01080227f, 0.01979468f, -0.00544319f, 0.03033210f, 0.09611605f, 0.08730095f, 0.00966829f, -0.12251078f, 
    0.07803162f, -0.09411933f, 0.02777307f, -0.01485478f, -0.02968552f, 0.09841818f, -0.01044623f, -0.12978560f, 
    -0.05651079f, 0.05352856f, 0.02578932f, 0.08448126f, -0.00799415f, -0.00655317f, 0.02481473f, -0.02334746f, 
    -0.01683951f, -0.02791279f, -0.07715073f, 0.08299731f, 0.04157287f, 0.27729782f, 0.21565852f, 0.24451321f, 
    -0.09947426f, 0.03071875f, -0.04399389f, 0.02270754f, 0.01028416f, -0.07315742f, 0.00440349f, 0.07303483f, 
    0.12748104f, 0.14267610f, 0.06381389f, -0.09095825f, 0.03162102f, 0.02837990f, -0.04402703f, 0.05435706f, 
    0.03144637f, 0.11197743f, 0.09394073f, 0.04038229f, -0.11268134f, -0.10996212f, -0.01788258f, 0.01332170f, 
    0.12322655f, -0.09631138f, -0.01392136f, -0.16207358f, 0.10935527f, -0.01281918f, 0.03215818f, -0.09382899f, 
    0.06649742f, -0.21142001f, 0.09790386f, 0.01972925f, -0.06351715f, -0.01661897f, 0.05102069f, -0.11063807f, 
    -0.01941138f, 0.01431965f, -0.08319800f, -0.00525991f, -0.24284539f, -0.13162778f, 0.10877870f, -0.14220725f, 
    0.06362357f, 0.10788823f, 0.03530851f, -0.05786068f, -0.02136127f, -0.00902517f, 0.00059002f, 0.01282034f, 
    0.10960250f, 0.03517360f, 0.13070789f, 0.04303383f, 0.11918525f, -0.05283781f, 0.05754265f, -0.14190485f, 
    0.13064085f, -0.02029550f, 0.01619392f, 0.11607073f, 0.08333767f, 0.09032074f, -0.11791304f, 0.12428822f, 
    0.00426050f, 0.03296914f, 0.00463343f, 0.09242782f, -0.07082713f, 0.01853450f, -0.02362908f, 0.07766903f, 
    -0.05975313f, -0.00175971f, 0.07889023f, -0.27244756f, -0.05058978f, -0.02702322f, 0.00119773f, -0.05928715f, 
    0.03450203f, 0.01133136f, 0.03289531f, 0.06752412f, -0.02938772f, 0.33588424f, 0.13108830f, 0.10151295f, 
    -0.14099596f, 0.01179722f, 0.03852190f, 0.03773311f, 0.08578300f, -0.03992463f, -0.01435319f, -0.16370517f, 
    0.31713507f, -0.39952540f, 0.31485793f, 0.28946608f, 0.05738597f, -0.01989462f, 0.01350364f, -0.05274507f, 
    -0.11063355f, -0.05486644f, 0.02085962f, 0.03466332f, -0.18992524f, -0.04696634f, -0.13445036f, 0.24362415f, 
    0.07693117f, -0.04779019f, 0.03994319f, -0.18550675f, 0.04485569f, 0.00170503f, 0.04663078f, 0.14620455f, 
    -0.20957875f, 0.11719394f, 0.05112047f, -0.25471941f, -0.12080942f, -0.01740861f, -0.11887090f, 0.09354904f, 
    -0.21214175f, -0.01742766f, 0.02135495f, 0.03145737f, 0.01680363f, 0.10499714f, -0.15816639f, -0.17372681f, 
    -0.01651247f, -0.10108674f, -0.03398182f, -0.00377408f, -0.10456809f, -0.01722310f, 0.05271890f, -0.02676467f, 
    -0.10175527f, 0.01105626f, -0.00017210f, -0.08133233f, 0.08854453f, 0.06498083f, 0.00898865f, -0.04785024f, 
    0.04789311f, -0.11253435f, -0.03500763f, -0.04016278f, 0.02603589f, -0.17504494f, -0.01608717f, -0.05215625f, 
    0.11665373f, 0.13640328f, 0.05391927f, -0.01397026f, 0.11109491f, 0.07000807f, 0.03769354f, 0.13169186f, 
    0.07729135f, 0.07988917f, 0.00755546f, 0.20366056f, -0.05545561f, -0.01113323f, -0.02025934f, -0.04353141f, 
    0.02098089f, 0.08308905f, 0.03380244f, 0.09935443f, -0.06722073f, -0.06070856f, 0.06200982f, -0.13341866f, 
    -0.05660735f, -0.09806428f, 0.09804252f, -0.09913248f, 0.13562891f, 0.05070566f, 0.07012534f, -0.00623708f, 
    -0.18846838f, -0.14201608f, 0.08585898f, 0.17279308f, 0.06813315f, 0.03376803f, -0.01257898f, -0.02934170f, 
    0.01041545f, 0.10562990f, 0.03069620f, -0.05322834f, 0.33734176f, 0.17153831f, -0.12475202f, 0.14224090f, 
    -0.14828631f, 0.01504434f, 0.01415680f, 0.11112923f, 0.05428557f, 0.10001984f, 0.06104830f, 0.05890829f, 
    -0.09235314f, 0.00477249f, -0.03913209f, 0.07370173f, 0.09256480f, -0.10670456f, 0.07501283f, -0.16697207f, 
    -0.10635706f, 0.03269970f, -0.03984242f, 0.03646168f, 0.30579740f, -0.07481915f, 0.04236078f, 0.00767211f, 
    0.07557128f, 0.02484489f, -0.03063594f, 0.00227249f, 0.10604642f, 0.01487195f, -0.02346197f, 0.00398980f, 
    0.21400656f, -0.09711574f, -0.02034726f, -0.09111992f, 0.01123045f, -0.03716042f, -0.05881399f, -0.04207366f, 
    -0.08949409f, 0.06481533f, -0.04286262f, -0.03112080f, -0.21271624f, 0.24061935f, -0.06128743f, 0.14845648f, 
    -0.04762318f, -0.00510730f, -0.04459216f, -0.03112792f, -0.05493315f, 0.07923079f, 0.00667213f, -0.06013420f, 
    0.19338617f, -0.05189739f, 0.16855025f, 0.02757966f, 0.08921590f, 0.06974887f, -0.01604880f, -0.08043192f, 
    0.01451079f, -0.01481813f, 0.08435483f, -0.03648290f, 0.26084194f, -0.29162195f, 0.06516924f, -0.04659014f, 
    0.12751739f, -0.01088666f, 0.04710746f, -0.03485806f, 0.07881761f, 0.07200511f, 0.00739831f, -0.05468100f, 
    0.16128935f, 0.04855503f, -0.00994128f, 0.03840230f, -0.06826075f, 0.09576422f, -0.11773350f, -0.01827347f, 
    0.14520234f, -0.18502751f, 0.02206313f, -0.09025790f, -0.25149223f, -0.03151057f, 0.20498134f, 0.04150528f, 
    0.02070945f, 0.10422470f, -0.07709282f, 0.02288156f, -0.07714863f, -0.07217047f, 0.06207407f, 0.00604320f, 
    -0.22841670f, -0.12796174f, 0.06605134f, 0.15097441f, 0.18842547f, 0.06233328f, -0.13184753f, 0.15667014f, 
    0.00688293f, 0.21648489f, -0.05384756f, 0.25179163f, -0.44353628f, 0.25980905f, -0.18439341f, -0.05426090f, 
    0.00031138f, -0.06982481f, -0.10357695f, 0.02464661f, -0.17424275f, 0.08482333f, -0.01833896f, -0.02700221f, 
    0.00253741f, -0.01208113f, -0.04722988f, -0.18526591f, 0.03061480f, 0.10999662f, -0.11853833f, 0.09504117f, 
    -0.04143687f, -0.01161492f, -0.05204891f, 0.15692969f, -0.06476805f, 0.00774606f, 0.09414043f, 0.11857712f, 
    0.05290569f, 0.11633711f, 0.00187827f, 0.01949437f, 0.13917330f, -0.07116120f, 0.08428592f, 0.25366721f, 
    0.19604112f, 0.15949188f, 0.05729301f, 0.07235476f, 0.07485156f, 0.04890631f, 0.05203563f, 0.11987477f, 
    0.08038860f, 0.02098737f, 0.00284011f, -0.06947837f, -0.25760302f, -0.30102840f, -0.08519761f, 0.05167314f, 
    0.14999156f, 0.02142663f, 0.07858250f, -0.04627015f, 0.02966138f, 0.12264686f, 0.17178310f, -0.03556478f, 
    0.01218220f, -0.23707487f, -0.04997750f, 0.01078045f, 0.04907335f, 0.02297683f, 0.04524956f, -0.14345546f, 
    -0.11665627f, -0.04937085f, -0.09796942f, 0.00121533f, 0.15024213f, 0.01883153f, 0.05181904f, 0.14037298f, 
    0.11135492f, 0.19873261f, -0.05986523f, 0.11476322f, -0.02561423f, 0.18900707f, 0.27098325f, 0.06589951f, 
    0.05699306f, 0.27222368f, 0.08853823f, -0.03840803f, 0.02265993f, 0.08127083f, 0.06944560f, -0.02761488f, 
    0.01015667f, -0.03384789f, 0.06493443f, 0.06941338f, -0.00797149f, 0.13092297f, -0.14915384f, 0.10230922f, 
    0.15011096f, 0.11419665f, -0.07504460f, 0.18219839f, 0.07657697f, -0.01016384f, 0.07001263f, 0.09159467f, 
    -0.06306227f, 0.07561715f, 0.12619726f, -0.09661175f, 0.09751064f, 0.02994929f, -0.05322938f, 0.01567599f, 
    0.03702131f, 0.08934210f, -0.00920118f, -0.02085694f, 0.18526851f, -0.31397712f, 0.24724668f, -0.06116820f, 
    0.02849314f, 0.06992067f, 0.02731628f, -0.14140892f, 0.14177796f, -0.11648101f, 0.03042670f, -0.12355892f, 
    0.04233476f, -0.01443883f, 0.04337125f, 0.12529671f, 0.07992341f, 0.04282081f, 0.00971194f, 0.03921891f, 
    0.11900732f, -0.03476307f, -0.05826339f, -0.15712829f, 0.05467443f, 0.00705458f, 0.13809374f, -0.02507847f, 
    0.11911530f, 0.00412375f, -0.09136930f, 0.03846351f, -0.03208817f, -0.04108316f, 0.04988535f, 0.07920271f, 
    -0.76799530f, -0.00401161f, -0.15876193f, 0.04447947f, -0.01442049f, -0.00453638f, -0.04003078f, 0.13567583f, 
    0.09397941f, 0.11034793f, 0.07717925f, -0.16876040f, -0.00540198f, -0.11309601f, -0.10829117f, -0.06666684f, 
    0.00092413f, -0.05902252f, -0.18334030f, 0.09786239f, -0.02837182f, -0.01545035f, -0.06318072f, -0.02238837f, 
    0.13597293f, -0.15144692f, 0.10949941f, 0.31942800f, 0.00843984f, 0.02342086f, 0.13765381f, -0.02264637f, 
    0.14535303f, -0.05885753f, -0.02149227f, -0.01894402f, -0.03843785f, 0.00917974f, 0.32449728f, 0.27005050f, 
    0.00672006f, 0.15877800f, -0.00656612f, 0.08754697f, 0.07659597f, 0.08808272f, -0.04326220f, 0.06975766f, 
    0.04432147f, -0.07710458f, -0.15365067f, -0.09375848f, 0.07167814f, 0.00804879f, 0.04321843f, 0.09153116f, 
    0.01238011f, 0.21440904f, -0.09213161f, 0.07341619f, -0.35832343f, 0.03597535f, -0.26813290f, -0.17490137f, 
    0.00894165f, -0.01143370f, 0.02375829f, -0.06225723f, -0.11317714f, -0.00499872f, 0.07060523f, -0.02126260f, 
    -0.24411418f, -0.16166387f, -0.04494978f, -0.04406166f, 0.06576208f, 0.03433052f, 0.21679878f, 0.08664090f, 
    -0.04179909f, -0.08591554f, -0.02362334f, 0.03621150f, -0.09098930f, 0.11745505f, -0.12646422f, 0.00472338f, 
    0.09892137f, 0.00792697f, 0.04781801f, 0.20412737f, 0.06053348f, -0.09694179f, -0.06158635f, 0.12286945f, 
    -0.31908911f, 0.29052514f, -0.22326411f, -0.14561176f, 0.05897868f, 0.06790370f, 0.07698178f, 0.00241695f, 
    -0.00173225f, -0.06699823f, 0.13503169f, 0.09662694f, 0.02294142f, -0.21620043f, 0.11195587f, -0.00542018f, 
    0.04023302f, -0.02405096f, -0.02583712f, -0.16066787f, 0.04197820f, 0.07318348f, -0.18414411f, -0.09491121f, 
    0.01810041f, 0.20674826f, -0.04833628f, -0.00145796f, 0.09349898f, 0.20735915f, 0.02607991f, 0.16343740f, 
    0.09512039f, 0.07326582f, 0.07466618f, 0.01443425f, -0.06797476f, 0.15325156f, 0.03446372f, 0.00987954f, 
    0.03679390f, -0.05341839f, 0.07893942f, 0.01983419f, 0.01830393f, 0.07114895f, 0.00166251f, 0.01347670f, 
    -0.04268314f, 0.00392977f, 0.08054833f, 0.00267051f, 0.00445788f, -0.08299050f, 0.07466464f, 0.02530294f, 
    0.12078877f, 0.06101665f, 0.12119033f, 0.20757727f, 0.15474594f, -0.22802551f, 0.22503570f, 0.04201064f, 
    0.12343517f, -0.03712161f, 0.06666836f, -0.02160584f, 0.00800997f, 0.00968964f, 0.03042554f, -0.07771291f, 
    -0.14683157f, 0.13253900f, -0.03087304f, -0.03047638f, -0.01015336f, 0.08153068f, 0.00598482f, 0.01831738f, 
    0.05315643f, 0.01063013f, -0.03906867f, 0.17425409f, -0.47810000f, 0.23100834f, -0.06013320f, -0.12036698f, 
    -0.06347044f, 0.03382896f, -0.00479292f, 0.05404312f, 0.05815121f, -0.03756110f, 0.07503544f, 0.11064501f, 
    -0.18313596f, 0.24465141f, 0.01129345f, 0.06956403f, 0.09825020f, 0.08026545f, 0.01910524f, -0.02010439f, 
    0.16567408f, -0.00327360f, 0.01544088f, 0.08651567f, 0.27890679f, -0.11864206f, 0.28029737f, 0.01104870f, 
    -0.06158522f, 0.10084283f, -0.09768993f, 0.09632076f, 0.05104943f, -0.07678032f, -0.05963716f, 0.18516709f, 
    -0.05470685f, 0.10894087f, -0.14508820f, -0.10320845f, 0.13595670f, 0.02616393f, 0.03294586f, -0.02114290f, 
    -0.06289430f, -0.01999108f, 0.13407981f, -0.08127701f, 0.00772174f, -0.10692583f, -0.13834468f, -0.01795654f, 
    -0.01129707f, 0.06603866f, 0.05064689f, 0.12375323f, -0.01880513f, 0.19186796f, 0.05129264f, 0.03047024f, 
    -0.13685931f, -0.03049437f, 0.00875841f, -0.03837496f, -0.00187753f, -0.03626198f, -0.10031204f, 0.06876919f, 
    0.10495279f, 0.10497294f, 0.08505645f, -0.00818842f, 0.43432215f, 0.22447480f, 0.14681765f, 0.07566824f, 
    0.10239232f, -0.04591512f, -0.05342630f, -0.01218778f, 0.05775832f, 0.13539498f, -0.05682873f, -0.02642748f, 
    0.00491610f, 0.05558743f, 0.18852009f, 0.08041424f, 0.00094794f, 0.03991498f, 0.10135745f, 0.06101949f, 
    0.03575825f, 0.05352882f, -0.06495473f, -0.08988670f, 0.16143233f, -0.27000806f, -0.07728679f, 0.01687089f, 
    0.06656613f, 0.06718335f, 0.00596734f, -0.05257617f, -0.01568482f, -0.07955989f, 0.08194362f, -0.04381403f, 
    -0.14137201f, 0.09504258f, -0.05844845f, -0.07154351f, 0.10634269f, -0.03204187f, 0.13666101f, 0.04146432f, 
    0.11607587f, -0.02942433f, -0.07937100f, -0.03277252f, -0.25401863f, -0.06095374f, 0.10591226f, 0.09547517f, 
    -0.08317363f, 0.05436007f, 0.01883115f, 0.04547688f, 0.07460918f, -0.10155757f, 0.05153612f, 0.01648497f, 
    -0.22193980f, -0.00360401f, -0.27353269f, 0.20173733f, -0.07317894f, 0.01455042f, 0.01833327f, -0.01020256f, 
    0.01482960f, -0.07902572f, -0.14188145f, -0.09427036f, -0.19312933f, -0.10815619f, -0.23056424f, -0.09411132f, 
    -0.00853229f, 0.07217883f, 0.08719689f, -0.01466271f, 0.04998184f, -0.03201385f, -0.00863234f, -0.00153082f, 
    -0.00409265f, 0.11286940f, 0.03605881f, -0.03838777f, -0.02904616f, 0.04722217f, 0.14050506f, 0.07832480f, 
    -0.11160759f, -0.02983950f, 0.09647957f, -0.07973766f, -0.13787182f, 0.11541925f, -0.07713416f, 0.00267923f, 
    0.04539698f, -0.09446065f, 0.13516738f, 0.00802419f, -0.06036095f, -0.08753581f, -0.03787677f, 0.06105953f, 
    0.19265808f, 0.12794279f, 0.05674856f, -0.09571323f, -0.01216612f, 0.03656928f, 0.04498646f, 0.00340977f, 
    -0.01489928f, -0.04931064f, 0.03855691f, 0.15431945f, 0.35541278f, -0.04954229f, 0.19080925f, -0.18061566f, 
    0.12122091f, 0.03773301f, 0.07183209f, 0.02845052f, 0.01647951f, 0.10438552f, -0.07881127f, 0.11999141f, 
    0.01675470f, -0.15015820f, -0.05532821f, 0.29179937f, -0.20914407f, 0.07107746f, -0.18072434f, 0.02554247f, 
    -0.08396320f, 0.00001617f, 0.17186248f, 0.11286791f, -0.08190418f, -0.22456126f, -0.07260665f, 0.07281544f, 
    0.01498773f, 0.02912425f, -0.03081984f, -0.05685851f, -0.03133386f, -0.01451047f, -0.01947498f, 0.05924946f, 
    -0.03349935f, 0.40863362f, -0.02843680f, -0.19366166f, 0.07389386f, 0.02565330f, 0.01253245f, 0.06038209f, 
    -0.05077678f, -0.07429122f, 0.12293079f, 0.04425648f, 0.38564461f, -0.02317870f, 0.09552293f, 0.14307486f, 
    -0.03112460f, -0.00737176f, -0.03339172f, -0.02411308f, -0.01595049f, 0.03971619f, 0.05712269f, -0.03002767f, 
    -0.20308955f, -0.00597009f, -0.19758175f, 0.11819954f, 0.02021745f, -0.13015458f, -0.01364821f, -0.05138164f, 
    -0.10450951f, -0.06727357f, -0.02900901f, 0.00583546f, -0.08611803f, -0.15130210f, -0.09270991f, 0.08094401f, 
    0.05319609f, 0.15807310f, 0.04519829f, 0.15894349f, 0.01206885f, 0.09279805f, -0.02860999f, 0.02257892f, 
    -0.25500831f, -0.11222202f, -0.07349926f, -0.03294314f, -0.00483116f, 0.05172601f, -0.01174439f, 0.03709586f, 
    -0.10907630f, -0.04754207f, -0.03132455f, 0.03772842f, -0.22939864f, 0.21093550f, -0.10622563f, -0.00314217f, 
    -0.06109304f, 0.03284697f, 0.11833625f, 0.01712513f, -0.00356627f, 0.08207238f, -0.01008512f, -0.09249787f, 
    -0.05589742f, -0.08563488f, 0.00446530f, -0.10190482f, 0.08499013f, 0.06165044f, 0.04399705f, -0.01155289f, 
    0.07376079f, 0.04560680f, 0.08596566f, -0.09850828f, -0.07605436f, 0.21186046f, 0.01720813f, 0.22439724f, 
    0.03812078f, 0.00935901f, 0.11050310f, 0.04609971f, 0.02419453f, -0.04120687f, 0.23130016f, 0.08042376f, 
    -0.23460683f, -0.02138404f, -0.31668922f, -0.11535145f, -0.04853462f, -0.05209310f, 0.02864617f, -0.12523766f, 
    0.01454315f, 0.05236988f, -0.09012681f, -0.01815995f, -0.00702306f, -0.01275779f, 0.10144612f, -0.14121418f, 
    0.10302424f, 0.15391655f, -0.08064152f, -0.06423048f, 0.07522518f, 0.05564887f, 0.03786748f, 0.17556672f, 
    0.16482654f, 0.17187120f, 0.04233650f, 0.06252442f, -0.07311793f, 0.12314829f, -0.00577409f, 0.01017564f, 
    0.01574719f, -0.13500732f, 0.01555304f, 0.01891963f, 0.17264023f, 0.18443394f, 0.01882874f, -0.00357540f, 
    0.09051146f, -0.14566678f, -0.08695149f, 0.10523497f, -0.02256973f, -0.03074249f, -0.00006533f, 0.10217615f, 
    0.52957082f, 0.09460068f, -0.02484189f, 0.04444628f, -0.03483576f, -0.01687661f, 0.06555143f, 0.05222793f, 
    0.00823750f, -0.03428439f, 0.11664517f, -0.07602566f, 0.36407378f, -0.06310061f, -0.09264826f, 0.11138612f, 
    0.14595032f, 0.06277616f, -0.01231604f, 0.05039659f, 0.01759090f, 0.00051376f, 0.02697230f, -0.11992957f, 
    0.00913015f, -0.05236128f, 0.12976895f, 0.25935376f, 0.01030718f, -0.01984741f, -0.02744147f, 0.02181617f, 
    -0.07637405f, 0.05754510f, 0.04053453f, -0.09152051f, 0.08191402f, 0.14871624f, -0.06642158f, -0.08263267f, 
    0.07243096f, -0.05879664f, 0.04073287f, -0.01156289f, 0.13241875f, 0.06132947f, -0.00471395f, 0.04318279f, 
    0.07864883f, -0.04555855f, -0.10991094f, -0.12615874f, 0.03474151f, 0.04693798f, -0.03043030f, 0.07563388f, 
    0.03009866f, 0.02559481f, 0.02391922f, 0.00151025f, 0.24119402f, 0.00846317f, 0.07125501f, -0.10136856f, 
    0.06275236f, 0.11344164f, -0.01905618f, -0.06530211f, 0.04295285f, 0.06884965f, 0.13596061f, 0.12368780f, 
    0.06204008f, 0.05089274f, 0.10220353f, -0.15025038f, -0.10761877f, 0.14560740f, 0.09223668f, -0.09043477f, 
    0.02369921f, -0.05260335f, 0.04925281f, 0.03234908f, 0.23124450f, -0.00400296f, -0.00657461f, -0.02469096f, 
    0.10315668f, 0.02966792f, -0.05493393f, -0.07223876f, 0.12797537f, 0.04077601f, -0.06798917f, 0.07817518f, 
    0.20505568f, -0.00436058f, -0.04280557f, -0.21508071f, 0.17476656f, 0.11514003f, -0.02063138f, -0.01949433f, 
    0.06547614f, 0.01176377f, 0.03563230f, 0.10538708f, -0.15952595f, -0.22127350f, 0.09313489f, -0.20082089f, 
    0.10949020f, -0.11693680f, -0.06614605f, -0.15562062f, 0.00957656f, 0.01594996f, 0.01727350f, 0.02907503f, 
    -0.08467139f, 0.13800721f, -0.15355702f, 0.19374608f, -0.04030449f, -0.12112106f, -0.00514378f, 0.28955421f, 
    0.10401332f, 0.02240375f, 0.00270957f, -0.00077254f, 0.05755264f, 0.10181632f, -0.07483006f, -0.11767969f, 
    -0.22805136f, -0.15955190f, 0.08394123f, -0.01142075f, 0.12764752f, -0.04571870f, -0.27015245f, -0.06233806f, 
    0.10468603f, -0.05439668f, -0.16806577f, -0.11627388f, 0.15827680f, -0.06490910f, 0.00134347f, 0.00539431f, 
    -0.09544194f, 0.07589052f, -0.00981949f, 0.07665084f, 0.21747191f, -0.19117163f, 0.19243324f, 0.10499932f, 
    -0.00924121f, -0.02874744f, 0.09774278f, -0.07798399f, 0.08598374f, 0.06188289f, 0.00590745f, -0.03043837f, 
    0.23231797f, -0.22528602f, -0.19453156f, 0.16078080f, 0.07805751f, 0.07971211f, -0.01792520f, 0.10836578f, 
    0.03016864f, -0.03436743f, 0.03067626f, -0.01869519f, -0.06917693f, 0.31166315f, -0.23081842f, -0.04450354f, 
    -0.00868446f, -0.09360687f, 0.06627770f, 0.03289433f, 0.04254293f, 0.11342692f, 0.02074653f, 0.06959851f, 
    0.04261512f, -0.08963071f, 0.05906326f, -0.02348955f, 0.03903713f, 0.05804816f, -0.11867379f, 0.04301325f, 
    -0.02060528f, -0.01032367f, 0.01902892f, -0.04232399f, -0.03054772f, -0.22815423f, -0.08538651f, 0.00898368f, 
    0.17963262f, -0.06330040f, -0.02600936f, -0.02349430f, -0.08464286f, 0.11053994f, 0.00859878f, -0.00937066f, 
    0.34617841f, 0.07161434f, -0.24988970f, -0.24296840f, 0.02300410f, 0.14576268f, 0.02117570f, -0.09053594f, 
    0.02056621f, -0.09257499f, 0.03811489f, 0.09696969f, 0.04995498f, 0.20068017f, 0.16698049f, -0.09100816f, 
    0.00211986f, 0.19150314f, 0.17333338f, 0.15781337f, -0.02981558f, 0.01966582f, 0.00601612f, -0.14433615f, 
    -0.53042877f, 0.10674299f, -0.23397873f, 0.03596238f, 0.26874796f, -0.05075629f, 0.01885597f, -0.01225484f, 
    0.18372655f, 0.10769919f, 0.01439340f, -0.05183312f, 0.02588397f, 0.01604139f, -0.13574761f, -0.13427076f, 
    0.18795893f, 0.09427068f, 0.02285885f, -0.07080498f, 0.07227973f, 0.08058088f, 0.02052625f, -0.07510839f, 
    -0.08099895f, 0.15896364f, 0.21597238f, 0.29363203f, -0.07790874f, -0.07683400f, -0.12825909f, 0.10043436f, 
    0.03844110f, -0.01350801f, 0.05218310f, -0.05065087f, 0.24275455f, 0.03946511f, 0.30832839f, 0.22249745f, 
    -0.01308032f, -0.04422572f, -0.02492282f, 0.08926763f, 0.07047651f, 0.06861855f, 0.00475644f, -0.10033712f, 
    0.02678636f, 0.09193373f, 0.01886910f, -0.05898649f, 0.07966697f, 0.08257067f, -0.09695282f, -0.05913690f, 
    -0.08499878f, -0.02826012f, -0.00553775f, -0.00176112f, 0.29749116f, 0.10062172f, 0.07418900f, 0.15943992f, 
    0.03929152f, 0.12839550f, -0.05838009f, -0.05795073f, -0.20269533f, 0.10937403f, 0.09880513f, -0.05651458f, 
    0.63071692f, -0.13639285f, 0.17765452f, 0.22115351f, -0.05565873f, -0.11365017f, 0.02915314f, 0.01899125f, 
    0.04398136f, 0.00262767f, -0.10353717f, 0.09479831f, -0.19081019f, 0.26722422f, 0.14064477f, -0.09153610f, 
    0.12793261f, 0.11974911f, -0.04990053f, 0.14172877f, 0.07921049f, -0.07283040f, 0.07707345f, 0.03406048f, 
    0.02466204f, -0.07143988f, 0.03126175f, -0.06570291f, -0.07158941f, -0.07427622f, -0.04000218f, -0.12389455f, 
    0.02034949f, -0.02012800f, 0.09063447f, -0.06164359f, 0.22000705f, -0.00358230f, -0.04024236f, 0.15611118f, 
    0.06833892f, 0.00750713f, -0.01808163f, 0.01580298f, -0.08307630f, 0.05248043f, 0.05430836f, 0.03434160f, 
    -0.06877624f, -0.11815830f, -0.14214848f, -0.17303720f, 0.00340842f, 0.05717266f, 0.04771593f, -0.15052605f, 
    0.07027932f, -0.07803871f, 0.04665558f, -0.11957651f, 0.16528164f, 0.06613501f, 0.19096673f, -0.26691943f, 
    0.00771300f, 0.02748241f, 0.11802188f, -0.17431952f, 0.12012101f, 0.00810222f, 0.10021143f, 0.14891259f, 
    0.40057424f, -0.07560590f, 0.08695798f, 0.01996812f, 0.04669298f, 0.09917773f, -0.04136237f, 0.02015120f, 
    -0.00279768f, 0.04848533f, -0.02592913f, -0.02609988f, 0.23051810f, 0.09582745f, -0.22468725f, 0.02414865f, 
    -0.14388147f, 0.09557208f, 0.03031434f, 0.04597762f, -0.11062333f, 0.02290217f, 0.05498431f, -0.01901613f, 
    0.05897830f, -0.03898928f, 0.05196162f, 0.07045887f, 0.03696487f, 0.13166007f, -0.09110332f, 0.11913322f, 
    0.18926477f, -0.09808193f, 0.04244124f, -0.06284312f, 0.05845924f, 0.00970582f, 0.12891184f, -0.14632706f, 
    -0.11695989f, 0.12435935f, -0.08310056f, -0.05968801f, 0.02143642f, -0.07142008f, 0.00150879f, 0.12722126f, 
    -0.14583996f, -0.03283536f, -0.17862314f, 0.04544941f, 0.00428745f, 0.19716185f, -0.10356187f, 0.09988447f, 
    -0.03927249f, 0.14798670f, 0.07366509f, -0.05418544f, 0.06754983f, -0.09329275f, -0.17050220f, -0.13255680f, 
    -0.00100369f, 0.06121266f, 0.14338650f, -0.00480693f, -0.05021617f, 0.06271143f, 0.08123816f, 0.03973714f, 
    -0.07426792f, 0.05054589f, 0.00182262f, -0.03797036f, 0.03877026f, 0.02558237f, -0.02861667f, -0.03430917f, 
    0.11409277f, 0.03725396f, 0.01976358f, 0.01506226f, 0.36337185f, 0.30447832f, 0.31713712f, -0.07267400f, 
    0.04047092f, -0.00405215f, 0.08336243f, 0.07204140f, 0.05116848f, 0.07770925f, 0.00553059f, 0.19087131f, 
    0.32391629f, 0.26937670f, 0.06940620f, 0.13916516f, -0.00188934f, 0.02636860f, 0.07676100f, 0.06779610f, 
    -0.02450473f, 0.13943528f, -0.02927237f, 0.10500397f, -0.26180530f, -0.41663021f, 0.15537971f, -0.10438368f, 
    0.07915954f, 0.01923007f, 0.04304482f, -0.07033809f, 0.01601788f, 0.02343716f, 0.05291902f, -0.13943136f, 
    -0.01394375f, -0.16679315f, -0.03644234f, -0.07121605f, 0.13810755f, -0.01396757f, -0.11003762f, 0.13278541f, 
    0.10858975f, -0.04842027f, 0.03367158f, 0.03792895f, -0.15521488f, 0.09151157f, 0.08235922f, 0.11240945f, 
    -0.10471536f, 0.01296923f, 0.01794026f, 0.02907154f, -0.01650060f, 0.06829314f, -0.04684175f, 0.03363887f, 
    -0.18869299f, 0.07440948f, -0.24320784f, 0.04820349f, 0.07854012f, 0.07172635f, 0.05848002f, -0.01204627f, 
    0.01107858f, -0.00999177f, -0.01496307f, -0.03967834f, 0.21187593f, -0.10786311f, -0.15066639f, -0.05015691f, 
    0.13183182f, 0.09435085f, 0.01140031f, 0.06191239f, 0.05470087f, -0.13041425f, 0.13227373f, 0.02081490f, 
    0.12908132f, -0.02788569f, 0.12593669f, 0.01307075f, 0.21645568f, 0.16185437f, 0.05878349f, 0.01392832f, 
    0.09176271f, 0.01981813f, 0.08952571f, -0.11032561f, 0.30797580f, -0.24928753f, 0.06284536f, -0.08271409f, 
    0.10239922f, -0.03876489f, 0.13369371f, -0.03363888f, -0.07454915f, -0.05307632f, -0.01691177f, 0.06138884f, 
    0.24139389f, 0.12379996f, 0.09267744f, -0.12849487f, -0.14033379f, -0.02269783f, 0.09952852f, 0.01986026f, 
    0.03301961f, -0.00886110f, -0.08632421f, -0.05096859f, 0.28950828f, 0.15738626f, 0.19019429f, -0.19168651f, 
    0.08523683f, 0.00685167f, -0.01861065f, 0.12388800f, -0.00140365f, 0.10711748f, -0.11227619f, 0.01057352f, 
    -0.23177801f, -0.23365049f, -0.20061034f, 0.10404074f, -0.06098954f, -0.05922408f, 0.00276779f, 0.02921824f, 
    -0.00970183f, 0.03195061f, 0.11894852f, 0.09457435f, -0.10658886f, -0.01870101f, -0.14855073f, 0.07926593f, 
    -0.02004384f, 0.06465869f, -0.06777671f, 0.04261070f, -0.05642776f, 0.07724748f, 0.04814891f, -0.02678536f, 
    0.01700928f, 0.24701354f, 0.07370222f, -0.10111639f, 0.00677579f, 0.04153392f, 0.08444629f, 0.06081539f, 
    -0.10763531f, 0.04023479f, 0.05415027f, -0.04917192f, 0.10608862f, 0.05752056f, 0.17891088f, -0.20387329f, 
    0.03510663f, 0.05850476f, 0.02344144f, 0.02901173f, -0.06259364f, 0.04239214f, 0.08106950f, -0.13454443f, 
    -0.02235389f, -0.10811028f, -0.07582303f, 0.08904479f, 0.09030051f, -0.07833916f, -0.02959330f, 0.15349182f, 
    -0.01648809f, -0.02999520f, 0.01051740f, -0.01589155f, -0.08415965f, -0.06969890f, -0.05590980f, 0.08227973f, 
    0.08856592f, 0.13217989f, -0.10568374f, 0.06825231f, 0.03079525f, 0.08264309f, 0.04757752f, 0.16556397f, 
    -0.13095649f, -0.19875251f, -0.06748591f, -0.03954605f, 0.02519417f, 0.00980494f, -0.04875613f, -0.01493323f, 
    -0.06636726f, -0.17356551f, -0.17074363f, -0.06259181f, -0.03799062f, 0.11974393f, -0.12901697f, 0.10874019f, 
    -0.12915747f, -0.07001368f, -0.06094179f, 0.02544330f, -0.01220133f, -0.02481373f, 0.03950776f, -0.00308699f, 
    0.19337299f, 0.08053733f, -0.20105623f, 0.07319155f, 0.02433805f, 0.04258210f, 0.06473372f, -0.02827837f, 
    0.01062335f, 0.01853744f, -0.00274582f, 0.02725908f, -0.07047252f, 0.22492224f, 0.06462256f, 0.22321691f, 
    -0.04191689f, -0.08186544f, 0.11640051f, -0.05122767f, 0.05324134f, -0.08142076f, 0.10334653f, -0.06526627f, 
    0.04006523f, -0.03589138f, -0.17688636f, -0.03151857f, 0.11035924f, -0.03692734f, 0.04363556f, -0.04978050f, 
    0.05391224f, 0.08526348f, 0.08552068f, 0.03434480f, 0.29149428f, 0.02661515f, 0.07220009f, 0.00869908f, 
    0.01883703f, 0.08829447f, 0.04820421f, 0.03407590f, 0.10084656f, 0.09562863f, 0.08213316f, -0.01272471f, 
    -0.10072340f, 0.00249942f, -0.00868374f, -0.09798659f, -0.05667964f, 0.04841484f, 0.07946522f, -0.03144812f, 
    -0.09355962f, -0.13858911f, -0.13200091f, -0.01886596f, 0.21860829f, 0.14264017f, 0.14544839f, 0.06078233f, 
    -0.01564959f, -0.03217229f, 0.11071459f, 0.03558920f, -0.08040860f, -0.17883943f, 0.08276618f, 0.22270186f, 
    0.44035095f, 0.20289652f, 0.08782579f, -0.02678097f, -0.05840318f, 0.09493858f, 0.09138308f, 0.04654028f, 
    0.07446347f, -0.12007213f, 0.12137073f, -0.06158405f, 0.26505920f, -0.12747727f, -0.22981322f, -0.04349679f, 
    -0.07532665f, 0.05841020f, -0.06487557f, -0.06340875f, 0.04186416f, -0.01667690f, 0.04985682f, -0.14845271f, 
    -0.10956904f, 0.24739905f, 0.05346173f, -0.19138037f, 0.03855335f, 0.05368570f, -0.13623740f, -0.07448795f, 
    -0.07361121f, 0.02077931f, -0.08320906f, -0.01775653f, -0.30580127f, 0.22845212f, -0.08624096f, -0.10839111f, 
    0.05615682f, 0.02787247f, -0.00214936f, 0.03882103f, -0.03324035f, 0.13120879f, -0.07708938f, -0.01938631f, 
    -0.42732376f, 0.17742892f, -0.06039923f, 0.06941384f, -0.08814247f, -0.06001281f, 0.02276358f, 0.00748770f, 
    0.01681834f, -0.08919921f, -0.13760029f, 0.02102856f, -0.05827451f, -0.01036541f, 0.09727889f, -0.00389911f, 
    0.07369764f, 0.15274651f, -0.07028512f, -0.01154413f, 0.08637458f, -0.02883528f, -0.10927283f, 0.00859752f, 
    0.34682995f, -0.13577344f, -0.03847124f, 0.12626921f, -0.12570067f, -0.04386970f, 0.02309406f, -0.03864682f, 
    -0.07116877f, 0.09313441f, -0.04237184f, 0.13379791f, 0.19680433f, 0.01485048f, -0.11510492f, 0.12339254f, 
    -0.12138426f, 0.05981299f, 0.00199027f, 0.10537549f, -0.00606164f, -0.05758413f, -0.11463030f, -0.03963980f, 
    0.27778500f, 0.03424357f, -0.00360351f, 0.04011266f, 0.05922537f, 0.01920838f, -0.01044644f, -0.07414771f, 
    -0.11803699f, -0.03942173f, 0.15902567f, 0.06593791f, -0.11833537f, -0.01248214f, 0.41013139f, -0.24280778f, 
    -0.06840409f, 0.11653914f, 0.03101111f, -0.07529156f, 0.00643299f, 0.03288721f, -0.00578204f, 0.07786407f, 
    0.30162504f, 0.13901219f, -0.21021429f, 0.15410121f, -0.03445356f, 0.01717552f, -0.02839748f, -0.03037027f, 
    -0.19495569f, 0.01248021f, 0.11884384f, 0.02297242f, -0.42192575f, 0.02189251f, 0.11393005f, 0.16726923f, 
    0.05769021f, 0.09584060f, 0.08485031f, 0.04558640f, 0.02490628f, 0.00352156f, 0.00828817f, 0.04912123f, 
    0.28289604f, 0.01197207f, 0.12284537f, -0.04964086f, 0.00542238f, 0.05679816f, -0.01729933f, -0.04685785f, 
    0.11041617f, 0.01902916f, -0.11508226f, 0.09923811f, -0.29379717f, 0.01201029f, -0.10828405f, 0.17001282f, 
    -0.02105521f, 0.00993907f, -0.14967778f, -0.02478736f, -0.02471311f, 0.00992536f, 0.00261088f, -0.03047436f, 
    0.36351147f, 0.00254648f, 0.20153935f, 0.10767469f, 0.02467934f, 0.16805574f, 0.10981403f, -0.04369263f, 
    0.09650566f, 0.04635377f, 0.00813519f, -0.02884836f, 0.17575811f, 0.30565140f, 0.07244954f, -0.11024369f, 
    -0.07513005f, 0.02135169f, -0.14250399f, 0.01794756f, 0.01656960f, 0.06628435f, 0.01782433f, -0.01860273f, 
    -0.11024637f, -0.16168448f, -0.13338885f, 0.14699785f, -0.01028323f, -0.07089318f, -0.02977106f, 0.04867630f, 
    -0.05021048f, 0.01735313f, -0.05629633f, -0.07023495f, 0.03589856f, 0.23113564f, 0.05184217f, 0.00330366f, 
    0.02163353f, 0.14157148f, 0.11296086f, -0.01332441f, -0.06593972f, 0.09825999f, 0.08408746f, 0.05807837f, 
    -0.00455489f, -0.11101224f, 0.34896660f, 0.04642614f, 0.09846152f, -0.05199591f, 0.03272690f, -0.05578263f, 
    0.00875150f, -0.07837913f, -0.02077847f, 0.02308549f, 0.05267774f, 0.04526290f, 0.06023862f, -0.11139014f, 
    0.10850699f, -0.12203954f, -0.04494811f, -0.11590455f, 0.15477349f, 0.01683355f, 0.06907751f, -0.01339070f, 
    0.06654079f, 0.03515718f, -0.00815601f, 0.28673425f, -0.03884267f, -0.04902062f, 0.03350302f, 0.03064258f, 
    0.06704362f, -0.00117635f, 0.01742164f, 0.02223485f, -0.03192005f, -0.00950846f, -0.01234038f, 0.17816886f, 
    0.08449823f, -0.04551134f, 0.00528606f, 0.10665587f, 0.02032179f, -0.11897229f, -0.02308789f, 0.02080736f, 
    -0.21974935f, 0.10163848f, 0.04145445f, 0.03216403f, 0.13568951f, -0.02338285f, -0.00333084f, 0.14733230f, 
    -0.01464085f, 0.01063004f, -0.03758682f, 0.04598040f, -0.31219575f, 0.11457290f, 0.03945054f, 0.03599683f, 
    0.41183454f, 0.04392534f, 0.03534665f, 0.06695857f, 0.02253116f, -0.00090678f, -0.08606558f, -0.07438570f, 
    -0.34459639f, -0.08099137f, 0.03181975f, 0.03001531f, -0.12891009f, 0.01065438f, 0.13121484f, 0.15260100f, 
    -0.02179573f, 0.03580643f, -0.01534000f, 0.13381962f, -0.11979698f, 0.09645928f, -0.12503448f, 0.14489041f, 
    0.05861412f, -0.01166037f, 0.00706020f, 0.08131450f, -0.03610101f, 0.07057891f, -0.11572739f, 0.04339507f, 
    -0.62333935f, 0.16659687f, 0.10157099f, 0.04708085f, 0.13910347f, -0.10831042f, 0.05963276f, -0.00078206f, 
    -0.00205129f, 0.11698801f, 0.02293529f, 0.10863958f, 0.62321126f, 0.04552763f, 0.14653501f, -0.16490659f, 
    0.03465483f, 0.00320218f, -0.11050089f, 0.09203582f, 0.01947635f, 0.00593315f, -0.01732311f, 0.06846871f, 
    0.11900304f, -0.03455444f, 0.00081527f, 0.33912984f, -0.07240453f, 0.08850986f, -0.05472113f, 0.07085148f, 
    -0.04384029f, -0.01845956f, 0.02851625f, 0.02167583f, -0.25318646f, 0.43295282f, -0.15769446f, 0.05490355f, 
    0.06668929f, 0.04501782f, 0.08036000f, -0.15367208f, -0.09256998f, -0.06706928f, 0.06717728f, -0.11730857f, 
    0.18340430f, -0.26702273f, -0.06526250f, 0.15632814f, -0.18187967f, 0.02480403f, -0.12250905f, -0.04387734f, 
    0.23667599f, 0.05720311f, 0.04569416f, -0.01839865f, 0.20999099f, 0.20888069f, 0.11022000f, -0.04732548f, 
    -0.18460020f, -0.07396882f, 0.02564287f, -0.02655111f, -0.06360179f, -0.03357454f, 0.12705284f, -0.02204376f, 
    0.21062207f, -0.08688499f, 0.20341717f, -0.01363053f, 0.04565628f, 0.05016910f, -0.01773729f, -0.03880960f, 
    0.07022766f, 0.19384320f, -0.02662793f, -0.01819558f, -0.44019052f, -0.06876800f, 0.05596866f, -0.04269947f, 
    -0.05188533f, -0.04936652f, -0.06180215f, 0.01277747f, 0.04157168f, 0.00926164f, 0.04164298f, 0.14798379f, 
    -0.04089919f, -0.05378412f, -0.01789895f, -0.00238096f, -0.05401978f, -0.03883485f, 0.03912240f, -0.01372538f, 
    0.02701288f, 0.03951950f, -0.00057344f, 0.00806458f, -0.04473457f, 0.03900667f, 0.01127669f, 0.04385081f, 
    -0.02893911f, 0.03455364f, -0.01612931f, -0.03895386f, 0.01163723f, 0.00779449f, -0.00375974f, 0.01951152f, 
    0.02395705f, -0.01600100f, -0.00675713f, -0.04348341f, 0.00893974f, 0.04361341f, 0.01362626f, 0.00909173f, 
    0.03732567f, 0.01159892f, -0.04563946f, -0.00611763f, 0.03795062f, -0.03842050f, -0.00998687f, -0.00001098f, 
    -0.02110364f, 0.02894715f, -0.04198224f, -0.04064278f, 0.03744047f, -0.00182249f, 0.03406580f, -0.02850567f, 
    -0.05085320f, 0.00239605f, 0.00661955f, -0.05562488f, -0.02645035f, -0.01316837f, 0.03735268f, 0.03256586f, 
    -0.00560022f, -0.01057554f, -0.01733788f, -0.00449023f, -0.05263086f, 0.00276043f, 0.01630861f, 0.02587877f, 
    -0.02686146f, 0.01760397f, -0.04084304f, 0.04356042f, -0.03752416f, -0.02886651f, -0.04378614f, -0.05389342f, 
    0.02587183f, -0.01086052f, -0.01446071f, -0.01079694f, -0.03722531f, -0.05139028f, 0.01269250f, -0.04089106f, 
    -0.03869532f, 0.00081014f, -0.05104858f, 0.00246010f, -0.01260243f, -0.05032738f, 0.01121769f, -0.02312445f, 
    0.02623997f, 0.03516714f, 0.02780942f, -0.02028968f, 0.00908401f, 0.02596660f, 0.00983117f, -0.03813654f, 
    -0.01636397f, 0.03571920f, -0.02210731f, -0.05044721f, 0.01385044f, 0.04365627f, -0.05266614f, 0.00355514f, 
    -0.03695904f, -0.02691752f, -0.05666925f, 0.02217513f, -0.01547167f, 0.00556769f, -0.04195443f, 0.00539476f, 
    -0.00927535f, -0.01822082f, -0.03348776f, 0.03918284f, -0.03282735f, -0.03335860f, -0.00723645f, -0.02131568f, 
    -0.00508315f, 0.01730238f, -0.01932891f, 0.02712556f, 0.03482404f, 0.02852217f, 0.03586476f, 0.01774995f, 
    -0.00919562f, -0.00135672f, 0.01760661f, -0.03897935f, 0.03038977f, 0.02605418f, -0.04985116f, -0.00077739f, 
    -0.04343613f, -0.04627608f, 0.03613718f, 0.00639466f, 0.02938421f, 0.03003497f, -0.03331350f, -0.02763323f, 
    -0.03958837f, 0.01033517f, -0.02519356f, -0.01838238f, 0.03981758f, 0.02103898f, -0.00091220f, -0.02286970f, 
    -0.02454802f, -0.03898530f, -0.01767952f, 0.00526121f, 0.03265308f, -0.04099223f, -0.00330846f, -0.03375308f, 
    -0.01209582f, 0.01376916f, 0.02233127f, -0.01318055f, 0.00267084f, 0.00902553f, -0.03449509f, 0.04240894f, 
    -0.04297015f, 0.03426401f, 0.03686877f, -0.02802488f, 0.02944321f, 0.02832934f, 0.03320572f, -0.02240063f, 
    0.01469979f, 0.01547742f, -0.05175682f, -0.00786283f, -0.01824654f, -0.01790864f, -0.02470393f, -0.03072979f, 
    -0.05409917f, 0.01693721f, 0.00555568f, -0.00770066f, 0.01853193f, 0.03579861f, -0.04842683f, -0.05354737f, 
    0.01565553f, 0.03727537f, -0.01574970f, -0.01264233f, -0.00672092f, 0.00971354f, -0.01266361f, 0.03037175f, 
    -0.04996210f, -0.04830787f, 0.00001880f, -0.01392736f, 0.02086968f, -0.02630946f, -0.00057761f, -0.05296146f, 
    -0.05362873f, -0.03634392f, 0.03655179f, -0.01395203f, 0.01001293f, -0.02094840f, -0.04834151f, -0.04969962f, 
    -0.04254972f, 0.03131690f, -0.05153806f, -0.03716962f, -0.03272616f, -0.01827587f, 0.01439805f, -0.02346818f, 
    -0.01557155f, -0.02280736f, 0.00905957f, -0.05537558f, -0.04101273f, 0.01806767f, 0.00902159f, -0.05660648f, 
    -0.04476587f, 0.02857175f, -0.05680893f, -0.02944023f, 0.02245634f, 0.01260601f, 0.00867209f, -0.02655071f, 
    -0.05305886f, -0.04540491f, -0.02675944f, -0.01147264f, 0.04373524f, 0.02856187f, -0.00773078f, -0.05261657f, 
    0.02887088f, 0.04390906f, -0.01563762f, 0.03502237f, -0.03226152f, -0.05237740f, 0.04142185f, 0.01328263f, 
    0.01796653f, -0.05368787f, -0.03749211f, -0.00104823f, 0.04306428f, -0.02967326f, -0.00889803f, -0.04137764f, 
    -0.02385376f, -0.03288824f, -0.01098790f, -0.00569316f, 0.03478703f, -0.03595309f, 0.02400231f, 0.00072720f, 
    0.02859426f, 0.01275683f, 0.03035744f, -0.02044985f, -0.00873884f, -0.05157855f, 0.01804593f, 0.04137248f, 
    -0.03246919f, 0.03100060f, 0.00053583f, 0.03426485f, 0.00273627f, 0.01504738f, 0.00654022f, 0.04366640f, 
    0.01546488f, 0.01040093f, -0.00676397f, 0.00798208f, 0.00797978f, -0.04967417f, -0.03080423f, 0.01441322f, 
    -0.04458326f, 0.01742689f, 0.02185206f, -0.00584654f, -0.05444345f, -0.04547651f, 0.04331504f, 0.00739593f, 
    -0.04604647f, -0.00735221f, -0.02354626f, -0.02702138f, -0.00941638f, -0.02139629f, -0.03674748f, 0.00787086f, 
    0.02944569f, 0.01213379f, -0.00540654f, -0.01411205f, -0.04411907f, 0.00902863f, -0.03497572f, 0.00065090f, 
    -0.03578875f, 0.01148413f, 0.03824627f, -0.02423451f, -0.04836825f, -0.02957288f, 0.01299114f, 0.03563798f, 
    0.00879914f, -0.04802942f, -0.02998241f, 0.01159163f, -0.02244295f, -0.04567691f, -0.03027838f, 0.02076159f, 
    0.01483104f, -0.00800725f, -0.04309249f, 0.02801932f, -0.00833361f, -0.03558090f, 0.01655564f, -0.05689387f, 
    -0.03747696f, -0.05604868f, 0.00509392f, -0.05633017f, -0.02968243f, 0.04040864f, -0.01216187f, 0.00969359f, 
    -0.02178212f, 0.00243886f, -0.01847229f, -0.01217550f, 0.01851506f, 0.01348033f, -0.04320413f, 0.01771648f, 
    0.00915656f, 0.01980649f, 0.00069517f, 0.02589770f, -0.02456254f, -0.05286755f, -0.00323105f, -0.04399412f, 
    0.00580022f, -0.02537371f, -0.01559479f, 0.02069329f, -0.00749603f, 0.03625051f, 0.02219662f, -0.03165914f, 
    0.00389880f, -0.02111169f, -0.00209312f, -0.03290506f, 0.03714587f, 0.04307323f, 0.04091017f, 0.00816946f, 
    0.03166857f, 0.03771971f, -0.03624375f, 0.00039422f, -0.02272535f, -0.00824768f, -0.02904500f, -0.02478960f, 
    -0.01664991f, 0.01408727f, -0.04257416f, -0.01919475f, 0.02646784f, 0.01045976f, -0.00659097f, -0.02782104f, 
    -0.03765004f, -0.03239900f, 0.03282857f, -0.02985866f, -0.05244402f, 0.01991265f, -0.03161316f, -0.02256697f, 
    -0.03784477f, -0.00701275f, 0.02826181f, -0.04874199f, 0.02602015f, 0.05041165f, -0.00592316f, 0.02531552f, 
    0.00896852f, 0.03876540f, -0.05666253f, -0.01898008f, -0.01230949f, 0.01583573f, -0.05214523f, -0.05073719f, 
    -0.03773003f, 0.04124187f, -0.03759514f, 0.02308012f, -0.00147326f, 0.02600598f, -0.02096267f, -0.01691121f, 
    0.00890092f, -0.03856861f, -0.00031269f, -0.04701617f, -0.03896827f, -0.03151637f, -0.04856190f, 0.04587156f, 
    -0.03966087f, -0.03694719f, -0.01679619f, 0.02976028f, 0.03777086f, 0.03909480f, -0.03915242f, -0.01548921f, 
    -0.01256071f, -0.01589477f, -0.04747915f, -0.01508803f, -0.04361719f, 0.00800070f, -0.03916223f, -0.02228472f, 
    -0.01599109f, -0.01325392f, -0.01157949f, 0.03962121f, 0.03914722f, 0.00271008f, -0.00873472f, -0.03465121f, 
    -0.04208373f, -0.03714380f, -0.03674642f, -0.02202410f, -0.00574573f, -0.05252160f, 0.03462672f, 0.02285495f, 
    0.00981444f, 0.03075361f, 0.02826907f, 0.03529647f, 0.02774303f, -0.00288737f, -0.04223618f, 0.00347741f, 
    -0.04374351f, -0.04346852f, 0.00096018f, -0.03820208f, 0.04464334f, -0.04749948f, 0.00439546f, -0.05091370f, 
    0.01062439f, 0.01977395f, -0.05244648f, -0.03846347f, -0.02542428f, 0.00794175f, 0.01555856f, 0.00069805f, 
    -0.01570491f, -0.01345970f, 0.01956599f, -0.00591686f, -0.04190087f, 0.01647870f, -0.00148250f, 0.04873507f, 
    0.00216379f, 0.02708342f, -0.00489582f, 0.03750540f, 0.02984045f, 0.01638256f, 0.03737339f, -0.04172589f, 
    -0.02080741f, 0.02675083f, -0.03253471f, -0.01914705f, -0.01663393f, 0.01928083f, 0.01158673f, 0.02463649f, 
    -0.01541854f, 0.02969287f, 0.01819343f, -0.04970311f, -0.01166829f, 0.03878145f, 0.04498334f, -0.02234338f, 
    -0.00696511f, 0.00125083f, -0.02923128f, -0.05137681f, 0.03166463f, 0.02437163f, -0.01679592f, 0.03446610f, 
    -0.03796853f, -0.02124464f, -0.03788251f, -0.04863283f, 0.04736762f, 0.00545082f, -0.05540860f, 0.00973116f, 
    -0.02636145f, 0.01311080f, 0.03304101f, -0.05047507f, -0.05144595f, -0.02657125f, 0.02076178f, 0.02837288f, 
    0.01588542f, -0.04874494f, -0.00523020f, 0.03865496f, 0.03271285f, -0.04757565f, -0.05287515f, 0.04431957f, 
    -0.02261492f, 0.02584431f, 0.01181019f, 0.01545030f, 0.02626665f, -0.04943974f, 0.02860871f, -0.00407102f, 
    -0.00678252f, 0.04017073f, 0.02831177f, 0.04801233f, -0.04337275f, -0.03342350f, -0.04289266f, -0.04836566f, 
    -0.00778669f, 0.04594378f, -0.02625092f, 0.01064573f, -0.03608198f, 0.03436228f, -0.01700015f, 0.02023978f, 
    -0.02027764f, -0.03496766f, -0.03856011f, 0.03377216f, 0.01357652f, -0.01330249f, -0.03903049f, -0.01311426f, 
    0.01948486f, -0.02871735f, 0.00677546f, 0.01016615f, -0.01671293f, -0.01861963f, -0.00589105f, 0.02144625f, 
    0.03705016f, 0.00425958f, -0.04809610f, 0.00750750f, -0.04653592f, -0.04748138f, -0.04727346f, 0.04179277f, 
    -0.03341864f, -0.03758846f, -0.03915752f, 0.03954662f, -0.04272006f, 0.04144792f, 0.02918031f, -0.01875478f, 
    -0.04864210f, -0.00040001f, 0.03686118f, -0.01587973f, 0.01049582f, -0.04764665f, 0.00856959f, 0.03417631f, 
    -0.02687538f, 0.02359137f, 0.03604596f, -0.05113467f, -0.03182156f, 0.00125236f, 0.00656360f, -0.00683893f, 
    -0.04055066f, -0.02526469f, -0.02123093f, 0.03942870f, -0.03080834f, -0.01913908f, 0.03082597f, -0.00497027f, 
    0.04638991f, -0.01826135f, 0.01427677f, -0.01789771f, 0.02802360f, 0.04634170f, -0.00558652f, -0.04275101f, 
    0.03901636f, -0.00595772f, 0.02109298f, -0.03889119f, -0.05127843f, 0.01128861f, -0.00813415f, 0.03386939f, 
    0.03653500f, -0.01825284f, -0.00136127f, -0.01612237f, -0.02750525f, -0.00891437f, 0.04096033f, -0.02659715f, 
    0.01028624f, -0.04332915f, 0.00558946f, 0.02303154f, 0.02958046f, 0.04343494f, 0.00362967f, 0.04002162f, 
    -0.02399866f, 0.00588789f, 0.04599037f, -0.02829617f, -0.05093331f, 0.02280001f, -0.00150538f, 0.01805310f, 
    -0.03149681f, 0.03033871f, -0.03674085f, -0.00517862f, 0.01711986f, -0.05591686f, -0.03742623f, -0.03647061f, 
    0.01445662f, 0.02939915f, 0.01653770f, 0.01974787f, -0.02213217f, -0.02946400f, -0.00978164f, 0.02576203f, 
    -0.00447578f, -0.04504048f, -0.01868289f, -0.00524580f, -0.02371707f, -0.00288638f, 0.02601385f, 0.02950554f, 
    0.04124929f, 0.02616914f, -0.01781060f, 0.01132131f, 0.01927303f, 0.02132742f, 0.03715663f, -0.04921842f, 
    0.04683187f, -0.02355880f, 0.02067371f, 0.00190794f, 0.01874330f, -0.00485054f, 0.04781707f, -0.02666744f, 
    0.00150078f, -0.03129176f, -0.05336341f, -0.03184193f, 0.02645393f, -0.04589272f, 0.01218662f, -0.00497701f, 
    0.03805566f, -0.03212991f, 0.04632825f, -0.00256162f, 0.01684110f, -0.04333963f, 0.02444179f, -0.04051199f, 
    -0.03563034f, -0.01994938f, -0.01437823f, -0.04622313f, -0.01928547f, -0.03408563f, 0.02741750f, -0.02927549f, 
    0.04395349f, 0.02301750f, 0.01266010f, -0.01365377f, -0.02575176f, -0.00526610f, 0.01977018f, 0.04579990f, 
    0.03033492f, -0.01343448f, 0.01932636f, -0.01385576f, -0.01672587f, -0.02491248f, -0.00552698f, 0.00990769f, 
    -0.00353969f, -0.04866301f, 0.00062399f, -0.01817263f, 0.00755142f, -0.02341413f, 0.01681846f, -0.02752000f, 
    -0.19008997f, 0.16293882f, -0.04248216f, -0.07218277f, 0.02215227f, 0.12298437f, -0.06072011f, -0.01444862f, 
    0.17342074f, -0.01972070f, -0.01211786f, 0.06277382f, 0.20122740f, -0.09670575f, 0.29391915f, 0.06037109f, 
    0.10530237f, -0.05422712f, -0.04027179f, 0.04095130f, 0.02354446f, -0.04201438f, -0.07925651f, 0.02789801f, 
    -0.31733111f, 0.21454550f, 0.22362591f, -0.03503016f, 0.05017323f, -0.04158583f, 0.09550615f, 0.02565515f, 
    -0.04398631f, -0.09831864f, 0.04484086f, -0.00902983f, -0.14943965f, -0.10734387f, 0.10945481f, 0.13543622f, 
    -0.00189812f, 0.12037149f, -0.00496775f, 0.10561249f, 0.07348717f, -0.00665577f, -0.10346068f, 0.08295280f, 
    0.06592035f, 0.03987814f, 0.22276229f, 0.08628072f, 0.19927919f, -0.11555472f, -0.13086167f, 0.02483808f, 
    0.03633824f, 0.17942373f, 0.05633921f, 0.04203185f, 0.23150073f, 0.10145599f, 0.01026322f, -0.01249114f, 
    0.11301328f, -0.07008785f, 0.00097765f, 0.00516973f, 0.00709982f, 0.05927462f, 0.00014353f, -0.03379451f, 
    -0.23008488f, -0.09224084f, 0.14498955f, -0.01127539f, -0.04584355f, 0.03362270f, -0.03016343f, 0.05682116f, 
    -0.07114076f, -0.04272248f, -0.07754020f, -0.15484504f, 0.29044446f, -0.01790554f, -0.05167821f, 0.40087467f, 
    -0.02102375f, 0.11395308f, -0.02127477f, 0.06270737f, 0.06225335f, -0.05491275f, 0.05391038f, 0.03397625f, 
    0.10739700f, 0.13276930f, -0.01851973f, -0.12880410f, 0.14529885f, -0.00036931f, 0.03477365f, -0.06491236f, 
    0.08910014f, 0.10297625f, 0.08657420f, 0.05919712f, -0.00718613f, -0.17766930f, 0.07093066f, 0.21248306f, 
    0.06776053f, 0.07931415f, -0.02375976f, -0.03868464f, 0.07070243f, 0.03400050f, 0.24709013f, -0.03782611f, 
    -0.05852422f, -0.08502412f, 0.12236862f, 0.21898393f, -0.06428170f, 0.02086776f, 0.04930841f, 0.01108866f, 
    0.07547008f, -0.12693906f, -0.09040853f, -0.04771943f, -0.28750163f, 0.06739168f, -0.16364758f, -0.22575077f, 
    0.01786939f, 0.09417072f, 0.02781553f, -0.00667731f, -0.03433484f, 0.01413120f, 0.00099061f, -0.00319579f, 
    -0.26933506f, 0.20411582f, 0.16319320f, -0.19355939f, 0.00819386f, -0.08582208f, 0.04333018f, -0.04066052f, 
    0.03937623f, 0.00764577f, -0.00643254f, -0.04409875f, -0.09528271f, 0.14820546f, 0.02435962f, 0.05498970f, 
    0.05048129f, 0.04012629f, 0.00946453f, -0.05415273f, 0.00222610f, -0.05787273f, 0.03688259f, 0.09413593f, 
    0.15742794f, -0.01116833f, 0.08118761f, -0.34782296f, 0.08088452f, -0.00732734f, 0.05747152f, -0.04365804f, 
    0.04430863f, 0.02534473f, 0.01722138f, 0.10627147f, 0.00504410f, 0.15235932f, 0.14417872f, -0.14730881f, 
    0.03114756f, -0.02857255f, 0.00189028f, -0.01829945f, 0.04788454f, 0.02404378f, 0.01159815f, 0.06509971f, 
    -0.22564666f, -0.28148991f, 0.33768716f, 0.55603576f, -0.14212410f, -0.04407581f, -0.20258631f, 0.04944040f, 
    -0.02365265f, 0.02888100f, 0.07890925f, 0.06466873f, -0.30998904f, -0.24919210f, -0.20366855f, 0.13413258f, 
    0.10629807f, 0.02914499f, -0.14551240f, -0.17384647f, -0.03473978f, 0.02491055f, 0.05128267f, 0.15104726f, 
    0.00776449f, 0.27135742f, 0.00009744f, -0.17835900f, -0.11542586f, 0.02223820f, -0.14934704f, 0.07190868f, 
    -0.05008333f, -0.13066138f, 0.08747134f, 0.05563206f, 0.34119096f, -0.01243822f, -0.07520604f, 0.18169421f, 
    -0.01202903f, -0.06959680f, 0.04416893f, 0.06739405f, -0.07711677f, 0.05041613f, -0.01486694f, 0.10749586f, 
    -0.06180933f, 0.09059963f, -0.20976247f, -0.11770713f, 0.09447289f, -0.06617127f, 0.03376320f, -0.15391171f, 
    -0.05589957f, 0.04604005f, 0.00521741f, -0.05077993f, -0.13591008f, -0.11654384f, -0.22014254f, -0.20793012f, 
    0.04787937f, 0.18510595f, 0.15811765f, -0.07481642f, -0.01194549f, 0.02760362f, 0.04908459f, 0.04367168f, 
    -0.09000568f, -0.09271064f, -0.03801049f, 0.24215120f, 0.00627024f, -0.12470155f, 0.09346213f, 0.04414630f, 
    -0.03044030f, 0.06115964f, 0.15173434f, 0.15119909f, -0.31473136f, 0.12139650f, 0.03821404f, -0.08155144f, 
    0.02092933f, -0.08540600f, 0.13107948f, -0.04175173f, 0.12297364f, 0.08137269f, 0.01901815f, -0.06739350f, 
    -0.43388382f, 0.10405890f, 0.05090441f, 0.00240262f, 0.13695635f, 0.07010704f, 0.11753915f, -0.01175218f, 
    0.00342565f, 0.11074053f, 0.15423435f, 0.02649827f, 0.21670431f, 0.03112450f, -0.06004958f, 0.13672213f, 
    -0.10418989f, 0.03918470f, -0.02871894f, 0.00963422f, -0.05392044f, 0.04899869f, 0.04209409f, 0.01484461f, 
    -0.09512626f, 0.16800168f, -0.28471175f, -0.06940715f, 0.02102056f, -0.02070643f, 0.00400732f, -0.16632411f, 
    -0.10164313f, 0.14210364f, -0.01896430f, -0.12603216f, 0.01365295f, 0.04332360f, 0.10820659f, -0.15453888f, 
    0.00538729f, 0.10490061f, 0.01674956f, -0.03794501f, 0.02004541f, -0.00495025f, -0.07775945f, 0.09454922f, 
    0.35037166f, 0.13551825f, 0.14688325f, 0.05531709f, 0.01205000f, -0.04477175f, 0.03522687f, 0.03125225f, 
    0.03062521f, 0.04600730f, 0.00559549f, 0.03662278f, 0.03030848f, 0.21269275f, 0.05601378f, 0.10772389f, 
    0.16606921f, -0.03060332f, -0.09900519f, 0.09804022f, -0.08295965f, 0.01216638f, 0.00643625f, -0.02048547f, 
    0.16193947f, -0.00761648f, 0.10998749f, 0.12520586f, 0.04303598f, -0.02137975f, -0.03926746f, 0.03334334f, 
    0.00313457f, -0.01765047f, 0.15523726f, 0.04055728f, 0.01033732f, 0.02513761f, 0.06421425f, 0.14566460f, 
    0.22017317f, -0.06020194f, 0.10127637f, 0.05075517f, 0.08359453f, 0.08345542f, 0.04539856f, 0.06658073f, 
    -0.01890290f, -0.03673835f, 0.00163787f, 0.00318528f, 0.03621363f, 0.01946837f, -0.04074351f, -0.02143260f, 
    0.02554952f, -0.04877822f, -0.04215526f, 0.01710174f, -0.05185190f, -0.00738189f, -0.03290772f, 0.04555951f, 
    0.03221239f, 0.03802177f, -0.01264915f, 0.00508051f, 0.00940819f, -0.02982922f, -0.00960073f, -0.04345398f, 
    -0.05081740f, -0.02323435f, -0.02888175f, -0.04094217f, 0.02979525f, -0.02101662f, 0.00105369f, -0.00938595f, 
    0.00319949f, -0.02092354f, -0.00272404f, -0.04461787f, -0.01613546f, 0.01694506f, 0.02121688f, 0.01366870f, 
    -0.01600588f, -0.02059912f, -0.04759095f, 0.03772345f, -0.04483967f, -0.04448637f, -0.04902495f, 0.04419334f, 
    -0.01685175f, -0.01314593f, 0.00093906f, -0.03487025f, 0.03217252f, 0.02573785f, 0.04377762f, 0.04209324f, 
    0.04865884f, 0.02521050f, 0.00491871f, -0.04443822f, -0.05147074f, 0.04953607f, -0.00429196f, -0.02312268f, 
    -0.03656599f, -0.03083088f, -0.04528397f, -0.03364937f, -0.04370494f, -0.02063086f, -0.04960123f, -0.02360097f, 
    -0.01949591f, 0.01239275f, -0.04323800f, 0.04161478f, 0.01823007f, 0.03225480f, 0.04536125f, -0.04806577f, 
    -0.04019080f, -0.01733338f, -0.04194019f, -0.02063786f, -0.03051986f, -0.01975250f, 0.01032217f, 0.00045361f, 
    -0.00278331f, -0.00431198f, 0.05214747f, 0.04302387f, -0.03434335f, -0.02719063f, -0.00143254f, -0.03414318f, 
    0.00671844f, -0.01429330f, -0.04184542f, -0.00746236f, -0.00272727f, 0.02396183f, 0.01365145f, -0.03407583f, 
    0.03219369f, 0.02627092f, 0.02614428f, 0.02131271f, -0.05171719f, -0.02285134f, -0.00791840f, 0.00697559f, 
    -0.01544106f, 0.03520552f, -0.05376116f, 0.03227147f, -0.02429345f, 0.03596742f, 0.02867102f, -0.04391330f, 
    -0.02317338f, 0.03678638f, 0.02379017f, 0.00098604f, 0.00250179f, 0.02369558f, -0.00054624f, 0.01981230f, 
    0.01909419f, -0.04501675f, -0.00138732f, 0.02408218f, -0.04870730f, 0.03933793f, -0.05282231f, 0.00386182f, 
    -0.02548777f, -0.00997674f, -0.01569361f, -0.03430906f, 0.02429165f, 0.02437114f, 0.00098721f, -0.02846927f, 
    0.01322381f, -0.00284932f, -0.00080664f, 0.02117535f, -0.03873288f, 0.04101827f, -0.02340436f, -0.04794582f, 
    0.03062531f, 0.01500606f, -0.00369744f, -0.02830678f, -0.00329579f, 0.02471173f, -0.01972426f, -0.01776735f, 
    -0.00267091f, -0.01081730f, 0.00255898f, -0.02287506f, -0.00462032f, 0.01260037f, -0.03724458f, 0.02280733f, 
    -0.03784833f, 0.02293972f, -0.01984457f, 0.03239429f, 0.02504357f, 0.00629768f, 0.04218863f, 0.00027935f, 
    -0.02110225f, -0.04662394f, 0.03885393f, 0.02584527f, -0.00677988f, -0.01399081f, 0.02800777f, -0.05200848f, 
    0.04069146f, -0.05409044f, 0.04515853f, -0.01713736f, 0.02073362f, -0.02310196f, -0.01202844f, 0.03130862f, 
    -0.02725858f, -0.02581456f, -0.01594248f, -0.03254218f, -0.02943338f, -0.01544141f, 0.00643382f, -0.01225963f, 
    -0.00823386f, -0.02212637f, 0.03735325f, -0.01990565f, -0.01560130f, -0.04170593f, 0.03665141f, 0.02790596f, 
    0.04398954f, -0.02113626f, -0.03267698f, 0.01423495f, 0.03815884f, -0.02990220f, 0.02237819f, -0.01408860f, 
    -0.04520513f, -0.01156025f, 0.04815191f, 0.02445434f, -0.02942462f, 0.04750926f, -0.04949797f, -0.02151607f, 
    -0.04677419f, -0.03681542f, 0.00907724f, -0.01600792f, 0.04590457f, -0.02352342f, 0.01079173f, 0.03440787f, 
    -0.00374441f, 0.04910341f, 0.00230050f, 0.00240121f, -0.01513629f, 0.03907523f, -0.03692957f, -0.00724247f, 
    -0.02969608f, -0.02227685f, 0.04265608f, 0.02565663f, -0.02044326f, -0.01032246f, 0.04313089f, -0.03176693f, 
    -0.02942506f, -0.03850507f, -0.01277710f, -0.01051337f, 0.02881767f, 0.04189515f, 0.00428989f, 0.03560650f, 
    -0.00173932f, -0.05391567f, 0.01804600f, 0.00613414f, 0.02505767f, -0.04852210f, 0.01135120f, 0.02409908f, 
    -0.04103581f, 0.02407996f, -0.04749018f, -0.03314206f, 0.01469457f, 0.02512948f, -0.00325864f, 0.03982949f, 
    -0.00746012f, 0.02031094f, -0.00297564f, 0.00065098f, 0.00017899f, -0.01601539f, -0.04562756f, 0.04885881f, 
    -0.00442458f, -0.00621784f, -0.03216681f, -0.03907054f, 0.01146462f, -0.04900170f, 0.01675990f, -0.00576270f, 
    -0.03536751f, 0.00866836f, -0.05056132f, -0.04271127f, 0.01663529f, 0.00545732f, -0.05121226f, -0.01278667f, 
    -0.03939452f, 0.01351938f, -0.05179555f, 0.03799733f, -0.00748548f, 0.02739656f, 0.01965590f, -0.02165007f, 
    -0.04149992f, -0.03632908f, -0.04484181f, 0.02833376f, 0.04646790f, -0.02756276f, 0.03178950f, 0.04828127f, 
    0.00846897f, 0.04575894f, -0.05024751f, -0.02639243f, 0.05256252f, -0.00272486f, -0.01878208f, -0.03970864f, 
    0.03473355f, -0.04251214f, -0.00313767f, 0.02532889f, -0.02251875f, 0.00490972f, -0.05547564f, 0.01291614f, 
    -0.03295305f, -0.03257234f, 0.01017551f, -0.02587889f, 0.01798017f, 0.00476537f, 0.04817611f, -0.01170645f, 
    -0.01074517f, -0.00475604f, -0.02483615f, 0.04138302f, 0.04631051f, -0.00586189f, -0.02265030f, -0.04654568f, 
    -0.02344581f, 0.00210728f, -0.01074619f, 0.02964246f, -0.01361574f, -0.00547781f, -0.04000106f, 0.01851792f, 
    -0.01202286f, -0.00274477f, -0.02137950f, 0.00345779f, 0.04767042f, -0.04388864f, 0.03524567f, -0.03239953f, 
    -0.02622379f, -0.03984838f, 0.04892517f, -0.01488448f, -0.03904014f, -0.00590775f, 0.03915906f, 0.04166813f, 
    -0.03412550f, -0.03616962f, -0.02892358f, 0.02235984f, -0.04905000f, -0.02125719f, 0.02511820f, -0.01320434f, 
    -0.01163525f, -0.04489005f, 0.03300754f, -0.03631198f, 0.02427748f, 0.03774250f, 0.00023688f, 0.01375975f, 
    -0.18450788f, 0.10650061f, -0.02242466f, -0.19674690f, -0.00674292f, -0.01364874f, 0.13908845f, 0.00743092f, 
    -0.21719868f, 0.21842563f, 0.04025287f, 0.10572205f, -0.17994943f, 0.26136711f, -0.26879838f, -0.28047222f, 
    -0.03223265f, 0.06349260f, -0.00305361f, 0.01066169f, -0.16396992f, -0.05398618f, -0.31705171f, 0.00986589f, 
    0.11445108f, 0.14250226f, -0.09649548f, 0.12253046f, -0.02884544f, -0.31610084f, 0.01696299f, -0.15526584f, 
    -0.10543796f, -0.16020183f, 0.08949673f, -0.15748101f, 0.30546999f, 0.02989066f, 0.00427972f, 0.08097430f, 
    0.00422356f, 0.21084532f, 0.05855218f, 0.09522673f, 0.08207875f, -0.02179423f, 0.01552378f, 0.10507662f, 
    0.36786222f, 0.02096727f, -0.04985861f, 0.13245857f, -0.12041888f, 0.16536862f, 0.16675434f, 0.07884220f, 
    -0.03907201f, 0.21837705f, 0.12097010f, 0.15284371f, -0.15819734f, 0.00365332f, -0.07360847f, -0.08609460f, 
    0.03347611f, 0.12247387f, -0.16741626f, 0.02417692f, -0.05929005f, -0.07055343f, -0.17299110f, -0.11629303f, 
    0.10203819f, -0.03948260f, -0.27654821f, -0.16121347f, 0.04716518f, -0.13157487f, -0.16533332f, -0.11705236f, 
    -0.12350503f, 0.00377702f, 0.22850648f, 0.09521839f, -0.06959926f, 0.08174006f, 0.47657058f, -0.05117871f, 
    -0.00171869f, 0.10948071f, 0.14688955f, 0.04313056f, 0.16100742f, 0.09121647f, -0.04436358f, 0.07353653f, 
    0.22485305f, 0.05628148f, -0.15898292f, 0.28471506f, 0.00439206f, 0.05289338f, 0.15871766f, 0.18877755f, 
    -0.02099903f, 0.23147069f, 0.25957328f, 0.11937952f, -0.08168941f, 0.07648419f, 0.03534741f, -0.11213966f, 
    0.01873991f, -0.05491109f, 0.02256790f, -0.03035182f, 0.04941960f, -0.29075623f, -0.23221372f, 0.09695472f, 
    0.30652031f, -0.07917454f, 0.06868684f, 0.01499961f, 0.00492818f, -0.01080189f, -0.09846659f, 0.11505888f, 
    0.11629342f, 0.05364063f, -0.15736772f, -0.07113498f, -0.03888306f, -0.09361655f, 0.04846624f, 0.16796115f, 
    -0.03131108f, -0.08226316f, 0.06368869f, -0.02400908f, -0.07869488f, 0.14528228f, 0.04876047f, 0.01024917f, 
    0.26920587f, -0.17867814f, -0.00778888f, 0.00315157f, -0.20563041f, 0.23948690f, 0.11108712f, 0.06753798f, 
    0.03755349f, -0.04757622f, 0.08785484f, -0.07821199f, -0.12257010f, 0.31059283f, 0.00458608f, 0.15847877f, 
    -0.06329270f, 0.08632982f, 0.03549825f, 0.06102021f, -0.14179759f, 0.10478789f, 0.15314068f, 0.17674743f, 
    -0.31077135f, -0.07704857f, -0.04288585f, 0.05228015f, -0.05953553f, 0.00472498f, -0.09950527f, -0.12862737f, 
    -0.13553531f, 0.07300103f, -0.00318837f, -0.00431779f, -0.19041893f, 0.21639793f, 0.00752730f, 0.01050225f, 
    0.07075746f, 0.09000701f, 0.14507034f, -0.06102207f, -0.00848036f, 0.02196832f, -0.10873444f, -0.07313734f, 
    0.65649372f, 0.08359108f, 0.09939248f, -0.11267751f, 0.09037684f, 0.08830410f, -0.00680605f, -0.16839294f, 
    -0.11642224f, -0.10067364f, -0.06296177f, 0.13111755f, 0.39344463f, 0.18871999f, 0.10698952f, -0.31911463f, 
    0.13025035f, 0.09262953f, 0.06418146f, -0.00675467f, 0.03931687f, 0.17753272f, 0.05326027f, 0.04087134f, 
    0.11583766f, 0.09243496f, -0.00412494f, 0.07573225f, 0.00858558f, -0.07469208f, 0.01403737f, -0.10041516f, 
    -0.07661504f, 0.00032325f, -0.00558823f, 0.14254044f, -0.09608147f, 0.14759834f, -0.02992039f, 0.01263856f, 
    0.11386895f, -0.18645611f, -0.19402577f, -0.14495109f, 0.01389892f, -0.10012888f, -0.03910111f, -0.07811807f, 
    -0.08624722f, 0.03181422f, 0.09188858f, 0.22579193f, -0.00823883f, 0.00912022f, 0.02479097f, 0.13268130f, 
    -0.15010084f, -0.14755727f, 0.00685225f, -0.08718346f, -0.03398545f, 0.00549639f, -0.00482370f, -0.09410945f, 
    0.19560142f, -0.03871702f, 0.07883357f, 0.18994048f, 0.03973173f, 0.13744463f, -0.03917304f, 0.02934048f, 
    -0.09550793f, 0.12643299f, -0.10352696f, 0.06839965f, -0.09179267f, -0.12277385f, -0.11923609f, -0.03468628f, 
    0.03202889f, 0.25009489f, 0.17800318f, 0.09381345f, 0.03514232f, -0.01017922f, -0.09794562f, -0.01922084f, 
    0.07775792f, -0.12073255f, -0.00776427f, 0.03024417f, -0.07971523f, 0.12382581f, -0.11199944f, -0.19828290f, 
    -0.07979280f, 0.12309831f, 0.14351283f, -0.00088259f, 0.15187961f, -0.08595873f, 0.07300784f, 0.14490117f, 
    0.10944381f, 0.11686796f, -0.06238239f, 0.07442839f, 0.27771774f, -0.06040280f, -0.06326237f, -0.13814457f, 
    -0.04130215f, 0.21033031f, -0.01062299f, 0.14880285f, 0.10680855f, -0.01646504f, 0.18572582f, 0.20672612f, 
    0.26895770f, -0.07713370f, 0.02800030f, 0.18738422f, 0.03866009f, 0.12905648f, 0.01189309f, 0.06327240f, 
    -0.21864454f, 0.05630468f, 0.07607542f, 0.06394996f, -0.17591347f, 0.24323657f, -0.20397620f, -0.28453797f, 
    0.03157119f, -0.03157538f, 0.02251544f, -0.12156766f, -0.19855638f, -0.07590645f, 0.13455690f, -0.08800136f, 
    0.05962272f, 0.00245310f, 0.15257670f, 0.22607847f, -0.16906537f, 0.20694019f, -0.22836515f, -0.12769753f, 
    0.15775006f, -0.12301558f, 0.00247907f, -0.15558046f, -0.11354496f, 0.13819432f, 0.08629843f, -0.06386308f, 
    -0.12569544f, 0.12373350f, 0.02762796f, -0.21749146f, 0.03045357f, -0.05785346f, 0.21062823f, 0.10701916f, 
    -0.03977365f, -0.14182548f, 0.08495755f, 0.07726964f, 0.13049878f, 0.10155082f, -0.08634843f, -0.04692784f, 
    0.00040572f, 0.03941438f, -0.04254445f, -0.05660303f, -0.19399296f, -0.06692023f, 0.13674772f, -0.04826697f, 
    0.07934471f, -0.05089233f, -0.21461405f, -0.00178510f, -0.05062518f, -0.09434433f, -0.04309506f, -0.07529912f, 
    -0.07769270f, -0.01095593f, -0.01382859f, -0.02153923f, 0.07250765f, -0.04337020f, 0.13519520f, 0.00462618f, 
    -0.02357613f, -0.00577423f, 0.07705103f, 0.02979761f, 0.21080355f, -0.07253764f, -0.17507723f, -0.07278210f, 
    0.02272438f, -0.05208347f, 0.07495200f, -0.09354544f, 0.01021235f, 0.03261804f, -0.02824637f, 0.05143335f, 
    0.15079218f, -0.09033464f, -0.30113539f, -0.00837488f, -0.04356639f, -0.03712401f, 0.09429729f, -0.02579580f, 
    0.05826136f, 0.07934867f, -0.01095670f, -0.05617414f, 0.10876835f, -0.00328847f, -0.04564387f, 0.13250132f, 
    -0.17178899f, 0.00522733f, 0.04155427f, 0.12147414f, -0.00097174f, -0.07802272f, 0.05796317f, -0.09667331f, 
    -0.17516726f, -0.14149335f, -0.10437658f, -0.03554187f, -0.01830709f, 0.11241940f, 0.11455064f, -0.03950847f, 
    0.01457957f, -0.19957918f, 0.01230918f, -0.01155734f, 0.06353598f, 0.18793625f, 0.03202588f, 0.06839544f, 
    -0.06669967f, 0.01870329f, 0.02374990f, -0.02899062f, -0.13186634f, 0.06507270f, 0.00455653f, -0.05181390f, 
    0.17502172f, 0.26172838f, 0.09544778f, 0.18694271f, 0.04789955f, -0.04100405f, -0.06781652f, -0.10121331f, 
    0.10359305f, -0.00625548f, 0.04351567f, -0.00941269f, 0.23078090f, 0.15119198f, -0.21185817f, -0.08539261f, 
    -0.00142903f, 0.07135604f, 0.07093406f, -0.14329104f, 0.04101101f, -0.02863871f, -0.12952453f, 0.03977979f, 
    -0.13240872f, -0.06733704f, 0.05971374f, -0.18764120f, -0.05662496f, -0.08988695f, 0.02498697f, -0.01782494f, 
    0.02532968f, -0.07551336f, 0.05203658f, 0.11080799f, -0.27452555f, -0.06559592f, -0.00006132f, -0.21991064f, 
    -0.02941017f, -0.16956928f, -0.03506904f, 0.00570984f, 0.07580557f, -0.12843338f, -0.05179905f, -0.07982523f, 
    0.01857671f, -0.03841341f, -0.16242091f, -0.09895676f, -0.05136960f, -0.04580822f, -0.05314807f, -0.06778635f, 
    -0.06304887f, 0.09123263f, 0.00905232f, -0.08628941f, 0.05785888f, -0.02270135f, 0.19497414f, -0.12098071f, 
    -0.01075732f, -0.08563544f, -0.06804352f, 0.00600852f, 0.00687746f, -0.06937595f, -0.00170013f, -0.07969233f, 
    0.17955190f, 0.10789167f, 0.00387466f, 0.37591648f, -0.02966372f, -0.03232482f, -0.02251220f, 0.07806833f, 
    0.01095021f, 0.00304835f, -0.08742060f, 0.02763227f, 0.02227226f, -0.14599460f, -0.09047528f, -0.16125329f, 
    -0.00588237f, -0.04861670f, -0.10794200f, -0.03602466f, -0.05724540f, -0.01962118f, 0.10019617f, -0.01737034f, 
    0.20874649f, 0.12345985f, 0.05144971f, 0.36585182f, 0.04815378f, -0.11259781f, 0.02281872f, 0.03496335f, 
    -0.04998012f, 0.15221806f, -0.05991810f, -0.00480624f, 0.19688973f, 0.13138907f, -0.08073026f, 0.25057539f, 
    -0.10749720f, 0.03652142f, 0.04967855f, 0.04006500f, -0.03218646f, -0.04403615f, 0.01652318f, -0.05491055f, 
    0.50790030f, 0.19807065f, -0.08227777f, -0.17424369f, 0.06476745f, 0.05256282f, 0.06387790f, 0.00750910f, 
    0.05992626f, 0.02287634f, -0.12948322f, -0.07004665f, 0.31683263f, 0.08340036f, 0.01753922f, 0.20939375f, 
    -0.07026735f, 0.11909523f, 0.02916276f, 0.10144893f, 0.00279749f, 0.01117105f, 0.08284248f, 0.06587420f, 
    0.16179271f, 0.09706833f, 0.19963090f, 0.10237579f, 0.04135621f, -0.04347981f, -0.16267654f, 0.01080899f, 
    -0.04467078f, 0.10973184f, 0.06408223f, 0.01761250f, -0.02592064f, 0.02287445f, 0.10723770f, -0.14659102f, 
    -0.08579209f, -0.07206633f, 0.02412364f, -0.01988832f, 0.13095467f, -0.02974409f, 0.05286073f, -0.04471370f, 
    0.04173460f, 0.08262753f, 0.05705118f, -0.12777543f, -0.11109718f, 0.09650081f, -0.00320352f, -0.00905971f, 
    0.06591339f, 0.01791553f, 0.09551016f, 0.01655850f, 0.31337366f, 0.17698178f, 0.15935537f, 0.11942754f, 
    -0.09432110f, -0.06445445f, -0.06202857f, 0.00893547f, -0.05948675f, -0.01655634f, -0.01770756f, 0.16012520f, 
    0.17812349f, -0.02958642f, 0.00834745f, -0.36868021f, 0.07140302f, 0.02859229f, -0.00585465f, -0.06036735f, 
    -0.10365298f, -0.03974267f, 0.02870566f, 0.03147002f, -0.02961816f, -0.08949671f, -0.03662219f, 0.00624844f, 
    -0.01115153f, 0.02505035f, 0.06221338f, 0.00264762f, -0.11242226f, 0.14287934f, 0.12361391f, 0.02221802f, 
    0.20698504f, -0.10535527f, 0.24205163f, -0.11576712f, -0.11484378f, 0.06315096f, -0.10900947f, 0.05864681f, 
    0.06904566f, -0.04772890f, -0.09316491f, -0.04633272f, -0.17045762f, 0.14008236f, -0.08544569f, 0.03525780f, 
    0.02855611f, 0.13216779f, 0.00010586f, -0.06077126f, -0.07443805f, 0.01081309f, 0.03828022f, 0.01104157f, 
    -0.21527067f, -0.20908937f, 0.02597895f, 0.01155710f, -0.03531899f, -0.11982795f, -0.06113879f, 0.06324681f, 
    0.03191909f, 0.01584844f, -0.02353362f, 0.01684352f, 0.27480790f, -0.08070241f, -0.04813875f, 0.26256511f, 
    -0.20083733f, 0.02923643f, 0.13370509f, 0.01284272f, 0.03237072f, -0.00747239f, 0.15329771f, -0.03746907f, 
    -0.23024674f, -0.06581219f, -0.00143572f, -0.04609215f, 0.14948976f, 0.03719659f, 0.00012934f, 0.07192111f, 
    -0.03411280f, -0.06173773f, 0.02365504f, -0.04608931f, -0.24401122f, -0.02435755f, -0.18071519f, 0.19428708f, 
    -0.05776886f, 0.02017882f, -0.02106057f, 0.04303789f, 0.07759531f, 0.00715540f, -0.05781412f, -0.06581897f, 
    -0.14067659f, 0.14218169f, 0.07840625f, 0.08689655f, 0.04320554f, 0.02131990f, 0.08777636f, -0.01802395f, 
    0.00222972f, 0.06675221f, 0.00753333f, -0.05827928f, 0.12664664f, -0.16346420f, -0.04354504f, 0.08526207f, 
    -0.11388409f, -0.02271282f, 0.06923517f, -0.11106999f, 0.03950269f, 0.11989926f, 0.01152029f, 0.02673990f, 
    0.15560861f, -0.11555044f, -0.09094571f, -0.01873939f, -0.07573763f, 0.07293834f, -0.01752084f, 0.09313708f, 
    0.13513167f, -0.13806492f, 0.11548442f, 0.01422783f, 0.00700708f, -0.04922403f, -0.19398265f, -0.17833613f, 
    -0.05282216f, -0.06669243f, 0.00157806f, -0.09872705f, 0.07136048f, -0.07032846f, -0.00377633f, 0.03250730f, 
    -0.03737173f, -0.01628737f, -0.22067012f, 0.12262586f, -0.02346304f, 0.10673594f, 0.01109177f, 0.03956533f, 
    0.05044480f, 0.21438864f, 0.01053769f, -0.01555245f, -0.08453119f, -0.01432219f, -0.13889322f, 0.04630442f, 
    0.01130894f, -0.04147052f, 0.17242372f, -0.00998255f, -0.11207762f, -0.01992782f, 0.09238957f, -0.12928827f, 
    -0.17849503f, -0.02283934f, -0.14877844f, -0.06861427f, -0.02214859f, 0.04337893f, 0.07170170f, -0.03864843f, 
    0.02743185f, -0.13706623f, -0.06169592f, 0.08420416f, 0.21650954f, 0.24028754f, 0.15196514f, 0.12046229f, 
    -0.15964477f, 0.04467878f, 0.02239998f, -0.04379499f, 0.00276667f, 0.03066347f, -0.00350404f, 0.08412046f, 
    0.44449925f, 0.31463900f, 0.04857684f, 0.23634824f, -0.06238868f, -0.02637850f, 0.05005663f, 0.01897444f, 
    -0.03211115f, -0.00471541f, 0.00585992f, 0.06437869f, 0.10030603f, 0.01279463f, -0.13448121f, -0.16205232f, 
    0.05183440f, 0.00352833f, 0.04370407f, -0.01472633f, 0.02545934f, 0.06392892f, -0.04501092f, -0.10243046f, 
    -0.09986033f, -0.17835273f, 0.13031131f, -0.11248396f, -0.01946656f, 0.08585467f, 0.00943053f, -0.01138984f, 
    -0.02457210f, -0.04952051f, 0.00921612f, 0.10084718f, -0.19682233f, 0.03440275f, 0.11355852f, -0.02074097f, 
    -0.05158111f, -0.10526279f, 0.00390478f, 0.00304731f, 0.02103075f, -0.07277359f, 0.06475325f, 0.00087546f, 
    -0.09789161f, 0.18524460f, -0.19736047f, -0.11411425f, 0.12385105f, -0.01502170f, -0.08563542f, -0.14532869f, 
    -0.02858810f, 0.03520572f, 0.02425468f, -0.10441413f, 0.04400871f, -0.01226329f, 0.04036682f, 0.10103367f, 
    0.06453499f, 0.01032592f, -0.12000681f, 0.10231734f, -0.06736667f, -0.12165097f, 0.12037549f, 0.05334209f, 
    0.13219011f, 0.07689115f, 0.07197756f, 0.23848900f, 0.06301784f, 0.02910089f, -0.07759744f, -0.05849129f, 
    0.10754600f, 0.02687129f, -0.01322510f, 0.01242972f, 0.28199342f, -0.40978283f, 0.05871489f, -0.17488343f, 
    0.03509931f, -0.06897988f, -0.04149363f, -0.02730452f, -0.05994448f, 0.00419341f, 0.05335069f, -0.03917992f, 
    0.26435053f, 0.19186942f, 0.01602625f, 0.42902943f, -0.14754169f, -0.15410867f, 0.03710159f, -0.01675675f, 
    0.08724213f, 0.07739040f, -0.01376056f, -0.06986891f, 0.46238172f, 0.12387672f, -0.05834992f, 0.27687755f, 
    -0.10382665f, 0.05534121f, -0.00873375f, 0.05944419f, -0.02400664f, 0.05383643f, 0.06859888f, -0.03790919f, 
    0.17673287f, 0.15795462f, -0.26300710f, -0.26022652f, 0.08394040f, 0.04282311f, 0.13672797f, -0.04636269f, 
    0.03605781f, -0.00899630f, -0.12645993f, -0.08723244f, 0.14854302f, 0.01282265f, -0.02087262f, 0.16154397f, 
    0.03018392f, 0.05462256f, -0.01734733f, 0.07411609f, 0.01683438f, 0.03689915f, 0.07919342f, 0.00281816f, 
    0.47968102f, 0.03568557f, 0.31199676f, 0.26118466f, -0.18509044f, -0.05183838f, -0.09611769f, -0.00665124f, 
    -0.01536613f, 0.11731694f, 0.10145384f, -0.07034966f, -0.13169701f, -0.00830072f, 0.31363276f, -0.09948954f, 
    -0.08715653f, -0.01174811f, -0.08921784f, -0.00519008f, 0.07308874f, 0.01871527f, -0.01475890f, -0.11988141f, 
    -0.05483636f, -0.02975097f, 0.03881729f, -0.03556180f, 0.05417624f, 0.04285762f, 0.08938616f, 0.15733276f, 
    0.14397869f, 0.07875778f, 0.11119571f, 0.00926458f, -0.08810211f, 0.00780733f, 0.06247028f, 0.03905226f, 
    0.02639666f, 0.04312812f, -0.10693745f, -0.06644292f, -0.04757289f, -0.00345540f, 0.03757624f, 0.22388078f, 
    -0.04118081f, -0.04070961f, 0.02762190f, -0.33352828f, 0.10982844f, 0.07620880f, 0.04630264f, -0.00975428f, 
    -0.19499087f, -0.12034462f, -0.15928940f, -0.10537420f, -0.01399836f, -0.09567852f, -0.01106080f, 0.11699194f, 
    0.03137808f, -0.05168452f, -0.10892706f, 0.07926303f, -0.07640550f, 0.04264669f, 0.07774608f, 0.01463159f, 
    -0.02381332f, -0.02125727f, 0.02718943f, -0.18527389f, -0.10840986f, 0.03875599f, -0.03665620f, 0.01672645f, 
    -0.02740796f, 0.07281058f, -0.01988964f, 0.02557479f, -0.08907176f, 0.03141708f, 0.03110120f, 0.11302781f, 
    0.01075915f, -0.00663587f, 0.10034508f, -0.10927465f, 0.03518336f, 0.06302599f, 0.04251885f, 0.01781575f, 
    -0.10651516f, -0.09331100f, 0.14326066f, 0.20275179f, 0.08846871f, 0.00254621f, -0.01372216f, 0.12739874f, 
    0.15312913f, -0.03057115f, 0.12047800f, 0.09557098f, 0.23794283f, -0.08557606f, -0.05619997f, 0.25800774f, 
    -0.06898842f, 0.03562978f, 0.13836040f, 0.08794039f, 0.12391012f, 0.01506138f, 0.02460329f, -0.01124309f, 
    -0.20635487f, -0.18354045f, -0.03293251f, 0.02886621f, 0.08550858f, 0.01708021f, 0.04826502f, 0.02160071f, 
    -0.02225490f, -0.09013214f, -0.08051515f, 0.09441262f, 0.15826231f, -0.09147283f, -0.17593738f, 0.21753854f, 
    -0.21201740f, -0.02700224f, 0.06587221f, 0.08103886f, -0.00787474f, -0.02333895f, 0.00177720f, 0.08085949f, 
    -0.07352872f, 0.25770584f, 0.02403788f, 0.02117008f, -0.05794118f, -0.05067232f, 0.12824771f, -0.06585645f, 
    0.03617086f, -0.05529096f, -0.04561110f, -0.01898271f, -0.20627847f, -0.18238302f, -0.05527274f, 0.00937676f, 
    -0.10424571f, 0.03243728f, -0.05754992f, -0.15706389f, -0.00903432f, -0.00490407f, 0.06269039f, -0.00192880f, 
    0.04394241f, 0.03560940f, -0.02287927f, -0.05565711f, -0.03245684f, -0.01411735f, -0.04263125f, -0.05647111f, 
    -0.02783166f, -0.02900348f, -0.00803364f, 0.00545607f, -0.00024521f, -0.02639071f, 0.01702502f, -0.02712685f, 
    -0.04568082f, 0.03042980f, 0.02170339f, -0.02143909f, -0.03637626f, 0.02618191f, -0.05745964f, -0.00138206f, 
    -0.03900711f, 0.02838271f, 0.02919841f, -0.04320618f, 0.04916745f, -0.05165867f, 0.00235666f, 0.03075515f, 
    -0.01995029f, -0.00602810f, -0.03303193f, 0.03278213f, 0.03423180f, -0.03398305f, -0.00143399f, -0.05414799f, 
    -0.05320765f, -0.01410041f, 0.00329300f, 0.00858121f, -0.01817663f, -0.02134237f, -0.00790585f, 0.00872348f, 
    -0.05700798f, 0.03167415f, 0.03719749f, -0.05666914f, 0.03097851f, -0.00502596f, -0.03515124f, -0.01198041f, 
    -0.04054239f, 0.03816217f, -0.01913471f, -0.03490752f, 0.01804133f, 0.01697886f, 0.04787891f, 0.01786617f, 
    -0.03236046f, -0.01708940f, 0.03608454f, 0.03214861f, -0.04423643f, -0.03798902f, 0.02836907f, -0.04289541f, 
    0.01763292f, -0.00409386f, -0.02274093f, 0.02532401f, -0.04724025f, 0.01479385f, 0.00943541f, -0.00830996f, 
    -0.05100151f, 0.04039900f, -0.04226298f, -0.00947637f, -0.03766500f, 0.00825381f, 0.01598727f, -0.05900374f, 
    -0.00246470f, 0.02261629f, 0.00650016f, -0.03638666f, 0.01915147f, -0.06405047f, 0.02254949f, -0.04221545f, 
    0.03880880f, -0.06084144f, -0.03771342f, -0.00150291f, -0.00993357f, -0.05234984f, -0.03815510f, -0.02845540f, 
    -0.03627981f, -0.01726649f, -0.05240090f, -0.03410785f, -0.03930259f, -0.06316312f, 0.01640612f, 0.03483193f, 
    -0.01905427f, 0.03554657f, 0.03253763f, 0.03502285f, 0.03993191f, -0.05917110f, -0.00766804f, -0.02479218f, 
    0.00764585f, 0.01157440f, 0.04264133f, -0.03510826f, 0.02468517f, 0.00909534f, 0.03721763f, -0.01721576f, 
    0.01306195f, 0.04004947f, -0.05396995f, -0.02813980f, -0.00141732f, 0.01430937f, 0.02452536f, 0.03378499f, 
    -0.05126008f, -0.00571698f, -0.04449377f, -0.00775329f, 0.01272407f, 0.03496827f, -0.02332828f, -0.03973789f, 
    0.03037146f, 0.03490046f, 0.01597460f, -0.04096800f, 0.01921658f, 0.03880044f, -0.02581809f, 0.03923652f, 
    0.04006171f, 0.03179646f, -0.04228859f, -0.01793520f, 0.03788502f, 0.03115696f, 0.01243853f, -0.00616774f, 
    -0.02796250f, -0.06071001f, 0.00488026f, 0.02606546f, -0.01252869f, -0.01682191f, -0.04580568f, -0.02549051f, 
    -0.02372185f, -0.00077821f, 0.00277058f, 0.03460277f, -0.04491030f, 0.00352775f, -0.01079357f, -0.02230584f, 
    -0.03075548f, -0.00669735f, -0.03656163f, -0.01655688f, -0.01742229f, -0.02182471f, 0.01409119f, 0.01332696f, 
    0.02744014f, -0.04966471f, -0.02079753f, -0.00942143f, -0.00625511f, -0.00971670f, 0.03251491f, -0.01989839f, 
    0.02225007f, -0.00778057f, 0.03307172f, 0.03152367f, 0.01137279f, 0.01116920f, 0.00009280f, 0.01962952f, 
    -0.03720042f, -0.03514627f, -0.05137036f, -0.03812692f, -0.04769346f, 0.03789220f, -0.00149523f, 0.01150100f, 
    -0.01575275f, 0.04199211f, 0.02497381f, 0.04267929f, 0.03639769f, 0.02101478f, 0.00750963f, 0.03508052f, 
    -0.01822556f, 0.00597672f, 0.01002630f, 0.03521833f, 0.04183698f, 0.01007242f, -0.01854105f, 0.03113860f, 
    -0.04673406f, 0.04233033f, -0.03024459f, -0.00127941f, 0.05064989f, 0.01078302f, 0.01071954f, -0.03644470f, 
    -0.01544488f, 0.03643002f, -0.03390052f, -0.01923065f, 0.03551237f, -0.03932825f, 0.00842975f, -0.03138966f, 
    0.03013611f, -0.00707672f, 0.02134434f, -0.01174468f, -0.03710091f, -0.02023115f, 0.01872366f, 0.00500288f, 
    -0.01811006f, -0.04197428f, 0.01160180f, -0.00871156f, -0.03038956f, -0.04322814f, 0.02186410f, 0.00710091f, 
    -0.02082891f, -0.05025572f, -0.04066182f, -0.01134104f, -0.05165149f, -0.01123520f, 0.04216643f, -0.04486630f, 
    -0.01318083f, -0.02361085f, -0.04480862f, 0.02575867f, -0.02099129f, 0.03143837f, 0.02949986f, -0.04772433f, 
    -0.02293664f, -0.02963639f, 0.03253478f, 0.02257532f, 0.03861425f, -0.04436340f, -0.03266995f, -0.01591989f, 
    -0.00281647f, 0.02192222f, 0.02526794f, 0.00074988f, 0.01020071f, -0.04955968f, 0.01386749f, -0.02221463f, 
    0.00522215f, -0.06095395f, 0.00728663f, -0.01914142f, 0.00848847f, -0.01858451f, -0.03150731f, 0.03857616f, 
    0.01471937f, -0.00202632f, 0.03481777f, -0.04319542f, -0.03145579f, 0.03369978f, -0.00431158f, 0.01274689f, 
    -0.02667227f, -0.04872314f, -0.05042909f, -0.04609152f, -0.01075744f, -0.00622483f, 0.03617458f, 0.03408316f, 
    -0.02102072f, -0.03080308f, -0.01069792f, -0.00940660f, -0.00408210f, -0.02409650f, 0.01536844f, -0.04022455f, 
    0.04242647f, -0.00304666f, -0.03559783f, 0.02295173f, -0.04838281f, -0.04446936f, -0.03587484f, 0.04678760f, 
    -0.01452289f, 0.01723089f, 0.00213389f, -0.01651410f, 0.01418705f, 0.01429924f, 0.02466238f, 0.01009603f, 
    0.02749700f, -0.04392954f, 0.03553231f, 0.02562459f, -0.00120210f, 0.01399946f, -0.00848536f, 0.00353714f, 
    -0.04570501f, 0.01976119f, -0.04706924f, -0.00635126f, 0.00097454f, -0.04874055f, -0.04025760f, -0.05420311f, 
    0.03939454f, -0.05637879f, -0.00812145f, 0.03375735f, -0.04593583f, -0.03376608f, 0.00937424f, 0.00725205f, 
    -0.05148115f, 0.03281444f, -0.03228575f, 0.01468039f, 0.03324855f, 0.02820981f, 0.03182209f, -0.02197438f, 
    -0.01918366f, 0.01142245f, -0.03825121f, 0.02701979f, 0.03891065f, -0.03140991f, 0.01952077f, -0.03032884f, 
    0.02900996f, 0.03760156f, 0.00193004f, 0.01589142f, -0.04631337f, -0.05077147f, -0.04724310f, -0.02477448f, 
    0.09079499f, 0.33426514f, 0.01456573f, 0.02485110f, 0.06933038f, -0.02942187f, -0.10100512f, 0.04306278f, 
    0.07389630f, -0.01935979f, -0.09341019f, -0.04826038f, -0.03105325f, 0.08529656f, 0.16208364f, 0.20472109f, 
    -0.00625841f, -0.04988239f, 0.00935134f, 0.01399880f, 0.01785325f, 0.13329606f, 0.10208349f, -0.08116029f, 
    -0.04453857f, -0.19362170f, -0.22739926f, 0.03506667f, -0.02482142f, 0.04152365f, 0.00086315f, 0.09117103f, 
    -0.05207193f, 0.07293605f, 0.06758116f, 0.16134872f, 0.30065668f, -0.20529240f, 0.02784156f, -0.06109961f, 
    -0.03062458f, 0.08645025f, -0.17714778f, -0.02424071f, 0.13081163f, 0.00135611f, 0.02734753f, -0.03336675f, 
    -0.06839757f, 0.18736607f, 0.06203775f, 0.16048297f, 0.02544515f, -0.02876153f, 0.02504077f, -0.14630686f, 
    0.03453511f, 0.00724305f, -0.05893210f, -0.06482672f, 0.38766718f, -0.00956974f, -0.07889687f, -0.03029160f, 
    0.12428360f, 0.03662555f, -0.01839855f, 0.02913664f, 0.08017392f, 0.14087577f, -0.00036627f, 0.00287487f, 
    -0.13868608f, -0.00183742f, 0.13921000f, -0.11945600f, 0.10286693f, 0.14907506f, -0.05402338f, -0.05381818f, 
    0.17672190f, 0.00708245f, -0.02386432f, 0.05223564f, -0.22273208f, 0.02496213f, 0.04241140f, -0.30894881f, 
    -0.05013182f, -0.06300785f, 0.03973611f, -0.15496200f, 0.14891541f, -0.04069542f, 0.04564928f, 0.15751848f, 
    -0.05243868f, 0.21983476f, -0.13880219f, -0.07030279f, 0.08594872f, -0.01722127f, -0.04332321f, 0.08388847f, 
    0.09374115f, -0.14067657f, -0.03352753f, -0.09081756f, -0.08637786f, -0.18176968f, -0.13957474f, -0.05769284f, 
    -0.07164934f, -0.12429000f, 0.04119683f, -0.02401141f, 0.16329825f, 0.16856846f, 0.08066780f, -0.14371359f, 
    -0.10311655f, -0.06977832f, 0.00967521f, 0.06658267f, -0.07688506f, 0.05933967f, 0.00165969f, 0.07447238f, 
    0.05995685f, 0.03926919f, -0.08284459f, 0.25421014f, -0.04034751f, -0.03910384f, 0.02622918f, 0.12561390f, 
    0.07068561f, 0.01791878f, 0.02432576f, -0.00454784f, 0.13693605f, 0.08502464f, -0.13532585f, 0.07064527f, 
    0.40057945f, -0.02433799f, -0.17003512f, 0.10284052f, 0.12183592f, 0.00247850f, 0.09522961f, -0.21764877f, 
    0.02004237f, 0.10356513f, -0.06411802f, -0.08941291f, -0.20317943f, 0.22074656f, -0.11842132f, -0.06715778f, 
    -0.03705167f, 0.05850203f, 0.08788151f, -0.24370782f, 0.24422526f, -0.13646644f, 0.08214881f, -0.10252546f, 
    0.19179206f, -0.21256071f, 0.02608235f, -0.09847485f, 0.18384461f, -0.02681982f, -0.13882530f, 0.02496219f, 
    -0.02220574f, -0.06466057f, -0.02225627f, 0.03644571f, -0.07813944f, -0.17821737f, 0.00602285f, -0.02121006f, 
    0.14890191f, -0.10352241f, -0.17475982f, -0.10618948f, 0.05634672f, 0.06068324f, -0.05731723f, 0.18581264f, 
    -0.12919202f, -0.29898131f, -0.05381928f, 0.16840197f, -0.03878894f, 0.05007641f, -0.04437311f, -0.03463094f, 
    0.03457475f, -0.00208530f, 0.10647629f, 0.08067698f, -0.04456146f, 0.10310389f, -0.01443863f, 0.06692956f, 
    -0.11731111f, -0.01598883f, 0.11486772f, -0.01123147f, -0.02892669f, -0.03904582f, -0.06076775f, 0.03190738f, 
    -0.61346638f, 0.19385187f, -0.16881019f, -0.26659530f, 0.18672611f, -0.00901784f, -0.02066383f, 0.10309339f, 
    0.06848296f, 0.08039262f, -0.01341871f, -0.03073408f, 0.26611525f, 0.20665500f, -0.24496369f, -0.09916434f, 
    0.07412552f, 0.05016155f, 0.05868790f, -0.02942013f, 0.13828874f, 0.18831903f, 0.10005310f, 0.27404326f, 
    0.01452562f, 0.16819002f, 0.00089475f, -0.01906081f, 0.01525305f, -0.01373538f, -0.11769348f, 0.02377876f, 
    -0.02783101f, 0.03384581f, -0.01793542f, -0.00022989f, 0.43792906f, 0.19366176f, 0.09464759f, 0.11151751f, 
    0.02174571f, 0.03376249f, 0.01893087f, 0.18314314f, 0.07926197f, -0.07592374f, -0.00219795f, -0.10574409f, 
    -0.07420044f, 0.04661095f, 0.09681079f, -0.03621381f, 0.01322165f, 0.05988639f, -0.02583218f, 0.09949230f, 
    0.11438483f, -0.00445106f, -0.07091524f, -0.08954538f, 0.05350314f, 0.14010777f, -0.01483757f, 0.05050328f, 
    0.03863711f, 0.06506019f, 0.04463523f, -0.08166271f, 0.02328345f, 0.06902657f, 0.19619612f, 0.01514075f, 
    0.19094293f, -0.03813073f, 0.17677858f, 0.24291229f, -0.05101588f, -0.08629306f, -0.01840933f, -0.06579434f, 
    -0.00644811f, -0.00697746f, 0.06057573f, 0.04182249f, 0.13441880f, 0.16859403f, 0.09805157f, -0.16168010f, 
    -0.06743688f, -0.03742517f, -0.12984933f, 0.05488902f, -0.06214047f, -0.18037494f, -0.03997457f, -0.02938903f, 
    -0.12224830f, -0.04476976f, -0.14750157f, -0.04005710f, -0.14318340f, -0.03550653f, 0.09528255f, -0.18009549f, 
    -0.00063850f, -0.06414834f, -0.10652836f, -0.09659959f, 0.12106125f, 0.23061015f, 0.00714462f, 0.12471690f, 
    0.17402403f, 0.01231101f, -0.15374219f, 0.09193754f, -0.01520762f, -0.03885146f, 0.02948803f, 0.11314708f, 
    -0.01071563f, 0.10701987f, 0.07784293f, -0.19971615f, 0.08872062f, -0.16934840f, -0.07350696f, -0.02081676f, 
    0.04523861f, 0.08219805f, 0.02486209f, 0.12812021f, -0.18815656f, 0.07135438f, 0.43984658f, -0.05768840f, 
    0.09950010f, -0.19310203f, -0.02295423f, -0.01856464f, 0.03264018f, 0.10061033f, -0.09342599f, 0.06435048f, 
    0.56416225f, -0.29884395f, -0.05380584f, -0.08980186f, 0.14993614f, 0.11364874f, -0.06895811f, -0.08194111f, 
    0.00932080f, 0.05805739f, 0.08174263f, 0.01226663f, 0.52074075f, 0.03589701f, -0.31775373f, -0.02735034f, 
    0.03725378f, 0.12278584f, 0.08979292f, -0.04108961f, 0.09435306f, 0.12409554f, 0.13252607f, 0.14693181f, 
    0.08749852f, -0.20171431f, 0.03473581f, 0.27417633f, 0.05849069f, -0.02287599f, 0.10219318f, 0.12070090f, 
    0.02377819f, 0.10454521f, 0.04846746f, 0.05320177f, 0.43093979f, -0.10268858f, 0.09736863f, -0.08447269f, 
    0.17233282f, -0.05893261f, 0.00386247f, 0.03246461f, 0.20192111f, -0.03821471f, 0.05012242f, 0.02280921f, 
    -0.11939908f, 0.14064462f, 0.25664487f, -0.24945217f, 0.05785991f, -0.00518539f, 0.09003330f, -0.04293393f, 
    0.00315166f, 0.07302454f, 0.02996911f, -0.04208539f, 0.05716622f, 0.01228575f, 0.07976308f, 0.13279788f, 
    0.15561421f, 0.14927065f, 0.05559278f, -0.02663418f, 0.04700992f, 0.04409431f, 0.08836861f, 0.18563983f, 
    0.13503402f, -0.00311623f, 0.28309223f, -0.18815346f, 0.13575035f, -0.04169404f, 0.02576758f, 0.13123356f, 
    0.11094189f, 0.03722852f, 0.17389764f, 0.10103317f, 0.03681148f, -0.14956860f, 0.12358826f, 0.04025633f, 
    0.10821855f, -0.05645758f, -0.01911452f, -0.06814238f, 0.03783853f, 0.01573488f, 0.15323438f, 0.01681745f, 
    -0.03235425f, -0.12977448f, -0.00648618f, -0.05101014f, 0.10856504f, 0.04170343f, -0.03817749f, 0.09078941f, 
    0.00984283f, 0.04685646f, -0.07344778f, 0.09833544f, 0.39221084f, 0.17120150f, -0.11630652f, 0.42903745f, 
    0.11246803f, -0.01703848f, -0.17678763f, 0.11538940f, 0.04562675f, 0.00908351f, 0.04057931f, 0.07150587f, 
    -0.22690479f, -0.02573730f, 0.09712742f, 0.05383094f, -0.05094405f, -0.13315018f, 0.04826060f, 0.14058700f, 
    0.20258309f, 0.19823471f, 0.09550951f, 0.10723668f, 0.30327398f, 0.00978092f, -0.01498221f, -0.11356214f, 
    -0.00465903f, -0.04812590f, -0.00653999f, -0.08684128f, 0.02583896f, -0.04536491f, -0.03411628f, -0.08641990f, 
    0.12079591f, -0.09316801f, 0.00598880f, -0.00141661f, 0.18434329f, -0.05398187f, -0.02414392f, 0.02620401f, 
    -0.09274335f, 0.05282215f, 0.06332602f, -0.03976026f, 0.16465317f, -0.00482266f, 0.23911443f, -0.28834727f, 
    -0.08540437f, -0.00010321f, 0.21120928f, -0.10105012f, 0.06444512f, 0.02074350f, -0.03386769f, -0.06426835f, 
    -0.24921322f, -0.15716204f, -0.04247968f, 0.03387520f, 0.13676618f, -0.14232472f, -0.15804298f, 0.18579684f, 
    0.09840871f, -0.08623897f, 0.09319666f, 0.02857124f, 0.09572184f, 0.23860221f, -0.18269476f, 0.24699095f, 
    0.05453685f, 0.11400723f, 0.03116430f, 0.13642427f, 0.06317494f, 0.20313713f, -0.00443688f, 0.18896696f, 
    -0.09725790f, 0.12558180f, 0.11397661f, -0.18959996f, 0.15035467f, 0.08637449f, 0.07223701f, -0.09142509f, 
    0.06801691f, 0.02696771f, 0.13044079f, 0.06199015f, 0.08377386f, 0.01609843f, -0.00885967f, 0.16525754f, 
    0.08043110f, -0.01388481f, 0.01031262f, 0.06126688f, 0.01704519f, 0.01173066f, 0.04962917f, -0.11098342f, 
    0.17485744f, -0.01844673f, 0.13696082f, -0.03570805f, -0.00376148f, 0.13455336f, -0.05422962f, 0.09664965f, 
    -0.02690644f, -0.02791276f, 0.18483366f, 0.16421297f, -0.20288892f, -0.03865549f, 0.05181864f, 0.05207139f, 
    0.00386248f, 0.12839697f, 0.06172725f, 0.14125499f, -0.02006592f, 0.06216693f, 0.03249234f, 0.13985461f, 
    -0.20321976f, -0.00363382f, -0.09830028f, 0.00391337f, 0.12584874f, 0.00786835f, 0.02231511f, -0.07171861f, 
    0.01873572f, 0.01100799f, 0.04842249f, 0.04475070f, -0.05571797f, -0.05863992f, -0.07820607f, 0.05223931f, 
    0.05857410f, -0.00512693f, 0.00001508f, -0.06039667f, 0.00522161f, 0.06450139f, -0.04887014f, -0.08535631f, 
    0.03338875f, 0.00405917f, 0.03452603f, 0.08167955f, -0.15197904f, -0.06531189f, -0.11501517f, -0.08240762f, 
    0.01209805f, 0.02571011f, 0.05346109f, -0.10318419f, -0.04064337f, -0.34722435f, 0.02030410f, -0.02280850f, 
    -0.07997948f, -0.01910670f, -0.01498691f, -0.00592780f, 0.02758998f, 0.05503336f, 0.06578771f, 0.00861674f, 
    0.40116361f, 0.13755068f, -0.10550644f, 0.25269383f, 0.08866974f, -0.03519449f, -0.06713665f, -0.11041152f, 
    -0.07944961f, 0.06117775f, 0.04293422f, 0.12742375f, 0.12814824f, 0.01281981f, 0.25031540f, 0.01143198f, 
    0.06193205f, -0.11886969f, 0.00855168f, -0.09436385f, -0.05301005f, 0.05951577f, -0.01472444f, -0.01244707f, 
    0.41328967f, -0.18705226f, 0.10838046f, 0.05835504f, 0.10067182f, -0.01647753f, -0.01461685f, -0.02527427f, 
    -0.00575653f, 0.07016049f, 0.00580431f, 0.03318926f, -0.37782872f, 0.10674239f, -0.16198651f, 0.10327822f, 
    0.01734688f, 0.16122469f, 0.06792291f, 0.12602401f, 0.09819230f, 0.05046615f, 0.13792527f, -0.01302853f, 
    0.01128318f, 0.06269235f, 0.14173509f, -0.25040230f, -0.06119940f, -0.04816371f, -0.03055122f, -0.08447141f, 
    -0.01315382f, 0.02370096f, 0.07504059f, 0.11135120f, 0.41581368f, -0.35052338f, 0.20032501f, 0.05170709f, 
    -0.00230354f, -0.04139718f, 0.06956753f, 0.07224646f, 0.11322233f, 0.13418315f, -0.05104244f, 0.07044649f, 
    0.18668292f, -0.10192436f, -0.00880158f, -0.06018627f, 0.12582780f, 0.16037866f, 0.11018356f, -0.00866699f, 
    0.01255109f, 0.01905597f, 0.03501940f, 0.00895661f, 0.22973663f, -0.00113160f, -0.20078881f, -0.06998448f, 
    0.22219595f, 0.23597896f, 0.11789178f, -0.00847189f, 0.05043150f, 0.03756777f, 0.04278903f, 0.02469184f, 
    0.22484148f, 0.02254649f, 0.18407826f, 0.12366755f, 0.04783767f, 0.04264266f, 0.07716191f, 0.00646599f, 
    -0.08299509f, -0.02415627f, 0.06239153f, 0.09305932f, 0.09912813f, 0.12331090f, 0.07769376f, 0.07006846f, 
    0.15325300f, -0.01173748f, -0.00437679f, -0.01171811f, -0.02248576f, 0.09488974f, -0.03523201f, -0.09307647f, 
    0.29783836f, 0.19070052f, -0.07086943f, -0.02795436f, 0.03136845f, -0.04389157f, -0.12893343f, 0.09902570f, 
    -0.03768535f, -0.01464432f, -0.02689845f, -0.01823328f, -0.22050166f, 0.13879341f, -0.15211932f, 0.32760948f, 
    0.02015667f, -0.01922864f, 0.11168949f, 0.05447735f, -0.10994709f, 0.16161998f, 0.17780657f, -0.10644935f, 
    -0.18342277f, -0.23843178f, -0.02926999f, 0.20206723f, -0.01373682f, -0.02027861f, -0.02375148f, 0.01773628f, 
    -0.00271077f, 0.08826772f, 0.01451773f, 0.21300602f, 0.11501521f, -0.00095978f, 0.09287571f, 0.06669563f, 
    0.04740482f, -0.06411007f, -0.12357672f, -0.09200699f, 0.05378996f, 0.01395793f, 0.05148416f, -0.00582767f, 
    -0.02902154f, 0.12932098f, -0.12038922f, 0.28813836f, 0.02521187f, -0.01342051f, -0.02187517f, -0.01689469f, 
    -0.11780743f, 0.07916179f, -0.06738444f, 0.00837817f, -0.13753444f, -0.17585926f, -0.04734824f, 0.12828790f, 
    0.05271606f, 0.12919934f, 0.06829080f, 0.02344933f, 0.07537340f, 0.00815482f, 0.11871470f, -0.04228244f, 
    -0.11848194f, -0.02917450f, 0.10670122f, 0.08228490f, 0.00525964f, 0.00015823f, -0.07480512f, -0.02830365f, 
    0.07380348f, 0.01556233f, 0.09368154f, 0.07116209f, -0.13214362f, 0.35108021f, 0.17957185f, -0.28387308f, 
    -0.10359358f, -0.03021359f, 0.08171123f, 0.09484177f, 0.02147518f, -0.07923040f, 0.03041078f, 0.16611375f, 
    -0.09145660f, -0.03885511f, 0.09318694f, -0.14243488f, -0.03130160f, 0.10543002f, -0.02016901f, -0.15780067f, 
    -0.09548976f, -0.03664592f, -0.04253031f, 0.03439596f, 0.17233615f, -0.10490029f, -0.30217227f, -0.15547784f, 
    0.10715824f, 0.06581048f, 0.04096299f, -0.08765209f, 0.00909045f, 0.25290692f, 0.17139935f, 0.04937880f, 
    0.06474558f, -0.05870600f, 0.23475672f, -0.13841207f, -0.02886469f, 0.12179076f, 0.07780232f, 0.10219665f, 
    0.09236392f, 0.17547423f, 0.18372369f, 0.30524439f, -0.15204903f, 0.01661521f, -0.04470173f, 0.07430796f, 
    0.14192848f, 0.10374993f, 0.02576825f, 0.01714367f, 0.04586415f, 0.14545520f, -0.02729305f, 0.09786902f, 
    0.36985859f, 0.02748553f, -0.05863503f, 0.07991602f, 0.08994018f, -0.05965172f, -0.09707928f, -0.22529556f, 
    0.06797101f, 0.12585714f, -0.01774995f, 0.15298313f, -0.08336923f, -0.06060605f, 0.05742045f, -0.08882484f, 
    -0.04380464f, 0.17638077f, -0.01405392f, 0.04398656f, 0.21356444f, -0.10971138f, 0.00457209f, 0.02213958f, 
    -0.14738940f, -0.28749949f, 0.06927370f, 0.18552582f, 0.14765163f, -0.12574835f, 0.05653863f, -0.02415515f, 
    0.11834685f, 0.04371567f, -0.01084340f, 0.02672978f, 0.02291813f, -0.07173678f, -0.07180849f, 0.21275908f, 
    0.02153598f, -0.05127650f, -0.16879308f, -0.11910103f, 0.08839339f, -0.00569787f, 0.09552847f, 0.04555189f, 
    -0.53051406f, -0.02553065f, 0.24435499f, -0.04594260f, -0.09813090f, 0.02016400f, 0.02660878f, 0.12245445f, 
    0.04174052f, 0.06982645f, 0.05566825f, 0.05873958f, -0.05955992f, -0.05028601f, -0.01422055f, -0.10486809f, 
    -0.07060635f, -0.20771530f, 0.09614788f, -0.09428574f, -0.05556978f, -0.06842425f, 0.04503023f, 0.12502994f, 
    0.05288893f, -0.48209843f, -0.12353030f, 0.09082334f, -0.01257425f, 0.01181404f, -0.02374963f, 0.03830763f, 
    0.09581965f, 0.00964619f, -0.04604683f, 0.07583170f, 0.08412852f, 0.12289046f, 0.06991681f, -0.02861236f, 
    0.03395857f, 0.10992482f, 0.04414563f, 0.09865528f, 0.01386164f, 0.03723346f, 0.12080956f, 0.20757289f, 
    0.06939989f, -0.23763573f, -0.13585460f, -0.30704367f, 0.12152468f, 0.10774838f, 0.08605651f, 0.02647237f, 
    0.08037817f, 0.10571903f, -0.15801175f, 0.21174270f, 0.22354716f, 0.15906090f, -0.11800217f, -0.25095952f, 
    0.00167987f, 0.03008205f, 0.03293283f, 0.00002847f, 0.03739120f, -0.12990779f, 0.05562239f, -0.00812208f, 
    0.04863956f, -0.01965720f, 0.08759852f, 0.03775961f, -0.04598723f, 0.05450800f, 0.08438700f, 0.12419266f, 
    0.18929985f, 0.10934509f, 0.07026321f, -0.00483379f, -0.01059696f, 0.02234499f, 0.04599984f, 0.04797751f, 
    0.01730160f, -0.03311582f, -0.00795743f, -0.04964218f, 0.13643841f, -0.05177729f, 0.05492571f, 0.04245603f, 
    -0.15400584f, 0.03424152f, -0.21032019f, 0.25178584f, 0.01992632f, -0.06561159f, 0.06439856f, 0.00651397f, 
    -0.01446790f, -0.06569055f, 0.08231315f, 0.10841436f, 0.08252321f, -0.23474404f, 0.16410005f, -0.14008278f, 
    -0.02860147f, -0.14218152f, -0.00210842f, -0.00368688f, 0.02793235f, 0.03511399f, -0.19334915f, -0.13816333f, 
    -0.16994482f, -0.16421585f, -0.12187469f, -0.17721127f, 0.00385945f, 0.01704600f, 0.05413472f, 0.14172934f, 
    0.12553686f, -0.11976870f, -0.04483163f, 0.10897131f, -0.06090017f, 0.37560660f, -0.01765757f, 0.21216758f, 
    0.11498343f, -0.14576235f, -0.04363610f, 0.13999321f, 0.02381077f, -0.03586638f, 0.02603541f, -0.04866837f, 
    -0.05385055f, 0.19631177f, 0.04127130f, 0.14335063f, 0.06448694f, -0.15875684f, 0.00231325f, 0.14020799f, 
    -0.04586884f, 0.24353428f, 0.01023819f, 0.18643731f, -0.08116379f, -0.10454530f, 0.08404788f, 0.12205120f, 
    0.00420752f, -0.02927998f, -0.00164040f, -0.02006631f, 0.02664085f, 0.08497662f, -0.19109477f, -0.03225499f, 
    -0.25809243f, -0.02351890f, -0.10341918f, 0.14917393f, 0.05377119f, 0.12152658f, -0.14184353f, -0.07998651f, 
    0.03753691f, 0.01944404f, 0.00440132f, 0.07184269f, -0.22984444f, 0.09631749f, 0.00454907f, -0.08791735f, 
    0.13062198f, -0.04694988f, 0.07718107f, -0.00534049f, 0.13480870f, 0.03263142f, 0.00189419f, 0.18028127f, 
    0.00461354f, 0.02282347f, -0.06488137f, -0.12429593f, -0.08123682f, 0.05134698f, 0.01724397f, 0.03124490f, 
    0.07331380f, -0.07484972f, 0.05803197f, 0.01399455f, 0.05055518f, -0.31008279f, -0.00886514f, 0.02100596f, 
    0.16187428f, -0.05172272f, 0.03748876f, 0.05992707f, 0.16188958f, -0.01994306f, -0.04662331f, 0.05575431f, 
    -0.13455781f, 0.14544649f, 0.24578318f, -0.03688613f, 0.06128657f, -0.11903633f, 0.02262499f, 0.04471164f, 
    -0.04351112f, 0.03476673f, -0.07523768f, 0.04187259f, -0.47867188f, 0.35935706f, -0.01085699f, 0.14219581f, 
    -0.03707507f, -0.01446003f, 0.03479635f, -0.00978520f, -0.16490342f, 0.16771422f, -0.00982743f, -0.03791812f, 
    -0.09114632f, -0.12020470f, -0.02645036f, -0.17093107f, -0.10843729f, 0.01092799f, -0.02625201f, 0.11656383f, 
    0.03615291f, -0.01394117f, 0.05451050f, 0.13022648f, 0.23467752f, -0.01989458f, -0.07766213f, 0.26681426f, 
    -0.11611895f, -0.06426951f, -0.02370403f, -0.04367156f, -0.01486868f, -0.06798030f, 0.01592614f, 0.03489207f, 
    0.03761956f, -0.05390329f, 0.07067788f, 0.12201203f, -0.09634542f, -0.01408810f, 0.03242435f, -0.00110239f, 
    -0.01669301f, -0.00885738f, -0.01013585f, -0.17883651f, 0.57073927f, 0.00957164f, -0.26590279f, 0.04729407f, 
    0.01167856f, 0.09587604f, -0.01632568f, 0.00369967f, -0.02755523f, 0.04246784f, 0.01334078f, -0.01207369f, 
    0.04439407f, -0.01472917f, 0.13370112f, -0.07613736f, -0.05370728f, -0.03502902f, 0.06213722f, -0.09770652f, 
    -0.07877718f, 0.15059395f, -0.00425279f, 0.09621872f, -0.07655503f, 0.08181487f, 0.29722193f, 0.16880842f, 
    -0.03491035f, 0.12470794f, -0.12374566f, 0.09703732f, -0.05874642f, -0.12948839f, 0.13537584f, 0.05048960f, 
    -0.13521874f, 0.22211318f, -0.04559523f, 0.10384390f, 0.05313094f, 0.01819815f, -0.10457457f, -0.02797764f, 
    0.05335058f, -0.15952125f, 0.03114239f, -0.16583700f, 0.01998961f, 0.28752381f, -0.03375081f, 0.03791167f, 
    -0.11738106f, -0.08670861f, -0.04119857f, 0.06895000f, -0.07770174f, -0.02490222f, 0.05145862f, 0.03650934f, 
    -0.30556446f, 0.26692480f, 0.03471774f, -0.07563457f, -0.03960877f, -0.00223596f, -0.14112394f, 0.08150364f, 
    -0.01369842f, 0.03637169f, 0.01585561f, -0.05653523f, 0.20471860f, 0.04968773f, 0.10809876f, -0.20859903f, 
    0.09414895f, -0.08523367f, -0.06076068f, 0.03895618f, 0.01412644f, 0.12018771f, 0.01963247f, -0.05268888f, 
    0.27067038f, 0.06845535f, -0.24013948f, 0.33102548f, 0.08482675f, 0.02996394f, 0.10055631f, 0.06712997f, 
    0.01184622f, -0.01848593f, 0.02826571f, -0.00831246f, 0.35588619f, -0.02745015f, 0.05740455f, 0.15951523f, 
    -0.03792964f, 0.04062004f, 0.07969417f, 0.02038927f, -0.10871835f, 0.04491660f, 0.11493594f, 0.04985708f, 
    -0.13158636f, 0.34339830f, 0.07496915f, -0.06946898f, -0.06669363f, 0.09207375f, -0.05695454f, 0.10137446f, 
    0.01451338f, 0.03095325f, 0.01849115f, -0.03671647f, -0.03751916f, -0.12547255f, 0.02646642f, -0.04694537f, 
    0.04323941f, 0.16496170f, -0.10003763f, 0.07446855f, 0.03716007f, 0.00633463f, 0.02114967f, -0.03685327f, 
    0.58165324f, 0.08385250f, 0.17188565f, 0.36158991f, -0.03070184f, 0.05732324f, -0.04535674f, -0.04989671f, 
    0.18866067f, -0.02000198f, 0.02605052f, -0.04481196f, 0.04215408f, -0.35773420f, 0.19377305f, 0.54680401f, 
    -0.07741404f, 0.04161023f, -0.04119432f, 0.00744202f, 0.07346155f, -0.12507227f, -0.08797009f, -0.05446730f, 
    0.03213214f, 0.12645182f, -0.05157336f, -0.14280564f, -0.00853046f, -0.05528004f, 0.07543874f, 0.03669811f, 
    0.02838263f, 0.10809270f, 0.02015946f, 0.01017577f, -0.35136592f, 0.08681632f, -0.00741163f, -0.07404243f, 
    -0.00285067f, 0.04299771f, -0.00317394f, -0.00177116f, -0.09306359f, -0.05959573f, 0.01453286f, -0.04951747f, 
    0.05019376f, -0.13676485f, 0.04218510f, -0.07150149f, 0.10604275f, -0.02769418f, 0.12277215f, 0.01284416f, 
    -0.08365312f, -0.05503944f, -0.00444460f, 0.03911889f, -0.28552869f, 0.05527825f, -0.00381294f, 0.00281384f, 
    0.09383298f, 0.03143125f, -0.07988992f, 0.06538115f, 0.00742514f, -0.01826624f, -0.05548981f, 0.07897475f, 
    -0.21710791f, 0.13433720f, 0.05064280f, -0.27705771f, 0.08832377f, 0.08695235f, 0.01003541f, 0.07042371f, 
    0.01061845f, 0.04114553f, 0.06444107f, 0.04180880f, -0.06609285f, -0.11259219f, -0.03804992f, 0.04723301f, 
    0.10814038f, 0.01880959f, 0.08078266f, -0.16191147f, -0.00040281f, 0.01317349f, 0.04757655f, 0.10294737f, 
    -0.02084804f, 0.05022113f, 0.11067916f, 0.04031756f, -0.08458608f, 0.07856303f, -0.04421774f, 0.11513323f, 
    0.02151403f, 0.03344702f, 0.07452308f, 0.07090114f, -0.17403401f, -0.05209621f, 0.13298494f, 0.06424011f, 
    -0.03014412f, 0.13379756f, 0.09613684f, -0.13183939f, 0.12930828f, 0.08060481f, -0.02673913f, 0.01958837f, 
    0.09162219f, -0.14005533f, -0.12225661f, 0.27530703f, 0.12819923f, 0.12948698f, -0.00874180f, 0.13366489f, 
    0.07340439f, -0.14099370f, 0.08169661f, 0.01944376f, 0.62929106f, -0.08788360f, -0.40661365f, 0.02842929f, 
    -0.03002137f, 0.06765711f, -0.02816203f, 0.18572722f, 0.06304153f, 0.04938770f, 0.02448096f, 0.00649935f, 
    -0.00397171f, 0.31436631f, -0.11145131f, 0.10643660f, -0.17465785f, -0.15988031f, 0.14604956f, 0.06124261f, 
    0.05715657f, 0.07533713f, -0.02807731f, 0.04269067f, -0.44475448f, 0.19931874f, 0.17330845f, 0.10245638f, 
    0.05721684f, -0.01035324f, -0.04175815f, 0.00735344f, -0.13277555f, 0.01893653f, 0.00907269f, -0.03797518f, 
    -0.15077764f, 0.12881348f, -0.07778972f, -0.19923045f, 0.01438236f, -0.05429541f, 0.11807257f, -0.08401141f, 
    -0.07513557f, 0.09246978f, 0.06587097f, 0.10360537f, -0.02606212f, -0.11409044f, -0.10453200f, 0.21628210f, 
    0.08411425f, -0.08726045f, 0.07849056f, 0.06622519f, 0.06121943f, 0.04044018f, -0.12639759f, -0.02841908f, 
    0.33878645f, 0.08024725f, 0.15952685f, 0.02575341f, 0.06234413f, -0.11609758f, 0.11367167f, -0.06214101f, 
    -0.05373563f, -0.13447754f, -0.06988786f, -0.07281373f, -0.06636241f, 0.06282532f, 0.12233599f, 0.14070036f, 
    -0.05826360f, 0.02960613f, -0.08119377f, 0.12835465f, 0.07265249f, 0.03111685f, 0.03305749f, -0.04442728f, 
    -0.11637794f, 0.07596073f, 0.04268380f, 0.26726061f, 0.04827000f, -0.03458519f, 0.06604204f, -0.08078009f, 
    -0.02051784f, 0.02148845f, -0.03678295f, -0.07170012f, -0.07184187f, -0.07957116f, -0.29098785f, -0.03640610f, 
    -0.10922433f, -0.09275395f, 0.02669294f, -0.00441653f, -0.07807088f, 0.06390926f, -0.10069069f, -0.17352283f, 
    -0.33973214f, -0.16597977f, 0.03750445f, -0.00739688f, -0.14278309f, -0.09109069f, 0.01106599f, -0.01174464f, 
    0.03366754f, -0.02536607f, 0.00141942f, -0.08794256f, 0.44251791f, 0.24737361f, -0.19620015f, 0.05623022f, 
    -0.16823064f, 0.01239797f, 0.01848635f, 0.03033809f, -0.01988285f, -0.02432725f, -0.05411568f, 0.08372791f, 
    0.25702825f, 0.24119180f, 0.07366265f, -0.04293184f, -0.06517181f, -0.01889314f, 0.05493731f, -0.10827931f, 
    -0.08679904f, -0.01205994f, -0.00354768f, -0.03511747f, -0.06289532f, -0.06087834f, 0.15909030f, 0.09987840f, 
    -0.01850730f, 0.00117728f, 0.07490489f, -0.01579790f, 0.08723285f, -0.10783827f, 0.04875853f, 0.06850386f, 
    -0.16832308f, 0.10513327f, 0.19000234f, 0.14263631f, -0.01787495f, -0.05221751f, -0.01176123f, 0.09505191f, 
    0.06003777f, 0.02138153f, 0.03641947f, -0.05489679f, -0.05151248f, 0.15969032f, 0.08994951f, 0.02483449f, 
    -0.04223199f, -0.01810362f, -0.00800041f, -0.07287094f, -0.01374254f, 0.05936650f, -0.05960332f, 0.06383968f, 
    -0.25525761f, 0.28120765f, -0.13861066f, -0.11346608f, -0.19296432f, -0.07383356f, 0.04318639f, -0.00620415f, 
    -0.04988008f, -0.01934725f, -0.07895928f, 0.02595108f, -0.21727294f, 0.23019190f, 0.05915846f, -0.04972518f, 
    0.00790935f, 0.02048370f, -0.05512659f, 0.03958706f, -0.02170393f, 0.10439136f, 0.02525320f, -0.05426293f, 
    0.18846793f, -0.09269326f, -0.29598701f, 0.20167014f, 0.04079991f, -0.00396043f, -0.01296440f, 0.10224123f, 
    -0.10265265f, 0.00440576f, 0.08512128f, 0.13140385f, -0.13735788f, -0.12857930f, -0.07971534f, -0.00144338f, 
    -0.20552151f, 0.09340093f, 0.06266365f, -0.00921427f, -0.04149751f, 0.02486934f, 0.04104866f, 0.15254827f, 
    0.36721161f, 0.27711809f, 0.11160868f, 0.11457695f, 0.04136880f, 0.05726228f, -0.07683921f, -0.03193331f, 
    0.04137664f, -0.02732324f, 0.03811616f, -0.01025152f, 0.13829765f, 0.10711393f, 0.12857425f, 0.00909835f, 
    0.06443270f, 0.15239830f, 0.02800821f, -0.03108719f, 0.05638895f, -0.02592554f, 0.03697326f, 0.03300206f, 
    0.27346218f, 0.10768226f, 0.02191375f, 0.08618969f, 0.01610218f, 0.05444342f, -0.19450547f, 0.06953584f, 
    0.09155038f, 0.01998967f, 0.00665988f, 0.02729376f, 0.13093105f, -0.24537000f, -0.17326076f, 0.25964493f, 
    -0.04926419f, -0.03480432f, -0.03179893f, 0.00847457f, 0.13425243f, -0.00229414f, 0.08687261f, 0.13705692f, 
    0.18878995f, 0.24616539f, 0.04283000f, -0.09621097f, -0.04159775f, 0.06346642f, 0.09798181f, -0.08602365f, 
    0.01015060f, 0.01794082f, 0.15113476f, -0.02670072f, 0.26854020f, 0.26921535f, 0.14482053f, -0.01000404f, 
    0.01611167f, 0.02198744f, 0.07098702f, 0.03158856f, -0.00205048f, -0.03437955f, -0.02399193f, -0.06631639f, 
    0.12543151f, 0.10603248f, 0.11086734f, -0.08799002f, 0.01479662f, 0.05661886f, 0.01647106f, -0.02056019f, 
    0.08591180f, 0.00219723f, 0.16328551f, 0.03912060f, -0.26563504f, 0.06586098f, -0.01013130f, -0.06466192f, 
    0.07954176f, 0.13558647f, 0.04416686f, -0.02729438f, 0.02729627f, 0.14513920f, 0.07929083f, 0.05851289f, 
    -0.10334916f, 0.07411774f, 0.32633105f, -0.13308237f, 0.02642820f, 0.05298137f, 0.04988074f, 0.07797080f, 
    0.02599415f, -0.00113849f, 0.01045416f, -0.06411388f, 0.21325028f, -0.09878388f, -0.05722022f, -0.03258696f, 
    0.03070285f, 0.06701729f, -0.05469713f, -0.02972104f, -0.12472231f, -0.05016330f, 0.02927225f, 0.15868787f, 
    0.02225567f, 0.02248372f, 0.18595837f, 0.06511598f, -0.07011188f, 0.02448385f, -0.02394082f, 0.04355521f, 
    -0.04411469f, 0.00196634f, -0.04155860f, -0.11900261f, -0.33760786f, 0.06982939f, -0.01529616f, -0.08645440f, 
    -0.03126073f, 0.04006352f, -0.01434595f, -0.08275789f, 0.04490682f, -0.08364295f, 0.01834952f, 0.00450059f, 
    0.16616797f, 0.12635091f, 0.00714909f, 0.15273215f, 0.09652148f, 0.03193231f, -0.05753072f, 0.06030742f, 
    0.04852032f, -0.01906886f, 0.11362448f, -0.06733283f, -0.06619794f, 0.01238414f, -0.19158904f, 0.06595246f, 
    0.00705999f, -0.01398351f, -0.24222417f, 0.11483584f, 0.13265164f, 0.11972423f, -0.03492802f, -0.11769194f, 
    -0.21866073f, 0.00568113f, -0.16883275f, -0.03128382f, -0.02910470f, -0.14938805f, -0.05036344f, -0.02691646f, 
    0.06271298f, 0.07930025f, 0.02799600f, -0.03057405f, 0.03092483f, 0.16683640f, 0.19945702f, 0.21949568f, 
    0.21363971f, -0.00367800f, 0.05862474f, 0.04409101f, -0.05882606f, 0.12428520f, 0.02299739f, 0.09974672f, 
    0.02519812f, 0.00842195f, -0.00728124f, -0.01115292f, -0.03390073f, 0.03017597f, -0.04640727f, -0.02225008f, 
    0.03097097f, -0.02528868f, -0.01472810f, 0.04273168f, -0.01725564f, -0.00536544f, -0.01205741f, -0.04405738f, 
    0.01566339f, -0.02324314f, 0.02595641f, -0.00553017f, 0.00878870f, 0.01842737f, -0.04154291f, 0.01650565f, 
    -0.03017507f, 0.02516479f, -0.02283739f, 0.01130696f, 0.02934813f, 0.01397363f, -0.05257397f, 0.01625623f, 
    0.00859476f, -0.05097127f, 0.01873900f, -0.02574723f, 0.00388415f, 0.02596865f, 0.02849002f, 0.00098928f, 
    -0.04217665f, 0.02296434f, -0.00169681f, -0.03767416f, -0.01226238f, 0.02112717f, 0.01392435f, -0.04102902f, 
    0.03077001f, -0.03179107f, -0.03414693f, 0.01259655f, 0.01575877f, -0.00567746f, -0.02767011f, -0.05693034f, 
    -0.00736851f, -0.04992794f, -0.02128050f, -0.03823590f, -0.02532864f, -0.01217438f, 0.00897137f, -0.03771073f, 
    0.01718657f, 0.02933703f, 0.01450586f, -0.04839563f, -0.05365361f, -0.01080766f, -0.03714707f, -0.02286432f, 
    -0.04045334f, 0.02455570f, 0.02401779f, 0.01798482f, -0.02395283f, 0.00429638f, -0.02382556f, 0.02331719f, 
    0.04124095f, -0.00050398f, 0.03230304f, -0.01073859f, -0.03637912f, -0.04479374f, -0.00085771f, 0.04589425f, 
    -0.02498500f, -0.01590432f, 0.02342291f, 0.03638599f, -0.02526385f, 0.00933358f, 0.02340438f, -0.02528464f, 
    0.00797419f, 0.01369347f, 0.02468701f, -0.05074676f, -0.03591802f, -0.05392595f, -0.02267378f, -0.03898797f, 
    -0.02100602f, 0.03667165f, 0.01187400f, 0.03410080f, -0.04262523f, 0.02334997f, 0.00903686f, 0.02971757f, 
    0.00651007f, -0.01047732f, -0.03934700f, 0.03524359f, 0.03240048f, -0.05184417f, -0.03496656f, -0.00450257f, 
    0.02976607f, 0.00668445f, -0.03139669f, 0.02137790f, 0.01824208f, -0.05309933f, 0.00647626f, 0.01364317f, 
    -0.04022724f, -0.01733512f, 0.04286073f, 0.03494208f, -0.04491882f, -0.02943654f, -0.02296106f, 0.02103993f, 
    0.02468295f, 0.04492672f, 0.02498790f, 0.03871922f, -0.01859217f, -0.04741920f, 0.03453018f, -0.04681579f, 
    0.03389598f, -0.00924638f, 0.02930034f, -0.00929601f, -0.00262243f, -0.05004780f, 0.01423435f, -0.04529365f, 
    0.00432818f, -0.01243155f, 0.03330036f, -0.01901468f, -0.02088710f, -0.01638198f, -0.05321717f, -0.02535517f, 
    0.04379917f, 0.03171731f, 0.01941995f, 0.02098845f, -0.03660389f, 0.01517991f, 0.02385006f, 0.01372513f, 
    -0.03302059f, -0.02305125f, 0.00375699f, 0.01164606f, 0.00348478f, 0.03381467f, -0.02685104f, 0.00082384f, 
    -0.05208487f, 0.00862648f, 0.03492637f, -0.01467982f, 0.00887435f, 0.03129840f, 0.03699433f, 0.02048923f, 
    -0.05133843f, 0.02921851f, -0.01131636f, 0.02760655f, -0.00786170f, -0.00816851f, -0.02295407f, 0.00669011f, 
    -0.04660854f, -0.01837821f, 0.02021129f, 0.04105673f, 0.01554006f, -0.04107863f, -0.00798211f, -0.01141738f, 
    0.03049409f, -0.02177191f, -0.02876761f, -0.02011019f, -0.00578605f, -0.02105519f, 0.03586311f, -0.03872718f, 
    0.00790959f, 0.03868399f, 0.00741610f, 0.02158398f, 0.03505955f, 0.01250632f, -0.04107006f, -0.02849703f, 
    -0.00387913f, -0.01240207f, 0.03070910f, -0.00777685f, -0.01517155f, -0.00830686f, 0.01149482f, 0.04139739f, 
    -0.04734679f, -0.03132846f, -0.02025194f, -0.03584640f, 0.03076635f, 0.02679123f, 0.03531035f, 0.00592256f, 
    -0.04280824f, -0.02918760f, -0.01658233f, 0.03180241f, 0.01423202f, -0.03069973f, -0.01714739f, -0.00913567f, 
    -0.03255201f, 0.03025026f, 0.01056801f, -0.02586940f, 0.02362312f, -0.05398794f, 0.00670353f, 0.01166853f, 
    -0.00369054f, -0.02358931f, 0.01644563f, 0.04419277f, -0.03395048f, -0.02866658f, -0.05579174f, 0.03169414f, 
    -0.03361648f, -0.01717094f, -0.02904632f, -0.04885186f, 0.03039632f, -0.00910279f, -0.05294349f, 0.03594526f, 
    0.01341434f, -0.00156174f, -0.03499518f, -0.02261676f, -0.00314272f, -0.01836612f, -0.03517537f, -0.03237314f, 
    -0.04125043f, -0.05490307f, -0.02748116f, -0.02819493f, -0.02902166f, 0.02215116f, 0.00526117f, -0.03099878f, 
    0.02079405f, -0.00105623f, -0.02185909f, -0.02932592f, -0.00704876f, 0.03430662f, -0.00459200f, 0.01908174f, 
    -0.03347714f, -0.01520488f, 0.01532755f, 0.01011468f, 0.00229379f, 0.01729958f, -0.00514920f, 0.00759246f, 
    0.03668145f, -0.05136900f, 0.00091443f, 0.04296517f, 0.00285454f, 0.01926302f, -0.05539524f, 0.02537512f, 
    -0.01315136f, -0.01692273f, -0.03206522f, -0.03746716f, -0.03215504f, -0.04044297f, -0.02394825f, 0.00122086f, 
    -0.03740618f, 0.03216098f, -0.03428524f, -0.00160581f, -0.01986331f, -0.04229550f, -0.01493992f, 0.02727444f, 
    0.02617179f, -0.03405202f, -0.04218982f, 0.01068979f, 0.03372180f, -0.01801441f, -0.02821288f, -0.04012527f, 
    -0.02236117f, 0.04058922f, -0.04119307f, 0.02026863f, 0.02019527f, -0.01277710f, -0.04536755f, 0.03504906f, 
    0.02577670f, 0.02335130f, 0.01265671f, -0.04974914f, -0.02869311f, -0.04967803f, -0.00672779f, -0.03037062f, 
    0.00247300f, 0.02966209f, -0.00440083f, 0.01424008f, -0.01242501f, 0.02394817f, 0.03856524f, -0.05768498f, 
    -0.04229794f, -0.04553849f, -0.01350561f, 0.00127943f, -0.03788392f, -0.02454575f, 0.02292115f, -0.01627024f, 
    -0.02323914f, 0.03340614f, -0.02004036f, 0.03729475f, -0.04052578f, -0.03594527f, -0.01960295f, 0.04002087f, 
    -0.01548698f, 0.00314446f, -0.03497248f, 0.00032139f, 0.01020251f, 0.02379704f, 0.03570428f, 0.02056356f, 
    0.04699187f, 0.03662325f, -0.01266148f, -0.02882361f, -0.01112647f, -0.03488161f, 0.03814972f, -0.04984501f, 
    0.03132809f, -0.02595364f, -0.01612159f, 0.00595405f, -0.00856482f, 0.03017877f, 0.02989952f, 0.01763649f, 
    -0.04552995f, 0.01114903f, 0.00301948f, -0.03324534f, 0.02937083f, 0.03838009f, -0.03138459f, 0.03838008f, 
    -0.04523544f, -0.05219400f, -0.03228064f, 0.02454167f, -0.03933207f, 0.02610323f, 0.02034281f, -0.04443735f, 
    -0.00487235f, 0.00003391f, 0.04283997f, -0.03476466f, -0.00448982f, 0.01544493f, -0.02534964f, -0.00065604f, 
    0.00993798f, -0.04491471f, -0.01495591f, -0.00656367f, 0.00461833f, -0.03656738f, 0.02278007f, -0.03442556f, 
    -0.04441684f, -0.03298588f, 0.00039063f, -0.02989267f, 0.03908870f, 0.03019593f, 0.01160429f, 0.03805787f, 
    -0.00051719f, 0.01586160f, -0.04442921f, 0.01593129f, -0.04624648f, -0.02337592f, -0.01994577f, -0.00223266f, 
    -0.03885647f, 0.01306193f, -0.00834346f, -0.01948681f, 0.02421635f, -0.03625569f, 0.00669005f, -0.03676758f, 
    -0.02886550f, -0.02888966f, -0.02039513f, -0.02573543f, -0.04468585f, 0.00836352f, 0.00399811f, 0.04149874f, 
    -0.03901224f, 0.01462388f, -0.04178263f, 0.03053101f, -0.02471099f, 0.02643283f, 0.01403569f, -0.02529609f, 
    -0.00724283f, -0.05571944f, 0.03709998f, -0.02092155f, -0.01986653f, 0.04379689f, 0.04143319f, -0.05356983f, 
    0.04262822f, 0.01663635f, -0.05598601f, -0.00127716f, -0.02349057f, 0.01400809f, 0.00777576f, 0.03211370f, 
    -0.03941847f, 0.04258725f, -0.00043302f, -0.02048963f, 0.01282538f, 0.02753515f, 0.03831145f, -0.02779284f, 
    -0.01808871f, 0.01503711f, 0.04366114f, -0.02941245f, 0.00041188f, -0.00444891f, 0.03110368f, -0.04796628f, 
    -0.03718352f, 0.02682925f, -0.02760347f, -0.02544382f, -0.03016180f, -0.01274508f, 0.02264229f, 0.02402037f, 
    -0.03368222f, -0.05069088f, -0.01379257f, -0.04499802f, -0.00917969f, -0.03623368f, -0.01589986f, -0.00053524f, 
    0.02888373f, -0.03539546f, 0.00130685f, -0.04427631f, 0.03484803f, 0.04343500f, -0.01495502f, -0.03525387f, 
    -0.04037072f, -0.03504892f, -0.04015389f, 0.02051318f, -0.00167467f, 0.02495543f, -0.01843574f, -0.02104277f, 
    -0.01914096f, -0.00168451f, 0.03425935f, 0.03029237f, -0.05570220f, -0.03876780f, -0.00144271f, -0.01793542f, 
    0.02740275f, -0.01785995f, -0.01130090f, -0.02768500f, 0.02736864f, -0.01974231f, -0.04999258f, -0.04179271f, 
    -0.01833829f, -0.04383197f, 0.02444663f, 0.00226534f, -0.00594469f, -0.01391148f, -0.02307699f, -0.00791121f, 
    0.01999862f, 0.03853090f, -0.03800121f, -0.05169126f, -0.00605025f, 0.01161354f, -0.00759494f, 0.01033435f, 
    -0.05465336f, -0.04665315f, 0.01310731f, 0.01553841f, 0.00254702f, 0.03549421f, 0.02204389f, -0.02231234f, 
    -0.02724149f, -0.01601855f, -0.03719370f, 0.01136504f, -0.00819244f, 0.03679301f, -0.02518496f, 0.00836478f, 
    -0.00792147f, -0.02370563f, 0.00930945f, 0.04271756f, -0.04575453f, -0.05534244f, -0.04776357f, -0.01289943f, 
    0.00726039f, -0.01013840f, -0.00696243f, -0.01549305f, 0.03363043f, -0.02946752f, 0.00093330f, -0.00172094f, 
    0.02272198f, -0.04116490f, 0.00117915f, -0.05598688f, -0.02458148f, -0.01639113f, -0.00923708f, 0.03558653f, 
    0.00194076f, -0.00876154f, -0.02151624f, -0.05253047f, -0.05635042f, 0.01525451f, -0.05051710f, -0.02527789f, 
    -0.04666927f, -0.05132377f, -0.02269528f, -0.02276896f, -0.00611559f, -0.03194906f, 0.01596423f, -0.01459009f, 
    -0.02568578f, -0.00970008f, -0.02680134f, -0.03200430f, -0.03803166f, 0.01210490f, -0.03668854f, -0.03229271f, 
    0.02696444f, -0.03744052f, 0.02495581f, 0.00635314f, -0.04610308f, -0.01923079f, -0.05305625f, -0.02841860f, 
    -0.02203094f, 0.02774053f, -0.05129224f, 0.02984490f, 0.03619135f, 0.01258011f, -0.03361664f, 0.01822491f, 
    0.02375587f, -0.02588056f, 0.00891337f, -0.05023044f, -0.03522368f, 0.04353963f, -0.05319279f, 0.02060066f, 
    0.03397781f, 0.02492911f, 0.02078710f, -0.02185079f, -0.00598841f, 0.02958072f, 0.03462679f, 0.02215907f, 
    0.02458820f, 0.01374953f, -0.01825214f, -0.02015497f, -0.04727589f, -0.03067924f, -0.04462605f, 0.00593423f, 
    -0.02271267f, 0.03154055f, -0.00256213f, -0.01009170f, 0.01394789f, -0.03857005f, -0.00965325f, -0.05680707f, 
    -0.04338251f, -0.00999884f, 0.02218914f, 0.02424787f, -0.03686154f, -0.05002454f, 0.01415562f, -0.00372682f, 
    -0.00492404f, 0.00559513f, 0.03806011f, -0.02055326f, 0.01082257f, 0.03954889f, -0.05697966f, -0.03870215f, 
    0.02606446f, 0.02636348f, -0.05282749f, -0.02250158f, -0.05674463f, 0.01966075f, -0.02212522f, -0.00097265f, 
    -0.04860751f, 0.01073628f, -0.04239083f, -0.00845404f, 0.01595137f, 0.03730199f, -0.01828024f, 0.02039908f, 
    0.01850795f, -0.05440413f, 0.01571455f, 0.00378765f, 0.02507525f, 0.02521125f, -0.05317334f, -0.02556941f, 
    0.03541449f, 0.01882452f, -0.01681231f, -0.02472266f, -0.02002397f, -0.03095095f, 0.03663317f, -0.05011490f, 
    -0.01877632f, 0.01993280f, -0.03509696f, 0.03984728f, -0.03880305f, -0.00643482f, -0.01477186f, 0.03215627f, 
    0.03668746f, -0.02957697f, -0.01292294f, -0.03060085f, 0.04042503f, -0.03640180f, -0.02611016f, -0.05048455f, 
    -0.00920944f, -0.04722689f, -0.03642531f, -0.02446408f, -0.03720469f, 0.01094532f, -0.01440276f, 0.01259409f, 
    0.02214123f, -0.03731902f, -0.02771025f, -0.00824417f, 0.03986649f, -0.05269207f, -0.05037568f, 0.01560069f, 
    0.04382220f, 0.01178838f, -0.03138683f, -0.02458019f, -0.05565254f, 0.00992914f, -0.04070956f, -0.00108247f, 
    -0.01863651f, -0.00701010f, -0.04012496f, 0.02511795f, -0.01539561f, 0.03686902f, -0.03544647f, 0.01461313f, 
    0.19116518f, 0.03055992f, -0.01261484f, -0.05462306f, 0.04070897f, -0.06558792f, -0.03480271f, 0.13626109f, 
    0.06888468f, 0.00121191f, -0.08115873f, 0.04332433f, -0.19069022f, 0.24257194f, -0.15972123f, 0.31246072f, 
    -0.11174291f, 0.05598707f, 0.12715195f, -0.05122054f, -0.18568565f, -0.01211354f, 0.09752183f, 0.03420551f, 
    0.27888882f, -0.13198607f, -0.01781517f, 0.26146102f, -0.08165096f, 0.11889876f, -0.00036122f, -0.06983349f, 
    -0.04071536f, 0.00052901f, 0.16011922f, -0.00402144f, 0.24867369f, -0.15506434f, 0.06677462f, -0.01756213f, 
    0.05958506f, -0.01492267f, 0.03960164f, -0.10202841f, 0.00620126f, -0.10763896f, 0.14926212f, -0.03050897f, 
    -0.36380407f, 0.25787166f, -0.12346671f, 0.47135559f, 0.07834037f, 0.03779041f, 0.05076646f, -0.06869079f, 
    0.10263690f, 0.14433378f, -0.06947631f, -0.08127534f, 0.09284829f, 0.21737240f, 0.15543024f, -0.11403840f, 
    -0.08997774f, 0.00709928f, 0.12179027f, -0.02411926f, 0.02096848f, 0.00156721f, 0.01715833f, 0.04065743f, 
    -0.16389689f, 0.18419860f, 0.11581250f, 0.22664274f, -0.10418572f, 0.02379684f, 0.00047079f, 0.05916268f, 
    -0.06779253f, 0.08101417f, 0.03799341f, 0.09919533f, -0.10613818f, 0.03124974f, 0.28568751f, -0.23807907f, 
    -0.14270662f, 0.02959161f, 0.12893350f, 0.15871403f, -0.04622707f, -0.02176088f, -0.02766617f, -0.08076895f, 
    0.24963059f, -0.04064640f, 0.16724688f, -0.27534643f, -0.01167673f, 0.15456408f, -0.08863463f, -0.05077254f, 
    0.04856198f, -0.07716040f, 0.02575515f, -0.03350990f, 0.08815143f, 0.04878952f, -0.07961332f, 0.07037847f, 
    -0.00449390f, 0.05493525f, 0.10565655f, -0.08508223f, 0.04159411f, 0.01141078f, -0.03074453f, 0.05038299f, 
    -0.29719570f, -0.00202993f, -0.05050145f, 0.04440507f, 0.00196519f, -0.01941091f, 0.07516158f, 0.13872163f, 
    0.13238889f, 0.01074040f, 0.11185905f, 0.11520223f, 0.23849483f, -0.01565688f, -0.16872397f, -0.08898622f, 
    0.11250099f, 0.03437708f, 0.05748529f, -0.00635075f, 0.03275709f, -0.09138092f, 0.01925368f, 0.06965309f, 
    0.13081618f, 0.07722284f, 0.01040718f, -0.04462602f, 0.14198609f, 0.07329327f, 0.09014257f, -0.19655517f, 
    0.06399257f, -0.02626628f, 0.10287033f, 0.11106594f, 0.22758806f, -0.31688035f, 0.03991105f, -0.15571778f, 
    0.07226533f, 0.06600983f, 0.04494840f, -0.01068790f, -0.12799269f, 0.06370679f, -0.04265342f, 0.15230897f, 
    0.23341206f, -0.06218218f, -0.02250086f, 0.09082502f, -0.16339231f, -0.11369929f, 0.05337640f, 0.04397568f, 
    0.07693753f, 0.07020750f, -0.07750204f, -0.00697786f, 0.15117970f, 0.10510091f, 0.06976233f, 0.07055905f, 
    -0.13599443f, 0.05078267f, 0.04854126f, -0.02650921f, 0.13594605f, -0.02840229f, -0.15823595f, 0.01852448f, 
    -0.35349271f, 0.00627967f, 0.07869390f, 0.14354159f, 0.00839899f, -0.01777359f, 0.00308326f, 0.02478106f, 
    -0.03918885f, -0.11424324f, 0.13757125f, 0.15887387f, -0.25807688f, 0.03553930f, -0.09126861f, 0.06008211f, 
    0.02575475f, -0.04125719f, 0.01104612f, -0.16095883f, -0.03955337f, -0.01269400f, 0.08487093f, -0.04382933f, 
    0.22394370f, -0.07208721f, 0.06172407f, -0.20455295f, -0.19761227f, 0.10041032f, 0.00024015f, 0.13594086f, 
    -0.15979956f, -0.05237374f, 0.02262370f, 0.09815051f, 0.13704304f, 0.15214325f, 0.03618275f, -0.27642977f, 
    -0.09217408f, -0.03293310f, 0.05908738f, 0.04123385f, -0.18420850f, 0.06891438f, 0.08215053f, -0.03444703f, 
    0.14287843f, -0.21663219f, -0.10297691f, -0.29711512f, 0.13730964f, 0.02255167f, 0.13501063f, 0.06408076f, 
    0.06009666f, -0.03687160f, 0.04960086f, 0.09640212f, 0.35520369f, 0.12412891f, -0.14430295f, -0.13348676f, 
    0.00823345f, 0.17012851f, -0.15022853f, 0.02382149f, 0.05982928f, 0.03641621f, 0.00512045f, 0.13159165f, 
    0.01830215f, -0.14809717f, -0.02742148f, 0.02790923f, -0.12026132f, 0.09789350f, -0.14847659f, 0.02014873f, 
    0.12219993f, -0.02427250f, -0.10133944f, -0.09213764f, -0.09470269f, -0.10918079f, 0.00328388f, 0.11128264f, 
    -0.11256158f, -0.00737600f, -0.19916223f, -0.11475988f, 0.17005803f, -0.04172756f, 0.06804517f, -0.09080269f, 
    0.21396273f, 0.23726539f, -0.26871607f, 0.22637710f, -0.01190858f, 0.07832041f, 0.07331996f, 0.04411122f, 
    -0.04057477f, 0.02888820f, -0.03111545f, -0.00675169f, 0.03373337f, 0.00039380f, 0.13508531f, 0.17769714f, 
    -0.13342938f, -0.21383286f, 0.14723785f, 0.03950227f, -0.00089125f, -0.05543456f, 0.02760527f, -0.02031194f, 
    0.04051226f, -0.03708715f, -0.20880793f, -0.02924030f, -0.00753064f, -0.00934975f, 0.08805726f, 0.02190306f, 
    0.09327142f, 0.11241415f, -0.08119208f, 0.04192442f, 0.08432776f, 0.13881497f, -0.02059440f, 0.13145152f, 
    0.01083319f, 0.10382704f, -0.03706511f, 0.09118741f, 0.15667741f, 0.06865278f, 0.08386102f, -0.00743279f, 
    0.04177592f, 0.27269763f, -0.09138424f, 0.10007373f, 0.06743913f, -0.05525571f, -0.00906282f, 0.07644080f, 
    -0.17712237f, -0.06967714f, -0.09787626f, 0.08223814f, 0.10060641f, 0.18949665f, -0.11517132f, 0.18534878f, 
    -0.11957835f, -0.04909007f, -0.00183395f, 0.04327592f, -0.13551714f, 0.02958690f, -0.12315395f, 0.15003321f, 
    -0.05212369f, 0.00952223f, 0.03100477f, -0.01989650f, -0.02052299f, -0.02711985f, -0.01292025f, -0.01201178f, 
    0.04749146f, -0.16322476f, 0.10326769f, -0.03578494f, 0.18641065f, -0.09846380f, -0.01831662f, -0.00407778f, 
    0.10328369f, 0.07132782f, -0.03322878f, -0.03044802f, 0.12803367f, -0.03596454f, -0.06638470f, -0.14078407f, 
    0.02502511f, 0.02070270f, -0.01093696f, -0.02028880f, -0.00196159f, 0.04498037f, -0.04192004f, -0.01676260f, 
    -0.04790361f, -0.02650968f, 0.00445864f, 0.02690449f, -0.01462749f, 0.03978265f, 0.02289866f, 0.00593181f, 
    0.02888984f, -0.01053334f, 0.02807113f, 0.00994285f, -0.03327203f, -0.00552167f, -0.02926428f, -0.01184538f, 
    -0.03716956f, -0.03320909f, 0.03390659f, -0.04559796f, -0.00133804f, -0.02562931f, -0.01560541f, -0.04894529f, 
    -0.01413167f, 0.01857091f, -0.05010744f, 0.01912821f, -0.02503875f, 0.00555792f, -0.03966470f, 0.03256862f, 
    -0.05675606f, -0.01390766f, -0.01081862f, -0.01282036f, -0.03000175f, 0.00280350f, -0.02861865f, -0.02148188f, 
    0.02587475f, 0.03581348f, -0.00341713f, -0.03933376f, -0.00325343f, -0.03460107f, 0.03742055f, -0.05623243f, 
    0.02879860f, 0.01329208f, 0.00694077f, -0.04535212f, -0.05149723f, -0.02384180f, 0.00850827f, -0.03845054f, 
    0.04421895f, -0.02739485f, 0.02982148f, -0.03924922f, -0.01952519f, 0.01273822f, -0.01564232f, 0.04074531f, 
    0.03112990f, 0.04450021f, -0.01304347f, -0.02111061f, 0.04197735f, 0.03739731f, -0.01075516f, -0.03410873f, 
    -0.04468957f, -0.00095111f, -0.01634865f, -0.04418015f, -0.05560856f, 0.00562691f, 0.00198576f, -0.01475960f, 
    -0.00107484f, -0.04796869f, 0.02723023f, -0.04316582f, -0.05368428f, -0.01124268f, 0.00032548f, 0.01222809f, 
    0.00354358f, -0.01287077f, 0.01359470f, 0.03822356f, -0.01071888f, -0.00851698f, 0.03406097f, -0.00689472f, 
    -0.01672425f, -0.05491424f, -0.02553777f, 0.00792508f, -0.05433416f, 0.02698613f, 0.03918936f, -0.01131412f, 
    -0.05397264f, -0.00493009f, -0.01099737f, 0.02334874f, 0.02438170f, -0.01157098f, 0.00715439f, -0.00162600f, 
    -0.04820282f, 0.00505218f, -0.00349909f, 0.01656277f, 0.00770718f, -0.03381510f, -0.03124721f, -0.00765130f, 
    0.01149396f, -0.04106443f, -0.02691819f, -0.03181966f, -0.02117491f, -0.01807929f, -0.01478937f, 0.00753057f, 
    -0.02280830f, 0.00662464f, -0.01049216f, -0.03311890f, -0.03810829f, 0.04096770f, -0.02437427f, 0.00171638f, 
    0.02457277f, 0.01231874f, -0.02879597f, 0.00410294f, -0.02794080f, -0.00480927f, -0.03827498f, 0.02833768f, 
    -0.01430079f, -0.03650091f, 0.03676028f, -0.04630942f, -0.00314091f, -0.05312462f, -0.00282551f, 0.01586681f, 
    -0.04716141f, -0.03820572f, -0.01400835f, 0.01814540f, -0.04699175f, -0.02969027f, -0.00455110f, -0.03561530f, 
    0.03681684f, 0.02714214f, 0.02392646f, 0.00575422f, -0.01797460f, -0.00151110f, -0.03507158f, -0.01832213f, 
    -0.03332294f, -0.03688184f, -0.02808434f, -0.03165406f, -0.04667240f, -0.05093760f, 0.01923572f, 0.00741387f, 
    -0.03236515f, -0.03745412f, -0.03324813f, 0.02810500f, -0.04450995f, -0.01518410f, -0.01536271f, -0.01428813f, 
    -0.03547195f, -0.04063556f, -0.01405498f, 0.00818185f, -0.01295585f, 0.00698377f, -0.01536093f, 0.01935888f, 
    0.01667124f, -0.01101528f, -0.03505662f, 0.02931035f, -0.01317419f, -0.05130974f, -0.01014572f, 0.00094727f, 
    0.01218308f, 0.00670507f, -0.04506037f, 0.00087342f, -0.03090470f, 0.04000795f, -0.01174171f, -0.01006859f, 
    -0.01228634f, -0.02643865f, 0.00120588f, -0.00758194f, 0.00868918f, 0.03457676f, -0.02367781f, -0.01992466f, 
    0.02536706f, -0.02421151f, -0.00104333f, -0.04072263f, 0.01332175f, 0.03483789f, 0.00573557f, -0.02866966f, 
    0.03796155f, -0.03769629f, -0.01525301f, 0.00558479f, 0.04477599f, 0.00909426f, -0.04749176f, -0.01348645f, 
    -0.04860633f, 0.03144326f, -0.03800463f, -0.00640681f, 0.02130937f, 0.04559703f, -0.04442388f, 0.01644717f, 
    -0.03706764f, -0.03370861f, 0.03941257f, 0.04344276f, 0.00249029f, -0.02761497f, -0.05453174f, 0.01899089f, 
    -0.00325172f, 0.04078822f, 0.03082077f, -0.05435277f, 0.04309343f, -0.02351959f, 0.02129055f, -0.04374478f, 
    -0.05448977f, 0.01837341f, 0.04370153f, 0.00420662f, -0.01881987f, -0.02780416f, -0.03352821f, -0.01031421f, 
    -0.02949740f, 0.04114494f, 0.02714379f, -0.03019764f, 0.01032278f, 0.02614723f, 0.01040934f, 0.03168791f, 
    -0.04777528f, -0.00206252f, 0.02663944f, -0.05491466f, -0.03164516f, -0.04840687f, 0.01064554f, 0.04083578f, 
    -0.04699583f, -0.01751894f, 0.04237825f, 0.00195150f, 0.04017309f, 0.01935565f, 0.03003450f, 0.03522133f, 
    0.00898495f, -0.04424386f, -0.03576128f, 0.01944678f, -0.00290987f, -0.05475919f, -0.04124451f, -0.01140985f, 
    0.00221388f, -0.03778530f, -0.02520670f, 0.00278837f, -0.05030434f, -0.01864346f, 0.04292101f, -0.00161625f, 
    -0.02227370f, 0.01794259f, -0.05459633f, 0.02255282f, 0.01115701f, 0.01651691f, 0.01141377f, 0.03095352f, 
    -0.01857557f, 0.00450438f, 0.02202820f, -0.00137663f, 0.02072263f, 0.00969643f, 0.03848360f, 0.04386852f, 
    -0.04758170f, 0.01442030f, -0.04383768f, 0.00611498f, 0.02280848f, 0.00776552f, 0.03790621f, -0.01778606f, 
    -0.01349753f, 0.04251523f, 0.03379600f, -0.03031569f, 0.02087679f, -0.05245734f, -0.02389113f, 0.02457229f, 
    -0.05234194f, -0.01713906f, -0.02875313f, 0.02189977f, -0.05211947f, 0.04064810f, -0.01178397f, 0.02089158f, 
    0.01666254f, -0.02285832f, 0.02291154f, -0.01647457f, -0.00823124f, -0.05331710f, 0.02263313f, 0.03415971f, 
    0.00010066f, 0.00428710f, -0.00215483f, -0.01001142f, -0.04006756f, 0.01563629f, -0.03126245f, 0.02589103f, 
    0.01537292f, 0.02842493f, -0.00944583f, -0.01500652f, 0.04040257f, -0.04519143f, 0.03041102f, -0.00918206f, 
    -0.02784383f, -0.03267346f, -0.05457438f, 0.00100396f, 0.04051036f, -0.02055708f, 0.01305525f, -0.02534533f, 
    0.36052126f, -0.16260085f, 0.14407603f, 0.07015997f, -0.17028835f, 0.17090142f, -0.08026442f, 0.06850085f, 
    0.07737412f, -0.02964410f, 0.01431335f, 0.03340678f, -0.39925084f, -0.08519892f, -0.19865850f, -0.03601270f, 
    0.09581311f, -0.09789970f, -0.05361619f, -0.07171975f, -0.01256058f, -0.08766451f, -0.04171809f, -0.08020468f, 
    -0.05394762f, 0.02914007f, 0.14055172f, 0.03033203f, 0.07061745f, 0.06521733f, -0.14546567f, 0.13436480f, 
    -0.11927235f, 0.01743649f, -0.04374237f, 0.12350716f, -0.22665170f, 0.08727460f, -0.01569811f, -0.15249060f, 
    -0.05878253f, -0.08452442f, -0.00305301f, -0.08970466f, -0.05200284f, 0.09883875f, 0.05455358f, 0.11438506f, 
    0.39087224f, -0.13173072f, 0.05723602f, -0.04338254f, -0.06079169f, 0.15351591f, 0.08228417f, 0.04384337f, 
    -0.06909920f, 0.04721503f, 0.07225329f, 0.07550686f, -0.13626558f, -0.13340069f, -0.05773014f, -0.02290520f, 
    -0.06603408f, -0.06657984f, -0.11799955f, -0.02243356f, 0.10552196f, -0.06099784f, 0.04631468f, 0.22757913f, 
    0.26507998f, -0.00510039f, -0.09623814f, -0.19201227f, 0.07867762f, 0.02874590f, -0.05569630f, -0.08890385f, 
    0.00860151f, 0.00206439f, 0.09206464f, 0.10198402f, -0.33599338f, -0.05383329f, -0.12813357f, 0.14867605f, 
    0.10407797f, -0.07888514f, -0.08071241f, -0.03684542f, 0.11463258f, 0.12826307f, 0.08250555f, -0.06637327f, 
    0.20235389f, -0.04532255f, -0.13436370f, 0.07327393f, -0.00590671f, 0.10870989f, -0.00912159f, 0.12807511f, 
    0.03165038f, -0.09625907f, 0.05535774f, -0.04234359f, 0.24636194f, 0.19647332f, 0.02390907f, 0.15667814f, 
    -0.02643468f, 0.02239630f, -0.02059489f, -0.12028351f, -0.03042576f, -0.00340402f, -0.14947036f, 0.05824937f, 
    0.32995373f, 0.04221737f, 0.23748966f, -0.01790443f, 0.06861344f, 0.03388179f, -0.02655088f, 0.01909848f, 
    -0.14495885f, 0.08410347f, 0.06621195f, 0.01855220f, 0.10481314f, 0.27371007f, 0.28174746f, 0.20490246f, 
    0.10740632f, -0.01154316f, 0.03440884f, 0.08389754f, 0.08752022f, 0.01605735f, 0.11280363f, -0.03391847f, 
    -0.00428792f, -0.29930913f, 0.01549778f, -0.09717734f, 0.06690553f, 0.00731458f, -0.00084533f, -0.07847510f, 
    0.10758075f, 0.10825840f, 0.07616802f, -0.03193770f, 0.30657572f, -0.07430123f, 0.12552381f, 0.09675087f, 
    -0.15767603f, 0.03703303f, -0.05187228f, -0.10609423f, 0.01242762f, -0.12307175f, -0.00837702f, -0.11357663f, 
    -0.20404311f, -0.07771552f, 0.15906399f, -0.12799114f, -0.05578995f, -0.11419049f, -0.04734772f, 0.03624706f, 
    -0.00342553f, -0.02736484f, -0.16339207f, -0.15632181f, -0.13225684f, -0.15322241f, -0.24244617f, -0.11204154f, 
    0.02724195f, -0.07331144f, -0.12297771f, 0.04007120f, 0.02761731f, 0.03281958f, 0.10180018f, -0.03113073f, 
    -0.28772530f, -0.10995030f, -0.13285221f, -0.03702491f, 0.09092470f, -0.08354692f, 0.04261784f, -0.08777333f, 
    0.11460188f, -0.01349698f, 0.02429841f, 0.05913885f, -0.14450337f, 0.23492177f, 0.09994283f, -0.01768805f, 
    0.02849328f, -0.01066572f, 0.17538901f, 0.24756792f, 0.09930357f, 0.04796537f, 0.04347230f, -0.04793248f, 
    -0.08635239f, -0.07317026f, 0.03822029f, 0.03877672f, 0.02835122f, -0.05953934f, -0.01600136f, -0.03652049f, 
    0.11599741f, 0.01783145f, -0.04131245f, -0.01721140f, -0.14876434f, 0.13842192f, -0.01020219f, -0.11142549f, 
    0.18694742f, 0.01506608f, -0.05389664f, -0.03363967f, 0.02809799f, -0.07692043f, -0.09241590f, -0.04407084f, 
    0.22573151f, 0.22017682f, 0.25016668f, 0.21154732f, 0.16341050f, 0.05346970f, -0.03251580f, 0.13529019f, 
    0.03168038f, 0.15604758f, -0.06107040f, 0.01520037f, -0.15218836f, 0.14160548f, 0.05167489f, 0.18699442f, 
    0.05368596f, 0.03144146f, -0.00054664f, 0.13027798f, 0.05021374f, -0.01955994f, 0.12740733f, 0.00268197f, 
    0.11132969f, 0.01277986f, -0.01615391f, 0.05125811f, 0.02361690f, 0.03350940f, -0.01939139f, 0.09215557f, 
    0.04895445f, -0.19746554f, -0.05971266f, -0.01462984f, -0.00674465f, -0.11214870f, 0.04938500f, 0.02901217f, 
    0.05522999f, 0.06195915f, -0.03169884f, 0.11628681f, -0.15897642f, -0.12276323f, -0.04915242f, 0.07931408f, 
    0.10169408f, 0.27233174f, 0.08740170f, 0.10239377f, -0.03420720f, 0.00597077f, 0.09727322f, 0.01935932f, 
    -0.16448276f, -0.05314679f, -0.01654006f, 0.17156896f, 0.11787538f, -0.11119849f, 0.22570655f, -0.13524617f, 
    0.09558939f, -0.10166814f, -0.02253084f, -0.07688349f, -0.02167588f, -0.07622246f, -0.05718273f, 0.02777024f, 
    0.27443013f, 0.20258757f, 0.32244584f, 0.29896668f, 0.22546251f, 0.17275029f, 0.07353113f, 0.03060236f, 
    -0.03495048f, -0.03784381f, 0.07988033f, -0.00946419f, 0.01882297f, -0.20091048f, -0.24584861f, 0.01047061f, 
    -0.08260264f, -0.05762290f, 0.05115938f, 0.02705458f, -0.13565129f, 0.14552318f, 0.01538709f, -0.07495065f, 
    -0.02127349f, -0.18394302f, 0.18155229f, -0.10149016f, -0.06311477f, -0.17084223f, -0.02343817f, -0.06457188f, 
    0.05964378f, -0.04028730f, -0.02652800f, 0.01721782f, -0.05702770f, -0.00579056f, 0.24551155f, -0.11880343f, 
    -0.03166940f, -0.09344590f, -0.01693082f, -0.13152170f, 0.06875762f, -0.11688766f, 0.04461284f, 0.04030576f, 
    0.06470346f, -0.19293508f, -0.01110349f, -0.14907184f, 0.02713099f, 0.04850386f, -0.05334552f, -0.08022076f, 
    0.00872979f, 0.02075016f, 0.04512099f, 0.17208433f, -0.36120892f, 0.03305802f, 0.04202291f, -0.17275029f, 
    -0.17307533f, 0.00448552f, -0.00927520f, 0.03117194f, 0.01087616f, -0.16309227f, -0.05384314f, 0.04065782f, 
    0.10997217f, -0.12237816f, -0.02593459f, 0.00414765f, -0.00471405f, -0.06469896f, 0.01517393f, 0.07938550f, 
    0.09222786f, -0.06373845f, -0.02965985f, -0.03200801f, -0.12693623f, 0.00860183f, -0.11732692f, 0.08249991f, 
    0.08426031f, 0.06578610f, 0.05086416f, -0.11359869f, 0.03932053f, -0.03165215f, 0.04108644f, 0.03646951f, 
    0.21875484f, -0.21232903f, -0.01881646f, 0.22026251f, 0.09258372f, 0.01583449f, -0.04859526f, 0.07279401f, 
    0.01180698f, 0.12545477f, 0.03523879f, 0.01492741f, -0.22128524f, 0.23234092f, -0.13079812f, -0.05202831f, 
    -0.02146403f, -0.03670750f, 0.01899363f, 0.00930982f, -0.06478804f, 0.13076714f, 0.15441339f, -0.04461582f, 
    -0.22243392f, 0.09258512f, -0.05591432f, -0.08183310f, -0.09586595f, 0.12414066f, 0.04299087f, -0.00274580f, 
    -0.01523733f, -0.03966116f, 0.06753902f, -0.02915207f, 0.02523533f, -0.06004423f, 0.00616224f, 0.07600228f, 
    -0.06998526f, 0.01062668f, 0.04210899f, -0.00155471f, 0.02967639f, 0.04016226f, -0.00454994f, 0.15787305f, 
    0.00095168f, 0.11246466f, 0.01539339f, 0.08442054f, -0.04459939f, -0.01306812f, 0.01111819f, 0.10091290f, 
    0.01261627f, 0.06384103f, 0.09964619f, 0.02349675f, 0.06099942f, -0.29402372f, -0.13050857f, -0.28437975f, 
    0.10809688f, -0.00828623f, 0.03060045f, 0.01953208f, 0.01113269f, 0.10633963f, 0.03808496f, -0.08376362f, 
    -0.05762608f, -0.12465025f, 0.08447822f, 0.02110959f, 0.00106898f, -0.03453307f, 0.04906847f, 0.08245970f, 
    0.05250642f, 0.00533332f, -0.01476146f, 0.02040840f, 0.19445023f, 0.11582032f, 0.07172323f, 0.07190719f, 
    -0.11778654f, 0.08228536f, 0.06917191f, 0.05332196f, 0.00413028f, -0.00817134f, -0.02309545f, 0.11564116f, 
    -0.16240093f, 0.27531824f, -0.04722864f, -0.13483781f, 0.12203133f, -0.00773953f, -0.08143350f, 0.06255852f, 
    0.04931465f, 0.01452654f, 0.12343103f, 0.02478016f, 0.43331584f, 0.07412214f, -0.09704523f, 0.03271199f, 
    0.07698151f, -0.11399842f, -0.01715291f, 0.08347782f, -0.02656762f, -0.08490444f, 0.09113482f, 0.05607216f, 
    -0.09016079f, -0.02101881f, -0.15014245f, -0.00588460f, 0.08019076f, 0.03530350f, -0.06241928f, 0.07146873f, 
    0.04429155f, -0.00096283f, -0.00915396f, 0.02852600f, 0.12064783f, -0.18728125f, 0.14138646f, -0.11638875f, 
    0.09655814f, -0.00218019f, 0.05472843f, -0.00597800f, 0.00863803f, 0.09972484f, 0.01521005f, 0.03088215f, 
    0.22253199f, -0.00222988f, -0.05588063f, 0.26261750f, 0.03160816f, 0.02721545f, 0.09905616f, 0.02835792f, 
    0.01165848f, -0.01334247f, -0.06282028f, -0.04260799f, 0.11213478f, -0.27443677f, -0.10339455f, 0.05948098f, 
    0.05677105f, -0.03026106f, -0.04920632f, 0.01782953f, -0.05800269f, 0.03293802f, -0.00102117f, 0.03877348f, 
    -0.33843023f, 0.38138762f, -0.25598544f, -0.25262570f, -0.02963217f, 0.05136580f, 0.02960895f, 0.05202042f, 
    0.10877696f, -0.01766678f, 0.07457843f, 0.04960255f, -0.05019515f, 0.10209800f, 0.11523283f, -0.10475042f, 
    -0.09217104f, 0.12681095f, 0.00907791f, 0.26235244f, -0.01357145f, 0.03576108f, 0.01432219f, -0.17284110f, 
    0.33135375f, -0.19172013f, 0.06010970f, 0.18302305f, 0.10107858f, 0.03708866f, 0.13204938f, -0.03232921f, 
    0.12552054f, 0.06054508f, -0.00380311f, -0.04794684f, 0.03932459f, -0.05043043f, 0.20088005f, 0.08560158f, 
    0.07007018f, 0.06631900f, -0.03945937f, -0.03581932f, 0.02098405f, 0.02736378f, 0.04005861f, -0.07230123f, 
    0.22525428f, -0.13787726f, -0.03823425f, -0.04550288f, -0.06764006f, -0.00621239f, 0.07670243f, 0.06302878f, 
    0.07204953f, 0.09556977f, 0.06581057f, 0.01232103f, 0.08992238f, 0.18177915f, 0.00546863f, -0.04151718f, 
    -0.12154106f, -0.08485060f, -0.08650029f, 0.00490942f, -0.05407120f, -0.02896644f, 0.07532796f, -0.00025504f, 
    0.12433222f, -0.09236468f, -0.02845174f, -0.14808610f, 0.14203523f, 0.09440512f, -0.04547956f, 0.00603753f, 
    0.03195427f, -0.10767180f, -0.03517898f, -0.08053517f, 0.09868051f, 0.02497441f, -0.07316251f, 0.13016985f, 
    0.02530666f, 0.00716358f, -0.17567722f, 0.06497516f, -0.07190298f, -0.00424882f, 0.02552981f, -0.02124863f, 
    0.43595934f, 0.23577563f, -0.14098212f, -0.00016086f, -0.08455397f, 0.01219933f, 0.01675927f, 0.05059974f, 
    0.01480865f, -0.00139151f, 0.02035995f, 0.06368645f, -0.40299901f, -0.19561943f, 0.15521961f, -0.02209094f, 
    0.09274156f, 0.02340208f, 0.11902128f, -0.10321077f, 0.06586050f, -0.08776984f, -0.04594512f, 0.05604950f, 
    0.08013963f, 0.10339785f, 0.04847988f, -0.11538426f, -0.04564930f, 0.06558736f, -0.08415643f, 0.14495078f, 
    0.09588485f, 0.06194318f, 0.07214127f, 0.09027889f, -0.04605383f, -0.02872715f, -0.13071710f, 0.12267403f, 
    -0.01341079f, 0.06993306f, 0.01313635f, -0.00048093f, 0.00948608f, 0.00875823f, 0.13431649f, 0.00953885f, 
    -0.23788971f, 0.13982178f, -0.06020955f, 0.12605292f, 0.12706123f, 0.05263257f, 0.01183471f, 0.07952391f, 
    -0.00652452f, -0.09355470f, -0.03605390f, 0.03007144f, 0.28038138f, -0.22559442f, 0.04105215f, 0.02049958f, 
    -0.01368249f, -0.00509862f, 0.05652204f, -0.05105621f, 0.04657304f, -0.09551051f, 0.03923261f, 0.15082657f, 
    -0.18325914f, 0.19623137f, -0.06083228f, -0.01201946f, -0.08879866f, -0.03123617f, -0.00167200f, -0.01250614f, 
    0.01020271f, -0.10248465f, 0.00844196f, 0.04139276f, -0.26241088f, 0.21096984f, -0.04166226f, 0.04091600f, 
    -0.06854287f, 0.08852784f, -0.04746913f, 0.05822524f, -0.01682339f, -0.03654724f, 0.03414690f, -0.02463073f, 
    0.03619974f, 0.00333794f, -0.01051016f, 0.02339436f, 0.01709447f, -0.03319906f, 0.03160295f, -0.04418005f, 
    -0.02223712f, 0.00260762f, -0.05038482f, -0.02525360f, -0.04758699f, -0.02290122f, 0.00128622f, -0.01139410f, 
    -0.04471251f, -0.02906555f, 0.03749611f, -0.04704270f, 0.03526736f, -0.01095256f, -0.04784834f, 0.04062895f, 
    -0.03018270f, 0.03787700f, 0.01026712f, 0.00256441f, -0.01688075f, 0.02337441f, 0.02022340f, -0.06134691f, 
    0.00638924f, 0.03263763f, 0.02009850f, 0.00049593f, 0.03545263f, -0.01529093f, -0.02238308f, -0.01536001f, 
    -0.01330685f, -0.04405914f, 0.00063518f, -0.00951150f, -0.02329769f, 0.00557087f, 0.03382754f, -0.01174386f, 
    0.00294185f, -0.00920859f, -0.05833231f, 0.00739512f, -0.02071317f, 0.02498748f, 0.03126976f, -0.00801355f, 
    -0.00236708f, 0.01668081f, 0.01496519f, 0.02307701f, -0.05910004f, -0.02635969f, -0.02564720f, -0.02736942f, 
    0.04138783f, -0.04624888f, -0.02003098f, 0.00039130f, -0.03889158f, 0.03494164f, 0.03965634f, 0.01085707f, 
    0.02287694f, -0.02394234f, 0.00169441f, 0.02827000f, -0.03619287f, 0.02071951f, 0.02656526f, 0.01170910f, 
    -0.03365549f, -0.03379901f, -0.02044137f, 0.02591015f, -0.00977902f, 0.02395985f, 0.03307971f, 0.02918886f, 
    0.01247061f, 0.03723907f, -0.05075090f, -0.00045185f, 0.00058157f, -0.01695359f, -0.01701143f, -0.04919671f, 
    -0.00284702f, 0.01645226f, 0.01928098f, -0.00926150f, 0.00423501f, -0.01017699f, 0.03620495f, -0.02920648f, 
    -0.00078419f, -0.03505714f, 0.02992694f, 0.02528380f, -0.03384799f, -0.04036758f, -0.00869901f, -0.05348180f, 
    0.00931537f, -0.04107890f, 0.04764546f, -0.01520160f, -0.01402291f, -0.04589801f, -0.03489318f, 0.00478335f, 
    0.00507941f, 0.01696590f, -0.05857371f, 0.00539729f, -0.00249364f, -0.02735407f, 0.03333170f, -0.03892593f, 
    -0.03822285f, -0.05859752f, -0.00239273f, -0.06203880f, 0.00616714f, -0.03407814f, 0.00104152f, -0.02395158f, 
    -0.01707936f, -0.01523905f, 0.01663819f, -0.01497828f, -0.01265241f, 0.02717339f, -0.00722915f, 0.02038754f, 
    0.02888230f, 0.01444585f, 0.01946962f, 0.00030512f, 0.01447225f, 0.01875627f, -0.00475485f, -0.04965222f, 
    -0.03767948f, 0.03518546f, 0.00413889f, 0.03788967f, 0.02702371f, 0.04168683f, 0.02226975f, -0.03533448f, 
    0.03608086f, -0.00887491f, 0.02447561f, 0.02523840f, 0.00942022f, -0.00953831f, -0.04622041f, 0.01300140f, 
    -0.00428216f, -0.04116932f, 0.00684322f, -0.05290696f, 0.00724059f, -0.00959702f, -0.00265677f, 0.00258527f, 
    -0.00688105f, -0.04763282f, -0.02152386f, -0.01611703f, -0.00189814f, 0.01886400f, -0.00588423f, -0.06356511f, 
    -0.02123431f, -0.03826318f, 0.02995246f, -0.05167098f, -0.02127279f, -0.00440730f, -0.01283930f, -0.02204800f, 
    -0.00139090f, 0.01047774f, 0.01204007f, 0.04625506f, 0.03582729f, -0.01879928f, 0.03129676f, -0.01335633f, 
    -0.01715561f, 0.02320300f, 0.01492130f, -0.03229759f, -0.05312410f, 0.01980512f, -0.02663714f, 0.02288308f, 
    0.04071745f, 0.03292682f, 0.02231637f, 0.00053625f, -0.03978381f, -0.00927562f, 0.04188476f, -0.03680730f, 
    0.03846877f, 0.04018914f, -0.00196731f, -0.00561774f, -0.05560513f, -0.00103001f, 0.03585052f, -0.01328701f, 
    -0.06163466f, 0.03440548f, -0.03615486f, 0.03957654f, -0.01441576f, 0.04774843f, 0.03768912f, -0.04337551f, 
    -0.00703230f, -0.04419351f, -0.00677425f, 0.01108302f, 0.00402568f, -0.03498150f, -0.00671325f, -0.01758705f, 
    -0.00281590f, -0.04081596f, -0.03375282f, -0.04152957f, -0.04044002f, 0.01008524f, 0.01987459f, 0.02815027f, 
    0.01128869f, -0.02690953f, -0.03328251f, -0.05513730f, 0.01362509f, -0.02946468f, 0.02800588f, -0.03592471f, 
    -0.03068371f, -0.03612792f, -0.03737105f, -0.03313611f, 0.00491893f, -0.03035750f, -0.03690330f, 0.01827101f, 
    -0.01083361f, -0.04632319f, -0.03266772f, -0.06132224f, -0.03558934f, 0.03667993f, -0.01618308f, 0.01562432f, 
    -0.00522436f, -0.03861205f, 0.01704912f, 0.03750485f, -0.05605903f, -0.00413531f, -0.02872069f, -0.06065013f, 
    -0.03455662f, 0.01165851f, 0.02972978f, 0.03943498f, 0.04137680f, -0.04827551f, -0.01044258f, -0.05334107f, 
    -0.04643417f, -0.03060110f, -0.04152348f, -0.05274193f, -0.02567606f, 0.02578345f, -0.04634550f, 0.04018853f, 
    -0.02892067f, -0.02766674f, -0.01338562f, 0.02806681f, 0.01165010f, -0.03844974f, 0.04848473f, -0.03787536f, 
    0.01160376f, 0.03541821f, -0.03573490f, -0.00530231f, -0.01700231f, -0.03992229f, -0.03715859f, 0.03683537f, 
    -0.01531751f, 0.01619511f, -0.03365304f, 0.02540303f, -0.01052031f, 0.03635870f, -0.01062350f, -0.00024372f, 
    0.02207317f, -0.02863858f, -0.02637983f, 0.03304077f, -0.02896963f, 0.02611845f, -0.05913650f, 0.03617083f, 
    -0.00356999f, 0.01246769f, -0.00822202f, -0.00135730f, -0.04086881f, -0.00155636f, -0.04172568f, 0.03611583f, 
    0.00868344f, 0.00376768f, -0.01546175f, 0.03344421f, -0.02466576f, 0.01614858f, -0.02620532f, 0.02458457f, 
    0.01870160f, 0.04277737f, -0.05799864f, -0.04235541f, -0.00293988f, -0.00885992f, 0.00772380f, 0.01822386f, 
    0.03001650f, 0.00426496f, 0.01890650f, -0.05936002f, 0.04185082f, -0.04950404f, -0.04805916f, -0.01862987f, 
    0.01688665f, 0.03462679f, -0.01216098f, -0.01531123f, -0.00026399f, -0.02189494f, -0.01146621f, -0.04727413f, 
    0.01647984f, 0.03726470f, -0.04359100f, -0.01579786f, 0.01252978f, -0.04326652f, 0.03409227f, 0.01275600f, 
    -0.00160417f, -0.05990733f, -0.06019399f, -0.03739645f, 0.00080497f, -0.00845509f, -0.05162970f, -0.03572426f, 
    -0.22313073f, -0.14488953f, 0.11249821f, 0.03758771f, 0.04556988f, 0.03888229f, 0.15756740f, -0.10469633f, 
    0.05425128f, 0.19649959f, 0.11620649f, 0.08217235f, 0.05094161f, 0.05175099f, 0.25264165f, -0.27498227f, 
    0.00784665f, 0.02957160f, -0.09345975f, 0.07822943f, 0.00295175f, -0.09363346f, -0.07045069f, 0.01813514f, 
    0.12428582f, 0.14082770f, 0.03820331f, -0.01364149f, 0.08758872f, 0.03605146f, 0.06928745f, 0.04738826f, 
    0.08249713f, -0.04808972f, -0.06585610f, -0.05418007f, -0.02827376f, -0.03196296f, -0.07929746f, 0.01273311f, 
    -0.00316356f, 0.08737680f, 0.06898301f, 0.21082619f, 0.06872204f, 0.00230110f, -0.13733113f, 0.16315971f, 
    0.46791476f, 0.00588599f, 0.19344503f, -0.13109565f, 0.14776090f, 0.05187684f, 0.01792191f, 0.10308745f, 
    -0.02629586f, 0.06975085f, 0.07890509f, 0.01410944f, -0.44738927f, -0.05611859f, 0.13075654f, -0.21843992f, 
    0.21860135f, 0.00488872f, -0.04391885f, 0.14570560f, 0.03803411f, 0.03180759f, 0.01910291f, 0.08017997f, 
    0.01868102f, -0.07822189f, -0.14702617f, -0.22703528f, 0.10184854f, -0.05020542f, -0.00225348f, 0.04192842f, 
    0.02552897f, -0.05356577f, 0.00910587f, 0.06033634f, -0.25281933f, -0.15594789f, 0.09795367f, 0.59215784f, 
    0.13905887f, 0.07595541f, 0.00414208f, 0.02396919f, 0.08822361f, 0.07296735f, -0.01176343f, -0.03811409f, 
    -0.06685315f, 0.01033162f, -0.16380700f, 0.25432891f, 0.07017981f, -0.06094442f, 0.04625700f, 0.14047036f, 
    0.06415524f, 0.03245725f, 0.08821312f, 0.03179054f, 0.21832666f, 0.03479668f, -0.01101461f, 0.01044109f, 
    0.08995655f, 0.03619153f, 0.05751587f, 0.03407251f, -0.02480939f, -0.08001216f, -0.02226717f, -0.01577130f, 
    0.37665507f, -0.02597610f, 0.17462049f, 0.07681795f, -0.06276993f, 0.02969279f, 0.06712500f, 0.06300396f, 
    -0.03674670f, 0.05851288f, -0.00914022f, -0.00649172f, -0.11224528f, -0.06480364f, 0.10005483f, -0.04592714f, 
    0.08572298f, 0.01961057f, 0.06466189f, 0.06166044f, 0.07019244f, 0.02489339f, -0.01051058f, -0.01839117f, 
    -0.26418486f, -0.20582773f, 0.12241304f, -0.10748509f, -0.11978167f, 0.08734442f, 0.08259231f, 0.22814555f, 
    -0.03785149f, -0.03443637f, 0.01458706f, 0.01882884f, -0.18199266f, 0.01506241f, 0.17546776f, 0.43343678f, 
    -0.06821710f, 0.04628568f, 0.08494983f, 0.07875683f, -0.03317192f, -0.03678421f, 0.16689074f, -0.01112555f, 
    -0.30171293f, 0.12106074f, 0.29957190f, -0.39757913f, -0.01881966f, 0.11139090f, 0.01283265f, -0.03466821f, 
    -0.05936167f, 0.05127732f, 0.02301125f, 0.04309319f, -0.46470374f, 0.14371751f, -0.01370559f, -0.31018931f, 
    0.03321738f, -0.01785134f, 0.03875813f, 0.08143516f, 0.01584693f, -0.05178699f, -0.04079770f, -0.01760101f, 
    0.32594159f, -0.13170680f, -0.05009773f, 0.14532907f, 0.13362645f, -0.05444982f, -0.00555170f, -0.05549490f, 
    -0.01991077f, 0.08444786f, -0.15412970f, -0.12210631f, 0.22743790f, 0.05010645f, 0.00859896f, 0.05478425f, 
    0.08086517f, 0.04794397f, -0.09818022f, -0.01388241f, -0.02505483f, 0.13511916f, -0.02988408f, 0.06455024f, 
    -0.29985863f, 0.18402424f, 0.01265489f, -0.14661123f, 0.01304758f, -0.00202239f, 0.06449731f, -0.00357821f, 
    0.00020311f, 0.03059841f, 0.05389214f, 0.10926925f, -0.14666045f, 0.18276876f, -0.09575730f, -0.11233075f, 
    0.07269616f, -0.07733218f, 0.04807085f, 0.03363506f, 0.10108706f, 0.02446502f, -0.02982609f, 0.06796365f, 
    -0.04765326f, 0.08689913f, 0.04023036f, 0.30848840f, -0.05170957f, 0.00354387f, -0.01691221f, -0.04723326f, 
    -0.03451720f, -0.02602391f, 0.10052594f, -0.01701771f, -0.23925708f, -0.15266356f, -0.03020478f, 0.06963301f, 
    -0.00215499f, -0.06726690f, 0.14892198f, -0.00399746f, 0.00466700f, 0.05856553f, 0.10529966f, 0.01267935f, 
    -0.02965670f, 0.13628107f, -0.02224027f, 0.11448421f, 0.04291436f, -0.01696338f, 0.02383040f, 0.03753354f, 
    -0.05536313f, 0.13548893f, 0.13075361f, 0.09827138f, 0.08727658f, -0.04020854f, -0.04301518f, -0.17999505f, 
    0.11214586f, 0.03650964f, 0.28860897f, 0.10694318f, 0.06305570f, 0.05320684f, 0.06475287f, -0.02335665f, 
    -0.09773445f, -0.03686162f, 0.04948394f, -0.10294221f, 0.06581902f, 0.09057784f, 0.04250540f, -0.01367061f, 
    0.09583796f, 0.08033704f, 0.01951066f, -0.02802486f, -0.01360871f, 0.00537552f, -0.04634136f, 0.09698943f, 
    0.09962577f, 0.24624161f, -0.04006774f, -0.01287689f, 0.05283977f, 0.10102008f, 0.02735791f, 0.10993768f, 
    0.19889006f, 0.20277983f, 0.09936327f, 0.04180904f, 0.21445008f, 0.05879683f, 0.03991057f, -0.11646648f, 
    -0.09460469f, 0.05704800f, 0.06641259f, -0.06270620f, 0.08884431f, -0.20417970f, -0.02402286f, -0.30083799f, 
    -0.00637136f, -0.10797323f, 0.04969703f, -0.01132078f, -0.10939860f, -0.00609483f, 0.03440814f, 0.00821249f, 
    0.09531056f, 0.04906602f, 0.28242072f, -0.13065237f, -0.11341929f, 0.02693510f, 0.07698005f, -0.00201771f, 
    0.07825860f, 0.01358586f, 0.09566780f, -0.04599928f, -0.60269684f, 0.10092163f, 0.37965113f, -0.05331817f, 
    0.12336627f, 0.16296555f, -0.03025579f, -0.06936086f, 0.02011858f, -0.08702984f, 0.10917983f, -0.02229380f, 
    -0.27298152f, -0.17668469f, 0.11084634f, -0.09891608f, 0.16798277f, 0.08405373f, -0.02601628f, 0.12681116f, 
    -0.05583807f, 0.10518596f, 0.07311496f, 0.04049419f, 0.05745354f, 0.10615042f, 0.10676909f, -0.01241637f, 
    -0.09375594f, 0.04902312f, 0.10287835f, 0.08383056f, -0.01385228f, -0.00855190f, 0.02374603f, 0.06452525f, 
    -0.19652422f, -0.00730489f, 0.01127994f, 0.02685907f, 0.15727246f, 0.05074721f, 0.13648999f, -0.01018852f, 
    -0.08970494f, 0.11947992f, 0.05015041f, 0.21913606f, 0.19477209f, 0.06722540f, -0.10929103f, -0.29719707f, 
    -0.21665886f, 0.05606731f, 0.00710442f, 0.02255275f, -0.07361677f, 0.00901692f, -0.09209213f, 0.04333409f, 
    0.09880115f, 0.10910390f, -0.26474386f, 0.08375142f, -0.01869285f, -0.03915932f, 0.23647848f, -0.01557952f, 
    0.01607520f, -0.10740229f, 0.06041750f, -0.16843863f, 0.32330537f, -0.13834199f, 0.01095532f, 0.01757556f, 
    -0.09987465f, 0.01240639f, 0.20307127f, 0.13035336f, 0.03914442f, -0.00975945f, -0.00667893f, -0.05754976f, 
    0.22387204f, -0.14431992f, 0.01286823f, -0.02593622f, -0.01738821f, -0.03811651f, 0.08729959f, 0.07462274f, 
    0.07291491f, 0.05902159f, 0.06370097f, -0.01546035f, -0.22050567f, 0.14377467f, 0.10743635f, -0.07691082f, 
    0.01445864f, 0.08257511f, 0.04873813f, 0.05137320f, -0.06195539f, 0.03293446f, -0.02727170f, -0.08290765f, 
    0.15891300f, 0.06563877f, -0.00043007f, 0.11136623f, 0.05447836f, -0.07458943f, -0.00523397f, -0.04084692f, 
    0.02185199f, -0.03461508f, 0.03355272f, 0.02034746f, 0.03051511f, 0.18667124f, 0.15118067f, 0.06251273f, 
    0.04046918f, 0.19637652f, 0.04416152f, 0.05495460f, 0.01190834f, 0.00436492f, -0.06075212f, -0.00395253f, 
    -0.32020718f, -0.08540589f, -0.03637805f, 0.19061592f, 0.03604492f, 0.11223336f, 0.06089624f, 0.02248731f, 
    0.01614954f, 0.05702376f, 0.07992543f, 0.10614668f, -0.20817538f, 0.02929552f, -0.00473920f, -0.23745260f, 
    0.12245169f, 0.02657579f, 0.07811695f, 0.05844799f, -0.06487506f, -0.15958996f, -0.03817045f, 0.10136332f, 
    0.26071995f, -0.14910506f, -0.10874794f, -0.13057187f, -0.11347958f, -0.05860543f, 0.09035986f, -0.02642476f, 
    0.03609956f, 0.17850754f, -0.09961254f, -0.04627900f, -0.17300710f, -0.19879617f, -0.00810637f, 0.17332545f, 
    0.08259374f, -0.06756508f, 0.04107931f, -0.02306528f, -0.00601227f, 0.06241723f, 0.07444347f, 0.04262554f, 
    0.30001712f, -0.13064864f, 0.09025218f, 0.31822678f, -0.19678339f, 0.12056954f, 0.20273843f, 0.08490156f, 
    -0.02428682f, -0.04967671f, -0.01838850f, 0.11104240f, -0.15754069f, -0.01651176f, 0.13141060f, 0.13884798f, 
    -0.09565108f, 0.03674021f, -0.02268811f, 0.22104771f, -0.06724657f, 0.00540327f, 0.02895504f, 0.17548822f, 
    -0.24367255f, 0.22964114f, 0.18597849f, 0.17602625f, -0.18227123f, 0.04564574f, -0.02872326f, 0.00641855f, 
    -0.04141393f, 0.13076697f, 0.04979492f, 0.02963158f, 0.09707259f, 0.06472480f, -0.10089216f, 0.09272696f, 
    -0.02694698f, 0.02319999f, 0.20933296f, 0.13240334f, 0.09674427f, 0.01212269f, 0.04939073f, -0.05040462f, 
    0.65639168f, 0.17133267f, 0.01740787f, -0.26578084f, -0.00617546f, -0.00989285f, 0.10428613f, 0.03036794f, 
    -0.06406431f, 0.02465024f, -0.17358485f, 0.00972162f, 0.51217175f, 0.00682205f, 0.10265185f, -0.06296653f, 
    0.00909756f, -0.02192658f, 0.02153984f, -0.01377101f, -0.02957060f, 0.05972351f, 0.20332098f, 0.12022222f, 
    0.16874795f, -0.06985093f, 0.12547655f, -0.07347117f, -0.07010908f, 0.06631611f, 0.06110333f, 0.00744167f, 
    -0.04964830f, 0.02428408f, 0.00037152f, 0.02629265f, -0.12591587f, 0.20758411f, 0.12558141f, -0.25955597f, 
    0.03161054f, -0.02939135f, -0.00880593f, 0.01115487f, -0.01998155f, -0.13675520f, 0.00718099f, -0.08582938f, 
    -0.28710535f, -0.09737973f, 0.09119083f, 0.15193664f, -0.03721041f, -0.00785258f, 0.00082171f, 0.08792729f, 
    0.01504018f, -0.13309976f, 0.07978201f, 0.07395242f, 0.06511391f, -0.11252850f, 0.04593344f, 0.19017687f, 
    0.04108010f, -0.08521245f, -0.00478329f, 0.08004170f, -0.00166285f, 0.06163081f, -0.03194014f, 0.16390556f, 
    -0.04095567f, 0.14925440f, 0.05586840f, -0.12666716f, 0.05622067f, 0.00641686f, -0.00890321f, -0.00968460f, 
    0.02801302f, 0.13263552f, 0.11899477f, 0.07741822f, 0.09029499f, -0.14801618f, -0.01796922f, 0.03999939f, 
    0.08426402f, -0.14771867f, 0.15822084f, 0.01713310f, -0.01231271f, 0.09104300f, 0.00397393f, -0.06388813f, 
    -0.01300414f, -0.28126654f, -0.07801633f, -0.10884017f, 0.01800676f, -0.00778193f, -0.03837232f, 0.09615666f, 
    0.10220142f, 0.05511768f, -0.12277772f, -0.11671392f, -0.09171572f, 0.08319772f, -0.02765519f, 0.08013852f, 
    0.03545135f, 0.10075857f, 0.14483754f, 0.03940319f, 0.04204257f, 0.12908016f, 0.13484956f, 0.02939322f, 
    -0.06026430f, -0.22041020f, -0.03299698f, -0.01639482f, -0.01692018f, -0.00293927f, 0.02572077f, 0.05964321f, 
    0.00794714f, 0.07141101f, 0.10480406f, 0.14748798f, 0.09776259f, 0.02805715f, -0.15498784f, -0.05935299f, 
    -0.00508617f, -0.05032600f, 0.07185955f, 0.04826242f, -0.06188392f, -0.07570900f, 0.08247825f, 0.02685045f, 
    -0.14667743f, 0.05554175f, 0.22705963f, 0.06370527f, -0.08281130f, 0.15857270f, 0.04313288f, 0.01995920f, 
    0.01261567f, 0.04749342f, -0.07840551f, -0.09284689f, -0.40122736f, 0.01132761f, 0.11194818f, 0.06301253f, 
    -0.11946445f, 0.16110539f, 0.04941787f, 0.08477099f, 0.10084775f, -0.03792300f, 0.03353756f, -0.02522004f, 
    -0.35045788f, 0.08485076f, 0.12401650f, 0.06101158f, 0.01217941f, 0.08107659f, 0.05578509f, 0.04195565f, 
    -0.05349471f, 0.14244041f, 0.04378699f, -0.09270920f, -0.03241630f, -0.14437725f, 0.15858299f, 0.02213830f, 
    -0.02573087f, 0.02585562f, 0.06124780f, 0.04445298f, 0.01103374f, -0.09165833f, -0.06332699f, -0.00692426f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.03075233f, 0.06551938f, -0.05332738f, -0.05070745f, -0.08195960f, 0.09801686f, -0.00435231f, 0.02712518f, 
    -0.00296400f, -0.00343465f, -0.00107242f, -0.04395109f, 0.03898406f, -0.02497500f, -0.01615537f, -0.11861833f, 
    -0.04011522f, -0.02975039f, 0.04661182f, 0.06318623f, 0.05285577f, 0.04010934f, -0.08200012f, 0.00281334f, 
    -0.00995180f, 0.03918200f, -0.01012809f, 0.11595085f, 0.09855475f, -0.04465133f, 0.08119520f, 0.01602580f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.25621113f, -0.19184256f, 0.26273450f, 0.00347869f, 0.07192817f, -0.22924177f, 0.08993447f, -0.32862440f, 
    -0.04478803f, 0.26294065f, -0.16361250f, 0.16514309f, 0.14928856f, 0.03755733f, 0.16964550f, 0.29716256f, 
    0.21840905f, 0.08670207f, 0.08539847f, -0.40362999f, 0.15239111f, 0.14313623f, 0.42959553f, -0.15889288f, 
    -0.14683798f, 0.28213617f, -0.15944871f, -0.84544599f, -0.01126019f, 0.05052190f, -0.56811875f, 0.11977839f, 
    0.03542259f, 0.12873690f, -0.08501094f, 0.07483377f, -0.20132302f, 0.27277550f, 0.03026003f, -0.02724287f, 
    0.35004044f, -0.03654146f, 0.10427129f, 0.15138607f, -0.15985678f, 0.12727736f, -0.69171774f, -0.00629594f, 
    0.48041725f, -0.08041516f, -0.07398801f, -0.02583394f, 0.08905476f, 0.16923586f, -0.49235591f, -0.05414542f, 
    -0.05008484f, 0.25033343f, 0.05270806f, 0.41383234f, 0.39982730f, -0.15381581f, -0.64055461f, -0.22245413f, 
    0.18351211f, 0.31302384f, 0.07620518f, 0.10622798f, -0.36376312f, -0.51948678f, 0.30781585f, 0.39575672f, 
    0.18341394f, -0.46690723f, 0.14127317f, -0.15792122f, -0.55124664f, 0.09435073f, 0.14728622f, 0.18386413f, 
    0.03510686f, 0.08271307f, 0.25855216f, -0.10894296f, -0.31211942f, -0.26959431f, -0.03149358f, 0.05755623f, 
    0.02609769f, -0.02289087f, 0.02892803f, -0.63691658f, 0.19398546f, -0.07295401f, -0.20248218f, 0.32492542f, 
    -0.44174939f, 0.18750232f, 0.33622226f, 0.13707076f, -0.29979268f, -0.11450250f, -0.44159713f, -0.23643939f, 
    -0.58776170f, -0.19661471f, 0.00513183f, -0.05459919f, -0.07498201f, -0.07234421f, 0.25204277f, -0.43748534f, 
    -0.33278677f, 0.02069966f, -0.82647574f, 0.29596269f, 0.14064591f, 0.40870279f, 0.24156402f, -0.04573946f, 
    -0.11264323f, -0.09817988f, 0.15797007f, -0.20537272f, 0.26860943f, 0.15348788f, -0.07848984f, 0.09200209f, 
    -0.13043551f, -0.09382930f, -0.13994884f, 0.12618296f, -0.25215906f, 0.27060264f, -0.05721560f, -0.07172627f, 
    0.05565556f, 0.33174387f, 0.16023843f, -0.04126896f, -0.12808843f, 0.12359647f, 0.33538893f, 0.28536046f, 
    0.31146699f, -0.04258703f, -0.36167777f, -0.17395452f, -0.26084504f, 0.10983001f, -0.25019270f, -0.17143710f, 
    -0.06789134f, -0.42020980f, 0.16361302f, 0.33820879f, 0.02806995f, 0.10209461f, 0.34290963f, 0.35550734f, 
    0.57271749f, 0.41211414f, -0.34175467f, 0.08031958f, 0.12849823f, 0.27406946f, 0.22981727f, -0.48919785f, 
    0.09276397f, 0.16131040f, -0.17916688f, -0.03749235f, 0.41106004f, 0.17230357f, -0.20099135f, -0.58268380f, 
    -0.28769821f, 0.11422636f, 0.10425832f, -0.15984342f, 0.22028877f, -0.00316630f, -0.15231872f, 0.11075669f, 
    -0.09928563f, 0.04489259f, 0.16585846f, -0.42045546f, -0.36835009f, 0.16975854f, -0.01507388f, -0.08453580f, 
    0.01856036f, -0.69389713f, -0.06059127f, 0.04676348f, 0.37958115f, -0.28422052f, 0.24450903f, -0.18465312f, 
    0.20458196f, -0.46228740f, 0.02486956f, -0.12258009f, 0.33948278f, 0.14190894f, -0.16671908f, 0.25722224f, 
    0.11948875f, -0.11600286f, -0.13370152f, 0.26609460f, -0.31420946f, -0.15806328f, -0.19538301f, 0.02542827f, 
    -0.12690496f, 0.04864890f, -0.01625969f, -0.77103376f, -0.27010426f, 0.12439534f, 0.30808848f, 0.26746348f, 
    0.47308421f, 0.26574290f, 0.08756725f, 0.00866534f, 0.28427413f, -0.45036504f, -0.44402510f, 0.02699453f, 
    -0.20220271f, 0.20937398f, 0.05190168f, 0.07516620f, -0.12697160f, -0.01676681f, 0.35083541f, 0.19572029f, 
    -0.08860853f, -0.12019370f, 0.01018013f, -0.08261092f, -0.53221887f, -0.19089191f, 0.21067998f, -0.10867395f, 
    0.01972147f, -0.19857146f, 0.15264280f, 0.26170084f, -0.49654955f, -0.09154976f, 0.28205562f, -0.31701314f, 
    0.13060607f, 0.26572642f, -0.45218980f, -0.06792253f, 0.13324827f, -0.18296134f, -0.22358087f, 0.18285255f, 
    -0.35410318f, -0.02865735f, 0.13375616f, -0.01203014f, -0.11169497f, -0.03354297f, -0.45925313f, 0.44590247f, 
    0.27490267f, -0.09371538f, 0.35066333f, 0.26789930f, 0.30723563f, 0.06937726f, -0.00388378f, -0.10653826f, 
    0.11583062f, -0.56107694f, 0.06950955f, -0.13002023f, -0.33088157f, -0.16087459f, -0.38065198f, 0.10054599f, 
    -0.61592454f, -0.06756630f, -0.08481157f, 0.03707557f, 0.30926821f, -0.34846631f, -0.00307825f, 0.25634605f, 
    0.07293119f, 0.27748454f, 0.09871475f, 0.09130100f, 0.05600230f, 0.12260314f, 0.34281343f, -0.38413829f, 
    -0.53993583f, -0.08613297f, 0.30957228f, 0.09268046f, 0.20993149f, -0.74544495f, -0.50298923f, 0.12423547f, 
    -0.15458013f, 0.06541820f, 0.02085947f, 0.11179125f, -0.36375976f, 0.11997953f, 0.19174619f, 0.22136873f, 
    0.29593104f, 0.07553656f, 0.18429928f, -0.00355252f, -0.53637671f, 0.30413067f, -0.36438549f, 0.04230529f, 
    -0.14256816f, -0.60572737f, 0.06346086f, 0.15951331f, -0.15710266f, 0.15624738f, -0.35979697f, -0.06662615f, 
    -0.47221741f, -0.13184291f, 0.35247090f, -0.13282390f, 0.36377391f, -0.37491092f, -0.01022721f, 0.16681361f, 
    0.11893295f, 0.03241906f, -0.02360322f, 0.38439173f, 0.35454193f, 0.15704779f, 0.30056623f, -0.17949095f, 
    -0.49582082f, -0.42150909f, 0.14483170f, -0.04578954f, -0.24109954f, 0.03867117f, 0.38425323f, 0.26025471f, 
    0.09979823f, 0.08081597f, -0.16742650f, -0.05828223f, 0.39103332f, 0.03600126f, -0.15360308f, -0.55204582f, 
    -0.47736198f, 0.13848864f, 0.21483165f, 0.16570769f, -0.44199488f, 0.38615528f, 0.16787143f, 0.08338728f, 
    -0.12973873f, -0.38566637f, -0.13221894f, -0.14859791f, 0.09211651f, 0.07474998f, -0.03267355f, -0.50024837f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.02376082f, 0.16011301f, -0.19036312f, 0.16366974f, -0.10978445f, -0.13120578f, 0.02161828f, -0.17294891f, 
    0.12845983f, -0.08209572f, 0.22466004f, 0.09122478f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
