#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.30720517f, -0.63395625f, -0.56453520f, 0.92976773f, 1.05616128f, 1.02677870f, -0.32252300f, -0.37253365f, 
    0.06323406f, -0.45944762f, 0.51615721f, 0.53377938f, -0.67872643f, 1.39550126f, -0.38981357f, 0.57151866f, 
    -0.20107834f, -0.08299849f, -0.08996227f, -0.96202022f, -0.53872168f, -0.94606900f, -1.11834168f, -1.28616583f, 
    1.10019457f, 0.16236216f, 0.10513417f, -0.62029213f, 1.80096436f, -0.95899999f, -0.16804966f, 0.05610739f, 
    0.02957111f, 0.37997526f, -0.23224515f, 0.50672090f, 0.36414084f, 0.31489000f, -0.48346034f, -0.49798214f, 
    0.21152875f, -0.91975236f, 0.17216402f, 0.47466904f, 1.06489110f, 0.10544024f, 0.12794220f, 1.16130245f, 
    0.30334082f, -0.32753378f, 0.75539052f, -0.54817969f, -0.62159437f, -0.72257596f, -0.70290333f, -0.77477360f, 
    -0.92609787f, -0.29573923f, 0.86097676f, 0.70503223f, 0.22863305f, 0.73950601f, -0.39399737f, -1.35627949f, 
    0.01655363f, -0.88243270f, -0.74109811f, -0.11783799f, 0.64442903f, -1.02719200f, -0.83695513f, -0.77975070f, 
    0.82953036f, 0.49791023f, -0.26202482f, -0.49355593f, 0.69701123f, 0.35366413f, 0.32894093f, 0.65361142f, 
    0.52498502f, -0.49191681f, -0.55673832f, -0.28862783f, -0.87827480f, -0.91847032f, -1.27801776f, -0.51889724f, 
    -0.72236466f, -0.75975895f, 0.65156269f, 0.13915785f, 1.10426128f, -0.78600210f, -0.82581472f, -0.63595849f, 
    0.23467340f, -0.16935168f, 0.70760190f, -1.18494737f, -0.71293485f, 0.78978938f, -0.93143642f, 0.51201200f, 
    -1.23638344f, -0.44516179f, 0.31773031f, 0.48243615f, 1.03081906f, -0.45743194f, 0.73613816f, -0.75337446f, 
    0.19650123f, 0.29397127f, -0.47922719f, -0.56132472f, 0.77119321f, -1.50256765f, -1.46688807f, -0.87538624f, 
    0.49445653f, 0.11531155f, -0.94632488f, 0.15668698f, 0.23025239f, 0.32789651f, 0.24502631f, -0.10496783f, 
    0.04452544f, 0.11560802f, -0.18993208f, 0.02006025f, 0.94288427f, -0.08386455f, -0.78016907f, 0.79900086f, 
    0.94729471f, 0.78746635f, 0.37875560f, 0.20666234f, 0.49245992f, 0.45583662f, 0.39747119f, 0.22461545f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.09842750f, 0.53935462f, -0.19498590f, -0.03993588f, 0.36446881f, 0.27290875f, 0.45255616f, 0.72633404f, 
    1.03059137f, -0.31264082f, -0.15364400f, 0.06184457f, 0.02859108f, -0.11329464f, 1.07509768f, -0.40498105f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.68669850f, -0.38357127f, -0.05795548f, -0.20726337f, 0.07806261f, 0.02847149f, 0.06619753f, -0.16894867f, 
    0.06319711f, -0.15107250f, -0.55376071f, -0.53156948f, -0.04037642f, -0.02462685f, -0.06986052f, 0.16804759f, 
    0.15015155f, 0.14244224f, -0.34305155f, -0.31285515f, 0.07632079f, -0.30784437f, -0.08654658f, -0.08143863f, 
    0.19057941f, 0.11268391f, -0.10897735f, 0.32422438f, -0.96173418f, 0.04239113f, 0.11854852f, -0.40689221f, 
    -0.10935678f, -0.11840291f, -0.17175740f, -0.18148857f, -0.20061448f, -0.20185943f, 0.17650424f, 0.00037501f, 
    0.13812767f, -0.24271609f, 0.08603849f, 0.17740124f, 0.00001526f, 0.17082073f, -0.34220353f, 0.02272973f, 
    0.01285897f, -0.04788573f, 0.00694287f, 0.06865262f, -0.09833127f, 0.05905751f, 0.21433468f, 0.32563516f, 
    0.41356811f, 0.00594461f, 0.11826161f, -0.11160896f, 0.00381888f, -0.07685106f, 0.07941471f, 0.07594105f, 
    0.09790459f, 0.42939556f, -0.10770603f, 0.18690886f, -0.00804363f, -0.01176446f, 0.18355247f, 0.13368687f, 
    0.41421938f, 0.02169300f, 0.13583344f, -0.20902427f, 0.38294426f, 0.10561035f, -0.00709631f, 0.30635330f, 
    0.00450357f, -0.07584775f, -0.01269226f, 0.02098008f, 0.04097211f, -0.09633751f, -0.11738528f, -0.00997470f, 
    -0.07948855f, 0.25872776f, 0.56053776f, -0.19022416f, 0.44151729f, -0.03341943f, -0.29706240f, 0.06757273f, 
    -0.26034209f, 0.09369260f, 0.29325643f, -0.30521604f, -0.30682164f, -0.81206083f, 0.14927922f, 0.03546038f, 
    0.09476016f, -0.15079018f, -0.20512283f, 0.08393848f, 0.10749743f, 0.00027916f, -0.02405135f, -0.34282836f, 
    -0.26304084f, 0.01676044f, -0.03032600f, -0.03272310f, -0.09754722f, -0.14375070f, -0.01592959f, 0.21115920f, 
    -0.07859280f, 0.07176094f, 0.01592807f, 0.03946589f, -0.00864951f, 0.09615981f, -0.00086864f, -0.04659374f, 
    0.33063227f, -0.11347186f, -0.02342761f, 0.20994075f, 0.20649420f, 0.24836758f, 0.35816613f, 0.11024359f, 
    -0.09506104f, 0.15720610f, -0.35723945f, -0.03774525f, -0.34424534f, -0.04976682f, 0.03393563f, 0.06338207f, 
    0.45567152f, 0.03281202f, 0.43803665f, -0.11063779f, -0.55760580f, -0.38218945f, -0.14171797f, 0.00767838f, 
    0.15107815f, -0.24201475f, -0.09643135f, 0.18601803f, 0.16733861f, 0.20735113f, -0.02797408f, -0.01795480f, 
    0.01264287f, 0.04108569f, 0.19923005f, -0.22032802f, -0.23048680f, 0.02422710f, -0.01812190f, -0.07299712f, 
    0.08621463f, 0.04953563f, -0.11595614f, -0.22888680f, 0.16114564f, -0.66317612f, -0.18135825f, -0.13927858f, 
    -0.31366241f, -0.03962431f, -0.12005366f, -0.06724543f, 0.07915795f, 0.19037637f, 0.02225508f, 0.20223676f, 
    0.12871550f, -0.24564947f, 0.17737703f, 0.03247818f, -0.06382313f, -0.28761727f, -0.36123136f, 0.09816458f, 
    -0.28179213f, -0.13566329f, -0.06417628f, 0.16457416f, 0.06751739f, 0.14046118f, 0.29676685f, -0.10166869f, 
    0.30525613f, 0.06711061f, -0.48973292f, -0.14972067f, -0.05556543f, -0.06962435f, -0.06693500f, -0.01069408f, 
    -0.06372718f, 0.54264337f, 0.02268971f, 0.00640381f, 0.35231489f, 0.02984497f, 0.01438997f, 0.02870505f, 
    -0.27570748f, 0.56087017f, 0.20123316f, 0.10276991f, -0.09651597f, -0.06025934f, 0.08877989f, -0.23249346f, 
    0.06682590f, -0.20361194f, -0.27796581f, 0.10356548f, -0.11808844f, -0.17891376f, 0.03755605f, 0.05517744f, 
    -0.07981444f, 0.05531562f, -0.08708615f, 0.28590935f, 0.02365934f, 0.14371768f, 0.12931305f, 0.01417138f, 
    -0.05173009f, 0.23801692f, -0.05444178f, 0.37451181f, -0.35067159f, -0.50090390f, -0.15004657f, -0.05229018f, 
    -0.16390078f, -0.04570897f, -0.08209966f, -0.04981258f, -0.64514440f, -0.39132252f, -0.11008827f, 0.03506590f, 
    0.13644454f, -0.30522582f, 0.09694605f, -0.03747748f, 0.14150609f, -0.01722777f, -0.47597873f, 0.24290398f, 
    -0.05385150f, -0.10900574f, -0.00771638f, 0.02893320f, -0.17165472f, 0.12366349f, 0.10450905f, 0.13978636f, 
    0.20405260f, 0.26059306f, 0.21998261f, -0.08898207f, 0.36368176f, 0.19196162f, 0.11623675f, -0.55267256f, 
    -0.35188025f, -0.27933154f, -0.47152841f, -0.21779291f, 0.18223792f, 0.11542488f, -0.06373558f, 0.10965483f, 
    0.49700230f, 0.16504754f, 0.14001380f, 0.01103946f, -0.02783245f, -0.10838785f, -0.14677951f, 0.09767848f, 
    0.18561456f, -0.16562515f, -0.56410444f, 0.03154379f, -0.00096587f, -0.40065473f, -0.12905356f, 0.03806597f, 
    0.07315929f, 0.41133931f, 0.70318669f, 1.02079463f, 0.39599323f, -0.04063034f, 0.06913140f, -0.05458885f, 
    0.09211853f, -0.12950282f, -0.07765111f, 0.06878973f, -0.13670486f, -0.79917496f, -0.13583604f, -0.27031246f, 
    0.10907118f, 0.08205151f, 0.17169286f, -0.14048113f, 0.11099813f, -0.05420176f, 0.26418361f, 0.09556168f, 
    0.31109479f, 0.24996474f, -0.04734870f, -0.09552396f, -0.01879629f, 0.22255251f, -0.35946071f, -0.36617950f, 
    0.23250103f, 0.02121226f, -0.01818948f, 0.17113659f, 0.09964276f, 0.26194263f, -0.30900225f, -0.32584989f, 
    0.00748222f, 0.04847483f, 0.11389485f, 0.13464332f, 0.19127111f, 0.03926042f, 0.06189865f, 0.14623246f, 
    -0.01767806f, 0.14311838f, 0.13059323f, 0.12731729f, 0.15904678f, -0.03324085f, -0.00683961f, -0.04142538f, 
    -0.20472923f, -0.24102932f, -0.39289227f, 0.07069804f, -0.01198577f, 0.13105468f, -0.00629027f, 0.20800024f, 
    -0.02250979f, 0.68253773f, 0.40265140f, 0.56042099f, -0.04705721f, 0.05522850f, 0.06061365f, -0.12708956f, 
    0.01027507f, -0.00083009f, -0.11312482f, -0.45819381f, -0.22285292f, -0.37821907f, -0.07104499f, -0.41176170f, 
    0.35877267f, -0.11894808f, -0.04070561f, 0.62337536f, 0.35328266f, 0.22185899f, -0.19361214f, -0.07000357f, 
    -0.11336373f, -0.03352958f, 0.07225616f, 0.05715942f, -0.07627464f, -0.18365085f, -0.29631913f, 0.17433888f, 
    -0.03670672f, -0.04185438f, 0.27573037f, 0.28079993f, 0.10516396f, 0.45817798f, 0.22511570f, 0.68302608f, 
    0.47278553f, -0.12577133f, -0.08315652f, 0.18258396f, 0.12622967f, 0.17239942f, -0.31896755f, -0.16566740f, 
    -0.39404491f, 0.25329223f, 0.06211345f, -0.03693972f, -0.00973580f, 0.04751353f, -0.00897275f, 0.29977918f, 
    0.27258387f, 0.24757220f, 0.37012339f, 0.18885890f, -0.09588391f, 0.14606614f, 0.18438901f, 0.32784775f, 
    0.00619729f, 0.04971478f, 0.07779984f, -0.45120651f, -0.19246998f, -0.20995434f, 0.08504640f, -0.15813254f, 
    -0.05658290f, -0.01593232f, 0.19992019f, 0.10117120f, 0.34070793f, 0.07698146f, -0.14519043f, 0.03676642f, 
    0.10475615f, 0.16974813f, -0.69375032f, -0.17782529f, -0.55271196f, -0.12426071f, 0.05586343f, 0.20332569f, 
    -0.01351826f, -0.18096817f, -0.18041606f, -0.23423558f, -0.12420214f, 0.01628683f, 0.11735083f, -0.19351225f, 
    0.13442770f, 0.01650367f, -0.26600063f, -0.05409025f, 0.06141889f, -0.11459526f, 0.10109594f, 0.26238096f, 
    0.10054226f, 0.25843468f, -0.16235992f, -0.15194072f, 0.15585580f, 0.01228263f, 0.12423814f, 0.00806252f, 
    -0.06108994f, 0.25620377f, -0.13364211f, 0.16396661f, -0.02718296f, 0.28187570f, -0.39903653f, -0.15256661f, 
    0.15918581f, -0.10268294f, -0.44299591f, 0.15253365f, 0.11987063f, 0.04676912f, -0.03678351f, 0.05654244f, 
    0.13817084f, -0.42521521f, 0.09521969f, 0.03502578f, -0.22107670f, -0.01217138f, 0.24411669f, 0.28331479f, 
    0.12900175f, 0.15904850f, -0.00082880f, 0.34612596f, 0.07003155f, 0.24104367f, -0.04592054f, 0.04988227f, 
    -0.05754375f, -0.21585789f, 0.14718896f, -0.50370234f, 0.02125693f, 0.07613522f, 0.01883090f, 0.01649349f, 
    -0.06416605f, -0.24764659f, 0.19581228f, -0.15318519f, 0.23908935f, 0.03691924f, 0.26410648f, 0.19942294f, 
    -0.07368413f, 0.11964336f, 0.14580731f, -0.32968885f, 0.53373778f, -0.38909611f, 0.00188923f, 0.22970280f, 
    0.01696764f, -0.01554833f, -0.19375716f, -0.30877402f, -0.00115696f, 0.01144550f, -0.23941529f, -0.17416714f, 
    0.15585066f, 0.04724104f, -0.01333997f, 0.16947833f, -0.08294860f, 0.05935387f, 0.49759772f, 0.51129138f, 
    -0.11827948f, 0.05173839f, 0.04013392f, 0.00898244f, 0.04482815f, -0.06081777f, -0.03605964f, 0.21171713f, 
    0.11038037f, 0.21420781f, 0.17481270f, 0.32014665f, 0.15258242f, 0.09003450f, 0.41004205f, 0.17276497f, 
    -0.06199411f, 0.28536388f, 0.16501631f, 0.05160625f, -0.07370802f, -0.13916659f, -0.23149239f, -0.00661219f, 
    -0.07507222f, 0.18922146f, -0.28450045f, -0.27510747f, -0.45831692f, -0.32886481f, 0.07388856f, 0.12112992f, 
    0.28700384f, -0.67070860f, 0.15410003f, 0.51100564f, -0.08956294f, -0.12794675f, -0.03744648f, 0.01372331f, 
    0.32633343f, 0.28203034f, 0.27883363f, -0.03614965f, 0.51466012f, -0.15262790f, -0.21715499f, -0.01994828f, 
    0.03186282f, 0.06291170f, -0.16279294f, -0.71672100f, 0.01070806f, -0.15616441f, 0.09552102f, 0.12915690f, 
    0.37451342f, -0.15095550f, -0.31885979f, -0.04505596f, 0.21053550f, 0.22603026f, -0.20061190f, 0.18165267f, 
    0.03642974f, -0.39251521f, -0.01483496f, -0.00477790f, 0.00517812f, -0.51426733f, 0.17486762f, -0.09748279f, 
    0.00736812f, 0.04480137f, 0.06606009f, 0.09044371f, 0.02123755f, 0.25072584f, -0.23909119f, 0.36952683f, 
    0.27276543f, 0.17673275f, -0.55121249f, -0.26683268f, 0.19363840f, -0.06475757f, 0.14964938f, -0.33577839f, 
    -0.12556465f, -0.23902924f, 0.13147451f, -0.24721815f, 0.33111969f, 0.05542496f, 0.09117882f, 0.06118499f, 
    0.03008763f, 0.22787930f, 0.15179482f, 0.13193265f, 0.15492526f, 0.08505917f, -0.12388757f, -0.02787335f, 
    -0.28702262f, 0.19287921f, -0.10328022f, 0.35791600f, 0.25198629f, 0.00485158f, -0.10178208f, -0.01226326f, 
    0.09663534f, 0.05295520f, -0.34982163f, 0.62979418f, -0.28949475f, 0.10003284f, 0.07459668f, 0.04705805f, 
    -0.13940117f, -0.15476860f, -0.20507754f, -0.48283479f, 0.12959439f, -0.06835649f, -0.21870863f, 0.15009078f, 
    -0.47501332f, 0.00168716f, -0.03950823f, -0.10484087f, -0.68472946f, 0.08927576f, -0.07127703f, 0.06857204f, 
    -0.12421108f, 0.49359596f, 0.11839723f, 0.09568235f, 0.04134385f, -0.34369257f, -0.23114552f, 0.18642220f, 
    0.16386548f, 0.15890755f, -0.17177348f, -0.06365465f, 0.12588504f, -0.03633107f, -0.24334003f, -0.10284282f, 
    0.26321509f, 0.14946134f, -0.00932856f, 0.06186525f, 0.23757888f, 0.07290643f, 0.08450118f, 0.08218966f, 
    0.05358401f, -0.13569929f, 0.03209321f, -0.03589709f, 0.08432829f, 0.28734922f, 0.18852484f, -0.17693684f, 
    -0.11282069f, -0.49367312f, -0.40201166f, 0.09684010f, -0.04240171f, -0.23884831f, -0.20383009f, 0.07210628f, 
    0.01026846f, -0.27440727f, 0.00591018f, 0.13198952f, 0.05015779f, -0.12022971f, -0.33496761f, 0.14971109f, 
    0.11076286f, -0.03549561f, 0.23480120f, -0.15407097f, 0.45817199f, 0.04540717f, 0.17190455f, -0.22119264f, 
    -0.15450677f, 0.06194293f, 0.16770746f, -0.24716635f, 0.10629134f, -0.47965366f, 0.04239521f, -0.34158430f, 
    0.27209204f, -0.05626706f, -0.01294943f, 0.04483158f, 0.11147346f, 0.14756572f, 0.17658587f, -0.30086496f, 
    0.22571568f, 0.06574570f, 0.23793788f, -0.02309965f, 0.04139686f, 0.30107489f, -0.06678996f, 0.38399389f, 
    -0.07471721f, 0.01616524f, -0.13956042f, -0.05116972f, 0.02972382f, 0.19204296f, -0.24254009f, -0.16158745f, 
    0.10366446f, 0.18731454f, -0.11650746f, 0.19717617f, -0.09906401f, -0.05600602f, 0.40468869f, 0.06355777f, 
    0.13262852f, -0.17772999f, 0.13079213f, -0.11376511f, -0.03897554f, -0.13166340f, 0.18546328f, -0.03944490f, 
    0.19087848f, -0.07768142f, -0.10493279f, 0.04934106f, 0.05889579f, -0.10069989f, 0.35761660f, 0.13842885f, 
    0.13400127f, -0.10851552f, 0.03678535f, 0.54910457f, 0.05875650f, -0.16684353f, -0.17865790f, 0.11953513f, 
    0.26919672f, 0.00940172f, 0.13845794f, 0.20131260f, 0.15475008f, -0.04285485f, -0.16946928f, -0.11693060f, 
    -0.04642162f, 0.21896206f, -0.06037839f, -0.27020878f, -0.23780173f, 0.36291033f, 0.17275082f, -0.03540159f, 
    -0.03555238f, 0.10369744f, 0.02194245f, -0.06685937f, 0.34290895f, -0.10866601f, -0.64888519f, -0.02256531f, 
    -0.38525558f, 0.04029111f, -0.00713323f, 0.39154780f, -0.26226440f, -0.54483885f, -0.15246657f, 0.43182585f, 
    0.12359928f, -0.13851720f, -0.21100837f, -0.00474202f, 0.04196550f, -0.06047722f, -0.11117522f, 0.71189511f, 
    0.53570336f, 0.14181560f, 0.01623679f, -0.05470024f, 0.36346635f, 0.32723972f, 0.34875527f, 0.23024566f, 
    0.09443359f, 0.14575729f, -0.11497842f, -0.22315489f, -0.43499264f, -0.05069052f, 0.10841746f, 0.06133089f, 
    -0.60150748f, -0.28529546f, 0.36416167f, 0.03191033f, 0.07690731f, -0.48862550f, 0.16234979f, -0.01693605f, 
    -0.34712321f, -0.48150137f, -0.57000941f, 0.82551438f, 0.00544853f, -0.09913029f, 0.04774030f, 0.17748623f, 
    -0.01407401f, -0.25997680f, -0.03385777f, 0.16703430f, -0.03082186f, -0.02322660f, -0.11805694f, -0.34208241f, 
    0.00841601f, 0.06252228f, 0.10076262f, 0.09778498f, -0.66407561f, -0.31348640f, -0.01456837f, 0.10473663f, 
    0.59092134f, 0.07574983f, 0.00417473f, 0.11747083f, -0.18245438f, -0.27342582f, -0.25105977f, 0.16619484f, 
    0.20726962f, 0.11089122f, 0.13025817f, 0.15421470f, 0.24541250f, 0.31221089f, -0.67277777f, 0.18087840f, 
    -0.09493764f, -0.16533796f, -0.16981597f, 0.15217812f, -0.21232790f, -0.05901261f, -0.20533428f, -0.05868433f, 
    0.22505458f, 0.03260698f, 0.31041139f, -0.10939465f, 0.30399513f, 0.00471474f, -0.00088981f, -0.74916959f, 
    0.11621888f, 0.15900446f, 0.13471846f, 0.15463582f, 0.01881423f, 0.22200328f, 0.09931661f, -0.36336449f, 
    -0.32781339f, -0.45570761f, 0.23755684f, -0.12375472f, 0.32652178f, -0.15906852f, 0.07204569f, 0.01513806f, 
    0.38290828f, 0.08297030f, 0.14126107f, 0.13368985f, -0.13857093f, 0.06776736f, -0.32519108f, 0.21020848f, 
    -0.04755324f, 0.10267791f, -0.28433919f, -0.31293240f, -0.52662152f, -0.11029495f, 0.24337266f, -0.02998130f, 
    -0.38208511f, -0.05575925f, 0.08949894f, -0.28004551f, -0.00733658f, 0.48603648f, -0.12716518f, -0.05962317f, 
    0.07284144f, -0.18739146f, 0.13590696f, 0.14234784f, 0.59822607f, -0.15597349f, 0.04303092f, -0.15260130f, 
    -0.27868485f, -0.09098117f, -0.33498356f, -0.05734199f, 0.16550228f, 0.22085826f, -0.02442203f, 0.13153854f, 
    -0.28343672f, -0.01395620f, -0.15666094f, -0.07621565f, 0.03652756f, -0.02852722f, 0.27893785f, 0.12768275f, 
    0.03722367f, 0.24187151f, 0.07385927f, 0.03470023f, 0.19951458f, 0.16117463f, -0.00367353f, 0.34940028f, 
    0.13270213f, 0.28602618f, -0.16050178f, -0.16571307f, -0.45758191f, -0.03344868f, 0.12908776f, 0.15134609f, 
    -0.53982627f, 0.15903021f, -0.19230343f, 0.05649711f, -0.07023329f, 0.27484107f, 0.08618854f, 0.17335106f, 
    0.27873772f, 0.10923716f, -0.11791810f, 0.19155604f, 0.16042553f, -0.00647417f, 0.07908612f, 0.12639645f, 
    0.16888079f, 0.13966511f, -1.78713465f, -0.97881019f, -0.12430570f, -0.26298365f, 0.07827641f, -0.07070681f, 
    0.10415330f, 0.06173069f, -0.07594988f, 0.62305802f, -0.29429790f, -0.01035068f, -0.03854576f, -0.01321511f, 
    0.47252250f, 0.14312367f, 0.04137770f, -0.14811274f, -0.15527375f, 0.17891835f, 0.14088739f, 0.25726798f, 
    -0.04089186f, -0.28661871f, -0.07108567f, -0.09707198f, -0.08540004f, 0.17043380f, 0.23203528f, 0.03229227f, 
    -0.07891922f, -0.00427336f, -0.14036976f, 0.03610313f, 0.23875347f, 0.21830697f, -0.56223482f, 0.16642517f, 
    0.45388380f, -0.22299474f, 0.13425338f, 0.05154250f, 0.23521829f, 0.12752499f, 0.11748082f, -0.21164697f, 
    -0.10251364f, -0.24465066f, 0.02407979f, 0.18113141f, 0.07227029f, -0.06813387f, 0.21579343f, 0.20900337f, 
    0.22251624f, 0.01972910f, -0.04082258f, 0.07609923f, -0.01454987f, -0.03149153f, 0.16679130f, 0.08500636f, 
    0.00836202f, -0.34097195f, 0.04723941f, -0.11768288f, -0.24273407f, -0.20853901f, -0.15167525f, -0.03338722f, 
    -0.13512428f, 0.22610277f, 0.24692340f, -0.86149526f, -0.46266675f, 0.02504386f, 0.07592449f, -0.00944463f, 
    0.07985466f, -0.03723840f, -0.13828015f, -0.20255598f, -0.53174126f, 0.59060746f, 0.10682859f, -0.13064431f, 
    -0.16218555f, 0.19149196f, 0.01765766f, 0.08714852f, 0.13722210f, -0.16618678f, 0.04742599f, -0.08077722f, 
    0.06266621f, -0.00895382f, -0.02238704f, 0.10308777f, -0.11703368f, -1.74059689f, -0.04309577f, 0.46363163f, 
    0.14364688f, 0.06364038f, 0.13953874f, -0.08178901f, -0.00749109f, -0.16553324f, 0.15433890f, 0.15430868f, 
    0.08199871f, 0.36906603f, 0.28687900f, 0.11063324f, 0.28738049f, 0.05189992f, 0.55783218f, 0.23688406f, 
    -0.05279435f, -0.20357008f, 0.01404135f, -0.15920700f, 0.03717209f, -0.13991535f, 0.06876124f, -0.06719521f, 
    -0.33025727f, 0.25662923f, 0.12966999f, -0.46944967f, -0.12870669f, 0.16226315f, 0.10986461f, 0.05341234f, 
    0.22112894f, -0.13478059f, -0.31031248f, -0.00833810f, 0.43070394f, -0.07551185f, -0.14769487f, 0.01208400f, 
    0.01036869f, 0.02196619f, -0.48155776f, 0.17560650f, -0.63663977f, -0.01217789f, -0.03548207f, -0.37957475f, 
    0.11056286f, 0.02904250f, 0.03852638f, 0.02631721f, -0.64673221f, -0.36023402f, 0.15215647f, -0.66434032f, 
    -0.26751533f, 0.22769448f, 0.02479925f, -0.15457246f, 0.28595239f, -0.24498823f, -0.58602411f, -0.00330635f, 
    -0.10404710f, -0.10805193f, 0.20561749f, 0.02212400f, -0.03377997f, -0.27811006f, -0.16252320f, -0.09679496f, 
    0.04158536f, 0.18371642f, 0.12925719f, -0.29695579f, 0.17675252f, 0.35585776f, -0.08259094f, 0.37991309f, 
    0.78577441f, -0.00063887f, 0.14346895f, 0.11229565f, 0.06852814f, -0.05583583f, 0.02624575f, 0.22815110f, 
    -0.08700496f, 0.23179632f, -0.07046383f, -0.09278464f, 0.02286293f, -0.04166465f, -0.14153084f, 0.11553792f, 
    0.37601450f, 0.19049339f, 0.03562099f, -0.09615555f, 0.25534281f, 0.33162010f, 0.23326659f, 0.19766504f, 
    0.11005041f, -0.21914190f, 0.10549527f, -0.24286833f, -0.01073506f, 0.05015714f, -0.22731583f, 0.10121280f, 
    0.06658077f, 0.11656284f, 0.24000302f, -0.54149824f, -0.59495544f, 0.14095159f, 0.14174926f, -0.18139054f, 
    0.19409236f, 0.02833835f, -0.22067870f, -0.23811941f, -0.68639874f, -0.62034810f, 0.03727729f, 0.00298762f, 
    -0.26805151f, 0.15547571f, 0.00080040f, -0.02964590f, 0.00225488f, -0.03849488f, -0.11846523f, 0.10871321f, 
    0.11050183f, 0.04733017f, 0.27473703f, -0.01481354f, -0.11355880f, -1.03485978f, 0.18254887f, 0.30914184f, 
    -0.15407567f, 0.27525890f, -0.20188268f, -0.02961487f, 0.16307943f, -0.01475541f, 0.18250528f, 0.14418325f, 
    0.23397934f, 0.08079345f, 0.44160995f, 0.08557258f, 0.36220890f, 0.21013422f, 0.49067661f, 0.10237537f, 
    -0.13800740f, -0.03533567f, -0.26783821f, -0.06163984f, -0.13510931f, -0.08159759f, -0.12686189f, -0.03886022f, 
    -0.93253559f, -0.47868285f, -0.23522985f, -0.28061569f, 0.03418662f, -0.26494884f, -0.01769245f, -0.09590438f, 
    0.13061315f, 0.14952847f, 0.23653327f, 0.11177738f, -0.14724562f, -0.03691894f, 0.05480691f, 0.11133724f, 
    0.09072176f, -0.11564103f, -0.54918635f, -0.24980766f, 0.18502143f, -0.16453537f, 0.19950363f, -0.04306097f, 
    -0.09102826f, -0.02968403f, 0.07300970f, -0.36326069f, -0.27964839f, -0.53682560f, -0.21301337f, 0.29565102f, 
    0.03556628f, 0.19424438f, -0.04281713f, -0.25547624f, -0.16441590f, 0.22772247f, 0.23475368f, -0.06669856f, 
    0.22632019f, 0.13568680f, 0.12353939f, 0.01820986f, 0.10349379f, 0.15499792f, 0.37624368f, 0.33313179f, 
    -0.28126630f, -0.30482894f, 0.06387515f, 0.08496653f, -0.19981232f, 0.35363132f, -0.33479577f, -0.88068968f, 
    -0.21866113f, 0.22832948f, 0.14861506f, 0.09797166f, -0.13169272f, -0.01640774f, 0.00813692f, 0.10377700f, 
    -0.91194302f, -0.19765268f, 0.19293258f, 0.04012468f, 0.27356926f, 0.06998629f, 0.02638896f, -0.13031657f, 
    0.24755901f, 0.24992423f, 0.23981225f, 0.01219792f, 0.05303081f, 0.06332349f, 0.35783711f, 0.00658267f, 
    0.18939601f, -0.25354871f, -0.07122116f, -0.71379477f, -0.28125405f, -0.16536015f, 0.02802547f, 0.24443564f, 
    -0.08971520f, 0.11493366f, 0.48998073f, 0.14899966f, 0.09595419f, 0.04823474f, -0.13251099f, -0.09736021f, 
    -0.00382526f, 0.00875161f, 0.04770442f, -0.26344076f, -0.36607638f, -0.49543411f, -0.06385743f, -0.12329043f, 
    0.25193325f, 0.24590136f, -0.03258109f, -0.11058658f, 0.58289379f, -0.22533192f, 0.29945153f, 0.06542818f, 
    -0.12593962f, -0.28610131f, -0.03311981f, -0.13148595f, 0.04660863f, -0.01624811f, -0.50512606f, -0.78134847f, 
    -0.44919556f, 0.37016690f, 0.05387581f, -0.05938426f, -0.01340214f, -0.08364443f, 0.04777180f, 0.32546893f, 
    0.30413729f, -0.01206704f, 0.28827518f, 0.04050289f, 0.11502659f, 0.36406317f, 0.20234522f, 0.18719736f, 
    0.27263251f, -0.19723928f, -0.30018705f, -0.27186012f, -0.22507554f, 0.25835043f, -0.30049750f, 0.06342331f, 
    -0.01836359f, -0.07956756f, -0.09845784f, -0.13924275f, -0.15927726f, -0.12175950f, -0.11281884f, -0.05935280f, 
    -0.13560066f, -0.00173762f, 0.15786445f, 0.11165943f, -0.32247955f, -0.09375494f, -0.00353873f, 0.10019092f, 
    -0.11455656f, -0.01124853f, -0.04475426f, -0.22195639f, 0.34572092f, -0.04789415f, 0.20554185f, -0.02874458f, 
    0.03838030f, -0.23575287f, 0.10237599f, 0.24355771f, 0.69045031f, -0.25195509f, -0.02713027f, 0.05603700f, 
    0.23404504f, 0.17080401f, 0.22917175f, -0.17416185f, 0.05998009f, 0.37264732f, 0.22773413f, -0.04736798f, 
    0.27827302f, -0.16413145f, 0.13175343f, 0.10065809f, 0.08764259f, 0.03754219f, 0.35547763f, -0.21419454f, 
    -0.07241406f, -0.01446766f, 0.09929762f, -0.00148027f, -0.01833808f, 0.05523469f, -0.14554487f, -0.11419398f, 
    0.46820706f, 0.16108140f, -0.03808501f, -0.14469397f, -0.02862448f, 0.04952966f, 0.18790980f, 0.10841360f, 
    -0.24494049f, -0.04638321f, 0.00380464f, -0.14931776f, 0.06472368f, 0.05329142f, 0.06047585f, -0.08663476f, 
    -0.00173549f, 0.29926550f, -0.07252120f, -0.09307929f, 0.12895723f, 0.01150304f, 0.21470323f, 0.11845274f, 
    0.09300052f, -0.00192170f, -0.24062313f, 0.23035882f, 0.17282031f, 0.09098388f, -0.07300767f, 0.05103803f, 
    -0.08770354f, 0.16423187f, -0.08909178f, 0.52124989f, 0.43222195f, 0.01066937f, 0.08781643f, -0.11474906f, 
    0.07309190f, -0.09016350f, 0.06853367f, 0.27269053f, 0.08551251f, 0.03274804f, 0.15159646f, -0.10204977f, 
    0.05936006f, -0.06310084f, 0.03910356f, -0.09409744f, -0.38103610f, -0.24000694f, -0.05889662f, 0.13527693f, 
    0.04641135f, 0.17671143f, 0.03709703f, 0.04273262f, -0.04907957f, -0.28068790f, -0.75210959f, 0.11509980f, 
    0.18394053f, 0.29076079f, 0.06486206f, -0.21506962f, -0.07037734f, -0.16944019f, -0.12624203f, 0.23581553f, 
    0.59171760f, -0.05545783f, 0.07937273f, -0.01449346f, 0.23403607f, -0.12871689f, 0.18325281f, -0.02199056f, 
    0.13228010f, -0.29342577f, 0.10289174f, -0.19609746f, -0.19867198f, 0.21797942f, 0.15659590f, 0.09329500f, 
    -0.18156150f, -0.63801986f, -0.21936470f, -0.46482798f, 0.05396568f, -0.04885157f, 0.09234110f, 0.07296414f, 
    0.32714981f, -0.01186308f, 0.20225692f, 0.02205127f, 0.31569323f, -0.13952245f, -0.11638629f, -0.11446531f, 
    0.20166266f, -0.05275587f, 0.30897382f, -0.05936067f, 0.29677564f, -0.16514230f, 0.07220179f, -0.05796622f, 
    0.03628119f, -0.12326297f, 0.03838952f, 0.20454869f, 0.09852184f, 0.02174770f, 0.11284222f, 0.18056682f, 
    0.19411473f, 0.03977397f, 0.47402582f, 0.02383266f, 0.21398062f, 0.43884405f, 0.32408020f, -0.18342902f, 
    0.00876748f, 0.06490757f, -0.04120997f, 0.06011173f, -0.23629977f, 0.22142190f, 0.00613795f, 0.32822356f, 
    -0.06280363f, -0.21350469f, 0.05973173f, 0.07816062f, -0.12795876f, -0.27963188f, 0.16892502f, -0.57253265f, 
    -0.19885236f, -0.00132812f, 0.41473892f, 0.18572359f, -0.04321744f, 0.01169583f, 0.15408365f, -0.22145417f, 
    -0.63135886f, -0.06374314f, -0.17141934f, 0.03679894f, 0.42043400f, -0.05759779f, 0.10407938f, 0.24454620f, 
    0.08128493f, -0.08894489f, 0.11044160f, -0.24478070f, 0.07149448f, 0.00971331f, -0.10611752f, 0.16352092f, 
    -0.12051427f, -0.11719152f, 0.18271104f, 0.19902363f, 0.03533968f, -0.01881369f, 0.00704836f, 0.17734466f, 
    -0.17858793f, 0.21447162f, 0.11110363f, 0.33895236f, 0.42650622f, 0.17322889f, 0.02412731f, 0.04281731f, 
    0.02261670f, -0.43995187f, 0.14215556f, -0.33144289f, -0.24829525f, 0.25301391f, -0.06593362f, 0.09465493f, 
    0.02316102f, 0.15139166f, -0.00410848f, 0.25564441f, 0.13351540f, -0.15615857f, 0.16206408f, 0.14662516f, 
    -0.20304237f, -0.06367048f, 0.03139383f, -0.19329640f, 0.05360453f, -0.13116002f, 0.03487914f, -0.23050533f, 
    0.13145125f, -0.08273415f, 0.05736937f, 0.05230029f, -0.21624452f, -0.18051456f, -0.13799803f, 0.28024408f, 
    -0.01629418f, 0.14939293f, 0.22775133f, -0.32469565f, -0.15710829f, 0.00301089f, -0.27162266f, 0.10542987f, 
    0.17774804f, -0.08366185f, -0.03462305f, 0.01136015f, 0.17230321f, -0.06691161f, 0.24042523f, 0.11468307f, 
    -0.05740099f, -0.16722955f, -0.29515973f, 0.17607695f, -0.01126561f, 0.19924109f, -0.14721644f, -0.23048872f, 
    -0.14410877f, 0.34713846f, -0.33158290f, 0.34573650f, 0.14686587f, 0.01231292f, 0.19644512f, -0.11968534f, 
    -0.00772690f, 0.07848353f, 0.10800233f, 0.31320229f, -0.44443667f, -0.12707767f, -0.09826345f, 0.04801134f, 
    0.11988349f, 0.28732774f, -0.19032310f, 0.20592739f, 0.26983672f, 0.23028931f, -0.03910597f, -0.13866684f, 
    0.07518523f, -0.08714005f, 0.02831292f, -0.07737397f, 0.01772141f, -0.19228806f, -0.21829994f, -0.18308231f, 
    0.31266677f, 0.05076289f, 0.39877957f, 0.29350144f, 0.21336137f, -0.18159719f, -0.14849727f, 0.01170888f, 
    -0.06644907f, 0.06516457f, -0.00792922f, -0.08772548f, -0.16715288f, -0.58766723f, 0.13879250f, 0.13840178f, 
    0.14326219f, -0.11830870f, -0.02458615f, -0.26886874f, -0.25577965f, -0.21463206f, -0.09514835f, 0.27090973f, 
    0.27150214f, 0.40256897f, -0.08171100f, -0.01864507f, -0.13358246f, -0.27021813f, -0.08362107f, -0.29684564f, 
    0.10589671f, 0.05518628f, 0.13925284f, -0.00523024f, 0.18750380f, 0.30392501f, 0.07656447f, 0.12124764f, 
    0.22632293f, 0.00608234f, 0.15574138f, -0.59434199f, 0.22919010f, 0.13995239f, 0.20993400f, 0.10002435f, 
    -0.16681291f, -0.65173817f, -0.86676854f, -0.05683756f, -0.04822507f, 0.19268474f, 0.32056823f, 0.10815978f, 
    -0.10928325f, 0.10026571f, 0.25769180f, 0.58934969f, 0.27033845f, 0.14358392f, -0.00076528f, 0.02176496f, 
    0.22025387f, 0.28314167f, -0.12650572f, 0.08558449f, 0.03706042f, -0.03659189f, 0.08843786f, 0.06506767f, 
    0.10951965f, 0.17728257f, 0.08333036f, 0.03291415f, -0.00275782f, -0.14994802f, 0.42856184f, 0.19311923f, 
    -0.16650733f, 0.02653343f, -0.18083142f, 0.09967760f, 0.12801503f, 0.21270214f, 0.17842422f, 0.00780591f, 
    -0.08582859f, -0.17071393f, -0.11445022f, 0.20753826f, -0.27239046f, 0.19512129f, -0.07582672f, -0.15750435f, 
    -0.09023148f, 0.05200984f, 0.10666781f, 0.01301607f, 0.10597709f, 0.02374828f, -0.00648859f, -0.03010048f, 
    -0.18770699f, -0.14960784f, -0.36105853f, 0.07787409f, -0.07628481f, -0.10626321f, -0.24724886f, -0.46107239f, 
    -0.09285320f, 0.34628528f, -0.02480761f, 0.24371116f, 0.17624590f, -0.07467929f, 0.07248899f, 0.13843971f, 
    0.15294383f, 0.47142088f, -0.20868035f, -0.10135871f, -0.23009357f, -0.26906642f, -0.09177812f, 0.16315503f, 
    0.12223900f, 0.38134757f, -0.02547917f, -0.15236062f, 0.12854899f, 0.18618333f, 0.16218233f, -0.08581917f, 
    0.05861538f, -0.00139549f, 0.37057832f, 0.26122680f, 0.07055526f, 0.17172502f, 0.20656319f, -0.11682610f, 
    0.15101314f, 0.08574984f, 0.31469959f, 0.34126630f, 0.21004812f, -0.11184652f, -0.06441537f, -0.09525008f, 
    0.10394227f, -0.05270723f, 0.02661405f, 0.01649297f, -0.20373960f, -0.47560450f, -0.18746272f, -0.32892027f, 
    -0.22853605f, 0.24247894f, -0.08744825f, 0.10373126f, 0.19438502f, -0.41491857f, 0.07879581f, 0.42730907f, 
    0.00623912f, 0.27786940f, -0.08370198f, -0.36281350f, -0.10942741f, -0.11641635f, -0.08119861f, -0.10379607f, 
    0.12632573f, 0.04392823f, 0.19330832f, 0.24651217f, 0.01437997f, 0.34192750f, 0.12017126f, 0.10418107f, 
    0.37198892f, -0.31914282f, -0.46177378f, -0.50687999f, 0.02635809f, 0.00436022f, 0.15535347f, 0.02170547f, 
    -0.02872546f, -0.16836430f, -0.55218709f, 0.17778443f, 0.24216974f, 0.24925886f, 0.32487413f, -0.11792549f, 
    -0.02237233f, 0.22614279f, 0.07835584f, 0.13406628f, 0.36201087f, 0.13444889f, 0.07467769f, 0.05244555f, 
    0.02287896f, 0.17258984f, 0.14733759f, 0.10091747f, 0.10627703f, 0.21425079f, -0.03782709f, -0.02996974f, 
    0.37433535f, -0.03650770f, -0.11682089f, -0.01852357f, 0.02899530f, -0.13105567f, -0.06228690f, 0.14309473f, 
    -0.11103453f, -0.22188897f, -0.07270218f, -0.08138022f, 0.03008892f, 0.00560997f, -0.02259760f, 0.26840878f, 
    0.37060106f, -0.02910655f, 0.20971107f, 0.50655973f, -0.23932827f, 0.35662025f, 0.36433128f, -0.16704346f, 
    -0.09327399f, 0.03928465f, 0.02826964f, 0.04139483f, -0.04945599f, -0.20838484f, -0.11898085f, 0.18036386f, 
    0.09648137f, -0.36799243f, 0.16235581f, -0.12460986f, -0.07414604f, -0.28428003f, -0.06800870f, -0.20930812f, 
    -0.06917176f, -0.25206649f, 0.50166583f, -0.02241763f, -0.34251323f, 0.05045415f, 0.13186215f, -0.08951280f, 
    0.02993299f, -0.18985897f, 0.44650397f, 0.00556234f, 0.04754641f, -0.19133016f, 0.00596319f, 0.12065317f, 
    0.06837946f, 0.08111887f, 0.16060972f, -0.21467124f, 0.07710807f, -0.10918105f, -0.19835365f, 0.40484497f, 
    0.33614001f, -0.05773655f, 0.03312398f, -0.00570541f, -0.22542398f, -0.05283002f, 0.23620386f, -0.01749944f, 
    0.23434158f, 0.24065843f, 0.24261518f, 0.19309749f, 0.35411242f, -0.40754116f, 0.13993207f, 0.07291672f, 
    -0.00097219f, 0.07714158f, -0.02471913f, -0.12438896f, -0.19476771f, -0.13282844f, 0.11809737f, -0.23130991f, 
    -0.22928640f, 0.06598869f, -0.15073521f, -0.14148405f, 0.08779960f, -0.06350398f, 0.05028680f, 0.58098769f, 
    0.01301995f, -0.27493152f, 0.14918141f, -0.01965938f, 0.05584534f, -0.22540028f, -0.13933633f, -0.15276352f, 
    -0.32289502f, 0.02557731f, 0.04116652f, 0.05989938f, 0.05336004f, 0.02785573f, 0.06378967f, 0.07141648f, 
    0.22474794f, 0.42858186f, 0.07691318f, -0.39922556f, 0.11607007f, -0.02101929f, -0.03471100f, -0.22119667f, 
    0.07946975f, 0.00000141f, -0.06506326f, 0.17024210f, 0.36854741f, -0.19938155f, 0.19373058f, -0.07439866f, 
    0.20836268f, 0.23081043f, 0.01849269f, 0.40185320f, 0.16239731f, -0.32661489f, -0.08546244f, -0.20193501f, 
    -0.08197674f, 0.14965406f, 0.14457013f, 0.07527252f, -0.27454799f, 0.42172825f, -0.17144753f, -0.12366468f, 
    0.04691875f, -0.10084528f, 0.08252098f, 0.02732154f, 0.29128763f, 0.54956532f, -0.31339064f, -0.54765862f, 
    -0.15390338f, 0.19643861f, -0.26563558f, 0.04609032f, 0.04252535f, 0.15648483f, -0.03320303f, -0.08116314f, 
    0.14652321f, -0.06080078f, -0.01313222f, -0.30811185f, -0.04445703f, 0.15296914f, -0.07139274f, -0.41798124f, 
    0.16952042f, -0.06210190f, -0.19065563f, -0.11226602f, -0.27284238f, 0.06297754f, -0.07438802f, -0.16816416f, 
    -0.03356266f, 0.20641989f, 0.10009556f, -0.01619237f, -0.40295765f, -0.46873975f, 0.11599525f, -0.01042376f, 
    0.01964675f, 0.05396925f, -0.20249194f, 0.10476732f, 0.10187976f, -0.20340566f, -0.13034630f, 0.19922753f, 
    -0.00569343f, 0.03174695f, -0.59480369f, -0.20525771f, -0.38624120f, -0.04271476f, -0.25452709f, -0.20152226f, 
    -0.09100464f, 0.01922377f, 0.04249137f, -0.05567918f, -0.46456125f, -0.34216189f, -0.62805158f, 0.14042249f, 
    0.21734402f, -0.07872930f, -0.10834362f, 0.05770478f, -0.51069832f, -0.81407976f, 0.27917886f, 0.23521414f, 
    0.21785867f, 0.07957815f, 0.02738520f, -0.06798310f, 0.26034513f, -0.11459911f, -0.16415599f, 0.03457406f, 
    -0.07198232f, -0.05491801f, -0.09074365f, 0.10955556f, -0.02825062f, 0.16761999f, -0.07365249f, 0.42640093f, 
    0.31005549f, -0.01171050f, 0.04902967f, 0.05872900f, 0.12240724f, 0.13502283f, 0.17440681f, -0.15421040f, 
    -0.12347902f, 0.16825780f, 0.09710171f, 0.11776889f, 0.35678533f, 0.22810982f, -0.05250955f, 0.03437121f, 
    0.01328405f, -0.15963885f, -0.08278554f, -0.09791672f, 0.30371371f, 0.01086890f, 0.10472519f, 0.28416014f, 
    0.40533882f, -0.38408241f, -0.08252878f, 0.24047288f, -0.10600992f, -0.15094702f, -0.01092299f, 0.10887626f, 
    0.20283043f, 0.12896545f, -0.49070954f, -0.76035255f, -0.23212542f, 0.03324564f, 0.06905701f, 0.30552980f, 
    -0.17147344f, 0.06048272f, -0.01719001f, -0.02171192f, -0.02296029f, 0.09052108f, 0.07206086f, -0.34432277f, 
    0.03291635f, -0.03328066f, -0.22565590f, 0.18802032f, 0.04767517f, -0.15194304f, -0.21755113f, -0.50887758f, 
    -0.23371658f, 0.03519115f, -0.10022523f, 0.00676600f, 0.40840867f, -0.80199158f, 0.10138238f, 0.00680903f, 
    0.20287229f, 0.08246571f, 0.07521597f, -0.24052539f, 0.10415438f, -0.03992954f, 0.26334965f, 0.14630795f, 
    0.00045394f, 0.23059797f, 0.30870023f, 0.05534426f, 0.52917242f, 0.24088149f, 0.39089128f, -0.30120066f, 
    -0.42939544f, -0.11446722f, -0.10809959f, -0.47305262f, -0.12096425f, 0.02318466f, 0.20414367f, -0.04468276f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    0.28319678f, 0.27595273f, -0.12415942f, 0.22692192f, 0.23033796f, 0.31119165f, 0.34356084f, 0.15220343f, 
    0.52248323f, 0.33708042f, 0.14331931f, 0.00119469f, 0.16077901f, 0.20692348f, -0.17955354f, 0.56781292f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -1.41416156f, 0.56243068f, 0.52181530f, -0.09817294f, -0.23765300f, -0.61603427f, 0.19278574f, -0.01865616f, 
    -0.13575920f, -0.71360481f, -0.91407895f, 0.23948216f, 0.16486190f, -0.22670518f, 0.82043988f, -0.89409494f, 
    0.02363450f, -1.11600029f, 0.09228905f, 0.52074116f, -0.68737310f, -0.04179059f, 0.53041244f, -0.63507169f, 
    -0.23860537f, 0.62890005f, -0.39075932f, -0.54350358f, 0.19275706f, 0.46224084f, -0.38316718f, 0.27303770f, 
    0.35370156f, 0.89835060f, -0.18495774f, 0.27043965f, -0.40416339f, -0.50886345f, 0.17407115f, 0.36042580f, 
    0.45678869f, -1.41035485f, -0.02629420f, -0.51092082f, 0.02768818f, -0.01752356f, -0.97830719f, 0.65609270f, 
    -0.53969663f, 0.41811797f, 0.18238938f, -0.12550755f, 0.18342139f, 0.57953739f, -1.26980436f, -0.27552503f, 
    -0.98468602f, -0.55208617f, 0.36153361f, -0.36467052f, -0.21829849f, 0.06076629f, 0.42101416f, 0.08716009f, 
    0.02627505f, -0.30636683f, 0.43423599f, 0.09690388f, 0.58794385f, -0.34004545f, 0.81276006f, -0.16807464f, 
    -0.25046819f, -0.35991797f, 0.18997297f, 0.06210757f, -0.28589600f, -0.44249099f, -0.67907351f, -0.50697845f, 
    -0.49936679f, -0.63191533f, 0.02433205f, -0.43120480f, -0.41000417f, 0.55388480f, 0.34303716f, -0.37163576f, 
    0.10329321f, -0.08837701f, -0.32978171f, 0.34495130f, 0.16189258f, 0.31138921f, -0.13046367f, 0.12750600f, 
    0.07532441f, -0.99215907f, -0.58699930f, 0.48537707f, -0.07541592f, -0.16690607f, -0.56378829f, 0.82538027f, 
    0.90398991f, -0.58777308f, -0.10526178f, -0.13719711f, -0.56869340f, -0.34319952f, -0.46343267f, 0.51751441f, 
    0.05683170f, -0.07655621f, 0.13412741f, -0.11076439f, -0.97952765f, -0.01391399f, -0.15974829f, 0.47269303f, 
    -0.68371731f, 0.39249602f, 0.03558623f, 0.69346792f, -0.49516609f, -0.14365241f, 0.73455966f, -0.85815459f, 
    0.00027126f, -0.16566537f, -0.38261256f, -0.59804982f, -0.41775167f, -0.30332437f, -0.27328190f, 0.00563815f, 
    0.04340678f, 1.02870321f, -0.09500225f, -0.40257415f, 0.81698215f, 0.39144179f, 0.50476152f, 0.24114980f, 
    -0.36152783f, 0.96372533f, -0.13593841f, -0.09204479f, 0.78058481f, 0.17950171f, -0.74901599f, -0.31405407f, 
    0.58011132f, -0.10727188f, 0.31730375f, 0.28771922f, -0.39279965f, -0.31165811f, -0.53829259f, 0.12299654f, 
    -0.50562823f, -0.41220072f, -0.64566970f, -0.34899110f, 0.58740741f, -0.24772355f, 0.76567173f, 0.01024928f, 
    -0.59952891f, -0.97110814f, 0.56156641f, -0.12331482f, 0.47689205f, 0.23779471f, 0.22175159f, 0.63127422f, 
    1.15436614f, -0.28603917f, -0.42883912f, -0.42394787f, 0.49052233f, 0.40930426f, -0.36024392f, 0.03645705f, 
    -0.27666911f, 0.12480408f, 0.27315515f, -0.09663571f, -0.06852799f, 0.44701701f, -0.52441496f, -0.52778286f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.18473339f, 0.33871382f, 0.17411055f, 0.43496609f, -0.09215731f, 0.00439189f, -0.17620310f, -0.35646132f, 
    -0.20202957f, -0.09891167f, -0.05643031f, 0.07135598f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
