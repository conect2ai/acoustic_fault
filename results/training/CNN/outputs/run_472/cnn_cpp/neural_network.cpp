#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -1.57939219f, -0.56051630f, -0.44680470f, 0.36017698f, 1.00084889f, 0.57501537f, 0.19934806f, -0.15926678f, 
    0.40354642f, -0.17393473f, -1.01990497f, -1.24396801f, -0.11004134f, 0.53235114f, 0.69255614f, -0.42815760f, 
    -0.14954269f, -0.06853130f, 0.54226387f, 0.70517343f, -0.20664571f, -1.25548577f, -0.85223484f, -1.40982711f, 
    -0.14545509f, -0.30257967f, 0.21423183f, 0.58349389f, 0.75681192f, -0.94058186f, 0.29150483f, -0.95136195f, 
    -0.57275838f, 0.69597065f, 0.61292791f, 0.34922376f, -0.63619018f, 0.12777612f, -0.73163778f, -0.46470091f, 
    -0.09890286f, 0.87199527f, -0.34043127f, 0.92622656f, -0.77820748f, -1.19264543f, -0.89686280f, -1.16343069f, 
    0.03031475f, 0.30281666f, 1.00484109f, 0.23053974f, -0.12657475f, 0.16703227f, -0.57053745f, -0.88297272f, 
    -0.90312153f, 0.73427606f, -0.63756466f, 0.19683853f, -0.60883623f, -0.84902418f, 0.49147257f, 1.50013232f, 
    -1.20228028f, 0.01460649f, -0.58897436f, -0.16998778f, -0.25690782f, -0.50837320f, -0.58926123f, -0.10089952f, 
    1.68839872f, -0.79740101f, -0.74647462f, -0.26376066f, -0.59288281f, 0.19295125f, -0.13125862f, -0.15347472f, 
    0.78775120f, -0.95894283f, 1.27927065f, 1.16867244f, 0.75788176f, 1.21366107f, 0.46783414f, -0.08010648f, 
    0.00633249f, 0.23853879f, -0.62528521f, -0.32602453f, 0.96422803f, -1.05595875f, -0.23115799f, 0.48821065f, 
    0.63499081f, -0.28563049f, -0.01889827f, 0.93537658f, 0.50934327f, 0.77020562f, 0.65650934f, -1.05013454f, 
    0.63013399f, 0.20186450f, 0.29626819f, 0.06968383f, -0.68550533f, -0.99096179f, -0.55103153f, 0.81079954f, 
    0.62172955f, 0.10708823f, -0.50244612f, -0.05555588f, -0.92560214f, -0.60729545f, -0.76602930f, -0.05993911f, 
    -0.60823643f, 0.67799854f, -0.98412663f, 0.58355463f, 0.00863479f, 0.81578082f, 0.35500109f, 0.27319196f, 
    -0.53655422f, 1.35126662f, 0.46744674f, 0.57210261f, 0.35571519f, 0.55224562f, 0.74536639f, 1.11882067f, 
    0.91868722f, 0.45786473f, -0.25658786f, 0.18170878f, 0.71314013f, -0.22966771f, -0.02858898f, -0.72625732f, 
    -0.90899688f, 0.56684738f, -0.95460349f, 0.31526610f, 0.27705067f, -0.60719365f, 0.66356474f, 0.43655771f, 
    -0.36549595f, -1.38279462f, 1.00894678f, -0.32434267f, -0.67243838f, 0.11809821f, -1.02589107f, -0.03207076f, 
    0.00865871f, 0.12193272f, -0.81655276f, -1.10405302f, -0.10394445f, -0.06171879f, -1.17744672f, -0.01919097f, 
    -0.57795483f, -0.41855305f, -0.73039001f, 1.32136238f, 0.58049798f, 1.32973325f, 0.70855200f, -0.15252270f, 
    0.35188472f, -0.60062772f, -0.47648966f, 0.08143543f, -0.81517297f, -0.99088418f, -0.92247641f, 0.25591090f, 
    -0.58081418f, -0.39998573f, -0.05407603f, 0.63262653f, 0.70706618f, 0.87509942f, -1.36997342f, 0.09016388f, 
    -1.17985070f, -0.40829012f, -0.17652909f, -0.02128163f, 0.54156506f, 0.62861615f, 0.65947902f, 0.90286636f, 
    0.56909138f, -1.07794881f, 0.66064030f, 0.06899812f, -0.44725052f, 0.19507325f, 0.66496742f, -0.62180078f, 
    -0.16599870f, -0.36112633f, 0.01503210f, 1.13201129f, -0.25606996f, -0.18535063f, -0.48424047f, -0.51014906f, 
    -0.06126134f, -0.35158172f, 0.71428776f, -0.88606131f, -1.61128354f, 0.42255551f, 0.00427876f, 0.33973649f, 
    -0.24079016f, -0.05974697f, -0.69690478f, -1.44250441f, -0.15410912f, -0.81935120f, -0.18132323f, -0.56786740f, 
    0.68684024f, -0.21190937f, 0.92443848f, 1.03995132f, -1.06751704f, -0.79090542f, 0.58614463f, 0.35966334f, 
    0.28610155f, 0.38582903f, 0.51906478f, 1.05738282f, -0.34310690f, -0.85306299f, 1.10151947f, 1.09451175f, 
    -0.91119277f, -0.03440182f, -0.35696289f, -0.14852135f, -0.03695941f, -0.25811788f, 0.73275656f, -1.14753354f, 
    -0.68179405f, -0.74602884f, 0.34593347f, 0.65376824f, 0.25864276f, -0.42443752f, -0.60029382f, 1.10166073f, 
    0.23712373f, 0.63563317f, -1.09832227f, -0.46690342f, -0.45110229f, 0.88609225f, 1.11329556f, 1.25935483f, 
    0.04909234f, -0.64068264f, -0.87609839f, 0.04086390f, 0.59264112f, 0.26584002f, -0.39988965f, 1.30074847f, 
    0.38018569f, 0.88847673f, -0.09175999f, 0.48120287f, -0.79162675f, 0.46116462f, 0.31055307f, 0.28693414f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17432813f, -0.00488730f, 0.29993451f, 0.04819364f, -0.29802310f, 0.04874657f, -0.01376875f, 0.15356927f, 
    -0.20161551f, 0.27003098f, 0.34817955f, -0.08028810f, -0.09769413f, -0.01690894f, -0.18290561f, 0.19950370f, 
    0.18775959f, 0.21456553f, 0.03773537f, 0.26152003f, 0.20268774f, 0.01106918f, 0.33590722f, 0.15792327f, 
    -0.01988070f, 0.25096354f, 0.13809341f, -0.11111094f, 0.10993426f, -0.07885204f, -0.32364058f, -0.03951157f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.33911306f, -0.15274236f, 0.13236310f, 0.09010585f, 0.15373835f, 0.03964915f, -0.02777902f, -0.04523557f, 
    0.20790175f, 0.00472503f, -0.01559106f, 0.16707125f, 0.08619840f, 0.07757738f, -0.22344591f, 0.00635425f, 
    0.11793242f, -0.06694841f, 0.18141790f, 0.13803303f, -0.19594313f, -0.20393996f, 0.07781088f, 0.09132470f, 
    -0.06623207f, 0.05041472f, -0.08501804f, 0.07137510f, 0.29106405f, -0.01534653f, 0.09337607f, 0.04481072f, 
    -0.08563194f, -0.02763546f, 0.09547477f, -0.16364598f, -0.08210159f, 0.26814055f, 0.05563698f, 0.08548144f, 
    0.01419207f, 0.00709863f, -0.10732151f, -0.08574384f, -0.34681192f, -0.00997900f, 0.23952046f, 0.31240603f, 
    0.28385067f, 0.06824072f, -0.19666821f, 0.18979804f, 0.03580105f, -0.00160043f, 0.58007830f, 0.05636876f, 
    0.15348914f, 0.10535172f, 0.21223004f, -0.03175030f, 0.36863738f, 0.12766831f, 0.06436651f, 0.01038812f, 
    0.04504972f, 0.11811046f, 0.02449531f, -0.08141559f, 0.12831609f, -0.04053390f, 0.08071502f, 0.09983884f, 
    -0.02643919f, 0.33825639f, 0.02303898f, -0.15817067f, -0.25497171f, 0.09808415f, 0.19841625f, -0.04956589f, 
    -0.02783709f, -0.30488911f, -0.00343456f, -0.19241430f, 0.12839307f, -0.11065102f, -0.24392477f, -0.11390163f, 
    0.07233872f, 0.24285044f, -0.15077461f, 0.11555379f, -0.36736104f, 0.12878859f, 0.13846338f, -0.06935555f, 
    -0.07903559f, 0.23497735f, -0.02562016f, 0.43854788f, -0.07982958f, -0.06108148f, 0.14419229f, 0.12554407f, 
    -0.08135998f, 0.22598170f, -0.00122762f, 0.23215798f, 0.03907454f, -0.02628247f, 0.20403223f, -0.21257347f, 
    -0.05782995f, 0.00168620f, -0.14728223f, -0.11127256f, 0.08259425f, 0.12112136f, 0.08539115f, -0.09340855f, 
    -0.05025538f, 0.01833936f, 0.17793906f, 0.07889016f, 0.00665299f, -0.08822433f, -0.13678387f, -0.37725431f, 
    -0.04594598f, 0.15845571f, 0.07600743f, 0.12242883f, 0.07189254f, -0.07049903f, -0.10070957f, 0.00773168f, 
    -0.16647908f, -0.28852820f, 0.18026055f, 0.01398768f, -0.15669261f, 0.03871268f, -0.02105063f, 0.02812432f, 
    0.03891486f, 0.04305424f, -0.17725892f, 0.00763963f, 0.00841090f, 0.21542564f, 0.00980313f, -0.01630739f, 
    0.05641614f, -0.56679922f, -0.21251944f, -0.07485158f, -0.20449576f, 0.12548578f, 0.23280250f, -0.24743590f, 
    -0.19504635f, 0.07868141f, 0.33369797f, 0.35026720f, -0.03001348f, -0.07239898f, 0.27207702f, 0.03118481f, 
    -0.27133277f, 0.15945445f, 0.10444569f, 0.25891340f, -0.02567611f, -0.24466689f, 0.08379031f, -0.00846705f, 
    0.17186321f, 0.03483379f, -0.25128365f, 0.12878518f, 0.27258223f, 0.03444887f, -0.03280680f, -0.09619053f, 
    -0.02057046f, -0.06615855f, 0.15106007f, -0.06519663f, -0.07888702f, -0.11880711f, -0.05558352f, -0.25312445f, 
    -0.01161045f, -0.23485993f, 0.06016099f, 0.13125439f, -0.03311577f, -0.03425482f, -0.03921343f, 0.11563630f, 
    -0.07138139f, 0.00018827f, -0.12569885f, -0.02255140f, 0.03265227f, -0.09166067f, 0.20144261f, 0.10261198f, 
    -0.08779363f, -0.09197188f, 0.12170925f, 0.02597191f, -0.12241100f, -0.34123704f, -0.03454505f, -0.08769798f, 
    -0.22238640f, -0.08651081f, -0.61401391f, -0.18058056f, -0.07733116f, 0.17296037f, 0.12261618f, 0.23642989f, 
    -0.04510403f, 0.31397346f, 0.27951458f, -0.09754418f, -0.16358097f, -0.17504846f, -0.20031317f, -0.14417972f, 
    0.07398799f, 0.08454157f, -0.09274007f, 0.25542206f, 0.22069453f, -0.01570004f, -0.06612510f, -0.06912991f, 
    -0.08647022f, -0.15086013f, 0.11255976f, 0.27346212f, -0.37320963f, -0.26061770f, 0.02035569f, 0.06312422f, 
    -0.21532585f, -0.07260159f, 0.10879073f, -0.20519507f, -0.01020458f, -0.12305618f, -0.38320601f, -0.06298880f, 
    -0.07110495f, 0.04458816f, -0.05413450f, 0.06085035f, -0.15060592f, -0.07461666f, 0.24641289f, 0.05666181f, 
    -0.15813991f, 0.12945420f, -0.03289783f, 0.11385592f, -0.07925260f, 0.17171203f, 0.67843872f, 0.09779438f, 
    -0.16801956f, 0.04322728f, 0.03381170f, 0.08933361f, -0.11515854f, 0.28412616f, -0.13284397f, 0.36347941f, 
    -0.01273671f, -0.15142293f, 0.03741407f, -0.06951082f, 0.16179778f, 0.11912081f, -0.09198448f, 0.07608760f, 
    0.08418050f, 0.22770414f, 0.00086341f, 0.19816634f, -0.08899707f, 0.14164101f, 0.08345616f, -0.06895356f, 
    0.04681856f, 0.10449392f, 0.24962954f, -0.20034833f, 0.03356225f, 0.00213377f, -0.01200249f, 0.13493533f, 
    0.08772609f, 0.26630753f, -0.39584079f, 0.08146502f, 0.08119661f, 0.25051540f, 0.06399385f, 0.05158793f, 
    0.08382928f, -0.06625833f, 0.06523286f, -0.29571000f, -0.10854771f, -0.00317705f, -0.04496326f, -0.09867772f, 
    -0.07806541f, 0.17877349f, 0.07783948f, 0.05681064f, 0.34412789f, 0.10937613f, 0.12844966f, 0.14013769f, 
    0.14553852f, -0.11667155f, -0.19773699f, -0.28048587f, 0.05121600f, 0.04355881f, 0.31947896f, 0.06872508f, 
    0.16782655f, -0.05376739f, -0.06269197f, 0.09900982f, -0.09566990f, 0.06896271f, 0.17069577f, 0.10259476f, 
    0.22956710f, -0.03904603f, -0.08225057f, 0.01560657f, -0.08985109f, -0.01224522f, 0.07957532f, -0.39576983f, 
    -0.15991352f, 0.25448450f, -0.01731150f, 0.14117353f, -0.14726682f, -0.10277220f, 0.12073944f, 0.00046944f, 
    -0.28267393f, 0.10667262f, 0.01809232f, -0.11816423f, 0.14560273f, -0.05375274f, -0.02677425f, 0.14554094f, 
    0.08419849f, -0.11463721f, 0.25516036f, -0.23168202f, 0.10046288f, 0.09538384f, -0.00509026f, 0.07402391f, 
    0.00947711f, -0.06771532f, -0.00236815f, 0.03238943f, -0.13506034f, 0.04508844f, 0.05768108f, 0.00469169f, 
    -0.17922440f, 0.00594088f, -0.16564031f, -0.14524317f, 0.10983314f, -0.23721878f, 0.03579316f, -0.08428359f, 
    -0.21777214f, 0.16818763f, -0.03500744f, -0.03981411f, 0.22696768f, 0.37972057f, 0.23902440f, -0.22674415f, 
    0.01484425f, 0.23201859f, 0.02565529f, 0.02004006f, -0.00699079f, 0.08711798f, -0.02182450f, -0.14473255f, 
    -0.21934298f, 0.03729811f, -0.09292960f, 0.02523156f, 0.07939056f, -0.04844511f, 0.25596836f, 0.10314698f, 
    -0.06810336f, -0.13731627f, -0.00258038f, 0.12541719f, 0.17296314f, -0.04869395f, -0.01576673f, 0.01403031f, 
    0.10603597f, -0.13007917f, -0.16766505f, -0.01490879f, -0.10672840f, -0.16768430f, 0.03619976f, -0.19473378f, 
    0.13246611f, 0.20072646f, 0.09201583f, 0.00579939f, -0.01216743f, -0.02877080f, 0.18536121f, 0.14900778f, 
    0.14340892f, 0.09086596f, -0.09033089f, -0.00871020f, 0.06767891f, 0.22062409f, -0.06734791f, -0.17193449f, 
    -0.03752939f, 0.18608432f, 0.23139256f, 0.13584250f, 0.14980368f, 0.11027487f, -0.10605387f, -0.15846264f, 
    0.10001937f, -0.04465830f, -0.10432031f, 0.07637259f, 0.23431711f, -0.23772015f, 0.01370996f, -0.01747489f, 
    0.01952385f, -0.12622760f, -0.11773627f, -0.27727246f, 0.13948713f, 0.09534502f, 0.13250488f, -0.06915493f, 
    0.08144697f, 0.18137476f, -0.05179766f, 0.02023807f, -0.05971207f, -0.23319870f, -0.01180571f, -0.07014548f, 
    -0.24950190f, 0.03985161f, -0.11742444f, 0.05443620f, -0.01626118f, 0.02609940f, -0.35795784f, -0.12257187f, 
    -0.19304669f, 0.15896446f, -0.13318974f, -0.06209293f, -0.10967904f, -0.06949918f, 0.27203694f, 0.27538723f, 
    0.27833146f, 0.08177486f, 0.08745406f, 0.01160404f, 0.16843988f, -0.05089081f, 0.21494429f, -0.04665787f, 
    0.16501768f, 0.10777570f, -0.08680186f, 0.02258814f, 0.03067851f, -0.21934816f, 0.11178545f, 0.13207686f, 
    -0.19210579f, 0.18105872f, 0.12168982f, 0.14169359f, -0.06291852f, 0.01612272f, -0.10382265f, -0.09983455f, 
    -0.01403979f, 0.06223641f, -0.61371684f, -0.16678692f, -0.08663080f, -0.03334702f, 0.10407303f, -0.01764815f, 
    0.01436464f, 0.03180258f, 0.20879331f, -0.16502334f, 0.18428746f, -0.12140787f, -0.18116747f, 0.10940826f, 
    0.20992775f, 0.23332851f, -0.03897639f, 0.09053470f, -0.07847077f, 0.05811918f, -0.41244978f, -0.23958807f, 
    -0.05042101f, -0.08441861f, -0.29718116f, 0.22978492f, -0.16449633f, 0.14293489f, -0.10884037f, -0.25562161f, 
    0.00466288f, 0.18586284f, 0.11688634f, 0.11848712f, 0.02479205f, 0.00037143f, -0.54267114f, 0.04702615f, 
    -0.18684541f, -0.07647260f, -0.17293750f, -0.16055778f, 0.29174057f, 0.20249598f, -0.11625084f, -0.09726860f, 
    0.03615456f, -0.01244748f, -0.00724215f, -0.14778802f, -0.06744264f, -0.06947639f, -0.04154172f, 0.06240515f, 
    -0.02871499f, -0.01891727f, -0.02871835f, -0.05418969f, -0.05349033f, -0.04822254f, -0.05203196f, -0.05678601f, 
    -0.06148988f, -0.05366881f, -0.02085276f, -0.05964524f, -0.01710016f, -0.03722827f, -0.04578285f, 0.04339033f, 
    -0.03432987f, 0.02022122f, 0.00786568f, 0.03303371f, -0.00312443f, -0.03148581f, 0.01524401f, -0.03994892f, 
    -0.05985995f, -0.05468468f, 0.01659792f, -0.06362984f, 0.02217288f, -0.01767839f, -0.03958360f, -0.01985481f, 
    -0.03614875f, -0.01249584f, 0.02557663f, 0.00579635f, 0.03436759f, -0.04648573f, -0.01371550f, -0.01379004f, 
    -0.07337475f, -0.03160483f, -0.05101032f, -0.02243267f, 0.02234133f, -0.06190411f, -0.02619363f, 0.03462301f, 
    0.00423143f, -0.01342603f, -0.02557671f, -0.00640427f, 0.03735508f, -0.07731067f, 0.05820286f, 0.05665364f, 
    0.03701530f, -0.02983283f, 0.00318832f, -0.07232685f, -0.04659615f, -0.01245095f, 0.00257863f, -0.05547124f, 
    -0.06916717f, 0.01528334f, -0.02736972f, -0.02743439f, 0.03049431f, 0.00834885f, 0.01992276f, 0.04582497f, 
    0.01028472f, -0.02444997f, 0.00940079f, -0.00278125f, 0.02253260f, -0.01951713f, -0.03760633f, 0.02466930f, 
    0.05911879f, 0.04037086f, -0.02054551f, -0.01835885f, -0.00838560f, 0.00280694f, -0.07428678f, -0.07765871f, 
    0.01971637f, -0.00691671f, -0.05555778f, 0.00113259f, -0.05884096f, -0.06589533f, 0.04721891f, 0.00387940f, 
    0.03378769f, 0.01733901f, -0.03818178f, 0.03849112f, 0.00799993f, -0.06077594f, -0.00355711f, 0.03440956f, 
    -0.04187305f, -0.03159696f, -0.06980768f, 0.02327981f, -0.06025571f, -0.04683719f, -0.02019171f, -0.03329171f, 
    -0.02335155f, 0.01712519f, 0.02641395f, -0.02887521f, -0.01460895f, -0.04433195f, -0.00994759f, -0.05395301f, 
    0.03805038f, -0.00225085f, -0.05112792f, -0.05320429f, 0.00883400f, -0.03249878f, -0.03775877f, 0.06258078f, 
    0.00319300f, -0.05601169f, 0.01937364f, -0.03188571f, 0.03679674f, 0.01685979f, 0.02599147f, -0.00360282f, 
    -0.03740185f, -0.01873210f, -0.03327796f, -0.01087893f, 0.01615065f, 0.03809816f, -0.07306869f, -0.03480981f, 
    -0.03332501f, -0.05293903f, -0.00883625f, -0.03618346f, 0.00365220f, -0.00539078f, -0.01284969f, 0.00328872f, 
    -0.03742815f, -0.02305077f, 0.03102290f, -0.00912509f, 0.00011489f, -0.01732424f, -0.06231290f, 0.02765615f, 
    -0.02973127f, 0.01818689f, -0.06501979f, -0.04632390f, -0.01810898f, 0.02698530f, -0.05374891f, 0.03142916f, 
    -0.05837416f, 0.04912689f, -0.05547443f, -0.06508549f, -0.07363866f, 0.03012000f, 0.00399901f, 0.06025712f, 
    -0.01917375f, -0.01908405f, -0.03755834f, 0.04110175f, 0.03499166f, -0.00493885f, -0.00393138f, 0.02375255f, 
    -0.04546203f, 0.00391226f, -0.01935474f, 0.00870903f, 0.01384368f, -0.01709721f, 0.02446794f, 0.04778619f, 
    -0.06817929f, -0.06200073f, -0.08124187f, -0.03403391f, -0.06016339f, -0.01985919f, -0.01774742f, -0.01743922f, 
    0.02736770f, -0.00635491f, -0.04273771f, -0.05963771f, 0.01584241f, -0.05617085f, 0.03652563f, -0.02519424f, 
    -0.03396307f, -0.05280900f, 0.02204673f, 0.01811805f, 0.03043475f, -0.05295856f, 0.02448977f, -0.05940922f, 
    -0.01218709f, 0.00124440f, 0.01499416f, -0.04345553f, -0.00375085f, -0.00823916f, 0.03101334f, -0.02828090f, 
    -0.06325251f, -0.03925832f, -0.02735485f, -0.04876470f, 0.04056031f, -0.02865073f, 0.00229094f, -0.01794110f, 
    -0.05403155f, -0.04297686f, 0.01503465f, -0.03683880f, 0.02083372f, 0.04337904f, 0.00723675f, 0.02227177f, 
    0.02337984f, 0.04380107f, -0.02390838f, -0.01666486f, -0.02829992f, -0.00942192f, 0.04208858f, -0.03758356f, 
    -0.06843763f, 0.00124670f, 0.01503969f, 0.03840902f, -0.04312708f, 0.00905681f, -0.02729481f, -0.02498825f, 
    -0.01868219f, -0.03776664f, 0.03281347f, 0.02073269f, -0.05861384f, 0.02540211f, -0.02666976f, 0.02750723f, 
    -0.03704342f, -0.05037927f, -0.03640914f, 0.00326984f, -0.03041333f, -0.05743201f, 0.02154283f, -0.01061691f, 
    -0.03023268f, 0.04084931f, 0.03497442f, -0.04380034f, -0.00478974f, -0.03387813f, -0.07122671f, -0.06617825f, 
    0.02378363f, 0.00935372f, -0.03276416f, -0.00757842f, -0.05136648f, -0.04859961f, -0.01481987f, 0.02833662f, 
    0.41162160f, -0.00334932f, -0.01228620f, -0.07210279f, 0.05989756f, -0.08624633f, 0.25883573f, 0.16047889f, 
    0.20916086f, 0.21593115f, 0.03637074f, 0.04798839f, -0.13342440f, 0.01439763f, -0.10422319f, -0.11085296f, 
    0.07470483f, -0.17843780f, 0.22826508f, 0.38565224f, 0.24870169f, 0.20459415f, -0.00491330f, -0.02762376f, 
    -0.22005925f, 0.15022066f, 0.05153173f, 0.13413985f, -0.34834200f, 0.04721473f, 0.06533877f, 0.06787114f, 
    0.00508021f, 0.00202413f, 0.14286165f, -0.17077699f, -0.15674075f, 0.12452491f, -0.14739640f, -0.15359783f, 
    0.12618229f, -0.37772393f, -0.04516414f, 0.28116018f, -0.12957641f, 0.43367082f, 0.12228500f, -0.21678917f, 
    -0.28553683f, 0.21101098f, -0.24243987f, -0.18512595f, 0.10184003f, -0.12052150f, -0.04492167f, 0.16619451f, 
    0.00217066f, 0.01482806f, 0.15569884f, 0.05811154f, -0.09735221f, 0.06529820f, -0.02078815f, 0.20274581f, 
    0.21410020f, 0.05757378f, 0.17048810f, 0.23150063f, 0.04612445f, 0.02027341f, -0.07695086f, -0.13582899f, 
    0.15287556f, 0.09749361f, 0.05143016f, -0.01070325f, 0.13976565f, 0.01726725f, -0.20025621f, 0.06622520f, 
    0.04588082f, -0.47555086f, -0.04128179f, -0.21324319f, 0.03802633f, 0.00695353f, 0.04598964f, 0.24342403f, 
    -0.26229796f, -0.01012419f, 0.30519822f, -0.08552878f, 0.16024074f, -0.12115039f, -0.13903531f, -0.13393830f, 
    -0.04260242f, -0.19980086f, 0.08839240f, -0.56809062f, -0.31867382f, -0.16896309f, 0.08770145f, -0.02250399f, 
    0.04902243f, -0.25651911f, 0.04674380f, 0.01521126f, 0.10000561f, -0.21738780f, -0.05636318f, -0.04890898f, 
    0.35789585f, 0.02942753f, -0.07382596f, 0.09052153f, -0.05237016f, -0.01546097f, 0.27062172f, -0.02786629f, 
    0.18934804f, -0.07175604f, 0.17280567f, -0.16137125f, 0.08290689f, -0.01462791f, -0.19321655f, 0.23438045f, 
    -0.06046261f, -0.30819589f, 0.24875759f, -0.02264650f, -0.03933812f, 0.12501056f, 0.05680187f, -0.22277792f, 
    -0.10895510f, 0.13977844f, 0.04827110f, 0.02814539f, -0.09917440f, 0.00305601f, -0.03451406f, 0.14439259f, 
    0.11851169f, -0.01363274f, 0.12984684f, -0.00916012f, 0.37480766f, 0.21754885f, 0.04417063f, -0.00907650f, 
    -0.09252560f, 0.39684993f, 0.02493963f, 0.07657444f, 0.16550982f, -0.05474421f, 0.19434971f, 0.05827564f, 
    -0.00238640f, -0.07277836f, -0.24454994f, -0.00820596f, 0.15090372f, -0.07482953f, 0.09313376f, 0.33642119f, 
    -0.10616507f, -0.05308326f, 0.10016456f, -0.83473080f, -0.21445243f, 0.04536190f, -0.04930672f, 0.12682867f, 
    0.07256730f, -0.11820062f, -0.18151312f, -0.02553737f, 0.13756070f, 0.06380907f, 0.07208938f, -0.23625992f, 
    -0.20551483f, -0.00932876f, 0.15005423f, 0.09071499f, 0.05584002f, 0.32031891f, 0.16567908f, 0.02255199f, 
    0.08221791f, 0.27165678f, -0.01075974f, 0.00590709f, 0.05956616f, 0.08026935f, -0.17433539f, -0.06390389f, 
    0.10373226f, 0.13748102f, -0.06246567f, 0.02107980f, 0.04644590f, -0.10350851f, 0.06802956f, -0.07038419f, 
    -0.19532435f, 0.02151698f, -0.10893510f, 0.30432785f, 0.05809484f, -0.08055031f, -0.05826785f, -0.02333039f, 
    0.15778244f, 0.13206002f, 0.09749145f, 0.07759725f, 0.01177581f, -0.31822890f, -0.12087135f, 0.13777745f, 
    0.06711979f, -0.04390333f, -0.12362181f, 0.06516801f, -0.04329923f, -0.16485308f, 0.27861571f, -0.04782014f, 
    -0.07586668f, 0.10435236f, -0.06963171f, -0.10908899f, -0.13950381f, 0.13423416f, -0.13603899f, -0.13908720f, 
    -0.11684602f, 0.17918257f, 0.11780659f, 0.09960081f, -0.06448989f, -0.23520176f, -0.07403617f, -0.04829082f, 
    -0.04295579f, 0.08928214f, -0.07345041f, 0.01360584f, 0.28239954f, 0.01814339f, 0.11982322f, 0.10757548f, 
    0.02876631f, -0.11107294f, -0.06198919f, 0.13456593f, -0.03002348f, -0.07926521f, -0.02336237f, 0.11230736f, 
    -0.05127440f, 0.00094387f, -0.03845245f, 0.21249604f, 0.02347493f, -0.22493218f, 0.05782576f, -0.32973710f, 
    0.01586803f, 0.14309645f, -0.00426581f, 0.03460994f, -0.09218539f, 0.02467534f, -0.12517965f, -0.45325938f, 
    -0.21252222f, -0.13101667f, 0.05275306f, 0.10054102f, 0.01008388f, 0.13992696f, 0.08244962f, -0.07194109f, 
    -0.84116334f, -0.35297948f, -0.19978097f, 0.12761754f, 0.25039056f, 0.15111569f, -0.07370412f, -0.07590900f, 
    -0.19175927f, -0.00274014f, -0.19555548f, 0.11309650f, 0.16560237f, 0.15216111f, -0.08285172f, 0.04645277f, 
    -0.07394671f, 0.08561992f, 0.07630759f, 0.14480074f, 0.11151825f, -0.11834553f, 0.15592617f, -0.07996372f, 
    -0.01490573f, 0.18009008f, 0.08678018f, 0.01715111f, -0.05863882f, -0.25691387f, -0.07761160f, -0.00331184f, 
    -0.03608153f, 0.06148529f, -0.06127992f, -0.01418890f, -0.27467462f, -0.08841417f, 0.41484144f, 0.01027222f, 
    0.05719010f, 0.07867541f, 0.11427972f, 0.06703833f, 0.08254961f, -0.85894948f, -0.41302523f, 0.06765007f, 
    0.20264778f, 0.22135518f, 0.20314756f, -0.03191149f, -0.09061863f, -0.08705761f, 0.19389778f, -0.07539916f, 
    -0.22510946f, 0.20955454f, 0.01289359f, -0.04199589f, 0.11681728f, 0.03869490f, 0.08000034f, 0.21391281f, 
    -0.16922279f, -0.03821860f, -0.33442935f, -0.03582090f, 0.15055980f, -0.05396258f, 0.08985512f, 0.11226375f, 
    0.23898579f, -0.39571214f, -0.12740785f, -0.14019433f, 0.01483630f, -0.11221810f, -0.04143619f, -0.02970334f, 
    0.07016534f, 0.01460240f, -0.04060618f, 0.00373505f, -0.03615768f, 0.00760316f, 0.10722400f, 0.05761793f, 
    -0.17515999f, -0.16611747f, -0.04432095f, -0.17940210f, 0.00746823f, 0.08676013f, 0.04562989f, 0.02767818f, 
    0.28531888f, -0.06751511f, 0.04690576f, -0.11558623f, 0.07112794f, 0.05469518f, 0.08929529f, 0.04107334f, 
    -0.01379941f, 0.37240994f, -0.05719176f, -0.16720757f, 0.17879978f, 0.01940554f, 0.15116063f, 0.23552799f, 
    0.07009643f, -0.01309838f, 0.10144039f, 0.01794437f, -0.09460115f, -0.31515953f, 0.07659984f, 0.05908393f, 
    0.09603810f, 0.09537417f, -0.06924453f, 0.01632825f, -0.40143511f, 0.09940236f, 0.34703243f, 0.24697284f, 
    0.16572985f, 0.20077924f, 0.09076522f, -0.56129068f, 0.03947591f, -0.39018410f, -0.33104342f, -0.20815711f, 
    0.17531133f, 0.18246722f, 0.05382474f, -0.01033826f, 0.03267209f, -0.02880855f, 0.05011861f, -0.05924334f, 
    -0.51765651f, 0.07406033f, 0.21330185f, 0.12730157f, 0.19392180f, -0.20993359f, 0.13027990f, -0.09571809f, 
    -0.14317629f, -0.03366698f, -0.16141997f, 0.17592558f, 0.13151816f, 0.03900322f, -0.06972450f, 0.15999326f, 
    -0.10208178f, 0.10426501f, 0.14279862f, -0.01725640f, -0.24273390f, 0.07093864f, 0.01778975f, -0.07557142f, 
    -0.16861553f, 0.18962358f, 0.03323899f, 0.35498244f, 0.41023704f, 0.17716096f, 0.05540109f, -0.16462575f, 
    -0.12619250f, 0.09292120f, 0.05546909f, -0.04994088f, -0.35596010f, -0.24456619f, -0.01282094f, 0.22100009f, 
    0.18844059f, -0.01612213f, 0.11922097f, -0.04112450f, -0.18653534f, 0.28577083f, 0.00841692f, -0.18957411f, 
    -0.40113476f, -0.10636068f, 0.16241683f, -0.08342088f, -0.01423417f, 0.16230398f, -0.11122439f, 0.26477382f, 
    0.06311144f, -0.11155619f, -0.12560451f, 0.13800263f, 0.10075852f, 0.04984254f, -0.26683432f, -0.14780100f, 
    -0.01748956f, -0.14886984f, -0.02173735f, 0.14587231f, 0.29378960f, 0.12770779f, -0.13815670f, 0.00554578f, 
    0.01452685f, -0.08731201f, -0.13403635f, -0.11355466f, 0.07003390f, 0.09173188f, -0.04252655f, 0.09426208f, 
    0.03089433f, -0.28490758f, 0.02184231f, -0.07834122f, 0.15326728f, -0.01452060f, -0.06878398f, 0.21889780f, 
    0.09359631f, -0.14716710f, -0.32312000f, -0.00692289f, -0.01980134f, -0.13526610f, -0.17409700f, 0.00249289f, 
    0.21126282f, -0.21559846f, -0.09421187f, 0.11344671f, -0.30219173f, -0.03516307f, 0.12908413f, -0.05698638f, 
    -0.06832940f, -0.11036267f, 0.21803942f, 0.04035300f, 0.35117197f, 0.25369602f, 0.01520276f, -0.14314122f, 
    0.13688795f, 0.09375674f, -0.16102260f, -0.00619069f, 0.25667322f, 0.03603849f, 0.06355071f, -0.48199263f, 
    -0.00713482f, 0.24958339f, 0.03274113f, 0.08902537f, 0.00630161f, 0.34538248f, -0.24953321f, 0.06050927f, 
    0.05702193f, -0.02727157f, -0.03646573f, -0.14534627f, 0.06002885f, -0.05031112f, -0.06127260f, 0.10257094f, 
    0.26952991f, 0.24414475f, -0.08501071f, -0.18111299f, -0.06355217f, -0.09477843f, -0.06411974f, 0.19844218f, 
    0.04304364f, -0.06014168f, -0.02127516f, -0.03876182f, -0.02696266f, -0.05029292f, 0.00905411f, -0.02051109f, 
    0.03345160f, -0.01150138f, 0.03054346f, -0.05709457f, -0.04107950f, -0.03940139f, -0.00212728f, 0.01915369f, 
    -0.02414860f, 0.00737326f, 0.03784672f, -0.03220689f, -0.05245965f, -0.02520268f, 0.04464498f, -0.02735183f, 
    0.02301988f, 0.03165646f, 0.04115966f, -0.01375077f, 0.03154340f, -0.06192500f, -0.02663240f, 0.00407245f, 
    0.03847884f, -0.03348120f, 0.01175113f, -0.00593632f, -0.00596916f, 0.03587628f, -0.00233012f, -0.01086264f, 
    0.03134433f, 0.01075533f, -0.02616614f, 0.02251608f, 0.04548861f, -0.00488258f, 0.03355661f, 0.00523194f, 
    -0.05458958f, 0.00345807f, -0.04450930f, -0.05141483f, -0.06353384f, 0.02200594f, 0.00696205f, 0.01790738f, 
    0.00458001f, -0.06642191f, 0.01874568f, 0.03485512f, 0.02763552f, -0.04070629f, 0.03509790f, -0.01042180f, 
    -0.01803925f, 0.04590310f, -0.00849029f, 0.03861842f, 0.03219182f, 0.02668183f, 0.00116352f, -0.03690703f, 
    -0.00829320f, 0.02551505f, -0.01398470f, -0.03876909f, 0.03030731f, -0.03934536f, 0.00852783f, 0.04343922f, 
    -0.02901915f, -0.04143986f, -0.01898810f, 0.03137441f, 0.00737918f, -0.02266880f, 0.04525827f, 0.03998344f, 
    -0.02446841f, 0.02168360f, -0.05520319f, -0.00832835f, 0.00620975f, -0.00416963f, -0.01803085f, -0.02510875f, 
    -0.00655860f, 0.00240186f, 0.03113487f, -0.04482523f, -0.03355673f, -0.02585221f, -0.04198832f, 0.02696923f, 
    -0.06113198f, 0.02953615f, -0.04729499f, 0.01209254f, -0.02026399f, -0.00973968f, -0.04222690f, 0.02695751f, 
    -0.01426394f, -0.03148397f, 0.04693251f, -0.04325684f, 0.03759224f, 0.04471261f, 0.05069495f, -0.03936034f, 
    0.00798042f, 0.05363310f, 0.02447051f, -0.06242051f, 0.02684108f, -0.05609407f, 0.02444468f, 0.00621419f, 
    0.04171727f, 0.02211964f, -0.04291751f, -0.00721089f, -0.00329757f, -0.02660570f, -0.03832068f, -0.00106117f, 
    0.00600713f, 0.00624317f, -0.01507493f, -0.05451631f, -0.00997069f, -0.00389863f, -0.03994147f, -0.01203295f, 
    0.01817935f, -0.06404799f, -0.06278792f, 0.04702609f, 0.01092186f, -0.01615226f, -0.00596400f, -0.04935271f, 
    -0.03757456f, 0.04627283f, -0.03726900f, -0.05903529f, 0.05406225f, 0.04775348f, 0.01170318f, -0.00362724f, 
    -0.04578311f, 0.01138522f, 0.01161564f, -0.03478386f, 0.00652494f, -0.03105134f, -0.04700406f, -0.05368228f, 
    -0.01540978f, 0.02595504f, 0.02895702f, -0.02298864f, -0.03357713f, -0.03144465f, 0.01707828f, 0.03267333f, 
    -0.05062546f, -0.01221752f, -0.03119497f, 0.00629424f, -0.02728620f, -0.05980146f, 0.01383459f, 0.03457691f, 
    0.03305759f, -0.03027575f, -0.01802904f, -0.02223691f, 0.01715627f, -0.02234087f, -0.04844811f, 0.03003948f, 
    -0.01186019f, -0.00433942f, 0.03755947f, -0.01004522f, 0.01595592f, 0.04930633f, 0.02924610f, -0.00373804f, 
    0.00501660f, -0.04509920f, -0.03489803f, 0.02374708f, -0.01184521f, 0.01250376f, -0.05612198f, -0.04327422f, 
    -0.04548313f, -0.03087207f, 0.03821012f, 0.01660522f, -0.01079606f, -0.00399550f, 0.02300064f, 0.01528336f, 
    0.02800958f, -0.03200403f, -0.06379950f, 0.02673337f, 0.03954664f, -0.00159633f, -0.01618072f, -0.00726227f, 
    -0.01472303f, 0.00197701f, 0.04299904f, 0.02449732f, 0.02219288f, -0.02348952f, -0.02817229f, -0.02069323f, 
    -0.00087080f, -0.02397323f, -0.01389775f, 0.00205156f, -0.01063551f, 0.00149132f, -0.06136838f, 0.04304897f, 
    -0.04638366f, 0.02942256f, -0.04481215f, -0.03984481f, -0.03773464f, -0.05549558f, -0.04709918f, -0.06496555f, 
    -0.05031068f, 0.00079223f, -0.04052410f, 0.02831732f, -0.04204163f, -0.05910218f, 0.03133019f, -0.00416402f, 
    0.00976274f, -0.06111920f, 0.01360296f, 0.00771537f, -0.04819385f, 0.02913429f, 0.02787096f, -0.04136324f, 
    0.01953732f, 0.02991528f, -0.01821895f, -0.01628287f, -0.04717113f, -0.00438096f, -0.05027556f, -0.02787759f, 
    -0.04520140f, 0.01831372f, 0.03530309f, -0.06659067f, -0.04235851f, 0.00218008f, 0.02506228f, -0.06445199f, 
    0.04513450f, -0.05901591f, -0.03741213f, 0.02473566f, -0.06648688f, -0.02314297f, 0.03544174f, 0.01096053f, 
    0.00337550f, -0.05245888f, -0.00807446f, -0.02003310f, 0.02274643f, 0.04426148f, 0.04086447f, -0.04687422f, 
    -0.04599926f, -0.01587885f, 0.02931121f, -0.01567588f, -0.02885010f, 0.04823315f, -0.07045253f, -0.01084606f, 
    -0.03334884f, 0.03395266f, -0.06278064f, 0.03712316f, -0.01654906f, -0.06344684f, -0.02929681f, -0.02970952f, 
    0.01422696f, 0.02858907f, 0.02964574f, 0.04381260f, -0.05300798f, 0.03379625f, -0.00227965f, 0.02658970f, 
    0.00770156f, -0.04839650f, 0.04591109f, -0.03251744f, 0.00871565f, 0.00639769f, -0.00132847f, 0.00061162f, 
    -0.06028373f, 0.03091899f, 0.04194339f, 0.03632040f, -0.01993395f, -0.00284724f, -0.06372163f, 0.00596573f, 
    0.03403407f, -0.04817187f, 0.03737902f, 0.03086283f, 0.00034409f, -0.01064374f, -0.06386778f, -0.04964250f, 
    -0.02192973f, -0.03040693f, -0.00407995f, -0.02004267f, 0.03480540f, -0.01889443f, 0.03878132f, -0.04478807f, 
    -0.05286155f, -0.04818022f, 0.03866606f, -0.00345612f, 0.01252243f, 0.00633906f, -0.05130514f, -0.03498346f, 
    -0.04170280f, 0.04123547f, -0.02037323f, -0.01010955f, 0.03028479f, -0.00775896f, -0.01119849f, 0.03865518f, 
    -0.00209298f, 0.02372674f, -0.04799925f, 0.04363432f, -0.00728024f, 0.03561734f, -0.01982748f, 0.02114083f, 
    -0.03851480f, 0.03821588f, -0.01238201f, -0.03243024f, -0.01253105f, -0.05002040f, -0.02680380f, -0.06913590f, 
    0.04325956f, 0.01667451f, -0.01037824f, -0.02766994f, 0.00920486f, -0.05192305f, -0.00954321f, -0.03648562f, 
    0.01582159f, 0.01408302f, -0.06726114f, -0.01035173f, -0.01802583f, 0.03091408f, -0.06979227f, -0.04329869f, 
    -0.05909987f, 0.01485986f, -0.06342359f, 0.02019545f, -0.04054812f, -0.04113253f, -0.05986977f, -0.06039706f, 
    -0.03267179f, 0.02711522f, 0.03831367f, -0.01451928f, 0.00285710f, 0.01293163f, 0.04846757f, -0.02903224f, 
    -0.04665170f, 0.01524485f, 0.01442786f, -0.01687302f, 0.04055774f, -0.04015342f, -0.02175350f, 0.01958222f, 
    0.03595056f, -0.05086624f, 0.02634517f, -0.02740600f, -0.00039563f, 0.01449861f, 0.05192709f, -0.00630831f, 
    -0.01521394f, -0.03511883f, 0.05149693f, -0.04393036f, 0.00260237f, -0.04999154f, -0.03583792f, -0.01453925f, 
    -0.00611779f, 0.02510582f, -0.06004406f, 0.02258474f, -0.03950631f, -0.04369329f, -0.04896586f, -0.03609908f, 
    -0.05042549f, -0.03275818f, -0.04711636f, 0.03985562f, -0.01802733f, -0.05036012f, 0.05244955f, 0.00911064f, 
    0.03009916f, 0.00611044f, 0.00789808f, -0.00244853f, -0.04318794f, -0.04239582f, -0.01979629f, 0.04180056f, 
    -0.06018303f, -0.03169070f, 0.00017750f, -0.00490872f, -0.00203075f, -0.03501499f, -0.01002620f, -0.03251208f, 
    -0.02354156f, 0.00282040f, 0.02173079f, 0.01099588f, -0.04330673f, -0.03905586f, -0.05281221f, 0.01328453f, 
    -0.03105063f, -0.00639364f, -0.06306528f, 0.03255475f, -0.05725054f, -0.01076005f, -0.04410295f, 0.01626216f, 
    0.03970711f, -0.04611057f, -0.05592120f, -0.04601356f, 0.01455184f, 0.01261177f, 0.04422785f, 0.02309875f, 
    -0.02151901f, -0.01826423f, -0.01813097f, -0.00560094f, 0.04950968f, -0.02659122f, -0.06540845f, -0.05776089f, 
    -0.01346299f, -0.03929376f, 0.02880863f, 0.04749938f, -0.03925686f, -0.01170494f, 0.00638769f, 0.01541406f, 
    0.03215287f, -0.01947636f, 0.03718342f, -0.03376673f, -0.03784596f, 0.02161003f, -0.03855820f, -0.04393836f, 
    0.04048008f, 0.00199820f, 0.02109881f, 0.03554013f, -0.01366844f, -0.00671819f, 0.00278308f, 0.01559900f, 
    -0.02057539f, -0.05368720f, -0.04139573f, 0.03483542f, -0.04001458f, 0.00700482f, -0.00611815f, -0.00353826f, 
    0.03897985f, 0.05836065f, -0.01346304f, -0.04285312f, 0.04014770f, 0.02245437f, -0.03098028f, -0.05855361f, 
    -0.00377202f, -0.00922871f, 0.01562949f, 0.04217559f, 0.01889730f, -0.02421547f, -0.01842890f, -0.05494436f, 
    -0.05821678f, -0.00479788f, 0.03396335f, 0.05000284f, -0.04285809f, -0.01970863f, -0.00838935f, -0.02035794f, 
    0.00413274f, 0.05007103f, 0.01705290f, -0.01528073f, -0.02160535f, -0.02798951f, 0.02989601f, -0.03974563f, 
    0.00675242f, 0.02693015f, -0.00181891f, -0.02536022f, -0.01173989f, -0.00002024f, -0.03167766f, 0.01038805f, 
    0.01451237f, 0.04590302f, -0.01117019f, -0.02419472f, -0.04927894f, -0.06017842f, -0.05079799f, 0.03163007f, 
    0.04501656f, -0.01363601f, 0.04826714f, -0.03131396f, 0.00802112f, 0.00599872f, -0.04462929f, -0.05928752f, 
    -0.03158639f, 0.02923515f, 0.00177270f, -0.00011842f, 0.01863395f, -0.03811547f, -0.06670024f, -0.06551201f, 
    0.00076865f, -0.06165584f, 0.01290720f, 0.04395080f, 0.02916442f, -0.04405822f, -0.02644484f, -0.04260878f, 
    -0.00329870f, 0.03576266f, -0.05930305f, 0.00562780f, 0.05237558f, 0.04419168f, -0.05157654f, 0.00297589f, 
    0.03275955f, 0.01583955f, 0.03889575f, -0.04907755f, 0.01523827f, -0.01678721f, 0.00703932f, 0.03971714f, 
    -0.02205282f, 0.04038347f, -0.01382010f, -0.05000572f, 0.02311777f, 0.01065652f, -0.04691402f, 0.04149567f, 
    -0.01715102f, -0.03255136f, 0.02859609f, -0.04236445f, -0.00734036f, 0.03480408f, 0.01106514f, -0.01142584f, 
    0.01869403f, 0.00047049f, 0.04533869f, -0.04872018f, -0.07152871f, -0.00110432f, 0.04678820f, -0.06633838f, 
    -0.05091105f, 0.04181048f, -0.01048660f, -0.05665009f, 0.02927309f, -0.04909404f, -0.06204352f, 0.04423099f, 
    0.02164025f, 0.03068480f, -0.07072942f, 0.00026378f, 0.00334438f, -0.00076019f, 0.02697933f, 0.01636898f, 
    0.03293421f, -0.00320143f, 0.02249305f, 0.02739938f, -0.01940016f, 0.02434175f, 0.00942547f, -0.01282511f, 
    -0.05506038f, 0.02081728f, -0.03826486f, -0.01137545f, 0.03842292f, -0.04750708f, -0.02570807f, -0.02323865f, 
    -0.04658754f, -0.05950869f, -0.05035828f, 0.01090486f, -0.02278143f, 0.06756423f, 0.01127903f, -0.02694174f, 
    -0.05599327f, 0.01990212f, 0.03353308f, -0.04957965f, 0.00328210f, -0.05190727f, 0.02000531f, 0.03950020f, 
    -0.02207728f, 0.01570570f, 0.01404347f, 0.03890282f, 0.00723475f, -0.06094910f, 0.00235320f, 0.04462451f, 
    -0.00429064f, -0.02185497f, 0.03309255f, 0.02013603f, -0.02074926f, 0.05069620f, -0.05217406f, 0.01288326f, 
    0.02011127f, 0.03546099f, 0.03907482f, -0.05575800f, -0.06184595f, 0.04868140f, -0.03440285f, -0.06172974f, 
    -0.05059994f, -0.04056318f, 0.00465025f, -0.02218396f, 0.01195213f, 0.00328980f, 0.00321726f, 0.02197529f, 
    0.01087576f, -0.02337190f, 0.03095484f, 0.00159973f, 0.01138655f, 0.02265784f, -0.04541676f, -0.02546001f, 
    0.00133829f, 0.00993342f, -0.05746718f, -0.04463451f, -0.00083347f, -0.04776099f, 0.03678164f, -0.03387158f, 
    0.01977876f, 0.04229327f, 0.00200367f, 0.01718618f, 0.02893016f, -0.06629722f, 0.04300177f, 0.02034336f, 
    0.03689320f, -0.00850718f, 0.04861370f, 0.00118056f, 0.00591863f, 0.00403399f, -0.04013764f, -0.04844552f, 
    -0.05338239f, -0.00652464f, 0.03927295f, -0.01886433f, -0.02767221f, -0.06095868f, -0.03726052f, -0.05385356f, 
    0.03295456f, 0.03607908f, -0.01777178f, -0.04618450f, 0.03773624f, 0.02841423f, 0.00021672f, -0.00212742f, 
    -0.00413365f, 0.01070596f, -0.05796950f, -0.01472088f, 0.02857788f, -0.01126836f, 0.02703734f, 0.01806389f, 
    -0.00660937f, 0.04568902f, 0.03359262f, -0.05861101f, 0.01381094f, 0.02977886f, 0.03204238f, 0.03530329f, 
    0.03035185f, 0.01693120f, 0.04023645f, -0.05102694f, -0.07045242f, -0.05303960f, -0.00351587f, -0.04342817f, 
    0.01570016f, -0.01868844f, -0.04136382f, 0.01935948f, 0.03253432f, 0.00954145f, 0.01917656f, -0.04055077f, 
    0.01714874f, -0.05670967f, -0.06159243f, -0.03854107f, 0.03458652f, -0.01299361f, -0.05598223f, -0.03649588f, 
    0.00694716f, 0.01377343f, 0.01557192f, 0.00691041f, -0.02869724f, -0.01617370f, 0.00555200f, 0.03772360f, 
    -0.02351922f, -0.05838280f, -0.05251290f, -0.04658336f, 0.01627068f, 0.02955407f, 0.02842793f, 0.01678339f, 
    0.04282404f, 0.00621348f, 0.01569846f, -0.04595082f, -0.00062815f, -0.05161069f, -0.06415052f, 0.02661199f, 
    -0.01056099f, 0.00661210f, -0.00274098f, 0.00090216f, 0.03854924f, 0.01345709f, -0.03358441f, -0.00802705f, 
    -0.05420354f, -0.00515353f, -0.02808028f, 0.02587231f, -0.01996872f, 0.01002019f, -0.04509857f, -0.06138186f, 
    -0.01871371f, 0.02554870f, 0.02269910f, -0.00745824f, -0.02138534f, 0.03009884f, 0.02936631f, -0.02208585f, 
    -0.00422824f, -0.23649424f, 0.19514586f, 0.16326123f, 0.00870058f, 0.07334804f, 0.01120131f, 0.18880060f, 
    -0.11228763f, 0.00230339f, -0.07295237f, 0.34371749f, 0.08869551f, 0.11208265f, 0.10265733f, -0.06087962f, 
    -0.07556064f, 0.04705840f, 0.01265244f, 0.14162795f, 0.03454160f, 0.26184657f, 0.28435817f, -0.11692172f, 
    -0.08700546f, 0.08404003f, -0.09170999f, 0.09159693f, 0.16089323f, -0.10549404f, 0.12099925f, -0.01645875f, 
    -0.12561937f, -0.07442204f, 0.29444551f, 0.00188993f, 0.15051439f, 0.00841131f, 0.27979061f, 0.04757312f, 
    0.01458981f, 0.27010408f, -0.15821047f, -0.11890210f, 0.23679952f, 0.03516040f, -0.20649835f, 0.33374128f, 
    0.01370548f, 0.08848005f, 0.09103283f, -0.13563047f, 0.04429754f, 0.14426419f, -0.04103122f, -0.13207711f, 
    0.03397660f, 0.05175590f, -0.02618586f, 0.00345609f, -0.29544428f, 0.09426676f, -0.01455949f, 0.23236082f, 
    0.19564639f, -0.10418060f, -0.13429569f, -0.01738164f, 0.01111888f, 0.00217648f, 0.03763179f, -0.01110445f, 
    0.35774398f, 0.16922165f, 0.16607350f, 0.04792134f, -0.20965949f, -0.04938060f, 0.02956006f, 0.16230015f, 
    -0.16496269f, 0.01214932f, 0.06210532f, -0.07219507f, 0.32077900f, 0.16576110f, 0.49316368f, 0.09752598f, 
    -0.03845839f, -0.48332465f, 0.13275257f, -0.09372614f, -0.07621051f, -0.02229777f, -0.13102680f, 0.13290361f, 
    0.13916083f, -0.08771470f, 0.04268799f, -0.19055291f, -0.10290357f, 0.08709494f, -0.29808107f, -0.02275327f, 
    -0.05178810f, -0.18687335f, -0.17945626f, -0.62437683f, -0.22054657f, -0.10833667f, 0.34678909f, -0.11203387f, 
    -0.03380149f, 0.22270229f, -0.09823761f, 0.10342326f, 0.25710383f, -0.17093715f, -0.13781565f, 0.27289826f, 
    0.15536161f, 0.08276998f, 0.01369621f, -0.24168195f, -0.00944056f, 0.08644547f, -0.04037213f, -0.11173673f, 
    0.22092651f, 0.07377417f, 0.13853440f, 0.02655552f, -0.14994544f, 0.03362898f, -0.32341892f, -0.30964145f, 
    -0.04439979f, -0.32416475f, -0.09125616f, 0.26284149f, 0.16592738f, -0.11444720f, 0.11201023f, -0.22482958f, 
    0.03966428f, 0.02959252f, -0.01692451f, -0.22667864f, -0.09019099f, 0.10521673f, -0.08115631f, 0.01642972f, 
    0.10776059f, 0.17601365f, 0.53126794f, 0.08750729f, 0.04357990f, 0.01650758f, -0.17735878f, -0.06178199f, 
    0.07137205f, 0.23103182f, 0.27874550f, -0.05746287f, 0.25872353f, -0.13321173f, 0.08556328f, 0.01941708f, 
    0.02218262f, 0.11625066f, 0.06730797f, -0.03389394f, -0.08513702f, -0.36279020f, -0.17760041f, 0.10271885f, 
    0.17192604f, -0.15342002f, -0.13487236f, -0.31218672f, 0.11721821f, -0.07500093f, 0.17234111f, -0.02711928f, 
    -0.15324524f, 0.07988843f, 0.01590256f, -0.10991288f, -0.07105764f, -0.05972556f, -0.06627706f, -0.12641315f, 
    -0.14436048f, -0.25751615f, -0.10189728f, 0.00362681f, 0.09439509f, -0.03865325f, -0.24845809f, 0.11783779f, 
    0.14119092f, -0.05527902f, 0.06345198f, -0.19441016f, -0.07493769f, -0.22212756f, -0.19609936f, -0.12736410f, 
    0.24599980f, 0.20527452f, 0.15524051f, -0.11972890f, 0.16824807f, -0.06153106f, 0.15042762f, 0.51819026f, 
    0.10514247f, -0.12446848f, -0.18592028f, 0.25191158f, 0.24333230f, 0.12196723f, 0.16352582f, -0.19479862f, 
    -0.17348360f, 0.29124668f, 0.06939008f, 0.09109139f, 0.06475263f, -0.12158402f, 0.24644281f, 0.05085908f, 
    -0.08941402f, 0.08177567f, -0.28319332f, -0.07893294f, -0.02341695f, 0.08752669f, 0.11933976f, -0.17437300f, 
    0.13045380f, -0.12146854f, -0.12088811f, 0.27509177f, 0.01928080f, 0.02643059f, -0.15677765f, -0.02029932f, 
    0.02960511f, -0.10137313f, 0.08492376f, 0.07699322f, 0.09491546f, -0.09627002f, -0.07731161f, 0.03978495f, 
    0.13631156f, -0.22682975f, -0.17334345f, 0.15145050f, -0.03281759f, 0.08651523f, -0.29714513f, 0.10690781f, 
    0.07631674f, 0.09048104f, 0.13525704f, -0.16663994f, 0.04195248f, -0.24188575f, -0.47827974f, 0.20787424f, 
    -0.14140141f, -0.25397599f, 0.01671766f, -0.11005889f, 0.13684428f, 0.16360782f, -0.38656193f, -0.13387543f, 
    0.15000658f, -0.11628243f, -0.30692393f, -0.00760317f, -0.08083937f, -0.01701939f, 0.11656002f, 0.08241488f, 
    0.09835908f, -0.16220771f, 0.35052115f, 0.14719532f, -0.13806133f, 0.00934688f, -0.10037273f, -0.03459862f, 
    0.19299425f, 0.17901430f, 0.00186407f, 0.54519898f, -0.19113190f, -0.08076868f, -0.11240969f, -0.14654639f, 
    0.15053110f, -0.17336555f, -0.04212010f, -0.04627537f, -0.66088116f, 0.15178666f, -0.11361302f, -0.38832662f, 
    -0.00793703f, 0.09349826f, -0.09705763f, -0.07219657f, 0.17411046f, -0.28105319f, -0.20987839f, 0.00783592f, 
    -0.16662544f, -0.00217338f, 0.19604145f, 0.04301780f, -0.10467199f, -0.37953630f, 0.08454157f, -0.16875668f, 
    0.24744986f, -0.01853542f, -0.06569588f, 0.14442632f, -0.01767681f, -0.07489797f, -0.18717071f, 0.51606220f, 
    0.04900378f, 0.22228308f, 0.11241398f, -0.05328994f, 0.09538353f, 0.08870288f, -0.08961108f, 0.08298645f, 
    0.31077769f, 0.16305584f, -0.11040612f, 0.04317402f, 0.04931077f, -0.24395341f, 0.06850944f, 0.18379113f, 
    0.15830091f, -0.06261805f, -0.15240911f, 0.04571111f, 0.06453669f, -0.09504423f, -0.00201466f, 0.04185458f, 
    0.21697216f, 0.17058054f, 0.23825693f, -0.31893647f, 0.18205182f, -0.04947207f, -0.04479751f, 0.04068248f, 
    0.07416673f, 0.50304765f, -0.15300044f, 0.33580786f, 0.02862865f, -0.23471341f, 0.01614333f, 0.04447836f, 
    0.05648116f, -0.06867683f, -0.10077453f, 0.00597006f, 0.09938364f, -0.10949188f, -0.10682646f, -0.22813374f, 
    0.04029736f, -0.00025857f, 0.01394119f, -0.05996917f, 0.21183941f, 0.13094935f, 0.04938724f, 0.08914322f, 
    -0.23168038f, -0.02324592f, 0.06699672f, 0.06610082f, -0.10290968f, 0.02802148f, 0.55261248f, 0.13990186f, 
    0.11141846f, 0.07357587f, 0.06302892f, 0.06992065f, 0.12152183f, -0.19875877f, -0.09422356f, 0.17563020f, 
    0.12149128f, -0.21430840f, 0.02598441f, 0.00817220f, -0.05445406f, 0.01626381f, -0.13186382f, 0.03001554f, 
    0.23804082f, -0.13409267f, -0.06371363f, 0.03813801f, 0.04600816f, 0.03664755f, 0.05333128f, -0.25767130f, 
    -0.23714150f, 0.11668536f, 0.01258946f, -0.04905941f, -0.05781680f, 0.02063997f, 0.05795361f, -0.05754725f, 
    -0.22585386f, -0.15037870f, -0.22978143f, -0.07092708f, 0.01905846f, -0.01544753f, 0.05636448f, 0.10138865f, 
    0.09282464f, -0.18202589f, -0.09631815f, -0.51707304f, 0.37868884f, -0.04659369f, 0.07050513f, 0.09250129f, 
    0.06104674f, 0.12079333f, -0.18000516f, 0.04917364f, 0.15326060f, 0.07687574f, 0.23861377f, -0.08945107f, 
    0.08170538f, 0.12472479f, 0.19686113f, 0.26836506f, 0.26121292f, -0.01362677f, -0.01133198f, -0.01348361f, 
    0.03231758f, -0.06087613f, 0.08185827f, -0.07397832f, -0.31040004f, 0.17091259f, 0.24068299f, 0.07104833f, 
    -0.12523992f, -0.11753792f, 0.05697185f, 0.03931305f, -0.10514155f, 0.38932166f, 0.44133496f, -0.09634606f, 
    -0.00866849f, 0.05820231f, 0.09934770f, -0.11934207f, 0.03341587f, -0.08384682f, 0.03169682f, -0.19883652f, 
    -0.26372159f, -0.10113380f, 0.07975174f, -0.05283627f, -0.00826209f, -0.01400194f, -0.06708585f, -0.10150323f, 
    0.17157553f, 0.11813977f, 0.09916025f, 0.08106163f, 0.03316597f, -0.01014696f, -0.14149797f, 0.04130028f, 
    -0.02746573f, 0.14881261f, -0.25133097f, -0.22046800f, 0.09724247f, -0.13078626f, 0.09765232f, 0.10837864f, 
    -0.08519536f, -0.04372223f, -0.00130708f, 0.30667442f, -0.19870536f, 0.00569993f, -0.18973430f, -0.02695874f, 
    -0.02046055f, -0.32819214f, -0.08181013f, 0.25153896f, -0.36048099f, 0.07372114f, -0.02491312f, -0.22426295f, 
    -0.02501602f, 0.06582186f, 0.09248757f, 0.11436065f, 0.20664731f, 0.17842978f, -0.29976490f, -0.28976119f, 
    -0.19869258f, -0.06048072f, 0.02258122f, 0.20981149f, 0.23360373f, 0.15778732f, -0.22362299f, -0.11158866f, 
    0.04647682f, -0.05377003f, -0.07567751f, -0.06045545f, -0.08411113f, -0.07651318f, -0.24979201f, -0.22956529f, 
    -0.09281889f, -0.01995589f, 0.10260076f, -0.06062600f, 0.08279531f, 0.11907063f, -0.54599160f, 0.13837585f, 
    -0.12509176f, 0.35556886f, -0.04157275f, -0.24216512f, -0.02308412f, 0.02921470f, 0.03922756f, 0.00158087f, 
    -0.10915102f, -0.43492654f, 0.07535394f, 0.05340097f, -0.04706001f, -0.02478633f, -0.01417234f, -0.02767661f, 
    -0.13722749f, 0.16680571f, 0.16128558f, -0.01234051f, -0.16809177f, -0.21992835f, -0.07084510f, 0.10441764f, 
    0.13344574f, 0.04733018f, 0.12611996f, -0.14239164f, 0.03144978f, 0.00431084f, 0.06227208f, -0.01808027f, 
    0.16691032f, 0.08080256f, 0.17168057f, 0.14499040f, -0.11350817f, 0.17725666f, 0.15155053f, -0.19889338f, 
    -0.11432291f, -0.16362047f, -0.06032914f, 0.46618050f, 0.08507881f, 0.10299844f, 0.01251951f, 0.09602445f, 
    -0.14076363f, 0.06258220f, 0.34169739f, -0.16212593f, -0.50222516f, 0.10368140f, -0.07963175f, -0.05074968f, 
    -0.01178511f, 0.09557808f, 0.09677755f, 0.18482123f, 0.18793218f, 0.25742793f, 0.12012612f, -0.14070238f, 
    0.13464697f, -0.04256026f, 0.13843058f, -0.08748128f, -0.00457928f, 0.16132151f, 0.03734149f, 0.07123657f, 
    -0.05293491f, -0.13416624f, -0.00351443f, 0.28701660f, -0.04978617f, -0.12673314f, -0.11126353f, 0.13344252f, 
    0.49987984f, -0.32547635f, 0.21263741f, 0.15190016f, -0.12140138f, 0.09465019f, -0.17215697f, 0.10059370f, 
    0.59677750f, 0.21701925f, -0.26122370f, -0.00447169f, 0.04998280f, 0.11650863f, -0.03996295f, -0.01323778f, 
    0.05196116f, -0.17488748f, 0.05248137f, -0.05304981f, -0.12793572f, -0.09637368f, 0.01204503f, -0.05539671f, 
    -0.05063793f, 0.13691011f, -0.20339949f, 0.09473751f, -0.23517123f, -0.17455947f, -0.06209728f, -0.01058619f, 
    -0.28052822f, 0.09099936f, 0.21180074f, -0.06561667f, -0.58038682f, -0.55041623f, -0.06138964f, -0.04537785f, 
    -0.00287019f, -0.02304797f, -0.03954275f, -0.26566759f, -0.15454227f, 0.20163977f, -0.16428384f, 0.00944837f, 
    0.01799982f, 0.06032335f, -0.08295248f, 0.09396920f, 0.38429320f, -0.44356450f, 0.12779735f, 0.36435252f, 
    0.10120519f, 0.05774488f, 0.06364658f, -0.27169931f, -0.07434074f, -0.23093285f, -0.14560910f, 0.24690273f, 
    0.20431918f, 0.05925111f, -0.03103556f, -0.25462139f, -0.08925253f, 0.17208429f, 0.03621100f, -0.22071923f, 
    -0.50359607f, 0.17345236f, -0.10263842f, 0.07784417f, -0.14445834f, -0.07726412f, 0.10366729f, 0.31807256f, 
    0.51402020f, 0.00504791f, -0.11277979f, -0.11723071f, 0.09647917f, 0.17869845f, 0.03625270f, -0.06776746f, 
    -0.26470441f, 0.55997419f, 0.20283593f, 0.35629544f, 0.08480055f, 0.03062770f, 0.06444234f, -0.15385827f, 
    -0.24359335f, -0.09433934f, -0.10823888f, -0.02997633f, -0.10266981f, -0.14251927f, -0.04014064f, 0.03728729f, 
    -0.18975343f, -0.02930786f, 0.17671712f, -0.74632663f, -0.46199539f, -0.32404554f, -0.15177698f, 0.08246626f, 
    0.12610291f, 0.10416220f, 0.15783069f, 0.14662644f, -0.14267987f, 0.02413714f, -0.05078539f, -0.10154291f, 
    -0.00396934f, 0.12549658f, -0.00519183f, 0.00643199f, 0.04601255f, 0.16110471f, 0.11006843f, -0.11434429f, 
    -0.14788733f, -0.22373310f, -0.15892264f, 0.21016714f, 0.01065286f, 0.07465118f, 0.31173736f, -0.20838831f, 
    0.07721922f, -0.02655542f, 0.08021369f, -0.05791426f, -0.30265310f, -0.09142366f, 0.01333256f, -0.12599069f, 
    0.13696432f, 0.43789005f, 0.02458022f, 0.11129312f, 0.00575689f, 0.04634818f, 0.00703502f, 0.24270076f, 
    -0.21358961f, 0.02192868f, 0.07259239f, -0.07635221f, 0.19457112f, -0.06286138f, 0.01230512f, -0.06884171f, 
    -0.01364059f, -0.15231629f, 0.10758865f, -0.16578865f, 0.02236954f, -0.06868538f, -0.27410084f, 0.02276182f, 
    0.01720162f, -0.08559930f, 0.18001783f, -0.20866507f, -0.18756296f, -0.18323119f, 0.04196578f, -0.01181484f, 
    -0.05751877f, 0.01138350f, -0.06947757f, 0.01929279f, -0.10852392f, -0.16082601f, -0.08357002f, 0.13449338f, 
    -0.06830598f, -0.12586139f, -0.03202954f, 0.27116445f, 0.10243985f, 0.15786897f, 0.04796034f, 0.13697585f, 
    -0.02185911f, -0.01487802f, 0.11055211f, 0.01196259f, 0.02151194f, -0.26278591f, -0.06597430f, 0.21374506f, 
    0.09239445f, -0.06183472f, 0.15074323f, -0.01391264f, 0.10521137f, -0.13048702f, -0.03693285f, -0.50051737f, 
    -0.03227601f, 0.00290202f, 0.11479163f, 0.10606346f, -0.00310744f, 0.08269648f, -0.16604823f, 0.07011466f, 
    -0.49138463f, -0.07763348f, 0.00192487f, -0.01013477f, 0.10490435f, -0.17026289f, 0.02018834f, -0.06923477f, 
    -0.01768111f, -0.02240666f, -0.04733515f, -0.01268259f, -0.01138912f, 0.01189972f, 0.02476906f, -0.00428095f, 
    0.03194389f, 0.04780109f, 0.00276338f, 0.02830793f, 0.04881638f, -0.06244039f, -0.06328300f, -0.02042954f, 
    -0.02264840f, 0.01730365f, -0.03592102f, -0.03246900f, 0.01169008f, -0.05167820f, -0.03932523f, -0.01371105f, 
    -0.03820191f, -0.05080870f, 0.01806511f, -0.05490110f, -0.04518762f, 0.00669315f, 0.00663705f, -0.06165689f, 
    0.01915742f, 0.05120580f, -0.01397587f, 0.04450438f, 0.05629620f, -0.04941697f, 0.02375527f, 0.04205546f, 
    0.04028092f, -0.06387085f, -0.00141128f, -0.00813882f, -0.06072592f, -0.02635188f, -0.02405590f, -0.05683417f, 
    -0.01035599f, 0.00047620f, -0.06704012f, 0.00856378f, -0.05478023f, 0.02081231f, -0.01024540f, -0.04639164f, 
    0.02640377f, 0.02462737f, 0.04410884f, 0.05143049f, -0.00723013f, 0.02793028f, -0.05894123f, -0.01234167f, 
    0.02620780f, -0.05350488f, 0.04696625f, -0.06074272f, -0.02506025f, 0.03637850f, 0.03229576f, 0.02767487f, 
    0.02962487f, -0.05306856f, 0.05049599f, 0.04126479f, -0.06410307f, 0.02013456f, -0.04845271f, -0.05938328f, 
    0.02566873f, 0.01267373f, -0.03581006f, -0.00871352f, -0.05012798f, -0.01204306f, -0.04217437f, -0.02023823f, 
    0.04597878f, -0.05199642f, -0.02932448f, 0.03744031f, 0.02520816f, 0.04748541f, -0.05031801f, 0.00411508f, 
    0.03138835f, -0.04690926f, -0.00083430f, -0.05299980f, 0.01011765f, -0.00617887f, -0.06532439f, 0.00840131f, 
    -0.02656611f, 0.02585387f, 0.02248521f, 0.01552748f, 0.00648241f, -0.00255340f, 0.00224904f, -0.02047013f, 
    0.03086582f, -0.05492407f, -0.05637717f, -0.01346705f, -0.05732990f, -0.04908894f, 0.02837393f, 0.01551552f, 
    -0.04890914f, 0.03910569f, 0.00889873f, 0.02453384f, -0.00250831f, 0.00092343f, -0.04444758f, -0.02362954f, 
    0.01770812f, -0.05282377f, -0.01763777f, -0.04858249f, -0.04247686f, -0.02463577f, -0.01574540f, -0.03456313f, 
    -0.00271755f, -0.04370169f, -0.04397918f, -0.03982005f, -0.00554112f, -0.02163665f, 0.00994333f, -0.05255627f, 
    -0.05189402f, -0.04947649f, 0.04561501f, -0.00801374f, -0.01213709f, -0.03070071f, -0.03645509f, -0.03324020f, 
    0.03330613f, -0.04112608f, 0.04113849f, 0.03639692f, -0.03318955f, -0.00209334f, -0.05007178f, -0.00755973f, 
    0.04031620f, 0.03401250f, -0.01977591f, 0.04872512f, 0.02413594f, -0.02678481f, 0.03855863f, -0.02188154f, 
    -0.04805665f, 0.03413969f, -0.03819815f, 0.04007093f, 0.05787968f, -0.02760099f, -0.05191775f, -0.01627800f, 
    0.02250826f, -0.00064668f, 0.02031001f, -0.06220828f, 0.03303467f, 0.00788094f, 0.01533109f, -0.04240277f, 
    -0.00100435f, 0.01879178f, -0.05054293f, -0.00782550f, 0.00939196f, 0.04573572f, -0.04593694f, -0.01997375f, 
    0.04916266f, -0.01179426f, -0.01856986f, -0.00879877f, -0.00863852f, 0.00064236f, 0.01913277f, 0.00240049f, 
    0.01066328f, -0.05130424f, -0.06251984f, -0.03363768f, 0.01624721f, -0.02079137f, -0.05798450f, 0.01079325f, 
    0.00997962f, -0.03885624f, -0.03024200f, 0.03486377f, 0.00662571f, 0.00187384f, -0.00634596f, 0.02242334f, 
    -0.04227540f, -0.03970692f, -0.02363515f, 0.00688361f, -0.04927954f, -0.05997501f, 0.02545872f, -0.02427348f, 
    0.04117471f, 0.00714719f, 0.02648395f, -0.02180712f, 0.02544652f, 0.04901466f, 0.03793459f, -0.00701325f, 
    -0.02756904f, 0.00079495f, -0.05527220f, -0.03678846f, -0.01135686f, 0.03871599f, 0.03181658f, 0.03927844f, 
    -0.04124443f, 0.04495705f, 0.00925005f, 0.00633307f, -0.00818613f, -0.01008894f, 0.00303650f, -0.00957995f, 
    -0.01683495f, -0.04462412f, 0.04937872f, 0.02164070f, 0.03482468f, -0.00434313f, -0.04876662f, -0.06537688f, 
    0.00804190f, -0.01357429f, 0.03489036f, -0.01206299f, -0.02630413f, 0.01886503f, 0.04160494f, 0.04853405f, 
    0.04951085f, 0.04209643f, 0.04580383f, 0.00379732f, 0.04915906f, 0.04665380f, 0.05228519f, -0.04429518f, 
    -0.03303538f, 0.01061304f, -0.02359905f, -0.03440846f, 0.03352724f, -0.00345390f, 0.04517387f, 0.04122224f, 
    -0.02485345f, -0.01806962f, -0.01884184f, 0.04822464f, -0.03554362f, -0.00344112f, -0.05495978f, -0.01680876f, 
    0.12306770f, 0.15111601f, 0.11691758f, 0.08855843f, 0.13736638f, -0.06571811f, -0.09821901f, 0.18075085f, 
    0.05867709f, 0.36548203f, 0.11781596f, 0.13579319f, 0.04593239f, 0.01289162f, -0.09880094f, -0.03539660f, 
    0.13927284f, -0.00207350f, -0.14311004f, -0.27176070f, -0.02073976f, -0.17442325f, -0.03921106f, 0.07515792f, 
    -0.33810183f, -0.09232785f, -0.16295069f, -0.11790675f, -0.01098694f, 0.03107225f, 0.13900089f, -0.08921304f, 
    -0.08201690f, 0.26602885f, 0.00373040f, -0.29951239f, -0.06187215f, 0.00802454f, 0.25947464f, 0.14501406f, 
    0.24529226f, -0.01086168f, 0.16855752f, 0.10766204f, 0.09094837f, 0.26277751f, 0.13339882f, 0.29663381f, 
    -0.00837486f, 0.12453533f, 0.01675574f, 0.08683699f, 0.17935595f, 0.02452379f, 0.23244725f, 0.22710787f, 
    0.08224795f, -0.02941440f, 0.10656053f, 0.35028005f, -0.28624970f, -0.29643732f, -0.21551190f, 0.38995185f, 
    -0.08025771f, -0.10219424f, -0.20135890f, 0.02985587f, -0.12638968f, -0.30288076f, 0.02701928f, -0.22357897f, 
    0.55264038f, 0.07625575f, 0.03035125f, 0.11596982f, -0.07292978f, 0.05498848f, -0.19664288f, 0.00537683f, 
    -0.12996453f, -0.07972527f, -0.07177258f, 0.04005469f, 0.23248959f, 0.06906067f, -0.21513616f, -0.07106360f, 
    -0.06737133f, 0.03586653f, 0.15055618f, -0.14332099f, -0.21733032f, -0.09901108f, -0.27878180f, -0.27459204f, 
    -0.18290879f, -0.08600385f, 0.04388258f, 0.23550358f, 0.00935782f, -0.21246913f, -0.09002320f, 0.01256392f, 
    0.11670868f, -0.14292210f, 0.09072517f, -0.04126566f, 0.25188786f, 0.29960227f, -0.06379399f, 0.12239572f, 
    0.17364083f, 0.03513604f, 0.25532719f, 0.10760451f, -0.12140059f, -0.14633732f, 0.20849341f, 0.15725823f, 
    0.25299695f, -0.12684070f, 0.03327400f, -0.06472591f, -0.34882689f, -0.26348028f, 0.08750780f, 0.16741183f, 
    -0.05206170f, -0.11882046f, -0.14197761f, -0.33787948f, 0.06113984f, 0.09327628f, 0.17984325f, -0.10635894f, 
    -0.18602340f, 0.05491820f, -0.19363327f, 0.01781948f, -0.24670441f, -0.05695854f, -0.01375322f, 0.07206548f, 
    -0.13799256f, -0.02789025f, -0.20158727f, 0.04841650f, 0.03008263f, -0.07112344f, 0.18334024f, 0.08785642f, 
    -0.06065970f, -0.01776725f, -0.15205427f, 0.02228266f, 0.05099070f, -0.10566877f, 0.26465988f, -0.08130259f, 
    -0.03346713f, -0.16302900f, -0.07217374f, 0.27103722f, 0.18596458f, 0.16272236f, -0.04488827f, 0.07761299f, 
    -0.24783936f, -0.15325043f, 0.00276365f, 0.22355936f, -0.11789911f, -0.11644112f, -0.28625607f, -0.01154535f, 
    -0.00144114f, -0.04120100f, -0.04559307f, 0.03230748f, -0.01654234f, 0.20284560f, 0.28763208f, -0.12804484f, 
    -0.20835800f, 0.01281800f, -0.08093496f, -0.02922850f, -0.06750634f, 0.47745228f, 0.28463277f, -0.12655613f, 
    -0.02342967f, -0.00737303f, -0.13359818f, 0.07104514f, -0.22173634f, -0.08884136f, -0.13857095f, 0.03232300f, 
    -0.21979444f, 0.08518242f, -0.09911836f, -0.12851189f, -0.10697971f, -0.01874572f, 0.07700359f, 0.14329448f, 
    0.18797840f, 0.07546806f, 0.06485657f, 0.16968800f, -0.22628282f, 0.05481918f, 0.06668340f, -0.34192574f, 
    0.27212477f, -0.05934962f, -0.11729728f, -0.29886982f, -0.14446868f, 0.05328834f, 0.03079748f, -0.14993972f, 
    0.15191363f, -0.00961823f, 0.29167816f, 0.30739534f, 0.03587065f, 0.08543020f, -0.11615995f, -0.24874946f, 
    0.00489612f, -0.26501441f, -0.02712028f, 0.14331850f, -0.06307776f, -0.04340600f, -0.08786879f, -0.12238254f, 
    0.08350722f, 0.11546927f, 0.03681220f, -0.07293832f, -0.02225816f, -0.40665790f, 0.03041985f, 0.07661816f, 
    -0.08254677f, -0.09537672f, 0.08689988f, -0.09817581f, 0.09053886f, -0.07748399f, -0.02093270f, 0.06953990f, 
    0.01195940f, -0.07762977f, 0.16187739f, -0.05823728f, -0.20866156f, -0.05351301f, 0.13035300f, 0.01817184f, 
    0.01129470f, -0.04456282f, -0.10222970f, 0.04282558f, 0.15704730f, -0.30994555f, -0.19407070f, -0.11023398f, 
    -0.08248423f, -0.15354529f, -0.06502682f, 0.13014320f, -0.05364977f, 0.10784554f, 0.06711235f, 0.04402883f, 
    -0.03410715f, 0.07569695f, 0.08734145f, -0.02605421f, -0.08590782f, -0.04300244f, 0.06812622f, -0.03437381f, 
    -0.00285847f, -0.04249118f, 0.01315094f, -0.00262585f, -0.00748751f, 0.04516976f, -0.06027468f, 0.03037741f, 
    0.02300630f, -0.04052485f, 0.03707105f, -0.02483810f, -0.03171934f, -0.01235646f, -0.05343879f, -0.00855847f, 
    -0.06262659f, 0.02080625f, 0.05907222f, 0.05417132f, -0.00851026f, -0.03129647f, -0.04959233f, -0.06742353f, 
    -0.06047372f, 0.04528809f, -0.01486955f, -0.01248936f, 0.02014110f, -0.00452164f, -0.02524769f, -0.04527475f, 
    -0.05535975f, -0.01353583f, -0.00358679f, -0.05156884f, -0.03671033f, -0.05535319f, 0.01245433f, -0.00378615f, 
    -0.06104869f, -0.00219868f, -0.02006633f, 0.01761572f, 0.03609300f, -0.00254181f, 0.01320464f, -0.03665380f, 
    -0.03752823f, -0.00007263f, 0.02397956f, -0.03094942f, 0.04680971f, -0.01120558f, 0.04342028f, 0.05140490f, 
    -0.01670536f, -0.01593711f, -0.01789092f, -0.01228235f, -0.01983440f, -0.01667594f, 0.04997249f, -0.00895041f, 
    -0.03208227f, 0.04726539f, -0.05804021f, -0.05506834f, 0.00427224f, -0.00639271f, -0.01043889f, -0.00669178f, 
    -0.01899294f, 0.02191965f, -0.06202855f, -0.05869365f, -0.05593849f, 0.01577654f, 0.05185497f, -0.06591879f, 
    0.02467363f, -0.00590207f, 0.04045102f, 0.02507548f, -0.01631039f, -0.02379468f, -0.00177068f, -0.02761615f, 
    -0.00610388f, 0.03774362f, -0.03222100f, -0.03385130f, -0.01985778f, -0.00504903f, 0.02499345f, -0.02206809f, 
    -0.06128274f, -0.05111786f, -0.02983135f, -0.00310679f, -0.02019742f, 0.00900487f, -0.00866154f, 0.01903716f, 
    -0.06431053f, 0.00759830f, -0.05248724f, -0.02992013f, -0.04664660f, 0.01689816f, 0.02151929f, -0.03210910f, 
    0.02601255f, -0.00404309f, 0.03147176f, -0.05048756f, 0.04527061f, 0.03821895f, 0.02348312f, 0.02650624f, 
    -0.02791351f, 0.00172211f, -0.04204202f, -0.02258585f, -0.01371120f, -0.04453211f, -0.06712566f, 0.00040381f, 
    0.02726367f, -0.04308113f, 0.02534189f, 0.01082178f, -0.02182615f, -0.00828261f, -0.02390754f, -0.01975427f, 
    0.00210483f, 0.00968613f, -0.02094506f, -0.05634239f, -0.05335803f, -0.03366614f, -0.00590466f, -0.00156952f, 
    0.03297200f, -0.04906329f, 0.03644530f, -0.01748560f, -0.02247955f, 0.01048822f, 0.03497137f, -0.00987247f, 
    -0.05027931f, 0.04337496f, 0.04382392f, 0.01274862f, 0.01881375f, 0.01079810f, -0.05527512f, 0.02030792f, 
    -0.00877125f, -0.01701416f, -0.01163324f, 0.01122790f, -0.00872563f, 0.04608731f, 0.01682140f, 0.01771984f, 
    0.02927351f, -0.00693842f, 0.00066811f, -0.03513160f, -0.01381505f, -0.03972581f, 0.00762222f, -0.03646999f, 
    0.04369133f, 0.00694603f, -0.02265721f, 0.02910872f, -0.01371027f, 0.02336188f, 0.05267880f, -0.04153328f, 
    0.03120499f, 0.04262633f, -0.04300327f, 0.03209722f, -0.00003059f, 0.04302484f, -0.01428794f, 0.04421377f, 
    0.00436626f, -0.02218732f, 0.02197123f, -0.01308745f, 0.01953090f, 0.03519841f, 0.00196330f, -0.04002055f, 
    0.02977119f, 0.02454345f, -0.04331300f, -0.02082796f, 0.00886307f, 0.00169485f, -0.01240688f, -0.04038836f, 
    -0.00142364f, 0.05001612f, 0.00967892f, 0.01426843f, -0.06175588f, -0.04665915f, 0.04946325f, 0.02256630f, 
    0.03450722f, -0.01222629f, 0.00322144f, -0.01019195f, 0.01920377f, 0.02109225f, -0.03868706f, 0.01656285f, 
    -0.04672075f, -0.03306080f, -0.03362429f, -0.00150442f, 0.03876140f, -0.01412407f, 0.00573503f, 0.01946507f, 
    0.01472886f, 0.02967811f, 0.01247773f, -0.04957661f, 0.04210722f, 0.02323943f, 0.03948248f, 0.02488364f, 
    0.00603486f, -0.03310736f, -0.05977883f, -0.01441094f, -0.01735350f, -0.00960728f, -0.02941412f, 0.04001910f, 
    -0.05153544f, 0.01031601f, 0.00148964f, 0.03838381f, -0.04984435f, -0.01905581f, -0.04856033f, -0.04525725f, 
    0.03402979f, -0.00436629f, -0.00644643f, -0.03847011f, -0.04943611f, 0.03619004f, 0.03088406f, -0.02650530f, 
    0.02204065f, 0.02011826f, 0.03974505f, 0.05036680f, -0.05592632f, -0.05476413f, -0.00193032f, 0.00526329f, 
    -0.02294718f, 0.04966651f, -0.01665940f, -0.02449221f, 0.03845702f, -0.04701954f, 0.01826394f, 0.04223302f, 
    0.02707964f, 0.01772479f, 0.03378608f, -0.06430658f, 0.00356172f, -0.03897902f, 0.00313560f, -0.03381474f, 
    -0.08303331f, -0.24617434f, 0.37449533f, -0.17683850f, -0.09916305f, 0.10417026f, -0.00298952f, 0.01944829f, 
    0.12315838f, -0.03555299f, 0.05847540f, 0.03267760f, 0.00789078f, -0.07057851f, -0.01043104f, 0.04061200f, 
    0.09856371f, 0.03080981f, -0.06147526f, 0.25066459f, -0.49615130f, 0.17415284f, -0.02963254f, -0.00879878f, 
    0.00634874f, -0.00263606f, -0.10161979f, 0.23421235f, 0.43109554f, -0.40811941f, -0.13429631f, 0.05147359f, 
    0.05390595f, -0.19111101f, 0.07990125f, 0.04841017f, -0.51486868f, -0.34259474f, 0.00851548f, -0.08668710f, 
    -0.13122354f, -0.15578867f, 0.28174010f, -0.02895194f, -0.29617628f, -0.30494598f, -0.22013490f, 0.51047903f, 
    -0.12851778f, 0.11552046f, -0.02373026f, 0.02252417f, -0.05957976f, 0.06388514f, 0.09432447f, 0.05727880f, 
    -0.06121672f, -0.10749473f, -0.07353520f, 0.09987057f, 0.11465124f, -0.13020027f, 0.00448196f, 0.32327247f, 
    -0.25874892f, 0.23564608f, -0.04321961f, 0.13158193f, 0.08223800f, 0.13258784f, -0.03693377f, 0.21720330f, 
    0.13279068f, -0.39321378f, 0.46376365f, -0.21259907f, -0.04448250f, -0.22367798f, 0.18553469f, 0.01037288f, 
    0.06938182f, -0.36891660f, 0.36740905f, -0.13312699f, 0.24974310f, -0.10805646f, -0.11002110f, 0.01556621f, 
    0.05245347f, 0.22185813f, -0.11361370f, 0.15569098f, -0.07591308f, 0.22566523f, -0.00690940f, -0.01178855f, 
    0.12675287f, -0.02604276f, 0.23529819f, 0.12963882f, 0.12100945f, -0.14672375f, 0.21305196f, 0.17477208f, 
    0.10944315f, 0.04673084f, 0.03345272f, -0.05117390f, 0.06305260f, -0.29044011f, 0.13284592f, -0.07724335f, 
    -0.09685668f, 0.04461291f, -0.08035989f, -0.01466230f, -0.03673503f, -0.30254090f, -0.33850282f, 0.08887969f, 
    0.18371825f, -0.02293590f, 0.08412163f, -0.08472627f, -0.09144195f, 0.07192516f, 0.04704641f, 0.35401183f, 
    -0.51260495f, 0.26287812f, -0.25421527f, 0.11573940f, 0.03484613f, -0.10217261f, 0.13817467f, 0.20572302f, 
    -0.10844722f, 0.20954779f, 0.19586273f, 0.00720180f, -0.04344475f, 0.06846432f, 0.06434803f, -0.07371176f, 
    -0.34999409f, -0.14654733f, -0.00055119f, 0.05211819f, -0.12798521f, 0.01982402f, -0.01024719f, 0.13132563f, 
    0.03748693f, -0.86910194f, -0.14190297f, -0.19415596f, 0.25414717f, 0.15406479f, 0.12389860f, -0.07144491f, 
    -0.02317849f, -0.01678347f, 0.28669566f, -0.24279588f, 0.03243736f, -0.10552499f, -0.09882163f, -0.09221409f, 
    -0.15050893f, 0.17297079f, 0.15389995f, -0.10493528f, 0.12912521f, -0.22175689f, 0.03743597f, 0.16351125f, 
    -0.07726621f, 0.09102160f, 0.13046943f, -0.06515896f, -0.22901540f, -0.00762403f, 0.42462075f, -0.07775156f, 
    0.16475910f, 0.03350078f, -0.04525764f, -0.06361254f, -0.02515573f, -0.15355800f, -0.26323050f, 0.07068148f, 
    0.38348255f, -0.05096419f, 0.17346023f, -0.12302227f, -0.05261622f, 0.10289546f, -0.38318795f, -0.00004240f, 
    -0.25798380f, 0.28281218f, -0.07008865f, 0.14854732f, 0.04941496f, 0.00233256f, 0.02901111f, -0.35540485f, 
    -0.10310205f, -0.08544584f, 0.12238558f, -0.10222983f, 0.04180066f, -0.20148569f, -0.05080035f, 0.18551724f, 
    0.01212237f, 0.12038003f, -0.35314819f, 0.00499488f, -0.14568600f, -0.16191466f, 0.18752567f, 0.09427731f, 
    -0.08352400f, -0.14471333f, 0.14575833f, 0.21097195f, 0.21775785f, -0.08337393f, -0.22686122f, 0.02374711f, 
    -0.10302226f, -0.06172138f, -0.06676298f, 0.32920271f, 0.06821742f, 0.00131066f, -0.18607390f, 0.03175982f, 
    -0.19630915f, -0.06028597f, 0.20339368f, 0.80370283f, 0.05006107f, 0.06088341f, -0.05435634f, -0.08122006f, 
    -0.10309187f, 0.21592379f, -0.06794730f, 0.12679805f, -0.01217458f, 0.21120489f, -0.33236843f, 0.24262920f, 
    0.00925639f, -0.03384773f, 0.00468613f, -0.03505658f, -0.05377718f, -0.43027329f, -0.01540615f, -0.49044189f, 
    -0.05350329f, 0.01899794f, 0.04795133f, 0.16301320f, -0.26423481f, 0.18481219f, -0.01698044f, 0.38866907f, 
    -0.16916093f, -0.00391693f, 0.03667141f, 0.21320365f, 0.01214155f, -0.08312649f, -0.14947446f, 0.18201515f, 
    0.12513801f, -0.58408767f, 0.14141648f, 0.03283519f, 0.12290461f, -0.08592035f, -0.10225111f, -0.07878944f, 
    0.14738840f, -0.37234589f, -0.29409432f, -0.11475409f, -0.00468209f, 0.11433370f, 0.17026927f, -0.17142512f, 
    -0.17864914f, -0.05695646f, -0.55980277f, 0.00836743f, 0.15156002f, 0.12203074f, 0.17190690f, 0.08064523f, 
    -0.16144301f, 0.13678712f, 0.29665697f, 0.18602744f, -0.21420282f, 0.08793721f, 0.11284228f, 0.17526135f, 
    -0.22767031f, -0.14137879f, 0.43410647f, -0.02123745f, 0.06718172f, 0.07656624f, 0.22050600f, 0.13416310f, 
    -0.27523321f, -0.10403454f, -0.25965184f, 0.05746037f, -0.23921698f, -0.28860927f, -0.23478387f, 0.00516467f, 
    -0.12264004f, 0.16796821f, 0.14083178f, -0.08510014f, 0.05125179f, 0.44488063f, -0.29402417f, -0.29927665f, 
    0.02992884f, 0.09692349f, 0.13528647f, 0.07268417f, -0.12531793f, -0.04690464f, 0.01073275f, -0.00271189f, 
    -0.08125666f, 0.12802558f, 0.37538758f, -0.15520382f, 0.14612514f, 0.13153374f, 0.01562404f, 0.12186140f, 
    -0.28193673f, -0.18108302f, 0.09544889f, 0.07665478f, 0.09731227f, 0.21057044f, -0.06508765f, 0.17495742f, 
    -0.65289760f, -0.50979966f, -0.32921943f, 0.25417140f, 0.08250502f, -0.30808929f, 0.05512711f, 0.03704892f, 
    0.02531982f, 0.29830608f, -0.02687618f, -0.02105699f, -0.13674144f, 0.29324281f, 0.03497354f, 0.07838285f, 
    -0.08744286f, 0.06889449f, -0.20399055f, 0.12649797f, -0.03399318f, 0.09941602f, 0.03308858f, -0.01389788f, 
    0.12458375f, -0.03649368f, 0.21029428f, 0.23805699f, 0.49390203f, 0.28653815f, -0.36994243f, 0.15630278f, 
    0.41057271f, 0.28105539f, 0.13907893f, -0.02614046f, 0.07726151f, -0.35308114f, -0.45629823f, 0.08778448f, 
    0.03061821f, 0.07606027f, 0.10218139f, -0.04264607f, -0.03426273f, 0.29982170f, 0.06662855f, -0.25099471f, 
    0.07929306f, 0.20577784f, 0.30381611f, -0.01117382f, -0.32011941f, -0.16068837f, -0.66519636f, -0.38874853f, 
    0.09620483f, 0.06521945f, 0.24248397f, -0.11782069f, 0.25045002f, -0.01992446f, -0.35931590f, 0.05469748f, 
    0.49299833f, 0.20853844f, 0.23332827f, -0.05025300f, 0.03548502f, 0.05786704f, 0.09478285f, 0.08548573f, 
    -0.00427719f, -0.34927815f, -0.09292949f, -0.03288711f, 0.14263214f, 0.01840182f, -0.02155968f, 0.24265334f, 
    0.12965411f, 0.01944174f, 0.10657199f, -0.34301183f, -0.19165829f, 0.11640060f, 0.26312196f, 0.15552653f, 
    0.04518170f, 0.17507812f, 0.14225005f, 0.25582606f, 0.02425763f, -0.30838925f, 0.00025546f, 0.18165436f, 
    0.28271157f, -0.01147008f, -0.00438250f, -0.09103197f, 0.17556651f, 0.36458418f, 0.06634419f, 0.15952063f, 
    0.15351774f, 0.21964946f, -0.05755597f, -0.13156274f, 0.06160580f, 0.11535303f, -0.20883498f, 0.19100252f, 
    0.20449474f, 0.00156481f, 0.03844666f, 0.00744864f, -0.10089544f, -0.45290041f, 0.23852865f, 0.16878869f, 
    -0.04394377f, -0.08005133f, -0.19175324f, 0.13704334f, 0.19334684f, -0.09527205f, -0.02835023f, 0.41503662f, 
    0.00765411f, 0.02065030f, 0.08358142f, 0.15630576f, 0.14434713f, -0.05131181f, 0.08313549f, -0.04266231f, 
    -0.42148885f, -0.43129247f, 0.05418548f, 0.20373562f, 0.29834023f, -0.16320150f, 0.05736553f, -0.18276797f, 
    -0.30813313f, 0.40221775f, 0.29760447f, 0.03481236f, 0.02209672f, 0.00992521f, -0.01484690f, 0.19729082f, 
    0.14016488f, -0.01963212f, 0.21129392f, -0.23908444f, 0.00617295f, 0.05172602f, -0.05882479f, -0.09646542f, 
    -0.14294751f, 0.26863015f, -0.23103459f, 0.29901752f, 0.21082547f, 0.11840941f, -0.16727191f, -0.23003478f, 
    0.19808879f, 0.16157188f, 0.04416136f, -0.54420578f, -1.21353471f, -0.25461999f, 0.28077519f, -0.05229394f, 
    0.02803398f, -0.04176388f, -0.12632397f, -0.04839138f, -0.35347846f, 0.29260466f, 0.16432658f, 0.16466565f, 
    -0.13953449f, 0.10695458f, -0.05075328f, -0.27727991f, -0.00688101f, -0.07766694f, -0.32059613f, -0.40559554f, 
    0.10860385f, -0.19478393f, 0.12610333f, 0.33022732f, -0.22625746f, 0.05064736f, 0.23746893f, 0.18284799f, 
    0.08029741f, -0.03687322f, -0.27900752f, -0.15702178f, -0.04988156f, 0.02353333f, -0.05400938f, 0.20881699f, 
    0.16664757f, 0.13372046f, -0.26213524f, 0.03097520f, 0.36253875f, 0.10327917f, 0.21579085f, -0.09828883f, 
    -0.03641884f, -0.01893145f, -0.01030242f, -0.05036792f, -0.03941190f, 0.00177092f, -0.04646707f, -0.00212242f, 
    -0.03369455f, -0.03888731f, 0.04050583f, -0.01210194f, 0.02505561f, -0.05093160f, -0.05571225f, 0.00498628f, 
    -0.06445011f, 0.00543114f, -0.04568880f, 0.01942787f, -0.01243300f, -0.06470648f, 0.04800165f, 0.01597518f, 
    0.00349164f, -0.01509913f, -0.05986905f, -0.00966623f, 0.04595144f, 0.01303416f, -0.06512763f, -0.03689741f, 
    -0.03169189f, -0.02364673f, 0.01867349f, -0.03538574f, -0.03605525f, 0.00832659f, -0.04198162f, 0.02958692f, 
    0.00222213f, -0.03830687f, -0.05330443f, -0.04790638f, -0.01576178f, -0.03208197f, -0.05858443f, 0.01946218f, 
    -0.00125564f, 0.04052696f, 0.00062518f, 0.04264117f, -0.00715797f, 0.05285829f, 0.04313676f, -0.03350409f, 
    0.04538982f, -0.03563764f, 0.04821775f, -0.05908107f, 0.03375261f, 0.01480329f, -0.03184846f, -0.01928864f, 
    -0.05753712f, -0.06000419f, -0.01372716f, -0.04127533f, 0.04482991f, -0.03064579f, 0.00282219f, 0.00915143f, 
    -0.05400449f, -0.01287811f, 0.04503837f, -0.03634515f, 0.03090657f, -0.03690251f, -0.02840531f, 0.02094158f, 
    -0.01931379f, 0.00461543f, -0.06519903f, -0.03144108f, -0.03316590f, 0.00474517f, -0.00836176f, -0.05592655f, 
    0.02998191f, -0.00026969f, -0.01309278f, -0.00763309f, -0.00818284f, -0.01711746f, -0.03526982f, -0.04748285f, 
    0.01291333f, -0.06073995f, 0.04752874f, 0.01829145f, -0.00092710f, 0.04990410f, 0.02379474f, -0.00936076f, 
    0.02212376f, -0.05050943f, -0.02766427f, 0.03183383f, -0.02248797f, -0.00591065f, -0.02732038f, -0.01045337f, 
    -0.00373628f, -0.04274724f, -0.02397471f, -0.02815458f, -0.02122107f, 0.02012941f, -0.03804162f, -0.01949286f, 
    -0.05229377f, -0.05337097f, 0.01377802f, -0.05207027f, -0.02068198f, 0.02673528f, -0.02786973f, 0.04704331f, 
    0.03132793f, 0.02699060f, 0.05858681f, -0.05727870f, -0.02905177f, -0.06115592f, 0.01276546f, -0.04991436f, 
    -0.04216455f, 0.00811093f, -0.04523633f, -0.02362359f, -0.03354544f, -0.03524779f, -0.00141055f, 0.04367110f, 
    0.00779133f, -0.02808468f, -0.03539533f, 0.03020892f, 0.00041077f, -0.00229044f, 0.00160410f, 0.04163836f, 
    -0.04451663f, 0.03276772f, -0.02652881f, 0.03800381f, -0.03670710f, -0.04393749f, -0.00310170f, -0.03635639f, 
    0.00888309f, -0.05956026f, -0.04253387f, -0.05114216f, 0.02091632f, -0.00827041f, 0.01780641f, -0.03316122f, 
    -0.04428910f, -0.00491292f, 0.01294123f, 0.03983822f, 0.01551004f, -0.05844258f, -0.04377898f, 0.04716784f, 
    -0.05912176f, 0.02270114f, 0.05732350f, -0.00345913f, -0.03793744f, 0.05908563f, 0.02621334f, -0.02147966f, 
    0.01181820f, -0.03451727f, -0.03591488f, -0.00727686f, -0.05290546f, 0.00792047f, 0.04984055f, 0.03847064f, 
    0.00130285f, -0.05872919f, -0.00381768f, -0.04330283f, -0.05488665f, 0.00279334f, 0.01376356f, -0.04839571f, 
    0.03916506f, -0.00505995f, 0.03729978f, 0.02416182f, 0.02373126f, 0.00170507f, -0.01828846f, 0.00153965f, 
    -0.04427342f, -0.02658021f, 0.01078655f, -0.04229339f, -0.05097071f, 0.01476589f, -0.00336665f, 0.04885381f, 
    0.02695009f, 0.03791569f, -0.00935799f, -0.01020557f, 0.02816689f, -0.00760288f, 0.05097448f, 0.00245327f, 
    0.04909016f, 0.02875237f, 0.02541133f, -0.02201604f, -0.03059955f, -0.02716349f, -0.06757987f, -0.06322050f, 
    -0.01657217f, 0.02276158f, -0.02212820f, 0.03060542f, -0.03028652f, 0.00460902f, -0.02034518f, 0.00711970f, 
    0.02658710f, -0.00949977f, -0.05503193f, 0.02607983f, -0.05761685f, 0.03175881f, -0.06209418f, 0.02119088f, 
    -0.00680376f, -0.01846665f, 0.03179934f, 0.00211507f, -0.01974570f, -0.02790827f, 0.04842021f, 0.00911838f, 
    -0.01626098f, -0.04704757f, -0.02578753f, -0.05645748f, 0.04535174f, 0.00425866f, 0.01886887f, -0.00780816f, 
    -0.00887937f, -0.00677550f, 0.04864448f, 0.00647982f, -0.05253526f, -0.04802166f, 0.03597974f, 0.03921871f, 
    0.01332115f, 0.04762493f, 0.05260814f, -0.02984213f, -0.02729819f, 0.03817197f, -0.02430066f, -0.05568189f, 
    0.01944529f, -0.06661402f, 0.00455028f, -0.03160905f, -0.00391662f, -0.02364260f, -0.05738105f, 0.02852650f, 
    0.04451024f, -0.06518511f, -0.05131818f, 0.00380002f, -0.03751627f, 0.00625716f, -0.03375803f, -0.01318818f, 
    -0.02498351f, -0.05199463f, -0.05646541f, -0.04038811f, -0.01971777f, -0.05365582f, 0.00459340f, -0.02655387f, 
    -0.02846869f, -0.05388615f, -0.00321902f, -0.02799661f, 0.02871192f, 0.02484359f, -0.01234414f, -0.04280021f, 
    -0.04111644f, 0.03394519f, 0.04171674f, 0.04583336f, 0.02668584f, -0.04181393f, -0.00264549f, -0.04329358f, 
    -0.01051470f, 0.03758161f, -0.05202242f, -0.01509823f, -0.06131279f, -0.01892460f, 0.03891139f, 0.05346185f, 
    -0.02625330f, 0.05655052f, -0.02918330f, 0.02033383f, -0.00693467f, -0.01927808f, -0.03103955f, 0.05486126f, 
    0.01790770f, -0.03125113f, -0.01637784f, -0.05509650f, 0.02089630f, -0.05257973f, -0.00982304f, 0.04014050f, 
    -0.00001037f, -0.03985526f, 0.03749673f, 0.00172108f, -0.00931929f, -0.01872477f, -0.00045069f, 0.00893110f, 
    0.02037381f, 0.03065028f, -0.04083931f, -0.03100246f, -0.03436070f, 0.03424698f, 0.04284848f, 0.04505277f, 
    -0.00801155f, -0.04668804f, 0.04062658f, 0.02808819f, -0.04612160f, -0.00229208f, 0.04478737f, 0.02697695f, 
    -0.02962117f, -0.01278012f, -0.06255393f, -0.00001959f, -0.02114529f, -0.04263557f, 0.05056920f, -0.04098136f, 
    0.00909381f, -0.02035441f, -0.06372665f, 0.00480600f, -0.01400928f, 0.04243220f, 0.02437836f, -0.02754724f, 
    -0.00262018f, -0.04945928f, 0.03029955f, 0.04003305f, 0.00557437f, -0.01399542f, -0.02148403f, -0.05910494f, 
    0.00689282f, -0.06010735f, 0.03023688f, -0.02379837f, -0.02254057f, 0.03994886f, 0.04204825f, -0.04922682f, 
    0.00775411f, -0.04635916f, 0.02709526f, 0.03052287f, -0.04590531f, 0.05613540f, -0.02729080f, 0.01961729f, 
    -0.00570810f, 0.03287972f, -0.01658490f, 0.01443741f, 0.05130818f, 0.02961286f, 0.00897222f, 0.02060963f, 
    0.04535749f, -0.02030920f, 0.04413295f, 0.02044635f, -0.01652092f, -0.05569965f, -0.02124815f, 0.02370605f, 
    0.03665978f, -0.04582577f, -0.01956500f, -0.01880950f, -0.05077030f, -0.03471664f, 0.04926803f, 0.04729899f, 
    -0.05693047f, 0.02864868f, 0.03683386f, -0.02664202f, -0.02905120f, -0.06101089f, -0.03955131f, 0.01292733f, 
    0.03936677f, 0.00228857f, -0.04919418f, -0.02072229f, -0.03020938f, -0.03711887f, -0.02488650f, -0.06090257f, 
    0.04073744f, 0.01440217f, -0.05343053f, -0.04094062f, -0.03628188f, -0.02026330f, 0.04275265f, 0.03336893f, 
    -0.05467724f, 0.00999878f, -0.00330782f, 0.03867836f, 0.01313643f, 0.01618525f, 0.01602729f, 0.00648554f, 
    0.02715279f, -0.05065535f, 0.01862066f, -0.01138108f, -0.06426679f, -0.01541883f, -0.04797717f, 0.05155937f, 
    0.03520657f, -0.03230643f, -0.04287324f, -0.06263374f, -0.03337952f, -0.01080601f, -0.01672263f, 0.03852535f, 
    0.04837614f, -0.00953086f, 0.03137833f, -0.01854081f, 0.02082917f, 0.02022990f, 0.02752917f, 0.01323435f, 
    -0.04791382f, -0.04767866f, 0.02987100f, -0.01584686f, -0.00853820f, -0.03030331f, -0.01165771f, 0.02091050f, 
    0.00096277f, 0.04802543f, 0.04360205f, 0.00199724f, 0.05126100f, 0.00252973f, 0.02106365f, -0.05311477f, 
    0.01441969f, -0.03610544f, 0.00717018f, 0.00478574f, 0.01999922f, 0.00538416f, 0.00212104f, 0.03576089f, 
    0.00245004f, -0.02382496f, -0.02837215f, -0.02619099f, -0.02546816f, -0.04566790f, 0.00022893f, 0.05226791f, 
    -0.02397949f, -0.02022391f, -0.06086869f, 0.04754146f, -0.00386075f, 0.02833228f, -0.00515493f, -0.01725785f, 
    -0.04563966f, -0.02476085f, -0.01585066f, -0.01050124f, 0.05184441f, -0.00802172f, 0.05747568f, 0.03058667f, 
    -0.02616461f, 0.01051321f, -0.05275179f, 0.04126740f, 0.01871487f, 0.04279285f, -0.05804026f, -0.06195894f, 
    0.01193651f, 0.00665161f, 0.03651317f, -0.02935298f, -0.00781148f, 0.02920419f, -0.03119739f, -0.03820952f, 
    0.01278863f, -0.05719860f, -0.05164495f, -0.00278665f, -0.03510931f, -0.04993372f, -0.02564605f, -0.01465497f, 
    -0.01231848f, -0.05976498f, 0.00197586f, -0.00092939f, 0.00723188f, -0.03619403f, 0.05063339f, -0.02473826f, 
    0.00601261f, -0.03905741f, 0.00150764f, -0.00339754f, -0.00685070f, 0.04210649f, -0.05887860f, 0.01158602f, 
    -0.05653541f, -0.01716126f, -0.14902166f, -0.01883853f, 0.08023082f, 0.02566047f, 0.06086247f, 0.05490275f, 
    0.14390936f, -0.00698983f, -0.20363665f, -0.07662618f, 0.09679505f, -0.11603141f, 0.18019186f, -0.11726719f, 
    -0.17574157f, 0.15014444f, 0.38891709f, 0.01674581f, 0.08533181f, 0.02685992f, -0.15919065f, -0.13992761f, 
    0.12854451f, 0.04488210f, 0.16216752f, 0.24116950f, -0.12140929f, 0.01877107f, -0.05248861f, -0.01096470f, 
    -0.04466521f, -0.11855072f, 0.06708191f, 0.04522369f, -0.00381657f, 0.33781692f, 0.21714509f, -0.05375142f, 
    0.17209753f, -0.25348324f, -0.13154194f, -0.17598876f, -0.20677288f, -0.11042666f, -0.26788479f, 0.04513615f, 
    0.11754717f, 0.09100626f, -0.06322607f, 0.00668394f, 0.02516066f, 0.04020065f, 0.03605335f, -0.21347196f, 
    0.04404468f, 0.07961016f, 0.11292919f, 0.22452351f, -0.25527146f, 0.10186630f, 0.02401008f, -0.15390559f, 
    0.21507476f, -0.01219798f, -0.09212569f, 0.06562582f, -0.11223186f, 0.11820062f, 0.02761737f, 0.18083981f, 
    0.08966324f, 0.19580798f, -0.04381194f, -0.44493547f, 0.09380107f, -0.04392317f, 0.05507742f, 0.00173752f, 
    -0.01114993f, 0.01900239f, 0.03820544f, 0.03652964f, 0.20695902f, 0.00621743f, 0.34350878f, 0.05434734f, 
    0.08373396f, -0.22051086f, -0.09088667f, 0.09906373f, -0.23410949f, -0.01165888f, -0.10769964f, -0.05843512f, 
    0.30240455f, 0.13288906f, -0.05024434f, -0.10476491f, -0.41334510f, -0.25245127f, 0.06145376f, 0.02040290f, 
    -0.07845737f, -0.03511940f, -0.05038677f, 0.02462688f, -0.05731907f, 0.19273224f, 0.02263643f, -0.20688325f, 
    -0.13552172f, 0.17037833f, -0.13306068f, -0.02826061f, 0.15145169f, 0.03553056f, 0.04882090f, 0.11668994f, 
    -0.24921022f, 0.06391681f, -0.31879359f, 0.20479572f, 0.15033427f, 0.19393851f, 0.20323125f, -0.05479928f, 
    0.09677679f, 0.21679494f, 0.17000148f, 0.17901863f, -0.11917411f, 0.14300783f, -0.14453842f, -0.02778416f, 
    -0.23596181f, -0.18969606f, 0.11306215f, 0.38482001f, 0.00413582f, 0.15893249f, -0.06106248f, -0.08298431f, 
    0.06635275f, 0.16569051f, 0.06228456f, -0.18871352f, -0.07164975f, -0.04611748f, 0.03438677f, 0.01423279f, 
    0.26266322f, -0.11329907f, 0.01329177f, 0.31545353f, -0.15673342f, -0.06276706f, -0.26629010f, 0.06470490f, 
    0.09047392f, -0.03013247f, 0.17217526f, 0.10307118f, 0.11790112f, 0.04765809f, 0.16138791f, 0.05241504f, 
    0.04768557f, -0.17068185f, 0.07897045f, 0.09365670f, 0.07094985f, -0.17364553f, 0.27718875f, 0.05691366f, 
    0.08473241f, -0.08401959f, 0.20374651f, -0.04630791f, 0.12942576f, -0.22676179f, 0.08620201f, 0.09960508f, 
    -0.02582704f, -0.20430206f, 0.16726342f, 0.00177712f, -0.04905209f, -0.24859563f, -0.07320150f, -0.12627551f, 
    -0.22117902f, -0.03237429f, -0.02012797f, 0.16115335f, 0.03975178f, -0.01317483f, -0.28641677f, -0.10391340f, 
    0.13893005f, -0.10904379f, 0.15557158f, 0.08286663f, 0.00019489f, -0.10090474f, 0.01226176f, 0.03031901f, 
    -0.07528386f, 0.13379833f, -0.11985578f, -0.02216039f, 0.29563472f, -0.06253188f, 0.15258867f, 0.26263365f, 
    0.14863530f, -0.24938084f, -0.22013623f, -0.09121288f, 0.06515191f, -0.04048479f, 0.11509208f, 0.18553492f, 
    0.08403162f, 0.43801308f, 0.00275248f, 0.20968261f, 0.22946566f, -0.04208397f, -0.11336287f, -0.05070381f, 
    0.03537660f, -0.09800554f, -0.27272391f, 0.04847801f, 0.08694058f, 0.10705496f, 0.16978243f, -0.14569682f, 
    0.12393226f, -0.01956112f, -0.13994585f, -0.07102741f, 0.00118520f, 0.23260148f, -0.04101653f, -0.22192115f, 
    -0.12015582f, -0.13720898f, 0.43895963f, 0.11654914f, 0.18839832f, -0.01425589f, -0.21345639f, 0.00402591f, 
    -0.04275480f, -0.22251385f, 0.01889755f, -0.01764727f, 0.13993883f, -0.05359754f, -0.13735943f, 0.10009367f, 
    0.04075636f, -0.20312586f, 0.11233613f, 0.14991046f, -0.10163417f, -0.11942683f, 0.02751462f, -0.35722318f, 
    -0.17981249f, 0.22595099f, 0.19552167f, -0.27310190f, 0.06351946f, 0.13192549f, 0.03455966f, -0.03793932f, 
    -0.12717077f, 0.00498468f, -0.06366505f, -0.00987155f, 0.07704457f, 0.13175884f, 0.10389313f, 0.15894841f, 
    0.17848091f, 0.24660209f, -0.00731938f, -0.08051731f, -0.12074161f, 0.01096216f, 0.04700018f, 0.04473061f, 
    -0.01219524f, 0.09915626f, 0.12803617f, -0.08516159f, 0.00492640f, -0.00173932f, -0.03381573f, -0.19934867f, 
    0.25764155f, 0.21269946f, 0.11820517f, 0.18045956f, 0.28397855f, 0.29334703f, 0.06339425f, 0.26901948f, 
    -0.20746791f, -0.07719313f, 0.09444366f, 0.38169795f, -0.01449812f, -0.18087038f, 0.00104245f, -0.07810372f, 
    0.28402856f, -0.07438673f, -0.02882793f, 0.00624012f, -0.12224225f, 0.00590626f, -0.04503988f, 0.12009420f, 
    0.05966936f, 0.03926845f, 0.18875828f, 0.01915552f, -0.20009188f, -0.04013196f, 0.24683125f, 0.10273194f, 
    0.10000363f, 0.12802878f, 0.08967946f, -0.17586420f, 0.22044463f, 0.06090107f, 0.21160758f, 0.25843114f, 
    -0.10821677f, 0.09357433f, 0.06069080f, 0.11851833f, 0.03490691f, 0.09000836f, -0.21990399f, -0.26269493f, 
    -0.36108109f, 0.50393111f, -0.09214871f, 0.00115671f, -0.01839322f, 0.06840864f, -0.03564441f, -0.09012721f, 
    -0.07928918f, -0.07322943f, 0.32239881f, -0.13670747f, 0.02953192f, 0.06560399f, 0.03172171f, -0.04617957f, 
    0.04127195f, -0.06927098f, -0.24313466f, -0.07648768f, -0.12459278f, -0.21546948f, -0.26906377f, 0.21337520f, 
    0.19382322f, -0.00052729f, -0.10693405f, 0.21814659f, 0.19461668f, 0.09142902f, -0.01701117f, 0.07195107f, 
    -0.16942775f, 0.10846902f, -0.08488412f, -0.31685826f, -0.52932096f, 0.05954801f, -0.03676645f, 0.13310114f, 
    0.20296274f, 0.08053818f, 0.14426510f, -0.06236541f, 0.34319490f, 0.15787664f, 0.19800434f, 0.14384131f, 
    -0.05498871f, -0.13458648f, -0.11144182f, 0.18046744f, -0.12935375f, -0.07341179f, 0.05653728f, -0.01149439f, 
    -0.12450875f, -0.16994488f, 0.04165968f, -0.00934240f, -0.15342477f, -0.14284873f, 0.07646073f, -0.03908820f, 
    0.18480183f, -0.07349311f, -0.09399381f, 0.20345527f, 0.17299683f, 0.19173433f, 0.23668520f, -0.22794294f, 
    -0.18213290f, -0.29560831f, -0.23012365f, 0.14586113f, -0.03147047f, -0.05730669f, -0.02661752f, -0.02870938f, 
    -0.00694583f, 0.04606834f, -0.06926964f, 0.11759095f, -0.07577284f, 0.07670116f, 0.08645769f, 0.15877098f, 
    0.03674682f, -0.05985861f, -0.16657481f, 0.13179447f, 0.20255977f, -0.13303064f, 0.20828058f, -0.23137084f, 
    0.03743361f, 0.22917332f, -0.06981029f, 0.10152951f, 0.26541656f, -0.04374531f, -0.00056600f, 0.00562507f, 
    0.06347414f, -0.13896701f, -0.31108990f, -0.64919430f, -0.36172068f, -0.13327512f, -0.15801243f, 0.05489578f, 
    -0.06130804f, 0.00751339f, -0.02539607f, -0.01955987f, 0.02864506f, 0.03712638f, -0.03716268f, -0.17945084f, 
    -0.11881991f, -0.04332240f, -0.24887864f, 0.47578624f, 0.05435272f, 0.23101906f, 0.04867761f, 0.34537011f, 
    0.08235185f, 0.13029006f, -0.13294584f, 0.19662143f, -0.05542386f, 0.01990646f, -0.35319504f, -0.13947906f, 
    -0.16576557f, -0.11041714f, 0.13204694f, 0.08741011f, -0.03831328f, 0.06026122f, 0.15944569f, 0.17243198f, 
    0.07406814f, -0.05901075f, 0.13472170f, 0.07614717f, 0.10478643f, 0.10005531f, 0.07660854f, -0.18963407f, 
    0.10844507f, 0.15122412f, 0.23894285f, -0.12440059f, -0.19442698f, -0.04608512f, 0.09747787f, -0.03639536f, 
    -0.02178179f, 0.11139269f, 0.13063122f, -0.35414660f, 0.06462835f, -0.08373217f, 0.03849767f, -0.04064314f, 
    -0.06289835f, 0.00059448f, -0.31969112f, -0.25145710f, -0.15081850f, -0.15057966f, -0.03695320f, -0.29606390f, 
    -0.11838818f, 0.04715489f, 0.13859120f, 0.15083165f, 0.23058924f, -0.56125325f, 0.15435725f, 0.12174477f, 
    -0.16814421f, -0.04908101f, 0.05588349f, 0.32599658f, 0.34002504f, 0.17230877f, 0.05840671f, -0.13386142f, 
    -0.24745239f, -0.25308019f, -0.00811628f, 0.01705642f, 0.21258022f, -0.17291801f, -0.00346610f, -0.03009461f, 
    -0.09792336f, -0.01970959f, 0.06144975f, 0.26078576f, -0.12950800f, -0.03150414f, -0.22420873f, -0.07743586f, 
    -0.48006782f, -0.22002122f, 0.04843297f, -0.07922398f, -0.19090207f, 0.04349742f, -0.10981017f, -0.59389973f, 
    -0.17936644f, 0.09033475f, 0.01811716f, 0.23514113f, 0.09032428f, 0.12975544f, 0.02154748f, -0.12899256f, 
    0.19330554f, 0.53681618f, 0.29481351f, 0.08548816f, 0.17737345f, -0.06223875f, 0.00943111f, -0.01936828f, 
    -0.12026563f, 0.10665131f, 0.37353820f, -0.40254134f, -0.07749185f, 0.06618640f, -0.12963480f, 0.04985841f, 
    -0.06006577f, -0.05967494f, 0.15172908f, -0.20494238f, -0.06656521f, 0.08330905f, 0.00325665f, -0.02315516f, 
    -0.04270283f, -0.07352985f, 0.24196611f, 0.18785073f, -0.18295617f, 0.21417198f, 0.08956913f, 0.00631113f, 
    0.01994105f, 0.00508253f, 0.05111673f, 0.05302184f, -0.44682610f, -0.10097704f, -0.05627864f, 0.23993813f, 
    -0.09738725f, -0.13372014f, 0.05184864f, 0.04663931f, 0.07645816f, 0.33706620f, 0.84763545f, -0.17511061f, 
    -0.00692978f, 0.09322917f, 0.01660944f, 0.06152370f, 0.05671144f, 0.11888583f, -0.13316776f, 0.39550936f, 
    -0.27337795f, -0.08991704f, 0.15290773f, 0.03371033f, -0.02212291f, 0.16305016f, -0.15371214f, 0.34714279f, 
    -0.18027975f, 0.07129333f, -0.27611455f, -0.01576338f, 0.21320638f, -0.02319757f, 0.11218607f, 0.17129469f, 
    0.21194768f, -0.34786665f, 0.19307993f, 0.16847813f, 0.13260508f, 0.12701023f, 0.08591302f, 0.15333201f, 
    -0.01496513f, 0.34518898f, 0.21609291f, 0.11188938f, -0.32255068f, 0.04757900f, -0.15748224f, -0.17314693f, 
    -0.01096129f, -0.05102630f, -0.23261167f, -0.16858868f, -0.40673345f, -0.20895165f, -0.11309277f, -0.06878337f, 
    -0.05741854f, -0.05352449f, 0.20298290f, 0.08565584f, 0.02021623f, 0.17221992f, 0.11895871f, -0.06147069f, 
    0.08991966f, -0.11591075f, -0.01461534f, -0.18361029f, 0.05348453f, 0.09542947f, -0.02067728f, 0.20456451f, 
    0.07095678f, 0.02352286f, 0.07939705f, -0.06121168f, -0.15349554f, 0.12930910f, -0.19338724f, -0.14951947f, 
    -0.02541952f, 0.24781379f, -0.16996148f, 0.05204034f, 0.11547543f, -0.10716230f, -0.10357314f, -0.49614960f, 
    -0.57156283f, 0.23460646f, 0.27062625f, 0.07866833f, -0.03079013f, -0.02261769f, 0.01158562f, 0.44570684f, 
    0.30817750f, -0.19520362f, -0.16565414f, -0.15746981f, -0.29087830f, -0.00183037f, 0.04414042f, 0.24352425f, 
    0.42991915f, -0.40701407f, 0.04557420f, -0.00797504f, -0.12280296f, -0.06368988f, 0.00065068f, 0.10442185f, 
    -0.03381773f, -0.09073249f, -0.27386343f, -0.49932942f, 0.14720252f, -0.12836900f, 0.03236053f, -0.04521482f, 
    0.22398153f, -0.24574363f, -0.25624987f, 0.19510810f, -0.07489227f, -0.04851994f, -0.07850713f, 0.32304516f, 
    0.18113069f, 0.08813099f, -0.19935957f, 0.27516553f, 0.14456460f, 0.07375655f, -0.04871034f, -0.14469838f, 
    -0.02333639f, -0.01557916f, 0.30740952f, -0.13463184f, -0.21493657f, -0.08394607f, -0.25433779f, 0.09219278f, 
    0.07790188f, -0.32975194f, -0.00690466f, 0.06392373f, 0.03143857f, 0.56202894f, -0.21769030f, 0.19917870f, 
    0.14913933f, 0.13236229f, -0.00383361f, -0.07820119f, 0.16288255f, -0.11204791f, 0.04266056f, 0.23578493f, 
    -0.35596552f, -0.19892466f, -0.07439111f, -0.09762648f, 0.07221390f, -0.01325469f, 0.00170728f, 0.25879350f, 
    -0.03263391f, -0.18814319f, -0.01478419f, 0.01589722f, -0.22414592f, -0.12921904f, 0.06018025f, -0.18996468f, 
    -0.48310846f, 0.02914606f, -0.29228753f, 0.00657896f, 0.04188074f, -0.29176578f, -0.09324388f, -0.14825368f, 
    0.31688449f, 0.15068801f, -0.14011191f, 0.12048653f, 0.03837739f, 0.04521981f, -0.22504434f, 0.03890922f, 
    -0.30852765f, 0.08417432f, -0.04176475f, -0.00219196f, 0.11862405f, 0.04310334f, 0.10387202f, -0.11317377f, 
    -0.15697277f, -0.05725133f, 0.05352917f, 0.02834948f, -0.49608111f, -0.18100733f, -0.25920320f, 0.09732851f, 
    -0.02644994f, -0.04507428f, 0.12329689f, -0.09019480f, -0.04533874f, -0.20601904f, -0.30892316f, 0.13975714f, 
    0.11022988f, -0.02581962f, -0.21839289f, -0.01036095f, 0.02560501f, -0.35713586f, -0.34444106f, 0.15546089f, 
    -0.22338289f, 0.12459512f, -0.06214068f, -0.07652373f, 0.15685797f, 0.15801767f, 0.42962688f, 0.31396061f, 
    0.13546115f, 0.00212272f, -0.25176105f, 0.23165987f, -0.11753254f, 0.13730930f, 0.20756096f, 0.40273497f, 
    0.12543264f, -0.08527426f, -0.03334673f, -0.28109583f, -0.08703642f, -0.03858618f, -0.02097874f, 0.21822385f, 
    0.53197330f, 0.17371388f, -0.19550715f, 0.14296012f, -0.11883096f, 0.15481666f, -0.02040527f, -0.00577676f, 
    0.11267626f, 0.44663641f, 0.00138440f, 0.15952758f, 0.12053917f, -0.13326867f, -0.15961027f, -0.01723790f, 
    0.02741355f, 0.12950300f, -0.07299613f, -0.14278217f, -0.30991474f, 0.11807355f, 0.08515249f, 0.13012438f, 
    -0.15375161f, 0.09921130f, 0.09380782f, -0.24295504f, -0.27575624f, 0.08887693f, 0.05858161f, 0.15857238f, 
    0.13009693f, -0.06015227f, 0.06153766f, -0.08487716f, -0.03222978f, 0.13517758f, -0.24303679f, -0.11113182f, 
    -0.05266614f, -0.15784112f, 0.01933024f, 0.36342773f, -0.05846693f, 0.66382939f, 0.21775299f, 0.18773030f, 
    0.02653871f, -0.20845594f, -0.13518137f, -0.07259183f, -0.09799659f, 0.05944439f, -0.16787609f, 0.31578052f, 
    0.06199963f, -0.00370371f, -0.04442838f, -0.03446501f, -0.06878573f, 0.12002429f, 0.04594979f, -0.37864673f, 
    0.04584725f, -0.33408040f, -0.04392095f, 0.01133086f, 0.25980479f, -0.00761673f, 0.00120393f, 0.09884181f, 
    -0.81457335f, -0.20390238f, -0.21827325f, 0.00630943f, -0.15377414f, 0.19906773f, -0.23150393f, -0.01106251f, 
    0.01187338f, 0.35966268f, 0.06104100f, -0.18922876f, 0.05496671f, 0.04598144f, -0.10088429f, -0.14934668f, 
    0.16426952f, 0.13289872f, 0.20657754f, -0.03758660f, -0.33358958f, 0.22150584f, 0.21991561f, 0.14887354f, 
    0.17333239f, 0.07527251f, 0.18451002f, -0.28689483f, 0.32830700f, 0.33589557f, -0.05755077f, 0.26381025f, 
    0.03462376f, -0.18454197f, -0.00125730f, 0.41166523f, 0.40621755f, -0.20560840f, 0.18409094f, -0.12435438f, 
    -0.17928465f, -0.29722714f, 0.19362094f, -0.08234289f, -0.17233683f, 0.28811827f, -0.38059410f, -0.33298340f, 
    0.14982250f, 0.06516464f, 0.06752644f, -0.17993407f, 0.02190978f, 0.00166033f, -0.07911057f, 0.34132719f, 
    0.33521131f, -0.05234789f, -0.18969783f, 0.10123236f, -0.16335143f, 0.06430642f, 0.01117663f, 0.07432300f, 
    -0.03001802f, -0.03937047f, -0.03351751f, 0.06626271f, 0.16998221f, -0.06761734f, 0.06703534f, 0.10728436f, 
    -0.10873418f, -0.05130092f, -0.17926376f, 0.14650235f, -0.02208707f, -0.00033701f, 0.24844919f, -0.03449461f, 
    0.08166713f, 0.00683774f, 0.07576495f, -0.83449388f, 0.05572432f, 0.20433003f, 0.22506993f, -0.32162321f, 
    -0.02152665f, 0.06332049f, -0.19641612f, -0.06428926f, 0.01847893f, 0.02906935f, -0.02996536f, 0.07568596f, 
    0.07372055f, 0.00151883f, 0.28138167f, -0.26879388f, -0.11864360f, -0.09838317f, 0.12590706f, -0.03079895f, 
    -0.05396088f, -0.29028174f, 0.17680375f, 0.12600102f, -0.17865755f, -0.32027882f, 0.16108154f, 0.10434920f, 
    -0.04577183f, -0.09805098f, -0.05777277f, 0.24742885f, 0.00383213f, 0.03833148f, -0.14127479f, -0.36188704f, 
    0.12623520f, 0.17685266f, 0.05008689f, -0.18758769f, 0.03501844f, -0.14486192f, 0.10463922f, 0.15541266f, 
    -0.18373588f, 0.29823652f, 0.11596733f, 0.18645771f, -0.28107455f, -0.20808497f, 0.10935378f, -0.03845947f, 
    -0.40521637f, -0.24167027f, 0.06216124f, -0.13842563f, 0.11823072f, 0.10449801f, -0.01022653f, -0.22094336f, 
    -0.52480245f, 0.14767566f, -0.33904418f, 0.01790334f, 0.02001965f, -0.09005247f, -0.03749535f, 0.13309641f, 
    0.44629121f, -0.44085664f, -0.35531253f, 0.22809532f, 0.07382297f, 0.24569389f, -0.06481182f, -0.01744521f, 
    -0.02586763f, 0.00064065f, 0.29066136f, 0.07456920f, 0.01530500f, -0.04893677f, -0.04391852f, 0.04617753f, 
    -0.00875350f, -0.00712571f, -0.06767387f, 0.11585160f, -0.58497995f, 0.12270473f, 0.11599230f, -0.21427749f, 
    0.08574728f, 0.16673669f, -0.12747544f, 0.25130478f, -0.05028128f, 0.21693760f, -0.34406218f, 0.04580960f, 
    0.17039511f, 0.06447141f, -0.05126744f, 0.11524544f, 0.13808395f, -0.16133790f, -0.24888742f, -0.37386039f, 
    0.09689361f, 0.07714365f, 0.06245078f, 0.08907548f, 0.05346193f, 0.14888594f, -0.35847563f, -0.02918271f, 
    0.31368512f, -0.15507157f, -0.08811670f, 0.12823780f, -0.06866504f, 0.10873833f, 0.04372521f, -0.09226780f, 
    0.11717353f, 0.13669544f, 0.00155801f, 0.10958833f, -0.05827494f, 0.06394435f, 0.11881088f, 0.06139652f, 
    0.05220966f, 0.43275875f, 0.20052299f, -0.11661589f, -0.11489127f, -0.03932395f, -0.10151231f, 0.08559725f, 
    0.05857519f, 0.36767903f, 0.04225121f, 0.11951076f, -0.01868614f, 0.01253696f, -0.16726097f, -0.09183418f, 
    0.32374147f, -0.05388943f, 0.22611029f, -0.22918329f, 0.20865071f, 0.07616394f, 0.21139386f, 0.03695760f, 
    -0.08830757f, -0.11758423f, 0.01398185f, 0.34153971f, -0.16841932f, 0.01658949f, -0.11513413f, 0.07053597f, 
    0.00658077f, 0.19432990f, 0.04033558f, 0.20321964f, -0.20983616f, -0.06713181f, 0.30591783f, -0.25780234f, 
    -0.22989206f, -0.04320547f, -0.00385241f, -0.10630960f, -0.30774960f, 0.03288925f, 0.34523126f, 0.11424194f, 
    -0.05519865f, -0.06135605f, -0.28381354f, -0.01070620f, 0.16256288f, -0.21288835f, -0.10081864f, 0.06153201f, 
    -0.22272968f, 0.27081275f, 0.15436332f, 0.10094596f, 0.02443846f, 0.04529740f, -0.32176530f, -0.29157278f, 
    0.12591960f, 0.02208269f, 0.01265527f, 0.08191293f, 0.12270348f, 0.04705230f, -0.03343215f, 0.09062877f, 
    -0.26816735f, -0.27982590f, -0.16246353f, 0.07332201f, -0.08602334f, 0.01637208f, 0.03526161f, -0.20836443f, 
    -0.09461064f, 0.03704780f, -0.02388923f, 0.08839433f, -0.08153760f, -0.11127513f, 0.08274549f, 0.21202371f, 
    0.08426491f, 0.00347296f, 0.00347291f, 0.30712652f, -0.15854661f, 0.06030796f, -0.12466443f, -0.01417343f, 
    -0.10585734f, 0.12718968f, 0.09290607f, -0.33035573f, -0.48700655f, -0.03616171f, 0.30003732f, -0.07329823f, 
    -0.08441483f, 0.04974247f, 0.06992991f, 0.18779829f, -0.06359569f, 0.42864665f, 0.13022327f, -0.13087188f, 
    0.00392781f, -0.06030467f, -0.11706600f, -0.05890016f, -0.09880451f, -0.15554801f, 0.18592873f, -0.30501556f, 
    -0.00721053f, -0.05894863f, -0.11299392f, 0.06832705f, 0.03245964f, 0.01297088f, 0.25376436f, 0.13108407f, 
    0.25823703f, 0.15590110f, -0.21898894f, 0.09130896f, -0.02040110f, 0.35142016f, 0.11190442f, -0.17020473f, 
    -0.35579583f, 0.04814325f, 0.32743099f, -0.08071817f, -0.18914023f, 0.00723952f, -0.26011449f, 0.06520476f, 
    0.21091054f, 0.03758924f, -0.19193193f, -0.13651390f, 0.10245132f, 0.02613714f, 0.08121531f, 0.02425985f, 
    0.34548378f, 0.10413706f, -0.12326010f, -0.16043094f, 0.05777666f, 0.00140442f, 0.11084098f, -0.26709783f, 
    -0.02371804f, 0.05974081f, -0.36849928f, 0.15325224f, -0.24182020f, 0.04477385f, -0.21523139f, 0.06137239f, 
    0.03738589f, 0.13835536f, -0.01130688f, -0.12311777f, -0.06804535f, 0.19471428f, 0.21106584f, 0.07717336f, 
    -0.08673514f, -0.20277640f, 0.20999190f, 0.00170873f, 0.23330314f, 0.12076408f, -0.10960010f, -0.04024822f, 
    -0.24528012f, -0.12083099f, 0.02974433f, 0.28204268f, 0.07853314f, 0.00645792f, 0.10659933f, -0.17452078f, 
    0.10789237f, -0.06115622f, 0.08140896f, 0.25312996f, 0.23300520f, 0.22750176f, -0.50476360f, -0.46558547f, 
    0.33389735f, 0.18363522f, 0.13868697f, -0.04481994f, 0.04138240f, -0.01692786f, -0.09147497f, -0.17408845f, 
    -0.29595280f, -0.14047153f, -0.16785267f, 0.26939005f, -0.05724699f, -0.13638464f, -0.30164710f, -0.05229784f, 
    0.05361871f, -0.23256955f, -0.27090746f, 0.14488336f, -0.09260079f, -0.11668866f, 0.10381257f, -0.06378371f, 
    0.01955951f, 0.25352234f, -0.09866262f, 0.06314926f, 0.14379314f, -0.05225989f, -0.07203938f, 0.02247967f, 
    0.22709008f, -0.10634077f, 0.05508557f, -0.26473650f, -0.10004130f, 0.11651402f, -0.08688958f, 0.00775154f, 
    -0.17048277f, 0.06392250f, 0.22306317f, -0.06552978f, 0.31672344f, -0.17888241f, 0.04600481f, 0.10801266f, 
    -0.01394657f, -0.03689355f, 0.01590022f, -0.15967780f, 0.12411828f, 0.17571895f, -0.12035017f, 0.10295121f, 
    -0.05337511f, 0.08737819f, 0.06479250f, -0.09417161f, 0.18209751f, -0.43175200f, 0.13161257f, -0.26480293f, 
    -0.18596940f, -0.16018055f, -0.08603509f, 0.03227835f, 0.10772924f, -0.10751765f, 0.09630843f, -0.42371672f, 
    0.08850340f, 0.29443735f, -0.08926602f, -0.02813378f, -0.00991023f, -0.17405872f, 0.19939016f, -0.48992410f, 
    -0.34715021f, 0.03816067f, 0.11213049f, 0.28823689f, -0.03356433f, 0.00153216f, 0.26438090f, -0.12093811f, 
    -0.09664536f, 0.17679733f, 0.10371369f, 0.20416984f, -0.06431312f, 0.06152495f, 0.23166390f, 0.07033040f, 
    -0.04590999f, -0.10578466f, 0.13339140f, -0.11075884f, 0.15402740f, -0.03113736f, 0.08687413f, 0.08482917f, 
    0.27441421f, 0.01044743f, -0.09261043f, -0.42547628f, 0.04789297f, -0.30146459f, 0.14916597f, 0.20867263f, 
    0.02086507f, -0.07954112f, -0.07449421f, -0.25692871f, -0.11152152f, 0.12081848f, -0.16264127f, -0.04669670f, 
    -0.15399426f, 0.02701581f, -0.13234532f, 0.01810849f, -0.13792612f, 0.14657177f, -0.13376494f, 0.09431402f, 
    -0.04548860f, 0.02891249f, 0.03475475f, 0.12385339f, 0.04522753f, 0.06763351f, 0.11181480f, 0.13596973f, 
    0.15426236f, 0.04149069f, 0.08189305f, 0.18099929f, 0.00987595f, -0.01608953f, 0.19251770f, 0.27288342f, 
    0.11701848f, 0.04901239f, 0.09734480f, 0.05793619f, 0.23964201f, -0.11875346f, -0.18123576f, 0.08044329f, 
    -0.09524598f, -0.00071141f, -0.00678162f, 0.02737494f, -0.23706840f, -0.06726140f, 0.02345424f, -0.03761850f, 
    0.35564277f, -0.05668997f, -0.36496401f, 0.14749764f, 0.03348848f, 0.06027043f, -0.11757948f, -0.07753290f, 
    0.17277983f, -0.07585344f, 0.25310305f, 0.18244293f, -0.02955659f, -0.02362794f, -0.35015929f, 0.06343076f, 
    0.12419183f, 0.20783184f, -0.19976114f, -0.15432665f, -0.20331642f, -0.00300886f, -0.25296536f, 0.03906859f, 
    0.03371462f, 0.09951482f, -0.06647617f, -0.11201792f, 0.19483352f, -0.29202753f, 0.00307031f, -0.07299878f, 
    0.08917722f, 0.11489797f, 0.07706571f, -0.07722304f, 0.03549271f, 0.06197410f, 0.09201941f, 0.23440838f, 
    0.10453665f, 0.02343109f, 0.27198514f, 0.27902347f, -0.13660236f, -0.09341573f, 0.12389724f, 0.04593690f, 
    0.10965827f, 0.10997967f, 0.12365966f, 0.18858583f, -0.21239707f, 0.15168367f, 0.30835092f, 0.30577981f, 
    -0.10254420f, 0.09168746f, -0.07613923f, 0.02802160f, 0.30410412f, -0.06594644f, -0.06774516f, -0.21586965f, 
    -0.05846635f, 0.13913427f, 0.05729533f, -0.13259655f, 0.01602779f, 0.05947275f, -0.11288502f, 0.10802133f, 
    0.11606926f, -0.06653680f, 0.05448495f, -0.00665667f, 0.11566050f, -0.11667279f, 0.10809352f, 0.20984492f, 
    -0.05995756f, 0.06951530f, 0.14086823f, 0.01268933f, -0.01169861f, 0.23565739f, 0.18660098f, -0.07000992f, 
    0.00778950f, -0.30457175f, 0.20515096f, 0.22379063f, 0.04689468f, 0.10636923f, 0.18254445f, -0.09686628f, 
    0.01575304f, 0.09625387f, 0.32315922f, 0.05781505f, 0.03174299f, 0.18582292f, 0.18448456f, 0.10774368f, 
    0.02523029f, 0.35521013f, 0.12666449f, 0.04793673f, -0.15572657f, 0.47852564f, 0.12699093f, 0.17825416f, 
    0.13465397f, 0.13578007f, 0.10447529f, 0.08625757f, 0.02497437f, -0.24194005f, -0.18210731f, 0.17347728f, 
    -0.08126589f, -0.08411395f, -0.08859397f, -0.23879617f, 0.00210573f, -0.15428804f, -0.14770132f, 0.07973297f, 
    0.11226845f, -0.06316531f, -0.03621520f, 0.00410061f, -0.03430489f, 0.07181236f, 0.15190971f, -0.20896198f, 
    0.19528489f, 0.16853710f, 0.28478393f, -0.14859079f, -0.03572112f, -0.12098336f, -0.08772049f, -0.20142096f, 
    -0.05444436f, -0.28965089f, -0.04720127f, 0.01652760f, -0.01152139f, -0.00235614f, -0.16878825f, -0.07148913f, 
    0.01906444f, -0.05916027f, 0.35996687f, -0.00796959f, 0.02242303f, 0.19385765f, 0.13675088f, 0.01480982f, 
    0.15725310f, -0.29127216f, -0.07372126f, -0.15358771f, -0.15754189f, 0.10513306f, -0.16317759f, -0.02391896f, 
    -0.04871864f, -0.12002777f, -0.02680192f, -0.21688972f, -0.24862719f, -0.00123127f, 0.02168688f, -0.05580209f, 
    -0.12200373f, -0.08678234f, 0.24891743f, 0.08823442f, -0.34155434f, -0.28334069f, 0.11864569f, -0.00429583f, 
    -0.06620120f, -0.08352137f, -0.03442090f, -0.07750720f, 0.01698741f, -0.15302499f, 0.29660887f, -0.25048202f, 
    0.05165630f, 0.12173457f, -0.18749842f, -0.05992279f, -0.07424267f, 0.01529825f, -0.27772588f, -0.59433997f, 
    -0.00309867f, -0.22144306f, -0.03173536f, 0.02087640f, -0.11280809f, -0.07891149f, -0.08122548f, -0.43017188f, 
    -0.03830165f, 0.20983577f, -0.07548770f, -0.19018246f, -0.07678939f, -0.02261952f, -0.16461128f, 0.21902820f, 
    0.00349769f, 0.04158165f, -0.00089965f, 0.03033326f, -0.02121179f, -0.03500635f, 0.00883174f, -0.04011411f, 
    -0.00050100f, -0.00106471f, -0.03863467f, -0.02686471f, -0.05119301f, -0.03217017f, 0.01306061f, -0.05599551f, 
    0.03129146f, -0.01575746f, 0.04807588f, -0.04389625f, -0.00495658f, 0.00969915f, 0.03156471f, -0.00642811f, 
    0.04452644f, -0.06160862f, 0.00454206f, 0.02303461f, -0.04832025f, 0.03989933f, 0.04114881f, 0.02033253f, 
    0.02418428f, -0.00662557f, -0.00093874f, -0.01059409f, -0.05110163f, 0.00775421f, 0.03195215f, 0.03446265f, 
    -0.03272301f, -0.02324087f, -0.00908487f, -0.02038005f, -0.01248649f, -0.00632935f, 0.03374765f, 0.01263295f, 
    -0.05975118f, -0.00020334f, -0.01828200f, -0.01524216f, 0.01198069f, 0.01885757f, -0.04320626f, -0.02434898f, 
    0.01521951f, -0.03800990f, -0.01449540f, -0.04264612f, 0.01420507f, 0.00414988f, -0.03028510f, -0.01835285f, 
    -0.03349886f, 0.01404706f, 0.03854587f, 0.03862517f, -0.04147693f, -0.04584861f, 0.00397989f, 0.04663841f, 
    -0.04933236f, -0.01873975f, -0.04749124f, -0.02118907f, -0.06541699f, 0.04237913f, 0.00872322f, -0.03531322f, 
    -0.01613300f, -0.03007726f, -0.00519294f, -0.00572999f, 0.01479956f, 0.01840268f, 0.01587109f, -0.06042000f, 
    0.00567517f, -0.03593747f, -0.05076622f, -0.04166088f, -0.01505495f, 0.00735071f, 0.03584516f, 0.05016010f, 
    -0.02623271f, -0.00155367f, -0.02066336f, -0.04402393f, -0.04600539f, -0.07200991f, -0.01885792f, 0.01934917f, 
    0.01680880f, -0.02681752f, -0.02300149f, -0.01928575f, 0.03262770f, 0.00648262f, 0.02021756f, 0.04578223f, 
    0.01902598f, 0.02363700f, 0.03315302f, 0.03424210f, 0.01173204f, -0.01604809f, -0.00158919f, 0.02110072f, 
    -0.03768618f, 0.01676596f, -0.00312812f, 0.02497362f, -0.02241983f, -0.05714795f, 0.02371296f, -0.04609697f, 
    -0.05928940f, -0.06378962f, -0.03463719f, -0.03562309f, -0.03774852f, 0.01529323f, -0.04966364f, -0.02195389f, 
    0.00526892f, 0.00471704f, 0.00376902f, 0.05104918f, 0.03432763f, -0.02030293f, -0.00602006f, 0.03405958f, 
    -0.07165816f, -0.02888345f, -0.05463386f, -0.00029860f, -0.05683746f, 0.02249942f, -0.05505627f, 0.04488349f, 
    0.02702237f, 0.00656560f, 0.02349716f, -0.03623103f, 0.03040286f, -0.02081234f, 0.03303635f, -0.00500403f, 
    0.04920433f, 0.02903105f, 0.03109205f, -0.03495429f, 0.02085909f, 0.01932741f, 0.00355481f, -0.01649741f, 
    0.02548229f, 0.03783794f, 0.05143918f, -0.04962766f, 0.00486139f, 0.04862624f, 0.04715194f, -0.04505155f, 
    0.03033237f, -0.04079532f, 0.02679101f, -0.03814933f, -0.04580997f, -0.06116248f, 0.02032864f, 0.01929395f, 
    0.04450001f, -0.03134304f, -0.01874992f, 0.03140470f, -0.01255222f, -0.02693486f, 0.03717503f, 0.00692848f, 
    -0.00091573f, -0.02938065f, 0.02314027f, -0.00784323f, -0.01957415f, -0.04661107f, 0.04410269f, -0.06525435f, 
    -0.01471698f, 0.01685855f, -0.06390456f, -0.03373332f, -0.04954119f, -0.05297098f, -0.03600798f, 0.01050520f, 
    0.01221080f, -0.04120820f, -0.00052795f, 0.01984309f, -0.05720548f, 0.04764434f, 0.00914896f, -0.00753227f, 
    0.04623868f, -0.01607185f, 0.01101066f, 0.04826313f, 0.01268849f, -0.00805438f, 0.03364360f, -0.01372934f, 
    -0.04970463f, -0.04147430f, 0.03543412f, -0.03320498f, -0.00261732f, 0.03042668f, -0.02796260f, 0.04358849f, 
    0.02518463f, -0.00170131f, 0.02635355f, 0.04339218f, 0.02455813f, -0.03445708f, 0.02280704f, 0.01048222f, 
    -0.04452861f, -0.01439701f, -0.03490278f, 0.01760430f, 0.02168907f, 0.00573481f, -0.00041846f, -0.04350489f, 
    -0.01687071f, -0.06729702f, -0.00357786f, -0.01559939f, -0.03553673f, 0.00878263f, -0.01189518f, 0.00363706f, 
    -0.02983075f, -0.02687988f, -0.02432281f, 0.00057948f, -0.02938562f, -0.05563882f, -0.01301391f, -0.06311756f, 
    -0.04120915f, -0.01340181f, 0.02674026f, -0.00317978f, -0.00623849f, 0.02391768f, 0.05574004f, 0.03868663f, 
    0.01742770f, 0.02128898f, -0.06279208f, -0.00467130f, 0.02084117f, -0.01587755f, -0.01915853f, -0.02578249f, 
    -0.06392152f, -0.06636430f, -0.03224938f, -0.02667652f, -0.05298733f, -0.01127042f, -0.03223195f, -0.04845222f, 
    -0.00059006f, -0.00933207f, 0.03660427f, -0.04057776f, -0.03203747f, -0.04014376f, -0.05022914f, -0.05897447f, 
    -0.02763705f, 0.04922641f, -0.01147165f, -0.04256635f, 0.02747736f, 0.02715421f, -0.05896370f, -0.03362942f, 
    -0.01562995f, 0.01105478f, -0.00220558f, -0.02315081f, -0.00561496f, 0.03493088f, -0.01923518f, 0.00842582f, 
    -0.04551266f, -0.05559185f, 0.00928195f, -0.04910099f, 0.01815547f, 0.01735826f, 0.01669647f, 0.03512758f, 
    -0.00954015f, 0.00286632f, 0.02347005f, 0.03130568f, -0.05688999f, 0.02311649f, -0.05339873f, 0.03087692f, 
    0.05407124f, -0.00711669f, -0.05918838f, -0.02510561f, -0.02976511f, 0.02556747f, -0.00061023f, -0.01444323f, 
    0.03747977f, -0.04960147f, 0.02367959f, -0.00970661f, -0.06678249f, -0.05452177f, -0.03451935f, 0.01983711f, 
    0.00865863f, 0.02056322f, -0.02481579f, 0.04003832f, 0.04038581f, 0.04400681f, -0.04631666f, 0.01567711f, 
    0.03889090f, 0.04116657f, 0.04088784f, -0.05094156f, -0.00293388f, -0.05883386f, -0.01724192f, 0.03770420f, 
    -0.03432429f, 0.04706777f, 0.03898722f, 0.01634032f, 0.03713482f, -0.04816236f, -0.03173461f, -0.03933490f, 
    -0.06762494f, 0.00275181f, 0.03365674f, 0.01845084f, -0.06719464f, 0.01954039f, 0.03617965f, 0.03922842f, 
    0.02821621f, 0.02270806f, -0.04854839f, 0.02733616f, 0.02894855f, -0.04697109f, 0.04219293f, 0.04900227f, 
    0.03564638f, -0.02285369f, -0.00494370f, -0.06435979f, -0.02126775f, -0.01288871f, -0.03981422f, 0.01157616f, 
    -0.01264349f, -0.03873263f, -0.03442357f, -0.00930161f, -0.05678267f, 0.04934014f, 0.00662644f, -0.01790763f, 
    0.02180776f, -0.01148022f, -0.02955039f, -0.02612584f, 0.01674106f, 0.02234811f, 0.05068272f, 0.02249488f, 
    0.03657416f, -0.03876017f, -0.00234847f, -0.00618938f, 0.00498884f, -0.01918163f, 0.00372162f, -0.04212212f, 
    0.01028941f, 0.01992429f, -0.05665994f, 0.02713756f, -0.02475664f, -0.04804939f, -0.00149664f, -0.05300855f, 
    -0.04410357f, 0.02397148f, 0.01829979f, -0.00322537f, 0.03247414f, -0.03248378f, -0.05345715f, 0.04037370f, 
    -0.05698332f, 0.02707492f, -0.03913685f, 0.04549096f, -0.06469700f, -0.01274724f, -0.02982547f, -0.04685717f, 
    -0.04615371f, -0.01682290f, -0.03162699f, 0.03876897f, -0.01325948f, 0.00900044f, -0.00856629f, -0.01956733f, 
    0.03846378f, -0.03730289f, 0.06615129f, -0.02254033f, -0.05763262f, -0.03721831f, 0.00586353f, -0.02994433f, 
    -0.05344064f, -0.02861512f, 0.04982347f, 0.04467214f, -0.00982864f, 0.01771974f, 0.01352429f, -0.02075173f, 
    -0.01688610f, -0.05747047f, 0.02946116f, 0.04131006f, 0.03626429f, 0.03999678f, -0.05100189f, 0.01436492f, 
    0.02525556f, -0.05187012f, -0.00774692f, 0.03237278f, 0.03943756f, -0.04650624f, 0.04988177f, -0.00974484f, 
    0.02255412f, -0.05636189f, -0.06911835f, -0.02800948f, -0.00993986f, -0.02223726f, -0.01786078f, 0.01429095f, 
    -0.04269522f, 0.01789742f, 0.03880099f, 0.00924427f, -0.00382247f, -0.01427609f, 0.00163167f, -0.05732572f, 
    -0.02615663f, 0.02557858f, -0.01085201f, -0.00222895f, 0.02714996f, -0.01792008f, 0.00855127f, -0.04685506f, 
    0.01789387f, -0.02766698f, 0.00102240f, -0.02329315f, 0.00168751f, -0.00983856f, -0.05426950f, -0.02687206f, 
    -0.05722240f, -0.04477610f, -0.04617003f, -0.03560996f, -0.01335155f, -0.02077297f, 0.04558409f, -0.03459481f, 
    0.02277010f, -0.03074612f, 0.01143692f, -0.05852589f, 0.04879420f, -0.06126038f, -0.00900020f, 0.04119280f, 
    0.00141270f, -0.05490509f, 0.00517427f, -0.04439241f, 0.03475155f, 0.04315304f, 0.01822153f, 0.05044047f, 
    0.04823072f, 0.04625750f, -0.02891305f, 0.04929583f, 0.03403332f, -0.03751670f, -0.05430428f, -0.01121933f, 
    0.04730318f, -0.01969871f, 0.02593230f, 0.00524717f, -0.05910888f, -0.01215254f, 0.05016526f, 0.00323330f, 
    -0.06669285f, 0.01546482f, -0.00882361f, 0.03011172f, -0.01648130f, -0.04779757f, -0.05455197f, -0.05627472f, 
    0.00043646f, 0.05206177f, -0.02759035f, 0.02720522f, -0.04073927f, -0.03630175f, 0.00274885f, -0.04914674f, 
    -0.02265846f, -0.01141190f, 0.03854588f, -0.03483016f, 0.02207015f, -0.05751364f, 0.04093450f, -0.06498555f, 
    0.02094348f, -0.01495383f, 0.02492443f, -0.03235903f, -0.01352890f, -0.01823571f, -0.06043865f, -0.00155960f, 
    -0.02922840f, 0.04522932f, -0.03809161f, 0.01322814f, -0.05517759f, 0.04806114f, -0.03225481f, 0.02841539f, 
    0.00760920f, 0.02293113f, -0.06264071f, -0.05181069f, 0.05164973f, 0.03264255f, 0.05279133f, -0.05927746f, 
    -0.05917840f, -0.00150878f, -0.05600675f, 0.01982765f, 0.02738841f, -0.04723233f, -0.00318090f, 0.00410373f, 
    0.01593913f, -0.04469088f, 0.00472958f, 0.04312057f, -0.05815319f, 0.01525003f, 0.03348993f, 0.00493003f, 
    -0.00241745f, 0.01116573f, -0.03921116f, 0.02758026f, -0.00185536f, 0.04567492f, 0.00252769f, -0.01191259f, 
    -0.03766498f, -0.03068249f, -0.03702660f, 0.04249677f, 0.03322835f, 0.00863632f, -0.00131623f, -0.01296728f, 
    -0.05234871f, 0.04767812f, 0.03604449f, 0.02496667f, -0.04879335f, 0.01020336f, -0.06333018f, -0.06124829f, 
    -0.02826040f, -0.03633497f, 0.01436135f, -0.06764341f, -0.00221461f, 0.04271784f, 0.02743771f, 0.02190521f, 
    0.01906563f, 0.01272106f, 0.00286737f, 0.04881118f, 0.01261943f, 0.00472697f, -0.06366112f, -0.00186931f, 
    -0.06660136f, -0.03973956f, -0.06834280f, 0.03221867f, 0.02149777f, 0.01651542f, 0.02678119f, -0.06398382f, 
    -0.03803455f, 0.01487916f, -0.05883255f, 0.02631726f, 0.00078647f, 0.02397312f, 0.04582247f, -0.05927467f, 
    0.00006009f, -0.01514941f, 0.01674116f, 0.03575272f, 0.01993873f, -0.01861965f, -0.02316652f, 0.02047979f, 
    0.03997313f, 0.03545209f, -0.05596945f, 0.01049901f, -0.05795807f, -0.02062545f, 0.02331407f, 0.03450289f, 
    -0.01458294f, 0.02110534f, -0.06209676f, 0.01106453f, -0.02056679f, 0.02514938f, 0.00267719f, 0.04026400f, 
    -0.02345855f, 0.00248911f, -0.06124667f, 0.04759781f, -0.05693351f, -0.03247231f, -0.03851920f, 0.04381730f, 
    -0.02535650f, -0.03025763f, -0.02166656f, -0.03533651f, 0.01611687f, 0.02856457f, -0.02369037f, 0.00687197f, 
    0.04188972f, -0.01984422f, 0.02281685f, 0.00561520f, 0.00667774f, -0.03957323f, 0.04813061f, -0.05902134f, 
    0.03466479f, -0.04237798f, -0.04224186f, -0.04543445f, -0.04113823f, -0.00939102f, -0.02381941f, -0.05740017f, 
    -0.04194279f, -0.00018425f, -0.03693831f, -0.03077323f, 0.03301661f, 0.01461059f, 0.00085334f, 0.02912774f, 
    0.05338383f, -0.00364612f, 0.04847601f, 0.03068463f, -0.02219174f, 0.01936849f, -0.02248926f, 0.04490506f, 
    -0.06643088f, -0.01541517f, -0.00799718f, 0.04094115f, -0.04480044f, -0.03974237f, 0.02234236f, -0.00588731f, 
    -0.02911579f, -0.01758937f, -0.00515529f, -0.00316631f, -0.02367855f, 0.01414270f, -0.00921146f, 0.04455548f, 
    0.03952620f, -0.04587477f, 0.01557041f, -0.00110178f, 0.02981964f, -0.01141771f, 0.00851140f, 0.01189965f, 
    -0.06332237f, -0.02266573f, -0.04239524f, -0.01409869f, -0.02464262f, 0.04823495f, -0.00646217f, -0.05561829f, 
    0.03655588f, 0.00889123f, -0.06725273f, -0.05883718f, -0.02542305f, -0.04444392f, -0.00148201f, 0.01664478f, 
    -0.01073995f, 0.01652665f, -0.00172938f, -0.05085932f, 0.00842679f, 0.00015511f, -0.05356880f, 0.04913809f, 
    0.04638761f, -0.04582670f, -0.06605698f, -0.01305437f, -0.03131344f, 0.01354269f, -0.03291188f, -0.05766166f, 
    -0.02245746f, -0.01950109f, -0.06327035f, 0.03016429f, -0.03269821f, 0.00377839f, 0.04872305f, -0.02203895f, 
    -0.02798955f, -0.02130027f, 0.03369735f, 0.04227365f, 0.00346183f, 0.01564261f, 0.00972877f, 0.03259328f, 
    0.04567016f, -0.02885730f, 0.02856711f, 0.03941899f, 0.04864714f, 0.03078002f, 0.01766106f, -0.00079041f, 
    -0.04366131f, -0.04222046f, 0.00995141f, -0.04566921f, 0.02455300f, -0.04150641f, -0.05491078f, -0.02213208f, 
    -0.01285075f, -0.00251283f, -0.06133004f, 0.02792119f, -0.00952495f, 0.02630911f, -0.01717036f, 0.05016064f, 
    -0.03100665f, -0.03749772f, -0.02990508f, -0.00386434f, -0.01152310f, 0.00623854f, 0.00194947f, -0.06780734f, 
    -0.04376778f, -0.02638819f, -0.04754170f, 0.03357720f, -0.00247198f, -0.03124214f, -0.06480899f, -0.06101743f, 
    -0.04818827f, 0.02537194f, 0.01968573f, -0.00494118f, 0.00123919f, 0.01410361f, -0.02639341f, -0.04803120f, 
    -0.01507205f, -0.06381826f, -0.07117411f, -0.05657863f, 0.02628501f, -0.02316871f, -0.01992167f, -0.04800622f, 
    -0.04125006f, -0.04649844f, -0.02400774f, 0.00689942f, -0.03933842f, 0.00196696f, 0.03633474f, 0.00889777f, 
    -0.06196804f, 0.05316399f, 0.02083029f, -0.02011042f, -0.04763164f, 0.02252878f, -0.03842255f, 0.02706619f, 
    -0.00865938f, 0.00338409f, 0.05138095f, 0.02080002f, 0.01110366f, -0.04085501f, 0.04420540f, 0.01673179f, 
    -0.03896055f, 0.04895950f, -0.05572670f, 0.02398316f, -0.01994343f, -0.03914251f, -0.06048010f, -0.05647917f, 
    -0.03796520f, 0.03190254f, -0.05089482f, -0.05604670f, -0.02687011f, -0.05930575f, -0.00100732f, -0.04958713f, 
    0.03566064f, 0.04862721f, 0.01401816f, 0.04094253f, -0.01902960f, -0.05494264f, -0.05221748f, -0.01876149f, 
    0.02003077f, -0.03574041f, -0.02478001f, -0.01889390f, 0.04544549f, 0.02373791f, 0.05187723f, -0.05800220f, 
    -0.00364710f, 0.00875080f, 0.03495603f, 0.04746506f, -0.02156226f, -0.04975858f, -0.03294777f, 0.00069491f, 
    -0.03833329f, -0.00049083f, 0.02564210f, 0.01780280f, 0.01277729f, -0.02684359f, 0.04689256f, 0.04844495f, 
    -0.06253923f, -0.03954452f, 0.00518192f, 0.03232642f, 0.03875293f, 0.05373862f, 0.03762927f, -0.01292267f, 
    -0.01269291f, -0.06696178f, -0.05403380f, -0.05078631f, -0.05326876f, 0.03426035f, 0.04583462f, -0.00032132f, 
    0.04737180f, 0.01047073f, 0.02049223f, 0.00320493f, 0.01112486f, 0.02945903f, -0.02370461f, 0.03983381f, 
    -0.04594773f, 0.00764900f, 0.01885596f, -0.06955220f, 0.03692269f, -0.05692518f, 0.00113430f, -0.02299551f, 
    -0.00301436f, -0.06075669f, 0.02445210f, 0.02751272f, -0.03644351f, 0.01474833f, 0.02154638f, 0.02179745f, 
    0.03811160f, -0.02748303f, 0.00087294f, 0.01866642f, -0.02206591f, 0.03487375f, -0.01288544f, -0.06029969f, 
    -0.02108699f, -0.04595704f, 0.03983538f, 0.01501048f, -0.04832004f, 0.01216161f, -0.02924040f, 0.01143481f, 
    -0.03611474f, -0.01423127f, -0.01192218f, -0.00747056f, -0.00228542f, -0.02104902f, 0.01582466f, -0.06677926f, 
    0.00481850f, -0.05156082f, 0.00220882f, -0.02521256f, 0.05250862f, 0.00665279f, 0.04654247f, 0.00225126f, 
    -0.04104327f, 0.02123358f, 0.04948630f, -0.01385286f, 0.00918810f, -0.05960207f, -0.03902482f, 0.02093091f, 
    -0.02352430f, -0.04059446f, -0.01235511f, 0.05353867f, 0.01285751f, 0.03440677f, 0.03341001f, -0.03060866f, 
    0.00965204f, 0.02053319f, 0.03432620f, -0.03121908f, -0.05827850f, 0.04606918f, -0.01888099f, -0.04306637f, 
    -0.02749963f, -0.03836665f, -0.01364580f, -0.01240368f, 0.01015677f, 0.05927212f, 0.01412628f, 0.01891479f, 
    0.04576869f, -0.05959119f, -0.02835022f, -0.05295845f, -0.04653300f, -0.03377242f, -0.01760864f, 0.03418955f, 
    -0.06312777f, 0.01202296f, -0.01108336f, -0.01713789f, -0.03449407f, -0.05721764f, -0.04276356f, -0.01614527f, 
    -0.00308893f, 0.03472816f, 0.02221662f, -0.01792593f, -0.00292994f, 0.04126497f, 0.00347415f, -0.00912020f, 
    0.05035830f, 0.04839012f, -0.05129258f, 0.04466554f, 0.04787318f, -0.00459238f, 0.04184917f, 0.00569394f, 
    -0.00124426f, 0.02562116f, -0.05629381f, 0.01574096f, 0.02502788f, 0.01672620f, -0.03579677f, -0.05630912f, 
    0.04991649f, -0.02267443f, -0.05629849f, 0.00987413f, -0.02704889f, -0.04518069f, -0.03536547f, -0.05240740f, 
    -0.04257615f, -0.00681658f, -0.03306799f, -0.01046597f, -0.03931041f, -0.04898816f, 0.00426565f, 0.02817020f, 
    -0.00453772f, 0.01651610f, -0.04446434f, -0.05726967f, -0.05511138f, -0.05264234f, 0.03067610f, -0.03851561f, 
    -0.01015082f, -0.00630569f, 0.00140490f, 0.02165985f, -0.00930683f, -0.04297704f, -0.00395742f, 0.00314393f, 
    -0.01902871f, 0.01948096f, -0.00597627f, 0.01957626f, 0.05077281f, 0.02507571f, 0.01701297f, -0.05661433f, 
    0.03260641f, -0.04670047f, 0.00564416f, 0.04913902f, -0.00046766f, -0.04235944f, -0.01618908f, -0.04622409f, 
    0.02362629f, 0.02022734f, 0.03857258f, 0.00295400f, 0.02398346f, 0.02514303f, -0.01186994f, 0.02729079f, 
    -0.05715557f, 0.04477494f, -0.00793825f, 0.00351206f, -0.04333115f, 0.02495876f, 0.03496249f, 0.01554594f, 
    -0.08556517f, 0.26808962f, -0.35006204f, 0.21838081f, 0.06884151f, -0.08654331f, 0.08548116f, -0.05666576f, 
    0.00155167f, -0.11774716f, -0.14989534f, -0.44800973f, -0.11935402f, 0.00942207f, -0.06149524f, -0.04500924f, 
    -0.06226590f, -0.02136200f, 0.24589829f, 0.07847615f, 0.09731809f, -0.34808910f, 0.00550182f, 0.24765606f, 
    -0.19696386f, 0.06337152f, 0.17750891f, -0.25659207f, -0.06261496f, 0.19761084f, -0.28217801f, 0.08062693f, 
    0.18720089f, 0.01058280f, -0.18605609f, 0.13107671f, -0.25420132f, 0.01714298f, -0.02383407f, -0.06946837f, 
    -0.02972657f, -0.27416232f, 0.17276599f, 0.04807473f, -0.15281299f, -0.22895846f, 0.04207449f, -0.63388985f, 
    -0.01831650f, -0.00938927f, 0.03369450f, 0.12483720f, -0.12264583f, -0.01271503f, 0.08004413f, 0.04960304f, 
    0.13186161f, 0.14436676f, 0.11330435f, -0.19239679f, 0.11280359f, 0.11035762f, 0.00341929f, -0.13288008f, 
    -0.28800952f, -0.00094560f, 0.21770531f, 0.17864320f, -0.00129740f, -0.07025099f, -0.12920848f, 0.10816846f, 
    -0.23798022f, -0.44410276f, -0.10275743f, 0.14723572f, -0.05261592f, 0.02222787f, 0.01888161f, -0.11304948f, 
    0.06636710f, -0.14463194f, 0.32270449f, 0.46302903f, 0.18720713f, 0.07228973f, -0.20658423f, -0.00292127f, 
    0.09805111f, 0.25335234f, -0.11071718f, -0.20535129f, -0.26546440f, 0.24969031f, -0.26658013f, 0.01844382f, 
    -0.16959488f, 0.16805819f, 0.05121303f, -0.16561504f, 0.07434671f, 0.16110650f, -0.05091913f, 0.18488668f, 
    0.03861886f, -0.04237588f, 0.08805805f, -0.03685550f, 0.22945538f, 0.30699968f, -0.32736060f, 0.00960448f, 
    -0.06631155f, -0.19030048f, 0.09686243f, -0.05367489f, -0.19732639f, -0.27347845f, -0.16004863f, 0.21579278f, 
    0.24219713f, -0.21623960f, 0.04250194f, 0.02381391f, 0.18565024f, -0.15503858f, 0.25136286f, -0.17326885f, 
    -0.20157121f, -0.07627276f, -0.08758678f, 0.02852042f, 0.16981748f, -0.18962705f, -0.25481549f, -0.02661463f, 
    0.12939738f, -0.10150859f, -0.12953886f, -0.11515532f, -0.03444667f, 0.07582571f, 0.11837795f, -0.07047268f, 
    -0.09247275f, -0.12332039f, 0.00495526f, -0.12600558f, -0.02104752f, 0.17994761f, -0.01695948f, 0.09201962f, 
    0.07494753f, 0.01841526f, -0.40004972f, -0.03068867f, 0.10749241f, -0.05125196f, 0.20206051f, 0.16061550f, 
    -0.03529660f, 0.00936983f, -0.37939960f, -0.14486979f, 0.17776220f, 0.29445213f, -0.12604472f, -0.14110519f, 
    0.18651232f, 0.14345685f, -0.19553472f, -0.05026988f, -0.01080926f, 0.08589900f, -0.14910032f, -0.10306378f, 
    0.02757321f, 0.37296203f, 0.12166267f, 0.08808661f, -0.59191805f, -0.14086878f, -0.13942710f, 0.04222519f, 
    0.11811711f, 0.02439045f, 0.19069871f, 0.11439782f, 0.32696989f, -0.30510604f, -0.18487559f, 0.28181729f, 
    -0.07934012f, 0.20051101f, 0.07781311f, -0.02990604f, -0.14958689f, 0.17494835f, 0.01192911f, 0.19835974f, 
    -0.18454075f, 0.00251152f, 0.04161236f, -0.05911441f, -0.02012822f, 0.06104134f, 0.33463225f, 0.26861677f, 
    0.13465834f, -0.13230389f, 0.07139514f, -0.07440015f, 0.07074442f, 0.20509487f, -0.15658295f, -0.13155311f, 
    0.06591179f, 0.13342385f, 0.15431978f, 0.08443046f, 0.00749949f, 0.08342113f, -0.18463697f, 0.04538692f, 
    0.09928020f, -0.50157499f, -0.22407131f, 0.14524186f, -0.10721008f, -0.09353334f, 0.01097364f, 0.06228569f, 
    -0.01104119f, 0.12371605f, -0.29593375f, 0.30632928f, -0.13004941f, -0.02360641f, -0.10945880f, 0.11645719f, 
    -0.11043929f, -0.10114744f, 0.15179855f, 0.00713869f, -0.16283679f, -0.05277894f, -0.15685001f, 0.05354823f, 
    -0.15506427f, 0.19270572f, 0.17668515f, -0.02722266f, -0.06577548f, -0.05504613f, 0.27603132f, -0.16037294f, 
    -0.03078755f, 0.16000810f, 0.01821416f, -0.05111032f, 0.24440683f, -0.06099300f, 0.01938176f, 0.00389358f, 
    0.17550196f, 0.04947584f, -0.05000788f, 0.00603040f, 0.04137650f, 0.40794063f, -0.00627939f, 0.18017399f, 
    0.06691042f, -0.31199217f, -0.02747913f, -0.05586549f, -0.25644150f, 0.18711601f, 0.03757658f, 0.04581684f, 
    -0.11025713f, 0.19726376f, -0.06569383f, 0.09369919f, 0.26538083f, -0.00385167f, -0.28792822f, 0.21384047f, 
    -0.05785704f, 0.03891446f, 0.05758455f, -0.02472672f, -0.00667319f, -0.06190422f, -0.04427134f, 0.04478340f, 
    -0.01060650f, -0.04605508f, 0.00084486f, 0.06485534f, -0.05423441f, -0.01889444f, -0.05405785f, -0.04284818f, 
    -0.03608004f, 0.04964851f, 0.04779402f, -0.04220539f, 0.02868504f, -0.04960819f, -0.02687231f, -0.01091895f, 
    -0.03614446f, -0.00064786f, -0.03037473f, -0.03483979f, 0.02392077f, -0.00164435f, -0.03990024f, 0.00520911f, 
    0.02737749f, 0.01914970f, 0.03801560f, -0.06434477f, -0.00488525f, 0.01140310f, 0.04483096f, 0.03013751f, 
    -0.03090815f, 0.04660494f, -0.03031879f, -0.03101204f, -0.02792894f, 0.05032132f, -0.00620092f, 0.02615955f, 
    -0.04623111f, -0.06337010f, 0.05018092f, -0.06647571f, -0.01500069f, 0.02762951f, 0.03586238f, 0.05672741f, 
    0.05104566f, -0.02709625f, -0.02170302f, -0.01021913f, -0.04817969f, -0.06125297f, 0.01123083f, -0.02493528f, 
    -0.04744842f, -0.03072660f, -0.04082710f, -0.05825501f, -0.02576020f, -0.03745843f, -0.06227795f, -0.04532582f, 
    0.06987090f, 0.04363657f, 0.00899349f, -0.00366460f, 0.04311650f, -0.01632733f, -0.06815671f, -0.00605188f, 
    0.00652484f, -0.00796475f, 0.00085716f, 0.05795322f, -0.01621069f, -0.06266010f, -0.02573899f, 0.04011606f, 
    -0.00407939f, -0.04059525f, 0.00306658f, -0.05643449f, 0.01361335f, -0.01640498f, -0.03828859f, -0.02198001f, 
    -0.03134390f, 0.00399390f, 0.03381364f, -0.01864297f, -0.00723846f, -0.04651082f, -0.00856131f, 0.00848262f, 
    -0.04458594f, 0.00092588f, -0.05617354f, -0.02622919f, -0.06247972f, 0.04716213f, 0.06028195f, 0.02634806f, 
    -0.00233550f, 0.00263525f, -0.06985632f, -0.02349923f, -0.04565886f, -0.02868633f, 0.01001164f, -0.02803341f, 
    0.00180750f, -0.00413899f, -0.00850336f, 0.02385766f, -0.06204906f, 0.04570707f, -0.01674028f, -0.00007946f, 
    0.01648676f, -0.03867085f, 0.00994875f, -0.04093426f, -0.02247079f, 0.02941190f, -0.04497358f, -0.06390499f, 
    0.01996078f, -0.03272913f, -0.02686069f, -0.05558327f, -0.06487216f, 0.03952945f, -0.02392199f, -0.01992206f, 
    0.01205952f, -0.02832183f, 0.01967279f, 0.03282020f, 0.00905054f, -0.00670463f, 0.03601802f, 0.00708380f, 
    0.01103481f, -0.04174663f, -0.01405477f, 0.01518205f, 0.02731508f, 0.04055670f, -0.03719213f, 0.03126710f, 
    -0.01051815f, 0.05265628f, 0.04725114f, -0.01311279f, 0.06251602f, 0.00694317f, -0.03247643f, -0.00814718f, 
    0.02203212f, -0.01266513f, -0.00801007f, 0.01130118f, 0.02193128f, 0.00668095f, -0.00086842f, 0.03559580f, 
    -0.00196820f, 0.02599546f, -0.00815419f, 0.03000238f, -0.02319603f, 0.05610419f, 0.03545273f, 0.02275883f, 
    0.04975970f, -0.05029619f, -0.03301562f, 0.04912422f, 0.04055393f, 0.03555309f, 0.03253281f, 0.04309546f, 
    0.01698798f, 0.00014308f, 0.02904394f, -0.05580672f, -0.00172063f, -0.06485051f, -0.02040728f, 0.03426025f, 
    -0.02296444f, 0.04412945f, -0.01866787f, 0.01285735f, 0.04917632f, 0.02986567f, -0.01513612f, -0.05119289f, 
    -0.05796649f, -0.03606389f, -0.05961399f, -0.03739458f, -0.03933489f, -0.03651380f, -0.01849355f, -0.03779746f, 
    -0.04207648f, -0.03535306f, -0.01985685f, -0.05935355f, -0.03447835f, -0.04250610f, 0.03995174f, -0.05474644f, 
    -0.01694488f, -0.00717300f, -0.02676646f, 0.03587395f, 0.03633671f, 0.04438353f, 0.03085423f, -0.01562300f, 
    -0.02375982f, 0.00654763f, -0.04666469f, -0.04448435f, -0.02152988f, 0.02661931f, 0.02625467f, -0.05290950f, 
    -0.06043194f, -0.05396272f, 0.01397558f, -0.03357456f, -0.02389425f, 0.05054783f, -0.04571780f, -0.06838901f, 
    -0.01919302f, -0.01906704f, -0.05865759f, 0.00412768f, 0.00427973f, -0.04949268f, -0.02426944f, -0.00908164f, 
    -0.00907617f, -0.04513438f, 0.02944776f, -0.00000709f, 0.01033264f, -0.04822634f, -0.05748885f, -0.02884379f, 
    -0.06324214f, 0.01340438f, 0.03978810f, 0.01876383f, -0.03841839f, -0.05654411f, -0.05066773f, -0.03633927f, 
    -0.03901399f, 0.04000656f, 0.02524366f, -0.05829019f, -0.02996866f, -0.06303935f, -0.06828769f, -0.00051002f, 
    -0.06252717f, -0.05396467f, 0.02156544f, 0.02763835f, -0.03738486f, -0.05522138f, -0.00483856f, 0.03539799f, 
    0.34392676f, -0.06025959f, -0.11895637f, -0.15999340f, -0.24538919f, -0.00634220f, 0.12752911f, -0.11039677f, 
    -0.00055384f, 0.06736705f, -0.02654050f, -0.02024738f, -0.15798448f, -0.20359558f, 0.04677257f, -0.15853174f, 
    0.02150065f, -0.00356423f, 0.02029184f, 0.42033029f, 0.14910024f, 0.41599646f, 0.14141341f, -0.27834550f, 
    -0.17885341f, 0.11296647f, -0.02999529f, 0.12626953f, -0.20549236f, -0.20456652f, 0.00488349f, -0.17205413f, 
    -0.14475976f, -0.20664722f, 0.22404374f, -0.02771572f, -0.10089425f, 0.25352108f, -0.11739893f, -0.13634454f, 
    0.00265725f, 0.20273703f, -0.37993774f, 0.04140833f, 0.14794046f, -0.04030575f, 0.31788951f, -0.13341883f, 
    0.00993967f, -0.07863239f, 0.04047096f, 0.05924540f, -0.03448322f, -0.04563490f, -0.18202944f, 0.12224213f, 
    -0.06101621f, 0.14053372f, 0.29132107f, -0.13041830f, 0.10325775f, 0.16244359f, -0.02090644f, -0.25365219f, 
    0.06959854f, 0.03176247f, -0.03579840f, 0.04263710f, 0.13523929f, 0.02467238f, -0.00354849f, 0.04327223f, 
    0.26740882f, -0.30294845f, -0.23646219f, -0.04456406f, -0.07467667f, 0.08864471f, -0.00643580f, 0.03753759f, 
    0.13908127f, 0.67132092f, -0.26170170f, -0.15504758f, -0.11293611f, -0.12940983f, 0.16751295f, -0.24628812f, 
    0.09478346f, 0.12388872f, 0.44908825f, -0.10355307f, 0.03416969f, -0.12671474f, -0.08013050f, 0.09995157f, 
    0.04264014f, 0.22785714f, -0.05261808f, -0.46095699f, 0.22868550f, 0.25148389f, -0.01278816f, 0.20616621f, 
    0.09904026f, -0.25120339f, 0.16123320f, 0.07423829f, 0.04782940f, -0.17436071f, -0.02034291f, -0.28004935f, 
    -0.15795574f, -0.08019845f, 0.16514024f, -0.13905302f, 0.07138512f, 0.46262911f, 0.19844343f, -0.09866217f, 
    -0.00024163f, -0.08493946f, 0.03817512f, -0.05358377f, -0.16899765f, -0.03449460f, 0.15041588f, -0.08767765f, 
    0.07121334f, 0.06456716f, -0.25477678f, -0.18881072f, -0.14217880f, -0.09628440f, -0.10238886f, -0.51216930f, 
    0.29608420f, -0.06615867f, -0.13427755f, 0.12016001f, 0.31572360f, 0.03221576f, -0.06518393f, 0.15959775f, 
    0.20852381f, -0.10786866f, 0.12095537f, 0.04688989f, 0.09419283f, -0.23825860f, -0.16163063f, 0.25323161f, 
    0.03926421f, 0.17129746f, -0.07833271f, -0.04489810f, -0.07764792f, 0.20064200f, -0.07677083f, 0.04251068f, 
    0.02173939f, -0.01625301f, -0.45822263f, 0.09245285f, -0.21167073f, -0.00580782f, -0.03140241f, -0.13282289f, 
    -0.13062087f, -0.15727302f, 0.13555899f, -0.51310325f, 0.38569024f, 0.23799022f, 0.05740838f, 0.07026139f, 
    -0.11289361f, -0.01640763f, 0.03904100f, 0.05266646f, -0.04184645f, -0.03888015f, -0.01259633f, -0.02488347f, 
    0.28722996f, -0.14488114f, 0.03695818f, -0.14667796f, -0.05002039f, 0.49364486f, 0.12784627f, -0.06137592f, 
    0.09721293f, 0.15700176f, 0.01578798f, -0.04088077f, -0.13479404f, -0.15404229f, -0.29874456f, 0.31091642f, 
    -0.01432274f, 0.10790779f, 0.13137414f, 0.19186103f, -0.23794264f, -0.11763003f, -0.14174600f, 0.14137077f, 
    -0.15180402f, -0.04881475f, -0.05951325f, -0.18315391f, 0.15815286f, -0.30775815f, 0.01362319f, 0.11989284f, 
    -0.15517639f, 0.01007170f, 0.09662441f, 0.06095525f, 0.02196220f, -0.08907954f, 0.06455133f, 0.05024846f, 
    -0.00478688f, 0.07808139f, 0.05710980f, 0.00828884f, -0.15292764f, 0.26686642f, -0.20776775f, 0.00034008f, 
    -0.01600659f, 0.01525637f, -0.27410319f, 0.18614976f, -0.31105384f, 0.09765831f, -0.09926801f, 0.08156040f, 
    -0.01052601f, 0.14318810f, -0.12767258f, 0.01959831f, -0.32736522f, -0.01553767f, -0.13252997f, -0.51192451f, 
    0.08171868f, -0.02364857f, 0.05577776f, 0.20248443f, 0.41400206f, 0.20343281f, 0.07175932f, -0.01568685f, 
    -0.01871960f, -0.12413975f, -0.11982130f, -0.03296820f, 0.01749094f, 0.32770750f, -0.24784335f, 0.07200030f, 
    -0.28528211f, 0.04209036f, -0.07033662f, 0.20606792f, 0.15266150f, -0.23490621f, -0.30249888f, 0.47206944f, 
    0.05409786f, 0.11721153f, 0.14083599f, 0.07143039f, 0.04117672f, 0.16294873f, 0.11026460f, -0.38083470f, 
    0.54545206f, 0.07391554f, 0.12958443f, 0.01472942f, 0.13655537f, 0.03810428f, -0.11990137f, 0.05189740f, 
    -0.05122433f, -0.00872686f, -0.06601532f, -0.00769980f, -0.03694698f, 0.00907774f, 0.01795265f, -0.04484097f, 
    -0.03277426f, -0.02791402f, -0.01251180f, -0.06333696f, -0.01601201f, -0.01129504f, -0.05428340f, -0.04628235f, 
    -0.05530611f, -0.02026902f, 0.01213828f, 0.00158295f, 0.01702029f, -0.00215156f, -0.03287449f, 0.03449808f, 
    -0.00908504f, 0.01535069f, 0.03354771f, 0.02839416f, -0.06312119f, -0.02975978f, 0.04249578f, -0.04931902f, 
    0.01891243f, -0.00262873f, -0.06309736f, 0.02507786f, -0.02719072f, 0.03530540f, -0.03623116f, -0.00337096f, 
    -0.01203713f, 0.04543039f, 0.05911903f, -0.04872474f, 0.02237188f, -0.05181497f, -0.05533330f, -0.02426101f, 
    0.00986512f, -0.01385753f, -0.02792825f, -0.00671690f, 0.01373095f, -0.00454936f, -0.02897520f, 0.04093558f, 
    0.00461816f, 0.02962565f, 0.02230226f, -0.04994174f, 0.04658229f, -0.02837103f, 0.02334490f, -0.02967593f, 
    -0.01009354f, -0.02373935f, 0.00687308f, -0.04150617f, -0.01180169f, -0.01575148f, 0.01755077f, 0.04891188f, 
    -0.06080337f, -0.00835364f, -0.04900973f, -0.03570862f, 0.00097338f, -0.03978425f, -0.03376171f, -0.03152051f, 
    0.03508786f, -0.04124355f, 0.03215617f, -0.03937259f, 0.00038520f, -0.00893481f, -0.04379260f, -0.02908844f, 
    -0.05761655f, 0.01037088f, 0.00648143f, 0.00082818f, 0.04387751f, -0.06308483f, -0.03877973f, -0.04526882f, 
    -0.00731361f, -0.02999341f, -0.03544195f, 0.03252205f, 0.00921318f, 0.03636541f, -0.05592882f, 0.02640411f, 
    -0.07040997f, 0.01694329f, 0.03787803f, 0.02368109f, -0.06922431f, 0.00990985f, -0.04034057f, 0.01435762f, 
    0.01350199f, -0.02350891f, -0.02550527f, -0.05109516f, 0.02654618f, -0.03244350f, -0.01488444f, -0.03902998f, 
    -0.03663627f, -0.01143149f, 0.03668916f, -0.00775769f, 0.04609421f, 0.04031589f, -0.06865271f, 0.00197075f, 
    0.01736529f, 0.01127236f, 0.04560107f, -0.01764776f, 0.02293061f, 0.00429339f, -0.03342453f, 0.03096698f, 
    -0.04748284f, -0.05572385f, 0.04760438f, 0.01205051f, -0.03969265f, 0.02634514f, 0.04461966f, -0.04607630f, 
    0.04666628f, -0.04331746f, -0.05401720f, 0.00815106f, 0.04557986f, -0.04997012f, -0.06355660f, -0.00829506f, 
    0.02482169f, 0.00686396f, 0.02675650f, 0.00020925f, -0.02110268f, 0.00354934f, 0.03883325f, -0.06226232f, 
    0.03130234f, -0.00743591f, -0.04611877f, 0.00679866f, 0.02018170f, 0.01159995f, -0.00238412f, -0.02761312f, 
    -0.03534902f, -0.00664801f, -0.05069926f, 0.00552404f, 0.00645541f, 0.01020339f, -0.04965959f, -0.06023966f, 
    -0.06810278f, -0.04221380f, -0.05947749f, 0.03307396f, -0.00543919f, -0.04775556f, 0.02499684f, -0.03768217f, 
    -0.00589168f, 0.05163198f, 0.01874498f, 0.04967625f, 0.01198087f, -0.06207908f, 0.00665852f, -0.04290644f, 
    -0.03102619f, -0.05938667f, -0.02324708f, -0.05756941f, -0.01549732f, 0.03800949f, -0.05894544f, -0.02934843f, 
    -0.02619155f, 0.01237050f, 0.00098612f, 0.02911268f, 0.02919850f, 0.03935473f, -0.00659920f, 0.02911888f, 
    -0.03038823f, 0.00140485f, -0.00241679f, -0.01886332f, -0.01511097f, -0.02153366f, -0.04131432f, -0.05773472f, 
    -0.04049392f, -0.01208154f, 0.00469738f, 0.04743272f, -0.04636205f, 0.04340146f, 0.03553662f, -0.02785630f, 
    -0.01891985f, 0.01054377f, 0.04308383f, -0.01817954f, 0.03470074f, -0.00770703f, 0.01675218f, 0.03468018f, 
    0.01793881f, -0.05341064f, -0.01026365f, -0.04440246f, -0.03131372f, 0.04825918f, -0.04116806f, 0.01148008f, 
    0.02931947f, 0.01605445f, 0.02943297f, -0.01655406f, -0.03173447f, 0.02286118f, -0.04110559f, 0.01096390f, 
    0.01180146f, -0.02039872f, -0.02694391f, -0.00334534f, -0.06695909f, -0.02187920f, -0.06573492f, 0.03847199f, 
    -0.04404766f, 0.04910969f, -0.04833693f, 0.01702604f, 0.02360621f, 0.02610259f, -0.02763332f, 0.02452997f, 
    -0.01575112f, 0.02926698f, 0.00934267f, -0.05755363f, -0.00230675f, -0.02102879f, 0.02924772f, -0.03210713f, 
    0.00674504f, -0.01396035f, -0.01600925f, -0.00598184f, -0.01652608f, 0.01374944f, 0.00885792f, 0.01387670f, 
    0.02522917f, 0.05143920f, -0.05277337f, -0.01545975f, -0.03330541f, -0.06715818f, 0.02424289f, -0.01872262f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.06620398f, 0.04158636f, 0.03612251f, 0.02706464f, 0.16168681f, 0.01796252f, -0.05406700f, 0.02048152f, 
    0.10738494f, -0.14363171f, -0.09473626f, 0.03780130f, -0.15960608f, -0.00640339f, 0.12440045f, 0.28362107f, 
    0.04310443f, -0.03161488f, 0.12750293f, 0.07567079f, -0.00807585f, 0.06520364f, 0.05950965f, 0.08350117f, 
    -0.01105621f, -0.05233278f, 0.03728035f, -0.02130605f, 0.21445329f, -0.04134657f, -0.08243029f, -0.01457108f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.59285736f, 0.59108460f, 0.13103358f, -0.06044354f, -0.57346469f, -0.00185632f, -0.09988000f, -0.01239641f, 
    0.24842218f, -0.20055859f, -0.16486301f, 0.13367644f, -0.59059495f, -0.10693835f, -0.17791028f, -0.01057061f, 
    0.04818166f, 0.07119298f, -0.01349764f, -0.11663975f, 0.94906050f, -0.45561084f, -0.40093878f, 0.24119690f, 
    0.15262109f, 0.01314546f, 0.00806733f, -0.06847326f, 0.41602346f, 0.08954619f, -0.20434499f, 0.04543727f, 
    -0.29637027f, -0.35865799f, 0.12219533f, 0.40030521f, -0.42426336f, 0.02255074f, 0.00567005f, -0.15834711f, 
    -0.22926408f, -0.30724838f, 0.06191187f, -0.05874945f, 0.46518472f, -0.14609291f, -0.02256430f, 0.49317342f, 
    0.06031919f, -0.12356136f, -0.78064209f, -0.49617726f, 0.43379846f, 0.54276043f, -0.23730144f, 0.31434327f, 
    -0.00033964f, 0.13468486f, -0.03584049f, 0.10862944f, 0.23990436f, -0.04776789f, -0.70675564f, 0.11045650f, 
    -0.26432246f, -0.13996525f, 0.04528172f, -0.21787971f, 0.21380888f, -0.15429179f, 0.10470949f, -0.00660035f, 
    0.16879997f, 0.52836818f, -0.41150647f, 0.03608933f, -0.78797585f, -0.08482639f, 0.10417388f, -0.21169600f, 
    -0.13371788f, 0.04384354f, -0.39024326f, -0.14972784f, 0.24406084f, 0.65698236f, -0.42094570f, -0.70302361f, 
    -0.13220285f, 0.12553801f, 0.04182926f, -0.16282381f, -0.72221893f, -0.15743513f, 0.85632992f, 0.09952696f, 
    -0.42751893f, -0.49905819f, -0.12263370f, 0.48308170f, -0.71407187f, 0.14716354f, 0.07502559f, 0.02119787f, 
    0.39798173f, -0.24702835f, 1.07551479f, -0.10198021f, -0.20332587f, 0.09550895f, -0.10694134f, -0.16272053f, 
    -0.04393300f, 0.08753236f, -0.00277638f, 0.24226397f, -0.50108284f, -0.19499071f, 0.11580300f, -0.11436694f, 
    0.15866728f, 0.09023543f, 0.12400575f, 0.14134151f, -0.38650292f, 0.09177613f, 0.08204306f, -0.14983024f, 
    -0.41283333f, 0.41029599f, -0.05355566f, -0.05535873f, 0.09408167f, -0.04626325f, 0.02280631f, -0.17153741f, 
    0.51736218f, 0.16233848f, -0.11244942f, -0.11105714f, -0.17836107f, -0.12721169f, -0.35774797f, -0.08500727f, 
    -0.15147856f, 0.14998472f, 0.43165806f, -0.63705444f, -0.73469353f, -0.12121116f, 0.05092478f, 0.34260115f, 
    -0.08610067f, 0.11845443f, 0.13972768f, -0.14078498f, -0.23753725f, -0.08141129f, 0.15003504f, 0.08166668f, 
    0.29079157f, 0.32593250f, -0.09800135f, -0.48896682f, 0.42124143f, 0.07762984f, 0.09751673f, 0.14213696f, 
    -0.56210107f, -1.12632835f, -0.12429754f, 0.00754669f, 0.64216512f, -0.16232838f, 0.04198373f, 0.03139133f, 
    -0.01425393f, 0.10176288f, -0.13794363f, 0.35799599f, -0.33634818f, 0.05650822f, -0.32847813f, 0.23364669f, 
    -0.02603465f, -0.12497126f, -0.15564847f, -0.12466434f, 0.78413755f, 0.01074069f, -0.12947634f, -0.04184023f, 
    -0.24286203f, -0.29409024f, 0.05796800f, 0.04764877f, 0.26565963f, -0.11953636f, -0.12351112f, 0.01345170f, 
    -0.03404088f, -0.19099392f, -0.32468143f, 0.08932562f, -1.43320215f, 0.11471239f, -0.44568136f, 0.55421895f, 
    0.12513216f, -0.04800004f, 0.18264334f, -0.12010986f, 0.12922721f, -0.60550249f, -0.58630890f, -0.09543034f, 
    -0.17679048f, 0.07605898f, -0.11975748f, 0.08333506f, -0.09223796f, 0.04005874f, 0.59274268f, 0.07785594f, 
    -0.04491469f, 0.07360353f, 0.14299536f, -0.20567639f, -0.00443526f, -0.00764690f, -0.09744346f, 0.06092327f, 
    0.18044738f, 1.08290374f, 0.09711282f, -0.03645383f, 0.54255390f, 0.17174858f, -0.74360168f, -0.52307624f, 
    0.00810630f, 0.14961728f, -0.11023171f, 0.21630450f, -0.33124554f, -0.15641488f, -0.15704033f, 0.21234843f, 
    -0.11294904f, 0.14925133f, -0.00319283f, -0.04962225f, 0.01760003f, 0.14898528f, -0.27304900f, 0.10578450f, 
    0.23106195f, -0.42244682f, 0.16402730f, -0.49765542f, -0.03741009f, -0.02157232f, -0.07997197f, 0.06410249f, 
    -0.46116707f, 0.78456897f, -0.07881206f, -0.11413392f, -0.06647815f, -0.12883943f, 0.45146331f, -0.22663242f, 
    -0.08786474f, -0.01577950f, -0.50572145f, -0.12364087f, 0.29313406f, 0.03595984f, 0.86227614f, 0.04359929f, 
    0.05644361f, -0.03538385f, -0.11243157f, -0.14526185f, -0.01932083f, 0.06168700f, -0.34584227f, -0.04366499f, 
    0.21456686f, 0.12730284f, -0.09008634f, -0.39286301f, 0.53218889f, -0.14970347f, 0.08091735f, -0.03810336f, 
    0.39230996f, 0.03524598f, -0.40220758f, -0.16184616f, 0.11049386f, 0.01034553f, 1.08921015f, -0.06622572f, 
    -0.00932007f, 0.03779635f, 0.07782883f, 0.28732291f, -0.32792544f, -0.00743273f, -0.53629136f, -0.64680815f, 
    0.13005795f, 0.15276316f, -0.12591490f, 0.00112952f, -0.18956421f, -0.06517643f, -0.17118412f, -0.09321456f, 
    0.05131438f, 0.38443780f, 0.09308659f, 0.52090824f, -0.68016553f, -0.15550295f, 0.13263376f, 0.04189248f, 
    -0.38140342f, -0.31792441f, -0.70001477f, -0.13408166f, -0.46109220f, -0.01003491f, -0.14517298f, -0.36038506f, 
    -0.12163053f, 0.16550888f, -0.02224291f, 0.91435933f, -0.64662719f, 0.17778791f, 0.51998246f, -0.34633607f, 
    0.03886749f, 0.00558898f, 0.17565419f, -0.05818945f, 0.00267254f, -0.18414213f, 0.12459366f, 0.11770146f, 
    1.06110203f, -0.75149775f, 0.10120104f, 0.18952601f, -0.50904280f, 0.02914927f, -0.02459158f, 0.00309314f, 
    0.09412598f, -0.67429346f, 0.15349260f, -0.04731122f, -0.40344980f, -0.10113710f, -0.26903683f, 0.10679234f, 
    -0.13779092f, 0.03310646f, 0.52149051f, -0.50409901f, -0.00387443f, -0.24697798f, 0.13462049f, -0.32524958f, 
    -0.02570433f, 0.08751860f, -0.14870495f, 0.08195680f, -0.67607224f, -0.01861642f, 0.01818069f, -0.15623277f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.14355944f, -0.00100609f, -0.00951771f, 0.09035451f, 0.26785332f, 0.39735079f, 0.15542221f, -0.54405147f, 
    -0.05757349f, 0.00890615f, 0.01974425f, -0.19938423f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
