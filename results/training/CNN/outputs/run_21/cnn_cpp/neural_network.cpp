#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.87816966f, 0.55766892f, -0.48048007f, -0.63254744f, -1.32037044f, 1.41683841f, 0.33018804f, -0.71530849f, 
    0.10787978f, 0.14993347f, -0.27297840f, -0.44926047f, 0.04318020f, 0.22946283f, -0.16537964f, -0.36104929f, 
    -0.10044053f, 0.09233621f, -0.04698648f, -0.42110521f, -0.00320978f, -0.07736970f, 0.05609975f, 0.30041748f, 
    -0.00604253f, 1.23858345f, 1.00350404f, 1.64285672f, 1.15575528f, 0.22514631f, -1.21990359f, 0.61794508f, 
    -0.92021936f, -0.33739513f, 0.43829915f, 0.30057940f, 0.01808102f, -0.30194494f, 0.33962768f, -0.20850874f, 
    -0.33378515f, -0.22628036f, 0.10347803f, 0.22684468f, -0.07659249f, -0.03754500f, 0.39317089f, 0.19229732f, 
    0.04842090f, 0.17258435f, -1.06351042f, -0.92325449f, -0.19545205f, -0.46358424f, -0.80685300f, 0.01922064f, 
    -1.17651117f, 0.29621363f, -0.45717919f, -0.79549539f, -0.48260343f, 0.18115598f, -0.50174147f, -0.46442190f, 
    -0.45913935f, -0.33167580f, 0.51189899f, -0.55538601f, 0.04946553f, -0.53964823f, 0.27907741f, 0.31128454f, 
    0.34050626f, 0.05818557f, -0.18693346f, 0.00126790f, -1.35969627f, -1.00743437f, -0.51880282f, -0.56610042f, 
    -0.24590756f, 1.51287448f, 1.20326412f, 0.62428242f, 0.68660140f, -0.38978961f, -0.15680340f, -0.43944100f, 
    -0.25932443f, -0.36996901f, -0.25417775f, 0.21887267f, 0.00295423f, 0.20538320f, -0.25214422f, -0.25391626f, 
    -0.18398908f, 0.05091545f, -0.14638074f, 0.01985786f, 1.10552180f, -0.36332029f, -0.98939174f, -0.96653467f, 
    -0.78591555f, -0.27542025f, 0.73294687f, -0.24214649f, -0.69081759f, 0.81361037f, 0.56091690f, -0.47982708f, 
    0.06816778f, -0.30942288f, 0.32986256f, -0.18305694f, 0.11492910f, -0.05986179f, 0.00577875f, 0.23762204f, 
    0.03196662f, 0.02059944f, -0.15741755f, 0.12348694f, -0.12392025f, -0.12679830f, -0.12510608f, 1.15706313f, 
    1.17537344f, 0.66728586f, 0.84962463f, 1.22908616f, 1.11805034f, 0.34808868f, 0.64945471f, 0.24936858f, 
    0.16382974f, 0.40496746f, 0.32800946f, -0.49587712f, 0.01532642f, -0.24035430f, -0.16325004f, -0.34663615f, 
    -0.26994890f, 0.24969058f, 0.12822951f, -0.09516597f, 0.03723586f, -0.35858899f, 0.35694650f, -0.57370919f, 
    0.34588224f, 0.98975623f, 1.13786042f, -0.43203786f, 0.04326925f, -1.09413040f, -1.51938736f, 0.14598185f, 
    0.33394596f, 0.75744885f, 0.44059697f, 0.34380940f, 0.06954721f, 0.14722595f, 0.37812814f, 0.23566344f, 
    -0.25605661f, -0.07735233f, -0.17423360f, -0.09653017f, -0.44629586f, -0.00129735f, -0.12427446f, 1.15354621f, 
    1.19135118f, 0.62570268f, -0.66989768f, 0.28442684f, 0.59774226f, -1.10297072f, -0.13957745f, -0.67958808f, 
    -0.04265164f, 0.32550824f, 0.01125032f, 0.36729696f, 0.20206967f, -0.78562117f, -0.37501705f, -0.24528176f, 
    0.39729747f, -0.13252679f, -0.45857799f, -0.26759616f, -0.02412855f, -0.00590319f, -0.42651513f, 0.16038719f, 
    1.09196198f, -1.39795029f, -1.13942897f, 1.17010033f, 0.37568051f, -0.07883869f, 1.06369925f, -0.36576450f, 
    0.50959742f, 0.16474853f, 0.23002160f, 0.51714551f, -0.21554664f, 0.48576561f, 0.39030278f, -0.11848957f, 
    -0.24502517f, 0.00410871f, -0.31244996f, -0.12186171f, 0.13550943f, 0.24022500f, 0.41012418f, 0.38380563f, 
    0.42107084f, 1.85929203f, 0.45675337f, 0.76649934f, 0.63428944f, 0.49733609f, 1.42082214f, -0.42066360f, 
    -0.40061197f, 0.69449770f, -0.10003165f, -0.84817100f, 0.35674363f, -0.43650430f, 0.32906398f, -0.23922135f, 
    0.44897389f, 0.38160217f, 0.05081159f, -0.20674841f, 0.14641616f, 0.23737893f, 0.21572509f, 0.37016669f, 
    -0.09884988f, 0.22783086f, -0.68751621f, -0.03917228f, -0.27810898f, -0.51400858f, 0.73665851f, -1.09525383f, 
    -0.83577758f, 0.09533895f, -0.50302595f, -1.29564679f, -0.06554297f, 0.26838320f, 0.11538093f, 0.25341380f, 
    -0.39257133f, 0.37483585f, 0.15057157f, 0.45643991f, 0.50912428f, 0.58593822f, 0.26920477f, -0.17770889f, 
    -0.01260467f, 0.59476322f, 0.15392573f, 0.13223293f, 1.28664684f, -0.74725878f, -1.05901098f, -1.33324730f, 
    0.20191504f, -0.45507804f, -0.15012088f, -0.00335332f, -0.28465351f, 0.41803345f, 0.44752324f, 0.55220330f, 
    0.49424663f, 0.00308298f, 0.43902823f, 0.04144220f, 0.19302489f, 0.41676906f, 0.46116900f, 0.09064993f, 
    0.16505733f, 0.15066138f, -0.14276740f, 0.48550740f, -1.18026471f, -1.47196269f, -1.35016227f, -0.41898417f, 
    -0.39052582f, -0.83652484f, -0.18989095f, 0.15204744f, -0.02480926f, 0.78986353f, 0.19897142f, 0.32590818f, 
    0.16329858f, -0.08091596f, -0.03766674f, 0.01976364f, 0.30800673f, 0.54482144f, -0.18598118f, 0.05737993f, 
    -0.00891458f, -0.02400155f, -0.09197620f, 0.19660808f, 0.25631759f, -0.28846225f, 0.64382631f, -0.99935842f, 
    -1.15784979f, -0.71187514f, 0.40977451f, -0.33615500f, 0.27782926f, 0.55979365f, -0.25669390f, -0.13734449f, 
    -0.54589611f, -0.99592954f, -0.72200739f, 0.26329216f, 0.28745624f, 0.26618621f, -0.17285876f, 0.01840563f, 
    0.17494875f, -0.13360709f, -0.50041789f, 0.55145782f, 0.18215801f, 0.22325346f, 0.15924799f, -1.06978357f, 
    0.40304431f, 1.07300436f, -0.57076681f, -1.39493370f, -0.24822260f, 0.79594487f, -0.20652108f, -0.15715328f, 
    -0.59787053f, 0.29122832f, 0.39682603f, -0.26156363f, 0.15493742f, -0.72538465f, 0.00346233f, 0.38932699f, 
    0.23304980f, -0.64313781f, 0.30040622f, 0.22875448f, -0.44081092f, 0.07407767f, -0.23683049f, 1.70013809f, 
    0.66189247f, -1.60473883f, 0.88363856f, 0.84397429f, 0.12190637f, 0.36838832f, 0.74506885f, 0.77146101f, 
    0.46553043f, -0.21843435f, -0.32245997f, 0.13657856f, -0.11556634f, 0.13298877f, -0.03515764f, -0.19199742f, 
    -0.01655499f, -0.23863418f, 0.10369430f, -0.17074658f, -0.10691819f, 0.10931908f, 0.13018671f, -0.17443216f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00239859f, 0.06083844f, 0.53395694f, 0.20244381f, 0.31475025f, 0.40610185f, 0.22313783f, 0.25143957f, 
    0.57250410f, 0.41331640f, 0.48896840f, 0.46993372f, 0.46483070f, 0.17945352f, 0.39073649f, 0.37397572f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.87670726f, -0.06851663f, -0.06115436f, -0.31751001f, -0.00980547f, 0.10042542f, -0.03144990f, 0.20815101f, 
    -0.04829323f, 0.10291699f, -0.05024962f, 0.09914092f, 0.39432156f, 0.10435908f, -0.14014705f, 0.46961212f, 
    -0.29398072f, -0.23887525f, -0.09239314f, 0.11576888f, -0.12037271f, 0.07803992f, -0.28289500f, -0.08975184f, 
    -0.71247500f, -0.15419507f, -0.13124710f, 0.23562041f, -0.04802690f, -0.02247508f, 0.14166510f, -0.06813327f, 
    -0.30985409f, -0.03822014f, 0.02336429f, -0.26396698f, -0.07182838f, 0.46245098f, -0.01173550f, -0.52021855f, 
    0.15213636f, 0.13074657f, 0.01322247f, 0.05880905f, 0.02890433f, 0.03742727f, -0.02980878f, 0.16286191f, 
    -0.74224818f, -0.27090153f, 0.38742369f, -0.24630921f, 0.06867718f, -0.08900739f, 0.06112021f, -0.17587540f, 
    -0.09939441f, -0.17303732f, 0.18173932f, 0.08061437f, -0.57510048f, 0.26834747f, -0.00930810f, 0.23252860f, 
    -0.19734280f, 0.28436306f, 0.14728059f, -0.20331390f, -0.01047136f, -0.18617187f, -0.03740956f, -0.10239214f, 
    0.25985670f, -0.38481680f, -0.08596665f, 0.14898492f, -0.21369991f, -0.19646747f, 0.12647888f, -0.02990973f, 
    -0.07786123f, -0.02358568f, 0.01150414f, -0.04540682f, 0.00478199f, 0.21260285f, 0.43234131f, -0.84481543f, 
    -0.35850424f, -0.15173203f, 0.04619968f, -0.05388858f, 0.11737907f, 0.09900451f, -0.14326635f, -0.08889997f, 
    -0.05369090f, 0.06750213f, -0.07468292f, 0.33618268f, -0.13077211f, -0.04175142f, -0.09484529f, -0.23218121f, 
    -0.10638783f, 0.18181814f, -0.02539556f, -0.19732101f, 0.54337162f, -0.42672649f, -0.05365923f, 0.10977330f, 
    -0.00261962f, -0.26495761f, 0.00755163f, 0.12188451f, -0.03388103f, 0.04805105f, 0.00014363f, -0.06859981f, 
    -0.39737734f, -0.01892365f, 0.03442394f, 0.07290115f, -0.11354943f, 0.13133104f, -0.12246002f, 0.22432832f, 
    0.17002016f, -0.02516813f, 0.20900187f, -0.12159202f, -0.25159687f, -0.00953389f, 0.25340542f, -0.21415699f, 
    -0.04181351f, 0.06497971f, 0.20157114f, 0.03692157f, -0.05395646f, -0.09839324f, -0.04690200f, -0.01793227f, 
    -0.15947549f, 0.04727049f, -0.46319738f, -0.22663671f, 0.05946722f, 0.06309450f, 0.01521407f, 0.21597841f, 
    -0.18466714f, -0.01260100f, -0.03727224f, -0.00499636f, 0.42055309f, 0.22970170f, 0.08689646f, -0.68510473f, 
    -0.04317575f, 0.01798292f, 0.20017725f, -0.04631193f, -0.30877161f, 0.04149031f, -0.00592796f, -0.09405274f, 
    -0.03039694f, -0.20816679f, -0.15921220f, 0.50573683f, -0.03749222f, -0.04372693f, 0.01079692f, -0.12793456f, 
    0.01532604f, -0.13656026f, -0.00640006f, 0.01197767f, 0.08281506f, 0.21765868f, 0.19384742f, 0.38149676f, 
    -0.33678094f, 0.19365130f, -0.23365209f, 0.25631481f, -0.11365796f, 0.13093247f, -0.02114370f, 0.00882529f, 
    -0.80842859f, -0.33777803f, 0.05388575f, -0.16357397f, 0.10079009f, -0.10559124f, 0.03768056f, 0.01382408f, 
    -0.07305665f, -0.08169971f, -0.03560699f, -0.24913824f, 0.42848855f, -0.02451147f, -0.00532153f, 0.39740580f, 
    -0.19782607f, 0.00877288f, 0.14611243f, 0.01619637f, 0.08431904f, -0.13821372f, 0.08360181f, -0.07047506f, 
    -0.07634260f, 0.06006311f, 0.13009882f, 0.20019332f, 0.17024364f, -0.27169213f, 0.07872952f, -0.12967253f, 
    0.22253124f, -0.01011099f, -0.18750829f, -0.18780102f, 0.27781883f, -0.47989431f, 0.03740365f, -0.16800435f, 
    0.09692232f, -0.06820702f, -0.04765607f, 0.05783447f, 0.19939958f, -0.04894133f, 0.05884989f, -0.09246077f, 
    0.64197904f, -0.34194735f, -0.24395424f, -0.21660063f, -0.12192199f, -0.07275645f, 0.14060105f, 0.17519017f, 
    -0.05958829f, -0.00663868f, -0.13220747f, -0.12904344f, 0.23210995f, 0.24514353f, 0.10250304f, 0.22563863f, 
    0.09472223f, 0.11647750f, -0.02596622f, 0.14891087f, -0.05502118f, 0.03459284f, 0.07900642f, -0.17427216f, 
    -0.06899013f, -0.03595044f, -0.20650284f, 0.05048162f, -0.19000387f, 0.02428642f, -0.13489808f, 0.12497135f, 
    0.10889864f, -0.29199022f, 0.16226456f, -0.04806661f, 0.32179692f, 0.09965442f, -0.06317544f, 0.02341120f, 
    -0.11617539f, -0.08844526f, 0.08033724f, -0.01032063f, -0.08328494f, -0.29652551f, 0.02975725f, 0.00182679f, 
    0.59277111f, -0.74961984f, -0.01858385f, 0.05517829f, -0.04807314f, 0.22110818f, -0.09886126f, 0.16270699f, 
    0.05095887f, -0.17137986f, -0.12779123f, 0.25381058f, 0.49500281f, -0.06177967f, 0.17348966f, 0.11968474f, 
    -0.29455209f, -0.07395967f, -0.07691947f, 0.06685147f, -0.06519634f, -0.12984152f, 0.12160695f, -0.03369576f, 
    0.15390988f, -0.18494804f, 0.01413050f, -0.65296841f, 0.03179678f, 0.15938860f, 0.01981607f, 0.00100547f, 
    -0.08660481f, 0.41198280f, 0.08223144f, 0.16497162f, -0.02655061f, -0.43221563f, 0.00529018f, -0.41383302f, 
    -0.12992671f, 0.03271849f, 0.02973433f, 0.21007282f, -0.00514486f, 0.27606913f, 0.16985339f, 0.07052354f, 
    0.37754980f, -0.09621706f, 0.05863640f, -0.03664463f, 0.06222501f, 0.11556794f, 0.10623200f, 0.03739041f, 
    0.07550401f, -0.33049127f, 0.11039299f, 0.09245782f, -0.39018106f, -0.21208917f, -0.02157528f, -0.52985400f, 
    -0.28864014f, -0.12715106f, -0.08711648f, -0.16581114f, 0.24691558f, 0.10048911f, -0.11230764f, -0.10451711f, 
    -0.69488817f, -0.23911665f, -0.34827074f, 0.20200738f, -0.01328048f, -0.14331923f, -0.24117041f, -0.16395807f, 
    -0.15388034f, -0.25369850f, 0.03213774f, 0.02798041f, 0.56730598f, -0.29224721f, 0.13046694f, 0.07104590f, 
    -0.12793416f, -0.29627392f, -0.15286045f, 0.11281411f, 0.07774374f, 0.03238860f, -0.14533556f, 0.13189614f, 
    0.36537018f, 0.45328909f, -0.06048274f, -0.08647670f, -0.05775431f, -0.12632470f, 0.01849411f, 0.15798296f, 
    -0.12465739f, -0.00682478f, 0.00177265f, 0.01787786f, -0.09437326f, 0.51356453f, -0.19356056f, -0.09138233f, 
    0.04716877f, 0.17989005f, -0.08385662f, -0.05707377f, -0.15396933f, 0.22622192f, -0.06032704f, -0.02918235f, 
    -0.87230629f, -0.26164463f, -0.34926495f, -0.60581541f, -0.03695099f, -0.08728866f, -0.24622492f, -0.13487713f, 
    0.11770928f, 0.04702877f, 0.02665302f, -0.16070940f, 0.41696298f, 0.28271955f, 0.11017866f, 0.73503995f, 
    -0.30397516f, -0.14844498f, 0.24362652f, 0.18587370f, -0.26945964f, 0.02416629f, -0.19237578f, 0.07093261f, 
    0.18504570f, -0.21850891f, 0.29992345f, -0.28547022f, -0.07823117f, -0.24004346f, 0.11726142f, -0.08362500f, 
    -0.03861814f, -0.14517559f, 0.06879871f, 0.08534620f, 0.18118940f, -0.32310635f, -0.01773817f, 0.03550435f, 
    -0.11102799f, -0.01255065f, 0.09443763f, -0.09752533f, -0.11719848f, 0.24171330f, 0.02006154f, 0.02361874f, 
    0.59826434f, -0.28313708f, 0.01794319f, -0.22449955f, 0.19746965f, 0.27230442f, -0.23502401f, -0.10012674f, 
    -0.13174118f, 0.11643296f, -0.08937102f, -0.25051057f, -0.43792707f, 0.01896036f, -0.03700684f, -0.14965767f, 
    0.39039519f, -0.11421282f, 0.16044612f, -0.15935078f, -0.34465274f, 0.07305135f, -0.17288327f, 0.06472520f, 
    0.20973265f, -0.35818851f, 0.13304514f, -0.15697162f, 0.16006988f, -0.07562472f, -0.02045657f, 0.01734161f, 
    -0.09726712f, 0.16136952f, 0.07294601f, -0.00124589f, -0.07073318f, 0.13365573f, -0.10322360f, 0.15801720f, 
    0.33535123f, 0.03578856f, 0.06294626f, -0.16884197f, -0.04529866f, 0.13789552f, -0.05800249f, -0.08474331f, 
    -0.41441014f, 0.11219191f, -0.81452167f, -0.19869609f, -0.10686408f, 0.14567500f, -0.04446384f, -0.20079599f, 
    -0.12744775f, -0.14708374f, 0.01247125f, 0.06933803f, -0.93582302f, 0.06378483f, -0.07300995f, -0.39174467f, 
    -0.01572972f, -0.00234081f, 0.08820177f, -0.09624611f, -0.11322362f, -0.04769523f, -0.05890695f, -0.08744026f, 
    0.66366959f, -0.54846704f, 0.25689751f, 0.48210734f, -0.48025027f, -0.18207312f, -0.04535184f, -0.06641212f, 
    -0.18114021f, 0.01128030f, -0.05247081f, -0.09000104f, -0.52402222f, 0.09672218f, -0.10730782f, 0.23260571f, 
    -0.02470185f, -0.08298017f, 0.04128120f, 0.16038811f, -0.03215990f, 0.04110701f, 0.05681489f, -0.12362460f, 
    0.80723584f, -0.03479929f, -0.29928908f, 0.08880486f, -0.08488270f, -0.04022457f, 0.12832801f, -0.00955750f, 
    0.10721271f, 0.26209021f, 0.06447235f, -0.04649048f, 0.28033003f, -0.33784482f, -0.20509130f, 0.05758119f, 
    0.18596955f, -0.20943198f, 0.25155902f, 0.17793983f, -0.22103024f, -0.13555121f, -0.01720665f, 0.02450541f, 
    0.24058047f, 0.23791635f, -0.05221719f, -0.21737921f, -0.05768697f, 0.04558640f, 0.07927259f, 0.00379193f, 
    -0.08816697f, -0.11021703f, -0.14288568f, 0.03600946f, -1.12216735f, 0.07380617f, -0.45830670f, 0.15982980f, 
    -0.02213454f, 0.19891834f, -0.02193131f, -0.11813980f, 0.00555383f, -0.11233860f, 0.18712096f, -0.03814793f, 
    0.37501639f, 0.00202117f, 0.01585519f, 0.00905333f, -0.25814012f, -0.01848056f, -0.20719460f, 0.11236095f, 
    0.08831816f, 0.26389745f, 0.01069506f, 0.01178975f, -0.10699502f, -0.24056910f, -0.04878097f, -0.17891724f, 
    -0.13013881f, -0.09917761f, 0.02786519f, 0.01687024f, -0.29785013f, 0.06808075f, -0.05577207f, -0.03266673f, 
    -0.21079326f, -0.02036341f, -0.03949428f, 0.32666126f, -0.17807870f, 0.04147249f, -0.20651980f, 0.07992326f, 
    -0.00376448f, -0.03510224f, 0.14487131f, 0.28160727f, -1.29490900f, -0.18519442f, -0.23671414f, -0.18979146f, 
    -0.00596884f, -0.13425364f, -0.04607686f, -0.00730521f, 0.16039273f, 0.02444419f, 0.04360151f, 0.08160406f, 
    -0.48205644f, -0.03978835f, 0.49514839f, 0.63678342f, 0.19572978f, 0.24198356f, 0.07575518f, -0.06086638f, 
    -0.13247727f, 0.10070982f, -0.16843250f, 0.01305394f, 0.53518158f, -0.01662834f, -0.26790687f, 0.22424370f, 
    -0.06845996f, -0.02574057f, -0.03451373f, 0.13221823f, 0.05740117f, -0.06430468f, -0.07236584f, -0.03916316f, 
    0.51257151f, -0.03974755f, -0.07942460f, 0.21474268f, 0.06157811f, -0.07723433f, -0.00821029f, -0.09900530f, 
    0.02108767f, -0.04447649f, -0.00806755f, -0.00606077f, -0.37702721f, -0.68784785f, -0.74528146f, 0.31119695f, 
    0.00056145f, -0.19690476f, -0.11280645f, -0.02391450f, 0.06495994f, -0.16356970f, -0.29933086f, 0.16409670f, 
    0.02653100f, 0.29281211f, 0.45240399f, 0.03247280f, 0.11269744f, 0.13285953f, 0.18028994f, 0.03619755f, 
    0.07003096f, -0.08128946f, -0.11336353f, -0.07407082f, 0.13211112f, -0.17231740f, -0.13740413f, -0.10255896f, 
    -0.19483571f, 0.11642985f, -0.13349520f, 0.17019410f, 0.12407158f, 0.13242216f, -0.30242276f, 0.00603023f, 
    0.23663826f, 0.02846316f, 0.05071516f, -0.25997916f, -0.21043940f, -0.02463857f, -0.07277691f, 0.01012411f, 
    -0.18510915f, -0.13412261f, -0.02568342f, -0.02140370f, -0.18993743f, -0.03789504f, 0.03714993f, -0.30209088f, 
    -0.08982396f, 0.22188552f, 0.19517006f, 0.01275249f, 0.09301596f, -0.16369614f, -0.08128387f, 0.08177005f, 
    0.23639029f, 0.41584954f, 0.29659802f, -0.10590212f, -0.05063973f, 0.24663715f, 0.07975326f, 0.06056032f, 
    -0.08337556f, 0.11168823f, -0.07860699f, 0.10123362f, 0.15601034f, -0.04403564f, -0.20798014f, -0.28757560f, 
    -0.11337454f, 0.00516606f, 0.03873604f, -0.01891781f, 0.07888354f, -0.32670945f, 0.02666941f, 0.00400336f, 
    0.08336249f, -0.37276450f, 0.14277554f, 0.05765324f, 0.15422241f, -0.19115861f, 0.24162208f, -0.00754462f, 
    -0.03423237f, 0.00928922f, -0.19265807f, 0.11960940f, -0.56001818f, 0.16460691f, 0.38083264f, 0.11293001f, 
    -0.03471725f, -0.00697476f, -0.06198275f, 0.08827868f, 0.18603188f, -0.10190538f, -0.02738903f, -0.30392259f, 
    0.30783373f, -0.33350506f, 0.20672596f, -0.33877307f, 0.14965242f, 0.29944208f, -0.18134883f, 0.33122027f, 
    -0.18684220f, -0.07146358f, 0.16745420f, 0.12741193f, -1.36078012f, 0.05792605f, 0.23348190f, 0.24799937f, 
    0.02116065f, -0.08660018f, -0.06488204f, 0.00535141f, -0.17572486f, 0.11166900f, 0.23038524f, 0.13885318f, 
    -0.10054429f, -0.24427307f, 0.22423409f, -0.01375955f, -0.16870220f, 0.18303765f, 0.01234784f, 0.01349912f, 
    0.02357247f, -0.30380008f, 0.04564141f, -0.10547492f, -0.31269938f, 0.21430233f, -0.41332453f, -0.02683957f, 
    0.13687454f, -0.16858703f, 0.11741475f, 0.25449693f, 0.02271870f, 0.06583473f, 0.00446244f, 0.03025819f, 
    -0.63241225f, -0.19777763f, 0.25518930f, -0.11114591f, 0.02877459f, -0.00670578f, -0.20608053f, -0.04308802f, 
    0.11796496f, -0.03420098f, -0.23691879f, 0.04905150f, -0.45099509f, -0.06534491f, 0.06187287f, -0.01282851f, 
    -0.29413003f, 0.03783652f, -0.22627567f, 0.09371167f, -0.13290629f, 0.00367927f, -0.10641375f, 0.03092393f, 
    -0.28128633f, 0.58928460f, -0.29078281f, -0.25820258f, -0.07343353f, -0.18168493f, -0.00990025f, 0.03393670f, 
    -0.25115538f, -0.17958239f, -0.22331549f, 0.06202814f, 0.07867969f, 0.26110315f, 0.07269294f, -0.03960836f, 
    -0.07369692f, 0.21756643f, 0.06281099f, 0.06131054f, 0.15966727f, -0.11819692f, -0.03251176f, 0.02400780f, 
    -0.10099757f, 0.04521404f, 0.10620932f, 0.14292440f, 0.06615877f, -0.33716574f, 0.04948683f, -0.04276637f, 
    0.02390856f, -0.16370715f, 0.12431074f, -0.17456135f, 0.16078404f, -0.13499801f, -0.26209840f, -0.02958437f, 
    0.00707241f, 0.04272627f, 0.07782735f, 0.09305052f, -0.11059146f, 0.01417882f, 0.05175422f, -0.11373171f, 
    -0.03265668f, -0.08254778f, -0.03732498f, 0.46897903f, 0.19002855f, 0.03612660f, 0.11429948f, 0.41679299f, 
    0.04667989f, 0.16812088f, 0.17182793f, -0.16407889f, 0.04088593f, -0.26347035f, 0.00984560f, 0.22635789f, 
    0.17011331f, -0.14305319f, 0.09085397f, -0.10682904f, -0.02127568f, -0.21305168f, 0.20906878f, 0.27237579f, 
    -0.22170427f, -0.16476381f, 0.10739603f, -0.25321800f, -0.14810096f, 0.23693652f, -0.03550749f, 0.03770035f, 
    0.01110990f, 0.10798408f, -0.08483669f, 0.08980134f, 0.85433602f, -0.50014967f, -0.53908360f, 0.20369890f, 
    -0.01786349f, 0.02431374f, 0.09906699f, -0.08004544f, 0.01203988f, 0.16164783f, 0.04605191f, -0.05659640f, 
    -0.33197975f, -0.15034290f, -0.03940236f, -0.10038830f, 0.05586623f, 0.08074102f, 0.05520256f, 0.04409873f, 
    0.10314152f, -0.07659634f, 0.01048138f, -0.48173103f, 0.02090244f, -0.18545426f, 0.09599098f, 0.01689416f, 
    -0.16777879f, -0.05131279f, 0.06984895f, -0.01969767f, -0.13167536f, -0.00797677f, -0.00319153f, 0.21646033f, 
    -0.20549008f, -0.20778359f, -0.13269499f, 0.19231330f, 0.22744273f, -0.02932171f, 0.13469714f, 0.12508897f, 
    0.14913309f, 0.04419650f, -0.32449380f, 0.06466150f, -0.03665468f, 0.08692641f, -0.43384469f, -0.21483481f, 
    0.06448413f, 0.05478661f, -0.14376400f, -0.26162425f, -0.03480952f, -0.01469627f, -0.20629478f, 0.01435049f, 
    -0.21679567f, -0.13409367f, -0.23821509f, 0.06605751f, 0.09270748f, -0.21309701f, -0.25995278f, 0.11501168f, 
    -0.17343368f, 0.16782311f, -0.02296227f, -0.11157521f, -0.18761355f, 0.05894230f, 0.34819731f, -0.14809123f, 
    0.22677316f, -0.22314535f, 0.07314122f, -0.05377604f, 0.16212893f, 0.01101675f, -0.05702634f, 0.16978449f, 
    0.23002848f, 0.09977600f, 0.24949262f, -0.21509600f, 0.09841526f, 0.16091247f, 0.18639839f, 0.02858108f, 
    -0.04082990f, 0.06306305f, 0.25986621f, 0.28413987f, -0.26199290f, -0.04375617f, 0.35733205f, 0.28307626f, 
    -0.14575945f, 0.05081759f, 0.08757467f, 0.04362202f, 0.05257065f, -0.21363257f, 0.09598291f, -0.05250516f, 
    -0.86807269f, 0.00772814f, 0.08546166f, -0.27562302f, 0.03444629f, 0.03748869f, 0.12683487f, 0.14624029f, 
    0.13675873f, 0.00587704f, 0.18956386f, -0.02247208f, 0.08754032f, -0.21088490f, 0.18063682f, 0.24125053f, 
    0.09939834f, -0.15561412f, 0.04776097f, -0.07750917f, 0.17879583f, 0.18151858f, -0.09842149f, 0.18689781f, 
    0.25234655f, -0.44458389f, -0.15066434f, 0.09986328f, 0.02982712f, -0.30458772f, -0.04024708f, -0.11782614f, 
    -0.02022340f, -0.04661272f, -0.03670636f, 0.33821726f, -0.03492674f, 0.22936910f, -0.07220811f, 0.16772446f, 
    -0.04030907f, -0.13882130f, -0.17539446f, -0.11118601f, -0.17114846f, -0.13230786f, 0.27228040f, 0.19475785f, 
    -1.06729817f, 0.15686269f, -0.36959434f, 0.11446824f, 0.13399595f, 0.06020672f, 0.00569674f, -0.03314118f, 
    0.09956739f, 0.07913198f, -0.03941494f, 0.24352236f, 0.30943620f, 0.06301497f, 0.02381908f, 0.23557751f, 
    0.21547061f, 0.08733384f, 0.06059258f, -0.11310953f, -0.07295311f, 0.10288972f, -0.23216966f, -0.04426446f, 
    -0.03449797f, -0.18213588f, -0.00870033f, 0.10705865f, -0.03524083f, -0.21384913f, -0.15398046f, 0.24577022f, 
    0.01102452f, -0.05898247f, 0.17553443f, -0.43757886f, 0.07427041f, 0.19647950f, 0.19879179f, -0.59633934f, 
    0.00855295f, 0.12776758f, -0.22380963f, -0.29387435f, -0.13905133f, -0.03482907f, 0.03358944f, 0.02080663f, 
    0.60641032f, 0.10619531f, 0.01363026f, 0.37018740f, -0.35554349f, 0.18036266f, 0.03880327f, -0.00132154f, 
    -0.21405661f, 0.33876941f, -0.01369235f, 0.29736033f, 0.01868339f, 0.44001836f, 0.20817356f, -0.45301083f, 
    0.01919065f, -0.06951022f, 0.03264372f, -0.05814729f, -0.04124967f, 0.08539216f, -0.00120033f, 0.03370712f, 
    -0.31259391f, 0.12548685f, -0.03038328f, -0.28345877f, -0.30727121f, -0.13841756f, -0.08159163f, -0.10369749f, 
    -0.09597166f, 0.15533750f, 0.19960082f, 0.10268557f, -0.30492297f, -0.85199761f, 0.00547392f, -0.26158142f, 
    0.16773564f, 0.15494879f, 0.08659030f, -0.22347595f, 0.14591381f, -0.17752455f, 0.19784085f, 0.33786002f, 
    -0.28150356f, -0.12283324f, -0.08599731f, 0.05571355f, 0.34577990f, 0.07381575f, 0.02993472f, 0.03688964f, 
    -0.05487134f, 0.04909142f, 0.15432286f, -0.07610855f, 0.70622128f, -0.79888010f, 0.14291784f, 0.09284560f, 
    -0.38485843f, -0.10809384f, 0.28398928f, -0.01768519f, -0.01722501f, -0.05944495f, 0.16613412f, 0.07621869f, 
    0.44571400f, 0.19831252f, -0.24418628f, -0.36229360f, -0.05524984f, 0.02509995f, 0.02910938f, 0.15788209f, 
    -0.06656916f, -0.05645808f, -0.30855155f, -0.10841139f, -0.04175443f, 0.08731430f, -0.15074897f, 0.35973090f, 
    -0.05799313f, 0.09816625f, -0.08646829f, 0.07047259f, -0.00570936f, 0.31918782f, -0.14003204f, 0.15717076f, 
    0.44881153f, -0.27353171f, 0.14918040f, -0.26040685f, 0.06231247f, -0.06818250f, 0.06321875f, -0.25973555f, 
    -0.10954928f, -0.07066773f, 0.16179174f, -0.07521057f, -0.75035620f, 0.46679607f, 0.15365902f, -0.26442608f, 
    -0.44234669f, 0.16371381f, 0.08144579f, -0.03926161f, 0.02042077f, 0.11369778f, 0.02629539f, -0.16714787f, 
    -0.13845721f, 0.24696992f, -0.33797383f, -0.02363580f, -0.13563855f, 0.24786563f, -0.15504862f, -0.11089793f, 
    -0.19938125f, -0.04033011f, -0.21159264f, -0.14422236f, 0.17025867f, -0.25792605f, -0.26497838f, 0.68243498f, 
    -0.00459258f, 0.04893372f, 0.15437616f, -0.13651934f, 0.12613249f, -0.25118795f, -0.34185475f, -0.19053200f, 
    -0.44059345f, -0.11585193f, -0.29988194f, -0.44990209f, -0.19942020f, -0.00734133f, 0.03860462f, -0.21559706f, 
    -0.13007917f, -0.02546858f, 0.00392441f, -0.00431670f, -0.37509111f, -0.17424671f, -0.25439781f, 0.42200163f, 
    0.04883170f, -0.22238640f, -0.12982777f, -0.06638293f, 0.16679326f, 0.06257084f, 0.11167377f, -0.02810475f, 
    0.41520816f, -0.21987760f, 0.11641480f, -0.30723318f, 0.21865951f, -0.01134043f, 0.39424711f, -0.02871364f, 
    0.04180994f, -0.05846474f, -0.18266837f, 0.17847919f, -0.82291335f, 0.21880317f, 0.25424683f, 0.19701600f, 
    0.07962362f, 0.01372986f, 0.24139152f, 0.16224362f, -0.12228473f, -0.02776956f, -0.05454913f, -0.13766594f, 
    -0.08118861f, 0.26692554f, -0.25455645f, 0.57080841f, 0.18112351f, -0.08025392f, -0.02434918f, 0.08805119f, 
    -0.04634442f, 0.26922184f, -0.00963394f, 0.03664057f, -0.01190286f, -0.84622014f, -0.20761076f, -0.18548518f, 
    -0.03484446f, 0.05095232f, -0.01184996f, -0.02939701f, -0.08155778f, 0.04453023f, -0.05678064f, -0.02041908f, 
    0.18577541f, 0.13380612f, 0.17642753f, 0.39756241f, 0.14286719f, 0.01129858f, -0.03229615f, -0.15286225f, 
    -0.35139558f, -0.20459341f, -0.21923575f, -0.09822033f, 0.27924669f, 0.33568415f, 0.18928115f, -0.11864907f, 
    0.05939978f, 0.24945356f, 0.24991100f, -0.18483792f, -0.03038752f, -0.01414184f, -0.05534926f, -0.03196563f, 
    -0.23455563f, 0.39687169f, -0.06572761f, -0.13675576f, -0.40119237f, -0.11766996f, -0.14999871f, -0.10785010f, 
    0.06540559f, 0.03689468f, -0.17613634f, -0.15590318f, -0.04504858f, -0.07293485f, -0.01878017f, -0.35983399f, 
    -0.00728804f, 0.01232382f, -0.22645754f, -0.40265930f, 0.00556373f, -0.19834261f, -0.01125592f, -0.08087917f, 
    -0.03109817f, -0.24587792f, 0.01421838f, -0.10206734f, -0.10666059f, -0.23583408f, 0.09039119f, -0.20364451f, 
    0.21178760f, -0.05043415f, -0.20518273f, -0.12702668f, -0.16728525f, -0.21936856f, -0.31328359f, 0.11965725f, 
    0.07111371f, -0.16976215f, -0.09843057f, -0.07032406f, -0.37648520f, 0.17924179f, 0.12218753f, -0.07928285f, 
    -0.08327697f, 0.36420459f, 0.09958506f, -0.17053144f, -0.54007757f, -0.09318721f, -0.11885215f, 0.06983983f, 
    0.02226022f, -0.10516525f, -0.07915750f, 0.05014052f, 0.03336997f, 0.19920647f, -0.15077356f, -0.00341906f, 
    -0.23293367f, 0.13849975f, -0.05814309f, -0.09237672f, -0.22406295f, 0.12168951f, 0.10219579f, 0.00428652f, 
    0.09754895f, -0.04198162f, 0.07025146f, 0.33505669f, -0.08280028f, -0.08226499f, -0.30198845f, 0.01602971f, 
    0.08353501f, -0.03318080f, -0.03701360f, -0.27046189f, 0.02936108f, 0.17959745f, -0.05445528f, 0.19429734f, 
    0.21325512f, -0.18032609f, -0.06732591f, -0.01943077f, 0.10356398f, 0.00507644f, -0.08998393f, -0.12653822f, 
    0.20331620f, 0.29741123f, 0.23830701f, 0.05480435f, 0.00461946f, 0.09134079f, -0.01030814f, -0.14815588f, 
    -0.08948439f, -0.04693226f, 0.05848300f, -0.10947545f, 0.24846952f, 0.22266747f, -0.14609897f, 0.42999169f, 
    0.28035012f, 0.02152003f, -0.14645888f, 0.10260348f, -0.01412897f, -0.06036558f, -0.20013373f, -0.03051065f, 
    0.66196096f, 0.34182319f, -0.10838135f, -0.37247065f, -0.13921583f, -0.07707451f, -0.03033913f, -0.15682660f, 
    -0.08675729f, -0.12602578f, 0.00045920f, -0.07675364f, -0.75117129f, 0.24179600f, 0.15925284f, -0.04260540f, 
    0.04792367f, 0.21092133f, -0.15908462f, -0.06185360f, -0.06483674f, -0.07689428f, -0.10693124f, -0.34677452f, 
    0.12075269f, 0.02956434f, 0.13771828f, -0.33908796f, -0.23134211f, -0.10318696f, 0.10488877f, -0.04207614f, 
    0.07512365f, -0.28541487f, -0.15461007f, -0.13489543f, -0.05004897f, -0.46261781f, -0.39317530f, 0.44268838f, 
    0.25162634f, -0.09734565f, -0.06417023f, -0.14083141f, 0.20075209f, 0.07279880f, 0.25763881f, -0.02204795f, 
    -0.39390934f, -0.08434797f, 0.07955963f, -0.44285595f, 0.03067048f, -0.05076228f, 0.11878536f, 0.05216255f, 
    0.24206752f, -0.25021625f, -0.40896112f, -0.15950641f, -0.10592721f, 0.22474879f, 0.16433698f, 0.24165064f, 
    -0.16491377f, -0.05232641f, -0.08988712f, 0.04546851f, 0.11090523f, -0.06930459f, -0.28321627f, -0.10603312f, 
    -0.17672673f, 0.44015014f, -0.36487177f, -0.01056855f, -0.00039551f, 0.30903387f, -0.01846542f, -0.14312576f, 
    0.20108916f, 0.16563293f, -0.11163132f, 0.01622883f, 0.40378031f, -0.31202012f, 0.19622903f, 0.23366505f, 
    -0.01942402f, -0.13017116f, -0.09737200f, -0.16713288f, 0.15033546f, -0.36667493f, -0.01299577f, -0.17835253f, 
    -0.16793992f, -0.11701559f, -0.58427548f, 0.05407563f, -0.13428038f, -0.05156350f, 0.15394360f, -0.21498062f, 
    0.16242166f, -0.11939798f, 0.31898668f, -0.08118884f, -0.11141986f, 0.08413374f, -0.19909240f, -0.00095603f, 
    0.12280232f, 0.02152975f, -0.39946130f, 0.05751150f, -0.02029835f, -0.07919468f, 0.34046182f, -0.22381626f, 
    0.21151650f, 0.03901181f, 0.02640741f, -0.01511731f, -0.05694199f, 0.05055181f, 0.13909036f, 0.05348909f, 
    -0.02671920f, 0.03021341f, 0.07436307f, 0.05829014f, 0.18979324f, -0.07852773f, 0.36521801f, 0.11345430f, 
    -0.02743977f, 0.03256524f, -0.05960647f, -0.01687226f, 0.00389597f, -0.07938726f, 0.12364835f, 0.05065770f, 
    -0.57631963f, -0.11343805f, -0.14168702f, -0.73353273f, -0.33161411f, -0.00795932f, -0.23369056f, 0.05984426f, 
    0.05471032f, 0.03019032f, 0.21322601f, 0.16870917f, 0.13669606f, 0.63928646f, -0.34940043f, -0.30505681f, 
    0.04316178f, -0.22333565f, -0.28013065f, -0.08719159f, 0.03192792f, -0.19799235f, 0.21973969f, 0.31009600f, 
    -0.53478187f, -0.03321699f, 0.31803903f, -0.02025835f, -0.20668326f, -0.04926538f, -0.21565652f, -0.13828017f, 
    0.08696215f, 0.04304881f, -0.10623192f, 0.12144415f, -0.03005421f, 0.35405108f, -0.29151347f, -0.23147699f, 
    -0.05844977f, 0.15440102f, 0.07324440f, -0.12239444f, -0.05108782f, 0.00050410f, -0.31033084f, -0.02968159f, 
    0.08270526f, -0.28702629f, -0.05882009f, -0.36540326f, 0.05607928f, -0.17894882f, -0.17862834f, 0.18749227f, 
    0.16525766f, 0.07595109f, 0.11204930f, -0.06543277f, 0.14286749f, 0.13028979f, 0.02406589f, 0.08475202f, 
    0.04771704f, -0.14085922f, -0.01244974f, -0.06161772f, 0.09552336f, 0.10342307f, -0.11446277f, -0.03775880f, 
    -0.88188320f, -0.19489974f, 0.47631773f, -0.09557889f, 0.15293899f, -0.02487369f, -0.30120394f, -0.21038339f, 
    0.20088743f, 0.02702871f, 0.12294407f, 0.24306208f, -0.55817008f, -0.14386736f, 0.27713108f, -0.54386550f, 
    0.06142855f, 0.04011528f, -0.07441108f, 0.07478826f, -0.07209592f, -0.18152656f, -0.21626084f, -0.08130259f, 
    0.20454516f, 0.37338552f, -0.22208852f, 0.21169731f, -0.09081356f, -0.03455785f, -0.06320702f, -0.13907170f, 
    -0.12104090f, -0.08326132f, 0.26630074f, 0.31474257f, 0.15985912f, -0.31228381f, -0.13437267f, 0.23166238f, 
    0.05170314f, 0.19154127f, 0.05082333f, 0.27861184f, -0.10132556f, 0.16019450f, -0.12189612f, -0.07414200f, 
    -0.28203326f, 0.33825043f, 0.02651122f, 0.34877425f, -0.06265760f, -0.01574867f, 0.10110128f, -0.01117129f, 
    -0.06728943f, 0.10373124f, 0.07983687f, 0.10217388f, 0.22635128f, 0.27613968f, -0.16319631f, -0.16912816f, 
    0.12553126f, 0.11673833f, -0.07234777f, -0.16848475f, 0.04423785f, 0.15077326f, -0.04867960f, 0.05585164f, 
    -0.61836863f, 0.57876658f, -0.27431133f, -0.57387054f, 0.16256163f, -0.21037646f, 0.02082280f, 0.05994016f, 
    -0.03820453f, 0.26172450f, -0.01838132f, -0.20382898f, 0.27767432f, 0.21730465f, -0.07881784f, -0.40878063f, 
    0.02679016f, 0.11278713f, 0.10883609f, 0.01963474f, 0.01086769f, 0.23870358f, -0.25402179f, 0.04105372f, 
    -0.54417741f, 0.55601048f, -0.15938485f, -0.06883600f, -0.02403266f, -0.04119095f, -0.00573577f, -0.08441290f, 
    -0.00855070f, 0.09278250f, -0.01821558f, -0.08473477f, -0.05209033f, 0.58663225f, -0.11428347f, -0.42936891f, 
    0.27170029f, 0.19055587f, -0.14955856f, 0.04920574f, -0.20627843f, -0.05903719f, 0.15924197f, -0.09052769f, 
    0.28032783f, -0.17590751f, -0.27630001f, -0.03467951f, 0.01779422f, -0.14900412f, 0.10222516f, 0.05400163f, 
    0.16158696f, -0.07008759f, -0.21971954f, -0.01670764f, -0.07726827f, -0.07921737f, 0.71552080f, -0.22594765f, 
    0.08292195f, 0.01640327f, -0.03518409f, -0.01560514f, 0.03108567f, -0.07817166f, -0.24082021f, -0.25336385f, 
    -0.25709516f, -0.82912099f, 0.13771412f, -0.27501270f, -0.02786170f, 0.00624649f, 0.02285673f, -0.04011245f, 
    -0.11267400f, -0.17672586f, -0.14505410f, -0.16484779f, 0.15535502f, -0.11251581f, 0.22879779f, -0.04585773f, 
    -0.26460186f, -0.05638984f, 0.06930130f, 0.49787101f, -0.09149636f, -0.22348008f, 0.36068037f, 0.00572999f, 
    -0.17350233f, -0.01281989f, -0.07197353f, 0.15429792f, 0.03651816f, 0.07478892f, 0.19139360f, -0.16520543f, 
    -0.09077511f, -0.03750441f, -0.13840562f, 0.18189679f, -0.89375138f, 0.30892035f, 0.06196623f, -0.04471968f, 
    0.08636954f, -0.05479928f, 0.13384436f, -0.03715788f, 0.04651368f, -0.03410170f, 0.31100979f, 0.13641377f, 
    0.15738511f, 0.29464996f, -0.36798713f, 0.18308407f, -0.17539346f, -0.21059266f, -0.03109292f, -0.09492192f, 
    -0.12798961f, -0.10044821f, 0.12507851f, -0.36741835f, -0.54473388f, -0.36990464f, 0.00479220f, -0.51302212f, 
    0.32348704f, -0.01186351f, -0.09969975f, -0.03134729f, -0.08968392f, 0.17127416f, 0.03503632f, -0.09305321f, 
    0.23985270f, 0.04007433f, 0.12479926f, -0.12454258f, 0.13081601f, 0.17765528f, 0.28762704f, -0.20904504f, 
    -0.04011988f, -0.21646786f, -0.14921868f, -0.17658196f, 0.72999954f, -0.23215549f, 0.04626349f, -0.18465331f, 
    -0.35824510f, -0.15137589f, -0.19525383f, -0.07632109f, 0.01102308f, -0.11777893f, -0.20283833f, -0.40401852f, 
    0.06010726f, -0.06503720f, -0.11118197f, -0.02198888f, 0.09086689f, 0.18025269f, 0.11003002f, -0.00550674f, 
    0.14231305f, -0.11644319f, -0.02151408f, 0.02290926f, -0.05122147f, 0.14189070f, -0.28849468f, -0.32488465f, 
    0.05329321f, 0.07360980f, -0.24004816f, 0.07709507f, 0.02580803f, -0.24807046f, -0.04453792f, -0.03896270f, 
    0.32634988f, -0.31791899f, -0.16896802f, -0.04701942f, -0.08493944f, 0.08982090f, -0.16306743f, 0.19069889f, 
    -0.20150600f, -0.14283404f, 0.29940817f, 0.02576380f, -1.15419829f, -0.69582164f, 0.09328910f, -0.19399725f, 
    0.23137039f, -0.03180204f, -0.22218361f, 0.01866264f, 0.23744087f, -0.08289877f, -0.04664917f, 0.03152978f, 
    -0.05964704f, -0.36758214f, -0.22238229f, 0.36600137f, 0.04649398f, 0.10867007f, 0.00537930f, 0.28360644f, 
    0.27412385f, 0.14612287f, 0.16285102f, 0.25659722f, -1.30752349f, -0.69835740f, 0.24755934f, -0.46128061f, 
    0.30503151f, 0.00746173f, 0.05100869f, 0.01008260f, 0.00919167f, 0.11397669f, 0.17221397f, 0.30637783f, 
    0.67451626f, 0.06827691f, 0.10771126f, -0.30429634f, 0.12324469f, 0.23639385f, 0.16664898f, 0.38115764f, 
    0.15469077f, 0.20452671f, 0.33394855f, 0.21318167f, -0.17021833f, 0.02714835f, 0.15629436f, 0.03372829f, 
    0.15039417f, 0.10604911f, 0.16628209f, 0.00297562f, -0.02815873f, 0.17895353f, 0.32468593f, 0.11008274f, 
    0.15339589f, 0.06080496f, -0.10937937f, -0.16727667f, 0.09730782f, -0.13995112f, 0.05844590f, -0.17076033f, 
    -0.00624696f, 0.05686894f, 0.04036078f, 0.16927710f, -0.13900830f, -0.28756413f, 0.25301602f, -0.21621493f, 
    -0.19722626f, 0.01413466f, -0.08697792f, -0.16223292f, 0.15847902f, 0.33377996f, -0.31911886f, -0.11251072f, 
    -0.37978762f, 0.03299281f, 0.06932016f, 0.11722572f, 0.27577192f, 0.24293180f, -0.19926563f, -0.06083491f, 
    -0.13422745f, 0.22132772f, 0.06585439f, -0.05365931f, -0.57117206f, -0.72726667f, -0.65969402f, 0.02580459f, 
    0.10907771f, 0.02498017f, 0.27779964f, 0.06555746f, 0.14673647f, -0.05804613f, -0.00426989f, 0.05976557f, 
    -0.18920970f, -0.56608856f, -0.48426524f, 0.15792705f, -0.36291119f, 0.30244717f, -0.20335332f, -0.14144342f, 
    0.04267176f, 0.05659479f, -0.02685035f, 0.17064333f, 0.99292755f, 0.17218456f, -0.63192594f, -0.21036120f, 
    0.19078785f, -0.18340808f, -0.09866057f, 0.04009607f, 0.01864050f, 0.15046155f, -0.06582034f, 0.19807968f, 
    -0.07666378f, 0.09672976f, -0.10629161f, -0.34631076f, -0.31838757f, 0.10704606f, -0.16805485f, -0.23067704f, 
    0.11411300f, 0.03045437f, 0.28550145f, 0.02775963f, -0.58705884f, 0.23821288f, -0.09119505f, 0.17226072f, 
    0.04430309f, -0.24995264f, 0.07506111f, 0.06935696f, 0.06015952f, -0.11899148f, 0.09671333f, -0.18884417f, 
    0.29722467f, -0.02152606f, -0.01164148f, 0.18897246f, 0.30539432f, -0.03743079f, -0.01843405f, -0.08968249f, 
    0.06383721f, -0.00923690f, -0.05031871f, 0.08432456f, -0.62252063f, -0.13497925f, -0.37127817f, -0.49872610f, 
    -0.00928199f, 0.06259144f, -0.09281858f, 0.03867292f, -0.00951620f, 0.08450516f, -0.09191957f, 0.11590702f, 
    -0.06121773f, 0.14136194f, 0.00300368f, 0.13890605f, 0.05265946f, 0.14100374f, 0.15608071f, -0.12862425f, 
    0.01630929f, -0.06307654f, -0.11374591f, 0.09469002f, 0.75875121f, -0.29359946f, -0.20157444f, 0.31252441f, 
    0.06061908f, -0.14173837f, 0.20698039f, 0.04938145f, 0.25144523f, 0.10795376f, 0.04048377f, 0.07052132f, 
    -0.37937856f, -0.11040933f, 0.14863557f, -0.02301325f, 0.26199564f, 0.02267175f, 0.11557435f, -0.08817243f, 
    0.10883139f, -0.01773461f, -0.04786787f, -0.14813443f, 0.07821429f, -0.46397898f, -0.17112225f, -0.20591447f, 
    0.07834424f, 0.12776381f, -0.05791258f, -0.02067096f, -0.07145920f, -0.11575514f, -0.12863755f, -0.26396319f, 
    -0.41049790f, 0.11029872f, 0.08184110f, 0.45264208f, 0.11288066f, -0.02741662f, 0.15165862f, 0.10942180f, 
    -0.03654517f, -0.17270699f, -0.14570646f, -0.44888702f, 0.17360975f, -0.09892780f, -0.29794574f, 0.16872451f, 
    0.06565659f, -0.00502092f, -0.03025554f, -0.21766697f, 0.03665325f, 0.07684720f, -0.07738218f, -0.01289342f, 
    0.28110892f, 0.41706783f, -0.08367714f, -0.03481378f, -0.17077042f, -0.22216497f, 0.07930140f, -0.43740666f, 
    -0.04457946f, 0.10619421f, -0.03763974f, -0.21783644f, -0.13304204f, -0.09555615f, -0.06755156f, 0.13301495f, 
    0.09453806f, 0.07004555f, -0.14813243f, 0.13270885f, -0.19411498f, 0.01930353f, 0.05296460f, -0.18097140f, 
    -0.82113874f, 0.42936769f, 0.11092813f, -0.01288702f, 0.01710842f, -0.03934494f, 0.11089256f, -0.10392182f, 
    0.15019874f, -0.10564288f, 0.04742225f, 0.13435094f, -0.54277265f, 0.21530154f, -0.04362544f, 0.13550976f, 
    0.23859239f, 0.10548560f, 0.10866022f, -0.03072851f, 0.27425981f, -0.01289586f, 0.00650423f, 0.09769017f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.13535020f, 0.05776357f, -0.09404216f, 0.14394955f, -0.08904063f, -0.05993892f, 0.03930709f, -0.32036531f, 
    -0.05878144f, 0.14869130f, 0.15057595f, 0.07015276f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
