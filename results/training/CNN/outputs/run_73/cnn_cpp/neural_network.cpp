#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.70066017f, 0.31465453f, 0.40890402f, 0.60230857f, -0.03817128f, 0.23600307f, 0.22972959f, 0.30728558f, 
    -0.35756418f, 0.78871989f, 0.54848492f, -0.77025849f, 0.49089038f, 0.21747261f, 0.52696902f, 0.30777866f, 
    -0.17397006f, -0.28314111f, 0.51068497f, 0.42619321f, -0.10919942f, -0.75087750f, -0.77061772f, -0.78650486f, 
    -0.05391539f, -0.05290917f, 0.48002347f, 0.45173818f, 0.51607388f, 0.37242705f, 0.56344634f, 0.51404095f, 
    -0.61096311f, 0.39198616f, 0.45172185f, 0.08233900f, 0.32670704f, 0.17267232f, 0.54078203f, 0.52436185f, 
    0.10961820f, 0.26752913f, 0.23507521f, 0.07618067f, 0.51320738f, -0.52151769f, 0.99071765f, -0.65001440f, 
    0.27980921f, -0.04945129f, -0.90105277f, -0.11781996f, -0.00590158f, -0.14221190f, 0.83800936f, 0.89936602f, 
    0.07276387f, 0.50673139f, -0.50487590f, -0.63750947f, -0.59678572f, -0.29226261f, -0.31461203f, 0.42373526f, 
    0.42425132f, 0.08490561f, 0.49665138f, -0.94675779f, -0.89018852f, 0.06617979f, 0.56101000f, 0.25948086f, 
    -0.09969153f, -0.73658252f, -0.01503523f, -0.69166070f, 0.69157976f, -0.36276200f, 0.19019739f, -0.22788353f, 
    -0.14255154f, 0.53707176f, 0.79183185f, 0.62361377f, -0.64963716f, 0.21231197f, -0.15792568f, 0.01501369f, 
    0.04441480f, -0.42325431f, -0.86210418f, -0.58699000f, 0.60605258f, -0.36872223f, 0.39431489f, 0.78738648f, 
    -0.25903517f, -0.04100946f, -0.50872242f, -0.29245871f, -0.68790299f, -0.28677034f, 0.28817838f, 0.75795543f, 
    0.48545277f, -0.32472163f, -0.36668953f, -0.45533070f, -0.91584092f, 0.65783179f, -0.12619047f, 0.23398748f, 
    -0.45287561f, -0.46333775f, -0.39602673f, -0.31279334f, -0.53762376f, 0.65864551f, 0.67376208f, 0.62374884f, 
    -0.49487600f, 0.37756166f, -0.00333265f, -0.27536008f, 0.23694053f, -0.10282230f, 0.80995876f, -0.93343890f, 
    0.77053541f, 0.66266757f, -0.56343538f, 0.26651230f, 0.20427904f, -0.04272532f, -0.36761588f, 0.99675894f, 
    0.11195773f, 0.06524438f, -0.02181875f, 0.38766336f, -0.21251775f, -0.42127243f, 0.37485263f, -0.24461974f, 
    -0.80857313f, 0.49532592f, -0.40909544f, -0.04648619f, -0.04911017f, 0.27410090f, -0.25515938f, 0.11810268f, 
    0.64528900f, -1.11128819f, 0.56289989f, -0.35599107f, 0.72188580f, -0.40992829f, -0.35552117f, 0.38600785f, 
    -0.00339462f, 0.34797418f, 0.01269213f, -0.77513367f, 0.20599452f, -0.94455862f, 0.34510341f, -0.48921430f, 
    -0.44054902f, 0.44277248f, -0.43768016f, 0.04047223f, 0.49232215f, 0.67911345f, 0.44328108f, 0.36565953f, 
    0.46713811f, 0.01030336f, 0.20096084f, 0.36139169f, -0.07122998f, 0.79888028f, -0.74447250f, -0.36364004f, 
    -0.48650199f, -0.35366964f, 0.47639680f, -0.31751761f, -0.35804918f, 0.62322485f, 1.09261858f, 0.66405201f, 
    -0.59741759f, 0.47008005f, -0.19480048f, 0.06030871f, 0.39055011f, -0.38020754f, -0.68317044f, 0.80399603f, 
    -0.29653516f, 0.53470576f, 0.76591849f, -0.00798752f, 0.19275768f, -0.34028846f, -0.63650620f, 0.62142438f, 
    -0.33507743f, 0.17240231f, -0.55141795f, 0.57851881f, 0.23961432f, -0.31817231f, -0.23868650f, -0.43814746f, 
    -0.89727736f, -0.21086107f, 0.31045857f, -0.90705353f, 0.28680876f, -0.52231926f, -0.18155645f, -0.18947855f, 
    0.26444620f, 0.42247266f, 0.43324852f, -0.48796856f, 0.35877371f, -0.56174564f, -0.26220039f, 0.53129971f, 
    0.44901827f, 0.08548281f, -0.23271802f, -0.53344393f, -0.67924064f, 0.22763442f, 0.68531704f, -0.19677666f, 
    0.18375523f, 0.10229386f, -0.26899076f, 0.88957679f, -0.04336540f, -0.69917065f, 0.79082680f, 0.46172395f, 
    -0.51944101f, -0.23772670f, -0.44438842f, -0.12582500f, 0.89369810f, -0.40984395f, -0.94804716f, -0.71902311f, 
    0.35885853f, 0.71096832f, -0.28047070f, -0.04727453f, -0.05329464f, -0.32890546f, -0.94238514f, -0.02256024f, 
    0.47439235f, 0.98015815f, -0.48338166f, -0.38353777f, 0.35349226f, -0.12923551f, -0.25244939f, -0.00746417f, 
    -0.55819100f, 0.95631498f, 0.55420434f, 0.64621907f, -0.34755468f, -0.14192791f, -0.08918586f, 0.06868528f, 
    -0.88149434f, -0.64929122f, 0.42995021f, 0.41682205f, 0.03624035f, -0.44815838f, 0.37458250f, -0.04295258f, 
    -0.20207916f, -1.00566995f, -0.41321865f, 0.60873306f, -0.26088902f, 0.60462654f, -0.20915540f, 0.20200065f, 
    -0.05433755f, -0.69062787f, -0.56745845f, -0.69730133f, 0.21166773f, -0.69453806f, -0.18567052f, -0.53666669f, 
    0.26431379f, -0.08940330f, -0.59720343f, 1.08232784f, -0.13330501f, -0.88752860f, 0.62655401f, 0.06076579f, 
    0.01898601f, 0.34058079f, -0.55572253f, 0.83611751f, 0.85949814f, -0.76864344f, 0.53879911f, 0.16150409f, 
    0.49561620f, -0.50849265f, -0.09729166f, 0.01604642f, -0.77619886f, -0.29448095f, -0.47306216f, -0.82893211f, 
    0.51629645f, 0.30672947f, -0.19904076f, -0.36367476f, 0.13587297f, -0.82263219f, 0.28521267f, 1.05016601f, 
    0.42230701f, 0.53190237f, -0.06235597f, -0.00759800f, 0.50512308f, 0.17041600f, -0.35899305f, -0.73866957f, 
    -0.37377474f, -0.33880416f, -0.61855268f, -0.81845725f, 0.02603489f, 0.40393355f, 0.04905040f, 0.70217013f, 
    0.06898242f, 0.52688646f, 0.47610897f, 0.54425329f, 0.48956472f, -0.38409585f, 0.42032409f, 0.19523147f, 
    -0.20701446f, -0.60563725f, -0.70902896f, -0.39510170f, 0.02331495f, -0.26873651f, -0.13976732f, 0.34186843f, 
    0.17265220f, 0.36166200f, 0.54479909f, 0.47291449f, 0.57574016f, -0.60090393f, -0.39439827f, 0.19053547f, 
    -0.32231349f, -0.37277853f, 0.42395440f, 0.55517137f, -0.33470094f, 0.59008378f, -0.72681701f, 0.32308894f, 
    0.64461005f, -0.49860236f, -0.24923608f, -0.10269909f, -0.29518694f, -0.35362226f, 0.53129536f, -0.72992533f, 
    0.58240312f, 0.33653295f, -0.66409159f, -0.35778239f, 0.76883692f, -1.01097107f, 0.23607837f, -0.82811826f, 
    0.09428940f, 0.24155621f, 0.37908801f, 0.11967657f, 0.30757454f, -0.27322274f, 1.14005184f, 0.87237960f, 
    0.41619679f, -0.10113455f, 0.09074558f, -0.35901982f, 0.02515785f, 0.09234563f, -0.70579374f, 0.39145809f, 
    0.65805459f, 0.75504375f, 0.24295366f, 0.60337692f, -0.09014846f, -0.35253683f, -0.17971426f, 0.56473422f, 
    0.83310354f, 0.14336653f, -0.25906381f, -0.24744743f, 0.66782528f, 0.21980181f, 0.01353955f, 0.52025247f, 
    0.54578388f, 0.84815425f, 0.75123036f, -0.11696350f, 0.50674921f, 0.08062045f, 0.42747426f, 0.02198937f, 
    -0.20233457f, -0.56035459f, -0.80853772f, -0.77963984f, -0.35356572f, -0.06910296f, 0.14953382f, 0.03333907f, 
    0.11799333f, 0.44359288f, -0.73663563f, -0.95583671f, -0.65670675f, 0.16019937f, 0.11237810f, 0.23635933f, 
    -0.31713998f, -0.16833939f, 0.00732176f, -0.80618429f, 0.92805117f, -0.34575704f, -0.50499207f, 0.75411993f, 
    0.43059817f, -0.20788233f, -0.26441532f, 0.18250979f, -0.54730731f, 0.00540555f, 0.88246047f, -0.98732764f, 
    -0.28993040f, -0.15889928f, -0.01334326f, 0.40378213f, -0.04830834f, -0.74102628f, -0.51283664f, -0.02431241f, 
    0.30444714f, 0.96907502f, -0.39686280f, -0.10434949f, -0.27874979f, 0.22677724f, -0.42175144f, -0.45893779f, 
    0.10061949f, -0.28705829f, -0.82828265f, -0.49092060f, 0.43147972f, -0.27255937f, 0.36883241f, -0.32399035f, 
    -0.94334221f, -0.45863447f, 0.18204933f, 0.89651304f, -0.03948329f, 0.57756722f, 0.26923904f, -0.48923621f, 
    -0.91205060f, 0.75569671f, -0.46556503f, 0.25274116f, 0.74272245f, -0.73365891f, -0.26622957f, -0.06670972f, 
    0.41404974f, -0.74468333f, -0.70066756f, 0.51023591f, 0.40932024f, -0.46473905f, -0.35517979f, -0.12843651f, 
    -0.39931026f, -0.37945125f, 0.07300854f, 0.32967880f, 0.77636915f, -0.76079810f, 0.42665026f, 0.37076163f, 
    0.43831676f, 0.33087087f, -0.01067583f, 1.04405773f, 0.72808504f, 0.06522664f, -0.41872051f, -0.17729005f, 
    -0.36623651f, 0.12811972f, -0.00360123f, 0.26424912f, 0.54234004f, -0.24313511f, 0.97174096f, -0.49558210f, 
    -0.67688513f, -0.54270017f, 0.61791855f, 0.41852468f, 0.05231486f, -0.74978340f, -1.02885818f, -0.80573934f, 
    -0.61138046f, 0.28069213f, 0.65506995f, 0.27729547f, -0.10063232f, -0.17989549f, -0.06861909f, 0.92120582f, 
    -0.29544249f, -0.33677730f, -0.72829330f, 0.75103176f, -0.04102061f, 0.53968847f, -0.41535461f, 0.98877525f, 
    0.33980328f, 0.28405669f, -0.76622474f, -0.81795305f, 0.44547057f, 0.32650208f, -0.19258204f, -0.49809965f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.17489402f, 0.14094597f, 0.15474655f, 0.13188122f, 0.02081685f, -0.18777917f, -0.28567269f, 0.05501061f, 
    0.07657219f, 0.07282066f, -0.01620115f, -0.13523483f, 0.08101362f, 0.29493949f, 0.06737167f, 0.12375604f, 
    -0.05510464f, 0.01017734f, -0.08039238f, 0.34696192f, -0.13924558f, -0.00049756f, -0.05176947f, -0.03130534f, 
    0.15736291f, 0.00544030f, 0.24695140f, 0.14538470f, -0.16736364f, 0.06342313f, -0.18296237f, 0.10982186f, 
    -0.00902311f, 0.02697601f, 0.03253084f, 0.03611080f, 0.02758763f, 0.09641213f, 0.34380236f, -0.06658926f, 
    0.22500476f, 0.09437468f, -0.18576503f, -0.12406256f, -0.24462306f, 0.07945117f, 0.21851164f, -0.08847082f, 
    0.27381268f, 0.25557539f, 0.10808024f, -0.13190708f, 0.20763539f, -0.15657580f, 0.22922483f, 0.23449412f, 
    0.00491257f, -0.03262576f, 0.21638927f, 0.15827939f, 0.10249106f, 0.13352996f, -0.09028377f, -0.10011439f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.15671252f, -0.07704484f, 0.00798159f, -0.09729966f, -0.00618891f, -0.07943741f, -0.01447821f, 0.03148810f, 
    0.01603910f, 0.01148417f, 0.01617889f, 0.00826022f, -0.04605283f, 0.02555671f, -0.01784850f, 0.04239758f, 
    -0.00459538f, -0.02900614f, -0.02574906f, 0.01766428f, 0.04387528f, -0.09809753f, 0.05528504f, -0.08998678f, 
    0.15544166f, -0.11279015f, 0.00168642f, -0.00682301f, 0.08099856f, -0.08980286f, -0.08840209f, -0.01925547f, 
    -0.02136636f, -0.03212469f, 0.01610753f, -0.01418363f, -0.03741987f, 0.04570112f, -0.08481479f, -0.01342911f, 
    0.00770787f, -0.01769688f, 0.15712340f, -0.01496650f, 0.04660213f, -0.04626381f, -0.00244468f, -0.06293111f, 
    0.06849658f, 0.02937383f, -0.01880707f, -0.01868837f, 0.02416512f, 0.01166361f, 0.00015465f, -0.06457414f, 
    -0.03137778f, -0.03282774f, 0.03884083f, -0.04304023f, -0.11129720f, 0.01571003f, 0.02930082f, -0.05693722f, 
    0.00166140f, -0.10349105f, -0.04945092f, 0.01142215f, 0.02589510f, -0.02136733f, 0.07038413f, 0.04167208f, 
    -0.01260808f, 0.02450668f, -0.01572629f, 0.03787762f, -0.04303502f, 0.00157263f, -0.01378051f, -0.03905924f, 
    -0.05775528f, -0.12718627f, 0.06440671f, -0.04128874f, -0.07045714f, -0.03539892f, -0.07065199f, 0.01762413f, 
    -0.03746782f, -0.05669951f, -0.02447561f, -0.01457203f, 0.02590824f, 0.03127271f, 0.05918195f, -0.06816197f, 
    0.00780222f, 0.01923842f, -0.04161251f, 0.02507013f, 0.26051319f, -0.14102533f, 0.07116500f, -0.08228404f, 
    0.19965465f, -0.04626364f, -0.08351881f, 0.03582031f, -0.06533916f, 0.06441386f, 0.03823511f, 0.03373128f, 
    -0.06651353f, 0.10727809f, 0.00752970f, -0.07240227f, -0.07859045f, 0.14186640f, -0.08437250f, -0.03817679f, 
    0.16939601f, -0.05402133f, 0.12303071f, -0.06762674f, 0.15333088f, -0.02550949f, -0.13936201f, 0.03661943f, 
    0.08569075f, -0.02790954f, -0.00413559f, 0.03158047f, -0.03690796f, 0.06584362f, -0.09690674f, 0.11228377f, 
    0.09779489f, 0.01851269f, -0.03933704f, 0.03670077f, -0.02155525f, -0.13473003f, 0.15784109f, -0.09933291f, 
    0.02803694f, -0.06839059f, -0.08090916f, 0.04199594f, -0.02155431f, -0.00973389f, -0.14461827f, 0.02981486f, 
    -0.03562553f, -0.01546263f, -0.02277748f, 0.07768378f, -0.01250564f, 0.01466990f, -0.02896210f, -0.05935906f, 
    -0.02752897f, -0.21436796f, 0.01427436f, 0.10376740f, -0.21419644f, -0.09241943f, -0.04631358f, -0.05099601f, 
    0.02163216f, -0.04537583f, 0.05117330f, 0.08859703f, -0.10983145f, -0.04129618f, -0.05447870f, -0.02974012f, 
    -0.10693234f, 0.03542812f, -0.07750051f, 0.01633888f, 0.09752654f, 0.11413253f, -0.03620116f, -0.07954799f, 
    0.18055516f, -0.17840944f, -0.10693425f, -0.10874694f, 0.02591148f, 0.02113964f, 0.02889597f, 0.00226387f, 
    -0.05551441f, -0.05863302f, 0.03698805f, 0.05838798f, 0.01922521f, -0.03915834f, 0.01924358f, -0.01129356f, 
    -0.30075660f, 0.08705764f, 0.02530082f, 0.13060550f, -0.05496947f, -0.07943189f, 0.01742820f, -0.00004555f, 
    0.11898445f, -0.04987269f, 0.05910556f, 0.02549962f, -0.06461371f, 0.01898972f, -0.01276154f, 0.03320771f, 
    -0.07794334f, -0.11519530f, 0.11564142f, 0.06471837f, 0.00232906f, 0.18713336f, 0.06467874f, -0.13401072f, 
    -0.19583048f, 0.13461865f, 0.05345988f, -0.02721041f, -0.01717699f, -0.01461283f, 0.05319350f, -0.00829669f, 
    0.03607542f, 0.06569283f, 0.00136752f, 0.03029521f, 0.04196712f, -0.03935105f, -0.01438117f, 0.08249125f, 
    0.00616199f, 0.02267962f, 0.06648523f, 0.02305981f, 0.02187305f, 0.01109280f, -0.08919306f, -0.01328303f, 
    -0.04835702f, 0.00821633f, 0.06999145f, 0.07171951f, -0.00116560f, 0.05748161f, -0.09774894f, -0.02987648f, 
    -0.02520766f, 0.04401217f, -0.02675989f, -0.07025785f, 0.11044285f, 0.10571352f, -0.06699707f, -0.09605798f, 
    0.08846145f, -0.10107869f, -0.07832606f, -0.09561995f, 0.02940371f, 0.00098686f, -0.00917492f, -0.01047415f, 
    0.00724561f, -0.02566280f, 0.02768665f, -0.00742506f, 0.03436454f, -0.04286151f, 0.01625871f, 0.00546720f, 
    0.11300657f, -0.28864279f, 0.06641948f, 0.03590295f, -0.35369006f, -0.00432826f, 0.04345613f, 0.01461352f, 
    -0.04101404f, 0.05721116f, -0.14493671f, 0.06802328f, -0.07928583f, -0.01804544f, 0.02615571f, -0.01308522f, 
    -0.05238139f, 0.10317234f, 0.02194232f, 0.03529834f, 0.15214822f, 0.05270788f, 0.00459352f, -0.06407240f, 
    0.16784379f, -0.02887121f, -0.06747045f, -0.18243797f, 0.08014558f, 0.01882880f, -0.06796811f, 0.05564094f, 
    0.03441979f, 0.01446775f, 0.01493425f, 0.00061990f, -0.02743883f, -0.04571567f, 0.05355821f, -0.04296067f, 
    0.14606130f, -0.00571333f, -0.00768772f, 0.00164931f, 0.02903850f, 0.00681342f, -0.02199879f, -0.04482436f, 
    -0.02745397f, -0.12043766f, 0.11379012f, -0.05208239f, 0.02540679f, 0.00543120f, 0.04875108f, -0.02878934f, 
    -0.12017691f, 0.16782610f, -0.09077417f, -0.02222929f, 0.30929491f, -0.36625186f, -0.00575214f, -0.04920134f, 
    0.00110212f, -0.03163520f, -0.07718910f, 0.01995251f, -0.10145254f, -0.00079308f, 0.03953391f, 0.07163730f, 
    0.03093103f, 0.04264793f, 0.10948323f, 0.01610162f, -0.03061849f, 0.07850049f, -0.04720652f, -0.12310088f, 
    0.12606966f, -0.45352343f, -0.10829119f, 0.14300373f, -0.22469789f, -0.07172706f, 0.01130217f, 0.09070243f, 
    0.05080886f, -0.01285434f, 0.04514538f, 0.14906782f, 0.01940952f, -0.05831610f, -0.02178791f, -0.05685109f, 
    -0.08434197f, 0.01080062f, -0.12771204f, -0.02149155f, -0.15028457f, -0.01973745f, 0.06669013f, 0.04148473f, 
    0.09806895f, 0.01422450f, -0.11449178f, 0.05616702f, -0.05435657f, -0.04019957f, 0.00903711f, -0.08167039f, 
    -0.01559891f, -0.01476740f, 0.02252302f, -0.03325386f, 0.00016436f, -0.05034912f, -0.05008389f, 0.02085214f, 
    0.07379583f, 0.02259177f, 0.21705475f, 0.10081930f, 0.17929874f, -0.10408191f, -0.01471074f, 0.09143532f, 
    0.03670681f, 0.01066705f, 0.05749447f, 0.00741735f, -0.00678644f, -0.06135984f, 0.03878580f, 0.03653379f, 
    -0.02492095f, 0.07574426f, -0.04510377f, -0.18262218f, 0.04835989f, 0.15258548f, 0.00068098f, -0.22084381f, 
    0.18790589f, -0.11031967f, -0.07567374f, -0.07518627f, 0.01432048f, 0.07637758f, 0.00832590f, 0.00218178f, 
    0.00372157f, -0.07019728f, 0.06207868f, -0.01559783f, 0.04662081f, 0.02120076f, 0.03533844f, -0.03931051f, 
    0.35664377f, 0.08564887f, 0.24436702f, -0.14391823f, 0.06808417f, -0.03764687f, 0.03564985f, 0.07557335f, 
    0.05202213f, -0.07361668f, -0.00196001f, 0.00843488f, -0.07088763f, -0.05141786f, 0.07258990f, 0.02038624f, 
    0.03741588f, -0.04694563f, 0.01126397f, -0.04831623f, 0.03673735f, -0.05427130f, -0.03393853f, 0.07651226f, 
    -0.03209548f, -0.20710741f, -0.06219027f, -0.09137866f, -0.00308503f, -0.01897765f, 0.01940520f, 0.03093736f, 
    0.10475360f, -0.08561981f, -0.04266247f, 0.04039676f, -0.03971369f, 0.00976864f, -0.01529637f, 0.00268933f, 
    -0.06817628f, -0.21931691f, -0.07566313f, 0.08715276f, -0.02046089f, -0.02363716f, -0.06058389f, 0.00109252f, 
    0.07722958f, -0.00496297f, -0.02395881f, 0.05748259f, -0.05388858f, -0.02449413f, -0.02658215f, 0.03582135f, 
    -0.06744906f, -0.00558667f, 0.04609422f, 0.02835223f, -0.01432600f, -0.14853947f, 0.08035371f, 0.03016401f, 
    0.15175933f, -0.11619267f, 0.03308409f, 0.03129689f, 0.04587035f, 0.02069768f, 0.06131753f, -0.01083439f, 
    0.00293228f, 0.04539511f, 0.05998198f, 0.07187643f, -0.04781021f, 0.05497789f, 0.08123879f, 0.04008229f, 
    0.01702501f, 0.09635016f, 0.03609321f, -0.13576959f, -0.16305751f, -0.01204956f, 0.02533273f, 0.03111250f, 
    0.03683138f, -0.05339396f, -0.00117053f, 0.02522270f, -0.00358730f, -0.00906891f, 0.01851011f, -0.00008801f, 
    0.10726725f, 0.05851222f, 0.06174915f, 0.00255584f, 0.03965661f, -0.10837352f, 0.15294603f, 0.08734734f, 
    0.30836630f, -0.04728311f, -0.06942859f, -0.01907622f, 0.06641031f, -0.07056137f, 0.04023821f, 0.05774396f, 
    0.00184935f, -0.03997421f, -0.02459158f, -0.00204145f, 0.03259998f, 0.06635418f, -0.10459024f, 0.03525922f, 
    -0.11198404f, 0.05739400f, -0.05918161f, 0.02786224f, 0.09619603f, -0.09884675f, 0.03260775f, -0.08196518f, 
    -0.08255177f, -0.01948883f, -0.03991856f, -0.00002502f, 0.15079179f, -0.03879855f, -0.02702239f, -0.02341555f, 
    0.01245842f, -0.06688835f, 0.03401526f, -0.05812973f, -0.29534826f, 0.11065082f, 0.14479552f, -0.05141110f, 
    -0.26191595f, 0.00857111f, 0.00212389f, 0.01264630f, 0.03845112f, 0.02081478f, 0.02089196f, -0.00453082f, 
    0.01746904f, -0.03180127f, -0.03964532f, -0.04934129f, 0.04740147f, 0.04322976f, -0.00091722f, -0.01007692f, 
    0.21958011f, 0.13926180f, 0.04513315f, -0.11134352f, -0.12698308f, 0.12968981f, 0.08969587f, -0.02653174f, 
    0.06184898f, -0.13232414f, 0.11280001f, -0.00693897f, -0.05348131f, 0.06229164f, 0.01187300f, 0.06499182f, 
    0.07819704f, -0.00684590f, 0.01634808f, 0.11918186f, 0.02780159f, -0.00534620f, -0.06217504f, -0.09896518f, 
    -0.15339883f, 0.06435198f, -0.02191030f, 0.06565293f, -0.05909233f, -0.04955832f, 0.01819801f, 0.00767853f, 
    0.02541642f, -0.00757280f, 0.01229662f, -0.00723252f, 0.08934137f, 0.03199638f, -0.04972214f, 0.05835450f, 
    0.19994418f, 0.00004032f, -0.10267463f, -0.13609098f, -0.28376144f, 0.03422776f, 0.09350514f, 0.01763248f, 
    0.04525936f, -0.05505171f, 0.02079858f, -0.02032825f, 0.03659964f, 0.03464606f, -0.02795915f, 0.14473109f, 
    -0.03806753f, 0.09708098f, -0.00614307f, 0.06509392f, 0.06806654f, -0.26274714f, -0.08241484f, 0.03679614f, 
    -0.15319510f, 0.09654289f, -0.03150890f, 0.02109802f, 0.00297671f, 0.00878020f, -0.05171200f, -0.09132268f, 
    -0.03780022f, -0.00589496f, -0.01180271f, 0.06124710f, -0.05563166f, 0.00610585f, -0.08534481f, -0.00139315f, 
    -0.03555633f, -0.01640827f, 0.16831745f, -0.12808140f, 0.20622531f, 0.03404698f, -0.05059944f, -0.00071880f, 
    -0.11756864f, 0.01684556f, -0.05810759f, -0.01321114f, -0.03723716f, -0.10539995f, 0.01707335f, -0.04073443f, 
    -0.01794491f, -0.00615547f, 0.06431916f, -0.07040587f, 0.14640824f, -0.07321317f, 0.02821925f, -0.04116654f, 
    0.25790694f, -0.08745221f, 0.02207004f, -0.00033682f, 0.10848310f, -0.03357254f, -0.03636541f, 0.01091082f, 
    -0.06181680f, 0.02537411f, -0.03311763f, 0.03909161f, 0.01252893f, -0.01533967f, -0.07169443f, 0.07330645f, 
    -0.06206432f, 0.28353018f, -0.08980678f, 0.00733837f, -0.06537376f, 0.06341765f, -0.00039448f, -0.06453691f, 
    0.02877415f, -0.05949664f, 0.06473969f, 0.02884164f, -0.01026498f, 0.04541202f, 0.01636158f, -0.03464998f, 
    -0.07641453f, 0.01642080f, 0.03842023f, 0.00494276f, -0.27722043f, 0.00511860f, 0.22294357f, 0.09974796f, 
    -0.09436112f, 0.02815888f, -0.04888103f, 0.10422011f, -0.04017659f, -0.06423613f, 0.05193438f, 0.00356387f, 
    0.04035066f, -0.00484261f, 0.00648997f, 0.03304034f, -0.05278090f, -0.02281399f, -0.00861501f, -0.01710610f, 
    -0.17369823f, -0.47324392f, 0.04830553f, 0.07347316f, -0.09664157f, 0.01347488f, -0.04940904f, 0.01721033f, 
    0.00714804f, -0.00003618f, -0.05407185f, -0.02233666f, -0.03935393f, -0.00433330f, -0.01610213f, 0.04312697f, 
    0.05709491f, 0.00064877f, 0.04578134f, -0.02547894f, 0.11831210f, -0.01003948f, -0.11191852f, -0.01835028f, 
    0.02961867f, 0.02097839f, -0.04357808f, 0.02578810f, -0.01094916f, -0.01050453f, -0.02111018f, 0.02556616f, 
    0.04590318f, 0.04907855f, 0.02049098f, 0.01908307f, -0.01032716f, -0.03814775f, -0.05832531f, 0.02427678f, 
    -0.19224551f, -0.20071326f, -0.07351170f, -0.07588525f, -0.12029464f, 0.02742773f, -0.03497340f, 0.04373583f, 
    0.00701770f, 0.02133181f, -0.01991027f, -0.07217476f, -0.02720957f, -0.05650974f, 0.05673122f, -0.04792954f, 
    0.00444612f, -0.01013797f, 0.02932100f, 0.05220125f, -0.01203952f, 0.01157830f, 0.06730299f, -0.01273690f, 
    -0.05603448f, -0.15888378f, -0.07700830f, 0.04190684f, -0.03210417f, 0.01321342f, 0.01782116f, 0.01553942f, 
    -0.04912135f, 0.00339640f, -0.02635799f, 0.06804281f, 0.02443459f, 0.01054479f, -0.05358338f, 0.00066097f, 
    0.14471909f, -0.15041021f, 0.20728137f, -0.07995932f, 0.03472117f, -0.12908742f, 0.11319829f, -0.00317222f, 
    0.05150022f, 0.01778245f, -0.02153697f, 0.04058860f, 0.04941746f, -0.00327727f, 0.02019342f, 0.07990501f, 
    -0.01400685f, 0.01230670f, -0.12708436f, -0.01533275f, 0.19374970f, -0.27238262f, 0.15026566f, 0.00404516f, 
    -0.25805503f, 0.08765940f, 0.14647271f, 0.01335159f, -0.01009812f, 0.01578952f, -0.01194154f, -0.02099054f, 
    0.04773499f, -0.00389739f, -0.04997383f, 0.01728420f, -0.05643079f, -0.02385260f, 0.06598786f, -0.07524201f, 
    0.17860796f, -0.23660995f, -0.02190300f, 0.16032097f, -0.36923477f, 0.04269934f, -0.03803685f, -0.08626447f, 
    0.00334568f, 0.03154688f, -0.00975679f, 0.06099300f, 0.02856761f, 0.01058010f, 0.08868338f, -0.03777029f, 
    -0.15051407f, -0.08650193f, 0.05016221f, 0.08497023f, -0.25125712f, 0.15709828f, 0.10477563f, 0.09456772f, 
    0.23362334f, -0.04700711f, -0.16957468f, 0.02989736f, -0.02032313f, -0.00173804f, -0.02136089f, -0.10726382f, 
    -0.07427843f, 0.06496619f, -0.03003857f, -0.03724672f, -0.01184682f, -0.00119020f, -0.08759356f, 0.02480106f, 
    0.07501207f, -0.01492165f, 0.19042452f, 0.04631415f, 0.01669108f, -0.02798177f, -0.01051141f, 0.08389063f, 
    -0.00662988f, 0.01247998f, -0.05795855f, -0.08793421f, 0.02519056f, -0.11156897f, 0.05487103f, 0.02311801f, 
    -0.00102190f, -0.11052798f, 0.01220325f, 0.02369811f, 0.01572143f, 0.05278640f, 0.03798915f, -0.24504274f, 
    0.07524564f, -0.03688487f, -0.11887264f, -0.06967837f, 0.02216928f, -0.04487836f, 0.00584973f, 0.00487535f, 
    0.05037340f, 0.03791527f, 0.01083114f, 0.06688912f, -0.00403913f, -0.00687593f, -0.09081247f, 0.08657005f, 
    0.01290707f, 0.12585635f, 0.03231600f, -0.11821848f, 0.14237225f, -0.07746302f, -0.11940365f, 0.01911279f, 
    0.03291670f, -0.02214545f, -0.04436572f, 0.00864433f, -0.03388550f, -0.00385478f, 0.02659367f, -0.04124033f, 
    -0.03126136f, 0.00729727f, -0.01294722f, -0.00176082f, -0.25374150f, -0.05468143f, -0.11247873f, 0.00197619f, 
    -0.12807921f, 0.01014668f, -0.04223697f, 0.05135894f, 0.01908330f, -0.00679524f, 0.00334509f, -0.01396235f, 
    -0.06452332f, -0.01472573f, 0.03436082f, -0.00900225f, -0.06673583f, 0.00605937f, -0.00711582f, 0.02145835f, 
    -0.00638224f, 0.02588124f, -0.17750235f, -0.11677394f, -0.29674497f, 0.06747171f, 0.06281480f, -0.02748646f, 
    0.03131954f, -0.01928977f, 0.01846231f, -0.06866321f, -0.02142978f, 0.02953642f, -0.03586889f, 0.00429734f, 
    -0.06169805f, -0.00970690f, -0.04830062f, -0.00051258f, 0.26507008f, 0.26590270f, 0.10503256f, -0.22859047f, 
    0.16474545f, 0.04432423f, -0.02529582f, -0.00873174f, 0.04342343f, -0.00739662f, -0.03325178f, -0.01950907f, 
    -0.01973656f, -0.01459387f, 0.09650006f, -0.02077245f, 0.03169075f, -0.06233123f, 0.02371811f, -0.03277573f, 
    -0.12746304f, -0.05149766f, -0.10333820f, 0.11296616f, -0.05835903f, -0.02620119f, 0.04221874f, -0.00994010f, 
    0.04417842f, -0.01525102f, -0.03941754f, -0.02988585f, -0.01605903f, -0.01996154f, -0.06429073f, 0.01846295f, 
    0.01526137f, 0.01825036f, -0.01889138f, 0.01884359f, 0.32601368f, 0.09285654f, 0.28556219f, -0.10736719f, 
    -0.33877176f, 0.00273042f, 0.05445081f, -0.02054091f, 0.01786032f, -0.05646396f, -0.03994877f, 0.01967004f, 
    -0.08840954f, 0.04480832f, 0.00033665f, 0.03980068f, -0.05583105f, 0.06077918f, -0.03300457f, 0.04174738f, 
    -0.23194110f, -0.27438632f, 0.03399378f, 0.05214607f, -0.01971259f, 0.02951248f, -0.01198460f, -0.11553466f, 
    0.02755874f, 0.05197544f, -0.00373329f, -0.04292166f, 0.01695377f, 0.02280717f, 0.01498565f, -0.00718020f, 
    0.07900557f, 0.03798402f, -0.01205715f, -0.08153311f, -0.16850600f, 0.10119473f, 0.04357241f, -0.08382615f, 
    -0.24845259f, 0.03084012f, 0.01442277f, 0.01213849f, 0.06491890f, -0.04484862f, -0.03369501f, 0.00157804f, 
    0.02724774f, -0.01480847f, -0.00430343f, 0.02141978f, 0.08808957f, 0.04768604f, 0.02364859f, -0.03695890f, 
    0.40106875f, 0.04091816f, 0.04254081f, -0.14916447f, 0.11118911f, -0.04665911f, -0.07426539f, 0.00401586f, 
    -0.06553490f, -0.00928677f, 0.09230055f, -0.02286639f, -0.07555160f, 0.06735490f, 0.05248803f, -0.07453191f, 
    -0.09332483f, 0.03210826f, -0.03269305f, -0.00363844f, -0.24603939f, -0.18226029f, 0.10314740f, 0.11793104f, 
    -0.08565252f, 0.05088039f, -0.05060556f, 0.01143476f, 0.05328656f, 0.02423426f, 0.00821146f, -0.01076253f, 
    -0.00711919f, 0.01072475f, -0.04273771f, -0.01758551f, -0.02119201f, 0.07194423f, -0.01694487f, 0.07025979f, 
    -0.08235928f, 0.04960290f, -0.07866535f, 0.03415459f, 0.06239087f, -0.03606682f, -0.06811877f, -0.10324172f, 
    -0.06329909f, -0.02801223f, 0.02985604f, -0.06685250f, 0.04835681f, 0.02731636f, 0.01079744f, -0.02679214f, 
    -0.03940384f, -0.03191026f, -0.08634215f, -0.03419803f, 0.04604442f, 0.11486577f, 0.05523996f, -0.15688320f, 
    0.11778303f, -0.13758154f, -0.04327115f, -0.08038783f, 0.05585824f, 0.01805113f, 0.01435641f, -0.03707344f, 
    0.00156083f, -0.00634084f, -0.04560157f, 0.00604257f, -0.03596054f, 0.06173357f, 0.04778566f, -0.01511606f, 
    0.11157054f, -0.07201819f, -0.09638811f, 0.01407691f, -0.15650582f, -0.07381073f, -0.00960859f, -0.03781839f, 
    -0.01926406f, -0.04922062f, -0.00967623f, 0.00167372f, -0.02127974f, 0.01583082f, -0.08242563f, -0.05217844f, 
    -0.02359036f, 0.05632082f, 0.07589705f, 0.04379113f, -0.27928627f, 0.14845581f, -0.17471337f, -0.01024303f, 
    -0.26360452f, -0.00951761f, 0.00103937f, -0.01045268f, 0.04387309f, 0.03241782f, 0.01675334f, -0.02882846f, 
    -0.09444432f, 0.02818402f, 0.03643833f, -0.04213460f, -0.07842769f, -0.03852612f, 0.05024996f, 0.02185446f, 
    -0.06223139f, 0.08013275f, 0.16345906f, -0.22079451f, 0.17491558f, -0.03886717f, -0.06716046f, -0.01842255f, 
    -0.16225818f, 0.01519083f, -0.08327425f, -0.12799378f, 0.00060179f, -0.03591735f, 0.00072410f, -0.05473205f, 
    0.01237893f, -0.05996371f, -0.07149822f, -0.05234589f, 0.25174943f, 0.01590558f, 0.13386035f, 0.01260628f, 
    0.09507521f, -0.16396186f, -0.08617761f, -0.20652135f, 0.00471054f, -0.00892689f, -0.10176987f, 0.01129216f, 
    0.10262366f, -0.11562274f, 0.09979774f, -0.02824821f, 0.04744359f, -0.08741835f, 0.08152159f, 0.04385946f, 
    0.12137330f, -0.01397923f, 0.15187277f, 0.04677986f, 0.06087032f, -0.07696387f, -0.05678567f, 0.00799172f, 
    -0.00729781f, 0.04205857f, -0.06149210f, -0.04156141f, 0.00209403f, 0.02150193f, -0.06368458f, -0.03274886f, 
    0.06942374f, 0.00793629f, 0.03748360f, 0.08988087f, 0.19820416f, -0.20463978f, 0.11389824f, -0.01451662f, 
    0.09255376f, -0.05203701f, -0.07783546f, -0.01833703f, -0.00820628f, -0.01128105f, 0.02154685f, -0.00053493f, 
    -0.00892513f, 0.05155102f, 0.01061160f, -0.07590486f, 0.03158831f, 0.03436619f, 0.05270651f, 0.08821373f, 
    0.11838537f, -0.07772237f, -0.11105761f, -0.08614070f, 0.01105895f, -0.00561488f, -0.10337979f, 0.10026778f, 
    0.02860511f, -0.06260082f, -0.12847753f, -0.02181172f, -0.02051746f, 0.03542840f, 0.07103133f, -0.01006139f, 
    -0.04966038f, -0.09756719f, -0.08737137f, -0.01077624f, 0.09382270f, 0.01111582f, 0.22457242f, -0.05690446f, 
    0.07095684f, -0.06776721f, -0.03956434f, -0.06168926f, -0.05581681f, -0.03460107f, -0.07269839f, -0.04639631f, 
    -0.00940714f, -0.00920903f, 0.02877202f, -0.02218893f, 0.03796569f, 0.02615337f, 0.00037338f, 0.03869533f, 
    -0.03948572f, 0.12275679f, 0.11802036f, 0.01772667f, 0.06421793f, -0.11746331f, -0.00108923f, 0.01262116f, 
    -0.00914227f, 0.06429859f, 0.03248985f, -0.01016829f, -0.03179469f, -0.06787637f, -0.00002359f, 0.01758370f, 
    -0.00419500f, 0.01378856f, 0.00534063f, 0.05315740f, -0.36897784f, -0.25413957f, -0.19169040f, -0.22314014f, 
    0.11205228f, 0.02605081f, -0.06205957f, 0.01057370f, -0.06980789f, 0.07294565f, 0.08895602f, 0.06581790f, 
    0.10887393f, -0.15294321f, 0.09397597f, -0.08996142f, -0.08112367f, -0.14890419f, -0.10620251f, -0.05416190f, 
    0.06916227f, -0.15157546f, 0.04644291f, -0.15511359f, 0.22586036f, -0.13273804f, -0.05963019f, 0.03515183f, 
    0.00192119f, -0.05322950f, -0.05440866f, -0.05566875f, -0.01970181f, -0.04379430f, -0.02165047f, -0.04137117f, 
    -0.09064567f, -0.13220155f, 0.07215632f, -0.03813676f, -0.12139351f, -0.03120704f, 0.05831514f, -0.12382596f, 
    0.16740057f, -0.00895124f, -0.01819970f, 0.04348136f, -0.01602672f, 0.01040007f, 0.06669097f, 0.03103953f, 
    0.08848047f, -0.00289656f, -0.01134268f, -0.04766375f, -0.03898576f, -0.14720969f, -0.00362053f, -0.03121318f, 
    0.09010246f, -0.10713578f, -0.12398778f, 0.14728214f, -0.01673368f, -0.03033697f, -0.03518777f, -0.01166752f, 
    0.00840797f, 0.04812361f, 0.11162058f, 0.03900494f, 0.01485611f, 0.01208021f, -0.00106710f, -0.01101506f, 
    -0.04918794f, -0.06360670f, -0.08596405f, 0.03075918f, 0.06989581f, 0.16264701f, -0.07533214f, 0.09043400f, 
    0.05384471f, 0.03823218f, -0.01816760f, 0.02725370f, 0.06104114f, 0.00848427f, 0.00324951f, -0.01268137f, 
    0.03331017f, 0.04500035f, -0.09421150f, -0.00107479f, 0.06974237f, 0.02186417f, -0.06279998f, 0.04562765f, 
    -0.22068405f, 0.06047104f, -0.06413531f, -0.03653916f, -0.25753716f, 0.06756758f, -0.01825774f, -0.08324558f, 
    -0.07663303f, -0.02606281f, -0.00534422f, 0.03350141f, -0.09940304f, -0.04597029f, -0.09423155f, -0.01500895f, 
    -0.04583805f, 0.05195580f, -0.07287415f, -0.05065854f, 0.14010389f, -0.08093357f, -0.08119947f, 0.05049969f, 
    -0.09143308f, -0.05672770f, 0.02317366f, -0.09670337f, -0.05045350f, 0.01125729f, 0.11304565f, 0.05984387f, 
    -0.03787034f, -0.07694633f, -0.00105087f, 0.01662493f, 0.02248105f, 0.00412052f, 0.01769909f, 0.02184320f, 
    -0.07972205f, -0.11960220f, -0.26815474f, -0.17573027f, 0.01500400f, 0.04783664f, -0.03499749f, 0.06391951f, 
    -0.03417645f, -0.00502671f, -0.00685751f, 0.04055526f, -0.04889133f, -0.08010934f, -0.02598447f, 0.00388747f, 
    -0.06193688f, 0.02762700f, -0.01056471f, -0.12144868f, 0.19914986f, 0.15975881f, -0.04999219f, 0.10049810f, 
    0.10851616f, 0.06513211f, -0.04220308f, 0.04478359f, 0.03600532f, -0.01500719f, 0.01805474f, 0.01151273f, 
    -0.03599084f, 0.06109422f, -0.00004455f, 0.08454204f, 0.01930272f, 0.01148163f, -0.03177936f, -0.00691692f, 
    0.08511567f, 0.12320011f, 0.15910633f, -0.07115257f, -0.13601570f, -0.07207692f, 0.00500116f, 0.05831848f, 
    0.00712562f, 0.07244572f, 0.09529484f, -0.01153419f, 0.07329964f, 0.00716360f, -0.00078945f, 0.03783002f, 
    0.02726366f, -0.06191724f, 0.05976285f, 0.10362341f, 0.28970405f, 0.06668702f, 0.07756303f, 0.03110957f, 
    0.01321095f, 0.01547632f, -0.10277337f, 0.04160567f, -0.01009839f, -0.02290187f, -0.04279613f, -0.04751368f, 
    -0.05031810f, 0.04220273f, 0.00520903f, 0.01521856f, 0.04223674f, 0.02690565f, 0.01527402f, 0.06235299f, 
    -0.18711877f, 0.10108055f, -0.05428969f, -0.19049343f, 0.09814259f, -0.00766863f, 0.01715418f, 0.03366273f, 
    -0.02488826f, 0.00794602f, -0.05007518f, -0.15794550f, 0.00265173f, -0.05798433f, 0.10805540f, 0.02455456f, 
    0.02559967f, -0.01112858f, 0.16489580f, -0.09323450f, -0.35054439f, 0.00247426f, -0.02866954f, -0.03412212f, 
    0.16011827f, 0.10033457f, -0.02066667f, 0.06068918f, 0.00989347f, 0.01289755f, -0.03355468f, -0.01442270f, 
    -0.02834343f, -0.05654010f, -0.04275248f, 0.08359876f, -0.05100091f, -0.11893596f, 0.01079913f, 0.02158684f, 
    -0.06194400f, -0.09606404f, -0.03861952f, 0.01996678f, -0.01484902f, 0.00640662f, 0.00222685f, 0.00004666f, 
    0.00880606f, 0.07759195f, -0.06009017f, -0.15996628f, 0.01556472f, 0.00171136f, -0.01897472f, -0.01758588f, 
    -0.02647656f, -0.01391723f, -0.08439687f, 0.14680754f, 0.05462609f, 0.20817602f, 0.01823999f, 0.02115474f, 
    0.07509410f, -0.12804081f, 0.02041557f, 0.05449986f, 0.00011181f, 0.05139659f, 0.03082724f, 0.05174386f, 
    0.02502303f, -0.04615521f, 0.03225173f, 0.06181321f, 0.01755591f, 0.04874938f, -0.02330609f, 0.03043789f, 
    -0.09834760f, -0.10986274f, -0.39080039f, -0.41100711f, 0.04121507f, -0.00204772f, 0.01095570f, -0.01862262f, 
    -0.03679256f, -0.04318007f, 0.13788646f, -0.08046611f, 0.04719475f, -0.02398609f, -0.04493246f, -0.08828814f, 
    -0.07462248f, -0.13503736f, 0.01599943f, 0.02440734f, 0.08283744f, 0.14095688f, -0.05393231f, 0.12831324f, 
    0.06290246f, -0.00478803f, -0.06668159f, 0.03141980f, -0.00556008f, -0.01293180f, 0.02247354f, -0.00332378f, 
    -0.00728696f, 0.07712842f, -0.11718912f, -0.02185599f, 0.05104521f, 0.02419785f, -0.04964017f, 0.05114549f, 
    -0.33736995f, -0.07132980f, -0.07193372f, -0.05130001f, 0.13669060f, -0.05476873f, 0.02269231f, -0.08044762f, 
    -0.01854773f, 0.02080936f, 0.09475836f, 0.04091183f, -0.06670906f, -0.04884832f, 0.05489562f, 0.10026795f, 
    -0.02099766f, 0.02917797f, -0.01108139f, 0.01725443f, 0.18668167f, -0.00673385f, 0.04360567f, 0.07566769f, 
    0.17424923f, -0.01286284f, -0.03802243f, 0.01249814f, -0.02017502f, 0.00450019f, -0.00985633f, 0.04986927f, 
    -0.14774776f, 0.01395667f, -0.09364744f, -0.06541056f, -0.08853485f, 0.03276537f, -0.00970757f, 0.06535500f, 
    -0.05807478f, 0.00409981f, -0.06939166f, -0.04731102f, -0.08230996f, -0.06238864f, 0.03446515f, -0.05709448f, 
    -0.01898097f, 0.04944613f, 0.00184367f, -0.04586251f, 0.00838225f, -0.01195076f, 0.02904439f, -0.01854463f, 
    0.03060677f, -0.03180731f, -0.21743634f, -0.09856495f, 0.06854973f, -0.21473561f, 0.06858766f, -0.05695871f, 
    0.08446719f, 0.09924342f, -0.07230106f, 0.06044351f, -0.06881398f, -0.02029273f, 0.05217841f, 0.10410269f, 
    0.02003565f, 0.02577541f, 0.00010866f, 0.00287246f, 0.00806586f, -0.21774389f, 0.01268986f, -0.03504601f, 
    0.19262588f, -0.13465132f, -0.22036700f, 0.04962220f, -0.09373014f, 0.05379618f, -0.01194766f, -0.01056372f, 
    0.00274879f, 0.11480822f, 0.00804600f, 0.01873977f, -0.07027900f, -0.01754007f, -0.01219523f, 0.12344960f, 
    0.06591712f, -0.01371269f, -0.02504035f, -0.00551011f, 0.21098088f, -0.43057865f, 0.06238854f, -0.12808064f, 
    -0.05653756f, 0.06804373f, -0.03674653f, -0.07324652f, 0.06660515f, -0.05607963f, -0.03140254f, -0.00399793f, 
    -0.04353508f, -0.07038891f, 0.01109429f, -0.10323177f, 0.05651559f, -0.13079697f, 0.08041784f, 0.00932420f, 
    0.22531779f, -0.57071710f, 0.13595238f, -0.20444562f, 0.01155449f, -0.13811670f, 0.01644917f, -0.09736064f, 
    0.05099217f, -0.06379450f, -0.09420861f, 0.03539387f, -0.11404629f, 0.06133458f, -0.05144817f, -0.01516732f, 
    -0.06302524f, 0.09698188f, 0.11186716f, -0.03642288f, 0.24163486f, -0.13068978f, -0.18793279f, -0.00955675f, 
    -0.13245305f, -0.03230261f, 0.03705524f, 0.05224464f, -0.02077667f, 0.08254502f, 0.00752976f, 0.00311960f, 
    0.00442047f, 0.03685983f, 0.02821641f, 0.03660443f, 0.05109426f, 0.02127213f, -0.03016378f, 0.12324138f, 
    -0.06815983f, -0.01563706f, -0.08715651f, 0.01863344f, -0.10627389f, 0.03344531f, -0.00971276f, -0.16661581f, 
    -0.09182010f, 0.00208823f, 0.11392184f, 0.08294735f, 0.01895997f, -0.05221217f, 0.04576917f, -0.01774399f, 
    -0.00017298f, -0.02104746f, 0.00204665f, 0.07521183f, 0.22780424f, -0.13815096f, -0.03759213f, -0.06012098f, 
    -0.16676930f, 0.03469784f, 0.06690665f, -0.03574822f, 0.06715617f, 0.01406586f, 0.02396022f, -0.04467666f, 
    0.02804663f, 0.02520463f, -0.02263810f, 0.05510241f, 0.08673486f, 0.01741451f, 0.00883305f, 0.01040017f, 
    0.07673147f, -0.08492869f, -0.00102020f, -0.03131893f, -0.15189746f, 0.00641604f, 0.07604863f, 0.01176227f, 
    -0.00726327f, 0.12492889f, 0.12254424f, -0.07027728f, 0.06756593f, 0.03825612f, -0.05880326f, -0.02166069f, 
    0.11336768f, -0.06087285f, -0.03846230f, -0.00407151f, 0.02619432f, 0.05838115f, -0.00346625f, -0.13618949f, 
    -0.01236034f, -0.04014748f, -0.09458242f, 0.04011291f, 0.02057247f, -0.03523762f, 0.07562534f, 0.02180278f, 
    0.07477614f, -0.00104078f, -0.03594087f, -0.12666823f, 0.06865557f, -0.17486773f, -0.08853167f, -0.03913778f, 
    -0.19232318f, 0.10312338f, -0.21321799f, -0.24618271f, 0.12175351f, -0.14359583f, 0.10010936f, 0.02051272f, 
    0.06874903f, 0.04395468f, 0.13072848f, -0.03185176f, 0.05183154f, 0.08394472f, -0.05073507f, -0.04376982f, 
    0.04657023f, 0.09080823f, -0.13134590f, 0.06377273f, 0.13309577f, -0.09594492f, 0.14140692f, -0.00909279f, 
    0.10777930f, 0.01699119f, -0.09942764f, -0.06881007f, -0.00247204f, -0.04857175f, 0.01524528f, -0.01270280f, 
    -0.03290052f, 0.01172874f, -0.05528113f, -0.06420165f, 0.05218660f, 0.04877648f, 0.07789691f, -0.10613762f, 
    0.13507496f, -0.05368521f, -0.01355851f, 0.00758126f, -0.14392236f, -0.00068073f, 0.05378201f, -0.08125158f, 
    0.07153603f, 0.05413390f, -0.04614707f, -0.03372347f, -0.01386885f, -0.02622193f, 0.08428476f, 0.01565540f, 
    -0.05781598f, 0.05631610f, -0.09370223f, -0.02152141f, -0.27987710f, 0.18524832f, 0.02466203f, -0.05865731f, 
    0.08818094f, -0.19076581f, -0.00657289f, -0.01014813f, -0.05145596f, 0.12438457f, -0.01750675f, 0.01195929f, 
    -0.05109215f, -0.09996120f, -0.04546861f, -0.05340158f, 0.02763993f, 0.03284200f, -0.05848688f, 0.12255125f, 
    0.04401536f, 0.01013651f, 0.02240116f, 0.00148173f, -0.06824049f, -0.01193067f, 0.04393737f, 0.06761008f, 
    0.04208059f, 0.09403355f, -0.09064399f, -0.07195637f, 0.05551493f, 0.06393174f, 0.01844478f, -0.02775457f, 
    -0.01082108f, -0.17485574f, -0.14334767f, -0.02062569f, 0.32535198f, 0.26278147f, 0.03626278f, 0.03095422f, 
    0.03313801f, -0.03189010f, -0.00898714f, 0.03751548f, 0.00193869f, 0.07902254f, 0.10424168f, -0.08968832f, 
    -0.00020039f, -0.06005799f, -0.06207990f, -0.06292839f, 0.08077060f, 0.05888518f, 0.06290926f, 0.04106947f, 
    0.10385948f, -0.04990974f, -0.00363275f, -0.01611219f, 0.00093088f, 0.02164136f, 0.00251637f, 0.03641206f, 
    0.09913712f, 0.12036534f, -0.10109971f, -0.03852818f, 0.05453157f, 0.04505176f, -0.00130371f, 0.11003391f, 
    0.08421896f, -0.02517988f, -0.08977987f, 0.00527416f, 0.03269829f, 0.04520438f, 0.04630890f, -0.00501940f, 
    0.11893710f, 0.05668093f, -0.01840906f, 0.03785048f, -0.00649672f, -0.03091545f, -0.08140104f, 0.01028020f, 
    0.05218840f, 0.02194606f, -0.03444415f, -0.02514968f, -0.07822312f, -0.02835031f, -0.01204738f, 0.02496632f, 
    -0.09449830f, 0.07215834f, 0.15155086f, -0.03295702f, 0.28057483f, -0.00248004f, -0.13208999f, 0.02305397f, 
    -0.05602217f, 0.00028693f, -0.00226950f, -0.04219569f, 0.01454705f, 0.02650918f, -0.08405837f, -0.15694226f, 
    0.06523445f, -0.00758539f, 0.08970453f, 0.06426739f, -0.26936617f, 0.20423296f, 0.01217278f, -0.04275077f, 
    0.07260444f, 0.00781140f, -0.10281389f, -0.04084871f, -0.11666375f, 0.05295269f, 0.11582644f, 0.03421330f, 
    0.00617881f, -0.00285477f, 0.00237594f, -0.08659980f, 0.06286361f, -0.08911389f, 0.06232068f, 0.10093085f, 
    0.05299553f, -0.43225953f, -0.02821579f, -0.00557606f, 0.08156791f, 0.02147458f, -0.00253885f, 0.10575762f, 
    0.06606679f, -0.03942701f, 0.00561477f, 0.03727867f, -0.00134661f, -0.05240026f, -0.03885049f, 0.08258865f, 
    -0.14829770f, 0.10697071f, -0.02525399f, -0.11984766f, 0.19736138f, 0.09381262f, -0.06392426f, -0.01063184f, 
    0.14968750f, -0.05895571f, 0.03320258f, 0.00908648f, -0.10766846f, 0.05839515f, 0.03893851f, -0.01279777f, 
    0.13446505f, 0.00326675f, 0.06429068f, 0.03325629f, -0.06665841f, 0.01835564f, 0.00064240f, -0.00970079f, 
    -0.09731093f, 0.12992631f, -0.03119841f, 0.05439479f, 0.06702560f, -0.00612763f, 0.03608367f, 0.01560825f, 
    -0.09589501f, 0.02682505f, -0.00231987f, 0.12506202f, 0.00217857f, 0.03677581f, -0.00472362f, 0.06375878f, 
    -0.06093990f, 0.08965993f, 0.01895438f, 0.01820089f, 0.06068103f, 0.07447132f, 0.08448549f, 0.04313597f, 
    0.14663149f, -0.03760576f, -0.11174727f, -0.02403972f, -0.00943644f, -0.02528452f, -0.10142908f, 0.04611395f, 
    -0.02034279f, 0.04099982f, 0.05631859f, 0.04111315f, -0.03282051f, 0.04756615f, -0.06404187f, -0.02601987f, 
    0.09037805f, 0.14360000f, 0.01865515f, 0.04953730f, 0.16043124f, -0.04771480f, 0.01687630f, 0.06529462f, 
    0.01082688f, 0.01254611f, -0.02120179f, -0.02016478f, 0.02790654f, -0.01208743f, -0.06818962f, 0.01532109f, 
    0.00858366f, 0.02606487f, -0.04055459f, 0.00989309f, 0.15786642f, 0.02923126f, -0.01248054f, 0.01044061f, 
    -0.06782315f, 0.04147475f, 0.03317777f, 0.12823655f, 0.10453244f, 0.05891839f, -0.05565436f, -0.07295947f, 
    0.04542382f, 0.00020295f, 0.02445292f, 0.14168060f, 0.04276199f, -0.02750790f, 0.00562400f, -0.10326798f, 
    0.16387352f, 0.04066574f, -0.03064535f, -0.00595080f, -0.24317996f, -0.02467487f, -0.03686940f, 0.05172663f, 
    0.06669558f, 0.09196586f, 0.02875486f, 0.03914177f, 0.02121277f, 0.02951959f, 0.02432878f, -0.00965019f, 
    0.04622732f, -0.07026656f, -0.03101104f, -0.06156223f, -0.03176062f, -0.03874153f, -0.14448108f, -0.17174399f, 
    -0.06378787f, 0.02205876f, 0.15142950f, -0.06804867f, 0.02276316f, -0.03653744f, 0.06998602f, -0.13073719f, 
    0.07866143f, 0.00721772f, 0.05346702f, 0.03297220f, -0.04906696f, 0.04858162f, -0.06534818f, 0.08759408f, 
    -0.46398330f, 0.02853416f, -0.08557735f, -0.05789242f, -0.26704878f, 0.01825118f, -0.04287169f, -0.05579951f, 
    0.03629706f, -0.00559146f, -0.04114015f, -0.00898961f, 0.03981368f, -0.02387305f, 0.01548791f, -0.11381288f, 
    -0.07640360f, -0.04418604f, -0.07732676f, 0.05113928f, -0.19159096f, -0.05416381f, -0.23116472f, 0.01552376f, 
    -0.07685493f, -0.02275790f, 0.02101485f, -0.00773082f, 0.01579274f, -0.03363814f, 0.00109177f, 0.05309983f, 
    -0.01433869f, -0.02382072f, 0.01656648f, -0.02339474f, 0.05094436f, -0.05029641f, 0.08024845f, -0.07398318f, 
    -0.13219060f, 0.03188966f, 0.04904682f, -0.02493361f, -0.13410823f, 0.15982743f, 0.00541881f, 0.12061337f, 
    0.08120666f, -0.04368135f, -0.03083790f, 0.01340129f, -0.00452941f, 0.05939691f, -0.08836105f, 0.02474711f, 
    -0.11318605f, -0.07914595f, 0.06098498f, -0.08243280f, 0.22723156f, -0.11848357f, -0.23580214f, 0.06267105f, 
    -0.09086224f, -0.01126040f, 0.01565672f, -0.05547141f, 0.03865602f, 0.12179321f, 0.00998723f, -0.00904357f, 
    -0.02926295f, -0.00918834f, -0.02372344f, 0.14368807f, 0.10202245f, -0.06065547f, 0.00280190f, 0.01925620f, 
    -0.43872005f, -0.09345319f, -0.03775128f, -0.06610939f, 0.08586051f, 0.03186263f, 0.02697462f, -0.02738783f, 
    0.04989403f, 0.00920737f, 0.03655418f, 0.01056257f, 0.08366647f, -0.08962023f, 0.10121679f, -0.01495699f, 
    -0.03522348f, -0.01962776f, -0.02163369f, -0.14390676f, -0.04087633f, 0.18137951f, -0.08828317f, -0.04819990f, 
    -0.53848189f, 0.05220957f, 0.01040589f, 0.01713799f, -0.04727482f, -0.03048805f, -0.04059567f, 0.10123371f, 
    -0.05266075f, 0.04419291f, 0.07547578f, 0.00222960f, -0.04121614f, -0.05457808f, -0.03006736f, -0.10111239f, 
    -0.16012837f, 0.16025572f, -0.01960547f, 0.00087192f, 0.04124080f, -0.00668304f, -0.04495092f, -0.00311637f, 
    -0.00711726f, 0.02177841f, -0.00986377f, 0.01652809f, -0.03227613f, 0.01031935f, -0.06484353f, 0.02854968f, 
    -0.09206976f, 0.02510854f, -0.01197326f, 0.04595092f, 0.24148156f, -0.08656934f, 0.05447900f, 0.02254459f, 
    -0.03272453f, 0.00636898f, -0.11311876f, 0.04854736f, 0.01350580f, -0.03681351f, -0.01660147f, 0.01581747f, 
    -0.05311172f, 0.06399009f, 0.03385209f, 0.01330651f, -0.03267672f, -0.02467169f, -0.09726261f, -0.07675687f, 
    -0.22482663f, -0.02108865f, 0.05494295f, -0.03393160f, -0.13996404f, 0.02040706f, -0.03462232f, -0.00124751f, 
    0.01920656f, -0.02389623f, 0.08559906f, 0.03106058f, 0.05170431f, 0.02816201f, 0.00314273f, 0.00533626f, 
    0.03224228f, -0.11700479f, -0.02797921f, -0.02297257f, 0.23952530f, -0.02087947f, -0.08271348f, 0.11654249f, 
    -0.15614040f, -0.02716114f, -0.02293048f, 0.01328257f, 0.11049714f, 0.08952843f, 0.00891775f, -0.04832922f, 
    0.02514373f, 0.04483018f, 0.01177816f, 0.06204631f, 0.04950506f, -0.00891642f, -0.06956118f, -0.03498523f, 
    -0.11377384f, -0.15336014f, 0.00928300f, -0.07252543f, 0.12781200f, 0.07816560f, -0.04931391f, -0.03713045f, 
    0.03134960f, -0.09357835f, 0.06650474f, 0.06775842f, -0.05362841f, 0.03702733f, 0.00025599f, -0.07225974f, 
    0.10370255f, 0.02715510f, 0.08915143f, -0.09069581f, 0.05798117f, 0.04749391f, 0.00148474f, 0.11247221f, 
    -0.05749914f, -0.03339161f, -0.11038033f, 0.06615936f, 0.04149112f, -0.04865041f, 0.03494762f, 0.00725677f, 
    -0.07939831f, 0.16646078f, -0.12361772f, 0.05207703f, -0.14363392f, -0.06708246f, -0.03256296f, -0.07706946f, 
    0.03387246f, -0.01023614f, 0.08829550f, -0.06851338f, 0.09330501f, 0.03797118f, -0.02467617f, 0.04961402f, 
    0.03905671f, -0.00601754f, -0.00167117f, 0.03108913f, 0.04555520f, 0.03695209f, -0.00192211f, 0.05209374f, 
    -0.03481004f, -0.05526727f, -0.03956085f, 0.00888160f, 0.13673104f, -0.04502725f, -0.00410861f, -0.06690355f, 
    -0.03338426f, 0.01653704f, -0.07413089f, 0.07312354f, 0.09497742f, -0.00075003f, 0.01059653f, -0.05790704f, 
    0.00929840f, 0.04092693f, -0.02931361f, -0.00044172f, 0.01997893f, -0.02062274f, -0.00527507f, -0.03089081f, 
    -0.18724275f, 0.06365770f, -0.05144751f, -0.15046982f, -0.05797713f, 0.08838483f, 0.01407352f, 0.05635354f, 
    -0.07134012f, -0.03009279f, 0.02299097f, 0.05105021f, -0.00903418f, -0.11186437f, -0.03092081f, 0.00341079f, 
    0.03458066f, 0.10911710f, -0.05371257f, -0.03560895f, 0.08082446f, -0.01684158f, 0.01460057f, -0.03435214f, 
    0.02312197f, 0.02551218f, 0.03824484f, -0.00311325f, -0.00126191f, -0.04112021f, 0.03366751f, 0.00236402f, 
    0.05083320f, -0.05089234f, 0.01442638f, -0.03175001f, -0.11254864f, -0.00961855f, -0.03369495f, -0.02160699f, 
    -0.01007946f, 0.05804433f, 0.06026404f, 0.00991118f, -0.02596146f, -0.01332954f, 0.02224077f, 0.01417605f, 
    -0.03523038f, -0.05178836f, -0.06756420f, 0.06544472f, 0.01703304f, 0.02494453f, -0.00599506f, 0.03412822f, 
    -0.10077926f, 0.01666757f, -0.02053328f, -0.01564234f, 0.06983956f, -0.23578970f, -0.20391427f, -0.25406554f, 
    -0.19746847f, 0.02884930f, 0.03319994f, 0.03097061f, -0.04755022f, -0.04441184f, -0.03388718f, 0.00229516f, 
    -0.07045463f, -0.01375887f, -0.05492824f, -0.00816421f, -0.03627920f, 0.11273007f, 0.02585002f, -0.02714768f, 
    0.03406692f, -0.31810799f, 0.00811111f, -0.14794767f, -0.07314608f, 0.13791020f, 0.04083230f, 0.06060064f, 
    -0.05303865f, 0.00272976f, -0.03027207f, 0.04539983f, 0.00150995f, -0.04783065f, -0.05243855f, -0.02841652f, 
    0.03494497f, 0.09994737f, -0.14074087f, -0.03706031f, -0.06282153f, -0.08025187f, 0.06895407f, -0.14888014f, 
    -0.09006451f, 0.05150625f, 0.04871638f, 0.04471705f, -0.04291370f, -0.00950984f, 0.02443739f, 0.05957853f, 
    -0.05078006f, -0.12114915f, 0.01982628f, 0.05850158f, -0.02253029f, 0.02525298f, -0.04720671f, -0.04323559f, 
    0.32554924f, -0.05315964f, -0.01999470f, -0.15465951f, -0.08714520f, -0.02468090f, 0.04552507f, -0.11019599f, 
    0.00106875f, -0.02660404f, -0.05628423f, 0.00059082f, 0.01206828f, 0.05154094f, -0.03299081f, 0.05211063f, 
    0.03812178f, -0.00479853f, 0.03357081f, -0.02248401f, -0.00506561f, 0.08579747f, -0.11580271f, -0.09268524f, 
    0.08303547f, 0.01841594f, 0.08618590f, 0.03508051f, -0.00565737f, -0.04369063f, -0.04294297f, 0.01198074f, 
    -0.03252430f, -0.00832384f, -0.01349396f, -0.02907572f, 0.03908827f, -0.04291082f, -0.01288251f, -0.00484095f, 
    0.16959770f, 0.01232832f, -0.21244375f, 0.07923682f, 0.02638254f, -0.11015800f, -0.03553081f, 0.06179130f, 
    0.08166693f, 0.00671837f, -0.00820753f, -0.03231614f, 0.03033413f, -0.06041271f, 0.00040480f, 0.00193972f, 
    -0.06272202f, -0.10119046f, 0.02909536f, 0.00149245f, 0.07939816f, 0.04435317f, 0.06886067f, 0.15078287f, 
    0.16998681f, -0.09186760f, -0.06706794f, -0.02821046f, 0.04907423f, 0.10147102f, 0.07296296f, -0.00054836f, 
    -0.00414580f, 0.03633723f, 0.03209103f, -0.06897338f, -0.06110245f, -0.02931505f, -0.06835002f, -0.01279256f, 
    -0.02905644f, -0.18275131f, -0.12674391f, -0.05744920f, -0.10210854f, -0.01163004f, -0.00132324f, 0.04006174f, 
    -0.05162217f, -0.02556850f, -0.06457104f, -0.02609315f, -0.01334552f, -0.01110754f, -0.08390797f, -0.05231800f, 
    0.07880666f, 0.00191408f, 0.00354592f, 0.01790618f, -0.03712154f, 0.07072743f, -0.09512841f, -0.05338434f, 
    0.10535066f, 0.05352413f, 0.06995264f, 0.06641710f, -0.03150226f, -0.07284013f, -0.02950689f, 0.01491050f, 
    -0.02417352f, -0.00214639f, 0.00323523f, -0.04609643f, -0.00479206f, -0.03069540f, -0.07774417f, -0.00760993f, 
    -0.46981329f, 0.14171161f, 0.01151257f, -0.00897894f, 0.07038449f, -0.02019969f, 0.08942354f, -0.06823749f, 
    -0.01955799f, -0.04747939f, 0.00552562f, -0.04345387f, 0.02293004f, -0.03807852f, 0.06549484f, -0.02053577f, 
    0.04282432f, -0.07635832f, 0.00614575f, 0.01965756f, -0.14385121f, 0.08763336f, 0.01298629f, -0.16441269f, 
    0.06265800f, 0.04179402f, 0.01789043f, 0.00517435f, 0.04819554f, 0.00543309f, -0.04196221f, 0.04293276f, 
    0.00605325f, -0.03993772f, 0.00750412f, -0.01620825f, -0.02992470f, -0.01918176f, 0.01552461f, 0.01821350f, 
    -0.04820370f, 0.07360370f, -0.03053242f, -0.01458412f, -0.03310768f, 0.11506109f, -0.03103874f, -0.00566858f, 
    -0.09507432f, 0.00593843f, 0.03456504f, 0.06995515f, 0.01799943f, 0.01687067f, 0.02127603f, -0.02872377f, 
    0.01608492f, -0.03817835f, -0.03197524f, 0.02274683f, 0.05744324f, 0.18245552f, 0.02787784f, -0.06865364f, 
    -0.01129249f, 0.07220671f, 0.01329464f, -0.05048480f, 0.07965671f, -0.02420288f, -0.04856703f, 0.01009185f, 
    -0.04457100f, -0.00883264f, -0.01275366f, -0.01684447f, 0.01253245f, 0.07771286f, 0.01977408f, 0.01401198f, 
    0.30853900f, -0.06705856f, -0.04960762f, -0.18559618f, -0.04812671f, -0.10221820f, 0.00589042f, -0.02397043f, 
    -0.01637156f, -0.07559431f, 0.00087439f, -0.03923986f, 0.02752432f, 0.01952859f, -0.08864678f, 0.05784472f, 
    0.11275550f, -0.02725278f, 0.01763246f, -0.05899623f, 0.08059958f, -0.02476816f, -0.02788640f, -0.01885819f, 
    -0.01602558f, -0.04936581f, 0.01215531f, 0.05740040f, -0.02451512f, -0.02703660f, 0.00401759f, 0.03888927f, 
    -0.03214685f, 0.02195408f, -0.01573648f, -0.04757165f, -0.05929294f, -0.03130504f, -0.00855259f, 0.03861488f, 
    -0.11032325f, -0.20809568f, -0.06857806f, -0.04857766f, -0.10713446f, 0.01723069f, -0.01689914f, 0.05691742f, 
    -0.06479099f, 0.00952535f, -0.07912283f, 0.02945621f, -0.01768463f, 0.00076631f, -0.02307226f, 0.02047308f, 
    -0.07369336f, 0.14462291f, -0.02072706f, -0.01046917f, 0.05235739f, 0.08543664f, -0.05204811f, -0.08711817f, 
    0.07647990f, 0.03667050f, 0.09720681f, 0.07055948f, -0.06023514f, -0.04955589f, 0.01597821f, -0.03166503f, 
    0.00666804f, -0.06726960f, 0.01442029f, -0.02666555f, 0.01572929f, -0.03989552f, -0.05952225f, 0.01008010f, 
    0.16736721f, 0.03861551f, 0.01581144f, -0.08142844f, 0.07666910f, -0.00243470f, -0.03809481f, 0.02031171f, 
    -0.02253807f, 0.08365094f, -0.01002412f, -0.09113644f, -0.01415921f, 0.00045586f, -0.03057426f, -0.01508830f, 
    -0.04910017f, -0.00980227f, -0.03105843f, -0.02242039f, 0.06397130f, 0.04435346f, -0.12283813f, -0.04522770f, 
    0.05575190f, 0.02315722f, -0.07700265f, 0.01055269f, 0.03195833f, -0.01647854f, -0.02623506f, 0.04753552f, 
    -0.00493805f, 0.00837453f, 0.00958965f, -0.04336660f, 0.02805237f, -0.05311282f, -0.02560733f, -0.03246614f, 
    0.21641661f, -0.10710012f, -0.24441476f, -0.07522082f, -0.14727212f, -0.04798233f, 0.02204103f, -0.06917594f, 
    0.01159188f, -0.01489349f, 0.04200747f, -0.00765540f, -0.02496631f, -0.02276091f, -0.00084758f, 0.00314834f, 
    -0.01080212f, -0.04830102f, 0.03496754f, -0.06601045f, -0.03571754f, -0.05064587f, 0.08031161f, -0.12302018f, 
    -0.10040111f, 0.00930864f, -0.07138715f, 0.08655400f, -0.08584730f, -0.02218520f, -0.06763403f, 0.07974115f, 
    0.04374610f, -0.06023316f, 0.02608135f, 0.05481361f, -0.06006800f, 0.09217757f, 0.01476417f, -0.02222565f, 
    0.10453431f, -0.12835801f, 0.12231795f, -0.02208915f, 0.06272684f, -0.10316019f, -0.03210413f, -0.08477830f, 
    -0.00979455f, 0.04026513f, 0.02872454f, -0.06889386f, 0.00858010f, -0.00235370f, -0.00591252f, -0.00223085f, 
    -0.06084060f, -0.01031453f, -0.00873040f, 0.04152983f, 0.05037213f, -0.26436016f, 0.07275169f, -0.07040472f, 
    -0.07170062f, 0.03863175f, -0.10438804f, -0.03300309f, 0.02783889f, 0.05959881f, -0.02292272f, -0.02387647f, 
    -0.01207948f, 0.04419418f, -0.10548458f, -0.01860180f, -0.10619272f, 0.03963709f, -0.01972187f, -0.02321151f, 
    0.34477249f, -0.02909968f, -0.16100468f, 0.14290044f, -0.25810495f, -0.06502222f, -0.15768133f, 0.16815048f, 
    0.15944797f, 0.10262274f, 0.00274205f, 0.01518205f, -0.06344521f, 0.02719854f, -0.03823554f, 0.00404481f, 
    -0.02220342f, -0.02451869f, 0.04284497f, 0.08934379f, 0.23129201f, -0.16672945f, 0.16710967f, -0.07746808f, 
    0.10147515f, -0.07382114f, -0.04903817f, -0.01906532f, -0.00165215f, 0.06496627f, 0.07457652f, -0.01135918f, 
    0.00794108f, 0.01703535f, 0.02712094f, -0.02339680f, -0.02706235f, -0.01160908f, 0.00273728f, -0.00623548f, 
    0.12884338f, 0.14030449f, 0.17609443f, 0.16539796f, 0.17268513f, -0.09806019f, -0.13178839f, -0.11741195f, 
    0.08326238f, 0.10840904f, 0.04610955f, -0.03570770f, -0.02109661f, 0.04821230f, -0.08142904f, -0.05023798f, 
    0.05241376f, -0.01541127f, 0.01524547f, -0.01991695f, 0.02627225f, -0.05090202f, 0.15107322f, 0.06233153f, 
    0.07647824f, -0.14186864f, -0.04093151f, -0.09033119f, 0.01831718f, 0.00808869f, 0.03200642f, -0.02293056f, 
    -0.03701923f, 0.02675163f, -0.01589676f, -0.00347116f, -0.01773706f, -0.02355640f, -0.00230091f, 0.00534466f, 
    -0.01714829f, 0.08259441f, 0.18895844f, 0.12320494f, 0.11722726f, -0.08968848f, -0.02320732f, -0.09847256f, 
    0.08585672f, -0.00433439f, -0.05349334f, -0.04340763f, -0.05534633f, 0.01824561f, 0.02070150f, 0.01364821f, 
    0.00220989f, -0.02752027f, 0.06785500f, 0.03910681f, -0.16213830f, -0.14098527f, 0.06987777f, -0.11325960f, 
    -0.05681408f, -0.04242133f, -0.06720430f, -0.09657577f, -0.02529521f, 0.00841406f, -0.05454842f, -0.00113672f, 
    -0.05827528f, 0.02637033f, 0.08727866f, -0.02023478f, 0.02283088f, 0.01101507f, -0.03044945f, -0.03643603f, 
    0.13933268f, 0.02537987f, -0.17422460f, -0.18720251f, -0.07059869f, -0.01179740f, 0.05810366f, -0.01256240f, 
    -0.10243554f, 0.00748912f, -0.10122677f, -0.03583554f, 0.07395205f, -0.01251099f, 0.01708172f, -0.00289990f, 
    0.02720578f, -0.06834065f, -0.05679542f, -0.00182617f, 0.13857882f, -0.13874775f, -0.02541962f, -0.02843682f, 
    -0.10523029f, 0.02496984f, -0.04819063f, 0.04684454f, 0.00580634f, 0.04661614f, -0.06596574f, -0.00208143f, 
    0.05477628f, 0.04364674f, -0.04865528f, -0.01395552f, 0.02569241f, 0.00138086f, -0.06508791f, -0.07011162f, 
    0.22459669f, -0.06931653f, -0.19376411f, 0.05489647f, 0.01755936f, -0.11008308f, 0.07912137f, -0.04942960f, 
    -0.00511384f, 0.02503639f, 0.06272813f, 0.06468282f, -0.00385558f, -0.00530817f, -0.05742271f, -0.01777191f, 
    -0.04525638f, -0.06820379f, 0.03252872f, 0.02991690f, 0.26025680f, -0.10533605f, -0.10279240f, 0.05081318f, 
    -0.03889231f, -0.10151683f, 0.00104499f, 0.02591647f, 0.04834217f, -0.04344323f, -0.00228795f, -0.00232354f, 
    -0.02130337f, -0.01639430f, 0.03027335f, 0.04025707f, -0.07449334f, -0.01422286f, 0.03864837f, -0.04697200f, 
    -0.01636363f, -0.23745134f, 0.02551278f, -0.14754842f, -0.24554633f, -0.03357664f, -0.00820510f, -0.12259147f, 
    0.02373387f, -0.02530504f, 0.05082697f, 0.02275339f, 0.04103506f, -0.05209226f, -0.01620678f, -0.05279442f, 
    -0.01290131f, 0.12404144f, 0.01450452f, -0.06320710f, -0.05348960f, -0.01759208f, 0.07531034f, -0.07363172f, 
    -0.01464278f, 0.02661581f, -0.04593661f, 0.03248186f, -0.01921045f, -0.03054832f, -0.02693687f, 0.04237844f, 
    0.01119387f, 0.05703105f, 0.05538520f, -0.00779149f, -0.11689421f, -0.08501988f, -0.03808450f, 0.00627490f, 
    0.24431142f, -0.20069723f, 0.01935912f, -0.05617511f, -0.12736420f, -0.10903387f, 0.00395613f, -0.09201758f, 
    -0.03249393f, -0.02912554f, -0.00312475f, -0.02407170f, -0.02649281f, -0.03726244f, -0.01223429f, -0.03242117f, 
    0.02195836f, 0.08133176f, -0.02033292f, -0.01109888f, 0.01540128f, -0.05644759f, 0.00313758f, -0.03319229f, 
    0.10306399f, 0.04369977f, 0.07817700f, 0.02183765f, -0.02893379f, -0.04774698f, 0.01275911f, 0.00411191f, 
    -0.06657392f, -0.00741268f, -0.05886502f, 0.00597093f, 0.05662182f, -0.06722796f, -0.17606924f, 0.00441995f, 
    0.04208905f, 0.07075877f, 0.01594222f, -0.09522507f, -0.02636914f, -0.01890545f, -0.10029514f, 0.07203871f, 
    0.02970392f, -0.01574375f, -0.03123039f, 0.01736537f, -0.02523135f, 0.02360843f, -0.01314114f, 0.06520870f, 
    0.00969845f, -0.05537061f, -0.19010317f, -0.02849929f, -0.21996963f, 0.08365535f, 0.06309914f, 0.05696852f, 
    -0.01220097f, -0.06070076f, -0.06148978f, -0.08799886f, 0.02313125f, -0.02308332f, 0.06678817f, 0.00017186f, 
    0.00945917f, 0.00530777f, 0.01051680f, 0.01255135f, 0.08354165f, -0.01897683f, -0.07235713f, -0.01381896f, 
    0.42756182f, 0.07816455f, -0.15049094f, -0.05401519f, -0.25509927f, -0.04909340f, 0.03191718f, 0.07819089f, 
    -0.01200603f, 0.08340212f, -0.04560206f, -0.04912500f, -0.05597236f, -0.10678242f, -0.07731580f, -0.03277674f, 
    0.07010669f, -0.00836626f, 0.12023157f, 0.03345267f, 0.20565043f, 0.04410656f, -0.14512263f, -0.00631048f, 
    -0.07657376f, -0.00078890f, 0.08034406f, 0.05271714f, 0.03131020f, 0.00463573f, -0.01661928f, 0.04280784f, 
    -0.05532197f, 0.01013922f, -0.02279398f, -0.06079319f, -0.00547193f, 0.02271530f, -0.05525487f, 0.06869029f, 
    0.13936976f, 0.06432523f, -0.00104509f, -0.03558635f, 0.09639552f, -0.03976643f, -0.03970326f, 0.02848831f, 
    0.05876396f, 0.06636284f, 0.00316076f, 0.00298477f, -0.02678895f, 0.00140864f, 0.00572155f, -0.05539559f, 
    -0.01507472f, -0.06835724f, -0.04439830f, 0.00054122f, -0.09675527f, 0.07781036f, -0.01360476f, -0.00383002f, 
    -0.00814350f, 0.01654894f, 0.00875784f, 0.14646460f, -0.02412895f, -0.02213835f, -0.02691986f, 0.02733686f, 
    0.03226961f, -0.04180919f, -0.00845455f, -0.02960505f, -0.11364349f, 0.01201397f, 0.02142490f, 0.01310143f, 
    -0.01801278f, 0.04858992f, 0.01148511f, -0.05174351f, 0.09014773f, 0.05464895f, 0.04562634f, 0.07821549f, 
    0.01011679f, -0.06553651f, -0.02326047f, 0.01535337f, 0.00564340f, 0.03091494f, -0.01134647f, -0.00664270f, 
    0.01179992f, -0.02311595f, -0.08078825f, -0.01182002f, 0.28388509f, -0.21668786f, -0.02797505f, 0.01848247f, 
    -0.09418816f, -0.12302074f, -0.04595444f, -0.12436500f, -0.04203834f, 0.00506418f, 0.04247541f, -0.01928503f, 
    -0.02231481f, -0.01464499f, -0.01631093f, -0.05176726f, -0.01005369f, 0.06189739f, 0.00436290f, 0.03809279f, 
    0.07014348f, -0.18861018f, -0.06093627f, 0.12538274f, 0.16462027f, -0.17467126f, -0.04031887f, -0.12639445f, 
    -0.06071081f, 0.00686225f, 0.06039825f, -0.01212119f, -0.01452947f, 0.02151880f, 0.00653170f, -0.05766517f, 
    -0.00922621f, -0.02764516f, -0.02002556f, -0.00345608f, 0.01460101f, 0.11223502f, -0.21635561f, 0.03284552f, 
    -0.00570399f, 0.02996971f, 0.05469830f, -0.00206314f, -0.01884615f, 0.05761781f, -0.01412291f, -0.00481693f, 
    0.07167006f, 0.01006966f, 0.04888468f, -0.04964006f, -0.02165632f, -0.09126392f, -0.07111181f, 0.03583328f, 
    0.26450557f, 0.04948117f, -0.22103812f, 0.05218756f, -0.12493452f, -0.02809034f, 0.02376378f, -0.00044182f, 
    -0.03680473f, 0.00225872f, 0.00693740f, -0.02886930f, -0.01039306f, -0.02702638f, 0.00084524f, 0.00253410f, 
    0.07680199f, -0.03102587f, 0.05668112f, -0.05777401f, 0.39127389f, -0.31159261f, 0.14749721f, -0.08421529f, 
    0.07565074f, -0.02463154f, -0.07626812f, -0.06073437f, 0.06285646f, 0.10133456f, 0.09845462f, 0.02210368f, 
    -0.04768465f, 0.00202978f, 0.00197217f, 0.10589457f, -0.08003799f, -0.02666407f, 0.05846190f, -0.01411951f, 
    0.06303620f, 0.01666253f, -0.07842007f, -0.01197605f, -0.18448731f, -0.02900171f, 0.04856065f, -0.11493016f, 
    -0.00089632f, 0.01550405f, -0.03627842f, 0.00648312f, 0.03718525f, -0.00532811f, 0.01697116f, 0.01272682f, 
    0.04812920f, 0.03250720f, -0.07516189f, -0.02990690f, 0.13976440f, -0.16408977f, 0.20156874f, -0.04069332f, 
    0.05709171f, -0.09733330f, -0.02004803f, -0.02931588f, 0.00070015f, 0.04682111f, -0.01560779f, -0.04901315f, 
    0.02597111f, -0.00476846f, -0.01788308f, 0.03681342f, -0.06816792f, -0.01975410f, 0.00263409f, 0.01794579f, 
    0.11311237f, -0.02105532f, -0.06147922f, -0.18887243f, -0.03731597f, 0.07812738f, -0.03769603f, -0.02042661f, 
    -0.02372588f, 0.06714316f, 0.04524779f, 0.01379426f, 0.02541263f, 0.02252251f, -0.00615359f, -0.02729790f, 
    -0.05876437f, 0.02490246f, -0.04560636f, -0.01075862f, 0.05346232f, -0.27989045f, -0.01499793f, -0.13630897f, 
    -0.04614345f, -0.08629214f, -0.00316525f, -0.03941902f, -0.03452906f, -0.05943779f, 0.00188280f, -0.04146465f, 
    -0.02150513f, 0.04370513f, -0.01563767f, -0.00212779f, -0.00124325f, -0.01827367f, -0.01722462f, 0.01551786f, 
    0.11764644f, 0.09017770f, -0.07777432f, 0.00357154f, 0.02005713f, 0.00891810f, 0.01572843f, 0.00956047f, 
    -0.05677767f, -0.07006635f, -0.04171016f, 0.00015300f, 0.01169608f, 0.01561567f, 0.00197744f, 0.03620037f, 
    0.01523856f, -0.11078379f, 0.02132318f, -0.03668937f, -0.06249923f, 0.06963621f, 0.01663118f, -0.13520202f, 
    0.02413268f, 0.03205911f, 0.02734616f, 0.09529493f, -0.03715274f, -0.00997669f, -0.08235112f, 0.07549161f, 
    -0.02116867f, -0.10090883f, -0.02043251f, 0.01808206f, 0.03858341f, 0.08401883f, -0.00386633f, 0.01925008f, 
    -0.05066899f, 0.12303437f, -0.02467442f, 0.00668712f, -0.00455968f, 0.00188131f, 0.13600941f, 0.01155598f, 
    -0.04914531f, -0.09818204f, 0.03645714f, -0.04788009f, -0.03501577f, -0.07498693f, -0.00160100f, -0.01116868f, 
    0.03250199f, 0.05129303f, 0.00838196f, -0.03642421f, 0.27929655f, -0.11111282f, 0.00697824f, 0.16017890f, 
    0.00477181f, -0.16868497f, -0.00929521f, -0.02653859f, -0.00668140f, 0.02059846f, -0.01412493f, 0.01619184f, 
    0.07451407f, 0.00427841f, -0.05030316f, 0.02501904f, -0.06441579f, -0.00303003f, 0.03690730f, 0.03320879f, 
    -0.01460541f, 0.00247809f, 0.02028612f, -0.07994622f, -0.12834662f, 0.01217620f, 0.00873334f, 0.09362315f, 
    -0.01341906f, 0.06779338f, -0.02656206f, -0.00201628f, 0.07231615f, -0.04627430f, -0.03073550f, 0.09782113f, 
    -0.05258548f, 0.00798408f, -0.01084008f, -0.02633968f, -0.24520351f, 0.13158791f, 0.03693961f, -0.15528908f, 
    0.08818071f, -0.01539062f, -0.02913734f, 0.08162844f, 0.05721528f, -0.02265318f, -0.00247975f, 0.00657611f, 
    -0.00335539f, -0.01150340f, -0.04075230f, -0.03338774f, -0.00426289f, 0.03148669f, -0.00257816f, -0.05367566f, 
    -0.18559372f, -0.25646448f, -0.24543540f, -0.00195226f, -0.01615770f, -0.07701334f, -0.07016395f, -0.03192691f, 
    0.02889403f, -0.03185991f, -0.06415088f, -0.03846218f, -0.00718893f, -0.06507262f, 0.02957669f, -0.04057491f, 
    -0.06116752f, 0.01351411f, -0.04255242f, -0.02286145f, -0.03309024f, -0.05418072f, -0.10193472f, -0.06549855f, 
    0.00942632f, -0.08440141f, -0.03219025f, -0.01270087f, -0.00404066f, -0.01959692f, -0.04559370f, 0.00742311f, 
    0.05521665f, 0.03109661f, 0.00664755f, -0.02248289f, -0.03014671f, -0.06098742f, -0.03009483f, -0.01210259f, 
    0.11269864f, -0.01289081f, 0.04872080f, 0.06182956f, 0.14690255f, 0.08159736f, 0.07025647f, 0.03799588f, 
    -0.08105386f, -0.01840637f, 0.02831813f, -0.01529668f, -0.03906133f, -0.05315934f, -0.03091709f, 0.08016458f, 
    -0.03150307f, 0.07419135f, 0.02916799f, 0.04117429f, 0.07216356f, -0.16130705f, -0.01011732f, 0.10305090f, 
    -0.07447184f, -0.02188828f, -0.09738866f, -0.07656561f, 0.09504132f, -0.05510066f, -0.08955647f, 0.00312720f, 
    -0.03202954f, -0.03258216f, -0.01299979f, -0.01827009f, 0.04776545f, 0.03366235f, -0.01219382f, -0.04792457f, 
    -0.29201928f, -0.40773287f, 0.01122930f, -0.03732955f, -0.18192899f, 0.01966774f, -0.02366229f, 0.02731246f, 
    0.01356299f, -0.11141285f, 0.00817533f, -0.05765537f, 0.04653875f, 0.03369248f, 0.03743483f, 0.04198195f, 
    0.02579851f, 0.01121844f, -0.13045239f, -0.01715437f, 0.51270312f, 0.25596324f, -0.00714359f, 0.01754613f, 
    0.02507731f, -0.01900684f, 0.03768211f, 0.00482003f, 0.05808913f, 0.02027921f, -0.09460473f, -0.05872319f, 
    -0.03921225f, 0.07346268f, 0.02405910f, 0.01782675f, -0.01053688f, 0.02880860f, 0.11222810f, 0.10963206f, 
    0.00805944f, -0.13882545f, -0.27723521f, 0.07127278f, 0.15065064f, -0.03628717f, -0.00035232f, -0.04315308f, 
    -0.01616853f, 0.04095830f, -0.01393470f, -0.02272613f, -0.05132486f, 0.13723309f, -0.06697894f, 0.00300225f, 
    0.04172249f, 0.01779627f, -0.03291568f, -0.03375731f, 0.14972445f, -0.04773521f, -0.07307390f, 0.18257682f, 
    0.00962675f, 0.09884224f, 0.03182177f, -0.00308002f, -0.01235620f, -0.02431701f, -0.03972502f, 0.03147854f, 
    -0.15635733f, -0.07094391f, -0.03336410f, -0.01543721f, 0.01525277f, 0.08340809f, -0.03866757f, -0.00857695f, 
    -0.16783424f, 0.11581100f, 0.06174148f, 0.11660052f, 0.06436855f, 0.04072828f, -0.03078853f, 0.05662553f, 
    0.00546584f, -0.00235856f, -0.03537250f, 0.00027195f, -0.05546208f, -0.00486080f, 0.03665104f, 0.06515553f, 
    0.05032868f, -0.01945599f, 0.08018486f, 0.00666468f, -0.32806343f, -0.00604411f, -0.18700904f, 0.00350211f, 
    0.16393630f, -0.00946123f, 0.05668131f, 0.01362901f, 0.02013926f, -0.02103117f, -0.03979643f, -0.03585938f, 
    0.05062074f, 0.01163879f, -0.00936868f, -0.03604141f, 0.00336764f, -0.00795336f, 0.06570192f, 0.04337249f, 
    0.03343614f, -0.01567342f, 0.21733595f, -0.06378470f, -0.05966290f, -0.01162211f, -0.13781081f, -0.00510665f, 
    -0.03066610f, -0.04504052f, -0.02327594f, -0.02365847f, 0.00736185f, -0.01086644f, 0.05245511f, -0.00832036f, 
    0.02508947f, 0.03297612f, 0.10886447f, 0.05733546f, -0.04294706f, -0.21435034f, -0.06739507f, -0.07240395f, 
    -0.13724378f, -0.08270452f, -0.04637050f, 0.08617084f, -0.08205821f, 0.06939243f, -0.04993514f, 0.02084197f, 
    0.05121350f, -0.04248941f, 0.03721449f, 0.00767386f, 0.03149633f, 0.06771490f, 0.03789305f, 0.08762505f, 
    0.23973808f, 0.13655135f, 0.00541105f, 0.01417888f, 0.06041892f, 0.02627646f, -0.02455243f, -0.06351392f, 
    0.02094101f, 0.02223834f, -0.05770427f, 0.00690259f, 0.00976519f, 0.02521231f, -0.00435817f, -0.02222707f, 
    0.05299135f, -0.04257834f, 0.03834881f, 0.05358086f, -0.28904209f, -0.02004890f, -0.26922357f, 0.00988012f, 
    0.12381094f, -0.02616328f, 0.02340044f, 0.01692379f, -0.00052067f, -0.04918507f, -0.01353788f, -0.03125027f, 
    -0.01782862f, 0.02013395f, 0.00829185f, -0.01456197f, -0.05164910f, -0.03386356f, 0.03368921f, 0.00421411f, 
    0.06417619f, -0.09890281f, -0.28321293f, 0.05118208f, 0.01125371f, -0.07599145f, 0.10489688f, -0.04198022f, 
    -0.02118099f, -0.09406079f, 0.03919880f, 0.04794151f, -0.00081582f, -0.04845582f, -0.03507630f, -0.03572785f, 
    0.02781232f, 0.01554527f, 0.06191402f, -0.07645480f, -0.08769041f, -0.15183519f, -0.14071266f, -0.04190063f, 
    0.01229393f, -0.02903899f, -0.01032116f, -0.04973032f, 0.01693566f, 0.00782368f, 0.00950174f, 0.00091430f, 
    0.05413743f, 0.09261767f, 0.01610772f, 0.01186261f, -0.07831407f, -0.00910809f, 0.02467542f, 0.00727494f, 
    0.03757924f, 0.18178362f, 0.02804101f, 0.00441310f, -0.08119960f, -0.10230366f, -0.04199719f, -0.00875108f, 
    0.00707868f, -0.00092977f, -0.07757302f, 0.05403991f, -0.07349819f, 0.02338229f, 0.04622312f, -0.06374811f, 
    -0.08130020f, -0.01476138f, -0.01804703f, 0.01711789f, 0.31397167f, 0.24233994f, -0.07742223f, -0.00876091f, 
    -0.04592790f, 0.04326039f, -0.04423779f, -0.02251416f, 0.09167651f, -0.04819405f, 0.00831680f, 0.02471241f, 
    -0.08531660f, 0.01825773f, 0.03501479f, -0.00537561f, -0.07253646f, -0.02955667f, -0.09095863f, -0.01949816f, 
    -0.15000287f, 0.24989630f, 0.15021689f, 0.13618396f, 0.05325716f, -0.01166011f, -0.00380720f, -0.02904792f, 
    -0.02864917f, -0.07811773f, 0.05942405f, -0.02808423f, -0.00236725f, 0.07044589f, -0.02445148f, 0.02554118f, 
    0.03922946f, 0.04742217f, -0.00707152f, 0.09997072f, -0.28119534f, -0.37146962f, -0.01606138f, -0.08403388f, 
    -0.14509383f, -0.07573015f, -0.08079222f, 0.02687832f, -0.00366559f, -0.06761918f, 0.01677451f, 0.01916119f, 
    0.00975033f, -0.00816145f, 0.01835185f, 0.05859748f, -0.02151511f, -0.00967259f, -0.02685061f, -0.01523115f, 
    0.22280632f, 0.29415014f, -0.10311628f, 0.06487431f, 0.06857911f, 0.03969935f, 0.08784363f, 0.05979496f, 
    -0.01779716f, 0.04299887f, 0.05378065f, -0.05707189f, -0.06886825f, -0.13420671f, -0.02104506f, -0.00053192f, 
    0.03325793f, 0.10358717f, 0.09915856f, -0.05133502f, -0.32684767f, -0.04074855f, -0.19159885f, -0.02720737f, 
    0.20515619f, -0.02302936f, 0.06731370f, 0.03177051f, 0.02474860f, 0.02357410f, -0.05250304f, -0.00279458f, 
    -0.00886765f, -0.07346058f, 0.00611516f, -0.07414394f, -0.02488204f, -0.08177695f, 0.00699547f, 0.03932103f, 
    -0.04278555f, 0.20620638f, -0.04317120f, -0.08166695f, -0.11202794f, -0.07677811f, -0.07609922f, -0.00927239f, 
    0.04104988f, -0.02151998f, -0.00784038f, -0.08863841f, 0.02086364f, 0.01591681f, -0.03434923f, -0.04462489f, 
    0.00750825f, -0.05694652f, 0.07297608f, 0.03383359f, -0.16610399f, 0.07909725f, -0.02745117f, -0.00493491f, 
    -0.04358489f, 0.00988307f, 0.06848855f, 0.03195615f, -0.02263404f, 0.00068911f, -0.07276591f, 0.01872606f, 
    0.02917246f, 0.03333651f, 0.00470909f, 0.02538782f, 0.00464309f, -0.03332532f, 0.03976997f, 0.07861049f, 
    -0.19993050f, 0.18354875f, 0.06202811f, 0.10355739f, -0.01227524f, -0.02133996f, -0.00118289f, 0.04173738f, 
    0.02527297f, -0.01273852f, -0.03964581f, -0.04091344f, -0.00041879f, 0.00133193f, -0.04809675f, 0.02115972f, 
    0.02012167f, 0.02022627f, 0.07265478f, 0.02067191f, 0.14341359f, 0.13896139f, -0.24900034f, 0.12561744f, 
    0.01433355f, 0.01765716f, 0.06993843f, 0.01301050f, 0.04694858f, 0.01376520f, -0.05912349f, -0.00932168f, 
    -0.03197841f, -0.08316623f, 0.05546895f, -0.05438809f, -0.03055030f, 0.09778677f, -0.11213914f, -0.06172413f, 
    0.03212693f, 0.02728998f, -0.04549721f, -0.02750244f, 0.02749687f, -0.07172250f, -0.07299981f, 0.02351701f, 
    0.01046687f, -0.02249582f, -0.03518819f, 0.01592962f, -0.00464456f, 0.04427106f, 0.01503271f, -0.02463774f, 
    0.03103927f, 0.03745935f, 0.01756742f, -0.02078294f, -0.05376377f, -0.05015947f, 0.02364020f, -0.01048539f, 
    -0.04480063f, -0.01656500f, 0.01210689f, -0.00005451f, -0.07994376f, 0.01657435f, -0.05759590f, -0.07281093f, 
    0.02404546f, 0.06524564f, 0.02005552f, 0.01099037f, -0.01032380f, -0.02627931f, -0.09436988f, 0.02607320f, 
    0.00699366f, -0.09802465f, 0.14553575f, 0.09960523f, -0.07264159f, -0.04994557f, -0.03247390f, 0.02833678f, 
    -0.04020631f, -0.00701978f, -0.04587910f, 0.06836341f, -0.08828608f, 0.02141655f, -0.00910530f, -0.02231764f, 
    -0.03707979f, -0.03354589f, -0.03774849f, 0.05660421f, -0.07686798f, 0.02602746f, 0.00407392f, 0.05480089f, 
    -0.04835185f, -0.02812682f, -0.08901495f, -0.07095894f, 0.00293366f, -0.00727813f, -0.02192166f, -0.02508757f, 
    0.04460879f, 0.03339057f, 0.01337771f, 0.02675351f, -0.01149162f, -0.01518637f, 0.06169898f, 0.07301784f, 
    -0.19500156f, -0.08918849f, -0.07967429f, -0.07442702f, -0.16232201f, -0.04381569f, -0.08790338f, 0.04884702f, 
    -0.09761051f, -0.01350146f, -0.12048861f, -0.07735758f, 0.07095201f, -0.05897916f, 0.02162710f, 0.03672478f, 
    0.01333589f, 0.07682046f, 0.00584216f, 0.05698211f, 0.07206894f, 0.05085380f, -0.13786784f, 0.00490045f, 
    -0.11693342f, 0.00788310f, -0.05771266f, -0.03693939f, -0.04420047f, -0.01610885f, -0.04633894f, -0.00499416f, 
    0.08937411f, 0.03259768f, 0.03229420f, 0.02768489f, -0.04565499f, 0.04919168f, -0.02453807f, 0.00536919f, 
    0.14333279f, 0.01800356f, -0.14470212f, 0.03481312f, -0.18190335f, -0.03497811f, -0.02028092f, -0.03203016f, 
    -0.06904434f, 0.04443611f, -0.08386832f, -0.03358792f, 0.06877781f, -0.03854485f, 0.05524491f, 0.00677748f, 
    -0.06648192f, -0.01122510f, -0.00348662f, 0.02774421f, 0.01200643f, 0.05687600f, -0.09049980f, 0.07269596f, 
    0.00413107f, -0.10031360f, -0.04558191f, -0.03136681f, 0.05600045f, 0.00314531f, -0.08191597f, -0.01824376f, 
    -0.00318813f, 0.00986986f, 0.01940564f, -0.01073549f, -0.03627578f, 0.05172233f, 0.00144820f, -0.00276313f, 
    -0.20994228f, 0.26003769f, 0.05401835f, -0.11524172f, 0.06579673f, 0.01965536f, 0.05900592f, -0.02195573f, 
    0.10057186f, -0.02893833f, 0.01988931f, 0.05070945f, -0.00080178f, 0.04488310f, -0.05741552f, -0.01109679f, 
    0.03835410f, -0.15141530f, 0.15038566f, 0.04109149f, -0.07915721f, -0.14878625f, -0.11245839f, 0.00966162f, 
    -0.01172228f, -0.13669592f, -0.02775606f, 0.01714456f, 0.04610121f, 0.01899541f, -0.01741520f, -0.01331469f, 
    0.03338329f, 0.02740199f, 0.05921648f, -0.01317057f, -0.05025245f, 0.00740993f, -0.04703365f, 0.05791602f, 
    -0.09341948f, 0.11990118f, 0.01581460f, 0.07551573f, -0.02999995f, -0.01005603f, -0.11056145f, 0.08332296f, 
    -0.03508212f, 0.02263894f, -0.06733684f, 0.01564162f, -0.07231861f, 0.00192035f, -0.02072026f, 0.06725977f, 
    0.01255520f, 0.05702052f, 0.10220624f, -0.02219168f, -0.21488284f, 0.05775490f, 0.03549286f, -0.10014442f, 
    -0.08041428f, 0.02290704f, -0.00250307f, 0.00251508f, 0.04223914f, -0.07867494f, -0.00785513f, -0.00679028f, 
    -0.01776948f, 0.00456394f, -0.04987699f, -0.06381717f, -0.05170760f, -0.06358054f, 0.02857495f, -0.00074272f, 
    0.01076911f, 0.13998471f, 0.07759695f, 0.10226967f, -0.03632500f, -0.02758964f, 0.05527117f, -0.06043551f, 
    -0.02830986f, -0.02901870f, 0.01133511f, 0.00899152f, -0.02703845f, -0.00647487f, -0.01816608f, -0.00772519f, 
    -0.00798911f, 0.09026267f, 0.00826430f, -0.05481096f, -0.10230840f, -0.27914447f, -0.16174902f, -0.13398716f, 
    -0.30163115f, -0.02947994f, -0.04473958f, 0.01773140f, 0.05348966f, -0.04548765f, -0.06160891f, -0.04128574f, 
    0.05985809f, 0.02634328f, 0.06344701f, 0.10962661f, -0.09304799f, 0.04121165f, -0.07954480f, 0.01013750f, 
    0.06124588f, 0.07122879f, -0.00200278f, -0.00596118f, -0.02900792f, -0.10715157f, -0.05699481f, -0.02745569f, 
    -0.01583178f, 0.00191605f, 0.00697395f, -0.00232415f, 0.04835575f, -0.01822935f, 0.02428156f, 0.00550816f, 
    0.01336312f, 0.09044164f, 0.01002325f, -0.04214604f, 0.08541916f, -0.01676286f, -0.24787031f, 0.13477753f, 
    0.03805309f, 0.00221308f, 0.04217111f, -0.03827844f, 0.03012607f, 0.01313623f, -0.01851091f, -0.00846485f, 
    0.00757101f, -0.04282640f, -0.02010733f, 0.05119728f, 0.07662753f, 0.04910062f, -0.00621385f, -0.05886567f, 
    0.08756493f, 0.18443175f, -0.35778096f, 0.12660168f, 0.07011755f, -0.07914391f, 0.17328170f, 0.03423605f, 
    -0.04936079f, -0.05769744f, 0.04544951f, -0.01843718f, -0.00489787f, 0.01005671f, 0.01419189f, -0.04683837f, 
    0.01704540f, -0.03595332f, 0.04255702f, -0.09620795f, 0.02834477f, 0.05314595f, 0.01661878f, -0.00323984f, 
    -0.01613590f, -0.01211505f, 0.05807471f, -0.00014407f, -0.05375103f, -0.02280596f, -0.03583112f, -0.02552178f, 
    -0.04581944f, -0.01167960f, 0.07303340f, -0.02855940f, 0.08305359f, 0.00565792f, -0.02194345f, -0.01997965f, 
    -0.12064730f, 0.09148944f, 0.03924575f, 0.19815995f, 0.05859363f, -0.00208742f, 0.04459895f, -0.01792855f, 
    0.06449882f, -0.02459706f, -0.00232396f, 0.07163630f, 0.02227075f, -0.13244392f, 0.03295280f, 0.00883803f, 
    0.03612599f, 0.01935540f, 0.01612800f, -0.05286766f, 0.09229471f, -0.44910797f, -0.08707171f, -0.00816513f, 
    0.00691968f, -0.05631242f, -0.01930141f, 0.07701574f, 0.08833117f, -0.09556248f, 0.03274659f, 0.06379467f, 
    -0.05457585f, 0.11284958f, -0.04571366f, 0.05609437f, 0.04754207f, -0.00891403f, 0.04478743f, 0.00160972f, 
    -0.27500379f, -0.08581586f, -0.06102306f, 0.01830295f, -0.12045126f, -0.04849733f, -0.09111409f, -0.00003225f, 
    -0.02497276f, -0.04213525f, 0.01619635f, -0.05997170f, 0.03104546f, 0.01724643f, -0.00258078f, 0.02460221f, 
    0.05194121f, -0.04168363f, 0.03440619f, 0.00344334f, 0.19066700f, -0.45573941f, -0.05331509f, 0.05044978f, 
    0.03757841f, -0.09537267f, -0.01101263f, 0.02989642f, 0.05259349f, -0.01508073f, 0.01776038f, 0.00104103f, 
    -0.02406263f, -0.02295127f, 0.04310940f, 0.00758892f, 0.01975364f, 0.03837489f, -0.00491395f, -0.02749270f, 
    -0.39714095f, -0.18194814f, -0.10232703f, -0.01160640f, 0.05655613f, -0.07086430f, -0.00855798f, -0.03152091f, 
    0.03848893f, -0.05020663f, -0.02640524f, -0.00261552f, 0.05031801f, -0.03817799f, 0.04883377f, -0.03739630f, 
    -0.00972351f, -0.04620462f, -0.02332592f, 0.00288631f, 0.08468261f, 0.04649594f, -0.01532423f, 0.01301047f, 
    -0.02862382f, -0.06327423f, -0.09541687f, -0.03724299f, -0.02343056f, -0.02055313f, -0.01151077f, 0.01903247f, 
    0.02445790f, -0.01212172f, 0.06080648f, -0.04257275f, -0.00988510f, 0.09037013f, 0.02055504f, 0.03279673f, 
    0.10882303f, -0.00523168f, -0.06129064f, 0.03958771f, -0.01322560f, -0.09939062f, -0.09658629f, 0.04337116f, 
    0.01368409f, -0.01021389f, -0.08021060f, -0.03796152f, 0.02753596f, -0.09493372f, 0.03439987f, -0.08710996f, 
    -0.01247651f, 0.06682067f, -0.00465096f, 0.02597007f, -0.24740839f, 0.33625445f, -0.00536658f, -0.05951006f, 
    -0.09171260f, -0.05179542f, -0.05902049f, 0.05012085f, 0.03424270f, 0.01379248f, -0.01291353f, 0.02358462f, 
    -0.03292096f, 0.00707617f, -0.11189817f, -0.02929791f, 0.04681318f, -0.03720476f, 0.11936828f, 0.01018734f, 
    -0.23515023f, 0.27534196f, 0.06036786f, 0.15034631f, 0.09747518f, 0.04427180f, 0.03735563f, 0.04129859f, 
    -0.05022931f, 0.00826189f, -0.00565009f, -0.04692996f, 0.01347253f, 0.01672197f, -0.06018602f, -0.01115337f, 
    0.00552805f, -0.02356612f, 0.04748210f, -0.02625435f, -0.25113395f, 0.06259692f, 0.02416647f, 0.13720854f, 
    -0.00271133f, 0.00407227f, -0.18500647f, -0.02200197f, 0.05402962f, -0.04738833f, -0.01047533f, -0.05324125f, 
    -0.00854345f, -0.05223643f, 0.06838582f, -0.03178686f, -0.04191093f, 0.00190334f, 0.05825097f, -0.00217086f, 
    0.04753888f, 0.15106124f, 0.06168711f, 0.08429798f, -0.04389713f, 0.05529162f, 0.02763351f, -0.01365012f, 
    0.02395765f, 0.00803349f, -0.00180172f, 0.06618458f, -0.03458142f, -0.08207601f, -0.03656450f, 0.01298736f, 
    0.06274337f, 0.01711256f, -0.01637441f, -0.00207645f, -0.02775324f, 0.01101719f, -0.01054026f, -0.04416406f, 
    0.03690899f, -0.04713013f, -0.10562047f, -0.04172282f, 0.00475255f, -0.02425405f, -0.00389609f, 0.01658284f, 
    0.04031373f, 0.03704070f, 0.01398235f, -0.05761623f, 0.06064429f, -0.08027305f, 0.06227275f, 0.01813187f, 
    0.32347444f, 0.21664816f, 0.00174718f, 0.00769695f, -0.05924442f, 0.05180296f, -0.03099402f, -0.04120003f, 
    0.04923353f, -0.02982443f, -0.01588765f, -0.00266884f, -0.09224196f, 0.09913675f, -0.08971380f, 0.01648319f, 
    -0.04109541f, -0.04884906f, 0.07198597f, 0.05440842f, 0.00724108f, -0.06996453f, 0.04471264f, 0.03362891f, 
    0.02366529f, -0.00412163f, -0.04496636f, -0.05980201f, 0.04428492f, -0.02685260f, 0.01896476f, 0.03182464f, 
    0.00705709f, -0.00828137f, 0.01573092f, -0.06545115f, 0.04448389f, 0.02425382f, 0.06796336f, -0.07934717f, 
    -0.34544402f, 0.08558937f, -0.01816213f, 0.05809496f, 0.07591001f, 0.00838518f, 0.05559211f, 0.01078367f, 
    -0.02177935f, -0.11463858f, -0.02741265f, -0.03141012f, 0.00358829f, -0.07079483f, 0.05132509f, -0.00003210f, 
    -0.00905377f, -0.04645593f, -0.00877930f, -0.02458450f, -0.03060083f, -0.30355817f, -0.21924566f, -0.02646805f, 
    0.13332592f, -0.02363577f, -0.00746217f, 0.03116969f, 0.02737096f, 0.02652865f, 0.00560796f, 0.01615055f, 
    -0.05117785f, -0.03967788f, -0.04943316f, 0.00812241f, -0.01918559f, 0.01515210f, 0.00455594f, -0.00216182f, 
    -0.07791542f, -0.03568817f, -0.06701363f, 0.15654419f, 0.08506320f, 0.02162197f, 0.11050518f, 0.06913489f, 
    0.04446546f, 0.00676095f, -0.03659724f, 0.03727434f, -0.02942246f, -0.12777875f, -0.04850868f, 0.01927059f, 
    -0.01061454f, 0.07221097f, 0.00719385f, -0.09573941f, 0.08324371f, -0.05854994f, 0.03498331f, -0.01935969f, 
    -0.04221496f, -0.08220006f, -0.14172132f, 0.03941101f, -0.04547876f, -0.04369722f, -0.00431083f, 0.05630615f, 
    -0.02286851f, 0.00666201f, 0.07818266f, -0.01140406f, 0.07180689f, 0.04074952f, 0.01882270f, 0.03385094f, 
    -0.02924805f, -0.14217599f, -0.08099514f, 0.07712328f, 0.09830094f, -0.08467117f, 0.10204015f, -0.03235578f, 
    -0.01882331f, 0.02123260f, 0.01105057f, 0.02231327f, -0.08849415f, -0.00459762f, 0.05891100f, -0.00497723f, 
    -0.04900171f, -0.05576888f, -0.00857997f, -0.02147074f, 0.10631645f, -0.40133128f, -0.03378164f, 0.10816765f, 
    0.13932405f, 0.04229337f, 0.20534557f, 0.01133544f, -0.04132521f, -0.04925671f, 0.01012341f, -0.00474447f, 
    -0.03465778f, -0.03437035f, -0.03715492f, -0.06374543f, -0.04370268f, 0.01150207f, 0.02467027f, -0.08199979f, 
    -0.15081383f, 0.03721268f, -0.02703428f, -0.13407210f, 0.06024165f, 0.03014072f, 0.00978784f, -0.11632454f, 
    -0.00953617f, 0.07576368f, 0.04964640f, -0.09877270f, -0.05368770f, -0.04381907f, -0.01731990f, 0.04704327f, 
    -0.08416486f, -0.07831568f, -0.05391299f, 0.00049297f, 0.02942007f, -0.09406486f, -0.12880999f, 0.09304023f, 
    -0.20095286f, 0.01800287f, 0.00470301f, 0.00989580f, -0.05839543f, 0.05612454f, -0.01303350f, -0.03425021f, 
    0.04305020f, 0.03819390f, -0.01281561f, 0.04443306f, 0.03993990f, 0.01576376f, -0.05177597f, -0.01512220f, 
    -0.10040651f, -0.20262636f, 0.08134579f, 0.13985120f, -0.01253130f, -0.01475384f, 0.08499233f, -0.03554530f, 
    -0.11447288f, -0.07364228f, 0.10769284f, 0.10879260f, -0.00315682f, -0.09086622f, 0.00309635f, -0.06105854f, 
    0.05068087f, -0.02504722f, 0.06913558f, 0.02828016f, -0.24362223f, -0.01802095f, -0.06872129f, -0.09109651f, 
    0.04504044f, -0.06451364f, 0.01923294f, -0.04478022f, 0.00241195f, -0.02670613f, 0.00582214f, 0.01574951f, 
    -0.07419056f, 0.03940736f, 0.05390310f, 0.02097723f, 0.02262487f, -0.07174970f, -0.02671692f, 0.00025596f, 
    -0.03010901f, 0.11678867f, -0.17765285f, -0.05293638f, 0.06658384f, 0.07936338f, -0.09527957f, -0.13208902f, 
    0.09720647f, 0.02511326f, -0.08255412f, -0.07075427f, 0.10146661f, 0.04512498f, -0.00481247f, -0.07022057f, 
    0.07338068f, -0.13026829f, -0.00912201f, -0.06360692f, 0.05770122f, -0.02789053f, 0.14273860f, -0.16837251f, 
    -0.37198737f, -0.01193747f, 0.10525352f, 0.03638851f, 0.05020030f, -0.03033394f, -0.01909669f, -0.00922419f, 
    0.02373372f, 0.02318085f, 0.07633945f, -0.10592540f, 0.14393437f, 0.02475636f, 0.06200010f, 0.09170479f, 
    -0.04290180f, 0.09868892f, 0.09299212f, 0.09351317f, -0.08972869f, -0.06335094f, 0.01396688f, 0.07430496f, 
    0.00328883f, 0.05353126f, 0.05710113f, -0.01349635f, 0.03265795f, 0.03212454f, 0.01976259f, -0.05462305f, 
    0.03927433f, -0.00990357f, -0.03272834f, 0.00663581f, -0.17451252f, -0.14906082f, 0.12876789f, 0.06703351f, 
    -0.11759896f, -0.08721961f, 0.03610049f, -0.04081019f, -0.00204772f, -0.03095805f, -0.02489378f, -0.12673911f, 
    0.00185416f, 0.09967393f, 0.07196071f, -0.09506784f, 0.01564408f, -0.01768999f, -0.02614429f, -0.01900095f, 
    -0.30560717f, 0.02227925f, -0.02416690f, -0.03726419f, 0.00584176f, -0.00140488f, -0.01544029f, -0.02682362f, 
    0.05715233f, 0.00364301f, 0.02226891f, -0.08852879f, 0.02302912f, -0.05491931f, 0.02871537f, -0.03235056f, 
    0.04686870f, 0.00740115f, 0.08984579f, -0.01123597f, -0.09278026f, -0.00326434f, 0.15939935f, 0.04866165f, 
    0.00040642f, -0.05810466f, -0.01701568f, 0.04013766f, -0.03372392f, 0.02099547f, 0.06703858f, -0.01051004f, 
    0.02346001f, -0.07715074f, 0.01640714f, 0.10068745f, -0.01624166f, -0.02369605f, -0.00839483f, 0.03881878f, 
    0.01995371f, 0.02343184f, -0.11539489f, -0.10527653f, 0.23653063f, -0.02451210f, 0.11547751f, 0.01425578f, 
    0.03815169f, 0.03978570f, -0.11363347f, -0.08721379f, 0.05810969f, 0.04312873f, -0.03087045f, -0.09292395f, 
    0.11797877f, -0.12470494f, -0.00430945f, -0.01973507f, -0.49267957f, -0.07508996f, 0.03177365f, 0.15264654f, 
    0.13583674f, 0.04408745f, -0.00581557f, 0.05016515f, 0.03950065f, 0.09465249f, -0.12914187f, -0.09356149f, 
    0.08409780f, 0.07134128f, 0.08680060f, 0.03915662f, 0.11617286f, 0.04705513f, 0.05925399f, -0.06941808f, 
    0.28694591f, 0.02895427f, -0.02541516f, -0.10009551f, -0.10350168f, -0.05673261f, 0.07152355f, 0.02740242f, 
    0.02612224f, -0.05776939f, 0.02872009f, -0.00835815f, 0.02406706f, 0.03556895f, 0.05558905f, -0.04982246f, 
    0.06652760f, 0.03402027f, 0.02164304f, 0.04569952f, -0.03587176f, 0.00920052f, 0.14878953f, 0.01185805f, 
    -0.01224852f, -0.07784166f, -0.00257761f, -0.02765840f, 0.00639612f, 0.02397485f, 0.09231265f, 0.00554693f, 
    0.03096895f, -0.07241140f, 0.00367246f, 0.04564162f, 0.00084589f, -0.02075584f, -0.01148081f, -0.00811610f, 
    -0.15694366f, 0.16697301f, 0.06785280f, -0.20222935f, -0.09065536f, 0.15825659f, -0.00957968f, -0.02252617f, 
    -0.10215696f, -0.03771887f, 0.06740645f, -0.01799278f, -0.10492003f, -0.03352150f, -0.09461163f, -0.01079674f, 
    -0.03858101f, -0.11175445f, -0.15904920f, -0.06064674f, 0.09645144f, 0.04776374f, 0.18023540f, 0.02322090f, 
    -0.15195842f, 0.02214005f, 0.06585851f, -0.00303983f, -0.00549148f, -0.04948017f, 0.07946497f, 0.05668193f, 
    0.01134507f, -0.03721814f, 0.05984022f, 0.03901143f, -0.00646947f, -0.07158237f, -0.06270249f, -0.00670059f, 
    0.07917339f, -0.11242937f, 0.07584321f, -0.01041865f, 0.06254615f, 0.01983285f, 0.03282964f, 0.00124103f, 
    0.01886499f, -0.03974064f, 0.02385729f, 0.04950724f, -0.09780014f, -0.03582132f, -0.01574922f, 0.02941179f, 
    -0.04917831f, -0.12807697f, 0.02747847f, 0.03030065f, 0.14060107f, 0.13732217f, 0.02175744f, -0.24018371f, 
    -0.07812163f, 0.04009090f, 0.03814866f, -0.08581493f, 0.03558230f, -0.07261941f, 0.01360015f, -0.09646808f, 
    0.03802702f, 0.00459334f, 0.01540510f, -0.01979412f, 0.03078899f, -0.05696410f, -0.06052287f, 0.08084954f, 
    -0.13335507f, -0.00776262f, 0.02530315f, 0.06332091f, -0.00703968f, 0.05050116f, -0.06284683f, -0.04174840f, 
    -0.04157441f, -0.06642734f, -0.01152192f, 0.08082169f, 0.07019284f, 0.01377986f, 0.07488187f, 0.01963068f, 
    -0.04752797f, -0.02272312f, 0.08203795f, -0.04089372f, 0.01474690f, 0.06464551f, -0.14086628f, -0.04771843f, 
    0.08133850f, 0.01823706f, -0.04480129f, 0.01730810f, 0.12699343f, 0.05500149f, -0.02446193f, 0.01840459f, 
    0.07156698f, 0.03864279f, 0.00951859f, 0.07666157f, 0.03313543f, -0.06561080f, -0.02349411f, 0.00573346f, 
    0.04745894f, -0.07404377f, -0.04830733f, 0.02854654f, -0.18508892f, -0.00474613f, -0.02723091f, -0.00179280f, 
    -0.08857168f, -0.06154162f, -0.01326209f, 0.05067038f, 0.04880540f, -0.03397610f, 0.03051715f, 0.00993668f, 
    0.01071383f, 0.11889359f, 0.01269043f, 0.16845919f, -0.23630244f, -0.07157496f, 0.17021689f, 0.05347764f, 
    0.09855922f, -0.07526349f, -0.04151206f, 0.01424310f, 0.00275660f, 0.00282635f, 0.06322087f, -0.00011068f, 
    0.02230375f, -0.11492469f, -0.05027913f, 0.05758605f, -0.02309642f, -0.03449228f, 0.02226134f, -0.00007024f, 
    0.13011135f, -0.14120394f, -0.05547256f, 0.03917723f, 0.04310223f, 0.05449501f, -0.02215918f, 0.07350370f, 
    -0.01209483f, -0.02417930f, 0.03310679f, 0.00689648f, 0.10380231f, 0.04969702f, -0.03355078f, -0.05311094f, 
    0.06563639f, -0.09990525f, 0.08326569f, 0.03730581f, -0.09932309f, 0.14074653f, 0.17923298f, -0.06851343f, 
    -0.01318982f, 0.01535908f, 0.03385110f, -0.06145253f, -0.03270625f, 0.07176114f, 0.03140489f, -0.12740043f, 
    0.06155014f, -0.02542951f, 0.06111487f, -0.02557267f, 0.08639561f, 0.01046918f, 0.06874596f, -0.00544344f, 
    -0.19434659f, -0.02113432f, 0.05884477f, -0.03313622f, -0.08275146f, -0.02405768f, 0.01993244f, -0.02494132f, 
    -0.02369707f, 0.04563787f, 0.06249085f, -0.04252381f, 0.04754415f, 0.08978566f, 0.01523370f, -0.03376454f, 
    0.06679337f, -0.05438118f, -0.00631833f, -0.01226133f, -0.16914836f, -0.13416737f, -0.06244279f, 0.07570751f, 
    -0.11615895f, -0.09112403f, 0.00845305f, -0.01397201f, -0.07435299f, -0.05901174f, -0.05586118f, -0.10793284f, 
    0.02104615f, -0.02758755f, 0.07287083f, -0.04437403f, 0.01898781f, 0.12261152f, -0.10285593f, -0.02370275f, 
    -0.18190739f, 0.08498057f, 0.06486165f, 0.03000071f, 0.02141408f, -0.04595558f, -0.01152613f, 0.05944816f, 
    0.02390352f, 0.00883798f, -0.03570243f, -0.01174846f, 0.02595843f, 0.03021073f, -0.00943196f, -0.05437185f, 
    -0.01776990f, 0.07099310f, 0.05572100f, -0.02543825f, 0.04069149f, 0.09577504f, -0.05122572f, 0.09605388f, 
    -0.21114117f, 0.07143238f, -0.05346103f, 0.03164859f, 0.04847019f, 0.01272528f, -0.05378195f, -0.03219950f, 
    0.02992268f, 0.08143602f, 0.06820237f, -0.04669083f, 0.00828944f, 0.04761161f, -0.05478881f, 0.02225912f, 
    0.04757440f, 0.12842581f, 0.01074284f, -0.08169362f, -0.14473410f, 0.07015821f, -0.03483031f, -0.01990263f, 
    -0.05868777f, 0.09628912f, -0.07340121f, -0.01201214f, 0.07015031f, -0.01144381f, -0.01439404f, 0.07340051f, 
    -0.05140987f, -0.02820719f, -0.02015552f, -0.12036894f, -0.36795712f, 0.17824894f, 0.09502122f, -0.03003685f, 
    0.01752588f, -0.01350965f, -0.08046989f, -0.06112691f, -0.03932953f, -0.08261133f, -0.03647754f, 0.13226233f, 
    -0.12323599f, 0.04266984f, 0.05382825f, -0.03512840f, -0.02090647f, 0.04415801f, 0.02220566f, -0.03774223f, 
    -0.34610760f, -0.23425287f, -0.11814680f, 0.22724481f, 0.08938973f, 0.14935194f, 0.00383559f, 0.19298384f, 
    -0.06521251f, 0.11577280f, -0.04007193f, -0.01719862f, 0.03765636f, 0.08503392f, 0.10675722f, 0.02948271f, 
    -0.06470632f, 0.07736675f, 0.04463393f, -0.07728596f, -0.27495313f, 0.22757787f, 0.01513640f, 0.14993331f, 
    0.00978550f, 0.04322625f, -0.07927062f, 0.02731208f, 0.02937802f, -0.00884392f, -0.02767906f, 0.02262517f, 
    -0.02160447f, -0.01103156f, -0.01214454f, 0.01260130f, -0.04828686f, 0.00313470f, 0.00244369f, 0.01207087f, 
    -0.43697223f, 0.03637263f, -0.16624033f, 0.15738389f, 0.10258270f, 0.04153282f, -0.00046126f, 0.07405122f, 
    0.03512537f, 0.09928168f, 0.06397472f, -0.03291294f, -0.03635308f, -0.06671662f, 0.03132105f, 0.02585421f, 
    -0.07799207f, -0.01825569f, 0.02527217f, 0.04505889f, -0.03477351f, -0.03813265f, 0.00316779f, -0.02144994f, 
    0.10932747f, 0.00096645f, 0.08687658f, -0.04363720f, 0.19306898f, 0.05110539f, 0.10818749f, -0.02308752f, 
    -0.02213769f, 0.00954838f, -0.01202957f, -0.02560082f, 0.02959211f, -0.05645435f, 0.11737204f, 0.11419687f, 
    0.01849844f, 0.11606666f, 0.02798506f, 0.09993778f, -0.05409710f, 0.02893411f, 0.00090749f, 0.10777071f, 
    -0.07514770f, -0.08751190f, -0.00163944f, -0.01925112f, -0.08047067f, 0.03507073f, 0.03188038f, 0.02096436f, 
    -0.04176864f, 0.07468401f, -0.10200407f, -0.05419243f, 0.15538581f, -0.21477418f, -0.14005934f, 0.11788363f, 
    -0.16423436f, 0.11531227f, -0.03093614f, 0.06541667f, -0.00580626f, 0.06234461f, -0.04214780f, -0.00240606f, 
    0.01547714f, -0.04986205f, -0.00916136f, 0.02442023f, -0.01983944f, 0.01487126f, -0.04680039f, -0.10953724f, 
    -0.15710030f, -0.04514482f, 0.00592431f, 0.01076663f, 0.09880210f, 0.02312648f, -0.05412604f, -0.02543018f, 
    -0.01680277f, 0.07974597f, -0.01346370f, -0.09529686f, 0.01938472f, 0.00378735f, -0.00714861f, -0.00145342f, 
    0.07467434f, -0.00341322f, 0.04911255f, -0.09953935f, 0.05526899f, 0.31452450f, -0.18912579f, -0.25287533f, 
    0.00786150f, -0.00054486f, -0.01642027f, 0.02183239f, 0.04379030f, -0.04681743f, -0.01949455f, 0.06555016f, 
    -0.01034952f, 0.02309111f, 0.02290872f, 0.13649987f, 0.03576704f, -0.11133561f, 0.01632926f, -0.09396034f, 
    -0.05034530f, 0.00533100f, 0.04557740f, 0.09733137f, -0.00512627f, 0.02848174f, 0.01747246f, -0.00833020f, 
    0.10161088f, -0.00360372f, 0.08714356f, 0.03567444f, -0.03490125f, 0.04338894f, 0.01548857f, -0.01809692f, 
    0.00011670f, -0.01070007f, -0.00850778f, 0.10195971f, -0.14374134f, 0.03010081f, 0.04610826f, 0.01655811f, 
    0.05692758f, -0.01635739f, 0.05597868f, -0.09838910f, 0.06548727f, 0.00166482f, 0.08054543f, -0.04647778f, 
    0.09614100f, 0.01491533f, -0.01099821f, 0.10868233f, 0.02164119f, -0.03853989f, -0.04163923f, -0.05553580f, 
    0.05543713f, 0.14118117f, -0.01548636f, 0.08243705f, 0.03074613f, 0.09663942f, -0.00058909f, 0.00519341f, 
    0.09385417f, 0.01871208f, 0.01640888f, 0.06990962f, -0.01479026f, -0.03943575f, -0.01459604f, -0.02524187f, 
    -0.03866936f, -0.03272722f, -0.00320187f, -0.06670260f, -0.01083913f, 0.04559999f, 0.12019641f, -0.00536964f, 
    0.06985331f, 0.06707188f, 0.03078099f, -0.06648002f, 0.01095545f, -0.01463761f, -0.00335760f, -0.02777764f, 
    0.00811656f, -0.04401239f, 0.02275971f, -0.03972531f, -0.01402177f, 0.01232978f, 0.00420908f, 0.01554122f, 
    -0.13841902f, -0.06478785f, -0.01399894f, 0.10527277f, -0.14145182f, 0.00570805f, -0.04337652f, -0.05720408f, 
    -0.04147840f, 0.02620161f, -0.06835733f, -0.09903015f, -0.03443905f, -0.04397465f, -0.04716973f, 0.03123572f, 
    -0.04532801f, 0.01235662f, -0.10367866f, 0.05966253f, 0.00518624f, -0.07458197f, -0.14081702f, 0.15484114f, 
    0.04329602f, 0.08895472f, 0.02853688f, -0.03417584f, -0.02398695f, -0.09765049f, -0.02849655f, -0.06691135f, 
    -0.00026360f, 0.00723504f, -0.05794629f, -0.05039521f, 0.06755321f, -0.01492938f, 0.00674194f, 0.00814890f, 
    -0.32790118f, 0.03314308f, -0.14722770f, -0.10401838f, -0.11112074f, -0.08162068f, 0.00496995f, -0.05847903f, 
    -0.08966079f, -0.03472494f, -0.10403141f, -0.06638980f, 0.04590248f, -0.00438007f, -0.00136892f, -0.12028052f, 
    -0.09982561f, 0.01984974f, 0.00806114f, -0.11966352f, 0.14473243f, 0.28381756f, -0.03702351f, -0.12075206f, 
    0.07104735f, -0.01402707f, -0.02492077f, 0.06350257f, 0.09387319f, 0.09085952f, -0.02798758f, 0.06167528f, 
    0.02232782f, -0.03038631f, -0.04940128f, 0.05596858f, 0.01913772f, 0.05068321f, 0.04308836f, 0.02807457f, 
    0.30680189f, 0.20664534f, -0.20614640f, 0.01266898f, 0.04712478f, 0.08862619f, 0.02573959f, 0.05159750f, 
    0.12955227f, -0.03179423f, -0.02714443f, 0.02634690f, 0.04666041f, 0.03208674f, -0.01463920f, -0.04379325f, 
    0.03601995f, -0.09098787f, -0.05762550f, 0.02865692f, 0.11794978f, -0.31037721f, -0.02777440f, 0.05074869f, 
    0.03693919f, -0.03202097f, 0.01251066f, -0.00922357f, -0.08339303f, -0.03972360f, -0.01707065f, 0.08067591f, 
    -0.01643331f, -0.01788138f, 0.02049049f, -0.12337037f, -0.05864955f, -0.09782770f, 0.09660508f, -0.06862962f, 
    -0.18789960f, -0.06163405f, 0.00954340f, -0.02964136f, 0.04974455f, -0.02457495f, 0.02080303f, 0.01364102f, 
    0.02349288f, 0.01052931f, 0.00558418f, 0.01294968f, -0.06671092f, -0.07674406f, -0.02247978f, 0.03549186f, 
    0.06225357f, -0.07869660f, 0.07952618f, 0.01984425f, 0.04506327f, 0.11134003f, -0.06549092f, 0.07897652f, 
    0.09231763f, 0.07927069f, 0.00095882f, -0.07015831f, 0.06641349f, 0.05919333f, 0.05191417f, 0.08773566f, 
    0.01994234f, -0.00154536f, -0.02308225f, 0.00328764f, -0.09114281f, -0.00719528f, 0.06085366f, -0.05484765f, 
    -0.34672245f, -0.03355664f, -0.08216292f, 0.10518146f, 0.10989080f, 0.03169240f, 0.04426492f, -0.00792440f, 
    0.12508020f, 0.07536080f, 0.06842837f, -0.01057689f, 0.02319033f, 0.01268849f, 0.02728013f, 0.05249029f, 
    0.02099837f, 0.05042193f, 0.06933452f, 0.04866099f, -0.01775341f, -0.03743749f, -0.00355745f, -0.00254126f, 
    0.06549279f, 0.08830275f, -0.07489005f, 0.06400007f, -0.11942803f, -0.05168080f, -0.02268020f, -0.01272358f, 
    -0.00808876f, 0.02584403f, 0.01612092f, -0.02387827f, 0.02534719f, -0.06763482f, 0.06803182f, -0.05379866f, 
    -0.07765589f, -0.07351554f, 0.13462077f, 0.00394316f, 0.09799129f, -0.07239302f, -0.05073509f, -0.01433094f, 
    -0.03373720f, -0.01905805f, -0.03565173f, 0.04752025f, -0.01638272f, -0.00560431f, -0.00524413f, -0.03372204f, 
    -0.06972429f, 0.01010224f, 0.07449529f, -0.05144273f, -0.68693554f, 0.05804654f, -0.12809500f, -0.11696505f, 
    -0.02563109f, -0.01606662f, -0.01027914f, -0.00576526f, 0.04123811f, -0.04891282f, -0.00017547f, 0.01126251f, 
    -0.08365540f, 0.03551667f, -0.02060694f, 0.03526263f, 0.03345267f, 0.06636541f, 0.00371380f, -0.02652534f, 
    0.04167811f, -0.00641715f, 0.04750047f, -0.00694157f, 0.07216870f, 0.03061640f, 0.04086699f, -0.04087904f, 
    -0.04044899f, -0.04284895f, 0.06097655f, 0.02233000f, -0.09431273f, -0.05123658f, 0.08914445f, -0.05458991f, 
    -0.03647044f, -0.01816946f, -0.02310978f, 0.10697996f, -0.41690260f, 0.06400313f, 0.04517639f, 0.01353809f, 
    0.12453151f, -0.04824383f, 0.00287345f, 0.03847280f, -0.00889971f, -0.01638721f, -0.03928649f, -0.00701018f, 
    0.00468578f, 0.03786343f, 0.06487282f, -0.07398552f, -0.00007183f, 0.05005281f, -0.01008628f, -0.03074850f, 
    -0.19113851f, 0.07134730f, -0.00533876f, -0.15417391f, -0.21121393f, 0.09716908f, 0.01444123f, 0.04948220f, 
    -0.07145450f, 0.00530931f, 0.01131666f, 0.01802568f, -0.04823012f, -0.00376761f, 0.04086313f, 0.01892602f, 
    0.07651308f, -0.01698497f, 0.06056966f, 0.04979472f, 0.16157931f, 0.03506817f, -0.06910227f, -0.19636324f, 
    0.03978135f, -0.08389956f, 0.03554042f, -0.01208836f, 0.02448162f, -0.06849475f, 0.02447720f, -0.07535233f, 
    -0.02376827f, 0.03924204f, -0.00158808f, -0.05651643f, 0.04224060f, 0.00084483f, 0.03114782f, 0.04656718f, 
    -0.22988337f, -0.17048949f, 0.03772755f, -0.01537133f, 0.08017942f, -0.02647114f, -0.05894752f, 0.06490555f, 
    0.05074001f, 0.02196311f, -0.01011430f, 0.02847568f, -0.05613656f, -0.03591582f, -0.04938947f, 0.01584303f, 
    -0.01657721f, -0.06532950f, 0.05687125f, -0.03106882f, -0.03290304f, -0.21091150f, 0.09686154f, 0.11246499f, 
    -0.07171489f, -0.08695231f, 0.01289977f, -0.02803675f, -0.05740881f, -0.00517514f, 0.05329785f, 0.02285323f, 
    -0.01904919f, -0.08286304f, 0.01170981f, -0.04908974f, 0.05031404f, -0.02754156f, 0.05111479f, 0.02383159f, 
    -0.22282803f, -0.31059542f, 0.16998975f, 0.09309941f, 0.07628106f, 0.02187218f, -0.02049453f, -0.05292676f, 
    -0.06805234f, 0.04038459f, -0.00204349f, -0.00934256f, -0.02378140f, -0.00927349f, 0.03577010f, -0.05653613f, 
    -0.11965273f, 0.00896318f, 0.00322901f, -0.01649714f, -0.24259907f, 0.06068156f, -0.13487537f, 0.09299838f, 
    0.16471635f, 0.06982158f, 0.02273026f, 0.05013322f, 0.07839991f, 0.08620615f, -0.01457190f, -0.01842307f, 
    0.03762185f, -0.02538431f, -0.06303289f, -0.02142143f, 0.08241727f, 0.06970244f, 0.04273176f, -0.08124456f, 
    0.19932817f, -0.34241506f, -0.07036599f, 0.01385075f, -0.12108603f, -0.16669321f, 0.02603214f, 0.14058228f, 
    -0.01410990f, -0.03597829f, 0.02413295f, -0.05965210f, 0.06322203f, -0.03944029f, 0.03893246f, 0.05634404f, 
    -0.10930381f, 0.01745889f, -0.03768282f, 0.02766808f, -0.01543050f, -0.32456395f, 0.09186095f, 0.04381014f, 
    -0.05049756f, -0.09765552f, -0.08024134f, 0.04818697f, -0.12882073f, 0.04744554f, 0.09130953f, 0.01449297f, 
    -0.10501935f, -0.01770077f, 0.01434394f, 0.06989393f, -0.02313824f, 0.02415115f, 0.03495184f, 0.05347968f, 
    0.02278011f, 0.02488905f, 0.05405464f, 0.11269844f, 0.01776595f, -0.00242666f, 0.08690839f, -0.00378157f, 
    -0.03793475f, -0.00959171f, -0.00077335f, 0.04313216f, 0.04551625f, -0.04665225f, 0.02340292f, -0.00720676f, 
    0.05636339f, 0.08440189f, 0.03225769f, -0.05976683f, 0.09761166f, 0.21219134f, -0.04323460f, -0.03571935f, 
    0.00111124f, -0.02560150f, -0.03275609f, -0.12686712f, -0.09684597f, 0.04703233f, -0.10082397f, 0.05037661f, 
    -0.05466330f, -0.01188384f, 0.06363580f, 0.07250436f, -0.05995094f, -0.02620934f, 0.08227361f, -0.02492342f, 
    0.09009973f, 0.00981631f, 0.08184242f, 0.07881868f, 0.07201678f, -0.03366430f, -0.12338936f, 0.05066878f, 
    -0.00393081f, 0.07928689f, 0.00718189f, -0.15160368f, 0.03244795f, 0.15501764f, 0.08152484f, 0.03435633f, 
    -0.05524909f, -0.10500358f, -0.05048578f, 0.00041374f, 0.01133638f, -0.10051647f, 0.06598306f, 0.17826821f, 
    0.05765732f, 0.07127645f, 0.06941184f, 0.05457273f, 0.01864357f, 0.05607264f, 0.00260514f, -0.06096739f, 
    0.00668860f, -0.02522540f, -0.03609280f, -0.02363697f, 0.07228343f, -0.08124126f, 0.05567640f, 0.02834894f, 
    0.13443917f, 0.00547794f, 0.17300127f, 0.09823334f, -0.06004790f, 0.00848942f, 0.12293032f, 0.08314984f, 
    0.06635090f, 0.04201197f, 0.06384839f, -0.03545214f, -0.07256118f, -0.06615493f, -0.03279462f, 0.06080488f, 
    0.01426835f, 0.07648165f, -0.00501125f, 0.04080889f, -0.09591921f, 0.04256687f, 0.20350102f, 0.11131945f, 
    -0.12620232f, -0.05017340f, 0.00968365f, 0.03361000f, -0.03047741f, 0.03303257f, -0.09012783f, -0.00148129f, 
    -0.02069845f, -0.05748322f, -0.13632841f, -0.04581906f, -0.06656897f, -0.20395619f, 0.04088137f, -0.02168697f, 
    -0.01346356f, -0.09702727f, 0.01377413f, 0.09603284f, 0.02109405f, -0.02284106f, -0.13590267f, 0.03301346f, 
    -0.06676329f, -0.02173685f, 0.00904742f, 0.03832139f, 0.03366711f, -0.02397405f, 0.05435727f, -0.02152338f, 
    -0.08497531f, 0.02943714f, 0.06698557f, 0.02175168f, 0.01949802f, 0.00510804f, -0.06125765f, 0.10124731f, 
    0.07432251f, -0.08902743f, -0.00585847f, 0.07178578f, -0.02068165f, 0.02852888f, -0.00565642f, 0.01778327f, 
    -0.02354112f, 0.07430287f, -0.00470681f, -0.04061885f, -0.00381940f, -0.01791729f, 0.11585825f, -0.03095966f, 
    -0.12987629f, -0.00871697f, -0.10075624f, -0.03596098f, 0.06316959f, 0.06457470f, 0.05684842f, -0.00093798f, 
    0.02688891f, -0.08970641f, -0.03106726f, -0.02662414f, 0.04524133f, 0.01950023f, -0.03160749f, -0.09240063f, 
    -0.03332614f, -0.02714471f, -0.13069454f, -0.05592202f, 0.05664182f, -0.05732859f, 0.00991050f, 0.05530482f, 
    -0.04336281f, -0.16412742f, -0.01871130f, -0.00081222f, 0.04712062f, -0.01348747f, -0.08348800f, -0.02607513f, 
    0.06932897f, 0.05328947f, 0.12652609f, -0.05927444f, -0.06685672f, 0.06184412f, 0.06075361f, -0.03672983f, 
    0.10982814f, 0.24309038f, -0.13980184f, -0.10501106f, -0.20576270f, 0.06521006f, -0.04127691f, 0.07392418f, 
    0.01134685f, 0.08753008f, 0.06385644f, -0.00489818f, -0.13417336f, -0.09052202f, -0.09850087f, 0.04022275f, 
    -0.06902993f, 0.08407002f, -0.00149415f, -0.05163182f, -0.00013643f, 0.24603315f, -0.12764263f, -0.09721661f, 
    -0.05364924f, 0.02404729f, 0.06716039f, 0.04874337f, -0.05482161f, -0.11044569f, 0.07458412f, -0.01283734f, 
    -0.07701313f, -0.07769639f, -0.00648049f, -0.03251743f, -0.05322057f, 0.01545256f, 0.10866024f, -0.01596822f, 
    -0.05661109f, 0.04007480f, 0.23319229f, 0.13969627f, -0.15761954f, 0.08017014f, 0.03568328f, 0.00273533f, 
    0.06475484f, -0.00199518f, -0.04036782f, 0.03916194f, 0.00688691f, -0.06578787f, 0.01009241f, -0.12040290f, 
    -0.08092308f, 0.01415484f, 0.03385596f, -0.02306212f, -0.01192739f, -0.02756865f, 0.03736456f, 0.04082013f, 
    -0.01467396f, -0.06061525f, 0.04433782f, 0.00003929f, 0.00302094f, -0.02658563f, -0.03595091f, -0.02914879f, 
    0.07571147f, 0.03756821f, 0.05459124f, -0.01518138f, -0.08085222f, 0.06678420f, 0.05906205f, 0.02237055f, 
    -0.22962146f, -0.14134298f, 0.05049779f, 0.29521400f, -0.01147411f, -0.11518525f, 0.01112744f, -0.04207336f, 
    -0.00880602f, 0.03209788f, 0.08111794f, -0.01093659f, 0.10027943f, 0.02573401f, 0.03580354f, 0.02203380f, 
    0.02575931f, -0.01540592f, -0.04722729f, -0.08823896f, -0.07176698f, -0.12346221f, 0.04314854f, 0.08032469f, 
    0.12606211f, 0.01083701f, -0.00583617f, 0.07880853f, 0.00616752f, 0.01809574f, 0.02673309f, -0.02371376f, 
    0.03562612f, -0.01291612f, -0.02560466f, -0.05994025f, -0.04842773f, 0.02375898f, -0.01888888f, -0.09713450f, 
    -0.41211861f, -0.16227721f, -0.08364246f, 0.08632049f, -0.07796808f, -0.04008743f, 0.17695223f, -0.07608982f, 
    -0.01681972f, 0.05390294f, 0.02299063f, -0.03879683f, 0.09859765f, 0.04998568f, -0.13592327f, -0.01930088f, 
    0.13804331f, -0.08426488f, 0.02798724f, 0.10990816f, -0.33417329f, -0.19871399f, 0.06605501f, 0.00754691f, 
    -0.13854641f, -0.07832172f, 0.02008284f, 0.06445371f, -0.06043748f, 0.07259674f, -0.04323239f, 0.07365473f, 
    -0.00625485f, -0.01023072f, -0.08658872f, -0.01960411f, 0.10772479f, -0.07105184f, -0.02076320f, 0.04624311f, 
    -0.10380007f, 0.05909776f, -0.03311708f, 0.08443299f, 0.07200555f, 0.08280028f, -0.07334960f, 0.04361873f, 
    0.10168267f, 0.01017991f, -0.02491405f, 0.02170502f, -0.09588294f, -0.05358417f, 0.10994193f, -0.15340257f, 
    -0.06326620f, -0.01325257f, -0.02748257f, -0.05765929f, -0.05430372f, 0.01643334f, 0.09222379f, 0.12254186f, 
    -0.14692609f, 0.02886999f, 0.02203008f, -0.06146034f, 0.01138150f, -0.02279786f, -0.01491172f, -0.07382847f, 
    -0.03705845f, 0.02206332f, -0.06650169f, -0.04783539f, 0.02903412f, 0.10174931f, 0.07002914f, 0.05411286f, 
    0.03394660f, -0.04337846f, 0.12994538f, 0.26227030f, -0.01053119f, -0.01377146f, -0.06712501f, -0.05962573f, 
    0.07877288f, 0.09667927f, -0.15600576f, 0.02099808f, -0.11420701f, 0.16528262f, -0.02442077f, 0.01125468f, 
    0.07677459f, -0.19568168f, -0.07503989f, 0.04755840f, 0.00510762f, -0.04466623f, -0.00356482f, 0.05823728f, 
    -0.13157886f, -0.11352665f, 0.04837703f, -0.02676453f, 0.01842320f, -0.01725579f, -0.07294326f, -0.01265083f, 
    0.03914684f, 0.07190264f, 0.14943580f, -0.06005580f, -0.08182260f, 0.05433661f, 0.03844484f, 0.02450772f, 
    0.02138600f, 0.21017256f, 0.11761547f, 0.05452874f, -0.09241486f, 0.03878554f, -0.05287512f, 0.07755290f, 
    -0.04399240f, -0.03139192f, 0.03477313f, 0.00182009f, -0.05567479f, -0.05539081f, -0.05545149f, -0.02925823f, 
    -0.12576833f, 0.10575757f, 0.00819633f, 0.11596426f, 0.01501832f, -0.02172993f, -0.07110295f, -0.05323623f, 
    -0.02853649f, 0.03213423f, 0.10205262f, 0.00890495f, -0.03623572f, 0.02856243f, 0.01404777f, 0.07902054f, 
    0.01088388f, -0.10051677f, -0.01228285f, -0.03891142f, -0.01736236f, 0.10080056f, -0.01025264f, -0.06482925f, 
    0.07697166f, 0.04611300f, -0.08499931f, 0.07674075f, -0.10534175f, 0.14277852f, 0.01062201f, -0.04096296f, 
    0.00028773f, -0.00198186f, -0.02980621f, 0.08033866f, 0.08335830f, 0.00627462f, 0.03203752f, -0.04634504f, 
    -0.12972064f, 0.00481563f, -0.11491127f, -0.01185525f, 0.00324042f, 0.09805046f, 0.05560474f, -0.00846609f, 
    0.01867593f, -0.08808841f, 0.00221717f, -0.02694208f, -0.05116344f, 0.12691076f, -0.04957088f, -0.07959525f, 
    -0.07384647f, 0.03483226f, -0.00434959f, 0.04343595f, 0.06329788f, -0.15468976f, 0.03080873f, -0.01664543f, 
    -0.31107479f, -0.02630296f, -0.12282478f, -0.14845531f, 0.03851021f, 0.09134651f, 0.01087252f, 0.01189327f, 
    -0.05377506f, -0.04920404f, 0.01632437f, -0.01440008f, -0.01968146f, -0.01184778f, 0.03413443f, -0.01081754f, 
    0.05643727f, -0.07390883f, -0.00797508f, 0.04094663f, 0.03843077f, 0.15434054f, -0.04363216f, -0.10000911f, 
    0.07682041f, -0.09101266f, 0.02371022f, -0.01137577f, -0.04258789f, 0.00921196f, 0.15397914f, 0.08104568f, 
    0.03093078f, -0.01097589f, -0.01019289f, -0.03353776f, 0.06674401f, -0.04365249f, 0.07614207f, -0.02801443f, 
    -0.12565231f, -0.15887745f, -0.08669657f, -0.10615878f, 0.04111402f, 0.01150913f, 0.09493906f, -0.02210073f, 
    -0.08754765f, -0.03200999f, 0.03779085f, 0.00587002f, -0.06119817f, -0.05080607f, 0.01253183f, -0.10571202f, 
    -0.02760771f, 0.09973355f, -0.01804793f, -0.02111605f, -0.30739743f, 0.16569309f, -0.19860189f, -0.04949468f, 
    0.08989767f, 0.16338989f, 0.01151824f, 0.00356835f, 0.07816123f, -0.04652183f, -0.05299152f, -0.05963123f, 
    0.08357774f, -0.09633473f, -0.00303618f, 0.02604903f, 0.05980501f, -0.09524205f, 0.03156995f, -0.04854289f, 
    -0.03513118f, 0.17099997f, 0.08624842f, -0.13379194f, -0.05549647f, -0.06201986f, 0.02678875f, 0.03546098f, 
    0.04755316f, -0.12016023f, 0.03143555f, 0.08030938f, -0.03420554f, -0.11505134f, 0.01222584f, 0.05663118f, 
    0.03171609f, 0.00398497f, 0.03290110f, 0.00915394f, -0.33156797f, -0.03205097f, -0.13027231f, -0.09926274f, 
    0.05034843f, 0.05143535f, 0.03045054f, -0.07819508f, -0.06267824f, -0.00763937f, 0.02914631f, 0.00798990f, 
    0.09390728f, -0.03326939f, 0.01710274f, -0.02528752f, 0.06683249f, 0.00305866f, 0.02260752f, -0.06443980f, 
    -0.36577538f, 0.03237054f, -0.12575497f, -0.09359875f, -0.05362654f, 0.03945677f, 0.07546372f, -0.01063265f, 
    -0.03467119f, -0.05431191f, -0.02119126f, 0.13227876f, 0.06152019f, -0.08682984f, -0.13402411f, 0.05078703f, 
    -0.03169857f, -0.04593169f, 0.00290639f, 0.04184448f, -0.25257429f, -0.01394272f, -0.12912205f, -0.04595521f, 
    -0.00626459f, 0.10212683f, 0.13171530f, 0.01973957f, -0.05624899f, 0.15205966f, -0.06731074f, 0.14505203f, 
    0.07458960f, -0.03498549f, 0.05644815f, -0.04968297f, -0.02774251f, 0.02282191f, 0.01564191f, -0.14544386f, 
    0.05282103f, -0.11808197f, 0.08321288f, 0.17490803f, -0.05866241f, -0.07468846f, -0.06637297f, -0.07715322f, 
    0.08940688f, -0.04821217f, 0.07228713f, 0.07097800f, -0.02339433f, 0.05718998f, 0.05363728f, -0.07973768f, 
    -0.10457647f, -0.01581839f, 0.07382990f, -0.02322880f, 0.17557791f, 0.13074063f, 0.10179191f, -0.09660303f, 
    -0.02865073f, -0.07476851f, 0.11726546f, -0.03025501f, -0.13083972f, 0.07385601f, 0.01791218f, -0.02870680f, 
    -0.05187896f, -0.00352903f, -0.00145658f, 0.05922128f, 0.04402779f, 0.01012036f, 0.07074607f, 0.05106361f, 
    -0.22570439f, -0.07834629f, -0.23038888f, -0.06404243f, -0.00095740f, 0.10836796f, 0.10217077f, 0.10258462f, 
    -0.01083422f, 0.01169749f, 0.11337125f, 0.00410896f, 0.02891155f, -0.01784959f, -0.05860332f, -0.02480133f, 
    -0.06117769f, -0.02910826f, -0.12909780f, 0.05474888f, -0.26450959f, -0.20900840f, 0.11622155f, 0.14139746f, 
    -0.17313206f, 0.08869587f, 0.00267158f, -0.11336049f, 0.03905062f, -0.03889456f, -0.03271350f, -0.05587699f, 
    0.01685785f, 0.07081939f, -0.00760567f, -0.00306066f, 0.08958073f, 0.03682584f, 0.07351620f, -0.03889753f, 
    -0.05008446f, -0.01777095f, -0.11788217f, 0.06015449f, 0.16555515f, 0.03559437f, -0.02819963f, -0.00672280f, 
    0.02884464f, 0.07508985f, 0.00561421f, 0.14676914f, 0.14388952f, 0.09739321f, 0.04844700f, -0.03810461f, 
    0.03086135f, -0.02574701f, -0.06338986f, -0.09398776f, 0.13477419f, -0.06481066f, 0.19194910f, 0.04534813f, 
    0.07340294f, 0.02632697f, 0.00268815f, -0.00760944f, -0.05098673f, -0.04744247f, 0.04006023f, -0.05624744f, 
    -0.09630817f, 0.11215679f, -0.01866788f, 0.09583966f, -0.01718972f, 0.00662893f, 0.03447095f, 0.04009794f, 
    -0.24494082f, -0.19202282f, -0.09282386f, -0.03214720f, 0.04913696f, 0.02497855f, 0.03857352f, -0.03151101f, 
    -0.02331004f, 0.02188754f, 0.03438920f, 0.07026366f, 0.06671409f, 0.06163809f, -0.02890332f, -0.08497713f, 
    0.01135457f, -0.00522734f, -0.06160485f, -0.02902929f, -0.04286804f, -0.06740756f, -0.05755446f, 0.11865624f, 
    0.03291228f, 0.00619269f, 0.04199115f, 0.04352113f, 0.00490938f, -0.00581037f, 0.07611791f, 0.01739030f, 
    0.02280100f, -0.01286252f, 0.11074159f, -0.04599665f, -0.01782566f, 0.00326784f, 0.07329727f, -0.07976655f, 
    0.00255191f, -0.05904266f, -0.14689496f, 0.01548638f, -0.18488501f, 0.06818668f, -0.10491443f, 0.02714083f, 
    -0.00591359f, 0.09534279f, 0.01130750f, 0.00352851f, -0.00612974f, -0.04904743f, -0.13307178f, 0.03905987f, 
    -0.02644096f, -0.03301303f, 0.09660000f, -0.01701401f, 0.03460804f, -0.05854682f, -0.08020670f, 0.03586819f, 
    -0.03684571f, 0.02438363f, -0.00489222f, 0.03718351f, 0.08766586f, 0.00334809f, 0.00455974f, 0.07979228f, 
    -0.06812564f, 0.03781198f, -0.07007042f, 0.10462905f, -0.00626708f, 0.04982467f, -0.05711003f, -0.03796217f, 
    -0.17018858f, -0.08175286f, 0.15508324f, 0.05889638f, -0.00363927f, -0.11966625f, -0.14052057f, -0.04671752f, 
    0.03669184f, -0.02167104f, 0.08669458f, -0.18531217f, -0.11923507f, 0.06630130f, 0.01894077f, 0.07428127f, 
    0.09173395f, -0.04772153f, -0.19953817f, -0.00298455f, -0.21097949f, -0.15461159f, 0.17059906f, 0.15890676f, 
    -0.35120401f, 0.03345663f, -0.02889498f, -0.06227794f, 0.03409474f, -0.11151814f, -0.07980326f, 0.01157451f, 
    0.01235429f, -0.13949285f, 0.09122902f, 0.05304800f, 0.00838396f, 0.04177076f, 0.11793796f, -0.05528857f, 
    -0.13303310f, -0.03074606f, 0.22347985f, 0.02895808f, -0.27109712f, 0.04187269f, -0.08393973f, -0.01777953f, 
    -0.06460470f, -0.03720960f, 0.04225311f, -0.03299833f, -0.06062474f, -0.05721569f, -0.09943714f, -0.00230484f, 
    0.01852720f, 0.12513460f, -0.00078271f, -0.00687701f, -0.00583189f, 0.09361491f, 0.02888360f, 0.08988299f, 
    -0.18787320f, -0.04774890f, -0.04866428f, 0.03443708f, -0.01345703f, 0.12228989f, 0.05482655f, -0.12400720f, 
    -0.01989935f, 0.00533043f, -0.06934431f, 0.12762950f, 0.00251965f, 0.00120737f, 0.03675042f, 0.08300897f, 
    0.05399137f, -0.01793419f, 0.02655607f, 0.07433914f, -0.14018518f, -0.02438882f, 0.04957908f, -0.00737543f, 
    0.00191631f, -0.03008455f, -0.00539507f, 0.01786007f, 0.07879518f, 0.03438419f, 0.02672594f, 0.01903634f, 
    -0.00091412f, 0.07858657f, 0.06886987f, -0.01295711f, -0.43471497f, -0.19617641f, -0.16364385f, -0.09343730f, 
    0.04076773f, -0.00715992f, 0.06622402f, -0.07691906f, -0.00182405f, -0.01913990f, -0.01015374f, 0.03183817f, 
    0.02803421f, 0.03982165f, -0.05617833f, -0.03560624f, 0.06817899f, -0.00054903f, -0.06126754f, 0.05941611f, 
    -0.30817896f, 0.04718757f, -0.24619263f, -0.16816249f, 0.00309989f, 0.08471286f, 0.16138025f, 0.05835750f, 
    -0.02853563f, -0.01847782f, -0.01332000f, 0.07808691f, -0.03786455f, -0.05018892f, 0.01235001f, 0.06586362f, 
    0.02435524f, 0.04934717f, 0.04544224f, 0.00837102f, -0.18094724f, 0.04308131f, -0.00117658f, 0.12843496f, 
    0.02410191f, -0.08335931f, -0.00373395f, 0.00862295f, -0.06295203f, 0.05519724f, 0.16926226f, 0.03674208f, 
    -0.05287872f, -0.00610591f, -0.13496599f, -0.03303233f, -0.03855912f, 0.01598964f, 0.03180623f, -0.04181672f, 
    0.26364714f, 0.05429959f, -0.08757279f, 0.02746198f, 0.02203840f, 0.02509611f, -0.04425760f, -0.00953436f, 
    0.07569832f, 0.05093201f, -0.05640802f, -0.03611610f, -0.00361996f, 0.08358653f, 0.13116245f, 0.00957845f, 
    -0.01673530f, 0.03945740f, -0.18485001f, -0.03650259f, -0.51062053f, 0.12564285f, -0.16180947f, -0.10652690f, 
    -0.03032816f, 0.02590604f, 0.08356400f, 0.10543256f, 0.02113149f, -0.08044904f, 0.03108910f, -0.01248381f, 
    0.08124916f, -0.08658116f, 0.01779815f, 0.05966980f, 0.01243748f, -0.05057255f, -0.01332231f, 0.04935507f, 
    0.00072025f, -0.06124703f, -0.05098572f, 0.07117198f, 0.19018222f, -0.03549058f, 0.00907084f, -0.06406220f, 
    -0.06343882f, 0.08832458f, -0.02083522f, 0.01769725f, 0.09681606f, 0.10124310f, 0.04494897f, 0.09082690f, 
    0.03219746f, -0.02859487f, -0.22545773f, 0.03530359f, -0.37287769f, -0.02956917f, -0.10048482f, -0.14877191f, 
    0.01279144f, 0.09967104f, -0.04111450f, 0.04820763f, -0.04924188f, -0.06449332f, 0.02979934f, -0.03721284f, 
    -0.03071458f, -0.00135644f, 0.00045999f, 0.07188787f, 0.02185999f, -0.04362800f, -0.04180485f, 0.06571928f, 
    -0.16607460f, -0.10789694f, 0.06998282f, -0.04872898f, -0.05971963f, -0.15946268f, -0.01587985f, 0.05679508f, 
    -0.08667196f, -0.00198782f, 0.00491395f, -0.05215995f, 0.08373361f, -0.05115318f, -0.07503225f, -0.02394405f, 
    0.03048297f, -0.10498440f, 0.03150773f, 0.05872908f, -0.09535987f, 0.10058719f, 0.03554343f, 0.24403919f, 
    0.13584448f, 0.01736531f, 0.00988840f, 0.04214396f, -0.07040714f, 0.06002182f, 0.06659320f, 0.04572489f, 
    0.03577179f, -0.08567870f, 0.03350734f, -0.05243702f, 0.00844701f, -0.02407977f, 0.03823191f, -0.03057019f, 
    0.14723569f, -0.04526953f, -0.00327848f, -0.02372278f, -0.25861132f, -0.08223296f, -0.02319017f, -0.00091534f, 
    0.04522003f, 0.00791478f, -0.00930316f, 0.04661661f, 0.06165326f, 0.00093227f, 0.00737875f, -0.04319478f, 
    0.09508201f, 0.04119818f, 0.02278228f, 0.06454512f, 0.05028417f, 0.04807022f, 0.02957918f, 0.09527075f, 
    0.19104698f, -0.02720746f, -0.01868953f, 0.01304957f, -0.04471287f, 0.06992329f, -0.07008433f, -0.12428407f, 
    0.09036876f, 0.07641920f, 0.05145493f, 0.04181062f, 0.00805678f, -0.07797244f, 0.05286516f, 0.03962579f, 
    0.08654865f, 0.04905982f, -0.00524303f, 0.12659138f, 0.12702699f, -0.14217889f, -0.03179245f, 0.08660637f, 
    0.07164033f, 0.06128428f, -0.01346366f, -0.15131159f, 0.03841323f, 0.12572940f, 0.10521236f, 0.04295512f, 
    0.09741884f, -0.07778999f, -0.12419008f, -0.01871941f, -0.43662003f, -0.01941558f, -0.17928016f, -0.21104214f, 
    -0.04879367f, 0.11204478f, 0.02079190f, 0.02077255f, -0.00155026f, -0.08443391f, 0.01934138f, 0.05302435f, 
    -0.14342856f, 0.08591221f, -0.05563244f, 0.07088853f, -0.02757188f, 0.04967588f, -0.13619743f, 0.02581913f, 
    -0.08262055f, 0.19382909f, -0.00233893f, 0.13823682f, -0.11244616f, -0.03713058f, 0.02046144f, -0.07421778f, 
    0.05759380f, 0.03478693f, -0.02794142f, -0.09695351f, -0.18052399f, 0.17751575f, -0.03917033f, -0.06184157f, 
    -0.06601371f, 0.06464673f, -0.03686559f, 0.01785629f, 0.06434936f, 0.03736069f, -0.01550175f, 0.07845443f, 
    0.13687180f, -0.03179440f, -0.00285337f, -0.19484927f, 0.00898212f, 0.07366918f, -0.01658440f, -0.02779467f, 
    0.07796002f, 0.06525677f, 0.00524673f, -0.01607143f, -0.03059300f, 0.07523534f, 0.00276009f, -0.05390885f, 
    -0.17045785f, 0.15948521f, -0.07680507f, 0.16240834f, 0.06077980f, -0.07913794f, -0.06801140f, -0.05277921f, 
    0.05404649f, -0.02598966f, -0.00959998f, 0.03610484f, -0.02098816f, 0.04762093f, 0.04747624f, -0.09359431f, 
    -0.02913751f, 0.01211814f, -0.06003731f, 0.03097313f, -0.18545294f, 0.00143924f, -0.14743230f, 0.14855446f, 
    0.06431178f, 0.01136050f, 0.01298270f, -0.00309545f, 0.07272976f, 0.08158536f, 0.05693425f, -0.01628968f, 
    0.07406523f, -0.04364869f, -0.03496188f, -0.01259526f, 0.05206435f, -0.07735063f, -0.02521100f, -0.00663805f, 
    -0.07471479f, 0.18547674f, -0.02737294f, -0.03691271f, -0.17035846f, 0.04829198f, 0.07394300f, -0.00369155f, 
    0.00284859f, 0.05961261f, -0.05288360f, 0.00912540f, 0.00128197f, 0.03711960f, -0.10818273f, -0.00077557f, 
    0.02612001f, 0.02936805f, 0.06998949f, -0.05593315f, -0.03048723f, 0.12044176f, -0.00597354f, 0.05067701f, 
    -0.06867377f, -0.04299093f, 0.00702420f, -0.03311275f, 0.06376904f, -0.02151810f, -0.03291953f, -0.03384209f, 
    -0.00508682f, -0.02159948f, -0.00876902f, -0.02486930f, -0.05702618f, -0.01182671f, -0.12599722f, -0.01807721f, 
    -0.12041741f, -0.05836846f, -0.02582066f, 0.20458755f, -0.00108479f, -0.20834477f, 0.00009809f, 0.00771496f, 
    -0.04016235f, 0.07183395f, -0.01288790f, 0.09555183f, 0.01071336f, 0.02486105f, -0.00820089f, 0.04352392f, 
    0.01800289f, -0.09269739f, 0.06848710f, -0.13589829f, -0.04621444f, -0.11695164f, 0.04704148f, 0.22174086f, 
    0.27564374f, 0.02434870f, 0.12346458f, -0.00801169f, 0.02823110f, -0.01978539f, -0.01625645f, -0.02815005f, 
    -0.01911846f, 0.02815175f, 0.03334074f, 0.12464008f, 0.01143368f, 0.15543358f, 0.03905563f, 0.02186773f, 
    -0.20107675f, 0.20753030f, -0.07147069f, 0.12446345f, -0.38898039f, -0.04976207f, 0.08645201f, 0.04345719f, 
    0.10071943f, -0.01604424f, 0.01162910f, -0.01903851f, 0.00531403f, -0.04129504f, -0.00738105f, -0.06967415f, 
    -0.05220094f, 0.07695974f, -0.06260702f, 0.08563922f, 0.04286134f, 0.08944354f, -0.08856580f, 0.06042193f, 
    -0.15991098f, 0.03785412f, 0.11254339f, -0.03500849f, -0.01507699f, -0.06025006f, 0.04332838f, 0.01753656f, 
    -0.08483445f, -0.03836391f, -0.04810629f, -0.00562458f, -0.05331298f, 0.14585355f, -0.07644278f, 0.13705669f, 
    0.26798719f, 0.05969354f, -0.04446372f, -0.24002478f, -0.09034014f, 0.03209516f, 0.01445727f, 0.12037761f, 
    -0.01363299f, -0.05749350f, -0.04391555f, -0.07105269f, 0.10186370f, -0.05966173f, 0.06480736f, 0.07974753f, 
    0.02291531f, 0.07288261f, -0.03003966f, 0.13347381f, -0.10191660f, 0.18495974f, 0.13618788f, 0.07199393f, 
    -0.27746207f, 0.08579101f, -0.04251467f, 0.01115354f, -0.01904594f, 0.01467616f, 0.00673157f, 0.03840773f, 
    -0.05217896f, -0.01541630f, -0.05321628f, 0.01851580f, 0.04021784f, -0.07860423f, 0.00287696f, -0.02570420f, 
    0.09315205f, -0.46295270f, -0.05308253f, -0.03123243f, -0.06901360f, 0.05918476f, 0.00571744f, 0.00922488f, 
    -0.08368213f, -0.07343038f, -0.11443748f, -0.04599504f, 0.04867471f, 0.01916342f, 0.12551905f, 0.03661782f, 
    0.04759911f, 0.05507052f, 0.04569869f, -0.06865697f, 0.03886230f, -0.42280146f, -0.04356866f, -0.18038836f, 
    0.07671167f, 0.05770115f, -0.00285697f, -0.05266659f, 0.01808956f, -0.00293894f, 0.00381146f, 0.02855130f, 
    0.05726224f, 0.06829257f, -0.02185786f, 0.06621224f, -0.01462149f, -0.10222173f, -0.18065883f, 0.00923943f, 
    -0.00695522f, 0.05946685f, 0.07364683f, -0.08909926f, 0.24100962f, -0.09574822f, 0.03077258f, -0.05359596f, 
    0.08146740f, 0.07405864f, -0.01369800f, 0.01505830f, 0.07436396f, -0.05503946f, -0.04067764f, 0.12682158f, 
    -0.00853283f, 0.05590171f, 0.01233998f, 0.00503018f, -0.12868473f, 0.12908420f, 0.08634183f, 0.06107759f, 
    -0.18663017f, 0.03978870f, -0.01744756f, 0.01315654f, 0.02161987f, 0.04114426f, -0.02373826f, 0.01426222f, 
    -0.00939686f, 0.03147969f, -0.03541305f, 0.04835356f, 0.04522466f, -0.05348707f, -0.02982122f, -0.08049594f, 
    0.09972521f, -0.06785880f, -0.01007806f, 0.02381596f, 0.39788887f, 0.00380696f, -0.04690505f, 0.05610532f, 
    0.00994454f, -0.02123002f, -0.09665604f, 0.04135045f, -0.03239923f, 0.02705354f, 0.11723559f, -0.07098064f, 
    -0.03538296f, 0.11939060f, 0.08466444f, 0.07637778f, -0.10263711f, -0.06280653f, -0.01009214f, -0.04053574f, 
    -0.07791086f, -0.08226895f, 0.02520351f, -0.03151241f, 0.00971721f, 0.04848959f, -0.11691466f, -0.08835048f, 
    0.00537970f, 0.07518608f, -0.00912953f, 0.00313546f, 0.01709297f, 0.06340081f, 0.01615926f, 0.08117044f, 
    0.00791872f, 0.03473867f, 0.08199299f, 0.03118069f, 0.05374873f, -0.00018564f, -0.15053983f, 0.03696742f, 
    0.03275999f, 0.04417813f, -0.07418270f, 0.01119552f, -0.09322237f, 0.04032463f, -0.04414006f, 0.01888110f, 
    0.00722544f, 0.05224899f, -0.09892385f, -0.08450273f, 0.24828258f, 0.05388875f, -0.01463492f, 0.18209134f, 
    0.16856493f, -0.11959574f, 0.01026750f, -0.05757412f, 0.03047736f, -0.05542153f, -0.00561267f, 0.02401095f, 
    -0.02518098f, 0.09081523f, -0.00000251f, -0.02900001f, 0.01603949f, -0.02943918f, -0.02527521f, 0.00518189f, 
    0.17338125f, -0.03067776f, -0.08346241f, -0.17513505f, -0.12772794f, 0.01921527f, 0.13565758f, 0.00644693f, 
    -0.10924227f, 0.07860096f, -0.06526170f, -0.07989731f, 0.05600311f, -0.05392367f, -0.11948799f, 0.05671743f, 
    -0.04157407f, 0.06585245f, 0.05858425f, 0.03844547f, 0.08830371f, 0.03267246f, -0.01231951f, 0.16893485f, 
    -0.07653106f, -0.04735309f, -0.06323012f, 0.02898250f, 0.01409523f, 0.06995849f, 0.04980950f, 0.11655580f, 
    -0.01132036f, -0.01960470f, 0.00225992f, 0.00247566f, 0.04703193f, -0.11529226f, -0.02450742f, -0.16800039f, 
    -0.15152617f, 0.02386072f, 0.04184020f, 0.11060376f, -0.05761790f, 0.07682204f, -0.02466883f, 0.01511727f, 
    -0.11021243f, 0.01070072f, -0.01763860f, 0.02647531f, -0.05878562f, -0.01240173f, 0.07454083f, 0.04358291f, 
    0.01085409f, 0.05618946f, 0.03843857f, 0.06612521f, -0.23286398f, 0.18699971f, 0.12975188f, 0.07805847f, 
    -0.35030851f, 0.05836423f, -0.07820889f, -0.00162272f, 0.01434490f, 0.05995881f, -0.01845023f, -0.01965299f, 
    -0.02384470f, 0.00933580f, -0.10270133f, -0.00834563f, 0.11041009f, -0.07690495f, 0.01434085f, -0.04552479f, 
    0.05969874f, -0.22031370f, 0.00243921f, 0.17202798f, -0.12268063f, -0.03450675f, -0.00746744f, -0.11537352f, 
    0.05189861f, -0.00104900f, -0.09889546f, 0.01185221f, 0.06865520f, 0.01896436f, 0.01736566f, 0.02965751f, 
    -0.03634677f, 0.06185655f, -0.00809708f, -0.07017721f, 0.16399810f, -0.12331650f, 0.08754180f, 0.03347426f, 
    0.08045030f, 0.10456464f, -0.04955268f, 0.04196563f, -0.00556240f, -0.15302129f, -0.03509650f, -0.00714304f, 
    -0.02355305f, 0.06571013f, 0.06726138f, 0.06408586f, 0.03979136f, -0.16502586f, -0.07724103f, -0.05037199f, 
    0.08086348f, -0.07377010f, -0.11330093f, -0.12191887f, 0.15572816f, 0.04691334f, 0.00753842f, 0.04865155f, 
    -0.04718710f, -0.08972685f, -0.03893948f, -0.01830325f, -0.09023669f, -0.10114963f, 0.01602347f, 0.00862954f, 
    0.07670650f, 0.07939931f, 0.12396181f, 0.00003990f, 0.10806892f, 0.02032525f, -0.11981568f, 0.11003935f, 
    -0.07150415f, -0.01196738f, 0.13424550f, -0.06771377f, 0.00130621f, 0.08284108f, 0.01692727f, 0.00262896f, 
    -0.11078853f, 0.04823652f, -0.01192023f, -0.10983522f, -0.01129523f, 0.16807559f, -0.10881661f, 0.09286079f, 
    0.04574119f, -0.11474413f, -0.01836117f, -0.03291821f, 0.06650512f, 0.02107265f, 0.12753589f, -0.00043868f, 
    0.01440720f, -0.06294685f, 0.03381648f, 0.08795332f, -0.03737121f, 0.00053420f, 0.05949371f, -0.05076514f, 
    -0.04141068f, 0.01429494f, -0.04678107f, 0.06255056f, -0.13674277f, -0.17976558f, -0.12370723f, 0.05020613f, 
    0.13581422f, -0.03179188f, 0.06936567f, -0.07546505f, -0.00905210f, 0.01403124f, -0.00658965f, -0.01869244f, 
    0.05031304f, 0.02314626f, -0.04567755f, 0.04049378f, -0.05395976f, 0.02207071f, -0.10132141f, 0.04047826f, 
    -0.00091387f, -0.28780869f, 0.07255947f, -0.03225697f, 0.29760429f, 0.08997943f, -0.13635005f, 0.03679818f, 
    0.01296375f, -0.07214296f, -0.04662123f, -0.12780218f, 0.09901528f, 0.02421078f, -0.13070972f, 0.07430146f, 
    0.05598313f, -0.05940495f, 0.01793801f, 0.03000952f, 0.23316716f, -0.39863652f, 0.01280589f, -0.02987630f, 
    -0.01495703f, 0.02077357f, 0.07967661f, -0.01650273f, -0.04380908f, -0.12780482f, 0.10954423f, -0.01478623f, 
    -0.01604142f, 0.05586362f, -0.04046715f, 0.01143967f, -0.00882677f, -0.00855665f, -0.02326380f, 0.08619745f, 
    0.01461121f, -0.29420665f, -0.13412836f, -0.13839728f, 0.01596478f, -0.11943619f, 0.03334082f, -0.06723484f, 
    0.05541198f, 0.06731410f, -0.06451012f, 0.00055990f, -0.01830252f, 0.15857621f, 0.01615332f, -0.02426099f, 
    -0.03486718f, -0.10843400f, -0.10158879f, -0.09763581f, -0.04436829f, -0.28190821f, 0.06718256f, -0.27194887f, 
    0.16855724f, -0.09466790f, 0.00606079f, -0.04068920f, 0.01421271f, -0.07747617f, -0.01687837f, -0.01432878f, 
    -0.11102794f, 0.04043949f, 0.05617815f, 0.00044265f, 0.00143961f, -0.03734886f, -0.02834089f, 0.04038253f, 
    -0.13764995f, -0.27507034f, -0.00357642f, -0.34820288f, 0.09247502f, 0.00146081f, 0.01566099f, 0.07439217f, 
    0.00184384f, 0.03854701f, -0.10157549f, 0.00045816f, -0.07591292f, 0.02133607f, 0.06082193f, -0.11478556f, 
    0.02128910f, -0.00929141f, 0.03310740f, -0.08835751f, -0.13787849f, 0.03656289f, 0.01986100f, -0.22381890f, 
    0.09385593f, -0.12226060f, -0.09521318f, -0.01641689f, -0.11007696f, -0.24370402f, 0.05678934f, -0.05067278f, 
    -0.02906906f, 0.05187875f, -0.00011841f, 0.03539057f, -0.02869928f, 0.03520549f, 0.00129772f, 0.00189495f, 
    -0.18885876f, -0.10412627f, 0.06939708f, 0.09588034f, -0.08473036f, 0.17111534f, 0.00265389f, 0.10411373f, 
    -0.02294580f, -0.10846398f, -0.10950588f, -0.03210687f, 0.08603292f, 0.02429756f, -0.07672171f, -0.02168190f, 
    0.08454108f, 0.04098187f, 0.11035502f, -0.00489219f, -0.23749790f, 0.13822331f, -0.13779952f, 0.08981887f, 
    -0.01490670f, -0.15997367f, 0.03936070f, 0.04919800f, 0.04484227f, 0.04952735f, -0.00814160f, -0.05779563f, 
    0.02793176f, -0.01787679f, 0.04833238f, 0.01621449f, -0.06003948f, -0.05257403f, -0.07336950f, -0.01764396f, 
    -0.21776658f, -0.13303976f, -0.04038598f, -0.24884129f, 0.04484969f, -0.00977675f, -0.03373586f, 0.04275763f, 
    -0.07938822f, -0.00186706f, -0.09204271f, -0.11655808f, 0.01502166f, 0.06321996f, 0.04505986f, 0.03222915f, 
    0.02845163f, -0.01219245f, 0.07591487f, 0.08890611f, 0.25438482f, -0.35954303f, -0.13898265f, 0.24664982f, 
    0.00778160f, 0.03688029f, -0.01749146f, -0.01531673f, 0.00228230f, 0.01406749f, 0.02335654f, 0.03973768f, 
    0.02059086f, -0.03892079f, -0.02451033f, -0.04494632f, -0.04238408f, 0.06518821f, -0.14269893f, -0.06076550f, 
    -0.04351008f, 0.02105143f, -0.12317931f, -0.16803442f, -0.01703477f, 0.05730214f, 0.04578681f, -0.02746736f, 
    -0.13741314f, -0.04144346f, -0.01212432f, -0.11501476f, -0.09204976f, -0.02935906f, -0.04374364f, -0.05100855f, 
    -0.09510291f, 0.12013399f, 0.00683339f, 0.06844505f, -0.22277065f, -0.16759229f, -0.02100485f, 0.17432228f, 
    0.07370096f, -0.14748050f, -0.01129754f, -0.06210956f, 0.04406145f, 0.03334755f, -0.19252451f, 0.07230977f, 
    0.02557273f, -0.03798338f, 0.09325822f, -0.06452176f, 0.03586826f, -0.09806293f, -0.09687997f, -0.18106449f, 
    -0.16956487f, 0.06636951f, -0.03651770f, -0.18791714f, 0.11338589f, -0.05465099f, 0.01471507f, 0.01724581f, 
    -0.05415713f, -0.09133273f, -0.03081237f, -0.08702722f, -0.02455793f, 0.00001323f, -0.03319354f, -0.06159516f, 
    0.01723160f, 0.06846827f, 0.06391011f, 0.07949205f, 0.00478108f, 0.14499031f, -0.07936198f, 0.04466904f, 
    -0.15710732f, -0.06519693f, -0.02707358f, 0.03943867f, 0.08103959f, -0.02398007f, 0.05067086f, 0.03211902f, 
    -0.01598209f, 0.03225903f, -0.05268604f, -0.05286395f, -0.01798801f, 0.04808538f, 0.01934271f, 0.08819132f, 
    -0.06826609f, -0.00573900f, -0.15693972f, 0.14200619f, -0.07517581f, 0.00649578f, 0.02432163f, 0.04138656f, 
    -0.05465748f, -0.01860065f, 0.01512297f, -0.00324027f, 0.07064229f, 0.03665774f, 0.11234482f, 0.03709136f, 
    -0.02095822f, 0.10570489f, -0.01238338f, -0.01219556f, -0.19681336f, -0.14949827f, -0.02249387f, -0.22147037f, 
    0.02022013f, 0.04331790f, 0.03848885f, 0.09421788f, -0.09409696f, -0.07571673f, -0.02822921f, -0.10305549f, 
    0.02046181f, 0.01959934f, 0.08718620f, 0.04299865f, -0.07450034f, 0.01926797f, 0.09998774f, 0.00513179f, 
    0.31032312f, 0.10273167f, 0.16457422f, 0.06317728f, 0.11536344f, -0.01923177f, 0.02428338f, 0.02424129f, 
    -0.03859348f, 0.19459027f, 0.08270960f, 0.01150809f, 0.07729143f, 0.03868639f, 0.09572951f, -0.04122367f, 
    0.03312494f, -0.01101429f, 0.02127315f, -0.09612244f, 0.03232165f, 0.29899913f, 0.00348540f, 0.06983954f, 
    -0.08792969f, -0.09722607f, -0.05633281f, 0.05365717f, 0.04852750f, 0.10836938f, 0.05516433f, 0.07549132f, 
    -0.03714513f, -0.02023863f, -0.06841529f, -0.07609091f, -0.03027724f, -0.07554188f, -0.06557976f, -0.05523301f, 
    0.17936529f, -0.19467793f, -0.12148943f, 0.12047958f, -0.11284519f, -0.06058645f, 0.05045328f, 0.01722057f, 
    0.00417052f, 0.05962040f, 0.00267117f, -0.02174751f, -0.01265873f, 0.02643111f, 0.10924987f, 0.11994164f, 
    -0.02532631f, -0.10991348f, -0.02189441f, -0.00259188f, -0.39268041f, 0.23582715f, 0.02252890f, 0.07279100f, 
    -0.08214666f, -0.01164499f, 0.04830532f, -0.07595492f, -0.00621220f, 0.04595493f, -0.01427604f, 0.10446483f, 
    0.04396373f, -0.04635522f, 0.02324430f, 0.01022828f, 0.04673149f, -0.04896262f, 0.00075696f, -0.22645094f, 
    -0.05986850f, 0.18578042f, 0.10527752f, 0.09253130f, -0.13754061f, 0.04728877f, -0.08687384f, -0.00853235f, 
    0.02803353f, -0.04252467f, 0.05634253f, 0.05290477f, -0.00116652f, 0.04833890f, -0.06004476f, -0.02942122f, 
    -0.00797095f, -0.09029648f, -0.03742643f, -0.13408834f, -0.22086869f, 0.00481754f, 0.03631665f, -0.25021926f, 
    0.07333034f, -0.08220592f, -0.02475543f, 0.08698686f, -0.08943041f, -0.02728677f, 0.06415386f, -0.04581570f, 
    0.04489331f, 0.08341017f, -0.00690688f, 0.00073213f, -0.03236067f, -0.06446285f, 0.04979805f, 0.03100344f, 
    -0.14501905f, -0.16531409f, 0.06668210f, -0.33334470f, 0.11742712f, -0.08509933f, -0.03287780f, -0.08402825f, 
    -0.04502096f, 0.00127709f, 0.00277503f, 0.01602358f, 0.03828492f, 0.06358340f, -0.09195261f, -0.00082255f, 
    0.02628875f, -0.12861677f, -0.01909620f, 0.03064335f, -0.18052889f, -0.13630126f, 0.07114086f, 0.06373955f, 
    -0.02755314f, 0.02455495f, -0.07479280f, 0.07655433f, -0.01686864f, -0.04881246f, -0.14772312f, -0.02736162f, 
    -0.00262159f, 0.03057006f, 0.04676611f, 0.04850725f, -0.02923230f, 0.07325300f, 0.00273080f, 0.02346379f, 
    0.09856104f, -0.05634319f, 0.00625194f, -0.07199512f, -0.02369113f, 0.07600889f, 0.02089413f, 0.02384158f, 
    -0.03030769f, 0.01408501f, 0.07690991f, 0.07572164f, -0.06862459f, -0.01734735f, -0.01373396f, -0.01788055f, 
    0.04645773f, -0.00062282f, 0.08719240f, 0.04559376f, 0.41428721f, -0.35225645f, -0.10915560f, -0.08175347f, 
    -0.02798485f, -0.03191244f, 0.04880099f, -0.06399777f, -0.05892453f, -0.01616008f, 0.07478351f, -0.02277645f, 
    0.06461987f, 0.03738569f, 0.07681492f, 0.00618328f, 0.03134713f, 0.08448263f, -0.12893705f, 0.10113438f, 
    0.02618735f, -0.06843553f, -0.14933345f, -0.14176701f, -0.02128448f, -0.05435196f, 0.03962927f, 0.03342305f, 
    -0.04390115f, 0.07845297f, -0.01981851f, -0.06804098f, -0.04164788f, 0.00295690f, -0.08467085f, -0.12329756f, 
    -0.04995093f, 0.07840727f, 0.11656565f, -0.01644413f, 0.27830902f, -0.04473233f, -0.08517011f, -0.05889835f, 
    0.04057441f, 0.01113770f, 0.08048794f, -0.00374732f, -0.00527013f, -0.12134281f, 0.00163664f, 0.05130270f, 
    0.01856844f, -0.02867956f, 0.02202213f, -0.06506020f, -0.03299674f, 0.06269321f, -0.12125566f, 0.05558714f, 
    0.00734325f, -0.07004891f, 0.08891856f, 0.23975453f, 0.19331540f, -0.00971274f, 0.07279713f, -0.04712702f, 
    0.06649029f, -0.03124480f, -0.05998946f, 0.01550343f, -0.15031509f, -0.05354857f, -0.00859100f, 0.02919706f, 
    0.04396062f, 0.09524490f, 0.01326569f, 0.08776866f, -0.01107940f, -0.06441810f, -0.05904662f, -0.26971659f, 
    0.05080027f, 0.01655404f, -0.03594898f, 0.00900738f, 0.06966840f, 0.00599647f, -0.01742240f, 0.03386728f, 
    -0.04214150f, -0.02859585f, -0.03539991f, 0.03160629f, -0.04894432f, 0.00419716f, -0.01857159f, 0.08342849f, 
    0.14844438f, 0.05587572f, 0.10355572f, 0.11084873f, 0.04594640f, 0.06019264f, -0.02523008f, -0.02478330f, 
    -0.04815759f, -0.04415859f, 0.04260952f, -0.00988998f, -0.00404286f, 0.01788520f, 0.05058926f, -0.00301584f, 
    0.02846690f, 0.00006430f, -0.05254029f, -0.13340516f, -0.10975343f, 0.17225353f, 0.01656133f, 0.07052551f, 
    -0.32966071f, 0.07727388f, 0.02813836f, -0.00615187f, 0.06058745f, 0.05642603f, 0.00997941f, 0.09480841f, 
    0.03273340f, 0.01887107f, -0.15401818f, -0.01155071f, -0.01529727f, -0.01733779f, -0.03141747f, -0.02534728f, 
    0.01538722f, 0.19232251f, 0.04429701f, -0.02468722f, -0.07532252f, 0.05779203f, 0.04763506f, 0.02985758f, 
    -0.03221436f, 0.03397904f, -0.03929387f, 0.05926079f, -0.09500246f, -0.04086551f, -0.05699902f, 0.04415189f, 
    -0.08422486f, 0.09147488f, 0.04427616f, -0.01119910f, -0.04554551f, -0.01505413f, 0.00172015f, -0.25972947f, 
    0.16117047f, -0.00498095f, -0.00208256f, 0.06352741f, -0.07551548f, -0.00580721f, -0.01537867f, -0.06805202f, 
    0.07168753f, -0.03294409f, 0.02285766f, -0.03622023f, -0.00805160f, -0.05531823f, 0.06065358f, 0.08801044f, 
    -0.14643548f, 0.19107077f, 0.08248682f, 0.06182071f, -0.01567608f, -0.09967732f, -0.06460238f, 0.08815018f, 
    -0.00710508f, -0.00367672f, 0.00618965f, -0.00684638f, 0.15564144f, -0.11925022f, -0.04353533f, 0.09241939f, 
    -0.05173604f, -0.02748407f, -0.02694594f, 0.03490178f, -0.07590555f, 0.14353271f, 0.07108086f, -0.03010010f, 
    -0.10256155f, 0.03240422f, 0.06927342f, 0.03851822f, 0.01916023f, -0.11517269f, -0.00801006f, 0.02668426f, 
    -0.00350990f, -0.06276226f, -0.07712757f, 0.03768994f, 0.01349215f, -0.14298595f, 0.08594073f, 0.13847019f, 
    -0.21414962f, -0.01916428f, -0.04560991f, -0.04861251f, -0.11148457f, -0.00600028f, -0.02619352f, 0.00967451f, 
    -0.01561782f, -0.03564667f, -0.02745028f, -0.01779407f, -0.04437788f, -0.02604184f, -0.00179843f, -0.00455605f, 
    -0.02056207f, -0.00868199f, -0.01833263f, 0.01903864f, -0.19527721f, 0.02271869f, 0.00323214f, -0.06109758f, 
    -0.06376515f, 0.02803468f, -0.00450483f, 0.00304026f, -0.02723381f, 0.00687673f, 0.01571546f, 0.03746839f, 
    -0.04507509f, -0.01796912f, -0.03107033f, 0.01896109f, 0.00788200f, -0.02187867f, -0.02658742f, -0.01697934f, 
    -0.09476063f, 0.00261787f, -0.08471318f, -0.05680935f, 0.11760392f, -0.03561930f, -0.06288149f, -0.10795037f, 
    0.00329370f, -0.04006935f, -0.04528010f, -0.01549815f, 0.04863682f, -0.05947463f, -0.05898929f, -0.06372253f, 
    -0.02849669f, -0.00081054f, -0.02897684f, -0.00571839f, -0.07477900f, 0.03488877f, -0.08587230f, -0.02095769f, 
    -0.07491367f, -0.03727736f, 0.01761888f, 0.02230397f, -0.01137813f, -0.10995103f, -0.03606702f, -0.00775966f, 
    -0.02944379f, 0.03401585f, 0.02203379f, 0.00791960f, -0.04142203f, -0.01326817f, 0.01457805f, -0.02687024f, 
    -0.02566097f, 0.00737422f, 0.01480203f, -0.06675930f, 0.00038224f, 0.01593870f, -0.00236941f, 0.04276177f, 
    -0.00109064f, -0.04247094f, -0.01730497f, -0.00645696f, -0.01884184f, 0.00688150f, -0.03597602f, -0.01434872f, 
    -0.01179643f, -0.01462462f, 0.03780999f, 0.02732100f, -0.26771939f, 0.18733682f, 0.02041340f, 0.10320575f, 
    0.15086965f, 0.03678559f, -0.10223359f, -0.05380239f, 0.09186236f, 0.01847125f, -0.04542958f, 0.01001367f, 
    0.02876248f, 0.02179375f, -0.13554156f, 0.06476144f, 0.01581054f, 0.02299646f, -0.01779692f, -0.05266014f, 
    0.02833255f, 0.14116678f, -0.07900908f, 0.04203198f, 0.04040870f, -0.08053787f, -0.02097739f, -0.05567030f, 
    0.01058057f, -0.05612843f, -0.07581607f, 0.05964641f, 0.05316903f, 0.10750092f, -0.07898513f, 0.05810209f, 
    -0.01883750f, 0.02829976f, 0.03180371f, 0.00161315f, -0.15346681f, 0.08736385f, -0.16838530f, 0.06989104f, 
    0.11683638f, -0.04922732f, -0.11878657f, -0.07272651f, 0.02618009f, -0.05584249f, -0.08434121f, 0.03985676f, 
    0.01783748f, -0.03423587f, -0.05314317f, -0.00739803f, -0.00955824f, 0.00762921f, -0.00508495f, 0.03558241f, 
    0.10717754f, 0.04102652f, 0.15152258f, -0.10138898f, 0.09898591f, -0.01155030f, 0.04218896f, -0.03037148f, 
    0.00426182f, 0.02244577f, -0.04329238f, 0.01989935f, -0.03865554f, -0.01863862f, -0.03208786f, 0.00234696f, 
    -0.03911399f, 0.00762330f, 0.03352931f, -0.05870333f, -0.04248164f, -0.34405124f, -0.06545074f, -0.08559049f, 
    -0.07768090f, -0.00038956f, -0.03347865f, -0.01524784f, -0.02836921f, -0.07757294f, -0.00368597f, -0.02778692f, 
    -0.04490716f, 0.00004281f, -0.02524366f, -0.03827493f, 0.02222871f, -0.00544616f, 0.00149463f, 0.01463080f, 
    0.16013572f, -0.16296718f, 0.07331878f, 0.13306890f, 0.09773461f, 0.13713484f, 0.08635560f, 0.00589634f, 
    0.00765269f, 0.02882257f, 0.01898339f, -0.00023412f, -0.01821902f, -0.02131524f, -0.00217952f, -0.05732629f, 
    0.01546088f, -0.03672015f, 0.01795141f, 0.02321001f, 0.05437865f, 0.03268600f, 0.12700413f, 0.02969712f, 
    0.00974726f, -0.01447595f, 0.07210115f, -0.00960722f, 0.02939640f, -0.03678567f, -0.03353402f, 0.00572643f, 
    0.00638414f, 0.01801126f, -0.03179273f, -0.00140777f, 0.00222983f, -0.00413332f, 0.00417379f, 0.00528561f, 
    -0.07999665f, 0.13959572f, -0.03051687f, 0.13146943f, 0.05776025f, 0.05806925f, -0.04903419f, -0.03312736f, 
    -0.02494489f, 0.01000986f, -0.01366694f, -0.03084678f, 0.01362947f, 0.00057461f, -0.07402512f, 0.01118617f, 
    -0.04392226f, -0.01521671f, 0.01343070f, 0.00354731f, -0.06592950f, -0.25287130f, -0.07889148f, -0.10159595f, 
    -0.11738817f, -0.02713940f, -0.04049163f, 0.00556788f, -0.01016929f, -0.08419975f, -0.04217089f, -0.02819872f, 
    -0.02894635f, -0.05015096f, -0.01065930f, -0.01861360f, 0.01963828f, -0.03647326f, -0.01825133f, -0.01252207f, 
    -0.19593935f, 0.06938848f, -0.26230863f, -0.03036512f, 0.07450160f, -0.00984026f, -0.01220157f, -0.08174295f, 
    0.00640250f, -0.00935481f, -0.12188084f, 0.01655019f, -0.08149312f, -0.04294836f, -0.01451613f, 0.01186289f, 
    -0.11406895f, -0.00888432f, -0.04556569f, 0.00854914f, -0.17818052f, -0.08971813f, -0.15587915f, 0.02276658f, 
    -0.02498129f, -0.07236659f, -0.02177351f, 0.01512861f, -0.03350003f, -0.03623359f, 0.01207593f, -0.05936597f, 
    0.00136066f, -0.07372476f, 0.02869851f, -0.00783839f, -0.01758812f, -0.04912214f, -0.02587979f, -0.04187714f, 
    0.04649443f, -0.02196897f, 0.02703616f, 0.04656047f, -0.06656490f, 0.05984440f, -0.12938496f, -0.02877763f, 
    0.02061768f, 0.05725957f, -0.02761273f, 0.08864843f, 0.02690830f, 0.08953676f, -0.03083942f, -0.07561813f, 
    0.02193430f, 0.05768124f, -0.06828426f, -0.00449950f, -0.17251474f, 0.08389100f, -0.03565215f, 0.10726012f, 
    -0.06766858f, 0.08351896f, -0.10592372f, -0.01780752f, -0.00208745f, 0.02650851f, -0.04760885f, 0.04724926f, 
    0.08727014f, -0.03782921f, 0.07143997f, -0.03302240f, 0.01759342f, 0.08942598f, 0.02376722f, -0.03382870f, 
    0.19308656f, -0.10308968f, 0.11043201f, -0.03884957f, 0.14923455f, 0.00367822f, 0.06154076f, 0.05478187f, 
    0.03325720f, 0.00033556f, -0.01542281f, 0.01970752f, -0.07196024f, 0.00779920f, 0.04772578f, -0.03191024f, 
    -0.01225182f, 0.00369388f, -0.02150747f, -0.03876146f, 0.00025239f, -0.10113034f, 0.02907396f, -0.08185156f, 
    -0.05902309f, 0.03972163f, -0.03564755f, 0.00282799f, -0.07061625f, -0.06276328f, 0.01214048f, -0.05225266f, 
    -0.05082357f, -0.02339641f, -0.06467680f, -0.01189401f, 0.00531027f, -0.00126529f, 0.00932419f, 0.00379708f, 
    -0.22587045f, 0.07728884f, 0.02692053f, 0.02262670f, 0.18279420f, 0.03753235f, -0.00963605f, -0.12249363f, 
    0.04239305f, -0.02157803f, 0.05909443f, -0.03108716f, 0.04360459f, -0.01569482f, -0.01496981f, 0.00172568f, 
    -0.02324198f, 0.05158980f, 0.01448631f, -0.05733046f, -0.12467007f, -0.33498400f, -0.07912817f, -0.08501123f, 
    -0.18407127f, 0.01085491f, -0.00997693f, 0.02621250f, -0.04264311f, -0.07800755f, 0.00977354f, -0.03659307f, 
    -0.05340766f, 0.01154401f, -0.01596860f, -0.02637656f, 0.06442358f, -0.02229521f, 0.03638811f, -0.00822015f, 
    -0.20014706f, 0.07000571f, 0.03439441f, 0.02780772f, -0.13866378f, -0.00367389f, -0.07025588f, -0.03110625f, 
    -0.03078196f, -0.04902450f, 0.02866097f, -0.03608025f, 0.01339098f, 0.03606046f, -0.07358851f, 0.05653333f, 
    -0.06836642f, 0.03170935f, 0.01992949f, -0.02010523f, 0.03385442f, -0.08011218f, 0.02796496f, -0.08584201f, 
    -0.04451158f, -0.08887854f, -0.03717939f, 0.02226424f, 0.01263143f, 0.03149954f, -0.01394287f, -0.01086303f, 
    0.03827970f, -0.00946632f, 0.07799563f, 0.00191940f, -0.02340033f, -0.00460293f, -0.02255924f, -0.06861452f, 
    0.08343069f, -0.03563850f, 0.08176737f, 0.02129760f, 0.05144330f, 0.02347356f, 0.01177954f, -0.00366373f, 
    0.00882483f, -0.01670675f, -0.02536758f, 0.02587068f, -0.05457479f, -0.02883489f, -0.02344397f, -0.01256554f, 
    0.02657063f, -0.01791606f, 0.03583580f, -0.02881950f, -0.33056656f, 0.13923571f, -0.08208483f, 0.00441205f, 
    0.08270699f, -0.05166745f, -0.05661921f, -0.06286592f, 0.05766199f, -0.00250524f, 0.00646490f, 0.00735554f, 
    -0.00555718f, -0.02874467f, -0.02155272f, -0.06053344f, -0.03503322f, 0.07780473f, -0.00278593f, 0.04156858f, 
    -0.06253587f, 0.09259789f, 0.19431691f, -0.02551948f, 0.07841327f, 0.01857765f, 0.04159333f, -0.01781232f, 
    0.00278164f, -0.05045564f, -0.04262977f, -0.00728335f, 0.03446139f, 0.02021023f, -0.08435678f, -0.02927991f, 
    -0.06676526f, -0.02147214f, 0.00587502f, -0.00670106f, -0.11553890f, 0.14141773f, -0.07110348f, -0.06332491f, 
    0.03254393f, -0.09890430f, 0.03726250f, -0.00777034f, -0.04558712f, -0.03048609f, -0.00096484f, -0.00245210f, 
    -0.01696819f, -0.01731749f, -0.05410070f, -0.01450878f, -0.02462810f, -0.02352204f, -0.00178959f, 0.00890907f, 
    0.04975695f, 0.15758103f, 0.13301088f, -0.10614918f, 0.17475791f, -0.02540835f, 0.14537254f, 0.00032474f, 
    -0.01073370f, 0.09235711f, 0.00052365f, 0.02738863f, -0.03427324f, -0.10790101f, 0.10140790f, 0.06780700f, 
    0.07270169f, 0.04831513f, -0.04453166f, 0.02058866f, -0.07557500f, 0.09655122f, 0.18298590f, -0.01139795f, 
    0.09169451f, 0.01455434f, 0.07180944f, 0.04055453f, 0.00132509f, -0.05158705f, 0.01204782f, -0.03744012f, 
    -0.04195729f, 0.04043299f, -0.05328848f, -0.10400363f, 0.01942938f, -0.01938121f, -0.01418136f, -0.05557087f, 
    0.10798585f, 0.04205823f, 0.13788833f, 0.00148142f, 0.04684644f, -0.09127445f, -0.01959264f, 0.07283838f, 
    -0.01645620f, -0.01258110f, -0.00033284f, 0.05753079f, 0.04762656f, 0.08128257f, -0.04310794f, -0.00866894f, 
    0.01808925f, 0.04928319f, 0.01516505f, 0.00364694f, 0.02374382f, -0.01506456f, 0.12777527f, 0.00253796f, 
    0.16009051f, -0.02178548f, 0.06837413f, 0.01006366f, -0.00129781f, 0.03353434f, -0.00120738f, -0.00466243f, 
    -0.06590805f, 0.01648491f, -0.00173686f, -0.04165294f, 0.00505449f, 0.07027294f, 0.00396023f, -0.04319148f, 
    0.11770268f, -0.00099627f, 0.18502095f, 0.14587224f, 0.17244674f, -0.04862156f, 0.10066452f, 0.02161628f, 
    0.02385299f, -0.05522104f, -0.02690467f, 0.02134322f, -0.06962420f, 0.00850991f, -0.05408521f, 0.01561901f, 
    -0.04942856f, 0.06864336f, -0.03456880f, -0.05697489f, 0.06052724f, 0.10241830f, 0.13023749f, 0.11947735f, 
    0.12257691f, 0.05075065f, 0.04517252f, 0.02310615f, -0.01355338f, -0.02415819f, -0.02311884f, -0.02889328f, 
    -0.04970786f, 0.01409688f, -0.07890718f, -0.03033761f, 0.00696484f, 0.06079475f, -0.01659814f, -0.02519681f, 
    0.10397664f, -0.18348442f, 0.10520820f, -0.02202147f, -0.11592814f, 0.06676538f, -0.04631576f, -0.05396384f, 
    -0.02852259f, -0.00152493f, -0.05610587f, -0.01231347f, -0.03476658f, -0.06985922f, -0.06668473f, -0.00524462f, 
    0.05838346f, -0.00050888f, -0.02169283f, -0.03247903f, 0.02073021f, 0.11045141f, -0.01964670f, -0.06522162f, 
    -0.06247595f, -0.05388356f, -0.01603610f, 0.00329166f, 0.00989700f, -0.03138873f, 0.04508652f, 0.08723572f, 
    0.03377442f, -0.01090948f, -0.03163054f, 0.02176036f, 0.00540748f, -0.01845293f, -0.04086663f, 0.03130957f, 
    0.11118929f, -0.03045859f, 0.15745960f, -0.01622391f, 0.01718730f, 0.10414737f, 0.02854823f, -0.05109883f, 
    -0.04036500f, 0.02795349f, -0.04432454f, 0.04342137f, -0.00282786f, -0.02062498f, -0.01198790f, -0.04524510f, 
    0.01857653f, -0.04599804f, 0.01501017f, -0.03504149f, 0.17852850f, -0.07080235f, 0.01896313f, -0.04875563f, 
    0.01610834f, 0.09239406f, -0.00171380f, 0.04894847f, -0.04585011f, -0.03617522f, -0.03425693f, -0.01881494f, 
    -0.02822611f, -0.03672078f, 0.00406247f, 0.01489072f, 0.00560369f, -0.03268345f, 0.03270599f, -0.01677487f, 
    0.03524683f, 0.04124906f, 0.08103254f, 0.02115231f, 0.11369403f, -0.00627415f, -0.02149138f, -0.03585989f, 
    -0.02253607f, -0.05817167f, 0.01225710f, -0.00580893f, -0.07144994f, -0.02212268f, -0.01289042f, -0.03549737f, 
    -0.01346417f, 0.01903559f, 0.02141034f, -0.02094260f, -0.18570738f, -0.00148253f, -0.01810594f, -0.04318167f, 
    -0.06499998f, -0.07138865f, -0.02769806f, 0.00310363f, -0.07700054f, -0.02430555f, 0.05537869f, 0.04809714f, 
    -0.01291105f, -0.03119557f, -0.04419818f, -0.03936894f, 0.00704053f, -0.00582770f, -0.00786280f, -0.00044592f, 
    0.05605639f, 0.01952352f, 0.15202932f, -0.00595337f, 0.12075279f, 0.02127318f, 0.06062537f, -0.02971081f, 
    -0.01697494f, -0.01517673f, -0.04380818f, -0.00380360f, -0.05733852f, -0.03040579f, -0.04542353f, -0.05108843f, 
    -0.03191444f, -0.01033831f, 0.05737949f, -0.01403129f, -0.13938209f, 0.01783940f, -0.10740868f, -0.06233336f, 
    0.01822961f, -0.03577037f, -0.09903823f, -0.03147040f, -0.04283536f, -0.04566801f, -0.03415523f, 0.05287480f, 
    0.01222889f, 0.02886098f, -0.00605587f, -0.00128867f, -0.06586933f, -0.01449767f, -0.00753996f, 0.04043843f, 
    -0.12161076f, 0.12741603f, -0.14278780f, -0.10095359f, -0.11537633f, 0.02617380f, 0.06528005f, -0.07227273f, 
    0.03585562f, -0.02178985f, -0.03462637f, 0.00582803f, -0.02564969f, 0.00277390f, 0.06207213f, 0.02603809f, 
    -0.05371361f, 0.01458830f, 0.00509883f, 0.03203892f, 0.05214087f, 0.11148383f, -0.05738324f, 0.08817221f, 
    -0.00831693f, -0.01750972f, 0.07975242f, -0.03880148f, 0.05296150f, -0.00909098f, -0.03526348f, -0.00966722f, 
    0.03889965f, -0.02662031f, -0.01091524f, 0.06388825f, -0.04826494f, -0.05697447f, -0.01416990f, -0.04307152f, 
    0.16022865f, 0.27859503f, 0.00170721f, -0.11019952f, 0.09807738f, -0.26133105f, 0.02849644f, -0.04311603f, 
    -0.07427301f, -0.02559255f, -0.04270527f, 0.04456491f, -0.04131925f, 0.08946587f, -0.00747357f, 0.01255829f, 
    0.02982974f, 0.09178089f, 0.01137615f, 0.09195702f, -0.12008759f, -0.05410028f, -0.01692384f, -0.07904831f, 
    -0.17704134f, 0.08678430f, -0.06824346f, -0.04831705f, -0.04820782f, -0.11634875f, -0.08809698f, 0.01960067f, 
    -0.09825228f, -0.05953512f, -0.12166940f, 0.05873583f, 0.06291486f, 0.02580059f, 0.04020362f, -0.02270735f, 
    0.02512402f, -0.00966767f, 0.00046987f, -0.05261718f, -0.05446114f, -0.00550521f, -0.04106183f, -0.01438141f, 
    -0.07208726f, -0.02319770f, 0.00451922f, -0.02583844f, -0.03836032f, -0.02404668f, -0.03566488f, 0.00770758f, 
    -0.04539165f, -0.02762207f, -0.03266637f, 0.02375094f, -0.28729460f, 0.01494001f, -0.05002016f, -0.08440916f, 
    -0.15479159f, 0.07872240f, 0.04014299f, 0.01388337f, 0.01386693f, 0.01246863f, 0.02136930f, -0.05402468f, 
    0.03607780f, -0.01907605f, -0.03183759f, -0.03663618f, 0.01226469f, 0.04763135f, -0.01606638f, 0.10526597f, 
    -0.05296188f, -0.19755708f, -0.00855699f, -0.06351051f, -0.16704111f, 0.00353264f, 0.01620229f, -0.00538510f, 
    -0.03741534f, -0.04592986f, -0.01886750f, -0.04114559f, -0.04853936f, -0.03803467f, -0.01247621f, -0.02714277f, 
    0.02045546f, -0.02754689f, -0.01464587f, -0.00288186f, 0.06415960f, 0.05328551f, 0.13774748f, 0.01095690f, 
    0.06082154f, 0.04858474f, 0.03676308f, -0.06522468f, -0.07256145f, -0.05149576f, -0.02700795f, 0.01545555f, 
    -0.07260220f, 0.01557436f, -0.01158230f, -0.06403684f, -0.00318579f, 0.02892151f, 0.07633548f, -0.06505816f, 
    -0.02972467f, 0.08598932f, 0.18143883f, 0.09004814f, 0.11586448f, 0.10086969f, 0.07249436f, 0.03787584f, 
    -0.02528235f, -0.05452113f, -0.08817989f, -0.03187331f, 0.01556234f, 0.00563590f, -0.03485057f, 0.01153337f, 
    0.02730865f, -0.02105625f, 0.03593259f, -0.02415209f, 0.07506219f, -0.20826654f, 0.09851404f, 0.04677536f, 
    -0.14440717f, 0.12152776f, -0.07319437f, -0.06763165f, -0.03153946f, 0.06580324f, -0.04806289f, 0.04907363f, 
    -0.05327288f, 0.02512016f, -0.04008735f, 0.01143139f, -0.00737561f, 0.00016588f, -0.03023598f, 0.01168605f, 
    0.11818711f, -0.23571777f, 0.06154675f, -0.03120657f, -0.00398760f, 0.03658398f, -0.04464406f, -0.04676247f, 
    -0.04461460f, -0.00398104f, -0.04404933f, 0.00310260f, -0.04088013f, -0.06373733f, -0.05704351f, -0.04509566f, 
    0.05169827f, 0.00926843f, 0.04876343f, 0.02246786f, -0.01780641f, 0.19449131f, 0.18618703f, 0.05978682f, 
    0.15454760f, 0.12982891f, 0.13410997f, 0.04665110f, 0.04024633f, 0.01794966f, -0.07619747f, 0.03927856f, 
    0.05842122f, 0.02862742f, -0.07964484f, 0.01411227f, 0.04094937f, 0.03220572f, 0.03851346f, -0.02396455f, 
    -0.02037491f, -0.00070625f, -0.01554731f, 0.06833950f, 0.07591730f, -0.00588077f, -0.11608195f, -0.07516883f, 
    -0.03657667f, -0.00196298f, 0.00515575f, -0.01397524f, -0.03529981f, -0.05723205f, -0.03938100f, -0.03497832f, 
    0.01940191f, -0.01043986f, 0.06018263f, -0.00278257f, -0.00927507f, 0.10694175f, 0.16961807f, -0.01640579f, 
    0.05568210f, -0.00024448f, 0.07152846f, -0.02523242f, -0.01615993f, -0.01979570f, -0.05853079f, 0.00851867f, 
    0.00805137f, -0.00010764f, -0.02977764f, -0.02742268f, -0.06610311f, 0.02707803f, 0.03264135f, -0.07155998f, 
    -0.17680889f, 0.04197393f, -0.01398464f, 0.06499690f, -0.07095072f, 0.01747036f, -0.08975518f, -0.03028018f, 
    0.07060439f, 0.00807233f, -0.07624814f, 0.02942322f, 0.03002814f, -0.02793401f, -0.08952627f, 0.04201236f, 
    0.04621077f, 0.02468806f, -0.02407707f, -0.00539012f, 0.02417885f, 0.09316773f, 0.06796394f, 0.16830955f, 
    0.18013042f, 0.10734682f, 0.11061535f, -0.02243825f, 0.00783059f, 0.01992497f, -0.08633148f, -0.03143064f, 
    -0.01981805f, -0.02276599f, -0.07074790f, 0.03989718f, -0.04450969f, -0.02884467f, -0.01065059f, 0.06132706f, 
    0.07938486f, -0.20119253f, 0.00004580f, -0.03961794f, -0.08068763f, -0.01010113f, 0.02710081f, -0.00365317f, 
    -0.03451718f, -0.02556607f, -0.01043091f, -0.06341242f, -0.03576379f, -0.01628320f, -0.08421782f, -0.08295174f, 
    0.06890193f, -0.01964112f, 0.02539263f, 0.03317870f, -0.28963229f, 0.01521186f, -0.02436474f, -0.03857987f, 
    -0.04424685f, 0.00682930f, -0.01358234f, -0.06137595f, 0.00181662f, -0.03408465f, -0.04085007f, -0.00735951f, 
    0.05632377f, -0.06599595f, -0.04127116f, -0.01604432f, -0.03522548f, 0.01210015f, -0.01163461f, 0.03250713f, 
    0.03453356f, -0.08192163f, -0.11980279f, -0.00178078f, 0.14818284f, -0.04170119f, -0.08087277f, -0.05291711f, 
    -0.01146793f, -0.02465465f, -0.01911015f, 0.01691415f, -0.01913606f, -0.01526854f, -0.02007470f, -0.06734350f, 
    0.00671219f, 0.00324584f, -0.01427599f, 0.04400697f, 0.12970302f, 0.00578219f, 0.18312287f, 0.03128087f, 
    0.05868717f, 0.08921852f, 0.09375395f, -0.03584381f, -0.03580430f, -0.00152550f, -0.06537009f, 0.03933845f, 
    0.01688797f, -0.04375950f, -0.06814673f, -0.01539363f, -0.04454198f, -0.04228211f, 0.03817871f, -0.06383897f, 
    0.07345046f, 0.06254257f, -0.09439632f, -0.02108722f, -0.06162463f, -0.01392691f, -0.15601934f, -0.03724376f, 
    -0.02104388f, 0.02335522f, 0.03729657f, -0.01076236f, 0.03684997f, -0.06749055f, -0.04277040f, -0.01332205f, 
    0.02734707f, 0.02537323f, -0.04652436f, 0.01340008f, -0.05931288f, 0.14824586f, -0.33047864f, -0.09460294f, 
    0.03474611f, -0.03853157f, 0.00209265f, -0.08018956f, -0.00131742f, 0.00472095f, -0.05563885f, -0.00718694f, 
    0.04599174f, -0.03992015f, 0.03236274f, -0.01371167f, 0.01078913f, -0.01639244f, -0.01666237f, 0.07932919f, 
    0.07672249f, 0.15488768f, -0.04532402f, 0.07181209f, 0.07051036f, 0.05960435f, -0.00895859f, -0.02377142f, 
    -0.05919130f, -0.03254808f, 0.01711903f, 0.01146642f, -0.02331830f, 0.05249797f, -0.07905149f, -0.06030313f, 
    0.01066233f, 0.02537710f, 0.07157007f, -0.06063851f, 0.01918422f, 0.16103902f, -0.08957943f, 0.05451266f, 
    -0.02511359f, -0.01337680f, -0.00362242f, -0.08634196f, -0.05686497f, -0.04509805f, 0.04286641f, 0.02977950f, 
    0.02745702f, -0.05457191f, 0.05214436f, -0.02092281f, -0.00908356f, -0.02351516f, 0.04238761f, -0.04308977f, 
    -0.08138578f, -0.07679678f, -0.21129994f, -0.17616174f, -0.11964228f, -0.06057221f, -0.06353137f, -0.03402501f, 
    0.00272058f, -0.05361887f, 0.11809345f, 0.01497113f, 0.03947095f, 0.00212724f, 0.08730564f, -0.00152462f, 
    0.07252273f, -0.01122450f, -0.00053311f, -0.01813379f, 0.12375415f, 0.05512193f, -0.19195980f, 0.02972226f, 
    0.04902774f, 0.02584512f, 0.01441004f, 0.02320117f, -0.05160212f, 0.05647761f, -0.00304396f, -0.03006290f, 
    0.02095192f, -0.00048471f, -0.00072416f, 0.02613285f, 0.04658061f, 0.02128042f, 0.07035986f, 0.00678556f, 
    0.15798222f, 0.08130928f, -0.06742661f, 0.06453222f, 0.10188917f, 0.06726736f, -0.00271856f, -0.06198080f, 
    -0.04855985f, -0.01773792f, 0.03606685f, 0.03808329f, 0.01810685f, -0.05551963f, -0.09333986f, 0.00810074f, 
    -0.02403214f, 0.04660903f, 0.04003559f, 0.03631552f, -0.01340842f, 0.09469257f, -0.32502908f, 0.04908345f, 
    -0.11332797f, 0.05962240f, -0.10468064f, -0.26092651f, -0.03724212f, -0.05109495f, 0.11853041f, -0.03145066f, 
    0.10082238f, -0.10324667f, 0.05732062f, 0.00236742f, -0.01743111f, -0.15674320f, 0.03202421f, 0.07111974f, 
    -0.08885079f, -0.09132546f, -0.01868463f, 0.13966295f, 0.10298185f, 0.04059267f, 0.04895769f, -0.15250145f, 
    -0.04038650f, -0.03333066f, 0.07489823f, 0.01512088f, 0.12675317f, -0.06477737f, 0.18985784f, -0.10748810f, 
    0.07711233f, -0.02296628f, 0.04938317f, -0.05741588f, 0.03443996f, -0.03993233f, -0.13576166f, -0.04286538f, 
    -0.00970268f, 0.01323869f, 0.00194919f, -0.02576189f, 0.01842647f, 0.00042534f, 0.08441987f, 0.03893935f, 
    0.04501134f, -0.00290443f, 0.06212863f, 0.05562390f, 0.01471988f, 0.01592477f, 0.09410253f, 0.03028059f, 
    -0.06386495f, -0.01846826f, -0.10666183f, -0.15253744f, -0.17635344f, 0.01913653f, 0.00658442f, 0.03675555f, 
    -0.13672560f, 0.00177626f, 0.02200782f, -0.00132837f, -0.03680026f, 0.00978728f, 0.01727054f, -0.00709505f, 
    0.00318217f, -0.08058102f, -0.00733997f, -0.03022204f, 0.01449444f, -0.13874969f, -0.08403200f, 0.13342786f, 
    0.13065055f, 0.09684192f, 0.05913633f, -0.00921417f, -0.03950440f, -0.00541978f, 0.00425266f, 0.02299061f, 
    0.00862156f, 0.06547337f, 0.02591271f, -0.01411248f, -0.03081097f, 0.04388399f, 0.00683644f, -0.06486659f, 
    -0.01449408f, -0.12522686f, 0.13628843f, 0.01088516f, 0.12810270f, -0.05867529f, -0.00284232f, -0.04630678f, 
    -0.05724215f, -0.01549558f, 0.04815795f, 0.02854191f, -0.04110418f, -0.01733736f, 0.05455178f, -0.04628507f, 
    -0.02933168f, 0.10476903f, -0.06673094f, 0.00507600f, 0.08009325f, 0.11364025f, 0.05921514f, -0.01404230f, 
    0.14662115f, -0.07185524f, -0.01424854f, 0.07167613f, -0.04023637f, 0.04546256f, -0.04445200f, -0.02901786f, 
    -0.15065658f, -0.10123406f, 0.07990777f, 0.02691041f, 0.04662039f, 0.04700455f, 0.08083086f, -0.00694704f, 
    -0.13696840f, -0.07729046f, -0.08871833f, -0.15799884f, -0.17147125f, 0.07154859f, -0.05502655f, -0.12472457f, 
    0.03850217f, -0.06815355f, 0.07585756f, -0.03491327f, 0.01807537f, -0.00274963f, 0.06564998f, -0.10270911f, 
    0.00177617f, -0.07610922f, -0.08422264f, -0.04270006f, 0.02362181f, -0.12998432f, -0.06261720f, 0.08638901f, 
    0.11026380f, 0.05707453f, 0.03521141f, -0.05451086f, -0.06610067f, -0.01283667f, -0.01252104f, -0.00978486f, 
    -0.03555708f, -0.00349660f, 0.04412341f, -0.03428843f, -0.02183274f, 0.07822446f, 0.01353927f, -0.04448819f, 
    -0.02570350f, 0.13767546f, 0.08760872f, 0.00264507f, -0.01838241f, -0.00455559f, -0.05158522f, -0.03030199f, 
    -0.10619578f, -0.07786439f, 0.05651652f, 0.02360573f, 0.00262223f, 0.01970249f, -0.09269322f, -0.09687843f, 
    0.07436339f, 0.00722180f, 0.02196395f, -0.08439497f, 0.09646271f, 0.02324302f, -0.03111544f, 0.04833011f, 
    0.06062168f, -0.00990929f, -0.00170697f, -0.02649149f, -0.04309835f, -0.04151034f, 0.02812856f, 0.01524559f, 
    -0.04398326f, 0.01293725f, -0.00686235f, -0.07079177f, -0.01304832f, 0.01430350f, 0.07411825f, -0.02594835f, 
    -0.07266419f, 0.02570286f, 0.04085338f, 0.07538100f, -0.01264117f, -0.01037947f, 0.02453124f, -0.19236548f, 
    -0.04368998f, 0.09053428f, -0.00528753f, -0.05880592f, 0.02142218f, -0.01748231f, -0.05209584f, 0.02489015f, 
    -0.00790131f, -0.06224829f, 0.02706940f, 0.02058123f, -0.19665246f, -0.07249052f, -0.01627099f, -0.11882508f, 
    -0.15814699f, -0.00838714f, -0.10745901f, -0.10256040f, 0.01366733f, -0.00681810f, 0.07471847f, 0.03333456f, 
    0.02995156f, 0.00426267f, 0.03500747f, -0.05598285f, -0.01349638f, -0.07757223f, 0.04388559f, -0.00043042f, 
    -0.06108316f, 0.03808286f, -0.14951490f, -0.25948972f, -0.18134341f, -0.03382090f, 0.03036278f, -0.03324600f, 
    -0.06041493f, -0.03936335f, 0.07746990f, -0.00769411f, 0.00156933f, -0.01033222f, -0.01284563f, -0.04874585f, 
    -0.01940341f, -0.09102418f, -0.12214355f, -0.08467977f, 0.15120976f, 0.09357828f, 0.02394051f, 0.03282489f, 
    0.10593265f, 0.02983796f, -0.02963262f, -0.05733588f, -0.04371045f, -0.02171162f, -0.05055501f, -0.03311070f, 
    -0.00862175f, -0.03245175f, -0.03830203f, 0.00985110f, -0.02957246f, 0.03696254f, 0.05758811f, 0.03380024f, 
    -0.18178889f, 0.06829449f, -0.16614078f, -0.13703613f, -0.18090667f, 0.06408441f, -0.03595249f, -0.05981629f, 
    0.07580587f, -0.08756514f, -0.03182673f, 0.02464642f, 0.01572288f, 0.02596535f, -0.00200643f, 0.01773357f, 
    -0.01455155f, -0.14556895f, -0.01970028f, -0.06428689f, 0.06505636f, -0.06129576f, -0.21862882f, 0.14786921f, 
    0.15120213f, 0.03600239f, -0.00627860f, -0.05905553f, -0.01433300f, 0.01361876f, -0.06138289f, 0.00324920f, 
    -0.02069647f, 0.07496916f, -0.00087684f, -0.01433637f, -0.03982656f, 0.02988715f, 0.09142432f, -0.03140483f, 
    0.07509890f, 0.08905778f, -0.13440435f, 0.10124232f, 0.08029861f, 0.01582300f, -0.06683589f, -0.14612599f, 
    -0.06035310f, -0.02549550f, -0.03472275f, -0.07852075f, -0.01654187f, -0.00846766f, 0.06145930f, 0.03688832f, 
    0.02705011f, -0.05275287f, 0.07688618f, -0.01604156f, 0.01838146f, -0.01016103f, -0.10608649f, -0.03149541f, 
    -0.00213345f, 0.03166959f, 0.03123765f, 0.02819950f, 0.00374337f, -0.06543268f, 0.09333696f, 0.00238718f, 
    -0.02985947f, 0.00033209f, 0.07038389f, -0.03468067f, -0.02369821f, -0.00367485f, 0.01707398f, -0.11024524f, 
    -0.13411507f, -0.08928796f, 0.07923374f, -0.10780118f, -0.14759085f, -0.03239952f, -0.05590650f, 0.00059521f, 
    -0.12628897f, -0.02583800f, 0.00914150f, -0.01100790f, 0.03058920f, 0.00972042f, 0.02405398f, -0.00741896f, 
    0.01117124f, -0.07334255f, -0.02326300f, -0.01144799f, -0.00439929f, 0.12799108f, -0.11103343f, -0.06871807f, 
    -0.08806540f, 0.05274045f, 0.03520156f, -0.08433920f, -0.00049785f, -0.01926746f, 0.02495341f, 0.03960105f, 
    0.01309266f, 0.05271917f, 0.01916745f, 0.06660292f, 0.06172397f, -0.01420754f, 0.08311334f, -0.00750023f, 
    -0.03428317f, 0.04245657f, 0.04785189f, 0.07478523f, 0.03760723f, -0.07125618f, 0.02095660f, -0.01119027f, 
    -0.05612694f, 0.00323984f, -0.00064230f, -0.03000496f, 0.02141969f, 0.04026929f, 0.04126859f, 0.00728775f, 
    0.02104900f, 0.00330938f, -0.00612635f, 0.00879486f, 0.07581023f, 0.13726389f, 0.03462251f, 0.02299928f, 
    -0.08975397f, -0.07884165f, 0.00025004f, 0.01711622f, -0.06143226f, -0.02902033f, 0.01934997f, -0.04967543f, 
    0.00472659f, -0.04483579f, 0.03410737f, -0.02931078f, -0.04529929f, -0.06670137f, 0.12270057f, -0.08593532f, 
    -0.16737619f, 0.29134640f, -0.11717948f, -0.11203569f, -0.19251792f, 0.01692297f, -0.00614326f, 0.00799901f, 
    0.01310769f, -0.07283172f, 0.12040890f, 0.00611119f, -0.12815709f, 0.03277422f, 0.07406213f, -0.08012608f, 
    -0.00607025f, 0.00390206f, 0.03487080f, 0.04222357f, 0.10712181f, -0.09512245f, 0.00996073f, 0.03019333f, 
    -0.02591052f, -0.16072232f, -0.02991892f, 0.05232153f, -0.06242138f, 0.01679742f, -0.01821560f, -0.00034178f, 
    0.00095047f, -0.00200569f, 0.06476619f, 0.02284496f, -0.05353322f, -0.07899760f, 0.08168621f, 0.02017285f, 
    0.13068178f, 0.06910667f, 0.06242767f, 0.03589661f, 0.11871032f, -0.13238102f, -0.06889870f, -0.00696432f, 
    0.01605627f, 0.01568286f, -0.02220860f, -0.07033910f, -0.06104738f, -0.11789841f, -0.02008318f, 0.06130062f, 
    0.07623550f, 0.08224558f, 0.06264746f, -0.01262690f, -0.12377561f, 0.05257592f, 0.06865960f, 0.04099392f, 
    -0.00092904f, -0.07593444f, -0.01958135f, 0.06484655f, 0.01931415f, 0.03982899f, -0.02908592f, 0.01028745f, 
    -0.01540690f, -0.04811746f, -0.02000124f, 0.01061316f, 0.01810063f, -0.09555934f, 0.05061664f, 0.04034547f, 
    -0.25261053f, 0.03124632f, 0.15635666f, 0.02795697f, 0.09744269f, -0.07277288f, -0.02880790f, 0.00493646f, 
    -0.04608154f, -0.02021752f, 0.01528179f, 0.02666113f, 0.01532637f, 0.00052547f, 0.06201606f, 0.00565912f, 
    0.08520619f, -0.01015823f, 0.00875808f, -0.01574904f, -0.15647280f, -0.12341700f, 0.08105956f, -0.09646386f, 
    -0.16519922f, 0.03894531f, 0.00079312f, 0.00675818f, -0.07074040f, -0.09131436f, 0.00737281f, 0.01420002f, 
    -0.05327578f, 0.01579844f, -0.04166159f, 0.00733015f, 0.08263258f, -0.05818094f, -0.05931588f, -0.06487733f, 
    -0.02181686f, 0.09918780f, -0.17177919f, 0.08544415f, 0.00205652f, 0.00420627f, -0.08670943f, -0.05504636f, 
    -0.04682963f, 0.00121446f, 0.00277971f, -0.02495638f, -0.03614327f, -0.00482738f, 0.01230394f, 0.04678895f, 
    -0.11988989f, -0.03699291f, 0.07446626f, -0.04889314f, 0.10084563f, 0.11849706f, -0.08628566f, 0.01892771f, 
    0.00243607f, -0.01808938f, 0.04252518f, -0.12198275f, -0.05031963f, -0.03852092f, 0.03219971f, 0.03120624f, 
    -0.02416110f, -0.15179668f, 0.03071529f, -0.06981594f, -0.00211705f, -0.03380907f, 0.07580082f, -0.01099022f, 
    -0.11032047f, -0.08002134f, 0.21564411f, -0.10609052f, 0.04770118f, -0.01804451f, 0.01139903f, 0.04794842f, 
    -0.14504951f, 0.01158805f, 0.03537552f, -0.03563097f, 0.04835866f, -0.04582706f, -0.03654964f, -0.04582811f, 
    -0.01486084f, 0.01140281f, -0.09627594f, -0.08684847f, 0.10530550f, -0.02738073f, -0.04312890f, 0.00801964f, 
    0.03623644f, -0.04716574f, -0.02228030f, -0.03143425f, -0.00481000f, -0.03492084f, -0.02244604f, -0.05152443f, 
    0.04375831f, -0.00871095f, 0.02879721f, 0.03151782f, -0.08088058f, 0.02292520f, 0.01920075f, 0.07941563f, 
    -0.07233741f, 0.04790355f, 0.03700913f, -0.17448711f, -0.20570607f, -0.08436155f, -0.02141050f, -0.02189112f, 
    -0.03951700f, -0.06827895f, -0.03741812f, 0.03776224f, 0.03615014f, 0.01988893f, -0.01312228f, 0.02099001f, 
    -0.00582948f, -0.06112887f, -0.16080444f, -0.00187967f, 0.13152996f, 0.07746133f, -0.01603997f, 0.06509428f, 
    0.07402892f, -0.00974575f, -0.01868316f, -0.03929130f, -0.05170755f, -0.00728889f, -0.00747883f, 0.07304148f, 
    0.01982148f, -0.01409616f, -0.06090663f, -0.03360639f, -0.00838938f, 0.01547242f, 0.05063271f, -0.00083533f, 
    -0.17466280f, 0.13623624f, 0.06546807f, -0.01700922f, -0.19809811f, 0.01668381f, 0.03771286f, -0.01261515f, 
    -0.08262994f, -0.07087366f, 0.02601549f, -0.00249757f, 0.02576630f, 0.06492835f, -0.03680740f, -0.01677881f, 
    -0.01183077f, -0.05179838f, -0.11420932f, 0.00047752f, -0.11034507f, -0.00786983f, 0.00593058f, 0.08353975f, 
    0.03915376f, 0.02771147f, -0.02673697f, -0.07874539f, -0.00611093f, -0.02595710f, 0.08684491f, 0.01179953f, 
    0.00342905f, -0.01203601f, 0.03637004f, -0.04166895f, 0.07355171f, -0.00993126f, 0.04646297f, -0.06877562f, 
    -0.06874369f, 0.16200329f, -0.04996701f, 0.01849511f, -0.08818245f, 0.00541793f, -0.00230657f, -0.11208583f, 
    -0.00252478f, -0.06391720f, 0.03037090f, 0.00404709f, -0.02094229f, 0.05774580f, 0.06418645f, -0.09843853f, 
    0.00305275f, -0.04284070f, 0.03391301f, -0.11505188f, -0.11666322f, 0.07286420f, 0.19093025f, -0.05307454f, 
    -0.01070271f, -0.02235195f, -0.08337501f, -0.04918639f, -0.01933773f, -0.01030488f, 0.00234110f, 0.03680753f, 
    -0.03450457f, 0.01496517f, 0.00951709f, -0.08481170f, 0.08909890f, 0.02363590f, -0.09784119f, -0.03435960f, 
    -0.03278053f, 0.01238444f, -0.00156717f, -0.12509948f, -0.02444523f, 0.11604945f, -0.01302861f, -0.08277677f, 
    0.00562723f, -0.14501980f, 0.10120393f, 0.05667595f, 0.03598286f, 0.04925396f, -0.01398501f, 0.05283829f, 
    0.16016981f, 0.06426978f, 0.05467141f, 0.05463006f, 0.11120542f, -0.01837330f, 0.02788680f, 0.03243289f, 
    0.19775769f, 0.04698964f, -0.02473816f, -0.11263172f, -0.00013592f, -0.01526387f, 0.03437247f, 0.00714103f, 
    0.03212722f, -0.06185840f, 0.08509099f, -0.02142931f, 0.01181078f, 0.05759889f, 0.00328618f, 0.07418518f, 
    0.09482600f, 0.11190250f, 0.09261032f, -0.00343755f, 0.11941738f, -0.04845931f, -0.02499302f, -0.06813201f, 
    0.00545296f, -0.05421116f, 0.00417498f, -0.00554191f, -0.01082215f, -0.09876120f, -0.04830454f, -0.04091381f, 
    0.02288864f, 0.05663295f, 0.02361748f, 0.02859596f, 0.12685929f, 0.12341965f, -0.05737385f, -0.03501353f, 
    0.05997997f, 0.06511184f, 0.06431328f, -0.08032937f, -0.01982208f, -0.02597837f, 0.02139898f, -0.02119740f, 
    0.03012198f, 0.02127784f, -0.04262555f, -0.04719330f, -0.00124905f, 0.02099982f, 0.06091590f, -0.00328433f, 
    0.12568921f, 0.01472479f, -0.12116931f, 0.09200381f, 0.11209082f, 0.12557258f, 0.03446157f, -0.02025148f, 
    -0.03137951f, 0.00344620f, -0.00430787f, -0.01455679f, 0.01393333f, 0.01183412f, -0.01613612f, 0.03724889f, 
    -0.02032062f, 0.06114118f, 0.04908783f, -0.04284563f, -0.23806396f, 0.06509314f, 0.18651336f, -0.03025159f, 
    -0.07939023f, -0.00451912f, 0.04881945f, 0.01921636f, -0.03987399f, 0.00438702f, 0.00798069f, -0.03371240f, 
    0.03204030f, 0.02872896f, 0.02011932f, 0.02258386f, -0.00121090f, -0.01412659f, -0.08199730f, 0.02010144f, 
    -0.18062285f, -0.09329214f, 0.23681411f, -0.05105786f, 0.02065551f, 0.03522122f, -0.01309065f, 0.03789778f, 
    -0.03356059f, -0.02836355f, -0.01116171f, -0.00495719f, -0.00208511f, -0.09179503f, -0.01520452f, -0.05635319f, 
    0.03784900f, -0.01161187f, -0.04272252f, -0.00619164f, 0.04076996f, 0.08260236f, 0.00444618f, 0.06474691f, 
    0.10530732f, -0.10623851f, -0.04050996f, -0.08458542f, -0.12630101f, 0.10773905f, -0.06349960f, 0.00887488f, 
    0.02155176f, -0.03098039f, -0.01403039f, -0.00936325f, -0.05348390f, 0.01527166f, 0.09810822f, -0.09010086f, 
    -0.03152359f, -0.13357984f, 0.02550213f, -0.18876487f, 0.02934525f, -0.02803138f, -0.04921779f, -0.02790981f, 
    -0.04056726f, -0.07652901f, 0.02685001f, 0.00272191f, 0.01739177f, 0.04843851f, 0.04117481f, 0.02685929f, 
    -0.05455498f, 0.01168020f, -0.17701080f, 0.02677675f, -0.04281445f, -0.22145359f, 0.13013650f, -0.01347804f, 
    -0.09209411f, -0.04544975f, -0.07936196f, -0.01203541f, -0.14858633f, 0.12530924f, 0.02973721f, -0.04139230f, 
    -0.02471808f, 0.01998445f, 0.08068562f, 0.01398838f, -0.04427873f, -0.10270612f, 0.09571152f, -0.02351448f, 
    -0.08146213f, -0.10797223f, 0.03400252f, -0.22919492f, -0.16846649f, -0.02639068f, -0.05960662f, 0.01123370f, 
    0.00303846f, -0.04921087f, -0.02816959f, 0.05763233f, 0.04218193f, 0.02354533f, 0.02777409f, -0.05168738f, 
    -0.02179555f, 0.02581940f, -0.10657374f, -0.03259342f, -0.08058242f, -0.03441120f, 0.10283585f, 0.06910294f, 
    0.08102455f, -0.04901044f, 0.01324001f, 0.00193146f, -0.10733842f, 0.04919435f, 0.04695209f, 0.03042660f, 
    -0.01386103f, 0.08835463f, 0.02388866f, 0.02201657f, 0.04711089f, -0.03886666f, 0.04874225f, 0.06946333f, 
    0.00021772f, 0.09465546f, -0.14160663f, 0.09832930f, -0.08338015f, -0.01323719f, -0.03509155f, -0.13211887f, 
    -0.05701041f, 0.07296287f, 0.03259353f, -0.06079932f, 0.04994439f, -0.02507784f, -0.03223567f, -0.00946568f, 
    -0.01569127f, -0.11362031f, 0.12646118f, 0.00375027f, -0.10104807f, -0.15268116f, 0.13856292f, -0.23962265f, 
    -0.19540931f, -0.02343494f, -0.02980599f, -0.00915026f, 0.00422926f, 0.00383936f, 0.03443714f, 0.07065830f, 
    0.00250532f, 0.00013425f, 0.01233573f, -0.03703542f, -0.01201419f, 0.04442775f, -0.05471411f, -0.05520005f, 
    0.13029918f, -0.04670191f, 0.00216828f, -0.02471099f, 0.08787012f, 0.09930082f, 0.02071862f, 0.00306765f, 
    -0.01857902f, -0.01673743f, 0.02152909f, 0.03916411f, -0.01918234f, 0.00423757f, -0.05938340f, 0.05791694f, 
    -0.03859382f, 0.02682037f, 0.00852093f, -0.01376786f, -0.01439278f, -0.04812333f, -0.18137006f, 0.06028365f, 
    0.07742360f, 0.02135232f, 0.01150378f, -0.07189720f, -0.05754570f, -0.06507675f, 0.02535859f, 0.00807109f, 
    0.03015454f, -0.03237569f, 0.06699125f, -0.01822951f, 0.00946368f, -0.02294609f, 0.06714365f, -0.04397050f, 
    0.05132058f, -0.05384983f, -0.05984882f, -0.14862747f, 0.00834306f, 0.09039154f, -0.03210160f, -0.01189115f, 
    -0.04304106f, -0.05777806f, 0.00960326f, 0.04368572f, 0.00324454f, 0.00825494f, -0.02434611f, 0.05037472f, 
    0.09058150f, 0.04020952f, -0.05742034f, -0.00186923f, -0.18787105f, -0.08653933f, 0.19660248f, -0.01421528f, 
    0.06923933f, 0.00348401f, 0.01574488f, 0.04692021f, -0.07929733f, -0.01699653f, 0.04696218f, 0.00989398f, 
    -0.08445816f, 0.06398696f, 0.04676168f, -0.05002794f, -0.01354548f, 0.06131977f, -0.10808530f, 0.06959870f, 
    -0.13633591f, 0.11001360f, -0.13886493f, -0.03816582f, -0.04561538f, 0.06138067f, -0.07680631f, -0.10340734f, 
    -0.00193588f, -0.00909385f, -0.01788513f, 0.00070686f, -0.07721552f, 0.06199332f, 0.04277920f, 0.04025989f, 
    -0.02135372f, -0.04839732f, 0.07144788f, 0.04659156f, -0.14491446f, -0.05409780f, -0.10536164f, -0.18213995f, 
    0.02888863f, 0.09433610f, 0.06492180f, -0.06222217f, 0.00632393f, -0.01754064f, 0.04339373f, 0.01398619f, 
    -0.00831401f, 0.05712896f, -0.04362033f, -0.07623587f, 0.01700342f, 0.06349995f, 0.07132256f, -0.08421224f, 
    0.15700911f, 0.05223602f, 0.02129078f, 0.00080589f, -0.11872852f, 0.02276558f, -0.02258888f, 0.06515536f, 
    0.04480904f, -0.04508066f, -0.02895795f, 0.04850822f, -0.01300489f, -0.02999846f, 0.07016021f, 0.00020126f, 
    0.02700095f, -0.02991606f, 0.03046559f, -0.01306728f, -0.13655038f, 0.15414935f, 0.20283234f, -0.00611106f, 
    0.05073890f, 0.04253368f, 0.00986888f, 0.04931215f, 0.08047026f, -0.10550165f, 0.00968061f, 0.00437572f, 
    0.02237919f, -0.03261421f, 0.04657171f, 0.02064842f, -0.02974723f, 0.06552473f, -0.13312572f, -0.01645207f, 
    -0.12701863f, 0.00535147f, 0.01487564f, -0.16464065f, -0.11828245f, -0.09915308f, 0.08136787f, -0.01048647f, 
    0.04321925f, -0.02352787f, 0.06656665f, 0.00559323f, -0.00730557f, -0.06279891f, 0.00882457f, -0.03379023f, 
    -0.02458496f, 0.04784732f, 0.00012341f, 0.07361227f, -0.01669487f, 0.16245653f, 0.00333178f, -0.14407568f, 
    0.02942616f, 0.05778870f, -0.02525093f, -0.05031051f, -0.02714554f, 0.02617617f, -0.04287901f, 0.04140153f, 
    0.07733260f, 0.07397205f, -0.03065976f, 0.02590278f, -0.01648689f, 0.12706816f, 0.02553323f, -0.01139818f, 
    0.11130767f, 0.05533070f, -0.02135067f, -0.16891666f, -0.13531554f, 0.07286019f, -0.02851108f, 0.01262500f, 
    -0.00696659f, -0.10926407f, 0.04599903f, 0.03944027f, -0.05539992f, 0.08064391f, -0.04212395f, -0.04505597f, 
    0.01773272f, -0.04476713f, -0.06086283f, -0.00948516f, -0.25782511f, -0.08402029f, 0.11471973f, -0.13633385f, 
    0.12884390f, -0.07784301f, 0.04298436f, 0.03857334f, 0.06216414f, -0.03583491f, -0.06478004f, -0.05792955f, 
    -0.13073018f, -0.00052456f, -0.01787143f, 0.12337735f, 0.05216362f, 0.06699537f, -0.08388605f, 0.06381628f, 
    -0.21090397f, 0.15441354f, 0.08126033f, -0.13707238f, -0.10214615f, -0.03899064f, 0.13998461f, -0.16111310f, 
    -0.04120964f, 0.07043602f, -0.11296569f, 0.02114827f, -0.05437081f, -0.00568826f, 0.02740409f, 0.10663787f, 
    0.04802202f, 0.02558541f, -0.08598918f, 0.05597973f, 0.00770083f, 0.25633484f, -0.03186668f, -0.33492446f, 
    -0.21234092f, -0.03930841f, -0.03374858f, -0.00756251f, 0.01749077f, 0.07715416f, 0.00118415f, -0.06079471f, 
    0.05754248f, -0.11116838f, 0.01624580f, 0.05624206f, -0.00492280f, -0.00359170f, 0.04490172f, -0.02912813f, 
    -0.07124297f, -0.06390437f, 0.04782709f, 0.03092004f, 0.03036621f, -0.04364260f, 0.02492449f, -0.05396260f, 
    -0.05443659f, 0.05992834f, -0.02926005f, 0.08349358f, -0.04524639f, 0.08890715f, 0.00012788f, -0.06989856f, 
    0.00923537f, 0.00293137f, 0.08383766f, -0.03747367f, 0.02944835f, -0.20583452f, 0.15398863f, -0.12805562f, 
    -0.15484488f, -0.01629926f, 0.05812494f, -0.08650298f, -0.02741740f, 0.00541919f, -0.04199727f, 0.03893755f, 
    -0.00256447f, -0.07506286f, -0.03171611f, -0.06329937f, -0.01471138f, 0.01239843f, -0.00905156f, 0.04158080f, 
    0.16717510f, -0.23031047f, 0.06618545f, 0.10508461f, -0.04721012f, -0.03696117f, -0.01888442f, 0.08018646f, 
    -0.08543980f, -0.00314084f, 0.07694416f, 0.01843604f, 0.11365147f, 0.04647241f, 0.06731272f, 0.06979545f, 
    0.06615264f, -0.14468357f, 0.00570678f, 0.08616210f, 0.16150860f, 0.02133177f, -0.14672479f, 0.02289240f, 
    0.00355489f, 0.06127701f, 0.04666856f, -0.01987987f, 0.01188073f, 0.08391846f, -0.08058918f, -0.09158069f, 
    -0.00758697f, 0.06352673f, -0.08067477f, 0.04822607f, -0.06348049f, 0.02477483f, -0.02032276f, 0.00820101f, 
    -0.22814932f, -0.28096095f, -0.01364716f, 0.08335426f, 0.03220976f, -0.10934325f, 0.04237617f, -0.02144813f, 
    -0.04862526f, 0.09816208f, -0.09252334f, -0.13848521f, -0.03513596f, 0.06550191f, 0.04985072f, 0.12963219f, 
    0.08133031f, -0.04890405f, -0.00493977f, 0.00630710f, 0.01594074f, -0.17572574f, 0.08553781f, -0.04269019f, 
    -0.08650007f, 0.04516232f, 0.02745365f, 0.01921634f, -0.02256862f, -0.00268197f, -0.05043778f, -0.00305923f, 
    -0.04634138f, -0.04068810f, -0.02324934f, -0.04212564f, 0.02388812f, -0.02503113f, 0.04650111f, -0.01237429f, 
    0.48954895f, 0.05059827f, -0.19601160f, -0.12709522f, -0.10574055f, 0.01013238f, -0.00319659f, 0.10101181f, 
    0.08653089f, -0.09942216f, -0.06007574f, -0.06636508f, 0.01456042f, 0.05462131f, -0.04773876f, 0.08358634f, 
    0.10615719f, -0.01991484f, -0.00774657f, 0.10384996f, -0.18176867f, 0.17185511f, -0.11720168f, 0.05863765f, 
    -0.21686441f, 0.02368954f, 0.00889752f, 0.00102343f, 0.04850715f, 0.00146956f, -0.05133667f, 0.09002527f, 
    0.01173823f, -0.00437243f, 0.02992071f, 0.00644256f, 0.00597367f, 0.06634012f, 0.07641449f, -0.01278531f, 
    0.33880848f, -0.35240075f, -0.05567379f, 0.03612183f, -0.13633473f, -0.02204523f, -0.05956352f, 0.06873742f, 
    0.09394620f, -0.01549578f, -0.02867486f, 0.01414380f, 0.04221476f, 0.02783165f, 0.01228343f, 0.05338323f, 
    -0.05331011f, 0.11021087f, -0.05206931f, 0.01015111f, -0.21856730f, -0.21913947f, -0.03305939f, 0.01765792f, 
    -0.08022428f, -0.07407509f, 0.02382329f, 0.11105266f, -0.03439463f, 0.05491903f, -0.03885037f, -0.04281570f, 
    0.02074017f, -0.04703075f, -0.04228093f, 0.03207184f, -0.07633055f, 0.09780450f, 0.06046577f, -0.05770124f, 
    -0.20425764f, -0.03741765f, 0.02994899f, -0.06274435f, -0.09324878f, -0.07749354f, -0.05703532f, 0.00003125f, 
    -0.02277022f, -0.02151787f, 0.06742530f, -0.03537798f, -0.03063506f, 0.12914474f, 0.04688000f, -0.05166411f, 
    0.12303637f, 0.03766223f, 0.11536247f, -0.01801513f, 0.04864975f, -0.10956070f, 0.12856957f, -0.14035800f, 
    -0.08139074f, 0.03108072f, 0.06518350f, -0.01837672f, -0.06240112f, -0.05230468f, -0.02121774f, 0.03415381f, 
    -0.01115431f, 0.05313178f, -0.00338098f, -0.01135824f, -0.01212973f, -0.06832533f, -0.07020343f, -0.05481537f, 
    0.00160350f, -0.17498562f, 0.16747440f, -0.18214913f, -0.07695175f, -0.08834451f, 0.02841821f, -0.02763222f, 
    0.16850761f, 0.02995394f, 0.02713005f, -0.05744480f, 0.09439287f, -0.09537148f, -0.12697457f, -0.13009666f, 
    0.09005473f, 0.04077878f, -0.03708046f, -0.13721494f, 0.06914956f, -0.15502454f, 0.15900095f, -0.13489033f, 
    -0.17158936f, 0.03263845f, 0.03813740f, -0.06826323f, -0.01949697f, -0.05067904f, -0.08559932f, 0.07758990f, 
    -0.06016891f, -0.07618003f, -0.02622505f, -0.01264651f, -0.03830146f, 0.02796522f, 0.00789976f, 0.00555959f, 
    -0.16525494f, -0.13410541f, 0.02001464f, -0.05854302f, 0.12481409f, 0.08758297f, 0.05767463f, 0.03401450f, 
    0.05793965f, 0.03042446f, -0.00639757f, -0.05928915f, -0.04285209f, 0.04172961f, -0.01153258f, 0.05701737f, 
    0.12011507f, -0.04140896f, -0.12366958f, 0.09715941f, -0.04815586f, -0.04832157f, -0.14456868f, 0.09127174f, 
    -0.22721441f, -0.04482213f, -0.01813930f, 0.04395248f, 0.02552379f, 0.08099041f, -0.02349264f, -0.07388978f, 
    0.01977447f, 0.09309281f, -0.03568920f, 0.04895995f, -0.00884589f, 0.03096018f, 0.00876625f, 0.01715340f, 
    0.27076668f, -0.13699718f, 0.07034733f, 0.01308475f, 0.27186540f, -0.03782924f, 0.03948832f, 0.01248482f, 
    0.03549340f, -0.01435295f, -0.03195423f, 0.00589781f, -0.00207055f, 0.00032690f, -0.04291501f, 0.01977234f, 
    0.00750678f, 0.05026495f, 0.03358171f, 0.06263094f, -0.02995291f, 0.18474077f, 0.14490080f, -0.23946564f, 
    -0.06184289f, 0.05039112f, 0.05671485f, -0.01274767f, 0.05188370f, -0.01916866f, -0.05920618f, -0.06701729f, 
    0.09690453f, -0.10837211f, -0.06514870f, 0.00097486f, 0.01633553f, -0.02403710f, 0.02322575f, -0.06117561f, 
    -0.24786261f, -0.05263785f, -0.07045606f, 0.16048937f, 0.02051729f, 0.06048014f, 0.02161290f, -0.11263231f, 
    -0.01780553f, 0.05736933f, 0.02036258f, 0.05587105f, -0.02380914f, -0.04436837f, -0.05689277f, -0.04296388f, 
    -0.07491494f, -0.01747871f, -0.03163847f, -0.05098264f, -0.50473285f, 0.27883008f, 0.04274573f, 0.07138477f, 
    0.04366025f, 0.15322521f, 0.01527297f, 0.00657616f, 0.02058872f, 0.10465720f, -0.02939306f, 0.00093998f, 
    -0.01468536f, -0.03155751f, 0.07935052f, 0.15984021f, 0.04951967f, 0.05610970f, -0.10777941f, -0.02159064f, 
    -0.42108324f, 0.26292932f, -0.20229693f, 0.23313630f, -0.15284361f, -0.01411602f, 0.03513428f, -0.06395576f, 
    0.02858906f, 0.05338103f, 0.04795555f, -0.00042882f, 0.07394611f, 0.02228473f, 0.08594420f, 0.02471118f, 
    -0.04181532f, 0.03224231f, -0.09714964f, 0.02489514f, -0.11527104f, -0.10545757f, -0.07818536f, 0.10200882f, 
    0.12948875f, 0.05482498f, -0.09457640f, -0.04856273f, -0.00316716f, 0.14409915f, 0.01567425f, -0.01645162f, 
    -0.01216844f, -0.00429015f, -0.01090895f, -0.00082381f, -0.05308644f, 0.00861660f, 0.01043796f, -0.06019976f, 
    -0.23610546f, -0.04283250f, 0.05741718f, -0.00778412f, 0.01473758f, 0.11801048f, 0.02859538f, -0.05108703f, 
    0.00984289f, 0.05473854f, -0.04191606f, 0.04688091f, -0.04944380f, -0.00762091f, -0.09600278f, -0.09869748f, 
    -0.11264984f, -0.02371398f, 0.03340558f, 0.08641617f, -0.11803142f, 0.02586046f, -0.03106955f, 0.10819848f, 
    -0.00653246f, 0.06726825f, 0.02087338f, -0.00746140f, -0.01293587f, 0.06030839f, 0.03052371f, -0.00923599f, 
    0.01326856f, -0.00543371f, 0.02355520f, 0.04003837f, -0.18900432f, 0.02495661f, -0.01741539f, -0.03664741f, 
    0.31968030f, 0.01098105f, -0.06745276f, 0.04654619f, 0.00543495f, 0.01964402f, -0.07686359f, -0.06352226f, 
    -0.05779728f, -0.05513652f, -0.03519318f, -0.03882649f, 0.01331145f, 0.09318460f, 0.09662770f, 0.03724978f, 
    -0.02463880f, 0.07729435f, -0.05399056f, 0.01348453f, -0.13086568f, -0.14950898f, -0.00897574f, 0.17086767f, 
    -0.09076660f, 0.02491285f, -0.03602777f, 0.02128582f, -0.07484008f, 0.03999755f, -0.05330254f, -0.05387640f, 
    0.01921789f, 0.05608429f, 0.05101605f, 0.09276492f, -0.09483106f, 0.03269924f, 0.09375103f, 0.07160953f, 
    0.22860855f, -0.44002828f, 0.13238066f, -0.00049084f, 0.03462938f, -0.00742940f, -0.01185644f, -0.10501137f, 
    0.08793374f, 0.09787986f, -0.01307622f, 0.03936194f, 0.05369814f, -0.18085852f, 0.01210019f, 0.09285738f, 
    0.00919071f, -0.12077188f, -0.04433094f, 0.16825527f, -0.37028271f, 0.20125161f, 0.16027015f, -0.00238329f, 
    0.12707959f, 0.06846496f, -0.04176323f, 0.05919651f, 0.07989662f, -0.16196537f, 0.09889617f, 0.10433576f, 
    -0.00712039f, 0.00421027f, 0.11255235f, 0.01582810f, 0.02924876f, 0.04410984f, -0.09742817f, 0.14700750f, 
    0.27206716f, -0.21129234f, 0.02067592f, 0.13866988f, -0.05089910f, -0.08829693f, 0.00487603f, -0.00406219f, 
    0.08380318f, -0.01207635f, -0.04122480f, 0.08818465f, 0.03350479f, 0.00515577f, -0.03956847f, 0.05120777f, 
    0.09253717f, 0.04726553f, 0.07208855f, 0.00528493f, 0.06142284f, -0.01549034f, 0.17254859f, -0.13797085f, 
    0.08241595f, 0.01939162f, -0.02395421f, 0.02348525f, -0.01514519f, -0.01636580f, -0.06462885f, -0.09318966f, 
    -0.02207990f, 0.13759500f, 0.04371022f, -0.05316877f, 0.00599282f, -0.12938093f, -0.10208289f, 0.01653432f, 
    -0.13497426f, -0.06562871f, -0.05144991f, 0.05870107f, 0.06347933f, -0.01277805f, 0.08015142f, 0.02580180f, 
    -0.06865811f, -0.06655993f, 0.03663624f, 0.04683417f, -0.13657790f, -0.10139115f, -0.06027808f, 0.03645426f, 
    0.01728014f, 0.00570724f, 0.13994576f, 0.06191148f, -0.01499528f, -0.00184909f, -0.13625488f, 0.09661473f, 
    -0.13652161f, 0.11304975f, 0.03991431f, 0.12443263f, -0.03714820f, -0.15211882f, -0.05951075f, 0.07609139f, 
    -0.04001590f, -0.04633129f, -0.02133514f, -0.08154403f, 0.02495171f, -0.03159659f, 0.11171216f, -0.00270714f, 
    -0.17752011f, -0.18841669f, -0.03920887f, 0.12596394f, 0.00954880f, -0.01848912f, 0.01794932f, 0.01041709f, 
    -0.10099567f, -0.01562600f, 0.03895256f, -0.00876289f, -0.04440853f, -0.01575367f, 0.02815746f, -0.02714903f, 
    -0.06669316f, 0.00499305f, 0.06770212f, 0.14763755f, 0.05615136f, -0.02926537f, 0.03890226f, -0.21048139f, 
    -0.07472701f, -0.01371363f, 0.02920935f, -0.04835787f, -0.02978406f, 0.05969987f, -0.04423269f, -0.10665943f, 
    0.02538109f, -0.05848767f, -0.01213843f, 0.09594310f, 0.03710725f, -0.06000106f, -0.07334809f, 0.03339000f, 
    0.07760917f, 0.01224140f, 0.16422135f, -0.22603305f, -0.00949609f, -0.17785712f, 0.06103199f, -0.00390840f, 
    0.12424199f, -0.01205519f, 0.08530342f, 0.02974404f, 0.02932398f, -0.06260791f, 0.08242142f, -0.03357062f, 
    0.08454319f, -0.02510776f, -0.07787790f, -0.01651550f, 0.22757049f, 0.07741951f, -0.03484657f, -0.19378953f, 
    -0.00930252f, -0.19728354f, -0.00920995f, 0.05321033f, 0.15241487f, 0.01627546f, 0.02977401f, -0.01844873f, 
    0.08882967f, -0.05958645f, 0.08019676f, 0.00932993f, -0.07046209f, 0.10762522f, 0.01626760f, 0.01378125f, 
    -0.05213127f, -0.10740568f, -0.18300506f, 0.12347095f, -0.21040261f, 0.03833416f, 0.04777558f, -0.05449412f, 
    0.01457385f, -0.02156391f, -0.14444941f, -0.02836153f, -0.05377434f, 0.09048396f, 0.04080812f, -0.00354200f, 
    -0.00346658f, -0.11165298f, 0.12949964f, 0.09023383f, 0.06256355f, -0.34199381f, 0.10475338f, -0.21448450f, 
    -0.08734202f, -0.00267775f, 0.04810803f, -0.11579756f, -0.00466002f, -0.09273960f, 0.02765493f, -0.03181208f, 
    -0.02387498f, 0.05204550f, -0.04525116f, -0.04561591f, -0.00147012f, -0.16205063f, -0.19906221f, -0.14912353f, 
    -0.08155007f, -0.09638698f, 0.03053292f, -0.14102703f, 0.04457263f, 0.01050150f, 0.01807073f, -0.05067060f, 
    -0.01475265f, 0.03115451f, 0.02107451f, 0.00095803f, 0.01150203f, 0.11623385f, -0.01924761f, -0.00445830f, 
    -0.04109719f, -0.10109645f, 0.02793682f, -0.13050641f, 0.13762660f, -0.13064362f, 0.09964247f, 0.01690966f, 
    -0.16476339f, -0.10062856f, 0.03125459f, 0.14503571f, -0.01871678f, -0.06654093f, -0.03129424f, -0.08491004f, 
    -0.02723139f, -0.04552482f, -0.04133351f, -0.00958336f, 0.01395468f, -0.00456550f, -0.08272434f, -0.05072373f, 
    0.02959805f, -0.12353527f, 0.13249384f, -0.01636684f, -0.09521951f, 0.00557607f, 0.05144594f, -0.05385876f, 
    -0.02383148f, 0.06673626f, -0.01381278f, -0.02252297f, -0.04749123f, 0.01727898f, 0.05284983f, -0.01415842f, 
    -0.04230426f, -0.02991863f, 0.00737504f, 0.04254878f, -0.04055775f, -0.13884747f, -0.02773749f, 0.15555099f, 
    0.04883527f, 0.00855463f, -0.03073697f, -0.03460196f, -0.06904137f, -0.02312048f, -0.07289040f, 0.02144253f, 
    -0.10347953f, -0.04795454f, 0.02976395f, -0.04419419f, -0.02401747f, 0.05995491f, 0.03709928f, 0.08008355f, 
    0.18126912f, -0.11540026f, -0.07146491f, 0.14609651f, -0.03492335f, -0.00948055f, -0.03536546f, 0.01422930f, 
    -0.04918762f, 0.06926406f, -0.08286160f, -0.00904790f, -0.05122183f, 0.03630668f, 0.07913238f, 0.01413925f, 
    -0.07441590f, 0.05717124f, 0.01769222f, 0.02224651f, 0.41269034f, -0.47330460f, 0.03685983f, -0.02588086f, 
    -0.02097775f, -0.05359344f, -0.08199874f, 0.10292199f, 0.17264628f, -0.04709845f, -0.04291673f, 0.05629244f, 
    0.07986168f, -0.04967903f, -0.00638418f, 0.07388468f, 0.07530372f, 0.05441631f, -0.05340508f, 0.01921034f, 
    -0.05692293f, -0.22252718f, 0.20885096f, -0.10829700f, 0.07388242f, 0.02009323f, 0.07860472f, 0.01048682f, 
    -0.03581964f, 0.04391829f, 0.02508481f, -0.06361621f, 0.02001617f, -0.11700525f, -0.00495995f, 0.00753513f, 
    0.00003875f, 0.08243384f, -0.01261266f, 0.04612081f, 0.15638319f, -0.22732884f, -0.10303306f, 0.10846573f, 
    0.26725918f, 0.06919255f, -0.03090820f, -0.10221653f, -0.05570965f, 0.19483598f, -0.03054195f, 0.04569311f, 
    -0.07199046f, 0.07082741f, -0.00946703f, -0.08480329f, -0.00064279f, -0.00444310f, -0.00814565f, -0.06915800f, 
    -0.06416254f, 0.08020700f, -0.02628419f, -0.02773429f, -0.02797514f, -0.00846540f, -0.02078363f, 0.09337816f, 
    0.00351796f, -0.04285800f, -0.00209475f, 0.08391732f, -0.00065229f, -0.07217719f, -0.01919638f, 0.04143171f, 
    -0.02978805f, -0.00704329f, 0.05950798f, 0.05282066f, -0.07580608f, -0.11018004f, -0.16912413f, 0.08012263f, 
    0.01708265f, 0.06168200f, -0.01467743f, -0.02458616f, 0.00043259f, 0.08945534f, 0.11950222f, 0.05238331f, 
    0.03703836f, -0.01876068f, 0.03046245f, -0.08001960f, -0.06051780f, -0.04861213f, 0.02558154f, -0.03594261f, 
    0.28232434f, -0.21415739f, 0.12488661f, -0.01852081f, 0.17446317f, -0.03392873f, -0.02611537f, 0.04247125f, 
    0.02452583f, -0.08685108f, 0.02022356f, -0.02860117f, -0.05550514f, 0.05877095f, -0.06252155f, 0.00781271f, 
    -0.01949212f, 0.12523253f, -0.10076885f, 0.06583503f, 0.11020327f, -0.01108615f, -0.21924153f, -0.11072307f, 
    0.12149671f, 0.09199105f, -0.07402249f, -0.00045006f, 0.00537292f, 0.13304642f, -0.06391208f, -0.01681713f, 
    0.02005315f, -0.01629644f, -0.02375059f, 0.06022217f, 0.03372366f, 0.11503746f, 0.03369264f, -0.12401671f, 
    0.03207547f, -0.15866911f, 0.21863244f, -0.08977973f, -0.17392910f, 0.04742321f, 0.01113186f, -0.00565965f, 
    -0.03505786f, 0.06652291f, 0.00983520f, -0.02109865f, 0.02759517f, -0.00790096f, 0.02134457f, 0.01500011f, 
    -0.00384682f, -0.02416375f, 0.03739994f, 0.03930202f, -0.18282092f, -0.01880571f, 0.02751342f, -0.10341280f, 
    -0.15921840f, -0.01438168f, 0.02185749f, 0.00433993f, -0.00402248f, -0.03925197f, -0.04167365f, -0.04936939f, 
    -0.06961663f, -0.02891533f, 0.00631262f, 0.00612937f, -0.05588788f, 0.08474389f, -0.04436332f, -0.02381961f, 
    0.10000111f, 0.11717948f, -0.05979892f, -0.35461867f, -0.25436077f, 0.01779645f, 0.04280398f, 0.01602254f, 
    -0.05830956f, 0.03388540f, -0.03221302f, 0.02484870f, 0.02957135f, -0.02368822f, -0.08069570f, -0.07740624f, 
    0.02330500f, -0.00209863f, 0.15081470f, 0.03141420f, 0.08203719f, -0.19293886f, -0.10900678f, 0.14143738f, 
    -0.06277324f, -0.09774330f, 0.02863959f, -0.05029755f, 0.03426594f, -0.03910541f, -0.00707923f, 0.08705074f, 
    0.08055536f, -0.03433161f, 0.06769442f, -0.07422367f, 0.00895285f, 0.01736350f, 0.07602176f, 0.00225469f, 
    0.13139400f, -0.32609653f, 0.04465483f, -0.00204619f, -0.15609321f, -0.01888457f, 0.04986016f, -0.10026056f, 
    0.07509428f, 0.03401768f, -0.03617989f, 0.08961286f, 0.08063792f, -0.04606092f, 0.04493405f, 0.01091735f, 
    0.05790372f, -0.00019149f, 0.00902655f, -0.11048245f, 0.09598255f, -0.07228960f, 0.05411750f, 0.04767644f, 
    -0.44219145f, -0.03207233f, -0.02914441f, 0.23912817f, -0.07266641f, 0.10148073f, 0.03132385f, 0.07088794f, 
    0.02140937f, -0.15075682f, -0.02574290f, -0.03751733f, 0.03181412f, 0.00783412f, -0.06938001f, -0.06392419f, 
    -0.29993975f, -0.26037586f, -0.03570738f, -0.06466299f, -0.09160666f, 0.07180745f, 0.05322702f, 0.03010393f, 
    -0.02865171f, 0.03641455f, 0.05612090f, 0.01120363f, -0.00710376f, 0.05920609f, 0.00364675f, 0.00588280f, 
    0.05047190f, 0.04246169f, 0.10362600f, 0.06004016f, -0.13488504f, -0.15128815f, -0.11089069f, -0.05707709f, 
    0.03815354f, 0.01503011f, 0.00941626f, 0.04648122f, -0.02638433f, -0.02569726f, 0.05222638f, 0.02656139f, 
    -0.09022826f, -0.01920770f, 0.00740281f, 0.02166593f, 0.06638491f, 0.09409215f, 0.09685367f, 0.04130047f, 
    0.07843644f, 0.07284924f, 0.19759947f, 0.03873737f, 0.01003444f, 0.10433608f, 0.03359624f, 0.03172730f, 
    0.06349757f, 0.03544076f, -0.03953176f, 0.03525311f, 0.05792776f, 0.10051948f, -0.00390619f, 0.03226328f, 
    0.07139054f, -0.13085073f, -0.10751251f, -0.12629554f, -0.26778841f, -0.18011433f, -0.15745936f, -0.09268533f, 
    -0.08237253f, 0.03946644f, 0.01286546f, 0.00297070f, -0.02095074f, 0.07496650f, 0.08023175f, -0.01189027f, 
    0.07255187f, -0.01571781f, -0.00801027f, 0.05939246f, -0.00439161f, 0.07867081f, 0.07642986f, 0.02968256f, 
    -0.27407122f, -0.12603237f, -0.01724139f, -0.07924708f, -0.02312646f, 0.06303457f, -0.00620195f, -0.01303641f, 
    -0.00983877f, 0.03604969f, 0.00568499f, -0.08148659f, -0.01768238f, -0.05640318f, 0.03594719f, 0.01918226f, 
    -0.03997008f, 0.07301196f, 0.11809135f, 0.05598337f, -0.20759346f, -0.08189544f, -0.09628140f, 0.09609049f, 
    0.02766293f, 0.05024582f, -0.04309077f, -0.00381550f, 0.00154693f, 0.04227913f, 0.00422410f, 0.02366732f, 
    0.06822716f, -0.09157322f, 0.11165688f, -0.01199249f, -0.06841645f, -0.18712078f, -0.03769304f, -0.06519296f, 
    -0.54309005f, -0.26073170f, 0.03365872f, -0.14260173f, -0.18366881f, 0.05681857f, 0.00987045f, 0.01424979f, 
    -0.07222307f, -0.03358507f, 0.04152257f, 0.02046981f, -0.03206652f, -0.04345595f, -0.05865603f, -0.01667396f, 
    -0.19406490f, -0.02469418f, -0.00747953f, -0.10438827f, 0.01332240f, -0.07091285f, 0.06145789f, -0.03829777f, 
    0.03589243f, 0.06311302f, 0.05469056f, 0.02938484f, -0.00341826f, 0.08941753f, -0.01348127f, 0.00749024f, 
    0.07689326f, 0.05367951f, -0.05480768f, 0.01522322f, 0.02025776f, -0.04152897f, 0.00091003f, 0.02337042f, 
    0.07830432f, -0.08216393f, -0.03682451f, 0.08216053f, -0.00469516f, -0.00165605f, 0.04536004f, 0.05654149f, 
    0.02042105f, 0.06091160f, -0.01951154f, 0.00738713f, -0.04735867f, -0.00542552f, -0.04496500f, 0.03726630f, 
    0.02712974f, -0.08293856f, -0.10334390f, 0.01943452f, -0.32102144f, -0.07888854f, -0.01442304f, -0.05823626f, 
    -0.19857134f, 0.01783745f, 0.00377714f, 0.02789203f, -0.02586128f, 0.05789221f, -0.04248662f, 0.04278118f, 
    -0.04717626f, 0.08842714f, 0.00936185f, 0.03718911f, -0.01616720f, 0.00312831f, -0.04870628f, -0.00549486f, 
    0.01759564f, -0.04696338f, -0.06073790f, -0.07200399f, 0.13831152f, -0.05774475f, 0.04021612f, -0.11894315f, 
    0.03203711f, -0.08269998f, -0.02010983f, 0.08504362f, -0.05576719f, -0.05433257f, -0.04836824f, 0.00549642f, 
    0.03152676f, 0.04582107f, -0.15741342f, 0.06299195f, 0.20868960f, -0.05153864f, -0.08889564f, -0.02813909f, 
    -0.00038053f, -0.12265401f, -0.07730209f, -0.07388831f, 0.01049623f, -0.15642045f, -0.01381262f, 0.04405450f, 
    -0.04655039f, -0.09178888f, -0.07656940f, -0.11843765f, -0.05758114f, -0.01610109f, -0.06700245f, -0.05647205f, 
    -0.16001181f, 0.01211907f, 0.03966514f, 0.08835328f, 0.02606067f, 0.04170622f, -0.01120819f, -0.01532760f, 
    -0.03578861f, -0.01423636f, -0.01278605f, 0.03187872f, -0.02218136f, -0.03774209f, 0.03655779f, 0.02194911f, 
    -0.06894775f, -0.12297153f, -0.10804959f, -0.03309146f, -0.39200914f, -0.18849924f, -0.00083067f, -0.00780940f, 
    -0.17531009f, 0.03547881f, 0.06020633f, -0.03992500f, 0.00620496f, 0.06353856f, 0.04441630f, 0.04499226f, 
    -0.03455795f, 0.06285264f, -0.00833408f, 0.01812737f, 0.01501399f, 0.03464565f, 0.00702550f, 0.02806199f, 
    -0.34582123f, -0.10912175f, 0.17396247f, 0.07398581f, -0.05187922f, 0.07052190f, -0.02691386f, -0.01134591f, 
    -0.03817101f, 0.09539414f, -0.02221948f, 0.03516074f, 0.02576561f, -0.01716213f, 0.07194769f, -0.06032702f, 
    0.00170617f, 0.05578179f, 0.06190512f, 0.04968354f, -0.36609733f, -0.22779322f, 0.05306130f, 0.02675050f, 
    -0.10225362f, 0.05348216f, 0.05672081f, 0.03189479f, -0.06056217f, 0.05329723f, 0.05921141f, -0.00971342f, 
    0.05045826f, -0.02866203f, -0.03663574f, 0.02651255f, 0.02338091f, 0.04681206f, 0.01661770f, 0.02745821f, 
    0.04295785f, -0.00324801f, 0.00853651f, -0.01265906f, 0.08036739f, -0.06530037f, 0.03727828f, -0.00108384f, 
    0.05034553f, 0.00624654f, 0.00648424f, -0.01270333f, 0.00446908f, -0.02422587f, 0.14160448f, 0.06608756f, 
    0.12209416f, 0.10294721f, -0.03784575f, 0.00877695f, 0.05853581f, 0.00776511f, -0.16076845f, 0.07003283f, 
    0.12154500f, -0.04518821f, 0.01064817f, 0.01897681f, -0.03677694f, 0.07615569f, 0.03025354f, 0.00168716f, 
    0.06309053f, -0.00449688f, 0.02905455f, 0.03549068f, 0.05966298f, 0.02142761f, 0.07423368f, 0.03763165f, 
    0.05157208f, -0.01284696f, -0.03786579f, 0.04567975f, -0.02247922f, 0.00252064f, 0.10579976f, 0.06083536f, 
    0.07443087f, 0.07764111f, 0.00204201f, -0.00621023f, -0.02077646f, -0.06705742f, -0.02491282f, 0.09947643f, 
    -0.03456893f, -0.07814724f, -0.09161835f, -0.01345238f, -0.30280450f, -0.10333443f, -0.12911046f, -0.10450219f, 
    -0.00511109f, 0.06433307f, 0.02904699f, -0.07262763f, -0.01552026f, 0.01191966f, -0.03463694f, -0.03536509f, 
    0.00394916f, 0.00015465f, 0.04398657f, -0.05354060f, 0.00974278f, 0.13071914f, 0.04710368f, 0.05974388f, 
    -0.00142766f, 0.03534142f, 0.00150906f, 0.04863707f, 0.03968599f, 0.10313945f, -0.00816537f, 0.05356553f, 
    0.00477297f, -0.06291649f, -0.00308114f, 0.02558474f, -0.00339419f, 0.09271870f, 0.09244711f, -0.07623366f, 
    -0.03578638f, -0.08461382f, -0.11271859f, 0.00137706f, -0.43226328f, -0.18249129f, -0.17553982f, -0.10069592f, 
    -0.18152322f, 0.00633978f, -0.00305665f, -0.07593408f, -0.03678092f, 0.06618427f, 0.00568926f, 0.04616803f, 
    -0.03287982f, 0.05948954f, -0.00511203f, 0.04970683f, 0.00436800f, 0.05358938f, -0.01912506f, 0.01299860f, 
    -0.00691096f, -0.10083431f, -0.13178052f, 0.00298990f, -0.03953012f, 0.00835959f, 0.04200492f, -0.11879358f, 
    -0.00522817f, 0.01740725f, 0.06312107f, 0.06850950f, -0.12928958f, 0.02898674f, 0.09767668f, -0.05844509f, 
    -0.01466306f, 0.00743453f, -0.01832764f, -0.03439659f, -0.07894146f, -0.12814438f, -0.04829436f, 0.00130147f, 
    0.00528044f, -0.04963882f, 0.01736972f, 0.00204937f, -0.02925919f, -0.03227874f, -0.00320651f, 0.01479558f, 
    0.04407826f, -0.08085138f, 0.02242295f, -0.00408766f, -0.05199303f, 0.05682950f, -0.04371977f, 0.02875239f, 
    0.11317027f, 0.10970721f, -0.04813341f, 0.03060164f, 0.03189234f, 0.00009548f, 0.01375250f, 0.02870619f, 
    0.00915620f, 0.02506228f, 0.02883682f, 0.03048828f, 0.01204587f, 0.04144707f, -0.03034342f, 0.08254255f, 
    0.02093075f, -0.03985001f, -0.13990463f, 0.05124793f, 0.04755796f, -0.14504912f, -0.08027944f, -0.03658580f, 
    0.12810658f, 0.06949404f, 0.02040290f, 0.00988953f, 0.08447285f, -0.03997676f, 0.06017093f, 0.03202411f, 
    0.02438729f, 0.04645668f, -0.03237516f, 0.09826246f, 0.13044043f, -0.05224043f, 0.10464305f, 0.06434353f, 
    0.13881470f, 0.03594790f, -0.05948970f, 0.08002471f, -0.08684792f, -0.09066492f, -0.05369217f, -0.01223742f, 
    0.03707432f, 0.00646717f, 0.01794382f, 0.02616312f, -0.00528990f, 0.01492472f, 0.03939454f, 0.02722841f, 
    0.00560723f, -0.05597464f, 0.02236416f, -0.04118422f, -0.11500876f, -0.00725287f, -0.01982594f, 0.03408908f, 
    -0.07631858f, 0.02806947f, 0.06594983f, 0.08267979f, -0.01300577f, -0.04488238f, 0.08025786f, -0.02514239f, 
    -0.00235024f, -0.06457834f, 0.01844510f, 0.01401975f, -0.03333665f, -0.02874370f, 0.12882027f, -0.00674999f, 
    -0.10353412f, -0.26295725f, -0.12087648f, -0.02141717f, 0.31532359f, -0.02903887f, 0.04411360f, 0.03348102f, 
    -0.01139477f, -0.10943816f, -0.00013301f, -0.06940098f, -0.01466457f, -0.04264848f, 0.05529873f, -0.06467662f, 
    0.01260005f, -0.05478218f, -0.01695344f, 0.10383447f, 0.19920298f, 0.12451229f, -0.12593101f, 0.05848351f, 
    -0.03713976f, -0.05711448f, -0.05796260f, 0.01138060f, 0.00622244f, -0.02602722f, 0.01716948f, -0.02541326f, 
    -0.00161629f, -0.07492810f, -0.06171801f, 0.02588935f, -0.02346193f, 0.00681504f, -0.01972796f, -0.01016502f, 
    0.20912644f, 0.06492738f, -0.05826991f, -0.03553897f, -0.11418955f, -0.10478925f, -0.01622914f, -0.07191923f, 
    0.03084443f, -0.08867642f, -0.05302146f, 0.00266202f, -0.07628105f, -0.11440523f, 0.05716982f, -0.03308163f, 
    0.02851447f, 0.02085564f, 0.00139790f, -0.03063324f, 0.16599415f, 0.05602935f, -0.00841336f, 0.02429772f, 
    0.00393259f, -0.08209100f, -0.06155598f, 0.02593264f, 0.04971369f, 0.01522311f, -0.04170046f, -0.03915221f, 
    0.00201612f, -0.07859804f, -0.02330724f, 0.03473648f, 0.01966470f, -0.03812924f, 0.06766550f, -0.01528472f, 
    0.06815237f, 0.06004374f, 0.03554082f, -0.10524475f, -0.04403104f, -0.05991533f, -0.11629737f, 0.06687557f, 
    0.04279628f, -0.01737051f, -0.04633234f, 0.02834827f, -0.03581116f, -0.05332237f, 0.02849585f, -0.04317402f, 
    0.01680127f, 0.01091720f, 0.01221770f, 0.05209987f, 0.13876666f, 0.10111359f, -0.00657188f, -0.03131235f, 
    -0.06491927f, 0.06293805f, -0.00501415f, 0.07196970f, -0.06948183f, 0.01687745f, -0.02761208f, -0.00728287f, 
    -0.00318026f, -0.06739705f, -0.03279914f, 0.01623807f, 0.01326401f, -0.13421798f, -0.02092565f, 0.02844334f, 
    -0.16432750f, 0.02461712f, -0.15668242f, 0.16540378f, 0.03744541f, 0.02404101f, 0.04537307f, -0.11051379f, 
    -0.00097968f, 0.09028021f, 0.00316938f, 0.01240817f, -0.03924173f, 0.03207092f, 0.13049459f, 0.04895374f, 
    -0.00405525f, 0.06220233f, -0.05935545f, -0.00671554f, -0.31853333f, -0.23144272f, -0.11100250f, -0.03938201f, 
    0.08089833f, 0.02087838f, 0.07427069f, -0.08062597f, -0.06754499f, -0.06301326f, 0.00599773f, -0.04678014f, 
    -0.03819909f, -0.02806132f, -0.01577193f, -0.00481231f, 0.02021394f, 0.02376220f, 0.08800303f, -0.03077987f, 
    0.11433632f, -0.03325834f, -0.00948831f, 0.03489278f, 0.00701823f, -0.00351576f, 0.07380823f, -0.02279068f, 
    0.03443497f, -0.04732731f, 0.06960773f, 0.11425914f, -0.00018882f, 0.02017620f, 0.05324143f, -0.01355485f, 
    0.03339093f, -0.03006107f, -0.18664081f, 0.04688187f, -0.26818863f, 0.08326542f, -0.16258255f, -0.05035645f, 
    0.02006699f, -0.01505037f, 0.08042457f, -0.03446764f, 0.01876803f, 0.04034622f, 0.04539141f, 0.00712040f, 
    0.06039789f, -0.05996233f, 0.00384058f, -0.05488338f, -0.03356267f, 0.08999828f, 0.05580204f, 0.07400754f, 
    0.19638440f, 0.14945811f, -0.02502651f, -0.03103276f, -0.04315525f, 0.08174346f, 0.02185803f, 0.08260231f, 
    0.03068297f, 0.00331648f, -0.00840034f, -0.01453303f, 0.01777640f, -0.01916227f, -0.04096130f, 0.08830836f, 
    0.10074287f, -0.13383357f, -0.08644042f, 0.01069860f, -0.20954481f, -0.15260638f, -0.05509289f, -0.05024493f, 
    -0.01362783f, 0.04366932f, 0.04223686f, -0.00634964f, -0.02894840f, -0.04479405f, 0.05970975f, -0.10635162f, 
    -0.01842614f, -0.02021334f, -0.04651593f, -0.06010055f, 0.00017110f, 0.10686925f, 0.11453975f, 0.10858417f, 
    0.15847994f, 0.04848333f, -0.03842897f, 0.02848879f, -0.06694046f, 0.00383779f, 0.05342491f, 0.04239807f, 
    0.03690355f, 0.04987714f, 0.00319059f, -0.03617877f, 0.03104298f, -0.00642642f, -0.01545311f, -0.00292851f, 
    0.02582523f, -0.14031392f, -0.03982183f, -0.01904669f, -0.32062149f, -0.05174046f, 0.03208737f, -0.08904997f, 
    -0.11222082f, 0.05964172f, 0.01767031f, 0.01981126f, -0.01183155f, 0.02759203f, 0.03125494f, -0.01414404f, 
    -0.00924241f, 0.05989642f, -0.03392634f, -0.06166015f, -0.05009751f, -0.03902378f, -0.02253038f, -0.00129398f, 
    -0.22717254f, -0.21220176f, -0.08073654f, -0.08150236f, 0.09898711f, 0.08913366f, -0.03173160f, 0.08953179f, 
    -0.06173663f, -0.02169895f, -0.01677045f, 0.08590892f, -0.12765244f, 0.01501895f, -0.04709230f, -0.04264701f, 
    0.00399832f, 0.01110491f, 0.07014535f, 0.07940672f, 0.04425546f, -0.10101859f, 0.05592184f, -0.07835201f, 
    0.08875918f, -0.01545429f, -0.11269779f, 0.04547301f, -0.01581297f, 0.05309600f, 0.01012743f, 0.07207248f, 
    -0.16002162f, -0.00206882f, -0.01468671f, -0.03512520f, 0.07105145f, -0.04519638f, -0.01020896f, -0.03548732f, 
    -0.25985569f, -0.11830468f, 0.06665982f, -0.12814781f, -0.02432840f, 0.07396028f, 0.10736157f, 0.02034355f, 
    -0.01216891f, -0.02770012f, -0.05132556f, -0.00736833f, 0.01607650f, 0.03270324f, -0.05400338f, 0.08509868f, 
    0.12793499f, 0.02718358f, 0.00728353f, 0.08403380f, -0.64777541f, -0.11976038f, -0.20193757f, -0.18979925f, 
    -0.04275273f, 0.10089704f, -0.04282358f, -0.17800061f, -0.10377437f, 0.07091898f, 0.04315568f, -0.02116844f, 
    0.01343303f, -0.09253211f, 0.07612817f, -0.04352174f, -0.07625134f, 0.05304615f, -0.01387190f, 0.01231618f, 
    -0.15176444f, 0.03491089f, -0.08996907f, -0.07721779f, -0.04513810f, 0.08564816f, 0.08221146f, -0.05346996f, 
    0.02470849f, 0.01724271f, 0.04378381f, -0.01046983f, -0.00750784f, -0.04346361f, 0.05834039f, -0.07624166f, 
    -0.03278219f, 0.10091319f, 0.04699167f, 0.03417009f, -0.32448331f, -0.13245144f, -0.12074371f, 0.02356592f, 
    0.14583245f, 0.10787325f, -0.00118954f, -0.07079805f, -0.01839108f, -0.03221082f, -0.03629395f, -0.03815706f, 
    0.00995019f, 0.09264605f, 0.04341048f, 0.05611184f, 0.10929342f, 0.10361502f, -0.00626232f, 0.02357461f, 
    -0.35498014f, -0.15351672f, -0.19650403f, -0.11166579f, -0.13753115f, 0.08106890f, 0.02954309f, -0.04597919f, 
    -0.05388938f, 0.02937916f, -0.03762045f, 0.01727867f, -0.04561594f, 0.03988607f, 0.02974590f, -0.01191459f, 
    -0.01032883f, 0.06463687f, 0.03478144f, 0.04560465f, 0.10131831f, 0.01568682f, 0.02481562f, -0.00399054f, 
    -0.10783479f, -0.00472519f, 0.00743548f, 0.07420073f, 0.01302300f, 0.04338574f, -0.00410696f, 0.01800840f, 
    0.02944149f, -0.04701654f, 0.04210586f, 0.04737256f, 0.04318744f, -0.03226123f, -0.07817365f, -0.01828742f, 
    0.14908795f, 0.03266594f, -0.01243590f, 0.01152143f, -0.12229561f, -0.08923659f, -0.06733333f, 0.02669631f, 
    -0.01898804f, -0.00556900f, 0.01020244f, 0.06117588f, -0.03864313f, -0.03236337f, -0.07727251f, -0.03933786f, 
    -0.05480193f, -0.06368210f, -0.11128565f, -0.06620988f, -0.05851641f, -0.05714430f, -0.00866037f, 0.05672523f, 
    0.04404164f, -0.03451601f, 0.05424722f, -0.13489217f, 0.01716981f, -0.03253853f, 0.00223973f, 0.04942190f, 
    0.00697433f, -0.01683585f, 0.16886853f, -0.00067286f, -0.01715035f, 0.00627406f, -0.04314253f, -0.01894754f, 
    0.11756969f, 0.16549040f, 0.01570002f, -0.06683759f, 0.01374546f, 0.03686632f, 0.03913493f, 0.06067572f, 
    0.07734496f, 0.06749412f, 0.00018366f, 0.06578615f, 0.06267238f, 0.01176402f, 0.03876910f, 0.08376539f, 
    0.03833293f, -0.00936346f, -0.06549398f, 0.08131382f, 0.27381378f, 0.11848470f, -0.31995443f, 0.11771341f, 
    -0.09445779f, -0.12207691f, -0.13057235f, 0.01017853f, -0.06826385f, -0.02056064f, 0.04737113f, 0.05512638f, 
    -0.05307719f, -0.05291073f, -0.13962103f, -0.04718126f, 0.00512936f, -0.01609367f, -0.04702407f, -0.02661217f, 
    0.15741983f, 0.19317405f, 0.00087663f, 0.00578733f, 0.00876930f, -0.00408132f, 0.04023921f, 0.06242156f, 
    -0.01536537f, 0.03223288f, -0.04791401f, -0.01143076f, 0.03991652f, -0.01880378f, 0.00765195f, 0.02933487f, 
    0.08771039f, -0.02793680f, -0.02601895f, 0.06946094f, 0.15290175f, 0.04037154f, -0.05417734f, 0.02563774f, 
    -0.05328438f, -0.06358139f, -0.07994309f, -0.03458801f, 0.03132294f, 0.02858394f, 0.01068207f, -0.02790888f, 
    -0.09414984f, 0.00867148f, -0.01829098f, 0.06464327f, 0.00819820f, 0.07464385f, 0.02670146f, -0.00618169f, 
    -0.14083695f, 0.01929688f, -0.14872494f, 0.08916368f, 0.07906936f, 0.01778489f, -0.00149113f, -0.04036896f, 
    0.04373512f, 0.01874635f, -0.00523891f, 0.01704583f, 0.11084900f, -0.08029141f, 0.11581897f, -0.01760132f, 
    0.04709784f, 0.05869795f, 0.02151726f, -0.05208424f, 0.03245491f, 0.11449440f, -0.00913267f, 0.08142261f, 
    -0.07181630f, 0.00468895f, -0.06252661f, -0.02723586f, -0.04545679f, 0.04092705f, -0.03422216f, 0.00674359f, 
    0.01841890f, -0.01805511f, -0.02001920f, -0.04411789f, -0.06343807f, -0.06515181f, -0.04708942f, -0.05033448f, 
    -0.26496094f, -0.02376155f, -0.07338962f, -0.06944310f, 0.00251069f, 0.04565149f, 0.03662449f, -0.03822392f, 
    0.05096824f, 0.07406434f, -0.01976377f, 0.00608636f, -0.00598365f, 0.04202564f, 0.00695841f, 0.07851046f, 
    0.00864116f, 0.14487974f, 0.00868368f, 0.07300558f, -0.33267114f, -0.16426353f, 0.10451893f, -0.02493422f, 
    -0.06074044f, 0.12792817f, 0.01448952f, -0.02317228f, -0.00179470f, 0.00869237f, 0.01942954f, 0.08845869f, 
    0.03411510f, 0.12476198f, 0.00645343f, 0.09543345f, -0.00807877f, -0.02227179f, -0.06145747f, -0.01595101f, 
    -0.00173304f, 0.12423781f, 0.10056228f, -0.07724891f, -0.08812971f, 0.07418737f, -0.02227050f, -0.02122862f, 
    0.06652423f, 0.02565137f, -0.01073480f, 0.03146229f, 0.07322079f, 0.04385666f, 0.02312833f, 0.07475035f, 
    0.09344099f, 0.01098553f, -0.02853311f, 0.00174208f, 0.09395549f, -0.02165988f, 0.01548129f, -0.03255330f, 
    -0.04652068f, 0.03174561f, -0.00687129f, -0.00915386f, 0.01195581f, -0.05263013f, 0.03219497f, 0.01460615f, 
    -0.04783388f, 0.04296179f, -0.01654463f, -0.03955521f, 0.02487982f, -0.02247275f, -0.10497198f, -0.01245117f, 
    -0.06680071f, 0.04989218f, -0.07336380f, -0.01520144f, 0.08269408f, 0.11297642f, 0.00502153f, -0.04237956f, 
    -0.01958794f, -0.02075238f, -0.02146457f, 0.08481965f, -0.11416476f, 0.03975219f, 0.01901131f, -0.04245788f, 
    0.15755786f, -0.00558483f, 0.04604228f, 0.09522207f, -0.38193271f, -0.03420772f, 0.08822248f, 0.01280333f, 
    -0.08019961f, 0.10453748f, 0.00455550f, 0.01230505f, -0.05555300f, -0.02469939f, -0.03166004f, 0.00869651f, 
    0.04832214f, 0.10850794f, 0.03352921f, 0.03487035f, 0.00583177f, 0.02727577f, -0.08512702f, -0.03103063f, 
    0.15754651f, -0.26752687f, -0.01297147f, -0.07792575f, -0.14031632f, 0.04230162f, 0.01747916f, 0.02533170f, 
    0.00131154f, 0.03579850f, 0.00978857f, 0.05355100f, 0.02234588f, 0.03401726f, -0.04142106f, -0.02566054f, 
    -0.00867555f, -0.01891238f, -0.02017697f, -0.03819443f, -0.16611677f, -0.09328671f, 0.00431361f, 0.04746534f, 
    -0.10515252f, 0.12420204f, 0.05378845f, 0.04027200f, 0.01919316f, 0.06320585f, -0.02353104f, 0.04460289f, 
    0.01458930f, 0.01283223f, -0.03546689f, -0.06655689f, -0.05000040f, -0.05478549f, 0.02531382f, 0.04610235f, 
    0.12304222f, 0.15885763f, -0.18508495f, -0.03237659f, 0.14209680f, -0.02464048f, -0.04147557f, -0.06517106f, 
    0.07594691f, -0.02680247f, 0.05803085f, 0.04625954f, 0.00731424f, 0.00714583f, -0.00060646f, 0.04070216f, 
    0.00093421f, 0.08124466f, -0.01724269f, 0.05748178f, 0.22007525f, -0.10029166f, -0.16174169f, 0.09076996f, 
    -0.12657747f, 0.03981912f, 0.00391501f, 0.02524036f, -0.01697614f, 0.03344779f, 0.04076625f, -0.03450777f, 
    0.03965170f, 0.05122828f, -0.03821188f, 0.02976380f, -0.02693587f, -0.07960189f, -0.01568000f, -0.04958128f, 
    0.03522759f, -0.23630300f, -0.05606821f, -0.03662580f, -0.04852858f, 0.00691214f, -0.04494364f, -0.02387138f, 
    -0.00412138f, 0.00679100f, 0.01041836f, 0.03402677f, -0.07755359f, 0.00443729f, 0.02341251f, -0.00114808f, 
    -0.06390086f, -0.09737138f, -0.02350883f, -0.10999194f, -0.05724997f, -0.00737994f, -0.26429334f, 0.15140237f, 
    -0.16287893f, -0.01553937f, 0.01175992f, -0.03450241f, -0.00030287f, -0.06689283f, 0.06174277f, -0.08010517f, 
    0.05513535f, 0.06914800f, -0.01591207f, 0.06693937f, 0.09201812f, 0.00391086f, -0.10885645f, -0.14378701f, 
    0.26943758f, 0.02842415f, -0.24660552f, -0.09020645f, -0.08600041f, 0.08446223f, 0.00026092f, -0.01799711f, 
    -0.01922579f, -0.00727116f, 0.07646954f, 0.01264056f, 0.01466274f, 0.04684525f, 0.00944744f, 0.03526296f, 
    0.05567160f, -0.01811569f, -0.04437786f, 0.01040898f, 0.20116012f, -0.05155385f, -0.11757883f, 0.14932021f, 
    0.03330184f, 0.09025943f, -0.00230908f, -0.05516195f, 0.05262676f, 0.03768011f, 0.04664411f, 0.06498752f, 
    0.02244988f, 0.04165957f, 0.01301623f, 0.05585224f, -0.01948300f, 0.01598546f, 0.02656798f, 0.05311779f, 
    0.02891265f, 0.15263681f, 0.00275173f, -0.00375317f, 0.13340624f, 0.09227864f, -0.09272005f, -0.01813446f, 
    -0.05023140f, -0.06438459f, -0.08282236f, 0.00865268f, 0.04067374f, -0.05967173f, -0.00014553f, 0.02700069f, 
    0.01931495f, 0.07202971f, 0.03015798f, -0.01744211f, 0.35762516f, 0.01798221f, -0.12321851f, -0.09342951f, 
    -0.02602933f, -0.06815917f, -0.03874734f, 0.01435347f, 0.00324334f, 0.02239916f, 0.11571464f, -0.01334849f, 
    -0.00026790f, -0.00836627f, -0.00251736f, -0.01238686f, -0.03732441f, 0.01583944f, -0.00102586f, 0.03752719f, 
    -0.51329702f, 0.22587401f, 0.00187637f, -0.08181933f, -0.00589448f, -0.04500110f, -0.06846987f, -0.03312923f, 
    0.07751204f, -0.06647328f, 0.04608648f, -0.00742128f, 0.05357064f, 0.00285970f, 0.08024826f, -0.02112322f, 
    -0.05422888f, -0.00236011f, -0.13810983f, -0.03748456f, -0.19397533f, -0.06140892f, 0.05242924f, -0.02792058f, 
    -0.14290413f, 0.03329926f, -0.03236467f, 0.01783081f, -0.04113533f, 0.00453604f, -0.07035106f, -0.03996252f, 
    0.04665812f, -0.05781985f, -0.04318202f, -0.05130769f, -0.07342747f, -0.05657846f, -0.00635835f, -0.00304817f, 
    -0.19167745f, -0.06576272f, -0.03769114f, -0.01420602f, -0.03169935f, -0.04635808f, 0.03379009f, 0.01960403f, 
    -0.01854368f, -0.09665091f, 0.05926837f, -0.03200721f, -0.01921275f, 0.07413439f, 0.02473960f, 0.07629763f, 
    0.00357662f, -0.00822066f, -0.01906515f, 0.06021711f, 0.28815696f, 0.05209073f, -0.10220793f, -0.05677234f, 
    -0.06808964f, -0.02914691f, -0.02210376f, 0.02063792f, 0.05291473f, 0.00408299f, 0.03097741f, 0.02343258f, 
    -0.01488907f, -0.00078439f, 0.00842686f, -0.04113497f, -0.01065549f, -0.01909456f, -0.02994377f, 0.02737889f, 
    -0.02001560f, -0.27186039f, 0.02347219f, -0.09422186f, 0.14116925f, 0.06252600f, -0.12466108f, 0.03765044f, 
    0.10326620f, 0.08486757f, -0.01395052f, -0.02250915f, 0.02090642f, 0.01812619f, -0.04220781f, 0.07106388f, 
    0.03729846f, 0.01110241f, 0.07827138f, -0.10480651f, 0.01760643f, 0.04423297f, -0.09542796f, -0.10082980f, 
    -0.02713745f, 0.02302702f, 0.03191154f, -0.01520108f, 0.01472184f, 0.03926308f, 0.03993506f, 0.04419488f, 
    -0.04183124f, -0.03894160f, -0.05521087f, -0.01420532f, 0.07588883f, 0.04603992f, -0.00860393f, 0.01491324f, 
    -0.17164917f, 0.13763323f, 0.00236884f, -0.02050228f, 0.03107112f, 0.04108715f, -0.01513006f, 0.01027226f, 
    -0.01334341f, -0.09178209f, -0.03931929f, -0.01284622f, -0.06198014f, -0.05313516f, -0.03893413f, -0.09488916f, 
    -0.00823811f, 0.01392163f, -0.05922416f, -0.06938137f, -0.03473699f, -0.14619717f, -0.00067874f, 0.13938744f, 
    0.05738203f, -0.07641932f, 0.14089546f, -0.00685160f, -0.01791418f, -0.05910305f, 0.03031090f, -0.08168274f, 
    -0.01202359f, 0.01619398f, 0.01001290f, 0.00856683f, -0.04903825f, 0.05440031f, -0.00572624f, -0.04852152f, 
    -0.12655987f, 0.06753166f, -0.10928994f, -0.12577049f, 0.24162108f, 0.01658062f, -0.10318121f, -0.05458544f, 
    0.03747229f, -0.02844429f, -0.00094152f, 0.01834884f, 0.02306170f, -0.04331241f, 0.03741448f, 0.10553201f, 
    0.04566234f, -0.01159130f, 0.04933538f, -0.13997370f, -0.07349094f, -0.13425195f, -0.02518321f, -0.07627131f, 
    -0.05685167f, -0.04870494f, 0.05950094f, -0.03940198f, 0.03233609f, 0.02836717f, 0.02019987f, -0.02400760f, 
    0.01708268f, -0.04169261f, 0.01984958f, -0.01501045f, -0.00987165f, -0.04577419f, -0.01335561f, -0.03169803f, 
    0.20277028f, -0.05912459f, -0.08086281f, 0.01580229f, 0.14136215f, -0.12069716f, 0.06467697f, -0.05935121f, 
    0.00460935f, -0.06833830f, 0.00623449f, -0.02944174f, -0.04162050f, 0.05262718f, -0.03403857f, 0.04299860f, 
    0.03079527f, -0.02887153f, 0.06876161f, 0.05871284f, 0.45383072f, -0.01114032f, -0.20126723f, -0.03934061f, 
    -0.15213896f, -0.10364238f, -0.04335316f, 0.05133015f, -0.01498150f, 0.00503495f, 0.07716805f, -0.00521134f, 
    0.01974477f, -0.00521041f, -0.00028080f, -0.01411326f, -0.06912559f, 0.01895699f, 0.00253017f, 0.02618878f, 
    -0.14636743f, -0.18168285f, -0.08173738f, -0.02184452f, -0.10097197f, -0.02920477f, 0.05147685f, 0.01707483f, 
    0.04240426f, 0.01667550f, -0.05934120f, 0.06639982f, -0.01900327f, -0.00695965f, -0.06674738f, -0.02573104f, 
    0.01222098f, -0.05592991f, -0.16239613f, -0.09689166f, -0.26641807f, 0.14024734f, -0.01516153f, -0.05440905f, 
    0.04652967f, 0.06392816f, -0.01384008f, 0.03832421f, 0.03963488f, 0.06616415f, 0.01707013f, -0.00565331f, 
    -0.04803061f, 0.05557800f, 0.00090403f, -0.00475389f, 0.06771065f, 0.01434133f, -0.04303874f, -0.02730231f, 
    -0.15848142f, 0.14436595f, -0.01362889f, -0.02627971f, 0.09658263f, -0.01087468f, -0.07161222f, -0.03040169f, 
    -0.04457883f, -0.04460452f, -0.00092691f, -0.00702644f, -0.03020918f, -0.00018182f, -0.05114802f, 0.02920519f, 
    -0.01512324f, 0.01399755f, 0.06446475f, 0.07429215f, 0.15186068f, -0.08527096f, 0.09310249f, 0.06591859f, 
    0.12797557f, 0.08686996f, -0.01229265f, -0.02775125f, 0.02487551f, 0.01711239f, 0.05545857f, 0.10529254f, 
    0.04993112f, 0.04702467f, 0.00631010f, -0.01539272f, -0.07095356f, -0.00009344f, -0.04090321f, 0.01826904f, 
    0.11618377f, -0.00553609f, 0.04732905f, -0.03651423f, -0.01633590f, -0.05376670f, -0.02491280f, 0.04685011f, 
    -0.05140395f, -0.07552373f, -0.03251700f, -0.04439930f, 0.04078304f, -0.01031838f, -0.07606325f, -0.01917913f, 
    -0.02885379f, -0.00489877f, -0.00732862f, -0.01982760f, 0.04574008f, -0.18646491f, 0.01038229f, 0.05809706f, 
    -0.13424747f, -0.03931783f, 0.02160481f, 0.10553025f, -0.02360871f, 0.08367030f, -0.05596690f, 0.05245253f, 
    -0.05170363f, 0.00845265f, -0.04894760f, -0.11367787f, 0.05513153f, -0.01741827f, -0.04241382f, -0.04927614f, 
    -0.43908563f, 0.29529876f, -0.06996556f, 0.10797799f, -0.15155192f, 0.13499886f, -0.00094153f, 0.05000234f, 
    -0.02504728f, 0.05237483f, 0.03017935f, 0.09011842f, -0.03303185f, -0.00419192f, 0.02550737f, -0.03979173f, 
    0.10778800f, -0.11610083f, -0.01038053f, -0.00401971f, -0.03580052f, -0.04757281f, -0.00393759f, 0.05041415f, 
    -0.00275025f, -0.04762012f, 0.02605950f, 0.08822558f, -0.00595371f, 0.05244853f, -0.07257465f, -0.03458363f, 
    -0.03850048f, 0.01051174f, -0.00008731f, -0.02841615f, -0.04331955f, 0.05118163f, -0.04941141f, -0.03349683f, 
    -0.08581897f, -0.22704141f, 0.05135358f, -0.06675703f, -0.10788969f, -0.00729152f, 0.05840363f, 0.01152611f, 
    -0.02254677f, 0.03805333f, -0.13120192f, -0.09850583f, 0.02989513f, 0.03051436f, -0.11375884f, -0.13408913f, 
    -0.06562508f, -0.03841508f, -0.11165413f, -0.04482067f, 0.04966115f, -0.05642116f, -0.05815293f, 0.04967549f, 
    0.01311763f, 0.03453549f, 0.00825644f, 0.00488061f, -0.03239697f, -0.03014243f, 0.00323562f, -0.02462628f, 
    -0.00527974f, -0.02219764f, -0.04919303f, -0.02768454f, -0.01336160f, -0.02818770f, -0.10176786f, 0.00907206f, 
    0.02266023f, 0.03579933f, 0.00110989f, -0.01313431f, 0.06104204f, 0.03343664f, -0.04042509f, -0.05800989f, 
    -0.01590859f, -0.09518974f, -0.02204359f, -0.01607097f, 0.01647568f, 0.01460732f, -0.09404686f, -0.03617462f, 
    -0.04830083f, 0.01396345f, -0.07452159f, -0.10078456f, 0.25530848f, 0.08237472f, -0.06988048f, -0.04134051f, 
    -0.03219176f, -0.02113208f, 0.00011111f, -0.03102171f, -0.01341235f, -0.07155377f, 0.01511961f, 0.03493509f, 
    0.02458608f, 0.00912634f, -0.02552764f, -0.01331929f, -0.02408617f, 0.07948899f, 0.00201151f, -0.00264539f, 
    0.00035554f, 0.04863108f, -0.04607889f, -0.00453612f, -0.31734115f, -0.10275371f, 0.04231637f, -0.01154916f, 
    0.06135870f, -0.00930880f, -0.05440615f, -0.03169346f, 0.03467890f, -0.02002965f, 0.09994755f, 0.03012440f, 
    0.03410793f, -0.00579485f, 0.00186663f, -0.03971603f, -0.18316489f, 0.04640923f, -0.04044929f, 0.06750970f, 
    -0.20588633f, 0.17366257f, 0.06016266f, 0.01154327f, -0.01776613f, 0.02364568f, 0.02785593f, -0.04563905f, 
    0.04433012f, 0.01354221f, -0.01559044f, -0.02481887f, 0.04566762f, -0.06632090f, -0.08122431f, 0.03967521f, 
    -0.07641751f, 0.16271113f, 0.06270886f, -0.03946788f, 0.00155159f, -0.04200144f, -0.08725794f, -0.09101808f, 
    -0.04415738f, -0.12148332f, -0.03792593f, -0.01923085f, 0.04200772f, -0.07835482f, -0.00728573f, 0.03416375f, 
    -0.02574545f, -0.00808558f, 0.08040190f, 0.01162004f, 0.06771532f, 0.04483676f, -0.01119751f, 0.07067479f, 
    -0.01388319f, -0.04199061f, 0.06793196f, -0.03044392f, 0.04095558f, 0.03424352f, -0.00439498f, -0.05522089f, 
    -0.01238217f, 0.04556156f, 0.02023387f, 0.04455938f, -0.02299676f, -0.03605977f, 0.00472447f, -0.00605067f, 
    0.00175146f, 0.07138854f, -0.11567215f, -0.08437108f, 0.05509792f, -0.02139565f, -0.10753607f, 0.02394349f, 
    0.02218623f, 0.00476017f, 0.05411907f, -0.02996503f, -0.00409795f, -0.03006706f, 0.04336338f, 0.04336451f, 
    -0.07117913f, 0.03104939f, 0.10126591f, -0.02712347f, -0.29319057f, -0.31476668f, -0.14699404f, -0.14453039f, 
    -0.12966515f, 0.03361972f, 0.00626977f, 0.03284893f, 0.00776025f, 0.12270845f, -0.03813651f, -0.02256256f, 
    -0.05245016f, -0.05366768f, 0.00365497f, -0.03155224f, -0.00863724f, -0.05077061f, -0.07385392f, -0.06714281f, 
    0.04263597f, 0.08931468f, -0.10282885f, -0.06968901f, -0.01863553f, -0.03583977f, -0.06688577f, -0.02382019f, 
    -0.09532366f, -0.02459439f, 0.07603614f, 0.05254421f, 0.04798396f, 0.00308164f, -0.01697999f, 0.02928491f, 
    0.00839409f, 0.02627196f, 0.02581995f, -0.03364659f, 0.21618336f, -0.13453650f, -0.04685671f, -0.06099474f, 
    0.00259175f, -0.02318682f, -0.00185317f, -0.00933324f, -0.00867975f, -0.03294930f, 0.03801545f, -0.00718551f, 
    -0.02781493f, 0.06293657f, -0.01567506f, 0.06427894f, 0.01402269f, -0.04544842f, 0.02442370f, -0.01415791f, 
    0.20071711f, -0.24281101f, 0.01684408f, 0.02150517f, 0.00590026f, 0.07016912f, 0.01283619f, -0.08877955f, 
    0.08267615f, 0.01455127f, 0.00068774f, 0.05585064f, 0.03962805f, -0.03821037f, 0.01281518f, -0.01924049f, 
    -0.04475880f, -0.04178365f, 0.00406507f, 0.04871253f, 0.07103723f, -0.12795487f, 0.01830845f, -0.01428233f, 
    0.01960679f, -0.01831443f, 0.00055301f, -0.02962624f, 0.00091097f, 0.04623750f, -0.04444301f, 0.01307898f, 
    -0.01785723f, -0.06013755f, 0.01038425f, 0.03076669f, -0.10928495f, 0.02857193f, 0.05358598f, 0.01585090f, 
    -0.39281780f, 0.28819218f, 0.05636331f, -0.10309206f, 0.26337954f, 0.22814251f, -0.10955054f, 0.00912214f, 
    0.03736898f, 0.05935497f, -0.02259578f, 0.10408574f, 0.08766429f, -0.03925505f, -0.02698825f, -0.08361830f, 
    0.10723423f, 0.00256316f, -0.15180124f, -0.03031573f, -0.00595993f, -0.18588822f, -0.01679335f, 0.07966216f, 
    -0.07182443f, -0.07667177f, 0.05780715f, -0.05213216f, -0.00175586f, -0.02603103f, 0.13583687f, -0.11475874f, 
    0.02938699f, 0.03789207f, -0.01537315f, -0.00834333f, 0.01081691f, -0.10031964f, 0.04712577f, 0.07153147f, 
    -0.33642030f, -0.25946838f, 0.02477860f, -0.03805956f, 0.04235134f, -0.05372138f, 0.07561471f, -0.00805766f, 
    0.03964673f, -0.01784077f, -0.03682151f, 0.05033584f, 0.05364174f, 0.00757025f, 0.01397280f, -0.04909017f, 
    0.03589975f, -0.00635842f, -0.03635170f, -0.05514337f, 0.03451765f, 0.04357225f, -0.04765419f, -0.04423638f, 
    -0.03534961f, 0.06943133f, 0.05875600f, -0.02703971f, 0.05822887f, -0.01441933f, 0.04560144f, 0.04767735f, 
    -0.02801869f, -0.05995508f, 0.06944876f, -0.02924044f, 0.00356938f, -0.02448907f, -0.05891992f, 0.07257812f, 
    0.33112022f, -0.08929715f, -0.13075171f, -0.05213835f, -0.15796810f, -0.03340427f, 0.02165584f, -0.00076541f, 
    -0.00689936f, 0.04216281f, 0.04358268f, 0.00353825f, 0.02004279f, 0.03515211f, 0.05274190f, 0.00783870f, 
    -0.06668101f, 0.01137824f, -0.00926389f, -0.01597052f, 0.03380180f, 0.09189432f, -0.04781555f, -0.09736644f, 
    0.01291010f, -0.01571780f, -0.07561199f, 0.05801271f, -0.10336156f, -0.08884177f, 0.07800423f, -0.01990205f, 
    0.01309414f, 0.01194142f, 0.01182808f, -0.00531565f, 0.02178285f, -0.00315699f, -0.02292906f, -0.04459507f, 
    0.15580328f, 0.03158233f, 0.01050626f, -0.07387076f, -0.01265519f, -0.04296448f, -0.02309705f, -0.00351790f, 
    -0.09966092f, -0.20253137f, -0.00860680f, -0.03038341f, 0.07049024f, 0.03450148f, -0.00905189f, 0.01495363f, 
    -0.05226008f, -0.02177171f, -0.01444631f, 0.00198952f, -0.34786713f, -0.03668823f, -0.00992307f, 0.01934104f, 
    -0.13410160f, -0.03116316f, 0.02810142f, -0.11518493f, 0.06859197f, 0.03395712f, -0.15463550f, -0.03320904f, 
    -0.03225636f, -0.07362917f, 0.05962479f, -0.06289997f, 0.07697130f, 0.03643431f, -0.05174352f, -0.04890377f, 
    0.05037226f, 0.06149412f, -0.04075438f, 0.00538739f, 0.18201341f, -0.03522600f, -0.03053835f, -0.01842395f, 
    0.08878107f, 0.01034780f, 0.03745328f, -0.00030946f, -0.06086789f, 0.06362145f, 0.03657233f, 0.07768370f, 
    -0.04549271f, -0.02398329f, 0.07692034f, 0.03820148f, 0.09327387f, -0.03215624f, 0.03714895f, 0.01477133f, 
    0.00703322f, -0.04862094f, 0.04244059f, 0.09186515f, -0.06504010f, -0.04931659f, -0.13007072f, -0.01263381f, 
    0.03488433f, 0.00930693f, -0.00925400f, -0.00236954f, -0.01271387f, 0.08925346f, -0.15582556f, 0.00635140f, 
    0.08103774f, -0.09903995f, -0.03147666f, 0.01360502f, 0.08596247f, -0.10586902f, 0.02916428f, 0.04477083f, 
    0.06442381f, -0.04150069f, 0.04216554f, -0.08820175f, -0.06307366f, -0.02020586f, 0.05019047f, 0.01745527f, 
    -0.07281967f, -0.00900654f, 0.08499901f, 0.03964790f, -0.03006304f, 0.04727826f, 0.03016039f, -0.07076298f, 
    -0.01966880f, 0.04836697f, -0.00720122f, 0.05944033f, 0.01427350f, -0.07679875f, -0.08144210f, -0.04844676f, 
    0.04172353f, -0.07681384f, -0.05686953f, -0.01929483f, -0.04725230f, 0.02778552f, -0.06305753f, -0.06549045f, 
    -0.02619497f, -0.05306056f, -0.08121382f, 0.05523326f, -0.20897922f, 0.01145510f, 0.03562480f, 0.00456165f, 
    0.00868006f, 0.02423486f, -0.05711671f, -0.01609327f, 0.03051678f, 0.07341080f, -0.00879297f, -0.01118876f, 
    -0.01487391f, 0.02969468f, -0.09881189f, -0.11357082f, -0.06178789f, -0.07324915f, 0.03347315f, 0.00150214f, 
    0.17199992f, -0.14203785f, 0.00070686f, 0.02681060f, 0.03740591f, -0.09148045f, 0.00375821f, -0.08511637f, 
    -0.05615223f, 0.02644276f, 0.02887622f, 0.04476537f, 0.03404111f, -0.02474793f, 0.04200253f, 0.12517852f, 
    0.25068051f, 0.02120306f, -0.10538048f, -0.00568881f, 0.08651540f, -0.03770693f, 0.04073025f, 0.01398400f, 
    0.04353924f, 0.06859545f, 0.04717474f, 0.00232881f, -0.00848772f, -0.02365202f, 0.07351153f, 0.02425228f, 
    0.00492044f, -0.01774699f, 0.00132248f, -0.02799311f, 0.22138433f, 0.21225558f, -0.12520736f, -0.00225906f, 
    0.02749832f, 0.00434832f, 0.05435193f, -0.07100931f, -0.00216415f, -0.02182867f, 0.03984415f, 0.05650004f, 
    -0.03436249f, 0.04742887f, 0.04223498f, -0.02713046f, 0.02959830f, 0.08332489f, -0.00669052f, 0.06100931f, 
    0.19148241f, 0.01053817f, -0.13479564f, -0.03610460f, 0.23230959f, 0.05363073f, -0.05979688f, -0.00754499f, 
    0.06142494f, -0.01004670f, 0.02733860f, -0.01218913f, 0.03740574f, -0.01915832f, 0.05526618f, 0.03962886f, 
    -0.03921309f, -0.00209468f, 0.01767934f, 0.07833334f, -0.11329557f, 0.16780229f, -0.03008270f, -0.14670755f, 
    -0.02123464f, -0.01238546f, -0.06742621f, -0.03417451f, -0.11263961f, -0.06886616f, 0.03411754f, 0.01671407f, 
    0.01945570f, -0.07328518f, 0.00371065f, 0.04835347f, -0.03771682f, -0.00532245f, 0.02043978f, -0.01513170f, 
    -0.01374817f, 0.23409685f, 0.00860793f, -0.01048160f, 0.03429404f, 0.14418475f, 0.05255383f, -0.10213362f, 
    -0.02290911f, -0.01018777f, 0.05486920f, -0.01958653f, 0.01336137f, -0.05191383f, 0.05516841f, 0.05572573f, 
    0.00976823f, 0.04357126f, 0.05201421f, 0.08043019f, 0.08919751f, 0.27865371f, -0.14077182f, -0.20313598f, 
    0.09893073f, 0.12456424f, 0.00870504f, -0.00557677f, 0.08489455f, 0.01341745f, 0.04311167f, 0.02411915f, 
    -0.02473719f, -0.01199134f, 0.06171892f, 0.01024805f, 0.02785162f, 0.03227787f, -0.01248957f, 0.05144033f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.02503172f, 0.05223726f, -0.05516043f, -0.01173328f, 0.02892535f, -0.01032990f, -0.01626692f, -0.06054607f, 
    -0.03325499f, -0.00243752f, 0.05063540f, -0.00431842f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 5120);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
