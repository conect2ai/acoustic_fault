#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.62162548f, -0.79088926f, -0.03882270f, 1.08698511f, 0.20680471f, -0.61904681f, -0.89917117f, -0.57362241f, 
    -0.09393741f, -0.55154651f, 0.67936599f, -0.57903242f, -0.00148902f, 0.08049811f, -0.23205718f, 0.05038609f, 
    -0.01718200f, 0.30862489f, -0.06062818f, 0.10472877f, -0.08995668f, 0.13336672f, -0.02376116f, 0.07431630f, 
    0.22544593f, -0.88539594f, -0.00498823f, 0.67365324f, -0.40268534f, -0.18842730f, -0.45997134f, -0.44641909f, 
    0.00009435f, 0.36946818f, 0.12566639f, 0.48020989f, 0.08308253f, 0.26863429f, 0.08360011f, -0.06766565f, 
    -0.27522060f, -0.34642538f, 0.02296936f, -0.47606421f, -0.27003422f, -0.09728035f, 0.20726854f, 0.38433301f, 
    -0.06355373f, 0.30616590f, 0.31180108f, 0.11579631f, 0.11918118f, 0.31936520f, 0.09021394f, 0.17589952f, 
    -0.01954398f, -0.06404370f, 0.00916106f, 0.20084420f, 0.11539242f, 0.28579184f, -0.04029712f, -0.10313514f, 
    0.11154503f, -0.02632088f, -0.00673719f, -0.27799025f, 0.21987255f, 0.01047252f, 0.06572119f, 0.48001388f, 
    0.20805043f, -0.27922392f, -0.00119232f, 0.42345312f, 0.80727291f, 0.35250938f, -0.19616739f, -0.32440060f, 
    0.32114756f, 0.28094184f, -0.18740924f, -0.00003420f, 0.21885322f, 0.09846682f, 0.13975552f, 0.02823877f, 
    -0.63114184f, -0.34943303f, -0.18224791f, -0.27401721f, 0.07470903f, -0.00148790f, -0.02106311f, 0.12369335f, 
    0.47361809f, 0.25802436f, -0.47760841f, -0.11172747f, 0.04965994f, 0.66971987f, 0.28101841f, -0.63567066f, 
    -0.42853156f, -0.30981666f, -0.18158789f, 0.39976758f, -0.10567170f, 0.08291993f, -0.32999188f, -0.41148549f, 
    1.07334244f, -0.58560765f, -0.19145355f, 0.08648400f, 0.05623088f, -0.36860999f, 0.15451373f, 0.09789319f, 
    -0.05206505f, 0.02251946f, -0.23203692f, -0.07442901f, 0.17349973f, 0.56045222f, 0.38174060f, 0.24849749f, 
    0.30939060f, -0.94810045f, 0.01418381f, -0.56819737f, 0.02714903f, 0.62223959f, -0.19277650f, 0.06205726f, 
    -0.01141171f, -0.16590923f, -0.34864163f, -0.46625960f, 0.05629728f, 0.39032957f, 0.06014867f, -0.25929227f, 
    0.17911272f, -0.21775636f, -0.23793890f, -0.06672147f, -0.09017716f, 0.12586108f, -0.91499877f, -0.56899530f, 
    -0.52478540f, -0.29933548f, -0.06198776f, 0.83180189f, 0.61883724f, 0.22022767f, 0.28437033f, 0.53388458f, 
    0.15922938f, 0.08859637f, -0.05933130f, 0.21606109f, -0.43404421f, -0.20263837f, 0.19165754f, -0.20769738f, 
    -0.24296013f, 0.06318611f, -0.03212255f, -0.10055926f, 0.11171378f, 0.17313910f, -0.20841627f, 0.40867737f, 
    0.83606118f, 0.26699111f, -0.41501728f, -0.52706367f, -0.49745885f, -0.57180351f, -0.23461497f, -0.28504050f, 
    -0.42079011f, -0.01633816f, -0.06153025f, -0.31809464f, -0.10130297f, 0.46836159f, 0.11894292f, 0.30942231f, 
    0.43897828f, 0.37988681f, 0.03927908f, -0.07216389f, -0.09428961f, -0.35606459f, -0.45985851f, -0.34581169f, 
    0.55446452f, 0.41438118f, 0.63283777f, -0.09925112f, -0.17545083f, -0.32314807f, 0.25097734f, 0.02247470f, 
    -0.28670570f, -0.23095447f, 0.18651932f, -0.04769666f, 0.16120045f, 0.18220185f, -0.28261647f, 0.18091568f, 
    -0.26912919f, -0.09071794f, 0.06803787f, 0.14517269f, -0.02725205f, 0.12818350f, -0.11769398f, 0.03815902f, 
    0.28350589f, 0.77586037f, 0.09302472f, -0.30450931f, -0.01218006f, -0.83941156f, 0.65949994f, -0.32835117f, 
    0.12997545f, 0.43930039f, -0.47121474f, -0.24296100f, -0.24614443f, -0.04219393f, 0.07939679f, -0.39739791f, 
    0.00507923f, -0.11127041f, 0.13157119f, 0.25314391f, 0.05401254f, -0.19723041f, 0.00110570f, 0.07181072f, 
    -0.03487945f, 0.05612782f, -1.09750879f, -0.07304203f, -0.08157067f, 0.34880897f, -0.02294482f, -0.45891652f, 
    -0.31323984f, 0.46978027f, 0.51555955f, -0.53936166f, -0.48770985f, -0.40495056f, 0.19413014f, 0.03274276f, 
    0.15594342f, 0.29042611f, -0.24747238f, -0.32325375f, -0.25934806f, -0.59474671f, -0.43191040f, -0.20464608f, 
    -0.30067787f, -0.58130586f, -0.30850625f, -0.37058446f, -0.59357458f, 0.08517388f, 0.41617256f, -0.72473967f, 
    -0.63909429f, -0.41558689f, -0.41918615f, -0.33966717f, -0.44907346f, 0.06456383f, -0.35467464f, -0.02758932f, 
    -0.10951951f, -0.30311543f, 0.01992346f, -0.33377844f, 0.03109342f, -0.32923964f, -0.27076319f, 0.08284578f, 
    -0.25072670f, -0.27648798f, -0.11655396f, 0.44351885f, -0.75530243f, -0.74473417f, -0.83718246f, -1.05381811f, 
    -0.43836403f, 0.91338933f, 0.11916162f, -0.66578239f, -0.39196399f, 0.40462962f, -0.31701553f, -0.57436895f, 
    -0.27481979f, 0.32383728f, 0.45024231f, 0.01845702f, 0.19291915f, -0.35008222f, -0.20335615f, -0.25818816f, 
    -0.14346291f, -0.31771439f, 0.11939485f, 0.05013461f, 0.04299391f, 0.81238586f, 0.81212181f, 0.37430483f, 
    0.10878471f, 0.24083768f, -0.68169755f, -0.46769828f, 0.05973936f, -0.42067790f, -0.74507016f, -0.03491022f, 
    -0.05686595f, -0.06309234f, -0.06317183f, -0.16225824f, -0.01224122f, -0.16146533f, 0.14265811f, -0.00765488f, 
    0.07754640f, -0.01575168f, -0.18756333f, -0.24488562f, 0.26625726f, -0.09547311f, -0.62958306f, -0.19613898f, 
    -0.21018422f, -0.93427020f, -0.87297559f, 0.64056259f, 0.19770512f, 0.21625035f, 0.25200039f, 0.73442525f, 
    0.06301035f, -0.19035900f, 0.22151442f, -0.21664385f, 0.16515444f, -0.25528693f, -0.13549602f, 0.17588116f, 
    0.00492833f, 0.23772834f, 0.02894268f, -0.01390854f, 0.33673099f, -0.13230152f, 0.07003485f, -0.03825832f, 
    -0.46128225f, 0.13586953f, 0.33400202f, 0.06927194f, -0.76630700f, -0.67582065f, 0.57439321f, 0.36854586f, 
    0.21372946f, 0.04919858f, -0.25594518f, -0.44905430f, 0.11101336f, 0.60529423f, -0.41275707f, 0.33027568f, 
    -0.05449820f, -0.29775047f, 0.21875641f, -0.07740151f, -0.15934712f, 0.06258507f, 0.19974427f, 0.25924700f, 
    0.73761064f, -0.80602598f, -0.14289995f, 0.31062713f, 0.12710364f, 0.64785188f, 0.80889136f, -0.23080187f, 
    -0.61483908f, -0.43818593f, 0.00850734f, -0.01371615f, 0.03812096f, -0.34582546f, -0.09601815f, -0.25027362f, 
    -0.40292686f, -0.01464712f, 0.35034177f, 0.08920559f, 0.31534749f, -0.24729985f, -0.38036606f, 0.24203728f, 
    -0.34190807f, -1.44787025f, -1.02431476f, 0.00353953f, 0.65478480f, 0.45578784f, -0.05080274f, 0.23084365f, 
    0.79696172f, -0.11413712f, -0.36121562f, -0.21360211f, 0.02417310f, -0.09070756f, 0.75354195f, -0.28654379f, 
    -0.03661728f, 0.06013909f, -0.35482088f, -0.00792200f, 0.26911017f, 0.16253492f, -0.17215991f, 0.22647738f, 
    0.19311257f, -0.17125726f, 0.24382795f, 0.80041587f, -0.41935834f, 0.19634624f, -0.77871144f, -1.25100982f, 
    -0.69198632f, -0.16015288f, -0.50658005f, -0.71424496f, 0.14703849f, -0.21291585f, 0.41401973f, 0.24751455f, 
    0.04633465f, 0.23062330f, 0.23242828f, -0.04797805f, -0.15988454f, -0.53490043f, -0.02024241f, -0.02824622f, 
    0.03899584f, -0.18408868f, 0.15690061f, -0.10511813f, -0.60455722f, -1.05004287f, -0.50634331f, 0.71426427f, 
    0.25218186f, 0.35993269f, -0.59671283f, -0.82014507f, -0.89423329f, 0.22705707f, 0.37713498f, 0.02152801f, 
    -0.18793577f, -0.01136679f, -0.46579018f, -0.70104593f, -0.01340369f, -0.52602834f, -0.26907933f, 0.37354887f, 
    -0.05789788f, -0.44023761f, 0.20286566f, -0.31382188f, -0.21186124f, -0.21163109f, -0.54596710f, -0.74267000f, 
    -0.66002870f, 0.36734989f, 0.45957780f, 0.45505890f, -0.46042258f, 0.34033602f, 0.38329691f, 0.49181771f, 
    0.07473891f, 0.23108533f, -0.34581050f, -0.46529979f, 0.07723998f, -0.37302783f, -0.33593678f, 0.03745951f, 
    0.22038451f, 0.01662206f, -0.12748970f, 0.37760592f, 0.11309385f, 0.36873490f, 0.27678913f, -0.05455409f, 
    -0.26461703f, -0.10665448f, 0.79501450f, 0.03038666f, -0.22454804f, -0.00971460f, -0.05434503f, 0.15615970f, 
    -0.38089406f, 0.06693432f, -0.01624277f, -0.00295091f, 0.25704217f, 0.00096627f, -0.05968713f, -0.07825915f, 
    -0.15159272f, -0.55841911f, -0.02656198f, 0.47506535f, 0.30395123f, -0.21249357f, -0.79261273f, -0.38433328f, 
    -0.73510522f, -0.46643361f, 0.00435077f, -0.37942705f, -0.25882286f, 0.02090188f, 0.34651518f, 0.53252858f, 
    -0.31379798f, -0.10909049f, -0.51859808f, -0.53769648f, 0.37692803f, 0.39832228f, -0.12845948f, -0.12845939f, 
    -0.16253440f, 0.22695799f, -0.24424471f, -0.50581747f, -0.29973543f, -0.50823617f, -0.20047046f, -0.32127905f, 
    0.41576159f, 0.47330323f, 0.16145602f, 0.01549852f, 0.23090537f, -0.53292352f, -0.02409435f, 0.16707855f, 
    0.03471645f, -0.23170698f, -0.34302253f, -0.26161158f, 0.36724350f, 0.09607351f, 0.46823618f, 0.32447082f, 
    -0.42156902f, 0.09343586f, -0.26579502f, -0.22080827f, -0.08999445f, -0.20662716f, -0.01613606f, -0.24080087f, 
    0.06830005f, 0.28117883f, -0.49818611f, -0.04663688f, -0.62247247f, -0.58268410f, 0.26183447f, -0.68002290f, 
    -0.65939260f, -0.80587715f, 0.38857719f, -0.09276878f, 0.09418178f, -0.02904955f, 0.19782649f, 0.07570683f, 
    -0.06122511f, 0.26234317f, 0.27420461f, 0.00683935f, -0.42578366f, -0.17047285f, 0.23379146f, 0.19347037f, 
    0.06553810f, 0.71838880f, 0.29324001f, 0.42262033f, -0.29286370f, -0.23198077f, -0.64177924f, -0.28938517f, 
    -0.15158977f, 0.12836754f, 0.30014834f, 0.34369230f, -0.05005383f, 0.49467105f, 0.17209633f, -0.23974869f, 
    -0.11404806f, 0.27169207f, -0.15924945f, -0.28849995f, -0.53210378f, -0.13356869f, 0.25625807f, 0.27999002f, 
    0.26081908f, -0.10913239f, -1.02362239f, -0.69987106f, -0.42953986f, -0.83590728f, -0.55896801f, 0.71505088f, 
    -0.36691535f, -0.39397198f, 0.42299700f, -0.01752793f, 0.03336458f, -0.28952643f, -0.48203081f, -0.21249966f, 
    -0.23827356f, -0.30598783f, -0.31574821f, -0.28502187f, -0.08031017f, -0.10005835f, 0.00547665f, 0.43720138f, 
    0.30565721f, -0.01484288f, -0.15444076f, -0.73379064f, -0.97780639f, -0.82096457f, -0.15488519f, -0.25722504f, 
    0.82550418f, -0.15441020f, 0.14437293f, 0.47046891f, 0.19013777f, 0.05541809f, 0.06796612f, -0.00341768f, 
    0.07940605f, -0.37053970f, -0.12999620f, -0.31824797f, -0.02417850f, -0.40406185f, -0.47424293f, -0.49972999f, 
    -0.40172443f, -0.18297362f, -0.49186823f, -0.37722325f, 0.40478101f, -0.48271763f, -0.23045893f, -0.20624200f, 
    -0.13462102f, -0.01764503f, 0.18846108f, 0.30953667f, -0.18760835f, -0.21222420f, 0.02085806f, -0.07451375f, 
    0.55763042f, -0.38908225f, -0.20924300f, -0.22395140f, -0.24912922f, 0.03519357f, -0.02805152f, -0.25425079f, 
    0.18738811f, 0.20582603f, 0.16516864f, 0.26383018f, 0.22531815f, 0.79720062f, 0.57907230f, -0.01786441f, 
    -0.38748544f, -0.49747026f, 0.40038553f, 0.22788034f, -0.26446855f, -0.48879674f, 0.30812687f, 0.18499595f, 
    0.22537802f, -0.40795425f, -0.39384469f, 0.28324169f, 0.21134503f, 0.21555072f, 0.12896116f, -0.24616472f, 
    -0.46659592f, -0.18780352f, 0.13146706f, 0.19301344f, -0.13801897f, 0.08984017f, -0.73807299f, -0.65804935f, 
    -0.91194463f, -0.81743801f, -0.20106415f, -0.18214235f, -0.24137354f, -0.63822603f, -0.82497233f, -0.56509119f, 
    0.41074219f, 0.50662935f, 0.08634589f, -0.19075495f, -0.56685317f, -0.01632636f, 0.03686863f, -0.08963374f, 
    0.04823302f, -0.22184257f, -0.42211491f, -0.24147595f, -0.14456506f, 0.10940424f, -0.43124282f, -1.63762152f, 
    -0.30568957f, 0.44204804f, -0.31325755f, -0.67529315f, 0.52389979f, 0.63893372f, -0.29771057f, -0.32978758f, 
    0.58648318f, -0.06018438f, 0.09404677f, 0.10735383f, 0.11500268f, -0.11961363f, 0.09606629f, 0.05702445f, 
    -0.25976449f, -0.12800716f, 0.27703750f, 0.14979161f, -0.01039851f, 0.28435752f, -0.03041810f, -0.04758203f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.49009359f, 0.14829890f, -0.09877130f, 0.22090890f, 0.25650850f, 0.38367411f, 0.29628170f, -0.11706898f, 
    0.02493405f, 0.16305697f, -0.22728547f, 0.11979516f, -0.17915392f, 0.12516916f, 0.30656701f, 0.62649304f, 
    0.33642292f, 0.30696383f, 0.01758371f, 0.15317300f, 0.40863168f, 0.47395349f, -0.31399420f, 0.40607890f, 
    0.25730526f, 0.20328012f, -0.33207867f, 0.12572233f, 0.34404171f, 0.56183475f, -0.72014350f, 0.43613181f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.33423340f, 0.20340924f, 0.21243501f, -0.59409457f, -0.05087183f, -0.03003187f, -0.03712156f, 0.03122414f, 
    0.02947332f, 0.02817121f, -0.07453583f, 0.05076139f, 0.15150741f, 0.13695805f, 0.27634418f, -0.10737240f, 
    0.01637908f, 0.07025068f, -0.03257312f, -0.15792279f, -0.14169945f, -0.13162941f, -0.06253280f, -0.13759561f, 
    -0.05150399f, -0.01182355f, 0.02442392f, 0.00260741f, 0.03022997f, -0.03376290f, 0.01208330f, 0.07869396f, 
    -0.03568445f, -0.03503492f, 0.05037529f, -0.07306144f, -0.67414910f, -0.94354278f, -0.80156410f, 0.06644735f, 
    0.09745915f, 0.06599977f, 0.12562476f, 0.06577329f, 0.00070592f, 0.02072045f, 0.01887178f, 0.05977983f, 
    -0.66924667f, -0.30780026f, 0.04007740f, -0.05235374f, 0.00535482f, -0.00480430f, -0.10844211f, -0.05543154f, 
    -0.00364253f, -0.02762143f, -0.12652925f, 0.08876108f, -0.56145239f, -0.21169917f, -0.24992353f, -0.27843985f, 
    -0.01098328f, 0.09417191f, -0.05462395f, 0.00241301f, -0.13341838f, 0.01341132f, 0.05139504f, 0.02598653f, 
    0.34684137f, -0.17655119f, -0.20358762f, 0.04695293f, 0.07302623f, 0.09577610f, 0.08204094f, -0.00720271f, 
    0.07462806f, 0.07347172f, -0.19395812f, -0.21758117f, 0.08009516f, 0.14317027f, 0.08720027f, 0.06346412f, 
    0.03892368f, 0.05928566f, 0.03062799f, 0.07579374f, 0.11936173f, 0.05212393f, 0.14349289f, 0.03573211f, 
    -0.01613537f, -0.13437890f, -0.02050003f, 0.09513531f, 0.04131911f, 0.04004493f, -0.05807256f, 0.08086973f, 
    0.01758504f, 0.06203032f, 0.02184472f, -0.06366570f, -0.11386257f, -0.32737148f, -0.26488459f, 0.00807959f, 
    -0.05838164f, 0.04039690f, -0.08756110f, 0.00721756f, 0.00604804f, 0.02880913f, -0.05145302f, -0.02556494f, 
    0.10397524f, 0.03826750f, 0.29108223f, -0.09413074f, -0.07261330f, -0.01594325f, -0.08940493f, 0.03979195f, 
    -0.00397511f, -0.08075429f, 0.06085236f, 0.12184708f, 0.39563483f, 0.25479883f, 0.00294852f, -0.52233016f, 
    0.05315610f, -0.05354499f, 0.22581036f, 0.20975284f, -0.07009026f, -0.17565639f, -0.14105718f, -0.12742837f, 
    0.37226528f, 0.15056080f, -0.15221871f, -0.21860690f, 0.09183534f, 0.20955840f, -0.10608810f, -0.15509227f, 
    -0.07454790f, -0.02283035f, 0.08529196f, 0.08519713f, -0.31871974f, 0.05506510f, -0.09918729f, 0.01105483f, 
    0.05811702f, -0.00326930f, -0.21529606f, -0.07741938f, 0.02613479f, 0.07766917f, 0.01409138f, 0.06255010f, 
    -0.11961850f, -0.27008951f, 0.00804097f, 0.05955693f, 0.12953496f, 0.20420980f, -0.13146928f, -0.17473774f, 
    0.06650124f, -0.11862903f, -0.06405900f, 0.05347959f, -0.34628049f, 0.10289994f, 0.28592891f, -0.67082441f, 
    -0.24312288f, 0.00658943f, -0.14665988f, -0.02444923f, -0.00277775f, -0.10409633f, -0.24739924f, -0.31813660f, 
    0.27088058f, -0.65114516f, -0.22493416f, -0.04340522f, -0.01307544f, -0.18375844f, 0.06735898f, -0.12410952f, 
    -0.10421231f, 0.04673282f, 0.04156860f, 0.17738105f, 0.45011064f, -0.20457330f, 0.14854640f, -0.12466850f, 
    0.17608069f, -0.02787154f, 0.04521901f, 0.01407645f, -0.10544311f, -0.03200361f, -0.10461887f, -0.02921820f, 
    0.27853018f, 0.12218163f, 0.22170281f, -0.22783226f, -0.04873069f, -0.12069454f, 0.08255216f, 0.12508444f, 
    0.02434605f, 0.09174538f, -0.03487539f, -0.02365158f, 0.35412371f, 0.15563293f, -0.65141660f, -0.01261506f, 
    -0.09273132f, -0.11965514f, -0.09948596f, -0.16768339f, -0.21638185f, -0.24011469f, -0.23054193f, -0.26744026f, 
    0.03002917f, -0.06344358f, -0.31181729f, -0.04842966f, 0.00586591f, 0.11942195f, -0.03206162f, 0.00053794f, 
    -0.20528780f, -0.18970065f, -0.07990002f, -0.08148982f, -0.09164760f, -0.54648823f, -0.64846450f, 0.10112499f, 
    -0.02600969f, 0.03842306f, 0.01432241f, -0.02941667f, -0.07878488f, 0.05092993f, -0.28392470f, 0.10606410f, 
    0.22703531f, 0.26437393f, 0.08040825f, -0.17492630f, 0.06704465f, 0.29012549f, 0.23004571f, 0.01115310f, 
    -0.14417595f, 0.05049802f, 0.12868729f, 0.11629619f, -0.32298380f, -0.13244116f, 0.09791851f, 0.02013635f, 
    0.07467783f, -0.01155478f, -0.05794077f, 0.01786237f, -0.00515134f, -0.06654518f, -0.05619820f, -0.16167338f, 
    0.40131587f, 0.02213725f, -0.34391114f, -0.21133707f, 0.01601896f, -0.07900582f, -0.00498874f, -0.08389373f, 
    0.06263501f, 0.04858723f, -0.03093343f, 0.04968718f, -0.22188412f, -0.56034356f, -0.21831249f, -0.26079044f, 
    -0.12485428f, 0.15105599f, -0.03857114f, -0.13097787f, -0.06067814f, 0.01236057f, -0.13938874f, 0.06068416f, 
    0.40252540f, 0.14357522f, 0.15436746f, -0.21154986f, 0.08076017f, 0.37001291f, 0.01168819f, 0.15197454f, 
    0.00211389f, -0.00430333f, -0.11513581f, 0.06250456f, 0.20885046f, -0.03643385f, -0.03872279f, -0.20923577f, 
    0.13632010f, 0.10314570f, 0.13079938f, -0.16376014f, 0.11607525f, 0.07313166f, 0.03715307f, 0.15953736f, 
    -0.04166251f, -0.01218771f, -0.22215194f, 0.06330052f, -0.03006968f, -0.01813923f, -0.08560503f, -0.01553778f, 
    -0.00557648f, -0.15152545f, -0.17798933f, -0.06052317f, -0.12293447f, -0.40907466f, -0.64803094f, 0.23190552f, 
    -0.02421892f, 0.05987943f, -0.01360507f, -0.02647099f, -0.18399958f, 0.12101981f, 0.00998116f, 0.00498840f, 
    0.47354305f, 0.32224211f, -0.23705187f, -0.09705257f, 0.17749189f, 0.21373576f, 0.25820929f, 0.08199520f, 
    -0.03924729f, -0.05720172f, 0.01585266f, 0.05434740f, 0.21799789f, -0.06596241f, -0.09327658f, -0.29783425f, 
    -0.02307979f, 0.21039593f, 0.01896749f, 0.11351953f, -0.08940471f, -0.02912018f, -0.01954049f, 0.00043675f, 
    -0.37510377f, 0.23874331f, -0.23861235f, -0.27344278f, 0.00878298f, -0.22044830f, 0.22308372f, -0.03790343f, 
    -0.01293653f, 0.00873813f, -0.05052593f, 0.03938209f, -0.38515502f, -0.11788020f, -0.29273924f, -0.11595576f, 
    0.01460564f, 0.14257054f, -0.16946283f, 0.21685667f, -0.02014297f, 0.05803647f, -0.02149843f, 0.04223159f, 
    0.17043938f, -0.00702333f, -0.02994872f, 0.05309577f, 0.01269918f, 0.11961281f, -0.01446118f, 0.07801723f, 
    -0.11456601f, 0.07005586f, -0.04715635f, 0.03054787f, 0.41667396f, 0.18682908f, 0.26395875f, 0.13596658f, 
    -0.02189814f, 0.04209836f, -0.02710583f, 0.08651595f, -0.12401672f, -0.00390930f, -0.04816898f, -0.02277519f, 
    0.23112608f, -0.21318206f, 0.02681909f, -0.02411526f, -0.01470116f, 0.07195632f, 0.03474694f, -0.15435979f, 
    -0.01118781f, -0.08503098f, -0.10189221f, -0.08104193f, 0.22153221f, 0.09422769f, 0.29624715f, -0.37479231f, 
    -0.05050385f, 0.00823572f, -0.02625451f, -0.05203213f, 0.05807689f, -0.11650831f, -0.09554195f, 0.11478531f, 
    0.48316029f, -0.10109758f, -0.36940074f, -0.15092239f, -0.08118115f, -0.02181186f, 0.09554642f, 0.00175869f, 
    0.07405795f, 0.07093669f, -0.01255129f, 0.13139306f, -0.02372224f, -0.10258538f, 0.13325953f, -0.51695132f, 
    -0.05078956f, -0.02365512f, -0.15638442f, -0.05367393f, -0.13158873f, -0.02682666f, -0.07273497f, -0.08140212f, 
    0.18806253f, -0.02619352f, 0.10296332f, -0.03954548f, -0.15076247f, -0.00856990f, -0.03253332f, -0.01146274f, 
    -0.00131626f, 0.00745481f, 0.07327226f, 0.03285030f, 0.66500020f, 0.06803805f, -0.29311785f, -0.06869201f, 
    -0.12485933f, -0.15412654f, -0.09201910f, -0.02614122f, -0.06334358f, 0.01439401f, 0.04639558f, -0.27081576f, 
    -0.57699984f, -0.13506509f, -0.11776428f, 0.00222149f, 0.06086843f, 0.01578532f, -0.01486436f, -0.12382910f, 
    -0.19182217f, -0.04330983f, -0.21246867f, -0.54502124f, -0.22227156f, 0.01498852f, 0.06831308f, -0.30935496f, 
    0.12835850f, 0.06077328f, -0.13253084f, -0.08593926f, 0.04766441f, 0.07267168f, 0.02478395f, 0.01298963f, 
    0.43324065f, 0.10777915f, 0.48955640f, 0.01056683f, 0.24332219f, -0.14848964f, -0.16923459f, -0.09405530f, 
    0.07647928f, 0.03997884f, 0.17658709f, -0.40021458f, 0.15013449f, 0.16455650f, 0.17313242f, 0.05618159f, 
    -0.08379907f, -0.07337657f, 0.07593091f, -0.16758461f, -0.01306533f, -0.01972866f, -0.00349409f, 0.05386006f, 
    -0.23141566f, 0.25473639f, -0.19395135f, -0.23154636f, -0.04590916f, 0.10330428f, 0.01396154f, -0.04116815f, 
    -0.09664068f, 0.10432142f, -0.05486987f, -0.20339614f, -0.78662610f, 0.41238093f, 0.07295536f, 0.08287527f, 
    -0.03151565f, 0.18696037f, 0.29404029f, -0.16866930f, 0.09727045f, 0.05333929f, -0.05844268f, 0.19084169f, 
    0.68860763f, -0.13210480f, -0.00011348f, 0.09244225f, -0.03926470f, -0.11768311f, -0.00422684f, -0.01895833f, 
    0.05008275f, -0.06642342f, 0.16132678f, 0.08657236f, -0.41154870f, -0.44054610f, 0.18581209f, 0.06294664f, 
    -0.07549140f, 0.15347670f, 0.30868495f, -0.14172302f, 0.13573806f, -0.05725783f, 0.15400819f, -0.06247918f, 
    -0.31675839f, -0.14017004f, -0.20570919f, -0.50648242f, 0.02848819f, -0.16455488f, -0.12371351f, -0.06778877f, 
    -0.08498164f, 0.10957771f, -0.02454418f, 0.18713254f, -0.03418901f, -0.35031390f, 0.17126511f, 0.23604946f, 
    -0.05522868f, 0.04384555f, 0.14083336f, 0.21033122f, 0.06206203f, -0.00036605f, -0.25841767f, 0.16051731f, 
    -0.08770506f, -0.54860568f, -0.39231485f, -0.41759536f, 0.01171006f, 0.03369077f, 0.07182011f, 0.02671033f, 
    0.13716140f, 0.12255362f, 0.05465573f, 0.00482731f, 0.20975995f, 0.12585331f, 0.10221780f, 0.13711062f, 
    0.00787711f, -0.15982100f, 0.14230588f, 0.03429238f, -0.07513806f, 0.29223698f, -0.00937212f, -0.13641375f, 
    -0.10575914f, 0.21404780f, 0.02282175f, 0.06227360f, -0.00156669f, -0.17424566f, -0.35716909f, -0.37163436f, 
    0.08666199f, 0.01421895f, 0.03602725f, -0.04760060f, -0.07213403f, 0.05708379f, 0.10185139f, 0.06129815f, 
    0.14298825f, -0.00550604f, -0.06509754f, 0.06499057f, 0.15276763f, 0.30339462f, -0.23243691f, -0.00254895f, 
    0.17470235f, 0.04708050f, 0.05658026f, -0.27851486f, -0.18960695f, -0.15964597f, -0.23087285f, 0.04604958f, 
    -0.08314490f, 0.01986200f, 0.00006430f, 0.06442583f, 0.26204956f, 0.06391531f, 0.15385093f, -0.24353337f, 
    -0.11518089f, -0.07045148f, -0.00154249f, 0.10444264f, -0.00530358f, -0.05486879f, -0.13325079f, 0.09080282f, 
    0.16571476f, 0.51582420f, 0.09550712f, -0.00757994f, 0.14415799f, -0.07243593f, 0.11907772f, 0.40478730f, 
    -0.04640413f, -0.02191349f, -0.02846678f, -0.17117710f, -0.21603151f, 0.19252937f, -0.53470474f, -0.09070208f, 
    -0.00135317f, -0.01374368f, 0.02806979f, 0.04270598f, -0.17126065f, -0.21275252f, -0.21606882f, -0.17843132f, 
    0.16802907f, 0.12066869f, -0.01717964f, 0.13200302f, -0.13600053f, 0.10896473f, -0.00708336f, -0.01218328f, 
    -0.16934495f, -0.02186212f, -0.04032472f, 0.01486504f, 0.48200765f, -0.26893634f, 0.40834871f, -0.02760877f, 
    -0.01258629f, -0.00934856f, 0.06485845f, -0.05969365f, -0.00034492f, 0.09475438f, -0.15085496f, 0.02556253f, 
    0.25043464f, 0.09405834f, 0.10250622f, 0.32830673f, -0.30916655f, 0.02217120f, -0.08513011f, -0.15442929f, 
    0.00953507f, 0.01922185f, -0.16667919f, 0.07963835f, 0.18259983f, 0.19975601f, 0.03477719f, -0.14040299f, 
    0.10001468f, 0.08657724f, -0.07978859f, -0.07607049f, -0.04462018f, -0.06508243f, 0.04279403f, 0.02623598f, 
    -0.49767816f, 0.08852243f, -0.33804166f, -0.18926513f, 0.07710760f, 0.00488566f, 0.20680460f, 0.10887124f, 
    -0.04589291f, 0.04674303f, 0.06180547f, -0.07920086f, 0.23185994f, -0.19406280f, -0.41529953f, 0.04486460f, 
    0.19369683f, 0.14638004f, -0.26387411f, -0.17216024f, 0.03948783f, -0.18433675f, -0.02650253f, 0.04107966f, 
    -0.11082107f, 0.00266990f, -0.06107127f, -0.04143293f, -0.01410202f, -0.01498939f, -0.02033062f, 0.06197279f, 
    0.02922576f, -0.09570089f, -0.06441518f, 0.00787322f, -0.08039036f, -0.12895019f, 0.25636083f, -0.66981912f, 
    0.07784517f, 0.01475356f, -0.11669880f, 0.11921515f, 0.02343896f, -0.11346907f, -0.02645302f, -0.09185911f, 
    0.16835757f, -0.16080976f, -0.01345611f, 0.09064794f, -0.06130764f, 0.03961607f, -0.00037047f, 0.13117398f, 
    0.00172602f, -0.01751483f, 0.02375208f, -0.06010235f, -0.69859082f, 0.27261159f, 0.08019929f, -0.25919235f, 
    0.01788809f, 0.02627498f, -0.06601539f, 0.02542443f, 0.02073613f, 0.03144839f, -0.12160495f, 0.03173443f, 
    -0.24953182f, 0.07872354f, 0.39601162f, 0.22096877f, 0.01040328f, -0.04285215f, 0.08717148f, 0.07285066f, 
    0.02172782f, -0.18277648f, 0.09625790f, -0.06209415f, -0.19172506f, -0.30189523f, 0.08967669f, -0.37252647f, 
    0.11256332f, -0.11764970f, -0.27971354f, -0.13379377f, 0.04185262f, 0.08823563f, -0.05384947f, -0.00813470f, 
    -0.10731009f, 0.01398038f, 0.00180997f, -0.25963032f, 0.01724581f, -0.03242588f, -0.10015086f, 0.02033115f, 
    -0.05710625f, -0.06688082f, 0.00362216f, -0.03264217f, -0.81323910f, 0.46274534f, 0.14890561f, -0.53076512f, 
    0.01546592f, -0.07140154f, -0.02064334f, 0.04858316f, -0.01603454f, 0.02961536f, 0.01759926f, -0.12313773f, 
    -0.26405928f, -0.01904958f, -0.28710774f, 0.18043105f, -0.13752182f, -0.00335201f, -0.02390999f, 0.00770199f, 
    0.09057090f, 0.11731318f, 0.13661356f, 0.08062370f, -0.64201409f, -0.13757132f, -0.30254439f, -0.28577596f, 
    0.08644272f, -0.01451068f, -0.12913573f, -0.07478097f, -0.05377226f, -0.05987883f, 0.02976531f, 0.04162852f, 
    -0.26054245f, -0.07370359f, 0.72846192f, 0.55962873f, 0.03412427f, 0.25386453f, -0.01352864f, -0.09362005f, 
    0.04053335f, 0.05500191f, -0.01241830f, 0.04671089f, -0.45696655f, 0.09846226f, 0.50555074f, -0.08223729f, 
    -0.04733378f, -0.00299521f, 0.07044159f, 0.06122248f, -0.02642662f, -0.05554242f, -0.04477324f, 0.02697835f, 
    0.20771630f, 0.41991156f, 0.33848023f, 0.34336641f, -0.01246755f, 0.03764443f, 0.20130222f, 0.14659430f, 
    0.06687894f, 0.17209481f, 0.03750115f, 0.02684367f, -0.15476526f, 0.00198723f, -0.30698413f, 0.18837184f, 
    -0.11277442f, 0.06750309f, 0.09861141f, -0.24839601f, 0.01467042f, 0.17605536f, 0.05715179f, 0.09661209f, 
    0.03120299f, 0.05950337f, -0.21397200f, -0.25042129f, 0.02497394f, -0.10183547f, 0.05634121f, 0.09555499f, 
    -0.02140369f, 0.09040111f, 0.07514909f, -0.18003999f, 0.28026640f, -0.21171764f, 0.08194713f, 0.19854961f, 
    -0.10003918f, 0.04160575f, 0.24802007f, -0.04310672f, 0.01666866f, -0.04083056f, -0.01248391f, -0.06854106f, 
    -0.69820029f, -0.83679116f, 0.03649355f, -0.34334141f, 0.02318978f, 0.02534233f, -0.19669093f, -0.57659405f, 
    0.11150481f, -0.09635604f, 0.05050369f, -0.00030787f, -0.01476910f, -0.14650948f, 0.11100739f, -0.29833299f, 
    0.16326268f, -0.29020128f, -0.00832770f, 0.18625036f, 0.06090622f, 0.13912821f, -0.13540007f, -0.14091946f, 
    0.16819397f, -0.08680111f, 0.03736699f, -0.06696837f, 0.00059526f, -0.00803676f, 0.05135518f, -0.13487560f, 
    -0.06796072f, -0.21848887f, -0.32468987f, 0.01091821f, -0.14913005f, -0.02411129f, 0.03635058f, -0.25355050f, 
    0.09368969f, 0.00051559f, 0.02602539f, -0.08111536f, -0.00567782f, -0.10533436f, 0.22165580f, 0.08955322f, 
    -0.14484110f, 0.00660847f, 0.14276424f, 0.34713429f, -0.06389663f, -0.03808286f, -0.04941630f, -0.14824340f, 
    -0.10881242f, 0.09944803f, -0.20775214f, 0.19378658f, 0.08413094f, -0.08707431f, -0.11094244f, 0.00035790f, 
    0.05290685f, 0.04059947f, -0.03077833f, 0.00670622f, 0.05460326f, 0.03787538f, 0.27666801f, 0.19083673f, 
    -0.52774996f, -0.35731524f, 0.03873099f, -0.32107723f, 0.05677636f, 0.09732667f, 0.13043153f, -0.22842532f, 
    0.02902159f, -0.02214793f, 0.07426734f, -0.00772256f, -0.61132067f, -0.10336913f, 0.20989729f, 0.03345731f, 
    -0.09531511f, -0.04024758f, 0.01938362f, -0.12265924f, 0.12493512f, -0.10429452f, -0.04618767f, 0.21791580f, 
    -0.58536595f, 0.30043241f, 0.33468962f, 0.46903893f, 0.05611474f, -0.06205159f, -0.10317975f, 0.06695282f, 
    0.03061309f, -0.06466389f, -0.04538890f, -0.01207168f, -0.13508169f, 0.15941787f, 0.41853479f, 0.30743745f, 
    -0.01968677f, -0.03483933f, 0.03667058f, 0.00404479f, 0.01587115f, 0.05820785f, 0.25777417f, 0.12361497f, 
    -0.06249373f, -0.03826654f, -0.14487137f, -0.07750672f, 0.01025803f, 0.09813348f, -0.07506879f, -0.02116179f, 
    -0.06940271f, -0.07589477f, 0.03569265f, -0.14064348f, -0.06707173f, -0.14231351f, 0.21750408f, -0.39462674f, 
    0.05470413f, -0.01336359f, -0.09768493f, 0.01848987f, 0.06564220f, 0.13778302f, -0.07912216f, 0.09683050f, 
    -0.91212338f, -0.35008043f, -0.08577494f, -0.43238601f, -0.02643405f, -0.18701427f, 0.00322534f, -0.10062976f, 
    -0.01338615f, 0.03895060f, -0.01058570f, 0.04794671f, 0.61215812f, -0.27984831f, 0.52623767f, 0.42230171f, 
    0.11164651f, -0.09220429f, 0.00387739f, 0.20939733f, 0.13395399f, 0.12915218f, -0.01517928f, 0.08792277f, 
    -0.01497023f, -0.00460707f, -0.15563633f, 0.09114156f, -0.05987455f, -0.03299465f, 0.01753968f, 0.19574666f, 
    -0.03943229f, -0.04289058f, 0.02100662f, -0.09746607f, 0.43558380f, 0.09818154f, 0.00463210f, 0.02716338f, 
    0.12720217f, 0.14128752f, -0.08903469f, 0.06287094f, 0.20685095f, 0.26047024f, -0.00590889f, -0.02124108f, 
    -0.24720110f, -0.27278265f, -0.03379927f, -0.13878506f, -0.35038492f, 0.05008367f, -0.50374311f, -0.27106595f, 
    -0.08204862f, -0.37547299f, 0.05072079f, -0.09983227f, -0.44281352f, -0.17480372f, 0.16143560f, 0.04336262f, 
    -0.15703668f, 0.13169178f, -0.26149219f, 0.13852665f, -0.04441934f, 0.03782890f, -0.16340038f, -0.02081491f, 
    0.44308090f, 0.36491108f, -0.20633987f, 0.06692126f, -0.23696145f, -0.13087592f, -0.49489754f, -0.09085192f, 
    -0.01388513f, 0.12057418f, 0.06480866f, 0.01230539f, -0.21796480f, -0.47188637f, 0.33800426f, -0.08245671f, 
    -0.15234597f, -0.15775061f, -0.14914735f, -0.08968429f, -0.13926801f, 0.21163797f, -0.24808231f, -0.00562844f, 
    0.06352884f, -0.28463063f, -0.17833792f, -0.11205003f, 0.40421563f, 0.25620010f, 0.18154977f, -0.00884462f, 
    -0.16512707f, -0.08520120f, -0.20771165f, 0.07638414f, 0.10424212f, -0.37506571f, 0.36021370f, 0.07615697f, 
    -0.34848022f, 0.25179067f, 0.03845337f, 0.01241403f, 0.17999963f, -0.01042431f, -0.15714762f, 0.06584489f, 
    -0.37666619f, -0.10728817f, 0.06649070f, -0.15971835f, 0.20679359f, -0.11042083f, -0.10473840f, -0.08321228f, 
    0.03215530f, -0.07032021f, 0.36396196f, -0.15366963f, -0.49420547f, -0.49733514f, 0.33669838f, 0.16045107f, 
    -0.06177627f, 0.15356003f, -0.01502008f, 0.19356215f, -0.00529224f, 0.10058887f, 0.07079997f, -0.06307574f, 
    0.37151238f, 0.14458159f, -0.08855669f, -0.13377164f, -0.00720142f, -0.07887512f, 0.04524757f, 0.00574473f, 
    -0.32569870f, 0.06740169f, 0.08138522f, 0.02375317f, -0.06397380f, -0.13448197f, 0.02327365f, 0.27380800f, 
    -0.11405897f, -0.08036982f, -0.02429614f, 0.05211176f, -0.19528116f, 0.17604029f, -0.07051619f, -0.18317223f, 
    -0.00834747f, -0.15521103f, -0.19242531f, 0.32358852f, 0.03068993f, -0.04716093f, -0.04052359f, -0.16359024f, 
    0.02576059f, 0.02407857f, -0.09178376f, 0.11877457f, -0.01859734f, -0.43262440f, 0.72877479f, 0.27472821f, 
    -0.16656424f, -0.08867432f, -0.10103296f, 0.07616396f, 0.21271050f, 0.05788873f, 0.09781573f, 0.04108432f, 
    0.70580953f, -0.36746052f, 0.09022132f, 0.17505941f, 0.21103482f, 0.05615082f, -0.06861433f, -0.00273605f, 
    0.11071000f, 0.05850280f, 0.01780811f, 0.04916720f, -0.02770984f, -0.13701408f, -0.05318593f, -0.47788769f, 
    0.04676434f, -0.09790141f, -0.15697262f, 0.01018540f, -0.17403293f, -0.01627361f, -0.06620827f, -0.13995464f, 
    -0.99897665f, 1.13260579f, -0.49604818f, 0.33281833f, 0.13217632f, 0.08821943f, -0.10529990f, -0.23608315f, 
    0.03149017f, -0.10035923f, 0.24805433f, -0.15304978f, -0.49048910f, 0.82807696f, -0.22489610f, -0.56691468f, 
    0.09285679f, 0.09591222f, -0.13269421f, 0.14356318f, -0.36706984f, -0.14824905f, 0.05863314f, -0.10303932f, 
    0.04555675f, -0.22289422f, 0.10904613f, 0.11559978f, -0.04335413f, 0.18713498f, -0.12089294f, 0.23383299f, 
    -0.06844546f, 0.01206139f, -0.03189075f, -0.11028573f, 0.00606554f, 0.27579880f, -0.11228693f, 0.24115072f, 
    0.12334873f, 0.08277903f, 0.12480608f, 0.14034225f, -0.19328378f, 0.01881073f, 0.05790963f, 0.13540339f, 
    -0.15567434f, -0.09708769f, -0.25267294f, 0.32817593f, 0.07870509f, -0.17445281f, 0.07861800f, 0.02381269f, 
    -0.03277757f, 0.16571507f, -0.15745917f, 0.10054826f, -0.57955408f, 0.00998141f, 0.04886335f, -0.19198841f, 
    0.03037199f, 0.22415054f, -0.16963997f, -0.09198186f, 0.05712371f, 0.06441728f, 0.10941827f, -0.15624657f, 
    0.34243912f, -0.17987210f, -0.11715036f, 0.01936196f, -0.01103986f, -0.13674268f, 0.12194651f, -0.21117863f, 
    0.11502913f, 0.13561876f, -0.02952815f, 0.25012451f, 0.34809148f, 0.52374959f, 0.26682967f, -0.41899070f, 
    -0.68357211f, 0.00637401f, -0.03921075f, -0.04001682f, 0.00954818f, 0.05293813f, 0.30139896f, 0.05690741f, 
    -0.04764223f, -0.28419676f, 0.05162040f, 0.23537123f, 0.04547014f, 0.04979996f, 0.02049976f, 0.00711730f, 
    -0.01927439f, -0.15042843f, -0.04617686f, -0.16610727f, 0.11543515f, -0.02270334f, -0.03100672f, 0.15258107f, 
    -0.09676765f, -0.20251396f, 0.07869390f, 0.05844291f, -0.00258730f, -0.01169080f, -0.13632672f, 0.01984472f, 
    0.19341473f, -0.15109593f, 0.01437525f, 0.17270501f, 0.03296580f, -0.04199503f, 0.01763750f, -0.04517436f, 
    0.14299469f, 0.07689211f, -0.00776625f, 0.12837508f, -0.17713435f, -0.07143827f, -0.00149646f, 0.17823423f, 
    0.11519609f, 0.12548761f, -0.00841251f, -0.06098568f, -0.10054378f, 0.00395238f, 0.01324574f, 0.04916643f, 
    -0.22993453f, 0.28360903f, -0.21072870f, 0.28714839f, 0.20057502f, -0.14642042f, -0.05437993f, -0.13810427f, 
    0.10440481f, 0.20120840f, 0.19415635f, -0.08918957f, -0.64236075f, -0.14834066f, -0.17247246f, 0.10854682f, 
    -0.03276305f, -0.12896176f, -0.34703273f, -0.07842275f, -0.05602678f, 0.09385871f, -0.08640970f, 0.00760035f, 
    -0.13354364f, -0.24307258f, -0.18097049f, 0.23730567f, 0.20258671f, 0.01298321f, 0.14389561f, -0.08266552f, 
    0.07489391f, 0.08077884f, 0.02059118f, 0.19717313f, 0.09986698f, 0.15913041f, 0.10609099f, 0.14426425f, 
    0.15719140f, -0.05120195f, -0.10538539f, -0.30586508f, -0.31009862f, 0.09857541f, -0.00036142f, -0.07275869f, 
    0.02252759f, -0.00881807f, 0.25757521f, 0.16913339f, 0.00464426f, 0.09044758f, -0.23804903f, 0.01214910f, 
    0.00252439f, 0.02508017f, -0.05694500f, -0.03135742f, -0.25946888f, 0.24067211f, 0.05641345f, 0.05827833f, 
    0.07467417f, 0.04333642f, 0.03977709f, -0.09939511f, 0.00525137f, -0.49748707f, 0.04947224f, -0.10023250f, 
    0.08079929f, 0.02203576f, 0.04130754f, 0.08006024f, 0.14542171f, 0.02687944f, 0.11704228f, 0.05588573f, 
    0.04128066f, 0.07943938f, -0.04623573f, 0.03973357f, 0.76637334f, 0.06528890f, -0.58477199f, -0.20316127f, 
    0.12721939f, 0.09216262f, 0.16089618f, -0.06223904f, 0.05313156f, -0.10469505f, 0.08344380f, -0.08474819f, 
    -0.05620573f, 0.02495072f, -0.40667912f, -0.47670454f, -0.17356391f, -0.05310293f, -0.05912655f, -0.05904875f, 
    0.11205156f, -0.26296920f, -0.17418423f, -0.38712028f, 0.31506523f, -0.35192889f, -0.34542480f, 0.08058524f, 
    -0.03165067f, 0.04103331f, 0.05220164f, 0.26499555f, 0.18158892f, 0.04094232f, 0.17157356f, -0.08835302f, 
    0.02415634f, 0.23409902f, 0.10711779f, -0.00953827f, -0.08496534f, -0.00835983f, 0.02162930f, 0.10328176f, 
    -0.01728155f, -0.05719180f, 0.02979675f, 0.03291461f, 0.28250301f, 0.36169651f, -0.08968022f, 0.44179228f, 
    0.27259824f, 0.07078098f, 0.08335738f, -0.07689586f, 0.02874503f, -0.02675276f, 0.00736917f, -0.01656074f, 
    0.10775653f, 0.02747957f, 0.04493395f, 0.27306333f, -0.01674842f, 0.18475612f, 0.00501431f, 0.09793242f, 
    0.12245063f, 0.01087044f, -0.02353896f, -0.07825537f, -0.32970247f, 0.06263208f, -0.06874871f, 0.22972095f, 
    0.07425224f, 0.03153857f, 0.08783878f, -0.00787120f, -0.07172434f, -0.06252425f, 0.06226761f, 0.08616474f, 
    -0.02698450f, -0.12732668f, -0.01982504f, -0.04046096f, -0.07899562f, 0.02348305f, 0.01623064f, -0.10242043f, 
    0.12563208f, 0.12393808f, 0.18959960f, 0.37756273f, 0.01613798f, 0.04459596f, 0.08235789f, 0.14632228f, 
    -0.18392316f, 0.02365476f, -0.03439035f, -0.05693866f, 0.01005942f, 0.00571738f, 0.02420646f, -0.03722208f, 
    -0.17787412f, 0.01024082f, -0.00574114f, 0.02674654f, -0.10773490f, 0.00981850f, -0.06043601f, 0.00334811f, 
    -0.06747377f, 0.00915509f, 0.04859669f, 0.12457516f, 0.18637267f, 0.44084796f, -0.31656358f, 0.15752958f, 
    -0.11040252f, 0.02542291f, -0.01714047f, 0.10905237f, 0.09757434f, 0.01134952f, 0.00882875f, -0.00132953f, 
    -0.17559971f, 0.19666950f, -0.03095928f, 0.00631965f, -0.11888656f, -0.13688686f, -0.02533290f, -0.05253968f, 
    -0.13372929f, -0.16614889f, -0.02101916f, 0.06102352f, -0.19283503f, -0.24194910f, -0.09979870f, -0.16565721f, 
    -0.43026909f, -0.30579183f, -0.12497851f, 0.11237174f, -0.24758235f, -0.20840618f, -0.11079200f, -0.05769473f, 
    -0.33655587f, -0.50535017f, 0.05642116f, -0.22526541f, 0.16910772f, 0.17387092f, -0.04629664f, 0.04143948f, 
    -0.21300045f, 0.07784159f, -0.23438203f, 0.08958246f, 0.06335372f, -0.79697156f, 0.11594718f, -0.26820207f, 
    -0.42083165f, -0.16660219f, -0.02277949f, -0.04529683f, -0.07058764f, 0.14052136f, -0.05227836f, 0.06623386f, 
    0.03132653f, 0.44880968f, 0.17994784f, 0.36259222f, -0.06182605f, 0.10065594f, -0.05114808f, 0.13059716f, 
    0.07185544f, -0.08808699f, 0.05283540f, -0.07561043f, 0.09731864f, -0.21748681f, 0.14311951f, 0.04155465f, 
    0.02699810f, -0.11797231f, -0.16397262f, -0.23951146f, -0.00718677f, -0.00941117f, -0.01206835f, 0.03050063f, 
    0.35888198f, 0.25538966f, 0.23181225f, 0.11961828f, 0.04703089f, 0.00538985f, -0.03363156f, -0.00965793f, 
    -0.16285267f, -0.29718179f, 0.00191426f, -0.08634656f, -0.06059850f, 0.13196795f, 0.11886010f, -0.14028621f, 
    0.15667044f, 0.07924258f, 0.00200393f, -0.07457993f, -0.13570955f, -0.38539335f, -0.19832800f, -0.16390756f, 
    -0.13433723f, -0.05501749f, -0.06176305f, 0.08222968f, -0.07567351f, 0.10404254f, -0.07468525f, 0.02799942f, 
    -0.10558636f, -0.02856454f, -0.05931984f, 0.14995918f, 0.11729806f, -0.09799922f, -0.26064965f, 0.09138702f, 
    0.00181424f, -0.00868866f, -0.09536472f, -0.02025930f, 0.07199674f, -0.02122710f, -0.35889629f, -0.01290330f, 
    0.05117809f, 0.47969905f, 0.08799946f, 0.24213192f, -0.07339552f, 0.04615065f, -0.19535910f, 0.22088549f, 
    -0.02936344f, 0.00017508f, 0.00531480f, -0.08511806f, -0.40587616f, 0.07530405f, -0.18110710f, 0.36023751f, 
    -0.00490908f, 0.24585116f, -0.07828494f, -0.15711172f, 0.01998084f, 0.02602759f, 0.02890338f, -0.18966641f, 
    -0.16821346f, 0.02934774f, -0.03070189f, 0.22287090f, -0.04595555f, -0.08437182f, -0.16899855f, -0.23646018f, 
    0.09827513f, 0.00538159f, -0.01582089f, 0.02153142f, 0.15926291f, -0.09647060f, 0.11760464f, 0.30648059f, 
    -0.05323388f, -0.13060316f, -0.00753997f, 0.11588690f, 0.07562300f, 0.01999508f, -0.06624378f, 0.06221610f, 
    0.08900333f, -0.02632104f, 0.08182349f, -0.10925544f, -0.04601314f, 0.06083215f, 0.07764124f, -0.02080904f, 
    -0.04578672f, -0.11438159f, -0.17687955f, -0.11142987f, -0.00705260f, -0.06533390f, -0.72739065f, -0.10824637f, 
    0.15738332f, 0.01647688f, 0.06679118f, -0.03315609f, -0.01048764f, -0.08754651f, -0.05012270f, 0.08617896f, 
    0.15457922f, 0.10939342f, 0.18665050f, 0.10317973f, -0.15620452f, -0.29492539f, -0.19760229f, 0.08620688f, 
    0.09852754f, 0.09031465f, 0.17448062f, 0.02306654f, -0.05007315f, 0.14200634f, -0.04850347f, 0.07498181f, 
    -0.18825117f, -0.19607048f, 0.09792063f, -0.33770198f, 0.08711555f, -0.05976038f, 0.10876100f, 0.01478620f, 
    0.33139876f, -0.01975549f, 0.28486374f, 0.15530336f, 0.14365707f, 0.17334297f, 0.14505211f, 0.00805355f, 
    0.11475991f, 0.02576889f, 0.09457006f, 0.07769569f, -0.05803797f, -0.03532216f, 0.14309777f, 0.11235471f, 
    -0.26589391f, -0.14679267f, 0.12795416f, -0.12710610f, 0.08894710f, 0.06562616f, -0.04161521f, -0.10173620f, 
    -0.25104299f, -0.14651723f, -0.05369131f, 0.02546950f, 0.00630377f, -0.22203226f, 0.00509588f, -0.02924465f, 
    0.14668426f, -0.00523930f, 0.04950523f, -0.04138033f, -0.18527009f, -0.14996420f, -0.88910848f, 0.23943752f, 
    -0.00389933f, -0.05034680f, -0.08007036f, -0.06408700f, 0.17102161f, 0.04252106f, 0.04208009f, 0.00705417f, 
    -0.15766205f, -0.04310646f, -0.18313426f, 0.34383747f, 0.31121644f, -0.02374157f, -0.01991690f, 0.05032640f, 
    0.00254226f, 0.16532466f, 0.21968336f, 0.26029915f, 0.39209127f, -0.13869722f, -0.36824548f, 0.39618811f, 
    0.11655077f, 0.03748507f, -0.02981688f, -0.05369611f, -0.02291401f, -0.09498651f, 0.07265277f, 0.07525295f, 
    -0.84392565f, -0.28333411f, -0.21496029f, -0.04115476f, 0.00110362f, -0.04583733f, -0.20023477f, -0.04483822f, 
    0.05160410f, 0.01845196f, 0.19438550f, 0.01154192f, -0.02118213f, 0.11978707f, -0.07502346f, -0.01545304f, 
    -0.09740970f, -0.41086441f, -0.05399650f, 0.16519964f, -0.04724102f, 0.07768971f, 0.15647477f, -0.23158602f, 
    -0.22759256f, -0.08637059f, -0.29722083f, 0.23795822f, 0.28137213f, -0.10357225f, -0.01550868f, -0.14428763f, 
    0.04828834f, 0.03054577f, -0.08973901f, 0.07049549f, 0.54917568f, 0.13465418f, -0.56976444f, -0.43168834f, 
    0.04685554f, 0.08658411f, -0.11401284f, 0.08087122f, 0.04382372f, -0.19079368f, -0.11415844f, 0.13185532f, 
    -0.13790399f, -0.02269036f, 0.16309425f, 0.11367289f, 0.05633109f, 0.05203566f, -0.14894527f, 0.10444452f, 
    0.24940865f, -0.24034567f, -0.34858865f, -0.50558800f, 0.28824663f, 0.12822294f, 0.24569146f, 0.25101778f, 
    0.18552458f, 0.23753588f, -0.06541568f, 0.15063058f, 0.14361851f, -0.01129522f, 0.08836117f, 0.19749062f, 
    -0.30953944f, 0.07910343f, -0.03421154f, -0.34031302f, 0.05190656f, -0.07852953f, -0.06364919f, 0.03424402f, 
    0.04586539f, -0.09394349f, -0.23299257f, 0.10251799f, 0.01335271f, -0.36492851f, -0.58274782f, 0.06794252f, 
    0.27716678f, 0.09966132f, -0.02795599f, 0.07243976f, 0.01238608f, -0.01651182f, -0.12829985f, -0.06720793f, 
    -0.41258964f, -0.50890887f, -0.41902190f, -0.33756828f, 0.01792646f, -0.04452186f, -0.03925856f, 0.01681693f, 
    0.05123413f, 0.02260569f, 0.05660193f, 0.02688173f, 0.29725018f, -0.48676458f, 0.08214036f, 0.35538062f, 
    0.13769794f, -0.07889774f, -0.21540509f, 0.17806251f, 0.03952798f, 0.09018566f, 0.04540319f, 0.07267676f, 
    0.00448332f, 0.25345847f, -0.31618616f, -0.38179034f, -0.12468986f, 0.11486124f, 0.11158655f, 0.13757609f, 
    0.14121287f, 0.05498539f, -0.12592214f, -0.22631587f, 0.26934221f, 0.06237895f, -0.31567201f, 0.21833789f, 
    0.18638812f, -0.19476686f, -0.15200534f, 0.11315075f, 0.11554310f, 0.17012422f, -0.16584046f, -0.00885109f, 
    0.36629841f, 0.12846111f, -0.01009117f, 0.13502760f, 0.03928387f, -0.00116816f, -0.15592378f, -0.14758247f, 
    0.05847789f, -0.07175571f, -0.03431072f, 0.04894569f, 0.00743586f, 0.36713350f, -0.05403399f, -0.59511620f, 
    0.00993876f, 0.08570410f, 0.01562636f, 0.14295343f, 0.04439178f, -0.14899343f, 0.05753503f, -0.07785975f, 
    -0.08329311f, 0.12586279f, -0.08315518f, 0.12508835f, -0.00631690f, 0.08424434f, -0.20574783f, -0.06979867f, 
    0.20628652f, 0.18665987f, 0.10451689f, 0.06700883f, 0.10947128f, -0.46721038f, -0.45601165f, -0.20004070f, 
    -0.00330101f, 0.20529084f, -0.09377582f, -0.03032227f, 0.27676499f, -0.26472640f, -0.09798142f, 0.07362779f, 
    -0.04962179f, 0.00058747f, 0.14393976f, 0.00442891f, -0.09314951f, -0.19553909f, -0.11858115f, 0.41905946f, 
    0.00409020f, -0.14978677f, -0.26408011f, -0.19517297f, -0.30112499f, -0.26650903f, 0.09053819f, 0.04591868f, 
    -0.05882609f, 0.09512918f, -0.01646097f, -0.15256260f, -0.15962279f, -0.24188237f, 0.17508776f, -0.03079023f, 
    0.03635024f, 0.20002264f, -0.10562345f, -0.16054350f, 0.20190702f, 0.24077129f, 0.37858582f, -0.17618397f, 
    0.08943855f, 0.04092324f, -0.00185626f, 0.10954805f, -0.19845021f, 0.05425465f, -0.07794472f, -0.06760947f, 
    0.23645744f, 0.07593711f, -0.05794940f, 0.05832571f, 0.01733346f, 0.07420915f, 0.28093529f, -0.15429422f, 
    -0.20245165f, 0.00139021f, -0.06161879f, -0.29866964f, -0.15753309f, -0.00127421f, 0.10603501f, -0.24208979f, 
    0.10695753f, 0.06152961f, 0.04171317f, -0.02667729f, 0.04917724f, -0.10166099f, 0.00593415f, -0.42434388f, 
    0.00555172f, 0.04327594f, -0.01912800f, 0.01065739f, 0.04551839f, -0.19660041f, 0.07792442f, -0.11548322f, 
    0.04459818f, -0.18075369f, 0.05133585f, -0.08906702f, -0.03529885f, 0.11290415f, -0.06381626f, -0.12782259f, 
    0.14511086f, 0.06752026f, 0.07077973f, 0.13276079f, 0.11371544f, 0.45121112f, -0.53275239f, -0.22987042f, 
    0.09606991f, 0.02915332f, 0.00009716f, 0.08480813f, 0.31899226f, -0.27363014f, 0.22973272f, -0.04378768f, 
    -0.16633092f, 0.29701075f, 0.08828007f, -0.45948881f, 0.03304847f, 0.05477058f, -0.16362503f, -0.07334769f, 
    0.03020988f, -0.08097866f, -0.03208782f, -0.00396853f, -0.78605831f, -0.17916499f, -0.14074370f, 0.00581986f, 
    0.07018911f, -0.03015576f, 0.13287693f, 0.20277445f, 0.13655306f, 0.09570596f, -0.09825092f, -0.11867984f, 
    -0.75475663f, -0.85528070f, -0.20588782f, 0.37139928f, -0.14999181f, -0.14817043f, -0.18596633f, -0.34785917f, 
    -0.03611923f, -0.00707519f, -0.05494742f, -0.00848633f, -0.01605639f, -0.24116543f, 0.16229469f, 0.08969522f, 
    -0.13745330f, -0.15302539f, -0.10969780f, -0.06381812f, -0.13486999f, 0.02863902f, 0.03588239f, -0.09082521f, 
    -0.03393996f, -0.12292793f, -0.09941638f, 0.08680477f, -0.02286912f, -0.04790275f, -0.04469940f, -0.03656618f, 
    -0.07355641f, -0.15177611f, -0.02569984f, -0.10766015f, 0.05796793f, -0.20978995f, -0.23201922f, -0.40086484f, 
    -0.04675807f, 0.03304929f, 0.02163951f, -0.05979433f, -0.03876130f, -0.04644124f, -0.00428795f, 0.03496600f, 
    0.40383062f, -0.09553766f, -0.12066283f, -0.00340606f, -0.05394849f, 0.09960708f, 0.22560003f, 0.13303779f, 
    -0.01389407f, 0.14459392f, -0.09985926f, 0.02553561f, 0.19808640f, 0.05375969f, -0.00374703f, -0.23068203f, 
    0.00997171f, 0.01648667f, 0.11361570f, -0.01885634f, -0.01403591f, 0.18904430f, 0.07959670f, -0.00847858f, 
    -0.43982530f, 0.14905110f, 0.49864808f, 0.09475341f, -0.04863973f, -0.07880678f, -0.08186339f, 0.06367395f, 
    -0.08123244f, 0.06446707f, 0.05578789f, 0.06564260f, 0.05978060f, -0.43340123f, -0.25305000f, -0.00394660f, 
    -0.08172020f, 0.18690349f, 0.18695852f, -0.12956008f, 0.16232961f, -0.05635795f, 0.10804167f, 0.08725985f, 
    0.11255818f, -0.09532157f, -0.15264612f, -0.17148818f, 0.07984070f, 0.06738061f, 0.10478110f, -0.20911190f, 
    -0.08872296f, -0.02364721f, -0.12920441f, -0.10693889f, 0.00981384f, 0.30035931f, 0.45994717f, -0.37334439f, 
    -0.02442203f, 0.00697866f, 0.11749190f, -0.11392180f, 0.20913117f, 0.06594504f, 0.07339890f, 0.20176919f, 
    -0.09181864f, 0.02198797f, -0.34440315f, -0.46399739f, -0.21659584f, 0.02617202f, 0.12934223f, 0.01893039f, 
    -0.04172681f, -0.00624408f, 0.22010064f, 0.10399485f, -1.08937430f, -0.87794721f, -0.67481411f, -0.49542657f, 
    0.10810751f, -0.27336949f, 0.08499361f, -0.57898152f, -0.05190190f, -0.02429087f, -0.11449166f, -0.00198193f, 
    -0.30568427f, -0.32137868f, -0.24425098f, -0.08524741f, 0.04030905f, -0.32229862f, 0.12039170f, 0.21373889f, 
    -0.00308380f, -0.01602520f, 0.11395049f, 0.13949035f, -0.08792949f, -0.25795597f, -0.15099850f, -0.27759528f, 
    0.06151245f, 0.09881207f, 0.20088224f, -0.23651469f, -0.07617249f, -0.00418712f, -0.00208145f, -0.02368259f, 
    -0.04238790f, 0.15679879f, 0.36669430f, 0.44501093f, -0.05406898f, 0.00798000f, -0.09954641f, 0.32034880f, 
    0.03452891f, 0.00303473f, 0.03654389f, 0.16122626f, 0.19703709f, 0.06698143f, -0.51371306f, 0.32563737f, 
    -0.03029686f, 0.12832485f, 0.06596670f, 0.27014750f, 0.01325070f, -0.19726774f, 0.17400973f, 0.04437759f, 
    -0.23748545f, 0.01148886f, 0.07644148f, 0.23482880f, 0.18257207f, 0.06965397f, 0.12564871f, -0.28866217f, 
    0.25239545f, -0.04524864f, -0.03677496f, 0.22461495f, -0.43275294f, 0.03526033f, 0.29178199f, -0.32548076f, 
    -0.20914209f, 0.08594499f, -0.14356069f, 0.04768920f, -0.15741560f, 0.02297648f, 0.03497844f, 0.00551263f, 
    0.26776212f, -0.71236277f, -0.79777509f, -1.06773484f, -0.20993827f, -0.01663003f, 0.21553467f, -0.12698576f, 
    0.05935362f, -0.04470121f, -0.04696827f, 0.06039131f, -1.09646010f, -0.09367866f, 0.22233839f, 0.34674525f, 
    0.15742990f, -0.00703309f, -0.13396935f, -0.40552372f, 0.02666538f, 0.12282499f, 0.06980338f, 0.09820664f, 
    0.06377697f, 0.26053044f, 0.48130241f, 0.15959950f, -0.03607767f, -0.11071278f, -0.02124507f, -0.00777089f, 
    -0.00063683f, -0.14298923f, 0.05176584f, -0.01019125f, 0.02621871f, -0.07392775f, 0.09669004f, -0.09584174f, 
    -0.02685168f, 0.14668097f, -0.04565226f, 0.09028270f, 0.07780821f, 0.14570647f, 0.09488472f, 0.15253697f, 
    -0.20906602f, -0.28141382f, -0.34709015f, 0.35243657f, -0.18299411f, 0.03831349f, 0.41263953f, 0.32297575f, 
    0.08269374f, -0.02332481f, 0.33521032f, -0.11610138f, 0.14176203f, 0.05739992f, -0.01581255f, 0.01109525f, 
    -0.02492412f, 0.16404524f, 0.02647440f, 0.10186701f, 0.02500334f, 0.03970787f, 0.09418330f, 0.08692619f, 
    -0.56653917f, -0.73362905f, -0.18644914f, 0.13623923f, -0.28164634f, -0.10465318f, -0.14460021f, -0.11151826f, 
    0.06073033f, -0.05562606f, 0.00466179f, -0.01911794f, 0.72730136f, -0.04853721f, -0.70661169f, -0.22072318f, 
    -0.01805474f, -0.11848085f, 0.14564793f, 0.13301577f, -0.03969280f, 0.20869467f, -0.18789543f, -0.52967960f, 
    -0.55399209f, -0.82631379f, -0.13104966f, -0.26326811f, 0.00984816f, -0.28008509f, -0.27580383f, -0.23477149f, 
    -0.00409508f, 0.00493034f, 0.08215984f, 0.04226822f, -0.31462908f, 0.37000528f, 0.32300451f, -0.02440561f, 
    -0.05913324f, 0.00973167f, -0.00658546f, 0.14346266f, 0.12863882f, 0.38434646f, -0.03391756f, 0.11656004f, 
    -0.14447446f, 0.22001237f, -0.09558871f, -0.14727071f, 0.02755283f, -0.30884135f, 0.10636073f, 0.05012964f, 
    0.02601239f, 0.17077473f, -0.22155395f, -0.04632843f, 0.32412645f, -0.00008670f, -0.07918744f, -0.14992738f, 
    0.06645720f, 0.03318903f, 0.05821820f, 0.00967985f, 0.05815051f, -0.00751018f, 0.07100300f, -0.20540677f, 
    -0.52842504f, -0.71301609f, 0.37485290f, 0.05343894f, -0.27144149f, 0.02357225f, -0.02990811f, -0.29227281f, 
    -0.05383139f, 0.05083169f, -0.04498285f, -0.06245458f, -0.36769667f, -0.22159824f, 0.69275039f, 0.05148295f, 
    -0.04488071f, -0.19460306f, 0.18596180f, -0.17899726f, -0.04142202f, 0.10347935f, 0.03471689f, 0.02655023f, 
    -0.25796553f, -0.78987855f, 0.21081606f, 0.13886383f, -0.03777094f, 0.04372592f, -0.02911595f, -0.00394369f, 
    -0.01686426f, 0.00543022f, -0.02015820f, 0.01496983f, 0.12509219f, -0.13931468f, -0.04053129f, 0.32118541f, 
    0.03564889f, 0.02728320f, 0.05544250f, -0.04638819f, -0.10742069f, -0.12783074f, 0.15143137f, 0.03306110f, 
    0.02534636f, 0.08375490f, 0.10148807f, -0.14425494f, -0.00403520f, -0.07845369f, 0.01348525f, -0.02500771f, 
    0.09292131f, 0.04502906f, 0.01467889f, -0.04048869f, -0.18751100f, 0.14385259f, 0.04453843f, -0.03690006f, 
    0.06437831f, 0.06679552f, 0.06842811f, -0.00223208f, 0.08366577f, 0.04742378f, 0.09100837f, -0.01795441f, 
    -0.35840964f, 0.27531984f, -0.47825360f, 0.16291207f, 0.02403578f, 0.23920499f, -0.03595848f, -0.03197093f, 
    -0.01212995f, -0.07455637f, 0.09659915f, 0.06042740f, -0.02490675f, 0.14468487f, 0.19309479f, -0.01324906f, 
    0.07779235f, 0.02433457f, -0.02111381f, -0.03836619f, 0.00877400f, 0.04061786f, 0.07296176f, 0.04277233f, 
    0.50791061f, -0.00946161f, -0.27645308f, -0.31737608f, 0.01931400f, -0.04063202f, -0.05017757f, -0.02842568f, 
    0.03398174f, 0.00844381f, -0.07249181f, -0.19015935f, -0.13043258f, 0.28510725f, -0.25613284f, 0.06958800f, 
    0.15329064f, 0.19274098f, 0.11206657f, -0.16318525f, 0.02686454f, 0.02486525f, 0.09639533f, 0.16971806f, 
    -0.05084224f, 0.11969811f, 0.00287609f, -0.02584099f, -0.02951352f, -0.02559099f, -0.03442897f, -0.00637523f, 
    0.06172926f, 0.03517140f, 0.02582803f, -0.03801961f, -0.15017127f, 0.24957101f, 0.15041800f, -0.02131744f, 
    0.13597940f, 0.11747130f, 0.11731748f, 0.01949862f, -0.05328331f, -0.05299950f, 0.09864274f, 0.03654431f, 
    0.22980000f, -0.06612892f, -0.18329635f, 0.33153370f, -0.02835855f, -0.02947845f, 0.06194770f, -0.22789931f, 
    0.04656864f, 0.05030221f, -0.12194400f, 0.10577632f, -0.77788383f, -0.49840909f, 0.34556565f, 0.53133047f, 
    -0.08044114f, -0.03974583f, -0.04822771f, 0.15582266f, -0.05308956f, -0.07543641f, -0.17872603f, -0.10687333f, 
    -0.08166637f, -0.77651542f, -0.29394737f, -0.57255334f, -0.13483292f, 0.05580379f, -0.01803553f, 0.06195267f, 
    0.08377833f, 0.07385547f, 0.00883490f, -0.04354018f, -0.17865774f, 0.18666525f, -0.37017286f, -0.19477184f, 
    -0.02493533f, -0.16344899f, -0.10556144f, -0.12505600f, 0.03764169f, 0.08108305f, 0.04594852f, 0.01544023f, 
    0.46693000f, -0.86069447f, -0.22932504f, -0.18014142f, -0.15239863f, 0.07669149f, -0.28069758f, 0.06663751f, 
    0.09002245f, -0.04795736f, 0.04117754f, -0.07614852f, 0.32911009f, -0.34522331f, -0.05034035f, -0.09627895f, 
    0.09335384f, 0.03209628f, -0.02086993f, -0.38811204f, -0.08197801f, 0.08256868f, -0.12297457f, -0.23920481f, 
    -0.13981943f, 0.14779690f, 0.27545360f, 0.10368652f, 0.00536935f, 0.06547908f, 0.15265542f, 0.07730546f, 
    -0.09252279f, 0.13704050f, 0.04362770f, -0.05674806f, 0.57481939f, 0.46590731f, -0.61650753f, -0.22189723f, 
    0.02385657f, 0.02225393f, -0.12699920f, -0.14867815f, -0.03172597f, 0.11248500f, 0.02143029f, 0.05065732f, 
    -0.95699745f, 0.10651593f, -0.37427384f, 0.49424309f, 0.11460086f, 0.12985966f, 0.07320476f, -0.01523059f, 
    -0.06419937f, -0.05613724f, 0.01334152f, -0.09883907f, -0.54966253f, 0.31765163f, 0.69689822f, 0.11134376f, 
    -0.07590484f, -0.01648246f, 0.11625260f, -0.03708072f, -0.06914666f, -0.09763032f, 0.02227352f, 0.01740648f, 
    -0.02772283f, 0.02347931f, -0.43897009f, 0.09680738f, 0.05493103f, -0.03944541f, 0.00792670f, -0.02567547f, 
    -0.09597901f, 0.02460132f, 0.02034751f, 0.12105829f, -0.02692561f, 0.22734760f, 0.11848028f, -0.02151757f, 
    -0.04428028f, 0.01432577f, 0.02210480f, 0.03647221f, 0.04882637f, -0.23018692f, -0.16306566f, -0.32349712f, 
    0.25847372f, -0.68807614f, -0.26925719f, -0.23327541f, 0.11882991f, 0.20470183f, 0.18443759f, 0.01388956f, 
    -0.03303459f, -0.09327871f, -0.10401190f, -0.06375260f, 0.11216147f, 0.01925856f, 0.08125661f, -0.06006898f, 
    -0.01084782f, -0.06192073f, -0.09050921f, -0.07078823f, -0.23031209f, 0.03179778f, -0.19885194f, 0.04539642f, 
    -0.50581336f, 0.11855569f, 0.12244286f, 0.18621352f, 0.11985675f, -0.09045884f, -0.06618007f, 0.10034009f, 
    -0.00048168f, 0.00052628f, -0.02152311f, -0.04253666f, -0.43246892f, -0.30060458f, 0.12265388f, 0.30113977f, 
    -0.03342758f, 0.01706160f, -0.06868251f, -0.04507993f, 0.03958478f, -0.21447119f, -0.01339331f, -0.09853695f, 
    -0.29139501f, -0.54990667f, -0.16428494f, -0.47650847f, -0.26147810f, 0.14328471f, -0.40490898f, 0.23501496f, 
    0.06639811f, -0.05862614f, 0.08027120f, 0.00161584f, 0.40499473f, -0.70249528f, -0.08635876f, -0.61870706f, 
    0.02934692f, -0.07979805f, -0.09782676f, 0.04524070f, 0.14970984f, 0.10931326f, 0.02190291f, -0.08644716f, 
    0.04797034f, 0.02136141f, 0.05759462f, 0.01867665f, -0.04224839f, -0.18148629f, 0.22993565f, 0.01794188f, 
    -0.02763201f, -0.04124806f, 0.00651599f, -0.02168426f, -0.09535848f, 0.05773102f, 0.23737791f, 0.05149338f, 
    0.00450324f, -0.01911804f, -0.03026264f, 0.00909949f, 0.02779860f, -0.25422937f, 0.10823283f, 0.10978434f, 
    -0.28501517f, -0.43118829f, -0.19069844f, -0.24033576f, 0.05298920f, 0.18474288f, 0.17370731f, 0.19628464f, 
    -0.01109918f, -0.10544344f, 0.00837813f, 0.01388713f, 0.68289983f, -0.59503835f, -0.73941964f, -0.39195111f, 
    -0.00779742f, -0.09767880f, -0.28761342f, 0.03598944f, 0.07843070f, 0.03693956f, 0.06028169f, 0.07416990f, 
    0.52098453f, 0.29080015f, -0.11565389f, -0.09251831f, -0.05262652f, 0.04489703f, 0.00407017f, -0.10120239f, 
    0.07117867f, 0.08589029f, -0.03592359f, 0.15268001f, 0.23659146f, -0.23311791f, -0.41194701f, -0.06720976f, 
    0.10630891f, 0.00641121f, -0.02767774f, 0.08170412f, 0.09259039f, 0.22160792f, 0.22727606f, 0.19826394f, 
    -0.20328277f, 0.05455911f, 0.10451205f, -0.23004384f, -0.06805240f, -0.07083655f, -0.04938797f, -0.15042457f, 
    -0.03530035f, 0.08251449f, 0.09858759f, 0.15967990f, -0.46456477f, 0.25162691f, 0.19320254f, 0.10681416f, 
    -0.18899983f, -0.22615916f, -0.18471611f, -0.03630781f, -0.12694439f, 0.10138480f, -0.13317689f, 0.01127735f, 
    -0.20708112f, 0.00791424f, -0.26591003f, 0.54261434f, 0.08119843f, -0.08443362f, 0.11478113f, 0.09919000f, 
    -0.09180714f, -0.01674264f, 0.15252368f, 0.03728158f, -0.75884306f, 0.38136023f, 0.03213487f, 0.18551506f, 
    0.04314623f, -0.05071695f, -0.10914898f, -0.12328348f, -0.03449132f, -0.08401234f, -0.08994942f, 0.03628483f, 
    -0.10790233f, -0.22398674f, 0.19198404f, 0.09716211f, -0.19841464f, 0.06674005f, 0.12121864f, 0.05954780f, 
    0.11338513f, 0.05153199f, -0.03769762f, 0.06463652f, -0.59038287f, -0.15344018f, 0.16382034f, 0.14830218f, 
    0.41200155f, 0.12720832f, -0.16637924f, -0.09135324f, -0.17004585f, -0.09816629f, -0.07715936f, -0.19852084f, 
    -0.35918221f, 0.17755046f, 0.08064184f, 0.02071501f, -0.06241748f, -0.05399214f, -0.13141187f, -0.01712794f, 
    -0.13998623f, 0.03544391f, 0.10927229f, 0.08169497f, -0.51706630f, -0.03418206f, 0.25756687f, 0.26068950f, 
    -0.01275483f, 0.00874706f, -0.13201185f, -0.15578592f, 0.17041108f, 0.12755652f, -0.00101721f, -0.03890080f, 
    0.26609337f, 0.14568795f, 0.05267797f, -0.01672043f, 0.23732109f, 0.16140980f, 0.09171282f, 0.19268629f, 
    -0.29710141f, -0.17517495f, -0.20258182f, -0.36050391f, 0.21655232f, -0.21316649f, -0.36366135f, -0.16819279f, 
    -0.06357814f, -0.09082329f, -0.14051810f, -0.00556617f, 0.03945446f, 0.08365197f, 0.06978916f, 0.08294755f, 
    -0.12227948f, -0.66750783f, -0.50866312f, -0.04815204f, 0.20870575f, 0.24630772f, 0.22514920f, 0.05390121f, 
    -0.10794108f, -0.05713700f, -0.02611291f, 0.11030208f, -0.45898360f, 0.19428937f, 0.25071388f, 0.29809663f, 
    0.03014176f, -0.17917249f, -0.05985419f, -0.22413868f, -0.05300743f, -0.06673582f, 0.02165635f, -0.08161962f, 
    -0.37265792f, -0.47710219f, -0.14846344f, 0.35533392f, 0.00747488f, 0.06461406f, 0.12752371f, 0.17809330f, 
    -0.07938354f, -0.03421041f, 0.07988784f, -0.03247135f, 0.61044228f, 0.56837302f, -0.12637503f, -0.22484079f, 
    0.14020813f, 0.13143045f, 0.20130704f, 0.05134254f, 0.27619863f, -0.04864161f, 0.32045186f, 0.15855807f, 
    0.02703996f, -0.28924832f, 0.17742157f, 0.16057335f, -0.06714932f, -0.12807532f, -0.02987511f, 0.02350941f, 
    -0.18029433f, -0.20616142f, -0.00254593f, 0.10142825f, 0.29265866f, -0.17495608f, -0.66614044f, -0.20078602f, 
    -0.15038519f, 0.16850349f, 0.25657752f, 0.14420509f, 0.25661668f, -0.17066459f, -0.01587213f, 0.05695394f, 
    -0.57239902f, -0.13818176f, -0.12372375f, -0.01427172f, 0.12317380f, -0.00604705f, -0.15903194f, 0.27043623f, 
    0.04667369f, 0.01664680f, 0.03160284f, -0.02118468f, 0.09566493f, -0.35739145f, -0.66768235f, -0.32295913f, 
    -0.21043441f, 0.07409674f, 0.29449320f, -0.21741082f, 0.07403915f, 0.13073511f, 0.25352979f, 0.01257662f, 
    -0.40068090f, -0.40152663f, 0.04933352f, 0.12003504f, -0.04794605f, 0.18349041f, 0.15503033f, 0.04795574f, 
    0.05082890f, 0.10585801f, 0.21795537f, 0.03226126f, -0.34473991f, 0.18063129f, -0.00348618f, 0.22623317f, 
    -0.07503377f, -0.08987711f, -0.09423513f, 0.08782094f, 0.13828568f, -0.02008964f, 0.01032346f, 0.00505147f, 
    0.07672271f, -0.29114515f, -0.15785687f, 0.05965813f, 0.13995111f, 0.03618003f, 0.22789878f, -0.04682958f, 
    -0.10185188f, -0.10439903f, -0.22878563f, -0.61268020f, -0.15365827f, -0.02559269f, 0.00880028f, -0.25655386f, 
    0.07520585f, -0.16039814f, 0.00828983f, 0.03594087f, -0.12247276f, -0.25969017f, -0.04917158f, -0.11937993f, 
    -0.20646974f, -0.19415483f, 0.19693939f, 0.21838693f, 0.00507733f, 0.12242086f, 0.04887527f, 0.01512661f, 
    0.03372243f, 0.02429016f, 0.16251709f, 0.06183855f, -0.08319986f, 0.39931667f, -0.32997498f, 0.07723183f, 
    0.22857907f, -0.09010909f, -0.12027134f, -0.01104945f, 0.02341284f, 0.19674887f, 0.21419670f, 0.14014134f, 
    -0.15330270f, -1.07464302f, -0.61901307f, -0.01072062f, 0.16932811f, 0.12999108f, 0.23156156f, 0.07361905f, 
    -0.12200882f, 0.13450977f, 0.06591920f, 0.07436047f, -0.06573730f, -0.28848323f, -0.07174706f, 0.13801941f, 
    0.07500415f, 0.03912569f, 0.09232992f, -0.06664378f, -0.11555143f, -0.03686873f, -0.15465659f, -0.46445620f, 
    -0.15206480f, -0.12548161f, -0.01242677f, 0.18983732f, 0.04532729f, -0.00136777f, 0.11959432f, -0.16892873f, 
    0.04942144f, 0.12624344f, 0.17409730f, 0.23865952f, -0.76798409f, 0.08770321f, 0.28054160f, 0.32053357f, 
    0.04145316f, -0.08645824f, -0.01674203f, 0.08107696f, 0.05850435f, -0.04119150f, -0.00873058f, -0.04343062f, 
    0.13636360f, -0.18647516f, -0.65016770f, -0.16091079f, -0.46193317f, -0.03699187f, 0.08444132f, -0.18581526f, 
    -0.10351167f, -0.13327625f, -0.05049404f, -0.07785076f, -0.05488864f, -0.28012466f, -0.40082332f, 0.23829697f, 
    -0.19383073f, 0.30165574f, 0.23391101f, 0.25522777f, 0.08104192f, -0.08669300f, -0.03618972f, -0.07763906f, 
    0.00530590f, -0.41487741f, -0.22585259f, -0.11451274f, 0.05901736f, -0.05043893f, -0.15825336f, 0.09111087f, 
    -0.01014286f, 0.03451790f, -0.00638763f, -0.15285373f, 0.09977724f, 0.43814129f, 0.01815379f, -0.08932626f, 
    0.00116348f, -0.35663199f, -0.08086070f, 0.06379909f, 0.23445889f, 0.07915214f, -0.10971680f, 0.02081234f, 
    0.19488283f, -0.16066322f, 0.00813634f, 0.05487987f, 0.09977233f, 0.23983011f, 0.00996968f, -0.00723545f, 
    0.10837059f, 0.00312797f, -0.05150833f, 0.05709512f, 0.01503909f, -0.13067889f, 0.09154603f, 0.19939201f, 
    -0.05789883f, 0.12826982f, 0.06023435f, 0.00867436f, 0.10613325f, 0.22428909f, -0.10176706f, 0.07717305f, 
    -0.55955386f, 0.54758722f, -1.11239827f, -0.40646720f, -0.03300759f, -0.35541934f, 0.16648710f, -0.19281982f, 
    -0.06936067f, -0.00492363f, -0.24978797f, -0.15280925f, -0.14716569f, -0.16926688f, -0.54993862f, 0.24697593f, 
    0.02318943f, 0.06055478f, 0.15435660f, 0.08390822f, -0.12778024f, -0.02943007f, 0.01695831f, -0.02705425f, 
    0.33452871f, 0.30332565f, 0.30896086f, 0.33298522f, 0.03717633f, -0.09804739f, -0.30929300f, -0.24595928f, 
    0.00558575f, -0.01668965f, -0.00922338f, 0.04517769f, -0.00102479f, 0.21621794f, -0.33790261f, -0.25935584f, 
    -0.36244932f, -0.05502845f, 0.09165055f, 0.05656206f, -0.10370395f, -0.05834280f, -0.11974796f, 0.19821879f, 
    -0.20430140f, -0.04126224f, -0.18197545f, -0.07888377f, 0.10416755f, 0.10491468f, 0.14830126f, 0.16916077f, 
    0.09538560f, -0.00406517f, -0.18774493f, -0.04691062f, -0.35523230f, -0.43322048f, -0.36357269f, -0.40658590f, 
    0.03402904f, -0.13735147f, 0.05996962f, 0.00046541f, -0.18574327f, 0.09362707f, 0.01310881f, 0.10272942f, 
    -0.42443022f, 0.09523072f, -0.22356194f, 0.53098017f, 0.07891248f, -0.06845664f, 0.05376748f, -0.01060174f, 
    0.11239298f, -0.01725405f, -0.07416040f, 0.30849752f, -0.32085356f, -0.02330310f, -0.45772669f, 0.01868493f, 
    -0.19747534f, -0.15663536f, -0.00616518f, 0.10490040f, 0.09946357f, 0.10900088f, 0.09516457f, -0.15640965f, 
    0.14203851f, -0.30198631f, -0.07376041f, -0.05603093f, -0.42612785f, 0.14550510f, -0.07949430f, 0.07498099f, 
    0.05463200f, 0.03552939f, 0.06990622f, 0.04313534f, -0.12520732f, -0.18403690f, -0.69389153f, 0.14778371f, 
    0.11649220f, 0.22553061f, 0.25167745f, 0.12953345f, 0.06965004f, -0.03845578f, -0.00916952f, -0.07199034f, 
    0.15010382f, 0.24431276f, 0.14436494f, -0.54791093f, -0.07075318f, -0.23757587f, -0.03653647f, -0.24384694f, 
    0.05563647f, -0.07477334f, 0.01210076f, 0.09729215f, 0.02792988f, -0.08162346f, -0.06669870f, -0.02272595f, 
    -0.03210005f, -0.13242406f, -0.02109227f, -0.10495155f, -0.06144229f, 0.00853878f, 0.02082590f, -0.00310362f, 
    -0.10521460f, -0.58304721f, 0.34924248f, -0.54752618f, -0.08136600f, 0.05905823f, -0.21764496f, 0.10197888f, 
    0.03646087f, 0.00617274f, -0.07264610f, 0.27250871f, -0.31505656f, 0.27728930f, -0.24479426f, 0.75174230f, 
    0.11491083f, -0.02844574f, -0.34836534f, 0.04842515f, 0.05238897f, -0.24137664f, 0.06471259f, -0.00126469f, 
    -0.20673695f, 0.65995884f, -0.70600957f, 0.08065708f, 0.08097123f, -0.29463384f, 0.15600896f, 0.15564863f, 
    0.04074194f, 0.16468294f, 0.04134023f, -0.04796709f, -0.24632728f, -0.39062971f, 0.25143641f, -0.29202050f, 
    0.13000427f, 0.00983439f, -0.20526230f, -0.06068929f, 0.06396843f, 0.10173102f, 0.00698773f, -0.02483611f, 
    0.09772492f, 0.49264628f, 0.41823626f, -0.30260351f, 0.06778929f, -0.13290007f, -0.13593931f, -0.08730811f, 
    -0.09962828f, 0.04687891f, 0.06669302f, 0.11037412f, 0.12771772f, 0.11481600f, -0.05644604f, -0.02624957f, 
    0.05215249f, -0.05993747f, 0.10327701f, -0.07387407f, -0.03109169f, 0.18666483f, 0.10741847f, -0.10327302f, 
    -0.09354489f, -0.15443261f, 0.42705095f, -0.02404397f, 0.14614423f, 0.08001532f, -0.15626973f, -0.17582642f, 
    0.16812399f, 0.06384456f, 0.06050545f, 0.07411415f, 0.06804930f, 0.06679966f, -0.39368206f, 0.11308472f, 
    0.06494343f, -0.02199573f, 0.29014409f, 0.02076673f, -0.01051355f, -0.04625427f, 0.08956664f, 0.06566972f, 
    0.14712122f, -0.14220570f, 0.12618665f, -0.51397198f, -0.00602773f, -0.15530951f, 0.04104485f, 0.23356977f, 
    -0.11902777f, 0.02450374f, -0.09201234f, -0.09579178f, 0.14365849f, 0.35653755f, -0.04811687f, -0.02284557f, 
    0.14060982f, -0.09328872f, 0.12530485f, 0.04719677f, 0.10962920f, -0.08503270f, -0.09695058f, -0.10495195f, 
    -0.24824941f, -0.38991603f, 0.12145434f, -0.08748748f, -0.22290820f, -0.03315636f, -0.03060095f, -0.06783857f, 
    0.12499344f, -0.04938508f, 0.04594711f, -0.04862300f, 0.28706446f, 0.03037138f, 0.26730129f, 0.18347529f, 
    0.02661675f, -0.05467622f, -0.11610492f, -0.16355833f, -0.14233418f, 0.08316814f, 0.04531671f, 0.09460041f, 
    0.06844981f, -0.08262531f, 0.17255160f, -0.08505602f, 0.20881945f, 0.01535126f, 0.08292135f, 0.18988810f, 
    -0.01316955f, -0.03582866f, -0.12664002f, -0.06261037f, 0.03059771f, -0.17185870f, -0.07398390f, -0.15603042f, 
    -0.12177601f, 0.10317935f, 0.11404622f, 0.05944725f, 0.11155100f, 0.03720648f, 0.02196303f, -0.09401567f, 
    -0.59352505f, 0.03890960f, 0.60671610f, -0.29199839f, 0.11597080f, 0.01963630f, 0.03036932f, 0.27330416f, 
    0.12386530f, 0.13695179f, 0.08207588f, -0.03183757f, -0.42656025f, 0.15024059f, -0.44868523f, -0.10474731f, 
    -0.28322041f, 0.26849324f, -0.43451419f, 0.00449542f, 0.16037230f, -0.22374737f, 0.08534639f, 0.08133564f, 
    -0.68887377f, 0.25370356f, -0.38474661f, 0.12815732f, 0.05813543f, 0.22113508f, -0.02146842f, -0.02701918f, 
    -0.12403978f, 0.10477664f, 0.03302724f, 0.25287241f, 0.05230237f, -0.01926325f, 0.27033597f, -0.32570738f, 
    -0.22375587f, 0.07354315f, 0.26096007f, -0.17721096f, -0.14854553f, 0.03720320f, 0.18826728f, 0.33035412f, 
    -0.13006942f, -0.14353460f, -0.36993498f, -0.36551276f, -0.12077887f, -0.16753563f, 0.01595910f, -0.23978913f, 
    -0.10797849f, 0.13698988f, 0.22387210f, 0.15418094f, 0.11132342f, -0.09220674f, 0.07194220f, 0.06602735f, 
    -0.12358112f, -0.22719586f, 0.07338948f, 0.00594950f, -0.01519118f, -0.17725533f, 0.00469517f, 0.19322318f, 
    0.29070616f, -0.23201585f, 0.66639537f, 0.36043417f, -0.14371362f, 0.03994046f, 0.21547037f, 0.14253433f, 
    0.09305591f, -0.07437635f, 0.22765242f, 0.14279863f, -0.06989719f, 0.33329248f, -0.35032570f, -0.04108174f, 
    -0.09577756f, 0.26199612f, -0.11750994f, -0.23543024f, 0.01732176f, 0.01096948f, 0.09349117f, 0.03212389f, 
    -0.08168871f, 0.30490887f, 0.03107442f, -0.19993775f, 0.16012740f, -0.19296126f, -0.22644548f, -0.10732721f, 
    -0.04770660f, 0.11212552f, 0.06171694f, -0.24546541f, 0.03664882f, -0.09534690f, -0.18418002f, -0.17501250f, 
    0.09433971f, -0.20263214f, 0.13710135f, -0.20131369f, -0.10515190f, -0.08351514f, -0.17974246f, -0.10390226f, 
    0.09290030f, -0.52213842f, -0.10771502f, -0.44607252f, -0.51589936f, -0.17386431f, 0.07247698f, 0.15628582f, 
    0.14036332f, 0.10321169f, 0.05071978f, 0.03087964f, -0.04479885f, 0.29965445f, -0.22849685f, 0.53789079f, 
    -0.08244759f, 0.00975031f, -0.00326495f, -0.14022419f, 0.00239363f, 0.23681803f, -0.20951003f, 0.01333258f, 
    0.24847800f, 0.12526911f, 0.32053286f, -0.28827289f, -0.11224046f, 0.09053838f, -0.01274348f, 0.06128190f, 
    -0.09543043f, -0.10709479f, -0.40495092f, -0.76454949f, -0.38490003f, -0.01414001f, -0.13293903f, 0.11432769f, 
    -0.16258596f, 0.16498090f, -0.08715249f, 0.01932569f, 0.04260113f, 0.13305295f, 0.09945659f, 0.17173341f, 
    -0.36051694f, 0.24580643f, -0.49967045f, 0.11637358f, 0.04572447f, -0.28375724f, 0.14438479f, 0.09504773f, 
    -0.14057443f, 0.16928577f, -0.09283215f, -0.17686580f, -0.09295736f, -0.40819710f, -0.05254749f, -0.31085822f, 
    -0.33492392f, -0.12264899f, -0.11496917f, -0.00522775f, 0.12917584f, 0.08531891f, 0.05532497f, -0.10190615f, 
    0.06338370f, 0.13731030f, 0.19315013f, 0.24624217f, 0.03198346f, -0.23336539f, 0.12532210f, 0.12382357f, 
    -0.01035412f, 0.22022326f, -0.00970286f, -0.04635483f, -0.31716663f, 0.13781102f, 0.17424779f, -0.35379419f, 
    -0.02092999f, -0.00902556f, -0.05495889f, 0.17573400f, -0.00775924f, 0.02524155f, 0.15833910f, 0.04846678f, 
    -0.06493688f, 0.27309746f, 0.12781467f, 0.27453104f, 0.01283166f, 0.03715231f, -0.38964683f, 0.12599590f, 
    -0.00804446f, -0.21278839f, -0.32433507f, -0.20481217f, -0.14698449f, 0.58595586f, 0.31715029f, 0.02909866f, 
    0.04762912f, 0.12389258f, -0.29102930f, 0.19206755f, 0.01016381f, 0.09544590f, -0.03671339f, 0.10766992f, 
    -0.29757062f, -0.53730524f, -0.12823315f, 0.14094985f, -0.05919127f, 0.09007902f, 0.45629820f, -0.29754826f, 
    -0.07320429f, 0.18133418f, -0.11868136f, 0.04913547f, 0.04193575f, -0.03745243f, 0.09974723f, 0.35548383f, 
    0.03755186f, 0.17177472f, 0.03043093f, -0.03113776f, 0.09585163f, -0.04560573f, 0.17263445f, -0.05506377f, 
    0.21407892f, -0.07112435f, 0.43650943f, -0.12744236f, -0.04127729f, 0.05164839f, -0.13107601f, -0.08557529f, 
    0.08027823f, -0.00324758f, 0.06581059f, -0.18873678f, 0.15947044f, -0.17811349f, -0.06454322f, 0.56301403f, 
    -0.12470170f, 0.05137578f, 0.07426358f, -0.09409693f, -0.20499580f, 0.01033680f, -0.33620414f, 0.09467974f, 
    -0.38725725f, 0.01093675f, -0.15147810f, -0.18119386f, -0.10490643f, 0.11113486f, 0.00475293f, 0.22664604f, 
    -0.06249939f, 0.09287713f, -0.16729018f, -0.36065978f, 0.03139542f, 0.05280609f, -0.09927171f, 0.01879435f, 
    -0.33068034f, -0.07389604f, 0.03344493f, -0.06411501f, -0.10123345f, -0.12379090f, -0.25716344f, -0.20450012f, 
    -0.09181799f, -0.22451317f, 0.28635314f, 0.33094382f, -0.00674630f, -0.02727972f, -0.12549932f, -0.06900816f, 
    0.12189145f, 0.02726259f, 0.02294659f, 0.07178945f, -0.39211690f, -0.25048140f, -0.27640757f, 0.23422305f, 
    -0.12414740f, -0.02584077f, 0.10774927f, 0.15427437f, -0.42195824f, 0.14073415f, -0.10826957f, 0.14624165f, 
    -0.12986661f, -0.09211227f, -0.41700879f, 0.03752012f, -0.01310296f, -0.34222832f, 0.15339927f, -0.09737283f, 
    -0.18933071f, 0.14116989f, -0.12032288f, -0.09834223f, -0.23035917f, 0.24361193f, -0.30763072f, 0.12249425f, 
    0.12934479f, -0.05834007f, 0.01521884f, 0.00684272f, -0.03283656f, -0.22279412f, -0.36088172f, -0.54965669f, 
    -0.11213121f, -0.04787019f, 0.25607350f, 0.13610019f, -0.19811291f, 0.02955190f, -0.13406384f, 0.26438865f, 
    0.18950497f, -0.04933530f, 0.30099770f, 0.34668383f, 0.16296464f, 0.23599240f, -0.02339656f, 0.32295230f, 
    -0.19542155f, -0.21787281f, 0.15453972f, -0.09195525f, -0.29888096f, -0.18378270f, -0.03558798f, 0.16005799f, 
    -0.25952259f, -0.68007618f, -0.15643165f, -0.03115282f, 0.05627908f, -0.08409197f, -0.06322502f, 0.04899848f, 
    -0.13620158f, -0.09626411f, 0.00003784f, -0.26692683f, 0.42390531f, -0.07868696f, 0.14965984f, -0.23144227f, 
    0.11529557f, -0.15935439f, -0.03114788f, 0.29338670f, -0.26409250f, 0.13176234f, 0.11601091f, 0.06925423f, 
    0.07457886f, -0.22300471f, 0.22996706f, 0.42382544f, -0.04136053f, -0.20047611f, -0.18867086f, -0.21141452f, 
    0.00560844f, -0.10201867f, 0.09315462f, -0.26971173f, -0.09175892f, -0.29906428f, 0.04370800f, -0.04382285f, 
    -0.00724440f, 0.09555950f, 0.18495458f, 0.11379771f, -0.08112425f, 0.17717548f, -0.03651310f, -0.27588281f, 
    -0.00456658f, 0.35405445f, -0.22601853f, -0.08013123f, -0.06775507f, 0.00982605f, 0.00227006f, 0.14315042f, 
    -0.10383619f, -0.33388057f, -0.11839866f, -0.28716400f, -0.19538081f, -0.02448148f, 0.37871754f, -0.11054639f, 
    -0.07280873f, 0.11316328f, -0.09806181f, -0.11866635f, -0.18692327f, -0.01048514f, 0.14300799f, -0.02635879f, 
    0.20513885f, -0.28288928f, 1.04326963f, -0.83428383f, 0.12838095f, -0.00401303f, -0.20702338f, 0.15169281f, 
    -0.02848372f, 0.22080714f, 0.09207127f, 0.02337055f, 0.37119022f, -0.26887402f, 0.35784566f, 0.31611583f, 
    0.03671706f, -0.15617247f, 0.14020123f, 0.00740293f, -0.16778103f, 0.13483231f, 0.05018569f, 0.01785212f, 
    -0.69288838f, -0.25070667f, -0.63568592f, 0.10760041f, 0.09534592f, -0.00595843f, 0.04196903f, 0.04680347f, 
    -0.09747828f, -0.05091893f, 0.09913018f, -0.04300440f, 0.31663910f, 0.04867488f, 0.20949991f, -0.24986869f, 
    -0.02941447f, -0.08621985f, -0.17852846f, 0.13087365f, 0.07552579f, 0.00458988f, -0.09658224f, 0.13710491f, 
    0.31551343f, 0.21966408f, 0.48951879f, -0.24372692f, -0.08876698f, 0.04658473f, -0.03136510f, -0.07884835f, 
    -0.12909937f, -0.15520045f, -0.05661040f, -0.15016589f, -0.13089149f, -0.61388093f, 0.43639350f, 0.34422347f, 
    -0.01559921f, -0.05879937f, -0.06168753f, 0.09508991f, -0.01744629f, -0.03455715f, -0.00709397f, 0.14813976f, 
    0.37736824f, -0.39931396f, 0.10702249f, -0.19169059f, 0.25814393f, -0.06664008f, -0.14019732f, 0.22087778f, 
    0.02968299f, 0.21054751f, 0.33403343f, 0.16245416f, -0.15184563f, -0.63586724f, -0.18014453f, 0.33541873f, 
    -0.22613409f, -0.42223144f, 0.11258368f, -0.20988153f, 0.09163380f, 0.02073744f, 0.12750137f, -0.05914279f, 
    -0.12725222f, 0.43733478f, -0.05628970f, -0.10708325f, -0.15355575f, -0.05641451f, 0.23972334f, 0.06461532f, 
    -0.01100635f, 0.08758260f, 0.02201338f, 0.12947591f, 0.74756193f, 0.16020863f, 0.32382181f, -0.37911949f, 
    -0.20292477f, 0.05014690f, -0.27799746f, 0.15348102f, -0.15531030f, -0.05795074f, -0.05089740f, -0.08845268f, 
    -0.21396621f, 0.24629006f, 0.02343102f, -0.28539029f, -0.05525184f, -0.00220947f, 0.22240062f, -0.19108610f, 
    -0.02219211f, 0.00216346f, -0.09778412f, -0.16208832f, 0.57361168f, 0.00922542f, 0.34933120f, 0.16913827f, 
    0.21961492f, 0.10547393f, 0.02154820f, 0.09413666f, 0.02215594f, -0.02529295f, 0.09229934f, -0.10927370f, 
    -0.74442023f, 0.30923948f, -0.37275484f, 0.15369223f, -0.28334561f, 0.06726189f, 0.25939128f, 0.19531550f, 
    -0.00410529f, 0.10751522f, 0.00487702f, 0.11483271f, -0.33242947f, -0.18934618f, 0.29562208f, 0.18978256f, 
    0.36410314f, 0.27311593f, -0.03336358f, 0.03513759f, -0.08024757f, -0.14486685f, -0.04765993f, -0.00032850f, 
    0.38581854f, -0.59167355f, 0.39616939f, -0.33263013f, -0.01688441f, -0.25797361f, -0.09857154f, 0.06715620f, 
    0.09165134f, -0.03550142f, 0.16771847f, 0.09055701f, -0.92755538f, -0.27557135f, -0.17663848f, 0.45615438f, 
    -0.46068445f, -0.06067839f, 0.08457309f, -0.00249498f, 0.01147277f, 0.06781925f, 0.14581417f, -0.03013557f, 
    -0.22170514f, -0.11420691f, -0.09429120f, -0.09159409f, -0.10677233f, -0.10692974f, 0.13665877f, 0.11326495f, 
    -0.10214352f, 0.07762725f, -0.25305930f, 0.07134402f, -0.02771213f, -0.05843692f, 0.26299658f, -0.05558554f, 
    -0.01207447f, -0.04466252f, -0.07860600f, 0.10838915f, -0.24982417f, -0.04050802f, 0.27900246f, 0.22727910f, 
    0.01862457f, 0.14750077f, 0.02832905f, -0.65834564f, 0.09202657f, 0.00517211f, 0.11263942f, -0.07475512f, 
    0.08465033f, 0.21462655f, 0.34341004f, -0.00229783f, 0.25985342f, -0.12647617f, 0.11068086f, -0.13467282f, 
    0.05015054f, -0.01166236f, 0.10722689f, 0.14302312f, 0.12787895f, 0.21785948f, 0.13263790f, 0.15763025f, 
    -0.09063564f, -0.00747398f, -0.15508217f, 0.15198755f, -0.20551351f, -0.07695100f, -0.27076042f, -0.15476550f, 
    -0.02020676f, 0.02758210f, -0.12047885f, -0.03018421f, 0.32774100f, 0.04183426f, 0.61472642f, -0.10049260f, 
    0.13070628f, 0.20748174f, 0.25043464f, -0.01681170f, -0.19088301f, 0.00058694f, 0.28227094f, 0.04270235f, 
    0.00879580f, -0.22459972f, 0.34040573f, -0.25623468f, 0.06412116f, -0.00081160f, -0.07140830f, -0.17016985f, 
    -0.04792865f, 0.01321623f, 0.07996432f, -0.02194637f, -0.38382700f, -0.27724218f, -0.23663525f, -0.00442442f, 
    0.01120287f, -0.20946079f, -0.06730371f, -0.06827608f, -0.06688201f, 0.05333092f, 0.16281630f, 0.10326868f, 
    -0.09334908f, -0.08221834f, 0.07961763f, -0.24940659f, 0.06301788f, -0.00738537f, -0.05557245f, 0.19432126f, 
    -0.23552321f, -0.01981297f, -0.10616953f, -0.45752874f, -0.12776853f, 0.12726030f, 0.05798118f, 0.07725140f, 
    -0.17946894f, 0.04308959f, -0.02155038f, -0.08266307f, -0.19938788f, -0.01287835f, 0.15234569f, -0.10747086f, 
    -0.20767960f, -0.09493329f, -0.30574918f, 0.14739394f, 0.11577222f, -0.00794791f, -0.04493785f, -0.11239009f, 
    0.03042134f, 0.12032826f, -0.07984719f, -0.05466230f, -0.76725709f, 0.25191373f, -0.57122350f, 0.41925025f, 
    -0.00014340f, -0.12571527f, 0.14936797f, -0.41686153f, -0.10337309f, -0.19626899f, -0.22096433f, 0.04026512f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.25765780f, 0.08789211f, 0.11869397f, -0.04840197f, -0.10310874f, 0.12549214f, 0.08882372f, -0.20829999f, 
    0.10420351f, 0.05223168f, 0.02237302f, -0.02158933f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1536);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
