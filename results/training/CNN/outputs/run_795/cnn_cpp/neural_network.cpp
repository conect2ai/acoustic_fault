#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.17871065f, -1.54495585f, -0.73816693f, -0.54834485f, -0.75881672f, -0.29426745f, -0.35521513f, 0.41581932f, 
    0.06893699f, -0.95235151f, -0.69647497f, -0.76136839f, -0.22276564f, 1.19322276f, -0.26253408f, 0.24254335f, 
    -0.09552872f, -0.81814474f, 0.67939061f, 0.65530705f, 0.17004642f, 0.43075141f, -0.17387855f, 0.99637282f, 
    0.56434429f, 0.47595969f, 0.76533616f, 1.21069014f, -1.19009089f, -0.84157521f, -0.80774295f, -0.21547697f, 
    0.73121041f, -0.00555733f, 0.02623223f, 0.71033245f, 1.44107497f, 0.81330794f, 0.94262356f, -0.70736355f, 
    -0.48525733f, 0.24024263f, -0.27465111f, -0.31787866f, -0.00916617f, -1.24886858f, -1.02008939f, -1.17851806f, 
    -0.56796432f, 0.60154754f, 1.05380297f, 0.43034422f, -0.12746689f, 0.28738788f, -0.72301072f, 1.23122048f, 
    0.12376397f, -0.75837785f, -0.40221950f, -1.03982401f, -0.01644210f, -0.25203300f, 0.00767149f, 1.53665280f, 
    0.01613303f, -1.29870725f, 0.29666424f, 0.70959467f, -0.59267163f, 0.01135769f, 0.05682520f, -0.29106686f, 
    0.37714571f, -1.00372016f, 0.40395769f, 1.16371727f, -0.33326292f, 0.78394455f, 0.29157272f, 0.31001255f, 
    -0.43941700f, -1.15395069f, -0.75296408f, -0.41006607f, 0.52287084f, 0.86327600f, 0.64192200f, -0.33437768f, 
    -0.55172145f, -0.04473644f, 0.86326814f, 1.16028690f, -0.86938524f, -0.12991525f, 0.27687904f, 0.31609273f, 
    0.62426841f, 0.35987651f, -0.37182510f, -1.15942407f, -1.16279078f, -0.12064762f, -0.16310327f, -0.81535912f, 
    -0.91105437f, 0.17192340f, 0.38713428f, 0.25470287f, 0.82041305f, 0.68347687f, 1.18970478f, 0.42482495f, 
    -1.03288209f, 0.22074679f, 0.36574736f, 0.14119315f, 0.20510007f, 0.05468163f, 0.63310403f, -0.69107431f, 
    -0.62988055f, -1.27646708f, 0.39001244f, 0.51847309f, -0.56126958f, -0.19303013f, 0.85965842f, -1.07621765f, 
    1.11241603f, 0.57978082f, 0.34048927f, 0.24987736f, -1.00060081f, -0.06433466f, 0.06819839f, -0.87474924f, 
    -0.85786062f, 0.35074583f, -1.04535544f, -0.27558720f, -0.44369385f, 0.58597863f, 0.57101768f, 0.09474070f, 
    0.39668965f, 0.15648511f, -0.76000249f, -0.92553771f, 0.92996711f, -0.70492697f, 0.59219110f, -0.29601592f, 
    0.60482335f, 0.79145324f, 0.87923944f, 0.26552016f, -0.83737934f, -0.90538085f, -0.60227698f, -0.31813142f, 
    -0.25671723f, 0.53399885f, -0.25698358f, -1.02728891f, -0.83221459f, 0.91731185f, 0.19738829f, 0.02996845f, 
    -0.81754702f, -0.05395283f, -0.51302528f, -0.45182207f, -0.90427965f, -0.80229139f, 0.93653190f, 1.08771908f, 
    0.64158219f, 0.27002570f, 0.51698524f, -0.16398986f, 0.39284912f, 1.19187117f, 0.05890075f, 0.50313634f, 
    -0.90379405f, -0.59853220f, 0.76709986f, -0.25252947f, 0.31489772f, -0.12345415f, -0.80233192f, -0.84115195f, 
    -0.97183639f, 0.03564207f, -0.90340078f, -0.79584789f, -0.42300045f, -0.68801069f, 1.15910423f, 1.18102777f, 
    0.03826137f, 0.12029121f, -0.49875838f, 0.16480795f, -0.57464373f, 0.76724231f, -0.08859154f, -0.69376069f, 
    -0.95539021f, 0.87525189f, 1.19391978f, -0.42646784f, 0.47943375f, 0.57209921f, -0.56471646f, 0.63572806f, 
    0.13128096f, 1.20390403f, -1.18217576f, 0.80387396f, -0.71515220f, 0.18991193f, 0.09653101f, 0.28062719f, 
    0.24179590f, -1.39835441f, 0.74333358f, 0.87263787f, 0.74898756f, 0.77802581f, 0.26642618f, 0.51310766f, 
    0.67731220f, -0.03799448f, 0.56887597f, -1.03960490f, 0.31069168f, 0.01324452f, 0.37687600f, 0.76964068f, 
    -0.38656995f, -0.90475023f, -0.68778938f, 0.31023848f, 0.16946039f, 0.61697334f, -1.00604427f, -0.89082032f, 
    -0.67263663f, 0.21866888f, 0.57237482f, 0.34039158f, 0.76344037f, 1.03699994f, 1.13948202f, 1.01819289f, 
    1.02164221f, 0.95715988f, -0.32569599f, -0.05213603f, -0.06333570f, -0.79272771f, 0.62538213f, -0.37528446f, 
    0.81683099f, 1.58396208f, -0.66763544f, -0.34042087f, 0.07653475f, -0.03232839f, 0.45873442f, -0.53324026f, 
    -0.76918447f, -0.15472074f, -1.12828326f, -0.82157320f, -0.22931910f, -0.35815141f, 0.63214219f, -0.25385886f, 
    0.66192132f, -0.25036618f, 1.06531477f, -0.28543827f, -1.62932134f, 0.21206771f, 0.48525649f, 0.48857147f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.32232398f, 0.02268136f, 0.08480730f, -0.14321457f, 0.35580200f, 0.26212156f, 0.16499399f, -0.05237236f, 
    -0.16286774f, 0.12465408f, -0.00542144f, 0.26923195f, 0.00424843f, -0.04124620f, 0.33004451f, -0.12914871f, 
    0.16734403f, -0.02291237f, -0.21173966f, 0.02030897f, -0.06190949f, -0.32652631f, 0.36758190f, -0.34147820f, 
    -0.26845080f, -0.02435888f, 0.16691001f, 0.39539126f, 0.56502968f, -0.16561444f, 0.18821725f, 0.12058587f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    0.02368361f, -0.01285751f, 0.00156231f, -0.01035069f, -0.06198483f, 0.04826063f, 0.03475894f, 0.04557520f, 
    0.01333751f, -0.03005525f, -0.04926963f, 0.05466153f, -0.03682036f, -0.02947082f, -0.02455077f, 0.04619072f, 
    -0.05994026f, -0.04850675f, -0.04465755f, -0.05297630f, -0.04696985f, 0.04074926f, -0.05120159f, -0.00263854f, 
    -0.01882255f, -0.05173601f, 0.04696129f, -0.00543871f, -0.01578978f, -0.01334886f, -0.06668940f, 0.05252215f, 
    -0.01445064f, 0.01497734f, 0.04537110f, 0.03147608f, 0.06649303f, -0.00534590f, 0.03349724f, 0.02870438f, 
    0.00340684f, -0.02179765f, 0.03742534f, -0.02278649f, 0.02278223f, 0.00466028f, 0.05294114f, -0.04026049f, 
    -0.04358222f, 0.04413568f, -0.05434125f, 0.03674933f, -0.00660061f, -0.02369283f, -0.05910619f, 0.03723857f, 
    -0.04921287f, 0.01385313f, -0.02073648f, 0.03181058f, -0.02182848f, 0.04946706f, -0.04448800f, -0.04076049f, 
    -0.05650537f, 0.02265823f, 0.00509805f, -0.01547975f, 0.00157384f, -0.01763643f, 0.05593693f, -0.03163132f, 
    0.00012597f, -0.05312472f, -0.05040383f, 0.00534803f, -0.05648232f, -0.04970457f, -0.00665662f, 0.00269426f, 
    0.00605720f, -0.05734149f, -0.04756973f, -0.03347535f, 0.04923030f, 0.05828897f, -0.03468585f, 0.01162884f, 
    -0.01867108f, 0.03341582f, 0.04528742f, 0.04819750f, -0.00888603f, 0.03309241f, 0.01308045f, -0.03767919f, 
    -0.01628183f, -0.00793155f, -0.00147917f, 0.00175938f, 0.01682047f, -0.03304074f, 0.02246490f, 0.02041721f, 
    -0.02048086f, 0.01075564f, 0.03566046f, -0.02259444f, 0.04166504f, -0.04547686f, 0.00903096f, 0.04914013f, 
    -0.05707311f, -0.03796215f, 0.05423918f, -0.03430493f, -0.04022422f, 0.03581648f, -0.04030894f, -0.02616604f, 
    -0.05524208f, -0.04792105f, -0.03988526f, 0.00756513f, -0.04069252f, -0.02815254f, 0.03744170f, 0.01805986f, 
    0.02204961f, 0.01661818f, -0.00787339f, -0.01648892f, -0.05855404f, 0.04453788f, 0.00805707f, -0.05710723f, 
    0.02795835f, -0.00462408f, -0.04154945f, 0.00589105f, 0.00284709f, -0.03735784f, 0.00566413f, 0.00947572f, 
    -0.02743432f, 0.05794097f, 0.00578676f, -0.05217648f, -0.01649214f, 0.03525914f, 0.04703632f, -0.01094207f, 
    -0.05219170f, 0.01370212f, 0.01464458f, -0.01746585f, -0.04507754f, 0.04575091f, 0.01313634f, 0.03908581f, 
    -0.03028925f, -0.04496912f, -0.03631712f, -0.03939129f, 0.01578316f, -0.04434571f, 0.01963296f, 0.05929868f, 
    -0.01206042f, 0.00837819f, 0.02969067f, 0.00246107f, -0.03176893f, 0.05017302f, -0.04648915f, -0.03825284f, 
    0.04007741f, -0.03023376f, -0.06269854f, -0.01263851f, -0.03074424f, 0.05490325f, 0.01544918f, -0.03661966f, 
    -0.04041709f, -0.02259316f, 0.03119143f, -0.01588911f, 0.05308424f, 0.02727626f, 0.03691315f, 0.03886212f, 
    -0.05039310f, 0.01886698f, 0.02233578f, -0.04977537f, -0.04762561f, -0.05164484f, 0.01228749f, -0.06219671f, 
    -0.02751089f, -0.03881127f, 0.00333275f, -0.04505120f, -0.03747889f, -0.01211110f, 0.02659813f, 0.00122753f, 
    -0.01082755f, 0.01263090f, -0.05272309f, -0.04564887f, -0.03692877f, 0.01752129f, -0.00867462f, -0.06316917f, 
    -0.03247212f, -0.02857581f, -0.03731271f, -0.03223528f, 0.00885948f, -0.03451079f, 0.01206706f, 0.04180727f, 
    -0.02945807f, -0.00315956f, 0.03634831f, -0.03160273f, 0.00583009f, -0.04947131f, -0.00693420f, -0.02001669f, 
    -0.03318970f, 0.03005340f, 0.02092136f, 0.03930109f, -0.03830759f, -0.00955673f, 0.05611348f, 0.03497941f, 
    -0.03886106f, -0.02540397f, -0.01174448f, 0.04439118f, -0.03040841f, 0.03413220f, -0.00477138f, 0.05154007f, 
    0.00817440f, 0.00993301f, 0.01092458f, -0.04208512f, -0.03857694f, 0.00120928f, 0.05064914f, -0.04386260f, 
    0.02503097f, -0.05495708f, -0.01770272f, -0.00337019f, -0.01870115f, 0.03225034f, 0.04764596f, -0.03932052f, 
    0.05727061f, 0.05288409f, 0.00779843f, 0.01378612f, -0.00185564f, -0.01461777f, 0.00701038f, -0.02836806f, 
    0.02475556f, -0.01444553f, -0.05101647f, -0.04060058f, 0.03938836f, 0.02164039f, -0.00991064f, -0.03550580f, 
    0.01455400f, 0.02352611f, -0.00101696f, 0.00947817f, -0.03490289f, -0.04695306f, -0.02536169f, 0.05355949f, 
    0.09785938f, 0.12151901f, 0.32778665f, 0.00403675f, -0.16651452f, 0.09479567f, -0.00891342f, 0.02182344f, 
    0.05227834f, 0.32540512f, -0.05055622f, -0.15799816f, 0.07628013f, -0.06820184f, 0.00350211f, -0.02442510f, 
    0.18858418f, -0.04675796f, -0.50376648f, 0.05695420f, -0.14993852f, 0.01762916f, 0.18968543f, -0.00753561f, 
    -0.11788298f, -0.11465900f, -0.03512063f, 0.27369332f, -0.26000935f, 0.00472390f, 0.04203413f, 0.02453104f, 
    -0.00337690f, -0.03143999f, -0.06438805f, -0.10715135f, -0.69471431f, 0.27487871f, -0.09554258f, -0.11076730f, 
    0.31938317f, 0.18952852f, -0.11155870f, 0.08171182f, -0.05651075f, 0.46028683f, -0.05253414f, 0.20765042f, 
    0.02649515f, -0.21595392f, 0.02848830f, -0.05913085f, 0.00761496f, 0.09708944f, 0.54653901f, 0.21783988f, 
    -0.33070073f, 0.04916056f, 0.22385347f, 0.04417047f, -0.05212243f, 0.03499672f, 0.07027675f, 0.04241977f, 
    -0.40081728f, -0.13324653f, -0.08966572f, -0.07460698f, 0.11515302f, 0.04237490f, -0.24608506f, -0.06240509f, 
    0.07459223f, 0.13940834f, 0.28954548f, 0.15587448f, -0.06650762f, 0.00394132f, -0.12243515f, -0.01553503f, 
    0.03156627f, 0.30228209f, -0.01553912f, -0.11906613f, -0.13781251f, -0.28975251f, -0.01961459f, 0.07606776f, 
    0.05887441f, 0.02537699f, -0.17818882f, -0.42525828f, -0.28603444f, -0.12623590f, -0.11552931f, 0.19069818f, 
    0.09641432f, 0.19746335f, -0.01742012f, 0.28539330f, -0.10561571f, 0.07297450f, -0.12326046f, -0.14547065f, 
    -0.03332712f, 0.03290477f, 0.08058074f, 0.15072952f, -0.72259140f, 0.06590100f, -0.10360711f, 0.05073929f, 
    0.28558904f, -0.13872476f, -0.24480541f, 0.00466421f, 0.05719987f, -0.49926013f, -0.20244598f, -0.10200627f, 
    -0.01386345f, 0.07429200f, -0.08974513f, -0.05325341f, 0.01080423f, -0.07538605f, -0.08590800f, 0.09224124f, 
    0.12879552f, 0.17809291f, 0.22202256f, -0.09354544f, 0.04919973f, 0.14738643f, -0.02478036f, 0.41626346f, 
    0.07196603f, 0.20425604f, 0.01400050f, -0.19046181f, -0.00049966f, -0.20424162f, 0.11126906f, 0.02201704f, 
    0.08916315f, 0.15781377f, -0.20293210f, 0.11090246f, 0.18039742f, 0.17488879f, -0.12640209f, -0.09027341f, 
    -0.06775238f, -0.11071671f, 0.35110039f, -0.03362145f, 0.08422780f, 0.08798102f, 0.03428876f, -0.16799618f, 
    0.10746502f, -0.02657057f, 0.17364666f, -0.04462254f, 0.18772298f, 0.06538118f, 0.09552274f, -0.03248844f, 
    0.13317727f, -0.01689122f, 0.04532595f, 0.40210637f, -0.01418538f, -0.00502411f, 0.06291842f, 0.01492627f, 
    -0.08360182f, 0.03185881f, 0.09361916f, 0.26124021f, -0.19069205f, 0.18789610f, -0.12872173f, 0.03777348f, 
    0.31822696f, 0.13459897f, -0.23238961f, 0.23907433f, 0.02490121f, -0.51110452f, -0.09734041f, 0.23389292f, 
    0.09266376f, 0.26408267f, 0.12874065f, -0.09939919f, -0.33007157f, 0.10178665f, -0.60970169f, 0.00066354f, 
    0.12828194f, 0.04032844f, -0.09056818f, 0.18185641f, -0.07042153f, 0.06037013f, -0.09196492f, 0.22944814f, 
    0.07752091f, -0.12726872f, -0.05872645f, 0.07603528f, -0.19348378f, -0.04686293f, 0.00150874f, -0.06461441f, 
    -0.06792622f, -0.23314753f, 0.01979765f, 0.03611057f, 0.15721169f, 0.02194705f, -0.12774277f, -0.10748453f, 
    -0.26235485f, 0.49096188f, -0.01403416f, -0.23753114f, -0.31435242f, -0.00429976f, -0.08777669f, 0.16427627f, 
    -0.01893493f, -0.03753404f, 0.04254604f, -0.01173795f, -0.14311203f, 0.00711490f, 0.02285815f, -0.04925898f, 
    0.02586557f, -0.21614295f, -0.14065203f, 0.16258632f, 0.35632765f, -0.17012426f, 0.17779869f, 0.01601193f, 
    -0.15524916f, -0.29112872f, 0.04063948f, -0.07836228f, -0.65524989f, 0.07824044f, 0.05633971f, -0.15231581f, 
    0.09733007f, 0.11015799f, 0.01609939f, 0.03842613f, -0.02260995f, 0.04272549f, 0.00009352f, -0.02934276f, 
    0.08154701f, -0.04206497f, -0.09754340f, 0.29607472f, 0.06597755f, 0.18206100f, 0.02457262f, -0.01346394f, 
    0.14483108f, 0.34635302f, -0.13077295f, -0.09716653f, -0.12488106f, 0.05988827f, 0.25324905f, 0.16356824f, 
    0.09776971f, -0.35248694f, 0.02668726f, 0.05201003f, 0.01987946f, -0.07932963f, 0.08941177f, 0.21071111f, 
    -0.00872510f, 0.01549981f, -0.04730992f, -0.00764003f, 0.04518460f, -0.06392492f, -0.04579072f, 0.00462722f, 
    0.04780905f, -0.04992488f, 0.01666329f, 0.00669502f, 0.01076343f, -0.05066466f, -0.03439808f, -0.04798979f, 
    0.04309579f, -0.00467539f, -0.01522199f, 0.02291611f, -0.01729663f, 0.05980932f, -0.05786889f, 0.05243910f, 
    0.00203700f, 0.03640987f, 0.03398259f, -0.02003863f, -0.00543649f, 0.02602743f, 0.03273981f, -0.01296813f, 
    0.04875595f, 0.02094664f, -0.03300925f, -0.03596370f, -0.00188564f, 0.02851269f, -0.02572227f, 0.02149974f, 
    -0.04542924f, 0.03395010f, 0.01945494f, -0.03746367f, -0.00044852f, -0.03715654f, -0.02130434f, 0.00722476f, 
    -0.04555018f, 0.00062154f, 0.01432220f, 0.02817980f, 0.05259624f, 0.03362883f, 0.01495195f, -0.04504215f, 
    0.03900225f, -0.03695436f, -0.00663287f, 0.06084777f, -0.04608158f, 0.04289057f, -0.01219724f, 0.00331001f, 
    -0.01204487f, 0.03547662f, -0.06250975f, 0.03060114f, -0.04955649f, 0.01434358f, -0.05754573f, -0.05102425f, 
    -0.00389616f, -0.05075511f, 0.00309144f, -0.03478243f, -0.03415555f, 0.01737221f, 0.03620710f, -0.00917810f, 
    0.00519715f, -0.05310477f, 0.05207444f, 0.03881123f, 0.01767874f, -0.05384184f, 0.02105789f, 0.02822748f, 
    -0.03854129f, 0.03921130f, 0.05485827f, -0.02536685f, 0.00886978f, 0.00016322f, -0.03398614f, 0.01464684f, 
    0.04861554f, -0.03112119f, -0.00095497f, 0.04384694f, 0.03847047f, 0.02920571f, 0.04806529f, 0.04252045f, 
    0.02655808f, -0.04329297f, -0.04478465f, -0.04297732f, 0.00307241f, -0.06439988f, 0.05067389f, 0.04487105f, 
    -0.05690358f, -0.03122109f, 0.02424070f, -0.04772510f, -0.00915257f, -0.04315984f, 0.01515973f, -0.00402344f, 
    -0.02876898f, -0.04673124f, -0.01951160f, -0.02009085f, 0.03052410f, -0.02167215f, -0.02901282f, -0.00340451f, 
    -0.02164450f, -0.04366995f, 0.03994525f, -0.06460646f, 0.02091118f, -0.05698589f, -0.05170033f, -0.03839075f, 
    -0.05890440f, -0.00854075f, 0.04678290f, 0.01848182f, -0.02409017f, -0.01179288f, -0.05615443f, -0.04202849f, 
    0.00490643f, -0.00437471f, -0.02553728f, 0.01833242f, -0.03265401f, -0.04532008f, -0.02154800f, -0.00818595f, 
    -0.03319957f, 0.02393539f, 0.02906202f, -0.02944940f, -0.02049637f, 0.01472088f, -0.00410249f, -0.00665013f, 
    -0.05665959f, -0.01029138f, -0.01203465f, 0.04842163f, -0.05889742f, 0.01516441f, -0.06423117f, -0.01020288f, 
    0.00396625f, -0.04404518f, -0.03886980f, -0.02130737f, -0.02599494f, -0.05434405f, 0.03603585f, 0.02014438f, 
    -0.02188263f, 0.04532923f, -0.05206855f, 0.00146863f, 0.04298397f, -0.01526859f, 0.00510924f, -0.01068880f, 
    -0.06301921f, -0.03980197f, -0.05249285f, -0.04612667f, -0.00492767f, 0.00625505f, 0.01891448f, -0.00677771f, 
    0.04999525f, 0.01027723f, 0.01837908f, 0.04672155f, 0.04744169f, 0.00610558f, 0.01720972f, 0.00569322f, 
    0.00422216f, 0.00977290f, -0.05022230f, -0.03304715f, 0.02716211f, 0.04920734f, 0.04787487f, 0.00830765f, 
    0.02975142f, -0.04505363f, -0.04591480f, 0.02321529f, 0.00822223f, -0.05750566f, 0.03690664f, 0.03647514f, 
    0.01492281f, -0.02260259f, -0.04397072f, -0.03006158f, -0.04144737f, 0.01088238f, 0.04225745f, -0.02596810f, 
    0.03271511f, -0.01232317f, 0.03286552f, -0.01994126f, -0.04173482f, 0.03595968f, 0.04564444f, -0.03351307f, 
    0.03595773f, -0.01445047f, -0.01152607f, -0.03040351f, 0.04190072f, -0.02666995f, -0.05543693f, 0.03958508f, 
    0.00242800f, -0.04906898f, -0.01743064f, 0.04191429f, -0.03911918f, -0.00028920f, -0.06290055f, -0.04392604f, 
    -0.00997326f, -0.01632171f, 0.04552292f, -0.00451183f, -0.05317668f, 0.01322491f, 0.00038564f, 0.03726686f, 
    0.03605938f, -0.00790967f, -0.01705210f, 0.01008682f, 0.01330378f, -0.04012998f, -0.06125338f, 0.00691736f, 
    -0.03490569f, -0.00605692f, -0.04157833f, -0.00864304f, -0.01026589f, -0.04388833f, -0.05753600f, -0.03331910f, 
    -0.02071642f, -0.03525972f, -0.01598828f, 0.00864237f, -0.04860297f, -0.01943932f, 0.03428713f, -0.00211809f, 
    0.01395730f, 0.04890065f, 0.01039521f, 0.00907775f, -0.04508965f, -0.01242955f, -0.04445376f, 0.03269443f, 
    0.03364389f, -0.02421118f, -0.00323246f, -0.02095372f, -0.00168686f, 0.05190574f, 0.00962551f, -0.00965747f, 
    0.01232954f, -0.01404341f, 0.04666552f, 0.04745049f, -0.03026500f, 0.01766126f, 0.01544422f, -0.02978506f, 
    -0.01905763f, -0.04653863f, -0.01935211f, 0.05069137f, 0.02945170f, 0.01116726f, -0.04000311f, 0.00079067f, 
    -0.00980135f, -0.02582446f, 0.02437359f, -0.02712777f, -0.00484221f, -0.05417696f, 0.00260777f, 0.02009196f, 
    -0.02348636f, -0.01244746f, 0.01683397f, -0.00027095f, -0.03770914f, -0.01735553f, -0.01435992f, 0.03021643f, 
    0.03407939f, -0.04782670f, -0.00990787f, 0.05306447f, -0.04562193f, -0.00023043f, -0.02440873f, -0.01806017f, 
    0.01104751f, -0.04408931f, -0.02841548f, -0.01522377f, -0.04809047f, -0.04092611f, -0.00881579f, 0.00273214f, 
    0.04824429f, 0.00580750f, 0.00358702f, 0.03136456f, 0.00463293f, 0.03424204f, 0.04594132f, 0.01649401f, 
    -0.04238990f, -0.04390334f, 0.03402089f, -0.01790855f, -0.06067943f, -0.01339977f, -0.01130244f, 0.04867001f, 
    0.04017772f, -0.01339610f, 0.02499845f, 0.05086962f, -0.00344326f, -0.01184001f, -0.00619701f, -0.01990524f, 
    -0.02529611f, -0.00914823f, -0.02712076f, -0.03519266f, -0.04137862f, 0.01730790f, 0.04266034f, -0.01608030f, 
    -0.00423748f, 0.03804037f, -0.00391097f, -0.05838535f, -0.00167004f, -0.01032618f, -0.04981069f, -0.01899713f, 
    0.03770402f, -0.00199407f, 0.00429096f, -0.03362278f, -0.02135377f, -0.04787781f, 0.03823994f, -0.00081958f, 
    -0.00619452f, 0.02897885f, 0.03586615f, 0.05251921f, 0.00898915f, 0.01533032f, -0.04429111f, 0.05547129f, 
    -0.03222860f, -0.01117071f, 0.00122971f, -0.03319774f, -0.05041264f, -0.04023596f, 0.00848881f, 0.04150133f, 
    -0.03098924f, -0.01564347f, 0.03575007f, -0.00116801f, -0.01775439f, 0.04209958f, -0.06210585f, 0.00130823f, 
    -0.00735314f, 0.04040649f, 0.03156508f, -0.03596928f, 0.01811650f, -0.01120774f, -0.03214255f, 0.02023027f, 
    -0.02471246f, -0.00368579f, -0.04251577f, 0.02250267f, -0.04159208f, 0.03627572f, 0.00239795f, 0.05149109f, 
    -0.01138084f, -0.05313553f, -0.02846709f, -0.02123310f, 0.03580055f, -0.02488435f, -0.04580489f, -0.02942478f, 
    0.00911373f, -0.02144236f, 0.01145500f, -0.00654818f, -0.03324770f, -0.01338775f, -0.04520256f, -0.03659448f, 
    -0.06168718f, -0.05979031f, -0.05174690f, 0.02469717f, -0.00131123f, -0.05022334f, -0.06139686f, 0.00674907f, 
    -0.02410298f, -0.00276019f, 0.01805179f, -0.01911494f, -0.04302236f, -0.04604270f, 0.04927446f, 0.05084752f, 
    -0.01501289f, 0.02784626f, -0.02519637f, 0.04399196f, -0.05195097f, -0.03593467f, -0.04332345f, 0.01196587f, 
    0.01591553f, -0.04155747f, -0.03659477f, 0.04149040f, 0.01249711f, -0.00418788f, 0.00295266f, 0.00111021f, 
    0.03933502f, -0.00733631f, 0.02359147f, -0.01034401f, 0.04290089f, -0.00684076f, -0.01651980f, 0.03442065f, 
    -0.02717761f, -0.00026142f, -0.00663745f, -0.04461493f, -0.04975990f, 0.04186355f, 0.03587256f, -0.03056237f, 
    0.06019963f, -0.01205276f, 0.03265837f, 0.04291837f, 0.04157149f, 0.03740535f, -0.03509447f, 0.00766622f, 
    -0.05607717f, 0.02629150f, 0.01755096f, 0.02339991f, -0.04411419f, 0.01852102f, 0.00915164f, -0.05403832f, 
    -0.03210602f, -0.00123965f, -0.00951289f, -0.01497042f, 0.02039358f, 0.03072497f, -0.04022172f, -0.01482385f, 
    -0.00569082f, -0.05156348f, -0.00696321f, 0.00188126f, 0.04606938f, -0.02604076f, -0.02249240f, -0.00080534f, 
    -0.02104325f, -0.05662946f, -0.06443230f, -0.03332209f, -0.05813079f, 0.03113908f, -0.03476427f, -0.05489225f, 
    0.01183803f, -0.04871372f, 0.02572036f, 0.02890603f, -0.00509767f, -0.01705635f, -0.02062751f, -0.05344013f, 
    0.04758098f, -0.00937683f, -0.06412544f, -0.01053759f, -0.06352531f, -0.03851335f, 0.05000507f, -0.03707622f, 
    0.01297330f, -0.06064472f, 0.04991016f, -0.03331395f, -0.03363330f, -0.01426123f, -0.02339511f, 0.02079092f, 
    -0.01901333f, -0.06455602f, 0.02180942f, 0.05198744f, 0.01247315f, 0.02116866f, -0.02971826f, 0.03100854f, 
    0.01935955f, -0.05347391f, -0.03473165f, -0.00629443f, -0.01182871f, 0.01150874f, 0.03293524f, -0.01798224f, 
    0.04657685f, -0.03714839f, 0.01753855f, -0.01558575f, -0.02380456f, 0.00199501f, 0.04941305f, -0.06518000f, 
    -0.00746619f, 0.01495728f, -0.00607306f, -0.00952848f, 0.00454526f, -0.05039345f, -0.00087264f, -0.03578203f, 
    -0.03902837f, 0.05022801f, -0.00591890f, -0.00634353f, -0.01979962f, -0.05462903f, -0.02096714f, -0.03631772f, 
    -0.03689516f, -0.02867712f, -0.00702532f, 0.01285531f, -0.01192919f, -0.03592282f, -0.00951517f, -0.02017996f, 
    -0.05883167f, 0.05439359f, 0.02585394f, -0.05944893f, 0.03467200f, 0.05282822f, 0.02027163f, -0.01374191f, 
    -0.03764741f, -0.00719236f, -0.03305205f, 0.04157225f, -0.02110607f, -0.04303548f, -0.04486019f, -0.02067575f, 
    0.00090948f, -0.05103053f, -0.04908961f, -0.00547636f, 0.02737986f, -0.05787179f, 0.01526678f, 0.00744323f, 
    -0.02789834f, 0.05532749f, 0.01783051f, 0.01036886f, -0.04296988f, -0.05568794f, 0.05287677f, -0.00515029f, 
    0.04020284f, 0.03543445f, -0.05415383f, -0.01146052f, 0.03831311f, 0.05167617f, -0.02379161f, -0.05730087f, 
    -0.03782098f, -0.04912313f, 0.04586222f, 0.02923547f, 0.00463780f, 0.02121266f, -0.02654529f, 0.03526365f, 
    0.01360311f, -0.04753499f, -0.06196794f, -0.04783572f, 0.04868514f, 0.04502588f, -0.04268926f, 0.03609604f, 
    -0.03254163f, -0.04014515f, -0.04238392f, -0.02644569f, 0.01819521f, -0.02448902f, 0.03189714f, -0.03305338f, 
    0.02285581f, -0.05116537f, 0.04692794f, 0.03667073f, -0.06075172f, -0.00895064f, -0.05849823f, 0.01550343f, 
    -0.00668444f, 0.03713223f, -0.02620479f, 0.04784756f, -0.00210849f, -0.04945132f, -0.02067698f, 0.03561927f, 
    -0.00574831f, -0.02963991f, 0.00186333f, 0.00900905f, -0.05146475f, -0.03245028f, -0.00164063f, 0.01679649f, 
    -0.03431223f, -0.02686800f, -0.03382203f, -0.04371433f, 0.04310654f, -0.06311127f, -0.03798587f, 0.00751313f, 
    -0.03798481f, -0.03081376f, -0.00417663f, 0.04817552f, -0.04583716f, -0.00946093f, 0.01357643f, -0.03487249f, 
    -0.02569402f, -0.00077674f, -0.05076975f, -0.01067024f, 0.01370046f, 0.02351913f, 0.01319954f, -0.03139019f, 
    0.00601813f, -0.06413090f, 0.01020634f, 0.00467352f, -0.05365246f, 0.05468543f, 0.02119388f, 0.02340187f, 
    0.02749726f, -0.01753996f, 0.02301599f, 0.00592606f, -0.04612374f, -0.03370794f, -0.03232070f, -0.05976653f, 
    -0.01245210f, -0.03115331f, -0.02478971f, -0.05365335f, 0.04286474f, -0.04272670f, -0.04954140f, -0.04152150f, 
    -0.01494613f, 0.00537553f, 0.01946183f, 0.02693240f, -0.05302791f, -0.01088258f, 0.03318340f, -0.04233435f, 
    -0.03279838f, -0.01366100f, 0.02621213f, -0.05789735f, -0.03624592f, -0.06487731f, 0.01943404f, 0.00394129f, 
    -0.02841176f, 0.02014621f, -0.05637480f, 0.04378548f, -0.00208050f, -0.05131184f, -0.02369580f, -0.05257471f, 
    0.02428601f, 0.04551216f, -0.05416692f, -0.02633957f, -0.02554153f, -0.03020746f, 0.04403983f, -0.04504694f, 
    0.01200229f, 0.00622381f, -0.00516291f, -0.01605906f, 0.01284878f, 0.00060060f, -0.00696316f, 0.03559614f, 
    0.00655904f, -0.06554909f, 0.05121905f, 0.05001968f, -0.03236062f, 0.05876711f, -0.04283040f, -0.04550195f, 
    0.01431474f, 0.03706383f, 0.03046101f, 0.03584813f, 0.04514892f, 0.01898389f, -0.03569539f, 0.03794233f, 
    -0.04776854f, -0.01994121f, -0.04120916f, -0.00292241f, 0.05260313f, 0.03264751f, -0.01047553f, 0.02573575f, 
    -0.03650809f, 0.00780704f, -0.00163839f, -0.00288400f, 0.02904103f, 0.03890241f, 0.01527102f, 0.01846306f, 
    0.04617329f, -0.05481992f, -0.06071295f, -0.01330288f, -0.04142972f, 0.01367345f, 0.01837569f, 0.00392302f, 
    -0.04648821f, -0.04960038f, 0.02690273f, 0.00388976f, -0.02507981f, 0.05002712f, -0.03283824f, -0.06084191f, 
    -0.01059465f, 0.01173398f, -0.02790457f, 0.05674320f, -0.00170455f, -0.00920361f, 0.03161893f, 0.03946097f, 
    -0.01223019f, 0.00299149f, -0.05199008f, 0.00416326f, 0.03066529f, -0.05173191f, 0.04535341f, 0.03354619f, 
    -0.01439286f, -0.02244426f, 0.00936315f, -0.05757472f, 0.03939716f, -0.06419292f, -0.04218154f, -0.04779525f, 
    0.03356029f, 0.04937913f, 0.01057644f, 0.05145771f, 0.04789759f, -0.05453606f, 0.04072611f, 0.05462921f, 
    -0.26855853f, -0.16093484f, 0.01621240f, 0.23923646f, 0.00627671f, 0.13692752f, 0.10476383f, 0.09293916f, 
    -0.15183964f, -0.15573998f, -0.23525308f, -0.03428483f, -0.15923829f, 0.25272834f, -0.00110766f, -0.09380863f, 
    -0.01080992f, -0.16403103f, 0.10977448f, 0.12344470f, -0.30456805f, 0.11345984f, 0.06525733f, -0.11390003f, 
    -0.00335998f, 0.10835128f, -0.09998439f, -0.58850533f, -0.38040060f, -0.10530771f, 0.35223690f, 0.08811238f, 
    0.32188532f, -0.36640176f, -0.09988921f, -0.04851700f, 0.15276273f, -0.21224982f, 0.04239924f, 0.08139508f, 
    0.00569008f, -0.42696953f, 0.16255663f, 0.12050505f, 0.17070344f, -0.03657268f, -0.10744080f, -0.04520762f, 
    -0.04669700f, 0.11876812f, 0.07401034f, 0.06282884f, -0.04271646f, -0.03755734f, -0.23438391f, 0.15317018f, 
    0.01315956f, 0.33934969f, 0.02167104f, 0.08478168f, -0.02136753f, -0.02668837f, -0.07490174f, -0.10991526f, 
    0.12973207f, -0.10832620f, -0.06858922f, -0.14819753f, 0.06763582f, -0.08985243f, -0.07722177f, 0.05863767f, 
    -0.05652671f, 0.06055654f, 0.11689293f, 0.19796789f, -0.09370076f, 0.15603341f, 0.24168594f, 0.05110785f, 
    -0.06569394f, 0.03409303f, 0.08829229f, -0.10188222f, -0.21517307f, 0.09482079f, -0.10663113f, 0.01936871f, 
    -0.20953381f, 0.03042748f, 0.00623935f, 0.22952598f, -0.20303558f, -0.18844606f, -0.02105623f, -0.02271546f, 
    -0.19739921f, -0.00188638f, 0.17933790f, -0.30697173f, -0.12884834f, 0.12124991f, -0.03615943f, -0.06476184f, 
    0.06419924f, 0.14732207f, 0.18009977f, -0.09152734f, 0.19929790f, 0.08972725f, -0.01349078f, 0.01925143f, 
    -0.18501642f, -0.17483422f, -0.20973577f, 0.16645548f, 0.15686533f, 0.07712003f, 0.38477498f, 0.13229261f, 
    -0.14305593f, 0.15465826f, 0.10834236f, -0.29273129f, 0.15322027f, -0.02462620f, 0.02743897f, 0.00600498f, 
    0.31681058f, -0.06514560f, 0.02371361f, -0.13750353f, 0.26157328f, -0.00970504f, -0.10308997f, -0.37855837f, 
    -0.19380097f, 0.05059215f, 0.00656485f, 0.20361033f, 0.15734419f, -0.02201628f, -0.14473557f, -0.00429772f, 
    -0.02274493f, -0.03147255f, -0.11301212f, 0.23002394f, 0.17705691f, 0.05183638f, 0.16155475f, -0.00634006f, 
    0.26476055f, -0.00162806f, 0.00368973f, 0.26657552f, 0.14172536f, -0.14222595f, -0.19880514f, 0.11844080f, 
    -0.07875643f, 0.01207183f, -0.15921049f, 0.01186704f, -0.11737210f, -0.04436078f, -0.09117929f, -0.14542952f, 
    0.04217030f, -0.18864247f, -0.17621206f, 0.11451091f, 0.00538927f, -0.05529465f, -0.08983546f, 0.13605256f, 
    -0.08347847f, 0.06683275f, -0.17730114f, -0.03572455f, 0.13174486f, 0.34603459f, 0.00058433f, 0.07697144f, 
    0.01274851f, 0.04050206f, -0.25407943f, -0.04606403f, 0.13760328f, -0.26488492f, 0.06746134f, -0.08973646f, 
    0.15256713f, -0.07149762f, 0.19979730f, -0.04952624f, -0.00038498f, -0.12743516f, 0.12072278f, -0.05981117f, 
    0.00765066f, 0.03041419f, 0.07693154f, -0.34539220f, -0.10024959f, 0.12720159f, 0.02024390f, 0.41851771f, 
    0.13589720f, 0.00834849f, 0.37645119f, 0.05962125f, -0.01502861f, -0.17845540f, -0.02621839f, -0.10181823f, 
    -0.56129861f, -0.07122719f, -0.14196396f, 0.01216952f, 0.05608591f, 0.04644477f, -0.03819507f, -0.08002295f, 
    0.01659693f, -0.19173257f, 0.11452082f, -0.16696735f, 0.16040517f, 0.07424620f, 0.02834049f, -0.08670779f, 
    -0.02707103f, 0.19248134f, 0.04184833f, 0.00063771f, 0.23968565f, -0.01225799f, 0.11663116f, -0.10959131f, 
    0.12574299f, -0.05059051f, 0.12376694f, 0.16966231f, -0.01491194f, 0.22683206f, 0.08364984f, 0.16499825f, 
    0.15152392f, -0.02144138f, -0.12702024f, 0.03899627f, 0.31933984f, 0.19097111f, -0.18700446f, -0.05404245f, 
    -0.02126413f, -0.23564400f, 0.29146037f, 0.06895467f, 0.22962531f, 0.08687968f, 0.10561416f, -0.49753973f, 
    -0.05508707f, 0.19729845f, 0.03997186f, 0.01070857f, 0.07180894f, 0.08329650f, -0.09906590f, -0.05245949f, 
    0.19976731f, 0.18092197f, 0.20913452f, 0.21547900f, 0.05186815f, -0.11858997f, -0.01458065f, -0.07357337f, 
    -0.14605057f, -0.21831129f, 0.09308833f, 0.03828876f, 0.16248758f, 0.12073668f, 0.06144318f, -0.03783776f, 
    0.04672616f, 0.04716065f, -0.02230354f, -0.06591388f, 0.04023258f, 0.02272017f, 0.02169031f, -0.06444707f, 
    0.01564342f, -0.05116950f, -0.05916284f, 0.02831952f, -0.02935290f, -0.00471059f, -0.01194696f, 0.02917381f, 
    0.02448635f, -0.02907714f, -0.03766469f, 0.03204427f, -0.02620694f, -0.00797489f, -0.02838940f, -0.00607442f, 
    -0.06168467f, -0.03317504f, -0.05472881f, 0.02154922f, -0.05449096f, -0.01890540f, 0.01718538f, 0.00602610f, 
    -0.03064186f, -0.01451443f, -0.04586928f, -0.01184284f, 0.02731563f, 0.01656413f, -0.06105947f, -0.05170181f, 
    -0.00601996f, -0.01142158f, -0.06226182f, -0.03093153f, -0.01925405f, 0.00039963f, -0.04474166f, -0.00799863f, 
    -0.03561896f, -0.01587685f, -0.03639681f, -0.03983163f, 0.02608965f, 0.04175257f, -0.03225940f, 0.01929457f, 
    -0.01273624f, -0.03418187f, 0.03125945f, 0.01474660f, 0.02252314f, 0.00893110f, 0.04544991f, -0.00509869f, 
    -0.05171505f, 0.02915356f, -0.04593196f, -0.06088854f, 0.00114906f, 0.01325245f, -0.02254845f, -0.03155245f, 
    -0.02254874f, -0.00352044f, -0.02969796f, -0.06593884f, 0.02172839f, 0.01413177f, -0.03179550f, 0.02982753f, 
    0.01111788f, 0.04718995f, 0.01767093f, -0.02639666f, 0.00936274f, -0.06323563f, -0.03695123f, -0.03827735f, 
    -0.02411469f, -0.01308019f, 0.04812567f, -0.02985347f, 0.01136376f, 0.02185480f, -0.01172723f, 0.04164147f, 
    0.03830849f, -0.03904334f, 0.01823174f, -0.03128733f, 0.04819059f, -0.03245970f, -0.00710669f, -0.03345870f, 
    0.01586698f, -0.01887036f, 0.03274920f, -0.01516595f, 0.04900615f, -0.05774239f, -0.02753566f, -0.02284139f, 
    0.00292689f, 0.00565979f, 0.01076954f, 0.03249815f, 0.03181912f, -0.01896680f, -0.05265522f, -0.01186286f, 
    0.04478976f, 0.01285800f, -0.05137817f, -0.00310627f, 0.00038603f, -0.01170239f, 0.02215317f, -0.01759980f, 
    0.04735861f, 0.04798270f, -0.00240888f, -0.00081735f, -0.05242163f, -0.00042445f, 0.02168859f, 0.03101598f, 
    0.00862991f, -0.03517087f, -0.05060710f, 0.04255678f, 0.01185457f, 0.00505874f, -0.05685072f, 0.00521240f, 
    -0.00210092f, 0.01769903f, 0.00447521f, 0.01222813f, -0.05773298f, -0.05928666f, 0.00048706f, -0.05447526f, 
    -0.06598379f, 0.03179966f, -0.00675325f, -0.00053277f, -0.03248445f, -0.01135674f, -0.02811545f, 0.01357032f, 
    -0.04915136f, -0.03935973f, 0.02038322f, -0.02435046f, 0.02934927f, 0.01694118f, -0.06562626f, 0.01157895f, 
    -0.06451932f, 0.04834964f, 0.04956531f, 0.02783073f, -0.03746290f, 0.02451935f, -0.04346738f, -0.04842797f, 
    -0.00658647f, -0.03774723f, -0.00184267f, -0.03308065f, 0.05131666f, 0.00037325f, 0.03391335f, 0.01756380f, 
    0.01328248f, -0.01090845f, -0.01523508f, 0.03459869f, -0.02628685f, 0.04441886f, 0.03345633f, 0.04666562f, 
    0.03898824f, -0.04887774f, 0.05356946f, -0.00108937f, -0.01407724f, 0.04068495f, -0.01081944f, -0.05645445f, 
    -0.01621057f, -0.04353274f, -0.06501410f, 0.03876799f, -0.01860547f, -0.05117165f, -0.02721532f, -0.04863555f, 
    0.00218053f, 0.02980073f, 0.05046846f, -0.01866951f, -0.03610527f, 0.01389367f, 0.01519250f, 0.02274939f, 
    0.04683730f, -0.01256267f, 0.03177859f, 0.03597838f, -0.04415065f, 0.04423155f, 0.00402493f, -0.05511605f, 
    -0.01918257f, -0.03731598f, 0.00693585f, 0.01640066f, -0.02024460f, 0.02247102f, 0.01817002f, -0.01370203f, 
    0.02578974f, 0.01100021f, -0.03889066f, 0.02809276f, 0.03320320f, 0.04617987f, 0.01680525f, -0.04618286f, 
    -0.03879887f, 0.02965703f, -0.03121036f, 0.03476632f, -0.01115317f, 0.02941591f, 0.04864877f, -0.01237778f, 
    -0.01092506f, -0.04153715f, -0.00174679f, -0.06485079f, 0.01545814f, -0.00967226f, -0.00823725f, -0.05013601f, 
    -0.02502036f, -0.02116446f, -0.05274684f, 0.03342212f, 0.04354830f, -0.02957272f, 0.05143970f, 0.04740172f, 
    -0.01197274f, -0.06282157f, 0.00757808f, -0.03071691f, 0.04530996f, -0.01761398f, -0.01891076f, -0.05623675f, 
    -0.03637565f, -0.05801873f, -0.05627771f, -0.03381750f, -0.00823670f, -0.00816721f, -0.05095461f, 0.02191014f, 
    0.03954035f, -0.01892012f, -0.02455313f, 0.04091926f, -0.04835342f, 0.04310446f, -0.00935450f, -0.03080025f, 
    0.07821272f, -0.36712646f, -0.25425273f, 0.07956697f, 0.13925442f, -0.23580644f, 0.14828560f, -0.01920367f, 
    -0.18596900f, 0.12622698f, -0.08138361f, -0.00348309f, -0.12704287f, 0.02453820f, 0.03045282f, -0.01558467f, 
    -0.13881926f, 0.01792248f, -0.06974477f, 0.08708358f, 0.02739439f, -0.12438228f, -0.12505952f, 0.17033756f, 
    -0.04325429f, -0.04844211f, 0.11508524f, 0.43352816f, 0.01863701f, -0.20769231f, -0.12921563f, -0.12740517f, 
    0.17081767f, 0.20748663f, 0.00834900f, 0.14323477f, -0.35887346f, 0.16081533f, -0.39872569f, 0.19833025f, 
    0.15654774f, 0.29595378f, -0.10221845f, 0.01706333f, 0.10396686f, 0.11995675f, 0.17672403f, 0.02168754f, 
    -0.13592350f, -0.17494439f, -0.17368872f, -0.22309831f, 0.03570912f, 0.00943266f, 0.02560363f, -0.45414940f, 
    -0.26151863f, -0.05121634f, 0.06415134f, -0.08691812f, -0.02094881f, -0.17844710f, -0.24662769f, -0.08557656f, 
    0.09949246f, 0.07113205f, -0.01139962f, 0.08009913f, -0.01825297f, -0.01462044f, -0.13325585f, -0.16660616f, 
    -0.27889091f, 0.25278696f, 0.24519411f, -0.13847581f, -0.12077328f, -0.07959542f, 0.12038156f, -0.05792246f, 
    -0.08992592f, 0.11739310f, 0.32640439f, 0.25210190f, -0.16144235f, -0.04096624f, -0.01329450f, 0.01692368f, 
    -0.01590161f, -0.13092917f, 0.18851262f, -0.19231586f, 0.05965775f, -0.02667823f, -0.10647772f, 0.04733542f, 
    0.17438225f, 0.02907272f, 0.15681657f, 0.00644679f, -0.18257193f, 0.06063072f, -0.07209236f, -0.16315907f, 
    -0.26886094f, 0.04702437f, 0.03290025f, 0.00776688f, 0.03607086f, 0.03662942f, -0.22058190f, 0.28553918f, 
    0.12476507f, 0.03964323f, -0.22309254f, 0.03047001f, 0.09929929f, 0.26893297f, -0.13936572f, 0.05719227f, 
    -0.23197018f, 0.05445251f, -0.02476866f, 0.10039239f, 0.13814628f, -0.03538777f, -0.74354124f, 0.13952354f, 
    -0.09936464f, -0.14907207f, -0.07799508f, 0.06658717f, -0.22676232f, 0.10904039f, 0.05952345f, 0.45740336f, 
    0.06055667f, -0.19442643f, 0.07970610f, 0.03997384f, 0.10162439f, -0.04500876f, -0.08337326f, -0.09090953f, 
    -0.03811454f, 0.01900026f, -0.05219340f, 0.13660665f, 0.10989372f, -0.08939108f, 0.01712320f, 0.01061820f, 
    -0.07244283f, -0.00806232f, -0.10275380f, 0.00905821f, -0.00097832f, 0.05274986f, 0.12785660f, 0.17165212f, 
    0.12890400f, -0.08534924f, 0.13387233f, 0.13108934f, 0.36574447f, -0.15327586f, 0.12670870f, -0.00350750f, 
    0.05203855f, 0.15482177f, -0.22905284f, 0.07279848f, 0.13740575f, 0.47417390f, -0.11914549f, -0.08008206f, 
    0.05548355f, 0.04795296f, 0.12135677f, -0.09075443f, 0.41279459f, -0.14876160f, 0.24758483f, 0.07890597f, 
    0.00316878f, 0.02417806f, 0.23312563f, -0.02038948f, 0.03169078f, -0.12710747f, -0.60901350f, -0.18987834f, 
    0.05316556f, 0.10001040f, -0.14047684f, -0.07939489f, 0.14589001f, 0.07824131f, 0.05813097f, -0.04842307f, 
    -0.01361099f, 0.05074632f, -0.04947327f, 0.21731912f, -0.11067665f, 0.25789359f, -0.10905933f, 0.05350481f, 
    0.13199916f, 0.12083892f, 0.11568704f, -0.02913975f, 0.07155005f, 0.04559348f, -0.04627937f, -0.03534608f, 
    0.18671222f, 0.21191399f, -0.29709211f, 0.02021279f, 0.05739319f, -0.03104904f, -0.06655844f, -0.09256165f, 
    -0.07814441f, 0.62183291f, 0.37842229f, -0.03578521f, -0.16456459f, 0.11241901f, 0.15245007f, 0.11410337f, 
    0.05038026f, 0.09895266f, -0.07756142f, 0.26819843f, -0.20915420f, -0.04860037f, -0.13026522f, 0.15965137f, 
    0.03934480f, 0.16686347f, 0.19786252f, 0.19240494f, 0.09342977f, -0.15964764f, -0.11627391f, 0.03652945f, 
    -0.05755728f, 0.11619206f, -0.04010024f, 0.08058309f, 0.13880302f, -0.14451960f, -0.10454456f, 0.07227018f, 
    -0.14809111f, 0.19662195f, -0.07256583f, 0.13354963f, 0.10773221f, 0.55250269f, -0.19006239f, -0.00860244f, 
    0.00060098f, -0.05216051f, 0.09514557f, -0.06223048f, 0.09055954f, -0.08184782f, -0.11118332f, -0.20782740f, 
    -0.22909299f, -0.05997097f, 0.05111388f, -0.01498944f, 0.27189767f, 0.08668160f, -0.12655738f, -0.08441091f, 
    -0.25233564f, -0.17981207f, -0.00898487f, 0.00191437f, -0.11218973f, 0.02941513f, 0.05878900f, -0.01117922f, 
    -0.04946791f, 0.00544797f, -0.05791916f, 0.00786754f, 0.02731989f, -0.02797713f, -0.05154769f, -0.01436661f, 
    -0.04534731f, 0.03298350f, 0.04074316f, 0.05026120f, 0.00157323f, 0.03085224f, 0.01208873f, 0.03195719f, 
    -0.03263691f, -0.01642461f, 0.00817813f, -0.04715408f, 0.01230821f, -0.00572652f, 0.01397377f, -0.03915950f, 
    -0.01065132f, 0.00919264f, 0.03483156f, -0.03545868f, 0.00932286f, 0.04034252f, -0.01920567f, -0.05407834f, 
    -0.05100326f, -0.04149468f, -0.00501012f, -0.03129747f, 0.01466861f, -0.00339830f, 0.04790116f, 0.04084175f, 
    -0.00456007f, 0.02555232f, -0.05609146f, -0.04051184f, -0.05707518f, -0.03691494f, -0.01541470f, 0.02065354f, 
    -0.01657356f, 0.04477622f, 0.02443057f, 0.02942658f, 0.04952002f, 0.04195481f, -0.00079379f, -0.01951273f, 
    -0.04155222f, -0.00008441f, -0.06237214f, -0.02801141f, -0.04286785f, -0.03442835f, 0.02357676f, -0.02159819f, 
    -0.01387568f, -0.02800583f, 0.01092154f, 0.02807191f, -0.00269352f, 0.02354198f, -0.01796180f, -0.03934252f, 
    0.02384541f, -0.03841071f, 0.01601421f, 0.00620349f, 0.02040480f, 0.01871732f, 0.02098914f, -0.05870372f, 
    -0.06336139f, -0.03210085f, -0.04181040f, -0.01730650f, 0.00345482f, 0.01915674f, 0.00711660f, -0.00700846f, 
    0.01654013f, 0.03783314f, 0.03516823f, -0.02421862f, 0.02698665f, 0.01522725f, 0.00315901f, 0.00316543f, 
    0.01735032f, 0.03290315f, -0.00953909f, 0.03439172f, 0.00696366f, -0.03727792f, -0.01251543f, -0.01975444f, 
    -0.02842734f, -0.05328970f, -0.05004881f, -0.01976460f, -0.06085622f, -0.03794825f, -0.01384752f, 0.00328545f, 
    -0.04203133f, 0.04276251f, 0.04891093f, -0.00768765f, 0.04889531f, -0.05222307f, 0.01409449f, 0.00604129f, 
    -0.04999785f, 0.00654451f, 0.03791859f, 0.00448375f, -0.02770586f, -0.03764568f, -0.06302504f, 0.01625857f, 
    -0.02285849f, 0.04897942f, -0.02324177f, -0.01720320f, -0.04452576f, -0.05655183f, 0.04279456f, 0.02647738f, 
    0.01572721f, -0.01089360f, 0.02054601f, -0.00812994f, -0.06025499f, -0.03782431f, -0.04856107f, -0.06105063f, 
    0.01219363f, -0.02566443f, -0.01220504f, 0.00108273f, 0.02280539f, 0.04914260f, -0.05094367f, 0.00608087f, 
    -0.02162508f, -0.05805633f, -0.04094975f, 0.02570260f, 0.02108186f, -0.05804453f, 0.05280713f, 0.01599088f, 
    -0.03155143f, -0.05499543f, -0.03930093f, -0.01447564f, 0.03426746f, 0.00981215f, -0.01912521f, -0.03892419f, 
    0.03289967f, -0.02711630f, -0.05092031f, -0.00227666f, 0.03819399f, -0.01598337f, -0.04709748f, -0.04032804f, 
    0.05229922f, 0.03984092f, 0.01517926f, -0.05904587f, -0.00961359f, 0.02339953f, -0.00475044f, -0.03474207f, 
    -0.00135781f, -0.01417856f, 0.05284212f, -0.05947425f, -0.02650657f, 0.00029950f, -0.00608597f, -0.01336330f, 
    -0.01624184f, 0.01644773f, 0.01030385f, -0.03204141f, 0.04073258f, 0.02903488f, -0.02693351f, 0.03013354f, 
    0.03458202f, -0.03685312f, 0.03401633f, 0.05107733f, 0.03623110f, 0.01710652f, 0.03127108f, -0.00017153f, 
    0.03444417f, 0.03532618f, -0.03430649f, 0.01581639f, 0.01704730f, -0.00283055f, -0.05745778f, 0.04069619f, 
    0.01585913f, -0.02333448f, -0.01569716f, -0.00094272f, 0.00820813f, -0.02954723f, 0.04809817f, -0.06244256f, 
    -0.00262727f, 0.02810323f, -0.00824294f, 0.04844653f, 0.00517268f, 0.05153293f, 0.02911021f, 0.01098193f, 
    -0.01948781f, -0.05883546f, 0.04757604f, -0.04882311f, 0.03953345f, 0.03939657f, -0.02593263f, -0.04031488f, 
    -0.05042657f, 0.05064277f, -0.06340498f, 0.02880212f, -0.02460367f, -0.01116057f, -0.05084587f, -0.04236015f, 
    -0.03651560f, -0.03966349f, 0.04387470f, -0.06191722f, -0.06208944f, -0.03296421f, -0.01425407f, 0.02325688f, 
    0.03108439f, -0.05232865f, 0.03289273f, -0.06144660f, 0.02375070f, 0.02611485f, -0.06155574f, 0.00428377f, 
    -0.02541052f, 0.04725208f, -0.03431788f, -0.01509890f, 0.01384746f, -0.00910250f, -0.05478136f, 0.04859202f, 
    -0.03590335f, 0.01885373f, 0.04227157f, -0.00540685f, 0.00201665f, -0.01199072f, 0.01958795f, -0.04889763f, 
    0.02985008f, -0.05804338f, -0.02276260f, 0.01215722f, -0.04937061f, 0.02684765f, -0.04654474f, -0.04339692f, 
    -0.06433738f, 0.02666307f, -0.00939328f, 0.00467148f, -0.00710158f, 0.03117665f, 0.00119257f, 0.04961714f, 
    0.03704778f, -0.03149931f, 0.03903948f, -0.05234832f, 0.04348738f, -0.02202775f, -0.04239549f, -0.03571189f, 
    -0.04782699f, -0.00770247f, -0.06059305f, -0.05949192f, -0.06391221f, 0.03937782f, -0.06290361f, -0.04037347f, 
    -0.01940195f, -0.00267086f, 0.04543433f, -0.04996625f, 0.01579467f, 0.04371101f, 0.04390102f, -0.02588077f, 
    -0.01050034f, -0.01997371f, 0.03591230f, 0.03740692f, 0.02808671f, 0.02694838f, 0.02291130f, -0.00408697f, 
    -0.04035936f, -0.01965010f, -0.06241838f, -0.04017835f, 0.04705169f, 0.03965803f, 0.04361903f, -0.04657415f, 
    -0.02322485f, 0.00289145f, -0.05380094f, -0.00116443f, 0.03846501f, 0.04379417f, -0.06317801f, -0.06048323f, 
    -0.00462145f, -0.06418826f, -0.03243261f, -0.00771900f, 0.04115549f, 0.01731993f, 0.01150499f, -0.03910973f, 
    -0.04431690f, -0.00808089f, 0.04407183f, 0.04812145f, -0.02736125f, 0.04936848f, -0.01824002f, -0.02858786f, 
    -0.04494362f, 0.04684274f, 0.01952723f, 0.00303955f, 0.05199834f, -0.00756697f, 0.00697134f, 0.01407905f, 
    -0.04089752f, -0.01409703f, -0.03373368f, -0.03220375f, -0.04949573f, 0.00723933f, -0.04870794f, -0.06235616f, 
    0.03831399f, 0.01439787f, -0.00911920f, 0.01404852f, -0.02635996f, 0.02386599f, -0.05661889f, 0.02112025f, 
    -0.02494810f, 0.02920121f, 0.04775663f, -0.01108252f, 0.02959421f, 0.01029094f, -0.05994299f, 0.01686441f, 
    -0.05009853f, -0.05308328f, 0.01256524f, 0.02840240f, 0.02749939f, -0.05464835f, 0.01017869f, 0.02064512f, 
    0.00159378f, -0.02975176f, -0.02718033f, -0.03917874f, 0.00709509f, -0.00343555f, 0.01582152f, -0.05698686f, 
    0.02550393f, 0.04528811f, 0.00022240f, -0.03911842f, -0.00918011f, -0.06263061f, -0.01392867f, 0.02080060f, 
    0.02235868f, -0.04401713f, 0.01447874f, -0.02874893f, -0.02665392f, -0.00423246f, -0.06170594f, -0.05016096f, 
    0.02697093f, -0.00739097f, 0.02913454f, -0.01074111f, 0.02065953f, -0.01326926f, -0.06646409f, 0.04291263f, 
    -0.03867871f, -0.00135411f, -0.01124412f, -0.01019327f, -0.05862355f, 0.01845112f, -0.01818563f, -0.04030126f, 
    0.03202813f, -0.01331298f, 0.03954411f, 0.03414880f, -0.05923425f, 0.01560471f, 0.01926460f, -0.03102242f, 
    0.00832233f, -0.01232276f, -0.01179061f, -0.06210151f, -0.04480771f, -0.03522816f, -0.00563546f, 0.04861949f, 
    -0.05583040f, 0.01139606f, 0.02227539f, -0.06401339f, -0.04338074f, 0.02438280f, -0.00908886f, -0.01031088f, 
    -0.00073487f, 0.04662490f, -0.05080202f, 0.03802932f, 0.03935241f, -0.00736015f, -0.02498807f, 0.02007903f, 
    0.00903479f, 0.01971778f, 0.04759123f, -0.03212820f, -0.06011981f, -0.00827300f, -0.02004297f, -0.00593960f, 
    -0.05997277f, -0.01897775f, 0.04928674f, -0.03998988f, -0.03001212f, 0.04355532f, -0.03195530f, -0.03757088f, 
    -0.01908774f, -0.03198070f, -0.00862351f, -0.06075041f, 0.03324711f, 0.04704234f, -0.06216685f, -0.04599390f, 
    -0.01984552f, -0.04246965f, 0.03872000f, 0.00474280f, 0.01139405f, -0.04127372f, -0.02444880f, -0.04493506f, 
    0.05308720f, -0.02745680f, 0.03521854f, -0.01144622f, -0.04454317f, -0.06502774f, 0.01081042f, 0.01151860f, 
    0.04128774f, 0.02673325f, 0.03273053f, 0.02487080f, -0.06769963f, -0.01399307f, -0.02785539f, 0.01992056f, 
    -0.04867507f, 0.00624977f, -0.01830665f, -0.00518741f, -0.04788435f, 0.04177085f, 0.04693290f, -0.05368874f, 
    0.03731271f, 0.03786773f, -0.04244148f, -0.02397395f, -0.01957063f, 0.02236689f, -0.00277599f, 0.00731588f, 
    -0.06237383f, 0.03977385f, -0.01384262f, -0.00933273f, 0.03969910f, -0.06422973f, -0.00506177f, -0.05778300f, 
    0.01928302f, -0.06161325f, 0.02847780f, 0.02003700f, -0.03170948f, 0.00304797f, 0.01482842f, 0.02224787f, 
    0.03910588f, -0.04191535f, 0.02269110f, -0.03989280f, -0.05169432f, 0.02178496f, 0.04480340f, 0.04779515f, 
    -0.02838492f, 0.01218055f, -0.03790725f, -0.03544335f, -0.05746076f, 0.03457189f, -0.02971700f, -0.03661777f, 
    -0.02294536f, 0.02696600f, -0.02109738f, -0.02951333f, 0.00325762f, -0.02686037f, -0.03017727f, -0.00660492f, 
    -0.05619225f, -0.00578327f, 0.02756180f, -0.01198240f, 0.03422208f, 0.03693922f, -0.00257794f, -0.01540130f, 
    0.04057194f, 0.01750170f, -0.04383593f, -0.01335948f, 0.00347946f, -0.00296930f, -0.00153954f, 0.03083403f, 
    0.00025739f, 0.01251880f, 0.00567769f, -0.04502679f, 0.00418805f, 0.03832410f, 0.00389060f, -0.02654096f, 
    -0.02957670f, 0.05426076f, 0.00329722f, 0.04372707f, -0.04379755f, 0.01749522f, -0.02684374f, -0.02062695f, 
    0.03135363f, -0.05263566f, -0.05428431f, -0.07087232f, -0.01939540f, -0.02482242f, -0.01095965f, -0.01761648f, 
    0.00468300f, -0.04689313f, 0.03944006f, -0.04773849f, 0.00074869f, -0.03727115f, -0.02480862f, 0.04504848f, 
    -0.03340831f, -0.01248762f, -0.03764378f, -0.05006299f, -0.03481380f, 0.01246186f, -0.02612615f, 0.02286237f, 
    0.01398047f, -0.07425486f, -0.01431601f, 0.03359868f, -0.03058516f, 0.04327160f, 0.00545981f, 0.02600695f, 
    -0.02960307f, -0.05751525f, -0.04982625f, -0.02554591f, -0.03033332f, 0.03588013f, -0.02665082f, 0.01960592f, 
    -0.06581298f, -0.03478686f, -0.04378953f, -0.06261243f, -0.06222359f, -0.04175230f, -0.07177076f, -0.00490902f, 
    -0.00695152f, -0.05157357f, 0.02970418f, -0.02838479f, -0.02276840f, -0.05280104f, -0.06588595f, 0.03828927f, 
    0.01277850f, -0.03210300f, -0.04178283f, -0.06306894f, 0.02282601f, -0.04987634f, -0.01266928f, 0.03174527f, 
    -0.05406910f, 0.00263418f, 0.00038558f, -0.05169577f, 0.03083280f, -0.03996484f, 0.01298846f, 0.01942566f, 
    0.01461810f, -0.00369914f, -0.04557757f, -0.01205618f, 0.02992872f, -0.04615230f, 0.01776539f, 0.00297594f, 
    0.00075756f, 0.03074596f, -0.01147202f, -0.05312456f, -0.00116961f, -0.02515686f, 0.02343309f, -0.02671159f, 
    -0.03109992f, 0.02360038f, -0.06285562f, -0.04712106f, -0.05575097f, -0.00940833f, 0.02517034f, -0.06030585f, 
    -0.02429499f, -0.03783823f, -0.05284527f, -0.00288355f, 0.00016314f, -0.04509015f, 0.00425835f, -0.02156186f, 
    -0.00907238f, 0.03655156f, 0.00890624f, 0.03971095f, -0.02797000f, -0.01790584f, 0.00254233f, -0.05068345f, 
    -0.01703534f, -0.04690670f, 0.04121044f, 0.02746065f, -0.06004518f, -0.01232995f, 0.03250503f, 0.00535086f, 
    -0.00469825f, 0.03732117f, 0.04126139f, -0.01378115f, -0.02504419f, 0.02913233f, -0.03582745f, -0.06579328f, 
    -0.06578114f, -0.05775306f, -0.00792381f, -0.03287502f, -0.00304718f, -0.06763386f, -0.04648976f, -0.03917234f, 
    0.03116257f, -0.00447912f, 0.01885754f, -0.06146283f, 0.03277807f, -0.01763730f, -0.03498327f, -0.03390311f, 
    -0.00181627f, -0.03488049f, -0.04213265f, -0.07095753f, 0.04492822f, -0.02084880f, 0.01579338f, -0.05826993f, 
    -0.04279255f, 0.00824809f, -0.05908691f, 0.04567780f, 0.02218948f, -0.04868427f, -0.06523647f, -0.02815571f, 
    -0.07221992f, -0.02537129f, -0.06399129f, -0.05891738f, -0.04600208f, -0.01198002f, 0.00160104f, 0.02117314f, 
    -0.03642622f, 0.01083031f, -0.00816405f, -0.01173013f, -0.00324096f, 0.03621357f, 0.01515784f, 0.02047779f, 
    -0.01166333f, 0.03780866f, -0.01296110f, 0.02540459f, -0.01693382f, -0.03472289f, -0.06420442f, 0.00349977f, 
    0.00150124f, -0.05094890f, -0.05784320f, 0.02436693f, 0.02162500f, -0.02779814f, 0.03673336f, 0.00774386f, 
    0.01842787f, -0.05116208f, 0.01444805f, -0.00188213f, 0.01401275f, -0.05456273f, -0.05661226f, 0.02540231f, 
    0.02987647f, -0.05725155f, -0.04389167f, 0.00617525f, 0.03269950f, -0.05810339f, -0.04864812f, -0.04945879f, 
    0.02684329f, -0.02456463f, -0.04142325f, 0.00141805f, 0.03185976f, 0.00091847f, -0.05422076f, 0.02754673f, 
    -0.07606048f, -0.03871678f, -0.04732880f, 0.01725151f, 0.04465242f, 0.00365232f, 0.01212590f, -0.03145282f, 
    -0.00619021f, -0.03988056f, -0.01981822f, -0.03182828f, 0.00466715f, -0.01041089f, 0.03489308f, -0.05460801f, 
    0.01949061f, 0.03667443f, 0.04285571f, -0.03990238f, -0.05366493f, 0.02823686f, -0.06377280f, 0.01234401f, 
    -0.00420656f, -0.04151726f, -0.02812838f, 0.02259759f, -0.00387531f, -0.03797483f, -0.02221898f, -0.06322530f, 
    -0.05134521f, -0.04676402f, 0.01791938f, -0.05620014f, 0.03781714f, 0.02607845f, -0.01066972f, -0.06253551f, 
    0.22008044f, -0.00344377f, -0.09046831f, -0.13145931f, -0.08014672f, -0.03488451f, 0.14692307f, 0.16271895f, 
    0.20811637f, -0.19784796f, -0.07361437f, 0.02451856f, -0.21403977f, -0.23976471f, 0.05594686f, -0.20639455f, 
    0.39037800f, 0.12448013f, -0.06229845f, -0.32235843f, -0.14760019f, 0.32216433f, 0.11421383f, 0.06395265f, 
    0.23431322f, 0.03852447f, -0.29191983f, -0.12999426f, -0.03827286f, -0.18619965f, -0.13654913f, -0.02855716f, 
    0.15076254f, 0.12948655f, 0.20693433f, -0.03866533f, 0.48006684f, 0.45313454f, -0.18104582f, 0.16845249f, 
    0.36126938f, -0.06951515f, 0.10102218f, -0.02719371f, -0.11693347f, -0.19385482f, 0.05810563f, 0.18155135f, 
    -0.15512468f, 0.20189647f, -0.11079773f, 0.05991279f, -0.05580996f, -0.06004542f, 0.13130464f, 0.34232482f, 
    0.01322576f, -0.38181499f, 0.09440640f, -0.29316393f, 0.04438885f, 0.09301400f, 0.12322017f, -0.05643720f, 
    0.31408668f, 0.39444777f, 0.28695190f, -0.07606862f, 0.02203644f, 0.08996292f, 0.07796596f, -0.06092841f, 
    -0.15079515f, -0.05338683f, -0.05451043f, 0.12646377f, 0.19670270f, 0.17837949f, -0.21626832f, -0.27881938f, 
    -0.12670995f, -0.09139127f, -0.31041825f, 0.31499949f, -0.07346214f, 0.04792548f, 0.15306555f, -0.18627158f, 
    0.23296608f, 0.12918852f, -0.03708854f, -0.04146316f, -0.19259311f, 0.18984784f, 0.24831414f, -0.13392636f, 
    0.08029832f, -0.19671406f, -0.12131752f, 0.22665963f, 0.13104384f, -0.01078721f, 0.02303511f, 0.04040999f, 
    0.07516891f, 0.13299121f, 0.05632959f, 0.12935264f, 0.08829219f, 0.08045277f, -0.16351523f, 0.14673389f, 
    0.03558609f, -0.09296080f, 0.05032236f, -0.01420025f, -0.07362085f, 0.13096507f, 0.07513002f, 0.04467455f, 
    -0.00034877f, -0.00327796f, 0.10712325f, 0.09058218f, 0.27660307f, -0.08424047f, -0.25373682f, 0.01478819f, 
    -0.41471213f, 0.28965521f, 0.17562829f, 0.18890180f, 0.40565863f, -0.14076786f, 0.26689965f, 0.23924941f, 
    0.08585976f, -0.06190278f, 0.00273653f, -0.03029439f, 0.06107875f, 0.18356302f, 0.11609664f, 0.16047801f, 
    -0.06889182f, -0.07731121f, 0.15418872f, 0.12213988f, 0.06868756f, 0.06575737f, 0.31624043f, 0.30788875f, 
    0.00943099f, 0.41818133f, 0.41014248f, -0.06753042f, -0.23372075f, 0.02841855f, -0.23613814f, 0.02449603f, 
    -0.01825196f, -0.09948309f, -0.27927959f, -0.17553380f, 0.11972182f, -0.14422739f, -0.19075519f, 0.11030781f, 
    -0.26680335f, -0.10185379f, 0.11847239f, -0.09816206f, 0.05793603f, 0.19043516f, 0.21175726f, 0.12195124f, 
    0.20959365f, -0.18068166f, -0.21192741f, -0.11338717f, 0.23556276f, 0.14159265f, -0.03898383f, 0.11429358f, 
    0.05350251f, -0.13404655f, -0.06527380f, 0.13248377f, -0.15255871f, -0.23673712f, 0.24672650f, 0.12968387f, 
    -0.03243587f, 0.03749918f, 0.00377686f, 0.13991749f, 0.24345535f, 0.28581676f, 0.24748506f, 0.20080930f, 
    0.17362352f, -0.01191549f, 0.30327368f, -0.00555420f, 0.18142727f, 0.03384767f, -0.10955521f, -0.06885388f, 
    -0.15313709f, -0.19552070f, 0.28691939f, 0.19135642f, 0.13719083f, -0.09434976f, 0.06257045f, -0.26296702f, 
    0.09298974f, -0.34662023f, 0.22890349f, 0.01184894f, -0.00662029f, 0.02154526f, -0.01828238f, 0.21391338f, 
    0.25012431f, 0.12809987f, -0.05513835f, -0.36438805f, 0.00076638f, 0.09961706f, 0.31601289f, 0.06587471f, 
    0.01107008f, -0.18012093f, -0.13821842f, 0.09269544f, 0.03853736f, 0.03607721f, -0.07584805f, 0.23838632f, 
    0.04831524f, 0.03533815f, -0.18473661f, 0.39773625f, 0.03382185f, 0.04961357f, -0.15511374f, 0.03110771f, 
    -0.27537286f, 0.02605288f, 0.14616327f, 0.20146824f, -0.16317056f, -0.16403323f, -0.16864344f, 0.35650197f, 
    0.27184859f, 0.28707203f, 0.12982734f, 0.07657968f, -0.08374809f, -0.00932719f, -0.42174581f, 0.11391401f, 
    0.15497537f, -0.08519363f, 0.10899000f, -0.40295845f, 0.25860146f, -0.23681550f, 0.33672810f, 0.16615090f, 
    0.00404661f, 0.07695234f, -0.03175694f, 0.00597740f, 0.09683873f, 0.13242045f, 0.10485715f, 0.00800050f, 
    0.20133674f, -0.02965800f, -0.29605323f, -0.01708282f, 0.15461522f, 0.15839839f, -0.00082913f, 0.04473577f, 
    0.26917237f, 0.11994527f, -0.18352111f, 0.07277245f, 0.02626368f, 0.05556599f, -0.05667318f, -0.14651664f, 
    -0.13885182f, -0.51813716f, -0.37572506f, -0.03810314f, 0.23608361f, 0.29793853f, -0.08596544f, 0.16183059f, 
    0.02722929f, -0.11490655f, 0.28341562f, 0.11475583f, -0.00666875f, -0.07955652f, 0.09014875f, 0.07714707f, 
    0.04125898f, 0.00467196f, 0.12388719f, 0.16466685f, -0.26307622f, -0.26497233f, -0.31858388f, -0.05881916f, 
    -0.09439050f, 0.12088226f, 0.01161461f, -0.17282505f, 0.02138318f, 0.08832752f, 0.26150388f, 0.18012972f, 
    0.20028201f, -0.00151531f, 0.01370680f, 0.06110429f, -0.03688566f, -0.47352469f, -0.30597404f, -0.16936527f, 
    0.13244191f, 0.14969394f, 0.09069302f, 0.09290934f, -0.03201970f, -0.07452609f, 0.22760341f, -0.00383803f, 
    0.38839081f, -0.06324138f, 0.26581383f, 0.04268198f, -0.09615759f, -0.00477035f, 0.08228520f, -0.19179979f, 
    0.19476575f, -0.13706210f, 0.08684161f, -0.11079694f, -0.08579107f, -0.16115044f, 0.16775474f, -0.14206764f, 
    0.18453808f, -0.03862947f, 0.09055582f, -0.15032671f, -0.13995838f, -0.00357921f, 0.14816791f, -0.04905149f, 
    -0.13956961f, -0.02851309f, 0.00980114f, -0.43438524f, 0.12769835f, -0.02189238f, 0.04628707f, -0.08696815f, 
    0.12250116f, -0.21177535f, -0.01434551f, -0.17966162f, -0.04201424f, 0.02153127f, -0.02468333f, -0.14550604f, 
    0.06403315f, -0.07132689f, 0.14379439f, -0.10139804f, -0.00182540f, -0.05938574f, 0.19071645f, -0.02893997f, 
    0.15301624f, -0.08080252f, -0.16753063f, 0.11770602f, 0.06961773f, -0.09280884f, 0.03030351f, 0.05543329f, 
    -0.03804600f, 0.14639655f, -0.09870010f, 0.01620197f, 0.15181057f, -0.09710018f, -0.16711642f, 0.13637541f, 
    -0.11454204f, -0.03106674f, 0.18192552f, -0.12867643f, -0.12479468f, 0.15447283f, 0.27221590f, 0.18491821f, 
    -0.19630654f, -0.11646143f, 0.03823825f, -0.23441294f, 0.04349463f, -0.18945706f, 0.03261217f, 0.00150243f, 
    -0.02690178f, -0.10557126f, 0.05584586f, 0.16918321f, -0.04088768f, 0.01013105f, -0.21479958f, 0.20632906f, 
    -0.17038560f, 0.30820328f, -0.05959967f, -0.06282951f, 0.00894122f, 0.04958388f, 0.05989066f, 0.11644873f, 
    -0.22218947f, -0.05220804f, 0.09026212f, 0.11055693f, -0.05658611f, -0.10134842f, 0.09379353f, 0.16019458f, 
    0.12278777f, 0.06860843f, 0.09911191f, 0.48719159f, -0.16591175f, 0.22857727f, -0.16598780f, -0.10987950f, 
    -0.31634954f, 0.23167416f, -0.32320097f, -0.10369061f, 0.07753735f, -0.02654375f, 0.12064080f, -0.18766627f, 
    -0.20824921f, 0.03648639f, -0.10576760f, -0.03858240f, 0.03314161f, 0.09523080f, 0.02190989f, -0.15358067f, 
    0.11900116f, -0.02389649f, 0.08189838f, -0.01364586f, 0.06456698f, 0.10425708f, 0.18355258f, 0.07533071f, 
    0.11592050f, -0.02127641f, 0.26324648f, -0.11572208f, -0.14886799f, -0.27610347f, -0.04711047f, 0.11401506f, 
    0.30757773f, -0.05292013f, 0.05577572f, 0.08458160f, -0.08925817f, 0.16692333f, 0.01186952f, 0.29336977f, 
    -0.26696360f, -0.55626392f, 0.04202486f, -0.18723209f, 0.10033985f, -0.15206401f, 0.07486409f, -0.07868128f, 
    -0.32701877f, -0.30890301f, 0.05444559f, -0.15224989f, 0.09056537f, -0.10582978f, -0.01370181f, -0.10307375f, 
    -0.03510727f, -0.01821366f, -0.02031556f, -0.33261013f, -0.15973167f, 0.09498908f, -0.02550944f, -0.14634526f, 
    -0.00891958f, 0.11478636f, 0.30686498f, -0.00811412f, -0.20186448f, 0.06306534f, -0.16683386f, 0.11124443f, 
    0.02802388f, -0.23279634f, 0.07154995f, 0.29198328f, 0.13499343f, 0.09081095f, 0.03949682f, 0.13053837f, 
    0.16649368f, 0.09000453f, 0.05961878f, 0.21035783f, 0.13194743f, 0.10056191f, 0.05871698f, -0.01715618f, 
    0.07969867f, 0.02535773f, -0.01504885f, -0.06269660f, 0.05400797f, -0.53437185f, -0.35021821f, 0.17485641f, 
    0.21462221f, 0.22159040f, -0.02970781f, 0.06700726f, 0.06255881f, -0.24478011f, -0.03463351f, 0.05999494f, 
    -0.07959664f, 0.05769201f, -0.02969508f, -0.03757899f, 0.01809430f, 0.04099385f, -0.07828750f, -0.40119511f, 
    0.01379543f, -0.04831173f, 0.23751844f, 0.10740683f, 0.17093463f, -0.02997114f, 0.04207066f, 0.18352351f, 
    0.34838855f, 0.25889710f, -0.02195845f, 0.18062364f, -0.10827462f, -0.09954119f, -0.21260269f, 0.14548020f, 
    -0.22274737f, 0.39001828f, 0.19508998f, 0.25598809f, 0.11925016f, -0.10607403f, -0.15952088f, 0.07577036f, 
    -0.13786732f, -0.07471587f, -0.23459050f, -0.06783672f, 0.07567291f, -0.01470834f, -0.00971998f, -0.09907602f, 
    0.10886666f, -0.00213235f, 0.13013172f, 0.11026029f, 0.22322813f, 0.18076143f, -0.13312085f, -0.03679046f, 
    -0.11032017f, -0.14275119f, -0.21211040f, 0.03231439f, -0.21865875f, -0.36803997f, 0.08944999f, -0.29886183f, 
    -0.20150717f, 0.03646015f, -0.16447264f, 0.07897280f, 0.17968941f, 0.12441503f, 0.09600428f, 0.15361723f, 
    0.16125967f, 0.18454829f, -0.20556022f, 0.09932864f, -0.00493607f, -0.00826329f, 0.12262503f, -0.16955800f, 
    0.13670927f, 0.26082185f, -0.09936580f, 0.19435112f, -0.26472655f, -0.08603196f, -0.08731037f, -0.07633088f, 
    0.11412076f, -0.11329000f, -0.05304263f, 0.22318192f, -0.00633818f, -0.19176207f, -0.05999346f, -0.01673381f, 
    0.29319268f, -0.20827258f, 0.03094191f, 0.15973039f, 0.10791873f, 0.13958929f, 0.13930468f, 0.14587176f, 
    0.02759425f, 0.35553896f, 0.13096789f, 0.20764509f, 0.08670505f, 0.20965533f, -0.11644008f, -0.10914186f, 
    0.06742422f, -0.01574490f, -0.58133161f, 0.01205320f, 0.00703845f, -0.19475435f, -0.20722568f, -0.09523220f, 
    0.32027975f, -0.02077380f, -0.05536364f, 0.13775510f, 0.22797295f, 0.20155607f, -0.09129164f, -0.04393243f, 
    0.08342230f, -0.14798416f, 0.06527312f, -0.05756867f, -0.02530710f, -0.39019373f, -0.41207334f, -0.10681447f, 
    -0.06088594f, 0.07237095f, -0.13877450f, 0.11907706f, 0.09388375f, 0.01029016f, -0.15956271f, -0.29179633f, 
    -0.09671982f, 0.06866119f, 0.29748747f, -0.06175388f, 0.17071426f, -0.22310762f, -0.25719181f, -0.19453560f, 
    -0.29485694f, 0.07129637f, -0.02303319f, -0.17207973f, -0.08746069f, 0.08911575f, -0.08627344f, 0.18212897f, 
    0.11944642f, 0.18926896f, -0.08090814f, -0.08305045f, -0.13251238f, 0.03204678f, -0.00702449f, 0.00364846f, 
    -0.19948265f, -0.11380025f, 0.00788788f, 0.10174874f, 0.09251890f, -0.07745843f, 0.00009445f, -0.14252202f, 
    -0.34038326f, -0.01803312f, -0.12073961f, 0.12203679f, -0.05484254f, 0.15017891f, 0.19442539f, -0.21778359f, 
    0.02363649f, -0.04348809f, 0.48374012f, 0.17504539f, -0.06536701f, 0.04998735f, 0.18305312f, -0.12574938f, 
    -0.12487884f, 0.32692230f, 0.21609539f, 0.35941717f, 0.01387388f, 0.11421990f, 0.03063524f, -0.01596185f, 
    0.00245058f, -0.08213542f, 0.06813220f, 0.41848201f, -0.16593775f, -0.23663990f, -0.22287735f, 0.12467576f, 
    -0.20639059f, 0.09489846f, 0.08837778f, 0.00900848f, -0.14751631f, 0.11483327f, 0.20363370f, 0.06036713f, 
    0.11449505f, 0.27749562f, 0.13961147f, -0.27232864f, -0.18477899f, -0.20786458f, 0.14840940f, 0.00155714f, 
    -0.18378244f, -0.11134572f, -0.03974344f, -0.03895253f, 0.13215721f, -0.02033262f, -0.25179434f, -0.04848594f, 
    -0.06773867f, 0.16306300f, 0.13400282f, -0.01477634f, -0.13965026f, 0.10329957f, 0.21716669f, 0.07945821f, 
    0.23068577f, 0.27061674f, 0.11506233f, 0.22100691f, 0.03651944f, 0.03765274f, 0.25216484f, -0.00149457f, 
    -0.12304658f, -0.08150945f, 0.25313756f, -0.09142681f, -0.10599986f, 0.02527338f, -0.10688478f, 0.07504044f, 
    0.10071442f, 0.18269299f, -0.01411681f, -0.12372435f, -0.29399201f, -0.01310012f, 0.04621591f, -0.33856827f, 
    -0.08053984f, 0.14887056f, 0.05053148f, 0.21233557f, -0.13332728f, 0.01669852f, -0.12646161f, -0.06435789f, 
    0.05943542f, -0.14108655f, -0.02850779f, 0.09199466f, -0.46547791f, -0.02702056f, -0.11312114f, 0.09969675f, 
    -0.07822286f, 0.05946671f, -0.06587454f, -0.17296058f, 0.12947960f, 0.22670905f, 0.16953319f, -0.28779432f, 
    -0.03593425f, 0.04528391f, -0.12217771f, 0.01405201f, 0.09381490f, -0.17183082f, 0.26788753f, -0.07950734f, 
    0.08110906f, 0.02519988f, -0.09589197f, 0.09569190f, -0.23315154f, -0.01694971f, -0.33055362f, -0.09425993f, 
    -0.02894066f, 0.10086330f, -0.25779757f, 0.06373926f, 0.15080461f, 0.15219475f, 0.11415917f, -0.27793577f, 
    0.22699262f, 0.41059443f, -0.34745723f, 0.12111353f, -0.01358148f, -0.00231902f, -0.03651965f, -0.01113307f, 
    0.02993961f, -0.08216579f, -0.10416503f, -0.10333563f, -0.13713962f, -0.07737047f, 0.07731331f, 0.02425902f, 
    0.16396409f, -0.01553584f, -0.04810105f, 0.10169894f, 0.10244054f, -0.03683962f, 0.02876072f, -0.03641279f, 
    0.00212365f, -0.07718278f, 0.00759567f, -0.02842127f, -0.14255732f, 0.01816653f, -0.04315996f, 0.08263820f, 
    0.05964408f, -0.02484591f, 0.18893191f, -0.02412241f, 0.09488185f, 0.21183351f, 0.04424045f, 0.11789390f, 
    -0.01055674f, 0.16727975f, -0.10590281f, -0.16025245f, -0.05603699f, 0.33835605f, 0.29306972f, -0.05196760f, 
    -0.34459803f, -0.01519448f, 0.11396525f, 0.05247438f, -0.11587210f, 0.17180343f, 0.28478920f, -0.10534506f, 
    -0.26023680f, -0.12434418f, 0.12253379f, -0.04770570f, 0.17914151f, -0.00809580f, -0.08501828f, 0.69607681f, 
    -0.11378648f, -0.35762385f, -0.18750964f, -0.09067784f, -0.12983631f, -0.22144786f, -0.05796037f, -0.04543169f, 
    0.14325444f, 0.21889055f, -0.10340177f, -0.08286632f, 0.16764219f, -0.02076251f, -0.16132008f, 0.09139211f, 
    -0.09703252f, 0.03361882f, 0.02957247f, -0.03325516f, -0.32679409f, -0.26491565f, 0.07104880f, -0.00294748f, 
    0.16613738f, -0.03853195f, 0.35659680f, 0.18132481f, 0.19234529f, 0.36156461f, -0.17979100f, -0.12804611f, 
    0.09080067f, 0.09055454f, 0.08068941f, -0.24756986f, 0.23014313f, 0.21489391f, 0.10762955f, -0.22154352f, 
    0.05161936f, -0.12696156f, 0.00635415f, -0.09650842f, -0.02156169f, 0.33421558f, 0.21250446f, 0.13650285f, 
    -0.08202486f, -0.07506850f, 0.19871317f, 0.01689146f, -0.11253157f, 0.07099697f, -0.00747249f, -0.19716468f, 
    0.12016716f, 0.01581281f, -0.15177134f, 0.01905384f, 0.06590553f, -0.02966389f, -0.22939669f, -0.30608264f, 
    0.02199852f, 0.12678151f, 0.01067671f, 0.01162393f, 0.07089580f, -0.04079749f, 0.04355595f, -0.09939904f, 
    0.08789672f, 0.09429336f, -0.02757340f, 0.04353180f, -0.12689067f, -0.29497227f, -0.03190068f, 0.08782119f, 
    0.01377167f, -0.14383328f, -0.34361607f, -0.12854970f, -0.09613760f, 0.20312168f, -0.02188112f, 0.16255030f, 
    -0.31683949f, 0.20174226f, 0.25766665f, -0.12896988f, 0.14276242f, 0.08178468f, 0.10122766f, -0.06918937f, 
    0.01296016f, 0.05986576f, 0.04686119f, -0.33976281f, -0.03663613f, -0.15558477f, -0.15780106f, -0.03440434f, 
    -0.04945572f, 0.13017434f, -0.10009588f, 0.04037887f, -0.24798009f, 0.08597981f, -0.10591089f, -0.11475366f, 
    -0.05762064f, -0.13653691f, 0.20307165f, -0.01945022f, 0.40149468f, 0.02008651f, 0.02541214f, -0.03369508f, 
    -0.04186625f, -0.01743974f, 0.08814400f, 0.02725198f, -0.13034548f, 0.16118482f, 0.11276828f, -0.37247837f, 
    0.08289247f, 0.17530338f, 0.21899213f, 0.19968469f, 0.16723017f, -0.22266816f, 0.14946894f, -0.14908428f, 
    0.02690149f, 0.09987450f, -0.00669831f, 0.11439883f, 0.03738212f, -0.04225949f, -0.15842240f, -0.28130424f, 
    0.10956440f, -0.10404014f, -0.13284911f, -0.10289890f, -0.00182753f, -0.03423512f, 0.14763907f, -0.13008921f, 
    -0.04210929f, -0.11654773f, 0.09481110f, 0.23270109f, 0.24010183f, -0.04774666f, -0.02253796f, -0.27182883f, 
    0.02441611f, 0.19093569f, -0.16641420f, -0.27799109f, -0.21066608f, 0.15660125f, -0.21539137f, -0.19072685f, 
    0.29631382f, -0.04161490f, 0.02902545f, 0.09394811f, 0.20127605f, 0.04480218f, -0.05089105f, 0.11094261f, 
    0.08774955f, 0.07960787f, 0.04772429f, 0.07840800f, 0.12977761f, 0.16514950f, 0.14122221f, -0.17654808f, 
    -0.11235993f, 0.12368342f, 0.06593306f, 0.12982860f, 0.00443747f, -0.04146114f, 0.16392902f, -0.02005198f, 
    -0.01555485f, -0.04821167f, -0.21495326f, -0.01568490f, -0.11233747f, 0.08976705f, -0.14023550f, -0.30045539f, 
    -0.28748316f, -0.05813500f, -0.19796206f, -0.27412671f, 0.17545399f, 0.08985503f, 0.08129440f, 0.16973376f, 
    -0.21235108f, 0.00842609f, -0.08705582f, 0.01543472f, -0.20127699f, 0.13175188f, -0.09009936f, -0.04900067f, 
    -0.05451825f, 0.14851421f, -0.10261369f, -0.32450688f, 0.03591999f, 0.14174294f, 0.05971436f, 0.13287669f, 
    0.36822563f, 0.17720038f, -0.14727239f, -0.08198813f, -0.31932962f, 0.15849400f, 0.10033014f, 0.14448799f, 
    0.10042788f, -0.17894053f, 0.11487162f, 0.16168647f, -0.23569293f, -0.30963835f, -0.04735066f, 0.08680370f, 
    -0.10380060f, 0.02149342f, -0.18735236f, -0.17816451f, -0.04695091f, 0.15850982f, -0.00695453f, -0.03979646f, 
    -0.06519225f, 0.07948945f, 0.17977136f, -0.07618085f, 0.03887624f, -0.64631939f, -0.32049143f, -0.00442773f, 
    0.09940453f, 0.02910733f, 0.32052290f, 0.07128867f, -0.30224335f, -0.77002662f, 0.07806099f, 0.19943163f, 
    0.23142664f, 0.06213713f, 0.18446596f, 0.22615996f, -0.02891688f, 0.02604992f, 0.27160245f, -0.09916276f, 
    -0.15418151f, -0.40092474f, -0.28485283f, 0.01042746f, 0.16168073f, 0.12946185f, 0.36382276f, 0.12158703f, 
    0.12225720f, 0.20592006f, -0.09347238f, 0.08108666f, -0.06956284f, -0.14839484f, 0.06864952f, 0.05931629f, 
    0.45634761f, -0.26345712f, -0.16881034f, -0.34577301f, -0.13563195f, -0.02836877f, -0.22117037f, 0.02621331f, 
    -0.01581068f, 0.16754016f, 0.07605591f, 0.04210115f, 0.18345898f, 0.18009141f, 0.09339446f, 0.22656401f, 
    -0.10063471f, 0.14231847f, 0.32867336f, -0.15320764f, -0.14527991f, -0.12163903f, 0.02922840f, 0.02758816f, 
    0.23350342f, -0.00321725f, -0.33967626f, -0.58846039f, -0.10889759f, -0.07226260f, -0.14850350f, -0.09689270f, 
    -0.06632306f, -0.11362179f, -0.04973874f, -0.00457342f, 0.23632330f, 0.11665438f, -0.06217185f, -0.13319454f, 
    -0.03782430f, -0.06666060f, -0.07443597f, -0.04691821f, -0.53528583f, -0.79953259f, -0.07775512f, 0.28430125f, 
    0.06252841f, 0.03909747f, -0.07393125f, 0.13949977f, 0.06800836f, 0.51982433f, -0.24618945f, -0.23114830f, 
    0.06038046f, 0.01404290f, 0.00889480f, -0.09520173f, 0.27128416f, -0.27811000f, -0.29937306f, 0.12029967f, 
    0.05571671f, -0.00750707f, 0.10175960f, 0.04437235f, 0.02910572f, 0.08341949f, 0.10112502f, 0.02836588f, 
    0.25450349f, 0.05152765f, 0.22346693f, -0.24625365f, -0.01706550f, -0.18387204f, 0.01975504f, 0.22595714f, 
    -0.14708066f, -0.23959059f, 0.08138550f, 0.19292977f, -0.00598384f, 0.00868189f, -0.13324282f, -0.03415296f, 
    0.04572151f, 0.17271866f, -0.08405578f, 0.22392406f, 0.07103171f, 0.41385874f, 0.03397353f, 0.09362753f, 
    0.09779018f, -0.11573103f, 0.08086164f, 0.21738431f, -0.36010218f, -0.14883852f, 0.14107241f, -0.08049996f, 
    0.08964702f, 0.02997688f, 0.22823508f, 0.21562444f, 0.23126835f, -0.17286670f, -0.15120426f, 0.20598009f, 
    -0.07190132f, 0.31046259f, 0.33856127f, 0.12590009f, 0.17505936f, -0.24823409f, -0.12193325f, 0.36347792f, 
    -0.04902327f, 0.11592670f, 0.07717199f, 0.11846282f, 0.24141352f, -0.20758884f, 0.37414363f, 0.09815593f, 
    -0.20368013f, -0.06330926f, 0.10426784f, -0.25559431f, 0.03298470f, -0.09988863f, -0.38783872f, -0.79807675f, 
    -0.01787415f, 0.12219127f, 0.06537052f, -0.10155469f, -0.08884652f, -0.02918434f, 0.13156380f, -0.08953269f, 
    0.03984092f, -0.20658791f, -0.04140810f, -0.04316612f, 0.04361253f, -0.39036289f, 0.04408128f, -0.08584179f, 
    0.34269959f, -0.25636479f, 0.02200292f, 0.10963943f, 0.14492482f, -0.00745335f, 0.09471190f, 0.27817345f, 
    0.18864025f, -0.14121333f, 0.12159242f, -0.00301358f, 0.20978020f, 0.00732438f, -0.14055830f, 0.23331212f, 
    -0.00235014f, 0.18738316f, -0.12838647f, -0.08028160f, -0.12164795f, 0.06411260f, 0.24871607f, -0.29129735f, 
    0.03713783f, 0.17186466f, 0.08304170f, 0.37436131f, 0.10511010f, 0.05203763f, 0.14766797f, -0.02306584f, 
    0.14341183f, 0.12812231f, -0.09433814f, 0.11144283f, -0.53226930f, -0.11042786f, 0.02441102f, 0.31346694f, 
    0.23805375f, 0.20037211f, -0.18144099f, 0.07002008f, -0.00825251f, -0.06691325f, -0.16048670f, -0.08103218f, 
    -0.01561646f, 0.03433773f, -0.10437112f, -0.14945516f, 0.05479122f, 0.05908059f, 0.56652492f, 0.16864605f, 
    0.00081503f, -0.16727610f, 0.20344211f, -0.02993882f, 0.10546760f, 0.06705905f, 0.12013619f, 0.30597010f, 
    -0.11659730f, -0.04867017f, -0.26968986f, -0.15893488f, -0.12886114f, -0.02515011f, 0.28654456f, 0.36137605f, 
    -0.16935465f, -0.45283422f, 0.38418972f, 0.03202547f, 0.09762786f, 0.04719336f, -0.13863242f, -0.01684432f, 
    -0.04047391f, 0.33858743f, -0.09731565f, -0.19445311f, -0.00191729f, 0.00879112f, 0.03529618f, 0.18282625f, 
    0.15206726f, -0.39322469f, -0.08329932f, -0.20804732f, 0.02064303f, 0.08655242f, -0.21443328f, 0.12977439f, 
    0.03528219f, -0.03774849f, 0.14707704f, -0.10214655f, -0.45619431f, 0.01034384f, 0.04907898f, -0.11722549f, 
    -0.07032029f, 0.13689075f, -0.10291521f, 0.12281778f, 0.40550372f, 0.05431432f, -0.34530821f, 0.26240951f, 
    -0.19920401f, 0.06349950f, -0.01128275f, -0.04680924f, 0.04280292f, 0.58980310f, 0.51603323f, -0.08290716f, 
    0.22720310f, 0.10362861f, -0.13789582f, 0.12996273f, -0.00150672f, 0.06325665f, -0.15710849f, -0.12212262f, 
    -0.47627592f, 0.18541361f, 0.09381818f, 0.38292322f, -0.19171198f, 0.03864884f, -0.01371483f, 0.35650954f, 
    -0.95013863f, -0.08856535f, -0.17387556f, -0.25009722f, -0.12291879f, -0.11238144f, 0.13218458f, -0.11891853f, 
    0.23550159f, 0.08005102f, 0.31168032f, 0.17327212f, 0.17695981f, 0.00472244f, -0.02933657f, -0.06337649f, 
    -0.09829252f, 0.04902961f, 0.58375299f, -0.15840298f, 0.20989452f, -0.02939351f, -0.08893224f, 0.02076166f, 
    0.07136197f, -0.16741610f, 0.13411471f, -0.18936935f, -0.15882659f, -0.05149192f, -0.09082549f, 0.06827345f, 
    0.01631653f, 0.05844587f, 0.23772165f, -0.11448950f, 0.01613447f, -0.23210828f, -0.18156897f, 0.06421061f, 
    0.32303420f, -0.00739357f, 0.11808673f, -0.13240406f, -0.27502966f, 0.13020340f, 0.16147329f, 0.02276516f, 
    0.06023442f, 0.06308480f, 0.03899344f, -0.12413918f, 0.15616253f, -0.04425944f, 0.14708920f, -0.33236015f, 
    0.01408892f, -0.15035412f, 0.17333850f, 0.06315080f, 0.02440178f, 0.01459341f, 0.28113085f, 0.14519033f, 
    0.08763488f, 0.02359202f, 0.15324393f, -0.06363312f, 0.12486965f, -0.05608425f, 0.19346714f, 0.10563041f, 
    -0.21392851f, -0.11632790f, -0.12877202f, -0.02804703f, 0.08615962f, 0.03905408f, 0.10116050f, -0.00821550f, 
    0.45009100f, -0.45329526f, 0.06094323f, 0.01521396f, 0.12885875f, 0.15707335f, -0.01654692f, 0.02748279f, 
    -0.00219561f, 0.32819980f, 0.07996079f, 0.09086467f, 0.02817092f, -0.15155786f, 0.06837992f, -0.19311622f, 
    0.01776540f, 0.20157652f, 0.39213401f, -0.26966825f, -0.02633125f, -0.04425453f, -0.14107358f, -0.33508843f, 
    0.20114765f, 0.08993612f, 0.05990157f, 0.38730547f, 0.07259620f, -0.12607996f, -0.08755182f, -0.02195904f, 
    -0.04140604f, -0.04620807f, 0.05011546f, 0.05701096f, -0.20398794f, -0.07993089f, 0.17597115f, 0.02204720f, 
    -0.11434492f, 0.03755991f, 0.12955290f, -0.06642843f, -0.11842608f, -0.15393546f, -0.25559697f, 0.09571033f, 
    0.19899461f, 0.04492459f, 0.29755473f, -0.02459125f, -0.02216448f, -0.43004623f, 0.26843846f, 0.25068039f, 
    -0.06881756f, 0.11718697f, -0.18039361f, -0.03740456f, -0.04734738f, 0.06913074f, 0.15218951f, -0.93446869f, 
    0.38049129f, 0.32414198f, -0.16564877f, 0.13271806f, -0.09904613f, 0.03415306f, -0.00305244f, -0.15775317f, 
    -0.18133253f, -0.77512652f, -0.48162544f, 0.06001414f, 0.10009386f, -0.11925066f, 0.10314551f, -0.01649729f, 
    0.18080071f, -0.49692318f, 0.14490353f, 0.36382663f, -0.17414603f, 0.09427457f, -0.15378164f, 0.19332215f, 
    0.09639265f, -0.08828144f, -0.05297578f, 0.10385553f, -0.01536275f, 0.03949575f, -0.00136642f, 0.03179012f, 
    0.21134166f, 0.03210237f, -0.14185739f, -0.23724073f, -0.18873703f, 0.05164549f, 0.06424876f, -0.02732487f, 
    0.18720815f, 0.10255203f, -0.00445938f, 0.26194486f, 0.20420568f, 0.39129362f, -0.06856196f, -0.00624716f, 
    0.01309349f, -0.08097628f, 0.04131484f, 0.18750198f, 0.07347035f, -0.14415851f, 0.01213372f, -0.06089072f, 
    -0.09342559f, 0.09135140f, -0.19429842f, -0.03408938f, 0.01641089f, -0.06210558f, -0.05397038f, -0.30711797f, 
    0.03987516f, 0.00966150f, 0.17667367f, 0.01920297f, -0.07789744f, -0.03679397f, 0.01915665f, -0.54844373f, 
    -0.57291210f, -0.12104773f, -0.09474880f, 0.05095916f, -0.24673451f, 0.26279038f, 0.00135182f, 0.25941738f, 
    0.02090780f, -0.00879672f, -0.01242829f, 0.01176942f, -0.06494006f, 0.01603821f, -0.05931836f, 0.03875463f, 
    -0.05742023f, -0.02046885f, 0.02440940f, -0.03906510f, -0.01326928f, 0.01978810f, -0.05578581f, -0.04208692f, 
    -0.01455987f, 0.03452915f, -0.04374918f, -0.01169245f, -0.01239872f, -0.03497719f, -0.05534380f, 0.02044266f, 
    -0.01178138f, 0.02406102f, -0.00352994f, -0.04517074f, 0.02077714f, 0.04765991f, -0.00355475f, 0.00429662f, 
    0.02097008f, -0.00833673f, -0.05719072f, 0.01082903f, 0.03830868f, 0.05206390f, 0.01000874f, 0.00819587f, 
    -0.01001157f, -0.04579620f, 0.04522469f, -0.04535456f, -0.04368420f, -0.00787685f, -0.06436707f, -0.05835329f, 
    -0.01210860f, -0.04331081f, -0.01980322f, -0.01887965f, -0.02608838f, 0.04934986f, 0.01953605f, 0.03044913f, 
    -0.06248882f, -0.02318053f, 0.04832599f, 0.01595641f, -0.04471673f, -0.05396578f, 0.03299113f, -0.05940963f, 
    -0.05310373f, -0.00420494f, -0.02076089f, 0.02296539f, -0.03187255f, -0.01483287f, -0.03642665f, 0.00696799f, 
    0.02200576f, -0.03007953f, -0.04652620f, 0.04937522f, -0.00153089f, -0.00156029f, 0.00219722f, -0.02050232f, 
    -0.01597778f, -0.01726281f, -0.03427428f, 0.04354511f, 0.02738782f, -0.05468934f, 0.01338018f, 0.00392218f, 
    -0.04407816f, 0.00340279f, -0.04499083f, -0.00292601f, 0.02162677f, 0.03599364f, -0.04660191f, -0.00935108f, 
    -0.04875267f, -0.00089959f, -0.03449839f, -0.02403305f, -0.04452540f, -0.01506006f, 0.01269044f, 0.01890575f, 
    -0.04633163f, 0.02521341f, -0.01693289f, 0.02784710f, 0.05224271f, -0.02965471f, -0.05038033f, 0.00981739f, 
    -0.03628869f, -0.05768183f, 0.00081575f, -0.04483945f, 0.02922187f, -0.03533208f, 0.03748012f, -0.00740798f, 
    -0.05732369f, 0.04942224f, -0.00126271f, 0.01017796f, -0.03207063f, -0.00522358f, -0.01646527f, -0.03828464f, 
    0.04909274f, -0.05842192f, -0.02780629f, -0.05828498f, -0.00053318f, -0.02535900f, -0.01367820f, 0.04973576f, 
    0.00763157f, -0.01032576f, 0.04393446f, -0.00621013f, -0.06321439f, 0.03499616f, 0.00874545f, -0.03221450f, 
    0.00574711f, 0.01736359f, -0.02577722f, 0.01170685f, -0.06217141f, 0.00288568f, -0.01776593f, -0.03675738f, 
    -0.03527091f, -0.01686349f, -0.05945037f, -0.01513724f, 0.03029015f, -0.01131768f, -0.02835040f, -0.03194785f, 
    -0.03531694f, -0.03104892f, -0.03396738f, 0.02529156f, -0.03765417f, 0.03022477f, 0.00467296f, -0.00608996f, 
    0.03437332f, 0.04758263f, -0.04402987f, -0.02474528f, -0.03668308f, -0.00391961f, -0.05198803f, 0.01496934f, 
    0.03980212f, -0.00317772f, 0.01635429f, -0.04010215f, -0.02210177f, -0.02139872f, 0.01693941f, -0.00312016f, 
    -0.04876651f, -0.03215927f, -0.06211207f, -0.03856100f, -0.01111875f, 0.05203274f, 0.03660513f, -0.00298511f, 
    -0.03040027f, 0.03913003f, 0.01263273f, 0.01498204f, -0.01613962f, 0.01339220f, -0.02435645f, 0.04247335f, 
    0.05240536f, 0.04713548f, -0.03067510f, 0.03412426f, 0.04472043f, 0.00516452f, 0.04493650f, -0.04875123f, 
    -0.05271365f, 0.00767576f, -0.00050873f, 0.04811001f, 0.04841006f, 0.02977243f, -0.00426319f, 0.00878553f, 
    0.04502648f, -0.03384041f, 0.00100237f, 0.02152129f, 0.02978196f, 0.02255842f, -0.04834226f, -0.01418247f, 
    -0.01268987f, 0.04681442f, 0.00587341f, 0.04811195f, 0.01552487f, 0.04612556f, 0.03215511f, -0.00429620f, 
    0.00463138f, 0.01421289f, -0.03764049f, 0.04630167f, 0.02236219f, -0.05045704f, -0.00456028f, -0.05834426f, 
    -0.01087925f, 0.03835981f, -0.02297205f, -0.01533531f, 0.05244488f, -0.04092402f, -0.00268606f, -0.03011529f, 
    0.03338205f, -0.02978117f, 0.05009282f, -0.05343321f, -0.00343345f, -0.05080787f, 0.00409075f, -0.01469837f, 
    -0.03672969f, 0.02433455f, 0.02078116f, 0.01042002f, 0.00629595f, 0.03247394f, 0.03960279f, 0.00166564f, 
    -0.06264740f, 0.04436010f, 0.00396864f, -0.00771611f, 0.04358543f, 0.03375601f, -0.02246870f, 0.00705553f, 
    -0.03278229f, -0.04607454f, -0.03483490f, 0.04499367f, -0.04509083f, 0.00609547f, 0.00410765f, -0.03279433f, 
    -0.00228361f, 0.00984541f, 0.04900142f, 0.04671822f, -0.03054830f, -0.05131981f, 0.01876196f, -0.03078027f, 
    0.00147427f, -0.00187082f, 0.01123970f, 0.02758996f, 0.00327942f, 0.00341176f, 0.00491803f, 0.03484192f, 
    -0.02244802f, -0.00232702f, -0.01533636f, -0.02642930f, 0.02089256f, 0.00390230f, -0.06900984f, 0.00133684f, 
    0.01898726f, 0.01674363f, -0.05615474f, -0.03098741f, -0.06517753f, -0.04843942f, 0.03863905f, 0.04847520f, 
    0.01745678f, -0.05370841f, 0.04361711f, 0.04400244f, 0.01808301f, 0.02716923f, -0.01032455f, -0.04709579f, 
    -0.04734630f, 0.00182305f, -0.01142408f, 0.03252853f, -0.02721075f, 0.00199641f, -0.02361754f, 0.01081204f, 
    -0.02893073f, 0.00411559f, 0.04203529f, -0.05351398f, -0.00924871f, 0.01375638f, -0.02350587f, 0.03052950f, 
    0.00543258f, 0.02507454f, -0.00295102f, 0.00247235f, -0.06183746f, -0.01517343f, -0.03663167f, -0.03456444f, 
    0.01148326f, -0.03101805f, -0.06114970f, -0.00851081f, 0.01233635f, 0.04118745f, 0.01535651f, -0.05291079f, 
    0.02828219f, 0.04510286f, 0.01195598f, -0.03059362f, -0.03969904f, -0.01680928f, -0.01253108f, -0.00644900f, 
    -0.01761615f, -0.06099080f, 0.01391517f, -0.01029541f, -0.06162927f, -0.03657796f, 0.02098852f, 0.01367456f, 
    -0.00840057f, -0.00325771f, -0.01888465f, -0.02973021f, -0.06658461f, -0.05448114f, 0.01969751f, -0.06463823f, 
    -0.05900690f, 0.00938344f, -0.02321058f, 0.02849576f, -0.00395053f, 0.01419422f, -0.01789721f, 0.04259785f, 
    -0.06273278f, 0.00715395f, -0.02067776f, 0.04204124f, 0.03169524f, -0.02055705f, 0.01929268f, 0.03637322f, 
    0.01345939f, -0.00452504f, -0.01277528f, -0.04368477f, -0.02969334f, -0.04075085f, -0.01531744f, 0.00058030f, 
    -0.01948003f, -0.03765134f, -0.02749784f, 0.03937354f, -0.00548102f, 0.00382081f, -0.05060313f, -0.00854354f, 
    -0.04639932f, 0.02606253f, -0.02994885f, -0.02115938f, 0.00635267f, 0.01589869f, -0.02749513f, -0.02645360f, 
    0.01309267f, 0.02373448f, 0.00752770f, -0.05674545f, -0.06674802f, 0.04223016f, -0.04024318f, -0.05443129f, 
    -0.04148038f, 0.00994269f, -0.01866974f, -0.01339431f, 0.02711505f, -0.07120059f, 0.01640802f, 0.00532664f, 
    -0.05860196f, -0.04504881f, -0.00163876f, -0.00964483f, 0.02700284f, 0.02710214f, 0.01773566f, 0.00002859f, 
    0.04362629f, 0.01845367f, -0.02866119f, 0.05012621f, -0.03355830f, -0.04336723f, 0.00773528f, -0.03468993f, 
    0.02575907f, 0.03168497f, -0.03165917f, -0.04276596f, 0.02377364f, 0.03796995f, -0.05337487f, 0.04307060f, 
    0.02258026f, 0.00943830f, -0.01885417f, -0.04936241f, 0.03186171f, 0.02752346f, 0.00912039f, 0.02322808f, 
    -0.03278333f, 0.01873598f, 0.03204839f, -0.07451791f, -0.03704239f, 0.03494360f, 0.01044697f, -0.06111993f, 
    0.03824079f, -0.04027229f, -0.05093361f, -0.00439973f, 0.03339224f, 0.00273660f, -0.04191274f, -0.03707671f, 
    -0.01744657f, 0.05787972f, -0.00030643f, 0.02527831f, 0.04722295f, -0.01863421f, -0.01985507f, -0.00282410f, 
    -0.05314305f, 0.04021756f, 0.03712207f, -0.02228366f, 0.02791939f, -0.03255590f, 0.03460108f, -0.01709609f, 
    -0.03574364f, -0.02444889f, 0.02775349f, -0.06168204f, -0.01081462f, -0.06028959f, 0.02957530f, -0.01722877f, 
    0.00836978f, -0.00192018f, -0.03605553f, -0.05333446f, -0.04158922f, -0.03297738f, 0.04748273f, -0.04301059f, 
    0.00249499f, 0.03066782f, 0.02345840f, -0.03941841f, 0.03825988f, -0.07098625f, -0.07077946f, 0.04668979f, 
    0.03871959f, 0.00943166f, -0.03952966f, -0.04464145f, 0.01359704f, 0.01434642f, 0.03513731f, -0.06841598f, 
    0.01577391f, -0.04372080f, -0.00829024f, -0.04470464f, 0.00505947f, 0.02560622f, 0.00332745f, 0.04421507f, 
    -0.06394248f, -0.01923391f, -0.03572484f, -0.01059294f, -0.03463766f, -0.00438458f, 0.00204179f, -0.00407770f, 
    -0.02184888f, 0.02851543f, -0.06792041f, -0.05762349f, 0.04021103f, -0.05675774f, 0.00575417f, -0.03159332f, 
    -0.01080314f, -0.04626208f, -0.05960111f, -0.02982403f, -0.02153308f, 0.03780668f, 0.04108468f, -0.04545399f, 
    -0.04195626f, 0.04595670f, -0.00581789f, 0.00884844f, 0.03183011f, -0.07114629f, -0.05702000f, 0.04121883f, 
    0.02786993f, -0.01428208f, -0.04768692f, 0.00457044f, -0.05119978f, -0.00148017f, 0.01394395f, 0.01085448f, 
    -0.23205064f, -0.03957842f, 0.16505046f, -0.15217383f, 0.28991520f, -0.04194430f, -0.06867381f, -0.16833812f, 
    0.01088596f, 0.00633448f, -0.34692255f, -0.69380689f, 0.17299686f, 0.28026804f, 0.05267455f, -0.10548832f, 
    0.00389204f, -0.26097393f, -0.39486653f, -0.10115615f, 0.00511587f, -0.00112609f, 0.11804610f, 0.26566401f, 
    -0.07488009f, 0.11906041f, -0.29044214f, -0.10311082f, -0.43169525f, 0.00649171f, 0.13092218f, 0.14710198f, 
    -0.06509616f, -0.01798850f, -0.05928408f, -0.09259358f, -0.03902170f, 0.15017357f, 0.29867160f, -0.22857477f, 
    0.13187328f, -0.17257433f, -0.22155355f, 0.01124829f, -0.06153507f, 0.20163724f, -0.20182192f, -0.44606185f, 
    0.03339263f, 0.20998617f, 0.08009546f, 0.02220118f, 0.04150372f, -0.13670853f, 0.21220082f, 0.25859058f, 
    -0.07686300f, -0.09391822f, -0.12447545f, -0.07011425f, 0.00914472f, 0.04785557f, 0.10023453f, -0.04406193f, 
    -0.01756561f, 0.20386946f, 0.08805049f, -0.04651079f, -0.24063337f, 0.00607338f, 0.03407660f, 0.19222049f, 
    0.53866881f, -0.03829933f, -0.37284839f, 0.15343401f, 0.29254127f, 0.40485287f, -0.03663782f, -0.13104458f, 
    -0.08971158f, 0.36865598f, -0.12022463f, -0.24404895f, 0.25133252f, 0.03191315f, 0.12666041f, 0.03284671f, 
    0.01296183f, 0.08367057f, -0.29057023f, 0.06541406f, 0.20364790f, -0.23658584f, 0.20678021f, -0.02091071f, 
    -0.05174083f, -0.01777677f, 0.01991581f, -0.57828283f, -0.09608410f, 0.07529595f, 0.02306660f, 0.12115261f, 
    -0.02534952f, 0.17090853f, 0.19802602f, -0.08032079f, 0.14956859f, 0.31311116f, 0.35357150f, -0.20349170f, 
    -0.12295999f, 0.12994152f, -0.16278583f, 0.11793761f, -0.08221442f, -0.08519995f, -0.00273431f, 0.30296576f, 
    -0.25470129f, -0.23152067f, -0.05362295f, -0.01676679f, 0.31514403f, 0.11673449f, 0.46533298f, 0.04007103f, 
    0.07774968f, 0.09920140f, 0.00128991f, 0.20104209f, 0.30601272f, 0.05746947f, 0.11832507f, -0.47353986f, 
    -0.28250369f, 0.03342268f, 0.07043049f, 0.12581402f, 0.06695876f, 0.07079122f, -0.17723118f, -0.15024695f, 
    -0.07033344f, -0.27951086f, -0.13502325f, -0.04460131f, 0.10092850f, -0.14116399f, 0.00985135f, -0.11542894f, 
    -0.04260093f, -0.01498446f, 0.22389084f, 0.07315194f, -0.24577455f, 0.08738687f, -0.17725517f, -0.07758372f, 
    0.06804855f, 0.00511999f, -0.19412270f, -0.28912544f, -0.29436168f, 0.03981538f, -0.03413811f, 0.01335020f, 
    0.07665552f, -0.30239210f, 0.05204939f, 0.16572013f, -0.16614495f, -0.55561268f, 0.29627660f, 0.08418668f, 
    0.10135405f, 0.15432888f, -0.07214285f, -0.07488187f, 0.07624787f, 0.06138816f, 0.25411302f, -0.15276925f, 
    -0.03765611f, 0.00662225f, -0.04097258f, 0.02507549f, -0.21847451f, -0.10202922f, 0.07168765f, -0.13238075f, 
    -0.12636942f, 0.13133629f, 0.02464020f, 0.05246145f, -0.11230326f, -0.04795466f, 0.06345857f, 0.19610012f, 
    0.25962853f, -0.01207046f, -0.01058344f, -0.09639470f, -0.06909325f, 0.08351754f, 0.07274920f, 0.18728927f, 
    -0.11485513f, -0.08684422f, 0.10960263f, 0.21815515f, 0.06058407f, 0.04183425f, -0.03127770f, -0.33235893f, 
    -0.36981797f, -0.33116436f, 0.07828983f, -0.05524264f, 0.11883249f, -0.12696674f, -0.17674367f, -0.24993539f, 
    -0.02458253f, 0.12189672f, -0.17765529f, 0.25965342f, -0.23763449f, 0.06064323f, 0.02186259f, 0.09052486f, 
    0.00444629f, -0.12580429f, 0.63074040f, -0.06569259f, -0.27569363f, 0.06174325f, -0.08907323f, 0.16550829f, 
    0.11341594f, 0.07625375f, 0.22168183f, -0.01269182f, 0.34149301f, 0.15063834f, -0.10441902f, 0.06085233f, 
    0.04393655f, -0.18161947f, 0.10141194f, 0.07318138f, 0.08771102f, 0.26779866f, 0.39932534f, 0.19713506f, 
    0.28743631f, 0.37713531f, 0.22725022f, 0.02607013f, -0.05104613f, 0.36485913f, -0.18735228f, -0.30631372f, 
    0.27893791f, 0.03579915f, 0.10686287f, 0.29036775f, -0.04750570f, -0.18200374f, -0.12536941f, -0.18563390f, 
    -0.15230915f, -0.11199701f, 0.08523124f, 0.00877078f, -0.05505379f, 0.12737434f, 0.02558495f, 0.03198430f, 
    -0.17310134f, -0.08448912f, -0.04030456f, -0.05856948f, -0.31284234f, 0.11540972f, 0.45531753f, 0.11467312f, 
    0.06991971f, 0.43402952f, 0.18526946f, -0.16040103f, -0.17565440f, -0.15103716f, -0.06731769f, 0.06644201f, 
    -0.08550313f, 0.09670602f, 0.13471262f, 0.33241868f, 0.04458032f, 0.03478486f, -0.24040024f, 0.20660427f, 
    -0.13227113f, -0.14839128f, 0.25079975f, 0.16114427f, 0.09983356f, 0.11944964f, -0.14371924f, -0.15993364f, 
    0.09470358f, -0.00273689f, 0.34502992f, -0.20233317f, 0.24949168f, -0.19590606f, -0.00931680f, -0.17312041f, 
    -0.13289620f, 0.04412680f, -0.07217187f, 0.00793953f, -0.47112003f, -0.32009345f, 0.19519639f, 0.32945022f, 
    -0.00316082f, 0.03156321f, -0.13871787f, -0.14420888f, 0.12682746f, -0.04917124f, 0.18885757f, 0.26718020f, 
    0.00397241f, 0.03589900f, -0.08111436f, -0.03156316f, 0.18378934f, 0.10737496f, -0.22000377f, 0.01888842f, 
    -0.14792210f, 0.11556556f, -0.17647307f, 0.22345331f, -0.01013313f, -0.07095344f, -0.22178152f, 0.03866044f, 
    0.20296022f, 0.04590698f, 0.17649691f, -0.01692246f, -0.32468325f, -0.15580623f, 0.02062536f, -0.08823637f, 
    -0.01979750f, -0.01082182f, -0.06930430f, -0.04978529f, 0.14138123f, -0.03553864f, 0.09684211f, -0.02487645f, 
    -0.14640225f, 0.13862781f, 0.15321131f, 0.07882645f, 0.10570338f, 0.01261283f, 0.01041093f, 0.09211519f, 
    0.12931719f, -0.23470098f, -0.01319623f, 0.19850725f, -0.08439488f, 0.09038097f, -0.29502586f, -0.35145190f, 
    -0.01649846f, 0.10588874f, 0.13182747f, -0.32295808f, 0.14409187f, 0.30433255f, 0.09175307f, 0.08330700f, 
    -0.01959978f, -0.03786462f, -0.05723883f, 0.07385435f, -0.19481161f, -0.01258906f, 0.09391725f, 0.23766704f, 
    0.00665910f, -0.02869594f, -0.20910077f, 0.07665042f, 0.21426743f, -0.15745969f, -0.17814504f, -0.48134407f, 
    0.14121948f, -0.02004043f, 0.25898996f, -0.00064358f, -0.05393807f, -0.14488238f, -0.21316183f, 0.02313015f, 
    0.13905746f, -0.05972804f, 0.11774216f, -0.17653076f, -0.04974454f, 0.09149954f, 0.00449290f, -0.37583950f, 
    0.26652974f, 0.18979625f, -0.13070634f, 0.01191152f, -0.01308161f, -0.02807733f, 0.03393928f, -0.05730768f, 
    -0.32193968f, 0.04630622f, -0.20200944f, 0.12799363f, -0.15418130f, 0.09522628f, -0.07476825f, -0.15326649f, 
    0.02223753f, -0.23142794f, -0.40922719f, -0.00062536f, 0.01675453f, -0.08418159f, 0.17685804f, -0.03225999f, 
    -0.06579380f, 0.02921188f, 0.28379771f, 0.31295377f, 0.08910214f, 0.14885984f, 0.02854423f, -0.00267807f, 
    0.07118551f, -0.07000077f, -0.08844868f, 0.05632705f, 0.13958287f, -0.02119310f, 0.03761288f, 0.13328174f, 
    -0.24395275f, -0.06827255f, -0.06202089f, -0.00727932f, -0.08298621f, -0.04396375f, -0.05355625f, 0.11679665f, 
    -0.12048969f, 0.20763259f, 0.16692331f, -0.13957258f, 0.08332188f, 0.36058721f, 0.20677476f, 0.43713847f, 
    -0.01340570f, 0.13076577f, 0.09046962f, 0.00817507f, 0.12878495f, -0.13734859f, 0.10078384f, -0.28059980f, 
    0.13303350f, 0.12700984f, -0.16918297f, -0.02215783f, -0.04846142f, -0.11172212f, -0.13317028f, -0.08888939f, 
    -0.12528427f, 0.30165765f, -0.01834580f, -0.09410400f, 0.06466165f, -0.07388360f, 0.15361387f, -0.01319456f, 
    0.00577350f, 0.64626664f, 0.22716160f, -0.05772545f, -0.21090965f, 0.12509730f, 0.03991473f, -0.14290349f, 
    0.29846904f, 0.02053387f, -0.13455270f, 0.14055337f, 0.06449591f, 0.13094270f, -0.22669299f, 0.10408223f, 
    0.07983851f, 0.07985930f, -0.14650507f, 0.06126993f, -0.30454496f, 0.05227635f, 0.03657971f, -0.23923202f, 
    0.26871869f, -0.04660782f, 0.10735352f, -0.07016302f, -0.00873965f, -0.17924060f, -0.10473882f, -0.16576017f, 
    0.01835322f, -0.11324195f, -0.01044447f, 0.14521658f, 0.21741210f, 0.26698366f, -0.05175108f, -0.02982199f, 
    -0.01211745f, -0.19424173f, 0.08885725f, -0.08088852f, 0.03865052f, -0.00548225f, -0.05443887f, -0.27067327f, 
    0.17321789f, 0.05482778f, 0.03301647f, -0.01414020f, -0.14100318f, -0.07901925f, -0.10069706f, 0.10455433f, 
    -0.37203026f, -0.02126407f, -0.11281865f, 0.00295290f, 0.03077999f, -0.06457928f, -0.00976826f, 0.10331721f, 
    0.10970493f, -0.09819788f, -0.06794073f, 0.02606401f, -0.09464385f, -0.04334054f, 0.11192628f, 0.16345669f, 
    -0.00498936f, -0.02545377f, -0.04894894f, 0.01796361f, 0.02832537f, -0.01177518f, 0.02456813f, 0.00826852f, 
    0.01437285f, 0.02216502f, 0.02382591f, 0.02132420f, -0.04363428f, 0.02578039f, 0.04168734f, -0.06779572f, 
    -0.00107799f, -0.07237959f, 0.01252532f, 0.05752814f, -0.04720395f, 0.00543875f, -0.02952911f, -0.02607335f, 
    0.02196623f, -0.04386137f, -0.02247544f, 0.01205537f, -0.00178141f, 0.03159749f, 0.02395881f, -0.06140755f, 
    -0.03689641f, -0.00131626f, 0.02796019f, -0.02517327f, -0.06581379f, -0.00028496f, -0.06788968f, -0.02683196f, 
    0.00180677f, 0.02137992f, -0.01135435f, -0.04253179f, -0.02485029f, 0.03897712f, -0.02151083f, 0.00034408f, 
    0.00272865f, -0.02644897f, 0.03723546f, -0.03893097f, -0.05041555f, -0.00182147f, -0.04327814f, -0.05205323f, 
    -0.06121818f, -0.04967688f, 0.01650601f, -0.03445432f, 0.04293407f, 0.02003245f, 0.02518363f, -0.00247959f, 
    -0.06166397f, -0.05544427f, 0.01889931f, 0.03902180f, 0.02889634f, -0.05609935f, 0.01529984f, -0.02104580f, 
    0.03246316f, 0.02307468f, 0.03856428f, 0.04564543f, 0.03763460f, -0.01556997f, 0.04297689f, -0.05320714f, 
    0.03981989f, 0.03218694f, -0.07184731f, -0.00623707f, -0.03911337f, 0.04743857f, -0.01298829f, -0.01815899f, 
    -0.02049246f, -0.00791886f, -0.03843783f, -0.01507986f, -0.02427575f, -0.03733953f, -0.05505496f, -0.02083432f, 
    0.02350565f, 0.03604025f, 0.02238567f, -0.04201861f, -0.06274986f, -0.05624926f, 0.01446282f, -0.03624319f, 
    0.04305547f, -0.00544976f, 0.05495359f, -0.01982527f, -0.02370438f, -0.04720402f, 0.00161402f, 0.05804801f, 
    0.00407046f, 0.00227349f, -0.03842130f, 0.00796215f, 0.04402591f, -0.03568207f, 0.03483763f, 0.01470811f, 
    -0.03419498f, 0.02838926f, -0.02966714f, -0.00186997f, -0.00730940f, 0.01465930f, 0.03476821f, 0.02000611f, 
    0.01893437f, -0.06013628f, 0.02342238f, -0.05104600f, 0.00274135f, -0.00845219f, 0.05458716f, 0.04612753f, 
    -0.06225811f, -0.05648198f, 0.03152103f, -0.02226445f, 0.04875228f, -0.02588655f, 0.04034725f, -0.04789319f, 
    0.00968665f, -0.06042478f, -0.02989735f, 0.01672644f, -0.02037275f, -0.04675624f, 0.02929415f, -0.04866853f, 
    -0.00523664f, -0.05292029f, -0.00094563f, -0.05247167f, -0.00772651f, 0.00635772f, -0.04202068f, -0.04779338f, 
    -0.00852135f, -0.00376063f, 0.01326610f, 0.00945770f, -0.03182856f, -0.01384201f, -0.00608854f, -0.05455220f, 
    -0.02961385f, 0.02817614f, -0.06619859f, 0.02754223f, -0.00343891f, 0.03714499f, -0.00946153f, -0.05951391f, 
    -0.00021588f, -0.00622069f, -0.00731562f, -0.01179342f, 0.00136886f, 0.01262151f, 0.01896584f, -0.03169818f, 
    0.02037230f, -0.04059193f, 0.04148812f, 0.04616538f, -0.01297222f, -0.03516993f, 0.04161341f, -0.03507345f, 
    -0.03864376f, -0.03502438f, 0.01539895f, -0.01123766f, 0.03125981f, -0.01873691f, -0.01697304f, -0.00114799f, 
    0.01039125f, -0.04938141f, 0.02909905f, -0.02338635f, 0.02183355f, -0.00882830f, -0.02550718f, -0.02942158f, 
    0.04577290f, -0.04213162f, -0.06745064f, 0.04446245f, -0.01149176f, 0.02485318f, -0.04183767f, -0.01841615f, 
    -0.04800026f, 0.00263130f, -0.05130156f, -0.01790205f, 0.00901407f, -0.05800233f, -0.02463400f, 0.00827921f, 
    -0.06039513f, -0.04953481f, 0.02957134f, -0.00951791f, -0.04570668f, 0.03573002f, -0.02675035f, 0.02401981f, 
    0.04438087f, -0.00673075f, 0.02029832f, 0.01337539f, -0.05168653f, -0.06021618f, -0.04604638f, -0.03107979f, 
    0.01018816f, -0.06452537f, 0.01041031f, -0.05334450f, 0.03605972f, 0.01020694f, 0.02057198f, -0.02198477f, 
    0.00015017f, 0.04012557f, 0.02709007f, -0.01330799f, 0.05801538f, -0.00366617f, -0.02603603f, -0.06016780f, 
    0.05641107f, 0.02817341f, -0.06365230f, 0.04516752f, -0.00979992f, -0.04485838f, 0.03060011f, -0.05252497f, 
    -0.04098392f, 0.03150157f, -0.00186587f, -0.02940981f, -0.02864343f, -0.04399819f, 0.02699858f, -0.04967783f, 
    -0.04818282f, 0.01272686f, 0.00739146f, 0.02907979f, 0.00372345f, -0.02722667f, -0.02605079f, -0.03507404f, 
    0.01422573f, -0.03775896f, -0.01417227f, 0.01538926f, -0.05044127f, -0.01572396f, 0.00850665f, 0.00527944f, 
    -0.02355056f, 0.03753422f, -0.03758377f, -0.04611045f, 0.02057700f, 0.01106940f, 0.02258258f, -0.00665967f, 
    0.01355596f, 0.03156117f, -0.01027775f, 0.03123238f, -0.03569127f, 0.00748567f, -0.03244275f, -0.05876416f, 
    0.02229100f, 0.03781954f, -0.03989195f, 0.02127178f, -0.06550605f, 0.01886937f, 0.03050658f, 0.01002500f, 
    0.01196355f, 0.00850318f, 0.01821754f, 0.01346312f, 0.02643661f, 0.03348382f, 0.04524371f, -0.06355986f, 
    -0.02930967f, -0.04562212f, -0.01608443f, 0.01094913f, -0.04223216f, 0.02807028f, 0.04623581f, -0.02576853f, 
    -0.01868634f, -0.01765908f, -0.02498334f, -0.06080274f, -0.06113207f, 0.02117957f, -0.03648765f, -0.06177454f, 
    -0.05946035f, -0.01440424f, 0.01927953f, 0.01715742f, -0.00393194f, -0.04153860f, -0.04458765f, 0.01502580f, 
    0.05471831f, -0.03936411f, -0.02963741f, -0.05127684f, -0.01768874f, -0.03562919f, -0.01904929f, 0.01898185f, 
    -0.01221282f, 0.02413861f, 0.01439505f, -0.03325010f, -0.00130506f, -0.00954953f, -0.04804039f, 0.03115907f, 
    -0.06353702f, 0.01168230f, -0.04457598f, -0.00090049f, -0.03932098f, 0.01935855f, -0.01982644f, -0.03523659f, 
    -0.03569281f, -0.03373282f, -0.00273476f, -0.06253986f, -0.00274469f, 0.00095530f, -0.00860248f, 0.03202962f, 
    -0.01932443f, -0.05277833f, -0.04094261f, 0.02669248f, -0.00168254f, -0.01336863f, -0.04105401f, -0.04880052f, 
    0.02894643f, -0.06298718f, -0.02701805f, -0.00922976f, 0.04868213f, 0.01431829f, -0.02359852f, -0.04115613f, 
    0.02825747f, -0.02475356f, 0.01153778f, -0.03393080f, -0.03726835f, 0.03182013f, 0.03657213f, -0.03317618f, 
    -0.04954342f, 0.03071601f, -0.03592061f, 0.02769608f, 0.05471230f, 0.04534946f, 0.00919806f, 0.04275468f, 
    -0.03860047f, -0.00679883f, 0.03205555f, -0.03291344f, -0.05844049f, -0.00704351f, -0.03960583f, 0.04341622f, 
    0.05250995f, -0.01241024f, 0.02441484f, 0.04919703f, -0.02835121f, 0.00045496f, -0.04210809f, -0.02709869f, 
    -0.01889623f, 0.02997841f, 0.02507626f, -0.05212041f, 0.03534104f, 0.00613219f, -0.06240736f, 0.04680955f, 
    0.01508641f, 0.04467818f, -0.04172367f, -0.06172121f, -0.06153298f, 0.00290795f, 0.03800139f, -0.03871503f, 
    -0.03974562f, 0.01763228f, -0.03006631f, -0.04436124f, -0.06372651f, 0.02701599f, 0.05590909f, -0.03423792f, 
    -0.06326721f, 0.02119497f, -0.01364314f, 0.00387582f, 0.04108094f, 0.01667615f, 0.04740734f, -0.04393435f, 
    0.01321173f, 0.04659723f, 0.03085037f, 0.02932991f, -0.06037554f, 0.00039781f, -0.03651594f, -0.04044818f, 
    -0.05782013f, 0.02371431f, -0.05790019f, 0.03131382f, -0.02603474f, 0.04343762f, 0.02066515f, 0.03383354f, 
    0.03827995f, 0.02383902f, -0.01791965f, 0.03254361f, 0.04029234f, 0.02497758f, 0.04084800f, 0.04147392f, 
    0.04047085f, 0.03522150f, -0.03333938f, -0.05833599f, -0.05808499f, -0.03171040f, -0.02515350f, 0.01183443f, 
    0.01267798f, -0.00521216f, -0.05040804f, -0.05803049f, 0.04150261f, -0.03276962f, -0.01664842f, -0.05191834f, 
    0.02498904f, -0.06355307f, 0.00429622f, 0.00429816f, 0.03943582f, 0.03088942f, -0.04744748f, -0.04941985f, 
    0.00874427f, -0.02055028f, -0.03479070f, 0.00392452f, 0.01316177f, -0.04819622f, 0.03789775f, -0.03021384f, 
    -0.02360718f, 0.01505145f, -0.00401245f, 0.03989867f, 0.04971852f, -0.02313340f, 0.02520069f, -0.04381631f, 
    0.00887369f, 0.04762681f, -0.02377373f, 0.03989667f, -0.01520389f, -0.05813833f, -0.05524698f, -0.03788683f, 
    0.01251549f, -0.02491652f, -0.05261041f, 0.01170333f, 0.02881763f, -0.02719892f, -0.01126990f, 0.00479185f, 
    -0.03688046f, -0.03615959f, -0.05388490f, 0.03763178f, 0.00865997f, -0.00374657f, 0.04462673f, -0.05528111f, 
    0.04236934f, -0.05263346f, 0.00769722f, -0.01509427f, 0.02792001f, 0.02493056f, 0.00642066f, 0.01769651f, 
    -0.05440681f, 0.04086218f, -0.01067124f, -0.03197317f, -0.02350633f, -0.04742228f, -0.05842122f, -0.04277484f, 
    0.02050724f, -0.04715397f, 0.04414458f, -0.05744484f, 0.00886620f, -0.03866589f, -0.01298979f, -0.03719707f, 
    0.01941046f, -0.03928165f, -0.04944028f, 0.04951705f, 0.03910459f, -0.02490673f, -0.03776737f, -0.02251536f, 
    0.10106833f, 0.29876551f, 0.08433045f, 0.03607621f, 0.09740867f, -0.03412642f, 0.01718840f, -0.01221777f, 
    0.11569737f, 0.10380895f, 0.19894758f, 0.18450831f, 0.05194209f, 0.08686290f, -0.00678352f, 0.13636862f, 
    0.00914767f, 0.17646013f, 0.43153417f, 0.15484002f, 0.09414896f, 0.06857516f, 0.15341280f, 0.06518926f, 
    0.09317121f, -0.07186798f, -0.18448380f, -0.09080878f, 0.32537508f, -0.13428333f, 0.03272963f, 0.05383257f, 
    -0.05765012f, -0.28229693f, -0.01435643f, -0.07372829f, -0.02867956f, -0.13069950f, -0.03733593f, 0.12536444f, 
    0.03543665f, -0.17178814f, 0.02972345f, 0.10426052f, 0.07568480f, 0.29942906f, 0.19025576f, 0.21984644f, 
    -0.09916637f, -0.14542559f, -0.04239649f, -0.06317602f, 0.10248746f, 0.07088735f, -0.66036564f, -0.43515173f, 
    -0.43555313f, 0.08550621f, 0.05716175f, -0.27152663f, 0.02399975f, 0.17023234f, 0.13539906f, 0.02309977f, 
    -0.07938759f, -0.33929822f, 0.17747772f, 0.20781150f, -0.03908939f, -0.11812619f, -0.15878406f, 0.03763835f, 
    0.04279273f, -0.14619042f, -0.11831670f, 0.00250002f, -0.03644740f, 0.05967622f, -0.06093214f, -0.05833869f, 
    0.05433048f, 0.41201890f, 0.13184007f, 0.17279211f, 0.01635979f, -0.10549872f, 0.00727473f, 0.05502187f, 
    -0.02567160f, -0.00993120f, 0.03740394f, 0.01592421f, 0.02023932f, 0.13670960f, 0.11003322f, -0.04218900f, 
    -0.07690872f, -0.12355368f, 0.06823087f, 0.17229766f, 0.02776750f, 0.37450209f, -0.05171188f, -0.18607911f, 
    -0.28325045f, 0.05626319f, -0.00251332f, 0.07056166f, 0.04840465f, 0.02781929f, -0.17421125f, 0.00246808f, 
    -0.00523831f, 0.13526408f, -0.23312998f, -0.00664481f, -0.13280207f, -0.36986801f, -0.13726033f, -0.13613144f, 
    0.20534413f, 0.17896545f, 0.03641292f, -0.17513587f, 0.10295136f, 0.03234556f, -0.05880022f, 0.00184284f, 
    0.05538781f, -0.07681875f, 0.05286909f, -0.10406092f, 0.18474324f, 0.11975008f, 0.10892932f, -0.07462460f, 
    -0.20822066f, 0.04405637f, -0.06871008f, -0.04518541f, 0.11469448f, 0.19933842f, -0.23568839f, 0.15718628f, 
    -0.10219205f, -0.35484332f, -0.60467887f, 0.03878364f, 0.04327510f, 0.20380183f, -0.11683331f, 0.16123761f, 
    -0.21266627f, -0.43977213f, -0.31233189f, -0.28610504f, -0.03267751f, -0.16529845f, 0.03657851f, -0.20693733f, 
    0.18116550f, -0.19486736f, 0.01211533f, 0.20663014f, 0.02575482f, 0.02953995f, -0.19095472f, 0.17796077f, 
    0.23414528f, 0.00078346f, 0.18178165f, -0.08569989f, 0.25381762f, 0.01618121f, 0.13292447f, 0.10186646f, 
    0.03232550f, 0.09611486f, -0.00066038f, 0.07751030f, -0.27986693f, 0.05705761f, -0.15328184f, -0.09570339f, 
    0.17218886f, 0.04314644f, -0.10307378f, -0.12984505f, 0.17949228f, 0.18362680f, -0.30013490f, -0.02128555f, 
    -0.05446213f, 0.07868855f, 0.00771288f, -0.02006173f, 0.21391773f, 0.19608261f, 0.06970604f, 0.12931328f, 
    0.18365090f, 0.05695754f, 0.11945819f, 0.07574219f, -0.12129912f, 0.14088242f, -0.13950577f, 0.34776172f, 
    -0.06972490f, 0.14516349f, -0.03262404f, 0.00538412f, -0.00206706f, 0.13626546f, -0.06569959f, -0.04522956f, 
    0.00449006f, 0.02482826f, -0.38626987f, -0.05498799f, 0.18621197f, 0.10131878f, 0.30412227f, -0.10687999f, 
    0.01777604f, 0.46114022f, -0.00382086f, 0.17784742f, -0.07316466f, -0.12150997f, -0.03307964f, 0.01341491f, 
    -0.05298310f, -0.09264137f, 0.06212738f, 0.09360232f, 0.30163652f, -0.06019213f, 0.08126244f, 0.04983973f, 
    0.19442886f, 0.18770601f, -0.15660582f, -0.33011776f, -0.35041952f, -0.29575241f, -0.13894562f, -0.05416453f, 
    -0.18887131f, -0.05932270f, 0.00246112f, -0.16133417f, 0.36799559f, 0.11521631f, 0.32044339f, 0.01786940f, 
    0.11711675f, -0.06071053f, 0.05344052f, 0.18548821f, -0.01810234f, -0.05033112f, -0.06840426f, -0.30498105f, 
    0.22305994f, -0.01418646f, 0.03445831f, -0.06608261f, 0.25612172f, -0.00979501f, -0.32016104f, 0.06240065f, 
    -0.38640684f, -0.05507763f, 0.00982700f, 0.18720029f, -0.10448620f, 0.13465032f, -0.04714044f, -0.43919989f, 
    -0.12209921f, -0.16232076f, 0.05735087f, -0.11211535f, 0.10255568f, -0.08325644f, -0.12664816f, 0.24342221f, 
    -0.14004594f, -0.16485380f, 0.30130830f, 0.24098526f, -0.10683524f, -0.10420364f, 0.04666072f, -0.04150404f, 
    0.14449057f, 0.02136035f, 0.41313401f, 0.02242963f, 0.17849222f, 0.18685937f, 0.18955015f, -0.16247120f, 
    -0.06784794f, -0.04511552f, -0.20754714f, 0.13855614f, -0.34210435f, -0.30677229f, 0.19460638f, -0.12388208f, 
    0.09360327f, -0.43244338f, -0.08910357f, 0.00618018f, -0.25380456f, -0.02361286f, -0.10315466f, 0.18728128f, 
    -0.22165613f, 0.11020646f, -0.10074057f, 0.09375890f, 0.10704530f, -0.41544515f, -0.03484182f, -0.48967874f, 
    0.15781371f, -0.09376628f, -0.08789572f, -0.10718237f, 0.04790153f, -0.28946835f, -0.06024662f, -0.18741745f, 
    0.12827948f, 0.13470814f, 0.00489955f, -0.07117490f, -0.08095803f, 0.26907286f, -0.17713113f, -0.07724489f, 
    0.14128652f, 0.12293765f, -0.01015338f, 0.02350757f, 0.18600968f, -0.10761470f, 0.01733673f, -0.29014435f, 
    -0.20111483f, -0.17967339f, -0.48788345f, -0.20591202f, -0.00830356f, 0.19206487f, -0.06284573f, 0.28202784f, 
    0.15147369f, -0.16381086f, -0.32137483f, 0.08757067f, 0.09657381f, 0.28569907f, -0.11555275f, -0.14594232f, 
    -0.19468649f, 0.18557875f, 0.27591154f, 0.04414983f, 0.07197925f, 0.31954518f, 0.00385501f, 0.04356907f, 
    -0.04063794f, 0.21564367f, -0.36402658f, 0.15874897f, -0.07413736f, -0.34620860f, 0.15527681f, 0.06470878f, 
    -0.11384533f, -0.03767290f, -0.06814453f, -0.51178271f, -0.31524262f, 0.25752661f, 0.37405038f, 0.06111894f, 
    -0.03768239f, 0.15892431f, 0.17886211f, 0.17680484f, -0.13993870f, -0.02477805f, 0.14462657f, -0.13675000f, 
    0.48428121f, -0.21253182f, 0.07202777f, -0.14678995f, -0.08748226f, -0.14221674f, -0.13883530f, 0.00711851f, 
    -0.32589263f, -0.16871756f, 0.13383591f, -0.08177572f, 0.15246797f, -0.07927122f, 0.23785794f, 0.25738677f, 
    0.06101464f, -0.22981700f, -0.15491368f, -0.23458086f, 0.14109604f, 0.05386094f, 0.09018978f, -0.60676152f, 
    -0.47451961f, 0.27073199f, 0.13106571f, -0.09328815f, -0.03841566f, 0.15494253f, -0.01542881f, 0.14652087f, 
    -0.28075746f, 0.27049896f, 0.26095027f, -0.07521996f, -0.04701778f, 0.09841631f, -0.29294357f, 0.00025406f, 
    -0.17586842f, 0.14298649f, -0.08117012f, 0.06941513f, -0.53109246f, 0.10572925f, 0.08040428f, 0.07906438f, 
    0.06806374f, 0.10554919f, 0.48407856f, 0.29096949f, 0.02651499f, 0.05543987f, 0.19630404f, -0.03030600f, 
    0.09223884f, -0.10848811f, 0.20197722f, 0.13578537f, 0.08573974f, -0.42970863f, 0.10109178f, 0.15026738f, 
    0.08404269f, -0.02178448f, -0.06256433f, 0.13114290f, -0.16182294f, 0.07414964f, 0.07860871f, -0.17805426f, 
    0.11636071f, -0.00222222f, 0.05075425f, -0.35886312f, -0.03880389f, 0.07020585f, -0.07187056f, 0.31032413f, 
    0.35192156f, 0.00950930f, -0.22415783f, 0.03238943f, -0.01773824f, 0.02581892f, 0.17705689f, 0.18389513f, 
    0.10320470f, -0.34150007f, 0.21092953f, 0.12247617f, -0.06990294f, 0.01956585f, -0.03101321f, -0.42407456f, 
    -0.23279521f, -0.24851498f, 0.06153833f, 0.25805077f, -0.02827093f, 0.07343913f, 0.00277119f, -0.11301752f, 
    -0.08929373f, 0.21797939f, -0.09406387f, 0.11713174f, 0.20209347f, 0.13352199f, 0.04943334f, -0.08683412f, 
    -0.08245213f, 0.04539368f, 0.20963287f, 0.56895012f, 0.10356039f, 0.12659815f, -0.04167417f, -0.26000562f, 
    -0.07790777f, 0.10821684f, 0.05917877f, 0.14976749f, -0.00682206f, -0.00487862f, -0.08511297f, -0.12424049f, 
    0.10349729f, 0.21466741f, 0.15061702f, 0.05888309f, -0.08628455f, -0.05097209f, -0.30243480f, -0.01946851f, 
    -0.06388120f, -0.32388663f, 0.19654442f, 0.15945938f, 0.07245021f, 0.13980316f, 0.15643890f, 0.15536837f, 
    0.10954494f, -0.24470824f, 0.08197714f, -0.04175590f, 0.19207534f, 0.34655780f, 0.21544684f, 0.20554513f, 
    -0.07067449f, -0.01188881f, -0.07210504f, 0.13689221f, 0.12990838f, 0.12091543f, -0.05096789f, -0.18936960f, 
    -0.02798088f, -0.08998951f, -0.07825205f, -0.09607867f, -0.07844425f, 0.21057267f, 0.15077452f, -0.13816956f, 
    -0.08432607f, -0.20488137f, 0.06990571f, -0.15680887f, -0.21488701f, 0.10800685f, -0.00334720f, 0.23602337f, 
    0.01928573f, -0.01984699f, -0.04972387f, -0.04642789f, -0.01877451f, 0.01593063f, -0.06852683f, -0.00224322f, 
    -0.02305159f, 0.00577805f, -0.01375220f, 0.03859909f, 0.00762693f, -0.01633476f, -0.04694920f, -0.02632466f, 
    -0.00059075f, 0.03048020f, 0.03977846f, -0.03811677f, 0.03815883f, -0.01193700f, -0.01951051f, 0.00634741f, 
    0.01403773f, 0.01202351f, -0.04855098f, -0.02763101f, -0.02795177f, 0.03435335f, -0.00802295f, -0.01055827f, 
    -0.05046765f, 0.02709834f, -0.06187315f, -0.02990235f, -0.03443064f, -0.00996562f, 0.03111740f, -0.00620568f, 
    -0.01557490f, 0.01927087f, -0.00867865f, -0.06283552f, -0.04348749f, 0.02131453f, -0.04902269f, -0.02219305f, 
    -0.00591361f, 0.00523230f, 0.01774399f, 0.04012639f, 0.01376582f, -0.03592669f, 0.00607058f, -0.00668069f, 
    -0.06460819f, -0.06197569f, 0.04682470f, -0.04269956f, 0.03511758f, -0.07060345f, -0.00090124f, -0.04153297f, 
    -0.01966571f, -0.02621383f, 0.03076157f, 0.01060439f, 0.04778011f, -0.02688035f, 0.03117136f, 0.03543672f, 
    -0.05195733f, 0.02358104f, -0.02428942f, 0.01939961f, -0.06355011f, -0.00858218f, -0.06846090f, -0.04017960f, 
    0.04698309f, -0.03395504f, -0.02064750f, -0.03009930f, -0.07104257f, 0.03876679f, -0.05428781f, 0.01938485f, 
    -0.04660029f, 0.03514582f, 0.03171800f, -0.02957503f, -0.05867245f, -0.05815566f, -0.02872694f, 0.04405355f, 
    -0.02058985f, -0.04533527f, 0.01593790f, 0.01577313f, -0.01585097f, 0.00400259f, 0.04206064f, -0.02176899f, 
    0.03632077f, -0.00330456f, 0.03803225f, 0.02412125f, -0.02758735f, 0.03640047f, -0.00037486f, 0.00554594f, 
    0.00256505f, -0.04630299f, 0.04350347f, -0.01800484f, -0.05809924f, -0.01534705f, -0.01972312f, 0.01870781f, 
    0.01849141f, 0.03158873f, 0.01842127f, -0.03788362f, -0.01698901f, 0.02246633f, -0.06773926f, -0.01277795f, 
    -0.05977610f, 0.03272324f, 0.04144474f, -0.06191187f, -0.02160118f, -0.05078996f, -0.06724618f, -0.04189166f, 
    -0.05454084f, -0.03827517f, -0.01893564f, -0.04105168f, 0.02267137f, 0.00445007f, -0.02633032f, -0.02044617f, 
    0.02060294f, -0.00782395f, 0.04170140f, -0.04543120f, 0.01935360f, -0.03751513f, 0.04675417f, 0.00949105f, 
    -0.05875931f, -0.04304970f, 0.03606990f, 0.00594881f, 0.04669963f, 0.00336851f, -0.00379874f, 0.01420079f, 
    -0.06516758f, -0.06082662f, 0.03714935f, 0.02398770f, -0.01651882f, 0.01352891f, -0.05487309f, -0.05985449f, 
    -0.01387839f, -0.01240730f, -0.01286547f, -0.04580247f, 0.01980942f, -0.06112085f, 0.03638986f, -0.01911313f, 
    -0.03325057f, 0.02594973f, -0.00196698f, -0.00685693f, 0.03370244f, -0.00978073f, -0.01677997f, -0.01739241f, 
    0.04104955f, 0.00400282f, -0.03231626f, 0.00333934f, 0.00895394f, -0.04848066f, -0.03220443f, -0.02113789f, 
    0.01903441f, 0.03296366f, -0.05690239f, -0.02992439f, -0.03196485f, 0.00951793f, -0.05315034f, 0.00977270f, 
    0.04433713f, -0.01556890f, 0.04139506f, 0.01951857f, 0.03712678f, -0.06547981f, 0.03197331f, 0.01274972f, 
    -0.06674101f, -0.00306091f, -0.07044196f, -0.06214978f, 0.04948016f, 0.00433741f, 0.04280113f, -0.01931450f, 
    0.00136563f, -0.01884428f, 0.02799150f, -0.05570166f, 0.02900582f, -0.06330994f, -0.04107217f, 0.01342903f, 
    -0.01983246f, -0.01880610f, 0.01225388f, 0.00059817f, 0.01736134f, -0.05210294f, 0.01934094f, -0.01736163f, 
    -0.03169687f, 0.03502726f, -0.06515875f, 0.01914748f, -0.02402815f, 0.02978167f, -0.06580069f, 0.03988450f, 
    -0.01545841f, -0.02570371f, -0.05262921f, -0.00187476f, -0.03685909f, -0.02689051f, -0.05419332f, -0.06303583f, 
    0.00303964f, 0.02128688f, 0.02064998f, 0.04004909f, -0.00968067f, -0.01972125f, -0.00616491f, -0.00417533f, 
    -0.02025697f, -0.01487524f, 0.00869737f, 0.04313039f, 0.00665304f, 0.01248125f, 0.03556809f, -0.02227768f, 
    -0.02102521f, 0.01518275f, -0.05647484f, 0.03846623f, -0.02222397f, 0.00627371f, 0.00686755f, -0.04012204f, 
    -0.02502945f, 0.01027621f, -0.05714296f, 0.03486502f, 0.01981919f, 0.04369114f, 0.02370240f, 0.00587500f, 
    0.00978955f, -0.05507434f, 0.04759803f, -0.06002789f, -0.03349136f, 0.04168614f, -0.06145504f, 0.01050146f, 
    -0.08509698f, -0.03188973f, 0.02437382f, -0.02872714f, 0.00910787f, 0.03180794f, 0.03407967f, 0.02162994f, 
    -0.04710418f, -0.01726291f, 0.02151486f, -0.06438850f, -0.01775132f, 0.02923207f, 0.03168843f, 0.00476963f, 
    -0.04214875f, -0.00552267f, -0.00534508f, 0.05010318f, -0.05971865f, -0.04820450f, 0.06224811f, 0.04880013f, 
    -0.06543347f, 0.03576314f, -0.05984887f, -0.04132313f, -0.04631369f, -0.03674422f, 0.01813933f, -0.02792377f, 
    -0.00819433f, -0.00186751f, 0.02923229f, -0.00196421f, 0.04229547f, 0.00316215f, -0.03962560f, 0.00729274f, 
    -0.02335740f, 0.01983769f, 0.02564196f, -0.06697609f, -0.06144584f, 0.00629353f, -0.00223868f, 0.02284756f, 
    -0.00176193f, -0.00260781f, -0.00034239f, -0.06538919f, 0.00768393f, -0.00540529f, 0.02205900f, -0.04935624f, 
    -0.02699960f, 0.01311872f, -0.03659986f, 0.04379258f, -0.03529324f, 0.03296125f, -0.06067830f, 0.00135835f, 
    -0.00707007f, 0.00997607f, 0.01317347f, 0.01200037f, 0.06255080f, 0.00431320f, -0.02595084f, -0.06303149f, 
    0.00363876f, -0.01116665f, -0.01121188f, 0.04361039f, 0.01765409f, -0.02740516f, 0.01513663f, 0.01639969f, 
    0.04655453f, -0.06055271f, -0.06028356f, -0.03673984f, 0.04598629f, -0.04918450f, -0.04291870f, -0.06906641f, 
    -0.00089182f, 0.01538119f, 0.01111809f, -0.03602954f, 0.03881562f, -0.01411574f, 0.05119408f, 0.03123534f, 
    -0.03360888f, -0.06648134f, 0.02923134f, -0.00102265f, -0.08719175f, -0.04998841f, -0.07282930f, -0.00158421f, 
    -0.03758022f, -0.04257299f, 0.02907909f, 0.00778225f, -0.05983578f, 0.04295683f, 0.00792788f, -0.04156131f, 
    0.03729605f, -0.01599202f, -0.00407656f, -0.05112396f, 0.01744259f, -0.04106750f, -0.05147140f, 0.01024609f, 
    0.03633899f, -0.02159141f, -0.03545443f, 0.01025323f, -0.02090890f, -0.05704451f, -0.04284131f, -0.02370850f, 
    0.00983922f, 0.04599814f, 0.03099659f, 0.03906292f, -0.00199107f, -0.02882826f, -0.03291655f, 0.01242806f, 
    0.00295311f, 0.02355525f, 0.00025737f, -0.05561052f, -0.06575889f, -0.07164156f, 0.06470387f, 0.00381811f, 
    -0.02263697f, -0.05361941f, -0.03425083f, -0.04413436f, -0.03578556f, 0.02886737f, 0.01821993f, 0.02567586f, 
    -0.03892486f, 0.04450379f, 0.02111989f, -0.05401627f, 0.04812706f, -0.03832704f, -0.01762649f, -0.06007223f, 
    0.00580155f, 0.02827305f, -0.08124481f, -0.02552003f, -0.06821662f, -0.01887549f, 0.03525013f, 0.04172423f, 
    -0.02025483f, -0.00506550f, -0.00616018f, 0.02649320f, -0.06559416f, -0.05980207f, 0.03205840f, -0.04436047f, 
    -0.06600799f, 0.01897413f, -0.02501673f, -0.00552910f, 0.02385891f, 0.02418537f, -0.04530843f, -0.04212543f, 
    -0.02336837f, -0.02035384f, -0.01953478f, 0.04056113f, 0.01924812f, 0.01430973f, 0.01352181f, -0.03492542f, 
    -0.06288819f, 0.02762669f, 0.01089487f, -0.03488879f, 0.02486022f, 0.00339342f, 0.01641212f, -0.02359223f, 
    -0.03021597f, 0.01245480f, -0.04937560f, -0.02436071f, -0.05766128f, -0.06140935f, 0.00961480f, -0.07410733f, 
    0.03360189f, -0.02985823f, -0.02356716f, 0.02613291f, 0.02622214f, -0.03195971f, -0.06364741f, -0.05428773f, 
    0.02446090f, -0.01634702f, 0.01854776f, -0.03164771f, 0.00152599f, 0.02725075f, 0.00591537f, -0.03963880f, 
    0.05122522f, 0.01322998f, -0.00467819f, -0.02504690f, 0.01478966f, 0.01404131f, 0.00587570f, -0.07537720f, 
    -0.01768441f, -0.00741030f, 0.03623713f, -0.03414584f, -0.04540785f, 0.01052145f, -0.07043648f, 0.00664358f, 
    -0.03710549f, -0.03547337f, -0.04059673f, 0.01941845f, 0.03068149f, 0.03527422f, 0.00333820f, 0.02456100f, 
    -0.05337502f, -0.07954969f, -0.00139420f, -0.07290389f, 0.05777918f, 0.03882035f, 0.01152878f, 0.02413841f, 
    0.01748319f, -0.01283801f, -0.02035367f, -0.03393110f, -0.03636064f, -0.00648777f, -0.06777374f, 0.01531818f, 
    0.02729524f, 0.01918909f, -0.01333386f, 0.01757277f, -0.02200669f, -0.00531458f, -0.04559137f, -0.00414363f, 
    0.02073821f, -0.05027860f, -0.02020045f, -0.01864054f, -0.00034142f, 0.02630096f, 0.02983462f, -0.07269526f, 
    0.00734794f, -0.00589428f, -0.06360164f, -0.02845570f, 0.01766722f, 0.02559990f, 0.04128250f, 0.00742957f, 
    0.08416331f, 0.11812376f, 0.43407732f, -0.18532780f, -0.05040923f, 0.03293715f, -0.02294947f, 0.03512710f, 
    -0.10541292f, -0.13633025f, 0.44550124f, 0.37538761f, 0.33135295f, 0.00851830f, 0.10129789f, -0.11135317f, 
    0.04013033f, -0.01594418f, -0.01266114f, 0.09168641f, -0.09337475f, 0.03817337f, 0.01667462f, -0.00128628f, 
    -0.11432984f, 0.03717253f, 0.12408389f, 0.30637303f, 0.24451192f, -0.15979068f, -0.14690192f, 0.13098307f, 
    0.22971204f, 0.09115959f, 0.18093041f, -0.05067582f, -0.28345186f, 0.05154806f, 0.01618852f, 0.15869242f, 
    -0.08874267f, -0.01397238f, -0.03912869f, 0.09392955f, -0.00151516f, -0.11129288f, 0.13786900f, 0.31518248f, 
    0.23680170f, 0.05934552f, 0.02225395f, 0.04310681f, 0.05501257f, 0.20185913f, -0.16634494f, -0.08714897f, 
    0.04631295f, 0.29748249f, -0.07478898f, 0.06048715f, 0.09874543f, -0.14404410f, -0.07864171f, -0.11479298f, 
    -0.15867400f, -0.03179580f, 0.05322557f, 0.09739649f, -0.04882208f, -0.13461620f, -0.07088254f, 0.17245109f, 
    0.07386209f, 0.05499703f, -0.05999929f, -0.10026176f, -0.15858026f, 0.01683959f, 0.06437324f, -0.18586285f, 
    -0.14745232f, -0.09406547f, 0.18282412f, 0.34897569f, 0.06629889f, -0.02606175f, 0.00364201f, -0.01931163f, 
    0.00612282f, 0.06512497f, -0.35970828f, -0.17671682f, -0.01246672f, 0.04766465f, -0.18396272f, -0.05326582f, 
    0.09786213f, 0.00596435f, 0.08107466f, -0.39190418f, -0.04350987f, 0.02286913f, 0.25859711f, -0.05679472f, 
    -0.05303993f, 0.03416785f, 0.16497199f, -0.13680370f, -0.12158158f, 0.00706074f, 0.15357386f, -0.04888692f, 
    -0.04270673f, -0.04239587f, -0.10233854f, 0.01884598f, -0.02503264f, -0.01105069f, -0.24419883f, -0.23456527f, 
    -0.31358030f, 0.15304461f, -0.13578919f, 0.13449143f, -0.09267746f, 0.11059237f, 0.15076317f, 0.01313334f, 
    -0.45647120f, 0.00385496f, 0.02075883f, -0.12582098f, -0.00556687f, 0.24606480f, -0.06330375f, -0.31765053f, 
    -0.06855166f, 0.03694811f, 0.04601713f, 0.04292666f, -0.07185888f, -0.03534864f, 0.00174234f, -0.11075027f, 
    -0.08534089f, 0.12452441f, 0.09413927f, 0.04639889f, 0.05217413f, -0.02464599f, -0.25862744f, -0.33938941f, 
    -0.26007438f, -0.18758056f, -0.06130588f, 0.12547037f, -0.02042521f, -0.00368571f, -0.14367512f, 0.04995675f, 
    -0.19551539f, 0.08946166f, -0.04568660f, 0.19577481f, 0.41979632f, 0.02744718f, -0.04354190f, 0.16557164f, 
    0.11468539f, 0.04399810f, -0.02529328f, -0.10152681f, 0.07404270f, 0.28884405f, -0.03206399f, -0.16068569f, 
    0.04546508f, 0.17024416f, -0.02604925f, 0.27076000f, -0.31890079f, -0.07792488f, 0.12344529f, 0.09726489f, 
    0.01364288f, 0.01849681f, -0.00385485f, 0.06501792f, 0.16785714f, 0.13741727f, 0.14815070f, 0.29985771f, 
    -0.04658081f, 0.00515260f, 0.17543076f, -0.05815833f, 0.15665038f, -0.07664387f, -0.09515037f, 0.20788439f, 
    0.17963237f, 0.01088660f, -0.26838741f, -0.03969638f, 0.08641739f, -0.02081783f, -0.09477654f, -0.06477359f, 
    0.06320623f, -0.24181424f, -0.02281065f, -0.22233315f, 0.00526106f, -0.02039484f, -0.04114936f, 0.04144400f, 
    0.08203360f, -0.20736438f, 0.20776287f, -0.13590777f, -0.07203545f, -0.01188250f, -0.04374972f, 0.14954060f, 
    0.03000049f, 0.34484473f, 0.05182008f, 0.28669453f, -0.05856123f, -0.21446212f, 0.16517927f, 0.15102640f, 
    -0.12597555f, 0.11274601f, -0.01693741f, -0.05904398f, -0.15826006f, -0.06295937f, -0.01992944f, 0.05356397f, 
    0.07642394f, 0.09218649f, 0.06442715f, -0.13478824f, -0.12093864f, -0.13043083f, -0.20646548f, -0.02953981f, 
    -0.25579822f, -0.07308855f, -0.23693711f, -0.05040009f, 0.18033119f, -0.04259722f, 0.06403190f, -0.20246822f, 
    -0.39857227f, -0.11799432f, 0.22746497f, 0.02359817f, 0.07276186f, 0.32169086f, -0.10353220f, 0.12521678f, 
    -0.08052059f, -0.27720404f, -0.06079398f, 0.04946351f, 0.07865452f, -0.15925276f, 0.13282627f, -0.05582028f, 
    0.08570863f, -0.01255186f, 0.02752785f, -0.09130400f, 0.19386847f, -0.04425452f, 0.14379728f, 0.05050352f, 
    -0.10749244f, -0.24837701f, -0.01120878f, 0.06172184f, -0.04519952f, 0.19666143f, 0.02982341f, 0.00670521f, 
    0.16652955f, 0.19040130f, -0.05568966f, 0.01560984f, -0.10877206f, -0.11711324f, 0.05148095f, -0.27364254f, 
    0.15495056f, 0.02001765f, 0.45269197f, 0.24773525f, 0.17237270f, 0.13709426f, 0.05828563f, -0.19282463f, 
    0.24248059f, 0.24120967f, -0.23003066f, -0.00885213f, -0.06944946f, -0.17173441f, 0.05584868f, 0.10391094f, 
    -0.19092473f, -0.02067826f, -0.37809002f, 0.18561736f, 0.14481942f, -0.23904841f, -0.03642767f, -0.01162398f, 
    -0.15354185f, 0.01951315f, -0.05437310f, -0.14350204f, 0.07170493f, -0.54741007f, -0.39863452f, -0.15306118f, 
    0.25481912f, 0.11945307f, 0.04922082f, -0.13406615f, -0.02230772f, 0.13538945f, 0.16148414f, -0.01532363f, 
    0.09810716f, 0.09307553f, 0.04754710f, 0.04903305f, -0.05208180f, 0.23390876f, 0.18970527f, 0.14894775f, 
    0.05183243f, 0.02436113f, -0.06885910f, 0.03577770f, 0.03193375f, 0.06904154f, 0.10560849f, 0.20580579f, 
    0.06261486f, 0.08142240f, -0.23019303f, -0.00056589f, -0.42457777f, -0.12805697f, 0.23935856f, 0.20580493f, 
    0.31074432f, 0.25323939f, -0.16043700f, -0.19211799f, 0.17386629f, -0.09030478f, -0.08950350f, -0.10171035f, 
    0.04685403f, -0.00905727f, 0.19543421f, 0.27884498f, 0.14481305f, 0.16130686f, -0.04269712f, 0.10592765f, 
    0.00491830f, 0.30830365f, 0.06159098f, 0.25999513f, 0.08602723f, -0.02302421f, 0.11897210f, -0.03587150f, 
    -0.19615647f, -0.18585908f, -0.07135987f, -0.08588895f, 0.12026522f, 0.20294587f, 0.01908425f, 0.18097289f, 
    -0.31659317f, 0.11809777f, -0.30280420f, 0.10209364f, -0.41778469f, -0.54128331f, -0.24367252f, -0.07065020f, 
    0.03454319f, 0.08165783f, 0.10294901f, 0.16653706f, -0.25275195f, 0.24033913f, 0.01996967f, -0.32492822f, 
    -0.16638763f, 0.05118812f, -0.00756107f, -0.00369823f, -0.14338177f, -0.21496992f, -0.14175871f, -0.38731191f, 
    -0.22237186f, -0.06307170f, -0.07225506f, 0.25891820f, -0.02262109f, 0.21223649f, -0.19162768f, -0.34232748f, 
    0.10281713f, 0.02827215f, 0.19236109f, 0.29507634f, -0.36205226f, 0.22342391f, -0.13517769f, 0.07497716f, 
    -0.12294412f, 0.18734890f, -0.16292140f, -0.17310406f, -0.14050232f, -0.16098130f, 0.08429278f, -0.09183991f, 
    -0.00367167f, 0.27464312f, -0.27995265f, -0.10729434f, -0.08598115f, 0.19981375f, -0.09962980f, 0.02312973f, 
    0.08052304f, 0.09118199f, -0.10173981f, 0.16129611f, 0.06760099f, 0.06581726f, 0.04970205f, 0.16959560f, 
    -0.12154183f, -0.14650759f, 0.26884988f, -0.13582700f, -0.02113451f, 0.13794114f, 0.14198631f, 0.20295641f, 
    -0.06141986f, 0.06921782f, 0.22601007f, 0.11498371f, 0.19880554f, -0.19943404f, 0.22264457f, 0.02662724f, 
    -0.34039888f, 0.10997745f, -0.12989713f, 0.04038045f, -0.11198697f, 0.14440946f, 0.39761502f, -0.10475300f, 
    0.13541922f, 0.01102396f, -0.07883576f, 0.18537878f, -0.38035992f, 0.25602767f, -0.10261609f, -0.19889942f, 
    -0.14313768f, 0.01074435f, 0.06116369f, -0.07347943f, 0.08839113f, 0.05051313f, 0.12816906f, 0.40474570f, 
    -0.26392108f, -0.34144366f, -0.09832525f, 0.05938842f, 0.04059319f, 0.00553919f, 0.08149561f, -0.32356042f, 
    0.53576159f, 0.14906281f, 0.17556876f, 0.00338894f, -0.03777647f, 0.05268946f, -0.24370140f, 0.10323876f, 
    -0.12493789f, 0.18783170f, 0.22273724f, 0.15398659f, 0.19483761f, -0.05621605f, 0.19313049f, 0.13567790f, 
    -0.13597082f, -0.23435912f, -0.08278259f, 0.02506706f, -0.11766750f, -0.12214919f, 0.18304561f, -0.04243138f, 
    -0.08800186f, -0.09447595f, 0.03451313f, -0.29727310f, -0.21538146f, 0.14609256f, -0.00368869f, 0.00078234f, 
    -0.25824174f, 0.09910238f, -0.10255228f, 0.09471354f, -0.57154536f, -0.22935189f, 0.35227507f, 0.25277960f, 
    -0.03461203f, 0.32150057f, 0.01146165f, 0.03451135f, -0.37208369f, 0.42845356f, 0.30354869f, 0.50424987f, 
    0.40016335f, -0.27514032f, -0.03296662f, -0.04039226f, 0.17090677f, 0.00932057f, 0.46624041f, 0.14711732f, 
    0.06505334f, 0.01036411f, -0.13097607f, 0.01213688f, 0.05312430f, -0.05571432f, 0.16179670f, 0.43620467f, 
    -0.30121055f, 0.41417781f, -0.05997570f, -0.01460614f, -0.00316962f, -0.30719948f, 0.02946253f, -0.18854703f, 
    -0.12579085f, 0.06840029f, -0.05036076f, 0.03421989f, 0.10457411f, -0.11249088f, -0.01964558f, 0.11253934f, 
    -0.03579995f, 0.05014527f, -0.10976449f, -0.22164090f, 0.05720347f, 0.04470223f, 0.15713948f, 0.05285230f, 
    -0.15733513f, -0.14453070f, 0.25810358f, 0.20330437f, -0.03199153f, -0.08740079f, 0.03236387f, 0.03975940f, 
    0.08046741f, -0.03363447f, -0.05462481f, -0.23677261f, -0.59123015f, -0.40811244f, 0.07026707f, -0.00497967f, 
    -0.00742062f, -0.07389151f, -0.09680406f, 0.01910535f, -0.03941858f, -0.01696545f, 0.37041858f, 0.25647828f, 
    0.18612449f, -0.03596238f, 0.05618313f, -0.17702106f, 0.21936347f, -0.22049028f, -0.17723779f, -0.11540538f, 
    0.07237329f, 0.25111273f, -0.06353216f, -0.04467967f, -0.13224202f, 0.22691397f, 0.28008705f, 0.22023404f, 
    0.17752026f, -0.27085626f, 0.12920406f, -0.01470034f, -0.02026444f, 0.15923958f, -0.13685070f, -0.13853186f, 
    -0.92211056f, -0.21353383f, 0.18104558f, 0.12156177f, 0.01458589f, -0.18529403f, 0.12645289f, -0.16009651f, 
    -0.86958915f, -0.06584530f, 0.03628107f, -0.16933605f, 0.00634190f, 0.01474375f, 0.14934669f, -0.09097223f, 
    -0.24796464f, -0.18861517f, -0.00916666f, -0.28260350f, -0.02799523f, -0.08897967f, 0.14449717f, 0.06435051f, 
    -0.00801034f, 0.03128935f, -0.32819590f, -0.04737132f, -0.05542596f, -0.16391967f, -0.21430613f, -0.34127942f, 
    -0.19999965f, 0.04124697f, 0.17432551f, 0.08533572f, 0.04629728f, -0.07577780f, 0.09265403f, 0.01796446f, 
    -0.02913281f, 0.24205448f, 0.27392772f, 0.13154212f, 0.01733750f, 0.04909858f, 0.48558944f, 0.03058369f, 
    0.11112390f, 0.06887510f, 0.14113162f, -0.02113073f, 0.11989848f, 0.09127138f, -0.34736082f, -0.16011514f, 
    0.01574345f, -0.09844219f, -0.12257183f, -0.11797467f, 0.14958522f, 0.09211195f, -0.41671836f, 0.14260916f, 
    0.05652347f, 0.08115814f, 0.33024412f, -0.04122370f, 0.04348945f, 0.19710934f, 0.23308845f, -0.00612716f, 
    0.09932856f, -0.10479398f, -0.03813953f, -0.13697004f, -0.06413192f, 0.08486622f, -0.09008833f, 0.14177042f, 
    0.07094814f, 0.02242242f, 0.16799666f, 0.24315697f, 0.13754453f, 0.05992790f, 0.24236874f, -0.23812521f, 
    -0.16870834f, -0.16812754f, 0.01069509f, 0.15621319f, -0.19601674f, -0.06963041f, 0.12446956f, 0.01019494f, 
    -0.14663988f, 0.09648757f, -0.18115887f, -0.05429130f, -0.32344520f, -0.00234379f, 0.06754219f, -0.09213103f, 
    0.09262843f, 0.13841653f, -0.22906612f, -0.18731651f, 0.01385312f, -0.07209395f, -0.06398533f, -0.21757723f, 
    -0.08147878f, 0.06365234f, 0.15821423f, -0.06143745f, -0.11474996f, -0.07215332f, 0.21214761f, 0.06186781f, 
    0.04960312f, -0.02485789f, 0.01052272f, -0.08244479f, 0.03428787f, 0.16704592f, -0.09672710f, -0.10466874f, 
    0.14408685f, 0.10250794f, -0.03779085f, 0.06369685f, 0.03160767f, -0.11822782f, -0.08653678f, 0.12796484f, 
    0.29225442f, -0.07234572f, 0.24564584f, 0.14313708f, 0.08996428f, -0.12704310f, 0.10468423f, -0.48057947f, 
    0.22558767f, 0.11729439f, 0.13382737f, -0.01977806f, 0.10789801f, -0.13748160f, -0.10466821f, -0.13346562f, 
    -0.10968400f, -0.26989469f, -0.33658671f, 0.03199590f, 0.15305606f, -0.13712232f, -0.16787222f, -0.22978656f, 
    -0.13171449f, 0.07113534f, -0.01093719f, -0.16162395f, 0.12536398f, 0.04863152f, -0.12486267f, 0.23102522f, 
    0.08013384f, 0.18097594f, -0.31524834f, 0.09404734f, -0.03928994f, 0.29840645f, 0.12940879f, -0.10636901f, 
    0.10718366f, 0.12883185f, 0.03239131f, 0.10069183f, -0.05840068f, 0.16800688f, -0.03012845f, -0.19660547f, 
    0.14123112f, 0.05879154f, -0.01033056f, 0.06718389f, 0.50275177f, 0.31676587f, 0.36906910f, -0.19583614f, 
    -0.02211946f, -0.13245828f, 0.20565519f, 0.11435211f, 0.08320762f, -0.69950151f, 0.13215779f, 0.03217235f, 
    -0.04115205f, 0.01642466f, 0.04716524f, 0.12456142f, -0.08107287f, -0.06416825f, 0.05082349f, 0.02545597f, 
    -0.25517216f, -0.03896549f, 0.10557246f, 0.07108992f, 0.20191728f, -0.01712174f, 0.01610911f, 0.06955338f, 
    -0.03867003f, 0.05557141f, -0.08057229f, 0.10504040f, 0.02622310f, 0.00194682f, 0.03622714f, 0.23686442f, 
    -0.10253178f, 0.10424449f, -0.53809202f, -0.09021296f, -0.03856407f, 0.00286531f, -0.02072466f, 0.01978657f, 
    0.01793160f, 0.03532462f, -0.01561609f, -0.07575110f, -0.13556926f, 0.03555955f, 0.04850376f, -0.24305741f, 
    -0.03024897f, 0.01597053f, 0.21553017f, 0.02979997f, 0.04608037f, -0.04889914f, 0.16289087f, -0.07749511f, 
    -0.06789120f, -0.15922683f, 0.08387543f, -0.12333909f, -0.04874272f, 0.00066639f, 0.08640213f, -0.03656060f, 
    -0.12688600f, 0.09160247f, 0.12957528f, 0.09510945f, 0.41519070f, 0.17470531f, 0.11417764f, 0.01095004f, 
    0.23766159f, 0.15746014f, 0.06656352f, -0.05978499f, 0.23439164f, -0.15770547f, 0.05569801f, 0.12302889f, 
    -0.00607719f, 0.14908963f, 0.04807083f, -0.18928939f, 0.05870471f, -0.00880111f, 0.00867319f, 0.10902634f, 
    -0.16207887f, -0.24359931f, -0.06331304f, -0.12868628f, -0.02266075f, 0.03816636f, 0.17845330f, -0.29240650f, 
    -0.28599277f, 0.20004106f, 0.03884731f, 0.08838512f, -0.14868735f, -0.07419303f, -0.00607491f, 0.31538171f, 
    -0.26126248f, 0.18759531f, 0.21929656f, 0.01768220f, 0.11438975f, 0.08346737f, -0.06016801f, 0.25675532f, 
    -0.14986342f, -0.24968505f, -0.28709027f, -0.16830048f, 0.05884636f, -0.04069619f, 0.01383601f, -0.13599950f, 
    -0.12811372f, -0.17128147f, 0.57182914f, 0.12087055f, 0.30623788f, 0.00752888f, -0.16443330f, -0.02360719f, 
    -0.12470675f, 0.19410160f, 0.07098977f, 0.03072105f, -0.06480681f, -0.61946779f, 0.06153456f, -0.07592189f, 
    -0.01043796f, -0.05396298f, 0.25380066f, 0.18010627f, 0.68040818f, 0.21507366f, 0.19218548f, 0.01555181f, 
    0.14514504f, 0.02175784f, 0.08744711f, -0.06417789f, 0.11766645f, -0.26597774f, 0.12184423f, -0.02965044f, 
    0.25703990f, -0.16755408f, -0.07970883f, 0.15926993f, -0.19457826f, -0.04677532f, -0.07206027f, -0.27833578f, 
    -0.01105107f, -0.12836143f, -0.21733916f, 0.01730060f, -0.10798422f, -0.12534425f, 0.00626534f, -0.00208671f, 
    0.01787460f, -0.20553634f, -0.01729244f, 0.19873373f, -0.16060239f, 0.01477793f, 0.01533874f, -0.02089334f, 
    -0.04374402f, 0.00069565f, 0.47972149f, 0.14303701f, 0.14258267f, -0.01481893f, 0.20353767f, -0.05777734f, 
    0.00972232f, 0.38696152f, 0.09582683f, -0.12964658f, -0.08362447f, -0.02655769f, -0.07646094f, -0.11909602f, 
    0.01265929f, 0.13495877f, 0.03880076f, -0.02120139f, -0.43327919f, -0.13310610f, -0.02687190f, -0.04794438f, 
    0.07229771f, -0.04421338f, -0.04336839f, -0.04500368f, -0.36976498f, -0.20552938f, -0.09349786f, 0.21215859f, 
    0.03351166f, -0.02879830f, 0.01770438f, -0.10043091f, 0.08304480f, -0.10520363f, -0.28745815f, 0.12867072f, 
    0.00770655f, 0.12932004f, 0.21542120f, -0.09001620f, 0.11380269f, -0.06583337f, 0.07224125f, -0.33828259f, 
    0.02092864f, -0.00219903f, -0.00069843f, 0.05685541f, 0.18323594f, -0.16024449f, 0.48908374f, 0.21598637f, 
    -0.06861376f, 0.04108127f, -0.11280803f, -0.09329237f, -0.13998140f, 0.17029642f, 0.21263547f, -0.64446610f, 
    -0.40194491f, 0.09778570f, -0.10634665f, 0.11759655f, 0.14056686f, 0.18444046f, 0.13870725f, 0.13519047f, 
    0.14460601f, 0.20578754f, 0.10330997f, -0.05977996f, 0.10849256f, -0.14786479f, -0.23221819f, -0.09435726f, 
    -0.02340675f, -0.82591814f, -0.34467188f, 0.06407167f, 0.03651198f, -0.12672816f, -0.04278262f, 0.02070079f, 
    0.00752151f, -0.05681407f, 0.25993714f, -0.13905135f, -0.28500909f, -0.20092243f, -0.02623832f, 0.12814251f, 
    -0.09686122f, 0.05063948f, 0.14316484f, 0.08924209f, 0.12726294f, -0.03930190f, 0.14281406f, 0.17577030f, 
    0.11284450f, 0.07978211f, -0.17731379f, 0.04757462f, 0.44255629f, 0.03585579f, 0.22388639f, 0.18669844f, 
    0.13909650f, -0.15587759f, -0.16760790f, 0.02529387f, -0.15566151f, -0.48266631f, -0.20368598f, -0.05465649f, 
    0.05361887f, 0.25447139f, -0.20075211f, 0.11365563f, -0.10240144f, -0.24016926f, -0.13451421f, 0.02965763f, 
    -0.54978943f, -0.03860414f, 0.05552646f, -0.04943343f, -0.08385611f, 0.05865398f, 0.04694568f, 0.07862666f, 
    0.12687972f, 0.10847117f, 0.25838828f, 0.04789482f, -0.00293696f, 0.26754621f, 0.04225860f, 0.19361533f, 
    -0.04849707f, 0.20157990f, 0.05696110f, 0.25534841f, 0.16194801f, 0.09046640f, -0.01757843f, 0.03051054f, 
    -0.08958514f, -0.95592421f, -0.35073268f, 0.17106482f, 0.11373112f, -0.02908793f, -0.17240502f, 0.03456991f, 
    0.03711938f, -0.04792869f, -0.01408360f, 0.43917608f, 0.10219581f, 0.03889424f, 0.13620676f, -0.00338191f, 
    0.03584494f, 0.01349437f, -0.06190976f, -0.05703687f, -0.11843625f, 0.24555621f, -0.01787222f, 0.03049760f, 
    0.02619657f, 0.07170837f, 0.08236345f, 0.03787185f, -0.06215411f, 0.09077249f, 0.16706483f, 0.14736676f, 
    0.28476173f, -0.12393413f, -0.04888501f, 0.11248843f, 0.13870876f, -0.46016186f, -0.22636604f, 0.55581182f, 
    -0.27226070f, 0.11535948f, 0.10245067f, -0.11548062f, 0.02695824f, 0.02196077f, -0.45540214f, 0.09191038f, 
    -0.87996322f, 0.20513742f, -0.01541104f, 0.02273192f, 0.02896132f, 0.04829932f, -0.12272367f, 0.83323985f, 
    0.27416363f, 0.14549427f, -0.33866134f, -0.17265850f, -0.14904161f, 0.07478359f, 0.31674194f, 0.01731975f, 
    0.12377121f, -0.29151192f, 0.04900875f, -0.32760477f, 0.06606183f, 0.10290515f, -0.16456798f, -0.00578770f, 
    0.07612479f, -0.20049994f, -0.14234193f, 0.49245897f, -0.26194856f, 0.02664375f, -0.04918949f, 0.06122352f, 
    -0.01142425f, 0.08390798f, -0.10306705f, 0.32908723f, -0.05717557f, -0.03428518f, -0.14921206f, 0.01102123f, 
    -0.14147976f, 0.04385215f, 0.02820725f, -0.17459847f, -0.41314566f, 0.43671405f, 0.01207252f, 0.00462335f, 
    -0.03414945f, -0.01917333f, 0.05733427f, 0.02301865f, 0.11191670f, 0.36995235f, -0.08420609f, 0.27041921f, 
    0.24446012f, 0.07885622f, 0.02178312f, -0.05078588f, -0.04690485f, -0.24591629f, 0.23201583f, -0.11480092f, 
    0.03015291f, 0.03642260f, 0.13295648f, 0.15551831f, 0.22728863f, 0.11290540f, 0.07243966f, -0.26914573f, 
    -0.29695421f, -0.16457202f, -0.09136717f, 0.21350175f, 0.07524389f, 0.15812320f, 0.09243353f, -0.25355724f, 
    -0.18085395f, -0.03784614f, 0.06461748f, -0.17518468f, 0.05862745f, -0.08769235f, -0.01653605f, -0.22260164f, 
    -0.12234777f, -0.06369209f, -0.15962639f, 0.07586851f, -0.20630167f, -0.05393289f, -0.07443891f, -0.00930500f, 
    0.16584767f, -0.03503069f, -0.04839422f, -0.30171812f, 0.14618847f, 0.07153326f, -0.11022317f, 0.07902414f, 
    0.11905319f, -0.03787880f, 0.00433528f, 0.19787453f, 0.19288065f, -0.04139455f, -0.09177107f, -0.07269622f, 
    -0.06274956f, -0.08379103f, -0.07078892f, -0.07419734f, -0.17910559f, 0.23913138f, -0.05952029f, 0.09047481f, 
    0.03738335f, -0.16896896f, -0.02649613f, -0.00472838f, 0.16525118f, 0.46130988f, -0.40692911f, 0.24274360f, 
    0.00816772f, -0.16941760f, 0.05680283f, 0.09551407f, -0.05874691f, -0.04239668f, -0.02079234f, 0.00868433f, 
    0.08839136f, -0.10823767f, 0.05029992f, 0.06894036f, 0.01144051f, 0.27134460f, 0.19815488f, -0.10866498f, 
    0.17333512f, -0.09256634f, 0.07369219f, -0.21482764f, -0.19278570f, 0.16574863f, -0.15616378f, 0.57952023f, 
    -0.03859763f, -0.26974347f, -0.05517365f, -0.19520609f, 0.00818582f, 0.05886511f, 0.01596138f, 0.14515553f, 
    -0.36182034f, 0.57977206f, -0.53755015f, -0.14705981f, -0.07243788f, 0.00483522f, -0.00461799f, 0.15359527f, 
    0.07973856f, -0.37191892f, -0.22999877f, -0.09959683f, 0.02962906f, -0.16310975f, 0.16134612f, -0.25172514f, 
    0.00969528f, -0.07148900f, 0.17545278f, -0.28583950f, 0.13140334f, -0.13469456f, 0.11261979f, -0.00903927f, 
    0.07040781f, 0.06908833f, 0.19116491f, 0.22031571f, 0.24774441f, -0.42219192f, 0.26376110f, -0.01970978f, 
    0.12053617f, -0.08503136f, -0.03955448f, -0.11231215f, -0.11561257f, 0.22858606f, 0.12571788f, 0.27200320f, 
    -0.01597565f, 0.00240443f, 0.12974475f, 0.02738433f, 0.16518350f, -0.32420802f, -0.20606367f, -0.32806134f, 
    -0.01310438f, -0.22888684f, -0.00444879f, -0.03184283f, -0.08051305f, 0.13072740f, -0.02814740f, 0.03782851f, 
    -0.30124232f, -0.02746082f, 0.02937110f, -0.00876438f, -0.14354491f, -0.13133544f, 0.12686458f, 0.30002448f, 
    -0.03334189f, -0.36200964f, 0.05915744f, -0.08862137f, 0.10347085f, 0.06400895f, 0.03732195f, 0.13851386f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.03095965f, 0.03960035f, -0.06274088f, -0.04343012f, -0.03339576f, 0.26129121f, -0.04802855f, -0.12150288f, 
    -0.05938609f, -0.04998248f, -0.05147892f, 0.17363127f, 0.24254058f, -0.06837925f, -0.13785838f, 0.13080366f, 
    0.16316587f, -0.05518542f, 0.03428052f, 0.13922207f, 0.03849167f, -0.03729924f, 0.01049978f, 0.02003323f, 
    -0.04442289f, -0.05832275f, -0.03731075f, -0.05394701f, -0.07214080f, 0.18574096f, -0.00799039f, 0.10812756f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    -0.01665761f, -0.15651283f, 0.02019143f, 0.15427577f, -0.08002078f, 0.37486562f, 0.04894212f, -0.07439274f, 
    -0.02065254f, 0.00134714f, 0.14525065f, -0.18399340f, -0.74999505f, -0.24201295f, -0.31696102f, -0.15990156f, 
    0.30764568f, -0.15726937f, -0.13023491f, 0.50653774f, -0.42643759f, -0.08723446f, 0.14706117f, 0.12032088f, 
    0.70556277f, 0.13022304f, 0.15563078f, 0.40760735f, 0.18148980f, -0.39910209f, -0.72182208f, -0.45410314f, 
    0.02942809f, 0.14318420f, -0.04725708f, -0.08271549f, 0.09510505f, 0.28739738f, -0.11365546f, -0.50566024f, 
    -0.06826818f, -0.16780083f, -0.03394564f, -0.31757438f, -0.02709270f, 0.12409729f, 0.34781694f, -0.30385262f, 
    0.88579428f, 0.00179181f, -0.16213700f, 0.24806063f, 0.06140191f, 0.09260975f, 0.03067984f, 0.46508151f, 
    -0.18828368f, -0.11635954f, 0.04113827f, -0.33622715f, -0.40352216f, 0.30146128f, -0.23490529f, 0.02624808f, 
    -0.02371415f, 0.70586747f, 0.01635792f, 0.04385725f, -0.02480770f, 0.18294021f, 0.04320551f, 0.78879052f, 
    -0.00973058f, -0.04292610f, -0.05126634f, 0.01544757f, 0.06791101f, -0.67584336f, 0.44877276f, -0.61031044f, 
    -0.07398894f, 0.15993440f, 0.02993464f, -0.24663685f, -0.88672614f, 0.11344004f, 0.04074528f, 0.15733512f, 
    -0.11455490f, 0.06067197f, -0.07148381f, -0.18642963f, -0.32211494f, -0.56070936f, 0.05697792f, 0.26742744f, 
    -0.17004536f, 0.09591106f, 0.06397027f, 0.15791212f, -0.10727863f, -0.31965989f, 0.08693388f, -0.03299922f, 
    -0.10520259f, -0.15480436f, -0.03140817f, 0.09737758f, -1.06928921f, 0.08861391f, 0.33097556f, 0.63379240f, 
    -0.46251255f, 0.12295107f, 0.14101809f, -0.22219765f, 0.15561868f, -0.06818452f, 0.04865693f, -0.97787744f, 
    -0.16143645f, -0.14350709f, -0.07596280f, -0.19574143f, 0.44034222f, 0.23227586f, -0.36107016f, 0.28905502f, 
    -0.00169828f, 0.05755830f, 0.04146463f, 0.11202260f, -0.00275842f, 0.02555762f, -0.16317761f, -0.02471541f, 
    -0.04737816f, -0.08232152f, -0.05058324f, 0.25708023f, 0.37067783f, -0.50636411f, -0.71656775f, -0.00869046f, 
    -0.69068033f, -0.00499141f, -0.11648629f, -0.09433636f, -0.14975779f, 0.15404528f, 0.07735713f, 0.43367651f, 
    0.08112872f, -0.09002276f, 0.10104698f, 0.57902616f, 0.05899474f, 0.54159236f, -0.85561132f, -0.30054060f, 
    -0.07979348f, -0.65885717f, -0.02399692f, -0.00436923f, 0.01261718f, 0.04833051f, -0.15403597f, -0.01388864f, 
    0.15454541f, -0.07409143f, -0.00265295f, 0.06508569f, 0.28971711f, 0.60758674f, -0.68809217f, -0.12213995f, 
    0.00303818f, -0.10683176f, 0.07381843f, 0.00309451f, 0.32852554f, 0.01622145f, -0.12430444f, -0.17795752f, 
    0.51645672f, -0.13375014f, 0.16411254f, -0.15386413f, -0.40264136f, 0.57124662f, 0.39864463f, -0.53127992f, 
    -0.10076296f, 0.19676326f, 0.00857175f, -0.15896671f, 0.07504888f, -0.20494787f, 0.17024218f, -0.66745520f, 
    -0.11417347f, -0.16768253f, -0.01484774f, 0.10868312f, 0.14605738f, -1.02449477f, 0.28282472f, -0.21502598f, 
    -0.42417282f, -0.04276261f, 0.16491228f, 0.43572587f, 0.03075188f, 0.13922182f, -0.01154141f, -0.45768806f, 
    -0.19436179f, 0.08826234f, -0.06673907f, -0.09552240f, 0.28475130f, 0.18931937f, 0.89119387f, -0.34570032f, 
    0.01188084f, 0.01399678f, -0.08483174f, 0.06501164f, -0.06153854f, -0.56832272f, 0.01599479f, 0.26238191f, 
    -0.12917897f, -0.01802208f, -0.15988590f, -0.28422087f, 0.18711293f, 0.38544175f, -0.30599758f, -0.02837484f, 
    -0.50515366f, -0.01224068f, -0.13773757f, -0.43805149f, 0.46671027f, -0.08709165f, 0.12327114f, 0.55664498f, 
    0.13443133f, -0.16826078f, -0.15830730f, 0.77734929f, 0.35696298f, -0.41433641f, -0.30992395f, -0.06312230f, 
    -0.09935614f, -0.58963364f, 0.05173755f, -0.17843354f, 0.13489686f, 0.15938731f, -0.09154963f, 0.08330023f, 
    0.09135892f, -0.12382510f, -0.11967588f, -0.48155707f, 0.14787042f, -0.22627585f, 0.29046717f, 0.17081614f, 
    0.14828040f, 0.14884084f, -0.09979827f, -0.33933705f, 0.91767216f, 0.15675646f, -0.09952397f, 0.40471628f, 
    -0.35042927f, -0.04357749f, -0.14568916f, 0.40492031f, -0.28369209f, 0.12991844f, 0.14430891f, 0.57245809f, 
    -0.06182918f, -0.36467233f, 0.04922561f, -0.00007389f, -0.04200083f, -0.01441510f, -0.15689462f, -0.23559768f, 
    -0.08182740f, -0.15311527f, -0.06952805f, 0.29453430f, 0.71182311f, 0.32408974f, -0.03342838f, -0.47961020f, 
    -0.62529701f, 0.00818671f, 0.04571587f, 0.55317479f, 0.01589382f, -0.13679728f, -0.10686883f, -0.21820667f, 
    0.11857955f, -0.13501377f, -0.15444142f, -0.44424158f, 0.02390081f, -0.75175017f, -0.35677075f, 0.92610830f, 
    -0.06681997f, 0.73530841f, -0.02710450f, 0.09174607f, -0.09982941f, 0.33714205f, -0.11012107f, 0.39431888f, 
    0.12528968f, 0.08221232f, 0.01115976f, 0.09766914f, -0.12389012f, 0.36177173f, -0.50616968f, 0.51082599f, 
    0.14620058f, 0.03740292f, -0.02638375f, -0.69383866f, 0.20239341f, 0.11209490f, 0.13082366f, -0.33505228f, 
    -0.95837116f, 0.14836685f, -0.07917684f, -0.17238274f, -0.57823199f, 0.09140849f, -0.26079860f, -0.22889005f, 
    -0.07042842f, -0.49247676f, 0.01734762f, -0.04236540f, -0.16560315f, -0.12348688f, 0.11472836f, 0.30031028f, 
    0.09322596f, 0.11571109f, 0.10988215f, 0.51103687f, -0.39265993f, -0.03886903f, 0.52853471f, 0.09962806f, 
    0.00610296f, -0.00800584f, -0.08566085f, -0.34603012f, -0.35278434f, -0.12181849f, -0.16501912f, -0.22749136f, 
    -0.30975929f, 0.03702139f, 0.08103728f, -0.59227228f, 0.34631586f, -0.25159103f, 0.30063331f, -0.56839538f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.04858244f, -0.09281998f, -0.06974119f, -0.07330818f, 0.13689303f, 0.08452683f, 0.10297051f, -0.13500841f, 
    -0.32998806f, -0.05329410f, 0.06431339f, 0.06525418f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 2560);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 192);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
