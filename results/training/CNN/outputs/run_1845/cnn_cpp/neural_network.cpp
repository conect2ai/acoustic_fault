#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    -0.91761887f, -0.70665705f, -0.56627494f, 0.63563377f, 0.66957408f, -0.20653497f, 0.04733677f, 0.45477960f, 
    0.24062215f, 0.23092891f, 0.03010974f, -0.23324484f, 0.05360075f, -0.51723742f, -0.39017332f, -0.67121053f, 
    -0.47139505f, -0.51744336f, 0.60551709f, -0.82789266f, -0.58634973f, 0.98520267f, 0.08014784f, 0.11616042f, 
    -0.40350524f, -0.24041705f, -0.40784511f, 0.17895071f, -0.25873053f, 0.42332533f, 0.18719704f, -0.52554995f, 
    0.14175928f, 0.52319890f, 0.52618468f, 0.48903936f, -0.76576906f, 0.18441574f, -0.19187029f, -0.67761123f, 
    -0.06651296f, -0.90081769f, 0.38514486f, -0.05014020f, 0.59518665f, -0.71564722f, -0.52083790f, 0.01232907f, 
    -0.44887951f, -0.86692882f, -0.26846537f, -0.27415162f, 0.39130920f, 0.21256639f, 0.53717560f, -0.52652448f, 
    0.14962637f, -0.68777198f, 0.78037894f, -0.20762210f, -0.12400422f, -0.33289486f, 0.39169851f, 0.04124621f, 
    0.50137591f, 0.38626280f, -1.03751373f, 0.94165093f, -0.66627753f, 0.02886051f, 0.18025586f, 0.05397235f, 
    0.10401782f, -0.37343895f, 0.41635746f, 0.06255015f, -0.47992194f, -0.43647292f, 0.68080592f, -0.49574479f, 
    -0.61245757f, 1.03199410f, -0.74353635f, -0.05379862f, 0.23174602f, 0.29402453f, 0.14545140f, 0.07933441f, 
    -0.00520501f, -0.14164262f, -0.95430756f, -0.90194762f, -0.35875401f, -0.04458829f, -0.14245695f, -0.05537707f, 
    0.06303521f, -0.32301494f, -0.37095568f, -0.22295539f, 0.36258647f, 0.85313934f, 0.76713073f, -0.25017324f, 
    0.02399330f, -0.59920090f, -0.33713388f, -0.23140864f, -1.03794241f, 0.13907464f, -0.03476539f, -0.64490151f, 
    0.33104002f, -0.77710354f, -0.48065737f, -0.03479533f, -0.55917269f, 0.17611717f, 0.03078917f, 0.90797323f, 
    -0.61704606f, 0.48067495f, 0.64222550f, 0.15124576f, -0.19083454f, -0.15595254f, 0.78245974f, 0.24692677f, 
    0.60366362f, 0.13321967f, 0.13534753f, 0.38568011f, 0.44616342f, -0.20505844f, 0.57619381f, 0.73147100f, 
    0.26326367f, -0.14002728f, -0.94828951f, -0.25618806f, -0.41457519f, -0.14611769f, 0.09772156f, 0.50196534f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.10244638f, 0.64632833f, -0.03470836f, -0.08530823f, 0.46826831f, -0.50100636f, -0.17719869f, -0.08493653f, 
    0.24691169f, 0.85081089f, 0.08591653f, 0.38743284f, -0.38959146f, 0.44016671f, 0.50774282f, -0.03877356f
};;

// Weights for convolutional layer conv1
const float conv1_weights[] PROGMEM = {
    -0.04812615f, -0.04439605f, -0.06375510f, 0.03058408f, -0.03807827f, -0.08423422f, -0.00775771f, -0.08414821f, 
    -0.05400404f, 0.01003100f, 0.00004080f, 0.04895364f, 0.01923074f, 0.02417003f, -0.05905699f, 0.04534724f, 
    0.03767249f, 0.05437471f, -0.06152727f, -0.05673962f, 0.03918723f, 0.01350800f, 0.01369036f, -0.03437144f, 
    0.01223700f, 0.05197009f, 0.07516545f, 0.02419335f, -0.09066884f, -0.00208839f, 0.05777012f, 0.06557060f, 
    -0.03592192f, -0.00600368f, -0.00384469f, -0.04768551f, -0.00617801f, -0.09003161f, -0.06571364f, -0.07670742f, 
    0.05246951f, -0.04608138f, -0.03560664f, -0.04544976f, -0.07281358f, -0.03437180f, -0.07321705f, -0.05858836f, 
    0.01369698f, -0.02857725f, -0.05678064f, -0.04971053f, -0.03174983f, -0.05540413f, -0.07324424f, -0.04892471f, 
    -0.07841395f, 0.03572007f, 0.08492386f, -0.03017562f, 0.01388179f, -0.06081606f, -0.01008405f, 0.01377842f, 
    -0.04039782f, -0.07039624f, 0.00436081f, 0.00546028f, 0.05574879f, 0.01753427f, 0.06067510f, -0.06311739f, 
    0.07222661f, 0.03577882f, 0.01213547f, -0.01335417f, 0.07069817f, 0.05150696f, -0.04900289f, -0.08189318f, 
    0.02310630f, -0.04259736f, -0.02756219f, -0.07260861f, -0.01206125f, 0.00423922f, -0.06356567f, -0.05249143f, 
    -0.03607356f, 0.03117283f, -0.02555871f, 0.06639627f, 0.06093163f, 0.06952894f, -0.03922289f, 0.07319997f, 
    -0.04159059f, 0.04617831f, -0.07539929f, -0.05252675f, -0.05831609f, -0.08799788f, 0.04576081f, 0.01441277f, 
    0.04622747f, 0.05910415f, 0.01759489f, -0.02650499f, -0.01060011f, -0.07730728f, 0.04668788f, 0.06855214f, 
    -0.08972549f, 0.06577383f, -0.06504722f, 0.03988248f, -0.01648423f, 0.01659916f, 0.05954839f, -0.01023945f, 
    -0.04199780f, -0.08623614f, 0.03502250f, -0.02417731f, -0.06232870f, 0.04462888f, -0.02648246f, 0.02253607f, 
    -0.04213873f, -0.06704084f, -0.04990414f, -0.07872361f, -0.01977366f, 0.00714324f, 0.00921462f, 0.07166455f, 
    0.01806599f, -0.08307688f, 0.01386323f, -0.05242185f, -0.01640401f, -0.00835829f, -0.02939805f, -0.04865116f, 
    -0.69479930f, 0.01442733f, 0.34815076f, -0.17243746f, 0.24034075f, -0.26275554f, 0.00317426f, -0.15723480f, 
    -0.04035095f, 0.24249561f, 0.26351035f, -0.06925390f, 0.19069546f, 0.16360013f, 0.08320358f, 0.12277347f, 
    -0.04711326f, 0.17248964f, -0.20919368f, 0.07989139f, 0.03316315f, -0.07827155f, 0.19517975f, -0.03577978f, 
    0.11632401f, -0.17586564f, 0.01446854f, -0.08660547f, -0.13618946f, -0.23485491f, -0.28915200f, 0.00913352f, 
    0.01744435f, 0.06893990f, 0.23745885f, 0.10805149f, -0.34312445f, -0.04596380f, 0.10424471f, 0.20569254f, 
    -0.03552676f, -0.20054218f, 0.13070314f, -0.08937853f, 0.13191974f, -0.20087284f, -0.21246871f, -0.43680960f, 
    -0.23014410f, -0.26954654f, -0.29158881f, 0.17029634f, -0.10296277f, 0.03321278f, 0.08264413f, -0.71495551f, 
    0.08222385f, 0.00358791f, -0.02215443f, -0.18271706f, 0.05563580f, -0.12464555f, -0.03307287f, -0.50564116f, 
    -0.32551372f, 0.47803017f, 0.08468024f, -0.20341675f, -0.15295753f, -0.01446270f, 0.09004328f, 0.19490980f, 
    -0.03362016f, 0.09207209f, -0.04644453f, 0.03679995f, 0.11505660f, -0.04061812f, 0.09270047f, 0.08943024f, 
    0.27427027f, 0.37014812f, 0.50602901f, -0.03030815f, -0.02952725f, 0.06795726f, 0.21899714f, 0.10860489f, 
    0.07708305f, 0.31554380f, -0.02425783f, -0.17231373f, -0.17629185f, -0.16628240f, 0.03272476f, -0.12713733f, 
    -0.11046240f, -0.02833687f, -0.07455426f, -0.24286036f, -0.04448391f, 0.02356885f, -0.08480115f, 0.18202244f, 
    -0.09956313f, 0.04501149f, 0.08405327f, 0.04280247f, -0.21170558f, -0.00397315f, 0.18139641f, -0.14547370f, 
    -0.02146997f, -0.08252870f, 0.27621639f, 0.04579434f, -0.18610863f, 0.35394609f, 0.08286096f, -0.20652021f, 
    -0.15651315f, -0.26453349f, -0.10738444f, 0.16435671f, 0.03074060f, 0.16092497f, 0.17240031f, 0.19618918f, 
    0.28095526f, -0.21428451f, -0.26132444f, 0.07304780f, -0.06182909f, -0.06501300f, 0.02169625f, 0.26506209f, 
    -0.38045257f, -0.02938394f, 0.09698360f, 0.06660504f, -0.01797985f, -0.01828072f, 0.03997085f, 0.12686865f, 
    0.02575347f, 0.03961398f, 0.02512802f, -0.06306173f, 0.03006326f, -0.00406074f, -0.03622570f, 0.02030696f, 
    0.01285836f, 0.03433843f, -0.08153895f, 0.04722688f, 0.02435451f, -0.06670146f, -0.01741303f, 0.03028905f, 
    0.02240653f, -0.00021107f, 0.05483828f, -0.00824179f, -0.00406415f, -0.01329429f, -0.05260456f, -0.04473509f, 
    -0.03606851f, -0.08865031f, 0.03780263f, -0.00505451f, 0.01590284f, -0.09764706f, 0.04985089f, 0.06558257f, 
    -0.03070828f, -0.08966133f, -0.03136192f, 0.02637066f, 0.01273288f, 0.01406195f, -0.07107975f, 0.00516561f, 
    0.00038054f, 0.03648100f, -0.08524785f, 0.00774409f, 0.05069510f, 0.06667204f, -0.06305759f, -0.01645333f, 
    -0.09151801f, 0.02853672f, -0.01430161f, 0.01121030f, 0.01766723f, -0.00622993f, 0.03528567f, -0.09013242f, 
    0.01468546f, 0.07718612f, -0.08077802f, -0.04121852f, 0.02481111f, -0.08349603f, 0.01593026f, -0.01339565f, 
    -0.07688855f, -0.00049887f, -0.07873844f, 0.01550234f, 0.01100005f, -0.05403793f, -0.01218198f, -0.07145752f, 
    -0.08003136f, 0.06340277f, 0.07259069f, -0.05869621f, 0.02473984f, 0.03001304f, 0.01964752f, 0.03979892f, 
    -0.07416993f, 0.01834419f, -0.01138522f, -0.03057487f, 0.04034466f, 0.02348587f, -0.07639635f, -0.07240129f, 
    0.00240001f, -0.04439653f, 0.06394180f, -0.06436250f, 0.06922228f, -0.02083305f, -0.06773139f, -0.06133494f, 
    0.03031367f, 0.04371171f, -0.05524981f, 0.01692749f, -0.08484836f, -0.07339557f, -0.08614471f, -0.02641058f, 
    -0.00048162f, -0.03381655f, 0.06630101f, -0.05313309f, -0.04817089f, -0.05923875f, -0.02236831f, 0.04269829f, 
    0.02068010f, -0.02891042f, -0.02784350f, -0.07475675f, -0.02037746f, -0.02292207f, -0.00300861f, -0.02349459f, 
    0.04269099f, 0.05352284f, 0.06156508f, 0.00443744f, -0.07356035f, -0.09199291f, -0.02008522f, -0.07907289f, 
    -0.03958420f, -0.06682158f, -0.05883506f, -0.02499896f, -0.06048095f, -0.00024165f, -0.07838906f, -0.07166509f, 
    0.00522022f, -0.06840838f, 0.06289700f, -0.01001044f, -0.09828028f, 0.01869392f, 0.03956550f, -0.05551346f, 
    0.21626849f, 0.01549671f, 0.18228985f, 0.03350544f, 0.03108221f, 0.25644803f, -0.00747729f, 0.00881328f, 
    0.03420095f, 0.02415903f, 0.15193343f, -0.11074147f, 0.01276922f, 0.14913307f, -0.09737458f, 0.03700630f, 
    -0.08011445f, -0.00577169f, 0.51564354f, -0.03642810f, 0.04272510f, -0.01782862f, -0.03340781f, -0.08791322f, 
    0.10607619f, 0.08195042f, -0.22315794f, -0.43313473f, -0.06163231f, 0.09531745f, -0.07659424f, 0.11337977f, 
    -0.02695346f, -0.10872693f, 0.11567089f, 0.13703682f, -0.13750350f, 0.00203628f, 0.19440295f, 0.08544989f, 
    0.00835167f, 0.12705514f, 0.14017338f, 0.22426113f, 0.17908530f, 0.17287864f, 0.02337294f, 0.16054945f, 
    -0.22133785f, -0.19748977f, 0.00340088f, -0.06283480f, 0.00300903f, 0.18065809f, -0.35117289f, 0.31479660f, 
    0.52148581f, -0.23955241f, -0.08408890f, 0.14050835f, -0.12003347f, 0.14964312f, 0.08501317f, -0.47754338f, 
    -0.89196169f, 0.56924379f, -0.10862020f, -0.01054769f, -0.07165635f, -0.09040163f, -0.02398770f, -0.14949650f, 
    -0.24502569f, -0.16220947f, -0.40972745f, 0.02922694f, -0.09072494f, 0.12357020f, -0.12043867f, 0.06550532f, 
    0.33058080f, 0.37939432f, -0.16520379f, 0.10703582f, -0.00607624f, 0.04608246f, -0.05648896f, -0.01119972f, 
    0.08099091f, 0.10747444f, 0.67215365f, 0.10631133f, 0.07645126f, -0.01159864f, -0.00565902f, 0.14714628f, 
    0.06877527f, 0.02181309f, -0.20998573f, -0.27142987f, -0.23268984f, -0.13885736f, -0.06915794f, -0.04967942f, 
    -0.12237700f, 0.01497436f, 0.08884282f, -0.16410631f, 0.27596870f, 0.09547361f, 0.27436364f, 0.10541870f, 
    0.12732270f, -0.23282111f, 0.15977849f, -0.12379219f, -0.10693607f, 0.06634901f, -0.29459292f, 0.31122556f, 
    0.05920193f, -0.07852525f, -0.21141301f, 0.11618338f, 0.15776144f, 0.06835694f, -0.14870089f, -0.01745621f, 
    -0.05573446f, -0.22325453f, 0.07435646f, -0.00839350f, -0.12935992f, 0.05572770f, 0.24224098f, -0.72102767f, 
    -0.53342277f, 0.06929810f, -0.15715471f, -0.17735128f, -0.22219165f, -0.05458161f, 0.00838423f, 0.23203605f, 
    -0.25379765f, -0.10110808f, -0.80655110f, -0.21252798f, 0.18859828f, -0.15267816f, 0.19598348f, 0.04274682f, 
    0.06485958f, 0.08876473f, 0.44218090f, -0.23673859f, 0.20663372f, -0.04805111f, 0.02091858f, 0.01369266f, 
    -0.08101477f, 0.11794803f, -0.11619388f, -0.25337136f, -0.29549566f, 0.02710260f, 0.03613816f, -0.12008920f, 
    -0.12267540f, -0.06851178f, -0.08147203f, 0.04517413f, 0.06874186f, 0.01687650f, -0.08230904f, -0.04192559f, 
    -0.01970450f, 0.09439700f, 0.16536394f, 0.03219146f, 0.10143410f, 0.17710532f, 0.06777542f, -0.01088103f, 
    -0.02065177f, 0.18957217f, -0.13821648f, 0.04196615f, 0.00689352f, 0.02305249f, 0.50763243f, 0.14429264f, 
    -0.13861760f, -0.57081854f, -0.20539328f, -0.00072860f, 0.06440019f, 0.17341022f, -0.13426401f, -0.01726327f, 
    -0.06316889f, -0.29921451f, -0.08958717f, -0.34453765f, -0.03269915f, 0.06015888f, -0.18429655f, -0.28168955f, 
    -0.19980957f, 0.40188968f, -0.06549811f, -0.07509215f, -0.13421564f, -0.04582308f, 0.22699861f, 0.05925018f, 
    0.19705337f, 0.22830571f, 0.13774000f, 0.00528177f, 0.17512611f, -0.01860743f, 0.02246636f, -0.10432215f, 
    0.18561852f, -0.11795022f, -0.09731272f, -0.08873833f, -0.11114622f, 0.10442217f, -0.13683593f, 0.08350394f, 
    0.09173427f, 0.02659727f, 0.18705019f, -0.29792809f, -0.22709665f, -0.04651587f, 0.02155150f, 0.02626724f, 
    -0.12687725f, -0.09688233f, 0.02856529f, -0.12112289f, -0.00321130f, 0.00547939f, 0.06932136f, -0.09397386f, 
    -0.07484335f, 0.03479709f, 0.11406463f, 0.12008012f, -0.08710015f, 0.20351231f, 0.31015092f, -0.18642105f, 
    -0.00267507f, 0.15795746f, -0.13994655f, 0.02106572f, -0.03566706f, 0.08894101f, 0.17594536f, 0.40663582f, 
    -0.38918352f, -0.06623968f, -0.05420079f, 0.12067406f, 0.09190906f, 0.11578158f, -0.17358761f, 0.05294745f, 
    0.20744810f, -0.18400662f, -0.12746066f, 0.02628028f, 0.00365985f, 0.07435205f, -0.12460722f, -0.18930820f, 
    0.30518293f, 0.08937105f, 0.02069156f, -0.13204879f, 0.05649450f, 0.16026512f, 0.19016665f, 0.04896621f, 
    0.22681235f, -0.10144141f, -0.45006859f, 0.11156630f, -0.10844702f, 0.20383207f, 0.05869686f, 0.08893923f, 
    0.08240202f, -0.00146357f, -0.06819334f, -0.00177388f, 0.04785913f, -0.14438921f, 0.01589510f, -0.08602044f, 
    0.03033346f, 0.06516292f, -0.25534216f, -0.07180219f, -0.54717946f, -0.04946574f, 0.07905398f, 0.17924882f, 
    0.00328548f, 0.18178265f, 0.03272835f, -0.09980952f, 0.09725942f, -0.22506987f, 0.01898228f, 0.07528004f, 
    -0.08795881f, -0.12786122f, -0.26898569f, -0.12312698f, -0.28785118f, -0.42014048f, -0.06305716f, -0.03542265f, 
    -0.07414806f, -0.08072681f, -0.10170443f, 0.04707501f, -0.24363664f, 0.19066536f, -0.00207128f, 0.56695223f, 
    -0.01931314f, 0.05108225f, 0.07838871f, 0.10283876f, -0.10628901f, -0.00653227f, -0.22868583f, 0.40198788f, 
    -0.15691970f, 0.08480118f, 0.02962861f, 0.14436227f, 0.13425344f, -0.32366112f, -0.05420205f, -0.12126827f, 
    0.36044955f, 0.08754558f, 0.06955130f, 0.05157811f, 0.13367575f, 0.12061872f, 0.20529324f, -0.19462243f, 
    -0.17506194f, 0.29042730f, 0.08011899f, -0.16641629f, -0.07245075f, -0.18323019f, -0.01599790f, -0.11291605f, 
    -0.20605354f, -0.09144711f, 0.10624178f, 0.11400546f, -0.15786555f, 0.20789815f, -0.16809052f, 0.15031937f, 
    0.02797309f, -0.15413074f, 0.82778299f, 0.19029763f, -0.26259911f, 0.17399351f, -0.15385267f, 0.16726683f, 
    0.19203091f, 0.05206290f, 0.04205692f, 0.24074697f, 0.11653758f, 0.22663830f, -0.00869362f, -0.03296762f, 
    -0.00879678f, -0.01997179f, 0.20051295f, 0.22317405f, 0.04539727f, -0.56755954f, -0.44759321f, 0.09640566f, 
    -0.06736135f, 0.04278269f, 0.03554607f, 0.03126976f, 0.16006437f, 0.16948913f, 0.37014475f, 0.20717894f, 
    -0.05424950f, 0.15942103f, -0.20672290f, -0.03271861f, 0.00773940f, -0.15434892f, 0.35799062f, 0.26312485f, 
    -0.03971222f, 0.09975179f, -0.21801400f, -0.00959555f, 0.00920979f, -0.09471765f, -0.18124261f, -0.04705199f, 
    -0.07780088f, 0.35959107f, -0.03494774f, -0.03104372f, -0.03886467f, -0.03604617f, -0.00832195f, -0.12768491f, 
    -0.30496117f, -0.56642234f, 0.23391286f, -0.03049809f, 0.01875346f, 0.03043398f, -0.04487823f, -0.12385624f, 
    -0.04385229f, 0.18464920f, 0.12423664f, 0.39691293f, -0.19449565f, 0.02243602f, 0.01879637f, 0.03466875f, 
    0.40027747f, 0.20542257f, -0.14391020f, 0.11146554f, 0.06499686f, -0.09269122f, 0.04003892f, 0.34371823f, 
    -0.12684745f, 0.05928360f, 0.14866346f, -0.15784633f, -0.21207425f, -0.35390791f, -0.30615690f, -0.11944409f, 
    0.02144321f, 0.29589862f, 0.19229776f, -0.06421930f, 0.03837578f, -0.35140342f, 0.14462493f, 0.09045559f, 
    0.09215046f, -0.06893572f, 0.09933892f, 0.16107793f, 0.21413416f, 0.21299353f, -0.30388656f, -0.36770952f, 
    -0.01334204f, -0.09294829f, 0.05224391f, -0.00614047f, 0.08729932f, -0.33059049f, -0.32291469f, -0.22679201f, 
    0.05960096f, 0.15058325f, -0.21901488f, -0.28915069f, 0.10577167f, -0.10277813f, -0.17447814f, 0.13253723f, 
    -0.38372460f, -0.12159831f, -0.05819567f, 0.12012836f, 0.23780161f, -0.09727716f, -0.27596864f, 0.09258936f, 
    -0.01876547f, 0.23336986f, 0.05398143f, -0.07492967f, 0.26230380f, -0.05316852f, 0.32990813f, 0.11468682f, 
    -0.07734058f, -0.43786508f, 0.25065979f, -0.12292514f, 0.09930195f, 0.06093067f, 0.14011127f, 0.14601173f, 
    0.19064447f, 0.15984552f, 0.17053576f, -0.21165350f, 0.10832917f, -0.05474918f, 0.07468420f, 0.03144335f, 
    -0.17982878f, 0.03189244f, -0.05333912f, 0.08429281f, 0.10024174f, 0.10957148f, -0.21886285f, 0.01063020f, 
    -0.02488088f, 0.01197426f, 0.08707873f, 0.18683816f, 0.39077827f, 0.28503665f, -0.23222402f, -0.08431467f, 
    0.12997250f, -0.01773951f, 0.01126945f, 0.12908690f, 0.11800927f, 0.13785021f, 0.02933981f, -0.22978191f, 
    -0.02581192f, 0.14721595f, 0.13162176f, 0.11326947f, 0.20855053f, 0.04355541f, 0.15043664f, 0.11715241f, 
    -0.13863240f, -0.29146200f, 0.05253850f, -0.01599438f, 0.12899621f, 0.30093348f, 0.13508536f, -0.02721877f, 
    -0.18778628f, 0.05233511f, -0.12526265f, -0.02729579f, -0.02294156f, 0.01756881f, -0.16974974f, -0.20187551f, 
    -0.20521300f, -0.28846177f, 0.27301332f, 0.06276645f, -0.14307508f, 0.09223223f, 0.11130102f, 0.08367325f, 
    0.21248794f, 0.26397631f, 0.35994101f, 0.32016659f, -0.00357565f, 0.05567366f, 0.02601108f, 0.23797745f, 
    -0.00163877f, -0.00798502f, 0.19518931f, -0.10627573f, -0.24866177f, -0.01053865f, -0.01678502f, -0.04653288f, 
    0.03354888f, 0.09896950f, 0.16143309f, 0.21281202f, -0.04646522f, -0.14919980f, -0.17493701f, 0.00309605f, 
    -0.06565612f, -0.00731180f, -0.12790874f, -0.11176725f, 0.22895285f, 0.19299923f, 0.13233873f, -0.04280150f, 
    -0.09071679f, -0.02550450f, -0.08109277f, -0.03493847f, -0.02463672f, 0.26665425f, 0.03754150f, 0.72442305f, 
    -0.01680412f, 0.15751205f, -0.01263362f, 0.02551481f, -0.15591109f, -0.26497921f, 0.21920407f, -0.03483500f, 
    -0.23572181f, -0.20336530f, -0.14315532f, -0.07878763f, 0.13270910f, -0.14913134f, -0.08059046f, -0.12323193f, 
    -0.45080814f, -0.46645278f, 0.09164410f, -0.17993191f, -0.12030149f, 0.01384878f, 0.01215379f, 0.00615635f, 
    0.14459917f, -0.12569860f, 0.03637270f, -0.00892642f, 0.21976700f, -0.03833380f, 0.16723259f, -0.02962917f, 
    0.09622098f, 0.22868428f, 0.06171029f, -0.39265889f, -0.29511479f, 0.01754433f, 0.02990854f, 0.16830379f, 
    0.08945876f, 0.26458779f, 0.26014069f, -0.04404868f, 0.23635922f, 0.09380371f, 0.02395248f, 0.30407879f, 
    0.12774409f, 0.01780959f, -0.08358566f, -0.27064478f, -0.36274227f, -0.46395323f, 0.06383769f, 0.04607771f, 
    0.07655296f, -0.04433028f, 0.30396843f, 0.02718697f, -0.35264188f, -0.07427983f, 0.26384097f, -0.00063012f, 
    -0.12061705f, 0.09433861f, 0.13990296f, 0.13835722f, -0.06175726f, 0.21093653f, -0.47321063f, -0.29822162f, 
    0.13460819f, -0.22599109f, -0.21787480f, 0.10211082f, 0.04442238f, 0.12401423f, -0.13060066f, -0.06041954f, 
    -0.17545268f, 0.06800690f, 0.03884850f, 0.26778367f, 0.04580596f, -0.03184344f, 0.21023561f, 0.18848337f, 
    0.00307153f, -0.50777721f, -0.01119806f, -0.22109397f, 0.14451729f, -0.15722300f, -0.24860762f, -0.29565254f, 
    -0.79434460f, 0.02265963f, 0.64535254f, -0.08171356f, 0.12443666f, 0.12061314f, 0.09048408f, 0.20674933f, 
    0.02049229f, -0.28534150f, -0.10281415f, -0.15039830f, 0.02328488f, 0.17735109f, -0.07006590f, 0.07718829f, 
    0.19900022f, 0.11612459f, -0.37544897f, -0.17698026f, -0.22567929f, 0.04608082f, 0.32615522f, 0.12908304f, 
    -0.08230305f, -0.06708243f, 0.20115645f, 0.17520538f, -0.05595302f, -0.08555401f, -0.32344499f, -0.18103641f, 
    -0.16655900f, 0.00416626f, 0.09793841f, 0.00324602f, -1.16965616f, -0.07530420f, 0.10541701f, 0.14383182f, 
    0.07865318f, 0.02751500f, 0.01653845f, -0.02658624f, -0.11412705f, -0.49953422f, 0.03832138f, 0.05137617f, 
    -0.16092639f, 0.07144815f, -0.21187547f, -0.01215270f, -0.01577736f, 0.03396063f, -0.00454120f, -0.07910556f, 
    -0.31624275f, -0.09867126f, -0.01084279f, -0.05157209f, 0.10670480f, 0.02291372f, 0.25201783f, -0.13932313f, 
    -0.43823758f, 0.26462752f, 0.04617504f, 0.16986242f, -0.07722084f, -0.03393346f, 0.26805353f, -0.05473280f, 
    -0.43369600f, -0.12802207f, -0.10188769f, 0.07170723f, 0.22078945f, -0.00188157f, 0.14805271f, -0.09791975f, 
    0.00368052f, 0.13898274f, 0.33401933f, -0.01686323f, -0.05429563f, 0.17415825f, 0.16175304f, 0.20960337f, 
    0.01174288f, 0.20081711f, 0.16844369f, -0.00762162f, -0.10042491f, -0.01458312f, -0.06910599f, 0.18724686f, 
    -0.13064636f, -0.06880186f, -0.11749791f, 0.05250870f, 0.11633138f, 0.18067586f, 0.01475978f, 0.01725159f, 
    0.00214426f, -0.08064002f, 0.07202141f, 0.12142150f, 0.32834560f, -0.25491753f, -0.14240573f, -0.15650578f, 
    -0.06203706f, -0.01528400f, -0.11128633f, -0.29400614f, -0.03958670f, 0.19447766f, 0.06198230f, -0.14614978f, 
    -0.00212032f, 0.17973998f, -0.03380008f, 0.01416738f, -0.16166362f, 0.26961219f, 0.30216092f, -0.04464836f, 
    0.08252489f, 0.02386097f, -0.10090328f, 0.00633650f, 0.01701224f, -0.00409419f, 0.10376142f, 0.10662687f, 
    -0.17619677f, -0.54536527f, 0.07101496f, 0.00131234f, 0.03444988f, -0.02201886f, 0.02514011f, -0.23942424f, 
    -0.06336661f, 0.00372253f, 0.01444856f, 0.03178856f, -0.07583703f, -0.02631691f, -0.00398355f, -0.04291778f, 
    -0.05964538f, 0.02424375f, -0.04871346f, 0.02987619f, -0.04135740f, -0.02307450f, 0.04195537f, 0.03711078f, 
    -0.03624284f, 0.03218206f, -0.09172701f, -0.02778599f, 0.04979480f, 0.04802181f, 0.03054167f, -0.04483926f, 
    0.06109848f, -0.01756692f, 0.00916353f, -0.03690006f, -0.02759865f, 0.02924960f, 0.05588234f, -0.06811278f, 
    -0.05708623f, -0.05696958f, -0.08098444f, -0.07626814f, -0.07656115f, -0.05131738f, 0.02645900f, -0.06372480f, 
    -0.08722317f, -0.05386796f, 0.04124264f, -0.00731477f, -0.09581798f, 0.06250899f, -0.04780451f, -0.07592923f, 
    -0.05298613f, 0.02822904f, -0.08646068f, -0.08586527f, -0.01308791f, 0.03737449f, -0.10373247f, -0.09130416f, 
    -0.03113976f, -0.08657049f, -0.07061538f, -0.03296854f, 0.03973613f, -0.06668536f, 0.02136857f, -0.06913365f, 
    -0.02154393f, 0.00726972f, 0.04574241f, -0.00177001f, -0.06810679f, 0.00948603f, -0.05192799f, 0.00185033f, 
    0.00941761f, -0.07033598f, 0.02230405f, 0.01938000f, -0.07958507f, -0.02620422f, 0.01704289f, 0.05016128f, 
    -0.00062669f, -0.08682907f, -0.10308933f, -0.00498965f, 0.07119062f, -0.09665663f, -0.06861994f, -0.01799570f, 
    0.05096434f, -0.00282550f, -0.00847255f, -0.03953220f, -0.06861334f, -0.08315691f, -0.02062612f, 0.01623859f, 
    0.04992666f, -0.04296011f, -0.01084945f, -0.05381388f, -0.01154197f, -0.01716617f, 0.06623583f, 0.00886863f, 
    0.02597181f, -0.02809849f, -0.03694517f, -0.01575382f, 0.05210798f, 0.02915266f, -0.07989675f, -0.01404507f, 
    -0.08655670f, -0.07779423f, -0.07079587f, -0.08580308f, 0.00026627f, -0.00233117f, -0.07957602f, 0.01826948f, 
    0.00678540f, 0.01470696f, -0.02265950f, -0.04563582f, -0.06326535f, -0.04912324f, 0.06522361f, 0.05220328f, 
    -0.08371675f, -0.02477978f, -0.06294589f, 0.04848886f, -0.08662395f, 0.00660826f, -0.06648815f, -0.04638287f, 
    -0.03185022f, -0.07078047f, -0.08216075f, 0.00046983f, 0.01118342f, 0.00897781f, -0.02142813f, 0.05233253f, 
    -0.23710799f, -0.38339227f, 0.46367678f, -0.10226512f, 0.09740686f, -0.22512308f, 0.10871261f, 0.02768654f, 
    0.18628375f, -0.01855470f, 0.24757734f, 0.11983328f, 0.10612641f, 0.04487289f, 0.18162419f, 0.21892495f, 
    -0.05173365f, -0.02903320f, 0.40323433f, -0.25911856f, 0.31756622f, 0.05661127f, -0.04888003f, 0.03919541f, 
    0.03205358f, -0.10442854f, 0.22167803f, 0.01129004f, 0.18099500f, 0.12873273f, 0.11457670f, 0.12785846f, 
    0.00379213f, -0.19028437f, -0.31152418f, -0.24653995f, 0.22839235f, -0.05508753f, 0.13145119f, 0.11127003f, 
    0.05085871f, 0.10299926f, -0.02288755f, -0.07180114f, -0.14297453f, 0.17639853f, 0.18719977f, 0.27958339f, 
    0.05676648f, 0.07335036f, -0.02982915f, 0.12377151f, 0.00057729f, -0.09207660f, -0.56300002f, 0.24777922f, 
    0.20870733f, -0.19577786f, 0.12384985f, 0.04193018f, -0.49756375f, 0.22991626f, -0.18670894f, -0.21631752f, 
    0.17396656f, -0.05063048f, -0.16660748f, -0.06970578f, -0.15262684f, 0.01513591f, -0.05166293f, 0.25877863f, 
    -0.30115494f, -0.23718683f, 0.15090808f, -0.04460638f, -0.03340167f, -0.13304095f, -0.00392820f, -0.02101528f, 
    0.29322973f, 0.07601584f, -0.21647334f, 0.29357898f, -0.09182006f, -0.04791012f, 0.07218705f, 0.01840893f, 
    0.10450660f, 0.02060805f, -0.19454807f, 0.06741645f, 0.27728814f, -0.05303567f, 0.04936187f, -0.15729043f, 
    0.10784829f, -0.02432625f, -0.02993241f, 0.16980657f, 0.33175933f, 0.06419821f, 0.19933935f, 0.10213020f, 
    0.08074060f, 0.29041877f, 0.04928542f, 0.25890860f, 0.34137723f, 0.19234474f, 0.11852169f, -0.13314012f, 
    0.09441923f, -0.05119164f, -0.11107036f, -0.16521275f, -0.07162112f, -0.00059624f, -0.10002043f, 0.00136601f, 
    0.06253956f, -0.00386226f, -0.10512140f, 0.05931143f, 0.21326298f, 0.01291338f, 0.06138577f, 0.14356412f, 
    0.15866162f, 0.01020816f, 0.11588694f, -0.03938956f, 0.11922880f, 0.13288513f, -0.14169475f, -0.38072374f, 
    0.36982724f, 0.15202476f, 0.11848645f, -0.13657932f, -0.13785487f, -0.03859309f, -0.28962469f, -0.26534447f, 
    0.17248072f, 0.20001587f, 0.31690076f, -0.34210762f, -0.19199418f, -0.31806439f, 0.07983062f, -0.06441029f, 
    0.07357599f, 0.11766204f, -0.22537914f, 0.01360177f, 0.14913808f, 0.16741611f, 0.01200706f, 0.07464711f, 
    -0.00275859f, 0.28671706f, -0.25226721f, -0.55304497f, 0.06685489f, -0.20677628f, 0.00579794f, -0.01355267f, 
    0.06585744f, 0.06565015f, 0.15762369f, 0.10851695f, -0.16297257f, -0.08633859f, -0.09282587f, 0.02585591f, 
    0.06946670f, 0.24839807f, 0.11792533f, 0.08866668f, 0.16537195f, 0.44264051f, 0.52507013f, 0.09975506f, 
    0.11218060f, -0.09397943f, 0.08933585f, 0.17987923f, 0.01291436f, 0.04418325f, 0.41298255f, 0.27751756f, 
    -0.19796485f, 0.11380206f, 0.09647001f, 0.10694233f, -0.03211999f, 0.11594477f, -0.44759634f, 0.02736464f, 
    0.01109348f, 0.22708997f, -0.12801737f, 0.28226346f, -0.05115884f, -0.21823913f, 0.21353057f, -0.34663978f, 
    0.43766779f, 0.12407236f, -0.13019238f, -0.05915768f, -0.47390914f, -0.04443795f, 0.09040792f, -0.07860868f, 
    -0.14886843f, -0.57796693f, 0.14114483f, 0.06663812f, 0.16060315f, 0.10287498f, 0.02314777f, 0.06640419f, 
    0.06984361f, -0.14235418f, -0.28814018f, -0.18394820f, 0.03814431f, -0.09919201f, 0.27902877f, 0.14035669f, 
    -0.01737816f, 0.10666952f, -0.30800909f, -0.41342187f, 0.14661355f, -0.01144802f, 0.14883287f, 0.04838337f, 
    0.02198764f, -0.19896664f, 0.07057803f, -1.04429698f, -0.45416692f, 0.17278405f, -0.14053954f, 0.07680570f, 
    -0.22484635f, -0.08071052f, -0.12424672f, 0.17716527f, -0.47613311f, 0.27640012f, 0.49585173f, 0.15622790f, 
    0.15827724f, 0.03475190f, 0.01889825f, 0.09221651f, 0.00734952f, -0.56769174f, -0.00078009f, -0.34964186f, 
    -0.14097261f, -0.10990004f, 0.08148379f, 0.03687124f, -0.00388196f, 0.04811320f, -0.08987722f, 0.01600198f, 
    -0.03096021f, 0.04485518f, 0.12964918f, -0.03870703f, 0.05702222f, -0.09879290f, 0.11910725f, -0.16932456f, 
    0.53285062f, 0.03605105f, -0.03297818f, 0.09076946f, -0.00734077f, -0.02821032f, 0.01075536f, -0.25800353f, 
    0.37537855f, 0.25227520f, -0.29475585f, -0.00551126f, -0.11320435f, 0.13518143f, 0.06169892f, 0.17074719f, 
    0.12402228f, -0.11242974f, -0.07710753f, -0.35500994f, -0.00014170f, -0.04227484f, 0.00817443f, -0.02834714f, 
    0.05870658f, -0.17971738f, -0.16817449f, 0.16863795f, -0.13628562f, 0.11564305f, 0.05570775f, 0.10138692f, 
    -0.31406102f, -0.51545620f, -0.52419871f, 0.02647064f, -0.02293384f, 0.02361612f, 0.09932337f, 0.13536032f, 
    -0.12243259f, 0.25722656f, 0.37329590f, 0.17858920f, 0.04377748f, 0.25475720f, 0.17362316f, 0.10604156f, 
    0.18007396f, -0.03213676f, 0.12045632f, 0.37467217f, 0.15605234f, 0.03993769f, 0.08889834f, -0.04326778f, 
    0.18331183f, -0.02104143f, -0.01622101f, 0.08784723f, 0.08325397f, -0.09343351f, 0.34307304f, 0.18231468f, 
    -0.52907145f, 0.18033962f, 0.17559458f, -0.18524148f, 0.14565352f, 0.38298243f, 0.24146284f, -0.14776240f, 
    0.11816312f, -0.01964971f, 0.20646675f, -0.02827848f, -0.01554294f, 0.03597916f, 0.42612484f, -0.12278654f, 
    0.24545096f, 0.21835531f, 0.22896563f, 0.18202834f, 0.02030623f, 0.01159198f, -0.02597777f, 0.34059480f, 
    -0.17866860f, -0.15683076f, -0.00855450f, 0.09566058f, 0.25305119f, 0.14272207f, 0.13938463f, -0.11385964f, 
    -0.14002697f, -0.18041156f, 0.31202987f, 0.03540319f, -0.32954389f, -0.15615019f, -0.13806228f, -0.11962112f, 
    -0.05828255f, -0.17975830f, -0.09978245f, -0.06711096f, -0.24817003f, 0.02524990f, 0.05239719f, 0.01376007f, 
    0.06960046f, -0.14778198f, -0.35411805f, -0.43415859f, 0.32162631f, 0.32500038f, 0.10561128f, 0.07702291f, 
    -0.05049067f, 0.01937479f, 0.02665854f, -0.16060692f, -0.18102343f, -0.06066883f, -0.03295849f, 0.15117271f, 
    -0.03893337f, 0.04339567f, -0.12243108f, -0.03812829f, 0.07803314f, -0.04708327f, -0.03384682f, 0.00465670f, 
    -0.14181907f, -0.12778632f, 0.00399421f, 0.14998358f, -0.02771452f, 0.06535949f, 0.04419682f, -0.25131345f, 
    -0.31701270f, -0.03704788f, -0.00794956f, 0.16600740f, -0.11048754f, 0.19876030f, 0.01204368f, 0.08106633f, 
    -0.07087074f, 0.07887219f, -0.02334386f, 0.05263729f, -0.07964045f, -0.03081005f, -0.08269130f, 0.07965135f, 
    -0.07518815f, -0.08192592f, 0.05893962f, -0.08435293f, -0.02792194f, 0.04830074f, -0.03249961f, -0.04153863f, 
    0.04419355f, -0.02311865f, -0.03499523f, 0.02400844f, 0.02876197f, -0.07699461f, -0.02144114f, -0.08165352f, 
    0.01188702f, 0.01629954f, -0.03062570f, 0.05262959f, -0.07786246f, -0.05073401f, 0.03072967f, -0.02699598f, 
    0.02672884f, 0.06304905f, -0.03810783f, -0.01256347f, -0.00506521f, -0.05898238f, 0.02951672f, -0.06417163f, 
    -0.05534254f, 0.00763068f, -0.00080927f, 0.05306496f, 0.02960737f, -0.03107317f, 0.00946154f, -0.05553665f, 
    -0.03256951f, 0.05242502f, -0.01498446f, 0.06578728f, -0.00134580f, -0.07632699f, -0.01462739f, 0.03195890f, 
    0.06815452f, 0.00424550f, -0.02974493f, -0.07584124f, -0.00809994f, 0.02659068f, -0.05937596f, 0.06503263f, 
    0.02675726f, 0.02095200f, -0.06465919f, -0.05779938f, -0.01985852f, 0.03216367f, 0.01892644f, -0.00775385f, 
    -0.06236276f, -0.01886810f, -0.03903451f, -0.04853796f, 0.00182363f, 0.06425697f, -0.02483449f, -0.04243559f, 
    -0.08443847f, 0.06814329f, 0.01521257f, -0.07078440f, -0.07469940f, -0.03338513f, 0.03216803f, -0.08247637f, 
    -0.03537953f, 0.04918058f, 0.00864247f, 0.03630624f, -0.07293156f, -0.02347890f, -0.04335289f, -0.00106634f, 
    0.01586549f, -0.06508897f, 0.02847744f, -0.07185033f, 0.01940221f, 0.07545925f, -0.04693203f, 0.02979723f, 
    0.00886733f, -0.02462001f, -0.02793287f, 0.04055278f, 0.01714256f, 0.01080612f, 0.04404740f, 0.00033022f, 
    -0.05163364f, -0.07935394f, 0.07395471f, -0.05571201f, -0.07604005f, -0.02537476f, -0.02127963f, -0.07622091f, 
    -0.07791320f, -0.08695435f, 0.02803832f, -0.06508312f, -0.04610147f, -0.03370216f, 0.06158219f, 0.00749336f, 
    -0.02952324f, -0.02754687f, 0.05068436f, -0.06331667f, -0.07146191f, -0.05293395f, 0.06668691f, 0.04146959f, 
    0.06049617f, 0.02931438f, 0.05565965f, -0.04463454f, -0.00539464f, 0.00978081f, 0.00499351f, 0.03653019f, 
    -0.42284352f, -0.08951173f, 0.37257963f, -0.16036598f, 0.12829979f, -0.26858652f, -0.01099346f, 0.05074233f, 
    0.07820965f, 0.46390542f, -0.06043606f, -0.20537640f, 0.14474863f, 0.33174354f, 0.14861088f, -0.01707828f, 
    0.18183531f, -0.02644685f, 0.41068253f, -0.36781964f, -0.38681093f, -0.24564271f, -0.07554663f, -0.23494479f, 
    0.15965523f, -0.04121632f, -0.21701677f, 0.11253639f, 0.09452163f, -0.17240943f, -0.18012606f, -0.04242294f, 
    0.01647879f, 0.15904804f, 0.10534943f, 0.09415181f, -0.27281657f, 0.29217446f, -0.21840961f, -0.18919560f, 
    0.09556844f, 0.02432988f, 0.18289727f, 0.06266471f, 0.05037474f, -0.88035280f, 0.04741360f, 0.07640310f, 
    -0.26826724f, -0.15661371f, -0.05087618f, 0.03003795f, -0.03752403f, 0.06587252f, -0.23121549f, -0.78665400f, 
    -0.49099231f, -0.07013553f, -0.06888510f, -0.22450802f, 0.40454587f, 0.06799404f, -0.12439853f, -0.09699874f, 
    -0.80921042f, -0.13207665f, 0.12310573f, 0.23945029f, -0.00841185f, -0.11396038f, 0.09716783f, -0.12753209f, 
    0.01400204f, -0.53889942f, -0.56823242f, 0.07211058f, 0.04882050f, -0.00019919f, -0.06094122f, 0.18196402f, 
    0.13599201f, 0.40264988f, 0.02704322f, 0.26877764f, 0.01130937f, -0.00985191f, 0.15649396f, 0.11394018f, 
    -0.01748942f, 0.05130232f, 0.08102778f, 0.28434214f, 0.62369567f, 0.03438388f, 0.02418378f, 0.04411119f, 
    -0.12878147f, -0.05076607f, -0.14729401f, -0.37419742f, -0.01865633f, 0.21517999f, -0.03947367f, 0.00722011f, 
    0.09167457f, 0.14563061f, 0.04551890f, 0.05340049f, -0.28747258f, -0.03814460f, -0.30563802f, -0.02636892f, 
    -0.02179696f, 0.01991604f, -0.10059753f, -0.03469339f, 0.05891981f, -0.27878302f, -0.07452346f, -0.03871284f, 
    0.07859340f, 0.00336502f, -0.01305713f, 0.16033304f, 0.03096000f, 0.07065292f, -0.01848037f, 0.00526392f, 
    0.10307116f, 0.11962953f, 0.09281573f, 0.19005276f, -0.01620110f, 0.10349879f, 0.03810441f, 0.35153490f, 
    -0.27118662f, -0.70371407f, -0.15384690f, -0.03148772f, 0.14418487f, 0.11035516f, 0.08232088f, 0.01879008f, 
    -0.25390500f, -0.26230621f, -0.18802913f, -0.38834459f, 0.07033169f, -0.17969471f, -0.04983139f, 0.00648197f, 
    -0.12349789f, 0.20166633f, 0.11163606f, 0.08403405f, -0.02841493f, 0.12913330f, -0.08323725f, -0.00021412f, 
    -0.27242669f, -0.20479789f, -0.01234089f, -0.75723124f, -0.13163687f, 0.09452239f, 0.07695880f, -0.13204239f, 
    -0.22535232f, -0.19411388f, -0.40409970f, -0.15869759f, -0.00496815f, -0.15339214f, -0.10377326f, 0.21259174f, 
    -0.19161533f, 0.15250254f, 0.23415922f, 0.05664174f, -0.34533650f, 0.16145222f, 0.39883950f, -0.04465182f, 
    -0.01839130f, -0.07375814f, 0.09354901f, 0.08875354f, 0.01380477f, -0.11911689f, -0.24579886f, 0.20313442f, 
    -0.38657275f, -0.11748368f, -0.04553233f, 0.12786613f, 0.09820895f, 0.08779932f, 0.10966712f, 0.13619974f, 
    0.08606515f, -0.25838444f, -0.28719738f, 0.47131404f, -0.26684079f, -0.07292448f, 0.13471809f, 0.05579670f, 
    0.18460821f, 0.35767862f, 0.14753735f, -0.48226160f, -0.42583907f, 0.18042096f, 0.04586636f, 0.05972528f, 
    -0.24577866f, 0.10375649f, 0.61103928f, -0.25929937f, 0.02694202f, 0.11049388f, 0.01589928f, 0.08076765f, 
    0.05557388f, 0.30519587f, -0.14024524f, 0.28935045f, 0.01664384f, 0.09251464f, 0.20297842f, -0.05334808f, 
    0.04415396f, 0.11010394f, 0.17580570f, 0.03546464f, -0.04099970f, -0.03430583f, 0.00753876f, -0.22532150f, 
    -0.08484770f, 0.03020407f, -0.09058774f, -0.30038676f, 0.12636046f, 0.24402587f, -0.08421332f, 0.03800829f, 
    -0.14559457f, 0.24055554f, 0.01800780f, 0.05451356f, -0.06333371f, -0.50469100f, -0.00146981f, 0.07038446f, 
    -0.02597510f, -0.18706109f, -0.05557816f, 0.12548551f, -0.08947764f, -0.05032854f, 0.34410846f, 0.21894030f, 
    -0.12173828f, 0.00494810f, 0.03467371f, 0.09045728f, 0.10717448f, -0.12188998f, 0.26712570f, 0.45620453f, 
    0.14564292f, -0.13596410f, -0.05611372f, -0.09512326f, -0.01043193f, 0.03669227f, 0.22992912f, 0.32376730f, 
    0.12037846f, 0.01636723f, -0.01008713f, -0.13245094f, -0.01820250f, -0.01461730f, 0.04881399f, 0.15213884f
};;

// Biases for convolutional layer conv1
const float conv1_biases[] PROGMEM = {
    -0.00394439f, 0.53001463f, -0.04692798f, 0.11509419f, 0.08663332f, -0.11567582f, 0.31859621f, 0.03088621f, 
    0.07923920f, 0.01222027f, 0.01711147f, 0.10023391f, -0.12096312f, 0.02224590f, 0.57781744f, 0.30050761f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.00826858f, 0.37723461f, 0.11498553f, 0.16784438f, 0.61404109f, 0.09016934f, -0.07698499f, 0.45559397f, 
    -0.02920536f, 0.18675607f, -0.40658221f, -0.50451171f, 0.06785518f, 0.01541272f, 0.03116554f, 0.09482011f, 
    0.20700565f, 0.03081734f, 0.03991685f, 0.19648333f, 0.40858120f, 0.38947529f, -0.28353292f, 0.22114171f, 
    0.61921835f, 0.18236195f, -0.11990263f, 0.34594905f, -0.16896115f, 0.08690051f, 0.23165698f, 0.08104509f, 
    0.11766217f, -0.07176202f, 0.20014885f, 0.14850006f, -0.59478974f, -0.18366124f, 0.30029795f, -0.28320822f, 
    -0.28987399f, -0.02809036f, 0.18722783f, 0.12678100f, -0.08640933f, -0.13516755f, 0.44654247f, 0.07923476f, 
    0.06506807f, 0.31260878f, 0.20052120f, 0.13534662f, 0.40204948f, -0.05463248f, -0.26214096f, -0.14443944f, 
    -0.11849368f, -0.16095449f, -0.12600711f, 0.39365888f, 0.13022128f, -0.12820375f, -0.08568195f, 0.45635918f, 
    -0.02492686f, 0.01115121f, -0.22360295f, 0.17632049f, 0.61144304f, -0.31612492f, 0.01748860f, 0.10980537f, 
    -0.23990873f, 0.21630959f, -0.29782775f, 0.38312370f, 0.44581345f, -0.10419904f, -0.09041043f, 0.01264846f, 
    -0.18955311f, -0.19901051f, 0.24443685f, -0.27766302f, 0.48672268f, 0.30074313f, -0.03325034f, 0.50736755f, 
    0.18692605f, -0.21159680f, 0.14420602f, 0.03207602f, 0.26715699f, -0.11157856f, -0.32413021f, -0.06095362f, 
    0.06235090f, -0.94594091f, -0.22088045f, 0.43825439f, 0.26982427f, 0.33555970f, -0.29452285f, 0.02112477f, 
    0.16544260f, 0.02984019f, 0.13158166f, -0.20973636f, 0.13479069f, -0.04522412f, -0.65606880f, -0.60427868f, 
    0.21341440f, -0.56045288f, -0.23047404f, 0.33120424f, 0.11767705f, 0.10528951f, -0.25148216f, 0.45238054f, 
    -0.77746433f, 0.15932217f, 0.19025289f, 0.33054513f, 0.11219389f, 0.04730485f, 0.34878275f, -0.07863892f, 
    0.05495528f, -0.22696514f, -0.12182147f, 0.13102874f, 0.35075408f, 0.19163790f, 0.10874220f, -0.01663082f, 
    -0.48631328f, -0.16219620f, 0.15214786f, -0.47328162f, 0.03718521f, -0.23884475f, 0.12054732f, 0.40684345f, 
    0.03817192f, -0.07660674f, 0.23320208f, 0.65507221f, -0.15685944f, 0.13551065f, -0.22091118f, 0.01375177f, 
    0.23021296f, 0.12803601f, 0.36475548f, -0.11642640f, -0.16057782f, -0.04440631f, 0.04174661f, -0.01917347f, 
    -0.17483360f, 0.26146188f, -0.10316164f, -0.16178663f, 0.21481463f, 0.24268106f, 0.37667069f, -0.19106174f, 
    0.40187982f, -0.17456849f, -0.32628739f, 0.20963439f, 0.20646681f, -0.20854513f, 0.22208607f, -0.39003369f, 
    0.13077292f, 0.18394795f, 0.18842812f, -0.03550747f, 0.52793831f, 0.05101909f, -0.17186323f, -0.03760459f, 
    0.42417410f, 0.24513999f, 0.18116783f, -0.36803818f, -0.03339940f, -0.23234043f, 0.03774713f, -0.19430347f, 
    -0.09248524f, 0.08553018f, 0.13017036f, -0.32909480f, 0.08281711f, -0.46214163f, 0.02340752f, -0.21194194f, 
    -0.18838979f, 0.18422821f, 0.23627563f, 0.60735947f, 0.23071407f, -0.01700812f, -0.08517238f, 0.21503189f, 
    -0.02499313f, -0.29966256f, 0.20138279f, 0.16235778f, -0.07203761f, 0.00694732f, -0.03376113f, 0.10494071f, 
    0.01133306f, -0.06245001f, 0.47597399f, -0.46102291f, 0.01258226f, 0.08268347f, 0.22151974f, -0.20369552f, 
    0.13379529f, 0.10294244f, 0.10886151f, 0.35613528f, 0.34963077f, -0.47804919f, 0.30612808f, -0.06966224f, 
    -0.21660204f, 0.12382663f, -0.46412686f, -0.26720428f, 0.41952375f, -0.23206322f, -0.04553162f, 0.14893320f, 
    0.02965304f, 0.15134396f, 0.08901267f, 0.47154960f, -0.14567371f, -0.74315310f, -0.18280901f, 0.11485709f, 
    -0.13967368f, 0.10527056f, -0.33904025f, 0.37224224f, 0.12379391f, 0.08162149f, 0.14609255f, 0.16830236f, 
    0.01777942f, -0.21383826f, 0.06549215f, -0.08393054f, -0.71280539f, 0.01663924f, 0.29969749f, -0.14487739f, 
    -0.00093986f, -0.18634246f, 0.33354628f, 0.40890759f, -0.15751341f, 0.02122765f, 0.03292755f, -0.05253705f, 
    -0.14879200f, -0.20522012f, -0.07052503f, -0.09832716f, 0.04241063f, -0.13142487f, -0.17513204f, -0.19588481f, 
    -0.24590957f, 0.15931596f, 0.47236094f, 0.38267905f, 0.05642517f, 0.13015540f, -0.07390494f, 0.33748928f, 
    -0.08417962f, 0.45296758f, -0.24313784f, 0.29449806f, 0.02595929f, -0.42012885f, 0.27120346f, -0.27155688f, 
    -0.11490288f, 0.11995266f, -0.05056052f, -0.15644622f, 0.24393867f, -0.08080090f, -0.19438095f, 0.14995077f, 
    -0.10495529f, 0.07072401f, 0.22720946f, -0.58249664f, -0.11537714f, 0.21831819f, 0.16862816f, -0.04170525f, 
    0.05111862f, -0.08956433f, 0.17475079f, -0.09364646f, -0.32514748f, 0.07295147f, 0.41084573f, -0.28089654f, 
    -0.15218705f, -0.23489040f, -0.24039593f, 0.12423375f, -0.07561892f, -0.34916690f, -0.50947297f, 0.73960203f, 
    -0.38272664f, -0.06534333f, 0.00795227f, 0.25828257f, 0.50235069f, -0.19437656f, 0.44439343f, -0.02498653f, 
    -0.22401531f, 0.15183546f, -0.02010871f, 0.50569320f, 0.50697368f, 0.11883399f, -0.12019055f, -0.02455339f, 
    0.02265143f, 0.12570669f, 0.32608816f, -0.31723472f, 0.35875505f, -0.13295141f, -0.53058386f, 0.36621627f, 
    -0.02203107f, 0.21951343f, 0.24267346f, 0.27249840f, 0.03260953f, -0.85149992f, -0.06874047f, -0.08952634f, 
    -0.24767601f, 0.21232586f, -0.26388457f, 0.10973974f, 0.38564765f, -0.19651455f, 0.12790343f, 0.20422037f, 
    0.12234668f, 0.15532194f, 0.17924613f, 0.41219315f, -0.56291264f, -0.29317677f, 0.23282743f, -0.37725684f, 
    -0.33367696f, -0.17252591f, 0.12766895f, 0.23600186f, 0.14335662f, 0.17704041f, 0.08091212f, 0.18383609f, 
    0.02661610f, 0.12532948f, 0.06020252f, -0.54317063f, -0.13302669f, 0.17235631f, -0.00542668f, 0.28449678f, 
    -0.24658480f, -0.15287626f, 0.23164187f, -0.26475111f, -0.23746832f, -0.13238990f, 0.29384887f, 0.32175249f, 
    0.18204504f, -0.22911391f, 0.01086659f, -0.40506753f, 0.20043397f, 0.16207869f, 0.42424473f, 0.01384848f, 
    -0.35768178f, 0.02892936f, -0.09568746f, 0.37840435f, 0.12275984f, 0.06293774f, 0.01072963f, 0.35963428f, 
    -0.13806653f, 0.31968108f, -0.11380108f, 0.20394443f, 0.09571130f, 0.05182743f, -0.13677247f, -0.27678052f, 
    0.01144980f, 0.03312109f, -0.00078967f, 0.23429385f, 0.34608901f, 0.04053953f, -0.47290060f, 0.43808591f, 
    0.19636530f, -0.27846897f, -0.06910864f, 0.16095759f, 0.81408113f, 0.02658284f, -0.29981899f, 0.42457864f, 
    -0.22454609f, -0.13934915f, -0.03299170f, 0.40973574f, 0.07306955f, -0.05701704f, -0.02239248f, 0.40252742f, 
    0.23613808f, -0.02004340f, -0.00298378f, 0.44573861f, -0.47102252f, -0.21043579f, -0.00129245f, -0.14549470f, 
    -0.14645915f, -0.08398045f, 0.17283589f, -0.14661354f, -0.37674233f, -0.16850519f, 0.20509556f, 0.31128800f, 
    -0.05453345f, 0.34798208f, -0.19118762f, -0.17071728f, 0.63802147f, -0.03769431f, -0.01663748f, 0.06927781f, 
    -0.27724198f, 0.19367985f, 0.08646357f, -0.00499125f, 0.18697830f, -0.20221585f, -0.54339528f, 0.56808501f, 
    -0.05311697f, 0.04419461f, -0.04320146f, -0.51759320f, -0.15259320f, 0.03664731f, 0.38082999f, 0.27012613f, 
    0.24648097f, -0.21492526f, 0.33659762f, 0.08628757f, -0.25135344f, -0.03403153f, -0.03420416f, -0.16603945f, 
    0.15602219f, 0.21143225f, 0.00395572f, 0.13714808f, 0.12009873f, -0.26244989f, 0.50896704f, -0.36392841f, 
    0.06265254f, 0.03394919f, 0.26517344f, -0.23406975f, -0.10126291f, -0.06637713f, -0.08290429f, -0.07374162f, 
    0.22726776f, 0.01077688f, 0.07542224f, -0.10748321f, 0.23582233f, -0.23130436f, -0.18344477f, 0.05414988f, 
    0.10581605f, -0.16266754f, -0.10778970f, -0.21031557f, 0.16501339f, -0.20991150f, -0.05043199f, -0.16840737f, 
    0.17047018f, 0.27649379f, -0.19199407f, 0.15659317f, 0.18545392f, -0.49318627f, 0.30218473f, -0.10914916f, 
    -0.19596092f, -0.24491827f, 0.28418693f, 0.03177959f, -0.35412079f, -0.07488620f, -0.24480802f, -0.13678934f, 
    -0.24144617f, 0.06682020f, -0.22185862f, 0.01828572f, 0.13958246f, -0.14125738f, -0.23757991f, 0.03165576f, 
    -0.06052053f, -0.23387915f, -0.13178137f, -0.03633842f, -0.10855222f, 0.04815239f, -0.16387439f, 0.09608856f, 
    -0.08888815f, -0.03828053f, -0.15319672f, -0.45098582f, 0.10218213f, 0.29948667f, 0.56862509f, -0.07920446f, 
    -0.42815039f, 0.02259564f, -0.09014352f, -0.06057766f, 0.17133735f, -0.14793727f, 0.33049700f, -0.13001730f, 
    0.16846599f, 0.39274952f, 0.17276311f, -0.24915516f, -0.44623181f, -0.15256099f, 0.40795442f, -0.05519933f, 
    -0.15134716f, -0.01952371f, 0.01351213f, 0.48047432f, -0.19258350f, -0.15775210f, 0.07414276f, 0.51669544f, 
    0.24737284f, 0.58586419f, 0.17282966f, 0.16115202f, 0.24035636f, -0.73256809f, 0.03913526f, 0.26633465f, 
    0.11565255f, 0.03427551f, -0.02588174f, 0.20352612f, -0.53368700f, 0.23085606f, 0.23627873f, -0.11638431f, 
    0.13271458f, -0.12868984f, -0.04162661f, -0.27198949f, 0.19331701f, 0.28655332f, 0.41084883f, 0.55840874f, 
    -0.09672812f, -0.05945669f, 0.06600088f, 0.12042436f, -0.13211435f, -0.07501096f, -0.46514255f, -0.39727271f, 
    -0.07875326f, -0.23275158f, -0.09994029f, -0.21486457f, -0.24784072f, -0.15920606f, 0.18351783f, 0.47461858f, 
    -0.51507151f, -0.08902796f, 0.12212930f, 0.10379256f, 0.28854114f, 0.02460117f, 0.17272761f, 0.00039424f, 
    -0.11834380f, -0.06564625f, -0.03704578f, 0.19643684f, -0.21331000f, -0.06818007f, -0.15457287f, 0.75380188f, 
    -0.23371993f, 0.09500399f, -0.05092128f, 0.06778827f, 0.43366653f, 0.06888142f, 0.38104534f, -0.30609226f, 
    -0.00476362f, -0.06447888f, 0.12456679f, 0.01585702f, 0.16764092f, -0.03082055f, -0.11332449f, -0.13469808f, 
    -0.13609815f, 0.04257630f, -0.13508666f, -0.17411926f, 0.03371507f, 0.02181834f, -0.18255235f, 0.09611712f, 
    0.17152706f, -0.89465630f, 0.13948190f, 0.31436974f, 0.63132435f, 0.85791361f, 0.12085713f, 0.30177411f, 
    -0.09598288f, -0.23953781f, 0.13667962f, -0.09290486f, -0.08255039f, -0.16237162f, -0.67331862f, -0.68572944f, 
    -0.09125527f, -0.32244176f, -0.10645743f, 0.20339389f, -0.81199002f, 0.24785239f, 0.44915944f, -0.18333636f, 
    0.02038305f, -0.07389037f, 0.15416272f, 0.23600486f, -0.31840929f, 0.21091056f, 0.44357592f, -0.07659962f, 
    -0.03684326f, -0.17201148f, 0.08536763f, 0.44705448f, 0.50287366f, 0.33440122f, -0.40479785f, 0.22034256f, 
    0.24078698f, 0.24335021f, 0.13282406f, -0.57931113f, -0.04741199f, 0.08481868f, -0.12884480f, 0.07981814f, 
    -0.00203101f, -0.20934351f, 0.18902074f, -0.07762749f, 0.03175140f, 0.18651150f, 0.19369493f, -0.26562938f, 
    -0.07675178f, -0.01903415f, -0.20857081f, -0.18561052f, -0.08392797f, -0.15433091f, -0.09490626f, -0.07413719f, 
    0.16998850f, 0.46025595f, -0.13030875f, 0.24926767f, 0.62936437f, -0.61159676f, 0.38607565f, 0.25851521f, 
    -0.60272253f, 0.11492371f, -0.07615937f, -0.11558975f, 0.13521627f, 0.10446896f, -0.50803077f, 0.53597212f, 
    -0.08046305f, 0.58662039f, -0.08823261f, 0.18920395f, 0.33914155f, -0.47326413f, 0.10897912f, 0.13283719f, 
    0.18568376f, -0.13223064f, -0.30058011f, -0.13837969f, 0.28499758f, 0.11631733f, 0.17500179f, -0.39956537f, 
    -0.23038514f, -0.12715001f, -0.13092288f, -0.19756241f, -0.12873876f, -0.08619080f, 0.15936804f, -0.09973328f, 
    -0.11149930f, -0.24072033f, -0.12684180f, -0.24797323f, 0.14844047f, 0.00624004f, -0.07647699f, -0.16631024f, 
    -0.03543375f, -0.07589178f, -0.24951297f, -0.12311044f, -0.02408402f, 0.16300333f, 0.45499784f, 0.09216796f, 
    0.38696966f, -0.20837371f, 0.13845162f, -0.32090804f, 0.24497326f, -0.14308877f, -0.27255335f, -0.26082447f, 
    -0.01944364f, 0.31305119f, -0.03819843f, -0.44096875f, 0.23264392f, 0.23716646f, 0.50197726f, 0.04597098f, 
    -0.11228958f, -0.18686058f, -0.22897978f, -0.26738933f, 0.06186365f, 0.23636366f, 0.23408523f, -0.13051023f, 
    -0.05116636f, -0.46734717f, -0.16620974f, 0.39571396f, 0.22873251f, 0.47898760f, 0.10074917f, 0.36080199f, 
    -0.03180699f, 0.07999263f, 0.01673622f, -0.03454062f, 0.21853957f, 0.16404247f, -0.37850326f, -0.32695517f, 
    -0.19078758f, 0.30442402f, -0.12423864f, -0.39894640f, 0.84580958f, 0.07285441f, 0.09099644f, -0.29152203f, 
    0.16387036f, -0.01254017f, 0.06950045f, -0.59995276f, -0.44444886f, 0.15662178f, 0.11318070f, 0.54554814f, 
    0.04241569f, 0.03359370f, 0.01108074f, -0.27949366f, -0.13518532f, 0.16800776f, 0.54465425f, 0.03437814f, 
    0.20220271f, 0.08000074f, 0.25901344f, 0.01304650f, -0.60920620f, -0.09151864f, -0.33040723f, 0.07752388f, 
    0.17077848f, 0.40589404f, 0.16704237f, -0.58512956f, 0.19126612f, 0.35753486f, 0.30078074f, -0.08868317f, 
    -0.33343822f, 0.11042091f, 0.07972649f, -0.33267507f, -0.72892410f, -0.20771971f, 0.08655977f, 0.38906503f, 
    -0.19247603f, -0.21719140f, -0.19664645f, -0.11838871f, -0.23099548f, -0.07991055f, 0.10433462f, -0.20015463f, 
    -0.15955654f, -0.16377777f, -0.08854297f, 0.05461863f, -0.21086487f, 0.19534305f, 0.07691908f, 0.12773150f, 
    -0.17389378f, 0.24411012f, -0.16042359f, -0.11750554f, 0.40409178f, -0.12195227f, 0.26813185f, 0.37985632f, 
    0.33982366f, 0.16211489f, -0.15823716f, -0.39292604f, 0.01463581f, 0.12386143f, 0.31697249f, -0.28446326f, 
    -0.12750334f, 0.30398959f, -0.03764491f, 0.07309731f, -0.42362070f, -0.21924581f, 0.24437025f, 0.19187398f, 
    -0.39903733f, -0.13033855f, 0.26590750f, -0.41472337f, -0.20420724f, -0.01353922f, -0.17279552f, -0.34245220f, 
    -0.05939469f, -0.09948273f, -0.21876636f, -0.13635859f, -0.06476170f, 0.15583216f, 0.42503202f, 0.06996243f, 
    0.04844076f, 0.09508973f, 0.36432946f, 0.13262910f, -0.56454408f, -0.08579639f, -0.65321320f, -0.16912621f, 
    -0.02286348f, -0.02690583f, -0.07251295f, -0.21444120f, 0.11274011f, 0.05105821f, -0.06548730f, -0.04444329f, 
    0.00424614f, -0.13132098f, -0.26274347f, -0.08598948f, -0.19136590f, 0.01889828f, 0.19903651f, -0.17452063f, 
    -0.17952956f, 0.18420184f, 0.21612351f, 0.18219902f, -0.06568115f, 0.13696763f, -0.30416882f, 0.33711848f, 
    0.48057315f, -0.08635176f, -0.19273642f, 0.10916816f, -0.35473186f, 0.18702663f, 0.57625246f, 0.01948916f, 
    0.17476209f, -0.44860196f, 0.17045347f, 0.22147386f, -0.10987812f, -0.33928719f, 0.23412989f, 0.35526523f, 
    -0.64821523f, -0.02290192f, 0.56565642f, -0.29657605f, -0.12191857f, 0.16070302f, 0.26839471f, -0.02189532f, 
    -0.03548846f, -0.08944368f, 0.04540315f, -0.18966596f, 0.08320528f, 0.00281942f, 0.17694403f, -0.27180013f, 
    0.01045026f, -0.17068654f, -0.08652010f, -0.33188713f, 0.03684558f, 0.15761614f, -0.11095726f, -0.11667147f, 
    -0.01765421f, -0.35733756f, -0.00156476f, 0.45832348f, 0.22710083f, -0.13735034f, 0.23601408f, 0.02142474f, 
    0.20483904f, -0.19455978f, -0.18906535f, -0.60321850f, 0.36400676f, -0.15530571f, -0.13308428f, 0.00526628f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    0.21625894f, -0.20417616f, 0.65525454f, 0.01796291f, 0.45915475f, -0.62185180f, -0.03708098f, 0.17494078f, 
    0.28948119f, 0.13938344f, -0.01567825f, -0.27515256f, 0.46887735f, 0.38986757f, 0.11803894f, -0.20848097f, 
    0.38330588f, 0.22720362f, 0.01148948f, -0.00251580f, -0.16782154f, -0.20505568f, -0.14311872f, 0.15723807f, 
    0.17253478f, -0.26009160f, -0.30707571f, 0.16881576f, 0.27275953f, -0.42802873f, 0.28268343f, 0.22332944f, 
    0.02111924f, 0.18632515f, -0.21440855f, 0.29997402f, 0.46724945f, 0.37262037f, 0.08215924f, 0.47134992f, 
    0.07495280f, 0.12836942f, 0.03478191f, 0.39972758f, -0.00626765f, 0.22821303f, 0.64501816f, 0.20701265f, 
    0.18548448f, -0.11396178f, 0.24317856f, -0.19399959f, -0.18832576f, -0.05149052f, 0.37690699f, -0.14875647f, 
    -0.07805447f, 0.36353219f, -0.23194240f, -0.04411170f, 0.26665133f, 0.56752354f, -0.15981634f, -0.08495374f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    0.19682880f, 0.17382830f, -0.37393758f, -0.10404589f, 0.07457733f, 0.18255052f, 0.99512172f, 0.13075060f, 
    0.14659466f, 0.20163180f, 0.09156052f, 0.06550539f, -0.64001989f, 0.01489164f, 0.04117629f, -0.14456390f, 
    -0.15647984f, -0.07982510f, -0.13444471f, 0.22149466f, -0.05020959f, 0.28506315f, -0.08701538f, -0.15334158f, 
    -0.15643643f, -0.40903887f, 0.13204305f, 0.20074730f, 0.04572225f, -0.01901104f, -0.30917740f, -0.09627951f, 
    0.03048919f, 0.03641262f, -0.02922101f, -0.18910295f, -0.49036106f, -0.06157282f, -0.05904660f, -0.21771123f, 
    0.03917213f, -0.08378070f, 0.38183624f, -0.21096778f, 0.40768611f, -0.10205457f, -0.00087187f, -0.00111822f, 
    0.02789792f, -0.06537556f, -0.33414686f, 0.35346279f, -0.32575557f, -0.22816697f, -0.35673916f, -0.12141889f, 
    -0.07180059f, -0.09331676f, -0.05497552f, -0.06657869f, -0.06115331f, -0.11087944f, 0.02903007f, 0.47085813f, 
    0.30236211f, 0.01347674f, 0.04092271f, -0.00146491f, -0.05889925f, -0.14473510f, -0.95288426f, 0.21103808f, 
    0.19112690f, 0.16600502f, -0.20551632f, 0.06184651f, -0.26879010f, 0.09698993f, 0.08298282f, 0.32131186f, 
    -0.25499082f, -0.15320456f, 0.04658299f, 0.04619396f, 0.48509783f, 0.02847415f, 0.12161795f, 0.02955093f, 
    0.08332203f, -0.30568364f, -0.02675568f, 0.11940237f, 0.26010069f, -0.11259740f, -0.28846848f, -0.21179362f, 
    0.01724985f, -0.30262774f, 0.00898737f, -0.15063393f, -0.14513308f, -0.04618942f, -0.43295494f, -0.06777629f, 
    0.21602063f, 0.04089577f, -0.70379537f, -0.13849899f, 0.25268704f, 0.06506860f, 0.05152662f, 0.24791864f, 
    0.05435952f, -0.09369375f, -0.09958307f, -0.07325540f, 0.23926145f, -0.01364132f, 0.54794085f, -0.12433423f, 
    0.01929541f, 0.30321306f, -0.55877680f, 0.01804702f, 0.18140528f, -0.05258929f, -0.04050965f, 0.30952191f, 
    -0.04464340f, -0.02895362f, 0.14390525f, -0.31108922f, -0.37386289f, -0.16118531f, -0.04796054f, -0.97977781f, 
    -0.19481879f, 0.23837332f, -0.11341278f, 0.20442234f, -0.00126319f, 0.46652904f, 0.02748890f, -0.26538685f, 
    0.18343441f, -0.11968811f, 0.08905342f, -0.07956552f, -1.08001304f, -0.23309760f, -0.17749977f, 0.05008521f, 
    -0.19030805f, -0.66967607f, -0.25914073f, -1.21938384f, 0.09627409f, -0.92929077f, 0.09033969f, 0.14461741f, 
    0.06973593f, 0.65867352f, -0.04641317f, -0.19897491f, -0.11666556f, 0.53355908f, 0.01931399f, 0.10555696f, 
    0.01933061f, 0.10063566f, -0.64261079f, 0.15092480f, 0.30781284f, -0.08442333f, 0.54195672f, 0.33899400f, 
    0.10170414f, 0.17411654f, -0.10398898f, -0.91213328f, -0.48053363f, -0.12266393f, -0.72416222f, -0.09844324f, 
    0.12337719f, 0.58490115f, -0.01904607f, 0.02590105f, 0.18085828f, 0.50988823f, -0.02020480f, -0.89306432f, 
    -0.35556629f, -0.78174168f, 0.09370887f, -0.53521037f, -0.08043177f, 0.07382454f, 0.20298222f, 0.11415282f, 
    0.35937688f, 0.08032580f, -0.39201155f, -0.41720256f, 0.04777565f, 0.37589478f, 0.06927157f, -0.74287975f, 
    0.11043017f, 0.19317992f, 0.10638371f, -0.80412155f, -0.18867736f, 0.24209489f, -0.09819740f, 0.09066585f, 
    -0.45503458f, 0.06864427f, -0.10889281f, -0.21656372f, -0.00681390f, 0.06225651f, 0.00173048f, 0.32378358f, 
    -0.04084238f, 0.23168898f, 0.10706088f, 0.32506049f, -0.26619318f, -0.72150362f, 0.17299072f, 0.17456600f, 
    -0.02100112f, 0.02537262f, 0.27566686f, 0.08218045f, 0.03402287f, 0.06759624f, 0.01092651f, -0.28478500f, 
    -0.10384245f, 0.16730484f, 0.06262016f, 0.10931083f, -0.95371419f, 0.28265923f, -0.86139590f, -0.09766759f, 
    -0.13361619f, 0.23882602f, 0.51797932f, -0.04757353f, -1.17735267f, 0.24401093f, -0.12680861f, 0.52279049f, 
    -0.92583585f, 0.20582177f, -0.16185084f, 0.14617665f, 0.06154411f, 0.27611196f, -0.88134855f, 0.15834007f, 
    -0.31126779f, 0.01302806f, -0.09935240f, -0.05532712f, 0.37159687f, -0.01757981f, -0.41776368f, -0.08659151f, 
    0.10394867f, 0.28868881f, -0.46458894f, 0.03097657f, 0.21303162f, -0.12406057f, -0.51350307f, -0.05359235f, 
    0.07380193f, 0.32463521f, 0.14164504f, 0.22419909f, -0.32122397f, 0.02094956f, 0.04685199f, -0.52371281f, 
    -0.03295881f, -0.20580111f, -0.11517330f, -0.21261671f, -0.03249586f, -0.18555227f, 0.20277281f, 0.21821390f, 
    0.04263668f, -0.11139713f, 0.21723163f, -0.08465557f, -0.26653004f, -0.02285742f, -0.22236346f, -0.45004332f, 
    0.04797466f, 0.00136818f, -0.24357052f, -0.01618342f, 0.14271127f, -0.56226861f, -0.40274954f, -0.07738821f, 
    -0.17797108f, -0.41706309f, 0.06866357f, 0.01485217f, -0.01544909f, 0.15138416f, 0.03199524f, -1.06343961f, 
    0.28397921f, 0.06398380f, -0.29804814f, 0.06077542f, 0.25727987f, 0.16963740f, -0.29896411f, 0.03208327f, 
    0.15484819f, -0.14633098f, -0.04710259f, 0.25042453f, 0.13171439f, 0.09647252f, 0.06574009f, 0.21308774f, 
    -0.48164234f, 0.05458953f, -0.09049237f, -0.07567590f, 0.28390798f, 0.05740510f, 0.20499754f, -0.30894461f, 
    0.05302636f, -0.11784430f, -0.18745874f, 0.21767549f, -0.58504701f, 0.25619903f, -0.00920038f, -0.11661734f, 
    -0.07020495f, -0.01538196f, 0.01572344f, -0.01955992f, -0.15905289f, 0.21161304f, -0.03600240f, 0.06613314f, 
    0.18588707f, -0.07539406f, -0.25948182f, -1.00885189f, 0.01875570f, -0.04601836f, 0.25721788f, 0.23750699f, 
    -0.04112719f, -0.11788423f, 0.09772036f, -0.15823224f, -0.05406409f, -0.53519797f, -0.15246581f, 0.07002717f, 
    0.22075015f, -0.25962600f, -1.07585204f, -0.04539954f, 0.06439512f, 0.01741055f, -0.09811680f, -0.67620146f, 
    -0.24135105f, 0.10705530f, -0.00476769f, -0.23585682f, -0.90637738f, -0.22574097f, -0.08610599f, -0.63381815f, 
    -0.68449408f, 0.03065703f, 0.41360605f, 0.05347667f, 0.11481515f, -0.05957339f, -0.99243629f, -0.54314303f, 
    0.10230079f, -0.49773771f, 0.09272924f, 0.30628994f, -0.47432974f, -0.49918410f, -0.73260897f, -0.02946074f, 
    0.00160722f, -0.42459473f, -0.42176852f, -0.38393161f, -0.14917670f, -0.84035498f, 0.23481211f, 0.18438385f, 
    0.02060672f, 0.26796010f, 0.09967758f, 0.10491163f, 0.02050085f, 0.56734687f, -0.25397459f, -1.26771450f, 
    -0.91760546f, 0.02983474f, 0.18975493f, 0.25161871f, -0.09819613f, 0.01446441f, -1.05239987f, 0.71608663f, 
    0.10141199f, 0.04865011f, 0.20848614f, -0.31934240f, -0.09699114f, 0.16567217f, -0.04523419f, 0.03143485f, 
    0.30240011f, -0.18502046f, 0.00797179f, -0.11117785f, 0.26587683f, -0.90238631f, -0.02723288f, -0.23151340f, 
    0.29161331f, 0.12978894f, -0.35289156f, -0.13517214f, -1.37013388f, 0.24570172f, 0.03773076f, 0.08101263f, 
    -0.12682131f, 0.12808582f, 0.01751745f, 0.13314973f, -0.22867133f, -0.17580780f, -0.57647711f, -0.22507039f, 
    -0.24045478f, -0.31296673f, 0.19100241f, -0.29959640f, -0.50191021f, 0.18712084f, 0.07484266f, -0.00367144f, 
    -0.25086671f, -0.05170275f, 0.13449842f, 0.08690277f, 0.04362367f, 0.19809180f, 0.14956608f, 0.21786195f, 
    -0.06642586f, -0.71803075f, -0.03282352f, -0.23999338f, 0.01593362f, -0.56205195f, 0.95514309f, -0.77149683f, 
    -1.01975524f, -0.05788299f, 0.49229503f, -0.61877149f, 0.11393244f, -0.09729187f, -0.44923034f, -0.21408328f, 
    0.04202296f, 0.24503240f, 0.04729401f, 0.85565126f, -0.08927214f, 0.15811361f, -0.47704065f, -0.08438686f, 
    0.19735077f, -0.12145112f, 0.49746782f, 0.01653495f, -0.03215406f, -0.93823200f, -0.06921262f, -0.12955581f, 
    0.36583537f, -0.02676542f, 0.00324716f, 0.19143353f, 0.36966181f, -0.00991136f, -0.00576704f, -0.91856033f, 
    -0.06691881f, -0.50818050f, 0.26835230f, -0.29125723f, 0.23650932f, -0.84851676f, 0.68561232f, -0.48421326f, 
    0.01505194f, -0.29155028f, 0.22064067f, -0.28565449f, -0.69595736f, -0.16526888f, 0.21730165f, 0.17250693f, 
    -0.03665214f, 0.34299546f, 0.23411205f, -0.41155660f, -0.23567587f, 0.16413276f, -0.12434260f, 0.07586662f, 
    0.02501442f, -0.84535605f, -0.05800903f, 0.31133389f, 0.15067565f, -0.67530555f, -0.06059504f, 0.06773876f, 
    0.06273510f, -0.06424814f, -0.15873535f, -0.22236043f, -0.05937834f, -0.10546713f, 0.15745206f, 0.34510893f, 
    -0.02322162f, 0.00919251f, 0.22620094f, -0.46480107f, -0.03717772f, -0.06173364f, -0.13262971f, -0.05786730f, 
    0.00733646f, -0.15521312f, -0.55651367f, -0.03204264f, -0.15449789f, -0.99746549f, -0.08441097f, -0.03757666f, 
    -0.49845383f, 0.06210280f, 0.32132319f, -0.32496601f, -0.46822262f, -0.19306876f, 0.06805476f, 0.20252922f, 
    0.35387310f, -0.03075273f, -0.05488508f, -0.35353601f, -0.08142591f, 0.13692942f, -0.92357033f, 0.01865511f, 
    0.21479313f, -0.03614233f, -0.40857998f, 0.23489790f, -0.11595193f, -0.74072033f, -0.33639693f, -0.05472371f, 
    0.25072375f, 0.28126878f, -0.58269882f, -0.01555214f, 0.28180820f, -0.93802810f, 0.23632491f, -0.09629641f, 
    -0.12551844f, -0.37724990f, -0.06769057f, 0.42420316f, 0.21490608f, -0.22656189f, -0.19119588f, 0.25049728f, 
    0.31999335f, 0.07765941f, -1.39947486f, 0.71958560f, -0.27648684f, 0.05298062f, -0.93867987f, -0.92369539f, 
    0.01288165f, -0.13058665f, 0.20348297f, -0.71369445f, -0.06092282f, 0.15416196f, 0.25003213f, -0.07925759f, 
    0.03036302f, -0.28636497f, -0.04437358f, -0.09199341f, 0.23461708f, 0.23651195f, 0.01513504f, -0.72007287f, 
    -0.56752467f, -0.08363079f, 0.25266647f, 0.54113144f, 0.29506102f, -0.40960968f, -0.46503350f, -0.13910609f, 
    -0.01175616f, 0.18715473f, -0.37693658f, -0.48917398f, 0.51776695f, -0.28675464f, 0.14808919f, 0.15104173f, 
    0.05156431f, 0.51056689f, 0.22001594f, -0.05427435f, -0.30438983f, 0.25566787f, 0.33815747f, 0.40134019f, 
    -0.61605400f, -0.16504471f, 0.54308385f, 0.17780317f, 0.27783215f, 0.39253992f, -0.46883070f, 0.14988072f, 
    0.09795332f, 0.22282442f, 0.08947334f, -0.49594817f, 0.23666669f, 0.01695995f, -1.29838717f, -0.01840872f, 
    -0.24824430f, 0.01822458f, -0.50135481f, -0.18565875f, -0.49655223f, -0.12684536f, 0.36207992f, -0.23843117f, 
    -0.00924362f, -0.61421168f, -0.52879477f, -0.75571233f, -0.91218537f, -0.21325327f, -1.06384337f, 0.07842167f, 
    -0.65516430f, -0.82323790f, -0.34617653f, 0.03527429f, -0.08788288f, -0.20852084f, 0.10785777f, -0.39781752f, 
    -0.41080406f, -0.37039971f, -0.00473285f, -0.00164252f, -0.83541691f, -0.31429002f, -0.09124718f, -1.01793420f, 
    0.08694632f, -0.20273910f, -0.36422706f, -0.30784342f, 0.26756957f, -0.33250511f, -0.23992682f, -0.92814332f, 
    0.07043041f, 0.17195973f, 0.19231525f, -0.12790485f, -0.97340423f, -0.00824536f, -0.82558143f, 0.06491526f, 
    0.13466130f, 0.15811610f, 0.05514503f, -0.43279567f, 0.14890999f, 0.34868890f, 0.07098177f, 0.17372531f, 
    -0.06945460f, 0.37418017f, 0.04325627f, 0.03861477f, 0.30229270f, 0.13512106f, 0.13951285f, -0.00415676f, 
    -0.69384372f, 0.02824449f, -1.13800800f, -0.19609880f, -0.54538959f, 0.09789237f, 0.52413404f, -0.90112984f, 
    0.05358257f, 0.00416291f, -0.00047985f, -1.13212597f, 0.14124523f, 0.24254964f, 0.30643353f, 0.08430542f, 
    -0.16577093f, -0.18064886f, 0.28905582f, -0.07545535f, -0.26383939f, -0.24615757f, 0.05805057f, -1.51943779f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    -0.26717925f, -0.06504116f, 0.27283344f, -0.01060668f, -0.15246648f, -0.06112520f, 0.11787719f, -0.10246523f, 
    0.18410170f, 0.14008960f, 0.04432368f, -0.05405866f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Convolutional Layer 1
    conv_layer(buffer_b, buffer_a, 
               CONV1_IN_CHANNELS, CONV1_IN_H, CONV1_IN_W,
               CONV1_NUM_FILTERS, CONV1_KERNEL_SIZE,
               conv1_weights, conv1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 96);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL1_CHANNELS, POOL1_IN_H, POOL1_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE1_OUTPUT_SIZE);

    
    return buffer_a;
}
