#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.85453743f, -0.14569238f, 0.37554982f, -0.64383668f, 1.01841819f, 0.54490525f, -0.41218489f, -0.92501175f, 
    -0.88164616f, -0.47431353f, 0.75142336f, 0.75926030f, -0.21858107f, 0.47645989f, 0.21537802f, 0.12711042f, 
    -0.45419979f, -0.90475821f, 0.10634807f, 0.26736063f, 0.39431578f, 0.42116266f, 0.09690819f, 0.07310077f, 
    0.32685885f, -0.75099653f, -1.19132447f, 0.44715345f, 0.88450277f, -0.73565686f, 0.31712717f, -0.06624503f, 
    1.07204342f, -0.71839350f, -0.87290061f, -0.20295128f, -0.20676723f, -0.52521533f, -0.04698306f, -0.13337362f, 
    0.04288730f, 0.54259402f, -0.57564890f, -0.19011435f, 0.02758523f, 0.09698371f, 0.80175835f, 0.46596369f, 
    0.25768799f, -0.21909282f, 1.11184812f, 0.24481687f, 1.30418408f, 0.83455294f, 0.72615856f, 1.34577012f, 
    0.20780350f, 0.07945451f, -0.44039679f, -0.19489364f, 0.38018814f, 0.10315508f, -0.40310189f, -0.14263041f, 
    -0.30761296f, -0.22945513f, -0.05287300f, 0.03038532f, -0.14058764f, -0.41213039f, -0.11520483f, 0.36351964f, 
    0.33131382f, -0.40123335f, 0.17057422f, 0.91669059f, 1.04034531f, 0.60145116f, -0.04757347f, -1.53817785f, 
    -0.52387506f, -0.31089884f, 0.27404618f, 0.26681176f, 0.49347916f, -0.20744699f, 0.01434970f, -0.34699923f, 
    0.43568599f, -0.46005458f, -0.15485620f, 0.07659693f, 0.00784922f, -0.59490365f, -0.58363128f, -0.43905216f, 
    -0.59009153f, -0.25145316f, -0.38967511f, 0.02762358f, -1.25406790f, -1.04493904f, 0.38019946f, 0.91854107f, 
    0.42745188f, 0.06358398f, -0.01208438f, -0.26793307f, 0.26936045f, -0.45045346f, 0.99368584f, 0.22245874f, 
    -0.01462053f, 0.37256113f, -0.12133704f, 0.06127505f, 0.76842439f, 0.60153556f, -0.12920158f, 0.19514857f, 
    -0.61369288f, -0.45811984f, 0.03149031f, -0.21941505f, 0.26347414f, -1.30521309f, -1.00474942f, -0.50015539f, 
    -0.19101757f, -0.88625920f, 0.74710703f, 1.81165576f, 0.15942860f, -0.03595968f, 0.50960648f, -0.56363767f, 
    -0.36509463f, 0.09585538f, -0.22528441f, -0.00492039f, -0.09771425f, 0.10850850f, -0.17879713f, -0.02567738f, 
    -0.14264743f, -0.10508099f, -0.50221926f, 0.08370551f, -0.19763452f, -0.15154751f, 1.75269139f, 0.84763539f, 
    -1.18490469f, -0.88253224f, -0.75018179f, 0.13130198f, 0.21307626f, 0.06967971f, 0.21021533f, -0.20947817f, 
    -0.25481272f, -0.13795827f, 0.17396516f, -0.19127816f, -0.20042799f, 0.00578333f, -0.44243699f, -0.16503266f, 
    0.10992834f, 0.35143855f, 0.41961467f, 0.62439013f, -0.28865936f, -0.18565248f, 0.05877296f, -0.36104357f, 
    0.63787037f, 0.33510411f, 1.05167532f, 1.49385214f, 1.51326835f, 0.39444917f, -0.54629648f, 0.30301282f, 
    -0.05437381f, -0.80884516f, 0.38684061f, -0.10290105f, 0.66935593f, -0.02996583f, 0.05664087f, 0.18406671f, 
    0.12705098f, 0.03859957f, -0.23020980f, -0.12400647f, -0.36908704f, -0.34710816f, 0.39158598f, 0.02273935f, 
    -0.68339086f, -1.35557103f, -1.11918664f, -1.29064333f, -0.32291776f, -0.16434537f, -0.55333853f, -0.48638833f, 
    -0.00548981f, -0.26979190f, 0.13491082f, -0.00320242f, 0.21809737f, 0.07597753f, -0.37025744f, -0.07795122f, 
    0.29227152f, 0.23397405f, 0.13087136f, 0.09046762f, 0.33132482f, 0.13576329f, 0.34468493f, 0.38638577f, 
    -0.05594787f, 0.96559775f, 1.33583248f, -1.40831769f, 0.46489570f, -1.17733800f, -0.21533762f, -0.40087172f, 
    -0.60543132f, -0.41472948f, -0.92965382f, -0.06964543f, -0.12916648f, 0.26020083f, 0.57672733f, 0.00326348f, 
    -0.13911077f, -0.00681721f, 0.18103270f, 0.03058030f, -0.04508593f, -0.07012343f, -0.10880719f, -0.07679749f, 
    0.01878412f, -0.08230802f, 0.62688172f, 1.04266870f, 0.77433223f, 0.63071430f, 0.26321808f, -1.13685298f, 
    1.20490682f, -0.12123556f, -0.53348655f, 0.67116004f, -0.39141998f, 0.13855457f, -0.29210475f, 0.31231645f, 
    0.43515319f, -0.39778793f, -0.10300017f, 0.28710446f, -0.28284708f, -0.16817540f, 0.47016507f, 0.57516295f, 
    0.37171400f, 0.34265289f, 0.24824098f, 0.79071718f, 1.35460222f, 0.76505119f, 0.22930905f, -0.11153667f, 
    -1.19312072f, -1.08876085f, -0.42672473f, 0.08131544f, 0.51573831f, 0.66819644f, -0.15846336f, -0.21792716f, 
    0.12960643f, 0.20931907f, 0.04350992f, -0.00097388f, -0.11926903f, 0.36671925f, 0.53312635f, 0.02264336f, 
    0.07100873f, -0.03383906f, -0.12794040f, -0.02519432f, 0.91674471f, -0.32753906f, 0.74114370f, 0.19977900f, 
    -0.30450836f, 0.80811387f, -1.26627994f, 0.86187756f, 1.02485180f, -0.00252230f, -0.05848203f, -0.12464001f, 
    0.08439815f, -0.52918410f, -0.13965423f, -0.17433941f, 0.38777786f, 0.18578567f, 0.18570739f, 0.10614499f, 
    0.21005949f, 0.10479452f, 0.21354662f, -0.14540979f, -0.50955802f, 0.49554238f, -1.42243004f, -1.31168520f, 
    -0.82000899f, 0.28627852f, 0.80252528f, -0.06286053f, 0.77829283f, 0.83261538f, 0.66443610f, -0.60695225f, 
    0.21619149f, -0.15935192f, 0.00713306f, -0.34684825f, -0.02940809f, -0.35637459f, 0.07565497f, 0.24512453f, 
    -0.30183810f, -0.11464893f, 0.05625955f, -0.50675261f, 0.15009089f, 0.42456964f, 1.15617335f, 1.13673329f, 
    0.96315783f, 1.56089342f, 0.99996996f, -0.27502421f, 0.19450025f, -0.43355554f, 0.43754393f, -0.28447652f, 
    0.21938668f, 0.02453556f, 0.29495215f, 0.62289417f, -0.07291814f, 0.51702046f, 0.17577270f, 0.71729445f, 
    0.50928903f, 0.12635942f, -0.06645846f, 0.03247602f, 0.04854134f, -0.12303147f, 0.22318757f, 1.73507953f, 
    0.54333371f, -0.39028475f, 1.15262318f, 1.81074739f, 0.25343412f, -0.25129071f, -0.45475501f, 0.95731181f, 
    0.40030873f, 0.02279390f, 0.68794382f, -0.13846575f, 0.00145243f, -0.11589075f, -0.42381403f, -0.39447305f, 
    -0.12837838f, -0.39323249f, -0.57834625f, 0.16222374f, -0.12783934f, 0.15488856f, 0.04460089f, 0.32822934f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    0.35677904f, 0.35994333f, 0.30437511f, 0.17433740f, 0.60524005f, 0.03344078f, 0.02476180f, 0.33259559f, 
    0.70231473f, 0.42463434f, 0.56773835f, 0.10941309f, -0.07237837f, 0.25449762f, -0.05392176f, 0.36334592f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.06387034f, -0.19388103f, 0.30391070f, -0.33843690f, -0.10767001f, 0.08025820f, -0.03078954f, 0.02903751f, 
    0.22638918f, -0.02478097f, 0.09997504f, -0.03272008f, -0.64856219f, 0.16596943f, -0.04948347f, 0.44331324f, 
    -0.04614283f, 0.19296189f, -0.14923869f, -0.03019322f, 0.07569292f, -0.07621568f, 0.11549758f, -0.16696970f, 
    0.29299754f, -0.12519105f, 0.02653027f, -0.06449664f, -0.29408535f, 0.11457486f, 0.13324526f, 0.07996255f, 
    -0.23679574f, 0.18874383f, -0.16524889f, -0.15836497f, -0.14572921f, -0.04300803f, -0.20895258f, -0.03355751f, 
    -0.22684827f, -0.40177271f, -0.07603046f, -0.05023966f, -0.09050615f, 0.06568439f, -0.13837270f, -0.21087290f, 
    -0.46363086f, -0.08460838f, -0.44861755f, 0.33391520f, 0.19039789f, -0.04118753f, 0.06519618f, -0.15863334f, 
    0.14405209f, 0.01592977f, -0.13126659f, -0.02619010f, 0.60672033f, 0.39126107f, 0.54426926f, -0.46118766f, 
    0.06119516f, 0.09821020f, -0.04865248f, 0.05862155f, 0.12225226f, -0.11367750f, -0.16482058f, 0.17180476f, 
    -0.22429460f, -0.08912812f, 0.06016933f, -0.60168147f, 0.07249010f, 0.00453759f, 0.21634218f, 0.06366928f, 
    -0.05797509f, 0.02549235f, 0.09757408f, 0.16652037f, -0.27382997f, -0.07380690f, 0.16536890f, 0.24501772f, 
    0.04123189f, -0.16725194f, 0.04448149f, -0.04204470f, -0.02125189f, -0.08996130f, -0.10461981f, 0.21817824f, 
    -0.55118346f, -0.43463770f, 0.09398533f, -0.27353996f, -0.15301292f, -0.13517350f, 0.15962608f, 0.20437759f, 
    -0.14747356f, -0.00444880f, 0.08919076f, -0.23713581f, -0.02736105f, 0.37226716f, 0.26531854f, -0.16073847f, 
    -0.29324836f, 0.01670669f, -0.09837598f, 0.05145250f, -0.12210976f, -0.06267551f, -0.09731837f, -0.11459075f, 
    -0.03845154f, 0.14101261f, -0.16606404f, -0.08926663f, -0.13334817f, -0.14670140f, -0.19907860f, -0.29265559f, 
    -0.01551043f, -0.10341483f, -0.10747074f, -0.10853702f, -0.21891907f, -0.02743836f, 0.11237386f, -0.02098656f, 
    -0.07272915f, -0.24465771f, 0.02698288f, -0.00272139f, 0.20158663f, 0.01653701f, 0.02665735f, 0.03070660f, 
    0.46936551f, -0.42996559f, -0.07104551f, 0.29145294f, 0.20010051f, 0.14466043f, 0.11492332f, -0.18836293f, 
    -0.01884365f, 0.08479273f, -0.08476038f, 0.08746310f, 0.53542274f, -0.09622292f, -0.19345798f, -0.41422433f, 
    0.17559172f, -0.16591527f, -0.01510135f, -0.02643151f, -0.11202005f, -0.06215921f, -0.16744339f, 0.23397988f, 
    -0.19426835f, 0.23542158f, -0.33904150f, 0.16880749f, -0.33288926f, -0.02985216f, 0.06007770f, 0.14552157f, 
    0.09597252f, -0.00509322f, -0.00306758f, -0.12608156f, 0.36681473f, -0.01630636f, 0.19620870f, 0.46199015f, 
    -0.13829385f, -0.11336121f, -0.17914785f, 0.17097132f, -0.15525298f, 0.21757828f, 0.04592365f, -0.24327506f, 
    -0.09922746f, -0.25396061f, 0.20010296f, -0.35513222f, 0.08847860f, -0.05871179f, 0.17472023f, -0.01987153f, 
    -0.04875528f, 0.09741205f, -0.35238174f, -0.04547277f, -0.34848201f, 0.08672217f, -0.43335351f, 0.33988109f, 
    -0.30578148f, -0.23248950f, -0.06295754f, -0.18462364f, 0.19510582f, 0.09523860f, -0.21499643f, -0.00605603f, 
    0.31199488f, 0.08798740f, 0.26268122f, 0.07588763f, -0.11193834f, 0.00050750f, 0.12519588f, 0.04583932f, 
    -0.14154863f, -0.16465741f, 0.16207249f, -0.01000867f, 0.22167139f, 0.14478789f, -0.44436076f, -0.25206065f, 
    -0.05570019f, -0.00532485f, -0.24991766f, -0.17677322f, -0.16865247f, -0.40787986f, 0.15745924f, -0.16679803f, 
    -0.09198983f, 0.19098391f, -0.42851323f, 0.10877871f, 0.01967824f, 0.21355864f, -0.32264763f, 0.07698416f, 
    -0.14181526f, -0.20376484f, 0.19284685f, 0.21514057f, -0.25732067f, -0.08670451f, -0.35678563f, 0.00964665f, 
    0.01094532f, -0.12510252f, 0.01695447f, -0.25561044f, 0.09655112f, 0.10495542f, 0.04366420f, -0.16755426f, 
    0.48414153f, -0.69278032f, 0.13646561f, -0.40304679f, -0.13641512f, -0.30850962f, 0.00512651f, -0.01054176f, 
    -0.05967969f, -0.09111402f, -0.17534266f, 0.07051390f, 0.48256698f, 0.26499975f, -0.24952371f, 0.17295052f, 
    -0.11391954f, 0.11668093f, -0.03911346f, -0.04715933f, -0.07667682f, 0.16856863f, 0.03692637f, -0.05212732f, 
    0.23352018f, -0.08424764f, 0.09997182f, -0.14921740f, 0.12146294f, 0.15428884f, 0.25533381f, 0.13781410f, 
    0.11384227f, -0.06980818f, 0.09213810f, 0.12359072f, 0.28245765f, -0.98678058f, -0.24406010f, -0.18674608f, 
    -0.13731059f, -0.11906654f, -0.10208817f, 0.00632809f, -0.05941584f, 0.13903239f, 0.03893286f, 0.01431152f, 
    0.29968444f, 0.32873923f, -0.15736175f, 0.09317274f, -0.13052838f, 0.14958252f, 0.16787586f, 0.10842829f, 
    0.12161645f, 0.01325722f, 0.12291396f, 0.13454928f, 0.04190065f, -0.14971747f, -0.28496599f, -0.00276137f, 
    0.06321911f, 0.02311582f, 0.10921604f, 0.02173287f, -0.22159268f, 0.08044693f, -0.02899942f, 0.20241298f, 
    -0.48813871f, 0.01350903f, 0.14361480f, 0.05889407f, -0.12768820f, -0.31007218f, -0.24788533f, -0.08775168f, 
    0.19360699f, -0.17713635f, -0.04992496f, -0.13950092f, 0.17973478f, -0.42515880f, 0.15743217f, -0.38867548f, 
    0.01311236f, 0.22291070f, -0.12687428f, 0.04553171f, -0.02818719f, -0.00678493f, 0.13424370f, 0.07808494f, 
    0.62908417f, -0.01588489f, 0.18934481f, 0.41880587f, -0.01229987f, -0.04783355f, -0.06212751f, 0.00532134f, 
    0.20685950f, -0.00854470f, -0.11674652f, -0.05372543f, 0.24497315f, -0.21083242f, 0.12911662f, 0.45169711f, 
    -0.08981353f, 0.05035837f, -0.12367471f, 0.08215253f, -0.12093849f, -0.05290652f, -0.47910449f, -0.04636196f, 
    -0.35600802f, 0.02109662f, -0.01873080f, -0.41138023f, 0.33996007f, -0.02560974f, -0.07859931f, 0.01857825f, 
    0.11690005f, -0.18068704f, -0.09587447f, -0.25237334f, -0.07652847f, -0.15362582f, -0.30315539f, -0.36010274f, 
    -0.26349306f, -0.03331538f, -0.12330686f, -0.07696713f, 0.28973064f, -0.11984636f, -0.07602131f, -0.09069731f, 
    -0.13807389f, 0.06546270f, -0.03799507f, -0.15513834f, 0.14495538f, 0.04398710f, -0.04018628f, 0.01475685f, 
    -0.25461692f, 0.28685653f, 0.05545049f, 0.20522200f, -0.63464272f, 0.12481302f, -0.08020898f, -0.05090130f, 
    -0.09554799f, 0.12500170f, 0.05818861f, 0.02129710f, -0.25077268f, 0.18542628f, -0.08873163f, -0.28978467f, 
    0.82670903f, -0.65158391f, -0.10795875f, 0.18659827f, -0.19878085f, -0.02405557f, -0.12737389f, -0.06948356f, 
    -0.19911844f, -0.09183604f, -0.14226429f, -0.09747933f, 1.11704099f, 0.14499640f, 0.18885095f, 0.18120466f, 
    -0.01282124f, -0.26844141f, -0.13609374f, 0.40173811f, -0.01082981f, 0.04306044f, 0.10832117f, -0.10642863f, 
    0.22921149f, 0.15438902f, 0.13859312f, -0.10549739f, 0.11738263f, -0.05555720f, 0.11543205f, 0.03054071f, 
    0.03381478f, -0.08106475f, 0.28553498f, 0.05752091f, 0.25966510f, -0.40979299f, 0.24386568f, 0.13563168f, 
    0.10110760f, 0.14198188f, -0.00267312f, -0.20965132f, -0.10837899f, 0.05536069f, -0.15044720f, 0.04493722f, 
    -0.91605735f, -0.46545058f, 0.18008210f, -0.09807621f, -0.24336645f, 0.03169702f, -0.55678457f, -0.15883775f, 
    0.12409028f, 0.01336139f, -0.12900636f, -0.07560381f, -0.18968302f, -0.42607161f, -0.53558844f, -0.65409362f, 
    0.08955411f, -0.03128396f, 0.03521612f, -0.03111124f, 0.01755183f, 0.08947586f, -0.16289243f, -0.11435160f, 
    0.35501379f, 0.12266668f, -0.00263362f, -0.10273213f, 0.07095058f, 0.13782683f, -0.04539321f, -0.14194418f, 
    -0.27210501f, -0.01860320f, -0.14686032f, -0.00580065f, -0.08293991f, 0.07768299f, 0.09995499f, 0.10364046f, 
    -0.13592431f, 0.18165891f, 0.25045359f, -0.13317971f, -0.20373060f, -0.17892294f, 0.00580685f, -0.02780402f, 
    -0.89767307f, 0.33199573f, -0.04318223f, -0.01694613f, 0.05560798f, -0.11202766f, -0.07132876f, 0.04291293f, 
    0.08496507f, -0.03233701f, 0.17055023f, -0.06333234f, -0.01317431f, 0.37900895f, 0.19136514f, 0.55004716f, 
    -0.07630482f, -0.03869477f, -0.03570144f, 0.17128728f, -0.21009962f, -0.15121652f, -0.20360616f, 0.14922547f, 
    0.25706813f, -0.06284652f, -0.25093943f, 0.27198818f, 0.19478385f, 0.03736055f, 0.08147079f, 0.00356689f, 
    -0.47287089f, 0.05452169f, -0.08756951f, -0.01285068f, 0.26326939f, -0.05358105f, -0.12386726f, -0.16187669f, 
    0.14972097f, 0.02165029f, 0.02028149f, -0.03953737f, 0.17540991f, 0.23464213f, 0.10499398f, -0.16968001f, 
    0.09945311f, 0.00683016f, 0.12192683f, 0.37536991f, -0.09371512f, -0.04307948f, -0.07275663f, 0.07397897f, 
    0.03758708f, -0.03481745f, 0.02075046f, -0.19029674f, 0.80339861f, 0.05628212f, 0.17360117f, 0.03460038f, 
    -0.01363927f, -0.02114850f, 0.10006741f, 0.13741294f, -0.17442469f, -0.19385308f, 0.11151189f, -0.07376121f, 
    -1.09471095f, -0.97210455f, -0.25176302f, 0.02354794f, -0.20654179f, -0.06775185f, -0.24180204f, 0.02940968f, 
    0.20486368f, -0.18550648f, -0.00882473f, 0.00341921f, -0.30129012f, -0.03402166f, -0.11055865f, 0.12717873f, 
    -0.38109201f, 0.09882868f, -0.04169528f, 0.11141176f, 0.27308282f, 0.27784416f, 0.09932663f, 0.15975997f, 
    -0.24099058f, 0.04782727f, 0.20218301f, -0.00577655f, 0.08338121f, -0.17451644f, 0.26837301f, 0.01972189f, 
    -0.10033922f, -0.11445661f, -0.05087978f, -0.22548507f, -0.26336744f, -0.09486549f, 0.06497259f, -0.17019728f, 
    -0.05709497f, -0.07894746f, 0.21430545f, 0.08104622f, -0.31839025f, -0.06298636f, -0.06803716f, -0.18435974f, 
    0.00121901f, -0.18795678f, 0.00158717f, 0.17025134f, -0.14101112f, 0.19577718f, 0.00626727f, 0.27734402f, 
    -0.08115658f, 0.28638497f, -0.14907049f, 0.12580906f, 0.86255610f, -0.30908537f, -0.34268695f, 0.11829361f, 
    -0.02578861f, -0.02206735f, -0.14430089f, -0.05544991f, 0.01302019f, -0.23005269f, -0.06576592f, 0.03787959f, 
    0.28451017f, 0.06077664f, -0.11571544f, -0.05424661f, -0.41842836f, -0.11781801f, -0.04021597f, -0.05161070f, 
    0.08896732f, 0.06714799f, -0.08059255f, 0.16601151f, 0.66649491f, -0.20785689f, 0.13822043f, 0.10168587f, 
    0.24105552f, 0.05938780f, 0.20229524f, -0.04144286f, 0.13576944f, 0.10463043f, 0.16795313f, 0.04025802f, 
    -1.71795833f, -0.42209998f, 0.10626161f, 0.06088107f, -0.09064799f, 0.11897238f, -0.20975190f, -0.09296439f, 
    -0.13555841f, -0.12459338f, 0.01089473f, 0.29846516f, -0.25341156f, -0.02691568f, -0.53694075f, 0.62655044f, 
    0.08014488f, 0.20651887f, 0.04534881f, 0.08872598f, 0.02733899f, -0.13793023f, 0.04774262f, -0.15968306f, 
    0.04554510f, 0.07303645f, -0.13339235f, 0.17712380f, 0.12134637f, 0.38122186f, -0.05939185f, 0.05353868f, 
    -0.03185032f, 0.25716493f, -0.14292227f, 0.20023777f, -0.13523591f, 0.25831082f, -0.23158857f, 0.04141329f, 
    -0.17059250f, -0.01085432f, -0.04809931f, -0.24401437f, -0.13098742f, 0.02089808f, 0.06970544f, 0.01746745f, 
    -0.43620512f, -0.08006611f, 0.06197954f, 0.12170938f, -0.28223851f, 0.09883730f, 0.19706681f, -0.00182328f, 
    -0.04307833f, -0.31617662f, 0.20681550f, -0.27241969f, 0.50403434f, -0.48336095f, -0.42662871f, -0.08146840f, 
    -0.02683301f, -0.02745384f, 0.04412229f, -0.28083280f, 0.10709577f, 0.00486114f, 0.04897945f, -0.05560315f, 
    -0.53073567f, -0.19193700f, -0.01389868f, -0.08118272f, 0.12090322f, -0.25150710f, -0.23322353f, -0.10785963f, 
    -0.10436817f, -0.05313414f, 0.15334420f, -0.14975153f, -0.17665574f, -0.02626791f, -0.22976099f, -0.46548668f, 
    -0.02238470f, 0.18954840f, -0.14242470f, 0.24210835f, -0.17356481f, 0.02487647f, 0.21512777f, 0.12393416f, 
    0.00091675f, 0.27716193f, 0.18281469f, -0.11082528f, 0.08300686f, -0.22217295f, -0.05484936f, 0.14628465f, 
    0.03108821f, -0.08000421f, -0.03242581f, 0.11454923f, 0.08307695f, -0.67672712f, 0.24029881f, -0.34635922f, 
    -0.03124605f, 0.21159999f, 0.28748938f, 0.13151950f, -0.02962668f, 0.29208824f, 0.06540735f, 0.26448125f, 
    -0.26057804f, 0.05394912f, 0.04772531f, -0.07923090f, 0.16260311f, -0.13103874f, -0.06542362f, -0.02964656f, 
    0.14090385f, 0.00181430f, -0.09622312f, -0.20361076f, -1.08026254f, -0.14334629f, 0.11918081f, 0.28958839f, 
    0.14182970f, -0.07430471f, 0.21383391f, 0.17817967f, 0.05754641f, 0.20244190f, 0.06085094f, 0.15188877f, 
    0.10493505f, -0.19843476f, -0.13319792f, 0.10026086f, -0.03889190f, 0.10791975f, 0.07539780f, -0.00584922f, 
    -0.25204977f, 0.01627848f, -0.00627430f, -0.14170443f, 0.14343011f, 0.12351368f, -0.47518250f, -0.38864759f, 
    -0.18695562f, 0.06404863f, 0.02894719f, 0.37149715f, -0.11292644f, 0.03159460f, -0.07959821f, -0.05508442f, 
    0.13821574f, 0.16815029f, -0.06475131f, 0.27309152f, 0.12389506f, 0.01526389f, -0.02638493f, 0.31726554f, 
    0.03241340f, -0.02523573f, -0.14507046f, 0.01946599f, -0.07594220f, 0.39017621f, 0.06715707f, -0.02498920f, 
    -0.03525183f, 0.02155934f, 0.22771786f, -0.33043662f, 0.11962500f, -0.04915844f, 0.12259795f, -0.07773123f, 
    -0.57979941f, 0.16699433f, 0.37496701f, 0.27737331f, -0.05775697f, -0.01216472f, -0.21037181f, 0.01104166f, 
    0.24508558f, -0.03268642f, -0.12386540f, 0.07694483f, -0.40341783f, -0.49332845f, 0.12736833f, 0.20157087f, 
    -0.17896119f, -0.07034057f, -0.00234677f, -0.19999790f, 0.10252644f, 0.03333120f, -0.04260622f, -0.14366418f, 
    -0.01682347f, 0.15097328f, -0.05177964f, -0.40563536f, -0.10687853f, 0.00686837f, 0.07450676f, -0.26263878f, 
    0.03891527f, 0.05431902f, -0.02858295f, 0.01214826f, -0.54135317f, -0.06658704f, -0.11295670f, 0.42989492f, 
    0.17072588f, -0.19484460f, 0.07287072f, -0.16643977f, -0.18307744f, 0.10217626f, 0.02636903f, -0.02431622f, 
    -0.08845860f, -0.07678078f, 0.00367010f, 0.29151395f, -0.10756408f, -0.04925785f, 0.26826218f, 0.16679928f, 
    0.15378390f, 0.17601278f, -0.03990845f, -0.12282225f, 0.54830927f, -0.28932303f, -0.11167581f, 0.22719592f, 
    -0.13079122f, -0.01492968f, 0.06211274f, -0.06514626f, -0.02082611f, -0.06419487f, -0.17568892f, 0.13078897f, 
    0.02955979f, 0.08828677f, 0.37056863f, 0.31798613f, -0.19949986f, 0.19794004f, -0.05582569f, -0.04440947f, 
    -0.05694346f, -0.00528669f, 0.02922574f, 0.25431484f, -0.54185683f, 0.16927901f, -0.15269561f, -0.20124404f, 
    0.26150995f, -0.02244272f, 0.30077872f, 0.09791131f, 0.03490549f, 0.16595832f, -0.15003568f, -0.20536555f, 
    -0.10062120f, -0.04517290f, 0.23289958f, 0.53095281f, -0.13462302f, 0.03408591f, 0.01750305f, -0.07057984f, 
    0.19337924f, -0.09909101f, -0.02460954f, 0.00321409f, 0.28596041f, 0.32441592f, -0.15308030f, 0.20335117f, 
    0.05250267f, 0.22812335f, -0.12211807f, -0.15001003f, -0.11380283f, -0.29091600f, -0.02476495f, -0.04939358f, 
    -0.46494579f, -0.12603921f, 0.01122339f, -0.45331436f, 0.04807484f, 0.02912004f, 0.07574507f, -0.17067243f, 
    0.09854928f, -0.06529565f, 0.20552421f, 0.33241108f, -0.64537507f, 0.15471272f, -0.48519218f, -0.19263856f, 
    0.21792518f, 0.06185835f, -0.01603368f, -0.21064821f, 0.06499740f, -0.29655096f, -0.09681262f, -0.18677624f, 
    0.04791870f, 0.03826039f, 0.02928213f, 0.05002409f, -0.10971790f, -0.06995644f, -0.19527137f, -0.02596007f, 
    0.14627872f, 0.05596205f, -0.00496890f, -0.23668312f, -0.31781772f, -0.05819793f, 0.60434878f, -0.18667932f, 
    0.15076904f, -0.06399653f, 0.07505111f, -0.21416062f, 0.01105039f, -0.01875570f, 0.04444443f, -0.28681776f, 
    -0.16629249f, -0.48205212f, -0.18417762f, 0.13064708f, 0.18239129f, 0.18390636f, 0.01082056f, 0.00197676f, 
    0.07028472f, -0.00346114f, 0.01034845f, 0.25383109f, 0.03301957f, 0.27051964f, 0.10170898f, 0.16618574f, 
    0.00759783f, -0.19221628f, -0.06268369f, 0.04643321f, -0.17217992f, -0.13192080f, 0.03339032f, 0.16277367f, 
    0.05563694f, -0.22469518f, 0.07949879f, -0.25175482f, -0.07944111f, -0.08206174f, 0.02175158f, 0.16422920f, 
    0.04754516f, 0.10763042f, 0.20766614f, -0.27075785f, 0.11436918f, 0.11951151f, 0.00867183f, -0.02313129f, 
    0.00451202f, -0.04352977f, -0.04776856f, 0.15191399f, -0.04609094f, -0.02581264f, 0.17400907f, 0.18203481f, 
    0.40803400f, -0.15713416f, 0.11325913f, 0.06901248f, -0.01176532f, -0.20920694f, -0.15019633f, -0.01521573f, 
    0.07354434f, -0.15549450f, -0.01303390f, 0.04143776f, -0.33138984f, 0.02901733f, -0.27915689f, -0.29543450f, 
    0.08017638f, 0.18524374f, -0.22770911f, -0.09545804f, 0.23745921f, -0.14059667f, -0.03713356f, -0.12230011f, 
    -0.00799566f, 0.11668369f, -0.01230552f, -0.19409594f, 0.09959979f, 0.05842140f, 0.05645512f, -0.13862893f, 
    0.08802895f, -0.02858880f, 0.14230537f, 0.39920661f, -0.13182874f, -0.00234185f, -0.02318239f, -0.57038337f, 
    0.04557384f, -0.16551672f, -0.05541683f, 0.02123356f, 0.01491443f, -0.14946571f, 0.15877041f, 0.10695168f, 
    0.05646273f, 0.05507115f, -0.22625838f, -0.04878522f, -0.07098670f, 0.10528913f, -0.09418878f, 0.01394241f, 
    -0.06759758f, -0.22487038f, 0.02920973f, -0.33669928f, 0.21781771f, -0.60139906f, 0.32540798f, -0.20102072f, 
    0.11107246f, -0.02088542f, -0.06520940f, -0.23888658f, -0.00382129f, -0.00360435f, -0.04898141f, 0.03868984f, 
    -0.06331550f, 0.02341937f, -0.01649043f, -0.13307680f, -0.07995571f, -0.20236656f, -0.01645172f, 0.29754454f, 
    0.01065660f, 0.15985222f, 0.07893899f, 0.08781911f, -0.17865929f, 0.36575690f, 0.08197352f, 0.44447517f, 
    0.07585011f, -0.00083441f, 0.06765209f, 0.11006468f, 0.21671583f, 0.13597824f, -0.10297061f, -0.03383919f, 
    0.29844308f, -0.29863968f, -0.12523575f, -0.14234982f, -0.23459364f, -0.07708425f, 0.20620650f, 0.07548186f, 
    -0.00377217f, 0.11410189f, -0.21908841f, -0.37945059f, 0.41562426f, -0.95704019f, -0.19690584f, -0.07939494f, 
    -0.24113902f, 0.10862931f, 0.01254712f, -0.13309623f, 0.03714024f, 0.09731102f, 0.14305562f, 0.41452795f, 
    -0.05676942f, 0.13864022f, -0.37917790f, 0.47658721f, 0.05462406f, 0.23749712f, -0.01767830f, -0.00630714f, 
    0.09875952f, -0.10112294f, -0.01182879f, -0.09115491f, 0.01200443f, -0.27099639f, -0.19610065f, -0.09628779f, 
    -0.11458600f, 0.06633559f, 0.20633759f, 0.02354899f, 0.05412840f, -0.07055112f, -0.14649725f, 0.10574985f, 
    -0.12415914f, 0.15336156f, -0.47859043f, -0.54444158f, -0.15311356f, -0.04590233f, -0.17662086f, -0.34866259f, 
    -0.29666787f, 0.16300651f, -0.05034161f, -0.13713449f, 0.10790659f, 0.10370199f, 0.14017527f, 0.51308972f, 
    0.36788550f, -0.07208019f, -0.20454356f, 0.18969928f, 0.10047714f, 0.01244151f, -0.01371586f, 0.12714873f, 
    -0.00260480f, 0.24100116f, 0.12131684f, 0.05308684f, 0.07049056f, 0.02872908f, 0.05195207f, 0.16182651f, 
    -0.29301324f, 0.16635773f, -0.18322684f, 0.10801629f, -0.24704555f, 0.59273106f, 0.06817219f, -0.32436353f, 
    0.03332885f, 0.00473075f, 0.10098544f, -0.10921133f, -0.19759345f, 0.01112468f, -0.18306988f, -0.22596277f, 
    -0.44449586f, 0.19152601f, -0.06405508f, 0.19087875f, 0.00633683f, 0.16606116f, 0.26813975f, 0.02812975f, 
    -0.17161965f, -0.03899636f, -0.15955094f, -0.01146553f, -0.29864675f, -0.45233911f, 0.01895679f, -0.24339008f, 
    -0.04220325f, -0.11077130f, 0.25901291f, -0.00281408f, -0.08422220f, -0.01493667f, 0.05888062f, 0.19010691f, 
    -0.01292747f, 0.55758667f, 0.24768071f, -0.82437104f, -0.02953888f, 0.01226654f, -0.06964301f, -0.04072893f, 
    0.04938471f, -0.00452752f, -0.23461226f, -0.17469588f, -0.45459491f, 0.26655859f, 0.44989136f, -0.41047597f, 
    -0.41224924f, 0.01101216f, 0.15170063f, 0.15042202f, -0.03390347f, 0.02645349f, 0.10536051f, 0.20669223f, 
    -0.46733472f, -0.23930317f, -0.24406025f, 0.49623969f, -0.21945781f, -0.12015758f, -0.05272825f, -0.22734924f, 
    -0.11114814f, -0.07692496f, 0.11682089f, 0.16632062f, 0.46445242f, -0.02581101f, 0.41735941f, 0.45279950f, 
    0.34025025f, 0.19744135f, -0.02901548f, 0.11092851f, -0.04076027f, 0.02734900f, 0.02710873f, -0.13692386f, 
    -0.29762834f, 0.19003861f, -0.29900911f, -0.28003472f, 0.05851978f, 0.06245886f, -0.05996782f, -0.05626364f, 
    -0.16491064f, 0.03845200f, 0.00591420f, 0.10613646f, -0.27924797f, -0.33794200f, -0.07708250f, -0.07039411f, 
    -0.12835896f, 0.01631515f, 0.16970666f, -0.10422669f, -0.03416488f, 0.09236299f, 0.03111017f, -0.02160307f, 
    -0.10079014f, -0.40093139f, 0.39681455f, -0.11891214f, -0.01116879f, -0.02056625f, -0.08532885f, -0.16750316f, 
    -0.06121256f, 0.06943170f, -0.06732579f, -0.15923649f, 0.17465647f, 0.39653051f, 0.33093521f, 0.33719254f, 
    0.37793133f, 0.21493302f, 0.14286055f, -0.00555217f, -0.09023564f, 0.11109686f, 0.06041880f, -0.06259998f, 
    -0.09088065f, 0.22448263f, -0.43003571f, 0.22340910f, 0.07945784f, 0.11326412f, -0.02520022f, -0.20446889f, 
    -0.05249248f, 0.00844523f, 0.18852504f, -0.06386845f, -0.47030833f, 0.56833386f, 0.20699145f, -0.31228647f, 
    0.02828337f, -0.13109131f, 0.01532603f, -0.05676357f, 0.10168713f, -0.05091304f, -0.03671042f, -0.07279299f, 
    -0.05260848f, 0.45011804f, 0.36205700f, 0.42548940f, 0.23355931f, 0.03438082f, 0.09913514f, -0.10437485f, 
    -0.20335379f, -0.09150410f, -0.06244680f, -0.31631866f, -0.31877917f, 0.56276983f, 0.15300803f, 0.38176382f, 
    -0.27391082f, -0.07227124f, 0.03663254f, 0.14928353f, -0.13537984f, 0.00559914f, 0.08023802f, -0.08542399f, 
    0.37268481f, -0.42076266f, -0.06044988f, -0.44104406f, 0.08690440f, -0.13325146f, -0.12752934f, -0.00908101f, 
    -0.06195403f, -0.04077146f, -0.14232871f, -0.11290896f, -0.30475926f, -0.21755782f, -0.10580404f, -0.30166268f, 
    -0.02805741f, -0.19686456f, -0.25779039f, 0.01142225f, -0.12996590f, 0.06794161f, 0.12006626f, -0.28890657f, 
    0.41295019f, 0.50119507f, -0.16961376f, -0.06588927f, -0.04722453f, 0.07314679f, -0.14975089f, -0.09169852f, 
    -0.08379910f, -0.12595452f, 0.02897488f, -0.35027575f, 0.19039711f, 0.12252494f, 0.07888902f, 0.20094898f, 
    -0.14980747f, 0.28243288f, -0.07149958f, -0.08822542f, 0.09727626f, 0.01883197f, -0.19176720f, -0.24246459f, 
    -0.54288971f, 0.08992279f, -0.02714305f, -0.20011917f, -0.05542665f, -0.02545733f, 0.09661442f, -0.03624006f, 
    0.07291830f, -0.06101827f, 0.14945097f, 0.06402300f, -0.84926832f, 0.24662112f, -0.27319667f, -0.01211679f, 
    0.11909321f, 0.09632128f, -0.01206433f, -0.13676949f, -0.32035354f, -0.12253058f, 0.08484971f, -0.08013536f, 
    0.07479735f, 0.31549296f, -0.32684043f, -0.14756416f, -0.03911323f, 0.21945721f, 0.00022626f, -0.01140908f, 
    0.14396828f, 0.13118033f, 0.11604360f, 0.21404867f, -0.56552190f, -0.18405536f, -0.03248950f, -0.74635148f, 
    -0.17580800f, -0.60616064f, 0.27288032f, 0.14037342f, 0.02712806f, 0.07637199f, -0.31957585f, 0.35266757f, 
    0.15496668f, 0.35277903f, 0.08407734f, 0.36522311f, 0.27103242f, 0.14199354f, -0.07231309f, -0.10917668f, 
    0.03177863f, -0.24910560f, -0.05280997f, -0.14417091f, 0.18858871f, 0.03723836f, -0.34690425f, -0.11559936f, 
    0.22350615f, -0.12816045f, -0.31834975f, 0.00139833f, 0.22517022f, -0.22637407f, 0.01522338f, -0.05295117f, 
    -0.52658546f, -0.59180897f, 0.26893571f, -0.21827583f, -0.19188052f, 0.00607252f, 0.02153464f, -0.27331513f, 
    -0.17481858f, 0.14527617f, 0.02272280f, 0.22548042f, -0.03073596f, -0.17153002f, 0.40780157f, -0.16766785f, 
    -0.45314574f, -0.21346253f, -0.04926837f, -0.21296260f, -0.05752080f, -0.18115006f, -0.08568039f, -0.19259799f, 
    0.06288382f, 0.48716831f, -0.46600339f, -0.03593665f, -0.05501779f, 0.09228822f, -0.38745010f, 0.20264938f, 
    0.18715423f, 0.00695119f, 0.08698411f, -0.12778552f, 0.50347149f, -0.33317876f, 0.07836378f, 0.26633039f, 
    -0.05078503f, -0.08859897f, -0.07124359f, -0.03559439f, 0.15394579f, -0.07280989f, 0.05314675f, -0.06915282f, 
    -0.60580111f, 0.47201037f, 0.37090737f, -0.21972528f, -0.03188081f, -0.27540275f, 0.17737135f, -0.08946143f, 
    0.08155741f, -0.28145522f, 0.13882099f, 0.06175966f, 0.04411829f, -0.47710314f, -0.81806827f, -0.27850333f, 
    -0.01858452f, -0.22572848f, -0.03637252f, 0.02866844f, 0.15789096f, -0.11774366f, 0.22532542f, -0.05624773f, 
    0.19380420f, -0.08829398f, -0.44150469f, 0.29561076f, 0.00865161f, 0.01596056f, -0.05023695f, -0.06711200f, 
    0.10653685f, -0.00358033f, 0.16118416f, -0.03340545f, 0.05277477f, -0.25858867f, -0.26201636f, -0.17856763f, 
    0.36323500f, -0.10171534f, -0.11595528f, 0.11681741f, 0.21363053f, 0.14793630f, -0.10249674f, -0.02850272f, 
    0.04072229f, 0.22414868f, 0.14096671f, 0.04250700f, 0.07269353f, -0.14211977f, -0.04896918f, 0.10175777f, 
    0.08344819f, 0.06162075f, 0.39633191f, -0.01353238f, -0.26646322f, 0.42965382f, 0.29286921f, 0.22730204f, 
    -0.05603442f, 0.12335799f, -0.03127497f, 0.01442777f, 0.19474363f, -0.09129374f, -0.11133976f, -0.08744828f, 
    0.26150262f, -0.25873488f, -0.07136939f, 0.47667000f, 0.23988189f, 0.10588673f, 0.00329472f, -0.12229379f, 
    -0.15253831f, 0.01291203f, 0.50230038f, 0.10724290f, -0.00082736f, -0.08611207f, 0.24325208f, 0.14615425f, 
    0.33934727f, -0.09235267f, -0.07268589f, 0.01456297f, -0.27038500f, -0.22117670f, -0.02668451f, -0.16847773f, 
    0.01211207f, 0.57988584f, -0.67673939f, -0.24814475f, -0.00935137f, -0.12460600f, 0.13794376f, -0.07223648f, 
    0.03144227f, 0.14233580f, 0.13142173f, 0.11001454f, 0.57686371f, 0.25928283f, -0.52990234f, 0.18594912f, 
    0.00081234f, 0.00049001f, -0.18312538f, 0.02597396f, -0.27427572f, -0.01876291f, 0.05395408f, 0.23788124f, 
    -0.02803289f, 0.33005372f, -0.45859283f, -0.58179492f, 0.18996218f, -0.04814044f, 0.15406163f, -0.09718005f, 
    0.04999238f, 0.07419997f, -0.02136531f, 0.00458043f, 0.46339560f, -0.13485070f, 0.47209498f, -0.10696791f, 
    0.11111034f, -0.06695998f, 0.11698581f, -0.03919341f, 0.11607517f, 0.12331402f, 0.05569081f, 0.05684954f, 
    0.28105667f, 0.20163794f, -0.38035598f, 0.24756442f, -0.07416870f, -0.08966797f, -0.10551395f, 0.04576027f, 
    0.22623241f, -0.02013314f, 0.01572861f, -0.33111855f, -0.18788867f, -0.57888186f, -0.12940829f, -0.07666938f, 
    0.16392294f, -0.07267395f, 0.04366133f, -0.07772228f, -0.03376261f, -0.02054518f, -0.03773192f, 0.00053404f, 
    -0.46547222f, 0.37824127f, 0.59341413f, -0.12462538f, 0.11435135f, -0.15727931f, 0.05665931f, -0.10677672f, 
    -0.07926531f, -0.00957374f, 0.00965229f, 0.19329065f, -0.52262819f, 0.65661585f, -0.51521641f, -0.00697058f, 
    0.19568993f, -0.00066614f, -0.07895879f, 0.00983384f, -0.08186857f, -0.07216455f, 0.07271515f, 0.02423633f, 
    -0.50234675f, -0.42736667f, -0.22418842f, 0.12464990f, 0.06658813f, -0.03575356f, -0.28085825f, 0.08377656f, 
    -0.00713036f, -0.01705581f, -0.11480178f, -0.04218376f, -0.71528602f, -0.01114844f, 0.27338552f, -0.33502358f, 
    0.00047084f, 0.00975822f, 0.10140380f, 0.08523306f, -0.20623659f, -0.15517439f, -0.00274018f, -0.10776372f, 
    0.19052893f, -0.47816122f, -0.08148956f, -0.02573126f, 0.14478146f, 0.05128824f, 0.19019485f, -0.09726522f, 
    -0.17994998f, -0.24091049f, -0.00980437f, -0.10220329f, 0.27295098f, -0.36842930f, 0.31926212f, -0.31231064f, 
    -0.05241036f, -0.30774578f, 0.00400361f, 0.00608939f, 0.04234703f, -0.26443923f, 0.05187719f, -0.19926971f, 
    0.60993958f, 0.17977381f, 0.09485491f, 0.02621774f, -0.04966247f, 0.05638644f, 0.05116896f, 0.10967012f, 
    -0.11111972f, 0.05006025f, 0.00319632f, -0.21128856f, 0.08383387f, 0.31507400f, 0.01535620f, 0.04734645f, 
    0.07679735f, -0.05772867f, -0.03445272f, 0.24199148f, 0.07882135f, 0.07757674f, -0.07369691f, 0.01915937f, 
    -0.21013471f, -0.00332003f, 0.06587065f, -0.27028930f, 0.03928454f, -0.04381810f, 0.05706369f, 0.00358208f, 
    -0.10972612f, -0.08281948f, -0.21889593f, -0.11232879f, -0.89319259f, 0.68869150f, -0.02256886f, -0.38000527f, 
    -0.00615770f, -0.00096727f, 0.08081947f, -0.25346413f, -0.05722722f, 0.01658289f, 0.27229822f, 0.13588616f, 
    0.16741061f, 0.22624741f, 0.25576022f, -0.29145059f, 0.09365258f, 0.05441063f, 0.19645381f, 0.00483217f, 
    0.14226195f, 0.08756982f, -0.27021497f, 0.42290244f, 0.25911713f, -0.13671795f, -0.10765713f, 0.11858937f, 
    0.17459331f, -0.02878494f, 0.02846525f, 0.11569373f, -0.01069852f, 0.20988275f, 0.14285088f, 0.12462371f, 
    -0.66710210f, -0.26327249f, 0.04531913f, -0.57583189f, -0.05667652f, 0.19191505f, 0.01736281f, -0.08511279f, 
    -0.00477531f, -0.13691962f, 0.03314571f, 0.03883813f, -0.85367811f, 0.00457883f, 0.38221693f, 0.06032290f, 
    0.25414899f, -0.09973181f, -0.02107520f, -0.42943650f, -0.10123605f, -0.56208348f, -0.19404501f, 0.06337152f, 
    0.29402444f, 0.27253258f, 0.03481762f, 0.03023148f, 0.10250594f, 0.01476011f, 0.11572833f, 0.34006745f, 
    0.02661952f, -0.05033848f, 0.05817306f, 0.21573907f, 0.57490957f, 0.34728003f, -0.09916997f, -0.22876705f, 
    -0.47944161f, -0.37808001f, -0.06416468f, -0.13604537f, 0.24870127f, -0.04046888f, 0.00552890f, -0.12963526f, 
    -0.90909952f, -0.61039203f, 0.39798576f, 0.10913728f, -0.01676722f, 0.06331500f, -0.07120427f, 0.04983765f, 
    0.18172160f, -0.04405516f, -0.06553184f, -0.10926020f, -0.58015871f, 0.02883240f, -0.08402472f, -0.21652338f, 
    0.12653635f, -0.19996302f, -0.11923951f, -0.01799137f, -0.09401774f, -0.14187343f, 0.18731560f, 0.06101538f, 
    0.32306749f, 0.04249529f, -0.02358064f, -0.14269522f, 0.02081650f, 0.07184879f, 0.00662273f, -0.11871196f, 
    0.02034715f, -0.04183347f, 0.36413524f, 0.00123764f, -0.73956418f, -0.32701594f, 0.35168251f, -0.00761538f, 
    0.05084286f, 0.11948379f, -0.08742563f, -0.11685111f, -0.04028998f, 0.30814269f, -0.07546452f, 0.06817669f, 
    -0.83208406f, 0.09334767f, -0.14777094f, 0.00486463f, 0.08003093f, 0.04544905f, 0.17009789f, 0.12540339f, 
    0.10186229f, 0.06918925f, 0.04813555f, 0.02499535f, -0.07521677f, 0.39499649f, 0.34813213f, 0.04345657f, 
    0.29653740f, -0.02888067f, -0.08539494f, -0.09295397f, -0.02809490f, 0.30511799f, -0.02849643f, 0.25552058f, 
    -0.62761545f, -0.48327100f, 0.15673415f, -0.18125869f, -0.13008896f, 0.02470853f, 0.18053602f, -0.14630851f, 
    -0.07476553f, 0.26912135f, -0.09033233f, 0.11617601f, 0.22284716f, 0.14150375f, 0.09394119f, -0.07561712f, 
    -0.21858221f, 0.00531193f, 0.06203365f, 0.08867296f, 0.13438173f, -0.08423579f, -0.06377091f, -0.23853247f, 
    -1.30023611f, -0.73652542f, -0.14166020f, -0.41063157f, 0.07774225f, -0.14937426f, -0.16661146f, 0.04097248f, 
    0.04280053f, 0.20407850f, 0.20402691f, 0.13748372f, -0.54888189f, -0.77322274f, -0.23914656f, 0.07820991f, 
    0.05751899f, -0.08280142f, 0.04070115f, 0.08120901f, 0.21565922f, -0.01108392f, 0.06706902f, 0.11521532f, 
    0.54332227f, -0.49033707f, -0.11100019f, 0.65794796f, -0.11249112f, -0.14894846f, 0.19665428f, 0.10501003f, 
    -0.01464319f, 0.03187170f, -0.02910423f, -0.10845909f, -0.49996102f, -0.17779969f, 0.40629223f, -0.31220728f, 
    -0.13943610f, -0.04316198f, -0.26565596f, 0.01772298f, 0.20181537f, -0.17529655f, -0.03416642f, 0.01108633f, 
    0.41171095f, -0.63214451f, -0.53452927f, -0.17968051f, -0.17699511f, -0.13283718f, -0.01074472f, -0.21283434f, 
    -0.01301388f, 0.25761122f, -0.02787891f, -0.22755137f, 0.34614074f, 0.13759457f, 0.15171051f, -0.14459622f, 
    -0.02664116f, -0.20937140f, -0.23935273f, 0.20289874f, 0.27717197f, 0.12588181f, -0.00469648f, 0.07200894f, 
    0.04897482f, 0.32492778f, 0.23928452f, -0.01250473f, -0.03662390f, -0.10204109f, 0.14683957f, 0.01116029f, 
    -0.15474398f, 0.11635043f, 0.03714273f, -0.06458751f, -0.25163284f, -0.22089699f, -0.00918600f, 0.11871788f, 
    -0.14669888f, 0.33643028f, -0.13948159f, 0.10160208f, -0.35012242f, 0.03134712f, -0.06006096f, -0.04872764f, 
    -0.07507344f, 0.29380602f, -0.12028601f, 0.23821267f, 0.24425696f, 0.20912296f, -0.36995247f, -0.22955875f, 
    0.03604910f, -0.03376478f, 0.05459053f, 0.17366816f, -0.11182502f, -0.33789662f, 0.24579105f, -0.05444926f, 
    -0.11610874f, 0.02764531f, 0.09165280f, 0.12916449f, 0.11248081f, 0.09332968f, -0.06690980f, 0.25261793f, 
    0.55108589f, 0.13681726f, -0.32768518f, -0.07872500f, -0.42271063f, -0.20227458f, -0.10554176f, -0.30433992f, 
    -0.16451272f, -0.08091178f, -0.04547741f, -0.08682424f, 0.22927067f, 0.05633483f, -0.34381247f, -0.00169287f, 
    0.15412581f, 0.22925374f, -0.10460531f, -0.08265895f, 0.15900962f, -0.01876123f, -0.13101348f, -0.13672164f, 
    0.73393232f, 0.15854032f, -0.33447117f, -0.03490077f, 0.08258327f, -0.02300450f, -0.07087322f, 0.14354426f, 
    0.00395537f, 0.06271306f, -0.03271967f, -0.02101294f, 0.95789999f, 0.18047653f, -0.25456291f, -0.09492397f, 
    0.08814432f, 0.22040012f, -0.03638306f, 0.23112579f, 0.12998995f, -0.10413237f, -0.12532313f, 0.16421461f, 
    -0.32510448f, -0.25763148f, -0.20185453f, -0.35286695f, 0.34718212f, 0.13173564f, -0.00037221f, 0.28727955f, 
    -0.19223148f, -0.33739492f, 0.10353455f, 0.07704046f, -0.25907481f, -0.14970949f, -0.39716163f, -0.04867957f, 
    -0.05658681f, -0.29857582f, 0.05575933f, 0.01075393f, -0.06780840f, 0.20398042f, 0.01625187f, -0.20001653f, 
    -0.01879990f, -0.26422551f, -0.06810685f, -0.38131112f, -0.06234043f, -0.00730467f, -0.13456352f, -0.00092480f, 
    -0.24415687f, -0.05978873f, -0.26189718f, -0.05203389f, 0.18749273f, -0.00431195f, -0.06632850f, -0.24850254f, 
    0.17079452f, 0.04160785f, 0.08710729f, -0.12006937f, 0.18929076f, 0.18905468f, 0.04438812f, 0.10407719f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.20105135f, -0.04865048f, -0.01709299f, 0.10557710f, 0.03276680f, 0.06688903f, 0.03938195f, -0.17153300f, 
    -0.06808678f, -0.00933767f, 0.27621761f, 0.09400373f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 768);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE0_OUTPUT_SIZE);

    
    return buffer_a;
}
