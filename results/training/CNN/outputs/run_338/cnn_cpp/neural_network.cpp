#include "neural_network.h"

// --- Global Buffers ---
static float buffer1[MAX_BUFFER_SIZE];
static float buffer2[MAX_BUFFER_SIZE];

// Weights for convolutional layer conv0
const float conv0_weights[] PROGMEM = {
    0.85396016f, 0.82165283f, 0.51360613f, 0.42870009f, -0.02554628f, -0.42078108f, -0.30425793f, 0.25017795f, 
    -0.30636784f, 0.62242568f, 0.17077637f, 0.72168148f, -0.91476262f, -0.48121500f, -0.52207410f, 0.45743105f, 
    0.03077151f, -0.07965425f, 0.51067227f, 0.68126422f, -0.77557570f, -0.14260182f, -0.39983097f, 0.50378639f, 
    -0.19510743f, 0.11150387f, 0.31716576f, -0.42057163f, -0.56126606f, -0.57828122f, 0.36651039f, -0.59790069f, 
    0.13980195f, -0.40156367f, 0.13347241f, -0.09828407f, -0.69865423f, 0.87596601f, 0.14032960f, 0.32033205f, 
    -0.22518784f, -0.38575810f, -0.05762754f, -0.44061124f, -0.14137703f, -0.24201165f, 0.30823040f, -0.43960020f, 
    -0.47475165f, 0.46746731f, -0.76663834f, 0.49371314f, 0.34583715f, 0.30887711f, 0.00920779f, -0.47374126f, 
    -0.81076777f, -0.29119688f, -0.38771403f, -0.01865276f, 0.27597362f, 0.22727521f, 0.09884886f, 0.07616910f, 
    -0.21199279f, -0.34072661f, -0.71477342f, -0.14621413f, 0.61265361f, 0.48330045f, 0.06716884f, 0.16444783f, 
    0.70498365f, -0.11386839f, 0.31847093f, 0.50200880f, 0.51679313f, 0.52178138f, -0.54421580f, -0.00610424f, 
    0.10322256f, -0.57832801f, -0.83146107f, -0.51792872f, 0.28152969f, 0.62786555f, 0.45152044f, 0.05854563f, 
    -0.08793216f, -0.39181274f, -0.70262259f, -0.53602618f, 0.27430731f, -0.69627595f, -0.64267612f, -0.01260150f, 
    0.02661182f, 0.15053943f, -0.02298994f, -1.03091669f, 0.96104193f, -0.00409565f, -0.52599984f, 0.52491003f, 
    0.32196882f, 0.01463728f, 0.20303661f, 0.02933910f, 0.77911013f, -0.55533355f, -0.64381772f, 0.78751314f, 
    0.35241419f, -0.12688759f, -0.36167252f, -0.01991482f, -0.30566886f, 0.02983707f, 0.69101328f, -0.26667836f, 
    0.71723926f, 0.39638358f, -0.04563417f, -0.25795165f, -0.42082521f, -0.27612418f, -0.71634108f, -0.76658928f, 
    0.56725055f, 0.71167427f, 0.42188278f, 0.49782726f, -0.16550539f, 0.01700854f, 0.12681895f, 0.42915595f, 
    0.88124007f, 0.79830658f, -0.38350832f, 0.24160649f, 0.21313687f, -0.02701045f, 0.14580350f, 0.07729238f
};;

// Biases for convolutional layer conv0
const float conv0_biases[] PROGMEM = {
    -0.00785145f, 0.17669071f, -0.02478268f, -0.13658732f, -0.01973262f, 0.24415617f, 0.05581004f, -0.02624310f, 
    0.06156220f, 0.24645674f, 0.21243869f, 0.26836759f, 0.20093964f, 0.10317977f, 0.12819895f, 0.10855560f
};;

// Weights for dense layer dense0
const float dense0_weights[] PROGMEM = {
    0.04094575f, 0.03196629f, -0.02752958f, -0.00121488f, -0.05859764f, 0.03535480f, -0.05102736f, 0.00914595f, 
    -0.00438324f, -0.04964680f, 0.00759778f, -0.01193789f, -0.05045468f, 0.02473193f, -0.00976187f, -0.05165974f, 
    -0.02472477f, 0.02554398f, -0.04513613f, 0.01207140f, -0.02952800f, -0.02849028f, -0.00014792f, 0.03848106f, 
    -0.02074570f, 0.04202339f, 0.04627073f, -0.00495878f, -0.00792814f, -0.01218355f, 0.04475405f, -0.01572490f, 
    0.02687386f, 0.00123099f, -0.01645796f, -0.02051554f, -0.05527600f, 0.00924879f, 0.01943308f, 0.04963994f, 
    -0.01393017f, -0.02100747f, 0.00114342f, -0.02907248f, -0.04922764f, -0.01281491f, -0.00207735f, -0.03313737f, 
    -0.03080644f, -0.00034652f, -0.04157411f, -0.01796549f, -0.03562818f, -0.06292715f, -0.04578193f, -0.00953445f, 
    -0.02462161f, -0.04879456f, 0.01951050f, -0.02361085f, 0.03182576f, -0.02772549f, -0.06507241f, 0.00686990f, 
    -0.02651481f, -0.02862732f, -0.03681087f, -0.03820658f, -0.00419176f, -0.02093276f, 0.00083981f, 0.05100212f, 
    -0.01537394f, -0.04120852f, 0.02358366f, -0.06145482f, -0.04054806f, 0.01880655f, -0.01450656f, 0.03840819f, 
    -0.04687633f, -0.05045781f, 0.01459058f, 0.03255555f, -0.03016993f, -0.01093413f, -0.05849236f, -0.03908667f, 
    -0.02994073f, 0.03541542f, 0.01781305f, -0.02632436f, 0.01345865f, -0.05028638f, -0.04315630f, -0.03339320f, 
    -0.03855361f, -0.04836074f, -0.04203416f, 0.01749205f, 0.01860904f, -0.01939500f, 0.01291267f, -0.01909697f, 
    0.01271296f, 0.00351403f, -0.03951094f, 0.03563999f, 0.02662318f, 0.01592547f, -0.05211690f, -0.02161529f, 
    0.02497795f, -0.02374686f, -0.02320938f, -0.00743662f, -0.01992458f, -0.02422162f, 0.01687586f, -0.01290826f, 
    -0.05251092f, -0.03700937f, -0.03375184f, -0.00543037f, 0.01175890f, -0.01899521f, 0.01867030f, 0.01706761f, 
    -0.01444058f, 0.03466121f, -0.06113978f, -0.01058241f, -0.04192957f, -0.03651809f, 0.01622160f, -0.03273785f, 
    -0.03418678f, 0.01370281f, -0.00461041f, -0.00557420f, 0.04844079f, -0.02257399f, 0.04145181f, 0.00680001f, 
    0.00178296f, 0.02872137f, -0.00448316f, 0.00418970f, -0.03508295f, 0.02657269f, 0.00254347f, -0.00719994f, 
    0.03996743f, -0.06225822f, 0.03022944f, 0.04550771f, 0.01951049f, 0.02879431f, -0.00296406f, 0.00365074f, 
    0.04195443f, 0.00193098f, 0.03044467f, 0.00338105f, -0.06192591f, -0.00405479f, 0.04690051f, -0.05475269f, 
    0.03737461f, 0.00764541f, 0.03810620f, -0.02925179f, 0.00068044f, 0.02545689f, 0.00234979f, 0.00263455f, 
    -0.01592542f, 0.00971013f, -0.03140296f, 0.03516415f, 0.00748827f, 0.01243745f, -0.03142537f, -0.02323967f, 
    0.00409181f, -0.01917199f, -0.04441770f, -0.02544730f, -0.02885782f, -0.03538285f, 0.04742261f, -0.00517312f, 
    -0.05237184f, 0.01965576f, -0.01930567f, 0.03416701f, -0.03350924f, 0.03797519f, 0.01338272f, 0.03480230f, 
    0.01419203f, 0.05691555f, 0.00598615f, -0.01769114f, -0.03372817f, -0.02157053f, -0.00211149f, -0.06214496f, 
    -0.01045541f, 0.03579687f, 0.04028676f, -0.00561556f, 0.04011374f, -0.05406301f, 0.01903322f, -0.00119796f, 
    0.03206300f, -0.05105539f, 0.03429228f, -0.02136008f, -0.04538599f, -0.00977961f, -0.00507443f, -0.03497859f, 
    -0.02134737f, 0.00585199f, 0.02002946f, 0.03063778f, -0.02902344f, 0.02176501f, 0.03245382f, 0.05320926f, 
    0.03525131f, -0.03405553f, 0.03652780f, -0.03119379f, -0.02370551f, 0.02178786f, 0.04223338f, 0.03560562f, 
    -0.02130372f, -0.00537584f, -0.04465132f, 0.02401654f, 0.01615788f, -0.04216221f, -0.00999922f, 0.04671656f, 
    -0.03995630f, -0.02399498f, 0.00734103f, -0.05894753f, 0.02019200f, 0.03576992f, -0.03517613f, -0.02770205f, 
    -0.04252632f, 0.04605227f, 0.03219336f, -0.00613553f, -0.05917987f, -0.01855859f, -0.01217404f, -0.04032402f, 
    -0.02959243f, 0.02803292f, 0.00678568f, -0.02994917f, 0.01826587f, 0.01881981f, 0.03731048f, 0.02868127f, 
    0.05295348f, -0.00300781f, 0.00645982f, -0.04299240f, -0.01155418f, -0.03675212f, -0.04835354f, -0.02565786f, 
    -0.02035905f, -0.02915234f, -0.04546589f, -0.02544998f, 0.03628694f, 0.04908483f, -0.01270423f, 0.04100633f, 
    0.00127100f, -0.02533911f, 0.01037870f, 0.01492429f, 0.00417742f, -0.01699930f, -0.01222430f, 0.03469317f, 
    0.00689959f, 0.00430127f, -0.05136393f, -0.01915029f, -0.01025198f, -0.03880588f, -0.04491451f, 0.00524068f, 
    0.03163236f, 0.00902754f, 0.00758631f, 0.03153899f, -0.05810602f, -0.00586730f, -0.04525629f, 0.01701145f, 
    -0.01980660f, 0.04209972f, -0.01501240f, 0.01993426f, -0.01855550f, -0.02743075f, 0.00640535f, -0.02005690f, 
    -0.00579853f, -0.01650959f, 0.04459437f, -0.03843194f, 0.04309979f, -0.04215961f, 0.03187207f, 0.01671368f, 
    0.01761197f, 0.01498249f, -0.00334873f, -0.05762009f, 0.04938264f, -0.02709906f, 0.03350821f, -0.03849975f, 
    0.00260730f, -0.01494522f, 0.00344641f, -0.02703762f, -0.00123639f, -0.01939701f, 0.04931498f, -0.03338452f, 
    0.00566377f, -0.05030691f, 0.01262222f, -0.00709344f, 0.01612270f, 0.03311955f, 0.02415714f, -0.02767075f, 
    -0.02704103f, 0.03011882f, 0.01529835f, -0.01931883f, -0.05980323f, 0.02092528f, 0.01463297f, -0.02284887f, 
    0.00854721f, 0.03621494f, 0.00832333f, 0.01961219f, -0.03402190f, 0.04944377f, -0.01545661f, 0.03277914f, 
    0.00544504f, -0.05881840f, -0.05651051f, 0.02935283f, 0.03552764f, 0.04140338f, -0.04818550f, -0.02683610f, 
    0.04516474f, -0.04655883f, 0.02890845f, 0.01251382f, 0.00050693f, 0.02287796f, 0.00405718f, -0.04768729f, 
    -0.03894109f, -0.04915500f, 0.00043646f, -0.00117947f, -0.03401018f, -0.00348984f, 0.01891273f, 0.00400763f, 
    -0.01902373f, -0.01262875f, -0.06098589f, -0.04431514f, 0.00295843f, -0.02759277f, 0.01461636f, -0.04714222f, 
    0.02916293f, -0.03991465f, 0.02837953f, -0.05454333f, -0.04473840f, 0.00322890f, -0.04008783f, 0.00527176f, 
    0.00303548f, 0.01202491f, 0.00707341f, -0.03096504f, -0.06187222f, -0.03310046f, -0.02204703f, -0.04999840f, 
    0.03831674f, -0.04284990f, 0.01499630f, 0.02029250f, -0.04488990f, -0.01636123f, 0.01294320f, -0.02611932f, 
    0.00448194f, -0.03143851f, -0.05538977f, 0.00700882f, -0.03407731f, -0.00924909f, -0.03979858f, 0.02580293f, 
    -0.00829345f, 0.01591964f, -0.03985125f, -0.05241909f, 0.00024006f, -0.01584525f, 0.00855668f, 0.00137403f, 
    -0.04662650f, 0.01533130f, -0.04173546f, 0.00084480f, 0.03310319f, -0.03899362f, -0.01696623f, -0.05009601f, 
    -0.03427741f, -0.04955531f, -0.01922494f, -0.01135421f, -0.05523406f, 0.03552866f, 0.02765530f, 0.01448170f, 
    -0.00185607f, -0.01905189f, 0.00025341f, -0.04873840f, -0.00375922f, 0.04839940f, 0.04497399f, -0.04376736f, 
    0.01070288f, -0.01381483f, -0.02227777f, -0.00795704f, 0.01229366f, 0.04751905f, -0.01834459f, 0.03283478f, 
    -0.00291304f, 0.04637723f, 0.04303608f, 0.01497549f, -0.00198214f, -0.06162423f, -0.00318212f, -0.02681902f, 
    -0.00582185f, -0.01645393f, 0.04844332f, 0.03896775f, -0.04111536f, -0.06121084f, 0.04559909f, 0.03423771f, 
    -0.06148339f, 0.02710007f, 0.00805244f, -0.01565009f, 0.02943980f, 0.02303562f, -0.00122090f, -0.03442604f, 
    0.04623932f, -0.01511726f, -0.05610939f, -0.06179116f, 0.03363938f, -0.01904259f, 0.02239443f, 0.00711230f, 
    -0.01944373f, -0.01769539f, -0.01155006f, -0.04828673f, 0.04144803f, -0.01981802f, -0.01469406f, 0.04852103f, 
    0.02101846f, -0.05904729f, -0.00905036f, -0.01017911f, -0.02968472f, -0.00669067f, 0.04400203f, 0.03781652f, 
    0.00449247f, -0.05323739f, -0.05052798f, -0.02975509f, 0.02413549f, 0.00247782f, -0.00071745f, 0.04657928f, 
    -0.01602470f, 0.02559058f, -0.04124740f, -0.05825181f, 0.02303394f, -0.01705173f, -0.03682547f, 0.04759051f, 
    0.04670263f, -0.05125133f, -0.02288031f, -0.05742209f, -0.06072885f, -0.03760467f, 0.01940161f, -0.02092875f, 
    -0.05027232f, -0.02258210f, 0.01019228f, -0.00588791f, -0.01444878f, -0.04320980f, -0.03911029f, -0.03459257f, 
    0.04523947f, 0.04682733f, -0.05600158f, -0.05712166f, -0.05930202f, -0.05464244f, -0.02771834f, 0.03177173f, 
    -0.06051244f, -0.05317483f, 0.00078596f, -0.00619035f, 0.00491892f, -0.04655071f, 0.04726940f, 0.02062587f, 
    0.01009633f, -0.03737731f, -0.02089453f, 0.01563931f, -0.03570497f, -0.03520169f, -0.02839536f, -0.04081994f, 
    0.04466078f, 0.04687005f, 0.00639056f, -0.03963036f, -0.05392357f, -0.01029810f, -0.05927418f, -0.02962336f, 
    0.02983944f, -0.01607764f, 0.03982933f, 0.02731151f, -0.01702667f, 0.04939125f, 0.03375883f, 0.01704997f, 
    -0.04809235f, 0.04749125f, -0.01486122f, -0.03974554f, 0.01941709f, 0.02827798f, -0.04294308f, 0.04671238f, 
    0.01169474f, -0.05383477f, -0.06000235f, -0.01841177f, 0.03233100f, -0.01608554f, -0.03738192f, 0.00797631f, 
    -0.05433741f, 0.00706372f, -0.01470739f, 0.04222817f, -0.05130809f, -0.00969649f, -0.05666319f, 0.04335618f, 
    -0.02616324f, -0.04535329f, -0.00291502f, 0.02883903f, -0.01148859f, 0.03028669f, -0.04242844f, 0.00461996f, 
    0.04633671f, -0.04372178f, -0.02261911f, -0.04117775f, -0.04800913f, -0.04537942f, 0.02544956f, -0.03283593f, 
    0.02570624f, 0.02754138f, -0.00651055f, -0.02799957f, -0.04937961f, -0.03384738f, 0.02154198f, 0.02970003f, 
    0.11578277f, 0.25192425f, -0.02465331f, 0.08348091f, -0.13554436f, -0.11255623f, 0.06573701f, -0.05679758f, 
    0.17286585f, 0.00829959f, 0.10566419f, -0.03667975f, -0.01009365f, -0.01109728f, 0.00039771f, 0.01366877f, 
    0.08320111f, -0.03658512f, -0.00948792f, -0.01540732f, -0.04599059f, -0.09255162f, 0.03254886f, 0.16437617f, 
    0.01140435f, -0.08408602f, 0.07437035f, 0.01024407f, -0.09343265f, 0.15641946f, 0.00353145f, 0.01354839f, 
    -0.04582563f, -0.07060189f, -0.05029389f, 0.04235020f, -0.05771281f, 0.01137557f, 0.11423931f, -0.00177861f, 
    0.25344965f, -0.19915348f, 0.01215213f, 0.08494791f, -0.15165301f, -0.07647855f, -0.03672469f, 0.04646803f, 
    0.03072105f, -0.07502017f, 0.03439587f, 0.07423186f, 0.00800791f, 0.00631355f, 0.01657951f, -0.08036757f, 
    -0.01699490f, 0.00774713f, -0.07703307f, 0.01322266f, 0.07288875f, -0.06818135f, -0.20073560f, 0.03045020f, 
    0.00444590f, 0.00131308f, -0.02108044f, -0.03656803f, 0.13088515f, -0.02190741f, 0.05534595f, -0.06652533f, 
    0.06842684f, 0.08762204f, 0.09831122f, 0.15369670f, -0.03821505f, 0.10431550f, 0.07348875f, 0.15996003f, 
    0.33443502f, 0.12403455f, 0.00631430f, -0.17416215f, 0.10793050f, -0.06557874f, 0.06750888f, -0.02028331f, 
    0.07074367f, 0.04672535f, 0.11120551f, -0.08742595f, -0.04175854f, 0.15631357f, 0.10478429f, 0.07890372f, 
    0.08837294f, 0.05282615f, 0.14799988f, 0.03423942f, -0.20357163f, -0.01736307f, 0.05285995f, 0.10937385f, 
    0.08381363f, 0.04073998f, 0.05947430f, -0.00537995f, -0.02854689f, 0.04115795f, -0.04632864f, 0.07165653f, 
    -0.15776168f, -0.00196562f, -0.02885751f, -0.09693529f, -0.02634350f, -0.03125618f, 0.03910376f, -0.00228020f, 
    0.03457953f, 0.17041753f, -0.17654797f, 0.07381742f, 0.12033173f, 0.02752689f, -0.00544153f, 0.00184852f, 
    0.02262405f, -0.02602250f, -0.05968650f, -0.00866243f, 0.06558782f, -0.02426825f, 0.00426155f, -0.13828418f, 
    0.04421181f, -0.00303398f, 0.04351876f, -0.03331893f, -0.21281202f, -0.01843153f, 0.00716040f, 0.08708488f, 
    0.02360916f, -0.02109756f, -0.10038369f, 0.01189671f, -0.07721821f, 0.05914688f, -0.00797199f, -0.02019886f, 
    0.03478952f, -0.08468129f, 0.09467582f, -0.01404956f, -0.06293558f, -0.07120201f, -0.00604678f, -0.13905786f, 
    -0.10250454f, -0.11607383f, -0.28082952f, 0.05368770f, -0.11592355f, 0.10788819f, 0.07891355f, -0.07162865f, 
    0.07374979f, 0.04522424f, -0.04402203f, 0.05362264f, 0.01327491f, 0.05813576f, -0.06115028f, 0.03483650f, 
    0.02287658f, -0.09248295f, -0.06781027f, -0.06017572f, -0.25105140f, -0.14762869f, -0.15810081f, -0.04639642f, 
    -0.02912179f, 0.11023884f, 0.02246678f, 0.07100984f, 0.03199128f, 0.03920814f, -0.00855531f, -0.00385714f, 
    0.14677164f, -0.00774264f, 0.02421280f, 0.01336509f, 0.05948551f, -0.00318021f, 0.07718043f, 0.03223724f, 
    -0.21450667f, 0.09744290f, 0.05238266f, 0.08785161f, 0.22369514f, -0.01418567f, -0.04025858f, 0.05465681f, 
    -0.01311129f, 0.08344917f, 0.07515566f, -0.09119763f, -0.01964870f, -0.03673687f, -0.01609079f, 0.09102963f, 
    -0.02038124f, 0.09203963f, 0.16154242f, 0.04326601f, 0.05515739f, 0.02899471f, 0.18840487f, -0.05735625f, 
    0.10544480f, -0.06906568f, -0.10481331f, 0.12830655f, 0.04584630f, -0.03677064f, -0.01726211f, -0.00088369f, 
    0.06910671f, -0.03626653f, -0.01719864f, 0.08888930f, 0.00593386f, -0.06690680f, 0.12081683f, -0.02330666f, 
    -0.04705008f, 0.16696754f, -0.11455562f, 0.16581030f, -0.13765308f, 0.08557504f, 0.01132683f, 0.10311306f, 
    0.00753642f, -0.02136648f, -0.03618294f, 0.06361339f, 0.04404178f, 0.07873702f, 0.03627143f, 0.06888773f, 
    -0.00731992f, 0.14228210f, -0.11657001f, 0.08897968f, 0.00509894f, -0.07239723f, -0.17770059f, 0.09683933f, 
    0.03579539f, -0.02405729f, 0.03053890f, 0.00613175f, 0.10277002f, 0.05460032f, 0.03850210f, -0.01351816f, 
    0.06681552f, 0.04223635f, 0.02975518f, -0.00282271f, 0.12246210f, 0.05456193f, -0.04052468f, 0.08490535f, 
    -0.06050359f, -0.04784984f, -0.03185741f, -0.13904606f, 0.01956089f, 0.18862885f, -0.00431472f, 0.01665553f, 
    0.01982438f, 0.05601063f, 0.00614470f, -0.03382403f, -0.08925577f, 0.13621764f, 0.02639704f, 0.08281027f, 
    0.00895599f, -0.03362850f, -0.04550355f, -0.05296773f, 0.05040381f, -0.16566025f, 0.14648490f, 0.05362749f, 
    0.15294574f, 0.05252836f, 0.01145635f, 0.07275847f, 0.02925795f, 0.07046711f, 0.08192291f, 0.00793415f, 
    0.09020697f, -0.11014058f, -0.03578655f, -0.02268982f, -0.03914784f, -0.13993436f, 0.04515526f, 0.01377185f, 
    -0.00832540f, 0.04239867f, 0.00136281f, -0.02089970f, 0.00676740f, -0.06393366f, 0.04484189f, 0.02538699f, 
    0.01147630f, -0.01655173f, 0.01737472f, 0.02039405f, 0.00270521f, 0.04133216f, 0.00391039f, 0.00554557f, 
    0.04151166f, 0.00282187f, -0.02571116f, 0.01366380f, -0.01206609f, 0.04776159f, -0.01520143f, 0.01999832f, 
    0.01597684f, -0.00253479f, -0.00420031f, -0.04059827f, -0.05799197f, 0.03774055f, 0.00670955f, -0.00710751f, 
    -0.04889919f, 0.03870482f, -0.03131096f, 0.03241544f, -0.03565148f, 0.00575942f, 0.01470906f, -0.04279286f, 
    -0.01240097f, 0.02522554f, 0.00566915f, -0.04220001f, -0.03097329f, 0.00821007f, -0.04760524f, -0.04999578f, 
    0.02271409f, -0.06035490f, -0.01355329f, -0.01119602f, 0.03862502f, 0.04886566f, -0.05088379f, 0.02854300f, 
    -0.03241737f, -0.05836707f, -0.00049395f, -0.04358846f, -0.03895682f, -0.01762894f, 0.00230542f, -0.04763789f, 
    -0.05216058f, 0.02998872f, 0.02742061f, -0.03881473f, -0.03243864f, 0.03239258f, -0.00971960f, -0.06539039f, 
    0.01485993f, -0.01369250f, -0.06416528f, 0.05171257f, -0.04483324f, 0.00473435f, -0.05270633f, 0.03810056f, 
    0.04006797f, 0.02042359f, -0.03570875f, -0.04421640f, -0.06191716f, -0.05627005f, 0.02204992f, -0.00752337f, 
    0.01006543f, 0.03789877f, -0.04246638f, 0.04131867f, 0.04172271f, 0.02709983f, -0.00321985f, 0.04409783f, 
    -0.03932939f, 0.00346754f, 0.00312516f, -0.01989138f, -0.03968122f, 0.03167972f, 0.04690602f, -0.02340545f, 
    -0.06042901f, -0.02595442f, -0.04730685f, -0.02694995f, 0.04584151f, 0.03976274f, -0.04336353f, -0.02447239f, 
    -0.04949052f, 0.05409975f, -0.02757784f, -0.02751303f, 0.02660166f, 0.00022023f, 0.03653233f, -0.05510111f, 
    -0.03395580f, -0.00056841f, -0.05777616f, -0.02595657f, 0.04347260f, -0.03719850f, 0.00813107f, 0.04381516f, 
    -0.00030426f, -0.05999634f, -0.04209696f, 0.03695535f, -0.03070549f, -0.02372829f, -0.04516921f, -0.02786956f, 
    -0.04693842f, 0.03303031f, -0.03652813f, -0.05836695f, 0.04380750f, -0.05237561f, -0.05490771f, -0.05146705f, 
    -0.04171432f, 0.01344121f, -0.00319644f, 0.04816394f, 0.01432788f, -0.04926486f, -0.00476173f, 0.01339892f, 
    -0.04836093f, -0.03985989f, -0.02397483f, -0.02063274f, 0.03974010f, -0.01261226f, -0.01721143f, 0.01431460f, 
    0.01285995f, 0.03399047f, -0.02774928f, 0.04752406f, -0.05476140f, -0.04565482f, -0.00000962f, 0.01794179f, 
    0.03758572f, 0.00885536f, 0.04016965f, -0.04078570f, -0.01319254f, -0.02586231f, -0.03925122f, 0.04045723f, 
    -0.02544382f, -0.04262849f, 0.01693694f, -0.06237845f, -0.05732163f, 0.04343363f, -0.05783392f, -0.06091717f, 
    -0.02158025f, 0.04509624f, 0.04609781f, 0.03539639f, 0.01250502f, -0.04526032f, -0.03346908f, -0.04776228f, 
    0.04238001f, -0.02484996f, -0.05309126f, -0.06241727f, -0.01133074f, 0.00723367f, 0.02263775f, -0.06253075f, 
    -0.01830901f, -0.04286049f, 0.01387327f, 0.02894801f, -0.03512073f, 0.01013959f, -0.05790552f, 0.00852371f, 
    -0.02354963f, 0.03858848f, 0.04342706f, -0.03275838f, 0.04285250f, 0.03273631f, -0.03977916f, -0.03204543f, 
    -0.03437734f, -0.02027401f, 0.02857720f, -0.02945827f, -0.03832734f, -0.02915751f, 0.02667692f, -0.01032560f, 
    0.04715746f, 0.03172522f, 0.01787435f, 0.04704329f, -0.01964102f, 0.02585571f, 0.00445538f, -0.00487301f, 
    0.02205290f, -0.02676244f, 0.04744226f, -0.02367742f, 0.00509981f, 0.01590332f, -0.01391500f, 0.03973482f, 
    0.00407512f, 0.00485880f, 0.04274637f, 0.03994338f, 0.01103705f, -0.05207199f, -0.05593589f, 0.03443585f, 
    -0.05803297f, 0.03563255f, 0.00613646f, 0.03981150f, 0.04167153f, 0.04626863f, 0.00346794f, -0.03701689f, 
    -0.00439252f, -0.01380568f, -0.05156840f, -0.04244604f, 0.03809946f, -0.04700675f, -0.06168937f, -0.00692619f, 
    -0.02650837f, -0.05296556f, 0.04555625f, -0.05863507f, 0.00115038f, -0.06104983f, -0.04257815f, 0.04966929f, 
    -0.05501073f, -0.04707142f, 0.03780697f, 0.03765820f, 0.01260859f, -0.00455403f, 0.00535002f, -0.04590399f, 
    0.00830422f, -0.03602317f, 0.04725928f, -0.02972679f, 0.01933292f, -0.00248529f, 0.04267142f, 0.03304963f, 
    -0.02739563f, -0.00122181f, 0.04308083f, -0.06423214f, -0.06189783f, 0.00507985f, -0.05219591f, -0.05531815f, 
    0.00749398f, -0.03384652f, -0.01346262f, 0.02933291f, 0.03567979f, 0.00479944f, 0.02084925f, 0.02459567f, 
    0.03279436f, -0.00502288f, -0.05971085f, -0.02540587f, -0.03912244f, 0.00373666f, -0.00318152f, -0.03518208f, 
    -0.05081001f, 0.04824392f, 0.02779707f, 0.01841715f, 0.00622616f, 0.04023083f, 0.05219418f, 0.03729006f, 
    0.30594137f, -0.03635060f, 0.04685654f, -0.03920412f, 0.35764104f, -0.08567817f, -0.09739459f, 0.01561761f, 
    0.06092968f, -0.06185465f, -0.05781513f, 0.03568390f, -0.05444483f, 0.05598870f, 0.03879554f, 0.00312140f, 
    0.06387080f, -0.00171794f, -0.06735656f, -0.05705841f, 0.07890853f, 0.01595581f, -0.16593206f, 0.19691949f, 
    0.13355424f, 0.00032122f, 0.04419084f, -0.00572437f, 0.00143299f, -0.04824778f, -0.03892467f, -0.04108127f, 
    -0.11766151f, 0.00106496f, -0.03476199f, 0.08300331f, -0.03716356f, 0.01530332f, 0.02789912f, 0.06412485f, 
    0.12142420f, 0.04350804f, 0.04087008f, -0.14911492f, 0.08507004f, -0.02810488f, -0.04887057f, -0.03578532f, 
    0.06869682f, 0.08570383f, -0.00168885f, -0.05258089f, -0.10947084f, -0.05566213f, -0.01557369f, 0.01582376f, 
    -0.04881467f, -0.00809917f, 0.05110029f, -0.03756802f, 0.19600369f, -0.17654297f, -0.00603999f, 0.05463722f, 
    -0.09819939f, 0.01032565f, 0.03534360f, -0.02908575f, 0.11126921f, 0.04031119f, 0.10177295f, -0.03096626f, 
    0.02495240f, -0.01790496f, -0.11515218f, 0.02969672f, 0.05155922f, 0.00206874f, -0.13112406f, -0.02843885f, 
    0.26416704f, 0.24789518f, 0.01762095f, 0.02189682f, -0.00357242f, -0.01622397f, 0.00671459f, 0.04075217f, 
    -0.05648052f, -0.04763653f, -0.07039189f, 0.08641824f, -0.02476476f, 0.09045247f, -0.11771707f, 0.03360542f, 
    -0.13511662f, 0.07403690f, 0.01349739f, -0.01375357f, 0.02175339f, 0.03748585f, -0.14858289f, -0.05830972f, 
    -0.16037594f, 0.04492540f, 0.01662516f, -0.02797494f, -0.00625306f, 0.08388806f, 0.09657155f, -0.01126252f, 
    0.05904964f, 0.00696081f, 0.18068823f, -0.06177662f, -0.09820996f, -0.00360297f, -0.02220600f, -0.06240654f, 
    -0.02850781f, -0.19452961f, -0.10156381f, 0.01613264f, -0.21175465f, -0.01430873f, -0.08321719f, 0.13442613f, 
    0.03167740f, 0.08683287f, -0.03103194f, 0.06119271f, -0.02711619f, -0.08939213f, 0.01381424f, 0.08918507f, 
    -0.05084961f, 0.06859075f, 0.09557000f, 0.04061162f, -0.04205566f, -0.10607228f, 0.00966131f, 0.09834366f, 
    -0.09742264f, -0.05165223f, 0.03824773f, -0.04013127f, -0.04098425f, 0.00290639f, 0.03362652f, 0.08616462f, 
    -0.03272352f, -0.00326260f, 0.06514394f, -0.03810035f, -0.05260061f, 0.02965830f, 0.04430995f, 0.06037333f, 
    0.27425921f, 0.19954310f, 0.16683140f, -0.20958029f, -0.07023250f, 0.01433131f, -0.01022376f, -0.03321546f, 
    -0.00842750f, 0.09561127f, -0.08747517f, -0.01714965f, 0.05119198f, -0.07917470f, 0.01153729f, -0.01387275f, 
    0.04119835f, 0.02940472f, 0.00685777f, 0.01732380f, -0.12326398f, 0.12712562f, 0.09535610f, -0.16364628f, 
    -0.22637191f, 0.01203279f, 0.10756598f, 0.12272370f, -0.01918390f, 0.01051197f, 0.09057558f, 0.00382169f, 
    0.02531756f, -0.02010779f, -0.01690450f, 0.07878648f, 0.08019603f, 0.02628074f, 0.09490515f, -0.05155857f, 
    -0.17538370f, -0.05249267f, -0.13125716f, 0.18771441f, -0.18393312f, 0.03796279f, -0.02044467f, -0.04692489f, 
    0.07790341f, -0.06586288f, 0.00249792f, 0.01363364f, -0.10529478f, -0.03628989f, -0.05019006f, -0.03172043f, 
    0.02701716f, -0.08415384f, 0.05863685f, 0.01182035f, -0.18705387f, 0.29127818f, -0.04971755f, -0.09968822f, 
    0.02552716f, 0.08284134f, -0.03229281f, 0.08908339f, 0.04594168f, -0.02655195f, -0.02617625f, -0.02026839f, 
    -0.08054925f, -0.02299142f, 0.05645741f, -0.01758262f, -0.06849030f, -0.00716013f, 0.12787680f, -0.02404884f, 
    0.27041739f, -0.08015829f, 0.15931374f, -0.14965147f, -0.00451222f, 0.02394734f, -0.10396494f, 0.03152901f, 
    -0.06177857f, -0.09801108f, -0.03715669f, -0.02090430f, 0.04512436f, 0.05152778f, -0.03254921f, 0.07854636f, 
    0.06450804f, 0.00839741f, -0.07070185f, 0.02070821f, 0.26912168f, 0.10425761f, 0.13485529f, -0.03448309f, 
    0.12814841f, -0.11416450f, -0.12703338f, 0.09712303f, 0.09845835f, -0.04018307f, 0.04565960f, 0.04026473f, 
    0.08180197f, 0.07066882f, 0.03257905f, 0.00552906f, -0.02916156f, -0.00524222f, 0.00467839f, -0.04005924f, 
    -0.22820261f, 0.11097499f, 0.36186969f, -0.00769307f, -0.22296096f, -0.12798427f, 0.07949745f, -0.01300501f, 
    0.15662917f, -0.08948826f, -0.06394349f, 0.02559003f, -0.08414370f, -0.00398922f, 0.02960477f, -0.07204444f, 
    0.03084091f, -0.04527904f, 0.05640058f, 0.00661465f, -0.01242380f, 0.41433698f, -0.25269502f, 0.09899326f, 
    0.32626209f, -0.05379039f, -0.05449113f, 0.02484752f, -0.01218465f, -0.08369189f, -0.07909190f, 0.04630473f, 
    -0.00072240f, 0.02228366f, 0.06256781f, 0.02821691f, 0.01906462f, 0.07301071f, -0.06415971f, 0.05766902f, 
    0.39411783f, -0.25642669f, -0.21201587f, 0.04913541f, 0.03310205f, 0.08300820f, -0.08082195f, -0.02822853f, 
    -0.10247397f, -0.13575102f, 0.04819669f, 0.11653221f, 0.02442895f, 0.03025992f, 0.03065324f, -0.05526543f, 
    -0.06744751f, -0.01607981f, -0.02623114f, -0.08226371f, 0.33444473f, -0.17833421f, -0.12742302f, 0.16962516f, 
    0.36367464f, -0.07359130f, -0.02685654f, 0.08336808f, 0.04161255f, -0.06018829f, 0.03244499f, 0.02054910f, 
    0.02137435f, -0.01371237f, 0.09394775f, -0.10732304f, -0.05891317f, 0.01949719f, -0.11109537f, 0.09429926f, 
    0.21154363f, 0.25124487f, -0.01175791f, 0.07854664f, -0.12649670f, 0.09802574f, 0.08143741f, 0.09553932f, 
    -0.02313397f, 0.04758830f, 0.02253545f, 0.03176517f, -0.06522287f, -0.01756816f, -0.09480514f, -0.02720650f, 
    0.01036945f, 0.00433591f, 0.00028910f, 0.07622942f, 0.23952305f, 0.23246069f, -0.07186683f, 0.28592327f, 
    0.09004118f, 0.16788241f, 0.24194510f, 0.09759180f, 0.14493342f, 0.09069424f, 0.04536304f, 0.11481368f, 
    0.05324204f, 0.02054085f, -0.08930355f, 0.06395745f, -0.00288094f, 0.11626223f, -0.06034636f, -0.03953951f, 
    0.03096186f, -0.03701914f, 0.06726766f, 0.30505347f, -0.26511005f, 0.05664058f, 0.09434255f, -0.08801242f, 
    -0.01928588f, -0.15917785f, 0.05268311f, -0.03821027f, -0.04834644f, 0.02399973f, 0.03673159f, -0.01082476f, 
    0.08788328f, -0.02665580f, -0.02035666f, 0.01243052f, -0.01940514f, 0.06477170f, 0.16676839f, -0.13545381f, 
    -0.15592100f, -0.03302579f, -0.01836945f, -0.04238433f, -0.01321040f, 0.04794619f, 0.01083940f, 0.02319286f, 
    -0.00834217f, 0.08259212f, -0.05381177f, -0.01454275f, -0.08897234f, -0.09840056f, 0.04448305f, 0.02534357f, 
    0.02413085f, 0.23051271f, -0.04462760f, 0.02170328f, 0.13291253f, -0.01760983f, 0.03051685f, -0.07158788f, 
    -0.07181879f, 0.02108922f, 0.04678886f, 0.18997906f, 0.07208722f, -0.12139619f, 0.02558412f, 0.13354185f, 
    0.04355603f, 0.04889570f, 0.01445585f, -0.05329130f, 0.11963687f, 0.21652816f, -0.00821647f, -0.06049429f, 
    0.02180580f, -0.03127446f, -0.11507180f, 0.02983845f, -0.12520337f, -0.00384420f, 0.02172161f, -0.11547810f, 
    -0.06090524f, -0.05044079f, 0.00248573f, -0.03017692f, 0.08147412f, -0.00093321f, -0.06224205f, -0.00055356f, 
    -0.08656818f, 0.00447996f, 0.03849160f, -0.27250683f, -0.43466526f, 0.07060748f, -0.05076408f, 0.11929913f, 
    0.00340675f, 0.13806623f, 0.06013814f, 0.04884943f, -0.13435051f, 0.05528461f, 0.08197012f, 0.06561670f, 
    -0.06690137f, 0.08286805f, -0.04927409f, 0.00390859f, -0.20235407f, 0.19829103f, 0.02596655f, -0.09124089f, 
    0.00272549f, 0.11247685f, 0.06486680f, 0.07466750f, 0.02304239f, 0.02980565f, -0.04919017f, -0.01076609f, 
    0.05503998f, 0.01197167f, -0.00895017f, 0.01024616f, -0.03397094f, 0.00872726f, 0.04122623f, -0.05944099f, 
    -0.02733236f, -0.00167417f, 0.22620454f, 0.12303264f, 0.25387636f, 0.01119131f, 0.03698845f, 0.03996056f, 
    0.04752932f, 0.10294883f, 0.06927777f, -0.07786907f, -0.02147371f, 0.01695512f, 0.15414353f, 0.00728627f, 
    0.07132496f, -0.00893880f, 0.10966659f, -0.05816606f, -0.12203695f, 0.06170490f, 0.07898564f, 0.08590309f, 
    -0.18038635f, -0.00240828f, 0.04034747f, -0.04924202f, 0.07982744f, -0.03554444f, 0.04264121f, -0.11210239f, 
    -0.08517149f, 0.03121099f, -0.08324010f, 0.00226232f, -0.00940494f, -0.09966452f, -0.01876715f, -0.03831827f, 
    -0.07221636f, 0.02407037f, -0.05826611f, -0.02827004f, -0.18028560f, 0.04411114f, 0.00537438f, 0.01343785f, 
    -0.09688133f, 0.13630213f, -0.03798239f, 0.13646860f, 0.00837778f, -0.04317105f, 0.07282978f, -0.01958172f, 
    -0.01088362f, -0.06449899f, 0.04296442f, 0.03408262f, -0.00969474f, 0.21037000f, 0.07899241f, -0.11400615f, 
    -0.24828075f, 0.00091088f, 0.01234970f, 0.06348822f, 0.02121832f, 0.11369161f, 0.00440027f, 0.08595167f, 
    0.02758277f, -0.00658942f, -0.06022279f, 0.02861671f, -0.05773079f, -0.06864481f, 0.00612230f, -0.02220696f, 
    -0.32934034f, 0.13633917f, -0.00334948f, -0.14564082f, -0.04980681f, 0.06671740f, -0.04927700f, -0.02366488f, 
    0.11544019f, -0.04957714f, 0.03419834f, -0.08852921f, 0.05737643f, 0.01706561f, -0.06499813f, -0.02410164f, 
    -0.04500075f, 0.03267628f, 0.04980026f, -0.05953027f, 0.21851510f, -0.19932196f, -0.14623395f, -0.14270093f, 
    -0.16359754f, -0.10890128f, 0.10412090f, 0.06190202f, 0.00282417f, -0.14798018f, 0.06578711f, -0.08737554f, 
    0.01914813f, -0.03245943f, 0.08712611f, -0.06861632f, -0.00490369f, 0.01184150f, 0.04043896f, 0.12832771f, 
    0.03033252f, -0.02414982f, 0.03668086f, 0.02584345f, -0.03451496f, -0.01429498f, -0.00471970f, -0.01741885f, 
    0.00725568f, -0.06004204f, 0.00563447f, 0.04016086f, 0.03388299f, -0.00449124f, 0.02056219f, -0.06045226f, 
    -0.00107326f, 0.03777421f, -0.02493281f, -0.03661963f, 0.03168222f, -0.05976156f, -0.01054116f, 0.03086702f, 
    -0.05701017f, 0.03585597f, -0.05469465f, -0.04703291f, -0.04945849f, 0.00816458f, 0.01294087f, 0.03899859f, 
    0.01179561f, 0.04025621f, 0.02029574f, -0.04433499f, 0.04650992f, 0.04928416f, 0.03609249f, -0.05614822f, 
    0.04168558f, 0.03438563f, 0.02716117f, 0.02849277f, -0.04506063f, -0.05144240f, -0.02061646f, -0.04869803f, 
    0.00689383f, -0.03519376f, 0.02867742f, -0.05880779f, 0.03605078f, -0.06087071f, 0.03587363f, 0.02028789f, 
    -0.00960299f, -0.01609625f, 0.03809901f, 0.01875380f, -0.01166580f, -0.00975744f, -0.04743333f, -0.01081135f, 
    -0.01511395f, -0.05120428f, 0.04437270f, -0.03006782f, -0.00330413f, 0.03986001f, -0.01742155f, -0.01791092f, 
    0.02355484f, 0.04926650f, 0.00768526f, 0.01725134f, 0.02592846f, 0.01018452f, 0.03035592f, -0.00320484f, 
    0.03252672f, -0.01050719f, 0.00723569f, 0.02644903f, 0.03842149f, 0.04404157f, -0.01856568f, -0.00281086f, 
    -0.05832244f, 0.01369690f, -0.04544001f, -0.01879008f, -0.02099419f, 0.04252174f, -0.01561481f, 0.03228625f, 
    -0.00012866f, 0.04374668f, 0.03165904f, -0.06148107f, 0.00410038f, -0.04129721f, -0.02040354f, 0.02939788f, 
    0.03457899f, -0.04638630f, -0.04068126f, 0.04167010f, 0.00653517f, -0.03259996f, -0.03791831f, 0.04300375f, 
    0.04295568f, -0.01997934f, 0.01278780f, -0.05001844f, -0.03536206f, 0.04174332f, 0.03330045f, 0.01229672f, 
    0.03123641f, 0.00206001f, -0.04626830f, -0.02253600f, -0.03137963f, -0.05221057f, 0.04284990f, -0.04907624f, 
    -0.02784674f, -0.02288367f, -0.02968947f, 0.04599239f, 0.02401326f, -0.05200941f, -0.04275202f, 0.03383307f, 
    0.03806284f, -0.03762042f, 0.04950638f, -0.05147710f, -0.00055541f, -0.01235324f, -0.00538638f, -0.02924830f, 
    -0.05281560f, -0.01317396f, 0.03281996f, 0.01921796f, -0.02912759f, 0.00893795f, 0.04249389f, -0.00948445f, 
    0.04425503f, 0.04671793f, -0.04026564f, -0.05917575f, -0.03600837f, -0.03817789f, 0.01062834f, -0.01146278f, 
    -0.02009040f, -0.00541985f, 0.02812161f, 0.02082567f, 0.01430165f, -0.02856426f, -0.03674047f, -0.02539941f, 
    -0.05407752f, -0.02326280f, 0.03679430f, -0.00015506f, -0.00560748f, 0.01559649f, -0.01378550f, 0.03962223f, 
    0.04255047f, -0.03518487f, -0.03196121f, -0.00378592f, -0.01910901f, -0.02835231f, 0.03804968f, 0.00354117f, 
    0.01454615f, -0.00038425f, -0.03404280f, -0.04091017f, -0.05664852f, -0.03082277f, 0.00462433f, -0.05418827f, 
    -0.01899601f, -0.01977321f, 0.00793656f, -0.02221529f, -0.01987598f, -0.02708299f, 0.04423203f, -0.01822860f, 
    -0.00328532f, 0.00144128f, 0.02699021f, -0.04552276f, -0.02692096f, -0.05940950f, -0.04918026f, -0.06188857f, 
    0.01373174f, 0.04196157f, 0.04412948f, -0.00129093f, 0.01628344f, 0.01365167f, -0.02150128f, -0.05519776f, 
    -0.03024614f, 0.04720194f, -0.05769068f, -0.05907057f, -0.03706577f, -0.04037600f, 0.04894736f, -0.01244843f, 
    0.00767940f, -0.00449824f, -0.00537690f, 0.01172507f, 0.01886699f, -0.04466166f, -0.03495159f, -0.01886745f, 
    -0.01102945f, 0.00775028f, -0.00575414f, 0.04458428f, -0.02981451f, 0.01342489f, -0.02903859f, -0.04319450f, 
    -0.03780514f, -0.05747771f, -0.05075686f, -0.03237730f, 0.03476720f, -0.00270956f, 0.03064786f, -0.04908932f, 
    0.04493527f, -0.04783718f, -0.03912576f, 0.00773645f, 0.04423211f, -0.04040377f, -0.04617425f, -0.04349309f, 
    0.03147706f, -0.05713923f, -0.01681424f, -0.04128084f, -0.02873479f, -0.02072263f, -0.03082898f, 0.03988425f, 
    -0.05384734f, -0.01618712f, -0.00232211f, -0.02933509f, -0.00387093f, 0.03325091f, -0.03693049f, 0.01536817f, 
    -0.05314439f, 0.04027518f, -0.01340997f, -0.05391318f, 0.02160226f, -0.03002222f, -0.02956366f, -0.05979511f, 
    0.02455239f, -0.05585515f, -0.01914222f, 0.00306402f, -0.01611657f, 0.02883920f, -0.03127009f, -0.03686483f, 
    -0.05535272f, -0.03096742f, 0.00036961f, -0.03350672f, 0.00952870f, -0.01687909f, -0.05605044f, 0.03303974f, 
    0.03955725f, 0.00679588f, -0.04491828f, -0.01739060f, -0.03497398f, -0.01287789f, -0.02117747f, -0.04068891f, 
    0.02278342f, -0.02118798f, -0.00184056f, -0.00226113f, -0.04085696f, 0.01825217f, 0.03251753f, 0.02647844f, 
    0.00643648f, 0.03726732f, -0.01116579f, 0.00599898f, 0.00039942f, 0.02317569f, -0.04523452f, 0.02729383f, 
    0.24904078f, 0.05918104f, -0.00042898f, 0.24075954f, 0.15736328f, 0.08768076f, -0.02790297f, 0.03613273f, 
    -0.06507016f, 0.01425673f, -0.01260427f, 0.00272442f, 0.04449623f, 0.11820706f, 0.18888174f, -0.07835417f, 
    0.11224638f, 0.01401039f, -0.00733049f, -0.04106886f, 0.11584917f, -0.01689663f, -0.04192872f, -0.00896887f, 
    0.19564319f, 0.07589142f, -0.01137592f, -0.03822160f, 0.10371263f, -0.04187206f, 0.06913622f, 0.00436476f, 
    0.06149466f, 0.06027382f, -0.01967045f, 0.00001021f, 0.04745016f, 0.04462617f, -0.11014470f, -0.00851937f, 
    -0.16152287f, 0.33413023f, -0.14373407f, 0.09667320f, -0.00652093f, 0.13890605f, 0.04736592f, -0.06244929f, 
    0.00311524f, 0.08094322f, 0.08887804f, 0.05210792f, 0.11211133f, -0.06982560f, -0.09432790f, 0.03569758f, 
    -0.00422052f, -0.13997495f, -0.01241465f, -0.00769192f, -0.37476018f, -0.08613126f, 0.08501883f, -0.28222796f, 
    -0.05188740f, -0.10718831f, 0.02045408f, 0.10626099f, -0.02309543f, -0.09344268f, -0.03297369f, 0.08359598f, 
    -0.05566962f, 0.05577147f, -0.01659033f, -0.06727458f, 0.04368541f, -0.05674471f, -0.09445256f, -0.11487047f, 
    -0.10992156f, -0.13608684f, 0.12909093f, 0.19629037f, -0.04516944f, 0.01714196f, -0.18519443f, -0.08549766f, 
    0.06851917f, 0.03843215f, 0.00150099f, 0.09131848f, 0.15508555f, -0.03105611f, 0.04115254f, -0.07686295f, 
    0.01965640f, -0.03728146f, 0.09946474f, 0.02061243f, 0.12941773f, 0.04378146f, -0.25389132f, -0.04329251f, 
    -0.11039682f, -0.04926728f, 0.00956608f, -0.02739277f, 0.01207289f, 0.01100983f, 0.04888875f, 0.06432256f, 
    0.10345087f, 0.05097068f, -0.00702630f, 0.02319232f, 0.05854136f, -0.08301596f, -0.01023322f, 0.05886667f, 
    -0.45535538f, 0.07251949f, -0.02506526f, -0.22444689f, -0.09927139f, -0.07172731f, 0.02104414f, -0.01918678f, 
    -0.03221847f, 0.03317032f, -0.01294240f, 0.04500084f, 0.00421958f, 0.10263617f, 0.11346422f, 0.07514949f, 
    -0.00385333f, -0.05788250f, 0.09354088f, 0.13171600f, -0.23270474f, 0.09144580f, 0.01092711f, -0.21124662f, 
    0.01535565f, 0.02520849f, 0.05272486f, -0.04662956f, 0.03453133f, -0.16555552f, -0.00295227f, 0.11489886f, 
    -0.06884698f, 0.12846170f, -0.07995605f, -0.01278454f, -0.01274111f, 0.00290703f, -0.01988218f, 0.02199721f, 
    0.22407666f, 0.25663882f, 0.12698269f, 0.02204375f, 0.19614372f, -0.01126298f, 0.01917627f, -0.05338378f, 
    -0.06438013f, 0.01318515f, 0.01494016f, 0.05552595f, 0.04502875f, 0.02202876f, -0.04887446f, -0.01531971f, 
    0.05150364f, 0.00392440f, 0.05903985f, -0.08689801f, -0.19780666f, -0.10334635f, 0.04183176f, -0.18913166f, 
    0.01920556f, 0.00776675f, -0.03768514f, 0.06881849f, -0.12712213f, -0.00957555f, 0.02756814f, -0.05150296f, 
    -0.03854273f, 0.04331784f, 0.03246646f, 0.06646500f, -0.03429424f, -0.01444225f, -0.05379129f, -0.01472807f, 
    -0.23815873f, -0.24521022f, 0.09454601f, -0.22173674f, -0.06349190f, 0.01224325f, -0.09885166f, 0.07286447f, 
    -0.09323549f, -0.04099733f, 0.04237853f, 0.06575955f, 0.05070185f, 0.12327117f, 0.12099002f, -0.06496473f, 
    -0.09850308f, 0.02872054f, -0.20240413f, 0.07162246f, -0.18189779f, 0.16263795f, 0.11871070f, 0.19312531f, 
    0.05368675f, -0.00542800f, 0.02110594f, -0.02998107f, -0.05042814f, 0.09340839f, 0.08158021f, 0.06722551f, 
    0.03181570f, 0.02716434f, -0.08568237f, 0.02953112f, -0.01454218f, -0.00650515f, 0.02094679f, 0.03082606f, 
    0.03372073f, 0.13503130f, -0.00157024f, -0.22309373f, 0.07390384f, -0.11271900f, -0.02819132f, -0.05149445f, 
    0.03142070f, -0.11565571f, 0.01636508f, 0.02404836f, 0.09011509f, -0.04843261f, 0.01686261f, -0.01575711f, 
    0.02220360f, -0.00954870f, 0.04954172f, -0.00800544f, 0.20376703f, 0.21432731f, 0.05551396f, 0.01478823f, 
    0.03823810f, -0.05603943f, -0.00250659f, -0.15455766f, 0.06701197f, -0.10557664f, 0.03019376f, -0.00819245f, 
    0.12124162f, -0.04823086f, 0.00667302f, -0.03684536f, -0.01003351f, -0.03635228f, 0.05824357f, -0.11203722f, 
    -0.04093782f, -0.05943670f, 0.15088712f, -0.04347380f, -0.02787967f, -0.01061360f, -0.00083347f, 0.11825188f, 
    0.08702508f, -0.06124142f, -0.05771167f, -0.07883325f, 0.03291269f, -0.02343145f, -0.07220344f, 0.05629329f, 
    -0.11062819f, 0.02957314f, -0.01712057f, -0.00129587f, 0.30732596f, 0.28887284f, 0.00154677f, 0.20715337f, 
    0.19079371f, 0.09421545f, -0.04411915f, -0.11186952f, 0.01315610f, -0.00966776f, 0.00831628f, 0.11475849f, 
    0.10926384f, -0.05886298f, 0.06338706f, 0.05299282f, 0.08828139f, 0.09956453f, -0.03835541f, -0.00647407f, 
    -0.04510386f, 0.00358834f, -0.03489716f, -0.04407186f, -0.02299130f, -0.02327485f, 0.03221071f, 0.00214366f, 
    -0.05605581f, 0.03593758f, -0.01292237f, 0.03972514f, -0.03667951f, 0.03228164f, -0.04824696f, 0.00929186f, 
    -0.03691376f, -0.03068864f, -0.03131808f, 0.02258494f, -0.04038380f, 0.00468527f, -0.00902107f, -0.04564450f, 
    -0.05445752f, 0.02864463f, -0.03427076f, -0.04839558f, -0.04407099f, 0.01164367f, -0.01287488f, -0.01900988f, 
    -0.01672611f, -0.00717589f, -0.05380345f, -0.05162065f, 0.04722875f, -0.03967654f, -0.03386585f, -0.01834045f, 
    -0.00895620f, 0.03281399f, 0.01773979f, -0.02964225f, 0.04321981f, -0.04484940f, 0.00262268f, 0.04036747f, 
    -0.05625708f, 0.00885290f, -0.04414904f, -0.01647057f, -0.03164845f, 0.04364786f, -0.05398279f, 0.00949548f, 
    -0.01778290f, -0.03448325f, 0.03264548f, -0.00838225f, 0.01032465f, -0.03227307f, 0.00970335f, 0.01411201f, 
    -0.01256034f, -0.00154499f, -0.05589257f, 0.02730297f, -0.00661300f, 0.04202031f, -0.03675666f, 0.03144947f, 
    0.02509029f, -0.05437370f, -0.01998951f, -0.02555510f, -0.02558079f, -0.05676652f, 0.02768652f, -0.01840460f, 
    -0.01386259f, -0.05218661f, -0.00675658f, 0.03364760f, 0.03428469f, -0.03579974f, -0.03543518f, 0.01700661f, 
    -0.05032953f, 0.04711383f, -0.05255618f, -0.06058042f, -0.06033344f, 0.03756446f, 0.03901891f, 0.03565792f, 
    -0.02639182f, 0.02026389f, -0.01286994f, 0.02192751f, 0.01811443f, 0.03300947f, -0.00341972f, -0.02371146f, 
    -0.01540421f, -0.06003916f, -0.02914389f, -0.04544514f, -0.05697265f, -0.03759072f, -0.00980872f, -0.03409090f, 
    0.00742749f, -0.03649408f, 0.03321359f, -0.02350314f, 0.03519395f, -0.04896962f, 0.00737158f, -0.04593819f, 
    0.01887969f, 0.03015007f, 0.00442428f, -0.06119182f, 0.01264722f, -0.04102492f, -0.04733544f, 0.01451018f, 
    -0.06335481f, -0.01126591f, 0.01035939f, -0.02145322f, 0.04705796f, -0.06240011f, 0.00905770f, -0.04554532f, 
    0.04078962f, -0.04749218f, -0.00985775f, 0.01433365f, -0.01589690f, 0.02098968f, 0.02073982f, 0.04635306f, 
    0.03078659f, 0.03354390f, -0.01950486f, -0.03934037f, 0.03268984f, -0.06053212f, -0.03564139f, 0.02607087f, 
    0.03007809f, 0.03239934f, 0.01382865f, -0.03413932f, -0.03083771f, -0.02175739f, 0.02976198f, -0.03329081f, 
    0.03570171f, 0.01793029f, -0.04879164f, -0.04502957f, 0.00794877f, -0.03828022f, -0.03769043f, 0.00467504f, 
    0.03349897f, 0.02850726f, -0.02829645f, -0.03100452f, 0.03187381f, 0.01512189f, 0.03576418f, -0.02106772f, 
    0.02129684f, -0.03220885f, 0.02430182f, -0.04970226f, -0.03049466f, -0.00073555f, 0.00922702f, -0.01403016f, 
    0.01199650f, -0.00802054f, -0.05180732f, -0.04242238f, -0.05428350f, 0.02038091f, 0.04260303f, -0.01923031f, 
    -0.01527513f, -0.00335419f, 0.03608403f, -0.03822295f, 0.04330514f, -0.00743275f, -0.00402124f, 0.00133578f, 
    0.02816645f, -0.01698000f, 0.03726637f, -0.00376927f, -0.02753099f, 0.02087452f, -0.05748610f, 0.02242749f, 
    0.00059699f, -0.00436436f, 0.00271527f, -0.04625324f, 0.01983733f, 0.04150426f, 0.02830389f, 0.04737350f, 
    -0.04261295f, -0.01388727f, 0.04757293f, 0.04563725f, -0.00842024f, -0.04999750f, -0.04062691f, -0.05105905f, 
    -0.05992607f, 0.01826693f, -0.05899695f, 0.03417351f, -0.04173115f, 0.03848930f, -0.00109738f, -0.00871590f, 
    -0.05789617f, -0.02015109f, -0.02212122f, -0.02109157f, -0.05333458f, 0.02625761f, 0.01790102f, 0.04028774f, 
    0.04229993f, -0.03782266f, 0.04594431f, -0.05661052f, -0.05252087f, 0.03578599f, -0.00682435f, 0.02472550f, 
    0.02821082f, 0.01897912f, -0.05312457f, -0.04209346f, 0.02695650f, -0.04668310f, -0.00916002f, -0.02374035f, 
    -0.01766068f, 0.01026944f, 0.03013235f, 0.00267465f, -0.04962791f, -0.03981286f, -0.04998346f, 0.02737360f, 
    0.01093874f, 0.00947733f, -0.02230959f, -0.00186201f, -0.05970455f, -0.05491510f, -0.03210161f, 0.00136301f, 
    0.02823202f, 0.01657340f, 0.04711384f, -0.00117941f, -0.05940891f, 0.01652982f, -0.05347094f, 0.03426475f, 
    0.04273555f, -0.02870410f, -0.04943081f, -0.03853202f, 0.03411794f, 0.02197858f, -0.00823819f, -0.00655300f, 
    0.02290335f, -0.05443939f, 0.00432840f, -0.05171819f, -0.03649707f, 0.03605705f, -0.04362130f, -0.02005172f, 
    -0.00586927f, -0.03418610f, -0.03893631f, -0.00444244f, -0.01980444f, 0.02277407f, -0.00573374f, 0.02275945f, 
    0.00224233f, 0.01677635f, -0.06364830f, -0.02691712f, 0.03382022f, -0.05279602f, 0.00525871f, -0.05991063f, 
    0.04750640f, -0.01283586f, -0.03667234f, -0.06221342f, 0.03114598f, -0.03525058f, 0.03606320f, -0.02896832f, 
    0.02998646f, -0.03510420f, -0.03411940f, -0.06102890f, -0.05979115f, 0.03061689f, 0.00057736f, -0.02079782f, 
    0.01253869f, -0.04748023f, -0.03371843f, -0.06179881f, 0.02274537f, -0.04621748f, -0.05232824f, -0.04420087f, 
    0.03710539f, -0.04718841f, 0.00687014f, -0.04585286f, 0.03123344f, 0.00973497f, -0.00005615f, -0.00858722f, 
    -0.04646511f, -0.00026530f, 0.02270268f, 0.01313385f, -0.06002850f, -0.02455558f, 0.00550091f, -0.02531135f, 
    -0.03871642f, 0.03817120f, -0.01316188f, -0.00048608f, 0.00086274f, 0.04553193f, 0.04255561f, 0.02418208f, 
    -0.05488659f, -0.05236989f, -0.00596163f, -0.02012259f, 0.01579607f, 0.04106439f, -0.05394952f, -0.00112093f, 
    -0.05673205f, -0.03522168f, -0.05123765f, 0.04108767f, -0.01210207f, 0.03868101f, 0.04375046f, -0.02917611f, 
    -0.02474255f, 0.02070236f, 0.04218846f, 0.04536001f, -0.03346554f, 0.04222912f, -0.04525316f, -0.03194606f, 
    -0.05718862f, 0.00917282f, 0.03202563f, 0.00710442f, -0.01036058f, 0.00505410f, 0.03387189f, 0.00116669f, 
    0.04110324f, 0.03946964f, -0.00574031f, 0.04255853f, -0.01533976f, -0.05483334f, 0.01606465f, 0.01583035f, 
    -0.03434260f, 0.00339923f, -0.04644298f, 0.00360735f, -0.02874558f, 0.01613807f, -0.04549796f, -0.00328314f, 
    0.02518742f, 0.02799652f, 0.03350042f, -0.00236976f, -0.04843180f, -0.03104567f, -0.01331911f, 0.01452678f, 
    -0.00813138f, 0.03926884f, -0.00673027f, -0.02238823f, -0.02946019f, 0.01097087f, -0.02908891f, -0.02862005f, 
    -0.01644246f, -0.05830002f, 0.02047971f, 0.00190388f, -0.02051491f, -0.02729855f, -0.01780703f, 0.04234143f, 
    0.01229970f, -0.03703648f, -0.02367975f, -0.01106296f, 0.04401276f, 0.00830598f, 0.01160349f, -0.02354809f, 
    -0.01983261f, 0.03133105f, -0.05738303f, 0.01947771f, -0.05112277f, -0.00553447f, 0.03091326f, -0.05322202f, 
    -0.01829437f, 0.00990496f, -0.04216540f, -0.05973694f, 0.04522306f, 0.02915634f, 0.04189731f, 0.02797001f, 
    -0.05124985f, 0.02093960f, -0.05173500f, -0.03825403f, -0.02345965f, 0.01648854f, -0.04731174f, -0.05160638f, 
    -0.03673831f, -0.05747100f, -0.02651692f, -0.03777222f, 0.02245188f, 0.03745970f, -0.06146143f, -0.05219830f, 
    -0.04390266f, 0.00078377f, 0.03884992f, -0.03032633f, 0.01882221f, -0.02540532f, 0.00339151f, 0.01335422f, 
    -0.02032297f, 0.04378543f, -0.02679296f, 0.01469032f, 0.01037852f, 0.04033874f, -0.03724415f, -0.01344570f, 
    -0.05130012f, 0.00388406f, -0.03939138f, -0.01673270f, -0.05437407f, -0.04736403f, -0.00485004f, 0.02795241f, 
    0.03853669f, -0.00654787f, 0.04932849f, 0.01353839f, -0.02622690f, -0.02094589f, -0.04104902f, -0.05787082f, 
    -0.03564581f, -0.03957302f, 0.02253591f, -0.03195618f, -0.05881739f, 0.03644194f, -0.06132856f, 0.03019257f, 
    0.03531478f, -0.00792749f, 0.04434527f, 0.00150853f, -0.00041767f, -0.06136983f, -0.01455214f, 0.02544754f, 
    0.03574294f, -0.02939449f, -0.01763465f, 0.03997553f, 0.02891907f, -0.00809049f, -0.03417001f, -0.00719710f, 
    -0.05719785f, 0.04241930f, -0.02110536f, -0.00695679f, 0.02885865f, -0.00370404f, 0.02253598f, 0.01076543f, 
    0.02779228f, 0.01335363f, 0.00182709f, -0.04615743f, 0.04306606f, -0.04837386f, 0.00123479f, 0.03395303f, 
    -0.01372607f, -0.05675877f, 0.02789003f, -0.05500118f, -0.03672132f, -0.02186307f, 0.03205885f, 0.02247011f, 
    0.01617925f, -0.03638233f, -0.04609908f, -0.05682872f, -0.03417382f, 0.02850227f, -0.02515941f, -0.01982820f, 
    0.01663243f, 0.04224067f, -0.02268965f, -0.02050806f, -0.02573918f, -0.05096554f, 0.02908720f, -0.01363554f, 
    -0.05674388f, 0.01235123f, -0.01855057f, -0.01379696f, 0.00876717f, -0.01497039f, -0.04504149f, 0.04119355f, 
    -0.02738812f, -0.02971766f, -0.01742202f, -0.00468033f, -0.00070954f, 0.01646400f, 0.02192869f, -0.00659547f, 
    0.01241077f, -0.04613938f, 0.02332486f, 0.02911355f, -0.01369577f, 0.01278524f, -0.03340018f, 0.00021475f, 
    -0.06088286f, -0.04248189f, -0.05430754f, 0.04408131f, -0.03451465f, 0.03023681f, 0.04571537f, -0.05792969f, 
    -0.00842736f, -0.05968959f, -0.03078659f, 0.03690047f, -0.04620871f, 0.01313308f, -0.01477035f, -0.03418554f, 
    0.01130915f, -0.05188680f, 0.02924741f, -0.00487233f, 0.04600878f, 0.04509220f, -0.05363067f, -0.02580331f, 
    -0.01110167f, -0.05688125f, 0.02668797f, -0.03232487f, 0.03074020f, 0.01789623f, -0.04323042f, 0.02491571f, 
    0.01615056f, -0.03023584f, -0.04441731f, -0.03187002f, 0.03758602f, -0.01728694f, -0.03489416f, 0.04187333f, 
    -0.00357952f, 0.01216658f, 0.00155338f, -0.01083530f, 0.03833825f, 0.01187858f, 0.02050038f, -0.04404144f, 
    0.00366248f, 0.01228840f, -0.04159525f, -0.01520774f, 0.02020580f, 0.04731856f, -0.05960248f, -0.03303630f, 
    0.00632995f, 0.06129346f, 0.01659056f, -0.04123891f, -0.04320262f, 0.03934222f, 0.00569163f, 0.04928700f, 
    0.01062887f, 0.04196524f, -0.00221604f, -0.02454149f, -0.02672678f, 0.05416516f, 0.02367532f, 0.03768089f, 
    -0.02398351f, 0.00052889f, -0.02935170f, 0.00821368f, -0.05134330f, 0.00921147f, -0.05733265f, 0.03373981f, 
    -0.05135277f, -0.03548906f, -0.04359577f, -0.01428326f, -0.01499701f, 0.01378285f, 0.00824672f, -0.04865436f, 
    -0.05138972f, -0.03465471f, 0.02862378f, -0.03610370f, 0.04155680f, -0.03247113f, -0.01069656f, -0.02270416f, 
    0.01159440f, 0.03823310f, -0.05894754f, 0.00113637f, -0.00283762f, 0.01195724f, 0.02113698f, -0.03617448f, 
    -0.04958191f, -0.03962616f, -0.00079691f, 0.02783611f, -0.03317458f, -0.00308548f, -0.02195135f, -0.05846265f, 
    0.00589300f, 0.02462513f, -0.03919162f, 0.02160100f, -0.03075676f, -0.00145836f, -0.02132387f, 0.02315276f, 
    0.01947581f, -0.01687774f, 0.05856273f, -0.00528913f, 0.02763220f, 0.00129664f, 0.02948982f, 0.04820723f, 
    0.00716345f, -0.03808751f, 0.03889908f, -0.05417325f, 0.00568003f, -0.02990581f, -0.05638963f, 0.03249166f, 
    -0.01940270f, 0.00974070f, -0.04345096f, -0.01350926f, -0.01042513f, -0.01098437f, 0.02677432f, -0.00028982f, 
    -0.00660261f, 0.04389289f, -0.00014201f, 0.02390624f, -0.01886107f, 0.01555141f, 0.03748405f, 0.02538386f, 
    -0.00081941f, 0.04166722f, 0.01897739f, 0.01856043f, 0.04411448f, 0.01317346f, -0.05795735f, -0.06093490f, 
    -0.00837361f, -0.03454316f, -0.04665601f, 0.04135323f, -0.00240847f, 0.00627757f, 0.01678811f, 0.04022564f, 
    -0.05217927f, -0.03199662f, -0.04511897f, 0.01193260f, 0.05049440f, -0.00358040f, -0.02618159f, -0.04387867f, 
    -0.05480007f, 0.01710094f, 0.01201939f, -0.04616339f, -0.05801302f, 0.03887396f, -0.03122996f, -0.02522745f, 
    0.03600356f, 0.02900900f, -0.02394456f, 0.04219998f, -0.05621284f, 0.00101911f, -0.02267540f, -0.04977732f, 
    0.04196877f, 0.00323114f, 0.00792475f, -0.03634796f, 0.00780344f, 0.02131118f, 0.03402091f, 0.02946094f, 
    -0.05454799f, 0.04949786f, -0.01081769f, -0.00541052f, 0.01057703f, 0.01070342f, -0.05417259f, 0.01699168f, 
    -0.04896393f, -0.01365887f, -0.01983967f, -0.03488820f, 0.03867648f, -0.03258202f, -0.02274401f, 0.02119067f, 
    0.04830771f, -0.00335960f, -0.04875629f, 0.02251302f, -0.02202175f, -0.01681352f, 0.02188586f, -0.04134272f, 
    0.03508855f, -0.00413553f, 0.00376354f, 0.00454178f, -0.03370640f, -0.01281342f, -0.03083628f, -0.04662039f, 
    -0.03083678f, -0.04559492f, -0.04383982f, -0.00724182f, -0.02033131f, -0.03824957f, -0.01907675f, -0.01924509f, 
    -0.00172930f, -0.05379629f, 0.00761037f, 0.02283063f, 0.04522778f, -0.01825162f, 0.04619390f, -0.04006863f, 
    -0.04349190f, -0.04346550f, 0.00096448f, 0.01898168f, 0.03800552f, 0.00593113f, 0.00253200f, -0.02245835f, 
    0.02646555f, -0.04191130f, -0.00595494f, 0.01889994f, -0.01008242f, 0.02923296f, 0.02179516f, -0.01729860f, 
    -0.05316968f, -0.01585915f, -0.03042266f, 0.03085342f, 0.04857488f, -0.00672613f, 0.03491517f, 0.04021589f, 
    -0.03669323f, 0.02045068f, -0.01284447f, -0.01069276f, 0.03007298f, 0.01160370f, 0.02485218f, 0.00137713f, 
    0.01416245f, 0.04263502f, 0.00683128f, 0.01812871f, -0.01365381f, 0.02052993f, 0.00567091f, -0.04649590f, 
    -0.03336678f, 0.01865674f, -0.04901422f, -0.01555104f, -0.02677811f, 0.02074415f, -0.01757911f, -0.03011971f, 
    0.04695400f, 0.03612632f, 0.03555588f, 0.01107746f, -0.00763162f, 0.05785807f, -0.06017991f, -0.06094130f, 
    -0.03004221f, 0.03760269f, -0.04568812f, 0.00405816f, -0.05235364f, -0.03881265f, -0.00545450f, 0.03228246f, 
    -0.02730080f, -0.04585665f, -0.03540182f, -0.00422591f, -0.03371469f, -0.03325558f, 0.00890522f, 0.03872084f, 
    -0.00356267f, -0.02907415f, -0.03126718f, 0.02059470f, 0.01760623f, 0.00734753f, -0.00344254f, -0.04206496f, 
    -0.03275899f, 0.02016491f, 0.04365744f, -0.00119507f, 0.01479856f, -0.01093216f, -0.02654836f, -0.03975422f, 
    -0.01198830f, -0.00728144f, -0.01395688f, 0.03873101f, -0.05365008f, -0.06018255f, -0.04093034f, 0.02472144f, 
    -0.00426599f, -0.03700341f, 0.03761648f, -0.02992099f, 0.00465336f, -0.03471825f, -0.02655456f, 0.04314444f, 
    -0.02443035f, -0.04219804f, 0.01461138f, -0.03716250f, 0.01220297f, -0.04140203f, -0.01539656f, 0.05182124f, 
    0.01342570f, 0.04973539f, 0.01548516f, -0.02932056f, 0.03666971f, 0.01877335f, 0.00378331f, -0.05719719f, 
    -0.00722751f, -0.00742261f, -0.03356197f, -0.00397468f, -0.01227851f, -0.04211424f, -0.04395962f, -0.01436705f, 
    -0.04973997f, -0.02670099f, -0.05747227f, -0.01017686f, 0.01109173f, -0.03783537f, 0.01639806f, -0.00257975f, 
    -0.03529130f, -0.01479463f, -0.02606641f, 0.02765418f, -0.01096614f, -0.04278135f, -0.01365047f, 0.03749343f, 
    0.03172239f, 0.03432562f, -0.03426345f, -0.02333490f, 0.03761928f, -0.00003168f, -0.02602214f, 0.04761260f, 
    -0.01823705f, 0.00059419f, -0.01759115f, -0.05802320f, -0.03265100f, 0.01941390f, 0.01691705f, 0.03092520f, 
    -0.04665065f, 0.01890949f, 0.02677059f, -0.00016353f, 0.04198236f, 0.01569273f, -0.04928868f, 0.00282614f, 
    -0.04948351f, 0.02064442f, 0.00394419f, -0.01470501f, 0.00985904f, -0.03683884f, -0.04239383f, -0.03444714f, 
    -0.04090064f, 0.03419714f, 0.01041947f, -0.03207944f, -0.05355833f, 0.01892081f, -0.03808375f, -0.03704693f, 
    0.03723694f, -0.05298895f, -0.05125152f, -0.01145105f, 0.04896893f, -0.05840524f, 0.01012920f, -0.02464637f, 
    -0.02568858f, 0.03582844f, 0.03062690f, -0.02188176f, 0.01074075f, 0.00603350f, 0.03703053f, -0.05803549f, 
    -0.02540747f, -0.01550973f, 0.03862709f, 0.04705971f, -0.04755303f, -0.03462155f, -0.04643035f, 0.04012081f, 
    -0.04144727f, -0.02569110f, -0.03924711f, 0.02240075f, 0.03693605f, 0.03146648f, 0.01441016f, -0.00115046f, 
    0.00478003f, -0.02089784f, -0.05697274f, 0.01179395f, -0.04476867f, -0.00642624f, -0.02461280f, 0.02766316f, 
    -0.05340133f, 0.04679375f, 0.04089041f, 0.01369270f, -0.04024596f, 0.00482078f, -0.01125110f, -0.04986189f, 
    0.04550033f, 0.03599770f, 0.00501064f, 0.03882099f, 0.01450681f, 0.04777351f, 0.03012450f, -0.02482696f, 
    0.00463757f, 0.01495529f, -0.02167261f, 0.04898833f, 0.02433483f, -0.05830245f, -0.05142481f, -0.00861281f, 
    0.03606928f, -0.01457326f, 0.03834063f, -0.01945246f, -0.01780448f, 0.01659481f, -0.05072761f, -0.01737187f, 
    -0.05553731f, -0.00445007f, 0.03598223f, -0.01756764f, -0.05316086f, -0.01297839f, -0.05805929f, 0.02874179f, 
    -0.03710919f, -0.05500899f, -0.06117089f, -0.00209333f, 0.04748539f, -0.02665688f, -0.05904387f, 0.02211471f, 
    -0.03381515f, 0.03516671f, 0.04572643f, 0.02987300f, 0.02701392f, -0.03426552f, -0.01489151f, -0.02099247f, 
    -0.01403692f, -0.03694686f, 0.01009496f, -0.03075499f, 0.02488755f, 0.02141012f, 0.02390263f, -0.03501340f, 
    0.02872658f, 0.01710851f, 0.04525605f, -0.03089737f, 0.02547041f, -0.03383412f, -0.01257136f, -0.01374703f, 
    -0.00633290f, -0.03092480f, 0.01319543f, 0.03304995f, -0.01802169f, -0.00048353f, -0.05431367f, -0.05138609f, 
    -0.04690039f, -0.03204706f, -0.05357685f, 0.01316067f, 0.04783494f, -0.00102050f, -0.03946495f, -0.03086584f, 
    -0.00817186f, 0.04894847f, -0.04938814f, 0.01505695f, 0.00854003f, 0.03646551f, 0.02351127f, 0.01457406f, 
    -0.01545996f, -0.04376411f, 0.04701025f, -0.05694368f, 0.03681775f, 0.04882151f, 0.03289970f, -0.03248888f, 
    -0.00879313f, 0.00145536f, -0.00724091f, -0.03810599f, 0.00593076f, -0.05426105f, -0.01262534f, -0.00110254f, 
    0.00956362f, 0.04322091f, -0.00307342f, 0.00009733f, -0.03980612f, -0.05089116f, -0.02591684f, -0.04156209f, 
    0.01439396f, -0.05556579f, 0.01664640f, -0.03964698f, -0.01921076f, 0.02292908f, 0.00582207f, 0.01370891f, 
    -0.04235526f, -0.05247850f, -0.05665174f, 0.03384795f, 0.04903700f, 0.01546601f, -0.05941054f, 0.01452065f, 
    0.01578257f, -0.05938979f, -0.05737677f, 0.04764508f, -0.00955762f, -0.01052902f, 0.00511083f, -0.02334514f, 
    0.01816302f, -0.00764553f, -0.04667456f, 0.02061369f, 0.03918269f, -0.00006578f, -0.05658505f, 0.00941064f, 
    0.00663492f, -0.04146532f, -0.02634451f, 0.02670332f, -0.01236385f, -0.04559271f, -0.00126391f, -0.05324576f, 
    -0.00680291f, -0.02720895f, 0.02364575f, -0.04696391f, -0.05470048f, -0.06045521f, -0.04151372f, -0.01226296f, 
    -0.00976492f, -0.03729691f, -0.01572936f, -0.05321322f, -0.04182151f, -0.02262901f, -0.04987821f, 0.04538409f, 
    -0.01486805f, 0.00676706f, 0.04417520f, -0.00723566f, 0.02218617f, 0.00457596f, 0.04153193f, 0.04655651f, 
    -0.01865783f, -0.04611663f, 0.00283981f, -0.03006652f, 0.03599897f, 0.02981049f, 0.00454951f, -0.05663148f, 
    -0.02095186f, 0.04031229f, -0.04718345f, -0.04193662f, 0.02545234f, -0.01171272f, -0.05864836f, 0.01983816f, 
    -0.02827973f, -0.03803311f, -0.05712824f, 0.01822574f, 0.03913149f, -0.02990192f, 0.04075380f, -0.03565194f, 
    -0.04351931f, -0.03615127f, 0.00687299f, 0.04724993f, -0.04103316f, 0.02544515f, 0.00633619f, 0.04244695f, 
    0.16541056f, -0.16201866f, -0.09088391f, 0.12077364f, -0.00407025f, 0.01616783f, -0.15093628f, 0.12318304f, 
    -0.02116530f, 0.00803644f, 0.03247180f, -0.04979915f, 0.01284044f, 0.14142980f, -0.04222467f, 0.02229685f, 
    -0.01433850f, -0.06850190f, 0.01586159f, -0.05115920f, 0.09415402f, -0.04659362f, -0.05251526f, 0.17383492f, 
    0.32124105f, 0.02301290f, -0.05057857f, 0.08489898f, 0.06178717f, 0.04010941f, 0.09117727f, -0.05209166f, 
    0.07125743f, 0.03780838f, 0.06525177f, 0.07911167f, -0.00485231f, -0.02272379f, -0.06766187f, 0.11715449f, 
    0.06834189f, 0.14544162f, -0.11430078f, 0.13974808f, 0.15847810f, 0.04622970f, 0.02759672f, 0.02722574f, 
    -0.02905343f, 0.03407346f, 0.03112157f, 0.03448905f, -0.05999302f, -0.06866115f, -0.03176947f, 0.02490005f, 
    0.03124472f, -0.01417409f, -0.00863827f, -0.02639754f, 0.22536686f, 0.24557474f, -0.11800486f, 0.03481457f, 
    0.16680776f, -0.05134293f, -0.01395740f, 0.03780576f, 0.00579378f, -0.01331713f, 0.07974357f, 0.07986709f, 
    -0.00986694f, 0.00521982f, -0.07274901f, -0.11739887f, 0.05895803f, -0.04182550f, -0.02419833f, -0.05601885f, 
    0.10961899f, 0.00107004f, -0.06802040f, 0.20433743f, -0.00774955f, 0.15239336f, 0.03400991f, -0.02420377f, 
    0.00741419f, -0.06217650f, -0.04347527f, 0.00425286f, 0.07847530f, 0.03734306f, -0.04558909f, 0.04722044f, 
    0.00372600f, -0.06360514f, 0.05343103f, 0.06679207f, 0.12048683f, 0.09194203f, 0.05087128f, -0.08684552f, 
    -0.12382118f, -0.05194921f, -0.00333134f, 0.04027526f, -0.02655474f, 0.08739322f, 0.04439748f, 0.00537789f, 
    0.11993188f, 0.04894307f, 0.08236428f, 0.04339610f, 0.04722594f, -0.00753963f, -0.03662330f, 0.05138694f, 
    0.11846644f, 0.14862859f, -0.15905303f, -0.06203569f, 0.03725403f, 0.04888160f, -0.06955993f, -0.00215734f, 
    0.06677484f, 0.10692910f, -0.02785380f, 0.09580252f, 0.06987370f, -0.02320416f, -0.01983880f, 0.10539281f, 
    -0.07013319f, 0.00290255f, 0.05159326f, 0.02329347f, -0.05561846f, 0.07034293f, -0.00070549f, -0.01797131f, 
    0.13943499f, 0.10934103f, 0.07856504f, 0.00560300f, 0.00758029f, 0.05087698f, -0.00193399f, 0.03478577f, 
    -0.03119594f, -0.06847340f, 0.00126079f, -0.01712642f, 0.00675735f, -0.02930580f, -0.04002980f, 0.06453253f, 
    0.03881160f, 0.02135544f, 0.14727288f, -0.15111913f, -0.10596581f, 0.00667182f, 0.11258420f, 0.01990780f, 
    0.04163396f, 0.08757030f, 0.02511323f, -0.04819046f, 0.00803169f, 0.01425152f, 0.01913038f, 0.07242642f, 
    -0.06391487f, 0.12893841f, -0.00174504f, -0.01313591f, 0.01540037f, 0.20079570f, 0.08115748f, 0.03984417f, 
    -0.02640171f, -0.00773663f, -0.04675691f, -0.00854021f, -0.06129226f, -0.04652376f, -0.02903330f, -0.02410507f, 
    0.01353383f, 0.02422321f, 0.00025320f, 0.08833297f, 0.01330930f, 0.07210344f, 0.02504887f, 0.01697462f, 
    -0.01602680f, 0.08917147f, 0.01010935f, -0.01206362f, 0.08325542f, -0.04143528f, -0.02101278f, -0.03886671f, 
    0.06231589f, 0.05271619f, -0.04086867f, -0.02903118f, 0.02173987f, 0.06800923f, 0.00996282f, -0.04352498f, 
    -0.05699311f, -0.03212642f, 0.00750922f, -0.05476470f, -0.30171528f, 0.31414980f, -0.09017180f, -0.01807074f, 
    0.05980406f, -0.02175102f, 0.13536441f, 0.00729623f, -0.01641186f, 0.00447898f, 0.00396959f, -0.01741468f, 
    -0.07671407f, 0.12615049f, -0.00503423f, -0.07016432f, 0.05042109f, -0.01640537f, -0.06558704f, -0.03277373f, 
    0.09599761f, -0.22873633f, 0.01684085f, -0.02175406f, -0.05282035f, -0.00826887f, 0.09607637f, -0.04948527f, 
    -0.07716713f, -0.00804219f, 0.01105810f, 0.06722587f, -0.04023058f, 0.04636789f, -0.03668689f, -0.07293416f, 
    0.06247434f, -0.05949705f, 0.04790546f, -0.04094440f, 0.00540743f, 0.03920690f, -0.03305761f, 0.07904679f, 
    -0.10341607f, 0.03269764f, 0.02877956f, 0.07967403f, 0.06691225f, 0.01311709f, -0.01171636f, 0.03027211f, 
    0.04278644f, 0.03554890f, -0.00858121f, 0.05522541f, -0.06072044f, -0.01112075f, -0.00891862f, -0.00022181f, 
    -0.19151627f, 0.15347171f, 0.04998469f, 0.08275078f, -0.01309023f, -0.10281766f, 0.02825469f, -0.02381506f, 
    0.06136516f, -0.08579755f, -0.02539560f, 0.06975537f, -0.04953626f, 0.01057204f, 0.00078680f, -0.00917131f, 
    -0.05817113f, 0.02140671f, -0.07648681f, 0.07061483f, 0.07819259f, 0.18400133f, -0.10014321f, 0.07206521f, 
    -0.09264154f, -0.08350956f, -0.06140511f, 0.02695523f, 0.09023426f, 0.03801624f, 0.08464634f, 0.04948987f, 
    0.08323190f, 0.07451340f, 0.06790543f, 0.15372841f, -0.00684530f, 0.07526608f, -0.04755032f, 0.03898904f, 
    -0.02393868f, -0.04389795f, -0.00120017f, -0.00792115f, 0.04844442f, 0.03662905f, -0.01839714f, -0.05134152f, 
    0.00753002f, -0.03849942f, -0.01613693f, 0.00351999f, 0.03875068f, 0.00615397f, 0.02565848f, 0.04828753f, 
    0.03626386f, -0.03962868f, 0.03933598f, -0.02083797f, -0.02436920f, -0.03265459f, 0.03994996f, -0.00392880f, 
    -0.05870853f, 0.04830004f, 0.00528222f, -0.02367945f, -0.02646203f, -0.01828385f, -0.02757040f, 0.02906748f, 
    0.00926650f, -0.00560584f, -0.05909545f, 0.01919616f, -0.03118378f, -0.00224022f, 0.02255620f, 0.01246749f, 
    -0.03498008f, 0.03786174f, -0.02140816f, 0.00001090f, 0.01838260f, -0.04792708f, -0.05242888f, 0.00051980f, 
    0.00546938f, -0.05447349f, -0.01041610f, 0.01207434f, 0.01825907f, -0.01972420f, -0.04699847f, -0.02080148f, 
    -0.03343482f, 0.02369140f, -0.03535069f, -0.04709970f, 0.01067243f, 0.01365502f, -0.04811487f, 0.01846432f, 
    -0.05753098f, -0.01759766f, 0.01639464f, 0.02644317f, 0.04374627f, 0.00051659f, -0.04637979f, -0.00609828f, 
    -0.01103677f, -0.03288341f, -0.02915980f, -0.00316690f, 0.01438951f, -0.05980568f, -0.04768626f, -0.01088631f, 
    -0.00805234f, 0.03456887f, -0.05782714f, 0.00805511f, -0.02785119f, 0.03133935f, -0.02578713f, 0.01888893f, 
    -0.02193949f, 0.00010840f, -0.02290742f, -0.00265523f, -0.02816342f, -0.02459057f, 0.03306021f, 0.04055084f, 
    0.00064697f, -0.03319162f, 0.04611291f, -0.00056426f, 0.03214559f, -0.05166019f, -0.02609014f, -0.03350027f, 
    0.00443976f, 0.00004367f, -0.06050697f, 0.01039059f, -0.05750598f, -0.01504817f, -0.03395093f, 0.04969945f, 
    -0.03743215f, 0.00960837f, 0.03270481f, -0.04280081f, -0.02791755f, -0.00509910f, -0.05723851f, -0.04307054f, 
    -0.00305081f, -0.03316007f, -0.01165283f, 0.01456809f, -0.03520297f, -0.01987972f, -0.01742851f, 0.00261866f, 
    0.04066627f, -0.05471398f, -0.05812993f, 0.03920899f, -0.02421546f, 0.03133019f, -0.00850981f, 0.00039195f, 
    0.03718331f, 0.02361125f, -0.05018050f, 0.02937272f, -0.03771496f, -0.04789788f, 0.01813759f, -0.04605103f, 
    -0.05726620f, -0.05916363f, 0.01999579f, -0.04475784f, -0.00291290f, 0.02994083f, 0.00516775f, -0.02192588f, 
    0.00911380f, 0.02453145f, 0.04685756f, 0.01887864f, -0.05135406f, -0.04924684f, -0.00404869f, -0.03536154f, 
    0.01760747f, 0.00839116f, -0.01205033f, -0.02580598f, 0.03427930f, -0.01658460f, 0.01806161f, -0.00946850f, 
    -0.04947650f, -0.00939549f, 0.04000649f, -0.02848915f, -0.03478899f, 0.02952928f, -0.05970544f, -0.03084731f, 
    0.03717766f, -0.01300293f, -0.01248165f, -0.04824468f, -0.03192671f, 0.00865323f, -0.05054521f, -0.01460314f, 
    0.02967950f, -0.02572221f, 0.03565015f, 0.04816730f, 0.00761804f, -0.04378928f, -0.04982557f, -0.05809601f, 
    -0.05384962f, -0.03218720f, -0.05618299f, 0.01344975f, -0.01843586f, 0.01242862f, 0.04662863f, -0.01662595f, 
    0.02433063f, -0.00518370f, 0.02062768f, 0.01954452f, -0.00485528f, -0.05181933f, 0.02395586f, 0.00933195f, 
    0.01211864f, -0.01947427f, -0.03128649f, 0.00910314f, 0.01357220f, 0.01913394f, 0.00350393f, -0.03028608f, 
    0.03825572f, 0.00464908f, 0.00859972f, -0.02508335f, 0.02260966f, -0.03126554f, -0.03041472f, 0.01344193f, 
    -0.02620656f, 0.01260218f, -0.05449777f, 0.02853749f, -0.05730261f, -0.00290662f, 0.04852852f, -0.05191343f, 
    0.03253644f, -0.03785535f, 0.04231671f, 0.04194813f, 0.00760919f, 0.04414218f, 0.03393526f, -0.01611640f, 
    -0.03844022f, 0.00835683f, -0.01613858f, 0.00112456f, -0.00104166f, -0.00397728f, -0.03606341f, -0.00796270f, 
    -0.04928842f, -0.01266321f, 0.01190655f, -0.04569418f, 0.04264406f, 0.01085872f, -0.03071157f, 0.04208657f, 
    -0.03236113f, -0.00512349f, -0.02633330f, -0.00565911f, -0.06080189f, 0.00851178f, -0.02330295f, -0.01750311f, 
    0.00557825f, -0.03095877f, -0.02686285f, -0.01685648f, -0.02954526f, -0.06041546f, -0.01172054f, 0.01727373f, 
    -0.03692497f, -0.00212596f, -0.03199955f, 0.01745873f, -0.05266639f, -0.05244599f, -0.01043890f, -0.05524051f, 
    0.03325199f, 0.03538139f, 0.04516737f, -0.04435741f, -0.01990456f, 0.00643920f, -0.02226108f, 0.03089620f, 
    -0.02392945f, -0.04737186f, 0.05035566f, 0.00299633f, -0.00581524f, -0.05404635f, -0.03220902f, -0.00957287f, 
    0.03602609f, -0.03072459f, -0.06061855f, -0.04663799f, -0.00543493f, 0.02919461f, 0.00337469f, -0.00246338f, 
    0.00985549f, -0.02133488f, 0.01295864f, -0.01176967f, 0.00212382f, 0.03317804f, 0.03625881f, -0.00840063f, 
    -0.03225088f, 0.00341662f, -0.02504618f, 0.00748775f, -0.05819672f, 0.03797874f, 0.04195431f, -0.00373471f, 
    0.03204252f, 0.01220537f, -0.02967671f, 0.00522854f, 0.02498866f, 0.04283505f, -0.00911312f, -0.00634869f, 
    0.01962616f, -0.01392038f, 0.02477410f, -0.02514906f, -0.05040645f, -0.05242003f, -0.01678512f, -0.01014843f, 
    -0.03537543f, -0.04938445f, -0.03996968f, 0.01938336f, -0.01475212f, -0.04544641f, -0.04849362f, -0.06199936f, 
    -0.05492718f, 0.02167350f, 0.00856923f, 0.01738288f, 0.03323442f, 0.02066622f, -0.05209137f, -0.02951385f, 
    0.00388953f, -0.05189655f, -0.05923921f, 0.03386328f, -0.00647267f, -0.02365138f, 0.01481487f, 0.00540056f, 
    -0.04460217f, -0.05848002f, 0.02831258f, -0.01385399f, 0.02049068f, -0.01122673f, 0.03927352f, 0.02152990f, 
    0.03255683f, 0.01232857f, 0.04504009f, -0.05323062f, -0.01192077f, -0.04105145f, 0.01845779f, -0.01424644f, 
    -0.04603964f, 0.03916889f, -0.01260129f, 0.03232159f, -0.00441741f, -0.00250242f, -0.05751479f, -0.02938955f, 
    -0.03367874f, -0.03676524f, -0.00023376f, -0.03081334f, -0.05253893f, -0.04584686f, -0.04859020f, -0.03520146f, 
    0.05547459f, -0.01543090f, -0.00092154f, -0.05511274f, -0.01869259f, -0.03879597f, 0.02160772f, -0.03983019f, 
    0.02230826f, -0.03783414f, -0.02026445f, -0.03735005f, -0.04518654f, -0.00710850f, 0.02600669f, -0.04579365f, 
    -0.05971996f, -0.03877334f, 0.02887124f, -0.05071205f, -0.02643285f, 0.02450509f, 0.04195173f, -0.01128923f, 
    0.03823235f, -0.06081715f, 0.02853201f, 0.03746463f, -0.05321818f, -0.05524320f, 0.04678097f, 0.00874495f, 
    -0.04127496f, -0.05625885f, -0.02911715f, 0.04551223f, -0.01554898f, -0.04884898f, 0.01922843f, 0.04258051f, 
    0.00597484f, -0.02610161f, -0.01312564f, -0.05624707f, 0.00822518f, -0.00960637f, -0.04363080f, 0.00346484f, 
    0.04704864f, 0.00695847f, 0.01781757f, -0.05971185f, 0.00509418f, 0.03598692f, -0.02936967f, -0.03571914f, 
    0.01884324f, -0.03701993f, -0.01644473f, -0.04536678f, -0.04325092f, 0.04039823f, -0.01565026f, -0.03260402f, 
    -0.04243362f, 0.01184571f, 0.03475618f, -0.02132081f, -0.06352545f, -0.01344164f, 0.01081613f, -0.04730211f, 
    -0.00354207f, 0.01903708f, 0.04592033f, 0.03850966f, -0.00493966f, -0.06066264f, -0.05285755f, -0.04697105f, 
    0.01822978f, -0.01834924f, -0.00392054f, -0.01414516f, 0.02679434f, -0.00748622f, 0.01836695f, 0.03825735f, 
    -0.02056178f, -0.05762906f, -0.02198872f, 0.02928156f, -0.06203920f, 0.03224312f, 0.02381303f, 0.01657894f, 
    0.05452688f, -0.02987959f, 0.01413281f, 0.02885077f, 0.01885399f, -0.04139341f, 0.00038748f, 0.05359385f, 
    -0.04706991f, -0.01847052f, -0.03058784f, -0.04117266f, 0.01835689f, -0.05411204f, -0.06275036f, 0.03431420f, 
    0.03440320f, 0.02641382f, 0.02781965f, -0.05879882f, -0.01019207f, -0.01166947f, -0.03209828f, 0.00437868f, 
    -0.04951790f, -0.03264586f, -0.02840837f, 0.02187852f, -0.01954836f, -0.05562513f, 0.00249773f, -0.04456449f, 
    -0.04057602f, -0.02902572f, 0.04235823f, 0.04108206f, -0.03972537f, 0.04808315f, 0.01367478f, -0.02325220f, 
    0.02832216f, -0.05452928f, 0.00665667f, -0.04565113f, -0.05809395f, -0.02942466f, -0.05380134f, -0.06204339f, 
    -0.05828903f, -0.05492910f, -0.02867757f, 0.01166539f, 0.00429180f, -0.05418897f, 0.00345954f, 0.00066223f, 
    -0.01873321f, -0.02776010f, -0.01207060f, 0.00459652f, 0.00234032f, 0.03050015f, -0.06320509f, -0.00612483f, 
    0.03980637f, -0.00613208f, 0.00216121f, -0.01574672f, -0.05193994f, -0.05024200f, -0.01240691f, -0.04650935f, 
    -0.02432335f, -0.04671404f, -0.02068186f, 0.00645141f, -0.03714914f, -0.04654770f, 0.01560914f, -0.01176468f, 
    -0.03665588f, 0.04068894f, 0.00754439f, -0.03896048f, -0.05278159f, 0.02668852f, 0.01642773f, 0.00474111f, 
    -0.01846107f, -0.01550890f, 0.01435864f, 0.01045057f, -0.05314447f, 0.04551223f, -0.01227860f, -0.05010215f, 
    -0.01213218f, -0.06232111f, -0.03397685f, -0.05289153f, 0.04442200f, -0.03580748f, -0.04926478f, 0.04191662f, 
    -0.00091168f, -0.00172596f, 0.03154825f, -0.01227785f, 0.01874977f, 0.02960165f, -0.02057131f, 0.02489226f, 
    -0.06227706f, 0.04122933f, -0.00050788f, 0.01291420f, 0.02049249f, 0.04158142f, -0.03264069f, -0.02037774f, 
    -0.01731293f, 0.02995691f, 0.02510843f, 0.00811904f, 0.03790451f, 0.02327739f, 0.03009373f, -0.03150251f, 
    -0.06016401f, 0.01355029f, -0.01975450f, -0.00917914f, 0.00545124f, -0.00939962f, -0.03572793f, 0.01153714f, 
    -0.00132704f, -0.01495087f, -0.02663460f, -0.01528717f, 0.02235655f, -0.05544195f, -0.01421806f, 0.01149216f, 
    0.04203993f, -0.03604868f, -0.01326015f, -0.00684716f, 0.00878923f, -0.04770157f, -0.02614304f, -0.05000759f, 
    0.00318146f, -0.03268173f, -0.04516535f, 0.01713856f, -0.00923755f, 0.04296254f, 0.04492866f, -0.04362269f, 
    -0.04618057f, 0.01858861f, 0.00025490f, 0.01798629f, 0.03145435f, 0.05689501f, -0.00603469f, 0.03798700f, 
    0.02037995f, 0.04234614f, 0.01577140f, 0.00929289f, 0.01888299f, -0.02711917f, 0.02016126f, 0.05293146f, 
    -0.04743521f, 0.01122853f, -0.00289228f, -0.03151523f, -0.02462392f, 0.00962387f, 0.00517923f, -0.02939470f, 
    -0.01368501f, 0.02829472f, -0.00564862f, -0.05480020f, 0.02515117f, -0.05808812f, -0.02119804f, -0.01943636f, 
    0.03126444f, -0.04805043f, 0.04276996f, 0.00601239f, -0.04100342f, -0.05065086f, -0.00515735f, -0.02395952f, 
    0.04476905f, -0.04676146f, -0.03749568f, 0.03511860f, 0.03138867f, 0.01897554f, -0.02654259f, -0.02070340f, 
    -0.02581462f, -0.05239377f, -0.01416771f, -0.03063381f, -0.03306428f, 0.02529333f, 0.03122171f, 0.00899162f, 
    0.02549834f, 0.00898914f, -0.04425419f, -0.03674084f, 0.03146086f, 0.00016977f, 0.03095025f, 0.04836233f, 
    -0.02727517f, -0.05319073f, -0.06396410f, 0.01988818f, -0.02221619f, -0.02289033f, -0.00306122f, -0.02139875f, 
    -0.00131016f, -0.04277235f, -0.05203363f, -0.03741255f, -0.00183046f, -0.02865477f, 0.03661999f, -0.04915395f, 
    -0.04595957f, 0.03787039f, -0.00639640f, 0.02832716f, 0.01739239f, 0.00057346f, -0.02967410f, 0.02861451f, 
    0.02847460f, -0.00428375f, 0.03888543f, -0.01160208f, -0.00574432f, -0.03360512f, -0.03071222f, 0.00201790f, 
    -0.04594265f, -0.01847343f, 0.03733413f, 0.02074226f, -0.02943348f, 0.00748364f, 0.00385988f, 0.04870853f, 
    -0.02791568f, 0.03269815f, 0.02026369f, -0.00287545f, 0.02880699f, 0.02217160f, -0.00666269f, 0.04885055f, 
    0.04243718f, -0.05539544f, 0.00044091f, -0.06005194f, 0.00871073f, 0.00764853f, -0.02498816f, -0.02936875f, 
    -0.01992311f, 0.02627275f, 0.02931227f, -0.00821865f, -0.00496404f, 0.02785154f, 0.00045085f, -0.02216478f, 
    0.01692180f, 0.04866119f, 0.04465845f, -0.01125467f, -0.02751803f, -0.05128276f, 0.00688044f, 0.00263546f, 
    -0.01495810f, 0.03772896f, 0.01153827f, 0.03074620f, 0.01732500f, 0.03873604f, -0.01846114f, -0.02391063f, 
    0.04821116f, -0.02059716f, 0.00193311f, 0.02818336f, 0.01753619f, -0.01565598f, -0.03704267f, -0.00237025f, 
    -0.05587639f, 0.03575244f, 0.00670627f, -0.05862980f, 0.03435146f, 0.01734857f, 0.01549542f, -0.00076483f, 
    0.02583243f, -0.00882391f, 0.00017654f, 0.03472149f, -0.03296001f, 0.00644794f, 0.01042343f, -0.06054882f, 
    -0.05828470f, -0.04295610f, 0.02806508f, 0.00308385f, -0.02393577f, 0.03021001f, 0.02106796f, -0.01778277f, 
    0.00308146f, -0.01376254f, -0.04007154f, -0.04698235f, -0.05208270f, -0.03989331f, -0.02099603f, -0.04402999f, 
    0.01933009f, -0.05678557f, 0.01786933f, 0.02393376f, -0.02918199f, 0.01196182f, 0.00133483f, -0.00960900f, 
    0.00684617f, 0.04029475f, 0.01399816f, -0.04556864f, 0.00395563f, 0.03812905f, -0.03183140f, 0.04910116f, 
    -0.03060711f, 0.00511224f, -0.05467630f, 0.04729201f, -0.04613336f, -0.05640191f, -0.04411516f, -0.04573112f, 
    -0.02211752f, 0.01671206f, 0.03730254f, 0.04645712f, -0.05184670f, 0.01498182f, -0.02169519f, 0.00996367f, 
    -0.04861505f, -0.04777142f, -0.03868462f, -0.03760809f, 0.02443187f, 0.01484722f, -0.03583995f, 0.02159309f, 
    -0.03887012f, -0.05728631f, 0.03668260f, -0.01283013f, 0.04295125f, 0.03308340f, -0.05238668f, 0.00885278f, 
    0.01503746f, -0.01161839f, 0.04394098f, -0.01704255f, -0.02103170f, 0.01515592f, 0.04116054f, 0.01556441f, 
    0.02239444f, 0.02411916f, 0.05140790f, 0.04091817f, 0.02625574f, -0.05067631f, -0.02184213f, -0.01799323f, 
    -0.03096574f, 0.03840843f, -0.03429588f, -0.03484606f, 0.03105047f, -0.04929360f, -0.00314449f, -0.01007218f, 
    -0.03500543f, 0.03985694f, -0.03217186f, -0.01582978f, -0.05375937f, -0.04261942f, -0.01879558f, 0.00596967f, 
    -0.03611879f, 0.04133107f, 0.01210134f, -0.03022350f, -0.00591919f, 0.01312032f, -0.04426424f, -0.03659913f, 
    -0.05336976f, -0.01844050f, -0.05666609f, 0.04382972f, -0.02370019f, 0.00972164f, 0.01031783f, -0.03609219f, 
    0.01307025f, -0.04647495f, -0.00136852f, -0.05482725f, 0.01309930f, -0.04999221f, -0.00956164f, -0.05956344f, 
    -0.03051995f, -0.01479750f, -0.00464541f, -0.04357411f, 0.01916636f, 0.04886852f, 0.01838334f, -0.02033173f, 
    -0.00323423f, -0.01469285f, 0.02862895f, -0.02131153f, -0.04715979f, 0.00033814f, 0.01592989f, 0.04630089f, 
    0.02723771f, -0.01653867f, -0.04861833f, -0.05448678f, 0.03282251f, -0.00310867f, -0.03261353f, 0.03283929f, 
    -0.03369040f, 0.01383761f, 0.03519886f, -0.02165457f, -0.03117378f, 0.02067678f, -0.01904949f, 0.02425228f, 
    0.03155083f, -0.02980163f, -0.03683653f, -0.03711409f, 0.02749095f, -0.05083658f, 0.02837970f, -0.04790307f, 
    0.01487850f, -0.04032776f, 0.00863710f, -0.00190617f, -0.02714088f, -0.05903852f, -0.02875666f, 0.02302484f, 
    -0.01682272f, -0.03613563f, 0.01447258f, 0.01461521f, -0.06371628f, -0.02445473f, 0.02456372f, -0.05954804f, 
    -0.02953649f, -0.06155471f, -0.01041038f, 0.04768415f, 0.02783119f, -0.02653261f, -0.01835091f, -0.03555518f, 
    0.00796795f, -0.04356701f, 0.02355078f, -0.00786348f, -0.00144842f, -0.01737462f, -0.01948373f, -0.00865968f, 
    0.01044024f, -0.02002433f, 0.01907403f, 0.05624999f, 0.00802400f, -0.00562609f, -0.03264479f, 0.00875808f, 
    -0.00550969f, -0.05375101f, -0.01819282f, 0.03758226f, 0.03947279f, -0.02765744f, -0.04414733f, -0.03139288f, 
    0.00848308f, 0.00090359f, -0.02357556f, -0.02248021f, -0.06425040f, -0.02620725f, 0.02505701f, -0.06260296f, 
    0.00895741f, 0.01179845f, 0.01624597f, -0.04482204f, -0.01074118f, -0.03173330f, -0.02631630f, -0.00209836f, 
    -0.02111067f, -0.05124785f, -0.01489710f, 0.00537684f, -0.04234138f, -0.03614838f, -0.00082982f, 0.02935072f, 
    0.01887053f, -0.04888722f, -0.01868396f, 0.03033873f, -0.05759187f, -0.04632365f, 0.04324867f, -0.03394271f, 
    -0.01611034f, -0.06489724f, -0.00376565f, -0.02704825f, -0.03318895f, -0.02737819f, 0.04077084f, -0.01618244f, 
    -0.03889313f, -0.04676514f, -0.02187834f, -0.04011615f, -0.03027820f, -0.00256906f, 0.00033955f, -0.04846590f, 
    0.02654965f, 0.04524018f, 0.04274636f, 0.02501043f, -0.00129109f, 0.01842921f, 0.01033915f, 0.00544772f, 
    0.01726185f, 0.01965511f, 0.00845931f, -0.02318013f, -0.00896236f, 0.02776891f, 0.01790371f, -0.00357325f, 
    0.00046667f, -0.03685968f, 0.00682498f, -0.00655278f, 0.02228115f, 0.01185014f, 0.03965995f, -0.00369808f, 
    -0.04288746f, -0.03664315f, -0.04807773f, -0.02432336f, 0.00493752f, -0.04661186f, -0.02988796f, -0.00944886f, 
    -0.01734136f, 0.05094088f, -0.04648087f, -0.00598891f, 0.02793498f, 0.03232265f, -0.03618034f, -0.05752483f, 
    0.01669544f, 0.03934779f, -0.02780489f, -0.04345689f, 0.02255886f, -0.00625971f, -0.00713898f, 0.03247750f, 
    0.03686891f, -0.04892189f, 0.01499035f, -0.01539094f, 0.01375916f, -0.02157773f, -0.05506293f, -0.02151550f, 
    0.00728701f, -0.04720058f, -0.02814362f, 0.04028799f, 0.02780180f, 0.01005716f, -0.00426890f, -0.02522108f, 
    0.00164671f, 0.03074174f, -0.05850540f, -0.01904494f, 0.04394408f, -0.02868921f, 0.01933219f, 0.00538661f, 
    0.04928054f, -0.00961753f, -0.06407683f, -0.06333246f, -0.06112726f, -0.03704220f, 0.04249289f, 0.04378495f, 
    -0.01740147f, 0.04550181f, -0.05496456f, 0.03016992f, -0.00940700f, -0.05819345f, -0.05147236f, 0.01929064f, 
    0.04644725f, -0.00686879f, 0.02531733f, -0.04593480f, -0.03783017f, 0.00646235f, 0.03148853f, 0.04876129f, 
    0.03761670f, -0.01272031f, -0.01205441f, -0.06349093f, -0.02465666f, -0.02461152f, 0.00651613f, -0.02204375f, 
    0.04242566f, 0.04558022f, 0.02405109f, 0.01585231f, -0.01692344f, -0.05741516f, 0.01920440f, -0.05800618f, 
    0.04223712f, -0.04646368f, -0.01618543f, 0.04168203f, 0.00031729f, -0.00652192f, 0.02930891f, 0.00225772f, 
    -0.02414280f, 0.03176422f, 0.00026631f, -0.01924179f, -0.00010170f, 0.03609999f, 0.01001443f, -0.01692278f, 
    -0.01327999f, -0.00466654f, 0.00763521f, -0.04721347f, -0.01422227f, -0.04005084f, 0.02923330f, -0.01955200f, 
    -0.05451901f, 0.02636450f, -0.03852972f, -0.05076325f, -0.02024421f, -0.06079809f, 0.03206302f, 0.02471560f, 
    -0.02618088f, -0.05899705f, 0.03312255f, 0.02179957f, -0.06115649f, -0.01028065f, 0.01629176f, -0.01839497f, 
    0.00058767f, 0.00907393f, -0.01290933f, -0.03940285f, -0.04901058f, -0.01398014f, 0.00139219f, 0.02111448f, 
    0.01505957f, -0.04679247f, -0.04487443f, -0.04359803f, 0.03535831f, -0.03163140f, -0.04810450f, -0.01222297f, 
    0.04605855f, -0.01012523f, -0.01783293f, -0.02684019f, -0.03726944f, 0.01319524f, -0.05520866f, -0.03554808f, 
    -0.02695450f, -0.01480661f, 0.00837215f, -0.05899258f, -0.02365478f, 0.00376129f, 0.01710165f, 0.02757825f, 
    0.03645420f, 0.00900845f, -0.04189997f, -0.01068037f, 0.02262173f, -0.00933739f, -0.03226889f, -0.01404122f, 
    0.04569278f, -0.04218794f, 0.03374749f, 0.01460233f, -0.06013647f, 0.04455454f, 0.04304022f, -0.02585992f, 
    -0.02633834f, -0.01014324f, 0.03875364f, -0.05723632f, 0.05495257f, 0.03882401f, -0.02264598f, -0.03903277f, 
    0.18758325f, 0.08835492f, -0.01852178f, 0.04909018f, -0.06914593f, -0.01083128f, 0.01786958f, 0.15042607f, 
    -0.00043774f, 0.07173370f, 0.06829099f, 0.04637623f, 0.04320600f, -0.00339946f, 0.04876119f, 0.02908760f, 
    -0.01554364f, -0.01618792f, -0.11920059f, 0.01975074f, 0.18779702f, 0.20917721f, -0.01652093f, 0.13283440f, 
    0.12151829f, 0.08228588f, 0.02917641f, 0.01589948f, -0.02294095f, 0.00082171f, 0.06899038f, 0.01702891f, 
    0.02504368f, 0.11132497f, 0.04718489f, 0.16118295f, 0.00194121f, -0.04140641f, 0.02925715f, 0.03195970f, 
    -0.03125007f, 0.21493624f, 0.04762414f, 0.05361310f, 0.13303412f, 0.11466510f, -0.02017744f, 0.13436213f, 
    0.03360917f, 0.05038744f, -0.06085533f, -0.04500923f, -0.04217412f, -0.03070450f, 0.03620055f, -0.06069160f, 
    0.01583697f, 0.03113137f, -0.08354140f, -0.06588138f, 0.09128108f, -0.00633357f, -0.12375189f, -0.20100233f, 
    0.12296986f, -0.02407588f, -0.02835834f, -0.01658401f, -0.00523613f, -0.05389982f, -0.04803881f, 0.00557764f, 
    0.03585111f, 0.04062662f, 0.05076984f, 0.01716234f, 0.09237022f, 0.02337164f, 0.02037355f, 0.01113690f, 
    0.18343252f, -0.12823585f, -0.01386025f, 0.09090184f, 0.02462313f, -0.08339032f, 0.05773942f, 0.10583930f, 
    -0.09704667f, 0.03010901f, -0.04924121f, -0.03718369f, 0.01801406f, -0.00383189f, -0.08063637f, 0.18259621f, 
    -0.06419466f, -0.04320193f, 0.02005219f, 0.03274953f, 0.11673437f, 0.02500407f, 0.04947149f, -0.03967934f, 
    0.02643150f, 0.09876152f, 0.02821717f, -0.03985978f, 0.03195309f, 0.13323948f, 0.02869308f, -0.09828019f, 
    0.06645144f, -0.08594116f, 0.10300379f, -0.01769220f, 0.00485887f, 0.06310213f, 0.10410646f, -0.06584162f, 
    0.10176132f, 0.02020098f, -0.11854204f, -0.02361522f, 0.01404880f, 0.09072692f, -0.06500675f, 0.06167600f, 
    -0.04950300f, 0.16844989f, -0.07249578f, -0.02278973f, 0.04015328f, -0.04404312f, 0.00453698f, 0.05516744f, 
    -0.10098309f, 0.02345680f, 0.11414229f, 0.07932853f, -0.08750385f, -0.05026970f, 0.02648315f, 0.09044886f, 
    0.09770029f, 0.08785170f, 0.00910047f, 0.03155098f, -0.04858270f, 0.13143122f, -0.03405644f, 0.10038182f, 
    0.00744345f, -0.10609155f, 0.03099300f, 0.01679229f, -0.02471441f, -0.01734552f, -0.00238222f, 0.05397580f, 
    -0.08138651f, -0.06832316f, 0.15910400f, 0.04364320f, -0.03803134f, 0.04449316f, 0.04678475f, 0.04732402f, 
    -0.00867639f, 0.13355044f, -0.03873715f, -0.02898330f, -0.04805216f, 0.07927373f, 0.08063090f, 0.13225237f, 
    0.02900350f, 0.02889137f, -0.02311787f, -0.05316567f, 0.15562887f, 0.12764549f, -0.10736014f, -0.15145241f, 
    -0.09994162f, -0.04277448f, 0.09206049f, 0.02407366f, -0.05447231f, -0.05625351f, 0.01216966f, 0.05396524f, 
    0.09363651f, 0.07306761f, 0.06414295f, 0.09051526f, -0.02670776f, -0.01806986f, -0.00922075f, 0.01373551f, 
    -0.14093947f, 0.17034057f, -0.17504330f, -0.04780013f, 0.02180393f, -0.02859182f, 0.06966084f, -0.02736314f, 
    0.08543289f, 0.00164111f, -0.03164775f, -0.03323340f, -0.01392800f, 0.03127021f, 0.01660352f, 0.05440382f, 
    -0.04137940f, 0.00511462f, 0.12582169f, 0.00098403f, -0.35204703f, 0.26958171f, -0.10889168f, -0.14984605f, 
    0.12348285f, -0.08139075f, 0.00990574f, 0.05666166f, -0.00861756f, 0.01251292f, 0.03921793f, 0.02813542f, 
    0.04365900f, 0.10006244f, 0.06160291f, -0.08031634f, 0.04705134f, 0.06754066f, 0.02362898f, 0.03215780f, 
    0.14829879f, -0.39155409f, 0.03064207f, -0.11442979f, 0.07311164f, 0.13040388f, -0.03428011f, -0.03192480f, 
    0.02193533f, 0.11247166f, 0.00380135f, -0.01444481f, -0.06133895f, 0.11359913f, 0.02616865f, 0.00654187f, 
    0.08526900f, 0.01166664f, -0.05291584f, -0.00052465f, 0.01139049f, -0.15508522f, 0.13380726f, -0.01057368f, 
    -0.03135594f, 0.00496146f, 0.03278210f, 0.11031548f, -0.02811866f, 0.07010650f, 0.02969271f, 0.02948847f, 
    0.05536178f, 0.04092400f, 0.04825750f, 0.09866057f, -0.01900489f, 0.09940883f, -0.11845484f, -0.02434988f, 
    -0.16601872f, 0.02481844f, -0.07210747f, 0.06974162f, -0.09082237f, -0.07116733f, 0.11056425f, 0.04640671f, 
    0.08973403f, 0.00981577f, -0.02440861f, 0.13477029f, 0.00818238f, 0.07495203f, 0.01509327f, 0.01226221f, 
    -0.00312945f, 0.02082545f, -0.09786905f, -0.04226278f, 0.16790159f, 0.54295802f, -0.11895187f, 0.04745455f, 
    -0.06156402f, -0.02857973f, 0.04049582f, 0.15801787f, 0.09098694f, 0.09148004f, 0.09345681f, 0.04310295f, 
    0.01468910f, 0.06505600f, 0.03727609f, 0.04422876f, -0.02177246f, -0.09131703f, -0.12308630f, -0.07711219f, 
    -0.04232967f, -0.00944302f, 0.04352102f, -0.03874976f, -0.02320205f, 0.00550526f, 0.02310152f, -0.02924784f, 
    0.01029616f, 0.02348000f, 0.03230475f, -0.05786748f, -0.01495331f, -0.01975669f, -0.02036875f, -0.05894817f, 
    -0.05430829f, -0.02136698f, 0.00735402f, 0.04133306f, -0.05194690f, 0.03202464f, 0.04794121f, -0.01359221f, 
    -0.03743179f, -0.00156600f, 0.04102968f, 0.04367593f, 0.04251698f, 0.04789003f, 0.02113066f, 0.03647893f, 
    0.03671093f, -0.02813106f, 0.04629223f, -0.06013338f, -0.01619836f, -0.05284271f, -0.01575475f, 0.00048459f, 
    -0.02863847f, -0.05098301f, 0.01752247f, -0.03443326f, -0.04534970f, -0.01750528f, -0.00202982f, -0.02028440f, 
    -0.03369300f, 0.02608598f, 0.01060911f, -0.04324206f, -0.02005713f, 0.01135301f, -0.05009035f, 0.01622852f, 
    0.03638161f, 0.01276250f, 0.04254165f, -0.00314209f, 0.02545111f, -0.00143387f, -0.03695235f, 0.04670270f, 
    -0.00877894f, -0.04082704f, 0.01985616f, -0.01735497f, 0.00398593f, 0.01040784f, -0.01568292f, -0.06075225f, 
    0.02171229f, -0.02434903f, -0.02531598f, 0.04176944f, 0.02752692f, 0.02061374f, -0.01124249f, 0.00512567f, 
    -0.05714669f, -0.05265149f, -0.04861968f, 0.02695785f, -0.03307227f, -0.00909201f, -0.01633838f, -0.05041949f, 
    -0.03417498f, -0.00430378f, 0.00816336f, -0.02378387f, 0.03492515f, 0.01987183f, -0.02215361f, 0.02816141f, 
    0.00769501f, -0.05134431f, 0.01958906f, -0.03431594f, 0.02329203f, 0.01026647f, -0.00646958f, 0.02737423f, 
    0.01449469f, 0.02543835f, 0.02879426f, -0.04171154f, -0.00194605f, -0.01687543f, -0.02622104f, -0.05026885f, 
    0.01154871f, 0.02025043f, -0.04262981f, -0.02749489f, 0.00181646f, 0.04656642f, 0.00045308f, -0.05418291f, 
    -0.05714603f, 0.04679643f, 0.02335126f, 0.03841396f, -0.04887918f, -0.01617783f, -0.04302922f, -0.03923388f, 
    -0.05365315f, -0.05262139f, -0.02486717f, -0.02266471f, 0.01967808f, -0.04085856f, -0.04128766f, -0.03768186f, 
    -0.05927840f, 0.03760640f, -0.03110084f, -0.01859275f, 0.03818967f, 0.04124113f, 0.03223098f, 0.04158713f, 
    0.01760539f, 0.03201544f, 0.02942328f, -0.02055201f, -0.02110725f, -0.05445996f, 0.02665862f, 0.03665076f, 
    -0.00542925f, -0.05672849f, -0.03948374f, -0.00272194f, 0.01626593f, 0.04966033f, -0.01089791f, 0.03603677f, 
    0.03559209f, 0.02662746f, -0.00545340f, -0.02480565f, 0.00583840f, -0.01723476f, -0.01390873f, 0.01029990f, 
    0.02194928f, -0.04526111f, -0.05228063f, -0.00388271f, 0.02543966f, -0.03562688f, -0.01382039f, -0.04813549f, 
    -0.00157398f, -0.06043592f, -0.03441831f, 0.03890159f, 0.03136388f, 0.04445207f, 0.01023072f, 0.01327930f, 
    -0.03392293f, -0.04940778f, -0.03197269f, 0.03591665f, -0.03568015f, 0.01862896f, -0.02042878f, 0.04872124f, 
    -0.01545036f, -0.03828529f, -0.05147322f, -0.01070997f, -0.04919892f, 0.04747178f, 0.01897472f, 0.00234950f, 
    -0.01734551f, -0.01478665f, -0.04326322f, -0.01112359f, 0.04738541f, 0.02310824f, 0.04174196f, -0.03552582f, 
    -0.02102588f, 0.00628609f, -0.02179023f, -0.03611081f, 0.01366319f, 0.03342078f, -0.04620326f, -0.03398858f, 
    -0.00907291f, -0.04279694f, 0.01380113f, 0.00997785f, -0.02125146f, 0.04923152f, -0.04361864f, -0.02176031f, 
    -0.03025935f, 0.02821399f, -0.03161259f, -0.04323682f, 0.04610574f, -0.05287922f, 0.00513221f, -0.05013324f, 
    -0.04871433f, -0.02123142f, -0.04289486f, -0.02267489f, 0.01526262f, -0.04205844f, -0.02749521f, -0.04393079f, 
    0.04034704f, -0.01868016f, -0.02153282f, 0.00987084f, -0.02839750f, -0.01478291f, 0.01417466f, 0.01508633f, 
    -0.05106314f, -0.05505054f, 0.02770783f, 0.02079050f, -0.04354659f, -0.03549788f, 0.00248977f, -0.00087843f, 
    0.01158558f, 0.01062778f, -0.00473010f, -0.04160820f, -0.02951020f, 0.02670443f, 0.02247913f, 0.00740385f, 
    0.00027879f, -0.02087203f, -0.04648206f, -0.04121551f, -0.04498448f, 0.01395675f, -0.05266205f, -0.01680612f, 
    0.04148359f, 0.01860906f, 0.04122379f, -0.05117970f, 0.02465638f, -0.03454920f, -0.03825198f, -0.03474105f, 
    -0.04728832f, -0.02054696f, -0.02469994f, 0.04405267f, 0.03965801f, -0.01845973f, -0.01878055f, 0.00661839f, 
    0.02247793f, 0.03791001f, 0.00703404f, -0.01558633f, 0.00538919f, 0.02601151f, 0.01805574f, -0.01907641f, 
    0.02001356f, -0.01709887f, 0.00262236f, 0.01435283f, 0.01764703f, -0.03782848f, -0.02093224f, -0.05658743f, 
    -0.04413294f, 0.01227982f, -0.01371195f, -0.01663668f, -0.05894661f, 0.03667392f, -0.01245024f, 0.03257459f, 
    -0.01533511f, 0.03386512f, -0.05118781f, 0.01458240f, -0.06121416f, -0.04880847f, -0.03717127f, -0.03709185f, 
    -0.01961549f, 0.05618185f, -0.04350672f, -0.05725557f, -0.05180025f, 0.00902613f, 0.02488224f, -0.01995889f, 
    -0.03609424f, -0.00553382f, -0.03383190f, -0.00809204f, 0.05462230f, -0.02172312f, 0.00899107f, 0.05150009f, 
    -0.02887219f, -0.00543082f, -0.04981133f, -0.00316095f, 0.02619007f, 0.03849380f, 0.03111876f, -0.03681122f, 
    0.03320058f, -0.04057339f, 0.00726159f, 0.02319370f, 0.01222150f, -0.05205272f, -0.02577405f, 0.01574790f, 
    0.03848341f, -0.00767870f, 0.04257411f, -0.05208324f, 0.04563428f, 0.02376435f, -0.05396730f, -0.01799005f, 
    -0.05988358f, 0.01423626f, -0.02455801f, 0.00257200f, 0.00977057f, 0.05196331f, 0.04582005f, -0.00334330f, 
    -0.05205861f, -0.05563501f, -0.03780106f, 0.01508369f, -0.00767209f, -0.03701672f, -0.04810594f, 0.04413597f, 
    -0.02190831f, 0.01417871f, 0.02696557f, -0.03788833f, -0.00308106f, 0.01068645f, 0.03610434f, 0.01399090f, 
    0.04290047f, -0.04284019f, 0.05014708f, -0.03428758f, 0.02933634f, 0.03919855f, -0.03954900f, 0.02506127f, 
    0.00589182f, -0.02184757f, 0.00491507f, -0.03018913f, 0.03582733f, -0.03427840f, 0.03563821f, 0.02985724f, 
    0.05178168f, 0.02065631f, 0.01103461f, 0.01587457f, 0.01656225f, -0.01603659f, -0.04143968f, -0.01669296f, 
    0.04566588f, -0.03749340f, -0.05224617f, -0.04702713f, -0.05342880f, -0.04054102f, 0.03351839f, -0.03607223f, 
    -0.03425685f, 0.01572977f, -0.02175615f, -0.01136395f, -0.01822248f, 0.00792000f, 0.03405658f, -0.03166764f, 
    0.02290308f, -0.01747905f, 0.03611970f, 0.02667097f, 0.01702132f, -0.03258042f, 0.01641867f, 0.02809550f, 
    -0.04634944f, 0.05129408f, -0.02154610f, 0.00062090f, 0.00771467f, -0.04335934f, -0.01936373f, -0.02354494f, 
    -0.00630986f, -0.05941161f, -0.05176310f, -0.00688169f, -0.02629252f, -0.04899070f, -0.04420661f, -0.02561974f, 
    -0.03927844f, -0.06392147f, 0.02033150f, 0.04600343f, 0.02758000f, 0.00391011f, 0.03146292f, -0.02116522f, 
    -0.01711549f, 0.01016083f, 0.01454484f, -0.01424554f, 0.00882935f, -0.00456876f, -0.04596655f, -0.05731779f, 
    0.03862070f, -0.02796774f, -0.04275305f, -0.01457182f, 0.02540865f, 0.04476208f, 0.01536271f, 0.00941094f, 
    -0.03343035f, -0.00466991f, -0.05637509f, -0.01061316f, -0.03529881f, -0.04073520f, -0.03527124f, -0.01661139f, 
    0.00186972f, -0.04389489f, -0.05241957f, -0.02519781f, -0.03982327f, -0.02050090f, 0.00720379f, 0.02713606f, 
    0.01789232f, 0.00484841f, 0.04698099f, -0.01593093f, 0.05352006f, 0.00862262f, 0.03932820f, 0.03875222f, 
    0.02350339f, -0.03401237f, -0.00250210f, -0.01264144f, -0.06164632f, -0.05762456f, 0.03927842f, -0.04184311f, 
    0.02880862f, -0.02916325f, -0.02365257f, 0.05142721f, -0.03106127f, -0.05490585f, -0.00099701f, 0.03116940f, 
    -0.00667086f, -0.02707154f, 0.03629917f, -0.01069819f, 0.01488071f, -0.05651009f, 0.00318223f, 0.02480485f, 
    -0.01904971f, 0.01268622f, 0.04334455f, -0.01272645f, -0.04374875f, -0.04783618f, -0.00604277f, 0.01658378f, 
    -0.01027713f, -0.01689264f, 0.02800074f, -0.02127015f, -0.04050129f, -0.05191294f, -0.00630086f, -0.05274425f, 
    -0.04902336f, 0.01172738f, 0.02402559f, -0.05850203f, -0.00765945f, -0.05103805f, -0.00821125f, -0.00438991f, 
    -0.01328497f, -0.04218183f, -0.03968042f, -0.04437736f, 0.01370193f, 0.03840071f, -0.05848426f, -0.03476011f, 
    -0.04808645f, 0.03500132f, 0.02389902f, 0.03405822f, 0.03665854f, 0.01284482f, -0.00270427f, 0.02096879f, 
    -0.06017811f, 0.01805620f, -0.06109540f, 0.02508111f, 0.01661867f, 0.02325397f, 0.01101224f, -0.04303737f, 
    0.00755080f, -0.06220108f, -0.04261034f, 0.03275397f, -0.05832887f, -0.00646959f, -0.05219989f, -0.06235475f, 
    0.00818404f, 0.01116240f, 0.01738380f, 0.04798863f, -0.02275521f, 0.04280886f, -0.01705840f, -0.04428348f, 
    0.00404072f, -0.05708447f, -0.01362427f, -0.02395846f, 0.02868841f, 0.00622641f, 0.02307996f, -0.01321406f, 
    -0.00493718f, 0.04639878f, -0.00232165f, -0.06158411f, 0.04249910f, 0.00359629f, 0.01235138f, 0.03474246f, 
    0.03041399f, -0.05936957f, -0.04923518f, -0.02445427f, -0.05771473f, -0.00499066f, -0.05437997f, 0.04532100f, 
    0.04560275f, -0.05740841f, 0.01575511f, 0.03307268f, -0.02272649f, -0.00566294f, -0.05811157f, 0.01825776f, 
    0.03175868f, 0.02583653f, -0.01267798f, -0.04787032f, 0.04282741f, 0.01861747f, 0.02264863f, -0.00310851f, 
    -0.02324253f, -0.01514987f, 0.00439056f, -0.04975813f, 0.00374331f, -0.00546358f, -0.01959996f, -0.02541865f, 
    0.01647772f, -0.04967830f, -0.03121106f, 0.00039975f, 0.03487331f, 0.03570738f, 0.01172898f, -0.04941024f, 
    -0.03705444f, -0.04954481f, -0.01864777f, 0.02288308f, 0.00497669f, -0.02262968f, -0.01118053f, 0.00140763f, 
    0.02527551f, -0.02371974f, 0.00197934f, -0.00068857f, -0.04410251f, 0.02570513f, -0.01665169f, 0.05234676f, 
    0.02657096f, -0.00545870f, -0.04449549f, -0.01228017f, 0.00509150f, 0.04011382f, -0.02101945f, 0.02362585f, 
    -0.00093617f, 0.01403926f, 0.00719654f, -0.03977831f, 0.03641133f, 0.03123330f, 0.00831588f, -0.05281018f, 
    -0.05951461f, -0.03988516f, -0.01921166f, -0.00039264f, -0.01803600f, -0.06015261f, 0.01184149f, -0.04627910f, 
    -0.04213000f, -0.01045982f, 0.00645426f, -0.02302467f, -0.05280341f, -0.01398155f, 0.03313271f, 0.01836893f, 
    0.00064349f, -0.02869315f, 0.00967632f, 0.02731897f, -0.01641663f, 0.03655241f, 0.00606790f, -0.00660465f, 
    0.04843586f, 0.03790395f, -0.00335439f, 0.04395256f, -0.05598127f, -0.00055593f, -0.05340880f, -0.01658130f, 
    0.03605705f, 0.01718056f, -0.01201244f, 0.00963097f, 0.00245949f, -0.04892795f, -0.00407633f, 0.02932077f, 
    -0.02440336f, -0.02211861f, -0.04265029f, -0.00449531f, -0.04620769f, -0.03047024f, -0.04479528f, 0.00292849f, 
    -0.00971848f, 0.04186894f, -0.01969752f, 0.00845499f, -0.04808358f, 0.02222068f, -0.01637269f, 0.04597498f, 
    -0.04570837f, 0.03206036f, 0.00417133f, -0.05290904f, -0.04757140f, -0.01614488f, -0.00794699f, 0.05283317f, 
    -0.00053834f, 0.05217834f, -0.00964703f, -0.01991487f, 0.02391585f, -0.03953184f, -0.01197341f, -0.02704122f, 
    -0.02193145f, 0.00475283f, -0.00633162f, 0.03563612f, -0.03330378f, -0.03381719f, 0.02983177f, 0.02214048f, 
    -0.05813192f, -0.03875204f, -0.02725025f, -0.04336654f, -0.04830317f, 0.02439089f, -0.00021492f, 0.02710153f, 
    -0.03230359f, -0.05313639f, 0.00624187f, 0.02865071f, 0.03517338f, 0.01660119f, -0.02577702f, 0.02209405f, 
    -0.00450899f, -0.03138258f, -0.01243618f, -0.05084516f, 0.02027204f, -0.02927805f, 0.03708103f, -0.04158534f, 
    -0.01491093f, 0.02154047f, -0.04905687f, -0.03047095f, -0.02126861f, -0.02734091f, 0.04106532f, 0.04986442f, 
    -0.03859427f, 0.01425289f, -0.04496383f, -0.02456928f, -0.06307844f, 0.02874586f, -0.02772735f, 0.00900085f, 
    -0.05961556f, -0.00589225f, 0.02479329f, 0.02805456f, -0.05675480f, -0.02645731f, -0.03467397f, 0.04004345f, 
    0.05573262f, -0.01663538f, 0.05055135f, -0.01846027f, -0.00276717f, 0.05005807f, 0.00082611f, 0.00243632f, 
    -0.04275450f, 0.03522873f, -0.01207274f, 0.05701871f, -0.03116655f, -0.05035595f, 0.04078560f, 0.02957851f, 
    0.03052584f, -0.02732680f, 0.05487143f, -0.03613022f, 0.00919197f, -0.05270758f, 0.00920097f, -0.01824341f, 
    -0.03481357f, 0.03904881f, 0.02609546f, 0.01401666f, -0.00963326f, -0.02718316f, -0.05822472f, -0.04990442f, 
    -0.04404169f, -0.04989453f, 0.02560783f, 0.00663023f, -0.05305478f, -0.01167933f, 0.00266250f, 0.01481221f, 
    0.03343469f, -0.03928264f, 0.03886536f, -0.03342427f, -0.05828159f, -0.05830501f, -0.02821683f, -0.01433121f, 
    -0.00895709f, 0.03665172f, -0.05093909f, -0.03028686f, 0.05122148f, 0.00686953f, 0.05086007f, 0.05095026f, 
    -0.01461525f, -0.06043173f, 0.04113395f, 0.02728429f, -0.02247242f, -0.05618333f, -0.04125828f, -0.01545608f, 
    -0.02832385f, -0.04422848f, 0.01734511f, -0.01429564f, -0.01083147f, 0.01154745f, 0.02217123f, 0.04268917f, 
    0.04686771f, -0.02639378f, 0.03600526f, -0.01924208f, -0.05810060f, -0.03763533f, -0.03390165f, 0.02355130f, 
    0.03633786f, 0.04917162f, 0.03146684f, -0.03801230f, 0.01240505f, -0.05419306f, -0.03295701f, 0.00361045f, 
    0.02573261f, -0.01609975f, -0.05781830f, 0.01048159f, 0.03443851f, 0.03394181f, 0.02579524f, -0.02377493f, 
    0.03364455f, -0.00041100f, 0.04610831f, 0.00678697f, -0.04220964f, 0.00946242f, -0.02982964f, 0.05186648f, 
    0.00021481f, 0.00821676f, -0.05343134f, 0.02642309f, -0.01606859f, 0.02539600f, -0.02930329f, -0.04138391f, 
    -0.01853692f, 0.02633472f, 0.02482799f, -0.04935186f, 0.01814745f, -0.01598250f, -0.00406552f, -0.03574715f, 
    0.05325665f, -0.03105371f, 0.04300316f, 0.00282087f, 0.03015584f, 0.04938419f, -0.04456677f, 0.02482367f, 
    -0.02945706f, -0.05890084f, -0.02914504f, 0.03159159f, 0.03433110f, -0.01210720f, -0.03885796f, -0.03295558f, 
    -0.04191759f, 0.03790880f, -0.02869540f, -0.02787854f, -0.01696336f, -0.01075541f, 0.04422423f, 0.00644148f, 
    0.03232493f, 0.01246797f, -0.01625499f, -0.00879019f, 0.05149451f, 0.03043733f, 0.02564355f, 0.01936382f, 
    -0.02921990f, -0.02569530f, -0.03692518f, 0.00752285f, -0.02723266f, -0.05726243f, -0.04625061f, -0.00073991f, 
    -0.06185412f, 0.16645338f, 0.16952258f, 0.21405558f, 0.23194800f, -0.00571088f, -0.05470596f, 0.03944810f, 
    0.04301473f, -0.04615101f, -0.01150647f, -0.02404738f, 0.00950751f, -0.02352085f, -0.03522690f, -0.04224020f, 
    -0.04136468f, -0.04335899f, -0.07227521f, 0.03638317f, -0.01647705f, 0.37600431f, -0.06899164f, 0.05328450f, 
    -0.12035175f, 0.04215541f, 0.07228650f, -0.03229320f, 0.03431955f, -0.00996359f, -0.04604658f, -0.10374054f, 
    -0.02035830f, -0.07365206f, -0.05147960f, 0.03772770f, -0.01464024f, -0.03734487f, -0.03057762f, 0.00997158f, 
    0.09950521f, 0.04134427f, 0.12743874f, -0.09587248f, 0.07275847f, -0.04340801f, -0.10328611f, -0.02853373f, 
    0.10791951f, 0.09311365f, -0.05024879f, -0.03153650f, -0.01748935f, -0.01209419f, -0.13204244f, -0.00477090f, 
    -0.06254073f, 0.01244617f, -0.04011645f, -0.09483428f, -0.06934136f, -0.08563108f, 0.01093738f, -0.23284274f, 
    -0.08732544f, -0.07992380f, -0.08875406f, 0.00699158f, -0.01812616f, -0.03312710f, -0.06535361f, -0.01277917f, 
    0.14614640f, 0.00180637f, 0.00884598f, -0.04857989f, 0.10588739f, 0.07175182f, -0.03149162f, -0.08061863f, 
    0.25832275f, 0.11350760f, 0.02890369f, 0.06366016f, 0.05836409f, 0.02737772f, -0.00864067f, 0.12537745f, 
    -0.03332881f, 0.05861016f, -0.05963082f, 0.05392516f, 0.00177551f, -0.00542933f, -0.08443239f, 0.06113860f, 
    0.00074610f, 0.02723117f, 0.03671001f, -0.05993026f, 0.07862911f, 0.04069605f, -0.09631717f, 0.03007567f, 
    0.01639045f, 0.05475578f, -0.08852214f, -0.01385991f, 0.02477980f, 0.10879371f, 0.02004536f, -0.03006750f, 
    -0.00870748f, -0.06641236f, 0.12409341f, -0.04294094f, -0.07818124f, 0.10530154f, -0.01236911f, -0.04006065f, 
    0.08430138f, -0.21737024f, 0.04543847f, 0.04768121f, -0.05417959f, 0.00902284f, 0.02180905f, 0.08434329f, 
    0.05434523f, 0.13130145f, -0.01973702f, -0.06546022f, -0.08944830f, -0.03453863f, 0.05783293f, 0.01228034f, 
    -0.02157247f, -0.04441496f, 0.14999317f, 0.11640816f, 0.10818210f, -0.17849359f, 0.08084406f, 0.12135670f, 
    -0.07311603f, -0.01556789f, 0.04727969f, -0.04272212f, 0.00676309f, -0.00183865f, 0.05681415f, 0.00210979f, 
    0.10334591f, -0.02085357f, -0.01676132f, -0.00980437f, -0.03504328f, -0.06684462f, 0.13993332f, 0.03796098f, 
    0.22426830f, 0.05312066f, 0.24194348f, 0.00367373f, 0.14599450f, -0.04201229f, -0.10198571f, -0.04047641f, 
    -0.02019520f, 0.00561060f, -0.08326863f, -0.05882107f, 0.00430388f, 0.00233682f, 0.04102505f, 0.05596825f, 
    -0.05612772f, -0.03167950f, 0.02320506f, 0.01661552f, 0.26162878f, 0.07743745f, -0.16171649f, -0.15082856f, 
    -0.26890853f, -0.05653260f, 0.04309011f, -0.03575397f, -0.03762667f, -0.00776407f, 0.12295855f, 0.04618500f, 
    -0.00733111f, 0.03265862f, 0.11036610f, 0.10529353f, -0.02525933f, -0.07460511f, -0.01189729f, 0.05385151f, 
    0.01821039f, -0.10438151f, -0.22636767f, 0.00725157f, -0.24322475f, 0.04521639f, -0.06825212f, 0.05816444f, 
    0.02257304f, -0.08815588f, -0.03757812f, 0.04143031f, 0.08171912f, 0.00673965f, 0.02250593f, 0.07637382f, 
    -0.04889967f, -0.07095341f, 0.05300150f, -0.00034211f, -0.10479198f, 0.09456128f, -0.13498424f, -0.01409176f, 
    0.02266470f, 0.16017315f, -0.04220450f, 0.02374614f, -0.05195820f, -0.03887053f, 0.00765356f, -0.04162317f, 
    0.11042058f, -0.05822074f, -0.00227647f, 0.03341600f, 0.01941804f, 0.08210296f, 0.17486538f, -0.03831255f, 
    0.30359203f, -0.22808541f, -0.05853259f, -0.21160255f, 0.25469193f, -0.02389933f, 0.03284706f, -0.08739699f, 
    0.09980902f, 0.04661823f, 0.02133647f, 0.03808866f, -0.05647173f, 0.09658203f, -0.05988138f, 0.09912907f, 
    0.03132731f, 0.07377022f, 0.03577189f, 0.08777568f, 0.14418426f, 0.06306712f, 0.24667379f, 0.01173053f, 
    0.11467436f, -0.16206942f, 0.03143897f, -0.01679632f, 0.06719651f, -0.05321217f, 0.01403700f, 0.06411155f, 
    -0.01477055f, 0.10465132f, 0.09351994f, 0.07946187f, 0.06683279f, 0.09962571f, -0.12130776f, 0.00704775f, 
    0.11509342f, -0.15210205f, 0.04672021f, 0.09905422f, -0.32262713f, -0.13788377f, 0.01499077f, 0.00191468f, 
    -0.08510944f, 0.04538999f, -0.01924770f, 0.08792178f, 0.06097221f, 0.03086988f, 0.07584411f, -0.04136714f, 
    0.06860553f, -0.00690031f, -0.00578363f, 0.00056870f, -0.07852718f, 0.42574945f, 0.02418274f, 0.25796431f, 
    0.01718129f, -0.01608074f, -0.04666998f, 0.08886573f, -0.03415339f, -0.04428511f, -0.09575125f, -0.05250197f, 
    -0.00429487f, 0.04795711f, -0.04888463f, 0.02660652f, -0.01028979f, -0.03996122f, -0.12517340f, -0.23718858f, 
    -0.01205546f, 0.07519310f, -0.14340591f, 0.06450234f, -0.19050479f, -0.02149172f, 0.05590831f, 0.06255854f, 
    0.07031249f, 0.06728797f, 0.14478226f, -0.00222864f, 0.00845850f, -0.06053857f, -0.00639122f, 0.07874100f, 
    -0.00086252f, 0.02768830f, -0.06679796f, 0.01975379f, -0.03508294f, 0.09590093f, 0.14497812f, 0.29660580f, 
    0.13582103f, -0.01410641f, 0.13926041f, 0.03205529f, -0.03840614f, 0.11983854f, 0.01337222f, 0.05698808f, 
    -0.09477351f, -0.04776202f, 0.06577318f, 0.02357055f, -0.01531030f, 0.10438006f, 0.10149367f, 0.01167838f, 
    0.21910948f, -0.00118269f, -0.13655803f, 0.16642220f, -0.17115702f, 0.06953835f, 0.08296136f, 0.15375622f, 
    0.01448015f, 0.04041110f, 0.07535674f, 0.05278718f, 0.05296547f, -0.06543886f, -0.00584221f, -0.04458404f, 
    0.03511374f, -0.07334309f, -0.08314078f, 0.02603579f, -0.18746221f, -0.02863971f, -0.21842334f, -0.22360702f, 
    0.05600767f, -0.10871690f, -0.01801990f, -0.05451877f, 0.08915838f, -0.11000995f, -0.04261212f, -0.04499341f, 
    0.00052528f, 0.04664539f, 0.13199697f, 0.09049410f, -0.01927235f, 0.03108916f, 0.08951102f, 0.06052043f, 
    0.50989163f, 0.25821298f, -0.05733139f, -0.02537506f, 0.10855770f, -0.07870773f, 0.13544224f, 0.06991398f, 
    0.10308009f, 0.05626737f, 0.00680858f, -0.03527408f, -0.07298641f, 0.00437442f, -0.00856565f, 0.09363893f, 
    0.12863080f, 0.07111197f, 0.12166873f, 0.09793767f, -0.16990919f, 0.09278433f, 0.09623819f, 0.05999914f, 
    -0.09727357f, 0.23447707f, 0.13862355f, 0.03584949f, -0.06720886f, -0.01436714f, -0.09309429f, -0.03748671f, 
    -0.04502343f, -0.00338955f, -0.03422883f, -0.05992008f, 0.03017405f, 0.04269792f, 0.03855766f, -0.12303824f, 
    0.16222695f, 0.11960319f, -0.22569160f, 0.08237813f, 0.07178687f, -0.01070366f, -0.01593472f, 0.05153454f, 
    0.04288806f, 0.04018347f, 0.00800987f, -0.01838636f, -0.00597252f, -0.04603058f, -0.07779802f, -0.05748539f, 
    0.05817523f, 0.06955893f, 0.09652341f, 0.07815683f, -0.19786911f, 0.04157845f, 0.00030687f, 0.06479208f, 
    0.02567784f, 0.07716297f, 0.09293719f, 0.06584901f, -0.13512819f, -0.05018979f, 0.08095580f, 0.04791584f, 
    0.00727399f, -0.12239881f, 0.05321195f, 0.04158636f, -0.03414290f, -0.04692396f, 0.03384271f, -0.10894267f, 
    -0.29963446f, -0.22872749f, 0.02503864f, 0.01588041f, 0.00737359f, 0.11543282f, 0.00039047f, -0.06754578f, 
    0.05642206f, 0.09900747f, -0.14788564f, -0.05788953f, 0.05147706f, 0.13971096f, -0.01611038f, 0.02017975f, 
    -0.10724108f, -0.15143384f, -0.07951070f, -0.12716207f, -0.13281931f, -0.18852544f, 0.03715651f, -0.24635641f, 
    0.11664703f, -0.01162953f, -0.08926992f, 0.05335015f, -0.06216227f, -0.03670813f, -0.04687178f, -0.03065339f, 
    0.12670690f, 0.00681711f, -0.01241051f, -0.07509378f, 0.06244082f, -0.01347947f, 0.04629328f, -0.03050058f, 
    -0.15500842f, 0.13756819f, -0.00823180f, -0.06875541f, 0.13784131f, 0.00564851f, -0.00931896f, 0.02630813f, 
    -0.09482978f, 0.04285346f, 0.06963924f, 0.05206729f, 0.01947127f, 0.01185982f, 0.07810380f, 0.00387369f, 
    -0.00401538f, 0.01692468f, 0.25459132f, 0.07367779f, -0.03950626f, 0.36798066f, 0.07842263f, -0.04681359f, 
    -0.02382924f, -0.04535023f, -0.08542158f, 0.19826975f, 0.00834555f, -0.02491412f, -0.04387182f, 0.04424072f, 
    -0.02366517f, 0.00359907f, 0.06086687f, 0.08204947f, -0.04017369f, 0.05142507f, 0.09682342f, 0.00194349f, 
    -0.19004691f, -0.10336333f, -0.15870151f, -0.00197710f, 0.03344990f, 0.02831023f, -0.05427869f, 0.11103472f, 
    -0.01149685f, 0.04812368f, -0.02426262f, 0.03870003f, -0.05678649f, 0.13943620f, -0.03125812f, 0.04033108f, 
    -0.02759783f, 0.00890552f, -0.06112356f, 0.01338442f, 0.15960705f, -0.12440201f, -0.16809791f, 0.14473598f, 
    -0.11538562f, 0.06528687f, 0.00787625f, 0.09983633f, 0.10053085f, 0.13088027f, -0.11179976f, -0.03707235f, 
    0.07713728f, 0.03280661f, 0.02942033f, -0.01233198f, 0.06141287f, 0.08255442f, -0.08702771f, -0.01883925f, 
    0.01631492f, -0.29053175f, -0.11478847f, -0.13683297f, 0.02527929f, -0.09599875f, 0.02902319f, -0.02962444f, 
    0.15364245f, 0.00923549f, -0.02100804f, 0.04429508f, -0.04112322f, 0.12295319f, 0.08298533f, 0.01570930f, 
    0.01076115f, -0.08268597f, -0.05600560f, 0.02835182f, -0.17736351f, 0.18068452f, 0.06623621f, 0.13883227f, 
    0.08303710f, -0.06027322f, -0.05881690f, 0.17616841f, 0.07069271f, 0.05372740f, 0.08945888f, 0.01989231f, 
    0.05649015f, -0.05928223f, 0.03191417f, 0.02778642f, 0.02545961f, -0.15524045f, -0.01275869f, -0.03091004f, 
    -0.20604245f, -0.01004807f, 0.19259548f, 0.12148587f, 0.08484374f, 0.04658893f, 0.14739192f, 0.06175823f, 
    -0.04572340f, -0.04689224f, -0.03456018f, 0.03228151f, 0.05828006f, 0.00455666f, 0.06137255f, 0.03271863f, 
    -0.07004108f, 0.01630897f, -0.17028394f, 0.04613639f, -0.21175161f, 0.22010128f, 0.11132806f, 0.03836190f, 
    -0.11186845f, 0.12085637f, 0.21530540f, 0.05397258f, -0.11624116f, -0.10073327f, 0.03588646f, 0.03452823f, 
    -0.00511033f, -0.09016960f, 0.01793128f, 0.00578558f, 0.06166386f, -0.00157058f, -0.07586285f, -0.02320681f, 
    -0.07022926f, -0.07919003f, -0.20893832f, 0.05621072f, -0.26941314f, 0.04134701f, 0.00433432f, 0.07460260f, 
    -0.03346490f, 0.02967007f, 0.01438666f, -0.01631595f, 0.04789627f, -0.01323722f, -0.05481642f, 0.06244138f, 
    0.06832414f, 0.02763364f, 0.06846425f, -0.15958256f, -0.56281555f, -0.04357024f, -0.01358210f, -0.17154330f, 
    0.01686767f, -0.06676199f, -0.03984725f, -0.14517137f, 0.04996401f, 0.00212747f, -0.02945963f, -0.03556103f, 
    0.02564423f, -0.02018592f, 0.11211966f, -0.04609843f, 0.08761662f, -0.02840784f, 0.18943386f, 0.03210574f, 
    0.21287794f, 0.11773898f, -0.09196353f, -0.06735443f, -0.01748774f, 0.08615007f, 0.11196575f, 0.04841666f, 
    -0.02864249f, 0.11183043f, -0.07007413f, 0.04165526f, 0.00977406f, -0.03959472f, -0.02570485f, -0.04508056f, 
    0.07630709f, 0.00462273f, 0.04658057f, 0.07202670f, 0.08321156f, 0.12189370f, -0.06669992f, -0.11852078f, 
    -0.05142162f, 0.16654783f, 0.09493670f, -0.02044999f, -0.00331489f, -0.07059938f, 0.01468758f, -0.06679872f, 
    0.04827265f, -0.11111200f, 0.03369231f, -0.06255589f, -0.01943406f, 0.05686565f, 0.02764706f, 0.06977462f, 
    0.09016715f, -0.09200657f, -0.03502095f, 0.02542294f, -0.19485915f, 0.06120730f, 0.02286618f, -0.00450759f, 
    0.03058361f, 0.02006412f, 0.06603720f, -0.02491278f, 0.05150104f, 0.01447766f, -0.01887139f, -0.01043981f, 
    0.07124138f, 0.07662074f, -0.00804215f, 0.15657350f, 0.28913862f, -0.12616210f, 0.03964700f, 0.08464710f, 
    -0.15418348f, 0.05004096f, 0.14968754f, 0.15138415f, 0.05915768f, -0.03437835f, 0.01570629f, -0.02023251f, 
    -0.01396414f, 0.05574280f, -0.00069863f, 0.01112034f, -0.05733836f, 0.04857944f, 0.02262916f, -0.01968944f, 
    -0.01815698f, 0.08510645f, 0.25923002f, 0.02817625f, 0.13045663f, -0.01240718f, -0.01236244f, -0.00852954f, 
    -0.00063550f, -0.04067605f, 0.03592831f, -0.08196712f, 0.03496531f, 0.04985725f, -0.01838344f, 0.05128791f, 
    -0.06365470f, -0.05337866f, -0.00068942f, -0.04384724f, 0.12828578f, -0.11251201f, -0.06984873f, -0.01046285f, 
    0.20710683f, -0.05601742f, -0.11384284f, -0.07280589f, 0.02882170f, 0.07220848f, 0.02911705f, -0.07494329f, 
    0.01922004f, 0.01823328f, 0.15495944f, -0.01201824f, 0.03366291f, -0.00772371f, 0.06712016f, 0.11467216f, 
    0.15897274f, -0.09775500f, -0.04357473f, -0.01990416f, -0.15001851f, 0.08167265f, 0.05877113f, -0.05477010f, 
    -0.04007051f, -0.07259657f, 0.01750264f, 0.01386893f, -0.04309336f, 0.03431853f, -0.03652497f, -0.04620690f, 
    -0.04527253f, 0.12037840f, 0.06430768f, 0.03022630f, -0.00374946f, 0.21072619f, -0.24867770f, -0.08276652f, 
    -0.17166933f, 0.05242652f, 0.03909706f, 0.10170934f, -0.12855947f, 0.03522472f, -0.04835168f, 0.08054534f, 
    0.05716075f, 0.01732780f, -0.03312932f, -0.02012097f, 0.03691258f, -0.02516730f, 0.06904437f, -0.00024789f, 
    -0.01943959f, -0.02992479f, 0.06270061f, -0.01859320f, 0.03142741f, -0.00418071f, -0.08914908f, -0.02335318f, 
    0.06909316f, 0.03280351f, 0.05157495f, 0.00671794f, -0.02702015f, -0.01861524f, -0.03426863f, 0.04719100f, 
    -0.11573860f, -0.05023934f, -0.00384995f, 0.02618293f, 0.13518649f, 0.02469213f, 0.06629935f, 0.14508493f, 
    0.02730820f, 0.07185795f, -0.09038677f, -0.06269877f, 0.02484185f, 0.07989629f, -0.09661473f, -0.05844098f, 
    0.08104818f, 0.03730480f, 0.10974682f, -0.05264832f, 0.07827201f, 0.08334128f, -0.04935602f, -0.04396044f, 
    0.28008270f, -0.07507806f, -0.12976411f, -0.06711498f, 0.07084686f, -0.10253363f, -0.04925651f, -0.12533087f, 
    0.01402966f, 0.01435796f, 0.08635371f, -0.01100604f, -0.00502802f, 0.05569036f, 0.12291128f, -0.04714171f, 
    0.01113101f, -0.03889978f, 0.10508168f, 0.03993123f, -0.17142974f, 0.20690180f, 0.01864819f, 0.24083270f, 
    0.04303658f, 0.14145172f, 0.05553870f, 0.06796852f, -0.04828025f, -0.12951000f, -0.07035312f, 0.02434615f, 
    -0.02342469f, 0.05402999f, 0.04795943f, 0.02005482f, 0.03560312f, -0.06283668f, -0.07791175f, -0.03735025f, 
    -0.05734836f, -0.04487547f, 0.00656178f, -0.02685545f, 0.02315922f, -0.04121116f, -0.02126283f, -0.03469353f, 
    -0.01266765f, -0.00735734f, -0.02682651f, -0.01627673f, -0.01641631f, 0.05321303f, -0.04595435f, 0.04544046f, 
    -0.00180217f, -0.04605368f, -0.02196925f, -0.01779331f, 0.00584888f, 0.05396397f, 0.04197649f, -0.01716427f, 
    0.01776443f, 0.06746587f, 0.02667635f, 0.03392199f, 0.02650163f, 0.05801322f, -0.00288094f, 0.00385024f, 
    0.01875537f, 0.00703889f, 0.04783939f, 0.03492809f, 0.04360448f, 0.01513283f, -0.04024111f, -0.05352750f, 
    -0.02440314f, -0.01860769f, -0.02922536f, -0.02138434f, 0.06908173f, -0.04090952f, 0.01913186f, -0.04289217f, 
    -0.03423006f, 0.00711437f, 0.01173111f, 0.03486190f, 0.03705005f, 0.04995859f, 0.00159501f, 0.01291125f, 
    -0.05104299f, 0.00192643f, -0.01504850f, 0.01371442f, -0.01853533f, 0.00704205f, 0.00471752f, -0.05482027f, 
    0.02074572f, -0.04420755f, -0.05874124f, 0.05057506f, -0.01462632f, 0.03959905f, 0.03980980f, -0.02104245f, 
    0.01957560f, 0.02283306f, -0.04206638f, 0.00486936f, 0.06008546f, -0.05272400f, -0.05631260f, -0.03632857f, 
    -0.00809113f, -0.04202351f, -0.05359942f, 0.02675407f, -0.04340483f, 0.00730221f, 0.03604428f, 0.01832123f, 
    -0.04100359f, 0.03034773f, 0.03430288f, -0.02918432f, -0.04389285f, 0.02718440f, -0.03714383f, 0.00778502f, 
    -0.02774881f, 0.05149972f, -0.02567906f, 0.05191146f, -0.00395244f, 0.06317649f, 0.02406168f, -0.03389101f, 
    -0.03092808f, 0.00127132f, 0.02410556f, -0.01482665f, 0.03971796f, -0.06182984f, -0.04665655f, -0.00556759f, 
    0.01460252f, -0.02917563f, 0.04995509f, 0.03494583f, -0.00794994f, -0.01832687f, -0.03880453f, 0.01766908f, 
    0.04010635f, -0.02014046f, -0.01227451f, -0.06394428f, 0.02766182f, 0.01246362f, 0.04312386f, 0.03744318f, 
    -0.05522458f, -0.04653579f, 0.00774134f, -0.02442902f, 0.05665313f, -0.01166568f, 0.00586962f, 0.05040528f, 
    -0.02327103f, -0.06982114f, 0.04130387f, -0.05271937f, 0.01639422f, 0.03840084f, -0.06582061f, -0.03361297f, 
    0.04914930f, -0.04971575f, -0.04053112f, 0.02448012f, 0.02366695f, 0.00349026f, -0.01739327f, -0.04449576f, 
    -0.02051943f, 0.01321817f, 0.01141948f, -0.01685716f, 0.05287103f, -0.04247126f, -0.03872253f, 0.02859168f, 
    0.00448081f, 0.02089248f, -0.05292534f, -0.01266980f, 0.00644618f, -0.02945308f, -0.01724713f, 0.03112106f, 
    -0.00533650f, 0.01441617f, -0.05867594f, -0.00641546f, -0.04577217f, -0.06130673f, -0.05854119f, 0.00772950f, 
    -0.00552240f, -0.01535538f, -0.00444935f, -0.05484114f, -0.01180632f, -0.03415561f, -0.01892837f, -0.07700939f, 
    -0.04029623f, 0.00125539f, -0.05315074f, 0.00535254f, -0.03369358f, -0.05214389f, 0.00471833f, -0.00742802f, 
    0.02653963f, -0.04866591f, 0.03265658f, 0.00097670f, 0.01613527f, 0.05373742f, -0.03633982f, -0.03176938f, 
    0.06326946f, 0.02048964f, -0.02300581f, -0.02965727f, 0.02583840f, 0.03663255f, -0.03300320f, 0.05019138f, 
    0.04686440f, -0.02624764f, -0.02964291f, -0.01453918f, -0.02330760f, 0.01177739f, -0.03328906f, -0.03633576f, 
    0.01631787f, 0.03678900f, -0.00603089f, 0.00460376f, -0.02880181f, 0.02672520f, 0.02926738f, -0.01797858f, 
    -0.05722677f, -0.01892103f, -0.03377449f, 0.03892423f, -0.04786191f, -0.05513012f, -0.05502054f, 0.00915005f, 
    -0.04718007f, 0.05126601f, -0.03621539f, 0.04689950f, 0.05056595f, -0.01405524f, 0.00837352f, 0.04142125f, 
    0.01676878f, 0.00241879f, -0.06122559f, 0.00970812f, -0.02604464f, -0.04193665f, -0.02466007f, 0.01856826f, 
    0.03540812f, -0.04367711f, 0.00418633f, -0.03022358f, -0.04638328f, -0.06781225f, 0.00023665f, 0.03250938f, 
    -0.00538070f, 0.03485322f, -0.02995913f, -0.05063817f, 0.01757476f, 0.02860381f, -0.01572146f, 0.01254687f, 
    -0.00792948f, -0.02530846f, -0.04164288f, 0.03696169f, -0.03668671f, -0.00461912f, 0.01272507f, -0.06211869f, 
    -0.07046301f, -0.02906043f, -0.03867994f, 0.00191638f, -0.00183509f, 0.02787855f, -0.04220438f, -0.03137097f, 
    0.00833766f, 0.00156431f, 0.00569032f, -0.00554697f, -0.03810315f, -0.02743436f, 0.03068093f, 0.02471287f, 
    0.05372619f, 0.04163104f, -0.00301096f, -0.02701252f, -0.01078786f, 0.03604938f, -0.01866769f, -0.05140796f, 
    0.03043218f, 0.04020034f, -0.01102854f, -0.00346987f, -0.04284696f, -0.06979212f, 0.01634482f, -0.01636840f, 
    0.01666065f, 0.06305370f, -0.05258091f, -0.05536065f, 0.03581187f, 0.03504565f, -0.04084319f, -0.01219522f, 
    -0.05600670f, 0.00578390f, 0.01995648f, -0.01222768f, -0.03760840f, -0.04818594f, 0.05601440f, -0.01328901f, 
    -0.18793219f, 0.25464010f, 0.05615929f, 0.13642228f, -0.08655690f, -0.00694621f, -0.04541214f, 0.03420447f, 
    0.07275473f, -0.12313534f, 0.00983896f, -0.04627769f, -0.03493003f, -0.07204236f, 0.01006633f, 0.06923542f, 
    -0.04270722f, 0.03451054f, -0.05859554f, 0.02886830f, -0.07296742f, -0.01592642f, 0.14117256f, 0.04323603f, 
    -0.07419557f, -0.05615224f, 0.03628138f, -0.04913108f, -0.05373365f, 0.04128436f, -0.11923639f, 0.02857386f, 
    -0.07832102f, -0.01123013f, 0.03400607f, -0.02245767f, -0.00880342f, 0.10057363f, 0.12302118f, 0.00252537f, 
    0.13272218f, 0.22873722f, -0.01656166f, 0.05740023f, -0.26889375f, -0.01302679f, 0.12166511f, 0.04144541f, 
    0.04559758f, 0.07925022f, -0.06185019f, 0.04439725f, 0.04926875f, -0.07392528f, -0.05707667f, -0.00353557f, 
    0.00557340f, 0.00151047f, -0.10419165f, 0.10640662f, -0.06393086f, 0.11118510f, -0.00103433f, 0.01339521f, 
    0.13244796f, 0.04318327f, 0.12795967f, -0.07572553f, 0.07456425f, 0.00901693f, -0.05768619f, 0.03167813f, 
    0.00460020f, 0.02572856f, 0.04963579f, 0.01766472f, -0.03607628f, 0.13120930f, 0.03426158f, 0.10234484f, 
    0.14153592f, 0.03893275f, 0.16741206f, 0.12791610f, -0.11220212f, 0.00718323f, 0.05312261f, 0.00045227f, 
    0.11068844f, -0.00859929f, -0.04369045f, -0.03988229f, -0.02118548f, 0.06020835f, 0.02830712f, 0.03774596f, 
    0.09595740f, 0.00098631f, 0.01098158f, 0.04212338f, -0.29880261f, -0.06139809f, 0.22595121f, 0.04174604f, 
    0.01133467f, 0.12428336f, 0.03988035f, 0.01298940f, 0.06653440f, -0.07091182f, -0.01584801f, 0.09939960f, 
    -0.09201169f, -0.00397088f, -0.12149581f, -0.11060860f, -0.01374269f, -0.04272857f, 0.06330559f, -0.05157039f, 
    -0.03798167f, 0.02341631f, -0.03891514f, 0.07644732f, 0.15551428f, -0.07158364f, -0.00289083f, -0.11763673f, 
    -0.02843700f, -0.00194593f, 0.05188862f, 0.02981082f, -0.01183181f, -0.05439127f, -0.04783954f, -0.18143944f, 
    0.03318816f, 0.05692928f, 0.09234509f, 0.03462912f, 0.01611576f, 0.11410861f, 0.01648113f, 0.02435403f, 
    -0.01108540f, -0.04588888f, -0.06327671f, -0.04562047f, -0.06792767f, 0.06037208f, 0.05508114f, -0.06157301f, 
    0.06265827f, -0.07145929f, -0.02252120f, -0.02939547f, 0.02252208f, 0.01198595f, 0.04571072f, -0.06036521f, 
    -0.15741579f, -0.15491016f, 0.01730597f, 0.07288552f, 0.05852449f, -0.01558819f, 0.01421818f, -0.05389064f, 
    0.06948640f, -0.08574399f, -0.03015717f, -0.04250170f, -0.09309956f, 0.07919507f, 0.04672905f, 0.02929319f, 
    -0.02667016f, -0.07403018f, -0.14164129f, -0.00066442f, -0.08594751f, -0.02570918f, 0.08573719f, -0.05100850f, 
    0.19688599f, 0.06028017f, -0.03528232f, 0.05658882f, -0.02752663f, -0.00112130f, -0.04048016f, 0.00339775f, 
    0.13127290f, 0.03338657f, 0.02815049f, -0.01017779f, 0.00022572f, -0.06299891f, 0.02696822f, 0.03028408f, 
    0.14797524f, -0.17565361f, -0.01310093f, 0.09341773f, 0.18695661f, 0.02757090f, -0.02814964f, 0.08906602f, 
    -0.06633405f, 0.01524053f, 0.11108584f, 0.01716553f, 0.00571673f, -0.03024510f, 0.04282862f, 0.00444543f, 
    0.03181555f, 0.11627289f, 0.14077418f, 0.01740980f, 0.29861599f, -0.24807876f, 0.12899406f, 0.17963688f, 
    -0.13875790f, 0.04780800f, -0.06322643f, 0.05833847f, -0.03256561f, -0.02693406f, -0.01401274f, 0.04820720f, 
    -0.05779118f, 0.04003409f, -0.02552856f, 0.09298828f, -0.03151882f, 0.00740014f, 0.07641644f, -0.02973860f, 
    -0.21774104f, 0.17350543f, -0.06093272f, 0.04716537f, 0.21757117f, 0.03999361f, 0.02390221f, 0.01555748f, 
    0.08469927f, -0.00565928f, 0.06163257f, -0.00473683f, -0.04415090f, 0.03164492f, 0.03085041f, 0.05336757f, 
    0.02276726f, 0.16240688f, -0.07926676f, 0.05092445f, 0.03294608f, 0.18143187f, 0.00327958f, 0.13344274f, 
    -0.16598088f, 0.02559630f, 0.05318433f, 0.10693353f, -0.02512870f, 0.02439584f, 0.00943947f, 0.00034508f, 
    0.04742854f, 0.01436585f, -0.06980132f, 0.06678586f, 0.05127316f, 0.04596010f, 0.01852461f, 0.07058768f, 
    0.01961843f, -0.21007659f, -0.02450430f, -0.03797489f, 0.18276517f, 0.15774314f, 0.01327927f, -0.03758823f, 
    -0.02868314f, -0.00239771f, 0.03632655f, 0.04381526f, -0.00745196f, 0.03704000f, -0.04869710f, -0.04159508f, 
    -0.02690453f, -0.05890710f, 0.04189031f, -0.02729593f, -0.06239842f, -0.06206588f, 0.15139489f, 0.09844530f, 
    -0.12042818f, -0.05129269f, -0.04884964f, 0.01544501f, -0.00335180f, -0.02972356f, -0.02861853f, -0.02945920f, 
    0.02668232f, -0.10251742f, -0.00466523f, -0.11983002f, 0.00571216f, -0.14272191f, 0.07694990f, 0.00249759f, 
    -0.15824823f, 0.02454486f, -0.05804412f, -0.32875603f, -0.09310135f, -0.14690751f, -0.07680806f, -0.16884935f, 
    -0.22003755f, -0.06632484f, -0.00274238f, -0.04951678f, -0.12912084f, 0.06245501f, -0.08519693f, 0.13271159f, 
    0.04290765f, -0.00475824f, -0.08455446f, -0.11986963f, 0.13174911f, -0.00383681f, 0.00706734f, -0.07945158f, 
    -0.02610767f, -0.03865959f, -0.04008631f, -0.13988522f, -0.06918260f, 0.10580505f, -0.11442226f, 0.07926158f, 
    -0.06661598f, -0.06140684f, -0.01311581f, 0.09685048f, 0.02414305f, 0.01449443f, 0.11831116f, -0.05633782f, 
    -0.00094327f, 0.00764159f, 0.02861975f, -0.09836193f, 0.18380019f, 0.01853016f, 0.08940066f, -0.07748476f, 
    -0.03698768f, -0.13317037f, -0.06393087f, 0.13832600f, 0.01411668f, -0.01708649f, 0.18455081f, 0.06247601f, 
    0.06970703f, -0.07396546f, -0.04167670f, 0.08494224f, 0.42805585f, 0.03127570f, 0.06232526f, 0.03232731f, 
    0.04661919f, 0.01957557f, -0.10120579f, 0.13407686f, 0.08353183f, 0.02799089f, -0.01407212f, -0.10046392f, 
    -0.05588074f, -0.01289444f, 0.10045009f, 0.14895749f, -0.06806851f, 0.14748526f, -0.00458201f, 0.07791645f, 
    0.01530605f, 0.26286569f, 0.02149614f, -0.00599805f, 0.25502166f, 0.02562820f, 0.07944608f, -0.18507992f, 
    0.03190986f, 0.03673824f, -0.03870857f, 0.05606744f, 0.04269568f, 0.12340897f, 0.13850446f, 0.15437704f, 
    -0.03020249f, -0.08385184f, -0.03423543f, -0.03758034f, -0.06474643f, 0.02903878f, 0.01460720f, 0.03012421f, 
    0.03511311f, 0.08005604f, 0.10221551f, -0.00314952f, -0.00005717f, 0.05413189f, -0.11432254f, 0.09506082f, 
    -0.16664803f, -0.05096867f, 0.00937773f, 0.03011861f, 0.04747584f, 0.04176573f, 0.08434932f, -0.01011376f, 
    0.27751327f, -0.04300828f, 0.07136186f, 0.07795585f, 0.03103088f, -0.01909355f, 0.04744460f, 0.11268581f, 
    -0.01461080f, -0.01326639f, -0.05300188f, -0.07066347f, 0.00323762f, -0.06775649f, 0.03236003f, -0.05680021f, 
    -0.00374457f, 0.12647323f, 0.16646467f, 0.03189135f, -0.01173344f, 0.13838555f, -0.03831606f, -0.04717768f, 
    -0.04734250f, -0.03671553f, 0.10719845f, 0.07936358f, -0.08258318f, 0.03147954f, -0.07118787f, -0.02636262f, 
    0.12857467f, -0.15992652f, 0.04099498f, -0.00794351f, -0.00428984f, -0.01331205f, 0.03440984f, 0.03833690f, 
    -0.19253586f, -0.18887034f, -0.35380375f, -0.24057269f, -0.12943015f, -0.10663486f, 0.07315794f, 0.10059542f, 
    -0.04236361f, -0.04289798f, -0.04992032f, -0.09129068f, 0.11954887f, 0.01121045f, 0.16126618f, 0.01115773f, 
    0.18534894f, -0.18935525f, -0.25078443f, 0.02555840f, 0.10930984f, 0.05223773f, 0.20846446f, -0.02687663f, 
    -0.10628506f, 0.06615813f, -0.00818711f, 0.07505471f, 0.15017238f, 0.12236302f, -0.07084090f, -0.00277118f, 
    0.06632907f, 0.07558510f, -0.05198890f, -0.05844629f, 0.07824585f, -0.05127767f, 0.01967499f, -0.03581336f, 
    0.11111899f, 0.13907576f, -0.02931170f, 0.20032924f, 0.05138085f, 0.00491390f, 0.06792593f, 0.06471109f, 
    0.10264492f, 0.04396263f, 0.00729682f, 0.09896103f, 0.00508871f, -0.11678291f, -0.05593030f, 0.04948186f, 
    0.18150051f, -0.07338149f, 0.13069473f, 0.09214660f, 0.32569411f, -0.00728314f, 0.11176950f, 0.04783979f, 
    0.08002676f, 0.06065870f, 0.03951333f, -0.07782980f, 0.02769819f, 0.08300447f, -0.10666230f, 0.04755786f, 
    0.03023981f, -0.02680700f, 0.10107528f, 0.07848312f, 0.12951377f, -0.10722654f, 0.03434610f, 0.08635986f, 
    -0.04036408f, 0.10215675f, 0.09554587f, 0.05967134f, 0.07690089f, -0.03771713f, -0.01117394f, 0.23301111f, 
    0.07831997f, 0.01148486f, 0.05900806f, -0.04481952f, 0.10905681f, 0.03523451f, 0.16534384f, 0.11278638f, 
    0.12418503f, 0.08918066f, -0.21882401f, -0.03779833f, 0.08253349f, -0.07794975f, -0.06335843f, -0.24625225f, 
    -0.16519065f, -0.00414154f, 0.09351549f, -0.01881298f, -0.05445753f, -0.00493848f, 0.06325207f, -0.03517787f, 
    0.10497937f, 0.07982463f, 0.00680303f, 0.06563968f, 0.05146933f, -0.14812434f, -0.07146861f, 0.05306938f, 
    0.20881894f, 0.06653748f, 0.15954646f, -0.05779826f, 0.06580041f, 0.07278066f, 0.03248939f, 0.00319706f, 
    0.09016054f, 0.05024844f, 0.00362298f, -0.01958892f, -0.00379296f, 0.10406359f, 0.04574009f, 0.00150669f, 
    0.05625755f, -0.01753471f, -0.17740193f, -0.11025566f, -0.12684716f, -0.15156443f, -0.11168373f, -0.18517146f, 
    0.03528298f, -0.07551520f, 0.01713618f, -0.29630423f, -0.14353789f, -0.03622206f, -0.01709489f, -0.06754678f, 
    -0.04790647f, 0.00118986f, 0.06669798f, 0.07651032f, 0.12351679f, -0.19589688f, -0.00054074f, 0.00255159f, 
    0.19194253f, -0.13998775f, 0.04155421f, 0.17425920f, 0.25840241f, -0.05061554f, -0.05431261f, -0.12503570f, 
    -0.01589656f, 0.15090606f, -0.02072201f, -0.05254473f, -0.00451971f, 0.12437882f, -0.00996041f, -0.05263041f, 
    0.04066321f, -0.07658980f, -0.02429068f, -0.02585297f, -0.17672664f, -0.27826193f, -0.12087203f, 0.06061895f, 
    0.07018439f, -0.01239879f, -0.05732781f, 0.06935526f, -0.01227599f, 0.00153084f, 0.06004202f, 0.07278069f, 
    0.01197088f, 0.01784634f, -0.00983638f, 0.02439757f, 0.04756105f, -0.05696643f, -0.05171013f, 0.07824082f, 
    0.14888497f, -0.26928985f, -0.11473670f, -0.01353850f, 0.00148959f, -0.13381132f, -0.09624366f, -0.01472141f, 
    -0.01192637f, -0.11457999f, 0.02860880f, 0.03497112f, -0.04516218f, 0.00677565f, 0.04603697f, -0.07483620f, 
    0.00394610f, 0.04336341f, 0.09626759f, -0.12699717f, -0.12065083f, 0.01624285f, 0.02842454f, 0.15737961f, 
    -0.05091326f, 0.00842606f, -0.03811761f, 0.03058874f, 0.02191252f, 0.10007988f, 0.08615729f, 0.05817483f, 
    0.09003858f, -0.04376217f, -0.06835625f, -0.10218370f, 0.11153184f, -0.01197424f, -0.00941461f, 0.01672995f, 
    0.00856430f, 0.11532553f, -0.01280347f, -0.07979642f, 0.04022681f, 0.10548837f, 0.03030752f, -0.08974515f, 
    0.10895454f, 0.03253018f, 0.11221862f, 0.05664236f, 0.06970047f, 0.03345887f, 0.02685107f, -0.02487858f, 
    -0.02904272f, -0.08103879f, 0.02611220f, 0.07235957f, -0.00200171f, 0.08052741f, -0.12215696f, 0.01683612f, 
    -0.04598074f, -0.03224060f, 0.01581445f, -0.00039534f, 0.00417991f, -0.01299693f, 0.12148757f, -0.04650514f, 
    0.06003946f, 0.02532027f, 0.02790361f, 0.02094091f, 0.08723506f, -0.08232392f, -0.08524998f, 0.00276601f, 
    0.00512617f, 0.25308815f, -0.03469883f, 0.03701742f, -0.11375965f, 0.01337064f, 0.05834300f, 0.00502657f, 
    0.17447282f, 0.00209064f, -0.03664612f, 0.06797981f, 0.04986995f, 0.04093685f, 0.05762492f, 0.09955022f, 
    -0.00052784f, 0.00372920f, -0.02123510f, 0.02287946f, -0.04225433f, -0.10864573f, 0.03953811f, -0.01681956f, 
    0.01235718f, 0.12594151f, -0.04506432f, -0.03179490f, 0.10421332f, -0.01080053f, -0.02661906f, 0.06086172f, 
    -0.03629566f, 0.11311922f, -0.00339558f, 0.03888221f, -0.09398855f, 0.02401610f, -0.02342406f, -0.02866092f, 
    0.33294600f, 0.16633675f, 0.01484774f, 0.01933928f, -0.02180591f, 0.03278220f, 0.05337494f, -0.10603577f, 
    0.05508249f, -0.05770963f, 0.20284826f, 0.09167681f, 0.02047901f, -0.11481436f, -0.06569682f, -0.08128947f, 
    -0.04536697f, 0.12349281f, 0.06755063f, 0.02740003f, -0.13561372f, -0.05113531f, -0.02092181f, 0.12871671f, 
    0.10655418f, -0.08988372f, -0.04461321f, -0.00130493f, -0.09522343f, 0.06810477f, -0.03387631f, 0.02571373f, 
    -0.07019034f, -0.01680153f, -0.01236534f, -0.01331703f, 0.12170693f, 0.02514446f, -0.00657075f, 0.04045901f, 
    -0.09751395f, -0.01727971f, 0.23910962f, -0.14572600f, 0.00205054f, -0.02171264f, -0.04692829f, 0.02990511f, 
    0.00788809f, 0.03481669f, -0.08220091f, 0.01282974f, -0.01189356f, 0.14420064f, -0.00671126f, -0.00439749f, 
    -0.03195943f, -0.01869638f, -0.12205283f, 0.04874600f, -0.24439949f, 0.30423957f, -0.08295370f, -0.14510694f, 
    0.17907405f, -0.12692025f, 0.16944319f, -0.03462053f, -0.01781512f, 0.00500512f, 0.04192155f, -0.04771024f, 
    -0.06892487f, -0.00874750f, -0.05652651f, 0.06026589f, -0.08935404f, -0.05455973f, -0.04743223f, -0.02615950f, 
    0.15019265f, 0.05636246f, 0.03838947f, 0.02050389f, -0.19784771f, -0.04143244f, 0.03853799f, -0.11289731f, 
    -0.06789155f, -0.12340960f, -0.04336678f, 0.09971616f, 0.05261863f, 0.01615457f, 0.01125100f, -0.06140807f, 
    0.02502689f, -0.09659278f, 0.03773101f, -0.01903206f, -0.01541996f, -0.05222710f, -0.10742240f, 0.12977503f, 
    0.14908431f, 0.06297781f, 0.00955882f, -0.09051675f, 0.08200505f, 0.02920749f, -0.07137206f, -0.01255834f, 
    0.06309594f, -0.02865193f, 0.04948167f, -0.10445933f, 0.01901447f, -0.09630072f, 0.16380036f, -0.04029533f, 
    -0.08574187f, 0.21798263f, -0.01605521f, 0.02681755f, 0.10528354f, 0.05592977f, -0.04222063f, -0.04570586f, 
    -0.01322212f, -0.04199702f, -0.03818930f, 0.02293856f, -0.00646548f, -0.00804554f, 0.04331104f, 0.14131540f, 
    0.00103530f, 0.07661735f, 0.05917630f, 0.05020990f, 0.05588483f, -0.08550115f, -0.06925032f, 0.11648004f, 
    0.21702571f, 0.00379577f, -0.11286000f, -0.01849992f, 0.08362363f, 0.03069739f, 0.04721249f, -0.03569458f, 
    0.09116964f, 0.07309221f, 0.08266607f, 0.10554001f, -0.06296252f, 0.06149279f, 0.02906137f, 0.08073693f, 
    0.05020117f, -0.00004093f, 0.00216466f, -0.00728229f, 0.02590731f, -0.05333818f, -0.02412394f, -0.03434581f, 
    -0.03048951f, 0.00800586f, -0.02657202f, 0.03229572f, 0.00854202f, 0.01907262f, -0.01024569f, 0.02334345f, 
    -0.05056585f, 0.02999750f, 0.00629975f, 0.02834724f, 0.00798065f, -0.05837902f, 0.04146279f, -0.02415441f, 
    0.00894088f, -0.04507529f, -0.04594959f, 0.02749165f, -0.03745316f, -0.02981413f, 0.01858393f, -0.00836358f, 
    0.04355004f, -0.02078883f, 0.02090530f, 0.03980431f, -0.04940621f, -0.05077998f, 0.05153324f, -0.05161582f, 
    -0.04806466f, -0.00217992f, 0.03988744f, -0.03435076f, 0.01208774f, 0.03261604f, -0.05013351f, -0.02970868f, 
    -0.04831855f, -0.03802392f, 0.01710233f, -0.03369567f, 0.03907020f, -0.01710224f, -0.03674595f, 0.02479735f, 
    -0.04129194f, 0.01827759f, 0.00761966f, -0.02683970f, -0.01583862f, 0.01823982f, -0.00977835f, -0.03207742f, 
    0.02793549f, -0.01247000f, 0.03730395f, -0.03597799f, -0.05473901f, -0.02278660f, -0.03256819f, -0.03901791f, 
    -0.04337155f, 0.00498832f, -0.02060694f, 0.04229312f, 0.02678080f, 0.01952218f, -0.03419950f, 0.00380643f, 
    0.05389523f, 0.05359901f, -0.05946468f, 0.04095246f, -0.02802475f, -0.02092097f, 0.02793483f, -0.02398737f, 
    -0.05956004f, 0.00252758f, -0.00337523f, -0.05634622f, 0.01745213f, -0.02295619f, -0.03485024f, -0.04762773f, 
    -0.03317565f, -0.06229908f, -0.02233409f, 0.02900856f, -0.03761255f, 0.02938860f, -0.04755856f, 0.04374802f, 
    0.01727341f, -0.04865661f, 0.04311647f, -0.04367498f, 0.03480164f, 0.02017245f, -0.02339772f, -0.05755413f, 
    0.05131701f, -0.02542805f, -0.05291832f, -0.04332391f, -0.02670958f, 0.02496545f, 0.03115906f, 0.03920060f, 
    -0.00169254f, -0.00400780f, 0.03845936f, 0.04515945f, -0.02051038f, -0.02375599f, -0.02754048f, 0.03078315f, 
    -0.03003655f, -0.03639528f, -0.02251408f, -0.04410880f, 0.03002666f, 0.01134060f, -0.02357942f, 0.01554801f, 
    0.05268076f, 0.02630313f, -0.00624862f, -0.00678409f, 0.03973303f, -0.01811141f, 0.03024125f, -0.01895958f, 
    -0.05971165f, 0.00606101f, -0.01625372f, -0.05486580f, -0.05003053f, -0.01217921f, 0.01414559f, -0.01722291f, 
    0.04272919f, -0.04843321f, -0.05346511f, -0.04712082f, -0.01854264f, -0.02544544f, 0.04911686f, 0.04426270f, 
    -0.02188877f, 0.01768907f, 0.03047614f, 0.02603132f, 0.03445580f, 0.04557143f, -0.06071258f, -0.03511704f, 
    0.00183917f, -0.01034250f, 0.01800647f, -0.03764352f, 0.00892426f, -0.00481958f, -0.02129014f, -0.02408119f, 
    0.04910191f, 0.02081949f, 0.03344384f, 0.03581249f, -0.01496677f, -0.04453683f, -0.01129273f, -0.05064521f, 
    -0.05616093f, -0.04172394f, -0.00559186f, 0.02268153f, -0.04087159f, 0.02826250f, 0.02134353f, 0.00781221f, 
    -0.01097669f, 0.04058728f, -0.03616654f, -0.02759583f, -0.03777445f, -0.05594791f, -0.04009042f, 0.00695273f, 
    -0.02723457f, -0.02309098f, -0.02526033f, -0.00253370f, -0.00046220f, -0.00568764f, -0.02107750f, 0.03571042f, 
    0.01367617f, -0.02597066f, 0.04371289f, -0.05702459f, 0.03083141f, 0.01631706f, -0.04052867f, -0.04892580f, 
    0.02893521f, -0.01190876f, 0.01256565f, 0.04641243f, 0.04528876f, -0.02954370f, 0.01063378f, 0.00339210f, 
    -0.03068293f, -0.00002478f, 0.00307084f, 0.01174841f, 0.02435256f, -0.04214758f, -0.05070088f, 0.04526798f, 
    -0.01880915f, 0.02868375f, 0.00249558f, 0.02753722f, -0.04868837f, 0.00436867f, -0.01879965f, 0.04215340f, 
    -0.06193435f, 0.02603105f, 0.01032821f, 0.00150086f, -0.01953827f, 0.03677156f, 0.04151147f, 0.04351010f, 
    0.03740495f, -0.00185762f, -0.00376598f, 0.00990317f, -0.01488590f, -0.01349425f, 0.02772125f, -0.03055520f, 
    -0.00743300f, 0.00331396f, -0.03558069f, -0.05235238f, -0.02535486f, -0.02312384f, 0.01664694f, -0.03242353f, 
    -0.00085846f, 0.01488353f, -0.03833196f, 0.04252522f, -0.01903992f, 0.01394072f, -0.00131030f, -0.04091258f, 
    0.02369689f, 0.02795300f, -0.01811032f, -0.03951433f, -0.00811051f, -0.03775170f, 0.04880470f, 0.04437998f, 
    -0.00691609f, 0.02057120f, -0.00616209f, 0.05227215f, 0.04710238f, 0.00709096f, -0.05870405f, -0.04291102f, 
    0.00289447f, 0.03192677f, -0.03022178f, -0.00635330f, 0.01916816f, -0.00880057f, 0.00624474f, -0.05057347f, 
    -0.05345012f, -0.00351140f, -0.04086160f, -0.04994536f, 0.00753562f, 0.02042792f, 0.02504580f, -0.03678342f, 
    0.01341140f, -0.01397656f, -0.05498283f, 0.04518094f, -0.04692565f, 0.04357750f, -0.00955577f, 0.02841770f, 
    -0.05549027f, 0.05311131f, -0.01134439f, 0.02027482f, 0.00803618f, 0.03979512f, -0.01139667f, 0.03327229f, 
    -0.05449655f, 0.00451428f, -0.00686102f, -0.00553804f, 0.00853263f, 0.03286266f, 0.00426476f, -0.01838564f, 
    -0.03740959f, -0.00256621f, 0.01890891f, 0.01861019f, -0.05369719f, 0.01916050f, 0.04405396f, -0.00926640f, 
    -0.04856906f, -0.01160730f, -0.05544685f, -0.00470608f, -0.01163543f, 0.00439360f, 0.00033000f, 0.02929218f, 
    -0.00726863f, -0.02800721f, 0.01450979f, -0.03186329f, -0.01930007f, -0.06178516f, 0.04983940f, -0.05344308f, 
    0.01301256f, -0.05367971f, 0.02364800f, -0.00960382f, 0.03879626f, -0.02034098f, 0.02769997f, 0.04180311f, 
    0.01629042f, -0.03979994f, 0.02608914f, -0.00349424f, -0.02339354f, -0.00216301f, 0.00566994f, 0.03149970f, 
    -0.03529723f, -0.04601980f, -0.01878438f, -0.06133708f, 0.04747570f, 0.02046912f, -0.00914719f, -0.05555571f, 
    0.04042402f, -0.02757668f, 0.00793179f, 0.01244337f, -0.01150137f, -0.00486665f, -0.02990957f, -0.01887074f, 
    -0.03612759f, -0.00801333f, 0.03310661f, 0.02058425f, 0.01127906f, 0.01729112f, 0.02838610f, -0.04986163f, 
    0.02534919f, 0.01556630f, 0.03000116f, 0.00048171f, 0.02012180f, -0.06114719f, 0.04783311f, 0.03498311f, 
    0.04936628f, -0.03727793f, -0.05702626f, 0.02730496f, -0.03526763f, 0.00835767f, -0.00487438f, 0.01512763f, 
    -0.02842150f, -0.04050120f, 0.00258664f, 0.01998879f, 0.03944059f, 0.03119734f, -0.01359091f, 0.04134170f, 
    0.03968921f, -0.01653037f, 0.03602334f, -0.01280176f, -0.06153615f, 0.00637752f, -0.03450602f, 0.00910150f, 
    0.03653163f, 0.03100314f, 0.04411623f, -0.03115445f, -0.02017752f, -0.04257320f, 0.00733557f, -0.04268339f, 
    -0.01813113f, -0.03694505f, -0.02404321f, -0.05057267f, 0.03972474f, -0.01656059f, 0.03720098f, -0.03148236f, 
    -0.03450333f, -0.05672698f, -0.04396273f, -0.01095935f, -0.05117282f, -0.04330551f, 0.03730335f, -0.04538900f, 
    -0.03371158f, -0.04738219f, 0.00512644f, -0.00634552f, 0.01101948f, 0.02461275f, 0.04312621f, -0.01665985f, 
    0.03022140f, 0.02309834f, -0.03189826f, -0.03024081f, -0.01432754f, 0.00922689f, 0.01427665f, 0.00532030f, 
    -0.00404602f, -0.05349917f, 0.03738894f, 0.04917680f, -0.01202599f, -0.04618106f, 0.01042444f, -0.02151435f, 
    -0.00379997f, 0.00584340f, 0.02988056f, 0.02183160f, -0.04529680f, 0.02591362f, -0.01246057f, -0.01301976f, 
    -0.03080319f, 0.04122513f, 0.00758781f, -0.05541055f, 0.00204700f, -0.01376890f, -0.04395983f, -0.05435020f, 
    -0.04328755f, 0.01687167f, -0.03496025f, 0.02322560f, 0.02416498f, 0.03335761f, 0.01470647f, 0.01076154f, 
    0.02956044f, -0.00482427f, -0.00960741f, 0.04353688f, -0.01896077f, 0.00174814f, -0.02610121f, -0.03269644f, 
    -0.04870256f, 0.02394447f, 0.04390364f, -0.03514019f, -0.05603016f, -0.06160350f, 0.04713655f, -0.01647105f, 
    -0.01382972f, 0.02982694f, 0.04282643f, -0.01510733f, -0.01218267f, -0.00942940f, -0.01883944f, 0.00191928f, 
    0.04349574f, -0.04226781f, -0.03530387f, 0.01608653f, -0.00480387f, 0.04406555f, -0.03990741f, -0.05371246f, 
    -0.03767582f, 0.04340739f, -0.03345744f, -0.05468436f, -0.05096557f, 0.01470488f, -0.05053789f, 0.03774273f, 
    -0.01020613f, -0.00678676f, 0.01296209f, 0.04278293f, 0.00628936f, 0.04795254f, -0.02474579f, -0.00071913f, 
    0.01648673f, 0.04477897f, -0.01686424f, -0.02960595f, -0.05361781f, -0.05480445f, -0.04750117f, -0.05535715f, 
    0.04131899f, 0.02180126f, -0.04388782f, 0.01754602f, 0.00572600f, 0.00347308f, -0.00903459f, -0.02828101f, 
    -0.02935435f, 0.00090331f, -0.03148533f, 0.01584520f, 0.03901309f, -0.03786896f, -0.01942277f, -0.03378731f, 
    -0.04598094f, 0.01725803f, -0.03122719f, -0.01365535f, -0.02360488f, 0.02054939f, -0.02566141f, -0.05473527f, 
    0.02715094f, -0.04373727f, 0.03429814f, -0.01346779f, 0.01731373f, -0.05278198f, 0.02350536f, 0.04208686f, 
    -0.02416400f, -0.04874054f, 0.03845193f, -0.01698947f, -0.01660576f, -0.01531184f, 0.03642638f, 0.03602508f, 
    -0.04698045f, -0.02662307f, -0.00550852f, -0.03120146f, -0.04684673f, 0.02140679f, -0.02330657f, -0.00452483f, 
    0.00387915f, -0.03577877f, 0.04504502f, 0.00410505f, 0.03463694f, 0.00577563f, 0.01417941f, -0.05928341f, 
    -0.05635573f, -0.05499479f, 0.02570924f, 0.04172371f, -0.05075760f, 0.02970997f, -0.03627699f, 0.03298492f, 
    -0.02902354f, 0.02616916f, 0.00204846f, -0.04362873f, -0.02993602f, -0.03694038f, 0.04085645f, -0.03529525f, 
    -0.04823910f, -0.05282249f, 0.01609148f, 0.02288150f, -0.03360766f, 0.01649122f, -0.05738410f, -0.04264640f, 
    0.04171544f, 0.04633268f, 0.01616447f, 0.00167091f, -0.01168502f, -0.02339862f, -0.04309461f, -0.01717519f, 
    0.02363672f, 0.17896585f, 0.02252210f, -0.21715404f, 0.19893767f, -0.15416078f, -0.07078861f, -0.13773975f, 
    -0.00485774f, -0.09021900f, -0.12218072f, 0.03854001f, -0.13995422f, -0.01711938f, -0.04823806f, 0.01467976f, 
    0.08470947f, -0.03583301f, 0.01679685f, -0.06918961f, -0.00815033f, -0.17924984f, -0.12760814f, -0.25863966f, 
    -0.12397266f, -0.08223183f, -0.08022125f, -0.08081239f, -0.05527014f, -0.02791458f, -0.08979640f, -0.00496031f, 
    0.04725359f, -0.05115474f, -0.05088794f, -0.05360808f, 0.04730207f, 0.05528119f, 0.05631408f, 0.00651176f, 
    0.02991260f, -0.05104224f, 0.18810239f, -0.13018462f, 0.14671586f, -0.05113319f, 0.08214005f, -0.10035403f, 
    0.03304700f, -0.15344544f, 0.03346380f, -0.02097113f, -0.01947429f, 0.09637836f, 0.05910600f, 0.05445707f, 
    -0.02827412f, -0.01160917f, 0.05243194f, 0.06769246f, 0.38224024f, -0.01059524f, 0.12318259f, 0.18866590f, 
    -0.04029619f, 0.09184955f, 0.10206414f, 0.06434871f, -0.01449938f, 0.03164978f, -0.08866017f, -0.07835504f, 
    0.07416447f, -0.01406737f, 0.03998248f, 0.04879890f, -0.11911356f, 0.09882791f, -0.02545378f, 0.09960563f, 
    -0.22776182f, -0.04111141f, 0.05050360f, -0.10385145f, 0.07092948f, -0.04185956f, 0.01341164f, -0.10510240f, 
    -0.03607081f, 0.04629670f, 0.01202352f, -0.03603962f, 0.02747662f, 0.13255815f, 0.03651440f, 0.02706959f, 
    -0.03523651f, 0.02874318f, 0.04691046f, -0.09392041f, -0.17893843f, -0.07760619f, 0.02949185f, -0.01021655f, 
    0.14779423f, -0.09602576f, -0.00441040f, -0.04451133f, 0.02244503f, 0.00571888f, 0.04248752f, 0.11112320f, 
    -0.11088784f, -0.00423334f, -0.10985520f, -0.05694873f, -0.03013852f, 0.06456155f, 0.01645476f, 0.03657036f, 
    -0.05647569f, -0.11541683f, 0.09678002f, 0.01983502f, 0.11458973f, -0.04716052f, 0.12159642f, -0.08369753f, 
    -0.06273115f, -0.04571275f, 0.03540390f, -0.01950361f, -0.06286040f, -0.08824295f, 0.03152987f, -0.09642281f, 
    -0.01726806f, 0.08192245f, 0.08480710f, -0.09179622f, 0.07882059f, 0.01181295f, 0.05958670f, -0.04279052f, 
    -0.03058253f, -0.11607267f, -0.04299194f, -0.04540655f, 0.05551961f, 0.09682890f, 0.04756629f, 0.01612745f, 
    0.08179510f, 0.05199901f, 0.05412850f, -0.07974356f, -0.05218631f, 0.00613427f, 0.06470273f, -0.09216513f, 
    0.14799821f, -0.00443402f, -0.25699022f, 0.06503551f, 0.03172442f, 0.00164484f, -0.01742647f, 0.10215017f, 
    0.01675402f, -0.06750062f, 0.03043773f, 0.08802744f, 0.01087679f, -0.08978228f, -0.04845656f, 0.01515935f, 
    0.15167154f, -0.10092069f, -0.14286020f, 0.05353928f, 0.06620243f, 0.08242440f, 0.09830520f, 0.16414362f, 
    -0.13177265f, 0.14682913f, 0.11533388f, 0.04956604f, 0.08119484f, -0.03003301f, -0.00599378f, -0.02177568f, 
    0.00238998f, 0.02029820f, -0.06573829f, 0.05004481f, -0.03512346f, -0.00909418f, 0.01272226f, -0.06053644f, 
    -0.03133667f, -0.08156175f, 0.02900364f, 0.13519998f, 0.01037914f, 0.01424980f, -0.01113933f, -0.04200701f, 
    -0.07441132f, 0.03969479f, -0.01111342f, -0.06840988f, -0.04835295f, -0.06704479f, -0.03998268f, 0.00438149f, 
    0.06091691f, -0.00609139f, 0.10787964f, 0.08861690f, 0.39287993f, -0.44869852f, 0.24510066f, 0.09403174f, 
    -0.01179095f, 0.04719383f, -0.10103685f, -0.04771380f, 0.03632164f, -0.05181960f, -0.09565257f, -0.00218926f, 
    0.05201991f, -0.04552979f, 0.02770214f, 0.04438665f, 0.06324527f, -0.01440575f, 0.01707826f, 0.01936888f, 
    0.05051392f, 0.30995089f, 0.08028928f, 0.06564800f, 0.12828936f, 0.00608640f, 0.08504132f, 0.02017419f, 
    0.04078115f, 0.03008010f, 0.01487361f, 0.03789258f, 0.07977927f, 0.01302555f, 0.02632556f, 0.07611489f, 
    0.06010978f, 0.14602931f, -0.08623628f, -0.00542612f, -0.11433664f, 0.15788634f, 0.08994190f, -0.17087635f, 
    0.09284931f, -0.03551253f, 0.02283553f, -0.01467297f, 0.04605812f, -0.08875341f, 0.07327478f, 0.12608691f, 
    -0.00838175f, 0.10967737f, 0.02316956f, 0.09191024f, 0.10751545f, -0.06111627f, -0.06208546f, 0.11478278f, 
    0.18365304f, 0.10424437f, 0.23906605f, 0.13646659f, 0.05329018f, 0.20022209f, -0.02077297f, 0.02458961f, 
    -0.04508440f, -0.01289853f, 0.05355297f, 0.09377864f, 0.04971411f, 0.03672722f, -0.09353174f, 0.07168045f, 
    0.03110367f, -0.07287098f, -0.04163666f, -0.13539183f, 0.12273898f, -0.28804219f, 0.13020398f, -0.08116640f, 
    -0.00503314f, 0.02582071f, 0.03590414f, -0.18926764f, -0.07384220f, -0.08156741f, -0.11219960f, -0.09188442f, 
    -0.04660948f, -0.00520275f, -0.03875896f, -0.04069590f, 0.04980882f, -0.01282115f, 0.10942004f, -0.01140309f, 
    -0.03417911f, -0.00248022f, -0.02373689f, 0.00507840f, 0.01494008f, 0.03655630f, -0.00620952f, -0.02320958f, 
    -0.01006464f, -0.03059257f, 0.03320456f, 0.00769169f, 0.04945375f, -0.01090960f, -0.05450535f, -0.03128535f, 
    0.05642739f, -0.00116075f, 0.04766930f, -0.01770180f, -0.00252942f, -0.02464983f, 0.00566727f, -0.04675703f, 
    0.01745422f, 0.02166737f, -0.01777573f, -0.01331603f, -0.04055399f, 0.00991887f, -0.01613478f, -0.02238883f, 
    -0.03567219f, 0.04857763f, -0.00064380f, -0.00052654f, -0.00944876f, 0.01821435f, -0.03559037f, -0.03621501f, 
    -0.02234829f, -0.05946288f, 0.03407623f, 0.03233090f, -0.02181497f, 0.02203122f, 0.04881568f, -0.02228183f, 
    -0.00791924f, -0.02230095f, 0.03006045f, -0.00736589f, 0.01082910f, -0.01655421f, -0.02198272f, 0.03108318f, 
    0.04173818f, -0.02558214f, -0.04310681f, -0.05381495f, -0.00165883f, 0.05214109f, -0.02267545f, -0.01957605f, 
    0.00037354f, 0.05218815f, -0.05623798f, -0.00890957f, -0.00720936f, -0.01421892f, 0.00209513f, -0.02307046f, 
    -0.05047775f, -0.00772312f, 0.03586265f, 0.04309839f, 0.00388385f, -0.02040505f, 0.00321966f, 0.01884570f, 
    -0.00985164f, -0.04911086f, 0.02222495f, -0.05475816f, 0.02847068f, 0.03371624f, -0.04112966f, 0.04191172f, 
    -0.05652374f, -0.00363053f, 0.03237852f, 0.00753530f, 0.05113806f, -0.03791859f, -0.02011643f, 0.03100216f, 
    -0.04473926f, 0.03500502f, -0.01718877f, 0.02588245f, 0.00549996f, 0.04982010f, -0.00802156f, 0.02074763f, 
    0.01514027f, -0.03245441f, -0.01858949f, -0.03658238f, -0.02925445f, -0.03937983f, -0.05597385f, -0.01452345f, 
    -0.03960190f, -0.00287628f, 0.03519003f, -0.02848708f, 0.00969376f, 0.00102169f, -0.02970506f, -0.00615929f, 
    0.03396640f, -0.00970547f, 0.02817036f, -0.03951295f, 0.02902780f, -0.03316569f, -0.04920050f, -0.04537504f, 
    0.02778349f, -0.04738120f, -0.03929880f, -0.04169575f, -0.02597721f, -0.06147116f, 0.02524740f, -0.04802595f, 
    -0.05324531f, 0.02610816f, -0.06279691f, 0.00624815f, 0.01224256f, -0.00778813f, 0.02905876f, 0.04002587f, 
    0.00915924f, -0.04455646f, 0.05345471f, 0.00655277f, -0.01682788f, -0.01787321f, 0.05784182f, 0.04888209f, 
    -0.03255976f, 0.04546320f, -0.05247043f, 0.02204639f, -0.01472281f, -0.01407901f, -0.01872437f, -0.04222008f, 
    -0.01771195f, 0.01346352f, -0.00846873f, -0.05094985f, 0.01180763f, -0.03549089f, -0.02119076f, -0.06259505f, 
    0.04944458f, 0.03316441f, -0.01242381f, -0.03629506f, 0.00372726f, 0.02104642f, -0.04949640f, 0.02914662f, 
    0.02642356f, 0.01457186f, -0.06240417f, -0.00293980f, -0.00466766f, -0.02157771f, 0.03737850f, 0.02766045f, 
    0.01218252f, -0.04417463f, -0.01558646f, -0.03331351f, -0.01638275f, 0.04907065f, 0.01366326f, 0.02875069f, 
    -0.04869321f, -0.00918761f, -0.01400101f, 0.02738808f, -0.00218865f, -0.01776277f, 0.02597130f, -0.02066118f, 
    -0.03443196f, 0.03056731f, 0.04626625f, 0.00056402f, -0.01336656f, 0.05048735f, 0.05555549f, -0.04350073f, 
    0.02021293f, -0.04598621f, -0.04654745f, 0.03188153f, -0.02759852f, 0.01580453f, -0.04591265f, 0.03410610f, 
    0.00770813f, 0.01273127f, -0.02744258f, 0.01976025f, -0.04788195f, -0.03229837f, -0.03714741f, -0.00051593f, 
    -0.02014774f, -0.01873325f, -0.05554863f, 0.00126503f, 0.00942070f, 0.02195421f, 0.00465943f, 0.00275668f, 
    -0.02973420f, -0.00338003f, -0.02925579f, 0.00190835f, 0.03021949f, -0.01612129f, 0.02647685f, -0.04512886f, 
    -0.05553126f, 0.04728558f, -0.04155948f, 0.02450271f, 0.03429830f, 0.03433120f, -0.02309963f, -0.00203287f, 
    0.04790481f, -0.03848742f, 0.00909401f, -0.04920771f, 0.02314766f, 0.04934792f, 0.03064250f, -0.00092112f, 
    0.02721662f, 0.00528534f, -0.02650703f, -0.02953265f, -0.04159367f, 0.00946096f, 0.03358891f, 0.02246776f, 
    -0.01081929f, 0.00952685f, -0.00727728f, -0.05803661f, -0.05431283f, 0.02749247f, -0.01713808f, 0.02494833f, 
    -0.03908601f, 0.01132756f, 0.00741060f, -0.04838749f, -0.02570797f, 0.00503745f, -0.00541923f, -0.03280822f, 
    -0.05015403f, -0.01640310f, 0.04126644f, -0.01974621f, -0.05508760f, 0.01037921f, 0.03076192f, 0.03828106f, 
    -0.00230602f, -0.05502244f, -0.05486551f, -0.04860793f, -0.05215433f, -0.00869544f, -0.01507202f, -0.00219956f, 
    -0.03238674f, 0.01763532f, -0.03410326f, -0.05824245f, -0.03708730f, -0.00990913f, -0.04609390f, 0.04584404f, 
    0.01597579f, -0.04586341f, -0.03704710f, 0.05814003f, 0.00809974f, -0.04010965f, -0.04650118f, 0.04259684f, 
    0.00820363f, -0.00960194f, 0.01933915f, 0.02768149f, -0.00085131f, -0.00110589f, -0.02223433f, 0.05207438f, 
    0.02687808f, 0.01369153f, -0.04637135f, -0.04181248f, 0.04145203f, -0.00486022f, -0.01726683f, 0.02350560f, 
    -0.00775048f, 0.00416622f, -0.02361232f, -0.04137105f, -0.03471219f, -0.04121832f, -0.03660347f, -0.02605868f, 
    -0.03912484f, -0.00123571f, -0.05240895f, 0.00177464f, -0.04627931f, -0.01865946f, 0.04491105f, -0.05698970f, 
    -0.00781251f, -0.03118554f, 0.04009262f, 0.02146032f, -0.00919585f, -0.04425091f, 0.03185794f, 0.02251798f, 
    -0.02459787f, -0.02993640f, 0.00726637f, 0.01805796f, -0.00603157f, -0.05731830f, -0.03248299f, 0.00875089f, 
    0.01097930f, -0.04990346f, -0.03555096f, 0.02862886f, 0.00664971f, -0.01398418f, -0.01953588f, -0.03016878f, 
    -0.00095914f, 0.04516383f, 0.02451960f, -0.02966124f, -0.01518002f, -0.04282463f, 0.02862713f, -0.06043792f, 
    -0.05572285f, -0.00519566f, -0.04150284f, 0.03014717f, -0.01604163f, 0.02855214f, 0.02348633f, 0.03235073f, 
    0.02155163f, 0.02796675f, 0.04674585f, 0.02585377f, -0.01507688f, -0.00089606f, -0.03506995f, -0.02129954f, 
    -0.02353132f, -0.02352938f, 0.03037909f, -0.04172461f, -0.02844836f, -0.03669180f, -0.04608679f, 0.01023948f, 
    0.01881333f, 0.01736110f, -0.02768163f, 0.01326829f, 0.03172459f, -0.02971854f, -0.00670102f, -0.02357611f, 
    0.03856012f, -0.00609395f, 0.03929469f, -0.02502039f, 0.03798931f, -0.04420890f, -0.04725629f, -0.04106876f, 
    0.02865296f, 0.01723483f, -0.02503790f, 0.02480558f, 0.01800626f, 0.01749863f, 0.02806109f, 0.03435480f, 
    0.03472041f, -0.02881190f, 0.00785115f, -0.06419387f, 0.01241690f, 0.04125240f, -0.05381322f, -0.03145996f, 
    -0.05136747f, 0.02576058f, 0.01016354f, 0.03861925f, -0.02008472f, -0.00134770f, -0.02144619f, -0.02564148f, 
    -0.03164127f, 0.01437347f, -0.02174702f, 0.03215912f, -0.02534722f, 0.04741621f, 0.02068663f, 0.00488767f, 
    -0.03565107f, 0.00175975f, 0.04321632f, -0.02935304f, -0.01813507f, 0.02452401f, -0.03698814f, -0.02375176f, 
    -0.02811461f, 0.00277912f, 0.02388530f, -0.04400611f, 0.04158374f, 0.00465824f, -0.03144220f, -0.02937542f, 
    -0.05266848f, 0.01625742f, -0.00449397f, -0.02962458f, -0.04551291f, 0.00781530f, 0.00197038f, 0.04225295f, 
    0.00785714f, 0.01510006f, 0.03185455f, -0.03983663f, -0.01259161f, -0.03075740f, 0.01919621f, -0.00514140f, 
    -0.04731944f, 0.04835151f, -0.02570531f, -0.03806920f, -0.03317257f, -0.00389328f, -0.04103392f, 0.02916778f, 
    -0.01715070f, -0.01623509f, 0.02894649f, -0.03991297f, -0.03461958f, -0.00827232f, 0.00156954f, -0.02702250f, 
    -0.03229555f, -0.04974619f, 0.00112961f, -0.03345411f, 0.00264327f, 0.02808158f, -0.05698069f, 0.02943304f, 
    0.03953133f, -0.04590457f, -0.06006818f, -0.01455805f, -0.05636854f, -0.01916998f, 0.02808438f, -0.03887582f, 
    -0.04014924f, -0.02779229f, -0.05964494f, 0.01987267f, 0.00399341f, -0.06282702f, -0.04393842f, -0.02910958f, 
    0.04334980f, 0.03526523f, -0.04520037f, 0.04785842f, 0.04638033f, -0.02455756f, -0.03808583f, -0.05752997f, 
    0.04650096f, -0.05322868f, -0.04287755f, 0.03267669f, 0.02127576f, 0.02124694f, -0.05694701f, -0.02814217f, 
    0.03295763f, -0.00570723f, -0.04101881f, 0.01601425f, -0.02433389f, -0.03662633f, -0.06496008f, -0.02380690f, 
    0.03075320f, -0.00758004f, -0.04891744f, -0.01208685f, 0.03867744f, -0.00068292f, -0.03406317f, -0.05338253f, 
    -0.02063832f, 0.02847854f, 0.03295289f, -0.00356277f, 0.03819469f, -0.04355958f, 0.03005601f, -0.01846366f, 
    0.04410644f, -0.01164394f, 0.02533329f, 0.02216091f, 0.02456058f, -0.02274145f, -0.01962478f, 0.00347960f, 
    -0.00901683f, -0.06476148f, 0.02184151f, 0.02859981f, 0.03321432f, -0.02228022f, -0.00481469f, 0.00977192f, 
    0.03512056f, -0.04067806f, -0.03621426f, 0.02097546f, -0.03351507f, -0.00366011f, 0.00001026f, 0.00495018f, 
    0.01491474f, 0.00551451f, -0.03465452f, -0.05651800f, -0.01742337f, -0.06173586f, -0.02817357f, -0.02195293f, 
    -0.05027247f, -0.05905929f, -0.03629033f, 0.01346370f, -0.05730184f, -0.02238336f, -0.01207110f, 0.01393006f, 
    0.04208529f, 0.02303737f, 0.03127874f, -0.03889304f, 0.03996113f, 0.01842398f, 0.02161083f, 0.00305506f, 
    -0.03190455f, -0.01917671f, -0.01152398f, -0.05231834f, -0.02288934f, 0.04002060f, -0.03035634f, -0.00708656f, 
    0.01547947f, 0.00191099f, -0.00869935f, 0.04178999f, 0.00376516f, 0.00874070f, -0.04005925f, -0.05721616f, 
    0.04611909f, -0.01791661f, -0.00602152f, -0.03314320f, 0.01497350f, -0.06329201f, -0.05721665f, 0.04016398f, 
    -0.04457751f, 0.04642164f, -0.04123868f, 0.02061349f, -0.02061535f, -0.01107775f, 0.00913962f, 0.00682575f, 
    -0.25610763f, -0.02446251f, 0.13866225f, -0.05966902f, -0.21733600f, 0.13208148f, 0.24813449f, 0.02757817f, 
    -0.18268493f, 0.10882504f, -0.06792548f, -0.06510303f, 0.07793414f, 0.00951351f, 0.01871124f, 0.03645609f, 
    0.01145665f, -0.02662859f, -0.05683095f, 0.01343403f, -0.13841715f, 0.05307881f, 0.14907216f, -0.26880601f, 
    -0.10862613f, 0.13206843f, 0.05887763f, 0.03962880f, 0.03887324f, -0.01848779f, 0.02315582f, 0.13492075f, 
    0.09052128f, 0.08057657f, 0.05386117f, 0.06483407f, 0.04331669f, -0.07976496f, -0.16145244f, 0.03883398f, 
    -0.25685218f, -0.03029861f, -0.09499458f, 0.04614015f, 0.10442343f, 0.08505809f, 0.02898130f, 0.09423524f, 
    0.01636864f, -0.06176142f, 0.00421368f, 0.02576719f, 0.05550381f, 0.06074168f, 0.03964759f, 0.11914100f, 
    0.00523102f, 0.09026419f, 0.12718740f, -0.04978442f, -0.27168939f, 0.09379304f, -0.04962878f, -0.00239599f, 
    -0.07488104f, -0.04833972f, -0.04745324f, 0.00747347f, -0.16254337f, 0.00491061f, -0.03086656f, 0.07152241f, 
    -0.04430084f, 0.00069473f, -0.01364227f, -0.03327746f, 0.07877674f, -0.02142114f, 0.06268974f, 0.04476818f, 
    -0.43069699f, -0.20161240f, -0.16043569f, -0.12477811f, 0.02818500f, 0.10961999f, 0.11219929f, -0.04829774f, 
    -0.05322549f, 0.06889623f, 0.04260335f, -0.03449482f, 0.01656365f, -0.00346190f, 0.13698740f, 0.00079005f, 
    0.07702286f, -0.07815383f, -0.07197808f, 0.02517477f, 0.20160498f, -0.09100009f, -0.07391836f, -0.02355796f, 
    0.01868916f, -0.01391554f, 0.08056972f, 0.03057149f, 0.03960011f, 0.05230980f, 0.03535418f, 0.03448080f, 
    0.04887759f, -0.11125600f, -0.07195865f, 0.10063504f, 0.09999739f, 0.01166942f, 0.13066959f, 0.13718790f, 
    -0.00551995f, -0.12682340f, 0.09357321f, -0.07892650f, -0.01761640f, 0.03472120f, 0.09093223f, -0.03661368f, 
    0.02820317f, 0.04883865f, 0.07306872f, 0.05203697f, 0.06108201f, 0.04835335f, -0.02760862f, -0.01352028f, 
    0.06358375f, 0.01240228f, -0.02315482f, 0.10118462f, 0.13172881f, 0.01119570f, -0.00216674f, -0.07751185f, 
    0.05171441f, 0.04184434f, 0.03950901f, 0.02673284f, 0.10763209f, 0.01051173f, -0.02382729f, 0.09266523f, 
    -0.00791514f, 0.00262134f, -0.05604586f, 0.09423379f, 0.03329673f, 0.06867048f, 0.08909950f, 0.06990619f, 
    -0.08016835f, 0.07730596f, 0.07916775f, 0.10168914f, 0.06427172f, -0.06811774f, 0.02712237f, 0.04779613f, 
    0.02861007f, -0.05055426f, 0.06297123f, -0.04321115f, 0.02652495f, -0.03243750f, -0.07237147f, -0.13340095f, 
    -0.02123030f, 0.04918025f, 0.16064797f, -0.06082258f, 0.20263898f, -0.14524728f, -0.18794848f, 0.17967041f, 
    0.25927636f, -0.09902839f, -0.12748890f, -0.05411731f, -0.01692118f, 0.01777506f, 0.06801058f, 0.02348373f, 
    -0.11189672f, 0.02960207f, -0.00391927f, -0.06174066f, 0.04372191f, -0.01588521f, -0.02758864f, 0.07754594f, 
    0.27186432f, 0.09443119f, -0.03940593f, -0.18882573f, -0.04086271f, 0.01415130f, 0.06175613f, 0.08366179f, 
    0.00975882f, -0.01253581f, 0.00077165f, 0.06918880f, 0.08487266f, 0.05250290f, -0.01852835f, 0.05301964f, 
    0.04302661f, 0.08812684f, -0.05532381f, 0.07162236f, 0.21620530f, -0.16425313f, -0.27230182f, -0.01893756f, 
    -0.07638690f, -0.03233055f, 0.12619087f, -0.01787028f, -0.00013386f, 0.09414511f, 0.03156181f, 0.10731731f, 
    0.08075967f, 0.06514306f, 0.12132213f, 0.04980807f, 0.02055417f, 0.05126122f, -0.06640799f, 0.06655645f, 
    -0.18479213f, 0.06162685f, 0.06859791f, 0.06525600f, -0.03539828f, 0.00194629f, -0.05469102f, -0.01587531f, 
    0.04088919f, 0.08599611f, -0.00580469f, -0.00634700f, -0.03093351f, -0.06804184f, -0.06731401f, 0.02803350f, 
    -0.00217523f, -0.01764617f, 0.10329603f, -0.11139745f, -0.20988923f, -0.06716924f, 0.01731095f, -0.07207333f, 
    0.03492020f, 0.14050514f, 0.06485466f, -0.10568076f, -0.06322271f, -0.00144084f, 0.02381399f, -0.01962858f, 
    -0.02660387f, -0.12924019f, 0.06210123f, 0.01456123f, 0.02841209f, 0.09404324f, 0.03783128f, -0.03736305f, 
    0.37096351f, 0.04321200f, -0.22431853f, 0.00469709f, 0.18725766f, -0.05524246f, -0.04542741f, -0.07983372f, 
    0.00501948f, 0.18966758f, 0.00097858f, 0.08173822f, 0.12021592f, 0.05902449f, 0.04354907f, 0.00044221f, 
    0.01011264f, 0.02748062f, -0.09353724f, 0.04000301f, 0.04888467f, -0.19449745f, 0.07677373f, -0.05799149f, 
    -0.23971668f, 0.06586858f, 0.14916193f, 0.01928631f, 0.01302368f, -0.02305705f, -0.04656664f, 0.12252261f, 
    -0.08514373f, 0.01272130f, 0.01310121f, -0.02614075f, -0.04509483f, -0.02639397f, -0.13741660f, 0.05705739f, 
    -0.22177014f, -0.23762685f, -0.09721822f, 0.01432526f, -0.04329146f, 0.03972988f, 0.03320379f, -0.04341684f, 
    -0.10631306f, 0.00327482f, 0.06672269f, -0.06242220f, 0.00115459f, 0.08170332f, -0.05881936f, -0.03511035f, 
    0.01769372f, 0.06157591f, -0.02530953f, -0.02088520f, -0.15849879f, -0.01247293f, 0.12465157f, 0.14402458f, 
    0.13746627f, 0.11931840f, 0.10846342f, 0.02768912f, -0.00772488f, 0.00885305f, 0.04977743f, 0.07780255f, 
    0.10540366f, 0.02352730f, 0.07735849f, 0.05737885f, 0.01538243f, 0.00423226f, -0.13087334f, 0.04501945f, 
    0.02103913f, -0.18574066f, -0.22678576f, 0.09054469f, -0.03193714f, -0.08341489f, 0.09361044f, 0.10291281f, 
    -0.11187717f, -0.01953593f, 0.07510169f, 0.00833026f, -0.04346798f, 0.00251022f, 0.00036452f, 0.05665395f, 
    0.05306797f, 0.02460444f, 0.04046681f, -0.01541720f, -0.12661013f, 0.17888819f, -0.12212405f, 0.06561444f, 
    0.06321919f, -0.00789384f, 0.04832411f, 0.05395607f, -0.03459695f, 0.13438402f, -0.03143312f, 0.07638777f, 
    0.00595024f, -0.11352693f, -0.02752891f, -0.07902426f, -0.02810906f, -0.01093815f, 0.07402904f, 0.01309266f, 
    0.00844700f, 0.13919428f, -0.03945423f, 0.03793500f, -0.03712402f, 0.13988860f, 0.04084370f, -0.11866640f, 
    0.12817107f, -0.04866153f, 0.07367934f, 0.02612641f, 0.04479893f, -0.02797349f, 0.11277503f, 0.01267856f, 
    0.00911164f, -0.12858228f, -0.05168438f, 0.16123241f, 0.07741755f, 0.18987513f, 0.01462003f, -0.01047543f, 
    -0.06890471f, 0.00823413f, 0.06909446f, 0.03284081f, 0.07969875f, -0.09880225f, 0.04614605f, 0.01543034f, 
    0.10088976f, 0.04074491f, 0.00145615f, 0.01003615f, 0.09290624f, -0.08465265f, 0.10715240f, 0.08370225f, 
    0.10701510f, 0.18600433f, -0.02994736f, -0.07498219f, -0.04888346f, 0.00789206f, -0.09238534f, -0.08256603f, 
    0.01154061f, 0.03786717f, 0.12640624f, 0.07822860f, 0.07290328f, -0.00608534f, -0.02171569f, 0.04262919f, 
    0.05880120f, -0.00710952f, -0.09573531f, 0.14353184f, 0.07347711f, 0.09549432f, -0.00539995f, -0.04522227f, 
    0.07076244f, 0.11445370f, 0.05645346f, 0.01357232f, 0.05249817f, 0.01426938f, 0.01656675f, 0.00663200f, 
    -0.06240138f, -0.03959402f, -0.00892938f, 0.06891250f, 0.11251868f, 0.03972514f, -0.05445857f, -0.02440565f, 
    -0.14116655f, -0.01866839f, 0.05749715f, -0.11571529f, -0.10446030f, -0.12314083f, 0.10273888f, -0.05112886f, 
    -0.04763473f, -0.08810444f, 0.11670439f, -0.06138125f, -0.00759831f, 0.04371848f, 0.06683611f, -0.05453808f, 
    -0.08832110f, 0.14669396f, 0.03304332f, -0.03444961f, 0.01573552f, -0.03130081f, 0.03108608f, 0.10635395f, 
    0.17582244f, -0.08664550f, -0.07600150f, 0.02078406f, 0.00896075f, 0.04545281f, -0.01543812f, 0.02486923f, 
    0.03604167f, -0.00112704f, 0.02607651f, -0.04823805f, 0.08229329f, 0.02907236f, 0.03251903f, 0.06989682f, 
    0.14306714f, 0.22360268f, 0.19921094f, 0.00688870f, 0.11618163f, 0.00602994f, 0.04596411f, 0.08959311f, 
    -0.08102760f, -0.03215742f, 0.00900163f, -0.03987510f, 0.05770106f, 0.11250278f, 0.03160906f, -0.04697501f, 
    0.00420944f, 0.10259856f, -0.02352349f, -0.01692020f, -0.27193916f, 0.28307581f, -0.02165777f, -0.00464608f, 
    0.02068480f, -0.02042212f, 0.12342709f, -0.08853000f, 0.03832288f, 0.02816805f, 0.06723855f, 0.14922504f, 
    -0.08812241f, 0.05167234f, 0.04914351f, -0.04489845f, -0.00399593f, -0.05687421f, 0.01082881f, 0.01202170f, 
    -0.10037671f, 0.03225390f, 0.00021441f, -0.02422148f, -0.10810361f, 0.03119684f, 0.02238336f, 0.01039798f, 
    -0.04335843f, -0.01859281f, 0.03493034f, 0.05258322f, -0.04860174f, -0.01974706f, 0.01917784f, 0.00925369f, 
    -0.05091741f, -0.03248128f, 0.04405164f, -0.05962864f, -0.09253588f, 0.06561104f, -0.19803809f, 0.10970625f, 
    -0.10455984f, 0.08853118f, -0.04196287f, 0.01673704f, 0.07911221f, 0.08298879f, -0.07601813f, -0.03893340f, 
    0.05923365f, -0.02273468f, 0.05797953f, -0.02798521f, 0.02665144f, 0.05507431f, 0.12493311f, 0.07038809f, 
    0.01384841f, 0.04932257f, -0.16422880f, -0.03338598f, 0.12646218f, -0.01369585f, -0.00988448f, -0.05085688f, 
    0.05987132f, -0.05133449f, 0.02662838f, -0.01747551f, 0.03215727f, -0.00451295f, 0.00715525f, 0.09541021f, 
    -0.02592798f, -0.02083481f, 0.06093508f, 0.06006907f, -0.28999650f, -0.16614287f, -0.05007880f, -0.03939492f, 
    -0.04224855f, -0.03025546f, -0.01352536f, 0.00386709f, -0.05501627f, -0.01575244f, 0.09847517f, 0.07553039f, 
    0.06311228f, 0.07461116f, 0.07508524f, 0.13889620f, 0.01257524f, -0.00818380f, 0.02754691f, 0.06162799f, 
    0.11835518f, -0.08623575f, -0.25337476f, 0.03444514f, -0.17310055f, 0.01367484f, -0.10513304f, -0.04061001f, 
    -0.03427558f, -0.06901508f, 0.09180598f, 0.01537241f, -0.02169147f, 0.06600717f, -0.01294862f, 0.00989164f, 
    0.02470268f, 0.02623923f, 0.06307454f, 0.03403676f, 0.37142265f, 0.09461634f, -0.09935060f, -0.10524637f, 
    0.23227447f, 0.08174588f, -0.04128918f, -0.04676953f, 0.21148650f, -0.00336646f, 0.10335026f, -0.00426585f, 
    0.05115945f, 0.12296439f, 0.08170356f, 0.00577268f, 0.01564389f, 0.00864641f, 0.00756269f, 0.05394892f, 
    -0.14558637f, 0.44185814f, 0.04856271f, 0.09744937f, 0.31023428f, 0.16335957f, 0.11177420f, -0.05420341f, 
    0.08599359f, 0.04009225f, 0.02390136f, -0.03679785f, 0.03805107f, 0.08301474f, -0.06882347f, -0.02758768f, 
    0.07820257f, -0.00169178f, -0.03664588f, 0.17590639f, 0.35522005f, 0.15097788f, -0.05505649f, -0.06935667f, 
    0.07301176f, -0.02918487f, -0.01021148f, 0.04150498f, -0.14209275f, -0.07919666f, -0.00439098f, -0.01062450f, 
    -0.03052507f, -0.00956844f, -0.02624587f, 0.01166811f, 0.09553491f, 0.03421922f, -0.13228869f, -0.04812564f, 
    -0.08442809f, -0.28289768f, 0.08483113f, 0.20521246f, 0.14898427f, -0.02130347f, -0.13626176f, -0.05772143f, 
    -0.02677011f, -0.05124090f, 0.08544623f, -0.00305566f, 0.01694761f, 0.02613606f, 0.04218621f, 0.05539032f, 
    -0.03827168f, -0.02569565f, 0.10302214f, -0.09150723f, 0.09525426f, 0.06642745f, -0.05933435f, 0.02137815f, 
    0.06086673f, -0.06216906f, -0.05223892f, 0.05046803f, 0.06276188f, 0.08015278f, 0.00298815f, 0.05103167f, 
    0.09177638f, 0.03704986f, 0.03333688f, 0.07553492f, 0.02941262f, -0.01879366f, 0.07782143f, 0.08386809f, 
    -0.06208234f, 0.08303151f, 0.07204521f, -0.12042881f, 0.19477493f, -0.10838021f, -0.04920312f, 0.06936291f, 
    -0.13398112f, 0.08947311f, 0.06389732f, 0.04510826f, -0.04712405f, -0.00415294f, 0.09863818f, 0.13072196f, 
    -0.04863235f, -0.13815999f, 0.13397703f, 0.03434324f, -0.15029304f, 0.18804529f, 0.09683855f, -0.13864797f, 
    0.06579035f, -0.03415713f, 0.02656361f, -0.01156721f, 0.03780762f, 0.05343466f, 0.04143936f, 0.03420034f, 
    0.06734394f, -0.07906740f, 0.02452107f, -0.00647926f, 0.08578654f, -0.08322152f, 0.04206359f, 0.13594148f, 
    -0.03455554f, -0.13170950f, -0.07175730f, -0.02225458f, -0.00671157f, 0.03048798f, 0.07554412f, 0.03351755f, 
    -0.04667497f, 0.08450074f, -0.07645192f, -0.02006410f, -0.01248814f, 0.04794692f, 0.05124808f, 0.09465247f, 
    0.05495396f, 0.07051616f, 0.04202376f, 0.00582929f, 0.15871944f, 0.06951127f, 0.03428050f, -0.10748462f, 
    -0.14410688f, 0.07957910f, 0.02550405f, 0.07703581f, -0.01628072f, -0.09914805f, -0.03032472f, 0.08765293f, 
    -0.03076816f, -0.02982072f, -0.02500944f, 0.10156996f, -0.07089235f, -0.03126953f, -0.01856397f, -0.00864997f, 
    -0.04316035f, 0.16042952f, 0.08613450f, -0.02592066f, 0.14625672f, -0.01910837f, -0.07980657f, 0.08924562f, 
    -0.00028470f, -0.00468674f, -0.03242319f, 0.00072821f, 0.08638909f, -0.03528000f, 0.17666243f, -0.00167496f, 
    0.02284150f, -0.03091062f, -0.09763110f, -0.05833239f, -0.29602984f, -0.06139402f, 0.09878150f, 0.11603363f, 
    0.08398628f, -0.02937462f, 0.04757405f, -0.05790766f, 0.13301224f, -0.04989326f, 0.01405306f, 0.04990954f, 
    0.06645019f, 0.02410120f, -0.06824485f, 0.02206122f, 0.03414724f, 0.05830471f, 0.09695865f, -0.00165004f, 
    -0.02791576f, -0.05394405f, -0.02830730f, -0.12984639f, 0.12867787f, 0.02208782f, 0.11899136f, 0.00357806f, 
    0.04326700f, 0.10745037f, 0.05509685f, 0.00363162f, 0.03171542f, 0.00657974f, 0.02375411f, 0.01881737f, 
    0.07729420f, -0.02001759f, 0.02534560f, 0.10996419f, -0.05364938f, 0.06092024f, 0.07993508f, -0.14421645f, 
    -0.25990704f, -0.03207481f, 0.04050583f, -0.09428573f, -0.06068594f, -0.08259574f, 0.06184456f, 0.08047289f, 
    0.00869588f, 0.08604275f, -0.01094030f, 0.14813940f, -0.05901879f, -0.03731944f, 0.01297567f, 0.00506348f, 
    -0.19303302f, -0.14927110f, 0.09805685f, 0.09236132f, -0.10716546f, 0.03827765f, 0.09483609f, 0.03674325f, 
    0.05270472f, -0.04789329f, 0.04851792f, 0.00662002f, 0.09286101f, -0.02389525f, -0.03416167f, -0.02511257f, 
    -0.01243895f, 0.13100185f, -0.11432620f, 0.03221446f, 0.26067907f, 0.07851523f, -0.11505821f, -0.12336645f, 
    -0.30453351f, 0.02164453f, 0.05401587f, -0.12330166f, 0.02592040f, 0.03683578f, 0.04645882f, 0.03465699f, 
    -0.03635510f, 0.06235876f, -0.03321986f, -0.03232296f, -0.03929944f, 0.00171661f, -0.00562223f, 0.00038549f, 
    0.00434040f, 0.00504341f, 0.10771105f, 0.05256281f, 0.19494390f, -0.10291333f, 0.07699574f, -0.14302211f, 
    0.01975683f, -0.02806736f, -0.09035411f, 0.03347102f, -0.02713092f, 0.06095231f, 0.00515133f, -0.10474887f, 
    0.09303675f, 0.00470971f, 0.04856451f, -0.01760241f, -0.15456894f, 0.15026672f, 0.02151816f, -0.12054283f, 
    -0.19275010f, 0.11548728f, 0.07388701f, 0.06331057f, 0.01596044f, 0.04397484f, -0.02239968f, 0.02479420f, 
    0.10621846f, 0.03487625f, -0.04546712f, 0.05489055f, 0.01492478f, -0.09914440f, 0.02092451f, -0.02122492f, 
    0.06994029f, -0.43794745f, 0.15502021f, -0.08403624f, 0.12508398f, -0.05420347f, -0.14601314f, -0.09684132f, 
    0.03182452f, -0.09159329f, 0.05789851f, -0.12471308f, -0.10582581f, 0.16588104f, 0.09448218f, -0.01628767f, 
    0.06313203f, 0.06111238f, 0.08400894f, -0.02408713f, -0.12053754f, -0.15449247f, -0.00934167f, 0.07940391f, 
    -0.08954525f, 0.08167154f, 0.00224387f, 0.00875414f, -0.09878177f, 0.16653319f, 0.00504468f, -0.04814824f, 
    0.14389092f, -0.00146416f, 0.06144704f, 0.01480693f, 0.09486834f, -0.03163120f, 0.00174149f, 0.01055563f, 
    -0.07624895f, -0.08014008f, 0.05916796f, -0.10225990f, 0.18759683f, 0.08275060f, -0.00719229f, 0.02370043f, 
    -0.03610979f, 0.04055944f, 0.07079484f, 0.03192778f, 0.13179801f, 0.05218958f, -0.01680806f, 0.04888695f, 
    -0.02580336f, 0.04848079f, 0.03173995f, -0.09549998f, 0.12397045f, 0.01471912f, -0.15730163f, 0.08007330f, 
    0.13405006f, -0.14012179f, -0.05401685f, 0.08040076f, 0.04794424f, 0.07710870f, 0.09494907f, 0.00887211f, 
    -0.02866270f, -0.02328354f, 0.09024181f, 0.04368300f, 0.05827557f, 0.03300785f, -0.03078132f, 0.06679688f, 
    -0.01752930f, -0.10310110f, 0.05551672f, 0.06160841f, -0.01739288f, 0.10115344f, 0.08049531f, -0.00605562f, 
    0.11848568f, 0.13481393f, -0.06997202f, -0.05524467f, -0.03672305f, 0.10212985f, 0.07567502f, 0.04202753f, 
    0.05081115f, -0.02717326f, -0.08880233f, 0.14965798f, 0.08998190f, -0.24495450f, 0.10119162f, 0.05136098f, 
    -0.04514778f, -0.03514200f, -0.06556431f, -0.00966960f, 0.22339283f, -0.02235434f, -0.06906946f, -0.03290240f, 
    0.03978995f, 0.04413015f, 0.03536880f, 0.02708814f, 0.02389969f, -0.01335230f, -0.03609592f, 0.05349131f, 
    0.27780709f, 0.13129823f, 0.00323023f, 0.06610660f, 0.08091920f, -0.02581803f, -0.02131918f, 0.06523076f, 
    -0.02992753f, -0.07964131f, 0.04821766f, 0.03671011f, 0.04721819f, 0.02248056f, -0.13640988f, -0.00423575f, 
    0.07617830f, 0.01868468f, 0.06868034f, 0.02202138f, 0.27119628f, -0.01386448f, -0.21825315f, 0.10233756f, 
    -0.17893188f, -0.01178211f, 0.07191519f, -0.04584665f, 0.05051498f, 0.10208281f, 0.04988425f, 0.12635161f, 
    0.00860920f, 0.00728649f, 0.12509693f, 0.07004837f, 0.00233821f, -0.00802516f, -0.02897987f, 0.00289171f, 
    0.01848460f, 0.08634854f, 0.08725455f, -0.00629311f, -0.08767061f, 0.08456362f, -0.05047866f, 0.04028657f, 
    0.10749107f, 0.05448465f, -0.10755483f, 0.00673355f, 0.08589531f, 0.07276536f, -0.07365842f, 0.11231105f, 
    0.05189703f, -0.02460349f, -0.10200190f, 0.05102573f, -0.04522705f, -0.05684539f, -0.12126500f, -0.11527815f, 
    0.20302796f, 0.02232677f, 0.15949371f, -0.04494598f, 0.02520141f, 0.13047893f, -0.00712193f, -0.02933360f, 
    0.09088247f, 0.00449084f, 0.08073359f, 0.00113969f, 0.01793053f, 0.01970208f, 0.02277378f, 0.09969895f, 
    0.21460642f, -0.01057380f, -0.04041181f, -0.00623948f, -0.09429695f, 0.07952303f, 0.07389069f, -0.03321788f, 
    0.08808850f, 0.05946635f, 0.02248066f, 0.06700653f, 0.11667512f, 0.05332258f, 0.02454419f, 0.10722245f, 
    0.01197587f, 0.04131722f, 0.05258439f, 0.06748591f, -0.11844162f, 0.06649516f, 0.12325291f, 0.01420248f, 
    0.19827667f, 0.00286805f, -0.00931538f, -0.11737392f, -0.00380727f, -0.00540349f, 0.05810808f, 0.05217431f, 
    -0.05460617f, -0.07265843f, 0.15378681f, 0.07418367f, 0.02348883f, 0.04710868f, 0.00476881f, 0.07094245f, 
    0.16266559f, 0.04177539f, -0.05180952f, 0.01935660f, -0.18997762f, 0.10761758f, -0.05076273f, 0.04998911f, 
    -0.14717996f, 0.12302133f, -0.03647909f, 0.08482973f, 0.03967541f, -0.04427104f, 0.10426994f, 0.06428374f, 
    0.09083592f, -0.05213860f, 0.07361138f, 0.02638751f, -0.04508115f, 0.01017226f, 0.08439098f, 0.04066091f, 
    0.08231171f, 0.10019892f, 0.09805451f, -0.01026631f, -0.02976135f, 0.00832292f, -0.03681282f, -0.05944476f, 
    -0.04447355f, 0.13960029f, 0.02407752f, 0.02085252f, -0.05193606f, -0.01722263f, -0.05536420f, -0.03908047f, 
    0.15903135f, -0.00388095f, 0.00346634f, -0.09421402f, 0.27451628f, -0.04331913f, -0.02242792f, 0.03909803f, 
    0.02266601f, -0.04142374f, 0.01304732f, 0.05661533f, 0.01093444f, -0.12270383f, -0.08207365f, 0.03056122f, 
    -0.02008515f, 0.00361964f, -0.07500719f, 0.01445363f, -0.03470150f, 0.01860121f, -0.23145355f, -0.02886936f, 
    0.00176065f, 0.05703050f, 0.09923200f, 0.00261937f, -0.08640352f, -0.14573313f, 0.06967928f, 0.12967515f, 
    0.06648365f, -0.08691512f, -0.15447938f, -0.00676805f, 0.00843524f, -0.00242034f, 0.02303347f, 0.04543332f, 
    -0.00537630f, 0.01516047f, -0.03894168f, -0.13123783f, -0.17913765f, 0.08428463f, -0.04168382f, 0.05413144f, 
    0.11536243f, 0.00184134f, -0.11954211f, 0.03918302f, 0.00718335f, 0.03661626f, -0.09391505f, -0.01036387f, 
    -0.00314862f, 0.12258926f, -0.06016903f, -0.07292473f, 0.07331218f, -0.03304963f, 0.33824036f, 0.20796385f, 
    -0.00326989f, 0.07420424f, 0.00107200f, -0.07843835f, 0.13342135f, 0.02733441f, 0.05196764f, -0.01406895f, 
    0.02232033f, 0.12142464f, -0.00634978f, -0.04176506f, 0.05870442f, 0.02629974f, 0.02672968f, 0.01156087f, 
    0.11324438f, 0.21793474f, -0.32266957f, -0.09539631f, 0.07927521f, 0.02208747f, 0.03926044f, 0.09445854f, 
    -0.07551586f, 0.02011212f, -0.04719851f, 0.04898119f, 0.01353146f, 0.04067925f, -0.00503940f, 0.01916860f, 
    0.02220666f, 0.05356584f, -0.05580927f, -0.04888847f, 0.15325341f, -0.01234795f, -0.14767559f, -0.09861942f, 
    -0.21922810f, -0.02392783f, 0.00105927f, -0.08391632f, 0.01542255f, -0.03220308f, 0.00248455f, -0.04847654f, 
    0.08363234f, -0.07721493f, 0.08897483f, -0.05081229f, -0.10786458f, 0.13685076f, -0.00109723f, 0.00394888f, 
    0.12920669f, -0.09283958f, 0.16341178f, 0.07359707f, -0.19868314f, 0.06228381f, -0.00357389f, 0.14731030f, 
    -0.10974156f, 0.00619257f, 0.00417569f, 0.05899820f, 0.05257367f, -0.04257050f, -0.06342474f, -0.06567680f, 
    -0.12499314f, 0.20368218f, 0.04530072f, 0.06844971f, 0.36146367f, 0.00480240f, 0.08585149f, 0.12707293f, 
    -0.20132171f, -0.07574464f, 0.04022709f, 0.09652585f, -0.00166978f, 0.01965087f, 0.07698322f, 0.06905800f, 
    0.07762536f, 0.01962517f, -0.07941737f, -0.07382597f, -0.16081266f, 0.04299908f, 0.08219140f, -0.05553100f, 
    0.04557391f, 0.04914965f, 0.21877329f, -0.00040915f, -0.03254786f, 0.00528608f, -0.10946837f, 0.06927571f, 
    0.07636450f, 0.06489336f, -0.01404956f, -0.01972042f, -0.06787486f, -0.05497534f, -0.06124297f, -0.08107103f, 
    -0.02370939f, 0.04466995f, 0.00047734f, -0.03293581f, 0.27210641f, -0.03080104f, 0.22409534f, 0.18349461f, 
    0.13631433f, -0.11726786f, -0.08419781f, -0.11693937f, -0.06012440f, 0.04473150f, -0.01704490f, 0.04146184f, 
    -0.02153561f, 0.01473307f, 0.01938041f, -0.00897478f, -0.09598245f, -0.05424098f, -0.01062371f, -0.06576949f, 
    0.12556149f, -0.16191411f, -0.00142915f, 0.03182626f, -0.24704391f, -0.02164138f, 0.08321068f, -0.06814829f, 
    0.12662639f, -0.04971095f, -0.02596809f, 0.10035534f, 0.02285204f, 0.01306753f, -0.15970397f, 0.01453800f, 
    -0.00296464f, -0.03556363f, 0.09414794f, -0.03147031f, 0.18018749f, 0.04541046f, -0.21402866f, -0.15900524f, 
    -0.12925409f, -0.03057395f, 0.02926227f, 0.03327693f, -0.15072298f, 0.00929145f, -0.06254630f, -0.04361698f, 
    0.04538913f, -0.02089383f, -0.05922320f, 0.03905269f, -0.00890878f, -0.05525310f, -0.00795176f, -0.03486923f, 
    0.16286401f, -0.12017156f, 0.20254113f, 0.03690299f, -0.04623490f, -0.00691053f, -0.01342109f, -0.02707620f, 
    -0.02221069f, 0.11278924f, -0.08776274f, -0.00853465f, -0.03582386f, -0.01140374f, 0.00485464f, -0.02682429f, 
    0.03413974f, 0.00963898f, -0.00947405f, 0.04903101f, 0.05994471f, -0.02144212f, 0.06537507f, 0.04767232f, 
    0.16765220f, 0.01534679f, -0.10869063f, 0.05391290f, 0.10511246f, 0.05407600f, 0.00702294f, -0.02783309f, 
    0.05790286f, 0.09851020f, 0.08030305f, -0.04452729f, 0.03015747f, 0.02154532f, -0.05537992f, 0.02042251f, 
    0.30209470f, -0.01283540f, 0.26523283f, 0.06036251f, 0.20879036f, -0.15266097f, -0.12720309f, -0.07120113f, 
    0.03009205f, -0.02089484f, 0.00174201f, 0.10661406f, -0.04148934f, -0.01202259f, 0.01444841f, -0.01658412f, 
    -0.05336548f, -0.04348921f, 0.09697767f, 0.08106764f, 0.11082651f, 0.15548195f, -0.15054122f, 0.03832192f, 
    0.15081006f, -0.02052686f, 0.06739477f, 0.10140153f, 0.06202177f, -0.14381026f, -0.10900594f, 0.03967246f, 
    -0.09616742f, -0.03217946f, 0.03497878f, 0.04422608f, 0.07434475f, 0.01863131f, -0.04018485f, -0.02577215f, 
    -0.14479192f, 0.04547201f, -0.09463603f, -0.05026453f, -0.36633945f, 0.10453098f, 0.06849170f, 0.02326026f, 
    -0.00745911f, -0.08554260f, 0.01349739f, 0.05341171f, 0.06079173f, -0.02818494f, 0.00082772f, 0.09044322f, 
    0.02041779f, 0.05667615f, -0.05056328f, 0.01611541f, 0.20175523f, 0.27043876f, 0.16876543f, -0.22651620f, 
    -0.04204644f, 0.00820615f, 0.02245384f, -0.03179416f, 0.02948235f, 0.02257973f, 0.03578047f, 0.02237958f, 
    0.00617478f, 0.09460880f, 0.08366548f, 0.03669599f, 0.00053051f, 0.03462848f, 0.11939947f, -0.05565828f, 
    -0.26742581f, 0.25281629f, 0.10614503f, 0.13429287f, 0.05437023f, 0.09640038f, 0.10690121f, -0.03851193f, 
    0.01932748f, -0.01695755f, 0.08425546f, 0.06575195f, 0.09455914f, 0.06507628f, -0.01761276f, 0.10312874f, 
    0.02957561f, 0.03068275f, -0.01024404f, 0.11930094f, 0.05472728f, 0.08621798f, -0.00893125f, -0.11579277f, 
    0.04201191f, 0.09130285f, 0.01596134f, -0.03353377f, -0.05342392f, 0.04193465f, -0.07223281f, -0.05645088f, 
    -0.06481071f, 0.06946345f, 0.12648907f, 0.11075410f, 0.03904157f, 0.10987786f, 0.01636953f, -0.04131736f, 
    -0.10654970f, -0.15294881f, 0.02593288f, 0.10729782f, 0.08401786f, -0.09432407f, 0.08920737f, 0.01102821f, 
    -0.01605084f, 0.04952469f, 0.00229335f, -0.02681695f, 0.02049697f, 0.07432587f, 0.08518771f, 0.06561802f, 
    0.04322741f, 0.03974628f, 0.02483106f, -0.02998428f, 0.04253732f, 0.08291049f, 0.07506397f, 0.05593292f, 
    0.17159812f, 0.05074633f, 0.03499070f, 0.03505724f, 0.04651738f, -0.00401791f, -0.05052557f, -0.00002344f, 
    0.03687484f, 0.00599040f, -0.01640157f, 0.06717179f, 0.08431759f, 0.08052703f, 0.13954473f, 0.01644891f, 
    0.08661110f, 0.01393316f, 0.05890378f, 0.00119429f, 0.16710819f, 0.07148634f, 0.12322941f, 0.01432826f, 
    -0.07392486f, 0.04478319f, 0.08714274f, -0.03292568f, 0.02063118f, -0.01672500f, 0.01669682f, -0.05173836f, 
    -0.03934494f, -0.04180151f, 0.12008057f, 0.05081938f, -0.09567004f, 0.27578667f, 0.00520690f, -0.05395691f, 
    0.04069837f, -0.02198228f, 0.07459676f, 0.04380134f, -0.06983668f, 0.02861937f, 0.07473923f, -0.00169696f, 
    0.06541024f, -0.10720386f, 0.04865877f, 0.07703771f, 0.14730306f, -0.05038768f, 0.02013663f, 0.07085218f, 
    -0.36890820f, -0.20417164f, -0.10990927f, -0.06342436f, 0.04804018f, -0.01145855f, 0.00490231f, 0.05208108f, 
    0.04125430f, -0.00396783f, -0.08988708f, -0.02231676f, 0.04196872f, 0.15093352f, 0.08310194f, 0.03010625f, 
    0.02383221f, -0.07208789f, -0.00506248f, 0.03084140f, 0.05725775f, -0.14023432f, -0.05820246f, -0.14411522f, 
    0.01065244f, 0.14370297f, 0.04549697f, 0.02510597f, 0.11890592f, -0.06226391f, -0.03686889f, 0.03210263f, 
    0.05644350f, 0.06192014f, -0.00160474f, 0.01552386f, -0.04796230f, -0.05588869f, -0.02229822f, 0.02337294f, 
    0.11971996f, 0.20785290f, -0.08602303f, -0.02899041f, 0.15476415f, 0.06154029f, 0.10570233f, 0.12312824f, 
    -0.11210827f, 0.01884204f, 0.09434991f, -0.01465335f, 0.10168652f, -0.09705763f, 0.06197666f, 0.05832853f, 
    0.09467183f, 0.12917459f, 0.08127420f, 0.03831241f, 0.14819555f, -0.17782719f, 0.07979560f, 0.21547174f, 
    -0.01764025f, -0.01626313f, -0.02253164f, -0.08077868f, 0.11428040f, -0.04568354f, -0.03416432f, 0.06193259f, 
    0.05766970f, 0.06341397f, 0.01930211f, 0.02301096f, 0.03308747f, -0.00598956f, -0.00110888f, 0.12206386f, 
    -0.21337035f, 0.04836052f, -0.08425431f, 0.03779385f, 0.14360312f, 0.05583594f, 0.08603553f, 0.10219362f, 
    0.13628139f, 0.05802943f, 0.09164809f, -0.01783188f, -0.00479927f, 0.06657796f, 0.08221342f, 0.03278840f, 
    0.07015374f, 0.09787975f, -0.00392946f, 0.06520128f, -0.01135407f, 0.00511994f, -0.02477501f, -0.09130905f, 
    -0.25540814f, 0.01062041f, 0.08753659f, -0.01192473f, -0.04096129f, -0.00898189f, 0.06831671f, 0.05604887f, 
    -0.01206494f, 0.03258318f, -0.00767851f, 0.09532368f, -0.02602902f, 0.08548934f, -0.08271555f, -0.02281411f, 
    0.07850667f, -0.16643645f, -0.12508121f, 0.06541075f, -0.06439753f, 0.03105862f, 0.11744978f, 0.07065927f, 
    0.06329577f, 0.11629090f, 0.03612118f, 0.10780648f, 0.12511483f, 0.11030687f, -0.00545923f, -0.07541338f, 
    -0.03121475f, -0.04654108f, -0.07429457f, -0.06263270f, 0.10509576f, -0.07212148f, 0.13753897f, -0.08371656f, 
    -0.27780968f, 0.03776972f, 0.12204111f, -0.06426390f, -0.06680829f, 0.03300109f, 0.02285661f, 0.00444892f, 
    -0.06608266f, 0.00583371f, 0.01608142f, -0.11336400f, -0.04371311f, -0.12053828f, 0.04477527f, -0.02259617f, 
    -0.17810471f, 0.02725464f, 0.00115582f, -0.15538444f, 0.10313586f, -0.19870815f, -0.23842092f, -0.07799744f, 
    0.04025459f, -0.03266939f, 0.03938000f, -0.01783570f, -0.09061401f, 0.02074822f, -0.06696048f, -0.00944856f, 
    0.07254488f, 0.00023244f, 0.07645199f, -0.03208794f, 0.00419950f, -0.03909828f, 0.02282202f, 0.10461919f, 
    0.01784670f, -0.03317190f, -0.14232650f, -0.09534484f, 0.03787748f, 0.05561107f, -0.07259290f, -0.00556236f, 
    -0.09937816f, -0.00946010f, -0.10844786f, 0.02801346f, 0.04457175f, 0.05108709f, 0.03927194f, -0.05652981f, 
    0.01539990f, -0.08697958f, 0.20966415f, -0.13265771f, 0.38857546f, -0.03590390f, 0.04409211f, -0.12565154f, 
    0.07378821f, -0.00904105f, -0.04119445f, 0.04907040f, -0.03620468f, 0.07265729f, 0.12114719f, -0.02518642f, 
    -0.05207156f, 0.04805576f, -0.02757855f, 0.13507603f, 0.47720465f, 0.04750894f, 0.11857650f, 0.14194694f, 
    0.06178024f, -0.00972581f, 0.07930448f, 0.14654809f, 0.00596884f, 0.04688340f, -0.04623809f, -0.10835574f, 
    -0.01439459f, 0.02063418f, -0.02268096f, 0.03794251f, -0.08381664f, 0.02068537f, -0.10181651f, -0.02467952f, 
    -0.04486046f, 0.16529804f, 0.03798806f, 0.07736021f, 0.08788705f, 0.13372372f, -0.16262384f, -0.00515049f, 
    -0.05194190f, 0.02836284f, -0.01364817f, 0.03843820f, 0.06842557f, 0.04086300f, -0.06062756f, -0.01345334f, 
    -0.15992317f, 0.04395866f, 0.05721971f, -0.05475474f, -0.03336317f, -0.01883491f, -0.02632877f, 0.08796988f, 
    0.03873298f, -0.06428269f, 0.01782798f, -0.02166268f, -0.00053210f, 0.03049530f, 0.06324042f, 0.07497064f, 
    -0.05627941f, -0.00006311f, 0.07282574f, -0.00267244f, 0.03929594f, 0.12278095f, -0.06739420f, -0.06346043f, 
    0.14033814f, 0.00023239f, 0.15731803f, 0.03011117f, 0.15712090f, 0.00859459f, 0.04478900f, 0.01513192f, 
    0.03846820f, 0.02997901f, -0.07451886f, -0.06236549f, -0.10568680f, 0.05507880f, 0.09941179f, 0.03457718f, 
    -0.04117866f, 0.01716766f, 0.06985920f, -0.05493824f, 0.04393133f, 0.01513918f, 0.05675780f, -0.01149300f, 
    0.06291440f, 0.03968014f, 0.07142504f, -0.08526674f, -0.06490865f, 0.06780858f, -0.04542040f, 0.07295373f, 
    0.10685904f, 0.07734481f, 0.01088250f, -0.03700377f, 0.00204536f, 0.04529244f, 0.02395811f, 0.05262593f, 
    0.08571337f, -0.06722722f, -0.07097527f, -0.07744233f, -0.01674966f, -0.07753713f, -0.04435407f, 0.12045652f, 
    -0.02744755f, -0.02788237f, 0.01314515f, 0.00440190f, 0.05460804f, -0.11574107f, 0.01117964f, -0.05037637f, 
    0.11528996f, 0.10397052f, 0.02923713f, 0.12875380f, 0.13998149f, 0.12516408f, 0.18240736f, -0.01756857f, 
    -0.23526943f, 0.02408369f, 0.04889148f, 0.01924807f, 0.04802845f, 0.00299261f, -0.02322493f, 0.01590882f, 
    -0.00232493f, 0.00761084f, -0.02720036f, -0.00069874f, -0.02546230f, 0.02067714f, 0.04654283f, -0.01005407f, 
    0.12845176f, 0.05795413f, 0.06331089f, 0.10195719f, -0.08214557f, 0.11407394f, -0.06253134f, -0.01454519f, 
    0.06387253f, -0.00803047f, -0.02443138f, -0.03205755f, -0.01526287f, 0.01323773f, 0.00254602f, 0.05764072f, 
    -0.00140617f, -0.15532722f, -0.03173524f, 0.01670427f, -0.01674561f, 0.00701993f, 0.23963225f, -0.07474519f, 
    0.13017008f, 0.11876074f, -0.00010564f, 0.06372176f, -0.03063550f, 0.10339648f, 0.02803927f, 0.00048906f, 
    -0.01228467f, 0.00353229f, 0.05507442f, -0.04856300f, 0.00114076f, 0.07238661f, -0.06835385f, -0.06956856f, 
    0.10802358f, -0.05474641f, 0.10229848f, -0.00853368f, 0.15855177f, -0.09200927f, 0.11536904f, 0.01967653f, 
    0.01929419f, -0.11806563f, -0.11997558f, 0.02768815f, 0.04836856f, -0.04349114f, 0.01698617f, -0.02037238f, 
    0.05490794f, 0.08158514f, 0.06462762f, 0.03139105f, 0.08811652f, 0.10722216f, 0.06572979f, -0.04414047f, 
    0.07396313f, -0.13808197f, -0.02094424f, -0.05085365f, 0.02995955f, -0.15914048f, 0.04089708f, 0.11844539f, 
    -0.00888256f, -0.00657715f, 0.02532111f, 0.01258216f, -0.00268190f, 0.03585085f, 0.02675540f, 0.05781177f, 
    -0.00213570f, 0.11565082f, 0.27738258f, 0.22286874f, -0.07496180f, 0.07203683f, 0.05804139f, 0.12515453f, 
    0.09316938f, -0.07568930f, -0.03788853f, 0.11041496f, -0.02144506f, -0.09628607f, 0.05199591f, 0.00556354f, 
    0.02027976f, 0.04332715f, 0.08112764f, 0.04276996f, -0.20265931f, 0.02060532f, -0.06738920f, -0.17787482f, 
    0.07711379f, -0.05424609f, -0.10427608f, -0.04161748f, -0.06429627f, 0.05001608f, 0.04542449f, -0.03633840f, 
    -0.03876150f, 0.00949988f, -0.09119672f, 0.08393605f, 0.11317235f, 0.07218589f, 0.05166363f, 0.05619981f, 
    0.08316866f, 0.16672795f, 0.30178142f, 0.02827924f, -0.05291300f, 0.04465992f, 0.15640429f, 0.03966339f, 
    -0.13907667f, -0.12344118f, -0.05416130f, 0.06982314f, 0.01112697f, -0.06530514f, 0.17245850f, 0.00400934f, 
    0.04985551f, 0.03727655f, 0.00779524f, -0.00145991f, 0.20310120f, 0.15450025f, 0.23155439f, -0.04381227f, 
    -0.04547502f, -0.09728850f, -0.10296490f, -0.08914427f, 0.00912998f, 0.01631782f, 0.03584506f, -0.02553315f, 
    0.09399904f, 0.02082558f, 0.12552164f, 0.00102416f, 0.11826181f, -0.04234922f, 0.06047121f, -0.01143010f, 
    -0.19837405f, 0.10744775f, 0.13029562f, 0.00430930f, 0.01701510f, 0.04782582f, 0.01125597f, 0.02197077f, 
    -0.02339552f, -0.03631000f, -0.01993338f, -0.04053521f, -0.01155096f, 0.08495194f, -0.00871538f, 0.01434800f, 
    0.01114068f, 0.02613543f, 0.08335762f, 0.07918959f, -0.20576358f, -0.19440572f, -0.10145369f, -0.11519680f, 
    -0.01000795f, 0.16617325f, -0.09775977f, -0.01584862f, -0.09138209f, -0.06263435f, 0.05175409f, 0.00444482f, 
    0.02765723f, -0.04388729f, -0.01791878f, 0.08134177f, -0.01638662f, -0.03967854f, -0.00692934f, 0.04376852f, 
    -0.08151492f, -0.21497385f, 0.13434072f, 0.05410589f, 0.02548116f, -0.13489744f, 0.02066703f, 0.02552836f, 
    -0.09980828f, -0.03913856f, 0.03357307f, 0.04253235f, 0.04414809f, 0.05718300f, 0.02493338f, 0.00300490f, 
    0.03790741f, -0.03805624f, 0.00972406f, -0.02998092f, 0.01671207f, -0.15357448f, 0.00082409f, 0.07982429f, 
    0.18078734f, -0.04679776f, -0.07844473f, 0.09885432f, -0.06005351f, 0.08493689f, 0.01417899f, 0.08298143f, 
    -0.03279209f, -0.00192704f, 0.07365038f, 0.01140721f, -0.06565158f, 0.03754555f, -0.01104075f, 0.09673586f, 
    -0.27988175f, -0.21120697f, 0.03219279f, -0.08645488f, -0.04955883f, 0.13001068f, 0.10500215f, 0.07726303f, 
    0.00695334f, 0.02590131f, 0.00207268f, 0.02904272f, -0.00969506f, 0.05671069f, 0.00853429f, 0.04817166f, 
    -0.07020636f, -0.06562079f, -0.01543685f, -0.02670186f, -0.16465048f, 0.03136035f, -0.07925111f, -0.04382928f, 
    0.01193277f, 0.05743626f, -0.03606584f, -0.05229383f, 0.14527269f, 0.03176527f, -0.06720526f, 0.02796857f, 
    -0.06131671f, -0.04056306f, 0.02507532f, 0.07864308f, 0.00073910f, -0.03987322f, 0.02934280f, 0.01610423f, 
    0.00663409f, 0.07723609f, 0.01365744f, 0.13540785f, 0.01709293f, 0.07261218f, -0.00455125f, 0.06156527f, 
    0.03938004f, -0.01745260f, -0.00306126f, 0.10889525f, -0.00129495f, 0.09400105f, -0.00226086f, -0.01056115f, 
    -0.00705122f, 0.01937337f, 0.03049350f, -0.07203028f, -0.13125262f, -0.04191209f, -0.33089826f, -0.02485160f, 
    -0.06761720f, 0.09002701f, 0.09288178f, -0.05578088f, 0.04824337f, 0.02007294f, 0.06078377f, 0.00826063f, 
    -0.07884026f, -0.03550571f, -0.04963280f, 0.08577829f, -0.10887889f, 0.01205535f, -0.09240618f, 0.04641887f, 
    -0.00744581f, -0.11540496f, -0.24945547f, -0.03380301f, 0.03239219f, 0.08484226f, 0.03193115f, -0.05977940f, 
    0.12865952f, -0.03910838f, -0.01265782f, 0.02991320f, -0.01465140f, 0.04315119f, 0.11952317f, 0.07782660f, 
    -0.02048999f, 0.06027580f, -0.00165105f, 0.10270391f, 0.04106726f, -0.26787642f, -0.13530146f, 0.13620082f, 
    0.11448023f, -0.00974060f, -0.01889915f, -0.04766784f, 0.07923824f, 0.02462829f, -0.02106782f, 0.00140419f, 
    0.06147115f, 0.02039927f, 0.00723577f, -0.02951985f, 0.06390519f, 0.12428973f, 0.03318708f, 0.05434089f, 
    -0.03425582f, -0.09462211f, -0.01612601f, -0.05540347f, 0.03088983f, 0.14560968f, -0.09747178f, -0.02108662f, 
    0.13174374f, 0.03587047f, 0.08961575f, -0.01002072f, 0.10114859f, 0.08390823f, -0.02486822f, 0.08867057f, 
    0.08457808f, 0.02696039f, -0.01754459f, -0.02551434f, 0.03417501f, -0.06890756f, 0.20778377f, -0.18810362f, 
    -0.08196682f, 0.02065837f, 0.03142294f, 0.03070674f, -0.02080234f, 0.04422856f, 0.06547950f, 0.08691996f, 
    -0.07670384f, 0.02258362f, 0.02977796f, 0.03614188f, 0.05020211f, -0.01703172f, -0.07840921f, -0.04195370f, 
    -0.18508370f, 0.03791398f, -0.15411338f, -0.07171145f, -0.19042589f, 0.14793764f, 0.12562914f, 0.02170057f, 
    0.06151330f, 0.12354862f, -0.12789160f, 0.02998954f, 0.06022247f, 0.11314162f, -0.04851545f, -0.00275940f, 
    0.03582815f, -0.07032650f, 0.00723275f, -0.04839643f, 0.30383947f, 0.14340426f, 0.22413793f, 0.08268769f, 
    -0.10509694f, -0.01435605f, 0.10644719f, -0.04419566f, -0.07334381f, 0.03206884f, -0.06081741f, 0.04496968f, 
    0.03473110f, 0.02962522f, -0.00749618f, -0.02604833f, -0.02829495f, 0.10356925f, -0.00758338f, -0.03753097f, 
    0.08583251f, -0.09642170f, -0.09287605f, -0.11033266f, -0.02566821f, -0.04033799f, -0.06854051f, 0.01753427f, 
    -0.02321061f, 0.02792345f, 0.12602012f, 0.04881440f, -0.00088393f, 0.01313173f, -0.14028391f, 0.01200493f, 
    0.01583971f, -0.04083139f, -0.05636469f, -0.00304324f, 0.07354554f, 0.12972382f, -0.12138748f, 0.06743876f, 
    0.13398604f, 0.10513597f, 0.11222578f, -0.02680562f, -0.04173390f, -0.08280337f, 0.07437145f, 0.15666766f, 
    -0.05384670f, -0.01971965f, -0.06252953f, 0.08409301f, -0.00777657f, 0.00785926f, 0.09682002f, 0.07968573f, 
    0.01824653f, 0.02501037f, -0.21001017f, 0.12055467f, 0.26719245f, 0.08797521f, -0.04634840f, 0.04273704f, 
    0.07418801f, -0.05712221f, 0.05771194f, 0.05404374f, -0.01380311f, -0.04081172f, 0.08172273f, -0.08733693f, 
    0.09529142f, -0.09950248f, -0.05126107f, 0.00027073f, 0.14430748f, -0.01117604f, -0.09262527f, -0.03871734f, 
    -0.07732793f, -0.07641834f, -0.09178321f, 0.00690859f, 0.05553398f, -0.00775427f, 0.02537122f, -0.10192452f, 
    -0.06739110f, 0.06409444f, -0.00240006f, -0.01705832f, -0.03472236f, 0.03370977f, -0.06306193f, 0.01491559f, 
    0.21950942f, 0.20885284f, -0.15109751f, -0.05434050f, 0.28142756f, 0.05562797f, 0.07687514f, -0.05041517f, 
    0.03613881f, -0.04894083f, 0.08303218f, -0.04338204f, -0.08754130f, 0.04370683f, -0.01616416f, 0.14486876f, 
    0.09424947f, -0.00644664f, 0.08429000f, -0.00761573f, 0.07286472f, 0.07648446f, -0.14677672f, -0.15736818f, 
    -0.16744304f, 0.09242310f, 0.10235409f, -0.00401565f, -0.04807217f, 0.00298905f, 0.00003564f, -0.04614437f, 
    -0.02799035f, -0.06085501f, 0.09789150f, 0.01614129f, -0.01433067f, 0.05068441f, 0.03673828f, -0.06979144f, 
    0.22176220f, 0.01171887f, -0.16769581f, -0.07642081f, -0.12075921f, -0.02202122f, -0.07264807f, 0.05952345f, 
    0.00390223f, -0.09076635f, -0.09570781f, -0.02688095f, -0.00883039f, -0.11407687f, -0.04132560f, 0.08648235f, 
    0.01899773f, 0.05796270f, 0.10009117f, 0.04142673f, 0.00141397f, -0.04971970f, -0.00604382f, 0.00612964f, 
    -0.06562312f, 0.06822971f, 0.14649248f, 0.13612972f, -0.04988963f, -0.02534594f, 0.03567438f, 0.07373666f, 
    0.04307578f, -0.04843225f, 0.01932201f, -0.01986925f, 0.00800592f, 0.03941193f, 0.11809286f, -0.02394989f, 
    -0.15235397f, 0.00257418f, -0.01981232f, -0.16059738f, -0.17089590f, 0.06435069f, -0.00123648f, 0.03150712f, 
    -0.01700778f, 0.10051666f, -0.03955013f, 0.01044142f, 0.13608138f, 0.03516144f, 0.06082389f, -0.13230523f, 
    0.03329979f, -0.11133385f, -0.11651760f, -0.01044068f, 0.13845778f, -0.00002243f, 0.08374448f, 0.05781865f, 
    -0.01826564f, -0.13882916f, -0.08966396f, -0.01620681f, 0.02535463f, 0.05196841f, -0.02022421f, 0.06096176f, 
    -0.00655514f, 0.01547276f, -0.03531010f, 0.02698315f, 0.00622736f, 0.04359620f, -0.00756022f, 0.02344412f, 
    -0.10387389f, 0.13207689f, 0.02826675f, -0.01431320f, -0.05482842f, -0.10833303f, 0.07155631f, -0.06787779f, 
    0.07453500f, 0.03306253f, 0.00600017f, -0.00386267f, -0.04698982f, -0.05865905f, -0.05485862f, 0.06843997f, 
    0.03315255f, -0.10406550f, 0.07461271f, 0.02560841f, -0.05253127f, 0.34779769f, -0.11147685f, -0.18360767f, 
    0.08940212f, -0.03592263f, 0.06544291f, 0.02868989f, 0.00276202f, 0.06152243f, -0.10698292f, 0.01137215f, 
    -0.03842551f, -0.02161559f, 0.10835064f, 0.00909720f, 0.03140905f, -0.14552879f, 0.09800050f, 0.08166260f, 
    0.10086146f, -0.15190315f, 0.06912731f, 0.07657837f, -0.06684946f, -0.02331463f, -0.00792786f, 0.06027037f, 
    -0.06107645f, 0.04595621f, -0.05731657f, -0.04090263f, 0.02808849f, -0.01432064f, -0.00097131f, -0.01473993f, 
    -0.03987286f, -0.04390265f, -0.11380322f, 0.01811816f, 0.07773601f, -0.19965719f, -0.01739184f, -0.03006546f, 
    0.00689625f, -0.05691517f, -0.00318752f, -0.10828335f, 0.01694582f, 0.03183065f, -0.08934743f, 0.02182677f, 
    0.10935679f, 0.07612953f, 0.03374134f, -0.03566984f, -0.00249296f, -0.10244141f, -0.01124965f, -0.00155447f, 
    0.19907798f, 0.12257206f, 0.14790681f, -0.07412829f, 0.02594762f, -0.15329006f, 0.02076629f, 0.05453278f, 
    0.14259902f, -0.00528755f, 0.02870140f, -0.00255629f, -0.00935189f, 0.06806480f, 0.06150702f, -0.02906717f, 
    0.04975343f, 0.03024497f, -0.09834620f, 0.04561006f, -0.06476191f, 0.19148934f, -0.23385881f, -0.00107347f, 
    0.28787351f, -0.01620646f, -0.00574290f, 0.00173347f, 0.02373668f, 0.03813687f, 0.10041186f, 0.03939377f, 
    -0.05646170f, 0.02061590f, 0.09764021f, 0.15321656f, 0.04324374f, -0.04829764f, 0.01458692f, 0.02658653f, 
    -0.03232374f, -0.07308402f, -0.17971198f, 0.18510777f, -0.23119362f, -0.04181952f, -0.05862210f, -0.04135657f, 
    -0.04986393f, -0.08760728f, 0.03726703f, -0.09426043f, 0.00783005f, 0.06274947f, 0.01941389f, -0.04501640f, 
    0.02582785f, -0.02700295f, 0.03971383f, -0.01036567f, 0.04086910f, -0.03727836f, 0.08240803f, -0.01790523f, 
    0.17001265f, 0.05244622f, -0.03367608f, -0.01619326f, 0.00003954f, 0.06274764f, -0.06855129f, 0.06249814f, 
    0.08517851f, 0.11724457f, -0.03772981f, 0.10532653f, -0.00163350f, 0.02607085f, -0.10766771f, 0.00297128f, 
    -0.00643384f, 0.22407031f, -0.10178453f, 0.27130029f, 0.05252159f, 0.04727426f, 0.12452302f, -0.00752529f, 
    0.01275889f, -0.00721463f, 0.06788605f, 0.05533390f, -0.01430211f, 0.09184803f, -0.02632279f, -0.08391964f, 
    0.01322697f, -0.10728054f, 0.00355754f, 0.09487207f, 0.17110536f, 0.36794943f, -0.02362185f, 0.10253917f, 
    0.24416518f, 0.01128979f, 0.11320101f, 0.05671636f, -0.05521126f, 0.09298190f, -0.10730483f, -0.02631231f, 
    -0.01800844f, -0.01549525f, -0.02679677f, -0.01314655f, 0.03668456f, 0.02773279f, 0.00153789f, 0.03990358f, 
    -0.12202317f, -0.09597401f, -0.00655367f, 0.17838506f, 0.03303300f, 0.06988925f, 0.03176549f, -0.09994286f, 
    0.14003868f, -0.06609571f, 0.02186991f, -0.00145763f, 0.08804491f, -0.00772804f, 0.10708220f, -0.01251634f, 
    -0.03132064f, -0.06018420f, 0.06633108f, -0.00400113f, 0.00415443f, 0.08975254f, 0.08820758f, -0.00982144f, 
    0.07533395f, 0.03059235f, 0.05869512f, 0.07462918f, 0.09436654f, -0.03723415f, -0.02512459f, -0.00113686f, 
    0.06992234f, -0.01337426f, -0.13081354f, 0.05287280f, 0.07776938f, -0.06486093f, 0.13119872f, 0.06533150f, 
    0.08853032f, 0.35471207f, 0.00506689f, -0.04063409f, 0.20271638f, 0.02351408f, -0.02818191f, -0.03650673f, 
    -0.01654662f, 0.03160018f, 0.03059221f, 0.01889740f, 0.05898589f, 0.01552297f, 0.03411314f, -0.01853601f, 
    0.05309748f, -0.05271165f, 0.01133016f, 0.04263929f, 0.03720289f, 0.18944333f, 0.07072724f, -0.14564881f, 
    0.15224127f, 0.11062940f, 0.04968756f, 0.06516199f, 0.05152339f, -0.04442935f, -0.06157963f, -0.02631639f, 
    -0.03762191f, -0.02152578f, -0.04207805f, 0.02913101f, 0.01273856f, -0.08457723f, 0.01902323f, 0.09102702f, 
    -0.17132686f, -0.15789811f, -0.01326228f, -0.05843313f, -0.05430684f, -0.13832739f, 0.05389059f, -0.01680480f, 
    -0.03312867f, 0.01061761f, 0.00159770f, -0.02438670f, 0.00505731f, 0.06514621f, 0.10588436f, -0.01739854f, 
    0.00123140f, 0.05595072f, -0.03933994f, -0.08297693f, 0.03123378f, -0.02916345f, 0.13558370f, 0.06023685f, 
    0.11287079f, -0.02637436f, 0.02134025f, 0.06011051f, -0.04320069f, 0.00773726f, -0.04005649f, 0.07274390f, 
    0.00566404f, 0.01425788f, 0.01578774f, -0.05115967f, 0.04425552f, 0.02614370f, -0.01576477f, 0.01930495f, 
    0.05290809f, 0.22346853f, 0.23072954f, -0.11546129f, 0.24266654f, 0.02565904f, 0.03146398f, 0.16819471f, 
    -0.17480601f, -0.00276755f, -0.08584872f, -0.00572374f, 0.04000796f, 0.11608683f, 0.06585859f, 0.01516710f, 
    -0.07155213f, 0.18756986f, -0.03213431f, 0.09193689f, -0.14395967f, 0.03554960f, 0.04541340f, 0.13379247f, 
    0.03632073f, 0.01102333f, 0.01157363f, -0.05186915f, -0.01047203f, 0.04867708f, 0.06989761f, 0.09822349f, 
    -0.06710806f, 0.06023530f, -0.02537208f, 0.00150730f, 0.03491058f, -0.00251627f, -0.01648026f, 0.03280509f, 
    -0.08960261f, -0.02613063f, -0.10927914f, 0.03296877f, 0.03449313f, 0.02244895f, 0.18294409f, 0.02509835f, 
    0.01209824f, -0.00227019f, -0.03181208f, 0.07599030f, -0.01370479f, 0.00835713f, 0.04274279f, -0.04446289f, 
    -0.04750297f, -0.01203207f, 0.07337558f, -0.02670829f, -0.07517353f, 0.11936919f, -0.21927395f, 0.07894643f, 
    -0.18150212f, -0.01052079f, -0.01707155f, -0.01980889f, 0.00244837f, -0.01557070f, -0.00639043f, 0.03519928f, 
    0.02452528f, -0.11334938f, 0.05399508f, -0.05548131f, 0.02033957f, -0.05479678f, 0.06956195f, -0.00926285f, 
    0.01997156f, -0.15127459f, -0.05122112f, 0.14280617f, 0.13522398f, -0.03259957f, 0.00198750f, 0.00150087f, 
    0.07961859f, 0.01143708f, 0.07746112f, -0.02448118f, -0.00852898f, 0.00355510f, -0.00951526f, 0.00149208f, 
    0.00165394f, 0.08169825f, -0.06783888f, -0.02386246f, 0.06575529f, -0.12622061f, -0.01139285f, -0.02814822f, 
    -0.23982683f, -0.06472205f, -0.08519219f, -0.05987542f, -0.00670894f, 0.01736087f, 0.02847236f, -0.02724852f, 
    -0.01062455f, 0.07714761f, 0.00328265f, 0.06151834f, 0.04906862f, -0.01746484f, -0.05249027f, -0.07511444f, 
    0.00523286f, -0.00185679f, 0.06982338f, 0.18165994f, 0.16826709f, 0.06686203f, -0.05252706f, 0.00406492f, 
    0.02895697f, -0.04421836f, -0.08791360f, -0.08205874f, 0.02912192f, 0.13027625f, 0.09292278f, -0.18563409f, 
    -0.05749010f, 0.07799621f, 0.10299332f, -0.02042935f, -0.17077568f, -0.05932738f, -0.01198463f, -0.02233299f, 
    0.03044649f, 0.06060438f, -0.01334009f, -0.00741248f, 0.00355717f, -0.01889258f, 0.00519350f, -0.07082761f, 
    -0.01976429f, 0.02654144f, 0.11989591f, -0.02078867f, 0.01299873f, 0.03370070f, -0.11871719f, 0.03518349f, 
    -0.03504363f, 0.12007350f, -0.08016026f, -0.02709568f, -0.33140260f, -0.09085866f, -0.01404311f, -0.05927983f, 
    -0.03847734f, 0.12679172f, -0.00191340f, -0.07858779f, 0.00170217f, 0.03997174f, -0.04262117f, 0.05999215f, 
    0.00233841f, -0.05408479f, 0.12389064f, -0.00947207f, -0.40617347f, -0.04657852f, 0.08006241f, -0.13287078f, 
    -0.02587619f, -0.03395588f, 0.08759442f, 0.05256569f, -0.03803080f, 0.05372026f, 0.01981982f, 0.18309587f, 
    0.05724122f, -0.02792994f, -0.05198212f, -0.06706034f, 0.17071639f, -0.13065568f, -0.01224034f, -0.08487558f, 
    0.06335209f, 0.04804343f, 0.17885339f, 0.09707851f, -0.19867094f, 0.15870842f, -0.11512931f, -0.12151635f, 
    0.01958265f, 0.07042028f, -0.04238877f, 0.11077552f, 0.12598711f, -0.08287670f, 0.00711491f, -0.19500279f, 
    -0.05117073f, -0.05659506f, -0.05424121f, -0.00781624f, 0.02503025f, 0.13986510f, -0.05122812f, -0.04137745f, 
    0.01838635f, 0.04290239f, 0.01154693f, -0.02030379f, 0.02172204f, -0.00587937f, 0.03301644f, -0.02356860f, 
    0.06716294f, 0.02505263f, 0.03481802f, -0.00341113f, 0.07287666f, -0.19333737f, -0.05418933f, 0.03099072f, 
    -0.25269878f, 0.10171682f, -0.00383434f, -0.04536709f, -0.13967647f, -0.00167958f, -0.01552780f, -0.14769882f, 
    0.08281551f, 0.01096739f, 0.11028522f, 0.11948257f, 0.02029865f, 0.12687227f, 0.05753235f, 0.03202457f, 
    0.05683642f, -0.04311828f, -0.06196729f, 0.14188193f, 0.13405952f, -0.09233994f, 0.09270315f, -0.04054762f, 
    0.00927004f, 0.00416738f, -0.09718186f, -0.08493049f, 0.09320810f, -0.15961640f, -0.06897553f, 0.02789933f, 
    -0.07443374f, 0.12612584f, -0.00888243f, 0.06007355f, 0.01390330f, -0.01097089f, 0.04129913f, 0.06114552f, 
    0.25678179f, 0.25293660f, 0.14383514f, 0.08647209f, 0.18285412f, -0.04623605f, 0.02954901f, -0.02898877f, 
    -0.00568660f, -0.12456188f, 0.04022703f, -0.00191572f, -0.06856039f, 0.00597020f, -0.00656990f, -0.00562740f, 
    0.00617995f, 0.03860168f, 0.13538751f, -0.02735424f, -0.16061303f, -0.00458601f, 0.05350693f, -0.01089083f, 
    0.12721439f, 0.08044370f, -0.01223303f, 0.11202471f, -0.12638524f, -0.00165856f, 0.08059459f, -0.00154438f, 
    -0.11159235f, -0.00011297f, 0.11083290f, 0.10449882f, 0.08453109f, -0.03063506f, 0.01537508f, 0.14096008f, 
    0.17946045f, -0.26970002f, 0.16906209f, 0.02161373f, -0.08538593f, 0.01874830f, 0.00217272f, 0.03274073f, 
    -0.05533676f, -0.15068637f, -0.01164903f, 0.04972021f, 0.00729638f, 0.04529389f, -0.01336915f, -0.06323576f, 
    -0.06030298f, 0.08193892f, -0.12355548f, 0.06143256f, -0.12305456f, 0.10424516f, -0.02247101f, 0.19981270f, 
    0.00627423f, -0.01841284f, -0.04940965f, -0.04749316f, -0.01035160f, 0.06142981f, 0.07503615f, 0.08472955f, 
    -0.04420830f, 0.10408599f, -0.11481499f, -0.01842226f, -0.01930502f, -0.03060924f, 0.07097407f, -0.01779322f, 
    0.09131341f, 0.13587244f, -0.02019322f, -0.15701994f, 0.04789026f, -0.06637435f, 0.04716008f, -0.00854263f, 
    0.03247160f, -0.10683686f, 0.07156385f, 0.03476242f, -0.02698230f, -0.00890876f, -0.06907987f, 0.06248214f, 
    -0.08760517f, -0.03309764f, 0.03999855f, -0.03285827f, 0.10146453f, 0.25327423f, -0.06663641f, 0.08599561f, 
    0.06527708f, 0.07487898f, -0.05257049f, -0.05199494f, -0.01417503f, -0.00336374f, -0.00096575f, -0.10946599f, 
    0.03090478f, -0.03637743f, 0.01300655f, -0.00735365f, 0.00656213f, -0.04471418f, 0.04938930f, 0.00438124f, 
    -0.02411533f, -0.07313707f, 0.04106357f, -0.04457252f, 0.02337988f, -0.00745733f, -0.03275535f, 0.03038372f, 
    -0.04524004f, -0.00580445f, -0.00433754f, -0.08114162f, 0.02598481f, -0.11588105f, 0.01629963f, 0.06258135f, 
    0.02671829f, 0.02240520f, 0.06505183f, 0.06016948f, -0.05061215f, 0.08327832f, 0.02014242f, 0.12757672f, 
    0.06933518f, 0.02057063f, 0.02746198f, 0.03535205f, 0.03545057f, -0.00597721f, -0.10147923f, 0.05733084f, 
    0.07702660f, 0.00112093f, 0.06362350f, 0.00174289f, -0.02478728f, 0.07373603f, 0.08777281f, -0.05111808f, 
    -0.27231687f, 0.11832604f, -0.03343552f, 0.12364744f, -0.06005580f, 0.00369699f, -0.05561199f, -0.01073790f, 
    0.09689121f, -0.09423313f, -0.01966461f, 0.00203883f, -0.00292055f, -0.09471361f, 0.04778968f, -0.00866343f, 
    -0.04290785f, 0.07496075f, 0.01377072f, -0.00979101f, -0.17642385f, 0.03941654f, 0.06008204f, 0.14678374f, 
    -0.02470767f, -0.06757782f, 0.11522402f, 0.00150394f, -0.02524894f, 0.02780580f, -0.06629326f, -0.00861677f, 
    -0.04565609f, -0.14605016f, -0.02165129f, -0.03453445f, -0.04384093f, 0.12780368f, 0.06934320f, -0.05240362f, 
    0.24588309f, 0.08763396f, -0.08902232f, 0.02911328f, -0.29275230f, -0.01484034f, 0.10066381f, 0.00057806f, 
    0.01179661f, 0.15984268f, -0.01910858f, 0.06484809f, 0.11123329f, -0.03312378f, -0.03673083f, 0.04065564f, 
    -0.03888782f, -0.00135730f, 0.01391503f, 0.03752550f, -0.18599743f, -0.01988771f, 0.04730795f, -0.03860947f, 
    0.11966069f, -0.05231602f, -0.00587873f, -0.11211114f, 0.07567460f, -0.03867752f, 0.00042998f, 0.04918645f, 
    -0.02657306f, -0.01432115f, 0.06639536f, 0.03868858f, 0.02418369f, 0.08636403f, 0.02963660f, 0.09663313f, 
    0.26912087f, 0.29212332f, 0.01966262f, 0.07120027f, -0.00544370f, 0.05842362f, 0.08653051f, 0.03623658f, 
    0.12865770f, 0.06902652f, 0.00455179f, -0.01773706f, -0.02910455f, 0.02071636f, 0.04909326f, -0.03657297f, 
    0.01128691f, 0.07186868f, 0.11071369f, 0.00175513f, -0.18925337f, 0.06557537f, 0.09264427f, -0.02502203f, 
    0.01291192f, 0.12933388f, 0.11925544f, -0.01238232f, 0.05324286f, -0.12113515f, -0.05568839f, 0.03441884f, 
    -0.04756358f, 0.06886087f, -0.11923923f, -0.04230795f, -0.01559666f, 0.03681954f, 0.05268150f, -0.07134985f, 
    0.02599020f, -0.05980528f, -0.00637442f, 0.00971283f, -0.02074144f, -0.04999802f, 0.01091629f, -0.06949949f, 
    0.02291722f, -0.07608559f, 0.05585264f, -0.02748867f, 0.04684437f, -0.06678444f, -0.03563929f, -0.07375428f, 
    -0.01723381f, 0.02959746f, 0.08282427f, 0.00807516f, 0.11488951f, 0.02315092f, 0.01513687f, 0.01440227f, 
    -0.14827752f, -0.06772652f, -0.00709573f, 0.07830879f, -0.10903582f, -0.04626044f, 0.11401150f, -0.01957955f, 
    0.06479785f, 0.01452311f, -0.00448572f, -0.01478019f, 0.06234393f, -0.00480224f, 0.08816315f, -0.09462729f, 
    -0.21408285f, -0.15875725f, 0.07112264f, -0.03553574f, 0.05638001f, -0.09447873f, -0.03932945f, -0.03302426f, 
    0.00320117f, -0.08882707f, -0.07405508f, -0.01407003f, 0.01808382f, 0.07415175f, 0.03982138f, 0.00682944f, 
    -0.06345210f, -0.15437847f, -0.08723363f, -0.05131251f, -0.03753256f, -0.10561131f, 0.20035459f, 0.03220805f, 
    0.21920648f, 0.07468202f, -0.02325835f, 0.01983631f, -0.00896258f, 0.02890097f, 0.04791996f, 0.01458160f, 
    0.17973097f, 0.02253872f, -0.01187244f, -0.04110115f, -0.00278160f, -0.02257980f, 0.11811669f, 0.06842811f, 
    0.12367685f, -0.19087267f, 0.03459353f, 0.03581760f, 0.07294837f, 0.07518053f, -0.02564326f, 0.02088379f, 
    -0.15256901f, -0.08277122f, 0.15720351f, -0.00501596f, -0.03946779f, -0.10295874f, -0.02297889f, 0.04028528f, 
    -0.01401178f, 0.02365761f, 0.17719397f, -0.00123695f, 0.27922252f, -0.06278718f, 0.24679521f, 0.12327645f, 
    -0.20794204f, 0.11454312f, -0.12980890f, 0.11193503f, -0.08404266f, -0.00820534f, -0.04394200f, 0.00276961f, 
    0.00969434f, 0.00294965f, -0.07603979f, 0.00043207f, 0.00376690f, -0.01550820f, 0.09751733f, 0.03274157f, 
    -0.18887286f, 0.16255353f, 0.03275368f, -0.01755417f, 0.22221816f, -0.16613403f, 0.05534321f, 0.04658601f, 
    0.08075518f, 0.04367336f, 0.03381495f, 0.00605361f, 0.01625625f, 0.06957985f, -0.01126724f, 0.07308515f, 
    -0.00280253f, 0.11665249f, -0.02167706f, 0.06826971f, 0.23121321f, 0.20868377f, -0.07310164f, 0.13733424f, 
    -0.05247192f, -0.00755436f, 0.03459178f, 0.01042173f, 0.06383073f, 0.02826227f, -0.01244694f, -0.07025576f, 
    0.04932136f, 0.12365807f, -0.02517010f, -0.03794690f, -0.00202824f, 0.05000709f, -0.02604941f, 0.08474323f, 
    0.19922681f, -0.24460578f, -0.00165839f, 0.01387166f, 0.15783840f, 0.08246338f, -0.02159031f, -0.08760674f, 
    0.02476222f, -0.01581110f, -0.03946713f, -0.07335059f, -0.01256792f, 0.04728224f, -0.02168445f, 0.00306774f, 
    -0.03838770f, -0.00529604f, 0.07676590f, -0.00642287f, -0.21371682f, -0.03327519f, 0.03361387f, 0.14102477f, 
    0.08427128f, 0.07209221f, -0.07401839f, 0.11222163f, 0.03378331f, -0.09538253f, -0.06549529f, -0.02316838f, 
    -0.05498298f, -0.09681839f, -0.08116671f, -0.06827316f, 0.01203680f, -0.07879276f, 0.05411496f, -0.05563630f, 
    -0.05573358f, 0.12149207f, 0.24561065f, -0.04848063f, 0.00187032f, 0.08753482f, 0.22098809f, 0.05328450f, 
    0.02659866f, -0.05368111f, -0.06570946f, 0.04252225f, 0.12314730f, -0.08865183f, -0.02003187f, 0.02839667f, 
    0.00667939f, -0.03028044f, -0.04441481f, 0.00835416f, -0.10785148f, 0.04692419f, 0.11503742f, -0.16637276f, 
    -0.24982975f, -0.03512954f, 0.09884401f, 0.07428363f, -0.06303529f, -0.01730699f, -0.04339321f, -0.03678253f, 
    -0.01016077f, 0.04333977f, 0.01537099f, 0.01488881f, 0.02914018f, -0.08128378f, -0.00065189f, -0.03529106f, 
    -0.04351589f, -0.21624057f, -0.03145897f, -0.00869776f, -0.26802674f, -0.01120356f, -0.04670342f, 0.18851459f, 
    -0.02542442f, -0.07104119f, 0.00721099f, -0.03806578f, -0.00087929f, 0.03602175f, -0.03189745f, 0.00958910f, 
    0.05068028f, 0.12076597f, 0.12823699f, -0.02123842f, -0.41830188f, -0.12819819f, 0.00077253f, 0.09022669f, 
    -0.01324956f, 0.06437730f, -0.02049082f, -0.16062345f, -0.10300103f, 0.14631529f, -0.00217970f, 0.02510042f, 
    0.01122339f, 0.05918653f, 0.11646947f, 0.03069963f, -0.02289045f, 0.01221878f, 0.10463703f, 0.03131376f, 
    -0.07608608f, -0.14743048f, -0.11735412f, -0.11831849f, -0.12411961f, -0.07446419f, 0.21223328f, 0.04838285f, 
    -0.00963636f, -0.03107606f, -0.03721286f, -0.10800584f, -0.03384608f, 0.02825126f, -0.01116392f, 0.00336224f, 
    0.06752391f, 0.00167961f, -0.09332630f, 0.07301007f, 0.14468195f, -0.12073878f, 0.07784981f, -0.09219930f, 
    -0.01186133f, -0.05914829f, 0.06156169f, 0.08437667f, -0.03866290f, 0.01177539f, -0.03249004f, -0.02779805f, 
    0.00743683f, -0.03343097f, -0.03503048f, 0.00654668f, 0.04026352f, 0.07828927f, 0.06991500f, 0.14544131f, 
    -0.00050881f, -0.27391496f, 0.05591118f, 0.03492548f, -0.19650011f, 0.00271090f, 0.04689186f, -0.02322628f, 
    -0.04932292f, 0.02810888f, -0.02886715f, -0.04958346f, 0.08771863f, 0.00668433f, -0.05317474f, -0.03873679f, 
    0.03323872f, 0.12586001f, -0.05816037f, 0.05630646f, 0.33559316f, -0.06534295f, -0.11887089f, 0.09720626f, 
    -0.16589774f, -0.04920664f, -0.05003865f, 0.10875544f, 0.10983253f, 0.09225187f, -0.00094310f, -0.06701373f, 
    -0.02216088f, -0.03290030f, -0.03465801f, -0.03040259f, 0.02356989f, 0.03297622f, 0.02009157f, -0.01064939f, 
    -0.09447716f, 0.13710256f, 0.08466116f, 0.14025882f, -0.10660215f, 0.00134961f, -0.03561811f, 0.08876857f, 
    0.09932581f, 0.02235820f, 0.11781585f, 0.06628045f, -0.05895822f, 0.06241575f, -0.07719565f, -0.10602026f, 
    0.00765725f, 0.03960596f, 0.01284628f, -0.01693436f, 0.19038755f, -0.02733744f, -0.16651735f, 0.16087356f, 
    0.10295863f, 0.01051307f, -0.04455444f, -0.06747538f, 0.09888102f, 0.17220698f, -0.00478756f, -0.02311398f, 
    -0.07357844f, 0.02039401f, 0.05966558f, 0.03169860f, 0.03472625f, 0.04947404f, 0.07001617f, -0.00300672f, 
    0.19912569f, -0.08296505f, -0.06168980f, 0.01181784f, -0.09061851f, -0.02662768f, 0.04602978f, -0.05057523f, 
    0.04148481f, -0.00511529f, -0.02271828f, -0.00450973f, 0.02364021f, 0.04138171f, -0.05413752f, 0.01584789f, 
    0.00715070f, 0.05455684f, 0.08239412f, 0.02568281f, 0.33942989f, -0.23956449f, -0.29372329f, -0.05802137f, 
    -0.12047844f, 0.00046627f, 0.13136190f, -0.06317765f, 0.01917322f, -0.01894352f, 0.05591806f, -0.05361808f, 
    0.07627290f, -0.01045163f, -0.02085628f, 0.09004628f, 0.03034958f, -0.03025429f, 0.01128375f, 0.00973891f, 
    -0.14120911f, 0.10071395f, 0.13362682f, 0.10827772f, -0.12478304f, 0.11281190f, -0.04930957f, 0.04756128f, 
    0.13126013f, 0.17472075f, 0.07448644f, 0.03493845f, -0.04050883f, 0.01989599f, 0.08243103f, 0.02446348f, 
    -0.05589481f, 0.06068762f, -0.06215853f, -0.08974481f, -0.10202742f, -0.00818027f, 0.08001258f, -0.00292716f, 
    0.15208395f, 0.18539946f, -0.02039439f, 0.00374915f, -0.00506575f, 0.12757541f, -0.03009672f, 0.00903472f, 
    -0.03745839f, -0.05057827f, 0.06710105f, -0.02768114f, 0.05026279f, 0.06363340f, 0.01795732f, 0.04774255f, 
    0.28255183f, 0.07981163f, -0.14367428f, -0.12027064f, 0.07777689f, 0.09263673f, -0.06489453f, -0.07319696f, 
    -0.08764802f, 0.11690041f, 0.08485636f, -0.02235904f, 0.04816408f, 0.00359547f, 0.05870293f, 0.03759078f, 
    0.01818982f, -0.10940758f, 0.06451707f, -0.01067163f, 0.15500695f, -0.12079290f, 0.13370480f, 0.04120557f, 
    -0.15788746f, 0.01198451f, 0.10594973f, 0.11551893f, 0.00255709f, -0.16962984f, -0.03068865f, -0.01895020f, 
    0.04132080f, 0.05021258f, -0.05582315f, -0.05485998f, -0.03493749f, -0.07282993f, 0.01550871f, -0.03571519f, 
    -0.00388907f, 0.02802057f, 0.01573277f, 0.00383637f, -0.02613081f, -0.05660463f, -0.02731773f, -0.03742760f, 
    -0.06222945f, -0.00484089f, -0.03112321f, 0.03095938f, -0.05890623f, -0.00238450f, 0.00912043f, 0.04426901f, 
    0.01019620f, -0.04643010f, 0.01076871f, -0.03405086f, 0.02311703f, -0.05843028f, -0.01856679f, 0.00653977f, 
    0.02178451f, -0.02959122f, 0.03511351f, 0.03288144f, 0.00681487f, 0.00269959f, 0.03019412f, 0.01242765f, 
    -0.01686434f, 0.04064780f, 0.02919803f, -0.02015129f, 0.02969782f, -0.01598129f, -0.01495202f, 0.02738560f, 
    -0.05261862f, -0.02464873f, 0.00030142f, 0.01267410f, 0.03237204f, -0.04552735f, 0.04502640f, -0.02282489f, 
    -0.00521845f, -0.00895511f, 0.03492863f, 0.03093210f, -0.04365027f, -0.01799228f, 0.00109186f, -0.01047435f, 
    -0.00418136f, -0.01795878f, 0.03416326f, -0.03228007f, -0.02801827f, -0.01293259f, -0.03272242f, 0.03984319f, 
    -0.03319568f, -0.04984793f, -0.00302682f, -0.01005762f, 0.04668094f, -0.04407503f, -0.05503341f, -0.05070330f, 
    0.01502084f, -0.02244301f, -0.05669205f, 0.00692350f, -0.04562463f, -0.04203918f, -0.00798241f, -0.00512210f, 
    -0.00011198f, -0.02526543f, -0.00130387f, 0.02952833f, -0.04018336f, 0.05006085f, 0.00654829f, -0.03769762f, 
    -0.00770997f, 0.00774979f, 0.02819340f, 0.04156658f, -0.00473494f, 0.00804545f, -0.05345602f, -0.03202235f, 
    -0.05584922f, 0.05333836f, 0.03440519f, 0.03361924f, -0.03861462f, -0.03273210f, -0.02140906f, -0.04617114f, 
    -0.02563718f, -0.05709934f, -0.04442586f, 0.02725393f, -0.01767017f, 0.01443706f, -0.04362917f, -0.02509413f, 
    0.02579794f, -0.00497775f, 0.01801382f, -0.05140205f, 0.01794555f, -0.04815532f, -0.03684708f, -0.01375768f, 
    0.01924231f, 0.01408702f, 0.00094874f, 0.04193880f, 0.03932206f, -0.01656897f, 0.00268788f, -0.02350238f, 
    0.01672195f, 0.00455829f, -0.05442465f, -0.00922683f, 0.00550371f, -0.05664704f, -0.01095575f, 0.01343911f, 
    -0.01522694f, -0.03263681f, 0.02693788f, 0.00807390f, -0.01387061f, -0.03048870f, 0.01624801f, 0.04875644f, 
    -0.01184414f, -0.03773303f, -0.02168015f, -0.03177276f, 0.00020139f, -0.06018390f, 0.02335064f, 0.01875968f, 
    -0.03731107f, -0.04063147f, -0.03875640f, -0.04041765f, 0.02561509f, 0.03041957f, 0.01218519f, 0.02306222f, 
    -0.03704897f, -0.05474134f, 0.03896616f, 0.03284426f, 0.04186664f, -0.00128338f, -0.01289244f, -0.02966371f, 
    0.02651690f, 0.05184030f, 0.03572478f, 0.00445852f, 0.04524674f, 0.00037955f, -0.03618772f, -0.04513831f, 
    0.05576866f, -0.00208332f, 0.05219545f, -0.00864034f, -0.01420233f, -0.05461971f, 0.04876908f, 0.00810901f, 
    -0.03647671f, 0.02856180f, 0.01955211f, 0.03820793f, 0.01722114f, 0.04150022f, -0.00229863f, -0.05636643f, 
    0.00965700f, -0.02896103f, 0.01815734f, 0.00446759f, -0.01901964f, 0.00796600f, 0.02060572f, 0.02662143f, 
    -0.02797030f, -0.00677179f, 0.00082160f, -0.03945415f, -0.02931347f, 0.02883749f, 0.00173703f, -0.04735313f, 
    -0.02905652f, 0.02879417f, 0.01261023f, -0.03705027f, -0.04901372f, -0.00976128f, 0.03471300f, 0.00307618f, 
    0.02004763f, -0.01810557f, -0.04710446f, -0.00480891f, -0.04849116f, 0.03852537f, 0.00586185f, -0.02570910f, 
    -0.06430352f, -0.00415783f, -0.02897300f, -0.03122423f, -0.05318621f, 0.02931478f, -0.00539689f, 0.00075025f, 
    0.02397036f, -0.05362475f, -0.04796589f, -0.05685968f, -0.01721536f, -0.04369951f, -0.04003637f, 0.04754066f, 
    -0.05855248f, 0.04832255f, -0.04189127f, -0.02241006f, 0.00284000f, 0.00828780f, 0.01818078f, 0.04154927f, 
    -0.03920722f, 0.02207540f, -0.03873615f, -0.00423623f, -0.05508673f, -0.03664967f, -0.01347415f, -0.03402849f, 
    -0.01418352f, -0.04126334f, 0.04740920f, 0.03715364f, 0.03888495f, -0.02424257f, 0.03227803f, -0.01916267f, 
    -0.02713945f, -0.00911850f, -0.02328864f, -0.04123770f, 0.05160456f, 0.03565570f, 0.02294954f, 0.00293571f, 
    -0.04024750f, -0.01117943f, 0.02632177f, 0.04633289f, 0.01751236f, 0.00533655f, 0.04121600f, -0.05204504f, 
    -0.05158828f, -0.02204707f, -0.02830930f, -0.01722702f, 0.03492416f, -0.05996377f, -0.00574856f, 0.04251253f, 
    0.03937268f, 0.02274508f, -0.01037385f, -0.02178438f, -0.01805696f, -0.02548700f, 0.03060583f, 0.00714122f, 
    -0.02108339f, -0.04219823f, -0.03921853f, -0.02208546f, -0.04047735f, 0.02680781f, -0.04096937f, 0.01257693f, 
    0.02035544f, 0.04445044f, 0.02238335f, 0.01376208f, 0.03042356f, -0.01018259f, -0.05860097f, -0.03813696f, 
    -0.05183856f, 0.01928398f, -0.04087852f, 0.01831721f, 0.02724916f, 0.04313035f, -0.05895472f, -0.02854131f, 
    -0.40533850f, -0.33504021f, -0.16927324f, -0.02315274f, -0.03075338f, 0.07456764f, 0.03545360f, -0.06344161f, 
    -0.15933451f, -0.06115014f, 0.03993592f, -0.07226742f, 0.05014923f, 0.10196463f, -0.00019042f, -0.05338240f, 
    0.07759910f, 0.09881365f, 0.09588963f, -0.03591432f, -0.16642697f, 0.10918203f, 0.10178073f, 0.05529220f, 
    0.04384285f, 0.12038009f, 0.09201518f, 0.10011816f, 0.03508022f, 0.02748837f, -0.00537079f, 0.09120043f, 
    -0.02556140f, 0.01867022f, 0.00919256f, 0.07723696f, 0.09975086f, 0.05226362f, -0.03311146f, -0.05718384f, 
    -0.01222176f, -0.26857609f, -0.15942568f, 0.08168281f, 0.03241589f, -0.08751653f, 0.13776061f, -0.01125704f, 
    0.04581122f, 0.05929974f, 0.02028525f, 0.02222711f, -0.02692563f, 0.01251610f, -0.01194093f, 0.06602702f, 
    0.05095309f, -0.03152249f, 0.14822492f, 0.05511402f, -0.21359989f, 0.10972422f, -0.04309581f, 0.01564737f, 
    -0.09442765f, 0.00257773f, 0.03676197f, 0.09176124f, -0.09769329f, 0.05060008f, -0.07738528f, 0.07124560f, 
    -0.08275141f, -0.11926096f, -0.00050411f, -0.05475486f, 0.04680518f, -0.03979149f, 0.01239596f, 0.09729794f, 
    0.01029802f, 0.26137024f, -0.04001424f, -0.00646966f, -0.00523669f, 0.19005604f, -0.11133146f, -0.18904054f, 
    0.07061858f, 0.01740935f, 0.03906933f, 0.04602740f, 0.09374581f, -0.09559217f, 0.02543223f, -0.03713987f, 
    -0.04248263f, -0.02606881f, -0.00813473f, 0.00224054f, 0.13555624f, 0.21978110f, 0.02719132f, 0.01025212f, 
    -0.12088335f, 0.03851763f, 0.03207327f, 0.01113882f, 0.09031139f, -0.07041045f, 0.01833684f, 0.02374603f, 
    0.10252523f, 0.06083458f, -0.02589696f, 0.06559557f, 0.08901148f, -0.09610417f, 0.07081782f, 0.14197561f, 
    0.05678568f, 0.09670856f, -0.03557450f, -0.11501685f, -0.12583856f, -0.00615991f, -0.02235571f, -0.04195305f, 
    0.01554699f, 0.00409840f, 0.04587928f, 0.10051393f, 0.05705834f, 0.13230909f, -0.00031896f, -0.02764460f, 
    0.05341967f, -0.06811822f, -0.07233851f, 0.13315156f, 0.13446273f, -0.04035730f, 0.07686736f, -0.11692501f, 
    0.03441276f, 0.05163883f, 0.06589802f, 0.02164669f, 0.06150913f, -0.03622224f, 0.04934059f, 0.09562092f, 
    0.04093512f, 0.00209026f, 0.01399490f, 0.12074673f, 0.11154732f, 0.10065869f, 0.00414572f, 0.03552004f, 
    -0.03126320f, -0.01801080f, -0.00645519f, -0.12258384f, 0.00323454f, -0.14469163f, -0.02345028f, 0.02521839f, 
    -0.04125845f, -0.18258238f, 0.03280612f, -0.03746773f, 0.04512616f, 0.01797554f, 0.01248145f, -0.01701598f, 
    0.01431463f, 0.09451697f, 0.16000946f, 0.08444382f, 0.12246257f, -0.15063475f, 0.14183080f, -0.03309181f, 
    0.10943682f, -0.08740092f, -0.10308204f, 0.08466341f, 0.05222051f, 0.02179626f, 0.05625508f, -0.00262733f, 
    -0.00703316f, 0.03186726f, 0.00772921f, -0.04074093f, 0.02065395f, -0.01163050f, -0.02107809f, -0.00706127f, 
    0.18110661f, 0.15949163f, 0.28465346f, 0.00101203f, -0.03425618f, 0.02141166f, 0.00141488f, 0.05596149f, 
    -0.04800207f, -0.05586079f, 0.08744256f, 0.04986558f, 0.09122901f, 0.02382751f, -0.05191493f, 0.04856462f, 
    0.10193325f, 0.11014592f, -0.17469767f, 0.03006047f, -0.24637176f, 0.22298643f, -0.04412447f, 0.04460218f, 
    0.03578956f, 0.00076168f, -0.02680314f, -0.07532824f, -0.04958483f, 0.11012013f, 0.06923265f, 0.07653821f, 
    -0.04396586f, 0.03061830f, 0.05965427f, 0.00313536f, -0.02150968f, -0.06909476f, -0.00552983f, 0.06797318f, 
    -0.11948360f, 0.11726247f, -0.08541574f, -0.02909167f, -0.13593489f, -0.07160835f, 0.02940586f, 0.02049658f, 
    0.02773690f, 0.01445585f, -0.02489763f, -0.01833403f, -0.03198906f, -0.00410874f, 0.00335241f, 0.04192678f, 
    -0.02126795f, -0.01434343f, 0.06911037f, 0.02443185f, -0.05669327f, 0.08853810f, -0.22577929f, 0.03752606f, 
    -0.11896026f, -0.01505029f, -0.03483505f, -0.09307079f, -0.03742251f, -0.01715634f, 0.01889521f, -0.03449566f, 
    0.02165618f, -0.03519199f, 0.08998492f, 0.01809349f, -0.05527909f, -0.04714879f, 0.07611046f, -0.02108438f, 
    0.10589969f, -0.08977128f, -0.04687340f, 0.00649857f, -0.07388908f, -0.05820859f, -0.15044940f, -0.03127795f, 
    0.05028069f, -0.06131617f, 0.06137619f, -0.01989052f, 0.01498808f, -0.08279155f, 0.01816978f, 0.06922220f, 
    -0.05671568f, 0.01944309f, 0.03115161f, 0.03301860f, -0.43323317f, -0.21911141f, -0.03111685f, -0.04259722f, 
    0.01526282f, 0.09324279f, -0.00915965f, -0.11398077f, -0.03883066f, -0.01516975f, 0.06882778f, 0.07996073f, 
    -0.06494565f, 0.04856828f, 0.09326942f, 0.09384350f, 0.04959207f, 0.07379644f, 0.02989904f, 0.01424502f, 
    -0.20614056f, 0.22669196f, 0.35721651f, -0.04323297f, 0.03353613f, -0.03241054f, 0.09985726f, 0.04832092f, 
    0.07730032f, 0.09248416f, 0.00698624f, 0.02959680f, -0.01046466f, -0.05230233f, 0.09309810f, 0.00506884f, 
    -0.00186807f, -0.00683680f, -0.09314088f, 0.10844000f, -0.15611747f, 0.02505160f, 0.27049747f, -0.00268017f, 
    -0.21856797f, -0.07899162f, -0.03736080f, -0.08346245f, -0.14869796f, -0.07021220f, 0.04354701f, 0.09824825f, 
    0.04041099f, -0.02952961f, -0.01656009f, 0.08093760f, 0.00806056f, -0.00168047f, 0.02947794f, 0.06903658f, 
    -0.07042849f, -0.25389966f, 0.03829295f, -0.05907139f, -0.09160523f, 0.02079444f, -0.02854410f, 0.09662654f, 
    -0.07820346f, -0.07820433f, 0.00761405f, 0.00690927f, 0.15987207f, -0.01799005f, 0.13059357f, 0.05803571f, 
    -0.01913641f, 0.06460416f, 0.05728727f, -0.10349995f, -0.41565600f, -0.17951794f, 0.05161665f, -0.13337441f, 
    -0.04244759f, 0.07399182f, -0.09714586f, 0.04120947f, 0.04844273f, -0.07238879f, 0.08651402f, -0.03739197f, 
    0.01140042f, 0.03201787f, 0.03770620f, -0.01439930f, -0.05082495f, -0.06748672f, 0.07777345f, 0.16248438f, 
    0.04943042f, 0.15589854f, -0.00407176f, -0.18619208f, 0.15420379f, -0.09722470f, 0.11745306f, 0.03390925f, 
    -0.08525060f, 0.04788425f, -0.00713863f, 0.02781552f, 0.02121192f, -0.06369035f, 0.03515037f, 0.00665660f, 
    0.05828672f, 0.04358790f, -0.00471428f, 0.07617877f, -0.03574941f, -0.16312324f, -0.06651447f, -0.01031522f, 
    0.00790683f, 0.13716029f, 0.10493328f, 0.03127350f, -0.01561086f, 0.01042415f, 0.08527876f, 0.06561998f, 
    -0.04454734f, -0.04810178f, 0.04928550f, -0.03095352f, 0.00920971f, 0.15489863f, -0.00713333f, -0.00253781f, 
    -0.09835880f, -0.13180275f, -0.04883247f, 0.01123131f, -0.01181598f, 0.12834130f, 0.11751860f, 0.12349778f, 
    0.08571226f, -0.07900542f, -0.03366597f, 0.00473596f, 0.07792503f, 0.01132463f, -0.13750046f, -0.06205258f, 
    0.01274229f, 0.10053281f, -0.04165268f, -0.02178069f, -0.04444415f, -0.14473706f, -0.07975779f, 0.04390432f, 
    0.03721550f, 0.13038160f, 0.07076901f, -0.03178946f, 0.01203861f, 0.00937207f, 0.00709378f, -0.03349505f, 
    0.05634936f, 0.02436978f, 0.06224416f, 0.04192303f, -0.04478870f, 0.04086671f, 0.03778099f, -0.10766490f, 
    -0.08167967f, 0.06407633f, 0.01992325f, 0.17253010f, 0.18202022f, -0.03655034f, -0.04875885f, -0.11973845f, 
    0.09533562f, -0.00412408f, -0.01603220f, 0.02040908f, 0.04131044f, 0.00260572f, -0.06273592f, -0.02958383f, 
    0.06539157f, 0.00115538f, 0.00039409f, -0.08334847f, -0.04310742f, -0.14719015f, -0.11401220f, 0.10707806f, 
    0.16611566f, -0.00139302f, 0.07216654f, 0.02708133f, 0.04361027f, 0.10962432f, 0.01884943f, -0.05114040f, 
    0.06490247f, 0.03001833f, 0.02918512f, -0.04776295f, 0.08140028f, -0.01101723f, -0.00869445f, -0.06212149f, 
    0.04241067f, -0.04189418f, -0.09915595f, -0.08348995f, -0.11147608f, 0.05746685f, 0.17497203f, -0.02926671f, 
    0.08475945f, -0.04763464f, 0.08924597f, 0.07620705f, -0.06047185f, 0.02058659f, -0.01734828f, 0.05181448f, 
    0.07739140f, 0.02505467f, 0.02724203f, 0.13890544f, 0.25692138f, -0.14375623f, -0.09654152f, 0.02140931f, 
    0.05802203f, 0.00214145f, 0.01167036f, 0.15426108f, -0.11428048f, 0.08441582f, -0.00964632f, -0.00537321f, 
    0.04711310f, 0.00682295f, 0.03458158f, 0.04244221f, 0.04573729f, 0.05157059f, 0.02306413f, 0.06741789f, 
    -0.05569865f, 0.04539416f, 0.09643202f, 0.09700324f, -0.00774745f, 0.01096274f, -0.07349915f, 0.05193266f, 
    0.05944425f, -0.04457311f, -0.00273276f, -0.02014793f, -0.02651880f, 0.05568976f, -0.03031350f, 0.00332034f, 
    -0.05950839f, 0.05923475f, -0.02833953f, 0.00815858f, 0.04582800f, -0.08098236f, 0.12241706f, 0.11382835f, 
    0.17311446f, 0.09884356f, 0.00865858f, 0.03367844f, 0.01795872f, -0.02349868f, 0.06862064f, 0.03815528f, 
    -0.02088654f, -0.04607180f, 0.08918054f, -0.04399895f, 0.03544383f, 0.08388935f, 0.02477987f, -0.03996781f, 
    0.16829160f, 0.04434152f, -0.12662768f, -0.05963919f, 0.17924486f, 0.02157612f, -0.02498850f, -0.03984515f, 
    -0.08664366f, 0.11333010f, -0.02642134f, 0.05370646f, -0.02196256f, 0.12703191f, 0.03357648f, 0.06802431f, 
    0.02562739f, -0.08405177f, -0.06614330f, -0.02952898f, -0.11059612f, 0.07509948f, 0.14148054f, 0.17356078f, 
    0.25901523f, 0.03651854f, 0.03312591f, 0.00445542f, -0.02573998f, 0.02752153f, 0.01433345f, 0.04131716f, 
    0.01118587f, -0.07652086f, -0.02870170f, 0.05398764f, 0.00007722f, -0.03734737f, -0.03491810f, 0.02267047f, 
    -0.11197571f, 0.12099622f, -0.02748582f, 0.28345177f, -0.10319813f, -0.09524412f, -0.09285340f, -0.02666470f, 
    -0.01094176f, -0.16482905f, -0.08568818f, -0.03153813f, -0.00319828f, -0.00216797f, 0.11130738f, -0.05955594f, 
    -0.00504162f, -0.07523927f, 0.00467088f, -0.06621829f, 0.05865977f, 0.09964835f, 0.15057769f, 0.05103152f, 
    0.03128681f, -0.08190262f, -0.03062457f, 0.06758143f, 0.07195415f, 0.15414155f, -0.08652446f, -0.12236363f, 
    -0.00270064f, 0.11115862f, 0.08261614f, -0.01488152f, 0.06699903f, -0.00906075f, -0.01448730f, 0.04627165f, 
    0.08370420f, 0.15801278f, 0.07815234f, 0.11414277f, -0.15049891f, -0.06883051f, 0.04940470f, -0.01784007f, 
    -0.05628827f, 0.01559313f, -0.02058029f, -0.01543372f, -0.05587623f, 0.07949206f, -0.07757778f, 0.08037273f, 
    0.02339246f, -0.07874282f, -0.01081589f, 0.09586678f, 0.05438780f, 0.14393470f, -0.14501053f, 0.05411100f, 
    0.12536183f, 0.07672089f, 0.07351040f, 0.04778721f, 0.02666723f, 0.06411040f, -0.02660517f, 0.14108782f, 
    0.18607071f, -0.04933766f, -0.03763142f, 0.03887815f, -0.00736786f, 0.03062894f, 0.04704344f, -0.05994447f, 
    0.07199273f, -0.06435112f, 0.22279204f, 0.15733813f, -0.14265054f, -0.04256295f, -0.04519467f, 0.04012297f, 
    0.09648737f, 0.07773669f, -0.10929477f, -0.06328328f, 0.07560772f, -0.00860975f, 0.00834827f, 0.00835273f, 
    0.05515208f, -0.02674879f, 0.04007016f, -0.02277702f, -0.18208934f, -0.00925406f, 0.10568298f, 0.10029079f, 
    0.11210730f, 0.05922459f, -0.01454533f, 0.09961512f, 0.03967313f, 0.02035015f, -0.02501911f, 0.04031236f, 
    -0.06930376f, 0.00090296f, 0.01884709f, 0.01391540f, 0.04092171f, -0.07407863f, -0.01826897f, 0.06646769f, 
    -0.04515864f, 0.13398851f, -0.05451025f, 0.08220395f, 0.23848747f, 0.01011564f, 0.06428743f, -0.09936790f, 
    -0.06574593f, 0.09598070f, -0.01755439f, -0.05137677f, 0.02958558f, 0.08627641f, 0.10368194f, -0.02311632f, 
    0.08944771f, -0.01176646f, 0.02028635f, -0.02838760f, -0.06467726f, -0.00173351f, 0.05233337f, 0.05496700f, 
    0.05932856f, -0.06245993f, -0.06850548f, -0.04227710f, 0.05610612f, 0.01063770f, 0.01709623f, -0.00610159f, 
    -0.09631764f, 0.00754296f, 0.06587812f, -0.01549302f, 0.05529115f, -0.08933955f, -0.06119484f, 0.05722696f, 
    0.05984702f, -0.08029138f, -0.03779369f, 0.03465971f, 0.10796915f, -0.04816833f, 0.01575571f, -0.05668447f, 
    0.03088796f, -0.04128972f, 0.00731201f, -0.03497281f, -0.02829663f, 0.10618324f, 0.03783911f, 0.19913319f, 
    -0.00567897f, 0.01842226f, -0.04888531f, 0.04012499f, -0.14278285f, 0.03771823f, -0.25972810f, -0.12787609f, 
    -0.05281660f, 0.21078795f, 0.07072881f, 0.09461845f, -0.00519778f, 0.02596542f, -0.00609414f, 0.07711618f, 
    0.02929664f, -0.04360040f, 0.05549404f, 0.10344606f, -0.00687964f, 0.02169007f, 0.03130285f, 0.05687222f, 
    0.16929051f, 0.09265874f, 0.04332548f, 0.10749604f, 0.22985652f, 0.13592055f, -0.00566109f, 0.11257167f, 
    -0.10053644f, 0.04742542f, -0.01742521f, 0.02769208f, 0.06815342f, 0.05770300f, 0.05326192f, -0.00814426f, 
    0.00156584f, 0.17053676f, -0.02489159f, -0.00578217f, -0.11192698f, -0.11296105f, 0.09568845f, 0.15833920f, 
    -0.03662430f, 0.07630971f, 0.00475406f, -0.01009359f, 0.06612220f, -0.06027157f, 0.04690454f, 0.02951195f, 
    -0.03346426f, 0.05259253f, -0.08789387f, 0.08738261f, -0.11153472f, 0.06205501f, 0.07112390f, 0.00505993f, 
    -0.01344344f, 0.02655243f, -0.19609158f, -0.17337888f, 0.15520993f, 0.10436904f, 0.05466308f, -0.06147490f, 
    0.01574262f, -0.06372739f, 0.10590335f, 0.07900251f, 0.00980269f, 0.12854445f, 0.05699156f, 0.03221010f, 
    0.06633861f, 0.08373492f, 0.00115483f, -0.02941138f, 0.02472196f, 0.20288631f, -0.01246274f, 0.03133502f, 
    -0.13539159f, -0.03876539f, 0.05356193f, 0.06717002f, -0.02572338f, -0.03266842f, 0.07278294f, 0.04635047f, 
    -0.02188605f, -0.02612549f, -0.01125565f, 0.09907145f, -0.01891162f, 0.02976443f, -0.08003702f, -0.03624539f, 
    -0.19410321f, -0.22289090f, -0.17331563f, 0.01744484f, -0.22802454f, 0.16591704f, 0.04255434f, 0.05740939f, 
    -0.02486939f, 0.05190512f, -0.00364686f, 0.03784424f, 0.06795413f, -0.01723784f, -0.01501902f, 0.00092350f, 
    0.01145714f, 0.00839369f, 0.00670914f, 0.03817343f, 0.04024412f, -0.00124514f, 0.17522773f, 0.09727878f, 
    -0.29982394f, -0.07140146f, 0.04107486f, 0.04096797f, -0.07409274f, -0.03598010f, -0.08760706f, -0.00223268f, 
    -0.00201010f, 0.05582768f, -0.07963563f, -0.00408889f, 0.01022377f, -0.11974441f, 0.01658965f, -0.06592042f, 
    -0.03744433f, -0.00960444f, -0.01207146f, -0.04291704f, 0.02656301f, 0.02133397f, 0.02899565f, -0.03613810f, 
    0.02600589f, -0.06068703f, -0.06220365f, -0.02387592f, -0.03270820f, -0.03260100f, -0.04323999f, 0.00114576f, 
    0.02579655f, -0.02959280f, 0.01293948f, -0.05889656f, -0.04309544f, -0.00184313f, -0.05375365f, 0.03573765f, 
    0.02501487f, 0.02591339f, -0.05837794f, -0.00335089f, 0.02441474f, -0.00499090f, 0.03640868f, 0.02392232f, 
    -0.05507698f, -0.01029260f, -0.03651326f, 0.03012677f, 0.03534284f, -0.06049835f, -0.05246050f, -0.05394483f, 
    -0.01542603f, -0.03432671f, -0.05310405f, -0.01376543f, -0.04786526f, -0.00403336f, 0.01277790f, 0.03129370f, 
    -0.03092549f, 0.01091282f, 0.01144862f, -0.00879201f, 0.00174077f, -0.01516461f, 0.00611299f, -0.05837356f, 
    0.00752596f, -0.02035009f, 0.02388670f, 0.00673511f, -0.03035123f, 0.00933072f, 0.00638894f, -0.02358042f, 
    0.02774252f, -0.00168364f, -0.01456969f, 0.02383980f, -0.00309165f, 0.02793396f, 0.02095830f, -0.06378006f, 
    0.01075427f, -0.00999474f, -0.05303103f, 0.00886938f, 0.03472627f, 0.04880478f, 0.03579194f, -0.04432819f, 
    0.00536822f, 0.03404679f, 0.01435123f, -0.01337664f, -0.00021778f, -0.01991112f, -0.02735616f, 0.02322745f, 
    -0.01976842f, 0.03330429f, -0.00132747f, -0.03363125f, 0.02603988f, -0.02529316f, 0.02149289f, -0.03951000f, 
    -0.01149592f, -0.02693924f, -0.05395275f, 0.04101101f, 0.02388038f, -0.05950056f, 0.00560032f, -0.02996515f, 
    0.00381855f, -0.04255990f, -0.04182670f, -0.05198150f, 0.02406980f, 0.01801459f, -0.05618757f, 0.00084878f, 
    -0.01917611f, -0.01339602f, -0.04958625f, -0.04380677f, -0.05728498f, 0.04572491f, 0.03508367f, -0.04321929f, 
    -0.00822219f, 0.03286713f, -0.05477489f, -0.02841987f, 0.03150059f, 0.03563134f, 0.03311297f, 0.04416595f, 
    0.03538746f, 0.04162033f, 0.01866895f, 0.04437721f, -0.06007601f, -0.02248409f, 0.00848782f, 0.01568411f, 
    0.00161004f, 0.00817275f, -0.05011675f, -0.00126069f, -0.06202685f, -0.03125251f, 0.03631305f, -0.03722012f, 
    0.00651796f, -0.00830100f, -0.02349860f, 0.01104021f, -0.00776777f, 0.02318766f, 0.04391925f, -0.04348655f, 
    -0.05788033f, -0.05035823f, 0.04087250f, -0.05617528f, -0.02212698f, -0.04226668f, 0.00587599f, -0.05752132f, 
    -0.03535227f, 0.03161058f, -0.01458905f, 0.04614181f, -0.05449743f, -0.05036845f, 0.02310078f, 0.05026192f, 
    -0.03846752f, -0.02314670f, 0.00831217f, 0.03874286f, -0.04821267f, 0.02000723f, -0.06319721f, -0.06184910f, 
    -0.06248209f, -0.03733636f, -0.01994032f, -0.01823523f, -0.02166235f, -0.05120598f, 0.04456366f, -0.04663640f, 
    -0.04039531f, -0.03381454f, -0.01673725f, -0.05293032f, -0.02647081f, -0.00044169f, -0.02384170f, -0.03143447f, 
    -0.03355415f, -0.04760022f, 0.00922536f, -0.06226495f, -0.05301873f, 0.00301565f, 0.03527823f, -0.01266570f, 
    0.02128160f, -0.05917446f, -0.00384187f, -0.05625241f, -0.00892150f, 0.04213190f, 0.04300023f, 0.04421338f, 
    0.02605325f, -0.05974218f, 0.02002786f, -0.02963197f, 0.00443084f, -0.04258136f, 0.04083159f, -0.05348600f, 
    -0.01212434f, -0.01823657f, 0.01431919f, 0.00466933f, -0.00525744f, -0.04228884f, -0.04970129f, 0.00092945f, 
    0.04494565f, 0.00803468f, -0.02445437f, 0.02081877f, -0.01683616f, -0.04617693f, 0.03534181f, -0.00222577f, 
    0.02444779f, 0.04155101f, 0.01361935f, -0.00862513f, 0.02672212f, -0.03927155f, 0.04390427f, 0.01240833f, 
    -0.04553374f, 0.03356301f, 0.01842097f, 0.04173502f, 0.01032978f, 0.02957312f, 0.01738299f, 0.03335224f, 
    -0.03168578f, 0.02466878f, 0.04300637f, -0.02087018f, -0.01555152f, -0.03102188f, -0.05864603f, -0.05125661f, 
    -0.00931110f, 0.02443431f, 0.02516963f, 0.00898448f, -0.05154513f, -0.06014128f, 0.00709935f, -0.00829589f, 
    -0.05753692f, 0.00770298f, -0.03622891f, -0.02623693f, -0.05838653f, 0.01582355f, 0.01223800f, -0.00116796f, 
    0.02967305f, 0.02755109f, 0.04254073f, -0.06150626f, 0.02944001f, 0.00265580f, 0.01024770f, -0.02410677f, 
    0.04178483f, 0.00781906f, 0.02009554f, -0.02572794f, -0.05680526f, -0.01916297f, -0.00522757f, 0.03417926f, 
    -0.01216716f, -0.04956548f, -0.02467802f, -0.05129365f, 0.04682550f, -0.03459932f, 0.00616037f, 0.03044978f, 
    -0.03112402f, 0.03594292f, 0.02075877f, -0.01831055f, -0.03102044f, 0.04187569f, -0.01991040f, 0.00022872f, 
    0.02709190f, 0.03366305f, -0.01585451f, -0.04653236f, -0.01392097f, -0.01437028f, -0.01526301f, -0.04382857f, 
    0.01698557f, -0.03860175f, -0.03225303f, -0.05887156f, 0.03474224f, 0.05061419f, -0.05626508f, 0.02550414f, 
    -0.07972651f, 0.17977171f, 0.30049369f, -0.12114999f, -0.02560219f, 0.03459957f, 0.03198691f, -0.04768601f, 
    0.06120390f, 0.00742281f, -0.05143968f, 0.08344331f, 0.03150375f, -0.01862064f, 0.14442672f, 0.11899298f, 
    0.04445760f, 0.00152889f, 0.04275674f, 0.06442763f, 0.02624769f, 0.01945932f, 0.16633400f, 0.01932826f, 
    -0.17304365f, -0.21312504f, -0.03001277f, -0.05558226f, 0.01224201f, 0.01969741f, 0.00336089f, -0.00135057f, 
    0.00945480f, 0.03650296f, 0.10532088f, -0.00255605f, -0.03269934f, 0.03954133f, 0.14162278f, 0.01249079f, 
    -0.08493257f, -0.19742356f, 0.23448758f, -0.10488531f, -0.01860424f, -0.07686631f, -0.01241285f, 0.05846253f, 
    -0.14583303f, 0.02255790f, -0.04105677f, 0.02874619f, 0.05204157f, 0.02487842f, 0.06543168f, -0.01744944f, 
    -0.07207172f, 0.01934214f, -0.05955661f, 0.14928806f, -0.02359030f, -0.37511811f, -0.02006084f, 0.02954894f, 
    -0.11076088f, 0.12486798f, 0.08578848f, -0.03058222f, 0.03004921f, 0.00451108f, 0.05967062f, 0.01605974f, 
    0.00301059f, -0.01825870f, 0.03379234f, 0.07496423f, -0.02144825f, -0.02877983f, 0.02868970f, 0.04135709f, 
    -0.01873671f, 0.02192065f, 0.17220123f, -0.05888163f, -0.09440718f, -0.22295164f, 0.02753074f, -0.02811771f, 
    -0.10757052f, 0.04346815f, 0.05157061f, 0.05514704f, -0.05470253f, 0.08916913f, 0.00941666f, -0.03283219f, 
    0.00962578f, 0.06645548f, -0.08023640f, -0.01679504f, -0.09921816f, -0.17516814f, 0.09810356f, 0.02096477f, 
    0.06834000f, 0.01049093f, -0.03161781f, 0.03466137f, -0.11434833f, 0.03667616f, 0.10226901f, 0.13037132f, 
    -0.14948197f, -0.00910392f, -0.02808684f, -0.06578030f, 0.00708977f, -0.06482908f, -0.01074616f, -0.00725038f, 
    -0.22562486f, -0.26969448f, -0.02071844f, 0.14734291f, -0.05602473f, 0.08931903f, 0.02591069f, 0.01133920f, 
    0.06480402f, -0.04370466f, 0.11308558f, -0.01523390f, -0.14800604f, -0.01790825f, 0.00292787f, 0.01213883f, 
    0.03477921f, 0.00004337f, -0.04198983f, -0.06999442f, -0.26128384f, 0.04281922f, -0.09899520f, 0.02157480f, 
    -0.06764581f, -0.05417775f, -0.05875111f, -0.09819689f, 0.05008234f, 0.03304022f, 0.06153852f, -0.00018878f, 
    -0.03657212f, -0.01281865f, 0.10775210f, -0.05098585f, 0.03537232f, 0.00131840f, 0.00838113f, -0.03948784f, 
    -0.04135337f, 0.08442943f, -0.10947110f, -0.03960819f, 0.05385727f, 0.12361687f, -0.00699073f, 0.05448686f, 
    -0.00960107f, -0.03021360f, -0.07039653f, 0.09418695f, 0.02020441f, 0.02737736f, -0.02658791f, 0.05326482f, 
    0.02565486f, -0.08004573f, 0.02323136f, 0.02182973f, -0.32182094f, -0.03804342f, -0.17507733f, -0.11077742f, 
    -0.14698842f, 0.22302225f, 0.12732366f, 0.04440344f, 0.13416560f, 0.00379622f, 0.03649900f, 0.01136508f, 
    -0.02858336f, 0.02220874f, 0.01492300f, 0.01672208f, 0.00817414f, 0.01980320f, 0.00528544f, 0.03742542f, 
    -0.05642904f, -0.11093055f, -0.21348231f, 0.18940713f, -0.01554624f, 0.05967692f, -0.04161940f, -0.01598840f, 
    0.08655433f, 0.08279926f, 0.14898708f, -0.02439959f, -0.06610831f, -0.08579604f, 0.09096022f, -0.06287466f, 
    0.02623544f, -0.06312104f, 0.05227989f, 0.04350213f, 0.23825765f, -0.23032740f, 0.07726273f, 0.14593089f, 
    0.05719753f, 0.01790402f, -0.11410138f, 0.02247357f, 0.00105272f, -0.03317951f, 0.03739786f, -0.05118050f, 
    0.02555288f, -0.00427549f, 0.05413198f, -0.04351880f, -0.03205053f, 0.03910046f, 0.02005139f, -0.06649514f, 
    -0.12869930f, 0.19161110f, -0.02316417f, 0.07446679f, 0.03463338f, 0.08227251f, -0.13374375f, 0.09181708f, 
    0.04687745f, 0.00445356f, 0.05247611f, 0.03917896f, 0.05397473f, -0.00870294f, 0.04699419f, 0.08435086f, 
    0.07877581f, 0.05530358f, -0.10438558f, -0.04121191f, 0.14278206f, -0.01447504f, 0.17270695f, -0.06224906f, 
    0.05172566f, 0.03637195f, -0.02608686f, 0.10084829f, -0.00191267f, -0.05494266f, 0.14856569f, 0.09276165f, 
    -0.02352338f, 0.05267084f, 0.04415549f, 0.04024314f, 0.03659481f, 0.05870047f, -0.06312179f, -0.00765624f, 
    -0.21081872f, 0.08801206f, -0.01477476f, -0.13358054f, -0.10291668f, 0.17435086f, 0.01163400f, 0.00670873f, 
    0.03342590f, 0.01333540f, 0.06223249f, -0.01271646f, 0.03950111f, 0.02054679f, -0.00831626f, 0.01663859f, 
    0.03209694f, -0.05164665f, 0.09449600f, -0.04833908f, 0.00973415f, -0.10375586f, 0.20255421f, -0.07286685f, 
    0.05248630f, 0.03708686f, 0.13225637f, -0.02230608f, -0.02192097f, -0.01422063f, -0.09230015f, 0.01225015f, 
    0.06094076f, -0.03664887f, 0.04981145f, -0.05116302f, 0.02308614f, 0.03926751f, 0.04652262f, 0.07564640f, 
    0.21670236f, 0.24798892f, 0.07425451f, -0.06650233f, 0.04847291f, 0.14733019f, 0.02605716f, -0.03379174f, 
    0.04886023f, 0.12904175f, 0.18330665f, 0.01666651f, -0.09546544f, -0.01007811f, 0.06409756f, 0.12080128f, 
    0.05087416f, -0.04942460f, -0.20966522f, -0.01112798f, 0.13443136f, -0.10217393f, 0.02122315f, 0.05757647f, 
    0.14264692f, -0.09080086f, -0.06513295f, -0.09378982f, -0.14513177f, 0.00585925f, -0.01727146f, -0.00353018f, 
    -0.03482502f, -0.10971779f, 0.05644435f, 0.02161471f, 0.02742167f, -0.01066081f, 0.07517914f, -0.03598861f, 
    0.14613211f, 0.26475963f, -0.15437596f, 0.07868397f, -0.20592491f, -0.02143605f, 0.12208386f, 0.03479816f, 
    -0.12534045f, -0.00222145f, 0.05312781f, 0.10410377f, 0.02098315f, -0.10005363f, 0.02562784f, 0.05136644f, 
    -0.03876752f, -0.16562706f, -0.09879541f, -0.00878192f, 0.06880584f, -0.17148758f, 0.06626578f, 0.01899576f, 
    0.09510797f, -0.03833115f, 0.08175723f, 0.04301164f, 0.17934018f, -0.08406685f, 0.03433489f, -0.03646620f, 
    -0.06687783f, 0.06821189f, 0.09817626f, 0.10277927f, -0.02156682f, 0.03179928f, -0.06288999f, 0.14164431f, 
    0.11498898f, 0.12602469f, 0.14243796f, 0.00734429f, -0.01708425f, -0.10880615f, 0.05213163f, -0.17885876f, 
    0.02790738f, -0.06482624f, 0.01434305f, 0.07400730f, -0.06606325f, 0.08616758f, 0.00355824f, 0.06426188f, 
    0.05310237f, -0.08651105f, 0.00965149f, 0.03469384f, -0.16938154f, 0.02052329f, 0.09461173f, -0.03576546f, 
    -0.04551216f, 0.07442877f, 0.01852755f, 0.01450855f, -0.04768029f, -0.09841496f, -0.03506288f, 0.07649348f, 
    -0.00899944f, 0.06407199f, -0.06581120f, -0.09374869f, -0.00300539f, -0.00778365f, 0.04721509f, -0.06170762f, 
    -0.11976597f, 0.16231391f, -0.10746232f, 0.03814291f, -0.08372769f, -0.04646366f, -0.05239537f, -0.02740992f, 
    -0.03294538f, -0.17608683f, -0.08072846f, 0.06958637f, 0.04378449f, -0.06512692f, -0.09134205f, -0.05684164f, 
    -0.09527691f, 0.06378157f, 0.08596875f, -0.07421908f, -0.08190296f, 0.23343369f, -0.26588795f, -0.08859769f, 
    -0.09746844f, -0.11533386f, -0.09040005f, -0.04308973f, -0.20170070f, -0.01160930f, -0.04788433f, -0.04354452f, 
    0.05140414f, -0.09351677f, 0.04258043f, 0.03099518f, 0.03146391f, -0.06178614f, -0.03352254f, -0.07770994f, 
    -0.07037584f, 0.04904588f, -0.18609081f, -0.11269706f, 0.13431670f, 0.19377245f, 0.12061999f, 0.05528618f, 
    -0.03248176f, 0.14440753f, 0.03825964f, -0.06212820f, -0.02084635f, -0.01949557f, 0.04392233f, 0.04309755f, 
    0.08092944f, -0.20261587f, -0.31486011f, -0.11220177f, -0.27622744f, 0.06287462f, 0.24873735f, -0.02491409f, 
    0.20577425f, 0.01460549f, 0.09639467f, 0.06057450f, 0.06347719f, -0.06265879f, -0.05699139f, -0.08651432f, 
    0.14685135f, 0.10171781f, -0.07934202f, 0.02609950f, 0.07904106f, -0.10348468f, 0.01404816f, -0.09224173f, 
    -0.05645545f, -0.16597363f, -0.22504586f, 0.04818309f, 0.11188786f, -0.00391486f, 0.06881453f, -0.09469236f, 
    0.02025394f, -0.02013899f, 0.07499003f, 0.08696706f, -0.01476604f, -0.01118400f, 0.08125272f, -0.02291407f, 
    0.06364226f, -0.04461332f, 0.16562727f, 0.08851196f, 0.38922173f, -0.00568296f, 0.11796930f, 0.23235244f, 
    -0.01857026f, -0.06160734f, -0.11704737f, 0.03970749f, -0.01154411f, -0.06332321f, -0.12962894f, -0.09282678f, 
    0.03162961f, 0.08830878f, -0.05591410f, 0.15764567f, 0.05829632f, -0.11575289f, 0.04295428f, 0.00382329f, 
    -0.05770707f, 0.28480139f, 0.10949778f, 0.07178812f, 0.03992642f, 0.02953025f, -0.03883383f, 0.12536605f, 
    -0.01460999f, -0.00109220f, 0.04916807f, 0.01929026f, -0.01819710f, 0.07850917f, 0.09141578f, -0.02065577f, 
    0.12156579f, 0.05143129f, -0.20136885f, -0.07444780f, 0.19514659f, 0.05558765f, -0.08523967f, -0.03918525f, 
    -0.00153173f, 0.11941916f, -0.00197905f, 0.03694916f, 0.02279638f, 0.14286488f, 0.08976033f, -0.02259806f, 
    0.12901817f, 0.09722785f, -0.00536889f, 0.04280806f, 0.11016145f, -0.06733152f, -0.13765290f, -0.07885961f, 
    0.06694282f, 0.05830548f, 0.17020403f, -0.15068340f, 0.33975169f, 0.07603548f, -0.00914641f, 0.02000247f, 
    0.11758547f, -0.03834173f, 0.00550817f, -0.04345730f, -0.09730998f, 0.09321018f, -0.04134321f, 0.07449730f, 
    0.01216445f, -0.11060397f, -0.09255891f, -0.02928809f, 0.13242400f, 0.08250809f, 0.06496670f, 0.00570833f, 
    0.28249997f, 0.01845410f, 0.05859494f, -0.09356888f, 0.10505666f, 0.02767858f, -0.01471802f, -0.03450416f, 
    0.00888512f, -0.13180222f, -0.00050506f, -0.04396547f, 0.12079868f, -0.18960558f, 0.04361732f, -0.01122473f, 
    0.11380685f, -0.09498222f, 0.10429292f, 0.12908426f, 0.36768430f, 0.06505314f, -0.06020525f, -0.08303134f, 
    -0.03157611f, -0.00323280f, -0.04798634f, -0.04105891f, -0.04936343f, 0.07506506f, 0.05283590f, -0.05128267f, 
    0.04010507f, -0.00814435f, 0.11203779f, -0.04219932f, 0.00178595f, -0.20732875f, -0.01060742f, 0.18662679f, 
    0.19218548f, -0.06072339f, -0.07465146f, -0.03473474f, 0.00037315f, -0.05559395f, -0.06044040f, -0.02352791f, 
    0.03413089f, 0.04402500f, 0.12307967f, -0.06428384f, 0.04177441f, -0.08583374f, -0.11344489f, 0.12195893f, 
    0.02325008f, -0.04524546f, -0.10896286f, -0.13060011f, -0.03421548f, -0.07677308f, -0.04727538f, -0.06573726f, 
    -0.16009523f, 0.00587940f, -0.05683737f, 0.04637267f, -0.11634151f, 0.07248715f, 0.03352530f, 0.01810526f, 
    0.06796367f, 0.00995530f, 0.07943483f, 0.00603469f, 0.02755357f, -0.04002066f, -0.05386923f, 0.14972228f, 
    -0.15770535f, 0.08767237f, 0.10961360f, 0.07405943f, 0.04506939f, 0.04722934f, 0.11485711f, 0.04057718f, 
    -0.04577253f, -0.06007504f, -0.08697893f, -0.10774896f, 0.02953568f, -0.07519881f, -0.03501429f, -0.05569165f, 
    -0.08628737f, 0.08252404f, 0.18352573f, 0.08771062f, -0.18848327f, 0.06648421f, -0.07633401f, 0.01342035f, 
    -0.04144326f, -0.01268189f, 0.07454626f, 0.07244127f, 0.04573373f, -0.05373719f, -0.01482047f, -0.08724087f, 
    -0.05866512f, -0.00806092f, 0.02835577f, 0.01146373f, -0.03274451f, -0.02200114f, 0.00829599f, -0.04278459f, 
    -0.12461809f, -0.05344199f, -0.10298139f, 0.07718400f, -0.01596723f, 0.02589263f, 0.14728832f, 0.00113155f, 
    -0.01320354f, 0.04921793f, 0.17093123f, 0.01345893f, 0.04929889f, -0.08469664f, -0.18958132f, -0.00384448f, 
    -0.15450430f, -0.05302946f, -0.08975010f, -0.07362971f, -0.17437612f, 0.03760380f, -0.04436035f, 0.00485518f, 
    0.10535110f, 0.13092978f, -0.00068976f, 0.09886058f, -0.01719024f, 0.06275968f, 0.06135197f, 0.14802648f, 
    0.01136136f, -0.00895164f, -0.11784001f, 0.00558709f, -0.14000389f, -0.08123831f, -0.16131906f, -0.05666301f, 
    0.12037470f, 0.04805669f, -0.02222380f, -0.09108382f, 0.06750291f, -0.05432776f, 0.00389627f, 0.11306282f, 
    -0.08352969f, 0.08253877f, -0.00287992f, -0.01710095f, 0.02119389f, 0.02474343f, -0.10332628f, 0.00856678f, 
    0.38917547f, 0.22655454f, 0.09599994f, -0.04407678f, 0.02371004f, -0.07765353f, -0.03995606f, 0.06534717f, 
    -0.07819345f, -0.05082958f, 0.12796167f, 0.07559701f, -0.02229445f, -0.09165660f, -0.03770086f, 0.01945126f, 
    0.10784963f, 0.15958144f, 0.05504369f, 0.06674980f, -0.25861174f, 0.23684044f, -0.06723365f, -0.05932967f, 
    -0.14795211f, 0.04444985f, 0.07514296f, 0.10400319f, 0.04504756f, 0.03408145f, 0.06363554f, 0.04497140f, 
    -0.10900255f, 0.06624832f, -0.00922875f, 0.12186119f, 0.08310167f, 0.05271120f, 0.10301621f, 0.06072926f, 
    -0.12444973f, -0.06432822f, -0.00172513f, 0.12030944f, 0.00910913f, 0.11692403f, -0.08976465f, -0.02867275f, 
    0.05448937f, -0.00554631f, -0.02491660f, -0.02789075f, 0.01397027f, 0.11895631f, 0.08683841f, -0.14115854f, 
    -0.08668103f, -0.12511903f, -0.16909705f, 0.00753286f, -0.35848993f, 0.34194511f, -0.03043456f, -0.07570659f, 
    0.13976723f, -0.09192752f, 0.09545927f, -0.02436007f, 0.03252831f, 0.07824774f, 0.13133676f, -0.07554250f, 
    -0.14061400f, 0.05786305f, -0.06058311f, -0.05756854f, -0.04290922f, 0.07757189f, -0.01542775f, -0.07627826f, 
    0.17955148f, 0.03039693f, 0.01476737f, -0.08501620f, -0.18831410f, 0.03108758f, -0.01871760f, -0.02009099f, 
    -0.07694285f, -0.11507043f, 0.07209018f, 0.03663239f, 0.04009343f, 0.02946841f, 0.00731603f, -0.05540630f, 
    0.05724377f, -0.02001776f, 0.03883952f, -0.03377278f, 0.05681233f, 0.16825931f, 0.02279297f, 0.05730617f, 
    0.15327930f, 0.03764188f, 0.00096828f, -0.03524649f, -0.04703175f, -0.10785546f, 0.02372986f, 0.05542817f, 
    0.07133302f, 0.01130430f, 0.04148020f, 0.06597960f, -0.03280463f, -0.08778232f, 0.09938410f, -0.00511150f, 
    -0.39524311f, 0.30982271f, 0.05391859f, -0.05207624f, -0.10957316f, 0.05076386f, 0.04289097f, -0.01396753f, 
    0.00634083f, -0.08892567f, 0.03592743f, 0.01627307f, -0.09892212f, -0.05573639f, -0.09527072f, 0.04662323f, 
    0.05433126f, 0.14976513f, 0.05633270f, 0.06971696f, -0.03079243f, 0.14816742f, -0.11064181f, -0.02032231f, 
    0.29502612f, -0.12457033f, -0.02167811f, -0.07134897f, 0.02411745f, 0.06948968f, 0.00418537f, -0.07911558f, 
    0.10846892f, 0.03645521f, 0.12641211f, 0.03919915f, 0.03193019f, 0.17943421f, 0.09588902f, 0.06206933f, 
    0.29471663f, 0.25541478f, 0.03470226f, -0.08087571f, -0.07344587f, 0.07533330f, 0.15638737f, 0.07374998f, 
    0.09969895f, 0.00559187f, -0.02095331f, 0.02447314f, 0.00247249f, -0.12672447f, 0.06947307f, 0.04879199f, 
    -0.04296326f, -0.02922316f, -0.01106985f, 0.04792704f, 0.18781875f, 0.23324153f, -0.18586405f, -0.35919419f, 
    -0.16398987f, 0.18671268f, -0.02168184f, -0.05885303f, 0.03722906f, -0.06359505f, 0.13354543f, 0.01826257f, 
    0.03012252f, 0.08098689f, -0.14083375f, 0.06434982f, 0.02154140f, -0.02872262f, 0.06097729f, -0.06425473f, 
    -0.18582082f, 0.38409394f, 0.17540425f, 0.00302472f, 0.15329793f, 0.19074246f, -0.03396443f, 0.00341843f, 
    0.16003884f, 0.05184472f, 0.05545164f, -0.07240871f, 0.04667574f, 0.02416141f, -0.06829739f, 0.02460882f, 
    0.05910164f, 0.01850199f, -0.07405415f, -0.05554684f, 0.05852207f, -0.06753981f, 0.20202830f, -0.28930566f, 
    -0.08332090f, -0.18194123f, -0.15435503f, -0.16516776f, -0.10259195f, -0.07750672f, 0.03423150f, -0.05210708f, 
    0.06413429f, 0.10437527f, 0.06395121f, 0.07308379f, 0.12319070f, -0.00598790f, -0.00678750f, 0.02311582f, 
    -0.10423835f, -0.29261503f, -0.11962014f, -0.08385469f, 0.14810452f, -0.04518807f, 0.06325904f, 0.07901429f, 
    -0.04431699f, 0.02470491f, 0.01824654f, -0.05322830f, 0.01914920f, -0.01740823f, 0.05711542f, 0.16079512f, 
    0.03284433f, 0.07685513f, 0.03274482f, -0.07355901f, 0.19255739f, -0.07586528f, -0.12586370f, 0.02665130f, 
    0.06501199f, -0.05060289f, -0.12970111f, -0.10896770f, 0.02253169f, 0.03989218f, 0.02418860f, -0.04486830f, 
    0.10599529f, -0.07208742f, 0.03259593f, 0.06439971f, -0.06000717f, 0.07835950f, 0.06880119f, -0.01831687f, 
    -0.07812254f, -0.18116584f, 0.13279499f, -0.06127992f, -0.06151594f, -0.06345756f, 0.01327011f, 0.07264242f, 
    -0.06364867f, 0.09190103f, -0.01602687f, -0.03504385f, -0.02155893f, 0.01239923f, -0.01581756f, 0.04240976f, 
    -0.06003791f, -0.06437825f, 0.07169166f, -0.00144195f, -0.06371452f, 0.09021435f, 0.12795882f, -0.06900391f, 
    -0.07959114f, -0.03904203f, 0.02392044f, 0.10021184f, -0.00892691f, 0.09857678f, 0.07885610f, 0.01195538f, 
    0.09599970f, -0.03317903f, -0.08964616f, 0.00852801f, -0.03913080f, -0.00443515f, 0.10298372f, 0.08359243f, 
    0.05761809f, -0.04897227f, 0.14027171f, 0.11779197f, 0.20500858f, 0.11137863f, 0.02637223f, 0.09934753f, 
    0.09099554f, 0.07566676f, -0.05248166f, 0.01077392f, 0.06036409f, 0.03319064f, 0.03984418f, -0.05418715f, 
    0.02256270f, -0.06707518f, -0.03243179f, -0.04386472f, 0.31300768f, -0.10415810f, -0.02442714f, -0.04695378f, 
    -0.17514671f, -0.10796439f, -0.06742726f, -0.17375253f, -0.09666837f, 0.03606234f, 0.05243055f, 0.01831977f, 
    0.03054404f, -0.00338190f, 0.02131312f, 0.06633947f, -0.18038304f, 0.00438144f, -0.11323614f, 0.01022129f, 
    -0.14304736f, -0.08846498f, -0.19951482f, -0.16833086f, -0.19125935f, -0.12000377f, 0.00890155f, 0.06214136f, 
    -0.06197285f, -0.01569404f, -0.01069985f, -0.05033729f, 0.01183044f, -0.04588407f, -0.02557734f, 0.07909616f, 
    0.02005011f, 0.04129627f, 0.01106311f, 0.03672226f, 0.13195083f, -0.30759552f, -0.04782643f, 0.01911149f, 
    0.04665620f, 0.09682193f, 0.03348079f, -0.05220551f, -0.07230552f, 0.03788957f, -0.00105554f, -0.03728616f, 
    0.13877881f, -0.09378410f, 0.03466748f, 0.07675743f, 0.06697729f, 0.04878617f, 0.02921770f, 0.05248990f, 
    0.14168879f, -0.06239627f, 0.11692935f, -0.01327577f, 0.13375646f, -0.03662696f, 0.09689847f, -0.08813890f, 
    0.13217647f, 0.09021821f, 0.03284257f, -0.04386036f, -0.02477044f, -0.03199279f, -0.04019187f, -0.04988499f, 
    0.02996901f, -0.07375538f, -0.00349834f, 0.13659312f, -0.08548113f, -0.07629520f, 0.14140980f, -0.11818618f, 
    0.02592797f, -0.01437990f, 0.06704769f, 0.02828781f, -0.00407868f, -0.04619857f, 0.01243037f, 0.13616301f, 
    -0.08328868f, 0.06934010f, 0.03523792f, 0.07105611f, 0.00806558f, 0.05373701f, -0.09991548f, -0.02717346f, 
    0.34221530f, -0.18634361f, 0.16409969f, 0.02843189f, 0.03107593f, -0.13922480f, 0.06075628f, -0.01837983f, 
    -0.12258807f, 0.12467746f, -0.04076714f, 0.12245120f, 0.06766456f, 0.05686292f, 0.03916436f, -0.08043635f, 
    -0.09370624f, -0.00831830f, -0.11799856f, -0.07887206f, 0.59063429f, 0.26807073f, 0.09255944f, 0.00311309f, 
    -0.05604501f, 0.22770664f, 0.08864246f, 0.01964477f, 0.04559379f, 0.05020235f, 0.04251285f, 0.09277022f, 
    -0.03753540f, -0.01891722f, 0.03457692f, -0.06871748f, -0.01000701f, 0.00889761f, -0.07404073f, -0.06096902f, 
    0.10610669f, -0.23990797f, -0.01963811f, -0.10514948f, 0.24478228f, 0.08659466f, 0.14322631f, 0.09005783f, 
    -0.06689352f, 0.01825126f, 0.00942772f, 0.03800530f, -0.00559378f, 0.10053178f, -0.04725925f, 0.00194140f, 
    -0.03101045f, -0.03139047f, 0.04391730f, -0.09987877f, -0.13191672f, 0.02512644f, -0.28358504f, -0.09859003f, 
    0.04085778f, 0.12630187f, 0.10033932f, 0.01259870f, 0.01682152f, -0.06080051f, -0.02539850f, 0.02085784f, 
    0.05527773f, -0.06910054f, -0.05892776f, -0.02071235f, 0.12247107f, 0.01680393f, -0.07397693f, -0.05580674f, 
    -0.04277109f, -0.06964553f, -0.04676677f, -0.09897282f, -0.00642909f, 0.10120454f, -0.05654543f, 0.10235786f, 
    -0.02360501f, 0.09222894f, 0.04587341f, -0.04282066f, -0.04362162f, 0.05957913f, -0.04057993f, 0.02614572f, 
    0.06731131f, 0.04435487f, 0.15602615f, -0.05135613f, -0.20479836f, 0.01854854f, 0.17136104f, 0.20691286f, 
    -0.13278908f, -0.10824556f, -0.09264582f, -0.09016441f, 0.03430106f, 0.04346278f, -0.00332521f, 0.03511643f, 
    -0.04296742f, 0.02891884f, -0.00935753f, -0.02553787f, 0.06471803f, -0.05429517f, 0.01557402f, -0.14074522f, 
    -0.05658217f, 0.07589900f, -0.14522175f, 0.00869448f, -0.06186178f, 0.19007298f, 0.05732436f, -0.04633688f, 
    -0.07512254f, 0.00844667f, 0.06383013f, 0.03402808f, -0.00570649f, -0.00068729f, -0.01638391f, 0.00895518f, 
    0.03495144f, -0.06964134f, -0.01160423f, 0.01883471f, 0.25676873f, 0.08215368f, -0.06910362f, -0.08084495f, 
    -0.15398307f, -0.05854942f, -0.01562117f, -0.01058113f, 0.04027053f, 0.03729526f, 0.01448904f, 0.00083355f, 
    0.12367711f, 0.03447843f, 0.01590451f, 0.08627784f, -0.04845445f, -0.05195338f, 0.03421828f, 0.13279979f, 
    0.07517436f, -0.11029568f, 0.17123142f, 0.01129269f, -0.31278670f, -0.03590701f, -0.13151732f, -0.09246274f, 
    0.00202031f, 0.02304716f, 0.05974066f, 0.09804296f, 0.05781070f, 0.10007217f, -0.01712675f, 0.12195636f, 
    0.02705427f, 0.08161857f, -0.09309112f, 0.09237544f, 0.32560599f, 0.06092128f, 0.07009868f, -0.01189409f, 
    -0.09554017f, -0.04657674f, -0.06443136f, 0.04294180f, 0.11334001f, 0.07093628f, -0.09850755f, 0.03842775f, 
    0.02032500f, 0.15795664f, -0.10864188f, 0.05270342f, 0.03973707f, 0.08320459f, 0.05362786f, 0.10149345f, 
    0.18751061f, 0.20072077f, 0.10795060f, -0.10978199f, -0.04064143f, 0.00667545f, -0.01440930f, 0.17818308f, 
    0.05370259f, 0.01933079f, 0.08645885f, 0.02750416f, 0.02294881f, -0.05517272f, -0.06889895f, -0.09487228f, 
    0.01108964f, 0.03611623f, 0.09916910f, 0.11617102f, 0.16663913f, 0.00928785f, 0.12499487f, 0.15201840f, 
    -0.00700439f, -0.16919616f, -0.09141388f, -0.04259096f, -0.00686425f, 0.10582438f, 0.07540523f, 0.01374580f, 
    -0.11174024f, -0.04294353f, 0.08533361f, -0.04314648f, -0.01799517f, 0.06256119f, 0.03810971f, 0.00383839f, 
    0.10489724f, -0.01949708f, 0.14538050f, 0.02321230f, -0.24577826f, -0.07743534f, 0.02979368f, -0.16236284f, 
    0.04081244f, -0.04594111f, 0.02452089f, 0.08681491f, 0.07445030f, -0.02967059f, -0.04128950f, 0.02711089f, 
    -0.00665098f, -0.03497720f, -0.12137368f, -0.06237720f, -0.02965994f, 0.14995877f, -0.14376427f, -0.09113766f, 
    -0.01650689f, 0.05052699f, 0.10366067f, -0.09014975f, 0.02637814f, 0.11355461f, -0.02366895f, -0.06188127f, 
    -0.04110501f, -0.02029115f, -0.05642793f, -0.01430363f, -0.00653820f, -0.07278053f, 0.01828388f, 0.04295902f, 
    0.12326279f, 0.04158460f, 0.17079677f, -0.03978657f, -0.20697768f, -0.04186612f, -0.03560199f, 0.07130151f, 
    0.05224288f, 0.06487786f, -0.00366997f, -0.06572172f, -0.03392692f, -0.03242737f, -0.02903451f, 0.01821447f, 
    -0.04760557f, -0.04222121f, 0.03604287f, -0.05959775f, 0.06855775f, 0.06295074f, 0.10771661f, -0.06594675f, 
    0.06660126f, 0.07476115f, -0.07606831f, -0.01239365f, -0.04249055f, 0.13849577f, -0.02959629f, -0.06624887f, 
    -0.00640702f, 0.03506121f, 0.00759028f, 0.05687695f, 0.01145213f, -0.05133259f, 0.06469797f, 0.02943183f, 
    0.19230677f, 0.13372417f, 0.23469660f, -0.02298884f, 0.08731261f, -0.04906475f, -0.08994452f, -0.03965725f, 
    0.01148005f, -0.02699354f, -0.00295477f, -0.02964500f, 0.06221089f, -0.09466153f, 0.00783598f, 0.02307061f, 
    -0.05736806f, -0.02369929f, 0.15259111f, 0.06334254f, -0.02456529f, 0.04234276f, -0.11917906f, -0.02356867f, 
    0.09546276f, 0.07673794f, 0.15040253f, -0.01884904f, -0.01995316f, -0.01963741f, -0.02366654f, -0.02248701f, 
    0.00517187f, 0.11347979f, 0.04174919f, 0.02549625f, 0.02594666f, 0.16165969f, 0.02153496f, 0.06766444f, 
    -0.03773698f, -0.05038525f, 0.04557034f, -0.02515472f, -0.03616652f, -0.04416186f, -0.03710244f, -0.01058048f, 
    0.04648373f, -0.02554949f, -0.04832011f, -0.00057114f, -0.00777764f, 0.00495681f, -0.04289115f, 0.03029989f, 
    -0.01586317f, -0.00914438f, -0.04004100f, 0.04828398f, -0.02096033f, 0.00530241f, -0.00684472f, -0.02421018f, 
    0.04057872f, -0.02440705f, 0.01291845f, -0.01160106f, 0.02659695f, -0.05923669f, 0.04010046f, -0.03071515f, 
    0.03705906f, -0.05157424f, -0.04827715f, 0.01801726f, -0.00552108f, 0.01305087f, 0.00517356f, -0.04354142f, 
    0.02081192f, 0.02303492f, -0.04321875f, 0.01589376f, -0.04390934f, -0.02318371f, -0.02236865f, 0.00701754f, 
    0.02020503f, 0.02299936f, 0.02807293f, 0.03989609f, -0.02493431f, -0.04150907f, -0.00922444f, -0.03001549f, 
    -0.02547973f, 0.02630896f, 0.03404637f, 0.02520918f, -0.02254822f, -0.03756572f, -0.00646306f, 0.04849863f, 
    0.02901624f, -0.03454885f, 0.04689426f, -0.04703508f, -0.05905472f, -0.00469761f, 0.00892249f, 0.02809758f, 
    -0.02609926f, 0.00887106f, -0.00008975f, -0.03328372f, 0.02696217f, 0.02310328f, 0.01497994f, 0.00210805f, 
    -0.00899836f, 0.00515435f, -0.01200252f, -0.00278170f, -0.04623879f, -0.00741064f, 0.02136078f, -0.06037845f, 
    -0.00861398f, 0.04863606f, -0.01900390f, 0.01914456f, 0.01082514f, -0.02540471f, -0.04617626f, 0.04275417f, 
    -0.02600732f, -0.00558937f, -0.05698106f, 0.01068391f, -0.05391687f, -0.00443757f, -0.00335414f, 0.00653564f, 
    0.01019807f, -0.04697227f, 0.00642840f, 0.03186214f, 0.03826193f, -0.03512906f, 0.02888573f, 0.03560570f, 
    -0.03948831f, -0.01351788f, -0.03854774f, -0.02773068f, -0.00937488f, -0.05690559f, 0.00988584f, 0.01870702f, 
    0.02632008f, -0.01031541f, 0.01778788f, -0.02755170f, -0.05845896f, -0.04479026f, -0.00485883f, 0.03322550f, 
    -0.02838824f, 0.00110680f, 0.02644257f, -0.00520260f, -0.00511897f, -0.01163428f, -0.03073952f, 0.04740497f, 
    -0.03078140f, 0.00933398f, -0.02385223f, 0.02308574f, -0.05368768f, 0.01280285f, -0.01023228f, -0.03906017f, 
    0.01046545f, 0.04296092f, -0.04501252f, 0.01253162f, 0.04176188f, -0.02808893f, -0.01407861f, 0.03293467f, 
    -0.05187054f, 0.00521299f, -0.03642009f, -0.03159089f, -0.02494631f, -0.05739943f, -0.01065954f, 0.02612501f, 
    0.04219852f, -0.01247102f, -0.02805348f, -0.02552961f, -0.04676168f, -0.05467591f, 0.04266940f, -0.02386995f, 
    0.02190614f, -0.00304757f, -0.05287655f, -0.01601133f, 0.04780103f, 0.00997768f, 0.01080526f, 0.02465560f, 
    0.01636725f, 0.03864295f, 0.03926553f, 0.00335103f, -0.02897003f, -0.03527235f, -0.04523940f, 0.01644095f, 
    -0.01971657f, -0.02323266f, -0.04959115f, 0.01105494f, 0.04482947f, 0.04666651f, 0.03587024f, -0.06037542f, 
    -0.03925492f, 0.01478899f, -0.05215444f, 0.00703041f, -0.02247316f, -0.05990295f, -0.03579530f, -0.05170621f, 
    -0.00760594f, -0.06084612f, 0.04725802f, 0.01238160f, -0.01933402f, 0.03555246f, 0.03264683f, -0.01984436f, 
    0.01629233f, -0.03985562f, -0.00650712f, -0.02538960f, -0.02074851f, -0.02513162f, -0.02839936f, 0.01140584f, 
    -0.04898943f, 0.02198095f, -0.02156103f, -0.01739288f, -0.03195345f, 0.02240414f, -0.04368315f, -0.05376383f, 
    -0.04620970f, 0.02461157f, -0.00056708f, -0.02996622f, -0.05216765f, 0.03982133f, -0.02510194f, 0.00845805f, 
    0.00920670f, 0.01862801f, -0.00858550f, -0.05325719f, 0.02911538f, -0.03292629f, 0.02099960f, 0.02974133f, 
    0.03980369f, 0.03922494f, -0.00885892f, -0.04730631f, -0.03217011f, 0.04396048f, 0.02826842f, 0.02167142f, 
    -0.04670981f, -0.05248895f, -0.01207121f, -0.01032997f, -0.04931590f, -0.01453662f, 0.04117753f, -0.00155267f, 
    -0.01007062f, 0.02217576f, -0.01688813f, -0.04896167f, -0.04877925f, -0.04959071f, 0.04580357f, 0.00743402f, 
    -0.05255399f, -0.05242159f, 0.04737326f, -0.05940660f, -0.02132074f, 0.00043281f, -0.05007240f, -0.03976531f, 
    -0.05672144f, 0.02959123f, -0.03853711f, -0.02227115f, -0.00113845f, 0.01010832f, -0.00696261f, 0.00103112f, 
    -0.04777308f, 0.04101204f, -0.01337887f, -0.05224982f, 0.03819755f, 0.04555461f, -0.01376663f, -0.03362165f, 
    -0.04277613f, -0.02562909f, -0.02177892f, -0.02630215f, 0.02122281f, -0.00370982f, -0.04038997f, -0.01841215f, 
    0.04064621f, -0.05895260f, 0.01006785f, -0.03246347f, -0.02383245f, -0.04206900f, 0.01825274f, 0.03011651f, 
    0.00903947f, -0.03575014f, -0.03259505f, -0.00997458f, 0.02228389f, 0.05451731f, 0.03022869f, -0.04433981f, 
    0.00603016f, -0.02074485f, -0.05053293f, 0.00679218f, 0.04521659f, -0.01126576f, -0.02429016f, 0.01518090f, 
    -0.27892336f, -0.09261896f, 0.03471764f, 0.18248779f, 0.02701740f, -0.02206626f, -0.11095937f, -0.01373777f, 
    0.01842133f, -0.21525969f, -0.10622767f, 0.06202018f, -0.04629876f, 0.02504958f, -0.04422219f, 0.02942964f, 
    -0.02178149f, 0.03792595f, 0.02475897f, -0.09347816f, -0.04366925f, 0.11100906f, -0.00898177f, 0.04239437f, 
    0.15324800f, -0.15817711f, 0.04134144f, 0.07641757f, 0.08770225f, 0.03372093f, -0.13888012f, -0.16546610f, 
    0.00086444f, 0.12438320f, 0.11522842f, -0.03791502f, 0.08733258f, -0.01735706f, -0.11280895f, -0.04175792f, 
    -0.01946322f, 0.16754839f, 0.08053654f, -0.07586410f, -0.16999763f, -0.12537716f, 0.00952287f, -0.02239057f, 
    -0.03416804f, 0.09990827f, -0.03193968f, -0.11167435f, -0.04316413f, 0.04448844f, -0.02570552f, 0.14635490f, 
    -0.01128379f, 0.03003626f, 0.04851402f, 0.15246162f, 0.06892963f, 0.18344910f, -0.11987165f, 0.18570167f, 
    0.14458451f, 0.13694841f, 0.13076752f, 0.02987277f, 0.04982812f, 0.24161266f, -0.13079873f, 0.06310456f, 
    0.08911324f, -0.15969795f, -0.07124022f, -0.03084495f, -0.02446063f, 0.10144112f, 0.04527593f, -0.04510431f, 
    -0.09926645f, 0.05455018f, 0.18051346f, 0.34210899f, -0.37597731f, 0.05971319f, -0.00950657f, -0.02716517f, 
    -0.01778829f, 0.00049376f, -0.11232748f, -0.00431514f, -0.01172377f, -0.08614062f, -0.02800599f, -0.07268721f, 
    -0.00861768f, 0.02355435f, -0.08074339f, -0.03330851f, -0.05406114f, 0.07493775f, 0.28304523f, -0.05591298f, 
    0.02656349f, -0.09972159f, -0.07890923f, 0.03683534f, 0.03049601f, 0.01553618f, 0.05859129f, 0.01191629f, 
    -0.05655252f, 0.03203080f, -0.07672316f, -0.06573278f, 0.05872380f, -0.13838989f, 0.00458112f, 0.13023371f, 
    -0.02319135f, 0.06418190f, 0.03132672f, 0.00568868f, 0.09381013f, -0.02179352f, 0.01581109f, -0.12538873f, 
    -0.09939926f, 0.06839810f, 0.10462377f, 0.01187474f, -0.04300327f, 0.07797415f, 0.02426649f, 0.05481167f, 
    0.07352863f, 0.03036783f, -0.04048777f, -0.05271753f, 0.19796462f, 0.07432535f, 0.00618185f, -0.06436399f, 
    -0.06175117f, -0.02501773f, -0.08644895f, -0.08075371f, -0.06103741f, -0.04346142f, 0.00762037f, -0.01557629f, 
    -0.15115650f, 0.00782047f, -0.00275058f, 0.04998960f, 0.15569761f, 0.05908098f, -0.10593153f, 0.09919041f, 
    0.02532017f, 0.08343544f, 0.18554009f, -0.11138207f, 0.02114591f, -0.07619226f, 0.01181359f, 0.05750706f, 
    -0.02906734f, -0.09946037f, 0.01083718f, 0.05898374f, -0.04561984f, -0.01928244f, 0.03349104f, 0.12452093f, 
    -0.04784520f, 0.06510556f, 0.01206941f, 0.03106676f, -0.06235327f, 0.25123167f, -0.00620186f, -0.10098818f, 
    0.02005726f, 0.18144353f, 0.07891782f, 0.05905276f, 0.00134363f, -0.03242624f, 0.00293541f, 0.00963175f, 
    0.00264422f, -0.00043295f, -0.06223242f, 0.08988085f, -0.06664387f, -0.04513822f, 0.10595894f, 0.00961803f, 
    0.31727111f, -0.01217547f, 0.03808871f, 0.19810733f, 0.12016606f, 0.10732658f, -0.03083915f, 0.06234573f, 
    -0.02841298f, 0.02850061f, 0.01483724f, -0.04378314f, 0.03706063f, 0.03330084f, 0.05696722f, -0.10646472f, 
    0.01824117f, 0.04855291f, -0.03165517f, -0.01961838f, -0.03057310f, -0.12522268f, 0.10365286f, 0.21674570f, 
    -0.15654249f, 0.07826414f, -0.00513839f, -0.04071843f, 0.08248300f, -0.05353117f, 0.13752438f, 0.12454946f, 
    -0.07164997f, 0.05692981f, -0.05660779f, -0.04569735f, -0.03338777f, 0.04903452f, -0.02067193f, -0.05241949f, 
    -0.09713741f, 0.17695488f, -0.12043848f, -0.17745477f, 0.09190331f, 0.01826399f, 0.06446740f, 0.05746970f, 
    -0.02393632f, 0.02486905f, 0.03581690f, 0.06702136f, 0.04321274f, -0.05219288f, 0.06750398f, 0.05707704f, 
    0.00659894f, 0.08895008f, -0.00367052f, -0.04605551f, 0.05848602f, 0.32723841f, 0.16746898f, -0.04718772f, 
    -0.17343959f, -0.05805903f, 0.00763686f, 0.07359841f, 0.03158897f, -0.07924885f, 0.01971876f, 0.03295923f, 
    -0.03983187f, 0.01126799f, -0.07091787f, 0.13688472f, -0.07853971f, -0.12122209f, 0.00853730f, 0.04410353f, 
    -0.26160955f, 0.11283017f, 0.05014526f, 0.05665559f, -0.14476253f, 0.07664866f, -0.03020899f, -0.02603937f, 
    0.06984364f, -0.00503822f, 0.08109832f, 0.01120600f, 0.08513858f, -0.12202348f, -0.00734635f, 0.01236679f, 
    0.04176660f, 0.06384709f, 0.11526419f, 0.01990932f, -0.18774228f, -0.09403758f, 0.06899751f, -0.06147178f, 
    -0.38855347f, -0.12762921f, 0.10135499f, 0.05251686f, -0.04629545f, -0.10330388f, -0.10089079f, 0.00181359f, 
    -0.02067255f, 0.02588089f, 0.00802932f, -0.02226545f, -0.03022406f, -0.00092492f, 0.00680430f, 0.04359009f, 
    -0.21052955f, -0.13624653f, -0.23337534f, -0.04422463f, -0.17500271f, -0.06482210f, -0.11775240f, 0.04249493f, 
    -0.01010188f, 0.03150246f, 0.10478151f, 0.02722047f, -0.03900288f, 0.08529446f, -0.07335615f, -0.04738796f, 
    0.02512970f, 0.00810346f, -0.03651141f, 0.04286084f, 0.11671742f, 0.09294055f, 0.10620356f, 0.10244931f, 
    0.14591637f, 0.16819917f, 0.02502431f, -0.00398191f, 0.02861288f, 0.02039490f, 0.04165339f, 0.04999461f, 
    -0.02767110f, 0.03185770f, -0.05469276f, 0.17254637f, 0.04828198f, -0.05582549f, 0.01029147f, 0.00423360f, 
    -0.02895075f, 0.00885827f, -0.03495376f, 0.06788872f, 0.34292638f, 0.03626737f, 0.06059122f, 0.00193364f, 
    0.02326022f, -0.00736120f, 0.06680557f, 0.02842669f, -0.07138974f, -0.00055578f, -0.01237752f, -0.03464485f, 
    0.13383360f, -0.06406474f, 0.02407536f, 0.02389253f, 0.23019008f, 0.15499806f, -0.08748505f, -0.07631323f, 
    0.03378892f, -0.07400134f, -0.08338255f, 0.12602226f, -0.06379681f, 0.01604239f, -0.03410816f, -0.11280625f, 
    -0.00924611f, -0.00635124f, -0.02453410f, -0.10711199f, -0.02714521f, 0.02652887f, -0.09330283f, -0.01359323f, 
    0.06809853f, 0.14818269f, -0.01577111f, 0.08668264f, 0.11327632f, 0.13367063f, -0.12586808f, 0.00743157f, 
    0.07512674f, 0.06315327f, -0.03478626f, 0.00389199f, 0.02468317f, -0.04032495f, 0.06871497f, 0.12282512f, 
    -0.11074115f, 0.01285620f, 0.06978524f, 0.04208823f, 0.10476504f, 0.04802449f, -0.01863822f, 0.06381772f, 
    -0.09539095f, 0.03968167f, 0.07076692f, 0.03063338f, 0.07814505f, -0.00701622f, 0.02925363f, -0.02858642f, 
    0.02250530f, -0.00604617f, 0.06885381f, 0.06203628f, 0.08777631f, 0.05275417f, 0.06488089f, -0.02059244f, 
    0.19837058f, 0.04314173f, 0.00305956f, -0.00793541f, 0.11036474f, -0.04649172f, -0.01809602f, 0.01758213f, 
    0.03658936f, 0.11176244f, -0.03642970f, 0.00372931f, 0.02711755f, 0.03476928f, 0.02189435f, 0.04522833f, 
    0.03897380f, -0.03295424f, 0.14188796f, 0.06879654f, -0.05399975f, -0.01123455f, 0.04039833f, -0.02344689f, 
    0.10167433f, 0.16431315f, 0.10078651f, 0.00699982f, -0.02197026f, 0.04384201f, 0.00001048f, 0.03696892f, 
    -0.00718688f, -0.08989877f, 0.07935794f, 0.00122781f, -0.02064781f, 0.03383433f, 0.05602290f, 0.04897850f, 
    -0.11263512f, -0.16361642f, 0.06349030f, -0.07975376f, -0.06978633f, -0.01856677f, 0.04705491f, -0.03944289f, 
    -0.04164817f, 0.02044603f, 0.01093986f, -0.03335222f, 0.07724584f, 0.01319882f, 0.12316044f, 0.07248013f, 
    0.05245456f, 0.09760030f, 0.03432046f, 0.00096886f, 0.20615102f, 0.00016719f, 0.08500339f, -0.03566517f, 
    -0.09168579f, -0.01512653f, -0.07979167f, 0.02816571f, -0.05322823f, -0.04294161f, 0.05803167f, 0.07119169f, 
    0.06092173f, 0.02114088f, -0.04373362f, -0.01236902f, 0.05329882f, 0.02507737f, -0.00299643f, -0.02862724f, 
    0.01871472f, 0.20064016f, 0.07671249f, -0.01628683f, 0.01513315f, 0.01667656f, 0.01243906f, 0.12880340f, 
    -0.02253122f, 0.00688163f, -0.04745382f, -0.01542298f, 0.01176721f, 0.00259907f, 0.04452917f, -0.02337664f, 
    0.06391114f, -0.01341675f, 0.04698954f, -0.01840562f, -0.33424893f, 0.29676455f, -0.01788794f, -0.05109619f, 
    0.06038158f, 0.09180207f, -0.03068310f, 0.01236039f, -0.01500738f, 0.05499273f, 0.03563762f, -0.00136875f, 
    -0.03235317f, 0.05419011f, 0.08040174f, -0.04332218f, 0.07233132f, 0.09724145f, -0.06439900f, -0.01300605f, 
    0.09870984f, -0.23577569f, -0.03239979f, -0.08446363f, 0.03955971f, -0.08352263f, 0.09842876f, 0.02379008f, 
    -0.06735991f, -0.03394222f, -0.02531794f, 0.01912897f, 0.02270687f, -0.01260758f, 0.00337437f, -0.08028481f, 
    -0.00782807f, 0.01831583f, 0.02594992f, 0.07641567f, -0.02966595f, -0.13057916f, -0.10652062f, 0.04796436f, 
    -0.13329372f, -0.10283249f, 0.01302003f, 0.01344422f, 0.07443558f, -0.08718245f, 0.01418221f, 0.01646508f, 
    0.09711759f, -0.03454076f, 0.01476692f, 0.01141873f, -0.03835502f, -0.01100712f, -0.01595684f, -0.01638116f, 
    -0.06554470f, -0.06669014f, -0.01119850f, 0.09249302f, -0.18184137f, -0.10370272f, 0.08142810f, 0.05200816f, 
    0.10992631f, -0.01780767f, -0.03253618f, 0.05610727f, 0.02531149f, 0.05548149f, 0.03776693f, 0.04214926f, 
    0.01339615f, 0.06093623f, -0.02629396f, 0.02526360f, -0.17716861f, 0.22500964f, -0.16856684f, -0.02817371f, 
    -0.06909292f, -0.03123219f, -0.06840369f, 0.02782739f, 0.02972366f, 0.02223354f, 0.11298705f, -0.01990042f, 
    -0.05404755f, 0.01573987f, -0.02686557f, 0.11733132f, 0.05575984f, -0.01657138f, -0.11216895f, -0.06496087f, 
    -0.06555885f, 0.05434174f, 0.11163117f, 0.00266572f, -0.20247254f, 0.06967749f, -0.01345956f, 0.11463396f, 
    -0.10828467f, 0.02411306f, 0.04202176f, -0.02071841f, 0.09798934f, -0.01749798f, 0.03438219f, -0.01740623f, 
    -0.03747261f, 0.04944935f, 0.03801387f, 0.05946521f, 0.14227411f, -0.03401691f, 0.28345400f, -0.15381046f, 
    0.03695894f, -0.11655813f, -0.13382280f, -0.02781876f, -0.05629747f, -0.00273278f, 0.05601559f, 0.00628040f, 
    0.01815252f, 0.18827139f, 0.20569831f, -0.05290775f, -0.06885766f, -0.09645040f, -0.09013262f, 0.14853309f, 
    -0.23120706f, 0.37059087f, -0.04599275f, 0.09292477f, 0.03734756f, 0.02392734f, 0.10103750f, 0.04964940f, 
    -0.10839172f, 0.06725083f, -0.02028425f, 0.07605777f, 0.09225313f, -0.05009158f, 0.01454175f, 0.06301434f, 
    0.03339911f, -0.00244567f, 0.05883342f, 0.07602201f, 0.03286301f, 0.17514697f, 0.14186068f, -0.02667888f, 
    0.15967029f, 0.16461423f, 0.13539983f, 0.05509509f, -0.00230544f, 0.02075835f, 0.13332656f, 0.07972298f, 
    -0.09113589f, -0.14985923f, -0.07911883f, -0.09781884f, -0.01381456f, -0.07925119f, 0.10566851f, -0.06846186f, 
    -0.41173059f, -0.21232156f, 0.05647724f, 0.08028655f, -0.09532374f, -0.06829173f, 0.00549993f, -0.03929752f, 
    -0.00506830f, -0.05245278f, 0.00002860f, 0.06618951f, -0.02532338f, -0.05596918f, 0.04231599f, -0.04116680f, 
    -0.02946335f, -0.07537539f, -0.07033096f, 0.07075441f, -0.00500437f, -0.09730654f, 0.07893125f, -0.01602809f, 
    0.03809613f, 0.09925959f, 0.05221751f, 0.08134965f, 0.02086771f, -0.00367388f, 0.05623929f, 0.07482241f, 
    0.12471804f, 0.00431781f, -0.03644213f, 0.08838666f, 0.03723712f, -0.02515341f, 0.07585756f, 0.08952410f, 
    -0.12678921f, 0.08829653f, 0.05768636f, -0.11658125f, 0.14745568f, 0.19693637f, 0.13361882f, 0.02305172f, 
    0.00188110f, 0.00711077f, 0.15678735f, 0.04984398f, 0.03425773f, 0.05323874f, -0.06081410f, -0.05288767f, 
    -0.00324755f, -0.02933644f, -0.02360017f, -0.00625026f, -0.07872243f, 0.20121440f, -0.17701001f, -0.11046853f, 
    0.17727816f, 0.15011773f, -0.00318765f, 0.00703981f, 0.02344467f, 0.06323200f, -0.01125735f, -0.03189321f, 
    -0.02319906f, -0.00637239f, -0.03237484f, 0.01700618f, 0.06742559f, -0.03055420f, -0.05626005f, 0.03237735f, 
    -0.10790610f, -0.04947545f, 0.08833944f, 0.02405938f, 0.13026106f, -0.07977856f, 0.03175775f, 0.00440803f, 
    -0.04983512f, -0.01102262f, 0.11694928f, -0.09148572f, -0.05039760f, -0.00699810f, 0.04527346f, -0.03985053f, 
    0.06874859f, 0.07515357f, 0.10602826f, -0.07234560f, -0.09684865f, 0.03655281f, 0.07443195f, 0.13961387f, 
    0.27812746f, 0.13865606f, 0.10828658f, 0.08863709f, 0.02168979f, -0.07457393f, 0.05049543f, -0.06584225f, 
    -0.07399598f, 0.03512757f, -0.10599199f, -0.01802980f, -0.00046446f, -0.03272462f, -0.04407967f, 0.01865104f, 
    0.20105101f, -0.02261955f, -0.15469439f, -0.12293637f, 0.21646927f, 0.06920104f, 0.12327001f, 0.00835044f, 
    -0.04849960f, 0.06862497f, 0.03545573f, 0.12704849f, 0.02674767f, 0.08456092f, 0.17992763f, -0.03337627f, 
    -0.06548002f, 0.05985041f, -0.07093137f, 0.11879101f, 0.13817061f, -0.21566980f, -0.13229541f, 0.26068106f, 
    -0.07142980f, -0.10226794f, 0.09582149f, -0.08657555f, -0.00656670f, 0.07291503f, 0.00081955f, 0.07066850f, 
    -0.01059062f, 0.06726120f, 0.04171389f, 0.03434133f, -0.02208251f, 0.13910119f, -0.15880434f, 0.00532273f, 
    -0.22162247f, 0.08472607f, 0.07752158f, 0.00940775f, 0.13970648f, 0.02445542f, 0.01942335f, 0.06030206f, 
    0.02465714f, 0.02740789f, 0.11535946f, -0.03715417f, -0.09437664f, -0.04945609f, -0.05050769f, -0.10330323f, 
    0.00006356f, -0.02711159f, 0.09379290f, -0.09995122f, -0.09392530f, 0.07196390f, 0.04332357f, -0.04321944f, 
    -0.10188533f, 0.06636799f, -0.02928667f, 0.03338017f, -0.04095802f, 0.01220374f, 0.04182638f, 0.02712931f, 
    -0.00352502f, -0.12080221f, 0.00899258f, 0.02437392f, -0.03613384f, -0.03719162f, -0.01431747f, -0.12326349f, 
    -0.25122562f, 0.11054780f, -0.15643053f, 0.13095288f, 0.28302661f, 0.04881499f, 0.12976755f, -0.02571891f, 
    0.08059074f, 0.03609592f, 0.02973278f, 0.06796041f, -0.05627950f, 0.02206251f, -0.00739943f, 0.05176650f, 
    -0.06263869f, 0.09476709f, -0.09819801f, -0.07195243f, 0.27353477f, -0.11831557f, 0.11387451f, -0.10414804f, 
    -0.22821753f, -0.09552059f, 0.00260621f, 0.00307527f, 0.07500826f, 0.01327571f, 0.03013242f, 0.02075147f, 
    0.01862063f, 0.03451442f, 0.05678935f, 0.02364950f, 0.01587415f, 0.00711724f, 0.09002171f, 0.05610627f, 
    0.05226767f, -0.16459702f, -0.10167667f, -0.25096554f, 0.05813444f, -0.00123452f, 0.07904644f, -0.08430754f, 
    -0.01204210f, -0.10275508f, 0.01784948f, -0.06157478f, -0.06002829f, -0.04452821f, -0.01626507f, 0.03940525f, 
    -0.06527410f, 0.05011173f, -0.06832643f, -0.08823572f, -0.10216681f, -0.21811873f, -0.06308203f, 0.08782244f, 
    0.04389805f, -0.07752405f, 0.09348440f, 0.00943708f, -0.02494239f, 0.05199424f, -0.03819818f, 0.07757325f, 
    0.00168468f, -0.12003392f, -0.05422897f, -0.06864826f, 0.04488765f, 0.07068969f, 0.07790019f, 0.02803115f, 
    0.22324966f, -0.18683589f, -0.09970906f, -0.13340388f, -0.22899003f, -0.02652513f, 0.03752939f, 0.09794834f, 
    -0.06463125f, -0.05794945f, 0.05419527f, -0.00120345f, 0.00445644f, 0.07480947f, 0.05980804f, -0.04419423f, 
    -0.07901624f, 0.06266245f, -0.00582404f, -0.00871932f, 0.17506430f, 0.09167410f, 0.01841220f, 0.34587809f, 
    0.04821486f, 0.03712441f, 0.13328728f, -0.05930372f, 0.12447894f, 0.16137248f, 0.00536227f, 0.00389477f, 
    0.03719599f, 0.05226546f, 0.04661144f, 0.05408076f, -0.06429069f, 0.06819337f, 0.07484751f, 0.07170022f, 
    0.02769124f, 0.22048101f, -0.13151880f, -0.05192120f, 0.02611392f, 0.06435417f, 0.18105891f, -0.11624864f, 
    0.06922603f, 0.01386893f, 0.04402635f, -0.07341006f, -0.09561374f, 0.10728744f, 0.04540441f, 0.01569283f, 
    0.13551134f, -0.05144172f, -0.01732427f, 0.05601408f, -0.06008941f, 0.04123906f, 0.11112043f, -0.07996476f, 
    -0.11263946f, -0.04321035f, 0.09506669f, 0.05170074f, 0.02672555f, -0.04971758f, -0.00362910f, 0.08172233f, 
    -0.09035863f, -0.06264619f, -0.14966166f, -0.03428647f, -0.00724424f, 0.00005672f, -0.00753601f, 0.02028782f, 
    0.15690269f, 0.09345626f, 0.05597515f, 0.05060580f, -0.06674223f, -0.01594467f, 0.06946821f, -0.05206402f, 
    -0.02814720f, -0.12468041f, 0.08988252f, -0.00417745f, 0.04452262f, -0.00258636f, -0.03155619f, -0.09485541f, 
    -0.01452646f, 0.10209041f, -0.06838527f, -0.06330398f, 0.28628981f, 0.12036163f, 0.00258718f, 0.00762525f, 
    -0.11339362f, -0.07529063f, -0.00663451f, 0.07910533f, 0.03437342f, 0.07798062f, 0.02454070f, -0.01242172f, 
    0.05361673f, 0.00558297f, 0.02056655f, -0.12949891f, -0.01576343f, 0.07462464f, -0.01591910f, -0.11987255f, 
    -0.11340617f, 0.09006000f, -0.12024944f, -0.09481701f, -0.32117096f, 0.02795702f, -0.04718045f, 0.10816670f, 
    0.01458155f, -0.04988355f, 0.00783069f, 0.05737415f, -0.04126925f, 0.01938011f, -0.05196950f, -0.13202165f, 
    -0.07291274f, -0.05307427f, -0.05516429f, 0.10978455f, -0.02172304f, 0.05898817f, 0.17839719f, 0.22372618f, 
    0.24589419f, 0.05982127f, -0.01899591f, -0.02013008f, 0.12020139f, 0.08471999f, -0.06291883f, -0.01073294f, 
    0.10444233f, -0.04798401f, -0.04981855f, -0.05319642f, 0.05903932f, -0.03374631f, 0.12547372f, -0.06214528f, 
    0.15583189f, 0.01048718f, 0.14106022f, 0.16441555f, 0.16509493f, -0.02590689f, 0.15803926f, 0.00306506f, 
    0.10064712f, 0.07854405f, -0.02111614f, 0.00928024f, 0.00074715f, -0.01345518f, -0.07215617f, 0.05043256f, 
    0.02691376f, -0.03422594f, 0.20154060f, 0.03416192f, 0.21831435f, -0.00123350f, 0.01467245f, -0.02150286f, 
    -0.11405899f, 0.01250819f, 0.06925125f, 0.02444510f, 0.07944240f, 0.02087279f, -0.00236101f, 0.00554156f, 
    -0.05295799f, 0.05772907f, -0.01791066f, 0.03986055f, 0.00671061f, -0.07317065f, 0.01875910f, 0.04003532f, 
    -0.10989461f, 0.26520887f, 0.17994797f, 0.29615131f, -0.16892244f, 0.05077568f, 0.00866673f, 0.12083837f, 
    0.04594365f, 0.09772120f, -0.04579094f, 0.07651998f, 0.06358152f, -0.01992022f, 0.01943665f, 0.04446388f, 
    -0.04708396f, 0.02596149f, -0.12795375f, -0.05062671f, -0.10919433f, 0.03318149f, -0.09135147f, -0.03964463f, 
    0.06870516f, 0.15717247f, -0.03992744f, 0.06820896f, -0.03755959f, 0.11442132f, -0.04056227f, 0.02120957f, 
    0.06876651f, 0.01692003f, -0.04506253f, -0.02906250f, 0.06819040f, 0.00991013f, 0.02053218f, 0.04410686f, 
    0.15594463f, 0.28552344f, 0.01115684f, -0.09839018f, 0.30586851f, 0.06092293f, -0.15680423f, -0.05328422f, 
    0.03321365f, 0.01892395f, 0.01470727f, 0.01985042f, 0.01290140f, -0.04866902f, -0.07532214f, -0.00754144f, 
    -0.05144531f, -0.07493808f, 0.09308547f, 0.02256843f, -0.09670801f, -0.46633267f, -0.08434055f, -0.15019727f, 
    0.15597843f, -0.08231280f, 0.08680552f, 0.04747939f, 0.02465085f, -0.14531502f, -0.00671184f, -0.00091370f, 
    0.02843720f, -0.00117002f, -0.02189855f, -0.00999406f, 0.03096870f, -0.07003843f, 0.04104942f, 0.10355306f, 
    -0.03797037f, -0.04779569f, -0.04244540f, 0.00090025f, -0.02098528f, -0.01684645f, -0.02860208f, 0.02226960f, 
    -0.03440050f, -0.01379181f, 0.00958010f, -0.03622567f, -0.03213515f, 0.04835965f, -0.00761575f, -0.04108479f, 
    -0.00368765f, 0.01280336f, -0.00007258f, -0.01055731f, 0.01890289f, 0.03003382f, -0.02926546f, -0.05271777f, 
    -0.00087520f, -0.00537203f, -0.01211832f, 0.01818390f, 0.01280446f, -0.01426605f, -0.00900013f, 0.06165074f, 
    -0.01873598f, -0.02759889f, 0.01615611f, 0.05898932f, 0.04470457f, -0.03939921f, -0.03854414f, -0.02103983f, 
    0.05975825f, 0.03904245f, 0.01878239f, -0.03376566f, 0.03547279f, -0.00927391f, -0.02691615f, -0.05121241f, 
    0.03854106f, 0.01776407f, 0.00828172f, -0.01918063f, -0.03623073f, -0.03715258f, -0.00397558f, 0.03798212f, 
    0.00765816f, -0.01860837f, 0.05863893f, -0.04210479f, 0.04411345f, -0.02510625f, 0.05667233f, -0.05289468f, 
    -0.01445423f, -0.02263308f, 0.03804766f, -0.03022974f, 0.02753945f, 0.00871665f, -0.04224034f, 0.03738094f, 
    0.04699291f, 0.01974675f, 0.01251731f, 0.02653542f, -0.01564881f, 0.04604192f, -0.00969578f, -0.04592456f, 
    -0.00148914f, 0.04517974f, -0.03642423f, -0.02029330f, 0.00098437f, 0.01045698f, 0.02645647f, 0.02510039f, 
    -0.01627086f, -0.04225521f, -0.03520554f, -0.04293132f, 0.01626435f, -0.02498167f, -0.05038975f, -0.06109127f, 
    -0.00029629f, -0.02532203f, 0.03810108f, -0.05412381f, -0.01395642f, 0.00959161f, -0.03636007f, -0.02699615f, 
    -0.03634834f, -0.03329094f, 0.04819708f, 0.04917604f, 0.00258805f, -0.01538240f, 0.00920404f, -0.04236070f, 
    0.04754493f, 0.01752029f, 0.01308498f, 0.02576304f, -0.00413357f, 0.02357306f, 0.00722196f, 0.02098544f, 
    -0.02767159f, -0.02335701f, 0.01963602f, 0.00067410f, -0.01049277f, -0.00015028f, 0.00685897f, 0.02450205f, 
    0.03254014f, -0.01590840f, -0.01134130f, -0.01363017f, -0.04446492f, 0.00173968f, -0.01788737f, -0.03117593f, 
    0.00275366f, 0.01447339f, 0.02177315f, -0.00592827f, -0.03737597f, -0.03147774f, 0.03165432f, 0.05845213f, 
    0.03058450f, -0.02847657f, -0.00193660f, 0.03507075f, -0.03967671f, 0.04903689f, 0.05295985f, -0.01226351f, 
    0.04383885f, -0.02042122f, 0.01572261f, -0.03598880f, 0.04028745f, -0.03462771f, -0.05729914f, -0.00129977f, 
    0.03072395f, -0.02822741f, -0.01031817f, 0.04208380f, -0.01687329f, 0.00722155f, 0.02421818f, -0.04337335f, 
    -0.00096108f, -0.02580060f, -0.03286194f, -0.01102424f, 0.04000051f, 0.02943210f, 0.00379055f, -0.02981747f, 
    -0.03362403f, -0.01482609f, 0.02946181f, 0.02088686f, 0.05323267f, 0.04103868f, -0.04316464f, -0.02001520f, 
    0.05809715f, 0.01936192f, -0.05527990f, -0.00192905f, 0.03482986f, 0.02380868f, -0.03338859f, -0.00063747f, 
    -0.04499739f, 0.03799402f, 0.02411844f, 0.04739673f, -0.01947706f, 0.00338061f, 0.01953647f, -0.03860669f, 
    -0.04232131f, 0.05654472f, -0.06115926f, -0.03883789f, -0.04201641f, 0.00454548f, 0.03632561f, -0.00875187f, 
    -0.00378667f, -0.04287700f, 0.02770540f, 0.01803303f, 0.01215145f, -0.00849327f, 0.03235981f, 0.02756104f, 
    0.03624572f, 0.00485165f, -0.01697886f, 0.01274428f, 0.01984103f, 0.01205305f, -0.04427772f, -0.04423269f, 
    -0.02791137f, -0.00624759f, 0.00159917f, -0.02563297f, -0.03567576f, 0.01813171f, 0.02294191f, 0.04751129f, 
    -0.05270310f, 0.00046506f, 0.01386775f, -0.03553508f, 0.05463201f, -0.04523604f, -0.00305543f, 0.00553191f, 
    0.01108928f, -0.05542561f, 0.03961058f, 0.02105000f, -0.01753111f, 0.00141586f, 0.03352385f, -0.06055933f, 
    0.02072755f, 0.04596338f, -0.02137540f, -0.00201458f, -0.03954493f, -0.05280342f, 0.04085891f, -0.01797490f, 
    -0.03743931f, 0.02077833f, 0.00757256f, -0.00628236f, 0.01948391f, -0.02264022f, -0.01643364f, 0.00188750f, 
    -0.04006791f, 0.02019521f, 0.01336710f, -0.04207421f, -0.04543986f, -0.06016774f, -0.04399189f, -0.05401720f, 
    0.04204471f, -0.02291317f, 0.02326065f, 0.02195334f, -0.04360878f, 0.02713122f, -0.04559169f, -0.05743671f, 
    -0.00164205f, -0.04612693f, -0.02252941f, -0.03604104f, -0.01057405f, -0.02652403f, -0.03739966f, -0.00809412f, 
    -0.02133543f, -0.02679114f, -0.02496892f, -0.02616763f, 0.03307271f, 0.04236871f, -0.05614219f, -0.00419271f, 
    -0.03814134f, 0.03633557f, -0.05648378f, 0.04008507f, -0.01357321f, -0.05722423f, 0.00053644f, -0.01777947f, 
    0.02619655f, -0.00816992f, -0.01689096f, -0.03053011f, 0.00531331f, 0.02158708f, -0.03782650f, 0.05864123f, 
    -0.04467703f, -0.04002650f, -0.04166536f, -0.04322140f, 0.01318913f, -0.01590365f, 0.04552263f, -0.01906257f, 
    0.21547787f, 0.05664658f, 0.28750756f, 0.14525150f, 0.31778231f, -0.04812393f, 0.02858444f, 0.01004247f, 
    0.05023135f, 0.07702058f, -0.07060754f, -0.01766504f, -0.06097261f, 0.05107007f, 0.07687325f, -0.05239194f, 
    0.01539787f, -0.03749503f, 0.07444572f, 0.04106612f, -0.03157573f, -0.17830014f, -0.05476906f, -0.06064050f, 
    0.00805673f, -0.02906521f, -0.08460650f, -0.02506547f, 0.03023974f, 0.02172408f, 0.06880485f, -0.05636170f, 
    0.07709493f, 0.11669807f, 0.01365223f, -0.00839244f, 0.03395835f, -0.03197618f, -0.07465371f, 0.02367410f, 
    0.04009758f, -0.17044526f, 0.07099570f, -0.10246954f, 0.09937023f, -0.11655165f, -0.13522689f, -0.09524205f, 
    0.01365351f, -0.04272757f, 0.05264405f, -0.07563622f, 0.00449953f, 0.02851489f, 0.04267331f, -0.06217761f, 
    -0.04234447f, -0.01217114f, 0.07114901f, -0.08378759f, -0.00725250f, -0.05097605f, 0.06335503f, 0.18293878f, 
    -0.11076847f, 0.03000968f, 0.05635948f, 0.04882598f, 0.01322853f, 0.07844236f, 0.09617965f, 0.03473729f, 
    0.15500616f, 0.00670923f, -0.03130125f, -0.06407378f, 0.09562203f, -0.11299305f, -0.08318169f, -0.02720655f, 
    -0.19466914f, -0.16591792f, 0.13476348f, -0.06449517f, -0.11249860f, -0.00287635f, 0.00237584f, 0.02230501f, 
    -0.09729504f, -0.03218000f, 0.04357964f, 0.00083416f, 0.08801758f, -0.02510083f, -0.03841773f, -0.06034173f, 
    0.00381617f, 0.01551856f, -0.06891721f, -0.05025862f, 0.08000406f, -0.10294262f, -0.05156190f, 0.00556085f, 
    0.07549968f, -0.09021762f, -0.08466953f, 0.03225454f, 0.00882977f, 0.10679319f, 0.07441566f, -0.03459240f, 
    0.05353282f, 0.01351696f, 0.13393787f, 0.03415433f, 0.03775163f, -0.03704736f, -0.12862647f, 0.08218557f, 
    -0.16480097f, -0.09182230f, 0.03741607f, 0.05610221f, -0.06948948f, 0.08139063f, 0.03173057f, 0.06381441f, 
    0.04936615f, 0.02776192f, -0.01341900f, 0.08187605f, 0.01472435f, 0.12437437f, 0.04632364f, 0.15755484f, 
    0.05243991f, 0.05533498f, -0.12883584f, -0.02064093f, -0.09168710f, -0.15019269f, -0.07190481f, -0.01449191f, 
    0.03866247f, -0.04442490f, -0.07719822f, -0.09149064f, 0.20243412f, 0.00164737f, -0.05021905f, 0.04480062f, 
    -0.00472770f, 0.07465865f, -0.04862369f, -0.05401437f, -0.07299527f, 0.06108274f, -0.06925886f, 0.07703895f, 
    0.40698481f, 0.27729908f, 0.10644805f, 0.11980313f, 0.00661382f, -0.02236286f, 0.01005524f, 0.02122558f, 
    -0.04335699f, -0.05778454f, 0.16879357f, 0.05542346f, -0.04840115f, -0.09543217f, -0.02390707f, 0.06897102f, 
    0.02856275f, 0.09443847f, 0.07729946f, 0.01551313f, -0.07178964f, 0.10715856f, -0.12724307f, 0.07519114f, 
    -0.08547186f, 0.10779408f, 0.09348866f, -0.03068866f, 0.04269341f, -0.00047712f, 0.06362939f, 0.05566686f, 
    -0.07442023f, -0.00311913f, -0.02192134f, 0.09090962f, 0.08713220f, 0.04350922f, 0.01177687f, 0.07809796f, 
    -0.06383483f, -0.11952610f, -0.03343097f, 0.01403766f, -0.10863645f, 0.03996519f, 0.00265298f, -0.08298904f, 
    0.16386558f, 0.07489465f, -0.05233040f, 0.04223366f, 0.05786598f, 0.14083575f, 0.05520592f, 0.02992179f, 
    -0.00461037f, 0.01647667f, -0.15114982f, 0.04176775f, -0.12542035f, -0.05887488f, -0.10986932f, -0.04901525f, 
    0.15503089f, -0.06713036f, 0.09848375f, -0.03569194f, 0.07590340f, 0.00613765f, 0.08316287f, -0.04700322f, 
    -0.05480806f, 0.01362559f, -0.00597603f, -0.04927565f, -0.01417772f, -0.01285833f, 0.00213486f, -0.03404560f, 
    0.27937701f, 0.08284554f, 0.05214244f, -0.05668652f, -0.15149257f, 0.02344846f, 0.03581249f, -0.11174364f, 
    -0.08164406f, -0.07954901f, 0.04690956f, -0.00586598f, 0.02226521f, 0.00979233f, 0.02506489f, 0.00618106f, 
    0.06465782f, -0.02469071f, 0.02182340f, 0.00051455f, -0.09456070f, 0.06248480f, 0.09587895f, -0.05997951f, 
    0.28527534f, 0.02179535f, 0.03437760f, 0.01967324f, -0.00174277f, -0.00678057f, 0.09043898f, 0.13152564f, 
    -0.07014642f, -0.05061551f, 0.01807918f, 0.01829695f, 0.02345158f, -0.06776874f, 0.01988446f, 0.03342120f, 
    -0.17335328f, 0.25276241f, 0.01635685f, -0.03747009f, -0.04183706f, 0.05722381f, 0.05743345f, 0.05594058f, 
    -0.08003889f, 0.09053709f, -0.03584985f, 0.04135713f, -0.03846868f, 0.00882268f, 0.01810149f, 0.11179084f, 
    0.06316292f, 0.01081424f, 0.04257564f, -0.03208351f, 0.27950475f, 0.03027423f, 0.08151437f, 0.07343661f, 
    0.14098921f, -0.04778953f, 0.04040743f, -0.01144882f, 0.06797619f, 0.09336244f, -0.05187571f, -0.02413961f, 
    0.03019621f, 0.06313059f, -0.00488272f, 0.07675746f, -0.08064150f, 0.08750867f, -0.03802590f, 0.07323167f, 
    0.06006880f, 0.17247234f, 0.21232606f, 0.06027040f, 0.31599152f, -0.05508718f, 0.04890530f, -0.06948429f, 
    0.09412868f, 0.00517297f, -0.08919422f, 0.07370108f, -0.09262516f, 0.04544320f, 0.03457955f, 0.01077783f, 
    0.06908462f, -0.02365604f, 0.02264975f, -0.00725348f, -0.06789535f, -0.03813749f, 0.13908613f, 0.24718104f, 
    -0.08052406f, -0.04436795f, 0.03340364f, 0.04125582f, -0.04174888f, 0.13846338f, -0.10919991f, -0.00503967f, 
    0.01185346f, -0.08266430f, 0.05702695f, -0.04085732f, -0.01479916f, 0.05954936f, 0.06587935f, 0.00263755f, 
    0.20456794f, -0.39203885f, 0.10860922f, -0.16131821f, -0.08889985f, -0.11797457f, -0.06052108f, 0.01888114f, 
    -0.01916232f, 0.00517645f, -0.03084778f, -0.00006852f, -0.03336604f, 0.07275866f, 0.05681042f, -0.04179476f, 
    -0.03759439f, 0.06452784f, 0.04874254f, 0.01939232f, -0.05720888f, -0.17877603f, -0.22271967f, 0.07015508f, 
    -0.12862386f, 0.11524321f, 0.04695235f, -0.06705385f, 0.07924834f, 0.13757980f, 0.11194225f, -0.01605739f, 
    0.16408661f, 0.00969005f, 0.02378706f, 0.02329074f, -0.01197917f, 0.02726097f, 0.02244364f, 0.10808609f, 
    0.31719127f, 0.19677708f, 0.15533993f, 0.01240619f, -0.03649954f, -0.03479286f, 0.01310590f, 0.09277335f, 
    -0.04937394f, 0.10654113f, 0.01275693f, 0.04296878f, 0.06868085f, 0.08477705f, -0.07404862f, -0.02211011f, 
    0.04450534f, 0.09276630f, 0.03526455f, 0.01329227f, -0.12063484f, -0.09747685f, 0.09415922f, 0.03563782f, 
    0.05021823f, 0.03554428f, 0.02986576f, -0.00019060f, 0.02493942f, 0.11166785f, 0.01979130f, 0.05580668f, 
    -0.13103659f, -0.02137799f, 0.08299373f, -0.06876508f, -0.02105280f, 0.00817538f, -0.05127372f, -0.07964485f, 
    -0.01866996f, -0.19703647f, -0.17111430f, 0.12017363f, -0.06781814f, 0.01225172f, -0.08086646f, 0.06399209f, 
    0.11220635f, 0.04781526f, -0.01622389f, 0.06224737f, -0.01814333f, -0.08190212f, 0.10273010f, 0.00300166f, 
    0.02758624f, -0.02239403f, -0.02228686f, -0.00842588f, -0.10900142f, -0.18796076f, -0.10569906f, 0.15840791f, 
    -0.05197184f, -0.07359561f, -0.10720338f, -0.07810123f, -0.01055607f, 0.07683118f, 0.03982563f, 0.01079161f, 
    0.03087441f, 0.03431522f, 0.10894751f, 0.02045297f, -0.00864802f, 0.02736662f, -0.03436612f, 0.00056531f, 
    0.21014307f, 0.19826931f, -0.06862811f, 0.04366552f, 0.00263395f, 0.07943282f, 0.04865860f, -0.00924300f, 
    0.01735932f, -0.06855746f, 0.07603942f, 0.04772873f, 0.01597094f, 0.03214924f, -0.02803329f, 0.16585614f, 
    0.04177890f, -0.05294430f, 0.01197090f, 0.05491706f, -0.16463487f, 0.09349619f, -0.26902851f, -0.11943379f, 
    -0.20281990f, 0.16665547f, 0.00292876f, 0.00568673f, 0.06068007f, 0.10680680f, 0.03576146f, 0.00503657f, 
    0.03598658f, 0.03596660f, 0.06352136f, 0.03867765f, 0.08009191f, 0.07081653f, 0.09645561f, 0.06535359f, 
    -0.11873046f, 0.02321856f, -0.05144184f, 0.14062124f, -0.02900046f, 0.11676799f, 0.03256562f, -0.00652773f, 
    0.14124307f, 0.06843871f, 0.05957916f, 0.00510978f, 0.05254734f, -0.02292098f, -0.00336252f, 0.05009101f, 
    0.04719989f, 0.02752060f, 0.11775961f, 0.00610411f, -0.04163335f, 0.11599120f, 0.05093100f, -0.06102155f, 
    0.07741880f, 0.07898700f, -0.03416805f, 0.13529414f, 0.10456979f, 0.08414203f, 0.03955437f, -0.02347493f, 
    0.05830837f, 0.06615109f, 0.05764994f, -0.02997113f, -0.02757599f, 0.05276399f, 0.12511410f, -0.03706561f, 
    0.14180335f, -0.01383828f, -0.03040702f, 0.00152178f, -0.10860195f, 0.13225652f, -0.07419860f, 0.02109646f, 
    0.05545161f, 0.00511279f, -0.00261734f, 0.05798996f, 0.15985550f, 0.04568265f, 0.08327895f, 0.12463685f, 
    0.08344823f, 0.14289322f, 0.00793657f, 0.08044149f, 0.06797028f, 0.03547487f, 0.12156436f, -0.00141304f, 
    0.25868911f, 0.04064679f, -0.01994823f, 0.14633344f, 0.00914586f, -0.01816867f, 0.08361071f, 0.07862869f, 
    0.02893044f, 0.11689590f, -0.01537796f, 0.07336455f, 0.10828406f, 0.07718699f, 0.03255450f, 0.03714397f, 
    -0.19602272f, 0.15580830f, -0.09678632f, -0.08288635f, -0.18699050f, 0.11940590f, 0.00331022f, -0.00735085f, 
    0.01842397f, 0.07044628f, -0.03158496f, 0.02102992f, -0.03508694f, 0.09702103f, -0.01265173f, 0.07549636f, 
    0.17229669f, 0.00081779f, -0.00198219f, 0.01182459f, -0.15828963f, 0.16930333f, 0.14537866f, 0.11002405f, 
    0.29964715f, -0.04189418f, 0.02760001f, 0.05401915f, 0.01325443f, 0.00092290f, -0.00419797f, -0.03938184f, 
    0.07246533f, 0.04141743f, 0.02422710f, 0.01205818f, -0.01215878f, -0.03054966f, -0.01529099f, 0.05159613f
};;

// Biases for dense layer dense0
const float dense0_biases[] PROGMEM = {
    -0.06056846f, 0.04209787f, 0.05383494f, -0.03714818f, -0.04321931f, -0.04349218f, -0.04082428f, 0.06521247f, 
    -0.04805202f, -0.03496429f, -0.04106926f, -0.02293163f, 0.00817590f, 0.00570753f, -0.05519353f, -0.03371568f, 
    0.03258976f, 0.11907096f, 0.00189674f, 0.04333629f, 0.04329768f, 0.05956015f, -0.01152562f, 0.08226074f, 
    -0.05965184f, -0.05131257f, 0.06298215f, 0.05451367f, 0.05178317f, -0.04412803f, -0.12273635f, -0.01183302f, 
    -0.00067187f, 0.14262114f, 0.04012202f, 0.03485569f, 0.04544360f, -0.01619624f, 0.10226620f, -0.02966893f, 
    0.05009392f, -0.00705493f, 0.11238793f, 0.01799425f, -0.01920982f, -0.00133720f, 0.01315637f, 0.06980411f, 
    0.00475288f, 0.06791718f, 0.02802289f, -0.00465616f, 0.00125431f, -0.04252922f, 0.02283718f, 0.01851793f, 
    0.01845751f, -0.04428142f, 0.10106571f, 0.07797136f, -0.01245579f, -0.00580927f, 0.01798738f, 0.01969250f
};;

// Weights for dense layer dense1
const float dense1_weights[] PROGMEM = {
    -0.06334123f, -0.10486469f, -0.12467594f, -0.04186588f, 0.01025677f, 0.09217138f, 0.08226888f, -0.06276053f, 
    0.06169719f, -0.03163205f, -0.08545148f, 0.05403829f, 0.17854701f, 0.01631333f, 0.01049205f, -0.07695092f, 
    0.08583026f, 0.19094825f, 0.01569154f, -0.02069798f, -0.08758603f, 0.17686050f, 0.07590275f, 0.28583685f, 
    0.05256003f, -0.19116142f, -0.26494625f, 0.24651602f, 0.07904527f, -0.01620136f, -0.44413680f, -0.00060653f, 
    0.12484699f, 0.16728839f, 0.24731468f, 0.07042032f, 0.06180383f, 0.07414243f, -0.12621041f, -0.12053809f, 
    -0.07467853f, 0.17581904f, 0.17500108f, 0.04688757f, -0.18794855f, 0.18789829f, -0.07314597f, 0.37660161f, 
    -0.10377405f, 0.14346406f, 0.03698765f, -0.26899153f, -0.41191250f, 0.12587947f, -0.10187154f, 0.14289938f, 
    0.07658389f, 0.13403004f, 0.15454438f, -0.11137257f, 0.10603140f, 0.12729508f, 0.16180816f, -0.00167277f, 
    0.11373624f, 0.05191468f, 0.21365257f, -0.03287703f, -0.04580957f, 0.01834482f, 0.10357460f, -0.24918784f, 
    -0.11238807f, -0.06550281f, -0.12574647f, -0.06265818f, 0.08172531f, 0.03396073f, -0.07018231f, -0.09727026f, 
    -0.06817213f, 0.14856406f, 0.10134535f, -0.10781850f, -0.09717875f, 0.05723557f, -0.03801300f, 0.02900854f, 
    -0.07271206f, -0.07564683f, -0.24905960f, 0.07123223f, -0.00177251f, 0.03525829f, 0.13384192f, 0.11557081f, 
    0.03107318f, -0.10967413f, -0.18057153f, -0.01990420f, 0.19840358f, 0.02168483f, 0.08221462f, 0.10587963f, 
    0.25534317f, -0.02697264f, 0.04143564f, -0.00248382f, -0.35389560f, 0.06769794f, -0.12171933f, -0.35220581f, 
    0.07583705f, 0.09303559f, -0.00834574f, 0.06370480f, -0.22846323f, 0.16206253f, 0.00503477f, -0.18695964f, 
    0.12183341f, -0.02142757f, 0.06614084f, -0.12170538f, 0.10437518f, -0.11282341f, 0.17437463f, 0.18076931f, 
    0.03964727f, 0.00040166f, 0.09411781f, -0.08760014f, 0.07168163f, 0.04419742f, -0.09699333f, 0.09649727f, 
    -0.11105668f, 0.07243486f, 0.01104149f, 0.03592100f, -0.08505411f, -0.07781511f, -0.12683219f, -0.00043997f, 
    0.12771396f, 0.14198217f, 0.10815732f, 0.09994478f, -0.07321734f, 0.06221115f, -0.07796335f, -0.10305444f, 
    -0.06878484f, -0.13129511f, -0.19963631f, 0.09309606f, 0.09226422f, -0.10934535f, 0.08784832f, -0.03653679f, 
    -0.06884601f, 0.16611393f, -0.13692142f, 0.11373470f, 0.21066301f, -0.14220026f, 0.10671614f, -0.01018636f, 
    0.46362442f, -0.27683312f, 0.02836999f, 0.10397061f, -0.31614754f, 0.15564185f, -0.11231975f, -0.17047124f, 
    0.24693352f, 0.14882609f, 0.11566283f, 0.22416154f, -0.19289790f, 0.27030388f, 0.14175341f, 0.00153175f, 
    -0.10477629f, -0.04125330f, -0.11668772f, 0.27601129f, -0.14255573f, -0.08460976f, 0.37371886f, 0.21406789f, 
    -0.01243159f, 0.04078482f, -0.03833074f, 0.11045185f, 0.04682271f, 0.12055630f, -0.08334538f, 0.10754524f, 
    0.02880862f, 0.07896835f, -0.07912032f, -0.11154154f, 0.11898729f, -0.03611512f, -0.08572060f, -0.01213339f, 
    0.11017244f, 0.18335605f, 0.11672261f, 0.08944303f, -0.07620873f, 0.06311033f, -0.07447569f, -0.00296122f, 
    0.10422441f, -0.16690485f, -0.05768735f, 0.14392219f, 0.11905000f, 0.02859239f, -0.26860011f, 0.09459886f, 
    0.12202062f, 0.16942243f, 0.21513554f, 0.12919524f, 0.20211866f, 0.10120120f, 0.13104396f, -0.13225166f, 
    -0.05949485f, 0.29915237f, 0.11812804f, 0.07850500f, -0.18305251f, 0.15384816f, -0.01487814f, 0.33386573f, 
    -0.19740497f, -0.03542322f, -0.05567371f, -0.40542680f, -0.30733889f, 0.04147026f, 0.25173628f, 0.36376855f, 
    -0.03502870f, -0.25010523f, 0.05008084f, -0.22133814f, 0.09122262f, -0.06309106f, -0.05197437f, -0.08146993f, 
    -0.03475505f, -0.09353043f, -0.12105785f, -0.11049725f, -0.15244004f, 0.20684686f, -0.09338132f, -0.17567912f, 
    -0.06949815f, 0.08461550f, 0.01521856f, -0.04322682f, 0.07753576f, -0.11693242f, -0.03672997f, -0.01898586f, 
    0.07163520f, -0.09920461f, 0.03161894f, -0.00573817f, 0.05653086f, -0.28536716f, -0.15614724f, -0.02131588f, 
    -0.06663910f, 0.14838147f, 0.24010201f, 0.03067565f, 0.10893095f, -0.06484519f, 0.30184785f, 0.09708716f, 
    -0.00447547f, 0.15118194f, -0.05014722f, 0.03423153f, 0.03206758f, 0.28807816f, 0.14155540f, 0.17429498f, 
    0.02195173f, 0.01194638f, 0.02937917f, -0.18137282f, -0.06441791f, 0.22368765f, 0.06866181f, 0.04357513f, 
    0.10392181f, -0.18717967f, -0.07016091f, 0.14691515f, 0.08700218f, -0.06638015f, 0.14971828f, 0.27683684f, 
    0.10825880f, -0.05039300f, -0.11034672f, 0.23777887f, 0.33087322f, -0.05183880f, 0.02488743f, -0.08925524f, 
    0.01712806f, -0.03745261f, -0.02698814f, -0.02981210f, 0.25422636f, -0.00925228f, 0.08926977f, 0.23580445f, 
    0.00026616f, 0.09597686f, 0.09041777f, -0.10051920f, 0.11829320f, 0.09291705f, 0.06578713f, -0.11496011f, 
    -0.05693590f, -0.10492381f, -0.03782666f, -0.08948133f, 0.10690755f, -0.02619756f, -0.13016492f, 0.04090230f, 
    0.08374242f, -0.27369815f, 0.04490140f, 0.31871831f, -0.03457311f, -0.08547981f, 0.14258684f, -0.03918592f, 
    -0.07487261f, -0.09982282f, 0.10045695f, -0.17317663f, 0.10108829f, 0.21971922f, -0.21068366f, 0.04278532f, 
    -0.01440175f, 0.22443108f, 0.00639116f, 0.14993075f, -0.02695739f, -0.06974680f, -0.09441460f, -0.02907406f, 
    0.20535576f, -0.14563775f, -0.06130170f, -0.12873617f, -0.06664844f, 0.21322738f, -0.03987930f, 0.12639996f, 
    -0.03098577f, -0.28797105f, 0.06741671f, -0.17522711f, 0.12740056f, -0.12005937f, 0.25556299f, 0.10738070f, 
    0.04918783f, -0.09622142f, -0.00639454f, 0.00167861f, -0.03020632f, 0.41013464f, 0.03592400f, 0.33230302f, 
    0.02203054f, 0.11598179f, 0.05669948f, 0.00192375f, 0.21162495f, 0.10268501f, 0.02057477f, -0.10864689f, 
    0.01726098f, -0.01710177f, 0.09171457f, 0.10118674f, 0.02238710f, -0.25031275f, -0.00565427f, -0.15384826f, 
    0.00181734f, -0.20046169f, -0.14789630f, 0.12109100f, 0.04446689f, -0.11533959f, 0.00520397f, 0.05894140f, 
    0.07178795f, 0.22659834f, -0.01531674f, 0.25880846f, -0.04742805f, -0.35449010f, 0.14158216f, -0.04485080f, 
    0.07038815f, 0.00663530f, 0.13424604f, 0.03376807f, -0.38203108f, -0.12444253f, 0.04884473f, -0.06113148f, 
    -0.08446350f, 0.01173708f, 0.02494330f, 0.07128351f, 0.12824945f, 0.17043786f, -0.00801069f, -0.03829355f, 
    0.10831437f, 0.05536095f, 0.12524073f, 0.34232923f, -0.03287640f, -0.02796485f, 0.14339337f, 0.03401121f, 
    -0.10018508f, -0.09588248f, 0.01421766f, 0.04466030f, -0.05603415f, -0.09880580f, 0.09247921f, 0.30081478f, 
    0.01370841f, 0.05933334f, 0.06915846f, -0.05874464f, 0.15616558f, 0.11360282f, -0.12450519f, 0.03324152f, 
    -0.03673227f, 0.14487383f, 0.07856318f, -0.09754005f, -0.10328695f, 0.07640070f, 0.24376027f, 0.24363911f, 
    0.00580430f, 0.23928286f, -0.31394252f, 0.02124631f, -0.02024981f, 0.09500308f, -0.48491254f, 0.07786403f, 
    -0.00474015f, 0.06806965f, 0.04593462f, -0.02202535f, -0.06695072f, 0.07820787f, 0.06517226f, -0.21556839f, 
    -0.04778061f, 0.04215054f, 0.22391762f, 0.22918820f, 0.30366638f, 0.00270769f, 0.04661404f, 0.14312068f, 
    0.14970848f, 0.14778130f, 0.04665811f, -0.22256650f, 0.18257256f, -0.11645585f, -0.07389367f, -0.15244353f, 
    0.10622048f, -0.09013695f, 0.06281674f, 0.17642824f, -0.09753996f, -0.08583952f, -0.17903565f, -0.06735642f, 
    -0.03752797f, -0.03727184f, 0.28481424f, -0.02751902f, -0.06424743f, 0.25329083f, -0.01891438f, -0.07922524f, 
    -0.09637608f, -0.00767016f, 0.02402985f, -0.11219982f, -0.06850999f, -0.09354328f, -0.04355206f, -0.00124098f, 
    0.02906097f, -0.15238236f, 0.10537849f, -0.03146672f, 0.09603407f, -0.25248906f, -0.05004074f, -0.14377601f, 
    -0.06317881f, 0.23928265f, 0.13631167f, 0.10811857f, 0.03458280f, 0.11618361f, 0.10299285f, 0.06958009f, 
    0.10329552f, -0.15842530f, 0.12661068f, 0.00729130f, 0.00702673f, -0.07357401f, -0.05541575f, -0.03062937f, 
    -0.02947850f, -0.19052686f, -0.00549510f, 0.16925608f, 0.27353084f, 0.04790751f, -0.08985981f, -0.03404855f, 
    0.15070261f, 0.13967378f, 0.08305787f, 0.34417352f, 0.20774208f, 0.22346614f, -0.37208655f, -0.14750199f, 
    0.06083977f, 0.24833967f, -0.17846411f, 0.06491485f, 0.27515602f, 0.06540259f, 0.02232052f, 0.22273837f, 
    -0.09334721f, 0.03260076f, -0.01478854f, 0.12517898f, 0.19778132f, -0.01225373f, -0.06670998f, 0.16046812f, 
    0.00385858f, 0.08169872f, -0.03210945f, 0.07856315f, 0.10588311f, -0.12173404f, 0.10799483f, 0.05631175f, 
    -0.04880673f, 0.21063675f, -0.06740266f, -0.01940158f, -0.10967640f, -0.13046865f, 0.07674561f, -0.14188679f, 
    -0.00227718f, 0.05977246f, 0.23074639f, -0.13253300f, 0.10116475f, -0.07222146f, -0.09633105f, -0.03194320f, 
    0.01737605f, -0.21154760f, -0.11274513f, 0.06647518f, -0.21689965f, -0.23014225f, 0.13234295f, 0.06443895f, 
    0.24445722f, 0.15445642f, 0.10071233f, -0.23776062f, -0.01196574f, -0.14369470f, 0.03028693f, -0.21562602f, 
    -0.03439943f, 0.02726692f, 0.07906128f, 0.08729984f, 0.35453466f, 0.06816963f, 0.03612632f, -0.36658943f, 
    0.01840222f, -0.15267864f, 0.16146289f, 0.21213643f, -0.13632883f, -0.00251636f, -0.12062772f, -0.05858999f, 
    0.07078098f, 0.05929751f, -0.15541871f, 0.07676329f, -0.01893569f, -0.33413064f, -0.04281859f, -0.17597640f, 
    -0.11412456f, 0.04399393f, 0.08282746f, 0.05015703f, 0.03119123f, 0.09003368f, -0.06424261f, -0.03398094f, 
    -0.12117989f, 0.23795925f, -0.00015217f, 0.09389881f, -0.06349427f, 0.27850899f, -0.00510578f, 0.17540000f, 
    0.03488399f, 0.14752121f, 0.17799446f, -0.27830127f, 0.11144804f, -0.03725380f, -0.09929480f, -0.08046776f, 
    0.03206226f, 0.24251485f, 0.01979278f, 0.10738076f, 0.17695338f, 0.01575838f, 0.17800529f, -0.05364499f, 
    0.12195184f, 0.11771234f, 0.13192295f, -0.09692589f, -0.01283611f, 0.28286949f, 0.04846981f, 0.04492381f, 
    0.11455043f, 0.14177851f, -0.02346104f, -0.16778407f, -0.24952935f, -0.29730004f, 0.20033367f, 0.00756691f, 
    0.05025940f, 0.15742584f, 0.13644882f, 0.12223350f, -0.12735866f, 0.08254934f, -0.23480196f, 0.05731622f, 
    -0.00694526f, -0.08184116f, 0.00541780f, -0.00833883f, -0.21087797f, -0.24721828f, -0.06356145f, -0.22886959f, 
    0.03949422f, 0.02110805f, 0.05860989f, -0.08059070f, -0.01564593f, 0.07465831f, -0.08613108f, -0.01285389f, 
    0.12157499f, 0.16898458f, -0.06016061f, 0.06047301f, 0.11155719f, 0.04297109f, 0.08816080f, 0.04581143f, 
    -0.06812421f, 0.02980503f, -0.14661787f, 0.03979838f, -0.02462807f, 0.07327557f, -0.15385012f, -0.12563027f, 
    -0.09632834f, 0.39239568f, 0.14011772f, 0.02493814f, 0.22418036f, -0.26866660f, 0.08990366f, -0.08902689f, 
    0.07245141f, -0.11627042f, 0.09788080f, -0.11804271f, -0.15174045f, 0.13888054f, 0.07456405f, 0.05507336f, 
    0.17252623f, 0.12517299f, 0.02074118f, 0.03462543f, -0.16246106f, 0.00898980f, -0.05817341f, -0.06417683f, 
    -0.11234570f, -0.06522457f, 0.16864216f, 0.21114439f, -0.10830508f, -0.09049699f, 0.08479586f, 0.13373511f, 
    -0.09502327f, -0.11398029f, -0.12636665f, 0.04540973f, -0.00380471f, -0.09844934f, -0.04880830f, 0.38682744f, 
    0.07433128f, 0.00252448f, 0.06175444f, 0.08797033f, 0.06229418f, 0.11682610f, 0.10179022f, 0.00877010f, 
    0.07658090f, -0.01338844f, 0.01520014f, -0.10934761f, -0.09727439f, 0.21105903f, -0.08434880f, 0.02740864f, 
    0.08005922f, 0.09704259f, -0.14281428f, -0.00977952f, -0.09507465f, -0.08940759f, -0.17922217f, 0.09802549f, 
    0.08661903f, -0.01698668f, 0.13560770f, 0.10768130f, 0.00520185f, -0.21153826f, 0.13599250f, -0.00443547f, 
    -0.04946485f, 0.04020407f, 0.09016801f, 0.24262036f, 0.11018331f, -0.13116167f, -0.09555391f, 0.19547363f, 
    -0.12949139f, 0.11750010f, 0.01229852f, -0.16619614f, 0.03903559f, 0.02199524f, 0.21789238f, -0.05568599f, 
    -0.07389721f, 0.04060271f, 0.18442298f, 0.04494828f, -0.22830133f, 0.03869460f, -0.05573389f, -0.00045473f, 
    -0.11561374f, 0.06553631f, 0.16500662f, 0.03608708f, -0.11339175f, -0.24472967f, -0.09191710f, -0.04046811f, 
    -0.05524119f, 0.10274343f, -0.03368272f, -0.11118855f, -0.21235780f, 0.00655701f, -0.10556741f, -0.07565766f, 
    -0.09986834f, -0.05283033f, -0.08175920f, -0.05564188f, 0.10471172f, 0.17738914f, -0.00624588f, 0.32217494f, 
    0.03735477f, 0.27708560f, 0.00327095f, -0.01672860f, 0.00277574f, -0.02460422f, 0.24841656f, -0.02320119f, 
    -0.11366905f, 0.14651898f, -0.00815170f, -0.19430549f, 0.16332926f, 0.05521352f, 0.03458077f, -0.02100343f, 
    0.22417946f, -0.24043463f, -0.00731001f, 0.32230631f, 0.36702958f, 0.31995904f, -0.05104566f, 0.09867793f, 
    0.13787891f, 0.11525932f, 0.08630636f, 0.25313717f, 0.14403985f, -0.18314601f, 0.12081245f, -0.06018206f, 
    -0.11628195f, 0.11884258f, -0.13836181f, -0.14192946f, 0.03883399f, 0.04848151f, 0.08689113f, 0.18631893f, 
    0.02972222f, 0.01107334f, -0.17432377f, 0.11707503f, 0.36478156f, 0.00373752f, 0.09284720f, -0.12396304f, 
    0.04997044f, 0.11718098f, -0.00660566f, -0.02098475f, 0.06757472f, -0.11576652f, 0.00920192f, 0.08971269f, 
    0.10837650f, 0.08305870f, 0.04095200f, 0.11474789f, -0.07824270f, 0.19142622f, 0.13797146f, 0.30529115f, 
    0.04819535f, -0.16217643f, -0.13460225f, 0.09045915f, 0.05674796f, -0.09991358f, -0.44246817f, 0.03256727f, 
    0.04230678f, -0.10017291f, 0.22940128f, -0.13968654f, 0.10949949f, 0.18902668f, -0.08355646f, 0.02590986f, 
    -0.09940387f, 0.12386794f, -0.22119424f, 0.25003999f, 0.09950709f, 0.13394365f, 0.00940527f, 0.24286790f, 
    0.02305244f, 0.05445231f, 0.11985723f, 0.09334778f, -0.23131788f, 0.30514228f, -0.39415762f, 0.31623164f, 
    -0.06656513f, 0.30259162f, 0.11903831f, -0.24546070f, 0.04675428f, 0.00984287f, 0.03726551f, 0.20913203f, 
    0.04468432f, -0.07891101f, -0.20867313f, 0.00095785f, 0.23033702f, -0.25114691f, 0.10452227f, -0.20776345f, 
    0.06739455f, -0.05866585f, -0.07049602f, -0.11688431f, 0.00765577f, 0.02169013f, 0.00180854f, -0.03627485f, 
    0.09313530f, 0.14653982f, 0.03627265f, -0.01984459f, 0.02875847f, 0.26113817f, 0.00409511f, 0.07217139f, 
    0.09542682f, -0.22617301f, 0.27110904f, 0.01801997f, 0.07084690f, 0.04572616f, -0.10362415f, -0.02264553f, 
    -0.06116387f, -0.03908208f, -0.13999560f, -0.03483959f, 0.13955666f, 0.33234686f, 0.04147283f, 0.25036135f, 
    -0.01868238f, 0.23855320f, -0.09760934f, -0.02770853f, -0.14009336f, -0.14842273f, -0.09921773f, 0.17028131f, 
    0.19862325f, -0.24783216f, 0.11772744f, -0.07679737f, -0.08670929f, -0.04245520f, 0.23016670f, -0.03890245f, 
    -0.04804597f, -0.33003953f, 0.33776847f, 0.07651520f, 0.05730316f, -0.01982212f, 0.04161032f, -0.04017891f, 
    -0.06107203f, -0.02294882f, -0.15590048f, 0.04436589f, 0.33247191f, 0.27189681f, 0.07834114f, 0.01771500f, 
    -0.10226447f, 0.04186197f, -0.05985199f, -0.12143664f, 0.16040123f, 0.06989305f, -0.11636416f, 0.07205620f, 
    -0.00184401f, 0.04634714f, -0.09250647f, -0.09484778f, -0.05433868f, 0.15860887f, -0.04224873f, -0.11300815f, 
    -0.13156964f, 0.13029720f, -0.01663289f, 0.06250802f, 0.07152687f, -0.05167523f, 0.23312764f, 0.10705479f, 
    0.03449490f, -0.30055410f, -0.15339386f, 0.16773209f, -0.01244167f, 0.42301118f, -0.11858917f, 0.16649596f, 
    -0.29785442f, 0.18131104f, 0.12292045f, 0.06075130f, 0.14140855f, -0.04740800f, 0.00530482f, -0.15073957f, 
    -0.26253349f, 0.06400260f, -0.02765249f, -0.28839642f, 0.10299364f, -0.09670930f, 0.19371079f, 0.32450843f, 
    0.07616816f, 0.11812841f, 0.09980457f, -0.04102940f, 0.21172234f, 0.01578135f, 0.02708986f, 0.05936015f, 
    0.02331568f, 0.11644606f, 0.08450484f, 0.02161717f, 0.12846622f, -0.15556547f, 0.00272971f, 0.49413338f, 
    0.10628239f, -0.07654184f, -0.11439295f, 0.06889345f, 0.07393124f, 0.05111498f, 0.10560142f, 0.05271144f, 
    -0.10026622f, 0.18950514f, -0.04765569f, 0.07665335f, -0.09047989f, 0.15105352f, 0.02590607f, 0.25651941f, 
    -0.06052778f, 0.10827633f, -0.27409306f, 0.01716823f, 0.04638466f, 0.00204132f, -0.02267462f, 0.00850264f, 
    0.09985073f, 0.05222593f, -0.09037445f, 0.11644798f, 0.10302980f, 0.21395320f, 0.17024496f, -0.19102696f, 
    0.41899472f, -0.10237418f, -0.04286474f, 0.15983351f, -0.10906728f, 0.21159472f, -0.09681814f, -0.22841638f, 
    -0.00113484f, 0.07936194f, -0.06921434f, 0.20354788f, 0.20433180f, -0.09097259f, 0.50580704f, 0.19569239f, 
    0.01234982f, -0.16127130f, -0.00335766f, 0.09000933f, -0.13773288f, -0.00624382f, 0.14631996f, -0.00200203f, 
    0.01629535f, -0.10100614f, 0.03546729f, -0.01681482f, -0.01057565f, -0.21604663f, -0.00180067f, 0.21576366f, 
    0.09380792f, 0.10823648f, -0.01858965f, 0.01884064f, 0.02652061f, -0.10574676f, 0.01086000f, -0.04374341f, 
    -0.04010417f, 0.18413095f, 0.08579231f, -0.10382119f, 0.04218304f, 0.19110999f, 0.06769429f, 0.05267340f, 
    -0.07181462f, -0.11585484f, -0.06824671f, 0.09873340f, -0.01561888f, -0.10683738f, -0.06687447f, 0.00861772f, 
    -0.02245583f, 0.04866913f, -0.06133537f, 0.11451490f, 0.02627071f, 0.18058324f, 0.07249613f, 0.12877087f, 
    0.08432531f, 0.17955437f, 0.10443041f, 0.00764267f, -0.00329660f, -0.33852196f, -0.10225736f, -0.06777445f, 
    0.05429636f, 0.05604944f, 0.11367221f, -0.21629485f, -0.08570525f, -0.08690254f, 0.28479439f, -0.15820558f, 
    -0.09537002f, -0.36708137f, 0.18382169f, 0.19129819f, -0.26374689f, 0.05712790f, -0.03230161f, -0.14219818f, 
    -0.00474914f, -0.05876056f, 0.11895394f, -0.10969253f, -0.12006419f, 0.13811120f, 0.02045283f, -0.22494763f, 
    -0.09407948f, -0.00364104f, 0.03565960f, -0.03675998f, 0.06769609f, 0.05934937f, -0.09226704f, -0.11391438f, 
    0.02367790f, 0.05105707f, 0.00334408f, -0.02710999f, 0.11276266f, 0.01420059f, -0.18596876f, -0.10579786f, 
    -0.00584342f, 0.13395847f, 0.11844234f, 0.09362216f, -0.09912522f, 0.08971156f, 0.59725004f, -0.05266686f, 
    0.08338073f, 0.01522233f, 0.02550627f, -0.00567402f, 0.00782769f, 0.09522765f, -0.06873970f, 0.10717535f, 
    -0.20740241f, -0.13565081f, 0.21984641f, -0.14275998f, 0.02657327f, 0.04543752f, 0.10423203f, -0.14892748f, 
    -0.12920861f, 0.08983818f, -0.08614360f, -0.42302218f, -0.03314932f, -0.10521825f, 0.15917827f, 0.04656023f, 
    0.12447694f, 0.21372411f, 0.01377921f, -0.02025404f, 0.24535641f, 0.11766750f, 0.04987105f, -0.09813834f, 
    -0.03113188f, 0.00538445f, -0.04785554f, 0.01487738f, -0.17537430f, -0.15970322f, -0.08268283f, -0.03431008f, 
    0.04019289f, 0.02587619f, -0.05898624f, -0.10716038f, -0.07537294f, 0.01839137f, -0.09094446f, -0.00657305f, 
    -0.06741311f, -0.09685893f, -0.01653182f, 0.02422325f, -0.09228771f, 0.10504089f, 0.15196563f, 0.21170090f, 
    0.07706553f, 0.20260315f, 0.36626691f, -0.08542771f, 0.05924286f, 0.06076990f, 0.15284376f, -0.11187004f, 
    -0.10467391f, 0.26973286f, 0.23692836f, 0.09481846f, -0.00040027f, 0.14984195f, 0.22724320f, 0.11737939f, 
    -0.20635726f, 0.15449896f, 0.24350490f, 0.00046905f, 0.37127635f, 0.13905801f, 0.06163755f, 0.33120641f, 
    0.05445081f, -0.09681404f, -0.04629029f, -0.34438956f, -0.04098685f, -0.46764052f, 0.08224042f, 0.12311509f, 
    -0.10897317f, -0.09844391f, 0.23888715f, -0.06578489f, 0.16417366f, 0.04597075f, -0.29600194f, -0.16620712f, 
    0.04842329f, -0.02783688f, 0.00634591f, 0.07570859f, 0.16053139f, 0.41394490f, -0.04660185f, 0.02226366f, 
    -0.12203364f, 0.10245776f, -0.03585883f, 0.01167261f, 0.18229935f, -0.05388357f, -0.10259053f, -0.00510680f, 
    0.00400350f, 0.11232470f, 0.03479798f, 0.00457769f, -0.11950640f, -0.26042309f, 0.03929187f, 0.04547720f, 
    0.05951041f, -0.16015108f, 0.14524446f, 0.18387073f, -0.01271196f, -0.10453133f, -0.21276227f, -0.02542873f, 
    -0.09416116f, -0.01551082f, 0.34955555f, 0.14922379f, 0.11901705f, -0.01640661f, 0.03898737f, 0.11238361f, 
    -0.26162040f, 0.15992659f, 0.11585075f, 0.07190713f, -0.10456441f, -0.16691153f, 0.10477613f, 0.34554246f, 
    -0.15941994f, -0.18612973f, 0.11389068f, -0.10413847f, -0.03428502f, 0.27421734f, -0.17467956f, 0.38409591f, 
    -0.08841431f, 0.04257857f, 0.19673647f, 0.02034155f, 0.22496857f, -0.11224906f, -0.10950517f, 0.08951399f, 
    0.10395262f, -0.11417081f, 0.14411612f, 0.03093950f, -0.06134357f, 0.03607337f, -0.00694033f, -0.42767364f, 
    0.11698605f, 0.03667221f, -0.06962219f, -0.07120606f, 0.01521058f, 0.12054048f, -0.01565010f, -0.05524011f, 
    0.08912379f, -0.10971212f, 0.06037736f, 0.00223645f, 0.00876951f, -0.37061235f, -0.15643778f, -0.22203632f, 
    0.09653589f, 0.05587446f, 0.36069050f, 0.05861059f, -0.11247968f, -0.05899538f, 0.49471140f, -0.01491906f, 
    -0.06081673f, 0.20167103f, 0.08659827f, 0.03748010f, 0.11012268f, -0.00148058f, 0.13977140f, 0.21163362f, 
    -0.28342450f, 0.07958612f, 0.33699620f, -0.12116019f, 0.08892561f, 0.11971454f, -0.07884754f, 0.20787029f, 
    -0.21125764f, 0.21132626f, -0.10335135f, -0.23719576f, -0.20721960f, -0.28674620f, -0.25468695f, 0.05020674f, 
    0.06400383f, 0.37999696f, 0.05389808f, 0.16173798f, 0.25245559f, 0.02093875f, -0.12904234f, -0.10754320f, 
    0.11710910f, 0.04333641f, -0.07966377f, 0.06179987f, 0.05904467f, -0.02316632f, -0.02736809f, -0.02453902f, 
    -0.07772358f, 0.03399372f, 0.02303844f, -0.11731490f, 0.07184823f, 0.10267285f, -0.05957890f, -0.00613502f, 
    0.08939866f, 0.05553802f, 0.07517268f, -0.05183902f, -0.05530465f, 0.04860723f, 0.07368798f, -0.07988066f, 
    -0.08021902f, -0.09603569f, -0.10378555f, 0.00493296f, 0.08305167f, 0.09005217f, 0.06410772f, 0.02882616f, 
    0.02863431f, 0.00187854f, -0.12142152f, -0.04778904f, -0.04587633f, -0.02003744f, 0.08832072f, -0.08758169f, 
    -0.00003001f, 0.01739847f, 0.02660120f, 0.06241129f, -0.00095339f, -0.04157628f, -0.04961579f, -0.04480138f, 
    -0.05469831f, -0.13524586f, -0.07153780f, -0.06350612f, -0.13492061f, 0.04929458f, -0.01594040f, -0.09981922f, 
    -0.03961781f, 0.02628803f, -0.12841004f, -0.01945631f, -0.09562656f, 0.00997916f, -0.03848424f, -0.09032944f, 
    -0.04566612f, 0.08233893f, 0.36408287f, -0.03275089f, -0.21931729f, -0.31743094f, 0.08993252f, -0.08912341f, 
    -0.05893324f, 0.03454312f, 0.06019564f, 0.07789296f, -0.08804000f, -0.02805616f, 0.10850079f, -0.02395137f, 
    -0.13127141f, -0.07911831f, 0.10866531f, -0.07434115f, 0.07793247f, -0.19492272f, 0.22576508f, 0.03618057f, 
    0.08882432f, -0.02775120f, 0.26197815f, 0.15434666f, -0.10702140f, -0.04791532f, 0.04285825f, -0.03168345f, 
    -0.05787428f, 0.30493900f, 0.19832659f, -0.12819639f, 0.13640489f, 0.10568579f, 0.07254179f, -0.06107689f, 
    0.00278909f, 0.26933980f, 0.16396587f, -0.18039779f, 0.06434880f, 0.23359592f, -0.03565748f, 0.25134662f, 
    0.11296234f, -0.05556571f, 0.06804498f, -0.06913330f, -0.11845626f, -0.12836622f, -0.02553778f, -0.21095498f, 
    0.09717712f, -0.35322207f, 0.19365031f, -0.09018094f, 0.15824710f, 0.07727666f, 0.00901661f, 0.13419256f, 
    0.03427637f, 0.05221191f, 0.36159578f, -0.04515475f, 0.12359339f, 0.05181217f, 0.04135373f, 0.07801062f, 
    0.11314620f, 0.10413688f, 0.09658812f, -0.11510700f, -0.06485789f, 0.06213264f, -0.12619516f, -0.02358083f, 
    0.08219138f, -0.10450572f, -0.11509509f, -0.07442187f, -0.04128319f, -0.17351650f, 0.26738426f, 0.18253325f, 
    -0.09214491f, -0.08215696f, 0.04231702f, 0.07340199f, -0.07002920f, 0.08639798f, 0.03243214f, 0.04797053f, 
    0.03815724f, -0.15065807f, -0.00196051f, 0.04502155f, 0.06956456f, 0.22402020f, 0.09144805f, -0.10306421f, 
    -0.11997727f, 0.33883750f, -0.11965063f, 0.05334216f, 0.11929061f, -0.08362357f, -0.09890443f, 0.00163425f, 
    0.16386701f, -0.14162321f, -0.03061907f, 0.10006497f, 0.32806668f, -0.15693191f, 0.05801435f, 0.10668420f, 
    -0.11631347f, -0.35898975f, -0.17864680f, -0.14937240f, 0.23590225f, -0.01844588f, 0.07332338f, 0.08665281f, 
    0.03294687f, 0.10617644f, -0.20067047f, -0.07218981f, -0.06661808f, 0.07906304f, -0.12230109f, 0.26275384f, 
    -0.11138011f, 0.08367570f, 0.10619369f, 0.09205779f, 0.13882677f, 0.11704361f, -0.04222541f, -0.07476509f, 
    0.02909204f, 0.10194750f, 0.01253454f, 0.07299792f, -0.03692509f, 0.20842487f, -0.13458920f, -0.18379989f, 
    0.06523791f, 0.15573001f, -0.11275405f, -0.13725498f, -0.02660758f, -0.07902493f, 0.20613554f, -0.06789430f, 
    -0.01404310f, 0.02070435f, -0.03694640f, 0.29602820f, 0.05241996f, -0.10889523f, 0.21038310f, 0.22999576f, 
    0.15402706f, -0.23468673f, 0.17913787f, 0.02395153f, -0.07460765f, -0.16814819f, 0.02129047f, -0.01449036f, 
    -0.05274371f, 0.22974460f, 0.07243010f, 0.03739011f, -0.16257496f, 0.06149343f, 0.33460844f, -0.19899943f, 
    -0.03754460f, 0.26722848f, 0.18139537f, 0.14236781f, -0.24851330f, -0.04019396f, 0.09843072f, -0.00573919f, 
    0.09765096f, 0.00895166f, -0.11934532f, 0.11387806f, 0.00017373f, -0.04394757f, 0.11656100f, 0.04380632f, 
    -0.03405991f, 0.09099367f, -0.00297172f, -0.06080983f, -0.11268724f, 0.04360305f, 0.02964304f, 0.06337224f, 
    -0.09347955f, -0.09712221f, -0.06940290f, 0.08689303f, 0.10036702f, -0.06100205f, 0.07434265f, -0.08730378f, 
    0.08315593f, -0.09331631f, 0.06279889f, -0.08009123f, -0.11212697f, -0.11080599f, 0.05453662f, -0.10834471f, 
    0.04847743f, -0.09679423f, -0.11957330f, -0.00369233f, 0.01485279f, 0.01352934f, -0.00701881f, -0.05815943f, 
    -0.11443150f, 0.05736591f, 0.11071870f, -0.07132380f, 0.12013976f, 0.07543085f, -0.09705065f, 0.00912117f, 
    0.07017411f, -0.04618416f, -0.07115485f, -0.07434281f, -0.11032622f, -0.06382462f, -0.05636709f, 0.09713084f, 
    0.12165442f, 0.01710684f, -0.12459965f, 0.06385253f, 0.02034508f, -0.08137605f, -0.01253662f, -0.09808888f, 
    -0.01019314f, -0.02757214f, -0.09461401f, -0.00156371f, 0.08348803f, 0.09341538f, 0.04045124f, -0.07645430f, 
    0.01732807f, -0.02065243f, 0.07600848f, 0.10778779f, -0.10974678f, -0.08951153f, 0.09741320f, -0.09878457f, 
    0.07339628f, -0.07918125f, 0.05647665f, 0.01944375f, -0.01171781f, -0.00101990f, -0.08084287f, -0.01074101f, 
    0.08137801f, 0.09094715f, 0.10531801f, 0.04697734f, 0.04607162f, 0.00976659f, -0.00899257f, -0.02986880f, 
    0.00434646f, -0.03124407f, -0.06468610f, -0.08387655f, -0.10636516f, -0.05834302f, -0.01639740f, -0.03558260f, 
    0.07700460f, 0.10286649f, 0.00765216f, 0.09322840f, 0.03607856f, 0.05402800f, -0.09781571f, -0.05682315f, 
    -0.08199011f, 0.01964234f, 0.11055021f, -0.03363134f, -0.12183566f, -0.09744121f, -0.08426869f, 0.08039989f, 
    -0.01882941f, 0.01158941f, -0.01721776f, 0.04075582f, -0.11685599f, 0.05147614f, -0.08786137f, 0.09220472f, 
    -0.00630889f, -0.02573222f, -0.09257077f, 0.03419561f, -0.02258455f, -0.07746883f, -0.07425154f, 0.26911587f, 
    -0.08878078f, -0.00469560f, 0.06331129f, -0.00288643f, -0.13893992f, -0.00462904f, -0.07272024f, 0.07478005f, 
    0.06417444f, -0.14057228f, 0.02661611f, -0.02488706f, 0.07131413f, -0.08976544f, 0.01162725f, 0.18035547f, 
    -0.05362167f, 0.19684941f, -0.17173041f, 0.13208219f, -0.00183735f, -0.09126022f, 0.12830710f, -0.01654454f, 
    0.05079808f, 0.06469636f, -0.05019005f, -0.15241574f, -0.04409428f, -0.17875218f, 0.08718065f, -0.10168447f, 
    0.19845442f, -0.21204589f, 0.00240768f, 0.26612109f, 0.16493453f, 0.36410764f, 0.03581960f, 0.09021227f, 
    0.16368642f, 0.16002673f, -0.11612035f, 0.23896258f, 0.15132073f, 0.06883611f, -0.16913998f, 0.04343291f, 
    0.09017994f, 0.16064486f, -0.25909394f, 0.30423626f, 0.10606651f, -0.05080911f, 0.23110411f, 0.11984808f, 
    -0.04248654f, -0.02454902f, -0.02385117f, 0.10928879f, -0.14714330f, -0.15905900f, -0.06117309f, -0.17276098f, 
    0.06236516f, 0.08482978f, -0.05414435f, 0.09092140f, 0.06457239f, 0.03340503f, 0.02989180f, 0.03135715f, 
    0.02142536f, 0.08627556f, -0.01237230f, -0.00349744f, 0.05337869f, 0.15594904f, -0.16490619f, 0.20127641f, 
    -0.04308906f, -0.20632185f, -0.11206351f, 0.14699434f, 0.04622142f, -0.04286778f, -0.03136545f, -0.01209592f, 
    0.04238683f, 0.35268319f, 0.00920278f, -0.09406421f, 0.23814754f, 0.18900433f, -0.09221986f, -0.04618214f, 
    0.19344623f, 0.05390538f, 0.06619736f, 0.00898766f, -0.31432015f, 0.37441757f, 0.02428606f, 0.16605227f, 
    0.05786383f, -0.17665388f, 0.07113017f, -0.20095514f, -0.22889611f, -0.03000768f, 0.01982488f, 0.12970348f, 
    0.08534776f, -0.35070959f, -0.03452935f, -0.11727058f, 0.13799690f, 0.02110146f, 0.07685719f, 0.06941145f, 
    -0.11375673f, 0.00739652f, 0.19048387f, 0.02256754f, 0.28240469f, 0.39113337f, -0.00536333f, 0.12236515f, 
    0.08753276f, -0.09937413f, 0.03519639f, 0.10186702f, 0.06455956f, -0.06462039f, 0.04079067f, 0.02729408f, 
    -0.11588834f, 0.12997009f, 0.10501912f, 0.10474896f, 0.12041557f, 0.05054515f, -0.02337673f, -0.22782035f, 
    -0.01054254f, -0.03755289f, 0.00930433f, 0.12390918f, -0.02493360f, 0.05415031f, 0.17100011f, -0.08968052f, 
    -0.11645562f, -0.29128188f, -0.12225785f, 0.14712630f, 0.04030477f, 0.36601800f, 0.04973293f, 0.04995052f, 
    -0.05406535f, 0.25796890f, -0.07091186f, -0.11168066f, -0.18648002f, -0.13680995f, -0.08214527f, -0.25159743f, 
    -0.21193117f, 0.00669039f, 0.08781063f, 0.01836145f, 0.17087394f, 0.05837650f, 0.22890908f, 0.14547476f, 
    0.05627554f, -0.29422835f, -0.07292712f, -0.25574657f, 0.04547373f, 0.06617942f, 0.19951625f, 0.13132495f, 
    0.03823791f, 0.02331801f, 0.01743714f, -0.11868624f, 0.10711727f, -0.09265693f, -0.00170094f, -0.17853020f, 
    0.05953928f, 0.02965430f, 0.06453351f, -0.04041014f, -0.11884988f, -0.06912167f, 0.09842405f, 0.09504126f, 
    -0.07421889f, -0.05315559f, -0.06060445f, 0.11487313f, -0.04203089f, 0.17828050f, 0.05820454f, -0.03814425f, 
    0.07918619f, 0.29632032f, 0.37168780f, -0.14978887f, -0.00708372f, 0.00623092f, 0.17146747f, -0.11683023f, 
    0.02721005f, -0.13933805f, 0.08789785f, 0.03718171f, -0.06660654f, -0.20349774f, 0.18075417f, 0.26950827f, 
    -0.15935698f, -0.06282982f, -0.07194731f, -0.05496970f, 0.35322350f, -0.17494503f, 0.08562390f, 0.18388797f, 
    -0.01409766f, 0.15404500f, 0.04502024f, 0.12233323f, 0.07976761f, 0.04008544f, -0.11804314f, -0.06176922f, 
    -0.06037417f, 0.42372069f, 0.20234217f, -0.03392922f, 0.03418912f, 0.08758041f, -0.17888464f, 0.18132122f, 
    0.05693747f, -0.11491784f, 0.20804007f, 0.05788869f, -0.06377191f, 0.37608394f, -0.05798271f, -0.27647924f, 
    0.07660919f, 0.09621833f, 0.08150186f, -0.03292503f, 0.17106396f, -0.01813984f, -0.05261020f, -0.08046059f, 
    0.11338464f, 0.08162753f, 0.05326936f, 0.04662921f, -0.04637893f, -0.24166954f, 0.26016057f, 0.09331730f, 
    -0.01733988f, -0.00047238f, 0.20141366f, -0.01669259f, -0.02183157f, -0.00761309f, -0.38609859f, 0.07150675f, 
    -0.08807186f, 0.01553379f, 0.12349584f, -0.14321446f, -0.18408835f, -0.05645690f, 0.17456897f, -0.16368760f, 
    -0.03728968f, 0.28236765f, 0.17560983f, -0.16225258f, -0.02494867f, 0.09849328f, -0.09245394f, 0.31562614f, 
    0.01427292f, -0.02601081f, 0.04819611f, -0.14760801f, 0.18007885f, 0.00435509f, -0.17557088f, 0.18080983f, 
    0.01606359f, -0.12918366f, 0.22238278f, -0.03366474f, 0.22849639f, -0.03308431f, -0.33462507f, 0.03100309f, 
    0.00647284f, 0.03741547f, 0.30107647f, 0.01243708f, 0.04192463f, 0.08139590f, -0.06374777f, -0.09706049f, 
    -0.00162345f, 0.09997146f, 0.05406659f, -0.09907528f, 0.01801274f, 0.09599996f, -0.01857068f, 0.11799961f, 
    0.07676644f, 0.02603972f, -0.13070129f, 0.02180261f, 0.04403251f, -0.20575534f, 0.08947761f, -0.09772822f, 
    0.09479032f, 0.14917505f, 0.10655563f, 0.26253188f, 0.08981421f, -0.02345487f, -0.00649902f, 0.04305755f, 
    -0.11488978f, -0.12679161f, 0.13603410f, -0.22051175f, 0.02897494f, -0.29970536f, -0.09483954f, 0.04862956f, 
    0.10134077f, -0.03022006f, 0.00236730f, -0.04324619f, -0.08761752f, 0.12399968f, -0.11943554f, 0.01849521f, 
    0.13704731f, 0.05182569f, 0.03106138f, 0.25220415f, 0.14842696f, 0.09717695f, -0.28833288f, -0.28582519f, 
    0.08075570f, -0.12473761f, 0.05751543f, 0.03196010f, 0.16872011f, 0.06885137f, 0.15562074f, 0.22539355f, 
    -0.03031783f, -0.08791693f, 0.08064968f, -0.00465174f, -0.05181038f, -0.28427380f, -0.08906624f, -0.26351774f, 
    -0.02863416f, -0.03376709f, -0.07357320f, -0.02949695f, -0.21756212f, -0.08846537f, -0.06125440f, 0.12255095f, 
    -0.11961603f, 0.09471651f, -0.02814808f, 0.03001593f, 0.02191038f, 0.04388687f, 0.12240960f, 0.04905060f, 
    -0.10862383f, 0.22421958f, 0.34528336f, -0.12004690f, -0.08538510f, -0.08797061f, 0.37825254f, 0.09697281f, 
    -0.09422523f, 0.00351462f, -0.10981761f, 0.07083617f, 0.09426117f, 0.25605190f, 0.11221118f, -0.02498062f, 
    0.18514663f, 0.14859276f, -0.12811938f, -0.12788069f, 0.01648368f, 0.27215353f, -0.08181320f, -0.37387770f, 
    0.23852079f, 0.04011098f, -0.09081980f, 0.38380137f, 0.38775429f, -0.22454743f, 0.25008407f, -0.18765083f, 
    0.10044550f, -0.22877297f, -0.22212234f, 0.05958779f, 0.13137735f, 0.06359817f, -0.08199585f, 0.14927903f, 
    -0.04384546f, 0.00512450f, 0.22618349f, -0.04107175f, 0.44184506f, 0.42967600f, 0.00312678f, -0.04868088f, 
    -0.05432598f, -0.03559150f, -0.02664560f, -0.09608687f, 0.27101055f, -0.11876535f, 0.10248733f, 0.05861597f, 
    0.03124446f, 0.27508044f, 0.02155684f, 0.09608882f, 0.08852905f, 0.13713238f, 0.31079531f, 0.00164481f, 
    -0.02746925f, 0.15183032f, -0.06993533f, 0.07106005f, -0.12527561f, -0.05528188f, -0.26865351f, 0.11791822f, 
    0.07838394f, -0.41097009f, 0.09069082f, 0.11234665f, -0.10009306f, -0.02865814f, -0.08632839f, -0.04336308f, 
    -0.01688884f, 0.04255331f, 0.04433237f, -0.02145264f, 0.06931360f, -0.31213871f, 0.02116805f, -0.07926672f, 
    -0.17733823f, 0.05706936f, -0.00629286f, -0.03519243f, 0.05233892f, 0.26078543f, -0.27560943f, -0.13084285f, 
    0.03242671f, 0.04081037f, 0.16326781f, -0.08841188f, 0.00436380f, -0.00479499f, -0.04357897f, 0.16756169f, 
    0.07778313f, -0.08783671f, -0.04929157f, -0.08259789f, 0.19002347f, -0.27828360f, -0.08605799f, -0.24450339f, 
    -0.05345370f, 0.10120927f, -0.03658975f, -0.00115380f, -0.05322985f, -0.01938292f, 0.03011346f, 0.09974515f, 
    0.10858551f, -0.01720659f, 0.00119648f, 0.09256051f, -0.04968350f, 0.30820528f, -0.11924251f, -0.09982495f, 
    0.02017316f, -0.21327297f, 0.19142933f, -0.08954952f, -0.07923852f, 0.09542146f, 0.43834814f, 0.03960532f, 
    -0.11560991f, 0.03281100f, -0.20057260f, 0.04106911f, 0.17377819f, 0.00159803f, 0.03815019f, 0.07707471f, 
    0.24007161f, 0.14002766f, -0.19372673f, -0.22956868f, -0.07589103f, 0.25156757f, 0.06385100f, -0.11712198f, 
    0.06837483f, 0.00496362f, -0.11648525f, 0.30082414f, -0.15116826f, -0.04399334f, 0.17057861f, 0.08143409f, 
    0.07076134f, -0.15700527f, 0.01667895f, -0.09511272f, 0.04669248f, 0.05990334f, 0.18710801f, 0.20925640f, 
    0.05423952f, 0.02904414f, -0.18398920f, -0.01762483f, 0.36733729f, -0.20576386f, -0.05096254f, 0.17123644f, 
    -0.07503058f, -0.07312551f, -0.03984479f, 0.06810252f, 0.06854528f, 0.09964848f, -0.09496854f, 0.09712032f, 
    0.03958678f, 0.10758788f, -0.10486017f, 0.08091088f, 0.01855171f, 0.20941374f, -0.05597369f, 0.23381931f, 
    0.05211965f, -0.16124859f, -0.16745454f, 0.06230788f, 0.01816997f, -0.02630977f, 0.04133248f, -0.11270119f, 
    -0.01008171f, 0.00914106f, -0.17245725f, -0.26910943f, 0.04204873f, 0.45218849f, -0.23742194f, 0.04576290f, 
    0.00057699f, 0.18378030f, -0.23971924f, 0.12601043f, -0.01424440f, 0.03365481f, -0.11943604f, -0.18441615f, 
    0.14370067f, -0.29511467f, -0.01551761f, 0.18485667f, 0.13870586f, 0.31208780f, -0.04109125f, 0.35631275f, 
    0.09503736f, -0.06862569f, -0.06547140f, -0.09828388f, -0.07609304f, -0.10861672f, 0.26919040f, 0.12207010f, 
    -0.08138499f, -0.10561207f, 0.23617262f, -0.04581501f, 0.17463633f, 0.01302203f, 0.01153055f, -0.05515707f, 
    0.05257525f, 0.07466969f, -0.06784993f, 0.07002467f, 0.19019873f, 0.02405296f, 0.02393876f, 0.12138855f, 
    0.07015358f, 0.18419865f, -0.04928984f, -0.05799522f, 0.01662769f, 0.34652317f, 0.04664469f, -0.03210150f, 
    0.10353483f, -0.11457005f, -0.27187979f, 0.08677859f, 0.12145834f, -0.07261236f, -0.00163590f, 0.11314867f, 
    -0.04024021f, -0.23342849f, 0.02293486f, 0.05696063f, 0.15999295f, -0.26990402f, 0.04317660f, 0.01779741f, 
    0.18850340f, -0.06386669f, -0.04200591f, -0.00861800f, -0.27648401f, -0.13608271f, -0.01445623f, -0.02601617f, 
    0.07359233f, 0.32987422f, -0.10703444f, 0.07355137f, -0.35940212f, 0.15366240f, -0.05184635f, -0.07003725f, 
    -0.09384325f, 0.14356323f, -0.03974976f, -0.21194291f, -0.04089016f, -0.06979404f, 0.23236337f, 0.26953542f, 
    0.04349757f, 0.06773223f, 0.21388046f, -0.06613585f, 0.04657983f, -0.30426598f, -0.03012401f, 0.23992191f, 
    0.12093979f, 0.08723980f, -0.07346885f, 0.03065605f, -0.11560771f, -0.10929874f, 0.09711948f, -0.03825357f, 
    -0.06766649f, -0.07362533f, -0.11895253f, 0.08976214f, 0.02986508f, 0.25761226f, -0.02550334f, 0.03611128f, 
    -0.02706552f, 0.26474220f, 0.05915695f, 0.11810677f, -0.06676394f, 0.13044152f, 0.34672228f, -0.03013200f, 
    -0.02177279f, -0.21741225f, -0.13540210f, -0.04742218f, 0.19182211f, -0.08027400f, -0.04783453f, 0.23515376f, 
    -0.04966084f, -0.11185496f, 0.04572881f, 0.18951552f, 0.34081399f, -0.21596710f, -0.05466812f, -0.03422627f, 
    0.11534199f, 0.22930649f, 0.11537027f, 0.22966228f, 0.08350233f, 0.09298278f, -0.05824993f, 0.01760558f, 
    -0.03715746f, 0.00413718f, -0.11952153f, -0.18902595f, -0.09531046f, 0.08027106f, 0.03101669f, 0.20380051f, 
    0.10281563f, -0.07651830f, -0.03416494f, -0.02250569f, -0.16147603f, 0.20108269f, 0.00121679f, 0.26864752f, 
    0.09890831f, -0.10425662f, -0.08422704f, 0.07012045f, -0.01983274f, -0.08312538f, -0.03599744f, -0.05912123f, 
    -0.11821739f, -0.02302326f, 0.08889881f, -0.02828692f, 0.02342744f, -0.22953346f, -0.25372052f, -0.12430111f, 
    0.04205998f, 0.05289278f, -0.06399588f, -0.04946328f, 0.01738587f, -0.08745008f, 0.37272173f, -0.13099223f, 
    -0.04126486f, 0.30475402f, 0.07524209f, 0.10926868f, 0.05987314f, -0.12878908f, 0.03714501f, -0.03977027f, 
    0.23553129f, -0.23707320f, 0.11551578f, 0.06160363f, -0.15289234f, 0.07542775f, -0.01770101f, -0.00182875f, 
    -0.13080482f, 0.10455507f, -0.10866425f, 0.14148617f, 0.00620791f, 0.16209099f, 0.15603536f, 0.11284706f, 
    -0.09929228f, 0.23252559f, -0.20609951f, 0.30688658f, 0.20298582f, 0.10800786f, 0.20633328f, -0.04996071f, 
    0.05974064f, -0.10326797f, 0.04817715f, 0.08362675f, 0.06805784f, -0.14276372f, 0.08034657f, -0.03658560f, 
    0.12723048f, 0.04781567f, -0.09955427f, 0.01145991f, 0.10242949f, -0.09819916f, 0.11739443f, -0.07445890f, 
    -0.02924321f, -0.12460662f, -0.07997663f, 0.07108312f, -0.09486681f, 0.04927379f, 0.07104190f, 0.06356864f, 
    -0.04407454f, -0.10436445f, -0.03688575f, -0.13720897f, 0.11801239f, -0.11574284f, -0.05323943f, -0.02677157f, 
    -0.08347671f, -0.07967970f, -0.11346342f, -0.08947356f, -0.00544041f, -0.09538157f, -0.05738055f, -0.12978515f, 
    -0.10597368f, -0.09678373f, 0.01323658f, -0.06886282f, 0.07685769f, 0.01904652f, 0.05480013f, -0.07241558f, 
    -0.11773537f, 0.06745125f, 0.08482962f, 0.06625151f, 0.07058700f, 0.07078554f, 0.04005631f, -0.03737959f, 
    -0.06683797f, 0.07066799f, 0.02161003f, -0.06574543f, -0.15775141f, 0.05773437f, -0.04745116f, 0.06569895f, 
    -0.00606467f, -0.11663859f, 0.05050068f, 0.05605115f, 0.11099965f, 0.08010539f, -0.07355274f, 0.02642914f, 
    -0.09433748f, 0.02023146f, 0.05216222f, 0.06881599f, -0.09005973f, -0.08612198f, -0.01003322f, 0.03589801f, 
    -0.01138853f, 0.00871075f, -0.01098250f, -0.02914347f, 0.10749175f, -0.09744824f, -0.11329371f, -0.00903457f, 
    -0.12483461f, 0.12020171f, -0.02146322f, 0.07257862f, 0.11145346f, 0.06599894f, -0.01848081f, -0.00058237f, 
    0.00130467f, -0.03649679f, -0.04099104f, 0.00856977f, -0.01380873f, 0.00467174f, -0.03800686f, -0.08000080f, 
    -0.02228906f, -0.08145946f, -0.12625261f, -0.11503273f, -0.02672686f, -0.04055353f, -0.10975625f, 0.03553659f, 
    -0.03641076f, 0.01464447f, -0.02583145f, -0.00283957f, -0.06352426f, 0.06128801f, -0.06250597f, 0.07005431f, 
    0.08822238f, 0.06741629f, -0.02279849f, -0.05226323f, -0.01314855f, 0.03139591f, -0.05773624f, 0.04904202f, 
    -0.10252772f, -0.01427181f, -0.41023302f, 0.03886126f, 0.14885092f, -0.00882788f, 0.03709073f, 0.15649447f, 
    0.12417863f, -0.00367956f, -0.05212212f, 0.10490608f, 0.16718441f, -0.12403007f, 0.11511011f, 0.08350860f, 
    -0.02003550f, 0.05482759f, -0.05970624f, 0.00673915f, 0.00358664f, 0.12528032f, -0.28421649f, 0.25744596f, 
    0.07855898f, -0.14775419f, -0.28940672f, 0.10696646f, 0.03851961f, -0.00606763f, -0.22105613f, 0.05224489f, 
    -0.06691460f, 0.15018201f, 0.18668310f, -0.05447068f, 0.01856910f, 0.23649925f, -0.04239792f, 0.10283079f, 
    0.04739030f, -0.08158429f, -0.10688527f, 0.15310790f, -0.14768311f, 0.34617096f, 0.01545012f, 0.06172654f, 
    0.06120809f, -0.13294569f, -0.06457793f, -0.19948342f, -0.29414985f, 0.18296669f, 0.08147980f, 0.34733164f, 
    -0.04517913f, 0.20942990f, 0.07355316f, 0.23990473f, -0.10184352f, -0.05678837f, 0.19937502f, 0.03673641f, 
    -0.07489964f, -0.02919687f, 0.01641683f, -0.11062235f, 0.13268465f, 0.04428898f, -0.07255396f, 0.17356916f, 
    -0.06781694f, 0.02708782f, -0.03483155f, 0.10923111f, 0.22615074f, 0.09145144f, 0.02358072f, 0.00454605f, 
    0.09347336f, 0.07184041f, 0.09311300f, 0.04095707f, 0.13466716f, 0.14094897f, 0.04454984f, -0.21189323f, 
    -0.08914446f, -0.12568429f, 0.14235196f, 0.04313898f, -0.01102621f, 0.09291974f, 0.09669625f, -0.01773068f, 
    -0.06767572f, -0.29198349f, 0.04378329f, 0.14416975f, 0.15684810f, -0.17189777f, 0.00189074f, 0.20795250f, 
    -0.08512805f, 0.07542383f, 0.09557562f, 0.03669576f, -0.08590553f, -0.38583583f, 0.02688786f, 0.16202049f, 
    -0.12720065f, 0.08609620f, -0.10390007f, 0.07433675f, -0.05699163f, 0.38099036f, -0.00318719f, -0.08285115f, 
    -0.09196166f, -0.05002689f, 0.32150596f, -0.03109889f, -0.16443975f, 0.03971999f, 0.15550275f, 0.13227421f, 
    0.09713410f, 0.05164315f, 0.06902966f, 0.04764667f, 0.02562895f, 0.43133363f, 0.11870185f, -0.13698536f, 
    0.05477148f, -0.06231203f, -0.03888427f, -0.10494667f, 0.17768332f, 0.04845532f, 0.12113733f, -0.00554470f, 
    0.02141054f, 0.09795607f, -0.00514171f, 0.04774564f, 0.09179234f, -0.11156484f, 0.03080270f, -0.05869578f, 
    -0.02847885f, 0.25501892f, -0.27901340f, -0.06301926f, 0.10100552f, -0.08746041f, 0.02218742f, 0.01747954f, 
    0.00703754f, 0.01152599f, -0.00120249f, -0.12504691f, -0.14217065f, 0.09472258f, 0.03819524f, -0.13932945f, 
    0.02348900f, -0.17399855f, 0.12629685f, 0.01156503f, 0.19087157f, 0.03499642f, 0.05925500f, -0.25349161f, 
    -0.02545759f, 0.17902526f, -0.08268809f, 0.01160580f, 0.27029335f, 0.07543103f, 0.03730861f, -0.10379171f, 
    -0.06527893f, 0.29918784f, -0.00608824f, 0.22219296f, 0.15918444f, 0.09472392f, 0.07834624f, 0.00500773f, 
    -0.12639256f, -0.10213567f, -0.00253176f, 0.06768750f, -0.02466469f, -0.01493854f, -0.13084123f, 0.07311163f, 
    -0.03485956f, -0.02659271f, 0.05773076f, -0.02995762f, -0.06621802f, 0.03544968f, 0.00818402f, -0.04750923f, 
    0.09059022f, 0.07995814f, 0.08293479f, 0.02813059f, 0.03375361f, -0.10267796f, -0.08423657f, -0.12482901f, 
    0.09445435f, 0.00153939f, 0.09783690f, -0.13321470f, -0.11924468f, -0.09688004f, 0.10891216f, 0.03845913f, 
    0.08019654f, -0.11729950f, -0.06820163f, -0.03964982f, -0.12476546f, 0.00648778f, 0.01627176f, -0.05597854f, 
    -0.03767584f, 0.01687303f, 0.04026208f, -0.01179164f, 0.05365524f, -0.09826939f, 0.01412583f, 0.04431984f, 
    0.01545018f, 0.00662153f, -0.02117195f, 0.08624677f, -0.05561495f, -0.04807566f, -0.09258043f, -0.10957039f, 
    0.00362022f, 0.01203702f, -0.10804547f, -0.09918607f, 0.02804856f, 0.09421511f, 0.11261689f, -0.01545911f, 
    -0.02053605f, -0.09737089f, 0.08178889f, -0.09976830f, 0.21579938f, 0.35359943f, 0.09916318f, -0.16660473f, 
    0.05687533f, -0.01210365f, 0.06948847f, -0.05671404f, -0.07485422f, 0.03726384f, 0.02203032f, -0.03632868f, 
    -0.06527852f, 0.09291144f, -0.02570196f, 0.12646255f, 0.04908248f, 0.18642494f, -0.07401265f, 0.00561095f, 
    -0.12759873f, 0.03964658f, 0.19090509f, -0.15609299f, -0.09544111f, 0.02801603f, 0.26885071f, 0.10344369f, 
    -0.04523470f, -0.12423242f, -0.15490694f, -0.08296274f, 0.11184140f, -0.00014899f, 0.06796782f, 0.08563834f, 
    0.11070689f, -0.07564196f, -0.18392737f, -0.17138973f, 0.02793880f, 0.16623503f, -0.04791381f, -0.34831834f, 
    -0.16133621f, -0.00964228f, 0.01928879f, 0.21621937f, 0.19189142f, 0.09572592f, -0.04183058f, 0.03322828f, 
    -0.06189045f, 0.16792640f, -0.01521324f, -0.17339689f, 0.19320080f, -0.10497522f, 0.15315096f, 0.23698574f, 
    -0.05679289f, -0.08201586f, -0.00120185f, 0.04258569f, -0.11476550f, -0.05267265f, 0.06843137f, -0.11050426f, 
    0.00192204f, 0.04978584f, 0.08635478f, 0.02802444f, -0.05837941f, -0.08536336f, -0.00271182f, 0.07324978f, 
    -0.04711738f, 0.01366538f, 0.02350974f, -0.04168835f, 0.01747747f, -0.12058286f, 0.09767570f, -0.13137175f, 
    -0.04185647f, 0.00262999f, 0.01501496f, -0.01450392f, 0.00352587f, 0.04746820f, 0.03020121f, 0.00331216f, 
    -0.01650614f, 0.02668570f, -0.05554221f, -0.04146516f, -0.01197861f, -0.02010210f, 0.09260793f, -0.02286912f, 
    0.03382518f, -0.08169366f, -0.07865700f, 0.02888866f, 0.08508805f, -0.06354066f, 0.08713122f, -0.11894942f, 
    -0.06646033f, 0.04375700f, -0.03610456f, 0.01751201f, 0.05942696f, 0.10139113f, -0.07973862f, -0.10896206f, 
    -0.10393721f, 0.00890492f, -0.13126835f, -0.12292809f, -0.14100844f, -0.12034462f, 0.09568574f, -0.09864424f, 
    0.07870588f, -0.11816480f, 0.27511391f, -0.01064024f, 0.12075169f, 0.04630923f, -0.10042782f, -0.07103398f, 
    -0.06523158f, -0.04258285f, 0.11122769f, 0.05424836f, 0.22195046f, -0.04551086f, -0.08153605f, 0.10668647f, 
    -0.10390733f, 0.15319185f, -0.03180253f, -0.04064134f, 0.01203775f, -0.03310674f, 0.29217356f, -0.12540348f, 
    0.05547426f, 0.14938352f, 0.13872133f, 0.07083418f, -0.08258940f, 0.04941786f, -0.10293913f, 0.10220167f, 
    -0.02206380f, -0.12331581f, 0.07167701f, 0.05024135f, -0.13160829f, 0.10995889f, -0.02263859f, 0.13079576f, 
    -0.12412938f, 0.15592866f, 0.16852355f, -0.11112974f, 0.07785042f, -0.25116688f, -0.10666541f, 0.05616863f, 
    -0.04839307f, -0.04726070f, -0.04182089f, -0.15971918f, 0.08077583f, -0.12385688f, 0.05846159f, -0.28404930f, 
    0.01566708f, -0.24399100f, 0.09009297f, 0.04410406f, 0.02293477f, -0.06525354f, -0.07285734f, 0.06642820f, 
    0.04716419f, 0.09893695f, 0.07044433f, 0.01449287f, 0.02201439f, -0.04166728f, 0.06579843f, 0.10995126f, 
    0.07271056f, 0.09959184f, 0.01421398f, 0.12208577f, 0.05898037f, 0.08598910f, -0.02851340f, -0.07869178f, 
    0.10124295f, 0.02459428f, 0.03721632f, -0.10549297f, 0.09564439f, -0.02193479f, -0.10207493f, -0.09688402f, 
    -0.02954493f, -0.07767523f, -0.04087169f, -0.02239340f, -0.10012282f, -0.02739520f, 0.03140516f, -0.12250743f, 
    0.00699334f, 0.07333484f, -0.03177450f, -0.09650747f, -0.13382591f, 0.05131301f, 0.00930947f, 0.09512429f, 
    0.00597625f, 0.01427711f, -0.02814875f, 0.00738537f, -0.01718527f, -0.00838225f, 0.00250776f, -0.01247458f, 
    -0.03123937f, -0.04025840f, -0.04229141f, 0.07575744f, 0.05613910f, 0.08669452f, -0.06637246f, -0.04536482f, 
    -0.02990142f, 0.03578774f, 0.01708737f, -0.01226248f, -0.02430927f, 0.02033125f, -0.00255994f, -0.11423430f, 
    -0.03958629f, -0.10982782f, -0.00161244f, -0.05524797f, 0.15129104f, -0.16922371f, 0.01102310f, 0.32481083f, 
    -0.09481385f, 0.03597891f, -0.08445367f, -0.07827476f, -0.00921893f, -0.10558634f, 0.08727019f, 0.10278367f, 
    -0.08005156f, -0.07060739f, -0.05860449f, -0.02578709f, -0.05580416f, 0.12534590f, 0.01293278f, 0.16659862f, 
    0.08596636f, -0.02521580f, -0.21549764f, 0.31094533f, 0.03764382f, -0.00758452f, -0.01647867f, 0.07623845f, 
    0.11692738f, 0.11856736f, -0.00649071f, -0.24853343f, 0.07341631f, 0.27576134f, -0.22822300f, -0.06176634f, 
    -0.13641697f, 0.18300396f, -0.22582774f, 0.04080150f, 0.05454294f, 0.03187963f, 0.03834682f, -0.04455668f, 
    0.36823070f, -0.36806676f, -0.07102420f, -0.12328266f, 0.25713640f, 0.23265165f, 0.12988710f, 0.24623184f, 
    -0.09455174f, -0.37676078f, -0.22768281f, -0.06742610f, 0.10952821f, 0.06425729f, 0.22654451f, 0.09654917f, 
    0.08965258f, 0.01400131f, 0.10342676f, -0.04596163f, 0.06429029f, -0.16292253f, -0.09441981f, -0.01055006f, 
    -0.09004247f, -0.10877506f, -0.02224563f, 0.11035806f, 0.02025358f, -0.11555699f, -0.07887462f, 0.06270072f, 
    0.02170426f, -0.08005668f, 0.04427509f, 0.05186024f, 0.02129237f, 0.27392289f, 0.24337521f, 0.24548668f, 
    0.11444430f, 0.31826746f, -0.15379485f, -0.17239951f, 0.06491259f, -0.07757583f, -0.08247184f, -0.12075772f, 
    0.11736845f, -0.08583742f, -0.07241531f, -0.11341711f, 0.08492427f, 0.03232556f, 0.15023409f, -0.00645723f, 
    0.13964681f, -0.13210690f, -0.13705878f, 0.22633173f, 0.33362213f, 0.23867925f, -0.00294810f, 0.12496535f, 
    0.08653548f, 0.25955385f, -0.02009327f, 0.26526996f, 0.19021314f, -0.23302563f, 0.10209935f, -0.03723936f, 
    -0.08540844f, 0.18615741f, -0.19645450f, 0.02893294f, 0.00175626f, 0.08526842f, -0.13846752f, 0.14441171f, 
    0.08466123f, -0.02644067f, -0.10039488f, 0.11807989f, 0.01197653f, -0.04489693f, -0.11043243f, -0.02108845f, 
    0.07631943f, 0.04162844f, 0.04988328f, -0.10175398f, -0.10404481f, -0.05214642f, 0.01511100f, 0.11768513f, 
    -0.07201057f, -0.05807522f, -0.02677029f, -0.03285054f, -0.01200418f, -0.07935947f, -0.06904571f, -0.04711157f, 
    -0.07501797f, -0.01627978f, -0.02750947f, 0.03675905f, -0.10686420f, -0.07672293f, -0.05908016f, -0.12932305f, 
    -0.09733400f, 0.03423811f, 0.00323965f, -0.04320302f, -0.07068402f, 0.00297519f, -0.02921939f, -0.03134003f, 
    -0.06290522f, -0.11646130f, 0.05142451f, 0.06521352f, -0.04561307f, -0.01401278f, 0.13043316f, -0.08751876f, 
    0.02365886f, 0.03030767f, 0.10755617f, -0.09443059f, 0.03197922f, -0.04455186f, 0.02279457f, 0.06612647f, 
    0.09564728f, 0.05765539f, 0.09200355f, 0.09515578f, 0.04581664f, 0.09423542f, -0.10844082f, 0.02931943f, 
    0.12223297f, 0.09807675f, -0.06037673f, -0.10098167f, 0.06287111f, -0.05779525f, 0.03940266f, -0.05333893f, 
    -0.06468998f, -0.00423896f, -0.01619650f, 0.12208568f, 0.08703282f, 0.02621563f, -0.06865901f, 0.07773696f, 
    -0.05529255f, 0.04935496f, -0.11183082f, -0.06093192f, -0.10347392f, -0.07637494f, 0.12352248f, 0.07152011f, 
    0.06968724f, -0.06856698f, 0.02659165f, 0.00894646f, 0.04072799f, -0.02739263f, -0.12618999f, -0.10501324f, 
    0.03536652f, 0.05342091f, 0.07252758f, -0.06554499f, 0.09790535f, -0.00986987f, -0.07922495f, -0.10461129f, 
    -0.10933395f, -0.10375184f, 0.04051771f, -0.11722933f, 0.08148652f, 0.03665534f, -0.11542779f, -0.02535356f, 
    -0.05422177f, -0.05798148f, 0.02805348f, 0.07477207f, -0.03865471f, -0.13927023f, -0.08639040f, 0.00717250f, 
    0.06425215f, 0.02851786f, 0.04788811f, -0.04429021f, -0.10052218f, 0.00915636f, -0.00390437f, -0.08980188f, 
    0.08389905f, 0.07538696f, 0.03904118f, 0.08427206f, 0.17971979f, -0.11807961f, -0.11029018f, 0.34367958f, 
    0.10973989f, 0.01163465f, 0.06959707f, 0.12534143f, 0.06706920f, 0.01436616f, -0.07867983f, 0.02912034f, 
    -0.09681705f, 0.04372583f, 0.10929785f, -0.10638069f, 0.07784116f, 0.02287837f, 0.25829023f, 0.09161755f, 
    -0.05910681f, 0.09810411f, -0.00696307f, 0.13455936f, 0.06577554f, -0.08623198f, -0.05662598f, -0.10691237f, 
    -0.01350648f, -0.24653770f, -0.02445426f, 0.01391009f, 0.03899068f, -0.17784432f, -0.00284856f, -0.05089341f, 
    -0.03779294f, 0.08084554f, 0.15506771f, 0.28698429f, 0.33420685f, -0.31330428f, 0.08319952f, 0.28994986f, 
    -0.11393037f, 0.05478634f, -0.09859213f, -0.02739676f, 0.18735990f, 0.08315267f, -0.13128258f, 0.07458527f, 
    -0.04205576f, 0.04367572f, 0.15445586f, -0.13308842f, -0.10362750f, 0.02589508f, -0.17291704f, 0.05566743f, 
    0.05725147f, -0.05251461f, -0.07049704f, 0.05831349f, -0.08849373f, 0.03897102f, -0.03704059f, -0.10088091f, 
    -0.11627652f, -0.05486891f, 0.10721189f, 0.00480494f, -0.09350855f, -0.07032439f, 0.12322092f, -0.04295349f, 
    0.01837327f, -0.10483555f, -0.11751679f, 0.06766324f, -0.04439247f, -0.06871365f, -0.02288666f, 0.05085992f, 
    0.08895240f, 0.10839467f, -0.04367248f, 0.03583301f, -0.10105110f, 0.02528277f, -0.00981817f, 0.09663078f, 
    -0.10077479f, -0.08033964f, -0.07409763f, 0.08685952f, -0.07164005f, 0.07802302f, -0.07275355f, 0.06933791f, 
    0.00252619f, -0.06082780f, -0.03786231f, 0.01322994f, -0.11282760f, -0.06088918f, 0.08555028f, 0.06118388f, 
    0.07457817f, 0.08224247f, -0.11560912f, -0.02709585f, -0.00552950f, -0.02183362f, 0.01251995f, -0.04016344f, 
    -0.11540706f, -0.10319872f, -0.09842636f, -0.02873236f, -0.03640398f, 0.11240335f, 0.05312504f, -0.12718052f, 
    -0.06139914f, 0.04736598f, -0.13484639f, 0.05851455f, 0.22769511f, 0.09899434f, -0.09828642f, 0.21483199f, 
    0.05210552f, -0.09749651f, 0.08755626f, -0.01832278f, 0.17853180f, 0.04883052f, 0.05763510f, 0.10325094f, 
    -0.04314630f, 0.26059413f, -0.10796218f, 0.09355807f, 0.09634154f, 0.20745677f, 0.02610527f, -0.12238514f, 
    0.07005194f, -0.07984893f, -0.16900839f, 0.08500377f, -0.05513525f, -0.11405312f, -0.30233896f, -0.00269565f, 
    -0.00377825f, -0.16007742f, 0.03033934f, 0.25290692f, -0.04511582f, -0.05006315f, 0.00185202f, 0.15688740f, 
    0.20188224f, 0.02352497f, -0.02457683f, 0.02394904f, -0.26669002f, -0.25124618f, -0.09286274f, -0.15629219f, 
    -0.06340155f, 0.12720869f, -0.01254462f, 0.00496798f, -0.18556370f, 0.35253739f, 0.02371274f, -0.05525756f, 
    -0.02220879f, 0.02463395f, 0.09943255f, 0.18229909f, -0.18458886f, 0.11939996f, 0.23749419f, 0.12546664f, 
    0.00558669f, -0.03039757f, -0.03163576f, 0.03128545f, -0.02726374f, 0.24784772f, 0.11538110f, 0.03280825f, 
    0.08321494f, 0.03548391f, 0.02998603f, 0.09808166f, 0.17678896f, -0.08088618f, 0.02237229f, -0.06505652f, 
    -0.02894588f, -0.21449013f, 0.04130213f, 0.08476037f, 0.07760467f, -0.31346506f, -0.00584778f, -0.08479182f, 
    0.10601086f, 0.13770233f, -0.06635706f, 0.27528682f, -0.07750759f, -0.09164860f, 0.01711854f, -0.01330196f, 
    0.03525038f, 0.01630625f, 0.25601348f, -0.06315627f, 0.03990814f, -0.07445390f, -0.04704408f, 0.19560248f, 
    -0.17977959f, -0.05374065f, 0.21628608f, 0.24803683f, -0.07330870f, 0.05380001f, -0.01129659f, 0.24865024f, 
    -0.05910688f, 0.18581335f, -0.12167999f, -0.02089918f, 0.10813975f, 0.39579311f, -0.36414424f, 0.05613052f, 
    -0.00699472f, 0.21088675f, 0.05999539f, 0.18813871f, 0.16192232f, 0.05353229f, 0.15754516f, -0.06420663f, 
    0.04702626f, -0.00463849f, 0.05607535f, -0.01460886f, 0.02609268f, -0.06244558f, 0.06102833f, 0.08429226f, 
    0.01166797f, 0.00765817f, 0.10500456f, -0.09111600f, 0.06158037f, 0.08424024f, 0.00763912f, 0.04945627f, 
    -0.04930605f, -0.07760622f, 0.04852802f, 0.05348289f, 0.08493544f, -0.03200513f, -0.02478527f, 0.05733921f, 
    -0.10201007f, 0.00165899f, 0.01024716f, -0.10505681f, 0.11581901f, -0.12483312f, -0.03575753f, -0.11881348f, 
    0.06775726f, 0.08073570f, -0.11337441f, -0.05284625f, 0.05477996f, 0.02696495f, -0.02401946f, -0.04139894f, 
    0.02734737f, 0.03583215f, -0.08705369f, -0.03469105f, -0.11258662f, -0.07290897f, 0.02287315f, -0.08564182f, 
    -0.11414275f, -0.04269212f, -0.08225144f, -0.09749603f, -0.09344514f, -0.09601900f, 0.02259159f, -0.11514032f, 
    -0.03517841f, -0.00876260f, 0.06349990f, -0.02606574f, 0.10943820f, -0.11500730f, 0.00488487f, -0.04891244f, 
    -0.00374348f, -0.04102427f, 0.26517880f, 0.07158969f, -0.02088474f, -0.28476942f, -0.01688717f, -0.26643372f, 
    -0.10994349f, -0.09274739f, -0.06878722f, 0.06788891f, 0.13160542f, -0.04808673f, 0.08276805f, -0.09644654f, 
    0.05885237f, 0.22188786f, 0.04275868f, 0.05556499f, -0.01352400f, 0.05081898f, 0.34895363f, 0.16562530f, 
    -0.06569640f, 0.13238375f, 0.18733364f, -0.03365992f, 0.03310455f, -0.05777700f, -0.18508162f, -0.08634531f, 
    -0.06722190f, 0.15791605f, 0.11593497f, -0.08014919f, -0.01470535f, -0.05331527f, 0.16688739f, 0.08411031f, 
    -0.10389457f, 0.29710618f, -0.01560880f, -0.32667774f, 0.11262029f, -0.01916475f, -0.00801850f, -0.10166817f, 
    0.23454273f, 0.10573566f, -0.04133572f, 0.02017932f, -0.00526265f, -0.23911709f, -0.11349021f, -0.18811259f, 
    0.08124424f, -0.34232000f, 0.32303619f, 0.06957839f, -0.10907646f, 0.08356648f, -0.13465530f, 0.18848236f, 
    -0.08647329f, -0.05312617f, -0.02387991f, 0.07024101f, -0.10059953f, 0.38760060f, 0.06037940f, -0.17267655f, 
    -0.09236597f, -0.11031825f, -0.11769478f, 0.09363936f, 0.10352769f, 0.08747806f, -0.07204477f, -0.08052382f, 
    0.09467903f, 0.15891004f, 0.02173821f, 0.04142211f, -0.05181965f, -0.01864180f, 0.19556279f, -0.06115047f, 
    -0.01993250f, 0.20259340f, 0.22409609f, -0.07599148f, -0.00547198f, -0.10261271f, 0.00204397f, 0.10450253f, 
    0.02541762f, 0.16897327f, 0.12068532f, 0.01426007f, -0.19948019f, 0.13586882f, 0.10660399f, -0.24515767f, 
    0.03586007f, 0.13780427f, 0.02141057f, -0.15357825f, 0.35134667f, 0.23670432f, 0.00007056f, -0.24115434f, 
    0.10819765f, -0.05441640f, 0.08002656f, 0.12196023f, 0.44397393f, -0.09146520f, 0.10898454f, -0.03033077f, 
    -0.12478864f, 0.14203937f, -0.18354598f, 0.27582422f, 0.22975929f, -0.05604377f, -0.19560696f, -0.10943058f, 
    0.02366403f, -0.04157348f, 0.11054830f, 0.07083497f, 0.19770733f, 0.22139649f, 0.04703904f, 0.07699820f, 
    0.08329780f, -0.07394677f, 0.04445479f, 0.01053567f, 0.03750093f, 0.11415532f, 0.03381230f, 0.03301394f, 
    0.10835207f, -0.03169005f, -0.01314899f, 0.02883314f, -0.02589286f, 0.11273472f, -0.04762642f, -0.15270221f, 
    0.02339981f, 0.03252752f, 0.37349230f, -0.01827891f, 0.09416022f, 0.03932090f, 0.27933109f, 0.10706341f, 
    0.06947464f, -0.31585807f, -0.26289210f, -0.06060177f, -0.14215319f, -0.04996328f, -0.09815203f, 0.21767475f, 
    0.09892683f, 0.11834190f, -0.19703549f, -0.12435675f, 0.00529368f, -0.21312772f, -0.05030147f, -0.23523746f, 
    -0.04908885f, -0.00817531f, 0.12253905f, 0.34888712f, 0.28821725f, 0.18226324f, -0.01636010f, 0.07090574f, 
    0.11053896f, 0.29833275f, -0.00116507f, -0.14055641f, -0.05322672f, -0.00799044f, 0.02685497f, 0.03259856f
};;

// Biases for dense layer dense1
const float dense1_biases[] PROGMEM = {
    0.20132455f, 0.13933322f, 0.18277422f, -0.02353587f, -0.02466373f, 0.03617895f, -0.02164746f, 0.14517230f, 
    0.00257811f, 0.09441701f, 0.11794312f, 0.16249371f, 0.13271993f, -0.00793797f, 0.12102065f, 0.08337371f, 
    -0.14622252f, 0.00225981f, 0.04659820f, 0.06816795f, 0.04923363f, 0.04981183f, 0.10924795f, 0.08170222f, 
    0.17718305f, -0.07376792f, -0.07569236f, 0.03648330f, 0.08935484f, -0.02236986f, 0.11138592f, -0.09737257f, 
    -0.01643357f, -0.01204442f, 0.11140820f, -0.09726303f, 0.09796756f, 0.07156987f, -0.16960666f, 0.20499146f, 
    -0.08270521f, 0.11744974f, -0.11258559f, -0.01914105f, -0.01403093f, 0.02568491f, -0.08305650f, -0.03673793f, 
    -0.08281911f, -0.05866314f, -0.06335691f, -0.04548274f, 0.00760132f, -0.07203399f, -0.06841669f, -0.08286975f, 
    -0.13670118f, -0.02265967f, 0.01258695f, 0.09835381f, -0.05685662f, 0.11299195f, -0.01511621f, -0.13872789f
};;

// Weights for dense layer dense2
const float dense2_weights[] PROGMEM = {
    -0.38114372f, 0.10410447f, 0.06501396f, -0.22356234f, -0.09215508f, 0.09883002f, -0.11676551f, -0.49702090f, 
    0.06751165f, 0.26640305f, -0.12454138f, -0.28547844f, -0.11548535f, -0.02191574f, 0.02412056f, 0.17290466f, 
    0.07083599f, -0.04966559f, -0.04860065f, -0.58776873f, -0.44068903f, -0.10156692f, -0.52295423f, -0.00895252f, 
    -0.28401166f, 0.07160401f, 0.01630418f, 0.01119813f, -0.07744028f, -0.19131927f, -0.44880667f, 0.27203721f, 
    0.16743617f, -0.14869006f, 0.07611442f, 0.14679337f, 0.13918859f, 0.29513893f, 0.20213255f, 0.12252149f, 
    0.19146040f, -0.18110397f, 0.02109295f, -0.09601560f, -0.16355571f, 0.30218074f, -0.17415637f, -0.02431158f, 
    0.28992879f, 0.05572820f, 0.02379442f, -0.08113227f, -0.00564463f, -0.10604621f, 0.02087796f, 0.03344622f, 
    0.06879000f, 0.02886844f, 0.15211600f, -0.22214918f, -0.07307012f, -0.01317979f, -0.15572283f, 0.38318783f, 
    0.26462290f, 0.32638487f, 0.15407507f, 0.14145663f, -0.17886817f, 0.18058898f, -0.07339918f, -0.12952295f, 
    -0.33060884f, -0.28048193f, -0.00472446f, 0.05222706f, -0.09219231f, -0.04194034f, 0.03610298f, 0.09305099f, 
    0.04756063f, 0.01812315f, 0.09745502f, 0.26534796f, -0.32488510f, -0.11509999f, 0.15636905f, -0.10616406f, 
    -0.04578573f, -0.13705201f, 0.01506437f, -0.11810791f, 0.12130193f, -0.09343436f, 0.33021447f, 0.13590811f, 
    -0.35803482f, -0.37408876f, -0.02953225f, -0.16374333f, 0.01368899f, 0.14861850f, 0.12466172f, 0.27074251f, 
    -0.03198189f, -0.08915180f, 0.08992025f, 0.05601874f, 0.26029822f, 0.09612898f, -0.01178018f, -0.04790189f, 
    0.00869215f, 0.07468970f, -0.08099768f, -0.07156894f, 0.12225617f, -0.15792431f, 0.11838066f, -0.05816223f, 
    -0.24328147f, -0.02317553f, 0.22870204f, -0.03974629f, -0.09886086f, -0.06309721f, -0.33167887f, -0.45671284f, 
    0.07677528f, -0.26276472f, -0.13127691f, 0.14358510f, 0.24631201f, -0.07983201f, -0.48768187f, 0.09103095f, 
    -0.38036072f, -0.28806281f, 0.23879802f, -0.22828634f, -0.17749323f, 0.14427716f, 0.25204048f, 0.16603418f, 
    0.18085210f, 0.12697424f, -0.12543367f, -0.34169340f, 0.13087772f, 0.04063277f, -0.19657101f, -0.06985860f, 
    -0.15184395f, 0.14461453f, -0.30411637f, -0.09858459f, 0.08318464f, 0.00665028f, 0.07404413f, -0.02157153f, 
    -0.03989147f, 0.13495107f, -0.45551676f, 0.14215878f, -0.17773505f, 0.05420709f, 0.28760147f, -0.23770593f, 
    -0.21795428f, -0.21383666f, -0.10160760f, -0.00028814f, 0.27213159f, -0.52983117f, -0.01372899f, 0.09254316f, 
    0.11632625f, 0.05860453f, -0.30998054f, 0.03618260f, 0.11447282f, 0.11925873f, 0.05381307f, -0.14005545f, 
    -0.23466882f, -0.01338479f, -0.16697271f, -0.26768708f, -0.05672733f, -0.02874942f, 0.27164590f, -0.19035402f, 
    0.26304340f, -0.10441080f, -0.42469552f, 0.21845298f, -0.25715423f, 0.12611078f, -0.21330641f, 0.03894616f, 
    0.01602617f, -0.24278033f, -0.05439971f, -0.23797642f, 0.01946106f, -0.03646002f, 0.24279168f, -0.11963253f, 
    0.16532736f, -0.25426361f, -0.36498719f, -0.01931780f, 0.13302474f, 0.24517588f, 0.15599297f, 0.00249229f, 
    0.13843247f, 0.22082309f, -0.24421920f, 0.01137854f, -0.00846656f, -0.37585273f, -0.23737711f, 0.14073959f, 
    0.11448666f, 0.21896695f, 0.03232576f, -0.32282966f, 0.27708477f, -0.33101502f, -0.35883266f, 0.11298321f, 
    0.01121152f, -0.42308271f, -0.02444218f, 0.06811942f, -0.23810464f, 0.14788683f, -0.13808624f, -0.12584522f, 
    0.05372696f, 0.02808760f, 0.09672592f, 0.02902452f, -0.48097685f, -0.04389460f, -0.02449387f, 0.01917912f, 
    0.33576980f, -0.09944173f, -0.12416045f, 0.13089976f, 0.02889997f, 0.03459080f, -0.10408936f, -0.20671459f, 
    -0.16754639f, -0.01885600f, -0.01713769f, -0.37440440f, -0.03544841f, 0.05763589f, -0.06688436f, 0.20766409f, 
    0.33819345f, 0.20909467f, -0.15425169f, 0.03643798f, -0.26746976f, 0.06818907f, 0.09834193f, -0.16901983f, 
    -0.24204445f, -0.13422915f, -0.28841147f, -0.20220701f, -0.20721017f, -0.02978133f, 0.03360125f, 0.11911505f, 
    0.10518819f, 0.14033665f, -0.33482039f, 0.05747053f, -0.07514973f, 0.22749045f, -0.06623883f, -0.18205760f, 
    0.01775617f, 0.22498426f, 0.35602054f, 0.04840680f, 0.16446137f, -0.28722280f, 0.13951407f, -0.02960969f, 
    0.00595283f, -0.15570676f, 0.01164436f, 0.02035261f, -0.07757553f, -0.14266776f, 0.15366454f, -0.02483171f, 
    0.03456009f, -0.08630297f, 0.03145890f, 0.08701503f, 0.44494465f, 0.00958731f, 0.07406030f, 0.08824534f, 
    0.03915690f, 0.11200454f, -0.10524645f, 0.25302219f, -0.06936565f, 0.11526199f, 0.13489026f, 0.09890583f, 
    0.07093191f, 0.02697182f, 0.20859858f, -0.09353678f, -0.24523737f, -0.39825922f, 0.17931618f, 0.07854463f, 
    0.02214926f, -0.09937228f, 0.05449674f, 0.02884369f, 0.15263368f, 0.07031010f, 0.13527864f, -0.35982454f, 
    -0.14485572f, 0.07005462f, -0.22227210f, -0.11161979f, -0.49622485f, -0.09800652f, -0.35066575f, 0.05670647f, 
    -0.43882611f, -0.33041519f, 0.23911665f, 0.10788392f, -0.07279217f, 0.24056597f, -0.12769987f, -0.17190892f, 
    0.07099834f, -0.36267123f, -0.02380444f, -0.21525902f, 0.07121667f, -0.13400419f, -0.25257188f, 0.22354622f, 
    -0.05088444f, 0.25246119f, 0.01614571f, 0.05839748f, 0.13800484f, 0.05937484f, 0.13541707f, 0.01238023f, 
    0.08526684f, 0.02744381f, -0.27394804f, -0.07685906f, -0.47916600f, 0.10466695f, -0.01819724f, -0.04737944f, 
    0.09299263f, -0.04477189f, 0.25635013f, 0.13610175f, 0.03260049f, -0.18284135f, -0.00016141f, -0.01278585f, 
    -0.20998153f, -0.08965813f, -0.01105542f, -0.11509430f, -0.46166253f, -0.38538754f, -0.29672849f, 0.35532513f, 
    -0.23817354f, 0.22172159f, 0.23969615f, 0.03519518f, 0.18596210f, 0.22809131f, -0.14054915f, 0.09435615f, 
    -0.11900515f, 0.13770774f, 0.28005251f, -0.28272113f, 0.19359313f, -0.46022591f, -0.35346419f, -0.07169972f, 
    0.06662387f, -0.00050397f, 0.19311081f, 0.04050469f, -0.01882717f, -0.04512151f, -0.27469438f, -0.19303504f, 
    0.12981397f, -0.16891746f, -0.13217063f, 0.11046420f, -0.05587850f, -0.10717792f, -0.43310779f, 0.05548526f, 
    0.19666857f, -0.30004087f, -0.00236741f, -0.03276637f, -0.31855696f, 0.01753885f, -0.05613661f, 0.00900711f, 
    -0.10012431f, -0.03250526f, 0.09838389f, 0.11010358f, -0.49773189f, 0.18876782f, 0.01110910f, 0.04995498f, 
    0.25287536f, -0.06656373f, 0.01044354f, -0.51214737f, 0.01702572f, 0.17602752f, 0.00690417f, -0.46897078f, 
    -0.20255305f, -0.21383600f, -0.28060791f, -0.17993662f, 0.28741860f, 0.00531291f, -0.08244805f, -0.11909905f, 
    0.14340927f, 0.05867760f, -0.05915298f, -0.40267095f, -0.05700164f, -0.04828227f, -0.31668365f, -0.11133727f, 
    0.25498074f, -0.21903628f, -0.17152093f, 0.26687482f, 0.22281562f, -0.01505289f, 0.24990605f, -0.04619237f, 
    -0.25762174f, -0.24576513f, 0.16663156f, 0.10454878f, 0.01201572f, -0.01446442f, -0.17553601f, 0.03833484f, 
    0.15628980f, -0.05701321f, -0.16558121f, -0.09284673f, -0.03460745f, -0.20702307f, 0.13107653f, -0.40909317f, 
    -0.00297360f, 0.24362276f, -0.08676947f, 0.01752573f, 0.08395020f, 0.05493229f, 0.22440034f, -0.11193211f, 
    0.04114963f, -0.02893880f, 0.06200467f, -0.00831945f, 0.12779184f, -0.08320818f, -0.01104864f, -0.12387996f, 
    -0.04177891f, 0.01047827f, -0.22027580f, 0.22212048f, -0.00379862f, -0.19255796f, 0.20950626f, 0.07906437f, 
    0.02408933f, -0.37559807f, 0.10369427f, 0.19414452f, 0.05537152f, 0.26115301f, 0.12754408f, 0.13956593f, 
    -0.03604851f, -0.06544577f, -0.39209288f, -0.26323697f, 0.18139151f, 0.08215997f, -0.03117617f, -0.01443757f, 
    0.02117655f, 0.12903996f, 0.08830159f, -0.09183786f, 0.00118243f, 0.12531731f, -0.06380184f, -0.05987091f, 
    -0.05736890f, 0.21255684f, -0.04708292f, -0.00028234f, 0.01000987f, 0.27287370f, -0.02534522f, 0.02206115f, 
    -0.38543120f, -0.25559857f, -0.21212094f, -0.30033174f, -0.32407889f, -0.45632401f, 0.14222811f, -0.13765599f, 
    0.13951382f, 0.20381404f, -0.09013700f, 0.07640769f, 0.20020397f, 0.08987930f, -0.22368458f, -0.11840030f, 
    -0.47663808f, 0.00741560f, -0.27138188f, -0.03785710f, 0.33392441f, -0.17765744f, -0.00047882f, 0.00061888f, 
    0.20592864f, -0.08051546f, 0.06371996f, 0.24910249f, 0.01050714f, -0.50030708f, -0.32039690f, -0.26187652f, 
    -0.43528956f, 0.11775656f, 0.13935903f, -0.03115585f, 0.23725368f, -0.20506145f, -0.08907225f, -0.28252608f, 
    0.11022571f, -0.18014395f, 0.10497957f, 0.09706673f, -0.27825877f, 0.23276317f, -0.32700825f, -0.15047814f, 
    -0.19248012f, 0.05893114f, -0.30174109f, 0.22803445f, 0.02481269f, -0.35514873f, 0.24119164f, -0.12436555f, 
    0.20768507f, 0.13395877f, -0.03059882f, -0.01220710f, 0.02958646f, 0.16804723f, 0.19835736f, -0.01211558f, 
    -0.00721659f, -0.11183473f, 0.09708710f, 0.28385729f, -0.57274896f, 0.27912560f, -0.40493709f, 0.01282393f, 
    0.02983672f, 0.29633117f, 0.01198078f, -0.11506014f, -0.34361085f, -0.35406715f, -0.04593277f, 0.09746077f, 
    0.18548746f, 0.00337629f, -0.28619549f, 0.02027068f, -0.07810768f, 0.05402864f, -0.04659712f, -0.09819115f, 
    -0.39631981f, 0.07591926f, -0.38651949f, -0.21343659f, -0.12081166f, 0.02869213f, 0.09983023f, -0.16631840f, 
    0.17631736f, -0.23306826f, -0.02438939f, 0.12020328f, 0.16383959f, -0.04119939f, 0.09134021f, -0.15215680f, 
    -0.25545070f, 0.04274463f, 0.24316305f, 0.26708317f, 0.04376747f, -0.22012100f, 0.02229401f, 0.24868383f, 
    -0.24822327f, -0.29780486f, 0.00696796f, -0.10912762f, 0.25541350f, 0.22671998f, 0.24213813f, 0.06094341f, 
    0.22132185f, -0.39250177f, 0.11830367f, -0.04751644f, 0.07393907f, -0.21826485f, 0.33555532f, -0.61927670f, 
    0.09638831f, 0.10855119f, -0.04807498f, -0.30676404f, -0.23557207f, 0.04609004f, -0.20348158f, -0.11842676f, 
    -0.38264412f, 0.04510460f, 0.02713635f, 0.09597393f, 0.26338062f, 0.14898302f, -0.30728638f, 0.10293189f, 
    -0.35346028f, 0.10830522f, -0.02667744f, -0.01337149f, -0.19262485f, -0.39716619f, 0.03887562f, -0.03358934f, 
    -0.14989212f, -0.05210452f, 0.04263299f, 0.18244810f, 0.01409791f, 0.13083871f, -0.14106961f, -0.36978117f, 
    -0.03321167f, -0.04949553f, -0.01946410f, 0.10102776f, 0.03387997f, -0.10706802f, 0.32665518f, 0.15542157f, 
    -0.29977605f, 0.36559135f, 0.01115840f, -0.09372640f, 0.09210523f, -0.40428445f, -0.38010290f, 0.01707065f, 
    0.03351512f, 0.11528894f, 0.21287049f, -0.18300425f, -0.04430518f, 0.07043067f, -0.15513040f, 0.10892950f, 
    -0.07717390f, 0.12969631f, 0.08961407f, 0.08413914f, -0.03257233f, -0.40516555f, -0.20825361f, 0.27865198f, 
    -0.24072078f, 0.21087053f, -0.07745700f, -0.03143304f, 0.17787644f, -0.32439551f, -0.51795620f, -0.06608371f, 
    -0.45784813f, 0.07904316f, -0.08283525f, -0.12860915f, -0.17126402f, 0.06945471f, 0.11417193f, -0.12133413f, 
    -0.02331494f, 0.04345011f, 0.21746132f, -0.06227604f, -0.16497365f, -0.26761314f, -0.02067468f, -0.12790442f, 
    -0.03020128f, 0.02082581f, 0.22269967f, -0.14085934f, 0.02077475f, 0.10008158f, 0.28022385f, 0.08753903f
};;

// Biases for dense layer dense2
const float dense2_biases[] PROGMEM = {
    -0.13657434f, 0.09185703f, -0.11984462f, -0.10252964f, 0.10019070f, 0.02194985f, 0.02463501f, -0.15229146f, 
    0.07270871f, 0.06460274f, 0.12856741f, 0.06406921f
};;

// Helper functions

void relu(float* arr, int size) {
    for (int i = 0; i < size; i++) {
        if (arr[i] < 0) {
            arr[i] = 0;
        }
    }
}

void softmax(float* arr, int size) {
    float max_val = arr[0];
    for (int i = 1; i < size; i++) {
        if (arr[i] > max_val) {
            max_val = arr[i];
        }
    }
    
    float sum_exp = 0.0;
    for (int i = 0; i < size; i++) {
        arr[i] = exp(arr[i] - max_val);
        sum_exp += arr[i];
    }
    
    for (int i = 0; i < size; i++) {
        arr[i] /= sum_exp;
    }
}

void dense_layer(float* output, const float* input, int input_size, int output_size, 
                 const float* weights, const float* biases) {
    for (int i = 0; i < output_size; i++) {
        float sum = 0;
        for (int j = 0; j < input_size; j++) {
            #if defined(__AVR__)
            float weight = pgm_read_float_near(weights + i * input_size + j);
            #else
            float weight = weights[i * input_size + j];
            #endif
            sum += weight * input[j];
        }
        #if defined(__AVR__)
        output[i] = sum + pgm_read_float_near(biases + i);
        #else
        output[i] = sum + biases[i];
        #endif
    }
}

void conv_layer(float* output, const float* input, int in_channels, int in_h, int in_w,
                int out_channels, int kernel_size, const float* kernels, const float* biases) {
    int out_h = in_h - kernel_size + 1;
    int out_w = in_w - kernel_size + 1;
    
    for (int f = 0; f < out_channels; f++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float sum = 0;
                for (int c = 0; c < in_channels; c++) {
                    for (int ky = 0; ky < kernel_size; ky++) {
                        for (int kx = 0; kx < kernel_size; kx++) {
                            int input_y = y + ky;
                            int input_x = x + kx;
                            int kernel_idx = f * (in_channels * kernel_size * kernel_size) + 
                                           c * (kernel_size * kernel_size) + 
                                           ky * kernel_size + kx;
                            int input_idx = c * (in_h * in_w) + input_y * in_w + input_x;
                            
                            #if defined(__AVR__)
                            float weight = pgm_read_float_near(kernels + kernel_idx);
                            #else
                            float weight = kernels[kernel_idx];
                            #endif
                            sum += input[input_idx] * weight;
                        }
                    }
                }
                #if defined(__AVR__)
                output[f * (out_h * out_w) + y * out_w + x] = sum + pgm_read_float_near(biases + f);
                #else
                output[f * (out_h * out_w) + y * out_w + x] = sum + biases[f];
                #endif
            }
        }
    }
}

void max_pool_2x2(float* output, const float* input, int channels, int in_h, int in_w) {
    int out_h = in_h / 2;
    int out_w = in_w / 2;
    
    for (int c = 0; c < channels; c++) {
        for (int y = 0; y < out_h; y++) {
            for (int x = 0; x < out_w; x++) {
                float max_val = -1e9;
                for (int pool_y = 0; pool_y < 2; pool_y++) {
                    for (int pool_x = 0; pool_x < 2; pool_x++) {
                        int input_idx = c * (in_h * in_w) + 
                                       (y * 2 + pool_y) * in_w + 
                                       (x * 2 + pool_x);
                        float val = input[input_idx];
                        if (val > max_val) {
                            max_val = val;
                        }
                    }
                }
                output[c * (out_h * out_w) + y * out_w + x] = max_val;
            }
        }
    }
}

// --- Main Inference Function ---

void setup_network() {
    // No initialization needed for this implementation
}

float* predict(float* input_data) {
    float* buffer_a = buffer1;
    float* buffer_b = buffer2;
    float* temp_ptr = nullptr;
    
    // Copy input data
    for (int i = 0; i < INPUT_SIZE; i++) {
        buffer_a[i] = input_data[i];
    }

    // Convolutional Layer 0
    conv_layer(buffer_b, buffer_a, 
               CONV0_IN_CHANNELS, CONV0_IN_H, CONV0_IN_W,
               CONV0_NUM_FILTERS, CONV0_KERNEL_SIZE,
               conv0_weights, conv0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, 1280);

    // MaxPool 2x2
    max_pool_2x2(buffer_b, buffer_a,
                 POOL0_CHANNELS, POOL0_IN_H, POOL0_IN_W);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 0
    dense_layer(buffer_b, buffer_a,
                DENSE0_INPUT_SIZE, DENSE0_OUTPUT_SIZE,
                dense0_weights, dense0_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE0_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 1
    dense_layer(buffer_b, buffer_a,
                DENSE1_INPUT_SIZE, DENSE1_OUTPUT_SIZE,
                dense1_weights, dense1_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // ReLU
    relu(buffer_a, DENSE1_OUTPUT_SIZE);

    // Flatten (implicit - data already in buffer_a as 1D vector)

    // Dense Layer 2
    dense_layer(buffer_b, buffer_a,
                DENSE2_INPUT_SIZE, DENSE2_OUTPUT_SIZE,
                dense2_weights, dense2_biases);
    
    // Swap buffers
    temp_ptr = buffer_a;
    buffer_a = buffer_b;
    buffer_b = temp_ptr;

    // Softmax on final layer
    softmax(buffer_a, DENSE2_OUTPUT_SIZE);

    
    return buffer_a;
}
